#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.60806817f, 0.58039427f, 0.13345061f, 0.50723988f, -0.04116746f, 0.09033422f, 0.50190288f, 0.37021491f, 
    -0.05027530f, -0.52126282f, -0.80119842f, -0.70882344f, 0.69087213f, 0.12214593f, 0.27792037f, -0.67082661f, 
    -0.01054225f, -0.27442682f, 0.90261561f, 0.28127256f, 0.65457773f, -0.25044438f, 0.58965188f, -0.40876710f, 
    0.02760989f, -0.05697257f, 0.11203354f, -0.80300254f, -0.14882600f, -0.03449533f, 0.17466606f, -0.02400628f, 
    0.58228445f, 0.40759569f, 0.40039656f, -0.25083971f, -0.94154584f, 0.72194684f, 0.72503054f, 0.33101419f, 
    0.51097196f, 0.22492018f, -0.14293760f, -0.18671051f, 0.13760471f, 0.92623377f, 0.20600152f, -0.49521402f, 
    0.46858719f, 0.42083910f, 0.00642213f, 0.20380087f, 0.33540341f, 0.36050722f, -0.26903698f, -0.49348974f, 
    -0.42057854f, 0.41732436f, 0.59201640f, 0.44779915f, -0.05043891f, 0.46719450f, -0.18007547f, 0.73610157f, 
    -0.75911117f, -0.19710422f, 0.16185102f, -0.68610525f, -0.42210126f, -0.21923199f, 0.31768662f, -0.22501819f, 
    0.11113780f, 1.06866813f, 0.81869692f, -0.19107790f, -0.56512046f, 0.28079814f, 0.03366883f, -0.11134317f, 
    -0.00672827f, -0.90012217f, -0.22753187f, -0.26872528f, 0.40825972f, 0.82488096f, -0.41145182f, -0.19559127f, 
    -0.32707727f, 0.27616504f, -0.59263247f, -0.43947938f, 0.61031938f, -0.21397878f, 0.52702558f, 0.71822250f, 
    -0.09758894f, -0.14099662f, -0.13370933f, -0.52018595f, -0.23408853f, -0.59086448f, -0.36728236f, -0.59624255f, 
    -0.51421529f, -0.34074661f, 0.16144814f, 0.23126774f, 0.07012308f, -0.00483845f, 0.54005277f, 0.56865454f, 
    0.07100562f, -0.10661750f, -0.40536082f, -0.01032240f, -0.44591901f, 0.61275828f, -0.97982514f, 0.65836817f, 
    0.39952800f, 0.68788511f, 0.43970153f, -0.41239104f, -0.14143023f, -0.06599152f, -0.80657756f, 0.57673049f, 
    -0.24461271f, 0.57701194f, 0.77210677f, 0.06626558f, -0.16099681f, -0.16210988f, 0.08388245f, -0.67489862f, 
    -0.79097176f, -0.77894926f, -0.77927256f, 0.06598428f, 0.42231521f, -0.28669763f, -0.12938946f, 0.04783821f, 
    0.64167398f, -0.50185090f, -0.57889938f, -0.55601323f, 0.19304016f, -0.40605059f, -0.03008383f, 0.08525995f, 
    0.55698276f, -0.41949350f, -0.45513713f, -0.57449758f, -0.55274439f, -0.68469125f, -0.50070965f, 0.47127160f, 
    0.16409229f, -0.15408628f, 0.61195165f, 0.64861381f, -0.79257137f, 0.80732697f, -0.57033598f, -0.34828284f, 
    0.34658825f, 0.37654483f, -0.16373037f, 0.38937107f, -0.33360115f, 0.32735971f, -0.33012354f, -0.95251155f, 
    -0.40105674f, 0.20101564f, 0.47125596f, -0.39666009f, -0.16632025f, -0.65744132f, 0.15179731f, -0.30070451f, 
    -0.68185508f, 0.14103171f, 0.08973220f, 0.25437567f, 0.19510436f, 0.29613224f, -0.18952268f, 0.74824160f, 
    -0.97539943f, -0.22826216f, -0.57228070f, 0.51308340f, 0.39439580f, -0.10503256f, 0.89660299f, -0.84009153f, 
    -0.19669217f, 0.79160237f, -0.18164134f, 0.14272389f, -0.03845376f, 0.13917559f, -0.44734490f, -0.89486015f, 
    0.71439940f, 0.00194332f, 0.74501818f, -0.57068002f, -0.56309092f, 0.27258787f, -0.43912476f, 0.36055976f, 
    -0.25075549f, 0.56604683f, 0.11438502f, -0.95225531f, -0.17857264f, -0.71808738f, 0.13824840f, 0.48162600f, 
    0.32616222f, 0.20638320f, -1.17092967f, 0.29366603f, 0.32833251f, 0.09312838f, 0.17704096f, 0.05579211f, 
    -0.00764863f, -0.57737565f, 0.76530606f, 0.08471803f, 0.56248623f, -0.61960334f, -0.81324732f, 0.59528756f, 
    0.27781683f, -0.47478631f, -0.44996697f, 0.74280131f, 0.60460597f, 0.36516953f, 0.34689870f, -0.48668846f, 
    0.46347851f, -0.27878097f, 0.51440543f, -0.39313373f, -0.70736259f, -0.80320275f, -0.58854550f, 0.46740749f, 
    -0.02129717f, -0.27492732f, 0.28398806f, 0.49166381f, 0.03373709f, 0.80857921f, 1.00988281f, -0.20503446f, 
    0.12222748f, -0.33750930f, -0.61921614f, 0.24541205f, -0.02565280f, 0.07111950f, -0.31346834f, -0.74350476f, 
    -0.35487875f, 0.44488373f, 0.71771544f, -0.47991288f, -0.22521248f, -0.14986129f, -0.34905753f, 0.09924002f, 
    -0.66056168f, 0.79136950f, -0.84449911f, 0.04457354f, -0.44625050f, 0.39543334f, -0.34025487f, 0.43266046f, 
    0.63012415f, 0.68075299f, 0.52290070f, -0.33208311f, -0.49324611f, -0.13215072f, -0.54190594f, -0.31158051f, 
    -0.10939381f, -0.57030791f, 0.61019754f, -0.59545517f, 0.00176725f, -0.32903710f, -0.38750872f, 0.02656378f, 
    -0.05362881f, -0.46735096f, 0.77639687f, 0.18025690f, 0.63100976f, 0.70021713f, -0.45368776f, 0.39559323f, 
    0.13348986f, -0.38305756f, -0.11408826f, 0.70085704f, 0.50656390f, -0.91342074f, 0.62009102f, -0.06101317f, 
    -0.32078680f, -0.49669388f, -0.49186286f, 0.16174869f, 0.38014886f, -0.13033214f, -0.34544364f, -0.04714537f, 
    -0.13398473f, 0.62458831f, -0.39156133f, -0.48507935f, -0.24643518f, -0.41260356f, -0.90083653f, 0.06904769f, 
    -0.24604194f, -0.45685259f, 0.25504065f, -0.30481565f, -0.40734082f, -0.34741545f, -0.08077636f, -0.88684088f, 
    -0.69928038f, -0.33948278f, 0.59405130f, -0.28369147f, 0.25292465f, 0.15065190f, -0.01879491f, 0.08696711f, 
    0.60206693f, 0.59368521f, 0.77885282f, 0.25337467f, -0.62520432f, -0.30106094f, 0.17138240f, -0.27306193f, 
    -1.10450017f, -0.28115225f, 0.71224713f, 0.71929473f, 0.12251806f, 0.28617498f, -0.28147101f, -0.35490108f, 
    -0.18326057f, 0.73119563f, -1.11910343f, 0.40016448f, -0.51863539f, 0.17193322f, 0.31870544f, 0.06766382f, 
    0.04272882f, 0.10098103f, 0.92551756f, 0.46738181f, -0.06661842f, -0.55579180f, 0.48903394f, 0.02464816f, 
    -0.32933903f, 0.30289623f, 0.31613347f, 0.48966888f, -0.07702597f, -0.04391621f, -0.64508837f, -0.81275809f, 
    -0.05051662f, -0.27021050f, 0.50786483f, 0.07083445f, -0.53773260f, 1.04299355f, -0.19150528f, 0.08423769f, 
    0.02872241f, -0.72678512f, -0.23483056f, 0.02963434f, -0.37213665f, 0.45695090f, 0.92929757f, 0.68502671f, 
    -0.33118883f, 0.50179696f, -0.15233620f, 0.16646124f, 0.11180881f, -0.30554160f, 0.50260282f, -0.56396770f, 
    0.12403888f, -0.60304075f, 0.06031450f, 0.10729814f, 0.53683716f, 0.24706559f, -0.46348017f, 0.34960204f, 
    0.64083368f, 0.51952225f, -0.52520466f, 0.45199353f, -0.35469609f, 0.32378465f, -0.01362708f, 0.33307180f, 
    0.80862343f, -0.40843305f, -0.79670197f, 0.12038226f, 0.34959102f, -0.53604484f, -0.38602877f, 0.01924270f, 
    -0.27680051f, 0.04486251f, -0.74991626f, -0.61511004f, -0.40625033f, 0.52017754f, 0.02409475f, -0.05324682f, 
    0.54490131f, 0.33178392f, -0.97110724f, 0.57828552f, 0.77591628f, -0.53810871f, 0.85322624f, -0.17251636f, 
    0.13350374f, -0.16071957f, 0.43582040f, -0.73055434f, -0.09684907f, -0.49029535f, 0.47729221f, -0.60351121f, 
    0.19957936f, -0.50405985f, 0.06509563f, -0.05893584f, -0.83184046f, 0.25780126f, 0.63525504f, -0.74647474f, 
    0.49058679f, -0.15692142f, -0.22068818f, 0.25920215f, -0.30778953f, -0.64972794f, -0.87129515f, -0.47180331f, 
    -0.40936434f, 0.10874104f, 0.40228373f, 0.17437021f, -0.37670949f, 0.23874183f, 0.75663936f, 0.00573285f, 
    -0.26247522f, -0.40480697f, -0.26566634f, -0.62139332f, -0.19872305f, -0.41887751f, -0.21860899f, -0.04064844f, 
    -0.83059436f, 0.80172563f, -0.21207587f, -0.62109929f, -0.37244090f, -0.03645711f, -0.06448200f, -0.26436329f, 
    -0.37996352f, -0.74535304f, -0.22062638f, -0.17062123f, 0.89808118f, 0.56500971f, -0.40596408f, 0.10985967f, 
    -0.08660815f, -0.59783202f, -0.38653809f, -0.32214198f, 0.64299905f, 0.52419013f, 0.63174069f, 0.31084755f, 
    -0.32259318f, -0.04898555f, -0.61853540f, 0.87698805f, -0.51425374f, 0.14922366f, 0.55969286f, -0.11197203f, 
    -0.42248437f, -0.19120458f, 0.37331033f, -0.87039608f, 0.69150734f, -0.55253488f, 0.34733149f, -0.07121830f, 
    -0.52491760f, -0.16697206f, 0.21779361f, 0.46621937f, 0.43336371f, -0.71993810f, -0.29558188f, -0.48703584f, 
    0.47579548f, 0.58021301f, 0.31306836f, 0.60519755f, -0.26639000f, 0.09691465f, -0.23336408f, -0.06250297f, 
    0.21680722f, -0.65744853f, -0.64784241f, -0.02930584f, 0.40261799f, 0.40055412f, 0.18177216f, -0.68379343f, 
    -0.56293589f, 0.60644424f, -0.60109502f, -0.24166031f, -0.34420878f, 0.22906062f, 0.18159416f, 0.40915257f, 
    0.68674016f, 0.79477537f, -0.86222941f, 0.74033409f, -0.15970874f, -0.27136618f, 0.23380767f, -0.23224021f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06484868f, -0.14978714f, -0.07863026f, 0.01830491f, 0.07696187f, 0.06923916f, 0.10885511f, -0.12492127f, 
    -0.04066834f, -0.21687874f, 0.00465706f, 0.12722155f, 0.05882065f, -0.11111677f, -0.04072546f, -0.09970926f, 
    0.07040507f, 0.20768435f, -0.12625596f, 0.15560040f, 0.13024314f, 0.05753411f, -0.03218710f, -0.17219499f, 
    -0.12829030f, 0.00614752f, -0.17209215f, 0.04413207f, -0.09891812f, -0.29199600f, 0.01036634f, -0.17603154f, 
    -0.26694474f, -0.01688925f, 0.14751595f, 0.00699131f, -0.14727965f, -0.11755929f, 0.20192941f, -0.10386161f, 
    -0.24308382f, -0.10169724f, -0.02939226f, -0.06601363f, -0.18877782f, 0.01127744f, 0.05155350f, -0.04007824f, 
    0.19279818f, -0.00010916f, -0.20580377f, -0.11159739f, 0.12702473f, -0.02720290f, -0.14643022f, 0.18631746f, 
    -0.07850125f, 0.06231109f, -0.30727643f, -0.13145174f, -0.03878120f, 0.06817082f, 0.20831056f, -0.14563054f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00096450f, -0.05692706f, -0.02612961f, -0.11170314f, 0.10833215f, -0.09486839f, 0.02530893f, 0.05972027f, 
    0.03330581f, -0.05216626f, 0.03767455f, -0.01841131f, -0.00730968f, 0.01626314f, -0.00984591f, 0.00525112f, 
    -0.00590714f, 0.03399163f, -0.02129624f, 0.00062079f, 0.08725484f, 0.02502220f, -0.05637776f, -0.13067825f, 
    -0.29307559f, 0.12680578f, 0.01696272f, 0.03763988f, 0.00529952f, -0.03652218f, 0.09384918f, -0.07111717f, 
    0.02955497f, 0.07315892f, -0.02095818f, 0.01134816f, 0.03219353f, 0.02558921f, -0.01458200f, 0.05160195f, 
    0.15040326f, 0.12556052f, -0.03086685f, -0.08977881f, 0.01633032f, -0.13180694f, -0.13914125f, -0.05996368f, 
    0.04339726f, 0.06674401f, -0.01014538f, 0.04442987f, -0.09484859f, -0.00966102f, -0.02029673f, -0.04300960f, 
    0.03138784f, 0.02540629f, -0.01788943f, 0.04985211f, -0.09271370f, 0.00909666f, 0.06682642f, -0.01239361f, 
    -0.17521876f, 0.06073212f, 0.01624972f, -0.03054290f, 0.01771029f, -0.00037506f, 0.06120411f, -0.04109822f, 
    0.09442022f, -0.01760415f, -0.00847256f, 0.02614690f, -0.06726219f, -0.00778184f, 0.07491375f, -0.03872249f, 
    0.12238043f, 0.02350048f, 0.18462178f, 0.09123250f, 0.10749407f, -0.07568891f, -0.01813120f, 0.00397469f, 
    -0.04056061f, -0.03272466f, 0.02702829f, -0.04202776f, 0.02075099f, -0.00194691f, 0.02117834f, 0.02733946f, 
    -0.00401566f, -0.01755245f, -0.01822913f, 0.01671672f, -0.06473923f, -0.17463478f, 0.01166061f, -0.10432012f, 
    0.24238977f, -0.10947610f, -0.05855810f, -0.04091682f, 0.06610756f, 0.01636240f, -0.06120207f, 0.06632755f, 
    0.04464960f, 0.04333227f, 0.02839733f, 0.09275171f, -0.08238871f, -0.01930025f, 0.03687279f, 0.02191025f, 
    -0.02406554f, 0.14409387f, -0.04077722f, -0.22895676f, -0.18322566f, 0.05381011f, 0.03712738f, -0.02061150f, 
    0.02078439f, 0.00466563f, 0.01441187f, 0.01552395f, 0.01278340f, 0.02357017f, 0.00510456f, 0.00788998f, 
    0.02838177f, -0.03723386f, -0.01361157f, 0.04186143f, 0.10470565f, -0.43226680f, 0.21758655f, 0.07216550f, 
    -0.12014426f, 0.03533164f, -0.05483804f, 0.07717097f, 0.00404189f, 0.05939575f, -0.12838332f, -0.00283196f, 
    -0.01461627f, 0.08569692f, 0.04599541f, -0.02878590f, 0.00399023f, 0.04229319f, 0.06866051f, -0.06259296f, 
    -0.15918408f, 0.21086703f, -0.01223247f, -0.00675826f, 0.25079015f, -0.09818818f, -0.16765879f, -0.03099271f, 
    -0.00642373f, 0.00764215f, 0.04577540f, -0.05224353f, -0.02943774f, 0.00297175f, 0.01794834f, 0.03761867f, 
    0.02979932f, -0.02436382f, 0.00149550f, 0.09838220f, 0.43548438f, 0.10640864f, 0.19859366f, -0.08580653f, 
    -0.20295398f, -0.02221942f, 0.08389511f, -0.04839079f, 0.02876013f, -0.04575349f, -0.01071647f, -0.01392638f, 
    -0.08139285f, 0.05867861f, 0.02136393f, 0.00564535f, -0.09530868f, 0.02915646f, -0.01488706f, 0.01172993f, 
    -0.18390374f, 0.11460862f, 0.10032354f, 0.07432231f, -0.03525438f, -0.04330926f, 0.01784069f, 0.06731124f, 
    0.04441527f, -0.08269395f, -0.00477120f, -0.02806780f, -0.01598266f, 0.00390944f, -0.02758423f, -0.02451510f, 
    0.00252503f, -0.04455387f, 0.08193821f, 0.06606720f, -0.16857643f, -0.30617353f, -0.07587012f, 0.07539012f, 
    -0.03419568f, 0.00933534f, -0.06849385f, -0.01933128f, 0.03675326f, 0.03728930f, -0.01390686f, -0.05103641f, 
    -0.13383980f, -0.00967128f, -0.09748571f, 0.05148001f, 0.00079982f, 0.04633841f, 0.03614539f, -0.01429669f, 
    -0.02987927f, 0.04022256f, 0.09389136f, 0.10533886f, -0.05189814f, -0.01916263f, -0.10146433f, 0.05204256f, 
    0.01286723f, -0.03804168f, -0.04617466f, 0.01335406f, -0.00704248f, 0.06295228f, -0.07688267f, 0.05487224f, 
    -0.05614166f, -0.01179185f, -0.09265524f, -0.01951306f, 0.04661391f, 0.07550921f, 0.00450309f, 0.06085803f, 
    -0.12109515f, -0.00554328f, -0.02910496f, 0.09598292f, -0.04560008f, -0.06752004f, 0.01138265f, 0.04133531f, 
    -0.00641423f, -0.05953300f, 0.05046533f, 0.01029602f, 0.01136228f, -0.01808919f, -0.05755329f, 0.04985195f, 
    0.33474684f, 0.10808542f, 0.13229750f, -0.06151494f, 0.02117189f, -0.00082910f, 0.02526444f, 0.04200606f, 
    0.00253805f, -0.08968796f, 0.04200327f, -0.06328035f, -0.12002721f, 0.01791948f, 0.08158090f, -0.02313739f, 
    0.01738507f, -0.00870115f, 0.00906705f, -0.00788537f, -0.24990442f, 0.13729486f, -0.20771955f, -0.03741436f, 
    -0.26450664f, 0.03527800f, 0.01385009f, -0.04123727f, 0.03381394f, 0.01794302f, 0.03000963f, -0.04736343f, 
    0.01641198f, 0.05423858f, -0.02272630f, 0.02639928f, -0.08314202f, 0.02082489f, 0.01706173f, 0.06185500f, 
    -0.21037859f, -0.22964138f, 0.16690198f, 0.05375193f, -0.07494525f, -0.01385783f, -0.05028860f, 0.05240350f, 
    0.04202193f, 0.06341612f, -0.00275295f, 0.07208320f, 0.00855309f, 0.01195543f, -0.04294225f, -0.03204046f, 
    -0.11640203f, -0.05114586f, 0.00821103f, -0.06726213f, -0.19167815f, -0.40945151f, -0.01324717f, 0.13590583f, 
    -0.03972805f, -0.01883148f, -0.08515008f, 0.04015665f, 0.06419127f, 0.02024510f, 0.01418584f, -0.07037374f, 
    -0.05305161f, -0.09309532f, 0.03161063f, 0.02529278f, 0.03515379f, 0.01701882f, 0.07545894f, -0.00171273f, 
    0.22717799f, -0.26297110f, 0.16350572f, -0.03818291f, 0.21275879f, -0.15982613f, 0.05361824f, 0.04271154f, 
    0.06216725f, -0.03044745f, -0.02193347f, -0.00542387f, -0.02565205f, 0.08370573f, -0.02450462f, 0.04512225f, 
    0.05143351f, 0.00471081f, -0.01999484f, -0.02402989f, 0.05155394f, -0.19611946f, 0.02494438f, 0.04912134f, 
    -0.14705943f, -0.04839065f, -0.03003724f, 0.00421835f, -0.08100960f, -0.05231261f, -0.04932304f, -0.00194253f, 
    0.01211689f, -0.05590051f, -0.00691607f, -0.04564869f, -0.05486440f, 0.02094737f, 0.00902090f, -0.01189571f, 
    -0.02902396f, -0.24484129f, -0.02864107f, 0.04305764f, -0.19088361f, 0.02159749f, 0.00413571f, -0.02473200f, 
    0.00164589f, 0.03537175f, -0.07990488f, 0.01013128f, -0.01168610f, -0.07559177f, -0.02620119f, 0.00830813f, 
    -0.01736708f, -0.07345051f, -0.03720669f, -0.04983899f, 0.08632315f, -0.07075408f, -0.11172592f, 0.12875235f, 
    -0.10246684f, -0.05856033f, -0.04502464f, -0.04875818f, -0.07667489f, 0.02882393f, 0.04245308f, 0.06130831f, 
    -0.00423912f, -0.00358719f, -0.04858031f, -0.01381988f, -0.04510528f, -0.02076777f, 0.02146973f, 0.06320266f, 
    0.26532894f, -0.07566278f, 0.07964806f, 0.00248416f, -0.13146846f, 0.01914489f, 0.00803311f, 0.00106205f, 
    0.02194976f, -0.04204769f, -0.16175842f, 0.02718393f, 0.01512338f, -0.03077016f, 0.01443345f, 0.02886931f, 
    0.05652901f, 0.01155636f, 0.00747333f, 0.03104246f, 0.09605064f, -0.08107845f, 0.05261839f, -0.05352992f, 
    0.04780722f, -0.08388130f, -0.08694876f, -0.00574440f, -0.15312736f, -0.02158382f, -0.01795864f, 0.05570398f, 
    0.04275247f, 0.03319341f, 0.00250725f, 0.00359429f, -0.04165308f, 0.07172778f, -0.09182510f, -0.13203134f, 
    -0.16200776f, -0.18102184f, 0.03392375f, 0.01305580f, 0.07385565f, 0.04544188f, -0.00958791f, -0.07866824f, 
    -0.05643151f, 0.07628807f, -0.02196043f, 0.07197207f, -0.06321147f, -0.04403036f, 0.02770077f, -0.10628003f, 
    0.00906648f, 0.07207163f, 0.12288934f, -0.10335980f, 0.01180504f, -0.00716650f, -0.03944851f, -0.02774447f, 
    -0.42102322f, 0.04843374f, 0.01801900f, 0.03218633f, -0.04213989f, 0.00831805f, -0.00844256f, 0.00928101f, 
    -0.09014377f, -0.02373359f, -0.04511741f, -0.01905307f, -0.00768961f, -0.01923239f, -0.02895524f, 0.05725176f, 
    0.18338659f, -0.02245240f, -0.02056736f, 0.03217712f, 0.04199201f, -0.15360427f, -0.07890224f, -0.11024034f, 
    -0.00942029f, -0.02617475f, -0.10003103f, 0.01528508f, 0.16394061f, -0.07738293f, 0.07336575f, 0.00412080f, 
    0.02151434f, -0.04705259f, 0.03893565f, 0.07463109f, 0.14701159f, -0.03164782f, 0.06276529f, -0.10273357f, 
    0.04868210f, -0.08569947f, -0.06401888f, -0.07224035f, 0.05370921f, 0.01596296f, -0.05891106f, -0.05316921f, 
    -0.03563702f, 0.04284146f, -0.01068148f, 0.01406528f, 0.02386053f, -0.08037008f, -0.01573917f, 0.03470404f, 
    -0.11982507f, -0.22749993f, -0.04993806f, -0.05166567f, -0.12854026f, -0.01271982f, -0.04299953f, 0.08120013f, 
    0.08357944f, 0.02334254f, -0.05978331f, 0.03886405f, 0.02971665f, -0.01063192f, 0.13394441f, 0.07010211f, 
    0.02037403f, 0.05192333f, 0.05936819f, 0.05594840f, 0.10107317f, 0.17062934f, 0.14525998f, -0.25462976f, 
    0.24781412f, -0.17836082f, 0.03888348f, 0.05238752f, 0.10256338f, 0.00073772f, 0.01493251f, 0.00468146f, 
    0.03268994f, -0.00614509f, -0.04839787f, 0.05418970f, -0.00545627f, 0.09893273f, -0.03101343f, 0.02932285f, 
    -0.08766279f, 0.08108430f, 0.16348659f, -0.00497865f, -0.26065180f, 0.01542699f, 0.00066886f, 0.00145764f, 
    0.03507710f, -0.07213397f, -0.02268758f, 0.03739179f, -0.01082926f, 0.03780811f, 0.02220462f, 0.00510754f, 
    0.04484371f, 0.02312361f, -0.06784723f, 0.00778073f, 0.24752834f, -0.08086016f, 0.00743642f, 0.09980901f, 
    -0.20227803f, -0.01584744f, -0.01538490f, 0.03670158f, 0.04024414f, -0.00416091f, 0.01046790f, 0.00461981f, 
    -0.00347979f, -0.00449274f, -0.02230007f, -0.08605576f, -0.00564983f, 0.01665269f, 0.01293902f, 0.04028371f, 
    0.18296412f, 0.15466461f, -0.03152318f, -0.05902732f, 0.15412240f, -0.04477530f, -0.18731444f, -0.03018153f, 
    0.08926890f, 0.08301088f, 0.01871388f, -0.03505569f, -0.02294664f, 0.01151124f, 0.00208198f, 0.12155767f, 
    0.06598026f, -0.03263474f, 0.06711021f, 0.12296972f, 0.08701748f, -0.11053583f, 0.13814703f, 0.00891696f, 
    0.01240743f, 0.00102952f, -0.09034488f, 0.03195996f, -0.00482760f, 0.04893602f, 0.05048453f, 0.00600688f, 
    -0.03257468f, 0.01283029f, -0.02905074f, -0.00274771f, -0.00504668f, 0.03677790f, 0.00080112f, -0.10427457f, 
    0.13314946f, -0.21460932f, 0.08192771f, -0.03227419f, -0.02752245f, -0.08982704f, -0.07147495f, -0.00954754f, 
    0.01723315f, -0.01051667f, -0.10380585f, -0.00073989f, -0.09571155f, -0.05618479f, 0.00805823f, 0.03857493f, 
    0.00565424f, 0.03748864f, -0.02592477f, 0.00690233f, 0.07429575f, -0.11225549f, 0.08556827f, 0.04833685f, 
    0.25307584f, -0.09823420f, -0.05549786f, -0.02496970f, 0.05336165f, -0.01923007f, 0.05714414f, 0.04684969f, 
    -0.01092508f, 0.01478456f, -0.09315100f, 0.08241855f, 0.00921286f, -0.01995151f, -0.15497893f, 0.01563403f, 
    0.10147455f, -0.00793378f, 0.05407112f, 0.06544776f, 0.08656723f, -0.08797135f, 0.10240242f, -0.04388892f, 
    -0.01656205f, -0.09102659f, -0.01846589f, -0.00198317f, 0.09589078f, -0.02325959f, -0.00779573f, 0.07567149f, 
    0.02287812f, -0.04776231f, -0.02879222f, -0.04056242f, -0.12394673f, -0.13700610f, -0.13070808f, 0.12188964f, 
    -0.25820765f, 0.01141219f, -0.00184369f, -0.08496478f, 0.07998937f, 0.04015387f, 0.04571581f, -0.01429990f, 
    -0.09412087f, 0.01327798f, 0.04484415f, 0.00436113f, -0.02970196f, 0.03017930f, 0.03544489f, 0.03002600f, 
    -0.26887831f, -0.02902492f, -0.05773737f, 0.01288571f, -0.18921438f, -0.04603726f, -0.07674532f, 0.02583375f, 
    0.01664955f, 0.03749721f, -0.02529346f, 0.05219288f, -0.02608817f, -0.01051484f, 0.01016709f, 0.00239911f, 
    0.02242093f, -0.00482897f, -0.03462559f, 0.01806239f, -0.12501481f, 0.04405891f, 0.16992791f, 0.02886334f, 
    0.00855493f, -0.07511643f, -0.18245181f, 0.06775204f, 0.01498510f, 0.03757238f, -0.01170746f, 0.04486909f, 
    -0.03356082f, 0.08377577f, -0.07730471f, -0.03265509f, -0.00889149f, -0.04203379f, -0.12145573f, -0.01885748f, 
    -0.08219139f, 0.07110460f, 0.30358148f, 0.15392314f, -0.27183354f, 0.03538316f, 0.03923992f, 0.09520418f, 
    0.08112059f, 0.01538216f, -0.04094300f, -0.00302826f, 0.02556134f, -0.12413424f, -0.02627088f, 0.03868374f, 
    0.04061881f, 0.00638515f, 0.03540014f, 0.07738095f, 0.16855769f, -0.22036432f, -0.00813670f, 0.13770650f, 
    -0.43606851f, -0.03779668f, 0.03214409f, 0.07001029f, -0.04312754f, 0.03060616f, 0.01552476f, 0.06272635f, 
    -0.00260348f, -0.06206159f, 0.07447261f, -0.04560164f, -0.08389172f, -0.03832802f, 0.00099224f, 0.02869649f, 
    -0.01799406f, 0.02133287f, -0.00080515f, -0.14293639f, 0.12725140f, -0.09680052f, -0.04372217f, -0.10032669f, 
    0.07074346f, 0.01920617f, 0.00075320f, 0.03484959f, 0.02244841f, -0.02801806f, 0.02822396f, -0.05578949f, 
    -0.02857623f, -0.07963071f, 0.01515668f, -0.06938358f, 0.10688355f, -0.07359345f, 0.06292614f, -0.02248135f, 
    0.00602260f, 0.00168833f, -0.04283182f, -0.05922386f, 0.02392977f, 0.04692670f, -0.09726278f, 0.01866999f, 
    0.00406784f, -0.03609438f, 0.07550425f, -0.03884157f, -0.04762709f, -0.09937432f, 0.05059716f, -0.03230900f, 
    -0.01871985f, 0.06346973f, 0.17473872f, -0.17892356f, 0.19127344f, 0.01167679f, -0.05632792f, 0.06907168f, 
    -0.10975646f, 0.06104824f, -0.01456553f, 0.06941335f, -0.09574791f, 0.07028683f, -0.04973591f, -0.11073659f, 
    -0.03903296f, 0.07520317f, -0.00356213f, -0.06273288f, 0.00158274f, 0.13035269f, 0.03238465f, -0.19133322f, 
    0.19934313f, -0.09800968f, -0.10565068f, -0.01244838f, -0.00084323f, 0.00747662f, -0.03934252f, 0.00746166f, 
    -0.02567976f, -0.03029898f, 0.07011978f, 0.00000017f, 0.01109659f, -0.03229972f, 0.02009420f, -0.00810944f, 
    -0.02874889f, -0.07886164f, -0.08422854f, 0.12183591f, -0.09771170f, -0.11447132f, -0.03139768f, -0.06291300f, 
    -0.08666363f, 0.01935525f, 0.01272710f, 0.00899614f, -0.02445962f, -0.00624580f, 0.01153185f, -0.03971763f, 
    -0.05120444f, -0.00113584f, -0.03287797f, 0.04713452f, 0.02336540f, 0.05903774f, -0.01632378f, -0.07320219f, 
    0.05982477f, -0.06850948f, -0.03936614f, -0.05608845f, 0.02952010f, -0.02211229f, -0.02543420f, -0.05393731f, 
    0.01193866f, -0.05989049f, 0.01884433f, -0.10729573f, 0.00043355f, 0.04526164f, -0.06048146f, -0.05946512f, 
    0.01887566f, -0.20673551f, 0.16411783f, 0.01535356f, 0.16771099f, -0.03207429f, -0.05590842f, -0.02432059f, 
    -0.01398123f, -0.04535849f, -0.03523555f, 0.02728525f, 0.06984358f, -0.01540620f, -0.04984308f, -0.07407371f, 
    0.05565367f, -0.00026844f, 0.02011906f, -0.04868196f, -0.23758379f, -0.02084717f, -0.05654793f, -0.04245613f, 
    -0.15173607f, 0.00306735f, -0.03892027f, 0.01583725f, -0.02984852f, 0.09520005f, 0.03044450f, 0.06657349f, 
    -0.00055156f, -0.04674903f, 0.05562039f, -0.01286450f, -0.02342340f, -0.04383390f, 0.02714667f, 0.04662598f, 
    0.06663993f, -0.08857758f, 0.19488913f, -0.04900268f, 0.09736715f, -0.01700463f, 0.00098797f, 0.04775935f, 
    -0.03614842f, 0.01451168f, 0.01082936f, -0.00913247f, 0.07465490f, 0.01211630f, 0.03418501f, 0.01603941f, 
    -0.00074641f, -0.02823206f, 0.02825841f, -0.04360960f, 0.19081469f, -0.12574333f, -0.07944804f, 0.02385606f, 
    -0.24088864f, 0.05387179f, 0.04628028f, 0.02776321f, 0.00609998f, 0.01699468f, 0.03540400f, -0.01865623f, 
    -0.07177024f, 0.06142588f, -0.00029445f, 0.11144158f, -0.04216230f, 0.02386486f, -0.11595202f, 0.02280104f, 
    -0.09237906f, -0.06579258f, 0.09586778f, 0.08024159f, -0.00042086f, -0.01633925f, 0.03017061f, 0.00908178f, 
    -0.01181675f, 0.08427209f, 0.01848756f, -0.02646167f, 0.00936292f, -0.03142114f, -0.06553995f, 0.06378032f, 
    -0.08818085f, -0.05570517f, -0.00007632f, -0.08167637f, -0.32024962f, 0.07500868f, -0.18213707f, -0.02603736f, 
    -0.33187759f, 0.08420637f, 0.04086873f, -0.02016411f, 0.05599999f, 0.02945729f, 0.04993580f, -0.04730142f, 
    -0.07462937f, 0.06122880f, 0.03261170f, -0.03453739f, 0.00336484f, -0.03985835f, 0.06909825f, -0.01912766f, 
    0.08938895f, -0.06248108f, 0.12686636f, 0.15965417f, 0.13271643f, 0.01011218f, -0.01451289f, -0.10604866f, 
    0.03280798f, 0.04356467f, 0.02788434f, -0.00256809f, 0.07251079f, -0.01752619f, -0.03675592f, 0.05268538f, 
    0.00887060f, -0.00775844f, 0.07855030f, -0.05971131f, 0.10865349f, -0.23316991f, -0.12406098f, 0.06936498f, 
    -0.22819851f, -0.03600688f, -0.08997692f, 0.04694071f, -0.00925096f, 0.05669219f, -0.07739762f, 0.10710836f, 
    -0.08518615f, 0.00053638f, -0.07282922f, -0.06191144f, -0.09786123f, 0.05728722f, -0.03912395f, -0.01121072f, 
    -0.15451650f, 0.16394824f, -0.05682659f, -0.18802094f, -0.16277474f, 0.00917549f, 0.03920639f, -0.00622913f, 
    0.06347567f, -0.05127632f, 0.01728163f, 0.02481686f, 0.04652938f, -0.03141311f, 0.00863376f, -0.04344319f, 
    0.02117147f, 0.02655435f, -0.00301870f, -0.00505829f, 0.10730968f, 0.02682195f, 0.08846638f, -0.13734634f, 
    -0.20736328f, 0.08548426f, 0.10137783f, -0.01002673f, 0.02776154f, 0.02435223f, -0.04717196f, -0.02579309f, 
    -0.05888379f, 0.05143302f, 0.05563799f, 0.04851788f, 0.04508300f, -0.03399913f, 0.07544217f, -0.01387419f, 
    0.50755155f, 0.15542413f, 0.03202943f, -0.11286442f, 0.17270884f, 0.00906765f, -0.06232696f, 0.05016775f, 
    -0.03994556f, -0.06817367f, 0.09664468f, -0.02365251f, -0.08698565f, 0.03567957f, 0.15376891f, -0.08253677f, 
    -0.04840646f, 0.05895215f, -0.05384467f, 0.02942816f, 0.32527629f, -0.03701925f, -0.04547967f, -0.04948991f, 
    0.03248635f, 0.02102133f, -0.05931406f, 0.02345137f, -0.11330138f, 0.03463490f, 0.03434738f, 0.00668147f, 
    -0.08749180f, 0.01332256f, 0.05924280f, -0.07986768f, -0.06033885f, 0.09116061f, -0.15083478f, -0.02601730f, 
    -0.11654967f, 0.06841833f, -0.13167220f, 0.01661174f, -0.14358450f, -0.13499001f, 0.07060493f, -0.03732421f, 
    -0.14958562f, 0.04275243f, 0.03772733f, 0.01617879f, 0.04616002f, -0.01272413f, 0.08369170f, 0.01196253f, 
    -0.01646223f, -0.05781097f, -0.09568437f, 0.00492241f, -0.07202803f, -0.22533262f, 0.09429266f, 0.02503201f, 
    -0.00976027f, 0.01081425f, -0.02943200f, 0.00993032f, -0.06301089f, 0.02456244f, -0.13350444f, -0.03995784f, 
    0.00616227f, 0.02360149f, -0.01192529f, 0.05171036f, 0.07330611f, -0.02210658f, -0.01801535f, -0.13140297f, 
    0.11822248f, -0.22510143f, 0.08418534f, -0.02693719f, -0.09198537f, 0.05524952f, -0.01956886f, 0.10066342f, 
    -0.02338149f, -0.06628460f, -0.07164729f, 0.02724439f, -0.03363192f, 0.02181754f, 0.05167348f, 0.04090806f, 
    0.03289614f, -0.00362955f, -0.10757324f, -0.00680003f, 0.09993878f, 0.07234963f, -0.04190388f, -0.03412018f, 
    0.10706040f, -0.13508759f, -0.07255915f, -0.06415983f, -0.01674465f, 0.04966648f, 0.02186498f, 0.00291218f, 
    0.04123528f, -0.07271039f, 0.02585372f, 0.00379225f, 0.04081718f, -0.06221886f, 0.01002319f, -0.03998018f, 
    0.02624932f, 0.04147835f, 0.20289317f, 0.06413117f, 0.09351046f, -0.12490360f, -0.09242940f, 0.00460753f, 
    -0.06243818f, -0.02759789f, -0.06371477f, 0.04435159f, 0.01117008f, 0.03154116f, -0.03541446f, -0.08715994f, 
    0.08246892f, -0.10495946f, 0.02723239f, 0.03744060f, 0.09288297f, -0.09392026f, -0.12876533f, -0.01856918f, 
    -0.21433231f, -0.01136275f, -0.02261848f, -0.03511890f, -0.02709854f, 0.08583792f, 0.09337337f, 0.05845064f, 
    0.03259723f, -0.09360128f, -0.05224130f, 0.01329048f, 0.07069486f, -0.04526957f, -0.05855998f, 0.07510362f, 
    0.29773980f, 0.03765370f, 0.11434135f, 0.06966959f, 0.21623538f, -0.02552463f, -0.06314423f, 0.03725163f, 
    0.02077175f, -0.02097215f, 0.12471373f, -0.01340754f, 0.05323890f, -0.01515863f, 0.03203835f, -0.06520042f, 
    0.04523239f, 0.00718229f, -0.03287211f, 0.01465278f, -0.07349078f, 0.04955927f, -0.15420806f, 0.04226103f, 
    -0.12726940f, -0.03350851f, 0.00321406f, 0.01342120f, 0.09414378f, 0.00195394f, 0.01316936f, -0.01434979f, 
    -0.04471346f, 0.03666845f, -0.07121445f, 0.04472257f, 0.10506666f, 0.00230434f, -0.01910544f, 0.12260378f, 
    -0.15654807f, 0.09236202f, -0.01708351f, -0.03933329f, 0.09098212f, -0.05314939f, 0.13724340f, 0.03004565f, 
    -0.07835720f, 0.00110304f, -0.00702883f, 0.04243665f, 0.06789263f, -0.00888699f, 0.00654457f, 0.12923653f, 
    -0.10403755f, 0.04400592f, 0.06917586f, -0.01262801f, 0.24470364f, -0.10183150f, 0.12828857f, -0.04448298f, 
    -0.08746674f, -0.04564695f, -0.07330917f, -0.01208231f, -0.00667549f, -0.05171333f, 0.01111691f, -0.06416375f, 
    -0.07988671f, 0.01479034f, 0.00853592f, -0.03230007f, 0.03773622f, -0.05175905f, 0.05272465f, -0.00266923f, 
    0.12689896f, -0.05546444f, -0.05758458f, 0.01078264f, -0.07272626f, 0.00815647f, 0.03782110f, -0.00126137f, 
    0.01135691f, 0.07131978f, 0.04811803f, 0.03492495f, -0.03319433f, 0.03751263f, -0.07325642f, 0.07189652f, 
    0.07306705f, 0.02587421f, -0.02385966f, 0.04570349f, 0.06454527f, -0.01045102f, 0.19073781f, -0.20412239f, 
    0.00449545f, 0.02743288f, 0.04603650f, -0.02619565f, -0.07251857f, -0.08318964f, 0.03692645f, -0.04667015f, 
    0.06536472f, -0.04877474f, -0.02705541f, -0.08885576f, -0.08057998f, -0.19539592f, -0.05440960f, 0.02541340f, 
    0.11309401f, 0.08988693f, -0.08631938f, -0.02631201f, 0.12640113f, 0.04740320f, 0.06218917f, 0.05677914f, 
    -0.04146742f, 0.06526613f, -0.12062545f, -0.04617579f, 0.03686607f, 0.12831746f, 0.08948870f, -0.01584688f, 
    -0.02232631f, 0.02079474f, -0.05376057f, -0.02361503f, -0.32908565f, -0.03075271f, -0.10957295f, -0.03463243f, 
    -0.06740693f, 0.02738785f, -0.03103550f, -0.05334993f, 0.04309538f, -0.04152429f, -0.04669368f, 0.06394824f, 
    -0.01635469f, -0.08385292f, 0.01666426f, 0.04479393f, 0.03172214f, -0.03772693f, 0.05480523f, -0.09578468f, 
    -0.15896739f, 0.09553216f, -0.08732495f, -0.00632365f, -0.07953717f, -0.00529586f, 0.00166661f, -0.09489750f, 
    -0.03362357f, 0.06490903f, 0.02179444f, 0.03578425f, -0.06302047f, -0.04022336f, 0.02672291f, -0.03942093f, 
    -0.03523080f, 0.02610659f, -0.05105546f, 0.02428155f, 0.00899211f, 0.02521345f, -0.02738033f, -0.15778832f, 
    0.04854986f, 0.01893592f, -0.05251447f, 0.14923537f, 0.03970810f, 0.00204477f, -0.06991938f, -0.08169349f, 
    0.08411370f, 0.07136303f, 0.03564691f, -0.05721005f, 0.11994095f, -0.11139268f, -0.03257921f, -0.11907553f, 
    0.21497403f, 0.04071226f, 0.01945454f, -0.02123208f, 0.07016986f, -0.03652102f, -0.00234124f, -0.01420852f, 
    -0.04567137f, 0.10004311f, -0.01232531f, 0.04870295f, 0.01431807f, -0.05494661f, 0.02172327f, -0.05862122f, 
    -0.00623430f, 0.07212717f, 0.03115464f, 0.12972446f, 0.34673551f, 0.00344114f, -0.00471424f, 0.05619053f, 
    -0.05463454f, 0.00924674f, 0.01608596f, -0.00998017f, -0.04959694f, 0.14815490f, 0.17877933f, 0.03823244f, 
    -0.06779688f, -0.07283748f, -0.10583441f, -0.01327101f, 0.04964622f, 0.08563900f, 0.04612309f, -0.00717543f, 
    -0.36903280f, 0.02485908f, -0.02894585f, -0.01075873f, 0.06231831f, -0.02471992f, 0.03675681f, -0.03723732f, 
    -0.04611914f, -0.00944000f, 0.08669616f, 0.10788671f, 0.05539808f, -0.04787431f, 0.02692546f, 0.10585864f, 
    -0.06424967f, 0.01176174f, -0.02333916f, -0.02353542f, 0.13175766f, -0.12721574f, 0.03254782f, 0.04008676f, 
    -0.05871147f, -0.03888404f, -0.03844565f, -0.03669545f, 0.07435901f, 0.07116556f, -0.04310074f, -0.08911593f, 
    0.05161430f, -0.00358801f, -0.00503705f, -0.04167883f, -0.00161625f, -0.02108805f, -0.02740705f, -0.03207839f, 
    0.22117461f, -0.35596940f, -0.10245150f, -0.01736241f, 0.03000182f, -0.01011175f, -0.00799559f, -0.02503857f, 
    0.07530618f, 0.04688963f, 0.00385072f, 0.02950048f, -0.04840031f, -0.05953151f, 0.12428064f, -0.00985524f, 
    -0.06916428f, 0.03730704f, -0.06831332f, -0.06582303f, 0.05296667f, -0.00593067f, -0.12516531f, -0.04140817f, 
    -0.07997632f, 0.15090269f, 0.01879496f, 0.04685649f, 0.07895009f, 0.02362101f, -0.04915674f, -0.00781407f, 
    0.06961196f, 0.12397512f, -0.02474419f, 0.02372581f, -0.02680771f, -0.13896726f, -0.10660676f, -0.11455561f, 
    -0.01161536f, -0.31170785f, 0.06033653f, -0.14207840f, 0.02040779f, -0.01609256f, -0.11324406f, 0.06615315f, 
    -0.08763368f, 0.01271525f, 0.03929471f, 0.04214385f, -0.04069192f, -0.02050506f, -0.02308033f, -0.05194803f, 
    0.01129398f, -0.18585540f, 0.01140853f, -0.02283514f, -0.09213311f, 0.05984036f, 0.04699937f, 0.00699642f, 
    -0.09955094f, 0.07381783f, 0.01634568f, -0.03033409f, 0.03957742f, -0.01698684f, -0.02654819f, -0.01531104f, 
    0.04382158f, 0.11446095f, 0.04553124f, -0.03698680f, 0.01300421f, -0.12419786f, -0.01851338f, 0.06377149f, 
    -0.23215720f, 0.11880697f, 0.04577720f, -0.01948877f, -0.11983050f, -0.01836678f, -0.01187189f, 0.08173142f, 
    0.05413790f, -0.00944082f, -0.02228152f, -0.00742710f, 0.05536654f, -0.01957969f, 0.01171551f, -0.01060538f, 
    -0.00310237f, -0.00517277f, 0.00433700f, -0.05608691f, -0.18942253f, -0.13372926f, -0.11843564f, 0.03175709f, 
    -0.11681071f, 0.03943039f, -0.00542126f, 0.03220958f, 0.02796156f, -0.02898883f, 0.04001661f, 0.01305172f, 
    0.05421117f, -0.03421748f, -0.02742620f, 0.03415031f, -0.00382225f, -0.10751502f, -0.03978421f, -0.01418356f, 
    0.26380080f, -0.35715747f, 0.17911562f, -0.12572141f, -0.08650934f, 0.02534173f, 0.11536090f, -0.08287106f, 
    -0.02327223f, 0.02656133f, 0.07004365f, -0.06960771f, 0.01659451f, 0.03354292f, -0.11008681f, -0.01864461f, 
    0.00041837f, -0.03462451f, 0.04619780f, 0.04275967f, -0.07286873f, -0.06614605f, 0.00437594f, -0.05248971f, 
    0.08864433f, 0.10615640f, -0.02756505f, 0.06582330f, -0.02289392f, 0.00407159f, -0.02041430f, -0.01318629f, 
    -0.05673708f, -0.02064221f, 0.01685746f, 0.06215234f, -0.02871044f, -0.03695275f, 0.03630465f, 0.08661390f, 
    -0.13763137f, -0.00824954f, -0.13170338f, -0.10271905f, -0.05823833f, -0.06128772f, -0.05259816f, 0.08861978f, 
    0.00102688f, 0.10858610f, 0.00712579f, 0.01514280f, 0.08480889f, 0.03569519f, 0.07749487f, -0.06722754f, 
    -0.00718052f, -0.05673742f, -0.16757077f, 0.10445792f, 0.23110162f, -0.06705490f, -0.02247648f, 0.07047117f, 
    -0.13221835f, 0.00548908f, 0.05271537f, 0.01017158f, 0.03685590f, 0.02867061f, 0.00888244f, -0.00328843f, 
    0.03218773f, 0.01921856f, 0.00076758f, 0.04202799f, 0.14450480f, 0.03787208f, -0.04478497f, 0.00571344f, 
    -0.05509882f, 0.14671344f, -0.00454757f, 0.09278557f, -0.02097839f, 0.00946034f, -0.12435359f, 0.06585730f, 
    -0.00300761f, 0.02405178f, 0.02268804f, 0.00484157f, -0.16652535f, 0.08469431f, -0.14391266f, 0.01185907f, 
    -0.09562244f, 0.01297773f, -0.01822338f, -0.04238520f, 0.13155407f, 0.07720532f, 0.09268129f, 0.07859320f, 
    0.15419807f, -0.04614766f, -0.02969102f, -0.00058362f, 0.00479938f, 0.00070146f, -0.00159262f, -0.01048737f, 
    0.03608997f, 0.00753729f, -0.05159545f, 0.05032924f, 0.02146813f, -0.01595701f, 0.03985564f, 0.03247323f, 
    0.14017764f, 0.15022492f, -0.15778583f, 0.04440405f, -0.09709714f, 0.06204203f, -0.00465756f, -0.00973679f, 
    -0.00355720f, 0.12059400f, 0.02003757f, -0.11205725f, 0.01151889f, 0.08608227f, -0.08314747f, 0.02415817f, 
    0.15213864f, -0.04900515f, -0.05285376f, -0.02489168f, 0.06787484f, -0.28225571f, 0.07797694f, -0.04131737f, 
    0.13384478f, -0.08022485f, -0.11951250f, 0.07754089f, -0.01712156f, 0.02807643f, -0.04708407f, -0.01763988f, 
    0.02550744f, 0.02783301f, 0.03349740f, -0.06467197f, -0.03845412f, -0.14972389f, -0.02332336f, -0.10424379f, 
    0.17020112f, -0.11511549f, -0.23140830f, -0.05317244f, -0.16963047f, 0.02738301f, -0.05816480f, 0.00531471f, 
    0.05971004f, 0.06943463f, -0.00104035f, 0.06279193f, -0.00030598f, -0.07682151f, 0.04872004f, 0.03408125f, 
    0.04039126f, -0.02911884f, -0.01641442f, 0.03864545f, -0.36027926f, -0.25713593f, -0.13019897f, -0.09554505f, 
    -0.10999430f, 0.16697206f, 0.03757147f, -0.04502261f, -0.07851334f, -0.06525492f, 0.10671560f, 0.05427349f, 
    -0.02654770f, 0.00029685f, 0.06743795f, -0.04778340f, -0.10070767f, -0.11046214f, 0.00165997f, -0.09366257f, 
    0.13564788f, 0.01719621f, -0.05350368f, 0.05200594f, -0.03676449f, -0.05217081f, -0.05894379f, 0.09526187f, 
    0.01864520f, 0.02398796f, -0.08332772f, -0.08267877f, -0.05447329f, 0.00043705f, 0.00227659f, 0.04592344f, 
    -0.01916993f, -0.05606756f, -0.09578379f, -0.05596476f, -0.18516912f, -0.05732024f, -0.44449028f, -0.41036290f, 
    0.17431100f, 0.09474704f, -0.05479484f, -0.01507837f, -0.07505455f, 0.09252784f, 0.09764054f, 0.04417654f, 
    0.03176674f, -0.09788832f, 0.09575142f, -0.03736373f, 0.04223292f, -0.05483865f, -0.03482253f, -0.08629046f, 
    0.05647052f, 0.11523908f, 0.16155189f, 0.04839286f, 0.10205935f, -0.05721925f, 0.00244275f, 0.07633448f, 
    -0.00353261f, 0.08932193f, 0.01212223f, -0.01306375f, 0.01727254f, 0.06688002f, 0.00825479f, 0.05240778f, 
    0.05825349f, 0.06132112f, 0.07666150f, 0.07008685f, -0.01556597f, -0.29613596f, 0.12198906f, -0.16294657f, 
    0.03179897f, -0.06798650f, -0.05242249f, -0.05844320f, 0.04449842f, -0.07029641f, -0.04406471f, -0.06810635f, 
    -0.08553236f, -0.00576958f, 0.02989186f, -0.09227873f, 0.06409702f, 0.00868568f, 0.08813313f, -0.13703175f, 
    -0.05298483f, -0.19169247f, 0.09714451f, -0.04356934f, 0.09327255f, -0.06095230f, 0.00570796f, -0.04142601f, 
    0.08927026f, 0.01030650f, 0.04568426f, 0.08348881f, -0.03188499f, -0.00353323f, -0.10357539f, -0.02878507f, 
    -0.06708218f, -0.04991893f, 0.16271645f, -0.04204281f, -0.15926369f, 0.06853037f, -0.06603458f, 0.02905717f, 
    -0.31062919f, -0.07719399f, -0.03349486f, 0.01219743f, 0.01909762f, 0.03755601f, 0.04376960f, 0.04657973f, 
    0.03761914f, 0.10040259f, -0.03721216f, -0.02406727f, -0.00275639f, -0.13009641f, -0.13331117f, -0.16641033f, 
    0.26541272f, -0.15159759f, -0.14349236f, 0.07798641f, -0.04047636f, 0.01644516f, 0.07678335f, 0.03540428f, 
    0.10586081f, 0.10236003f, 0.03046423f, 0.03204117f, -0.00196979f, 0.05351605f, 0.03418658f, 0.16178197f, 
    -0.00984596f, -0.03977229f, 0.00219940f, 0.00487185f, 0.11485991f, 0.16230223f, 0.18263090f, -0.03794235f, 
    0.25312781f, -0.12202501f, 0.02320728f, -0.03434214f, -0.04091937f, 0.05917213f, -0.03308502f, -0.03962454f, 
    0.06344642f, -0.03750518f, 0.08225186f, -0.05088104f, 0.02257425f, 0.04072970f, 0.12343507f, 0.13564292f, 
    -0.23586093f, 0.20953161f, -0.16639701f, 0.00811545f, -0.28922173f, 0.00514760f, -0.02396568f, 0.00021723f, 
    -0.19401717f, 0.08580296f, 0.04461214f, 0.20865212f, -0.12167197f, 0.05872149f, 0.04229687f, 0.00690855f, 
    -0.09943823f, 0.02134510f, -0.01085482f, 0.01217054f, -0.02529179f, -0.22103164f, 0.01775125f, -0.03782281f, 
    0.10130924f, -0.03657343f, 0.00927061f, 0.02625223f, -0.00327659f, 0.05209290f, 0.06414920f, 0.03881006f, 
    -0.04233118f, -0.05810733f, -0.04308491f, 0.05840050f, -0.10843614f, 0.12718257f, 0.00788367f, -0.02708067f, 
    0.31622249f, 0.12906021f, 0.04099038f, 0.01191398f, -0.04828255f, 0.01515217f, -0.04565514f, -0.06569302f, 
    0.00037134f, -0.05961711f, 0.01764533f, -0.04102895f, -0.08338310f, 0.08873674f, 0.00971308f, 0.00767213f, 
    -0.00550298f, 0.09469739f, -0.05250750f, 0.04784939f, -0.02543314f, -0.13653915f, -0.00216630f, -0.03176060f, 
    -0.07004036f, 0.07025158f, 0.00290075f, 0.05617122f, 0.03307471f, -0.02875154f, -0.06836998f, -0.04767656f, 
    -0.03730434f, 0.01944865f, -0.02790873f, 0.04512211f, -0.05127638f, -0.02817482f, -0.07595272f, 0.02729543f, 
    -0.12087383f, -0.18624616f, -0.31797948f, -0.18597415f, 0.15731509f, -0.03110824f, -0.03926477f, -0.04000537f, 
    -0.07172775f, 0.12820925f, 0.12513413f, -0.01847561f, 0.10481367f, -0.11755629f, 0.06150428f, -0.04263126f, 
    -0.06649239f, -0.01791018f, -0.05490054f, 0.00170062f, 0.10563374f, 0.19803816f, 0.05454814f, 0.05647147f, 
    0.17575157f, -0.08337104f, -0.02600846f, 0.06814966f, 0.03066874f, 0.02162440f, 0.04396163f, 0.00962012f, 
    0.06867130f, 0.01745636f, -0.09958767f, -0.02702484f, 0.09674328f, 0.05845905f, -0.06946014f, 0.02204952f, 
    0.12394987f, -0.12866457f, 0.02409109f, 0.03976304f, -0.02774464f, -0.00932059f, -0.01022126f, -0.04573340f, 
    0.07183253f, -0.05354151f, -0.03232517f, -0.00450050f, 0.03843158f, 0.02423127f, -0.05545012f, 0.04270247f, 
    -0.08084633f, 0.03645073f, 0.00072488f, -0.09504611f, 0.06322981f, 0.08696896f, 0.01711235f, -0.05379038f, 
    0.12275536f, -0.01252463f, -0.07787143f, 0.00895823f, -0.01158376f, -0.00182631f, 0.07348682f, -0.00187715f, 
    0.03919804f, 0.05058509f, 0.06081437f, -0.02137531f, 0.03357803f, -0.01915359f, -0.05632560f, 0.01511395f, 
    0.21517727f, -0.28006926f, 0.02997760f, -0.30095574f, -0.05427511f, 0.00568080f, -0.02212773f, -0.00486156f, 
    0.02517294f, 0.04779652f, -0.05073104f, 0.02169569f, -0.04210043f, 0.03676071f, 0.01292558f, -0.00580262f, 
    0.04583238f, -0.10718154f, -0.00545826f, 0.07189003f, 0.14329217f, -0.22787647f, -0.02403344f, -0.00397444f, 
    0.00436269f, 0.00501496f, 0.09537886f, 0.04262358f, 0.07320970f, 0.11512470f, -0.03228998f, -0.09037196f, 
    -0.01266959f, 0.02601116f, 0.01074954f, 0.11719137f, 0.02207970f, 0.01861455f, -0.07593049f, 0.08952298f, 
    -0.32044244f, 0.12535015f, -0.14623952f, -0.21488528f, 0.15557903f, -0.14349905f, 0.09647997f, -0.00392186f, 
    -0.07701444f, -0.01754515f, -0.05498230f, -0.10082206f, 0.06193373f, -0.03245265f, -0.02898324f, 0.00869101f, 
    -0.03221427f, 0.03311482f, -0.08474511f, 0.02486758f, -0.10010725f, 0.07431845f, -0.07160933f, -0.12390137f, 
    -0.10728747f, -0.06034798f, -0.13824508f, 0.04711817f, -0.04588237f, -0.06348923f, 0.12233205f, 0.09132790f, 
    -0.00313864f, -0.05854702f, -0.05336314f, -0.11660455f, -0.06240779f, -0.05132972f, -0.00504113f, -0.00740207f, 
    -0.32275781f, 0.09297919f, -0.19384645f, -0.17868294f, 0.00282383f, -0.01469400f, 0.04811237f, -0.03702246f, 
    0.04162899f, 0.01249755f, -0.00700689f, -0.02289807f, 0.02235230f, -0.10178440f, -0.12336773f, -0.05306622f, 
    0.02424783f, 0.07343931f, -0.14725137f, 0.03722071f, 0.29206762f, 0.09066474f, -0.01859729f, 0.04441143f, 
    -0.11186546f, 0.00841734f, 0.01098626f, 0.02511397f, 0.01525192f, 0.09501529f, -0.00138153f, -0.00598087f, 
    -0.04305596f, 0.08623707f, 0.05681297f, 0.04875383f, 0.06635506f, -0.04199298f, -0.02270167f, -0.03375543f, 
    0.26593387f, -0.16742769f, -0.09504040f, -0.18527873f, -0.01222790f, -0.02176612f, -0.07920093f, 0.09122913f, 
    -0.01637139f, -0.05213037f, -0.10303429f, -0.01079412f, -0.00709298f, -0.00373746f, -0.03855540f, -0.16077219f, 
    -0.09195092f, -0.04521812f, -0.01623014f, -0.00348692f, -0.39008948f, 0.22681142f, 0.01744874f, -0.04211990f, 
    -0.37010846f, -0.07432403f, 0.04068590f, -0.01349595f, -0.02532850f, -0.02900346f, 0.06214110f, -0.02225283f, 
    0.08151883f, -0.01238688f, 0.07473929f, -0.04272126f, 0.00118969f, -0.09889675f, -0.04855009f, 0.07710876f, 
    0.11855239f, -0.04553961f, -0.05067789f, -0.06780662f, -0.13382579f, 0.02737900f, 0.05061626f, -0.02791321f, 
    -0.03350595f, 0.00225166f, 0.03694665f, -0.00344046f, 0.00680314f, 0.01128076f, 0.02849786f, 0.01227923f, 
    -0.00705215f, -0.01677161f, -0.09117053f, 0.08769767f, -0.01301116f, 0.14540891f, -0.13430791f, 0.05305291f, 
    -0.07575450f, 0.02510997f, 0.07160831f, -0.02624503f, -0.08733825f, 0.03544332f, 0.07171369f, -0.00177144f, 
    -0.00576617f, -0.02019162f, 0.02676876f, 0.07286259f, 0.04770538f, -0.04759354f, 0.00377010f, 0.11057232f, 
    -0.48180950f, 0.02167112f, -0.01170211f, -0.09266292f, 0.06416514f, 0.00118523f, 0.03670046f, -0.10297137f, 
    0.08255843f, -0.03455719f, 0.00805913f, 0.03623410f, 0.01669036f, -0.08598652f, 0.12568073f, 0.05802120f, 
    -0.01322222f, 0.02766695f, 0.01813661f, -0.10329913f, -0.42732921f, -0.00594835f, -0.03868472f, -0.15937445f, 
    0.17067088f, -0.03166647f, -0.00931897f, 0.03159678f, -0.03282406f, -0.01760932f, 0.01160819f, 0.04721159f, 
    0.03853700f, -0.06091149f, 0.08826106f, 0.02149954f, -0.00742533f, -0.10277171f, 0.05310550f, -0.15520965f, 
    0.19055976f, -0.28971195f, -0.00243463f, 0.06247845f, 0.04529082f, -0.15797882f, 0.04973938f, 0.01298837f, 
    0.15124126f, -0.03810458f, 0.01551644f, -0.06691081f, -0.05454941f, 0.05074109f, -0.11736596f, 0.10020373f, 
    -0.05880529f, 0.07285418f, 0.01455808f, 0.07005470f, -0.13090630f, -0.11574156f, 0.04918651f, -0.01061827f, 
    0.05948440f, -0.00098387f, -0.07545102f, 0.05729604f, 0.02913968f, -0.03344652f, 0.02702852f, 0.00917710f, 
    0.05217643f, -0.04132304f, 0.00627297f, -0.05339142f, 0.02223217f, -0.10190266f, 0.03558223f, -0.00669917f, 
    0.00773775f, -0.06056872f, 0.08002002f, 0.00504734f, 0.05977802f, -0.08730121f, -0.00568508f, 0.04347692f, 
    -0.02019518f, 0.05262786f, 0.01340504f, -0.07908966f, 0.07608072f, -0.02987998f, -0.06715921f, -0.02226212f, 
    0.00745751f, -0.15242112f, 0.02753760f, -0.02588792f, 0.10197709f, 0.23059563f, -0.02043490f, 0.11086962f, 
    0.22690344f, 0.02306326f, -0.03898969f, -0.01713238f, 0.03355468f, 0.01311603f, 0.06617878f, -0.04422739f, 
    -0.05199430f, 0.05226814f, -0.12923981f, 0.00857076f, 0.06675067f, 0.08787476f, -0.01957681f, 0.05540061f, 
    0.09485810f, 0.04233667f, 0.08129810f, -0.08997364f, -0.00002358f, -0.03042275f, -0.02140213f, 0.09178438f, 
    -0.03798273f, -0.00708765f, -0.03992421f, 0.04531140f, 0.06095262f, -0.01195885f, -0.02140647f, 0.04644168f, 
    -0.08479106f, 0.00607141f, -0.04484495f, -0.03407195f, 0.09247099f, 0.02846221f, 0.09436690f, 0.09728105f, 
    0.17628168f, -0.12570675f, -0.07506903f, -0.15075333f, 0.03197690f, 0.03939953f, 0.03606744f, -0.01578502f, 
    -0.09666407f, 0.01173884f, 0.08325493f, -0.06249744f, 0.04486704f, -0.03486289f, 0.03921461f, 0.02470493f, 
    -0.13145788f, 0.13343655f, 0.07532959f, -0.24401015f, 0.11047946f, 0.08827927f, 0.07652443f, 0.07736682f, 
    0.03340175f, -0.06626154f, -0.09633576f, 0.01082441f, -0.00846070f, -0.00503117f, -0.02083825f, -0.01714587f, 
    -0.02271948f, 0.01980192f, -0.01311086f, -0.08283463f, 0.13564351f, -0.01290466f, 0.15700252f, 0.04564362f, 
    0.07789430f, -0.14280617f, -0.04136592f, -0.04534783f, 0.01717167f, 0.04152316f, -0.02197328f, -0.09384922f, 
    -0.00873032f, -0.01446819f, -0.04959671f, 0.05665069f, -0.04198661f, -0.05303625f, 0.05839603f, -0.07375798f, 
    0.18429889f, 0.02986246f, -0.10771091f, -0.04582906f, 0.00379126f, 0.00488371f, 0.02813525f, -0.02283987f, 
    0.01473896f, 0.09188677f, -0.00964698f, 0.01723925f, 0.04518773f, 0.04651629f, 0.03789077f, -0.03578332f, 
    -0.00987746f, -0.05366386f, -0.01777054f, -0.02639789f, 0.01442583f, -0.02143565f, 0.09726768f, -0.14193490f, 
    -0.05256971f, -0.03767582f, -0.10497651f, 0.02336364f, 0.02176710f, -0.00467576f, -0.10081148f, 0.04087522f, 
    0.06486423f, -0.03867102f, -0.01815611f, 0.02704439f, -0.06094294f, 0.02035453f, 0.03297862f, -0.00880680f, 
    0.14649020f, 0.04747240f, 0.12275738f, 0.03139947f, 0.09371730f, -0.11104697f, -0.04104877f, -0.05994100f, 
    -0.02340758f, 0.01589287f, 0.01141888f, -0.04118964f, 0.00561475f, -0.04346026f, -0.02658776f, -0.02064216f, 
    -0.06005127f, -0.06282846f, 0.00521688f, 0.00114500f, -0.59132594f, -0.32439807f, -0.04239168f, -0.25554460f, 
    -0.15563382f, 0.10067088f, 0.07998069f, 0.02316936f, 0.01403657f, 0.03862352f, -0.00837865f, 0.03464584f, 
    0.05605977f, -0.04789427f, -0.03427091f, 0.05348519f, -0.00798080f, 0.05091011f, 0.06468023f, -0.05656265f, 
    -0.02880417f, 0.11329792f, -0.13336109f, 0.02437346f, 0.05352365f, 0.03156191f, 0.13482353f, 0.04838894f, 
    -0.03921375f, -0.08349991f, -0.00428747f, 0.04082661f, 0.01809320f, 0.01604692f, -0.01817405f, -0.01412993f, 
    0.01085892f, 0.00122851f, -0.08276028f, -0.00023036f, 0.33139595f, -0.08852002f, 0.08108062f, -0.03352500f, 
    0.13759753f, 0.04896903f, -0.07946310f, -0.10131536f, 0.02267298f, 0.05703139f, 0.06494167f, 0.02859184f, 
    0.02033000f, 0.03263535f, 0.03558348f, 0.07393187f, -0.05662203f, -0.02449390f, 0.04702940f, -0.03808768f, 
    0.12127984f, 0.01582743f, -0.09328137f, 0.03169779f, 0.00004337f, -0.03539493f, -0.01136589f, 0.04759897f, 
    0.08913955f, 0.01526025f, 0.03285115f, -0.00103748f, 0.01680651f, -0.02284801f, 0.01572278f, -0.00468356f, 
    -0.07503681f, -0.11198057f, 0.02298831f, -0.05436246f, -0.17779590f, -0.20370358f, -0.11872019f, -0.10466442f, 
    -0.25350198f, 0.05244391f, -0.03371181f, -0.01823301f, 0.03370740f, -0.05639574f, 0.00337081f, 0.06192400f, 
    -0.05395434f, -0.03023771f, 0.02278293f, -0.06494059f, -0.02287189f, 0.08411585f, -0.02301726f, 0.00074725f, 
    -0.06292321f, -0.06257488f, -0.00515729f, -0.03309724f, -0.00236535f, 0.00278697f, 0.02733982f, 0.02178653f, 
    0.02909378f, 0.02034728f, 0.03635315f, 0.01314429f, 0.01992889f, -0.00109627f, 0.01764339f, -0.02273761f, 
    -0.03652121f, 0.01617090f, -0.09629165f, -0.02515128f, -0.14141041f, 0.08152189f, 0.05898022f, -0.09192474f, 
    0.07685126f, 0.05430053f, 0.00321157f, 0.09668298f, 0.07845050f, 0.05373525f, -0.05367533f, 0.00051094f, 
    -0.00997459f, -0.00988680f, 0.04210337f, -0.09144125f, 0.00599027f, -0.04438695f, 0.01705034f, 0.04629244f, 
    0.20356303f, 0.07299848f, 0.05868998f, 0.00123389f, 0.13260072f, 0.03244259f, -0.02615256f, -0.03624206f, 
    0.02201478f, 0.09074175f, -0.00605048f, -0.02811006f, 0.01335181f, 0.03385928f, 0.01487906f, 0.00743586f, 
    -0.06638681f, -0.03799759f, -0.01314002f, -0.01129858f, 0.41183311f, -0.21680999f, -0.17587650f, 0.19860175f, 
    -0.10836384f, -0.16629966f, 0.04671629f, -0.06732741f, -0.01809170f, -0.03039688f, 0.00894269f, 0.03362569f, 
    0.04516267f, 0.00798406f, -0.02253898f, 0.00628166f, -0.04556189f, -0.00622536f, 0.00891686f, 0.06181419f, 
    0.24705772f, -0.01750767f, -0.03503729f, -0.11301187f, -0.32345268f, -0.02271887f, 0.03348564f, 0.01471472f, 
    -0.01011993f, 0.02754223f, -0.03101024f, -0.03170741f, -0.02053539f, -0.06506860f, -0.06006012f, -0.02381067f, 
    0.01404034f, 0.08311017f, 0.03699355f, -0.00147380f, 0.01951093f, -0.27849153f, 0.03100723f, -0.06013011f, 
    -0.29423529f, -0.03426432f, -0.00358268f, -0.06179371f, 0.02159801f, 0.03235923f, 0.04159316f, 0.03090690f, 
    -0.00969211f, -0.06413421f, -0.03142843f, 0.03549571f, -0.04028577f, 0.08807080f, 0.04144214f, -0.00533076f, 
    0.09170675f, -0.32444373f, 0.09519309f, -0.14459944f, -0.13393259f, 0.07225081f, -0.15361749f, 0.10792244f, 
    -0.04963796f, 0.04507060f, -0.04939160f, 0.03968557f, 0.10708246f, -0.12581588f, -0.04818797f, 0.07735999f, 
    -0.04851649f, 0.01810261f, -0.00032325f, -0.04663073f, -0.23333643f, -0.00126712f, 0.01077571f, -0.08840682f, 
    -0.02113717f, 0.02021634f, 0.11664448f, 0.00334434f, 0.01168558f, -0.07615490f, 0.04348679f, 0.02662515f, 
    0.08145354f, -0.05502591f, -0.07073943f, 0.00234095f, -0.01795506f, -0.07672415f, 0.01451750f, -0.08240737f, 
    0.05595383f, -0.10393856f, -0.06359909f, -0.07957184f, -0.15115514f, -0.03346032f, 0.07172368f, -0.07743549f, 
    0.01667574f, -0.03240089f, 0.00910395f, -0.03635046f, -0.01875815f, -0.08733800f, -0.02459702f, 0.00528991f, 
    0.02259979f, 0.03466566f, 0.01138474f, -0.03303028f, 0.12631355f, 0.15147702f, -0.00064137f, -0.00278016f, 
    -0.03709114f, -0.01210542f, 0.06952328f, -0.02498140f, -0.01028885f, -0.04246868f, -0.01835155f, -0.02924459f, 
    0.00330499f, 0.01875470f, -0.06898436f, 0.05281910f, 0.04489876f, -0.04218652f, 0.04034884f, -0.07737053f, 
    -0.36669677f, 0.05149399f, 0.07388882f, -0.01923476f, 0.01909980f, 0.01957893f, -0.03966169f, 0.00985260f, 
    0.05023175f, 0.05206520f, 0.04790534f, 0.00417733f, 0.05262460f, -0.02704106f, 0.02022250f, 0.02259460f, 
    0.02220856f, -0.10054693f, -0.00768094f, 0.04464910f, 0.04771044f, 0.17999461f, 0.04029676f, -0.04033032f, 
    -0.02028747f, 0.07015741f, 0.06124585f, -0.00514151f, -0.03005511f, -0.00495336f, -0.04556621f, -0.00178167f, 
    0.01438269f, 0.08546448f, -0.01755070f, 0.03453332f, -0.00421829f, 0.02341970f, -0.01121670f, -0.02238557f, 
    0.15174162f, 0.21627301f, -0.11442966f, -0.17461148f, -0.16480416f, 0.11541450f, 0.09063500f, -0.05740596f, 
    -0.04555704f, 0.00994911f, -0.06010745f, -0.03834040f, 0.02744027f, -0.15893206f, -0.06747878f, -0.00646625f, 
    0.06507286f, 0.01913436f, -0.00620078f, -0.08657669f, -0.20513044f, 0.02250890f, 0.04726335f, -0.01058384f, 
    -0.00662726f, -0.01629395f, 0.04827037f, -0.07178918f, 0.03906318f, 0.00201895f, 0.03106023f, -0.02352915f, 
    0.08301240f, -0.03511183f, 0.08579327f, 0.10150322f, -0.01127492f, -0.05080179f, -0.00289117f, 0.02750899f, 
    -0.31123856f, 0.16209388f, -0.05207523f, -0.06910943f, 0.07786855f, -0.03793864f, -0.03740852f, -0.03430684f, 
    0.03590187f, -0.06092047f, -0.00312623f, 0.04496120f, 0.02557713f, -0.00021459f, -0.02040710f, -0.10451344f, 
    -0.00845473f, -0.03542235f, 0.00279556f, -0.02939396f, -0.10636763f, 0.00809340f, 0.06784993f, -0.09601603f, 
    0.01939349f, 0.09377306f, 0.03284086f, 0.04308543f, -0.01184199f, 0.02154778f, -0.04675501f, -0.00380074f, 
    0.05785230f, 0.00742367f, -0.01171153f, -0.01016155f, -0.02642671f, -0.02588722f, -0.03299377f, -0.03731162f, 
    0.08624898f, -0.21171066f, 0.17503187f, -0.07385696f, 0.08949290f, -0.08318286f, -0.03113444f, -0.13171840f, 
    0.01265372f, -0.03594415f, -0.01010490f, -0.02113793f, 0.00881975f, -0.06005855f, 0.04643422f, 0.01698464f, 
    -0.01422140f, 0.02029389f, 0.06404406f, 0.05289307f, 0.12198805f, -0.14878313f, -0.02424154f, -0.17821349f, 
    0.03726314f, 0.05571049f, -0.08066625f, 0.16752972f, -0.08991127f, -0.03905236f, -0.05100117f, 0.06670307f, 
    0.01376874f, -0.08460689f, 0.00035786f, 0.09290251f, -0.04007027f, 0.12379026f, -0.04609232f, -0.01315553f, 
    0.20648308f, -0.22674805f, 0.10408643f, -0.05113742f, 0.10951935f, -0.04314603f, -0.05330191f, -0.05792250f, 
    -0.00650344f, 0.05168197f, 0.06830435f, 0.00967076f, -0.04672410f, 0.01539158f, 0.03011296f, 0.03052941f, 
    -0.02433460f, 0.02207445f, 0.00725539f, 0.00437948f, 0.20000443f, 0.03070488f, -0.09707460f, 0.07370729f, 
    -0.19491373f, -0.06948095f, 0.06869736f, -0.00881569f, 0.04913900f, -0.01631266f, -0.01461898f, -0.08194716f, 
    -0.03911530f, -0.02028169f, -0.09015311f, -0.03294748f, 0.05757744f, 0.02899809f, 0.08838096f, -0.08973639f, 
    -0.12622225f, 0.01209590f, -0.12676077f, -0.04803569f, 0.06939719f, 0.03532545f, 0.11251352f, 0.07472293f, 
    0.00346180f, -0.04309016f, -0.06568833f, -0.00754418f, -0.00986531f, -0.02929373f, -0.03941659f, -0.07317585f, 
    0.05003704f, 0.09167401f, -0.06445680f, -0.03776105f, -0.19567952f, -0.28573942f, -0.12071353f, -0.12368514f, 
    -0.23746465f, -0.01443713f, -0.07269771f, 0.05978050f, -0.08496422f, -0.03090397f, -0.09238876f, -0.04338586f, 
    -0.02112921f, 0.00676773f, -0.08587405f, 0.01325517f, -0.01083679f, 0.11031055f, -0.00056188f, -0.00635724f, 
    -0.16979448f, 0.08258219f, 0.03267859f, -0.07107983f, 0.03905170f, 0.08178364f, 0.02857642f, -0.03723503f, 
    0.03320640f, -0.01889830f, -0.05026384f, -0.00993962f, -0.00414772f, 0.02395703f, 0.05938929f, -0.07967128f, 
    0.05298363f, -0.06761254f, -0.12636471f, -0.01497019f, 0.09158564f, -0.29462898f, -0.05840529f, -0.00249553f, 
    -0.13559897f, 0.09651981f, -0.09549608f, 0.02815424f, -0.04432040f, 0.06868398f, -0.03875234f, -0.05993225f, 
    0.04583356f, 0.00796437f, -0.01782464f, -0.02157864f, -0.07362387f, 0.06509385f, -0.04342432f, -0.04436643f, 
    0.03968443f, 0.05738150f, -0.09659731f, 0.13271405f, -0.13142255f, 0.09015667f, -0.10215706f, -0.02553288f, 
    0.10642564f, 0.08541674f, -0.03028422f, -0.04087287f, 0.00371020f, 0.01166964f, -0.03456293f, -0.07643773f, 
    0.01906013f, 0.05071641f, -0.04249698f, -0.01972548f, -0.06280749f, -0.16088383f, -0.17197284f, -0.03792912f, 
    -0.14641844f, -0.13995183f, 0.07964046f, -0.05942795f, -0.01905877f, -0.08798509f, 0.04803099f, -0.01143387f, 
    0.06799515f, -0.02362202f, 0.03482000f, -0.01951505f, -0.05642768f, -0.02911287f, 0.02758777f, 0.02450523f, 
    0.25657815f, -0.28535992f, 0.09402265f, 0.00392555f, -0.01618277f, -0.11095778f, 0.05909071f, 0.02285403f, 
    0.01015469f, 0.00991296f, 0.01380108f, -0.05946155f, 0.00626502f, 0.02597948f, 0.01329154f, 0.03172272f, 
    -0.02118857f, 0.05332585f, -0.01365782f, -0.02541365f, 0.09643666f, -0.25051904f, 0.01136855f, 0.00942323f, 
    -0.00992861f, 0.04965599f, 0.00855300f, 0.04649033f, -0.01512655f, 0.04370577f, 0.00619593f, -0.00089342f, 
    0.01353072f, -0.02979895f, 0.01950312f, -0.02352003f, -0.09201252f, -0.04593958f, -0.07474898f, -0.05755227f, 
    0.28321007f, -0.01018286f, -0.05168240f, 0.02466068f, 0.18008615f, -0.12854543f, -0.09155013f, 0.03838735f, 
    -0.00057104f, 0.05571012f, 0.06103518f, -0.00142896f, 0.01839623f, -0.02193547f, 0.05143209f, -0.00250839f, 
    0.05621468f, 0.00828578f, -0.01181784f, -0.02066833f, 0.31727779f, 0.03772288f, -0.18104213f, -0.09525833f, 
    -0.15595540f, -0.03177905f, 0.03019038f, 0.00676594f, 0.05687148f, 0.02123816f, -0.06916739f, -0.04187345f, 
    -0.06601465f, -0.05786062f, -0.05730306f, 0.00637252f, 0.05411687f, -0.04479428f, 0.13211046f, 0.07555325f, 
    0.11032961f, 0.14950447f, -0.02095165f, -0.09683144f, 0.03496747f, 0.02919005f, 0.04188062f, 0.06030525f, 
    0.02140879f, -0.04442988f, -0.04583798f, -0.00226583f, 0.02288253f, -0.00382398f, 0.04463958f, 0.01758089f, 
    -0.02178703f, -0.05089138f, -0.01279719f, 0.01662117f, -0.15008172f, 0.10825725f, -0.01662181f, -0.13377322f, 
    -0.00152698f, 0.00984438f, 0.05517912f, 0.03418390f, 0.01425013f, -0.01944756f, 0.05669913f, 0.04902107f, 
    -0.01976485f, -0.08213967f, -0.05010317f, -0.00442744f, 0.02027846f, -0.01053984f, -0.00166196f, -0.02395884f, 
    0.12462664f, -0.17728311f, -0.25612450f, -0.13564853f, -0.11750869f, 0.02093100f, 0.03473958f, 0.07262833f, 
    -0.13878800f, 0.02235809f, -0.07069034f, -0.04265748f, -0.04144361f, -0.00364715f, -0.03260859f, 0.03616266f, 
    -0.03012417f, 0.03700449f, -0.03217909f, 0.01284833f, 0.01449675f, 0.02545415f, -0.05320395f, -0.11759136f, 
    0.06047321f, 0.04200955f, 0.08972799f, 0.04584695f, -0.04403419f, -0.05021868f, -0.04171895f, -0.00019001f, 
    0.02750411f, -0.01456315f, -0.00408613f, 0.03376961f, -0.02689121f, -0.02053582f, -0.09090505f, -0.03069774f, 
    0.09888559f, -0.00183450f, 0.05389706f, -0.00117565f, -0.01750824f, -0.03341406f, 0.05595953f, 0.05285408f, 
    0.01910334f, -0.04763864f, -0.03994849f, 0.01665916f, 0.01872238f, 0.02454860f, -0.01839452f, 0.02168887f, 
    -0.07407851f, -0.03335796f, 0.09481994f, -0.04332530f, 0.11288950f, 0.09451696f, -0.02696837f, -0.02520095f, 
    0.01093309f, 0.01626125f, 0.05473195f, 0.04380722f, -0.08983204f, -0.05918862f, -0.02259077f, -0.06860913f, 
    0.00715001f, -0.05476395f, -0.01466559f, -0.02058356f, -0.05297742f, -0.02011576f, -0.04779594f, -0.00444120f, 
    -0.13411842f, -0.27043524f, -0.06664017f, -0.08694131f, -0.14653230f, -0.00737782f, -0.03194188f, 0.03796072f, 
    0.03154551f, 0.08490083f, -0.00620301f, -0.02060116f, -0.02494208f, -0.02239387f, -0.01439082f, 0.07730307f, 
    -0.01391698f, 0.02529574f, 0.03102267f, -0.06219373f, 0.27188110f, 0.01204931f, 0.06340595f, -0.00888200f, 
    -0.03289461f, -0.06686888f, 0.02290846f, -0.01213206f, -0.01777529f, -0.02987260f, 0.05243697f, -0.04597071f, 
    0.00376151f, -0.03867526f, -0.02414284f, -0.03134929f, 0.01986184f, 0.03173288f, -0.03743038f, -0.00503379f, 
    0.23869643f, 0.00154239f, -0.21301498f, 0.01437786f, -0.18837579f, -0.00629312f, 0.02316312f, -0.01159328f, 
    -0.04853704f, -0.02467166f, -0.02221088f, -0.04315459f, 0.09471553f, -0.03834112f, 0.03904292f, 0.09011775f, 
    -0.06639078f, -0.11550464f, 0.09366171f, -0.03784602f, -0.04860010f, 0.05045149f, -0.00375126f, 0.04927263f, 
    0.09413937f, -0.00591060f, -0.05623679f, -0.15046909f, 0.03351910f, -0.00289704f, -0.04872380f, -0.00609294f, 
    -0.06534971f, 0.07478537f, 0.04093196f, -0.01992730f, 0.06143656f, -0.02717273f, 0.05569112f, -0.00787465f, 
    0.24652296f, -0.00089102f, -0.30360171f, -0.04966551f, -0.11985792f, -0.04429489f, 0.00081791f, -0.00697713f, 
    -0.03049217f, -0.03441855f, -0.06504019f, -0.05002371f, 0.01753464f, -0.05719491f, 0.00458129f, 0.05376289f, 
    -0.00350523f, -0.11196322f, 0.04837213f, -0.03190941f, 0.27646169f, -0.21913852f, -0.08801915f, 0.14675081f, 
    0.06527962f, -0.23393568f, 0.06066412f, -0.11457617f, -0.05957413f, 0.07309475f, 0.08951686f, -0.00750471f, 
    0.04245301f, -0.00434684f, 0.03689712f, -0.00167978f, -0.02774698f, -0.03970481f, 0.06868257f, 0.02999927f, 
    -0.19075902f, -0.06965964f, -0.08457996f, -0.14253503f, -0.05202928f, 0.03343362f, 0.01651554f, -0.05076405f, 
    0.03696799f, 0.00878426f, -0.03954903f, -0.01040457f, 0.01430195f, -0.08469525f, -0.02736458f, 0.04295639f, 
    0.05735330f, 0.04007822f, -0.02813455f, -0.03048362f, -0.01391031f, -0.16268024f, -0.21191709f, -0.01663026f, 
    -0.13119331f, -0.02212989f, 0.04336503f, 0.01335603f, 0.00455998f, -0.10698105f, 0.02968778f, -0.07623815f, 
    -0.02444447f, -0.03281653f, -0.07972103f, 0.05797170f, -0.00375384f, 0.06737429f, -0.02321824f, -0.06814277f, 
    0.22736026f, 0.07736762f, 0.05950073f, 0.09371039f, 0.13134865f, -0.11880837f, -0.06019741f, -0.04876106f, 
    0.05627972f, 0.00588174f, 0.06779884f, -0.02849292f, 0.00212870f, 0.05517673f, -0.02791512f, -0.05211330f, 
    0.02944046f, -0.01723351f, -0.04361771f, 0.03486270f, 0.13613425f, 0.07427530f, 0.11586795f, 0.05493445f, 
    0.17997372f, -0.08371178f, -0.06235372f, -0.08790442f, 0.00290323f, 0.00988934f, 0.02920460f, -0.04788792f, 
    -0.02308697f, -0.03806449f, -0.01369174f, 0.03887259f, -0.04934917f, -0.00387837f, -0.02553983f, -0.02468685f, 
    0.05654308f, 0.07063872f, -0.00047422f, -0.05876762f, 0.03388158f, 0.11086433f, 0.01480324f, -0.00194626f, 
    0.00585212f, 0.08122416f, -0.01005105f, 0.03097866f, 0.07546296f, 0.04563595f, -0.02046136f, -0.04865271f, 
    -0.05045695f, 0.04030165f, -0.07616653f, -0.01918925f, 0.00185267f, 0.10845748f, 0.00088224f, -0.13897489f, 
    -0.10480134f, 0.06775352f, -0.02520162f, -0.00951027f, 0.04894193f, -0.00966686f, -0.05347840f, 0.02410227f, 
    -0.01944254f, -0.01984604f, -0.03130256f, -0.06703744f, -0.03174747f, 0.03856669f, 0.10038032f, 0.03195056f, 
    0.22277647f, 0.01261559f, 0.09511024f, -0.02460724f, 0.01771041f, -0.02555699f, -0.06957448f, 0.05124972f, 
    0.00360222f, -0.01728852f, -0.04757662f, -0.02531433f, 0.05315181f, -0.02628059f, -0.04062625f, 0.07727257f, 
    -0.07367311f, -0.02984135f, 0.04326263f, 0.01499200f, -0.12288933f, -0.09359452f, 0.06335500f, -0.15001912f, 
    -0.16165335f, 0.09068134f, 0.03007969f, -0.00913546f, 0.03954699f, 0.01517405f, -0.04961068f, 0.00940133f, 
    -0.01731872f, -0.07579756f, -0.00222191f, -0.00773048f, -0.03155338f, 0.09476341f, -0.03031112f, 0.00158520f, 
    -0.30078381f, -0.14932261f, 0.08780479f, -0.06470317f, -0.06057912f, 0.00199089f, -0.02532566f, -0.09206285f, 
    -0.02835573f, 0.05236729f, -0.08806001f, -0.00000579f, -0.09169509f, -0.01144632f, 0.01316023f, -0.00699526f, 
    0.00205096f, -0.00843916f, -0.00840761f, -0.02377266f, 0.02879615f, 0.16460754f, -0.13231198f, -0.17303662f, 
    0.05772241f, 0.06192207f, 0.05529854f, 0.03235491f, -0.05160437f, -0.08562686f, -0.06602950f, -0.04483347f, 
    0.01183211f, -0.00928929f, 0.02819653f, 0.04202021f, 0.03415303f, -0.08295508f, -0.04802260f, -0.08147592f, 
    -0.07093290f, -0.24675174f, -0.26999077f, -0.00288474f, -0.07386582f, -0.09215239f, -0.12697168f, 0.02943421f, 
    0.04621950f, -0.09104566f, -0.07051682f, 0.00152116f, -0.02582459f, -0.00588087f, 0.02374331f, -0.03766958f, 
    -0.01433168f, -0.00572654f, -0.00930775f, -0.08333366f, 0.02165921f, -0.00971350f, -0.15410876f, -0.04700312f, 
    -0.05299177f, -0.02745235f, -0.04718968f, 0.02401573f, 0.01395407f, 0.05422361f, -0.07788146f, -0.05649107f, 
    0.05406726f, -0.07262450f, 0.04426226f, 0.01814728f, -0.06123042f, 0.08188309f, 0.02188670f, 0.02138355f, 
    -0.56893653f, -0.08404776f, -0.29159036f, 0.05147946f, 0.02621363f, -0.11851385f, 0.02889428f, -0.01723208f, 
    0.03631246f, -0.00785636f, -0.05360722f, -0.01627729f, 0.06171722f, 0.03218922f, -0.06863133f, 0.04540815f, 
    0.00187134f, 0.06676636f, -0.03131259f, 0.03359870f, 0.01816921f, 0.04942733f, 0.08537965f, -0.15187442f, 
    -0.04821206f, -0.06013731f, -0.05639563f, -0.03891344f, -0.07504116f, 0.00136624f, -0.04434074f, -0.04160437f, 
    0.00170834f, 0.02833399f, 0.00831035f, -0.01198038f, 0.02480411f, -0.03476264f, 0.09814228f, -0.07128734f, 
    -0.10055768f, 0.00713207f, 0.01806374f, -0.04558031f, -0.11074235f, -0.00354476f, -0.02372468f, -0.02164505f, 
    0.03047644f, -0.07732743f, 0.04733667f, -0.00984560f, -0.00766446f, 0.01249120f, -0.06502199f, 0.01255945f, 
    -0.00664562f, -0.07881519f, 0.01124867f, -0.01096575f, 0.02883662f, -0.13043611f, -0.18782327f, 0.00824749f, 
    -0.12236196f, -0.09240667f, -0.05965391f, -0.02417103f, 0.06682307f, -0.02491032f, -0.10687349f, -0.00862813f, 
    0.02949211f, 0.03888892f, 0.05047117f, -0.02201511f, -0.02217569f, -0.03424366f, 0.01032946f, -0.05644510f, 
    -0.04525461f, -0.01363646f, -0.07284926f, -0.11673408f, -0.11259857f, 0.02805161f, -0.09516437f, 0.03849382f, 
    -0.03221447f, 0.01991048f, -0.04038779f, 0.00215196f, 0.02742424f, -0.00458623f, 0.04061562f, 0.01256070f, 
    -0.05268989f, -0.00950834f, 0.02946136f, 0.05324628f, 0.09521947f, 0.19680645f, 0.04849380f, 0.13345537f, 
    -0.01716321f, -0.00025293f, 0.11805054f, -0.06316908f, 0.05864401f, 0.03166774f, 0.05959636f, 0.00927776f, 
    -0.11577719f, -0.07503572f, -0.03406440f, 0.02790044f, 0.02837008f, 0.05881151f, 0.08328445f, 0.03450036f, 
    -0.15306258f, -0.45132113f, -0.17564987f, 0.12010740f, 0.16233526f, 0.02781659f, -0.00265225f, 0.08933783f, 
    0.03324498f, -0.06233209f, -0.01794397f, 0.03356071f, -0.02991156f, -0.01176304f, 0.00299709f, 0.08015132f, 
    0.02833995f, -0.02235596f, 0.08691736f, -0.05895498f, -0.16676147f, 0.10713083f, -0.05006424f, 0.08758039f, 
    -0.05962611f, 0.03934103f, -0.08488554f, -0.00056837f, 0.07232526f, 0.01929365f, -0.01663084f, -0.05758533f, 
    -0.06773598f, -0.00328824f, -0.00308776f, -0.05504327f, -0.00564440f, -0.04069167f, 0.06552813f, 0.04299016f, 
    0.05564284f, -0.02885609f, 0.13179184f, -0.10342219f, -0.05664628f, 0.02091721f, -0.11611801f, 0.02182798f, 
    -0.02611793f, -0.08791927f, -0.00320754f, -0.07207618f, -0.05630353f, -0.01005271f, 0.03243218f, 0.01696001f, 
    0.00981509f, -0.02058667f, 0.05964827f, 0.02878892f, 0.03620955f, 0.15005383f, 0.03506660f, 0.07481612f, 
    -0.01440740f, -0.09709208f, 0.00799750f, 0.00290912f, -0.04689471f, -0.06003676f, -0.07538474f, -0.03162698f, 
    0.04071433f, 0.01564879f, 0.03893825f, 0.00743282f, 0.00342048f, 0.12817623f, 0.01821594f, 0.04082464f, 
    -0.12044472f, -0.20781437f, -0.15943848f, 0.02884850f, -0.08727863f, -0.06612355f, -0.09590977f, -0.00783708f, 
    0.00904267f, -0.05044542f, -0.02534128f, -0.04024518f, 0.04587036f, 0.01135822f, -0.02125298f, 0.06804734f, 
    0.00278367f, 0.04438860f, -0.03978389f, 0.02668100f, -0.09845373f, -0.17898475f, -0.15643513f, -0.11918452f, 
    -0.23720168f, -0.03292996f, -0.02102248f, -0.05078992f, 0.04444680f, -0.02076539f, -0.10329428f, 0.02250413f, 
    0.05228800f, 0.01059301f, 0.05531181f, 0.03410876f, -0.06138730f, -0.01751486f, 0.02229133f, 0.10495741f, 
    -0.06672662f, 0.12880708f, -0.03072452f, -0.04084326f, -0.11908774f, -0.02841575f, -0.04576028f, 0.00805107f, 
    0.05746023f, 0.00683701f, -0.01395410f, -0.08249493f, -0.01707670f, -0.00085102f, -0.02855642f, -0.04959803f, 
    -0.00592148f, -0.06985858f, 0.05242614f, 0.07346532f, 0.10414234f, 0.02062513f, 0.05329905f, 0.04335462f, 
    -0.04329722f, -0.11954286f, -0.16303274f, 0.04073034f, -0.05986577f, -0.04343394f, -0.09862071f, -0.01636824f, 
    -0.07266683f, -0.05030503f, 0.06950738f, 0.00409156f, 0.01542127f, 0.12325877f, 0.05114052f, -0.00766856f, 
    0.04845703f, 0.05974891f, 0.09408440f, 0.00507982f, -0.03351846f, -0.08580191f, -0.02081474f, 0.02166795f, 
    -0.00944876f, 0.08968396f, 0.01861456f, 0.03118634f, 0.03787373f, -0.01129614f, -0.03002854f, 0.07572696f, 
    -0.02599984f, 0.01054451f, -0.00644629f, -0.00538147f, 0.07234634f, 0.15633191f, -0.01924653f, 0.08227466f, 
    -0.01505045f, -0.06303596f, 0.00262926f, -0.02935704f, -0.04164165f, 0.01703628f, -0.04570756f, -0.05080451f, 
    -0.02602456f, -0.09217364f, 0.01337140f, -0.01864685f, 0.02593985f, 0.10019360f, -0.00572508f, -0.00895429f, 
    0.16178875f, 0.20916365f, -0.26835915f, 0.20857540f, 0.05106495f, -0.02724078f, 0.00103472f, 0.03685440f, 
    0.07447718f, 0.01666812f, -0.04890794f, -0.01602187f, -0.09259543f, -0.07634965f, 0.06201889f, -0.03353043f, 
    0.05667195f, 0.03329211f, -0.07546841f, 0.00716756f, -0.00124404f, 0.08735808f, 0.03869440f, 0.20354174f, 
    0.05006946f, 0.03935153f, 0.06905519f, 0.09071607f, -0.03131817f, 0.07150324f, 0.02466145f, 0.00149368f, 
    -0.05639229f, -0.04186251f, -0.02677253f, -0.01216585f, -0.04618215f, 0.04398265f, 0.07434094f, -0.08213983f, 
    0.07858019f, 0.11568678f, 0.08695055f, 0.09779136f, 0.02652588f, -0.03751178f, 0.03347088f, -0.02151578f, 
    -0.03894966f, -0.02505689f, -0.01408002f, 0.00838837f, -0.01987139f, 0.00182043f, -0.02728450f, 0.03619545f, 
    0.01620179f, -0.01842960f, 0.02187182f, 0.04529763f, -0.25107944f, 0.18638447f, -0.04729496f, 0.16163735f, 
    0.10215970f, 0.02928185f, 0.05251067f, 0.03908992f, 0.04614134f, 0.04288504f, -0.02570709f, 0.00664958f, 
    -0.00504356f, -0.12043548f, 0.01522935f, 0.01927479f, 0.00849467f, 0.02933482f, 0.06569087f, -0.06729834f, 
    -0.01992531f, 0.10755473f, -0.18568809f, 0.06271116f, -0.10901820f, -0.05839383f, 0.08333593f, -0.01734363f, 
    0.01946889f, 0.01756186f, -0.02727724f, 0.01018381f, -0.04281621f, 0.01198975f, 0.00531935f, 0.02162400f, 
    -0.02070782f, -0.03486550f, -0.07377528f, -0.02674395f, 0.34326109f, 0.19372180f, -0.01203585f, 0.09531542f, 
    -0.05699876f, 0.08451281f, -0.00189304f, -0.03227177f, 0.09038346f, -0.04106218f, 0.01087090f, 0.03673980f, 
    -0.08773876f, -0.01896565f, 0.02315944f, -0.00946565f, 0.06470046f, -0.06157828f, 0.01118875f, 0.00536406f, 
    -0.17616385f, 0.14352444f, 0.02337126f, 0.07711158f, 0.10119369f, 0.07148238f, 0.15168226f, 0.07940433f, 
    0.02238878f, 0.00976215f, -0.01796907f, -0.03281786f, -0.01578885f, 0.01497111f, -0.11525311f, 0.02591877f, 
    0.03245191f, 0.05870267f, 0.01071595f, 0.03592778f, 0.10724068f, -0.12439939f, 0.00927517f, -0.02037594f, 
    -0.04943027f, -0.07931454f, -0.00692460f, -0.11604244f, -0.02769849f, 0.05946006f, 0.07837311f, 0.04762904f, 
    0.03176076f, -0.06337183f, 0.02953962f, -0.04208861f, 0.01977516f, -0.04743094f, 0.00100873f, -0.00257278f, 
    0.08098683f, -0.30216187f, -0.05527366f, 0.10551584f, 0.20078318f, 0.00983075f, 0.12469522f, 0.03601351f, 
    -0.02796234f, -0.02184326f, -0.08470090f, 0.03381140f, -0.01146703f, -0.03885902f, 0.00903656f, -0.07330084f, 
    0.02997909f, -0.00756951f, -0.01682007f, -0.13006504f, -0.16306150f, -0.47532675f, -0.32844713f, 0.09728722f, 
    0.08361311f, -0.07873321f, -0.03690073f, 0.00453990f, -0.03705276f, -0.07245509f, -0.00831485f, -0.01933946f, 
    -0.11576561f, 0.00941486f, 0.04866840f, -0.03866966f, -0.07009583f, 0.00723090f, -0.08140306f, -0.05518323f, 
    0.12039920f, 0.10884710f, -0.13962424f, -0.06088637f, -0.03916914f, -0.05241325f, -0.04928416f, -0.06118812f, 
    0.03035949f, 0.01624517f, -0.06480614f, 0.02030108f, 0.03546989f, 0.00334812f, 0.01202335f, -0.02892019f, 
    -0.06494949f, 0.00417726f, -0.00766276f, -0.00562766f, 0.15306009f, -0.06895011f, -0.36995509f, -0.02133166f, 
    0.12340767f, -0.05654519f, 0.06607880f, -0.01931998f, 0.03596991f, -0.00507251f, -0.00904066f, 0.01067604f, 
    0.00352382f, -0.01650018f, -0.00043273f, -0.02991479f, 0.03823942f, 0.01695980f, 0.03229683f, -0.02821399f, 
    -0.04088252f, 0.02478046f, -0.05277497f, 0.04800721f, 0.01779556f, -0.04872042f, -0.08006819f, -0.00173463f, 
    -0.00354974f, -0.00950288f, 0.00981499f, 0.00749715f, 0.02463606f, 0.02639636f, 0.01367267f, -0.02043974f, 
    0.00592434f, 0.04134964f, -0.01563416f, -0.01118321f, -0.18634447f, 0.22281171f, 0.01962280f, 0.16120023f, 
    0.04082098f, 0.06736737f, 0.00725648f, 0.05307004f, 0.02224606f, 0.02846462f, -0.03362371f, 0.02586936f, 
    -0.01502051f, -0.01082422f, -0.01713689f, 0.08846550f, 0.00070440f, 0.00430951f, -0.07521633f, -0.06507364f, 
    -0.11482121f, -0.43805149f, -0.30218408f, 0.02075514f, 0.18832558f, 0.02472354f, -0.00253492f, 0.01864054f, 
    -0.09259355f, -0.01253706f, 0.03572759f, 0.01960284f, -0.01416270f, 0.04508344f, -0.01555241f, 0.06636114f, 
    0.09129623f, 0.01090234f, 0.00184339f, -0.00272751f, 0.27040392f, 0.27028173f, 0.01293328f, 0.02836181f, 
    0.05433369f, 0.00174706f, 0.02429373f, 0.02422513f, 0.04310558f, 0.02494839f, -0.03453437f, -0.04533935f, 
    -0.03072089f, -0.02914803f, 0.07494779f, -0.03026809f, 0.02165202f, 0.09091330f, 0.03606716f, 0.06201554f, 
    -0.14173739f, -0.23674501f, -0.33273274f, 0.04921336f, 0.02669811f, -0.07796048f, 0.04465367f, -0.01584653f, 
    -0.04448844f, -0.08838783f, 0.04851650f, -0.03531129f, -0.02620987f, -0.00231682f, 0.00702317f, -0.01565759f, 
    0.00531130f, -0.01334080f, -0.03966299f, -0.03614602f, 0.00385334f, -0.01165604f, -0.02092967f, 0.06025234f, 
    -0.05398363f, -0.03755570f, 0.05453623f, -0.03040838f, -0.04970796f, 0.04342810f, 0.02829360f, -0.05897292f, 
    -0.02515095f, 0.03039869f, 0.01488620f, -0.04818071f, 0.05250520f, -0.07752573f, -0.07704753f, 0.02802966f, 
    -0.00101178f, -0.16961679f, 0.03763068f, 0.02807210f, 0.01242904f, -0.05572333f, 0.08242569f, 0.00014101f, 
    0.01142403f, 0.02429686f, -0.07480411f, 0.03999525f, -0.02571732f, -0.01059836f, -0.00947993f, -0.05131974f, 
    -0.00209648f, -0.01897257f, -0.05296472f, 0.07592075f, 0.17113774f, 0.01082376f, 0.14287797f, 0.06445549f, 
    -0.03904033f, -0.07275080f, -0.03105930f, -0.01858281f, -0.02791548f, -0.05538481f, -0.00840414f, -0.03281344f, 
    -0.01692168f, -0.01310809f, 0.07496310f, -0.02232630f, 0.05688494f, 0.07478955f, 0.10484264f, -0.04206581f, 
    0.06833666f, 0.02504762f, -0.01029444f, 0.03624367f, -0.04855146f, -0.06562475f, -0.10426389f, 0.01640706f, 
    -0.05339505f, 0.01240441f, 0.02192116f, 0.03507614f, -0.05024624f, 0.05582479f, -0.01397450f, -0.00740100f, 
    0.03097614f, 0.01904752f, 0.00437423f, -0.00554107f, 0.29367784f, -0.28307688f, -0.21111441f, 0.10963038f, 
    -0.10727604f, -0.04421949f, -0.12919927f, -0.07827900f, 0.06522097f, -0.06166887f, -0.02562591f, -0.03005933f, 
    -0.01842182f, -0.01163549f, -0.07477261f, 0.01463685f, -0.01708871f, 0.06125674f, -0.04689723f, 0.02436700f, 
    -0.20683846f, -0.13623536f, -0.00050982f, -0.09441946f, -0.10372284f, -0.07650313f, -0.13667747f, -0.08480591f, 
    0.05499142f, -0.10483888f, 0.00817169f, -0.08222214f, 0.02457404f, -0.02248225f, -0.03811582f, -0.02589259f, 
    0.07703448f, -0.00139761f, -0.00877032f, 0.01390382f, -0.06171140f, 0.16848493f, 0.06592818f, 0.13357203f, 
    0.07513785f, 0.01285759f, 0.06196324f, -0.03593136f, 0.10734833f, 0.01812463f, 0.04211163f, 0.03725983f, 
    -0.06145982f, -0.04240281f, 0.03307268f, -0.00008883f, -0.01994255f, -0.07117136f, 0.00595868f, -0.01154938f, 
    -0.07551564f, -0.17737217f, -0.21154314f, -0.14513597f, 0.05369170f, -0.07043035f, -0.01777737f, -0.01985738f, 
    0.02137810f, 0.00370493f, -0.02101539f, 0.08325993f, 0.02047744f, 0.03076910f, -0.04726195f, 0.02914129f, 
    -0.08901682f, -0.02732640f, -0.02187869f, 0.00719074f, 0.05365300f, 0.06959431f, 0.09404703f, 0.12385782f, 
    0.15850799f, 0.06694563f, 0.01006129f, -0.00403883f, 0.00735469f, -0.02087479f, 0.04111272f, -0.01321818f, 
    -0.08468566f, 0.02072453f, -0.10870595f, 0.09417445f, -0.03559419f, 0.01561726f, 0.05776382f, -0.00132422f, 
    0.48998716f, 0.16254640f, -0.06611134f, 0.05723720f, 0.11577357f, -0.00309934f, 0.02720455f, -0.01056089f, 
    0.09097547f, 0.05441780f, -0.14221589f, 0.03246382f, -0.04963057f, 0.07862211f, -0.04223442f, -0.09129824f, 
    0.12443276f, -0.11002146f, 0.05351384f, 0.07429027f, -0.21133459f, -0.09701087f, -0.12589097f, -0.01532629f, 
    0.13263863f, -0.11139745f, -0.02439850f, -0.05958964f, 0.03810702f, -0.01629016f, -0.00283676f, 0.00512048f, 
    0.05621972f, -0.01891618f, 0.00804886f, -0.06206031f, 0.01041356f, -0.08239616f, -0.02580448f, 0.04154243f, 
    -0.09771408f, 0.01013554f, 0.02790831f, 0.08435348f, 0.05761532f, -0.02026867f, 0.05760996f, 0.02526032f, 
    0.02166246f, 0.00775927f, -0.04795748f, 0.03176229f, -0.02343329f, -0.02531013f, 0.02468671f, -0.00111916f, 
    0.01495593f, -0.07083960f, 0.04073096f, -0.10348687f, -0.35675234f, -0.09773485f, -0.02892982f, 0.05205639f, 
    0.05071821f, -0.07244925f, 0.01346261f, 0.00510089f, -0.01645230f, -0.05860628f, -0.05559118f, 0.01511823f, 
    -0.06117143f, -0.03858370f, -0.02115488f, 0.00778968f, 0.02219326f, -0.03378721f, -0.02658932f, 0.01442883f, 
    0.05534140f, 0.03387793f, 0.16013479f, 0.06051589f, -0.02717683f, -0.07423195f, 0.05897448f, 0.00104220f, 
    -0.02545882f, 0.04893882f, -0.05028153f, 0.01553223f, -0.00952599f, 0.05887761f, -0.03974728f, -0.00125586f, 
    -0.00398154f, -0.00548578f, -0.02349188f, 0.04970013f, 0.05164800f, 0.06212141f, -0.02135459f, 0.00655020f, 
    -0.09535728f, -0.03936532f, -0.07183204f, -0.07380901f, -0.08086288f, -0.01039931f, -0.00289962f, 0.08444378f, 
    0.02994358f, 0.00730306f, 0.00410866f, 0.03483476f, -0.00143515f, -0.00292009f, -0.00688278f, 0.01879532f, 
    -0.40018710f, 0.24048683f, 0.12868047f, 0.00804336f, -0.07662380f, 0.08577903f, -0.01773036f, -0.01640895f, 
    0.05107071f, -0.07970461f, 0.01940719f, -0.03894809f, -0.08029914f, 0.09031144f, -0.04179492f, -0.06945894f, 
    0.00206509f, -0.08832196f, 0.03504640f, -0.07095778f, -0.00764915f, 0.08373410f, -0.06257968f, 0.05524927f, 
    0.08237024f, -0.07083672f, -0.06698733f, -0.00537696f, 0.07223286f, -0.00251133f, -0.14393757f, -0.03104744f, 
    -0.00220263f, 0.05197313f, 0.09780009f, -0.02346763f, -0.02970136f, 0.04017622f, 0.00343412f, -0.00033781f, 
    -0.22038007f, 0.22393259f, 0.05240724f, 0.02074907f, 0.07707272f, 0.00375585f, -0.02784360f, -0.01011738f, 
    -0.00445893f, -0.02290210f, 0.00566958f, -0.03931065f, -0.04180219f, 0.03436802f, -0.07659650f, -0.06683826f, 
    0.00467034f, -0.05763550f, 0.10264494f, 0.04491260f, 0.15037483f, -0.00229765f, -0.01484778f, 0.03869549f, 
    -0.12128548f, -0.09748629f, -0.08680928f, 0.01521142f, -0.02631527f, -0.01626752f, -0.10882021f, -0.03450748f, 
    0.00160892f, -0.06647234f, 0.07185130f, -0.06738444f, 0.03743112f, 0.08512527f, -0.00737954f, 0.01184273f, 
    0.08131384f, -0.05871918f, 0.10393103f, -0.09117582f, 0.12529376f, -0.01625203f, 0.14422555f, -0.00089612f, 
    -0.02626137f, 0.08725462f, 0.00029239f, 0.00394568f, -0.06362745f, 0.01678069f, -0.02941476f, 0.12262846f, 
    0.04961565f, 0.00014202f, 0.05635089f, 0.02335140f, 0.03233952f, 0.10647006f, 0.05476775f, 0.06274770f, 
    0.00200167f, 0.02604850f, 0.02048026f, 0.05653597f, -0.06125956f, 0.02694652f, -0.02705274f, 0.06885649f, 
    -0.06030665f, -0.00812420f, -0.00684774f, 0.00273011f, 0.01277469f, 0.03712620f, 0.07651354f, -0.09064347f, 
    -0.02432321f, -0.00686516f, 0.00381125f, -0.00776515f, -0.12576318f, -0.04400052f, -0.06203214f, 0.04217532f, 
    -0.03636660f, 0.01554183f, -0.02704852f, 0.06339240f, -0.02451027f, 0.00562473f, 0.03477256f, 0.01696447f, 
    -0.02723790f, 0.02481010f, 0.08482979f, 0.08308066f, 0.04000191f, -0.08740832f, 0.00100324f, -0.10897504f, 
    -0.06542923f, -0.02907074f, -0.10650644f, 0.02798425f, -0.06401874f, -0.04592879f, -0.04396581f, -0.02122419f, 
    -0.00581816f, -0.01065242f, -0.00622381f, 0.01930736f, -0.02335688f, 0.02918990f, 0.02129991f, 0.02179131f, 
    0.15688714f, 0.21532702f, -0.05865217f, -0.04559117f, -0.09768332f, -0.02204266f, -0.01073966f, -0.03987691f, 
    0.03859233f, 0.06265050f, -0.04770136f, -0.06246637f, -0.10041883f, 0.11507101f, -0.06980743f, -0.02642189f, 
    -0.02792243f, -0.02824197f, 0.07415634f, 0.07879600f, 0.33175072f, 0.16327026f, 0.05828356f, -0.01057075f, 
    0.00477048f, 0.00878144f, 0.03689647f, -0.04121409f, 0.08122239f, -0.02242696f, -0.04304560f, -0.02283879f, 
    -0.08009715f, 0.03822511f, 0.03346122f, 0.02348401f, -0.03474820f, -0.06440738f, -0.04812467f, 0.02414090f, 
    -0.08562249f, -0.05772907f, 0.06264596f, 0.05176706f, -0.08492200f, 0.01830490f, -0.04716637f, -0.09552018f, 
    -0.01795431f, -0.05567959f, -0.00000390f, -0.00664177f, -0.05524167f, 0.06701054f, 0.08275402f, -0.04601077f, 
    0.01319470f, -0.03432544f, -0.04901491f, 0.02359648f, 0.08016319f, 0.11169023f, 0.00466797f, 0.13528644f, 
    -0.06247550f, 0.06505232f, 0.08673121f, -0.02059234f, 0.00423962f, 0.01109070f, -0.04527015f, 0.00233017f, 
    -0.04535614f, -0.03054197f, 0.00267168f, 0.04054184f, -0.02679924f, 0.06505106f, -0.02047384f, 0.01017971f, 
    0.05723593f, 0.17437480f, -0.13331005f, 0.11089834f, -0.06940214f, 0.00904472f, 0.08744305f, -0.05517689f, 
    0.05000734f, -0.04452129f, -0.02621996f, -0.02666903f, -0.00938371f, 0.01711855f, 0.03572358f, 0.08145217f, 
    -0.07369246f, 0.02459807f, -0.07486997f, -0.00789747f, -0.47997835f, 0.21884854f, -0.22874795f, -0.06011139f, 
    0.20099451f, -0.04618245f, 0.01229254f, -0.01463287f, 0.01801067f, -0.04758726f, -0.03171968f, -0.05605948f, 
    0.08649305f, 0.03862641f, 0.00274294f, -0.04227370f, -0.05862956f, -0.07774642f, 0.04575557f, 0.08622000f, 
    -0.17836377f, -0.10842838f, -0.06455019f, -0.04642075f, 0.04940657f, -0.00721978f, -0.03445881f, -0.16145135f, 
    0.04994795f, 0.07609628f, 0.01199416f, -0.11866841f, -0.03334403f, -0.05606223f, 0.01349980f, 0.08421714f, 
    -0.05669227f, -0.01107189f, -0.01961824f, -0.05062123f, -0.48951820f, -0.09097646f, -0.06589729f, 0.12799147f, 
    0.14768101f, 0.05385226f, 0.01144253f, 0.02793081f, 0.08495598f, 0.07320794f, -0.00335875f, 0.00200619f, 
    0.01957417f, 0.03700005f, 0.03419119f, -0.01761062f, -0.02199234f, 0.03930056f, 0.10274467f, 0.08739601f, 
    -0.06027268f, 0.06606845f, 0.10467586f, 0.02899791f, -0.14034344f, -0.08102818f, 0.00022447f, -0.06999107f, 
    0.04344684f, 0.03563659f, 0.09888037f, -0.04419641f, 0.01065083f, -0.05576192f, 0.01595977f, -0.08553277f, 
    0.03829042f, -0.10044432f, 0.00724926f, 0.06785630f, 0.08960454f, 0.11127133f, -0.06809247f, -0.06574886f, 
    0.18830059f, 0.03920416f, 0.06573779f, -0.01094854f, 0.02266178f, 0.03104150f, -0.02162912f, -0.01208269f, 
    0.02843090f, -0.01424835f, -0.04309479f, -0.01380323f, -0.08042464f, -0.03077528f, 0.06505278f, -0.09867121f, 
    0.15120630f, 0.21183139f, -0.21548037f, -0.07325518f, -0.00845147f, 0.04445364f, 0.00035103f, 0.09410860f, 
    0.07420362f, 0.06701083f, -0.02480084f, 0.03272380f, -0.06014151f, -0.00308267f, -0.01233825f, -0.01925302f, 
    0.05364366f, -0.00868508f, 0.02278536f, 0.00877139f, 0.19081122f, 0.00019708f, -0.18041046f, -0.03553434f, 
    -0.12047291f, 0.02116765f, 0.09361022f, 0.01721838f, -0.06979085f, -0.04658105f, -0.06594925f, -0.04018642f, 
    0.01140702f, 0.02075328f, -0.01523050f, -0.01472508f, -0.00222286f, 0.01904603f, -0.02227205f, -0.07455534f, 
    -0.38910306f, 0.06081672f, 0.01574298f, 0.10736840f, 0.11919575f, 0.01237224f, -0.02841573f, 0.07474591f, 
    -0.04413353f, 0.09086397f, -0.00150790f, 0.08090317f, 0.02253639f, -0.03257045f, 0.01462102f, 0.02667849f, 
    -0.02838164f, 0.00912056f, 0.06381065f, -0.08127699f, -0.08008954f, 0.17697200f, -0.07120737f, 0.15270527f, 
    -0.21639350f, -0.05755668f, -0.01274075f, -0.01077638f, -0.02416296f, -0.10204633f, 0.06851491f, -0.02841024f, 
    -0.01941376f, 0.06291240f, -0.03451420f, -0.01289452f, -0.00895696f, -0.01510382f, -0.00100640f, -0.01476694f, 
    0.07091397f, -0.13895860f, 0.05357915f, 0.07882521f, 0.06015661f, -0.12946716f, -0.09413929f, 0.01163982f, 
    0.02313260f, 0.02594215f, -0.00295111f, -0.00057872f, -0.00922705f, -0.07908375f, -0.03382385f, 0.01388450f, 
    -0.03903858f, 0.01195420f, 0.04813324f, 0.06420352f, -0.36066428f, -0.02265541f, -0.07909868f, -0.13222189f, 
    -0.01060185f, -0.00057589f, -0.02498765f, 0.02790415f, -0.03094871f, 0.01451507f, 0.04673280f, -0.05377888f, 
    -0.01919469f, 0.03711283f, -0.02284175f, -0.02342885f, 0.02089129f, 0.10763450f, 0.06326754f, 0.03060436f, 
    -0.04665769f, -0.02790462f, -0.04222202f, 0.00479443f, 0.11281299f, -0.04583438f, 0.06798628f, 0.02902416f, 
    0.11426968f, 0.05737588f, -0.09106965f, -0.08097257f, 0.03527128f, 0.10376425f, -0.04155422f, -0.04727566f, 
    0.06652732f, -0.05427048f, -0.04867733f, -0.04387192f, 0.01381376f, -0.03040456f, 0.08786854f, 0.07054501f, 
    -0.02207859f, 0.00770289f, 0.04226143f, -0.01622425f, 0.11547521f, 0.02406236f, 0.10429560f, 0.05226715f, 
    0.03266205f, -0.00020921f, 0.07015778f, 0.02700635f, 0.03826892f, -0.01589184f, 0.02240135f, 0.06574740f, 
    0.07995287f, 0.09485099f, -0.06723732f, -0.10309686f, 0.01377942f, 0.01332035f, 0.02662571f, 0.04542744f, 
    0.01608815f, -0.07962245f, -0.00522672f, 0.00968513f, -0.05377398f, 0.05119044f, 0.00394958f, 0.00568313f, 
    0.06458234f, 0.02708008f, -0.03685367f, 0.01174177f, -0.52046585f, 0.22112204f, 0.04965604f, -0.03417479f, 
    -0.02079881f, 0.11982466f, 0.00647098f, -0.08028182f, 0.10314526f, -0.05051978f, 0.08397300f, -0.07762741f, 
    0.05502734f, 0.09127353f, 0.00601073f, 0.05761207f, 0.01533669f, -0.02890576f, -0.03686636f, -0.05052697f, 
    0.00013630f, -0.05919069f, -0.10095780f, 0.04356277f, 0.02808822f, 0.14856341f, -0.05291676f, 0.10259378f, 
    -0.00747544f, 0.03474182f, 0.00536133f, 0.01505725f, -0.00102899f, 0.01106506f, 0.03159538f, 0.02922587f, 
    0.07141773f, 0.00342375f, 0.04638891f, 0.03971005f, -0.16402954f, 0.02366924f, -0.05585878f, 0.14024463f, 
    0.10747511f, 0.06025644f, -0.01050455f, -0.03453188f, 0.09227300f, 0.11099514f, -0.01928522f, 0.01806368f, 
    -0.00159858f, -0.02447047f, 0.00312298f, 0.04148893f, 0.04294026f, 0.03498302f, 0.10194170f, -0.09304066f, 
    0.07835475f, 0.07340407f, -0.14291066f, 0.05929753f, -0.11617753f, 0.04702517f, -0.01371623f, 0.02505218f, 
    -0.06859559f, -0.19563782f, 0.05611279f, -0.03540748f, 0.03522420f, -0.01822148f, -0.02031307f, 0.01065444f, 
    0.01532926f, 0.02017319f, 0.09484925f, -0.06695282f, 0.00231440f, 0.00534995f, -0.07956491f, 0.07853858f, 
    0.00604372f, 0.05817283f, 0.09254579f, 0.00958683f, 0.04985152f, 0.00678616f, 0.03405300f, 0.04058138f, 
    0.05566834f, -0.04229869f, 0.04326388f, -0.07308894f, -0.03587409f, 0.07487845f, 0.03866213f, 0.10901474f, 
    -0.24815178f, -0.03972393f, -0.08422842f, 0.05986821f, -0.18983972f, -0.04722226f, -0.02410106f, -0.02141999f, 
    -0.04945890f, -0.03918711f, -0.02278882f, -0.13065653f, -0.01757265f, -0.02695261f, 0.07336402f, 0.03021292f, 
    -0.01651930f, 0.05969501f, -0.06219086f, 0.01664960f, -0.06936330f, -0.17780253f, 0.05128466f, 0.14502373f, 
    0.02555873f, -0.00584144f, 0.01595244f, -0.03696176f, -0.08546595f, -0.01337146f, 0.11045932f, 0.04104042f, 
    0.01122607f, -0.00156686f, 0.04156260f, -0.01506179f, -0.10560028f, 0.05687343f, 0.00621144f, -0.06014728f, 
    -0.05072844f, -0.02297815f, -0.00658313f, 0.04198466f, 0.10982567f, 0.01843248f, 0.02882568f, -0.06127131f, 
    0.00221225f, 0.00888690f, 0.03326662f, 0.06411602f, -0.07177090f, -0.02152493f, -0.00836839f, -0.08505507f, 
    0.03395818f, -0.03620847f, -0.01046971f, 0.00448829f, -0.25284430f, -0.27512050f, 0.15970029f, 0.06392206f, 
    0.04560741f, -0.03719709f, -0.05928718f, 0.02806170f, -0.09815110f, -0.01623531f, -0.06861665f, 0.00101143f, 
    -0.01341527f, -0.04135969f, 0.02094328f, -0.02666340f, -0.08149312f, 0.04015981f, 0.04193817f, -0.00663044f, 
    -0.29423675f, 0.22048992f, -0.11799767f, 0.01182722f, -0.13932982f, 0.04066889f, -0.07885213f, 0.00941134f, 
    -0.16211483f, -0.00588738f, -0.02876294f, 0.01433147f, -0.07650541f, -0.01994362f, 0.00611504f, -0.01491936f, 
    -0.12145165f, -0.04781219f, -0.14177711f, 0.01491871f, 0.10556854f, 0.10891123f, 0.05956558f, -0.16140416f, 
    -0.06014704f, -0.00579304f, 0.04806697f, -0.07337090f, 0.04387908f, 0.01563817f, -0.04430709f, -0.09539255f, 
    0.01800727f, 0.01252882f, -0.06891108f, -0.01570215f, 0.03365970f, -0.04048070f, -0.03313971f, 0.09219399f, 
    -0.20402648f, -0.23173523f, 0.15559082f, 0.13956067f, 0.00381208f, -0.00693271f, 0.06855259f, -0.03080306f, 
    -0.13032964f, -0.17884885f, 0.03199527f, -0.02260357f, -0.04527131f, 0.04530409f, 0.08735830f, -0.08022591f, 
    -0.11660367f, 0.02627326f, -0.01841817f, -0.09345960f, -0.39367378f, 0.08499873f, 0.10559459f, 0.00203049f, 
    -0.00215196f, 0.06040486f, -0.07575230f, -0.01282433f, 0.02511654f, -0.09578661f, -0.01312933f, -0.03807526f, 
    -0.01279001f, -0.05856155f, -0.01938969f, 0.00748856f, -0.00668589f, -0.13226940f, 0.05445221f, 0.01487637f, 
    -0.00294215f, -0.21415231f, 0.12431710f, -0.01696479f, -0.01375915f, -0.01045578f, -0.10388260f, 0.04776328f, 
    -0.11805074f, 0.04307801f, 0.07161185f, -0.01037373f, -0.13976616f, -0.04490832f, 0.09254479f, 0.02730627f, 
    0.01739637f, -0.00071947f, 0.05110216f, 0.03180684f, -0.01704223f, -0.14533511f, 0.05316716f, -0.05868542f, 
    0.01340138f, -0.06180714f, 0.06292381f, 0.02587676f, -0.04101019f, 0.08041877f, 0.12148219f, 0.00456321f, 
    0.07888971f, -0.01938951f, -0.04026232f, 0.06490969f, -0.03976084f, -0.05618456f, -0.04905658f, -0.01928415f, 
    -0.21360560f, 0.09255299f, 0.05103780f, -0.03282687f, 0.06870010f, 0.09387553f, 0.03279933f, 0.00628381f, 
    0.02830059f, 0.00474013f, 0.00668075f, 0.00436240f, -0.05783146f, -0.04739585f, 0.04354011f, 0.01774502f, 
    -0.07512611f, -0.05459686f, 0.01494486f, 0.03251335f, -0.09721896f, -0.22405279f, 0.17328908f, 0.14310578f, 
    -0.10755600f, -0.12013303f, 0.01118718f, -0.00368384f, 0.04798025f, 0.02270606f, 0.00850938f, -0.03364388f, 
    -0.02874392f, -0.02770005f, 0.03798947f, -0.04874314f, 0.09196366f, -0.01719408f, 0.03661343f, 0.04487151f, 
    -0.24631722f, 0.01844165f, 0.08646795f, -0.02816684f, 0.03383240f, -0.04151406f, -0.03560048f, -0.03193140f, 
    0.06764467f, -0.04044181f, -0.04189414f, 0.01474882f, -0.01728668f, 0.07428022f, 0.03569654f, -0.03662974f, 
    0.02629461f, 0.04318218f, 0.04583136f, 0.03410404f, -0.13310137f, -0.10980760f, 0.06330536f, -0.06630103f, 
    0.01126467f, 0.00703140f, -0.09737667f, 0.02150793f, -0.03177759f, 0.07194921f, -0.02482238f, -0.05954341f, 
    0.01251105f, 0.02575557f, 0.07124509f, -0.01722101f, 0.01369786f, -0.06308395f, 0.05611129f, 0.00611508f, 
    0.05184227f, -0.13339438f, 0.19215433f, 0.15997334f, -0.01384313f, -0.08738685f, 0.06249022f, 0.05021171f, 
    -0.01488364f, 0.03528790f, 0.06354788f, 0.08792921f, 0.03885603f, -0.01693299f, -0.00614500f, -0.03972854f, 
    0.07696975f, 0.04644749f, 0.03548006f, 0.07616853f, 0.28029823f, -0.05293017f, -0.01974597f, -0.13098757f, 
    -0.14636807f, -0.09792689f, 0.05603202f, -0.00106260f, 0.00322223f, -0.04072638f, -0.00772898f, -0.02270559f, 
    0.08451833f, 0.01400785f, 0.02872144f, -0.07258976f, 0.05754640f, 0.15516362f, 0.02562193f, 0.06056567f, 
    0.03659977f, 0.13269585f, 0.06411461f, -0.07715867f, 0.01910516f, 0.07457103f, 0.02133774f, -0.09463996f, 
    0.00389691f, 0.02588872f, 0.00096245f, 0.00998228f, 0.03806207f, 0.00941343f, -0.09916718f, -0.03970223f, 
    -0.03315573f, -0.07509688f, -0.07868906f, -0.00789068f, 0.14745127f, -0.03356225f, -0.23475373f, 0.17289619f, 
    -0.21041523f, 0.02359292f, -0.02708034f, 0.04319169f, -0.00541517f, 0.06618041f, -0.08402626f, 0.00955579f, 
    0.06998199f, -0.02482043f, 0.06594250f, -0.04468025f, 0.03057107f, 0.02936680f, -0.02605841f, 0.06832802f, 
    0.07321279f, -0.15575971f, -0.02154514f, 0.16143881f, -0.06539536f, 0.03656953f, -0.06134771f, -0.03511366f, 
    -0.03736461f, 0.04954647f, -0.04010667f, 0.03562098f, 0.02668328f, 0.01701055f, 0.04319596f, -0.02546145f, 
    0.10150120f, 0.04501959f, -0.06471170f, -0.03978232f, -0.13862099f, -0.10816401f, 0.01385084f, 0.05774186f, 
    0.13929546f, 0.04075443f, 0.00748551f, -0.07619390f, 0.02638079f, -0.00139533f, 0.04596851f, 0.07513193f, 
    -0.06714801f, 0.02830187f, 0.02803917f, -0.04978063f, 0.11863478f, 0.06109407f, 0.03287973f, 0.01658602f, 
    -0.19212818f, 0.19198474f, -0.03690466f, 0.04163043f, 0.02624860f, 0.05242570f, 0.04123612f, -0.01277891f, 
    0.07983586f, -0.00968014f, -0.04505290f, -0.01043306f, 0.01381838f, 0.02748303f, -0.00041390f, -0.01331830f, 
    -0.04242018f, 0.03225499f, 0.05164295f, -0.06138410f, -0.02452838f, 0.24072762f, -0.12681647f, -0.20780253f, 
    0.00065969f, -0.03243854f, 0.00532987f, -0.02125961f, 0.04036201f, 0.02740953f, -0.05443848f, 0.03243876f, 
    -0.03794474f, 0.08790752f, 0.02911610f, -0.02074397f, 0.10835293f, -0.01580912f, -0.05210781f, 0.01594276f, 
    0.32933879f, 0.13766025f, -0.39455751f, -0.23557231f, 0.18493268f, -0.06816072f, 0.00349370f, 0.02487757f, 
    0.15144382f, -0.13859914f, 0.03765978f, -0.05597383f, -0.04721500f, 0.09538773f, -0.00126621f, -0.00470090f, 
    0.03181589f, -0.09652372f, 0.00971018f, 0.04946653f, -0.42710102f, 0.16613451f, -0.12487436f, -0.22243917f, 
    -0.09348628f, 0.01661423f, 0.00045017f, -0.02185100f, -0.08841726f, 0.01555789f, -0.13246918f, 0.01616000f, 
    0.09179037f, -0.02086134f, -0.00549711f, -0.02546811f, -0.01589132f, -0.00560502f, 0.07240269f, -0.08605222f, 
    0.20952840f, -0.13698821f, 0.20074303f, 0.05921777f, -0.01595249f, -0.04373969f, -0.07742987f, 0.03572129f, 
    -0.05732836f, -0.06117573f, 0.07013904f, 0.00384450f, -0.02958297f, -0.07544915f, 0.01375224f, -0.01499453f, 
    0.04446761f, -0.08771298f, -0.01404982f, -0.03869245f, -0.04400257f, -0.24066749f, -0.00661655f, 0.16890050f, 
    -0.02658264f, -0.16599244f, 0.02908429f, 0.03710394f, -0.07765670f, -0.03156971f, 0.00790355f, 0.08388482f, 
    0.04010807f, -0.01904023f, -0.00828689f, -0.01117746f, 0.00285414f, 0.03827337f, -0.01186418f, -0.00964431f, 
    0.10626459f, 0.17651716f, 0.10701127f, -0.13198057f, -0.24721397f, -0.05476651f, 0.05674301f, 0.08026069f, 
    -0.04715600f, -0.01853092f, 0.02490792f, 0.04725046f, -0.00658098f, 0.10393015f, 0.04431557f, -0.11567277f, 
    0.10305737f, 0.04279017f, 0.05217100f, 0.07287718f, -0.23882033f, 0.02107179f, 0.08911230f, 0.02400707f, 
    0.03741862f, -0.07372093f, -0.03009098f, 0.06179454f, 0.03739086f, 0.04586317f, 0.04778921f, 0.01507221f, 
    -0.03290964f, -0.06566831f, 0.00191944f, 0.08652588f, 0.05477498f, -0.04044751f, -0.01762845f, 0.03238979f, 
    -0.24783663f, -0.05343420f, -0.00380386f, -0.11228240f, 0.01453435f, -0.02830079f, -0.01355314f, 0.02604503f, 
    -0.04253368f, 0.01547272f, -0.01007552f, 0.00354837f, 0.02514540f, -0.05616100f, -0.04216245f, 0.02656864f, 
    -0.00660152f, 0.01517796f, -0.10569285f, 0.04016415f, -0.30123076f, -0.09409018f, 0.02339772f, 0.13050690f, 
    0.01485016f, -0.02733580f, 0.00893317f, 0.03016175f, -0.00590034f, 0.01065469f, 0.01887290f, 0.01264221f, 
    -0.01322418f, -0.00305080f, -0.02169882f, -0.06036310f, 0.04875865f, -0.15508662f, 0.03456831f, -0.04256198f, 
    0.05837901f, 0.22094813f, -0.02454712f, 0.07716851f, -0.18829036f, 0.06229011f, -0.02558400f, 0.01482104f, 
    0.05298434f, -0.08437907f, -0.04390372f, 0.01582551f, -0.01294319f, 0.01297824f, 0.02430835f, 0.01200718f, 
    -0.02597478f, -0.01364841f, -0.02649023f, 0.02415092f, -0.06216079f, 0.27165580f, 0.00141549f, 0.03821163f, 
    0.04834288f, 0.08075106f, -0.04194364f, 0.03435992f, 0.03851810f, -0.03530149f, -0.02889447f, 0.03742931f, 
    -0.00852924f, -0.01720152f, -0.02657159f, -0.05436208f, -0.07375586f, 0.01210054f, -0.00323712f, -0.12526871f, 
    -0.31890509f, 0.21615677f, -0.05395854f, 0.00749149f, -0.08771427f, 0.08024972f, -0.04426597f, 0.05539956f, 
    -0.02656550f, 0.00314462f, 0.04360095f, 0.02410447f, -0.09100287f, -0.03168904f, -0.02074646f, 0.00178918f, 
    0.05832314f, -0.14124295f, -0.01652553f, -0.05674455f, 0.07439008f, -0.20022009f, -0.05771765f, -0.08754241f, 
    0.18503205f, 0.02309881f, 0.06749173f, 0.00411557f, 0.07738572f, 0.01931959f, 0.05956296f, -0.01107042f, 
    -0.00108041f, -0.06183919f, 0.07097286f, 0.06229814f, 0.01117989f, 0.01515323f, 0.08080893f, 0.13899192f, 
    -0.03533583f, 0.09775192f, 0.05777610f, 0.03296926f, -0.05489461f, -0.09200772f, -0.04476901f, 0.01929685f, 
    -0.01265673f, 0.00514089f, -0.00242135f, -0.00728943f, -0.06644053f, 0.04616214f, 0.02545685f, 0.03142711f, 
    0.01692904f, -0.00468343f, 0.03741201f, -0.01272539f, -0.25281438f, -0.00834082f, -0.14083867f, 0.05251289f, 
    0.11646110f, 0.04280205f, -0.06143225f, -0.04129406f, 0.13328704f, 0.05420061f, 0.02890404f, -0.02849922f, 
    0.00612156f, -0.00938823f, -0.03555298f, -0.00780936f, -0.01707045f, 0.05404383f, 0.03070511f, -0.02791072f, 
    0.06238580f, 0.09908686f, 0.02562602f, 0.14924659f, -0.05882245f, 0.01338286f, -0.02974579f, 0.00830715f, 
    -0.00091351f, 0.04440984f, 0.02919622f, 0.01023941f, 0.04940938f, -0.05541048f, 0.02779760f, 0.02579519f, 
    0.08726539f, 0.02842668f, 0.02017745f, 0.13084979f, -0.00774802f, -0.04219539f, 0.07157353f, -0.01956442f, 
    -0.02234278f, 0.07516173f, 0.02162668f, -0.05832508f, -0.04193962f, -0.02252034f, 0.01095819f, 0.01081595f, 
    -0.05802650f, 0.06014706f, -0.04792930f, 0.03264416f, 0.03525940f, 0.02691280f, 0.05292827f, 0.03953154f, 
    -0.68755990f, 0.10370936f, 0.08984417f, 0.09303157f, 0.14472333f, 0.06664276f, -0.07629882f, -0.02063920f, 
    -0.00249854f, 0.11367894f, -0.12298006f, 0.01771112f, 0.03426871f, 0.09676152f, 0.00543219f, 0.00667224f, 
    0.00956071f, 0.06149013f, -0.01210676f, -0.09319708f, -0.29986465f, -0.01323431f, -0.11117533f, 0.13004126f, 
    0.15735967f, 0.04336781f, 0.02632025f, 0.07700056f, 0.05524281f, -0.00872326f, -0.03111430f, -0.07183254f, 
    0.07405133f, 0.05765856f, -0.01044090f, -0.03755674f, 0.01939462f, -0.02280849f, 0.01053063f, -0.07827058f, 
    -0.04769559f, -0.12683901f, -0.12091514f, 0.00680321f, -0.14206189f, 0.15766160f, -0.11199013f, 0.12275647f, 
    -0.05744636f, -0.00189613f, -0.00654312f, -0.07348488f, -0.05948085f, -0.00169804f, -0.00286192f, 0.06237916f, 
    0.05693159f, -0.09164826f, 0.04235185f, 0.05250372f, 0.05655858f, -0.03237292f, 0.14465010f, -0.22801350f, 
    -0.13814512f, 0.04284330f, 0.09615049f, 0.00067443f, -0.01219117f, -0.01455231f, 0.06141034f, -0.06409117f, 
    -0.06268257f, -0.01629524f, 0.06887315f, 0.00129592f, -0.00881113f, -0.01991956f, 0.02691140f, 0.08688816f, 
    -0.34224799f, 0.18121926f, -0.00342976f, -0.07201891f, -0.00516732f, 0.03946431f, 0.11503042f, 0.02332347f, 
    -0.04895612f, 0.01625660f, -0.07580778f, 0.09634548f, 0.07213417f, -0.01472758f, -0.08478215f, 0.02422653f, 
    0.01679035f, 0.06948625f, -0.01273068f, -0.07708246f, -0.09958947f, -0.11805827f, 0.07574578f, 0.06050363f, 
    -0.03906502f, -0.06046569f, 0.04174194f, -0.05096773f, -0.00161721f, -0.09097331f, 0.10508455f, -0.11249924f, 
    -0.09397894f, 0.06033811f, 0.05808260f, -0.10381901f, 0.00337233f, 0.01763676f, -0.05873431f, 0.09766009f, 
    -0.12462272f, 0.09304050f, -0.05175247f, 0.09442535f, -0.08875721f, -0.03963858f, 0.02571582f, 0.06980459f, 
    -0.02923776f, 0.00285116f, 0.06292760f, -0.02837383f, -0.09534666f, -0.00380737f, 0.03054446f, -0.00477254f, 
    -0.03794267f, 0.03929966f, -0.00453960f, 0.10645744f, -0.31305388f, 0.08087868f, 0.21979360f, 0.05824136f, 
    -0.03707394f, -0.04798551f, -0.03653923f, 0.01995348f, 0.00497836f, 0.00739524f, 0.06785216f, 0.00967917f, 
    0.02972678f, -0.08783453f, 0.05495040f, 0.06080849f, 0.00622043f, -0.06678583f, -0.04981147f, 0.02268076f, 
    0.07451677f, 0.05013892f, -0.03445867f, 0.09267005f, -0.00923266f, 0.04583001f, 0.12913638f, 0.01927001f, 
    -0.03504745f, 0.06266043f, 0.06193801f, -0.03559851f, 0.00141087f, -0.02982931f, 0.04411663f, 0.06362826f, 
    0.11634497f, 0.04234757f, 0.03021470f, 0.05178706f, -0.09950623f, 0.12118267f, -0.16914552f, -0.13032447f, 
    -0.01910778f, 0.13308048f, 0.11930478f, 0.08167300f, -0.10434809f, -0.04888849f, -0.06193506f, 0.06092612f, 
    -0.01850004f, -0.12846892f, -0.03130203f, 0.03369413f, 0.00454163f, -0.06436682f, 0.05782983f, -0.07280561f, 
    0.01177870f, -0.03572938f, 0.07197752f, 0.12668823f, 0.09983111f, -0.03111978f, 0.02537601f, 0.11081483f, 
    -0.02772815f, 0.02712893f, -0.06608744f, 0.00257396f, 0.02403069f, 0.06332363f, 0.02342795f, -0.00627970f, 
    -0.04883223f, 0.00825160f, 0.04114481f, 0.02075180f, -0.25075123f, -0.10459200f, -0.01346134f, -0.10131634f, 
    -0.03540770f, 0.08539209f, -0.00301916f, 0.07606939f, 0.02216218f, 0.01456194f, 0.08527177f, 0.07218122f, 
    -0.14357397f, 0.03869882f, -0.01450739f, 0.00803311f, 0.02157113f, 0.04935433f, -0.11052083f, 0.05040776f, 
    -0.24168953f, -0.06153811f, 0.18596002f, 0.05986721f, -0.29175594f, 0.03595304f, -0.03924514f, -0.05694542f, 
    -0.02241181f, -0.00114941f, 0.03635730f, -0.00280890f, -0.02205878f, -0.01065566f, -0.05417429f, -0.03305041f, 
    0.00264830f, 0.08480579f, 0.03109797f, 0.05221136f, 0.01207759f, 0.14327870f, 0.02534638f, 0.03367687f, 
    0.12802665f, 0.01373559f, -0.01564350f, 0.08593436f, 0.00860289f, 0.09271082f, 0.10309578f, -0.00178655f, 
    -0.03181203f, 0.01011891f, 0.00265176f, 0.00234178f, 0.06247009f, -0.03313617f, 0.08761480f, 0.00402670f, 
    -0.17615530f, 0.06033792f, -0.07755342f, -0.08436082f, 0.00094726f, 0.02084912f, 0.01113179f, 0.04559829f, 
    -0.00373291f, -0.14426997f, 0.03729943f, -0.02496178f, 0.04339136f, 0.01968920f, 0.06357614f, 0.05189746f, 
    -0.00784644f, -0.04040153f, 0.00956170f, 0.00011863f, 0.04381171f, -0.06995016f, -0.19569024f, 0.11131745f, 
    0.17750092f, 0.02022538f, -0.15347388f, -0.07476719f, 0.10082012f, 0.12640102f, 0.01319347f, 0.02305141f, 
    0.04673667f, -0.06487552f, 0.11617679f, -0.10864366f, -0.02421348f, -0.01172547f, -0.04627449f, -0.14429203f, 
    -0.05410926f, 0.00468617f, 0.04821758f, 0.20229939f, -0.31966296f, -0.11715963f, 0.00133456f, -0.00353046f, 
    0.01648052f, -0.03570568f, 0.00100627f, 0.02075921f, 0.01286128f, 0.01594627f, 0.09812394f, 0.00336500f, 
    0.00513916f, 0.06540202f, 0.05259290f, -0.04263708f, -0.41113541f, 0.03794673f, -0.11109949f, -0.14955476f, 
    -0.05455492f, -0.05173194f, 0.04984914f, 0.13930070f, -0.02433920f, -0.07715425f, 0.06398083f, -0.03224239f, 
    0.05460678f, -0.07881828f, 0.06297307f, 0.01275669f, 0.02289154f, -0.13541576f, -0.02491433f, 0.04924916f, 
    0.03513905f, 0.12895623f, -0.11589326f, -0.06209308f, -0.19291295f, 0.03099010f, 0.03332273f, 0.04770501f, 
    -0.03850850f, -0.00860971f, 0.06081259f, -0.01613087f, -0.06397906f, -0.01253664f, -0.12881333f, 0.04098165f, 
    -0.05273646f, 0.08620415f, 0.09415454f, 0.06320707f, -0.01095117f, -0.06512341f, -0.06521889f, 0.06369145f, 
    -0.00418413f, 0.06904051f, 0.09112794f, -0.05589042f, -0.08492690f, 0.09210189f, -0.00898444f, 0.04307427f, 
    0.10627884f, 0.04059673f, 0.01401107f, -0.07446069f, -0.01390771f, -0.05130563f, -0.15253891f, -0.01911804f, 
    -0.02160203f, 0.07247227f, 0.11196202f, 0.13157493f, 0.02473893f, 0.02030043f, 0.01345886f, 0.02576653f, 
    -0.01080103f, 0.00528493f, 0.03483123f, 0.00512732f, -0.06910387f, -0.08143906f, 0.01913460f, -0.00667163f, 
    0.05931420f, -0.07518511f, -0.01373832f, -0.08481098f, -0.02325279f, 0.21650322f, 0.13531180f, 0.10479491f, 
    0.04527229f, -0.10516638f, 0.03354784f, 0.00239016f, -0.01784139f, -0.00509388f, -0.07080688f, -0.05646534f, 
    -0.05217121f, 0.01326198f, 0.04932647f, 0.00063616f, -0.03219525f, 0.11692243f, 0.03544186f, 0.07690714f, 
    -0.14317663f, 0.13385174f, 0.10201779f, -0.04132926f, -0.07221370f, -0.05306662f, 0.00234149f, 0.04120718f, 
    -0.04573038f, -0.05787593f, 0.07555918f, -0.03221420f, 0.04159792f, -0.03855710f, 0.02271849f, 0.03935990f, 
    -0.00867790f, -0.00328841f, 0.03603079f, 0.00381752f, -0.38601756f, -0.02761420f, -0.29553556f, -0.16532749f, 
    0.03224432f, 0.11118074f, 0.14291596f, 0.08994026f, 0.01288429f, -0.02985350f, 0.02394598f, 0.07056646f, 
    -0.09562457f, 0.01267174f, -0.04041936f, -0.03882609f, 0.05575964f, 0.03948897f, -0.11423621f, 0.07650275f, 
    -0.09414209f, -0.07514692f, 0.02076182f, 0.10320608f, 0.10715926f, -0.00693111f, -0.11771654f, -0.00009251f, 
    0.02416953f, 0.02451598f, -0.01452213f, -0.06487122f, 0.02971870f, 0.09142963f, 0.00478489f, -0.10355160f, 
    0.03364376f, -0.24789368f, -0.10395865f, 0.07531238f, -0.06733980f, -0.02278671f, 0.08157711f, 0.05148102f, 
    0.15558088f, -0.00112338f, -0.01794865f, -0.04471374f, 0.01585045f, 0.02424199f, -0.00388131f, 0.06604986f, 
    0.04657098f, 0.10273021f, 0.05901533f, 0.05826894f, 0.02949171f, -0.00595589f, -0.20027488f, -0.04935082f, 
    -0.11372470f, 0.13843662f, -0.03350234f, -0.03884121f, -0.08522625f, -0.01312790f, -0.00659863f, -0.06235776f, 
    -0.03334185f, 0.06289791f, -0.00548188f, -0.05637707f, -0.08143146f, 0.01494202f, -0.07041206f, 0.00593029f, 
    0.03029223f, -0.03397029f, 0.08628207f, -0.06918360f, 0.03041687f, 0.01961484f, -0.11591126f, 0.07733364f, 
    0.21835130f, -0.10658743f, -0.11264704f, -0.03466716f, 0.13227488f, 0.02307900f, 0.03596324f, -0.06448435f, 
    -0.00142262f, 0.07368948f, 0.12986767f, -0.02269593f, 0.11660803f, -0.08161275f, -0.09112962f, -0.09769304f, 
    -0.03776110f, -0.19314922f, -0.08507525f, 0.09699211f, 0.05576913f, 0.01249857f, -0.01514209f, 0.04319001f, 
    0.02097891f, 0.01510179f, 0.05411154f, 0.00139601f, 0.02145757f, 0.14735609f, 0.02866254f, 0.07678745f, 
    0.05558163f, -0.01547640f, -0.05911649f, 0.03430891f, 0.05218755f, 0.06019144f, -0.00265686f, -0.05126068f, 
    0.08669524f, -0.11017967f, -0.05717394f, 0.08343039f, 0.09550812f, 0.00842244f, 0.01861886f, -0.10738670f, 
    -0.02433968f, 0.01650953f, 0.13956816f, -0.02727192f, 0.03713592f, 0.05303460f, -0.10089746f, -0.03706576f, 
    -0.21715425f, -0.05518707f, -0.09874632f, 0.06545208f, 0.01889228f, -0.03257605f, 0.00720555f, -0.02746669f, 
    0.00112211f, -0.03540330f, 0.13187478f, 0.00061617f, -0.01079499f, 0.00829666f, 0.05638720f, -0.00506141f, 
    -0.02196725f, -0.00344662f, 0.09392802f, -0.09630232f, -0.18307711f, -0.17787999f, 0.13043173f, 0.09152944f, 
    -0.09569267f, -0.08370059f, 0.00365842f, 0.07048664f, -0.04957466f, 0.06356399f, -0.00832607f, 0.10104890f, 
    0.00790782f, -0.04956458f, -0.00592113f, -0.02054205f, 0.00631195f, -0.06812750f, 0.01408973f, 0.06046962f, 
    0.22424820f, 0.04308848f, 0.00692896f, 0.13045961f, 0.03429871f, -0.08681300f, -0.10979605f, 0.01635689f, 
    -0.00542557f, 0.00791615f, 0.04640291f, -0.12002487f, 0.00023275f, 0.18230775f, 0.06844914f, 0.02983247f, 
    0.01999243f, -0.12401608f, -0.15920517f, 0.01116132f, -0.43650997f, 0.18580633f, -0.16529807f, 0.06470874f, 
    -0.05647139f, 0.00315506f, 0.03857335f, 0.00771040f, -0.01738787f, 0.00984595f, -0.00664732f, -0.00603680f, 
    -0.08618386f, 0.04920926f, -0.00231023f, 0.04331288f, -0.04126973f, -0.02418416f, 0.05046533f, -0.08620498f, 
    0.05640068f, 0.02584237f, -0.02671801f, 0.05926967f, 0.03306276f, -0.09210352f, 0.04389539f, -0.15059058f, 
    0.06528933f, 0.13676208f, 0.05534583f, -0.06785315f, 0.09831644f, 0.08626387f, 0.00309505f, 0.04435427f, 
    -0.02447953f, 0.09562022f, -0.02918008f, -0.01178402f, 0.00957104f, 0.10619909f, 0.09476817f, 0.03775047f, 
    -0.04526284f, -0.00107763f, -0.02208248f, -0.06157381f, -0.04142261f, -0.05249481f, 0.00465937f, 0.04773566f, 
    -0.09786033f, 0.00429559f, 0.08888424f, 0.00261948f, 0.06434849f, 0.14304174f, 0.01429575f, -0.06531484f, 
    -0.60200632f, -0.12372302f, -0.16867052f, -0.12267368f, 0.00780719f, -0.00326501f, 0.07526764f, 0.03177669f, 
    0.00345396f, -0.03038814f, 0.02380966f, 0.07729089f, 0.11283564f, -0.02606598f, 0.02736577f, 0.07757477f, 
    0.04053440f, -0.02062661f, -0.03030378f, -0.04122928f, 0.05374292f, 0.00869583f, -0.08574778f, 0.18864930f, 
    0.04787375f, 0.06947503f, -0.07894981f, -0.01104051f, -0.07507379f, 0.03498062f, -0.09069674f, -0.13520759f, 
    -0.05508962f, 0.06538165f, 0.05674567f, 0.01221860f, 0.02327235f, -0.10533319f, 0.11609104f, 0.03302729f, 
    -0.10497056f, 0.19138585f, -0.21352091f, -0.12402869f, 0.08687482f, 0.08396021f, 0.08492488f, 0.07700330f, 
    0.01186652f, -0.07158099f, 0.03708733f, -0.05193531f, 0.01252181f, -0.05885988f, 0.04705967f, -0.03731290f, 
    0.03297921f, -0.11478199f, 0.04058401f, -0.03603064f, 0.01883457f, 0.15506244f, 0.05086007f, -0.00473217f, 
    0.04244627f, -0.03487873f, -0.03662477f, -0.01494144f, 0.01501059f, 0.02266683f, -0.01312186f, -0.08034737f, 
    0.03603803f, 0.01348726f, 0.06377149f, 0.09214133f, -0.00925383f, 0.05251905f, -0.15648513f, 0.03887627f, 
    0.05104392f, 0.03531296f, 0.08229587f, 0.06593017f, 0.09444828f, -0.02931569f, -0.11446874f, -0.05271586f, 
    0.00120380f, -0.00761085f, -0.02842241f, 0.00063026f, 0.05833847f, 0.14376624f, 0.09354167f, -0.08718003f, 
    -0.08112096f, 0.01608837f, 0.06520043f, -0.07844695f, -0.08189396f, -0.00132752f, 0.14224753f, 0.19697087f, 
    -0.03871722f, 0.06231172f, 0.01548683f, 0.01829927f, 0.04334584f, 0.02989118f, -0.02092439f, 0.01773979f, 
    -0.00159199f, 0.03742099f, -0.03634083f, -0.03228883f, -0.05586538f, -0.07885105f, -0.08977999f, -0.01058792f, 
    0.06379560f, -0.00599492f, -0.00146507f, 0.10391433f, -0.01090356f, 0.04308458f, 0.01624776f, 0.05317089f, 
    -0.01665592f, -0.00107510f, 0.06263688f, -0.01209338f, 0.00245651f, -0.02889691f, -0.02453899f, 0.03321817f, 
    -0.04026589f, 0.08724172f, 0.05044130f, -0.02029956f, 0.07729343f, 0.09510399f, 0.04811705f, -0.15580347f, 
    -0.02679712f, -0.06328544f, -0.04121638f, 0.05612265f, -0.07030077f, 0.04397489f, 0.02313569f, 0.07860987f, 
    -0.00545393f, -0.00820868f, -0.08260910f, 0.02618461f, -0.01644242f, -0.04536385f, 0.10962761f, 0.11419959f, 
    0.07138493f, 0.13609906f, 0.03607837f, -0.17895336f, 0.00504311f, 0.01443138f, 0.02349977f, -0.01401364f, 
    -0.10758983f, 0.03024719f, -0.00205509f, 0.00972084f, -0.05171215f, 0.01575625f, 0.06137903f, 0.02614623f, 
    -0.07993092f, 0.06484190f, -0.01667367f, 0.05058384f, -0.15501207f, 0.18062894f, -0.15827550f, -0.01063798f, 
    0.00224469f, 0.20630658f, 0.01956973f, 0.10662396f, -0.03706020f, 0.04517994f, -0.01270271f, 0.05286210f, 
    0.03196041f, -0.11305252f, -0.07554373f, -0.09468406f, -0.03034456f, 0.04001927f, -0.11213415f, -0.02350879f, 
    -0.43249300f, -0.22680727f, -0.08826479f, -0.09398267f, 0.06812294f, 0.10178135f, -0.02036615f, -0.04938398f, 
    0.03131096f, -0.06862765f, -0.00334874f, -0.02389648f, 0.02709511f, 0.05682059f, 0.00502689f, -0.07790574f, 
    0.01969325f, -0.09360631f, -0.03363534f, 0.00187216f, -0.01877084f, -0.16686289f, 0.17275475f, 0.15237086f, 
    -0.09776759f, 0.06916556f, 0.04117236f, -0.04517947f, -0.00540219f, -0.07237884f, 0.00349894f, -0.01199736f, 
    0.01073304f, -0.06863939f, 0.06935898f, 0.01699098f, 0.02411254f, -0.02059382f, 0.03563720f, -0.08727546f, 
    -0.38057905f, -0.05437424f, 0.16354829f, 0.08307042f, -0.32884502f, 0.14798674f, 0.05815034f, 0.04836101f, 
    -0.21302241f, 0.03386509f, 0.06070412f, -0.13688555f, -0.07308761f, -0.08250415f, -0.08409303f, 0.05263063f, 
    0.03049984f, 0.00536626f, -0.02179192f, -0.05370694f, -0.28614205f, -0.06084724f, 0.09240776f, 0.11169671f, 
    -0.06249482f, -0.04386529f, -0.09498899f, -0.03588507f, 0.05291634f, -0.02937231f, 0.03156838f, -0.10171000f, 
    -0.10286377f, 0.03320484f, -0.03301962f, -0.01764918f, -0.04977446f, -0.03734991f, -0.13902517f, -0.04897650f, 
    -0.01659621f, -0.01398016f, 0.03951846f, 0.02990987f, 0.10183637f, 0.00565193f, -0.02321193f, 0.07821803f, 
    -0.02149326f, 0.06137316f, 0.02699271f, -0.04980704f, 0.04772908f, -0.05079252f, -0.03512732f, 0.01461197f, 
    -0.13648036f, 0.05467771f, 0.08523128f, 0.03620573f, 0.06948709f, 0.08576500f, -0.05918666f, -0.03619276f, 
    0.07421827f, -0.01967447f, -0.17198192f, -0.00827817f, 0.00995442f, 0.03229583f, -0.00304165f, -0.10366201f, 
    -0.03924445f, 0.03927027f, 0.04683257f, -0.04065301f, -0.00857989f, 0.02933214f, -0.06786039f, -0.01798514f, 
    -0.05498004f, -0.12644680f, 0.21432212f, 0.27758870f, -0.30701354f, 0.01743086f, -0.01862305f, -0.07359347f, 
    0.05856797f, -0.07411540f, -0.11547725f, 0.02159907f, 0.01681353f, -0.05588346f, 0.12099256f, -0.03983233f, 
    -0.09751264f, -0.11772520f, 0.07574818f, -0.05672795f, -0.01670483f, -0.05045006f, 0.02481425f, 0.13035423f, 
    -0.15704985f, -0.10456266f, 0.09710491f, -0.04226171f, -0.00569463f, -0.00148070f, -0.04290026f, 0.00726026f, 
    0.02343652f, 0.05322202f, 0.11452968f, -0.04830809f, -0.04474963f, 0.08771889f, 0.07724328f, 0.01587478f, 
    -0.08716623f, -0.02636697f, 0.07019170f, -0.00275234f, 0.06908172f, -0.06796550f, 0.01540277f, -0.02597720f, 
    0.05806478f, 0.06948423f, 0.03860051f, -0.05498961f, -0.03003720f, -0.07080431f, 0.01309661f, 0.04195092f, 
    0.08155365f, 0.06142366f, -0.06448491f, -0.04782108f, 0.06643729f, 0.06030453f, 0.06911739f, 0.03646535f, 
    -0.10280485f, -0.05538178f, 0.00126694f, 0.04247234f, 0.04188419f, 0.11791090f, -0.02588333f, -0.05068107f, 
    0.04853479f, 0.02788029f, 0.04608183f, 0.04376619f, 0.02160523f, -0.02014207f, 0.03979275f, 0.08368870f, 
    -0.05914492f, -0.18257137f, -0.05786712f, 0.02542487f, 0.13916023f, 0.01060982f, 0.00306439f, -0.02186847f, 
    -0.01779713f, 0.01815863f, 0.08049656f, -0.00610188f, 0.02508681f, 0.00942051f, 0.00319322f, -0.17039359f, 
    -0.00747011f, -0.00079542f, -0.03481901f, -0.05890292f, -0.41566229f, -0.10173366f, -0.09080461f, -0.02245027f, 
    0.02415380f, 0.03752957f, -0.08389043f, -0.00128060f, 0.00118590f, -0.01916541f, 0.00202735f, 0.04389025f, 
    0.05518002f, -0.01010545f, 0.03455744f, -0.01451927f, 0.05850936f, -0.08466425f, 0.06890713f, 0.04115216f, 
    -0.10469868f, -0.12160083f, -0.02456271f, 0.10361880f, -0.40332675f, -0.01979778f, -0.06550014f, -0.05691594f, 
    0.06994004f, -0.04775898f, 0.05597322f, 0.10020213f, 0.02853174f, 0.04256826f, -0.07192688f, -0.03954745f, 
    -0.00263965f, 0.11246095f, -0.08854667f, -0.05735151f, -0.26632980f, -0.00784291f, 0.09407243f, -0.03880981f, 
    -0.06731683f, 0.11558995f, 0.16505937f, 0.00604102f, -0.06083876f, 0.10694703f, -0.04582953f, 0.07225589f, 
    0.04608364f, -0.12745969f, -0.08879092f, -0.09063550f, 0.11814514f, -0.01961030f, 0.03599833f, -0.07532868f, 
    0.05891741f, -0.03650262f, -0.10862514f, 0.01638870f, -0.13116544f, -0.01366638f, -0.00965467f, 0.01271794f, 
    0.07679936f, -0.06619954f, -0.02053325f, 0.09411106f, -0.01928452f, 0.01526402f, 0.10738144f, -0.11155873f, 
    0.01253929f, 0.03514260f, -0.03168482f, -0.04633041f, -0.60040230f, -0.22484197f, -0.33641678f, -0.07927677f, 
    0.01355598f, 0.15682709f, 0.13557899f, 0.06226518f, -0.04977804f, -0.11412466f, -0.01063947f, 0.01684092f, 
    0.04212471f, 0.02697993f, -0.08858017f, 0.09640861f, 0.00070966f, -0.01527472f, -0.16105205f, 0.04426643f, 
    -0.03793294f, -0.12748782f, -0.01099490f, 0.00341607f, 0.21155144f, -0.02969965f, -0.08730686f, 0.05793841f, 
    -0.00059807f, 0.00478141f, -0.04817834f, -0.01312485f, 0.11140827f, 0.16366595f, 0.04440244f, -0.06345150f, 
    -0.03216232f, -0.02222954f, -0.06738172f, -0.01215619f, -0.00661409f, 0.05065320f, -0.07044388f, 0.16207024f, 
    0.19349645f, 0.09361669f, -0.00445987f, 0.00212766f, 0.09957821f, 0.04737258f, 0.04080621f, -0.01713754f, 
    0.05849306f, 0.06070749f, 0.11418744f, -0.01096811f, 0.05210430f, -0.01305202f, -0.11176063f, -0.11369260f, 
    -0.02355823f, 0.13990296f, -0.16148718f, 0.00739254f, 0.02021462f, 0.05565384f, 0.05477577f, 0.04332975f, 
    -0.00247597f, -0.15798974f, 0.02074696f, 0.02630250f, -0.03522236f, -0.09925465f, -0.03609733f, 0.00780576f, 
    -0.01728585f, -0.00227163f, 0.08842624f, 0.01426442f, -0.12457142f, 0.03420943f, -0.06987990f, -0.11411271f, 
    -0.10087264f, 0.06767422f, -0.02268507f, 0.12562740f, 0.01379130f, -0.10787365f, 0.06403127f, 0.00038019f, 
    -0.06628721f, -0.06161195f, 0.01710233f, 0.08804024f, 0.03394455f, 0.06787897f, -0.05691302f, 0.01359364f, 
    -0.18870425f, 0.01819577f, 0.07589130f, 0.01266919f, -0.02288415f, -0.26182711f, 0.11409394f, 0.00666799f, 
    -0.15729842f, 0.04870113f, 0.10067965f, 0.02712385f, 0.04519749f, 0.03191434f, -0.12856512f, 0.04554170f, 
    0.00773239f, -0.15572850f, 0.09760203f, 0.12393975f, -0.34695414f, -0.20445421f, 0.02153916f, 0.10402801f, 
    -0.16005789f, -0.14515164f, 0.08015931f, 0.07430431f, -0.08178259f, 0.03336680f, -0.09159619f, -0.00649280f, 
    0.07502616f, -0.04348994f, -0.12174003f, -0.03876612f, 0.04510185f, -0.12808546f, 0.01397501f, 0.03906878f, 
    -0.26093081f, -0.01392555f, 0.00394940f, -0.00181264f, -0.04120944f, 0.06706744f, -0.13049708f, 0.03237206f, 
    -0.00937624f, -0.01184013f, 0.03642110f, -0.02756440f, -0.12045869f, -0.04680809f, 0.05045703f, 0.06732019f, 
    0.04196464f, 0.00884547f, -0.00276370f, 0.09356782f, 0.03678901f, 0.06170097f, -0.10717671f, 0.07405216f, 
    0.10697665f, -0.10371715f, -0.03276311f, 0.03883040f, 0.03533471f, 0.07377569f, -0.00571774f, 0.11956953f, 
    0.05942460f, 0.06507514f, 0.04232333f, 0.01419149f, 0.03167107f, -0.13683498f, 0.10399731f, -0.08706621f, 
    -0.14777035f, -0.09653193f, -0.16588946f, -0.09250728f, -0.01730604f, 0.01510952f, 0.03123815f, -0.08366051f, 
    0.05325576f, 0.13891216f, 0.04427655f, 0.17246476f, 0.18381566f, -0.06988857f, 0.00728195f, 0.00386402f, 
    0.02022019f, -0.02221154f, 0.08332661f, -0.00487476f, 0.00119040f, -0.03204042f, -0.02166709f, 0.03964200f, 
    -0.13676891f, -0.06555647f, 0.10387596f, 0.03634044f, 0.02212340f, -0.02848935f, -0.01548503f, 0.04626928f, 
    0.02738902f, -0.01141914f, 0.07241577f, -0.11643130f, -0.13368037f, 0.06503224f, 0.06294044f, 0.01480347f, 
    -0.14047086f, 0.12695163f, -0.21160766f, 0.14562975f, -0.08505354f, -0.13056582f, -0.00798908f, -0.03244184f, 
    -0.00348458f, -0.07432672f, 0.01227415f, 0.06925860f, -0.00264740f, -0.01039980f, -0.01031025f, -0.08706126f, 
    -0.02513118f, -0.01987250f, -0.13519755f, -0.01724136f, -0.10617471f, -0.23117138f, -0.00092779f, -0.31652781f, 
    0.10134013f, -0.15243752f, 0.00901553f, -0.09140646f, 0.08304368f, -0.05674405f, -0.06369145f, 0.05918920f, 
    -0.04383568f, 0.10008916f, 0.08272473f, 0.00950729f, 0.06709589f, -0.04446497f, -0.04781454f, -0.00944358f, 
    -0.16572261f, 0.17102462f, 0.18323360f, 0.02825281f, -0.19914375f, -0.00038012f, -0.05257789f, -0.04039054f, 
    -0.03195336f, 0.01903745f, -0.00649949f, -0.01720416f, 0.12240284f, 0.05869922f, 0.10902069f, 0.11536590f, 
    0.00493389f, -0.05219218f, -0.00753375f, -0.11681523f, 0.01989466f, -0.12362089f, -0.10354685f, 0.00664606f, 
    -0.07730626f, -0.05857339f, 0.01722044f, 0.01522427f, -0.01069695f, -0.12167254f, 0.01829463f, 0.03540609f, 
    0.02675956f, -0.03691199f, 0.16425101f, 0.07923137f, -0.05811917f, 0.05385610f, -0.02313056f, -0.00616552f, 
    0.20450045f, -0.19401093f, -0.03654318f, 0.10102508f, -0.03287265f, -0.05421260f, -0.02391745f, 0.06772473f, 
    0.05619092f, 0.07031536f, 0.00725899f, 0.01177244f, -0.09130348f, -0.01091208f, 0.01856562f, -0.01680671f, 
    -0.03079389f, 0.00793760f, -0.06895837f, -0.03045327f, -0.16906209f, -0.19113620f, -0.08175915f, 0.09856733f, 
    0.06998912f, -0.07730427f, 0.10463617f, -0.02785694f, -0.01152820f, 0.08090295f, -0.10602796f, 0.00685238f, 
    -0.01780145f, -0.09357601f, -0.08292335f, -0.04597550f, -0.06049353f, -0.00195977f, -0.11617478f, -0.06422116f, 
    0.04153840f, -0.33929259f, -0.02266973f, -0.07663437f, 0.00027403f, -0.04325527f, 0.06012881f, -0.02502564f, 
    0.09162094f, 0.06278534f, -0.04362659f, -0.02390992f, -0.00715626f, 0.01112847f, 0.07386988f, -0.05010010f, 
    -0.00841131f, -0.01048043f, -0.09892397f, -0.07484162f, -0.03908568f, -0.06044388f, -0.25235638f, -0.27818981f, 
    0.19347006f, -0.07279900f, 0.03963107f, -0.01302462f, -0.05305871f, -0.09374347f, 0.01027754f, -0.06619273f, 
    -0.11331196f, 0.00805167f, -0.02849735f, 0.02222269f, -0.13083209f, 0.21204995f, -0.00739078f, 0.14655121f, 
    -0.05164869f, 0.28151608f, 0.06481867f, 0.02864586f, -0.14621678f, -0.01295473f, -0.15331258f, 0.03191322f, 
    0.02722866f, 0.05280464f, 0.04489698f, 0.01971857f, -0.02890130f, -0.05845314f, -0.09168006f, -0.03262845f, 
    -0.05156268f, -0.12032231f, 0.04741924f, -0.03676645f, 0.15182111f, -0.23396714f, -0.06594291f, 0.00336724f, 
    0.05859029f, -0.01059860f, 0.11819102f, -0.12244479f, -0.06074882f, -0.03749789f, 0.00548478f, -0.00637599f, 
    0.04800694f, 0.07302479f, 0.04161384f, -0.03040827f, 0.04103263f, 0.06576667f, -0.15515499f, 0.09225576f, 
    0.07795876f, -0.40076631f, -0.06558488f, 0.05934797f, -0.03452417f, 0.06898776f, 0.04360120f, 0.01092960f, 
    -0.01650829f, -0.02272905f, -0.02412488f, 0.03277473f, 0.11455011f, -0.00014476f, 0.12492578f, 0.01524781f, 
    0.05781589f, 0.03564063f, -0.02481904f, -0.10605995f, -0.04047685f, -0.03883261f, -0.04696269f, -0.12557526f, 
    0.12026190f, 0.00704953f, 0.03074456f, -0.01063370f, -0.11155554f, -0.07947859f, -0.06770668f, -0.07731571f, 
    -0.02466032f, -0.04506917f, 0.02515038f, -0.01160936f, -0.05380733f, 0.03120015f, 0.09098351f, 0.02360060f, 
    -0.08653162f, 0.00906448f, -0.04303144f, 0.05033338f, -0.00767247f, -0.01217537f, 0.01091555f, -0.00410590f, 
    0.10527600f, 0.01369933f, 0.00026590f, -0.05231063f, 0.05642994f, 0.06176681f, 0.07303341f, 0.02206698f, 
    0.04017933f, -0.02481344f, -0.06207735f, -0.00451195f, 0.14498739f, -0.34997445f, 0.02969389f, -0.00791658f, 
    0.30767509f, 0.03364073f, -0.00384648f, -0.10030271f, -0.01259947f, -0.01981048f, -0.04776191f, -0.06007627f, 
    0.11131629f, 0.08951544f, 0.08913127f, -0.00156009f, -0.00042146f, -0.17422658f, -0.13355669f, -0.17765915f, 
    0.05125882f, -0.16410042f, -0.03036606f, 0.08156753f, -0.03066658f, -0.05747826f, 0.01456338f, -0.02928083f, 
    0.04790644f, 0.05088406f, -0.06887095f, 0.02965014f, 0.00445509f, 0.05681444f, 0.00108730f, -0.00499943f, 
    0.00377116f, 0.00100064f, -0.14253886f, 0.01925369f, -0.24347204f, -0.03482684f, -0.04880650f, -0.42899254f, 
    0.21306270f, 0.03803549f, -0.09594397f, 0.08382601f, -0.09847290f, 0.02151040f, 0.01046177f, -0.08970320f, 
    0.10845393f, 0.02928714f, -0.01193919f, 0.01237000f, -0.01134262f, -0.07620905f, 0.05264618f, 0.07932299f, 
    -0.13456228f, 0.01407320f, -0.02793657f, -0.05507307f, 0.12886727f, -0.00182986f, 0.05242161f, -0.00924279f, 
    -0.08281747f, -0.00554724f, -0.01509077f, -0.04714654f, 0.08631917f, -0.01896508f, -0.11351217f, 0.06323534f, 
    0.02938637f, 0.14523484f, 0.09164291f, -0.04580557f, -0.12844892f, -0.00787322f, -0.21035074f, -0.13013993f, 
    0.02848998f, 0.00597774f, 0.07951256f, 0.01982393f, -0.05741550f, -0.02464960f, -0.00388295f, -0.08977532f, 
    -0.02872062f, -0.01057456f, 0.04503036f, -0.04374850f, 0.02646011f, 0.05875950f, 0.04501462f, 0.00242483f, 
    0.22918904f, -0.16972303f, -0.25553444f, 0.20674270f, -0.06496451f, -0.09617871f, 0.15217869f, -0.09922315f, 
    0.04551523f, 0.02090323f, 0.04709827f, 0.02348925f, -0.05783945f, -0.02720783f, 0.05440021f, -0.07577617f, 
    -0.02358172f, 0.14105950f, -0.15369000f, 0.08318995f, 0.02428316f, 0.13958780f, -0.05461304f, -0.11801884f, 
    -0.07159367f, 0.01972562f, -0.00665487f, 0.12056246f, 0.00807883f, 0.00654228f, 0.01166624f, 0.01904023f, 
    -0.10402193f, -0.08033908f, -0.06504799f, 0.03545884f, -0.05051660f, 0.17472397f, 0.05564439f, 0.09616918f, 
    -0.04960833f, 0.02000907f, -0.00088309f, -0.13289593f, 0.01745492f, 0.07290172f, 0.01930844f, 0.05488859f, 
    -0.10903318f, -0.04747399f, 0.06279926f, -0.07209805f, -0.01144050f, -0.07147268f, 0.01836916f, -0.07749652f, 
    -0.12061892f, 0.06645735f, 0.02582565f, -0.13823476f, 0.07629161f, 0.14027676f, 0.04453953f, -0.02703858f, 
    -0.08851294f, 0.05549296f, 0.02758329f, -0.01793318f, -0.04424035f, 0.00504763f, 0.01979654f, 0.01779550f, 
    -0.05358583f, 0.03173849f, -0.06023663f, 0.06162611f, -0.02486376f, 0.01170573f, 0.01799292f, 0.05603223f, 
    0.02243497f, -0.23405112f, -0.07513057f, -0.23012519f, 0.39338166f, -0.00129698f, -0.05510320f, 0.04253383f, 
    0.04169880f, 0.04185450f, -0.11621634f, -0.04722031f, -0.00431917f, -0.00476234f, 0.01919684f, -0.05509622f, 
    -0.01495333f, 0.10079837f, -0.12345099f, 0.13386434f, 0.14103003f, -0.03394198f, -0.02098895f, 0.08753713f, 
    0.16639693f, -0.02353534f, 0.06219755f, -0.04113276f, 0.04622359f, 0.00852530f, -0.03863423f, 0.01680818f, 
    -0.02687673f, 0.05465630f, -0.12112454f, 0.02216258f, 0.05763800f, -0.03882275f, 0.04314468f, 0.01117387f, 
    -0.03689315f, -0.01150077f, 0.05134280f, -0.06090793f, 0.01309627f, 0.12408362f, 0.04230287f, -0.02626102f, 
    0.00953257f, -0.09060247f, -0.09743229f, -0.00644660f, -0.10033965f, -0.03502659f, -0.19044115f, 0.04841551f, 
    0.07870226f, 0.08221424f, 0.10495763f, -0.01959602f, 0.22084600f, -0.11653486f, -0.06392567f, -0.10334342f, 
    0.24265432f, -0.03352350f, -0.06100826f, 0.04388180f, 0.05188145f, -0.08948516f, -0.14238213f, -0.00545722f, 
    0.04826146f, -0.05565820f, 0.04360668f, -0.07577547f, -0.06675930f, 0.11673260f, -0.14048952f, 0.15061513f, 
    -0.06945536f, 0.10538480f, 0.04634349f, -0.01157459f, -0.00626432f, 0.03920890f, 0.09051348f, 0.07454289f, 
    0.02081241f, -0.15379025f, -0.01774649f, -0.00202756f, -0.07350627f, 0.01030788f, -0.05467578f, 0.05542281f, 
    0.02142322f, -0.13395762f, 0.10868716f, -0.01276162f, -0.30349761f, 0.20033255f, -0.02024910f, 0.12503561f, 
    -0.02225438f, -0.11716309f, -0.07836850f, 0.01200016f, 0.11552026f, 0.00947515f, -0.02681478f, -0.02921245f, 
    0.03729463f, -0.04740087f, 0.03390325f, -0.00908316f, 0.00066101f, -0.00547532f, -0.01407352f, 0.05606403f, 
    0.15730193f, -0.03364891f, -0.09482341f, -0.19072905f, 0.07384997f, -0.01339417f, -0.00162094f, 0.00592494f, 
    -0.12468690f, -0.11658727f, 0.04364090f, -0.01150995f, -0.15164560f, -0.01884480f, 0.08993825f, -0.10208625f, 
    -0.04884370f, -0.03198093f, -0.08803895f, 0.06578103f, -0.15002407f, 0.23026113f, -0.14219132f, 0.10832103f, 
    -0.54820383f, -0.01000341f, 0.06525760f, -0.05980740f, 0.07998881f, -0.02274129f, 0.11685055f, 0.19027323f, 
    0.02041378f, 0.00701373f, -0.08686966f, 0.01720636f, -0.10517554f, 0.03992872f, -0.01816518f, 0.02272419f, 
    0.20175193f, -0.23504511f, -0.02927933f, -0.14744286f, -0.00935802f, -0.00263869f, 0.09864096f, -0.05289647f, 
    -0.00086011f, -0.02823975f, 0.04158101f, 0.01433468f, 0.01622101f, 0.00797220f, 0.00231791f, 0.05000343f, 
    -0.02300489f, 0.02437613f, -0.09730342f, 0.12914722f, 0.17815097f, 0.05842640f, -0.01414767f, -0.05205892f, 
    -0.05485234f, -0.08983937f, 0.05661907f, 0.05980808f, -0.04095872f, 0.02994320f, 0.13558435f, 0.01862661f, 
    -0.02844996f, -0.02083047f, 0.07888610f, 0.06939038f, -0.04326290f, 0.03004633f, 0.03437146f, 0.03839411f, 
    -0.21424229f, 0.34137991f, 0.02926311f, 0.00727270f, -0.34575182f, 0.05167860f, 0.04472283f, 0.05730064f, 
    0.02390284f, 0.07531040f, 0.02872367f, 0.00471304f, -0.02053953f, -0.15048596f, 0.00434574f, 0.03316236f, 
    -0.05623979f, -0.06136493f, 0.05960697f, 0.02792033f, -0.10382410f, 0.00033174f, 0.13920411f, 0.08573589f, 
    0.15088855f, -0.07248706f, 0.05372348f, -0.02594023f, -0.11882620f, -0.01930066f, 0.02747236f, 0.01330526f, 
    0.00731231f, 0.05942849f, 0.04453734f, 0.03601566f, -0.06289683f, 0.00926944f, 0.01517063f, 0.06233190f, 
    -0.35940903f, 0.14344500f, -0.03488532f, 0.09533794f, 0.10439087f, -0.07439882f, -0.02172090f, 0.01997146f, 
    0.01694155f, -0.03398490f, -0.04420800f, 0.06371632f, 0.04795095f, 0.06509447f, 0.03229859f, 0.02264316f, 
    0.00911549f, 0.01249105f, -0.00291534f, -0.06534155f, 0.03585472f, 0.05633068f, -0.11450548f, 0.15500610f, 
    0.01730550f, -0.09782844f, 0.04998516f, -0.01379123f, -0.03157211f, -0.00783445f, 0.04228562f, 0.06173958f, 
    0.01003338f, -0.03092838f, 0.00242772f, 0.02284519f, -0.04928435f, 0.07640630f, -0.03531287f, -0.02240304f, 
    -0.19770157f, -0.04122008f, -0.07390991f, -0.05471625f, 0.14977682f, 0.06036204f, 0.03335198f, 0.04863092f, 
    -0.03341536f, -0.05246779f, 0.05503568f, -0.13082798f, -0.02555585f, 0.06294319f, -0.07474628f, 0.12135801f, 
    -0.00216441f, -0.14212023f, 0.01474520f, -0.03716763f, -0.18481186f, -0.13692440f, 0.00106724f, -0.44891691f, 
    0.01053184f, -0.00542747f, -0.02834258f, 0.06765541f, -0.00033417f, 0.02077722f, -0.06619662f, -0.07304412f, 
    -0.09795161f, -0.10069581f, 0.01318863f, -0.00848301f, -0.06694362f, 0.04204757f, 0.12851407f, -0.00118035f, 
    0.04076232f, 0.01993066f, -0.06299308f, -0.23964770f, 0.10143584f, 0.01155626f, 0.08090652f, 0.04506082f, 
    -0.05792756f, -0.00811745f, 0.01912941f, -0.05902754f, 0.05218515f, -0.04029575f, -0.05414604f, 0.02345037f, 
    0.02817417f, 0.04566665f, 0.04165570f, 0.15247910f, -0.01565638f, -0.00431149f, -0.03769936f, 0.10334493f, 
    -0.11066962f, -0.07474664f, 0.02219423f, 0.11960203f, 0.07439646f, -0.03097599f, 0.04367187f, -0.01125832f, 
    0.06450588f, 0.02462307f, -0.01817464f, 0.00156535f, 0.02258477f, 0.00978082f, -0.16251865f, 0.11837088f, 
    0.17457971f, -0.56628740f, -0.28022727f, -0.02767972f, -0.13431552f, -0.04042668f, 0.14793058f, -0.03510117f, 
    0.04712100f, 0.03659289f, -0.05956675f, 0.12176535f, -0.00808793f, 0.09424328f, 0.09748098f, 0.09489883f, 
    -0.02882614f, -0.00035039f, -0.03974071f, 0.03089479f, 0.37971622f, -0.04625509f, 0.15198244f, 0.12475514f, 
    0.24179636f, -0.07317971f, -0.02108674f, 0.00729508f, -0.03250675f, -0.00077142f, 0.01681449f, -0.01225490f, 
    0.12205502f, -0.04999821f, 0.09904057f, 0.01869713f, 0.03993936f, -0.02590694f, 0.00057156f, -0.08046059f, 
    -0.24255282f, 0.10295824f, 0.12362796f, 0.13412431f, -0.10401437f, 0.00571449f, 0.00953557f, 0.02047488f, 
    0.05082551f, 0.00427371f, -0.11124867f, -0.03800628f, 0.08053415f, 0.09173805f, -0.06468197f, 0.02678207f, 
    0.00828688f, -0.00731609f, -0.02099193f, -0.11271710f, 0.08385565f, 0.10009941f, 0.01415707f, -0.08685462f, 
    -0.07252417f, 0.06383096f, 0.05425888f, 0.04596294f, 0.11791168f, 0.00906829f, 0.07734232f, -0.01898907f, 
    0.04030363f, 0.03543780f, -0.08108266f, -0.01465253f, 0.01699727f, 0.10254753f, 0.00445418f, 0.03183676f, 
    -0.08274025f, -0.00383382f, 0.03748290f, -0.01168351f, 0.22651768f, -0.03811986f, 0.15551686f, 0.10456546f, 
    0.10639592f, -0.05159000f, 0.02316529f, 0.00200974f, 0.02036866f, 0.01764818f, -0.11221071f, 0.10470144f, 
    -0.01055072f, 0.13959506f, 0.06404926f, 0.04429735f, -0.10433463f, 0.23966937f, 0.10809828f, 0.08022365f, 
    -0.29674485f, 0.08144833f, -0.06363026f, 0.03165146f, -0.01486084f, 0.00969292f, -0.01494870f, 0.02703786f, 
    -0.03465678f, 0.04746559f, -0.10244313f, 0.03357839f, -0.02051497f, -0.07830955f, -0.03217319f, -0.07788341f, 
    0.24840142f, 0.18934405f, -0.01240910f, 0.01047036f, 0.04600773f, 0.00698801f, -0.04609038f, -0.01436037f, 
    -0.06228461f, -0.05549828f, -0.03365350f, -0.04353782f, 0.04757192f, 0.01801387f, -0.03602746f, -0.03428617f, 
    0.04135787f, 0.04831344f, 0.02264901f, 0.03900677f, -0.01331701f, 0.14588834f, 0.17601226f, -0.00271066f, 
    -0.08951540f, 0.09068723f, -0.03506840f, 0.01817025f, 0.02126029f, -0.05427669f, 0.02188831f, -0.02264848f, 
    -0.04430882f, -0.00071016f, -0.06483454f, 0.08459347f, -0.08985801f, -0.00578032f, 0.00366432f, -0.08541542f, 
    -0.05216174f, -0.23557907f, -0.09674397f, 0.00125499f, 0.11212222f, -0.01332662f, 0.06147225f, -0.01734740f, 
    0.03172430f, -0.09847204f, -0.01302584f, -0.03134222f, -0.06520291f, 0.02033718f, -0.06075515f, 0.05782733f, 
    0.02897763f, 0.07948177f, 0.10848144f, 0.08834069f, 0.02364079f, -0.08205546f, 0.07934291f, -0.17748715f, 
    0.12107359f, -0.04280201f, 0.00943366f, -0.02870064f, -0.05228813f, -0.07060671f, 0.05140660f, -0.09903285f, 
    0.02683833f, 0.03642293f, -0.12637311f, -0.07402391f, -0.02490239f, 0.03468456f, 0.06339005f, 0.03129867f, 
    0.22914906f, -0.22399086f, 0.07860209f, 0.07616565f, 0.11844515f, 0.04060712f, -0.06403759f, 0.05461432f, 
    0.02955520f, -0.03411346f, 0.01691889f, -0.02146017f, -0.11860567f, -0.15317798f, 0.10888892f, -0.13483138f, 
    0.07677725f, 0.10955431f, 0.05052109f, -0.02052906f, -0.01380741f, -0.01582147f, -0.07512882f, -0.32906714f, 
    0.08250992f, -0.13725950f, -0.11174952f, -0.04312525f, 0.00391941f, -0.07330352f, 0.05541439f, 0.01327920f, 
    -0.00801917f, 0.07788820f, -0.01317657f, 0.10981842f, 0.00512175f, -0.01043770f, 0.07164924f, -0.03054966f, 
    0.13792047f, -0.22055373f, 0.01730482f, -0.01221720f, -0.01734491f, 0.12681611f, 0.00278503f, 0.00620526f, 
    -0.06010311f, -0.00632525f, -0.05143697f, -0.04341159f, 0.03365288f, -0.02311879f, -0.04373452f, 0.03293951f, 
    0.02690542f, 0.10029151f, 0.07516460f, 0.00561936f, -0.29460451f, -0.09420645f, 0.02742390f, -0.28052840f, 
    0.05938218f, -0.00887905f, -0.03534143f, 0.02651431f, -0.16342899f, 0.10290238f, 0.02814140f, -0.05574800f, 
    0.04911756f, 0.08316312f, 0.00253909f, -0.06126589f, -0.02947539f, -0.06696407f, 0.07848985f, 0.02090146f, 
    -0.20436625f, 0.10903186f, -0.16917551f, 0.01159225f, -0.21184264f, -0.00552676f, 0.10869148f, -0.00596899f, 
    0.06954233f, -0.00126722f, -0.02678794f, -0.03631722f, 0.01889626f, 0.02973300f, -0.04006341f, 0.03858938f, 
    -0.02248193f, -0.00303003f, 0.04763238f, 0.02708564f, 0.01364852f, 0.02283748f, -0.03737864f, -0.14425008f, 
    -0.00025267f, -0.01172916f, 0.02311760f, 0.03885238f, 0.00705085f, 0.03600422f, -0.04289370f, -0.00526097f, 
    -0.03143087f, -0.10203214f, 0.02629982f, 0.07660788f, -0.12281906f, 0.04084880f, 0.10595407f, 0.07102189f, 
    0.05615611f, -0.40621537f, 0.00986650f, -0.16502878f, 0.05050159f, 0.00828363f, 0.06461292f, -0.01474457f, 
    -0.05120629f, 0.00193948f, 0.01745697f, -0.04218336f, 0.10619488f, 0.10487293f, -0.02334297f, 0.03422216f, 
    -0.01220006f, -0.05786797f, -0.09516310f, 0.06912865f, 0.01066005f, -0.38224483f, -0.04569527f, -0.05282572f, 
    -0.03301447f, -0.09226801f, 0.04109815f, -0.02337548f, -0.02077955f, 0.07609496f, -0.08146921f, 0.09621886f, 
    0.03791637f, 0.08871591f, 0.03874378f, -0.05735344f, -0.02733662f, -0.04432653f, -0.02127635f, -0.01129879f, 
    -0.10434409f, 0.10936891f, 0.06631470f, 0.15933590f, 0.08463658f, -0.07590631f, -0.03397432f, -0.00417142f, 
    0.03594555f, -0.07191010f, -0.15502883f, 0.03124643f, -0.09075877f, -0.03033619f, -0.03140761f, 0.02211031f, 
    -0.05169577f, 0.10557466f, -0.13768938f, 0.02563563f, 0.05548025f, 0.07863553f, 0.10911856f, 0.13211854f, 
    0.20832872f, -0.00989238f, -0.02872638f, -0.01517099f, 0.05525431f, -0.11986117f, -0.02973346f, 0.02990739f, 
    -0.07646388f, 0.03443706f, -0.02735127f, 0.07396465f, 0.09062862f, 0.03885067f, 0.03600628f, -0.00162790f, 
    0.35213608f, -0.04530389f, 0.10287596f, -0.01275744f, 0.19938773f, 0.03114944f, -0.01337033f, -0.06314775f, 
    0.02292694f, 0.01621559f, -0.09135386f, -0.00905888f, 0.09657121f, -0.07755920f, 0.00048461f, -0.14992931f, 
    0.03556725f, 0.01422485f, -0.01342031f, -0.06325965f, 0.05349459f, -0.06185126f, -0.11158518f, -0.05930449f, 
    -0.00115072f, 0.07757305f, 0.03305453f, -0.03381788f, -0.16205344f, -0.09014194f, -0.00977941f, -0.13886607f, 
    -0.04118921f, -0.02540284f, -0.03664758f, -0.03694839f, -0.10918026f, 0.17338392f, -0.09393647f, 0.07573199f, 
    0.04335446f, -0.13405600f, -0.04301838f, -0.14950313f, 0.09595299f, -0.04182375f, 0.03707097f, 0.00287532f, 
    -0.03507997f, -0.11497864f, 0.01564863f, -0.11049463f, -0.05812484f, 0.01934154f, 0.00213741f, -0.05131196f, 
    0.05052467f, 0.05129372f, 0.01019641f, 0.00247823f, -0.04775297f, 0.08860605f, 0.15439452f, 0.07040725f, 
    -0.27263442f, 0.12627248f, -0.02346501f, 0.10388813f, -0.06539562f, 0.04615612f, -0.14919993f, 0.00032895f, 
    0.00538191f, 0.13791643f, -0.01387318f, 0.11229412f, 0.00959642f, -0.04936684f, 0.01028444f, -0.06020638f, 
    -0.37048811f, 0.05964815f, 0.00612822f, -0.15364392f, -0.15729696f, -0.01756986f, -0.03707489f, 0.01983895f, 
    0.00842947f, -0.07952312f, -0.04322603f, -0.00697544f, -0.03090780f, -0.02919783f, 0.02705012f, -0.01231126f, 
    0.01918986f, 0.02835436f, -0.03290370f, 0.03192284f, 0.07839981f, 0.10766934f, 0.19365259f, 0.12699707f, 
    0.14127302f, 0.01356880f, 0.11128651f, 0.02584694f, 0.07512683f, -0.04570309f, -0.01942504f, -0.03327277f, 
    -0.02452265f, 0.07273772f, -0.05819821f, -0.03261992f, 0.00691148f, 0.03986285f, -0.00487695f, -0.04657128f, 
    -0.11888361f, -0.31124216f, -0.29318559f, -0.06940985f, -0.07072678f, -0.12836266f, -0.00641781f, -0.02598550f, 
    -0.01201601f, -0.06201628f, 0.00305075f, -0.05027081f, -0.03501988f, 0.03744965f, -0.02423644f, 0.05239751f, 
    0.02300236f, -0.05242190f, -0.01557966f, -0.03450115f, 0.06373519f, -0.06568408f, 0.11237955f, 0.07569681f, 
    -0.00597631f, 0.09393506f, 0.01886440f, 0.03411056f, -0.02077614f, -0.01713604f, 0.01329565f, 0.00705612f, 
    0.03901563f, -0.05905690f, -0.00146870f, -0.07601899f, -0.02286347f, -0.07341728f, 0.00280292f, -0.04064913f, 
    0.03145753f, -0.16542076f, 0.01272159f, 0.02134608f, -0.07995181f, 0.02768802f, -0.06085934f, 0.01239932f, 
    -0.05546151f, 0.00706233f, 0.00134885f, -0.01416787f, -0.03967671f, -0.03400137f, -0.03058845f, 0.02107508f, 
    0.04001461f, 0.00434693f, -0.04782380f, -0.01891792f, -0.16846831f, 0.07113618f, 0.01554277f, -0.05421680f, 
    -0.03230335f, -0.06408301f, 0.03744387f, -0.10255317f, -0.04019276f, -0.01895521f, -0.01831047f, 0.03741416f, 
    -0.04671187f, -0.02870573f, -0.00759942f, -0.01002480f, 0.03151904f, 0.03971915f, -0.08629981f, -0.05372161f, 
    0.03222341f, -0.07285494f, 0.12472951f, 0.01891445f, 0.04699976f, -0.05812935f, 0.01870871f, -0.02888345f, 
    -0.02117819f, -0.06930915f, 0.04186403f, 0.02745194f, -0.01450950f, -0.00421095f, -0.08791896f, -0.06680297f, 
    -0.03948006f, 0.01398919f, -0.00108853f, -0.03357154f, 0.01536043f, 0.15583490f, -0.06828862f, 0.13761093f, 
    0.12910978f, -0.06242731f, 0.02723206f, -0.07834456f, -0.00183496f, -0.02651734f, -0.11370131f, 0.02927342f, 
    -0.11825118f, -0.04391813f, -0.04877559f, 0.02767166f, 0.00836893f, 0.07064991f, -0.05407147f, -0.05180482f, 
    -0.13019240f, -0.24072459f, -0.10051795f, -0.15080085f, -0.13203056f, 0.07446786f, -0.02747261f, -0.02884340f, 
    -0.05041902f, -0.11650518f, -0.05780575f, -0.06559078f, -0.04892124f, 0.00864169f, -0.10391250f, 0.00765925f, 
    0.05216059f, -0.04280358f, -0.00385861f, 0.03738654f, -0.05658347f, 0.09761728f, 0.11232748f, 0.07760344f, 
    0.05985412f, 0.10007797f, 0.10081853f, 0.04850537f, 0.03856589f, -0.00714141f, -0.05995921f, 0.01156229f, 
    0.02382645f, 0.00875423f, -0.04710063f, 0.01748246f, 0.05953934f, 0.03482308f, 0.02743972f, 0.01273243f, 
    0.10694686f, -0.13973650f, 0.03116649f, 0.00957755f, 0.07551443f, 0.05633589f, 0.04485534f, -0.06275805f, 
    -0.02340651f, -0.02364088f, -0.00711017f, 0.02167983f, 0.00692777f, -0.01835334f, -0.02907386f, -0.02973285f, 
    -0.00290696f, -0.04056986f, -0.00264216f, -0.05359900f, 0.06836084f, 0.05082754f, 0.10745658f, 0.04827134f, 
    0.11270490f, 0.04904994f, -0.05675774f, -0.08338553f, 0.01985358f, -0.00079359f, 0.03053531f, -0.00072245f, 
    -0.05273806f, -0.01112499f, -0.01443350f, -0.03064471f, -0.02207424f, 0.04229516f, 0.04296916f, -0.04373779f, 
    0.05261940f, -0.03166306f, -0.12840943f, -0.06682004f, -0.04286890f, -0.01454039f, 0.00366906f, -0.02164772f, 
    -0.03125680f, -0.10694391f, 0.00366964f, 0.03120784f, -0.04557044f, 0.01822208f, -0.04375396f, -0.01406008f, 
    -0.04239639f, -0.02250607f, -0.04154737f, -0.02223840f, -0.04344258f, -0.16260552f, -0.06495816f, -0.07043891f, 
    0.00841758f, -0.09207495f, -0.04297426f, -0.03573326f, -0.03370750f, -0.03907010f, 0.04593245f, 0.03138257f, 
    -0.14534390f, 0.04502547f, 0.04697727f, 0.02493496f, -0.00004311f, -0.00692555f, -0.03827681f, -0.03400242f, 
    -0.06973267f, 0.00231069f, 0.06254765f, 0.03385300f, -0.04994158f, -0.03215670f, -0.06393636f, -0.01457409f, 
    -0.00425973f, -0.04369061f, 0.02130301f, 0.01498249f, -0.00229871f, 0.02694743f, -0.05852722f, 0.02586905f, 
    0.02821524f, 0.00351115f, -0.03219013f, 0.01977674f, 0.15980075f, 0.07541192f, 0.19585134f, -0.01018871f, 
    0.11635668f, 0.10107121f, 0.07946052f, -0.03962820f, -0.01110091f, 0.01050931f, -0.02782485f, 0.02463719f, 
    -0.01669045f, -0.00165058f, -0.03103239f, -0.00896011f, 0.01694966f, 0.01576172f, 0.06850375f, -0.02877923f, 
    0.10000879f, 0.12571695f, 0.10463382f, -0.08345595f, 0.10009211f, -0.04842751f, 0.05218765f, -0.02587641f, 
    -0.02669172f, -0.01806798f, -0.02799839f, -0.00784243f, -0.08041321f, -0.01672564f, -0.05459147f, -0.05217003f, 
    0.00470300f, 0.09104795f, -0.03487647f, -0.02385992f, 0.04222447f, 0.04575144f, 0.06391650f, 0.03845612f, 
    0.09149131f, -0.02936202f, -0.01521736f, -0.06470847f, -0.04577401f, -0.00781726f, 0.01544996f, 0.00622124f, 
    -0.04626149f, -0.03323318f, -0.04583339f, 0.00224472f, -0.05032393f, 0.01767689f, 0.06272281f, 0.00267197f, 
    -0.17717169f, 0.16917926f, -0.13487834f, -0.01472716f, 0.02045072f, -0.09322358f, -0.04961225f, -0.07883620f, 
    0.02785252f, -0.05735701f, 0.00032292f, 0.11091698f, 0.01037399f, -0.02280192f, -0.03647396f, -0.00425248f, 
    -0.01273447f, 0.08197688f, -0.00470614f, 0.01039395f, -0.00169487f, 0.08320089f, -0.14819448f, 0.06577192f, 
    0.12474258f, -0.05724723f, -0.03469785f, -0.07453769f, -0.02831977f, -0.05099433f, -0.08768556f, 0.01606330f, 
    -0.06243755f, -0.04199725f, -0.05685429f, -0.02244993f, -0.05345110f, 0.01529824f, -0.07117281f, 0.02340406f, 
    0.07623149f, 0.02674051f, 0.02879182f, 0.02974102f, 0.08106135f, -0.06316087f, -0.00927082f, -0.07625389f, 
    0.00137052f, -0.03327231f, 0.00136728f, 0.00661919f, -0.05588382f, 0.02335597f, -0.01040505f, -0.06688823f, 
    -0.02644848f, 0.01922794f, 0.02695948f, -0.00648795f, 0.11820106f, -0.16758233f, -0.05402070f, 0.02153760f, 
    0.08688159f, -0.09441645f, -0.04075978f, -0.04978363f, -0.00597413f, -0.03078500f, -0.05614863f, -0.05648205f, 
    0.01220811f, 0.05748478f, -0.01393185f, -0.02802811f, 0.02125520f, 0.00033945f, -0.01348765f, 0.08362447f, 
    -0.15138219f, 0.02342611f, -0.05558789f, 0.03081777f, 0.01154669f, -0.10695624f, 0.07570738f, -0.09426820f, 
    0.02741851f, -0.02362535f, -0.05717889f, 0.07932556f, -0.11658456f, -0.08435982f, -0.05618333f, -0.00333591f, 
    -0.02141214f, 0.09387820f, -0.07823385f, 0.01200815f, -0.14557891f, 0.08477502f, -0.09389221f, 0.13737273f, 
    -0.03906899f, 0.08734291f, -0.08037066f, 0.01494642f, -0.01156617f, -0.01287556f, -0.02917786f, 0.05864400f, 
    0.09242563f, -0.05773658f, -0.00228681f, 0.00490658f, -0.06524432f, 0.04292635f, 0.01929025f, -0.00590313f, 
    0.05764393f, -0.15475552f, 0.08891127f, -0.00172037f, 0.00662912f, 0.01353499f, -0.07739888f, -0.09894646f, 
    -0.00782127f, -0.02757657f, -0.02544693f, -0.03057095f, 0.05198929f, 0.03157421f, -0.08755376f, -0.02233244f, 
    0.06696127f, -0.00492305f, 0.07826190f, 0.06349522f, 0.01262262f, 0.03200941f, 0.06080533f, 0.07744208f, 
    0.14186968f, -0.08952958f, 0.07618344f, -0.04505721f, 0.03046243f, 0.01863216f, -0.01590333f, 0.04952481f, 
    -0.06425880f, -0.02236150f, -0.04353125f, -0.02851178f, -0.08474300f, -0.01487625f, -0.02938851f, 0.00545636f, 
    -0.00054940f, 0.08624513f, -0.21311854f, -0.08976171f, 0.04528619f, -0.04288485f, -0.07310685f, -0.08644637f, 
    -0.03317563f, 0.00186690f, -0.07224622f, -0.01491357f, -0.00104894f, -0.00883224f, 0.02230834f, 0.01799191f, 
    -0.04110662f, -0.02914278f, 0.00576828f, 0.07136828f, -0.04715443f, 0.01218898f, -0.13151081f, -0.18848814f, 
    -0.11789897f, 0.00335018f, -0.03691129f, -0.05882175f, 0.01029784f, -0.08258379f, -0.05384143f, -0.02780229f, 
    -0.04259194f, -0.09311737f, -0.05551305f, 0.02684625f, 0.00023332f, -0.03626572f, -0.02235262f, -0.00639821f, 
    0.02278620f, 0.05218832f, 0.15861620f, 0.12498646f, 0.05882709f, 0.04291936f, 0.08874127f, 0.01380953f, 
    -0.02848214f, -0.04407376f, 0.00784130f, 0.00883324f, -0.04410398f, -0.05076784f, -0.01368827f, -0.08658218f, 
    -0.02733597f, -0.00177085f, 0.04309160f, -0.00123384f, -0.40888536f, 0.12988119f, -0.07586252f, -0.08464883f, 
    -0.05347765f, 0.02401215f, -0.02707002f, -0.09233280f, 0.02214455f, -0.06701872f, -0.05286841f, 0.03306438f, 
    0.03068658f, 0.03882093f, -0.09687720f, 0.04101558f, 0.01047352f, 0.06003999f, 0.01160442f, 0.04077009f, 
    -0.09192182f, 0.17426084f, 0.17322683f, 0.02059817f, 0.08527090f, 0.00572544f, 0.07464960f, 0.00208487f, 
    0.00308009f, -0.00126436f, -0.05587451f, 0.00979258f, 0.00666872f, -0.00671473f, -0.06649766f, -0.06152064f, 
    -0.00843626f, -0.02792477f, 0.01316569f, 0.00483984f, 0.15933903f, -0.12333190f, -0.00679297f, -0.04519222f, 
    0.16314356f, -0.13772273f, -0.05831365f, 0.01483223f, 0.00921863f, -0.00516298f, 0.01015458f, -0.00429726f, 
    -0.01082610f, 0.02120287f, -0.06231196f, 0.01024888f, 0.02994483f, -0.01886820f, 0.03505307f, -0.00948417f, 
    -0.04099622f, -0.11833836f, -0.17033653f, -0.08462199f, -0.00889033f, -0.07083507f, -0.13878611f, -0.05882224f, 
    -0.03479261f, -0.06638319f, -0.06274134f, 0.00179442f, 0.04352232f, 0.00456142f, -0.06642443f, 0.02695008f, 
    -0.02204986f, -0.04788393f, 0.05319684f, 0.01180219f, -0.07306398f, 0.11188836f, 0.08734147f, 0.09021480f, 
    0.08964677f, 0.11473758f, -0.06659323f, -0.02729084f, -0.01277696f, 0.00797390f, -0.00135177f, -0.01509543f, 
    0.00908529f, -0.04486436f, -0.06091642f, 0.06595902f, -0.04991233f, -0.01355399f, 0.00309972f, -0.02001318f, 
    -0.06875062f, 0.02854147f, -0.23338342f, -0.11729378f, -0.13677540f, -0.04242197f, -0.02648940f, -0.07647198f, 
    -0.05381827f, -0.06146713f, -0.04989469f, 0.03064621f, -0.04785970f, -0.05071668f, -0.01663151f, 0.02152258f, 
    -0.09769416f, -0.01208417f, -0.01574665f, -0.00364260f, 0.05084587f, 0.17863975f, 0.05477292f, -0.01576547f, 
    0.01484739f, -0.06091088f, 0.02536569f, -0.06745036f, 0.01360499f, 0.00666032f, -0.10672468f, 0.00726172f, 
    0.00476731f, 0.02879169f, -0.04404061f, 0.03041773f, -0.00552976f, -0.02726430f, -0.00969303f, -0.05576330f, 
    0.02613323f, 0.08503857f, 0.03398591f, -0.08452613f, -0.00861420f, -0.03864397f, 0.05596459f, -0.00940204f, 
    0.05926328f, -0.03909841f, -0.04987783f, -0.01252351f, -0.03112018f, -0.00431436f, 0.01623866f, 0.02149311f, 
    -0.04359825f, -0.01012485f, -0.02846498f, -0.00846398f, 0.07482419f, 0.05137261f, 0.13085693f, 0.16880803f, 
    0.17981362f, 0.06541233f, 0.07234150f, 0.02517612f, -0.05061115f, -0.04626008f, -0.08733323f, 0.06125329f, 
    -0.06116440f, -0.01746572f, -0.09035575f, -0.01194259f, 0.02526751f, -0.04627546f, -0.03200424f, 0.05635763f, 
    0.08609163f, 0.06834193f, 0.18775539f, -0.02000511f, 0.10914160f, -0.03014313f, 0.06248618f, -0.05514967f, 
    0.00973437f, 0.02714544f, -0.03650519f, -0.00471688f, -0.06815670f, -0.01990151f, -0.09150726f, -0.02397136f, 
    -0.02459152f, -0.01142021f, 0.00097439f, -0.03761617f, -0.08410976f, 0.09481388f, -0.20921047f, -0.01977185f, 
    -0.08503654f, 0.01862459f, 0.00942598f, 0.03246078f, -0.02108613f, -0.13234426f, 0.00361332f, 0.03325145f, 
    -0.01703851f, 0.07841733f, -0.09122213f, 0.07143912f, -0.03544152f, 0.00029044f, -0.00989790f, -0.06210908f, 
    0.08492664f, 0.07704093f, 0.08398146f, 0.14317061f, 0.20683478f, 0.13769734f, 0.06557839f, -0.05786882f, 
    0.01707723f, 0.03365470f, -0.01642122f, -0.05253582f, 0.06986393f, -0.07357116f, -0.02860553f, 0.03406354f, 
    -0.01388635f, -0.07074392f, -0.00506062f, 0.06623671f, 0.11173607f, 0.12868251f, -0.04219810f, -0.05747526f, 
    0.19293116f, -0.14976445f, -0.00688910f, -0.00314242f, 0.00110692f, 0.01003532f, -0.00378695f, 0.00915053f, 
    -0.08043242f, 0.04361735f, 0.01632481f, 0.02634566f, -0.01219946f, -0.01755843f, -0.04363259f, 0.03953596f, 
    -0.08555382f, -0.09347676f, -0.09231003f, -0.18211626f, -0.09447760f, -0.06656795f, 0.02426526f, -0.08707283f, 
    -0.00605810f, -0.05354544f, -0.03053350f, -0.05005648f, 0.00526584f, -0.09308945f, 0.00106574f, 0.03676059f, 
    0.07750214f, -0.06289239f, -0.03911060f, -0.00917571f, 0.04945232f, 0.11055708f, -0.10081474f, 0.01350943f, 
    0.05565493f, -0.10210627f, 0.02905182f, -0.10077651f, -0.02551055f, 0.00736663f, -0.07758664f, -0.01217364f, 
    0.02294046f, -0.03650616f, 0.00135641f, -0.00327227f, 0.00290783f, -0.01863424f, 0.00061784f, 0.07514840f, 
    -0.22679996f, 0.06009344f, 0.01783112f, 0.12712930f, 0.10655234f, 0.07866774f, -0.07280149f, -0.00901548f, 
    0.07026779f, -0.03160135f, 0.00555597f, 0.01332496f, 0.05739679f, 0.06233028f, -0.13209969f, 0.05100366f, 
    -0.06655050f, 0.03906631f, 0.00655791f, -0.07304521f, -0.06857514f, -0.32784554f, -0.05761870f, -0.15075101f, 
    -0.20492117f, -0.01181142f, -0.01551098f, -0.01475085f, -0.01112384f, -0.09348464f, -0.03868239f, -0.04397956f, 
    -0.07777159f, 0.02586640f, -0.04513815f, 0.03365345f, 0.05039414f, -0.02654156f, 0.00560513f, -0.07169855f, 
    0.07402485f, 0.03840470f, -0.06193913f, -0.03924870f, 0.04467882f, -0.11281965f, -0.02955889f, 0.01160582f, 
    -0.03896232f, -0.02072255f, -0.01923807f, 0.01683374f, -0.01900132f, 0.03215984f, -0.01895439f, -0.00567778f, 
    -0.00586827f, 0.01888845f, -0.05132113f, 0.07165587f, -0.04124691f, -0.21971665f, -0.01960217f, -0.08858301f, 
    -0.06338680f, -0.05703742f, 0.03423287f, -0.02639942f, -0.00901883f, -0.04170422f, -0.00975076f, -0.03408642f, 
    -0.00537781f, -0.01399743f, -0.05324374f, 0.03694271f, -0.00566313f, -0.01986085f, -0.00997838f, 0.02670181f, 
    -0.07015282f, 0.05908883f, 0.03781368f, 0.03227904f, 0.10261489f, -0.02799301f, 0.02213248f, 0.02335439f, 
    -0.01887329f, 0.00659370f, -0.01009499f, -0.01556694f, -0.10943355f, -0.07085922f, -0.00706250f, -0.02805831f, 
    0.02087596f, 0.02498353f, -0.00980768f, -0.02586012f, 0.10606506f, 0.00033993f, 0.16125338f, -0.03676940f, 
    0.06001110f, -0.04794848f, 0.10147685f, -0.05082823f, -0.01150267f, 0.00082007f, 0.01292750f, 0.04043360f, 
    -0.04834350f, 0.02903817f, -0.05668685f, -0.07453232f, -0.03865887f, 0.04472285f, -0.01689873f, -0.02911367f, 
    0.23451731f, -0.19345447f, 0.13513130f, 0.13527417f, -0.19416420f, 0.06951500f, -0.02836244f, -0.03824107f, 
    -0.02365793f, 0.06717692f, -0.10787690f, 0.05354348f, -0.03592285f, -0.00579988f, -0.01429010f, 0.09801379f, 
    0.05239374f, 0.03823215f, -0.02508185f, -0.02443622f, 0.13644288f, 0.12784015f, 0.12588486f, 0.17129068f, 
    0.09230243f, 0.08001722f, 0.06378444f, 0.07999697f, 0.05322756f, -0.00502873f, -0.03942053f, 0.00563023f, 
    -0.00075767f, 0.01207910f, -0.07078284f, 0.00444661f, 0.02041580f, 0.02710181f, -0.04637100f, -0.00892139f, 
    0.14102778f, -0.20040736f, 0.12739210f, 0.01793485f, -0.00583069f, 0.07798245f, 0.01744409f, -0.01308855f, 
    -0.03909907f, -0.00026973f, -0.03131802f, -0.04118514f, -0.01343550f, -0.01823406f, -0.00915334f, -0.02006932f, 
    0.02712034f, 0.00386076f, 0.02269890f, -0.06267047f, 0.04743976f, 0.10678060f, 0.19087794f, 0.06638829f, 
    0.08722941f, 0.06512086f, 0.04968021f, -0.03307693f, 0.00957396f, -0.04736673f, -0.02538475f, 0.05021163f, 
    -0.00372651f, -0.06770526f, -0.05026522f, 0.02341498f, 0.00870227f, -0.01437701f, 0.11489841f, -0.04823681f, 
    -0.05381780f, 0.06733175f, -0.10897354f, 0.08338238f, 0.09597815f, -0.02237141f, -0.04764259f, -0.07156195f, 
    0.00029297f, -0.05669467f, -0.08427411f, 0.01075265f, 0.01317120f, -0.01914301f, -0.01893154f, 0.00526339f, 
    -0.08081877f, -0.01311512f, -0.03835588f, -0.00530853f, 0.09233207f, -0.06138001f, 0.00524576f, 0.04468007f, 
    0.20967077f, 0.01161299f, 0.01895294f, -0.02547676f, -0.02560551f, -0.02024096f, -0.05104657f, 0.00383239f, 
    -0.03434122f, -0.03385926f, -0.02124220f, -0.03543023f, -0.05593490f, -0.01972602f, 0.00561831f, 0.03698097f, 
    0.16252300f, -0.09524994f, 0.14140789f, -0.02190983f, 0.03001138f, -0.03566728f, 0.12047935f, -0.03099822f, 
    -0.01271229f, 0.00460599f, -0.02100265f, 0.01135419f, -0.04397538f, 0.06780133f, -0.03912800f, -0.09005139f, 
    0.00846862f, 0.05792561f, -0.02636783f, -0.04764069f, -0.08655356f, 0.02170287f, 0.09621342f, 0.01837710f, 
    0.02116456f, 0.01973217f, -0.00627404f, -0.02654168f, 0.04088347f, -0.08860923f, -0.01140832f, 0.00668629f, 
    0.00424297f, -0.00642164f, 0.00279571f, 0.00084503f, -0.08597201f, 0.01541752f, 0.02006164f, -0.04257835f, 
    -0.14091499f, 0.03258445f, 0.05066618f, 0.07431972f, -0.04004460f, -0.02590189f, -0.04409945f, -0.05139546f, 
    0.08002934f, 0.06658285f, -0.00990117f, 0.05382086f, 0.02269219f, 0.05128645f, -0.04442308f, 0.02565333f, 
    0.03529244f, 0.02121678f, -0.06978160f, 0.08392572f, -0.07089260f, 0.04945827f, -0.00616387f, 0.08918606f, 
    -0.04612035f, 0.05387139f, -0.11952250f, 0.03584416f, 0.01791481f, 0.04120040f, -0.05532698f, 0.10581406f, 
    0.05221101f, -0.01780729f, -0.02225932f, -0.00304706f, 0.03133970f, 0.01614163f, -0.01361927f, 0.02298206f, 
    0.14292690f, 0.01225121f, 0.07485451f, -0.02121061f, 0.02281360f, -0.10622135f, 0.10854144f, -0.09904084f, 
    -0.03292667f, 0.04173666f, -0.00877592f, 0.02661711f, -0.04282809f, 0.04238554f, -0.01813911f, -0.03366139f, 
    -0.02355594f, 0.02797768f, -0.02858265f, -0.01068819f, 0.00226503f, 0.08475928f, -0.10347689f, -0.02965165f, 
    0.00552113f, -0.02960561f, -0.05201739f, -0.08946719f, -0.03659684f, -0.04544365f, -0.06345242f, -0.00407249f, 
    -0.02685122f, -0.05669408f, -0.01687952f, -0.00194554f, -0.00319544f, 0.07945164f, 0.02951789f, -0.03690871f, 
    0.07601363f, 0.07897624f, 0.03042541f, 0.02165399f, 0.09997441f, -0.04210044f, 0.02132855f, -0.04386274f, 
    0.00902865f, -0.00316460f, -0.00769233f, -0.00262669f, -0.07377272f, -0.05287581f, -0.05218276f, -0.03716789f, 
    0.00811612f, 0.03215280f, -0.02750880f, -0.01911760f, 0.16617632f, -0.45214775f, -0.00544207f, -0.16674966f, 
    -0.18147901f, -0.02374383f, -0.04616908f, -0.00807133f, -0.00308511f, -0.09649066f, 0.00269901f, -0.01786263f, 
    -0.10511677f, 0.02825257f, 0.01344851f, 0.03245016f, 0.05528153f, -0.05243859f, 0.01226287f, -0.08398515f, 
    0.10511162f, 0.16150041f, -0.09691130f, 0.04787383f, 0.05854237f, 0.09005860f, 0.04239438f, -0.02353008f, 
    -0.01661996f, 0.01730901f, 0.01673623f, -0.02342441f, -0.00830356f, 0.01807418f, -0.04678863f, 0.00267302f, 
    0.04316405f, 0.02227575f, 0.05622509f, -0.00839304f, -0.10561970f, -0.03481822f, 0.18036093f, -0.01974766f, 
    0.01554081f, -0.02147569f, -0.04572617f, 0.01430479f, -0.03451452f, -0.03800158f, -0.00457436f, 0.00152208f, 
    -0.08585909f, -0.04253725f, 0.00714818f, -0.00767032f, 0.05543056f, -0.07283489f, 0.03563010f, -0.07205253f, 
    0.09778728f, -0.16828804f, -0.18887334f, 0.14063576f, 0.17114280f, 0.10823685f, 0.08545695f, -0.03575996f, 
    -0.07840549f, -0.02404230f, -0.00997311f, -0.00353312f, 0.05456859f, -0.05031124f, 0.00026905f, 0.01618724f, 
    -0.00308722f, 0.03508874f, 0.06511470f, -0.04893970f, -0.06567653f, -0.06373329f, 0.05177286f, 0.10756952f, 
    0.08265091f, -0.08895669f, 0.00665615f, 0.00004455f, -0.07250968f, 0.02616683f, -0.01073606f, 0.00097662f, 
    -0.00307020f, 0.07608497f, 0.01626233f, 0.03580543f, 0.01212142f, 0.01518187f, -0.04938224f, 0.10737998f, 
    0.03496993f, 0.03833599f, 0.03887613f, -0.00492321f, 0.11573017f, -0.00287574f, -0.07824154f, -0.07704521f, 
    -0.02090946f, 0.02469870f, 0.01654693f, -0.01987380f, -0.00483679f, -0.11925563f, 0.02573285f, -0.01242937f, 
    -0.00934971f, -0.02245310f, 0.02173511f, 0.03249311f, 0.05866076f, 0.11940051f, -0.06233362f, 0.07572266f, 
    0.00504920f, -0.01519960f, 0.03392607f, -0.03070973f, -0.06086440f, -0.00430772f, 0.07692432f, 0.06505091f, 
    0.05147378f, -0.00033048f, 0.01019414f, -0.03080427f, 0.02656509f, -0.02294651f, 0.08628344f, 0.04715795f, 
    0.05274862f, -0.00926203f, 0.02969448f, 0.06829019f, 0.13367273f, -0.10526820f, -0.05330594f, -0.01578975f, 
    -0.01130014f, -0.02867838f, -0.01832678f, -0.01843832f, -0.06150307f, -0.00271051f, 0.06447205f, 0.02849243f, 
    0.02992391f, -0.03773189f, 0.04219727f, 0.00639816f, -0.07018720f, 0.14115189f, 0.05836786f, -0.20695014f, 
    -0.10998491f, -0.09428906f, 0.04244136f, -0.04373060f, -0.08077870f, -0.09251761f, 0.07538690f, 0.05379239f, 
    0.07796364f, 0.00334208f, -0.00468713f, -0.08156684f, 0.04083817f, -0.16845879f, 0.03040400f, 0.01860569f, 
    0.10403670f, -0.07670315f, 0.08921354f, 0.03156574f, 0.19174781f, 0.09925263f, 0.00943938f, -0.07152107f, 
    0.01648586f, -0.01779727f, 0.11815578f, 0.05642935f, 0.03782992f, -0.03625191f, -0.01226574f, -0.02477055f, 
    0.01279411f, 0.05753809f, 0.04677280f, -0.00857393f, -0.05830228f, -0.16858883f, 0.08003022f, 0.04893947f, 
    -0.03790480f, -0.00263254f, -0.12784117f, 0.02871343f, -0.11430999f, 0.16631475f, 0.02567760f, -0.01976135f, 
    -0.03064345f, -0.06571706f, -0.00487456f, 0.02492100f, 0.02314277f, -0.09903898f, 0.08705338f, 0.02198049f, 
    0.06620966f, -0.05453894f, 0.12764278f, 0.04959560f, 0.11105616f, -0.02062736f, -0.04985307f, -0.01827741f, 
    -0.12211496f, -0.02925744f, 0.00529529f, -0.00296757f, -0.02523968f, -0.05059486f, 0.03008839f, 0.01236106f, 
    -0.01818884f, 0.06824674f, -0.00183452f, 0.07542814f, -0.17787345f, 0.00400116f, -0.00888454f, -0.14621602f, 
    -0.16151895f, 0.01211287f, 0.00375672f, -0.01340118f, -0.00581388f, -0.05698457f, 0.02811976f, -0.00156989f, 
    0.05909649f, 0.00594771f, 0.01824599f, 0.01771408f, -0.03700826f, -0.08234285f, -0.12955351f, -0.00443505f, 
    0.06630827f, 0.05022416f, 0.05871372f, 0.03156956f, 0.03234706f, -0.04353976f, -0.00372367f, -0.06074075f, 
    -0.06803977f, -0.04437122f, 0.02612818f, 0.00523934f, 0.01553964f, -0.00234961f, 0.06096018f, 0.00257881f, 
    -0.08022084f, -0.01190085f, 0.05003300f, -0.04913938f, 0.16537035f, 0.16828302f, 0.07139654f, 0.01446778f, 
    0.10607580f, -0.07049412f, -0.05796590f, -0.04103158f, -0.05342577f, -0.16308333f, 0.06398247f, -0.05089354f, 
    -0.01854147f, -0.06058834f, 0.05280373f, -0.02154859f, -0.03574651f, 0.00054390f, 0.10118480f, -0.05657213f, 
    0.00587137f, 0.04110993f, -0.06959593f, 0.07299729f, 0.05097332f, -0.02123808f, -0.08456456f, -0.14846510f, 
    -0.05673914f, 0.06423856f, -0.02392495f, -0.06391549f, -0.05169152f, -0.08148475f, 0.00058623f, -0.02437955f, 
    0.04342000f, -0.02003143f, 0.08422864f, 0.02337112f, -0.22785759f, -0.02518773f, 0.18774533f, -0.18088955f, 
    0.00791903f, 0.06843506f, 0.01186986f, 0.05512092f, -0.01330116f, -0.02619421f, 0.03934680f, -0.03238802f, 
    -0.04731546f, 0.01432709f, 0.08651184f, -0.01701915f, -0.04004601f, 0.04183475f, -0.13921870f, -0.04263708f, 
    -0.08351170f, 0.17384978f, -0.08064715f, -0.09322964f, -0.20614408f, -0.08760661f, 0.02865789f, -0.01372352f, 
    -0.04752666f, -0.02078738f, 0.02857796f, -0.02223152f, 0.03680726f, 0.00476704f, 0.00174735f, 0.00604588f, 
    -0.01106907f, -0.15933368f, -0.05662029f, 0.06682929f, -0.14612268f, 0.03484255f, 0.12318341f, -0.17514390f, 
    -0.12605423f, -0.02172172f, -0.03106838f, -0.04587233f, 0.05460643f, -0.05756890f, 0.00477594f, 0.01759219f, 
    -0.02282854f, 0.08646125f, -0.01952742f, -0.00879846f, -0.02737021f, -0.04055243f, -0.14023909f, 0.03277391f, 
    -0.06945720f, 0.16490509f, -0.08062862f, 0.00041780f, -0.13569410f, -0.03284816f, 0.09304105f, -0.11538148f, 
    0.02151536f, -0.05793775f, 0.06288232f, -0.01791430f, -0.02359910f, 0.04648247f, 0.09578475f, 0.00805921f, 
    0.01532447f, -0.01444319f, 0.10806053f, -0.05632757f, -0.08302193f, -0.09321196f, 0.02757134f, -0.27390817f, 
    -0.09632428f, -0.04559530f, 0.00625164f, -0.00045935f, 0.00369807f, 0.01083495f, 0.00948819f, 0.02219309f, 
    -0.02690190f, 0.01977809f, -0.04258891f, 0.00545453f, 0.04885564f, -0.03766084f, -0.09333338f, 0.00840027f, 
    -0.15000270f, -0.04802242f, 0.08557885f, -0.10462164f, -0.03346740f, 0.01466299f, -0.01102392f, -0.00018683f, 
    -0.01698166f, -0.15752739f, 0.00998153f, 0.00597034f, 0.04424158f, 0.02760046f, 0.05011784f, 0.03001841f, 
    0.02475968f, -0.05941672f, -0.16449116f, 0.05279586f, 0.00347182f, -0.10779244f, -0.16828273f, -0.18238866f, 
    -0.03238418f, 0.06690756f, 0.02028771f, -0.03244774f, -0.03580881f, -0.04778427f, -0.00284947f, 0.08471364f, 
    -0.00133301f, 0.04912226f, -0.02287206f, 0.01951945f, 0.00258282f, -0.00164300f, -0.08789859f, -0.02028662f, 
    -0.02987414f, 0.18041198f, 0.12364726f, 0.01751997f, -0.04231868f, -0.09448472f, -0.02691333f, -0.03905617f, 
    -0.04783434f, -0.11817514f, 0.05154024f, 0.04075328f, 0.00306539f, 0.00680334f, -0.07268406f, -0.14462189f, 
    0.02244997f, -0.05621361f, 0.10118488f, -0.08964495f, -0.18366225f, -0.05103507f, -0.05046374f, -0.23339114f, 
    -0.21462555f, 0.00546311f, -0.12699063f, -0.06718213f, 0.05366218f, -0.02411882f, 0.09927106f, 0.03511338f, 
    0.05909022f, -0.08290146f, 0.05347303f, -0.10321662f, -0.03879048f, -0.00661939f, 0.03690767f, -0.04960261f, 
    -0.03171976f, 0.12560423f, -0.13944882f, -0.09888697f, -0.11248270f, 0.01721777f, -0.01581934f, -0.01167652f, 
    0.01070513f, -0.10422415f, 0.09372438f, 0.04287209f, 0.07227967f, 0.02741198f, 0.08341984f, 0.08326741f, 
    -0.03773887f, -0.08578972f, -0.05653080f, 0.01369261f, -0.16628940f, 0.00626800f, 0.15360771f, 0.04194585f, 
    0.03327552f, -0.02811032f, -0.04484582f, -0.05777741f, 0.01408852f, 0.05887613f, 0.02413200f, 0.02720572f, 
    -0.00278741f, 0.00399878f, 0.02764421f, -0.06049177f, 0.02485270f, 0.04974191f, 0.08468310f, -0.07943329f, 
    -0.10528626f, -0.06630597f, -0.06299759f, -0.04958860f, 0.02241175f, 0.13166247f, 0.07833205f, -0.06644864f, 
    -0.00218983f, -0.03863531f, 0.07144275f, 0.03718052f, -0.04571149f, -0.06818311f, -0.03087451f, -0.05409609f, 
    -0.00018848f, 0.15552539f, 0.00792848f, -0.08956230f, 0.08532174f, 0.09552867f, -0.07884793f, 0.03499105f, 
    0.10559518f, 0.07524997f, 0.00564497f, -0.02712025f, -0.02975746f, -0.00528633f, 0.03408222f, 0.04330860f, 
    -0.06259438f, 0.01696278f, 0.00999440f, -0.04548747f, 0.01628214f, 0.02668372f, 0.09074891f, 0.00063756f, 
    -0.17894889f, -0.03688643f, 0.15264346f, 0.00886621f, 0.00765771f, -0.07406907f, 0.06121325f, 0.01907230f, 
    0.03392362f, -0.05875009f, 0.05073160f, 0.06262127f, 0.02130459f, 0.04668222f, -0.02755529f, -0.00495220f, 
    0.02669312f, -0.06716011f, -0.00038559f, 0.03770934f, -0.00508818f, -0.00640853f, -0.12770022f, 0.13228695f, 
    0.06704804f, 0.08987013f, 0.07241401f, -0.09193815f, -0.01125553f, -0.03169640f, 0.07931768f, -0.02390444f, 
    0.08489333f, -0.04351696f, 0.09791946f, -0.00017103f, 0.00979286f, -0.01925827f, 0.11839873f, -0.08724442f, 
    0.02268087f, -0.10525640f, 0.12062127f, -0.03245767f, -0.03270122f, -0.06633122f, -0.11044890f, 0.00483002f, 
    -0.04375684f, 0.07815169f, 0.00353645f, -0.02626935f, -0.03744203f, 0.02226208f, 0.04585587f, 0.00482141f, 
    -0.05507017f, -0.07692537f, 0.02892836f, -0.04464142f, -0.14823619f, -0.17704932f, -0.08736186f, -0.14349692f, 
    -0.04351356f, 0.06745633f, -0.04484163f, -0.02731371f, -0.12776360f, -0.11439471f, -0.04274679f, 0.03665550f, 
    0.02148856f, -0.00634199f, 0.01236344f, -0.03178699f, 0.03479886f, -0.00935333f, -0.14189190f, 0.02525516f, 
    -0.24101123f, -0.28850782f, 0.06204442f, 0.00951535f, 0.19670652f, 0.07300372f, 0.07865269f, -0.12751105f, 
    -0.04409290f, -0.02243599f, 0.07830804f, 0.09450797f, 0.10580264f, 0.03825400f, 0.08461782f, -0.08297263f, 
    0.06487010f, 0.10245506f, -0.00485435f, -0.06195653f, -0.19489859f, -0.00514870f, -0.22384369f, -0.11050725f, 
    -0.20870519f, 0.04674464f, 0.00466923f, -0.18896231f, 0.04352938f, -0.02236359f, 0.03517158f, -0.01221503f, 
    0.00246287f, -0.02246711f, 0.02856285f, -0.02560348f, -0.00059268f, -0.18975154f, 0.01268654f, 0.04075094f, 
    0.05634563f, 0.16656619f, -0.01705897f, 0.06006105f, 0.06723589f, 0.04445877f, 0.03423480f, -0.05236709f, 
    -0.03036015f, -0.06995505f, 0.07998282f, 0.01282417f, -0.02424415f, -0.01800785f, -0.06738567f, -0.09067505f, 
    0.02623007f, 0.04237035f, 0.02805471f, -0.10136754f, -0.00516794f, -0.01388006f, -0.04502687f, 0.06004030f, 
    -0.10931102f, -0.01045915f, 0.00695060f, -0.07190146f, -0.01490461f, -0.07462868f, 0.09216167f, -0.00835746f, 
    -0.00508787f, -0.05323353f, 0.09421691f, -0.06260455f, 0.00422822f, -0.13329864f, 0.17084983f, -0.09369339f, 
    -0.04571325f, 0.15418269f, -0.05334070f, -0.12764750f, -0.09916629f, 0.03190832f, 0.02303515f, 0.00301234f, 
    0.02457665f, -0.06622491f, 0.02363457f, -0.02089478f, -0.06768250f, -0.11815072f, 0.03630599f, -0.09167449f, 
    -0.00067695f, 0.06930569f, -0.00220640f, -0.06782441f, -0.16481884f, -0.09698378f, 0.19002478f, -0.22141428f, 
    -0.11275436f, 0.01398461f, 0.04761476f, -0.04630572f, 0.02275070f, -0.00173076f, 0.02658763f, 0.04418724f, 
    0.05252770f, 0.04365395f, 0.01426920f, -0.06756488f, 0.07594798f, 0.09719869f, -0.19057076f, -0.00887898f, 
    -0.11376319f, 0.14684945f, 0.09219340f, -0.01421226f, -0.08801141f, -0.03615969f, 0.00743779f, -0.06346910f, 
    0.00228732f, -0.01343561f, 0.00396900f, 0.01523381f, 0.03286266f, -0.02350440f, 0.04545350f, -0.02512695f, 
    -0.02991216f, -0.05592012f, -0.03372148f, 0.04572330f, 0.14955537f, 0.12979995f, -0.01605241f, 0.08959863f, 
    0.06001412f, -0.05319918f, -0.06270663f, -0.05607654f, -0.05102198f, 0.00217499f, 0.11959894f, -0.04091442f, 
    -0.01449121f, -0.07435879f, 0.13730375f, -0.02070450f, -0.07684270f, 0.04243491f, 0.04206477f, -0.01922580f, 
    -0.04386356f, -0.10050766f, 0.17685495f, -0.02205589f, 0.13048245f, -0.10470901f, -0.02840537f, -0.06103661f, 
    -0.01643487f, -0.08282585f, 0.00917086f, 0.00208688f, 0.01361869f, -0.11315708f, -0.05694915f, -0.03166394f, 
    -0.03320512f, 0.04964304f, 0.04419393f, 0.03860742f, -0.09962422f, 0.01187542f, 0.05993037f, -0.10957883f, 
    -0.02863923f, 0.08743653f, -0.01653400f, -0.07596443f, -0.02284519f, -0.14332195f, 0.10504518f, -0.06551611f, 
    0.10197040f, -0.03157293f, 0.04754318f, 0.02600425f, 0.09175931f, 0.01400200f, 0.02229231f, 0.01143268f, 
    0.09162653f, -0.06573102f, -0.18002880f, 0.10590884f, 0.04998624f, 0.01445997f, 0.02180189f, -0.01253424f, 
    -0.08823147f, -0.02763856f, 0.03423166f, 0.05703954f, -0.01241500f, 0.08598337f, 0.03095090f, -0.03241583f, 
    -0.01281930f, 0.02544590f, 0.08188332f, -0.04115986f, -0.15662913f, -0.12177724f, -0.08812086f, -0.27614439f, 
    -0.11357477f, -0.00557628f, -0.04871736f, -0.04872265f, -0.03270278f, -0.00060281f, 0.07806230f, 0.05445786f, 
    0.00914144f, 0.03802372f, 0.04066642f, 0.02507114f, 0.04017721f, -0.01613242f, 0.01885999f, 0.06939249f, 
    -0.12021907f, 0.11844115f, -0.29927284f, 0.04126854f, -0.02656567f, 0.09427118f, -0.07175670f, -0.16255355f, 
    -0.02798064f, -0.00450342f, 0.10952862f, -0.03854688f, 0.09315091f, -0.04324971f, 0.07128801f, -0.02813384f, 
    -0.00972732f, -0.03753119f, 0.08934598f, 0.02839992f, 0.10110270f, -0.06820971f, -0.16250280f, 0.15236993f, 
    0.13745661f, 0.09736461f, 0.00872338f, -0.05756903f, -0.06958405f, -0.02231645f, -0.03145028f, 0.00461726f, 
    0.03489856f, -0.00902221f, -0.00083502f, 0.01357712f, -0.02023471f, 0.04469828f, 0.06841692f, -0.05001759f, 
    -0.07068332f, 0.00361287f, -0.05375970f, -0.08525737f, -0.03704071f, 0.12674479f, -0.00431072f, -0.01470301f, 
    0.03563881f, 0.00505301f, 0.02495452f, 0.00314211f, -0.03556985f, -0.00106275f, -0.02060621f, -0.02452111f, 
    -0.01145903f, -0.00012071f, -0.03485550f, 0.04579527f, 0.07690914f, -0.06701734f, -0.27242827f, 0.04769613f, 
    0.10019260f, 0.07380420f, 0.04818933f, -0.02413532f, -0.02667117f, -0.03991036f, -0.00435697f, 0.09303474f, 
    0.03106722f, 0.00784140f, -0.03136824f, 0.02983766f, 0.01129863f, -0.00298854f, 0.05215891f, -0.03048594f, 
    0.01171259f, 0.23025958f, 0.00571614f, -0.08190742f, -0.12224853f, -0.06602379f, 0.01890466f, -0.02425718f, 
    -0.04966963f, -0.01475891f, 0.04234771f, -0.03395168f, 0.04867469f, -0.08100755f, 0.03639646f, -0.03785469f, 
    -0.05189198f, -0.15360643f, -0.04189570f, -0.02615722f, -0.03381683f, 0.11652163f, 0.01986349f, 0.05329252f, 
    0.00365726f, -0.03923511f, 0.08779723f, -0.02410847f, 0.03151677f, 0.00192472f, 0.02457226f, -0.00561435f, 
    -0.00514442f, 0.04410011f, 0.06410711f, 0.02348498f, -0.01992203f, -0.06733596f, 0.03696737f, -0.02034589f, 
    0.03957443f, -0.06370492f, -0.11160514f, -0.03955663f, 0.03907087f, -0.00223307f, -0.00228057f, -0.01651213f, 
    -0.06180165f, -0.02071460f, 0.04219828f, 0.01916233f, -0.03875934f, -0.05113301f, 0.01366124f, 0.01948370f, 
    -0.00234760f, -0.07371364f, 0.06242796f, 0.02880422f, -0.16488753f, -0.17582266f, 0.14024232f, -0.09091312f, 
    -0.06890487f, 0.02743241f, -0.00138664f, 0.02473738f, -0.02868756f, -0.01015014f, 0.03365133f, 0.01142240f, 
    0.00274215f, -0.05331089f, -0.00959871f, 0.02087724f, 0.04355351f, -0.04439105f, -0.00414207f, -0.06654371f, 
    -0.06165238f, -0.08713131f, -0.07399667f, -0.06811461f, -0.00334259f, -0.03553706f, -0.03247828f, 0.01169942f, 
    -0.04930149f, -0.03157942f, 0.04131635f, 0.00510399f, -0.03586230f, 0.01494824f, 0.06849597f, -0.00575640f, 
    0.02072180f, -0.01859843f, 0.02136316f, 0.01944943f, -0.23915800f, -0.18546553f, 0.25455999f, -0.16979575f, 
    0.05260941f, -0.02417308f, -0.02955936f, 0.12321095f, -0.05293999f, -0.02393610f, -0.00834134f, 0.00340235f, 
    0.05230805f, -0.08925168f, 0.07874727f, -0.05630482f, -0.03205460f, 0.06221051f, -0.19661680f, 0.01753888f, 
    -0.06576892f, -0.07689486f, -0.09929182f, 0.06520914f, -0.08545256f, -0.02651519f, 0.04401037f, -0.00674552f, 
    -0.08341853f, -0.04620285f, 0.06882706f, 0.03286476f, 0.03208638f, -0.00630554f, 0.10415803f, -0.06064091f, 
    -0.00549144f, -0.03250786f, -0.04005269f, -0.13242553f, -0.16961873f, -0.16312712f, 0.03886607f, -0.19259107f, 
    -0.13786423f, -0.02150035f, -0.07520108f, -0.02401326f, -0.03222146f, -0.00870181f, -0.00194236f, 0.04224918f, 
    0.01224137f, 0.04046298f, -0.04091875f, -0.01023102f, 0.02901069f, 0.01442253f, -0.16929768f, -0.06558667f, 
    0.04170898f, -0.00579604f, 0.09194887f, 0.05606036f, 0.12764046f, -0.06414536f, -0.04368170f, 0.08787037f, 
    -0.03713977f, 0.00329300f, 0.02084319f, -0.02427248f, -0.03952213f, -0.09391198f, 0.05086819f, 0.02576473f, 
    -0.02903105f, -0.02303241f, 0.04169121f, 0.00745727f, 0.03773450f, 0.01448401f, 0.07288907f, 0.05855808f, 
    0.12408415f, -0.08140410f, -0.02701932f, -0.01837322f, -0.05378238f, 0.02623552f, -0.03116573f, -0.00873516f, 
    -0.04623913f, 0.00584112f, 0.02300926f, -0.03634354f, 0.00947086f, 0.05291545f, 0.01560379f, 0.02298681f, 
    0.09448114f, 0.09463394f, -0.09690835f, 0.05091409f, 0.01821175f, 0.06543975f, -0.02205409f, -0.24433185f, 
    -0.10404295f, 0.12197399f, -0.03114174f, -0.06540849f, 0.05804202f, -0.07799268f, -0.04340092f, -0.04969145f, 
    -0.01332172f, -0.07289004f, 0.16691481f, 0.02903146f, -0.13288733f, -0.00054808f, -0.09621987f, 0.00737979f, 
    -0.18127909f, 0.07179490f, -0.03538848f, -0.19642407f, -0.00701478f, 0.04314779f, 0.10266954f, -0.02447541f, 
    0.07691801f, -0.02444214f, 0.00880452f, 0.01906843f, -0.01082925f, -0.08398402f, 0.05912580f, 0.06683908f, 
    0.00046815f, 0.09108143f, -0.05085762f, 0.00506843f, 0.06439774f, 0.02162074f, 0.05285776f, -0.04319841f, 
    -0.01830178f, 0.06072238f, 0.07430118f, 0.03958068f, 0.02018441f, 0.07850900f, 0.02337622f, -0.00588212f, 
    0.03338126f, -0.00582452f, 0.05117279f, 0.04762577f, -0.01809896f, 0.00377996f, -0.01687710f, -0.10413943f, 
    -0.06924170f, -0.06841066f, 0.00946261f, -0.00820651f, -0.00574998f, -0.01566774f, 0.04550643f, 0.05705598f, 
    0.05935698f, 0.00201133f, 0.03546042f, 0.03014643f, -0.04302313f, -0.12335201f, -0.00427965f, 0.01659558f, 
    -0.09063879f, 0.07450915f, 0.07134904f, -0.02450117f, -0.10787828f, -0.04742132f, 0.00993681f, 0.03377573f, 
    0.01437900f, -0.06553780f, 0.03235054f, 0.04787893f, 0.01559007f, -0.01121820f, 0.01275019f, -0.01776646f, 
    0.00215635f, -0.16370815f, 0.03867394f, -0.03661338f, 0.09674808f, -0.12712432f, -0.13311358f, 0.13546169f, 
    0.10277321f, 0.05290798f, 0.03343150f, -0.06257496f, -0.03880518f, 0.01087016f, 0.00058746f, 0.01789634f, 
    0.01009206f, 0.02463066f, 0.04845018f, -0.01739059f, -0.03202121f, 0.02473723f, 0.05355884f, -0.02455558f, 
    0.09074279f, 0.15138201f, 0.16794375f, -0.18013582f, -0.17539875f, 0.04581846f, 0.05418971f, 0.00653290f, 
    -0.00876801f, -0.03897461f, -0.06788474f, 0.01310124f, 0.03268101f, -0.06666172f, 0.05172651f, -0.02290525f, 
    0.06195984f, 0.01298208f, -0.06279773f, -0.01332489f, -0.10518054f, -0.01351769f, 0.07406220f, 0.07097016f, 
    -0.00252896f, 0.06274529f, -0.04419528f, -0.03891392f, -0.06080245f, 0.08280841f, -0.06522253f, -0.09648997f, 
    0.02843555f, 0.04879101f, 0.03036218f, 0.01781511f, -0.11238995f, 0.05546554f, 0.02769686f, -0.03474846f, 
    -0.24566378f, -0.11266971f, -0.02718910f, -0.14400966f, -0.16510433f, 0.05471630f, 0.04798907f, -0.08640776f, 
    0.03882767f, -0.10229901f, -0.06195095f, 0.01246817f, -0.08105108f, -0.00929904f, -0.10790376f, 0.02293474f, 
    -0.03968002f, 0.02103435f, 0.02959428f, 0.01444362f, -0.00153448f, -0.13454260f, -0.17859836f, 0.11903798f, 
    -0.00830862f, -0.01984433f, 0.00723745f, 0.00365642f, 0.03523560f, 0.03763893f, -0.05643703f, -0.01306079f, 
    0.04487404f, -0.04248948f, 0.05923747f, -0.08442966f, 0.01164947f, -0.12329019f, 0.04893491f, 0.04742367f, 
    0.09755864f, -0.18473892f, 0.07816522f, -0.10125857f, 0.06459793f, 0.04551031f, 0.01406730f, -0.01918731f, 
    -0.04513176f, -0.06935896f, -0.00391154f, -0.02437530f, 0.01493280f, 0.14153823f, 0.02884228f, 0.00358825f, 
    0.02901106f, -0.04704692f, -0.08546424f, -0.07146798f, -0.19285482f, 0.25377849f, 0.09857866f, 0.12058774f, 
    -0.08615628f, 0.08045911f, 0.03535477f, 0.02835046f, -0.00771317f, -0.10763779f, 0.00415517f, -0.05825306f, 
    0.05715092f, 0.03045258f, 0.03383789f, 0.09684448f, 0.01386851f, 0.06848581f, -0.11955070f, 0.01938010f, 
    -0.03689231f, 0.01242068f, -0.07738400f, 0.09897143f, 0.00248201f, 0.09543269f, 0.00242799f, -0.07935657f, 
    -0.03487150f, 0.02792867f, 0.03482268f, 0.01376590f, 0.00759537f, 0.00809961f, -0.01605398f, -0.04450068f, 
    -0.10862619f, -0.02714854f, -0.02513570f, -0.00656318f, 0.05281119f, 0.04896117f, -0.06721888f, -0.03472390f, 
    -0.24523573f, -0.04726056f, 0.06931898f, 0.03112841f, -0.01504100f, 0.01733302f, -0.11531071f, 0.00257121f, 
    0.00999602f, 0.01598734f, 0.07686625f, 0.08874770f, 0.08972785f, -0.06245257f, 0.07616014f, 0.02636408f, 
    0.09341494f, -0.15739235f, 0.15548050f, -0.18996984f, -0.28965700f, 0.05159353f, 0.11251620f, -0.09768370f, 
    -0.01724264f, -0.00131335f, 0.03385281f, -0.01696551f, 0.10478021f, 0.02338431f, -0.09128613f, 0.00494453f, 
    0.05890561f, -0.13075382f, -0.01887685f, -0.05852234f, 0.11652020f, -0.17907459f, -0.05498370f, 0.12862942f, 
    0.19765665f, 0.04016237f, -0.04932519f, -0.04071453f, -0.03464904f, 0.14644654f, -0.02960494f, 0.04770642f, 
    -0.04235424f, 0.11737340f, -0.03430663f, -0.00409351f, -0.05831422f, 0.03525672f, -0.04702227f, -0.04302439f, 
    0.14481176f, -0.11287685f, 0.05291007f, 0.00928275f, -0.03221352f, 0.04777662f, -0.02757551f, 0.04761178f, 
    -0.08394130f, -0.02534178f, 0.01245210f, 0.08292172f, -0.01509237f, 0.01288530f, 0.00838526f, 0.02401012f, 
    0.03101538f, -0.09506544f, -0.01420909f, -0.00256788f, -0.04401924f, -0.16449492f, 0.02492804f, 0.20894606f, 
    0.02800616f, -0.04426635f, -0.00635711f, -0.00138171f, -0.00058507f, -0.03490255f, 0.05491431f, -0.04843716f, 
    -0.10784261f, 0.01139579f, 0.00037558f, 0.04227905f, -0.00815483f, 0.09350402f, 0.03317479f, 0.07913450f, 
    -0.08350509f, 0.05809548f, -0.01187484f, -0.11775303f, 0.06545239f, 0.06178934f, 0.01378608f, -0.08884133f, 
    0.00327464f, -0.03448459f, -0.02125783f, -0.04033965f, 0.00644380f, -0.00553143f, -0.07452052f, 0.04482971f, 
    -0.00061544f, 0.04252530f, 0.08693946f, 0.00086283f, 0.30582231f, -0.13888711f, -0.17352812f, -0.02423645f, 
    -0.13340962f, 0.09195665f, 0.01627229f, 0.01300132f, -0.07177665f, 0.01954854f, -0.08241469f, 0.07948113f, 
    -0.03280974f, 0.04244235f, -0.11200891f, 0.01315622f, 0.01846781f, -0.02334118f, 0.04221981f, 0.01359130f, 
    0.09479661f, -0.22281529f, 0.00770812f, -0.01135842f, 0.02569648f, 0.05528682f, 0.03160256f, 0.00959573f, 
    -0.00801446f, -0.00880135f, 0.00940313f, 0.03593649f, -0.01889890f, 0.02935366f, -0.01146061f, 0.00529127f, 
    -0.01564693f, 0.01393264f, -0.04619334f, -0.02388752f, 0.03429678f, -0.14335628f, -0.05515696f, 0.15652013f, 
    -0.01647757f, -0.13354473f, 0.03357154f, -0.04529345f, 0.01712941f, 0.04028266f, -0.08112257f, 0.05188857f, 
    0.01054634f, 0.01307355f, 0.08518748f, -0.01236362f, -0.02562690f, 0.06797680f, 0.02522444f, 0.06854230f, 
    -0.30181074f, 0.08615606f, -0.10878097f, 0.05317872f, -0.07048248f, -0.00881998f, -0.03389410f, -0.03164311f, 
    -0.02919768f, 0.03253493f, -0.12749708f, -0.01166484f, -0.10988571f, 0.04607055f, 0.06856859f, -0.02888873f, 
    -0.02773255f, 0.02225312f, -0.01226402f, 0.08188241f, -0.10251993f, -0.15108748f, 0.10061865f, 0.06880893f, 
    0.04013691f, -0.10753642f, 0.03262922f, 0.02439960f, -0.04827143f, -0.08733474f, 0.05578607f, 0.02921722f, 
    -0.01839780f, -0.09028734f, -0.03085754f, -0.06478246f, 0.07372570f, -0.06904730f, 0.07032133f, -0.02643302f, 
    -0.15764974f, 0.35309559f, 0.23804575f, -0.16848859f, 0.04079438f, 0.02866345f, -0.00313751f, 0.00492744f, 
    0.06057390f, 0.01022856f, -0.06270000f, 0.03185088f, 0.10057344f, 0.00539374f, 0.03043138f, -0.02229526f, 
    0.05462455f, 0.00190216f, -0.08829597f, 0.01861027f, 0.16159078f, -0.01350555f, 0.03650424f, -0.16922197f, 
    -0.17314950f, -0.06513330f, 0.03270892f, 0.03363931f, -0.07956593f, 0.04033512f, -0.04447176f, -0.04360785f, 
    0.00303231f, -0.04748066f, 0.02916199f, -0.00622206f, 0.07694490f, -0.08385073f, 0.10740585f, 0.04730638f, 
    0.10469637f, -0.00327795f, -0.10598013f, -0.05179165f, 0.03179189f, -0.09712423f, -0.01281969f, 0.00495253f, 
    0.01718065f, -0.02612628f, -0.05931192f, -0.02289690f, -0.04109095f, -0.03249933f, -0.02446876f, 0.10126001f, 
    0.05494693f, -0.02514958f, 0.04064408f, 0.13251272f, -0.05470181f, 0.03160293f, 0.05546496f, -0.28155276f, 
    -0.20176193f, -0.06454752f, 0.02985947f, 0.00311107f, -0.05924689f, 0.02398470f, 0.00036558f, 0.00718265f, 
    0.03878876f, -0.00370831f, -0.00604269f, -0.10747567f, 0.00464160f, 0.02701257f, 0.12651733f, 0.03909293f, 
    0.31550881f, 0.22296344f, -0.11403467f, 0.18655819f, -0.05045624f, 0.05661464f, 0.01506500f, 0.10493248f, 
    0.09061363f, -0.03417340f, -0.06207426f, -0.00088923f, 0.04150435f, 0.05739997f, 0.06327378f, 0.09660803f, 
    0.11626387f, 0.06911944f, 0.01726533f, -0.07730583f, -0.28489992f, -0.05615476f, 0.05469372f, -0.19971676f, 
    -0.08178145f, -0.15079869f, 0.04043347f, 0.04613940f, 0.01700817f, 0.07257742f, 0.06683993f, -0.07402927f, 
    0.01308885f, 0.00945783f, 0.07006723f, 0.00950629f, -0.01684955f, 0.06718130f, -0.05167042f, -0.08615442f, 
    -0.04186080f, -0.11486123f, 0.00005263f, -0.19819960f, 0.01089407f, -0.22998419f, 0.01676783f, 0.06895889f, 
    0.11171928f, 0.03582042f, -0.01407074f, -0.01515137f, 0.03338476f, -0.18708526f, -0.08176212f, -0.00506084f, 
    -0.02938522f, 0.06677356f, 0.06510496f, 0.10712465f, 0.47751978f, -0.07033341f, -0.16403040f, -0.11610123f, 
    0.04245529f, 0.04391049f, -0.03483174f, 0.13844566f, -0.00748022f, 0.01724603f, 0.03150315f, -0.01564656f, 
    0.02937476f, 0.07883990f, -0.05303944f, 0.06192305f, 0.00102898f, 0.05451258f, 0.05178363f, -0.03273799f, 
    0.26036504f, -0.05518203f, 0.00954391f, 0.04073700f, -0.35444784f, -0.07013629f, 0.03131607f, 0.13846321f, 
    -0.02337864f, 0.02208482f, 0.01629245f, 0.00818457f, 0.06919745f, -0.09764960f, 0.02781349f, 0.02588966f, 
    -0.00201484f, -0.02220562f, 0.01439548f, -0.00689642f, 0.11540988f, 0.07305975f, 0.05133149f, 0.01115140f, 
    -0.21692188f, 0.01163354f, 0.05265491f, 0.07503733f, -0.00710998f, -0.06140983f, -0.06786234f, 0.06595998f, 
    -0.01638177f, -0.08977687f, 0.03733925f, -0.03024077f, 0.03711096f, -0.10407932f, -0.04810937f, -0.01170955f, 
    -0.16542858f, -0.25487587f, -0.10327367f, 0.22140034f, 0.14145724f, 0.02219789f, -0.01890670f, -0.02547614f, 
    -0.02936180f, 0.07922952f, -0.01643569f, 0.11312349f, 0.01571628f, -0.04276009f, -0.07879744f, -0.09338534f, 
    -0.02285289f, 0.01383708f, 0.03603533f, 0.01378742f, -0.29026669f, 0.16937956f, 0.19301431f, -0.18534721f, 
    -0.12013649f, 0.02225538f, 0.14297318f, -0.03309383f, -0.10424386f, 0.09024931f, -0.02321543f, -0.03668617f, 
    -0.01262663f, -0.06365147f, 0.05250406f, -0.02894630f, 0.01159046f, 0.14232938f, -0.16599388f, 0.02500894f, 
    -0.24430150f, -0.04628752f, -0.11346543f, 0.12438399f, 0.15850778f, 0.10455932f, -0.03150484f, -0.00268893f, 
    -0.05297942f, 0.14383887f, 0.00794192f, -0.03095952f, 0.01135657f, -0.03230448f, -0.07010876f, 0.03775591f, 
    -0.04187294f, 0.07172485f, 0.00002966f, -0.08635122f, -0.04422302f, 0.03233216f, -0.08009945f, -0.06917660f, 
    -0.10862477f, -0.02840291f, 0.07243562f, -0.06047384f, 0.04372669f, -0.01962081f, -0.03863689f, 0.07681639f, 
    -0.04033582f, 0.03554562f, -0.02696320f, -0.00095470f, -0.06379597f, -0.00277123f, 0.06759650f, 0.00483776f, 
    -0.06009428f, -0.29671672f, 0.00867156f, -0.05244664f, -0.15770817f, 0.04359660f, 0.13068485f, -0.10014581f, 
    -0.07849727f, -0.06379125f, -0.07121739f, 0.00140920f, 0.01993323f, -0.09999977f, -0.11246698f, -0.01877884f, 
    0.03355365f, -0.11702053f, -0.09509668f, -0.05742925f, -0.24683149f, -0.35659105f, 0.02245742f, 0.03669266f, 
    0.03486608f, -0.07569713f, 0.09700699f, 0.05309732f, 0.08143828f, -0.04023733f, -0.11779238f, -0.04246912f, 
    -0.02118315f, 0.01976909f, -0.04248489f, 0.08287663f, 0.05759998f, -0.04114714f, -0.00990768f, 0.06014409f, 
    0.27282619f, -0.02026734f, -0.02724044f, -0.08486211f, -0.07193898f, -0.01361821f, 0.04599178f, 0.00487812f, 
    0.01361010f, -0.13347091f, 0.05176402f, -0.04007498f, -0.05823843f, -0.05727841f, 0.05032940f, 0.06386980f, 
    0.02145233f, -0.08799902f, -0.07300867f, 0.03052491f, -0.41824597f, 0.18834686f, 0.19092922f, -0.06020476f, 
    0.17951684f, 0.07813596f, 0.06278624f, 0.00420359f, 0.01742807f, -0.02454844f, -0.01985783f, -0.00066478f, 
    0.02783818f, 0.08683020f, 0.07034513f, 0.06463888f, 0.04856291f, 0.08706842f, -0.06204043f, 0.08769565f, 
    -0.02208356f, 0.17029718f, -0.09925798f, 0.07447895f, 0.03626330f, -0.10474396f, -0.05014617f, 0.05410437f, 
    0.03408036f, -0.09085773f, 0.03452374f, 0.01339429f, 0.09588684f, -0.02554392f, 0.05219740f, 0.10223687f, 
    0.02278327f, 0.04604867f, -0.07152066f, 0.02471638f, 0.45237494f, -0.02972239f, -0.16718735f, -0.01405262f, 
    0.04560845f, -0.03182722f, 0.03189513f, 0.01921499f, -0.01695535f, -0.03167455f, -0.06666746f, -0.13893703f, 
    0.11189748f, 0.08079815f, 0.03422762f, 0.10278700f, 0.00698155f, 0.02046916f, 0.01572189f, 0.08198126f, 
    -0.19616731f, -0.11627208f, -0.05968791f, 0.11234655f, 0.00447260f, 0.00915434f, 0.02809784f, -0.11411364f, 
    -0.08907636f, 0.06348765f, -0.01800266f, 0.05549376f, -0.00565550f, -0.02091197f, 0.04561029f, -0.00596462f, 
    -0.05215482f, -0.00698511f, -0.01813387f, -0.05220880f, -0.27008536f, 0.13968699f, 0.05953053f, -0.22415730f, 
    0.05813017f, 0.11489197f, -0.01053101f, -0.11532563f, 0.02692688f, -0.01966697f, -0.00531060f, 0.01842873f, 
    0.01639717f, 0.01204886f, -0.04309859f, 0.09100529f, 0.02052282f, 0.00026292f, 0.08305609f, -0.07648306f, 
    0.08837850f, 0.02469691f, -0.05312292f, -0.12539795f, 0.11346436f, 0.12195322f, -0.17131704f, -0.00306695f, 
    -0.02701909f, 0.19217274f, -0.03447743f, -0.03372825f, 0.07087718f, 0.20942819f, 0.01229887f, 0.05273671f, 
    -0.01180978f, -0.01567405f, -0.02965894f, -0.17959021f, 0.19548352f, -0.23056956f, -0.21815431f, 0.12246384f, 
    -0.18491463f, 0.00515450f, 0.09908868f, -0.05791188f, 0.04164751f, -0.05894402f, -0.14947064f, -0.01940260f, 
    -0.04376873f, 0.13314903f, 0.01976056f, 0.02079472f, 0.00266499f, -0.02934373f, 0.02194362f, 0.09696952f, 
    -0.22803411f, -0.03631660f, -0.06899523f, 0.04047272f, -0.17340124f, 0.08426172f, -0.00106568f, 0.04850014f, 
    -0.04361312f, -0.05552159f, 0.02399395f, -0.04908239f, -0.06990553f, -0.01500847f, -0.02426139f, -0.03763450f, 
    -0.03390380f, -0.01341746f, -0.00950970f, 0.04234798f, -0.09896055f, -0.02614145f, 0.06095595f, 0.00171556f, 
    -0.13315879f, -0.02920403f, 0.02665827f, -0.00557780f, -0.09383512f, 0.02375722f, -0.00344987f, -0.03578523f, 
    -0.07120068f, -0.08195776f, 0.02637751f, -0.03317263f, 0.06475481f, -0.03998470f, 0.11593755f, 0.04097547f, 
    -0.09838482f, -0.27615651f, 0.12901475f, -0.16912097f, 0.18189400f, -0.02351451f, 0.04449567f, -0.09384605f, 
    -0.03493837f, 0.01738856f, -0.11181109f, -0.10198280f, -0.09841596f, 0.02119816f, 0.00598979f, 0.08975309f, 
    0.10539742f, -0.03182482f, -0.14482257f, 0.04962447f, 0.04927064f, -0.17310949f, 0.13456313f, -0.11465500f, 
    -0.13428478f, 0.06590217f, 0.01567882f, -0.09588125f, -0.03762443f, -0.00452502f, -0.05800996f, 0.02145280f, 
    -0.03012227f, -0.01947187f, -0.03034331f, 0.00401373f, -0.05476208f, 0.01447750f, 0.00771174f, 0.01654229f, 
    0.07103497f, -0.08665720f, -0.02416793f, 0.05073641f, -0.20895253f, 0.00694801f, 0.02012710f, 0.03864545f, 
    0.01720058f, -0.02155457f, 0.08565108f, -0.00871338f, 0.00126421f, 0.10751300f, 0.09128641f, -0.03701332f, 
    0.00277628f, -0.05757013f, 0.04320560f, 0.00563868f, -0.01497252f, -0.04444944f, 0.00988994f, -0.10674370f, 
    -0.08992855f, -0.00678700f, 0.03865404f, -0.07617538f, -0.00042534f, 0.04779531f, -0.00738759f, -0.01945368f, 
    0.00019746f, -0.03810213f, -0.03447420f, -0.03427228f, -0.11216548f, 0.05855335f, 0.00111340f, 0.04590045f, 
    -0.32931763f, 0.30886838f, -0.07353472f, 0.06450321f, -0.07804483f, 0.02515470f, -0.03894421f, -0.04408706f, 
    0.08321448f, 0.08825001f, -0.01792208f, 0.03830018f, 0.04743119f, 0.05331428f, 0.11502478f, 0.12313695f, 
    -0.04191741f, 0.08914539f, -0.03142820f, -0.03199125f, -0.22565828f, -0.11132939f, -0.11344508f, 0.11385345f, 
    0.01140953f, 0.04252399f, 0.05862654f, -0.01696908f, 0.00842238f, 0.03097130f, -0.02591331f, 0.01551518f, 
    -0.10263824f, -0.05581127f, 0.03800287f, -0.00422928f, -0.06939362f, 0.01416234f, -0.01687700f, -0.00859921f, 
    0.33633319f, -0.30262747f, 0.07447921f, -0.07955345f, 0.21674801f, -0.00801701f, -0.02385896f, -0.02681771f, 
    0.03706575f, 0.00051038f, 0.03545527f, 0.00700981f, -0.03870383f, 0.01875322f, 0.04091389f, -0.01181887f, 
    -0.08587690f, 0.00099618f, 0.01584970f, 0.14132462f, -0.17542027f, -0.14831798f, -0.02403212f, 0.18215513f, 
    -0.06376036f, -0.03408089f, -0.05978224f, -0.03622832f, 0.02478252f, 0.04269379f, -0.09712092f, -0.02271693f, 
    0.01578806f, 0.08350788f, 0.10189711f, 0.08983223f, -0.01796887f, 0.03151118f, -0.00846937f, -0.07568867f, 
    0.09206722f, -0.31759578f, 0.22229604f, -0.02345271f, 0.19455713f, -0.02581373f, 0.05468003f, -0.02788293f, 
    -0.03528617f, -0.02017195f, 0.03080581f, 0.00619040f, 0.05093274f, -0.01809492f, 0.03051311f, -0.01911308f, 
    0.04480304f, -0.04450914f, 0.00972756f, 0.08943173f, 0.24192835f, -0.01516862f, -0.00748381f, 0.10524896f, 
    0.02318625f, -0.06686325f, -0.07935090f, -0.04045481f, 0.06082509f, 0.00051626f, -0.06948152f, 0.10514385f, 
    -0.03007953f, -0.11761052f, 0.05644239f, 0.06639729f, -0.05081786f, 0.03097072f, 0.09201846f, 0.05219661f, 
    -0.23742715f, 0.06356831f, 0.01779646f, -0.07513166f, -0.26588926f, -0.06480629f, -0.06309909f, -0.06834748f, 
    -0.01229769f, -0.00452539f, -0.00094578f, 0.01981875f, -0.02541566f, 0.02129310f, 0.06583105f, 0.06935442f, 
    0.03029338f, 0.04239514f, -0.01471323f, -0.02808905f, 0.25159600f, -0.08168849f, -0.08627944f, -0.16554819f, 
    0.02979827f, -0.02791590f, -0.04221747f, 0.04795826f, 0.02573787f, -0.05056883f, -0.03037080f, -0.01305690f, 
    0.02255879f, -0.02232866f, -0.04414496f, 0.01196049f, 0.09321651f, 0.06391908f, 0.02650405f, 0.08595765f, 
    0.09270925f, -0.09539606f, 0.01126017f, 0.04616845f, -0.05669674f, 0.01551645f, -0.03263735f, -0.01868662f, 
    -0.03297368f, 0.08861949f, -0.01817351f, -0.02213015f, -0.03161290f, -0.07463380f, 0.03900989f, 0.02227483f, 
    -0.02175258f, -0.05844112f, -0.02294299f, -0.05170456f, 0.01069771f, -0.01857361f, -0.05249696f, 0.01989456f, 
    0.00023290f, 0.01650801f, -0.01868807f, -0.03428807f, 0.00676162f, 0.06072544f, -0.00368912f, -0.00246593f, 
    -0.03489307f, -0.02455744f, -0.03170659f, -0.10377724f, -0.02722729f, 0.01574722f, -0.01319861f, 0.00838758f, 
    0.33121181f, -0.42124313f, 0.18245493f, -0.05993624f, 0.05459827f, -0.04399655f, 0.00928451f, 0.10541273f, 
    0.09123915f, -0.04680007f, 0.07033782f, 0.07100098f, 0.04917837f, 0.02669000f, -0.06812268f, 0.04078342f, 
    0.04247627f, 0.10015241f, -0.09397900f, -0.00839831f, 0.07706323f, -0.26146430f, -0.01878097f, 0.07276720f, 
    0.00769388f, -0.05006370f, -0.01238928f, 0.06494495f, 0.07546832f, 0.00308539f, -0.05421725f, -0.07770956f, 
    -0.05367195f, 0.03369496f, -0.08786464f, 0.08138293f, -0.05368110f, 0.13670814f, -0.06396174f, -0.01792685f, 
    -0.10193156f, -0.06470641f, -0.10227309f, 0.07087769f, -0.14634712f, 0.11922106f, 0.00440033f, -0.02424463f, 
    0.02196322f, -0.02492709f, 0.03419215f, -0.07467784f, -0.01608011f, -0.03807888f, 0.13189718f, -0.05147683f, 
    -0.03673615f, -0.00010933f, 0.00613940f, -0.00888380f, -0.02051696f, 0.19508241f, -0.07337979f, -0.08386132f, 
    -0.00338898f, 0.01079209f, -0.03799421f, -0.00192745f, 0.00677859f, 0.05208055f, -0.03012176f, 0.04497543f, 
    0.00328220f, -0.05096131f, -0.04200917f, 0.04113567f, 0.00271883f, 0.03377933f, 0.01569993f, -0.01990770f, 
    -0.03473825f, 0.11401589f, 0.04243767f, 0.01546098f, 0.04894397f, 0.00500752f, -0.07046545f, -0.06477252f, 
    -0.01783589f, 0.04786620f, -0.01961325f, 0.01150604f, -0.02969586f, 0.04805396f, 0.00423849f, 0.05318619f, 
    -0.05761397f, 0.06401300f, -0.02259619f, 0.03164641f, 0.05156539f, -0.36347991f, 0.18409128f, -0.11911237f, 
    -0.18370809f, 0.05340997f, -0.01698627f, -0.11451849f, -0.04966945f, -0.02447935f, -0.02214326f, -0.00461642f, 
    -0.02087080f, 0.01796131f, -0.03735169f, -0.03442891f, 0.03948890f, -0.00753476f, 0.04691721f, 0.03937929f, 
    -0.30619606f, -0.29806957f, -0.17359152f, -0.09486992f, -0.04201585f, 0.03744252f, 0.02940621f, -0.02924019f, 
    0.01341118f, -0.02013342f, 0.11699781f, -0.01226360f, -0.00154833f, 0.05130381f, -0.00842783f, 0.06607989f, 
    0.03802588f, 0.03624970f, 0.08983133f, 0.02293830f, 0.17172202f, 0.05630790f, 0.07415764f, -0.02795034f, 
    -0.10848564f, -0.07074622f, -0.05937854f, 0.03766925f, 0.00442652f, -0.02036892f, -0.03031721f, 0.00073154f, 
    -0.00838470f, -0.09425028f, -0.09138390f, -0.03333013f, -0.01455045f, -0.02406533f, -0.00411357f, -0.05664970f, 
    -0.55240911f, -0.38823441f, -0.03541252f, -0.16072333f, -0.32118952f, 0.06616519f, 0.01480540f, -0.02542831f, 
    -0.03331393f, 0.06732244f, 0.05814722f, 0.06007132f, -0.00785075f, -0.00225843f, 0.05386050f, -0.02955943f, 
    -0.03254464f, 0.05577133f, -0.00113945f, 0.01498330f, 0.09967187f, 0.05720552f, -0.02234202f, -0.05222220f, 
    0.00024550f, -0.01392748f, 0.04594044f, 0.07507120f, 0.09623693f, -0.00060953f, -0.05988114f, 0.04446332f, 
    -0.04782244f, 0.06170726f, 0.02584781f, -0.06549821f, 0.12041518f, 0.10749463f, 0.02890544f, 0.09302258f, 
    -0.26542130f, 0.00147607f, -0.19666432f, -0.03627576f, 0.05923481f, 0.01338897f, 0.01141534f, -0.09689719f, 
    -0.03879076f, -0.00156551f, -0.00048369f, -0.01381094f, 0.01743400f, -0.04697459f, 0.06647840f, -0.06737674f, 
    0.00466028f, 0.11445411f, 0.03031561f, 0.03297598f, -0.20144174f, -0.19575271f, -0.09347925f, -0.00422574f, 
    0.09883723f, 0.00995469f, 0.03506129f, 0.01063619f, -0.00194930f, -0.02898530f, 0.08988913f, -0.06990156f, 
    -0.01875218f, -0.00472350f, 0.01442258f, 0.03778169f, 0.08946282f, 0.03278881f, 0.11706893f, 0.06495032f, 
    0.17883246f, 0.04820783f, 0.00180809f, 0.01850608f, -0.00967208f, -0.12330096f, 0.02134002f, -0.03505065f, 
    0.08486617f, -0.03869301f, -0.02978308f, 0.01333464f, -0.02496100f, -0.02860948f, -0.00205175f, -0.05564575f, 
    0.07028014f, 0.04324567f, 0.02903972f, 0.02750888f, -0.01366138f, -0.08723759f, 0.09290425f, 0.02614850f, 
    0.00407573f, 0.15068091f, -0.02406011f, 0.05133399f, -0.06479770f, 0.08095204f, -0.02456371f, -0.02568466f, 
    0.01185532f, 0.05721296f, -0.03939636f, -0.04045899f, -0.00810866f, -0.14360891f, -0.05639663f, -0.05191706f, 
    -0.40951037f, 0.02612830f, -0.07450024f, -0.14062306f, -0.10357960f, 0.10715289f, -0.06237570f, -0.03912995f, 
    -0.08252886f, 0.01681262f, 0.06886899f, -0.00535956f, -0.02060276f, 0.07677571f, 0.04255374f, -0.04121609f, 
    0.00647082f, 0.04671616f, -0.07917006f, 0.03864720f, 0.19354518f, 0.05385587f, -0.20087011f, 0.12454127f, 
    -0.09387153f, -0.10926368f, -0.10296334f, -0.00017897f, 0.00041139f, -0.08287204f, 0.01232880f, 0.00043800f, 
    0.00284224f, -0.12355638f, -0.08032357f, -0.09773756f, 0.01772399f, -0.01803131f, -0.01587471f, -0.04775688f, 
    0.08393066f, -0.01095208f, -0.11231339f, -0.05569465f, 0.12046653f, 0.00915218f, 0.03699128f, -0.02634447f, 
    0.05455704f, 0.01253187f, 0.02526379f, 0.04069289f, -0.00242032f, -0.05462048f, -0.04520583f, -0.06234639f, 
    0.03816345f, 0.03383070f, -0.10466893f, 0.06437168f, 0.28152895f, 0.11259679f, -0.01946765f, -0.01516260f, 
    0.05380315f, 0.05303320f, -0.00146930f, 0.07755107f, 0.03197480f, 0.01135061f, -0.04566231f, 0.03030230f, 
    0.02849654f, -0.02085266f, -0.03439360f, 0.03931867f, 0.04153684f, -0.14901255f, -0.10810324f, 0.02240475f, 
    -0.19607750f, -0.01108511f, 0.02937946f, -0.02694676f, -0.10178405f, 0.06648343f, 0.05487907f, -0.03952837f, 
    -0.01316665f, 0.01930178f, 0.00980722f, 0.03731954f, 0.02262639f, -0.01559889f, -0.00915882f, -0.02629398f, 
    0.00267461f, 0.06256270f, 0.07227453f, -0.01850175f, 0.01117270f, -0.19541501f, -0.01297748f, 0.00728665f, 
    0.05433745f, -0.10264204f, -0.00942320f, -0.05037174f, -0.01265419f, -0.01863286f, 0.03354326f, 0.01289462f, 
    0.07367975f, -0.11270198f, -0.00122931f, -0.16490804f, -0.00041260f, 0.09035602f, 0.05195682f, 0.07106608f, 
    -0.00382082f, -0.02637282f, -0.13829102f, 0.04439574f, -0.01712138f, -0.02487797f, 0.00299271f, -0.08219954f, 
    0.01892110f, -0.04854274f, 0.01304052f, 0.04371967f, 0.00560615f, -0.08263402f, 0.10262919f, -0.01495746f, 
    0.01745826f, 0.09916630f, 0.01542952f, -0.02756697f, 0.08492031f, -0.02983842f, -0.02652687f, -0.08412893f, 
    -0.04885628f, -0.02286769f, 0.05296113f, 0.01089048f, 0.02725751f, -0.01388994f, 0.01510301f, 0.03959601f, 
    -0.05761865f, 0.01153414f, -0.02689630f, -0.04854462f, -0.00647083f, -0.10616590f, -0.22115317f, 0.04571689f, 
    -0.01783481f, -0.07880915f, 0.00979115f, 0.02983513f, -0.00285464f, 0.03454328f, 0.12783851f, 0.04629201f, 
    -0.00695528f, 0.01334191f, 0.01040935f, 0.01797952f, -0.01551266f, 0.04997162f, 0.09461419f, 0.02583157f, 
    0.03793010f, -0.09654442f, -0.03050713f, 0.02362522f, 0.23238577f, 0.15709071f, 0.09055302f, -0.05119191f, 
    0.02188580f, 0.14334893f, -0.00255386f, 0.09012400f, 0.03701449f, -0.04272575f, -0.02176416f, -0.03133517f, 
    -0.00559359f, 0.05189281f, -0.04098247f, 0.02977006f, -0.00232475f, -0.08281650f, -0.01766161f, 0.00964817f, 
    -0.15134957f, -0.30337903f, -0.15138112f, -0.04615803f, 0.12695506f, 0.13179232f, 0.03914952f, 0.02922449f, 
    0.09422469f, -0.03263573f, 0.04226298f, 0.05708980f, -0.00756497f, 0.06040839f, -0.01774707f, 0.02699660f, 
    0.04239515f, -0.05781783f, 0.15446886f, 0.07705265f, 0.13881874f, 0.10130662f, 0.15589973f, -0.00126138f, 
    -0.10603968f, 0.09922605f, -0.01888999f, -0.02488268f, 0.02108794f, 0.02374693f, 0.01896088f, 0.03318067f, 
    0.06520489f, 0.04577341f, -0.00968243f, 0.03655013f, 0.06100839f, -0.03698005f, -0.05811324f, -0.00700776f, 
    0.14276344f, 0.17920893f, 0.00816968f, -0.06616521f, 0.02169965f, 0.07182298f, -0.04799503f, 0.05420109f, 
    0.04089335f, 0.03217412f, -0.02654192f, 0.05328720f, 0.04108122f, 0.01680265f, -0.00275513f, 0.11147518f, 
    0.08415581f, 0.01156741f, -0.00885241f, 0.03260958f, 0.07732331f, 0.13178435f, 0.07804836f, -0.04270559f, 
    -0.13551545f, 0.06471180f, 0.05707432f, -0.01875354f, 0.04924401f, 0.03048783f, -0.02773486f, 0.03870268f, 
    0.08132924f, 0.01297221f, -0.00622405f, 0.07087537f, 0.06675243f, 0.02747698f, -0.03079707f, 0.04217558f, 
    -0.18754095f, -0.09388415f, 0.12800832f, 0.05101956f, -0.04699952f, 0.08700897f, 0.00696841f, 0.03356008f, 
    -0.03565115f, 0.04002095f, 0.05620734f, -0.01996509f, 0.02403704f, -0.00820696f, -0.02400431f, -0.03815275f, 
    -0.04293399f, 0.01450393f, 0.10173952f, -0.00581031f, -0.08017896f, 0.02111590f, -0.24026404f, 0.09497991f, 
    0.12965240f, 0.06341932f, -0.01980441f, -0.01668869f, 0.02831884f, 0.09597778f, 0.00633068f, -0.02255890f, 
    0.03245361f, -0.07254233f, 0.09637441f, -0.03509803f, 0.02320141f, -0.00861175f, -0.05519213f, 0.04822347f, 
    0.26689121f, 0.14524926f, 0.01519106f, 0.04578236f, 0.05771854f, 0.04091497f, -0.04727044f, -0.04355507f, 
    0.02935115f, -0.00770572f, -0.07665405f, 0.04939761f, 0.02062253f, 0.02949679f, 0.01045684f, 0.11571028f, 
    0.02734757f, -0.06181249f, -0.08194444f, -0.06694892f, 0.06012530f, 0.03557086f, 0.15084404f, 0.10352688f, 
    -0.00452704f, -0.01719496f, -0.04317936f, -0.00630370f, -0.01197023f, 0.04546681f, 0.05223482f, 0.01693079f, 
    0.00360236f, -0.07261152f, -0.04677727f, -0.06239755f, -0.00395435f, 0.10422006f, -0.03522631f, 0.00592149f, 
    -0.37277234f, 0.02672645f, 0.09099822f, 0.02548176f, -0.11855838f, 0.06126355f, -0.09171586f, 0.00742486f, 
    -0.08963800f, 0.02458393f, -0.01914865f, -0.00469034f, -0.01461598f, 0.07935671f, -0.00978529f, -0.02508436f, 
    -0.06620286f, -0.00843548f, -0.12281345f, 0.02786403f, -0.38787833f, -0.29117760f, -0.05274964f, -0.06210337f, 
    -0.02638472f, 0.07184865f, -0.00328933f, -0.03640700f, -0.06576779f, 0.02572652f, 0.02893126f, 0.01236513f, 
    -0.07552553f, 0.10297278f, 0.03402563f, 0.02274370f, 0.03442585f, 0.01303978f, 0.07315166f, 0.07846737f, 
    0.18010083f, 0.09146243f, -0.02798834f, -0.02210840f, -0.16600965f, -0.07267450f, -0.11231180f, 0.07071450f, 
    -0.04418441f, -0.01572742f, 0.00750108f, -0.03976651f, 0.00741404f, 0.04681737f, -0.03951287f, -0.00686566f, 
    0.04857637f, 0.06726692f, 0.03520819f, -0.01441105f, -0.44690493f, -0.29432335f, -0.03059291f, -0.15484551f, 
    -0.18124133f, 0.07372537f, -0.02702681f, -0.04829753f, -0.01180487f, -0.05884285f, 0.15811473f, 0.02182704f, 
    -0.00467694f, 0.00397867f, 0.00839839f, -0.00532584f, -0.07531226f, -0.08839565f, -0.08367757f, -0.07283174f, 
    0.21848132f, 0.09222244f, -0.12337705f, 0.06361160f, -0.07863893f, -0.07118727f, -0.06364858f, 0.01707404f, 
    0.02873546f, -0.00162661f, 0.02603720f, 0.00031901f, -0.00118333f, -0.05089289f, -0.02305936f, -0.04340908f, 
    -0.00529867f, -0.06435387f, 0.00306270f, -0.02529540f, 0.05552124f, 0.14445654f, 0.06954023f, -0.09583196f, 
    -0.12849364f, 0.06671627f, 0.06998329f, -0.01468484f, 0.05602599f, 0.08550776f, -0.05454824f, 0.04394704f, 
    -0.00379982f, -0.03632119f, 0.04323869f, 0.11328370f, 0.03802924f, -0.03377947f, -0.05452778f, 0.10578447f, 
    -0.44426572f, -0.05845284f, 0.13272943f, -0.07227906f, -0.27773574f, 0.06251024f, -0.03648616f, -0.10299118f, 
    -0.10464881f, -0.06137293f, 0.02833713f, -0.04624041f, -0.05869273f, 0.03494650f, -0.03731961f, -0.02008058f, 
    -0.14776973f, -0.07657887f, -0.12522756f, -0.12010574f, 0.10600498f, 0.02566219f, 0.00082488f, 0.08960169f, 
    0.02246420f, 0.04200502f, 0.02570766f, 0.08164947f, 0.06945260f, -0.07078145f, -0.03092432f, 0.07188929f, 
    -0.02179684f, -0.00248561f, 0.10374650f, -0.02405625f, 0.01142938f, -0.25896823f, -0.06817761f, -0.03654316f, 
    -0.41819990f, -0.25800025f, 0.00099546f, -0.06241384f, -0.08345776f, 0.05167143f, 0.01490076f, 0.01910068f, 
    -0.02291657f, 0.06233881f, 0.02675588f, -0.01074589f, -0.01977838f, 0.05540800f, 0.05857984f, 0.00116554f, 
    -0.00047205f, 0.06653116f, 0.05109935f, 0.02655247f, -0.29607531f, -0.19666277f, 0.01886268f, -0.05839279f, 
    0.07139903f, 0.06221666f, 0.05101136f, 0.02948910f, -0.06593567f, -0.08618081f, 0.07210402f, -0.01824938f, 
    0.03898376f, -0.02406394f, -0.00992820f, 0.05028470f, -0.09754425f, -0.02778558f, 0.08882409f, -0.02654149f, 
    -0.16781797f, -0.18595409f, 0.00683495f, 0.00448208f, 0.10256651f, -0.03895801f, 0.02670411f, 0.04799125f, 
    -0.00333428f, -0.02959367f, 0.03307476f, 0.01067455f, -0.01877249f, -0.04511892f, 0.02406602f, -0.03944941f, 
    -0.05613591f, -0.15184459f, -0.02721884f, 0.07786798f, 0.00550151f, 0.02563217f, -0.05319451f, -0.08993272f, 
    0.02508327f, -0.01663251f, -0.01963890f, 0.06545445f, -0.08062995f, 0.06164249f, 0.00176918f, 0.00558457f, 
    -0.01486314f, -0.03377758f, -0.07998059f, 0.02498429f, -0.07866378f, -0.17827359f, -0.20445462f, -0.06746054f, 
    0.14831856f, -0.02050967f, -0.06945024f, 0.05923625f, -0.09654658f, -0.03146153f, -0.01403031f, -0.00549992f, 
    0.02005499f, -0.01393724f, 0.02482864f, -0.02495193f, -0.03568742f, -0.00621399f, 0.02734574f, 0.03400672f, 
    0.04578514f, -0.10083668f, 0.02295820f, -0.00057476f, -0.53715396f, -0.10021939f, -0.20712055f, -0.17820433f, 
    -0.17857131f, 0.07805271f, 0.08712859f, -0.01411538f, -0.08436305f, 0.02423996f, 0.04419044f, -0.06707031f, 
    0.05910188f, -0.00912141f, -0.01328029f, -0.04868027f, -0.05768638f, 0.04495852f, 0.05438199f, -0.01881826f, 
    0.00462751f, 0.07191818f, -0.12121762f, 0.02762912f, -0.00811606f, -0.09090925f, -0.04439916f, -0.07577962f, 
    0.04406994f, 0.04750498f, 0.04168021f, -0.00852379f, -0.03363397f, -0.10877014f, 0.00880364f, -0.14240497f, 
    -0.13716990f, 0.05061522f, -0.03723181f, -0.06035993f, -0.15664910f, -0.13593324f, 0.05602264f, 0.00534524f, 
    0.07285532f, 0.03710204f, -0.01770237f, 0.03256444f, -0.03204062f, 0.00608423f, -0.00096369f, 0.01116741f, 
    -0.00629889f, 0.05867409f, 0.03090299f, 0.00378436f, 0.01658991f, 0.04108644f, 0.02120815f, 0.11620504f, 
    -0.50288641f, -0.28719953f, 0.04861218f, 0.04964454f, 0.02763527f, 0.05844793f, 0.08844763f, -0.02734639f, 
    0.01290101f, -0.02688024f, 0.06073066f, 0.00802664f, -0.01008203f, 0.05507018f, 0.02356819f, 0.06014287f, 
    0.06702515f, 0.09518985f, -0.00305544f, 0.03033592f, 0.06015228f, -0.03416043f, 0.04252904f, 0.05958453f, 
    0.01619854f, 0.08611888f, 0.02813989f, -0.04016625f, 0.02242083f, -0.01403599f, -0.00593015f, 0.05365246f, 
    -0.01233781f, 0.04541508f, 0.02320141f, 0.03688445f, 0.04324095f, -0.07728156f, -0.06820001f, -0.03793947f, 
    -0.49928835f, -0.07333519f, -0.09106334f, 0.09716075f, 0.06732076f, 0.03957034f, -0.08752136f, -0.10975035f, 
    0.06456647f, 0.01050399f, 0.00330415f, 0.03788336f, -0.01186786f, -0.09821006f, 0.13976935f, -0.00463362f, 
    -0.05910787f, -0.15011790f, -0.04384210f, -0.11403965f, -0.45298392f, -0.30038494f, -0.22267523f, -0.12497387f, 
    -0.21538503f, -0.02775202f, 0.02344255f, -0.10708410f, -0.05381958f, 0.01198735f, -0.01149841f, -0.03751654f, 
    -0.05797996f, 0.03449137f, -0.00426770f, 0.01509379f, -0.02399834f, 0.05292974f, -0.00221648f, 0.01883359f, 
    -0.01570590f, 0.02217918f, 0.05254323f, -0.00623519f, -0.07104796f, 0.08194029f, 0.01170722f, -0.02959488f, 
    -0.01176565f, -0.00146133f, -0.00795303f, -0.03444589f, 0.05672317f, 0.01640415f, -0.03202687f, 0.00481352f, 
    0.05642262f, 0.07536677f, 0.05629712f, 0.05369614f, -0.27618027f, -0.17444529f, -0.06347411f, -0.08830635f, 
    -0.05290839f, 0.06614837f, 0.03950143f, -0.03682026f, 0.01265809f, 0.02237960f, -0.00354407f, -0.00012375f, 
    -0.01093544f, 0.04392710f, 0.06078382f, 0.09733383f, 0.01106909f, 0.06793916f, 0.04126426f, 0.04886607f, 
    -0.09464107f, -0.07843496f, 0.02424142f, 0.10944736f, 0.00870934f, 0.01686816f, 0.08170070f, 0.05861519f, 
    0.02696706f, 0.00271943f, 0.03400031f, 0.02030148f, 0.08388580f, -0.00730323f, 0.01003455f, -0.01296343f, 
    0.05337758f, -0.14067933f, 0.06073612f, -0.02951896f, 0.08054267f, -0.02899523f, -0.10195573f, 0.01159352f, 
    -0.02793754f, -0.01219996f, -0.01593806f, 0.01900862f, 0.03783272f, 0.00788982f, -0.03698021f, -0.04717480f, 
    -0.01647375f, 0.01889120f, 0.03703393f, 0.01397982f, 0.05026029f, -0.00087633f, 0.01614282f, -0.01639045f, 
    -0.28319943f, 0.02566017f, -0.23586322f, -0.05830353f, 0.13468762f, -0.02311040f, 0.04496292f, -0.07362361f, 
    0.01053470f, 0.08354997f, 0.04166580f, -0.03057708f, 0.00781341f, 0.01306070f, 0.01421724f, 0.06368935f, 
    0.04294023f, 0.08103804f, -0.04275084f, 0.07517328f, 0.07296627f, 0.08974937f, -0.00826573f, -0.05391416f, 
    -0.04338568f, 0.05501919f, -0.00859114f, 0.06724585f, -0.05697941f, 0.01564151f, -0.03155080f, 0.02931908f, 
    -0.04540047f, -0.12065928f, -0.02666002f, -0.02488737f, 0.00281485f, 0.00684942f, -0.03872138f, 0.04781305f, 
    -0.09726930f, 0.11744414f, -0.05776680f, 0.06702651f, 0.10259839f, 0.01390163f, 0.04778194f, 0.01967863f, 
    0.03840004f, 0.06965486f, 0.04369872f, 0.08061356f, 0.02852946f, 0.03799941f, -0.00411733f, 0.10332200f, 
    -0.04758275f, 0.00430668f, -0.11248724f, 0.04248154f, 0.15811968f, 0.05345279f, -0.00202533f, -0.07348006f, 
    -0.05922985f, -0.04942463f, 0.00461511f, 0.04108756f, -0.00664225f, -0.05188644f, -0.00476373f, 0.01322688f, 
    -0.02245612f, 0.08967403f, -0.07523351f, 0.02282953f, 0.01920302f, -0.00440329f, -0.15687625f, -0.05443812f, 
    -0.26786581f, -0.16906792f, 0.23468663f, 0.07607607f, -0.15519725f, 0.00119844f, 0.02204573f, 0.05609552f, 
    -0.03711419f, -0.01239004f, 0.03152510f, -0.00101631f, -0.00316938f, -0.04153030f, 0.04468594f, -0.04737327f, 
    -0.07140076f, -0.12003845f, -0.09155863f, -0.07613979f, 0.06564443f, 0.19215210f, 0.12667294f, 0.06343651f, 
    -0.07348756f, 0.01258466f, -0.00241109f, -0.06771512f, 0.01838445f, 0.09120537f, 0.02789120f, 0.02591386f, 
    0.06444564f, 0.01858406f, 0.04686849f, 0.00499168f, 0.00701849f, -0.16325429f, -0.11200492f, 0.03072761f, 
    0.22520897f, -0.02346707f, -0.07223896f, -0.02113012f, 0.00802357f, -0.11430651f, -0.02481072f, 0.01333876f, 
    0.05200294f, -0.07112864f, 0.01280746f, 0.04100655f, -0.01187848f, -0.07923326f, -0.02263491f, -0.08669767f, 
    0.05080351f, -0.04898722f, -0.04044779f, 0.02491613f, 0.15486261f, 0.03308349f, 0.00116813f, -0.00672291f, 
    -0.00627523f, -0.05167595f, -0.06309381f, 0.01987481f, 0.02911619f, -0.03524512f, -0.01872118f, 0.03182786f, 
    -0.06089824f, 0.00454046f, -0.04149536f, -0.06309041f, 0.06718520f, 0.03948992f, -0.00394051f, -0.02262242f, 
    -0.24324735f, -0.06754243f, -0.14995553f, 0.07491034f, 0.05135753f, -0.04184906f, 0.00083306f, -0.13229781f, 
    0.06498034f, -0.09021630f, -0.04336444f, 0.05532140f, 0.03511147f, -0.11410987f, 0.10696925f, 0.02180451f, 
    0.04361590f, 0.06051367f, -0.01031124f, -0.12701739f, 0.08700240f, 0.04953112f, -0.19392173f, 0.10980479f, 
    0.12049001f, 0.01066160f, -0.04264404f, -0.01107123f, -0.00248170f, 0.11227373f, -0.03656195f, 0.01761391f, 
    0.10544035f, -0.03559726f, 0.11389371f, 0.02390692f, 0.02898743f, 0.01390861f, 0.04206612f, 0.00761404f, 
    -0.01527462f, -0.08062469f, -0.06827879f, -0.02053141f, 0.04110887f, -0.01864398f, 0.03120999f, 0.00773068f, 
    -0.01500070f, -0.00210693f, 0.00919003f, -0.02707898f, -0.02329180f, -0.00183839f, -0.01639958f, 0.00073692f, 
    0.07223806f, 0.04427879f, 0.11574549f, 0.05267779f, 0.17663588f, 0.11848770f, -0.00745846f, -0.03027748f, 
    0.03526655f, 0.07165810f, -0.01597483f, 0.08781974f, -0.00649210f, 0.05617039f, -0.05169422f, -0.03039550f, 
    0.03531547f, -0.02700713f, -0.00781703f, 0.00498078f, 0.13490482f, -0.05069065f, 0.02599390f, 0.05841696f, 
    0.09231506f, 0.06830520f, -0.01285347f, 0.02487691f, 0.02448568f, 0.06623676f, -0.06061920f, 0.10871538f, 
    -0.01825837f, -0.00439264f, -0.05003409f, 0.04566199f, 0.02704546f, -0.00488946f, 0.01425543f, 0.02692568f, 
    0.05507193f, -0.02256270f, 0.03540348f, 0.02528715f, -0.45929715f, -0.23667710f, -0.15241361f, -0.03309220f, 
    -0.16855264f, 0.00082751f, 0.04475657f, -0.02562811f, -0.01205724f, 0.06101623f, -0.03190316f, 0.01625277f, 
    -0.06908104f, 0.00621421f, 0.02123812f, 0.09609438f, -0.04296773f, 0.07253344f, -0.04808288f, 0.05044948f, 
    0.32438251f, -0.27448463f, -0.03345837f, 0.00244556f, -0.09768058f, 0.12672508f, 0.06542448f, 0.00637370f, 
    -0.03195233f, -0.00002090f, 0.04587135f, 0.09602436f, 0.00147028f, 0.05481855f, 0.00239022f, 0.01394593f, 
    -0.09660991f, -0.06053915f, -0.07384658f, 0.06601804f, 0.16936432f, -0.04533713f, 0.01214140f, 0.02138595f, 
    -0.03678129f, -0.07910100f, 0.01297061f, -0.02746184f, -0.00558250f, -0.11720160f, -0.05858747f, -0.05985792f, 
    0.02801016f, 0.07879752f, -0.09426027f, -0.04398523f, -0.03286235f, -0.02319685f, -0.03792095f, 0.04324182f, 
    0.33700275f, 0.07555356f, -0.19292620f, -0.02305611f, 0.00870165f, 0.07715080f, -0.05866181f, 0.01043108f, 
    -0.04324057f, 0.04435011f, -0.01421681f, 0.04115850f, -0.00316019f, 0.00601028f, 0.00196577f, 0.01166857f, 
    0.00577405f, -0.01408502f, -0.03239338f, -0.01882103f, -0.13518493f, 0.09763587f, 0.04756714f, -0.08133128f, 
    0.01925327f, -0.02602369f, 0.04956917f, -0.00908776f, -0.01685919f, -0.04696726f, -0.04307320f, 0.02751531f, 
    0.02325350f, -0.08947620f, 0.05141295f, 0.04382779f, -0.07478480f, -0.00169119f, -0.06711847f, -0.13388246f, 
    -0.40855157f, -0.07231744f, -0.01026173f, 0.01562925f, 0.05065951f, -0.05563808f, 0.08756384f, -0.04333769f, 
    0.02564447f, -0.03069644f, -0.00616649f, 0.00952155f, 0.04127211f, 0.05547841f, 0.02617434f, -0.04181387f, 
    0.02986786f, -0.07647751f, -0.06417353f, 0.04638463f, -0.12185235f, -0.20011497f, -0.08278836f, 0.02477083f, 
    -0.10676230f, 0.19732718f, 0.04796680f, -0.01968710f, -0.03789291f, 0.03910304f, 0.04232236f, -0.02824916f, 
    -0.04063754f, 0.05601456f, -0.06290743f, -0.09998158f, -0.00618968f, -0.03906146f, -0.11396733f, 0.04482348f, 
    -0.01423145f, -0.01629349f, -0.03047537f, 0.01635929f, -0.01792480f, 0.00206741f, 0.01106554f, 0.01285084f, 
    -0.01843145f, -0.00711229f, -0.03803486f, -0.03841896f, 0.02996788f, 0.02943922f, -0.08812684f, -0.07495624f, 
    -0.05656172f, -0.00232851f, -0.07180650f, -0.02709058f, -0.01065941f, -0.09147711f, -0.08228812f, -0.05916107f, 
    0.19951825f, 0.05980051f, -0.23962851f, -0.05619918f, 0.04660674f, 0.07710993f, -0.00934379f, 0.04275998f, 
    -0.03106610f, 0.00095946f, 0.01210029f, 0.10313674f, 0.09558256f, 0.09039009f, 0.03298932f, -0.00766578f, 
    0.29444745f, -0.04880517f, -0.08423978f, -0.11117171f, 0.01584386f, 0.00567457f, 0.12879330f, -0.06795367f, 
    0.08557390f, -0.03253744f, 0.07186922f, -0.07650432f, -0.00301133f, 0.00472870f, 0.04895804f, -0.03437391f, 
    -0.00294980f, -0.08282397f, 0.04046608f, 0.00713106f, 0.12239314f, -0.09675071f, 0.04957470f, 0.03157384f, 
    -0.02233395f, -0.06187210f, 0.09665347f, 0.03020110f, -0.06089531f, -0.05867581f, -0.09484781f, -0.03381272f, 
    0.05009969f, 0.06370673f, -0.04398360f, 0.04998732f, -0.02621116f, 0.00805635f, -0.12429330f, 0.02859829f, 
    -0.47502598f, 0.18615806f, 0.00210731f, -0.05852002f, 0.06021356f, -0.01757237f, 0.00037261f, -0.00252371f, 
    0.06502656f, 0.04346526f, -0.00475734f, 0.06653646f, 0.06907476f, -0.06368048f, 0.06122573f, -0.05125752f, 
    -0.01836170f, 0.01323204f, -0.12698781f, -0.03591482f, -0.00492406f, 0.14898504f, -0.12480140f, -0.11271830f, 
    0.06321277f, -0.16863474f, -0.05972464f, -0.00441375f, -0.01703169f, -0.01610049f, 0.09902704f, 0.00243267f, 
    -0.01584318f, 0.00849754f, -0.06302773f, 0.06102085f, -0.00162676f, 0.00175061f, 0.06759786f, -0.01814237f, 
    -0.06170349f, -0.18553600f, -0.01066979f, -0.07287859f, -0.01557829f, -0.11518284f, 0.02156918f, 0.10910701f, 
    -0.02332446f, 0.04730447f, 0.02474875f, 0.07173271f, 0.00163860f, -0.05101091f, -0.01721038f, 0.00024758f, 
    0.04842319f, -0.01534391f, 0.05399688f, 0.00891527f, -0.47132605f, -0.23171087f, -0.18225646f, -0.07345002f, 
    -0.04712250f, 0.06155770f, -0.03852595f, 0.09523908f, 0.02412066f, 0.20622486f, -0.01791407f, 0.02345967f, 
    -0.00579828f, 0.00885234f, -0.00194650f, 0.07712020f, -0.03203209f, -0.05093858f, -0.11150964f, -0.09364753f, 
    -0.13399944f, -0.11260881f, 0.00116618f, -0.02592057f, -0.07255109f, -0.01293158f, 0.09561001f, -0.05172838f, 
    0.01145988f, 0.04777676f, -0.08697210f, -0.00861822f, 0.01064305f, 0.07509763f, -0.01642140f, -0.07916363f, 
    0.00002102f, -0.01000505f, -0.13026135f, -0.01530082f, -0.00092174f, 0.17551263f, -0.06060189f, -0.07847054f, 
    -0.09059610f, -0.10169808f, -0.19015345f, -0.09142769f, -0.13430823f, -0.17701742f, 0.07168790f, -0.01950485f, 
    0.07106139f, -0.05585601f, 0.01182850f, 0.11975754f, 0.04239545f, -0.07343882f, 0.07884908f, -0.01337050f, 
    -0.11558570f, 0.14380743f, 0.01088246f, -0.00798411f, 0.15067874f, 0.14580916f, -0.01308805f, -0.04969520f, 
    0.02159189f, 0.02426948f, 0.04249775f, 0.10441567f, -0.03186034f, -0.05022216f, 0.05937872f, -0.02331366f, 
    0.05101103f, 0.06431104f, -0.02202016f, 0.02352382f, -0.05824065f, 0.08905621f, -0.06929226f, -0.13059925f, 
    0.01690337f, -0.10664017f, -0.07589856f, 0.03176530f, -0.09364925f, 0.00407057f, -0.02021434f, 0.01432988f, 
    -0.04567065f, -0.00313184f, 0.01472923f, 0.02201473f, -0.08107892f, 0.01171182f, 0.10134444f, -0.04905782f, 
    0.21897848f, -0.05718243f, 0.04200301f, 0.10182030f, 0.04938585f, 0.17552254f, -0.00331573f, 0.01028681f, 
    -0.05067577f, -0.06492758f, 0.01022404f, 0.06407638f, 0.07087952f, 0.06039924f, -0.09939673f, -0.00298113f, 
    -0.06605096f, -0.05122586f, -0.06448995f, 0.02524972f, 0.04235962f, -0.01568300f, -0.02805218f, -0.08626513f, 
    0.16759466f, 0.04518725f, -0.05244583f, -0.03725677f, 0.02775028f, 0.07379188f, -0.02599237f, -0.02252033f, 
    -0.00505916f, 0.01002381f, 0.03477402f, 0.09497053f, 0.00471492f, 0.10637553f, 0.03461754f, 0.08030991f, 
    -0.05770952f, 0.05380898f, -0.06582949f, -0.06567211f, 0.09576377f, 0.03408766f, -0.03976982f, 0.01656708f, 
    0.02181643f, 0.07521646f, -0.01360758f, -0.02068335f, 0.01924140f, 0.02664870f, 0.04183016f, -0.03286040f, 
    -0.04220760f, 0.01918887f, 0.03461748f, -0.05365910f, 0.22807509f, 0.04050034f, -0.06825964f, -0.00601884f, 
    0.23501180f, 0.09076113f, -0.04505242f, -0.00882963f, 0.07740872f, 0.00441092f, 0.06660333f, -0.02569258f, 
    0.00909444f, 0.05392316f, 0.01963403f, 0.01055748f, -0.01374258f, 0.00226383f, 0.00824250f, 0.03711896f, 
    -0.03065646f, -0.34655508f, 0.06285182f, -0.06951708f, -0.01887360f, -0.02672835f, -0.09571728f, -0.00762099f, 
    0.01016679f, 0.03354777f, -0.12622127f, 0.03074230f, -0.11556363f, -0.00064601f, -0.02937802f, -0.03328604f, 
    0.07526775f, 0.03995429f, 0.01428087f, -0.06058891f, 0.02573992f, -0.25673398f, -0.02855831f, 0.17945941f, 
    0.11802805f, -0.10532574f, 0.10670085f, -0.01394217f, -0.00424015f, -0.11116281f, 0.05719877f, -0.10328604f, 
    -0.10827442f, 0.07681015f, 0.01560754f, 0.07855443f, -0.02651577f, 0.00772273f, 0.03925696f, -0.07442462f, 
    0.09297059f, 0.04338701f, -0.19944973f, 0.07982544f, -0.01184507f, -0.13280816f, 0.00395211f, 0.01690788f, 
    0.06250886f, -0.01981794f, 0.08058837f, 0.00131344f, -0.03593626f, -0.07879324f, 0.00286690f, -0.00279678f, 
    0.03227916f, -0.02177905f, 0.06511549f, 0.01473008f, -0.20635350f, -0.03129976f, -0.07585663f, -0.11951159f, 
    0.10860364f, -0.00074876f, -0.07427672f, 0.01507114f, 0.02575348f, 0.01042796f, -0.06742221f, 0.01838743f, 
    -0.00683698f, 0.04748798f, 0.00130554f, 0.03156331f, -0.04488501f, -0.05700845f, 0.00136718f, -0.02373483f, 
    0.00125789f, 0.14739999f, -0.08117718f, -0.30205795f, 0.06454854f, 0.15801203f, 0.00002582f, 0.02529711f, 
    0.09044840f, 0.05913458f, 0.03491864f, -0.05885174f, -0.03098882f, -0.05544259f, -0.00531585f, -0.01748078f, 
    0.04175469f, -0.02023449f, -0.02140352f, 0.03762322f, 0.20341001f, -0.08579590f, -0.07576263f, -0.11842068f, 
    -0.16894841f, 0.11702006f, 0.01321379f, -0.03533962f, -0.00391352f, 0.01434484f, 0.03581110f, 0.01896721f, 
    0.06392848f, -0.02814598f, -0.03335943f, -0.00146336f, -0.03713173f, -0.00694679f, 0.03130117f, 0.04900423f, 
    0.13284059f, 0.03972541f, 0.01403912f, -0.08662020f, -0.06565544f, -0.02485841f, 0.05773027f, 0.02566076f, 
    -0.01467565f, -0.14212361f, -0.02797062f, -0.13116582f, -0.04649801f, 0.02517947f, -0.04755120f, -0.05432272f, 
    -0.08816759f, 0.04667714f, -0.07839551f, -0.06772784f, 0.38133433f, 0.12890488f, -0.24120097f, 0.05616413f, 
    -0.04153221f, 0.08000716f, 0.00928522f, -0.11493912f, 0.00082160f, -0.04454647f, 0.10008974f, 0.10332892f, 
    0.03160584f, 0.09727510f, -0.03303877f, 0.01797032f, -0.01805526f, -0.03952771f, -0.06774355f, 0.07586522f, 
    0.08601786f, -0.03766399f, 0.02024529f, 0.08052024f, 0.03904774f, -0.07935936f, 0.01532730f, 0.02532520f, 
    -0.06571238f, -0.09700043f, -0.05455319f, -0.04459625f, 0.00381021f, 0.02685910f, -0.04524806f, -0.00235789f, 
    -0.03881210f, 0.03754615f, -0.03551019f, 0.03146932f, -0.02416632f, 0.09890725f, 0.01548169f, 0.04501790f, 
    0.34714156f, 0.09565125f, -0.10528112f, 0.02379599f, 0.04997877f, -0.00048395f, -0.00486241f, -0.02787057f, 
    0.10537164f, -0.01439239f, -0.07933713f, -0.09647340f, 0.04177682f, 0.09977919f, 0.06676942f, 0.01829632f, 
    0.23997091f, 0.22566482f, -0.16398905f, -0.26688236f, -0.12987012f, -0.02111806f, 0.02654113f, -0.02939051f, 
    0.05197100f, -0.00252489f, 0.10370772f, -0.02187008f, -0.05433613f, -0.00615521f, 0.04060303f, -0.05830732f, 
    -0.05291810f, 0.01525092f, 0.01802824f, 0.10811154f, -0.01037777f, 0.01611655f, -0.00921821f, 0.06920642f, 
    -0.00129728f, -0.05648543f, -0.01789330f, -0.08344388f, -0.04550515f, -0.11582034f, 0.04711013f, -0.03505500f, 
    -0.00149452f, 0.06278958f, -0.08945886f, 0.13411911f, 0.09431846f, 0.01274044f, 0.04108602f, -0.07456345f, 
    0.15396427f, -0.40197256f, -0.08772475f, -0.12426071f, -0.19769306f, 0.03685212f, -0.05354202f, 0.03988434f, 
    0.05366477f, 0.09782404f, -0.00052605f, 0.01308450f, 0.07910527f, -0.04785539f, -0.01445324f, -0.01365480f, 
    -0.00546814f, -0.06932651f, 0.01089146f, -0.05849762f, 0.05055101f, 0.05309458f, -0.10449702f, 0.04520991f, 
    -0.08516565f, 0.09547973f, -0.00066060f, 0.02334151f, -0.01328850f, 0.00407528f, 0.00968094f, -0.03164343f, 
    -0.02529725f, -0.00175240f, -0.06249046f, -0.03027661f, 0.02601877f, -0.07823881f, -0.09368453f, -0.01608649f, 
    -0.08149154f, 0.09609093f, 0.01966302f, 0.03741798f, -0.19684552f, 0.06677259f, -0.04717159f, 0.02938749f, 
    0.02891406f, 0.02955016f, 0.00326824f, -0.05833120f, -0.01368329f, 0.00808316f, 0.02906960f, -0.04825051f, 
    0.02457985f, -0.02863966f, 0.01343234f, 0.06903021f, 0.01863355f, 0.10186230f, 0.00062689f, -0.13245462f, 
    0.17406711f, -0.10031907f, -0.14694671f, -0.05069460f, -0.02584049f, -0.07821171f, 0.01566033f, -0.06038972f, 
    0.06047441f, 0.01098468f, -0.00444089f, -0.00514532f, -0.11160199f, -0.04303672f, 0.02407926f, 0.11134460f, 
    0.01833071f, 0.05203070f, -0.03974630f, 0.01233047f, -0.00439096f, 0.05658552f, -0.04863438f, 0.01946382f, 
    -0.07053858f, -0.08757775f, 0.00710832f, -0.03415567f, 0.01731602f, -0.07595237f, -0.07531171f, 0.01598585f, 
    0.03712710f, 0.03786024f, 0.02403209f, 0.00462792f, 0.14354952f, -0.18288557f, -0.18370356f, 0.06490684f, 
    -0.15588701f, 0.00619573f, 0.05262994f, 0.13149744f, -0.01968828f, 0.02192293f, 0.07775906f, 0.02850417f, 
    -0.05631648f, -0.05260791f, -0.03224137f, 0.01612400f, 0.01970236f, -0.06080565f, 0.04229759f, -0.06701003f, 
    -0.43260080f, -0.13514535f, 0.09614935f, -0.08130410f, 0.17863461f, -0.12245045f, 0.10869551f, 0.04163308f, 
    0.11062166f, -0.19959320f, 0.01483264f, -0.05042477f, 0.08275939f, 0.05758494f, -0.03968099f, -0.03838478f, 
    -0.04898061f, -0.02457727f, -0.14212851f, 0.04148068f, -0.42208701f, 0.24243562f, 0.03953813f, -0.05517435f, 
    0.26018775f, 0.13589135f, -0.08733895f, 0.09761985f, 0.01651334f, 0.09862559f, 0.00834041f, 0.09285923f, 
    0.08070342f, -0.00442990f, -0.00871623f, -0.00309000f, 0.12497811f, -0.03083360f, -0.15479672f, -0.06682083f, 
    -0.12060682f, 0.13791363f, -0.06038824f, -0.01124723f, -0.10462887f, 0.10586338f, 0.01532956f, -0.03061300f, 
    0.04599690f, 0.07349178f, -0.03567726f, 0.05014013f, -0.03217961f, -0.03860920f, 0.14349136f, 0.04306744f, 
    0.07497074f, 0.02295634f, -0.08226604f, 0.09124390f, -0.12164833f, 0.14697215f, -0.07588795f, -0.09180251f, 
    0.13535245f, 0.04034333f, -0.06006051f, 0.01706552f, 0.02245043f, -0.00582851f, 0.03175669f, 0.08065061f, 
    0.01245108f, 0.01280887f, 0.01983622f, 0.04321646f, -0.00131006f, 0.09392299f, -0.00172185f, -0.01044520f, 
    -0.02854034f, 0.05128615f, -0.18646640f, 0.12538688f, -0.39827725f, -0.07457317f, -0.04952222f, 0.03523668f, 
    0.00317079f, -0.14812884f, 0.10965142f, -0.14291757f, 0.08739278f, 0.09981593f, -0.01444285f, 0.12977849f, 
    0.05795835f, -0.01654423f, -0.08190604f, -0.05877993f, 0.39729589f, -0.05390033f, -0.27708998f, 0.00647620f, 
    -0.20630915f, 0.01626067f, -0.02740571f, 0.03030434f, -0.01589317f, 0.04334081f, 0.04756565f, 0.00341124f, 
    0.02339987f, -0.00370857f, 0.02843839f, -0.01739700f, -0.04112193f, -0.03696276f, -0.04006618f, -0.00917367f, 
    -0.06968124f, 0.16667242f, -0.02149128f, -0.14225145f, 0.11034634f, 0.12232374f, 0.00916184f, 0.02321383f, 
    0.04242953f, 0.09135457f, 0.00984929f, 0.00518355f, -0.00854559f, -0.03218805f, 0.10755823f, -0.01219931f, 
    0.03540364f, -0.07010075f, 0.01996459f, -0.03050470f, 0.29996714f, -0.00352897f, -0.14905229f, 0.05242210f, 
    -0.00254543f, 0.00976225f, 0.02081798f, 0.00136774f, -0.01138007f, 0.05516283f, 0.00293155f, 0.07548133f, 
    -0.01249995f, 0.02874133f, 0.01053468f, -0.00272653f, 0.03705541f, 0.03588091f, -0.04684682f, -0.03208809f, 
    -0.02250524f, 0.06039388f, -0.06599328f, 0.04385990f, 0.00170378f, 0.00896412f, 0.03036123f, 0.02512111f, 
    -0.06503996f, 0.01820169f, 0.04037418f, 0.05648432f, -0.05207364f, -0.00974424f, -0.00753699f, -0.03041320f, 
    0.01635811f, -0.04491507f, 0.03219392f, -0.02378755f, -0.08106504f, 0.04376072f, -0.03551184f, 0.00025231f, 
    0.01534403f, 0.05867338f, -0.03983297f, 0.04696610f, -0.07947368f, 0.00294069f, -0.00292720f, 0.00104664f, 
    0.00981959f, -0.06513928f, -0.02530024f, -0.03849119f, 0.04954870f, 0.01970514f, -0.00623765f, -0.06430473f, 
    -0.09169605f, 0.12497738f, 0.02722538f, 0.05721111f, 0.01421973f, -0.05806356f, 0.05200994f, -0.04709326f, 
    0.00045360f, 0.02226080f, -0.07949141f, 0.08890314f, 0.02332742f, 0.07234447f, 0.00810590f, 0.01026742f, 
    0.00607222f, -0.04078958f, 0.03527483f, -0.01316344f, 0.20912267f, 0.00331866f, 0.01181564f, -0.01309235f, 
    0.03974093f, -0.12171961f, 0.10235336f, -0.00768848f, 0.02741249f, -0.08623029f, -0.04402397f, -0.00801103f, 
    0.02799763f, 0.07877337f, -0.06286433f, -0.05640046f, -0.05545038f, 0.04625274f, -0.06662083f, 0.00821673f, 
    -0.03383926f, 0.11780352f, 0.05233633f, -0.00792940f, 0.00495616f, -0.07355825f, -0.06716668f, -0.07533678f, 
    0.04438224f, -0.02401404f, -0.00087736f, -0.02344446f, 0.01211720f, 0.04204497f, 0.02577141f, 0.07823133f, 
    0.00996190f, -0.00788732f, -0.01181018f, 0.02749918f, -0.03884798f, 0.17319851f, 0.01861248f, -0.04002840f, 
    0.00852037f, -0.16268957f, -0.04462119f, 0.02774222f, -0.08847825f, -0.12643345f, 0.05087737f, -0.04308303f, 
    0.04765185f, -0.12416147f, -0.03645959f, -0.07216532f, -0.04510432f, -0.11163209f, 0.05946912f, 0.04099141f, 
    0.07954364f, 0.15956037f, -0.04710617f, -0.10400813f, 0.04112501f, 0.01351649f, -0.02887360f, 0.04556045f, 
    -0.05467695f, 0.02293248f, 0.03174769f, 0.02769798f, -0.12182222f, -0.05115368f, -0.04510034f, 0.00020267f, 
    0.06619085f, 0.06938642f, 0.06759635f, -0.00024814f, -0.04357900f, -0.06385092f, 0.00565633f, -0.00533693f, 
    0.32276821f, 0.03497551f, -0.05177254f, 0.07837269f, 0.03579823f, -0.02433902f, -0.00899055f, -0.09553412f, 
    0.00042430f, 0.11205025f, 0.01861468f, 0.05733689f, 0.06661458f, -0.04895659f, 0.06842317f, 0.03245148f, 
    -0.18012361f, 0.07511832f, -0.08793733f, 0.06706597f, -0.06086046f, 0.02178333f, -0.04310425f, 0.00271909f, 
    0.02049203f, 0.07506519f, -0.00765807f, -0.05960599f, 0.05487480f, -0.07844622f, -0.01327180f, 0.03847469f, 
    -0.00630652f, -0.02195037f, -0.07164475f, -0.06267698f, -0.02091047f, -0.18036398f, 0.06217258f, -0.03715497f, 
    0.00924647f, -0.00450300f, 0.08444170f, 0.00620982f, -0.03471281f, 0.02502222f, -0.02880422f, 0.06383277f, 
    0.03351000f, 0.01444024f, -0.11307836f, -0.02820320f, -0.11130247f, -0.03631978f, -0.06265143f, 0.01576370f, 
    -0.16858837f, -0.16379337f, -0.07429334f, 0.05124486f, -0.25133115f, 0.05227853f, 0.08760659f, -0.05206519f, 
    0.02587339f, 0.01542307f, -0.08936179f, -0.07095474f, 0.02162175f, 0.03911104f, 0.02515670f, -0.11471128f, 
    0.03095070f, -0.02252812f, -0.10720745f, -0.14558278f, -0.11372817f, 0.03018207f, -0.05759626f, 0.12071624f, 
    -0.05810537f, 0.01938598f, 0.09058867f, -0.01153283f, -0.01633252f, -0.11414516f, 0.00492330f, -0.06750362f, 
    0.04662164f, 0.06398227f, -0.00557866f, 0.03901990f, -0.04067883f, 0.11190960f, -0.06694712f, -0.10700440f, 
    -0.29245785f, 0.19497345f, -0.07644346f, -0.06226832f, -0.03885567f, 0.08356650f, 0.00458466f, 0.10017893f, 
    -0.00970329f, 0.09169871f, -0.02893656f, 0.02082585f, 0.00730942f, -0.10853844f, 0.01514860f, 0.01077060f, 
    0.05536965f, -0.10164136f, -0.03859783f, -0.14028449f, 0.12284850f, -0.06130928f, -0.08304041f, 0.07312872f, 
    0.05256568f, 0.07333574f, 0.00984651f, -0.06564324f, 0.09261752f, 0.07343390f, 0.10633847f, 0.02491875f, 
    -0.01024537f, 0.09839819f, -0.03955235f, 0.03794505f, -0.04944472f, 0.00708870f, 0.03360790f, -0.01710750f, 
    0.16091053f, -0.06738386f, -0.00622419f, 0.07038058f, 0.01136615f, 0.00836136f, -0.05357032f, -0.00796164f, 
    0.05464313f, -0.03179245f, 0.06274650f, -0.03118083f, -0.03198830f, 0.04098553f, -0.03238508f, 0.00766629f, 
    -0.00386423f, 0.00853466f, -0.06058589f, -0.01450732f, 0.39157483f, 0.00322914f, -0.15278190f, -0.09148952f, 
    -0.06352597f, -0.03116710f, -0.13111942f, 0.00433438f, -0.00010431f, 0.04627691f, 0.04911399f, 0.00065702f, 
    -0.08014205f, -0.06028527f, -0.04929988f, 0.03951908f, 0.02195495f, -0.01308135f, -0.04296613f, -0.00464693f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03285718f, 0.02845582f, -0.02034407f, -0.03856627f, -0.01064184f, 0.02852801f, 0.02309268f, -0.06000760f, 
    -0.02496249f, 0.01454240f, 0.04457822f, 0.01866077f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
