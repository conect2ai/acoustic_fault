#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.55793434f, -1.38347399f, 0.22649273f, 0.77794611f, 1.36440539f, 1.19508326f, -0.55625457f, 0.08584230f, 
    -0.26535025f, 0.73058903f, 1.65425301f, -0.54197860f, 0.14962453f, 0.38142523f, -0.52426410f, 0.91762775f, 
    -0.22999994f, 0.30388793f, 1.50881565f, 1.12974966f, 0.29403815f, 1.01010609f, 0.29914546f, -0.10141870f, 
    -0.87974358f, 0.02555043f, -0.78264976f, 1.27038050f, 0.27732918f, 1.39146304f, 0.79699767f, -0.01034535f, 
    0.34886363f, 0.70806855f, 0.59838635f, -0.07413367f, -0.14405003f, -1.91316414f, -1.07654500f, -0.95496655f, 
    -0.38558817f, 0.04132923f, 0.45283753f, 0.73258299f, 0.33624512f, 1.59191978f, 0.69432276f, -1.31975818f, 
    0.27285227f, -0.10699394f, -0.76862103f, -0.13035285f, 0.05559824f, 0.74781460f, -1.29966187f, 1.06644642f, 
    0.92441541f, -1.26103377f, 0.69363821f, 0.27420014f, 0.04791408f, -0.24857686f, 0.46170771f, -0.84882158f, 
    -1.22119904f, 0.59100807f, -1.12901163f, -0.70883405f, -1.10294712f, -0.51421672f, 0.52989662f, -0.88733310f, 
    -0.52033550f, -1.84467840f, -1.03806722f, 0.98861867f, 0.90592968f, -0.74519074f, -0.33844429f, -0.21953005f, 
    0.22314923f, -1.78635263f, 0.35136580f, -0.51980060f, 0.63925481f, 1.77614057f, -0.43980399f, 0.17826408f, 
    -0.10650186f, 0.08785774f, -1.73842025f, -0.01707665f, 0.80567491f, 0.90001667f, 0.58837378f, 0.80511093f, 
    -0.28219256f, -0.41976798f, -0.60906798f, -1.55458057f, 1.59150422f, 0.04022506f, 0.44768411f, -0.21507855f, 
    -0.21187691f, -0.63453239f, -0.26142412f, -0.34242246f, -1.20099592f, -1.01295364f, -1.25915718f, -1.08065653f, 
    0.90959841f, 1.07906640f, 0.18799877f, -0.41963315f, 0.25464022f, 1.36938214f, 1.50144923f, 1.07461488f, 
    -0.68084747f, -1.42917323f, -0.60934430f, 0.09855501f, 0.25748724f, 0.10783091f, -0.27001482f, 1.37869704f, 
    1.18986750f, -0.01496264f, 1.29562807f, -0.33328950f, -0.48568428f, 0.37950331f, -0.14833547f, -0.30808511f, 
    0.84813666f, 0.11727249f, -1.48273122f, -0.84673262f, -1.15199494f, 0.55812049f, 0.35917997f, -0.23729584f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12687930f, 0.43607512f, 0.28317466f, 0.27553785f, 0.65210730f, 0.10247540f, 0.12416906f, 0.17005597f, 
    0.39293078f, -0.19222072f, 0.07660720f, -0.05767923f, 0.37497342f, -0.00066465f, 0.54239070f, 0.28647125f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07769156f, 0.15015674f, 0.03759817f, -0.14151949f, -0.24969818f, 0.12545429f, 0.09443437f, 0.05774532f, 
    -0.12964392f, -0.11827178f, 0.02698812f, -0.05688073f, 0.03898833f, -0.10511205f, 0.06423786f, 0.10197306f, 
    0.10761338f, -0.07434029f, -0.01907832f, 0.04199789f, -0.03797147f, 0.07080563f, 0.08108328f, -0.11574978f, 
    0.27236590f, -0.27801058f, 0.17985845f, 0.13687925f, 0.10634858f, 0.06145614f, -0.04662252f, -0.04562652f, 
    0.06685537f, 0.04750133f, 0.04557858f, 0.02691881f, -0.12345130f, 0.16306819f, -0.29472482f, -0.06782778f, 
    0.30622399f, -0.03644893f, 0.07702909f, -0.06506344f, 0.41099682f, -0.10930352f, -0.28589335f, -0.04923661f, 
    0.04628270f, -0.05361590f, -0.08160017f, 0.17502581f, -0.07125529f, 0.04700305f, -0.05093124f, 0.10715874f, 
    0.13850571f, -0.08515072f, -0.02209508f, 0.04312919f, 0.08890305f, -0.33691621f, -0.14214168f, -0.25969586f, 
    -0.22098361f, -0.16956130f, -0.03603762f, 0.07491693f, -0.05712612f, -0.05681980f, -0.01052139f, 0.11872131f, 
    -0.12700287f, 0.04849613f, -0.18920165f, -0.13153128f, -0.20647320f, 0.11062340f, -0.06116875f, 0.11440557f, 
    -0.27013913f, -0.52770686f, -0.19598919f, 0.15714154f, -0.34546930f, 0.03260650f, -0.15718402f, 0.14300562f, 
    0.10821938f, -0.02918090f, 0.05755946f, -0.02767241f, -0.00598570f, -0.08045333f, 0.16763209f, 0.12355050f, 
    -0.07695714f, -0.01661056f, 0.13581833f, 0.04409936f, -0.03628074f, -0.25810874f, 0.20885968f, -0.33414271f, 
    0.48435196f, -0.29505813f, -0.03727313f, -0.14228500f, 0.13208759f, 0.14586750f, -0.03579037f, 0.01746135f, 
    0.07891869f, 0.06969664f, -0.12160832f, 0.15006417f, -0.12881476f, 0.08802892f, -0.03780628f, -0.12484738f, 
    -0.27524489f, -0.10925966f, -0.01755042f, 0.05809798f, 0.33096251f, -0.08537277f, -0.09709924f, -0.03348772f, 
    -0.00146985f, -0.16226994f, -0.01834230f, -0.09618653f, 0.13074194f, 0.08151469f, 0.02003640f, 0.02474668f, 
    -0.11805178f, 0.03016851f, 0.06018690f, -0.06989531f, 0.00032023f, -0.63923919f, -0.19065505f, 0.35802230f, 
    -0.32068241f, -0.02087095f, -0.05016375f, 0.05581588f, 0.20642594f, 0.00936354f, -0.19380420f, 0.13588777f, 
    -0.06726731f, -0.19290087f, -0.19549243f, 0.09016490f, -0.07893430f, 0.08638926f, -0.14640324f, 0.02967730f, 
    -0.28097355f, -0.18792105f, 0.02800487f, 0.02368866f, -0.33712092f, 0.04367287f, -0.08875790f, 0.23169430f, 
    -0.07784665f, -0.19081403f, -0.04535671f, 0.03294574f, 0.08703043f, -0.04757234f, 0.07033127f, -0.04185931f, 
    0.08659308f, 0.08389071f, -0.25910041f, 0.08269715f, 0.89063781f, 0.22342791f, 0.39549869f, -0.24159712f, 
    -0.28528741f, 0.02470684f, 0.20448354f, -0.13963670f, 0.04156789f, -0.02010768f, 0.05717775f, -0.01410931f, 
    -0.19369046f, -0.05076466f, 0.12252179f, 0.03093613f, 0.01304128f, -0.01183187f, 0.08970376f, -0.03270288f, 
    0.00488247f, 0.13303556f, 0.31984231f, 0.18607970f, -0.12531625f, 0.00816333f, 0.20352095f, 0.06865035f, 
    0.10819446f, 0.06848650f, -0.03595634f, -0.10946565f, 0.06667963f, -0.20316689f, -0.07017266f, 0.09345460f, 
    -0.08949214f, -0.17996214f, 0.11643119f, 0.07135171f, 0.12895182f, 0.25043860f, 0.19451998f, 0.23144244f, 
    0.20319583f, -0.04436805f, -0.23766479f, 0.09901319f, -0.08613457f, -0.09587944f, 0.03838265f, -0.00018350f, 
    -0.08114880f, 0.01360620f, 0.02494814f, -0.10620719f, -0.22468236f, 0.12876762f, -0.10142633f, -0.05769578f, 
    -0.58633178f, 0.60051018f, -0.26892602f, -0.10367543f, -0.54787117f, 0.07371698f, 0.10410464f, -0.05306024f, 
    0.09250665f, -0.07821514f, 0.14449057f, 0.00179531f, -0.04126808f, 0.27340013f, 0.00650152f, -0.12318705f, 
    -0.09975916f, -0.03404881f, 0.13428582f, -0.07220891f, 0.28230920f, 0.15455976f, 0.12554762f, -0.29918778f, 
    0.12351180f, -0.21186157f, -0.30493057f, -0.09094132f, 0.11636654f, 0.03867345f, -0.01683450f, -0.15996921f, 
    0.05065985f, 0.01183777f, -0.00084466f, 0.06082203f, 0.12564789f, 0.06891292f, 0.06644625f, -0.04813269f, 
    -0.28171265f, -0.06123688f, 0.24206460f, -0.18001108f, 0.21461177f, -0.06358796f, -0.07668550f, 0.00843086f, 
    -0.18811829f, -0.01384825f, -0.12963705f, -0.07317791f, -0.02440372f, -0.07229389f, 0.03520104f, -0.00627929f, 
    0.02186047f, 0.04332582f, -0.08860444f, -0.06107104f, -0.16050136f, -0.14670815f, -0.07702140f, 0.24465938f, 
    -0.06096219f, 0.03147800f, -0.00620329f, -0.03048571f, -0.14596407f, -0.02300242f, -0.01745563f, 0.09424481f, 
    -0.04010189f, 0.01488559f, -0.05795500f, 0.02355747f, -0.00099836f, 0.01534168f, 0.10030371f, -0.25672296f, 
    0.62236983f, -0.15893975f, -0.00923899f, 0.13311437f, -0.14175440f, -0.04262840f, 0.28709039f, -0.03418010f, 
    0.11176473f, 0.02580415f, 0.19326945f, 0.09058408f, 0.00676302f, 0.04093422f, -0.22075093f, 0.07741671f, 
    0.11820380f, -0.05313595f, 0.06423214f, 0.07775580f, 0.34238580f, -0.10669356f, -0.00257512f, -0.10577925f, 
    0.26810831f, -0.12574321f, -0.18885396f, 0.01293766f, -0.04815049f, 0.08141606f, -0.12799163f, 0.06958389f, 
    0.10415728f, 0.04076138f, 0.01282121f, -0.07756899f, 0.01425607f, -0.13942331f, 0.09424986f, 0.12236151f, 
    0.48838642f, 0.01583202f, 0.28709719f, 0.04857950f, 0.32401228f, -0.03568970f, -0.04257507f, -0.14934896f, 
    0.02847300f, 0.02908030f, -0.10569596f, -0.14176349f, -0.13224149f, -0.06336793f, -0.07812103f, -0.02945183f, 
    -0.03156216f, -0.05488282f, 0.12415988f, 0.04851795f, 0.02401879f, 0.20913352f, 0.37438059f, 0.08016944f, 
    0.05241909f, -0.36385345f, -0.27083263f, -0.06402060f, 0.00477706f, 0.10230756f, 0.02538017f, -0.12374067f, 
    0.07691453f, -0.06741099f, -0.07681745f, -0.18906957f, 0.15824033f, -0.00006249f, -0.03438858f, 0.15853301f, 
    0.17237295f, -0.22952572f, 0.03431077f, 0.10381072f, 0.12277327f, -0.06047179f, 0.12262164f, 0.20107807f, 
    0.21439418f, 0.05263323f, -0.14518917f, -0.01120309f, 0.16505386f, 0.08863738f, -0.05625283f, 0.23029819f, 
    0.06583815f, -0.02202361f, -0.15523548f, -0.09939382f, 0.44158289f, -0.54038244f, 0.34746042f, -0.39849964f, 
    -0.01028221f, -0.03040652f, -0.40786308f, -0.01635068f, 0.03260991f, -0.09362874f, -0.07847615f, -0.04770616f, 
    -0.11322209f, -0.07814631f, 0.17974262f, -0.17755139f, -0.14450060f, -0.22537141f, -0.05287501f, -0.09956955f, 
    -0.58440322f, 0.03660670f, -0.27342030f, -0.55100369f, -0.22171995f, -0.00819626f, 0.25668597f, 0.01000925f, 
    0.00273470f, -0.17780872f, -0.12777492f, -0.12207920f, -0.07935173f, -0.02515960f, 0.00355473f, 0.07116481f, 
    -0.08543462f, 0.11048911f, -0.06614325f, -0.02881866f, -0.21410331f, -0.04168289f, -0.09750322f, -0.11038515f, 
    -0.41780305f, -0.02802539f, -0.03048367f, -0.03828334f, 0.05547034f, 0.04441136f, -0.08093336f, -0.21315266f, 
    0.03845232f, 0.04914512f, -0.02460697f, -0.15789557f, 0.04696462f, -0.17517743f, -0.21043563f, 0.11609349f, 
    0.33364046f, -0.09614211f, -0.29268107f, 0.04270678f, -0.32229134f, 0.09891804f, 0.07259402f, -0.00779430f, 
    -0.01657259f, 0.09408016f, -0.05951070f, -0.03676043f, 0.00602069f, 0.08775946f, 0.02351216f, 0.03849503f, 
    0.06800063f, -0.05010713f, 0.11728334f, -0.09130463f, -0.81592560f, -0.01129946f, -0.21239544f, -0.13494882f, 
    0.09543704f, -0.07586544f, 0.19218600f, -0.09709947f, 0.01279922f, 0.05779007f, 0.05017883f, 0.13436405f, 
    -0.04353372f, -0.09295517f, -0.03349435f, 0.15939169f, -0.02176524f, -0.01608903f, -0.00856354f, 0.03780121f, 
    -0.47337773f, 0.07897664f, -0.25194442f, -0.00674525f, -0.13380429f, 0.08352005f, 0.04555355f, -0.06483732f, 
    -0.22400036f, 0.08960864f, 0.07950577f, 0.32435146f, -0.07598969f, -0.00543229f, 0.17138121f, -0.02630789f, 
    -0.07139438f, 0.14678790f, -0.03158530f, -0.00901989f, -0.34812215f, -0.27284592f, -0.58901584f, -0.19351596f, 
    0.07443468f, 0.06918994f, 0.02318873f, -0.01792198f, -0.16502227f, -0.10076900f, 0.08819080f, 0.13883922f, 
    -0.03051408f, -0.14405139f, 0.03213628f, 0.10948753f, -0.10744717f, -0.05019623f, 0.16647431f, -0.21432063f, 
    0.62536716f, -0.06798127f, -0.13132857f, 0.04284950f, -0.41109729f, -0.11136117f, 0.01056358f, 0.05133968f, 
    0.07681581f, 0.09566769f, -0.00029034f, -0.03478063f, -0.01012732f, 0.06731875f, 0.10223129f, 0.06370497f, 
    -0.01277213f, 0.04463177f, -0.13575478f, 0.10286423f, 0.02054884f, 0.11341508f, 0.01976154f, 0.20747323f, 
    0.22329172f, -0.06990919f, -0.12343977f, 0.12981038f, -0.04972188f, -0.03961259f, -0.07799760f, -0.09659548f, 
    0.07841799f, 0.08173879f, -0.03946095f, 0.03165373f, -0.01776667f, -0.16964689f, -0.17457873f, -0.10535558f, 
    0.07748647f, 0.42628503f, 0.06771944f, 0.01088987f, 0.37481889f, -0.11768038f, 0.18536158f, 0.02888821f, 
    -0.03822551f, 0.14131404f, 0.17518282f, -0.13981481f, 0.22261810f, 0.00996830f, -0.12433635f, 0.05883222f, 
    0.02741342f, 0.14662679f, -0.07863221f, 0.03046888f, -0.24791536f, -0.17274337f, -0.34083867f, -0.12237770f, 
    -0.36137986f, 0.09241761f, -0.14953537f, 0.06054238f, 0.00429193f, 0.00323386f, 0.04609567f, 0.00103931f, 
    0.18841013f, 0.09469494f, -0.09729522f, -0.24416402f, 0.05428385f, -0.15019199f, -0.22125968f, 0.03775489f, 
    -0.02686543f, 0.23150533f, 0.23871577f, 0.15125488f, 0.22019990f, -0.09027607f, -0.28047648f, -0.04989928f, 
    0.29033089f, 0.05943562f, -0.01579860f, -0.02702230f, -0.04472335f, -0.08947722f, 0.02991186f, -0.18308425f, 
    -0.08734575f, -0.14333571f, -0.04983728f, -0.07956301f, 0.30848062f, 0.03684507f, -0.00245833f, -0.12652688f, 
    0.02426624f, 0.00756372f, -0.05919374f, 0.26982051f, -0.10353673f, -0.09123652f, -0.13905439f, -0.10898655f, 
    -0.01594657f, 0.05892523f, -0.03481032f, -0.06389701f, -0.22446284f, 0.18377708f, 0.05383116f, 0.07242677f, 
    0.20076816f, -0.39345041f, 0.09651411f, -0.16616091f, 0.00039489f, 0.20305012f, -0.03553742f, 0.19435258f, 
    -0.02779937f, 0.07180575f, -0.08186339f, -0.01166125f, 0.13881789f, -0.03628844f, -0.14613794f, 0.01487086f, 
    -0.10583378f, 0.07516025f, -0.25557753f, -0.16096121f, -0.38796982f, 0.24201569f, 0.12599276f, -0.07314955f, 
    0.27233669f, -0.08481009f, 0.15258081f, 0.12933867f, 0.08224781f, -0.28483328f, 0.05731713f, -0.01130751f, 
    0.01791447f, 0.12045308f, 0.05758614f, 0.05283466f, -0.12537980f, -0.14894074f, -0.02797399f, -0.14315961f, 
    0.72319782f, -0.54314923f, -0.10103275f, -0.08334213f, -0.51287514f, -0.18003707f, 0.14229579f, -0.05216449f, 
    -0.18511759f, -0.07390091f, -0.02218516f, 0.02358988f, -0.00954144f, -0.11040539f, -0.02805021f, -0.03376393f, 
    0.04342319f, 0.24686149f, 0.09467525f, -0.02515083f, 0.06611075f, -0.17429730f, 0.04447699f, -0.51103723f, 
    -0.49085778f, 0.07440484f, -0.18716957f, 0.19986282f, -0.09259714f, -0.03796666f, -0.21440047f, 0.15724744f, 
    0.04002188f, -0.09345109f, 0.00998533f, 0.16309230f, -0.05686332f, 0.15823960f, 0.04608024f, 0.01218930f, 
    0.37552354f, -0.01932079f, -0.59942597f, -0.01722042f, -0.50533825f, -0.01104951f, 0.17389849f, 0.00897731f, 
    -0.16975860f, -0.09208575f, -0.05823838f, -0.08952314f, -0.04088616f, -0.02231920f, -0.06798796f, 0.11789431f, 
    0.02554673f, -0.14998475f, 0.18975657f, -0.04640039f, 0.40754649f, -0.36907530f, -0.22508809f, -0.25437561f, 
    -0.45458218f, -0.32791382f, -0.05904524f, -0.04397862f, 0.01949438f, -0.05215266f, 0.01517079f, -0.02876406f, 
    0.00058056f, 0.05299804f, -0.06919009f, 0.04097760f, -0.11081354f, 0.00875000f, 0.08915780f, -0.21681751f, 
    0.15169536f, -0.54493088f, 0.37892449f, 0.04483775f, 0.25007015f, -0.25623733f, -0.23273185f, -0.11455320f, 
    0.13157028f, 0.20006500f, 0.15987623f, -0.14882946f, -0.16922046f, 0.09634847f, 0.09482528f, -0.03652674f, 
    -0.02002312f, 0.02302894f, 0.09272980f, -0.01968852f, 0.67671281f, -0.04261024f, 0.17052650f, -0.11819943f, 
    0.26393604f, 0.08974179f, -0.17108220f, -0.20822601f, -0.04251945f, 0.13407256f, 0.03176665f, -0.13163564f, 
    0.02308377f, 0.01678088f, -0.01047345f, 0.07581735f, -0.31006429f, 0.06460138f, -0.00422399f, 0.02356725f, 
    0.51333648f, -0.00281726f, -0.03380150f, 0.08031180f, 0.30497897f, -0.12446091f, -0.31331727f, 0.02668315f, 
    0.18670806f, 0.07515561f, 0.02472369f, 0.00831918f, -0.04902788f, -0.06407041f, 0.11507137f, 0.01509460f, 
    -0.16263583f, -0.29937667f, -0.09406385f, -0.04331625f, 0.25347686f, 0.07071187f, -0.60783833f, -0.43013540f, 
    -0.10707841f, -0.02818420f, 0.19119787f, 0.20894405f, -0.05606498f, 0.10686707f, -0.21137482f, 0.05035535f, 
    -0.15928477f, 0.14577414f, -0.08768069f, -0.06183113f, 0.19842291f, 0.10079339f, -0.10922189f, 0.05155002f, 
    0.51489753f, -0.19052070f, -0.02825446f, 0.38324276f, -0.02089052f, -0.49107671f, 0.07485256f, -0.17633234f, 
    -0.07721559f, 0.20289011f, 0.12369146f, 0.12748894f, 0.07152803f, 0.15930536f, -0.08884722f, 0.12830508f, 
    -0.25844690f, -0.02435355f, 0.02393328f, 0.02187548f, -0.30020830f, 0.22682501f, -0.14195071f, -0.20728250f, 
    0.08613870f, 0.18453421f, 0.38907343f, 0.14868885f, -0.23042689f, -0.25321317f, -0.04937627f, 0.22878544f, 
    -0.00450160f, -0.30688843f, -0.19160005f, -0.06842089f, 0.06641859f, 0.12795430f, -0.20852049f, 0.03221640f, 
    0.35345736f, -0.02798294f, -0.23241852f, -0.19981915f, -0.06086833f, 0.01508200f, 0.06400272f, 0.02443671f, 
    -0.11951211f, -0.07657708f, -0.04649017f, -0.07347495f, -0.00145664f, 0.00620237f, 0.11720650f, -0.09847956f, 
    -0.27650759f, -0.02994146f, -0.07072446f, -0.11165692f, 0.10855459f, 0.12030587f, -0.43568981f, -0.14445135f, 
    -0.34441596f, 0.13943395f, 0.02953526f, -0.07554014f, -0.06008269f, 0.00339953f, -0.08787995f, -0.05904883f, 
    0.03304446f, -0.15185641f, -0.14498045f, -0.05984971f, 0.07396481f, 0.04186016f, 0.02476273f, -0.12183951f, 
    -0.15899168f, -0.30179968f, -0.23444603f, -0.25790563f, -0.53362232f, 0.01769908f, 0.03901640f, 0.00784652f, 
    -0.05145380f, -0.09265295f, -0.10940812f, 0.06941307f, 0.16723807f, -0.01931232f, 0.14395632f, 0.08444636f, 
    -0.02707630f, 0.03416280f, -0.08528122f, 0.21324338f, 0.10113260f, 0.15259166f, -0.23730226f, 0.01425761f, 
    -0.04046343f, -0.07683897f, -0.01956663f, -0.08975890f, 0.04803707f, 0.00153204f, -0.01694582f, -0.09106632f, 
    -0.04522252f, 0.07059843f, -0.05664233f, -0.23268470f, 0.11867350f, -0.03721503f, -0.00550781f, -0.02588287f, 
    -0.51431465f, -0.59403867f, -0.84193045f, -0.05524550f, -0.11811766f, -0.27901506f, -0.09649322f, -0.00495756f, 
    0.05855947f, -0.06379967f, -0.07311419f, -0.08972962f, 0.04998336f, 0.20781504f, 0.01215508f, 0.05095708f, 
    -0.11817560f, -0.01594497f, -0.10082687f, 0.06615955f, -0.68972790f, -1.02283049f, -0.65897852f, -0.08374076f, 
    -0.11716372f, -0.08012789f, -0.02649397f, -0.03665604f, 0.07716975f, -0.26895383f, 0.00424839f, 0.05210916f, 
    0.02032986f, -0.26243585f, 0.01980020f, -0.06431894f, -0.05744780f, 0.12791313f, -0.09523882f, -0.23767160f, 
    0.07572509f, 0.16167609f, 0.12721202f, 0.00682659f, -0.17604026f, -0.18027806f, -0.03165516f, -0.16110516f, 
    -0.17998075f, -0.06171871f, 0.00383094f, 0.00453860f, 0.08674067f, -0.12051573f, 0.09238214f, -0.01162990f, 
    0.10205113f, 0.00480025f, -0.09225310f, 0.01313056f, 0.25587288f, -0.07495435f, 0.21766557f, 0.11027847f, 
    -0.00207397f, -0.00659218f, -0.08801942f, -0.02961880f, -0.00436975f, 0.00480426f, 0.09093079f, -0.10527378f, 
    -0.16482654f, 0.09611875f, 0.06788599f, -0.15990947f, 0.00076028f, 0.03131541f, -0.10176448f, 0.08051445f, 
    -0.69633406f, 0.65599072f, 0.25532460f, -0.14091995f, -0.04712601f, 0.09369142f, 0.09571616f, 0.03520720f, 
    0.09702552f, -0.14810230f, 0.01301021f, -0.00813684f, -0.04479999f, 0.01962510f, -0.17830294f, 0.05705231f, 
    0.12145714f, -0.17877957f, -0.00617255f, -0.04088726f, -0.22606061f, 0.53896677f, 0.37997344f, 0.33514401f, 
    0.03439580f, 0.00884439f, 0.01252532f, -0.09798381f, -0.03725490f, -0.08110157f, -0.08351208f, -0.09810778f, 
    -0.10441750f, 0.05678526f, -0.18150406f, -0.15091079f, 0.00935625f, 0.19321847f, 0.12871230f, 0.00306340f, 
    0.18850383f, 0.07949055f, -0.23422323f, 0.04414566f, -0.11248031f, -0.17389038f, -0.13158193f, 0.07571568f, 
    0.06768052f, -0.01144643f, 0.07987608f, 0.10703690f, 0.01311230f, -0.00554351f, 0.08407971f, -0.06227714f, 
    -0.02940660f, 0.08274524f, -0.03026148f, -0.03796209f, -0.42165372f, 0.69278252f, -0.13052548f, 0.06401835f, 
    -0.05896491f, -0.00339430f, -0.08901344f, 0.00829314f, 0.01406154f, -0.06806774f, 0.00187651f, -0.12522410f, 
    -0.00634759f, 0.10289957f, -0.01825774f, -0.07195937f, -0.12196433f, -0.19165377f, 0.13064732f, -0.01326158f, 
    -0.31040800f, 0.08283605f, 0.34948787f, -0.22143923f, -0.05904716f, -0.08970132f, -0.42479429f, -0.06076517f, 
    0.07496629f, -0.03535189f, 0.06090943f, -0.19363697f, 0.16427165f, -0.09882998f, 0.06196513f, -0.07544126f, 
    0.12061362f, 0.10373012f, 0.03468353f, 0.06252714f, 0.56329882f, 0.48948023f, -0.03547174f, -0.10811093f, 
    0.10915554f, -0.01450135f, -0.02535898f, -0.09909782f, 0.40248835f, 0.07805798f, -0.04019647f, -0.05347640f, 
    -0.14580424f, 0.02793015f, -0.15189037f, -0.11388578f, 0.10728451f, -0.08886665f, 0.23631759f, 0.29568183f, 
    0.03835229f, -0.09651832f, -0.05298676f, 0.04943976f, -0.10077105f, -0.07726134f, -0.20070100f, 0.18932846f, 
    -0.13194534f, -0.00838401f, -0.04672363f, 0.14135870f, -0.14944406f, -0.04199850f, 0.19575672f, 0.11309578f, 
    0.07525258f, 0.17853680f, 0.19493462f, 0.02309621f, 0.01004617f, -0.88934648f, -0.51398104f, 0.16436316f, 
    0.47337070f, 0.20043209f, 0.17908379f, 0.04624759f, -0.01705672f, -0.10343751f, 0.12900491f, 0.02700717f, 
    -0.23310232f, -0.14320633f, 0.03159737f, 0.08855350f, -0.09666494f, 0.14875899f, 0.05179227f, -0.03258445f, 
    -0.24298631f, 0.23082748f, 0.00789401f, -0.09612298f, 0.04733465f, -0.09106666f, -0.00747819f, 0.01942238f, 
    0.07210446f, 0.01019829f, 0.09427705f, 0.02843286f, 0.02451772f, 0.07546942f, -0.02511703f, -0.04364311f, 
    -0.11085325f, -0.11353091f, 0.07531943f, 0.12835988f, -0.16386248f, 0.35788542f, 0.15616229f, 0.33822879f, 
    0.28214830f, 0.18449393f, 0.18613115f, -0.06572122f, 0.05660941f, 0.12186618f, -0.01297523f, 0.02329236f, 
    -0.06026309f, -0.23534825f, -0.12357853f, -0.04710151f, 0.05193134f, 0.10253847f, 0.15300360f, 0.01083418f, 
    -0.87782311f, 0.23436497f, 0.13972771f, 0.12060896f, 0.10507094f, 0.05706719f, -0.05570794f, -0.03698105f, 
    -0.01316685f, 0.20403160f, -0.02061295f, -0.03673159f, 0.19469188f, 0.11535680f, 0.08842111f, 0.05813838f, 
    0.05105282f, -0.03072486f, 0.04142562f, -0.07512893f, -0.17350842f, -0.20445468f, -0.05759025f, -0.05908236f, 
    -0.15553521f, -0.05536639f, -0.07540429f, 0.00692208f, -0.05609462f, -0.04668424f, -0.08143985f, 0.00875998f, 
    0.03366490f, -0.05113233f, 0.00334206f, -0.11249007f, 0.15887775f, -0.14015529f, -0.02683832f, -0.05654919f, 
    0.04786151f, 0.24251795f, 0.15989564f, 0.03017382f, -0.10210409f, 0.06562498f, -0.09145893f, 0.05293746f, 
    0.03791469f, 0.15047190f, 0.12582293f, -0.07476498f, 0.15758973f, -0.04164132f, -0.05020779f, -0.04177868f, 
    0.02560551f, -0.01893551f, -0.06103143f, -0.03720235f, -0.10102575f, 0.03347842f, -0.17025903f, -0.35495484f, 
    0.10884357f, 0.09958038f, 0.06741013f, -0.29142046f, 0.06515419f, 0.14103217f, 0.18502839f, -0.10584573f, 
    -0.02310831f, 0.00949375f, -0.02604466f, 0.06524400f, -0.20243225f, -0.15980208f, 0.01401104f, -0.01156159f, 
    -0.42936510f, 0.36218989f, -0.25742289f, 0.18112189f, 0.08717781f, 0.09414311f, 0.02095651f, -0.03325526f, 
    0.23246819f, 0.03873174f, 0.00032487f, 0.17864388f, -0.01581797f, -0.08127374f, -0.12684938f, -0.08882139f, 
    -0.13823085f, -0.02876366f, 0.01579118f, -0.12259642f, 0.09848808f, -0.12800844f, -0.33849457f, 0.09954551f, 
    -0.60068965f, -0.24963467f, 0.04449368f, -0.00037875f, -0.17354299f, -0.11588997f, -0.11510052f, -0.10671462f, 
    0.11521396f, 0.03553817f, 0.02934022f, -0.14883097f, 0.11854142f, -0.03308025f, -0.01897789f, -0.00281366f, 
    -0.40095997f, 0.06002739f, 0.20351823f, 0.12705539f, -0.00450327f, 0.17020066f, -0.10966600f, 0.17572081f, 
    -0.10800129f, 0.04370277f, 0.01520746f, -0.03442582f, -0.27750182f, -0.02206281f, -0.04613239f, 0.01535945f, 
    -0.01793266f, -0.29580322f, -0.16977687f, -0.15773773f, -0.04361166f, -0.19207147f, 0.14081740f, 0.01221976f, 
    -0.02841127f, 0.02320841f, 0.13018447f, -0.18586904f, 0.01571487f, 0.10392959f, 0.04467268f, 0.12833901f, 
    -0.05584376f, 0.10896806f, -0.01541764f, -0.08242837f, 0.01336529f, 0.01321530f, 0.20772363f, 0.12557237f, 
    -0.81572384f, 0.30233130f, -0.09284896f, 0.06455753f, 0.02380461f, -0.00992743f, -0.13515572f, 0.01083501f, 
    0.17182587f, -0.05177077f, 0.07630537f, 0.02365209f, -0.09634740f, 0.02501774f, 0.08408456f, 0.09334550f, 
    -0.07384383f, 0.26642498f, 0.06888238f, 0.09497309f, -0.46428242f, 0.00939825f, -0.03391846f, -0.06826573f, 
    0.04901890f, 0.04451035f, -0.03158765f, 0.18173228f, -0.14194351f, -0.09856791f, -0.03519390f, 0.06854337f, 
    0.10919625f, 0.05418360f, -0.09128623f, -0.08122337f, 0.02116477f, -0.00744941f, 0.04375843f, -0.01229390f, 
    0.55093354f, 0.01433309f, -0.32934582f, -0.11546527f, 0.36983675f, 0.00740864f, -0.03869919f, 0.10630480f, 
    0.17604345f, -0.19486487f, -0.06933593f, -0.16224283f, 0.13509388f, 0.15719785f, 0.03172198f, -0.04552715f, 
    0.08074012f, -0.00552415f, -0.01747889f, -0.00907760f, 0.72850639f, 0.18055505f, -0.10932897f, -0.28354004f, 
    -0.18824202f, -0.12024178f, 0.04706080f, 0.19514607f, 0.06477664f, 0.06222397f, 0.01912104f, -0.02959241f, 
    -0.05038789f, 0.08399893f, 0.03161655f, -0.14649428f, 0.13512491f, 0.03447136f, 0.01359744f, 0.02373083f, 
    -0.32561368f, -0.01735908f, -0.13802806f, 0.00799867f, 0.32120237f, 0.12829976f, -0.03444046f, -0.04347282f, 
    0.04801939f, 0.16553716f, -0.03803693f, -0.16390948f, -0.05064746f, 0.01303155f, -0.08527244f, -0.05629342f, 
    0.03932328f, 0.05811948f, 0.09946896f, -0.17419189f, -0.53637487f, -0.53505403f, 0.33902293f, 0.33500335f, 
    0.05069127f, -0.21983509f, -0.01816319f, -0.01739736f, -0.04264647f, 0.11985075f, 0.12234458f, 0.14714609f, 
    -0.04843151f, -0.16054058f, -0.10820726f, -0.16386706f, -0.07159720f, 0.09594038f, 0.05477319f, 0.08408286f, 
    -0.47056437f, 0.41507244f, 0.01038921f, -0.11760318f, -0.02408424f, -0.08725098f, -0.09616079f, 0.10563637f, 
    0.10422982f, -0.03787348f, -0.07793036f, 0.06038418f, -0.07076786f, -0.00411265f, 0.12312418f, 0.15182802f, 
    0.12058486f, -0.05996564f, -0.02502025f, -0.03725749f, -0.19431831f, -0.23957343f, 0.25134337f, 0.16157587f, 
    -0.12562157f, -0.08587608f, 0.09589665f, -0.04664703f, -0.09234053f, -0.03239069f, 0.02741302f, -0.07583648f, 
    -0.08180146f, -0.00699210f, 0.25143427f, -0.02485468f, -0.13457598f, 0.21006055f, -0.05356444f, 0.07772298f, 
    -0.06106556f, 0.33287889f, 0.00567774f, -0.06567104f, -0.04285855f, -0.12098572f, -0.02677535f, 0.05771819f, 
    -0.09396553f, -0.17233683f, -0.04051640f, -0.02475863f, -0.14811361f, -0.17005166f, 0.03869322f, -0.01175672f, 
    -0.11223152f, 0.17577735f, 0.19192147f, 0.04204851f, 0.09499847f, 0.10649532f, 0.04311607f, 0.17540404f, 
    -0.08155652f, 0.08237419f, -0.18918099f, -0.05144801f, -0.03714713f, 0.17385454f, -0.00122325f, -0.17367280f, 
    -0.07815668f, -0.09525688f, -0.08264744f, 0.07401847f, 0.03120990f, -0.18697564f, 0.16088587f, 0.11255281f, 
    0.06525199f, -0.22839598f, 0.12585522f, -0.04160959f, 0.00479402f, -0.05328259f, -0.03611584f, -0.03728325f, 
    -0.04939465f, -0.13996661f, 0.03883175f, 0.02137530f, -0.01459875f, -0.02276594f, 0.08510274f, -0.11042231f, 
    0.02380794f, 0.06970285f, 0.02879821f, -0.04969042f, 0.06755817f, 0.18500416f, 0.28776047f, 0.48115319f, 
    0.12989925f, 0.05059301f, 0.22630812f, 0.12871443f, 0.06559181f, -0.01060072f, -0.00426728f, -0.01609358f, 
    0.06265651f, -0.01256735f, 0.19399817f, 0.13044198f, 0.17747708f, -0.02190951f, 0.00658728f, -0.12244362f, 
    -0.59854496f, -0.37900141f, -0.11041795f, -0.00666532f, -0.06950592f, 0.13652544f, -0.06637986f, -0.05456398f, 
    -0.03036560f, 0.05231328f, 0.06089063f, 0.01339680f, 0.06809887f, 0.17086278f, 0.03219799f, 0.01788504f, 
    0.11403192f, 0.04262582f, -0.23283999f, 0.04850500f, -0.05996436f, 0.00137329f, 0.09469333f, 0.13804729f, 
    0.17795224f, -0.22799796f, -0.14655723f, 0.08298375f, -0.01817382f, 0.13822785f, 0.09067633f, -0.15518646f, 
    -0.08706815f, 0.13406347f, -0.16794413f, 0.00260667f, 0.05274418f, -0.15928487f, 0.11982549f, 0.05455900f, 
    -0.09393982f, -0.09568369f, -0.18564257f, 0.23107542f, -0.34925821f, -0.17198174f, -0.12624864f, -0.11244516f, 
    -0.05966238f, 0.10274477f, 0.06011364f, 0.14340541f, 0.14844932f, 0.07230348f, 0.09723955f, -0.07805569f, 
    -0.08706573f, 0.03384534f, -0.17403723f, -0.02282309f, 0.07941964f, 0.25318211f, -0.04116720f, 0.16873927f, 
    0.32366443f, 0.17527784f, -0.12118618f, 0.12925307f, 0.12744400f, -0.00668652f, 0.01273055f, -0.01911617f, 
    0.12831800f, -0.04574721f, 0.29538140f, -0.15832423f, 0.06245856f, -0.10631247f, -0.15519275f, -0.18973188f, 
    -0.64775485f, -0.05174987f, -0.48572865f, -0.23115021f, 0.00257642f, 0.17073520f, 0.37909028f, -0.16783489f, 
    0.01788881f, -0.01503928f, 0.10508987f, 0.07453413f, 0.15934865f, -0.20797588f, 0.08178317f, 0.04151628f, 
    0.16072150f, -0.18226707f, 0.12873966f, -0.03999568f, -0.63391060f, -0.03762437f, -0.01328842f, -0.18021314f, 
    -0.07961303f, -0.00700086f, 0.01521908f, 0.29259261f, -0.02329065f, -0.17709494f, 0.11536618f, 0.00443544f, 
    0.05533355f, -0.16743380f, 0.01595160f, -0.00185390f, -0.09013579f, -0.13553905f, -0.05812949f, 0.06468382f, 
    -0.16721676f, 0.15585683f, 0.19606915f, 0.11811342f, -0.34024477f, 0.08698305f, 0.13412371f, 0.08020974f, 
    -0.33701015f, 0.03026303f, 0.02775943f, -0.18595751f, -0.09612247f, -0.03571829f, -0.23003975f, 0.05017632f, 
    0.04326530f, 0.12455630f, 0.06846904f, 0.01640935f, -0.39507034f, -0.18592840f, 0.61798400f, 0.34694886f, 
    -0.52438468f, -0.03805782f, -0.01500521f, -0.09708819f, -0.03733068f, 0.02073550f, -0.13231334f, -0.00033204f, 
    0.09024084f, -0.10657125f, -0.01275066f, -0.13157786f, -0.06793895f, -0.07254659f, 0.04378122f, -0.00022533f, 
    -0.77899086f, -0.34753749f, -0.38469622f, -0.29200816f, -0.00271556f, 0.21856771f, 0.13606301f, 0.01156506f, 
    -0.00670960f, -0.19060239f, 0.11647628f, 0.14207007f, -0.04667202f, -0.04538025f, -0.17003478f, 0.04066842f, 
    0.01563983f, -0.00540360f, -0.21805245f, 0.02301070f, 0.29216069f, 0.01665141f, -0.00293207f, 0.16193224f, 
    -0.00983096f, -0.09193607f, -0.08489139f, 0.01898764f, 0.02402167f, 0.01663187f, -0.14568622f, -0.14502686f, 
    0.11790411f, 0.23914033f, 0.22348382f, -0.01652512f, -0.03376232f, 0.05137299f, 0.07035124f, 0.04704883f, 
    -0.27698541f, -0.35277462f, -0.01448162f, 0.05512635f, -0.38368148f, -0.00285738f, -0.05603558f, -0.15074357f, 
    0.15153554f, -0.09590532f, 0.02827216f, 0.05133361f, -0.10386967f, -0.00235423f, 0.09476259f, -0.05100786f, 
    -0.06069207f, 0.07417466f, 0.13299623f, 0.04142987f, 0.15728946f, 0.01903685f, -0.14381616f, 0.15429486f, 
    0.30860808f, -0.14442143f, -0.04895090f, -0.06461309f, 0.13585930f, 0.09939209f, -0.05053896f, -0.04094969f, 
    -0.06525527f, 0.26409912f, 0.22730009f, 0.07049176f, 0.05821482f, -0.14926887f, -0.30230311f, -0.11005887f, 
    0.03000403f, -0.84708542f, 0.04022036f, -0.14919639f, 0.40365708f, 0.14989510f, -0.05635200f, -0.18240893f, 
    0.08217365f, -0.01588772f, -0.04900243f, -0.04480660f, 0.00236836f, 0.19623540f, 0.05624818f, -0.04370116f, 
    0.00827960f, -0.28071603f, -0.22881939f, -0.27980241f, -0.21202482f, 0.37291721f, -0.06227151f, 0.25408903f, 
    -0.36653399f, 0.14537175f, 0.04247678f, 0.00875501f, 0.20537344f, -0.07585923f, 0.13317035f, 0.20273232f, 
    0.04196384f, 0.03493918f, 0.02574200f, 0.01625702f, -0.05562771f, 0.06591883f, -0.07343925f, -0.14842993f, 
    -0.60514140f, 0.22702920f, -0.09318468f, 0.26137978f, -0.29824802f, -0.27405971f, -0.00451164f, 0.10749046f, 
    0.12558115f, 0.03979593f, 0.00006094f, -0.09882832f, 0.06918852f, 0.04888162f, 0.15096150f, -0.12939116f, 
    -0.01522537f, 0.05306548f, -0.18440382f, 0.15865055f, -0.45822918f, 0.39977166f, -0.13436203f, 0.54263508f, 
    0.24441031f, -0.17490992f, -0.20707649f, -0.06352185f, 0.02321456f, -0.01338555f, -0.09286484f, 0.09370907f, 
    0.08408833f, -0.01150912f, -0.00010624f, -0.05776740f, -0.04310019f, -0.03285962f, -0.15378971f, -0.13766742f, 
    -0.01087364f, 0.15543200f, 0.03561338f, -0.48419303f, 0.23303363f, -0.08199906f, 0.04216420f, 0.09192764f, 
    -0.23276880f, 0.00780241f, 0.10156723f, -0.11514990f, -0.01490800f, -0.11441466f, -0.04774148f, -0.30693355f, 
    -0.05827587f, 0.02255268f, 0.03919083f, -0.03181005f, -0.02029431f, -0.14074053f, -0.19446672f, 0.27447209f, 
    -0.03900180f, 0.16455543f, 0.24697994f, -0.03425782f, -0.00644943f, 0.11287313f, 0.00900288f, 0.09876055f, 
    0.02997842f, 0.06731073f, -0.36159599f, 0.10096714f, 0.04155880f, 0.16519074f, -0.16866827f, 0.08283066f, 
    0.25736967f, -0.33595577f, 0.15385464f, 0.08687960f, 0.15190098f, 0.08157710f, -0.06728801f, 0.15403111f, 
    0.07936113f, -0.06085974f, 0.05668410f, -0.04806761f, -0.26419231f, -0.24383323f, -0.09060971f, -0.19774339f, 
    0.19403127f, 0.17332560f, 0.15557173f, -0.10506742f, -0.14693953f, 0.04402227f, -0.38335714f, -0.35393438f, 
    -0.06930711f, -0.02628172f, 0.05593798f, 0.07973295f, -0.14000984f, 0.00578203f, 0.05323116f, 0.06101443f, 
    0.10113708f, 0.04116082f, -0.12988718f, 0.13974611f, -0.30451283f, 0.05646195f, 0.08012591f, 0.07817227f, 
    0.29188675f, -0.39619389f, 0.15311393f, -0.65072340f, 0.32924062f, -0.23241125f, -0.03646674f, 0.01852805f, 
    -0.10653368f, -0.09832472f, 0.03381647f, 0.01565475f, 0.00216806f, 0.16158834f, -0.03398782f, -0.03539717f, 
    -0.07269410f, -0.03014126f, -0.09145591f, 0.15533327f, 0.19517733f, -0.39254859f, -0.22325818f, 0.30400288f, 
    -0.09673155f, 0.01234078f, 0.04227790f, 0.02587748f, 0.05135597f, 0.06418820f, -0.04800347f, -0.00008670f, 
    0.00428560f, 0.04834830f, 0.17650904f, -0.07691849f, 0.11856252f, 0.23355845f, -0.03186231f, 0.11465924f, 
    0.31574866f, -0.59774226f, -0.27802536f, -0.01818518f, -0.28743488f, -0.08928472f, 0.12653564f, -0.10923002f, 
    -0.06914151f, -0.00526431f, -0.05594939f, 0.11806563f, -0.10587647f, -0.08533385f, 0.18595880f, 0.16001910f, 
    -0.09015444f, -0.12561420f, -0.19682969f, -0.04746490f, 0.18271367f, 0.20570345f, -0.00330540f, -0.01939779f, 
    0.40663344f, -0.03372227f, -0.07718900f, -0.04219241f, -0.02078551f, 0.14160298f, -0.06692517f, 0.10812473f, 
    0.05899485f, 0.04784602f, -0.05430738f, 0.14065208f, -0.02940145f, 0.08598689f, 0.17067541f, 0.11829794f, 
    -0.45452097f, -0.29675353f, -0.08230243f, -0.37880865f, 0.20613620f, 0.00161465f, 0.00667490f, 0.14511070f, 
    -0.15298912f, 0.03957135f, 0.02843343f, -0.20561919f, 0.18375063f, 0.06429558f, 0.03846837f, 0.00400040f, 
    -0.00748369f, -0.18318880f, 0.14291826f, 0.19451036f, -0.24985752f, 0.76544261f, 0.00440675f, -0.00511007f, 
    -0.71855712f, 0.02786788f, -0.13366562f, 0.11691385f, 0.12615678f, -0.00303699f, 0.06227883f, 0.14862023f, 
    -0.06397369f, -0.02559913f, -0.16346714f, 0.12897255f, 0.02500069f, -0.07995905f, 0.02681923f, -0.07380849f, 
    0.21556251f, 0.02240519f, -0.03669529f, 0.17469192f, -0.29248643f, 0.16995755f, -0.10709704f, 0.17620656f, 
    0.00305087f, 0.10910489f, -0.13535105f, 0.01559303f, -0.01846624f, 0.07850235f, -0.20932695f, -0.11605538f, 
    -0.06389283f, 0.01363299f, -0.14590886f, -0.18225327f, -0.06475170f, 0.09492481f, -0.02885907f, -0.07804462f, 
    0.06140415f, 0.15347476f, 0.07649279f, -0.03150397f, -0.04511011f, 0.02635966f, -0.14096710f, 0.00220929f, 
    -0.15792707f, -0.00452215f, -0.13694254f, -0.04051853f, -0.02160954f, 0.23606376f, 0.15919444f, 0.04410837f, 
    -0.00224934f, -0.40243509f, 0.01388734f, -0.19834395f, -0.17716251f, -0.25869080f, 0.05264014f, 0.03617535f, 
    0.03061204f, -0.03554036f, 0.08176626f, 0.01344129f, -0.14694859f, -0.07869792f, -0.07794106f, -0.08782849f, 
    0.04951164f, 0.09082709f, -0.04655317f, -0.04639045f, -0.74303013f, 0.14395039f, 0.12234700f, -0.21388984f, 
    -0.27031520f, 0.04328739f, -0.03286029f, -0.07825990f, 0.04441701f, -0.18229008f, 0.05002037f, -0.01876329f, 
    -0.05834888f, -0.05443436f, -0.11025962f, -0.09774128f, -0.00023385f, 0.06157026f, -0.06432106f, -0.01167991f, 
    0.09795454f, 0.13188490f, -0.18902184f, -0.24323186f, -0.27321342f, -0.18336356f, -0.06264572f, 0.03416738f, 
    -0.02467487f, -0.14111461f, 0.13419925f, -0.01579526f, -0.06103705f, -0.02244018f, -0.05233868f, 0.06750858f, 
    -0.03216878f, -0.06911226f, -0.08148080f, -0.07812986f, -0.35736123f, 0.00355324f, -0.18376520f, -0.16550840f, 
    -0.10196524f, 0.07422320f, -0.03723137f, 0.06118175f, -0.01056954f, -0.16990097f, -0.10545744f, -0.07253508f, 
    -0.14835465f, 0.04524908f, 0.06511344f, -0.06305332f, -0.15836282f, 0.01278219f, -0.04075503f, 0.13950349f, 
    0.26693493f, 0.14515720f, 0.28805450f, 0.06333199f, 0.22741713f, -0.14609997f, 0.14275679f, -0.13998197f, 
    -0.04115750f, -0.12434260f, -0.16092159f, -0.00593823f, -0.13134953f, 0.01862312f, -0.00582394f, -0.07735264f, 
    -0.05334200f, 0.13729368f, 0.10584449f, -0.06693625f, -0.31228343f, 0.44203371f, -0.11106799f, -0.08299131f, 
    0.03181164f, 0.03872488f, 0.07735030f, -0.28225115f, 0.12819274f, -0.00666666f, -0.05307328f, 0.04902623f, 
    -0.00803046f, -0.04905399f, -0.14389277f, -0.08505329f, 0.04112527f, 0.13677700f, -0.00353550f, -0.05043524f, 
    0.45007485f, -0.81574929f, 0.33131316f, 0.21089363f, -0.24329156f, 0.16753216f, -0.05049653f, -0.16829076f, 
    -0.20734483f, 0.15683101f, -0.02459837f, -0.08291355f, -0.13166335f, -0.00752356f, -0.07128124f, -0.12023304f, 
    0.12117425f, -0.04560577f, -0.01267741f, 0.01471574f, 0.13020787f, -0.17212190f, 0.11991590f, 0.16135469f, 
    0.38125837f, -0.01054612f, 0.09400633f, 0.08351421f, -0.03092933f, 0.02454015f, -0.13195510f, 0.09313386f, 
    -0.16786999f, -0.03763171f, 0.11717860f, -0.09081664f, -0.01348759f, -0.04615157f, 0.05067958f, 0.04535669f, 
    -0.22141570f, 0.31482592f, 0.40529382f, 0.10005464f, 0.30485272f, -0.02687224f, 0.24528058f, 0.05612846f, 
    -0.03537798f, 0.04011545f, -0.04529786f, 0.06119812f, -0.08587505f, -0.04607809f, -0.08634289f, -0.07032967f, 
    0.12343948f, 0.10997353f, 0.00887483f, -0.16934137f, -0.08689127f, 0.29472175f, 0.37139389f, 0.04208151f, 
    -0.02011043f, 0.13351394f, -0.06214211f, 0.00023955f, 0.13718131f, -0.05445024f, -0.04158737f, 0.05169372f, 
    0.07539031f, -0.01613644f, -0.14708973f, 0.00318665f, -0.02118726f, 0.17797905f, -0.02217647f, -0.12455653f, 
    0.02117419f, 0.08696239f, 0.14445823f, 0.12515441f, 0.08938684f, 0.20877449f, 0.05293012f, 0.04511931f, 
    0.01368049f, -0.04993477f, -0.00209271f, -0.02925691f, 0.06478924f, -0.02091715f, -0.06592064f, 0.04238120f, 
    0.01295063f, -0.07018118f, -0.08391804f, -0.07623290f, -0.22906902f, 0.29204825f, 0.15054859f, 0.13096160f, 
    -0.03628481f, 0.18372463f, -0.05179211f, 0.01634387f, -0.15956183f, 0.14947365f, -0.08852601f, 0.01963581f, 
    0.07715765f, -0.09863376f, -0.18042575f, 0.12023689f, -0.06385992f, -0.12494893f, -0.06302004f, 0.03044754f, 
    0.23791434f, -0.00304621f, 0.42723590f, 0.02563238f, 0.18654244f, 0.00094538f, 0.18080622f, -0.03833556f, 
    -0.15005475f, -0.03362059f, -0.08401752f, 0.11419658f, 0.01066114f, 0.05192702f, -0.00421459f, -0.06634244f, 
    0.01142294f, -0.04902897f, 0.11330821f, -0.23429827f, -0.62850779f, -0.16971889f, -0.45417595f, -0.14853249f, 
    0.00122495f, 0.02789485f, -0.24230671f, -0.14523667f, -0.04196034f, -0.14776853f, -0.22363597f, 0.14309552f, 
    0.18287568f, -0.08763346f, -0.15917699f, -0.11563310f, 0.06798471f, -0.04244192f, 0.08820438f, 0.07966604f, 
    0.02721939f, -0.55510187f, 0.17191155f, -0.19468617f, -0.28874835f, 0.07135143f, -0.16883940f, -0.12314896f, 
    -0.05820378f, -0.14306879f, -0.05815484f, 0.02026325f, -0.11713488f, -0.06737290f, -0.04743424f, 0.05255329f, 
    0.16988556f, -0.03841127f, -0.14671044f, -0.02907259f, 0.01612205f, -0.21218608f, 0.02729148f, 0.02298862f, 
    0.30431861f, 0.04610818f, -0.21200745f, -0.16155702f, -0.02726471f, -0.10129795f, -0.07616155f, -0.05627095f, 
    0.02942901f, -0.06815504f, -0.08471509f, -0.10443311f, 0.01515281f, 0.01652206f, 0.09183244f, 0.07357895f, 
    0.21949829f, 0.45091492f, 0.02850764f, 0.03984442f, 0.27893981f, -0.24688777f, -0.09779812f, 0.12486231f, 
    -0.05614582f, -0.08397828f, 0.04706370f, 0.00712240f, -0.03058970f, -0.09344997f, 0.04935532f, -0.01700889f, 
    -0.01166254f, 0.14144532f, 0.20411119f, -0.02581472f, 0.04298695f, 0.14601915f, -0.39432833f, 0.17540137f, 
    0.08033912f, 0.13816881f, 0.11556269f, -0.09818845f, -0.07257673f, -0.06641886f, -0.02973520f, 0.06776046f, 
    0.13503470f, -0.04642045f, -0.04925098f, 0.05269928f, 0.00268487f, -0.04187060f, 0.24510707f, -0.00663724f, 
    0.28682199f, 0.00784017f, -0.12984015f, 0.11909728f, 0.18957472f, -0.02227644f, 0.19374342f, -0.19929637f, 
    -0.12146219f, -0.09207683f, -0.02605728f, -0.00693067f, -0.09142860f, -0.13465685f, 0.16072781f, -0.24530935f, 
    -0.02411027f, -0.04426664f, 0.15802787f, -0.15558724f, 0.33493838f, 0.30144054f, -0.15943168f, 0.06421284f, 
    0.19975013f, 0.18342781f, 0.04402693f, -0.02929233f, -0.15285294f, -0.06294218f, 0.00028068f, 0.04113734f, 
    -0.05118626f, 0.06309596f, -0.25988418f, -0.07350720f, 0.06374998f, 0.06939687f, 0.10409259f, -0.14246599f, 
    -0.33778390f, 0.17711873f, 0.32201293f, -0.14287142f, -0.20922515f, -0.04525382f, 0.00242256f, -0.04566357f, 
    -0.06586493f, -0.15739287f, 0.06557222f, 0.05288903f, 0.00949893f, 0.11760788f, 0.02776428f, -0.02238404f, 
    0.11444418f, -0.07428631f, -0.05361658f, 0.09849435f, -0.12938538f, 0.05334942f, -0.43359467f, 0.21239275f, 
    -0.10364170f, -0.16967978f, 0.05822550f, -0.12522542f, -0.08079930f, -0.03188193f, 0.22194852f, -0.04265355f, 
    0.07522484f, -0.10299710f, 0.07405445f, -0.04922818f, -0.03321175f, -0.17326514f, 0.19907135f, 0.02584418f, 
    0.05430127f, 0.12114117f, 0.02758112f, -0.17816839f, 0.12820408f, -0.13842572f, -0.08316867f, -0.06817694f, 
    -0.16454409f, 0.11745280f, 0.01759835f, 0.18147618f, 0.07330890f, -0.19115563f, 0.00533969f, 0.05891175f, 
    -0.01235010f, -0.06667697f, -0.01684153f, 0.18407156f, -0.27584925f, -0.23525691f, -0.04735280f, -0.83535886f, 
    -0.40194777f, 0.00966193f, 0.06224113f, -0.06493529f, -0.18566383f, 0.00684795f, 0.11603563f, 0.02729588f, 
    0.09054363f, 0.11272287f, -0.04569567f, -0.12364119f, 0.06222740f, 0.14575289f, -0.49717221f, -0.17469798f, 
    -0.17604880f, 0.02023401f, 0.42981577f, -0.08739510f, -0.16277675f, -0.19120827f, -0.03974221f, 0.05838516f, 
    -0.09882820f, -0.00765341f, -0.00257688f, -0.01349737f, 0.01575647f, -0.03932387f, -0.00081883f, 0.01191108f, 
    -0.02747210f, -0.35859022f, 0.12374221f, -0.09631285f, 0.10986219f, -0.20910534f, -0.13697065f, 0.22157057f, 
    0.11464138f, -0.09296671f, -0.12088832f, -0.13218416f, -0.07848600f, 0.16208057f, -0.00273191f, -0.17444597f, 
    -0.13641176f, 0.17607062f, 0.04650989f, 0.09143353f, 0.05921499f, -0.06602377f, 0.11237469f, -0.00863582f, 
    0.00526045f, -0.12680651f, 0.02681600f, -0.05386798f, 0.14561832f, -0.14430811f, -0.04656301f, -0.03091368f, 
    -0.05981317f, 0.09752025f, -0.09960057f, 0.02384237f, -0.11071631f, -0.12550035f, -0.01429155f, -0.03598276f, 
    0.04092848f, 0.14778012f, 0.01308599f, 0.00994471f, -0.24818483f, 0.07203124f, -0.17214696f, -0.23226358f, 
    -0.13447735f, 0.05506713f, -0.14240137f, -0.43170565f, -0.11065667f, -0.01263082f, 0.07249811f, -0.00738448f, 
    -0.00858753f, -0.23121557f, 0.10764652f, -0.17611125f, -0.03545026f, -0.05781289f, 0.00992773f, -0.05862917f, 
    -0.38669869f, -0.20473796f, 0.37716579f, -0.18725057f, 0.22386502f, -0.06963360f, -0.04624137f, 0.13133274f, 
    -0.12784925f, 0.06223685f, 0.01409508f, -0.06895308f, 0.02895692f, -0.10588472f, 0.03000831f, -0.09147833f, 
    -0.13013871f, 0.03254516f, -0.16267261f, 0.07747991f, -0.03439695f, -0.29246193f, -0.30749470f, 0.03053357f, 
    0.25350448f, 0.13347493f, 0.00260732f, -0.15747412f, -0.07964736f, -0.05918861f, 0.04371587f, -0.02272492f, 
    0.05137260f, 0.09040143f, 0.12897816f, -0.08844793f, 0.11437790f, 0.11793789f, 0.07740451f, -0.01490113f, 
    0.24379493f, 0.05656218f, -0.30324864f, 0.19225937f, 0.20556973f, -0.06323770f, 0.01991185f, -0.15075238f, 
    -0.10683244f, 0.04026241f, -0.09877191f, -0.02486174f, 0.02315223f, -0.04827580f, 0.09923228f, 0.05173362f, 
    -0.08969229f, -0.01996136f, 0.18012311f, 0.05276098f, -0.15575840f, -0.00118527f, -0.33784032f, -0.51315993f, 
    -0.21188921f, 0.08759546f, -0.10207094f, -0.07171519f, 0.06828403f, -0.16167055f, 0.20865807f, -0.01735146f, 
    0.12368409f, -0.03130089f, -0.04380445f, 0.07520761f, -0.07432384f, -0.10610394f, -0.27942681f, 0.04022877f, 
    0.38026026f, 0.19169210f, -0.47319299f, 0.19167380f, -0.12277991f, 0.21804136f, -0.04334280f, 0.07225021f, 
    -0.20152409f, -0.02718105f, -0.10628022f, -0.00738305f, -0.00539442f, 0.07804660f, -0.06152562f, 0.11610410f, 
    -0.02557959f, -0.07289990f, -0.13745829f, -0.02537983f, -0.34040111f, -0.24947658f, 0.36603305f, -0.32048410f, 
    0.12610470f, -0.15646240f, 0.10599530f, -0.04176668f, 0.04907165f, -0.01841133f, 0.06139815f, -0.08455036f, 
    -0.02081802f, -0.20643516f, 0.02909156f, 0.05920019f, -0.03775909f, 0.18676518f, -0.20971963f, 0.02356801f, 
    -0.66371751f, 0.42072412f, 0.07755562f, 0.15993027f, -0.11852533f, 0.03588893f, 0.26635823f, -0.09988553f, 
    0.01119336f, -0.03992170f, -0.00910113f, 0.21513809f, 0.00165521f, -0.03266943f, -0.04349874f, 0.15281840f, 
    -0.03002076f, 0.06203562f, -0.13182169f, 0.01007271f, 0.50096786f, -0.13236459f, -0.01499526f, -0.42414853f, 
    -0.50246429f, 0.11883863f, 0.05245509f, 0.17485838f, -0.15541951f, -0.16762748f, -0.24696048f, 0.00205750f, 
    -0.02900441f, 0.03815589f, -0.00820416f, 0.00845562f, 0.07655235f, -0.10092752f, 0.08160622f, -0.10216271f, 
    0.08720587f, -0.29681036f, -0.22518279f, 0.23271042f, 0.13812973f, -0.01828458f, 0.16080542f, -0.07948093f, 
    -0.13689061f, -0.02539722f, -0.06832117f, -0.14207268f, -0.15577617f, 0.04010163f, 0.09818576f, -0.08157022f, 
    -0.09784321f, -0.06002098f, 0.20824352f, 0.15652682f, -0.89442468f, 0.53513622f, 0.31669968f, -0.10673715f, 
    -0.12241858f, 0.08560873f, 0.13031578f, 0.03204146f, 0.02828881f, -0.09343101f, -0.00822245f, 0.04145114f, 
    0.11354916f, 0.01989331f, 0.17662504f, 0.11968629f, 0.02683324f, 0.19826850f, -0.06852538f, 0.04711855f, 
    0.60075653f, -0.41968593f, 0.20685589f, -0.23299372f, 0.02432982f, -0.07350763f, -0.13655771f, 0.02057253f, 
    0.07178126f, 0.00051803f, 0.04993181f, -0.10934065f, 0.20047030f, -0.01531335f, 0.05060900f, 0.06867093f, 
    -0.18279579f, 0.12591828f, -0.02734480f, 0.05769706f, 0.03764709f, -0.25527704f, 0.15834215f, -0.08527545f, 
    0.14294532f, -0.11800671f, 0.11494911f, 0.07621996f, -0.13018544f, 0.02076707f, -0.04720003f, -0.00406972f, 
    -0.06512826f, -0.04889087f, -0.01716743f, 0.09405040f, 0.19336469f, 0.09292603f, 0.15493126f, 0.02505674f, 
    -0.18668841f, -0.38541719f, -0.06086175f, 0.36448792f, 0.15323314f, 0.24003071f, -0.05062792f, -0.07939926f, 
    -0.13476437f, 0.39688572f, -0.14391427f, 0.10868303f, -0.11213630f, 0.06002746f, 0.01442592f, -0.07049096f, 
    -0.23889391f, 0.00111560f, -0.10627445f, -0.13302280f, 0.22987652f, -0.50067782f, 0.06292353f, 0.14970078f, 
    0.25662777f, 0.06666385f, -0.01972670f, -0.16450608f, 0.01224406f, 0.08478677f, -0.02801350f, -0.00166029f, 
    -0.08491789f, 0.06080253f, -0.02358914f, -0.09497904f, -0.04390535f, 0.03349817f, -0.03657987f, 0.15062676f, 
    -0.06812828f, -0.02611438f, -0.03152756f, 0.08119977f, 0.05418248f, 0.12631989f, -0.09445498f, 0.12883472f, 
    0.04569563f, 0.11183418f, 0.04147443f, -0.11800458f, 0.12744333f, 0.27934206f, 0.10254472f, -0.00672772f, 
    0.00689823f, -0.07960121f, 0.11936740f, 0.00518190f, 0.08284006f, -0.96251136f, -0.16071618f, -0.06270377f, 
    -0.08999594f, -0.10943304f, 0.04039298f, -0.11004221f, 0.08888669f, 0.03818941f, -0.16275349f, -0.22007641f, 
    0.06987573f, 0.17645933f, 0.13781975f, 0.15410678f, 0.13677587f, 0.05143517f, -0.19963133f, -0.10591206f, 
    0.36920011f, -0.02128146f, -0.12289907f, 0.24698915f, -0.13008884f, -0.08959296f, -0.02175845f, -0.06600778f, 
    0.15464729f, 0.02572546f, -0.18163936f, 0.11111348f, -0.01655209f, -0.12956612f, 0.17142783f, 0.00103575f, 
    0.10658582f, 0.05937482f, 0.09102377f, -0.07563315f, -0.00908428f, -0.31101221f, 0.36919865f, -0.61959654f, 
    -0.69245088f, 0.00799097f, 0.24516991f, -0.17643563f, -0.20676999f, 0.10062248f, -0.07482456f, -0.13948546f, 
    -0.00728093f, -0.14873119f, -0.11368331f, -0.11424445f, 0.03090896f, -0.06763819f, 0.01952623f, -0.11127036f, 
    0.40651911f, -0.73392427f, 0.24400909f, -0.14428268f, 0.25628552f, 0.13448888f, 0.05250325f, -0.20091581f, 
    0.03716983f, -0.13464358f, 0.05500720f, 0.13798039f, -0.08425323f, 0.01332097f, -0.04516723f, -0.05236693f, 
    0.06300036f, -0.23218057f, -0.12304161f, -0.13013150f, -0.08618685f, -0.12344147f, 0.22132425f, -0.59677017f, 
    -0.09731462f, -0.25556701f, -0.04770625f, -0.00957965f, 0.01722613f, 0.12164702f, 0.09481939f, 0.00177677f, 
    0.18063971f, -0.24386747f, -0.13423780f, -0.01248331f, -0.03515986f, -0.00986292f, 0.20086302f, 0.11928520f, 
    0.33608913f, 0.10146705f, -0.09153488f, -0.04382893f, 0.10015430f, -0.35124505f, 0.10979735f, -0.04494083f, 
    0.13672802f, -0.14480917f, -0.03208121f, -0.10104179f, -0.01850840f, -0.28986135f, 0.02531361f, -0.28886378f, 
    0.04028708f, 0.18189961f, 0.15342866f, 0.10820560f, -0.28457123f, -0.32572946f, -0.24525844f, -0.04679862f, 
    0.01932112f, 0.15668362f, 0.05769634f, -0.01825582f, -0.00214503f, -0.03233918f, 0.27686027f, 0.05248879f, 
    0.04139747f, 0.05201647f, 0.22133918f, 0.16235727f, 0.08593319f, 0.11464514f, 0.12539533f, 0.02091148f, 
    -0.86433804f, -0.41729176f, -0.13461319f, -0.26438940f, -0.43452886f, 0.05216220f, 0.20564038f, -0.05413428f, 
    -0.20053783f, -0.02777216f, 0.18000895f, -0.15745285f, -0.09567142f, -0.05749536f, -0.07512213f, -0.06248444f, 
    -0.12913282f, 0.07781507f, 0.20719215f, 0.08120337f, -0.92221940f, -0.77386498f, -0.07219053f, -0.34305963f, 
    -0.53688699f, 0.15925170f, 0.08718289f, -0.07776850f, -0.04733324f, -0.01976229f, -0.14140852f, -0.04966017f, 
    -0.01627052f, 0.10415768f, 0.08904047f, 0.08819576f, 0.18135609f, 0.18683815f, 0.09021799f, 0.19813398f, 
    0.19486077f, 0.06562617f, 0.01432294f, -0.15572149f, 0.01247405f, 0.14154410f, 0.06302916f, 0.07449620f, 
    0.01647741f, 0.00082652f, -0.01456586f, -0.09166696f, -0.03375861f, 0.00315105f, -0.03750556f, 0.07343785f, 
    -0.02620231f, 0.01344202f, -0.00294726f, 0.14457992f, -0.64770281f, -0.73048192f, -0.00237076f, -0.04077198f, 
    0.24326786f, 0.16669342f, 0.21643077f, 0.19513820f, 0.07019581f, -0.18212520f, 0.20414639f, 0.02128297f, 
    0.01936048f, -0.04754058f, 0.06197504f, 0.08351921f, 0.02034116f, -0.08310244f, 0.13318323f, 0.05291777f, 
    -0.38971317f, 0.38876083f, -0.23170815f, -0.06197377f, 0.25315326f, 0.08409791f, 0.04629086f, 0.05028677f, 
    0.07012538f, 0.27271166f, 0.03015029f, 0.04479574f, -0.00010102f, 0.05444897f, 0.17528115f, 0.11102582f, 
    0.09438448f, 0.18480393f, -0.07453087f, 0.28693604f, 0.19957195f, 0.17343526f, 0.03508000f, 0.05881444f, 
    -0.05986675f, -0.01212203f, -0.05619311f, 0.06821076f, 0.04127155f, 0.01563545f, -0.00557517f, 0.04062411f, 
    0.08810485f, -0.14356560f, -0.07013413f, 0.11917750f, 0.05071813f, -0.26576740f, -0.19586746f, 0.15174930f, 
    0.30786970f, 0.24277280f, -0.22522333f, 0.25896838f, -0.30625117f, -0.18454506f, -0.19074029f, 0.28628400f, 
    0.02001298f, 0.00948177f, -0.05163792f, -0.04460238f, 0.08422966f, -0.21771334f, -0.13995367f, 0.16305171f, 
    0.08718070f, -0.05202931f, 0.05432994f, 0.04464193f, 0.18274671f, 0.02533907f, -0.33812675f, 0.21055000f, 
    -0.08709926f, -0.14461523f, -0.08435838f, 0.01927525f, 0.03923796f, -0.00917541f, -0.02944352f, 0.10915709f, 
    0.00126566f, -0.08781449f, 0.03994964f, -0.14533348f, 0.09277824f, -0.00282214f, -0.00819167f, -0.14624386f, 
    0.09113110f, 0.12929925f, -0.26361579f, -0.16871490f, 0.03756119f, 0.01882941f, 0.10170272f, -0.04293185f, 
    0.18888611f, -0.04731087f, 0.04647312f, 0.17257902f, -0.09093931f, -0.06339382f, -0.05809946f, -0.06008612f, 
    -0.03381117f, 0.25670648f, -0.06877837f, 0.01633755f, -1.10469711f, -0.00789503f, -0.33106807f, 0.09788191f, 
    0.06829204f, 0.12940219f, 0.00499867f, -0.22057413f, -0.07764819f, -0.11809844f, 0.06971212f, 0.06601652f, 
    0.02358849f, -0.43054923f, 0.22119312f, -0.02230963f, -0.24017200f, -0.12104170f, -0.26109651f, 0.01367353f, 
    0.28937241f, -0.09328078f, -0.00721258f, 0.06129355f, 0.03647249f, -0.09354439f, 0.16012798f, -0.08017106f, 
    0.06878740f, -0.18098617f, 0.08364429f, 0.13586499f, -0.03929060f, -0.02027873f, 0.01270039f, -0.12965639f, 
    0.12263560f, -0.02453550f, -0.28417104f, 0.07190564f, -0.66004741f, -0.23841698f, 0.07768837f, -0.18078992f, 
    -0.32366261f, 0.28978375f, -0.05987134f, -0.11991673f, -0.10457949f, 0.04152456f, -0.01245178f, 0.03315729f, 
    -0.04476739f, 0.32225129f, 0.03874481f, 0.01775295f, -0.05232986f, -0.20781010f, -0.24548715f, -0.19505252f, 
    -0.81411183f, -0.12592642f, -0.43708491f, -0.13349871f, -0.09414448f, 0.05303516f, 0.13659695f, -0.14798628f, 
    -0.03281645f, 0.11073297f, 0.07208605f, 0.03047422f, 0.06017176f, 0.01726072f, 0.03690767f, -0.00603548f, 
    -0.01969026f, 0.13557602f, 0.02365709f, 0.11958814f, 0.39571017f, 0.31806740f, 0.37948984f, 0.06322942f, 
    0.01650628f, 0.18693732f, -0.05017008f, 0.16150378f, 0.05306140f, -0.03318249f, -0.09656435f, 0.05140845f, 
    0.05712995f, 0.08204288f, -0.03985215f, 0.05798059f, -0.02748076f, -0.19829553f, -0.25513110f, -0.11363205f, 
    -0.96577036f, -0.36964673f, -0.16638385f, 0.04415926f, -0.15286568f, 0.12244032f, -0.02045372f, 0.19866717f, 
    -0.02466170f, 0.31940955f, -0.08088737f, -0.18827794f, 0.08694827f, -0.01089041f, -0.04316752f, 0.00169727f, 
    -0.21666825f, -0.04671855f, -0.23716636f, -0.08280534f, 0.48920724f, -0.34416741f, 0.02111214f, 0.21300274f, 
    -0.01073987f, 0.00932133f, 0.17425166f, -0.03377166f, -0.03849908f, 0.00493206f, 0.05991926f, 0.19770227f, 
    0.02002270f, 0.12978850f, 0.11983655f, -0.00368672f, 0.03478093f, -0.03796446f, -0.04338382f, 0.03474357f, 
    0.00608259f, -0.44554406f, -0.28717858f, -0.16628650f, -0.67062229f, 0.10048333f, 0.05980057f, 0.25678626f, 
    -0.04920981f, 0.11310778f, 0.14425203f, 0.00673501f, 0.03330736f, -0.08218383f, -0.10795642f, -0.06617692f, 
    0.10326172f, -0.16148996f, -0.12598483f, -0.03603908f, 0.55806762f, -0.51532823f, -0.34205857f, -0.33335093f, 
    -0.20028767f, 0.09321526f, -0.02553708f, 0.03497909f, 0.05132821f, 0.11170413f, 0.13645191f, -0.06032157f, 
    -0.06511514f, -0.01096293f, -0.01964635f, 0.05455177f, -0.02957081f, -0.01871932f, -0.11529199f, -0.27035511f, 
    -0.17870212f, 0.25269908f, -0.28001308f, -0.27224836f, 0.01409565f, 0.07764763f, -0.12396582f, 0.08354516f, 
    -0.09239757f, -0.01660543f, 0.00639999f, -0.02718277f, -0.00094891f, -0.08243345f, 0.10812309f, -0.01804184f, 
    -0.04139252f, -0.05544858f, -0.01962302f, -0.13057685f, 0.09416956f, 0.37206420f, -0.21768323f, 0.37878254f, 
    0.12694661f, 0.31991661f, -0.08647432f, -0.10998959f, -0.06587725f, 0.06396089f, -0.00749185f, 0.02544462f, 
    -0.06808300f, 0.00009351f, 0.11032531f, -0.06437928f, 0.07684913f, -0.00587578f, -0.26279005f, 0.03733655f, 
    -0.20746903f, 0.29647189f, -0.15535282f, 0.16550528f, 0.24121313f, -0.15226965f, 0.16049992f, -0.08568710f, 
    0.06806443f, 0.01454904f, 0.02020088f, 0.15098260f, 0.04709859f, 0.05920488f, -0.06606680f, 0.05028521f, 
    0.03703687f, -0.05801133f, 0.11827036f, 0.04745630f, -0.23701201f, 0.18945092f, -0.27287057f, -0.18494704f, 
    0.29447570f, -0.05964769f, -0.18890290f, 0.02624400f, 0.08336829f, -0.15665440f, 0.06347028f, -0.04770084f, 
    -0.02458695f, -0.04440529f, 0.05881603f, 0.32140666f, -0.03890158f, -0.02800661f, 0.20492770f, -0.02757734f, 
    0.46399441f, -0.29081410f, 0.18755667f, 0.09314525f, -0.00394118f, 0.01376680f, 0.06004245f, 0.13603279f, 
    -0.09872233f, -0.21885671f, 0.01707686f, -0.12176869f, -0.02889955f, 0.15634394f, -0.26757485f, -0.18664408f, 
    0.03191366f, -0.07336296f, -0.24425709f, -0.09625022f, 0.24961352f, -0.25495592f, 0.17697775f, -0.00592229f, 
    -0.16962837f, -0.11003664f, 0.00777758f, -0.07911123f, -0.07775190f, -0.04540000f, -0.33040127f, 0.05043783f, 
    0.12908871f, 0.16139567f, 0.00040649f, -0.03186418f, -0.04295747f, 0.06313834f, -0.34949553f, -0.13378184f, 
    -0.72713399f, 0.05156861f, 0.17324302f, -0.15796036f, 0.12533635f, -0.17210750f, 0.04346914f, -0.01416546f, 
    0.14547403f, -0.24316213f, -0.12344209f, 0.13227753f, 0.10845774f, 0.01962951f, -0.16114017f, -0.07462800f, 
    0.01108908f, -0.11171331f, -0.19843853f, 0.14660610f, -0.75701928f, -0.17958906f, -0.06647323f, 0.20225161f, 
    -0.00103114f, -0.08204485f, 0.22596949f, 0.01343517f, 0.06283786f, -0.30149448f, 0.16096938f, -0.08951841f, 
    0.08180925f, 0.15786146f, 0.08485362f, 0.00129101f, 0.13559708f, -0.12664601f, -0.07587644f, 0.07893704f, 
    -0.32097751f, 0.35924366f, 0.09975912f, -0.02529841f, -0.02277784f, 0.07208762f, -0.13638316f, -0.04753231f, 
    -0.29620871f, -0.17467499f, 0.04146407f, -0.03358572f, 0.07091448f, -0.21462411f, 0.01138473f, 0.05970827f, 
    0.06908666f, -0.01331561f, 0.05832041f, 0.04691248f, 0.78886497f, 0.53209829f, -0.47439915f, -0.16151072f, 
    0.07205535f, -0.04433995f, 0.03341895f, -0.05955007f, 0.18199584f, -0.03559627f, 0.29761863f, 0.10920746f, 
    -0.03532663f, 0.12513849f, 0.09848899f, 0.08136225f, -0.09187676f, 0.09653194f, 0.01826270f, 0.21800731f, 
    0.17695682f, 0.03279006f, -0.25126681f, 0.04785266f, -0.39456308f, -0.19045022f, 0.02305908f, 0.03495768f, 
    -0.05940618f, 0.01392669f, -0.04522178f, -0.21669517f, 0.04547893f, -0.06662286f, 0.02282915f, 0.05301547f, 
    -0.05025587f, -0.11571455f, -0.03628969f, 0.06831263f, 0.54616565f, -0.02474278f, -0.34828982f, 0.09520303f, 
    0.10801341f, -0.15117715f, 0.05096303f, 0.00779219f, 0.20761795f, -0.12467538f, 0.16354774f, 0.03780797f, 
    -0.09853906f, 0.04832833f, 0.05569506f, 0.13400584f, 0.05746013f, -0.11002918f, 0.15542540f, 0.18743561f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14832591f, 0.11321285f, -0.05891177f, -0.07039447f, 0.07038722f, 0.04882499f, 0.01651510f, -0.04610496f, 
    -0.02405480f, 0.00088125f, 0.06476707f, 0.03260484f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
