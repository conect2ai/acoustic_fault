#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.22924230f, 0.03580182f, 0.71336430f, -0.45909053f, -0.30043313f, -0.03755971f, -0.12517600f, -0.31108436f, 
    0.41571364f, 0.76172000f, 0.36398572f, 0.17080256f, -0.19354741f, -0.22639127f, 0.05625823f, 0.63835561f, 
    -0.14670436f, -0.42768916f, -0.54048526f, 1.01923323f, -0.56263626f, -0.16816062f, 0.25252977f, 0.12221533f, 
    -0.43624178f, 0.13873398f, 0.33633032f, 0.76606363f, -0.35692018f, 0.01922214f, 0.58443999f, 0.11022786f, 
    0.04472067f, 0.10973020f, 0.63153476f, -0.57093602f, -1.19003797f, -0.27934304f, 1.00360012f, -0.01468963f, 
    0.00086125f, 0.72597325f, 0.23304150f, 0.05282573f, 0.10471220f, -0.66953951f, 0.04736431f, 0.16201787f, 
    -0.24287444f, -0.23005818f, 0.09744097f, 0.15682346f, -0.35522306f, -0.40038040f, 0.15855505f, 0.47356763f, 
    0.30456552f, 0.31708899f, -0.18340740f, -0.90311062f, -0.36187962f, -0.45798433f, -0.40120018f, 0.53960615f, 
    0.38608110f, -0.41901281f, -0.91419762f, -0.53362840f, -0.58118045f, 0.17453980f, -0.20304956f, 0.14726469f, 
    0.13346985f, 0.48816040f, 0.00610381f, 0.06254662f, 0.22573349f, 0.02261125f, -0.39271289f, 0.41105422f, 
    0.46239901f, 0.22344774f, 0.01802135f, -0.15911144f, -0.42104161f, -0.48207742f, -0.08689061f, 0.04517100f, 
    0.73661548f, 0.61552697f, -1.12750208f, -0.92235309f, -0.22464398f, 0.13151182f, -0.31923127f, -0.30489445f, 
    0.42006159f, 0.07128450f, -0.24251549f, -0.73327267f, 0.32090142f, -0.26665446f, 0.33171543f, 0.47843313f, 
    0.13842693f, 0.55327404f, 0.05076445f, -0.00284097f, -0.50859505f, -0.40336055f, -0.43003169f, 0.38648960f, 
    0.73028678f, 0.47445026f, -0.28118208f, -0.48575351f, -0.36066261f, 0.36045024f, 0.53809643f, 0.09014139f, 
    -0.21786064f, 0.37624976f, -0.35743764f, -0.48574159f, 0.64956552f, -0.38564235f, -0.34403029f, -0.45491967f, 
    1.09674096f, -0.79832238f, -0.43955436f, 0.35602209f, 0.41708347f, -0.17994797f, 0.00101922f, -0.49658608f, 
    1.08911014f, -1.09766209f, -0.07201249f, 0.22644985f, -0.41940355f, 0.30866563f, -0.24551408f, -0.42135361f, 
    -0.69044381f, 0.95552778f, -0.39014554f, 0.44843069f, -0.44233909f, -0.39358127f, 0.23636939f, 0.13981983f, 
    0.40215856f, -0.37542599f, -0.01428390f, 1.01957655f, 0.52418602f, -0.61461699f, -0.38739562f, 0.06561874f, 
    -0.08108269f, -0.04555962f, -0.55147016f, -0.07877057f, -0.37185887f, 1.27190232f, -0.45801544f, -0.29955161f, 
    -0.26028714f, -0.04170025f, -0.28823248f, 0.15334697f, 0.20811471f, -0.17395046f, 0.63981974f, 0.25926778f, 
    0.53178948f, -0.42491627f, 0.35283622f, -0.24510770f, 0.23075236f, 0.71422446f, -0.86307323f, -0.48797074f, 
    0.15148725f, -0.14668965f, 0.31813365f, 0.19393727f, 0.32933569f, -0.50902247f, -0.65925342f, -0.28266627f, 
    -0.26526615f, 0.75639272f, -0.70187747f, 0.11315760f, -0.10920940f, 0.13428625f, -0.01652392f, -0.02451831f, 
    -0.72037417f, -0.69763070f, -0.48976049f, -0.38057873f, -0.26345682f, -0.59592420f, 0.36920953f, -0.05248771f, 
    -0.19364788f, -0.42141381f, 0.52229589f, 0.66686004f, 0.54592425f, 0.14422250f, 0.71380591f, -0.43711096f, 
    -0.11816955f, -0.62187380f, -0.44005972f, 0.05156131f, 0.89892668f, -0.12811941f, -0.02644212f, 0.25544572f, 
    0.10329971f, -0.69985169f, 0.30831826f, 0.07755452f, -0.56327653f, -0.18973917f, -0.90638822f, 0.47470707f, 
    0.59585154f, 0.08548768f, 0.30656773f, 0.31042171f, 0.59691948f, -0.01812528f, 0.62444842f, 0.11291468f, 
    -0.03800654f, 0.05660846f, 0.27588174f, 0.49259964f, -0.13603552f, -0.65343463f, 0.46737996f, 0.43022496f, 
    0.08367829f, -0.23847713f, -0.42431676f, -0.15451711f, 0.33909386f, -0.24082203f, -0.08614406f, 0.38878340f, 
    0.41820294f, -0.51313120f, -0.31709132f, -0.00495643f, -0.60431075f, -0.68816417f, -0.08178489f, -0.23530661f, 
    -0.25321028f, -0.33077452f, -0.47690031f, -0.26450431f, -0.52137852f, -0.27759480f, 0.23087902f, 0.72348231f, 
    -0.20066896f, -0.37397248f, -0.24380739f, 0.60336423f, -0.45520109f, -0.54071170f, -0.27947280f, 1.08591247f, 
    -0.75818914f, -0.60284263f, 0.66646016f, -0.76322943f, -0.66682786f, -0.31710020f, -0.29909465f, 0.06479251f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.56154859f, 0.54190546f, 0.45918295f, 0.31574136f, -0.27915198f, 0.59142119f, -0.16440791f, 0.10392704f, 
    0.16355860f, -0.13391060f, 0.13305470f, 0.37051368f, -0.13744764f, -0.03862334f, -0.07896140f, 0.04660948f, 
    -0.05201602f, 0.17314537f, -0.12038322f, 0.18032274f, -0.04470474f, -0.14548567f, 0.17645258f, -0.01654461f, 
    -0.11983055f, 0.10549024f, -0.03487238f, 0.21221323f, 0.30343133f, -0.07692013f, -0.31931886f, -0.09918424f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.23916376f, 0.13333812f, 0.02261874f, -0.00439356f, 0.11288723f, -0.11384106f, 0.00074376f, -0.17445558f, 
    0.11359324f, -0.21643622f, 0.06812408f, 0.23890880f, 0.11770200f, -0.14029458f, 0.06791964f, 0.06503879f, 
    0.10049798f, -0.11213457f, 0.14380710f, 0.07141045f, -0.00135302f, 0.08473993f, 0.10297008f, 0.13243939f, 
    -0.08600095f, -0.01970774f, -0.04308396f, 0.16407496f, -0.03886904f, 0.29748777f, 0.13118447f, 0.05440194f, 
    0.11530636f, 0.07761698f, -0.13878019f, -0.20048179f, 0.04954478f, 0.22350410f, -0.37721577f, 0.18775384f, 
    0.08627418f, -0.15095863f, -0.11320238f, -0.10829815f, 0.12693495f, -0.31348273f, 0.15362929f, 0.07979203f, 
    0.08944003f, 0.13955252f, 0.23280226f, 0.00753199f, 0.01552365f, 0.03745990f, -0.06533320f, 0.01102016f, 
    0.01165065f, 0.03343013f, -0.07062923f, -0.01196154f, -0.04979795f, 0.17244250f, 0.03047562f, -0.18808210f, 
    0.03532165f, 0.10691959f, 0.09061419f, -0.06235963f, -0.02573296f, 0.10085102f, 0.00316532f, 0.10078911f, 
    0.05660712f, 0.11589526f, -0.01447573f, -0.02993893f, 0.11694951f, -0.03694947f, -0.06783144f, -0.11214775f, 
    -0.10749570f, 0.07627037f, -0.07959268f, -0.02370330f, 0.09603234f, -0.06016677f, -0.06214039f, -0.07945165f, 
    -0.24658370f, -0.26329303f, -0.21345720f, -0.29184747f, -0.08866036f, 0.16481936f, 0.11116841f, -0.03484626f, 
    -0.03597036f, -0.21425346f, 0.01226713f, 0.03589902f, -0.04905145f, -0.06240091f, -0.13074124f, -0.12339082f, 
    0.00787080f, -0.04501578f, 0.06436826f, 0.14512484f, 0.29044345f, -0.09528458f, -0.02337630f, -0.09679779f, 
    0.07450863f, 0.09838954f, -0.21352720f, -0.07087135f, -0.00073673f, -0.19516319f, 0.03261960f, 0.13676994f, 
    0.08522038f, 0.04152783f, 0.02498690f, 0.07823014f, 0.14824267f, 0.07224950f, -0.47614384f, 0.23000515f, 
    0.17804034f, -0.08468769f, 0.18074754f, 0.17942435f, 0.02204605f, -0.06356887f, 0.07072296f, 0.24768691f, 
    0.00483151f, 0.40719295f, -0.01309835f, 0.16722032f, 0.06653563f, 0.06146756f, 0.11267909f, 0.13268216f, 
    0.11665052f, -0.11034169f, 0.20316806f, 0.07783606f, -0.01401913f, -0.10852531f, -0.05624888f, -0.05418688f, 
    -0.03154861f, -0.02623025f, 0.39084670f, 0.19862697f, 0.03237834f, 0.10206903f, 0.02844340f, -0.04666711f, 
    -0.04911799f, 0.01751826f, -0.07539576f, 0.11566772f, 0.18523403f, 0.01769887f, 0.02646916f, -0.02264069f, 
    -0.08249578f, -0.07387137f, 0.16356365f, 0.11478087f, -0.01335514f, -0.11564294f, 0.03914075f, -0.20531747f, 
    -0.02480961f, -0.12625627f, -0.03436511f, -0.00050419f, 0.16317977f, 0.25821567f, -0.07292049f, 0.02107680f, 
    0.09769914f, 0.05640333f, -0.03194202f, -0.05193374f, -0.30994594f, -0.06588583f, -0.41974050f, 0.18288304f, 
    0.02646663f, 0.14074008f, -0.12501243f, -0.03986067f, -0.05601555f, 0.09417725f, -0.10325304f, -0.07742532f, 
    0.14081630f, 0.10874131f, 0.07535587f, -0.05244335f, -0.05272715f, -0.09073319f, 0.02832374f, 0.11472156f, 
    -0.05165518f, 0.04316748f, 0.05114140f, -0.08488654f, 0.08258528f, -0.00090937f, -0.01200056f, -0.16459514f, 
    -0.12041052f, -0.31204516f, 0.35065162f, -0.14325789f, -0.22788963f, -0.01435972f, -0.02044239f, 0.13547686f, 
    -0.04324287f, -0.10464419f, -0.05740684f, -0.15619624f, -0.15979239f, -0.05799111f, -0.23654114f, -0.02562431f, 
    -0.03768769f, -0.10061591f, 0.12539741f, 0.06265964f, -0.05684364f, 0.02488019f, -0.09491903f, -0.04818011f, 
    0.01357967f, -0.00778103f, -0.07353578f, 0.35421261f, -0.15414953f, -0.03361150f, 0.01619908f, 0.07787663f, 
    0.09858341f, 0.10936622f, 0.05232172f, 0.09874173f, 0.28284413f, 0.09866350f, 0.02927937f, 0.02774148f, 
    0.14009674f, 0.05253999f, 0.06105772f, 0.13223362f, -0.03821843f, -0.23593834f, -0.10961358f, 0.02814620f, 
    0.06231726f, 0.03718099f, 0.05405184f, 0.01048910f, -0.05135865f, -0.04577741f, -0.01771448f, -0.01295523f, 
    0.00928114f, 0.16450317f, -0.17520116f, 0.04416313f, -0.05717786f, 0.05644596f, -0.01586473f, 0.12749852f, 
    -0.02292260f, 0.38353261f, -0.04910494f, 0.02412308f, 0.10423913f, -0.02178439f, 0.03170744f, 0.18280496f, 
    -0.01864679f, 0.02620495f, 0.04961519f, -0.04225516f, 0.00653835f, -0.00940894f, 0.03267113f, 0.03744100f, 
    0.00118806f, 0.04201326f, 0.03819233f, -0.01927564f, -0.01875362f, 0.01425393f, -0.00075231f, 0.00904867f, 
    0.00026529f, -0.04767954f, -0.06057397f, 0.04673476f, -0.02794751f, 0.03665882f, 0.04916814f, -0.02778294f, 
    -0.05942867f, -0.06009259f, 0.04337300f, -0.02837471f, 0.04684066f, 0.04050745f, -0.02032224f, -0.05386709f, 
    0.01880778f, 0.00091155f, -0.05655115f, -0.00813712f, 0.00641786f, -0.00759883f, -0.05063239f, 0.00267743f, 
    0.01749193f, -0.00251505f, 0.00055353f, -0.04453141f, -0.04253839f, 0.00578997f, -0.05575006f, -0.01501565f, 
    0.02019710f, 0.02141980f, -0.03411265f, -0.00815781f, -0.02664875f, 0.02480511f, 0.00771023f, -0.01843777f, 
    0.04980901f, 0.02725620f, 0.00287594f, 0.03841477f, -0.00607377f, 0.04555869f, -0.04985134f, 0.01280206f, 
    -0.04610004f, -0.00681522f, -0.04729008f, -0.01021481f, -0.05742793f, -0.04856996f, -0.02681060f, 0.05258708f, 
    -0.02909762f, -0.02041147f, -0.02235344f, -0.00926550f, -0.04887604f, 0.02344658f, 0.00981962f, -0.05264243f, 
    0.04640692f, -0.05271205f, 0.03635545f, -0.04855580f, -0.01469068f, -0.03759653f, 0.04071997f, 0.02693930f, 
    -0.06117471f, 0.01214406f, -0.02356844f, -0.04273220f, -0.04646575f, -0.04672957f, 0.02395391f, 0.03173003f, 
    -0.01407624f, -0.00807546f, -0.03400653f, -0.02539070f, 0.04231399f, 0.04170892f, 0.03279715f, 0.04398267f, 
    0.02024085f, -0.01336077f, -0.01175980f, -0.02364288f, 0.01330405f, -0.01992749f, 0.03361447f, 0.02670798f, 
    -0.05651179f, -0.01461350f, 0.01193355f, -0.05115228f, -0.02804324f, 0.02285396f, -0.04802838f, -0.05956687f, 
    -0.01888244f, -0.04776890f, -0.02569868f, -0.01990311f, 0.00261105f, -0.01251337f, -0.00150768f, 0.03222865f, 
    0.01848185f, -0.03665332f, -0.06156045f, -0.04941477f, 0.01332106f, 0.03183561f, -0.02465470f, -0.06391091f, 
    -0.05014371f, 0.00768455f, 0.01830769f, 0.01040541f, -0.05736512f, -0.00330887f, -0.02300794f, 0.02547638f, 
    0.04357288f, 0.05157677f, -0.05732135f, -0.03433234f, 0.04754900f, -0.04024146f, 0.01624547f, -0.01368727f, 
    -0.02394749f, 0.02298912f, -0.00259071f, -0.02615570f, -0.04633265f, -0.05625917f, -0.01703526f, 0.03466207f, 
    0.04525699f, 0.03092445f, -0.03576111f, 0.02549790f, 0.05403531f, -0.00453234f, 0.03088756f, -0.04633977f, 
    -0.03740880f, 0.04729828f, 0.02598610f, -0.00046552f, 0.02775988f, -0.05336687f, 0.00976637f, 0.05160866f, 
    -0.02373167f, 0.02678948f, 0.02644871f, -0.05475696f, 0.00109714f, -0.05706018f, 0.02909097f, 0.01428338f, 
    0.00449334f, 0.01437097f, 0.01917147f, -0.06246059f, -0.00785030f, 0.04965110f, -0.06820631f, -0.00977082f, 
    0.02001693f, 0.01548998f, -0.02840988f, -0.04161137f, -0.04574211f, -0.03042358f, 0.01507186f, 0.00390863f, 
    0.02835401f, 0.04043784f, 0.03557325f, -0.01366792f, -0.00094441f, -0.01618007f, 0.03148307f, 0.04980098f, 
    -0.04045843f, -0.01466955f, 0.00266010f, -0.05979276f, -0.04364215f, 0.03900375f, 0.03104585f, -0.04480441f, 
    -0.00389499f, -0.02811215f, -0.04200692f, -0.04074186f, -0.06958400f, 0.04323298f, -0.02317744f, 0.03037578f, 
    0.03231419f, -0.00982322f, 0.03025607f, -0.03790670f, 0.01282293f, 0.03752211f, 0.02246676f, 0.01807225f, 
    -0.00306715f, 0.00763958f, -0.04554646f, 0.00583378f, -0.05703276f, 0.02868734f, -0.04231432f, 0.02446175f, 
    -0.01729464f, -0.00089896f, -0.01459606f, 0.00002965f, -0.01294588f, -0.02837207f, 0.05045804f, 0.01619342f, 
    -0.03838532f, -0.03814870f, -0.02109681f, -0.00912819f, 0.01250792f, -0.03318189f, 0.05333131f, 0.02526738f, 
    -0.06436688f, -0.04087574f, -0.04362533f, -0.05597267f, 0.04513402f, 0.01341883f, -0.06785256f, -0.02209261f, 
    0.02398911f, -0.03077280f, -0.03175222f, 0.03225795f, -0.03464038f, -0.04714242f, 0.04231352f, -0.01503511f, 
    0.04811835f, -0.05887678f, -0.01762957f, -0.04025559f, 0.00413819f, -0.01991528f, -0.04255390f, 0.03891918f, 
    -0.01297666f, 0.04867354f, -0.03977133f, -0.01259744f, 0.00270693f, -0.00066571f, -0.04369713f, 0.00945830f, 
    0.01576017f, 0.04286981f, -0.06255116f, -0.04293554f, -0.06718120f, -0.00062458f, -0.06420135f, -0.05757773f, 
    -0.03782720f, -0.04172764f, 0.00536834f, -0.05806746f, 0.03209419f, 0.00859440f, 0.04963822f, -0.05230842f, 
    0.00975113f, -0.05156793f, -0.03744705f, -0.03796091f, -0.05619899f, -0.06621163f, 0.01175363f, -0.03584126f, 
    0.05235672f, 0.03612132f, -0.03889571f, -0.07243536f, -0.03980914f, 0.04729285f, -0.05237774f, 0.01279411f, 
    -0.02729170f, -0.02726544f, -0.00175857f, -0.01729774f, -0.01012403f, 0.02559663f, -0.04698491f, 0.03101154f, 
    -0.05637176f, -0.02293950f, -0.02829280f, 0.00471739f, -0.02142728f, -0.04621962f, 0.00082750f, 0.04667225f, 
    -0.04555020f, -0.02617189f, 0.00842751f, 0.03637582f, -0.05598813f, 0.03157844f, 0.01671250f, -0.00008770f, 
    0.03895198f, 0.04361570f, 0.00968880f, 0.00084962f, -0.04649796f, -0.03302044f, -0.02300016f, -0.04901690f, 
    -0.03814242f, -0.04386252f, -0.00801432f, 0.01006907f, -0.06372347f, 0.04785564f, 0.03616625f, -0.00926909f, 
    -0.03626571f, -0.02746448f, -0.03349812f, 0.01742374f, 0.00558137f, 0.01885669f, -0.06744679f, -0.04928405f, 
    -0.02147239f, 0.02004218f, 0.01998667f, 0.04790136f, -0.06281698f, 0.03793418f, 0.03320471f, 0.01451612f, 
    -0.01597921f, -0.07478900f, -0.00215544f, -0.05691378f, -0.00212431f, -0.05763766f, -0.04909963f, -0.04556125f, 
    -0.05806337f, -0.01060318f, -0.03961226f, 0.00862959f, 0.02905997f, -0.01991471f, -0.04976795f, -0.05530138f, 
    -0.00907916f, -0.04498920f, 0.03134806f, -0.06036303f, -0.05651373f, 0.02889942f, -0.03480396f, -0.04861278f, 
    -0.00464593f, -0.01938808f, -0.01780640f, -0.06126108f, -0.04665039f, -0.04525252f, -0.01797038f, -0.05250436f, 
    0.00219841f, -0.06101910f, 0.03893484f, 0.05115680f, 0.00773768f, -0.05827343f, -0.01671111f, 0.02386868f, 
    0.03276373f, 0.01807516f, -0.04332265f, -0.02453504f, 0.03431270f, -0.00748719f, 0.02030742f, -0.03500085f, 
    0.01986438f, -0.05364948f, 0.02395930f, 0.04869558f, 0.02668477f, -0.03133188f, -0.05605680f, -0.05657787f, 
    -0.00857466f, -0.00579009f, 0.00335876f, -0.01886910f, 0.04786227f, -0.06635243f, -0.00133048f, 0.03364792f, 
    -0.04050586f, 0.03535574f, 0.01228198f, -0.04247156f, 0.04537267f, -0.04845572f, 0.04112615f, -0.03636609f, 
    0.03817692f, -0.02524905f, -0.02490998f, 0.01057948f, 0.04746709f, -0.05187523f, -0.03153741f, -0.04394742f, 
    0.02509190f, -0.04659588f, 0.02296704f, 0.04523338f, 0.02529642f, -0.01336567f, -0.04151850f, 0.04701856f, 
    -0.06160563f, -0.06535397f, 0.04764981f, 0.00966733f, -0.00434632f, -0.00941026f, 0.03866567f, 0.02412995f, 
    0.01364062f, -0.01840493f, -0.05429298f, 0.02865101f, -0.07218409f, -0.02139524f, -0.04522284f, -0.05909082f, 
    0.04270530f, -0.00993083f, 0.00671703f, 0.00841468f, 0.00831564f, 0.02502350f, -0.01524041f, 0.01027324f, 
    -0.02120343f, -0.03706564f, 0.01692330f, 0.01773627f, -0.05514542f, 0.05258099f, -0.00733558f, -0.00909642f, 
    -0.04299176f, 0.04973006f, 0.00704233f, 0.00573812f, -0.04661555f, -0.05862508f, -0.00378713f, -0.05090153f, 
    0.00171303f, 0.00807891f, 0.00466444f, -0.02234720f, 0.03030355f, -0.00569624f, -0.06484161f, 0.02898891f, 
    0.04641306f, 0.03590483f, 0.04850148f, 0.00624220f, -0.00023116f, -0.02185917f, -0.01658021f, 0.03992952f, 
    -0.01718536f, 0.00044977f, -0.05350280f, -0.04393868f, 0.02986020f, -0.00854083f, 0.01248443f, 0.04599674f, 
    -0.03105650f, 0.02022897f, 0.03815335f, 0.02003398f, -0.01946941f, -0.06237239f, 0.04733918f, -0.00859319f, 
    -0.04932885f, 0.00804132f, -0.02818155f, -0.04088612f, -0.01831112f, 0.03257609f, -0.05843235f, -0.02952474f, 
    0.03036039f, -0.02236779f, -0.03257823f, 0.03959861f, 0.02872784f, -0.03078884f, 0.04227098f, 0.02825698f, 
    -0.06190536f, 0.04555697f, 0.04985950f, 0.02328308f, -0.04376305f, -0.01153204f, 0.02165150f, -0.06780800f, 
    0.00688704f, 0.00033910f, 0.04785570f, 0.00483630f, 0.04021649f, 0.02350713f, 0.04788655f, 0.03672586f, 
    -0.04426922f, -0.01474801f, -0.05049723f, -0.01756666f, 0.03837568f, 0.05366515f, 0.04055323f, 0.03435887f, 
    -0.05553321f, -0.03688517f, -0.00385312f, -0.02016119f, -0.05883032f, 0.02245526f, -0.00589311f, -0.00068662f, 
    -0.00106650f, 0.04367867f, -0.04141061f, -0.01997028f, 0.03331220f, 0.02522843f, -0.06400713f, -0.03577943f, 
    -0.03520488f, -0.00839077f, 0.02410842f, -0.04114998f, -0.05720365f, 0.01943825f, 0.03439708f, -0.06022709f, 
    -0.06555741f, 0.04770409f, 0.00671765f, -0.00776139f, 0.01554423f, -0.02660096f, -0.01897811f, 0.03203870f, 
    -0.00724376f, -0.03494546f, -0.02176330f, 0.00853211f, 0.00079892f, 0.05555982f, -0.02239295f, -0.03992845f, 
    0.02316999f, -0.03302966f, 0.02631672f, -0.06284530f, 0.03364126f, 0.03556440f, -0.03537889f, 0.02104934f, 
    -0.05116682f, 0.02518274f, 0.03189792f, -0.04823422f, 0.02697733f, 0.00950431f, 0.04001276f, -0.01571874f, 
    0.01303333f, -0.02581890f, -0.02568135f, 0.04501484f, -0.01345911f, -0.00393116f, 0.04520359f, 0.02070406f, 
    0.04187625f, 0.00591488f, 0.01370433f, -0.06600308f, -0.04292841f, -0.02629871f, -0.03255614f, 0.01491426f, 
    0.00446278f, 0.03128441f, -0.05843703f, -0.02879469f, 0.04450879f, 0.04357140f, 0.01669881f, -0.04330207f, 
    0.02369382f, 0.04781960f, 0.03438200f, 0.01700291f, 0.03725106f, -0.00771552f, -0.03009844f, -0.01980991f, 
    0.03786744f, 0.02321543f, 0.01697323f, 0.00279072f, 0.01519164f, 0.03028975f, 0.02709914f, -0.03831122f, 
    0.03716797f, -0.00668485f, -0.00522844f, 0.01264226f, 0.03124758f, -0.05482054f, -0.04139913f, -0.05854556f, 
    -0.03919768f, 0.03251544f, -0.03947021f, -0.00728604f, 0.04220098f, -0.02038237f, -0.01904576f, -0.05696089f, 
    -0.01299395f, 0.03161293f, 0.01681289f, 0.03431444f, -0.02599522f, 0.03527784f, 0.03516273f, -0.06450485f, 
    -0.05663703f, 0.01835320f, 0.03342367f, -0.03207364f, 0.01384578f, 0.05234685f, -0.03795416f, -0.03834723f, 
    -0.01226561f, -0.05558572f, -0.05575475f, 0.02687804f, 0.04413679f, -0.01738256f, -0.00507047f, -0.01726154f, 
    0.04655639f, -0.05413274f, -0.02748062f, -0.02170079f, -0.00382560f, 0.04251050f, -0.02325001f, -0.03323194f, 
    0.01292446f, 0.00959581f, 0.02515191f, -0.06754654f, -0.04641897f, -0.05273180f, 0.03966469f, -0.04672679f, 
    0.00590993f, 0.00484861f, -0.01274434f, 0.04037099f, 0.03632538f, -0.03929564f, -0.04196707f, 0.00086073f, 
    -0.00858561f, -0.03438053f, 0.03567121f, -0.02727898f, -0.06529238f, -0.04981032f, -0.03592823f, -0.05233556f, 
    0.04291653f, 0.03736837f, -0.01032217f, -0.04822852f, 0.01409284f, -0.05720704f, -0.05882461f, 0.02057590f, 
    0.00647590f, 0.03745816f, -0.02241919f, 0.01989200f, -0.03030155f, -0.05254323f, -0.05659174f, -0.04833255f, 
    -0.04622934f, -0.01783886f, -0.00242189f, -0.03722665f, -0.00233143f, -0.03355935f, -0.04669786f, -0.05247650f, 
    -0.00814459f, -0.04891047f, -0.05252097f, -0.04057979f, 0.00875288f, 0.01491972f, -0.00617709f, 0.04003853f, 
    -0.03757958f, 0.00899864f, -0.03408979f, -0.05753104f, 0.04974060f, 0.00412291f, -0.03660190f, -0.00411384f, 
    0.05301364f, -0.02486910f, -0.04869232f, -0.03835081f, -0.02136385f, 0.03054053f, 0.04923023f, 0.02192802f, 
    -0.00132180f, 0.03318228f, -0.04138242f, -0.06136050f, -0.05209340f, -0.03351631f, -0.01987348f, 0.00817797f, 
    0.04587025f, 0.03205459f, 0.01669946f, -0.05130155f, 0.02083584f, -0.02347588f, -0.00394770f, -0.00231177f, 
    0.00973476f, 0.01679050f, -0.03452360f, -0.02733457f, -0.04670851f, 0.04686885f, 0.05014743f, 0.01291225f, 
    -0.03909063f, -0.02849074f, 0.03142337f, -0.04191663f, 0.02102138f, 0.00369761f, -0.01988536f, 0.03793339f, 
    -0.02753306f, -0.04945873f, 0.04518547f, 0.00882738f, 0.03175590f, -0.06657095f, -0.05862138f, 0.03044987f, 
    -0.06477173f, 0.01468810f, -0.05978615f, -0.05560697f, -0.00974526f, 0.01134853f, -0.00254500f, -0.05634797f, 
    0.00709378f, -0.03598688f, -0.03743559f, -0.04104258f, -0.02341236f, -0.00928210f, 0.03109779f, 0.02578405f, 
    0.01674137f, 0.03125707f, -0.04604224f, -0.00516089f, 0.01407913f, 0.01186130f, -0.01397209f, -0.04600107f, 
    -0.02859003f, -0.03067408f, -0.00055238f, 0.02223979f, 0.05768052f, -0.03454830f, 0.03915210f, -0.02273781f, 
    0.03946931f, 0.04606770f, -0.06978799f, -0.03588596f, -0.02707774f, 0.01736409f, -0.06430583f, -0.01533899f, 
    -0.02207134f, -0.03920349f, 0.03943441f, 0.04689635f, -0.03017467f, 0.01821527f, -0.01634821f, 0.03956107f, 
    0.02542419f, 0.03487764f, 0.03308421f, -0.00686879f, -0.06349531f, 0.04559628f, 0.03090329f, -0.01025698f, 
    0.02361058f, 0.03059037f, -0.02875508f, 0.04529612f, -0.04202745f, 0.01727336f, -0.05167625f, -0.04323310f, 
    -0.02563746f, 0.00559800f, 0.00866872f, 0.01202511f, 0.04226264f, -0.00244245f, 0.01961308f, -0.04838951f, 
    0.03714494f, -0.02636838f, 0.04232111f, 0.02557295f, -0.02037303f, -0.05686603f, -0.06768374f, 0.01249283f, 
    -0.01968786f, -0.04289943f, -0.05982844f, 0.03539405f, -0.03796519f, -0.02931216f, -0.06512712f, -0.02075153f, 
    -0.04219357f, 0.00423078f, 0.00302067f, -0.03860447f, 0.02140033f, 0.04287751f, -0.02822962f, -0.06353789f, 
    0.02358702f, -0.06329727f, -0.03566173f, -0.04114335f, 0.02252354f, 0.01578148f, -0.01252097f, 0.04007564f, 
    0.01480608f, 0.01127659f, 0.00474423f, -0.04729542f, -0.00392270f, -0.03701860f, 0.04219824f, -0.05482473f, 
    0.02908890f, 0.01509419f, -0.02904544f, -0.02030932f, 0.03529370f, 0.00987933f, 0.04114423f, 0.05039912f, 
    0.03984480f, 0.00352894f, 0.03961204f, -0.02159456f, 0.02042177f, 0.00665730f, -0.06685365f, 0.02996481f, 
    0.02389866f, -0.03332304f, -0.01962582f, 0.04331248f, 0.04901376f, -0.05889825f, -0.06477640f, -0.01323630f, 
    0.02234893f, 0.03502783f, 0.02001766f, 0.04477273f, -0.06420753f, 0.00318572f, -0.05676886f, -0.06512938f, 
    -0.02639218f, -0.02762721f, 0.00770512f, 0.03237109f, 0.02653261f, 0.02329168f, -0.05023882f, 0.04659471f, 
    -0.05099226f, -0.02311500f, 0.05227240f, -0.04171646f, -0.05541566f, 0.00010451f, -0.02133142f, -0.04374478f, 
    -0.01451004f, 0.00007725f, 0.00916748f, -0.04366406f, 0.02175935f, -0.02316263f, 0.00134591f, 0.02321293f, 
    0.02707206f, 0.00042645f, 0.02090343f, -0.02478359f, -0.05915053f, 0.02234676f, 0.01792153f, -0.01241421f, 
    0.03372417f, -0.04533286f, -0.00959566f, -0.02165008f, 0.03358284f, -0.03971291f, -0.04912370f, -0.03036107f, 
    0.04904662f, 0.04164726f, -0.03155731f, 0.02594117f, 0.01387962f, -0.03534300f, -0.02500449f, -0.03966352f, 
    0.03442060f, -0.06130702f, 0.01013032f, 0.03514632f, 0.02607559f, -0.03888435f, -0.03254658f, -0.03808803f, 
    -0.04014008f, 0.00482390f, 0.01180567f, 0.06545971f, -0.01793845f, 0.04391956f, -0.02726329f, -0.04405965f, 
    -0.05046500f, -0.03449139f, 0.00302021f, -0.05610329f, -0.02647637f, -0.05312340f, -0.02901916f, 0.03814481f, 
    -0.06365833f, 0.00789715f, 0.02805664f, -0.06032964f, -0.01609728f, -0.02632533f, -0.03785327f, 0.01431204f, 
    0.01100463f, -0.00713184f, 0.03480187f, 0.02806936f, -0.01478904f, -0.03029396f, 0.03522835f, -0.01739108f, 
    0.02948470f, -0.01387268f, 0.01613345f, 0.04247984f, -0.03887041f, 0.00578475f, 0.00900688f, -0.05306087f, 
    0.04431510f, -0.03555673f, -0.02249897f, 0.01615803f, -0.00866492f, -0.00829987f, -0.01685452f, -0.00202387f, 
    -0.00668249f, 0.02283779f, 0.01090559f, -0.03368060f, 0.04371418f, -0.05415951f, -0.05466650f, 0.00570463f, 
    0.01586174f, 0.00065669f, 0.01699694f, -0.01516300f, -0.01128540f, -0.06191050f, -0.06701253f, -0.04313475f, 
    -0.03283230f, -0.01802889f, -0.02736345f, 0.01332292f, -0.04958717f, -0.00263644f, 0.04145736f, -0.03958419f, 
    0.00380084f, 0.01291993f, -0.01889177f, 0.01626205f, -0.01498620f, -0.00409067f, 0.01594373f, -0.02233226f, 
    -0.02543673f, -0.03557660f, 0.04644885f, 0.03877008f, 0.00663728f, -0.05577612f, -0.06216701f, -0.02360193f, 
    -0.06297096f, -0.01761041f, -0.04587726f, -0.04842407f, -0.04920202f, 0.02963654f, -0.03174494f, -0.04215670f, 
    -0.03975092f, 0.02748682f, -0.03693058f, 0.03300714f, 0.01671033f, 0.03100829f, -0.02530487f, 0.01379472f, 
    -0.01041838f, 0.04023973f, 0.05196970f, -0.04533774f, -0.05852929f, -0.04338494f, 0.03252610f, -0.00034332f, 
    -0.04388281f, 0.03176408f, 0.04056827f, -0.05654957f, -0.02074822f, -0.04257211f, -0.05320425f, -0.05267689f, 
    -0.06519515f, 0.01389676f, -0.01092417f, 0.02376448f, -0.02982643f, 0.03142590f, -0.03851644f, 0.02898137f, 
    -0.04044059f, 0.02838453f, -0.00809957f, 0.04977611f, 0.01205461f, -0.02488802f, 0.03067849f, -0.03464770f, 
    0.02554662f, -0.02826689f, 0.03584024f, -0.02545066f, 0.03744781f, -0.05174903f, -0.03280532f, -0.01022747f, 
    -0.00062253f, 0.04199858f, -0.04271519f, -0.04267661f, -0.04178542f, 0.04588307f, -0.01672674f, 0.03365592f, 
    -0.00819754f, -0.03619451f, 0.03000704f, -0.04753882f, -0.01399642f, 0.03510917f, 0.05055835f, -0.01814580f, 
    0.02384775f, -0.00485802f, 0.01622267f, -0.00539937f, 0.02802385f, -0.05738261f, 0.00514187f, 0.04478878f, 
    -0.02204286f, 0.00686038f, -0.00178465f, 0.04789644f, 0.02162775f, -0.02713862f, 0.01753615f, -0.04415425f, 
    -0.02671107f, 0.02469415f, -0.01906108f, -0.00066336f, 0.02628672f, -0.02184161f, 0.02407647f, -0.03813669f, 
    -0.04088796f, -0.00060363f, -0.05500733f, -0.05353358f, -0.03051237f, 0.00638423f, 0.01919044f, 0.04212818f, 
    -0.01458090f, -0.01188416f, -0.02504681f, 0.00171099f, 0.02875376f, 0.02400482f, -0.02348075f, 0.00211824f, 
    -0.04329875f, -0.01596745f, 0.00395507f, -0.01821274f, 0.00992926f, -0.06369819f, -0.01147087f, -0.00700827f, 
    0.05239863f, -0.00334127f, 0.01414699f, 0.03586639f, 0.02759727f, 0.04139214f, -0.02975617f, -0.02674736f, 
    -0.03656666f, -0.00021041f, -0.00279492f, -0.05809012f, -0.05018194f, -0.03902126f, 0.00592777f, -0.01606025f, 
    -0.05706465f, -0.04512735f, -0.05204164f, 0.03236262f, 0.00168706f, 0.04224063f, -0.06396937f, -0.03765830f, 
    -0.05651160f, 0.04772618f, -0.05513779f, -0.04680577f, -0.00729894f, 0.00629033f, 0.00873558f, 0.01875738f, 
    -0.06525242f, -0.03071462f, -0.00277843f, -0.01139555f, -0.01850185f, -0.03735438f, -0.01053770f, -0.05056896f, 
    -0.03161631f, 0.03090120f, 0.03032894f, -0.00947380f, 0.01312538f, 0.01648079f, 0.00258421f, -0.03306343f, 
    -0.05093786f, 0.02277332f, -0.03789997f, -0.06344423f, 0.02576364f, -0.02187166f, -0.01255174f, 0.03709128f, 
    -0.05293902f, 0.03580017f, -0.01580267f, -0.02570996f, 0.01984315f, -0.00746272f, -0.04082011f, -0.04133089f, 
    0.02624793f, -0.05641899f, -0.02844148f, -0.06633279f, 0.04033158f, 0.00057964f, -0.04203417f, -0.05147010f, 
    -0.02962634f, 0.00933445f, 0.02905348f, 0.01476370f, -0.05894208f, 0.00712030f, 0.01564436f, 0.00560973f, 
    -0.01567874f, -0.00859118f, 0.02390410f, -0.01753370f, 0.01134623f, -0.01192249f, 0.04702178f, -0.01840881f, 
    0.02950152f, 0.00954122f, 0.02307571f, 0.00011441f, 0.00622951f, -0.01133403f, 0.01511610f, -0.00513556f, 
    -0.02031513f, -0.04795625f, 0.02757115f, 0.02349836f, 0.04381528f, -0.06071814f, -0.05207392f, 0.02695820f, 
    0.03845846f, -0.02837290f, -0.00362588f, -0.05662454f, -0.04966023f, 0.01776306f, -0.02392563f, -0.04418425f, 
    0.03817648f, -0.05811609f, -0.05949198f, 0.00735035f, 0.01493722f, -0.03242261f, 0.03030198f, -0.03635893f, 
    -0.06218890f, 0.01030648f, -0.03068186f, -0.06381924f, -0.04059140f, -0.03248078f, 0.02148202f, -0.02586272f, 
    -0.02974272f, 0.04722906f, -0.04662850f, 0.01906698f, -0.05896667f, 0.03949148f, 0.03678210f, -0.02398778f, 
    -0.01441398f, -0.04544462f, 0.02849068f, 0.01806111f, -0.01156826f, -0.03259005f, -0.01079579f, -0.02545013f, 
    -0.04386402f, 0.04255965f, 0.04028194f, 0.05531652f, -0.05757825f, 0.04721000f, -0.06126608f, 0.00910175f, 
    0.00174917f, -0.02567110f, 0.04433906f, 0.02448196f, 0.01209539f, -0.02709584f, -0.04963609f, -0.05506495f, 
    -0.01321454f, 0.03010971f, -0.03061657f, -0.01308025f, -0.01473081f, -0.04277802f, -0.01599848f, -0.05094897f, 
    -0.02706378f, -0.03863255f, -0.00042761f, -0.04478236f, 0.02856771f, -0.01915074f, -0.05513205f, -0.00476175f, 
    -0.02855426f, -0.02919152f, -0.02971799f, -0.02130373f, 0.00475223f, -0.05061492f, 0.03143616f, 0.02635004f, 
    -0.05445488f, -0.04034674f, 0.05170097f, 0.02907822f, -0.06678316f, 0.04178727f, 0.00970843f, 0.05069107f, 
    -0.00909482f, 0.01843756f, -0.00965602f, 0.01137583f, 0.01715342f, -0.04581385f, 0.04829466f, -0.03062339f, 
    -0.01607832f, -0.02074543f, -0.00112486f, -0.02442438f, -0.00544174f, -0.04011133f, 0.01777355f, -0.01903241f, 
    -0.05323762f, -0.01073275f, -0.03387815f, -0.05273435f, 0.01260571f, 0.02703776f, -0.03646776f, -0.06355499f, 
    0.03161902f, -0.03899021f, -0.00952549f, -0.05426510f, -0.03750491f, 0.00178045f, -0.00663966f, -0.05300755f, 
    -0.02126185f, -0.00728002f, 0.00481346f, 0.02168259f, 0.01212454f, 0.04756552f, -0.01850988f, -0.02225306f, 
    0.03915413f, -0.05681226f, -0.05725362f, -0.03884481f, -0.06056572f, 0.04418856f, 0.01016546f, 0.03602584f, 
    -0.03993802f, -0.00661777f, -0.01416548f, -0.00419687f, 0.04422905f, 0.00108531f, -0.04638713f, 0.04811266f, 
    0.02927384f, 0.04136494f, -0.05904541f, -0.01227538f, -0.01040076f, -0.01653855f, 0.01944649f, 0.01513047f, 
    -0.00586469f, -0.04027290f, -0.05434003f, -0.03859889f, 0.04260336f, 0.04088233f, -0.06698215f, -0.04801562f, 
    -0.00618130f, 0.02021751f, 0.02862433f, -0.00195535f, 0.01940949f, 0.00011989f, -0.02978588f, -0.04592971f, 
    0.04018665f, -0.02267575f, 0.00367229f, 0.00324239f, 0.04832180f, -0.02689097f, 0.02162346f, -0.01590846f, 
    -0.05701476f, -0.04801124f, -0.01992618f, 0.00951853f, -0.04563135f, 0.00932610f, -0.00266109f, -0.03401932f, 
    -0.02024009f, -0.01640444f, 0.00515555f, -0.03913112f, -0.00309155f, -0.04008486f, 0.01868951f, 0.03112236f, 
    -0.01892375f, -0.02647887f, 0.03279185f, 0.00352027f, -0.00342672f, -0.00363751f, -0.06867927f, -0.01544050f, 
    -0.01329934f, -0.06708667f, 0.00158114f, 0.04951525f, -0.02348408f, -0.02674707f, -0.03514756f, 0.03830734f, 
    0.02734500f, 0.00312015f, -0.01077616f, 0.02602972f, -0.02379490f, 0.01232693f, 0.01180069f, -0.05373073f, 
    -0.04176124f, 0.04678423f, 0.01389550f, -0.03470035f, -0.04726783f, 0.04615035f, -0.00296733f, -0.04751011f, 
    -0.00726678f, 0.01479368f, -0.04073159f, 0.03643394f, -0.04239659f, -0.00455582f, 0.03685634f, -0.05871782f, 
    0.01177850f, -0.04922782f, 0.00144153f, 0.02969139f, 0.01238744f, -0.05366056f, -0.03749546f, -0.05619746f, 
    -0.04004227f, 0.00424077f, 0.03559531f, 0.02101567f, -0.05040750f, 0.01814837f, 0.00631150f, 0.03877404f, 
    -0.01720830f, 0.02988869f, -0.05495118f, -0.04969415f, -0.06348525f, 0.03690984f, -0.00357274f, -0.05745821f, 
    -0.04319650f, -0.00352420f, -0.03822864f, -0.01386541f, -0.05098097f, -0.03076369f, -0.05651706f, 0.03884700f, 
    0.03825384f, 0.04160262f, 0.00771677f, 0.02874111f, -0.03259096f, 0.04859089f, 0.02453103f, 0.02443488f, 
    -0.03343028f, 0.02558539f, 0.02345533f, 0.02808484f, 0.01372418f, 0.04464781f, 0.01933073f, -0.03309078f, 
    0.05240842f, 0.03869098f, -0.01801164f, -0.03496452f, 0.05426786f, -0.02657263f, 0.02982148f, -0.06364791f, 
    0.00391526f, -0.00234750f, -0.06640388f, -0.00376036f, -0.00180792f, 0.03649135f, 0.02308884f, -0.01916248f, 
    0.00763669f, -0.02422043f, -0.00403161f, 0.02547110f, -0.04021098f, 0.02877911f, -0.04281854f, -0.04497282f, 
    0.03923167f, -0.02296125f, -0.03031531f, -0.01837084f, 0.04235232f, -0.01361531f, -0.00151416f, 0.03508406f, 
    -0.00890248f, -0.03358115f, 0.04274734f, -0.02724949f, -0.03477806f, -0.02723179f, 0.04667088f, -0.04410421f, 
    -0.03392909f, -0.01317208f, -0.00054816f, 0.04296653f, -0.02137387f, -0.04999739f, 0.04635973f, 0.01674543f, 
    0.01483170f, 0.05329449f, 0.00704152f, 0.03919582f, -0.05786483f, -0.04737265f, -0.06697931f, 0.03217835f, 
    -0.01791182f, 0.01012039f, -0.02739858f, -0.00424695f, -0.01166482f, -0.01594302f, -0.03990524f, -0.02628389f, 
    -0.00135617f, -0.06205330f, 0.00586037f, 0.00839116f, 0.02468778f, 0.00716124f, -0.06401371f, -0.02412556f, 
    -0.06349041f, 0.04270112f, 0.00536403f, 0.04185497f, -0.02078952f, -0.05671492f, -0.02802945f, -0.04557875f, 
    0.00717297f, -0.01959300f, 0.02555239f, -0.04161365f, -0.00201758f, -0.02712525f, -0.05170828f, 0.04122619f, 
    0.02787129f, -0.05236389f, 0.02222917f, 0.05216922f, 0.04393265f, 0.03115334f, 0.03660598f, 0.02701018f, 
    -0.01560574f, -0.06787480f, -0.01801959f, -0.00958725f, 0.01886737f, 0.04754787f, 0.03140046f, 0.02160567f, 
    0.02097684f, 0.01419725f, -0.41115654f, 0.12918526f, -0.06220268f, 0.16882554f, 0.07575332f, -0.05182153f, 
    -0.00016170f, -0.03468066f, -0.18191099f, -0.27628380f, 0.02527998f, 0.16747256f, 0.13130705f, 0.21001707f, 
    0.23105069f, -0.01762347f, -0.15647589f, 0.10453077f, -0.20919907f, 0.07393070f, -0.03668083f, 0.11814050f, 
    -0.11328054f, -0.06392381f, 0.16266942f, 0.10888154f, -0.11296360f, 0.21447425f, 0.06393822f, 0.04672742f, 
    -0.00275530f, 0.13115352f, 0.04673829f, 0.16099179f, -0.25557679f, 0.07288612f, 0.07458931f, -0.14074141f, 
    0.03584715f, -0.00391460f, -0.13350163f, -0.00199498f, -0.06589612f, -0.23875989f, -0.07772367f, 0.21374960f, 
    0.17792550f, 0.08043350f, 0.02920776f, 0.00500184f, 0.01869635f, 0.19393811f, 0.00669503f, -0.07615307f, 
    0.03715114f, 0.09659638f, -0.05134606f, -0.06770486f, 0.03417924f, 0.02508953f, 0.08392826f, 0.14307623f, 
    0.11244795f, -0.35246298f, 0.07047149f, -0.06736941f, 0.04535471f, 0.01037099f, 0.10432243f, -0.05517323f, 
    -0.13071990f, 0.02677595f, -0.04656797f, 0.06693178f, -0.00398937f, 0.10050476f, 0.29431769f, 0.07026520f, 
    0.08457514f, -0.00437775f, 0.22546603f, 0.02480602f, -0.05246443f, -0.08037952f, 0.15554744f, 0.08669999f, 
    -0.17130817f, -0.26878554f, -0.10969450f, 0.09134377f, 0.67323357f, 0.10952950f, 0.05054505f, -0.15145144f, 
    0.04963483f, -0.03117143f, 0.05813073f, 0.10795116f, 0.12541026f, 0.25763619f, -0.01718445f, 0.13439730f, 
    -0.05433232f, 0.13525678f, -0.05747703f, -0.05486265f, 0.18010943f, 0.43783003f, 0.55957043f, -0.23828600f, 
    -0.15828557f, -0.15262811f, 0.17207599f, 0.09605651f, 0.14680931f, 0.01714240f, -0.20731434f, -0.14884612f, 
    0.08424921f, 0.00755067f, -0.00780689f, 0.04325571f, 0.14485177f, -0.10154179f, -0.16146454f, -0.44408789f, 
    -0.79566681f, 0.03117446f, -0.30546245f, 0.13047999f, -0.00244217f, 0.07338349f, -0.09681278f, -0.08564744f, 
    -0.47618705f, -0.43816963f, 0.03229411f, -0.00646112f, -0.04477732f, -0.17886652f, 0.01205391f, 0.09312163f, 
    0.03936942f, -0.02726149f, -0.13709962f, -0.21303718f, 0.02624003f, -0.07521734f, 0.20833059f, -0.01385948f, 
    -0.02904970f, 0.29645687f, -0.25060636f, -0.19645372f, -0.23213530f, 0.01030403f, 0.13980632f, 0.17835815f, 
    0.01409223f, -0.04349977f, -0.37147075f, -0.09318105f, 0.03125172f, -0.33400238f, 0.01272014f, -0.15298508f, 
    0.11282831f, 0.08907964f, -0.08271669f, 0.29398605f, 0.08492577f, 0.15665323f, -0.05550482f, -0.04468260f, 
    0.03322373f, 0.22559932f, -0.00175898f, 0.11548359f, 0.10142635f, 0.18946004f, 0.01104388f, 0.25561219f, 
    -0.18682861f, 0.26672828f, 0.14239070f, -0.03916793f, -0.28451875f, -0.22570585f, -0.09851635f, 0.05093243f, 
    -0.09001905f, 0.00549307f, -0.09043058f, 0.07937947f, -0.11284700f, 0.01597456f, -0.14347337f, -0.02836476f, 
    -0.14527965f, -0.06909928f, -0.18557096f, 0.03549301f, -0.02220662f, -0.03699706f, 0.06478110f, 0.37090704f, 
    0.31692308f, 0.32912955f, -0.04962514f, -0.07822505f, -0.01539373f, 0.04480578f, 0.03667003f, 0.08514331f, 
    -0.11392451f, 0.10680581f, 0.19208136f, -0.09817864f, 0.04565201f, -0.22928517f, 0.00605802f, -0.02075693f, 
    -0.05474633f, 0.09131865f, 0.08176751f, 0.12540589f, -0.13067716f, -0.13717316f, -0.07929111f, -0.03692251f, 
    -0.12736166f, -0.15674093f, -0.15596877f, -0.14693718f, 0.02238791f, 0.09136762f, 0.12598690f, 0.07563778f, 
    0.24299814f, 0.08730616f, 0.09843990f, 0.14344215f, -0.01752272f, 0.03389162f, -0.07936830f, -0.08731089f, 
    -0.04205803f, -0.04810713f, 0.07066808f, 0.13315059f, 0.13953161f, -0.19695969f, 0.11820682f, 0.06508548f, 
    0.01167384f, 0.08138822f, -0.09719183f, -0.02671085f, 0.17595568f, -0.17618115f, 0.02868850f, 0.16124031f, 
    -0.09907959f, -0.12874238f, -0.26460248f, 0.02271818f, 0.03837131f, 0.15142146f, -0.19678518f, -0.45598283f, 
    -0.32300586f, 0.04041544f, -0.08893605f, 0.15795442f, 0.06176835f, 0.18189424f, 0.07058594f, -0.29976586f, 
    -0.16976482f, -0.26072097f, -0.38712257f, -0.15430519f, -0.17017725f, -0.01282762f, -0.11727326f, -0.15903594f, 
    -0.02611410f, -0.01845866f, 0.00283631f, -0.04511521f, -0.06110570f, -0.03033083f, 0.00636287f, -0.04294220f, 
    0.02824511f, 0.03835056f, 0.02021922f, -0.06208314f, 0.04202793f, -0.05153194f, 0.04569677f, -0.01024429f, 
    -0.04468467f, -0.05486505f, -0.01457230f, -0.03318250f, 0.00310860f, -0.02131458f, 0.05131991f, -0.00879448f, 
    -0.00244641f, -0.01615647f, -0.05417732f, 0.03310988f, 0.03545917f, -0.02819705f, -0.04049787f, -0.02824727f, 
    0.02116655f, -0.00330642f, -0.01308812f, -0.04016904f, -0.05955901f, 0.00219232f, -0.00154598f, -0.02584667f, 
    0.04322809f, 0.04781672f, -0.01517437f, 0.05437861f, 0.03984890f, 0.02846859f, -0.06194559f, 0.01368193f, 
    -0.03988045f, 0.03571783f, 0.03580654f, 0.03713670f, -0.02561826f, 0.00998250f, 0.02190552f, -0.00152426f, 
    -0.05005097f, 0.01290835f, 0.04527366f, -0.06796719f, 0.04446083f, -0.04888133f, 0.03397547f, 0.04306077f, 
    0.01274025f, -0.01590535f, -0.00625909f, 0.03413231f, -0.01234299f, 0.04527766f, -0.00511953f, 0.04990065f, 
    0.04675006f, -0.05683225f, -0.01910049f, 0.03617315f, -0.06391092f, -0.01856244f, 0.03697462f, -0.03634814f, 
    -0.02570624f, -0.05382968f, -0.03560811f, -0.05144845f, 0.01316279f, -0.01695688f, 0.03498471f, 0.01903162f, 
    -0.05680389f, -0.00100058f, -0.03772584f, -0.01232652f, -0.04671231f, -0.04132265f, -0.03031300f, 0.00318523f, 
    0.04209969f, -0.03398747f, -0.00967894f, 0.04636966f, -0.04746953f, -0.01726785f, -0.03259782f, 0.02827894f, 
    -0.02381880f, 0.01051301f, -0.05521216f, -0.06198546f, 0.01137856f, -0.01006517f, -0.01730229f, -0.00335835f, 
    -0.06114643f, -0.00385471f, 0.02209282f, 0.00266479f, -0.06341010f, -0.01820188f, -0.03754366f, -0.03710630f, 
    -0.01545276f, -0.04323974f, -0.04586463f, 0.04486608f, 0.03884949f, 0.00346303f, 0.03421718f, -0.02298429f, 
    0.02838289f, -0.03391645f, 0.00823764f, 0.04622165f, 0.03181347f, -0.00433379f, 0.03551500f, 0.04163848f, 
    -0.03958182f, 0.02757266f, -0.04522884f, -0.06171323f, 0.02598588f, -0.01699336f, -0.00849062f, 0.01817376f, 
    0.01859524f, -0.01143572f, -0.00010511f, 0.01008658f, -0.00349891f, -0.04014307f, -0.00958485f, -0.05146065f, 
    0.01476924f, -0.06009328f, 0.01446674f, 0.03038975f, -0.00670310f, 0.02238474f, -0.00147800f, -0.06304788f, 
    0.01378630f, -0.03948212f, -0.06131196f, 0.02588484f, -0.01931206f, 0.02770305f, -0.00748794f, 0.02945848f, 
    0.03433776f, 0.02995035f, 0.05482233f, -0.01133390f, -0.03188628f, 0.00147584f, -0.00418210f, 0.04678128f, 
    -0.06083659f, 0.00882356f, -0.06327244f, -0.03652436f, -0.00165844f, -0.02959986f, 0.04837823f, -0.00842437f, 
    -0.05816090f, 0.01389052f, 0.03849623f, -0.00251498f, 0.00475946f, 0.05114787f, -0.05449276f, -0.04977421f, 
    -0.02317189f, -0.01809852f, 0.04745282f, 0.04683359f, -0.01292049f, -0.06840160f, -0.00253788f, 0.00573497f, 
    -0.05925514f, -0.03299530f, 0.02530774f, -0.00756612f, -0.00657405f, 0.02915492f, -0.06255677f, -0.03886649f, 
    -0.06811292f, -0.03905760f, 0.02150988f, -0.04741032f, 0.02479733f, -0.03519018f, 0.05460093f, -0.02029108f, 
    -0.03897645f, -0.03047505f, -0.00941964f, -0.00968523f, 0.02385034f, -0.03209434f, -0.02112431f, -0.00496723f, 
    -0.05973321f, 0.01343003f, -0.02102604f, -0.02793789f, -0.04468095f, 0.04736036f, 0.00299577f, -0.02169747f, 
    -0.04158852f, 0.02263322f, -0.03006490f, -0.04994033f, 0.01755385f, -0.04986808f, 0.02276864f, -0.06091939f, 
    0.04088298f, -0.05920281f, 0.00594996f, 0.03915177f, 0.03120942f, 0.03219726f, -0.00104281f, 0.01763884f, 
    0.01623738f, 0.02002884f, -0.03787956f, 0.03532287f, -0.00136501f, -0.05182119f, -0.03148637f, -0.04467548f, 
    0.04315379f, -0.04076274f, -0.04084934f, 0.03302645f, 0.01409026f, 0.04756413f, 0.04723550f, -0.03649061f, 
    0.05357263f, 0.02421124f, -0.01317442f, -0.00522866f, 0.00626305f, -0.05844741f, -0.04159448f, -0.03968947f, 
    -0.00182674f, -0.03558111f, 0.02744352f, -0.05702319f, 0.01098874f, -0.02125075f, -0.01484981f, -0.03386251f, 
    0.02585554f, 0.03799277f, -0.02606539f, -0.03164313f, -0.04707760f, -0.05076767f, 0.04389668f, 0.03745133f, 
    0.31904465f, 0.18360689f, -0.12196604f, -0.11429410f, 0.01385912f, 0.05179315f, 0.05736820f, 0.09025038f, 
    0.01701787f, 0.24360082f, 0.39969712f, 0.02041003f, 0.05709551f, 0.05561411f, -0.01716114f, 0.05450742f, 
    0.00134214f, -0.09502486f, -0.14163791f, 0.00218763f, -0.03359031f, 0.10428797f, -0.00378614f, 0.05833736f, 
    0.13285662f, 0.03634442f, 0.02870695f, 0.01960974f, -0.02650608f, -0.08309592f, 0.03527541f, 0.02279778f, 
    0.11404059f, 0.10467710f, -0.18269908f, 0.23089494f, -0.18134467f, -0.28707564f, -0.21205708f, 0.13650031f, 
    0.22021756f, -0.01683963f, -0.02361788f, -0.22009313f, -0.36191440f, 0.16796921f, 0.08216349f, 0.05252735f, 
    0.04860670f, 0.15510817f, 0.06364418f, 0.12280958f, 0.02537590f, 0.18591775f, 0.31754211f, 0.23490386f, 
    0.25447366f, 0.02191758f, -0.07374316f, 0.18079954f, -0.02996725f, 0.00617859f, -0.09908009f, 0.11797999f, 
    0.37447470f, 0.03532839f, 0.21172692f, -0.04259036f, 0.02192243f, 0.20057258f, 0.07518727f, -0.00309067f, 
    -0.17367969f, 0.01309336f, 0.02432244f, -0.08316205f, -0.03473714f, -0.00408439f, -0.05191756f, -0.07828256f, 
    -0.17734681f, -0.10827181f, -0.00275044f, 0.04582653f, -0.05354151f, -0.09417807f, -0.32663947f, -0.07133542f, 
    -0.16785118f, -0.41416022f, -0.02612402f, -0.28156668f, 0.14354677f, 0.06302069f, -0.06316016f, 0.17018752f, 
    0.04487795f, 0.00751758f, 0.01606368f, 0.04710726f, 0.02043039f, -0.13809630f, -0.00705290f, 0.04145181f, 
    -0.00852588f, 0.01933864f, -0.00261424f, -0.36249709f, -0.07610447f, -0.02314252f, 0.00728559f, 0.07209133f, 
    0.13497147f, -0.06213971f, 0.10505820f, 0.09206919f, 0.00980592f, -0.01126091f, 0.16133402f, -0.23333895f, 
    0.05581880f, -0.11171384f, 0.21051538f, 0.08348329f, -0.16426347f, 0.04970086f, 0.51111919f, -0.08662681f, 
    -0.29520464f, 0.09533380f, 0.03168895f, 0.01117424f, 0.11451492f, 0.09814255f, -0.10538359f, 0.09540044f, 
    -0.06350029f, -0.08268043f, -0.08431438f, 0.15578327f, -0.17943415f, -0.06960388f, 0.02159712f, 0.07854749f, 
    0.28962696f, -0.30631125f, -0.37360057f, 0.11211433f, -0.04568459f, -0.14821868f, -0.03649175f, -0.31032440f, 
    -0.07488997f, 0.34596413f, -0.04891277f, -0.07429163f, -0.17649965f, -0.02165354f, 0.09373822f, -0.04045661f, 
    -0.00474932f, -0.24885382f, 0.00931025f, -0.17094432f, 0.04290020f, 0.01278349f, -0.03743033f, 0.22956420f, 
    -0.05303887f, 0.00594096f, 0.27524042f, -0.22355181f, 0.14015819f, 0.01726783f, 0.13468151f, -0.02547985f, 
    0.09694154f, 0.02484282f, 0.10389552f, -0.12688838f, -0.21387658f, 0.02499631f, -0.08498190f, -0.08466003f, 
    -0.22415540f, -0.34346083f, -0.02512160f, 0.01397759f, -0.27667838f, 0.14451736f, -0.34881613f, -0.14805534f, 
    -0.08943395f, 0.17724448f, 0.15552691f, -0.08382574f, 0.00959976f, 0.06411551f, 0.03415753f, -0.22093000f, 
    0.07053005f, 0.14409594f, -0.14812960f, -0.01744080f, -0.03940127f, -0.04887033f, 0.02492884f, 0.08380291f, 
    -0.08154792f, -0.05872315f, 0.03463816f, 0.01203552f, 0.23309124f, 0.05993880f, -0.17764653f, -0.00123997f, 
    -0.02111267f, -0.11622258f, 0.05160334f, 0.03253435f, 0.15932901f, 0.11613836f, -0.06882764f, -0.00023442f, 
    0.06583694f, 0.07819693f, -0.17830771f, -0.26314738f, 0.09048468f, 0.04162936f, -0.02882885f, -0.25949639f, 
    -0.00664157f, -0.11601385f, 0.06317654f, 0.19869013f, -0.17866050f, 0.16078863f, 0.00802026f, 0.10655665f, 
    -0.12783314f, -0.11576828f, -0.13949047f, -0.35305625f, 0.05813813f, 0.32956120f, 0.14000614f, 0.09839075f, 
    0.09792193f, -0.03797987f, 0.13869900f, 0.14099693f, 0.03358057f, 0.15320595f, 0.16642509f, 0.01326262f, 
    0.03472269f, 0.08699222f, 0.03351823f, 0.09895048f, 0.25757658f, 0.12742537f, -0.14733803f, 0.05805573f, 
    0.04592702f, -0.13576011f, 0.07417536f, -0.02073526f, -0.02203512f, 0.19687712f, -0.23568872f, 0.20080394f, 
    0.13874288f, 0.06655724f, 0.12585106f, -0.05950695f, 0.07996540f, 0.08541492f, -0.06217403f, 0.06397825f, 
    0.20507304f, 0.29354680f, 0.15610416f, 0.10711227f, -0.05335055f, -0.06264377f, 0.04888510f, -0.13799594f, 
    -0.14501448f, -0.20713964f, -0.09465709f, 0.01833412f, 0.05305202f, -0.08123259f, 0.05226656f, -0.00459198f, 
    -0.08952698f, 0.50183022f, -0.13935319f, 0.09833712f, 0.07972173f, 0.04447079f, -0.01560083f, 0.08865455f, 
    -0.00763373f, 0.03916086f, -0.13272186f, 0.11034305f, -0.04219243f, -0.17834026f, 0.13268942f, 0.16264232f, 
    -0.21263729f, -0.01188998f, -0.07861857f, 0.37807247f, -0.02808904f, 0.27554852f, -0.09578529f, 0.02774031f, 
    -0.12203851f, 0.06934601f, -0.02615722f, 0.05906483f, 0.04804002f, 0.39742264f, 0.19346783f, -0.27727753f, 
    -0.27073985f, -0.01588459f, 0.10570500f, 0.02413881f, -0.18973199f, -0.27659893f, -0.15652747f, -0.10017888f, 
    -0.06583924f, -0.10741732f, -0.10294037f, 0.11697768f, 0.02663886f, 0.13615239f, 0.20004158f, -0.27786314f, 
    0.09333507f, 0.02740397f, 0.04804597f, 0.05786334f, -0.01552058f, -0.16266245f, 0.22649817f, 0.28813425f, 
    -0.34494436f, -0.25964200f, -0.13814418f, 0.03591106f, 0.00463151f, -0.02616456f, -0.00155525f, -0.05701079f, 
    0.14072298f, 0.03784306f, -0.01609021f, -0.19514240f, 0.04336074f, -0.05691991f, 0.01798099f, 0.10385346f, 
    -0.01670079f, 0.06666382f, 0.15176521f, -0.02226376f, 0.23924811f, 0.10824992f, 0.06348000f, -0.01278105f, 
    0.04655367f, 0.20789102f, 0.02879748f, -0.18093069f, -0.24504945f, -0.05759164f, 0.01284542f, -0.05381262f, 
    0.20092183f, -0.00823561f, 0.02477006f, 0.30825540f, 0.12568842f, -0.01348776f, -0.03707597f, -0.09773768f, 
    0.16677973f, 0.05917931f, 0.05443347f, -0.10148909f, 0.05146736f, 0.06528084f, -0.27095544f, 0.08536965f, 
    -0.02443684f, -0.05204952f, 0.09203477f, 0.10907494f, -0.07657328f, 0.15662579f, 0.13852945f, 0.31480694f, 
    0.06087137f, 0.11512350f, -0.01671012f, -0.00117966f, 0.30643922f, -0.10389412f, -0.58391666f, 0.03413349f, 
    0.13968123f, -0.22554907f, -0.18484361f, 0.29446876f, -0.08106397f, -0.11643109f, 0.11288384f, -0.24589130f, 
    -0.30607757f, 0.10503865f, -0.08374127f, 0.09148123f, 0.00992263f, -0.09291014f, -0.10070449f, -0.07585689f, 
    0.04956119f, 0.17868367f, 0.07948447f, -0.31602284f, 0.33804196f, 0.11621326f, -0.08722262f, 0.07230200f, 
    -0.18428427f, -0.48761234f, -0.01189781f, 0.26522797f, -0.01053655f, 0.17936344f, -0.15071806f, 0.01669874f, 
    -0.20417964f, 0.13421674f, 0.29796365f, -0.38317114f, -0.27590793f, -0.04223042f, -0.04069146f, -0.00977617f, 
    0.06117013f, 0.01540270f, -0.07473546f, 0.33177403f, 0.26580602f, 0.29206827f, -0.14215823f, -0.05411768f, 
    -0.23533744f, -0.01196133f, 0.02322953f, 0.05944103f, 0.17761955f, 0.10335964f, 0.03225802f, 0.04655222f, 
    0.28577235f, 0.02585675f, -0.25516880f, 0.10661641f, -0.09936316f, 0.14492819f, 0.05551102f, -0.28117219f, 
    -0.16011982f, -0.12038384f, -0.17852186f, 0.00147017f, 0.12209725f, -0.15419193f, -0.05072789f, -0.27518696f, 
    -0.09178329f, 0.03936506f, -0.02630903f, 0.05618689f, 0.02704461f, -0.12515095f, -0.05740311f, 0.20366287f, 
    0.03269717f, 0.15424855f, -0.12482941f, -0.03336550f, -0.36239809f, -0.03388728f, 0.00928981f, -0.02072717f, 
    0.12594023f, -0.22263975f, -0.51883030f, -0.12761272f, -0.00370101f, -0.11407733f, 0.02587410f, 0.14060061f, 
    -0.10458236f, -0.32062083f, 0.05044287f, 0.09344233f, -0.07590836f, 0.08912967f, 0.08071700f, -0.00758808f, 
    0.07681575f, 0.22086263f, 0.06788420f, 0.11702045f, 0.09054828f, -0.08001030f, 0.00221576f, -0.01404567f, 
    -0.13497488f, 0.12922627f, 0.06665326f, 0.33974516f, -0.04613196f, 0.00638715f, 0.06399119f, -0.05095445f, 
    -0.09630883f, 0.11258411f, 0.08948095f, 0.16762426f, 0.06554976f, -0.06789659f, 0.03981089f, 0.01904644f, 
    -0.02404571f, 0.01427415f, -0.09585980f, -0.00369396f, -0.03391794f, 0.32455280f, -0.28653732f, -0.17733127f, 
    -0.05858652f, -0.02190327f, -0.13943337f, -0.12175922f, 0.03197990f, 0.22543500f, 0.14368805f, 0.13309214f, 
    -0.06625982f, -0.02922991f, 0.20660961f, 0.15124680f, 0.14311807f, 0.04782454f, 0.09494459f, 0.19722135f, 
    -0.68748581f, 0.22748780f, 0.17043909f, -0.01643923f, 0.11718854f, 0.25205758f, 0.04738421f, 0.02180074f, 
    0.02217296f, -0.03960763f, -0.01455899f, -0.02233554f, -0.03116200f, 0.03308700f, -0.02099803f, -0.06284420f, 
    -0.02836592f, -0.05240831f, 0.01656277f, -0.06257074f, 0.01657205f, -0.05988093f, 0.00856586f, -0.03168394f, 
    -0.04268821f, -0.02612424f, 0.04506568f, -0.05473395f, 0.03033927f, -0.02202989f, 0.04463144f, 0.01759415f, 
    -0.05967259f, 0.02112615f, -0.00789954f, 0.03647249f, -0.03962730f, 0.01538464f, -0.04854111f, 0.05005830f, 
    -0.02502248f, -0.05164677f, 0.04053228f, 0.02939061f, -0.00984772f, 0.02581412f, 0.00475237f, -0.04234137f, 
    -0.01171336f, 0.00176061f, -0.04029887f, 0.01177408f, 0.02143916f, 0.02004905f, 0.01721103f, -0.04733915f, 
    0.00463789f, 0.00913036f, 0.02715628f, 0.03165421f, -0.05952679f, -0.03751969f, 0.00699572f, -0.05263253f, 
    0.04706163f, -0.03221096f, 0.04112310f, -0.05512653f, -0.04329349f, -0.02506023f, -0.00820765f, -0.01406233f, 
    -0.03374967f, 0.01505334f, 0.04978774f, 0.04034421f, 0.04831681f, 0.05417366f, 0.04269335f, 0.00106758f, 
    -0.03809057f, -0.05724022f, 0.00643306f, 0.03297313f, -0.03840142f, -0.01603764f, 0.03112207f, 0.04937140f, 
    -0.05321183f, -0.05058245f, 0.04303309f, 0.01482671f, 0.05247302f, -0.01374113f, -0.03120909f, -0.05832652f, 
    0.00567293f, 0.03338018f, 0.02780328f, -0.05805119f, -0.00327795f, -0.04766021f, -0.00240567f, -0.01196226f, 
    -0.00305354f, 0.00861114f, 0.01386572f, 0.02611174f, 0.03012695f, -0.02167586f, -0.03526293f, 0.02837536f, 
    -0.06264916f, 0.00474695f, -0.00908958f, -0.05300285f, 0.00021860f, 0.03692241f, 0.03010657f, 0.00743171f, 
    -0.02696522f, -0.05736431f, -0.02957586f, -0.00641885f, -0.02979173f, 0.03497859f, -0.00439574f, 0.00096363f, 
    -0.03798219f, -0.02136818f, -0.04547282f, -0.00994312f, -0.03640743f, 0.04851690f, -0.02629955f, -0.00066633f, 
    -0.01424317f, 0.03785423f, -0.02621860f, -0.05196739f, 0.03199185f, 0.04855543f, 0.05032032f, 0.03315990f, 
    0.05130023f, 0.01742662f, -0.03597065f, -0.01535750f, 0.01611379f, 0.01591512f, 0.00627649f, -0.02743787f, 
    0.01101406f, -0.03415093f, 0.05234452f, -0.04561196f, 0.00035260f, -0.01682936f, -0.04161278f, 0.03104109f, 
    -0.04943509f, 0.05011757f, 0.04420936f, 0.00682684f, -0.05852112f, -0.00845464f, 0.02440148f, -0.01870563f, 
    -0.02006821f, 0.01613230f, 0.03302327f, 0.00329677f, -0.04670787f, 0.01825214f, -0.02147627f, -0.05383222f, 
    0.00098568f, 0.00470251f, -0.01661417f, -0.05232937f, -0.01079638f, -0.04174268f, 0.03731275f, 0.04468182f, 
    -0.05489508f, 0.00683367f, 0.00832498f, -0.06379977f, -0.03925519f, 0.00116247f, 0.04066751f, -0.05213280f, 
    -0.01612740f, -0.02925657f, -0.02887999f, -0.04977107f, 0.02512526f, 0.00515711f, -0.03071949f, -0.03707161f, 
    -0.05386877f, -0.00557884f, 0.04968176f, -0.04248201f, -0.04996268f, 0.05275701f, 0.04854801f, -0.03403210f, 
    0.04864157f, 0.02416628f, 0.02802751f, 0.01909967f, 0.01550216f, -0.04448558f, -0.02700067f, -0.02512646f, 
    0.00718024f, -0.02117156f, -0.01843604f, -0.01542022f, 0.01580804f, -0.01990448f, -0.03370142f, -0.05909837f, 
    -0.05267252f, -0.03130280f, -0.05500738f, -0.00010114f, -0.02396765f, 0.01195264f, -0.03475977f, -0.02040246f, 
    -0.02720732f, 0.04169212f, 0.03965535f, -0.01770826f, -0.01012492f, -0.04131269f, -0.04374554f, 0.00376210f, 
    -0.01070879f, 0.00996833f, 0.02309513f, -0.04829283f, -0.03647479f, -0.00806271f, 0.03098732f, 0.01929889f, 
    -0.02796370f, 0.00306164f, -0.01642211f, -0.05954499f, -0.00895390f, -0.00092582f, -0.00690548f, 0.01711128f, 
    -0.03178412f, 0.01624620f, -0.03986125f, -0.04672716f, 0.01222004f, -0.04797671f, 0.00318156f, -0.05751355f, 
    -0.06393231f, -0.01524863f, -0.03524853f, 0.00296584f, -0.04173290f, -0.01985304f, -0.04309329f, -0.05583597f, 
    0.02911589f, -0.05203205f, 0.02210407f, 0.03926117f, -0.04462666f, 0.01176244f, 0.02528129f, -0.05994624f, 
    -0.03416932f, -0.05099364f, -0.04945173f, -0.04186111f, -0.03676529f, 0.03832157f, 0.01229867f, -0.00323629f, 
    0.03193455f, 0.02560662f, 0.03159013f, 0.02419866f, -0.02988607f, 0.01366114f, -0.04581938f, 0.00508571f, 
    0.09260356f, -0.01274907f, 0.08198106f, 0.08769163f, 0.11348907f, -0.07365166f, -0.04240464f, 0.01624139f, 
    -0.12142061f, -0.07679849f, 0.07218075f, 0.12320649f, -0.07444472f, 0.05083880f, 0.01583080f, -0.06493103f, 
    0.05335539f, 0.07711428f, -0.46125695f, -0.68989521f, -0.65906388f, 0.03940224f, -0.00504813f, 0.22738436f, 
    0.15039246f, 0.04038144f, -0.18328202f, 0.39875621f, -0.52072507f, -0.09335279f, -0.13490373f, -0.35669538f, 
    0.14657106f, -0.12590221f, 0.01447914f, -0.08924200f, -0.43511745f, -0.38332921f, 0.10268963f, -0.22386444f, 
    0.02336225f, 0.47080013f, -0.05639408f, -0.10587721f, 0.15686670f, -0.19257641f, -0.10023343f, 0.10054117f, 
    -0.01626518f, -0.07396191f, -0.14248079f, -0.02103246f, 0.02396004f, -0.01007501f, -0.16343288f, -0.16793586f, 
    -0.44405103f, 0.03176595f, -0.14817959f, -0.08703074f, 0.19983931f, -0.00059710f, -0.15899804f, 0.02916899f, 
    0.10241856f, -0.06461987f, -0.02547808f, -0.06478786f, -0.09982812f, -0.12476730f, -0.01465236f, -0.00423305f, 
    0.06329915f, -0.13829656f, -0.32201591f, 0.14306720f, 0.01662328f, 0.09615231f, 0.19737762f, -0.03289469f, 
    -0.10162756f, 0.15890421f, -0.05644538f, -0.04827226f, 0.03757823f, 0.08996759f, -0.00513591f, 0.04675745f, 
    -0.02610137f, 0.11064401f, 0.37994766f, 0.22713929f, 0.32593313f, -0.09727002f, -0.08793757f, 0.02668267f, 
    0.02160612f, 0.03217976f, -0.05075803f, -0.37289539f, -0.43044344f, -0.12741050f, -0.15712003f, -0.01031001f, 
    0.08062439f, -0.01745333f, 0.00014911f, 0.06251369f, -0.06593114f, -0.33524346f, 0.35557809f, -0.08345888f, 
    0.11915363f, -0.04035723f, 0.24720779f, 0.03993317f, 0.08408977f, 0.00940260f, -0.87245768f, -0.10252402f, 
    0.13162348f, 0.17456865f, -0.08443892f, -0.12059160f, 0.18019554f, -0.13246103f, -0.36540458f, 0.04746942f, 
    0.04345538f, -0.16159654f, 0.02849753f, -0.16384692f, 0.03519772f, -0.00848059f, -0.05442790f, -0.23984745f, 
    0.04990072f, -0.10134867f, -0.00231082f, -0.06233125f, 0.12709112f, 0.05549648f, 0.10043070f, -0.09403641f, 
    0.08755580f, -0.01633628f, -0.43612549f, -0.13537697f, -0.18390127f, -0.04382481f, -0.14561012f, 0.15682301f, 
    0.08025458f, -0.66758829f, -0.77662063f, -0.72855520f, 0.17401840f, -0.02253138f, -0.09052038f, -0.11838774f, 
    -0.01581165f, 0.00532927f, -0.15124770f, 0.31152996f, 0.15595646f, -0.24345309f, 0.04108414f, 0.14058357f, 
    0.15655024f, -0.21105298f, 0.01377005f, 0.61721087f, 0.05564186f, -0.65641057f, -0.04205733f, -0.18179460f, 
    0.06630211f, 0.07159964f, 0.12545930f, -0.06276625f, -0.03996246f, -0.04358893f, -0.86980635f, 0.03341867f, 
    0.07786707f, 0.12637192f, 0.15929806f, -0.16301933f, 0.01944893f, 0.36564341f, -0.12045817f, 0.26512480f, 
    -0.08133585f, -0.01988003f, 0.15625325f, 0.04213363f, 0.16054356f, 0.20999622f, 0.02437488f, 0.19397500f, 
    0.24839069f, -0.00015831f, 0.09226961f, -0.01986580f, -0.02689223f, -0.01354534f, 0.02189753f, -0.09937371f, 
    -0.15748054f, -0.00360659f, -0.13921119f, -0.14529829f, 0.08476941f, 0.09401737f, 0.13932107f, 0.02185897f, 
    0.38787767f, -0.32973060f, 0.12323503f, -0.10218711f, 0.04874437f, 0.21312369f, -0.01078723f, 0.05308315f, 
    0.19337913f, -0.00838626f, 0.28290710f, 0.29472059f, -0.16259465f, 0.13596906f, -0.08999944f, 0.04378350f, 
    0.13420692f, 0.03484704f, -0.09826750f, -0.39151815f, -0.83667022f, 0.07944562f, 0.10273395f, 0.06187548f, 
    0.19546455f, -0.07379096f, 0.03274190f, 0.20018496f, -0.13278431f, 0.16841882f, 0.05283167f, 0.05746156f, 
    -0.08909431f, 0.14726336f, -0.06670459f, 0.14668280f, 0.20031063f, -0.14598371f, 0.26356688f, 0.15688963f, 
    -0.02866778f, -0.09519797f, 0.13207774f, -0.14268953f, 0.10371292f, 0.05915877f, 0.14910167f, 0.21045382f, 
    -0.05890486f, 0.09736618f, 0.07619293f, 0.07470042f, 0.07092366f, 0.16653469f, -0.14619623f, 0.38917056f, 
    0.02198812f, 0.00108916f, -0.07968334f, 0.15043348f, 0.09671795f, 0.09979386f, -0.10229783f, 0.54439992f, 
    -0.11893075f, 0.11033852f, 0.07123670f, -0.00299127f, -0.06813198f, 0.04750156f, 0.11304101f, 0.04993763f, 
    0.16780734f, -0.22806160f, 0.01178811f, 0.09346972f, 0.12649237f, 0.06064788f, 0.05214740f, 0.12464988f, 
    0.03428420f, 0.17796180f, 0.06237432f, -0.19087331f, 0.21686608f, 0.09751453f, 0.15586917f, 0.06814355f, 
    0.04328699f, 0.19665390f, 0.02100591f, 0.22575001f, -0.51202840f, -0.07456291f, -0.04531140f, -0.01376000f, 
    -0.03706428f, 0.09166364f, -0.09007505f, -0.04379675f, -0.04088275f, -0.05272014f, 0.30374846f, 0.01798011f, 
    -0.13117670f, 0.10569492f, -0.04557971f, 0.26240948f, -0.26646832f, -0.36214074f, -0.19146226f, 0.08995234f, 
    -0.13820930f, -0.19168891f, 0.33110309f, -0.16278575f, -0.07063188f, -0.05341880f, 0.27986458f, 0.21026376f, 
    0.06779943f, 0.10645608f, 0.17572694f, 0.20130263f, 0.09431252f, 0.08664238f, 0.03630607f, -0.06639488f, 
    0.18205261f, 0.10250322f, 0.11384781f, -0.03141106f, 0.02179688f, -0.14329663f, 0.02873056f, 0.53233451f, 
    0.07588618f, -0.07741233f, 0.04297470f, -0.05887541f, 0.08610813f, 0.05105365f, 0.03799627f, -0.05033894f, 
    0.04945200f, -0.06920014f, -0.34881175f, -0.20075069f, 0.09486779f, 0.16606456f, 0.11588871f, -0.06277876f, 
    -0.07587374f, 0.24837595f, 0.03023405f, 0.02606768f, -0.12252049f, -0.00868690f, -0.02056405f, -0.12128638f, 
    -0.08147564f, -0.16737597f, -0.06751577f, 0.02913210f, 0.31408086f, 0.07725510f, 0.01187948f, 0.02933076f, 
    0.16383243f, -0.11370283f, -0.09259704f, -0.06240083f, 0.19311023f, -0.34829307f, 0.10170105f, -0.04270507f, 
    -0.03187418f, 0.21900162f, -0.02990475f, 0.04699953f, -0.21081346f, -0.36539260f, -0.78320998f, -0.02909590f, 
    -0.04435190f, 0.15634759f, 0.04285957f, 0.15499972f, 0.08454797f, 0.01679554f, -0.20880570f, 0.10093212f, 
    0.12689526f, -0.09772714f, 0.03434639f, 0.06812873f, -0.23777106f, 0.00037446f, 0.24561888f, -0.13233069f, 
    0.04459398f, 0.24437931f, -0.21772820f, -0.14685114f, -0.21535429f, 0.07377430f, 0.15956473f, -0.03265283f, 
    0.34759229f, -0.38926542f, 0.02719383f, -0.11423218f, 0.29497433f, 0.08398577f, -0.12657222f, 0.21423213f, 
    -0.13603002f, -0.19649132f, -0.09915434f, 0.16712801f, -0.16437981f, -0.19944069f, 0.21903190f, 0.12017702f, 
    0.07914502f, -0.19409488f, -0.33447775f, 0.05534730f, -0.15491137f, 0.09579487f, 0.07139863f, 0.14568621f, 
    0.05556384f, -0.06753201f, -0.60060310f, 0.01683826f, -0.17487830f, -0.02715104f, -0.10783077f, 0.26611102f, 
    0.13179474f, -0.15843125f, -0.07180256f, -0.23656642f, -0.19955480f, -0.27574122f, -0.00759312f, -0.04788531f, 
    0.07630891f, 0.06783674f, -0.10798011f, 0.22840464f, 0.41446501f, 0.06654793f, -0.63467455f, 0.01275792f, 
    -0.10344224f, 0.06932601f, 0.10549485f, 0.20842981f, -0.13718803f, -0.25138518f, -0.19991413f, 0.10787057f, 
    -0.04373561f, 0.04778362f, 0.14928924f, 0.07169682f, -0.00564920f, -0.12408756f, 0.30653480f, 0.21196231f, 
    0.27527040f, 0.02686138f, 0.03810132f, 0.07212471f, 0.04267909f, -0.04780136f, -0.03241432f, 0.11315504f, 
    -0.08371375f, -0.29425907f, -0.04453947f, -0.09568110f, 0.02971413f, 0.05812591f, -0.12080274f, 0.23280995f, 
    -0.42506117f, -0.24788129f, -0.26088628f, -0.03090847f, 0.19928348f, 0.05901567f, 0.04828472f, -0.06167857f, 
    -0.02205280f, 0.20518586f, 0.02004489f, 0.43525907f, 0.04303357f, -0.01317867f, 0.01507339f, 0.07807832f, 
    -0.02434831f, -0.14251833f, 0.03200677f, -0.06887045f, -0.25585747f, 0.05899365f, 0.03144110f, 0.15636320f, 
    0.02234703f, 0.01244416f, 0.16223323f, -0.01039598f, -0.00139718f, -0.26563063f, -0.02435931f, 0.08730908f, 
    0.07917939f, 0.05366820f, 0.18316875f, 0.06791540f, -0.10246247f, 0.09801153f, 0.36850634f, 0.26227501f, 
    0.13351431f, 0.13864374f, 0.06014385f, -0.13312094f, 0.09647400f, -0.15391198f, 0.13771330f, 0.42040667f, 
    -0.03034448f, -0.10237322f, 0.21232718f, -0.06376699f, -0.08229740f, 0.02182050f, 0.42582250f, 0.01309435f, 
    -0.38969603f, 0.20842198f, -0.07182412f, -0.09117915f, 0.04158889f, 0.13211532f, 0.14489314f, 0.14271896f, 
    0.48194662f, 0.23144501f, -0.25021759f, 0.19602801f, -0.16475986f, 0.09748928f, -0.16424115f, -0.23422208f, 
    0.27475396f, 0.02648464f, -0.00680335f, 0.01844181f, 0.05601474f, -0.01586853f, 0.11938335f, 0.01894920f, 
    0.01658846f, 0.26570013f, -0.01371348f, 0.06320539f, 0.09231115f, 0.05653321f, -0.13902621f, 0.16931641f, 
    0.10935397f, 0.15589380f, 0.04923005f, 0.02525031f, -0.00693097f, 0.06452987f, 0.01205047f, 0.21862824f, 
    0.17053084f, 0.12823236f, -0.08957718f, 0.26417297f, 0.01045454f, -0.01392970f, 0.20429535f, -0.06437235f, 
    0.15144163f, 0.10752320f, -0.00755647f, 0.06641999f, 0.00308291f, 0.11810564f, -0.01310687f, 0.07218065f, 
    0.07021859f, -0.07234254f, 0.26614007f, -0.15317450f, -0.19479036f, -0.10343910f, -0.07047713f, 0.11878978f, 
    0.08674033f, -0.06242299f, 0.12630489f, 0.10049732f, 0.24485651f, -0.07880087f, 0.35147220f, -0.02479382f, 
    -0.25031310f, -0.03530704f, -0.03325200f, 0.14822668f, 0.00939736f, 0.09455068f, 0.06245643f, 0.10621375f, 
    0.07934956f, -0.50337422f, -0.04952162f, -0.01113491f, 0.04170608f, -0.02349575f, -0.28773680f, -0.11898535f, 
    0.05301356f, -0.02654724f, 0.08858579f, 0.08550178f, -0.12241071f, 0.09422209f, 0.13913649f, 0.12673938f, 
    -0.05811790f, -0.08322615f, 0.03605163f, -0.19819055f, 0.17464991f, 0.07300985f, 0.20344411f, 0.07166474f, 
    -0.33775941f, 0.00473184f, -0.18707368f, 0.10747055f, 0.08428867f, 0.06360611f, 0.01296574f, -0.06748602f, 
    0.04154016f, 0.03550019f, -0.06236526f, 0.18437748f, 0.00881958f, 0.03579099f, 0.00065504f, -0.08196288f, 
    0.15155481f, 0.20212884f, -0.00425437f, 0.02450965f, -0.39576289f, 0.02724997f, -0.22585535f, -0.03303120f, 
    -0.01405081f, -0.02056796f, 0.05731455f, 0.00019069f, -0.08984320f, 0.15487349f, -0.00683191f, 0.04313082f, 
    0.02999113f, -0.06772819f, -0.04970809f, 0.05111060f, 0.00125644f, -0.00725528f, -0.38273293f, -0.02429013f, 
    0.28054735f, -0.11476851f, 0.21886708f, -0.18323424f, -0.18942693f, 0.04918900f, 0.04663648f, -0.19180919f, 
    -0.17536825f, -0.40893248f, 0.09930808f, 0.08348271f, 0.02836827f, -0.07568416f, 0.17947328f, 0.01517717f, 
    -0.19242014f, -0.25718328f, 0.09640203f, 0.08759258f, 0.07907980f, 0.13986711f, 0.04972789f, 0.06760135f, 
    -0.21094650f, 0.26194191f, -0.25662994f, 0.15647931f, 0.07125356f, 0.17712194f, 0.01318527f, 0.02629733f, 
    0.01775843f, 0.15483768f, -0.24075922f, -0.11042934f, 0.21613282f, -0.04345892f, -0.06744508f, -0.15200545f, 
    0.11193348f, 0.00550495f, 0.07064109f, 0.12408602f, 0.17144723f, 0.12573397f, -0.04133513f, 0.01463376f, 
    -0.01600070f, -0.09499109f, -0.00043304f, 0.04899519f, 0.14899443f, 0.09368107f, -0.17971423f, 0.17897421f, 
    -0.22788507f, 0.36831263f, 0.00041951f, -0.08341880f, -0.22238925f, -0.00426649f, 0.21633948f, -0.05109971f, 
    -0.24503644f, 0.02937557f, -0.14587571f, -0.00153624f, -0.12672223f, 0.05155922f, -0.05602748f, -0.11855773f, 
    -0.67333704f, 0.02678189f, 0.04238518f, -0.11675040f, 0.10813260f, -0.07045490f, -0.03407794f, -0.01936391f, 
    0.03456105f, 0.07126717f, -0.06270041f, -0.14092675f, -0.08807655f, 0.00264035f, -0.23024480f, 0.10324564f, 
    -0.26847276f, 0.01858437f, -0.14949830f, -0.08214725f, -0.17992222f, -0.08295069f, 0.05482545f, -0.01209672f, 
    0.00512830f, -0.17474626f, -0.16035910f, -0.01544926f, 0.02942416f, -0.14371647f, 0.02915356f, -0.08209386f, 
    -0.10823192f, -0.13463724f, 0.09199060f, 0.08331285f, 0.08220469f, -0.04184979f, 0.06662040f, -0.09086026f, 
    0.05686097f, 0.00041956f, -0.00613872f, 0.07773599f, 0.09827115f, 0.12502670f, -0.05459324f, 0.05683993f, 
    -0.02604178f, 0.01573976f, -0.09411264f, 0.24162102f, 0.08716519f, 0.02243556f, 0.07400711f, 0.11680482f, 
    -0.02034760f, 0.13020054f, -0.05154754f, 0.11523222f, 0.06698018f, -0.16231753f, -0.23320706f, -0.51508695f, 
    0.01065313f, -0.05822713f, -0.19605048f, -0.10240084f, 0.05400523f, 0.07346473f, 0.02772946f, 0.12276608f, 
    -0.31322184f, -0.14749314f, 0.11802870f, 0.01922129f, 0.17648254f, -0.09733614f, -0.00573872f, 0.04919087f, 
    0.24622311f, -0.06067266f, -0.09375979f, 0.11955958f, -0.03273884f, 0.16430378f, 0.07688238f, 0.07193692f, 
    0.01753038f, -0.05836402f, 0.05152892f, -0.01109643f, 0.02939752f, -0.05301426f, -0.05511265f, 0.00164154f, 
    0.01272039f, -0.00505657f, 0.01539711f, -0.04955052f, 0.03594768f, 0.03014741f, -0.06578386f, -0.02232254f, 
    0.04404140f, -0.01676069f, 0.01606628f, -0.00059327f, -0.00179348f, -0.00131742f, -0.02453114f, -0.02031025f, 
    0.04210341f, -0.06396987f, 0.02101039f, -0.00151656f, -0.02099568f, -0.00847200f, -0.02676143f, 0.02166215f, 
    -0.03438176f, 0.02183783f, -0.01377368f, -0.00219949f, -0.05574524f, -0.05374075f, -0.01440509f, 0.05017862f, 
    -0.05361948f, 0.02558560f, 0.02532501f, -0.01278645f, 0.01041674f, -0.00758501f, -0.00370057f, 0.01520660f, 
    -0.05231546f, -0.03826263f, 0.01016875f, 0.00353057f, -0.03177150f, -0.05138238f, 0.02477820f, -0.03487541f, 
    0.04456433f, -0.04807711f, -0.03788995f, -0.00637414f, -0.04174066f, -0.00847418f, -0.00688290f, 0.01755369f, 
    0.01561364f, 0.01559794f, 0.02089823f, -0.06328126f, 0.03810852f, 0.04536145f, 0.01257573f, -0.04928080f, 
    -0.04419684f, 0.03180950f, -0.05152314f, 0.04460094f, -0.01269608f, -0.05498836f, -0.06230094f, 0.00516354f, 
    -0.05031988f, -0.03649818f, -0.04054701f, -0.02452027f, -0.01470447f, 0.01240816f, 0.03693059f, 0.03157684f, 
    -0.04014566f, -0.06651959f, -0.06462079f, -0.03715857f, -0.03019589f, -0.00194994f, -0.05157802f, -0.05737391f, 
    0.03228661f, -0.01338269f, 0.03236347f, -0.04502949f, 0.00608807f, 0.04372173f, -0.00588331f, 0.05263854f, 
    -0.02869179f, -0.04675282f, -0.00565583f, -0.03064063f, -0.02742114f, -0.06109658f, 0.03882395f, -0.02275856f, 
    -0.00677225f, -0.00937817f, -0.03039612f, 0.02704926f, 0.01705063f, 0.02746615f, 0.04500091f, 0.01165291f, 
    -0.04923511f, 0.00470303f, 0.01864672f, -0.02749515f, -0.04195127f, -0.04738250f, -0.05263654f, 0.00201418f, 
    -0.02600737f, -0.02951883f, 0.03522667f, 0.03351492f, -0.06783208f, 0.01401508f, 0.00589887f, 0.04822104f, 
    -0.06018907f, -0.01297176f, 0.00092688f, -0.06376345f, 0.00280981f, -0.05615192f, 0.02270378f, -0.06468780f, 
    0.01992881f, -0.03669089f, -0.02412837f, -0.03912089f, 0.03020302f, 0.04638171f, -0.05418776f, -0.03225024f, 
    -0.01250051f, -0.04053424f, -0.03161684f, 0.01258696f, -0.00962482f, 0.03205366f, 0.01589037f, 0.04886778f, 
    -0.05823434f, 0.03638182f, -0.03487460f, -0.00317562f, -0.04560174f, 0.00324115f, -0.00765595f, 0.03704731f, 
    0.01455934f, -0.02159449f, -0.06160624f, 0.04440856f, 0.01740298f, 0.01979578f, -0.02792352f, -0.00982403f, 
    0.03482156f, 0.02286919f, -0.06511551f, 0.04666783f, -0.05102983f, -0.05930205f, -0.02618633f, -0.06737839f, 
    -0.05792814f, -0.01535927f, -0.01342230f, -0.02128064f, 0.04291474f, -0.01566435f, -0.01187725f, -0.01334817f, 
    0.03615169f, -0.04388585f, -0.05985282f, -0.05524534f, 0.03585109f, -0.04201917f, -0.00778074f, -0.00553654f, 
    -0.06240370f, 0.03763039f, 0.02504036f, 0.01880875f, -0.00808152f, 0.03317671f, 0.01661740f, 0.01000875f, 
    0.00019751f, -0.03586338f, 0.00626928f, 0.05048330f, -0.00749826f, -0.05300335f, -0.00203757f, -0.01248990f, 
    0.02356166f, 0.00834544f, -0.00338505f, -0.04370571f, -0.06587368f, -0.05034072f, -0.04388233f, 0.01017249f, 
    0.03234727f, -0.04817747f, -0.05992537f, -0.01359088f, -0.04934648f, -0.05276796f, -0.06583744f, 0.03006881f, 
    0.01586174f, -0.03173324f, -0.04934534f, -0.03587181f, 0.03158268f, -0.03986648f, -0.03174621f, -0.01179163f, 
    0.04185743f, -0.02992490f, -0.02172160f, -0.01383043f, -0.01170593f, -0.03377781f, 0.01133894f, 0.02033454f, 
    0.02322037f, -0.02373375f, -0.02397906f, 0.01605661f, 0.03044463f, -0.05018701f, 0.01647377f, 0.04029443f, 
    0.01381143f, 0.04096913f, 0.02218495f, -0.03591842f, -0.06263223f, -0.06197405f, 0.04672290f, 0.04508126f, 
    0.02811408f, 0.00112191f, -0.00452252f, -0.04485022f, 0.02413427f, 0.00966346f, 0.02540106f, 0.02783910f, 
    0.00440222f, 0.04297521f, 0.01308978f, 0.03453023f, 0.04234464f, -0.01215153f, -0.06478514f, -0.02592931f, 
    0.00060815f, 0.02714125f, -0.06707014f, -0.02415019f, 0.03867805f, -0.06810834f, 0.04945719f, -0.06131840f, 
    -0.01087251f, -0.00712461f, 0.00395268f, -0.00582451f, 0.04476468f, 0.02614432f, 0.01479784f, 0.03670734f, 
    -0.01299880f, -0.00792786f, 0.01089845f, 0.02800410f, 0.02984003f, -0.00949807f, -0.03215464f, -0.05311922f, 
    0.00119538f, -0.05466055f, -0.05816178f, 0.04625122f, -0.05427969f, 0.03822552f, 0.01682292f, -0.06161558f, 
    -0.01369125f, 0.03158977f, -0.02654278f, 0.03264912f, -0.06515004f, -0.04342357f, -0.02605514f, -0.00250291f, 
    0.00188222f, -0.03889867f, 0.02612341f, 0.02486620f, -0.00023140f, -0.03100731f, 0.00516585f, 0.02990533f, 
    0.00673194f, -0.04138253f, -0.03741661f, -0.02777003f, 0.02036208f, -0.06166887f, -0.04418717f, -0.02346439f, 
    0.02217859f, -0.00096754f, -0.02255857f, 0.01877151f, -0.03986370f, -0.03723215f, 0.03983627f, -0.04727542f, 
    -0.03326844f, -0.03315270f, 0.03547529f, -0.05198386f, 0.01563288f, 0.03080866f, 0.03471041f, -0.06408095f, 
    0.03305590f, 0.00854725f, -0.02777080f, 0.01714100f, -0.06204457f, -0.00760817f, -0.00362885f, 0.01919042f, 
    0.00990243f, 0.01855016f, -0.06750484f, -0.01979155f, -0.06069616f, -0.06240531f, 0.00248618f, 0.00557793f, 
    -0.03511812f, 0.03868020f, 0.00369003f, 0.00166399f, -0.03103011f, 0.04648994f, 0.02275687f, -0.04438821f, 
    -0.06280372f, -0.03984069f, 0.02196904f, -0.03252249f, -0.00522173f, 0.00479508f, -0.01274266f, 0.02899171f, 
    -0.01136098f, 0.01983780f, 0.02883039f, 0.03353228f, -0.00974798f, -0.04406222f, -0.03270429f, 0.01232063f, 
    -0.02702884f, -0.01090509f, -0.00988205f, -0.05698046f, 0.02695759f, -0.06885003f, 0.03106745f, 0.02838752f, 
    -0.03874002f, 0.02938808f, -0.02234884f, 0.03216958f, -0.03523401f, 0.01403841f, 0.01319981f, 0.01957399f, 
    0.04216027f, 0.00091160f, -0.05731506f, -0.05206912f, -0.03597616f, 0.00316960f, 0.04155975f, 0.05772558f, 
    -0.00277418f, 0.03358437f, -0.05697791f, -0.01075037f, 0.00672243f, -0.06180296f, -0.00224279f, 0.03877007f, 
    -0.03209571f, 0.00626445f, -0.01055163f, 0.02487789f, 0.03348081f, 0.04165192f, -0.03597888f, -0.04862535f, 
    -0.04945910f, -0.04355452f, 0.04701386f, 0.03223561f, -0.03414064f, -0.03442501f, -0.03038689f, 0.01070875f, 
    0.01967343f, -0.05025865f, 0.00341170f, 0.03717960f, -0.04333279f, 0.00768525f, 0.04621275f, 0.02021597f, 
    0.03339940f, 0.02399731f, -0.00749890f, 0.00371773f, -0.02136998f, -0.04936968f, -0.01844255f, -0.05613181f, 
    -0.05833910f, -0.00762998f, -0.05645931f, -0.05900187f, 0.04078791f, -0.04439253f, 0.00640874f, -0.01075026f, 
    0.02514216f, 0.00184768f, -0.04765518f, 0.00059636f, 0.01728799f, -0.03685447f, -0.02754350f, -0.02322302f, 
    -0.00352376f, -0.01507061f, 0.01980900f, 0.02605042f, -0.00305931f, -0.00796159f, 0.00592883f, 0.01726329f, 
    0.00326645f, -0.03364079f, -0.03948312f, -0.06349035f, -0.03989499f, 0.03459021f, 0.01195572f, 0.02280241f, 
    -0.03092908f, 0.00082259f, 0.02274846f, -0.02025840f, -0.06687114f, -0.01724922f, 0.04037806f, 0.01583768f, 
    0.01670746f, -0.03579675f, -0.05592477f, -0.00158015f, -0.05905323f, 0.00985836f, -0.05591699f, 0.01668251f, 
    -0.06260749f, 0.02762109f, 0.01366296f, -0.05507510f, -0.00765898f, 0.01522470f, -0.03303430f, -0.00458462f, 
    0.03249394f, 0.05406636f, -0.01029033f, -0.06518159f, -0.06063581f, -0.03721074f, -0.05923465f, -0.04743488f, 
    -0.05509535f, -0.03397542f, 0.00366097f, 0.01208059f, -0.04145197f, 0.00146879f, -0.00841484f, 0.03550036f, 
    -0.02394611f, -0.05329760f, -0.03292476f, 0.02431512f, 0.00587932f, -0.06488980f, 0.01770621f, -0.04269069f, 
    0.03926045f, -0.01957577f, 0.02830338f, -0.01055454f, -0.06193723f, -0.04262238f, -0.04979143f, -0.05408591f, 
    -0.05294603f, -0.06547661f, 0.02485327f, 0.01408508f, 0.01255463f, 0.02684916f, -0.04284894f, 0.01513135f, 
    -0.05860570f, -0.01406383f, 0.00370471f, -0.03130123f, -0.01924416f, -0.03818483f, 0.00492307f, 0.00731343f, 
    -0.02571421f, 0.00003026f, 0.03985625f, -0.02458575f, -0.02675339f, 0.03468014f, 0.01614062f, 0.00243509f, 
    -0.03210964f, 0.03891020f, 0.00306716f, -0.01281675f, -0.03365447f, 0.01266265f, 0.02901966f, -0.00357899f, 
    0.01022943f, 0.00447969f, -0.02515315f, -0.04437159f, -0.04480316f, -0.05213043f, 0.02546285f, -0.01716241f, 
    -0.05762040f, -0.04727829f, 0.05576365f, -0.03818440f, -0.03037149f, 0.00360209f, 0.03495834f, 0.04252499f, 
    0.04171542f, -0.03096992f, -0.04494369f, 0.03123448f, -0.00388999f, 0.03767316f, -0.04143040f, -0.00840892f, 
    0.03676321f, -0.00704159f, 0.00700169f, -0.00286726f, -0.01650386f, 0.03150769f, -0.01714892f, -0.03194389f, 
    -0.01465755f, 0.05676861f, -0.03279018f, -0.00994155f, -0.03707922f, 0.04720979f, -0.04425786f, -0.02002386f, 
    -0.01700856f, -0.02332335f, 0.01690288f, 0.02907220f, -0.03053137f, -0.04797230f, 0.03563349f, 0.04001159f, 
    -0.03069313f, 0.02363349f, -0.02627886f, -0.03191352f, 0.00563066f, 0.05104369f, -0.03798838f, -0.03566235f, 
    0.04971875f, -0.00723869f, -0.02890840f, 0.05585786f, -0.05663656f, -0.05249147f, 0.05715909f, -0.05698574f, 
    0.00141125f, -0.01875109f, -0.04670316f, 0.00148138f, 0.04356217f, -0.01952645f, 0.00017732f, -0.02178794f, 
    0.02388764f, -0.04307121f, -0.05202255f, -0.02287448f, -0.00497392f, -0.05633860f, -0.02527171f, 0.03655892f, 
    -0.02255073f, -0.01974647f, 0.04322292f, -0.02398751f, -0.01613199f, -0.02934037f, 0.05868036f, -0.01669300f, 
    -0.03502921f, 0.05213903f, 0.00543970f, -0.00782201f, -0.04158279f, 0.05553170f, -0.01881756f, -0.03249886f, 
    -0.02968828f, -0.01117155f, -0.03891462f, 0.01606420f, -0.02179041f, -0.04007787f, 0.04511845f, 0.01323379f, 
    -0.00027293f, 0.05551405f, -0.02432415f, -0.04288736f, 0.05612841f, -0.01860760f, 0.01912636f, 0.04461178f, 
    -0.01781738f, 0.03443943f, 0.02412184f, -0.04870182f, -0.02369769f, -0.03412873f, -0.00992031f, -0.03919807f, 
    0.02358599f, 0.03777766f, -0.05157700f, -0.00170001f, -0.01142496f, 0.02834501f, -0.04384891f, -0.01587260f, 
    -0.02601316f, 0.01211808f, 0.04504304f, 0.00766660f, -0.04058574f, -0.02403148f, 0.01377698f, -0.00667182f, 
    0.01183638f, 0.00526133f, -0.03311903f, 0.00264135f, -0.00498567f, 0.02644692f, -0.01113525f, -0.05233160f, 
    0.01534707f, 0.01538773f, 0.04655885f, -0.04413097f, -0.00228805f, 0.02674223f, -0.04739559f, -0.05600043f, 
    -0.02560699f, 0.04039773f, -0.02748694f, 0.00534263f, -0.02573914f, -0.04638200f, -0.00892453f, -0.02875975f, 
    -0.05870100f, -0.01738402f, 0.00903325f, -0.04961897f, -0.02031712f, 0.03977898f, 0.05326887f, -0.04184322f, 
    0.01909768f, 0.00534749f, -0.03604120f, 0.03735509f, 0.00095382f, -0.00132605f, 0.00210099f, 0.04287019f, 
    0.01314148f, -0.05668654f, 0.04767076f, 0.01148511f, 0.02740123f, 0.01479462f, -0.01528611f, -0.01855002f, 
    0.02743423f, -0.01849616f, -0.03438167f, -0.04382625f, 0.02948150f, -0.03973686f, -0.00460090f, -0.05091502f, 
    0.01915893f, 0.00386556f, 0.02914165f, 0.01678598f, -0.01838459f, -0.04532690f, 0.00645434f, 0.05366462f, 
    0.01349338f, -0.00277193f, 0.04878021f, 0.02633736f, 0.01973064f, -0.02299809f, -0.05840903f, 0.04257549f, 
    0.00213162f, -0.00135561f, -0.05650441f, 0.05803739f, 0.04003720f, -0.02043072f, -0.01583739f, -0.03648237f, 
    -0.00378028f, 0.00750253f, 0.02117250f, -0.00315196f, 0.05093572f, -0.05280149f, 0.01758626f, 0.03433526f, 
    0.00905305f, -0.04891078f, -0.03740518f, -0.00494691f, -0.02882096f, -0.02070996f, -0.00008598f, -0.02654286f, 
    -0.04354357f, 0.02746817f, -0.02211116f, 0.01052547f, -0.05209395f, -0.03173827f, 0.05200167f, -0.04873058f, 
    0.05773487f, 0.01758498f, -0.05097389f, 0.03845304f, -0.02673973f, 0.02136218f, -0.05175375f, 0.03003162f, 
    0.02132893f, 0.03700685f, -0.03843352f, -0.05243240f, -0.02421447f, -0.03747985f, 0.04449124f, 0.02819750f, 
    -0.01416620f, 0.02002041f, -0.02349600f, -0.02380908f, -0.02693052f, -0.04660792f, 0.02320491f, 0.02008606f, 
    -0.01223070f, -0.00375436f, -0.01784619f, -0.04542087f, -0.04485457f, -0.02530619f, 0.00132352f, 0.02543071f, 
    -0.04572682f, 0.04597475f, 0.01466103f, 0.02794843f, 0.00251576f, -0.03718316f, -0.02189389f, -0.05737661f, 
    0.04649474f, 0.04772753f, -0.05287404f, -0.01283966f, -0.01587212f, 0.03013553f, -0.03854026f, 0.02930863f, 
    -0.13826095f, 0.10321170f, 0.14821897f, 0.05669471f, 0.10576390f, 0.01004043f, -0.20925909f, -0.09189270f, 
    -0.02931818f, -0.34036461f, -0.04819848f, 0.03746933f, 0.08835132f, -0.09764197f, 0.12048739f, 0.14506538f, 
    -0.08170564f, -0.09072536f, 0.06240894f, -0.01071402f, -0.00128927f, 0.10533758f, 0.10036296f, -0.20866370f, 
    -0.04934477f, 0.18204159f, 0.02261050f, -0.32998884f, -0.13971466f, 0.00357304f, -0.00862310f, -0.01704616f, 
    0.05115200f, 0.04166862f, 0.08555306f, -0.02880964f, 0.14915822f, 0.00497318f, -0.06059676f, -0.13389160f, 
    0.04464939f, -0.40928954f, 0.05486033f, 0.06737801f, -0.04845083f, 0.23907192f, -0.05324147f, -0.06430608f, 
    0.03458837f, -0.02472026f, 0.03609399f, 0.09638276f, -0.00644396f, 0.07657748f, -0.25057301f, -0.04156218f, 
    -0.06947497f, 0.22568099f, 0.07251211f, 0.01212718f, 0.09132392f, -0.12331069f, -0.00410815f, -0.19484930f, 
    -0.03236137f, 0.47921765f, 0.00735041f, 0.18476912f, 0.17338149f, -0.04064648f, -0.31208897f, -0.18733808f, 
    -0.12229341f, -0.14446880f, -0.11800454f, 0.06170977f, -0.14538477f, -0.02736761f, 0.24721482f, 0.09090306f, 
    0.02068919f, 0.03083442f, 0.06178959f, -0.04235794f, -0.03801912f, 0.03980337f, -0.06651442f, 0.05279495f, 
    0.12259630f, -0.09409269f, 0.16405575f, -0.30972582f, 0.08911176f, -0.08007798f, 0.04139128f, 0.05794810f, 
    0.12175375f, -0.03173327f, -0.01350781f, 0.06177928f, 0.09723279f, 0.12736206f, 0.12322159f, 0.11291859f, 
    -0.03590992f, -0.07378411f, 0.08377185f, 0.04023686f, -0.12094928f, -0.00063111f, -0.12238078f, -0.01597769f, 
    -0.12860918f, 0.02273747f, -0.13468768f, -0.11381769f, -0.30465069f, -0.21356519f, 0.06507830f, -0.03304626f, 
    0.03698193f, -0.02756832f, 0.20483387f, -0.15171762f, 0.04660251f, -0.09704473f, 0.01091836f, -0.02080504f, 
    0.27890053f, 0.17829536f, -0.07818504f, 0.01480066f, 0.20712511f, 0.09485879f, 0.01382553f, 0.03570785f, 
    0.05946426f, 0.56808043f, 0.04888441f, 0.12416320f, 0.04129602f, -0.17869833f, 0.06662561f, 0.18411486f, 
    0.28746060f, 0.26020414f, 0.19936116f, 0.01169544f, 0.14348029f, -0.03793232f, -0.00625028f, 0.23182647f, 
    0.12016614f, -0.15668909f, -0.04202278f, -0.01507559f, 0.06428281f, 0.14434397f, -0.01082043f, 0.08770257f, 
    -0.07187737f, -0.22648306f, 0.00721694f, 0.09286741f, 0.28125867f, -0.03064142f, -0.11748778f, -0.11140629f, 
    0.11350485f, -0.16542971f, 0.07294962f, -0.15032402f, -0.08344916f, -0.05491135f, -0.02500613f, -0.02138267f, 
    0.06634728f, -0.09790810f, 0.00049910f, 0.07346026f, -0.10273398f, -0.06973792f, 0.03146497f, -0.01034162f, 
    0.13071668f, -0.05699871f, -0.02364680f, 0.22656868f, -0.04109442f, 0.03715120f, 0.17070596f, 0.24932460f, 
    -0.13087608f, -0.08489238f, -0.05002283f, 0.13532728f, 0.18335313f, 0.04247094f, 0.08866019f, 0.13103284f, 
    0.34968308f, 0.12636673f, 0.15068442f, 0.10625913f, 0.09503289f, -0.13689761f, -0.04769012f, 0.07753680f, 
    0.07027611f, -0.05977845f, -0.14049873f, 0.12140797f, 0.10294969f, -0.09768485f, -0.13463135f, 0.02242685f, 
    0.09415676f, 0.41529799f, 0.35767290f, -0.07866445f, -0.14145073f, -0.25177589f, 0.04828156f, 0.13066238f, 
    0.16085169f, 0.38852003f, 0.35018623f, 0.43142095f, 0.01858906f, 0.08243192f, 0.09037914f, 0.03004663f, 
    -0.13302965f, 0.04514555f, -0.05017678f, -0.19725753f, -0.09449717f, 0.00408974f, 0.01400553f, 0.10994408f, 
    0.09643915f, -0.05968730f, 0.01443161f, -0.10935682f, 0.02335826f, 0.06334946f, -0.03944807f, -0.02800838f, 
    -0.09208581f, -0.02923560f, -0.11193034f, -0.06571690f, -0.04208778f, -0.05228513f, -0.00914576f, 0.02487615f, 
    0.05897107f, 0.13054405f, 0.14136229f, -0.05553838f, -0.02555799f, 0.15255824f, 0.03750037f, 0.26340085f, 
    0.04443940f, 0.08503722f, 0.01541127f, 0.29510242f, 0.04889015f, -0.15807553f, -0.21129097f, -0.07998054f, 
    0.00161471f, 0.19194633f, -0.08918125f, 0.04063518f, -0.38022381f, 0.26647079f, -0.05868185f, -0.10749806f, 
    0.12626392f, 0.20170966f, -0.00130194f, 0.13921031f, -0.13455401f, 0.03783326f, -0.50808436f, -0.28479457f, 
    -0.42801809f, -0.04391685f, 0.15944020f, 0.02068590f, 0.13764578f, 0.02313986f, 0.06218090f, 0.39561051f, 
    0.08389147f, -0.36467177f, -0.06961293f, 0.20612265f, -0.02538230f, 0.11376957f, -0.04725941f, 0.09816875f, 
    0.02553939f, 0.30098116f, -0.00992996f, -0.08761213f, -0.18125452f, 0.02825690f, -0.08145183f, 0.25261050f, 
    0.12857525f, 0.00783918f, 0.03258029f, -0.14439571f, -0.04571226f, 0.11614248f, 0.04363209f, 0.00967851f, 
    -0.14749038f, 0.10974868f, 0.06804300f, 0.25986469f, 0.23362117f, 0.11936096f, 0.14539421f, -0.16427931f, 
    -0.07420417f, -0.16572255f, 0.05436388f, 0.12959731f, -0.13113925f, 0.46748236f, 0.21161659f, 0.04655860f, 
    0.05572863f, -0.06752814f, -0.00104658f, -0.02376970f, -0.03162498f, 0.26102933f, -0.44901136f, -0.02042569f, 
    -0.03515762f, -0.06777826f, -0.00562404f, -0.10635877f, -0.00372040f, -0.14508444f, -0.23938119f, -0.38092926f, 
    0.04158088f, 0.08074262f, -0.11933775f, 0.04759145f, -0.08770977f, 0.05951482f, -0.14367479f, 0.14775962f, 
    0.03110774f, 0.03003224f, 0.04816386f, 0.06067972f, -0.24903186f, 0.13977483f, 0.26172328f, 0.18627022f, 
    -0.00208543f, -0.51853621f, -0.32350525f, -0.32295072f, 0.02540072f, 0.04074353f, -0.04295071f, 0.01847419f, 
    0.01297250f, 0.11731436f, 0.41076490f, 0.07646531f, 0.24469143f, 0.04779980f, -0.01363327f, 0.19221963f, 
    0.05770800f, 0.01935695f, 0.06850003f, 0.02477695f, 0.02177332f, -0.01507002f, 0.18706918f, 0.07051015f, 
    0.10149060f, -0.00075473f, 0.13534431f, 0.10372945f, 0.23056120f, -0.25167978f, -0.15081976f, 0.09337284f, 
    0.08580468f, 0.00293792f, 0.03792009f, -0.22888368f, -0.00921326f, -0.28770262f, 0.06799524f, 0.23493662f, 
    -0.18540809f, -0.00262032f, -0.00875715f, -0.21558465f, -0.15877074f, 0.09298284f, 0.01267343f, -0.12195256f, 
    0.11454730f, 0.15238674f, 0.01529895f, -0.04263155f, 0.03807263f, 0.03567566f, 0.00605508f, -0.17504795f, 
    0.18971242f, 0.07414174f, -0.16779184f, 0.04490549f, -0.07369780f, 0.08769791f, 0.02089220f, 0.01945726f, 
    0.08352501f, 0.15376678f, 0.01070568f, -0.20037682f, 0.08677185f, 0.03258025f, -0.05504084f, 0.16186310f, 
    0.04275624f, -0.30262750f, 0.10552856f, -0.04890222f, -0.20321070f, 0.09312293f, 0.01393253f, 0.06644159f, 
    0.15940145f, 0.21117204f, 0.36017054f, 0.39432007f, 0.10579345f, -0.08548398f, 0.11069072f, -0.07625450f, 
    -0.06275357f, 0.12755263f, 0.29410681f, 0.01255985f, 0.03232155f, 0.04307581f, -0.01813160f, -0.12281113f, 
    -0.33017606f, -0.00326931f, -0.12298423f, 0.07845009f, -0.45331341f, -0.20380221f, -0.54557598f, -0.01479898f, 
    -0.05410904f, 0.00806150f, 0.03547287f, 0.19109936f, -0.20469834f, 0.43082330f, 0.11800346f, -0.00428339f, 
    0.08787492f, -0.02169823f, -0.03095136f, 0.15545480f, 0.02020592f, -0.04198388f, 0.10478814f, 0.13961022f, 
    0.24637310f, -0.03510057f, 0.08267973f, -0.12806615f, -0.09539817f, 0.10193451f, -0.24732225f, -0.05202392f, 
    0.07476555f, 0.06510152f, 0.04903525f, -0.34081644f, -0.17763995f, -0.04522763f, -0.05105277f, 0.09798247f, 
    0.42259848f, -0.05305529f, -0.24883458f, 0.33300877f, 0.05758514f, 0.09437963f, 0.03817913f, -0.04046785f, 
    0.04941142f, 0.26585492f, 0.15583390f, 0.04713770f, 0.06755409f, -0.05945087f, 0.00048121f, -0.09047844f, 
    0.01353282f, 0.08301178f, 0.10421915f, -0.04920437f, 0.00044555f, -0.03748592f, -0.14926367f, -0.02867704f, 
    0.09547524f, 0.11437795f, -0.01821855f, 0.28861949f, 0.00757795f, 0.04335114f, 0.07789915f, 0.13116665f, 
    -0.08940180f, 0.07562842f, -0.24828716f, -0.11294656f, 0.01245392f, -0.02777941f, -0.05328832f, 0.05745236f, 
    0.04181503f, 0.03154757f, 0.22872740f, -0.24718139f, -0.09319422f, 0.46645218f, 0.29523382f, 0.30971175f, 
    -0.03908686f, 0.06860657f, -0.17048135f, 0.05119565f, 0.14268896f, -0.04142296f, -0.20900701f, -0.10429308f, 
    0.23412699f, 0.13950405f, -0.04549450f, 0.05011576f, -0.08895786f, -0.11253623f, -0.14705907f, 0.26112545f, 
    -0.12199952f, -0.08662882f, -0.04914872f, -0.17789812f, -0.09319500f, 0.02236312f, -0.01647343f, -0.05245490f, 
    -0.04893041f, -0.05821494f, -0.04452726f, -0.00180713f, 0.02988422f, 0.02379316f, 0.02313630f, 0.00059060f, 
    0.02978899f, -0.03286977f, -0.04805240f, -0.05998001f, 0.03519868f, -0.04619815f, -0.02726500f, 0.01942122f, 
    -0.02379057f, -0.01764760f, -0.05605100f, -0.01348271f, 0.01506252f, -0.02396278f, -0.03489044f, -0.06274348f, 
    -0.01432170f, 0.04143390f, 0.03707363f, -0.02695606f, 0.03037959f, -0.03916144f, 0.00675894f, -0.04992431f, 
    0.04007254f, 0.00235302f, -0.04349799f, 0.01036054f, -0.01520839f, -0.04521593f, -0.02666377f, -0.00877937f, 
    0.02968585f, 0.03522287f, 0.04837117f, 0.03174652f, -0.03596025f, -0.00722728f, -0.04573225f, -0.00619217f, 
    -0.00542693f, -0.01307542f, -0.00929857f, -0.06109983f, -0.04332789f, -0.02187372f, 0.03804298f, 0.01412412f, 
    0.04238223f, 0.02237669f, -0.01801557f, -0.00072280f, -0.00322953f, -0.05896178f, -0.05215035f, -0.02145059f, 
    -0.00582218f, 0.03935865f, 0.03789473f, -0.02381475f, -0.00371265f, 0.01683659f, 0.01475961f, -0.02441799f, 
    0.02348473f, 0.03822213f, -0.03798627f, -0.04896501f, -0.02241241f, -0.06517646f, 0.04703594f, 0.05090987f, 
    0.00288908f, 0.02837339f, -0.05177727f, 0.03565286f, -0.02479967f, -0.03560808f, 0.00647608f, 0.03397330f, 
    0.03700171f, -0.01809965f, -0.04850243f, -0.03115075f, -0.02231590f, -0.04964013f, 0.04940169f, 0.01701321f, 
    0.00902817f, -0.00263977f, 0.02409866f, 0.02799226f, 0.04076293f, -0.05374226f, 0.03851865f, -0.00655940f, 
    -0.05425821f, -0.00646808f, -0.00681459f, -0.03744085f, -0.02184076f, -0.02690960f, 0.00610376f, -0.05186014f, 
    -0.01666284f, 0.04383839f, 0.02072359f, 0.03133189f, -0.03992778f, -0.02232110f, -0.02455695f, -0.04529000f, 
    -0.01804818f, 0.00322593f, 0.01603724f, 0.04674802f, -0.04200810f, -0.04277334f, -0.05015166f, -0.02718266f, 
    -0.03024925f, 0.03646234f, 0.03130599f, 0.00697133f, -0.04131503f, -0.06517206f, 0.02492242f, 0.02279786f, 
    0.05006822f, -0.05116550f, 0.02262085f, -0.01665458f, 0.04794263f, -0.04318781f, 0.04024370f, 0.01575074f, 
    0.00311734f, -0.06560417f, 0.03912467f, -0.01629370f, -0.03796215f, -0.02966950f, 0.00371155f, 0.02569125f, 
    -0.04306298f, -0.06187325f, 0.04076691f, -0.01033829f, -0.02787346f, 0.04161863f, -0.00972086f, -0.02135010f, 
    0.03910836f, -0.05006228f, 0.03455786f, 0.04075772f, 0.04896698f, -0.05776243f, 0.03639534f, 0.00981638f, 
    -0.00909284f, -0.02970534f, -0.05195215f, -0.01326033f, 0.04351745f, -0.04802191f, -0.01586472f, 0.04669477f, 
    0.00119402f, -0.02718611f, 0.03100014f, 0.00816228f, -0.05810414f, -0.00972873f, 0.02373133f, 0.04695984f, 
    -0.02828334f, 0.05749803f, -0.05865090f, -0.02067453f, 0.02495648f, -0.06353018f, 0.00779916f, 0.02711310f, 
    -0.04014583f, 0.03257470f, -0.06777039f, 0.04622006f, 0.00919109f, 0.01035130f, -0.02214003f, -0.05756239f, 
    0.03160162f, -0.00682685f, 0.01855544f, 0.01819702f, -0.03709301f, -0.01170478f, 0.02543118f, -0.02442873f, 
    -0.02371013f, 0.01628810f, -0.01879881f, 0.00078051f, -0.00170781f, 0.04027443f, 0.02672422f, -0.05088750f, 
    0.03929951f, -0.04919712f, -0.00346311f, -0.01027566f, -0.04357504f, -0.01107593f, -0.01319153f, 0.00720169f, 
    0.03024213f, -0.05471520f, -0.03933077f, -0.00477462f, -0.05121277f, -0.06017669f, 0.03015556f, 0.01610368f, 
    -0.01387590f, -0.04709652f, 0.01932236f, 0.02325230f, -0.05352300f, 0.03101594f, -0.00709669f, -0.03955391f, 
    0.00188678f, -0.05634859f, 0.00913450f, 0.03945056f, -0.05637116f, -0.00614866f, 0.03742164f, -0.02858926f, 
    0.02814941f, -0.04894203f, -0.06014288f, 0.00547357f, 0.02761540f, 0.01454681f, 0.01471076f, -0.04937482f, 
    -0.05774168f, 0.04502138f, 0.01116121f, -0.01733066f, 0.04105705f, -0.00251879f, 0.05513999f, -0.01554446f, 
    0.00261131f, 0.02599174f, -0.02896976f, 0.04001048f, -0.04227970f, 0.03731854f, 0.01567545f, -0.04257105f, 
    0.00357750f, -0.03123725f, -0.05724166f, -0.01397972f, -0.04621582f, -0.01538745f, 0.01912383f, -0.00231403f, 
    0.01033339f, -0.05712722f, -0.00578353f, -0.05089024f, 0.03936562f, 0.00002156f, 0.02925362f, -0.02337253f, 
    0.10861028f, 0.01673318f, 0.09202269f, 0.05528953f, 0.11870379f, 0.05700498f, 0.20274666f, -0.12689039f, 
    0.01513465f, 0.05576432f, 0.11940696f, -0.00961805f, -0.06559660f, 0.12410694f, 0.12456515f, -0.14864160f, 
    -0.03217240f, -0.03869695f, 0.13997319f, 0.15245578f, 0.32863608f, -0.01245777f, -0.22429079f, 0.01034237f, 
    0.03464383f, -0.09214289f, 0.04002256f, -0.09155964f, -0.01405294f, 0.10474293f, 0.03340256f, 0.19867577f, 
    -0.08327167f, -0.13921118f, -0.24235755f, -0.03003723f, -0.12840113f, 0.06772345f, 0.17466368f, 0.14095199f, 
    -0.15989432f, 0.00196330f, -0.01774702f, 0.13959195f, -0.16599952f, -0.07074498f, -0.20183744f, 0.15346116f, 
    -0.14120330f, -0.18872647f, -0.00611351f, -0.04015838f, -0.11777808f, -0.14747116f, -0.02993372f, -0.06231012f, 
    -0.13074319f, 0.13150927f, -0.09572069f, -0.03999362f, -0.16929661f, -0.25011441f, -0.42745471f, -0.07282409f, 
    0.05528262f, 0.00363846f, 0.00507306f, -0.04601635f, 0.09057663f, 0.08598831f, 0.11754029f, 0.01119956f, 
    0.11473785f, -0.01218845f, 0.19299553f, 0.17124726f, -0.05608831f, 0.00979394f, 0.14515081f, 0.10719863f, 
    0.12794362f, 0.18693845f, -0.10033223f, 0.12027753f, 0.07640391f, 0.13036619f, 0.06783101f, 0.17125030f, 
    0.14791743f, 0.31465012f, -0.16980393f, -0.03452627f, -0.08207179f, -0.01758920f, -0.10569323f, -0.02068323f, 
    -0.07545026f, -0.03835099f, -0.06485997f, 0.02158688f, 0.08628862f, 0.09648660f, 0.17385718f, 0.04099362f, 
    -0.13652256f, -0.08890503f, 0.13364965f, -0.03396294f, -0.17685096f, -0.06211252f, -0.18015057f, 0.14515951f, 
    -0.04531756f, 0.00957938f, -0.22410992f, -0.14143394f, -0.40687367f, 0.04258475f, 0.00804594f, 0.12782548f, 
    -0.03349490f, 0.10254080f, 0.08404055f, 0.10010718f, -0.01466507f, -0.21070369f, 0.07646175f, 0.43073341f, 
    0.28356972f, -0.01638943f, -0.16865136f, 0.23821631f, -0.00972698f, 0.11719014f, 0.12147520f, 0.12352755f, 
    0.51946884f, 0.28732631f, 0.01574663f, -0.24028222f, 0.05554450f, -0.17462671f, 0.24209613f, -0.01276722f, 
    -0.05947560f, 0.31098181f, 0.31910062f, 0.04808927f, -0.22110514f, 0.15432242f, -0.14525791f, 0.27568015f, 
    -0.00089995f, -0.23731355f, 0.28613454f, -0.08860814f, 0.02153574f, 0.08568067f, 0.22288516f, -0.10888840f, 
    0.06423534f, 0.02518816f, -0.08641574f, 0.11824098f, 0.03408904f, 0.01218371f, -0.01797238f, -0.05439878f, 
    -0.18935645f, -0.25211656f, -0.05681017f, -0.09795443f, -0.09015244f, -0.15352041f, 0.03010876f, 0.09152365f, 
    0.08406209f, -0.02647576f, 0.11887009f, -0.02905498f, -0.01865864f, 0.24584782f, 0.04118819f, 0.05470074f, 
    0.08929055f, 0.32740766f, 0.14699499f, 0.21510504f, 0.04599771f, -0.01600062f, 0.06657709f, -0.04456798f, 
    -0.03073559f, -0.11893991f, -0.03506732f, 0.02533364f, 0.12850425f, 0.15401728f, 0.08559898f, 0.06448103f, 
    0.03365749f, -0.00874915f, 0.21682593f, 0.15162118f, 0.10391703f, 0.08095328f, -0.01623707f, -0.02638121f, 
    0.01875293f, -0.06631958f, 0.16262752f, 0.17383167f, 0.11029147f, -0.06164056f, -0.01301546f, -0.17417431f, 
    0.23842986f, 0.08416613f, 0.01164786f, 0.10893453f, 0.03969432f, 0.00347155f, 0.04215372f, -0.08545425f, 
    0.01649905f, -0.09991514f, 0.17765386f, 0.03558312f, -0.09617595f, 0.05730249f, 0.05336431f, -0.00396303f, 
    0.28056124f, 0.09186859f, -0.00592319f, -0.10756038f, -0.02574800f, 0.04369218f, -0.06128285f, 0.03507866f, 
    0.20333792f, 0.07800946f, -0.01109281f, -0.08429693f, 0.20391624f, -0.12687737f, -0.07481071f, -0.11877871f, 
    -0.08527460f, -0.23917983f, -0.00490468f, -0.11711040f, 0.06029423f, -0.07791783f, -0.12482660f, 0.01279166f, 
    -0.15768416f, -0.01702855f, -0.00914960f, -0.04858467f, -0.28901336f, -0.23153242f, -0.03855935f, 0.12440860f, 
    0.15023023f, 0.00704742f, -0.01871648f, 0.06179678f, -0.15740655f, -0.12132550f, 0.28440276f, -0.01482957f, 
    0.03229650f, -0.08942890f, -0.00349608f, 0.01355858f, -0.43859112f, -0.16754137f, -0.41014710f, -0.13983290f, 
    -0.03394137f, 0.03487106f, 0.06072206f, 0.00851081f, 0.09715386f, -0.02678354f, -0.13369633f, 0.12600851f, 
    -0.18504243f, -0.07245679f, -0.01476693f, -0.15980516f, -0.03834938f, -0.14024396f, 0.03810981f, -0.01195182f, 
    -0.02496038f, -0.20904431f, -0.02904337f, -0.15444049f, -0.11950826f, -0.06153065f, -0.07914466f, 0.03947306f, 
    0.01451304f, -0.10552695f, 0.00138804f, 0.24636663f, -0.06346665f, -0.04690991f, -0.02677349f, -0.02076645f, 
    -0.14444268f, 0.04262124f, -0.01638653f, -0.16259657f, 0.34263071f, 0.02811966f, 0.08851037f, 0.07072163f, 
    -0.03257780f, 0.05125304f, -0.08670859f, 0.28314289f, 0.33937493f, 0.27036351f, 0.20020601f, 0.02746757f, 
    0.14578989f, -0.00615751f, 0.08608798f, 0.11890606f, -0.04414353f, 0.14154971f, 0.12336810f, 0.00669390f, 
    -0.15536648f, 0.18603243f, -0.03660015f, -0.07330312f, -0.09137605f, 0.14561176f, 0.19870187f, 0.26086381f, 
    0.21202394f, -0.11194521f, 0.07325936f, -0.08663141f, 0.16574866f, 0.01522548f, -0.17543444f, -0.03119968f, 
    0.25029966f, 0.23143965f, 0.01590162f, 0.07260309f, -0.00902730f, -0.02328721f, 0.15519212f, -0.13460086f, 
    -0.05764988f, -0.08409725f, -0.01130990f, 0.20193617f, 0.02808658f, 0.07421428f, -0.22794378f, -0.16017990f, 
    -0.18346064f, -0.20833020f, 0.00311557f, -0.10389426f, 0.19185060f, 0.08045769f, 0.07224761f, -0.21331054f, 
    -0.23676732f, -0.19883165f, 0.11364438f, -0.01115941f, 0.02435219f, 0.23528527f, 0.09095619f, -0.01853392f, 
    -0.00644161f, -0.08268885f, 0.05365683f, -0.10795225f, -0.08717335f, 0.09639677f, 0.06560132f, -0.01214172f, 
    -0.09762505f, -0.10085828f, -0.19978391f, -0.10082591f, 0.03351633f, -0.11086003f, 0.04838211f, 0.09153353f, 
    0.23201104f, 0.43895951f, -0.02342375f, 0.27269876f, 0.27059463f, -0.24457835f, -0.00808239f, -0.13539302f, 
    -0.07017754f, -0.06365691f, 0.27572501f, 0.23704782f, 0.01421364f, 0.05576693f, 0.30974025f, 0.19998057f, 
    -0.05121812f, -0.17375781f, 0.21687570f, -0.11183413f, 0.02925408f, 0.03963488f, -0.03346099f, 0.08492075f, 
    -0.02280554f, 0.20589449f, -0.12388387f, 0.12596615f, -0.16969198f, -0.05880069f, 0.04737308f, 0.30495757f, 
    0.10333131f, 0.19997191f, -0.11570086f, 0.02569468f, 0.07088882f, 0.13261597f, 0.18156105f, 0.09730884f, 
    -0.03025446f, 0.02431816f, 0.07379321f, -0.04942428f, 0.14581276f, 0.06667981f, -0.01698009f, 0.04851449f, 
    -0.02230372f, -0.04898416f, 0.32912135f, -0.01298025f, -0.06771223f, 0.13112521f, 0.21032818f, -0.01722826f, 
    0.14678214f, 0.34089282f, 0.50964588f, 0.05686111f, -0.12686920f, -0.09995793f, 0.15175633f, 0.03336998f, 
    0.17685242f, -0.07969739f, -0.19311996f, -0.24837638f, -0.16441447f, 0.29874980f, 0.05375612f, -0.03721470f, 
    0.35689414f, -0.09152257f, -0.16404130f, -0.13080880f, -0.27626729f, 0.08380510f, 0.02140736f, 0.10999513f, 
    0.06701728f, 0.08801294f, 0.02560565f, -0.03931522f, 0.09903310f, -0.05708349f, 0.05092330f, 0.15318222f, 
    0.14187954f, -0.04968271f, -0.09324300f, 0.06150049f, -0.19274260f, -0.03736836f, -0.07139160f, -0.02231841f, 
    -0.01383946f, 0.02443955f, -0.01541607f, -0.06488191f, 0.05831491f, -0.13207228f, -0.15334359f, 0.06225640f, 
    0.17852053f, 0.11866695f, 0.30283427f, -0.09174808f, 0.10190627f, -0.11437717f, 0.08210720f, 0.00746576f, 
    0.27467266f, 0.14084026f, 0.04579686f, -0.10259637f, 0.06890449f, 0.11634965f, -0.06356329f, -0.15590447f, 
    0.08352668f, -0.05843570f, 0.10584890f, -0.13070974f, -0.18181434f, 0.06598496f, 0.03480029f, -0.06846984f, 
    0.05571763f, -0.09894157f, 0.08000700f, -0.05926889f, -0.05282421f, -0.00285363f, 0.00181710f, 0.15622532f, 
    0.08778567f, -0.09414107f, 0.10985892f, 0.07071356f, -0.01873633f, 0.19702999f, -0.19268049f, -0.15522286f, 
    0.06164371f, 0.04137187f, 0.09519793f, 0.02132818f, 0.05068671f, 0.35126567f, 0.23436251f, 0.03298051f, 
    0.01821017f, 0.11139616f, -0.18331942f, -0.17075059f, -0.08147586f, 0.12098342f, -0.07090854f, -0.05510882f, 
    0.02666352f, -0.03516407f, 0.03491345f, 0.00651692f, 0.24996935f, 0.19394636f, 0.00569012f, 0.05075748f, 
    0.25087333f, 0.33087048f, -0.10052832f, 0.06501783f, -0.01485734f, -0.01918290f, 0.14760746f, 0.06223145f, 
    0.25664818f, 0.37056616f, 0.08147004f, 0.03321803f, 0.04478078f, -0.05010984f, 0.04975446f, 0.09233998f, 
    -0.04009373f, 0.23159751f, 0.43356544f, 0.29859656f, 0.02476926f, -0.05429468f, -0.08387938f, -0.04016390f, 
    0.07646580f, 0.12799124f, 0.15877168f, -0.02705434f, -0.14411764f, 0.07803138f, 0.04161488f, 0.22192219f, 
    0.20019490f, -0.01716721f, -0.09554052f, 0.09274285f, 0.09727159f, 0.17002429f, -0.02418501f, 0.06650004f, 
    0.14959247f, 0.03742747f, 0.11382169f, 0.13288918f, -0.11384529f, -0.14197384f, -0.49357414f, 0.22583769f, 
    -0.02335500f, -0.12098616f, -0.00448762f, -0.07080979f, 0.08418828f, -0.08008343f, 0.10727105f, 0.19209662f, 
    -0.10804249f, -0.02324226f, 0.10480943f, -0.00186621f, 0.10234511f, 0.13952459f, -0.06543684f, 0.22025616f, 
    -0.08170778f, -0.01294304f, 0.04117799f, -0.14466283f, 0.04640529f, -0.06442165f, 0.13479312f, 0.03409048f, 
    0.27649948f, 0.04935835f, -0.12992960f, -0.21743277f, -0.09819965f, -0.01938594f, 0.05761320f, -0.04335291f, 
    0.28991634f, 0.19337086f, -0.01291849f, 0.11137521f, 0.02085458f, 0.08287717f, 0.16031566f, -0.07034404f, 
    -0.14285418f, 0.03066781f, -0.04238499f, -0.02957916f, 0.11291414f, 0.01940125f, -0.01159200f, 0.29910043f, 
    0.12723276f, -0.13352643f, 0.18776709f, -0.02418778f, -0.34331015f, -0.16571829f, -0.03670598f, -0.07052850f, 
    0.00961664f, 0.11586943f, -0.02576652f, -0.15158825f, -0.21471488f, -0.12514791f, 0.13423119f, 0.09320936f, 
    0.11969987f, 0.02462614f, 0.11026508f, 0.04733900f, -0.39840633f, -0.25168175f, -0.06960350f, 0.24467194f, 
    0.07358952f, -0.07134216f, -0.24145748f, -0.02687997f, 0.23879226f, 0.13016035f, 0.08117493f, 0.39063492f, 
    -0.00985060f, -0.05774768f, -0.10723329f, -0.04405946f, -0.02234579f, 0.07022775f, -0.10682053f, -0.13751164f, 
    0.46714869f, -0.20471260f, 0.22245069f, -0.14530139f, 0.02236559f, 0.00473255f, 0.04450886f, 0.06816841f, 
    -0.63235945f, -0.18576862f, 0.20545574f, -0.05538613f, 0.13012116f, 0.08080805f, 0.21366955f, -0.19969562f, 
    -0.47422588f, -0.20682754f, -0.22114901f, -0.08417268f, -0.14132804f, -0.01380454f, 0.06012665f, -0.16221997f, 
    0.00514845f, 0.09908924f, 0.23408480f, 0.14970076f, -0.08323397f, 0.19225067f, -0.18662561f, 0.09691685f, 
    0.06400633f, 0.07876281f, -0.26939496f, -0.27705628f, 0.49784142f, -0.06016724f, 0.04319442f, -0.02197916f, 
    -0.10008545f, -0.08586449f, -0.09578773f, -0.07150064f, -0.02561512f, 0.16705777f, -0.07088871f, -0.02425965f, 
    -0.08505476f, 0.05462041f, -0.03141320f, 0.13142210f, -0.03392989f, -0.07506862f, -0.11148877f, -0.13052548f, 
    -0.02047913f, 0.03366238f, 0.06104642f, -0.16573632f, -0.06128507f, -0.00148817f, -0.03914715f, 0.20448646f, 
    -0.10504559f, 0.18631257f, -0.25336143f, -0.12307826f, 0.12156712f, -0.15505579f, -0.07682658f, -0.03577737f, 
    -0.22174272f, -0.30362341f, -0.04360535f, -0.04879335f, 0.08825971f, 0.02204433f, -0.10293861f, -0.09607162f, 
    -0.18070237f, 0.01142211f, 0.07168449f, 0.03251280f, 0.07915127f, 0.10658634f, 0.15515353f, 0.17473020f, 
    -0.41269413f, -0.60744631f, 0.49780622f, -0.05645924f, -0.02081317f, 0.11667102f, -0.11571441f, -0.08458564f, 
    -0.12686361f, -0.44692615f, -0.39896411f, 0.00178781f, 0.01694652f, 0.18032385f, -0.24344099f, 0.10311409f, 
    0.15565398f, -0.16110231f, 0.45556909f, 0.27391392f, -0.12655656f, -0.12016446f, -0.08526354f, -0.15024973f, 
    -0.08922269f, -0.04153409f, -0.17970641f, -0.15219972f, -0.20113401f, 0.10087641f, 0.08561686f, 0.10152837f, 
    -0.13791236f, 0.05736365f, 0.04616265f, 0.10264869f, 0.04395372f, 0.00295511f, 0.04180075f, 0.10078222f, 
    0.06338405f, -0.07508660f, -0.06187963f, -0.03710670f, 0.30652669f, 0.00292577f, 0.12880093f, -0.30465257f, 
    -0.39920813f, -0.15242113f, -0.07253060f, 0.12869683f, -0.01521110f, 0.01357189f, -0.07203489f, 0.18515545f, 
    0.02406709f, 0.04714597f, -0.14576584f, -0.02543206f, -0.02391444f, 0.00296570f, 0.01874214f, -0.37454718f, 
    -0.04228703f, 0.29112279f, -0.18209082f, -0.01890876f, -0.11611472f, 0.14732082f, 0.01032525f, -0.04083753f, 
    0.12784012f, 0.16656519f, 0.03892148f, 0.09065494f, 0.22128955f, 0.04808894f, 0.22508186f, 0.07704822f, 
    0.17347428f, -0.03534188f, -0.09631149f, 0.25099185f, -0.12472435f, 0.23574890f, 0.06291191f, -0.10323434f, 
    -0.03989894f, 0.17879725f, 0.01505185f, 0.28397334f, 0.22546826f, 0.01643712f, 0.22206315f, 0.18120244f, 
    0.40628466f, -0.22191884f, 0.04436159f, -0.15401942f, 0.02995494f, 0.01500418f, 0.12440412f, 0.27286893f, 
    0.13620506f, 0.09956693f, 0.08437055f, -0.14522526f, -0.23713264f, 0.09015925f, -0.00396452f, 0.00827828f, 
    -0.13102596f, -0.16179807f, -0.21448904f, -0.00958725f, -0.05641711f, 0.01626457f, 0.11311060f, 0.20363164f, 
    0.06991372f, 0.05955080f, 0.15345946f, 0.02938277f, 0.07990215f, 0.02160007f, -0.07799204f, -0.24092807f, 
    -0.25773561f, -0.12936097f, -0.02099396f, 0.06923860f, -0.18612623f, -0.14973974f, -0.28395170f, -0.06911729f, 
    -0.17859142f, 0.36788273f, 0.01895762f, 0.03472987f, -0.00106676f, -0.05385365f, -0.00245799f, 0.19428104f, 
    -0.09592186f, -0.01699878f, -0.02110900f, 0.09818763f, -0.14167282f, 0.01789419f, 0.32770044f, -0.13087733f, 
    0.13726303f, -0.03942377f, -0.21283504f, 0.04056210f, 0.06111398f, 0.13207488f, 0.26202270f, 0.22503702f, 
    -0.01148890f, 0.30429152f, -0.14615194f, 0.11846337f, 0.28274527f, -0.08123662f, 0.00579941f, 0.19550389f, 
    -0.08693931f, 0.09049387f, -0.16562128f, 0.05192763f, -0.03671250f, -0.12801869f, 0.09601329f, -0.03909080f, 
    0.08288206f, -0.06274354f, 0.05322493f, 0.00646294f, -0.11711340f, -0.06366123f, 0.04993318f, -0.02758173f, 
    -0.15222487f, -0.34138528f, -0.14020532f, -0.26776707f, -0.13656279f, -0.10324860f, -0.17931758f, -0.14686462f, 
    -0.03490855f, 0.06411592f, 0.09237963f, 0.29965290f, -0.02667268f, -0.05715701f, 0.22990704f, 0.15192638f, 
    0.18511407f, -0.01260681f, 0.21962342f, 0.09063111f, -0.19889088f, 0.26558995f, 0.09187504f, 0.23987448f, 
    0.44605473f, -0.09941578f, 0.08388505f, -0.14392497f, 0.04494675f, 0.03008298f, -0.00475275f, -0.14218956f, 
    -0.15172563f, 0.26802075f, 0.21229355f, -0.01694222f, 0.09331052f, 0.24462099f, 0.13647829f, -0.02611120f, 
    -0.07355803f, -0.14399268f, 0.22552633f, 0.26136884f, 0.01579315f, 0.08584794f, 0.05293545f, 0.07152168f, 
    0.29834080f, -0.02940471f, 0.26239371f, 0.14875565f, 0.12315754f, -0.09670986f, -0.03748745f, -0.18107198f, 
    -0.08029509f, -0.39058453f, 0.10061186f, -0.00689694f, -0.00758807f, -0.04063930f, 0.29291099f, -0.00315345f, 
    0.07642157f, 0.09291141f, -0.12942086f, -0.02436183f, -0.12732650f, -0.14782125f, 0.15994081f, 0.05567242f, 
    0.14255387f, 0.24133021f, 0.03842955f, 0.22428457f, -0.01183922f, 0.16207336f, 0.15053093f, -0.03291977f, 
    -0.31144679f, -0.07905626f, -0.05541234f, -0.09290705f, -0.13371086f, -0.02614563f, 0.00091355f, 0.03791583f, 
    -0.04065375f, 0.12379085f, 0.07320285f, -0.19299258f, 0.24884471f, 0.01940262f, -0.31695870f, -0.08408894f, 
    -0.14135775f, -0.13970016f, 0.18152204f, 0.10673046f, -0.08673314f, -0.08494996f, -0.20019618f, -0.08294182f, 
    0.25167626f, 0.15084809f, -0.38102216f, -0.20351072f, -0.02156066f, 0.17867146f, -0.07213312f, -0.05642789f, 
    0.06414215f, 0.10660525f, 0.08915589f, 0.42003441f, -0.04350785f, -0.01253535f, 0.16878618f, 0.12387269f, 
    0.08547270f, 0.28452674f, -0.07342058f, -0.09173230f, -0.05222660f, 0.07241599f, 0.02094022f, 0.03846885f, 
    -0.09596253f, -0.04815525f, -0.05074455f, -0.03314100f, 0.17355271f, 0.01755012f, -0.16948694f, 0.11099601f, 
    -0.01483910f, -0.06116633f, -0.20034227f, 0.01926151f, 0.11765013f, -0.04864284f, -0.01309593f, 0.02618336f, 
    0.03762381f, 0.10991761f, -0.04526487f, -0.00265068f, -0.05659527f, -0.00980339f, 0.00714838f, 0.13354418f, 
    0.00391759f, -0.01305189f, -0.17053306f, 0.16292632f, -0.11300573f, -0.54485482f, -0.08216140f, 0.11356210f, 
    -0.18674383f, -0.18885611f, -0.04974214f, 0.16829689f, -0.31872785f, -0.22649503f, -0.19284409f, -0.16822872f, 
    -0.01678115f, -0.11058640f, 0.06209577f, 0.09193541f, -0.07339744f, -0.06972960f, -0.23512627f, -0.09294360f, 
    0.08006820f, 0.06062533f, -0.13374680f, 0.19083157f, 0.02961359f, 0.10287113f, 0.05271534f, 0.15054721f, 
    0.09011737f, 0.05191961f, 0.02518152f, 0.06214047f, 0.05923413f, 0.12881222f, -0.05638477f, 0.15401225f, 
    0.27371779f, 0.21147285f, 0.05435752f, -0.08644729f, -0.08051275f, -0.13455194f, -0.02382110f, -0.06991342f, 
    -0.01155436f, -0.17120299f, -0.05095083f, 0.12678351f, -0.08841112f, -0.09499107f, -0.08276404f, 0.14338353f, 
    -0.11099999f, -0.13327338f, -0.04093824f, 0.10066632f, -0.32425779f, -0.24843094f, 0.09424071f, -0.08582829f, 
    -0.01887781f, 0.00146276f, -0.09429028f, -0.13017629f, 0.06649560f, -0.15839329f, -0.03124405f, 0.16174582f, 
    0.10849180f, 0.01529629f, 0.07139731f, 0.01670569f, -0.09692131f, 0.01456919f, -0.18487093f, -0.06081538f, 
    -0.18620035f, 0.11177377f, 0.03426265f, -0.01470161f, -0.13916880f, -0.02509026f, -0.29487216f, 0.07192574f, 
    -0.08720149f, -0.39168784f, 0.16853386f, 0.07721493f, 0.05236131f, 0.10106166f, 0.19028141f, -0.03050300f, 
    0.12048263f, -0.00214437f, 0.09542611f, -0.03993667f, -0.06281157f, -0.06813636f, 0.06593578f, 0.10723661f, 
    -0.01032445f, 0.03505624f, -0.19905376f, 0.02879566f, -0.00014955f, -0.10885387f, -0.14915262f, 0.11401072f, 
    0.20808029f, 0.11702438f, -0.34574151f, 0.17457397f, 0.10614700f, -0.05467138f, 0.01217140f, 0.03896276f, 
    0.12324511f, -0.03103362f, 0.18775694f, 0.02175127f, 0.10291081f, 0.03789076f, 0.18404852f, 0.17618930f, 
    -0.08218256f, 0.17501023f, 0.04090233f, 0.00527179f, 0.01782600f, -0.02438059f, 0.06686179f, -0.02881255f, 
    -0.31468612f, 0.01178521f, -0.09796798f, -0.33570835f, -0.29312897f, 0.07526955f, -0.15089270f, -0.20617148f, 
    -0.04312088f, -0.11709549f, 0.05269729f, -0.08185685f, 0.07029329f, -0.19499393f, 0.00089344f, -0.30935639f, 
    -0.07646327f, 0.09542124f, -0.02648770f, 0.13003479f, -0.08143596f, 0.17295323f, 0.24483724f, -0.10738797f, 
    0.29723659f, -0.26432994f, 0.15540631f, -0.19445863f, -0.00690295f, -0.12666297f, 0.01512647f, 0.00452572f, 
    -0.27901915f, -0.31420955f, -0.16249929f, 0.18139987f, -0.06975226f, -0.21204874f, 0.09750307f, 0.00403696f, 
    0.06702735f, 0.01818660f, -0.17737986f, 0.08880536f, 0.08436111f, -0.21515346f, -0.08093400f, 0.22980882f, 
    -0.05161836f, -0.02090081f, -0.03756068f, 0.20055062f, 0.07719076f, 0.05348374f, -0.21901494f, -0.21039557f, 
    0.03374421f, -0.04053527f, -0.14856417f, -0.03063725f, 0.05089501f, -0.03316116f, 0.22825795f, 0.00507246f, 
    0.10290688f, -0.02218843f, 0.13682483f, -0.11810296f, -0.03061311f, -0.11191875f, -0.11645773f, -0.06020362f, 
    -0.17361189f, 0.09813878f, 0.07794082f, 0.18608177f, 0.02056286f, 0.00112790f, 0.19690132f, 0.14266051f, 
    0.06333887f, -0.13324538f, 0.18941866f, -0.01709031f, 0.04669975f, 0.07699537f, 0.04570603f, -0.01594372f, 
    -0.08570760f, 0.14448802f, 0.08055926f, 0.17726330f, 0.06883706f, 0.08609759f, -0.09538000f, 0.05760798f, 
    0.13371316f, -0.12726508f, 0.25334230f, 0.11100432f, 0.22002177f, 0.09289826f, 0.10614997f, -0.13397567f, 
    0.06399832f, 0.17613338f, 0.06051326f, 0.10661159f, -0.01067467f, 0.17902741f, 0.02266586f, 0.06151575f, 
    0.04721963f, -0.19554751f, 0.02686073f, 0.05007233f, 0.10540483f, -0.03112434f, -0.00959682f, 0.15579073f, 
    0.12414671f, 0.31382388f, -0.16286719f, -0.14580277f, 0.00246416f, -0.05440656f, -0.09141264f, 0.12106905f, 
    0.14075769f, 0.08237727f, 0.02897913f, -0.00496891f, 0.02320519f, -0.16504136f, -0.01348593f, -0.17421940f, 
    0.14759140f, -0.23930037f, 0.03782085f, -0.27427074f, -0.04584828f, -0.08329053f, -0.10780322f, -0.14988953f, 
    0.06824198f, 0.15152879f, -0.23521999f, -0.01017229f, -0.26662090f, -0.28875995f, -0.00921508f, 0.15860006f, 
    0.11867135f, -0.13567050f, 0.09800322f, 0.03108619f, 0.09465092f, -0.13803045f, -0.02687292f, -0.25725901f, 
    -0.11310103f, -0.16910870f, -0.01021021f, 0.02872440f, -0.32310456f, 0.01284202f, 0.03545401f, 0.07315007f, 
    0.08254369f, -0.27019197f, 0.01149337f, 0.04676400f, 0.04672226f, 0.04065223f, -0.02241663f, -0.04361009f, 
    -0.03171640f, 0.00984763f, -0.06564000f, -0.02786857f, -0.04009359f, 0.03505344f, -0.06118049f, -0.01021746f, 
    -0.00435748f, 0.03485639f, -0.01490948f, -0.05005508f, -0.06090790f, 0.04378628f, 0.04538471f, -0.00147005f, 
    -0.00836736f, -0.02952588f, -0.03042707f, -0.00392833f, -0.01623557f, -0.01928248f, -0.00675765f, 0.00408892f, 
    0.04029990f, 0.03580181f, 0.02469188f, 0.02682715f, -0.04924298f, 0.04511490f, -0.04347832f, 0.03802172f, 
    -0.04263164f, -0.06751741f, -0.05544704f, 0.03024361f, 0.03039511f, -0.02754423f, 0.03997030f, -0.00639646f, 
    0.00319623f, 0.02509063f, -0.05852295f, -0.04134906f, -0.04952754f, 0.02351921f, 0.00652263f, -0.02470644f, 
    -0.06461497f, 0.03582867f, 0.01660411f, 0.04863799f, -0.02643722f, -0.01382712f, 0.03997926f, -0.01331309f, 
    0.03079460f, 0.03265592f, 0.01137325f, 0.05271105f, -0.03490104f, 0.03377062f, -0.04160848f, 0.00982382f, 
    0.02446811f, -0.00966504f, 0.00090438f, -0.06219400f, -0.01091274f, -0.03768032f, -0.04428887f, -0.06279684f, 
    0.03505834f, -0.02386203f, -0.03548075f, 0.01456263f, -0.00068561f, 0.03922439f, 0.03902403f, -0.06021919f, 
    0.01673615f, 0.04037106f, 0.00365208f, 0.03839935f, -0.00577625f, 0.03548197f, -0.00965391f, -0.05711402f, 
    0.01165871f, -0.02200821f, 0.00063765f, 0.04724080f, -0.01412395f, 0.04008586f, 0.03161637f, -0.01881253f, 
    -0.03199856f, 0.02344575f, 0.03444269f, -0.00483406f, -0.03453615f, -0.04047303f, 0.03461294f, 0.01673612f, 
    -0.05784613f, -0.03082674f, 0.02306079f, 0.02061523f, 0.04764184f, -0.01383080f, -0.04214343f, -0.00492383f, 
    0.02072322f, -0.01109808f, -0.01974864f, -0.04581538f, -0.03827884f, 0.01450074f, 0.00218261f, 0.04066883f, 
    -0.05894129f, -0.02451273f, 0.04150948f, 0.04401411f, 0.03432253f, -0.02532720f, 0.01427977f, -0.02400966f, 
    -0.02353760f, -0.04020045f, -0.02945527f, 0.03505541f, -0.05716687f, 0.04950495f, -0.03741769f, 0.00758695f, 
    0.03836429f, 0.03464941f, 0.05036672f, -0.05272583f, 0.01609207f, -0.00550896f, -0.04873688f, -0.01407257f, 
    0.03690915f, -0.04192566f, 0.01506733f, 0.02661527f, -0.02190772f, 0.01627865f, -0.06007225f, -0.00125497f, 
    -0.01794526f, 0.04110467f, 0.03584681f, -0.06205521f, -0.05314809f, -0.06000548f, -0.03059995f, -0.05861300f, 
    -0.05209845f, 0.03665626f, -0.00062471f, 0.02481604f, 0.02574741f, -0.00842590f, 0.02839943f, -0.05919936f, 
    -0.04927324f, -0.06811512f, 0.03149465f, -0.04909900f, 0.05050994f, -0.02018461f, -0.00005968f, 0.02365677f, 
    -0.04449527f, 0.03608930f, -0.04079144f, -0.00400042f, -0.05665945f, -0.04167053f, -0.00703950f, -0.04952998f, 
    -0.04119229f, -0.02837954f, -0.03487972f, 0.01486906f, 0.00010676f, 0.03353072f, -0.05630878f, 0.03310897f, 
    0.02025883f, -0.06334034f, -0.04768825f, 0.03928695f, 0.01204766f, -0.00173953f, 0.01962901f, -0.03557963f, 
    0.02594241f, -0.05597856f, -0.00110932f, 0.01723179f, 0.03871376f, -0.03275462f, -0.02434040f, -0.04208595f, 
    0.05081462f, -0.03013692f, -0.04948869f, -0.06488795f, 0.00044205f, -0.00826753f, 0.02141847f, 0.01872564f, 
    0.00509782f, -0.05683856f, -0.06210967f, -0.00291716f, 0.00807155f, -0.03873409f, -0.05204012f, 0.03704063f, 
    -0.00024258f, -0.02151565f, 0.02305274f, 0.04322914f, 0.01558231f, -0.05291475f, 0.03592343f, -0.03593459f, 
    0.02115606f, -0.06236979f, -0.01046553f, 0.04812695f, -0.00282102f, 0.01612578f, 0.01288712f, 0.00085768f, 
    -0.01611058f, -0.03776729f, -0.04251830f, 0.02615105f, -0.01649642f, -0.00962767f, 0.00951933f, 0.02790268f, 
    0.00815383f, 0.03145466f, -0.05137700f, -0.03458653f, -0.04623797f, 0.03429977f, -0.03915506f, 0.00650155f, 
    -0.02028001f, 0.03714907f, -0.01225914f, -0.02492868f, 0.02609901f, -0.04027347f, -0.03733363f, -0.00341370f, 
    0.02042204f, 0.03893677f, -0.06791101f, -0.00622111f, -0.02483746f, -0.06291906f, 0.04022547f, -0.01529821f, 
    0.01616933f, -0.00040692f, 0.04029758f, 0.00774828f, 0.00044473f, -0.01008105f, 0.03190913f, -0.02567321f, 
    0.00824690f, -0.03805035f, 0.04761362f, 0.05147520f, -0.03690489f, -0.02321182f, -0.05212840f, -0.05123193f, 
    0.33322835f, -0.21891136f, 0.00939371f, 0.13281603f, 0.09547792f, 0.11894968f, 0.14229566f, 0.22165065f, 
    0.09046323f, 0.35160729f, -0.03327789f, -0.04534080f, 0.09839774f, 0.08601124f, -0.12868415f, 0.05058100f, 
    0.07540172f, 0.15170883f, 0.05931094f, -0.03766196f, 0.27508104f, 0.28455085f, 0.08188404f, 0.22897363f, 
    0.09012651f, 0.06926803f, -0.06123739f, -0.04938396f, -0.02173156f, 0.07191375f, 0.10426660f, 0.03524758f, 
    0.32319257f, 0.00732313f, 0.06566586f, 0.13600361f, -0.44884509f, -0.31123710f, 0.08774036f, -0.20579471f, 
    -0.27507055f, 0.04893256f, -0.09317765f, -0.07616866f, 0.11722828f, 0.30391359f, 0.18176866f, -0.04217437f, 
    0.07404071f, 0.22904718f, 0.17229079f, 0.05237219f, 0.05035004f, 0.14888649f, -0.46906784f, -0.12145434f, 
    -0.11351590f, -0.01036107f, 0.07075322f, -0.12205680f, 0.05167287f, -0.02293735f, 0.16785455f, 0.13619047f, 
    -0.35814533f, -0.37028465f, 0.04883621f, 0.12787755f, 0.07013882f, 0.03787801f, 0.11201446f, -0.00597550f, 
    0.06458727f, -0.07236024f, 0.02299174f, 0.01193482f, -0.08948103f, -0.01740174f, -0.14417237f, 0.06077790f, 
    0.01288367f, 0.27010381f, -0.27508444f, -0.63237470f, -0.21481971f, -0.12442143f, -0.23122124f, 0.08983945f, 
    -0.05242065f, 0.04437107f, -0.14784162f, -0.03071469f, 0.10164887f, 0.05540022f, 0.23470680f, 0.06124549f, 
    -0.11543106f, 0.02380703f, -0.00860641f, -0.27191702f, 0.00741795f, 0.18264091f, 0.08043931f, 0.12493570f, 
    0.21931045f, 0.10407782f, 0.03781610f, 0.08174133f, -0.15797839f, 0.06208849f, -0.08159576f, -0.10587185f, 
    0.11271464f, -0.05809784f, 0.08526384f, -0.06467618f, 0.03206762f, -0.04010668f, -0.15561388f, 0.10230817f, 
    -0.12093457f, 0.06806848f, -0.09515864f, -0.25902170f, 0.06789674f, 0.14867859f, 0.06643289f, -0.53694874f, 
    -0.79313141f, -0.08757415f, 0.01287790f, 0.11671477f, -0.12919708f, -0.05906029f, 0.04937856f, -0.14822333f, 
    -0.09647747f, -0.06679866f, 0.20214026f, 0.09788323f, 0.16720212f, 0.04158328f, 0.00794831f, 0.16695669f, 
    -0.33404335f, -0.40928721f, 0.05918347f, -0.03092989f, -0.06666285f, 0.01670484f, 0.11012121f, -0.13315134f, 
    0.00688935f, -0.14418256f, -0.31442636f, -0.53897512f, 0.10588437f, 0.19443884f, -0.05339552f, 0.31506690f, 
    -0.00116966f, 0.13025045f, 0.12065087f, -0.23087557f, -0.04537143f, -0.17148225f, -0.10108626f, 0.05400074f, 
    0.06510823f, 0.12244070f, 0.04780349f, -0.07592916f, -0.00956555f, 0.03955011f, 0.07033353f, 0.06129064f, 
    -0.02452131f, -0.10350242f, 0.02099933f, 0.04860113f, 0.48719993f, -0.26875097f, -0.55102628f, -0.36961102f, 
    -0.13810159f, -0.11046579f, -0.10876583f, -0.09277136f, -0.05719440f, -0.21714883f, 0.05924093f, 0.18300311f, 
    0.08470769f, 0.19929618f, -0.00307280f, 0.04837430f, -0.08661915f, -0.08043101f, -0.37637031f, -0.37774190f, 
    -0.25473300f, 0.03771723f, -0.02076856f, -0.02142631f, 0.13067982f, -0.04442348f, 0.03321141f, -0.29842880f, 
    -0.15934047f, 0.21460962f, -0.10499324f, -0.06211417f, -0.02401230f, 0.00124516f, 0.12694085f, 0.15288687f, 
    -0.35923600f, 0.36163875f, 0.48017189f, -0.07596384f, 0.11163254f, -0.05548981f, 0.15598734f, -0.01902735f, 
    0.00698718f, -0.33253291f, -0.29828021f, 0.07333085f, -0.14583693f, 0.18018320f, -0.19779120f, 0.11053377f, 
    -0.01607923f, 0.09956980f, 0.03552224f, 0.03360019f, 0.05081301f, -0.23785201f, -0.09281611f, 0.04994620f, 
    0.00362812f, -0.22498012f, -0.08960374f, 0.02655564f, 0.12401589f, 0.21594197f, 0.13843901f, 0.15227243f, 
    -0.18383923f, 0.20225610f, -0.01212625f, 0.14710560f, 0.08249465f, 0.10762714f, 0.13221243f, 0.01908264f, 
    0.11799782f, -0.07455776f, -0.00724984f, -0.04350758f, 0.08229480f, -0.25513375f, 0.26343337f, -0.10155217f, 
    0.00877345f, 0.05103436f, 0.04734942f, -0.18576398f, -0.01266097f, 0.15048636f, -0.30670217f, -0.01348398f, 
    -0.00800109f, -0.19041146f, -0.17820860f, -0.12683599f, 0.13260585f, -0.12545294f, 0.14545719f, 0.09272517f, 
    -0.17596127f, -0.25772277f, -0.03889284f, -0.16639310f, -0.08758814f, -0.02087295f, -0.18521267f, 0.05980069f, 
    0.10541381f, -0.09593905f, -0.07637222f, 0.15392053f, 0.08664836f, -0.08030668f, 0.07938857f, 0.02193110f, 
    0.23794423f, -0.04669409f, 0.31419736f, -0.13086899f, 0.05435183f, 0.07907934f, 0.00518558f, 0.05791374f, 
    0.00335793f, 0.14428329f, 0.10585059f, -0.22468029f, 0.01793946f, -0.00543527f, 0.13682145f, 0.10614171f, 
    0.23877154f, 0.09543016f, 0.07434316f, -0.17498970f, 0.25998795f, -0.08086014f, 0.03228058f, 0.10900953f, 
    -0.15723763f, 0.10152047f, -0.01530375f, 0.22376479f, 0.32816362f, -0.49340177f, -0.63775826f, -0.00734164f, 
    -0.01806731f, 0.06635278f, -0.05858554f, 0.09960125f, 0.03051822f, 0.03645820f, 0.00445813f, 0.05243945f, 
    0.03881374f, 0.09948984f, 0.20659560f, 0.24635975f, 0.06152084f, 0.22739196f, -0.23135482f, 0.09614342f, 
    0.00917596f, -0.01116190f, -0.07125879f, -0.09843471f, 0.09512524f, 0.16480993f, 0.11527536f, -0.29126269f, 
    0.01784607f, 0.00765877f, 0.12221479f, 0.12176894f, -0.04369524f, 0.23727216f, -0.05930042f, -0.09564539f, 
    0.05661947f, -0.01454984f, 0.08851551f, -0.22162841f, -0.04606211f, 0.16318740f, 0.01200710f, 0.02053190f, 
    -0.03702924f, -0.20206483f, -0.11732072f, 0.13333833f, -0.05065759f, 0.02242414f, -0.04490988f, 0.12259069f, 
    -0.11523964f, -0.12110993f, -0.15050526f, -0.03488802f, 0.37683541f, 0.05766889f, 0.00590596f, -0.03556355f, 
    0.01619622f, -0.04505098f, 0.04738384f, 0.02533655f, 0.07438178f, -0.12049043f, -0.03991611f, -0.01605291f, 
    0.06965379f, 0.04605789f, -0.04744140f, 0.03643559f, -0.17933661f, -0.09308954f, 0.27798784f, -0.04145226f, 
    -0.09477577f, 0.08618960f, 0.00765052f, 0.04995481f, 0.09207502f, -0.21931149f, 0.16687742f, -0.12261929f, 
    -0.01302308f, -0.04349175f, -0.03800026f, -0.14891087f, 0.12220862f, 0.07266187f, -0.00905669f, -0.25444207f, 
    -0.16483447f, 0.15054759f, 0.27180773f, -0.15501727f, -0.00334589f, -0.00929567f, 0.01403576f, 0.42261040f, 
    -0.44844234f, -0.11923586f, -0.02947167f, 0.28547606f, -0.14178707f, -0.07535762f, 0.12726881f, -0.09505028f, 
    0.24535190f, -0.36084768f, -0.22588997f, 0.21500286f, -0.01400364f, 0.03563748f, 0.03187006f, 0.01992596f, 
    -0.09362704f, 0.06922532f, -0.02563509f, -0.04736467f, 0.07394581f, -0.07501471f, -0.16561079f, 0.15267047f, 
    0.18690951f, -0.12474628f, -0.05439199f, -0.10673661f, 0.19432078f, -0.16481113f, -0.03428104f, 0.02724869f, 
    0.05924207f, -0.11075813f, -0.11523639f, -0.04653836f, 0.19314794f, 0.08669956f, -0.05959752f, 0.23381402f, 
    -0.06025559f, 0.04205000f, -0.01725391f, -0.03354380f, 0.07545833f, -0.33134755f, -0.19487178f, -0.16566403f, 
    -0.14059059f, -0.08660513f, 0.09886157f, 0.03224307f, 0.03060442f, -0.62634307f, 0.08147079f, 0.13509822f, 
    -0.09796351f, 0.08882996f, -0.00628740f, -0.08986682f, -0.14387168f, -0.06096457f, -0.39690816f, -0.48459876f, 
    -0.11809218f, -0.09482678f, 0.11516158f, -0.05154585f, -0.02010392f, -0.03122366f, -0.14909303f, -0.10543483f, 
    0.21041483f, 0.11258115f, -0.17759848f, -0.18722831f, -0.12670134f, -0.02355930f, 0.00820578f, 0.08665338f, 
    -0.56306344f, 0.07315348f, -0.00890912f, -0.11215453f, 0.15173456f, 0.03824078f, -0.03429893f, -0.01909837f, 
    -0.02883645f, -0.04256663f, -0.33284038f, -0.05626335f, 0.19870333f, 0.09115843f, -0.01929063f, 0.01468383f, 
    0.20850700f, -0.08584551f, 0.17843480f, -0.06442151f, 0.06500346f, 0.00846554f, -0.13714124f, 0.00495455f, 
    -0.05594534f, 0.00594719f, 0.02311509f, -0.18949755f, 0.18002953f, 0.32058686f, 0.05458665f, -0.00826897f, 
    0.02233436f, 0.05883446f, -0.03925426f, 0.08065568f, -0.17307046f, 0.07031021f, 0.15092762f, 0.02339042f, 
    0.04668362f, -0.04854948f, 0.03364162f, 0.09913464f, 0.13623564f, -0.14888242f, -0.31448457f, -0.49479139f, 
    -0.15474209f, -0.12132665f, -0.07326541f, -0.02804407f, -0.28049287f, 0.04732883f, -0.09590600f, 0.05766212f, 
    0.08245762f, -0.04080724f, -0.03188877f, -0.10449165f, 0.10049671f, 0.06054688f, 0.00801046f, -0.89034206f, 
    0.48201206f, -0.10090841f, -0.11872239f, 0.06626989f, -0.05577311f, 0.06931987f, 0.20738448f, 0.05839775f, 
    0.42619130f, 0.00538678f, -0.08949351f, 0.35559174f, 0.08892319f, 0.18475601f, 0.07428229f, 0.10899430f, 
    0.11942786f, 0.14471619f, -0.00102961f, -0.09895194f, -0.05806548f, 0.21959606f, -0.04844353f, 0.01109855f, 
    0.06865363f, 0.09128179f, -0.28257555f, 0.14697798f, 0.06645223f, 0.23011422f, 0.03068917f, 0.28145525f, 
    0.21572387f, 0.12517613f, 0.02966056f, 0.11296013f, -0.03539165f, 0.03966856f, 0.06999368f, 0.16465908f, 
    0.09632204f, -0.09276701f, 0.04515967f, 0.17604791f, -0.53833795f, -0.09259786f, -0.01532519f, -0.09065443f, 
    -0.17848283f, -0.08244731f, -0.10246578f, -0.38659212f, 0.00624849f, 0.02317116f, 0.16380005f, 0.20228052f, 
    -0.06299974f, 0.14635892f, 0.14574777f, 0.13059445f, 0.06806480f, 0.24585140f, -0.63965696f, -0.58038205f, 
    0.27778780f, 0.20194639f, 0.05043720f, 0.04469306f, -0.11899321f, -0.01835439f, -0.08507993f, 0.38562724f, 
    -0.05545381f, -0.58002567f, 0.04505067f, -0.02621228f, 0.18987454f, 0.07865756f, -0.00202008f, 0.05898750f, 
    -0.05641304f, -0.02058436f, 0.05188028f, 0.04763792f, 0.11006171f, -0.01662551f, -0.03395643f, 0.00567290f, 
    -0.00026631f, 0.23480780f, 0.12578163f, -0.19073914f, -0.15389194f, -0.04875293f, 0.00162880f, -0.13105947f, 
    -0.01434308f, 0.15477623f, -0.49027371f, -0.09291324f, 0.21441205f, -0.19737665f, 0.01682256f, 0.11409738f, 
    -0.05377126f, 0.02413545f, -0.05312959f, -0.17512028f, 0.14423759f, 0.12306499f, 0.11255405f, 0.08995060f, 
    -0.07717635f, 0.04595429f, -0.12004495f, 0.14262316f, 0.10369809f, 0.19934137f, -0.09458824f, -0.11497362f, 
    -0.19233702f, -0.05982919f, -0.05122336f, -0.19913529f, 0.02113459f, -0.20853302f, -0.26574305f, -0.01684819f, 
    0.04399457f, 0.17593661f, -0.02964673f, -0.19275738f, 0.06748792f, 0.08417791f, 0.30434525f, -0.03248100f, 
    -0.37065122f, -0.12668748f, 0.06492323f, -0.05907699f, 0.04995860f, 0.08491348f, 0.22870097f, -0.43669161f, 
    0.14342090f, -0.21634226f, 0.36096931f, -0.03114585f, 0.08362568f, -0.11768484f, -0.00606767f, -0.06146644f, 
    -0.62157601f, -0.03212586f, -0.46325010f, -0.03681369f, 0.10994936f, 0.07101057f, 0.02965234f, 0.14178941f, 
    -0.02003533f, -0.06859872f, -0.16359548f, 0.05497734f, 0.06371398f, 0.26376167f, 0.04303284f, 0.05671973f, 
    0.09928697f, -0.06466711f, 0.13985622f, -0.30946407f, -0.31107172f, -0.15669419f, -0.01568717f, -0.01561692f, 
    0.04752800f, 0.00019299f, 0.09743699f, -0.13673468f, 0.19157487f, -0.06240875f, 0.02398015f, -0.05785872f, 
    0.00013570f, 0.14077598f, 0.14998952f, 0.08195017f, -0.02003885f, 0.12705638f, -0.04503691f, -0.18117532f, 
    -0.06512003f, 0.12414742f, 0.00000651f, 0.07316297f, -0.10700928f, -0.36491606f, -0.22493257f, 0.20446251f, 
    0.36510760f, -0.02180191f, -0.11880562f, -0.03321581f, -0.01798394f, -0.10398787f, 0.20067610f, 0.03703101f, 
    -0.22284704f, -0.00295720f, -0.10121429f, -0.02644656f, -0.00772154f, 0.03866883f, 0.09146503f, 0.19196306f, 
    0.02387442f, -0.00039283f, 0.16961002f, -0.09377486f, -0.08282982f, 0.01560499f, -0.06861617f, 0.26245880f, 
    -0.00654807f, -0.09427404f, -0.06029945f, 0.17432696f, -0.23064196f, -0.18544810f, -0.06953736f, -0.09794348f, 
    0.07061708f, -0.33970055f, 0.19033675f, -0.05984538f, -0.09738839f, 0.25474831f, -0.07245058f, 0.03191692f, 
    -0.02583545f, 0.02047797f, -0.11401891f, 0.03157700f, 0.14800033f, 0.05960718f, 0.04927346f, 0.00875226f, 
    -0.00782485f, 0.06731287f, -0.14507191f, 0.14049993f, -0.05689124f, -0.10411680f, -0.18863325f, 0.01607982f, 
    -0.08638187f, 0.07100973f, 0.14092828f, -0.10503127f, -0.08545442f, -0.05542007f, 0.16791396f, 0.01520776f, 
    0.13995789f, 0.03029352f, 0.05038492f, 0.01454094f, 0.03938027f, 0.08453475f, 0.09896162f, 0.10176559f, 
    -0.06887210f, 0.02945742f, -0.19210497f, -0.06347341f, 0.09501927f, -0.01780131f, -0.28663585f, -0.55781639f, 
    -0.44324324f, -0.02903654f, -0.11825690f, -0.01788077f, -0.12453564f, -0.13756219f, 0.09081318f, 0.18215518f, 
    -0.87006295f, -0.09145979f, -0.13154346f, -0.03430846f, -0.01233069f, -0.05015154f, 0.06290429f, 0.02626368f, 
    -0.02340046f, 0.03820719f, -0.01720127f, -0.03142633f, -0.06297844f, -0.00355967f, -0.00824589f, -0.05119889f, 
    0.03854305f, -0.01022404f, -0.04572101f, -0.02782633f, -0.02795522f, 0.03714150f, -0.02462843f, -0.01520729f, 
    0.02130951f, 0.04495544f, 0.02968020f, 0.04531217f, 0.03558130f, -0.01652023f, -0.06301324f, -0.00029142f, 
    -0.03460263f, -0.06370208f, 0.00898876f, -0.05491415f, -0.01222222f, -0.06326070f, 0.04667073f, -0.04192527f, 
    -0.00719807f, -0.04189697f, 0.04982837f, -0.01638705f, -0.06489657f, -0.00731360f, 0.03202098f, 0.00983175f, 
    -0.06074498f, 0.00811686f, -0.03614223f, -0.00651180f, 0.01281243f, -0.02451334f, -0.00230854f, -0.05235124f, 
    0.02398274f, -0.02555172f, -0.02531971f, -0.04057628f, -0.02067949f, 0.02218563f, 0.04211869f, 0.00024032f, 
    0.05368673f, -0.05332156f, 0.00209202f, -0.05732720f, 0.01602603f, -0.01299151f, 0.00856553f, -0.04489953f, 
    0.04486009f, 0.02791928f, 0.00894848f, -0.00410516f, 0.01184895f, 0.00451111f, 0.03625862f, -0.00920494f, 
    0.03334497f, 0.04063404f, 0.02347176f, 0.01702261f, -0.04995226f, -0.04540802f, -0.03340147f, -0.04728292f, 
    0.00012470f, -0.04223036f, -0.03200484f, -0.05241815f, 0.03384688f, 0.02350600f, -0.02639460f, 0.01951633f, 
    0.00390416f, -0.06087758f, 0.02316735f, 0.02133236f, -0.00459712f, -0.00685990f, -0.04089053f, 0.06078716f, 
    -0.00141606f, -0.03275447f, 0.01832062f, 0.04303572f, -0.04453623f, 0.01288413f, -0.05488892f, -0.03947271f, 
    -0.05661216f, 0.01503307f, 0.04844815f, -0.01508538f, -0.03951885f, 0.00542960f, 0.01563591f, 0.00866412f, 
    0.01010213f, 0.03313682f, -0.01254633f, 0.04448031f, 0.00970107f, -0.01825876f, -0.01433361f, -0.04683843f, 
    -0.03116325f, 0.02463639f, -0.05304531f, -0.02180036f, 0.03897325f, -0.03286342f, -0.04257442f, 0.05606810f, 
    0.00022847f, -0.03958154f, -0.01561609f, 0.01815525f, -0.04960438f, 0.00923062f, 0.03553091f, -0.04378116f, 
    0.04092620f, 0.04547258f, -0.04772388f, 0.01705972f, -0.00986640f, -0.05775912f, 0.02286314f, 0.03845292f, 
    0.00228395f, 0.04462007f, -0.04498138f, -0.03343358f, -0.02215211f, 0.01053169f, -0.02983152f, -0.01176440f, 
    0.04120253f, -0.06451837f, -0.03450343f, 0.00620470f, 0.04164181f, 0.02935678f, -0.04206686f, 0.03713475f, 
    -0.04290291f, -0.02269718f, -0.04289783f, 0.01519249f, -0.01870561f, -0.04725744f, -0.02008137f, -0.04630010f, 
    -0.00243300f, -0.03519518f, 0.04028940f, -0.00894026f, -0.01733660f, 0.00725436f, 0.02325879f, 0.01700989f, 
    -0.00870979f, 0.01596581f, 0.00809046f, -0.03690302f, -0.00789865f, 0.04038736f, -0.03656365f, 0.00200706f, 
    -0.03603798f, -0.05935760f, 0.03982460f, 0.02223632f, -0.03941426f, 0.03243578f, 0.05938578f, 0.02729887f, 
    0.03656431f, -0.01388440f, -0.02764135f, 0.03451912f, -0.05529597f, 0.04763400f, 0.00930237f, -0.00411831f, 
    -0.00517501f, 0.01987067f, -0.02820001f, 0.03344321f, -0.01019783f, -0.03598326f, -0.05470618f, -0.07075047f, 
    0.00110664f, -0.01989721f, -0.03518204f, 0.00125655f, -0.01799728f, -0.05390972f, -0.02458568f, -0.00780378f, 
    -0.01039173f, -0.03388553f, -0.06801002f, 0.00476382f, 0.03714983f, -0.00780164f, -0.02389420f, 0.03344158f, 
    0.01662189f, -0.05629839f, -0.00045730f, 0.02951432f, 0.03595042f, -0.04235645f, 0.02672604f, 0.04476484f, 
    -0.01123286f, 0.02934934f, 0.01536147f, -0.04191877f, 0.02423458f, -0.00563027f, -0.05789182f, -0.00357258f, 
    -0.03011870f, 0.02782757f, -0.03109650f, -0.02600687f, -0.01966617f, -0.05787515f, 0.01789571f, -0.05209498f, 
    0.00948241f, -0.05632297f, -0.05036600f, 0.01464652f, 0.04038158f, -0.01578370f, 0.01988610f, -0.06260050f, 
    -0.01356613f, -0.04057625f, 0.04501331f, -0.00846263f, 0.01219413f, 0.06030102f, 0.01939912f, 0.04314572f, 
    -0.01168410f, -0.01781543f, -0.01084996f, -0.03625762f, 0.03644417f, 0.00695318f, -0.02007012f, -0.02718597f, 
    0.00611490f, 0.03053512f, -0.00874264f, -0.00821419f, 0.02937400f, -0.04191743f, -0.06636604f, -0.04568372f, 
    -0.02447859f, -0.02062126f, 0.00681894f, 0.01894461f, -0.02924522f, -0.01671663f, 0.01297586f, -0.00550523f, 
    -0.12880068f, -0.03983635f, 0.22064495f, 0.17220400f, 0.03941109f, -0.01898720f, -0.14873566f, -0.13553889f, 
    0.14354432f, 0.12511241f, -0.01548963f, -0.09213455f, 0.19251159f, -0.04935737f, 0.02472062f, -0.00375615f, 
    -0.11020004f, 0.15608706f, 0.42101192f, -0.01041081f, -0.13101739f, -0.17811000f, 0.07699072f, 0.02335638f, 
    0.01224271f, 0.06004671f, -0.05243950f, -0.14697504f, 0.07580807f, -0.07368235f, -0.00515042f, 0.01386173f, 
    0.04386498f, 0.03432165f, -0.08438858f, 0.14144832f, 0.31984162f, -0.03950784f, -0.41542956f, -0.18937269f, 
    -0.13404378f, 0.05370578f, -0.01685939f, 0.01596431f, -0.02994991f, -0.06266820f, 0.02560146f, 0.01613753f, 
    -0.11748413f, -0.15891327f, 0.14671585f, 0.01268142f, -0.00751033f, 0.05247485f, 0.14871337f, -0.11796878f, 
    -0.01608869f, -0.03277705f, -0.05774980f, 0.00214568f, 0.10273175f, 0.01777034f, -0.13766728f, -0.08844762f, 
    -0.03373896f, -0.00776963f, 0.00479036f, -0.04413710f, -0.11463227f, -0.00290957f, -0.09722076f, -0.01126030f, 
    0.04650154f, -0.00228169f, -0.04471483f, 0.01395990f, 0.00550440f, 0.00901840f, -0.06508065f, 0.13831249f, 
    -0.01435214f, -0.25565392f, -0.33396357f, -0.01529243f, -0.14078985f, 0.02509447f, -0.09614289f, -0.01493013f, 
    -0.04160172f, -0.03128411f, 0.12057161f, 0.12553419f, 0.33605477f, 0.05545971f, -0.11684327f, -0.06696462f, 
    -0.16929249f, -0.05481356f, 0.05221607f, 0.12262763f, 0.18903758f, 0.06696695f, 0.05124281f, 0.02738609f, 
    0.01122176f, 0.12455533f, 0.04636577f, 0.01081706f, -0.43085343f, -0.13758138f, 0.21666150f, -0.03400696f, 
    0.12279478f, -0.17601322f, 0.08435780f, 0.01842644f, 0.09960724f, 0.05991028f, 0.04926706f, 0.01778503f, 
    0.15160118f, -0.19261555f, 0.02208311f, -0.06139442f, 0.00490140f, 0.16200770f, -0.32944465f, -0.36493552f, 
    -0.02309118f, 0.06723814f, -0.14301363f, 0.02876377f, -0.23039496f, -0.02515738f, -0.03427496f, 0.24307047f, 
    0.09920842f, -0.11105950f, -0.06362627f, -0.07666212f, 0.20024055f, -0.05579391f, -0.00975880f, -0.07094611f, 
    0.13012342f, 0.15417808f, 0.01262551f, -0.10438297f, -0.08540425f, -0.03702963f, 0.10798437f, 0.22518462f, 
    0.30218682f, -0.08323438f, -0.18360528f, 0.09180968f, -0.24301942f, -0.00172274f, -0.10289530f, -0.07249576f, 
    0.23743539f, 0.16547796f, -0.56404901f, -0.19038820f, 0.12095681f, 0.14850152f, -0.14725824f, -0.05439415f, 
    -0.09011434f, -0.00551506f, 0.05909104f, -0.04416698f, -0.04480133f, -0.01089365f, -0.23648170f, -0.08435217f, 
    -0.10708351f, 0.15575735f, 0.02197813f, -0.00648325f, 0.10397965f, -0.13658072f, -0.30670038f, -0.08001538f, 
    -0.03861158f, 0.09860780f, 0.05391192f, -0.02350924f, 0.03414194f, -0.27584606f, 0.08927909f, 0.62928629f, 
    -0.01648192f, 0.10785056f, -0.12012441f, -0.03824050f, 0.11223368f, 0.07307474f, -0.13346614f, 0.08158178f, 
    0.26420319f, -0.07676048f, 0.03762181f, -0.11528356f, 0.13289826f, 0.14157198f, 0.01536436f, -0.05399690f, 
    0.16149302f, 0.16366628f, -0.23693012f, 0.15008715f, 0.25043669f, 0.12351361f, 0.04164774f, 0.12229153f, 
    -0.26489639f, 0.10976452f, 0.84852159f, -0.06172885f, 0.22324842f, -0.20279899f, 0.05046596f, 0.06985667f, 
    0.04285465f, -0.20292372f, -0.10788960f, 0.29489359f, 0.05089696f, -0.03928676f, -0.12520579f, 0.11289683f, 
    -0.03394139f, 0.03771218f, 0.06440463f, 0.02410700f, 0.14781044f, -0.18451585f, -0.19593567f, -0.11199513f, 
    0.15102684f, 0.16342574f, -0.06782947f, -0.21993062f, 0.13248411f, -0.09990620f, 0.09961965f, 0.02362862f, 
    -0.14652814f, 0.16873705f, 0.07697094f, 0.02301202f, -0.14169252f, 0.27251828f, 0.02657799f, 0.00208434f, 
    0.04177226f, 0.01184040f, 0.05601295f, 0.05202802f, -0.07830700f, -0.34837979f, 0.02630699f, 0.13079722f, 
    -0.00620097f, -0.08427549f, -0.03657772f, 0.06127997f, 0.10547284f, 0.06609204f, 0.36093849f, -0.04678932f, 
    -0.20846201f, -0.07182736f, 0.02020425f, -0.04683667f, -0.04248500f, -0.12451802f, -0.11040648f, 0.25652122f, 
    0.37548837f, 0.18940461f, -0.02862647f, -0.04616541f, -0.34287611f, -0.02140490f, -0.18585229f, -0.13278702f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.06805038f, -0.01887172f, -0.02446135f, -0.00718818f, 0.01154078f, 0.04087013f, -0.02331658f, 0.09355506f, 
    -0.01864071f, 0.12991439f, -0.05550497f, -0.04362728f, -0.01561636f, 0.18117468f, 0.19804044f, -0.04823259f, 
    -0.00378998f, -0.03630346f, -0.01395601f, 0.02555291f, 0.03854236f, -0.01784434f, -0.20802695f, 0.08084941f, 
    0.21358441f, 0.03766389f, 0.04252253f, 0.30008593f, 0.25642571f, 0.21326476f, -0.03801401f, 0.05705648f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.14752817f, 0.10511766f, -0.01982794f, 0.12486468f, 0.14326955f, 0.16763496f, 0.09329708f, -0.29426688f, 
    0.10511950f, -0.22778593f, -0.20025626f, 0.13613242f, -0.34171617f, 0.29692766f, -0.29653174f, 0.15999550f, 
    -0.12182947f, 0.10576151f, 0.20034049f, -0.06637288f, -0.11284000f, 0.44367471f, -0.18204397f, 0.29724631f, 
    0.11015058f, 0.16272606f, -0.16681969f, 0.08043835f, -0.32996586f, 0.37239081f, -0.10180296f, 0.19332191f, 
    0.30577084f, -0.14756468f, 0.11516406f, 0.07513867f, -0.16509928f, -0.03850884f, 0.07071681f, -0.34185109f, 
    -0.07874338f, -0.06630737f, 0.09630709f, -0.11107983f, -0.41603413f, 0.10914633f, 0.36508784f, -0.08997627f, 
    0.03861284f, -0.16222784f, -0.08927943f, -0.22608885f, 0.01263637f, 0.10491835f, -0.00094788f, 0.49990544f, 
    -0.17999320f, -0.11796988f, 0.07497068f, 0.28779992f, 0.04582501f, -0.17348853f, 0.04825724f, -0.10286928f, 
    0.35916063f, 0.10904549f, -0.02553337f, 0.07508019f, 0.15315707f, -0.02533435f, -0.02948680f, 0.35829073f, 
    0.09628053f, 0.20204915f, -0.04623299f, -0.07644302f, -0.31830278f, 0.08626881f, -0.17252260f, -0.11255074f, 
    0.02751969f, 0.00211343f, -0.01979459f, 0.05790523f, 0.13317442f, -0.15656443f, 0.37978911f, 0.05097857f, 
    -0.28505313f, -0.16445361f, 0.01889176f, -0.18347545f, 0.08708373f, 0.07757390f, -0.16823457f, 0.36967391f, 
    -0.05152573f, -0.02651956f, -0.08155364f, -0.05936738f, 0.09221184f, -0.10803230f, -0.00871200f, -0.21497343f, 
    -0.00650945f, -0.08653775f, 0.16092394f, 0.01616626f, 0.85431540f, 0.15994585f, -0.15856282f, -0.13398010f, 
    -0.12861045f, -0.01221038f, 0.29433495f, 0.30446079f, 0.13293366f, 0.29350609f, 0.17679903f, -0.69988590f, 
    0.33036110f, -0.15948880f, 0.09592304f, -0.29993805f, -0.54181629f, -0.13897525f, 0.00645268f, 0.01109267f, 
    -0.07139795f, 0.04315777f, 0.14155217f, 0.02941587f, -0.00833715f, 0.12656535f, 0.10704031f, 0.03597111f, 
    0.12055577f, -0.00007347f, -0.28773460f, -0.02964626f, -0.44450715f, 0.31441218f, -0.19828871f, -0.05500875f, 
    -0.17080848f, 0.00584549f, 0.10587049f, -0.21416439f, -0.18543044f, 0.22487128f, 0.05275463f, -0.03237851f, 
    0.12958378f, 0.02555643f, -0.14124060f, 0.37788430f, 0.10946424f, 0.65920019f, 0.03864276f, -0.02548823f, 
    -0.13957420f, 0.18455441f, -0.02273330f, -0.08538940f, -0.00655285f, -0.02721698f, -0.02095317f, -0.00372793f, 
    -0.16128159f, 0.49227953f, -0.29187515f, -0.14791299f, -0.01598087f, 0.30136663f, 0.03160144f, -0.00844986f, 
    -0.04059476f, -0.13265166f, -0.18720227f, -0.31408554f, -0.12363748f, -0.21454354f, -0.04677492f, 0.17889348f, 
    0.32969773f, 0.41858464f, 0.02186928f, 0.17528158f, 0.06780811f, 0.57355297f, -0.05759257f, -0.13480815f, 
    0.32965025f, -0.07090076f, 0.17046542f, -0.15375829f, -0.12645254f, 0.03845939f, 0.12736669f, 0.25326842f, 
    0.06520706f, 0.21479020f, -0.38634944f, 0.08918121f, 0.09073012f, 0.07896934f, -0.14017275f, -0.06494188f, 
    -0.04312217f, -0.08221524f, 0.29361293f, -0.25550777f, 0.11909706f, -0.05743550f, 0.04326416f, 0.11915965f, 
    -0.25499728f, -0.04430170f, -0.16668700f, 0.01719511f, 0.13718480f, -0.07736941f, -0.01710904f, 0.62111223f, 
    -0.17301443f, -0.13891210f, 0.16792038f, -0.03721860f, -0.03264151f, 0.02848830f, 0.07114895f, 0.11459071f, 
    -0.03719748f, 0.01212915f, -0.11523086f, 0.00128649f, -0.19330382f, 0.09290332f, -0.09898575f, 0.05130871f, 
    -0.13898380f, 0.14403167f, -0.13886255f, -0.12066388f, 0.03399323f, -0.13187082f, -0.04582715f, -0.12455163f, 
    0.05055673f, -0.12261680f, -0.11921824f, 0.00424640f, -0.12914395f, 0.16144870f, 0.09211899f, -0.15781781f, 
    -0.02518608f, 0.08542140f, 0.07473029f, 0.00280505f, -0.10023250f, -0.02655359f, -0.09334204f, 0.24595216f, 
    -0.04949259f, 0.30271533f, -0.12123249f, 0.02124657f, 0.42571038f, 0.43959883f, -0.24486859f, -0.08400147f, 
    -0.00940298f, -0.01798023f, 0.13158335f, 0.10689462f, -0.02997269f, -0.15137014f, 0.06467915f, 0.18819714f, 
    -0.09687708f, 0.02828840f, -0.06501791f, -0.67942750f, 0.19891891f, -0.26742452f, 0.09119102f, 0.00107319f, 
    -0.05101767f, -0.03678942f, -0.02528821f, 0.00543861f, 0.00155952f, -0.11618487f, 0.09398912f, -0.04170552f, 
    0.03644959f, 0.01052558f, 0.09420200f, -0.02534541f, -0.58196896f, 0.12608109f, 0.37275201f, -0.06930764f, 
    -0.01239535f, -0.14640845f, -0.24425647f, -0.13939168f, -0.14472735f, -0.16641149f, 0.18501090f, 0.05217747f, 
    -0.15127070f, -0.14575091f, 0.08651962f, 0.50352484f, 0.27148575f, -0.08171064f, -0.15881512f, 0.03991622f, 
    0.04230914f, 0.14080867f, -0.01698466f, -0.06466272f, 0.15499339f, -0.17784697f, 0.07841010f, -0.22355711f, 
    -0.08525283f, 0.09116898f, -0.09542026f, -0.02373443f, -0.69147313f, -0.05406631f, -0.35288909f, -0.11226471f, 
    0.14985709f, 0.02669773f, 0.23887616f, 0.25699568f, 0.04939515f, -0.08887450f, 0.25502500f, 0.42762244f, 
    0.16521034f, -0.05432837f, -0.04614478f, -0.19693016f, 0.49433938f, -0.04738595f, -0.11854959f, -0.29343534f, 
    0.21805179f, 0.11391251f, -0.11006975f, -0.11574308f, 0.16725214f, 0.05468656f, 0.09993587f, -0.02156078f, 
    0.10232852f, 0.17312491f, -0.11890180f, 0.09471297f, 0.23871408f, -0.15452826f, 0.35072833f, -0.02472043f, 
    0.07063961f, -0.16934653f, 0.05325095f, -0.00822535f, 0.00683555f, -0.32206446f, -0.10179887f, -0.17194667f, 
    0.35041007f, -0.20180075f, -0.16867158f, 0.39441431f, -0.16293272f, -0.07974371f, -0.11071245f, 0.27789384f, 
    0.08607075f, 0.07612518f, -0.15661380f, 0.12852067f, -0.01838253f, 0.03136089f, 0.06246284f, 0.01446247f, 
    0.04633524f, 0.21400672f, 0.11011352f, -0.10115429f, 0.82076401f, 0.35109723f, -0.21780890f, 0.06681467f, 
    0.01642271f, 0.10842875f, 0.14411280f, 0.08293617f, -0.06465990f, -0.37470400f, 0.34826523f, 0.03613644f, 
    0.17487566f, -0.21434245f, -0.15526468f, -0.57292795f, -0.34788376f, -0.05608525f, 0.18115498f, -0.42261666f, 
    -0.02009225f, 0.00560691f, 0.05546355f, 0.04117593f, 0.09882437f, 0.13997971f, -0.05889912f, -0.10039162f, 
    0.12883750f, 0.26622671f, -0.35449433f, 0.06718102f, 0.69732440f, -0.02128318f, 0.44046742f, 0.14987318f, 
    -0.14482267f, -0.10068193f, -0.23969305f, 0.12448432f, -0.15749355f, -0.06963604f, -0.13947423f, 0.30521712f, 
    0.19238855f, 0.18345213f, -0.05488115f, 0.23085003f, 0.49535102f, -0.02562645f, -0.14578879f, -0.40759459f, 
    -0.07470804f, 0.03874153f, 0.13462642f, -0.05919647f, 0.02721268f, 0.08387347f, -0.03789366f, 0.01894835f, 
    -0.05235486f, -0.06986014f, -0.09272407f, -0.02162201f, -0.07462376f, -0.14244683f, -0.14594051f, -0.10363693f, 
    0.02817702f, 0.06802685f, -0.18340813f, 0.12023436f, 0.10961699f, 0.02675643f, -0.17059185f, -0.14362811f, 
    0.06619951f, 0.06141616f, -0.00001608f, -0.11473621f, 0.08172214f, 0.06926282f, -0.00473505f, 0.03311911f, 
    -0.02683788f, 0.11539699f, 0.14837217f, -0.00530549f, 0.13798112f, -0.14733033f, 0.15603015f, -0.56780148f, 
    -0.12348083f, -0.01322565f, -0.46522963f, -0.16589983f, -0.41941303f, 0.10360312f, -0.19183365f, -0.01813786f, 
    -0.12447938f, -0.10438805f, -0.00603417f, 0.20669678f, -0.00463522f, 0.22850703f, -0.02108404f, 0.65006608f, 
    0.13595550f, 0.26396254f, -0.09471091f, 0.07704681f, 0.57040089f, -0.21813156f, 0.17210931f, 0.00223901f, 
    -0.11318767f, 0.13018627f, -0.09763760f, -0.13848640f, -0.09678967f, -0.00814054f, 0.10064376f, -0.12992111f, 
    -0.12921458f, -0.14036083f, 0.08124530f, 0.05508032f, -0.14268911f, 0.03384379f, -0.05706839f, -0.14780377f, 
    0.14378844f, 0.03411081f, 0.03387533f, -0.14354913f, -0.17393778f, 0.05411760f, -0.11781151f, -0.06950784f, 
    -0.13354720f, -0.07199005f, -0.01244639f, -0.04530355f, -0.06265109f, -0.05817942f, -0.13218141f, -0.15289508f, 
    0.01353133f, -0.03654259f, 0.10169902f, 0.14454578f, -0.11235184f, -0.03026224f, -0.14161918f, -0.18384139f, 
    0.05354973f, 0.08422750f, -0.60138118f, -0.12055309f, -0.13699754f, 0.31077927f, -0.07844897f, 0.06341333f, 
    0.06862151f, -0.06654646f, 0.00860746f, 0.32480422f, 0.01264802f, -0.09314848f, -0.27971914f, -0.30609730f, 
    0.30833068f, 0.61127293f, 0.10407728f, 0.00010130f, 0.31832528f, -0.10072692f, -0.07328891f, 0.02173434f, 
    0.28666794f, -0.06170069f, 0.11528245f, 0.01220674f, -0.12693481f, -0.04438136f, 0.11851658f, -0.60453320f, 
    -0.11679203f, -0.12167343f, -0.01296617f, 0.08795634f, 0.45326653f, 0.30691314f, 0.12366652f, -0.01624432f, 
    0.13901001f, 0.03973240f, -0.06127072f, 0.10620156f, 0.08729576f, 0.12285682f, -0.24547482f, 0.57144946f, 
    -0.03750585f, 0.12436406f, 0.14335428f, -0.17723332f, -0.01512020f, 0.10819295f, -0.02480454f, -0.09660941f, 
    0.10237274f, -0.01141005f, 0.00162342f, -0.07794370f, 0.03214610f, 0.01162766f, 0.06148881f, -0.19772024f, 
    -0.16513288f, -0.08994474f, -0.47029507f, 0.11872786f, -0.34754148f, 0.20975547f, 0.07257957f, 0.14776467f, 
    0.15197673f, -0.10032674f, 0.06758363f, 0.27914354f, -0.17030592f, -0.06446580f, 0.33151272f, 0.33771905f, 
    -0.23058574f, -0.50045365f, -0.17977138f, 0.27650839f, 0.09828499f, -0.21342464f, 0.06225705f, 0.07658848f, 
    -0.31346455f, 0.08293129f, -0.15177700f, 0.06561548f, -0.09465688f, -0.07300885f, 0.07545640f, 0.05213338f, 
    0.10236327f, 0.06735416f, 0.04006171f, 0.14023350f, -0.34081557f, 0.00315185f, -0.11299904f, -0.15200227f, 
    -0.09164200f, -0.11356736f, -0.01167439f, 0.21776539f, 0.05308398f, -0.10432606f, 0.11708055f, -0.39913386f, 
    0.25857708f, 0.19893771f, -0.10842427f, 0.43304485f, 0.04542460f, 0.38572502f, -0.05240735f, -0.25878108f, 
    -0.03057449f, 0.09022500f, -0.15112169f, -0.16578352f, -0.16519848f, 0.10328010f, 0.17781737f, -0.42004284f, 
    0.02815921f, -0.20961832f, 0.02453370f, -0.12307972f, 0.52818716f, -0.02162584f, 0.04346062f, -0.08537402f, 
    -0.05888977f, 0.15355882f, -0.09849093f, 0.15948021f, 0.08268765f, 0.20226231f, -0.21059565f, 0.36088428f, 
    0.30750850f, 0.02307975f, 0.06105601f, 0.47510219f, -0.20258541f, 0.21103793f, -0.16367657f, -0.01711531f, 
    0.11446054f, 0.07283413f, -0.11432471f, 0.03089601f, -0.12537037f, 0.12758133f, 0.16133253f, 0.04277428f, 
    -0.10395788f, -0.26621246f, -0.02505643f, 0.06754056f, 0.04274872f, 0.15180621f, 0.20390919f, 0.00577417f, 
    0.07743102f, 0.02876162f, 0.16563143f, 0.28021225f, 0.12667575f, -0.17218995f, 0.16896312f, -0.22855957f, 
    0.11318799f, -0.16989844f, 0.12673411f, 0.04659208f, 0.25601864f, -0.50818670f, 0.14155625f, 0.34969664f, 
    -0.09313236f, 0.07072723f, -0.01133050f, -0.10560098f, 0.14147960f, 0.10658409f, 0.14466557f, -0.09556603f, 
    0.09879421f, -0.13312070f, 0.08741387f, -0.05936706f, 0.04301089f, 0.26846558f, -0.06537703f, 0.08849099f, 
    0.17006686f, -0.03654513f, 0.28166109f, 0.07074656f, 0.08879115f, 0.29555809f, 0.02617870f, 0.25130013f, 
    -0.05825085f, 0.05668580f, -0.14069636f, -0.15964216f, -0.13219991f, -0.43004614f, 0.15683798f, 0.19418943f, 
    0.27248597f, 0.04098517f, 0.01485676f, 0.10425875f, 0.01825264f, -0.05265328f, 0.13464105f, -0.09362184f, 
    -0.12196464f, -0.04364647f, 0.11471588f, 0.13998325f, -0.00474896f, 0.24860796f, 0.10564648f, -0.14628932f, 
    0.03566443f, 0.17189801f, -0.10925872f, -0.12901781f, 0.13782269f, -0.10252745f, -0.04319555f, 0.50775260f, 
    -0.05845066f, -0.00959097f, -0.06219169f, -0.16691715f, -0.09093538f, 0.08247373f, -0.04849878f, -0.29052636f, 
    -0.11785934f, -0.01520570f, -0.00972937f, -0.09217126f, -0.11980962f, 0.15730497f, 0.01844055f, 0.42821702f, 
    0.01661807f, 0.24879809f, -0.37844256f, -0.00283545f, 0.11831829f, 0.14319035f, -0.06237265f, -0.17052463f, 
    -0.07246097f, -0.02242910f, 0.08375748f, 0.19714053f, -0.16950126f, -0.57097805f, 0.23008676f, -0.19644354f, 
    -0.09756588f, -0.21202002f, 0.11350974f, -0.00153654f, 0.03002503f, 0.18840371f, -0.10974547f, 0.20219357f, 
    0.36510611f, 0.12151413f, 0.09801771f, -0.03283886f, 0.10358457f, -0.14790623f, -0.16479754f, 0.05257124f, 
    0.17640807f, -0.12501544f, -0.06384908f, -0.05910111f, 0.25333437f, 0.14195319f, 0.14782982f, 0.11223234f, 
    0.09896872f, 0.08487819f, 0.24401550f, -0.09754624f, 0.02718581f, -0.04166952f, -0.08881935f, 0.50748491f, 
    -0.18082896f, -0.07195417f, 0.16986871f, -0.24449901f, -0.29113013f, -0.01542079f, 0.13784666f, 0.32638061f, 
    0.22818537f, 0.08970080f, -0.11634020f, 0.01083302f, 0.02065590f, -0.03897795f, 0.15275373f, 0.03124377f, 
    0.08609574f, 0.21337992f, -0.01378504f, -0.06146355f, -0.00155884f, 0.25985438f, 0.17237578f, -0.12194443f, 
    -0.13098295f, -0.15650724f, -0.22174641f, -0.04014232f, -0.09700719f, -0.14592756f, 0.03467578f, -0.24733752f, 
    -0.10554734f, -0.05614023f, -0.01097461f, 0.18277718f, 0.24839139f, -0.02162910f, -0.16704848f, 0.41214743f, 
    -0.06112475f, 0.15069921f, 0.07547086f, 0.05623718f, 0.10067727f, -0.03623826f, -0.01904433f, -0.19514214f, 
    0.08891280f, -0.00907859f, 0.11534382f, 0.08569722f, 0.12567841f, -0.00225267f, -0.18199264f, -0.04275069f, 
    -0.05808508f, -0.07111908f, -0.12326122f, -0.21389450f, 0.12436180f, 0.06641968f, -0.03625810f, -0.04057298f, 
    0.09357099f, 0.08087139f, -0.11305228f, -0.07080597f, -0.01946151f, -0.08009692f, 0.07569640f, 0.09365667f, 
    -0.00124422f, -0.09082071f, -0.06268425f, 0.12589574f, -0.16506813f, -0.07972061f, 0.04128331f, -0.10747468f, 
    -0.02981159f, 0.09952009f, -0.06353000f, 0.00140383f, 0.03292487f, 0.22759904f, -0.05377006f, -0.10094580f, 
    -0.11812556f, -0.06718201f, 0.15058297f, -0.16622430f, 0.07674917f, 0.13330516f, -0.32081717f, 0.06985476f, 
    0.21651529f, 0.36582708f, 0.10586904f, 0.21331504f, -0.10697746f, 0.16313969f, 0.12386236f, -0.02665449f, 
    0.12202998f, 0.17624122f, -0.02799071f, -0.16465020f, -0.12242959f, 0.05320774f, 0.07610366f, 0.08601167f, 
    0.02624628f, -0.17121513f, 0.05958594f, 0.00296261f, 0.05409423f, -0.02697391f, 0.02678289f, -0.16042554f, 
    0.06029399f, 0.10276756f, -0.13829289f, 0.08049492f, -0.12277318f, -0.18789867f, -0.15221368f, -0.03417884f, 
    -0.11027917f, -0.05311977f, 0.07195345f, -0.10733873f, 0.09169734f, 0.00708958f, -0.13194227f, 0.01965718f, 
    -0.37107688f, 0.08284576f, -0.05921827f, 0.16366649f, -0.02655751f, -0.08393046f, 0.15754685f, 0.02371928f, 
    0.00658005f, 0.10857725f, -0.48993787f, 0.14151169f, -0.36057025f, 0.19504212f, -0.16244172f, 0.13690209f, 
    0.15983705f, 0.17392664f, 0.03314112f, 0.21980028f, 0.01491389f, -0.06535242f, -0.06365448f, -0.07251882f, 
    -0.08658735f, 0.36712649f, -0.18162096f, 0.54584670f, 0.59469897f, 0.05110960f, 0.05841875f, -0.00135128f, 
    -0.04344582f, -0.05569989f, 0.16061237f, -0.15353164f, -0.13999249f, -0.05043713f, 0.02644978f, -0.18100345f, 
    -0.14894685f, -0.16499908f, -0.27277020f, -0.12609595f, -0.03672463f, 0.33037129f, -0.23346142f, -0.15893151f, 
    0.01621903f, 0.06649078f, 0.20538118f, 0.51789451f, 0.10591164f, 0.29248938f, -0.08463542f, 0.07559592f, 
    0.32510078f, -0.04943066f, 0.08494806f, -0.21451667f, -0.03660198f, 0.17835122f, 0.14764254f, -0.16141461f, 
    0.24944310f, 0.05213235f, 0.00178396f, -0.05929264f, -0.16954169f, 0.12478979f, 0.08610784f, 0.05359522f, 
    0.13838521f, -0.01292211f, 0.08339688f, 0.08913222f, 0.25659007f, -0.00496269f, -0.01294763f, 0.02121780f, 
    -0.04782125f, 0.16665114f, -0.21241328f, 0.21951172f, -0.04146427f, -0.13896704f, 0.08231262f, -0.42476606f, 
    -0.18926387f, -0.28266653f, 0.13209260f, -0.15467718f, -0.31534371f, 0.33506727f, -0.01648278f, -0.13516036f, 
    -0.02870944f, -0.00832198f, -0.00247729f, 0.05997881f, -0.07330051f, 0.08323841f, 0.07962617f, 0.13167635f, 
    -0.07485469f, 0.11604387f, 0.00564326f, 0.14353845f, 0.20210664f, 0.26548183f, -0.06450488f, 0.11751667f, 
    -0.11363304f, -0.05703777f, -0.20412052f, -0.31528518f, -0.05285358f, -0.14132695f, -0.10878414f, 0.50289142f, 
    -0.04924355f, -0.04280265f, 0.12101363f, 0.27787870f, -0.25055832f, 0.41517329f, -0.12758729f, -0.14119494f, 
    0.26770836f, -0.14339022f, 0.08739766f, 0.02512900f, 0.08818106f, -0.04815024f, 0.06101983f, 0.49376747f, 
    0.09553453f, 0.39553079f, -0.36935523f, -0.09160955f, -0.21755299f, 0.01288556f, -0.04979640f, -0.05522817f, 
    0.10721306f, -0.13499393f, -0.05088769f, 0.00572826f, 0.16210225f, -0.57046890f, 0.35807750f, 0.05240014f, 
    -0.06337133f, -0.40932366f, -0.13461287f, -0.17186548f, 0.30743384f, -0.09673040f, 0.15229838f, 0.11589782f, 
    0.03849437f, -0.15772308f, 0.00790654f, 0.12000623f, 0.04400133f, 0.05545139f, 0.01188668f, 0.15523288f, 
    0.05564569f, -0.15821369f, 0.04672715f, -0.06881119f, 0.38758007f, -0.29724237f, -0.07362013f, -0.16099137f, 
    -0.09423643f, -0.09863627f, 0.15164097f, 0.20728025f, 0.06438384f, 0.10321143f, 0.06477404f, 0.11303543f, 
    0.35999346f, -0.44476944f, -0.12695496f, 0.11871656f, -0.33717108f, -0.20364535f, 0.03839766f, -0.14236377f, 
    -0.13866620f, -0.12854369f, 0.04894613f, -0.07699836f, -0.02664184f, 0.11196979f, -0.12093520f, 0.22859275f, 
    0.04658315f, -0.10912576f, 0.17378378f, 0.10786969f, 0.33372319f, 0.06445684f, 0.27404478f, 0.07119820f, 
    -0.16660129f, -0.14011960f, -0.12596720f, 0.14986421f, 0.06365082f, -0.34230575f, 0.16287553f, -0.29779720f, 
    0.23223470f, -0.03609575f, 0.01834756f, -0.15913826f, 0.30379632f, 0.01476329f, -0.10944504f, -0.28040066f, 
    0.39824957f, -0.02320899f, -0.12896210f, 0.10761567f, 0.03968282f, 0.02084064f, 0.02819675f, -0.08309162f, 
    0.00726860f, 0.35549593f, -0.60334206f, -0.14688560f, -0.30503094f, 0.08082293f, -0.20156187f, 0.12831125f, 
    0.06160184f, -0.10157605f, 0.26165047f, -0.26977521f, -0.04051287f, 0.03918497f, -0.05459401f, 0.18619545f, 
    0.07131411f, 0.08836278f, 0.08767797f, 0.37535274f, -0.13650391f, 0.35077578f, -0.02803792f, 0.59201115f, 
    0.14626020f, -0.16541642f, 0.06630372f, 0.07648609f, -0.11908717f, -0.06338673f, 0.06087425f, 0.28537300f, 
    -0.04130394f, -0.16522579f, -0.14859761f, 0.01643613f, 0.24768893f, 0.33580723f, -0.15353824f, 0.11927090f, 
    0.04673677f, -0.06291722f, 0.22858833f, 0.28169394f, 0.15636007f, -0.13394798f, 0.24375728f, -0.25881428f, 
    0.07732619f, -0.04476599f, -0.08618806f, -0.44638985f, -0.50265670f, 0.23220368f, 0.11152017f, -0.16816804f, 
    0.39171705f, 0.03332850f, -0.02146738f, 0.05512655f, 0.10502888f, 0.12205158f, -0.01633939f, -0.35432425f, 
    0.09048483f, -0.36547813f, -0.06110802f, -0.00612959f, -0.46487337f, -0.26533905f, 0.07419064f, 0.05407103f, 
    0.05054675f, 0.06880228f, 0.19051810f, 0.27340081f, -0.05795972f, 0.11531832f, 0.21865591f, 0.34790787f, 
    0.14063580f, -0.40373719f, 0.15523715f, 0.22063141f, 0.09119766f, 0.07182050f, 0.07612852f, 0.11452091f, 
    0.08658771f, 0.00089925f, -0.16580784f, -0.05844558f, 0.06093051f, -0.02561183f, -0.17315234f, 0.01501289f, 
    0.04886444f, 0.18889815f, 0.16311239f, -0.05551149f, -0.41020995f, 0.29364410f, 0.04665346f, -0.07637215f, 
    -0.08635679f, 0.08944198f, -0.27857545f, -0.19351527f, -0.15791354f, 0.06541758f, 0.11068232f, -0.11496656f, 
    -0.10332072f, -0.25367913f, 0.12279864f, 0.24706002f, 0.18797871f, 0.03734948f, -0.01759648f, -0.15931427f, 
    -0.24206485f, -0.15837483f, 0.12143350f, 0.17463343f, -0.08208548f, -0.14790078f, -0.12789452f, 0.12487318f, 
    0.06516664f, 0.30986473f, 0.26353136f, -0.02012137f, 0.59567493f, 0.37059069f, 0.00971207f, 0.09050252f, 
    0.09944225f, -0.17071766f, 0.16779080f, 0.23816536f, 0.16490220f, -0.31329229f, -0.04424264f, -0.26420850f, 
    0.13458402f, 0.00862611f, 0.08021763f, -0.41305739f, 0.31399387f, -0.41680768f, 0.01655365f, 0.15061845f, 
    -0.05676010f, 0.00298832f, 0.00496052f, -0.17289722f, 0.11663365f, 0.08688307f, 0.04750538f, -0.16584983f, 
    0.14618526f, -0.08272944f, -0.04597919f, -0.11260319f, -0.09686334f, 0.02051977f, 0.05520171f, -0.00237946f, 
    -0.09014743f, 0.13541146f, -0.12983151f, -0.01593659f, -0.14054884f, -0.15160586f, -0.02955827f, 0.03956557f, 
    -0.18137066f, 0.10377920f, -0.16758478f, -0.15385059f, -0.03708287f, 0.12275916f, 0.00512160f, 0.05631427f, 
    -0.00621103f, 0.15574986f, -0.14018251f, 0.15955457f, 0.08221865f, -0.01113552f, 0.09018696f, 0.30168486f, 
    0.09489642f, 0.24968743f, -0.04980402f, 0.15094994f, -0.42536476f, -0.06146922f, -0.01844198f, 0.03735073f, 
    0.11693066f, -0.06718229f, 0.11835218f, 0.08762877f, 0.04083567f, -0.05613581f, 0.30603907f, -0.32757989f, 
    -0.18167034f, -0.16296087f, 0.04084820f, 0.36945269f, -0.26304585f, 0.35243595f, 0.12606817f, -0.01743686f, 
    -0.17649686f, 0.10284401f, -0.13545033f, 0.11198040f, -0.02621139f, -0.13115174f, -0.07459565f, -0.30867520f, 
    0.05763317f, 0.12407557f, 0.07181437f, 0.08476651f, -0.35523623f, -0.23792824f, -0.11643552f, 0.04680382f, 
    -0.04561161f, -0.10116348f, 0.10626631f, -0.04689308f, -0.15628926f, 0.39616126f, -0.11498732f, 0.34131414f, 
    0.08851728f, 0.05424001f, 0.01601565f, 0.09603649f, 0.15853879f, 0.05093794f, 0.00693194f, 0.01010147f, 
    -0.00450062f, 0.03415481f, 0.07354318f, 0.15461767f, 0.05630450f, 0.16959427f, -0.17159946f, -0.05975479f, 
    0.00462038f, -0.12897056f, -0.02097940f, 0.11714824f, -0.16415365f, -0.13978222f, -0.18229815f, -0.04017633f, 
    0.13495651f, -0.05312745f, 0.05942581f, -0.17335168f, -0.13455357f, -0.07722691f, 0.03441641f, -0.18520905f, 
    -0.00954142f, 0.06756900f, 0.04707127f, 0.10533645f, 0.09356246f, 0.13898979f, -0.06530433f, 0.06734914f, 
    -0.10093614f, -0.14332472f, 0.00183993f, -0.14407670f, 0.15110971f, -0.05918176f, -0.16693731f, 0.19025166f, 
    0.01497994f, 0.18941458f, -0.19633308f, 0.00419331f, 0.24568741f, -0.15030545f, 0.26494795f, 0.04938818f, 
    -0.08975835f, -0.00910863f, 0.10249972f, -0.09847917f, 0.03281614f, -0.06993375f, -0.07625089f, 0.01160984f, 
    0.11455911f, 0.27905884f, -0.15537184f, 0.12728056f, 0.33539000f, -0.11881734f, -0.08989628f, 0.14247769f, 
    -0.24893065f, -0.01286134f, -0.07267010f, 0.08950859f, -0.10238282f, 0.03722768f, 0.01622386f, -0.19952571f, 
    0.06599659f, 0.07334083f, 0.04624904f, -0.09912068f, 0.14076944f, -0.22906144f, 0.00581936f, 0.00497278f, 
    0.03976785f, -0.02174004f, 0.00637256f, -0.22339232f, 0.11243346f, -0.18646613f, 0.10776916f, -0.09472620f, 
    -0.17527698f, 0.05343405f, 0.10508693f, -0.21431662f, -0.05278234f, -0.17933273f, 0.11001655f, 0.06915890f, 
    -0.21520585f, 0.00184585f, 0.04407682f, -0.08940854f, 0.07084362f, 0.00707713f, 0.09299700f, -0.43132725f, 
    0.09641453f, -0.06237435f, -0.19231379f, 0.15610565f, -0.19732447f, 0.17855988f, -0.27164817f, 0.07275799f, 
    0.09401955f, 0.01295813f, 0.17519715f, 0.15725861f, -0.11682536f, 0.41091987f, 0.11920807f, 0.20108287f, 
    0.29926851f, 0.04947634f, -0.01843572f, -0.10126472f, -0.26266110f, 0.35462174f, -0.03024262f, -0.51683533f, 
    0.07490527f, 0.00698782f, -0.17646179f, 0.17615518f, 0.02828195f, -0.03571077f, -0.14983830f, -0.11581543f, 
    0.01519065f, -0.09083959f, 0.25233799f, 0.04123133f, -0.52550572f, 0.21107523f, 0.08575524f, 0.03684495f, 
    0.11607720f, 0.03925353f, -0.04465988f, -0.06881546f, -0.12753609f, -0.06998206f, 0.14279614f, 0.24682805f, 
    -0.24531339f, -0.17836475f, -0.03524758f, -0.11133554f, 0.04792122f, -0.28913844f, -0.02590451f, 0.15027699f, 
    0.10387076f, -0.16183947f, 0.10390566f, -0.00361678f, -0.00414465f, -0.11927014f, 0.15881824f, 0.09474429f, 
    -0.14167665f, 0.18396640f, 0.03636257f, -0.15364307f, 0.36996052f, -0.31651285f, -0.06932048f, 0.09272004f, 
    -0.07875210f, -0.13978453f, 0.01626355f, 0.16409397f, 0.12438126f, 0.00379861f, -0.14645715f, -0.09021625f, 
    0.13881201f, 0.16323325f, 0.00289021f, -0.14595155f, 0.33792669f, -0.09332576f, 0.08134735f, 0.19740690f, 
    -0.10304867f, 0.08758305f, -0.16281553f, 0.05416905f, 0.07827988f, -0.06347127f, -0.12844467f, -0.10216798f, 
    0.08909027f, 0.01811330f, 0.05354394f, 0.13193782f, 0.19944593f, -0.16204458f, 0.09164456f, 0.16473967f, 
    -0.09530209f, -0.08744898f, -0.12627508f, 0.13372819f, -0.03624142f, -0.05101708f, -0.00844828f, 0.03171470f, 
    -0.13552326f, -0.06393166f, 0.14003231f, -0.24055292f, 0.04531443f, -0.15116751f, -0.15906458f, -0.20932341f, 
    0.29873967f, -0.14863104f, -0.05719574f, -0.16202952f, -0.16530469f, 0.10149634f, -0.00046392f, 0.12284521f, 
    -0.04411713f, 0.25855559f, -0.20820458f, 0.11165196f, 0.69301999f, 0.10719554f, 0.19850668f, 0.12976348f, 
    0.03932813f, -0.02194239f, -0.22389464f, -0.25601581f, -0.07366560f, -0.05706623f, -0.13944261f, 0.15199447f, 
    0.21349958f, -0.05427271f, 0.13019451f, 0.38265628f, -0.18708661f, 0.35415539f, -0.14144988f, -0.06303743f, 
    -0.13193579f, 0.09039814f, -0.04340757f, 0.07538687f, 0.06637513f, -0.11534382f, 0.06574935f, -0.00561059f, 
    0.00781192f, -0.12112530f, -0.13641901f, -0.08272786f, -0.06502873f, 0.05227056f, 0.10516483f, -0.12968659f, 
    0.09974300f, -0.10097392f, 0.17448269f, -0.16998424f, -0.00353387f, -0.13800931f, -0.08551549f, 0.15777227f, 
    -0.07145102f, 0.02805962f, 0.12436926f, -0.16524987f, -0.17150062f, -0.16186589f, -0.03170903f, -0.02138093f, 
    -0.34887525f, -0.17506407f, 0.13678288f, 0.16485094f, 0.13070931f, 0.12038843f, -0.15467446f, -0.14509818f, 
    -0.12515709f, -0.18983161f, -0.31032410f, -0.01354011f, 0.15396060f, 0.25672132f, -0.21837822f, -0.17757694f, 
    0.05476950f, -0.04656470f, -0.18878856f, 0.41925421f, 0.07740194f, 0.34767303f, 0.14909111f, -0.01686786f, 
    -0.04901517f, 0.20555726f, 0.08689590f, -0.03851814f, 0.13387421f, 0.30893037f, -0.15121409f, -0.69628131f, 
    0.06422278f, 0.14797767f, -0.09732070f, -0.01810887f, 0.08831383f, 0.16261856f, -0.12363480f, -0.11904997f, 
    -0.03419133f, 0.15090893f, 0.03157207f, -0.07670050f, -0.00295763f, -0.12074806f, -0.14234133f, -0.15562886f, 
    0.09813722f, 0.15054949f, -0.17086159f, -0.18314409f, 0.08419763f, -0.01592021f, -0.17101665f, 0.08832704f, 
    -0.01327438f, -0.09961731f, 0.07515011f, -0.20127802f, -0.21159376f, 0.11647141f, -0.16124249f, 0.05288710f, 
    0.08142613f, 0.04724822f, -0.09951710f, 0.13064039f, -0.04549189f, -0.05324101f, 0.08506739f, -0.44862801f, 
    0.15541895f, -0.30079451f, 0.10463700f, 0.08408649f, 0.33258545f, -0.01779214f, 0.10062910f, -0.16395396f, 
    0.11946484f, 0.13865487f, 0.09258965f, -0.18797830f, -0.04840626f, 0.24107428f, -0.02802725f, 0.10788348f, 
    0.26613483f, -0.01560224f, -0.16824859f, 0.12128711f, -0.15960412f, 0.01486336f, 0.14299692f, 0.22811040f, 
    0.47037730f, 0.04114171f, 0.01589141f, 0.04882559f, -0.15564252f, -0.00406475f, 0.16867888f, -0.15214655f, 
    0.10807845f, -0.22392026f, -0.30761492f, 0.06905488f, 0.01349721f, 0.18362418f, 0.04374807f, 0.09375648f, 
    0.02588283f, -0.09154163f, 0.00199881f, -0.16881958f, -0.14283593f, 0.25447929f, -0.04082760f, -0.03107573f, 
    -0.07063147f, -0.11994115f, -0.09309378f, 0.55648023f, -0.22604831f, 0.13993347f, 0.13655327f, 0.61565077f, 
    -0.10650046f, 0.00714300f, 0.14977962f, -0.12727879f, 0.13616295f, 0.08231200f, -0.09137785f, -0.03977103f, 
    -0.11767279f, 0.31726763f, -0.18224454f, -0.01992972f, -0.54291946f, 0.01213216f, -0.04616121f, -0.13804734f, 
    -0.16095725f, -0.05044377f, 0.08797334f, 0.02908794f, 0.07404319f, 0.22947173f, -0.14846289f, -0.10304235f, 
    0.20086610f, 0.18712530f, 0.13263938f, 0.24444713f, 0.32711270f, 0.24670021f, 0.04487843f, 0.29697266f, 
    0.09077196f, 0.01511540f, -0.10083153f, -0.09379406f, -0.11594779f, 0.15384194f, -0.07622164f, 0.07352728f, 
    0.16601445f, 0.13227157f, -0.10736402f, 0.15327686f, 0.02083340f, -0.17179716f, -0.07220474f, -0.07503418f, 
    -0.03001975f, -0.09258275f, -0.16916892f, 0.07985312f, 0.03220034f, -0.14726503f, -0.02562655f, 0.04864756f, 
    -0.04208209f, -0.20631982f, -0.15815714f, -0.11614195f, -0.16990340f, 0.06479326f, 0.03743129f, -0.16433665f, 
    0.22851180f, -0.12366414f, -0.01707388f, -0.09411617f, 0.00783276f, -0.01406063f, 0.15647244f, -0.12583208f, 
    -0.14169455f, 0.12380715f, -0.71032166f, 0.05845546f, -0.38548043f, 0.31559613f, -0.34957391f, -0.06983845f, 
    0.03258820f, -0.04424861f, -0.04947614f, -0.06449833f, 0.12610181f, -0.10951613f, 0.24433464f, 0.20150475f, 
    -0.18627132f, 0.45424002f, -0.09093781f, 0.11661062f, 0.40776804f, -0.20034897f, -0.09866664f, 0.40463799f, 
    -0.08382610f, -0.03033018f, -0.10250419f, 0.01489870f, 0.09685784f, -0.10872184f, -0.00484558f, 0.15646233f, 
    0.16179256f, -0.30672526f, 0.04335674f, -0.10630000f, -0.06894276f, -0.30241615f, -0.02318862f, 0.03928307f, 
    -0.13834102f, 0.07195607f, -0.18784100f, -0.28634101f, 0.02794132f, -0.04754790f, -0.23637763f, 0.30340651f, 
    0.11845446f, 0.07880230f, -0.12720983f, 0.03532972f, -0.14706060f, -0.08681121f, 0.12965821f, -0.23499230f, 
    -0.07134769f, 0.16699392f, -0.17350605f, 0.01643521f, 0.12968084f, 0.16698499f, 0.13530836f, -0.15582524f, 
    0.05358650f, -0.16541907f, 0.13400045f, -0.11980969f, -0.13357475f, -0.00875660f, -0.13760307f, 0.18047020f, 
    -0.12121953f, -0.10161253f, 0.03691064f, -0.09624015f, -0.04409871f, -0.13440512f, -0.01465081f, 0.04032610f, 
    -0.01459664f, 0.03085450f, 0.11799837f, -0.05748294f, -0.11404382f, -0.13223796f, 0.06239764f, 0.11138309f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.14801711f, 0.09992462f, 0.00697841f, -0.02644315f, 0.39067945f, 0.25365165f, 0.15397024f, -0.06345110f, 
    0.17809467f, 0.18801473f, 0.02667945f, 0.37786248f, 0.02164524f, 0.33673504f, -0.18762459f, 0.27982393f, 
    -0.04673338f, 0.08280372f, -0.05203693f, 0.20175149f, 0.06699647f, 0.18103813f, -0.09124996f, -0.24094853f, 
    0.25743401f, 0.35629070f, 0.13175325f, 0.12884970f, -0.16078842f, 0.16481519f, 0.05373224f, -0.07260589f, 
    0.26373544f, 0.07347808f, 0.32308364f, 0.06515139f, 0.04772984f, 0.01835717f, 0.22591990f, 0.22453374f, 
    0.14708506f, 0.17227520f, -0.04045001f, -0.06137502f, -0.00161188f, -0.03233256f, -0.12159374f, 0.21682486f, 
    -0.15209872f, 0.12255497f, 0.06185120f, 0.05544008f, 0.00867331f, 0.21162345f, -0.14048943f, -0.11473202f, 
    -0.01808850f, 0.06795467f, 0.29318568f, 0.25640747f, -0.14513256f, 0.13330165f, 0.48670226f, -0.17570394f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.61582029f, -0.41270804f, -0.17224365f, 0.22454613f, -0.67902362f, -0.70804346f, -0.50479186f, -0.13148014f, 
    0.12905067f, 0.03519629f, -0.12084434f, -0.30692700f, 0.34070989f, 0.33588707f, 0.00994030f, -0.19896369f, 
    -0.01861954f, -0.14350481f, 0.19649212f, 0.20675273f, 0.02622615f, -0.00379639f, 0.07258302f, 0.03015924f, 
    -0.24523078f, 0.15347536f, -0.27504343f, -0.08690683f, -0.01367776f, -0.42917380f, -0.00946544f, -0.36933151f, 
    0.18285541f, 0.39095783f, 0.02375001f, -0.07437265f, 0.11093301f, 0.34595898f, -1.01212549f, 0.24194539f, 
    0.05801269f, 0.00749381f, 0.19550434f, 0.07739295f, -0.01304857f, 0.03678266f, -0.04941045f, -0.15280089f, 
    -0.09069934f, 0.11755706f, 0.09853502f, 0.06404516f, 0.09869453f, -0.09847657f, -0.08911304f, 0.46348596f, 
    0.03094528f, -0.20875090f, -0.45953637f, -0.31321213f, -0.00972163f, -0.68666023f, -0.25611496f, -0.01113087f, 
    -0.07238409f, 0.27527294f, -0.45111403f, 0.36442852f, -0.10135885f, 0.15950769f, -0.80334139f, -0.02287552f, 
    -0.30567005f, 0.17783648f, -0.33987746f, 0.49889949f, 0.05497031f, 0.53400880f, 0.00070145f, -0.17582570f, 
    -0.05150944f, 0.14679664f, 0.19303086f, -0.51680148f, 0.14493895f, 0.35069841f, 0.07440999f, -0.08967822f, 
    0.14334968f, -0.20883310f, -0.08895905f, -0.08714356f, -0.00549189f, 0.18423426f, 0.12194052f, -0.20230283f, 
    0.16792189f, -0.39972794f, 0.05631473f, -0.59343767f, 0.15839665f, 0.12968929f, -0.16088259f, 0.06427413f, 
    -0.13975576f, 0.11844952f, 0.04390963f, 0.04000860f, -0.20996410f, -0.15173417f, -0.06490787f, 0.15343888f, 
    -0.08808677f, 0.04688155f, 0.18425870f, 0.02971343f, 0.04188024f, 0.32205445f, 0.02951285f, 0.06634653f, 
    -0.04681048f, 0.06651512f, -0.02117488f, -0.06012924f, 0.01847875f, -0.76028639f, 0.28169686f, 0.01394701f, 
    -0.19255710f, -0.76472574f, 0.12229649f, -0.53560418f, -0.15672877f, -0.21315071f, 0.24889125f, -0.13843521f, 
    -0.24274571f, -0.10107384f, -0.06691577f, 0.06728655f, -0.80012113f, 0.19674824f, -0.08949830f, 0.31929752f, 
    0.00468160f, 0.41924629f, -0.40076420f, 0.36664847f, 0.02688649f, -0.32055107f, 0.23212090f, -0.03336835f, 
    -0.38525581f, 0.30205265f, -0.19476126f, 0.23751464f, -0.09369253f, 0.00167121f, 0.04028696f, 0.49526194f, 
    -0.01733877f, -0.20738144f, -0.25373441f, 0.13059215f, -0.13841319f, 0.04510396f, 0.06724868f, -0.16537507f, 
    -0.17729811f, -0.20987526f, 0.06962411f, 0.00645253f, 0.14798571f, -0.17994595f, 0.07724462f, 0.21056667f, 
    -0.05384003f, -0.53946978f, -0.09543540f, 0.19510674f, -0.04311120f, -0.28040391f, -0.00324760f, -0.31108701f, 
    0.09859299f, -0.14524184f, 0.12275807f, 0.19648901f, -0.09726802f, 0.47504190f, -0.52135295f, 0.08570997f, 
    -0.11364970f, -0.28718540f, 0.19268274f, 0.02210623f, 0.13166298f, -0.14229862f, -0.10307469f, -0.02392120f, 
    0.04898536f, -1.26931763f, 0.47455508f, -0.22260337f, 0.14924283f, -0.54462153f, 0.04906194f, 0.06991459f, 
    -0.01279086f, 0.05912075f, -0.54016936f, 0.31725696f, 0.32079595f, -0.60043192f, 0.10570617f, -0.02415972f, 
    -0.07805972f, 0.13513267f, -0.26768336f, -0.20274730f, 0.03046987f, -0.22501004f, 0.01706013f, 0.12449412f, 
    0.10549908f, -0.38772431f, 0.05374033f, 0.27677318f, 0.01536207f, 0.03503922f, -0.05682303f, 0.26970667f, 
    0.12491333f, -0.66270947f, 0.02871457f, 0.01047581f, 0.36281464f, -0.04553497f, 0.01418392f, -0.11350770f, 
    0.08969652f, 0.13220197f, -0.28327087f, -0.27829656f, 0.05067274f, -0.69467509f, -0.12084050f, 0.15751618f, 
    0.04232057f, -0.60680503f, -0.41517004f, 0.00433072f, 0.08921657f, 0.06725929f, -0.32852635f, -0.00958232f, 
    -0.21199952f, -0.09878235f, 0.07323135f, 0.14190307f, -0.38153967f, -0.28162667f, 0.53080481f, 0.00007734f, 
    0.25225046f, -0.10337801f, -0.39580935f, 0.17103359f, 0.26282504f, -0.17148009f, 0.00471017f, -0.55584842f, 
    -0.11468931f, -0.14542611f, -0.05128797f, -0.18477549f, -0.45486930f, -0.21352477f, 0.09577312f, 0.13543513f, 
    0.06822442f, 0.11271984f, 0.39517689f, -0.02467964f, -0.06503925f, -0.01920878f, -0.09071586f, -0.63137972f, 
    -0.12804352f, -0.12266716f, 0.01928720f, 0.09456059f, 0.15352364f, -0.03067672f, 0.07244377f, 0.13205406f, 
    -0.32300282f, -0.21333113f, 0.23193838f, 0.00616571f, -0.12354790f, 0.02013622f, 0.10360371f, 0.19915803f, 
    -0.08142689f, -0.16940807f, -0.03629851f, 0.07366488f, -0.09570576f, 0.08370604f, 0.02456234f, -0.54812938f, 
    -0.06122295f, -0.01798771f, 0.09902338f, -0.24193196f, -0.08899250f, -0.21430297f, 0.05732925f, -0.04755097f, 
    0.37654865f, 0.14681695f, -0.01199773f, 0.12021805f, 0.27175325f, 0.03227316f, -0.02613341f, 0.00172084f, 
    0.01895820f, -0.11469964f, -0.24487714f, -0.65606320f, -0.07908127f, -0.22801109f, -0.13328768f, 0.13668016f, 
    -0.02937948f, 0.22335912f, 0.33139849f, -0.18939060f, -0.05193375f, -0.04740750f, -0.05243515f, 0.23397790f, 
    0.19589265f, -0.11695874f, 0.09717679f, 0.03149880f, -0.05761774f, 0.20733885f, 0.02856412f, 0.30407590f, 
    0.16681980f, -0.13726279f, 0.00983658f, -0.95152175f, -0.33665708f, -0.22359660f, -0.06385476f, 0.10233802f, 
    -0.36266077f, 0.04529835f, 0.07672974f, 0.02316917f, -0.09609093f, -0.09605629f, 0.00890604f, -0.17335814f, 
    -0.07611769f, 0.19970784f, 0.24660370f, -0.27298266f, -0.09586151f, -0.19629224f, 0.02037808f, 0.33220783f, 
    0.04025142f, -0.01849381f, 0.14218591f, 0.01238147f, -0.02459798f, 0.17055693f, -0.30091164f, -0.06456596f, 
    -0.32214671f, 0.13042998f, 0.03286560f, -0.44468719f, 0.36066064f, 0.19605301f, 0.10583695f, -0.06017790f, 
    -1.06422043f, 0.28010875f, -0.22283152f, 0.18208984f, -0.75797254f, 0.16392758f, 0.06369901f, -0.14787053f, 
    -0.06195424f, -1.02632618f, -0.79775912f, 0.17897518f, 0.20231821f, -0.07063691f, -0.11951575f, -0.47257817f, 
    -0.11302060f, -0.02150948f, -0.35113069f, 0.20407970f, -0.11311737f, -0.04767984f, -0.04339436f, 0.38729426f, 
    -1.17571676f, -0.03584172f, 0.18615197f, 0.17128266f, -0.08440969f, 0.07312737f, 0.28928688f, -0.91017509f, 
    -0.03439199f, 0.31344935f, -0.58155221f, -0.12045245f, 0.34751350f, -0.09703241f, -0.05545755f, 0.13904926f, 
    -0.00926065f, -0.60583287f, -0.12232052f, -0.16227022f, -0.02118660f, 0.28585529f, 0.08749484f, -0.24546424f, 
    0.04114214f, -0.22081493f, 0.31988955f, 0.03303910f, 0.04652180f, 0.27421054f, -0.83300221f, -0.15674850f, 
    -0.45903906f, 0.10352726f, 0.01597132f, -0.43363214f, -0.84381384f, -0.48123550f, 0.35455713f, 0.04573787f, 
    0.25660834f, -0.01349089f, 0.30661634f, 0.01480628f, 0.06184836f, -0.03568855f, 0.00687899f, 0.16682850f, 
    0.07848187f, -0.73371470f, 0.06937638f, 0.11577974f, -0.46818531f, -0.11236159f, 0.49384508f, 0.05077381f, 
    -0.04206195f, -0.44857135f, 0.06395068f, 0.16735403f, 0.09415413f, -0.20765202f, -0.09161491f, -0.25217316f, 
    -0.27737549f, -0.08363427f, -0.44385219f, 0.35971066f, -0.15578756f, 0.14765693f, 0.02072640f, -0.35732052f, 
    0.26335174f, -0.08238501f, 0.11864755f, -0.09518514f, -0.45318568f, -0.07531344f, 0.12171121f, 0.11377437f, 
    0.04745990f, -0.51560181f, 0.20539588f, 0.10996371f, 0.09467342f, -0.16923006f, 0.12251133f, -0.14447233f, 
    0.06603515f, 0.14176016f, -0.02680268f, -0.00218359f, -0.11979350f, 0.37416941f, -0.15924685f, 0.00934752f, 
    0.09082308f, -0.04110445f, -0.44827753f, -0.71444869f, 0.09417142f, 0.24425562f, -0.20953654f, 0.09643891f, 
    -0.19744094f, -0.19435360f, 0.40437382f, -0.40296456f, -0.53549975f, 0.33910021f, 0.06431298f, 0.53433448f, 
    0.08866958f, 0.09145196f, 0.13149168f, -0.16353182f, 0.14422499f, 0.19440183f, -0.56456029f, -0.02914504f, 
    -0.10938957f, -0.45910445f, -0.29534215f, -0.22663343f, -0.08232308f, 0.25337422f, -0.08605073f, 0.44153103f, 
    -0.01885383f, 0.04072457f, 0.08357821f, -0.11951305f, -0.14151849f, -0.36843213f, 0.13188843f, -0.72956532f, 
    -0.08890851f, -0.22014210f, -0.27760860f, -0.12892470f, -0.15765093f, 0.56166589f, -0.11550169f, 0.20738649f, 
    0.02348943f, 0.45764604f, -0.22053704f, 0.20278905f, -0.07373712f, -0.05845921f, 0.09741591f, 0.39396584f, 
    -0.02143998f, -0.03549585f, -0.24022956f, 0.27343780f, -0.01840223f, 0.03592428f, -0.06042862f, -0.07624713f, 
    -0.00413570f, -0.62896454f, 0.15007758f, -0.49284571f, 0.08202074f, 0.41066897f, 0.22735704f, 0.05626857f, 
    0.14028472f, -0.23139350f, -0.08163499f, 0.05002823f, 0.12447565f, 0.08406486f, -0.01939225f, -0.78353512f, 
    -0.09886204f, -0.18476963f, -0.26202920f, -0.70678556f, 0.21730617f, -0.29260036f, -0.31727827f, -0.56063604f, 
    0.06454627f, 0.26182505f, -0.12309205f, 0.18761028f, -0.00033543f, 0.15636480f, -0.06331041f, -0.09024528f, 
    -0.23627903f, 0.14317562f, 0.23632903f, 0.35543776f, -0.40625834f, 0.18656726f, 0.17363626f, 0.23050192f, 
    -0.50603884f, 0.03644740f, 0.01278568f, -0.11305354f, 0.19474748f, -0.38681659f, -0.03118772f, 0.10907399f, 
    -0.06839074f, -0.03552676f, -0.33518827f, 0.09858796f, 0.05350811f, 0.27409565f, -0.08238906f, -0.15175691f, 
    -0.03708814f, -0.27401274f, -0.06783695f, 0.14235766f, 0.06884696f, -0.12649146f, -0.68864465f, 0.02741973f, 
    0.38861188f, -0.33140555f, -0.18764396f, 0.33473328f, 0.26634845f, -0.58512551f, -0.14716168f, 0.06157763f, 
    -1.06185389f, -0.41211170f, -0.00831115f, 0.18122730f, -0.48328757f, -0.82125145f, 0.07913602f, 0.00854930f, 
    0.08780933f, -0.29554677f, -0.21573406f, 0.04997865f, 0.15459660f, 0.39312369f, 0.11665205f, 0.11282773f, 
    -0.49789929f, -0.34220865f, -0.07477424f, -0.05506061f, 0.09311283f, 0.02494603f, -0.25742444f, -0.24406616f, 
    0.36583310f, -0.09733418f, -0.37597197f, -0.50115490f, 0.42625213f, -0.58259362f, 0.23494907f, 0.06220362f, 
    0.54893088f, 0.18366806f, -0.49191630f, -0.09196049f, 0.25579110f, 0.20543371f, -0.09537861f, -0.31453758f, 
    -0.09310257f, 0.22068214f, -0.37073189f, -0.12483267f, -0.07559183f, -0.19004676f, 0.00892200f, -0.33105257f, 
    0.09374780f, 0.23127671f, 0.43724576f, 0.16474070f, -0.11888494f, -0.51070529f, -0.16646494f, -0.02038761f, 
    0.37008363f, 0.11799822f, 0.03343500f, -0.77153945f, 0.09484011f, 0.05464343f, 0.19905318f, -0.12859155f, 
    -0.08693416f, -0.15815148f, 0.04811483f, 0.01281630f, -0.08377388f, 0.00249921f, 0.01523951f, 0.19381550f, 
    0.12235132f, -0.47165737f, 0.43682933f, 0.41283810f, -0.42507762f, 0.08100145f, -0.37569103f, -0.13187331f, 
    0.25037152f, -0.04763070f, 0.49982178f, -0.11118512f, -0.02435505f, 0.01631747f, -0.02893738f, -0.68698812f, 
    -0.02992269f, -0.16024280f, 0.23627850f, -0.03569431f, -0.00523140f, -0.32277325f, 0.35560554f, -0.04507327f, 
    0.33947724f, -0.25666380f, -1.01928759f, -0.03558812f, -0.05196225f, -0.09495898f, -0.13982776f, -0.19209097f, 
    0.10447229f, -0.02617201f, -0.06027882f, -0.24180241f, -0.02416625f, 0.22125773f, 0.06627484f, -0.36009097f, 
    0.01745793f, -0.01632619f, 0.29861069f, -0.10396852f, 0.05892903f, 0.19659954f, -0.30795661f, -0.07435236f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.20556696f, 0.12335403f, 0.19563624f, 0.05728542f, 0.05178659f, 0.01889646f, -0.13393451f, -0.07992218f, 
    -0.17311791f, 0.15940896f, 0.12500355f, -0.09449435f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
