#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.70776570f, -1.18924654f, 0.30918643f, -0.18768555f, -0.50364572f, -0.49436882f, -0.13424422f, 0.00130389f, 
    -0.13931468f, 0.97365439f, -0.19321311f, 0.07996752f, 0.52911878f, 0.52170759f, -0.05013788f, -0.43369204f, 
    -0.15479867f, -0.42597011f, 1.03131580f, -1.15028310f, -0.68708539f, 0.04697684f, 0.13533822f, 0.39626330f, 
    0.35102332f, 0.00587231f, 0.06254466f, -0.51112789f, -0.37431154f, -0.55281872f, -0.20772709f, 0.16768700f, 
    -0.43277806f, -0.31672519f, -0.54073554f, -0.56215042f, -0.16782746f, 1.02181876f, -0.83754992f, -0.65084648f, 
    0.71587938f, -0.43185404f, 0.39686555f, 0.29438475f, -0.32325909f, 1.22094798f, -0.73017275f, -0.95133936f, 
    0.53279209f, 0.28495347f, -0.41986096f, -0.11698230f, 0.31101018f, -0.19642240f, -0.89294553f, 0.47335371f, 
    0.26373333f, -0.21005666f, 0.23748195f, 0.27028516f, -0.26353198f, -0.23669024f, 0.39695552f, -0.45615849f, 
    0.13503075f, -0.28676662f, -0.65724331f, -0.19338597f, -0.41284540f, 0.33090025f, -0.31911245f, 0.27526507f, 
    0.36991751f, 0.24410111f, 0.03475340f, -0.48274288f, 0.51511759f, -0.32012311f, -0.52582234f, 0.43765596f, 
    0.55664313f, 0.75365013f, -0.69015402f, -0.78126240f, 0.26123029f, 0.63164854f, 0.55178994f, -0.35739937f, 
    -0.25306624f, -0.37627450f, -0.92083019f, 0.72709751f, 0.41137606f, -0.57299888f, -0.51178443f, -0.05471430f, 
    -0.01259375f, -0.18051389f, -0.24942125f, -0.70853651f, -0.40545127f, -0.08763444f, 0.88206023f, -0.45060849f, 
    0.11205447f, -0.45478535f, 0.07450791f, -0.32148489f, -0.60482919f, 0.12868695f, -0.16103683f, -0.20952089f, 
    -0.30688334f, -0.26407099f, 0.01361065f, -0.40655923f, -0.32581761f, 0.17202821f, 0.80460161f, 0.69481260f, 
    0.11995225f, -0.55427212f, -0.61737937f, -0.15980163f, -0.34939680f, -0.22103339f, 0.50548100f, -0.76161826f, 
    0.37378323f, -0.35495338f, 0.47053641f, 0.31767249f, -0.45437190f, -0.12637351f, 0.31145629f, 0.21876656f, 
    -0.29682752f, 0.40234351f, 0.40230736f, -0.34290200f, -0.31398278f, -0.37662974f, -0.05181868f, 0.48105526f, 
    0.20901698f, 0.73174328f, -0.16885071f, -0.70448023f, -0.48425010f, -0.51164132f, -0.22859606f, -0.39958334f, 
    -0.20712513f, 0.06412648f, -0.77687103f, -0.65878898f, -0.49119711f, 0.31647262f, 0.42664856f, -0.05860560f, 
    0.19933769f, 0.56389713f, -0.86767226f, 0.03419761f, -0.62319994f, 0.28806493f, 0.49159276f, 0.30473831f, 
    0.30234623f, 0.39165306f, -0.03526979f, 0.73175669f, 0.72295564f, 0.69056129f, -0.56194097f, 0.08406276f, 
    0.17433640f, 0.13701051f, 0.04197149f, -0.10586306f, 0.33379126f, -0.41694853f, -0.90897512f, 0.29929093f, 
    0.46362588f, 0.21116357f, -0.50339478f, 0.53461170f, -0.30978402f, 0.10639400f, -0.36045364f, 0.42821217f, 
    -0.16707310f, -0.19686073f, 0.22974758f, 0.43466640f, -0.62548590f, 0.28995597f, -0.30606416f, -0.31274465f, 
    0.73245680f, 0.17829201f, 0.10213365f, 0.00622501f, -0.01277142f, 0.15811455f, 0.06166730f, 0.48526588f, 
    -0.30386573f, 0.41654909f, 0.71197528f, -0.77788103f, -0.22613065f, 0.21523249f, -0.11729743f, -0.11572973f, 
    -0.40179223f, -0.19829702f, 0.25574183f, -0.07859005f, 0.37864512f, -0.39389750f, 0.19064450f, -0.14827932f, 
    0.44190586f, -0.43746313f, -0.35551795f, -0.29491901f, 0.04982804f, -0.04937181f, -0.46250579f, 0.53951752f, 
    0.48916361f, 0.14435257f, -0.56670070f, -0.59143311f, 0.24796577f, -0.56452769f, -0.59053528f, -0.83094478f, 
    0.23855102f, 0.39468163f, 0.44537556f, -0.45848292f, -0.81139791f, 0.12503026f, 0.00768569f, -0.21499948f, 
    -0.01075630f, 0.10503600f, -0.19923902f, 0.54305166f, -0.74689126f, -0.19073729f, -0.39691505f, 0.43174189f, 
    -0.32213920f, -0.24283145f, -0.36267471f, -0.43589640f, -0.45712996f, -0.65350598f, -0.68415749f, -0.08668037f, 
    0.58783644f, 0.76295483f, 0.23343782f, 0.40743977f, -0.47188589f, -0.01212192f, -0.41068855f, -0.25833175f, 
    -0.24043602f, -0.46563420f, -0.15873869f, 0.82282573f, -0.05634303f, -0.35917625f, 0.10453705f, 0.67507935f, 
    0.47353739f, -0.74004370f, -0.54836702f, -0.38844764f, -0.37293071f, 0.00755710f, 0.42566735f, 0.43163690f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.21850447f, 0.00625909f, -0.02571249f, -0.14421114f, -0.10208664f, 0.16671242f, 0.22411433f, -0.21322507f, 
    -0.14640139f, -0.06284921f, 0.00325205f, -0.16114709f, -0.12102666f, 0.22879195f, 0.25792214f, 0.15684094f, 
    -0.14867334f, -0.06204926f, -0.21390674f, -0.23343930f, -0.05303237f, 0.07987651f, -0.06403286f, 0.11518619f, 
    0.02822554f, 0.17673679f, -0.05116154f, -0.08741139f, -0.07627508f, -0.18165842f, 0.24186845f, 0.01120207f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.44678476f, 0.25028524f, -0.03069141f, 0.17510851f, 0.11963620f, -0.07941387f, 0.05551535f, -0.05617886f, 
    -0.05338595f, 0.18889578f, -0.04381782f, 0.00393185f, 0.04571720f, -0.06660829f, -0.13563752f, -0.03133427f, 
    0.00890421f, -0.10272948f, -0.14942753f, 0.04426080f, -0.09819718f, -0.22482029f, -0.39921969f, -0.13890888f, 
    -0.39769161f, 0.05324684f, -0.10331391f, -0.01552334f, 0.06454027f, 0.07482184f, -0.10742866f, 0.18335606f, 
    0.00651581f, 0.03822651f, 0.00419926f, -0.04782740f, -0.05104204f, -0.04483182f, 0.28147945f, 0.03973157f, 
    0.02846962f, 0.21869871f, 0.20158401f, 0.24460799f, 0.22150551f, 0.00691993f, 0.00214443f, -0.13865331f, 
    -0.02223404f, -0.05812440f, -0.06023647f, -0.04560472f, 0.07552426f, 0.13006632f, -0.04650226f, 0.04607791f, 
    0.00891273f, -0.03102353f, -0.02994925f, -0.01509179f, -0.06219572f, 0.01111110f, 0.25658688f, 0.20223652f, 
    0.17001693f, 0.01460945f, 0.08103974f, 0.07862899f, 0.05713343f, 0.11335325f, 0.01339711f, -0.04336726f, 
    -0.04058291f, -0.08458857f, -0.03158918f, -0.09765141f, 0.05813472f, -0.02118076f, -0.04088539f, 0.17029752f, 
    -0.00078037f, 0.01532264f, -0.05470378f, -0.12178963f, -0.28175807f, 0.28847620f, 0.06363892f, 0.04223067f, 
    -0.05729781f, 0.17531623f, -0.22217818f, -0.12632877f, -0.00222604f, 0.13688277f, -0.04746680f, -0.05773299f, 
    0.09135498f, -0.07414803f, -0.00720793f, 0.09472485f, 0.23557404f, 0.20377138f, 0.02982001f, 0.18835948f, 
    -0.02439643f, -0.16022247f, 0.00434317f, -0.13000664f, -0.20708212f, -0.04714861f, -0.02745203f, -0.11828291f, 
    0.14488153f, 0.08902568f, -0.12372664f, -0.01827355f, 0.02046498f, -0.18176785f, 0.15322368f, 0.02731240f, 
    0.10846338f, -0.23384136f, 0.00973609f, -0.09887924f, -0.06761167f, 0.09959670f, -0.08594271f, -0.01490175f, 
    -0.08537761f, -0.02230558f, -0.18506703f, -0.00159564f, 0.01635497f, -0.17561556f, 0.05739313f, 0.02991700f, 
    -0.00881084f, 0.07917071f, 0.01196530f, -0.08008825f, 0.07788273f, -0.01135642f, -0.06707675f, 0.15853219f, 
    0.09769059f, -0.06491094f, 0.14555147f, -0.01130073f, 0.14544180f, 0.07513383f, 0.00281692f, 0.02709903f, 
    -0.01893176f, -0.02193828f, 0.03128276f, -0.08393534f, -0.04629659f, -0.01294820f, -0.13037877f, 0.04209908f, 
    -0.19769317f, -0.30468646f, -0.10198121f, -0.38498092f, -0.13116553f, 0.02617478f, -0.04354971f, -0.00785666f, 
    0.01601283f, 0.06010379f, -0.04898087f, -0.01126176f, 0.19850937f, 0.00757735f, 0.13663590f, 0.10692292f, 
    -0.05746621f, 0.03678031f, 0.06174008f, -0.11095747f, 0.29945466f, 0.48298749f, 0.36162242f, 0.24435398f, 
    -0.31386194f, 0.12029131f, 0.02217981f, 0.02617451f, 0.03224556f, 0.07634185f, -0.09051879f, -0.14350085f, 
    -0.15032503f, 0.11100236f, 0.11661930f, 0.02426695f, 0.03044591f, -0.14673653f, -0.08866645f, -0.08039411f, 
    0.20859872f, 0.05659978f, 0.02285238f, 0.03935081f, 0.07923817f, 0.01755331f, 0.09451960f, 0.05208571f, 
    0.03393988f, 0.16701764f, 0.02950584f, -0.01826497f, -0.10172593f, -0.00970890f, -0.05423473f, -0.21616752f, 
    -0.12050728f, 0.14595366f, 0.00039758f, 0.09112234f, 0.01113743f, 0.28698456f, 0.35822979f, 0.18425104f, 
    0.19355546f, 0.04384710f, 0.17559992f, 0.09489030f, 0.16945875f, -0.10277516f, -0.12203248f, 0.02830091f, 
    -0.01997937f, 0.05532208f, 0.07765135f, 0.06699228f, 0.05313556f, 0.09909163f, -0.11448992f, -0.14065264f, 
    0.07021169f, -0.04551451f, -0.00766549f, 0.07294469f, 0.12991704f, -0.01814752f, 0.17306729f, 0.09426848f, 
    0.03470754f, 0.12541084f, -0.01929487f, 0.00048021f, -0.02670934f, -0.09766849f, -0.09942031f, -0.13000835f, 
    -0.04502206f, 0.13470544f, -0.02952430f, 0.19621214f, -0.14445159f, -0.24382152f, 0.09094641f, -0.02295047f, 
    0.22386129f, -0.09994170f, -0.16149808f, -0.12730733f, -0.02682222f, 0.05158529f, 0.05740128f, 0.03144327f, 
    0.07050737f, -0.05528289f, 0.08137152f, -0.02269486f, -0.00779647f, -0.07288364f, -0.04084701f, -0.00369553f, 
    -0.27830616f, 0.10804643f, -0.08729427f, -0.09852544f, -0.25196195f, 0.01848612f, -0.02898460f, 0.01190757f, 
    0.04726320f, 0.00287324f, -0.04223565f, -0.00270025f, -0.00315411f, -0.11182389f, -0.02600860f, -0.03021533f, 
    0.03945629f, -0.01668072f, -0.02499158f, -0.02338844f, -0.28098705f, 0.01713704f, -0.05059969f, -0.15130810f, 
    0.05327766f, 0.09584714f, -0.02082028f, -0.05922098f, -0.04656208f, -0.00042535f, -0.09373413f, 0.02126561f, 
    0.02353332f, -0.01626233f, -0.00866027f, -0.10459520f, -0.05715320f, 0.05994717f, -0.08482997f, -0.00330874f, 
    -0.03118897f, -0.12114748f, 0.32594123f, 0.19708407f, 0.17530508f, -0.14367911f, -0.05372195f, -0.03656797f, 
    0.07003972f, 0.24494176f, 0.01253041f, -0.01279940f, 0.05796761f, -0.02480503f, -0.00264701f, -0.22439146f, 
    -0.08082211f, -0.02852224f, 0.01990373f, 0.07768726f, 0.31512779f, 0.17834534f, 0.26733911f, 0.18448223f, 
    0.33206832f, 0.11289164f, -0.02037787f, 0.17052719f, -0.07100488f, -0.12195942f, -0.10300057f, -0.12268296f, 
    0.10370600f, -0.04621819f, 0.08668668f, 0.03959157f, 0.01217039f, 0.00033654f, -0.02544498f, -0.04982367f, 
    0.23785484f, -0.09258445f, -0.00292940f, 0.11655545f, 0.21843798f, 0.15517917f, -0.03041074f, 0.10151572f, 
    0.08858777f, 0.09833121f, -0.12349115f, 0.11961284f, 0.10977790f, 0.06299479f, -0.05624810f, 0.06134123f, 
    0.02093837f, 0.00108960f, 0.03678136f, 0.04594082f, -0.50010520f, -0.55201548f, -0.24320102f, -0.09257510f, 
    -0.21093737f, -0.03291700f, -0.12602390f, -0.14803950f, -0.04163605f, -0.03915605f, 0.12108338f, 0.16656642f, 
    0.12226252f, 0.13542858f, 0.14740111f, 0.10346019f, 0.08088421f, 0.11327378f, -0.00397285f, -0.10001788f, 
    0.41531965f, 0.25386044f, 0.34223956f, 0.25050250f, -0.03994013f, -0.06679140f, 0.07249645f, -0.02069441f, 
    -0.00828753f, 0.01444991f, -0.04138659f, -0.03476263f, 0.00769134f, -0.04745585f, 0.17005983f, 0.04164594f, 
    0.08558913f, -0.13765606f, 0.06224703f, -0.00725064f, -0.31254312f, -0.02456466f, -0.08047277f, -0.14623700f, 
    -0.15982901f, -0.08097319f, -0.02896173f, -0.05388549f, -0.02806127f, -0.09156753f, 0.02010707f, 0.02853962f, 
    -0.06848072f, -0.03117432f, 0.00590312f, 0.11769880f, -0.01020060f, 0.12829784f, 0.00593897f, -0.06427352f, 
    0.05672813f, -0.00296522f, -0.13764723f, -0.08827931f, -0.01431468f, 0.01272378f, -0.07574960f, 0.10249524f, 
    -0.08746240f, 0.00296525f, -0.26865664f, 0.02624430f, -0.09948507f, -0.00276163f, 0.10514035f, 0.08398480f, 
    -0.05107854f, 0.04127801f, -0.06347554f, 0.09265288f, -0.57728571f, -0.09108633f, -0.26742926f, -0.16601941f, 
    -0.13432972f, -0.04868257f, -0.15636234f, -0.09305280f, -0.00125130f, -0.06340503f, -0.06836905f, -0.02309012f, 
    -0.02239653f, 0.02880692f, 0.08000667f, 0.00736125f, -0.04304947f, 0.09045503f, 0.01548294f, 0.00747355f, 
    0.07447701f, 0.07357849f, -0.08616605f, -0.03488410f, 0.13769391f, 0.12201100f, 0.07968222f, 0.11277735f, 
    0.01273524f, 0.15367271f, -0.15524866f, 0.07420922f, 0.11653760f, 0.01706824f, 0.01430311f, 0.00674132f, 
    -0.06333998f, 0.03647389f, 0.00964853f, -0.06340930f, 0.19164905f, 0.16905504f, -0.15718891f, 0.16536950f, 
    0.23018518f, 0.16040401f, 0.07736544f, 0.17966941f, 0.11964303f, 0.07971056f, 0.06583031f, -0.02287528f, 
    0.00123241f, 0.11739381f, -0.05826351f, 0.08832923f, 0.04087540f, 0.00178849f, 0.07464621f, 0.11601114f, 
    0.14708832f, 0.35377714f, -0.02861257f, 0.28783089f, 0.37259033f, 0.14055546f, 0.12187705f, 0.11255908f, 
    0.26808774f, 0.21298136f, 0.04943083f, 0.03055661f, -0.02465666f, 0.07849782f, -0.03009923f, 0.01780904f, 
    -0.09794192f, 0.03999460f, -0.22209977f, 0.06556965f, -0.14832091f, 0.19644670f, -0.07989313f, 0.18429632f, 
    0.61549222f, 0.01751524f, 0.05035969f, 0.10365333f, 0.04685009f, 0.01597136f, -0.00991019f, -0.09349459f, 
    0.04294502f, -0.02280012f, 0.01260187f, 0.02866366f, 0.03000338f, -0.01695292f, -0.15152287f, -0.12529430f, 
    0.04852310f, 0.04740031f, 0.12448676f, 0.28492156f, 0.11407539f, -0.01969164f, 0.14794432f, 0.05823281f, 
    0.06076103f, -0.02465321f, 0.01891279f, -0.01855676f, -0.02422852f, -0.07483169f, -0.00233048f, -0.11023555f, 
    0.05605945f, 0.03191027f, 0.01902255f, 0.10215561f, 0.13952263f, 0.22060095f, 0.45882422f, 0.13846569f, 
    0.13592260f, 0.19870862f, 0.02842465f, 0.06196345f, 0.05976625f, 0.18312021f, 0.04502533f, 0.02239482f, 
    0.07890216f, -0.03584523f, 0.09335465f, 0.05459925f, 0.04471800f, -0.00314828f, -0.01069054f, -0.08023655f, 
    -0.06336772f, 0.25295952f, 0.09607738f, -0.02216171f, 0.20186371f, 0.11543854f, -0.07157128f, 0.01445180f, 
    -0.06942242f, -0.00092192f, -0.03051548f, -0.00780761f, 0.01660371f, -0.07849189f, -0.02107811f, -0.01824518f, 
    -0.05873452f, -0.01362549f, -0.17393805f, 0.00226289f, -0.19586359f, 0.03540142f, 0.19755243f, 0.12462651f, 
    0.15569580f, 0.10540118f, 0.08533867f, 0.00191499f, -0.14920145f, 0.03238145f, 0.08472015f, -0.02731246f, 
    0.09815242f, 0.01430037f, -0.00901936f, 0.04179159f, -0.07072090f, -0.06471056f, 0.03757464f, -0.03184889f, 
    -0.26802528f, 0.02267322f, -0.25897890f, 0.14197096f, -0.13864681f, 0.10903863f, 0.10152415f, 0.03809869f, 
    0.16472800f, -0.14446877f, -0.05080802f, -0.04989843f, -0.10285565f, 0.03168007f, 0.10710040f, -0.03086649f, 
    0.01976475f, -0.07242812f, 0.03160200f, 0.13293035f, -0.27842849f, -0.07825863f, -0.09476864f, -0.08801366f, 
    0.22987586f, 0.00740929f, -0.04940917f, -0.05221077f, 0.02192481f, 0.01368525f, 0.00663264f, -0.04612802f, 
    -0.17218556f, -0.12142635f, -0.09712213f, 0.27199987f, 0.09928689f, -0.02018651f, 0.07683592f, 0.06101607f, 
    -0.32529604f, 0.31013820f, 0.47082683f, 0.12724449f, -0.00375437f, -0.06396137f, 0.08911836f, -0.30262595f, 
    0.15816039f, -0.22122426f, 0.09755713f, -0.03249120f, 0.19337256f, 0.01449175f, 0.09569869f, 0.01796790f, 
    -0.05760183f, -0.04231129f, 0.05479823f, 0.00378093f, -0.25453454f, -0.17434247f, -0.13782205f, 0.22172070f, 
    0.09118295f, -0.09945487f, 0.08165842f, -0.01953145f, -0.08921487f, -0.09317901f, -0.00770122f, 0.01303024f, 
    0.06581372f, 0.08258502f, -0.05069321f, -0.11347715f, -0.07429236f, 0.05267633f, -0.01828869f, 0.06965212f, 
    -0.04443665f, -0.31708667f, 0.15604907f, -0.03027689f, 0.33027190f, -0.06016320f, 0.07674321f, 0.02632859f, 
    0.15236869f, 0.01152522f, 0.00646438f, 0.04371771f, 0.11132442f, -0.17673506f, 0.08237701f, 0.18877386f, 
    -0.00992621f, 0.02553200f, 0.08097397f, 0.04380749f, -0.17355245f, 0.48893923f, -0.00251288f, 0.06800234f, 
    -0.15092795f, 0.12374040f, -0.05265570f, -0.20690739f, 0.09145789f, 0.18844470f, -0.02080484f, 0.08081814f, 
    -0.04472294f, 0.16161165f, 0.06002715f, 0.09409793f, 0.03641109f, 0.02021665f, -0.04570280f, -0.08492223f, 
    0.02305413f, -0.13053334f, 0.07140818f, 0.03643778f, 0.12351491f, -0.06557024f, 0.11899469f, -0.00684564f, 
    -0.03014935f, 0.12543271f, 0.07145930f, 0.11494108f, 0.06321079f, 0.14775303f, 0.17634511f, 0.05217315f, 
    0.08192283f, 0.01473619f, 0.15501639f, -0.00242957f, -0.25320882f, -0.31203288f, -0.27031767f, 0.01075438f, 
    0.08793910f, -0.13178416f, -0.08171678f, -0.05463583f, -0.07311736f, -0.10487268f, 0.03190903f, 0.05094789f, 
    0.01535650f, 0.04103185f, -0.01753974f, 0.06110573f, -0.07770500f, -0.00706855f, 0.10265672f, -0.03103016f, 
    0.08721215f, -0.00338668f, 0.04195678f, -0.17724033f, 0.16862029f, 0.15629597f, -0.04697655f, -0.02583890f, 
    0.06258558f, 0.03397445f, 0.03558844f, -0.07502845f, 0.01239670f, -0.01466007f, 0.06899237f, 0.04499916f, 
    0.07485608f, 0.15592916f, 0.01629171f, -0.08238615f, -0.48316932f, 0.17628470f, 0.05216449f, -0.09228166f, 
    0.15167020f, 0.05970853f, -0.04995190f, -0.16481842f, 0.08608826f, 0.01321845f, 0.02118172f, 0.09312014f, 
    0.18464489f, 0.01011556f, -0.06999286f, 0.00839248f, 0.19345929f, 0.20726696f, 0.02730106f, -0.01449796f, 
    0.00918384f, -0.11697823f, -0.32547435f, -0.16271086f, 0.21585782f, -0.06127919f, 0.00423438f, 0.07157368f, 
    -0.09114379f, -0.03594099f, -0.03723964f, -0.06173808f, 0.06649216f, 0.04919012f, -0.05928824f, 0.17924134f, 
    -0.09506539f, 0.03090322f, 0.08674667f, 0.04252259f, -0.14293233f, -0.17406213f, 0.00188768f, 0.46388549f, 
    -0.00595661f, 0.20120409f, -0.05193963f, -0.05965157f, -0.27597004f, 0.11377916f, -0.04259704f, 0.11910763f, 
    0.10063896f, 0.18673009f, -0.10425508f, 0.05772325f, -0.03718663f, 0.03354751f, -0.03594201f, 0.01505721f, 
    -0.19247767f, -0.16261037f, -0.26924476f, 0.03911475f, 0.08980015f, -0.12097302f, 0.01738578f, 0.12189488f, 
    0.00015606f, -0.06660760f, -0.08318745f, -0.03782320f, 0.05803723f, 0.15546572f, 0.01078183f, 0.04701938f, 
    -0.12581021f, -0.00671581f, 0.16291156f, 0.10684663f, 0.32022128f, -0.33569109f, 0.00704393f, -0.07009607f, 
    0.19645071f, 0.00024237f, 0.16774321f, 0.18264334f, -0.03482012f, 0.05643256f, -0.04283249f, -0.02833683f, 
    -0.06693632f, -0.05652675f, 0.01786082f, 0.08768005f, 0.17378168f, 0.05036898f, 0.10617616f, 0.21618879f, 
    -0.21267335f, 0.14322786f, -0.08358297f, -0.09531113f, 0.14009587f, 0.13022782f, -0.03739583f, -0.04113107f, 
    0.17339072f, -0.03764192f, 0.11070752f, -0.12659435f, -0.10240806f, 0.01518100f, -0.02364413f, 0.21514039f, 
    0.18576701f, 0.11664049f, 0.22101848f, 0.01758638f, -0.12899540f, 0.12655637f, -0.06873965f, -0.00180052f, 
    0.11743839f, 0.04448442f, 0.12971134f, 0.25455025f, 0.18792588f, 0.08680471f, 0.01866417f, 0.02731786f, 
    -0.03462222f, 0.00860453f, 0.04234801f, -0.03256612f, 0.10331392f, -0.08080984f, 0.14424582f, 0.01912540f, 
    0.09495722f, -0.31879133f, -0.18526886f, -0.06790451f, 0.35651943f, -0.03457602f, 0.12993819f, 0.16473457f, 
    -0.01232809f, -0.17407799f, -0.02068431f, -0.02251125f, -0.06256559f, -0.03137689f, 0.00212770f, -0.11643585f, 
    -0.16008072f, 0.10831480f, 0.09293874f, 0.16637819f, -0.24042299f, 0.35759345f, 0.25942749f, 0.02954953f, 
    0.00541654f, -0.14031938f, -0.11005408f, -0.31504741f, 0.16205427f, 0.10685903f, 0.22548386f, 0.15658835f, 
    -0.00067367f, 0.03897424f, 0.10537884f, 0.01118035f, -0.05374697f, -0.05213320f, 0.03056268f, -0.08909874f, 
    -0.26265037f, 0.00605228f, 0.38526234f, 0.07610370f, 0.07982798f, -0.06201252f, -0.07788978f, -0.09219118f, 
    0.03443701f, -0.09266352f, 0.05922113f, 0.02658343f, 0.01390663f, -0.01599757f, 0.15003854f, -0.01951685f, 
    -0.08685684f, -0.02709286f, -0.04185463f, -0.04028143f, 0.16418651f, -0.24048439f, -0.01555486f, -0.26764306f, 
    0.14067499f, -0.03843421f, -0.02271560f, 0.13460216f, 0.05857368f, 0.06137083f, -0.03807914f, -0.02193725f, 
    -0.06679688f, -0.10271976f, -0.09995572f, 0.03492693f, -0.01531414f, -0.15818751f, 0.00839770f, 0.07029159f, 
    -0.20924060f, 0.29772159f, 0.46137232f, 0.15325527f, 0.11445654f, 0.11910009f, -0.08902538f, -0.07298642f, 
    0.03237538f, 0.18076198f, 0.06445485f, 0.15963401f, -0.04659419f, 0.11258111f, 0.07175041f, 0.00303189f, 
    -0.00009628f, 0.16914994f, 0.00893029f, -0.06972883f, 0.04039341f, 0.12159026f, -0.10541617f, 0.21849079f, 
    0.03034346f, -0.09716448f, -0.01265177f, 0.00978826f, 0.08643389f, 0.12667859f, -0.09225623f, 0.09324164f, 
    0.08334578f, 0.11949751f, 0.09267186f, 0.11707586f, 0.15576048f, -0.15792620f, 0.02502056f, 0.05170878f, 
    0.01310483f, -0.00354254f, 0.01075787f, 0.16746597f, 0.16187711f, 0.07957422f, -0.01974791f, 0.03408705f, 
    -0.05126429f, 0.14839450f, 0.01393943f, 0.07425757f, 0.10459194f, 0.15128066f, 0.00376238f, 0.10072377f, 
    -0.01558921f, -0.03526523f, 0.00005361f, 0.03155263f, 0.06414673f, -0.07588566f, -0.15919739f, 0.17462677f, 
    -0.14579751f, 0.09136704f, 0.15558378f, 0.20059100f, 0.00532021f, 0.16374891f, -0.09671390f, 0.05319328f, 
    -0.07535310f, 0.01910091f, -0.01810253f, 0.07968121f, -0.04383937f, 0.11365487f, 0.06166467f, 0.13825496f, 
    -0.05566236f, -0.05189324f, 0.16743915f, 0.28610292f, 0.07193483f, 0.00078274f, -0.07705405f, -0.11814629f, 
    -0.05673697f, 0.06621469f, 0.06125107f, 0.15439552f, 0.02156530f, 0.06365076f, 0.05340341f, 0.04158119f, 
    -0.02726993f, -0.11835770f, 0.02035756f, -0.01125762f, -0.26304770f, 0.06437928f, 0.22095515f, 0.19421045f, 
    0.04485122f, -0.00474117f, -0.25973681f, -0.35358107f, -0.07424039f, -0.03765845f, -0.02812502f, 0.22656976f, 
    0.02099003f, 0.03132624f, -0.05247741f, 0.10132515f, -0.07136298f, 0.01825017f, -0.03561324f, -0.08403213f, 
    -0.40021494f, -0.33723539f, -0.13871272f, 0.01042241f, -0.01108062f, -0.00152987f, -0.01293231f, -0.08953496f, 
    -0.10038542f, -0.02650054f, -0.05008031f, 0.06275176f, -0.04488591f, -0.01320190f, -0.08240800f, 0.03003011f, 
    0.01501421f, 0.04007227f, -0.08993620f, -0.09484832f, -0.30190429f, -0.08808835f, 0.17078564f, 0.39562950f, 
    -0.13320222f, -0.05502982f, -0.14065158f, -0.15081508f, -0.08848936f, 0.06962016f, -0.00517848f, 0.08754395f, 
    0.02964797f, 0.00884504f, 0.01624081f, -0.04253732f, 0.03350428f, -0.07539386f, -0.07305714f, -0.07503105f, 
    -0.18260746f, -0.20547663f, -0.17832361f, 0.27198106f, 0.07299364f, -0.02011773f, 0.01489595f, 0.04224213f, 
    -0.13846895f, -0.10225303f, -0.02052279f, 0.01134564f, 0.04972025f, 0.05852268f, -0.03359826f, -0.08867103f, 
    0.00837748f, 0.00720761f, 0.12409505f, 0.06021258f, -0.41059878f, 0.13161168f, 0.64647597f, 0.10498202f, 
    0.18515280f, -0.03113754f, 0.00026295f, -0.04366888f, -0.14981204f, 0.06633262f, -0.09615405f, 0.04652525f, 
    0.01731543f, 0.02953204f, -0.01756328f, 0.02052130f, -0.08155385f, -0.00099326f, -0.08179403f, -0.01941947f, 
    -0.00740467f, 0.12330525f, 0.20207842f, 0.18595991f, 0.16125844f, -0.03208562f, -0.00965736f, -0.09616360f, 
    0.05573748f, 0.06705394f, 0.07457636f, 0.04966290f, 0.11797506f, 0.04703517f, 0.09582566f, -0.06372819f, 
    0.14333493f, -0.08742298f, 0.08070444f, 0.07155450f, 0.11086371f, 0.02746305f, 0.07597004f, -0.02072510f, 
    0.16912922f, 0.07924549f, 0.17039320f, 0.06525417f, 0.01453556f, -0.21891846f, 0.13592106f, 0.08711806f, 
    -0.15721564f, -0.00593626f, 0.03219806f, -0.01494221f, -0.07632913f, 0.09763321f, -0.03490014f, -0.02643730f, 
    0.25069511f, -0.03248838f, -0.11072395f, -0.17448437f, 0.05370877f, 0.04749597f, -0.00772934f, 0.03139956f, 
    0.01386179f, 0.05379409f, 0.02708115f, -0.06481687f, 0.05312538f, 0.01415285f, -0.00722386f, -0.08726826f, 
    -0.09154327f, -0.06072942f, -0.04676741f, 0.01861049f, -0.17225647f, 0.16340737f, 0.36358744f, 0.10911568f, 
    0.04560758f, 0.01081708f, 0.03718909f, 0.00816310f, -0.00063666f, 0.02707818f, 0.04554380f, -0.02002454f, 
    0.07674650f, 0.05200224f, 0.10331368f, -0.22356787f, -0.03927672f, -0.02024740f, -0.24891171f, -0.01034081f, 
    0.12487077f, -0.03032233f, -0.49303308f, -0.03743884f, 0.07968995f, 0.18789572f, 0.01098026f, 0.10749319f, 
    0.02786843f, 0.40869686f, 0.03315154f, 0.15877135f, -0.04477499f, 0.01126809f, 0.03584928f, -0.04547870f, 
    0.13739134f, 0.06548914f, 0.11787622f, 0.10023916f, 0.29220924f, 0.15692538f, -0.14804970f, -0.21303622f, 
    -0.09045308f, 0.09805772f, 0.03659843f, 0.10090216f, 0.12226670f, 0.02200748f, 0.00017404f, -0.12046207f, 
    -0.15818033f, -0.12572560f, 0.07805999f, -0.07502369f, -0.18792102f, -0.07128976f, -0.02563627f, -0.21292701f, 
    0.02196817f, 0.24077088f, 0.24157424f, -0.06218921f, -0.10868257f, -0.12060239f, 0.07235742f, 0.16462879f, 
    -0.07656690f, -0.01279003f, -0.02372616f, 0.01419610f, 0.02092781f, 0.04908302f, -0.09588425f, -0.09678368f, 
    0.05337215f, 0.18507805f, 0.01853863f, 0.06963534f, 0.00443041f, -0.14852542f, -0.27751973f, 0.05161765f, 
    0.23754019f, 0.02873848f, 0.09650545f, 0.07011292f, -0.08969906f, 0.14023107f, 0.03937481f, 0.08287837f, 
    0.07801635f, -0.13052100f, 0.00773710f, -0.08453173f, 0.02197670f, 0.12522879f, 0.06171494f, 0.17119631f, 
    0.06034119f, 0.12995110f, 0.13411084f, 0.00851161f, -0.07141965f, 0.02224326f, -0.02827218f, 0.06601318f, 
    0.09983741f, -0.01308720f, 0.07464424f, 0.05557029f, 0.01657849f, 0.02801233f, -0.03885687f, 0.06264674f, 
    -0.10387272f, -0.03609768f, -0.05379429f, -0.02885426f, 0.19884557f, 0.13330151f, 0.11471333f, -0.28999984f, 
    -0.01131024f, 0.11897481f, 0.08197051f, 0.21402605f, 0.04867833f, 0.00555807f, -0.09881290f, -0.07723225f, 
    -0.00310491f, 0.01465598f, 0.03734662f, -0.03368134f, 0.02382556f, -0.02162010f, -0.09344081f, 0.17501229f, 
    -0.14827029f, -0.02172882f, 0.05536451f, 0.23856714f, -0.19152133f, -0.04885929f, 0.04041589f, 0.01834308f, 
    0.03886161f, 0.10179225f, 0.01860018f, 0.05091646f, 0.05542016f, 0.02669025f, -0.10908443f, 0.07137713f, 
    0.29377800f, -0.04109885f, 0.14745682f, 0.12622705f, 0.33234084f, -0.16589586f, -0.14598079f, 0.07164580f, 
    0.21956117f, -0.07507941f, -0.00266335f, 0.14420782f, 0.02945434f, -0.00558272f, 0.19479357f, 0.02882042f, 
    -0.06244542f, -0.01725794f, 0.00399787f, 0.03048712f, -0.00713877f, -0.02412760f, 0.00172838f, -0.05214633f, 
    0.05118480f, 0.19267142f, 0.13700493f, -0.17898148f, 0.00659286f, 0.01417102f, 0.10595450f, 0.03256544f, 
    0.02555359f, -0.12037453f, 0.01824271f, 0.03241985f, -0.03186362f, 0.01306647f, 0.08513461f, -0.03553937f, 
    -0.08171340f, -0.02861959f, -0.01830228f, -0.10894971f, 0.23015375f, 0.22072637f, -0.30438700f, -0.36902440f, 
    0.14835991f, -0.08346202f, 0.07066597f, 0.15291834f, 0.16541667f, 0.12632519f, -0.09511777f, -0.04273459f, 
    -0.00379494f, -0.00533469f, 0.10960895f, -0.07313376f, -0.04365741f, -0.05578183f, -0.00261217f, -0.00015071f, 
    0.18328106f, 0.19366127f, 0.02651437f, -0.23369218f, -0.03359127f, 0.10597955f, 0.03551589f, -0.00391475f, 
    0.00719088f, -0.06421993f, -0.01566548f, -0.09270915f, -0.10875292f, -0.10114338f, 0.01928302f, -0.13293354f, 
    -0.13998529f, -0.01438187f, -0.07441263f, -0.19067392f, -0.52916247f, 0.09103434f, -0.06874977f, 0.25513762f, 
    -0.00891312f, -0.04233379f, -0.09719624f, -0.08930229f, -0.03440385f, -0.04908578f, 0.01259953f, -0.05467314f, 
    0.04486184f, 0.08118945f, 0.02488551f, 0.03705208f, -0.12192228f, -0.07761667f, -0.16901216f, -0.16704740f, 
    0.13630566f, -0.00250311f, 0.32786593f, 0.03416521f, 0.02645794f, -0.04147834f, 0.02038049f, 0.02262599f, 
    -0.04371418f, 0.19108284f, 0.18239613f, 0.14207365f, 0.14256354f, 0.06742074f, 0.08087097f, -0.09542415f, 
    -0.02123566f, -0.03088386f, -0.05327439f, -0.05858435f, 0.18735118f, -0.18797822f, 0.01238689f, 0.19052227f, 
    -0.05974130f, 0.09022667f, -0.06138134f, -0.18625849f, 0.04413043f, 0.01244157f, 0.13602710f, 0.03474928f, 
    0.07883298f, 0.00430589f, -0.01501613f, 0.11368513f, 0.14279498f, 0.07096311f, -0.07012217f, 0.02786100f, 
    -0.07337746f, 0.20513287f, -0.03873940f, -0.13518628f, -0.15844907f, 0.03585368f, -0.03653508f, 0.15434402f, 
    -0.01562568f, -0.10922137f, -0.00817337f, -0.00469062f, -0.01959859f, 0.08994208f, 0.03811824f, 0.02880957f, 
    -0.04419111f, -0.04817258f, -0.03896586f, -0.20883435f, -0.10264117f, -0.11560340f, -0.29448661f, -0.16663361f, 
    -0.06833843f, 0.14573169f, 0.22309452f, 0.06227630f, 0.03175346f, 0.08080680f, 0.01862654f, -0.07837959f, 
    -0.04899798f, 0.01446356f, -0.10077764f, -0.07261609f, 0.03319545f, 0.03717569f, 0.05066109f, 0.01053901f, 
    0.00741088f, -0.06671619f, -0.22290157f, -0.08279806f, -0.06574535f, 0.08606004f, 0.15240833f, 0.12375224f, 
    -0.03280200f, 0.03944968f, -0.09755505f, 0.04333345f, -0.00522476f, 0.08521742f, -0.14132746f, -0.03685979f, 
    0.09044425f, 0.00045437f, 0.06613815f, -0.00049229f, -0.11729551f, 0.23263086f, -0.11448704f, 0.17365594f, 
    0.04209071f, 0.05557026f, 0.04465459f, 0.02622928f, -0.05511991f, -0.03921136f, -0.07515188f, 0.04268249f, 
    0.04929051f, 0.05064173f, 0.11678850f, -0.04604985f, 0.02594355f, 0.01639806f, 0.10760371f, -0.06392952f, 
    0.14299220f, -0.25496867f, -0.42168829f, -0.04638799f, 0.17742017f, 0.12479655f, 0.20390238f, 0.08537739f, 
    -0.06547135f, 0.08121961f, -0.04735803f, 0.02585622f, 0.13813397f, 0.01235314f, -0.10309148f, -0.04042980f, 
    0.00795231f, -0.08204322f, 0.05106000f, 0.00281554f, 0.14346497f, -0.03358033f, 0.15047213f, 0.00219021f, 
    0.09746317f, 0.13561641f, -0.02397492f, -0.04311845f, 0.12753347f, 0.04052872f, 0.02287591f, 0.08804711f, 
    0.03085116f, 0.00880110f, 0.06295654f, -0.02327667f, -0.11935175f, 0.07447980f, 0.11204426f, -0.07211474f, 
    -0.02745166f, 0.00759902f, 0.05437869f, -0.07438087f, -0.20192164f, -0.08271655f, 0.09312018f, 0.04450589f, 
    0.04893740f, -0.05419774f, 0.15377463f, -0.06161134f, -0.06252891f, -0.07398681f, -0.04210620f, -0.06387846f, 
    0.19597840f, 0.02950314f, 0.10789489f, 0.03576111f, -0.02203508f, -0.00154258f, 0.10863873f, 0.20245013f, 
    0.22475445f, -0.08863886f, 0.01647308f, -0.02603975f, 0.12599859f, -0.04810673f, 0.16776413f, 0.00749915f, 
    0.14104991f, -0.02232964f, 0.12587132f, -0.01601086f, 0.15154846f, -0.14074215f, -0.01889648f, 0.02686336f, 
    0.02663341f, 0.06270585f, 0.00788399f, -0.25687200f, -0.07114071f, -0.05767076f, 0.10853383f, 0.13463919f, 
    0.08971655f, -0.03808564f, 0.12356358f, -0.06155218f, -0.02773545f, -0.04678535f, -0.05466994f, 0.02495375f, 
    0.20308463f, 0.12182752f, 0.12194631f, 0.10656042f, -0.02860006f, 0.06316730f, -0.15085214f, -0.24487098f, 
    -0.01031412f, -0.02842713f, 0.18646745f, 0.17837453f, -0.00340220f, 0.04742924f, 0.04056156f, -0.07869889f, 
    0.00879359f, 0.06837899f, 0.06444675f, -0.06202956f, 0.11042988f, 0.09598994f, 0.10326348f, 0.21544358f, 
    0.23039901f, 0.20978706f, -0.04493441f, -0.39539480f, -0.02862025f, -0.01390826f, 0.03403723f, 0.01658710f, 
    0.08141871f, -0.09436791f, 0.05885668f, -0.07531175f, 0.01224523f, 0.01944923f, 0.02850869f, 0.02238009f, 
    0.01451968f, -0.06247629f, 0.15111561f, 0.13177241f, 0.04211280f, 0.06719514f, -0.16098960f, -0.51426512f, 
    -0.07307882f, 0.09030547f, 0.07388693f, 0.15302935f, 0.04955035f, -0.05541967f, -0.01057027f, -0.01065773f, 
    -0.09095414f, 0.03969281f, -0.05555638f, 0.00568270f, -0.03593407f, -0.04683452f, 0.14280394f, 0.14153723f, 
    0.24070732f, 0.21495481f, -0.18894252f, -0.28423047f, -0.00344536f, 0.00062445f, -0.02861289f, 0.00229802f, 
    0.09288500f, 0.05856553f, -0.05664779f, -0.06207016f, -0.08704974f, -0.03586198f, 0.10128744f, -0.13069870f, 
    -0.19218980f, -0.06102458f, -0.07895170f, -0.09996133f, 0.35716039f, -0.07014498f, -0.51148206f, 0.00475964f, 
    -0.06610207f, 0.07974663f, 0.10151519f, 0.07362339f, 0.03561547f, 0.07091200f, -0.04210371f, 0.06831681f, 
    -0.02251564f, 0.05980271f, 0.04822467f, -0.00119337f, 0.03081776f, 0.03885423f, 0.07686879f, -0.05446215f, 
    0.06828804f, -0.09409338f, -0.21373041f, -0.17980979f, 0.00828134f, 0.08866417f, 0.04127092f, 0.09265222f, 
    0.20060118f, 0.06263984f, -0.06780439f, -0.08979166f, -0.04325428f, -0.06081305f, -0.05246421f, 0.14663321f, 
    -0.12458344f, -0.01553528f, -0.01704507f, -0.17274281f, 0.07311841f, 0.12050670f, -0.25943992f, -0.03843724f, 
    -0.14482190f, -0.06873602f, -0.06169177f, 0.01337187f, 0.08502966f, 0.09397990f, -0.09473243f, -0.06266982f, 
    -0.00098339f, 0.04551106f, -0.07897104f, 0.05705475f, 0.09433229f, 0.04895503f, 0.11105941f, 0.10624853f, 
    0.09306439f, 0.04612348f, 0.33956134f, -0.12586746f, 0.24211402f, 0.02635456f, 0.04258819f, 0.01719376f, 
    0.20569338f, 0.07953571f, -0.03994216f, -0.02123525f, 0.08712441f, -0.03554146f, -0.07753184f, 0.00064933f, 
    0.02535713f, -0.19684970f, -0.02341883f, 0.17895789f, 0.15705545f, -0.06687744f, 0.03716264f, -0.07327707f, 
    0.14926496f, -0.02087399f, -0.04177627f, -0.05058366f, 0.02554824f, 0.00962265f, 0.04498022f, 0.12316597f, 
    -0.02462925f, 0.02959497f, -0.05418912f, -0.23515634f, 0.03704991f, 0.05639603f, -0.09899196f, 0.16963345f, 
    0.09289115f, -0.32648206f, -0.19072647f, 0.08828444f, -0.27864480f, 0.03466317f, -0.08196239f, -0.00394656f, 
    0.12100065f, -0.00342019f, -0.01365066f, -0.09736014f, 0.03760008f, -0.06153733f, -0.04966086f, -0.02783877f, 
    -0.08082593f, -0.03287755f, 0.08524629f, 0.17314303f, -0.03127432f, 0.08840721f, 0.19276150f, 0.11804436f, 
    -0.00418707f, 0.07751115f, 0.08704897f, 0.04745119f, 0.02719290f, 0.01788254f, -0.02631384f, 0.04837589f, 
    0.03053551f, 0.10286067f, 0.09477172f, 0.12197307f, 0.10351802f, 0.02824269f, 0.05718559f, -0.02061025f, 
    -0.09204426f, 0.24943334f, 0.18011740f, 0.21181098f, -0.15580155f, 0.07791166f, -0.07036894f, 0.45807725f, 
    0.11934040f, 0.10580114f, 0.07911610f, 0.10368276f, -0.00998662f, -0.05667149f, -0.09223073f, -0.12356142f, 
    0.15225281f, 0.23595752f, -0.23646866f, 0.12429262f, 0.13915490f, -0.12422708f, -0.00733848f, -0.15897533f, 
    -0.09771042f, -0.05684165f, 0.04756394f, 0.09788782f, -0.03162203f, 0.09742628f, -0.11207657f, -0.04000951f, 
    -0.01833999f, 0.05108139f, 0.07698245f, -0.12638018f, -0.11869702f, -0.05592840f, -0.03628211f, 0.07070976f, 
    -0.27189958f, -0.27115190f, 0.13154447f, 0.03161406f, -0.10499609f, 0.03802380f, -0.04145913f, -0.01432895f, 
    0.13874881f, 0.00559807f, -0.02397610f, 0.02263310f, -0.00034168f, -0.01780613f, 0.10225428f, -0.08139100f, 
    -0.14199772f, 0.01113044f, -0.06843869f, -0.02108203f, -0.04565838f, 0.33606538f, 0.52375656f, 0.33437115f, 
    0.10013596f, -0.00981172f, -0.02585946f, 0.13044518f, 0.07482134f, 0.10986261f, 0.08533429f, 0.06063830f, 
    0.06105113f, 0.10191058f, 0.05650047f, 0.02573720f, 0.00533510f, -0.09548044f, 0.03750953f, -0.10909173f, 
    -0.08508910f, -0.06292005f, -0.20646943f, 0.09129804f, -0.08846665f, 0.14147291f, 0.11702733f, 0.03160690f, 
    -0.09247649f, 0.06774507f, 0.08977405f, -0.13535312f, 0.06569568f, -0.16501386f, 0.00918744f, 0.03123192f, 
    -0.09862513f, 0.15862958f, -0.03485239f, 0.01128769f, -0.15783711f, -0.16774487f, -0.30426115f, -0.05913745f, 
    -0.13640474f, 0.00588738f, 0.02381076f, 0.04349527f, 0.01269563f, 0.02768245f, 0.03271992f, -0.00053995f, 
    0.03879223f, 0.17357329f, 0.01755130f, -0.20561258f, -0.04987629f, 0.01115311f, -0.00530248f, 0.04922992f, 
    -0.09633630f, 0.02115241f, 0.03409012f, 0.37932605f, -0.09537963f, 0.00049086f, 0.02111191f, 0.11767615f, 
    0.02987053f, 0.01225203f, 0.06993109f, -0.01703524f, -0.04869631f, 0.00319531f, 0.02897865f, 0.08134934f, 
    0.03997985f, 0.01355873f, -0.06828918f, -0.08475657f, 0.17945984f, -0.12228557f, 0.17835850f, 0.06182609f, 
    0.01047137f, -0.14860386f, 0.14935663f, 0.04265395f, -0.06960899f, -0.01660462f, -0.03192859f, 0.05322988f, 
    0.08190342f, -0.15020096f, 0.13092017f, -0.01254004f, -0.02755177f, -0.14496267f, -0.00006478f, 0.02798992f, 
    0.00135369f, 0.03237246f, 0.14717492f, 0.11225621f, 0.00071525f, 0.06694285f, 0.01024235f, 0.08005220f, 
    0.09268648f, 0.07964436f, 0.01131263f, -0.00930155f, -0.01708021f, 0.10299388f, 0.07459436f, 0.08481450f, 
    0.06648350f, -0.04628936f, -0.01659793f, 0.00878105f, 0.15619311f, -0.20971386f, -0.65175909f, 0.37869871f, 
    -0.00128832f, 0.00130451f, -0.00216206f, 0.02692156f, -0.05832687f, 0.03457568f, 0.00816191f, 0.01833014f, 
    -0.04377984f, 0.03149992f, 0.01419906f, -0.00057519f, -0.13011247f, -0.07381231f, 0.03435582f, 0.08526143f, 
    -0.08992255f, -0.46628007f, 0.08718044f, -0.04484235f, -0.03588718f, 0.01399905f, -0.00765205f, -0.05777271f, 
    0.09607573f, -0.05743248f, 0.03812630f, 0.06514144f, -0.03353610f, 0.10235887f, 0.08329710f, -0.16111669f, 
    -0.00788612f, -0.06849135f, 0.03746162f, 0.04128180f, -0.01585685f, -0.23527606f, -0.07214811f, -0.07223378f, 
    0.11122704f, -0.05887360f, 0.11396323f, 0.06019335f, 0.14249100f, 0.06791312f, 0.02624133f, -0.13682655f, 
    -0.05494204f, 0.13230984f, -0.10423576f, -0.10472363f, -0.12554683f, -0.08417200f, 0.02964425f, 0.01106698f, 
    0.07529593f, 0.44172746f, -0.03471925f, 0.30920017f, 0.00571888f, 0.06984928f, 0.08311085f, 0.15515380f, 
    0.02660086f, 0.16520259f, -0.00333016f, 0.04793926f, -0.04215235f, -0.01330070f, -0.03165726f, 0.08578591f, 
    0.10046860f, 0.12464990f, 0.00619371f, 0.10245530f, -0.09311776f, -0.15238272f, 0.07113078f, 0.03684320f, 
    -0.12847374f, -0.00526028f, 0.01470525f, -0.12055643f, 0.04515157f, 0.02299993f, 0.00380635f, -0.09364508f, 
    -0.10768320f, 0.03881549f, -0.13501598f, -0.05046804f, 0.12829742f, -0.00383835f, -0.00231121f, 0.12689720f, 
    0.06126416f, -0.00659216f, -0.17029545f, 0.01609103f, -0.11656570f, -0.02672922f, -0.02373043f, -0.04763234f, 
    0.05338274f, 0.09540442f, 0.09386590f, -0.09731329f, 0.03803769f, -0.13592878f, -0.10225733f, 0.01274716f, 
    0.06235061f, 0.11523364f, -0.06654835f, 0.06470816f, -0.24354300f, -0.46899396f, -0.65749371f, 0.04460220f, 
    0.05210163f, 0.05496520f, 0.07526415f, 0.12331661f, 0.00675667f, -0.03166648f, 0.07149101f, 0.06516257f, 
    0.02234473f, -0.02473757f, 0.15180120f, 0.12729168f, 0.03817243f, -0.01196491f, -0.08397841f, -0.00610261f, 
    -0.21347955f, -0.02014367f, -0.08959134f, 0.00089497f, -0.18286070f, 0.00016500f, 0.10586666f, -0.02320947f, 
    -0.00606798f, 0.10903680f, -0.07066294f, 0.03038376f, 0.04634069f, -0.06584972f, 0.04091695f, 0.00252159f, 
    -0.02777734f, -0.00085302f, -0.08348353f, 0.05458364f, -0.15160626f, -0.42614603f, 0.15975030f, 0.17320140f, 
    -0.03948978f, -0.02846409f, 0.03246749f, 0.06040690f, 0.10276198f, 0.02308505f, -0.09906300f, 0.00312020f, 
    -0.14010926f, 0.07833274f, 0.12561336f, 0.11972222f, -0.12384362f, -0.07647931f, 0.02734760f, 0.13563477f, 
    -0.26039654f, -0.26358652f, -0.04161695f, -0.09137685f, -0.14514945f, -0.04766900f, 0.00566323f, 0.08163409f, 
    -0.11191243f, -0.03736312f, 0.02504593f, 0.14890915f, -0.21811017f, 0.03529658f, -0.01489043f, 0.01907326f, 
    -0.05716722f, 0.04517047f, -0.00133752f, 0.01782044f, 0.18431850f, -0.39912200f, -0.37193701f, 0.12246916f, 
    0.08885386f, 0.01291291f, -0.00177455f, 0.10743544f, 0.00146904f, 0.01437360f, -0.02203234f, -0.05099352f, 
    -0.04723354f, -0.01240509f, -0.01879506f, -0.04389230f, -0.11866511f, -0.04985715f, 0.09209257f, 0.15032195f, 
    -0.06612494f, 0.20515718f, 0.02930979f, 0.09848667f, -0.08745435f, -0.02121352f, 0.02915268f, 0.04909571f, 
    -0.08569816f, 0.04672353f, 0.02239122f, 0.02780544f, -0.08822531f, 0.06833538f, 0.05113455f, 0.00249430f, 
    -0.00668275f, -0.03427164f, -0.14367899f, 0.05480416f, 0.12377132f, 0.33012083f, 0.24155104f, -0.02359853f, 
    -0.04335900f, 0.04237444f, 0.07541160f, 0.07803604f, 0.01064881f, 0.14519250f, 0.04906361f, -0.02642977f, 
    -0.00986134f, 0.01462127f, -0.00135187f, -0.01163403f, -0.04027515f, -0.00895893f, -0.03554569f, 0.06630447f, 
    -0.01394118f, 0.45061865f, 0.46505406f, 0.10085153f, 0.21567550f, -0.05516847f, 0.03467100f, 0.12988204f, 
    0.04692183f, 0.17535308f, 0.07342084f, 0.02526168f, -0.00314128f, 0.01949100f, 0.03342868f, -0.07464454f, 
    -0.04049608f, -0.10660203f, 0.26682070f, 0.00997817f, 0.09770098f, 0.28365362f, 0.19214992f, 0.06429155f, 
    -0.02127974f, 0.00795305f, 0.06652115f, 0.02980297f, 0.05713567f, 0.15026811f, 0.00035463f, -0.06792349f, 
    0.00957919f, 0.04056692f, -0.02643613f, -0.01366840f, 0.04228468f, -0.14662878f, 0.13068227f, 0.04446000f, 
    -0.01727606f, 0.03013052f, 0.08726257f, 0.01891486f, -0.02177839f, -0.01469610f, 0.07372478f, 0.05704744f, 
    0.04882879f, 0.00059963f, -0.02327817f, -0.05805817f, 0.04194535f, 0.03957776f, 0.09721075f, 0.07335212f, 
    0.09232748f, -0.04188154f, 0.01349844f, 0.06234392f, 0.34613222f, 0.07702027f, -0.18775719f, 0.11849432f, 
    -0.18846387f, -0.14602095f, -0.02558112f, -0.00095745f, 0.00274030f, 0.19240661f, -0.04616670f, 0.07803687f, 
    -0.02168020f, 0.09712529f, -0.09351459f, -0.07809661f, -0.00883078f, 0.05746928f, -0.10657049f, 0.07114019f, 
    -0.12467388f, -0.11155428f, 0.18647085f, 0.03755326f, -0.18890186f, 0.05314707f, -0.02603173f, 0.03894565f, 
    0.05408545f, 0.06898011f, 0.06090817f, -0.05171667f, 0.02231750f, 0.05736240f, 0.02911325f, -0.03088827f, 
    -0.06849530f, -0.11065549f, 0.08259758f, 0.04993249f, 0.16171588f, 0.29401273f, 0.05962016f, -0.05341262f, 
    -0.05121018f, -0.02300452f, -0.02893402f, 0.24893184f, 0.08783911f, 0.22425629f, 0.01339128f, 0.01908455f, 
    0.03225815f, -0.13394581f, 0.03354991f, -0.09344698f, -0.08586153f, -0.13954200f, 0.20100683f, 0.03285021f, 
    -0.00867256f, -0.02209102f, -0.00925981f, -0.02548225f, 0.00930698f, 0.01236079f, -0.02199844f, -0.03871831f, 
    -0.01587354f, 0.03176944f, -0.03868790f, 0.02151594f, 0.03125956f, -0.01758248f, 0.00078357f, 0.03212344f, 
    0.02807533f, -0.03073297f, 0.02656244f, -0.02221442f, -0.02752648f, 0.02829553f, -0.02974777f, -0.02065572f, 
    -0.02239333f, 0.00476663f, 0.01449911f, -0.04149017f, 0.01173080f, 0.01011064f, -0.02294967f, -0.03819639f, 
    -0.00318759f, 0.00885314f, 0.00798770f, 0.01036590f, 0.01289027f, -0.02620934f, -0.01764522f, 0.02885925f, 
    0.02022887f, 0.01007009f, 0.03005185f, -0.03035831f, 0.02592117f, -0.04317489f, -0.01014766f, -0.00935667f, 
    -0.00600647f, -0.02879889f, -0.00766216f, -0.04105820f, -0.02620246f, 0.03073424f, 0.01767761f, 0.01781627f, 
    -0.00143267f, 0.01058405f, 0.02775392f, -0.03670282f, 0.02753628f, -0.01739945f, -0.01284315f, -0.03329115f, 
    -0.00168319f, -0.04325291f, 0.00659610f, -0.00863537f, -0.02530166f, 0.01018662f, -0.02370393f, 0.02753610f, 
    -0.04244450f, 0.03319098f, -0.01136009f, 0.03152892f, 0.03281149f, -0.00214236f, -0.02886938f, 0.02141092f, 
    0.00343538f, 0.02282849f, -0.00348493f, -0.02771584f, 0.02739286f, -0.02906724f, 0.03121570f, 0.00834453f, 
    0.02543778f, 0.00797990f, 0.00865545f, -0.03635003f, -0.01624662f, -0.03099033f, 0.02273071f, 0.02624867f, 
    0.01608963f, -0.02403957f, -0.02588690f, -0.03676772f, -0.02133547f, 0.01470707f, 0.01260675f, -0.01640892f, 
    -0.02515991f, 0.02806685f, -0.01578674f, -0.00433725f, -0.01624834f, -0.01918949f, -0.02653425f, -0.04030904f, 
    -0.04549249f, -0.01632797f, -0.00945810f, -0.02557181f, 0.02533266f, 0.02036684f, -0.03045472f, -0.00937955f, 
    -0.02931341f, -0.03643485f, 0.03306710f, -0.01252434f, -0.03692332f, 0.02221641f, -0.02747941f, -0.04192480f, 
    0.00274347f, -0.04155361f, 0.02676582f, -0.02893061f, -0.01435718f, -0.04009552f, -0.01053524f, 0.00365842f, 
    -0.00111694f, -0.02645535f, 0.00471608f, 0.02354665f, -0.04172642f, 0.00174517f, -0.02176791f, -0.01315042f, 
    -0.04465170f, -0.01076933f, 0.02211822f, 0.00741516f, -0.00409181f, 0.01639554f, -0.00578391f, 0.02609698f, 
    0.00108063f, -0.02686304f, -0.01269179f, 0.03076705f, -0.00362164f, -0.01431546f, -0.02986023f, -0.04240662f, 
    -0.04330688f, 0.02734147f, -0.04523041f, -0.00312637f, 0.01635803f, -0.02600262f, 0.02764205f, 0.01307070f, 
    0.02981661f, -0.02444209f, 0.02851093f, -0.00500092f, -0.03417045f, -0.02232863f, 0.03008665f, -0.02772676f, 
    -0.00176475f, -0.01222317f, 0.00220932f, -0.00642290f, 0.01354487f, 0.02718571f, -0.02983558f, 0.02152114f, 
    0.02645681f, 0.02869654f, -0.02170421f, 0.03076638f, -0.01392169f, -0.00392687f, -0.01092121f, -0.01058409f, 
    0.00309477f, -0.00443823f, -0.02387347f, 0.02492352f, -0.00081079f, 0.03243504f, 0.02277199f, 0.02222707f, 
    -0.01549359f, -0.02094180f, 0.01518720f, 0.00356534f, -0.00559449f, -0.00036779f, 0.02648028f, 0.00995123f, 
    -0.03744200f, -0.03678470f, -0.00059211f, 0.00929833f, -0.03214924f, -0.01438550f, 0.02571722f, -0.02354378f, 
    -0.03912978f, -0.01552508f, -0.03923975f, -0.00895826f, 0.01147319f, -0.00555226f, 0.03265455f, 0.02800102f, 
    0.00743673f, -0.00486832f, -0.03494898f, 0.01516311f, 0.00419918f, 0.00384169f, 0.01114003f, -0.04134755f, 
    0.02011292f, -0.01940470f, 0.03067107f, -0.01224514f, 0.02247218f, 0.00200352f, -0.03690189f, 0.03031674f, 
    0.00928169f, -0.01144688f, 0.00617364f, 0.02441252f, -0.03929669f, -0.03873103f, 0.03328320f, -0.00001440f, 
    0.01516487f, -0.04144748f, 0.00592639f, 0.03216263f, -0.03943674f, -0.01572215f, -0.03149277f, -0.00490932f, 
    0.02470752f, 0.01098517f, 0.02130289f, 0.02829932f, 0.02407425f, -0.04223225f, -0.03231312f, 0.02650228f, 
    0.01099112f, -0.02809764f, 0.01713746f, 0.00902704f, 0.02364300f, -0.03264518f, -0.03066678f, 0.00516799f, 
    -0.00748918f, 0.01153871f, -0.03199055f, -0.04347636f, 0.01642561f, -0.02793914f, 0.03322979f, -0.00241000f, 
    -0.02030723f, -0.02808565f, -0.00798424f, -0.02705961f, 0.00333268f, 0.00795607f, -0.03200323f, -0.02351319f, 
    0.02862677f, -0.01667151f, -0.03643999f, 0.00110060f, -0.02405953f, 0.02402340f, -0.01310842f, -0.03687497f, 
    -0.03257762f, 0.01449522f, -0.00940322f, -0.02746763f, 0.03049527f, -0.00183218f, -0.02679420f, -0.00625707f, 
    -0.03471683f, -0.03989897f, -0.01447918f, 0.03002643f, -0.03413263f, 0.02541767f, -0.01316241f, -0.01120533f, 
    -0.02195288f, -0.02770064f, -0.01248634f, -0.00903983f, 0.00980865f, -0.01912126f, -0.00099654f, -0.00951942f, 
    0.02183974f, -0.04107080f, 0.00856233f, -0.00905792f, -0.00448909f, -0.03195324f, 0.01786438f, 0.00515890f, 
    0.01836488f, 0.00988558f, -0.00851265f, -0.02611928f, -0.04097709f, -0.03915378f, 0.01353802f, -0.01028085f, 
    -0.00795321f, 0.01630381f, 0.01472228f, 0.01362371f, -0.01685467f, 0.04253209f, -0.02621520f, -0.03186415f, 
    0.02282592f, -0.01846906f, -0.01051187f, -0.03029334f, 0.00569431f, -0.03636123f, 0.00598064f, -0.01620983f, 
    -0.02965967f, -0.01324330f, 0.02656866f, 0.02432475f, 0.01544178f, -0.00868551f, -0.01659412f, 0.01928273f, 
    -0.04310021f, -0.01253845f, 0.01173800f, -0.01958904f, 0.00544223f, 0.02965277f, 0.02629163f, 0.02956045f, 
    -0.03060576f, 0.02004827f, -0.02984892f, -0.02983749f, 0.02948747f, 0.01467228f, 0.01639536f, -0.00923733f, 
    -0.04234536f, -0.03776145f, -0.02814444f, -0.03411615f, 0.01770399f, -0.00134099f, -0.00727380f, -0.00500211f, 
    0.03062193f, -0.00115019f, 0.00173472f, -0.02917038f, -0.01793144f, 0.00620076f, 0.02429289f, 0.01921907f, 
    -0.01492797f, 0.01570478f, -0.02743562f, 0.03028712f, -0.02267078f, -0.00309731f, -0.03894201f, -0.01801857f, 
    -0.04301486f, -0.02575269f, 0.01727661f, 0.00558572f, -0.03167752f, 0.03042231f, -0.01599668f, -0.03775382f, 
    -0.00183037f, -0.02627126f, -0.00871875f, -0.03261939f, 0.02255483f, -0.03503848f, 0.00696991f, -0.02715769f, 
    0.00084734f, 0.03093460f, 0.01920017f, -0.01071962f, -0.01881364f, -0.02895922f, 0.01523351f, 0.02482814f, 
    -0.03777798f, -0.02276063f, -0.00382083f, -0.01392892f, -0.00839673f, 0.01079521f, -0.00484351f, -0.01315833f, 
    -0.01303819f, -0.02690323f, 0.00129939f, -0.02885716f, -0.02270178f, -0.02108457f, -0.04483853f, -0.03478466f, 
    -0.03750081f, 0.02239443f, 0.02553729f, -0.02524702f, -0.04297864f, -0.02630263f, -0.00825907f, -0.00845697f, 
    0.00077957f, -0.03916432f, -0.02806883f, 0.02910706f, 0.01549923f, -0.01055224f, -0.03509527f, -0.03428888f, 
    -0.02501051f, -0.03530081f, -0.02405241f, 0.00867669f, 0.02629975f, -0.00586989f, -0.01113433f, 0.02811070f, 
    0.00173116f, -0.04525728f, 0.01878106f, -0.04018793f, -0.02910561f, -0.03473389f, 0.02823972f, -0.01251823f, 
    -0.00227900f, 0.02077154f, -0.00499716f, -0.04366822f, -0.02206572f, 0.02018816f, -0.02960348f, -0.02419433f, 
    -0.01002676f, -0.02848308f, -0.02371720f, -0.00407166f, 0.00710648f, -0.03632779f, -0.01652003f, 0.03232862f, 
    -0.02994282f, 0.00290228f, 0.00664678f, 0.00641867f, -0.01209076f, -0.02783204f, -0.03657896f, -0.04254304f, 
    -0.01020618f, -0.04193244f, -0.04282439f, -0.00896667f, 0.01886658f, -0.04016228f, 0.00715709f, 0.00751288f, 
    0.00750039f, 0.01509420f, -0.00293630f, -0.01031416f, -0.01876681f, 0.02808523f, 0.01821474f, -0.00534783f, 
    -0.03787390f, -0.02024388f, 0.00126286f, 0.02450342f, -0.00643298f, 0.01068086f, 0.02590351f, 0.00756816f, 
    -0.01720031f, 0.02422310f, -0.00332127f, -0.03806421f, 0.02632997f, -0.04379184f, -0.03411504f, -0.04319855f, 
    -0.02881956f, 0.00869574f, 0.01733002f, -0.01730083f, 0.00786748f, 0.02499584f, -0.04423541f, -0.03679120f, 
    -0.02855766f, -0.00860927f, 0.03940444f, 0.00484819f, 0.02163274f, -0.00048801f, -0.00698474f, 0.01683700f, 
    0.03240450f, -0.01828296f, -0.03828984f, 0.02926137f, 0.02540592f, 0.00027052f, 0.01865986f, -0.02991693f, 
    -0.02460114f, -0.03213038f, -0.00030201f, 0.03050005f, 0.02859558f, 0.02666780f, -0.00361807f, 0.00898159f, 
    -0.00935046f, -0.03426956f, -0.01418693f, -0.02002390f, -0.02734229f, 0.00624615f, 0.00809299f, -0.04521838f, 
    -0.00640810f, -0.04298272f, -0.02134168f, -0.02047692f, -0.02950953f, 0.03258161f, -0.03663397f, -0.01908048f, 
    0.02102468f, 0.01173088f, -0.02345587f, 0.01530319f, -0.01743655f, -0.01183853f, -0.03657034f, 0.01721303f, 
    -0.03443794f, 0.01243995f, -0.03078618f, -0.03195062f, 0.01899874f, 0.03635573f, -0.01334168f, -0.00714651f, 
    0.02177628f, 0.02197471f, -0.00172123f, 0.03119556f, -0.00594288f, -0.04433304f, 0.00607016f, 0.01070390f, 
    -0.01725489f, 0.00729476f, 0.00707549f, 0.01220900f, -0.03120887f, -0.03118571f, 0.01040907f, -0.00082419f, 
    0.00543968f, 0.01976683f, 0.00221073f, 0.00466772f, -0.02064907f, -0.02700181f, -0.04126862f, 0.00093140f, 
    -0.03318679f, 0.03012157f, -0.01376694f, 0.00671648f, -0.02603327f, 0.00223179f, 0.03145847f, -0.04342043f, 
    -0.01754737f, -0.00993018f, 0.00536295f, 0.02261851f, -0.03259403f, -0.00061038f, 0.02602693f, -0.00095170f, 
    -0.02105135f, 0.03166111f, 0.00175229f, -0.01753023f, 0.00734676f, 0.03065169f, 0.02155343f, -0.01972337f, 
    0.14845516f, -0.00416547f, 0.09039843f, 0.14265423f, -0.26026076f, 0.11465190f, 0.31345356f, 0.01959107f, 
    0.03961986f, 0.02807867f, 0.00885603f, -0.03303170f, -0.04733596f, -0.05651363f, -0.00737260f, -0.02126430f, 
    0.07126671f, 0.09599697f, 0.12890208f, 0.13045396f, -0.48220548f, 0.01840622f, 0.14100838f, -0.12801412f, 
    -0.12602140f, -0.02945934f, -0.15713756f, -0.14789060f, -0.08871347f, -0.06389236f, 0.19609980f, 0.04383644f, 
    0.00425726f, -0.03983456f, 0.09438581f, 0.00637557f, 0.00514207f, 0.17077038f, 0.28615716f, 0.03629439f, 
    -0.23770727f, 0.45488486f, 0.27986988f, -0.20305513f, 0.46211049f, 0.03822851f, 0.00824516f, -0.06723362f, 
    0.09244105f, 0.12339254f, 0.06970206f, 0.08895365f, 0.07952004f, 0.02918215f, 0.05270721f, -0.08169370f, 
    -0.00221871f, -0.04200122f, 0.03791810f, -0.00799414f, -0.24320471f, -0.14433582f, -0.01343246f, 0.14605117f, 
    0.08240025f, -0.03973021f, 0.05200320f, 0.05737957f, 0.00372037f, -0.07882477f, -0.02150418f, -0.04738218f, 
    -0.08756350f, -0.04066949f, -0.01333465f, 0.07160033f, 0.12822652f, 0.08003148f, -0.02338569f, -0.00557311f, 
    0.41443667f, 0.11194703f, 0.22409023f, -0.09265241f, 0.44694036f, 0.14431465f, -0.14935784f, 0.25853345f, 
    0.02931676f, -0.23715830f, -0.08407751f, -0.08038900f, 0.06928188f, -0.07024837f, 0.03389139f, 0.15299797f, 
    -0.12788127f, 0.16620931f, 0.20039611f, -0.07419341f, -0.39322087f, 0.44687322f, 0.32815772f, -0.31216002f, 
    0.07802883f, 0.15460847f, 0.05796229f, 0.03739692f, 0.01986751f, -0.07162973f, 0.13493532f, 0.07542095f, 
    0.03445227f, 0.06333000f, -0.00588050f, 0.07461507f, 0.02506892f, 0.02969150f, 0.11100302f, -0.01991125f, 
    0.20965800f, 0.17899139f, 0.00153652f, 0.02876835f, 0.03987903f, -0.04629617f, -0.03929549f, -0.04066968f, 
    0.03331641f, 0.12424003f, 0.06239258f, 0.05419768f, 0.14733206f, 0.14603323f, 0.05256993f, 0.01484723f, 
    0.00768974f, 0.16395690f, 0.09412836f, 0.10054959f, -0.30047765f, -0.34755272f, -0.29734734f, -0.04683691f, 
    -0.21040089f, 0.05265648f, 0.14672258f, 0.03440249f, 0.09398631f, -0.21636052f, -0.03880842f, -0.09405018f, 
    0.01489309f, 0.05731822f, 0.02814360f, 0.05021764f, -0.02890583f, 0.03864712f, 0.09316774f, 0.31975746f, 
    -0.21851276f, -0.25703293f, -0.17129378f, -0.05296065f, 0.20589480f, -0.05725418f, -0.11826251f, -0.05204248f, 
    0.03461261f, -0.08860638f, -0.16845584f, -0.22635275f, -0.08311749f, -0.19148555f, -0.12834336f, 0.10963471f, 
    -0.12869014f, 0.17635152f, 0.04838074f, -0.08881019f, -0.23914298f, 0.25292185f, 0.40187147f, -0.16042650f, 
    0.42371625f, -0.02862543f, -0.00270085f, -0.07027255f, -0.04450758f, -0.01300232f, 0.08029799f, 0.13162087f, 
    0.16757038f, 0.08534601f, 0.06283636f, -0.07272157f, 0.11555512f, 0.11230935f, 0.11376502f, -0.08883787f, 
    -0.02106024f, -0.02072758f, 0.07608784f, 0.03840188f, -0.00857749f, 0.00535648f, 0.13902417f, 0.14725901f, 
    0.00085684f, -0.00953743f, 0.00689459f, 0.06779697f, 0.00541057f, -0.03655278f, 0.01878305f, 0.17111748f, 
    -0.08393168f, 0.10122423f, 0.11762287f, 0.12389228f, -0.29092857f, -0.14578596f, 0.10496447f, 0.21612757f, 
    0.16246586f, 0.09846904f, -0.08860029f, -0.01499052f, -0.01336656f, 0.10796996f, -0.06980786f, 0.08978336f, 
    -0.02713286f, 0.09568220f, -0.06844466f, -0.09039837f, -0.13056728f, 0.12280735f, -0.04684076f, 0.08054224f, 
    -0.24750069f, -0.05729582f, 0.01204652f, 0.09436210f, -0.03829817f, -0.08936117f, 0.12875094f, 0.05792027f, 
    0.11261092f, -0.11626568f, -0.02518921f, 0.00222069f, -0.06130737f, 0.05282865f, 0.05094064f, 0.12060039f, 
    0.04551332f, 0.06165964f, 0.08922066f, 0.17024620f, -0.43041307f, -0.00377574f, 0.17600244f, -0.00123418f, 
    0.32153273f, 0.08991399f, -0.02441573f, -0.07745745f, 0.02248602f, 0.01403890f, -0.06811018f, 0.06678827f, 
    -0.01331821f, -0.01998551f, 0.04946523f, -0.00673963f, -0.03706533f, 0.08046643f, -0.08863966f, -0.07778078f, 
    0.18618459f, 0.00481174f, -0.09606612f, -0.06433648f, 0.19327579f, -0.00411641f, -0.11040270f, -0.07126588f, 
    -0.01856751f, 0.17884371f, 0.15964592f, 0.19718061f, 0.12131784f, 0.10130739f, 0.05878888f, 0.17638345f, 
    0.00136171f, 0.12590474f, 0.12002306f, 0.20137087f, 0.10285545f, 0.06999196f, -0.11408061f, -0.06894293f, 
    0.18232910f, 0.04210496f, 0.07642055f, -0.03495059f, 0.15962808f, 0.08523275f, 0.07365134f, -0.04425895f, 
    0.12315583f, -0.13494201f, 0.14046437f, 0.00497658f, 0.01422393f, -0.00591249f, 0.08616642f, 0.16798392f, 
    -0.13518330f, -0.30097419f, 0.12959230f, 0.11006881f, 0.25097588f, 0.10163489f, 0.22951525f, 0.14647606f, 
    0.07957875f, -0.24572921f, -0.04348817f, 0.05927691f, -0.06658401f, -0.10751427f, -0.00620799f, 0.04288049f, 
    -0.01695590f, 0.13742006f, -0.06458575f, 0.06766641f, 0.22116654f, 0.23808450f, 0.09718291f, -0.08811330f, 
    0.26884499f, -0.02288700f, -0.08518933f, -0.09121284f, 0.21563314f, 0.30646953f, 0.03992279f, 0.06442758f, 
    -0.03530176f, -0.08542273f, -0.02881722f, -0.05045310f, -0.05539835f, -0.02920453f, -0.02099112f, 0.06349604f, 
    -0.29386836f, 0.09462038f, 0.46673745f, -0.10646434f, 0.15192758f, -0.16170265f, -0.10914833f, 0.01618523f, 
    0.18049614f, 0.05719228f, 0.02437690f, 0.08144073f, 0.08062935f, 0.02003286f, 0.05309874f, -0.11626869f, 
    -0.10122721f, 0.00528508f, -0.10221903f, -0.07800673f, -0.48321620f, -0.37852204f, -0.05311510f, -0.21966098f, 
    0.02275637f, 0.05310107f, -0.09921230f, -0.06148615f, -0.09085708f, 0.04586304f, -0.05989549f, -0.14812288f, 
    -0.20019390f, -0.11370569f, -0.06767822f, -0.09368949f, -0.11158496f, 0.08046552f, -0.08138870f, -0.04569101f, 
    -0.34936643f, 0.15714462f, 0.51805747f, -0.09402876f, 0.44394091f, 0.14365323f, -0.10221463f, 0.10495930f, 
    0.05425148f, 0.07498867f, 0.09258512f, 0.07255369f, 0.13067564f, 0.12875320f, 0.10727243f, 0.04407717f, 
    -0.09957240f, 0.13495594f, 0.00504741f, -0.12318522f, 0.24665053f, 0.06234284f, -0.11583562f, -0.08389140f, 
    0.07747049f, 0.22253002f, -0.21423393f, 0.06039119f, -0.07033752f, 0.21733063f, 0.01673350f, 0.12448657f, 
    0.10647260f, 0.10442053f, 0.17112538f, 0.01155701f, 0.00100390f, -0.08058771f, 0.06418371f, 0.11843217f, 
    0.19571792f, -0.08510382f, -0.05973606f, -0.05393229f, -0.01977781f, 0.02185394f, -0.01594880f, -0.27414462f, 
    0.02111431f, 0.18963824f, 0.11017592f, -0.11181186f, 0.22061609f, -0.01449076f, 0.00321719f, -0.03608009f, 
    -0.07884797f, -0.04513633f, 0.07297641f, -0.03781657f, -0.20542905f, 0.07915655f, 0.01899416f, 0.01599063f, 
    0.16990633f, 0.14926267f, 0.06663154f, -0.07260351f, -0.02491784f, 0.03680183f, 0.07302140f, 0.03152378f, 
    0.07945652f, -0.06266863f, 0.07298894f, 0.07815754f, 0.11445446f, 0.05708720f, 0.00044849f, 0.03946833f, 
    0.05370568f, -0.22224815f, 0.17446128f, -0.06026627f, 0.04684402f, 0.05773975f, -0.07244822f, -0.13283598f, 
    0.09592614f, 0.06109738f, 0.15915239f, 0.05485353f, 0.08220579f, 0.09021990f, 0.06879807f, 0.07569360f, 
    0.06206490f, -0.14870468f, 0.10377084f, 0.14453734f, -0.07320198f, -0.01933512f, 0.30248779f, 0.00312667f, 
    0.02382970f, 0.00511353f, -0.08068146f, -0.04411097f, 0.03524903f, -0.06798275f, 0.03951595f, -0.02439414f, 
    0.01534124f, -0.06130781f, -0.00908109f, -0.00429089f, 0.01827188f, 0.07392729f, -0.00905246f, 0.04968159f, 
    -0.07903780f, -0.49414787f, -0.08666060f, 0.03938726f, -0.25887063f, 0.10573255f, 0.11276384f, -0.14729777f, 
    -0.02894430f, -0.11490815f, 0.01243023f, -0.05891682f, -0.05693758f, -0.02897047f, -0.01705184f, -0.05689456f, 
    0.00749583f, 0.01520619f, 0.03670033f, 0.19144680f, -0.06524707f, -0.29221994f, 0.07013894f, 0.19281051f, 
    -0.08225637f, -0.01294112f, -0.04208153f, -0.16709797f, 0.09405607f, 0.08767234f, -0.00304814f, -0.05716009f, 
    -0.07444348f, 0.07808277f, -0.03992824f, -0.04105791f, -0.05296678f, -0.02782222f, 0.01919021f, 0.12187554f, 
    -0.26437864f, -0.11503633f, 0.07103273f, 0.13999274f, 0.12420194f, 0.00654587f, 0.01977779f, -0.00803732f, 
    0.02784754f, 0.00549045f, -0.02167143f, 0.00126758f, -0.05354263f, -0.01217215f, 0.00076862f, 0.03655409f, 
    0.11238767f, 0.08886311f, 0.06945201f, 0.06269951f, -0.44039831f, 0.09457194f, 0.45407826f, -0.30376422f, 
    0.34029219f, -0.05871542f, -0.02102203f, -0.05115475f, 0.05370324f, 0.09991086f, -0.06678025f, 0.14135222f, 
    -0.01641886f, 0.09707888f, 0.16697298f, -0.24779032f, -0.17162348f, 0.06271245f, -0.01408778f, -0.05685886f, 
    0.06299209f, 0.23395346f, -0.02418138f, 0.11303382f, 0.39868894f, 0.07058242f, 0.19153284f, 0.16973528f, 
    0.21722735f, 0.26972774f, -0.00927618f, 0.02908921f, 0.04854132f, 0.00907827f, -0.01763150f, -0.09866848f, 
    0.06802487f, 0.03367941f, 0.07863995f, 0.06077521f, 0.15309913f, 0.00391536f, -0.17045037f, -0.08984841f, 
    0.16018471f, 0.01663283f, 0.26017964f, 0.14074033f, -0.01181395f, -0.13491136f, -0.16822313f, -0.06336908f, 
    -0.04275576f, -0.08673152f, -0.10477992f, 0.04713591f, 0.02817622f, 0.05952040f, -0.10945644f, 0.06857549f, 
    0.01230579f, 0.02604902f, 0.01799783f, -0.02601028f, -0.02016021f, -0.00351304f, -0.00391097f, 0.01751797f, 
    0.02898769f, -0.02235330f, 0.03176805f, 0.00093076f, 0.02557988f, 0.02435997f, -0.01976128f, -0.03287692f, 
    0.03041178f, -0.02749044f, -0.01896320f, -0.02811122f, 0.02563541f, 0.02947636f, -0.04082410f, -0.01012918f, 
    0.02668191f, 0.02950802f, 0.03036104f, 0.01965868f, 0.00191867f, -0.03332561f, 0.00815890f, 0.03363663f, 
    0.00786403f, 0.00732004f, -0.00690428f, -0.01782166f, 0.00432155f, 0.01312726f, 0.02400603f, -0.02440692f, 
    0.02288700f, -0.01663937f, 0.02210169f, 0.00625076f, -0.01188030f, -0.02756536f, 0.00681916f, -0.01142673f, 
    -0.02825030f, 0.00734034f, -0.03172219f, -0.00084205f, -0.04028488f, 0.00149202f, -0.03574845f, -0.02334845f, 
    -0.02877193f, -0.01919752f, 0.00707405f, 0.00160705f, 0.00253096f, -0.04393801f, -0.04336242f, -0.02500190f, 
    0.01189415f, 0.01609753f, -0.02329915f, 0.02187198f, -0.00861107f, 0.00179496f, 0.00250750f, 0.01346882f, 
    -0.01150553f, -0.03301402f, -0.01683208f, -0.03081890f, 0.03164041f, -0.00957092f, -0.01237042f, -0.04021680f, 
    0.01106160f, -0.01480425f, 0.00443810f, -0.04749040f, -0.03115473f, -0.00819946f, -0.00999228f, 0.01262543f, 
    -0.04156823f, 0.00211462f, 0.01326425f, -0.02281668f, -0.04616090f, 0.02489220f, -0.00073276f, -0.02753437f, 
    -0.02515311f, -0.03515068f, 0.00102687f, -0.03485128f, -0.03461201f, -0.02250641f, 0.01387651f, -0.01430386f, 
    -0.02488258f, 0.02725453f, 0.02019369f, -0.01812437f, -0.04453953f, -0.03851259f, 0.01324332f, -0.01515382f, 
    -0.01903099f, 0.00915255f, -0.01332919f, 0.00536560f, -0.03115415f, -0.01573246f, 0.01975597f, -0.02587393f, 
    0.00099441f, 0.00209738f, 0.02416194f, 0.00818132f, -0.04519307f, 0.00749369f, 0.00800622f, 0.01587258f, 
    -0.04443567f, -0.01384864f, 0.02817270f, -0.01693815f, -0.00296726f, 0.01242985f, -0.00196526f, 0.00513385f, 
    -0.03836651f, 0.01659315f, -0.01770122f, -0.04469943f, -0.01714824f, 0.01258398f, 0.01103117f, 0.02488617f, 
    -0.02661277f, 0.03203322f, 0.02955416f, -0.01549108f, 0.02391910f, 0.02699530f, -0.03327940f, 0.00276727f, 
    0.00032817f, -0.00049672f, -0.00776802f, 0.00390420f, -0.00999054f, -0.04006837f, 0.00753444f, -0.00077934f, 
    -0.00781101f, 0.00094717f, 0.00467941f, -0.02810418f, 0.00583200f, -0.02479922f, -0.03240718f, -0.01920599f, 
    -0.04512836f, -0.01677288f, -0.00813738f, -0.01599961f, -0.02661853f, 0.02326006f, -0.01797409f, 0.02578972f, 
    0.02115360f, -0.01297937f, -0.01023968f, 0.01713751f, -0.03518657f, 0.02412267f, 0.02616047f, -0.01699960f, 
    -0.01022801f, 0.00805423f, -0.03455321f, -0.00964708f, -0.03793810f, -0.03094101f, 0.03497225f, 0.01056911f, 
    0.01984218f, 0.00089879f, 0.01071905f, -0.00034777f, 0.01486410f, 0.00044881f, 0.03157402f, 0.01252365f, 
    -0.02429851f, 0.01192771f, 0.02847175f, -0.00209238f, -0.02459010f, 0.02662212f, -0.00570668f, -0.02743129f, 
    -0.04747857f, -0.00809516f, -0.02670640f, 0.00924085f, -0.04486920f, 0.01732334f, -0.03824073f, 0.02799956f, 
    -0.01022560f, 0.00644707f, 0.01053757f, -0.02945522f, -0.00838528f, -0.01066445f, -0.03893580f, 0.02938122f, 
    -0.01232896f, -0.00094844f, 0.01741448f, 0.02250210f, 0.00498360f, 0.01892984f, 0.01615602f, -0.00091245f, 
    -0.00373683f, 0.02244159f, -0.02109001f, 0.02697228f, 0.03534659f, 0.03475763f, 0.00612980f, 0.00418502f, 
    -0.01788611f, -0.04144698f, -0.01392411f, 0.02783170f, -0.02367800f, 0.01146132f, -0.03241829f, -0.01371664f, 
    0.00756473f, -0.03840663f, -0.02496091f, -0.01774088f, -0.01729378f, -0.00936744f, 0.00039966f, -0.03202461f, 
    -0.00940264f, -0.02779285f, 0.02436109f, 0.03072819f, -0.01722950f, -0.00686575f, 0.01990687f, -0.04216001f, 
    0.01687802f, 0.01778058f, 0.00140510f, 0.00015996f, -0.01767057f, 0.00780279f, -0.04041210f, -0.03417531f, 
    0.03214698f, 0.01207799f, 0.00600302f, 0.00019197f, -0.04155931f, -0.03624843f, -0.00292490f, 0.01245576f, 
    0.00126695f, 0.00550459f, -0.00380777f, -0.00324395f, 0.02233928f, -0.01687677f, 0.03285868f, -0.02796672f, 
    -0.02982148f, -0.03649599f, 0.00473024f, -0.04178778f, -0.02921030f, 0.01913492f, -0.00352207f, 0.00552588f, 
    0.01172782f, -0.04720370f, -0.01715085f, 0.01784713f, 0.02999063f, 0.01295365f, 0.01186991f, 0.03631266f, 
    0.00360241f, -0.02414335f, -0.00919893f, -0.01785065f, -0.04435469f, 0.01503066f, -0.03559595f, 0.00673911f, 
    -0.02297655f, -0.04620754f, 0.02404532f, -0.02602427f, -0.03112058f, 0.01290785f, 0.00865110f, 0.01387034f, 
    -0.02142982f, -0.02204019f, 0.00133127f, -0.03323364f, -0.00811983f, -0.01424954f, -0.02762318f, -0.02610490f, 
    -0.04578581f, 0.01532526f, -0.01132382f, 0.02411430f, 0.01194213f, -0.04113881f, -0.03287410f, -0.02124830f, 
    0.00302647f, 0.02191910f, -0.03065693f, 0.01056665f, 0.01250364f, -0.00919820f, 0.02941222f, 0.02145493f, 
    -0.02114341f, 0.01279572f, -0.02105208f, 0.01066053f, -0.01322055f, 0.00284755f, 0.02425377f, 0.02817604f, 
    -0.00070634f, 0.01792839f, -0.01907161f, 0.01579939f, -0.03025304f, 0.00879045f, 0.04191363f, -0.00052788f, 
    0.01816547f, -0.01261694f, 0.00673168f, 0.02311674f, -0.02194959f, 0.02789286f, -0.00872199f, -0.01684841f, 
    -0.00334175f, -0.03498757f, -0.00678514f, -0.00799970f, 0.01184031f, 0.01528106f, -0.01532039f, -0.02169087f, 
    -0.02862813f, -0.01041985f, 0.02729538f, -0.01694139f, -0.02567290f, -0.00048949f, 0.00129693f, -0.01135898f, 
    -0.00752016f, 0.02407594f, -0.00309282f, -0.01822321f, -0.00388240f, 0.03000300f, 0.00256613f, -0.02576431f, 
    -0.00635264f, 0.00755379f, -0.03574592f, -0.04279151f, 0.02592201f, -0.02482770f, -0.02281762f, -0.03927565f, 
    -0.00536053f, -0.01076117f, -0.04621247f, 0.01377635f, 0.02128224f, 0.03268090f, -0.01837756f, -0.03518366f, 
    -0.03996293f, 0.01645223f, 0.02258374f, 0.03219841f, 0.02608304f, -0.04584819f, -0.00342941f, 0.01071090f, 
    -0.00834485f, -0.02988786f, -0.03394874f, -0.00398610f, -0.02068257f, 0.02020922f, 0.02502964f, -0.03992794f, 
    -0.01615505f, 0.02276901f, -0.00683604f, -0.04531544f, -0.01200037f, -0.03135754f, -0.02564196f, -0.00127457f, 
    0.01820142f, -0.00343369f, 0.00939194f, -0.00988329f, 0.00380482f, 0.00127668f, 0.02403152f, -0.02511062f, 
    -0.03653999f, -0.02555862f, -0.02524123f, -0.03941216f, 0.03492486f, 0.03118283f, 0.02764103f, -0.00379850f, 
    -0.01843169f, 0.02991264f, -0.04833953f, 0.01740992f, 0.00869802f, 0.01452020f, 0.01918050f, -0.01692724f, 
    -0.01540471f, 0.01606126f, -0.01294268f, -0.02232253f, 0.01680614f, 0.01142428f, -0.02474489f, 0.00665049f, 
    -0.01989476f, -0.03799461f, -0.01857373f, -0.03747735f, 0.01682186f, 0.02122620f, 0.02455394f, -0.00039455f, 
    0.03109648f, 0.02388518f, 0.00572908f, -0.00131155f, -0.00258186f, 0.02950040f, -0.03642016f, 0.00930919f, 
    0.00641844f, -0.04688456f, -0.04737420f, 0.02812724f, 0.00206478f, 0.01088845f, -0.02444237f, -0.03681854f, 
    -0.00641231f, -0.02862390f, 0.02766430f, 0.02488442f, -0.03021315f, -0.02987743f, 0.02229254f, 0.03039237f, 
    -0.01621740f, -0.02587185f, -0.01147665f, 0.00365013f, 0.04070080f, 0.03142451f, 0.00020467f, 0.00848021f, 
    0.02159639f, -0.03449379f, -0.02661543f, 0.03460350f, 0.02542185f, 0.02706737f, -0.03290476f, 0.01549149f, 
    -0.00861517f, 0.00669766f, -0.04205611f, -0.00691355f, -0.01818925f, 0.03488090f, -0.03666059f, 0.03471523f, 
    -0.03468773f, -0.01134724f, -0.02978080f, 0.01124359f, 0.01073226f, 0.02108113f, -0.01551331f, 0.01148936f, 
    -0.04467724f, 0.02382104f, -0.01099654f, -0.02387058f, 0.01433733f, -0.01064468f, -0.01282875f, 0.02758781f, 
    0.00665684f, -0.03542796f, -0.00838260f, -0.03366566f, -0.03927869f, -0.04502412f, -0.03517620f, -0.01811281f, 
    -0.01718843f, -0.04450646f, -0.03674272f, 0.01403129f, -0.02932820f, -0.04419312f, -0.04965080f, -0.04183220f, 
    -0.02316678f, 0.00285419f, 0.00811158f, 0.00839735f, 0.00510402f, -0.03493241f, 0.00702406f, -0.02499997f, 
    -0.04476892f, -0.04067670f, 0.01975202f, 0.02294953f, -0.02415523f, -0.02202223f, -0.03379510f, -0.03451277f, 
    -0.00578473f, 0.02902596f, -0.03264737f, -0.02163402f, -0.03887539f, -0.03683905f, -0.04259882f, -0.02519674f, 
    0.01669974f, -0.02478532f, 0.01693768f, 0.01769067f, -0.00143466f, 0.02514866f, 0.02091597f, -0.03730970f, 
    -0.03017442f, -0.03471071f, 0.02620352f, 0.00798483f, -0.01563844f, 0.03406177f, -0.03986069f, -0.02591900f, 
    0.01265987f, -0.03484984f, 0.00442873f, -0.03883491f, -0.04512681f, 0.01825398f, 0.03952197f, -0.02192011f, 
    -0.03357285f, 0.00195539f, -0.04415048f, 0.01710236f, -0.01227865f, 0.01965520f, -0.02924438f, -0.00417765f, 
    -0.02761623f, -0.02660704f, -0.02612365f, 0.01340147f, -0.02727412f, -0.01800073f, 0.02063721f, 0.01119806f, 
    -0.04621435f, -0.00347497f, -0.00539529f, -0.02154858f, 0.02479536f, -0.03408571f, -0.00931182f, -0.02526536f, 
    0.00027253f, 0.02059804f, 0.00845951f, -0.01551829f, 0.00027082f, 0.00338572f, -0.01728420f, -0.00659880f, 
    0.01914228f, -0.02522315f, -0.02295114f, 0.00850608f, -0.01942967f, 0.02400926f, 0.00857363f, 0.01117116f, 
    0.00466246f, -0.00693262f, 0.02293392f, 0.01199983f, -0.04409833f, 0.02546116f, -0.04052179f, 0.02856420f, 
    0.02971358f, 0.02455597f, -0.01386479f, -0.01473259f, 0.00384612f, -0.03377302f, -0.01294173f, 0.00306447f, 
    -0.02544305f, -0.00382809f, -0.00262704f, -0.02627089f, -0.00581190f, -0.00935289f, 0.00249317f, -0.03525455f, 
    -0.02277533f, 0.00533584f, -0.01580036f, 0.00145622f, 0.01439219f, 0.01212003f, -0.03504010f, -0.00835241f, 
    -0.02222919f, -0.00606216f, -0.00293481f, -0.02961280f, -0.01589106f, 0.01832007f, 0.01909607f, -0.02977565f, 
    0.01416444f, -0.03393776f, 0.02123258f, 0.02582345f, -0.02012575f, 0.00279424f, -0.03112866f, 0.00579344f, 
    -0.04346742f, -0.01749897f, 0.02748634f, -0.02596282f, -0.02789611f, -0.02465557f, 0.00086431f, -0.03764859f, 
    -0.00730346f, -0.02135509f, 0.00515710f, 0.00678787f, -0.02486446f, 0.00284657f, -0.03334321f, 0.02924012f, 
    -0.00365574f, 0.00309583f, -0.01220474f, -0.02907430f, 0.01524514f, -0.02913037f, 0.02018146f, -0.00961361f, 
    0.00696135f, 0.02985677f, 0.02986667f, -0.00723670f, -0.00635874f, 0.01431711f, -0.04472064f, 0.01811435f, 
    0.01426139f, -0.02888874f, 0.01260810f, -0.03860411f, -0.02343287f, 0.00255422f, 0.01022286f, -0.03454609f, 
    0.02168432f, 0.02405217f, 0.00502720f, -0.02338769f, -0.03032893f, -0.02281476f, 0.01541666f, 0.01802831f, 
    0.01290827f, -0.04818656f, -0.02705508f, -0.00928063f, -0.02567091f, -0.01143814f, 0.02813071f, -0.04640368f, 
    0.01549944f, -0.04103213f, -0.01334340f, -0.01733483f, 0.00210691f, 0.02664918f, -0.03583646f, 0.01326088f, 
    -0.00215294f, -0.00143932f, 0.00611129f, -0.00458746f, -0.03845849f, -0.04375153f, -0.01396634f, -0.01783391f, 
    -0.04125326f, -0.01461990f, -0.02721638f, -0.00616559f, 0.00576865f, -0.04839917f, 0.02075235f, 0.01405665f, 
    0.00838059f, 0.01290367f, 0.02804936f, -0.04221559f, -0.00159818f, -0.04076970f, 0.02978216f, -0.04297985f, 
    -0.01972870f, 0.01941001f, 0.01368680f, -0.02097879f, 0.00425072f, 0.02424602f, 0.00895736f, -0.04335341f, 
    0.00376591f, -0.02390087f, -0.00753739f, 0.02471483f, 0.00535841f, 0.01181375f, -0.00299057f, 0.01296017f, 
    -0.03277314f, -0.04749174f, 0.02212534f, 0.00768721f, -0.03359403f, 0.00829795f, -0.04296796f, -0.03300406f, 
    -0.03387238f, 0.00713010f, -0.00488158f, -0.02455730f, 0.01373407f, -0.03025597f, -0.01140900f, 0.03826442f, 
    -0.03848369f, -0.03265366f, 0.02163519f, -0.00481773f, -0.01281789f, -0.01657933f, -0.02244158f, 0.03363988f, 
    -0.03649912f, -0.02390481f, -0.02706164f, 0.02369324f, -0.01899826f, 0.02599221f, -0.04531286f, 0.02807695f, 
    -0.01586149f, -0.03714357f, 0.01865563f, -0.03216682f, -0.03479352f, -0.04130759f, 0.02664150f, -0.01105308f, 
    -0.02918400f, -0.02627372f, 0.00338910f, 0.02287554f, -0.02370645f, -0.03683614f, 0.00792836f, 0.00329307f, 
    -0.02039861f, -0.01088596f, -0.00644985f, 0.02459397f, 0.02021740f, -0.03886793f, -0.01096790f, 0.02234556f, 
    -0.01605818f, 0.02420701f, -0.03294760f, 0.01962737f, -0.03039437f, -0.04365731f, -0.00522243f, 0.01421949f, 
    -0.02797907f, 0.01170621f, -0.04010364f, 0.00380256f, -0.01725319f, -0.00123287f, 0.00753775f, -0.01419333f, 
    -0.04545655f, -0.03337520f, 0.01505539f, -0.02779011f, 0.00722772f, -0.03259913f, 0.01370108f, -0.03218013f, 
    -0.04726398f, -0.00015591f, -0.03155211f, -0.01863840f, -0.01632555f, -0.00702748f, 0.00954030f, -0.01657687f, 
    0.01323542f, 0.00885422f, -0.02581817f, -0.03319447f, -0.03778611f, 0.01184199f, -0.02155852f, -0.03170758f, 
    -0.03422258f, -0.04542315f, 0.00539115f, -0.04792137f, 0.01825322f, 0.02208167f, -0.01279246f, -0.02903416f, 
    -0.01249447f, -0.03048178f, -0.02635742f, -0.00965762f, 0.02322158f, -0.00051376f, 0.01350372f, -0.03902347f, 
    0.01172598f, 0.01433377f, 0.00924971f, -0.02683960f, -0.03642373f, -0.01201645f, -0.04362873f, -0.03260454f, 
    0.00220263f, -0.04501679f, -0.00159530f, -0.04671780f, -0.03357510f, -0.02138170f, -0.04525021f, -0.02775713f, 
    -0.01657201f, -0.02182993f, 0.00659634f, 0.01986342f, -0.01036096f, 0.00402642f, -0.02928218f, -0.01693785f, 
    -0.00239084f, 0.02222301f, -0.00363971f, 0.01788902f, -0.01859787f, -0.00187502f, 0.00440926f, -0.04889606f, 
    -0.02482486f, -0.01505352f, 0.02831179f, -0.01538221f, -0.01428943f, -0.02433962f, -0.01885549f, -0.03876829f, 
    -0.03833041f, -0.01328664f, -0.04691642f, -0.00637808f, -0.04573669f, -0.02246209f, -0.04634241f, 0.00055484f, 
    -0.04706285f, -0.03976484f, 0.01782065f, -0.02889473f, -0.01888794f, 0.02148761f, -0.01048789f, 0.00493663f, 
    -0.01301979f, -0.02884375f, 0.01998644f, -0.01664496f, 0.02658842f, -0.04205585f, -0.02193673f, 0.01237951f, 
    -0.01106312f, 0.02963572f, -0.02014771f, -0.02698503f, 0.01352331f, 0.01306019f, 0.00745707f, -0.02887023f, 
    -0.04224666f, -0.04013426f, 0.02695356f, 0.02732013f, 0.00292625f, -0.03236996f, 0.01041048f, -0.02063764f, 
    0.01655484f, -0.03268415f, 0.00386335f, 0.03424849f, -0.00857109f, -0.01152720f, -0.02309249f, -0.02861771f, 
    0.00244490f, -0.01080372f, -0.02514355f, -0.04321628f, 0.02802301f, 0.00851444f, -0.04194044f, -0.02417256f, 
    0.00416516f, 0.01535446f, -0.00669097f, -0.01159877f, -0.01574033f, -0.01817308f, -0.01202533f, -0.03249275f, 
    -0.01158377f, -0.02882851f, 0.02533928f, 0.00524821f, 0.02622898f, -0.01465184f, -0.01815524f, 0.00514781f, 
    -0.04422034f, -0.03141427f, 0.00013666f, -0.03029672f, -0.03917085f, -0.00234252f, -0.02577045f, -0.03026276f, 
    0.00364207f, -0.02591031f, 0.01149911f, 0.02359090f, -0.00177174f, 0.03435471f, 0.03393017f, -0.02655506f, 
    0.03638148f, -0.01543928f, -0.03411475f, -0.03058982f, 0.03346023f, -0.03871741f, -0.00216747f, -0.01465006f, 
    -0.02525616f, -0.01113549f, -0.03318565f, 0.00560344f, -0.03925657f, -0.03228196f, -0.01413304f, -0.00922557f, 
    -0.01977799f, 0.01539120f, -0.01695853f, -0.00826687f, -0.00190389f, -0.02185227f, -0.02217611f, 0.02564918f, 
    -0.02450124f, -0.00610630f, -0.01365269f, -0.01549525f, -0.03185654f, -0.02046554f, -0.00875103f, 0.02744839f, 
    -0.00804297f, -0.02926435f, -0.01675472f, -0.04754924f, 0.02139257f, 0.00858820f, -0.04645519f, -0.04755049f, 
    -0.03419663f, 0.02438757f, -0.00141627f, -0.00809258f, -0.02405330f, -0.02733751f, -0.02051153f, 0.01659182f, 
    -0.00333889f, -0.02131168f, -0.01670578f, 0.02638151f, -0.04694299f, -0.01568168f, 0.02929020f, 0.01728351f, 
    -0.02711287f, 0.00733138f, -0.00977337f, -0.01720978f, -0.01994183f, -0.04507763f, -0.01946769f, 0.02549505f, 
    -0.02802006f, -0.02162803f, -0.00412697f, -0.02946280f, 0.00586509f, 0.03515321f, -0.01855654f, 0.02601132f, 
    0.00339430f, -0.03928109f, -0.00642385f, -0.02934916f, -0.00895238f, -0.01142817f, -0.00223992f, -0.03648118f, 
    -0.00259619f, -0.04562760f, 0.00949380f, -0.03900233f, -0.00484537f, -0.04436646f, 0.02052904f, 0.00748984f, 
    0.00042034f, 0.01198889f, -0.00542699f, -0.03384509f, -0.04701314f, -0.01225212f, -0.02605863f, 0.01172218f, 
    -0.03725269f, -0.00981025f, -0.03802050f, -0.03768237f, 0.01379838f, 0.02962743f, -0.01139111f, -0.04640220f, 
    -0.00211692f, -0.03578662f, 0.01120457f, 0.02200094f, -0.01101499f, -0.04183596f, 0.02528558f, -0.03199643f, 
    0.00693745f, -0.03017498f, -0.02185793f, 0.02122463f, -0.04119460f, -0.03130632f, -0.01382563f, -0.03195500f, 
    -0.04554673f, 0.00386381f, -0.03781622f, -0.01581617f, 0.01592770f, -0.02980124f, 0.02746391f, -0.01545125f, 
    -0.04832295f, 0.02449279f, -0.01508029f, -0.04178441f, -0.02097241f, -0.01966530f, -0.00050212f, -0.01633123f, 
    -0.02570989f, -0.01377118f, 0.00995667f, 0.00176997f, -0.04047523f, -0.01154250f, 0.02192719f, -0.02845957f, 
    -0.04164935f, 0.00193172f, -0.04379570f, 0.00933594f, -0.01710290f, -0.01124656f, -0.03725300f, 0.02003306f, 
    -0.03165101f, -0.03159144f, -0.03191660f, -0.02702107f, 0.00827829f, 0.00024451f, -0.04678751f, -0.03260903f, 
    -0.04536526f, 0.00797980f, -0.00082389f, -0.01322264f, 0.00248132f, -0.00411320f, -0.00667552f, -0.00077321f, 
    -0.03519139f, 0.01961768f, -0.04719941f, -0.04473983f, -0.03896068f, -0.03630112f, 0.00915230f, -0.00750659f, 
    -0.04047190f, -0.02155955f, -0.01687015f, -0.04292745f, 0.02024573f, 0.01650123f, -0.00341423f, -0.00289960f, 
    -0.00372758f, -0.00042395f, 0.01532626f, 0.00280078f, -0.04784830f, -0.03463219f, 0.03357759f, 0.00478364f, 
    0.01361869f, -0.00830115f, -0.02669134f, 0.01878005f, -0.00506648f, -0.02256763f, 0.01367389f, 0.01690296f, 
    -0.03426689f, -0.01853376f, -0.01769410f, -0.01589200f, 0.01201286f, -0.02115725f, -0.04503129f, 0.00034103f, 
    0.02565778f, -0.02760022f, 0.02428092f, 0.00456677f, -0.01066348f, -0.03899387f, -0.01037368f, 0.00297984f, 
    -0.03909294f, -0.03179643f, -0.04815673f, -0.04430786f, -0.02545119f, -0.03359998f, 0.02539150f, -0.02235815f, 
    -0.03976730f, -0.02274127f, 0.02455298f, -0.02642388f, 0.00219076f, -0.00871508f, -0.00731769f, 0.00582112f, 
    0.02060378f, 0.01286800f, 0.02476641f, -0.03322963f, -0.03249355f, 0.00269855f, 0.02012328f, -0.01391499f, 
    -0.01712066f, 0.00359650f, 0.02050577f, -0.00809528f, 0.01482769f, -0.02597522f, 0.02185382f, -0.01074688f, 
    -0.37259856f, 0.23867677f, -0.09514014f, 0.19078673f, 0.07999757f, 0.04119982f, 0.15368345f, -0.00297549f, 
    0.11730280f, 0.20144664f, -0.02578478f, 0.07336435f, 0.03764072f, 0.08251532f, 0.09885371f, 0.09516669f, 
    0.11427384f, 0.25469503f, 0.13079852f, 0.09157562f, 0.66741133f, 0.18969019f, 0.03674567f, 0.26912224f, 
    0.12066026f, -0.14543428f, -0.08258735f, -0.04313783f, -0.05267633f, -0.07243501f, -0.04437294f, 0.08584730f, 
    0.02660641f, 0.09566769f, 0.08553809f, 0.23163573f, 0.03393395f, 0.10422890f, 0.19014446f, -0.00502915f, 
    0.40706885f, 0.14608698f, -0.55175418f, 0.11687024f, -0.03987669f, -0.12881908f, -0.02562652f, 0.08783814f, 
    -0.18454650f, 0.06181932f, 0.19407570f, 0.07208146f, 0.09310734f, -0.10480303f, -0.04621961f, -0.10336357f, 
    -0.01219086f, -0.00387683f, -0.00459191f, 0.00053247f, 0.06163553f, 0.04389642f, 0.14481525f, -0.00204365f, 
    0.10435710f, 0.16050485f, 0.04097399f, 0.06554349f, 0.20427378f, 0.27648196f, -0.06727171f, -0.03786103f, 
    0.04753381f, 0.03681136f, 0.05159178f, 0.06878607f, 0.15811196f, 0.22881065f, 0.23543808f, 0.22837794f, 
    0.16384977f, -0.49535528f, 0.17535761f, 0.33460519f, -0.32536659f, -0.06949458f, 0.01095536f, 0.04473630f, 
    -0.09064256f, 0.02356702f, 0.12843169f, 0.25407976f, 0.06854892f, 0.05918279f, 0.04439389f, 0.09286087f, 
    -0.14450091f, -0.16938752f, 0.17807205f, 0.06039741f, 0.65172029f, 0.46317255f, -0.27994174f, 0.24114573f, 
    0.08682361f, 0.24164787f, -0.02260605f, 0.14426684f, 0.25136283f, 0.08737593f, 0.21176127f, 0.03835411f, 
    0.05446617f, -0.00600852f, 0.12392097f, 0.08909892f, -0.00146650f, 0.28802407f, 0.22327423f, 0.21479560f, 
    -0.01752319f, -0.04188411f, 0.32798332f, 0.04783372f, 0.04502269f, -0.04219936f, 0.04717019f, 0.16107559f, 
    0.12591819f, -0.09199341f, 0.16188215f, 0.20768449f, -0.01911491f, 0.16354296f, -0.02928430f, -0.01612644f, 
    0.15750560f, -0.06783291f, 0.20043148f, 0.03033840f, -0.09338666f, 0.07065930f, -0.03162356f, 0.03866258f, 
    0.13747780f, -0.01467013f, 0.08424269f, -0.06296469f, -0.00086249f, 0.10315683f, -0.12330672f, 0.02690830f, 
    -0.06342871f, -0.07107914f, 0.02525221f, -0.06732248f, -0.01238041f, 0.13246854f, 0.17482261f, 0.21030782f, 
    0.08878225f, 0.08979420f, 0.27029389f, 0.11608498f, 0.03306578f, -0.04674268f, -0.12515038f, -0.04152599f, 
    0.06143615f, -0.04907196f, -0.05521455f, 0.02329964f, 0.03609833f, 0.01058976f, 0.01503495f, -0.16376132f, 
    0.08283426f, -0.13520938f, -0.06222206f, -0.06157526f, 0.44074625f, 0.26840654f, -0.04617799f, 0.03905774f, 
    -0.24651782f, -0.03687409f, -0.07255445f, -0.00974958f, -0.11529978f, -0.06514252f, 0.13156307f, -0.03784436f, 
    0.04032978f, -0.10142352f, 0.02877123f, 0.27900696f, 0.07009876f, 0.15989940f, 0.17599858f, 0.26186284f, 
    -0.21045400f, -0.09322912f, 0.17340979f, 0.01502719f, 0.13927239f, 0.10479505f, 0.23178336f, 0.14280164f, 
    0.26564801f, 0.28710201f, -0.00975565f, 0.01334076f, -0.03571245f, -0.05645492f, 0.03047093f, 0.03586295f, 
    0.00261629f, 0.14143313f, -0.01370353f, -0.01532075f, -0.08454183f, 0.13469918f, 0.06481916f, -0.12674066f, 
    -0.14218247f, -0.03018327f, 0.18543418f, -0.02047871f, 0.20000200f, 0.10868850f, 0.03570897f, -0.00925776f, 
    0.02513406f, -0.18831119f, -0.00518660f, 0.08111659f, 0.05751791f, 0.10792906f, 0.10487646f, 0.12126216f, 
    0.00175900f, 0.10141227f, 0.04078280f, 0.07776567f, 0.17515284f, 0.17403343f, 0.15356822f, 0.00068820f, 
    0.10928986f, 0.23623362f, -0.06329352f, -0.02604830f, 0.09891138f, 0.01491631f, 0.06593458f, 0.07169495f, 
    0.07776833f, 0.23298152f, 0.05030241f, 0.09629623f, 0.58161074f, 0.35840541f, 0.20581625f, 0.07325305f, 
    0.20766716f, -0.07193035f, -0.00276326f, -0.01358165f, 0.05445855f, -0.06071456f, -0.07623136f, -0.07461938f, 
    -0.05296262f, 0.03691261f, 0.00351676f, 0.04524156f, -0.06918879f, 0.07789177f, 0.08022247f, -0.02462306f, 
    0.25022915f, 0.20704797f, 0.27730158f, 0.32742023f, 0.15690900f, -0.06559475f, -0.04721147f, 0.09118596f, 
    0.00635288f, -0.05825977f, 0.18014744f, 0.07247804f, 0.15875074f, 0.08738156f, 0.12405737f, 0.09195134f, 
    0.09231991f, 0.13815926f, 0.08988496f, 0.05776067f, 0.03995762f, 0.34602243f, 0.13742264f, 0.19193380f, 
    0.03664005f, 0.27896369f, 0.01817739f, 0.08171082f, 0.13278346f, 0.04046121f, -0.01314756f, 0.04754350f, 
    0.12951404f, 0.01681652f, 0.01286463f, 0.02956499f, 0.33754244f, -0.09522894f, 0.07114186f, 0.12838539f, 
    -0.01504263f, -0.00822376f, 0.08407591f, -0.08104423f, -0.23251151f, -0.02082555f, 0.14537033f, -0.02531120f, 
    0.15522718f, 0.39981094f, -0.13840653f, 0.00421548f, -0.09916961f, -0.05563118f, -0.02131383f, 0.01346378f, 
    0.01495949f, -0.07070215f, 0.04998500f, 0.12248576f, -0.07382710f, 0.04516326f, -0.16169862f, -0.02743581f, 
    -0.08392055f, -0.14262518f, 0.04712258f, 0.21690120f, -0.24185999f, -0.10765812f, 0.07023706f, 0.05151540f, 
    -0.07269812f, -0.07438384f, -0.11402533f, -0.07857020f, -0.00098998f, -0.07325210f, 0.05600359f, -0.08826331f, 
    0.12722848f, -0.09793640f, -0.34446922f, -0.04232457f, -0.09349652f, -0.07350821f, -0.09171151f, -0.00616490f, 
    0.07938536f, -0.12097190f, -0.06725917f, 0.07127760f, -0.17582533f, -0.10400984f, -0.11085045f, -0.23508574f, 
    -0.17816404f, -0.10020570f, -0.06126091f, -0.08740786f, 0.32525092f, 0.16701214f, 0.28587747f, 0.25782630f, 
    0.09405562f, -0.00525955f, -0.06526832f, -0.02898849f, 0.02668581f, 0.00385273f, -0.12612861f, -0.05676673f, 
    -0.05491684f, -0.01511530f, -0.03458004f, 0.08556562f, 0.11726687f, -0.15288234f, -0.08738440f, -0.09213904f, 
    0.36834940f, 0.10065307f, -0.22371541f, -0.04699588f, -0.24799806f, 0.06776324f, -0.03140384f, 0.22186075f, 
    0.04222493f, 0.01526381f, 0.17130542f, -0.03665382f, -0.23975615f, 0.00467834f, 0.10243003f, -0.02203629f, 
    -0.07883260f, 0.19056149f, 0.09091582f, 0.06238259f, -0.10674577f, 0.25463539f, 0.34764293f, 0.10257599f, 
    0.13118148f, -0.11200456f, 0.15858838f, 0.15176670f, -0.11565278f, 0.02184547f, 0.18407255f, 0.08074017f, 
    0.08615758f, 0.10467502f, 0.04037151f, 0.12002831f, 0.12677750f, 0.01510338f, -0.09454787f, -0.04967244f, 
    0.16464844f, 0.07903134f, 0.12403548f, 0.10053071f, 0.01299437f, -0.06479231f, -0.06656733f, 0.14338936f, 
    0.06042113f, -0.00201428f, 0.21277262f, 0.11249000f, 0.08300819f, 0.16532400f, -0.04694810f, -0.20272303f, 
    -0.12064361f, -0.06248547f, 0.01037461f, -0.07672547f, 0.09046659f, 0.28108424f, 0.17162943f, 0.06013109f, 
    0.06312517f, -0.02959961f, 0.03908774f, -0.07441753f, 0.12730159f, 0.02215030f, -0.08957014f, -0.01321939f, 
    0.04687390f, 0.03234730f, -0.01765186f, 0.07312685f, 0.08963401f, 0.07556693f, 0.10476167f, -0.02330944f, 
    0.04660545f, 0.12361097f, 0.21779273f, -0.00815908f, 0.09408495f, 0.05968748f, -0.01594971f, 0.07746696f, 
    0.10213787f, -0.07334747f, -0.04038563f, 0.08301518f, 0.09438092f, -0.01058122f, -0.00698220f, -0.07690187f, 
    -0.04729877f, -0.10194510f, 0.04935088f, -0.06097376f, 0.07415218f, -0.06634565f, -0.06813052f, 0.12047801f, 
    0.09333984f, -0.03726482f, 0.06032141f, -0.00084254f, 0.13244946f, 0.00764488f, 0.00911381f, 0.04294273f, 
    -0.14969410f, -0.02113972f, -0.05451109f, -0.06910104f, 0.00330244f, 0.03879388f, 0.09792863f, 0.00043063f, 
    -0.13557723f, 0.01781610f, 0.05618680f, 0.00401881f, 0.10068322f, 0.11720565f, 0.09316651f, -0.17297469f, 
    0.01774814f, -0.00323149f, -0.10322277f, 0.09710063f, -0.08538094f, -0.05370866f, -0.06490405f, -0.11402166f, 
    -0.08515892f, 0.16388351f, 0.05519600f, 0.08230555f, -0.07912446f, -0.00431290f, 0.02808538f, -0.07033245f, 
    0.11062538f, -0.00790467f, 0.09015008f, -0.03018585f, 0.01621606f, 0.01358189f, -0.12213403f, -0.00983242f, 
    -0.05078758f, -0.10834344f, -0.07589260f, -0.02764167f, 0.04428584f, 0.06764913f, -0.00728420f, 0.01318604f, 
    -0.03981064f, 0.13094932f, 0.08522869f, 0.00128278f, 0.07440267f, 0.20704208f, 0.12945737f, 0.04741966f, 
    0.13193128f, 0.22976328f, -0.03050482f, 0.01393514f, 0.08335502f, -0.00080194f, 0.07526071f, 0.22500777f, 
    0.22059266f, 0.13515447f, 0.29763415f, 0.19878450f, -0.00607105f, -0.17398848f, -0.08404338f, -0.29264981f, 
    -0.02956923f, 0.02214998f, -0.11754554f, 0.06539875f, 0.06255006f, -0.15448089f, 0.08674843f, 0.18647155f, 
    0.01606897f, 0.00999149f, -0.00764081f, -0.17497730f, -0.13403264f, -0.13441983f, -0.06764397f, -0.02412388f, 
    -0.10757190f, -0.00567032f, 0.05335947f, -0.12618724f, 0.00733636f, 0.10429471f, 0.07673138f, 0.09390317f, 
    -0.09951366f, 0.04941317f, -0.01768504f, 0.05474972f, -0.05289622f, -0.00221714f, 0.03194175f, 0.14484440f, 
    0.25192967f, 0.06141661f, 0.18342756f, 0.11118753f, -0.08287924f, -0.14531791f, 0.11778086f, 0.04836595f, 
    -0.06237999f, 0.10227987f, 0.07658570f, 0.10425394f, 0.06438737f, 0.06803986f, 0.06184516f, 0.12188576f, 
    -0.09875908f, 0.10114222f, 0.10248379f, -0.02903195f, -0.06103020f, 0.03013089f, 0.15409000f, 0.25523406f, 
    -0.01424072f, 0.00098447f, -0.00660864f, 0.01792726f, 0.01524039f, -0.02008018f, -0.01423742f, -0.02769208f, 
    -0.02669363f, -0.02088030f, 0.02759637f, 0.01106826f, -0.00645020f, 0.02109591f, -0.02509856f, -0.03582157f, 
    -0.02480814f, 0.01878391f, -0.00881889f, -0.00136581f, 0.03149941f, -0.00072100f, -0.04200773f, 0.01640556f, 
    -0.00554151f, 0.00619581f, 0.01568896f, -0.00111617f, -0.01987445f, 0.00717198f, 0.01627237f, 0.00513969f, 
    0.01335467f, 0.00516262f, -0.04194735f, -0.00371549f, -0.00351005f, -0.00992413f, 0.00372401f, -0.03676745f, 
    -0.03739036f, -0.04148245f, -0.00713426f, 0.00593521f, 0.03241963f, 0.02587922f, 0.03082019f, 0.03240475f, 
    -0.03804614f, 0.01164758f, 0.02745435f, 0.03121069f, -0.02648164f, -0.01619873f, -0.01413327f, 0.02722639f, 
    -0.02435924f, -0.00158095f, -0.01657585f, 0.00069955f, 0.02441999f, -0.01430484f, 0.00728809f, 0.03107060f, 
    0.00899897f, -0.02170030f, -0.03696602f, -0.00102128f, -0.01872117f, -0.04345519f, -0.03742427f, -0.01496372f, 
    0.00275302f, -0.02995877f, -0.04358469f, -0.03678045f, -0.01004868f, 0.02700864f, -0.00759933f, -0.03120419f, 
    0.00431310f, 0.02222165f, 0.00890653f, -0.03952795f, -0.01756636f, 0.03104614f, -0.04206445f, -0.02384603f, 
    -0.04542445f, 0.00516147f, -0.00900941f, 0.00765879f, -0.03396249f, -0.03863258f, 0.01268863f, 0.02306068f, 
    0.00265270f, 0.01414427f, -0.00298968f, -0.03481802f, -0.02148125f, 0.02047386f, -0.00361495f, -0.04211347f, 
    -0.00984338f, 0.00764221f, 0.00954410f, -0.04109361f, -0.01641875f, 0.00805501f, 0.02647002f, 0.00440533f, 
    -0.00622746f, 0.01142899f, -0.01571879f, 0.03350947f, -0.01208889f, -0.02865888f, 0.03240526f, -0.02710632f, 
    0.02678095f, 0.02979367f, -0.01574192f, 0.02445978f, -0.02453314f, 0.02778601f, -0.03635905f, -0.00103729f, 
    0.00880712f, -0.01029343f, 0.00683087f, -0.03887957f, -0.01715648f, -0.03969683f, -0.00567599f, -0.04464526f, 
    -0.03846027f, 0.00000529f, -0.01838298f, 0.00282838f, -0.03651176f, 0.01691322f, 0.02204043f, 0.00005707f, 
    0.03931265f, -0.00373992f, 0.01376546f, -0.02108957f, -0.01453859f, 0.03127938f, -0.03091101f, 0.03317418f, 
    0.03299259f, 0.02875725f, 0.00485658f, -0.04414686f, -0.04293929f, -0.04493936f, 0.00014693f, -0.01943752f, 
    0.01935860f, 0.00936586f, -0.01483872f, 0.00544518f, 0.00796702f, 0.02775504f, -0.00303655f, -0.01742769f, 
    -0.02686560f, -0.02615635f, 0.03334646f, 0.00600580f, -0.01696773f, 0.00498051f, -0.01849481f, -0.02013921f, 
    -0.02679703f, -0.03270051f, 0.02753160f, -0.02457792f, -0.01270842f, -0.02822602f, -0.03601100f, -0.02960603f, 
    -0.01076244f, -0.04220487f, -0.01060053f, -0.03609011f, -0.03446659f, -0.04343406f, -0.01409049f, 0.00132317f, 
    -0.03813475f, -0.03157540f, 0.01647870f, 0.03825945f, -0.04352903f, 0.01003217f, 0.03099846f, -0.03961290f, 
    0.02586187f, -0.00286969f, 0.02707702f, 0.00871047f, -0.00076278f, -0.00274043f, 0.00546346f, 0.03300999f, 
    0.00296511f, -0.00663238f, -0.04534606f, -0.03054335f, -0.02929315f, -0.01901051f, -0.04178809f, -0.01305807f, 
    -0.03656016f, -0.01976037f, -0.03595147f, 0.02628706f, -0.00635616f, -0.01631352f, -0.01696125f, -0.00113557f, 
    0.01219363f, -0.00994126f, -0.04459587f, -0.00223804f, -0.00296432f, -0.03570416f, 0.02375510f, 0.02598834f, 
    -0.03665959f, -0.03772821f, -0.01199201f, -0.04170371f, -0.02987579f, -0.00196550f, 0.00595018f, 0.01135970f, 
    -0.02231714f, 0.03715231f, 0.01110912f, -0.00503240f, -0.04491295f, -0.00977316f, -0.00193789f, -0.02766769f, 
    0.02371015f, -0.01109675f, -0.00283827f, 0.00913371f, 0.01648282f, -0.04190456f, 0.01431146f, 0.01369521f, 
    -0.01473793f, -0.03518765f, -0.00829216f, 0.02311102f, 0.01743898f, -0.02849221f, 0.00513583f, 0.02932065f, 
    -0.04266100f, -0.01670095f, 0.00060951f, 0.00965304f, -0.02478065f, 0.01860076f, -0.04073751f, -0.03027234f, 
    0.01654646f, -0.04390785f, 0.01709579f, -0.02906970f, -0.03597023f, -0.01218759f, -0.04114608f, -0.02376769f, 
    -0.04289852f, 0.00808155f, -0.03781902f, -0.02396446f, 0.02514917f, -0.00998496f, -0.03605998f, 0.02559148f, 
    -0.00756771f, 0.02704778f, -0.04550962f, -0.03077198f, 0.02306141f, 0.00579592f, -0.01187636f, -0.02790147f, 
    0.01801900f, -0.03183948f, -0.02292473f, 0.02062924f, 0.02188010f, -0.00113425f, 0.03272926f, 0.01493027f, 
    -0.01798603f, -0.00872008f, 0.01146851f, 0.00995925f, 0.02586079f, -0.03183539f, 0.00113584f, -0.04518932f, 
    -0.03456565f, -0.03814383f, 0.01745019f, 0.01085593f, -0.04439903f, -0.02584103f, -0.03664766f, 0.01174691f, 
    -0.00262942f, 0.02573093f, 0.01221203f, 0.00333576f, -0.02240113f, 0.02153231f, 0.00708218f, 0.01512691f, 
    -0.00941616f, 0.00569778f, -0.04519559f, 0.03118509f, -0.02705023f, -0.00892045f, 0.01923605f, -0.01773740f, 
    0.01600397f, 0.03729030f, 0.03527358f, 0.00533864f, 0.01460403f, 0.01536118f, -0.00467508f, -0.00456467f, 
    0.02145322f, 0.01117347f, 0.00813921f, 0.00879584f, -0.02525643f, 0.02199865f, -0.03448375f, 0.02643417f, 
    -0.04014157f, -0.00597786f, 0.02699027f, 0.01099398f, 0.02721610f, 0.02848564f, -0.03342210f, -0.03982469f, 
    -0.03346078f, -0.01229308f, -0.00083014f, -0.03400819f, 0.02211532f, -0.02444801f, -0.02827421f, 0.00391349f, 
    0.00099952f, -0.02531212f, -0.00345078f, -0.02291928f, 0.02285065f, -0.02393428f, 0.03252267f, -0.02136609f, 
    0.01799720f, -0.04439218f, 0.01445912f, -0.03030469f, -0.03659849f, 0.00289897f, 0.02751920f, 0.00929738f, 
    -0.01348674f, -0.02362825f, -0.02943482f, -0.01722972f, 0.01715960f, 0.00215633f, -0.00321365f, 0.00344026f, 
    -0.03307351f, 0.02761543f, -0.01846310f, 0.02924534f, 0.03059976f, 0.02554459f, -0.03436948f, -0.03867407f, 
    -0.02309626f, -0.00359174f, 0.02617713f, -0.02820884f, 0.02197194f, -0.02721390f, -0.03611197f, 0.03625818f, 
    -0.01205676f, 0.03023760f, -0.01614982f, 0.03298887f, -0.03657885f, -0.00014392f, -0.04196338f, -0.03257930f, 
    0.03000117f, 0.00770460f, 0.02708994f, -0.00200035f, 0.00001525f, 0.00634741f, -0.03001493f, -0.03948514f, 
    -0.00337965f, -0.01935373f, -0.03726251f, -0.02059894f, 0.03202664f, -0.01321985f, -0.00724305f, 0.02614461f, 
    0.01656449f, -0.02956415f, 0.00399173f, -0.03651009f, 0.00098461f, -0.01721215f, -0.01206188f, -0.02756392f, 
    0.01134012f, -0.04307966f, 0.03296058f, 0.01931292f, -0.04013966f, 0.01544009f, -0.00883021f, -0.01105949f, 
    -0.04167831f, -0.03087846f, -0.01451134f, -0.00102640f, -0.03128047f, -0.04383192f, -0.04283539f, -0.01154977f, 
    -0.02362601f, 0.03296021f, 0.01303369f, 0.01059845f, -0.02052970f, -0.04004027f, 0.01383848f, 0.00608855f, 
    -0.01518680f, -0.03907939f, -0.04364893f, 0.01076472f, 0.01427741f, 0.00810150f, -0.03512031f, 0.02394625f, 
    -0.00056120f, 0.03019403f, -0.01691364f, 0.00225475f, 0.00084285f, -0.00878414f, 0.00132866f, 0.01664239f, 
    0.01519905f, -0.00070720f, 0.00352671f, 0.00697694f, -0.03406410f, -0.01081746f, 0.02329289f, 0.02063371f, 
    -0.03539835f, 0.01976133f, -0.04140476f, 0.00757085f, -0.01411297f, -0.03598725f, 0.00955237f, 0.00512804f, 
    0.00241990f, -0.03565243f, -0.01440130f, 0.03315122f, -0.00892404f, -0.01808085f, -0.01872209f, 0.03393915f, 
    0.00119414f, -0.03872493f, -0.02900922f, -0.01552087f, 0.01112324f, -0.03975110f, 0.00290628f, -0.03475610f, 
    0.01813840f, 0.02407949f, 0.01689803f, 0.02449891f, 0.00792556f, 0.01756408f, -0.00007205f, 0.01948703f, 
    -0.03085453f, -0.02759154f, -0.02423013f, 0.03538363f, -0.03140803f, -0.01628531f, 0.00183096f, -0.04384988f, 
    -0.01326258f, -0.03082178f, -0.03387659f, 0.02326000f, -0.00910660f, -0.03530275f, 0.00764072f, 0.02815666f, 
    0.00024140f, 0.00197675f, -0.03845116f, 0.01648168f, 0.02943532f, 0.00988459f, -0.03642754f, 0.01847865f, 
    0.00543025f, 0.03157532f, -0.04468100f, 0.00942304f, 0.02811248f, -0.01039750f, 0.02779270f, 0.02552582f, 
    0.03438073f, 0.01040930f, -0.00285822f, -0.03251843f, 0.01179416f, 0.01270481f, 0.00202421f, -0.01867867f, 
    -0.01102888f, 0.02501828f, 0.01581545f, 0.02741315f, 0.00798422f, 0.02610191f, -0.02900779f, 0.00132294f, 
    0.02960330f, 0.01309377f, 0.03063656f, -0.00786736f, 0.03247040f, -0.04002928f, 0.02798324f, 0.03188002f, 
    -0.03040857f, 0.00634112f, 0.00234647f, 0.00205586f, -0.02786368f, -0.03336937f, -0.01304374f, -0.04432403f, 
    -0.03291369f, 0.02405280f, -0.00482197f, 0.02330390f, 0.01223567f, -0.03161496f, -0.00053798f, 0.00523301f, 
    0.02197950f, 0.01053623f, -0.03739417f, -0.01326528f, -0.03841457f, 0.01019125f, 0.02880148f, -0.03165497f, 
    -0.02211445f, 0.00622284f, -0.00132872f, -0.00955039f, 0.00452883f, -0.03227846f, -0.02809871f, 0.01773806f, 
    0.00866806f, -0.00169977f, -0.01993773f, -0.01652784f, -0.01127961f, 0.00025762f, -0.01277056f, 0.00545985f, 
    0.00210383f, 0.03207878f, -0.01551188f, 0.02352277f, -0.01068484f, 0.03231550f, -0.01380382f, -0.01069677f, 
    0.01427422f, 0.01896128f, -0.01740472f, 0.02741655f, -0.02407284f, -0.02758824f, 0.01798897f, 0.01483999f, 
    -0.00511453f, 0.01576405f, -0.02718073f, -0.02554392f, -0.00821497f, 0.00160555f, -0.00060334f, 0.01929997f, 
    0.03775265f, 0.03723763f, 0.02784862f, 0.10949834f, 0.07969768f, 0.02862876f, -0.02989268f, -0.03842811f, 
    0.13231592f, -0.04624572f, -0.07687192f, -0.01275513f, -0.00549037f, 0.06778394f, 0.08148109f, 0.06478690f, 
    -0.02290739f, 0.10451813f, 0.10816916f, -0.03304126f, 0.54506588f, -0.01537878f, -0.18893027f, -0.00080633f, 
    0.17974141f, 0.00348273f, 0.04502153f, 0.02191658f, -0.00632357f, -0.04169733f, -0.00333241f, 0.07050949f, 
    0.06745428f, 0.02072155f, 0.06597879f, 0.25423548f, -0.01394390f, -0.00467451f, 0.00146500f, -0.21503367f, 
    0.11292507f, -0.27480453f, 0.09930196f, 0.02419523f, -0.35571504f, -0.10061975f, 0.11625088f, -0.00922816f, 
    -0.00543210f, -0.06808899f, 0.00986129f, -0.13704781f, 0.07909018f, -0.05221241f, -0.10117687f, -0.05859222f, 
    -0.00695604f, -0.08841917f, -0.11175150f, -0.05655758f, -0.14666580f, 0.05362240f, 0.17500243f, 0.22858593f, 
    0.03114038f, 0.02212381f, -0.09375361f, -0.03561440f, 0.08429199f, 0.03899426f, -0.09259026f, -0.00081193f, 
    0.04283464f, 0.06840069f, 0.03748431f, 0.04428288f, 0.11381926f, 0.03096370f, 0.05016326f, 0.10338949f, 
    -0.36107051f, -0.14270166f, -0.27433255f, 0.14854884f, 0.03081119f, -0.06881186f, 0.05886242f, -0.17933720f, 
    0.15035190f, 0.19326298f, 0.09445515f, 0.15294616f, 0.03714203f, 0.06298776f, 0.15384401f, -0.02009074f, 
    -0.00002956f, -0.08527055f, 0.01313993f, -0.10026838f, 0.44557673f, 0.00349458f, -0.35588166f, -0.01718659f, 
    -0.29723772f, -0.06041830f, 0.22793581f, -0.05326208f, 0.17404117f, -0.08197397f, 0.01128937f, -0.00006029f, 
    0.02768188f, 0.06739908f, 0.10413741f, -0.00459757f, 0.04765949f, 0.12844491f, 0.00676325f, -0.02046796f, 
    -0.24718259f, -0.10865967f, 0.05463290f, 0.09161029f, 0.21715614f, 0.09647951f, 0.15360305f, 0.07622693f, 
    0.06030609f, 0.06669556f, 0.10334348f, 0.03347961f, -0.01428628f, -0.00947858f, 0.10173690f, 0.06563748f, 
    0.08391873f, 0.04281273f, 0.04069933f, 0.03940594f, -0.19242331f, 0.01149184f, 0.10496075f, 0.27727976f, 
    0.16407333f, -0.16528931f, -0.20403129f, -0.07590736f, -0.11014917f, -0.01206040f, 0.02728947f, -0.01979142f, 
    -0.03125062f, -0.03910842f, -0.01937139f, -0.02811438f, 0.02895024f, -0.00878678f, 0.07996348f, -0.08525045f, 
    0.42305866f, 0.16601880f, -0.02745212f, 0.03783506f, 0.14938587f, 0.07578520f, 0.21770392f, 0.04166428f, 
    -0.00774509f, -0.02876954f, 0.06513470f, 0.10522299f, 0.08233554f, 0.03551337f, 0.08763956f, -0.00492709f, 
    -0.06737534f, -0.05738776f, -0.09271454f, 0.02589690f, -0.02007196f, -0.08070017f, -0.14475259f, -0.05251844f, 
    -0.20602997f, 0.00103956f, 0.09878342f, -0.08858334f, 0.01500729f, -0.08072809f, -0.12992194f, -0.14048553f, 
    0.13933723f, -0.01616537f, -0.09005318f, 0.02024871f, -0.01887408f, 0.06132166f, -0.04078982f, 0.04603173f, 
    -0.13378350f, -0.23180033f, -0.09481556f, 0.24861994f, 0.06827646f, 0.05394383f, -0.22697836f, -0.05912460f, 
    0.10446730f, 0.07912998f, -0.00654366f, -0.02898488f, -0.02299518f, -0.03947185f, 0.03484558f, -0.04158330f, 
    0.02829242f, 0.04288208f, 0.00851458f, -0.05121830f, -0.28436783f, -0.16998252f, -0.03914208f, 0.20127897f, 
    -0.20752218f, 0.07904296f, -0.04042919f, -0.01345649f, -0.12965524f, 0.07295361f, 0.04537172f, -0.19289671f, 
    -0.07907591f, 0.04850418f, -0.00217432f, -0.02066312f, -0.08423682f, -0.11009008f, 0.07652061f, -0.00302835f, 
    -0.12457284f, -0.05065737f, 0.07983492f, 0.26843560f, 0.01497108f, 0.03476018f, -0.12623791f, 0.05814755f, 
    0.10011847f, 0.02209600f, -0.01875574f, 0.06259999f, 0.04636307f, 0.00347936f, 0.06868412f, 0.04096065f, 
    0.08241130f, 0.00208839f, 0.13274258f, 0.02992363f, 0.69417489f, -0.11979541f, -0.09463321f, -0.00297845f, 
    -0.09323356f, 0.02510809f, 0.09193358f, 0.12414125f, 0.00817355f, 0.03476231f, 0.04649416f, 0.09489650f, 
    0.08438250f, 0.04541427f, 0.09473246f, 0.06455449f, 0.08662184f, 0.10902649f, 0.10424133f, 0.02339998f, 
    0.25308889f, -0.05239899f, -0.04069144f, 0.06830429f, 0.18768080f, 0.03337153f, 0.09632548f, -0.00148652f, 
    0.01162545f, -0.04579222f, -0.14447610f, -0.09829412f, 0.03251974f, 0.07381999f, 0.02344595f, 0.05439295f, 
    -0.04070520f, 0.09651778f, -0.02158659f, 0.04329855f, 0.09698262f, 0.16840568f, 0.09869029f, 0.08926166f, 
    0.02557367f, 0.11022902f, 0.03588271f, 0.25824168f, -0.02889364f, 0.11876665f, -0.07959723f, 0.08354467f, 
    0.06718276f, 0.15481773f, 0.03377768f, 0.10195622f, 0.01893629f, 0.06046990f, -0.00932993f, 0.01529869f, 
    0.27467987f, -0.01803756f, -0.21769592f, 0.10749912f, 0.00374289f, 0.07621954f, -0.13038850f, -0.14385277f, 
    0.03520995f, 0.14560580f, -0.08714014f, 0.01830977f, 0.00710654f, -0.00428276f, 0.01703010f, -0.01692064f, 
    0.02635915f, -0.08297896f, -0.01542958f, 0.09039818f, -0.23010872f, -0.37677082f, 0.04395121f, 0.04957602f, 
    -0.25526315f, -0.18505082f, -0.00316836f, -0.04947747f, -0.10893660f, 0.04523234f, -0.03064772f, -0.05689131f, 
    0.12108362f, 0.03853295f, -0.06697682f, 0.01266360f, -0.01518091f, -0.00064915f, -0.04784110f, 0.05575102f, 
    -0.29754612f, -0.04445752f, -0.17065483f, 0.00125219f, -0.17433774f, -0.06919546f, -0.01304332f, -0.04622775f, 
    0.02614686f, 0.05081978f, 0.06854898f, 0.01625250f, -0.03347359f, 0.01258065f, -0.05467020f, -0.04947684f, 
    -0.12460373f, -0.11350089f, -0.10613726f, -0.00783942f, 0.53460270f, 0.15634719f, 0.18034096f, 0.12409069f, 
    0.14152804f, 0.02934943f, 0.03642787f, 0.05443591f, 0.03657324f, 0.01284319f, 0.00932993f, 0.05043760f, 
    0.03697477f, -0.01010459f, 0.01559720f, -0.01477869f, 0.02139202f, -0.03015827f, -0.03139430f, -0.01260146f, 
    0.06516439f, 0.19200647f, -0.21592556f, -0.05540116f, -0.31163305f, -0.07779280f, 0.00924348f, -0.18612123f, 
    0.08197407f, 0.00014831f, -0.00320905f, -0.14338636f, -0.03356626f, 0.04107466f, 0.02900278f, -0.04487879f, 
    -0.06385736f, 0.09084097f, -0.04764612f, 0.04099096f, 0.08670006f, 0.15285023f, -0.00230438f, 0.15289541f, 
    0.11938360f, -0.09437687f, 0.09772107f, 0.06254975f, -0.02283573f, 0.04768258f, 0.02354026f, -0.04590175f, 
    0.07656095f, 0.05168781f, 0.10170610f, 0.12862231f, 0.08115093f, 0.05573452f, -0.09061573f, -0.04552983f, 
    -0.14938574f, -0.09022301f, -0.02221646f, 0.13880436f, 0.10363264f, 0.16900197f, 0.02863880f, 0.12522757f, 
    -0.02368596f, 0.08400692f, -0.07101702f, 0.14213945f, -0.03666631f, 0.17331061f, -0.03146483f, -0.02726470f, 
    -0.14308241f, 0.05632497f, -0.18826376f, -0.08378197f, 0.39393878f, 0.11505334f, -0.08824226f, 0.02464065f, 
    -0.16016474f, 0.12868980f, 0.02451366f, 0.12795861f, -0.04331176f, 0.05527004f, -0.03863376f, 0.04476469f, 
    0.02322332f, 0.08941945f, 0.00974713f, 0.09942178f, -0.03154565f, 0.05857630f, 0.12334053f, -0.06943572f, 
    -0.09995268f, 0.03971308f, -0.05888339f, 0.32522497f, 0.02591775f, -0.01571372f, 0.00938816f, 0.08294528f, 
    -0.01124143f, 0.00949100f, -0.10988344f, -0.01535585f, 0.09486611f, 0.02991358f, 0.00753890f, -0.02831511f, 
    -0.02506874f, 0.01725832f, -0.11590762f, -0.06954067f, -0.14910237f, -0.03699359f, 0.12275851f, 0.20837207f, 
    -0.11774309f, -0.06275721f, -0.07498926f, 0.01804811f, 0.03907705f, 0.08657505f, -0.06174190f, 0.10595286f, 
    -0.02490875f, 0.02194607f, -0.04575916f, 0.00213373f, -0.02821074f, 0.02414040f, -0.12185276f, -0.08174131f, 
    -0.25078240f, -0.06541169f, 0.17272556f, 0.24064036f, 0.05895561f, -0.04070302f, -0.05212827f, 0.01130266f, 
    -0.13324371f, -0.02024309f, -0.09154567f, -0.02114520f, -0.02708250f, -0.04508396f, -0.07163969f, -0.06119368f, 
    -0.00542689f, -0.02936384f, -0.07935274f, -0.01235973f, -0.16220111f, -0.05002369f, 0.16797854f, 0.37899935f, 
    -0.11367626f, -0.17801024f, -0.11232828f, 0.01216841f, -0.03021345f, 0.11801750f, -0.01182946f, -0.07808436f, 
    0.10226264f, -0.09949354f, -0.07741971f, -0.02074796f, 0.02437700f, 0.03680011f, -0.11404307f, -0.04793881f, 
    -0.12212407f, -0.02945882f, 0.18058471f, 0.19725394f, -0.01596823f, 0.11861560f, -0.06530859f, 0.08248707f, 
    0.02936988f, 0.02187422f, -0.07246014f, 0.01888769f, 0.09644251f, 0.04838648f, -0.03320173f, 0.10613290f, 
    0.12348891f, 0.04682411f, 0.11596455f, 0.02506624f, -0.21304223f, -0.15688963f, -0.22257046f, 0.07851925f, 
    -0.20376572f, -0.03199873f, -0.08595999f, 0.04078018f, -0.14475842f, -0.08080473f, 0.03800996f, -0.12715480f, 
    0.11879038f, 0.03941424f, -0.13244794f, 0.03732614f, -0.12540007f, -0.10316229f, -0.13473371f, -0.03274220f, 
    -0.14544748f, -0.03823092f, 0.20653304f, 0.21017091f, -0.12242571f, -0.06468264f, -0.08221597f, -0.05817214f, 
    -0.04510954f, -0.00793461f, 0.06570287f, 0.01103526f, 0.03759882f, 0.02760339f, 0.02393483f, -0.00345040f, 
    0.12442976f, 0.06825620f, 0.06683729f, 0.05988709f, 0.30981657f, -0.00687681f, 0.15898715f, -0.01110369f, 
    0.00003510f, 0.01615055f, -0.00031133f, -0.02683493f, 0.10383435f, 0.01553881f, 0.01578164f, -0.00695708f, 
    0.03061219f, 0.05838222f, 0.10740115f, -0.03967285f, 0.01049204f, -0.02655785f, 0.07619777f, 0.00073683f, 
    0.06979022f, -0.27519292f, -0.00133019f, 0.13893209f, 0.21336010f, 0.00290592f, -0.13930075f, -0.03680693f, 
    0.02759208f, 0.05019613f, 0.00748173f, 0.00966889f, 0.02547586f, 0.02967808f, 0.06861719f, 0.14131841f, 
    0.07788594f, -0.09822784f, -0.06397275f, -0.07234059f, 0.28339869f, -0.11179859f, 0.16448832f, 0.04156263f, 
    0.35858110f, -0.07449334f, -0.02790420f, 0.02076285f, -0.07956240f, -0.09472048f, -0.03340664f, 0.00284499f, 
    0.02935456f, 0.01955029f, -0.09195863f, 0.12530495f, 0.11474752f, -0.02429485f, 0.00847695f, 0.13086005f, 
    0.13370484f, -0.27065086f, 0.50884688f, -0.22356482f, -0.33208120f, -0.02627541f, -0.11436750f, -0.00977079f, 
    0.10077886f, 0.10500683f, 0.12850791f, 0.08361232f, 0.06567542f, 0.10344510f, 0.04967744f, -0.00579029f, 
    -0.07600201f, -0.07019202f, -0.02315838f, 0.02433819f, 0.00144842f, 0.01624692f, -0.05037182f, 0.07491809f, 
    0.01586069f, -0.01333595f, -0.18217622f, -0.20740908f, 0.14252815f, 0.09169376f, 0.07379599f, -0.00104341f, 
    -0.03837248f, 0.00585781f, -0.11379748f, -0.05426450f, 0.05516488f, -0.03243636f, 0.02119196f, -0.03138918f, 
    -0.32073140f, -0.07628637f, 0.03097191f, -0.42425242f, 0.07966780f, 0.23164709f, -0.04921062f, 0.01772316f, 
    -0.02706190f, 0.16240929f, 0.18666036f, -0.10591052f, -0.04672444f, 0.05826825f, 0.07474454f, 0.08413049f, 
    0.02736458f, 0.00697633f, 0.09190148f, -0.00799904f, 0.43848479f, -0.39766318f, 0.62025326f, -0.41839316f, 
    -0.07129943f, -0.05161893f, -0.00089381f, 0.06153460f, 0.18439922f, 0.18992016f, 0.03700224f, 0.13013497f, 
    0.01644961f, 0.29102477f, 0.21866491f, -0.01743446f, 0.08179968f, 0.11549344f, -0.06432100f, 0.13443922f, 
    -0.01773707f, 0.41599482f, -0.22509590f, 0.26098153f, -0.11854399f, -0.12745401f, 0.05173925f, -0.00115345f, 
    -0.15107678f, 0.01108114f, 0.16709995f, -0.05716527f, 0.07746224f, 0.10198893f, -0.00320371f, 0.18878298f, 
    0.04860268f, -0.03420827f, 0.03343028f, -0.08686969f, -0.19726773f, -0.14508952f, -0.11509565f, 0.19720624f, 
    0.05416449f, 0.04127358f, -0.27982089f, 0.07760381f, -0.17996155f, 0.19781624f, 0.05235993f, 0.09232847f, 
    -0.06046651f, -0.02553911f, -0.02507121f, 0.08069908f, 0.05570872f, 0.08045615f, 0.11016338f, -0.05811766f, 
    -0.15382069f, 0.17429368f, 0.01853710f, -0.09384387f, -0.12919180f, -0.06948688f, 0.04713271f, 0.08837214f, 
    -0.01092150f, -0.06185482f, -0.00384031f, -0.13799302f, 0.12847534f, 0.14841601f, -0.13612483f, -0.03826395f, 
    -0.01486181f, 0.06155555f, 0.03948175f, 0.06726240f, 0.09844863f, -0.31922138f, 0.06105141f, 0.07631446f, 
    0.07112751f, -0.05743971f, -0.03509809f, 0.17174414f, 0.04549608f, -0.04592104f, -0.02248954f, 0.00424434f, 
    0.03634674f, 0.01056734f, -0.01300468f, 0.14628528f, 0.06677698f, -0.04325715f, 0.10161486f, 0.26827225f, 
    -0.07037834f, -0.20327415f, -0.50902724f, 0.39101049f, -0.18367624f, 0.05049735f, -0.05231612f, 0.02705309f, 
    -0.14805670f, 0.06480559f, 0.00731554f, 0.05921938f, 0.06092363f, -0.01486117f, 0.01111255f, 0.00927665f, 
    0.01339476f, -0.11892910f, 0.04926619f, -0.11935975f, 0.12206584f, -0.14951079f, -0.29120970f, -0.06802481f, 
    -0.11576956f, -0.11028577f, -0.10144632f, -0.26035365f, 0.24748994f, 0.01655751f, 0.27432373f, -0.05157563f, 
    -0.00051126f, 0.00995906f, 0.03194273f, 0.06821637f, 0.07139268f, -0.06746927f, 0.01142550f, 0.06552882f, 
    -0.09499990f, -0.00137624f, -0.07954536f, 0.31915686f, -0.04790111f, 0.00211465f, -0.16651314f, -0.06140380f, 
    -0.07342377f, 0.13885422f, -0.00535729f, 0.07949999f, 0.01209526f, 0.11977790f, 0.11482038f, -0.08351066f, 
    0.13557024f, 0.08581371f, 0.07874899f, -0.03995245f, 0.17418621f, -0.04757825f, -0.20436835f, -0.00847901f, 
    -0.20168497f, 0.03853681f, 0.11904763f, 0.08275602f, -0.06785994f, -0.02960390f, 0.04548349f, -0.05776418f, 
    -0.00828767f, 0.01367035f, -0.09273247f, 0.12027134f, 0.03322998f, -0.02779832f, 0.00132776f, 0.05414062f, 
    0.16287233f, 0.03656058f, -0.01403698f, 0.07340951f, -0.04189359f, 0.04778209f, 0.01719539f, 0.08235119f, 
    -0.14114219f, -0.07817462f, 0.01989860f, 0.02324655f, 0.02640509f, 0.18489234f, 0.00021033f, 0.01716292f, 
    0.02260493f, 0.02083810f, -0.05775157f, 0.01199551f, 0.13038397f, -0.01376081f, 0.09430014f, 0.02759350f, 
    -0.11325374f, 0.16328864f, 0.19551411f, 0.07387432f, 0.05002160f, 0.02482350f, -0.01423661f, 0.06416163f, 
    -0.03277519f, 0.05519000f, -0.11617285f, 0.13338171f, -0.01397061f, 0.24864841f, -0.07424981f, 0.14472544f, 
    -0.13296659f, -0.05751257f, -0.55061281f, 0.17342517f, -0.06691355f, 0.10185860f, -0.06354455f, 0.05626917f, 
    -0.03492616f, 0.25695583f, 0.04016340f, 0.01079513f, -0.00590847f, -0.00034158f, -0.02531192f, 0.06457292f, 
    0.06127073f, -0.10220617f, -0.13319556f, -0.12670980f, -0.25519201f, -0.22300038f, 0.17979066f, -0.08414239f, 
    -0.46059033f, -0.09833846f, -0.15597519f, -0.02693212f, 0.07341619f, -0.02454663f, 0.15840279f, 0.07025611f, 
    0.04432364f, 0.08624278f, -0.09021942f, -0.05999923f, 0.00078073f, -0.03080775f, 0.03889222f, -0.01708545f, 
    0.25370169f, 0.02169492f, 0.20314005f, -0.06779019f, -0.22128718f, -0.10566290f, -0.14993542f, -0.17982551f, 
    -0.17598049f, -0.17291889f, 0.12630093f, 0.10414249f, 0.10672942f, 0.15283410f, 0.09886420f, 0.04055127f, 
    -0.08965211f, -0.04269129f, 0.04003937f, -0.02642629f, 0.08163006f, 0.18116759f, -0.12870868f, -0.02649472f, 
    -0.10678811f, -0.06352403f, 0.04435164f, 0.05943624f, -0.03407960f, -0.05111860f, 0.06857610f, -0.06642329f, 
    0.00977788f, -0.07319620f, -0.09641161f, 0.02262649f, 0.03597818f, 0.13451843f, 0.11464035f, -0.01858273f, 
    0.14088304f, -0.24060005f, 0.13175590f, -0.19976068f, -0.12310220f, -0.03399293f, 0.00662553f, -0.07204179f, 
    0.30461362f, 0.12120886f, 0.09233529f, 0.04963072f, 0.00278894f, 0.18519329f, 0.01979371f, -0.01156009f, 
    0.03557150f, 0.08981501f, 0.05195495f, 0.11740418f, 0.16556811f, 0.12436445f, -0.12338473f, -0.01335296f, 
    0.00122999f, -0.06394447f, 0.15100475f, -0.07180837f, 0.09977826f, -0.12878345f, 0.09349158f, 0.01147463f, 
    -0.04600286f, -0.04053227f, 0.01583144f, 0.06909371f, 0.25712991f, 0.12563184f, 0.06469385f, 0.02377852f, 
    -0.01297421f, 0.09302477f, 0.06819928f, 0.06986529f, 0.01584615f, -0.07635402f, -0.01635101f, -0.15425225f, 
    0.01142999f, -0.21844156f, 0.05565638f, 0.06871253f, 0.01611444f, -0.13552338f, -0.04763947f, 0.00888292f, 
    -0.03723452f, 0.00295377f, -0.06200960f, -0.06992044f, 0.37123641f, -0.18484217f, 0.01511837f, -0.18304925f, 
    -0.03401883f, 0.02703034f, 0.13061050f, -0.09241243f, 0.00667969f, 0.04126551f, 0.07744163f, -0.02720339f, 
    -0.08951405f, -0.00233731f, -0.04675873f, 0.12030750f, -0.11228956f, -0.07427767f, 0.07136042f, 0.02040705f, 
    0.09425595f, -0.02886482f, -0.09818652f, 0.03197560f, -0.06326227f, -0.09770514f, 0.19290353f, -0.08156836f, 
    -0.02453980f, -0.11920995f, -0.03052331f, 0.06106573f, 0.13394502f, 0.05211773f, 0.05477049f, 0.00231468f, 
    0.04826064f, 0.08692091f, 0.02193303f, -0.02058751f, -0.00784535f, -0.30243170f, 0.17175353f, 0.10664129f, 
    0.00268719f, 0.02723558f, 0.01441936f, -0.09808128f, 0.13007565f, 0.11919553f, 0.03266317f, 0.12227423f, 
    0.12573649f, 0.03948499f, 0.06268831f, 0.02094540f, 0.04066151f, 0.07575250f, -0.02201708f, -0.03364244f, 
    -0.22137737f, -0.19123568f, 0.04649113f, 0.36669952f, 0.02370092f, -0.04797804f, 0.02209034f, 0.08090724f, 
    0.08618170f, 0.08475243f, -0.00903368f, 0.07482626f, -0.01399823f, -0.03899489f, 0.00753146f, 0.07491314f, 
    0.10638936f, 0.07132035f, 0.14911991f, -0.07788351f, -0.13666815f, -0.12090211f, -0.02359874f, 0.29000893f, 
    -0.15601051f, -0.13615027f, -0.01317368f, 0.06914640f, 0.11676332f, 0.08134931f, 0.08255830f, 0.04567226f, 
    0.02201828f, -0.04161633f, -0.04368025f, -0.02081693f, 0.08088768f, 0.12483838f, -0.02089195f, -0.00152358f, 
    0.00601832f, -0.08906778f, -0.08665172f, 0.15881777f, -0.06680522f, 0.00735140f, -0.06891374f, -0.14591560f, 
    0.10524385f, 0.04235155f, 0.07739507f, 0.03664117f, 0.00737195f, 0.03355342f, -0.01130547f, -0.02179829f, 
    0.13006496f, 0.04001092f, -0.05949230f, -0.04454881f, 0.34511796f, 0.24577725f, 0.16271821f, 0.23600921f, 
    -0.28206885f, -0.17667523f, -0.07008711f, -0.23241624f, -0.08203702f, -0.12222990f, 0.18122388f, -0.18584026f, 
    0.02018660f, -0.06389005f, -0.01995396f, 0.11728704f, 0.00776852f, -0.09274396f, 0.08045055f, 0.07852554f, 
    -0.16726942f, -0.14112276f, -0.13274440f, 0.25023028f, -0.34287021f, 0.07346103f, -0.13527313f, 0.01894401f, 
    0.01527509f, -0.02548626f, 0.06548809f, 0.10639004f, 0.03454746f, 0.04251415f, -0.11270488f, 0.00989927f, 
    0.02333342f, 0.07121896f, 0.05480658f, -0.03587270f, -0.26955804f, -0.00015535f, 0.07319178f, -0.11302509f, 
    -0.12262136f, 0.13713549f, 0.03929684f, 0.08845047f, 0.18066745f, 0.19757308f, 0.14738955f, -0.06860697f, 
    0.04790929f, -0.01744012f, -0.08161102f, 0.07736994f, 0.04997538f, 0.00244876f, 0.10642040f, 0.14207000f, 
    0.01815500f, 0.02734449f, -0.00288812f, 0.02695041f, 0.02637140f, 0.01555957f, 0.02306644f, -0.00921238f, 
    0.02388843f, -0.00438651f, -0.03744525f, -0.00756049f, 0.01829706f, -0.00125299f, -0.03430077f, 0.02328822f, 
    -0.03894988f, -0.02608437f, -0.02725981f, 0.02458206f, -0.02157154f, -0.00351603f, 0.02624449f, 0.01309352f, 
    -0.00916752f, -0.00433832f, -0.00803577f, 0.02042530f, -0.02905653f, -0.03496068f, 0.00399508f, 0.02066578f, 
    0.00539854f, 0.03732947f, 0.00446567f, 0.01842458f, 0.01627987f, -0.03506270f, 0.02843471f, -0.03855640f, 
    0.02066050f, -0.02952975f, 0.00438301f, -0.03630656f, 0.00243046f, 0.00733388f, -0.01623158f, -0.02111713f, 
    -0.01845782f, -0.01583963f, -0.04259339f, -0.01093773f, 0.02394495f, 0.01606183f, -0.02616316f, 0.00776339f, 
    0.04606888f, 0.01261413f, 0.00158989f, 0.02051551f, 0.03753128f, -0.03808874f, -0.01226578f, -0.04245707f, 
    -0.03263232f, -0.03485860f, 0.03249123f, -0.01153884f, 0.01183377f, -0.01449040f, -0.01019442f, 0.03303066f, 
    -0.04579607f, 0.01513543f, 0.01725893f, -0.02334718f, -0.01001843f, -0.02237989f, -0.03591113f, 0.00291151f, 
    -0.00258260f, -0.01812524f, -0.00421243f, -0.01951755f, 0.00728326f, -0.00474330f, -0.01144964f, -0.04372978f, 
    0.04470360f, -0.00756154f, -0.04277407f, -0.01990549f, 0.00698903f, -0.02333057f, 0.02731883f, 0.00850874f, 
    -0.00725878f, -0.03822349f, -0.00761355f, -0.01813173f, 0.02420862f, -0.03173072f, 0.03127511f, -0.02643705f, 
    -0.02888621f, 0.02395672f, 0.02796919f, -0.04589859f, 0.02387530f, -0.02802712f, 0.00952995f, -0.00076456f, 
    -0.02643564f, 0.04641456f, 0.01087613f, -0.00399523f, -0.03493578f, -0.00648260f, 0.00745757f, 0.02393233f, 
    -0.01881508f, 0.00257778f, -0.01643043f, -0.00277209f, -0.04585965f, -0.04587191f, 0.00096362f, -0.01402821f, 
    0.01461847f, -0.01111492f, 0.00695149f, -0.04438563f, 0.01231009f, 0.03083814f, 0.00667260f, 0.03251765f, 
    -0.02037373f, 0.02985705f, 0.02825565f, -0.03150687f, 0.02026591f, -0.01650657f, -0.03946998f, -0.03860082f, 
    0.01717509f, 0.00797106f, -0.01703999f, 0.01881684f, -0.02777071f, 0.00291412f, 0.03256308f, -0.04211015f, 
    -0.04642054f, 0.01962168f, -0.02230647f, 0.00024379f, -0.02530251f, 0.01992480f, -0.03876399f, -0.02351117f, 
    -0.03136344f, 0.02125031f, -0.02910491f, 0.02364551f, 0.00301432f, 0.01478907f, -0.00976319f, 0.03539964f, 
    0.02621588f, 0.02211799f, -0.01388513f, -0.00010852f, 0.00247418f, 0.00462733f, -0.00192133f, 0.02228304f, 
    -0.00367276f, -0.01357562f, 0.02073630f, 0.02849198f, -0.03180352f, -0.03103979f, -0.00644807f, -0.01630673f, 
    -0.02594959f, -0.00699581f, -0.02552617f, -0.04486173f, 0.00104786f, -0.03320866f, -0.04304373f, -0.02707605f, 
    0.01142520f, 0.01388973f, -0.04210196f, -0.00731033f, 0.01544840f, 0.01140620f, -0.03112669f, -0.01654851f, 
    0.01941563f, 0.00190670f, -0.00535740f, 0.02570354f, -0.01328418f, -0.00114741f, -0.03355247f, -0.02263403f, 
    0.01105235f, -0.03453669f, 0.03727692f, 0.02980682f, 0.01208663f, -0.02229901f, -0.02398833f, -0.03707942f, 
    -0.02993256f, -0.03902747f, 0.00946315f, -0.01091031f, -0.02390144f, 0.01653967f, 0.03024105f, -0.03482032f, 
    -0.03947208f, 0.02788391f, -0.00644628f, -0.03441473f, -0.01452236f, -0.00024781f, -0.02761660f, 0.01480471f, 
    -0.00398416f, 0.03089921f, 0.00996129f, -0.04044615f, 0.01875488f, 0.01558685f, 0.02367893f, -0.03595829f, 
    -0.01117705f, -0.00291677f, -0.03916874f, -0.01912845f, -0.00797247f, 0.02702035f, 0.03165186f, 0.01440848f, 
    -0.03377224f, 0.01489425f, 0.03424857f, -0.03179317f, -0.03565272f, -0.02511752f, 0.02121729f, 0.02920661f, 
    0.03221156f, 0.01231899f, 0.02937198f, -0.02144492f, 0.00465531f, 0.02156110f, -0.00856173f, -0.02543118f, 
    -0.01037089f, 0.00528097f, 0.01166198f, 0.01182567f, -0.03557279f, 0.01813821f, 0.03365233f, 0.00146472f, 
    0.03180452f, -0.03813520f, 0.01498422f, -0.03434926f, 0.03238151f, -0.02938770f, 0.02797293f, 0.01775261f, 
    -0.03986256f, -0.02212024f, -0.01131581f, -0.03090068f, -0.03597566f, 0.01760429f, -0.02061220f, -0.00354663f, 
    -0.02483162f, -0.00179262f, -0.02165699f, -0.03217752f, -0.02227279f, 0.01007617f, -0.00428646f, -0.01822521f, 
    -0.00310363f, -0.03529402f, 0.00256393f, -0.02039126f, 0.03079349f, 0.01785136f, -0.04540462f, 0.00190074f, 
    0.01885520f, -0.02965346f, 0.01971070f, 0.02957256f, -0.02052621f, -0.02286180f, 0.01010860f, -0.00439842f, 
    0.03380782f, -0.03495772f, 0.01075330f, -0.00700886f, 0.01838064f, -0.01632099f, -0.02040667f, -0.00510265f, 
    -0.03170636f, -0.01263152f, 0.01595982f, -0.04550107f, -0.02074196f, 0.01022397f, -0.00300989f, 0.01557933f, 
    -0.00881900f, -0.01532114f, 0.02451507f, -0.03748231f, -0.02733753f, 0.02545190f, -0.00829507f, -0.02809211f, 
    -0.02535589f, -0.01249954f, -0.04100984f, -0.04307244f, 0.00835656f, 0.02839326f, 0.02311483f, -0.04619740f, 
    0.01672468f, 0.01670662f, 0.02275530f, -0.00836204f, 0.00659067f, 0.00263592f, -0.00914526f, 0.00786774f, 
    -0.02278293f, 0.01466390f, 0.00792754f, 0.04512112f, -0.03356466f, 0.02930761f, 0.04257171f, -0.02684617f, 
    0.02618795f, -0.00595538f, 0.03039026f, -0.00382731f, 0.02392511f, -0.02990781f, -0.03107793f, 0.02665771f, 
    -0.02590939f, 0.00373613f, -0.02008987f, 0.01237556f, 0.00409869f, -0.04109458f, 0.02220291f, 0.01520617f, 
    -0.00584949f, 0.02620493f, -0.02980439f, -0.00846065f, -0.00371935f, -0.03047714f, 0.02693190f, -0.01563481f, 
    0.02413845f, -0.02479689f, 0.00715596f, -0.04436888f, -0.01611032f, 0.00376314f, -0.00774017f, 0.03667772f, 
    0.02063601f, -0.01151519f, 0.04647833f, -0.01635193f, -0.01272704f, -0.04429093f, -0.02828591f, -0.00558506f, 
    -0.02516807f, -0.01172937f, -0.03061036f, 0.01808689f, -0.01456335f, 0.01582936f, -0.03713384f, -0.01667589f, 
    0.02565415f, 0.03537918f, 0.00181548f, 0.01655620f, 0.03614357f, 0.02975448f, 0.01889271f, -0.02254282f, 
    -0.02816408f, 0.01744632f, -0.02604495f, -0.00298878f, 0.00887507f, -0.01469094f, -0.01471614f, -0.04173404f, 
    -0.00357004f, -0.02438813f, 0.02912634f, 0.00432288f, 0.01758986f, 0.02949371f, -0.00545520f, -0.01164353f, 
    -0.01363200f, 0.03119298f, 0.00608561f, 0.00672840f, -0.01266226f, -0.02415564f, 0.01159267f, -0.03711326f, 
    -0.04350119f, -0.02514280f, -0.03583649f, 0.02574535f, 0.00401020f, -0.00806167f, 0.01884020f, -0.00960169f, 
    -0.01583366f, -0.03043145f, -0.01745520f, 0.03586410f, 0.01155267f, -0.01067791f, -0.02442414f, -0.02368883f, 
    -0.03164005f, 0.02938690f, 0.01506897f, -0.02031005f, 0.02875811f, -0.03422426f, 0.03760749f, -0.04076101f, 
    -0.01906396f, -0.03980284f, -0.04023034f, -0.01070314f, 0.00579646f, -0.00244512f, 0.00884341f, -0.02237032f, 
    -0.01111934f, 0.01227430f, -0.03850903f, 0.02257531f, -0.03242184f, -0.02115080f, -0.03104567f, 0.02538250f, 
    -0.01183551f, 0.00338702f, -0.04451086f, 0.00761106f, -0.00359273f, -0.00056655f, 0.01967109f, -0.00878950f, 
    -0.02715630f, 0.01989363f, -0.00860271f, -0.00915438f, 0.00957689f, -0.00686466f, -0.02709091f, -0.00534316f, 
    0.02869269f, -0.00683478f, -0.02801465f, -0.03375718f, -0.01780332f, -0.02885100f, -0.00381752f, 0.00464999f, 
    0.02309310f, 0.01331105f, 0.01477294f, 0.00641084f, 0.01139386f, -0.02191354f, 0.01400999f, 0.01210341f, 
    0.01181954f, 0.00326860f, -0.03781615f, 0.01385804f, 0.04123123f, 0.03741955f, 0.01594162f, 0.02356723f, 
    0.00589703f, -0.00943425f, -0.02149423f, 0.02801756f, 0.01201717f, -0.00608229f, -0.01725214f, -0.02763667f, 
    -0.01487242f, 0.02478880f, -0.01022606f, -0.04330428f, 0.01095282f, -0.02148113f, 0.00203501f, 0.00808544f, 
    -0.00931535f, 0.02687190f, -0.03615554f, -0.02281214f, 0.02055798f, 0.00272286f, 0.00002948f, 0.03047760f, 
    -0.02301292f, -0.03800480f, -0.02696693f, 0.00690454f, -0.03138237f, 0.01435203f, 0.00382883f, -0.02249371f, 
    -0.03889962f, 0.01501678f, -0.01163527f, 0.02759475f, 0.00058982f, 0.01939136f, 0.00699535f, -0.02657537f, 
    -0.03080232f, -0.03807349f, -0.00807860f, 0.01196513f, 0.02379725f, -0.02966758f, 0.01142768f, 0.00272252f, 
    0.00576812f, 0.00977021f, 0.02033355f, 0.02577448f, 0.00852800f, 0.02749658f, -0.03502975f, -0.02335114f, 
    0.03175789f, -0.03344416f, -0.01212201f, -0.04479502f, -0.01447574f, -0.03400109f, 0.00848694f, 0.02780837f, 
    0.01556016f, 0.01832851f, -0.01558930f, -0.00790174f, -0.01654484f, 0.03207847f, -0.01924382f, -0.00687864f, 
    -0.01439114f, 0.01165827f, -0.03306337f, 0.01587964f, -0.03449101f, -0.02271808f, 0.03935845f, -0.02307362f, 
    -0.00350182f, -0.02228194f, -0.03960510f, 0.01804956f, 0.01484552f, 0.02143863f, 0.04076249f, 0.00226709f, 
    -0.00928724f, -0.01787752f, -0.01830029f, 0.01386425f, -0.01652381f, -0.00903009f, -0.02337077f, -0.00257087f, 
    -0.03420595f, 0.02959628f, 0.03794236f, 0.02590425f, 0.01144608f, 0.00382380f, -0.03581123f, 0.01408793f, 
    -0.00034772f, 0.00715880f, -0.02427048f, -0.01536618f, 0.03286089f, -0.02985556f, -0.02251419f, -0.00303327f, 
    -0.03344211f, -0.03589230f, -0.02492475f, 0.01566559f, -0.00318116f, -0.01689432f, 0.03621931f, 0.00636433f, 
    0.03761459f, 0.03904134f, 0.04063173f, -0.01009420f, 0.03336859f, 0.00702697f, 0.01350858f, 0.01629075f, 
    0.03220380f, 0.00684836f, -0.01201680f, 0.01620165f, 0.03534948f, 0.02949743f, -0.02185564f, 0.01615481f, 
    0.03154226f, -0.02939284f, -0.03131164f, 0.01333179f, -0.04670370f, -0.00331514f, 0.00978194f, -0.00354901f, 
    -0.04010885f, -0.01226372f, -0.04136702f, 0.02240137f, 0.01483339f, 0.03790075f, -0.03358829f, -0.01269729f, 
    0.01721653f, -0.04673598f, 0.00964273f, 0.00748603f, -0.03324478f, 0.01159170f, -0.00777003f, 0.01914003f, 
    0.03715909f, -0.03191559f, -0.03850113f, 0.00308504f, 0.03015996f, 0.00809459f, -0.00172327f, -0.00458668f, 
    -0.02591713f, -0.03141678f, 0.03246941f, -0.03074553f, 0.00385611f, -0.00850997f, 0.02594525f, -0.02102573f, 
    0.01006856f, -0.00074332f, -0.01275337f, -0.01382659f, -0.02930772f, 0.00818075f, 0.01139694f, 0.02391334f, 
    -0.01152576f, 0.03331694f, 0.00115018f, 0.03759915f, 0.00097134f, 0.02899130f, 0.01329319f, -0.01249120f, 
    -0.01930530f, 0.04170705f, 0.03268146f, -0.02885329f, -0.03376849f, 0.00520196f, -0.01713548f, -0.03470072f, 
    -0.00120745f, -0.02350229f, -0.00824340f, -0.03557765f, -0.01759928f, -0.02018004f, 0.01552596f, -0.00561213f, 
    -0.00855804f, -0.02978813f, 0.03810310f, -0.04637936f, 0.03403055f, 0.02633978f, 0.01917620f, 0.01088298f, 
    -0.04882896f, 0.00025167f, -0.01503693f, 0.03166806f, 0.03716952f, -0.04100781f, -0.02230000f, -0.02014165f, 
    -0.00174222f, -0.02715224f, -0.00723783f, 0.01783855f, 0.01439256f, 0.03310446f, -0.01345959f, -0.03722773f, 
    -0.02170693f, -0.02905285f, -0.02407738f, 0.02496584f, -0.00150326f, -0.00663918f, 0.02834748f, -0.04288440f, 
    0.00827628f, -0.01218440f, 0.02458301f, -0.04632144f, -0.03948298f, 0.00537348f, -0.04521308f, -0.01034066f, 
    -0.00167155f, 0.01414593f, 0.00722948f, -0.02418780f, 0.01347023f, 0.01783186f, -0.02630194f, -0.03075417f, 
    -0.01470897f, -0.02978824f, -0.00796035f, -0.00264525f, 0.01062126f, 0.03617842f, 0.03137632f, 0.00452091f, 
    0.02979998f, -0.01210945f, 0.03550982f, 0.03301304f, -0.03729679f, 0.00434800f, -0.02950343f, 0.01543826f, 
    -0.02292220f, -0.02231379f, -0.02749153f, 0.00332827f, -0.01823100f, -0.00362383f, -0.04409641f, -0.02862059f, 
    -0.01284126f, -0.03319493f, -0.00251339f, 0.01155887f, 0.00710897f, -0.00485364f, -0.02013692f, -0.03957958f, 
    -0.00462393f, -0.04854363f, -0.03915980f, -0.02460322f, -0.04620444f, -0.03848888f, 0.02760416f, -0.03667616f, 
    -0.02034414f, -0.03119594f, -0.02303047f, 0.01054455f, 0.00793631f, 0.02692260f, 0.00742743f, 0.01577855f, 
    -0.03989343f, 0.02138105f, -0.03146766f, 0.01263506f, 0.01214393f, -0.02078824f, 0.00227484f, -0.02226140f, 
    -0.00050279f, -0.04247670f, 0.02710090f, -0.04306128f, -0.02081177f, -0.02220039f, 0.00040504f, -0.01277401f, 
    -0.01843519f, 0.02546522f, -0.01577370f, 0.02610064f, -0.03037710f, -0.02510914f, -0.01234584f, -0.02270842f, 
    -0.03388904f, 0.02196732f, -0.03477041f, -0.03666239f, -0.02481911f, 0.00251610f, 0.02887191f, -0.00882549f, 
    0.00619909f, 0.02034706f, 0.00341434f, -0.03216008f, 0.03870593f, -0.01322801f, -0.00980105f, -0.00190737f, 
    -0.01318508f, 0.00279865f, 0.04405176f, 0.03670216f, 0.02108211f, -0.03012952f, -0.00962790f, -0.01204267f, 
    -0.00450838f, -0.00655378f, 0.00022377f, 0.00155286f, 0.01294154f, -0.04813215f, -0.00598325f, -0.01061847f, 
    -0.00401505f, 0.00102578f, -0.00253120f, 0.01912392f, -0.01187801f, 0.00568807f, 0.00593244f, -0.01957964f, 
    -0.04465248f, 0.02573020f, -0.03195090f, 0.00100321f, 0.02039721f, 0.00029619f, -0.01083874f, 0.01272757f, 
    -0.02855688f, -0.02920655f, -0.00545370f, 0.01398438f, -0.04169053f, -0.00450322f, 0.01656063f, 0.01727536f, 
    0.01753195f, -0.03658305f, -0.00878663f, 0.01452468f, 0.04121308f, -0.01257464f, 0.01915304f, 0.01782270f, 
    -0.02254943f, -0.02040141f, -0.03831065f, -0.01804952f, -0.00829277f, -0.04681836f, -0.01638322f, -0.01222429f, 
    -0.02845327f, -0.01818888f, 0.01783734f, -0.03176973f, -0.00086498f, -0.00120883f, -0.03669119f, -0.03239864f, 
    -0.02336628f, 0.02430268f, -0.01352383f, -0.03204690f, 0.02405057f, -0.01661903f, -0.04172613f, -0.03612717f, 
    0.01894003f, 0.02867544f, -0.02274292f, -0.01773314f, 0.00895432f, 0.00843753f, 0.02720942f, 0.02757557f, 
    0.02999931f, 0.01786786f, -0.00580365f, 0.02178195f, -0.01101076f, 0.01135053f, -0.01885454f, -0.02571079f, 
    -0.00416295f, -0.03720492f, -0.01563589f, 0.00895669f, -0.00641667f, 0.01579830f, -0.03886360f, -0.01601214f, 
    -0.00862175f, 0.02748724f, -0.02527432f, 0.01877858f, -0.01025926f, 0.00676129f, 0.00797081f, 0.02778686f, 
    -0.00979995f, 0.00105243f, 0.00349978f, 0.01003069f, -0.00061377f, 0.02112216f, -0.02568348f, -0.01424968f, 
    -0.01646964f, -0.01586460f, -0.03427344f, -0.01535496f, 0.03205386f, -0.01323496f, 0.00854699f, -0.02262836f, 
    0.03210775f, -0.00340592f, -0.02566200f, -0.02975035f, 0.03120023f, -0.02485168f, -0.01598598f, -0.00927359f, 
    -0.01839746f, -0.01139797f, -0.01263186f, -0.02846880f, -0.01122312f, 0.00978166f, -0.03633820f, -0.04830984f, 
    -0.00809777f, 0.00923185f, -0.00874214f, -0.02677161f, -0.00931519f, 0.03894916f, 0.02866841f, 0.02747191f, 
    0.01893565f, -0.04166670f, 0.00120947f, -0.00195935f, -0.02215285f, 0.01304063f, 0.01757669f, 0.00281498f, 
    -0.04140383f, 0.01538096f, -0.04600065f, -0.04032582f, -0.03771918f, 0.01009868f, 0.01509553f, -0.01204598f, 
    0.02064496f, 0.01066978f, -0.02175803f, 0.01508731f, -0.04355383f, 0.00759848f, -0.01259170f, -0.01549264f, 
    -0.04013706f, 0.01506799f, -0.00275344f, -0.02514477f, -0.04270720f, -0.03015752f, 0.00116181f, -0.02089488f, 
    0.02894855f, 0.00295177f, -0.03286259f, 0.00264255f, -0.02094818f, 0.02100717f, -0.00651652f, -0.00941670f, 
    0.01142609f, -0.03070408f, 0.03574430f, 0.02543079f, 0.02683744f, -0.02438068f, -0.03132463f, 0.00685501f, 
    -0.03554225f, -0.01365099f, 0.00931687f, 0.01602689f, -0.04835318f, -0.01982685f, 0.01235822f, 0.01425092f, 
    0.00202999f, -0.03335292f, 0.01693229f, -0.04787564f, -0.00346984f, 0.01573426f, -0.04012671f, 0.01816313f, 
    -0.02925701f, -0.02707667f, 0.01508233f, -0.00334505f, 0.01192318f, -0.00954292f, 0.02743913f, 0.00540539f, 
    -0.01634671f, -0.02268581f, -0.00557337f, 0.01816020f, -0.01806262f, 0.01460060f, 0.02614115f, -0.02798989f, 
    -0.00604787f, -0.02881410f, -0.01045247f, -0.00961818f, -0.00923235f, -0.03045636f, 0.00010299f, -0.00366478f, 
    -0.02924363f, -0.00315328f, 0.02110914f, 0.00553794f, -0.02238011f, -0.02520541f, 0.00659140f, -0.04648328f, 
    0.00802175f, 0.00144524f, -0.04033178f, -0.03705113f, -0.01007830f, -0.03267374f, -0.01376211f, 0.02451816f, 
    0.02216194f, -0.00129314f, -0.04325651f, 0.02816901f, 0.01646538f, -0.04545414f, 0.02577866f, 0.02394926f, 
    -0.01543075f, -0.02921920f, -0.03017825f, -0.03765397f, -0.01457226f, 0.01948600f, 0.01058802f, -0.04220913f, 
    -0.00063361f, -0.02142404f, -0.02690067f, -0.04009048f, -0.01078964f, -0.03074315f, -0.04801444f, 0.01850036f, 
    -0.00605098f, -0.01078992f, -0.00182222f, -0.00702292f, 0.02321352f, -0.02956845f, 0.02171379f, -0.02982839f, 
    0.04346749f, 0.03419925f, -0.04071390f, 0.00971946f, 0.01712397f, -0.02452256f, -0.01292348f, 0.00194847f, 
    -0.01496905f, 0.00518820f, -0.00088775f, 0.01678287f, 0.01638565f, 0.02247221f, -0.02679641f, -0.00812111f, 
    0.04297341f, -0.01832994f, -0.02878940f, -0.00387974f, 0.00240094f, -0.03336225f, 0.00524049f, 0.02919117f, 
    0.01960910f, -0.02256607f, -0.04790144f, 0.00356185f, -0.00072074f, 0.01498266f, 0.00806888f, -0.04244976f, 
    0.02690623f, -0.00618954f, -0.00037644f, -0.04967372f, 0.00997470f, 0.01882491f, 0.02087711f, -0.02886422f, 
    0.01929597f, -0.02702810f, -0.02970983f, 0.03231693f, -0.04018901f, -0.00299643f, 0.01248890f, 0.01904593f, 
    0.00196955f, -0.00433115f, 0.01654984f, -0.02622614f, -0.00217576f, 0.01162137f, -0.02108795f, -0.00381401f, 
    -0.01853470f, 0.04613874f, 0.02654893f, -0.00958643f, -0.02837645f, 0.03768245f, -0.02941177f, 0.01208068f, 
    -0.00514012f, -0.00775447f, 0.02543287f, -0.00987803f, 0.02219739f, -0.02377582f, -0.02628513f, -0.00442188f, 
    -0.00425426f, -0.03030263f, 0.02727999f, 0.00031972f, -0.02319561f, -0.01714094f, -0.03336776f, 0.02875229f, 
    -0.00903489f, -0.01473517f, 0.01191571f, 0.00610570f, 0.02462996f, -0.00848661f, 0.04382959f, -0.02465962f, 
    -0.00414536f, 0.02874088f, -0.02121079f, -0.00000341f, -0.02454150f, 0.01686574f, 0.00332443f, -0.00246089f, 
    0.02884115f, -0.03935428f, -0.01563596f, -0.01746769f, -0.03924849f, 0.00827719f, -0.02665191f, 0.02695626f, 
    0.01887337f, 0.02437005f, -0.00410392f, -0.00731157f, 0.02349163f, -0.01216948f, -0.02055553f, -0.03772188f, 
    -0.02695815f, 0.01242584f, -0.00679485f, -0.04380749f, 0.02530558f, -0.02446382f, 0.03940092f, 0.01253311f, 
    -0.02343472f, -0.03459772f, -0.03918029f, -0.03429817f, 0.02059184f, 0.01293736f, -0.01940790f, 0.01441630f, 
    -0.01376022f, -0.04749518f, -0.01383847f, -0.03821674f, -0.01728511f, -0.04194384f, 0.01306821f, -0.04258324f, 
    -0.01067757f, -0.02050369f, 0.01853519f, 0.00005155f, -0.03028148f, 0.03199709f, 0.00723519f, -0.02583534f, 
    0.01512820f, -0.01004312f, -0.00282489f, 0.01514685f, -0.01950769f, -0.02205053f, 0.00267576f, 0.01029165f, 
    0.00291760f, -0.01563564f, -0.04467743f, 0.00182858f, 0.03066737f, -0.01528048f, -0.00257841f, -0.01144376f, 
    -0.03662683f, 0.00960146f, -0.04040910f, 0.01084340f, 0.01566184f, 0.02407102f, -0.03496389f, 0.01303918f, 
    0.02215398f, 0.03072839f, -0.03111974f, 0.01344092f, 0.02707948f, 0.00698006f, 0.01984180f, -0.00579993f, 
    -0.02514737f, -0.01739777f, -0.04225885f, 0.02441251f, 0.02001401f, 0.01930821f, -0.01188218f, 0.02498305f, 
    -0.00375852f, 0.02926194f, 0.02011232f, 0.00054342f, -0.03304472f, -0.02503820f, 0.00175831f, 0.02494182f, 
    0.01712906f, -0.03981115f, 0.03023139f, -0.02022441f, -0.00123593f, 0.02198308f, -0.00949360f, -0.00050794f, 
    -0.00483900f, -0.02767660f, 0.02865270f, -0.01076649f, 0.00661324f, -0.01971231f, 0.01323126f, -0.03392770f, 
    0.02186068f, 0.00462748f, 0.01212867f, 0.02254177f, -0.01000019f, 0.00332762f, 0.03322969f, -0.03422194f, 
    -0.01203461f, -0.02542635f, -0.00962803f, 0.01917591f, 0.01355982f, -0.03723969f, -0.03347681f, 0.01599573f, 
    -0.01719546f, -0.02503427f, 0.02960350f, -0.02044698f, 0.00182717f, 0.00049249f, 0.01410065f, -0.03496898f, 
    -0.03749194f, -0.01888782f, -0.03185932f, -0.04015209f, 0.00301563f, -0.02044406f, -0.03474762f, 0.00502240f, 
    0.02426708f, -0.00581397f, -0.01875017f, -0.02504922f, -0.02397719f, -0.03404686f, -0.00546568f, 0.00260565f, 
    0.02123614f, -0.01014806f, -0.01547346f, -0.01217139f, -0.00873998f, -0.04367531f, -0.03839562f, -0.02097582f, 
    -0.03765721f, -0.00886467f, -0.03266146f, -0.03261033f, -0.04147997f, -0.04263249f, -0.01781549f, 0.03317176f, 
    -0.00711396f, 0.00581534f, 0.01648445f, -0.03494012f, 0.02276455f, -0.02937365f, 0.00490429f, -0.01810561f, 
    0.00428328f, 0.02086839f, -0.00442220f, 0.00721373f, -0.01664707f, 0.02251687f, 0.00883902f, -0.03811783f, 
    0.03718460f, -0.03683148f, -0.00807010f, 0.01881274f, 0.01952007f, -0.03722555f, -0.00887556f, -0.02272062f, 
    -0.03119644f, 0.01329312f, -0.03160165f, -0.00730044f, 0.03143952f, -0.02698247f, -0.04447442f, -0.01125768f, 
    -0.03601498f, -0.03644123f, 0.00772552f, 0.01203203f, 0.02426809f, -0.02723782f, -0.02382069f, 0.01446016f, 
    0.00606004f, 0.02641059f, 0.00173784f, -0.01713159f, 0.00042676f, 0.02321017f, 0.01908722f, -0.01584644f, 
    0.03076514f, -0.01048635f, -0.01110017f, -0.03077032f, 0.00014083f, -0.02406820f, -0.00859485f, 0.00921686f, 
    -0.02717397f, -0.03753351f, 0.01535107f, 0.00438860f, -0.02246528f, -0.02997791f, -0.03157353f, -0.04233550f, 
    -0.04140787f, 0.00183113f, -0.00106105f, -0.04142772f, 0.02764555f, -0.03241009f, 0.00885284f, 0.01863622f, 
    0.02923279f, -0.04215761f, -0.04042455f, 0.03159367f, 0.03036392f, -0.02733065f, -0.04137531f, 0.01047331f, 
    -0.04073582f, -0.01441845f, 0.01093232f, -0.03166983f, 0.02293244f, -0.00109048f, 0.00963569f, 0.01472918f, 
    -0.03649364f, -0.00268836f, 0.01024388f, -0.02041198f, 0.00608148f, 0.02605474f, -0.00752933f, -0.02119750f, 
    -0.03247068f, 0.02436405f, 0.03126970f, -0.00401260f, 0.00713667f, -0.00152083f, -0.00178875f, -0.02651066f, 
    -0.00891147f, -0.01353625f, -0.00152680f, -0.03313245f, 0.00994014f, 0.02763495f, 0.01273571f, -0.03630440f, 
    -0.00357544f, -0.02807033f, -0.02404032f, -0.04027667f, -0.03630246f, 0.00431627f, 0.00482466f, 0.00597940f, 
    -0.03115391f, -0.02569396f, 0.01704480f, -0.00303004f, 0.01807714f, -0.03762794f, -0.04282888f, 0.00245398f, 
    -0.01820601f, 0.01301516f, -0.00951060f, -0.02180808f, 0.03058576f, 0.03012627f, 0.01469033f, 0.01573897f, 
    -0.02214265f, -0.03572563f, 0.02074519f, 0.03176354f, 0.01641361f, -0.00098113f, -0.02126402f, 0.00209840f, 
    -0.00818282f, -0.03091059f, -0.04301820f, -0.00117987f, -0.00209059f, -0.01199966f, -0.04443400f, -0.04177880f, 
    -0.02640272f, -0.01285517f, -0.03281615f, -0.02605032f, 0.00764940f, -0.03221186f, -0.02684590f, -0.04182308f, 
    0.02444982f, -0.01812616f, -0.00596108f, -0.04279618f, 0.02369918f, 0.00745960f, 0.02471739f, 0.02469790f, 
    -0.02353915f, 0.00283811f, -0.01461547f, 0.01646846f, -0.00739379f, -0.01109743f, 0.00237161f, -0.00149749f, 
    -0.00549166f, -0.04249307f, 0.01657043f, -0.01567783f, -0.00474457f, 0.01501495f, 0.01077081f, 0.00287646f, 
    0.01048073f, -0.03928471f, -0.04537722f, -0.03212338f, 0.00587776f, -0.01407714f, 0.01826931f, -0.03360668f, 
    0.01101451f, -0.01398242f, 0.03239792f, 0.00858493f, 0.00443333f, -0.04334962f, 0.01503430f, -0.03563603f, 
    -0.03513222f, -0.01360863f, 0.02068353f, 0.01752637f, -0.00221529f, 0.00453539f, -0.04114436f, 0.02255659f, 
    -0.00342032f, -0.01207707f, 0.03565026f, -0.00019760f, 0.03744078f, -0.00420692f, -0.02823148f, 0.00707780f, 
    -0.01993368f, -0.03915709f, -0.00804641f, 0.00575251f, 0.00460087f, -0.00298679f, -0.02993672f, -0.02556688f, 
    0.01429499f, 0.02132982f, -0.03595179f, -0.04266266f, 0.00351238f, -0.00898215f, -0.00942125f, 0.02547028f, 
    -0.03284199f, -0.00244986f, -0.03062315f, 0.03034365f, 0.00789347f, 0.02545283f, -0.03459132f, -0.00380235f, 
    0.03944065f, 0.02426748f, 0.01396891f, -0.02010176f, -0.00040136f, 0.02886671f, 0.00296491f, -0.00079388f, 
    0.02595848f, -0.00805046f, -0.00671719f, -0.00722117f, 0.01206481f, 0.03589819f, 0.00852194f, 0.00328767f, 
    -0.02069791f, -0.02166802f, -0.04151645f, -0.01031816f, -0.01206053f, -0.03356094f, -0.01573620f, 0.00833895f, 
    0.00651550f, -0.03090535f, 0.02626135f, -0.01398402f, -0.00087736f, 0.02759252f, -0.02996971f, -0.02716074f, 
    -0.02478012f, 0.01067315f, 0.02873082f, -0.01921687f, -0.01716074f, 0.02605996f, 0.02214104f, -0.02475474f, 
    -0.01764852f, -0.04376657f, 0.01410534f, -0.00669948f, -0.00447447f, 0.00864127f, -0.00070523f, -0.02927127f, 
    -0.02363566f, -0.02782086f, 0.00334488f, -0.02841148f, 0.01027628f, 0.01821426f, 0.03230352f, -0.00597333f, 
    0.03317283f, -0.03716123f, 0.02662475f, -0.04484827f, 0.01503776f, 0.00536233f, 0.02699978f, 0.02751287f, 
    0.00014117f, -0.01705398f, 0.00341275f, -0.01860219f, -0.03320232f, -0.03241005f, -0.03499347f, 0.02693854f, 
    0.01605724f, 0.03368877f, -0.02245368f, -0.00130566f, -0.02503589f, 0.03778600f, -0.03850362f, -0.01036406f, 
    -0.03230079f, -0.04457159f, 0.02134735f, 0.03093478f, -0.00848220f, 0.00377004f, 0.03024534f, -0.03178055f, 
    0.02573798f, -0.00360787f, -0.00179601f, -0.00652931f, -0.00465607f, -0.00436686f, -0.04283229f, 0.03041737f, 
    -0.04519950f, -0.00406287f, -0.01153568f, -0.01985293f, 0.00594528f, -0.01091302f, 0.03152903f, -0.00682722f, 
    -0.01724507f, -0.02125746f, 0.01081940f, -0.01410565f, 0.01418572f, 0.03076930f, 0.01042622f, -0.00198202f, 
    0.03183207f, -0.03052661f, 0.02057368f, -0.00752995f, 0.02621037f, -0.03549509f, 0.00302708f, -0.03041435f, 
    -0.01572469f, -0.02396407f, -0.04414804f, -0.01439446f, -0.02139809f, -0.02036247f, -0.00244036f, 0.00667122f, 
    0.01350960f, -0.02371124f, -0.00229648f, -0.00084688f, 0.00149375f, 0.03092853f, 0.02466238f, -0.01883107f, 
    0.01320345f, -0.01593206f, 0.02379275f, -0.02511533f, -0.00875841f, -0.01569684f, -0.03394135f, -0.01544762f, 
    -0.03273182f, -0.00094112f, 0.02009933f, -0.01090665f, -0.03381300f, -0.02724655f, -0.03270740f, -0.03117101f, 
    -0.02562329f, 0.02830580f, -0.04388381f, 0.01800448f, 0.00460720f, -0.00589726f, -0.03032838f, -0.01567201f, 
    -0.02873434f, -0.03573396f, -0.01933001f, 0.01921571f, 0.01431226f, 0.02688729f, 0.01516653f, -0.02295442f, 
    -0.00653537f, -0.02010139f, 0.01054960f, 0.00714889f, -0.01183784f, 0.01778002f, 0.00827340f, 0.02971642f, 
    0.03887146f, -0.02238142f, -0.04366823f, 0.02975721f, -0.01155310f, -0.00629391f, -0.03870684f, -0.04471297f, 
    -0.00370455f, 0.00126961f, -0.02874853f, 0.03327442f, 0.01449056f, 0.03339878f, 0.01409274f, -0.00077225f, 
    -0.04423461f, 0.01997514f, 0.02026117f, -0.00399061f, -0.01081240f, -0.00269012f, -0.00443700f, -0.00357188f, 
    -0.01308725f, -0.01537451f, -0.03635137f, -0.00803552f, 0.01915432f, -0.00916243f, 0.00164733f, 0.01377546f, 
    -0.03055144f, -0.03722973f, -0.03089742f, -0.02958255f, -0.02506639f, 0.02131214f, -0.01573603f, -0.00342997f, 
    -0.01716887f, -0.02181028f, -0.02513868f, 0.02731462f, 0.02141573f, -0.03264236f, 0.01231883f, -0.00239103f, 
    -0.02461497f, 0.02928351f, -0.04189052f, 0.00875253f, 0.00963926f, -0.03700983f, -0.02564160f, -0.01401947f, 
    0.01011271f, -0.04113367f, 0.00877728f, 0.02982292f, -0.01980730f, -0.03945943f, -0.04499984f, 0.01393200f, 
    -0.03343065f, 0.01841453f, -0.02540375f, -0.02541089f, 0.01150566f, -0.02833781f, 0.02921775f, -0.02757443f, 
    0.02546619f, 0.00228994f, -0.01845208f, -0.00841883f, -0.03233072f, -0.03537454f, 0.00365963f, -0.03717510f, 
    -0.02511694f, -0.02030665f, 0.00542830f, 0.01324992f, -0.01120939f, -0.00832815f, 0.02859592f, 0.03202280f, 
    0.03106580f, 0.00665602f, 0.00635615f, -0.02400618f, -0.01092142f, -0.03921732f, 0.01995521f, 0.00660959f, 
    0.15067735f, -0.04303224f, 0.52787405f, 0.00993700f, 0.27513796f, -0.09085452f, 0.10951975f, 0.21279472f, 
    0.00288049f, -0.00715667f, -0.02129468f, 0.07107113f, 0.03953112f, -0.01906810f, -0.09536030f, -0.03405013f, 
    0.10092234f, 0.07679757f, -0.05229372f, 0.12331511f, -0.25807148f, 0.04115780f, -0.12057406f, -0.12264900f, 
    0.08967631f, 0.13280843f, -0.09910391f, 0.11834011f, 0.01310752f, 0.11281073f, 0.09517133f, 0.03064234f, 
    -0.01932100f, 0.01152324f, -0.05133596f, -0.00943696f, 0.07722235f, 0.10547452f, 0.06307368f, 0.19391587f, 
    -0.15684463f, -0.49948698f, 0.39151329f, -0.18131776f, 0.07058600f, 0.14054643f, -0.05769418f, 0.15629995f, 
    -0.06609071f, -0.25147194f, -0.09045987f, 0.01862375f, 0.02308141f, 0.02928022f, 0.04082958f, 0.04299803f, 
    -0.04592564f, 0.00684122f, -0.06573136f, -0.02317607f, -0.12090332f, -0.02719399f, -0.02462613f, -0.00342643f, 
    0.06528401f, -0.10951357f, 0.05348192f, -0.06390531f, -0.01287186f, 0.09593656f, -0.01532163f, 0.04315870f, 
    0.14825520f, 0.19409831f, 0.09709486f, 0.03859568f, 0.20356710f, 0.00689376f, 0.06126618f, 0.16598047f, 
    0.12047943f, 0.54022872f, -0.43405712f, 0.01401504f, 0.15406550f, 0.23555097f, -0.05279994f, 0.06307960f, 
    -0.10724615f, 0.11079114f, -0.06546235f, 0.11137383f, 0.00212262f, -0.08913197f, -0.25135201f, 0.01739440f, 
    -0.03006045f, -0.02405748f, 0.02745604f, -0.08191751f, -0.27499554f, -0.32888028f, 0.43828386f, -0.24103040f, 
    0.20431079f, -0.06100696f, -0.00725868f, 0.08629515f, -0.01724724f, -0.12571254f, 0.05941836f, -0.04177071f, 
    -0.01137720f, 0.09502329f, -0.05145519f, -0.02789454f, -0.04200463f, -0.03142393f, -0.04532148f, -0.19421875f, 
    0.06456555f, 0.22191902f, -0.32119125f, 0.10836707f, -0.32095945f, -0.05347953f, 0.00574883f, -0.19308135f, 
    -0.01627700f, -0.04274474f, -0.05739519f, -0.05591887f, 0.05475225f, 0.00980784f, 0.08321995f, -0.06431368f, 
    -0.04283144f, -0.14024444f, -0.02715562f, -0.03957002f, 0.25871512f, 0.15718280f, 0.25692359f, 0.19678292f, 
    -0.01546601f, 0.19047034f, 0.02656103f, -0.05899104f, 0.06014700f, 0.20996048f, 0.09919210f, -0.01485327f, 
    0.06255495f, -0.04449557f, -0.01407647f, -0.10725234f, 0.02976921f, -0.02998883f, 0.18391423f, -0.12288877f, 
    -0.36378014f, 0.16639215f, -0.23265274f, -0.14989649f, -0.07854274f, 0.24703468f, -0.03864209f, 0.22285719f, 
    -0.08883452f, 0.08987241f, 0.26510787f, -0.03461651f, -0.00989520f, -0.03043214f, 0.05198114f, 0.18717267f, 
    -0.22381042f, 0.07054203f, -0.21911402f, -0.20299917f, -0.35198146f, 0.01855710f, -0.16548657f, -0.12711100f, 
    -0.00461933f, -0.01498715f, -0.06897774f, 0.02624836f, 0.00828735f, 0.02590585f, -0.14392614f, -0.01958828f, 
    0.14538972f, 0.18816797f, 0.13969283f, -0.15242229f, 0.09296752f, 0.04852415f, 0.05385244f, 0.12528896f, 
    0.21648689f, 0.12818429f, 0.13776852f, 0.41252485f, -0.09011991f, -0.01814712f, 0.04394170f, -0.01458792f, 
    -0.13152903f, 0.03812951f, 0.09732068f, -0.07767573f, 0.08421328f, -0.03016628f, -0.02401094f, -0.00268825f, 
    -0.01102801f, 0.09004015f, 0.06391495f, 0.12839606f, 0.07716536f, -0.21310146f, 0.09531015f, 0.01911802f, 
    0.03991368f, 0.15810198f, 0.02856929f, 0.00192867f, -0.10322051f, -0.05668842f, -0.02707644f, 0.01772819f, 
    -0.12333751f, 0.18809919f, 0.14875330f, -0.02737135f, 0.04264413f, 0.27117726f, -0.09532756f, 0.04277601f, 
    0.08281394f, 0.01440898f, 0.14830451f, 0.14671364f, 0.00104681f, -0.09566637f, 0.06189225f, -0.04660172f, 
    0.05919749f, 0.14706890f, 0.00806983f, 0.08754926f, 0.07205024f, 0.14194451f, -0.00671279f, 0.01298482f, 
    0.08264965f, 0.00056653f, 0.14584799f, 0.15739901f, 0.28336859f, 0.07073203f, 0.05533355f, 0.13214450f, 
    0.10843585f, -0.00673588f, 0.06240808f, 0.02169672f, -0.01828106f, 0.12352208f, 0.00245623f, -0.05149225f, 
    -0.04851454f, -0.06974457f, -0.06237001f, 0.05392719f, 0.08270939f, 0.06787349f, -0.07841911f, 0.10001544f, 
    -0.24681069f, -0.07555210f, -0.33475065f, -0.18526840f, -0.19288079f, 0.18114948f, -0.17437734f, 0.07569062f, 
    -0.01140195f, -0.19036861f, 0.09516218f, 0.05346579f, -0.09477319f, -0.01517069f, 0.06156266f, -0.03307540f, 
    -0.01136135f, -0.08859167f, -0.14237109f, 0.08010349f, -0.01902128f, -0.03674734f, 0.14455727f, -0.22706541f, 
    0.04736923f, -0.15550473f, 0.13989146f, -0.07581406f, -0.01437160f, -0.00141278f, 0.02764659f, -0.15587638f, 
    -0.13490160f, -0.01852108f, 0.03010930f, -0.04469826f, -0.14979166f, 0.05094080f, -0.10560179f, -0.04986663f, 
    0.31624976f, 0.18561096f, 0.19074832f, 0.41399872f, 0.44020519f, 0.11541701f, 0.32246521f, 0.10414859f, 
    0.11077199f, 0.25934282f, 0.02425593f, -0.02536282f, -0.01671781f, -0.13789035f, -0.03793798f, 0.08656880f, 
    0.07876416f, 0.14047238f, 0.10874145f, 0.15447754f, 0.19862415f, -0.13731633f, 0.17568940f, -0.02836714f, 
    0.23749982f, 0.20156397f, -0.12565646f, 0.03697698f, 0.07245804f, -0.03450603f, -0.19020742f, 0.07335091f, 
    -0.03678458f, -0.08968274f, 0.02685121f, 0.00391071f, 0.00513357f, -0.02414544f, -0.01662220f, 0.01341011f, 
    0.33514017f, 0.36981112f, -0.09222112f, 0.07372145f, 0.14039159f, 0.07624548f, -0.05581550f, -0.07620697f, 
    -0.08250069f, 0.15625986f, 0.07174132f, -0.09907577f, 0.10142975f, -0.03491136f, 0.05313244f, 0.03336219f, 
    -0.03072706f, 0.04641928f, -0.08819221f, -0.03636534f, -0.44447365f, -0.15214129f, -0.19754314f, 0.04053526f, 
    -0.15140940f, 0.15395467f, 0.17528576f, 0.06505945f, -0.05769539f, -0.00309609f, 0.21518785f, 0.05685739f, 
    0.05368236f, -0.05249210f, 0.09490014f, 0.19764575f, -0.01202215f, -0.05116905f, -0.11089822f, -0.04279072f, 
    -0.32774442f, -0.04209939f, -0.02327237f, 0.00655221f, -0.06620485f, -0.00732312f, -0.05948665f, 0.08988614f, 
    0.06492253f, -0.06373361f, -0.04535795f, -0.06915376f, 0.09092500f, 0.01450486f, 0.19707499f, 0.09290879f, 
    0.07826597f, 0.09864774f, -0.04972886f, 0.09240961f, 0.11305580f, -0.35436127f, 0.08855303f, -0.17143336f, 
    -0.40461209f, 0.24366291f, 0.01622047f, -0.05308595f, -0.09420191f, -0.18355252f, 0.01802032f, 0.08752771f, 
    -0.01437815f, -0.15336102f, 0.09644262f, 0.12069698f, 0.10151739f, -0.12248014f, -0.16611996f, -0.02908385f, 
    -0.36739203f, 0.29858211f, -0.15582588f, -0.15191804f, 0.02541638f, -0.04896250f, 0.07418695f, -0.13243993f, 
    -0.16326992f, -0.18841510f, 0.01134076f, 0.02698597f, -0.00119826f, 0.00437124f, 0.12436158f, 0.11351689f, 
    0.05537699f, -0.10710666f, -0.10637020f, -0.03630774f, 0.16277419f, -0.32044119f, 0.24978407f, -0.19853812f, 
    -0.00819409f, 0.01923159f, 0.14112075f, -0.09513911f, -0.25875252f, -0.19024453f, 0.05680499f, -0.07961933f, 
    -0.05680748f, 0.03702461f, -0.01623027f, 0.06055752f, -0.03678060f, -0.01036501f, -0.23825493f, -0.07411225f, 
    0.03034026f, 0.11000977f, -0.17690030f, 0.01253975f, -0.15450042f, 0.06788589f, 0.00196451f, 0.00325413f, 
    -0.06313427f, 0.02205101f, 0.08820889f, 0.05264868f, -0.15539131f, -0.12322232f, 0.06905635f, 0.05404804f, 
    -0.08238330f, -0.14575420f, -0.11807380f, 0.00584598f, 0.27811667f, 0.09040719f, 0.17697400f, 0.04398294f, 
    -0.00751963f, 0.23301406f, 0.03404408f, 0.04764427f, -0.04072377f, 0.17512491f, -0.00462982f, 0.05417234f, 
    -0.07638227f, -0.09242354f, -0.07604829f, -0.01302938f, -0.09510288f, -0.05129170f, -0.08121352f, -0.10329158f, 
    0.21176550f, 0.08487014f, 0.19395836f, 0.14973877f, 0.10231977f, 0.12698324f, 0.03603290f, 0.21875955f, 
    -0.06085576f, 0.26972172f, 0.06307290f, 0.06060473f, -0.02455987f, -0.08149257f, 0.00361799f, -0.09991778f, 
    -0.06383344f, 0.06871793f, -0.03925011f, -0.05992377f, 0.27778292f, 0.10080329f, -0.01439611f, -0.01928288f, 
    0.08487566f, 0.19270647f, 0.03897398f, -0.09118026f, 0.03735828f, 0.16357751f, 0.03263678f, -0.02263291f, 
    -0.13134263f, -0.03717309f, 0.12834856f, -0.08350535f, -0.02515577f, 0.07788232f, 0.03997646f, -0.01656353f, 
    -0.02886884f, -0.14700259f, 0.05836073f, -0.07586853f, -0.02865472f, -0.12138746f, 0.03714454f, -0.04191005f, 
    -0.04250529f, 0.14155236f, -0.01651893f, 0.00803185f, 0.07802430f, 0.19790497f, 0.03652624f, 0.01151187f, 
    0.19546629f, 0.12373238f, 0.10098176f, 0.09048487f, 0.03677441f, 0.48905191f, -0.17601039f, -0.07794983f, 
    -0.12984273f, 0.02928224f, 0.12702337f, 0.05954861f, 0.01737687f, 0.16783053f, -0.13335238f, -0.03808052f, 
    -0.00518849f, 0.05366860f, 0.01881643f, -0.17323104f, 0.20232919f, 0.07529976f, 0.01516465f, 0.07069269f, 
    0.16598821f, -0.06571252f, -0.02156529f, -0.05266719f, -0.10803521f, -0.00974740f, 0.01304566f, -0.06035201f, 
    0.03958789f, -0.06964545f, -0.11964672f, -0.02130085f, 0.07243674f, 0.08978633f, 0.06906187f, -0.16094124f, 
    -0.02950154f, -0.15093517f, 0.01193434f, 0.12223858f, 0.05532321f, 0.25809100f, 0.33849004f, 0.01033870f, 
    0.29166517f, 0.07333151f, -0.03592274f, 0.13865417f, -0.01048768f, 0.14033042f, 0.01444001f, 0.03542460f, 
    -0.07218336f, -0.19260128f, -0.14413151f, -0.09857595f, -0.10569084f, -0.09688448f, -0.06000611f, -0.21280806f, 
    0.00364120f, -0.01980245f, 0.02772059f, -0.02939290f, 0.01904535f, 0.02056138f, -0.00625145f, -0.03774888f, 
    -0.03694106f, -0.01613993f, 0.00984710f, 0.02314535f, -0.04469551f, -0.01742612f, -0.00897411f, 0.02291262f, 
    0.00597213f, -0.04249611f, -0.01054253f, 0.01337858f, -0.02331121f, -0.03429539f, -0.01265443f, -0.01806006f, 
    0.02947944f, -0.02027418f, 0.00296154f, 0.02869242f, -0.03304936f, -0.03773902f, 0.01866854f, -0.02345236f, 
    0.02411972f, 0.02772171f, -0.01188159f, -0.03676857f, -0.01730388f, -0.02038574f, -0.03941436f, -0.02368721f, 
    0.01559491f, -0.02852739f, 0.03042359f, 0.03196495f, 0.02879576f, -0.00296396f, 0.01006650f, -0.01052058f, 
    -0.03034563f, 0.02091637f, -0.01690993f, -0.02257313f, 0.01606333f, -0.01571417f, -0.02397965f, 0.01385512f, 
    -0.01338917f, -0.00302737f, 0.02548525f, -0.01804212f, -0.00104000f, -0.02158253f, -0.01654515f, -0.01079949f, 
    -0.00735675f, -0.01545496f, -0.04328299f, 0.00106319f, 0.01628373f, 0.02972398f, -0.04469997f, 0.03084114f, 
    0.00520059f, 0.00451156f, -0.01904739f, 0.02591676f, 0.03260563f, 0.01997952f, -0.01397862f, -0.03334964f, 
    0.02296475f, -0.03218593f, -0.02267578f, -0.01949006f, -0.03963578f, -0.03777130f, -0.02872352f, 0.02738222f, 
    -0.03906156f, -0.01755905f, 0.02840118f, 0.01826873f, -0.03261082f, -0.00336741f, -0.04268292f, 0.00105323f, 
    0.02548712f, 0.02778337f, -0.03360701f, 0.00541201f, -0.03817225f, -0.03361853f, 0.00052491f, -0.03350775f, 
    -0.03057355f, 0.00433903f, 0.03137062f, -0.00626254f, 0.03308742f, -0.03888756f, -0.04358597f, 0.00736270f, 
    -0.02304093f, 0.02802257f, -0.00730198f, -0.03777652f, -0.04436150f, -0.02069022f, 0.00164086f, -0.03573049f, 
    0.02753310f, -0.01845351f, -0.02009112f, -0.00783114f, -0.01383240f, 0.01422337f, 0.03316639f, 0.01480863f, 
    -0.03055804f, 0.03185699f, 0.00592015f, -0.04551703f, -0.01097804f, 0.01473011f, -0.01260281f, -0.00584432f, 
    -0.02751929f, -0.00647562f, 0.02159470f, -0.01646494f, 0.00741452f, -0.04485703f, -0.02505388f, 0.01708400f, 
    -0.03884168f, -0.03666578f, -0.00162520f, 0.03315607f, -0.01755845f, -0.04499061f, 0.02323195f, -0.02537889f, 
    0.00986043f, 0.01532888f, 0.02771663f, -0.00519188f, -0.00710018f, 0.00166535f, -0.00226380f, 0.00660897f, 
    0.02562441f, 0.01514269f, 0.00519271f, 0.00545582f, -0.02674771f, 0.00461834f, -0.02690351f, 0.03268763f, 
    0.00754735f, 0.01551217f, -0.02444536f, -0.01962987f, 0.02611253f, 0.02273123f, -0.03241257f, 0.00621987f, 
    0.00566572f, -0.02412438f, 0.02479504f, 0.02853856f, -0.04159849f, -0.00665931f, -0.02405916f, 0.02601858f, 
    -0.01819735f, -0.04438979f, -0.00241706f, -0.00274809f, -0.01169438f, 0.00523712f, -0.03331964f, -0.00856035f, 
    0.00066084f, -0.01557980f, 0.01511441f, 0.00743735f, -0.00406898f, -0.00570688f, 0.00967680f, 0.00615945f, 
    0.01310954f, -0.00417267f, -0.02532499f, -0.02138452f, -0.03864711f, -0.01496798f, -0.02309028f, -0.01325437f, 
    0.00960206f, -0.03869163f, 0.00417126f, 0.02189236f, -0.00656578f, -0.01847398f, 0.00960020f, -0.01706368f, 
    0.00997768f, -0.01615619f, -0.01882697f, -0.02827027f, 0.02138870f, 0.02353896f, 0.01893822f, -0.02437819f, 
    0.00811959f, 0.01962295f, -0.04523681f, -0.02168809f, 0.02243720f, -0.01734509f, 0.00918644f, 0.00076306f, 
    0.01787498f, -0.00320073f, -0.04329592f, -0.04277933f, 0.01557033f, -0.02539864f, 0.02860305f, -0.03717500f, 
    0.01010046f, -0.01248974f, -0.00858366f, 0.02404274f, 0.02489384f, -0.03459067f, -0.02852498f, -0.03217097f, 
    -0.02353541f, -0.02465112f, -0.01025694f, -0.01878857f, 0.01948649f, 0.00997377f, -0.00955418f, -0.00149154f, 
    -0.04432234f, 0.00424969f, 0.01279396f, -0.02764667f, 0.02556954f, -0.04091174f, -0.03729151f, 0.00464735f, 
    0.00226892f, -0.02600115f, -0.01126123f, -0.04521640f, 0.00681305f, 0.02908577f, 0.00216111f, 0.02864938f, 
    -0.01698392f, 0.02001626f, -0.00116752f, 0.02019990f, -0.03620876f, -0.03301097f, 0.01665884f, -0.03756317f, 
    -0.01566174f, 0.01273966f, -0.01371564f, -0.03890742f, 0.01732270f, -0.04013785f, 0.02742107f, 0.00444803f, 
    -0.01917140f, 0.01063194f, -0.02630745f, -0.00488030f, -0.00018041f, 0.02920172f, -0.00654824f, -0.03546041f, 
    -0.00557840f, -0.01595364f, 0.00942188f, 0.02118666f, -0.04171232f, 0.00483746f, -0.02496276f, 0.02923860f, 
    -0.02141445f, -0.01727400f, 0.02674199f, -0.01752637f, -0.02873389f, -0.00480244f, -0.01933779f, -0.04546851f, 
    0.00795449f, -0.01145372f, 0.01825912f, 0.01280175f, 0.01592757f, 0.00114055f, -0.00349455f, -0.01702990f, 
    0.02878630f, 0.01859514f, 0.00039247f, 0.02087478f, -0.01587714f, 0.00561971f, 0.01441815f, -0.02808329f, 
    -0.03082746f, 0.00685471f, -0.03532338f, 0.01147934f, -0.00569114f, -0.03691263f, -0.04289569f, 0.02491102f, 
    -0.02222236f, -0.02351768f, -0.01029320f, -0.04414969f, 0.01030937f, -0.01638546f, -0.00751312f, -0.03047309f, 
    0.03332446f, -0.00876493f, -0.01182742f, 0.02101737f, -0.01462994f, 0.02099919f, -0.02712034f, -0.00753807f, 
    -0.02121321f, -0.02484202f, 0.03253930f, 0.02062505f, 0.02118931f, 0.01965002f, -0.03871113f, 0.01838603f, 
    -0.00320286f, -0.00854520f, -0.03091509f, -0.01137935f, 0.01393728f, -0.03084991f, -0.01762356f, -0.00292175f, 
    -0.03360882f, 0.01381983f, -0.03239282f, -0.01821877f, 0.00967552f, -0.03949969f, -0.00373527f, 0.03238191f, 
    -0.03951536f, -0.02890793f, -0.02038715f, 0.00547804f, 0.03185366f, -0.02917475f, -0.01636090f, 0.00684402f, 
    -0.01369951f, 0.01857598f, -0.04196655f, 0.00072973f, -0.03940888f, -0.03563958f, -0.04240942f, -0.03099258f, 
    -0.02548721f, 0.03081712f, -0.00512894f, 0.01144919f, -0.03577399f, 0.01463108f, -0.03628964f, 0.02823843f, 
    0.02042290f, -0.03404197f, 0.01801231f, 0.00940767f, -0.02766750f, -0.04302576f, 0.00313356f, 0.02661911f, 
    0.00768284f, 0.00723933f, -0.00847134f, 0.01000446f, 0.00621390f, 0.02757489f, -0.03645336f, -0.01888922f, 
    0.00790486f, -0.01803243f, 0.00996295f, -0.00373710f, 0.00407066f, -0.00715550f, 0.02609977f, -0.04251252f, 
    -0.01064434f, -0.01141722f, 0.03295301f, 0.03132106f, -0.03349911f, 0.01464803f, 0.00946688f, 0.02021348f, 
    -0.03679154f, -0.00559370f, -0.02774837f, -0.02218360f, 0.00617528f, -0.02772672f, -0.03369186f, 0.02038374f, 
    -0.03476752f, 0.02214909f, -0.03364320f, 0.00584082f, 0.00965745f, 0.02878268f, 0.01287945f, -0.01953840f, 
    -0.00598347f, 0.02779600f, 0.02679303f, -0.00510222f, -0.04365524f, -0.04171130f, -0.01830173f, 0.01306466f, 
    0.01475870f, 0.00809820f, 0.02537609f, -0.03625757f, -0.02388109f, -0.00455993f, 0.00241154f, -0.03162081f, 
    -0.04049315f, 0.00662641f, -0.03252310f, -0.04448571f, 0.01409615f, -0.03432045f, -0.04281057f, 0.01206849f, 
    0.00811840f, 0.03040800f, -0.04242854f, 0.01765152f, 0.00955816f, -0.01785589f, -0.00262454f, 0.00465879f, 
    -0.02523425f, -0.01506768f, 0.01713960f, 0.02298889f, -0.03783289f, -0.01150478f, 0.00103265f, -0.03769369f, 
    -0.04142423f, -0.00338434f, 0.00202205f, -0.03751530f, 0.02011594f, 0.00285355f, 0.02008076f, -0.04316102f, 
    -0.03416340f, 0.02930371f, 0.01014612f, 0.03166091f, -0.01902868f, -0.00371101f, -0.01126109f, 0.02274029f, 
    -0.00165767f, 0.00312557f, -0.02966650f, -0.02536104f, -0.01556183f, 0.02922790f, 0.00153269f, 0.03329355f, 
    0.02623483f, 0.02362321f, -0.01756414f, -0.00678976f, 0.02633314f, -0.04539264f, -0.04031057f, -0.03022387f, 
    -0.02046385f, -0.00220569f, 0.02863625f, 0.03191277f, 0.02817246f, -0.01172137f, 0.00356894f, -0.03510365f, 
    0.00545071f, -0.03147879f, -0.00078371f, -0.02949671f, 0.00230163f, -0.03804443f, 0.01969737f, -0.01777160f, 
    0.02157493f, 0.02909312f, 0.01956868f, -0.02421926f, -0.02732283f, -0.04404319f, 0.03259187f, 0.00929782f, 
    0.01006000f, -0.04408064f, 0.01055750f, 0.02181563f, 0.00456850f, -0.02430155f, -0.02296397f, 0.01247235f, 
    0.03074750f, 0.00022012f, 0.01790787f, -0.00027517f, -0.02051460f, 0.00483362f, 0.01485521f, -0.02162620f, 
    -0.02101246f, -0.03182586f, -0.03397464f, -0.03599446f, -0.04043320f, -0.01870692f, 0.01874771f, -0.02408021f, 
    -0.02400644f, -0.03825402f, -0.01784159f, -0.04366865f, -0.01316915f, -0.04334773f, -0.03094572f, 0.02648316f, 
    -0.01864138f, 0.01738819f, -0.04494753f, -0.02571616f, 0.01248823f, 0.00252389f, 0.03239101f, 0.01827195f, 
    0.02967343f, -0.00054155f, 0.01349445f, -0.04043860f, 0.02659972f, 0.01563809f, -0.00471853f, -0.03895062f, 
    -0.01850021f, 0.01814017f, 0.01920529f, 0.01692379f, 0.02170473f, 0.03276872f, -0.03008665f, -0.04491204f, 
    -0.04159381f, -0.03965468f, -0.01609515f, 0.01608526f, 0.01176376f, -0.02381954f, 0.00369561f, -0.03615889f, 
    -0.01832330f, -0.02799409f, -0.01117113f, -0.00914280f, -0.00826187f, 0.03082924f, -0.01046535f, -0.03848750f, 
    -0.02994167f, -0.03822741f, -0.04186263f, -0.00128121f, -0.03931974f, 0.01397666f, 0.00100051f, -0.00231917f, 
    -0.01062306f, 0.02919871f, -0.03094211f, 0.03279043f, -0.02567605f, 0.02461643f, 0.01090076f, 0.02602088f, 
    0.00578958f, 0.02941825f, -0.03159269f, 0.01943010f, -0.04308832f, 0.01773941f, -0.02212518f, -0.03376728f, 
    -0.00911401f, -0.03851882f, -0.00667445f, 0.03801554f, 0.00084462f, -0.01462871f, 0.00339873f, -0.02843746f, 
    -0.01812949f, -0.01040869f, 0.03074489f, -0.02961284f, 0.02213358f, 0.03257260f, 0.00194370f, -0.01793668f, 
    -0.00198805f, 0.03252314f, -0.02151367f, 0.01488301f, -0.00924907f, 0.01796778f, -0.01379842f, 0.02751879f, 
    -0.01785633f, -0.03471755f, 0.00811934f, 0.00109982f, 0.03329105f, -0.01922592f, -0.02007833f, 0.03692709f, 
    0.02665158f, -0.02310430f, -0.03016875f, -0.02174171f, 0.01349421f, -0.00280895f, 0.03766031f, -0.02498147f, 
    -0.01621976f, 0.02432686f, 0.02114931f, -0.03683372f, 0.02568744f, 0.03590927f, 0.00709986f, -0.03541120f, 
    0.02202630f, -0.03132359f, -0.00729295f, 0.02814524f, -0.02283406f, 0.00604876f, -0.03351687f, -0.03101607f, 
    0.03239061f, -0.03764677f, -0.01567482f, 0.01426517f, -0.03158374f, -0.03911256f, -0.03634967f, 0.00666512f, 
    0.03093218f, 0.02443507f, -0.01575296f, -0.02474134f, -0.01201807f, -0.00199762f, -0.03128840f, -0.00783779f, 
    0.00934034f, 0.02064951f, 0.01338636f, 0.01992076f, -0.02075307f, 0.03364206f, -0.01609682f, 0.02808327f, 
    0.01184845f, 0.01088839f, 0.03817954f, -0.02155315f, 0.00928819f, 0.03139859f, 0.00047787f, -0.03549140f, 
    -0.03016420f, 0.02550948f, -0.02346306f, 0.01235927f, -0.00442507f, 0.03320475f, -0.00279289f, 0.02542590f, 
    -0.00642248f, 0.00070038f, -0.03889971f, -0.02372424f, 0.03194825f, -0.01297938f, -0.03412647f, 0.01117964f, 
    0.00182163f, -0.01816317f, -0.02420498f, 0.02016379f, 0.03094376f, -0.00032867f, -0.03671034f, 0.03879921f, 
    -0.02886068f, -0.00701349f, 0.01714762f, 0.02588263f, -0.01473382f, 0.01676854f, -0.02114947f, 0.01014291f, 
    0.01616308f, -0.03851471f, 0.00257283f, 0.01323489f, -0.01646891f, 0.01385248f, -0.03227848f, -0.03855976f, 
    -0.03391892f, -0.03875971f, -0.00047608f, -0.01693841f, -0.00908643f, 0.01390694f, -0.02659294f, -0.00319308f, 
    0.02139890f, 0.02179057f, 0.01763935f, 0.00215677f, -0.01175763f, -0.00262204f, 0.02320224f, -0.03905560f, 
    -0.00217533f, -0.03328278f, -0.00078494f, 0.03635516f, 0.00513616f, -0.00362301f, -0.01364266f, 0.02120424f, 
    0.00887984f, -0.03594986f, -0.02678845f, -0.00718705f, 0.01788054f, 0.01960004f, 0.02546456f, 0.01087709f, 
    -0.01662583f, 0.00560046f, 0.01861507f, 0.03268365f, 0.03502380f, 0.00682447f, -0.01523018f, -0.03270799f, 
    -0.01373813f, 0.01579266f, 0.00258046f, -0.02697580f, -0.01481193f, -0.01243494f, 0.00531104f, 0.02740766f, 
    0.03844998f, 0.00269752f, -0.01539365f, 0.01983919f, -0.02802397f, -0.03145812f, -0.00258159f, -0.03017495f, 
    -0.01555494f, -0.00564747f, 0.00619628f, -0.01830287f, -0.02062356f, -0.00848350f, 0.00012799f, -0.03518922f, 
    0.01351896f, -0.00315437f, -0.03364561f, -0.01376296f, -0.00560685f, 0.01579930f, -0.03228984f, 0.01049821f, 
    -0.02670565f, -0.02053890f, 0.01384946f, -0.00568481f, -0.01998409f, -0.00701267f, 0.02992546f, 0.02385394f, 
    0.02507019f, 0.01031917f, -0.00590737f, -0.01099957f, -0.03079481f, 0.01380274f, 0.03707871f, 0.03508346f, 
    -0.00312409f, -0.03878327f, -0.03374958f, -0.00456680f, -0.02094651f, 0.00929763f, 0.02989385f, 0.03649904f, 
    -0.02562949f, 0.03526076f, -0.00216013f, 0.00452208f, 0.00289695f, -0.03278062f, 0.03160798f, 0.01285826f, 
    0.03243427f, 0.03181478f, 0.02890782f, 0.01462655f, -0.01590799f, -0.02008406f, -0.00242251f, 0.01977096f, 
    0.03292064f, -0.01770364f, 0.03211075f, -0.00259795f, 0.01552764f, 0.01784845f, 0.02393926f, 0.02971045f, 
    -0.03618648f, -0.00220779f, -0.02810207f, -0.01327524f, 0.00145261f, 0.03717308f, 0.03080630f, 0.02637893f, 
    0.02333562f, 0.00466497f, -0.02424072f, -0.01350926f, -0.03361217f, -0.02978246f, -0.02330215f, -0.03815878f, 
    0.03060118f, -0.03311824f, -0.03352256f, -0.01144748f, -0.03574030f, -0.01025722f, 0.00383247f, 0.01917742f, 
    0.02417733f, -0.02451448f, -0.02315719f, -0.01494626f, 0.01717939f, -0.00715176f, -0.01901829f, -0.02205315f, 
    0.00467561f, -0.01440494f, -0.03699397f, -0.00570062f, 0.02376341f, -0.01533493f, -0.00916300f, 0.01442145f, 
    0.01949989f, -0.03200824f, 0.00580472f, -0.00009349f, 0.00895980f, 0.00450413f, 0.01122254f, -0.03496389f, 
    0.01316060f, 0.00190724f, -0.00713186f, 0.00726616f, -0.03353749f, 0.03041517f, 0.01749134f, 0.02741268f, 
    0.01547286f, 0.00175805f, -0.03793265f, 0.03026061f, -0.02023093f, 0.03412908f, -0.03521173f, 0.02033792f, 
    -0.00382360f, -0.02138871f, -0.01324177f, -0.00639216f, -0.01352093f, -0.02470023f, 0.03460986f, 0.03193394f, 
    -0.02298142f, 0.01084910f, -0.00582947f, -0.00266552f, 0.03802645f, 0.00581953f, -0.02926116f, -0.01666319f, 
    -0.01413946f, -0.02060698f, -0.00504814f, -0.02198526f, -0.00217778f, -0.02724770f, -0.02151437f, -0.00416139f, 
    -0.00379699f, -0.03437972f, 0.02532417f, -0.00960879f, -0.03107391f, 0.03808736f, -0.00650943f, -0.01332688f, 
    0.01446146f, 0.02985061f, 0.03327296f, -0.03434631f, -0.01864539f, -0.03183753f, -0.03162954f, -0.00632425f, 
    0.01202825f, -0.03940375f, 0.00647348f, -0.03101398f, 0.01752788f, 0.02198270f, 0.00989751f, -0.03153664f, 
    0.02911919f, 0.02741858f, 0.01252195f, 0.00127113f, 0.02726553f, 0.00596457f, 0.01556309f, 0.02457196f, 
    -0.00584545f, 0.00484654f, 0.01778659f, 0.01354411f, 0.03413609f, 0.01409193f, -0.02302006f, 0.00940920f, 
    0.03837746f, 0.01508799f, -0.02156710f, -0.00664920f, -0.03038622f, 0.00217728f, -0.01067017f, 0.03117509f, 
    0.01083621f, 0.03253600f, 0.02183758f, 0.02523079f, -0.03570722f, 0.01095901f, -0.02398484f, -0.01385292f, 
    0.00680091f, 0.02811539f, 0.02243203f, -0.02203330f, -0.03528066f, -0.01536978f, 0.00922814f, 0.01233793f, 
    0.00353930f, 0.02684171f, -0.00934766f, -0.00511044f, -0.03896286f, 0.00518250f, -0.01420896f, -0.02781972f, 
    -0.02854636f, 0.01152586f, 0.00195131f, -0.00578142f, 0.00469911f, -0.02118581f, -0.03833611f, -0.01775819f, 
    0.00729596f, -0.03231624f, -0.01710503f, 0.00936195f, -0.02157538f, -0.00113259f, -0.00862008f, -0.02621277f, 
    -0.01996376f, 0.00605160f, 0.00968297f, -0.03709525f, -0.02638336f, 0.01144360f, -0.03341877f, -0.00983725f, 
    -0.00376296f, -0.01450069f, -0.03414577f, -0.03134691f, 0.03424172f, -0.01298958f, -0.01050327f, 0.03695123f, 
    -0.03107728f, -0.00590928f, -0.03090172f, -0.03789103f, -0.02515179f, -0.01537110f, -0.01820917f, -0.01733434f, 
    -0.00195731f, 0.00452655f, 0.00592603f, -0.02703000f, -0.00044783f, 0.02343747f, 0.03746532f, -0.01112927f, 
    0.03550860f, -0.02086433f, 0.03288092f, -0.03871330f, 0.01307253f, -0.03753912f, -0.03578155f, -0.01732637f, 
    0.03746391f, -0.00639526f, -0.00896868f, -0.00377286f, 0.00392792f, 0.02263208f, 0.00653623f, -0.00339594f, 
    -0.00967100f, -0.00278391f, 0.03210550f, -0.02394728f, -0.02518927f, -0.02016982f, 0.01415706f, 0.02490021f, 
    0.02735352f, -0.02666102f, -0.00640255f, -0.02168969f, -0.01204498f, 0.02867394f, -0.03410184f, 0.00316241f, 
    0.02040575f, 0.02963421f, -0.01354289f, -0.02584905f, -0.03540969f, -0.01883195f, 0.01172229f, -0.02353599f, 
    0.00574858f, 0.02579915f, -0.02668795f, -0.01539205f, 0.01519749f, -0.00095499f, 0.02233395f, 0.02877933f, 
    -0.02429443f, -0.02811141f, 0.02763776f, 0.01832630f, 0.00714736f, -0.00603346f, 0.00213564f, 0.01918903f, 
    -0.03435337f, 0.03923650f, 0.01930545f, -0.03721382f, -0.03582704f, 0.01486259f, -0.02300368f, -0.01611206f, 
    0.01425953f, -0.00186443f, -0.02432955f, -0.01405819f, -0.01711472f, -0.02860306f, -0.02536465f, -0.01213570f, 
    -0.00298030f, -0.00328615f, -0.02255230f, -0.02905319f, 0.03423978f, 0.01439857f, -0.03118227f, -0.03814131f, 
    -0.00243848f, -0.02955621f, -0.03133141f, -0.03075686f, 0.03818288f, 0.00181069f, -0.02352358f, -0.03167558f, 
    -0.01003904f, -0.02535512f, 0.03668490f, -0.01083817f, 0.00290850f, -0.00038430f, 0.03851505f, 0.00438517f, 
    0.01938979f, -0.02422906f, -0.00533666f, 0.00861852f, 0.00607749f, 0.00626601f, -0.00213151f, -0.00373628f, 
    0.03835271f, 0.03810389f, -0.03617049f, 0.02973802f, -0.03841338f, -0.01767581f, -0.03527615f, -0.03131269f, 
    -0.03128025f, -0.00636179f, -0.02495403f, -0.03151083f, 0.02886377f, 0.00855905f, 0.01488691f, -0.01614940f, 
    0.01910775f, 0.02968838f, 0.01816902f, 0.01025231f, -0.02879113f, 0.03490605f, 0.02402869f, 0.01313362f, 
    -0.00901096f, -0.00438422f, 0.02832969f, 0.03765494f, 0.03502025f, -0.03594485f, -0.01264977f, 0.02779332f, 
    0.00683107f, 0.03797415f, -0.03810307f, 0.01234059f, -0.02573905f, -0.02735409f, -0.01962884f, -0.00944505f, 
    -0.00249963f, -0.00369888f, 0.02725321f, 0.01666575f, -0.02464315f, 0.03581059f, 0.02980733f, 0.02879318f, 
    -0.02787497f, 0.01937495f, 0.02981367f, 0.01168548f, 0.00944525f, -0.02273763f, -0.02854029f, -0.00732561f, 
    0.03381918f, 0.00654207f, -0.03134594f, -0.02466922f, -0.02134913f, -0.02502724f, 0.02008586f, -0.01057429f, 
    0.03156514f, 0.03235012f, -0.01875997f, -0.03775525f, 0.02572455f, 0.02820093f, 0.00634218f, -0.03134324f, 
    -0.01239049f, 0.00301184f, -0.01091139f, 0.00530103f, -0.02296896f, -0.01919306f, 0.03605481f, 0.00368360f, 
    0.37980032f, 0.00863779f, 0.30135593f, -0.28003359f, -0.07081652f, 0.12124780f, 0.08662080f, 0.05468775f, 
    -0.00071084f, 0.03542070f, 0.10494886f, -0.03752134f, -0.02800115f, 0.04703553f, 0.06239423f, -0.04233839f, 
    -0.00817847f, 0.04131193f, 0.23718755f, 0.18597464f, 0.05278814f, -0.04880429f, -0.02730247f, -0.04839025f, 
    0.36276969f, 0.01179662f, 0.03879818f, -0.11145378f, -0.06616013f, -0.01276355f, 0.10997201f, -0.09377757f, 
    0.07001171f, -0.03644785f, -0.02269435f, -0.00695603f, 0.04653922f, 0.23025283f, -0.16888592f, -0.07947682f, 
    0.01279667f, -0.20655860f, -0.27080923f, -0.17724206f, -0.23552708f, 0.10612089f, 0.00890363f, -0.01711954f, 
    0.00572379f, -0.16292807f, -0.05705907f, -0.04174508f, -0.08113808f, -0.06931840f, -0.09317423f, 0.06673128f, 
    0.08542816f, 0.09546055f, 0.02065642f, 0.12496386f, -0.00328970f, 0.09933130f, 0.15409176f, -0.03000247f, 
    -0.17678355f, 0.01659844f, -0.02535637f, -0.01919970f, -0.11288898f, -0.12827098f, 0.02076318f, 0.02465770f, 
    0.05048922f, 0.17062204f, 0.04886195f, 0.06709636f, -0.03025428f, -0.07304937f, 0.04433931f, -0.04913175f, 
    0.11646263f, 0.30446368f, 0.02880708f, 0.15839842f, 0.14362794f, 0.07646589f, -0.16858813f, -0.00006826f, 
    0.10713830f, -0.08931973f, 0.12569453f, 0.07291024f, -0.17116757f, -0.11485350f, 0.09902991f, 0.07529702f, 
    0.05338778f, 0.07907633f, -0.04698670f, -0.09881742f, -0.21550965f, -0.01682826f, -0.14272937f, -0.43665549f, 
    -0.18994269f, 0.10088220f, 0.11605752f, 0.15072310f, 0.18106012f, -0.09483094f, 0.01665084f, -0.02526710f, 
    -0.21733783f, -0.21031171f, 0.05822625f, 0.01569805f, 0.01225401f, 0.15498766f, -0.06206580f, -0.06915794f, 
    -0.66434616f, -0.05232751f, 0.04300959f, 0.20202936f, 0.16599321f, 0.06063160f, -0.05307727f, -0.14818475f, 
    0.16621551f, 0.01826929f, 0.15650895f, 0.04988210f, -0.05550933f, 0.05709957f, -0.06231317f, -0.01560389f, 
    -0.07864556f, -0.00935764f, 0.00850095f, 0.26098204f, -0.04252288f, 0.15002003f, 0.38351390f, 0.05461753f, 
    -0.19409128f, 0.13527146f, -0.00760441f, 0.00806083f, 0.00860389f, -0.10441685f, 0.07535214f, -0.08774708f, 
    0.04393866f, 0.13271709f, 0.00503591f, 0.04004306f, 0.02537829f, -0.06903812f, 0.19904917f, -0.03118568f, 
    0.22337939f, -0.02933160f, -0.17438540f, 0.19779953f, 0.23987952f, 0.06940639f, 0.03586411f, 0.03161951f, 
    0.03353030f, -0.06950027f, 0.07744925f, -0.10546627f, -0.14431924f, -0.22910646f, -0.00212322f, 0.16566932f, 
    -0.25830501f, 0.02629979f, -0.16198987f, 0.01707636f, -0.23181596f, -0.30750567f, -0.21282510f, -0.23561136f, 
    0.10452276f, 0.02001939f, 0.04269383f, -0.05141038f, 0.06582888f, -0.08121051f, -0.06195520f, 0.09153912f, 
    0.14112659f, -0.04686476f, 0.01730562f, -0.13261770f, -0.03577407f, 0.12288189f, -0.00612088f, 0.01906601f, 
    -0.29563078f, 0.07803550f, 0.26751104f, 0.15210633f, -0.20805910f, -0.03890558f, -0.09201707f, 0.01246591f, 
    0.11698652f, 0.03839876f, 0.00295055f, 0.02901065f, 0.02048744f, -0.02129574f, -0.01889595f, 0.02930988f, 
    -0.02208689f, 0.00018602f, 0.02147597f, 0.11458835f, -0.20823741f, -0.15559396f, 0.19845541f, -0.07390457f, 
    -0.24066924f, 0.08450019f, -0.02207121f, -0.03952314f, -0.40708184f, -0.01974509f, 0.07028524f, -0.04895592f, 
    0.04498345f, 0.00558953f, -0.00124862f, -0.08762792f, -0.15278123f, -0.11024021f, 0.09915189f, 0.14572847f, 
    -0.09402438f, 0.11843140f, 0.23408914f, 0.03144211f, -0.11999377f, -0.01084379f, -0.10013881f, 0.01354454f, 
    0.08775850f, -0.13614736f, 0.00509901f, 0.02805127f, 0.12393115f, 0.06858620f, 0.03496889f, -0.01068258f, 
    -0.00860006f, -0.18711728f, 0.00837550f, 0.10217901f, 0.01036704f, 0.11851363f, -0.39205256f, 0.14294715f, 
    0.02372762f, 0.15373091f, 0.17410336f, 0.07144725f, 0.08531420f, 0.10365388f, -0.02879305f, 0.07019571f, 
    -0.05052207f, 0.02395794f, -0.06757580f, -0.12172094f, 0.05098628f, 0.27399829f, 0.19155337f, 0.01406001f, 
    0.21473384f, -0.52249879f, -0.05289172f, 0.12232833f, 0.26863620f, -0.00333820f, -0.09359804f, -0.07249113f, 
    -0.07712157f, -0.05596716f, -0.04009807f, 0.13868311f, -0.03455141f, 0.04666700f, -0.00422176f, 0.14479360f, 
    -0.16871576f, 0.12622099f, 0.05891499f, 0.28498635f, 0.15583527f, -0.14789984f, -0.14477466f, 0.10356635f, 
    0.05009979f, -0.26108965f, 0.08460654f, 0.09219889f, -0.01505017f, -0.00606506f, 0.08631349f, -0.08118010f, 
    -0.05832740f, -0.04802924f, 0.02788075f, 0.04050108f, -0.07689801f, -0.08162037f, 0.03963375f, 0.02368554f, 
    0.11243175f, 0.30660424f, 0.03548149f, 0.03289529f, -0.10466217f, 0.17245026f, 0.04275412f, 0.00522707f, 
    0.05143011f, -0.07224653f, 0.03527917f, 0.03798605f, -0.00882200f, -0.00471081f, 0.04208805f, 0.05329745f, 
    -0.00484978f, 0.15951788f, 0.05436287f, 0.15499578f, 0.09135784f, -0.02511922f, -0.10619105f, -0.05255836f, 
    -0.21865274f, 0.14914657f, -0.12887774f, -0.14711767f, -0.01577786f, 0.18238373f, -0.07395135f, 0.11267937f, 
    -0.18164988f, 0.06192285f, 0.01088356f, 0.12315474f, 0.06231123f, 0.03139398f, -0.06786977f, 0.14951070f, 
    -0.46751738f, 0.14758810f, -0.13300124f, -0.01182291f, -0.02678918f, 0.02488154f, 0.02008989f, -0.04438139f, 
    -0.08230715f, -0.03148269f, 0.09798669f, -0.02299330f, -0.01523810f, -0.02900355f, 0.05907266f, 0.01811989f, 
    0.05937999f, 0.10944211f, -0.10047954f, -0.00756359f, 0.05497709f, -0.08754682f, -0.02148373f, 0.11145490f, 
    0.23342021f, 0.07854313f, 0.05022972f, -0.00834738f, 0.04589861f, 0.08725970f, -0.05351677f, -0.03564280f, 
    -0.08893289f, -0.06314588f, -0.12425148f, -0.00239011f, -0.07474095f, 0.02789938f, -0.11375425f, 0.01463282f, 
    -0.50296432f, 0.10081340f, -0.10026114f, -0.24069050f, -0.13287322f, 0.23363590f, -0.13002510f, 0.04087837f, 
    0.01677877f, -0.10936000f, 0.02751661f, 0.02681250f, -0.04467591f, -0.01048534f, 0.05961110f, 0.04627401f, 
    -0.11230033f, 0.09249552f, -0.05709077f, -0.01072421f, -0.01336619f, -0.25461781f, 0.05073436f, 0.07722636f, 
    0.07248376f, 0.13394015f, -0.22550932f, 0.21359709f, -0.05517968f, 0.14769761f, -0.13080692f, -0.07025582f, 
    0.07597181f, 0.05088632f, -0.05036728f, -0.09652140f, -0.11694803f, -0.15688702f, 0.04234487f, 0.10655639f, 
    -0.16796918f, -0.15885119f, -0.09698258f, 0.08186737f, 0.06723671f, 0.10421396f, 0.03058834f, -0.06349003f, 
    0.02362130f, -0.00282184f, 0.21467102f, -0.05883962f, 0.07989344f, 0.09730057f, -0.07835571f, 0.03634558f, 
    0.06284998f, -0.03497588f, 0.04500457f, 0.04879950f, 0.26932624f, -0.01804209f, -0.04509472f, 0.03915053f, 
    0.10182898f, 0.01480004f, 0.16646160f, 0.00759500f, -0.06703883f, 0.07369096f, 0.12434518f, -0.03892067f, 
    0.01902246f, 0.01904980f, -0.12951693f, 0.06358257f, 0.03547328f, 0.03914539f, -0.01619447f, -0.02437140f, 
    -0.11351813f, -0.01769719f, 0.09950561f, 0.05160127f, -0.11385807f, 0.03725433f, -0.10448652f, -0.06639794f, 
    0.02538864f, -0.14907815f, 0.15442581f, 0.02187579f, -0.13808107f, -0.02249354f, 0.03714913f, 0.01560343f, 
    -0.06248920f, -0.07326795f, 0.04480615f, 0.06957822f, 0.10240021f, 0.17157698f, 0.35141271f, -0.13205007f, 
    -0.21097153f, -0.07443014f, -0.01550269f, -0.05937173f, -0.11818802f, -0.09235008f, 0.02747741f, 0.01461654f, 
    -0.06818705f, -0.08053501f, -0.02371913f, -0.01678938f, 0.01916878f, -0.06576575f, -0.05136991f, -0.02510510f, 
    0.07632434f, -0.04035996f, 0.38261592f, -0.08215021f, -0.28773078f, 0.05825540f, 0.00670400f, 0.01075852f, 
    -0.14861558f, -0.12796696f, 0.04471667f, 0.01129239f, 0.06031698f, -0.05512751f, -0.01415447f, 0.02301084f, 
    0.00443590f, -0.05689562f, 0.20681636f, 0.03353494f, 0.23905070f, 0.08848977f, 0.34860849f, -0.03823024f, 
    -0.40080622f, 0.02535303f, 0.02959283f, -0.07800397f, -0.07282104f, 0.06121723f, 0.11868770f, 0.03423233f, 
    -0.02364375f, 0.03145264f, -0.01822712f, -0.01114703f, -0.03929665f, -0.07783266f, 0.14755650f, 0.02693790f, 
    -0.08649125f, 0.04599526f, 0.19037502f, -0.13951097f, -0.15375246f, 0.00074363f, -0.04356196f, -0.00285426f, 
    -0.10989379f, -0.05286693f, 0.00277261f, -0.03781185f, 0.05284420f, 0.13240561f, 0.04786901f, 0.15501028f, 
    -0.03424789f, -0.00199395f, -0.00417355f, 0.06247559f, -0.50323540f, -0.26156148f, -0.47888795f, -0.07474550f, 
    -0.04077921f, -0.03994584f, 0.03058787f, -0.01425424f, -0.08285157f, -0.13029039f, -0.04772312f, 0.07743218f, 
    0.00209941f, 0.22699770f, -0.03811455f, -0.03356222f, 0.05616776f, 0.08196124f, -0.04572735f, 0.03607530f, 
    0.06899294f, 0.02791056f, 0.17720373f, 0.07790090f, -0.20438194f, 0.08196868f, 0.07434568f, 0.05974058f, 
    0.00676313f, 0.20724675f, 0.01075920f, 0.05406827f, -0.06380921f, 0.09885968f, 0.15495941f, -0.05266192f, 
    0.00692716f, -0.08386032f, 0.08443451f, 0.02716426f, 0.49471471f, 0.13607414f, -0.06626781f, -0.13645190f, 
    -0.05076315f, -0.18488640f, 0.06831184f, 0.05149931f, 0.15624972f, -0.01306039f, -0.14289491f, 0.12050694f, 
    -0.12984890f, -0.08985779f, 0.08032923f, 0.07179927f, -0.00294733f, -0.00277639f, -0.06124163f, -0.04782614f, 
    -0.02319765f, -0.04397556f, -0.04584679f, -0.04064755f, 0.01256920f, -0.02907186f, 0.02235230f, -0.03383434f, 
    0.00269373f, -0.03913398f, -0.04234085f, 0.02645247f, -0.02493200f, -0.03109329f, -0.02514143f, -0.00569392f, 
    -0.01682212f, -0.00837312f, 0.00049555f, -0.00393935f, 0.03927541f, 0.03406361f, 0.02721703f, -0.01099012f, 
    0.00478598f, 0.03468667f, -0.01461523f, 0.01933578f, -0.01730272f, 0.01463541f, -0.03653877f, 0.00192139f, 
    -0.03732945f, -0.02183248f, 0.03498608f, -0.00520261f, 0.02056008f, 0.01075200f, 0.01341561f, -0.04384612f, 
    -0.02530752f, -0.02313831f, 0.00871614f, 0.02721443f, 0.00097559f, 0.02054906f, -0.02847226f, -0.02781444f, 
    -0.03020581f, 0.02466813f, -0.01369615f, 0.02766768f, -0.04300147f, 0.01791034f, 0.01446745f, 0.02801667f, 
    0.02032419f, 0.00153969f, -0.02410319f, -0.03218106f, -0.00219946f, -0.01490814f, 0.00211308f, -0.00268663f, 
    0.00107154f, 0.00392240f, 0.00218566f, 0.02892112f, -0.01335299f, -0.02568162f, -0.00116433f, -0.02918350f, 
    -0.01394430f, 0.02828088f, -0.01445604f, 0.02318203f, -0.00490576f, 0.03181998f, -0.01859265f, 0.02205347f, 
    0.00898496f, -0.01385608f, 0.02879704f, -0.02963153f, -0.02495895f, -0.03097959f, -0.02420029f, -0.00873565f, 
    -0.01253326f, -0.00221618f, -0.04159248f, -0.00506845f, -0.04871382f, 0.00945630f, -0.02674273f, 0.02764853f, 
    -0.00100978f, 0.01842293f, -0.03896186f, 0.02776369f, 0.02337204f, -0.04635581f, 0.00689182f, 0.01391492f, 
    -0.04655635f, -0.00297961f, 0.01271046f, 0.02611309f, -0.01159182f, -0.02780361f, -0.01968688f, 0.02322580f, 
    -0.03774678f, -0.01107207f, 0.03019544f, -0.02251888f, 0.02226742f, 0.01425124f, -0.01560231f, -0.00611259f, 
    0.02797550f, -0.00944990f, -0.03025326f, -0.04379895f, 0.02129022f, -0.03721642f, 0.02741463f, 0.00294355f, 
    0.00463850f, 0.02580470f, -0.01174123f, 0.00680019f, -0.00772413f, -0.01693461f, -0.01783257f, 0.03380731f, 
    -0.02153980f, -0.02256329f, 0.01614201f, -0.04920901f, 0.03740678f, -0.04825917f, -0.02294325f, -0.02165225f, 
    -0.04137317f, 0.02499972f, -0.00200866f, -0.02417602f, 0.00840979f, 0.02972920f, 0.00420251f, -0.03048224f, 
    -0.02349167f, -0.00467259f, -0.04767465f, 0.01476320f, 0.02854467f, -0.03871830f, 0.01264863f, 0.02200420f, 
    -0.03973770f, -0.03326914f, -0.03130674f, 0.02027716f, 0.00777412f, 0.02878275f, -0.00430405f, 0.01890748f, 
    0.02362944f, 0.02474229f, -0.01229312f, 0.01650775f, 0.02565166f, -0.04519624f, 0.00677522f, -0.02538383f, 
    -0.03633851f, 0.00213958f, -0.01465799f, 0.00595808f, 0.01026336f, -0.00319418f, 0.00550224f, -0.00387266f, 
    -0.02642703f, 0.02386100f, 0.00448240f, -0.01009372f, -0.04548504f, 0.01641007f, -0.00513436f, -0.03228038f, 
    -0.03348777f, -0.03826452f, 0.02621323f, 0.00843436f, -0.02035529f, 0.00247802f, 0.01174071f, 0.00011364f, 
    0.01571300f, 0.01217636f, -0.04362724f, -0.00974257f, 0.02324776f, -0.04155850f, -0.00893492f, -0.00953726f, 
    -0.03737790f, 0.02848490f, -0.02389363f, 0.02259349f, -0.03690308f, -0.03416403f, 0.00974901f, -0.04631995f, 
    -0.00500146f, -0.03167394f, -0.00729945f, 0.02986575f, 0.01652992f, 0.01810431f, 0.00349787f, -0.02590434f, 
    -0.01323681f, 0.01621092f, -0.01334189f, 0.01636370f, 0.02140224f, 0.01765163f, -0.01810295f, 0.00716666f, 
    0.01273313f, -0.03055349f, -0.02882662f, 0.00743956f, -0.00070223f, -0.00396942f, 0.01206772f, 0.02478974f, 
    0.01675453f, -0.03626874f, -0.02720547f, -0.01036433f, -0.03502779f, -0.04436495f, -0.02019164f, -0.02477742f, 
    0.00055765f, -0.00743841f, -0.01596537f, -0.00825300f, -0.02065038f, -0.04556647f, -0.03670540f, -0.01900923f, 
    0.00080772f, -0.00196016f, -0.00810869f, -0.00105580f, 0.00449602f, -0.02373139f, 0.02840484f, 0.00114265f, 
    -0.04123891f, 0.01246850f, 0.00629411f, -0.01941484f, -0.03563632f, -0.01554251f, 0.01579225f, -0.02496477f, 
    -0.04237933f, 0.00185944f, 0.01604197f, -0.04140870f, 0.00593444f, -0.02159713f, -0.01789682f, -0.01881091f, 
    -0.01120846f, 0.01570066f, 0.02507357f, 0.01458074f, 0.00058616f, 0.02297052f, -0.02062622f, -0.04779095f, 
    -0.01818520f, 0.00323178f, 0.00188836f, 0.01277412f, 0.02530212f, -0.00506729f, -0.01648525f, 0.01756879f, 
    -0.02750554f, -0.03337160f, 0.00771851f, -0.01297856f, -0.03131549f, -0.04234815f, -0.02986277f, -0.03048127f, 
    -0.01363034f, 0.02511131f, -0.04540268f, -0.01250292f, -0.01030749f, -0.04821002f, 0.03018727f, -0.00112654f, 
    -0.01843983f, -0.03702741f, 0.02077313f, -0.04392345f, 0.00428276f, -0.01334903f, -0.04456540f, 0.01194000f, 
    0.00892709f, -0.05065622f, -0.03232891f, 0.02579074f, 0.02151036f, -0.00133864f, -0.00152636f, -0.03411247f, 
    -0.02385212f, -0.00288402f, -0.03196640f, -0.04202815f, -0.01601310f, -0.02227790f, -0.04739248f, -0.02564586f, 
    0.02353780f, -0.00596802f, -0.00697435f, 0.02956336f, 0.01038462f, 0.02011005f, 0.02283447f, 0.00176555f, 
    0.00883103f, -0.03070548f, 0.02665009f, 0.02962262f, -0.02458291f, 0.02138063f, 0.03446234f, 0.02874250f, 
    -0.01607198f, -0.04083075f, 0.00209500f, -0.03704192f, 0.00445904f, -0.01451020f, 0.02227897f, 0.00771590f, 
    0.03620313f, -0.01116955f, -0.01385658f, -0.03278894f, -0.04253132f, 0.01625722f, 0.00904880f, 0.01926042f, 
    0.00755611f, 0.01709633f, -0.04731938f, 0.02181467f, -0.04166144f, -0.03948390f, 0.02605649f, -0.00590643f, 
    0.01920536f, -0.02461118f, 0.00339430f, -0.01376161f, 0.03703423f, 0.02630027f, 0.04610733f, 0.03754166f, 
    -0.00569972f, 0.00017725f, 0.01079568f, -0.04319037f, 0.00967091f, -0.00540541f, -0.03064189f, -0.01234151f, 
    -0.00532420f, 0.01360061f, -0.00400244f, 0.00462728f, 0.02273352f, 0.01709598f, -0.01096370f, -0.00666727f, 
    -0.04214352f, 0.02833864f, -0.01566702f, 0.02547741f, 0.01690052f, 0.02890292f, 0.02852926f, -0.03888634f, 
    -0.01625945f, 0.00384965f, -0.00796582f, -0.00058602f, 0.00486211f, 0.02732617f, -0.01789048f, 0.00461938f, 
    -0.04312409f, 0.02450613f, -0.02899634f, -0.03885203f, 0.00089260f, -0.04278109f, -0.01448598f, -0.00347417f, 
    0.01493004f, 0.01800833f, -0.05008756f, 0.02043407f, 0.00308833f, -0.00994636f, -0.05024387f, -0.04836770f, 
    -0.00118771f, 0.02763565f, -0.00749698f, -0.02744569f, -0.00926340f, -0.04134050f, -0.02805029f, -0.04504051f, 
    0.02753658f, 0.03287098f, 0.02756426f, 0.00569775f, 0.04003759f, -0.01315614f, -0.02157581f, -0.00842998f, 
    0.00244785f, 0.00839725f, -0.00905506f, 0.02906126f, -0.02769721f, -0.04112587f, 0.02284562f, -0.01556162f, 
    0.01952576f, -0.00174166f, 0.00284615f, -0.03932163f, -0.01732541f, 0.01790201f, -0.01144128f, -0.03728390f, 
    -0.01221348f, 0.03424139f, 0.00008517f, 0.01410364f, -0.01622377f, 0.00574816f, -0.03387799f, -0.04581951f, 
    -0.01348666f, 0.00368221f, 0.00087829f, 0.02350152f, -0.02677160f, -0.01553838f, -0.02040959f, 0.02169914f, 
    -0.00744601f, 0.00894020f, -0.03973675f, 0.00111810f, -0.04890273f, -0.02131096f, -0.00392555f, 0.01475648f, 
    -0.01394429f, 0.03012035f, -0.02525646f, -0.05152252f, -0.02307602f, -0.00992823f, 0.00983628f, -0.03714826f, 
    0.02494863f, -0.00800416f, -0.00388561f, -0.02285784f, -0.03335226f, -0.03360554f, -0.01249306f, 0.02736306f, 
    -0.00914119f, 0.00059844f, 0.02776502f, -0.01983232f, -0.03336826f, 0.01939583f, -0.02583171f, -0.01892241f, 
    0.00656578f, -0.00229228f, -0.00136399f, 0.01193310f, -0.03114789f, 0.01294058f, -0.00346541f, -0.02651715f, 
    -0.01862942f, -0.04986728f, 0.01693486f, -0.03988441f, -0.00217650f, 0.02180419f, 0.02214319f, 0.03011787f, 
    -0.00330256f, -0.00966254f, -0.00487759f, 0.01107923f, 0.02670812f, 0.02789876f, 0.01632054f, 0.01955795f, 
    -0.04216714f, -0.03606507f, -0.03574625f, 0.02117526f, -0.02913130f, -0.04508454f, -0.04779705f, 0.01325482f, 
    -0.03974741f, -0.04163385f, -0.04205237f, 0.03265469f, -0.01645507f, -0.01363932f, -0.03163170f, 0.01521919f, 
    -0.00831150f, -0.04465453f, -0.00966283f, 0.00777923f, -0.00571221f, -0.00225603f, -0.04061335f, -0.01060545f, 
    0.01265108f, 0.01549032f, 0.02982077f, 0.01047474f, -0.04824655f, -0.04858281f, -0.02243811f, -0.04430412f, 
    0.00429714f, -0.04516055f, -0.03439494f, -0.02830287f, 0.02518968f, 0.02789241f, 0.00716837f, -0.00563128f, 
    0.01724271f, 0.00895299f, -0.01337200f, -0.00874525f, -0.03214360f, -0.00837498f, -0.02210019f, 0.01025105f, 
    -0.02561772f, 0.00135256f, -0.03101972f, -0.01968503f, -0.02039851f, 0.02673198f, 0.00206257f, -0.04388289f, 
    -0.02834291f, -0.00786911f, -0.00202661f, 0.01284472f, 0.02710278f, 0.02397233f, 0.00747052f, -0.03123276f, 
    0.01880731f, 0.00380683f, 0.02422803f, 0.01009522f, -0.00416369f, -0.00083121f, -0.03123369f, 0.02686430f, 
    -0.02414234f, -0.00075132f, -0.00495547f, -0.02809757f, 0.00301718f, 0.02586670f, 0.01854845f, 0.01801112f, 
    -0.02679207f, -0.03685158f, -0.02015977f, 0.02487611f, 0.00227668f, 0.02110484f, 0.02321733f, 0.02355040f, 
    -0.02478909f, -0.03801148f, -0.02832398f, -0.01935730f, -0.00610457f, 0.02360368f, -0.03564708f, 0.01939917f, 
    0.01608518f, 0.00355402f, -0.01227290f, -0.02472493f, -0.03419066f, -0.02603741f, -0.04117892f, -0.03334657f, 
    0.22053251f, -0.06559119f, 0.36084911f, 0.21222953f, 0.08652397f, 0.04109994f, -0.05186663f, 0.14650236f, 
    0.22162516f, -0.04759366f, -0.02626009f, 0.03561157f, -0.04872696f, -0.01106306f, 0.03788844f, 0.03567945f, 
    -0.09662917f, -0.00564568f, 0.04850152f, -0.12190042f, -0.55572993f, -0.06118927f, -0.07135747f, 0.10154803f, 
    -0.01175734f, 0.05186762f, 0.01744373f, 0.07163580f, 0.04325678f, -0.03309922f, 0.04670728f, -0.11281262f, 
    -0.07100470f, -0.03405610f, -0.04925274f, -0.06966697f, -0.01290281f, -0.04247580f, 0.03301723f, -0.11265849f, 
    -0.41430020f, -0.50238717f, 0.05662725f, 0.04474639f, 0.07090002f, 0.05392126f, -0.01424688f, 0.14678325f, 
    0.20112544f, 0.04086864f, -0.14569804f, 0.02531759f, -0.02813275f, 0.05191315f, 0.05262752f, 0.03547639f, 
    -0.00054111f, -0.03464294f, 0.02741759f, 0.00343170f, -0.14125438f, -0.06126124f, -0.21658340f, -0.07738774f, 
    0.04015410f, -0.10207911f, 0.05262430f, 0.05919684f, -0.10246034f, 0.00413155f, -0.00594193f, 0.06202925f, 
    0.01414039f, 0.06350151f, 0.05389652f, 0.22895589f, 0.15945472f, 0.03609452f, -0.03623421f, 0.04802599f, 
    0.18591709f, 0.38833427f, -0.47648191f, 0.45613697f, 0.63493949f, 0.03591849f, 0.01260461f, 0.14307253f, 
    0.05667293f, -0.04826715f, -0.09864587f, 0.00162756f, 0.06881781f, -0.02787343f, -0.04147198f, -0.00625192f, 
    -0.07032722f, 0.11701372f, -0.04073955f, 0.04547024f, -0.64549208f, -0.21755983f, 0.15611400f, 0.21430124f, 
    0.58275151f, -0.03220214f, 0.12429839f, 0.15335266f, 0.17405063f, 0.23075049f, -0.14852521f, -0.00868978f, 
    -0.06807949f, -0.04486497f, -0.02114467f, -0.02507437f, 0.05625187f, -0.06452569f, 0.03828359f, -0.04220703f, 
    0.51072121f, 0.22004059f, -0.07073735f, -0.05485504f, -0.24745949f, 0.04251844f, 0.13552535f, -0.05769732f, 
    0.03855531f, 0.00397098f, -0.04016505f, 0.03843796f, 0.07334411f, 0.08468737f, -0.03046261f, -0.12564932f, 
    -0.02897269f, -0.01657196f, -0.01387207f, -0.01032036f, 0.23507106f, -0.16362195f, -0.08137469f, 0.12789163f, 
    0.03526052f, 0.02838208f, -0.06540620f, 0.13643637f, 0.08299649f, -0.01953396f, 0.06500360f, -0.06662066f, 
    0.00197039f, -0.07318264f, -0.04948954f, 0.03834026f, -0.03758987f, -0.11467569f, 0.21164325f, 0.07767140f, 
    -0.00583690f, 0.14831050f, 0.14609484f, 0.21002884f, -0.15638210f, -0.11001705f, 0.10181797f, -0.02497335f, 
    0.10783608f, -0.01789863f, 0.10215860f, 0.10756851f, 0.04306541f, 0.09459810f, 0.09854016f, 0.00389281f, 
    0.00165439f, 0.25863424f, 0.17866729f, -0.05728129f, -0.44889078f, 0.00852915f, -0.25816324f, 0.07013314f, 
    0.15046710f, 0.03619972f, 0.07788493f, -0.03540123f, -0.02722355f, -0.00577947f, -0.26909491f, 0.01715422f, 
    0.10794568f, 0.07276185f, 0.13355505f, -0.12844557f, -0.08992873f, 0.06361600f, 0.02718099f, 0.09556513f, 
    0.45666981f, 0.02437091f, 0.39270675f, 0.12519820f, 0.11309307f, 0.00897544f, -0.16172211f, -0.00781299f, 
    0.06004104f, -0.01031500f, 0.04501618f, 0.01645393f, 0.00698705f, 0.05874183f, -0.06426000f, 0.16486982f, 
    0.01460102f, -0.04025928f, -0.06538863f, 0.08576500f, 0.07359441f, -0.11713787f, -0.20131522f, 0.07926044f, 
    -0.07250822f, 0.35243365f, 0.05323322f, 0.12555899f, -0.14942878f, 0.01533232f, -0.07413059f, -0.02539229f, 
    -0.01553218f, 0.09800374f, 0.15750399f, -0.09840450f, -0.03978203f, 0.08705816f, -0.02083651f, -0.01366377f, 
    0.05032827f, -0.02806052f, 0.03127154f, -0.01098343f, 0.02129769f, -0.07727406f, -0.00386756f, 0.09283718f, 
    0.02356686f, 0.05753260f, 0.01553558f, 0.01854830f, -0.06792314f, 0.06865255f, -0.04217758f, 0.12048948f, 
    0.00026437f, -0.15712205f, 0.03736024f, -0.05377783f, 0.11030851f, 0.00013316f, 0.43745121f, -0.05114514f, 
    -0.08627725f, -0.00801661f, -0.05976251f, 0.05316909f, -0.02917594f, -0.05710823f, -0.03135878f, 0.01044282f, 
    -0.08524147f, -0.13217011f, -0.04472750f, -0.06277922f, -0.01432796f, 0.01772491f, 0.00219591f, 0.03427034f, 
    -0.06313632f, 0.02554025f, -0.17881803f, -0.04151833f, -0.19079906f, 0.07159613f, 0.07611196f, 0.03657132f, 
    -0.03224668f, -0.09972499f, -0.04067434f, 0.01671549f, -0.03816107f, -0.03569207f, 0.08973783f, 0.03871219f, 
    -0.13319315f, -0.00106054f, 0.10636352f, -0.00965858f, 0.13276796f, -0.00502549f, 0.33780628f, 0.00527168f, 
    -0.16976938f, -0.09505760f, -0.09365907f, 0.09706450f, -0.05362965f, 0.06549540f, -0.05908567f, -0.05638894f, 
    -0.00811509f, -0.08272400f, 0.13184316f, 0.03405806f, -0.13180935f, 0.11188414f, 0.14631836f, -0.03419319f, 
    0.39401409f, -0.10664045f, 0.31819415f, 0.20104942f, 0.29666165f, 0.11575488f, 0.07556681f, 0.08342767f, 
    0.07142844f, -0.01330867f, 0.06384750f, 0.00884052f, 0.02629660f, -0.05924858f, -0.04075888f, 0.10342223f, 
    0.02872871f, 0.02375019f, -0.02856792f, 0.03999146f, 0.33973479f, -0.52876562f, 0.09691239f, -0.03227017f, 
    0.09766316f, 0.11560552f, -0.03777273f, -0.06316528f, 0.27836335f, -0.02849653f, -0.03734332f, 0.07103863f, 
    0.03275752f, -0.09105112f, 0.03571623f, 0.03024404f, -0.04246319f, 0.01149978f, -0.02473597f, 0.08696827f, 
    0.17272571f, 0.06108063f, -0.29043242f, -0.07735027f, -0.04575999f, -0.00288289f, 0.04262492f, 0.02780959f, 
    0.00375165f, 0.06066879f, 0.14597762f, -0.05278808f, 0.05536608f, -0.03409320f, -0.08021389f, 0.00947552f, 
    0.03270468f, 0.02972852f, 0.04087981f, -0.01594759f, -0.13922048f, 0.12879954f, 0.20950623f, -0.06043497f, 
    -0.29594040f, -0.03302339f, 0.02875612f, -0.05396613f, 0.08463994f, -0.10115324f, -0.07553004f, -0.03113589f, 
    -0.04183076f, -0.04479566f, -0.03005078f, 0.02682657f, -0.02177326f, 0.25310314f, 0.02847666f, 0.07276653f, 
    -0.40368605f, -0.04278760f, -0.24772394f, 0.17683701f, 0.03513550f, 0.04097115f, 0.15920930f, 0.07892421f, 
    -0.00146536f, -0.07063600f, -0.12336554f, -0.08897241f, 0.11672929f, 0.05341884f, 0.03318070f, -0.02913186f, 
    -0.00370596f, 0.10753593f, -0.03008316f, 0.04051257f, 0.24983607f, -0.15297934f, 0.14697199f, 0.10877424f, 
    -0.25534385f, 0.15642904f, -0.04022846f, 0.04379326f, -0.01586000f, -0.16340335f, -0.01762805f, -0.00645992f, 
    0.01715519f, 0.01282655f, 0.00441482f, 0.11596937f, -0.00035346f, 0.11647729f, -0.03559688f, -0.03449706f, 
    -0.23578155f, 0.11151391f, -0.11167563f, -0.07890436f, -0.18218663f, 0.07685532f, 0.01311478f, 0.04747535f, 
    -0.04088139f, -0.12118085f, 0.03117681f, -0.01205316f, 0.02372904f, -0.03873964f, 0.23011683f, 0.13127516f, 
    0.06831072f, -0.01295393f, 0.03853192f, -0.01868983f, 0.02547609f, 0.07806797f, 0.25060853f, 0.12810002f, 
    -0.07834946f, -0.00325606f, -0.16492391f, 0.18962765f, -0.06466763f, -0.06397302f, -0.06456756f, 0.01540262f, 
    -0.03390628f, -0.01636939f, -0.00301047f, -0.01697382f, 0.09309400f, 0.15917191f, -0.01345025f, 0.02839929f, 
    0.06799269f, -0.13736926f, -0.04777478f, 0.10414582f, -0.08706990f, 0.04112612f, -0.02653284f, -0.08740529f, 
    -0.17892359f, 0.02652988f, 0.11104373f, 0.06668193f, -0.09567422f, -0.06330272f, -0.00178681f, 0.03400714f, 
    0.13235427f, -0.03037250f, 0.04701233f, 0.16653913f, 0.20318460f, -0.24457811f, -0.25687900f, 0.14131264f, 
    0.05087636f, 0.11447308f, -0.01707460f, 0.10245287f, -0.12377243f, 0.08607907f, 0.12219584f, 0.09404138f, 
    -0.01144189f, -0.12639998f, -0.02448887f, 0.00809542f, 0.01795710f, -0.04886745f, -0.05066162f, -0.03799137f, 
    0.19814605f, -0.25863314f, -0.07897644f, 0.03879832f, -0.05736860f, 0.14766105f, -0.10641863f, 0.09160937f, 
    -0.07419205f, 0.08117814f, 0.14487644f, 0.06862758f, -0.02609990f, -0.09993345f, 0.02532623f, 0.02111022f, 
    -0.03179737f, -0.12929404f, 0.06469470f, 0.13272969f, 0.22780943f, -0.25930226f, -0.10656178f, -0.12154660f, 
    0.03943682f, 0.18643491f, -0.14201862f, -0.20129190f, -0.05320036f, 0.14686757f, 0.12036487f, 0.12365144f, 
    -0.00789828f, -0.00792785f, -0.03202733f, 0.08951136f, -0.07842088f, 0.02446594f, -0.02088355f, 0.02997387f, 
    -0.06604123f, -0.16370358f, -0.09510273f, -0.13309832f, 0.02082414f, -0.03404865f, -0.04402518f, 0.07821959f, 
    0.00800323f, 0.07550479f, -0.05861871f, -0.01073342f, 0.01884422f, 0.16813153f, 0.03024093f, 0.13966976f, 
    0.09477105f, 0.01059887f, 0.04277633f, -0.01721543f, -0.16543674f, 0.40898067f, -0.52208328f, -0.15122472f, 
    -0.27478760f, 0.10963807f, 0.08821210f, 0.12443838f, -0.09641398f, 0.03865545f, -0.01501749f, 0.08448955f, 
    -0.05391688f, 0.01608163f, -0.00182574f, -0.11821246f, 0.03680374f, 0.02401191f, 0.00917766f, 0.05568365f, 
    0.52042443f, -0.30687702f, 0.00207497f, -0.15509389f, -0.01956513f, 0.08955203f, 0.17073672f, -0.16121317f, 
    0.18318103f, -0.15256451f, 0.02179234f, -0.03547348f, -0.01488160f, 0.04299058f, -0.03669450f, -0.03300220f, 
    -0.13771324f, 0.03522569f, -0.04679691f, 0.01354877f, -0.01388379f, -0.14577888f, 0.40995046f, 0.39150155f, 
    0.20920239f, -0.02278051f, -0.04877142f, -0.06603567f, 0.07355469f, 0.08235279f, 0.03988469f, 0.16563390f, 
    0.06864806f, -0.07858609f, -0.07351197f, -0.09091055f, 0.03553531f, -0.05307336f, 0.09302404f, 0.02924689f, 
    0.29211232f, 0.16932012f, 0.29053140f, -0.11724215f, 0.07207090f, 0.00567865f, -0.17880577f, -0.04907616f, 
    0.05178565f, 0.30273324f, 0.01302609f, 0.09616354f, 0.12788905f, 0.05698325f, -0.05383270f, 0.03305728f, 
    0.02891457f, -0.07070360f, 0.00393817f, -0.07995313f, 0.24467027f, 0.00249250f, -0.10667100f, 0.02845518f, 
    0.11089189f, -0.10072120f, 0.00528746f, 0.02590081f, 0.00291728f, -0.12777010f, -0.18287989f, -0.07135167f, 
    -0.08567367f, -0.08018333f, -0.11800310f, 0.00713222f, 0.02886052f, 0.18615110f, 0.04078476f, -0.11296339f, 
    0.30837941f, -0.45629182f, 0.03435346f, 0.01314185f, -0.30868423f, 0.15775983f, -0.07509981f, 0.16455415f, 
    -0.03967468f, -0.00311380f, -0.01333559f, 0.18020438f, 0.04589180f, 0.11594820f, 0.02080622f, -0.03038886f, 
    -0.01823813f, 0.05122886f, -0.09864920f, -0.04607653f, 0.13210103f, 0.20795974f, 0.37832659f, -0.02652580f, 
    -0.08254208f, 0.08644424f, -0.08124231f, 0.03565358f, 0.19326100f, 0.08125958f, 0.07339600f, -0.03627740f, 
    -0.01285623f, 0.01898663f, 0.16997921f, 0.04720282f, 0.01172589f, 0.03697023f, 0.02001152f, -0.01646654f, 
    -0.16577730f, 0.16616391f, -0.11309659f, -0.09001729f, -0.03792793f, 0.09964912f, -0.00132175f, -0.26920119f, 
    -0.15749979f, 0.19180544f, 0.06362414f, 0.02068233f, -0.14250742f, 0.21778265f, -0.27137199f, -0.02496652f, 
    0.10034037f, -0.11861932f, 0.13675199f, 0.09461604f, 0.11253633f, -0.32968581f, 0.25645971f, -0.22951400f, 
    0.00218248f, -0.10881565f, -0.10000338f, 0.17634490f, 0.12048571f, 0.23653394f, -0.00040877f, 0.07906141f, 
    0.06061869f, -0.14818928f, -0.04891433f, -0.10453008f, 0.05184396f, 0.08149876f, 0.19894277f, 0.01742954f, 
    -0.20618105f, 0.11202330f, -0.10491496f, 0.16633599f, -0.03418978f, -0.01377615f, -0.02068233f, -0.07296899f, 
    0.04643527f, -0.13187610f, 0.11663368f, 0.00033849f, -0.01752693f, -0.00623354f, 0.04052236f, 0.03339818f, 
    0.15127318f, -0.01800228f, -0.07894304f, 0.08553386f, 0.09484192f, 0.27079600f, 0.27995181f, 0.18922409f, 
    -0.08307844f, 0.08566156f, -0.08404471f, -0.03772243f, 0.12108209f, 0.18200956f, -0.07748710f, -0.00452931f, 
    0.03295707f, -0.04619857f, -0.03493891f, -0.04738634f, -0.07785197f, -0.03076542f, 0.01394434f, 0.04832061f, 
    -0.04389745f, 0.08574620f, 0.00438036f, 0.01727105f, -0.20609279f, -0.08044182f, -0.00007352f, 0.00781888f, 
    -0.04207666f, -0.01229643f, 0.15796238f, 0.04513219f, 0.01465918f, 0.16483098f, 0.20282835f, 0.13847335f, 
    0.16311586f, -0.05164519f, 0.02993145f, 0.14415301f, 0.44058138f, 0.04992443f, 0.25069359f, 0.13115606f, 
    -0.17276073f, -0.00527294f, -0.12366042f, 0.02209806f, -0.09001090f, -0.11212607f, -0.11179885f, 0.03939863f, 
    -0.09082313f, -0.02842935f, 0.13572107f, 0.06068474f, -0.10743855f, 0.13730602f, -0.00196053f, -0.05215174f, 
    -0.08172832f, 0.05426093f, 0.33908686f, 0.27766186f, -0.27975672f, 0.18679942f, -0.11164541f, -0.03433917f, 
    0.13848212f, 0.15326278f, 0.05825734f, 0.01750589f, 0.04823716f, 0.01455718f, -0.05475946f, 0.00246013f, 
    0.03769357f, -0.00174381f, -0.03938758f, 0.07653276f, -0.12701268f, 0.36882392f, 0.24601959f, -0.17786634f, 
    -0.08603320f, -0.02008302f, 0.14020236f, 0.06628194f, 0.04009845f, -0.23113652f, 0.12054439f, -0.12955526f, 
    0.05048668f, 0.03617081f, 0.18725921f, 0.07277096f, 0.01754861f, -0.12133487f, 0.06360358f, -0.08561880f, 
    0.05331115f, 0.16239455f, 0.38127422f, 0.10538863f, -0.09434521f, 0.07729410f, -0.03664502f, 0.03733389f, 
    0.01441055f, 0.22631025f, 0.03578572f, 0.03678657f, 0.06386630f, -0.03005064f, 0.08051056f, 0.03215711f, 
    0.02413988f, 0.04207524f, -0.08175471f, -0.04217596f, -0.04508604f, 0.20813741f, 0.01605280f, 0.07431907f, 
    -0.09613607f, 0.03750240f, -0.03305174f, -0.04376121f, 0.02207260f, -0.03903373f, 0.02320085f, -0.02392990f, 
    -0.04717259f, -0.15529326f, -0.13492712f, -0.05734385f, -0.03960719f, -0.07270282f, 0.02321501f, 0.01984698f, 
    0.34669185f, -0.04602142f, 0.00552460f, 0.12828407f, -0.01243604f, -0.07146547f, 0.02608639f, 0.06639409f, 
    -0.13324782f, -0.14811838f, 0.00382847f, 0.06708254f, 0.12127529f, 0.08240262f, 0.03151835f, 0.00465426f, 
    -0.01932389f, 0.11915559f, -0.12282110f, -0.02248080f, 0.08449880f, 0.15527682f, 0.10016535f, 0.11673108f, 
    -0.13481657f, 0.00719704f, -0.07644814f, 0.05943906f, -0.07236780f, 0.04965164f, 0.02196987f, 0.02866860f, 
    0.02947357f, -0.07962052f, -0.06608495f, 0.22127636f, 0.03614785f, 0.11297047f, 0.02948084f, 0.05840245f, 
    0.04608957f, 0.21473402f, 0.19352180f, 0.07433001f, -0.42767578f, 0.01126942f, -0.17619944f, -0.20882377f, 
    0.08439789f, 0.36265656f, -0.04154417f, 0.03594403f, 0.05469070f, 0.02103724f, -0.05998309f, 0.03849063f, 
    0.05918648f, -0.14916976f, -0.11247905f, -0.02349659f, 0.27466595f, -0.54070067f, 0.04659735f, 0.07202017f, 
    -0.24404913f, 0.15711798f, 0.02317117f, 0.15320855f, -0.14432466f, -0.21253705f, 0.02411078f, 0.05735225f, 
    0.06765324f, 0.01343552f, 0.03762438f, -0.00628407f, 0.04587398f, -0.03241751f, -0.09331392f, -0.01036750f, 
    0.19223663f, -0.09628440f, -0.28003865f, 0.04250743f, -0.19719465f, 0.03153639f, 0.07522163f, 0.02300136f, 
    -0.07589590f, -0.20403320f, 0.24365403f, 0.14552452f, 0.09719608f, 0.09678752f, -0.03561361f, 0.02219077f, 
    0.06194083f, 0.03683084f, 0.01056144f, 0.00942043f, -0.25359058f, 0.17539237f, 0.15379721f, 0.28448784f, 
    -0.16632132f, -0.01623204f, 0.08030969f, -0.08873448f, -0.02068684f, -0.08563539f, 0.01772931f, -0.04306729f, 
    0.04112576f, -0.00963487f, -0.15719032f, 0.19984314f, 0.16053954f, 0.14357115f, -0.02286931f, 0.00841604f, 
    0.18220493f, 0.06632392f, -0.06622784f, -0.07663072f, -0.32629567f, -0.04684214f, -0.07123272f, 0.11179288f, 
    0.05460932f, -0.07011774f, 0.01549214f, -0.03558245f, -0.03840934f, 0.01783065f, 0.11831763f, -0.04534436f, 
    -0.02071889f, -0.02906455f, 0.06969146f, -0.00742003f, -0.09762111f, 0.02814375f, -0.05238551f, -0.11394633f, 
    -0.04633304f, 0.06017894f, 0.07056918f, 0.05975553f, -0.00631466f, -0.25673914f, 0.05637016f, 0.01362734f, 
    0.05569948f, -0.00377348f, -0.04103729f, 0.07366024f, 0.10454009f, 0.17843880f, -0.05219220f, -0.02604386f, 
    0.02207216f, 0.04290847f, -0.16338396f, -0.04680189f, -0.06488682f, -0.08809759f, -0.07299103f, 0.04858210f, 
    0.03750292f, -0.23700312f, 0.00087478f, 0.07602032f, 0.02048860f, 0.00659716f, 0.27882370f, 0.10337500f, 
    0.09616856f, -0.02322406f, -0.02063906f, 0.00324931f, -0.02128591f, 0.04513033f, -0.08535165f, -0.16794868f, 
    -0.11157762f, -0.13725837f, -0.06417613f, -0.11186658f, 0.07540385f, -0.08066838f, -0.01919930f, 0.02051076f, 
    0.06797430f, -0.04438631f, -0.13818593f, 0.05641662f, 0.11526129f, 0.04844303f, 0.15559278f, -0.03856958f, 
    0.16694725f, 0.03439689f, -0.19395037f, 0.05193634f, 0.01353288f, -0.02171610f, 0.03323143f, 0.09215540f, 
    0.02680052f, 0.02014922f, 0.03521651f, 0.04657897f, 0.11966053f, -0.06408504f, 0.01629442f, 0.05337550f, 
    -0.00789844f, 0.01105273f, 0.00581149f, -0.03511978f, 0.43466803f, -0.14186220f, -0.21070738f, 0.06425967f, 
    0.03940221f, 0.04856102f, 0.03578689f, 0.10542463f, 0.14342964f, 0.09493476f, 0.05707085f, 0.03217719f, 
    0.02138543f, 0.01292345f, -0.03267037f, -0.07322893f, 0.01873348f, 0.01796930f, 0.05695909f, 0.05374091f, 
    0.43501768f, 0.32992610f, 0.16621308f, 0.21796557f, -0.09872317f, 0.07432526f, -0.02856429f, 0.10731400f, 
    0.17459182f, 0.13737588f, -0.09442876f, 0.00444399f, 0.08853962f, -0.03407187f, -0.02130805f, 0.00232937f, 
    -0.05998114f, 0.02745638f, -0.04229594f, 0.11704812f, 0.24440673f, -0.07249884f, -0.10465252f, -0.01326383f, 
    0.21482652f, 0.00640461f, 0.06822536f, 0.17111312f, 0.00957512f, 0.03725334f, 0.01843749f, -0.01410457f, 
    0.08497563f, -0.04323512f, -0.08106634f, 0.04939874f, -0.02600168f, 0.06315881f, -0.08682080f, -0.01908156f, 
    0.04644680f, 0.27589720f, 0.43848506f, 0.05400311f, -0.05547194f, 0.09201051f, 0.06612724f, 0.07736897f, 
    0.11287027f, 0.08228874f, 0.05088511f, -0.02730806f, 0.09466326f, 0.03587136f, 0.15783119f, 0.03250389f, 
    0.00057987f, 0.05469059f, -0.07442011f, 0.03517072f, 0.17455474f, -0.12041434f, -0.22413911f, 0.23419122f, 
    -0.33475748f, -0.11199769f, 0.05387854f, 0.07284722f, 0.01660321f, -0.36294472f, 0.29979551f, 0.00546575f, 
    0.03871472f, 0.02995668f, 0.02039015f, 0.07645722f, 0.02363558f, 0.07571686f, 0.00841565f, -0.06321073f, 
    0.04021665f, 0.01347881f, -0.04020355f, 0.05198181f, -0.20212780f, 0.24443674f, 0.07605406f, 0.06792773f, 
    -0.11188870f, 0.01099317f, 0.04927744f, 0.09099916f, 0.05075421f, 0.05769750f, -0.01753284f, 0.08950392f, 
    -0.03315050f, 0.06097877f, -0.11414006f, 0.04061285f, -0.12911348f, 0.13417517f, 0.34822625f, 0.11011171f, 
    -0.24810153f, -0.01730787f, -0.20556094f, -0.07368556f, 0.03522204f, 0.28102127f, 0.05792735f, 0.17351323f, 
    0.06312471f, 0.00258472f, -0.01427579f, 0.02245585f, 0.08745752f, -0.14915720f, 0.06225116f, 0.17684434f, 
    -0.37765977f, 0.13650088f, -0.35816038f, 0.03453548f, -0.00938022f, -0.01592043f, -0.01265829f, 0.01973179f, 
    -0.01046512f, 0.04244265f, -0.03091745f, -0.02751364f, 0.06435084f, -0.02802381f, 0.02083933f, 0.08993696f, 
    -0.05901441f, 0.00191258f, -0.07405067f, 0.05244935f, 0.05398054f, -0.00969146f, -0.16850042f, 0.09105528f, 
    -0.09164431f, -0.02862485f, 0.02929223f, 0.07753880f, 0.09856704f, -0.00253700f, -0.16537569f, -0.07513757f, 
    -0.00303972f, 0.03607737f, -0.08003633f, -0.04135402f, 0.04575359f, -0.14048029f, -0.03663113f, -0.00270291f, 
    -0.05787982f, 0.73831779f, -0.31275520f, 0.40053931f, 0.16145474f, -0.14495616f, 0.02665310f, -0.18943131f, 
    0.04631709f, 0.08890717f, 0.08311400f, 0.00324931f, -0.02822852f, -0.00217164f, 0.10043075f, 0.05236204f, 
    0.00398997f, 0.03882146f, 0.04045608f, 0.00979542f, 0.23317969f, 0.07645354f, -0.02086246f, -0.02338580f, 
    0.02862165f, 0.11464419f, 0.07133085f, 0.07632028f, 0.02600796f, 0.07907721f, -0.04173378f, -0.02718054f, 
    -0.04738367f, -0.01023152f, 0.05081399f, 0.03222169f, -0.04591597f, 0.10317515f, 0.05251402f, 0.07788783f, 
    -0.22283255f, -0.19213040f, 0.21129459f, 0.14295469f, -0.42950195f, -0.11422049f, 0.19224039f, 0.04942370f, 
    0.17188017f, 0.07056589f, 0.19606899f, 0.06582632f, 0.00653423f, -0.05967035f, 0.15052217f, -0.17198162f, 
    0.08292691f, -0.14419489f, -0.11033507f, 0.13098848f, 0.19258796f, 0.42675731f, -0.36486769f, 0.54532927f, 
    0.00955642f, -0.00682621f, 0.02625724f, -0.02554862f, -0.02697816f, 0.05930789f, 0.02907219f, -0.07659351f, 
    0.04591652f, 0.02953714f, 0.14038727f, 0.02164499f, -0.00206061f, 0.02759523f, 0.05226836f, 0.14014474f, 
    0.10005463f, -0.29171637f, 0.24835812f, -0.20825687f, 0.14043391f, 0.08680726f, 0.00396595f, 0.06774149f, 
    -0.13472150f, -0.09082673f, -0.01978585f, 0.05814093f, -0.00212930f, -0.06747119f, 0.10231030f, -0.01219234f, 
    0.06465914f, -0.09048372f, -0.04609215f, -0.14908779f, 0.18148386f, 0.10672285f, -0.04097247f, -0.11125044f, 
    0.19070849f, -0.02628758f, 0.10750530f, 0.03750762f, 0.01691153f, 0.04250232f, -0.02010683f, 0.13704352f, 
    0.01763412f, -0.10946973f, -0.03958056f, -0.11581646f, -0.11776346f, 0.02151391f, -0.07576008f, 0.03238336f, 
    0.14783616f, -0.25750268f, 0.22109208f, -0.27938160f, -0.15258317f, 0.00672230f, 0.00983503f, -0.06772374f, 
    -0.10227662f, 0.00033130f, -0.16086550f, 0.05167268f, -0.03600243f, 0.04180769f, 0.02790971f, -0.00852249f, 
    0.14934732f, -0.12487286f, -0.08662710f, -0.11082778f, 0.31219450f, 0.28364030f, -0.06027614f, 0.31909135f, 
    -0.16247976f, 0.12724760f, 0.11595041f, 0.13929717f, 0.02295857f, 0.06291687f, 0.13495763f, -0.06535701f, 
    -0.17622121f, 0.11445300f, -0.00773745f, 0.08547837f, -0.04095227f, -0.00138854f, 0.07113703f, 0.03275890f, 
    0.04848729f, 0.15586318f, -0.10103450f, -0.35568738f, 0.21109895f, 0.09500234f, 0.09891964f, 0.00313374f, 
    0.02540685f, 0.01811078f, 0.04084031f, -0.05025771f, -0.00888193f, -0.05030137f, -0.05068836f, -0.02945239f, 
    -0.04165811f, 0.06477822f, 0.07784555f, 0.01254574f, 0.19652024f, 0.35253221f, 0.09155113f, 0.04329580f, 
    0.14514782f, 0.08023538f, 0.23848636f, 0.14476807f, 0.16473757f, 0.11450892f, -0.11294591f, 0.14685041f, 
    0.06241970f, 0.00114031f, 0.13093258f, 0.03740400f, 0.13922571f, 0.05587327f, 0.10626038f, -0.00015118f, 
    0.23008338f, 0.05997379f, -0.12220357f, -0.15898536f, 0.14054969f, 0.11755227f, 0.06414931f, 0.03255799f, 
    -0.06027227f, 0.11299266f, -0.06468093f, -0.12468281f, -0.01566965f, -0.12892306f, -0.06299670f, 0.02438138f, 
    -0.06609254f, 0.08886836f, -0.04394494f, 0.05326568f, -0.06652479f, -0.05926710f, 0.09896430f, -0.02566648f, 
    0.06144967f, -0.12095055f, -0.14667255f, -0.03859982f, -0.06574943f, 0.03292041f, -0.02604410f, -0.01564880f, 
    0.04172485f, -0.04537075f, -0.03406244f, 0.09678535f, -0.00327754f, -0.04947000f, 0.12648883f, 0.11384963f, 
    -0.41812369f, 0.30705416f, 0.19032653f, -0.03986423f, -0.13750264f, -0.03797722f, -0.01438539f, 0.00862559f, 
    0.09884177f, -0.11000265f, 0.00760339f, -0.05456380f, -0.03683971f, -0.08763670f, -0.07716120f, -0.03226174f, 
    0.13702559f, -0.04569957f, -0.01134903f, -0.23846334f, -0.18635479f, -0.03375403f, -0.14827757f, 0.02622997f, 
    -0.01822435f, 0.15126115f, -0.06615356f, 0.07585610f, 0.04533567f, -0.04288469f, -0.06214145f, 0.07612827f, 
    -0.00768026f, 0.05341907f, 0.00952725f, -0.08835565f, 0.06044604f, 0.01091582f, 0.00733629f, -0.09552343f, 
    -0.06855349f, 0.03157462f, 0.12088875f, -0.18657199f, 0.03317563f, -0.13711937f, 0.01797010f, 0.08973041f, 
    0.04515328f, 0.02050674f, -0.02493289f, -0.06067475f, -0.00461333f, 0.06464802f, -0.05940135f, -0.05664973f, 
    -0.07307442f, -0.09095595f, 0.18548821f, 0.01619267f, -0.16811140f, 0.54341781f, -0.11984998f, 0.08038055f, 
    0.11687629f, -0.08410756f, 0.03072566f, -0.07707558f, -0.17990854f, -0.09870378f, 0.06515564f, 0.01737148f, 
    0.02175653f, 0.02147854f, 0.08153351f, 0.08267387f, -0.03122011f, -0.01943708f, -0.03235057f, -0.18079890f, 
    0.00476574f, -0.25484273f, -0.04012879f, -0.00207923f, 0.12596627f, 0.10887934f, 0.02381939f, 0.05309553f, 
    -0.11496594f, -0.16775589f, -0.27643639f, 0.03773309f, -0.05734238f, -0.15936469f, -0.09374386f, 0.03836641f, 
    0.00591389f, -0.05499786f, -0.00838084f, 0.06139727f, 0.33887053f, -0.19042866f, -0.23536164f, -0.13639224f, 
    0.11525397f, -0.25050417f, -0.19822362f, -0.12117678f, -0.11160821f, -0.11786392f, -0.14523681f, 0.02829698f, 
    0.01381128f, 0.04037706f, -0.09416881f, 0.02430630f, 0.03886504f, -0.09014063f, -0.06679539f, -0.09453718f, 
    0.50480896f, 0.19206229f, -0.00951848f, 0.25201514f, 0.01787156f, 0.02810427f, 0.11186020f, 0.06956229f, 
    0.00372733f, 0.05180711f, 0.04634439f, 0.13887243f, -0.09449787f, 0.00019947f, -0.05506105f, 0.01680249f, 
    0.01118884f, -0.07225503f, 0.15487584f, 0.02236660f, -0.38902825f, 0.11966155f, 0.02187424f, 0.08122614f, 
    0.01078258f, -0.24224807f, 0.08890112f, -0.13108502f, 0.12267552f, -0.02840876f, -0.01228914f, 0.02358510f, 
    -0.01869866f, -0.00644198f, -0.15808930f, 0.05075542f, -0.03992458f, 0.01265322f, 0.03580210f, -0.10621835f, 
    0.09826580f, -0.04981001f, 0.12951842f, -0.07873264f, -0.06558451f, -0.12540777f, -0.15792833f, 0.11670092f, 
    -0.03762913f, -0.00335646f, -0.11724987f, 0.04893932f, -0.16007200f, 0.04536010f, -0.09818507f, -0.08333993f, 
    -0.00553770f, -0.07142323f, 0.02068773f, -0.05079684f, -0.42565441f, 0.03652146f, 0.03050818f, 0.21253495f, 
    -0.03393520f, -0.15395267f, -0.11452599f, 0.07460645f, 0.04972877f, 0.00349348f, -0.17299405f, 0.02747987f, 
    -0.04831712f, -0.02980161f, 0.03113943f, -0.12693164f, -0.05797635f, -0.00758342f, 0.02315679f, 0.05950553f, 
    -0.10066043f, 0.10496528f, 0.16828808f, -0.03346275f, 0.09212454f, 0.00321344f, -0.02615223f, 0.09139509f, 
    -0.00621628f, 0.01253474f, -0.06455061f, 0.01284336f, 0.06191108f, -0.04126402f, -0.05598641f, -0.07474210f, 
    0.03438577f, 0.08251333f, -0.01160421f, -0.19713201f, -0.18796787f, 0.17705573f, -0.28455138f, -0.00708043f, 
    0.15358599f, -0.07804275f, -0.05780484f, 0.02349436f, 0.04054912f, -0.04911832f, 0.01535547f, 0.02940399f, 
    0.01890831f, -0.01533904f, 0.01308316f, 0.07948636f, -0.03903307f, 0.06383961f, 0.10306869f, 0.00835949f, 
    -0.09355322f, 0.27520871f, -0.12773947f, -0.18239672f, 0.23843940f, -0.01548482f, -0.03420566f, 0.01725702f, 
    0.15022376f, 0.01367569f, 0.05762493f, 0.01594524f, -0.00989297f, 0.06151225f, -0.09841477f, 0.03707753f, 
    -0.13631018f, -0.01985951f, -0.04307985f, -0.01609731f, -0.19827582f, 0.32510918f, -0.00867048f, -0.08563371f, 
    0.35673821f, 0.07886926f, 0.05302015f, 0.19293562f, -0.03816083f, -0.10804092f, -0.03097777f, 0.08603626f, 
    0.06359320f, 0.03071420f, 0.01321568f, -0.00037084f, -0.12007532f, -0.02650296f, -0.03815119f, -0.16148053f, 
    0.22401886f, 0.14364545f, -0.11740740f, 0.05715146f, 0.05246721f, 0.05574090f, 0.07967464f, 0.03676840f, 
    0.01718546f, 0.01374229f, -0.06466254f, -0.00578428f, -0.02193619f, -0.09675579f, 0.07838009f, 0.02829906f, 
    -0.01760303f, 0.09816410f, 0.04085863f, 0.13014133f, 0.17665978f, 0.10158012f, 0.35838598f, 0.01924980f, 
    0.23496349f, 0.23676306f, -0.07531684f, 0.08567571f, 0.01587477f, 0.11487958f, -0.15845518f, -0.02927887f, 
    -0.00330395f, 0.03510324f, 0.06165892f, 0.06554040f, -0.02734340f, -0.10154057f, -0.09485652f, -0.04021673f, 
    -0.00820570f, 0.12175602f, 0.13050948f, -0.03404528f, 0.12233841f, 0.05229945f, -0.01263254f, 0.02036237f, 
    -0.11052128f, -0.14118774f, 0.04474512f, -0.00708898f, 0.04057876f, 0.00871720f, 0.06048656f, 0.19358329f, 
    -0.04973880f, 0.05685439f, -0.06794132f, -0.08603825f, -0.14451380f, -0.10725331f, -0.13231593f, 0.01536155f, 
    -0.09117512f, 0.04529596f, 0.03458536f, -0.00067223f, 0.00246977f, -0.00303212f, 0.16948090f, -0.07198461f, 
    0.03548350f, 0.18018839f, 0.08877938f, -0.06373417f, -0.07542379f, -0.04209221f, 0.16978970f, 0.07369159f, 
    0.05461363f, -0.16791122f, 0.18325883f, -0.25934446f, 0.24784391f, -0.04792382f, 0.02137646f, 0.12353657f, 
    -0.08777655f, 0.07068917f, 0.06385775f, -0.07381220f, 0.05896834f, -0.09160101f, -0.10887258f, 0.05632067f, 
    0.18147564f, 0.05489320f, -0.00133360f, 0.19915529f, 0.04521988f, -0.03904675f, 0.19868007f, -0.20168065f, 
    0.14272660f, 0.07111555f, -0.18564858f, 0.02202430f, 0.07505804f, 0.15485390f, -0.05309746f, 0.13150465f, 
    0.11210469f, 0.08777263f, -0.04919038f, -0.07283819f, 0.13282378f, 0.19658500f, 0.14303881f, 0.33340758f, 
    0.13426696f, -0.01997892f, 0.28700542f, -0.06905936f, -0.09350844f, 0.13121693f, -0.22768007f, 0.06648251f, 
    -0.06934844f, -0.18847103f, 0.05091643f, 0.00573819f, 0.01875615f, -0.07330059f, 0.03408024f, 0.04227589f, 
    -0.13278170f, -0.04883592f, -0.00237552f, 0.02112350f, 0.13858463f, -0.03063859f, -0.02950285f, -0.10414092f, 
    -0.14236191f, 0.02696032f, 0.08572727f, -0.04068968f, 0.01636293f, 0.09697066f, 0.05500121f, 0.00948757f, 
    0.01353599f, 0.13981715f, 0.15208124f, 0.07256877f, 0.12449475f, 0.01090079f, 0.19477206f, 0.27445158f, 
    -0.05034137f, 0.37197560f, -0.18293758f, -0.21831110f, -0.27947843f, 0.13125247f, -0.07176401f, 0.05265010f, 
    -0.07369683f, 0.16873428f, 0.18947053f, 0.15540549f, 0.05078145f, -0.07152481f, -0.13445868f, -0.15333714f, 
    -0.01223892f, -0.12647209f, -0.08695711f, -0.05174565f, 0.08678816f, -0.41385356f, 0.29069489f, -0.19137852f, 
    -0.06320257f, -0.07756556f, -0.04997339f, -0.00635436f, -0.05757858f, -0.03509895f, 0.03566596f, 0.04778302f, 
    0.01262877f, 0.17743403f, 0.03813606f, -0.07777336f, -0.00477662f, -0.02021956f, -0.10372797f, 0.05841219f, 
    -0.28162831f, 0.17098132f, -0.06607786f, 0.21326543f, -0.09064202f, -0.00669154f, -0.14968285f, 0.00501861f, 
    -0.04621202f, -0.10887214f, 0.06696763f, -0.00839724f, -0.04014643f, 0.01750750f, 0.01840691f, 0.05718653f, 
    -0.10519065f, -0.03537934f, -0.19259606f, -0.16799854f, 0.13847038f, 0.18927072f, 0.24188071f, -0.02216323f, 
    -0.09413166f, 0.19739175f, -0.04643752f, -0.00389207f, -0.01340569f, 0.21330303f, 0.09566032f, -0.02585844f, 
    0.05431733f, -0.05101150f, 0.03357994f, 0.04556913f, -0.03656459f, 0.02617562f, 0.01491794f, -0.17526248f, 
    -0.44823471f, 0.06808651f, -0.01671356f, -0.11207654f, -0.05525595f, 0.27587894f, -0.12183247f, 0.20611261f, 
    -0.15785021f, -0.06461469f, 0.11524364f, -0.09678493f, -0.16789040f, -0.05548156f, -0.07186270f, 0.00632261f, 
    -0.35508847f, 0.03360900f, -0.22467291f, -0.20904076f, -0.07445560f, -0.37530360f, -0.15732546f, 0.03201354f, 
    -0.00382768f, 0.05223479f, -0.18405007f, 0.05552244f, 0.04601061f, 0.01525377f, 0.02432658f, 0.05969200f, 
    0.03235340f, 0.11904863f, 0.06598657f, 0.00914055f, 0.15997732f, 0.15789394f, 0.17763947f, 0.22401625f, 
    -0.03970492f, 0.15677299f, -0.21619983f, 0.21614417f, -0.22344686f, 0.01760639f, 0.08386944f, 0.19110475f, 
    -0.04367651f, 0.04110122f, 0.16744769f, -0.05655492f, 0.06516377f, 0.06002876f, -0.05169937f, 0.02623535f, 
    0.19822934f, 0.08766810f, 0.11740713f, 0.10564315f, 0.34988400f, -0.19343156f, 0.03847807f, -0.08765791f, 
    0.08692408f, -0.16223796f, 0.03812851f, -0.19761230f, -0.00841191f, -0.04439908f, 0.13526647f, 0.03054083f, 
    -0.02134264f, 0.04887256f, 0.11272358f, 0.12793452f, 0.17747983f, 0.22227199f, 0.02899223f, 0.13172889f, 
    0.11159660f, 0.06202903f, 0.04093839f, -0.00338553f, -0.15714891f, -0.01444771f, 0.10894924f, -0.05737274f, 
    0.04104346f, 0.13198473f, -0.03684302f, 0.00114319f, 0.05567612f, 0.12379619f, 0.02189496f, -0.02313048f, 
    0.12680618f, 0.08625025f, 0.16940068f, 0.20753105f, -0.07725184f, 0.07140527f, -0.36204955f, 0.15578125f, 
    0.09148922f, 0.06257373f, 0.18206219f, 0.20011835f, -0.05214647f, 0.09075367f, -0.12242893f, -0.17684820f, 
    -0.03758148f, -0.03129353f, -0.11474590f, 0.13890393f, 0.21615800f, 0.07552689f, 0.04571674f, 0.18745901f, 
    -0.22590765f, -0.09604624f, 0.11399768f, -0.04242970f, -0.04351747f, 0.13732739f, -0.13548578f, -0.01617085f, 
    0.01292574f, -0.18805587f, 0.18346766f, 0.09622087f, -0.11986911f, 0.03682176f, 0.07488272f, -0.06889641f, 
    0.12873596f, -0.01512963f, -0.03650995f, -0.03383749f, -0.04174494f, -0.24964431f, -0.09189820f, -0.21350023f, 
    0.13396816f, 0.06262492f, 0.19314511f, -0.05098191f, 0.01703410f, -0.04777808f, 0.09500529f, -0.09271321f, 
    -0.14085428f, 0.00888140f, -0.00513338f, -0.11841460f, -0.13969955f, 0.00684913f, -0.07151937f, -0.01022692f, 
    -0.10908499f, 0.41769043f, -0.18352291f, 0.18426673f, 0.12099437f, 0.15220477f, 0.19010392f, 0.24835463f, 
    0.13879243f, 0.22464363f, 0.02912304f, -0.09993123f, -0.08515330f, -0.07338939f, 0.00018560f, 0.17008434f, 
    0.14473403f, 0.21377014f, 0.16368081f, 0.11841460f, 0.05631663f, 0.28633928f, 0.15375762f, -0.08228330f, 
    -0.15149628f, -0.08689106f, -0.31721535f, 0.02103935f, -0.15826198f, -0.31553018f, -0.02984780f, 0.07627670f, 
    -0.01911817f, -0.05397746f, 0.02766628f, -0.00485434f, -0.10649922f, -0.05046095f, -0.06414278f, -0.23844244f, 
    0.36659244f, 0.40443745f, 0.38023004f, 0.26416114f, 0.11256137f, -0.08551469f, -0.29333526f, -0.23318729f, 
    -0.13233504f, -0.21600060f, 0.03111972f, -0.03291247f, 0.03435320f, 0.06647018f, 0.04518802f, 0.00985698f, 
    -0.19001421f, -0.02305513f, -0.14115463f, -0.20311205f, -0.21550635f, -0.03895108f, -0.46757331f, 0.09956599f, 
    0.19527203f, 0.17905909f, 0.20469056f, 0.40595230f, -0.10205734f, -0.04050296f, 0.18760315f, 0.00222755f, 
    -0.03224437f, 0.09503856f, 0.04906420f, 0.15992601f, 0.02309781f, -0.12212954f, 0.02879108f, -0.07010953f, 
    0.05184122f, -0.21860060f, 0.00988694f, -0.05368657f, -0.04030333f, -0.03819749f, -0.12891915f, 0.00139787f, 
    0.06621771f, -0.03495890f, -0.06696758f, 0.08598987f, 0.05347532f, 0.02227630f, 0.06639370f, 0.19402003f, 
    0.16449223f, 0.10177041f, 0.03813669f, 0.15738869f, -0.04947315f, -0.18697982f, 0.01755036f, -0.06960388f, 
    -0.02395940f, 0.20819165f, 0.06625613f, -0.09048554f, 0.10290889f, -0.02401851f, -0.00192594f, 0.00495034f, 
    -0.07748082f, -0.08098063f, 0.10848869f, -0.05324019f, 0.11189301f, -0.14803490f, -0.01911598f, 0.04581958f, 
    -0.17212097f, 0.22012527f, 0.25559172f, -0.02690214f, 0.15726873f, -0.24164328f, 0.09361704f, -0.16708279f, 
    0.02047455f, -0.17606728f, 0.14157128f, 0.07784577f, -0.02254102f, 0.00878517f, -0.11034026f, -0.00470201f, 
    0.00306238f, -0.15953439f, -0.12430255f, -0.06780007f, 0.13934194f, -0.38969892f, 0.09344040f, -0.08098825f, 
    0.22450960f, 0.01389889f, 0.27829829f, -0.04107174f, -0.10169295f, 0.00634490f, 0.01304208f, -0.11457863f, 
    -0.06099799f, -0.01651714f, -0.01261436f, 0.05932682f, -0.00395931f, -0.12210459f, -0.19504835f, 0.12941733f, 
    -0.04755860f, 0.20130843f, 0.01168138f, 0.04337750f, -0.23288065f, -0.09246419f, 0.00610827f, -0.05585599f, 
    -0.09146282f, -0.10806438f, 0.12528172f, 0.08700100f, -0.07266931f, 0.02648042f, 0.00535593f, -0.02768469f, 
    -0.25052682f, -0.10467225f, -0.27007458f, -0.20141475f, 0.15707937f, 0.24224047f, 0.31579959f, -0.09305082f, 
    -0.21401201f, -0.00569245f, -0.07885663f, -0.16682763f, -0.08522794f, 0.05276264f, 0.06282324f, 0.03336500f, 
    0.01650014f, 0.09331238f, -0.08385013f, -0.10558145f, -0.34813437f, -0.19713773f, -0.07937063f, -0.20054498f, 
    0.06187946f, 0.21549708f, 0.19889434f, -0.08790549f, 0.03650324f, -0.15873258f, 0.00846016f, 0.11799596f, 
    -0.02444212f, 0.19170523f, 0.14695053f, -0.03652168f, 0.01136103f, -0.03790802f, -0.00770278f, -0.01464448f, 
    -0.23840481f, -0.03034053f, 0.02558693f, -0.33778509f, 0.16549839f, 0.20817594f, -0.02751286f, -0.15815085f, 
    -0.13035218f, -0.03044474f, 0.10796911f, 0.11487272f, -0.00820713f, 0.03757302f, 0.08734774f, -0.07074221f, 
    -0.06086494f, -0.02566938f, 0.04398960f, -0.09556936f, -0.00015617f, -0.02162714f, 0.14245346f, -0.13989921f, 
    0.16148810f, -0.11509214f, -0.03813495f, -0.05184115f, -0.11267897f, -0.12291651f, 0.10188607f, -0.09181663f, 
    0.00735327f, 0.07555798f, 0.09578442f, -0.05655740f, 0.00917303f, 0.04307443f, 0.05808019f, -0.00240590f, 
    0.21019803f, 0.18805297f, 0.15004054f, 0.20711666f, 0.51871169f, 0.28264633f, 0.15387662f, 0.22387409f, 
    0.15796009f, -0.30965862f, -0.18700159f, -0.24261384f, 0.09414019f, -0.02765292f, 0.06865159f, -0.03346728f, 
    0.06829070f, 0.08526550f, -0.03795522f, -0.02475088f, 0.16354664f, 0.04864844f, 0.05306478f, 0.13200848f, 
    -0.02352214f, 0.03437995f, 0.07070380f, 0.04216176f, -0.16067882f, 0.05934620f, -0.12926151f, 0.08024885f, 
    -0.07566505f, -0.14850987f, -0.03230449f, 0.02075297f, 0.03194197f, 0.02918562f, 0.10891423f, 0.01653916f, 
    0.03980395f, -0.04330360f, 0.09332778f, 0.00192556f, -0.02362582f, 0.28134298f, 0.07067513f, -0.21949835f, 
    -0.04431679f, 0.00588213f, 0.03979544f, 0.10149979f, 0.01993550f, 0.12469086f, 0.06064536f, -0.04336691f, 
    0.01730074f, -0.31760946f, -0.18018237f, -0.17952533f, -0.26903507f, -0.17265795f, -0.17340598f, -0.26260605f, 
    0.20509629f, 0.08544782f, 0.01714927f, -0.11230760f, -0.15515548f, 0.08506603f, 0.01921517f, 0.03000155f, 
    -0.10450175f, 0.13043532f, 0.09012520f, 0.05049995f, 0.09183535f, -0.05842035f, -0.05214492f, -0.12914780f, 
    0.00081138f, 0.02706763f, 0.10068627f, -0.00262125f, 0.30716977f, 0.11097126f, 0.10392570f, 0.13161266f, 
    0.03346011f, -0.14787592f, -0.17120558f, -0.16393794f, -0.08939693f, -0.06987762f, -0.00217945f, -0.19635454f, 
    -0.04081704f, -0.04483422f, 0.03867070f, -0.05942652f, -0.00266305f, 0.11035115f, 0.07782954f, -0.03574569f, 
    0.25958574f, -0.04672049f, -0.37161168f, -0.17468436f, -0.03768245f, 0.09954287f, -0.10508072f, -0.00163860f, 
    -0.03423134f, 0.19041978f, 0.04554834f, 0.21104670f, 0.08779088f, -0.01457116f, 0.05947876f, -0.11212709f, 
    0.10371816f, 0.08405749f, 0.05670663f, 0.04859601f, 0.18245056f, 0.11102851f, 0.12468807f, -0.08778360f, 
    -0.06855213f, 0.13138498f, 0.02677027f, 0.09767655f, 0.05100147f, 0.00122635f, 0.11215428f, -0.08662438f, 
    -0.08730120f, -0.09947848f, 0.11330520f, -0.05065697f, -0.05924327f, -0.00342137f, 0.00049387f, -0.13755524f, 
    0.02667280f, -0.02754758f, 0.27790147f, -0.13020246f, -0.25408697f, 0.06574360f, -0.12921546f, -0.19712161f, 
    -0.06960458f, -0.08513822f, -0.00908390f, -0.02304047f, -0.14242192f, 0.21047632f, -0.11847565f, 0.06695790f, 
    -0.00617875f, 0.07414189f, 0.14743519f, -0.03561229f, 0.08220927f, 0.10012543f, -0.00090255f, -0.22503579f, 
    -0.02463914f, 0.07511093f, -0.18103057f, 0.04700401f, -0.07187430f, 0.08908562f, 0.06894657f, 0.06186282f, 
    -0.00642255f, -0.21688768f, -0.00375002f, -0.02857920f, 0.03297886f, 0.02819171f, 0.17963855f, 0.05395690f, 
    -0.26922604f, 0.13330702f, 0.06776214f, 0.04018312f, 0.07822920f, -0.05057897f, -0.03697877f, 0.00107519f, 
    0.12570386f, -0.01561596f, 0.09960089f, 0.01621706f, 0.06292864f, -0.04345879f, 0.00579953f, 0.00808304f, 
    -0.00489620f, 0.07236332f, 0.02141938f, 0.23393846f, -0.00647088f, 0.06834092f, 0.10663119f, -0.17000744f, 
    -0.10751834f, 0.13925992f, 0.14187425f, 0.05654932f, 0.09110927f, 0.00981548f, -0.04278766f, -0.13169225f, 
    0.02379492f, 0.13486850f, 0.01659484f, 0.00947519f, -0.05529541f, 0.01749783f, -0.08706051f, 0.13415161f, 
    -0.23114596f, -0.16705419f, -0.16476002f, 0.13066250f, -0.02333286f, -0.27584943f, -0.27619863f, -0.02020730f, 
    -0.05719223f, 0.02262125f, 0.12907714f, -0.15240307f, -0.12528288f, -0.06980853f, 0.05986693f, -0.00838123f, 
    0.12028710f, -0.13891304f, 0.04128588f, 0.34823674f, 0.43573371f, 0.04219241f, 0.14779815f, -0.00570580f, 
    0.02583004f, -0.05060235f, -0.16346227f, 0.01577370f, -0.08602680f, 0.03196906f, 0.03614353f, 0.06591028f, 
    -0.04388260f, -0.15723580f, 0.08570105f, 0.05746108f, -0.05246608f, 0.05508032f, 0.09897782f, -0.05906566f, 
    -0.11934774f, 0.07329838f, 0.26276216f, -0.09740444f, -0.16821557f, 0.02768257f, 0.06201051f, -0.02032370f, 
    0.16525732f, 0.01075382f, 0.08400287f, 0.04872083f, 0.04323941f, -0.03543824f, 0.01611683f, 0.01990843f, 
    -0.00545698f, 0.07555223f, -0.07111333f, -0.01085574f, -0.08473634f, 0.19893098f, 0.07493035f, -0.26638937f, 
    0.01022897f, -0.08110444f, -0.00567229f, 0.01523803f, -0.08942708f, -0.10545335f, 0.09908590f, 0.01097667f, 
    0.04245206f, -0.07262617f, -0.03378680f, 0.05343124f, -0.08749115f, -0.10589554f, -0.01239765f, -0.04651975f, 
    0.05282579f, 0.14177531f, 0.19199532f, -0.07136599f, -0.05445853f, 0.09486617f, 0.05537311f, 0.05162317f, 
    0.03978631f, 0.02683286f, 0.11778023f, 0.02100341f, 0.00538439f, -0.04323310f, 0.02896214f, -0.02013071f, 
    -0.00475844f, 0.04626670f, -0.16092706f, -0.12350791f, -0.57615560f, 0.27452332f, -0.07452551f, 0.04426344f, 
    -0.02963994f, -0.02555283f, -0.05137783f, -0.18535332f, 0.08922556f, -0.07746480f, -0.01879201f, -0.11573532f, 
    -0.06508704f, -0.01074800f, -0.04996556f, -0.02449061f, -0.04111169f, 0.07565872f, 0.02317684f, -0.05008262f, 
    0.46961173f, -0.00369603f, 0.15562740f, 0.16550693f, 0.12836453f, -0.16829592f, -0.12921104f, -0.02043382f, 
    -0.20577201f, 0.09974651f, 0.00385235f, 0.17434706f, 0.22728893f, 0.04921692f, 0.06832340f, 0.00488029f, 
    -0.01290486f, 0.11931463f, -0.01551248f, 0.18150850f, 0.06557832f, 0.11937426f, -0.11121639f, 0.11847224f, 
    -0.05379775f, -0.08419095f, -0.05238923f, -0.09537417f, 0.01969668f, -0.00005401f, 0.12115120f, -0.01797324f, 
    0.16474937f, -0.05547982f, -0.01741035f, 0.06236406f, 0.20185155f, 0.05284354f, 0.14133359f, 0.13140637f, 
    -0.17468666f, 0.14149815f, 0.09803769f, -0.18100762f, -0.42454407f, -0.03848128f, -0.10819893f, -0.13681169f, 
    -0.01303369f, 0.00360246f, 0.05641828f, -0.03998971f, -0.02754094f, 0.05393331f, 0.04311249f, 0.01147095f, 
    -0.01056153f, 0.03796173f, -0.13229208f, -0.10521634f, 0.04661024f, -0.12971146f, -0.26738653f, -0.07222411f, 
    -0.04889203f, 0.11702183f, 0.07748171f, 0.02194931f, -0.01853757f, 0.18818979f, 0.05632926f, 0.09142032f, 
    0.01817835f, 0.12658128f, 0.04831997f, -0.06190912f, 0.04973893f, -0.04289369f, -0.01692720f, 0.04595266f, 
    -0.31626663f, -0.34558845f, -0.33060950f, -0.24502295f, -0.10229155f, 0.01147204f, 0.07859871f, 0.00963472f, 
    -0.09362599f, -0.10307351f, 0.08146618f, 0.05149426f, 0.02068514f, 0.16474138f, 0.08097818f, -0.09585074f, 
    0.08216332f, -0.06625528f, 0.04342423f, 0.02106461f, -0.40627727f, 0.13559312f, -0.01785610f, 0.23077075f, 
    0.09514831f, -0.09615827f, -0.17495786f, -0.22798797f, -0.19629589f, -0.05853814f, -0.09882955f, -0.17984056f, 
    -0.15118563f, 0.10265752f, -0.01303371f, 0.01855242f, 0.07293940f, 0.19394962f, 0.12319522f, 0.10864698f, 
    0.10841840f, 0.02588823f, -0.06247047f, -0.23873022f, -0.00396363f, 0.07635423f, -0.05424301f, 0.15074126f, 
    -0.07867525f, -0.00638540f, -0.01694823f, 0.04783511f, 0.03704591f, -0.08137448f, 0.03257865f, -0.01925365f, 
    -0.11598714f, -0.08560029f, 0.11796311f, 0.00072441f, -0.00335399f, 0.08865705f, 0.02446414f, -0.17015515f, 
    0.17825569f, 0.09330954f, -0.07860748f, 0.13340853f, -0.15532276f, -0.00207910f, -0.00922557f, 0.01099334f, 
    0.08676688f, 0.07719166f, -0.00365147f, -0.09632694f, -0.04467647f, 0.13208002f, 0.05887609f, 0.04481202f, 
    0.27042523f, -0.09108242f, -0.02810115f, -0.04847202f, -0.05826529f, -0.22348753f, -0.14574406f, -0.05670732f, 
    0.09896974f, -0.09967536f, 0.07706357f, -0.10614403f, 0.14352821f, 0.02954397f, 0.14268735f, -0.00082312f, 
    0.22657718f, 0.11020548f, 0.07670303f, 0.08590141f, -0.25268194f, 0.22720842f, -0.09610012f, -0.16996299f, 
    0.17693530f, -0.19219470f, -0.02844040f, -0.22908731f, 0.05162499f, -0.07678934f, 0.09016828f, -0.01437058f, 
    0.19742829f, -0.02688863f, -0.03076913f, 0.03563321f, 0.08481805f, 0.01034160f, 0.21699245f, -0.01160359f, 
    0.12051165f, -0.10020085f, -0.00926488f, -0.27325580f, -0.01566338f, -0.07723670f, -0.07777506f, 0.05242927f, 
    0.12565310f, 0.01277896f, 0.12160807f, 0.00539670f, 0.16092265f, -0.06608568f, 0.04842705f, 0.06268595f, 
    0.06110899f, -0.05277841f, 0.09111854f, 0.15243019f, 0.07773004f, -0.07495383f, -0.17013128f, -0.20592940f, 
    -0.04857537f, 0.02402594f, 0.04780567f, 0.00472089f, 0.16021013f, -0.06161617f, 0.05836299f, -0.04501839f, 
    0.00908315f, 0.07368325f, 0.08988718f, -0.05194782f, 0.12010184f, -0.01551563f, 0.10165721f, 0.13807996f, 
    0.17360251f, 0.05515106f, -0.00897375f, -0.18449923f, -0.22024605f, 0.06556422f, 0.07360222f, -0.08560072f, 
    0.15638621f, -0.08774710f, -0.00414051f, -0.09989165f, 0.02653706f, -0.00212537f, 0.02098556f, 0.00215837f, 
    0.02289839f, -0.00953325f, 0.02721357f, 0.19038935f, 0.09041487f, 0.01295838f, 0.01509748f, -0.21113208f, 
    -0.12804350f, 0.08336773f, 0.11701815f, 0.06624493f, 0.05676460f, 0.00652019f, 0.02462301f, -0.02560161f, 
    0.00125148f, 0.00433849f, -0.02046482f, 0.01790522f, 0.04785971f, -0.05450734f, 0.03932292f, 0.03032827f, 
    0.07864914f, 0.23461871f, 0.17252892f, -0.09618525f, -0.02101684f, 0.07912657f, -0.00181171f, 0.05244894f, 
    0.02525701f, -0.01006514f, 0.09364206f, 0.03871946f, -0.04113899f, -0.05526690f, 0.08032383f, 0.03357996f, 
    -0.11316760f, 0.02356598f, -0.08729646f, -0.04639836f, 0.04750295f, -0.45095739f, -0.30292466f, -0.18359658f, 
    -0.05906089f, -0.10486845f, -0.00105074f, 0.00683387f, 0.02207529f, -0.17855772f, 0.10478954f, 0.02472201f, 
    -0.04498797f, 0.02636365f, 0.14842770f, -0.01266631f, -0.02423175f, -0.01570044f, 0.06300475f, -0.09004891f, 
    -0.00696699f, 0.08442801f, -0.13709664f, -0.03306317f, -0.05163698f, 0.03539325f, 0.11071575f, 0.12871978f, 
    -0.03042897f, 0.23614945f, 0.02425975f, 0.06760401f, -0.01894486f, -0.05334539f, -0.00615723f, 0.08002168f, 
    0.03258111f, 0.04075069f, 0.01399936f, -0.03192482f, -0.03339179f, 0.05882908f, -0.26499012f, -0.13758387f, 
    -0.30490318f, -0.06739445f, -0.12455733f, -0.11693935f, -0.00111895f, 0.04340413f, 0.05738172f, -0.00198056f, 
    -0.09062955f, 0.21644926f, 0.08472923f, 0.13965733f, 0.13761303f, -0.07276877f, -0.01787987f, 0.22524714f, 
    -0.03675430f, 0.03036792f, 0.00216409f, 0.01983985f, -0.03144053f, 0.02539041f, 0.02735164f, -0.02980553f, 
    -0.03736686f, -0.00749867f, -0.02847418f, 0.01742577f, 0.00660232f, -0.03341808f, -0.01120789f, -0.04476113f, 
    -0.03331506f, 0.02297783f, -0.03760419f, -0.04349387f, 0.01573612f, -0.03460728f, 0.00322077f, -0.01339610f, 
    0.02506874f, -0.03164880f, -0.00194199f, -0.03614149f, -0.03576342f, -0.04229458f, -0.02995437f, 0.02758728f, 
    -0.01738250f, -0.03765466f, -0.00086346f, 0.03276609f, 0.00697718f, 0.02314522f, -0.03386274f, 0.00431987f, 
    -0.03798528f, 0.00225061f, 0.02212883f, -0.01245778f, -0.02569659f, 0.00410056f, 0.00644100f, 0.01548724f, 
    -0.03090614f, -0.03087664f, -0.04380884f, 0.00661667f, -0.02958399f, 0.00162257f, 0.00881825f, -0.01845445f, 
    0.01165565f, -0.02904527f, -0.00092086f, -0.04144450f, -0.01998272f, 0.00922407f, 0.00736069f, 0.01519852f, 
    0.02060379f, 0.02332623f, 0.01135491f, 0.01848948f, -0.00325619f, -0.04194538f, 0.00615016f, 0.03379969f, 
    -0.03859016f, 0.00940446f, 0.00154662f, -0.01400338f, 0.02330321f, -0.00523513f, -0.02200862f, -0.00850240f, 
    0.00701834f, -0.04292195f, -0.02659274f, 0.01413341f, -0.00713223f, -0.02285184f, 0.00755548f, -0.01688449f, 
    -0.01944513f, 0.02039924f, 0.02416255f, -0.02714272f, -0.04115728f, -0.01870906f, -0.03316494f, -0.04500077f, 
    0.00540758f, -0.04489908f, -0.02535136f, 0.02374832f, 0.00092820f, -0.01069434f, -0.01880657f, 0.00537865f, 
    -0.02621027f, -0.01039997f, 0.00667296f, -0.01712541f, 0.00803132f, 0.00834057f, -0.01214651f, -0.02708200f, 
    0.00543403f, -0.03487882f, 0.00221485f, 0.02259469f, -0.01679993f, -0.03056298f, 0.03276490f, -0.01036193f, 
    -0.03001118f, 0.02808904f, 0.01195130f, -0.01467291f, -0.02441591f, -0.04254366f, -0.04073457f, 0.02669107f, 
    -0.01764687f, 0.00448750f, -0.01465779f, -0.01040380f, 0.02954974f, 0.02658570f, -0.00152876f, 0.00458807f, 
    -0.03410070f, 0.01143253f, -0.02702951f, -0.00632242f, 0.01793936f, -0.02453988f, -0.02878447f, 0.00807592f, 
    -0.02386131f, 0.01275331f, 0.01656585f, 0.01831243f, 0.01632914f, 0.01086692f, -0.03065464f, 0.02640587f, 
    -0.00867066f, 0.02316895f, -0.01272814f, 0.00088512f, -0.02799069f, 0.03137551f, 0.00125731f, -0.00684836f, 
    -0.00424223f, -0.03335764f, -0.02736166f, -0.03514624f, -0.02970023f, -0.04108430f, -0.00546074f, -0.00694276f, 
    0.02590123f, -0.01020398f, -0.00420802f, -0.02659205f, 0.00905515f, -0.04441654f, -0.01896121f, 0.02376352f, 
    -0.01964424f, 0.01731187f, -0.00506505f, -0.03842755f, -0.03533605f, -0.03625689f, 0.00240272f, -0.04537712f, 
    -0.00478820f, 0.01361335f, 0.00404694f, 0.02044968f, -0.02954634f, 0.02626808f, 0.03070452f, -0.03331687f, 
    -0.01465155f, -0.00092027f, 0.00392514f, -0.01389468f, 0.01513062f, -0.00897595f, -0.03132989f, -0.04532317f, 
    0.01505377f, -0.04374484f, 0.00436748f, -0.04291119f, -0.04492545f, -0.03551708f, -0.02321387f, 0.00472352f, 
    -0.02231224f, 0.00212609f, -0.03712486f, -0.03258252f, 0.00151228f, 0.02629097f, -0.00514062f, 0.00541403f, 
    0.02065923f, 0.03269010f, 0.03106100f, -0.00029899f, -0.01593257f, -0.01006983f, -0.03285184f, -0.00300781f, 
    -0.02455977f, -0.03367528f, 0.03295144f, -0.03986691f, -0.02566040f, -0.00409929f, 0.00587588f, -0.04470223f, 
    -0.02098117f, 0.01204501f, 0.00621798f, 0.02341792f, -0.01966935f, 0.02347003f, 0.01368537f, 0.00101962f, 
    -0.04450788f, 0.01325637f, 0.02318003f, -0.02890059f, 0.03297377f, 0.01383773f, -0.01282189f, 0.02912142f, 
    0.00711452f, -0.03529875f, 0.01763679f, -0.01230369f, -0.00480392f, -0.02905530f, -0.00289217f, -0.03795789f, 
    -0.01417170f, -0.03266170f, -0.03287571f, -0.02094365f, -0.00341513f, -0.03979969f, 0.01845261f, -0.03216909f, 
    -0.03119408f, 0.00020927f, 0.02254839f, -0.00713170f, -0.03217971f, -0.01613072f, -0.04213607f, 0.00237120f, 
    0.02261690f, -0.02286500f, -0.03244782f, -0.03739471f, -0.01939773f, 0.02014239f, 0.01317627f, 0.00475232f, 
    0.00936176f, 0.00412111f, -0.00130599f, -0.01960683f, -0.03515593f, 0.03009601f, 0.00954472f, -0.03761527f, 
    0.00630749f, 0.00027524f, -0.00171086f, -0.02684117f, 0.00668905f, -0.03637953f, -0.00433212f, 0.02820830f, 
    -0.00030054f, -0.02098581f, 0.02755950f, -0.00554575f, -0.02185665f, -0.00807046f, -0.03431172f, 0.00099674f, 
    -0.02688275f, 0.01278508f, -0.00487802f, 0.01881138f, 0.00923178f, -0.01484813f, -0.02273219f, -0.00467960f, 
    -0.02633254f, 0.02797903f, 0.03118748f, 0.00587273f, 0.00463936f, 0.00968204f, 0.02260089f, 0.00967397f, 
    -0.02050700f, -0.00160356f, 0.02903870f, -0.03601661f, 0.01652268f, -0.00462654f, -0.04382941f, -0.03997721f, 
    0.00837002f, -0.00002438f, 0.00460821f, -0.01176639f, -0.03067332f, 0.01589189f, 0.00523088f, -0.02402481f, 
    -0.03172394f, -0.02221005f, 0.02726680f, 0.00686018f, 0.01867762f, 0.01959165f, -0.02733593f, -0.01337532f, 
    0.00658582f, 0.02223676f, 0.02620392f, 0.01486809f, 0.00498323f, -0.03178583f, -0.00933080f, -0.00601077f, 
    0.01611434f, 0.01804653f, -0.02527729f, 0.00220775f, -0.02229345f, 0.02884465f, 0.02429950f, -0.01467878f, 
    0.02429594f, -0.00434619f, -0.03253518f, -0.01055959f, -0.01363757f, -0.04440632f, 0.03226405f, 0.02875335f, 
    0.02328689f, 0.03302177f, -0.00055035f, -0.03548112f, -0.03422846f, 0.02204194f, 0.01683528f, -0.02994562f, 
    -0.02407874f, -0.03288376f, 0.02448080f, -0.00559627f, -0.02234163f, -0.01672982f, -0.04257955f, 0.00777378f, 
    0.00132272f, -0.02836918f, -0.03486238f, 0.00540944f, -0.01781943f, 0.02185916f, -0.02192696f, 0.03207557f, 
    -0.03081055f, 0.02339534f, -0.03658389f, 0.01487589f, 0.03019009f, 0.01366478f, -0.00385676f, -0.00153315f, 
    -0.00963582f, 0.00726692f, -0.01873184f, -0.01839134f, -0.02206669f, -0.01539593f, 0.01016741f, -0.03034926f, 
    0.00347687f, -0.03786062f, 0.02436409f, 0.02890567f, 0.00048901f, -0.01367998f, -0.00045769f, -0.00852755f, 
    0.02494144f, -0.03726606f, -0.00444798f, 0.00245122f, 0.01427363f, 0.00279580f, 0.02027554f, -0.02057594f, 
    0.02186448f, -0.01040559f, 0.01801196f, -0.02719644f, 0.03001441f, -0.02786333f, 0.02185532f, 0.03108556f, 
    -0.01588660f, 0.02298276f, 0.01939811f, -0.03840732f, -0.00071263f, 0.02991832f, -0.02766002f, -0.02687218f, 
    -0.00811613f, -0.04244749f, -0.00887138f, 0.01902188f, -0.02383045f, -0.02228992f, -0.02227710f, -0.01908630f, 
    0.02410325f, 0.03329590f, -0.04498106f, 0.01449635f, 0.00088254f, 0.02407631f, 0.02768456f, 0.03005452f, 
    0.00592507f, -0.02323399f, -0.03598307f, -0.04264739f, -0.03555129f, 0.02190944f, -0.00409539f, -0.01626568f, 
    -0.01731517f, -0.04541343f, 0.00192887f, -0.01827965f, 0.01962152f, 0.01045035f, -0.00517890f, -0.04176979f, 
    -0.00115447f, -0.04338864f, -0.02749564f, -0.01596811f, -0.01208980f, 0.02520893f, -0.00680920f, -0.01422402f, 
    -0.04256903f, -0.01407591f, -0.00508488f, -0.04291941f, -0.04468803f, 0.03196764f, 0.01582699f, -0.03575297f, 
    -0.01322581f, -0.02474299f, 0.03035885f, -0.01116614f, -0.02995608f, 0.01190763f, 0.00603206f, -0.01645453f, 
    0.00658006f, -0.01360236f, -0.02212020f, 0.01585617f, -0.02936987f, -0.02550084f, -0.04074727f, -0.00280239f, 
    -0.04471372f, -0.01547197f, -0.03642020f, -0.03040720f, -0.03076670f, 0.02223022f, -0.00730282f, 0.00591600f, 
    -0.03095591f, -0.00345066f, -0.02451125f, 0.01559642f, -0.04409172f, 0.02602804f, -0.02949343f, -0.03011221f, 
    -0.00875211f, -0.00143164f, 0.02305805f, 0.03236759f, 0.01226335f, 0.03264931f, 0.00039100f, -0.04222178f, 
    -0.01416017f, -0.00221724f, -0.02806888f, -0.01504122f, -0.04015885f, -0.02817005f, -0.03768628f, 0.00402101f, 
    -0.01510682f, 0.01587056f, -0.02009865f, -0.02310164f, -0.03344158f, -0.03305220f, -0.02754074f, -0.00620927f, 
    -0.01890885f, -0.02998057f, -0.03912779f, -0.03433742f, -0.00609714f, 0.02582863f, 0.02137132f, 0.02230341f, 
    -0.02775569f, 0.02504919f, -0.00043174f, -0.03552434f, -0.00660421f, -0.00047549f, 0.00540476f, -0.00464214f, 
    -0.02572928f, -0.02657830f, 0.00596652f, -0.01492951f, -0.03885463f, 0.00559362f, 0.02514241f, 0.01554343f, 
    -0.00818252f, 0.02402637f, -0.00279731f, 0.00078535f, -0.03041213f, 0.00775058f, -0.04506601f, 0.01311724f, 
    -0.03779655f, -0.01998610f, 0.00644918f, -0.03737899f, -0.04049738f, 0.01202881f, -0.00522261f, -0.00856844f, 
    0.02462127f, -0.03891714f, 0.01402050f, 0.01846541f, 0.02292472f, -0.02076673f, 0.01198343f, 0.01854421f, 
    -0.02220614f, -0.00708014f, 0.03148666f, -0.02342470f, -0.03079635f, -0.04007803f, -0.04448267f, -0.03829087f, 
    -0.00536247f, -0.03035354f, 0.01553869f, -0.03562284f, -0.02229905f, 0.01630728f, -0.00067163f, -0.02515583f, 
    -0.02226512f, -0.00938657f, 0.01809068f, 0.01369559f, -0.00015249f, 0.02462346f, -0.02706755f, 0.01543759f, 
    -0.00958400f, -0.01598108f, -0.04211836f, 0.03214370f, 0.02762766f, -0.03242227f, -0.03664581f, 0.00098612f, 
    0.01464013f, -0.02348124f, 0.01051356f, 0.02101520f, -0.04421769f, -0.03437926f, 0.02542411f, -0.01802853f, 
    -0.00318527f, 0.01784550f, -0.00224247f, 0.01107344f, 0.01430333f, 0.00095637f, 0.00818514f, -0.00903154f, 
    -0.01062364f, -0.02873618f, -0.01690874f, 0.01166791f, 0.02058426f, -0.01900828f, 0.01785756f, 0.02089501f, 
    0.00374858f, -0.03022453f, -0.00759697f, 0.01508543f, -0.02714849f, 0.01918821f, -0.02018537f, 0.01206830f, 
    0.01830412f, 0.01531380f, 0.02696874f, -0.02237279f, 0.00603512f, -0.01254560f, 0.00385144f, -0.00843516f, 
    -0.00889606f, -0.02639250f, 0.01416952f, 0.01519720f, -0.03133168f, 0.02789737f, 0.01467440f, 0.00132986f, 
    0.00141704f, -0.02829279f, -0.00315366f, -0.02122769f, 0.01247125f, -0.01594351f, -0.03179967f, 0.00530560f, 
    -0.04571706f, -0.02009304f, -0.02354266f, 0.01868685f, -0.00852555f, -0.01012899f, 0.01137324f, 0.02699723f, 
    0.02329608f, -0.03590616f, -0.00790667f, -0.04290681f, -0.02548828f, -0.00817955f, -0.02591483f, -0.02664411f, 
    -0.01794432f, 0.03018882f, -0.04664369f, -0.04248426f, 0.01379614f, -0.04374911f, -0.03223682f, 0.02418086f, 
    -0.02721385f, 0.02520832f, -0.00040832f, 0.03420021f, -0.03471423f, -0.04083487f, 0.00464856f, -0.03906949f, 
    -0.02454927f, -0.03881213f, -0.03541575f, -0.02436263f, 0.03010031f, 0.01865899f, 0.03758958f, -0.03985394f, 
    -0.01183408f, 0.00854265f, 0.00066475f, -0.01350309f, 0.01595957f, -0.02919875f, -0.01239526f, -0.03929654f, 
    -0.01359642f, 0.03037879f, 0.00281401f, 0.00598641f, 0.02872602f, 0.01200559f, -0.02916216f, 0.01982198f, 
    -0.03129930f, 0.01765870f, -0.02000279f, -0.04295425f, 0.00394628f, 0.01086792f, -0.02046419f, -0.03545592f, 
    -0.02793834f, 0.02293783f, -0.04077621f, -0.03935722f, -0.00677439f, -0.02561204f, 0.00809967f, 0.01458154f, 
    -0.01298820f, -0.04506574f, -0.04028206f, -0.01286608f, -0.03099675f, -0.02278198f, -0.03558596f, 0.00301167f, 
    -0.02452553f, 0.01676819f, 0.02238892f, -0.01118234f, 0.01668421f, -0.04579353f, 0.01699748f, 0.02737326f, 
    -0.03495092f, -0.04127788f, -0.04196863f, -0.00703500f, -0.00937152f, -0.03821669f, -0.02366522f, 0.02455781f, 
    -0.04288130f, 0.01593891f, -0.00062238f, 0.00363310f, 0.02651882f, -0.04007606f, -0.04585796f, 0.00588856f, 
    -0.02737311f, -0.00701227f, 0.02274600f, -0.03645949f, 0.00550112f, 0.01460320f, -0.04480322f, -0.02380009f, 
    -0.03517896f, -0.02500024f, -0.04042061f, 0.02015133f, 0.02392489f, -0.02225726f, -0.02684473f, -0.02171579f, 
    -0.02640250f, -0.04276055f, 0.02489774f, -0.04091716f, -0.01334368f, -0.02061417f, -0.02945162f, 0.02901281f, 
    -0.03325081f, -0.04658585f, -0.00544052f, 0.02382204f, -0.01011733f, -0.00462600f, 0.02697261f, 0.01415110f, 
    -0.03361326f, -0.00304591f, 0.02259741f, 0.02480369f, -0.00839448f, -0.03432281f, 0.02555609f, -0.01272091f, 
    0.00385865f, -0.00947868f, -0.00028782f, -0.03355686f, 0.01953554f, 0.01235839f, 0.01228758f, 0.03181324f, 
    -0.00468404f, -0.02471933f, -0.02052472f, -0.04576297f, -0.01642697f, -0.01051638f, -0.03336217f, -0.02885869f, 
    -0.00119609f, -0.01093844f, -0.04032285f, -0.02193958f, 0.00069341f, 0.01932627f, -0.00732720f, 0.02866497f, 
    -0.02976131f, -0.04129974f, 0.01067778f, 0.01594438f, -0.00425551f, 0.00127883f, 0.02554601f, 0.01452618f, 
    -0.01980497f, -0.03109616f, 0.02230802f, 0.01662996f, 0.03069261f, 0.02907187f, -0.03102967f, -0.00733998f, 
    -0.03701438f, -0.03195730f, 0.00550460f, -0.03168880f, 0.02856925f, -0.03913748f, -0.03914677f, 0.01891885f, 
    -0.00652913f, -0.01894196f, 0.01326705f, 0.02301861f, 0.00930091f, -0.01965199f, -0.03298549f, -0.01863472f, 
    0.01752032f, -0.02639678f, -0.01173476f, 0.02770545f, -0.01432819f, 0.01565767f, -0.01775121f, -0.03769444f, 
    0.03104148f, -0.00397504f, -0.02696447f, 0.00107717f, -0.00413216f, -0.03988602f, 0.02916803f, -0.00717774f, 
    0.01223730f, 0.01833254f, 0.02325263f, 0.02458774f, 0.01269875f, 0.02117636f, -0.01410384f, 0.02622887f, 
    -0.00622186f, -0.04026048f, 0.00300256f, -0.01951005f, -0.02748743f, -0.00869879f, -0.01458378f, 0.01154585f, 
    -0.03987357f, 0.00920751f, -0.03549589f, -0.03507238f, 0.02838140f, -0.04004157f, 0.01057844f, -0.04273892f, 
    -0.02972500f, -0.01357452f, -0.03847063f, 0.00534426f, -0.02155846f, 0.00853737f, 0.02952188f, 0.01558365f, 
    -0.03614239f, 0.02028432f, -0.01715169f, 0.01955427f, -0.01211005f, 0.00707983f, -0.02727462f, -0.00583167f, 
    -0.00219829f, -0.03833783f, -0.02338488f, 0.00029317f, 0.02270828f, -0.03864849f, -0.00922040f, 0.00283271f, 
    -0.03843808f, 0.03022344f, -0.00648542f, -0.01286829f, 0.00614983f, -0.04325536f, -0.01203853f, -0.01381724f, 
    0.00572134f, 0.02991287f, -0.02738396f, 0.00272160f, -0.00911682f, 0.01155651f, -0.02277859f, -0.00467265f, 
    0.00772992f, -0.04166718f, 0.02762782f, 0.01960457f, 0.03022060f, 0.02902545f, 0.00186942f, -0.04154079f, 
    -0.01155919f, -0.01272739f, -0.04007807f, -0.03198466f, -0.00384939f, 0.03270776f, -0.00404625f, 0.02890348f, 
    0.02680820f, 0.03062081f, -0.01051914f, -0.02956026f, -0.04656863f, 0.03089909f, -0.01764282f, -0.00353481f, 
    0.01648703f, 0.02867325f, -0.03705727f, 0.02250463f, -0.01155601f, -0.03818715f, -0.01199716f, -0.00322209f, 
    -0.01827662f, -0.00805311f, -0.04008238f, 0.02901239f, 0.00641699f, -0.04174542f, -0.04145331f, -0.03352049f, 
    -0.03409835f, 0.03422865f, -0.02330660f, 0.02975280f, -0.02042192f, -0.01449473f, -0.02144788f, -0.04319001f, 
    -0.00953540f, 0.02695504f, -0.02102870f, -0.00827944f, -0.00350860f, -0.03942265f, -0.00579589f, -0.04422433f, 
    -0.03337027f, -0.02742951f, 0.00033783f, 0.02074011f, 0.00766954f, -0.00521725f, -0.03766209f, -0.03640561f, 
    -0.02446935f, -0.02274352f, -0.01879858f, -0.03581428f, 0.02884129f, -0.03846880f, -0.03063117f, -0.02506393f, 
    -0.00050733f, -0.03485183f, -0.01911737f, -0.00721315f, -0.01691014f, -0.01876188f, 0.00812088f, -0.02472477f, 
    -0.01695298f, -0.02796693f, 0.02746682f, 0.02910306f, 0.00469519f, 0.02476911f, -0.00709897f, 0.00065402f, 
    -0.02241074f, -0.04441258f, -0.04312702f, 0.01641187f, -0.01390679f, -0.03044433f, 0.02500525f, -0.04132622f, 
    -0.03177172f, 0.03517846f, -0.03302407f, 0.00154975f, -0.02562800f, -0.03442137f, 0.02419644f, 0.00557962f, 
    0.00927774f, -0.01963217f, 0.00377279f, 0.01784776f, 0.02100326f, 0.02275004f, -0.00883692f, -0.03343667f, 
    -0.04339533f, 0.01516386f, -0.00128773f, 0.02074182f, 0.02648628f, -0.00058414f, -0.02661643f, -0.03824381f, 
    0.00817680f, -0.03332191f, 0.00579984f, -0.01869195f, -0.02651316f, -0.00396893f, 0.02596751f, 0.02421959f, 
    0.02657304f, 0.02173834f, -0.02526228f, -0.03347389f, 0.01049092f, 0.01355931f, -0.00367973f, 0.01768530f, 
    0.02575908f, -0.03088208f, -0.02338979f, -0.01391307f, 0.02414132f, 0.01018290f, -0.03992161f, 0.00999354f, 
    0.00631298f, -0.02427446f, -0.03433450f, 0.01187342f, 0.02228773f, -0.00367925f, -0.01760209f, -0.01268708f, 
    -0.02909949f, 0.02040744f, 0.01807164f, -0.01736844f, 0.02178679f, -0.01805012f, -0.04765638f, -0.03561771f, 
    -0.01418917f, -0.02633801f, 0.01225345f, -0.02190768f, 0.02941486f, -0.03412426f, 0.03085382f, 0.00454172f, 
    -0.00335193f, -0.04222731f, 0.00350100f, 0.02867959f, 0.00191038f, -0.00701343f, -0.00703179f, 0.00471444f, 
    0.00596106f, -0.01047874f, -0.01641808f, -0.01253263f, -0.03028734f, -0.00162060f, -0.00681283f, -0.00988941f, 
    0.00062048f, -0.02081132f, -0.04633503f, -0.04074789f, 0.00972600f, 0.02465311f, -0.00169418f, -0.02767178f, 
    -0.04313149f, 0.02193404f, -0.00547858f, -0.00151685f, -0.04241604f, 0.00673146f, -0.04233808f, -0.00534845f, 
    -0.02135681f, -0.03229317f, 0.00513700f, -0.00367378f, 0.00532416f, -0.01739982f, 0.02343849f, 0.00160093f, 
    -0.03917230f, 0.02822508f, 0.01393463f, -0.01797691f, -0.03340615f, 0.00236256f, 0.00984726f, -0.02509360f, 
    -0.03238643f, -0.04609001f, 0.02715295f, -0.03308231f, -0.03166706f, -0.03031595f, -0.04525654f, -0.01417488f, 
    0.04049848f, -0.03771544f, -0.03589651f, -0.01619929f, 0.00170956f, 0.02293823f, 0.02704194f, -0.02877691f, 
    0.00337824f, 0.01008552f, 0.01588426f, -0.04548209f, 0.00885470f, 0.01349675f, 0.00579670f, -0.02540068f, 
    -0.00901560f, 0.00015977f, 0.00581039f, 0.00673926f, 0.01694711f, -0.01372393f, -0.01692031f, 0.02940803f, 
    -0.00102914f, 0.00553988f, 0.00133685f, -0.04187039f, 0.02243198f, 0.02638556f, 0.01160999f, -0.01614537f, 
    0.01280000f, 0.01293352f, -0.02786927f, 0.00677067f, -0.00086332f, -0.01680306f, 0.01154607f, 0.00985942f, 
    0.01444181f, -0.03539175f, -0.01962635f, 0.02701367f, 0.03151419f, -0.03448836f, -0.00685997f, -0.04367369f, 
    0.02457781f, -0.03440571f, -0.00191833f, 0.00992275f, -0.02084500f, 0.00847775f, 0.03051096f, -0.02533821f, 
    -0.01035441f, 0.00108838f, -0.03025479f, 0.01327116f, 0.00046206f, 0.00033324f, -0.00449274f, -0.02908788f, 
    -0.03468500f, 0.00473140f, -0.00658595f, -0.03736456f, -0.01393974f, -0.01201238f, 0.02813341f, 0.00701150f, 
    0.01019061f, -0.02866937f, 0.00190245f, 0.03016645f, -0.00934648f, -0.01435038f, 0.00551445f, -0.02838467f, 
    0.03040068f, 0.02195428f, 0.00602985f, 0.01465632f, 0.00003991f, -0.04122112f, -0.00710564f, 0.01906243f, 
    0.02680545f, -0.03062189f, 0.02337823f, -0.00781713f, 0.00220141f, 0.00610006f, -0.00288713f, 0.01409620f, 
    -0.28273287f, -0.17073469f, -0.23108900f, 0.20943698f, -0.03130509f, -0.03019478f, -0.07489183f, 0.20998998f, 
    -0.14584172f, 0.00013586f, -0.03492402f, -0.11426011f, -0.04831798f, -0.00534163f, 0.12227714f, 0.08805346f, 
    -0.06565347f, 0.29380217f, 0.01523324f, -0.03300503f, -0.11007813f, -0.10523787f, -0.17577742f, 0.01210235f, 
    0.04898882f, 0.03801963f, 0.13080843f, 0.25576681f, -0.05022416f, -0.00198061f, -0.01734829f, -0.05111866f, 
    0.20170262f, -0.01735137f, -0.02976764f, 0.16274755f, 0.05541305f, -0.00579317f, 0.04508467f, -0.03930385f, 
    -0.31283388f, 0.34589639f, 0.27852952f, 0.09548929f, 0.03754178f, 0.04115236f, 0.03424768f, -0.00309713f, 
    -0.08185234f, -0.01880708f, -0.12197704f, 0.03955790f, 0.17600593f, 0.04226917f, 0.02592460f, 0.11298510f, 
    0.07718768f, 0.05917947f, -0.13401887f, -0.06188987f, 0.07397994f, -0.02045049f, -0.17446476f, -0.02496240f, 
    0.01308905f, 0.00011786f, -0.05989191f, -0.04490585f, 0.12198693f, 0.11213928f, -0.04439657f, -0.07830806f, 
    0.10050169f, 0.05792881f, 0.00806217f, 0.03228021f, 0.10748970f, 0.14119354f, 0.07966457f, 0.17304733f, 
    -0.16628531f, 0.07367530f, -0.25465080f, -0.22421183f, 0.25017056f, -0.01332396f, 0.15703171f, -0.37605914f, 
    -0.00643759f, 0.24683535f, 0.07771867f, 0.04139317f, -0.16783448f, -0.20318380f, 0.19902043f, 0.03984701f, 
    0.00978517f, -0.26064464f, 0.23105262f, -0.03629806f, 0.10628171f, 0.05277449f, 0.01831224f, 0.08378143f, 
    0.11181612f, -0.09003205f, 0.03234723f, 0.05207356f, 0.08296082f, -0.13001797f, -0.00082114f, 0.10489199f, 
    0.13995481f, 0.15139753f, 0.06297675f, 0.10223773f, 0.14142476f, 0.16397475f, -0.09643732f, -0.00746195f, 
    0.19245127f, 0.34225240f, -0.11705305f, 0.08552718f, -0.03172845f, 0.16532034f, 0.18159598f, -0.01616505f, 
    -0.18900180f, 0.02123609f, 0.04180721f, 0.07685434f, 0.02166751f, 0.12046658f, 0.05630916f, 0.15164040f, 
    0.02854791f, -0.19598135f, 0.08521393f, -0.13479771f, 0.13192824f, -0.17858934f, -0.29086417f, -0.27994552f, 
    0.02986301f, 0.10526053f, -0.05839009f, -0.06631303f, -0.02597551f, 0.10988215f, 0.05534243f, -0.04691692f, 
    -0.07243498f, -0.16025761f, -0.10845045f, -0.17454000f, -0.00135013f, 0.12085582f, 0.11816235f, -0.08928198f, 
    0.12853767f, 0.13013612f, 0.20097569f, -0.50165349f, 0.06818742f, 0.04557429f, -0.09575643f, 0.10341375f, 
    -0.01718075f, -0.07417209f, 0.04066516f, 0.16482027f, 0.03368586f, 0.33255917f, 0.08917801f, -0.01134019f, 
    -0.04118473f, -0.14115740f, -0.18398215f, -0.16184480f, 0.33315897f, 0.31743383f, -0.00348047f, 0.18257797f, 
    0.07679538f, 0.03474099f, -0.09412356f, 0.08698398f, 0.10600885f, -0.04093045f, -0.18195310f, -0.11516811f, 
    0.13571528f, 0.05403853f, 0.07997068f, 0.06570557f, 0.03138636f, 0.08954567f, 0.03329967f, 0.20633826f, 
    0.10520549f, -0.03030984f, -0.05801294f, -0.22615984f, 0.17278971f, -0.02312195f, -0.00617117f, 0.05317493f, 
    -0.07474252f, 0.04714957f, 0.02484867f, -0.05024026f, -0.05864808f, -0.01583361f, -0.04678118f, -0.14502436f, 
    -0.07343768f, 0.08195988f, 0.15380946f, 0.01221395f, 0.06819132f, 0.19058141f, -0.23097649f, -0.21298920f, 
    0.03772628f, 0.24597394f, 0.02612728f, -0.09198713f, 0.20988098f, 0.07117310f, -0.05577572f, -0.11255558f, 
    0.05147242f, 0.24340054f, 0.10402855f, 0.01356672f, 0.06486602f, 0.29450637f, 0.08390459f, 0.11959178f, 
    0.07297060f, -0.06708202f, -0.17284150f, -0.02605147f, 0.11973532f, 0.02681820f, -0.03010042f, 0.03447632f, 
    0.03765529f, 0.09184092f, -0.03439277f, -0.05219817f, 0.02888947f, -0.04454703f, -0.04360262f, -0.09678953f, 
    -0.02706215f, 0.13287589f, 0.12781875f, -0.02282549f, 0.04228101f, -0.17802879f, 0.44927001f, -0.27355930f, 
    0.08575010f, -0.17131479f, 0.07204857f, 0.15639493f, -0.08062582f, 0.11725693f, 0.00694986f, -0.02844286f, 
    0.09199020f, -0.03026249f, 0.06171414f, 0.01762161f, 0.11071987f, 0.09096456f, -0.05446992f, 0.04469352f, 
    -0.29256165f, 0.56452954f, -0.25701421f, -0.03525869f, -0.13997574f, 0.21888466f, 0.01653050f, 0.15586042f, 
    -0.11637525f, -0.07600618f, 0.04601858f, -0.05132413f, -0.02140632f, -0.12633552f, -0.04064202f, 0.12567408f, 
    0.00483939f, -0.12179863f, 0.04213595f, 0.00776078f, -0.11425210f, 0.07047831f, 0.10997937f, 0.07540824f, 
    0.00133692f, 0.02903832f, 0.09665105f, 0.08913802f, -0.11820731f, 0.01459049f, -0.07418490f, -0.00392425f, 
    -0.15008050f, 0.05098139f, 0.05118493f, 0.03570141f, 0.04872138f, 0.12391584f, -0.13822128f, -0.02034813f, 
    0.03505172f, -0.30604073f, -0.14832179f, -0.13135122f, 0.25597396f, -0.10213536f, -0.04253483f, 0.06679293f, 
    0.04067248f, 0.09301341f, 0.02349688f, -0.07436033f, -0.07572944f, -0.04384365f, 0.01899790f, -0.15849084f, 
    -0.02920216f, -0.04359644f, 0.12244205f, -0.02056273f, -0.28434917f, 0.47666427f, -0.05268356f, -0.02471705f, 
    0.03658978f, 0.06888156f, -0.12677203f, -0.06245358f, -0.01859126f, 0.08086874f, -0.16401459f, 0.16148478f, 
    0.03094140f, -0.08002387f, 0.15936062f, 0.11966984f, -0.17985699f, -0.01146772f, 0.02399648f, 0.00801210f, 
    -0.28666094f, 0.12340214f, 0.04620355f, -0.03807510f, 0.00024588f, 0.19402932f, -0.00765289f, -0.14657684f, 
    -0.29100981f, -0.06910361f, -0.13867524f, 0.03134306f, 0.06387512f, 0.04367822f, 0.07412297f, 0.07352261f, 
    -0.15346417f, -0.19111484f, -0.05651296f, -0.04640952f, 0.24788867f, 0.11409489f, 0.04437001f, -0.35511544f, 
    -0.08482824f, -0.15470424f, -0.06492301f, 0.01888039f, -0.09881649f, -0.07253690f, 0.05943894f, -0.00999541f, 
    -0.00126918f, 0.03398781f, -0.17039642f, -0.05571425f, -0.06824092f, -0.23264544f, -0.07323027f, -0.07313129f, 
    0.43621445f, 0.13478503f, -0.06166027f, 0.03381834f, 0.14754121f, -0.01733299f, -0.09891770f, 0.02742875f, 
    0.15647349f, -0.10176951f, -0.14862929f, -0.03751374f, 0.14644857f, 0.15107559f, 0.06634601f, -0.00418571f, 
    -0.04896583f, 0.14282018f, 0.10818110f, 0.13330303f, 0.13233313f, 0.28101087f, -0.11242630f, -0.22538503f, 
    -0.06529670f, -0.01816522f, 0.09853236f, -0.15654701f, -0.02393962f, -0.12127251f, 0.25533402f, 0.06631462f, 
    0.20055462f, -0.08381771f, -0.09209300f, -0.03513100f, 0.25286424f, -0.01725440f, -0.03184769f, -0.17845821f, 
    -0.44094843f, 0.19642481f, -0.02793846f, -0.08467942f, 0.05081629f, -0.09240799f, 0.19864361f, -0.25250468f, 
    0.01184918f, -0.13916467f, -0.03953296f, 0.00126951f, -0.01681429f, -0.00091489f, -0.01755435f, 0.08340377f, 
    0.07428008f, -0.20940787f, -0.03572140f, -0.12956071f, -0.09797782f, -0.05317876f, 0.51481700f, -0.12752359f, 
    -0.14793919f, -0.25173011f, 0.20644590f, 0.08291034f, -0.19228685f, -0.00778312f, -0.01458990f, -0.02614774f, 
    -0.01681083f, 0.12620671f, 0.09375145f, 0.06234083f, 0.07358417f, 0.13559711f, -0.22991116f, -0.18392140f, 
    -0.24551569f, -0.13042651f, 0.02442686f, -0.06374351f, 0.04976014f, 0.05488443f, 0.08876052f, -0.15822273f, 
    0.11549272f, -0.03620454f, 0.06277397f, -0.00083913f, -0.08257592f, -0.09994032f, -0.13720207f, -0.03397774f, 
    0.02447381f, 0.02601791f, 0.14329109f, -0.09516406f, -0.30966747f, -0.27814949f, -0.00165360f, -0.00920234f, 
    0.01141666f, 0.01735526f, 0.00253464f, 0.01081108f, -0.01614453f, 0.02698334f, 0.01947825f, 0.02693913f, 
    -0.04293057f, -0.10214946f, -0.05634854f, 0.04007900f, -0.04761013f, 0.09329986f, -0.05854029f, -0.15271556f, 
    -0.10270867f, -0.21616873f, -0.35735875f, -0.03398200f, 0.04574041f, 0.11016799f, -0.11340331f, 0.01909262f, 
    0.04763054f, 0.00884180f, 0.01143603f, -0.08234804f, -0.10447012f, -0.05735731f, -0.16215383f, 0.03914465f, 
    -0.00576386f, 0.16668288f, -0.06182277f, -0.01948470f, -0.24573623f, -0.03750247f, -0.15999325f, -0.00164883f, 
    0.02038802f, 0.16473021f, -0.09308998f, -0.06062736f, 0.04357105f, 0.00886550f, -0.01301627f, 0.04019876f, 
    -0.05974635f, 0.01108282f, -0.04167591f, -0.01998941f, -0.00267202f, 0.24306542f, -0.07125832f, -0.11264550f, 
    0.15081383f, -0.01251002f, -0.11213800f, 0.01041198f, 0.03323842f, 0.05431876f, -0.00781258f, -0.03089721f, 
    0.03177604f, 0.09139315f, -0.00761185f, -0.03798071f, 0.03816591f, 0.10204247f, 0.05523200f, 0.05092067f, 
    0.03129366f, 0.20970844f, 0.15746626f, 0.10329760f, -0.26242229f, 0.48233855f, 0.10949862f, -0.13696109f, 
    -0.01574956f, 0.20266478f, 0.14066161f, -0.09340050f, -0.09519558f, -0.02827507f, -0.07167052f, -0.19582374f, 
    0.20983636f, 0.08713234f, 0.06868070f, 0.02010224f, 0.00980534f, -0.28926936f, 0.08956911f, 0.12237224f, 
    0.11957455f, 0.11741388f, -0.05596771f, 0.05172119f, -0.04941300f, 0.14260466f, -0.12315899f, -0.09368839f, 
    0.01291752f, -0.10547648f, -0.13858840f, -0.01527817f, 0.01068766f, 0.06566185f, 0.10973478f, 0.00310205f, 
    0.07685303f, 0.08217755f, 0.04965750f, 0.05639803f, 0.10505454f, 0.11359982f, 0.19602542f, 0.06918349f, 
    0.25034553f, 0.00254746f, -0.01165303f, -0.03097923f, 0.03354041f, -0.06765576f, 0.10784724f, -0.04960271f, 
    -0.10508578f, 0.05717665f, -0.00464398f, -0.09030540f, -0.04282641f, 0.05757779f, -0.00427701f, -0.04612650f, 
    -0.25507540f, 0.10078817f, -0.28876874f, -0.02698233f, 0.08014397f, 0.04125996f, -0.12305249f, -0.05172383f, 
    0.19283475f, -0.07155744f, -0.06820026f, -0.03693692f, 0.00341589f, -0.04711279f, 0.05170874f, 0.05138616f, 
    -0.01590928f, -0.09658791f, -0.03507242f, 0.06337906f, 0.36556539f, 0.03051858f, 0.07840873f, 0.00792428f, 
    0.12456790f, -0.01359369f, 0.04829895f, -0.02012300f, 0.07095628f, 0.00430617f, -0.05926358f, 0.12832609f, 
    -0.04330504f, 0.06670683f, 0.04473786f, 0.06442656f, 0.06886744f, -0.10559197f, -0.18220434f, -0.03916477f, 
    0.17539297f, -0.00549740f, -0.04961959f, 0.36930436f, -0.28554332f, -0.06811967f, 0.14880116f, -0.19421871f, 
    0.03467219f, -0.10165755f, 0.06659202f, -0.16425203f, 0.00793825f, -0.18705299f, -0.02309467f, -0.10481202f, 
    0.01900681f, -0.05771200f, 0.02516305f, 0.06491903f, -0.01152185f, 0.06567974f, 0.04759018f, 0.08763302f, 
    -0.08149388f, 0.01961744f, -0.04886952f, 0.00696560f, -0.00847180f, -0.07486354f, 0.01626666f, -0.03680108f, 
    0.10863990f, 0.01936362f, 0.00503016f, -0.06922518f, -0.05182079f, -0.01592074f, 0.05305564f, 0.02055549f, 
    -0.29020938f, -0.46552196f, 0.25391901f, 0.13919921f, -0.33632329f, -0.13989215f, 0.20187089f, 0.22932246f, 
    0.11153173f, 0.11516204f, 0.08775601f, 0.15365502f, 0.09379063f, 0.06845395f, 0.00494524f, -0.06991466f, 
    0.11940444f, 0.10208338f, -0.14930731f, 0.10340294f, 0.48460996f, 0.04057846f, -0.29829639f, 0.27605820f, 
    -0.35062283f, -0.03647481f, 0.05242029f, -0.04418221f, 0.10080259f, 0.05538474f, -0.04371207f, -0.04287561f, 
    0.01256459f, -0.09646289f, 0.09247339f, -0.04922032f, -0.06466360f, 0.00687661f, -0.01229940f, 0.01813699f, 
    -0.27376202f, -0.40540615f, 0.27034158f, -0.02198683f, 0.24216096f, 0.02554812f, -0.04520978f, 0.09322277f, 
    0.06518514f, -0.01218660f, 0.00430816f, 0.00990733f, -0.07912115f, -0.05989719f, 0.11177829f, -0.01329818f, 
    -0.06415290f, 0.08953728f, 0.01015881f, -0.04278899f, -0.16372696f, 0.13979678f, 0.18538725f, 0.13928799f, 
    0.13352653f, -0.18421562f, -0.14484778f, 0.09224001f, -0.07974637f, 0.09613116f, 0.02337546f, 0.08731807f, 
    -0.00322301f, 0.03942887f, -0.00865789f, 0.04669464f, -0.01058856f, 0.07063245f, -0.03838295f, -0.18293324f, 
    0.16313572f, 0.02257921f, 0.04293643f, -0.07599103f, 0.15169039f, 0.23505789f, 0.07717815f, -0.07514208f, 
    -0.02584459f, 0.09167858f, -0.03866099f, 0.11708129f, 0.04520663f, -0.04874276f, 0.05172635f, -0.05125830f, 
    0.13578635f, 0.02208478f, 0.05145894f, 0.02135634f, 0.06375778f, 0.04372925f, -0.14756401f, 0.05995871f, 
    -0.27428928f, 0.09728034f, -0.03023576f, -0.14109749f, 0.11106434f, 0.01941421f, -0.01230892f, -0.10554034f, 
    0.00691737f, 0.06632126f, -0.07110125f, -0.04421735f, 0.00366175f, 0.00846180f, -0.22930504f, -0.11550278f, 
    -0.14783558f, -0.14078568f, -0.37238318f, -0.03006280f, 0.09802249f, 0.00714259f, -0.10501911f, -0.03536253f, 
    -0.04234999f, 0.00261363f, 0.05661576f, -0.10555554f, 0.01932231f, 0.01597747f, -0.01854023f, 0.04092200f, 
    -0.01324046f, 0.06231314f, -0.07131102f, -0.05835156f, 0.17127547f, 0.08935083f, 0.05400345f, 0.27887398f, 
    -0.05051159f, -0.17159450f, 0.03387043f, 0.08302604f, -0.02540521f, 0.04313467f, -0.11508939f, -0.01525257f, 
    0.10576446f, -0.11172449f, -0.11916945f, 0.07945672f, -0.01126317f, -0.15059739f, 0.01467071f, -0.11142923f, 
    -0.04214871f, -0.01114528f, -0.17443728f, -0.06054658f, 0.01092366f, 0.07707810f, -0.06874531f, 0.03591671f, 
    -0.06602620f, 0.03613072f, -0.06766163f, 0.01403709f, 0.05737051f, 0.02930440f, 0.05504186f, 0.06688967f, 
    -0.05058908f, 0.04777204f, 0.03549726f, 0.00089273f, 0.38873678f, -0.17378408f, -0.33527863f, 0.24037735f, 
    -0.05051748f, -0.12985891f, 0.02146544f, 0.13970689f, -0.05260580f, 0.01932047f, 0.02271277f, 0.01619574f, 
    -0.02880132f, 0.00759465f, 0.06335808f, 0.13476340f, 0.08837037f, -0.06180890f, 0.06374449f, 0.14102985f, 
    -0.15885854f, 0.01636112f, 0.26788804f, -0.02810602f, 0.11529931f, 0.12145527f, 0.00656869f, -0.07120674f, 
    0.25047934f, -0.11973384f, -0.03779490f, -0.06102905f, 0.04401946f, 0.01324133f, 0.03331253f, -0.08348997f, 
    0.08958636f, 0.05366701f, 0.00173256f, -0.15773296f, -0.13778245f, -0.09051345f, -0.09820250f, 0.16451836f, 
    0.08108331f, 0.05564272f, 0.07200045f, 0.20861782f, 0.06332228f, 0.04520882f, 0.02295591f, 0.04045862f, 
    0.00783897f, 0.13480353f, 0.03650120f, 0.03589648f, 0.17289136f, -0.03927796f, 0.07322881f, 0.00972151f, 
    -0.03708137f, 0.19965771f, -0.31032136f, -0.01100617f, -0.07656526f, 0.02627577f, -0.19223456f, 0.06047209f, 
    -0.24881418f, -0.02622250f, -0.04205011f, -0.00301079f, -0.02237990f, 0.04963304f, -0.03415589f, -0.02965634f, 
    -0.05003782f, -0.03462940f, 0.09022389f, 0.06765618f, -0.54273129f, 0.05774078f, 0.02806699f, 0.09441027f, 
    -0.10998728f, -0.05090278f, 0.14819840f, -0.12193307f, -0.12185176f, -0.07479307f, 0.13658458f, -0.20056377f, 
    0.04086266f, -0.06416990f, 0.03624199f, -0.05444200f, 0.06807654f, 0.04882074f, 0.00666398f, -0.00919721f, 
    -0.17430358f, -0.19359922f, -0.00938108f, 0.05851927f, -0.02903915f, -0.01506293f, 0.01621059f, 0.00478883f, 
    0.11225067f, -0.02152363f, -0.01020460f, 0.07833888f, -0.05833483f, -0.12395902f, -0.12194355f, 0.06313825f, 
    0.02213085f, -0.00466141f, -0.02072329f, 0.09783448f, 0.30065477f, -0.00073125f, -0.08450706f, -0.00116498f, 
    0.22705637f, 0.05330852f, -0.03795150f, 0.07976283f, 0.02445481f, 0.02511371f, -0.01596379f, 0.11032190f, 
    0.01756867f, 0.10034725f, 0.06121812f, 0.11516632f, 0.13922228f, -0.14079919f, -0.06241017f, -0.00876104f, 
    0.21799819f, 0.12108698f, 0.00157683f, 0.12279391f, -0.23125923f, -0.08854166f, 0.00599590f, -0.09639801f, 
    0.02988248f, 0.06573796f, -0.03593903f, -0.01393600f, -0.06412920f, -0.15157840f, -0.03236853f, -0.10906044f, 
    0.00212090f, -0.02410011f, -0.01718432f, -0.03887141f, -0.15321994f, -0.06281459f, 0.06704273f, 0.25119525f, 
    0.07217781f, -0.21347247f, 0.13221692f, 0.03204592f, 0.10621108f, 0.10202671f, -0.07847490f, -0.06749531f, 
    -0.04428310f, 0.14369962f, -0.01322310f, 0.12834460f, -0.01431242f, -0.00538677f, 0.00157231f, 0.07449251f, 
    -0.11199028f, -0.13259041f, 0.05697675f, 0.17558040f, 0.09475947f, 0.02937571f, -0.06514556f, 0.21545710f, 
    0.02872926f, 0.15482304f, -0.02646806f, 0.19122308f, -0.06733610f, 0.15828085f, 0.02379764f, 0.04323098f, 
    -0.09156808f, 0.11619413f, -0.02185446f, 0.14190766f, 0.17836009f, -0.09328772f, -0.31082022f, 0.31417212f, 
    -0.11251006f, 0.05546067f, 0.04772960f, 0.20697229f, 0.05431754f, 0.14372060f, -0.10101106f, 0.09074447f, 
    -0.03060864f, 0.03382491f, 0.06219021f, 0.07220504f, -0.00954309f, -0.02240546f, 0.04188477f, 0.09155978f, 
    -0.18265955f, 0.12614745f, 0.06420823f, 0.23310933f, 0.05048398f, -0.02998140f, 0.04177378f, 0.15434697f, 
    -0.00197626f, 0.11510471f, -0.10709516f, 0.06140419f, 0.03354364f, 0.05509816f, 0.01197322f, 0.01742905f, 
    0.00161405f, 0.06020017f, -0.04149248f, -0.08986147f, -0.19959573f, 0.21479148f, -0.01115791f, 0.04323642f, 
    -0.02091789f, -0.03050446f, 0.02213828f, -0.05014704f, -0.04325698f, 0.09357458f, -0.04502992f, 0.05409265f, 
    0.02812015f, 0.00389088f, -0.00409307f, 0.06916973f, -0.06187380f, 0.02917790f, 0.07042632f, 0.05364311f, 
    -0.25235066f, 0.35560384f, 0.16782598f, 0.01760180f, 0.25311658f, -0.10482735f, -0.05427571f, 0.01170328f, 
    0.02709114f, 0.02601883f, -0.04379235f, 0.04119515f, -0.04675966f, 0.06638397f, -0.02860740f, -0.00640444f, 
    -0.00259053f, 0.02823667f, 0.13655259f, -0.06154069f, -0.28771946f, 0.27667400f, 0.09504730f, 0.13436724f, 
    0.05151615f, -0.13659970f, -0.04222441f, 0.08516391f, 0.06141864f, 0.02955805f, -0.02681754f, -0.09746565f, 
    0.06351383f, -0.00138352f, -0.01086845f, 0.00080674f, -0.00287552f, -0.05821767f, 0.02531970f, -0.06435711f, 
    0.00639810f, 0.06170738f, -0.15382859f, 0.13150220f, -0.00606600f, -0.00319608f, -0.03483403f, 0.06502828f, 
    -0.06845327f, -0.02987187f, -0.04250829f, 0.00748063f, 0.00905255f, -0.06204177f, 0.01040022f, 0.00027511f, 
    -0.05679718f, -0.07359919f, 0.02420936f, -0.04638913f, 0.11463179f, -0.26742154f, 0.20398779f, 0.30149740f, 
    0.00782934f, -0.10873432f, -0.01532105f, 0.02527661f, 0.00973915f, 0.07065146f, -0.10896133f, -0.04017024f, 
    0.04804016f, 0.04934504f, -0.13780098f, 0.04373251f, -0.07193816f, 0.01851828f, -0.16320667f, -0.00490959f, 
    -0.27083135f, -0.03969076f, 0.25204575f, 0.08662912f, -0.13482946f, -0.04661233f, -0.10185605f, -0.10054305f, 
    0.01406973f, 0.02173378f, 0.10816956f, -0.01244385f, 0.07628725f, -0.10989179f, 0.06705149f, 0.02084250f, 
    -0.00269604f, 0.00658893f, -0.02368277f, 0.06214963f, -0.01146656f, -0.01532507f, -0.02332425f, -0.09389625f, 
    -0.15324846f, 0.11770826f, 0.02738555f, 0.05582115f, 0.12316472f, -0.04010364f, -0.00238768f, -0.05507395f, 
    0.01820863f, -0.04340555f, 0.10928169f, -0.03687614f, 0.02972586f, 0.11263342f, 0.18103620f, -0.05734736f, 
    -0.02801055f, 0.01174467f, -0.02356860f, 0.01223919f, -0.02958190f, 0.01840294f, -0.03542498f, 0.00053568f, 
    -0.02396482f, 0.01977246f, -0.04087033f, -0.02594789f, -0.00438701f, 0.02295714f, 0.01520841f, -0.01175011f, 
    -0.00193740f, 0.00011317f, -0.00616446f, -0.04130068f, -0.00622590f, -0.01155610f, 0.00838562f, -0.03500119f, 
    -0.01927868f, -0.01544414f, -0.01611798f, -0.03416006f, -0.02954508f, -0.03733770f, -0.03517592f, -0.00867061f, 
    -0.03145244f, -0.01629335f, -0.04249153f, -0.03206278f, -0.00235281f, 0.01680745f, 0.01075783f, 0.01144794f, 
    0.00591633f, 0.03903088f, -0.00846851f, -0.03670797f, -0.00877875f, 0.01069151f, -0.04098244f, -0.03648878f, 
    0.00289369f, -0.00927222f, -0.03918961f, 0.00265053f, 0.02480573f, -0.03427721f, -0.02220727f, -0.03421935f, 
    0.00587491f, -0.02804073f, -0.00626457f, 0.02607592f, 0.00998247f, -0.01561464f, -0.01535884f, -0.03717891f, 
    0.01657350f, -0.00963647f, 0.02986583f, -0.01220796f, -0.02960802f, -0.01499742f, -0.03824019f, 0.01864352f, 
    0.01433136f, -0.02416786f, 0.02303085f, -0.01343544f, -0.00125286f, -0.04541576f, 0.00962862f, -0.02265153f, 
    0.01886743f, 0.01057929f, 0.03127667f, 0.00527330f, -0.00963067f, -0.04604188f, 0.00924312f, 0.01027385f, 
    -0.01850490f, -0.01711463f, 0.01273371f, 0.03338883f, 0.01779160f, -0.03134685f, -0.00979338f, -0.01024288f, 
    -0.03891796f, 0.00974022f, -0.03842878f, 0.02489474f, -0.02527996f, 0.02347516f, -0.04216263f, -0.03706330f, 
    0.00299752f, 0.03040814f, -0.00440228f, -0.04007301f, -0.01970496f, 0.01762357f, -0.01105035f, -0.02190807f, 
    0.00295020f, 0.01562304f, 0.00864226f, 0.02607430f, -0.00588594f, 0.02473175f, 0.00526145f, 0.00906231f, 
    -0.02390966f, -0.04314769f, 0.00315577f, 0.01966306f, -0.02869673f, -0.02048742f, -0.02261475f, 0.01651643f, 
    -0.04132709f, -0.01119671f, -0.00114965f, -0.00702097f, 0.00584187f, -0.01166831f, 0.00734655f, -0.03715795f, 
    -0.02908212f, -0.03329919f, -0.01212915f, 0.01939327f, 0.02843871f, 0.00484239f, 0.02717604f, 0.00076840f, 
    0.00203051f, 0.01505610f, 0.00867210f, 0.01106463f, -0.00524133f, -0.02301327f, -0.00951378f, 0.02608256f, 
    -0.01159457f, -0.01069207f, -0.01093220f, 0.00619624f, 0.00516535f, 0.03184679f, 0.01175018f, -0.00575717f, 
    0.00528990f, -0.03146982f, 0.00566021f, -0.03661242f, 0.01044154f, 0.01873204f, 0.02538723f, -0.00415260f, 
    0.00206126f, 0.02313601f, -0.04222506f, -0.02220480f, 0.03332237f, 0.02567332f, 0.02020346f, 0.00793270f, 
    -0.02999187f, -0.03300461f, -0.03864988f, -0.03886260f, -0.00854966f, 0.03335010f, 0.00475431f, -0.02517951f, 
    -0.00190227f, -0.04155568f, 0.01488527f, -0.01554894f, 0.01114214f, 0.02073420f, -0.03550221f, 0.01841251f, 
    -0.00222406f, -0.02546579f, -0.03962816f, -0.02670395f, -0.02575729f, -0.03553684f, -0.02698663f, -0.01551661f, 
    -0.00891283f, 0.02730152f, -0.01159266f, 0.00661841f, -0.02135658f, 0.00861634f, -0.04221269f, -0.03561279f, 
    -0.03008280f, -0.01227094f, 0.01642899f, -0.02684592f, 0.02434593f, 0.02744639f, -0.01743032f, -0.01204286f, 
    -0.01675258f, -0.03781394f, -0.03943045f, -0.03499579f, -0.00344233f, -0.00681424f, -0.03304605f, -0.01221846f, 
    -0.00521045f, 0.02789171f, -0.03264508f, -0.02216885f, -0.03079009f, -0.00196353f, -0.04154090f, 0.02184752f, 
    -0.01020494f, -0.02124856f, -0.02765275f, 0.01910987f, 0.00057218f, 0.02302775f, 0.00621703f, -0.02172151f, 
    -0.01386366f, 0.02777367f, -0.03747105f, -0.02434709f, -0.00104698f, -0.03570779f, 0.00533751f, -0.02044244f, 
    -0.00004414f, 0.00869296f, 0.01592519f, 0.02089704f, 0.00851001f, -0.03807637f, -0.04127320f, -0.04186152f, 
    -0.02007717f, -0.00674288f, 0.00434125f, -0.03909897f, -0.03442913f, -0.01738515f, 0.02676174f, 0.01731425f, 
    -0.04296431f, -0.00783111f, 0.02093950f, -0.00709363f, 0.00299154f, -0.03214938f, -0.02717536f, -0.02765734f, 
    -0.01893865f, -0.02140565f, -0.03576599f, -0.03394249f, -0.00350317f, -0.00128983f, -0.02927982f, 0.01641071f, 
    0.02950275f, 0.00904431f, -0.02283067f, -0.03819028f, 0.03158318f, 0.02298556f, -0.00574252f, -0.01139561f, 
    -0.03570032f, -0.00997625f, 0.02972712f, -0.00686611f, -0.01657976f, 0.00388530f, 0.02836076f, -0.04304990f, 
    0.02765070f, 0.00172215f, -0.03896722f, 0.00629499f, 0.00840941f, -0.03003496f, -0.02762420f, 0.01285194f, 
    -0.00902805f, -0.00661030f, -0.00542671f, 0.01223107f, 0.02134631f, -0.02569854f, 0.01520065f, -0.01755403f, 
    -0.01542639f, -0.02565777f, 0.02338851f, -0.04210228f, -0.03454677f, -0.02115184f, -0.00440516f, 0.03142928f, 
    0.01404455f, 0.01427132f, -0.00764015f, 0.00767143f, 0.00813999f, 0.01823053f, -0.00093570f, 0.03178114f, 
    -0.03653122f, -0.02183182f, -0.01658473f, 0.02898695f, -0.04462940f, 0.01125695f, -0.01035413f, 0.00712886f, 
    0.01721234f, 0.02410705f, 0.01047973f, 0.00599565f, 0.00734921f, -0.00344919f, -0.00626364f, 0.01084094f, 
    0.00422077f, -0.00073438f, 0.00390872f, 0.01122319f, 0.03075581f, -0.01930486f, 0.01383826f, -0.02786158f, 
    -0.03041053f, -0.01725575f, 0.01710920f, -0.03026297f, 0.02540634f, -0.03140506f, -0.00414333f, 0.02808332f, 
    -0.01349910f, 0.00249902f, 0.01451256f, 0.03011613f, 0.02854898f, -0.03790292f, 0.02893244f, -0.01879259f, 
    0.01904287f, 0.03304006f, 0.02274620f, -0.04478418f, 0.00228380f, -0.01876257f, -0.02278385f, -0.02641900f, 
    -0.03861699f, 0.02541581f, -0.03873664f, -0.02409409f, -0.04592938f, 0.01549945f, -0.00741778f, -0.01272848f, 
    -0.00850217f, 0.01037649f, -0.00533851f, 0.01176217f, -0.01581785f, 0.01148871f, 0.03760803f, 0.02180768f, 
    -0.02685551f, 0.01681324f, 0.01015321f, -0.03399774f, -0.02219211f, -0.00406655f, -0.04024926f, -0.00466208f, 
    -0.00800788f, 0.02947743f, -0.04372067f, -0.00892192f, -0.02131643f, 0.03320841f, -0.02302167f, -0.02619156f, 
    -0.01979071f, -0.02719865f, -0.00228997f, 0.01986527f, -0.00539513f, -0.01980888f, 0.01101108f, -0.01345806f, 
    0.01321866f, -0.01949328f, 0.03179810f, -0.03617977f, -0.00261601f, -0.04010624f, 0.02168076f, 0.01317587f, 
    -0.00671719f, 0.01978595f, -0.02491380f, -0.00720192f, -0.00808607f, 0.01415855f, -0.00856419f, -0.03876649f, 
    -0.03766604f, 0.01650462f, -0.00675547f, 0.02142829f, 0.00444794f, -0.02427987f, -0.04153519f, 0.01279981f, 
    0.02294719f, -0.00882380f, -0.00310382f, 0.02069715f, 0.02351258f, -0.01206671f, -0.04269412f, -0.03944414f, 
    0.01345196f, -0.02286352f, 0.00731149f, -0.00827644f, -0.02893381f, -0.00383721f, 0.01025770f, 0.02076079f, 
    -0.01472738f, -0.00670488f, 0.01361895f, 0.02746982f, -0.00124774f, 0.02024592f, 0.00306899f, -0.03688000f, 
    -0.00498168f, -0.00889073f, 0.00969045f, 0.00407821f, -0.00629314f, 0.00714073f, -0.04607540f, -0.02571294f, 
    0.00567819f, 0.00907695f, -0.02335125f, -0.01399072f, 0.01221048f, 0.00731411f, -0.01768503f, -0.00742682f, 
    0.01145653f, -0.01969615f, 0.01796900f, 0.02948033f, -0.01164462f, -0.00556800f, -0.00061804f, -0.04078391f, 
    0.01612029f, -0.03776270f, -0.01020936f, 0.00037757f, 0.02307265f, -0.03978956f, -0.01588518f, -0.03373935f, 
    0.00000609f, 0.02706776f, 0.02538257f, 0.03315002f, -0.04297073f, 0.01233891f, -0.03568432f, 0.01649820f, 
    -0.01169652f, 0.00278498f, -0.01131411f, 0.00201855f, 0.01463464f, 0.02510245f, -0.03906854f, -0.02447347f, 
    -0.02855396f, -0.03136734f, 0.02316886f, 0.00877732f, -0.04177617f, 0.02113347f, -0.03266937f, 0.00621982f, 
    -0.03146793f, 0.00398219f, 0.02955769f, -0.01814862f, -0.03544468f, 0.01045056f, 0.01906826f, 0.00154802f, 
    0.03649089f, -0.03744540f, -0.01743373f, -0.03675063f, -0.00342124f, -0.02334945f, 0.01939021f, -0.00943385f, 
    0.01078461f, 0.00399679f, -0.03110351f, 0.02437743f, 0.00221214f, -0.01666423f, -0.02223557f, -0.02587907f, 
    -0.04118356f, -0.03464165f, -0.03153975f, 0.00844966f, -0.02848919f, -0.03268332f, 0.03059510f, 0.01264677f, 
    0.00905219f, -0.00136154f, 0.01820459f, 0.01901357f, 0.02577833f, 0.01267695f, 0.01525467f, 0.01899931f, 
    0.02802131f, -0.00463083f, -0.03501908f, 0.03121456f, -0.00749812f, 0.01688737f, 0.01675688f, 0.02375040f, 
    -0.01405189f, -0.01073973f, 0.00892722f, -0.02244018f, -0.04312665f, -0.01630682f, 0.02811695f, 0.01840735f, 
    -0.03192505f, -0.01317476f, -0.00339953f, -0.03274936f, -0.01280009f, -0.00721001f, -0.01133928f, -0.00625702f, 
    -0.02927569f, 0.02127730f, -0.00499770f, 0.01153484f, -0.04602766f, 0.00582586f, 0.02547617f, 0.00598667f, 
    -0.04701370f, 0.03154401f, 0.01593702f, -0.00227722f, -0.00923623f, 0.03079998f, -0.03484456f, -0.03881340f, 
    -0.02547650f, 0.03191623f, -0.00136251f, 0.03420616f, 0.00204709f, -0.02465531f, -0.04372922f, -0.01534613f, 
    0.02680036f, -0.00318129f, 0.00673319f, -0.03965767f, 0.00413200f, -0.01492338f, -0.00639817f, -0.00684561f, 
    0.01392669f, 0.01183898f, 0.00346443f, -0.03861071f, -0.00996107f, -0.03922978f, -0.02012340f, -0.00891418f, 
    -0.01109483f, 0.01062574f, -0.03329805f, 0.03230875f, 0.02760689f, -0.00022179f, 0.03240607f, 0.00533416f, 
    -0.04312053f, -0.04198033f, -0.03039834f, -0.03181987f, -0.01791619f, 0.00369489f, -0.03363136f, 0.00159037f, 
    0.01692323f, -0.04656438f, -0.07994416f, 0.23663464f, 0.02854849f, 0.02734068f, -0.01375430f, 0.14402717f, 
    0.00280917f, -0.03787077f, 0.00585758f, 0.06841919f, 0.03546404f, 0.04169513f, 0.09544560f, 0.09719044f, 
    -0.02379124f, 0.21954022f, -0.01016833f, -0.10634635f, -0.35018501f, 0.08576677f, 0.10463045f, 0.31215364f, 
    -0.16589379f, 0.01022496f, 0.01042462f, 0.01838189f, 0.03642149f, -0.02151976f, 0.00656326f, -0.10285071f, 
    -0.04803130f, 0.03642134f, 0.05631308f, 0.10031290f, -0.01472669f, -0.09539323f, -0.08369324f, -0.09990044f, 
    -0.15329212f, -0.02181228f, -0.27230260f, -0.01894531f, 0.32860705f, -0.09612930f, 0.08799201f, 0.15519837f, 
    0.01731050f, 0.20518485f, 0.04043314f, 0.09786452f, 0.01365317f, 0.01134202f, 0.01380288f, -0.02364828f, 
    0.08575712f, 0.04721326f, 0.04002060f, -0.08708733f, 0.09583265f, -0.05329428f, -0.34976256f, -0.16760878f, 
    0.19958957f, -0.01882578f, 0.08045723f, 0.05666249f, 0.01123244f, 0.08954989f, -0.05178737f, -0.00554681f, 
    0.03386299f, -0.01390405f, 0.01045879f, 0.08179747f, 0.00387832f, 0.09324652f, 0.03909229f, -0.03650223f, 
    0.16183117f, -0.18175149f, -0.30443552f, 0.27789459f, 0.21775745f, -0.14636992f, 0.19957393f, -0.07263789f, 
    0.11008183f, -0.09846334f, -0.05182412f, -0.01268466f, 0.18060438f, -0.02000634f, 0.09723057f, -0.03924125f, 
    -0.18482427f, 0.02294240f, 0.15765764f, 0.00589414f, -0.26435477f, -0.02574992f, -0.23748650f, 0.55785608f, 
    0.50618905f, 0.01158992f, 0.04772547f, 0.09147428f, 0.08290100f, 0.07064769f, 0.02182933f, -0.02246529f, 
    0.11292020f, 0.04644320f, 0.02528743f, 0.08247361f, -0.04782686f, 0.04798568f, -0.01922884f, 0.02890075f, 
    0.63993418f, 0.16633701f, 0.02882676f, -0.28641012f, -0.19324929f, -0.00071158f, 0.13569140f, 0.08215544f, 
    -0.00681013f, -0.00250305f, 0.04458832f, 0.02784595f, 0.03972616f, 0.15992343f, 0.08444709f, -0.02169565f, 
    0.05880406f, -0.04862460f, 0.03959499f, -0.11115775f, 0.39434114f, -0.19071615f, -0.34178206f, -0.24845272f, 
    0.23154263f, -0.04576866f, 0.09847207f, -0.01329241f, 0.02407305f, -0.00997885f, -0.00713161f, 0.02054366f, 
    -0.01770541f, -0.09209869f, 0.00407532f, -0.02820833f, 0.04112227f, 0.11774931f, 0.11491882f, 0.12940867f, 
    -0.04927650f, 0.12819603f, 0.24966533f, 0.18051553f, -0.16297089f, -0.09476359f, 0.02675603f, 0.02325928f, 
    0.03546141f, 0.03223750f, -0.05788881f, 0.20740500f, 0.07739880f, 0.19410099f, 0.06461284f, -0.04617270f, 
    0.25102076f, 0.10613241f, 0.20025237f, -0.08494805f, 0.00933526f, 0.18001232f, -0.06005931f, 0.10836970f, 
    0.22896893f, -0.00994929f, 0.09474783f, 0.05649264f, -0.10836793f, 0.03929123f, -0.02660189f, -0.03410548f, 
    0.02936855f, 0.06555157f, 0.01154849f, 0.03135649f, -0.01779373f, -0.06544058f, -0.01739422f, 0.00664007f, 
    0.47360292f, 0.01592945f, 0.16605841f, -0.24006847f, 0.29033336f, 0.05402823f, 0.05082889f, -0.02157604f, 
    0.07987431f, -0.06104548f, -0.03358661f, 0.03635532f, 0.00880565f, 0.08256061f, -0.00141345f, 0.12416804f, 
    0.12213416f, -0.07784634f, 0.02981294f, 0.00462480f, 0.11339349f, 0.05378659f, -0.37337220f, -0.05396129f, 
    0.13105467f, 0.22742511f, 0.05212672f, 0.13945979f, 0.16171212f, 0.13305438f, -0.10786437f, -0.01105388f, 
    -0.04864222f, 0.03767071f, 0.06832108f, -0.03107920f, 0.02386298f, 0.13090020f, 0.03388497f, -0.00810840f, 
    0.22605985f, -0.02896281f, -0.12992410f, -0.18481085f, 0.18314986f, 0.00541719f, -0.00556954f, 0.05276803f, 
    -0.00562454f, 0.05123217f, 0.03595577f, 0.04606832f, -0.01632281f, -0.06604112f, -0.02318145f, 0.09372218f, 
    0.08886925f, -0.03229562f, 0.01491610f, -0.12439894f, 0.08361501f, 0.08021629f, 0.59443420f, -0.12935066f, 
    -0.04427204f, -0.21691780f, -0.12260038f, -0.04807308f, -0.07210034f, -0.12568648f, -0.00456217f, -0.05383480f, 
    0.02729741f, -0.03562941f, 0.05793134f, 0.04855071f, -0.04460710f, -0.08289803f, -0.10069378f, -0.01700863f, 
    -0.05816549f, 0.33022130f, -0.01124630f, 0.04469990f, -0.16699937f, 0.03363239f, 0.04978862f, 0.05711845f, 
    0.01847388f, 0.07032631f, 0.04119565f, -0.00666806f, -0.01096990f, 0.04232511f, 0.07430465f, -0.04504469f, 
    0.04882037f, -0.08426569f, 0.03362800f, -0.19286680f, 0.04935075f, 0.15963443f, 0.24109368f, 0.06073914f, 
    -0.09137291f, 0.09482575f, -0.06407098f, -0.01018286f, 0.01590359f, 0.01765616f, -0.06165219f, 0.05534880f, 
    0.08757173f, -0.01150381f, 0.03174819f, 0.13359410f, 0.13572107f, 0.10351140f, 0.04242755f, -0.06645341f, 
    0.16162492f, -0.23770323f, 0.19512062f, -0.11869758f, 0.19870624f, -0.03097272f, 0.07706163f, 0.06200234f, 
    0.11051203f, -0.10980885f, -0.03389063f, -0.01623118f, -0.00818863f, 0.00194082f, -0.02352589f, 0.10365765f, 
    0.09206150f, -0.02945753f, 0.04876048f, -0.09961662f, -0.00545995f, -0.10544820f, -0.27816227f, -0.11675370f, 
    0.24629486f, -0.08576687f, 0.13459188f, 0.16448040f, 0.11156175f, 0.07167075f, 0.01021394f, -0.02984016f, 
    -0.02877665f, -0.05986014f, 0.01192806f, -0.04457102f, -0.01605104f, 0.00159127f, 0.04718078f, -0.08819705f, 
    0.14729103f, -0.11834657f, -0.30330065f, -0.16175921f, -0.10943669f, -0.04517213f, 0.01884796f, 0.16597258f, 
    -0.01770062f, 0.11676960f, -0.06466459f, -0.00081491f, -0.02597320f, -0.11634460f, -0.12545830f, -0.04778089f, 
    0.03207510f, -0.05540330f, 0.10260596f, -0.05482409f, 0.23374720f, 0.29476228f, 0.29390916f, -0.01407608f, 
    -0.20335358f, -0.11033463f, -0.11076855f, -0.06461763f, 0.00800844f, -0.16129524f, -0.11650001f, -0.07253216f, 
    0.02245219f, 0.00688105f, 0.05049702f, -0.02707249f, 0.03413391f, -0.00112042f, 0.01361223f, 0.04459717f, 
    0.05743594f, -0.14433682f, -0.30883825f, 0.18071474f, 0.21320096f, -0.10644335f, 0.19637939f, 0.12687346f, 
    -0.00911498f, 0.04141792f, -0.00228252f, -0.06959985f, 0.03851257f, 0.00576977f, -0.00194997f, -0.07876105f, 
    -0.01176159f, 0.01178151f, -0.01860165f, -0.00708113f, 0.22321136f, 0.14069749f, 0.23428248f, 0.09151471f, 
    -0.08039714f, 0.02100396f, 0.14628014f, -0.13676758f, 0.04700063f, -0.08822501f, 0.09903818f, 0.02748744f, 
    0.10758753f, -0.07783461f, -0.00659201f, 0.07287855f, 0.08104113f, 0.09482773f, -0.03400752f, -0.11892085f, 
    0.00382367f, 0.13471927f, 0.06184075f, -0.08398071f, -0.18234140f, -0.05680466f, 0.00054856f, 0.03962743f, 
    0.01395625f, -0.07652436f, 0.04197970f, 0.09111756f, 0.10319065f, -0.02675937f, 0.16297306f, -0.02614616f, 
    -0.00399880f, -0.04947294f, 0.03476298f, -0.08035079f, 0.05070558f, 0.18970299f, 0.39587426f, 0.16634643f, 
    -0.01241278f, -0.08689869f, -0.12898958f, 0.09555064f, 0.07434523f, -0.09718493f, -0.03850792f, 0.02107938f, 
    0.05508133f, -0.01380867f, 0.13391382f, 0.00100585f, 0.08027291f, 0.04799871f, -0.00872825f, 0.02147613f, 
    -0.04141821f, -0.03490757f, 0.01677590f, -0.09868831f, -0.08714473f, -0.04636825f, -0.06298918f, 0.06835920f, 
    0.00297854f, 0.14880566f, 0.06240034f, 0.01870030f, -0.03613632f, -0.09048917f, -0.10767686f, -0.01415175f, 
    0.16966817f, 0.06257316f, 0.13215069f, 0.02386377f, -0.15985958f, -0.27195734f, -0.39796638f, 0.02104217f, 
    0.05564626f, 0.04795733f, 0.05923469f, 0.10936496f, 0.02330212f, 0.11768065f, -0.05294870f, -0.00796248f, 
    -0.08385730f, -0.02685344f, 0.00842906f, 0.01797014f, 0.06464897f, 0.04418060f, 0.06176301f, -0.03170651f, 
    0.10749277f, -0.24147268f, -0.37213084f, -0.23034087f, 0.08846719f, 0.13726911f, 0.01108540f, -0.09166136f, 
    -0.02357716f, -0.01057740f, 0.01735082f, -0.00564951f, -0.07094034f, 0.04749328f, 0.05683189f, -0.05244517f, 
    0.02551198f, 0.03564530f, -0.00571559f, 0.09684602f, 0.07655035f, -0.11275700f, -0.29865131f, -0.30582067f, 
    0.23595567f, 0.12255599f, -0.04066521f, -0.05672228f, -0.06199085f, -0.04208372f, -0.12973203f, 0.05402738f, 
    -0.03461530f, -0.02164063f, -0.01108713f, 0.04848259f, 0.02319129f, 0.05222553f, -0.05292359f, 0.04475682f, 
    0.17169386f, -0.03736395f, -0.22720720f, -0.13107616f, 0.12646662f, 0.05007119f, -0.01890968f, 0.08422237f, 
    0.07107240f, 0.05922743f, -0.04596727f, 0.03715097f, -0.01553095f, 0.03997103f, -0.01702681f, 0.05479581f, 
    0.01656564f, -0.03247935f, 0.08118219f, -0.01032768f, -0.10383908f, 0.16190685f, -0.29307902f, -0.37133220f, 
    -0.14240757f, 0.08505980f, 0.03975856f, 0.14084579f, 0.03626629f, 0.18254268f, -0.06437276f, -0.03852959f, 
    0.01969819f, -0.05082336f, 0.00780059f, -0.06856958f, -0.05594928f, -0.03443065f, 0.08568416f, 0.01175618f, 
    0.32046786f, -0.16072443f, -0.19090405f, -0.29281735f, 0.22695713f, -0.05691949f, 0.09310222f, 0.00181295f, 
    0.11152342f, -0.12789702f, -0.02543113f, -0.03816779f, -0.06858157f, 0.01098371f, -0.06847895f, 0.12174234f, 
    0.06727467f, 0.04033148f, 0.00793305f, -0.08071616f, -0.24968021f, -0.30856827f, -0.02427227f, 0.22449262f, 
    0.12094644f, 0.11072210f, 0.00109197f, -0.08278648f, -0.01174084f, -0.09315728f, 0.02578871f, -0.03526377f, 
    0.02367058f, 0.15784070f, -0.04963439f, -0.08273342f, 0.04334536f, 0.21919061f, 0.07238907f, 0.11744394f, 
    0.56935179f, 0.14363965f, 0.15484674f, -0.04113213f, -0.23446886f, 0.15659423f, 0.01187738f, -0.14949337f, 
    -0.07644407f, 0.09612301f, 0.10834309f, 0.03256603f, 0.08128247f, 0.07396716f, 0.02514005f, 0.08111411f, 
    0.01417352f, 0.02384236f, 0.00384308f, -0.07182442f, -0.13487162f, -0.16331388f, -0.17808841f, -0.23149827f, 
    -0.03671851f, -0.13525432f, -0.06963225f, -0.12107735f, -0.08301351f, -0.14122684f, -0.05992106f, -0.01015299f, 
    -0.00202127f, -0.08097582f, 0.14324252f, 0.09827586f, -0.07113293f, 0.17553692f, 0.02080215f, -0.23126511f, 
    0.16256557f, -0.14228545f, 0.02060509f, -0.05916591f, 0.03156301f, 0.04889185f, 0.05061751f, -0.07887314f, 
    -0.00937892f, 0.14105010f, 0.00385271f, 0.01492370f, 0.10124679f, 0.07224289f, -0.05715401f, -0.06946695f, 
    0.06211572f, 0.02288668f, -0.04727753f, 0.00414839f, -0.06308067f, 0.10669234f, 0.22461672f, 0.11133882f, 
    0.04443413f, -0.02775220f, -0.09871878f, 0.06790731f, 0.06853230f, -0.07212500f, 0.08049733f, -0.03016369f, 
    -0.02589093f, 0.01702863f, 0.06179198f, 0.06351753f, 0.03498647f, -0.07827659f, -0.14320341f, -0.11901129f, 
    0.00774725f, 0.16542740f, 0.08683638f, -0.13583201f, 0.32275835f, 0.09374017f, -0.11225040f, -0.14639497f, 
    0.03598418f, -0.13010432f, -0.00302004f, -0.09929937f, -0.19139209f, 0.12317540f, 0.03081251f, 0.19805185f, 
    -0.01661277f, -0.00146394f, 0.36217165f, -0.00720761f, -0.03602147f, 0.05894725f, 0.06388622f, -0.29239702f, 
    -0.09929063f, 0.03684865f, 0.19221812f, 0.01742902f, -0.00333912f, 0.10354908f, 0.04795061f, -0.04256818f, 
    -0.04368009f, 0.01408795f, -0.02703509f, 0.04456588f, 0.00763329f, 0.03692091f, 0.11988430f, 0.02841459f, 
    -0.15078910f, 0.03961709f, -0.09789460f, -0.01553505f, 0.09576574f, 0.07481161f, 0.01123851f, -0.04501461f, 
    0.09963419f, 0.02011194f, 0.18612039f, 0.06313271f, -0.03925062f, 0.09660321f, 0.05303364f, 0.14874934f, 
    0.12492185f, 0.08140797f, 0.05855563f, 0.14744771f, -0.19452588f, -0.07847326f, 0.01637770f, 0.06278297f, 
    -0.13734572f, 0.00914302f, 0.02057459f, -0.07116164f, 0.09371479f, -0.21029176f, -0.01626465f, -0.02006166f, 
    0.00654444f, 0.09833913f, 0.02010458f, 0.06537669f, -0.00821686f, -0.00995081f, -0.01317156f, 0.29274330f, 
    0.11179332f, -0.22772534f, -0.28777954f, -0.12415603f, -0.07939882f, -0.13457422f, -0.00140923f, -0.08365754f, 
    -0.01055943f, -0.00037418f, -0.12914582f, -0.13565689f, -0.05158973f, 0.01177840f, 0.06657685f, 0.15185298f, 
    0.03125931f, -0.05771821f, 0.04982544f, 0.01855381f, 0.21253586f, 0.21882518f, 0.53476590f, -0.08896241f, 
    0.13731438f, -0.07686397f, -0.02555780f, -0.17707981f, -0.05972818f, -0.06690888f, 0.02496118f, -0.08699377f, 
    0.14829566f, 0.05907690f, 0.12340579f, 0.06101571f, -0.05298707f, 0.06479878f, -0.00331752f, -0.11817737f, 
    0.07051104f, 0.03672272f, 0.35209760f, 0.03267895f, -0.08450113f, 0.06217885f, -0.09047162f, -0.05471946f, 
    0.07582754f, 0.04468340f, -0.00750577f, 0.12124559f, 0.02406880f, -0.02976944f, -0.03385723f, 0.06886775f, 
    -0.00618591f, 0.01462996f, -0.11173739f, -0.00232799f, -0.43486592f, 0.20776737f, 0.15088606f, 0.07806876f, 
    0.03756738f, 0.09839056f, -0.06447344f, 0.12126665f, -0.10771718f, -0.00945314f, 0.16879210f, -0.13489643f, 
    -0.06492605f, 0.14138281f, 0.04697889f, 0.01707295f, -0.11530341f, -0.08463898f, -0.03545469f, 0.01085633f, 
    -0.18736281f, 0.07774568f, 0.19016518f, 0.06644674f, -0.07232130f, -0.01686140f, -0.07180087f, 0.01244446f, 
    0.07515928f, -0.09207223f, 0.13480337f, 0.06388531f, 0.04839617f, -0.01718238f, 0.08118580f, 0.11299422f, 
    0.01305924f, 0.00438154f, -0.20237686f, -0.06013149f, -0.40467942f, -0.00958893f, 0.05536225f, -0.06195182f, 
    0.06988636f, 0.21240789f, -0.11304452f, -0.12993363f, 0.10665795f, -0.08429301f, -0.03822192f, 0.05237829f, 
    0.00695815f, -0.04962302f, 0.04327102f, -0.12904230f, -0.00266213f, 0.01407796f, -0.03919100f, -0.05846862f, 
    0.56588525f, -0.12150381f, -0.05666634f, 0.01465826f, 0.12672472f, -0.07503907f, 0.03888923f, -0.11065853f, 
    -0.16176318f, 0.09158026f, -0.09617528f, 0.11150011f, 0.07069105f, 0.13552284f, 0.01434317f, 0.15728661f, 
    -0.06790967f, 0.22268438f, -0.02962500f, 0.08906911f, 0.16860451f, 0.06908493f, -0.14192082f, 0.06980479f, 
    -0.10552520f, 0.07268568f, 0.00588402f, -0.05201681f, -0.01695840f, 0.11497585f, -0.03331673f, 0.04558606f, 
    0.11457241f, -0.07609621f, 0.07723030f, 0.15646000f, 0.02779658f, 0.01518353f, 0.02963905f, 0.16527516f, 
    0.11918497f, -0.06736965f, 0.26326433f, -0.07585941f, -0.24498276f, 0.13739197f, -0.15399794f, -0.23285916f, 
    0.01894225f, -0.05074458f, -0.03538846f, 0.07337493f, 0.08627582f, -0.01674442f, 0.06025882f, 0.06000118f, 
    -0.07034094f, -0.05277220f, -0.24886310f, -0.13137074f, 0.47559550f, -0.34227350f, 0.05668402f, 0.08575136f, 
    -0.02632797f, 0.08263786f, 0.04533784f, 0.05176490f, 0.09666859f, 0.24146172f, 0.00948921f, -0.09325409f, 
    0.01150606f, -0.02875266f, -0.03466577f, 0.06924828f, 0.10209901f, -0.08785503f, -0.03513072f, 0.08923278f, 
    -0.34984487f, -0.10044303f, -0.07413676f, -0.02317858f, 0.00099091f, -0.08394293f, 0.06005674f, 0.09509531f, 
    0.04478874f, -0.02968603f, 0.14618112f, 0.11024086f, -0.00580483f, 0.08060370f, -0.01126989f, -0.02238395f, 
    0.10231588f, -0.02475609f, -0.10246800f, -0.09951743f, -0.63094467f, -0.10494077f, 0.18088336f, 0.07928105f, 
    -0.17455927f, 0.01650605f, 0.03442550f, -0.14565231f, -0.07358788f, -0.05109144f, -0.21821363f, -0.18849607f, 
    -0.05762462f, -0.03168520f, -0.07669888f, -0.01731175f, 0.05915985f, 0.07212552f, -0.12914282f, -0.06643401f, 
    -0.01613143f, 0.27049649f, 0.25412604f, -0.03935285f, 0.07811693f, 0.10278659f, 0.06199538f, 0.09853480f, 
    0.00844428f, 0.13023295f, 0.08217592f, -0.12434117f, -0.02690348f, 0.05920700f, 0.12248220f, 0.08752840f, 
    -0.04802239f, -0.10565872f, 0.05213966f, -0.07396781f, 0.06688663f, 0.06694932f, -0.30768397f, -0.10179454f, 
    0.07359526f, 0.17040929f, -0.14892571f, 0.12642942f, -0.13453142f, 0.02576288f, 0.04456095f, -0.00189746f, 
    0.16553247f, 0.10150342f, 0.02197172f, 0.05374574f, 0.00828401f, 0.02316876f, 0.04659598f, 0.01267820f, 
    0.07429783f, -0.15742709f, -0.32460177f, -0.03312408f, -0.07221387f, -0.01885893f, -0.07762919f, -0.12098806f, 
    0.04349476f, -0.03032980f, 0.00834218f, -0.04945679f, 0.15796465f, 0.10885006f, 0.12964296f, 0.02658353f, 
    0.10446342f, -0.01292005f, 0.00278253f, 0.01233791f, -0.25402859f, 0.11038686f, -0.30158064f, -0.17315005f, 
    -0.10203552f, 0.03855130f, -0.10510486f, -0.15515582f, 0.06713052f, -0.12078250f, 0.02997892f, 0.00626057f, 
    0.10717006f, -0.06356861f, -0.03182518f, 0.12079970f, 0.18423185f, 0.06273238f, 0.12298004f, 0.04144976f, 
    0.14577881f, -0.14881760f, -0.16270837f, 0.03530832f, 0.07104886f, -0.02515818f, -0.04502920f, 0.05870626f, 
    0.11861867f, 0.15039681f, 0.00129562f, -0.03243332f, 0.04102009f, -0.01576230f, 0.09984332f, 0.07650238f, 
    0.14100739f, -0.00779018f, 0.09052471f, 0.07776622f, 0.19156770f, -0.01646834f, 0.04527999f, 0.08030546f, 
    0.08407854f, -0.08011676f, -0.06111217f, 0.03929414f, 0.17816892f, 0.06817596f, -0.02621224f, -0.11435545f, 
    -0.06155171f, 0.00287335f, -0.00180003f, 0.05000146f, 0.08931235f, 0.10274078f, -0.01145664f, 0.06419901f, 
    0.28080559f, -0.08519425f, 0.10569579f, 0.22158159f, -0.22494009f, 0.13709284f, 0.08536581f, -0.03329335f, 
    0.02783712f, -0.10193731f, -0.02744001f, -0.03165213f, 0.01571139f, -0.06794073f, 0.02142044f, 0.01071415f, 
    0.03981135f, 0.09652610f, -0.04393685f, 0.28052860f, 0.20194289f, -0.19906834f, 0.05877356f, 0.19741745f, 
    0.00021658f, -0.06314316f, 0.02644301f, 0.04702799f, -0.07384903f, 0.08461808f, 0.11295201f, -0.04650655f, 
    -0.02569631f, -0.02273220f, -0.10304125f, 0.01682439f, 0.05819317f, 0.05926934f, -0.13775751f, 0.11175502f, 
    -0.18540066f, 0.11664654f, 0.29977691f, 0.08243563f, 0.02946598f, 0.08093466f, -0.04017349f, 0.05468811f, 
    0.04186798f, -0.00044531f, 0.04107958f, -0.01009412f, -0.01476354f, 0.08248487f, 0.08248112f, 0.07418021f, 
    -0.04619544f, -0.03194415f, -0.16474877f, -0.07259175f, -0.38899532f, -0.22184867f, -0.01274598f, 0.01337035f, 
    0.03040353f, -0.03264275f, 0.06065536f, 0.07110149f, -0.01091062f, -0.14709915f, 0.04945586f, -0.01339914f, 
    0.02665716f, 0.04853807f, 0.14070635f, 0.05043066f, -0.05790329f, 0.08882890f, -0.08382173f, -0.13160026f, 
    -0.00244034f, 0.16721396f, -0.03417640f, 0.13517837f, 0.18804091f, 0.15206821f, 0.20300233f, 0.17219612f, 
    0.03633396f, 0.27006990f, 0.04907723f, 0.05415852f, 0.00745765f, -0.00501695f, 0.00535143f, 0.15345745f, 
    0.11342198f, -0.00129275f, -0.02886711f, 0.02453550f, 0.23771334f, 0.06064301f, 0.04079471f, 0.02982723f, 
    -0.11125505f, -0.03601558f, 0.00245183f, -0.07664646f, -0.04251554f, 0.09425039f, -0.19129351f, -0.03892308f, 
    0.03355948f, 0.04187540f, 0.05798170f, 0.13985261f, 0.13603105f, -0.03577867f, 0.05821113f, 0.10254455f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10028407f, 0.06548715f, 0.01013887f, 0.04655179f, -0.00437732f, 0.12460979f, -0.02684323f, -0.02382300f, 
    0.17164445f, 0.01025914f, 0.14559987f, 0.09485059f, 0.01338379f, 0.02259890f, -0.03995561f, -0.02330380f, 
    -0.02243967f, -0.03224405f, 0.02482099f, 0.00122350f, -0.04032132f, 0.05558154f, -0.03884495f, -0.03114011f, 
    0.03972943f, 0.01871313f, -0.02048047f, 0.04487261f, 0.02687689f, 0.01961923f, -0.04055912f, 0.13066319f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.02395828f, -0.35680231f, 0.11064949f, 0.27808046f, 0.10827190f, -0.06856221f, 0.08629623f, 0.07460268f, 
    0.13355261f, -0.10377683f, 0.07084999f, -0.33683035f, 0.09428252f, 0.11526099f, -0.00203384f, 0.04469856f, 
    -0.05334076f, -0.03565691f, 0.23372269f, -0.11507721f, -0.02739212f, 0.29736462f, 0.00576520f, 0.13689962f, 
    0.42874253f, 0.06301814f, -0.10507325f, -0.27253464f, -0.14795631f, 0.07332761f, -0.38639346f, 0.15767881f, 
    -0.49812478f, 0.15496464f, 0.18266863f, -0.41895843f, 0.07663727f, -0.11397907f, -0.02272632f, -0.00454657f, 
    0.28758124f, -0.08850779f, 0.18652906f, 0.03821155f, -0.01592628f, 0.00408305f, -0.00009487f, -0.16806598f, 
    -0.16506340f, 0.12111735f, 0.19755977f, -0.10492788f, -0.00727943f, -0.37020510f, -0.07427102f, -0.11552561f, 
    0.01906020f, -0.10968893f, 0.16327034f, 0.21262291f, 0.01423729f, 0.04250537f, 0.25613967f, -0.25132027f, 
    -0.21839145f, 0.23175949f, 0.06544475f, 0.15930225f, -0.13764107f, 0.20647028f, 0.07726336f, 0.02188361f, 
    0.06854130f, 0.15373927f, 0.07479506f, 0.27119470f, -0.09549204f, 0.16023286f, -0.10761843f, 0.09381539f, 
    0.02106843f, -0.13047598f, 0.29610130f, -0.02425023f, -0.37724063f, -0.09045723f, -0.11529907f, 0.25282761f, 
    0.00571896f, 0.16408034f, 0.01577180f, -0.27083084f, 0.00692217f, 0.02965814f, -0.39973781f, 0.14518012f, 
    0.01649963f, 0.02299026f, 0.06799171f, -0.17811550f, -0.04453666f, 0.31397647f, 0.13792033f, -0.00829756f, 
    0.09376720f, 0.06090362f, -0.16158137f, -0.16306235f, 0.04564525f, -0.04890727f, 0.17579971f, -0.01073315f, 
    0.05954300f, 0.11088970f, -0.07474903f, -0.10626961f, 0.39096931f, -0.03375512f, -0.34621096f, -0.25073934f, 
    0.27628842f, 0.03296390f, -0.04865273f, -0.14018059f, -0.36372173f, 0.15995769f, 0.24759702f, 0.22110213f, 
    0.28213170f, -0.05452870f, 0.06837523f, -0.30184236f, 0.04748750f, -0.35055384f, 0.16688606f, 0.12122755f, 
    -0.00715571f, -0.09579747f, 0.04937064f, 0.24268989f, 0.15608011f, 0.16414325f, -0.09144314f, -0.03902568f, 
    0.03361923f, 0.05383931f, -0.28743446f, 0.04336570f, -0.20141651f, 0.29243788f, 0.02517718f, 0.32248086f, 
    0.23076457f, 0.09662407f, -0.10182996f, 0.23186320f, -0.01551649f, -0.15003140f, 0.01306635f, 0.08576860f, 
    -0.02080223f, -0.08270864f, 0.04109658f, 0.33595496f, 0.16453101f, 0.19761133f, 0.12073518f, -0.17045447f, 
    0.11380581f, 0.02028993f, 0.14709000f, 0.25371450f, 0.14936525f, -0.07441300f, 0.01551424f, -0.15264046f, 
    -0.13136759f, -0.12244681f, -0.13782868f, -0.05255245f, 0.11823253f, 0.10124777f, -0.30186504f, -0.61048526f, 
    0.22066270f, -0.11651640f, 0.02801483f, -0.53601199f, -0.04344779f, 0.01600601f, 0.26006225f, 0.16251302f, 
    0.26683909f, -0.06402879f, -0.22900455f, -0.12544446f, -0.00151191f, 0.16806251f, 0.10523422f, -0.09056062f, 
    0.02835206f, -0.04013970f, -0.31108469f, -0.26075301f, -0.14358413f, -0.08353385f, 0.14581029f, 0.30127522f, 
    0.12198977f, 0.10311304f, -0.04045727f, 0.04940614f, -0.03816633f, -0.02554553f, 0.10920040f, 0.29855368f, 
    0.34421644f, -0.07113355f, -0.01589416f, 0.11096075f, -0.41301712f, -0.06132304f, 0.11074854f, 0.03870710f, 
    0.09203387f, 0.19680852f, -0.34802902f, -0.01322710f, -0.00873687f, 0.14126915f, -0.07577311f, -0.15341586f, 
    -0.00365020f, -0.08532961f, 0.19989291f, -0.19256419f, 0.09519576f, 0.01564086f, -0.06470228f, 0.42296895f, 
    -0.11009330f, -0.10240407f, -0.25602907f, 0.15592621f, 0.07669169f, -0.23183505f, 0.08961193f, 0.34411272f, 
    -0.52947193f, -0.12568229f, -0.06885918f, 0.29776075f, -0.20956701f, 0.00968630f, 0.35434750f, -0.06367282f, 
    0.16888584f, 0.42617753f, -0.26694769f, 0.24499296f, -0.18104987f, 0.03597371f, -0.14354116f, 0.08836515f, 
    0.05973349f, 0.12151196f, 0.08762473f, -0.17824775f, -0.15190305f, 0.12967721f, 0.09496911f, -0.00613983f, 
    0.12049498f, -0.12675869f, -0.00677713f, -0.01530010f, 0.05650870f, -0.00639240f, 0.29662937f, 0.10601311f, 
    -0.32508957f, 0.00983883f, 0.01975052f, 0.14785396f, 0.08501260f, 0.05576350f, -0.20852509f, 0.17489898f, 
    0.06871322f, 0.00624045f, -0.20599598f, 0.08466724f, 0.00806242f, 0.33394155f, -0.05926776f, 0.07200380f, 
    0.14792295f, -0.08432984f, -0.04935509f, 0.05483032f, 0.03683951f, 0.08435163f, -0.12152915f, 0.25715426f, 
    -0.13148780f, -0.02750744f, 0.20292747f, -0.13482608f, -0.15996391f, 0.06299461f, -0.28762779f, 0.38926339f, 
    0.16448659f, 0.15108153f, 0.09472147f, -0.15901478f, -0.35819414f, -0.04999793f, -0.39111334f, 0.04239926f, 
    -0.10761206f, -0.26866966f, -0.08005674f, -0.29422158f, -0.07220663f, -0.12216132f, -0.08865161f, -0.05612880f, 
    0.24360691f, 0.17927657f, 0.10373354f, 0.04127472f, 0.09458115f, -0.10345346f, 0.00292652f, -0.14645199f, 
    0.13899323f, -0.01246523f, -0.02877317f, 0.14869566f, 0.25064903f, 0.17733870f, 0.07910814f, -0.42332277f, 
    0.19864546f, 0.15256882f, -0.01061254f, 0.11140417f, -0.13617522f, -0.13672809f, 0.32995984f, 0.19565706f, 
    -0.14028202f, -0.04347507f, -0.04800669f, -0.00444193f, -0.10324233f, -0.11653019f, 0.01356820f, 0.03078532f, 
    -0.10412019f, -0.01113543f, 0.12392298f, 0.04971375f, -0.12299653f, -0.10730879f, 0.07702612f, 0.08935151f, 
    -0.08514076f, -0.02949392f, -0.11540169f, 0.04152458f, 0.17286032f, -0.01155963f, -0.02438595f, 0.18679878f, 
    0.12888990f, -0.15197267f, -0.10480905f, 0.11700429f, -0.15443587f, 0.11984599f, -0.11761554f, -0.03929003f, 
    0.03395977f, 0.10301188f, 0.03568607f, -0.40493527f, 0.04820866f, 0.27883518f, 0.03070239f, 0.03798013f, 
    -0.03799028f, 0.00918954f, -0.04982771f, 0.25634816f, -0.07157283f, -0.01783609f, -0.02654400f, -0.14515598f, 
    0.15525548f, 0.03065939f, 0.14607270f, 0.14337361f, -0.47592700f, -0.04948670f, 0.03856461f, -0.01302171f, 
    0.23196195f, 0.15700273f, -0.04297435f, 0.50575608f, -0.17600501f, 0.14196151f, -0.06280807f, 0.32481095f, 
    0.17743008f, 0.02604589f, -0.21537788f, 0.28951445f, -0.17815380f, 0.10983112f, -0.11517581f, -0.08200575f, 
    -0.17505459f, 0.13305236f, 0.06854977f, 0.05014964f, 0.13929480f, 0.07451499f, -0.15624984f, 0.43621492f, 
    -0.13547075f, -0.10151760f, -0.09151407f, 0.16443796f, -0.09176237f, -0.06441166f, -0.21178475f, 0.23903842f, 
    -0.15810962f, -0.11106419f, 0.04094659f, 0.10809226f, 0.01138838f, 0.12873827f, -0.39780545f, 0.08466400f, 
    0.17733213f, 0.15653683f, 0.00964871f, 0.00106881f, 0.12702465f, 0.27624702f, 0.16429995f, -0.07926577f, 
    0.16862550f, -0.07949574f, -0.37924504f, -0.25066534f, -0.10641433f, 0.04097639f, -0.07757865f, -0.04668257f, 
    -0.11522663f, -0.11066953f, -0.35945112f, 0.06191362f, 0.23179661f, -0.14667927f, 0.44555557f, -0.02411667f, 
    -0.07595018f, -0.04465935f, 0.06134171f, -0.21969837f, -0.10523991f, -0.01422019f, 0.34042421f, 0.04089569f, 
    0.11278109f, 0.09544177f, -0.69954669f, -0.30106878f, 0.14401343f, 0.13064949f, 0.10598310f, 0.05748703f, 
    0.19245327f, -0.07850979f, -0.12328932f, 0.21504971f, 0.11045378f, 0.05455705f, -0.00860198f, 0.25473413f, 
    -0.06049507f, -0.05919329f, -0.33365607f, -0.15763986f, 0.27331591f, 0.07437680f, -0.10404626f, -0.08644671f, 
    -0.32383698f, -0.09365907f, -0.08928390f, 0.02877548f, -0.43227115f, -0.07273227f, -0.07733285f, -0.08046085f, 
    0.25722581f, 0.18013461f, -0.29122591f, -0.11396530f, 0.00429967f, 0.25718138f, -0.16065304f, -0.03436063f, 
    -0.00384211f, -0.04205382f, 0.32427660f, -0.02787765f, -0.10500455f, -0.16711248f, -0.05465410f, -0.18760839f, 
    0.02141206f, 0.11109186f, -0.00839786f, 0.12928104f, 0.17621811f, 0.20347887f, -0.02346937f, -0.51039571f, 
    -0.04293861f, -0.01027871f, 0.00324383f, 0.20364866f, -0.09022022f, 0.00718875f, -0.20477404f, 0.19918023f, 
    0.18568955f, 0.12468656f, -0.32949376f, 0.05684050f, 0.14089274f, -0.10736591f, -0.10802224f, 0.16608974f, 
    -0.04447886f, 0.10400203f, 0.01807652f, 0.02112116f, 0.05155035f, 0.16524801f, -0.12617704f, 0.39099485f, 
    0.12659048f, 0.15641189f, 0.14841604f, -0.07515450f, 0.48157743f, 0.03534207f, -0.13699257f, 0.06542376f, 
    -0.25682330f, 0.09593139f, -0.08027810f, -0.04659776f, -0.09532791f, 0.04946982f, 0.11912350f, -0.02746946f, 
    0.00852016f, 0.18418674f, -0.38615909f, 0.17677453f, -0.11131808f, -0.12416621f, -0.17835891f, 0.13223542f, 
    0.12665521f, 0.12019607f, 0.33690310f, 0.31904900f, -0.08467086f, 0.00101080f, 0.13052912f, 0.29393685f, 
    0.16020927f, -0.05712327f, 0.02700335f, 0.00197868f, 0.16601211f, -0.19340646f, -0.36049721f, 0.25848100f, 
    -0.35026950f, -0.00999572f, -0.11892791f, 0.20856388f, -0.04651416f, 0.09387341f, -0.14144927f, -0.15847653f, 
    0.01930089f, 0.09764376f, -0.01576601f, 0.16014591f, -0.00800423f, 0.04324645f, -0.10231514f, -0.02056197f, 
    -0.08743121f, 0.15584187f, -0.06812666f, 0.06162579f, 0.11919657f, 0.11233060f, 0.08597630f, -0.11703186f, 
    -0.07219989f, -0.07203128f, -0.17650780f, -0.07954545f, 0.08227630f, -0.15939096f, 0.03258451f, -0.12573494f, 
    -0.11295713f, 0.14000562f, 0.11050440f, -0.09210240f, -0.05736020f, -0.17508817f, 0.01747727f, -0.14275257f, 
    -0.21857522f, 0.09053962f, 0.06688979f, -0.11455868f, -0.15963726f, 0.20064387f, -0.16578259f, 0.05308388f, 
    -0.00140892f, -0.13445254f, -0.02583702f, 0.29603463f, -0.12743606f, 0.05687904f, -0.15398678f, 0.02605727f, 
    0.00407352f, 0.00260019f, -0.04633912f, -0.06785931f, 0.01276984f, -0.19920242f, 0.04841727f, 0.44014406f, 
    -0.08344749f, -0.08261699f, 0.01635129f, 0.52050853f, -0.17692214f, -0.12542190f, 0.04522094f, -0.26654896f, 
    0.13232373f, 0.15510260f, -0.10120931f, 0.24151079f, -0.07063439f, 0.17378303f, 0.11893388f, -0.12789991f, 
    0.06279949f, -0.08362955f, 0.10441934f, -0.16409130f, -0.08957172f, 0.02593847f, 0.16046818f, -0.00187533f, 
    0.13350077f, 0.11253537f, 0.09601845f, 0.12745194f, 0.16203557f, -0.28810534f, 0.20475647f, 0.17133923f, 
    -0.08761688f, -0.03170606f, -0.13413830f, -0.48946062f, 0.22920111f, -0.02598554f, -0.06192505f, -0.12275267f, 
    0.22180118f, -0.00859551f, -0.32741067f, -0.02150242f, -0.08571931f, 0.05378132f, 0.14220352f, -0.00131467f, 
    0.16052382f, 0.04286278f, 0.30502254f, 0.01519403f, 0.16256319f, 0.00359173f, -0.09391019f, -0.25821859f, 
    0.00944873f, 0.03938442f, -0.22401132f, -0.08085741f, -0.45682099f, 0.32731062f, -0.01695032f, -0.17468743f, 
    0.24553503f, 0.13454373f, -0.09530330f, -0.19051591f, 0.06118361f, 0.04317700f, -0.28501421f, 0.13550268f, 
    -0.16069932f, 0.22123107f, 0.03306439f, -0.20367470f, -0.14929408f, 0.02764815f, 0.08855563f, 0.13570900f, 
    -0.01518270f, -0.04433270f, -0.07570041f, 0.02328697f, 0.09466626f, -0.09632187f, 0.13160534f, 0.33742148f, 
    -0.05704245f, 0.15055689f, 0.11657352f, -0.10223748f, 0.57745302f, 0.11698369f, -0.04356360f, -0.21181135f, 
    -0.01800740f, -0.12399267f, -0.14898843f, 0.48734567f, -0.15466589f, -0.13494053f, 0.10519812f, 0.07733772f, 
    0.30971649f, -0.41209537f, 0.23004028f, 0.06091463f, 0.15137726f, 0.00583239f, -0.04129958f, -0.09607895f, 
    -0.00515278f, 0.14935271f, -0.19631115f, -0.50214750f, 0.08288873f, 0.04699374f, 0.00934411f, 0.27829513f, 
    0.14023554f, -0.08486652f, 0.09382616f, 0.07708579f, 0.12466607f, 0.11540280f, 0.34051436f, -0.02455734f, 
    0.12336531f, 0.11680270f, -0.11113206f, 0.41184786f, -0.04460798f, 0.06072002f, -0.02138131f, 0.09182540f, 
    0.05995549f, -0.24605486f, 0.00899996f, 0.31711853f, -0.08796774f, 0.09718038f, -0.14447202f, -0.05130070f, 
    -0.01352715f, -0.02757323f, -0.19371615f, -0.00252095f, 0.09111312f, -0.08674862f, -0.05017786f, -0.12685037f, 
    0.12258781f, 0.07159612f, 0.27343374f, 0.10053066f, -0.09057539f, 0.06913814f, 0.08984173f, -0.08799671f, 
    0.16592650f, -0.08115856f, -0.09502845f, -0.29525983f, 0.18639055f, 0.13647120f, -0.37736416f, 0.22555532f, 
    0.03974817f, 0.47143462f, -0.27627498f, -0.11868250f, -0.16406873f, 0.14032945f, 0.14472716f, 0.06386486f, 
    0.28584164f, 0.01850061f, 0.22697236f, 0.02706743f, 0.14742365f, -0.15052287f, 0.17577612f, -0.55798340f, 
    0.01088605f, 0.01565182f, -0.05158211f, -0.11261147f, -0.23298118f, -0.08999497f, 0.19612913f, -0.46185738f, 
    -0.08159993f, -0.03290618f, -0.00978166f, 0.50974840f, 0.24581270f, 0.09605964f, -0.12328603f, 0.12817949f, 
    0.01353816f, 0.09312101f, 0.30179593f, 0.10703420f, -0.09705308f, -0.19503394f, 0.06730790f, 0.04621004f, 
    -0.40329239f, -0.11055723f, 0.31849170f, -0.02780813f, 0.09530257f, -0.14115138f, -0.12606589f, 0.02434432f, 
    -0.03653599f, 0.02996321f, -0.13389602f, -0.08968008f, 0.13000220f, -0.13497706f, -0.01668285f, -0.22239497f, 
    0.23398660f, 0.11456510f, -0.13680092f, -0.38767347f, 0.18078545f, -0.10515002f, 0.02680435f, -0.02368772f, 
    -0.23356757f, -0.18293263f, 0.12703699f, 0.12601355f, -0.04950331f, -0.01054764f, 0.01253358f, -0.02572763f, 
    0.04189954f, 0.07809632f, -0.10459102f, 0.27860442f, -0.15354834f, 0.03653232f, 0.11988067f, 0.25412476f, 
    0.09022893f, 0.15994230f, -0.05101063f, 0.12955011f, 0.24448916f, 0.19161105f, -0.51684499f, 0.36692321f, 
    0.01990956f, -0.12251662f, -0.03073687f, -0.08613561f, -0.10817137f, 0.15120506f, 0.03312643f, -0.05538684f, 
    0.03510188f, -0.16194317f, -0.03786543f, 0.09561516f, -0.07362428f, -0.37297118f, -0.17034997f, 0.03928101f, 
    0.18075122f, -0.07540122f, 0.27541950f, -0.08909196f, 0.15570112f, 0.07979646f, -0.11516605f, 0.29163060f, 
    0.11650204f, -0.06212112f, 0.14201401f, 0.06975968f, 0.28522879f, 0.47100016f, -0.00678786f, -0.04277722f, 
    0.19086680f, -0.09734090f, 0.05169554f, -0.28518003f, -0.00825662f, 0.07613871f, 0.17548257f, 0.08444676f, 
    0.16708784f, -0.26140732f, -0.12701617f, 0.31027314f, -0.10784900f, -0.09906314f, -0.03871035f, 0.10265521f, 
    0.11749835f, -0.00115813f, -0.13485825f, 0.05798057f, 0.03387608f, 0.10279289f, -0.03519664f, 0.23600367f, 
    -0.13970633f, 0.14294671f, -0.13126984f, -0.07774735f, 0.07527677f, 0.20281351f, 0.23883320f, 0.43821564f, 
    -0.22980851f, -0.17577094f, 0.10728645f, 0.08849841f, -0.05734353f, -0.15555204f, -0.20397449f, -0.16471098f, 
    0.22994883f, -0.09823394f, 0.13470678f, 0.16041797f, -0.05018463f, -0.21829006f, 0.02798359f, 0.15672575f, 
    0.23132262f, -0.09989328f, -0.19327743f, 0.09392773f, 0.07436547f, -0.09288421f, -0.15294844f, -0.21427050f, 
    0.04894277f, -0.01704303f, -0.23688090f, 0.11307429f, -0.28064537f, -0.10669994f, 0.37618697f, -0.01846228f, 
    0.20102088f, 0.03773205f, -0.08745890f, 0.20320027f, 0.01710302f, 0.07255349f, 0.10865905f, -0.18786778f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.10231280f, 0.25023001f, 0.19457468f, 0.06765880f, -0.09282918f, 0.07590184f, 0.01252807f, -0.03163925f, 
    0.22345659f, 0.08365358f, 0.06108239f, -0.20669821f, 0.03299646f, 0.08132526f, 0.09994482f, 0.13011244f, 
    0.03186168f, -0.05509483f, 0.15157738f, -0.14901496f, -0.03573652f, -0.10214955f, 0.08275652f, 0.07616274f, 
    -0.16562016f, -0.08954655f, 0.25276294f, 0.23575974f, 0.16022128f, -0.11544030f, -0.00426199f, -0.12229837f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.38809496f, -0.23031677f, -0.02734699f, -0.35434207f, 0.13729039f, -0.42739156f, 0.20927474f, -0.16074933f, 
    -0.05411322f, 0.02635134f, -0.12818623f, -0.26533100f, -0.21007611f, -0.09580123f, 0.14958417f, -0.67780852f, 
    -0.45480070f, -0.07656884f, -0.44155398f, 0.00671925f, -0.12247489f, 0.07703886f, -0.22714330f, -0.31231871f, 
    0.13889572f, 0.11439391f, -0.28596085f, 0.02207315f, 0.00886636f, 0.14383966f, 0.27007625f, 0.15667720f, 
    0.02017239f, 0.21667655f, -0.09123566f, -0.36307639f, 0.20983744f, 0.09957455f, -0.32650363f, -0.51602095f, 
    -0.09541766f, -0.23194943f, 0.17294332f, 0.06239788f, 0.13072838f, -0.19912201f, -0.23394077f, -0.28796223f, 
    0.10939350f, -0.37325966f, -0.09500758f, -0.20208909f, -0.06826489f, -0.17374618f, 0.54076731f, -0.32883829f, 
    -0.04265912f, 0.30169076f, 0.24757448f, -0.05435611f, -0.24253206f, 0.15084603f, -0.03770903f, 0.27417836f, 
    -0.62720191f, -0.39453018f, 0.12109382f, 0.26247978f, 0.13698657f, -0.19693445f, 0.35640255f, -0.04094380f, 
    0.07184986f, 0.30383947f, -0.24193145f, -0.04597346f, 0.34117123f, -0.17120887f, 0.03937586f, 0.40436319f, 
    0.24403590f, -0.11699495f, -0.27493966f, -0.11518877f, -0.09926890f, -0.04567991f, 0.18983842f, -0.11660760f, 
    -0.26408765f, -0.11731863f, 0.16035366f, 0.28958288f, -0.30412197f, -0.32139584f, -0.27621138f, -0.16157345f, 
    -0.21027917f, -0.67002398f, -0.63835281f, -0.03958408f, 0.15340106f, -0.19465286f, 0.19300506f, 0.31141990f, 
    0.00298961f, -0.17891431f, -0.07996025f, -0.07741332f, 0.11146447f, 0.12680098f, 0.21645251f, 0.09446310f, 
    -0.05299446f, 0.10329049f, -0.08662827f, -0.08764336f, 0.11397030f, -0.13399450f, -0.40095603f, 0.10840410f, 
    0.17514104f, -0.21601169f, -0.09080213f, -0.24396446f, -0.13801891f, 0.06320967f, 0.15337278f, 0.17144518f, 
    -0.01709059f, 0.18077323f, 0.01612468f, -0.28087962f, -0.01910548f, 0.02713891f, 0.04211916f, 0.16381669f, 
    0.10988358f, 0.03762496f, -0.38691530f, 0.14793111f, -0.39561462f, 0.29507640f, 0.04661434f, -0.03477732f, 
    -0.16825786f, 0.27029794f, 0.16861701f, -0.16466402f, -0.44895169f, 0.04379386f, -0.04433612f, -0.29043269f, 
    -0.07425406f, 0.04174000f, -0.35724941f, 0.10460890f, 0.01067470f, 0.13407260f, 0.19847268f, -0.29362842f, 
    0.26446009f, 0.00472991f, 0.19137844f, 0.27007419f, -0.18145224f, 0.17591305f, 0.02938921f, -0.54572952f, 
    -0.13463701f, 0.26735541f, -0.09459580f, -0.06082492f, -0.05102372f, 0.14283520f, -0.20470574f, -0.36689520f, 
    0.20403098f, -0.04314261f, -0.05708461f, -0.25244528f, -0.21380335f, -0.05188904f, -0.05637435f, 0.03153127f, 
    -0.01108532f, 0.19637150f, -0.03381607f, -0.08347905f, 0.04382644f, 0.09725838f, -0.19334896f, -0.16928339f, 
    -0.23552305f, 0.10832677f, 0.29947859f, -0.07549545f, -0.29430938f, -0.15978332f, -0.07101493f, 0.38845333f, 
    0.03803194f, -0.02759468f, -0.29741749f, 0.06798653f, 0.34707600f, -0.30003628f, 0.04861221f, -0.11086776f, 
    -0.11838477f, -0.35090932f, 0.13750264f, -0.08052884f, 0.28838554f, 0.00667287f, -0.48550281f, -0.12128746f, 
    -0.37755385f, -0.15904891f, 0.29174086f, -0.16767141f, -0.20552492f, -0.76868129f, -0.67508233f, -0.05935931f, 
    -0.13111681f, -0.11432245f, -0.21692279f, 0.14851353f, 0.07588253f, 0.06817708f, 0.01377387f, -0.09007835f, 
    -0.65533638f, 0.04747361f, 0.10762192f, 0.05783113f, -0.27873439f, -0.23148532f, -0.28261513f, 0.29185596f, 
    -0.38045424f, 0.08771283f, 0.15673700f, 0.16193743f, 0.14726077f, -0.38775170f, -0.27558777f, 0.10520104f, 
    -0.30185214f, -0.56579936f, -0.34393910f, 0.30096009f, 0.38854241f, 0.02511878f, 0.33128327f, -0.00956154f, 
    -0.24322084f, -0.23470503f, -0.05927339f, 0.46812031f, 0.14447081f, 0.26751366f, -0.24530497f, -0.26416010f, 
    -0.69658536f, -0.57414722f, 0.17771930f, -0.22066996f, 0.33727893f, -0.08222344f, 0.19194019f, -0.13299794f, 
    -0.13267839f, -0.26643911f, -0.53804100f, 0.01384822f, -0.03465770f, -0.27098778f, -0.67018032f, 0.15675369f, 
    -0.23449787f, 0.00723718f, -0.01604399f, -0.06172415f, 0.25462961f, 0.04807178f, -0.53853852f, -0.30128595f, 
    -0.23351020f, -0.42192245f, 0.28464827f, -0.57792902f, 0.33357528f, -0.27746096f, -0.18297836f, -0.05839290f, 
    -0.01213514f, 0.05987777f, -0.44330648f, -0.11674172f, 0.14343953f, 0.36251810f, -0.58748156f, -0.04375691f, 
    0.01100877f, 0.04964686f, 0.33368266f, -0.07507958f, 0.09362879f, -0.19579332f, -0.20140980f, 0.04126544f, 
    -0.20955953f, -0.15598409f, 0.15482788f, -0.17111963f, 0.29418975f, -0.24003932f, 0.11711921f, -0.10076827f, 
    -0.35239744f, -0.46522412f, -0.03059658f, 0.00472531f, -0.38089177f, 0.37999913f, -0.46343234f, -0.35722682f, 
    0.20290764f, -0.37689948f, -0.15530409f, -0.09837241f, -0.31758368f, -0.18917033f, 0.39416102f, -0.15701471f, 
    0.10416104f, -0.06464293f, -0.15407699f, 0.13289505f, -0.39463550f, 0.31348118f, -0.04731717f, -0.13755111f, 
    -0.27458057f, -0.01802543f, 0.28792328f, -0.57842529f, -0.27990195f, -0.10555927f, -0.03255956f, 0.35971022f, 
    -0.24913807f, 0.00835568f, -0.26129040f, -0.12494310f, -0.19200522f, -0.04445789f, -0.35005623f, 0.18100712f, 
    0.14693886f, -0.65405697f, 0.25887662f, -0.26089981f, -0.10137133f, -0.36950403f, -0.25869757f, -0.11602959f, 
    0.27581769f, 0.38238671f, 0.17173931f, -0.11516612f, -0.17939289f, -0.05679216f, -0.38495082f, 0.32208019f, 
    -0.15272447f, -0.34084952f, 0.26846290f, -0.27547485f, -0.27604061f, 0.09482913f, -0.22640869f, -0.41897228f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.27458999f, 0.03940967f, 0.20742376f, 0.07574250f, -0.19532439f, -0.12653315f, 0.18375735f, -0.11614901f, 
    0.09570326f, -0.09729850f, 0.22106676f, 0.11447477f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
