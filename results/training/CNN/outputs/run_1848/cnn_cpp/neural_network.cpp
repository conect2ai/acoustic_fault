#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.24919960f, -0.21067408f, -0.03624158f, -0.72032005f, -0.56494713f, -0.66953140f, 0.41397426f, 0.41794285f, 
    0.07389116f, 1.36532199f, -0.96132553f, -0.73431939f, 0.22198933f, 0.44825432f, -0.50820971f, -0.10836843f, 
    -0.11123463f, -0.22376822f, 0.42332405f, -0.06207376f, -0.88067985f, -0.71622622f, -0.46551099f, -0.43095696f, 
    -0.20133506f, -0.57866722f, -0.05626040f, -0.37424970f, 1.26094043f, -1.00452662f, -0.05673156f, 0.09825774f, 
    0.03010251f, 0.02363997f, 0.07852253f, 0.09454708f, -0.18567608f, -0.32396388f, 0.50520706f, 0.36366141f, 
    -0.16174664f, -0.29792774f, 0.48560631f, 0.39166427f, 0.53870940f, -0.00980541f, -0.59949833f, -0.75604659f, 
    -0.07392659f, 0.51110184f, 0.34911665f, 0.16564085f, 0.24158266f, -0.31486478f, -0.51300669f, 0.34830225f, 
    0.23151903f, -0.40394044f, 0.07920067f, 0.82707387f, -0.20910029f, -0.60540432f, -0.86001486f, 1.06900251f, 
    -0.81188500f, 0.23654813f, -0.54526639f, 0.29165897f, 0.21543317f, 0.04013932f, 0.04468210f, 0.05451997f, 
    -0.65059495f, -0.79271001f, 0.08858196f, -0.51929373f, 0.42287275f, -0.16576168f, -0.36097053f, -0.23735207f, 
    0.12837404f, -0.32072857f, 0.22826603f, 0.04195326f, 0.78875148f, 0.39870852f, 0.73608673f, -0.10945569f, 
    0.70289022f, -0.12979637f, 0.00047349f, 0.44420442f, -0.24387349f, 0.07549150f, -0.21709344f, -0.00152246f, 
    -0.51857710f, 0.22333267f, 0.54923564f, 0.30113140f, 0.63931417f, 1.02602446f, -0.58003634f, -0.37743738f, 
    -0.08853734f, -0.35363424f, -0.28243810f, -0.01089958f, 0.84832788f, 0.25018916f, 0.60266811f, 0.53572863f, 
    0.01938424f, 0.12892802f, 0.29558906f, -0.49672559f, -0.30820900f, -0.78445220f, -0.17164759f, -0.33255816f, 
    0.88995987f, 0.49591789f, -0.31930897f, -0.12213931f, -0.35241359f, -0.17120790f, 0.90282500f, 0.20087744f, 
    0.21102920f, 0.26621860f, -0.53655046f, -0.56151015f, 0.39838251f, 0.02460043f, 0.43517101f, 0.65443903f, 
    0.67257828f, 0.01892399f, 0.33560085f, 0.10097891f, 0.06664152f, -0.20446222f, 0.83475655f, -0.33552912f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.08173231f, 0.40944713f, -0.17380670f, 0.15542571f, 0.03168604f, 0.61236376f, -0.28617364f, 0.35489646f, 
    -0.32091764f, -0.31600606f, 0.23677365f, 0.03653211f, -0.03756447f, -0.00834169f, 0.15337144f, 0.29530182f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.25831237f, 0.03971639f, 0.03391249f, -0.17663589f, 0.00057575f, -0.10559074f, 0.07684858f, -0.04989547f, 
    0.18453303f, -0.07132091f, -0.13247983f, -0.09831699f, 0.14172420f, 0.16307904f, 0.06242007f, -0.17558265f, 
    0.01748761f, -0.04262095f, -0.41665387f, -0.31199172f, -0.11565913f, 0.05836136f, -0.12867711f, -0.01672785f, 
    -0.12904875f, -0.06628851f, -0.15816113f, -0.26759541f, -0.36883396f, -0.48305601f, 0.12232386f, -0.01439162f, 
    0.08430869f, 0.10857349f, -0.02786029f, -0.19422029f, -0.15192232f, -0.18865594f, -0.20244196f, -0.09187251f, 
    0.07906992f, -0.04070462f, 0.37571529f, 0.04426499f, -0.10243425f, 0.13860491f, -0.35414928f, -0.26026425f, 
    0.10193770f, 0.09670548f, 0.14523546f, -0.03163146f, -0.13950267f, 0.26122764f, -0.19611076f, -0.09308332f, 
    0.32424307f, -0.09555297f, -0.12687123f, -0.03087519f, -0.08013079f, -0.06988378f, 0.05870597f, 0.46696639f, 
    0.19036739f, -0.06480704f, -0.01658157f, 0.15099190f, 0.01506066f, 0.16411902f, 0.24931183f, -0.00275269f, 
    0.33914116f, -0.16648901f, -0.08632069f, -0.14431380f, -0.17285027f, -0.03132341f, 0.28864953f, 0.07973369f, 
    0.03904681f, 0.04821767f, 0.13259295f, -0.18305257f, -0.32260811f, 0.05540032f, -0.18294924f, -0.21226083f, 
    -0.20411323f, -0.09844897f, 0.12913956f, 0.20760389f, 0.48298252f, -0.01864887f, 0.07264335f, -0.08508192f, 
    0.28374276f, 0.21959963f, -0.27213523f, 0.50889659f, 0.01504506f, 0.01030458f, -0.00791557f, -0.03929131f, 
    -0.13041814f, 0.02201944f, 0.17293978f, 0.08373588f, 0.22673944f, 0.09161520f, 0.24164483f, -0.07746939f, 
    -0.20558190f, 0.06666524f, -0.05108043f, -0.07544341f, 0.09881565f, -0.12249385f, -0.50892341f, -0.75520742f, 
    -0.20949726f, 0.17892183f, -0.02790277f, -0.08281422f, -0.21097353f, -0.10493438f, 0.25840804f, 0.16754308f, 
    0.01232877f, -0.08484018f, -0.18741359f, -0.22782917f, -0.02502467f, 0.14306062f, 0.09555851f, 0.28282821f, 
    0.11942147f, 0.22785079f, -0.22529732f, 0.01240181f, -0.03530516f, 0.14569806f, 0.24016844f, 0.08418060f, 
    0.22649565f, -0.14906493f, 0.53541654f, 0.01009358f, 0.03867284f, -0.07498099f, 0.08953661f, -0.16952263f, 
    -0.25825623f, 0.46129799f, -0.10126336f, 0.52643734f, -0.14626297f, 0.13480118f, 0.05784749f, 0.20127971f, 
    0.19934943f, 0.16736479f, 0.06750102f, -0.17234448f, 0.56544006f, -0.06972216f, 0.18337218f, 0.15400898f, 
    -0.30963811f, -0.27163437f, -0.37234592f, -0.32111800f, 0.05258380f, 0.48762870f, 0.18383190f, 0.53455341f, 
    0.12639509f, -0.16642126f, -0.12209799f, 0.16630074f, 0.22885448f, -0.35857487f, -0.16021912f, -0.16609405f, 
    0.03426451f, -0.34196532f, -0.13591440f, -0.20038725f, -0.08619813f, -0.01152800f, 0.17119575f, 0.48154667f, 
    0.03797358f, -0.08638590f, 0.00075900f, 0.19609740f, 0.09037054f, 0.11008711f, 0.01258390f, -0.45072278f, 
    -0.42440018f, -0.01007564f, -0.15986770f, 0.08069695f, -0.13573751f, 0.18139605f, 0.04311990f, -0.15947537f, 
    -0.14155641f, 0.25356716f, -0.22079514f, 0.08646906f, 0.05951128f, 0.15369301f, 0.00829948f, 0.02856104f, 
    0.31449735f, 0.27086005f, -0.21692286f, -0.05273352f, 0.20337418f, -0.24731968f, 0.22786288f, 0.14165336f, 
    -0.08352220f, 0.57851642f, -0.40005976f, -0.02114355f, -0.25697625f, -0.39615980f, -0.11745206f, 0.14271660f, 
    -0.03363193f, 0.04668861f, -0.20286238f, 0.36930346f, 0.00454741f, 0.32510018f, 0.17202480f, 0.00246523f, 
    -0.02235658f, 0.03776385f, -0.08527572f, -0.61391717f, 0.49920440f, -0.09935638f, 0.04799117f, 0.04232844f, 
    0.12161441f, -0.02725847f, -0.04378096f, -0.07420415f, -0.41067213f, -0.39868975f, -0.03686046f, 0.03813138f, 
    0.01354536f, 0.07341214f, 0.18182537f, 0.19827110f, 0.17935909f, 0.15184647f, -0.33712733f, 0.42780489f, 
    -0.13149080f, 0.05861224f, -0.23683989f, 0.15429249f, -0.16306111f, -0.05961425f, -0.38279480f, 0.49055508f, 
    0.10194171f, 0.01628681f, 0.06594466f, -0.00193588f, -0.28285274f, 0.03479111f, -0.04286776f, 0.09556970f, 
    0.08903913f, -0.33276781f, 0.02673724f, -0.32772473f, -0.20047207f, 0.25722858f, 0.04117890f, 0.20785575f, 
    0.05107382f, -0.08410843f, 0.44896129f, -0.19116317f, 0.22474524f, -0.02833488f, 0.11413559f, -0.11141517f, 
    -0.11594751f, 0.19787686f, 0.47428045f, -0.00615229f, 0.22502129f, 0.18685257f, -0.05712939f, 0.03642114f, 
    -0.02025818f, -0.00799379f, 0.50464684f, -0.08169640f, -0.10230077f, -0.04834353f, 0.06898258f, 0.18883511f, 
    0.20334473f, -0.10593010f, -0.04023619f, 0.40758544f, 0.19044739f, -0.29620540f, -0.18949330f, -0.14151300f, 
    0.02224790f, 0.24731869f, -0.21916598f, 0.00139427f, -0.09674511f, -0.54839265f, -0.10853022f, -0.10891682f, 
    0.07362530f, -0.08545393f, 0.00976888f, 0.07033362f, -0.20728056f, -0.00828132f, 0.04718640f, 0.36576790f, 
    0.05738473f, 0.07036471f, 0.20104338f, -0.02703476f, -0.06455619f, 0.12690121f, -0.09520309f, 0.21069458f, 
    -0.38011724f, -0.23113909f, -0.51833779f, -0.36452180f, 0.09844920f, 0.03253638f, 0.21121147f, 0.99674469f, 
    -0.42354426f, -0.59274411f, 0.32135430f, -0.14772581f, -0.27268317f, 0.08971381f, 0.04581840f, 0.24712095f, 
    -0.10209798f, -0.03834820f, 0.12987714f, -0.16020937f, -0.07298932f, -0.16363700f, 0.15110071f, -0.09318882f, 
    0.16078375f, -0.33071265f, -0.23260625f, -0.15372552f, -0.07734364f, -0.01792448f, -0.24841775f, -0.05253883f, 
    -0.04760305f, 0.06120041f, 0.22876243f, -0.03434570f, -0.01854063f, 0.09715484f, -0.16468260f, 0.11940444f, 
    0.11641881f, 0.11910237f, -0.12216341f, -0.22084716f, -0.34199733f, -0.03806266f, -0.08330160f, -0.08731475f, 
    0.10066621f, -0.13613719f, 0.12719320f, -0.18849514f, 0.01610821f, 0.02044050f, -0.09107006f, -0.26729998f, 
    -0.01995500f, 0.09017995f, -0.02529399f, 0.08522460f, -0.09494164f, -0.53998327f, 0.17399335f, 0.14181487f, 
    -0.03286297f, -0.10987211f, 0.09872525f, 0.06664443f, -0.11228643f, -0.04459261f, 0.48375028f, 0.15003482f, 
    0.16051014f, -0.02145598f, 0.17980750f, 0.05862667f, -0.02614087f, -0.08477731f, -0.08036495f, 0.11470982f, 
    0.05802983f, 0.11584112f, -0.27969915f, -0.03223787f, -0.07311606f, 0.06829852f, 0.20364566f, 0.23111582f, 
    0.49204060f, 0.41748133f, 0.47039929f, -0.15396607f, 0.20729949f, -0.12838759f, -0.04890148f, -0.10533253f, 
    -0.00681167f, -0.40406698f, -0.00568844f, -0.67280668f, 0.12582223f, 0.10496638f, -0.03486561f, 0.04510815f, 
    0.01523916f, 0.01151210f, 0.10793500f, 0.45294914f, 0.31233653f, -0.08936091f, -0.05240533f, 0.04991710f, 
    0.05154515f, 0.18530138f, 0.01792192f, 0.12101071f, -0.28069559f, -0.87965375f, -0.09815431f, 0.12841929f, 
    0.20247261f, 0.02225778f, 0.01371505f, 0.17597070f, -0.18314791f, 0.15580288f, -0.37589088f, 0.03601852f, 
    -0.09329887f, -0.12364692f, 0.01241294f, 0.10813251f, -0.17057766f, 0.18084572f, 0.13277173f, 0.14539628f, 
    -0.04900443f, 0.02786391f, 0.30388945f, 0.02552400f, 0.11893174f, 0.12957683f, -0.00421344f, -0.55531859f, 
    -0.05616549f, -0.20445660f, -0.05595305f, -0.06350066f, -0.03241875f, 0.09369811f, 0.13785772f, -0.48890316f, 
    -0.08886579f, -0.22741660f, -0.17814791f, 0.02398529f, -0.01167334f, 0.19783777f, 0.11582941f, -0.20460972f, 
    0.36160362f, -0.38979796f, 0.01932993f, 0.09377216f, -0.01361053f, -0.08985092f, 0.02771174f, 0.24333325f, 
    0.04362715f, 0.52002430f, 0.11883855f, -0.35818598f, -0.36653632f, -0.38088706f, 0.07024512f, 0.10983691f, 
    0.13103607f, 0.28097504f, -0.00968580f, 0.03219141f, 0.10193970f, 0.09580813f, -0.01703807f, -0.19595245f, 
    0.09240524f, 0.15537250f, -0.14575382f, 0.13708788f, -0.13880818f, 0.13089445f, 0.12411354f, 0.16310948f, 
    0.01681233f, -0.00449930f, 0.02081903f, 0.03561427f, -0.34868944f, 0.07769280f, 0.24466553f, 0.09117097f, 
    -0.00343634f, -0.13875909f, -0.03181880f, -0.02484396f, 0.07061038f, -0.27423483f, -0.47967532f, -0.01328802f, 
    -0.03802706f, -0.33548135f, 0.04149176f, -0.03631239f, -0.06808437f, -0.06083384f, 0.01540417f, 0.00107589f, 
    -0.22345479f, -0.22433841f, 0.05428001f, 0.04957537f, 0.11672420f, -0.03211886f, -0.13528623f, 0.01456277f, 
    0.09202679f, -0.32049423f, 0.00041412f, 0.27490643f, -0.12408396f, 0.08273227f, 0.04306782f, 0.10918758f, 
    -0.25229663f, -0.37650985f, 0.26545468f, 0.07456161f, 0.09787142f, -0.14263861f, 0.06249546f, 0.14535174f, 
    -0.13564011f, -0.53891373f, 0.65690577f, 0.01330125f, -0.04303210f, 0.25962883f, 0.02595807f, -0.12503999f, 
    0.15629876f, -0.05132350f, -0.24050361f, -0.64609891f, -0.24841379f, 0.12718387f, 0.10155262f, -0.12109923f, 
    -0.00293719f, -0.04358271f, 0.01256207f, 0.10426792f, -0.80580139f, -0.15782626f, -0.01268926f, 0.20739214f, 
    0.11312822f, 0.02642176f, 0.05643027f, -0.14618535f, -0.01167197f, 0.03048941f, -0.22254021f, -0.00471366f, 
    -0.21353151f, -0.19877516f, 0.12544212f, -0.03804354f, -0.10971542f, 0.02077544f, -0.11649568f, 0.32774848f, 
    0.13942350f, 0.24501222f, 0.06752831f, 0.08127400f, 0.01025719f, 0.18500520f, 0.11661666f, 0.19358395f, 
    -0.05176431f, -0.12345110f, -0.22044790f, 0.13407888f, 0.14593185f, -0.02228856f, 0.26632920f, 0.10905220f, 
    -0.06620281f, -0.07630258f, -0.05819359f, 0.00110081f, -0.23827948f, 0.23627353f, 0.14592406f, 0.09903712f, 
    -0.36050725f, -0.03940445f, -0.44873855f, -0.05102608f, 0.01456537f, 0.02563400f, -0.13377246f, -0.13262351f, 
    -0.12050102f, -0.11455297f, 0.05957961f, -0.20058107f, -0.25696453f, 0.04498324f, 0.01708108f, -0.17959006f, 
    0.15306722f, -0.01312928f, 0.01295129f, 0.00226084f, 0.00702425f, 0.02665196f, 0.02328807f, 0.04822258f, 
    0.10776104f, 0.08013046f, -0.08142004f, 0.09907099f, 0.00951468f, -0.06319132f, 0.06092038f, -0.09688754f, 
    -0.05463863f, 0.01459274f, 0.06400609f, 0.07290452f, -0.07850256f, 0.22670983f, -0.04181266f, 0.15289931f, 
    -0.21328643f, 0.08048644f, -0.04202240f, 0.08175805f, 0.08000609f, -0.31709915f, -0.54371470f, 0.16395694f, 
    -0.08403905f, 0.08638979f, 0.24551745f, -0.06160786f, -0.03204829f, 0.10450038f, 0.04581860f, 0.18649703f, 
    -0.22873577f, -0.00688029f, -0.19732900f, -0.20754071f, 0.14695135f, -0.05967972f, 0.05320984f, -0.08065287f, 
    0.25534713f, 0.02438097f, -0.18025547f, 0.19041003f, -0.18734856f, -0.10251994f, -0.06611908f, 0.13825475f, 
    0.02249971f, -0.01758973f, -0.00216099f, -0.05236444f, 0.01209936f, 0.01157991f, -0.05195098f, -0.07092674f, 
    0.02311582f, -0.04502870f, -0.05622740f, -0.03139916f, -0.09317859f, 0.06546259f, -0.07166690f, -0.03755141f, 
    -0.00987889f, -0.09007651f, 0.06220246f, -0.04976200f, -0.04393854f, 0.01916378f, 0.03169340f, 0.01281090f, 
    -0.05005898f, 0.05615834f, 0.07959130f, -0.05538490f, -0.02717791f, -0.01280036f, 0.00668386f, 0.05627992f, 
    -0.02339396f, 0.05200530f, -0.04369573f, -0.00110109f, 0.01131658f, 0.00937588f, -0.08495154f, -0.08780355f, 
    0.05477185f, -0.04158607f, 0.02526882f, -0.02376387f, 0.07363816f, 0.05761584f, -0.07395914f, -0.02060478f, 
    -0.05558231f, -0.06492104f, 0.00732104f, -0.05812480f, 0.01699458f, -0.00510802f, 0.04636552f, 0.00053693f, 
    0.01836781f, 0.02932286f, -0.00489514f, -0.05800496f, -0.02312697f, -0.04301996f, -0.05874832f, -0.03899760f, 
    -0.03542325f, 0.02043368f, -0.03549609f, -0.04211794f, 0.03356152f, 0.03533551f, -0.07520565f, -0.05560264f, 
    0.03387806f, -0.07636248f, 0.00224525f, -0.02913514f, 0.03147945f, -0.04942257f, 0.00221366f, 0.01461003f, 
    0.00131596f, -0.05269614f, 0.02080211f, 0.05718690f, 0.06961168f, 0.07864630f, 0.00132302f, 0.06427333f, 
    -0.07409626f, 0.04798941f, -0.00478563f, -0.07244147f, 0.04640084f, -0.07463211f, -0.06321628f, -0.02604663f, 
    -0.08378047f, -0.06704980f, 0.06574388f, 0.04915803f, -0.02126248f, 0.06675888f, -0.08255968f, 0.06482711f, 
    0.00077344f, -0.01004552f, 0.06121854f, -0.08616994f, -0.03000743f, -0.04050394f, 0.02257515f, -0.03632434f, 
    -0.01999330f, 0.04175995f, -0.07964819f, -0.03243942f, 0.03302267f, -0.00962025f, 0.04203204f, 0.01835665f, 
    -0.07372392f, 0.02890327f, 0.00257197f, 0.01705973f, -0.01955891f, -0.05546141f, 0.06845006f, 0.00331242f, 
    0.01872106f, -0.07560533f, 0.00867534f, -0.04978194f, 0.00820898f, -0.07098314f, 0.00707903f, -0.07395571f, 
    -0.08564453f, 0.05540246f, -0.05030821f, 0.02170521f, 0.05381966f, 0.00955114f, 0.03995031f, -0.04460824f, 
    -0.49028823f, -0.31033349f, -0.30140772f, 0.01185754f, 0.19528481f, -0.36154225f, -0.07607783f, 0.02705650f, 
    0.12825705f, -0.39320245f, -0.00933145f, 0.16696112f, -0.01495857f, -0.03473910f, 0.05173975f, 0.17491592f, 
    -0.07434785f, 0.14287981f, -0.47266486f, -0.39601991f, -0.34038085f, -0.10252772f, -0.00109724f, -0.13745333f, 
    0.04456870f, 0.07270288f, -0.09988535f, -0.05548755f, -0.43091646f, -0.59953356f, 0.10671490f, -0.03302005f, 
    0.31505811f, 0.24037746f, -0.00015125f, -0.09652782f, -0.35967478f, -0.11967167f, 0.21117987f, -0.03082538f, 
    0.19024269f, 0.00738432f, 0.21205042f, -0.11605179f, -0.12245952f, -0.20166220f, 0.16319408f, -0.14471839f, 
    0.08293252f, 0.08034766f, 0.19177064f, -0.08390585f, 0.03669004f, 0.07032435f, -0.16213837f, 0.03757672f, 
    -0.14431283f, -0.09311219f, -0.14548200f, 0.03787233f, -0.10126206f, 0.04881835f, 0.31597015f, 0.51721364f, 
    -0.01131580f, -0.15463744f, -0.08334507f, 0.02780920f, 0.27377662f, 0.00148644f, 0.22614466f, 0.09682191f, 
    0.24692461f, -0.23482990f, 0.30605042f, -0.06876235f, -0.03278138f, -0.02768119f, 0.03608961f, 0.16519701f, 
    0.07746188f, -0.08448229f, 0.25015938f, 0.07050403f, -0.02113019f, 0.18969198f, 0.09673651f, -0.14375418f, 
    -0.13057204f, -0.09923533f, -0.24746750f, 0.21190096f, -0.04038083f, -0.02831440f, 0.02679539f, 0.00062843f, 
    0.01994321f, 0.02035648f, 0.11843112f, 0.17370863f, 0.11071752f, -0.53325701f, -0.10463311f, 0.10761452f, 
    -0.09620781f, 0.03515103f, 0.02925228f, -0.02369859f, 0.09820598f, 0.22095989f, 0.08039708f, 0.10434076f, 
    0.07881664f, -0.10666126f, -0.01739296f, 0.18642411f, 0.07557027f, 0.34953836f, -0.69546127f, -0.07577708f, 
    0.00415087f, 0.25205198f, -0.06993787f, -0.01784203f, -0.10080877f, 0.04863766f, 0.29586068f, 0.02318290f, 
    -0.01258191f, -0.10656262f, -0.07819059f, -0.20048250f, 0.00679222f, 0.04348149f, -0.06523695f, 0.06773068f, 
    0.12106636f, 0.14769435f, 0.05979192f, -0.25086388f, 0.14832404f, 0.11789609f, 0.08891605f, 0.17591359f, 
    0.01035770f, 0.07628899f, 0.12750550f, 0.10755885f, -0.44361383f, 0.06423751f, 0.02239988f, -0.07828730f, 
    0.20203337f, 0.17273331f, -0.14533199f, 0.00133862f, -0.02513402f, 0.05152732f, 0.11813828f, 0.00779719f, 
    0.01974301f, 0.00538859f, -0.03576824f, -0.14493918f, -0.50947940f, -0.20758432f, -0.57709336f, -0.00195385f, 
    0.17871514f, 0.12455360f, 0.05035102f, -0.38763574f, -0.02314757f, -0.34432414f, -0.19726646f, -0.02867030f, 
    0.05466465f, -0.01296876f, 0.16340327f, -0.15848824f, 0.15412256f, -0.25436893f, -0.07823336f, -0.15340079f, 
    0.10740867f, 0.05033245f, 0.12041701f, 0.10768052f, 0.13197470f, 0.05521189f, -0.07364842f, 0.35313430f, 
    0.22166096f, 0.14735989f, 0.02137977f, -0.07743293f, 0.12847956f, 0.05364900f, -0.17773014f, -0.11817525f, 
    -0.22950231f, -0.04147995f, -0.21975419f, 0.30400646f, -0.11423395f, 0.09194110f, 0.25209439f, -0.19621041f, 
    0.03136611f, 0.06786770f, 0.27321896f, -0.09663650f, 0.07331894f, 0.10455772f, 0.00266190f, -0.09490435f, 
    -0.81377393f, 0.08752792f, -0.53373706f, 0.16356978f, -0.02970390f, 0.08655342f, 0.17595075f, 0.01816172f, 
    -0.14704776f, 0.14191870f, 0.19022615f, 0.00843993f, 0.01447998f, -0.23966070f, -0.11909133f, 0.20506957f, 
    0.28099185f, 0.13643299f, -0.24973662f, -0.24409337f, -0.00739616f, 0.29726014f, -0.04906850f, -0.00185182f, 
    0.07734977f, -0.03661725f, -0.19535194f, -0.10327382f, -0.49948457f, -0.45828098f, 0.16133216f, 0.02586414f, 
    0.14986439f, 0.16770148f, 0.01242277f, -0.19797547f, -0.14439493f, -0.25601789f, 0.04148250f, -0.03136839f, 
    0.09397446f, 0.08477713f, -0.06603025f, -0.06042496f, -0.07056519f, 0.06667910f, -0.15865655f, -0.01950523f, 
    -0.38829920f, 0.02234002f, -0.21269631f, 0.17519037f, 0.03038134f, -0.02180096f, 0.39630413f, -0.06506772f, 
    -0.22519976f, 0.21953520f, 0.20237984f, 0.18127455f, 0.14467596f, -0.11366995f, -0.02216074f, 0.02223309f, 
    -0.30563858f, -0.05514208f, 0.06858345f, 0.12630709f, -0.03601320f, 0.19085938f, -0.13752881f, 0.24745050f, 
    -0.16020638f, -0.09539868f, 0.01870139f, 0.09732144f, 0.05987115f, -0.11739780f, 0.06720024f, 0.00552452f, 
    -0.35739210f, 0.02760988f, 0.14264925f, 0.39657205f, 0.10893113f, 0.08467644f, 0.44933710f, 0.05111295f, 
    0.27212721f, 0.09339413f, 0.02227608f, 0.12785509f, 0.05921325f, 0.24121061f, 0.05032203f, -0.07495574f, 
    0.23207255f, 0.12366936f, 0.18386629f, 0.18009523f, 0.15068319f, 0.25546819f, 0.07202747f, 0.36452588f, 
    -0.13127723f, 0.08154950f, -0.03654927f, 0.19713001f, -0.02729678f, -0.11345521f, -0.07863590f, -0.09123976f, 
    0.12857810f, 0.20450106f, -0.12465647f, -0.24503942f, -0.34523579f, 0.20680118f, -0.08364529f, 0.24093418f, 
    -0.02428382f, 0.22801661f, 0.09719253f, 0.07090800f, 0.18735373f, 0.30030355f, -0.22396827f, 0.30288801f, 
    0.00762668f, -0.10631870f, -0.21041086f, -0.08519165f, 0.12554647f, 0.06089116f, -0.02702082f, 0.08613414f, 
    0.18065733f, 0.07165620f, 0.29618135f, -0.04160238f, 0.30421704f, 0.18076870f, 0.11356592f, 0.07644686f, 
    0.01892924f, -0.03192001f, 0.21042834f, -0.27860725f, -0.02180804f, 0.02180063f, 0.14014196f, 0.01677330f, 
    0.28964120f, -0.18381140f, -0.35757849f, -0.21480669f, 0.13575934f, 0.18001354f, 0.14794315f, 0.12356851f, 
    -0.06330136f, -0.30080464f, 0.16925153f, 0.18469797f, 0.10173518f, 0.21593712f, 0.09860647f, -0.02950922f, 
    0.22736377f, -0.10147281f, -0.11729051f, -0.09397908f, 0.34272444f, 0.05079541f, -0.30063424f, 0.18564813f, 
    0.03568990f, -0.06075817f, -0.03466757f, -0.11645260f, 0.24877430f, 0.35444400f, 0.23443341f, -0.25585759f, 
    0.03420066f, -0.07528783f, 0.05742236f, 0.27145463f, -0.11355252f, -0.18814771f, -0.03638071f, -0.08897758f, 
    -0.01473383f, -0.06540535f, 0.00431126f, 0.00397030f, 0.17615265f, 0.21285287f, 0.24203886f, 0.36553392f, 
    0.20304348f, 0.10116448f, -0.15269229f, 0.02173547f, -0.15884423f, 0.18549134f, -0.08112711f, 0.21730709f, 
    0.18084481f, 0.02479427f, -0.07456501f, 0.03590163f, 0.17300150f, 0.33936706f, 0.09920630f, -0.20662917f, 
    -0.06980643f, 0.23752257f, 0.27606785f, -0.00485191f, -0.10108511f, 0.04282862f, -0.00179666f, -0.05089934f, 
    0.13204917f, 0.42037281f, 0.04899425f, -0.09536273f, 0.07166823f, -0.03357683f, -0.07599764f, 0.00552608f, 
    0.04202360f, 0.12200063f, 0.00287276f, 0.44413763f, 0.03123440f, 0.17559011f, 0.28991175f, -0.10083154f, 
    0.13275084f, -0.06608226f, -0.11155964f, -0.04210588f, -0.29591131f, 0.03246380f, -0.24054022f, -0.02245222f, 
    0.30584279f, -0.10267280f, 0.19668381f, -0.04371168f, -0.31941375f, 0.15621419f, 0.08448461f, -0.14337018f, 
    0.07395304f, 0.00746321f, 0.09492802f, 0.19421948f, 0.18958157f, 0.07393904f, 0.00951314f, -0.15612622f, 
    0.15472727f, 0.16532351f, 0.07825328f, 0.17699912f, 0.12296278f, 0.01690861f, -0.70493978f, 0.12951361f, 
    0.03094637f, -0.05837140f, -0.04232682f, -0.35352671f, 0.09701767f, -0.05676055f, 0.28300589f, 0.08326410f, 
    -0.23000379f, 0.13106781f, -0.08262937f, 0.02208420f, 0.14271477f, -0.16987108f, 0.25542626f, 0.03800476f, 
    -0.04298799f, -0.14544792f, 0.05822102f, -0.11296474f, 0.01128907f, 0.08202599f, 0.13033517f, 0.07722549f, 
    0.14754920f, -0.48501721f, -0.39996552f, -0.36942455f, -0.07510725f, 0.12210895f, -0.21560045f, 0.09786360f, 
    -0.11559331f, 0.07700381f, 0.08022171f, -0.11150369f, 0.04184915f, -0.23482816f, 0.23459287f, 0.12707280f, 
    0.19355910f, 0.23759554f, 0.37011597f, -0.20097226f, -0.48236996f, -0.18214945f, 0.09179858f, 0.07997686f, 
    -0.01151384f, 0.05192202f, 0.05805637f, 0.14700459f, -0.68143237f, -0.67703998f, 0.10130154f, 0.04937007f, 
    0.11467270f, -0.22105882f, 0.05539354f, -0.12590249f, 0.11510964f, 0.42717981f, 0.04619717f, 0.26565799f, 
    0.01654936f, 0.09124937f, -0.11976412f, 0.04706442f, -0.11533453f, 0.01532921f, -0.40027222f, -0.00487172f, 
    -0.09085747f, -0.02503186f, -0.17147833f, -0.29453233f, -0.07172045f, -0.18818413f, 0.28062260f, -0.17548721f, 
    -0.10184218f, 0.29432139f, -0.06999777f, -0.01395889f, 0.03842908f, 0.04402520f, 0.10462035f, 0.10009101f, 
    0.13168178f, 0.17494828f, 0.54480493f, 0.07290417f, 0.19838299f, 0.10073604f, 0.25300220f, -0.10222398f, 
    -0.01750487f, 0.07674966f, 0.16530734f, -0.06661835f, 0.12868947f, 0.08998836f, 0.13688008f, 0.03544394f, 
    -0.08238345f, 0.09978977f, 0.19380014f, 0.52544123f, 0.30875161f, 0.21753401f, 0.06569201f, 0.12886137f, 
    0.10584649f, -0.29222354f, -0.19989923f, 0.04187433f, 0.17732199f, -0.23321100f, 0.10629458f, -0.13102740f, 
    0.28947425f, 0.06060012f, -0.00750510f, -0.01149562f, 0.03948350f, -0.02945653f, -0.10141837f, -0.02279962f, 
    0.17319746f, -0.17309161f, 0.34482411f, 0.31714895f, 0.22687957f, 0.12440694f, 0.01265318f, 0.01508717f, 
    0.12164342f, 0.04571810f, 0.10597254f, -0.17144603f, 0.08543534f, 0.12880591f, -0.20262124f, 0.01149190f, 
    -0.02093150f, -0.04607119f, -0.01729258f, 0.02158856f, -0.02089325f, -0.12937263f, -0.29182971f, 0.00988002f, 
    -0.32040796f, -0.29601860f, -0.04457823f, 0.02974906f, 0.20348875f, 0.12521797f, 0.11843782f, -0.03900062f, 
    -0.09142990f, -0.28507715f, -0.01295205f, 0.14243656f, -0.19729635f, -0.17315789f, 0.04467376f, -0.08170193f, 
    0.01597778f, -0.04293195f, -0.07817739f, 0.02439251f, 0.19501682f, 0.31152320f, 0.13196613f, 0.14867318f, 
    -0.24074282f, 0.09909327f, 0.09484544f, 0.05494543f, 0.07934099f, 0.06934075f, 0.08142132f, 0.01105644f, 
    0.34323204f, 0.09314457f, 0.04839667f, -0.13160968f, -0.68179905f, -0.13082230f, 0.19771370f, 0.02611171f, 
    -0.06264585f, -0.10657805f, -0.05143362f, 0.06870831f, -0.52271485f, -0.12124763f, 0.01138401f, 0.00992712f, 
    -0.26312530f, 0.11156090f, -0.13332501f, -0.02611850f, -0.40782434f, -0.24280128f, 0.08059184f, 0.33255887f, 
    0.03845099f, 0.04026738f, 0.00761481f, 0.10339037f, -0.36068594f, -0.04212654f, -0.46691039f, -0.16692805f, 
    -0.31128243f, 0.14447112f, 0.13527064f, 0.02159208f, 0.23428844f, 0.00656716f, -0.15759686f, -0.27531067f, 
    -0.05423727f, 0.06366678f, 0.04224291f, -0.02679034f, 0.17121564f, 0.09060795f, -0.04232220f, 0.17154770f, 
    -0.04132925f, -0.57480347f, -0.18526192f, -0.05630177f, -0.01134096f, -0.01176188f, 0.01235619f, 0.15405464f, 
    0.24463078f, 0.63223654f, -0.00462005f, -0.09032921f, -0.15758929f, 0.11378494f, -0.06271277f, 0.12222524f, 
    0.12249558f, 0.12529227f, 0.03508452f, -0.15449570f, -0.11572339f, -0.09769517f, -0.03301867f, -0.05052628f, 
    0.05522823f, 0.19612645f, -0.21243656f, -0.05089684f, 0.22291110f, -0.27517113f, -0.00146283f, -0.02315350f, 
    -0.00711932f, 0.04083017f, 0.15622267f, -0.04432786f, -0.00278927f, -0.44749272f, -0.09961648f, 0.00568698f, 
    0.02003785f, 0.04476931f, -0.04352992f, 0.20883349f, 0.08839042f, 0.22601864f, 0.22019270f, 0.09017579f, 
    -0.03297190f, 0.10313682f, 0.21273094f, 0.19451264f, -0.23868847f, 0.07825165f, -0.11806169f, -0.34535885f, 
    -0.21658053f, -0.02604332f, -0.14550921f, 0.12166601f, -0.12104934f, -0.32212070f, -0.13164605f, 0.49804786f, 
    -0.17024173f, -0.13957481f, -0.11111796f, 0.29936391f, -0.30824170f, 0.12279849f, 0.07667889f, 0.20185752f, 
    0.01596257f, -0.16572261f, 0.07107519f, 0.11700574f, -0.03633502f, -0.18919514f, 0.15406650f, -0.07863533f, 
    -0.01927742f, -0.33780438f, 0.03070522f, -0.04403555f, 0.00469699f, -0.36890426f, -0.07988980f, -0.06870484f, 
    0.01545035f, 0.01724145f, -0.09085630f, -0.22842637f, -0.14383219f, -0.04561248f, 0.09760042f, 0.25662282f, 
    -0.05245301f, 0.17031677f, 0.15011106f, -0.53866094f, 0.19612192f, -0.37248904f, -0.01451584f, -0.12968306f, 
    0.10516547f, 0.01538408f, 0.01569875f, 0.04666864f, -0.03379429f, 0.40494034f, 0.05343155f, 0.07562678f, 
    -0.26555642f, -0.14121629f, 0.03571749f, 0.25274807f, 0.13062008f, -0.10325252f, 0.48010644f, 0.09033811f, 
    0.00714194f, -0.22257973f, 0.06431092f, 0.04428886f, 0.00094540f, -0.28721046f, -0.51105332f, -0.22304381f, 
    0.26989868f, 0.00556657f, -0.27051827f, 0.01372934f, 0.01718188f, 0.20347631f, -0.09748644f, -0.19046040f, 
    0.38625354f, 0.10721807f, -0.00331131f, -0.02002094f, -0.30638593f, 0.10436120f, 0.14217994f, 0.09565088f, 
    -0.29148787f, 0.13689098f, -0.03255049f, 0.11865807f, -0.06745987f, 0.20905522f, 0.06846166f, 0.34786078f, 
    -0.13313687f, 0.00745319f, -0.00848351f, 0.28002715f, 0.09138141f, 0.16583833f, -0.12300929f, -0.15128544f, 
    -0.03139766f, 0.16065298f, -0.18510456f, 0.28986576f, -0.30584475f, 0.22960940f, 0.04864956f, 0.17488487f, 
    -0.21291156f, 0.23611434f, -0.46713674f, 0.39484608f, 0.86170292f, 0.28353605f, 0.15229146f, -0.19232027f, 
    -0.17251024f, 0.13335370f, 0.30307212f, -0.06611411f, -0.05110610f, 0.27602530f, -0.05609852f, -0.14051184f, 
    -0.14331426f, -0.11760855f, -0.05048653f, 0.19639786f, 0.16289560f, 0.19392250f, -0.01022504f, 0.17455527f, 
    -0.00219717f, -0.03764078f, -0.06251409f, -0.15453354f, -0.12156508f, -0.29947919f, 0.03891188f, -0.34442219f, 
    0.07893449f, -0.04801390f, 0.06379826f, 0.01816615f, -0.23071277f, -0.21627335f, -0.65288854f, 0.13199419f, 
    -0.09330551f, 0.25800690f, 0.22919635f, -0.09931718f, 0.12208481f, -0.06593069f, 0.05140730f, 0.12602489f, 
    -0.31904197f, -0.34779853f, 0.22674491f, 0.08335056f, -0.00771232f, -0.19940400f, -0.02069174f, -0.03190683f, 
    -0.02999765f, 0.19221218f, -0.17786200f, -0.06007883f, 0.11215824f, 0.11283775f, 0.03937674f, 0.03139663f, 
    0.11611804f, -0.07579253f, 0.16838144f, -0.09246456f, 0.06921285f, -0.02836427f, 0.26885515f, -0.01057355f, 
    0.26942959f, -0.05527782f, 0.23406070f, 0.00718814f, -0.08095706f, 0.13991313f, 0.07520908f, -0.12430230f, 
    0.13092624f, -0.08159126f, -0.24966525f, -0.00820174f, -0.25812164f, -0.05314437f, 0.25808722f, 0.09384061f, 
    0.02080441f, -0.04940514f, -0.05876236f, -0.09609513f, -0.15645687f, -0.11065193f, 0.03785764f, 0.00714020f, 
    0.24392730f, -0.05187050f, -0.09744237f, -0.14073782f, -0.05234752f, -0.25001597f, -0.20503354f, -0.20090206f, 
    0.15234789f, 0.06281754f, 0.10106434f, 0.05049017f, 0.02762184f, 0.17024018f, 0.36292282f, 0.03916641f, 
    -0.15664715f, 0.02717508f, 0.02505623f, 0.20083097f, 0.13455005f, 0.02756729f, -0.01323802f, -0.15025187f, 
    0.44507572f, 0.11843411f, 0.04128087f, -0.26698345f, -0.13623849f, -0.22000848f, 0.12810656f, 0.01171375f, 
    -0.00193592f, 0.47653335f, -0.29953697f, -0.07603155f, 0.10046022f, -0.06894455f, 0.09492061f, 0.07330395f, 
    0.05466862f, 0.02426324f, -0.01224561f, 0.23162901f, 0.13211645f, -0.00603860f, -0.27442992f, -0.10872699f, 
    -0.15372734f, -0.03630066f, -0.18579455f, -0.39195436f, -0.23935403f, -0.57608777f, 0.19021730f, -0.36321723f, 
    -0.13454148f, 0.07488497f, 0.15285131f, -0.08771875f, 0.13808315f, 0.01130419f, 0.06171339f, -0.00776451f, 
    0.07665749f, 0.10422178f, 0.11866285f, -0.15717475f, 0.14486568f, 0.33060572f, -0.00952294f, -0.24056672f, 
    0.00753108f, 0.18773776f, 0.20574613f, -0.04091348f, -0.04294283f, 0.01594372f, -0.26835173f, -0.06587626f, 
    0.39498213f, 0.00116639f, 0.14814132f, -0.10527121f, 0.01057904f, -0.12906507f, 0.02617278f, -0.15352057f, 
    -0.00929021f, -0.13136606f, -0.28222856f, -0.00732736f, 0.09550072f, -0.06041337f, 0.05077819f, 0.00579334f, 
    0.57777023f, 0.11623225f, -0.07118342f, 0.10450420f, 0.30140224f, 0.17157029f, -0.10061878f, 0.15155689f, 
    -0.09646864f, -0.12898134f, -0.49997720f, -0.51752889f, 0.07709782f, -0.30975834f, 0.23749809f, -0.17402872f, 
    0.18915249f, 0.03069713f, -0.49059269f, -0.13250479f, -0.12408333f, -0.03617839f, 0.07042287f, -0.32349643f, 
    0.18088241f, 0.11116450f, -0.07363933f, -0.16675596f, 0.14210181f, -0.26515996f, -0.03267119f, -0.11556687f, 
    -0.10135395f, 0.14284383f, 0.16635646f, -0.11006498f, 0.19929756f, -1.04637802f, -0.63980550f, -0.00233262f, 
    0.19329585f, 0.02517479f, -0.01997400f, 0.06796663f, -0.04231546f, 0.55438238f, 0.33733612f, 0.04370783f, 
    -0.20452675f, 0.06042266f, 0.17016190f, -0.10620634f, -0.09046074f, 0.00384247f, -0.50425464f, 0.23854306f, 
    -0.14872541f, -0.14851877f, -0.05311493f, 0.07578178f, -0.18014412f, 0.08629331f, 0.16776681f, 0.14393760f, 
    -0.24208492f, -0.39710781f, -0.01504528f, 0.00765146f, 0.05969365f, -0.19941245f, -0.02661284f, 0.05563629f, 
    0.19169109f, 0.30645004f, 0.03113165f, -0.14752796f, -0.05544491f, -0.10891947f, 0.02853259f, -0.04423421f, 
    0.16321003f, 0.34502092f, -0.15948032f, -0.40777132f, 0.16119070f, -0.08734705f, -0.05014237f, 0.15531960f, 
    0.04393179f, -0.12040751f, 0.19864866f, 0.25460470f, 0.14396092f, -0.06831366f, -0.10152877f, -0.00999384f, 
    -0.00283665f, -0.11095478f, 0.08307055f, 0.05041072f, -0.29255912f, -0.52290660f, -0.12677637f, 0.11241010f, 
    -0.02084468f, 0.03266820f, 0.04583239f, -0.18345433f, 0.27925232f, 0.05056593f, 0.03575819f, -0.04343620f, 
    0.04957720f, -0.06194952f, 0.16122048f, 0.27716210f, 0.00933414f, 0.20952278f, -0.24128707f, -0.30225965f, 
    0.04248291f, 0.00021128f, -0.14379360f, 0.05091212f, -0.09854601f, 0.13381304f, -0.20510352f, -0.12225154f, 
    0.48898339f, -0.14467865f, 0.06514342f, -0.04123358f, 0.03456840f, -0.16658497f, -0.03977058f, -0.26064697f, 
    -0.01867380f, 0.28951076f, -0.03435178f, 0.03789553f, -0.07009473f, 0.04213385f, 0.09674162f, -0.04312950f, 
    0.42274424f, -0.10483398f, -0.10708379f, -0.07207134f, 0.09275804f, -0.08710694f, -0.01118878f, -0.05322205f, 
    -0.14033279f, 0.61705089f, 0.42950812f, 0.34249017f, -0.34096158f, -0.29623839f, -0.70414490f, 0.02058500f, 
    -0.19657466f, -0.12841479f, -0.21364322f, -0.15851372f, 0.01367874f, 0.13720934f, 0.12434854f, 0.05170211f, 
    0.03673432f, -0.19453722f, -0.28702736f, 0.09837084f, 0.02006300f, 0.34267130f, 0.10563807f, 0.13153556f, 
    -0.05533073f, -0.01427427f, 0.01588284f, 0.00914778f, 0.00571300f, -0.11655811f, 0.10986034f, 0.11246346f, 
    0.08565676f, -0.06017518f, 0.07264180f, -0.09551744f, -0.10787092f, 0.20287816f, 0.01679702f, -0.47517094f, 
    -0.22355026f, -0.07606979f, -0.21642306f, 0.08001287f, 0.02217168f, -0.29030010f, -0.03357843f, 0.08461835f, 
    0.32489139f, 0.18554765f, 0.08822688f, -0.03715253f, 0.13371465f, -0.01553554f, -0.05559768f, 0.20196551f, 
    0.29247975f, 0.14798656f, 0.19139631f, -0.09960957f, -0.23800327f, -0.07056067f, 0.06530265f, 0.20502354f, 
    -0.20859456f, 0.30738980f, 0.17821124f, -0.12386983f, 0.11475845f, 0.10299864f, 0.12444413f, 0.06178816f, 
    0.38124838f, 0.13971074f, -0.17571977f, 0.21503763f, 0.07617509f, 0.12786451f, 0.19601266f, -0.12239472f, 
    -0.08139664f, -0.10228939f, 0.02375879f, 0.13037021f, -0.22770618f, -0.14359015f, -0.05934105f, 0.11395753f, 
    -0.08667779f, 0.22893210f, -0.06303649f, -0.13689014f, 0.48952594f, -0.19512659f, 0.07854293f, -0.13772707f, 
    0.28722230f, 0.07258610f, 0.11319212f, -0.04980109f, -0.10342165f, 0.05904390f, 0.01451607f, 0.01941503f, 
    0.22122169f, 0.03535845f, 0.11995393f, 0.21536779f, 0.02446688f, -0.20922433f, -0.34377190f, -0.20789860f, 
    0.20907883f, -0.09375130f, 0.10211401f, -0.02559780f, -0.21175478f, -0.10329331f, -0.33142549f, 0.20055145f, 
    0.09588795f, 0.01681424f, -0.25754935f, 0.03561921f, -0.20248637f, -0.17365858f, -0.31584153f, 0.24841136f, 
    -0.03250415f, 0.21660447f, -0.19565678f, -0.01714013f, 0.18505815f, -0.20654421f, -0.01628086f, 0.09039542f, 
    -0.45955530f, -0.03732403f, 0.25472456f, 0.03591914f, 0.02867130f, -0.09553278f, 0.14546654f, -0.14000021f, 
    0.22893842f, -0.27089208f, 0.01833034f, 0.08365551f, 0.00024396f, -0.11685687f, -0.01846116f, -0.23743525f, 
    -0.03012401f, 0.02992177f, 0.20110740f, 0.16715539f, 0.13563527f, 0.02229053f, 0.19393963f, 0.09500726f, 
    0.09815288f, 0.05031577f, -0.09370117f, -0.18522398f, 0.11896472f, -0.03963669f, 0.10392569f, 0.11563365f, 
    -0.19759566f, 0.00786291f, 0.00517284f, 0.00620863f, -0.39067367f, -0.01815672f, 0.29489297f, 0.01883468f, 
    -0.20348246f, -0.20272443f, -0.02393014f, -0.03165546f, -0.08147834f, -0.12730044f, 0.08990271f, -0.31077653f, 
    -0.04553449f, -0.11154968f, -0.18540272f, -0.03950487f, 0.05060929f, -0.18157385f, 0.01352375f, 0.06031000f, 
    0.18206319f, -0.03605535f, 0.09717996f, 0.20900133f, 0.22960353f, -0.03955648f, 0.18500784f, -0.06891048f, 
    0.07476771f, 0.52489430f, -0.15955366f, 0.28176957f, -0.00471231f, 0.02263818f, 0.02947683f, 0.03247649f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.21871540f, 0.12083461f, 0.29681215f, 0.24661168f, 0.25418541f, 0.01606482f, 0.10552440f, 0.19210306f, 
    0.20279226f, 0.08633333f, 0.13464370f, 0.31269750f, 0.04339203f, -0.13646203f, 0.02616014f, 0.11692443f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.30642921f, 0.38638532f, 0.05659672f, 0.13843064f, -0.56521499f, 0.12038353f, -0.70110416f, -0.26116446f, 
    0.02368952f, 0.30615178f, 0.48412126f, 0.50796402f, 0.42369956f, 0.33936059f, 0.23771754f, 0.22238208f, 
    0.84126657f, 0.06852131f, 0.00917486f, 0.05054717f, -0.25937447f, 0.19534643f, 0.42796496f, -0.03347445f, 
    0.04850992f, 0.38418880f, 0.32102028f, -0.43001494f, -0.36691898f, 0.06739013f, -0.35415846f, 0.28452918f, 
    0.06098738f, 0.10355082f, -0.22437841f, 0.03197533f, -0.06623408f, 0.19396842f, 0.10116678f, -0.17343390f, 
    -0.13627112f, -0.10347325f, -0.24843791f, 0.03164732f, 0.15738875f, 0.10576889f, -0.04258803f, -0.18387395f, 
    0.27431035f, -0.47060841f, 0.54906708f, 0.52086341f, 0.53943932f, 0.14500494f, 0.05299580f, 0.16282634f, 
    0.11061215f, -0.16564541f, 0.26186755f, -0.04347728f, 0.13727844f, -0.64713877f, -0.15344147f, 0.03710476f, 
    -0.18976930f, 0.19334602f, 0.14380592f, 0.37707272f, -0.20554829f, -0.13718109f, 0.04091819f, -0.32422414f, 
    -0.05245644f, 0.17659968f, 0.34376627f, 0.09431317f, -0.21668831f, 0.81402302f, 0.43270883f, -0.38763237f, 
    -0.30434188f, -0.04743640f, 0.54923469f, -0.23876518f, 0.23047122f, -0.02933335f, 0.14041592f, 0.00174785f, 
    0.07779856f, 0.14000434f, 0.18152368f, 0.52622956f, 0.36303535f, -0.27144340f, -1.13091290f, -0.11180948f, 
    -0.04872016f, 0.45351472f, -0.02136923f, 0.06853922f, 0.73266500f, -0.07245895f, 0.13469769f, -0.00227667f, 
    0.43400317f, -0.26648974f, 0.02476917f, 0.17823143f, -0.41969383f, 0.03081511f, -0.40875560f, -0.46357891f, 
    -0.29359543f, 0.09959251f, -0.05222985f, -0.24220404f, -0.09849084f, -0.19484493f, 0.08059789f, -0.08729365f, 
    -0.05356736f, 0.02327547f, 0.11956765f, -0.07575329f, -0.27120826f, -0.12879731f, 0.12979083f, -0.22151920f, 
    -0.20863220f, -0.21830809f, -0.20789853f, -0.14696145f, -0.19179836f, 0.02094829f, -0.13741326f, 0.00685638f, 
    -0.02542904f, -0.17538604f, 0.10191295f, -0.14112297f, 0.08000061f, 0.06779790f, -0.02115715f, -0.20133618f, 
    0.38442063f, 0.43238276f, 0.10932840f, -0.20836146f, 0.58221406f, -0.03297459f, 0.43457377f, -0.63748288f, 
    0.09425089f, -0.18901810f, 0.17122315f, -0.11575038f, 0.01288105f, -0.53974450f, -0.19702864f, 0.10071958f, 
    -0.20476946f, -0.04154900f, -0.18811487f, 0.18751103f, 0.06117375f, 0.06738636f, -0.12189327f, -0.06400075f, 
    0.10790905f, -0.33990201f, -0.12144121f, -0.14129698f, 0.08311372f, 0.11728062f, -0.20640852f, -0.20936690f, 
    0.04464203f, 0.13435659f, 0.26545995f, -0.34049892f, -0.72886938f, -0.14855091f, -0.24155082f, -0.22043431f, 
    0.09124608f, 0.64598918f, 0.29208750f, 0.27711630f, 0.56128001f, -0.18440399f, -0.40149397f, 0.19482104f, 
    0.61336339f, 0.03641738f, 0.16276236f, 0.33498698f, 0.22453773f, 0.19448484f, 0.07658917f, -0.53198165f, 
    -0.21732591f, 0.21256150f, 0.48723710f, -0.38110864f, 0.31273523f, -0.48804700f, -0.20342898f, 0.52138245f, 
    -0.05535780f, 0.01810796f, 0.02550362f, -0.55420578f, -0.14313716f, 0.17516150f, -0.07272960f, 0.29732940f, 
    -0.15662850f, 0.48624447f, 0.24858420f, 0.32882109f, 0.65628999f, -0.24156496f, -0.35630083f, 0.25999424f, 
    0.41505650f, -0.23034602f, 0.24651147f, -0.50519335f, -0.10323332f, -0.15093143f, 0.37136993f, -0.45070156f, 
    -0.06945916f, 0.45916086f, -0.07160507f, 0.36397791f, 0.18697204f, 0.13848180f, 0.31448588f, 0.48900032f, 
    -0.21958500f, 0.31965849f, -0.22855124f, 0.09382667f, -0.30737588f, -0.22721718f, -0.35182169f, 0.20727766f, 
    -0.00704062f, 0.58996177f, 0.28384766f, 0.37226713f, 0.21025300f, 0.66379035f, -0.05454687f, -0.29255944f, 
    -0.01472345f, -0.09965703f, -0.18408984f, -0.24395010f, 0.11088413f, 0.05015442f, -0.04401376f, 0.03411537f, 
    -0.26321790f, -0.24088183f, -0.19213820f, -0.05633670f, -0.16418579f, 0.07716846f, 0.18027624f, -0.17198488f, 
    0.49335063f, -0.46105790f, -0.11586225f, 0.14134878f, -0.31922275f, -0.09639260f, 0.20297074f, -0.02843084f, 
    -0.23897287f, -0.04630138f, -0.30941799f, 0.43928730f, 0.36886460f, -0.32147211f, -0.01733646f, -0.02201355f, 
    -0.29253349f, -0.35101628f, -0.14544690f, -0.29396817f, 0.20794086f, -0.13924795f, -0.10818683f, 0.27418810f, 
    -0.10760204f, -0.19478369f, -0.11436814f, -0.25441664f, 0.20436302f, -0.11627379f, 0.06763394f, 0.01736035f, 
    0.12394662f, -0.27169722f, 0.20407295f, 0.06153974f, -0.16417848f, -0.06349826f, -0.11639453f, 0.18922837f, 
    -0.27370530f, -0.16497301f, 0.03688687f, -0.21335079f, -0.09694149f, -0.15511084f, 0.10682469f, -0.22054517f, 
    -0.13475755f, 0.44143537f, 0.57524770f, 0.34083676f, -0.23464343f, 0.07282740f, -0.10551602f, 0.35576987f, 
    0.46783054f, -0.26406327f, -0.43681622f, -0.27239376f, -0.25383177f, -0.46877629f, -0.48935312f, -0.26217327f, 
    -0.31322512f, -0.46441731f, 0.08556567f, -0.15280050f, 0.08407716f, -0.13339064f, -0.02290748f, 0.44042599f, 
    -0.32323393f, -0.34494099f, -0.09734730f, 0.09752892f, 0.17159127f, -0.38369587f, 0.14167652f, 0.14472163f, 
    -0.40997121f, 0.63492143f, 0.00243111f, 0.14399497f, 0.34642455f, -0.02356991f, -0.27460936f, -0.63097119f, 
    0.31866479f, -0.05897869f, 0.13448901f, -0.03411066f, -0.31275865f, -0.68024540f, -0.78866470f, -0.53220665f, 
    -0.07890777f, -0.31104213f, 0.28518781f, 0.66570127f, 0.94777799f, -0.05037019f, 0.14336930f, -0.01713953f, 
    -0.10285984f, 0.05030048f, 0.54363859f, -0.04129295f, -0.32356280f, -0.54608864f, 0.42885321f, -0.09741512f, 
    -0.41066384f, -0.18710285f, 0.36170396f, -0.39062977f, 0.71186858f, -0.03008966f, 0.43812630f, -0.36757711f, 
    0.06998140f, 0.26038507f, 0.12495817f, 0.68838757f, 0.26705161f, -0.20754163f, -0.48762381f, -0.39024359f, 
    -0.07014844f, -0.04450292f, -0.15288828f, -0.06322646f, -0.19263679f, -0.07904407f, -0.19248408f, -0.08853221f, 
    0.04666161f, 0.19279662f, -0.26310477f, 0.02400021f, -0.13907978f, -0.23007677f, -0.14650941f, -0.07367904f, 
    -0.27031565f, 0.03682194f, -0.18065149f, -0.13051663f, -0.26446640f, -0.08284252f, 0.15703607f, -0.02354483f, 
    -0.00956479f, -0.10022648f, -0.22770277f, 0.06794494f, -0.16145346f, -0.24878849f, -0.06693976f, -0.18167645f, 
    0.08784988f, 0.12934645f, -0.39930090f, 0.56490010f, -0.61835933f, 0.03063385f, -0.01594328f, 0.44531861f, 
    0.22940905f, 0.07595571f, -0.03703494f, -0.57969773f, 0.32200068f, -0.26936489f, -0.02607636f, 0.40331119f, 
    -0.08919805f, 0.03752802f, -0.00584033f, -0.27804646f, -0.20402390f, 0.19591863f, -0.17058170f, -0.10323390f, 
    -0.01778384f, 0.04156817f, -0.29847205f, -0.12183043f, -0.03720731f, 0.09888767f, -0.17566393f, 0.01094602f, 
    -0.30998537f, -0.41678062f, 0.03139692f, 0.33408302f, -0.30207068f, 0.09620246f, -0.17528026f, 0.12163141f, 
    0.02770349f, -0.32298937f, 0.07762264f, -0.41920209f, -0.00290618f, 0.05315130f, 0.15400772f, -0.10401917f, 
    0.17249574f, 0.10756474f, 0.51988465f, 0.03315432f, 0.05945337f, -0.03438752f, 0.63300431f, -0.14507607f, 
    0.42187679f, -0.45136899f, -0.25013295f, 0.11975049f, 0.22991170f, -0.56720722f, -0.53889096f, 0.13299483f, 
    0.13952166f, 0.05334892f, 0.23157479f, 0.92497665f, -0.16123642f, 0.14018658f, -0.59871095f, 0.45949370f, 
    0.16550373f, 0.51134121f, 0.38263905f, -0.24143273f, -0.33732748f, 0.25119704f, 0.37772954f, -0.38304761f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.22436933f, -0.09675099f, -0.20753822f, 0.07259827f, 0.29408541f, 0.25963452f, 0.44656724f, -0.16413368f, 
    -0.03905296f, -0.20767057f, -0.15645741f, 0.28731969f, -0.35952103f, 0.13481721f, -0.04045184f, 0.07379726f, 
    -0.07910853f, 0.38790724f, -0.15670723f, 0.00158730f, 0.15072861f, -0.09582883f, -0.04685493f, 0.05570639f, 
    0.42427704f, -0.26729545f, 0.00283390f, -0.27449915f, 0.15160361f, 0.09777319f, 0.27058131f, 0.12768210f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.02700451f, 0.09467213f, -0.03821097f, -0.08669552f, -0.16560681f, -0.05605380f, -0.16168822f, 0.15509869f, 
    -0.11231802f, -0.07296854f, -0.09589067f, 0.11930736f, -0.18207379f, 0.13383284f, 0.00084811f, -0.16332307f, 
    -0.17423545f, -0.02377503f, -0.12976038f, 0.16115159f, -0.02603655f, 0.12215021f, 0.13932750f, -0.06980005f, 
    -0.12693068f, -0.07086900f, -0.11374670f, -0.13434726f, -0.12433019f, 0.14025931f, 0.04562963f, -0.15397394f, 
    0.22819848f, -0.46161386f, -0.17654383f, 0.35812491f, 0.25969210f, 0.17271020f, 0.08569692f, 0.05853919f, 
    0.12939067f, -0.23081625f, -0.08438610f, 0.00726951f, -0.77738553f, -0.21340394f, -0.08555912f, 0.16630040f, 
    0.02176316f, -0.28074613f, 0.21350566f, -0.12052552f, 0.50515985f, 0.08184055f, -0.04533963f, 0.16731274f, 
    0.33991691f, -0.03439777f, -0.14608116f, -0.03398732f, -0.03527106f, 0.02907780f, 0.19734743f, 0.16100502f, 
    0.00251187f, -0.06345332f, -0.15293907f, -0.04315891f, 0.02392721f, 0.03964624f, 0.21904716f, 0.16846769f, 
    0.15755099f, -0.04842401f, 0.12287986f, -0.33214536f, -0.05429219f, -0.48465234f, 0.31889692f, -0.65351468f, 
    -0.15833832f, 0.18837635f, -0.05355069f, -0.11746017f, -0.30982512f, -0.31121168f, -0.04145857f, 0.38024446f, 
    0.34586212f, -0.16292256f, -0.06246599f, 0.31735620f, 0.15219988f, -0.02339487f, -0.06813727f, 0.12515473f, 
    0.45083585f, -0.13666457f, 0.03600898f, -0.06507903f, -0.18892422f, -0.00619292f, -0.08073129f, 0.06760897f, 
    -0.12586313f, 0.12514009f, -0.06701747f, 0.22368036f, -0.17171022f, 0.25788936f, 0.19293532f, 0.32701173f, 
    -0.07691503f, 0.36440170f, 0.09554525f, -0.19249627f, -0.34446782f, -0.09772847f, -0.07548280f, 0.01868135f, 
    0.15184702f, 0.20488895f, 0.09779694f, 0.04763365f, 0.02457105f, 0.06969880f, -0.16099860f, -0.18506701f, 
    -0.18752779f, 0.14437301f, -0.14911452f, -0.16899183f, 0.09801674f, -0.12381045f, 0.48305205f, 0.02026604f, 
    -0.10640193f, 0.47220251f, -0.16451113f, -0.06028001f, -0.20941532f, -0.73988825f, -0.19909222f, -0.25760773f, 
    0.14863382f, -0.76514322f, -0.07894579f, -0.02061628f, 0.31375405f, 0.14272171f, 0.45822272f, 0.38643187f, 
    0.48893988f, 0.14073116f, 0.09862396f, -0.36198369f, -0.13843387f, 0.24006782f, -0.17212500f, 0.20738246f, 
    -0.04368474f, 0.03748598f, -0.07396780f, 0.01093005f, -0.11745755f, 0.13024880f, -0.13539979f, 0.02868670f, 
    0.07609268f, -0.08135136f, -0.00135150f, -0.09860232f, -0.11030833f, -0.16386785f, -0.04511316f, -0.13674077f, 
    0.01844432f, -0.11145974f, -0.07506219f, 0.06514343f, -0.17222784f, -0.15959182f, 0.07891795f, -0.09695119f, 
    -0.13632646f, -0.15567349f, -0.16704921f, -0.06909036f, -0.01948409f, -0.14915000f, -0.07801013f, 0.08130464f, 
    -0.07303987f, 0.31000546f, -0.04581487f, 0.17592327f, 0.14328243f, -0.15743549f, -0.07903431f, -0.04107589f, 
    -0.02586023f, 0.29379627f, 0.15297072f, -0.14039494f, 0.22146778f, 0.12583296f, 0.18896279f, 0.03718979f, 
    -0.14279245f, 0.48477766f, 0.03716168f, -0.02105494f, -0.87600344f, 0.32443845f, -0.90287679f, 0.68891966f, 
    0.11887327f, 0.00312639f, -0.03766455f, -0.27550295f, -0.01997826f, 0.11286493f, -0.06263129f, 0.20811276f, 
    0.25153109f, 0.41165912f, 0.16608697f, -0.35496688f, -0.02314616f, 0.14769030f, -0.24986143f, -0.00430688f, 
    -0.15311126f, -0.47575614f, 0.19796188f, 0.24862245f, 0.22890273f, 0.16755883f, -0.25807711f, 0.31341887f, 
    -0.10157896f, 0.07722515f, -0.00877061f, 0.12901299f, 0.28438738f, 0.31237730f, -0.03684312f, -0.53690195f, 
    -0.17912890f, -0.01208991f, 0.15826815f, 0.25118458f, 0.07373093f, 0.03589842f, -0.27243775f, 0.34568182f, 
    0.04851791f, -0.11172274f, -0.15609261f, -0.45921794f, 0.02055732f, 0.30001295f, 0.10519335f, -0.19223686f, 
    0.09977917f, 0.14738132f, 0.02081384f, 0.23178563f, -0.66782695f, 0.34252277f, 0.09409965f, 0.23494494f, 
    0.14350557f, -0.63564068f, 0.29174590f, 0.04045219f, 0.30807588f, 0.11685718f, 0.40499490f, -0.98815930f, 
    0.44810215f, -0.08460312f, 0.14778991f, -0.16175978f, -0.06731069f, 0.04567564f, 0.38797921f, -0.46343490f, 
    -0.02202204f, -0.30329525f, 0.17578274f, -0.25715852f, -0.08363701f, 0.13189927f, 0.44895375f, 0.07266945f, 
    0.15713686f, 0.20066531f, -0.04924292f, -0.14779077f, -1.04018605f, -0.17036980f, -0.47285110f, 0.10203548f, 
    0.17273696f, -0.24279389f, 0.20657353f, 0.04796292f, 0.70121014f, 0.19198801f, 0.79284418f, -0.33943611f, 
    0.39393508f, 0.03942411f, 0.10371801f, -0.04068882f, 0.09918600f, -0.19253728f, 0.42506751f, -0.12234236f, 
    0.47246900f, -0.46871167f, 0.02277038f, 0.15827549f, 0.19704312f, 0.13338791f, -0.20884998f, -0.12613088f, 
    0.15955901f, -0.32341805f, -0.02429060f, 0.08593685f, 0.45506540f, 0.04279947f, -0.28766757f, 0.25963488f, 
    0.12145677f, 0.09130081f, -0.08359228f, -0.09082747f, 0.02569842f, -0.46558455f, 0.73468816f, 0.28704742f, 
    -0.08822402f, -0.06286825f, 0.03906598f, -0.14018576f, -0.11731806f, 0.22350030f, -0.05825474f, 0.30659053f, 
    -0.30629468f, 0.26782957f, 0.00557955f, -0.06682807f, 0.03466865f, 0.30834258f, 0.48260912f, 0.09848913f, 
    -0.08546049f, 0.10365038f, -0.09819142f, -0.07140733f, -0.42769924f, -0.37635320f, -0.47203502f, 0.05381229f, 
    -0.06171980f, -0.56202674f, 0.13209194f, 0.07397467f, 0.85922539f, 0.42887682f, 0.68894798f, -0.44387591f, 
    -0.20914751f, -0.01157592f, -0.13093717f, 0.09475838f, 0.14429621f, 0.25989521f, 0.37603274f, -0.09228568f, 
    0.28235871f, -0.14630969f, 0.04577262f, -0.51373929f, 0.52844357f, -0.26152405f, -0.07355211f, 0.16559939f, 
    -0.11108082f, -0.27685431f, -0.14405015f, 0.04702750f, -0.23709479f, -0.23942159f, 0.11661430f, 0.18924372f, 
    0.08272488f, 0.07351357f, 0.17545979f, 0.03854993f, -0.17492309f, 0.04331206f, -0.22173072f, -0.00533595f, 
    -0.58020699f, 0.09971575f, 0.05855176f, -0.13373578f, 0.12595774f, 0.04388560f, -0.60287863f, 0.08274093f, 
    0.00513724f, 0.14506085f, -0.01588245f, -0.01219023f, 0.34902969f, 0.01588769f, -0.03693482f, -0.03532372f, 
    -0.15319832f, -0.48894548f, -0.02994999f, 0.09926114f, -0.33947879f, 0.08852139f, -0.45021582f, 0.30668455f, 
    -0.12734830f, -0.05759339f, -0.02079884f, 0.09065396f, 0.26067799f, 0.24281335f, -0.22366197f, -0.25141665f, 
    -0.21135308f, -0.06276818f, 0.16278692f, 0.21182340f, -0.11837670f, 0.19000882f, -0.25545296f, 0.43192747f, 
    -0.00863392f, -0.08532646f, 0.14257844f, -0.26977021f, -0.01793132f, 0.49668014f, 0.24300317f, 0.06778762f, 
    -0.13247769f, -0.12561266f, -0.12274919f, 0.24498783f, -0.46579245f, 0.40285161f, 0.32810912f, 0.01498167f, 
    0.17182918f, 0.30252585f, 0.07203288f, -0.09626589f, -0.26511866f, 0.20849372f, -0.49419370f, -0.14275606f, 
    1.00930476f, 0.19128005f, 0.17238440f, -0.54024363f, -0.00199487f, -0.12737964f, 0.11423296f, -0.14630216f, 
    0.17367050f, -0.16446517f, -0.15566197f, -0.12964250f, 0.58362794f, -0.08769941f, 0.06272653f, -0.10543729f, 
    0.12825914f, -0.63192737f, 0.10367199f, 0.12755366f, -0.22389379f, 0.00926507f, -0.23093829f, 0.31105027f, 
    0.11379211f, -0.17059681f, 0.06844565f, 0.03792405f, -0.34118420f, -0.21658066f, -0.36166534f, -0.03168375f, 
    0.25590220f, -0.10500823f, 0.05212701f, -0.13689061f, -0.00220160f, 0.52759606f, -0.12608132f, 0.22009087f, 
    -0.23760846f, 1.29136074f, 0.05278465f, 0.38605672f, -0.15894954f, -0.10509294f, 0.10574692f, 0.13150382f, 
    -0.14180377f, 0.36840987f, 0.11044408f, 0.02082859f, 0.73587811f, -0.52553111f, 0.20365608f, -0.43060687f, 
    -0.00897876f, -0.30279335f, 0.00262847f, -0.11303298f, 0.27987707f, -0.28663912f, -0.21275413f, -0.03706338f, 
    -0.11704920f, 0.11486811f, -0.10398737f, -0.11400531f, 0.05722477f, -0.07506697f, 0.31682286f, -0.23394652f, 
    -0.13493763f, -0.09401297f, 0.15303360f, -0.12944649f, 0.12380030f, -0.01083205f, -0.00511626f, 0.17153870f, 
    -0.16718076f, -0.08360267f, -0.06732246f, 0.04010033f, -0.26424080f, 0.08640395f, -0.07579865f, -0.20614423f, 
    -0.04807215f, 0.05821857f, 0.11781529f, -0.12187260f, 0.17407784f, -0.07218722f, -0.16577624f, 0.11860510f, 
    -0.04210994f, 0.06886742f, 0.04490270f, -0.05506434f, -0.06511996f, -0.09145100f, 0.01763578f, -0.10937899f, 
    -0.14862445f, 0.39949715f, 0.13367434f, 0.37902576f, 0.01299577f, 0.50021774f, 0.02572434f, -0.00365711f, 
    0.12693356f, 0.29315981f, -0.09565791f, 0.17147328f, 0.69081885f, 0.21195047f, -0.06525844f, -0.14001493f, 
    0.06600136f, -0.11681414f, -0.18925448f, 0.12054117f, 0.15679990f, -0.19047345f, 0.42550558f, 0.18870036f, 
    0.32478818f, -0.02769877f, -0.03596162f, 0.04792035f, -0.09553114f, -0.01772075f, 0.35904860f, -0.23499951f, 
    -0.00078333f, -0.02981835f, 0.13810904f, 0.10066919f, -0.04391384f, -0.16755171f, -0.01755146f, 0.15290353f, 
    -0.06523721f, -0.12768140f, -0.00378451f, -0.18637735f, 0.02285407f, -0.17752273f, -0.19750626f, 0.05943806f, 
    -0.01813254f, -0.12992054f, 0.12606980f, -0.06327780f, -0.11646408f, -0.10280175f, -0.14443518f, 0.02637857f, 
    0.10364149f, 0.01380309f, -0.05900433f, -0.03570037f, 0.13991818f, -0.09228215f, -0.13880517f, -0.04377595f, 
    0.25545901f, 0.19857559f, 0.11154707f, 0.07123319f, -0.15454608f, 0.45222658f, 0.04327178f, -0.07723958f, 
    0.15491359f, 0.40917286f, -0.04316437f, 0.34999725f, 0.62556154f, 0.14261481f, 0.11167172f, 0.04264933f, 
    -0.00662076f, 0.23588167f, -0.26392648f, -0.00307043f, -0.30268368f, -0.32434186f, -0.41600227f, 0.12022121f, 
    0.65684032f, 0.06393319f, -0.18022732f, -0.60298139f, -0.05711991f, -0.23760150f, 0.07527061f, -0.21305794f, 
    -0.04370453f, -0.13282776f, -0.17542928f, -0.17317674f, 0.18093774f, 0.00488984f, 0.23415159f, 0.09643313f, 
    0.07370299f, 0.21426721f, 0.03286775f, -0.07231420f, 0.09950988f, -0.05108669f, -0.04311816f, -0.09424025f, 
    0.10263651f, -0.22765185f, -0.09825712f, 0.02322757f, 0.10217181f, 0.03409484f, 0.35280034f, 0.07061139f, 
    0.03719848f, -0.10519320f, 0.01647619f, -0.29591992f, 0.11688215f, -0.10840419f, -0.04432175f, -0.13536157f, 
    -0.02103848f, 0.83760434f, -0.06890881f, -0.19540256f, 0.20954978f, 0.09014989f, -0.00330402f, -0.00837910f, 
    0.06768520f, -0.17189221f, -0.05694339f, 0.18415724f, -0.07851352f, 0.23341766f, 0.03446127f, 0.08280984f, 
    0.10525255f, 0.05703050f, -0.00880505f, -0.14016132f, 0.00118857f, -0.06364825f, -0.35682598f, -0.07254096f, 
    -0.16680643f, -0.09370805f, 0.20693366f, 0.24506021f, 0.10893779f, -0.09350378f, -0.18223503f, 0.05782131f, 
    0.39980841f, -0.04750568f, 0.16721703f, -0.00258363f, -0.40868443f, 0.35639703f, 0.04038363f, -0.26769033f, 
    -0.12368477f, 0.47455886f, 0.05726823f, 0.36964887f, 0.61420512f, 0.87082291f, 0.04165449f, 0.15906323f, 
    -0.14233366f, -0.37542057f, 0.22047377f, 0.09589750f, -0.59397066f, 0.02847572f, -0.07538757f, -0.36319947f, 
    0.21990719f, -0.01846990f, -0.21623908f, 0.27435866f, 0.09425323f, 0.31604922f, 0.14640154f, -0.45091984f, 
    0.52651423f, 0.11531753f, -0.16660491f, -0.21040174f, 0.57853454f, -0.11811788f, 0.06616795f, 0.07044866f, 
    0.14606182f, 0.09042664f, -0.05350129f, 0.26143470f, 0.69782126f, 0.04547961f, -0.15436375f, 0.19745411f, 
    -0.10046919f, -0.11101899f, -0.12921545f, 0.16099550f, -0.01124914f, -0.50181013f, 0.83430868f, -0.20533484f, 
    -0.11308847f, 0.08130868f, 0.08389580f, 0.30886897f, 0.13517469f, -0.39418697f, -0.06896520f, 0.36194199f, 
    0.40299985f, 0.29545212f, 0.10493650f, -0.20604251f, 0.41196346f, 0.18633571f, 0.16141981f, -0.10255200f, 
    0.04792798f, -0.21147913f, 0.07289734f, 0.09435353f, 0.33712915f, 0.16435808f, -0.08407111f, 0.30588984f, 
    0.03089611f, 0.01769836f, 0.29715532f, 0.20969522f, 0.13633218f, 0.27861598f, -0.16266423f, -0.13832819f, 
    -0.15047066f, -0.17324181f, 0.04061231f, 0.04928248f, -0.00911523f, 0.21420863f, -0.23049429f, 0.44776690f, 
    0.21278605f, 0.24680424f, 0.06960520f, -0.30149186f, 0.16470520f, -0.16005021f, 0.25168601f, 0.02688457f, 
    0.11213308f, -0.20274951f, 0.18187135f, 0.25263527f, -0.27992418f, 0.18718897f, -0.15451622f, 0.40162247f, 
    0.00143911f, -0.01594195f, -0.14239515f, -0.15585425f, 0.30257878f, -0.04651307f, -0.03410122f, -0.28617936f, 
    -0.62841672f, 0.13492943f, 0.09283598f, 0.16158217f, -0.12944499f, -0.18995196f, -0.09760359f, 0.36384013f, 
    0.41669166f, 0.13644396f, 0.07388945f, -0.69705987f, 0.57653195f, -0.16384578f, 0.17151876f, -0.08519014f, 
    -0.15179232f, -0.03654302f, -0.20203726f, 0.12037602f, -0.25633827f, -0.39121681f, -0.42661315f, 0.31559557f, 
    -0.00646364f, 0.21106476f, -0.03579969f, 0.00399691f, -0.10521975f, -0.18171926f, 0.26450861f, -0.17976327f, 
    -0.56180292f, 0.11384179f, -0.10194176f, 0.09664902f, 0.10614216f, -0.00821462f, -0.35711578f, 0.19129243f, 
    -0.19961520f, -0.28269979f, 0.09820076f, 0.61961734f, 0.01359705f, 0.35891333f, 0.26714259f, -0.03808101f, 
    0.12657706f, -0.17760122f, 0.18151785f, -0.01594827f, -0.31272206f, -0.34220436f, -0.39089897f, 0.05963369f, 
    -0.06291837f, -0.01225185f, -0.29502448f, -0.09988975f, 0.79203182f, -0.51593107f, 0.38249716f, 0.85404873f, 
    0.04770678f, -0.00934286f, 0.17195560f, 0.09628225f, 0.13605633f, -0.19461046f, 0.22249472f, 0.30188185f, 
    0.22551315f, 0.01300627f, -0.13543878f, 0.29090369f, -0.26730457f, 0.16451634f, -0.11758596f, 0.06133647f, 
    0.03789282f, -0.10026899f, 0.04248119f, 0.16934606f, -0.57871020f, 0.16054638f, 0.01522556f, -0.07785758f, 
    -0.11962345f, -0.24303061f, -0.21158931f, -0.01954463f, 0.92794842f, -0.46455541f, -0.29732108f, -0.45255509f, 
    -0.41529676f, 0.14220046f, 0.09091992f, 0.04943630f, -0.00838883f, 0.34436634f, 0.32874724f, 0.09946930f, 
    0.09518894f, 0.09341557f, -0.04538687f, -0.83586037f, 0.46318975f, -0.11145134f, 0.08944218f, -0.06092427f, 
    0.07340278f, -0.25175574f, 0.01465808f, -0.03439659f, 0.02288184f, -0.35098407f, 0.06236630f, 0.18756203f, 
    -0.07304955f, -0.04014984f, 0.24582642f, 0.00116858f, -0.19116554f, -0.06666613f, -0.17385861f, -0.07044537f, 
    -0.39475784f, -0.04541797f, 0.12473288f, -0.14948958f, -0.05346813f, -0.16984448f, -0.24366973f, 0.06557023f, 
    -0.10581864f, 0.13786431f, 0.08318935f, 0.10033800f, 0.06069816f, -0.15992558f, -0.09596567f, 0.00436265f, 
    0.00697105f, -0.15217477f, 0.03348750f, -0.07047636f, -0.20212422f, -0.11757690f, -0.10625923f, -0.14664435f, 
    0.10396711f, 0.09623110f, 0.12920600f, 0.01878974f, -0.20465577f, -0.14050189f, -0.16382591f, 0.00539237f, 
    -0.09469826f, 0.07833624f, -0.01732528f, -0.19053869f, -0.15366817f, -0.15818144f, -0.02683495f, 0.05276439f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.13895281f, 0.48166394f, 0.02656296f, 0.42426077f, 0.04333078f, -0.06087189f, 0.46249938f, -0.16716456f, 
    0.22966327f, 0.40876541f, -0.16161403f, -0.02099543f, 0.04339474f, 0.30117178f, 0.55331147f, 0.03757055f, 
    0.33088708f, -0.17501959f, -0.22627856f, 0.04219826f, -0.00423387f, 0.07200728f, 0.00269703f, -0.20335834f, 
    -0.03137859f, 0.44017473f, 0.35302356f, 0.15079682f, 0.20467187f, 0.16959836f, -0.20675926f, 0.06792504f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.09396930f, 0.15369783f, -0.09877458f, -0.09004931f, -0.14182885f, -0.04580199f, 0.13514411f, -0.02737946f, 
    -0.13359895f, -0.98201042f, 0.02123269f, -0.72891307f, 0.59470069f, 0.18765113f, -0.52997971f, 0.15025771f, 
    -0.49621770f, -0.05494828f, -0.51720196f, -0.06131089f, -0.61881286f, -0.36419505f, 0.13154294f, -0.38217813f, 
    0.13627027f, 0.18739724f, 0.11641042f, 0.41002423f, -0.41170526f, -0.10517335f, 0.45372432f, -0.11898374f, 
    0.10300333f, -0.08823384f, -0.14113419f, 0.06658451f, -0.26284641f, -0.15240806f, 0.27409312f, 0.24056050f, 
    0.34016204f, -0.55994695f, -0.32298213f, -0.47681418f, -0.33127290f, 0.36202902f, 0.49115983f, 0.28618169f, 
    0.48036033f, -0.15823203f, -0.06345288f, -0.06771901f, 0.24910693f, -0.38967565f, 0.24278235f, -0.19807291f, 
    -0.14036512f, 0.10734946f, 0.23413411f, 0.02890122f, -0.39784649f, 0.01205624f, -0.75465679f, -0.08737486f, 
    -0.13284148f, 0.19011441f, 0.26588455f, 0.13132161f, 0.28997067f, 0.09130879f, -0.12540561f, -1.03862143f, 
    0.43007109f, 0.62491107f, 0.25079742f, -0.05561482f, 0.20157108f, -0.52219403f, 0.38641420f, -0.36551130f, 
    -1.02787197f, -0.20610730f, -0.00984948f, 0.00665082f, -0.15216701f, 0.16546518f, -0.67032552f, -0.02048043f, 
    0.14961228f, -0.00234380f, -0.44526213f, -0.73075420f, 0.09686655f, -0.22817795f, -0.16298367f, 0.07520323f, 
    0.03946979f, 0.14333618f, -1.37199771f, 0.11046370f, 0.30471677f, -0.07405505f, 0.90023375f, -0.26220316f, 
    0.35137871f, 0.29450929f, 0.14403367f, 0.07778429f, 0.53097445f, 0.03526586f, -0.30687195f, -0.09334131f, 
    -0.04487296f, -0.36518052f, -0.17782773f, 0.14960061f, -0.25921008f, 0.11255252f, -0.22867741f, 0.02860460f, 
    0.12071079f, 0.08283000f, 0.15969644f, 0.25913018f, -0.16085942f, 0.10653612f, 0.08194491f, -0.07030799f, 
    0.14752300f, -0.05294579f, 0.01522788f, 0.04343409f, 0.00934506f, -0.01127879f, 0.01774986f, 0.25837067f, 
    -0.71464801f, -0.75972444f, 0.16866431f, -0.33721736f, -0.64653772f, 0.19263406f, -1.22797906f, -0.08538602f, 
    -0.34278804f, -0.23054092f, 0.18435852f, -0.15995102f, -0.22614066f, -0.17633793f, 0.07995990f, -0.18534890f, 
    0.25191164f, 0.03463094f, 0.18691932f, 0.18062611f, 0.17089704f, -0.07547234f, -0.70491725f, 0.04828398f, 
    -0.02881594f, 0.25410119f, -0.01945358f, 0.04894924f, -0.47633040f, -0.12488239f, -0.08186976f, 0.06092253f, 
    -0.46179479f, -0.66029340f, 0.34368768f, -0.93204367f, 0.11729763f, 0.14962053f, -0.04421129f, 0.02897896f, 
    -0.11110024f, 0.04531932f, 0.19639796f, -0.13610518f, 0.25473475f, 0.01500358f, -0.33298019f, -0.11738246f, 
    0.09603184f, 0.06075675f, -0.07927255f, -0.41969785f, 0.21186198f, 0.25354418f, 0.42970398f, -0.03295182f, 
    -0.08102342f, 0.33039954f, 0.25007522f, -0.17266051f, 0.25710210f, 0.01469037f, -0.36023641f, -0.04992501f, 
    0.54097325f, 0.68851823f, -1.17914975f, 0.37912223f, -0.60932225f, -0.46668687f, 0.35176235f, -0.22292300f, 
    -0.16463038f, 0.02585231f, 0.06974383f, -0.03336657f, -0.16367799f, -0.07245544f, -0.00918130f, -0.24717107f, 
    -1.07336569f, -1.07396138f, -0.56760120f, -0.15619361f, 0.30023968f, 0.25131238f, -0.08468728f, -0.07418142f, 
    -0.05133187f, -1.01074553f, 0.04801644f, -0.29199469f, 0.95161003f, -0.05104141f, 0.18653075f, -0.29421514f, 
    -0.51232713f, -0.37564728f, -0.83326387f, -0.31924918f, -0.17829983f, -0.23440763f, 0.03271701f, -0.25863606f, 
    0.17706497f, -0.12925628f, 0.17559391f, 0.02729779f, 0.08475079f, 0.29170141f, 0.26809725f, -0.06145281f, 
    -0.12698962f, -0.78399259f, -0.88158822f, -0.14294736f, 0.13050310f, -0.91557169f, 0.13830802f, -0.07667770f, 
    -0.02474555f, -0.21555239f, -0.45857236f, 0.12769897f, -0.35977861f, -0.02677065f, 0.26975158f, -0.72719193f, 
    -0.49706984f, -0.66074210f, -0.07316758f, -0.55274153f, -0.41117084f, -0.27620661f, 0.38220784f, -0.08042117f, 
    -0.08566146f, -0.13871314f, 0.27478567f, 0.08477926f, 0.42195627f, 0.21510863f, -0.27886230f, 0.46204266f, 
    -0.28077289f, -0.24871171f, -1.26882195f, -0.17721276f, -0.01041421f, -0.41745770f, -0.11108955f, 0.12875023f, 
    -0.01590244f, 0.21181618f, -0.38472399f, -0.15048842f, 0.09586956f, 0.17515635f, 0.04455842f, 0.18503319f, 
    -0.46694380f, 0.27941009f, 0.11207590f, 0.31679919f, -0.63663453f, 0.36498865f, -0.21384484f, -0.89016682f, 
    -0.08292849f, -0.06499854f, -0.06237943f, -0.05728702f, -0.33535472f, -0.29846257f, -0.17000954f, -0.42559761f, 
    -0.31234872f, 0.02597270f, 0.31201226f, -1.17172837f, 0.56957453f, 0.31878373f, -0.30296984f, -0.18159007f, 
    -0.08583821f, -0.38135538f, 0.08037963f, 0.30066684f, -1.17951524f, 0.17503445f, -0.89270920f, 0.10968440f, 
    0.53323704f, -0.36794913f, 0.01086773f, -0.25194666f, 0.04469416f, -0.47408706f, -0.04129648f, -0.84940481f, 
    -0.59214675f, -0.08470962f, 0.03955146f, -0.08032745f, 0.28666571f, -0.22464302f, -0.04958201f, 0.46172291f, 
    0.04367049f, -0.03272175f, -0.11109354f, -0.39370731f, -0.69686961f, 0.35763252f, -0.17218816f, -0.00665377f, 
    -0.17696868f, -0.61872739f, -0.74205267f, -0.39192519f, -0.23362590f, -0.07451984f, -0.28052303f, -0.77812898f, 
    0.19400983f, -0.10556474f, 0.04354478f, 0.52681714f, -0.01374055f, -0.46256799f, -0.23764686f, -0.32309100f, 
    0.46205136f, -0.13927652f, 0.31891727f, 0.03891969f, 0.01556053f, -0.00550771f, 0.08895512f, 0.14160739f, 
    -0.02583317f, -0.03387483f, -0.38303220f, -0.21015130f, -0.11636572f, 0.21000154f, -0.09810896f, -0.11413861f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.04976916f, 0.25927487f, 0.14921571f, -0.03485116f, -0.25917518f, 0.04786738f, -0.14137606f, -0.12055148f, 
    0.29390553f, 0.32131618f, -0.11288466f, -0.26565713f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
