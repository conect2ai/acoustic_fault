#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.66825336f, -0.94880402f, -0.66498047f, 1.10825121f, -0.76838064f, -0.56673646f, 0.43407881f, -0.08299077f, 
    0.31743717f, -0.17014641f, 0.01503013f, 0.53599602f, -0.99859190f, -0.70970929f, -0.99316400f, 0.91564429f, 
    -0.77732825f, -0.01311973f, -0.05750366f, -0.11387329f, 0.55133384f, 0.38061991f, 0.52308428f, 0.12990147f, 
    -0.23663591f, -0.39558926f, 0.82918143f, -0.56543010f, -1.07697630f, 0.89017856f, 0.40646464f, -0.62249345f, 
    -1.02135324f, -0.57860255f, -0.10533143f, -0.45133990f, -0.78076351f, -0.04037782f, -0.72916675f, 0.51648301f, 
    -0.00923691f, 0.25459933f, 0.38936654f, 0.35188171f, 0.79207104f, -0.77756751f, -0.30631733f, 0.12042709f, 
    -0.79814750f, -0.75129128f, -0.70717728f, -0.15539187f, -0.46788138f, -0.57024038f, -0.84867477f, 0.05960944f, 
    0.75278890f, 0.86156124f, -0.75699407f, -0.12904648f, 0.15416302f, -0.04599522f, -0.44149819f, 0.26167655f, 
    0.58525640f, 0.63039511f, -0.23998755f, 0.25467756f, 0.05448214f, 0.61041021f, 0.49641901f, -0.69434971f, 
    -0.51277524f, 0.20121956f, 0.10410915f, -0.61308575f, -0.78415096f, -0.91812479f, -0.30376008f, 0.67567366f, 
    0.17405729f, 0.46955454f, -0.06678679f, -1.19258916f, -0.57566994f, -0.34501040f, -0.94736564f, -0.75406873f, 
    -0.89617425f, 0.51274973f, 0.16301815f, -0.09636407f, -0.11796708f, -0.40274677f, 0.46773633f, 0.05812454f, 
    -0.58494049f, 1.07570148f, -0.52810591f, -0.84322554f, 0.13823721f, -0.19182791f, 0.54346055f, 0.70006824f, 
    0.87469077f, 0.39975050f, 0.22603408f, -0.21003415f, 0.09063029f, 0.07491986f, 0.32879737f, -0.16157761f, 
    -0.04664323f, -0.43366590f, -0.41322961f, -0.42875502f, -0.25346279f, 0.39063016f, 0.65521508f, -0.56270331f, 
    -0.57847953f, 1.01411879f, -0.94918150f, -0.32319447f, -0.06034449f, -0.10939415f, 0.18546374f, 0.43071353f, 
    -0.31987107f, 0.16704884f, -0.47944355f, 0.02498909f, -0.36947805f, 0.22878002f, 0.83614719f, -0.02455488f, 
    -0.45800775f, 0.18438569f, -0.44941556f, -0.95174605f, -0.95120573f, 0.42182609f, 0.79808962f, 0.68268460f, 
    -1.01403451f, -1.08548963f, -1.25645721f, -0.12160465f, 0.68157214f, -0.05317383f, 0.34513360f, 0.82820398f, 
    0.11274593f, 0.45675415f, 0.76129103f, -0.02543171f, -0.18967716f, -0.61038142f, -0.03211033f, -0.21165314f, 
    -0.57088715f, -0.42651522f, -1.30264747f, -0.79710656f, 0.09528040f, 0.72355884f, 0.25301972f, 0.05013312f, 
    -0.30405340f, -0.80774969f, -0.95043278f, 0.48226544f, 0.06941389f, -0.29130673f, 0.07270844f, -0.62219465f, 
    0.06201896f, -0.10636368f, 0.17426379f, -0.38790026f, 1.08358538f, 1.30153060f, -0.91867024f, -0.57366633f, 
    -0.16968045f, -0.20343187f, 0.06734312f, 0.04214212f, 0.24134970f, -1.13384306f, -0.63191450f, -0.40956524f, 
    1.17117667f, 0.91048443f, 0.42199162f, -0.26698565f, 0.23105539f, -0.30176106f, 0.44870844f, 0.35924494f, 
    0.49603394f, -0.58193278f, 0.25487158f, 0.71683592f, -0.03899202f, -0.41273811f, -0.52096075f, 1.01806080f, 
    -0.30427235f, 1.16496181f, 0.03745147f, -0.62296861f, -0.57279658f, -0.24994057f, -0.24029502f, 0.42664626f, 
    0.50839347f, -0.89702314f, -0.73487866f, 0.93723440f, 0.21854459f, 0.24349351f, -0.26338521f, -0.64676297f, 
    -0.46075526f, -0.80801773f, -0.04072839f, -0.26323390f, -0.79675537f, -0.82919794f, -0.65278542f, 0.04768875f, 
    0.95710933f, -0.49661627f, 0.49202639f, 0.19289970f, 0.58920777f, -0.57147467f, -0.56072587f, -0.11719377f, 
    0.08700378f, 0.89658177f, 0.01359087f, 0.87121630f, -0.44840989f, -0.24068575f, -0.27521375f, 0.74202764f, 
    0.59995276f, -0.72206581f, -0.03345462f, -0.57079744f, -1.00312352f, -0.68161196f, 1.60472167f, -0.61507016f, 
    -0.35029259f, 0.99408400f, -0.38721988f, 0.21680066f, 0.16124722f, -0.51100403f, -1.01930702f, -1.19188559f, 
    -0.70020574f, 0.19494644f, 0.83801478f, -0.00243602f, -0.31758052f, -0.49177468f, -0.71040249f, -0.69418472f, 
    -0.66341496f, -0.30093637f, -0.03761183f, -0.72418970f, 0.57822096f, -0.24424972f, -0.57754749f, 0.23110503f, 
    -0.52775669f, 0.59653199f, 0.29385176f, 0.61337137f, 0.39321414f, 0.47107050f, 0.18456534f, -0.31911573f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.68154436f, 0.18840390f, 0.39851147f, -0.19239569f, 0.43495524f, -0.67990243f, 0.32547745f, 0.30872956f, 
    0.27822688f, -0.08369752f, 0.44562367f, 0.38504329f, 0.33657435f, 0.03760345f, 0.34178945f, 0.01735931f, 
    0.62479812f, -0.17242530f, 0.14065680f, 0.47574458f, 0.34197780f, 0.01465333f, 0.37055865f, -0.01217767f, 
    0.12992403f, -0.50375754f, 0.14605998f, -0.16969916f, 0.23485532f, -0.07072795f, -0.16528231f, -0.19991489f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.27926603f, 0.44518939f, 0.44991252f, 0.11210626f, -0.02165851f, 0.11332730f, 0.04305977f, -0.01153428f, 
    0.01298120f, -0.51673400f, -0.46995941f, -0.05128669f, 0.08534305f, 0.12409590f, -0.04611112f, -0.04816027f, 
    -0.32572836f, 0.10513894f, 0.15330929f, 0.05388426f, -0.14150952f, -0.17905454f, -0.05934334f, -0.13452458f, 
    0.14568409f, 0.20398031f, 0.16818455f, -0.20838889f, -0.17608303f, -0.03350921f, -0.09696510f, -0.09570830f, 
    -0.06920103f, 0.13134405f, 0.12175576f, 0.14436352f, 0.08552953f, 0.07908296f, -0.03236277f, -0.40741450f, 
    0.06668401f, 0.08188515f, 0.05972125f, 0.04663225f, -0.04012531f, -1.19041693f, -0.85640651f, -0.83650357f, 
    -0.07873730f, -0.02202776f, -0.12121008f, -0.10431831f, -0.34544739f, 0.18852067f, 0.33247310f, -0.07232025f, 
    0.25746050f, 0.03566415f, -0.06409453f, -0.27665800f, 0.16947392f, 0.11363403f, 0.13856238f, 0.06058548f, 
    -0.10650077f, 0.08723282f, 0.00852156f, -0.06267549f, -0.08966554f, -0.07030073f, 0.05272965f, 0.06259292f, 
    -0.52177060f, -0.60583347f, -0.13713294f, -0.01458609f, 0.00546623f, -0.13990685f, 0.02154294f, -0.13685440f, 
    -0.06859159f, -0.28793806f, -0.67011738f, -0.32638249f, -0.07930239f, -0.10696562f, -0.02605839f, 0.00423968f, 
    -0.26646927f, 0.07198597f, -0.12851912f, -0.09983376f, 0.16578485f, 0.20391434f, 0.11457689f, -0.14915016f, 
    -0.11760977f, 0.10270733f, 0.11608156f, 0.01323100f, 0.17206675f, 0.02126396f, -0.37612039f, -0.31144252f, 
    0.02836635f, 0.04888923f, 0.09276520f, 0.12541983f, -0.03639108f, 0.08923439f, -0.00617027f, 0.00766639f, 
    0.03657505f, -0.03172999f, 0.23784079f, 0.14409937f, 0.29817399f, -0.10487512f, 0.05684767f, 0.19915175f, 
    0.06627961f, -0.00915938f, 0.06637637f, -0.13014700f, 0.01887269f, 0.17415462f, -0.01887734f, -0.05960652f, 
    0.00970237f, -0.09419160f, 0.02907959f, 0.01064933f, 0.19987038f, 0.06411248f, -0.01588760f, -0.27184927f, 
    -0.36802092f, -0.09053947f, 0.01578095f, 0.00534364f, 0.02809191f, 0.05055610f, 0.05511288f, -0.25641099f, 
    -0.27017558f, 0.45490500f, 0.63456196f, 0.04976792f, 0.02414640f, 0.01457595f, -0.01674375f, 0.09774835f, 
    0.02961123f, 0.03297523f, 0.06611054f, 0.07879073f, 0.07983354f, -0.00799764f, 0.02062805f, 0.15431274f, 
    -0.07474875f, 0.18058151f, 0.03523839f, -0.15669693f, 0.18353169f, 0.01449678f, -0.08973063f, -0.03060128f, 
    -0.03645666f, 0.02143227f, 0.18981385f, 0.06422941f, 0.27027068f, 0.00037280f, 0.17160879f, 0.04765682f, 
    -0.04109240f, -0.04408087f, -0.13530657f, 0.21401627f, 0.28118193f, 0.15067124f, -0.08899581f, 0.18701114f, 
    -0.00994307f, 0.09359513f, 0.06738257f, -0.28936839f, -0.06820976f, -0.18835364f, 0.19512363f, 0.13371633f, 
    0.07526275f, -0.10989671f, 0.04444657f, 0.01785839f, 0.18467046f, 0.14602302f, -0.03098076f, 0.01551290f, 
    0.00314493f, -0.01272339f, -0.01637976f, -0.06446683f, 0.22456214f, -0.01223881f, 0.20767447f, 0.09501384f, 
    -0.18974502f, 0.06902405f, 0.06262737f, 0.07188654f, -0.06242791f, -0.14340763f, -0.28267482f, 0.17898265f, 
    -0.27320516f, -0.10034140f, 0.03574961f, 0.11391238f, 0.02037957f, 0.34455255f, 0.00340549f, 0.30109233f, 
    0.17246124f, -0.73363727f, -0.68364447f, -0.13970108f, -0.04621381f, -0.12024395f, -0.14442611f, -0.04414715f, 
    -0.16034007f, 0.03149427f, -0.14765508f, -0.39771920f, 0.03168410f, 0.14253666f, -0.01157351f, -0.06468754f, 
    0.02381810f, -0.06519596f, -0.02785925f, -0.13374791f, 0.03049299f, -0.00335518f, -0.03528327f, -0.09549288f, 
    0.04510990f, -0.08107402f, -0.03309295f, 0.23887968f, 0.42112324f, -0.27020839f, -0.30890524f, 0.10374590f, 
    -0.07578113f, 0.03899033f, -0.05583405f, 0.08021454f, 0.01910434f, 0.18220714f, 0.60758120f, 0.52015823f, 
    0.01755166f, 0.03820656f, -0.05647307f, -0.15018490f, 0.00340787f, -0.08820675f, -0.48845878f, -0.11839877f, 
    -0.12861927f, -0.00223235f, -0.02829456f, -0.13351290f, -0.08452259f, -0.02577420f, -0.00020127f, 0.00576417f, 
    -0.02290175f, -0.07390567f, -0.54212660f, -0.27975914f, -0.47243765f, 0.24810939f, 0.15124862f, 0.15411191f, 
    0.12347317f, 0.25877601f, -0.55247051f, 0.10281858f, 0.18610594f, 0.21523407f, 0.14020348f, 0.02089391f, 
    -0.08911571f, -0.11993941f, 0.35644567f, 0.16658600f, 0.09275971f, 0.00656853f, -0.10727721f, 0.02006192f, 
    0.07365183f, 0.05262053f, 0.21068701f, -0.00442519f, 0.27902249f, -0.37769920f, -0.24820386f, -0.10207941f, 
    -0.04743094f, -0.02281328f, 0.00015531f, 0.35111579f, 0.23413558f, -0.15951779f, 0.02222426f, -0.00649860f, 
    0.04878073f, 0.21710408f, 0.08254294f, 0.14684032f, 0.18707682f, -0.11232006f, -0.21881413f, -0.10614292f, 
    -0.13741396f, -0.00118702f, 0.16311868f, 0.05532284f, 0.06796167f, 0.14513139f, 0.21621107f, 0.30297375f, 
    -0.07145735f, -0.05025027f, -0.05043087f, 0.29234385f, 0.08124808f, 0.10107023f, -0.36044240f, 0.09169156f, 
    0.22598642f, 0.07834558f, 0.02686636f, -0.01181781f, 0.12344564f, -0.14140712f, -0.07415684f, 0.19525285f, 
    0.30192930f, 0.27497163f, 0.06853530f, -0.05619770f, -0.10292852f, -0.00320648f, 0.15354432f, 0.14716999f, 
    -0.22244135f, -0.03396962f, 0.24310826f, 0.04119661f, 0.00029327f, 0.07768281f, 0.08078042f, 0.02425567f, 
    0.11575826f, 0.13422738f, 0.45174256f, 0.08691549f, 0.30482888f, 0.25637922f, -0.13078122f, -0.04781072f, 
    0.00647031f, -0.24791208f, -0.04443422f, 0.05563105f, 0.38073856f, 0.19532475f, 0.05816821f, 0.31238836f, 
    0.09620951f, -0.00237531f, -0.04416938f, 0.38748717f, 0.08802458f, -0.04015859f, -0.17445099f, -0.09061456f, 
    -0.12720865f, 0.13844842f, 0.06850973f, 0.07988370f, -0.03213194f, -0.04627265f, -0.10508846f, 0.08221715f, 
    0.02237131f, -0.04284569f, 0.05021996f, -0.24169862f, -0.30379704f, -0.20733631f, 0.31009230f, -0.00934898f, 
    -0.10415170f, 0.16999215f, 0.16574009f, -0.06371889f, -0.26081231f, 0.00457201f, 0.08415916f, -0.03110408f, 
    -0.01399070f, -0.18459152f, 0.00102302f, 0.05734435f, 0.04137249f, -0.00571002f, 0.18815303f, -0.15595788f, 
    0.19624664f, 0.21007903f, 0.22994927f, 0.02299654f, 0.05268358f, 0.06797583f, 0.01419955f, 0.05997986f, 
    0.00365327f, -0.11470801f, -0.38004905f, -0.05164945f, -0.02685997f, 0.03875849f, -0.05684375f, 0.04962267f, 
    0.05945718f, -0.01210426f, -0.00612115f, -0.07654532f, 0.10770978f, 0.08299883f, 0.06670927f, -0.16609246f, 
    -0.39501131f, -0.21084335f, -0.39128709f, -0.18125384f, -0.31709746f, -0.06705493f, -0.09839768f, 0.11337009f, 
    0.10914128f, -0.22195195f, -0.26461655f, 0.15555300f, 0.16724665f, -0.22570613f, -0.00985543f, 0.04080251f, 
    -0.10616039f, 0.16195841f, -0.03531885f, 0.15838525f, 0.24263388f, -0.08423224f, -0.57217443f, 0.03565296f, 
    0.18261564f, -0.01746174f, 0.17234656f, -0.11081567f, 0.05202820f, 0.29966968f, -0.23657857f, -0.40268558f, 
    -0.11735478f, -0.17197375f, 0.01897225f, 0.18635266f, -0.11404713f, -0.01472536f, 0.02286607f, 0.08574931f, 
    0.19913688f, -0.05057404f, 0.10464291f, 0.00709025f, -0.05990634f, -0.22606878f, -0.32978988f, -0.11329585f, 
    -0.15604818f, -0.47828367f, 0.05347577f, -0.03552903f, -0.09351834f, 0.12993468f, 0.07371994f, -0.16118269f, 
    -0.02495953f, -0.48657861f, -0.38341063f, -0.04466064f, 0.24328068f, -0.09750453f, 0.07419056f, -0.34394380f, 
    -0.09127203f, -0.09831136f, 0.14032273f, 0.59279865f, -0.16658226f, 0.03806574f, 0.05607573f, 0.06217029f, 
    -0.01452539f, -0.11760990f, -0.27848190f, -0.11217953f, 0.17149206f, 0.05240324f, -0.01299738f, -0.04283190f, 
    -0.05339899f, 0.21694104f, 0.28043815f, 0.13717017f, -0.06973480f, 0.20214735f, 0.25135735f, 0.14985701f, 
    -0.19765227f, 0.11877510f, 0.02514871f, 0.04239880f, -0.26025000f, -0.53879613f, 0.29703054f, -0.13686749f, 
    0.35701850f, 0.25619942f, -0.06315126f, -0.12110496f, 0.08729675f, -0.10597402f, -0.11945199f, -0.17158474f, 
    -0.13679115f, 0.02858139f, -0.16367213f, -0.05502335f, 0.04236257f, 0.03025051f, 0.06489860f, 0.20008770f, 
    -0.09637854f, -0.16423447f, -0.03175778f, 0.02181905f, -0.02475594f, -0.01925682f, 0.02365468f, 0.29542539f, 
    0.30289435f, 0.03354017f, -0.06395707f, -0.18263300f, -0.39076933f, -0.05499448f, -0.05910505f, 0.01252589f, 
    0.04606869f, -0.05281960f, -0.03382440f, -0.00553815f, -0.06140749f, -0.00795359f, -0.00199633f, -0.01129633f, 
    -0.04800974f, 0.00855145f, -0.00110866f, 0.00559321f, 0.00517617f, -0.04808139f, 0.01642303f, 0.00903053f, 
    0.02448959f, -0.03001832f, 0.00153540f, 0.05762288f, -0.05420928f, -0.03502716f, -0.01640473f, 0.01545208f, 
    0.01832108f, -0.00098217f, -0.05351990f, 0.04022458f, -0.05335416f, -0.02921363f, -0.06535989f, -0.03104669f, 
    0.04817419f, -0.03178282f, -0.05439857f, 0.04044981f, -0.03774964f, 0.00943158f, -0.03433109f, 0.03629916f, 
    0.03501662f, -0.00770832f, -0.03161003f, -0.02091302f, -0.01261808f, 0.02964410f, -0.06426627f, 0.03223922f, 
    -0.00327350f, 0.03102429f, -0.01044365f, 0.01388705f, -0.02818790f, -0.03861900f, -0.03405403f, 0.02729770f, 
    -0.04799582f, -0.05454182f, -0.00076740f, 0.01320305f, 0.04645341f, 0.04581293f, 0.03242512f, -0.00290577f, 
    -0.05691368f, 0.00981912f, -0.02398833f, 0.00935493f, 0.03290426f, -0.06104646f, -0.05264030f, 0.02407787f, 
    -0.03757045f, 0.00867501f, 0.02180957f, 0.01151001f, -0.00554453f, -0.03270582f, -0.05353237f, 0.02471479f, 
    0.02649267f, -0.06422149f, -0.05310734f, -0.01920943f, 0.00831887f, 0.01527335f, 0.02663853f, -0.04630459f, 
    0.00873074f, -0.00692908f, 0.02445140f, -0.00568159f, 0.02989347f, -0.03977506f, -0.06440936f, -0.06328402f, 
    -0.03909627f, 0.01990804f, -0.00529102f, -0.04169090f, 0.00782095f, 0.02064363f, 0.00971122f, 0.00991734f, 
    0.02530101f, 0.00953196f, -0.01695726f, -0.01086254f, -0.04175190f, -0.01279250f, -0.04275878f, -0.06386384f, 
    -0.02864577f, -0.02693482f, -0.05833011f, 0.00287358f, 0.04700328f, 0.02708622f, 0.02154400f, -0.06331743f, 
    0.00261840f, -0.01703426f, -0.03704412f, 0.01208077f, -0.02174380f, -0.05719933f, -0.01806879f, 0.03430619f, 
    -0.02736188f, -0.02767917f, 0.05038220f, 0.02526912f, 0.03458693f, -0.04788014f, -0.02077974f, 0.03924338f, 
    -0.01393463f, 0.02925967f, -0.05814467f, -0.02589267f, -0.00280692f, -0.02869202f, 0.02894761f, -0.03945037f, 
    -0.06208400f, -0.00012953f, -0.01957100f, -0.04211050f, -0.03326685f, -0.01833663f, 0.02871589f, -0.01445460f, 
    -0.00021553f, -0.01893000f, 0.01535208f, 0.03869606f, -0.03305086f, 0.01804418f, -0.05735002f, 0.01524231f, 
    -0.04195045f, -0.00842918f, -0.01810775f, 0.03633852f, 0.04256321f, 0.03407869f, -0.04998014f, -0.00859428f, 
    0.03072863f, -0.05292507f, -0.02631342f, -0.03127148f, -0.02153132f, 0.00898236f, 0.04397325f, 0.00020341f, 
    -0.04503702f, -0.06042301f, 0.02024423f, -0.02849453f, 0.01211201f, -0.03153891f, -0.06442261f, 0.00720892f, 
    -0.03032571f, 0.00254916f, -0.00129599f, -0.06061836f, 0.00501095f, -0.02168712f, 0.05377740f, 0.02764151f, 
    0.00002566f, -0.05280161f, 0.02480157f, -0.03278510f, 0.04384372f, 0.04534699f, 0.01298462f, -0.04877055f, 
    0.05354117f, -0.03106865f, 0.02174470f, -0.04728562f, -0.02125261f, -0.04192769f, -0.02516107f, -0.01667331f, 
    -0.01816966f, 0.03903088f, -0.05575639f, -0.01240243f, 0.01541100f, -0.01545118f, 0.01922685f, -0.02525159f, 
    -0.01281209f, 0.04214586f, -0.04493555f, 0.00855955f, -0.00310922f, -0.05686120f, -0.05795385f, 0.03379765f, 
    -0.03797026f, 0.03573397f, 0.02946361f, 0.02355477f, 0.02564606f, -0.03271336f, 0.00316715f, -0.04009416f, 
    0.03869341f, 0.01132707f, -0.04187011f, -0.00398640f, 0.01083486f, -0.05905750f, 0.02650732f, -0.06093657f, 
    -0.01465612f, -0.05536234f, -0.03284132f, -0.03692935f, 0.00166569f, -0.04124157f, -0.01661190f, -0.00581635f, 
    0.00440481f, 0.05015963f, -0.06427854f, 0.02578510f, -0.03022722f, -0.04757405f, -0.05413130f, -0.02474063f, 
    0.04428186f, -0.03730561f, 0.00615954f, -0.01551035f, -0.01377238f, -0.04021698f, 0.04028277f, 0.02934957f, 
    0.00007954f, 0.00506204f, 0.01248825f, -0.05584943f, -0.06278133f, 0.03679529f, -0.04508074f, -0.00398544f, 
    -0.03792834f, 0.00269095f, -0.05394754f, -0.02079031f, 0.00329422f, 0.01237264f, -0.01421917f, 0.00686739f, 
    -0.04233385f, 0.02866015f, -0.03392769f, -0.04748252f, -0.04158092f, 0.01532444f, 0.01955002f, -0.03499772f, 
    -0.23833899f, 0.23849505f, 0.11782904f, 0.04275254f, -0.12919065f, 0.06461716f, -0.14140324f, -0.00169122f, 
    -0.03663684f, -0.50492013f, 0.11662138f, 0.30862531f, 0.20217523f, -0.12272232f, 0.15593523f, 0.05448844f, 
    0.05190225f, 0.04255334f, 0.07399202f, 0.16292775f, -0.10000622f, 0.08510404f, 0.01565467f, 0.03069027f, 
    -0.18506323f, 0.00465857f, -0.00466649f, -0.11358926f, -0.10196648f, 0.04642780f, 0.09213624f, -0.02750005f, 
    0.12313122f, -0.07346816f, 0.04143426f, 0.08126031f, 0.03779813f, 0.06355336f, -0.02611798f, 0.11853098f, 
    -0.11227265f, -0.02840578f, -0.25485620f, -0.44601077f, -0.10303649f, -0.48562631f, -0.18619274f, 0.02848478f, 
    0.12007594f, -0.21437518f, 0.10634994f, -0.07866532f, -0.07901646f, -0.07270630f, -0.23513949f, 0.05209592f, 
    0.13674614f, 0.11137276f, 0.18019874f, 0.04713143f, 0.02623294f, 0.20538625f, 0.07281643f, -0.03643844f, 
    0.08045579f, 0.02541302f, 0.02162351f, 0.08667437f, 0.01217244f, 0.02889880f, 0.02962666f, -0.14062624f, 
    -0.18752569f, -0.12338570f, -0.20664307f, 0.04818602f, 0.04605843f, -0.14264813f, -0.04488314f, -0.18569469f, 
    0.03036207f, -0.21737264f, 0.03691237f, 0.01108164f, -0.09388983f, -0.05365427f, -0.05137870f, -0.01211097f, 
    -0.00194458f, 0.01572363f, 0.10824967f, 0.08743110f, 0.08240474f, 0.04899850f, 0.12645122f, 0.11505710f, 
    0.03575292f, 0.07936486f, 0.20618339f, 0.16781564f, 0.18675637f, 0.05046145f, 0.03336499f, 0.08324631f, 
    -0.01963519f, -0.27444291f, -0.33658877f, -0.17127089f, 0.21704085f, -0.08864751f, 0.09283429f, 0.00865814f, 
    0.01003254f, 0.06695157f, 0.13212919f, 0.07741857f, 0.10556419f, 0.09728806f, -0.01226439f, -0.02330681f, 
    0.22526461f, 0.08036700f, 0.01206871f, 0.10487336f, 0.11036153f, 0.19865057f, 0.05411972f, 0.09126083f, 
    -0.10039017f, 0.02178710f, 0.15758842f, -0.07610345f, 0.13485239f, -0.36948088f, -0.15308037f, -0.14389433f, 
    -0.03824844f, -0.05712844f, 0.07221717f, -0.03370552f, -0.05191423f, -0.15392922f, -0.30886725f, -0.14793487f, 
    -0.20161183f, -0.05594970f, 0.09808446f, 0.01137584f, -0.18507238f, -0.14131804f, -0.02056662f, 0.13687292f, 
    0.06349479f, -0.15595016f, -0.37100071f, 0.00621784f, -0.02146477f, 0.00330293f, -0.02687517f, 0.05307809f, 
    0.04646756f, 0.01683754f, -0.11916956f, 0.18543282f, 0.25333366f, 0.05470852f, 0.13652945f, 0.00785836f, 
    0.01293939f, -0.01110568f, 0.13068272f, 0.08517464f, -0.03909979f, -0.02744286f, 0.07885338f, -0.04801920f, 
    0.14495681f, 0.12398273f, 0.05290331f, 0.09484561f, 0.18776517f, 0.08456583f, 0.01380474f, 0.06564039f, 
    0.21906298f, -0.05626875f, 0.16464089f, 0.08246478f, 0.02258397f, -0.02302004f, 0.31790534f, 0.41040200f, 
    -0.03359954f, -0.05259224f, 0.08790105f, -0.09313872f, -0.01935787f, 0.07385896f, -0.11908945f, -0.16160695f, 
    -0.11431517f, 0.05908543f, -0.03793395f, -0.03880695f, 0.19794002f, 0.13595530f, 0.00751754f, -0.03915533f, 
    -0.09784580f, -0.03498696f, -0.04027012f, -0.17100583f, -0.02043799f, -0.01762058f, 0.01884675f, -0.04090622f, 
    -0.30008152f, 0.17177509f, 0.16648276f, 0.11864995f, 0.13629442f, 0.21039867f, 0.03568618f, 0.17732637f, 
    0.32542723f, -0.32576185f, 0.13660888f, -0.51735520f, 0.04564079f, -0.25782153f, -0.03303962f, -0.04037977f, 
    -0.03546562f, -0.02325350f, -0.14937536f, -0.06552933f, -0.09040782f, -0.04085259f, 0.07966904f, -0.16738836f, 
    0.10488927f, -0.14122446f, -0.02003348f, -0.50301605f, -0.49528283f, -0.16329302f, -0.00743038f, 0.04793235f, 
    0.03354272f, 0.21555975f, -0.04344180f, 0.18957673f, 0.56001496f, 0.36723182f, -0.04791198f, 0.00052217f, 
    0.30728814f, 0.02195520f, -0.22707675f, 0.01841121f, 0.18868347f, 0.10372117f, -0.03375329f, 0.15070856f, 
    0.01577644f, 0.17143589f, 0.16240761f, -0.08771999f, 0.09452419f, 0.09815071f, -0.66130149f, -0.26795503f, 
    -0.26917556f, 0.11317670f, 0.20989576f, 0.14922836f, -0.07482592f, -0.01320347f, -0.00270466f, -0.04641408f, 
    -0.00178453f, 0.02371461f, 0.00459345f, 0.00812999f, -0.02561262f, -0.26902503f, -0.31293568f, -0.04169630f, 
    -0.39643836f, -0.17059235f, 0.15788129f, -0.08234856f, -0.00362144f, 0.34000707f, 0.10932107f, 0.08944688f, 
    0.04913469f, -0.34007108f, -0.24905178f, 0.13675025f, -0.08691517f, 0.00711263f, 0.09170666f, -0.05903200f, 
    0.04219628f, 0.14060706f, 0.10482612f, 0.29667914f, 0.10590873f, -0.09859648f, 0.10578573f, -0.16596377f, 
    0.13554971f, 0.12709175f, -0.11550294f, -0.19561276f, 0.02785070f, 0.14941557f, 0.00493594f, -0.18670103f, 
    0.03664126f, 0.03605354f, -0.12473708f, -0.18244073f, 0.06567597f, -0.27747545f, -0.18598054f, 0.15012333f, 
    0.15266150f, 0.12614293f, 0.04831127f, 0.03922414f, 0.00507447f, -0.11479151f, -0.19071463f, -0.34219685f, 
    -0.00766813f, 0.04020319f, -0.09212614f, 0.06177423f, 0.08902897f, -0.06899445f, -0.01581471f, 0.15311979f, 
    0.10696921f, 0.17233919f, 0.22876407f, -0.08359648f, -0.04560616f, 0.07057906f, 0.00209844f, 0.16657925f, 
    0.29142350f, 0.26308143f, -0.01410101f, 0.04989186f, -0.11921433f, 0.25242484f, 0.03708357f, 0.09502591f, 
    0.10963441f, -0.22658563f, 0.10603881f, 0.00777694f, 0.07073919f, 0.08901742f, -0.03007597f, -0.02539072f, 
    0.06567669f, -0.11907455f, -0.04169627f, -0.25807625f, 0.05489908f, 0.01783737f, -0.28442627f, -0.07328703f, 
    0.07783266f, -0.29390061f, 0.28409892f, -0.25566879f, 0.23495877f, 0.07578973f, -0.02407761f, -0.01721187f, 
    0.09821188f, -0.22694200f, 0.02531907f, 0.17916571f, 0.05687387f, 0.02610070f, -0.02395478f, -0.02024737f, 
    -0.08602359f, 0.01663670f, -0.17578700f, 0.05656420f, 0.06928264f, 0.01035071f, 0.09647644f, 0.13281029f, 
    0.03099141f, 0.09835989f, 0.00286792f, 0.06827960f, 0.17585081f, 0.10413657f, -0.19858590f, -0.01632332f, 
    0.15110545f, -0.05459837f, 0.05248692f, -0.08965976f, -0.35687295f, -0.06306683f, -0.09087629f, 0.19985428f, 
    0.03586990f, 0.26099479f, 0.18569873f, 0.06365997f, 0.06774225f, -0.08808693f, -0.04293048f, -0.12633324f, 
    -0.01398597f, 0.06025986f, 0.06730833f, 0.15532285f, 0.08625829f, -0.03548681f, 0.00822111f, -0.22777374f, 
    0.11445178f, -0.11701769f, -0.06339528f, -0.08761519f, -0.01902760f, 0.09939171f, 0.08287895f, -0.02417612f, 
    -0.10309259f, -0.06504215f, -0.03540937f, 0.07491580f, 0.00826670f, -0.02903087f, 0.05922116f, 0.01280529f, 
    0.12017728f, 0.01950141f, -0.29318175f, -0.09291442f, 0.20647940f, -0.00332691f, -0.10228563f, -0.27698106f, 
    0.19361374f, -0.07607153f, 0.04421024f, 0.22213526f, 0.02349010f, 0.25846466f, -0.02467429f, -0.04967016f, 
    0.02533392f, 0.09949217f, 0.29773968f, 0.13193494f, -0.18192582f, 0.12601937f, 0.26162031f, 0.04172808f, 
    -0.19127904f, -0.07296209f, 0.00002255f, 0.01435422f, 0.23519626f, -0.17491777f, -0.33816645f, 0.10190861f, 
    -0.30830082f, -0.28277576f, -0.24823213f, 0.13674487f, -0.15027606f, 0.11802638f, 0.15662032f, 0.15350839f, 
    0.19836287f, -0.01833908f, 0.00900123f, -0.07642213f, -0.09635222f, 0.12794751f, 0.18585266f, 0.24786668f, 
    0.41347498f, 0.06285343f, -0.15621547f, 0.00055519f, 0.04664832f, 0.13738008f, 0.20235944f, 0.16655491f, 
    -0.30143458f, -0.18073848f, 0.10884694f, -0.16037998f, 0.00645736f, 0.06066253f, -0.04353281f, 0.07483282f, 
    -0.11278391f, 0.02769978f, -0.33807626f, -0.36835551f, 0.04042151f, -0.11761556f, 0.01540211f, -0.01139749f, 
    -0.05357095f, -0.09140146f, -0.03481860f, 0.05613890f, 0.19755396f, -0.02864747f, 0.03268841f, -0.11568157f, 
    0.10015572f, -0.05721191f, -0.01486961f, 0.00803785f, -0.13239640f, 0.08958099f, -0.07543851f, -0.18216302f, 
    0.10798147f, -0.52488881f, -0.14294955f, -0.12369350f, 0.27756920f, 0.26122802f, -0.27317011f, -0.15743615f, 
    0.35412532f, 0.14548033f, -0.02472712f, 0.15596057f, -0.42871368f, 0.04401971f, 0.64191943f, 0.32142016f, 
    -0.13790347f, -0.17733584f, -0.24050398f, 0.00564060f, 0.09235856f, -0.14425263f, 0.02012768f, 0.39981765f, 
    -0.09184328f, -0.11238034f, -0.09398697f, 0.01866069f, 0.12675315f, 0.01014934f, -0.07222702f, 0.08044165f, 
    0.03757789f, -0.02244907f, -0.08264423f, -0.20191781f, -0.10821648f, -0.02998655f, -0.12009037f, -0.12636891f, 
    -0.38177919f, 0.50861138f, 0.23009789f, 0.02409876f, -0.06464476f, -0.10918088f, 0.08137454f, -0.22563751f, 
    0.20483434f, -0.81926340f, -0.37505537f, -0.42654547f, 0.03439979f, 0.06467462f, -0.01856263f, 0.03900592f, 
    0.04369149f, 0.15965118f, -0.07324636f, 0.00440084f, -0.03942009f, 0.17660043f, 0.00762808f, 0.00111702f, 
    0.05101547f, 0.07568991f, 0.06681966f, -0.04446807f, -0.07837816f, -0.56053615f, 0.02629539f, 0.09792516f, 
    -0.00349243f, 0.09402093f, 0.02670668f, 0.02892801f, -0.30145088f, 0.07216271f, -0.02276422f, 0.00605594f, 
    0.13006398f, 0.01313484f, -0.14745493f, 0.07348710f, 0.11813164f, -0.04639526f, -0.22722891f, -0.39413038f, 
    -0.34330431f, -0.06417835f, -0.10842355f, 0.02994447f, -0.00963169f, 0.01954210f, 0.29555067f, 0.05455374f, 
    -0.05934875f, 0.27453887f, -0.10087662f, 0.13797121f, 0.21190366f, 0.34300479f, 0.00511673f, 0.20841913f, 
    0.08138254f, 0.09278309f, 0.02672927f, -0.15605460f, -0.09230880f, 0.03085971f, -0.03832440f, 0.04866266f, 
    -0.52644742f, -0.67691857f, -0.41812882f, 0.20007193f, 0.07011020f, -0.09515332f, 0.16705181f, 0.02652347f, 
    0.19137178f, -0.49355513f, -0.20349655f, -0.12621808f, -0.09109244f, 0.03579762f, -0.06213096f, 0.01342258f, 
    0.00507306f, 0.03159110f, 0.16584860f, -0.17728835f, 0.49694765f, 0.21003139f, 0.18863332f, 0.00299940f, 
    0.14626768f, -0.22052889f, 0.38590845f, -0.34041363f, -0.11704185f, 0.11647394f, 0.05095868f, 0.00599914f, 
    0.13060006f, -0.09417322f, -0.02490499f, 0.20099208f, -0.21287027f, 0.22100843f, -0.07018459f, -0.05504922f, 
    0.05140599f, -0.00653961f, 0.00600662f, 0.06837165f, 0.14000812f, -0.13974102f, -0.30459240f, 0.56822038f, 
    0.00784362f, 0.19239980f, -0.02782503f, -0.01856877f, 0.16985951f, 0.06755041f, 0.10295457f, -0.18983726f, 
    0.05174861f, 0.08640560f, 0.11666657f, 0.05553478f, 0.02494525f, 0.16877224f, 0.11196785f, -0.32437041f, 
    -0.33971560f, -0.38383862f, -0.11029326f, -0.02574746f, -0.09955987f, 0.05140214f, -0.11177206f, 0.11922208f, 
    -0.41385388f, 0.46675912f, 0.42971402f, -0.02001148f, 0.21023253f, -0.26430327f, 0.11485921f, 0.00831790f, 
    -0.08215667f, -0.46366450f, 0.08826162f, -0.06478732f, -0.07060470f, -0.10311542f, -0.24835050f, 0.05658475f, 
    -0.03765148f, 0.06251742f, 0.14737299f, 0.33555418f, 0.07254082f, -0.04514737f, -0.04490641f, 0.15150920f, 
    -0.05669598f, -0.00218414f, 0.00705522f, 0.15924822f, 0.21463180f, 0.33362588f, 0.08931118f, 0.12797651f, 
    -0.06130607f, 0.11785880f, 0.08254432f, 0.23076165f, 0.47271717f, -0.19889759f, 0.09912673f, 0.07052813f, 
    0.13449770f, 0.21786201f, 0.01402512f, 0.17259684f, -0.03826037f, -0.62841237f, -0.27538964f, 0.28798762f, 
    0.24062787f, 0.07007422f, -0.10189353f, -0.20987277f, -0.10068924f, -0.09747215f, -0.02558433f, 0.07378218f, 
    0.01374806f, -0.10852925f, -0.11851741f, -0.23189528f, -0.11690572f, 0.05136289f, 0.08622368f, 0.08799593f, 
    -0.06922724f, -0.17381494f, -0.02918940f, 0.13396303f, 0.01757761f, -0.07473395f, -0.03936039f, 0.07066823f, 
    -0.24759686f, 0.44300056f, 0.30265853f, -0.01814995f, 0.01090801f, 0.00103148f, 0.18167681f, 0.00535252f, 
    0.06347074f, 0.05009833f, -0.63106173f, -0.17721657f, -0.00094326f, 0.02808698f, -0.17440973f, 0.07951542f, 
    -0.05781785f, 0.12739232f, 0.26250276f, -0.19667348f, -0.01056407f, -0.26815224f, 0.04980521f, 0.08752616f, 
    -0.09357953f, -0.00753704f, 0.12314094f, -0.44115999f, -0.14942893f, 0.15306628f, -0.20739500f, -0.07597576f, 
    -0.04663090f, 0.11412776f, -0.09914973f, -0.20054530f, 0.32243711f, 0.12175227f, -0.34460321f, -0.23950092f, 
    0.07808352f, 0.17733023f, 0.00023398f, 0.12933262f, 0.25713247f, -0.10754614f, 0.15557876f, -0.30137891f, 
    -0.25670430f, 0.10273594f, -0.07623538f, 0.06116842f, 0.08762915f, -0.14012006f, -0.44457272f, 0.15807262f, 
    -0.09561229f, -0.19642980f, 0.11046401f, 0.02249631f, -0.01803233f, 0.12610255f, 0.08037122f, -0.09801479f, 
    -0.03539585f, -0.13092729f, -0.01891109f, 0.00526791f, 0.03828367f, 0.12935023f, -0.14654879f, 0.26416048f, 
    -0.04181750f, 0.00361098f, -0.05551270f, -0.00135903f, -0.02852907f, -0.02732768f, 0.00041220f, 0.03064750f, 
    0.00523545f, 0.00333081f, 0.00232533f, -0.01752408f, -0.06164593f, -0.04313885f, -0.04278104f, 0.03492071f, 
    0.05082333f, 0.01780172f, 0.03545607f, -0.03884714f, -0.04416829f, 0.02485342f, -0.00442051f, 0.00476311f, 
    -0.01891447f, -0.00667550f, 0.05174912f, 0.03076687f, -0.01043041f, -0.06719737f, 0.00978494f, -0.06688649f, 
    0.00425018f, 0.02858792f, -0.01921186f, -0.00506309f, 0.02580928f, -0.03975317f, 0.00170162f, 0.00377981f, 
    -0.02318459f, 0.01401511f, 0.05120718f, -0.00055008f, 0.02453833f, -0.05549331f, 0.03198785f, 0.02681984f, 
    0.02766840f, -0.06463030f, 0.00795427f, -0.01300068f, -0.03444580f, -0.06203511f, -0.04784778f, -0.00604077f, 
    -0.04054670f, -0.05130986f, 0.01593942f, 0.01344539f, 0.00765493f, 0.03218381f, -0.00553952f, 0.02358515f, 
    -0.03873521f, 0.01015561f, -0.03593005f, -0.01998811f, 0.00568988f, -0.04314016f, -0.05356974f, -0.04872582f, 
    -0.02774599f, 0.02756390f, 0.03798475f, 0.04772332f, -0.03546067f, 0.00407215f, 0.02983578f, 0.00045507f, 
    -0.05622737f, 0.02209756f, -0.00775994f, 0.01857821f, -0.06531791f, 0.01156736f, -0.02843235f, -0.05960234f, 
    0.01527125f, -0.01221369f, -0.00524920f, -0.04604176f, -0.01093715f, -0.00242256f, -0.00580415f, -0.03449127f, 
    0.02550679f, 0.01140107f, -0.02306952f, -0.06074255f, 0.00652132f, -0.05666171f, -0.06302781f, 0.03832689f, 
    -0.05648057f, 0.04746241f, -0.03870762f, -0.06029511f, 0.01733748f, -0.05158198f, 0.03353192f, 0.03207374f, 
    0.04149967f, -0.04612514f, 0.01160298f, 0.04816389f, 0.03857923f, 0.02452224f, -0.01174024f, -0.03317016f, 
    0.03775783f, -0.04557049f, 0.01437837f, -0.02272886f, 0.00563590f, 0.02377707f, -0.02628526f, -0.03034327f, 
    0.02622828f, -0.03274658f, -0.00036655f, -0.05593988f, -0.03537342f, 0.01024931f, -0.05459132f, 0.03168910f, 
    -0.03327431f, 0.02579490f, -0.04918971f, -0.00979037f, 0.02704606f, -0.04187401f, 0.00704553f, 0.04303072f, 
    0.00390803f, -0.02283474f, 0.01174487f, -0.02248652f, -0.00591044f, -0.04108664f, -0.03798277f, -0.01938779f, 
    -0.03167644f, 0.03827452f, 0.03342771f, 0.01732605f, -0.05617360f, 0.01312152f, 0.02086370f, -0.05747023f, 
    -0.00470650f, -0.02233430f, 0.04798508f, 0.02020159f, -0.05920237f, 0.02868514f, 0.01794399f, -0.03838165f, 
    -0.05857831f, -0.03053402f, 0.04829908f, 0.04022275f, -0.02071428f, 0.02561351f, -0.04983247f, 0.00946440f, 
    0.01360329f, -0.06650371f, -0.05020887f, -0.04360767f, 0.04187518f, -0.00400375f, 0.00905921f, 0.01424861f, 
    -0.04502000f, -0.06689486f, 0.04764425f, 0.04010967f, 0.04248912f, 0.00958142f, 0.04657752f, 0.00974901f, 
    -0.05280811f, -0.00059875f, 0.02342303f, -0.01673384f, -0.06048169f, -0.02747180f, 0.03351627f, -0.05885314f, 
    0.01635478f, -0.04095477f, -0.03568340f, 0.01812715f, -0.02041711f, 0.03081747f, 0.00976680f, -0.02778537f, 
    0.03250851f, -0.04286379f, -0.04647257f, -0.00145313f, -0.03966527f, 0.03742035f, -0.03347668f, 0.04833955f, 
    0.03663560f, -0.04361648f, -0.05320618f, -0.06342835f, -0.02827149f, 0.04943044f, 0.03552078f, -0.03879661f, 
    0.04822706f, 0.01721554f, 0.00365862f, 0.00886103f, -0.06043122f, 0.03054012f, -0.02495083f, 0.00297687f, 
    -0.06642657f, 0.02755941f, 0.00927847f, 0.03413573f, -0.06222957f, -0.05976918f, -0.03306865f, -0.03039103f, 
    -0.04928876f, -0.00491939f, -0.06374944f, -0.03740975f, -0.01308081f, -0.02814488f, -0.03524214f, 0.02988244f, 
    -0.02958312f, -0.04772969f, -0.01528770f, -0.04818147f, 0.01715132f, -0.02034443f, 0.00214607f, 0.00708462f, 
    -0.00924374f, -0.05240398f, -0.02595462f, -0.02287355f, 0.03199281f, 0.03793718f, 0.02788658f, -0.01830088f, 
    0.00044899f, 0.03846586f, 0.00141512f, -0.04709019f, -0.02272528f, 0.02351732f, 0.03480596f, -0.06300180f, 
    -0.05435930f, 0.03531250f, -0.02203871f, 0.00724278f, 0.00305824f, 0.04946982f, -0.05476542f, -0.03383576f, 
    -0.04758381f, -0.05966600f, 0.03294079f, -0.04649026f, -0.01067163f, -0.05568627f, 0.01986430f, 0.02376006f, 
    0.03770692f, -0.16665578f, 0.16764182f, -0.19850414f, 0.01685227f, -0.04777141f, 0.05100567f, -0.12707174f, 
    0.18404792f, -0.07213905f, 0.00143551f, 0.08231211f, 0.04642140f, 0.05248199f, -0.02443114f, -0.10560650f, 
    -0.00962156f, -0.10817742f, -0.12914295f, 0.09503982f, 0.05523359f, -0.15712528f, -0.00073960f, -0.47247815f, 
    -0.17309409f, 0.08878720f, -0.10493551f, 0.28486836f, 0.01995965f, 0.33514655f, -0.07247691f, 0.14652760f, 
    -0.08563613f, 0.08203565f, 0.07704150f, -0.05713159f, 0.06495760f, 0.09103918f, 0.27696744f, -0.04566732f, 
    -0.03892118f, -0.19407359f, 0.07243893f, 0.04019743f, 0.08112005f, 0.29764622f, -0.03265154f, 0.25869322f, 
    0.07014353f, 0.03907984f, 0.03092186f, 0.06586374f, -0.09133814f, 0.13768740f, 0.01762076f, 0.29387113f, 
    -0.00660496f, -0.16894652f, 0.20485586f, -0.22977415f, 0.03484143f, -0.01670985f, -0.19167887f, -0.25420448f, 
    0.15202585f, -0.05200362f, -0.06159445f, 0.14547789f, 0.14807500f, 0.27366573f, 0.10335302f, -0.02602410f, 
    0.23947135f, 0.38411319f, 0.06605850f, -0.07501207f, 0.19596082f, 0.01628145f, 0.00675878f, -0.26134646f, 
    0.03583858f, 0.01214924f, 0.05130926f, 0.37016395f, -0.02867113f, 0.15811428f, 0.09267341f, -0.15410943f, 
    0.23137049f, -0.24620837f, -0.04391631f, 0.25175312f, 0.09440196f, -0.22705266f, -0.00193537f, 0.00255358f, 
    0.23075619f, 0.27883351f, 0.11591714f, -0.10833129f, 0.04266353f, 0.00814714f, -0.05464656f, -0.40813774f, 
    -0.21460952f, -0.01978967f, -0.04126751f, -0.02909600f, -0.10863306f, 0.09611568f, 0.06351501f, -0.03587255f, 
    0.03678770f, 0.06766149f, -0.24091871f, -0.29208088f, -0.22747144f, -0.04848585f, 0.20213895f, -0.07298497f, 
    -0.17226081f, 0.11151676f, 0.08806544f, -0.31042632f, 0.21297507f, 0.14757340f, 0.04914279f, 0.31976300f, 
    -0.08522586f, -0.15964894f, -0.01006847f, -0.13859931f, -0.07500368f, -0.01646531f, 0.03090427f, 0.34679168f, 
    0.28959572f, 0.44681630f, -0.01720790f, 0.11668076f, 0.15256330f, 0.05314481f, -0.22342515f, 0.05273694f, 
    0.04576451f, -0.11549485f, 0.17083322f, -0.04466531f, -0.13078050f, 0.02592013f, 0.09211513f, -0.00790967f, 
    0.01418982f, -0.18578392f, -0.07030005f, -0.17023869f, 0.06620251f, 0.06672108f, 0.04141944f, -0.37723988f, 
    -0.12923644f, -0.23920986f, 0.42887953f, -0.02227822f, -0.10737859f, 0.00756460f, 0.00729193f, -0.09423397f, 
    0.01176486f, -0.12349908f, -0.13735163f, -0.23476937f, -0.07495853f, -0.06841713f, -0.03314003f, 0.07391614f, 
    0.01520963f, -0.09497536f, -0.10753065f, -0.04660735f, -0.03795812f, 0.14870560f, 0.19545451f, -0.18946372f, 
    0.13474539f, 0.13917111f, -0.25613907f, 0.18906698f, 0.05280192f, 0.32679945f, -0.12306687f, 0.05419528f, 
    -0.04026176f, -0.09248100f, -0.45364746f, 0.05149735f, -0.01710467f, -0.03063579f, -0.15557301f, 0.03180723f, 
    -0.04410694f, -0.03609024f, 0.04198633f, 0.14836685f, -0.09491613f, -0.03334412f, 0.08845071f, -0.57351190f, 
    0.19573654f, 0.28876111f, -0.02023378f, 0.17595956f, 0.20346434f, 0.08107436f, -0.18616240f, -0.06731120f, 
    0.28899741f, -0.21124351f, -0.03107000f, 0.00119214f, -0.09679173f, -0.01523512f, 0.00910681f, -0.33802664f, 
    -0.09341071f, 0.16651396f, 0.35732394f, 0.08601583f, -0.05876457f, 0.06779227f, -0.01890580f, 0.12776028f, 
    -0.16612241f, 0.21167468f, -0.10729831f, 0.51646310f, 0.07325233f, -0.05837244f, 0.16940752f, 0.17223452f, 
    0.11771008f, -0.06557010f, -0.02192165f, 0.16376004f, 0.05160838f, 0.05402774f, 0.08184897f, 0.15846619f, 
    0.27840027f, 0.09789339f, 0.14329536f, -0.03359196f, -0.10483255f, 0.66106218f, -0.28062105f, -0.12863481f, 
    -0.08659507f, -0.23280683f, -0.09780823f, 0.20584947f, -0.11169390f, 0.14388867f, -0.29496685f, 0.25184947f, 
    -0.08401214f, -0.23377943f, 0.07113353f, 0.06924108f, -0.01195920f, -0.03146022f, 0.03784752f, -0.30739194f, 
    0.24365553f, 0.04108119f, -0.06264687f, -0.02301513f, -0.05592573f, -0.07121743f, -0.07500484f, -0.05668560f, 
    0.10674426f, 0.06036255f, -0.30016506f, -0.17457364f, -0.46537510f, -0.02807246f, 0.07808832f, -0.15987416f, 
    -0.09501783f, 0.02395124f, 0.31701463f, 0.12465922f, 0.05285122f, 0.07526265f, 0.09731184f, 0.19852689f, 
    -0.03113498f, -0.04862900f, -0.59795296f, -0.73467755f, 0.07713421f, 0.10510229f, -0.05540546f, -0.03204634f, 
    -0.04930932f, 0.01481047f, 0.08272161f, 0.16257635f, 0.10835023f, 0.13817786f, -0.09946647f, -0.05128476f, 
    0.05415576f, -0.10252637f, -0.10450792f, -0.29030883f, -0.24387828f, -0.29117072f, 0.13917202f, -0.01921050f, 
    0.01640079f, 0.11021341f, -0.07241498f, 0.04684657f, -0.22870596f, 0.14682791f, -0.07230558f, 0.00816425f, 
    -0.18085982f, -0.06942303f, 0.03268520f, 0.06051721f, -0.21094018f, 0.19519238f, 0.44140518f, 0.10690636f, 
    -0.12703094f, -0.07655190f, 0.16007572f, 0.09617641f, 0.02132026f, 0.03835209f, -0.71018583f, 0.14417574f, 
    0.41385114f, 0.18201359f, 0.16072927f, -0.07604107f, 0.34220651f, -0.27099743f, 0.20373322f, 0.17718497f, 
    0.12247711f, -0.01943613f, -0.02575014f, 0.01347349f, -0.22622387f, -0.08953325f, -0.01703772f, 0.01212866f, 
    -0.18952151f, -0.26769286f, -0.64947104f, 0.15681057f, 0.02545549f, 0.06650308f, -0.01238113f, -0.03315673f, 
    0.10392926f, 0.16852148f, -0.81243533f, -0.48557934f, 0.00018277f, -0.11823346f, -0.16099302f, 0.01974951f, 
    0.00527912f, 0.05793871f, 0.21918224f, 0.08071309f, -0.06189888f, 0.25971001f, 0.25867915f, 0.10650201f, 
    0.00263263f, 0.08131804f, 0.33568445f, 0.01318091f, 0.11016779f, -0.01592617f, -0.05328034f, -0.09651740f, 
    -0.07973439f, -0.01804275f, 0.02972335f, 0.13195360f, -0.29088184f, -0.42699453f, -0.08675482f, 0.10707636f, 
    0.19829983f, 0.13815461f, -0.00744972f, -0.03421423f, -0.06122031f, -0.01737078f, -0.37701398f, 0.04044487f, 
    0.05065394f, 0.31312212f, 0.00553745f, 0.15170158f, 0.03638410f, -0.12841918f, 0.22332717f, 0.12628363f, 
    -0.16130280f, 0.13729836f, -0.17708893f, 0.13950852f, 0.18351705f, 0.05910307f, -0.02877976f, 0.12050184f, 
    -0.01759837f, -0.33754551f, 0.06285367f, -0.19158538f, 0.04580344f, -0.07099455f, -0.13276483f, 0.05201061f, 
    -0.37640831f, 0.21862896f, -0.00613527f, 0.11842825f, -0.00987532f, -0.05353337f, -0.05378275f, 0.07638157f, 
    -0.01549881f, -0.02192742f, -0.39206976f, -0.13038054f, -0.07031894f, 0.02580203f, 0.03019879f, 0.00474866f, 
    -0.02333206f, -0.06015013f, 0.33883426f, 0.06592380f, -0.37687609f, 0.04724524f, -0.12865640f, 0.10379167f, 
    0.03436219f, -0.01019691f, 0.29567394f, 0.28197750f, -0.48223346f, 0.08698544f, 0.20875861f, 0.07071764f, 
    0.22103363f, 0.02895945f, 0.10790326f, -0.02170475f, 0.64832324f, -0.05646920f, -0.32637018f, 0.09142791f, 
    0.17440090f, 0.18289407f, 0.12182810f, 0.19347091f, -0.23180519f, -0.01283649f, 0.13686988f, -0.54265279f, 
    -0.07247608f, -0.23682955f, 0.00275724f, -0.18495227f, 0.04155276f, 0.06256351f, 0.01835489f, 0.08225888f, 
    -0.13082625f, -0.01465652f, 0.05131263f, 0.04556026f, 0.01728112f, -0.10064184f, -0.03354432f, 0.58282399f, 
    -0.46644059f, -0.01760344f, 0.10072508f, 0.11150865f, -0.06357899f, 0.16488576f, 0.01851736f, -0.02497124f, 
    0.15212287f, -0.21359749f, -0.25189081f, -0.07130093f, 0.08131617f, 0.15445538f, -0.05230653f, 0.02986857f, 
    0.07846621f, 0.02115130f, 0.15328729f, -0.36649454f, -0.09844277f, -0.18668696f, -0.13796462f, 0.04918452f, 
    -0.02913678f, 0.04734140f, 0.57027847f, -0.15333679f, -0.24605905f, 0.07917850f, 0.29598492f, 0.01360998f, 
    0.07062238f, 0.11425389f, -0.08518767f, -0.08548050f, 0.03610906f, -0.11825438f, -0.09341117f, 0.03480048f, 
    0.02683996f, 0.05585952f, -0.06674162f, 0.11869444f, -0.48449647f, 0.04464934f, 0.21036795f, 0.15320350f, 
    0.10669655f, 0.35692960f, 0.30565250f, -0.06455773f, -0.13288645f, 0.20938011f, -0.90927619f, -0.14763004f, 
    -0.28760546f, -0.26862535f, -0.12866007f, 0.14774446f, 0.02425785f, 0.17941244f, 0.00137756f, -0.04788649f, 
    0.01660413f, -0.01751369f, 0.06271673f, -0.11255474f, 0.02139113f, 0.02142141f, -0.09608207f, 0.04440763f, 
    0.19522943f, -0.04123536f, -0.04155597f, -0.01351556f, 0.05493205f, -0.14551352f, -0.07511249f, 0.01985410f, 
    -0.11273399f, 0.04736711f, 0.12207880f, 0.07862183f, 0.12717958f, -0.13561922f, 0.01657259f, 0.05829126f, 
    -0.12406225f, -0.04853309f, 0.23623367f, 0.14188792f, 0.16011937f, 0.00035060f, 0.11698253f, -0.01163055f, 
    -0.06030015f, 0.03998002f, 0.22038317f, 0.00869970f, -0.12843001f, 0.12336453f, 0.25211194f, 0.16413721f, 
    0.20617811f, -0.07632768f, -0.31135160f, -0.04995735f, -0.08140282f, 0.31381822f, 0.12334467f, 0.06079076f, 
    0.02087626f, -0.10359613f, 0.15586533f, 0.07119257f, -0.06211185f, -0.17397521f, 0.10927291f, -0.01697778f, 
    -0.02004709f, 0.07997140f, -0.40608111f, -0.33160841f, -0.39119026f, -0.06586944f, -0.02864783f, 0.31853548f, 
    0.01655631f, 0.06190963f, 0.24202614f, -0.07464726f, -0.01931745f, 0.08271161f, 0.11815377f, -0.04924285f, 
    0.18751094f, -0.08961249f, 0.05728067f, 0.23737790f, -0.06588105f, 0.23417442f, 0.10558200f, 0.15820487f, 
    0.08981848f, -0.17423034f, 0.09610887f, -0.04369812f, 0.00554949f, -0.03786533f, 0.05688838f, -0.09001744f, 
    -0.17504942f, -0.03595051f, -0.00302800f, -0.03013640f, 0.18217832f, 0.02747794f, -0.03271085f, -0.22155839f, 
    -0.18209848f, -0.00934265f, 0.12147297f, 0.32690185f, 0.37974069f, 0.17455696f, -0.15593119f, -0.08854005f, 
    0.03217179f, 0.02838630f, -0.17652628f, -0.06409713f, -0.05207023f, 0.05965895f, -0.10418393f, 0.18231137f, 
    0.07076935f, -0.19517291f, 0.06454816f, 0.23487024f, 0.01653475f, -0.11060763f, 0.00089937f, 0.02324012f, 
    0.03680102f, -0.11415628f, -0.23409085f, -0.22994722f, 0.20142637f, 0.01819493f, -0.00823346f, 0.09221289f, 
    0.07468946f, 0.18939126f, 0.01084033f, 0.12412947f, 0.14704655f, -0.06980895f, -0.03206104f, -0.09399835f, 
    0.35786638f, -0.15808511f, -0.10007502f, 0.15820377f, -0.15394978f, 0.31617135f, -0.00099785f, 0.10812463f, 
    0.08187055f, 0.02562219f, 0.01550578f, 0.00730857f, 0.12032451f, -0.56293064f, -0.39843056f, 0.02489751f, 
    -0.02568326f, -0.01248779f, -0.04618496f, 0.24301644f, 0.07421269f, -0.18973462f, -0.31568301f, -0.32538369f, 
    -0.11998492f, -0.39211398f, 0.25346908f, -0.07795110f, 0.03834924f, -0.01714578f, 0.11186926f, 0.07163227f, 
    0.02098148f, 0.07905941f, 0.20734496f, 0.12853049f, 0.10895990f, -0.08263941f, 0.17829902f, 0.09052718f, 
    0.11858729f, 0.21306995f, 0.00636012f, -0.10947437f, 0.02335624f, 0.10545819f, -0.07785267f, 0.04402805f, 
    0.18463758f, 0.06178811f, 0.14954868f, 0.09262023f, 0.08870119f, -0.02391252f, 0.02500015f, -0.06354695f, 
    -0.02674397f, 0.29459387f, -0.00888285f, 0.11225457f, -0.02895159f, 0.31380510f, 0.02910212f, 0.08226626f, 
    -0.04395945f, -0.23368014f, 0.28932685f, -0.01992631f, -0.04500164f, 0.03875071f, -0.21259153f, 0.01977046f, 
    0.05557070f, -0.03578978f, 0.12031893f, 0.11056124f, -0.14910294f, 0.06459586f, 0.17121615f, -0.09835996f, 
    -0.34985527f, 0.11280879f, 0.02194181f, -0.03621757f, 0.08478736f, 0.19829769f, 0.07991852f, 0.38037062f, 
    0.26525465f, -0.60245079f, -0.00458812f, -0.24464685f, -0.00355445f, 0.00844534f, -0.01232102f, 0.07096628f, 
    -0.13410622f, 0.04993481f, 0.13522087f, 0.16752706f, 0.12018045f, -0.02981140f, -0.00488733f, 0.19273077f, 
    0.06949585f, -0.10230970f, -0.17030582f, -0.04464412f, 0.05901871f, 0.12923239f, 0.14158109f, 0.01201332f, 
    -0.05558141f, -0.07536652f, 0.24940400f, 0.21693330f, -0.23377615f, -0.02504995f, -0.16354215f, -0.01463689f, 
    0.09619345f, -0.28616047f, -0.11793811f, -0.44994316f, -0.34890777f, -0.26503566f, 0.09037927f, 0.03753751f, 
    0.07353655f, 0.03118267f, -0.18892668f, -0.10469319f, 0.40366375f, 0.02168129f, -0.13715489f, 0.23118681f, 
    -0.05427775f, -0.09702725f, 0.07495674f, 0.06907059f, -0.01350648f, -0.07455193f, -0.19766298f, 0.28670222f, 
    0.02822268f, 0.09852110f, 0.05212520f, 0.11262718f, 0.17970373f, 0.04207610f, -0.04558522f, -0.15663834f, 
    0.16465245f, 0.10136790f, 0.02168990f, 0.08923075f, 0.01854987f, -0.11518766f, -0.03390691f, 0.24920149f, 
    -0.11264691f, 0.01205374f, 0.13589677f, 0.05952380f, 0.12077238f, -0.00906522f, -0.19248386f, 0.10353123f, 
    0.15202786f, -0.16589388f, 0.45605633f, -0.06768145f, 0.08961206f, -0.05554205f, 0.00449260f, 0.04509371f, 
    -0.06450069f, 0.08380177f, -0.06943335f, 0.14444770f, 0.04571569f, -0.21977875f, -0.03453580f, 0.03916522f, 
    -0.08446080f, 0.00223245f, -0.30393857f, -0.39895916f, -0.03415433f, -0.08007906f, 0.09306630f, -0.02784874f, 
    -0.00330953f, 0.26162133f, -0.05911995f, -0.13823491f, -0.16835487f, 0.51468742f, -0.11791766f, 0.01587752f, 
    -0.08670077f, -0.04512880f, 0.13279486f, 0.17381790f, -0.01444801f, -0.14741606f, -0.01648982f, -0.09667791f, 
    0.13980359f, -0.03784451f, 0.16213910f, -0.08183537f, 0.10314599f, -0.09619509f, -0.12349160f, 0.35403571f, 
    -0.10709101f, -0.10912727f, -0.24265401f, 0.05621745f, 0.19401672f, 0.08462188f, -0.75591785f, -0.31414688f, 
    0.42218998f, -0.13252492f, 0.16043375f, 0.03347262f, 0.13188703f, 0.03878779f, -0.06187804f, -0.29692596f, 
    0.07635707f, -0.00112591f, -0.00380248f, -0.11052348f, -0.12656200f, 0.19428740f, 0.05400627f, -0.00474068f, 
    -0.08105685f, 0.11890621f, 0.32001853f, -0.11119104f, 0.13768420f, 0.00641804f, -0.00981306f, -0.09183999f, 
    0.07260136f, 0.16656412f, 0.22796325f, 0.07704436f, -0.00681249f, -0.07699566f, -0.02014816f, 0.07742850f, 
    -0.00747812f, 0.01737560f, -0.00438344f, -0.29995099f, 0.37569052f, 0.18613587f, -0.06761963f, 0.05180470f, 
    -0.02983463f, -0.12580265f, 0.42738003f, -0.31438980f, 0.01600419f, -0.13554949f, 0.09556978f, 0.13967954f, 
    0.05234590f, 0.13931668f, 0.22503413f, 0.16578670f, -0.08745202f, -0.03933279f, 0.20011236f, 0.07126928f, 
    0.10993690f, 0.11344530f, -0.01408873f, 0.08848038f, -0.04868020f, 0.30572066f, -0.40595719f, -0.01340283f, 
    0.38393897f, -0.32159999f, 0.07262884f, -0.01213591f, -0.26116890f, -0.16354458f, 0.26975098f, 0.17817089f, 
    -0.11157873f, -0.38994220f, 0.04244541f, 0.15737101f, 0.02963834f, 0.04143341f, -0.11775446f, 0.12898111f, 
    0.00032464f, 0.28348657f, -0.16355976f, -0.02992907f, -0.06080763f, 0.02979967f, 0.02864202f, 0.02247889f, 
    -0.01774333f, -0.26373407f, 0.14275445f, 0.07329111f, 0.06199633f, 0.08957012f, 0.01894990f, 0.04991921f, 
    0.10069341f, 0.56562245f, -0.52701098f, -0.33236936f, -0.04823792f, -0.11256417f, -0.03857704f, -0.06999750f, 
    0.10285289f, -0.05237287f, -0.29013467f, -0.02855649f, 0.14884736f, -0.18260612f, 0.13160317f, -0.00442357f, 
    0.03715631f, -0.02273422f, -0.01788981f, 0.27892137f, -0.21251415f, 0.17414406f, -0.02916835f, 0.13697238f, 
    0.08280696f, 0.17037529f, -0.02610045f, 0.36693975f, 1.19144547f, 0.06146063f, -0.78167892f, -0.04906988f, 
    -0.23278868f, 0.11117791f, 0.11711909f, 0.12704568f, -0.14924130f, -0.61160940f, 0.41258258f, -0.28439358f, 
    -0.10728282f, -0.02396310f, -0.04323632f, 0.12016859f, 0.07260618f, 0.27171838f, 0.22911726f, -0.35284445f, 
    0.01931146f, -0.10156181f, -0.21880664f, -0.32124287f, 0.15844221f, -0.05025543f, -0.11269643f, 0.28833583f, 
    -0.00734101f, -0.15811490f, -0.31124008f, 0.10832138f, -0.00350136f, -0.18276680f, -0.07627517f, -0.28833902f, 
    -0.00290683f, 0.07496248f, -0.00206559f, -0.11204796f, -0.15876083f, -0.05357301f, -0.04584221f, 0.12236302f, 
    0.05976637f, -0.06439467f, -0.04838930f, 0.17901960f, 0.03920145f, -0.01477155f, -0.02857038f, 0.06151793f, 
    -0.13329135f, 0.05972118f, 0.04315056f, 0.08939317f, 0.15049808f, -0.34428149f, -0.00410683f, -0.30745071f, 
    0.04213515f, -0.18085618f, 0.12250872f, -0.24527608f, -0.70032132f, -0.00040018f, 0.07701299f, -0.45238376f, 
    -0.15234238f, 0.00499796f, -0.22733673f, 0.13528472f, -0.45546061f, -0.34677330f, -0.30815351f, 0.00264661f, 
    0.10872594f, 0.10484120f, -0.20938849f, 0.05915203f, 0.00048327f, -0.13225351f, -0.09476268f, -0.41488343f, 
    -0.08892413f, -0.05252532f, 0.13046652f, 0.03904505f, 0.09532541f, 0.05947175f, -0.00902233f, -0.08536531f, 
    0.15712111f, -0.09147373f, -0.13167165f, 0.02334970f, 0.09571091f, 0.01521920f, -0.11583161f, -0.13776092f, 
    -0.25162050f, 0.25182283f, 0.10231389f, 0.12872104f, -0.08698177f, 0.26226175f, -0.02396555f, 0.07845233f, 
    0.07156774f, -0.11334547f, -0.00833962f, 0.09049682f, -0.23310275f, -0.01797247f, -0.06022504f, 0.13391592f, 
    0.19064282f, 0.05426031f, -0.08939928f, -0.01959330f, -0.03415012f, -0.11052117f, -0.06245988f, -0.02950613f, 
    0.18297267f, -0.05289559f, 0.02130883f, -0.04998021f, -0.03850124f, 0.03773754f, 0.19020183f, -0.03905299f, 
    0.10253411f, -0.20037022f, -0.08132675f, 0.20580052f, 0.21706061f, -0.06329495f, -0.00260955f, -0.15876821f, 
    -0.00321049f, -0.11913057f, 0.07483967f, -0.11175828f, -0.19263199f, -0.06049144f, 0.10424128f, 0.09241779f, 
    0.06210628f, 0.11393759f, 0.15727773f, -0.15249850f, 0.01666413f, 0.13408159f, 0.05724989f, -0.05678738f, 
    -0.19262524f, -0.13427879f, -0.25667101f, 0.04917401f, 0.12504919f, 0.05229697f, 0.57866216f, 0.11734119f, 
    0.26625547f, -0.20943312f, 0.17452937f, 0.06008191f, -0.05744996f, 0.11263318f, -0.15655744f, 0.04350889f, 
    -0.27104327f, 0.11557270f, -0.17997061f, 0.01200007f, 0.22599073f, 0.12111265f, 0.02233296f, 0.14840505f, 
    0.03570263f, -0.23638216f, -0.17138667f, 0.14981017f, -0.03949474f, 0.05384988f, -0.15862778f, -0.14015965f, 
    -0.17876793f, 0.01680634f, -0.07015507f, -0.27987361f, 0.16434118f, 0.17017837f, -0.19692993f, -0.07575544f, 
    0.01746221f, 0.17215379f, -0.14847277f, 0.16409159f, -0.25520381f, -0.01824092f, -0.14900291f, 0.17678365f, 
    0.08666281f, 0.03614717f, -0.10165496f, -0.34096822f, -0.10083030f, 0.23967883f, 0.00699073f, 0.24080470f, 
    0.28094673f, 0.08048578f, -0.19031514f, 0.03760094f, 0.03336339f, 0.09600767f, 0.04545986f, 0.03965527f, 
    -0.03287452f, -0.03856127f, 0.04757909f, 0.16276594f, 0.11155859f, -0.04584706f, -0.12668511f, -0.31974480f, 
    -0.08833396f, -0.26348102f, 0.06092631f, -0.00418983f, 0.03002779f, 0.23536418f, -0.06420667f, -0.00303637f, 
    0.10918408f, 0.03151472f, -0.01468226f, -0.07804893f, 0.30811891f, 0.06727383f, 0.26026371f, 0.05114347f, 
    -0.15520911f, -0.09393331f, 0.08668650f, -0.07757315f, -0.06503768f, -0.18344238f, -0.12068082f, -0.31123996f, 
    0.04761566f, 0.24661174f, 0.01560054f, 0.09823108f, 0.11251146f, 0.07503707f, 0.07725152f, -0.09120579f, 
    -0.18226270f, -0.10562555f, -0.24705513f, 0.26025224f, -0.09809181f, 0.04672679f, -0.05057870f, -0.01662672f, 
    0.11425369f, 0.00841396f, 0.35457751f, 0.12429126f, -0.04922523f, -0.28957734f, -0.06403469f, -0.20026352f, 
    0.07920238f, 0.01212107f, 0.05442584f, 0.10656458f, -0.03736896f, 0.10128105f, -0.14660715f, -0.10908952f, 
    0.08271490f, -0.04885902f, 0.09947351f, 0.18996459f, -0.16495128f, -0.12420806f, 0.15365244f, -0.14322837f, 
    -0.01086493f, 0.01895676f, -0.11886130f, 0.00971419f, 0.11682385f, -0.48563653f, -0.02643137f, 0.10866770f, 
    -0.02044434f, 0.36185944f, 0.38723698f, 0.08869021f, -0.23607935f, -0.12953229f, 0.19137993f, -0.10528705f, 
    0.06809139f, 0.06252445f, -0.05733790f, 0.06122228f, 0.13483351f, 0.02202206f, 0.05460186f, -0.34565499f, 
    0.10170045f, -0.26811010f, -0.23016289f, 0.21230601f, 0.01167322f, 0.00234655f, 0.26458675f, 0.10410483f, 
    0.19346012f, 0.08794095f, 0.01300347f, -0.01162531f, -0.03654484f, -0.03481593f, -0.05312941f, 0.07981075f, 
    0.19108245f, 0.34406686f, -0.20734021f, -0.26605850f, 0.16854019f, -0.24950264f, -0.22126688f, 0.02310412f, 
    0.02568402f, -0.16111930f, 0.00930681f, 0.04535585f, 0.12141209f, -0.35236415f, -0.24134544f, -0.19139691f, 
    0.11057936f, 0.01918242f, -0.04346238f, -0.30111969f, 0.07514678f, -0.22196653f, -0.00402353f, -0.09954611f, 
    0.02215356f, 0.11018505f, -0.24956878f, 0.26115593f, 0.48664439f, 0.27290118f, -0.27193627f, -0.14937635f, 
    0.17523606f, 0.03797977f, 0.24424040f, 0.28871998f, -0.20763548f, 0.25346065f, 0.22484057f, -0.31047851f, 
    0.11025732f, 0.05290790f, -0.14773896f, 0.12325999f, 0.00892727f, 0.21496923f, 0.17292273f, 0.08373497f, 
    -0.16994767f, 0.15517348f, 0.11834446f, -0.03347539f, 0.04913973f, 0.07471175f, 0.03908676f, -0.06246361f, 
    -0.33275414f, 0.04191876f, 0.01145376f, 0.18489623f, 0.07865790f, 0.17493193f, 0.14730798f, 0.29031050f, 
    0.11942034f, 0.33401337f, -0.02971952f, 0.04329761f, -0.00257893f, 0.15537737f, 0.13289358f, 0.03211061f, 
    0.20108822f, 0.12785096f, -0.19271733f, -0.11753641f, 0.01057410f, 0.05039861f, 0.16976239f, 0.03362462f, 
    -0.00256197f, -0.02678512f, 0.00399485f, -0.05135357f, 0.01326346f, 0.02795727f, 0.21825370f, 0.08695851f, 
    0.10950929f, -0.16502555f, 0.00515101f, 0.10640990f, -0.07410293f, 0.17856778f, 0.00187345f, 0.08126315f, 
    0.06299528f, 0.07596322f, 0.03935951f, -0.33629665f, 0.07557678f, 0.20771855f, 0.04301145f, -0.11582418f, 
    -0.03072582f, 0.07815444f, -0.06248567f, 0.00243156f, -0.10248977f, -0.29693264f, -0.53274304f, -0.12433112f, 
    0.03122199f, 0.20064996f, 0.18173990f, 0.07609510f, 0.04824480f, -0.29977858f, -0.10396774f, 0.26438117f, 
    0.37964198f, 0.23957783f, -0.25547904f, 0.23004889f, 0.09373984f, 0.27887398f, 0.13668373f, -0.08267966f, 
    -0.00928225f, 0.07747953f, 0.10901506f, -0.02266841f, 0.03337127f, -0.00893562f, 0.03756801f, -0.00991721f, 
    0.23089068f, 0.07555699f, 0.13794658f, -0.01733670f, 0.14382140f, -0.01476873f, 0.04823864f, 0.12875968f, 
    -0.01785651f, -0.20747513f, -0.15361916f, -0.10519224f, 0.05565640f, 0.01023031f, 0.10977375f, 0.14983015f, 
    -0.06412205f, -0.15688953f, 0.23110589f, 0.14608395f, 0.21802314f, 0.04226822f, 0.03883657f, 0.34273675f, 
    0.04344538f, 0.05539609f, 0.30431801f, -0.04432254f, -0.08035743f, 0.01508199f, 0.10283457f, 0.07564702f, 
    0.11848505f, -0.16241054f, 0.15123563f, -0.13038895f, 0.06726699f, -0.00297153f, 0.14668441f, 0.04478517f, 
    -0.00453447f, 0.03332152f, 0.06228546f, -0.09957270f, -0.04247591f, 0.08158506f, 0.03307232f, 0.02048207f, 
    -0.10149891f, 0.03473158f, 0.08376735f, 0.03225684f, 0.05583318f, 0.13053502f, 0.03224377f, 0.17140162f, 
    -0.10298428f, 0.01585204f, 0.15655999f, -0.06221440f, 0.13099569f, 0.05811728f, -0.23057710f, 0.23652951f, 
    0.06068416f, -0.04548521f, -0.16258395f, 0.05337099f, 0.05242272f, -0.06964938f, 0.12873946f, -0.03424233f, 
    0.17964065f, 0.21998595f, 0.25497958f, -0.10071113f, -0.14751820f, -0.04180385f, -0.04069096f, -0.07827660f, 
    -0.14068031f, 0.09850386f, -0.15208344f, -0.00455514f, 0.01302150f, 0.04649850f, -0.09934818f, 0.03452700f, 
    -0.20018885f, -0.07993727f, -0.14434156f, 0.13688424f, 0.15507707f, 0.08007866f, 0.03749714f, 0.04784824f, 
    -0.06786277f, -0.10795126f, -0.27468935f, 0.07844931f, 0.06039468f, 0.18783239f, 0.09183161f, 0.18316801f, 
    0.05596655f, 0.00649506f, 0.08879086f, 0.18733773f, 0.06244984f, 0.03334675f, -0.19768412f, -0.11408788f, 
    0.04083867f, 0.11292575f, 0.10281725f, -0.03136577f, 0.01188042f, -0.18002138f, -0.23890030f, -0.39626843f, 
    0.10341597f, -0.09157067f, 0.20003462f, -0.27997401f, 0.02661010f, -0.03935494f, -0.00540666f, -0.08012179f, 
    -0.00594638f, -0.04075700f, -0.03653790f, 0.03005639f, 0.06697236f, -0.02813256f, 0.10911161f, -0.18477768f, 
    -0.23344254f, 0.20588827f, -0.10374695f, 0.14808303f, -0.10289016f, -0.03100261f, 0.08456333f, 0.10295831f, 
    -0.19693872f, 0.08115089f, -0.11110828f, -0.07400220f, 0.01414883f, -0.08198304f, 0.01257345f, -0.19651255f, 
    0.11385646f, -0.12124437f, -0.12151209f, 0.00554255f, 0.00866828f, 0.06897458f, 0.01606494f, 0.08551899f, 
    0.09646434f, -0.05462789f, -0.15429187f, 0.01762861f, 0.03986173f, 0.12438766f, 0.18775345f, -0.09767623f, 
    -0.17078757f, 0.09855532f, 0.03325561f, -0.02648070f, -0.10351580f, -0.16874129f, -0.25331405f, -0.03283906f, 
    -0.04073891f, 0.09935211f, 0.04726213f, 0.25673202f, 0.36912507f, 0.06866068f, 0.35810763f, 0.32416391f, 
    0.08591037f, 0.00466166f, 0.19785094f, 0.17790109f, -0.18973510f, -0.15785252f, 0.09537914f, -0.05447654f, 
    -0.05162147f, 0.01892147f, -0.07349126f, 0.13399284f, 0.13668673f, -0.04117525f, -0.13920632f, 0.18447915f, 
    0.03031603f, -0.01764777f, 0.02851312f, 0.06495634f, 0.03245628f, 0.06758022f, -0.08896912f, -0.03264173f, 
    -0.05637432f, 0.03164200f, 0.12373927f, 0.11600034f, 0.15304480f, -0.14790826f, -0.03439297f, -0.08203720f, 
    -0.08967359f, -0.32296959f, 0.35861593f, -0.14152329f, 0.02866499f, 0.14707947f, -0.01916554f, -0.16360469f, 
    -0.09364990f, 0.19479436f, 0.09202055f, 0.26646399f, -0.03077309f, -0.06947386f, -0.14508577f, 0.27405614f, 
    -0.04714210f, 0.04305661f, -0.07736747f, 0.14947717f, -0.08948662f, 0.13857092f, -0.13608748f, 0.06090262f, 
    0.15459855f, 0.17735046f, 0.03968416f, 0.07112998f, -0.01135762f, 0.09136913f, 0.00218934f, -0.12404066f, 
    0.09578172f, 0.22726162f, -0.14061715f, 0.33588052f, -0.24453874f, -0.07576116f, -0.01334653f, 0.03897826f, 
    0.07742477f, -0.02009997f, 0.16149464f, 0.03301793f, -0.15506513f, -0.14607561f, 0.12998186f, -0.08836754f, 
    0.02808775f, 0.04776213f, 0.05602992f, 0.24000554f, -0.00146221f, 0.21947816f, -0.38520089f, 0.14088628f, 
    -0.13238223f, 0.00777834f, -0.13186383f, 0.00587307f, -0.04574905f, -0.15662998f, -0.01452114f, 0.12734784f, 
    0.05624378f, -0.03272144f, -0.03332430f, 0.24990913f, -0.00598111f, 0.28315058f, 0.06038891f, 0.07797878f, 
    -0.32631141f, -0.07955068f, 0.28087389f, 0.07144453f, -0.06424974f, -0.11182156f, 0.14887719f, -0.03199127f, 
    0.08540978f, -0.14109220f, -0.19002765f, -0.13932721f, -0.05996088f, -0.00853533f, 0.05704452f, 0.15001819f, 
    0.14343777f, 0.06741086f, 0.24754095f, 0.03350349f, 0.36708879f, 0.02452493f, 0.09793026f, 0.19081688f, 
    0.02585121f, 0.01013639f, 0.05316233f, -0.20924877f, -0.12132253f, -0.17248406f, 0.05368104f, 0.10622512f, 
    0.11206519f, 0.21257162f, 0.10311281f, 0.09951120f, 0.14615184f, 0.18583187f, 0.32354170f, 0.00323817f, 
    -0.01592392f, 0.06859941f, 0.04979582f, 0.07054204f, -0.00213435f, 0.02260297f, 0.01862003f, 0.15302335f, 
    0.13734418f, 0.13392001f, 0.04163190f, -0.08482116f, 0.13023798f, -0.17188461f, -0.00493955f, 0.19228530f, 
    0.03810845f, -0.00127944f, -0.04387642f, -0.19226074f, 0.10227629f, 0.16339354f, -0.04396972f, -0.36747646f, 
    -0.29379660f, 0.18681802f, -0.01111882f, -0.10392419f, -0.22421333f, 0.16779932f, -0.08197612f, -0.00878777f, 
    -0.18611604f, -0.50823510f, -0.12202968f, 0.02535154f, -0.08890790f, 0.00323970f, -0.20119201f, 0.09258988f, 
    0.02398610f, -0.10735345f, 0.09137757f, 0.11000381f, -0.18699792f, -0.20980442f, -0.01465828f, -0.08513905f, 
    0.02998560f, -0.02961885f, 0.21113423f, 0.10910745f, 0.13540381f, 0.02669260f, 0.20481609f, 0.03477701f, 
    -0.02646026f, -0.08026077f, 0.37522137f, 0.09629630f, 0.20794573f, 0.35624650f, 0.05411315f, -0.00347944f, 
    0.04437833f, 0.03449203f, -0.05063314f, 0.13725486f, 0.20089681f, 0.22122289f, 0.11918458f, -0.01822938f, 
    0.07098332f, 0.06068855f, -0.10555992f, 0.16308588f, -0.19033830f, -0.10663208f, -0.32716590f, -0.24378262f, 
    -0.07588961f, -0.01541238f, 0.18080524f, -0.00321617f, -0.02952791f, 0.10749665f, 0.08900113f, 0.17015123f, 
    0.05905596f, -0.05428034f, -0.09516006f, -0.01745879f, -0.04217836f, -0.19134668f, -0.07784284f, 0.58617109f, 
    0.17963056f, 0.45248803f, -0.16267721f, -0.10691603f, 0.09667257f, -0.14075479f, -0.10783111f, -0.10484116f, 
    0.07812864f, -0.32847247f, 0.02302963f, -0.13944724f, 0.21662578f, 0.18216078f, -0.05744681f, -0.09827109f, 
    0.24048929f, -0.26580924f, -0.10078157f, -0.16288933f, 0.09174046f, -0.05286705f, 0.04638295f, 0.11496623f, 
    -0.06721856f, 0.28150269f, 0.40850526f, 0.02340557f, 0.17520283f, 0.03944440f, 0.25450125f, -0.15869176f, 
    0.05590301f, 0.02638961f, 0.02696978f, 0.00380043f, -0.15189126f, 0.00524109f, -0.10028861f, -0.16705036f, 
    -0.08661278f, -0.05672879f, -0.27329856f, 0.17181796f, -0.18598016f, 0.14497003f, -0.20599757f, 0.24067473f, 
    0.19516166f, -0.09797527f, -0.08401142f, -0.14528225f, -0.16533440f, 0.08294347f, -0.60117501f, -0.10972290f, 
    -0.06119321f, -0.10065273f, 0.11949611f, -0.07806364f, 0.01573344f, 0.16054590f, 0.01244435f, -0.29111797f, 
    -0.08474290f, -0.12460275f, -0.06778388f, -0.04908376f, -0.04136721f, -0.06530799f, 0.10684761f, -0.21812472f, 
    -0.13827041f, -0.08317082f, -0.01247364f, 0.10564303f, -0.04347278f, 0.26098385f, 0.09233756f, 0.22774015f, 
    -0.07469794f, 0.22348119f, 0.02045097f, -0.18281892f, -0.14764558f, -0.07368152f, -0.15388483f, 0.07688460f, 
    -0.06998862f, 0.03006345f, 0.16278498f, 0.07575587f, -0.20501085f, 0.13646349f, -0.17585929f, -0.12870388f, 
    -0.01524825f, 0.01830769f, 0.01261541f, 0.05198511f, -0.45514175f, 0.14425503f, 0.07657932f, -0.20027469f, 
    0.17106839f, -0.07530709f, -0.31188518f, 0.21061955f, 0.30413523f, 0.01066940f, -0.03590271f, 0.08895283f, 
    0.07437707f, 0.11795838f, 0.08002524f, 0.18003421f, 0.01916826f, 0.04648419f, -0.08439382f, 0.16051152f, 
    -0.16647120f, -0.14016543f, -0.07446770f, -0.05229803f, -0.38209090f, 0.34497410f, 0.42707655f, 0.19792227f, 
    0.11438396f, 0.26352942f, 0.21452619f, -0.23154072f, -0.15477902f, -0.05527467f, 0.02755711f, 0.58312041f, 
    -0.11300535f, -0.31872743f, 0.04998438f, 0.00045061f, 0.10119487f, 0.06130790f, 0.04830557f, -0.12958458f, 
    0.16215332f, -0.09828421f, -0.13692935f, -0.06501535f, 0.06616573f, 0.04725325f, -0.09966563f, -0.21806949f, 
    -0.01387379f, 0.20808136f, 0.10526653f, -0.04210070f, -0.14740416f, -0.15559147f, -0.27830449f, -0.09984837f, 
    -0.09654531f, 0.02199099f, 0.14998159f, 0.02281848f, 0.11689973f, -0.02850469f, 0.06235768f, -0.21986952f, 
    -0.03692791f, -0.00062877f, -0.08128988f, -0.17078622f, 0.19963422f, -0.33595294f, -0.01285173f, 0.05083444f, 
    -0.10284445f, -0.09075432f, -0.08920293f, 0.30685803f, -0.26932520f, -0.06151478f, -0.11731666f, 0.08624777f, 
    -0.01158532f, -0.03431356f, -0.33351347f, -0.45296362f, -0.10059758f, 0.21376167f, 0.09994134f, 0.06459233f, 
    0.05400220f, -0.09292120f, -0.10061882f, -0.17460723f, -0.13102297f, 0.18303581f, 0.07075505f, 0.08410275f, 
    0.06343510f, -0.27150473f, 0.13006306f, 0.12430332f, 0.07201005f, 0.27013180f, -0.16077331f, 0.21247996f, 
    0.09283059f, 0.08101266f, -0.19805941f, -0.37010902f, -0.17810032f, -0.15749930f, -0.40654019f, -0.00013652f, 
    0.22595374f, 0.03979332f, -0.03059367f, -0.07975892f, -0.29778287f, -0.09089458f, -0.05487619f, -0.35545623f, 
    0.17389010f, -0.05492179f, 0.23294482f, -0.02362265f, 0.01903946f, -0.04145347f, 0.00903703f, -0.07406042f, 
    -0.05385267f, 0.01084207f, 0.40807465f, 0.37279019f, 0.11461058f, -0.04875482f, 0.06727042f, -0.01598731f, 
    -0.12996478f, -0.08046208f, 0.27851242f, -0.01336800f, -0.07616185f, -0.21505949f, -0.12172100f, 0.16068007f, 
    -0.02811019f, 0.03147484f, 0.21942110f, -0.27426299f, 0.02254074f, 0.06006745f, -0.19538099f, -0.20060597f, 
    -0.05019309f, -0.06191486f, 0.07184953f, 0.04202330f, -0.12804335f, 0.11608422f, 0.28119829f, -0.04544555f, 
    -0.11347988f, -0.02707865f, 0.01232304f, 0.03132130f, 0.05756807f, 0.36572507f, -0.58812487f, -0.55585784f, 
    -0.19442180f, -0.01315252f, 0.34797364f, 0.16247793f, 0.14117679f, 0.26084751f, -0.05254069f, 0.17664041f, 
    -0.05651516f, -0.06546884f, 0.08262201f, 0.04043850f, 0.13887820f, -0.05797185f, -0.19842352f, 0.06264309f, 
    0.66145229f, 0.32729039f, -0.10614182f, -0.18159471f, -0.23687728f, 0.08053755f, 0.04954845f, -0.17862442f, 
    0.11779564f, -0.08299135f, 0.11094513f, -0.12232720f, 0.06137903f, 0.29503384f, 0.00733072f, 0.32967135f, 
    0.08075014f, 0.35261369f, 0.11384065f, -0.07371275f, -0.06353177f, 0.15097995f, -0.07670017f, 0.01512844f, 
    0.05593891f, 0.02129708f, -0.08878132f, 0.39291033f, 0.19746476f, -0.12307081f, -0.09790936f, -0.07099714f, 
    -0.07220986f, -0.14615123f, -0.19540466f, -0.24034069f, -0.15850627f, 0.22802062f, -0.14653958f, 0.06893360f, 
    0.21392387f, 0.04499323f, 0.27465245f, -0.26463524f, 0.23208399f, 0.22360042f, 0.27422020f, -0.10040069f, 
    -0.00562656f, 0.00242140f, 0.08339994f, -0.16307941f, -0.31904197f, 0.28029981f, -0.11790044f, 0.26990268f, 
    0.01941797f, 0.25090352f, -0.01042181f, -0.05355210f, 0.19656670f, 0.33102822f, 0.28360507f, 0.11705507f, 
    -0.00352224f, 0.32548058f, 0.18425061f, -0.16471785f, 0.13818625f, -0.11923920f, 0.06761422f, 0.22521587f, 
    -0.05518916f, 0.05901985f, 0.04301210f, 0.16441557f, 0.06257875f, 0.09738062f, -0.12721866f, -0.33068883f, 
    -0.12550485f, 0.26915497f, 0.08780429f, 0.05314982f, -0.13305102f, -0.04739724f, 0.04315412f, 0.03481832f, 
    0.16297518f, 0.32356113f, 0.08724809f, 0.74078614f, -0.00094306f, 0.06938249f, 0.08517803f, 0.01291996f, 
    -0.07469354f, -0.27031860f, 0.02547811f, -0.08773968f, -0.12672822f, -0.09776107f, -0.02600561f, -0.23911777f, 
    -0.00805026f, -0.36244473f, -0.03527839f, -0.03845419f, 0.49263945f, -0.04659711f, -0.08045520f, 0.03091632f, 
    0.07844713f, 0.23720776f, 0.08001609f, 0.04258002f, 0.20556511f, 0.08385632f, 0.05909229f, -0.05903762f, 
    -0.13150153f, -0.37103105f, 0.21592496f, 0.15413727f, 0.05039990f, 0.17402662f, 0.34839210f, 0.39766636f, 
    0.01718755f, -0.02823277f, 0.04979269f, 0.17617662f, 0.05476547f, -0.14596167f, -0.25066137f, -0.50238681f, 
    0.23364539f, 0.12676120f, -0.12613523f, -0.21857369f, 0.12769504f, -0.05878652f, -0.39522952f, 0.05182840f, 
    -0.05738531f, -0.12860712f, 0.14601739f, 0.08388169f, 0.00531944f, 0.07247301f, 0.16698456f, -0.10241906f, 
    0.22850192f, 0.20075653f, 0.34817198f, 0.15863609f, -0.09043217f, -0.00844769f, -0.03597941f, -0.04196161f, 
    -0.07229475f, 0.27379566f, 0.61675972f, 0.19077055f, 0.05685351f, -0.06869730f, 0.16362171f, 0.00169147f, 
    -0.09163132f, 0.26150709f, -0.01547137f, -0.12599444f, -0.11530492f, -0.08526235f, 0.01819060f, -0.01463368f, 
    0.06827342f, -0.10563161f, -0.14009817f, 0.10418936f, 0.15251644f, -0.04455210f, -0.07103372f, -0.08876437f, 
    -0.01475979f, 0.09522477f, -0.00576488f, 0.07695679f, 0.10756692f, -0.12255867f, -0.07579759f, 0.11437106f, 
    0.06335728f, 0.10695376f, -0.26454225f, -0.05708455f, -0.22934513f, 0.14319517f, -0.19928418f, -0.16470192f, 
    0.10197473f, 0.03903969f, -0.02933969f, 0.06682257f, -0.11410758f, 0.12801801f, 0.06233451f, 0.00055841f, 
    -0.22605594f, -0.08604269f, 0.00513952f, -0.30849123f, 0.19994178f, -0.12714331f, 0.07858548f, 0.06021303f, 
    0.20007241f, 0.07525730f, 0.05195407f, -0.12711294f, -0.07040615f, 0.14801693f, 0.09390624f, 0.01658293f, 
    0.28471002f, 0.25258368f, 0.18889584f, -0.14138283f, -0.13297194f, -0.20137993f, 0.08870570f, 0.01716117f, 
    0.12478794f, 0.33521929f, -0.17006870f, 0.00233646f, 0.18496944f, 0.04808334f, 0.15871076f, -0.18131207f, 
    -0.05675356f, -0.00034192f, -0.54410762f, -0.15502441f, -0.13667376f, -0.01486594f, 0.10124549f, -0.18807042f, 
    -0.23244393f, -0.12584975f, -0.22440484f, -0.03574174f, -0.10994392f, -0.01318560f, 0.02613092f, 0.02056190f, 
    0.11892384f, -0.21004759f, 0.16765827f, -0.05872587f, -0.10865118f, -0.24557571f, -0.08708637f, 0.06470802f, 
    -0.01137466f, -0.01116279f, -0.10487246f, 0.08621874f, 0.13209935f, -0.00741234f, 0.21169509f, 0.22414629f, 
    0.05031395f, 0.10631290f, -0.16454349f, 0.05330012f, -0.12676935f, 0.05020579f, 0.07135025f, -0.11111052f, 
    -0.21697326f, 0.01346554f, -0.03898433f, 0.12291171f, -0.26886240f, -0.16970575f, -0.15927105f, -0.10540818f, 
    -0.20731939f, 0.00681634f, 0.07097428f, 0.10668196f, 0.06397665f, -0.03518268f, -0.01585858f, -0.20225319f, 
    -0.21556835f, 0.14511369f, -0.00262200f, -0.01622625f, -0.09779725f, -0.27107927f, -0.24584797f, -0.32662001f, 
    -0.00233903f, 0.55809391f, 0.32041618f, 0.26882967f, 0.12929951f, -0.07058646f, 0.17944174f, 0.04432887f, 
    0.02618854f, -0.11840367f, -0.00773563f, -0.06860594f, 0.09351717f, 0.07543162f, 0.04684991f, -0.01846968f, 
    -0.12948018f, 0.32447201f, -0.09786350f, -0.01346346f, 0.08702748f, -0.07911362f, 0.27443561f, -0.16194554f, 
    0.13315804f, -0.10565508f, -0.13982628f, 0.19722298f, 0.05337524f, -0.37807035f, -0.37711346f, -0.12626460f, 
    -0.01390479f, -0.35682496f, 0.14232028f, -0.26144958f, -0.01272096f, -0.09998845f, 0.16133086f, -0.24216545f, 
    0.10225811f, -0.18667544f, -0.11389192f, 0.07487331f, -0.07419945f, 0.02888960f, 0.27741855f, 0.19502059f, 
    0.02061528f, -0.07864507f, 0.02453577f, 0.07038563f, 0.14980836f, -0.00904564f, 0.13149671f, 0.22634673f, 
    0.06637845f, -0.00511068f, -0.12754233f, -0.18765037f, 0.36974776f, -0.07424282f, 0.02892707f, -0.03578131f, 
    0.17842592f, 0.12708950f, 0.16408527f, 0.17277846f, -0.16632175f, -0.06376253f, 0.12932782f, 0.10794114f, 
    -0.12842707f, 0.15623386f, -0.11435256f, -0.68784976f, 0.23572047f, -0.08623374f, 0.01958143f, 0.22779813f, 
    0.05784950f, -0.00670046f, -0.08913510f, 0.00016646f, 0.12782769f, 0.04558958f, 0.01279268f, 0.11635589f, 
    0.02283823f, -0.04886903f, 0.23845512f, -0.27339402f, -0.19279097f, -0.47256446f, -0.36065662f, 0.03116355f, 
    -0.12672082f, -0.01455718f, 0.03007854f, 0.04923184f, 0.00078546f, 0.25298807f, 0.34398213f, 0.09763501f, 
    -0.00600184f, -0.03685308f, 0.13180196f, -0.15821280f, 0.01498830f, -1.08532596f, -0.16349421f, -0.52395689f, 
    -0.09903996f, -0.28257063f, -0.37208933f, -0.06495847f, -0.04076424f, 0.07218051f, -0.30982241f, -0.42651805f, 
    -0.18155806f, -0.12504619f, 0.24670571f, -0.13165492f, 0.37162235f, -0.13088234f, 0.02725372f, -0.01174541f, 
    -0.09621368f, -0.10364362f, 0.05983640f, 0.12111395f, -0.05728966f, 0.29929411f, 0.10118955f, 0.05953319f, 
    -0.17061630f, -0.22541288f, -0.78682929f, 0.04933728f, 0.05485118f, -0.08198162f, 0.07354402f, -0.03849815f, 
    -0.05840834f, -0.24019028f, -0.30331162f, -0.38384494f, -0.02806480f, -0.21134423f, -0.07538910f, 0.10307031f, 
    -0.01800505f, 0.00648881f, 0.09509790f, -0.08647376f, 0.16817404f, 0.11194129f, 0.19352402f, -0.10880025f, 
    0.07946330f, -0.02312163f, 0.00956529f, -0.12749246f, 0.25502282f, 0.31327853f, -0.01543653f, 0.03126248f, 
    -0.01925306f, -0.01989131f, -0.06582703f, 0.24007697f, -0.15948720f, 0.15437111f, 0.11694679f, 0.14147727f, 
    0.03463064f, 0.16795787f, 0.07394975f, 0.12713321f, 0.03514782f, -0.05658261f, -0.72616023f, 0.22186080f, 
    0.33379728f, -0.02696856f, 0.14896816f, 0.00717761f, 0.09775890f, -0.02552062f, -0.06811726f, -0.05203326f, 
    -0.06575648f, 0.22709918f, -0.06041439f, 0.07323823f, 0.24167332f, -0.12756258f, -0.08070527f, 0.27352741f, 
    0.02107182f, -0.20040353f, -0.03442068f, -0.08689587f, -0.11555999f, -0.03367303f, -0.05678456f, -0.28041649f, 
    -0.33839223f, 0.04991405f, 0.74390936f, 0.07813188f, -0.03124752f, -0.28308582f, 0.05672612f, 0.07764992f, 
    0.01794642f, -0.48065901f, -0.47087485f, -0.15804066f, 0.05531220f, 0.03524093f, 0.01559555f, 0.09704158f, 
    0.04424866f, 0.03299563f, 0.10137904f, 0.49024117f, 0.38053879f, -0.13193442f, 0.18320684f, -0.19675545f, 
    0.14809653f, 0.10705864f, 0.44097781f, 0.02545798f, -0.06149759f, -0.05805581f, 0.13161550f, 0.28290650f, 
    0.01490179f, 0.21834190f, 0.03809746f, 0.02011736f, 0.15307742f, 0.28606537f, -0.41360846f, -0.00741940f, 
    -0.08086649f, 0.15890619f, 0.18315622f, 0.08436120f, -0.14735444f, -0.50654429f, 0.12338762f, 0.64733124f, 
    -0.04720205f, -0.13344128f, -0.26401865f, 0.10036932f, 0.16215914f, 0.30094972f, -0.11906394f, -0.22477122f, 
    -0.53096378f, 0.10431896f, 0.05905169f, 0.09448583f, 0.19412807f, 0.04326585f, 0.16499835f, -0.02782897f, 
    -0.44223204f, -0.36511683f, 0.29189694f, 0.01424993f, 0.14622965f, -0.00005543f, -0.14271204f, -0.10336340f, 
    0.14216638f, -0.06615640f, 0.31906462f, -0.08342694f, -0.03678473f, -0.13203514f, 0.17604791f, 0.16005783f, 
    0.37611985f, -0.87178475f, -0.51091349f, -0.41699240f, -0.23574427f, -0.29472271f, -0.35608310f, -0.05207828f, 
    -0.04510516f, -0.06612086f, 0.11560984f, 0.03316166f, -0.28441593f, -0.08512519f, 0.00165438f, -0.06091834f, 
    0.17699976f, -0.04622764f, -0.17978646f, -0.30216405f, -0.51927233f, -0.73506898f, -0.01513700f, -0.13190351f, 
    -0.09323357f, 0.20272720f, -0.08373610f, 0.28192544f, 0.04559693f, -0.09872475f, -0.54250419f, -0.34743005f, 
    -0.27193475f, 0.14000657f, -0.16677143f, 0.03577845f, 0.07025343f, -0.07487833f, -0.21041493f, 0.44536781f, 
    0.23283908f, 0.10675738f, 0.13137041f, 0.01130604f, 0.12729698f, 0.11218631f, -0.58409536f, -0.41051990f, 
    0.43508738f, 0.45510125f, 0.23441905f, -0.19984919f, -0.01277017f, -0.05350783f, -0.00444173f, -0.06775253f, 
    -0.00215518f, 0.05439177f, -0.03460218f, -0.02790188f, 0.04131474f, -0.00051774f, -0.18587661f, 0.22960690f, 
    -0.08079831f, 0.01587109f, 0.02921356f, -0.01983646f, -0.04602920f, -0.05467064f, -0.07143189f, -0.01546488f, 
    -0.04246227f, 0.01455454f, 0.01161073f, -0.01380842f, -0.04556312f, -0.02848306f, 0.01221926f, -0.08167493f, 
    -0.00256455f, -0.03591834f, -0.06945767f, -0.06563862f, -0.07469708f, -0.09084242f, -0.08387190f, -0.08817214f, 
    0.00253036f, -0.02958853f, -0.03916603f, -0.05283332f, 0.02589575f, -0.01353044f, -0.05528687f, 0.00679281f, 
    -0.02252808f, -0.06172204f, -0.04001765f, -0.08249621f, -0.00471646f, -0.04140101f, 0.00523240f, -0.01321682f, 
    -0.07653610f, 0.01087935f, -0.05877854f, 0.04153302f, -0.01565914f, -0.02972102f, 0.00788807f, 0.04360728f, 
    -0.02245031f, -0.03443048f, 0.02364820f, -0.00522745f, 0.00882236f, -0.02048677f, -0.00199175f, -0.04860231f, 
    -0.02337277f, -0.04488140f, 0.02299229f, 0.01272950f, 0.00517259f, -0.05836191f, -0.06929779f, 0.02122022f, 
    -0.03197520f, -0.01742176f, -0.06955111f, -0.08257487f, 0.01613640f, 0.00482499f, -0.05273782f, 0.02111278f, 
    -0.03291149f, -0.08290253f, -0.00249233f, 0.04533618f, 0.03995347f, -0.06283996f, -0.02154757f, 0.03476156f, 
    -0.07167995f, 0.02696423f, -0.01359399f, -0.03757752f, 0.00823016f, -0.01925398f, 0.00940768f, -0.08076568f, 
    -0.08774672f, -0.04953433f, -0.06766444f, 0.02941310f, -0.02711887f, -0.00264925f, 0.01619096f, -0.06232789f, 
    -0.03969459f, -0.06346479f, -0.03726078f, -0.01524778f, -0.07298527f, -0.06753840f, -0.04792479f, -0.03515309f, 
    -0.00868694f, -0.04051239f, -0.03856825f, -0.05812727f, -0.04696472f, -0.06117393f, -0.06089976f, -0.01135604f, 
    -0.06628620f, -0.04176810f, 0.01597283f, 0.01066863f, -0.07052257f, -0.04434222f, 0.03807409f, -0.00423502f, 
    -0.07488464f, -0.05361235f, 0.00884496f, -0.06171255f, -0.04223973f, -0.06898946f, 0.00684928f, -0.06909241f, 
    -0.01688169f, -0.08201962f, -0.06293191f, -0.06060196f, 0.02816985f, -0.02109071f, -0.04144111f, 0.00945847f, 
    -0.04921940f, -0.03624199f, 0.04227404f, -0.00720823f, -0.06581143f, -0.08497847f, -0.06976680f, -0.00183180f, 
    -0.00822786f, 0.01387945f, -0.03884672f, -0.07036191f, -0.00531324f, 0.00401768f, 0.00198147f, -0.02941385f, 
    0.01841004f, 0.02558359f, -0.04448380f, -0.01865589f, -0.08478514f, -0.04832460f, 0.01153714f, -0.01020258f, 
    0.01099865f, -0.04041854f, -0.04957583f, 0.04282282f, -0.02888778f, -0.05162840f, -0.03004333f, -0.03966317f, 
    -0.03326206f, 0.02278611f, -0.04706098f, -0.01852212f, -0.00046003f, 0.00118683f, 0.00399921f, -0.02839062f, 
    -0.01218555f, -0.08679065f, -0.06684809f, -0.06251065f, -0.03901815f, -0.04668846f, -0.06213421f, -0.07233711f, 
    -0.00458461f, 0.01913635f, -0.07550254f, -0.04770536f, 0.02484998f, 0.03125512f, -0.00676776f, -0.03736925f, 
    -0.02144719f, 0.01423086f, 0.01386154f, 0.02381797f, -0.05484815f, -0.03823113f, -0.07183703f, -0.04394844f, 
    -0.03649519f, 0.01848815f, -0.07687326f, -0.06966775f, -0.08788732f, 0.01217753f, 0.02226305f, 0.03208400f, 
    0.01854520f, 0.01551098f, 0.01422937f, -0.01548271f, -0.09032037f, -0.06002887f, -0.03405985f, -0.07700001f, 
    0.01993733f, -0.04931300f, -0.03531043f, -0.04448300f, -0.00245571f, 0.01976511f, -0.03596757f, 0.01305744f, 
    -0.03555238f, 0.02625406f, -0.04977606f, 0.04771723f, 0.02738746f, -0.03241919f, 0.03351150f, -0.02140532f, 
    -0.00971247f, -0.07667143f, -0.09280567f, 0.01356145f, 0.00150285f, -0.02675842f, -0.00490474f, -0.01234296f, 
    -0.00360452f, -0.08497812f, -0.05410144f, 0.01068671f, -0.05098366f, -0.04510658f, -0.05766152f, 0.03057128f, 
    -0.07006686f, -0.00678363f, -0.00423029f, 0.02141429f, 0.00316095f, 0.00883514f, -0.04717129f, 0.02187738f, 
    -0.01307759f, 0.00364708f, 0.03129147f, 0.03104967f, -0.07471780f, -0.01894218f, -0.00898555f, -0.01930461f, 
    -0.02433179f, -0.05183509f, -0.00020178f, -0.07520110f, 0.01164671f, -0.02359795f, 0.01201553f, 0.02372053f, 
    0.04982350f, 0.05120574f, 0.04836208f, 0.05260418f, -0.00341178f, 0.03219499f, 0.01123054f, -0.03827838f, 
    -0.05270220f, -0.06420117f, 0.01587979f, -0.00306347f, 0.02567936f, -0.05995672f, 0.03047602f, 0.01531946f, 
    -0.04548232f, 0.00556904f, -0.05456953f, 0.01015096f, 0.02098941f, 0.05263079f, 0.00216368f, -0.00904183f, 
    -0.02262531f, 0.04936099f, 0.03771134f, -0.05802298f, -0.00583144f, 0.02613418f, 0.02889345f, -0.04506601f, 
    0.02196985f, 0.03362387f, -0.05436686f, 0.01776321f, 0.01181231f, -0.02805982f, -0.06049367f, -0.02926808f, 
    -0.04186409f, -0.01592628f, -0.00649336f, 0.02997549f, 0.00378274f, -0.00273985f, 0.00012805f, -0.03099971f, 
    -0.05551390f, 0.05858988f, -0.01436367f, -0.03511684f, 0.00533837f, 0.02667432f, -0.06228240f, -0.01776538f, 
    0.04191487f, -0.01286376f, 0.03078070f, -0.00906891f, 0.01179245f, 0.05217206f, -0.03003492f, 0.02487970f, 
    0.01647601f, -0.03882356f, -0.01872700f, -0.00687933f, -0.00211083f, -0.05669528f, -0.03284999f, -0.03944156f, 
    0.02649141f, 0.01908459f, -0.03138316f, -0.02181626f, -0.04549751f, -0.04873767f, -0.00836487f, 0.00824791f, 
    0.01415522f, 0.03066565f, -0.01526199f, 0.01942150f, 0.03851920f, -0.02657551f, 0.05263798f, 0.03967499f, 
    0.01416557f, 0.02010273f, 0.03135397f, -0.02775495f, -0.01896596f, 0.05074046f, -0.00829025f, -0.04643085f, 
    0.00384707f, 0.00808116f, -0.02473644f, -0.04020058f, 0.01046272f, 0.04810306f, 0.03211245f, 0.03121682f, 
    -0.02229811f, -0.02877523f, -0.00217882f, -0.00854861f, -0.02097126f, -0.00942306f, -0.02369179f, 0.00383859f, 
    -0.01190732f, 0.04878234f, -0.06248607f, 0.00114692f, -0.01808084f, 0.00413242f, -0.06371416f, 0.05141696f, 
    -0.00117400f, -0.05254992f, 0.05053625f, -0.00665305f, 0.03623008f, -0.04808204f, -0.02331587f, -0.05458056f, 
    -0.01453490f, -0.03146358f, 0.03826899f, -0.06288608f, -0.06405466f, -0.00129695f, -0.00232255f, -0.06440040f, 
    -0.04284988f, 0.04329615f, -0.03109571f, 0.02330192f, -0.04171492f, -0.01857659f, -0.02611306f, -0.01315816f, 
    -0.05303168f, 0.02245619f, 0.01020745f, -0.02289701f, 0.04407935f, -0.03406929f, 0.01503205f, 0.00598686f, 
    -0.00366599f, -0.01284130f, -0.04193720f, -0.05025491f, 0.04137425f, 0.02921089f, -0.06179674f, -0.02017467f, 
    -0.03076557f, 0.03252539f, -0.02775896f, -0.03649819f, 0.00185423f, -0.00916035f, -0.00054394f, -0.01788942f, 
    -0.02224062f, 0.04808358f, -0.04480783f, 0.04063257f, -0.05984816f, -0.05455204f, -0.04208761f, -0.03481644f, 
    -0.04050423f, 0.04885530f, 0.03521318f, -0.06373128f, -0.03440085f, 0.02936738f, 0.00841997f, -0.02612128f, 
    -0.02176534f, -0.06409360f, -0.02811157f, -0.03527713f, 0.02329969f, -0.05262639f, -0.04076357f, -0.05124615f, 
    0.03310762f, -0.02499013f, -0.00918355f, 0.00920725f, 0.01616612f, -0.01714558f, 0.02652106f, -0.03168989f, 
    -0.04399226f, -0.02654414f, -0.04621620f, -0.04520049f, -0.05749166f, 0.01636113f, 0.02093589f, -0.00059669f, 
    -0.02292101f, 0.01237523f, 0.01668216f, -0.04279774f, -0.05907347f, -0.02131915f, -0.03147482f, 0.02722952f, 
    0.04720449f, -0.00618921f, -0.04923103f, -0.01188968f, -0.03377184f, -0.03177655f, -0.00635670f, 0.04592194f, 
    -0.05343059f, -0.03855526f, 0.02865225f, -0.02821235f, 0.00327732f, 0.00369104f, 0.04018708f, -0.02392179f, 
    0.01940188f, -0.00516408f, 0.03628442f, -0.02909348f, -0.03262886f, -0.05699251f, -0.03628131f, -0.00367377f, 
    0.01300574f, -0.05604658f, 0.02520361f, 0.05159174f, -0.03305651f, -0.02129278f, -0.04526325f, 0.05557007f, 
    -0.03470884f, 0.03371932f, 0.04382604f, -0.01190099f, -0.01321512f, -0.04195888f, -0.02819837f, -0.01597964f, 
    0.00801697f, 0.02395005f, 0.04211249f, -0.00903761f, -0.03777124f, -0.05766612f, -0.04815789f, 0.00195764f, 
    0.05863984f, -0.01018139f, -0.01433991f, -0.00628078f, -0.04687928f, -0.03230681f, -0.05121247f, -0.05742764f, 
    -0.04019935f, 0.03551147f, -0.03163031f, -0.02381911f, -0.03766799f, -0.01867605f, 0.01761520f, 0.03766906f, 
    0.03051398f, -0.03517784f, -0.00512696f, 0.04725662f, 0.02841062f, -0.02625349f, -0.05198160f, 0.03754837f, 
    -0.02978400f, -0.01170961f, 0.01586947f, -0.00736206f, 0.01539174f, -0.04932639f, 0.03907144f, 0.00710794f, 
    -0.02765957f, -0.00590236f, 0.03059196f, 0.00243069f, 0.02120394f, 0.04741768f, 0.01646684f, -0.00028569f, 
    -0.30574036f, -0.08247061f, -0.51092809f, 0.21328481f, -0.07928398f, 0.08684916f, 0.07458242f, 0.16961172f, 
    -0.02286452f, 0.05376736f, 0.08987748f, 0.25151214f, -0.00110896f, 0.22184230f, -0.00246766f, -0.10233343f, 
    0.13439037f, -0.06276252f, -0.01118004f, -0.06026944f, -0.09434456f, -0.04882661f, -0.02040694f, -0.09288291f, 
    0.22979312f, -0.15789963f, -0.03298973f, 0.11370075f, 0.20580450f, -0.36822960f, -0.05262287f, -0.18279634f, 
    -0.00886574f, -0.03448402f, 0.04833972f, -0.06185145f, 0.17960958f, -0.44716039f, -0.54108256f, 0.09639630f, 
    -0.05144832f, -0.06199975f, 0.10144178f, -0.19191706f, 0.01288424f, 0.30006185f, -0.11178903f, -0.15862186f, 
    -0.02681874f, -0.06058092f, 0.01133470f, 0.00484818f, 0.16315319f, 0.04127727f, 0.41363576f, 0.22042626f, 
    -0.40037620f, 0.17236240f, 0.10085865f, -0.01091116f, 0.21139947f, -0.03075841f, 0.02786339f, -0.16963783f, 
    0.26839149f, -0.16900159f, 0.06079860f, 0.07335722f, 0.04197074f, -0.02959754f, -0.09554175f, 0.01174390f, 
    0.13730343f, 0.07561827f, 0.07364858f, 0.03633128f, -0.10169853f, 0.17196970f, -0.05421228f, 0.16802455f, 
    0.13985606f, -0.12380731f, -0.24101706f, -0.45844302f, 0.01640137f, -0.13155946f, 0.08691600f, -0.01593803f, 
    0.18472148f, 0.07141571f, -0.03659289f, 0.02104467f, -0.04457624f, 0.08152120f, 0.06361967f, 0.16107497f, 
    -0.02268879f, 0.21542519f, 0.36173326f, 0.17244431f, -0.03866884f, -0.29888511f, -0.09417893f, 0.03090204f, 
    0.06024590f, 0.25700256f, -0.00909931f, -0.07705739f, 0.06412231f, 0.08986802f, 0.14943470f, -0.12331748f, 
    -0.19719708f, -0.06094742f, 0.03881340f, 0.13533223f, 0.11615576f, -0.52492285f, 0.19466844f, 0.03587566f, 
    0.16673020f, 0.03099050f, 0.08946183f, 0.09340599f, 0.15193971f, 0.01820651f, -0.18713444f, -0.27174070f, 
    0.00632615f, -0.07713842f, 0.09559768f, -0.03783024f, 0.04712294f, 0.13637190f, 0.05303199f, 0.02482037f, 
    0.07651452f, 0.03912022f, 0.09355448f, -0.16315891f, 0.06667187f, 0.09783316f, -0.00068747f, 0.01007350f, 
    0.21654379f, -0.93387496f, -0.45180732f, 0.02517475f, 0.05205363f, 0.07702147f, -0.01193847f, -0.15717441f, 
    0.06832758f, -0.20216726f, -0.04322803f, 0.11292390f, -0.25660872f, -0.08013967f, 0.01294459f, 0.04844767f, 
    -0.06046999f, 0.06985936f, 0.32037812f, -0.30269361f, -0.28620368f, 0.15391402f, 0.00802794f, 0.14515822f, 
    0.02502416f, 0.09348745f, -0.05021193f, -0.04644287f, 0.06099555f, 0.09159446f, -0.07638798f, 0.01662361f, 
    0.10715219f, 0.05265009f, 0.15926607f, 0.04150053f, -0.50051075f, 0.01481211f, 0.13714252f, -0.07101373f, 
    0.20791577f, 0.08473166f, -0.00700463f, 0.18790363f, 0.01272053f, 0.38390341f, -0.51252490f, -0.26863176f, 
    0.07222737f, 0.17465509f, 0.31262743f, -0.01815740f, -0.07409886f, -0.01050949f, -0.05205452f, 0.28658056f, 
    0.19927074f, -0.14394093f, 0.06138014f, -0.04641973f, 0.00229165f, -0.12522539f, -0.05535475f, 0.04648212f, 
    -0.06262882f, -0.03052825f, 0.09714188f, -0.25189897f, -0.27308023f, 0.10285182f, 0.04757006f, -0.29274648f, 
    -0.10937510f, -0.25276029f, 0.09132356f, 0.05144209f, 0.12886955f, 0.09971273f, 0.08333074f, 0.11000957f, 
    0.02686825f, 0.45991588f, -0.48728836f, -0.01840414f, -0.03384762f, -0.07692458f, -0.12667462f, 0.05988405f, 
    0.04440148f, 0.01726639f, -0.00578060f, 0.12937509f, -0.14484437f, 0.08125108f, 0.05308694f, -0.07789000f, 
    -0.05358731f, 0.01258890f, -0.19976933f, -0.47741574f, -0.16723348f, 0.04790618f, -0.02680846f, 0.20341462f, 
    -0.26497811f, -0.04271669f, 0.09766669f, 0.12555262f, 0.90219182f, -0.33080626f, -0.39574948f, 0.04042965f, 
    0.19918989f, 0.00216032f, 0.17836769f, 0.08560318f, 0.02679591f, 0.19031565f, -0.62201238f, -0.58815265f, 
    0.09111667f, 0.14553744f, 0.28041965f, -0.11449794f, -0.18523289f, 0.09080207f, 0.28626940f, -0.42089400f, 
    -0.36417231f, -0.06792717f, 0.11934892f, 0.21872018f, -0.10670871f, -0.00335816f, -0.10528347f, -0.02305594f, 
    -0.02694742f, -0.41207227f, -0.14650576f, -0.05473143f, -0.22933401f, 0.09448849f, -0.04068679f, -0.12421379f, 
    0.31600615f, 0.14486337f, -0.31576833f, -0.13884476f, -0.02026061f, -0.03458329f, 0.08741251f, -0.11484249f, 
    0.10009232f, -0.19279699f, 0.30245310f, -0.00563254f, -0.06048192f, -0.01935341f, -0.12610330f, -0.24432179f, 
    -0.08613891f, 0.10018165f, 0.02847071f, -0.17597154f, -0.24438363f, -0.13632418f, -0.24606493f, 0.03845825f, 
    0.03917932f, 0.21636291f, -0.00705345f, 0.42048427f, 0.24472971f, -0.02761767f, 0.03429764f, 0.14464422f, 
    -0.05163592f, -0.01438052f, -0.19693217f, 0.02207764f, 0.00474256f, -0.10673574f, -0.20437193f, -0.15730870f, 
    0.04909098f, 0.22602403f, -0.01909047f, -0.12438363f, -0.06070439f, 0.24203008f, 0.38079858f, 0.04300591f, 
    -0.05645019f, 0.06625823f, -0.12543856f, -0.02685232f, -0.09474996f, -0.04411150f, -0.37599236f, -0.03655337f, 
    0.04926387f, -0.04033538f, -0.03344765f, -0.10384769f, -0.14732532f, 0.21124780f, -0.02097361f, -0.15416189f, 
    -0.56056529f, 0.54960889f, -0.14164846f, 0.27841264f, -0.12908567f, -0.18899243f, 0.07359468f, 0.22177033f, 
    0.02072827f, 0.30142659f, 0.07362383f, -0.05646751f, -0.19047661f, -0.09721731f, -0.07340875f, -0.02297982f, 
    0.13227373f, 0.18761005f, 0.34022212f, 0.34095064f, -0.09314032f, -0.05441279f, 0.15749767f, -0.07344131f, 
    -0.01924195f, -0.16936034f, -0.28092945f, -0.41994676f, 0.33705407f, 0.19581920f, -0.12289388f, -0.00206387f, 
    0.21731640f, 0.10527793f, -0.03195302f, -0.03363766f, -0.51772916f, 0.12502888f, -0.24583423f, -0.05798385f, 
    -0.06425150f, -0.01566673f, 0.03714446f, 0.12425339f, -0.08068088f, 0.18036243f, -0.12646224f, -0.12902650f, 
    -0.05052498f, -0.09422240f, -0.05815301f, -0.20278913f, -0.35194880f, -0.18105817f, -0.32796970f, 0.19783777f, 
    -0.02541263f, -0.16495623f, 0.23204936f, -0.21368757f, 0.21694748f, -0.12988713f, -0.03975274f, -0.27528423f, 
    -0.35918623f, 0.08059669f, -0.13094591f, -0.01920423f, 0.01337793f, 0.12877396f, 0.19687799f, 0.12711996f, 
    0.56756729f, 0.17393354f, -0.27439851f, -0.17852959f, -0.19254367f, 0.10159896f, -0.12905811f, 0.22676730f, 
    0.17795750f, 0.17635521f, -0.21877886f, 0.10510217f, -0.08829411f, 0.14708790f, 0.00713947f, -0.05056674f, 
    -0.13342479f, 0.02057824f, 0.36212015f, 0.10918648f, -0.07027967f, -0.11093432f, -0.02234877f, 0.02401740f, 
    -0.11385917f, -0.10237613f, 0.21543856f, 0.09099065f, 0.00411445f, 0.07621554f, 0.10668193f, 0.03235465f, 
    0.06794690f, 0.08075253f, -0.22053595f, -0.07079674f, 0.05955343f, -0.00616592f, -0.22094178f, -0.12047134f, 
    -0.15878381f, -0.07145193f, -0.05372748f, 0.05673707f, -0.09591506f, -0.39506784f, -0.65694106f, 0.01228094f, 
    -0.30700117f, 0.26327398f, -0.14534272f, 0.17918499f, -0.07401507f, 0.13066268f, -0.33939996f, -0.58767480f, 
    -0.00933654f, 0.24288222f, 0.00365874f, -0.01459929f, 0.30355081f, 0.11096184f, -0.10268865f, -0.24467234f, 
    0.27567771f, -0.08896518f, -0.27741560f, -0.39602235f, -0.13286063f, 0.10161754f, 0.00231064f, -0.28099409f, 
    -0.10896131f, -0.22615542f, -0.43192747f, -0.04954000f, 0.13069826f, 0.08019865f, -0.02860305f, 0.15852441f, 
    0.40045995f, -0.23472612f, -0.21937659f, 0.20113146f, 0.00181528f, -0.01487470f, 0.20424174f, -0.02755613f, 
    -0.11506651f, 0.07766381f, 0.43829009f, 0.44993964f, -0.18076347f, -0.18837532f, -0.13189963f, 0.05167652f, 
    0.12509875f, 0.06188615f, -0.65346414f, -0.67623460f, 0.09328919f, -0.14710622f, 0.00463578f, 0.08800882f, 
    -0.01972739f, 0.11994334f, 0.27460128f, 0.51468015f, -0.65603870f, 0.36142385f, 0.31058538f, -0.18772566f, 
    -0.24103767f, 0.29735941f, -0.04776850f, 0.01534276f, -0.43143490f, -0.00803757f, 0.62360346f, -0.11267179f, 
    0.04363959f, 0.02238813f, 0.19264403f, -0.07192393f, 0.07495993f, 0.28353971f, 0.09769280f, -0.04476441f, 
    0.24531959f, 0.15704967f, 0.19334817f, 0.05642850f, 0.09234063f, -0.18213649f, 0.43391016f, 0.28331515f, 
    0.03832226f, 0.08301532f, 0.04031806f, 0.00531101f, 0.08546085f, 0.06522453f, -0.03684955f, -0.05152959f, 
    -0.04173703f, -0.05756577f, -0.83184624f, -0.06973108f, 0.01374572f, 0.04251054f, 0.09960908f, 0.14083101f, 
    -0.05621677f, -0.00304862f, -0.04931456f, -0.01808717f, 0.03682321f, -0.04226180f, -0.03684407f, 0.03712078f, 
    0.01134822f, 0.04532184f, 0.00235450f, -0.05338423f, -0.02530426f, -0.04906929f, -0.04284057f, -0.03975672f, 
    -0.00725630f, -0.02068578f, -0.04118688f, -0.04743166f, -0.04619952f, -0.05369233f, 0.02384157f, 0.02190185f, 
    -0.04317418f, 0.05031760f, 0.05236053f, -0.01108929f, -0.00276329f, -0.01599803f, -0.02037937f, -0.03920179f, 
    -0.00526268f, -0.02743932f, -0.02161571f, -0.00793679f, 0.00367167f, 0.01259924f, 0.01988332f, 0.00973523f, 
    -0.04020467f, -0.04197911f, -0.05712104f, -0.00955516f, -0.00691046f, -0.03912048f, -0.02520071f, 0.02881260f, 
    0.04134883f, 0.02543359f, 0.05237335f, 0.00767910f, -0.00157586f, 0.02420184f, 0.05131783f, 0.04515998f, 
    -0.04835886f, -0.02631981f, -0.03981426f, 0.00319687f, -0.01976750f, 0.04446799f, 0.01989115f, -0.05842377f, 
    -0.03381447f, -0.01435420f, -0.06114212f, -0.05093395f, 0.04262222f, 0.03077325f, -0.06221550f, 0.04201869f, 
    -0.01635865f, -0.01071006f, 0.01730480f, -0.02642988f, 0.04348686f, -0.03596511f, -0.03664287f, 0.01746900f, 
    -0.00984173f, -0.00069940f, -0.04321162f, 0.01568073f, -0.03562894f, -0.05025974f, 0.03593028f, 0.00424663f, 
    -0.00829467f, -0.02663760f, -0.02625765f, 0.02746917f, 0.01354374f, -0.03538279f, -0.05318505f, 0.03730955f, 
    -0.06098417f, 0.03892536f, -0.00677855f, -0.05618877f, 0.04240139f, -0.00113209f, 0.00985255f, -0.02390172f, 
    0.03785089f, 0.02254089f, 0.04696312f, -0.03718244f, -0.06234241f, 0.03730931f, -0.01751999f, 0.00986970f, 
    -0.02557499f, 0.03463344f, -0.05177209f, -0.00010806f, -0.00712745f, -0.04967779f, -0.04015746f, -0.04837121f, 
    0.05108535f, 0.00014455f, -0.05332524f, 0.04564987f, 0.02136713f, -0.05089544f, -0.06355304f, 0.05134822f, 
    -0.00034466f, -0.06251029f, -0.04895101f, 0.01421260f, -0.06063012f, -0.00874036f, -0.02700485f, -0.04514005f, 
    0.04147872f, 0.01826738f, -0.04614300f, 0.01793003f, 0.00890868f, -0.03220398f, 0.01180075f, -0.02277233f, 
    0.04777988f, -0.00049202f, 0.00704609f, 0.00451467f, -0.05520673f, -0.05484964f, -0.04835839f, 0.03536205f, 
    -0.04462766f, -0.05292010f, 0.05453691f, -0.06108515f, -0.04738984f, -0.04087610f, 0.04075201f, -0.01108601f, 
    -0.02120123f, -0.00850148f, -0.03278101f, -0.03039439f, 0.05319620f, -0.01298810f, 0.03745072f, 0.00534319f, 
    -0.03911425f, -0.05479242f, -0.03210038f, -0.05598996f, -0.04084879f, -0.01655879f, -0.04323345f, 0.05024099f, 
    -0.00881781f, -0.01404074f, -0.05305807f, 0.01192216f, -0.01589880f, 0.01606989f, 0.01124512f, 0.02814991f, 
    -0.02360325f, 0.03894635f, -0.04390854f, 0.02423594f, -0.04685971f, -0.04341765f, 0.00664874f, -0.01819727f, 
    -0.00719310f, -0.02133244f, 0.02341571f, -0.04902299f, -0.02027379f, -0.02243585f, 0.02061949f, -0.04389429f, 
    0.04831230f, -0.00558918f, 0.02791404f, -0.06073480f, 0.01165627f, -0.05336663f, -0.03464077f, -0.04496494f, 
    -0.05499563f, -0.01629003f, 0.04744425f, 0.03346689f, -0.05688830f, 0.04188285f, -0.03225804f, -0.01136495f, 
    -0.06202258f, 0.02361641f, 0.01485949f, -0.01087611f, 0.03105538f, 0.00428407f, -0.00103355f, 0.02931510f, 
    -0.01797011f, -0.01894945f, 0.02123802f, -0.00210763f, -0.05619768f, -0.02306776f, 0.02743637f, 0.01066181f, 
    0.00990699f, 0.00357008f, 0.02514469f, -0.02853132f, 0.00500149f, 0.01739314f, -0.01462160f, -0.03645726f, 
    -0.03256481f, 0.04497248f, -0.05408859f, 0.03461792f, -0.01120377f, 0.00022400f, 0.03391612f, 0.00798215f, 
    -0.04437833f, 0.00665544f, -0.01033934f, 0.05483056f, -0.05410494f, -0.04091664f, 0.04298456f, -0.01899435f, 
    -0.01210319f, 0.01337748f, 0.02013254f, -0.00851904f, -0.03380822f, 0.01863484f, 0.05851375f, -0.02773867f, 
    -0.02553888f, -0.01337057f, -0.01626174f, -0.00424073f, 0.01002404f, 0.05178030f, 0.03640085f, 0.01886093f, 
    -0.02518030f, -0.05372385f, -0.03476401f, 0.02163190f, -0.02258361f, 0.01661622f, 0.02034715f, 0.05667080f, 
    -0.04340643f, -0.01988044f, -0.01544849f, 0.03358427f, 0.00906681f, -0.01745090f, 0.00567745f, 0.04398896f, 
    0.11700483f, -0.03232315f, 0.21526144f, -0.18585072f, -0.25201795f, 0.13636546f, 0.09530652f, 0.10857087f, 
    0.10078958f, -0.05477656f, -0.13245179f, 0.52873766f, 0.11027591f, -0.12976970f, -0.18941380f, 0.06929538f, 
    -0.03686054f, 0.00874635f, 0.03522191f, 0.05996345f, -0.07133273f, -0.10087264f, 0.00949598f, 0.02924395f, 
    0.05744719f, -0.07148777f, 0.07099075f, -0.13308834f, 0.09884993f, -0.10963780f, 0.13551959f, 0.14951035f, 
    -0.00365744f, 0.00202626f, 0.02341613f, 0.07102577f, 0.15481766f, 0.14025597f, 0.09426310f, 0.06230779f, 
    0.02642109f, 0.09861351f, -0.01799047f, 0.01762682f, 0.04911584f, -0.03247855f, -0.13561866f, -0.04360232f, 
    0.06957386f, 0.11457818f, 0.03124112f, -0.03325472f, -0.06342773f, 0.12172206f, -0.34511894f, -0.55682796f, 
    0.18987921f, -0.02603722f, 0.13222457f, -0.59331262f, -0.08525673f, -0.29464421f, 0.02943313f, -0.09581093f, 
    0.21716371f, -0.04175398f, -0.10948499f, 0.03484875f, -0.01404305f, 0.20364894f, 0.11577896f, -0.15045513f, 
    -0.04005016f, 0.17198274f, 0.24792342f, 0.13854918f, 0.00190383f, -0.10613514f, -0.05998240f, -0.01900669f, 
    -0.00766753f, 0.07862086f, 0.53762281f, 0.11181267f, 0.05761049f, 0.02721257f, -0.07173552f, -0.07341157f, 
    -0.00647922f, -0.08996917f, 0.03732518f, 0.37469882f, 0.39150336f, -0.04295604f, -0.14553002f, -0.22907786f, 
    0.19902974f, 0.14625135f, -0.47117645f, -0.07888450f, 0.36505768f, 0.13511963f, -0.07650014f, -0.05302648f, 
    0.00958453f, 0.11518300f, -0.05320673f, 0.07497028f, 0.11268517f, 0.05365351f, 0.07781067f, 0.07338434f, 
    0.02891597f, -0.00824438f, 0.09212237f, -0.01755016f, -0.00180137f, 0.16824637f, 0.35002765f, 0.46272668f, 
    0.13572688f, -0.00326614f, -0.13846056f, 0.12963246f, 0.09825395f, -0.03754878f, -0.14537901f, 0.05960917f, 
    0.05139572f, -0.05768162f, -0.05055280f, 0.02575829f, -0.04129894f, 0.04485165f, 0.01370841f, -0.13057399f, 
    -0.00246473f, -0.34441933f, -0.00849920f, 0.02036571f, -0.11822206f, -0.01907603f, -0.14147180f, 0.00243942f, 
    0.25179410f, 0.29179522f, 0.12598518f, -0.20222330f, -0.29413354f, -0.20918609f, 0.08870665f, 0.05401787f, 
    0.10620801f, 0.10465770f, -0.68806624f, 0.07611955f, -0.01133395f, -0.01463483f, -0.18244767f, 0.14933096f, 
    0.03790414f, 0.13970697f, -0.48971361f, 0.01755604f, 0.17403764f, 0.04219473f, 0.17815112f, -0.11770358f, 
    0.06544945f, 0.03063039f, -0.10751788f, 0.13035879f, 0.11750499f, 0.18507756f, -0.02888988f, -0.01113492f, 
    -0.12526463f, 0.00751541f, 0.15056841f, 0.02131110f, -0.41071346f, -0.19162793f, 0.16453096f, -0.14506562f, 
    0.22277980f, -0.17656763f, -0.11211436f, 0.13293687f, -0.01609109f, -1.07081318f, 0.60520053f, 0.46559250f, 
    -0.32410204f, -0.02522631f, -0.19214757f, 0.09649299f, -0.17117698f, 0.11897597f, 0.06051623f, -0.13398859f, 
    -0.47547212f, 0.00624252f, -0.10265337f, -0.04882748f, 0.16592088f, 0.16582222f, 0.09087215f, -0.34253567f, 
    0.03426692f, 0.00948111f, -0.04668096f, 0.23829053f, 0.17238656f, 0.09098139f, 0.01835024f, 0.03893745f, 
    -0.16501912f, -0.28283045f, 0.05630771f, 0.03314410f, 0.00413243f, 0.02638879f, 0.17323346f, 0.05367930f, 
    0.17367695f, 0.16763380f, 0.37458077f, 0.31353095f, -0.01220554f, 0.17742929f, 0.02746363f, -0.02677008f, 
    0.01572716f, -0.03282116f, -0.25737357f, 0.06934775f, 0.15326840f, -0.05267635f, -0.04432241f, -0.12414780f, 
    0.07009908f, 0.04330042f, -0.17652644f, -0.53562689f, 0.04057274f, -0.14240414f, 0.00197780f, -0.11326179f, 
    0.04917914f, 0.06349837f, -0.20279826f, 0.28975156f, -0.22128069f, 0.23479049f, -0.43573388f, -0.17278385f, 
    0.13644210f, 0.05142399f, -0.31361270f, 0.19170305f, -0.07730664f, -0.25502583f, 0.30056384f, -0.15401256f, 
    0.13662554f, -0.03910713f, -0.08581360f, 0.03348269f, -0.17339413f, -0.04111160f, 0.02788928f, -0.07328934f, 
    0.11496262f, -0.12057494f, -0.08764106f, 0.06483921f, 0.10266156f, -0.02352188f, 0.10389869f, 0.02525897f, 
    0.04235046f, 0.01740967f, -0.05128980f, 0.08070108f, 0.04433147f, 0.19370514f, 0.02988714f, -0.17715462f, 
    0.36251411f, 0.06160343f, -0.34803015f, -0.04278730f, 0.19584630f, 0.21592778f, 0.04738339f, -0.00844972f, 
    0.08514787f, -0.24628995f, -0.64269382f, -0.41969654f, 0.06344409f, 0.00957328f, 0.06521211f, -0.12341500f, 
    0.01149085f, -0.34809047f, 0.07962810f, 0.08874723f, 0.03308829f, -0.01316220f, -0.10839286f, -0.13628252f, 
    0.14017522f, 0.12954681f, -0.03673897f, -0.68723971f, -0.43696120f, -0.56324697f, -0.09088501f, -0.11229831f, 
    -0.04199352f, -0.00784610f, 0.12889390f, -0.14721356f, 0.11043828f, 0.06046815f, -0.11009423f, 0.08703828f, 
    0.23545563f, 0.05933063f, 0.19906272f, 0.09303644f, -0.00595625f, 0.06001919f, 0.12175962f, -0.58581930f, 
    -0.06897973f, -0.17011589f, -0.17268792f, -0.01857949f, 0.12444816f, 0.15906371f, 0.13837659f, -0.13541618f, 
    0.19987631f, -0.36777037f, 0.08858167f, 0.00394500f, 0.16573068f, 0.10890135f, 0.20932801f, 0.02944240f, 
    -0.20779590f, 0.02088371f, 0.15172568f, -0.01985627f, 0.08845675f, 0.15423375f, 0.16915125f, -0.07385546f, 
    -0.48124042f, -0.24671912f, -0.44531369f, -0.14878559f, -0.10419585f, 0.09503850f, 0.00915669f, -0.13925946f, 
    -0.27107686f, -0.21660043f, -0.31527269f, -0.88074142f, -0.09293839f, -0.06180588f, -0.18409048f, -0.04655692f, 
    0.14207618f, 0.01662191f, -0.03682747f, 0.24774884f, 0.29364541f, 0.19384645f, -0.18397662f, -0.13536498f, 
    0.09661037f, 0.25745934f, 0.00897139f, 0.12893794f, 0.22521551f, 0.07786837f, -0.13208850f, -0.09067089f, 
    -0.15540691f, 0.13117880f, 0.06517991f, -0.04094367f, -0.13876775f, -0.02218659f, -0.15210052f, 0.08649009f, 
    0.00301461f, -0.04633404f, 0.05735425f, 0.20259383f, 0.03153603f, -0.04173960f, -0.03108378f, 0.29956669f, 
    0.18102612f, 0.06808241f, 0.15746406f, 0.22326678f, 0.01864518f, 0.14161140f, 0.03066093f, -0.04456462f, 
    0.01976981f, -0.07501548f, 0.03889620f, 0.26130515f, 0.14889520f, 0.10713144f, 0.07348655f, 0.02482736f, 
    0.25250867f, 0.02084130f, -0.19780630f, 0.08422785f, 0.19054146f, -0.05289235f, -0.23529267f, -0.09742995f, 
    0.12329713f, 0.40205520f, 0.04081541f, 0.09755773f, 0.03217332f, 0.04442582f, 0.11985543f, 0.05166147f, 
    0.02174334f, -0.07346929f, -0.01289501f, -0.11896472f, -0.02275818f, 0.06209701f, -0.00683710f, -0.03754692f, 
    0.25403938f, 0.12130857f, 0.51549995f, -0.10015069f, -0.06271399f, -0.13315964f, -0.05073435f, -0.08127899f, 
    0.02665669f, 0.00185902f, 0.33121544f, 0.16403861f, -0.04717639f, -0.19709936f, 0.08141454f, 0.10415277f, 
    0.09243362f, 0.14398579f, 0.02406271f, -0.09719190f, 0.31930956f, -0.20187441f, -0.28950673f, 0.05402721f, 
    0.09397946f, 0.25716740f, 0.14600497f, 0.15689282f, -0.07821200f, 0.24822494f, 0.23934954f, 0.18067078f, 
    -0.28262490f, -0.25856361f, -0.17432575f, 0.06792159f, -0.01020913f, -0.00195402f, 0.06574985f, 0.03101458f, 
    -0.02486872f, 0.07188604f, 0.09012705f, 0.07395614f, 0.11757197f, 0.20765506f, 0.48071387f, -0.05106816f, 
    -0.30891567f, -0.10125305f, 0.08968244f, 0.04799784f, -0.05226689f, 0.01257220f, -0.22900964f, 0.07931725f, 
    0.23702437f, -0.28175017f, -0.26067725f, -0.05440725f, 0.08242998f, 0.35114005f, -0.04176890f, -0.12050171f, 
    0.23281592f, -0.27860421f, 0.02649177f, 0.25582144f, -0.19766238f, -0.16863891f, -0.08471215f, -0.02189837f, 
    0.03917534f, -0.01850291f, 0.16846643f, -0.15107730f, -0.03359664f, 0.08891843f, -0.00523116f, 0.21280907f, 
    0.05953679f, -0.07300259f, -0.25792325f, -0.00923266f, 0.10317302f, 0.01396105f, -0.08329416f, -0.16397110f, 
    -0.12984815f, -0.00202868f, 0.07772776f, 0.15954795f, -0.32444745f, 0.01538723f, -0.29815829f, -0.20417747f, 
    -0.10518640f, -0.14250909f, 0.25790873f, 0.10851630f, -0.06706018f, 0.04792599f, -0.25004530f, -0.47571868f, 
    0.00580476f, -0.12522520f, -0.23854589f, -0.08305874f, -0.05027556f, 0.00967235f, 0.19659659f, -0.17056079f, 
    -0.34809813f, -0.05077808f, -0.05318329f, -0.01606062f, -0.05602669f, -0.05102104f, 0.03083307f, 0.11587124f, 
    0.12563498f, 0.05011784f, -0.10600858f, -0.18971264f, -0.20527573f, 0.04997168f, 0.01312213f, 0.04281924f, 
    0.25037697f, 0.04690249f, -0.05284376f, 0.03019294f, 0.28264943f, 0.11244266f, -0.13855636f, -0.04937524f, 
    -0.04430889f, 0.08645299f, 0.31176642f, -0.03931976f, 0.10666029f, -0.03349135f, -0.11550580f, -0.18820253f, 
    -0.00951087f, -0.01190616f, -0.03392050f, 0.14048061f, -0.05339589f, -0.08908901f, -0.09866772f, 0.03570804f, 
    0.09274958f, 0.13754624f, 0.03699157f, 0.40407237f, -0.02987189f, 0.00339054f, 0.03720729f, 0.01623049f, 
    0.07276364f, 0.09307054f, -0.02760766f, 0.00170230f, -0.05232719f, 0.01262370f, 0.03367143f, 0.09397887f, 
    0.03351551f, 0.09479146f, -0.01289673f, 0.17381145f, 0.12975268f, 0.30997735f, 0.28928554f, 0.16396800f, 
    -0.00744940f, -0.02198087f, -0.29525182f, 0.10521405f, 0.03546488f, 0.02427702f, -0.39013717f, -0.37012789f, 
    -0.39879125f, -0.34593803f, -0.07316778f, 0.10223258f, -0.09435296f, 0.03031370f, 0.03975913f, -0.13264602f, 
    -0.23264106f, 0.00100036f, 0.09669902f, 0.18925382f, -0.10299846f, 0.09529056f, -0.00166337f, 0.04174104f, 
    0.07741986f, -0.03066923f, 0.07990007f, -0.07130388f, -0.03861396f, 0.06649470f, -0.11233614f, -0.06131119f, 
    0.01128513f, 0.06057600f, 0.19812672f, 0.10590149f, -0.03961147f, 0.11934336f, 0.00031077f, 0.11466628f, 
    -0.13896874f, 0.00307129f, -0.14581673f, -0.22343306f, -0.24696022f, 0.06403567f, -0.16266656f, -0.07755040f, 
    0.02361313f, -0.08756400f, 0.00697007f, -0.10006332f, -0.11642764f, -0.03174263f, -0.03719136f, 0.03945648f, 
    0.03131401f, 0.12058533f, -0.07527478f, 0.12675214f, -0.10937590f, -0.13090439f, -0.25293651f, 0.04155753f, 
    -0.01496829f, -0.02462570f, 0.10431702f, 0.01383942f, -0.04671293f, -0.65484393f, -0.78155649f, -0.51674902f, 
    -0.10111587f, -0.17923005f, -0.00339298f, -0.06857996f, 0.01392323f, 0.03838957f, -0.27500513f, -0.24583712f, 
    -0.20648448f, 0.11875096f, -0.05562827f, 0.03077727f, 0.10445062f, -0.12516589f, 0.07463295f, 0.26094869f, 
    0.20492117f, 0.26860285f, -0.08113606f, -0.03330582f, -0.03605019f, 0.02768931f, -0.03317109f, -0.07822614f, 
    0.23446165f, 0.15209930f, 0.23334767f, 0.10864139f, 0.13553391f, 0.20609386f, 0.09773534f, -0.09616285f, 
    0.09476896f, -0.22086048f, -0.06827887f, -0.00101791f, -0.13457000f, 0.03669909f, -0.01838747f, 0.01040604f, 
    -0.04302434f, 0.05622768f, 0.36024541f, 0.25148278f, 0.27688846f, 0.00233282f, -0.12647229f, 0.06927916f, 
    0.14185713f, 0.12461206f, -0.00559557f, -0.08376037f, -0.10520712f, -0.16270579f, -0.09723390f, -0.06101985f, 
    -0.26700914f, 0.03968434f, -0.02735276f, 0.02814115f, -0.44803432f, -0.38518378f, -0.54850185f, -0.11938322f, 
    -0.29905111f, 0.00495991f, 0.05364134f, 0.00490423f, 0.09781282f, 0.27508777f, -0.02430729f, 0.25864726f, 
    0.09028459f, -0.00123450f, 0.12201441f, 0.08098239f, -0.01404970f, 0.23199038f, -0.21771863f, -0.20098527f, 
    0.06149009f, 0.08697017f, 0.02537242f, -0.07043335f, 0.01083111f, 0.21061626f, 0.12493557f, -0.40131846f, 
    -0.53253245f, -0.74333519f, -0.07232432f, 0.03459819f, -0.19362256f, 0.06924710f, 0.03823949f, -0.03269216f, 
    0.26683682f, 0.04289621f, 0.27860412f, 0.07133796f, -0.01635127f, 0.05196426f, 0.01260617f, -0.00941764f, 
    0.17256252f, 0.07283603f, 0.01712848f, 0.40244812f, -0.25924855f, -0.04132823f, -0.08791528f, -0.01125243f, 
    0.04043287f, -0.09387080f, -0.08486921f, -0.40104669f, -0.27993095f, -0.09503757f, -0.07228552f, -0.16138415f, 
    0.11346754f, -0.01396838f, 0.05831529f, 0.43813363f, -0.26516855f, 0.07944745f, 0.12075225f, 0.02896989f, 
    0.01393170f, -0.18290095f, 0.10779749f, 0.10583015f, -0.10198995f, -0.48977157f, -0.10906069f, -0.29722035f, 
    0.02815682f, 0.09088524f, 0.14226873f, 0.10344943f, 0.05804506f, 0.24594353f, 0.35952064f, 0.30905336f, 
    0.08766662f, 0.14963453f, 0.20485044f, 0.14035417f, 0.10956959f, -0.03224321f, 0.47041219f, 0.31751370f, 
    0.41903538f, 0.11318861f, 0.06730429f, -0.01528528f, 0.08768724f, 0.05887217f, -0.09062827f, -0.05029050f, 
    0.00690539f, -0.03863883f, -0.09805252f, -0.11379625f, -0.01624840f, 0.07312685f, 0.08601411f, 0.05385332f, 
    -0.01069867f, -0.01593486f, -0.05973062f, 0.08209660f, 0.02070907f, 0.22297205f, 0.05579489f, 0.13572446f, 
    0.03522060f, -0.03575445f, 0.14929143f, 0.31520253f, -0.23235779f, 0.03394504f, -0.09302933f, 0.00256684f, 
    -0.04789297f, 0.01361940f, -0.59989351f, -0.09107780f, -0.26887101f, 0.04600235f, -0.03299513f, 0.08881163f, 
    0.09992468f, 0.00046421f, 0.17538649f, 0.00649285f, 0.10004788f, 0.01958857f, 0.04105332f, -0.14519581f, 
    0.15914965f, -0.03612458f, 0.00286510f, -0.00862640f, -0.42447171f, -0.20624816f, -0.06867354f, 0.08565933f, 
    0.07266722f, 0.12134814f, 0.00639284f, -0.04051526f, -0.02349456f, -0.28262722f, -0.01650665f, 0.07557926f, 
    0.04311052f, -0.16824448f, 0.01766155f, 0.07804625f, 0.02236427f, -0.04414343f, 0.07047901f, 0.16090806f, 
    -0.24405263f, 0.11999330f, -0.21964277f, 0.14928049f, 0.06604423f, 0.11983546f, 0.33677247f, 0.11691727f, 
    -0.43003070f, -0.12918206f, -0.06563315f, 0.03670921f, -0.12858742f, 0.11728963f, -0.15514340f, 0.06572388f, 
    0.15774606f, 0.02876267f, -0.04339928f, 0.04195772f, -0.02696799f, -0.01952040f, -0.12452140f, -0.06045111f, 
    -0.02268202f, 0.09233826f, -0.24201904f, 0.20685756f, 0.03059360f, -0.00725846f, 0.23864387f, 0.04736806f, 
    0.00685229f, -0.21114022f, 0.44247690f, 0.04943899f, -0.24279593f, -0.14814024f, -0.03714102f, 0.07592805f, 
    0.39999598f, -0.16581576f, -0.18250012f, -0.41415963f, -0.33564559f, -0.24965632f, 0.08375908f, 0.11566916f, 
    0.22038785f, -0.08547911f, -0.03927351f, 0.05207151f, 0.05568976f, 0.02437406f, 0.23673084f, -0.00915263f, 
    -0.04433402f, 0.12432458f, 0.14912219f, 0.06220413f, 0.15370591f, 0.15887074f, -0.29040763f, -0.10579597f, 
    -0.38099191f, -0.28766221f, 0.02792169f, 0.24797747f, -0.31775796f, -0.01454185f, 0.06227320f, -0.27214047f, 
    -0.25094128f, 0.15062332f, -0.08035364f, 0.13858667f, -0.05377591f, -0.10407452f, 0.03708961f, 0.05251902f, 
    -0.17070132f, -0.13045633f, -0.07268139f, 0.17229857f, 0.03197106f, -0.16880040f, -0.22000377f, -0.12300639f, 
    -0.10516854f, -0.04251469f, 0.40190154f, -0.08434596f, 0.14716485f, 0.17675276f, 0.30455559f, 0.07829770f, 
    0.09008900f, -0.31863695f, -0.39827996f, 0.30047363f, -0.07381784f, -0.13990629f, 0.03991269f, 0.02990296f, 
    -0.17473242f, 0.23127821f, -0.05409801f, 0.17971200f, 0.24037257f, 0.14676125f, 0.04996002f, 0.07627721f, 
    0.13341039f, 0.21055207f, 0.04743288f, 0.14155895f, -0.03887619f, 0.36260515f, 0.16937505f, 0.14114894f, 
    -0.06771150f, -0.07363580f, 0.05476490f, 0.18727672f, -0.28491229f, -0.18813528f, 0.27494100f, -0.02376290f, 
    -0.33523414f, 0.04527697f, -0.00697960f, -0.02291142f, 0.06720906f, -0.26527524f, 0.03879507f, 0.48858654f, 
    0.06402655f, -0.09365091f, 0.01060799f, 0.09270866f, -0.03760154f, 0.14647067f, -0.03521327f, -0.13429624f, 
    0.00350855f, -0.14541806f, 0.03032586f, -0.19892329f, 0.14085764f, -0.04415435f, 0.09821826f, -0.57877344f, 
    -0.23903118f, -0.27223924f, -0.22654836f, -0.22183369f, -0.19952637f, 0.01202702f, 0.02779680f, 0.21688835f, 
    0.31162378f, 0.36036834f, 0.37373266f, 0.10586362f, 0.15140967f, -0.09693813f, 0.33519608f, 0.20817156f, 
    -0.12412994f, -0.11090252f, -0.14444521f, -0.00146988f, -0.04541615f, 0.04854595f, -0.14994593f, -0.01994397f, 
    0.14976029f, -0.26871276f, 0.07884972f, -0.13733673f, -0.49181119f, -0.02242232f, -0.14239791f, -0.28806230f, 
    -0.04953404f, -0.29056203f, -0.20599441f, 0.81487775f, 0.09865520f, -0.37949437f, -0.28211060f, -0.21034008f, 
    -0.11287619f, 0.19199738f, -0.08902390f, -0.11337765f, 0.18901578f, 0.00063845f, -1.04049981f, 0.02537841f, 
    -0.02258364f, -0.37466905f, 0.10094839f, 0.00264918f, 0.03508469f, -0.29856414f, 0.29089478f, 0.64418960f, 
    0.13691977f, 0.01848047f, -0.14825375f, 0.23059139f, 0.27554291f, 0.02926243f, -0.14166149f, -0.09248403f, 
    0.28000292f, 0.02183680f, 0.07649810f, 0.13350640f, 0.24144110f, 0.06331819f, -0.22827742f, -0.32673961f, 
    -0.30953926f, -0.16199082f, -0.13920298f, -0.01547850f, -0.41867602f, -0.04537473f, 0.03250331f, 0.02865635f, 
    0.02914889f, 0.15270048f, 0.00587724f, 0.04049349f, 0.09827757f, 0.09525141f, -0.02159593f, 0.25828719f, 
    0.10739133f, 0.17017323f, -0.10352070f, -0.04841257f, -0.05850850f, 0.04488300f, 0.14700612f, 0.04911136f, 
    0.35367942f, 0.03061545f, 0.06392498f, 0.11644190f, 0.06780086f, 0.15534674f, 0.27802879f, 0.05038428f, 
    0.13642785f, 0.17637134f, 0.07817134f, 0.38154507f, 0.21015792f, -0.06669220f, 0.00441210f, -0.13854629f, 
    -0.00098128f, -0.14425692f, -0.12415204f, -0.29957920f, -0.07196911f, 0.18313947f, 0.08593750f, 0.01095866f, 
    -0.14174238f, -0.10339606f, 0.01136689f, 0.25486031f, 0.27061215f, 0.01415903f, -0.18661001f, -0.16483279f, 
    0.17082277f, 0.04624946f, -0.01725488f, -0.05077204f, 0.04230954f, -0.02955938f, 0.14643919f, 0.35200360f, 
    0.15215236f, 0.33092642f, 0.29369080f, 0.26696444f, -0.11266758f, 0.21204366f, -0.07609725f, 0.07417205f, 
    0.06248621f, 0.15299620f, -0.00263211f, 0.16883826f, 0.06460322f, 0.06854869f, 0.19872063f, 0.09215542f, 
    0.37072930f, -0.09874900f, -0.07244536f, 0.10389395f, 0.08206134f, 0.09892953f, 0.12052527f, 0.06239381f, 
    0.05070224f, 0.07662717f, 0.07632648f, 0.03363853f, -0.04793087f, 0.11163595f, -0.02779322f, 0.05193406f, 
    -0.08508007f, 0.21858893f, 0.47765514f, 0.12737027f, 0.06718404f, 0.17107415f, 0.34914812f, 0.14346568f, 
    0.18326552f, 0.01493983f, 0.14568692f, 0.08533751f, 0.05365133f, 0.13216530f, 0.27283388f, 0.23589456f, 
    -0.10126189f, -0.06967770f, 0.00990679f, 0.10355279f, 0.03569513f, -0.00786627f, -0.06189225f, -0.00957876f, 
    0.00232124f, -0.02139802f, -0.00952203f, -0.02310270f, -0.27250430f, 0.09567557f, 0.07412884f, 0.13279924f, 
    0.05834745f, 0.09443016f, 0.08789072f, -0.09295072f, 0.16842221f, -0.09816116f, 0.03300706f, 0.12213724f, 
    0.04544298f, -0.02124748f, 0.44921494f, 0.15330437f, 0.33017990f, 0.19818424f, 0.13612838f, -0.13359527f, 
    -0.11286336f, -0.24270968f, -0.11871970f, 0.11914639f, 0.18202379f, 0.14469220f, 0.13868277f, 0.13117203f, 
    -0.15679836f, 0.36807021f, 0.20663996f, -0.16581839f, -0.03779082f, -0.12125137f, 0.00268376f, 0.05250787f, 
    0.05980241f, -0.16145495f, -0.15976076f, -0.09085929f, -0.12810051f, -0.01334009f, -0.03182902f, -0.20406108f, 
    -0.33183333f, -0.32746023f, -0.31730548f, 0.04851791f, -0.12699969f, 0.20071101f, 0.00935302f, 0.07168315f, 
    -0.10529900f, -0.36980599f, -0.69880176f, 0.15665026f, -0.00773888f, 0.05551245f, 0.02672790f, 0.13008364f, 
    0.24206342f, 0.14469071f, 0.09063629f, 0.09251952f, -0.06915557f, 0.06339771f, 0.10640270f, 0.07729235f, 
    -0.00042452f, 0.26906797f, 0.10087929f, 0.24753813f, 0.20641257f, -0.15349542f, 0.00947636f, -0.13952710f, 
    0.26261932f, 0.09514104f, 0.04485352f, -0.18918768f, -0.15872632f, -0.18070349f, 0.04934090f, 0.01052196f, 
    0.05192455f, -0.02496471f, 0.03236163f, 0.05979462f, -0.09380991f, -0.14576927f, -0.09424857f, -0.31359929f, 
    0.01289974f, 0.11025631f, -0.11796788f, 0.05695523f, -0.00824631f, 0.13113286f, 0.18627071f, -0.09134912f, 
    -0.11459681f, -0.16216893f, -0.13224778f, -0.21938552f, -0.00170504f, -0.19494639f, -0.06042146f, -0.32361165f, 
    -0.43480757f, 0.21904677f, -0.01851659f, 0.03597476f, 0.12437899f, -0.03139288f, 0.03259968f, 0.14807494f, 
    0.06617998f, -0.20484886f, -0.28618625f, 0.08576559f, -0.13989696f, -0.09808247f, 0.18640906f, 0.12027848f, 
    0.08145609f, 0.15227413f, 0.08992569f, 0.09505284f, -0.02132104f, -0.02365653f, -0.03681186f, -0.05139927f, 
    0.11896527f, -0.15134661f, -0.41887590f, -0.22077878f, 0.34328976f, 0.22181228f, -0.03285980f, 0.28217828f, 
    -0.07599317f, 0.15283255f, 0.14974062f, 0.20682809f, 0.19125031f, 0.06104653f, -0.09405378f, -0.02502446f, 
    -0.03379957f, -0.07852445f, -0.19783087f, -0.09134684f, 0.05933155f, -0.05368926f, 0.02556824f, 0.04971345f, 
    0.15066145f, -0.08638736f, -0.01906776f, -0.02530461f, 0.06168440f, 0.12449829f, -0.13573901f, -0.00221053f, 
    -0.03954216f, 0.06376299f, 0.18843544f, 0.22521508f, 0.09483835f, -0.14782660f, -0.10141951f, 0.08674003f, 
    -0.02167005f, -0.17570429f, 0.32441491f, -0.18950653f, -0.11542651f, 0.05161080f, -0.01064706f, -0.04426144f, 
    0.20952903f, -0.68461031f, -0.33192572f, 0.30826357f, -0.01672042f, 0.09196269f, -0.09784310f, 0.00048897f, 
    0.14561252f, 0.07951284f, -0.01631049f, 0.02109001f, -0.29320535f, -0.01628673f, 0.07603100f, -0.13546784f, 
    0.18176648f, -0.01444994f, 0.07630828f, -0.03066663f, -0.21440300f, 0.34422219f, 0.11259303f, -0.03325197f, 
    -0.22600187f, 0.06558868f, -0.04284913f, -0.10263871f, 0.10714283f, -0.01222482f, -0.21157396f, -0.06859445f, 
    0.18504797f, 0.03526433f, 0.19476956f, -0.10258230f, 0.13222994f, -0.29118571f, -0.20956571f, 0.00312232f, 
    -0.03002380f, -0.10700111f, -0.13181984f, -0.01984688f, 0.04177677f, -0.14730124f, 0.33826599f, 0.20568383f, 
    0.29297423f, 0.24272875f, 0.02192998f, -0.19041498f, -0.09691449f, 0.10588123f, 0.06312183f, -0.14481945f, 
    -0.00702909f, 0.04568796f, -0.04545594f, 0.02708383f, -0.12086387f, -0.03517340f, 0.15573908f, -0.05324216f, 
    -0.36766386f, -0.21144956f, 0.31431541f, -0.00830038f, 0.00677151f, -0.16688181f, 0.15667537f, 0.07349744f, 
    0.25497514f, -0.19585657f, -0.32394412f, 0.55106336f, 0.03272767f, -0.00372519f, 0.03016606f, 0.06612440f, 
    0.04290614f, 0.03993278f, -0.19013879f, 0.01906419f, 0.18885195f, -0.06984817f, 0.03321281f, 0.04704591f, 
    -0.18208207f, 0.22707614f, 0.65351325f, -0.03376941f, 0.04342689f, -0.24802005f, 0.02804842f, -0.09241276f, 
    0.01849023f, 0.09411880f, 0.11375055f, -0.00280866f, -0.14650971f, 0.08722635f, 0.00445361f, -0.07452680f, 
    0.11316123f, -0.02749894f, 0.02054529f, 0.04910022f, -0.08556338f, -0.24488546f, 0.14859423f, 0.56599331f, 
    -0.19484830f, 0.07530086f, -0.10625128f, 0.05605077f, -0.02548832f, 0.02682309f, -0.15356770f, 0.00447095f, 
    -0.18394755f, -0.00458730f, 0.07406384f, 0.12637043f, 0.10685613f, 0.13513862f, 0.07629530f, -0.49189469f, 
    -0.53693318f, 0.27475551f, -0.04554704f, -0.06735554f, -0.27520311f, 0.13839518f, -0.06774363f, 0.19992657f, 
    0.37631553f, 0.05878889f, -0.04182959f, -0.12246184f, 0.13050663f, 0.04343566f, 0.02470806f, -0.07437766f, 
    0.05122466f, -0.31599224f, 0.07866104f, -0.26905808f, -0.05480718f, -0.02457844f, -0.11365502f, -0.03386471f, 
    -0.00159770f, -0.05231465f, 0.20402531f, -0.05998436f, -0.21534161f, 0.10131480f, 0.06943268f, -0.00550827f, 
    -0.02450872f, 0.05182343f, -0.05822325f, -0.15069777f, 0.31543487f, 0.32908735f, 0.01463878f, 0.01938189f, 
    -0.05911033f, -0.07244744f, 0.10875608f, 0.10529836f, -0.08110198f, 0.03037710f, 0.24494725f, -0.13859980f, 
    0.21034995f, -0.07733212f, 0.11415809f, 0.25379032f, -0.01574986f, 0.25626567f, 0.12000729f, 0.05103115f, 
    -0.05786009f, 0.12196364f, -0.33514637f, -0.07724317f, -0.00265869f, 0.07502294f, -0.15801124f, -0.01033040f, 
    -0.12055936f, -0.03607678f, -0.04425296f, -0.13695771f, -0.10207494f, 0.02200927f, -0.03019975f, -0.59802586f, 
    0.07391584f, 0.16629517f, 0.09584601f, -0.01939072f, -0.13950108f, -0.03681724f, 0.10889541f, 0.01533642f, 
    0.07660508f, -0.04968384f, 0.11640824f, 0.07267904f, 0.12897862f, -0.00928085f, 0.00656454f, 0.29944849f, 
    0.00760204f, -0.02849524f, -0.31890139f, 0.05907150f, 0.04359239f, 0.08623272f, -0.29201087f, 0.05810705f, 
    0.04338131f, 0.06453124f, -0.44959736f, -0.06431901f, -0.03650092f, -0.02869989f, 0.14312182f, -0.11322568f, 
    0.11004663f, -0.00777218f, 0.20250314f, -0.25665617f, -0.17251493f, -0.29907060f, -0.17049573f, 0.00620042f, 
    -0.00884940f, -0.38371015f, -0.10995970f, 0.35002604f, 0.32291454f, 0.13354121f, -0.74403834f, 0.23964295f, 
    0.07377224f, -0.08441702f, -0.01554528f, 0.21452826f, -0.03261648f, 0.13442849f, -0.07426389f, -0.43999115f, 
    0.03926692f, -0.04782100f, 0.09678260f, -0.09678391f, 0.12073070f, 0.09775562f, 0.16132651f, -0.17312707f, 
    0.10510287f, -0.06371929f, 0.03673669f, -0.08099376f, -0.08725342f, 0.08777770f, -0.08239324f, -0.07997097f, 
    -0.08743943f, -0.17383833f, -0.04511594f, 0.01762230f, -0.00482853f, 0.24721625f, 0.05263662f, 0.02355316f, 
    -0.20213848f, -0.14257990f, 0.19507304f, -0.08032421f, 0.29879543f, 0.06993666f, 0.13075420f, 0.04884762f, 
    -0.05027597f, -0.64723331f, -0.08838683f, 0.23596957f, -0.21878238f, 0.02403175f, -0.24670579f, 0.00160845f, 
    0.01518737f, -0.03485352f, 0.03313677f, 0.18571274f, 0.02036398f, 0.03088839f, 0.01391817f, -0.05410618f, 
    0.00750140f, 0.19722371f, -0.19861643f, -0.23584892f, -0.17090917f, 0.33595130f, -0.11137025f, 0.12093984f, 
    0.01114170f, -0.03456251f, 0.04179038f, -0.06347658f, -0.00993012f, -0.08694030f, -0.29743055f, 0.05895725f, 
    0.10712802f, -0.02828730f, 0.11575297f, 0.01174921f, -0.06026077f, -0.15396971f, -0.04714394f, -0.01767682f, 
    -0.06183260f, 0.06427021f, 0.08356924f, 0.10684916f, 0.04653744f, -0.12233172f, -0.35441455f, 0.02679686f, 
    0.64670062f, -0.10359682f, 0.08249079f, 0.00353815f, -0.14068645f, -0.02829823f, 0.03089537f, 0.09292204f, 
    0.12920341f, 0.35101905f, 0.02532110f, -0.12037767f, -0.18278491f, -0.04064317f, 0.18506134f, -0.00631895f, 
    -0.28713796f, -0.08586548f, 0.28139782f, 0.16348732f, 0.11485404f, 0.07005305f, 0.08977394f, 0.08953433f, 
    0.08940551f, 0.03169382f, 0.19197361f, -0.27145204f, -0.14417358f, -0.11945862f, 0.23426446f, 0.17101857f, 
    0.05836302f, -0.26241899f, 0.22030063f, -0.27628124f, 0.40183085f, -0.10818101f, -0.14009440f, 0.16242753f, 
    0.02153866f, 0.12725121f, 0.21014212f, 0.09495483f, -0.06507809f, -0.17417210f, -0.00809043f, -0.02631875f, 
    -0.01380674f, -0.05794165f, 0.11235262f, 0.09172485f, -0.02857449f, -0.03400692f, -0.20788050f, -0.01107242f, 
    0.03684969f, -0.05109791f, -0.04489128f, -0.11544567f, -0.14907198f, 0.04937568f, -0.31245759f, 0.22624059f, 
    0.11663096f, -0.21702489f, -0.12069968f, -0.02998197f, -0.13124473f, 0.03878319f, 0.07204269f, 0.21771443f, 
    -0.10324154f, 0.19094253f, 0.09605393f, 0.05480854f, 0.26427749f, 0.12944402f, -0.12840490f, -0.31730703f, 
    -0.09948057f, 0.00421625f, 0.12912105f, 0.07737191f, 0.02340221f, 0.20169893f, 0.19087461f, 0.22978127f, 
    0.28106198f, -0.28850076f, -0.17332618f, -0.03176617f, -0.01979278f, -0.04050080f, 0.08158389f, 0.09707543f, 
    -0.02097660f, 0.00465795f, 0.01576598f, -0.23767073f, 0.01676155f, -0.04153719f, -0.08858076f, 0.04243251f, 
    -0.05693167f, -0.05374580f, -0.07411845f, -0.33814451f, -0.15153919f, 0.10958564f, -0.01098037f, -0.16664383f, 
    -0.06644163f, -0.25539884f, -0.04771010f, -0.00889091f, 0.20025228f, 0.26466620f, -0.07330196f, -0.15931088f, 
    -0.06189140f, 0.01549180f, 0.04580083f, 0.05861056f, -0.03165041f, 0.13092907f, 0.12369236f, 0.11598615f, 
    -0.22012587f, 0.20794111f, 0.10802664f, 0.10742020f, 0.05437358f, 0.18776511f, -0.33860144f, -0.24381934f, 
    -0.02500518f, -0.07438122f, -0.30368099f, -0.19266228f, -0.07886230f, -0.05372367f, 0.05858810f, 0.15168935f, 
    0.21035992f, 0.02912614f, -0.12251168f, -0.25404438f, 0.10407662f, 0.05128512f, 0.07362039f, 0.05222319f, 
    0.45848694f, 0.09793021f, -0.18740231f, 0.00818917f, -0.15613990f, 0.27871424f, 0.30106410f, 0.14695278f, 
    0.20092019f, -0.16075444f, -0.11131439f, 0.02607043f, -0.00854354f, -0.09038011f, -0.18305126f, -0.17757718f, 
    -0.20464742f, 0.10012019f, 0.18148758f, -0.26024219f, 0.02132469f, 0.18099962f, -0.16723306f, -0.00669175f, 
    0.10362919f, 0.05762101f, 0.05679748f, 0.13787390f, 0.35901579f, 0.06070576f, 0.10233089f, -0.16143550f, 
    0.27643326f, 0.15801115f, 0.24716291f, 0.03431620f, -0.01512994f, 0.03731974f, -0.00687868f, -0.01606772f, 
    0.04791237f, -0.16296628f, -0.07300434f, 0.27901813f, -0.57119960f, 0.42402971f, 0.09071578f, 0.20575824f, 
    0.32361192f, 0.08001498f, 0.05307629f, 0.08463047f, 0.24865936f, -0.18441756f, 0.46025270f, -0.59677953f, 
    -0.10427344f, -0.28506666f, -0.07661799f, -0.05671896f, -0.02366350f, 0.05684349f, 0.25084820f, 0.28369293f, 
    -0.08351471f, -0.01867340f, 0.00594889f, -0.18664880f, 0.02682356f, 0.11989237f, 0.01417598f, 0.11235461f, 
    -0.00141481f, 0.08031134f, -0.09053715f, 0.09779523f, 0.06682210f, -0.17160694f, -0.07387752f, 0.14280117f, 
    0.32672569f, -0.14564972f, 0.05241087f, 0.17721270f, -0.00429141f, 0.29312921f, -0.00146486f, 0.08591778f, 
    0.15711319f, 0.21743146f, 0.19719836f, -0.33471915f, 0.09889349f, 0.12297653f, 0.02097565f, 0.01345220f, 
    0.13861363f, 0.00758713f, -0.25895974f, -0.10588525f, 0.07623413f, -0.03964532f, 0.06658085f, 0.11332938f, 
    0.12151010f, 0.03874296f, 0.15585963f, -0.00298351f, 0.18006487f, -0.41568777f, -0.03000269f, -0.07487622f, 
    0.10616412f, 0.00025189f, 0.00499186f, -0.16121823f, 0.03614254f, -0.05436527f, 0.11577213f, -0.04505489f, 
    0.08337646f, 0.02063903f, 0.15608710f, 0.10039686f, 0.18255267f, -0.08823833f, -0.06013335f, -0.22620307f, 
    0.04242580f, -0.10945541f, 0.06666496f, 0.02654621f, -0.01608049f, 0.01483927f, -0.21332434f, 0.23664497f, 
    0.08058115f, 0.06925775f, -0.06686634f, 0.16899747f, -0.01516233f, -0.24945736f, -0.04783355f, -0.24512722f, 
    -0.13162675f, 0.07429588f, -0.18051009f, 0.10446521f, 0.07593445f, 0.19318749f, 0.20839575f, 0.07698807f, 
    0.19206272f, 0.18274488f, -0.10230923f, 0.06404337f, 0.08213320f, -0.03156922f, 0.18818127f, 0.03263230f, 
    0.03693683f, 0.21395884f, -0.24916482f, -0.19497809f, -0.03751888f, 0.27200103f, 0.06281368f, 0.21099304f, 
    -0.00796546f, 0.14567906f, 0.12153396f, -0.01600593f, 0.44660547f, 0.02463071f, 0.33515793f, 0.19141531f, 
    0.08111859f, 0.08058873f, 0.23384184f, 0.13382453f, -0.05896992f, 0.05080250f, 0.09952331f, 0.12242261f, 
    -0.03356835f, -0.08028322f, 0.11426537f, 0.14107327f, -0.00356878f, -0.22099787f, 0.17841791f, 0.07854381f, 
    -0.04421940f, 0.06644852f, 0.06343908f, -0.00583795f, 0.01859941f, -0.16643485f, -0.21173173f, 0.33175573f, 
    -0.10901990f, 0.01709266f, 0.26972544f, 0.03070211f, 0.07108054f, -0.01804337f, -0.10753661f, 0.06479681f, 
    0.04093082f, 0.21116327f, 0.06005125f, -0.05865343f, 0.04959940f, 0.12078456f, -0.01371227f, 0.25758836f, 
    0.07766905f, -0.02401575f, 0.15651509f, -0.04965621f, -0.06367210f, 0.29999322f, 0.28134745f, 0.07713891f, 
    0.15477510f, -0.21421538f, 0.00686691f, -0.03181325f, 0.00476117f, 0.04257479f, -0.04434863f, 0.01669340f, 
    0.06952951f, -0.28840372f, -0.29977307f, -0.23561212f, 0.03646116f, -0.01802163f, 0.10458807f, -0.06363242f, 
    -0.09502120f, -0.14332989f, -0.05921884f, 0.21805561f, -0.01052609f, 0.01972206f, -0.14822082f, -0.09466004f, 
    -0.07739288f, -0.20737515f, -0.29140833f, -0.05710692f, -0.13592708f, -0.24251108f, 0.06905363f, 0.07583527f, 
    0.05426349f, 0.02699901f, 0.02762687f, 0.13803664f, -0.47156167f, 0.09798826f, -0.32348511f, 0.01715991f, 
    -0.12277578f, 0.15994507f, 0.04319753f, 0.07432674f, -0.10980756f, -0.09233007f, -0.01399728f, -0.18024187f, 
    0.04172920f, -0.05538970f, -0.07484917f, -0.18635076f, -0.07212832f, 0.03259405f, -0.31752548f, -0.19732291f, 
    0.01987102f, -0.10460483f, 0.00830213f, 0.04529003f, -0.01503129f, -0.00178008f, -0.01813089f, -0.07031420f, 
    -0.33487108f, -0.22938114f, 0.14395157f, -0.11645410f, 0.06884187f, -0.07239200f, -0.02799925f, 0.03360479f, 
    -0.07391684f, -0.23538962f, -0.00845595f, -0.24406035f, -0.06332861f, -0.10181809f, -0.12590794f, -0.44113889f, 
    -0.39053631f, -0.31556633f, -0.07614090f, -0.30908504f, 0.09665362f, -0.09401352f, 0.06036230f, 0.03495373f, 
    0.00866824f, 0.04625171f, -0.20090984f, 0.03510438f, -0.04246702f, 0.08805441f, 0.10553887f, -0.16132611f, 
    0.04371336f, 0.03075928f, 0.12658575f, -0.15487364f, -0.30186880f, -0.05824429f, 0.07118858f, 0.03485411f, 
    -0.03195496f, -0.13248423f, 0.06420777f, -0.20156293f, -0.13409692f, 0.46470183f, 0.07568320f, 0.20774777f, 
    -0.13530175f, 0.02588098f, 0.11032376f, -0.00781333f, -0.06035823f, 0.08811366f, -0.09051783f, 0.36702725f, 
    -0.04312040f, -0.23583384f, -0.09639192f, -0.03278686f, -0.21526067f, 0.00519120f, -0.23903911f, 0.18244535f, 
    0.10045243f, -0.01181597f, -0.06106915f, 0.14612412f, -0.07064104f, -0.12472744f, 0.06011938f, -0.20405962f, 
    -0.24787724f, -0.03433083f, 0.08250725f, 0.03808460f, 0.07092368f, -0.21129903f, 0.12627181f, 0.14581181f, 
    -0.09618483f, 0.01014933f, 0.39598235f, -0.29237741f, -0.15390602f, -0.18834578f, 0.13634965f, -0.09295923f, 
    -0.15568721f, 0.20034711f, 0.28070804f, 0.13976832f, -0.01144921f, -0.10858213f, 0.25032219f, 0.12299626f, 
    0.10210258f, -0.04234571f, 0.23513322f, -0.12137103f, -0.15129462f, 0.09538827f, -0.00218374f, 0.03725532f, 
    -0.07696725f, -0.09885682f, -0.10717049f, -0.01676595f, 0.18381219f, 0.34152576f, 0.15562119f, 0.06308673f, 
    0.07017900f, -0.11183430f, 0.05921745f, -0.02166443f, 0.09243778f, 0.06730173f, 0.17560181f, 0.04199972f, 
    0.05874315f, -0.03307868f, 0.09459445f, -0.16142890f, -0.27978864f, 0.13578826f, 0.11481818f, 0.41750863f, 
    0.32348749f, 0.04842337f, 0.05071141f, -0.07444359f, 0.00429237f, -0.04944657f, 0.00284470f, -0.17237160f, 
    0.07372896f, 0.06823908f, -0.15383847f, -0.06530718f, 0.04797376f, -0.19292666f, -0.27186352f, -0.01465700f, 
    0.11564221f, -0.10177918f, -0.05293140f, 0.02312103f, -0.01093934f, 0.13525711f, 0.08555996f, 0.03360049f, 
    0.31731284f, 0.27115208f, -0.04867797f, 0.06397172f, -0.19340937f, 0.12076677f, -0.00179230f, -0.17910667f, 
    -0.14339027f, 0.16444457f, 0.20821951f, 0.21200642f, 0.31418464f, 0.01148811f, -0.03043703f, -0.09044980f, 
    -0.10539679f, -0.03961300f, -0.47969064f, 0.00511923f, -0.18763077f, -0.02366628f, -0.12236756f, 0.21173476f, 
    -0.08126248f, -0.05790318f, 0.30400872f, 0.01875928f, 0.00519816f, -0.03716023f, 0.08011208f, 0.06125778f, 
    0.09821946f, -0.07950010f, -0.20682016f, 0.00062151f, 0.04205617f, -0.04971836f, 0.14686334f, 0.06742588f, 
    -0.06091915f, -0.14467686f, 0.02283656f, 0.08186861f, 0.01746821f, 0.26760456f, 0.24052526f, -0.24824102f, 
    0.05539307f, -0.06063911f, -0.06427065f, 0.10652614f, 0.02688367f, 0.22037582f, 0.02756663f, 0.02275723f, 
    -0.04112199f, 0.01941022f, -0.05070284f, -0.25382102f, -0.03559263f, -0.09324917f, -0.24408519f, 0.25717482f, 
    0.09256853f, -0.06388170f, 0.13474707f, 0.04893486f, -0.02703853f, -0.22385316f, -0.21780668f, -0.29450029f, 
    -0.17352343f, -0.04538535f, 0.28657004f, 0.05169421f, -0.14315821f, -0.10140207f, 0.01541650f, 0.11006724f, 
    0.00006936f, 0.50085324f, -0.15369980f, -0.04032665f, 0.10299618f, 0.07117987f, 0.09386514f, 0.12653506f, 
    0.16391841f, 0.05201931f, -0.16683003f, -0.21526968f, -0.00053894f, 0.00465968f, 0.01237745f, -0.15990564f, 
    -0.14587009f, -0.04020865f, -0.02080414f, -0.06963886f, 0.06097613f, -0.04598067f, 0.09043725f, -0.01585417f, 
    0.02342533f, 0.05853562f, 0.01269388f, -0.05740635f, 0.28799459f, 0.20819464f, -0.12736383f, 0.16008416f, 
    0.19144939f, -0.06273933f, -0.02758813f, 0.09110395f, -0.07423390f, -0.05717764f, -0.19363071f, 0.02933121f, 
    -0.02647661f, -0.01010073f, 0.08754319f, 0.08624972f, 0.02194313f, 0.24474128f, -0.00188072f, -0.16451396f, 
    -0.50214165f, 0.14857794f, -0.01507556f, -0.05488834f, 0.17111620f, 0.03780914f, 0.18613918f, -0.03555239f, 
    -0.22269943f, -0.13691030f, 0.26280707f, -0.08619937f, 0.26902652f, -0.00608830f, 0.01210713f, -0.07031860f, 
    0.01200778f, 0.11544903f, -0.06579020f, -0.21956462f, -0.06094601f, 0.07791016f, -0.01172534f, -0.00590599f, 
    -0.01369606f, 0.54822254f, 0.24814215f, 0.24869168f, 0.16687623f, -0.05888545f, 0.12988749f, 0.11007155f, 
    -0.10628962f, -0.10120943f, 0.00201614f, 0.10325946f, -0.27471453f, 0.02384274f, 0.13209972f, 0.20339555f, 
    0.03723342f, 0.16385125f, -0.13435967f, -0.44241181f, 0.05177755f, -0.40119430f, 0.05942081f, 0.04389318f, 
    0.05097514f, 0.00714919f, -0.11160111f, 0.34996265f, 0.13488142f, -0.11182234f, -0.60850054f, 0.18420386f, 
    -0.27432901f, -0.26245004f, -0.01837609f, -0.15195018f, 0.04479121f, -0.19766657f, -0.21002702f, 0.01717909f, 
    0.13364790f, -0.07514217f, 0.17870532f, 0.00680361f, 0.10748617f, 0.01020677f, 0.00656023f, -0.10816421f, 
    0.29414704f, 0.19291890f, -0.20869331f, -0.12651005f, -0.03092035f, -0.00623827f, -0.13498452f, 0.24794865f, 
    0.17968923f, -0.01966276f, 0.10570658f, 0.00319158f, -0.07961120f, -0.22611731f, -0.39831355f, 0.37555879f, 
    0.02445949f, -0.02166641f, -0.04983760f, -0.01718149f, -0.01848147f, 0.03568725f, 0.04923199f, -0.03639844f, 
    -0.05098731f, 0.02014044f, -0.05537202f, -0.05907312f, -0.04629325f, 0.00775299f, 0.01293272f, -0.01477245f, 
    -0.05282008f, -0.00011061f, -0.00964076f, 0.01756407f, 0.02618583f, -0.06269211f, -0.04185143f, 0.01383838f, 
    -0.06337424f, -0.03128327f, 0.00445697f, 0.00575926f, -0.02289676f, -0.05519657f, 0.03118889f, 0.04347448f, 
    -0.03606287f, 0.05054099f, -0.00649625f, -0.04560984f, 0.02940634f, -0.05462086f, -0.03879859f, -0.05983444f, 
    -0.05569175f, -0.02060434f, 0.00543365f, -0.00774590f, -0.03061135f, -0.03639940f, -0.00814293f, -0.03283801f, 
    -0.03322673f, -0.02030198f, -0.03404224f, 0.00002149f, 0.02902825f, -0.02338487f, 0.01506177f, -0.02384837f, 
    -0.05978857f, -0.00962463f, -0.02993889f, 0.05290528f, -0.03752901f, -0.02787806f, -0.02917069f, -0.02971899f, 
    0.01622542f, -0.01650852f, -0.04526170f, -0.04022280f, -0.04467614f, -0.00309144f, -0.00806504f, -0.04719196f, 
    -0.02260925f, -0.04201820f, -0.04473286f, -0.01152367f, 0.03167232f, -0.04766977f, -0.06345192f, 0.01807914f, 
    0.03578024f, 0.03800422f, 0.00743789f, 0.01134420f, 0.04890438f, 0.00125678f, 0.01666547f, -0.05504147f, 
    0.01976033f, -0.02390132f, 0.04874365f, -0.01535496f, 0.01540224f, 0.04414360f, 0.04558501f, -0.00821167f, 
    -0.02701694f, -0.00601679f, 0.01635768f, -0.02236066f, -0.03701063f, -0.03983683f, 0.03704106f, 0.02365546f, 
    -0.05500748f, 0.00057199f, -0.02672820f, -0.04660252f, 0.00146380f, -0.05841269f, 0.02200564f, -0.05860612f, 
    0.05296461f, 0.05358463f, 0.01210445f, -0.00486745f, -0.03889747f, 0.03841728f, -0.05210591f, -0.03520693f, 
    -0.00995291f, -0.04520868f, -0.03390591f, 0.00082313f, -0.05168944f, -0.03733065f, -0.03250175f, 0.04488285f, 
    -0.05504610f, -0.03121587f, 0.01418109f, -0.02712618f, -0.01774817f, -0.00090466f, -0.05081920f, 0.03274090f, 
    -0.04873010f, 0.00722731f, -0.04345018f, 0.01650709f, 0.05107676f, -0.05034866f, 0.00498901f, -0.02418119f, 
    0.00627999f, 0.02623344f, -0.00686094f, -0.02163098f, -0.02840555f, 0.04833131f, 0.03165231f, -0.00437424f, 
    0.01469196f, -0.00988027f, 0.04629210f, 0.00046553f, -0.02256829f, -0.04059463f, 0.00414797f, -0.00640091f, 
    -0.05910119f, -0.02793485f, -0.04871104f, -0.03370600f, -0.05903611f, -0.00606648f, 0.04828009f, 0.01452911f, 
    -0.04793173f, -0.04641049f, 0.01546131f, -0.02609135f, 0.01893984f, 0.01741869f, 0.00746255f, -0.04909085f, 
    0.01146533f, 0.04753238f, -0.00934790f, 0.00612460f, -0.04289456f, 0.04409593f, -0.05438708f, 0.00158795f, 
    0.01038565f, -0.02036521f, 0.03023957f, 0.02557972f, 0.02865306f, 0.03726009f, 0.03046235f, -0.01176192f, 
    -0.03982662f, 0.00549003f, -0.03041880f, -0.04285838f, 0.03296311f, -0.02894031f, -0.03125897f, 0.04807546f, 
    -0.02982339f, 0.03362033f, -0.06341996f, -0.06217203f, 0.00526109f, 0.00188874f, -0.03280773f, -0.02791095f, 
    -0.05511223f, -0.04740689f, 0.00866172f, -0.06053329f, -0.00369394f, -0.02815060f, -0.03019326f, 0.02546747f, 
    0.00202926f, 0.00913506f, -0.01919345f, -0.04459698f, -0.04623662f, 0.05047029f, -0.02994808f, -0.05434984f, 
    0.04477111f, -0.01112481f, -0.00333593f, 0.02721147f, 0.00567943f, 0.00350741f, -0.00010638f, 0.00660709f, 
    0.02172225f, -0.01473595f, 0.03987313f, -0.04951428f, 0.02861432f, -0.04105521f, -0.05313355f, 0.03194092f, 
    0.00406113f, -0.03124594f, -0.04512316f, 0.00478283f, -0.00041750f, -0.02446973f, -0.04197225f, 0.04905123f, 
    -0.05844656f, 0.05889766f, -0.01093236f, -0.06086332f, 0.03558398f, -0.03932388f, 0.01877731f, 0.04382523f, 
    -0.05633417f, -0.02659962f, 0.01355356f, 0.05345397f, -0.04008622f, -0.03179110f, -0.00356499f, 0.04915397f, 
    0.01578463f, 0.02977751f, 0.04489699f, -0.04092018f, -0.01635331f, -0.02150557f, 0.00221717f, -0.02932619f, 
    0.00129191f, -0.06271434f, 0.04396405f, -0.01514402f, -0.00012507f, 0.04025132f, -0.05808744f, 0.01201319f, 
    -0.01079235f, -0.00483641f, 0.01776123f, -0.02369604f, -0.03238052f, 0.02361094f, -0.03599101f, -0.01822922f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.00295181f, 0.00092090f, 0.02939084f, 0.12836884f, 0.30535385f, 0.18418139f, -0.06507247f, -0.02933148f, 
    0.20246750f, 0.07757738f, 0.25168788f, -0.00704165f, 0.30080464f, 0.17921807f, -0.17181297f, -0.11326760f, 
    0.40983742f, -0.05330564f, 0.04782447f, 0.18364725f, -0.07682938f, 0.03021377f, 0.01036875f, 0.20715615f, 
    -0.01089675f, 0.13338354f, 0.30440092f, -0.01027812f, 0.09011989f, 0.17852414f, -0.08505820f, -0.04288168f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00760970f, 0.26443034f, 0.01620877f, -0.18988414f, 0.00879527f, -0.22096436f, -0.10754414f, 0.08901615f, 
    0.03103472f, -0.08222177f, -0.93864995f, 0.04599163f, -0.16190800f, -0.41667190f, 0.30856979f, 0.05074672f, 
    0.14276254f, -0.13952218f, -0.01744522f, 0.04385833f, 0.62694222f, 0.11290054f, -0.21922787f, 0.06461316f, 
    0.42769185f, -0.42349243f, -0.04489561f, -0.55739218f, -0.18111034f, 0.07539387f, 0.03221754f, -0.14024739f, 
    -0.23840851f, 0.13531275f, 0.14772065f, -0.20982032f, 0.28380811f, -0.05810304f, 0.00005246f, -0.05492172f, 
    0.26093236f, -0.08923782f, -0.15735999f, -0.10024712f, 0.18675499f, -0.10002439f, -0.48532930f, -0.11139142f, 
    -0.35072002f, -0.08588915f, 0.03920595f, -0.29619211f, 0.10076287f, -0.17758137f, -0.32007563f, 0.15986253f, 
    0.42461383f, 0.65327382f, 0.21343660f, -0.29430786f, 0.17683508f, -0.11232705f, -0.58635277f, 0.12188090f, 
    0.36807528f, -0.13643415f, 0.00204199f, 0.28811392f, 0.21154302f, 0.17504373f, -0.05111904f, -0.31634498f, 
    -0.51991701f, 0.19357282f, -0.50462997f, 0.28434375f, 0.09608711f, -0.25161776f, -0.34866291f, -0.33871961f, 
    0.40642574f, 0.09734345f, 0.06577882f, -0.21064875f, -0.62171811f, 0.04596742f, 0.13999651f, -0.16832303f, 
    0.05900565f, 0.62684500f, 0.00429174f, 0.00971800f, -0.44979259f, -0.09197401f, -0.06375741f, 0.12917584f, 
    -0.73399568f, -0.76184446f, -0.15830612f, -0.24130772f, -0.46909535f, -0.51638067f, -0.10751004f, 0.50186902f, 
    -0.51940966f, 0.15711235f, -0.56934226f, 0.51896280f, -0.02578656f, -0.34618428f, 0.32674766f, 0.02270553f, 
    -0.23761034f, -0.13159904f, 0.11236045f, 0.54930872f, -0.16433202f, 0.15799601f, -0.33218017f, 0.51425546f, 
    -0.20665510f, 0.46945068f, 0.07496814f, 0.52904302f, -0.21001422f, -0.21087776f, 0.40987372f, 0.09250753f, 
    -0.04345514f, -0.05858397f, -0.08045879f, 0.10763724f, -0.01594207f, -0.41137937f, 0.02218757f, -0.04693676f, 
    -0.09794972f, 0.01912235f, 0.31320450f, -0.11610425f, -0.10183144f, 0.35154566f, -0.11250616f, 0.43047711f, 
    0.00070255f, 0.04298810f, 0.12603669f, -0.55668956f, 0.06988627f, 0.03908891f, 0.64502609f, 0.26121789f, 
    0.15047382f, -0.06030668f, -0.17636043f, -0.56551623f, 0.04268346f, -0.39016929f, 0.29143673f, 0.00706579f, 
    -0.10417978f, 0.24998569f, -0.17154284f, -0.14507423f, -0.37907317f, -0.23006845f, 0.12904543f, 0.01455372f, 
    0.06731471f, -0.06203266f, 0.80802375f, -0.21999627f, 0.28970852f, 0.02051225f, -0.17528529f, 0.14420809f, 
    -0.08460670f, 0.15896611f, -0.02217725f, -0.42438075f, -0.03256392f, -0.01635014f, -0.45040902f, -0.32846192f, 
    -0.06776527f, -0.03327331f, 0.07048848f, -0.02591483f, 0.21538487f, 0.39310452f, 0.47123042f, -0.12299287f, 
    0.39541665f, -0.20216911f, -0.04505489f, 0.21391793f, -0.40643385f, 0.52804744f, 0.15723281f, -0.51338351f, 
    0.42611772f, 0.08075549f, -0.24835308f, 0.21731947f, -0.29233518f, 0.03776285f, 0.24211982f, -0.25996801f, 
    0.40892732f, 0.13905884f, -0.17944399f, -0.25132689f, -0.78535289f, -0.01516504f, 0.15151191f, 0.35867429f, 
    -0.82935238f, -0.07355344f, -0.20720434f, 0.30631456f, -0.35075113f, -0.46498337f, 0.01335149f, -0.05709596f, 
    0.27027190f, 0.36003253f, -0.10034274f, 0.26133981f, 0.17130607f, -0.27906835f, -0.14248116f, 0.11724798f, 
    -0.09677822f, 0.06720833f, -0.14034240f, -0.15435007f, -0.33247602f, -0.14288706f, 0.05373301f, -0.10364228f, 
    -0.47337949f, 0.13164137f, 0.03737804f, 0.68781829f, -0.35812968f, 0.06371369f, -0.09968495f, 0.05709369f, 
    0.02307776f, -0.24475902f, -0.23924282f, 0.49897966f, 0.23804286f, -0.29485551f, 0.20527779f, -0.14592688f, 
    -0.31225896f, -0.02249191f, -0.02730478f, -0.30473968f, 0.17804132f, 0.27384713f, 0.05674113f, -0.43843314f, 
    -0.02089625f, -0.34477583f, -0.61524260f, 0.21251006f, -0.09291268f, 0.29313755f, -0.54387730f, 0.17634316f, 
    -0.08986063f, -0.08661382f, -0.14519656f, 1.04210484f, -0.63228840f, -0.14027233f, -0.07210252f, -0.42991188f, 
    -0.07695551f, -0.11810233f, 0.29721498f, 0.01519529f, -0.17685241f, 0.37115785f, -0.35347506f, 0.15386665f, 
    -0.06809918f, -0.14915742f, 0.11401657f, 0.23695685f, 0.11605175f, -0.64314067f, -0.13487193f, 0.05374063f, 
    0.19135860f, 0.45374712f, 0.20747395f, -0.38167650f, 0.02923043f, 0.25395170f, 0.32842728f, -0.76055646f, 
    0.65227187f, 0.12048223f, 0.12838763f, 0.02928091f, -0.89056051f, -0.12111591f, -0.01022084f, 0.21767472f, 
    0.32986876f, -0.04434868f, -0.19645321f, -0.39070097f, -0.45716393f, 0.43238398f, 0.00548124f, -0.08377573f, 
    -0.34339187f, 0.02987943f, -0.11484390f, -0.04433481f, -0.56573498f, 0.38346198f, -0.00804961f, 0.57699233f, 
    -0.46110037f, -0.58254170f, -0.50867862f, -0.37887216f, 0.14000328f, 0.15309742f, -0.26819798f, -0.36545724f, 
    -0.10721365f, 0.03598643f, 0.14648527f, -0.76165879f, 0.16817294f, 0.05300269f, 0.75826645f, -0.19213590f, 
    -0.30319351f, -0.36904779f, 0.31704274f, 0.43322417f, -0.07684976f, 0.28173065f, 0.00030154f, 0.09189941f, 
    -0.34579295f, -0.89210337f, 0.04163079f, 0.27266362f, 0.12021306f, 0.13152711f, 0.07414712f, -0.06607419f, 
    0.58803630f, -0.05023038f, 0.70863789f, 0.15160011f, 0.16600452f, 0.42914981f, 0.40263408f, -0.15257832f, 
    -0.13642967f, -0.16989824f, 0.16101368f, -0.45847946f, -0.69571000f, -0.15299778f, 0.15476453f, -0.59239709f, 
    -0.30471739f, -0.36259380f, -0.07505480f, 0.15593226f, 0.48312879f, -0.27784881f, -0.32456419f, 0.10981131f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17672756f, 0.38185120f, 0.29561895f, 0.12040544f, 0.04248389f, -0.19054317f, -0.23921391f, -0.25676703f, 
    0.13042663f, 0.02368981f, 0.19737443f, -0.08423633f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
