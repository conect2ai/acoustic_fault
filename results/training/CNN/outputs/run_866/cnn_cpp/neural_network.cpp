#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.87842268f, -1.00757551f, -0.89112353f, -0.40276909f, -0.77962112f, -0.74754184f, -0.44329324f, -0.11392910f, 
    -0.23226938f, 1.05286741f, -0.80107123f, 0.44219452f, -1.36474586f, 0.48073348f, -0.38818872f, -0.16820517f, 
    -0.23768869f, 0.14696777f, 0.66396129f, 0.24619108f, 0.74480325f, 0.25972301f, -1.03407466f, -0.39841264f, 
    0.54279894f, 0.58596110f, 0.48923543f, 0.78120977f, 1.10746181f, 1.14392018f, -0.49841052f, -0.62599134f, 
    -0.03787436f, -0.83353114f, -0.01709108f, 0.38013092f, -0.35795566f, -1.14129627f, -0.18229498f, 0.87923378f, 
    -0.33505112f, 0.78549510f, -0.00918151f, -0.38979948f, -0.13050056f, 0.87615740f, 1.01434910f, 0.94305778f, 
    0.75875467f, 0.64653122f, 0.55004799f, 0.02396636f, 0.81041521f, 0.19339684f, 0.29625246f, 0.89154893f, 
    -0.15129565f, -1.15604377f, -1.31900322f, -0.77327758f, 0.23775366f, -0.02798687f, -0.16083919f, -0.83230394f, 
    -1.04594004f, -1.00033998f, -0.71856040f, 0.42895955f, 0.95809752f, -0.45533136f, -0.11074377f, -0.00666268f, 
    1.41134429f, 0.53385252f, -1.08283341f, 0.06567090f, 0.69862109f, -0.20454100f, 0.70591509f, 0.25519490f, 
    -0.01451720f, -1.06140113f, -0.91157347f, -0.79560715f, 0.44111025f, 1.09237337f, 0.29918459f, 0.32764864f, 
    -0.47440466f, 0.10112750f, -1.35969627f, 0.87709010f, -0.44660684f, 0.22551022f, 0.23884669f, -0.41440389f, 
    0.37106133f, 0.62512034f, -0.26258302f, -0.74094725f, -1.45462871f, -0.90597218f, -0.21056893f, -0.61071372f, 
    0.20460010f, 0.30445400f, -0.03514677f, -0.47164741f, 1.14572334f, 0.31773061f, 1.18580484f, 0.65339929f, 
    -0.86677361f, 0.25614777f, -0.00332412f, 0.03482548f, -0.78541327f, -0.34913909f, -0.06182301f, -0.64748514f, 
    0.95843917f, 1.19318902f, 0.97834635f, -0.24333316f, 0.47411555f, 0.90876657f, -0.51027155f, -0.70955706f, 
    0.23228979f, -0.75138456f, 0.93578941f, -1.25663543f, 0.54044819f, 0.40770262f, -0.18088105f, 0.74528927f, 
    1.37969887f, -0.46821329f, -0.30774507f, -0.20091306f, -0.24261442f, -0.16402929f, -0.31226212f, -0.07555576f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07683364f, 0.04005677f, 0.36175510f, 0.21893963f, 0.31447145f, 0.60615456f, 0.67095721f, -0.29526493f, 
    -0.50163418f, 0.34578311f, 0.03096940f, -0.06691923f, 0.28998220f, 0.30628276f, 0.33389187f, -0.17502059f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03648365f, 0.18656774f, 0.59194165f, 0.34518144f, -0.01129692f, -0.24379613f, 0.00126749f, -0.16199163f, 
    0.11314927f, 0.44012287f, -0.44830155f, -0.24068889f, -0.56650257f, -0.05530212f, 0.20146422f, -0.02149584f, 
    0.04029750f, 0.08916414f, -0.10343045f, 0.50093871f, -0.41626617f, 0.00601463f, -0.06834857f, -0.27715790f, 
    -0.51014417f, -0.08730025f, -0.36069450f, -0.18985464f, -0.04250789f, -0.20406067f, 0.01782502f, 0.13186318f, 
    0.04922267f, 0.06344751f, 0.17869386f, 0.12526836f, 0.28353432f, -0.04287187f, 0.13970663f, 0.33183047f, 
    0.05247451f, 0.13252053f, -0.07425498f, -0.09125163f, 0.07379661f, 0.04777639f, 0.46714240f, 0.13196248f, 
    0.10501009f, -0.04039624f, 0.03049525f, 0.06458692f, 0.07087914f, -0.17544937f, -0.26978144f, 0.01652942f, 
    -0.57811487f, -0.27965155f, -0.21127294f, -0.14549515f, -0.10802022f, 0.03853307f, 0.02737021f, 0.49719495f, 
    -0.30067226f, 0.53738874f, 0.17098460f, 0.01667969f, 0.12565561f, -0.02525373f, 0.05698812f, 0.10077997f, 
    -0.10409313f, 0.37790972f, -0.01442074f, -0.20682548f, -0.26224163f, -0.15170684f, -0.14855441f, -0.23366499f, 
    0.20968735f, -0.18428527f, -0.05144577f, 0.37161195f, 0.19810519f, 0.13874844f, -0.03023575f, -0.10202447f, 
    0.02943568f, 0.36801571f, -0.34074157f, -0.01839218f, -0.08679882f, 0.11287690f, -0.48237479f, 0.22258151f, 
    0.21445844f, 0.09566604f, 0.02676106f, 0.25187188f, -0.14469072f, 0.51215321f, 0.18024679f, 0.18129861f, 
    -0.06759946f, -0.05869774f, -0.08431435f, 0.04245823f, 0.32946011f, 0.17645964f, 0.03486837f, -0.05032034f, 
    -0.09999775f, 0.00183668f, 0.06218688f, -0.07438026f, -0.16348316f, 0.14188808f, -0.49549311f, 0.07258081f, 
    0.01556543f, 0.10515022f, 0.08852583f, 0.16416880f, 0.04749675f, 0.05827809f, -0.19255880f, -0.02042897f, 
    0.30388674f, 0.14774325f, -0.12269742f, 0.05083799f, -0.09911406f, -0.15507799f, -0.21360347f, -0.51136714f, 
    0.24850172f, 0.16374102f, 0.20185792f, -0.02865518f, -0.19884279f, 0.00009147f, 0.06820849f, -0.10464559f, 
    0.01624847f, -0.02523650f, -0.07935923f, 0.01691279f, -0.08889129f, -0.00661139f, -0.09119976f, -0.02351923f, 
    -0.06132193f, -0.00823620f, -0.09780096f, 0.02533260f, 0.03092447f, 0.05453343f, -0.05959686f, -0.06911369f, 
    -0.08994643f, -0.06440523f, 0.06348162f, -0.06384059f, -0.07585041f, 0.00464198f, -0.02504298f, 0.03438608f, 
    -0.06087853f, -0.02398248f, -0.04420668f, 0.02699186f, 0.04142123f, -0.00378673f, -0.09438293f, -0.06144438f, 
    -0.02933360f, -0.02348818f, -0.03315401f, 0.00977393f, -0.06972115f, -0.04845264f, -0.01978479f, -0.06546873f, 
    0.07096107f, -0.00442566f, 0.04381720f, 0.02548835f, -0.02030601f, -0.06320830f, -0.08010793f, -0.07537971f, 
    -0.03510956f, -0.03085819f, -0.01400812f, 0.00585501f, -0.01804991f, -0.01161869f, 0.00114375f, -0.06204934f, 
    -0.01652663f, -0.02493916f, -0.06809248f, -0.04513514f, 0.00162642f, -0.05640491f, -0.02263963f, -0.07294540f, 
    -0.06544323f, 0.00907165f, -0.06513699f, 0.02798515f, -0.00054492f, 0.05894155f, -0.01643851f, 0.04999303f, 
    -0.00350177f, -0.05072679f, -0.05615740f, 0.06351724f, 0.00577389f, 0.03680173f, -0.03180883f, -0.00367685f, 
    0.05612784f, 0.06401462f, 0.00819926f, 0.06713419f, -0.09163737f, 0.03114825f, -0.04672550f, -0.07789669f, 
    -0.00911807f, -0.00314150f, -0.07580602f, -0.06301302f, -0.00396328f, 0.01063426f, 0.01318007f, 0.01478726f, 
    -0.01641569f, -0.06343638f, -0.03229262f, -0.00248014f, -0.09377897f, -0.06388070f, 0.00704954f, -0.05491842f, 
    -0.04648626f, 0.00365598f, 0.01198103f, 0.03918138f, -0.06935058f, -0.07779226f, 0.04475762f, -0.02008115f, 
    0.06548696f, 0.01223897f, -0.02040156f, 0.02184335f, 0.03720700f, 0.04337497f, -0.07916265f, 0.05190795f, 
    0.00635703f, -0.02123424f, -0.04284525f, 0.01128401f, 0.06745283f, 0.05797133f, 0.03911776f, 0.03897280f, 
    -0.06238360f, -0.08568643f, 0.00289454f, -0.03384990f, 0.02659445f, 0.03623930f, -0.02521648f, 0.01491820f, 
    0.05676165f, -0.03415671f, 0.05290670f, -0.05647600f, 0.01323721f, -0.07570031f, 0.05239656f, 0.06753125f, 
    0.34534386f, -0.23301145f, 0.43833682f, -0.11732296f, -0.13483137f, 0.21393959f, 0.04595750f, -0.23994273f, 
    0.46799773f, 0.29872468f, -0.01727011f, -0.11126863f, 0.06105190f, -0.05116651f, 0.22415750f, 0.18368430f, 
    -0.12935261f, 0.03326951f, -0.42489412f, -0.27758610f, 0.06535036f, -0.05017122f, 0.07837059f, -0.00302305f, 
    -0.04691256f, 0.06729092f, -0.15225111f, 0.22599274f, 0.13130878f, 0.15635236f, 0.00795960f, -0.17590787f, 
    -0.03618418f, -0.07082265f, -0.04205109f, -0.16968867f, 0.18197650f, 0.10445981f, -0.09355223f, 0.23781174f, 
    0.00578153f, 0.22366492f, -0.18107370f, 0.09504209f, 0.16452853f, -0.58225399f, 0.07301695f, -0.19587822f, 
    0.24596013f, -0.00848571f, 0.48061329f, 0.24966049f, -0.10616781f, -0.17674555f, 0.30178836f, -0.01016335f, 
    0.20751281f, -0.11150824f, 0.17222840f, -0.25855443f, -0.00289142f, 0.05913882f, -0.22185452f, 0.15279913f, 
    -0.30493748f, 0.25452325f, -0.42081308f, 0.09628858f, -0.09331234f, 0.25086635f, -0.15106009f, 0.11433303f, 
    -0.41893449f, -0.45687884f, 0.40259784f, -0.13958135f, 0.17148942f, -0.28682452f, 0.09694174f, -0.11539028f, 
    -0.03773081f, 0.14765023f, -0.01180611f, 0.08886109f, 0.11792395f, 0.07730138f, 0.01470906f, 0.11865512f, 
    0.26223478f, 0.04447984f, 0.18618469f, 0.49433702f, 0.23682241f, -0.03039274f, -0.26015729f, 0.09608225f, 
    -0.11034819f, 0.32425305f, -0.00227138f, 0.26354441f, -0.44283855f, 0.08022337f, -0.20180736f, -0.00600520f, 
    -0.04690304f, 0.24932452f, 0.14984015f, 0.16695008f, -0.79057974f, -0.22843193f, -0.44591111f, 0.25251940f, 
    0.19856183f, 0.18495236f, 0.06569585f, -0.10465433f, 0.11691540f, -0.04349883f, -0.08107450f, -0.06140535f, 
    0.47891355f, 0.33726913f, -0.01363692f, 0.09732775f, -0.02951851f, 0.02198300f, 0.23881437f, 0.01144473f, 
    0.20303108f, 0.03910526f, -0.57455397f, 0.05753681f, 0.08887734f, -0.12954463f, -0.32366663f, 0.58568472f, 
    0.05449721f, 0.19574793f, -0.09113561f, -0.10782741f, -0.19532697f, -0.21185534f, 0.15779339f, 0.02364477f, 
    0.05112945f, -0.02831367f, -0.03247702f, 0.07996719f, 0.01334075f, -0.03502260f, -0.07756989f, 0.04251656f, 
    0.04042105f, -0.10216162f, -0.04435074f, 0.04321668f, 0.06373572f, 0.02568702f, -0.09607285f, -0.08029366f, 
    -0.00844130f, -0.04017652f, -0.01014628f, 0.04239428f, -0.01831359f, 0.02669945f, 0.01967888f, 0.00977270f, 
    0.03661569f, -0.00531110f, 0.01970849f, 0.06787774f, -0.10379447f, -0.06184388f, 0.01570797f, -0.00756584f, 
    -0.06019200f, -0.07365108f, -0.02583610f, 0.03804697f, -0.00641974f, 0.02800939f, -0.05107098f, -0.05297356f, 
    0.01900224f, -0.04136220f, -0.01038830f, 0.05052495f, -0.11893985f, 0.06653978f, 0.00363363f, -0.02876532f, 
    0.02471896f, 0.03531226f, 0.05875403f, 0.00257011f, -0.05881459f, 0.05911129f, -0.08208204f, -0.07962544f, 
    -0.09272590f, -0.02105826f, -0.08784985f, -0.06738628f, -0.04940943f, 0.00628097f, -0.05395172f, 0.05792740f, 
    0.02796639f, -0.03546547f, -0.07349066f, -0.06962832f, 0.03563762f, -0.09001294f, -0.03165292f, -0.02958765f, 
    -0.08697476f, -0.05600716f, -0.05570713f, -0.11615698f, 0.04955073f, -0.05492339f, -0.07176466f, -0.04390722f, 
    -0.05020563f, -0.03194961f, -0.07067937f, -0.03535346f, -0.04697527f, -0.00524948f, 0.04444186f, 0.01441911f, 
    0.05195690f, -0.00270852f, 0.06041819f, 0.03783196f, -0.03053976f, -0.02204370f, 0.00397019f, -0.02622176f, 
    -0.03855464f, -0.00585211f, -0.00339466f, -0.01376407f, 0.01857155f, -0.08651809f, -0.07656340f, 0.03741084f, 
    -0.08500938f, -0.01997366f, 0.04436746f, -0.03892080f, -0.03319736f, -0.01007923f, -0.02984398f, -0.05365060f, 
    0.03089115f, -0.02124512f, -0.06118241f, -0.09703342f, 0.02190688f, -0.06919987f, 0.00246592f, -0.01538356f, 
    -0.02498094f, -0.02159587f, -0.00078901f, 0.00261607f, 0.04848592f, 0.05322907f, -0.05913387f, 0.04000729f, 
    0.01395759f, 0.04231527f, -0.05682206f, -0.07440207f, 0.00224368f, -0.07255588f, -0.06731389f, -0.05751952f, 
    -0.01173419f, -0.09902594f, -0.05519535f, -0.01737246f, -0.00902139f, 0.01625590f, -0.00868790f, -0.08820263f, 
    0.06534735f, -0.03471307f, 0.00436588f, -0.08798114f, -0.02583564f, 0.06429701f, -0.09497993f, -0.02075958f, 
    0.00482510f, 0.04047805f, -0.00436894f, -0.03433767f, -0.02907252f, 0.01036601f, 0.04485310f, -0.02056204f, 
    0.02785725f, 0.04197470f, -0.04110812f, -0.06030056f, -0.04974281f, -0.01062895f, -0.00294850f, -0.03770771f, 
    0.01431234f, -0.06286115f, 0.02568782f, -0.01810075f, -0.04893872f, 0.00618405f, -0.04147328f, -0.06018675f, 
    -0.02555613f, -0.08651177f, 0.02475620f, 0.01067218f, -0.05539098f, -0.04980776f, 0.04410021f, 0.02825038f, 
    0.04330042f, 0.04323616f, 0.02480633f, -0.06868508f, 0.04047755f, -0.01349487f, -0.07113101f, 0.04420431f, 
    -0.00384965f, -0.09329566f, -0.05077660f, -0.08188498f, -0.01638929f, -0.04648743f, -0.09273586f, 0.03432000f, 
    0.00458069f, 0.05046050f, 0.06679952f, 0.03582004f, -0.08046839f, 0.04364580f, 0.01401058f, 0.04487154f, 
    -0.07479082f, 0.01970010f, -0.06327602f, -0.07837461f, -0.03100420f, 0.04171320f, -0.07628981f, -0.00840698f, 
    0.01969877f, -0.02023984f, -0.03739912f, 0.00949205f, -0.02454207f, -0.08151812f, -0.05768429f, -0.06278218f, 
    -0.06439757f, -0.06732267f, -0.02113168f, 0.04256692f, 0.06666299f, 0.04585095f, 0.00213934f, -0.05451877f, 
    -0.03291519f, 0.07343046f, -0.05258204f, -0.06935541f, -0.04969293f, 0.01400527f, -0.05197712f, 0.00135074f, 
    0.03148271f, -0.07308188f, -0.01498911f, 0.00683474f, -0.02838223f, 0.01113264f, 0.00843216f, -0.05605713f, 
    0.01356979f, -0.07163531f, 0.01774281f, 0.04097765f, 0.05526675f, 0.05725323f, -0.05371822f, -0.06490421f, 
    0.08952190f, 0.00172883f, 0.00384944f, -0.06401309f, 0.05251643f, 0.05029595f, -0.03161946f, 0.05085249f, 
    0.05214425f, 0.01244162f, -0.01299674f, -0.05817802f, -0.00158050f, -0.04858073f, -0.10755544f, 0.00864423f, 
    0.00247741f, -0.08170544f, -0.06645928f, -0.03934651f, 0.01011902f, -0.02322545f, 0.02458748f, 0.01170228f, 
    0.03142383f, -0.03413453f, -0.06612039f, 0.00342929f, -0.05069301f, -0.07314257f, 0.05103292f, -0.01329171f, 
    -0.69332582f, -0.14627224f, 0.31902090f, 0.23469085f, 0.11096049f, -0.31577110f, 0.13759066f, -0.03903880f, 
    -0.05649295f, 0.20083599f, -0.43483010f, -0.10328596f, -0.35600254f, 0.22863232f, -0.09119125f, 0.01125542f, 
    0.07694653f, 0.29176024f, 0.01922773f, -0.05238422f, 0.23476201f, -0.41222173f, -0.06179732f, 0.14905910f, 
    -0.12751146f, 0.09327595f, -0.19432533f, 0.20231883f, 0.53936857f, 0.44883099f, -0.02854208f, -0.05923230f, 
    -0.24936265f, 0.37582588f, 0.11550847f, -0.20794711f, 0.00645993f, -0.01444419f, -0.68245727f, 0.41182923f, 
    0.24265911f, 0.35475248f, 0.00310492f, -0.08890483f, -0.13790426f, 0.36587903f, 0.52135199f, 0.32141894f, 
    0.12163583f, 0.08884021f, 0.17363827f, 0.04333646f, 0.02562526f, -0.15815645f, -0.02914709f, 0.13543190f, 
    0.23906250f, -0.22402841f, 0.02483725f, -0.08124143f, -0.07286407f, 0.32363400f, 0.43548158f, -0.47064787f, 
    0.50920928f, -1.00389397f, -0.07392033f, 0.06921855f, 0.13175216f, -0.00782671f, -0.13754696f, 0.24510127f, 
    -0.52879566f, -1.13088167f, -0.07653086f, -0.35006958f, 0.05078458f, -0.53342152f, -0.14277846f, 0.02323643f, 
    0.09107310f, 0.50419700f, 0.19818075f, 0.00016266f, 0.20076323f, 0.26796034f, 0.09004392f, 0.06752087f, 
    -0.15316087f, -0.15009424f, 0.23554581f, -0.17182270f, -0.16648060f, -0.15428011f, 0.05505504f, 0.01663119f, 
    -0.20099346f, -0.08130884f, 0.13794766f, -0.05723894f, 0.05085209f, -0.09694526f, 0.10411163f, -0.02092717f, 
    0.12020157f, 0.18954499f, 0.10398892f, -0.01032418f, 0.21420784f, 0.27523461f, 0.57202268f, 0.22613096f, 
    -0.31437820f, -0.03252090f, 0.23408911f, 0.16518290f, 0.02828481f, 0.24767657f, 0.25881031f, -0.38230914f, 
    0.31864354f, -0.08328336f, 0.22522201f, 0.26691094f, 0.07655431f, -0.09306441f, -0.46263978f, -0.57539469f, 
    -0.11735775f, 0.29367408f, 0.09759306f, 0.10276584f, 0.03418934f, 0.13410935f, -0.12439716f, 0.02693249f, 
    0.06868796f, 0.10069979f, -0.22979382f, 0.10221946f, -0.15236457f, -0.18487352f, -0.22842939f, 0.00408408f, 
    0.49575102f, -0.61007339f, 0.28139120f, 0.36521870f, -0.12888899f, -0.06004624f, 0.04816784f, -0.13357472f, 
    0.05829807f, -0.00519514f, -0.14567187f, -0.18238197f, -0.19616832f, 0.13399298f, 0.14835541f, 0.27604723f, 
    0.17375438f, 0.03696038f, 0.36102018f, -0.12899911f, -0.10375316f, 0.10080741f, -0.01671607f, -0.04292745f, 
    0.35798982f, -0.18252429f, -0.47315699f, -0.17739199f, 0.48669514f, -0.16156092f, 0.37827337f, 0.12719302f, 
    -0.21442536f, 0.17027085f, -0.12873007f, 0.00521554f, -0.11018160f, -0.17955889f, 0.37753907f, -0.11797109f, 
    0.15132065f, -0.09887015f, -0.27525586f, 0.16224787f, 0.11016836f, 0.09691484f, -0.43046090f, -0.22574562f, 
    0.18743806f, 0.22735493f, 0.13976857f, 0.08519258f, -0.03325411f, -0.05515699f, -0.04868038f, 0.57731521f, 
    -0.52880877f, 0.23113462f, -0.04055122f, -0.19710855f, 0.21110475f, 0.26082146f, -0.00833284f, -0.28737399f, 
    -0.41137540f, 0.25875017f, -0.13432240f, 0.06587649f, 0.06258426f, -0.08949648f, -0.16300423f, 0.03919598f, 
    0.23050204f, 0.02204444f, -0.03620784f, 0.00262070f, -0.00992886f, -0.05458521f, -0.10369042f, 0.14835733f, 
    -0.11504932f, -0.36313638f, -0.09810111f, 0.65222335f, -0.29924974f, -0.21330605f, 0.32945022f, -0.10547342f, 
    0.14990212f, 0.30788162f, -0.18226264f, -0.28201115f, 0.00926503f, -0.24938582f, -0.16998470f, 0.07929201f, 
    -0.02498541f, -0.23916699f, -0.11304097f, -0.30618939f, -0.06258641f, 0.20613927f, 0.00461554f, 0.00781632f, 
    0.07528484f, -0.24181259f, 0.09815109f, -0.05712545f, 0.29884002f, 0.01103072f, -0.37136748f, 0.30107310f, 
    0.39811462f, 0.00267690f, -0.07419612f, 0.14684753f, 0.00929971f, 0.02626636f, 0.26289508f, 0.45335928f, 
    -0.06759557f, -0.05815983f, 0.18517335f, -0.17481542f, -0.00390575f, -0.21951841f, -0.14596692f, 0.17807174f, 
    -0.45759371f, 0.27411193f, -0.08638506f, 0.14964953f, -0.03663123f, 0.01575499f, 0.12073389f, 0.40943310f, 
    0.08996019f, -0.32652012f, 0.27665547f, -0.18594071f, -0.14840306f, -0.31057233f, 0.07373121f, -0.00249086f, 
    0.10052425f, 0.01117638f, 0.09300727f, 0.33356524f, -0.01311805f, 0.20321128f, -0.11573364f, -0.12981142f, 
    0.01453138f, -0.63076890f, 0.25234208f, -0.27916327f, 0.12003773f, 0.11463887f, -0.02174042f, -0.03750513f, 
    -0.02784664f, 0.08155248f, 0.08280053f, 0.21250658f, 0.25278053f, 0.14659880f, -0.28794369f, 0.08274914f, 
    -0.18402554f, 0.24937259f, 0.30613968f, 0.01976054f, 0.02713527f, 0.12345464f, 0.04972962f, 0.25540689f, 
    -0.10602380f, 0.06381436f, 0.10923690f, 0.22408634f, -0.29792100f, 0.06320887f, 0.18647987f, -0.12266999f, 
    -0.12531109f, -0.04816290f, 0.02710809f, 0.14162746f, -0.23100238f, 0.22266658f, 0.28142035f, 0.23780538f, 
    0.26463136f, -0.25084212f, -0.20942920f, -0.02731435f, 0.24383032f, -0.03016084f, -0.10528556f, -0.25216109f, 
    -0.16526607f, -0.24398126f, 0.01634516f, 0.10028432f, 0.35810781f, -0.07976904f, -0.11320243f, -0.44452521f, 
    0.45763066f, 0.05975619f, 0.22639784f, 0.30447915f, -0.08662707f, -0.20900832f, -0.21391349f, -0.07923004f, 
    -0.32500958f, -0.18688986f, -0.72037524f, 0.01566178f, -0.19445485f, -0.29224989f, -0.01967513f, -0.02696120f, 
    0.02117863f, -0.06722735f, -0.12154229f, -0.26487088f, 0.15898976f, 0.08335467f, -0.01323288f, 0.06582647f, 
    0.09863449f, -0.20217445f, -0.56438273f, -0.18787810f, -0.31152141f, -0.07138412f, 0.05381052f, 0.15817423f, 
    0.19640832f, 0.01750639f, 0.11082868f, -0.76936734f, 0.31992599f, 0.59245515f, 0.25822008f, -0.15378205f, 
    -0.06188656f, 0.06680281f, 0.12197879f, -0.02141946f, -0.26793933f, 0.15774751f, 0.42581898f, 0.15803577f, 
    0.20907179f, -0.02050406f, 0.03046476f, -0.00585231f, 0.11895041f, 0.29190439f, 0.20611183f, -0.20617719f, 
    -0.15733086f, 0.04929677f, -0.15165393f, 0.05144782f, -0.03975767f, 0.22240052f, 0.14696823f, 0.01573966f, 
    -0.25759646f, 0.02840296f, 0.00869651f, 0.11695430f, 0.15389474f, -0.01569994f, 0.12110618f, -0.12079973f, 
    -0.33443815f, -0.16113989f, -0.11696333f, -0.22320963f, 0.07209025f, -0.09720005f, -0.00209249f, -0.29036486f, 
    0.08248153f, 0.54590034f, -0.06113305f, 0.14648063f, -0.11944056f, -0.05353117f, 0.21686780f, 0.00464051f, 
    -0.05988525f, -0.70397866f, -0.25431037f, -0.14430712f, 0.01088953f, -0.04215692f, -0.16034311f, -0.13947973f, 
    0.08552067f, 0.19841926f, 0.09427597f, -0.61873055f, 0.23574890f, 0.05609760f, 0.00827775f, 0.23631129f, 
    0.18427296f, 0.05913491f, -0.05364686f, -0.15946220f, -0.22362334f, 0.26062062f, 0.02892860f, -0.14104447f, 
    0.18975571f, 0.28242582f, -0.13324599f, 0.07456066f, 0.30995151f, 0.45918950f, -0.10986285f, -0.04623417f, 
    0.18441392f, 0.02666325f, -0.17568812f, -0.04150107f, -0.05498092f, -0.07729957f, 0.15853509f, -0.17636319f, 
    0.09229444f, 0.07337233f, 0.08595816f, 0.06633796f, 0.06876996f, 0.14613032f, 0.34762228f, -0.41867256f, 
    -0.10756119f, -0.03646110f, -0.05664796f, 0.18796596f, -0.07689203f, -0.03826934f, -0.11781165f, -0.10251475f, 
    0.60392934f, -0.17106637f, -0.10391714f, -0.23462795f, -0.12832847f, 0.08410746f, 0.21988247f, 0.10567050f, 
    -0.07425021f, -0.26271462f, -0.10573109f, 0.11561393f, 0.03470765f, -0.18620610f, -0.19063376f, 0.06394094f, 
    -0.01290082f, -0.11628956f, 0.41509816f, 0.02442281f, 0.07573128f, 0.13810377f, 0.07136506f, -0.03363193f, 
    0.06776663f, 0.05657348f, 0.56411648f, -0.03082424f, 0.02348667f, -0.27736810f, -0.23652288f, 0.20296076f, 
    0.10453752f, -0.11781224f, 0.02229734f, -0.20375700f, 0.42604437f, -0.45182946f, 0.11055326f, -0.24485585f, 
    -0.11099418f, 0.11962550f, 0.27078786f, -0.01097205f, -0.19406810f, -0.70665860f, 0.07928881f, 0.04005631f, 
    0.25043765f, -0.16216768f, 0.07473847f, -0.13000770f, 0.15873787f, -0.05504968f, -0.08756208f, 0.11820072f, 
    0.03219867f, 0.12438080f, -0.20087773f, 0.04367894f, 0.21514629f, -0.07722764f, -0.41839048f, 0.19723690f, 
    -0.24135864f, -0.01829717f, -0.01519733f, -0.08853422f, -0.18689552f, 0.01432953f, -0.05846458f, 0.75849289f, 
    -0.00982284f, -0.10264379f, -0.05787682f, -0.09176163f, 0.03250184f, -0.03776487f, -0.01949574f, -0.02400939f, 
    0.07395927f, -0.10325976f, 0.05805116f, -0.13579416f, -0.04736421f, 0.02538437f, -0.01514970f, -0.10305277f, 
    -0.00475477f, 0.07001762f, -0.16517508f, -0.31956056f, 0.16762169f, 0.08320247f, -0.00276142f, 0.09781368f, 
    -0.06475005f, -0.12949334f, 0.18050900f, 0.21586084f, -0.09401053f, 0.01332867f, 0.11462896f, -0.16818114f, 
    0.22120915f, -0.18330389f, 0.01646528f, -0.14433824f, -0.15594938f, 0.07589832f, 0.20924553f, 0.18245424f, 
    0.08779867f, -0.11152197f, -0.28024808f, 0.15895599f, 0.42293209f, 0.33150598f, 0.17873387f, -0.13561910f, 
    -0.20197661f, 0.16799782f, 0.03639781f, 0.09456211f, -0.25371373f, 0.21351884f, 0.33669540f, -0.01035166f, 
    0.04712668f, -0.01418904f, -0.05288668f, 0.13793501f, 0.00151142f, 0.25200510f, -0.15803427f, -0.31431958f, 
    -0.33028737f, 0.18220435f, 0.05404129f, 0.02469430f, 0.17959413f, 0.13041578f, 0.01381188f, 0.04469094f, 
    0.07649159f, 0.18292972f, -0.05789378f, -0.12601672f, -0.37474671f, 0.07528133f, 0.20706396f, 0.08230607f, 
    0.47461459f, -0.04947339f, -0.54637510f, -0.06788323f, -0.06434047f, 0.03178506f, -0.11069154f, -0.12521607f, 
    0.07439628f, 0.00299419f, -0.04662432f, 0.13766368f, -0.13081542f, 0.00511453f, 0.07613103f, 0.11346748f, 
    -0.11875868f, -0.20379992f, -0.10417844f, -0.61132073f, -0.47935647f, -0.04648612f, -0.05338297f, -0.17808636f, 
    -0.12011641f, 0.11929809f, -0.08019919f, 0.20832162f, 0.31867990f, 0.32323727f, 0.04154618f, -0.02897682f, 
    -0.02707244f, -0.27707455f, 0.22264105f, 0.19099647f, 0.11140538f, 0.48460418f, -0.07429471f, -0.18383390f, 
    0.02412919f, 0.09747604f, 0.11671583f, 0.01631195f, -0.00968557f, 0.17773858f, 0.14269523f, 0.12405615f, 
    -0.03514146f, -0.05459362f, 0.05700109f, -0.14848098f, 0.15154187f, 0.08574917f, -0.39927921f, -0.76307613f, 
    -0.39709520f, 0.26436639f, -0.01887873f, 0.16560373f, 0.04559244f, -0.21010326f, 0.13349913f, -0.03935879f, 
    -0.09878765f, -0.37597367f, 0.05455030f, -0.03976201f, 0.25602552f, -0.17497893f, 0.13893394f, -0.07592039f, 
    0.03908513f, 0.07485929f, -0.08359674f, 0.03727259f, -0.02905071f, -0.03875966f, 0.01970449f, -0.03649899f, 
    -0.08441258f, -0.06490734f, 0.01990616f, 0.02144037f, -0.08848630f, 0.03310094f, -0.08424773f, -0.06612325f, 
    -0.05541848f, -0.01116069f, -0.03683531f, 0.06868176f, -0.03271436f, -0.02598656f, -0.02388416f, -0.07857183f, 
    0.03756441f, -0.07567220f, -0.01120309f, 0.03351863f, 0.02567857f, -0.03952286f, 0.05223712f, -0.03975375f, 
    -0.10250066f, -0.09224378f, -0.01756247f, 0.04813401f, 0.05669871f, -0.01945681f, 0.06147158f, 0.02632849f, 
    -0.01557594f, 0.06494470f, -0.06894872f, 0.02402925f, -0.09447964f, -0.07490618f, -0.00185528f, -0.03754988f, 
    -0.01489513f, -0.03351488f, 0.00904068f, -0.02003292f, -0.03059064f, 0.07434601f, -0.08371333f, 0.03782146f, 
    0.04496083f, -0.03253503f, 0.01733245f, -0.04348724f, 0.04549974f, 0.05337642f, -0.07189042f, 0.01774069f, 
    0.03910265f, -0.06122997f, 0.05226996f, 0.04056790f, -0.10134081f, -0.07760124f, -0.01161903f, -0.02668847f, 
    -0.06023870f, -0.05923700f, 0.02243740f, -0.04186353f, 0.01007746f, 0.02400517f, 0.01479308f, -0.01483657f, 
    -0.08672097f, -0.06478086f, 0.00993335f, 0.00736226f, -0.10943189f, 0.05820093f, 0.06379341f, -0.03943350f, 
    -0.00129521f, -0.08104218f, 0.02370112f, 0.00280999f, -0.03253567f, -0.09955910f, -0.08422990f, -0.04878550f, 
    -0.09252970f, -0.01276433f, -0.03553363f, -0.06200635f, -0.01803900f, 0.03837262f, -0.08010764f, -0.05924144f, 
    0.04339296f, 0.02519053f, 0.01071750f, -0.05350102f, -0.04180416f, -0.08290261f, -0.07865082f, -0.01038441f, 
    0.08892804f, 0.02198585f, 0.02192138f, 0.02726008f, 0.01717364f, -0.03633273f, -0.07110307f, 0.03311143f, 
    0.05746914f, -0.06031867f, 0.01819704f, -0.02927976f, -0.06959048f, 0.03547496f, -0.01485952f, -0.09248114f, 
    -0.00506060f, -0.07862902f, 0.03730884f, -0.01938245f, -0.01853694f, 0.01955644f, 0.04246956f, -0.03960091f, 
    -0.01803265f, -0.04936386f, -0.04561038f, -0.07364528f, 0.00328486f, 0.01091459f, -0.03512615f, -0.02354853f, 
    0.24435367f, 0.11417929f, -0.21395741f, 0.37518749f, 0.16552095f, -0.17560217f, 0.19538218f, 0.06524103f, 
    0.02902478f, -0.13230708f, 0.39531109f, -0.00490000f, -0.20835012f, -0.01426035f, 0.19101028f, 0.24254707f, 
    0.01585067f, 0.00669898f, -0.02057187f, 0.05800557f, 0.25727940f, -0.00679920f, -0.01901470f, 0.02422252f, 
    0.13121174f, 0.09211138f, -0.16404399f, 0.38654110f, 0.32560879f, 0.27391863f, 0.11264900f, 0.10456764f, 
    -0.19832587f, -0.18437994f, 0.10066088f, 0.24208701f, -0.01376097f, -0.34273213f, -0.22552310f, 0.24376251f, 
    0.07631171f, 0.02365225f, -0.14711238f, -0.11520474f, -0.10177778f, -0.40968332f, 0.07206506f, 0.39361799f, 
    0.29492006f, 0.30290508f, -0.02786924f, 0.15034458f, -0.04201411f, -0.08197293f, 0.07469510f, -0.16825818f, 
    0.40517831f, -0.22629599f, 0.09152251f, 0.12240522f, -0.04269487f, 0.07007749f, 0.26649392f, -0.26358575f, 
    -0.44847670f, -0.11126835f, -0.06257121f, 0.20325483f, -0.07795335f, -0.11275645f, -0.18219525f, 0.04006990f, 
    -0.19901456f, 0.18575206f, -0.24296470f, -0.24174133f, -0.25625598f, -0.27459943f, 0.07468250f, 0.15305296f, 
    -0.00147952f, -0.79768783f, -0.19558731f, -0.08386484f, 0.13087541f, -0.05328242f, -0.06668606f, -0.08074041f, 
    -0.03232963f, -0.09872704f, -0.46000305f, 0.15824749f, -0.13102385f, 0.05359193f, 0.17411764f, -0.17021051f, 
    0.01155778f, -0.10365488f, 0.03926628f, -0.25969642f, 0.10048878f, -0.49428207f, 0.17618161f, 0.06132909f, 
    0.06050221f, 0.05609812f, 0.14986022f, -0.00519807f, -0.41221777f, 0.11967557f, -0.07843976f, 0.11683322f, 
    0.19308949f, 0.03230868f, 0.19744109f, -0.04586186f, -0.03642870f, 0.07925416f, -0.04751466f, 0.38842082f, 
    0.23516870f, 0.14793237f, 0.04521951f, 0.03910966f, -0.06417312f, -0.07724722f, 0.06622913f, -0.06680369f, 
    0.05242426f, 0.11691873f, 0.12123639f, -0.08400047f, 0.02282594f, -0.18376453f, -0.01049380f, 0.06439595f, 
    -0.27482301f, 0.11715265f, 0.06897961f, -0.11246824f, -0.22334228f, -0.30713928f, 0.07132703f, -0.01062318f, 
    -0.40704313f, -0.04876651f, 0.18223177f, -0.21100299f, 0.21231689f, 0.19379872f, -0.07487977f, 0.29577115f, 
    -0.40321723f, -0.03495497f, -0.12955689f, 0.06866486f, 0.12330558f, 0.10338688f, -0.21352851f, -0.27005976f, 
    0.00689042f, 0.43950975f, 0.29536980f, 0.15453981f, -0.17352642f, -0.09405898f, -0.01711427f, 0.11789619f, 
    -0.17141360f, 0.14470795f, 0.09161254f, -0.16453968f, -0.13500419f, -0.34655920f, 0.06538134f, -0.26240507f, 
    -0.06022485f, 0.24449399f, -0.07427291f, 0.11163127f, 0.81711966f, 0.11287348f, -0.10677310f, 0.07985631f, 
    0.32086304f, -0.12641430f, 0.15138067f, 0.03009132f, 0.06744298f, 0.10635567f, 0.16645728f, 0.10756485f, 
    0.18176205f, -0.06294481f, -0.09587266f, -0.07746596f, 0.07664306f, 0.11115142f, 0.24682736f, 0.14459278f, 
    0.06769421f, 0.09975006f, -0.04068826f, 0.41678500f, -0.21486074f, -0.05450269f, 0.03862009f, -0.00197088f, 
    -0.13192151f, -0.57598400f, 0.07521636f, 0.08422890f, -0.05416280f, 0.06567893f, -0.22906646f, -0.26640445f, 
    -0.02456980f, 0.31064048f, 0.29244807f, 0.07122404f, -0.07233642f, -0.30009353f, 0.06785775f, -0.00372112f, 
    0.10827890f, -0.03708382f, -0.41993713f, -0.03287264f, 0.04338618f, 0.03814065f, -0.22308497f, 0.04016471f, 
    0.06301846f, -0.30944654f, -0.89785188f, -1.10662186f, 0.17686613f, -0.11089821f, 0.05547666f, -0.24584952f, 
    0.02901820f, 0.05758421f, -0.16820846f, -0.18141207f, 0.23757516f, -0.01034906f, -0.02460838f, 0.19974346f, 
    -0.03092309f, 0.06459672f, 0.39326608f, -0.21584466f, 0.13339986f, -0.12455816f, 0.14843017f, -0.37772727f, 
    -0.18678817f, 0.19786806f, 0.13279837f, 0.35463643f, 0.13035561f, 0.13591386f, -0.03091942f, -0.07769773f, 
    0.05838210f, 0.10266363f, -0.05976075f, 0.04275531f, 0.03376518f, 0.32195476f, -0.39150167f, -0.09683065f, 
    0.26652190f, 0.21801667f, 0.30015063f, 0.20855828f, 0.08697757f, -0.02467903f, -0.18272783f, -0.05777735f, 
    -0.02725135f, -0.02682614f, 0.17125311f, -0.06858131f, 0.17196742f, -0.33752987f, -0.18934001f, -0.08042946f, 
    -0.01681045f, -0.06594564f, -0.02848975f, -0.06311368f, -0.00775999f, -0.02182576f, -0.06638201f, -0.03906306f, 
    0.07065574f, -0.06563277f, -0.01817816f, 0.00439098f, 0.02213292f, -0.02067136f, -0.04540490f, 0.07257058f, 
    -0.06930648f, -0.08337224f, -0.03724718f, -0.03996465f, 0.03990701f, -0.05168765f, -0.05832008f, 0.01736379f, 
    -0.02967829f, -0.06984212f, -0.00574572f, 0.06041773f, -0.06856149f, -0.04364987f, 0.02026074f, -0.02228615f, 
    0.05785482f, -0.05674291f, 0.06133453f, 0.02529529f, -0.01999544f, 0.03756121f, -0.01804466f, -0.02126894f, 
    -0.01767952f, 0.05445616f, -0.05998082f, 0.01526492f, -0.04779167f, 0.03244321f, -0.04642085f, 0.01995233f, 
    0.04661299f, -0.07434662f, -0.05860280f, -0.07265070f, -0.05652234f, -0.02786422f, 0.01771639f, 0.00451399f, 
    -0.01370880f, 0.00898381f, -0.01094346f, 0.01873422f, -0.06190859f, -0.03732035f, -0.06321184f, 0.02824797f, 
    0.07201657f, -0.05521963f, 0.06658057f, -0.03188889f, 0.07351594f, 0.01328570f, 0.03571235f, -0.02474060f, 
    -0.01856477f, -0.01295122f, -0.05038578f, -0.06718154f, 0.07252165f, 0.01042325f, -0.02086741f, 0.01589069f, 
    0.03427948f, -0.00364951f, -0.06379554f, 0.01751577f, -0.04235898f, 0.00997574f, -0.07338750f, -0.01691840f, 
    0.03000162f, -0.06920430f, 0.01077690f, 0.03017546f, -0.08403803f, -0.03105561f, -0.06066137f, 0.03489018f, 
    0.04984033f, -0.06634035f, 0.04418663f, -0.03971668f, 0.05043023f, -0.07350203f, -0.05216378f, -0.01021289f, 
    -0.00245346f, -0.00951632f, 0.03481176f, -0.01912721f, 0.00259813f, -0.02802091f, -0.00567140f, -0.06699098f, 
    -0.00555937f, 0.05637972f, -0.03594432f, 0.04912463f, 0.03124977f, 0.03927779f, 0.02130489f, -0.08485507f, 
    -0.08688713f, 0.01640330f, -0.08003472f, -0.08224126f, 0.07247204f, -0.00840736f, -0.01645968f, 0.06429278f, 
    0.04760256f, -0.05289324f, -0.05677729f, -0.00762410f, -0.01087079f, 0.03671661f, -0.05494326f, -0.05151992f, 
    -0.03392922f, 0.06236770f, -0.00463793f, 0.06421428f, -0.03185987f, 0.07299127f, -0.02641402f, -0.04240514f, 
    -0.35340580f, -0.04781218f, 0.26929486f, 0.03193165f, 0.02899255f, 0.17015086f, -0.07936894f, 0.15418953f, 
    0.10819580f, -0.15185091f, 0.07183679f, 0.19771428f, 0.23976977f, 0.25973561f, 0.09720352f, 0.19708498f, 
    -0.10476772f, -0.20290685f, -0.30016312f, -0.08178070f, 0.11986538f, 0.18849754f, 0.08523609f, -0.20839052f, 
    -0.21059845f, -0.11557738f, 0.17403588f, -0.94157040f, -0.13908640f, -0.21274230f, 0.22895351f, 0.43084124f, 
    0.30907482f, -0.12232395f, 0.04101709f, -0.01904831f, 0.03354215f, 0.25468254f, 0.12495863f, 0.35411820f, 
    0.14354977f, 0.07766391f, -0.06135793f, 0.21047656f, -0.08307549f, -0.99981380f, -0.32486743f, -0.20828782f, 
    0.13131638f, 0.17118399f, 0.15654337f, 0.20889178f, 0.06931510f, 0.27678362f, 0.51847112f, 0.30024359f, 
    0.06596301f, -0.07203135f, -0.15785202f, 0.03808652f, -0.26583475f, 0.20433381f, -0.02579172f, 0.32173505f, 
    0.15959236f, -0.10918311f, -0.14012514f, 0.29282528f, -0.10527138f, -0.13538568f, 0.12561749f, 0.21013407f, 
    -0.04306759f, -0.75850725f, -0.18555036f, -0.44593337f, -0.20045750f, 0.21189958f, -0.10714585f, 0.10315800f, 
    -0.01120183f, 0.60085231f, 0.43445414f, -0.23869976f, -0.17272735f, -0.02551479f, 0.12608114f, 0.27101597f, 
    -0.04833708f, -0.14329886f, 0.53212625f, -0.13090426f, -0.21016307f, -0.36731896f, -0.06669609f, 0.00618962f, 
    0.41194549f, 0.26358163f, 0.13845110f, -0.07366405f, -0.12619926f, 0.01834287f, 0.05470620f, -0.19391027f, 
    -0.49135494f, -0.21119004f, 0.23775743f, -0.09839332f, -1.20891953f, -0.35299218f, 0.08575013f, 0.27286479f, 
    0.32940075f, 0.13628665f, -0.11302544f, -0.14901687f, 0.26196834f, 0.42148495f, 0.22660856f, 0.13486496f, 
    0.11929820f, -0.02417245f, -0.15057485f, 0.23365825f, 0.34114307f, 0.10075606f, 0.16696663f, 0.03538047f, 
    -0.28183237f, -0.04949727f, -0.20861125f, 0.29824069f, -0.03984687f, -0.04602437f, -0.24221741f, -0.19818448f, 
    0.19187859f, -0.11626910f, -0.03880684f, -0.08074497f, 0.21709991f, -0.24742851f, -0.06024812f, -0.18832420f, 
    0.10049220f, 0.04295762f, -0.40455589f, -0.13802104f, 0.05415242f, -0.08471422f, -0.03479586f, -0.08092307f, 
    -0.22636820f, 0.03956610f, -0.14387593f, -0.02136563f, 0.01728765f, 0.00297699f, -0.07520320f, -0.06219911f, 
    0.15209201f, -0.15755992f, 0.02282264f, -0.11711930f, 0.09052880f, 0.11591208f, 0.01156404f, 0.11397830f, 
    0.20592643f, -0.08082153f, 0.00137235f, 0.50073451f, 0.27005985f, -0.11361703f, 0.03847060f, -0.03953384f, 
    0.28592908f, 0.06689032f, -0.16076633f, 0.00611971f, -0.42841128f, 0.02380503f, -0.16204137f, -0.08332211f, 
    0.08766224f, 0.02887628f, -0.15933985f, 0.08508191f, 0.03539366f, 0.89197958f, -0.00687409f, 0.14200497f, 
    -0.26128340f, 0.09664682f, 0.03242809f, 0.11698720f, 0.00800074f, -0.13702387f, 0.25456151f, -0.26615593f, 
    -0.29288244f, 0.16006859f, -0.11663356f, -0.01762065f, 0.03207332f, -0.09370998f, -0.09364004f, 0.43734097f, 
    0.12648427f, -0.17758542f, -0.04664565f, 0.03894111f, -0.17235681f, -0.07243574f, 0.08067254f, -0.04062794f, 
    0.30015343f, -0.59910858f, 0.27541083f, -0.14047115f, 0.05709019f, 0.09456777f, 0.06989320f, -0.02329137f, 
    0.09613720f, -0.16724107f, 0.19995807f, -0.01479689f, -0.07227042f, -0.06906125f, 0.11424404f, -0.14975481f, 
    0.03401339f, -0.20080882f, -0.69150281f, -0.10333040f, 0.01831097f, -0.20523815f, 0.00736955f, -0.08887734f, 
    -0.06072205f, 0.19437188f, -0.07286099f, 0.39459199f, 0.22327818f, -0.12319566f, -0.31532383f, 0.12858805f, 
    -0.08341635f, 0.08595611f, 0.04606895f, 0.11236464f, 0.40109774f, 0.16703466f, 0.22614458f, 0.08987153f, 
    0.04964846f, 0.03881270f, 0.15876679f, 0.09499139f, -0.03086986f, -0.74566585f, 0.01530663f, -0.32533985f, 
    0.08524176f, 0.07623830f, -0.18474947f, 0.03813388f, -0.23717684f, -0.10986952f, 0.36755350f, -0.13288586f, 
    -0.51733971f, -0.13817166f, 0.07460183f, 0.16319038f, -0.07670721f, -0.02568930f, -0.00305574f, 0.51990777f, 
    0.17071584f, 0.12559405f, 0.30916625f, 0.14474028f, -0.09730303f, 0.18742554f, -0.07131258f, 0.23219292f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.31248119f, 0.03621633f, 0.38159937f, 0.06033402f, 0.00964252f, 0.38910052f, 0.22580901f, 0.17640807f, 
    -0.00844814f, 0.03160247f, -0.08549869f, 0.27164954f, 0.32463008f, -0.05262605f, -0.03050171f, -0.25438327f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18591368f, 0.21798868f, 0.03835773f, -0.04027683f, -0.06971975f, 0.77103919f, -0.37522715f, -0.81633270f, 
    -0.04131502f, -0.01250936f, -0.21666056f, -0.49945465f, 0.18313950f, 0.00083461f, -0.28684953f, -0.51192439f, 
    -0.03687277f, -0.09171046f, -0.02985431f, -0.01639717f, -0.16179456f, 0.27570981f, -0.84022093f, 0.24637257f, 
    -0.27902704f, 0.55922031f, 0.00572139f, -0.16466095f, 0.27991208f, 0.01394308f, -0.14112890f, 0.22082452f, 
    0.06094706f, 0.07343628f, -0.43013611f, 0.20195605f, 0.00378358f, -0.07589702f, 0.32174742f, -0.44640797f, 
    -1.40259564f, 0.61558437f, -0.09567253f, -0.13014221f, -0.15489578f, -0.02944247f, 0.39385509f, 0.54844022f, 
    -0.36507532f, 0.03979082f, 0.37142816f, -0.11686697f, -0.12008730f, -0.24727941f, 0.09179212f, -0.58911848f, 
    0.70205003f, -0.31194657f, -0.02174185f, -0.39202854f, -0.57765549f, -0.02236742f, 0.37194324f, -0.37686840f, 
    0.16910715f, -0.20075235f, 0.15133269f, 0.06221560f, 0.25486633f, 0.17014030f, 0.20209539f, 0.17379464f, 
    -0.00086726f, -0.21753271f, -0.17386198f, 0.43293867f, -0.43136570f, 0.00189924f, -0.25460079f, -0.85934794f, 
    -0.16772527f, 0.14149377f, -0.12991525f, 0.14355874f, 0.11954384f, 0.17146315f, -0.49205726f, 0.43694568f, 
    -0.01793964f, -0.46957272f, -0.18511197f, 0.67698741f, 0.47298983f, 0.08905887f, -0.37917700f, -0.10176156f, 
    -0.22245766f, -0.15519565f, -0.15266250f, 0.12968941f, -0.16330463f, 0.29457027f, -0.13214076f, -0.25660664f, 
    -0.16056068f, -0.96546966f, -0.05081825f, 0.40612835f, 0.21706291f, 0.15890540f, -0.30150074f, 0.73980057f, 
    1.11912286f, 0.07181625f, -0.17533267f, 0.01335591f, -0.06609562f, -0.22528487f, -0.48529816f, -0.35034874f, 
    0.53856701f, -0.06151121f, -0.10124017f, -0.28522819f, -0.32239434f, 0.20526321f, 0.10687943f, -0.36382544f, 
    -0.18887581f, -0.14123130f, -1.00854301f, -0.04528226f, 0.17170154f, -0.35095391f, 0.11464633f, 1.01944208f, 
    0.55528116f, 0.60337788f, -0.19699799f, -0.11362386f, 0.19172440f, -0.14830513f, -0.11188731f, 0.16783242f, 
    0.28259087f, 0.11152143f, -0.06317808f, -0.09885702f, -0.10458221f, 0.10127456f, 0.54030460f, -0.71784985f, 
    -0.25773600f, -0.22110873f, -0.15147761f, 0.32551908f, 0.66102153f, -0.17841262f, -0.47767600f, -0.46820503f, 
    -0.59414065f, -0.24085233f, 0.08342990f, 0.00606444f, -0.02641130f, -0.54563934f, -0.19796950f, 0.18282680f, 
    0.02493319f, 0.14822774f, 0.11997307f, -0.52108741f, 0.01105101f, -0.01801896f, 0.79811954f, 0.01661896f, 
    -0.67929363f, -0.17996623f, 0.53122991f, 0.03625685f, -0.12114044f, -0.30424315f, 0.33284941f, -0.52705669f, 
    0.46106601f, -0.00623300f, 0.03696465f, -0.08790643f, -0.18716136f, -0.16988850f, -0.18889996f, 0.55385572f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.23291178f, -0.13460892f, 0.01057846f, 0.09609100f, 0.32152438f, -0.01034180f, -0.07479235f, -0.85248625f, 
    -0.65127397f, -0.15421402f, 0.33268449f, -0.04529356f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
