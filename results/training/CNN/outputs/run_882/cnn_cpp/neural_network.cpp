#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.78270042f, 1.13043439f, -0.97033173f, -0.28405672f, -0.23516673f, -0.56663662f, 0.37489805f, 0.17018364f, 
    0.75578731f, 0.17498960f, -0.57439864f, -0.02329496f, 0.16663711f, -0.27987731f, -0.35992831f, -0.13839248f, 
    -0.62162656f, -0.24871893f, 0.10897094f, 0.60059530f, -0.18814269f, 0.10645415f, -0.22218950f, -0.18177648f, 
    -0.56993628f, -0.24939196f, -0.04669920f, -0.93598658f, -0.81656891f, -0.96604759f, 1.01604509f, 0.67114681f, 
    0.66575438f, 0.24850546f, 0.75221479f, -0.47142920f, 0.25563285f, 0.21819542f, -0.01802038f, -0.87082022f, 
    0.37370351f, 0.06006957f, 0.15499452f, -0.29566365f, 0.62202907f, -0.21523018f, -0.00505416f, -0.04060218f, 
    -0.00198072f, 0.63122398f, -0.30076736f, -1.42890215f, -0.83678550f, 0.25618288f, 0.04389834f, -0.41924381f, 
    0.95652813f, -0.95348459f, 0.22391871f, 0.61478823f, 0.40170678f, 0.58555353f, -0.24468765f, 0.31610647f, 
    0.33760136f, 0.06043165f, 0.18786158f, 0.05909444f, -0.11833642f, 0.13934968f, 0.26369426f, 0.40625817f, 
    0.27943397f, -0.25380039f, 0.17964850f, 0.06570026f, 1.10721481f, 0.67680478f, -0.97642899f, 0.23268317f, 
    -0.39680815f, 0.49054319f, -1.08336270f, 0.51860452f, -0.96868908f, -0.17808968f, 0.01159861f, -0.07846249f, 
    0.47906142f, -0.51164919f, -0.09975160f, -0.12242264f, 0.12529185f, -0.03461235f, -0.14573790f, -0.27712017f, 
    -0.19104850f, 0.16624323f, 0.05625120f, 0.21537416f, -0.46984664f, -1.04787672f, -1.34510207f, -0.64999586f, 
    -0.13780430f, -0.40801865f, -0.58347410f, 0.06833192f, 0.58253199f, -0.20580859f, -0.79198569f, 0.18475629f, 
    0.66941941f, 0.44155401f, -0.25115597f, -0.09052122f, 0.03216292f, 0.25044587f, 0.24798343f, 0.10160554f, 
    -0.21701472f, 0.23690751f, -0.07302394f, 0.04655719f, -0.35252613f, 0.32943246f, -0.81587738f, 0.87222022f, 
    0.74818438f, 0.66673970f, -1.14201164f, -0.75319731f, -0.82532001f, -1.48533690f, -0.23209719f, 0.37777212f, 
    0.38614130f, 0.34340253f, 0.40230092f, 0.06660376f, 0.15793572f, -0.29504010f, -0.01333232f, 0.35597375f, 
    -0.38734642f, -0.15131477f, 0.18762814f, 0.22822748f, 0.24907532f, 0.29414916f, 0.95920092f, 1.19080508f, 
    0.69607550f, 0.68919504f, -0.65420496f, 0.45473686f, -0.83189970f, -0.44681624f, -0.12937190f, 0.00098105f, 
    0.70944256f, 0.24024726f, -0.01556834f, -0.08271919f, -0.32059729f, 0.08081720f, -0.62816453f, 0.36944297f, 
    0.36485976f, -0.51991725f, -0.04345061f, 0.25113064f, -0.07099476f, 0.19704373f, 0.07869524f, 0.78581148f, 
    1.05512261f, 1.04242885f, 1.34933627f, 0.75759608f, -0.77511400f, 0.71606100f, -0.06808282f, 0.12090672f, 
    0.64023203f, -0.00470594f, -0.12013227f, -0.37865311f, 0.38413230f, -0.21874788f, 0.16222222f, -0.13499446f, 
    -0.28059143f, -0.08509441f, -0.35621610f, 0.29076782f, 0.07668891f, -0.15598221f, 0.20737730f, -0.12261353f, 
    0.94243282f, -0.14690292f, -0.90441030f, 0.29554391f, 1.18148220f, -0.20072013f, -1.03879452f, -0.37768713f, 
    -0.11187153f, 0.23554772f, -0.53874296f, 0.64666814f, 0.01573728f, -0.35187656f, 0.09049936f, 0.06948137f, 
    -0.44382623f, 0.11366200f, 0.34594736f, -0.06975208f, -0.15018883f, 0.05594154f, -0.32925451f, -0.79510164f, 
    -0.31078500f, -0.86955500f, -1.29745197f, -0.13943858f, -0.24168219f, -0.66789263f, -1.00761938f, 0.38651213f, 
    0.77209818f, -0.51239479f, -0.44983605f, 0.19837537f, -0.24388035f, -0.43900236f, -0.21850182f, -0.25776380f, 
    0.01760145f, 0.41909742f, -0.54507077f, -0.10400259f, -0.53419298f, -0.19416955f, -0.16433357f, 0.39604098f, 
    0.46787927f, 0.19647460f, -2.12383580f, 0.17657503f, -0.26902062f, 0.65380305f, -0.81024045f, 0.75675505f, 
    1.07856011f, -0.38102987f, 0.55362880f, 0.50660485f, -0.14986920f, -0.29334605f, 0.38206038f, 0.09205968f, 
    0.34621140f, -0.02878673f, -0.11088219f, -0.40773699f, -0.10319410f, -0.06578234f, -0.09700642f, 0.02793152f, 
    0.28983968f, 0.11868338f, 0.14356135f, 1.61869574f, 0.90695071f, 0.63814223f, -1.52916670f, -0.86879128f, 
    0.18093230f, -0.15415244f, 0.26026133f, -0.57829481f, 0.06371953f, 0.37928218f, 0.72909218f, -0.06431815f, 
    0.37184951f, -0.10376748f, 0.23756994f, 0.30513132f, 0.04382220f, -0.08883806f, 0.03335250f, -0.31153256f, 
    -0.12412608f, 0.13883714f, -0.34460184f, 0.62640959f, -1.86509621f, 1.67014289f, 0.98817337f, -1.20250916f, 
    -0.16837734f, -0.74861348f, 0.65511847f, 0.23632774f, 0.01722800f, -0.48869345f, -0.10488316f, 0.31426537f, 
    -0.32621297f, -0.01710803f, 0.09388387f, 0.15022939f, -0.01617850f, -0.25542697f, -0.13045590f, -0.04072682f, 
    0.34874836f, 0.31457216f, 0.17579225f, 0.53487992f, 0.11884456f, -1.25788176f, -0.41181225f, -1.34182620f, 
    -0.59601158f, 0.50922471f, -0.87344646f, 0.42582843f, 0.47652572f, 0.40882570f, 0.82059044f, 0.15395413f, 
    -0.29157221f, 0.51968002f, -0.31551859f, 0.06659576f, 0.04628298f, 0.03717869f, 0.11014488f, 0.34826401f, 
    -0.05625265f, 0.13515179f, 0.17761415f, -0.50967020f, 0.29152989f, -0.22028980f, 1.43313253f, 1.13215387f, 
    0.43549246f, 0.77925557f, 1.56740022f, -0.12062348f, 0.57839692f, 0.66986144f, -0.45734781f, -0.70357043f, 
    -0.30264509f, -0.10411055f, -0.13932365f, 0.15574645f, 0.36827672f, -0.14451768f, 0.07530978f, 0.37585092f, 
    0.31771892f, 0.30137032f, 0.21685249f, 0.08122905f, 0.26553920f, 0.21504478f, 0.25669989f, -0.49199665f, 
    -1.31685746f, 0.25910634f, 1.20608246f, 0.73642761f, 0.71375632f, 1.53019691f, 0.96676725f, -0.60316998f, 
    0.16842717f, -0.20952515f, 0.12730089f, 0.44166160f, 0.45030847f, 0.06877565f, -0.29007462f, -0.18472356f, 
    0.06968105f, -0.01681085f, -0.21892044f, 0.07100976f, -0.09824093f, 0.00322931f, 0.09181363f, -0.17337799f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17286067f, 0.03130807f, 0.41837111f, 0.14128695f, 0.44955775f, 0.51633018f, 0.31272715f, 0.42683157f, 
    0.13138805f, 0.33114260f, -0.22509742f, 0.32243890f, 0.48708299f, 0.36745852f, 0.11554544f, 0.51001376f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.09670016f, 0.00914333f, -0.24846531f, -0.27318808f, -0.05811959f, -0.20484746f, -0.08744590f, 0.14792451f, 
    0.00748047f, -0.03196283f, 0.18884903f, 0.07577834f, 0.23358035f, 0.30292791f, -0.17343377f, -0.48853910f, 
    0.29470959f, 0.04265115f, -0.01646241f, 0.09096175f, -0.09058882f, 0.09324936f, 0.00155988f, 0.01816761f, 
    -0.19418293f, -0.19444706f, -0.07277603f, 0.10903568f, -0.14443289f, 0.02495881f, 0.09323143f, -0.08820544f, 
    0.04873224f, 0.00792084f, -0.05687309f, -0.02268460f, -0.28584534f, 0.12113324f, 0.17713007f, -0.48981705f, 
    0.14367837f, 0.01485692f, -0.06582108f, -0.04379343f, -0.04099215f, -0.02220341f, -0.10966702f, -0.10952996f, 
    -0.18018614f, -0.22556216f, 0.04874104f, -0.30654940f, 0.02777512f, -0.11484617f, 0.31235704f, 0.01609642f, 
    -0.05857632f, -0.07021891f, 0.01259318f, 0.00378056f, 0.05276936f, -0.22887808f, 0.06266516f, 0.35299668f, 
    -0.14938940f, -0.00153640f, 0.03101121f, 0.05429799f, -0.27270207f, 0.12002277f, -0.10759661f, 0.05232130f, 
    0.07930213f, 0.01802038f, -0.11012992f, 0.06539107f, -0.13139305f, 0.02203519f, 0.04968231f, -0.03888091f, 
    -0.08677875f, 0.00045994f, -0.09723867f, -0.02784980f, 0.10887897f, -0.01215737f, 0.18373208f, 0.42809364f, 
    -0.32143700f, -0.08605264f, 0.02296522f, 0.01960749f, -0.07407421f, 0.06041653f, 0.03480572f, -0.27323222f, 
    0.40009761f, -0.68108863f, 0.41217744f, -0.13840280f, -0.09996708f, 0.14557584f, 0.03458806f, 0.11758669f, 
    -0.14273223f, -0.05253966f, 0.07064789f, -0.00742294f, -0.74680519f, 0.07663808f, -0.17512828f, -0.03805773f, 
    -0.02565327f, 0.15626174f, -0.18026337f, 0.15606935f, 0.12154868f, 0.06620783f, -0.11732785f, -0.01015431f, 
    1.19192696f, 0.43086213f, 0.10027961f, 0.05419665f, -0.04663819f, -0.05935082f, -0.36630881f, -0.01310946f, 
    0.13688841f, -0.05520212f, 0.04613880f, -0.02634197f, -0.34203526f, 0.35678405f, 0.33917916f, -0.68085003f, 
    -0.13182165f, -0.05630371f, -0.09265550f, 0.17733327f, -0.14528410f, -0.04546059f, 0.04756534f, -0.05790812f, 
    -0.26703933f, 0.11362284f, 0.26095819f, -0.09206702f, 0.03062214f, 0.08968853f, 0.03014397f, -0.02350793f, 
    -0.02045624f, -0.08359300f, -0.12652294f, -0.17296965f, -0.13549457f, 0.57100832f, -0.20323461f, -0.21025482f, 
    0.02266268f, 0.03182391f, 0.14904635f, -0.01814364f, -0.09987503f, -0.09998257f, -0.10809638f, 0.20560218f, 
    0.39154544f, 0.25858480f, 0.07633011f, 0.00178656f, -0.41421232f, -0.04151791f, -0.10747371f, 0.14287651f, 
    0.00205728f, -0.10229330f, -0.01034247f, -0.03118359f, -0.85390651f, 0.31508255f, -0.02453525f, 0.02247101f, 
    -0.03134976f, 0.06051131f, -0.03010520f, -0.17956175f, 0.06835041f, 0.01305066f, -0.06777004f, -0.09402779f, 
    0.69423556f, -0.11748770f, 0.23956603f, -0.09867538f, 0.01474225f, -0.45692429f, 0.26837379f, -0.01507127f, 
    -0.14589721f, -0.16122118f, -0.30692351f, -0.02565254f, -0.28759822f, -0.32261649f, -0.05741873f, -0.34077784f, 
    0.07501035f, -0.14211573f, -0.12538841f, -0.00678154f, 0.04776800f, -0.07868367f, 0.19636627f, -0.13698956f, 
    0.47247171f, -0.21471100f, -0.56201243f, 0.01466350f, 0.03038917f, 0.04131234f, -0.02642720f, 0.07061564f, 
    -0.06199919f, 0.02560389f, 0.07408652f, 0.11540252f, 0.16677207f, 0.19793105f, -0.05050095f, 0.05917705f, 
    -0.06777161f, -0.13964280f, 0.14962345f, 0.12285984f, 0.07723766f, -0.18510407f, 0.26304501f, 0.06572071f, 
    -0.13657004f, -0.16209157f, 0.06183197f, -0.52408266f, -0.11867233f, -0.13190675f, 0.22210103f, 0.04991876f, 
    -0.23542282f, -0.11188211f, 0.24121299f, 0.06822558f, -0.67555869f, -0.29405904f, -0.28431982f, -0.12238261f, 
    0.02577766f, 0.02784126f, 0.19110556f, 0.12095048f, 0.16219491f, 0.05441756f, 0.00473881f, -0.06758931f, 
    -0.00834336f, -0.08034549f, -0.01158530f, 0.24108352f, 0.00093074f, -0.16617106f, 0.08473226f, 0.09663923f, 
    -0.03838569f, 0.07991060f, 0.01010863f, 0.15160491f, 0.48317614f, 0.08626280f, 0.12226300f, 0.31306350f, 
    -0.15193322f, 0.04296719f, 0.05027789f, 0.07731535f, 0.12322751f, -0.14781444f, -0.17923328f, 0.10068522f, 
    0.19773924f, -0.36686066f, 0.27880317f, -0.21311919f, 0.13547772f, -0.04622013f, -0.20958355f, 0.03064227f, 
    0.06485777f, -0.09227934f, 0.04248841f, -0.07121789f, 0.04077384f, -0.12208495f, -0.10174371f, 0.38771203f, 
    -0.22661883f, -0.09328952f, -0.21137941f, -0.14699243f, 0.14401171f, -0.30862418f, -0.43795988f, -0.10153954f, 
    -0.79968613f, 0.05330493f, -0.10919701f, -0.09262095f, 0.10860696f, 0.00262923f, 0.09102429f, -0.03072296f, 
    -0.00808523f, 0.06433459f, -0.23157804f, 0.04598663f, 0.45327634f, 0.21231289f, 0.07621443f, -0.25949049f, 
    0.06766970f, -0.24485576f, -0.19935018f, -0.09924379f, -0.23749529f, 0.01444620f, 0.01295599f, 0.05051078f, 
    -0.90937620f, 0.02972329f, -0.54381514f, -0.69819605f, -0.03697067f, 0.05348178f, 0.02411491f, 0.08954489f, 
    0.03050429f, 0.11005065f, 0.08359515f, -0.11231168f, 0.70271194f, 0.15513133f, -0.05068626f, -0.17699480f, 
    0.27362365f, -0.04629535f, -0.00717329f, 0.18108988f, 0.16777851f, -0.12151986f, 0.06689928f, 0.09190783f, 
    0.36484233f, 0.09225833f, 0.18667527f, 0.30738354f, -0.08417988f, 0.10478570f, 0.00955275f, -0.00808997f, 
    0.00467258f, 0.10108538f, -0.15455583f, 0.32599875f, 0.25000599f, 0.10312487f, -0.13119873f, 0.41005081f, 
    -0.17394565f, 0.11802662f, -0.11930213f, 0.01256554f, 0.03784388f, 0.08113875f, 0.08669700f, -0.12495148f, 
    0.35911292f, 0.24018224f, -0.29891875f, -0.13165911f, -0.08478355f, 0.02905271f, 0.20214818f, 0.22821477f, 
    -0.20448749f, -0.06743315f, 0.09982679f, -0.10222267f, 0.33644232f, 0.35334155f, 0.29712790f, 0.43580160f, 
    -0.01056758f, -0.18947922f, -0.07419834f, 0.27843693f, -0.18079081f, 0.01384118f, 0.03424643f, 0.08126676f, 
    0.62162805f, -0.45397508f, 0.15323053f, -0.04997582f, -0.25007409f, 0.09276123f, -0.18177265f, -0.00106053f, 
    0.00093034f, -0.18365705f, -0.04232952f, 0.05906920f, 0.04920246f, 0.20467694f, -0.61880374f, -0.16284163f, 
    0.11166986f, -0.05095292f, -0.00192181f, -0.02597065f, -0.24258070f, 0.01745130f, -0.00026638f, -0.03134656f, 
    -0.27296814f, -0.13206376f, -0.38753247f, 0.22514062f, -0.34584251f, -0.04757280f, 0.08566337f, 0.01949214f, 
    0.12471390f, -0.01623178f, -0.30728692f, 0.06626452f, 0.43265042f, -0.14120924f, -0.39655304f, -0.23143293f, 
    0.05111681f, 0.27144855f, -0.16252418f, -0.03023404f, -0.33465180f, 0.01469462f, -0.08813579f, -0.38497260f, 
    -0.24769099f, -0.01160909f, 0.04813550f, -0.28551370f, 0.05275778f, 0.06058615f, 0.04943604f, -0.11206855f, 
    -0.16030690f, 0.06658842f, -0.14230910f, -0.10936280f, 0.12860174f, 0.13180242f, -0.13275069f, 0.09458550f, 
    0.18628411f, 0.02644921f, 0.15532504f, -0.33501670f, -0.16189323f, 0.11860913f, 0.02809921f, -0.02266734f, 
    -0.55104810f, -0.20039380f, 0.32024246f, -0.36698413f, 0.07319493f, 0.27658582f, 0.00023496f, -0.19476403f, 
    -0.00747591f, 0.22674556f, -0.00094293f, -0.15994968f, 0.52514327f, -0.44999138f, -0.38060027f, -0.07849746f, 
    -0.28892165f, 0.09181409f, -0.25406501f, -0.13769650f, 0.16828324f, 0.12193266f, 0.07717180f, 0.05296388f, 
    0.82111740f, 0.13475347f, 0.11329903f, -0.12124741f, -0.04651958f, -0.26969081f, -0.41237026f, 0.19389263f, 
    -0.05704787f, 0.15320157f, 0.12843457f, -0.05321966f, -0.87089479f, -0.10367148f, 0.01307498f, -0.38104177f, 
    0.08241507f, 0.01070148f, 0.10329568f, -0.07335497f, -0.21557924f, 0.06121216f, -0.11880086f, 0.06232219f, 
    0.62369025f, -0.10138827f, -0.76632971f, -0.34131125f, 0.11627463f, 0.12321310f, -0.04843289f, -0.09559938f, 
    -0.00870746f, -0.12720980f, 0.12690589f, -0.11040414f, 0.16032197f, -0.02473112f, -0.01466026f, 0.45094162f, 
    -0.18544732f, -0.02801759f, -0.33308372f, 0.02186496f, 0.00635021f, 0.00517852f, -0.10769907f, 0.01001011f, 
    0.03313970f, 0.03713038f, -0.08487683f, -0.12928449f, 0.39671409f, -0.21963468f, 0.00102355f, -0.07080456f, 
    -0.02279036f, -0.17776754f, 0.08087512f, 0.28409261f, 0.25089860f, -0.27259028f, 0.42345673f, 0.12257250f, 
    -0.20300056f, -0.02679810f, -0.05896397f, 0.13551128f, 0.18436956f, -0.08520163f, 0.03860489f, -0.02695413f, 
    0.09798653f, -0.16305892f, -0.09337857f, -0.24876800f, -0.15126228f, 0.06452409f, -0.02868546f, 0.11459820f, 
    -0.06635133f, 0.15791883f, 0.13251804f, 0.26557660f, -0.27101013f, -0.18716170f, -0.07430498f, -0.21063709f, 
    -0.11352707f, 0.01016832f, 0.09218810f, 0.02370541f, -0.16706859f, 0.05041820f, -0.00672820f, -0.01033074f, 
    -0.04140964f, 0.06470175f, -0.03380149f, 0.07402543f, -0.24096525f, 0.07343485f, 0.15625209f, -0.00367947f, 
    -0.09916859f, 0.01057875f, 0.07364365f, 0.05149195f, 0.77132714f, 0.56703693f, -0.04566287f, -0.09204342f, 
    -0.05600867f, 0.00291197f, 0.06837192f, 0.09906378f, -0.12508225f, 0.21676458f, 0.17920321f, -0.01757404f, 
    0.11011044f, 0.07782132f, -0.06700402f, 0.06410035f, -0.20924416f, -0.08245635f, 0.04371287f, 0.09241451f, 
    -0.20043698f, -0.04686149f, 0.13191144f, 0.23399620f, 0.01562282f, 0.23734619f, 0.41046226f, 0.29612932f, 
    0.25753331f, 0.11957597f, -0.03361674f, -0.14878130f, -0.07142559f, 0.01985671f, -0.11097184f, -0.28590205f, 
    0.05424090f, -0.62673616f, -0.60264850f, 0.35730341f, 0.10786840f, 0.00179974f, -0.03846684f, 0.01894128f, 
    -0.03476655f, -0.07451472f, -0.08433986f, -0.23257656f, -1.05462444f, -0.61216253f, -0.26312247f, 0.17675272f, 
    -0.14663701f, 0.10798173f, -0.05265351f, -0.20403334f, -0.03098182f, -0.08429605f, 0.05540569f, 0.00330547f, 
    0.37416947f, 0.31607005f, 0.15080875f, 0.58085310f, 0.04560876f, 0.11350704f, 0.10769177f, 0.01421017f, 
    0.18802272f, 0.03797235f, -0.13631527f, 0.01712740f, 0.41753584f, 0.23914203f, 0.33881450f, 0.15181841f, 
    -0.09184150f, -0.36790112f, -0.19066615f, 0.22396342f, -0.03863480f, 0.04328072f, -0.18184559f, -0.04589626f, 
    -0.50470930f, 0.39736247f, -0.06652603f, -0.18339466f, 0.02519255f, 0.00723516f, -0.11300332f, 0.25808403f, 
    -0.00057023f, -0.35737571f, 0.01291512f, -0.14403777f, -0.32448637f, -0.49128094f, -0.19048041f, 0.04038128f, 
    -0.15292199f, -0.14903949f, -0.05836802f, 0.23536210f, -0.00544457f, 0.24282134f, -0.23173541f, -0.20641221f, 
    -0.30451596f, 0.65815067f, 0.25649554f, -0.24583471f, 0.04707752f, 0.09024651f, 0.01242766f, 0.12992686f, 
    -0.02251935f, 0.01933864f, -0.02264058f, 0.06328399f, -0.18645599f, 0.01791739f, -0.03923389f, -0.22268552f, 
    -0.05540956f, -0.24415320f, -0.00778596f, 0.02944629f, -0.15255876f, 0.03453081f, -0.08986516f, 0.08132327f, 
    -1.20335853f, -0.93493009f, 0.43433505f, -0.20014957f, -0.05712277f, 0.06084779f, 0.05378994f, -0.09350996f, 
    0.04687323f, -0.27981547f, 0.05700105f, -0.07237896f, -0.28994709f, -0.15914795f, 0.26003152f, -0.02696406f, 
    0.06589287f, -0.04034144f, 0.02441438f, -0.06914651f, -0.12584141f, 0.11983595f, -0.18261822f, 0.07226362f, 
    0.06748234f, -0.09621213f, 0.00282765f, 0.15997487f, -0.14602754f, 0.06554914f, 0.16345832f, -0.10105187f, 
    -0.09245203f, -0.00343921f, 0.04291524f, 0.02487467f, -0.29722530f, -0.24382640f, -0.02690476f, 0.53433365f, 
    0.15815088f, -0.04171451f, -0.21291000f, 0.00664922f, -0.09042847f, 0.26807678f, 0.09593818f, 0.02071728f, 
    -0.54105508f, 0.67823279f, 0.29829037f, -0.18093556f, 0.12244698f, 0.00979945f, -0.03964004f, -0.03844641f, 
    -0.12941405f, -0.09761651f, -0.05254473f, -0.09326042f, -0.10943587f, 0.13105506f, 0.02246991f, -0.10472249f, 
    -0.12280518f, -0.00078302f, -0.04273205f, -0.20700286f, 0.17175826f, 0.19125845f, -0.15215483f, 0.01613227f, 
    0.00854591f, 0.07730880f, -0.21007322f, 0.38566834f, 0.13667366f, 0.16512896f, 0.01671006f, 0.35929397f, 
    0.17065999f, 0.05703036f, -0.08590839f, 0.02275450f, -0.57188070f, -0.39318979f, 0.72744262f, 0.06144173f, 
    0.12946762f, -0.17741163f, -0.06368778f, -0.21195577f, 0.18441406f, -0.05696744f, -0.06005723f, -0.09870531f, 
    -0.35633644f, 0.11584300f, 0.34418717f, -0.27865991f, -0.16927478f, -0.03579375f, -0.10852513f, 0.00541605f, 
    0.23998733f, -0.26579273f, -0.15544774f, -0.00194619f, -0.57221854f, 0.32400933f, 0.09475960f, 0.17057364f, 
    0.00548880f, -0.05000763f, 0.14361446f, 0.09349341f, 0.07501125f, 0.12747522f, 0.00365011f, -0.02791388f, 
    -0.11054450f, -0.38501781f, -0.26969388f, 0.46380201f, -0.18213139f, 0.08998961f, 0.27607936f, -0.00919421f, 
    0.10845020f, -0.14187102f, 0.01724306f, 0.15901193f, -0.13990179f, -0.27098432f, -0.01111449f, -0.11867358f, 
    0.04860709f, 0.00636378f, 0.17121799f, 0.33163711f, -0.16542119f, 0.12281913f, 0.21086310f, 0.06320655f, 
    -0.30117244f, -0.22349299f, -0.19294952f, -0.02040380f, 0.13380584f, 0.13589448f, -0.05479892f, 0.13061048f, 
    -0.05643963f, -0.17798729f, -0.05788216f, 0.03157349f, -0.01217837f, -0.45178017f, 0.22980830f, -0.30089754f, 
    -0.12954614f, 0.21721350f, -0.11159455f, 0.02939397f, 0.07584526f, -0.01724681f, 0.10134207f, -0.08014721f, 
    0.50835836f, 0.44763181f, -0.16900112f, -0.13287568f, -0.18872796f, -0.19996449f, 0.22276929f, -0.23458071f, 
    -0.05228795f, -0.16920644f, -0.11373018f, -0.10793862f, -0.07175445f, -0.15968837f, -0.14853907f, 0.32900363f, 
    -0.17794083f, 0.01956753f, 0.05474992f, -0.07982885f, 0.28746542f, 0.02305906f, -0.03247694f, -0.06350607f, 
    0.64233840f, -0.00067112f, 0.12744990f, -0.02117503f, 0.05738005f, -0.11316840f, 0.00486027f, 0.02994926f, 
    -0.10711294f, -0.11937223f, 0.01500123f, -0.27119187f, -0.98648512f, 0.15072030f, -0.26806250f, -0.13802887f, 
    0.05268489f, -0.22663629f, 0.08401664f, 0.03875117f, -0.05525852f, 0.08819547f, -0.04351432f, 0.22922021f, 
    0.28048390f, -0.10665324f, 0.04301967f, -0.01203683f, 0.01101862f, -0.25091100f, -0.13033879f, -0.14950706f, 
    0.00088343f, 0.03245866f, -0.05830797f, -0.43602428f, 0.23323464f, 0.27273858f, -0.11395235f, -0.24043651f, 
    -0.10069507f, -0.04820621f, -0.15273952f, -0.10282520f, 0.12705493f, 0.03289275f, -0.22611836f, 0.02217523f, 
    -0.55128360f, -0.22475298f, -0.00438409f, 0.06275184f, 0.14281094f, -0.00995518f, 0.01998657f, 0.10738012f, 
    0.02403990f, -0.01410802f, 0.04231934f, 0.02183216f, 0.03368729f, 0.04785036f, 0.16401690f, 0.44169578f, 
    -0.06470008f, 0.20628856f, 0.05436439f, 0.13139147f, -0.07582157f, -0.19871382f, -0.06201070f, 0.01613236f, 
    -0.35464293f, -0.60925686f, -0.15047224f, 0.13184251f, 0.05595350f, 0.31249806f, -0.15242732f, -0.24974416f, 
    0.00461193f, -0.07458574f, 0.28889900f, 0.02513650f, 0.20499964f, -0.01112505f, -0.11596876f, 0.00172548f, 
    -0.17026813f, -0.05647057f, -0.01966129f, 0.18575029f, -0.01309015f, -0.14392784f, 0.35963705f, 0.32524458f, 
    -0.06374540f, -0.02814501f, -0.03223317f, 0.12950911f, 0.06928536f, 0.22406577f, 0.09422468f, 0.23860563f, 
    -0.00351027f, -0.18514273f, 0.20847809f, -0.15689631f, 0.23034894f, -0.01708371f, 0.19402520f, -0.18623394f, 
    -0.01832641f, -0.02521860f, -0.03126708f, -0.08106736f, -0.00234062f, 0.03604452f, -0.16207963f, 0.01661067f, 
    -0.06797414f, -0.08325078f, -0.24699970f, -0.33988374f, -0.05071655f, -0.15229245f, -0.12986070f, 0.02132262f, 
    -0.17906921f, -0.09698531f, 0.24907836f, 0.11126240f, -0.24135025f, 0.06337937f, -0.35200059f, -0.30371624f, 
    0.34948713f, 0.16644254f, 0.34337905f, 0.03553082f, 0.11611607f, 0.03557394f, -0.21926244f, 0.07617702f, 
    -1.10652697f, -0.14396217f, 0.00212330f, -0.18902197f, -0.17686954f, 0.07290514f, 0.24352026f, -0.23821175f, 
    -0.10572697f, -0.00554358f, 0.10054927f, -0.12833621f, -0.17279984f, 0.30276921f, 0.06530186f, 0.18025611f, 
    -0.06714528f, 0.03337760f, 0.21947360f, -0.08022973f, 0.07795496f, -0.11836638f, 0.08511171f, 0.17554434f, 
    -0.35745364f, -0.37266058f, 0.21318819f, 0.50185245f, -0.05790129f, -0.08978257f, -0.02476577f, 0.14121510f, 
    0.16177580f, 0.20892364f, -0.02482642f, 0.03376546f, -0.46718833f, -0.32253420f, -0.13956124f, -0.29860410f, 
    0.02861273f, 0.09306458f, -0.05302687f, -0.24146928f, -0.07902778f, 0.15208596f, 0.10794630f, -0.07497786f, 
    -0.04812507f, -0.00662712f, 0.34298879f, -0.05141947f, -0.07340525f, 0.16345306f, 0.09504899f, -0.07348492f, 
    0.18392593f, 0.01583118f, 0.23925528f, 0.04922765f, -0.50708413f, 0.35166487f, 0.22653696f, -0.42598692f, 
    0.20187785f, 0.01052844f, 0.04809024f, 0.07829809f, -0.04042339f, -0.22279216f, 0.14159061f, -0.13217764f, 
    -0.86992520f, 0.08267753f, 0.10123637f, 0.34703597f, -0.03116215f, 0.28407797f, 0.23846559f, 0.15684788f, 
    -0.01563346f, -0.03952099f, 0.16813396f, 0.14594235f, 0.10606163f, -0.28897494f, -0.25411525f, 0.30340526f, 
    -0.12305114f, 0.17699978f, 0.30881438f, -0.44417676f, 0.10984115f, 0.11499651f, 0.01892584f, 0.17682284f, 
    0.09374673f, 0.16051084f, 0.04073842f, -0.08862008f, -0.08571726f, -0.00744252f, 0.04832462f, -0.17865215f, 
    0.00798400f, -0.07346112f, 0.16062997f, -0.19742948f, -0.15549004f, -0.03657036f, 0.07373848f, 0.00682222f, 
    0.17970906f, 0.02067417f, -0.02665299f, -0.08498140f, 0.15956691f, 0.13593848f, -0.11944504f, 0.05156499f, 
    -0.12556612f, -0.12326628f, 0.06026360f, -0.23146482f, -0.09464828f, -0.16781402f, 0.13729766f, 0.20560628f, 
    0.07834610f, -0.01519832f, -0.27695000f, -0.04976703f, 0.34092644f, 0.10618154f, -0.19770405f, -0.51983112f, 
    0.09223795f, -0.00613216f, -0.07779925f, -0.11902314f, -0.12680160f, -0.01583423f, -0.30174288f, -0.10167939f, 
    -0.06248124f, 0.24568105f, 0.13406351f, 0.15844741f, -0.03521979f, -0.03245343f, 0.06846634f, 0.09671979f, 
    -0.06890839f, 0.20215960f, 0.00027588f, 0.29633465f, 0.05244494f, 0.38911435f, 0.10626677f, -0.38149086f, 
    -0.10797235f, -0.02099827f, 0.09709559f, 0.21133041f, -0.21841818f, 0.14757155f, 0.15518919f, 0.04178338f, 
    0.36643985f, 0.17444813f, 0.03198906f, -0.40260562f, -0.10696429f, 0.15891829f, 0.17865424f, 0.19362052f, 
    0.10161569f, -0.17071666f, -0.23526177f, 0.16792804f, 0.19211915f, -0.21516939f, -0.17103954f, -0.60340202f, 
    -0.16106792f, -0.11209446f, 0.03998194f, -0.14134479f, -0.10413079f, 0.05712000f, 0.36195695f, -0.08321475f, 
    0.62952793f, -0.22878408f, 0.29149902f, 0.03743777f, -0.20461437f, 0.10678560f, 0.02968450f, -0.10604119f, 
    -0.13016304f, 0.10399779f, 0.01482441f, 0.13048090f, -0.14298989f, -0.03271897f, -0.26489151f, 0.67763853f, 
    -0.06947016f, 0.10265855f, -0.07954191f, 0.07864379f, 0.10725436f, -0.04963849f, -0.19594961f, -0.26679364f, 
    -0.06876006f, -0.35349631f, -0.25176710f, 0.15301484f, 0.05760535f, -0.06697590f, -0.05587538f, -0.05323316f, 
    -0.17572799f, 0.04088243f, -0.13734388f, 0.03815757f, -0.95639086f, -0.21990214f, -0.00666070f, -0.30515000f, 
    0.09678820f, 0.13928100f, 0.01783505f, -0.01207320f, -0.10685331f, -0.08310501f, -0.03829769f, -0.00735009f, 
    -0.09481429f, 0.29948735f, 0.16755323f, -0.46609658f, -0.00727710f, -0.12228265f, -0.06477215f, 0.09884685f, 
    0.06991409f, -0.10618816f, -0.25905949f, -0.29053164f, 0.51847410f, -1.02343786f, -0.04829160f, -0.05886578f, 
    0.03732795f, 0.08346927f, 0.08474262f, -0.01652406f, 0.13357474f, 0.13023308f, -0.00926884f, 0.10064889f, 
    0.04512879f, 0.09066682f, -0.31894752f, 0.07984590f, -0.09916674f, 0.13877885f, -0.21236986f, -0.02732470f, 
    -0.07738207f, -0.06030210f, 0.11450691f, -0.10008094f, 0.23715398f, 0.28854564f, 0.14766197f, 0.25581354f, 
    0.18919428f, -0.01261655f, 0.27252153f, -0.00541904f, 0.11569452f, 0.15960349f, -0.13806477f, -0.24303684f, 
    -0.10483845f, 0.07534496f, 0.48500571f, -0.15018091f, -0.17909995f, -0.15894924f, -0.12136601f, 0.17445253f, 
    -0.23799579f, -0.12929767f, -0.04915662f, 0.00120106f, -0.13776229f, -0.60097969f, 0.27747226f, 0.28152648f, 
    -0.05035469f, -0.01360837f, -0.05282826f, 0.03560137f, 0.00850023f, -0.09488704f, 0.06731757f, -0.05854536f, 
    0.41717267f, 0.35544428f, 0.18459852f, 0.03043124f, 0.22799820f, 0.13510841f, 0.05893354f, -0.14123245f, 
    -0.02415502f, 0.04311536f, -0.20012532f, -0.11124596f, 0.34206936f, -0.25152460f, 0.01254025f, 0.16712134f, 
    -0.21428852f, -0.17584707f, -0.01031827f, -0.07481457f, 0.00827403f, -0.15649582f, -0.08599067f, -0.24320014f, 
    -0.47681487f, -0.11546861f, -0.41451412f, -0.20083758f, -0.09580118f, -0.18716268f, 0.04704824f, -0.16769828f, 
    -0.30846775f, -0.01264938f, -0.11603758f, 0.02925231f, -0.11591371f, -0.24169374f, -0.21407282f, -0.63694936f, 
    0.03036648f, 0.03840045f, -0.02304506f, -0.10375470f, -0.19539401f, -0.11740950f, 0.03921208f, -0.17192502f, 
    -0.10778008f, 0.14672711f, -0.02792658f, 0.15714072f, 0.00758618f, -0.08249439f, -0.17737900f, -0.01665721f, 
    -0.18232810f, -0.06758727f, -0.04598970f, -0.14366567f, 0.37715486f, 0.11932451f, 0.54904735f, 0.21365021f, 
    0.11684044f, 0.28239077f, 0.10849927f, -0.09967992f, -0.10393317f, 0.17825596f, -0.02815808f, -0.10404730f, 
    0.17126819f, 0.05930143f, 0.21337052f, 0.07401696f, 0.32268837f, -0.22323410f, 0.11789772f, 0.00606520f, 
    -0.13504803f, 0.20243570f, 0.20539498f, 0.04612326f, -0.46108735f, -0.40321705f, -0.35208881f, 0.03771969f, 
    0.14050446f, -0.14090808f, -0.08355445f, 0.07196961f, 0.04059891f, -0.06352326f, -0.03011765f, -0.09253013f, 
    0.68066424f, -0.35477361f, 0.54071176f, 0.31039292f, 0.27219576f, -0.05342703f, -0.08793807f, -0.20642255f, 
    -0.15193383f, -0.31500784f, -0.15527828f, -0.15511148f, -0.32600608f, -0.00951977f, 0.25531340f, 0.00001925f, 
    0.19579172f, -0.00642672f, -0.01995707f, -0.09724545f, -0.02938397f, 0.05446673f, -0.00162953f, -0.05541155f, 
    -0.16877100f, -0.00251369f, -0.21761818f, 0.04025723f, -0.17021383f, -0.01778740f, -0.00230552f, -0.13215975f, 
    0.07010277f, 0.00543726f, -0.03824246f, -0.28816089f, 0.34417951f, -0.66397285f, 0.06383546f, -0.35853827f, 
    -0.06455808f, 0.12540132f, 0.00181302f, -0.12648201f, -0.01881168f, 0.04410882f, -0.21465215f, -0.00225573f, 
    0.18214504f, 0.05452289f, -0.16692026f, 0.05397230f, -0.03270526f, -0.21768759f, -0.30901754f, -0.12061150f, 
    0.09040554f, 0.11772463f, 0.10551853f, -0.12884672f, -0.00985200f, 0.19684158f, 0.30717003f, 0.17940287f, 
    -0.23058587f, 0.03411207f, 0.04838416f, -0.01494667f, -0.00447059f, -0.27002254f, 0.06913439f, 0.09135398f, 
    0.13401276f, 0.09420557f, 0.07044679f, 0.09571903f, -0.31573305f, -0.00739409f, -0.23251939f, -0.01979377f, 
    0.09898151f, 0.13022977f, 0.09606754f, 0.22711450f, 0.05068209f, -0.64194620f, -0.67163515f, -0.01055429f, 
    0.06983431f, -0.08460434f, -0.00258565f, 0.02437251f, -0.07038569f, -0.02746758f, 0.26090404f, -0.07686228f, 
    -0.68920326f, 0.04748442f, 0.16984703f, -0.42607668f, 0.20593667f, -0.15385868f, -0.14467862f, 0.04249419f, 
    0.01005041f, -0.00041203f, 0.22786833f, -0.13629472f, -0.50716162f, -0.29990089f, -0.52993214f, -0.48851112f, 
    -0.18250316f, 0.05841604f, 0.07388846f, -0.44366971f, 0.15848163f, 0.03099025f, 0.12393383f, 0.04157159f, 
    -0.04744511f, 0.11979768f, 0.09980029f, 0.15629803f, 0.19876014f, 0.08720607f, -0.04103637f, 0.08314870f, 
    0.06447218f, 0.13050778f, 0.01343079f, 0.05907174f, 0.16321051f, -0.01632064f, -0.24034333f, 0.42534187f, 
    0.19543457f, -0.08213286f, -0.08811935f, -0.17002088f, 0.01753554f, -0.16641444f, 0.14671807f, -0.20494680f, 
    -0.48081940f, 0.16063894f, -0.33285898f, -0.20068896f, -0.04696115f, -0.25251701f, -0.18740708f, -0.08306742f, 
    0.12928946f, -0.07535417f, 0.03966994f, -0.14988773f, -0.36761767f, -0.31950673f, 0.09484965f, -0.31751224f, 
    0.32101762f, 0.08992347f, 0.17948474f, -0.28832138f, 0.08106680f, -0.14824009f, -0.26801530f, 0.26521352f, 
    0.08208178f, -0.24787325f, 0.21510310f, 0.08742552f, 0.06110550f, -0.24154404f, -0.02466257f, 0.02459563f, 
    0.02253178f, -0.09181823f, -0.03106827f, -0.14485361f, 0.42267537f, 0.64919114f, -0.62745243f, -0.14332369f, 
    0.06580877f, 0.04462881f, -0.15731843f, -0.04104378f, 0.12581904f, -0.11098204f, 0.04293271f, 0.26645556f, 
    0.17915817f, 0.27684659f, -0.27138704f, -0.30790153f, 0.05701927f, -0.04804177f, 0.06100750f, -0.00409660f, 
    -0.05607401f, 0.09073937f, -0.05963684f, 0.04387206f, -0.24625777f, 0.11705980f, 0.22488844f, 0.16549453f, 
    -0.24802542f, 0.01157792f, -0.06511130f, -0.17212455f, 0.11950281f, -0.08524965f, 0.03407473f, -0.10838921f, 
    -0.01302272f, -0.09748684f, -0.04689834f, 0.42635038f, 0.02971539f, 0.01509108f, -0.15075128f, 0.00944582f, 
    0.14272664f, 0.00259246f, 0.19411576f, 0.19722882f, 0.37873006f, -0.06626306f, 0.05150929f, 0.24885723f, 
    -0.17716476f, -0.05918587f, 0.01149021f, -0.19401361f, -0.10576241f, -0.15665396f, 0.10460037f, -0.07743014f, 
    -0.26833937f, 0.45319119f, 0.32173020f, 0.16348389f, 0.06723073f, 0.19097389f, -0.04991818f, 0.04144325f, 
    0.08516926f, 0.01143716f, -0.00241073f, 0.21287748f, -0.34447598f, -0.19171007f, 0.32081264f, -0.21245208f, 
    0.10939842f, 0.07927578f, 0.01324215f, 0.34531072f, 0.09904980f, -0.07563989f, -0.06077369f, 0.03706072f, 
    -0.70862550f, -0.47175357f, 0.16955653f, -0.06986605f, 0.16615269f, 0.23307815f, 0.00849355f, -0.20544797f, 
    0.06598413f, 0.06617752f, -0.22729158f, -0.22046113f, -0.19943272f, -0.36172846f, 0.02108778f, -0.52684063f, 
    -0.15936494f, 0.10720853f, -0.27259713f, 0.07444327f, -0.17759396f, 0.03189242f, 0.15463370f, 0.21092701f, 
    0.16567928f, -0.39869228f, -0.08316061f, 0.28204155f, 0.11681353f, 0.05808947f, -0.18705691f, 0.15323232f, 
    -0.01548583f, 0.11303350f, -0.45372990f, 0.06160312f, -0.13199075f, 0.15261945f, -0.30208033f, -0.50485975f, 
    -0.06603447f, 0.01483177f, -0.09293120f, -0.01110901f, -0.04415250f, -0.00444533f, -0.06338938f, -0.02189760f, 
    -0.03162386f, 0.28066751f, 0.43033171f, -0.25214496f, 0.10760207f, -0.03532743f, -0.16692351f, -0.02728543f, 
    -0.27267319f, 0.13540116f, 0.04295937f, -0.25100330f, -0.12004120f, -0.07078324f, 0.44185042f, -0.36999354f, 
    0.16854113f, 0.06430973f, -0.23694101f, 0.03077606f, 0.14452353f, -0.11398414f, 0.12066997f, 0.07536060f, 
    -0.49274081f, 0.35519931f, -0.09424209f, -0.06902939f, -0.16362253f, 0.23743270f, 0.06135019f, -0.35082144f, 
    0.01746861f, 0.32894617f, -0.10221603f, -0.05589761f, 0.43716192f, -0.03653176f, -0.18565294f, 0.41523600f, 
    -0.17810172f, 0.01303002f, -0.03474319f, -0.00617889f, -0.34847811f, 0.01460538f, 0.19182639f, -0.07601368f, 
    0.13899548f, -0.39525762f, -0.10238029f, 0.15965202f, 0.11882712f, -0.17363125f, -0.05241403f, -0.04228168f, 
    0.12792578f, 0.13995829f, 0.03284696f, 0.03801174f, 0.35454667f, 0.06377060f, 0.41750887f, 0.22339097f, 
    -0.07757550f, 0.26229402f, -0.00092342f, 0.13931276f, -0.15234488f, 0.10643552f, 0.07117970f, -0.07306752f, 
    0.42821214f, -1.01005733f, 0.38924059f, -0.12174895f, 0.10754377f, -0.04649939f, -0.00295855f, 0.02259373f, 
    -0.17763448f, -0.25263032f, 0.20198317f, 0.18060669f, 0.70751500f, -0.98858887f, 0.06603166f, 0.17614126f, 
    -0.08531483f, -0.07746189f, -0.14911067f, 0.15744859f, -0.34173682f, 0.00061292f, -0.08364242f, -0.08859701f, 
    -0.11319512f, 0.22219364f, -0.95707297f, -0.04003014f, 0.12759827f, 0.00500491f, 0.19630514f, 0.01756733f, 
    -0.32239637f, -0.12189742f, -0.33909127f, -0.10748387f, 0.56168646f, 0.08200045f, -0.48433739f, -0.11921256f, 
    0.08302632f, 0.03856194f, 0.00713533f, -0.00216776f, 0.03331333f, 0.04775295f, -0.10752103f, 0.07264627f, 
    -1.12930727f, -0.87582690f, 0.18816583f, -0.12820567f, 0.19703120f, 0.11823437f, 0.00234501f, -0.23945913f, 
    0.05190723f, -0.11572035f, -0.16571459f, -0.10767620f, 0.14949362f, 0.15162081f, -0.32158750f, -0.00414202f, 
    -0.26390046f, -0.05744901f, 0.00522347f, 0.04081101f, 0.09196077f, -0.30058184f, 0.20821020f, -0.02708603f, 
    0.20145331f, 0.14330909f, -0.18383922f, 0.12023821f, 0.12611426f, -0.14748925f, 0.11504155f, 0.16478311f, 
    0.26422352f, 0.32519066f, 0.30546677f, 0.13454199f, -0.44964615f, -0.27444878f, 0.21814482f, -0.11369754f, 
    0.22412632f, 0.10691068f, 0.01490502f, 0.26124939f, -0.15443218f, -0.00508431f, -0.34201437f, -0.22335225f, 
    0.24266000f, 0.32175428f, 0.15724081f, -0.19097520f, 0.08789761f, 0.05144311f, -0.12138823f, -0.13394673f, 
    -0.08953914f, 0.05023302f, 0.15022197f, -0.28036842f, 0.48967481f, 0.51450545f, 0.19287845f, -0.12674563f, 
    0.06495579f, 0.16484818f, 0.00482842f, 0.28732872f, 0.03160023f, 0.15954390f, 0.05535510f, 0.18089081f, 
    -0.66274279f, -0.15281041f, 0.01037687f, 0.01780118f, 0.14938168f, -0.00426675f, -0.09229461f, -0.00968436f, 
    0.08758175f, 0.10500774f, 0.15084031f, 0.03086490f, -0.76882416f, -0.55026138f, -0.54443216f, -0.56092829f, 
    0.30869901f, 0.11475743f, -0.28078440f, 0.00586072f, 0.15937425f, -0.03968824f, -0.03352949f, 0.09788523f, 
    -0.08345407f, -0.03492024f, -0.14487630f, -0.31386858f, 0.10782599f, -0.22147050f, -0.11415613f, 0.11114695f, 
    0.02579901f, -0.09033860f, 0.12973665f, 0.02191304f, -0.09589969f, -0.02724110f, 0.07222917f, -0.01772553f, 
    0.08098695f, 0.25580776f, -0.02522767f, -0.09886812f, 0.09592338f, -0.22093707f, 0.07335348f, -0.01652160f, 
    0.21174996f, 0.13296194f, -0.21413447f, 0.24732569f, -0.36937752f, -0.06024064f, 0.11290088f, 0.10676868f, 
    -0.09485030f, 0.23135628f, -0.05059325f, 0.02197160f, -0.62435097f, -0.44784477f, -0.00358067f, 0.16604976f, 
    0.25292879f, -0.17167200f, -0.06111787f, -0.08883977f, 0.04462076f, -0.16653714f, 0.09033167f, 0.19029471f, 
    -0.66314739f, 0.28814340f, -0.22813836f, -0.12715119f, 0.04080309f, 0.08152622f, -0.00036184f, -0.04730086f, 
    0.03696320f, 0.12480522f, -0.01727030f, 0.21955530f, 0.28462082f, 0.07917140f, 0.09031180f, -0.00086952f, 
    -0.08065330f, 0.16613087f, -0.04485812f, 0.00331705f, 0.13358176f, 0.10809357f, 0.06538377f, -0.11094042f, 
    -0.83106714f, -0.31805500f, -0.60283571f, -0.27716026f, -0.22436002f, -0.18525887f, -0.27356115f, 0.00142482f, 
    0.07698490f, 0.39807659f, 0.19254185f, 0.13269155f, 0.36299855f, 0.17972946f, -0.11713026f, 0.26987395f, 
    -0.13124235f, -0.13744356f, -0.11897297f, 0.21542658f, -0.10169403f, -0.04895672f, 0.00077342f, -0.11803330f, 
    -0.37916562f, 0.31701905f, -0.12104142f, 0.00187726f, 0.15214361f, 0.07621520f, -0.23265648f, 0.08806585f, 
    0.25868717f, -0.03410585f, 0.03148713f, -0.03327926f, -0.16303799f, -0.12891409f, -0.02302104f, 0.05959610f, 
    0.03298670f, 0.22998419f, 0.03067858f, -0.16570118f, -0.07667846f, -0.09575060f, -0.17003791f, -0.35313761f, 
    0.36048770f, 0.34044254f, -0.12202463f, -0.07297017f, 0.01747573f, 0.05756150f, 0.05812050f, 0.00362944f, 
    -0.12406392f, -0.26633874f, -0.26737809f, -0.24250655f, 0.13317373f, 0.08791389f, -0.21067539f, 0.50191718f, 
    -0.00105185f, -0.32291582f, 0.05506671f, -0.23299117f, -0.00088761f, -0.05194512f, -0.21564387f, -0.10182571f, 
    0.36541283f, 0.43066779f, -0.20805863f, 0.06673550f, -0.12536718f, -0.35815778f, -0.09967346f, -0.35191226f, 
    0.24549909f, 0.20118289f, -0.00529830f, -0.01346806f, 0.09416284f, 0.07323072f, -0.27320492f, 0.27523705f, 
    0.11819851f, -0.13849109f, 0.26393968f, 0.20253180f, -0.23480906f, -0.04308895f, -0.15760383f, 0.05794526f, 
    1.06040454f, -0.15400402f, -0.25996414f, -0.21899238f, -0.03218605f, -0.22413298f, -0.07273049f, -0.29417735f, 
    0.16976589f, 0.17179906f, -0.05774505f, 0.15644114f, 0.39061454f, 0.00999006f, -0.63265473f, -0.57020366f, 
    -0.19423130f, -0.15650883f, -0.04014540f, 0.19003057f, 0.02723640f, 0.05262524f, -0.05820227f, 0.10570323f, 
    -0.12959926f, 0.38293776f, -0.42653072f, 0.20874003f, 0.25333878f, -0.19126344f, -0.18279301f, -0.19606805f, 
    0.13124026f, 0.14950438f, -0.18292513f, 0.12420306f, -0.59222388f, 0.48904902f, -0.01809159f, -0.19172093f, 
    -0.31343246f, -0.36830547f, -0.11671982f, -0.15814400f, 0.02347356f, 0.24209489f, 0.19138896f, 0.00829964f, 
    -0.33564472f, -0.26017064f, -0.10957523f, -0.02791170f, 0.02856198f, 0.07032012f, 0.03087944f, 0.13281734f, 
    -0.24403057f, 0.05617717f, -0.09185091f, 0.20606324f, 0.46332207f, -0.47528371f, -0.07499678f, 0.22181724f, 
    -0.07840196f, -0.21723056f, 0.16162317f, -0.15708497f, 0.13902439f, 0.12657286f, 0.03442337f, 0.00860045f, 
    -0.20199917f, 0.23727442f, -0.13545325f, 0.26359469f, -0.23611607f, 0.05759428f, -0.12591809f, 0.12891057f, 
    0.01602426f, 0.04290508f, 0.29151291f, 0.07930697f, -0.06761948f, 0.27872962f, -0.23695236f, 0.11104234f, 
    0.13512658f, -0.10588236f, 0.00560265f, 0.10670120f, 0.04821641f, 0.01076163f, -0.05080793f, -0.13697347f, 
    -0.20738436f, -0.01134643f, -0.03228403f, 0.07006539f, 0.31811112f, 0.05146576f, 0.01824435f, 0.03361479f, 
    0.04683967f, 0.06741214f, -0.08225688f, -0.08360938f, -0.49112773f, -0.17442615f, 0.11737020f, -0.03321625f, 
    0.07772259f, 0.02248795f, -0.01775820f, -0.09722038f, -0.04901557f, -0.12794286f, 0.02767401f, 0.15618692f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09493013f, 0.04285183f, -0.12099284f, -0.04943392f, -0.04190883f, 0.03159771f, 0.10358731f, -0.17310071f, 
    -0.02043965f, 0.07784650f, 0.28575525f, 0.02890243f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
