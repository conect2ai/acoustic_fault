#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.54990673f, -0.24226591f, -0.12473378f, -0.57229304f, -0.11174221f, -0.79374951f, -0.16444634f, 0.40672782f, 
    -0.01682706f, -0.51919687f, -0.57859063f, -0.63353741f, 0.40245157f, -0.37579319f, 0.13600352f, -0.45807844f, 
    -0.07426804f, -0.17744693f, 0.00277451f, 0.24208155f, 0.48750168f, 0.42798790f, 0.29741374f, 0.02665585f, 
    -0.05424351f, -0.45171821f, 0.05321712f, -0.28289142f, -0.67782444f, -0.11615476f, -0.65612096f, -0.17408694f, 
    -0.22734949f, 0.12974881f, -0.51648456f, -0.34477401f, 0.49427709f, 0.34746829f, 0.60591793f, 0.38536367f, 
    -0.52120835f, 0.34914073f, 0.00265267f, 0.10631842f, -0.35970920f, 0.23222069f, 0.73293549f, -0.64148587f, 
    0.77179277f, -0.22072011f, -0.20606638f, -0.24650183f, -0.23977165f, 0.11517851f, 0.75001627f, 0.55778474f, 
    0.13505712f, -0.13732018f, 0.26220110f, -0.37030298f, 0.17537862f, 0.39387175f, -0.34149483f, 0.00327279f, 
    0.38232175f, 0.47004548f, -0.57228684f, -0.25833482f, -0.84679770f, 0.17687507f, 0.45145175f, 0.24567614f, 
    -0.02219887f, 0.68654543f, -0.77553374f, -0.32409939f, -0.57575756f, 0.00188460f, 0.15579253f, 0.04874418f, 
    0.38725889f, -0.35623631f, 0.05377587f, -0.55213410f, 0.61900616f, 0.21717714f, -0.20681715f, -0.25891134f, 
    0.56067204f, 0.39144295f, -0.81365514f, 0.27952608f, 0.28867003f, 0.50649869f, 0.74544072f, -0.41375878f, 
    0.30311349f, 0.32034579f, 0.01587377f, -0.57293355f, -0.42367128f, 0.05226248f, 0.58490103f, 0.09504116f, 
    0.62703609f, 0.47078323f, 0.14854346f, 0.30274284f, -0.83813435f, -0.29581568f, -0.25987938f, 0.62351972f, 
    0.92062289f, 0.36806294f, -0.05641645f, -0.29773533f, 0.07861824f, 0.45068702f, 0.03870385f, 0.10097776f, 
    -0.29374051f, 0.20504072f, 0.54615504f, 0.13486476f, 0.29023957f, 0.25942552f, 0.26264569f, -0.54708463f, 
    0.54161131f, 0.04029701f, 0.19154847f, 0.36475137f, -0.34396055f, -0.20402342f, -0.02838846f, -0.57140392f, 
    0.56132728f, -0.14637680f, 0.26925051f, 0.57345247f, 0.24270587f, -0.42438027f, -0.07228377f, 0.18901214f, 
    -0.68051112f, 0.14175554f, -0.38594040f, -0.51318949f, -0.05132893f, -0.58947873f, -0.09948719f, 0.50283343f, 
    -0.07247268f, 0.81152970f, 0.02159915f, 0.63163179f, -0.40246502f, 0.38459238f, -0.34778795f, 0.17792571f, 
    0.07568583f, 0.22847308f, -0.10989735f, -0.58775181f, 0.19915414f, -0.25747895f, -1.02590358f, 0.46979609f, 
    -0.06033085f, 0.21616401f, 0.15245004f, 0.86422271f, -0.23689114f, 0.47606280f, 0.11701651f, 0.16718404f, 
    0.51809877f, -0.08197609f, -0.45505732f, -0.41738671f, 0.23494996f, 0.16624230f, 0.54043031f, 0.16850913f, 
    -0.12441810f, 0.33504811f, 0.52234101f, -0.54622024f, -0.08291882f, 0.24798462f, -0.72438651f, -0.51533806f, 
    0.30600002f, -0.63033873f, -0.34431615f, -0.28049105f, -0.12564406f, 0.17082496f, -0.26274428f, -0.43583122f, 
    -0.14324856f, -0.07335429f, 0.54830402f, 0.30742750f, -0.24698485f, 0.34060979f, -0.65281779f, 0.43785667f, 
    0.75926828f, 0.70740968f, -0.18281123f, -0.01088654f, -0.41855934f, -0.15582182f, -0.27771538f, -0.07188927f, 
    -0.69952685f, -0.45361128f, -0.78098959f, -0.42019957f, -0.04896067f, 0.55904239f, -0.13580382f, -0.27146992f, 
    0.24362399f, 0.50661129f, -0.67253536f, -0.68600190f, 0.09528098f, 0.56267720f, 0.46398720f, 0.11634636f, 
    0.24055584f, 0.00014187f, -0.35100633f, -0.59485143f, -0.07173064f, -0.66895235f, 0.63344061f, 0.09188437f, 
    0.26949987f, 0.19553795f, 0.12343847f, -0.64556611f, 0.24584042f, -0.08226852f, 0.43302542f, -0.34950358f, 
    -0.60938430f, 0.01462928f, -0.31777689f, -0.32893527f, 0.53544718f, 0.22395507f, -0.28974947f, -0.70966113f, 
    -0.57442033f, -0.53724980f, 0.25053108f, -0.38424402f, 0.11902536f, -0.13477503f, -0.49279690f, 0.53509361f, 
    0.27128181f, 0.25267377f, -0.72799498f, -0.20079169f, -0.23035401f, 0.15593386f, -0.52824152f, -0.24681416f, 
    0.37007487f, 0.44815049f, -0.56644744f, 0.31029099f, 0.06819249f, -0.08300047f, -0.10526185f, 0.59173834f, 
    0.44755659f, 0.34859073f, 0.09822382f, -0.07272008f, 0.27819526f, -0.15469410f, 0.43613315f, 0.19023609f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14708278f, -0.21188663f, -0.14103349f, -0.05571062f, 0.06201535f, -0.33694133f, -0.19401675f, -0.06346128f, 
    -0.21335003f, -0.14037566f, 0.19952232f, -0.09240545f, -0.28324565f, 0.20265199f, 0.22430730f, -0.09808710f, 
    -0.00922588f, -0.23897320f, 0.03550743f, -0.18627404f, -0.16828381f, 0.26877710f, -0.28942508f, 0.33624199f, 
    -0.22615132f, 0.14796773f, 0.06484039f, -0.20434812f, 0.03119913f, -0.24806112f, -0.05435997f, 0.35608569f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.01082553f, -0.04747192f, -0.05236288f, 0.02947670f, 0.00703748f, -0.04259322f, -0.04773300f, 0.02589725f, 
    -0.00123485f, 0.00788073f, -0.04197227f, -0.01193693f, 0.01697397f, 0.03420511f, 0.01516441f, -0.02547401f, 
    0.05025292f, 0.03676185f, 0.00669334f, 0.01440024f, -0.03949934f, -0.01943434f, 0.01536009f, 0.05396489f, 
    -0.04524304f, -0.03506554f, 0.04342492f, 0.05120406f, 0.01111773f, 0.02232454f, 0.03328419f, 0.01659379f, 
    -0.00303825f, -0.01767522f, 0.00572077f, -0.02967047f, 0.04264856f, -0.05046671f, 0.04497112f, -0.01356045f, 
    0.04443311f, -0.06445811f, -0.04435781f, -0.02205303f, 0.01488770f, 0.05525708f, -0.04659417f, 0.04799976f, 
    -0.01026443f, -0.05692645f, -0.03851020f, -0.02936538f, -0.02543616f, 0.01452510f, 0.04353528f, 0.02387591f, 
    -0.06505883f, -0.06401690f, 0.03007723f, -0.05762732f, 0.03725807f, -0.02142507f, -0.06037772f, 0.02021415f, 
    -0.05990086f, 0.02922172f, -0.03459599f, 0.01160047f, -0.00085531f, 0.03993699f, 0.02653433f, 0.01894881f, 
    0.04223740f, -0.03331896f, -0.05347065f, 0.02120742f, -0.03645329f, -0.00261851f, -0.05610262f, -0.00627305f, 
    0.02918146f, -0.06630443f, -0.04223999f, -0.06059000f, -0.05595445f, -0.02703428f, -0.03012619f, -0.01320805f, 
    -0.02324318f, 0.02192111f, 0.04282311f, -0.02024605f, -0.02275421f, -0.03159341f, -0.01781791f, -0.02273955f, 
    0.00948447f, 0.02800575f, 0.01973986f, 0.00658840f, -0.04120474f, 0.00088694f, -0.02174111f, -0.02961390f, 
    0.04107374f, 0.02107226f, 0.04049151f, -0.01959727f, -0.06446958f, -0.00284725f, -0.05956761f, -0.04202570f, 
    -0.05523213f, 0.03648501f, 0.04973935f, -0.00397119f, -0.01270976f, 0.01292935f, -0.02341093f, -0.01355251f, 
    -0.03135164f, 0.01520781f, -0.03848542f, 0.01003546f, 0.02312293f, 0.01391684f, -0.03182402f, -0.05397559f, 
    0.03403726f, -0.01341181f, 0.04333344f, 0.02148420f, -0.03468124f, 0.03977196f, 0.04742922f, 0.05049697f, 
    -0.04313866f, -0.00252172f, 0.04783043f, 0.01408879f, 0.03700896f, 0.04137941f, -0.01970165f, 0.03455712f, 
    -0.06709470f, 0.05156623f, -0.01910952f, -0.05896829f, 0.00130852f, -0.06297150f, 0.04200029f, 0.04373547f, 
    -0.00570186f, -0.00627367f, 0.04498581f, 0.03443953f, -0.01356638f, -0.03411024f, -0.02967723f, 0.02618018f, 
    -0.04797539f, -0.06591224f, 0.00741980f, -0.03317807f, 0.03648868f, -0.04359576f, 0.04255310f, 0.04666289f, 
    0.00840395f, 0.03673146f, 0.00930488f, -0.01777749f, 0.03491491f, -0.04140808f, -0.00410675f, 0.01153888f, 
    0.04986492f, -0.04792290f, 0.03532904f, 0.02659404f, 0.03224481f, -0.04110025f, -0.02574103f, -0.02524125f, 
    0.00205682f, -0.03080434f, 0.03624236f, -0.06784874f, -0.06413711f, -0.03859080f, -0.00971615f, 0.03529101f, 
    -0.01661023f, -0.03107266f, -0.06420126f, -0.04952458f, -0.00586509f, -0.04097474f, 0.01911481f, -0.02619809f, 
    0.00808428f, -0.02354540f, -0.00119834f, 0.04843467f, -0.04918237f, -0.02669697f, 0.01689058f, -0.02156310f, 
    -0.01242677f, -0.04816267f, -0.04916131f, 0.01793900f, -0.00884668f, -0.00860195f, -0.04665746f, -0.05896389f, 
    -0.01844819f, -0.00842860f, -0.01867336f, 0.02853430f, 0.02515072f, 0.05006848f, 0.00687990f, -0.04215352f, 
    0.01145902f, -0.03933933f, 0.02685982f, -0.05451991f, -0.01994041f, 0.00611230f, -0.05877526f, -0.03963009f, 
    -0.05480884f, -0.02871109f, -0.03357158f, 0.04635954f, 0.03107736f, 0.02043945f, 0.03608492f, -0.04530285f, 
    -0.00764619f, -0.00688323f, -0.01886013f, -0.03864048f, -0.02101859f, 0.04552032f, -0.01813233f, -0.04174441f, 
    -0.03001948f, 0.01791409f, 0.05056734f, -0.03512578f, -0.02964166f, 0.04496900f, -0.04285744f, -0.04436804f, 
    -0.05618941f, 0.00288244f, 0.03852977f, -0.05481901f, -0.01090282f, -0.06233924f, -0.02258046f, 0.03897804f, 
    -0.05569003f, -0.06362534f, -0.03040048f, -0.00679613f, -0.04554243f, -0.02440813f, -0.06559406f, 0.01308486f, 
    -0.06318577f, 0.00199669f, -0.01924715f, -0.05269539f, 0.04664567f, -0.05363348f, 0.03909660f, 0.00432358f, 
    -0.02612695f, 0.01160250f, -0.05067186f, -0.04525320f, 0.01376402f, 0.01568844f, 0.01190836f, 0.03797299f, 
    0.07736754f, -0.14877425f, -0.12184567f, 0.02518359f, -0.11567374f, -0.05058131f, -0.02724114f, -0.04277843f, 
    -0.05667799f, 0.00442563f, 0.20900275f, 0.16883969f, 0.07933436f, 0.08954386f, 0.00780961f, 0.00803735f, 
    0.06117347f, -0.11035251f, 0.01429841f, -0.13858145f, -0.10480782f, 0.11573207f, -0.08351942f, 0.10163713f, 
    -0.00371404f, 0.14559445f, -0.12313954f, 0.05761757f, 0.15826362f, 0.05038543f, 0.00424478f, 0.09179735f, 
    -0.10719290f, 0.00914183f, 0.03357079f, 0.00577163f, 0.21538417f, 0.00901974f, -0.11490578f, 0.15919404f, 
    -0.00492391f, 0.01323820f, 0.01676408f, -0.14647397f, -0.09183233f, 0.26223052f, 0.00630585f, 0.07538669f, 
    -0.12721324f, -0.14125869f, 0.15706524f, -0.06404630f, -0.05592150f, 0.02478459f, 0.11188875f, -0.04428256f, 
    0.12299672f, -0.00015318f, 0.05203906f, 0.06900179f, -0.05631418f, -0.08304450f, 0.03115349f, 0.09771063f, 
    -0.17999724f, 0.07741574f, 0.03671306f, -0.16766582f, -0.01482512f, 0.06378487f, -0.03912571f, -0.03262495f, 
    0.35696775f, -0.11258348f, -0.08785621f, 0.06400763f, -0.07629500f, 0.00296363f, 0.10317501f, -0.08605196f, 
    -0.10209492f, -0.15118951f, 0.04900733f, 0.10267957f, 0.10129906f, -0.01369727f, 0.02537512f, 0.01177102f, 
    0.04414666f, 0.10188298f, 0.28741792f, 0.01643622f, -0.05497883f, -0.11827934f, -0.02020754f, -0.05565839f, 
    -0.04657393f, -0.08743553f, 0.05165471f, -0.03248703f, 0.07492249f, 0.16304788f, 0.03599785f, -0.14889450f, 
    -0.05550517f, -0.10172093f, -0.00468086f, 0.14331204f, -0.14668122f, 0.01458173f, 0.17913730f, 0.07832621f, 
    0.02229505f, 0.00438044f, -0.15880372f, 0.03241705f, 0.10213363f, -0.09184118f, -0.03617297f, -0.00029198f, 
    0.10674616f, 0.15544713f, 0.07967563f, -0.05270927f, -0.06994503f, 0.13246626f, -0.11779746f, -0.14149506f, 
    -0.17910461f, -0.05004232f, 0.06998204f, -0.07558807f, 0.02774116f, -0.05528923f, -0.01446422f, 0.08135660f, 
    -0.01563827f, -0.02017869f, -0.00994094f, -0.09986769f, 0.04062059f, -0.09428324f, -0.08057038f, 0.02075436f, 
    0.07590836f, -0.03226089f, 0.05869012f, 0.00261629f, -0.03114795f, -0.13622706f, 0.00818543f, -0.10113286f, 
    0.05117663f, -0.06966294f, 0.12441669f, 0.19550483f, 0.09159184f, 0.09912064f, 0.08761032f, -0.03769286f, 
    0.00826782f, 0.01728338f, -0.13645832f, -0.13994297f, -0.04855156f, -0.24156377f, 0.02230654f, -0.14305288f, 
    -0.16287988f, 0.12037125f, -0.07775039f, 0.18976177f, -0.24567127f, 0.06253763f, 0.11372032f, 0.03632278f, 
    0.01694995f, 0.15652031f, -0.07541353f, 0.08136098f, 0.15211836f, -0.04499137f, 0.06285272f, 0.10336401f, 
    -0.06754469f, 0.27856672f, -0.04416550f, -0.01110154f, -0.23397081f, 0.08331303f, 0.12672703f, -0.03598445f, 
    -0.00814773f, 0.04034655f, -0.07967401f, -0.02692905f, 0.01642819f, -0.24342933f, -0.09492407f, 0.19049521f, 
    0.11216664f, -0.06323984f, -0.04626119f, -0.02651501f, -0.25912586f, 0.03657526f, -0.09207920f, -0.16209874f, 
    -0.16878770f, 0.03737087f, 0.06435956f, 0.05615916f, 0.12761185f, 0.10483329f, 0.06974174f, 0.15582465f, 
    0.12910245f, 0.07821609f, 0.03382528f, -0.07135330f, 0.04643871f, -0.02316891f, -0.01431242f, 0.00166602f, 
    -0.10210548f, -0.00746749f, 0.07242545f, 0.05660421f, 0.06750027f, -0.09152932f, -0.01770641f, 0.07483504f, 
    0.11765035f, 0.01158716f, -0.26117715f, 0.01272266f, 0.04488995f, -0.16808967f, -0.05999634f, -0.13028763f, 
    0.04151694f, 0.02625367f, -0.04617320f, 0.21483009f, -0.05360327f, 0.14707272f, -0.09343335f, 0.09069531f, 
    0.00047223f, 0.08298575f, 0.06665181f, 0.01779110f, 0.03907424f, -0.08944586f, -0.01630048f, -0.02733381f, 
    -0.14784932f, -0.16552043f, 0.24565300f, -0.11765160f, 0.04355472f, -0.05080923f, 0.08108624f, -0.10862094f, 
    -0.03242953f, -0.04549003f, -0.12289510f, -0.01947305f, 0.02743400f, 0.00672850f, 0.14956947f, -0.06576820f, 
    0.10467610f, -0.01983038f, 0.02428935f, -0.01258057f, -0.07193886f, -0.12794319f, -0.17236660f, 0.07001814f, 
    0.00721065f, 0.03932074f, 0.05059709f, -0.03781589f, 0.04082841f, -0.04883543f, -0.07530826f, 0.05427314f, 
    -0.04153687f, 0.08300045f, -0.07574379f, -0.00262763f, -0.01809211f, -0.07975174f, 0.11200359f, -0.01027110f, 
    0.21018659f, -0.16724788f, -0.23427899f, 0.10234977f, -0.07682472f, 0.06470907f, 0.03156216f, -0.08889848f, 
    -0.07590615f, 0.22226614f, 0.03170907f, -0.06650766f, -0.13405435f, 0.20482524f, -0.23270766f, 0.10654902f, 
    0.00784962f, 0.11537693f, -0.20492934f, 0.00172336f, 0.11243366f, 0.20576985f, 0.10936248f, -0.20311441f, 
    -0.09293564f, 0.13878022f, 0.12844688f, 0.19062909f, -0.05874318f, 0.03706377f, -0.06721541f, -0.01189793f, 
    0.18370059f, 0.01175872f, 0.12217957f, -0.09354212f, -0.00594369f, 0.23639426f, -0.01003839f, 0.05177222f, 
    -0.13929409f, 0.00164948f, -0.11279842f, -0.03615949f, 0.10396610f, -0.18167187f, -0.10220397f, 0.10227214f, 
    0.08646945f, 0.16502725f, 0.04484884f, -0.05675970f, 0.19487849f, 0.00966423f, 0.10972890f, -0.11827511f, 
    0.01546303f, 0.10082904f, 0.02464088f, -0.03190126f, -0.16733947f, -0.08879990f, 0.11060595f, 0.08842096f, 
    0.10236054f, -0.09887294f, 0.25285095f, -0.15648764f, 0.10035118f, -0.04933783f, 0.03276909f, 0.17365143f, 
    -0.21471813f, 0.14241697f, 0.03022230f, 0.28651640f, 0.02632540f, 0.05483083f, -0.07605331f, 0.14599198f, 
    -0.01529704f, -0.00896644f, 0.04960364f, -0.05245617f, -0.07004768f, 0.20096038f, -0.06396513f, 0.06421128f, 
    0.13480884f, 0.07591412f, -0.11675359f, 0.04079640f, 0.01290205f, 0.04036461f, 0.18445662f, 0.08973450f, 
    -0.09452744f, -0.09255106f, -0.02155836f, -0.15286110f, -0.18206088f, -0.08610403f, -0.17281455f, 0.18942994f, 
    0.08479380f, 0.07093379f, -0.04816750f, 0.05018910f, 0.06176909f, -0.02227261f, -0.14619963f, -0.05459829f, 
    0.04046449f, 0.07742268f, 0.10593400f, -0.01165418f, -0.03529835f, -0.19723253f, 0.08834639f, 0.03232129f, 
    -0.06096001f, 0.05191304f, -0.09628549f, 0.12893032f, 0.22288100f, 0.03324298f, 0.03080262f, 0.05771571f, 
    0.00262468f, -0.03662643f, 0.12573317f, -0.03039363f, 0.10986315f, 0.17474024f, 0.11731400f, -0.28819689f, 
    -0.01786094f, 0.18389925f, 0.37247452f, 0.05636219f, 0.02603525f, -0.02493307f, 0.16026674f, -0.16379508f, 
    0.24483865f, -0.10521805f, 0.09193093f, 0.04893190f, -0.14531270f, -0.01184680f, 0.00342997f, 0.00152076f, 
    0.09226084f, 0.03818243f, -0.05457762f, -0.26488438f, 0.02105854f, 0.09597985f, 0.06501800f, -0.10092740f, 
    0.06531486f, 0.16051683f, -0.01518700f, -0.14042948f, 0.19411664f, -0.09197476f, 0.03865429f, -0.00556655f, 
    0.19814238f, 0.19173415f, 0.05416333f, -0.12283403f, -0.28394008f, 0.02465755f, -0.16616370f, 0.14406595f, 
    0.00011021f, 0.14861979f, 0.02418386f, -0.04635744f, -0.01763988f, 0.06760833f, 0.14001246f, 0.17878667f, 
    -0.15775625f, 0.09137226f, 0.13758329f, 0.05756218f, 0.18162201f, 0.19526181f, -0.43955085f, 0.05950042f, 
    0.08162610f, 0.02060520f, -0.03910876f, 0.03700327f, 0.01896388f, 0.02664517f, -0.03471780f, 0.09698480f, 
    0.03068826f, 0.16112323f, 0.15266508f, 0.06023068f, 0.04235362f, 0.20095600f, 0.17027438f, 0.20358838f, 
    0.14200303f, 0.01249738f, -0.07801217f, -0.00180432f, 0.14813462f, -0.04007888f, 0.01136126f, -0.04096385f, 
    0.08292873f, -0.01211793f, 0.10483392f, 0.07354192f, 0.21186022f, 0.02712039f, -0.04130686f, -0.01742518f, 
    0.02990385f, 0.03340983f, -0.22668472f, 0.02378054f, 0.08647167f, 0.16810100f, -0.15740694f, 0.09880630f, 
    -0.11647902f, 0.10354999f, -0.03376321f, 0.13282444f, 0.08547498f, 0.13766475f, -0.06153132f, -0.02667058f, 
    0.28166422f, 0.09937911f, -0.03087274f, 0.08263333f, 0.04892940f, 0.03249391f, 0.16108921f, -0.17881194f, 
    0.11059645f, -0.15344657f, 0.02186878f, 0.03154408f, 0.11039908f, -0.08308782f, -0.03792077f, -0.21454006f, 
    0.05781006f, -0.15047346f, 0.05769111f, 0.11913452f, 0.08782640f, -0.04600240f, 0.07165600f, -0.07750453f, 
    -0.04782284f, 0.09754860f, 0.11615431f, 0.07674714f, 0.00006372f, -0.05172019f, -0.09683666f, 0.02340285f, 
    -0.12002355f, -0.02099848f, 0.01804596f, 0.14575791f, 0.00718672f, 0.05158190f, 0.00299207f, -0.04491836f, 
    0.03286606f, -0.16352417f, -0.13770361f, 0.05776954f, 0.04221556f, 0.13074099f, 0.04306125f, -0.07724344f, 
    -0.07033679f, 0.03571163f, 0.16597141f, -0.09775064f, -0.00843359f, 0.04663533f, 0.01570052f, 0.02976942f, 
    0.11778466f, -0.01811048f, -0.10589302f, 0.11490631f, 0.17660537f, -0.05673806f, 0.10847732f, -0.00927832f, 
    -0.11092055f, 0.05033326f, -0.05277041f, 0.12452701f, -0.14933690f, -0.08749554f, -0.06590097f, -0.02360224f, 
    0.00814118f, 0.09820956f, -0.10842267f, -0.10091249f, 0.25799114f, 0.02841317f, 0.16081317f, -0.05869696f, 
    -0.06303795f, 0.09248662f, 0.01764536f, 0.01009034f, 0.05548535f, -0.15044965f, -0.38262710f, -0.10517150f, 
    -0.07559263f, 0.03673733f, -0.01923475f, -0.11994845f, 0.04026654f, 0.00179919f, 0.26507860f, 0.05158101f, 
    0.12709373f, 0.01136195f, -0.16435568f, 0.16087943f, -0.02338922f, 0.14304952f, -0.13034314f, -0.11866050f, 
    -0.11609057f, -0.12470486f, 0.12164277f, -0.03786708f, 0.03678349f, 0.03085311f, 0.02511878f, 0.09002580f, 
    0.06188855f, -0.35474083f, -0.14318411f, 0.15374790f, -0.04474174f, -0.06493387f, -0.07132088f, 0.04301568f, 
    0.06058145f, -0.05471957f, 0.04584339f, -0.02432426f, -0.01753743f, 0.00779865f, -0.13011731f, 0.02805255f, 
    -0.15400322f, 0.10434539f, -0.33550331f, -0.12380480f, 0.21592319f, -0.16135955f, 0.01774286f, 0.01172273f, 
    -0.00120161f, 0.00940621f, 0.09107601f, -0.13787632f, 0.26955089f, 0.02783889f, 0.09153061f, 0.06201727f, 
    0.08721728f, 0.02512751f, 0.02094403f, -0.10105951f, 0.01196287f, 0.13606566f, -0.20330733f, 0.01430794f, 
    -0.02774922f, -0.07574737f, -0.00585238f, 0.07831122f, -0.08082066f, 0.11451794f, -0.01812940f, -0.00491748f, 
    -0.01396009f, -0.02212924f, -0.08084127f, -0.03403626f, 0.04423293f, 0.02044578f, -0.05769718f, 0.02003017f, 
    -0.00100359f, 0.02029747f, 0.03173234f, -0.08093202f, 0.04909993f, 0.10774036f, -0.09248825f, -0.13788930f, 
    0.15118092f, -0.14240895f, -0.08773471f, 0.05254602f, -0.09592279f, -0.02772482f, -0.05205721f, 0.05997984f, 
    -0.10568307f, -0.10167307f, -0.13402022f, 0.02432378f, 0.03917207f, 0.08079543f, 0.08805512f, 0.04291641f, 
    -0.15555616f, 0.19553083f, -0.03142183f, -0.03383493f, 0.06839579f, -0.10745440f, -0.12295949f, 0.10777315f, 
    0.15347661f, -0.06123142f, -0.41926432f, 0.25074986f, 0.11209939f, 0.03358252f, -0.07651226f, -0.01878101f, 
    0.07780506f, -0.00781882f, 0.01887826f, 0.02051409f, 0.06221315f, 0.00821269f, 0.07802384f, -0.03772725f, 
    0.00049509f, -0.00393549f, 0.06505224f, -0.10054415f, -0.09350796f, 0.14251009f, 0.23273204f, -0.00391555f, 
    0.06441734f, 0.07688894f, -0.02793782f, 0.14630526f, -0.08771411f, -0.09532584f, 0.03057821f, 0.02308637f, 
    -0.06056465f, 0.04923581f, 0.03454944f, 0.11445243f, -0.05212591f, -0.01523654f, 0.05505636f, -0.16534705f, 
    -0.14471614f, 0.09547379f, 0.04736330f, -0.03190836f, 0.07173129f, 0.23732910f, -0.02922163f, 0.15638955f, 
    0.12992744f, -0.03089349f, -0.03478478f, 0.04140586f, 0.13094856f, -0.03557239f, -0.05219954f, -0.00434198f, 
    0.21602604f, 0.26327705f, 0.03979670f, 0.03969147f, -0.14587450f, 0.14125371f, 0.00669671f, 0.02192785f, 
    0.08591821f, 0.24480487f, -0.33635473f, -0.06318983f, -0.02545371f, 0.03505092f, 0.03813422f, 0.13054331f, 
    -0.05356973f, -0.05365606f, 0.13324681f, 0.10391762f, -0.15634036f, -0.07984012f, 0.21070579f, 0.02016263f, 
    0.04234268f, -0.03215303f, -0.03569020f, -0.01626904f, -0.09118444f, -0.42513400f, 0.01358093f, 0.02399044f, 
    -0.01678541f, -0.06241579f, 0.14803559f, -0.08811663f, 0.14253114f, -0.26824531f, -0.09271701f, 0.12214515f, 
    -0.00813948f, 0.09100237f, -0.03174190f, -0.04034043f, 0.02908152f, -0.13584425f, -0.31795618f, -0.10509272f, 
    0.07500523f, 0.02247264f, 0.13866489f, 0.02983692f, 0.01564433f, 0.08823846f, -0.20222916f, 0.15633568f, 
    0.05093674f, 0.08890642f, 0.14847946f, -0.09140038f, 0.06512684f, 0.02320082f, 0.04327595f, 0.23860432f, 
    0.15651287f, 0.07510968f, 0.06754054f, -0.11173058f, -0.06396341f, -0.00199930f, -0.09511571f, 0.04090741f, 
    0.12259190f, 0.15533791f, -0.08022452f, 0.03098451f, 0.11426293f, -0.19523583f, 0.11642836f, -0.03790084f, 
    0.10558080f, -0.02879247f, -0.14773318f, 0.00754605f, -0.02415486f, -0.06592488f, 0.10196110f, -0.10939382f, 
    -0.15687969f, 0.06083607f, -0.19030121f, -0.02323414f, 0.03936131f, -0.10223021f, -0.09148708f, 0.02886840f, 
    -0.02742282f, 0.23873644f, -0.11022517f, -0.21337724f, 0.11796881f, 0.05845664f, -0.17478703f, 0.01459674f, 
    -0.13267638f, 0.10154650f, -0.08326031f, 0.05673266f, -0.21783248f, -0.05380291f, 0.08286372f, -0.10444056f, 
    0.07350104f, 0.00667100f, -0.05361284f, -0.02941165f, -0.01377453f, 0.44628885f, 0.18123026f, -0.02626168f, 
    -0.09890905f, 0.05041341f, 0.09382464f, -0.07134418f, 0.11223433f, -0.10668473f, -0.17902447f, -0.00117820f, 
    -0.09834987f, -0.06097155f, -0.05116964f, 0.08641721f, -0.00999784f, -0.07537063f, -0.00659018f, 0.02551359f, 
    -0.11708747f, 0.23018862f, 0.14344831f, -0.06405749f, -0.01123313f, -0.02818498f, -0.06259838f, 0.03105941f, 
    0.29429758f, -0.08227221f, -0.22377537f, 0.03594609f, 0.09390298f, 0.00096440f, -0.04117703f, 0.07981344f, 
    -0.10442828f, 0.09513310f, 0.10279393f, 0.04143878f, 0.04277107f, -0.09063465f, -0.08971623f, 0.07053647f, 
    0.05864497f, -0.02139824f, 0.24029180f, 0.09308878f, 0.05678688f, -0.08770538f, -0.02858714f, -0.06446477f, 
    -0.15900077f, 0.03416981f, -0.06702553f, 0.24483015f, 0.01891254f, -0.12001158f, -0.03088127f, 0.19367035f, 
    -0.12130962f, 0.00792438f, 0.03327497f, 0.03478028f, -0.05267820f, 0.15024792f, -0.06876270f, -0.02820639f, 
    0.11640702f, 0.10372275f, -0.06468190f, 0.14812590f, 0.15244305f, -0.17245391f, -0.03883785f, 0.00035657f, 
    -0.07847611f, 0.00504580f, 0.05136126f, 0.02489181f, -0.00446788f, -0.07674697f, 0.10464346f, -0.20225303f, 
    0.04823769f, -0.09978546f, -0.05385730f, 0.02060291f, 0.04829387f, 0.06697051f, -0.00209343f, 0.07727671f, 
    0.16133572f, 0.05523129f, 0.09156550f, -0.13947767f, -0.00193556f, -0.00023628f, -0.01647431f, -0.08108868f, 
    0.15365219f, -0.00511769f, 0.11484320f, 0.08260593f, 0.13321890f, -0.03820161f, 0.03768053f, -0.02460713f, 
    0.03369183f, -0.07421914f, 0.03929289f, 0.11573408f, -0.04684239f, 0.01184262f, 0.17957412f, -0.06327733f, 
    -0.03895813f, 0.06009439f, 0.14259915f, -0.10605823f, -0.04873066f, 0.00206277f, -0.03421658f, -0.12249068f, 
    -0.00056445f, -0.02011187f, 0.04386634f, -0.12015644f, -0.03407469f, 0.09721739f, -0.07221156f, 0.06403980f, 
    0.02940501f, -0.01228946f, -0.00048025f, -0.00775956f, -0.17979036f, -0.01609821f, -0.00075592f, -0.10252361f, 
    0.04721407f, 0.00951632f, -0.05002296f, -0.05583908f, -0.04303897f, 0.20522866f, 0.13194890f, -0.04369968f, 
    0.05223778f, -0.05080675f, -0.08747968f, -0.07591303f, -0.02154866f, 0.03980659f, -0.11250276f, 0.26643315f, 
    0.15550339f, 0.08348941f, 0.05766236f, 0.00331841f, -0.19711088f, 0.06070060f, 0.12862547f, 0.08629068f, 
    -0.17863743f, 0.11319925f, 0.03861750f, -0.07598107f, 0.10785913f, -0.02565286f, 0.00278814f, -0.00937916f, 
    0.01414222f, -0.07642706f, -0.20295742f, 0.13934481f, 0.04932613f, 0.03663754f, 0.10526767f, -0.17404182f, 
    -0.01033062f, 0.01895393f, 0.02941036f, -0.15323101f, -0.02502303f, 0.04129262f, -0.06493387f, -0.01753516f, 
    0.01081567f, -0.04527687f, 0.00613894f, 0.04375316f, 0.05248313f, -0.11916795f, -0.07415552f, -0.15764716f, 
    -0.00161293f, 0.02944809f, 0.02919348f, 0.41208756f, -0.01223561f, -0.02787695f, 0.11493775f, -0.12032428f, 
    0.15145302f, 0.06723688f, 0.15910593f, 0.09114844f, 0.21216476f, 0.05779508f, -0.19454825f, 0.10741107f, 
    0.07563180f, -0.18504588f, -0.03972587f, 0.08133627f, 0.05098392f, 0.03840937f, -0.10702551f, 0.26090738f, 
    0.03662680f, -0.01698917f, 0.13271338f, -0.04074213f, 0.09108564f, -0.01953569f, 0.07503560f, 0.03947433f, 
    0.06795602f, -0.03723412f, -0.08849609f, -0.01832319f, 0.00305997f, -0.01936982f, -0.04157489f, -0.16942684f, 
    -0.26418802f, -0.02295084f, -0.11972910f, -0.02619354f, 0.06362103f, -0.06102725f, 0.00919760f, -0.10595315f, 
    0.06122210f, 0.00436204f, 0.02035894f, 0.09145533f, 0.02551286f, 0.04730188f, 0.01455067f, -0.16902786f, 
    -0.06522355f, 0.21327735f, 0.39045724f, 0.01215536f, -0.03127978f, 0.04080823f, 0.03263399f, 0.01323767f, 
    0.10746944f, -0.06686957f, -0.19055893f, -0.03581440f, -0.12644574f, 0.10745375f, 0.14991568f, 0.00990227f, 
    -0.07821109f, -0.03695084f, 0.01933353f, -0.02598406f, 0.24646290f, 0.04468929f, 0.01736411f, -0.04763315f, 
    0.18868922f, -0.14365911f, 0.04002919f, -0.01700078f, -0.13814549f, -0.37136549f, -0.05011095f, 0.04462306f, 
    0.06798311f, 0.03321389f, -0.06506174f, -0.01543411f, 0.00937284f, 0.22806713f, -0.27922714f, -0.11281583f, 
    -0.07287394f, 0.02332190f, -0.18737690f, -0.03536410f, 0.04853436f, -0.01913640f, -0.16232574f, -0.29963428f, 
    -0.12946394f, 0.02554959f, -0.00735309f, -0.01776193f, 0.11276647f, -0.16406205f, -0.08198781f, 0.11118828f, 
    -0.15606402f, -0.00339990f, 0.07005291f, 0.01211931f, 0.14124981f, 0.04261072f, 0.04861152f, 0.13797247f, 
    0.27869463f, -0.18098705f, -0.07651491f, -0.10151421f, 0.10070959f, 0.05057280f, 0.08717167f, -0.13057658f, 
    -0.14341508f, 0.15945573f, 0.02252975f, -0.07449419f, -0.19986604f, -0.04989916f, 0.07733772f, 0.08896293f, 
    0.16032852f, 0.10991454f, -0.00976952f, 0.05928091f, -0.00166119f, -0.04020984f, 0.09962524f, 0.06234703f, 
    0.03525325f, -0.03301384f, 0.04056376f, -0.00914222f, 0.20326653f, 0.10920921f, 0.06292994f, -0.07817461f, 
    -0.01977049f, 0.06923921f, 0.11312940f, 0.10877033f, 0.15557478f, 0.15963423f, 0.07757933f, -0.03833956f, 
    0.22205508f, -0.19850247f, 0.05180981f, 0.07310221f, 0.03116787f, -0.12319935f, -0.12701434f, 0.03600913f, 
    -0.05807815f, -0.04781614f, -0.00287993f, 0.13545400f, -0.01287469f, 0.23033372f, 0.06189615f, 0.03187007f, 
    -0.02566792f, 0.02187906f, 0.05633809f, -0.02430306f, -0.04021700f, -0.01498119f, -0.00100276f, -0.21874031f, 
    -0.27249357f, -0.02406299f, 0.07709609f, -0.01822568f, -0.06352457f, -0.09003331f, -0.06320549f, 0.08294971f, 
    0.00186718f, 0.10576422f, 0.02012954f, -0.00044838f, 0.02461970f, 0.05113521f, -0.02451067f, 0.03638213f, 
    -0.00081967f, -0.31232312f, -0.30214432f, -0.02229591f, 0.08916011f, 0.09782833f, 0.09329182f, 0.04618510f, 
    -0.04607115f, 0.01946226f, -0.05065273f, 0.08278671f, -0.05149973f, -0.01147172f, -0.05422826f, 0.07527224f, 
    -0.01154721f, 0.03354540f, 0.13622236f, -0.03007797f, -0.11689529f, 0.01647396f, 0.14199357f, 0.15861624f, 
    -0.14701529f, 0.05176786f, 0.04951566f, 0.13331510f, -0.01459181f, -0.13555342f, 0.09461957f, 0.09197653f, 
    0.08497373f, -0.00023608f, -0.06797475f, 0.00837101f, -0.03260212f, 0.16998526f, 0.12088320f, -0.05856814f, 
    0.00427963f, 0.05825969f, 0.07405109f, 0.00796931f, -0.04301488f, -0.11193093f, 0.09631708f, 0.05459158f, 
    0.02108852f, -0.04925035f, 0.05928534f, -0.18757966f, 0.11802759f, 0.00468838f, -0.00694042f, -0.00918920f, 
    -0.22126538f, 0.03831922f, -0.00005859f, 0.05123666f, 0.06449175f, -0.14842853f, -0.03568851f, 0.06499898f, 
    0.04555260f, 0.18303841f, -0.03885951f, -0.09616725f, 0.07888331f, 0.08661105f, -0.05849659f, 0.00985596f, 
    0.05502301f, 0.07420395f, 0.10792559f, 0.08004536f, -0.02311074f, -0.05900624f, -0.14309183f, 0.02203624f, 
    0.11190363f, 0.00172342f, -0.15547262f, 0.07487701f, -0.00858165f, 0.02788478f, -0.22709067f, -0.08591019f, 
    0.04492264f, 0.01537059f, 0.01308946f, 0.10848440f, -0.08274870f, 0.11382478f, -0.01798468f, -0.02423756f, 
    0.12314454f, -0.09473567f, -0.01672695f, 0.00654733f, 0.20331728f, -0.05118336f, 0.03917943f, 0.07467227f, 
    0.00043514f, 0.06192318f, -0.04597018f, -0.02463561f, -0.07871896f, -0.24590488f, 0.20567487f, -0.07908822f, 
    -0.20640031f, -0.12666444f, 0.16463670f, -0.01900178f, -0.10063151f, -0.06644405f, -0.23702320f, 0.07062665f, 
    -0.00829879f, 0.00528942f, -0.09157611f, 0.04885690f, 0.02235069f, -0.00594740f, 0.08321768f, -0.14062634f, 
    -0.23605233f, 0.06967754f, 0.04230912f, 0.00459237f, -0.08277932f, 0.08750478f, -0.03453450f, 0.17761074f, 
    -0.13661005f, 0.02185251f, -0.15810817f, 0.05816039f, -0.10327774f, -0.00186147f, -0.06834874f, -0.01144787f, 
    -0.08148152f, 0.38828292f, -0.00390536f, -0.04428390f, 0.03456585f, -0.06109647f, 0.08458193f, 0.01951768f, 
    -0.01280715f, 0.12513408f, -0.01455429f, -0.20522282f, -0.13666189f, 0.00597323f, 0.17395078f, 0.01707365f, 
    -0.01555396f, 0.13983485f, -0.10587958f, 0.12798299f, 0.10084368f, -0.17536427f, 0.09822802f, 0.01660150f, 
    0.11747690f, -0.13229796f, -0.02251265f, 0.15444757f, 0.22282451f, -0.24457723f, 0.06112320f, 0.07122204f, 
    0.07226737f, -0.06184903f, -0.02605654f, 0.05882279f, 0.00088662f, 0.02016681f, -0.23807563f, 0.05410163f, 
    0.16500697f, 0.06894808f, 0.04160567f, 0.01870715f, -0.03352311f, -0.04157619f, 0.38540688f, -0.10966808f, 
    -0.03754701f, -0.02170610f, -0.01917527f, 0.05288043f, -0.00499956f, -0.12539220f, 0.11724845f, 0.33110112f, 
    -0.06538393f, -0.10264615f, -0.06604869f, 0.00657073f, 0.05390820f, 0.02131722f, -0.08898661f, -0.17889789f, 
    0.06812829f, 0.24405646f, 0.00662149f, 0.05072115f, 0.17390053f, 0.03740844f, 0.08325749f, 0.06090824f, 
    -0.18222837f, 0.08265755f, 0.09540021f, 0.02146464f, -0.02968186f, 0.06894872f, -0.05263447f, 0.21494615f, 
    -0.18840519f, -0.23129341f, 0.15275732f, -0.03793088f, -0.02168892f, 0.12781629f, -0.08043899f, 0.05525831f, 
    -0.12359142f, 0.06483092f, 0.04427415f, -0.25284582f, -0.13861571f, -0.00388204f, 0.02992433f, 0.08057840f, 
    0.03972621f, 0.07972098f, 0.03801307f, -0.06646536f, -0.18070924f, 0.02270073f, 0.03239356f, 0.09140528f, 
    0.10951043f, 0.10858908f, -0.15115303f, 0.09356752f, 0.09536718f, -0.04347809f, 0.06146710f, -0.01715376f, 
    0.05743437f, -0.03732079f, 0.07496448f, 0.14394949f, 0.15692815f, -0.13537185f, -0.39277315f, -0.00501950f, 
    -0.08697557f, 0.03080307f, -0.09794047f, 0.04363834f, -0.00568241f, 0.02830447f, 0.00744525f, -0.20295736f, 
    -0.08578718f, -0.02616872f, 0.01795179f, 0.17627247f, 0.01594469f, -0.08254370f, -0.08949554f, -0.02655820f, 
    0.03004574f, 0.06479423f, -0.17175798f, -0.16094470f, -0.07433277f, 0.05394497f, -0.01440763f, -0.06664396f, 
    0.04017406f, 0.13287336f, 0.21633106f, 0.14385264f, 0.14512880f, -0.09299420f, 0.10326957f, -0.00013894f, 
    0.16264668f, -0.04112092f, -0.26443601f, -0.03200778f, -0.16365427f, 0.09293351f, 0.00335876f, 0.03229146f, 
    0.00192197f, 0.11601410f, 0.06538714f, -0.34538215f, 0.20657076f, -0.19188355f, 0.12067376f, 0.06629782f, 
    0.10366213f, 0.01523892f, -0.03092288f, -0.05161542f, 0.16127302f, -0.15027350f, -0.10898936f, 0.02908313f, 
    -0.01452876f, -0.12899494f, 0.04963411f, 0.10329777f, -0.02491099f, 0.16994749f, -0.13705339f, -0.06717780f, 
    0.04592077f, -0.15807788f, -0.02655992f, 0.13155453f, 0.04725583f, -0.04847623f, -0.19542767f, 0.22513041f, 
    -0.08663092f, -0.22826509f, -0.18667638f, 0.04627511f, -0.00583025f, 0.03962632f, 0.00415691f, 0.45922711f, 
    0.12303149f, -0.01695988f, -0.05455134f, -0.01589888f, -0.07965460f, 0.07465867f, -0.01478194f, 0.15868968f, 
    -0.03713160f, 0.06437419f, -0.01813618f, -0.03946690f, -0.10485022f, -0.10847688f, 0.18528683f, -0.09812241f, 
    0.08562587f, -0.16420445f, -0.05840772f, -0.00676570f, 0.12000746f, 0.03438233f, -0.01542152f, -0.07368582f, 
    0.09733175f, -0.03595654f, -0.23361623f, 0.07773875f, -0.05755737f, -0.10976487f, -0.01322289f, 0.00860692f, 
    -0.07907944f, 0.00094702f, 0.08941008f, -0.20178869f, -0.12873685f, 0.07430577f, -0.20710760f, 0.01165944f, 
    -0.00792024f, 0.08767854f, 0.07344797f, 0.00030306f, 0.22365707f, 0.14529589f, -0.16221082f, 0.10111269f, 
    -0.07887197f, -0.04160569f, -0.03440258f, 0.05916184f, 0.02897934f, -0.16300736f, 0.03248013f, -0.05506305f, 
    -0.10176570f, 0.07206300f, -0.00323089f, -0.02850690f, -0.03204333f, 0.00352257f, -0.29992655f, -0.22602352f, 
    -0.06333171f, -0.05318057f, 0.24880350f, 0.16515926f, -0.18926187f, 0.02801230f, -0.05363704f, 0.06451013f, 
    -0.00016212f, 0.03176228f, 0.04647922f, -0.07531684f, 0.03839117f, 0.08824575f, 0.02216093f, -0.01594398f, 
    -0.05184681f, -0.00828787f, -0.04775717f, -0.02466737f, -0.01120545f, -0.06210396f, -0.01895729f, 0.05043071f, 
    0.04499879f, -0.01830726f, -0.05192657f, 0.05588475f, 0.02771890f, -0.00722165f, -0.04197475f, 0.01813459f, 
    0.04443316f, 0.04484356f, 0.04532891f, 0.03153870f, 0.00693840f, -0.05469986f, 0.00505091f, 0.04661962f, 
    -0.02284125f, 0.03416901f, -0.00848535f, 0.01526037f, -0.00492107f, -0.00149468f, 0.04560426f, 0.03865663f, 
    -0.05621745f, -0.06131681f, 0.00922719f, -0.03181486f, -0.03355357f, 0.03625338f, -0.01365789f, 0.01372463f, 
    -0.05430207f, 0.03542322f, -0.04440647f, -0.02756850f, 0.05154575f, -0.04692815f, -0.04104127f, -0.02751663f, 
    -0.05648083f, 0.01125424f, 0.03567533f, 0.01787745f, -0.03297705f, -0.06653806f, -0.04683075f, -0.01298427f, 
    0.00525121f, 0.04538580f, -0.01924916f, 0.05044701f, -0.02547870f, -0.06225481f, -0.03609147f, 0.01474725f, 
    0.05052639f, 0.01134392f, -0.02343746f, -0.02327596f, -0.05993336f, -0.03119648f, -0.06390247f, -0.03619617f, 
    0.00614163f, 0.02753143f, 0.01482302f, 0.03725313f, 0.04558513f, -0.02157951f, -0.05736368f, 0.03957961f, 
    0.02040550f, -0.00019414f, -0.06091191f, -0.06322115f, -0.01466791f, -0.00893083f, -0.04816468f, 0.02358665f, 
    -0.04404497f, -0.00110110f, 0.02364870f, -0.02933475f, -0.02776451f, 0.03216843f, 0.03458175f, -0.05906016f, 
    -0.01754449f, -0.02745434f, -0.02632662f, -0.01591385f, 0.02187858f, -0.05990987f, -0.02638422f, 0.04499675f, 
    -0.03222182f, -0.05937294f, -0.06019012f, -0.04591174f, 0.03841813f, -0.05802102f, -0.02152934f, 0.04962629f, 
    -0.02118313f, -0.02040277f, -0.00108015f, 0.00800025f, 0.03869461f, -0.03699464f, 0.00639533f, -0.02511410f, 
    -0.00243505f, 0.02718828f, 0.01354129f, -0.05044537f, 0.01486588f, 0.01481813f, -0.00511884f, 0.02484200f, 
    0.00890854f, -0.00654797f, -0.04788245f, 0.03539972f, -0.01679187f, 0.01756431f, -0.05601054f, -0.06355921f, 
    0.01577992f, 0.04036346f, 0.02356401f, 0.03438722f, -0.03000517f, 0.03877153f, -0.06596577f, 0.03396086f, 
    -0.02196255f, -0.04728109f, 0.01986242f, -0.02012683f, 0.01466088f, 0.03617130f, -0.01820303f, -0.03197269f, 
    -0.04094429f, -0.01665836f, -0.02561814f, 0.02686062f, -0.01850611f, -0.05655103f, 0.04978715f, 0.01034317f, 
    -0.01227461f, -0.02554157f, -0.05176494f, 0.00178765f, 0.01332594f, -0.06437438f, 0.00273752f, -0.02386194f, 
    0.04819680f, -0.01268861f, -0.04254453f, 0.01600811f, -0.04553610f, -0.03009475f, 0.04229126f, -0.01855064f, 
    0.04091600f, 0.02944558f, 0.04663765f, 0.02331110f, -0.01011885f, -0.05970979f, 0.02820258f, 0.00263241f, 
    0.01793162f, -0.05883238f, -0.05941487f, -0.03360766f, -0.01766008f, -0.04295388f, 0.03777294f, 0.01461094f, 
    0.04368062f, -0.01589296f, -0.02490865f, 0.02655320f, -0.05065576f, -0.04711019f, 0.02278203f, 0.02000937f, 
    0.03412296f, 0.00218905f, -0.01433979f, 0.02027638f, 0.05078951f, -0.01269732f, -0.01385835f, -0.03128684f, 
    0.00160221f, 0.03971573f, -0.03674778f, 0.01613024f, -0.05215899f, 0.01770617f, -0.00959637f, -0.04908786f, 
    0.02499797f, 0.02767380f, 0.03557283f, 0.00976317f, -0.01535277f, 0.02572544f, -0.01156300f, -0.05805001f, 
    -0.01138840f, 0.01236777f, 0.01929318f, -0.05439798f, -0.04018433f, -0.06204905f, 0.03957278f, -0.00361163f, 
    -0.01961987f, -0.01484611f, -0.05956612f, 0.05031580f, -0.02021024f, -0.04609637f, 0.01348583f, -0.06600693f, 
    0.03514486f, -0.03542915f, 0.01712556f, -0.00542731f, 0.05559367f, 0.01084595f, 0.03404334f, -0.02033439f, 
    -0.03860891f, -0.01539880f, 0.01250583f, -0.05683214f, -0.04059456f, -0.01625636f, -0.00461510f, -0.06515925f, 
    0.02548651f, 0.02062420f, -0.04533122f, -0.01868360f, 0.01094362f, 0.02444953f, -0.03665850f, -0.05588563f, 
    -0.01641298f, 0.04949500f, -0.01224009f, -0.05996712f, -0.02196779f, 0.04129585f, 0.03581006f, -0.01747698f, 
    -0.03744997f, -0.00301575f, 0.04446070f, 0.03601547f, -0.06117989f, -0.05777247f, -0.04231446f, -0.01550179f, 
    -0.05895418f, -0.00096247f, -0.02330780f, -0.02744568f, -0.01327227f, -0.03009726f, 0.03962144f, -0.00318517f, 
    -0.08087709f, -0.03930452f, 0.14444698f, -0.08698080f, -0.04423198f, 0.13679056f, -0.14662904f, 0.00756927f, 
    0.02874948f, 0.34080431f, 0.17315406f, 0.27572984f, 0.07634839f, -0.04040693f, 0.12616563f, -0.04806890f, 
    -0.01284630f, -0.15577236f, -0.08645740f, -0.12162352f, -0.08968201f, 0.09241508f, -0.10513756f, 0.00269777f, 
    -0.08506118f, 0.00759458f, -0.05142629f, 0.25749484f, 0.08560736f, 0.24801338f, 0.13278712f, -0.22493140f, 
    -0.08752868f, -0.01166755f, -0.07020130f, -0.11582293f, -0.05181129f, 0.09043960f, 0.03921212f, -0.12015539f, 
    -0.04488068f, 0.09008349f, -0.10996944f, 0.03315374f, 0.04346521f, 0.41692099f, 0.18277089f, -0.08310822f, 
    -0.04546284f, -0.05374692f, 0.06573649f, -0.02881747f, -0.04127527f, -0.15250173f, -0.37490273f, -0.12983710f, 
    -0.03028473f, 0.05432645f, -0.19179314f, -0.01900189f, -0.06577717f, 0.11835594f, -0.04290299f, -0.15215062f, 
    -0.06557395f, -0.03183184f, 0.05329570f, -0.21053396f, 0.02453537f, 0.09709941f, -0.03911497f, 0.06639238f, 
    -0.21221004f, 0.24772339f, -0.10040003f, -0.08271770f, 0.10260028f, -0.02473796f, 0.04130912f, -0.02092293f, 
    0.07684383f, 0.04233865f, 0.00179282f, 0.19425726f, 0.00986582f, 0.07202824f, 0.13161430f, 0.07024561f, 
    0.13311973f, 0.04186378f, 0.08393472f, 0.11617008f, -0.07170079f, -0.10465898f, 0.00591523f, 0.03884539f, 
    -0.04106830f, 0.03537128f, 0.01290988f, 0.01778723f, -0.08936753f, 0.00570974f, -0.00844450f, -0.04016955f, 
    0.11976011f, 0.06304364f, -0.08643046f, 0.12595157f, 0.20134106f, 0.15863596f, -0.02549055f, 0.03858713f, 
    0.04557068f, 0.20784535f, -0.00608866f, 0.07854009f, 0.05533139f, -0.02339454f, -0.11878732f, -0.11985841f, 
    0.00430659f, 0.04410373f, -0.20490551f, 0.07869852f, 0.01292311f, 0.11993843f, 0.05265773f, -0.07590380f, 
    -0.12267514f, -0.01443325f, -0.06152698f, -0.03703591f, 0.11163998f, 0.00280780f, -0.05032486f, -0.02358100f, 
    -0.20434709f, -0.03930173f, -0.04915811f, -0.04803065f, -0.04753705f, 0.11133801f, 0.21644199f, -0.01783311f, 
    0.19601154f, -0.01643817f, 0.24925824f, 0.10113768f, -0.17101038f, -0.08303750f, -0.02251811f, -0.03554112f, 
    -0.14685822f, -0.01004513f, -0.12636672f, 0.07414719f, -0.02664606f, -0.13778839f, 0.05454964f, -0.05127661f, 
    -0.06402138f, 0.00545608f, 0.16431934f, 0.04394547f, 0.06108294f, 0.05513661f, -0.06772755f, -0.15452449f, 
    -0.02783107f, 0.00876719f, 0.03782026f, 0.04296996f, 0.00420363f, -0.07456642f, -0.02313622f, -0.15460819f, 
    -0.10831991f, 0.00636926f, 0.01208757f, -0.09963434f, -0.27297965f, -0.04404613f, -0.10986231f, -0.10402370f, 
    0.05765456f, -0.03562681f, -0.16057099f, -0.03408808f, -0.03415222f, 0.10629968f, 0.13040370f, 0.12644108f, 
    -0.08694146f, -0.02602080f, 0.04460793f, -0.04552003f, 0.03014918f, 0.11895441f, 0.25513315f, 0.09971280f, 
    0.00645471f, 0.17297709f, 0.13840076f, -0.04302732f, 0.06401043f, 0.00000876f, -0.03584634f, -0.20658737f, 
    -0.00018680f, 0.00862805f, -0.13089313f, -0.03834944f, -0.00736581f, 0.00288883f, 0.02626304f, -0.01476689f, 
    0.19217321f, -0.03875105f, 0.11148088f, 0.18071295f, 0.05663409f, 0.04409101f, 0.00452227f, -0.17302787f, 
    0.08632785f, -0.00243088f, 0.07556648f, -0.09425063f, -0.05223808f, -0.01745434f, -0.02252066f, -0.04577263f, 
    0.17613442f, -0.03815285f, -0.19054586f, 0.01601099f, 0.11176556f, 0.06930988f, -0.00343137f, 0.03677224f, 
    -0.03940333f, -0.00372421f, 0.03832767f, 0.10914740f, 0.17365567f, 0.03949362f, 0.05842524f, 0.08455152f, 
    0.07188687f, -0.07965069f, 0.04513118f, -0.07994887f, -0.18614326f, -0.07566645f, -0.08994973f, -0.02803969f, 
    0.03102126f, 0.02170716f, 0.05990516f, 0.07405070f, 0.03381737f, -0.03969391f, 0.14623533f, -0.19933276f, 
    0.02567942f, -0.01207636f, 0.03186269f, 0.07546525f, -0.06115172f, 0.05704651f, 0.03500800f, -0.12353200f, 
    0.11158618f, 0.00075008f, -0.08017814f, 0.06606593f, 0.10752455f, -0.07594989f, -0.03045005f, -0.19848011f, 
    -0.10116188f, -0.10415708f, 0.08026761f, 0.01021655f, -0.07874081f, -0.11496571f, -0.02351414f, -0.01986724f, 
    -0.05649201f, 0.01337660f, -0.02889088f, -0.06484283f, 0.00830530f, 0.00349069f, -0.01171654f, -0.02916552f, 
    -0.02530854f, 0.04712383f, -0.00544299f, 0.04271896f, -0.01383595f, 0.02089600f, 0.04715705f, 0.00144078f, 
    -0.01407224f, 0.00435926f, 0.04517219f, -0.02020222f, -0.01371878f, 0.01114214f, -0.00082215f, -0.03870301f, 
    0.01258823f, 0.01811357f, 0.00288746f, -0.02302733f, -0.04385879f, -0.02746270f, 0.01542566f, 0.02183305f, 
    0.01684394f, 0.04000431f, -0.03246596f, -0.06574416f, 0.01546979f, -0.03168450f, 0.04682153f, -0.00617490f, 
    -0.02416760f, -0.03595560f, -0.01546232f, 0.00723165f, 0.00820675f, -0.03071073f, 0.03199526f, -0.00063560f, 
    0.04652715f, 0.01816625f, -0.00798363f, -0.04556406f, 0.00056273f, -0.03296294f, -0.03213687f, -0.05601478f, 
    0.00249245f, -0.05174870f, -0.03862955f, -0.06003343f, -0.06075479f, 0.02714922f, -0.02686223f, -0.06203488f, 
    -0.00693045f, -0.03307745f, 0.01361446f, -0.03911136f, -0.01340844f, 0.04724094f, 0.04394542f, -0.03243592f, 
    0.03570738f, -0.03981772f, -0.03068103f, -0.01143664f, -0.03954988f, 0.04573787f, 0.02388752f, 0.04570131f, 
    -0.03984769f, -0.00320928f, -0.02083736f, 0.02196569f, -0.00123890f, -0.02537118f, -0.01297873f, -0.05987789f, 
    -0.06014993f, 0.02748581f, -0.01906405f, -0.06274271f, -0.02963541f, -0.00572962f, -0.02370327f, 0.03665857f, 
    -0.04325148f, 0.01531988f, -0.05533125f, 0.04182152f, 0.01363571f, -0.02931689f, -0.05803104f, -0.03486889f, 
    -0.05961003f, -0.04552092f, 0.00019642f, 0.00823445f, 0.02226668f, 0.00510943f, 0.01438607f, -0.00631613f, 
    -0.06580932f, 0.04237917f, -0.00845109f, -0.04790297f, -0.04599041f, 0.03556768f, -0.05414074f, 0.05001368f, 
    -0.04268788f, -0.02547128f, 0.00275097f, 0.02461141f, -0.02057379f, -0.05140771f, 0.02652645f, 0.04788403f, 
    -0.03584043f, -0.00641691f, 0.01354366f, -0.04819941f, -0.05439930f, -0.04632178f, 0.03948052f, 0.03398108f, 
    0.00883451f, -0.00580850f, 0.01804635f, -0.03122178f, 0.03774672f, -0.03794592f, 0.02757559f, 0.01782603f, 
    -0.03390681f, -0.00367082f, -0.01014658f, 0.00802361f, -0.03437886f, -0.02565619f, -0.00556251f, 0.04321123f, 
    0.01624737f, -0.00714401f, 0.01521649f, 0.03751568f, 0.01804611f, -0.03480574f, 0.03914763f, -0.00248673f, 
    -0.01153035f, -0.02553963f, -0.05941032f, -0.06741856f, -0.06355376f, -0.04055621f, 0.02417449f, -0.04089696f, 
    0.00321405f, -0.05629563f, 0.03797860f, -0.01506503f, -0.06044568f, 0.01522366f, -0.05250366f, 0.00261888f, 
    -0.04694334f, -0.00086664f, 0.03723717f, 0.03556194f, 0.03325219f, -0.03366112f, -0.01248780f, -0.06877969f, 
    0.05452991f, -0.03214849f, -0.01513930f, -0.02585765f, -0.05569182f, 0.01166793f, -0.03557138f, -0.04048200f, 
    -0.03123615f, -0.00587344f, -0.03140463f, -0.05258340f, 0.02073112f, 0.01534861f, 0.02678052f, 0.03861384f, 
    0.01874821f, -0.05867196f, -0.00639781f, 0.01476043f, -0.05710647f, 0.02619779f, -0.04961883f, -0.05344957f, 
    -0.05404394f, -0.04757061f, 0.00711906f, -0.00202848f, 0.03290750f, 0.01068654f, 0.02318508f, 0.02756201f, 
    -0.06346294f, 0.00486600f, -0.05101485f, 0.04710661f, 0.00356498f, -0.02456656f, -0.04808620f, 0.03576882f, 
    -0.03265678f, -0.06909770f, -0.01478430f, -0.06368394f, 0.00993989f, 0.04390698f, -0.02270831f, 0.04841166f, 
    -0.05239224f, -0.02638500f, -0.03783314f, 0.03648349f, -0.03020266f, -0.03488902f, -0.05020773f, -0.04361807f, 
    -0.06876338f, 0.02997089f, -0.01680023f, -0.03528818f, 0.04357273f, 0.00809835f, -0.05617445f, 0.01792920f, 
    0.03025506f, -0.01540403f, 0.03204540f, -0.05969441f, -0.03554207f, 0.01516978f, 0.03915591f, 0.04466937f, 
    0.01505984f, -0.01036376f, -0.02174396f, 0.00474446f, -0.01326735f, 0.02733343f, -0.06029830f, 0.00571054f, 
    -0.03858998f, -0.06226159f, -0.02667931f, 0.04978738f, 0.00657131f, 0.04519922f, 0.04663122f, -0.03772318f, 
    0.04379081f, 0.03853419f, 0.03868337f, -0.00246341f, -0.01493636f, 0.02596413f, 0.00986664f, -0.01400221f, 
    -0.00439965f, -0.06168160f, 0.03025071f, -0.05102770f, -0.04295272f, 0.02291673f, -0.05325363f, 0.01829884f, 
    -0.06495735f, -0.02627012f, -0.03029653f, 0.03777508f, 0.04741982f, -0.03078419f, 0.02129565f, 0.03695885f, 
    -0.06871736f, -0.00767972f, -0.00479216f, 0.00621571f, 0.04192939f, -0.03947238f, 0.02092244f, -0.03843584f, 
    0.05836731f, -0.05487841f, -0.05186220f, 0.00274551f, 0.01920391f, 0.04914547f, 0.04240249f, 0.03296610f, 
    0.00709470f, -0.03057262f, -0.02423465f, 0.05060440f, 0.01304479f, -0.03484051f, 0.00805952f, -0.01239048f, 
    -0.05613333f, -0.05303695f, 0.01753388f, -0.00678729f, 0.03493267f, 0.04648503f, 0.03207064f, 0.04161046f, 
    0.04942657f, -0.00981205f, 0.03979291f, -0.04769162f, -0.05658320f, 0.01474683f, -0.02640626f, 0.01806141f, 
    0.02843742f, -0.05035410f, -0.00290216f, -0.03752995f, 0.05604649f, -0.04840275f, 0.00612925f, -0.05271721f, 
    -0.04878720f, -0.03526859f, -0.03303843f, -0.03656645f, -0.00482061f, 0.02730890f, 0.02339465f, 0.02999614f, 
    -0.03112442f, -0.03807744f, 0.03529899f, 0.02178021f, 0.01072110f, -0.00038205f, -0.05190051f, -0.02710809f, 
    0.02396842f, 0.00225696f, -0.04806072f, -0.03710572f, -0.02819424f, -0.00334804f, 0.02998506f, -0.03331873f, 
    0.03658829f, -0.01885444f, -0.02337027f, -0.02330365f, -0.02865731f, -0.03805176f, 0.03040401f, 0.04070327f, 
    -0.00730684f, 0.03384303f, 0.03315227f, -0.02496614f, 0.01721230f, -0.00757436f, -0.00369255f, -0.04146419f, 
    -0.04728497f, -0.02334634f, -0.04899075f, 0.04306508f, 0.04431005f, 0.01532574f, 0.00685045f, -0.04295376f, 
    0.01010144f, -0.02665736f, 0.04209606f, -0.04872055f, -0.04192599f, -0.04751385f, 0.01163206f, -0.01299802f, 
    -0.04101908f, 0.02460215f, 0.04105556f, 0.05471000f, -0.02327114f, 0.00970447f, 0.01222137f, -0.06057810f, 
    0.02519138f, -0.00649885f, -0.06428265f, -0.06211036f, 0.04279484f, -0.01026040f, -0.04307268f, 0.02583103f, 
    -0.00353121f, -0.01381785f, -0.00227483f, -0.05263209f, -0.04759294f, -0.04615941f, -0.04199424f, -0.04041100f, 
    -0.06307450f, -0.03631597f, 0.04087450f, -0.02293029f, 0.02760656f, 0.00106999f, -0.02311240f, -0.04759093f, 
    -0.02717355f, -0.03372167f, 0.04044840f, -0.01156942f, 0.04639569f, 0.00280014f, 0.00747424f, -0.04815446f, 
    0.06224738f, 0.05437730f, -0.04747563f, -0.04737854f, 0.03558854f, -0.01853873f, 0.01379843f, -0.03749277f, 
    -0.02504293f, -0.06383942f, 0.01688254f, -0.05658087f, -0.06690083f, -0.00020425f, 0.04625386f, 0.03225904f, 
    0.02764039f, 0.03909394f, -0.05485041f, -0.02886396f, -0.03448104f, -0.02005974f, -0.02745884f, 0.04813917f, 
    -0.03359275f, -0.01075881f, -0.03677085f, 0.03559314f, -0.02470027f, 0.01730112f, -0.00579668f, 0.04284307f, 
    -0.02122209f, -0.03948610f, 0.02960795f, -0.02778047f, 0.02376990f, -0.00293943f, -0.02213293f, -0.03984446f, 
    0.00766542f, 0.04324985f, 0.02551270f, -0.04190431f, -0.02581067f, -0.01046600f, -0.06671540f, 0.04299575f, 
    -0.00685341f, 0.00804778f, 0.03932910f, 0.00565764f, -0.00808521f, -0.00835834f, 0.03252992f, 0.06379656f, 
    -0.05184777f, 0.01739634f, 0.03868209f, -0.05862865f, -0.03254573f, 0.04282442f, 0.01603406f, 0.00588219f, 
    -0.05003788f, -0.02740991f, -0.04594931f, 0.02827700f, -0.04372104f, -0.00133922f, 0.02848851f, -0.03293807f, 
    -0.03772310f, -0.01451300f, -0.00946657f, 0.04881373f, 0.01863193f, 0.01417333f, -0.03579258f, -0.01538902f, 
    -0.04078220f, -0.00766599f, 0.01194634f, -0.05819143f, -0.04951664f, -0.03336070f, -0.04467373f, -0.01362488f, 
    -0.02754812f, -0.02068909f, -0.02530111f, 0.03792688f, 0.02074305f, -0.03853567f, -0.03073303f, 0.03167275f, 
    0.01096410f, -0.00477829f, 0.05991595f, 0.02792913f, -0.03436176f, 0.05278174f, -0.04562899f, 0.01959787f, 
    0.00645484f, 0.03874818f, -0.06228342f, 0.03773197f, -0.02417124f, -0.02998821f, -0.02274664f, -0.00091928f, 
    0.03583426f, 0.00260489f, 0.00392816f, 0.05320754f, -0.01570213f, -0.00727418f, -0.01419589f, 0.04561426f, 
    0.00563059f, 0.00270738f, 0.00204521f, 0.02092973f, -0.04722333f, -0.06402354f, -0.03834254f, 0.01167496f, 
    -0.05560844f, 0.01233167f, -0.00336270f, -0.00014402f, -0.03037126f, -0.04308479f, 0.01945012f, -0.05430028f, 
    -0.10401515f, 0.17859094f, -0.17481504f, -0.04596636f, 0.16247848f, 0.01967539f, 0.08291799f, -0.00125661f, 
    -0.05524181f, 0.03150497f, -0.08662578f, 0.26927710f, 0.08527987f, -0.00515473f, -0.07458123f, -0.00778458f, 
    -0.06855620f, 0.04019507f, 0.07860301f, -0.01045802f, -0.07058482f, -0.03602441f, -0.00982487f, -0.14200680f, 
    -0.02963425f, 0.20337614f, -0.03497834f, 0.07543465f, -0.07449605f, -0.05798124f, 0.06258925f, 0.07804343f, 
    0.07852362f, 0.13473839f, 0.04673907f, 0.07600366f, -0.05561654f, 0.08513551f, 0.10929167f, 0.03215991f, 
    0.09919883f, -0.02328291f, 0.18685609f, 0.01307361f, -0.05183078f, -0.20910642f, -0.01190315f, -0.27976376f, 
    -0.01078277f, -0.02096212f, -0.16061141f, 0.02727118f, 0.02678520f, 0.04676935f, 0.11204614f, -0.14434662f, 
    -0.05593696f, 0.06157954f, 0.15693705f, 0.00953813f, 0.02487552f, 0.07195819f, -0.07343729f, 0.06778265f, 
    -0.09702934f, -0.08080108f, 0.04707320f, 0.14257646f, 0.04604588f, -0.02089512f, -0.05930860f, 0.12367432f, 
    -0.31718460f, 0.18649788f, -0.38033509f, 0.03387835f, 0.03236125f, 0.03067557f, 0.00270920f, 0.05300927f, 
    0.21566445f, 0.04548632f, -0.20727201f, -0.11153144f, 0.08711893f, 0.12266222f, 0.10728214f, -0.04000259f, 
    -0.04382693f, 0.07981682f, 0.20868294f, -0.09136378f, -0.09160968f, -0.16794333f, -0.03494017f, 0.06317071f, 
    0.17997155f, -0.07137143f, 0.08110559f, 0.01323128f, 0.17647298f, 0.16803548f, -0.02309011f, -0.02554148f, 
    0.02231290f, -0.11380798f, -0.01867948f, 0.20448959f, 0.13799807f, -0.09498949f, 0.22639661f, -0.22405994f, 
    -0.13756502f, 0.08612294f, -0.10377655f, -0.02634034f, -0.10382783f, 0.05269166f, 0.13698748f, -0.06836080f, 
    0.22873470f, -0.04635959f, 0.03366733f, 0.06972142f, -0.02851981f, 0.04458630f, -0.11179162f, 0.12947409f, 
    -0.06150715f, 0.00106119f, -0.06172539f, -0.00743323f, 0.12278832f, 0.00722485f, 0.06702459f, 0.22809111f, 
    0.10144690f, -0.00582522f, -0.03743120f, -0.15464540f, 0.06887838f, 0.07708234f, 0.15385990f, 0.19076259f, 
    -0.39476731f, -0.09941824f, -0.18222997f, 0.01150559f, 0.01640410f, -0.14890964f, -0.01791131f, 0.03094114f, 
    -0.08042794f, -0.14091237f, -0.11217759f, -0.15453051f, 0.11646109f, 0.17157288f, -0.00034073f, -0.07170950f, 
    -0.16232264f, 0.00198422f, -0.12456086f, -0.06717393f, 0.03235147f, 0.04834643f, 0.05418151f, -0.05626512f, 
    0.01855331f, 0.05093879f, 0.27394021f, -0.02357751f, 0.08769763f, -0.03806398f, 0.14719573f, -0.03421101f, 
    -0.06896031f, 0.06967849f, 0.01857716f, 0.09265738f, 0.12690732f, -0.02458719f, 0.09027939f, 0.00413303f, 
    0.06764877f, -0.13149151f, -0.04956201f, 0.24943623f, 0.02385848f, -0.20019315f, 0.09328967f, 0.13153151f, 
    -0.04091104f, -0.05283402f, -0.14199184f, 0.02777695f, 0.05094014f, -0.04377460f, -0.08108120f, 0.10521937f, 
    0.02910403f, -0.03575629f, -0.06921475f, -0.18909086f, 0.05041912f, 0.07086909f, -0.25365725f, -0.21700613f, 
    -0.22322732f, -0.19818074f, 0.16251698f, 0.09596556f, 0.01092656f, -0.02877420f, 0.02880366f, -0.00890190f, 
    -0.14909415f, -0.13612033f, 0.25823537f, -0.02106545f, -0.04067494f, -0.10861170f, -0.05088558f, -0.07144450f, 
    0.09633914f, -0.09523351f, 0.30266678f, -0.10213666f, -0.03024592f, -0.01887164f, -0.00802826f, -0.05509536f, 
    0.01265959f, 0.06588975f, -0.06237739f, -0.01267702f, -0.00701526f, 0.07454389f, -0.01098949f, 0.09180152f, 
    0.00528272f, 0.02492567f, -0.07680540f, -0.28938764f, -0.29235014f, -0.00553395f, 0.10611478f, 0.01922187f, 
    -0.03295247f, 0.03535874f, -0.04875802f, 0.11202050f, -0.11746052f, -0.12939158f, -0.05900613f, 0.03922911f, 
    0.01220381f, 0.05726201f, 0.07966296f, 0.06236620f, -0.04378996f, -0.19634227f, -0.24812233f, -0.21724920f, 
    -0.10729752f, -0.15086284f, -0.08346112f, -0.01322822f, -0.11995113f, 0.04099255f, -0.02641612f, 0.00570136f, 
    -0.00087306f, 0.03831293f, -0.08801349f, 0.06406046f, -0.00692223f, -0.03393660f, 0.04662839f, 0.06271631f, 
    -0.02251345f, 0.04916378f, 0.20671268f, -0.02718679f, -0.03290487f, 0.01248782f, 0.11148834f, 0.03669829f, 
    0.01985741f, -0.20987518f, 0.01937424f, -0.11907473f, 0.02937268f, -0.03203367f, -0.04131495f, -0.13790487f, 
    0.00480525f, 0.40469292f, 0.25921395f, 0.25526372f, 0.21547514f, 0.07072899f, 0.14530639f, -0.02737603f, 
    0.16271111f, 0.03823515f, 0.09894558f, 0.11155942f, -0.06170721f, 0.04692239f, -0.02164968f, -0.04496221f, 
    -0.01543022f, 0.11286744f, 0.03121015f, 0.28949553f, 0.07609484f, -0.16002424f, -0.03090658f, 0.01722321f, 
    -0.00454351f, 0.01769705f, 0.06703166f, -0.00241826f, 0.37931737f, 0.04257635f, -0.05619943f, 0.05083002f, 
    -0.05358864f, -0.08903924f, -0.10072538f, -0.10300476f, 0.03976876f, 0.20767333f, 0.07207786f, -0.08889382f, 
    -0.16812015f, 0.05757631f, -0.05929833f, 0.02412532f, -0.05227567f, 0.02395163f, -0.16037686f, -0.13274302f, 
    0.02540272f, 0.11143628f, -0.08064754f, -0.12526608f, 0.04488175f, -0.01013794f, 0.01740497f, -0.09058704f, 
    -0.12235162f, -0.06934682f, -0.03253670f, -0.02047168f, -0.07112930f, -0.05489391f, 0.01198537f, 0.10599457f, 
    -0.20644699f, 0.26587740f, 0.23127790f, -0.25250152f, -0.01849190f, 0.04046877f, 0.00994109f, 0.11890323f, 
    -0.02938804f, -0.17473330f, -0.19052969f, 0.04000652f, 0.00868905f, 0.14101243f, 0.18210351f, 0.04341152f, 
    0.00407809f, 0.00003205f, 0.15240222f, 0.17141493f, 0.01140745f, 0.01453240f, -0.03909209f, 0.01586812f, 
    0.00261397f, -0.04452467f, 0.05896038f, -0.13801754f, 0.00997276f, 0.23631756f, 0.09466425f, 0.07849227f, 
    -0.10419992f, 0.12599514f, 0.01272275f, -0.00527948f, 0.23663449f, 0.09564174f, 0.09371167f, 0.29142678f, 
    0.09011490f, -0.14043526f, -0.00372435f, 0.05958349f, 0.09725992f, -0.04401657f, 0.14615773f, -0.05549168f, 
    -0.06051093f, -0.09497628f, -0.02027601f, 0.09828448f, -0.11881524f, -0.01470894f, -0.10041212f, 0.00335656f, 
    -0.10752863f, -0.03182456f, -0.05279762f, -0.04769860f, -0.03196635f, -0.06972664f, -0.05884648f, 0.00281664f, 
    -0.20679620f, 0.05070409f, 0.07882427f, 0.01784023f, -0.05898482f, -0.07046324f, 0.05977383f, 0.12796061f, 
    -0.22188289f, -0.13367370f, 0.17623127f, 0.06002590f, -0.04583182f, 0.01593787f, -0.07119502f, -0.02995779f, 
    -0.20176794f, 0.14259560f, -0.06995475f, -0.13092308f, -0.03277816f, 0.12384864f, -0.10032449f, 0.06471006f, 
    -0.15376222f, 0.05569162f, 0.01062630f, -0.09079199f, 0.04397137f, -0.05924037f, -0.10692421f, 0.04289226f, 
    -0.09644934f, 0.05628365f, -0.11672200f, 0.10594387f, -0.23798355f, 0.02255869f, -0.02115989f, -0.05273849f, 
    -0.06759170f, -0.19367486f, 0.14544648f, 0.02978477f, -0.20219746f, 0.06378531f, -0.16918515f, 0.06291661f, 
    -0.08598853f, 0.00942153f, 0.04088013f, 0.02552900f, -0.16499954f, 0.18845679f, 0.13468654f, -0.00975229f, 
    -0.02061481f, 0.00496464f, -0.00645041f, -0.13392058f, -0.07409751f, -0.16477332f, 0.06228803f, 0.25696954f, 
    0.02119206f, 0.30670908f, -0.03250761f, -0.01130506f, -0.02329276f, 0.13056688f, 0.11928207f, -0.26707572f, 
    0.00918052f, -0.10567220f, -0.10573054f, -0.03780328f, -0.09609829f, -0.01999626f, 0.08607980f, -0.01534220f, 
    0.16296995f, 0.12492000f, 0.07721262f, 0.10055222f, 0.10491592f, 0.03431299f, 0.15482117f, 0.11103216f, 
    -0.07276530f, -0.14481980f, 0.08122392f, 0.01128311f, -0.05050414f, 0.01182093f, -0.05060827f, 0.12718502f, 
    0.01189557f, -0.11094002f, -0.13117735f, -0.00626293f, -0.00115264f, 0.06001512f, 0.09026010f, -0.05236809f, 
    -0.00912540f, -0.15626433f, -0.06393070f, 0.01548112f, -0.02801952f, -0.02248072f, -0.04309735f, 0.07746016f, 
    0.13932291f, -0.02151865f, 0.12659110f, 0.04144902f, -0.04412099f, -0.16472021f, 0.00613591f, -0.19911934f, 
    -0.14925660f, 0.03641872f, -0.04347280f, 0.07965434f, -0.06435477f, 0.07328678f, 0.07128914f, -0.25896305f, 
    -0.01650102f, -0.04499628f, 0.12104659f, -0.10841341f, 0.00913862f, 0.00598593f, 0.15870461f, 0.04039152f, 
    0.14582594f, 0.06407411f, -0.00034517f, -0.01089050f, -0.03266511f, 0.01428656f, -0.12553887f, 0.10687329f, 
    0.12244578f, -0.06398695f, 0.07357588f, 0.00334239f, -0.07970000f, 0.07754432f, -0.03851558f, -0.04712429f, 
    0.02602008f, 0.17938721f, -0.26132521f, -0.00524903f, 0.08908664f, 0.06716558f, -0.12418345f, 0.06351241f, 
    -0.00586867f, -0.15225145f, 0.04161023f, -0.15259562f, 0.00786470f, 0.00635234f, 0.00812840f, 0.06248281f, 
    -0.03544660f, -0.03794455f, -0.04545065f, -0.17577432f, -0.07470208f, -0.12182869f, 0.02225159f, -0.08251020f, 
    0.14948057f, 0.02051375f, -0.10358270f, 0.09160673f, 0.12799597f, -0.09572826f, -0.10290383f, 0.05501615f, 
    -0.00675608f, 0.06809892f, 0.14569144f, -0.08236725f, 0.14374512f, 0.17814879f, 0.05405479f, 0.05838044f, 
    0.08948888f, 0.12923370f, 0.03225690f, 0.02059784f, 0.04995446f, -0.28165832f, 0.04922390f, 0.43447462f, 
    -0.00719566f, -0.02313994f, -0.13873062f, 0.07967986f, 0.02182614f, -0.12749955f, -0.20748766f, 0.32350212f, 
    0.09993216f, -0.02888789f, -0.09531573f, -0.05942933f, -0.11875782f, 0.05700545f, 0.05150569f, 0.18220192f, 
    0.25944987f, 0.10719820f, -0.06891205f, 0.07104278f, -0.00927696f, -0.03919445f, 0.01800241f, -0.03519561f, 
    -0.10793668f, -0.20995910f, 0.15132782f, -0.05166598f, -0.10228872f, -0.06473798f, -0.17168328f, -0.08332600f, 
    0.11140926f, -0.17979670f, -0.17721412f, 0.10961720f, 0.00195038f, -0.10037524f, 0.03802283f, 0.11870654f, 
    0.07393306f, -0.06539816f, -0.02061052f, -0.27283376f, -0.13681887f, 0.06531046f, 0.09745446f, -0.11724912f, 
    0.00967022f, -0.00109412f, -0.02859331f, 0.02343747f, -0.09863648f, -0.22509609f, 0.07208864f, 0.00964880f, 
    -0.01307321f, -0.00019764f, -0.09523036f, -0.13715346f, 0.11577822f, -0.41876584f, -0.16702895f, 0.06465617f, 
    0.08380400f, 0.09092006f, 0.01844489f, -0.00301120f, -0.06262498f, -0.07398134f, 0.06978531f, 0.07005645f, 
    -0.05707098f, -0.06469224f, 0.08445687f, -0.00520777f, -0.02744283f, -0.05361107f, 0.38464883f, -0.00408279f, 
    0.09024727f, 0.16582753f, 0.02096961f, 0.01594385f, -0.02533364f, 0.01067573f, 0.17927946f, 0.49581599f, 
    -0.24404733f, 0.05156614f, 0.11321140f, 0.00884124f, 0.11257169f, -0.02168655f, 0.09378105f, 0.03548044f, 
    -0.24142331f, -0.10860626f, -0.03722777f, -0.05017006f, 0.05322644f, -0.00581601f, -0.04401236f, 0.10445593f, 
    0.00438627f, -0.13852327f, 0.05087103f, 0.17344126f, -0.04651755f, 0.03703780f, 0.01256939f, -0.12878875f, 
    -0.03201745f, 0.01573810f, 0.05171079f, -0.04880627f, -0.34371552f, 0.03919962f, 0.08644409f, -0.07273094f, 
    0.06338467f, 0.10415179f, 0.02681348f, 0.46040648f, 0.03093755f, 0.01422618f, -0.02177224f, 0.04988788f, 
    0.11137378f, -0.01089003f, -0.04014388f, 0.00117501f, -0.00288543f, -0.01932001f, 0.10393754f, -0.06592423f, 
    0.01940288f, 0.08588430f, 0.12796627f, 0.11051907f, 0.03109254f, 0.03166374f, 0.05536183f, -0.21392396f, 
    0.18073036f, 0.06368538f, -0.09033891f, 0.05354811f, 0.01554413f, 0.06331579f, -0.28454170f, -0.16670622f, 
    -0.39276275f, -0.02898537f, 0.05719901f, -0.04102689f, -0.08873672f, -0.06811697f, 0.01573535f, 0.01649655f, 
    0.06929269f, 0.18062212f, 0.06273816f, 0.03903823f, -0.20552947f, -0.01302283f, 0.01740373f, 0.12170242f, 
    -0.03907356f, -0.07690934f, -0.28625041f, -0.06537066f, 0.09320123f, 0.09011759f, -0.05415221f, -0.02159884f, 
    0.04684464f, -0.00099691f, -0.07395618f, 0.06579317f, 0.09096856f, 0.10015155f, -0.04278351f, 0.02152893f, 
    0.01245684f, 0.00458345f, -0.14311922f, -0.26903242f, -0.08526263f, -0.03675112f, 0.05203315f, 0.02922478f, 
    -0.10262755f, 0.04197406f, -0.08093762f, -0.22898830f, 0.01832011f, -0.07093998f, -0.06158418f, 0.00892015f, 
    0.05407334f, 0.14425550f, -0.02239820f, 0.07277006f, -0.10852744f, 0.05998925f, 0.08307635f, -0.10272681f, 
    -0.01137226f, 0.04593025f, 0.11533582f, 0.13854200f, -0.01402468f, -0.00942743f, -0.16425832f, -0.45227367f, 
    0.04393979f, 0.01633238f, -0.10734787f, 0.05855214f, 0.00653380f, 0.07122334f, 0.09060080f, -0.30219465f, 
    -0.39731139f, 0.13761893f, 0.03169899f, 0.20973298f, -0.09607115f, -0.09614297f, 0.10264754f, -0.19598193f, 
    0.18958618f, 0.20193516f, -0.03912295f, 0.14693680f, -0.13698812f, 0.02212287f, 0.14690216f, -0.00822491f, 
    0.02794162f, 0.05784664f, -0.06252784f, -0.06283437f, -0.01268233f, 0.04010532f, 0.01620234f, 0.05069102f, 
    0.01282169f, -0.02216203f, 0.18797354f, -0.22050092f, 0.03461358f, 0.11887515f, 0.00276394f, -0.07717502f, 
    0.03827294f, -0.03313269f, 0.07642721f, 0.22561130f, 0.12059458f, 0.10864276f, -0.00568276f, -0.01301844f, 
    0.03859979f, -0.01714334f, 0.02779999f, -0.12337185f, -0.06436244f, -0.21720570f, 0.23360780f, -0.08546302f, 
    -0.00316999f, 0.19339162f, -0.03921326f, 0.01331478f, -0.20972373f, 0.08135806f, 0.19648272f, 0.06973279f, 
    0.11961991f, 0.02167091f, 0.12982333f, -0.01418336f, -0.05132814f, -0.04865523f, -0.12322547f, -0.08288687f, 
    -0.20211340f, -0.00258503f, 0.11014657f, -0.02746294f, -0.07634111f, -0.01011786f, -0.16544405f, 0.06065351f, 
    -0.02710705f, 0.10843830f, 0.08276264f, -0.02688279f, -0.05804031f, -0.19359405f, -0.12621173f, 0.05206758f, 
    0.09626398f, -0.04820107f, -0.04912206f, -0.02426407f, 0.03442421f, 0.03555222f, 0.01515956f, 0.25449646f, 
    -0.11714460f, -0.27700675f, -0.08457918f, -0.07224479f, -0.02797661f, -0.00355755f, -0.03530934f, -0.00182889f, 
    0.01610243f, -0.35165852f, -0.12645891f, -0.32312381f, -0.06001200f, 0.16265967f, -0.18675913f, 0.12760785f, 
    0.12397113f, 0.14143929f, -0.28013965f, -0.08632008f, 0.14158805f, 0.02675594f, 0.04706429f, 0.01668699f, 
    0.04134452f, -0.03547689f, 0.06672267f, -0.14405645f, 0.05453723f, -0.07687900f, 0.11971080f, 0.01972171f, 
    0.05304281f, -0.05123300f, -0.02064949f, -0.13462952f, -0.28459200f, 0.04554853f, -0.35401365f, 0.00284498f, 
    -0.03580125f, 0.10259144f, 0.10380224f, -0.09303044f, -0.08078115f, 0.12452828f, 0.04314792f, 0.11378416f, 
    0.00367386f, 0.12520565f, 0.03030389f, 0.10018386f, -0.05037666f, 0.04359734f, -0.11200482f, 0.19051939f, 
    -0.05058177f, 0.08138646f, 0.04373776f, 0.05820358f, 0.00935659f, 0.17200735f, 0.02834638f, -0.21039753f, 
    0.18801686f, 0.11228197f, -0.07628112f, -0.00699366f, 0.01300063f, 0.16790816f, -0.03641224f, 0.04085590f, 
    0.10494862f, 0.06618837f, -0.10143149f, 0.02585615f, 0.13239796f, 0.00870950f, 0.01047801f, 0.19783653f, 
    0.08279981f, -0.35980615f, 0.01765637f, 0.11340442f, -0.08662566f, 0.19698741f, 0.06530979f, -0.09137895f, 
    -0.16451861f, -0.03452257f, -0.17767537f, -0.25486237f, 0.01053921f, 0.02722966f, 0.05952590f, -0.00045746f, 
    -0.08621731f, -0.03027014f, 0.03857462f, -0.20063718f, 0.09797820f, 0.04520478f, 0.05476131f, 0.08207430f, 
    -0.03658935f, 0.00239998f, -0.00093135f, -0.02685694f, -0.16981857f, -0.05696729f, 0.06845197f, 0.13847555f, 
    -0.04505957f, -0.09510093f, -0.04822372f, -0.01821626f, 0.00050133f, -0.11703122f, -0.28928107f, -0.35920101f, 
    0.03719802f, 0.09320526f, -0.07709286f, 0.13073511f, 0.07397910f, 0.11611356f, 0.11984164f, 0.28381413f, 
    -0.18548329f, 0.06840701f, 0.06770152f, -0.02801621f, -0.09370789f, 0.02212332f, -0.25404057f, 0.01083264f, 
    0.09087428f, 0.15512401f, 0.02481019f, 0.09679031f, 0.06575922f, 0.05752864f, -0.05662000f, 0.02531929f, 
    -0.33737779f, -0.28910720f, -0.25282744f, 0.06432002f, 0.09350205f, -0.01235097f, -0.04485219f, -0.14482959f, 
    0.17533381f, -0.12444834f, 0.03389056f, -0.12879448f, 0.07870828f, 0.01936129f, -0.05028724f, 0.04474976f, 
    0.01081991f, -0.07256755f, -0.20442088f, 0.06701908f, -0.32820433f, 0.06264388f, 0.00185804f, 0.11638679f, 
    -0.00780028f, -0.05793766f, 0.01694515f, 0.40267116f, 0.06518409f, 0.18940824f, -0.02424550f, -0.08035374f, 
    -0.08372443f, 0.12726600f, 0.18315923f, 0.04165374f, 0.17626992f, -0.07282835f, -0.08216441f, -0.04611325f, 
    -0.08977968f, -0.07187191f, 0.05953544f, 0.03652776f, 0.16193251f, -0.11040027f, 0.03326042f, 0.02875455f, 
    -0.12519747f, 0.11866824f, -0.18794875f, -0.11121354f, 0.05481539f, 0.07691349f, -0.11640272f, -0.23235284f, 
    -0.09195373f, 0.07376540f, 0.01014751f, 0.11998650f, -0.04331788f, -0.14523126f, -0.20024277f, 0.16953935f, 
    0.06093953f, 0.20953441f, 0.07899798f, 0.08041964f, 0.06252565f, 0.09520379f, 0.04168224f, 0.10364133f, 
    0.03748989f, 0.20586941f, -0.27745163f, 0.12512062f, -0.09524354f, 0.22912426f, -0.03140410f, -0.01974967f, 
    -0.08371270f, -0.01847404f, 0.15412517f, -0.18326409f, -0.01727552f, -0.01013598f, -0.14188430f, -0.00478556f, 
    -0.02914973f, -0.10218902f, 0.10437622f, -0.02392808f, 0.07166091f, -0.01133869f, 0.06775330f, -0.06099813f, 
    -0.01631257f, 0.08168148f, -0.00281480f, 0.11172441f, 0.11681966f, -0.08329442f, 0.06994926f, 0.04484401f, 
    0.10431854f, -0.18098202f, -0.07602690f, -0.00412111f, -0.04465614f, 0.12337344f, 0.01162884f, -0.02903314f, 
    -0.00108086f, -0.01928871f, -0.00341929f, -0.08739620f, 0.07179783f, -0.22275020f, 0.17198946f, -0.17713244f, 
    0.26343530f, -0.04952771f, 0.01998836f, -0.03363545f, -0.05715176f, 0.01221057f, 0.10535410f, -0.04298938f, 
    -0.07669131f, -0.02211026f, -0.16229682f, 0.11320987f, -0.01905460f, -0.05458784f, 0.12015671f, 0.30558529f, 
    0.11366746f, -0.16283450f, 0.03781664f, 0.01936034f, 0.19421355f, 0.10713600f, -0.03876786f, 0.01663884f, 
    0.01588410f, -0.14670850f, -0.18513039f, 0.18133609f, 0.08123536f, 0.22812125f, 0.04137648f, -0.11140701f, 
    -0.08005824f, 0.02091415f, 0.02187994f, -0.16931473f, -0.03593722f, -0.00840766f, 0.12611936f, -0.01184134f, 
    -0.06286478f, -0.04451543f, -0.10124994f, -0.27212161f, 0.03857453f, -0.10284182f, -0.12207518f, 0.07404577f, 
    0.03784151f, 0.05567235f, 0.03353846f, -0.09658709f, -0.08224230f, 0.15833090f, -0.15560444f, -0.05267234f, 
    -0.00804880f, 0.04235427f, 0.07786489f, 0.03717232f, 0.03993667f, -0.04152238f, -0.17809926f, -0.13473949f, 
    -0.04312600f, -0.19583681f, -0.07859202f, -0.13210300f, -0.12457731f, 0.23999022f, 0.00294541f, 0.17133652f, 
    0.07642753f, -0.03737256f, -0.03679404f, 0.05892666f, 0.13006808f, 0.15692037f, 0.21641555f, 0.10085078f, 
    0.00524780f, 0.03972462f, 0.01769256f, -0.06431915f, 0.04260827f, 0.03753490f, 0.00498643f, -0.04796701f, 
    -0.03045399f, -0.01012741f, 0.03741696f, -0.04294102f, -0.26799420f, -0.01088209f, 0.06707174f, 0.08970845f, 
    -0.07683077f, -0.12852015f, -0.25854322f, 0.00492215f, -0.01283871f, 0.16684778f, 0.09167816f, -0.10102107f, 
    -0.15432742f, 0.02688168f, 0.01168884f, 0.01651026f, 0.21967833f, -0.13250712f, 0.02650303f, 0.12503900f, 
    0.14588834f, 0.19839469f, 0.09570347f, 0.30091658f, 0.01428183f, -0.00112289f, -0.09855161f, 0.19578899f, 
    0.06484305f, 0.08368429f, 0.01413646f, -0.07909261f, 0.09089178f, -0.10698910f, 0.00100914f, 0.00448065f, 
    0.03185904f, -0.14717025f, 0.12527408f, -0.02256806f, 0.16988342f, 0.15622814f, -0.04267538f, 0.09180821f, 
    -0.04038075f, -0.00581854f, 0.11387650f, 0.00275160f, 0.09644976f, -0.17750500f, -0.01549145f, -0.02407906f, 
    0.03289633f, 0.03103462f, 0.09655585f, 0.12049767f, 0.02965419f, -0.09456766f, 0.22372052f, -0.11142177f, 
    -0.07509171f, 0.02548662f, -0.23836201f, -0.06281000f, 0.01052336f, 0.07385430f, -0.08344024f, 0.07754616f, 
    -0.08487296f, -0.05117819f, -0.07258481f, -0.07378935f, 0.13572806f, -0.07230206f, -0.11404591f, 0.00003248f, 
    -0.23547053f, 0.11318667f, 0.15277660f, -0.02276756f, 0.06938082f, -0.05751828f, -0.17921181f, 0.01264946f, 
    -0.03051058f, 0.03821774f, -0.12559702f, -0.07023694f, 0.05092482f, -0.04673377f, -0.03353972f, 0.11011454f, 
    0.10017008f, 0.03905759f, 0.21520334f, 0.04168467f, -0.14009640f, -0.07195783f, 0.03794859f, 0.05950263f, 
    0.03964182f, -0.01115600f, -0.01851357f, -0.05314526f, -0.29464790f, -0.05193683f, 0.06476972f, 0.14735180f, 
    -0.02259551f, -0.00801594f, -0.09988248f, -0.16940978f, 0.08795422f, 0.02076616f, -0.23807873f, 0.18042332f, 
    -0.08022377f, 0.21965408f, -0.06716614f, -0.09714819f, -0.24187058f, 0.09660461f, 0.10849243f, 0.12924875f, 
    -0.06390780f, 0.05558005f, 0.01627964f, 0.22761072f, -0.06744511f, -0.07440239f, -0.11070725f, -0.03485623f, 
    0.17272986f, 0.04894512f, -0.09254166f, 0.07299074f, 0.18531851f, 0.14023949f, 0.05073860f, 0.02508294f, 
    0.09167305f, 0.06795297f, 0.05562836f, 0.09363922f, -0.09792067f, -0.02274972f, 0.12635139f, 0.13958207f, 
    -0.02932438f, 0.00070246f, -0.00433541f, -0.04682126f, -0.03004946f, -0.02306999f, -0.04594946f, 0.00191283f, 
    -0.01892147f, -0.00125397f, -0.04521013f, -0.00565372f, -0.04630734f, -0.01393061f, 0.03642312f, -0.00203391f, 
    -0.05285384f, 0.04362005f, 0.04846799f, -0.00137979f, 0.04507820f, 0.00411336f, 0.04119986f, 0.00625274f, 
    0.00202602f, -0.05016185f, 0.01495675f, -0.01182643f, 0.02214751f, -0.05893136f, -0.03925556f, -0.02861725f, 
    -0.03937830f, -0.00609024f, 0.01741897f, 0.00103932f, -0.05730651f, -0.02507688f, -0.05411996f, 0.04293194f, 
    0.00707898f, 0.02068179f, -0.03591949f, 0.02209822f, 0.01513601f, -0.05405986f, 0.01698846f, -0.06829828f, 
    -0.05312396f, -0.00181178f, -0.00311192f, -0.00936633f, 0.00037203f, 0.02068659f, -0.04770304f, -0.04278426f, 
    0.02966426f, 0.04320981f, -0.05792965f, -0.03231606f, -0.00187057f, -0.04570745f, -0.02236939f, -0.01898986f, 
    -0.05346196f, 0.01010261f, -0.06351864f, 0.01871048f, -0.03047675f, -0.01203299f, 0.02126260f, -0.02274667f, 
    0.01759120f, -0.01592548f, -0.03951414f, -0.02304196f, -0.02743902f, 0.00810441f, -0.03774785f, -0.04794377f, 
    -0.02330965f, -0.00015776f, -0.03810391f, -0.00562353f, -0.03659179f, 0.03646091f, -0.05951340f, 0.00683879f, 
    -0.03586461f, -0.02256302f, 0.01594622f, 0.01010372f, -0.05204785f, -0.00498345f, 0.03533699f, 0.04434101f, 
    -0.00263576f, 0.01282897f, 0.03974424f, 0.02574903f, 0.00781116f, 0.02874245f, 0.03882219f, 0.03967725f, 
    0.03681031f, -0.04423732f, -0.06660147f, -0.02621056f, 0.03688020f, 0.02566488f, -0.04322048f, -0.02937140f, 
    0.03661692f, 0.00647883f, 0.01534508f, -0.02045527f, 0.00818022f, 0.04414334f, -0.03728906f, 0.05463272f, 
    -0.03153434f, -0.06419070f, -0.03792050f, -0.06592233f, 0.01674493f, -0.02404339f, -0.06561290f, 0.03528171f, 
    0.01501649f, -0.03962744f, -0.02348031f, 0.03221632f, -0.05652807f, -0.05604241f, 0.02079297f, 0.02526941f, 
    0.01824081f, -0.05055076f, 0.01889435f, -0.01540115f, -0.03270715f, -0.06501676f, -0.05994229f, -0.04520985f, 
    -0.02657333f, 0.01107984f, 0.04540304f, 0.00480392f, 0.03023744f, 0.02753987f, -0.06062496f, -0.02307705f, 
    -0.00989530f, 0.03580023f, -0.04592609f, 0.01523285f, -0.00638317f, -0.05474278f, 0.01601957f, 0.00599193f, 
    0.02864093f, -0.06119232f, -0.05086692f, -0.01208801f, 0.01250913f, -0.01730334f, -0.04977272f, 0.00519681f, 
    -0.00491823f, 0.03501330f, -0.04103554f, -0.05423586f, 0.00324473f, -0.00118254f, -0.03765060f, 0.02369154f, 
    -0.04768615f, -0.03450537f, 0.02839890f, -0.00466748f, -0.00304190f, -0.03148117f, 0.05962806f, -0.00127495f, 
    -0.03967546f, 0.04834613f, -0.03007992f, 0.00773375f, 0.04344980f, 0.03680257f, 0.04660108f, -0.02968895f, 
    -0.00236367f, -0.02398235f, -0.00800100f, -0.02699062f, -0.04453577f, -0.03259184f, -0.00824176f, -0.04136811f, 
    0.05442547f, -0.04118692f, -0.04095234f, 0.01499139f, -0.04858777f, 0.02694776f, -0.04311078f, -0.04442903f, 
    -0.01083392f, 0.00315064f, -0.02723399f, -0.01099200f, -0.02805686f, 0.00237367f, 0.02259726f, 0.01662898f, 
    0.00451002f, -0.03914879f, 0.00656900f, -0.03569904f, -0.06392940f, -0.05333693f, 0.01577756f, 0.02807814f, 
    0.01427813f, 0.02155360f, 0.04548692f, 0.03089509f, -0.06878075f, -0.06416640f, -0.03633373f, 0.00669307f, 
    -0.04397316f, -0.04991959f, 0.03167722f, 0.03671219f, -0.06168527f, 0.03624343f, 0.01684977f, -0.05425690f, 
    -0.05346708f, -0.02847710f, 0.01197157f, 0.00278165f, 0.00152593f, -0.02043346f, 0.04561590f, -0.04199413f, 
    0.02358682f, -0.01044587f, 0.01389973f, 0.03124129f, -0.06547704f, -0.04903770f, 0.02317691f, -0.05992825f, 
    0.04290576f, 0.01427941f, -0.00537224f, -0.02692414f, -0.04867066f, 0.00533105f, 0.01202814f, -0.01820199f, 
    0.03245555f, 0.01754205f, 0.01367278f, 0.02225366f, 0.03562136f, -0.01546898f, 0.04232336f, -0.01479548f, 
    0.04452838f, -0.03431994f, 0.01394604f, -0.04375860f, 0.00647834f, -0.06535921f, 0.01490554f, -0.01247492f, 
    -0.01448851f, 0.04377982f, -0.03850207f, 0.01696030f, -0.03293971f, 0.00549669f, -0.00368724f, 0.02331332f, 
    -0.02418324f, -0.03830099f, -0.04656979f, -0.04501040f, -0.02988129f, 0.05054942f, -0.03668983f, -0.00942960f, 
    -0.03046707f, -0.06381805f, -0.03199420f, -0.03670952f, 0.05330352f, -0.04431828f, 0.00351170f, 0.02604936f, 
    -0.05061826f, -0.04221009f, 0.04427851f, -0.03827730f, 0.03961562f, -0.01015331f, -0.04117830f, 0.04640307f, 
    -0.06179633f, -0.01962195f, 0.04302308f, -0.01640475f, -0.04789152f, -0.01324694f, 0.00874751f, 0.03329497f, 
    0.00498966f, 0.02170893f, 0.03888198f, -0.01560985f, 0.02392000f, 0.03562169f, -0.03624795f, -0.05314674f, 
    -0.04782516f, -0.04396308f, 0.00163933f, 0.05809527f, 0.01027771f, -0.00147238f, 0.03778065f, -0.04347008f, 
    -0.02668012f, -0.01642055f, -0.04317552f, 0.04228862f, 0.02662216f, -0.04906251f, -0.00901704f, -0.03340633f, 
    -0.02081290f, -0.02473117f, 0.03502503f, -0.05836084f, -0.06507320f, -0.03114717f, 0.05164882f, -0.00288907f, 
    0.00288046f, -0.02426769f, -0.01225936f, -0.03757656f, -0.01320119f, 0.03051270f, 0.02815142f, -0.02811405f, 
    -0.02111979f, 0.00502723f, -0.05462309f, -0.06148130f, -0.03388697f, 0.03455569f, 0.02074272f, 0.00093627f, 
    -0.02803191f, -0.05033031f, 0.01273687f, 0.03186877f, 0.04288838f, 0.00009364f, -0.06300707f, -0.01718551f, 
    -0.01727361f, 0.04445793f, -0.04665980f, 0.03880908f, 0.03101283f, 0.04289114f, -0.01147653f, -0.05129972f, 
    -0.02702612f, -0.06056338f, 0.02991166f, 0.02088961f, 0.01461148f, -0.05172436f, 0.03810704f, 0.00919107f, 
    -0.01271755f, 0.01015049f, -0.02534102f, 0.05787281f, -0.03359040f, -0.02922281f, 0.03845674f, 0.00755321f, 
    0.01363616f, -0.01501283f, -0.02104151f, -0.03367348f, 0.04498567f, -0.03490045f, 0.02003372f, -0.05776092f, 
    -0.03078500f, -0.01062176f, 0.04574493f, 0.02549669f, 0.04290890f, -0.01188170f, 0.04734438f, -0.01692113f, 
    0.01962681f, -0.04988444f, -0.04956304f, -0.01175787f, -0.00837221f, 0.01781899f, 0.03336657f, -0.00470137f, 
    -0.03929264f, 0.02951227f, 0.03179545f, -0.03365856f, -0.02539525f, 0.02854464f, 0.06002615f, 0.03931957f, 
    0.00644332f, -0.01567506f, -0.02474052f, 0.01105970f, -0.00338361f, -0.01918681f, 0.00717616f, 0.02747845f, 
    -0.04389512f, 0.00641971f, -0.05194203f, -0.06662982f, -0.05946369f, -0.02012577f, 0.01380166f, 0.00641437f, 
    -0.04760916f, -0.00762574f, -0.04816214f, -0.00078472f, -0.00494266f, -0.04706047f, 0.02085278f, 0.04306125f, 
    0.02099874f, 0.05162080f, 0.02334958f, 0.02681891f, 0.04940630f, -0.02332598f, 0.00548919f, -0.03693587f, 
    -0.00415243f, 0.00486019f, 0.00255977f, 0.00052893f, -0.03507628f, -0.02791833f, 0.01123540f, -0.03644899f, 
    -0.01388425f, -0.01424797f, -0.05451237f, 0.00598292f, -0.01975220f, -0.01734924f, -0.05640589f, 0.02064857f, 
    -0.02271504f, 0.04387387f, -0.02624192f, -0.05686265f, -0.03334921f, -0.05507391f, 0.02461905f, 0.00126471f, 
    -0.00503317f, -0.03928556f, -0.03393640f, 0.00975417f, 0.06040737f, -0.05795486f, 0.00262353f, -0.05391407f, 
    -0.03615953f, -0.04481871f, 0.05670113f, 0.00228515f, 0.01799013f, -0.01862221f, 0.02252173f, -0.04790523f, 
    -0.04575212f, -0.03253693f, -0.01867888f, -0.02525810f, 0.03258009f, -0.01590523f, -0.00678390f, -0.03486265f, 
    0.03722227f, -0.00102021f, -0.00158314f, 0.03285706f, 0.05295983f, -0.04034103f, -0.01964329f, 0.03909100f, 
    -0.04075605f, 0.00670967f, -0.03331419f, -0.06610169f, 0.02420834f, 0.01529059f, -0.00541450f, -0.03781345f, 
    -0.04487980f, 0.00618443f, 0.02180233f, -0.05689304f, -0.00602970f, -0.02804791f, -0.02951065f, -0.00187155f, 
    -0.01718113f, -0.05338636f, 0.03799522f, 0.00857389f, -0.00849287f, -0.02784063f, -0.05160262f, -0.01647633f, 
    0.05520408f, 0.02986681f, -0.01042635f, -0.00790537f, 0.04077160f, -0.01561925f, -0.00405173f, -0.00935855f, 
    -0.01133870f, 0.01318683f, -0.04827653f, 0.04754655f, -0.03771757f, -0.02272284f, -0.01815090f, -0.01492522f, 
    0.03617698f, -0.05960359f, 0.02092252f, -0.03865768f, -0.02212442f, 0.03670234f, -0.04799460f, -0.00229142f, 
    -0.03063998f, -0.03923122f, -0.05001708f, 0.04559288f, -0.06016698f, 0.04848379f, 0.04421378f, 0.00564892f, 
    0.14973210f, -0.07925488f, 0.22673903f, -0.00519190f, -0.01647554f, -0.00598648f, -0.02375492f, 0.05456039f, 
    -0.01170416f, 0.02978736f, 0.07089876f, -0.20565677f, 0.23373550f, 0.14372151f, 0.03165601f, 0.13448147f, 
    -0.04428963f, -0.05522930f, -0.03101678f, 0.05312904f, 0.21689217f, 0.10311663f, 0.06357392f, -0.12497920f, 
    0.11965936f, 0.01999194f, 0.10756655f, -0.22175911f, -0.17992622f, -0.01427386f, -0.03305481f, -0.07392797f, 
    -0.05865595f, -0.05380813f, 0.07937350f, -0.13097067f, 0.05600508f, 0.02003258f, 0.06804821f, -0.02546989f, 
    -0.14128861f, 0.01172847f, 0.09643474f, -0.07062749f, -0.00847698f, -0.10222889f, -0.21247357f, 0.09567115f, 
    -0.06454786f, -0.01812365f, 0.03361363f, 0.02368461f, 0.04173357f, -0.08486917f, 0.11663381f, 0.07505853f, 
    -0.04892852f, -0.01704011f, -0.11011904f, -0.13064384f, -0.24899378f, 0.18467669f, 0.08268297f, -0.01798138f, 
    0.12194113f, -0.10849476f, -0.08825766f, -0.09810671f, 0.00479343f, -0.12139069f, 0.16007350f, 0.05188351f, 
    -0.04110449f, 0.08328104f, 0.22265747f, -0.15880203f, 0.03052075f, 0.06359584f, -0.03115638f, -0.19293086f, 
    0.09291728f, 0.12860116f, -0.20846918f, -0.21883823f, 0.10766478f, 0.00621872f, -0.11106484f, 0.04491164f, 
    0.02907480f, 0.06173184f, 0.22690699f, 0.03871554f, 0.32143837f, -0.14860341f, 0.04507702f, 0.06230940f, 
    -0.10041968f, -0.05981237f, 0.02029618f, -0.24201946f, 0.07358037f, 0.00995764f, 0.05320847f, 0.22900234f, 
    0.05797124f, 0.06083397f, 0.03113836f, 0.11767229f, 0.52609909f, 0.33896524f, 0.02347385f, 0.10009570f, 
    0.10009187f, -0.05940628f, -0.02710238f, -0.14207280f, -0.04775311f, -0.02475409f, -0.11000985f, -0.31776309f, 
    -0.05701709f, -0.08258637f, -0.03164636f, 0.01585266f, 0.07942443f, 0.04018039f, 0.04249366f, 0.05022766f, 
    -0.06025065f, 0.13978903f, 0.02287813f, -0.14089665f, 0.05533897f, 0.01129263f, 0.06444646f, 0.50806946f, 
    0.15731120f, 0.03274265f, 0.08323827f, 0.00115011f, -0.20600507f, 0.04066256f, -0.02273872f, -0.05812694f, 
    -0.28390995f, -0.32857734f, -0.04511548f, 0.05258143f, 0.11468139f, -0.07221313f, -0.05250786f, -0.04281090f, 
    -0.20854203f, 0.39449134f, -0.00158155f, -0.06717690f, -0.10113626f, -0.12077419f, 0.08538314f, -0.06882159f, 
    0.03528975f, 0.03582735f, -0.03962968f, -0.20322856f, -0.35903314f, 0.00177885f, 0.03393829f, 0.00796318f, 
    -0.03033116f, 0.19531015f, 0.17081721f, 0.24517688f, -0.02149505f, -0.21326788f, -0.11819015f, 0.05518233f, 
    -0.05262468f, 0.06201174f, -0.02878456f, 0.15161003f, -0.20762281f, 0.02850532f, -0.15132919f, -0.14017674f, 
    -0.10406964f, 0.10142539f, 0.03833104f, 0.01585443f, 0.16662088f, 0.01498204f, -0.27846274f, 0.05159535f, 
    0.12189702f, 0.04535513f, -0.00318729f, -0.02494300f, 0.14473973f, -0.08684134f, -0.05431043f, 0.09725643f, 
    -0.37442687f, 0.01046425f, -0.03251152f, 0.03272273f, -0.08231239f, -0.02604510f, 0.03540684f, -0.07933766f, 
    0.03429029f, 0.04274762f, -0.08634493f, -0.09636256f, -0.07912961f, 0.02703890f, 0.07001656f, 0.06667188f, 
    -0.23728012f, 0.38756561f, -0.33927032f, 0.02368062f, 0.05941978f, -0.23372589f, 0.10079814f, 0.06439645f, 
    0.16423367f, -0.10801926f, -0.13298175f, -0.25233236f, -0.14276911f, 0.06920834f, 0.04131234f, 0.02017624f, 
    0.02049925f, 0.00586254f, -0.43610498f, 0.11544295f, -0.05756276f, -0.00600892f, 0.06606216f, 0.02196945f, 
    0.04626080f, 0.09701000f, -0.11786354f, 0.06846225f, 0.03042162f, 0.10778893f, -0.04877583f, 0.00232717f, 
    0.22822475f, 0.06381158f, 0.21670157f, -0.07888283f, 0.02243029f, -0.00134592f, 0.24487789f, 0.04715606f, 
    -0.06288652f, 0.08404528f, -0.15120916f, -0.08426670f, 0.15447663f, -0.26278964f, 0.04805999f, 0.08097328f, 
    0.02916114f, -0.17727403f, -0.06858742f, -0.05641671f, 0.13534853f, -0.00932462f, -0.46003225f, 0.08956203f, 
    0.12012900f, 0.01461892f, 0.11982861f, 0.15228318f, -0.10596272f, -0.00462645f, 0.04997123f, 0.17637160f, 
    0.19087699f, 0.05131289f, -0.01337363f, -0.07687926f, -0.04282644f, 0.01490097f, 0.03695485f, 0.00056557f, 
    0.23713440f, -0.00066622f, -0.21209764f, 0.04887024f, 0.05248363f, -0.06745935f, 0.08135130f, -0.04856288f, 
    0.12122547f, -0.05967483f, -0.11637630f, 0.25403625f, -0.09524450f, -0.13590497f, 0.10568732f, -0.10446448f, 
    0.08382203f, 0.17009971f, -0.22348925f, 0.07134662f, -0.07505409f, 0.03574741f, -0.13822152f, 0.00431620f, 
    -0.01486252f, -0.02901649f, -0.03036936f, 0.02516596f, -0.02399642f, 0.00082250f, 0.32642427f, 0.12385956f, 
    -0.05751771f, 0.02046173f, -0.01675243f, 0.09799124f, 0.04141365f, 0.12969393f, -0.10851362f, -0.02594129f, 
    0.04566460f, -0.02814572f, 0.10832602f, -0.01796569f, -0.28455499f, 0.02093892f, 0.17528839f, -0.18441859f, 
    0.04282186f, -0.05752864f, 0.21305534f, -0.15246302f, -0.17099459f, 0.17164825f, 0.44389153f, 0.12246155f, 
    0.00919322f, -0.14800794f, -0.00370422f, -0.03722698f, -0.11840121f, 0.06069408f, 0.02576292f, 0.15479036f, 
    0.20838442f, -0.27388361f, 0.20070650f, -0.12090785f, -0.08242168f, 0.07412155f, 0.03398868f, -0.07131537f, 
    -0.21967955f, 0.15560888f, -0.36971077f, 0.17629725f, -0.08160404f, 0.04031302f, -0.17991145f, 0.10198376f, 
    0.15859036f, -0.06838989f, -0.00194663f, -0.00434987f, 0.05103939f, -0.15485257f, 0.03663759f, -0.03882511f, 
    -0.05525662f, -0.04563431f, 0.03116764f, -0.10067803f, 0.01079372f, 0.08097535f, -0.05009933f, -0.07550074f, 
    -0.05590594f, -0.03066668f, 0.06745011f, 0.09246755f, -0.00154061f, 0.24314196f, -0.05851598f, -0.02360820f, 
    -0.00910262f, -0.10022008f, -0.00900582f, 0.08971635f, 0.11074980f, -0.15387009f, 0.27234054f, -0.08042466f, 
    -0.15614724f, 0.11939438f, -0.01274897f, -0.00127790f, 0.03510771f, 0.07487950f, -0.06260896f, 0.10270685f, 
    0.03735884f, 0.04466170f, -0.00630846f, 0.05427537f, -0.05194188f, -0.20284039f, 0.07538942f, -0.17595792f, 
    -0.10338935f, -0.00352025f, 0.00666660f, 0.13442773f, 0.05401757f, 0.03061284f, 0.01188133f, -0.09337959f, 
    -0.08984423f, -0.10978999f, 0.06788524f, -0.01509139f, 0.09126430f, 0.01191069f, 0.01514625f, -0.05459317f, 
    -0.11908497f, -0.02431297f, -0.10183894f, 0.11360200f, -0.01511015f, -0.15511890f, 0.16084428f, -0.02230091f, 
    0.10520624f, 0.16579282f, -0.06666897f, -0.40476176f, 0.12490921f, -0.07185949f, 0.04521378f, -0.07252394f, 
    -0.10079707f, 0.01466623f, -0.06807415f, -0.03238301f, -0.02309210f, 0.10463235f, -0.06234942f, 0.11892891f, 
    0.05004311f, -0.01877501f, -0.10817139f, 0.15239902f, -0.18499425f, -0.06358864f, -0.09898356f, -0.00042328f, 
    -0.02854275f, 0.01115732f, 0.00807193f, -0.10882469f, 0.01553828f, 0.05898510f, 0.08625831f, 0.05179955f, 
    -0.09349106f, -0.02730907f, 0.04152108f, -0.01185075f, 0.11922844f, 0.09149989f, 0.19905208f, 0.16646098f, 
    -0.07687626f, -0.09156176f, -0.07828220f, -0.07090497f, -0.03446496f, 0.01825514f, 0.01513201f, -0.02042847f, 
    0.16002287f, -0.18351685f, 0.04801981f, 0.02397161f, 0.03383655f, 0.07399182f, 0.16273384f, 0.04442994f, 
    0.06324338f, -0.19468620f, 0.03206280f, -0.07837215f, -0.08477838f, 0.06495922f, -0.06035546f, 0.02896832f, 
    -0.13292325f, -0.08115592f, 0.31698900f, -0.07628360f, -0.02326868f, 0.05338788f, 0.08517691f, 0.09677912f, 
    0.20870960f, 0.15942642f, 0.08116817f, 0.29642317f, -0.10358232f, -0.01367930f, -0.02086687f, 0.01891085f, 
    0.10928365f, -0.18515946f, 0.02143948f, 0.05411489f, 0.07883006f, 0.15726925f, 0.02912146f, 0.01601775f, 
    -0.03734320f, -0.00883857f, -0.03515255f, -0.11160472f, -0.10284990f, -0.18536465f, -0.08329879f, 0.02420814f, 
    -0.10098368f, 0.01366911f, 0.10109155f, 0.08820093f, 0.09106943f, 0.15538299f, -0.22857818f, 0.00219275f, 
    0.05780170f, -0.11358711f, 0.13182685f, 0.03045149f, 0.00701584f, -0.10785877f, -0.17586319f, -0.13968082f, 
    -0.07405088f, -0.06624126f, 0.19526578f, -0.06068711f, -0.09595601f, 0.05978355f, 0.16488381f, -0.10459768f, 
    -0.11735284f, -0.13236651f, 0.11563354f, 0.09302074f, -0.02730153f, 0.06023116f, -0.07574551f, 0.08362558f, 
    0.06534678f, -0.03771452f, -0.04405802f, 0.01428221f, -0.00569631f, 0.01238506f, -0.02799994f, -0.15268621f, 
    0.06523516f, 0.08653310f, 0.17140467f, 0.16316730f, 0.03551359f, -0.03602041f, 0.08845405f, -0.00053791f, 
    -0.00412353f, 0.12504986f, -0.08323538f, 0.27323329f, -0.04365117f, 0.04388793f, 0.02936449f, -0.13327144f, 
    0.04287742f, 0.09051646f, -0.06130799f, -0.09094969f, -0.21525641f, 0.09181975f, -0.14379787f, -0.00555686f, 
    -0.00965996f, 0.05709485f, -0.10555588f, -0.18879926f, 0.12394339f, -0.06593955f, 0.05019311f, -0.00739072f, 
    -0.03205769f, -0.04767752f, 0.13238722f, 0.07986419f, -0.18741940f, -0.33989018f, -0.10397892f, 0.20485723f, 
    0.11504831f, 0.06541807f, 0.05432418f, 0.00116118f, -0.01401012f, 0.14262408f, 0.09085915f, 0.03628900f, 
    -0.07391808f, -0.16238692f, 0.03691482f, -0.03931209f, -0.06994802f, -0.17080726f, -0.27577904f, -0.35207313f, 
    -0.16376449f, 0.00487533f, 0.19726186f, -0.02878645f, 0.04340655f, -0.01126316f, -0.05254847f, 0.03814396f, 
    0.08974541f, 0.24979183f, 0.02285364f, -0.08157195f, -0.02148474f, -0.02563657f, 0.02527414f, 0.04211401f, 
    0.28477600f, 0.01186610f, 0.00429287f, 0.05315223f, -0.10914765f, 0.07719579f, 0.02353994f, 0.13589586f, 
    0.01121104f, 0.04061939f, 0.04104651f, 0.08146277f, 0.04291525f, -0.02460914f, -0.06039490f, 0.10860001f, 
    0.15532936f, 0.06531461f, 0.05645299f, 0.09717990f, -0.16659527f, -0.05790344f, -0.01547078f, -0.01410891f, 
    0.11469756f, 0.04900503f, 0.06703290f, 0.03844133f, 0.08882001f, -0.00321836f, 0.08104326f, 0.12736745f, 
    -0.01103763f, -0.00717142f, 0.01949832f, 0.17312765f, 0.02137678f, 0.12007049f, 0.11943534f, -0.09046523f, 
    0.04980490f, -0.05110633f, -0.08574355f, 0.08815961f, -0.05403817f, -0.18014887f, -0.06208668f, 0.00100760f, 
    -0.02058075f, 0.00550190f, -0.00486586f, 0.06131064f, 0.05429026f, 0.01973314f, 0.00938650f, 0.08188514f, 
    0.00173536f, -0.04420747f, 0.11848304f, 0.10034262f, -0.11210462f, -0.00601311f, -0.00857642f, -0.27925172f, 
    0.05233078f, -0.12425036f, -0.00714679f, -0.01555864f, -0.04210982f, 0.09386050f, -0.12794197f, 0.04004690f, 
    0.09676635f, -0.06798196f, 0.10290686f, 0.10775912f, -0.05089979f, -0.04019170f, 0.03208574f, -0.02360258f, 
    -0.00994089f, -0.34010112f, -0.16772449f, 0.16540493f, -0.00780941f, 0.06219142f, -0.01614585f, 0.01375981f, 
    -0.04414817f, 0.03078920f, 0.15247719f, -0.05292869f, 0.01281261f, -0.19294953f, -0.10695150f, -0.05119110f, 
    0.23220786f, 0.05361805f, 0.02106166f, -0.29590306f, -0.06078207f, -0.14138606f, -0.00888258f, 0.09723436f, 
    -0.00564423f, -0.00270237f, -0.04257222f, -0.11702038f, -0.24000750f, -0.14120606f, -0.17260855f, 0.24357447f, 
    0.12233343f, 0.06066356f, -0.04189234f, -0.03782192f, -0.28814706f, 0.12119930f, -0.02332122f, 0.11321488f, 
    -0.03444563f, -0.02924528f, -0.19882810f, 0.01595615f, 0.02920207f, 0.03018157f, -0.02222726f, 0.08113366f, 
    0.09900334f, -0.10368754f, -0.18101792f, -0.01973707f, 0.16119596f, -0.07376052f, -0.07884505f, -0.21946231f, 
    -0.14362466f, 0.00178375f, 0.06535119f, 0.13906430f, 0.02960871f, -0.08933768f, -0.08541353f, -0.02222755f, 
    -0.08757003f, -0.08478439f, -0.06341743f, 0.03183889f, 0.08158759f, -0.09952911f, 0.11872926f, 0.01599471f, 
    0.06444832f, 0.04103999f, -0.00143021f, 0.06192571f, -0.04081700f, 0.10102595f, -0.00334975f, 0.09144765f, 
    0.14484484f, -0.04431110f, -0.03150427f, 0.05629386f, 0.00222678f, -0.01790389f, -0.15930784f, -0.18493654f, 
    0.05654933f, 0.05759887f, -0.07219864f, 0.14706965f, -0.00294526f, 0.04023933f, 0.01431349f, -0.09213997f, 
    -0.13145284f, -0.17291102f, 0.06389813f, -0.02438771f, 0.11902363f, 0.09825011f, 0.02561795f, 0.16330345f, 
    -0.10353111f, -0.09953873f, -0.08288924f, 0.10606562f, 0.01035467f, -0.14402972f, 0.09152058f, -0.00026246f, 
    0.06012608f, -0.10218054f, -0.01159902f, 0.08379328f, 0.04137907f, -0.00729107f, 0.01338543f, -0.08909563f, 
    0.09468173f, -0.02668629f, 0.14540769f, 0.03648974f, 0.09719095f, 0.11135627f, -0.05469012f, -0.25839439f, 
    -0.11098254f, -0.13279881f, 0.11530016f, 0.10505574f, 0.01058344f, -0.01043660f, 0.07958567f, -0.14945528f, 
    0.03808688f, -0.09773422f, 0.08361268f, 0.00292853f, 0.11948609f, 0.16365016f, -0.00137434f, 0.01494326f, 
    -0.12646651f, -0.05284789f, 0.08643755f, -0.13893540f, -0.08993109f, 0.10490495f, 0.01039999f, 0.13416204f, 
    -0.00261738f, -0.15140493f, 0.16891119f, 0.04630395f, 0.03171686f, 0.04343205f, 0.09711332f, -0.03839422f, 
    0.14198492f, 0.02646993f, -0.05931641f, 0.09421364f, -0.03691714f, -0.09367073f, -0.03380255f, -0.07899824f, 
    0.21289429f, 0.07891367f, -0.00782485f, -0.11389676f, 0.33227357f, 0.26156694f, 0.15901335f, -0.10354736f, 
    0.00941667f, 0.01306403f, 0.20475377f, 0.08161690f, 0.01142888f, -0.11403953f, -0.30192354f, -0.02014817f, 
    -0.10088933f, 0.22434299f, -0.01333037f, -0.02025071f, -0.11911753f, -0.13970782f, 0.30195999f, 0.10552847f, 
    0.02273381f, -0.13441724f, -0.12614821f, -0.05723605f, 0.10142551f, 0.10824572f, 0.00664096f, -0.04447534f, 
    0.10271955f, -0.02110039f, -0.09771905f, -0.00580592f, 0.15736406f, -0.02834854f, 0.05159332f, 0.01769776f, 
    -0.15200667f, 0.01750573f, 0.11302214f, -0.03537001f, -0.10472643f, -0.08200981f, -0.12931982f, -0.18321443f, 
    -0.06567044f, -0.23103674f, -0.07951353f, -0.20928784f, 0.06064675f, 0.10536312f, -0.04187044f, 0.11530928f, 
    -0.11914445f, 0.04679596f, -0.20206478f, -0.12969798f, -0.04931653f, 0.00001741f, 0.07411792f, 0.05284886f, 
    0.01429262f, 0.01035809f, 0.02458045f, -0.14905676f, 0.10019148f, -0.09300651f, 0.00429635f, 0.09249385f, 
    0.03519629f, -0.06471020f, -0.13800824f, 0.02619844f, -0.11846378f, -0.15804480f, -0.22636984f, 0.05431992f, 
    0.03510967f, 0.08123077f, 0.02219069f, -0.18635502f, -0.03505969f, 0.06253903f, -0.08359457f, 0.09540971f, 
    -0.01706190f, -0.02563353f, -0.01520554f, -0.02186911f, -0.02194549f, 0.04129616f, -0.02632298f, -0.11651648f, 
    -0.03567931f, 0.10801256f, -0.05722203f, 0.15760803f, 0.06787694f, -0.08626408f, 0.18823259f, -0.09008249f, 
    0.05378832f, -0.15889713f, -0.00957608f, -0.08567291f, -0.08703585f, 0.14144467f, -0.02625111f, 0.05741233f, 
    -0.16859013f, -0.02006674f, -0.15740180f, 0.18453583f, 0.13026778f, 0.10376437f, -0.03838700f, -0.12884437f, 
    -0.09071145f, -0.02149041f, 0.05155533f, 0.18772805f, -0.13460085f, 0.04303464f, 0.00752199f, -0.01797332f, 
    -0.01721109f, -0.06411928f, -0.28442979f, 0.00575010f, -0.08501285f, -0.07642238f, 0.19441743f, -0.04904402f, 
    -0.03743204f, -0.01416009f, 0.08488708f, 0.10918720f, 0.05527449f, -0.01349235f, 0.10431777f, -0.18020962f, 
    -0.06118895f, -0.00466529f, 0.01195051f, 0.16638160f, 0.00439189f, 0.02439676f, 0.09500373f, -0.12305439f, 
    0.06924565f, -0.04432876f, 0.09134506f, 0.08451962f, 0.01984056f, 0.02124894f, 0.00883225f, -0.15251888f, 
    -0.03784361f, 0.16539696f, -0.07411738f, -0.07561877f, -0.01435145f, -0.16683814f, 0.07035264f, -0.20249087f, 
    -0.09748090f, 0.02080842f, 0.09133551f, -0.00608976f, 0.13549140f, 0.06420685f, -0.17071295f, 0.16845351f, 
    0.24704906f, 0.20239143f, 0.00591208f, -0.15044889f, -0.05719864f, 0.01456127f, 0.16792250f, 0.09421458f, 
    0.12023950f, 0.03498386f, 0.02072739f, -0.09190004f, -0.01699284f, 0.04318126f, -0.07301331f, 0.03669173f, 
    0.00616032f, 0.10193144f, -0.20940773f, -0.04527873f, 0.01744412f, 0.10195196f, 0.05117838f, -0.11022859f, 
    0.02122696f, -0.03695740f, 0.05929195f, -0.04351257f, -0.02774648f, -0.03544274f, 0.26623774f, 0.14996555f, 
    -0.05064113f, -0.19065589f, -0.04188715f, 0.01716435f, 0.07307343f, -0.00071428f, 0.16302928f, 0.00897523f, 
    -0.11003095f, -0.09247308f, 0.12231434f, 0.13174558f, 0.01212114f, -0.10427260f, 0.06505860f, 0.03884003f, 
    -0.03871051f, 0.05930628f, 0.12561578f, -0.12431217f, 0.11929775f, -0.27367875f, -0.05837394f, -0.12882140f, 
    0.12338056f, -0.07907698f, 0.07372689f, 0.02271226f, -0.05616882f, 0.15514615f, -0.10398678f, -0.09527121f, 
    0.03307777f, 0.03119351f, 0.08294558f, -0.06429892f, -0.07848354f, -0.17880222f, 0.05172274f, 0.28855386f, 
    0.19600861f, 0.15200773f, -0.06398358f, -0.06899098f, 0.04961547f, 0.08077677f, 0.02800524f, 0.01010343f, 
    -0.04627972f, 0.00769805f, -0.00818561f, -0.04327119f, -0.00213671f, -0.05242115f, 0.02630969f, -0.01220775f, 
    0.03026965f, 0.00259141f, 0.03993698f, 0.02160441f, -0.03401229f, -0.02544318f, -0.02655729f, 0.01597251f, 
    0.03037539f, -0.00741140f, 0.02497108f, 0.01304672f, 0.02708749f, -0.05125630f, 0.02776422f, 0.02983899f, 
    -0.01193496f, -0.04615755f, -0.03075911f, -0.06492870f, 0.01380565f, -0.03265134f, 0.00557439f, 0.04086573f, 
    0.00678454f, -0.00065114f, 0.00101293f, -0.03049929f, -0.05811725f, 0.00431814f, 0.00041239f, -0.05049289f, 
    -0.02511515f, 0.00147590f, 0.00383946f, 0.03247037f, -0.05962704f, -0.01614524f, -0.05302431f, 0.00362533f, 
    -0.04668633f, -0.06387459f, -0.00255993f, -0.02345474f, 0.02436567f, -0.03627231f, -0.01761034f, -0.03915254f, 
    -0.06070571f, -0.01951529f, -0.00224789f, 0.02366283f, 0.00511908f, 0.01744580f, -0.02179956f, -0.02611396f, 
    -0.01613392f, -0.00697898f, 0.05018481f, -0.01790023f, 0.02618167f, 0.04555375f, 0.00251425f, 0.01965913f, 
    0.04209737f, 0.04508949f, -0.05599175f, -0.01092258f, 0.01648613f, -0.01659229f, 0.01227904f, -0.02778259f, 
    0.03209680f, -0.00924711f, 0.01159818f, 0.00860929f, -0.03739651f, -0.00221669f, -0.03641133f, 0.00336852f, 
    -0.05926485f, -0.02926340f, -0.02623468f, -0.04467166f, 0.01885585f, -0.01751434f, -0.02359733f, 0.00647775f, 
    -0.04910881f, -0.04561065f, -0.02457732f, -0.00869894f, -0.01380857f, -0.05258848f, 0.02211818f, -0.02057514f, 
    0.01723981f, -0.03172878f, 0.03159575f, -0.05680049f, 0.02795327f, 0.04673764f, -0.05342171f, -0.05719227f, 
    0.01598677f, 0.01285128f, -0.03598158f, -0.01763701f, 0.02833116f, -0.01687049f, 0.02006915f, 0.03700991f, 
    -0.04491007f, 0.02497863f, -0.05463163f, 0.00081434f, -0.03117693f, 0.00018710f, 0.02764558f, 0.03754677f, 
    -0.01851785f, -0.01550949f, 0.02113028f, -0.02733880f, -0.03061629f, 0.01824135f, 0.00711602f, -0.06334318f, 
    -0.01354608f, 0.01575804f, 0.00942002f, -0.03996092f, 0.01938602f, -0.05532920f, -0.01276594f, 0.03214296f, 
    -0.04287117f, 0.03345274f, -0.03735522f, -0.02881967f, -0.03747588f, -0.01653001f, 0.00542216f, -0.03515162f, 
    -0.06143970f, -0.04899359f, -0.02111196f, -0.00129221f, 0.01776242f, -0.02957890f, -0.00764712f, 0.03182364f, 
    0.01783743f, 0.04691948f, 0.02127211f, -0.04489681f, -0.00386563f, -0.03034743f, 0.02276471f, -0.05336251f, 
    0.03983333f, -0.04225824f, 0.02582812f, 0.01266515f, -0.04541429f, -0.02372431f, -0.05062686f, -0.01394915f, 
    0.03883931f, 0.04368695f, -0.06008682f, 0.02632499f, 0.04445502f, 0.02570427f, -0.01812279f, -0.04743299f, 
    0.02785562f, -0.04995929f, -0.01286526f, -0.00195771f, -0.01023494f, -0.04133904f, 0.00798196f, 0.01381368f, 
    0.00954034f, 0.03663816f, -0.05477112f, -0.06077736f, -0.06717668f, -0.01233441f, 0.01443480f, -0.01095930f, 
    0.02116269f, 0.03578305f, -0.04759740f, -0.01892164f, 0.00511415f, 0.00385786f, -0.06377501f, 0.00822580f, 
    0.00215484f, 0.05056967f, -0.02147613f, -0.02999079f, 0.03414845f, -0.05445049f, 0.02139702f, -0.05461910f, 
    -0.00135231f, -0.05485819f, -0.00627537f, -0.02571698f, 0.00104792f, 0.01169894f, -0.02134534f, -0.04203111f, 
    0.01017634f, 0.01759173f, -0.05930197f, -0.01977490f, 0.04921265f, 0.00244708f, 0.03900600f, 0.02103252f, 
    -0.01038024f, -0.06092698f, -0.00255673f, -0.01644476f, -0.00140244f, -0.03691820f, -0.02404331f, -0.00107408f, 
    -0.04543563f, -0.06038852f, -0.04353533f, -0.05841846f, 0.01263180f, -0.04199765f, -0.02160874f, 0.02755752f, 
    -0.03315973f, -0.03186741f, -0.03009766f, 0.04034132f, -0.02375907f, -0.00674491f, -0.05437747f, -0.00154010f, 
    -0.06264728f, 0.01332318f, -0.06553441f, 0.02484410f, 0.04694913f, 0.03824927f, -0.06564598f, 0.03716417f, 
    0.02851986f, -0.04571771f, -0.05947617f, 0.02927676f, -0.02166557f, -0.01302938f, -0.02354526f, 0.00799092f, 
    -0.03921831f, 0.05040296f, -0.06225488f, -0.00847817f, 0.00722762f, 0.00656695f, -0.02018619f, -0.06136136f, 
    0.00417236f, -0.05563854f, -0.01312206f, 0.01120140f, 0.01649584f, 0.03285419f, 0.00352327f, 0.01055102f, 
    0.00357834f, -0.00236329f, -0.03536937f, 0.02409669f, 0.03135060f, -0.04050325f, -0.00642160f, 0.02331671f, 
    -0.04299007f, 0.05942464f, 0.01597462f, 0.05194807f, -0.02064162f, -0.04831624f, 0.04107811f, -0.05220765f, 
    0.04528153f, -0.04163257f, 0.03411234f, 0.01802377f, 0.04608774f, -0.03827585f, 0.02293065f, 0.04102661f, 
    -0.04528613f, 0.02791168f, -0.05578195f, -0.04821677f, -0.03906053f, -0.00835061f, 0.03806780f, -0.01258769f, 
    -0.01694867f, 0.03116425f, 0.06402043f, -0.02874595f, -0.00870619f, -0.02162161f, -0.05235217f, 0.01037598f, 
    -0.04342113f, 0.00428682f, 0.04075469f, -0.06801707f, 0.03232220f, 0.04065621f, 0.03471256f, -0.00071754f, 
    -0.01313192f, -0.00653032f, -0.00008399f, 0.03626839f, 0.03916324f, -0.01072403f, -0.02762081f, -0.05012551f, 
    0.05460333f, -0.03252088f, 0.02889926f, 0.04294346f, 0.02089570f, -0.03048084f, -0.02548768f, 0.00857007f, 
    -0.03484603f, 0.00122045f, 0.01513967f, 0.03286986f, -0.00873909f, -0.02306518f, -0.02618990f, 0.02703277f, 
    0.02355537f, -0.05057421f, 0.02676151f, -0.03625187f, 0.02867539f, -0.05597107f, -0.04591466f, 0.02785653f, 
    -0.03563018f, 0.00113670f, -0.03340740f, 0.01278302f, 0.01172052f, -0.01515019f, -0.04266986f, -0.05425875f, 
    0.00586406f, -0.05197097f, -0.02550157f, -0.05279196f, 0.00018487f, -0.04361857f, 0.00053346f, 0.02492694f, 
    -0.02290675f, -0.01197256f, 0.01048198f, 0.03347009f, 0.03142126f, -0.02713893f, 0.00660332f, -0.03639913f, 
    -0.04998715f, 0.04291507f, 0.00730050f, -0.05108800f, -0.02595272f, 0.01013736f, -0.04550676f, -0.02838049f, 
    -0.03485962f, 0.03208892f, -0.06134124f, 0.02135143f, 0.02491024f, -0.02911613f, 0.02071149f, -0.06306291f, 
    0.04409481f, -0.04479606f, -0.04339760f, 0.03249460f, 0.03488749f, 0.00801540f, -0.01520095f, -0.04702942f, 
    0.01705228f, 0.02173452f, 0.00541024f, -0.02518478f, -0.02116454f, 0.00057814f, -0.02328114f, -0.03530327f, 
    0.00090330f, 0.02051036f, -0.02903761f, -0.04986133f, -0.02519957f, -0.01023830f, 0.02694255f, -0.02625606f, 
    0.02081078f, -0.04788751f, -0.00059234f, -0.00246703f, 0.03032246f, 0.04383707f, -0.00850047f, 0.01604828f, 
    0.02323858f, 0.03066879f, -0.06736834f, -0.00530003f, -0.04904541f, -0.01329555f, 0.03366613f, -0.02583021f, 
    -0.05956768f, -0.06154694f, 0.01814457f, 0.01390992f, -0.01978216f, 0.02116319f, -0.06406166f, 0.02809174f, 
    -0.03639833f, 0.03357153f, 0.01981418f, 0.02057157f, -0.03476659f, -0.03686806f, 0.02265755f, -0.01353915f, 
    -0.07122134f, -0.01366170f, -0.03993333f, -0.00828427f, 0.00817380f, 0.04821320f, -0.04305216f, -0.04816479f, 
    -0.02269378f, 0.01435987f, -0.02693674f, 0.00429722f, -0.05679489f, 0.01306897f, 0.00426379f, -0.04782220f, 
    0.03736983f, 0.04716260f, -0.03747920f, 0.03405983f, -0.06383009f, -0.03563190f, -0.00897889f, 0.03805894f, 
    -0.05378375f, -0.00338718f, -0.02186027f, 0.04145170f, -0.00506567f, -0.00020838f, -0.00419310f, -0.05949473f, 
    -0.03307122f, 0.03865280f, -0.00677361f, -0.06179865f, -0.00469855f, 0.00339359f, 0.04335851f, -0.02328433f, 
    -0.01050372f, 0.05075560f, -0.04818833f, -0.06312689f, -0.01500263f, -0.02206846f, 0.03918665f, -0.03445563f, 
    0.00460298f, -0.02662747f, -0.01084404f, 0.04260752f, -0.02518347f, 0.04231297f, -0.01360905f, -0.05700590f, 
    0.03786825f, 0.01617178f, 0.01989508f, -0.04919705f, -0.06133730f, -0.02342152f, -0.04997527f, -0.03333900f, 
    -0.00582274f, 0.03123972f, -0.02938876f, 0.00739978f, 0.05165601f, -0.04567484f, -0.03076789f, -0.06349083f, 
    -0.02716918f, -0.02562492f, -0.01908009f, 0.00280447f, 0.05493209f, -0.04051504f, -0.03728324f, 0.03478647f, 
    -0.02716127f, -0.02437760f, -0.05442333f, 0.04348530f, -0.05295942f, -0.03981182f, -0.02658935f, 0.05006848f, 
    -0.05259562f, -0.06025426f, 0.02544524f, 0.03586274f, -0.01864940f, -0.04030807f, 0.01549550f, -0.00935992f, 
    -0.05571073f, -0.00170341f, -0.00442182f, 0.03348979f, 0.03269453f, -0.05547676f, -0.04579155f, -0.04776538f, 
    0.02602914f, 0.03474922f, -0.02385684f, 0.03302627f, 0.02185122f, -0.01786270f, -0.01275106f, -0.03099947f, 
    -0.01481580f, -0.05911832f, -0.05365568f, 0.00556589f, 0.04671292f, 0.04848418f, -0.05079191f, -0.05934872f, 
    -0.02156247f, -0.03520657f, 0.02058556f, -0.04645488f, 0.00528439f, -0.04002855f, -0.03229658f, -0.06251364f, 
    -0.04463356f, 0.03039910f, -0.00106225f, 0.02420400f, 0.03264821f, -0.00101703f, 0.00065947f, -0.05521848f, 
    0.00819505f, 0.04406922f, 0.04359097f, -0.04983349f, 0.01668726f, 0.03207206f, -0.03423387f, -0.01427288f, 
    -0.00575549f, 0.00498191f, 0.01756049f, 0.03949817f, 0.02803889f, 0.02783078f, -0.04587958f, 0.05191556f, 
    -0.02409190f, -0.00371566f, 0.05274943f, 0.01040866f, -0.04187487f, -0.03824616f, -0.01637797f, 0.00326977f, 
    -0.05343747f, -0.01457983f, 0.00696065f, 0.01349783f, -0.01479650f, -0.03083810f, -0.04225679f, -0.05615688f, 
    -0.05157671f, 0.00141719f, -0.03925864f, -0.00413610f, 0.05273383f, 0.04244561f, -0.05383645f, -0.01202080f, 
    -0.02542808f, 0.04867211f, -0.01169402f, -0.01052860f, 0.02852058f, -0.02916313f, 0.02786353f, 0.01988471f, 
    -0.03903250f, -0.01477149f, 0.01690918f, 0.00663136f, -0.06140966f, 0.04495516f, 0.02412522f, 0.02189565f, 
    -0.00029130f, -0.01392533f, -0.01841919f, -0.04992739f, -0.01918703f, -0.02650520f, -0.00477623f, 0.04404144f, 
    0.03440870f, -0.00217452f, -0.03589918f, 0.00206149f, 0.04985977f, 0.05152112f, -0.02656014f, -0.05507378f, 
    -0.04748292f, -0.01879766f, -0.04949849f, -0.01487577f, -0.00872963f, 0.01924530f, 0.00976691f, 0.04416299f, 
    -0.05131998f, -0.04650417f, 0.02750472f, -0.01928990f, 0.04359788f, -0.00549091f, -0.05202058f, 0.02036991f, 
    0.03062078f, 0.00201779f, -0.00477439f, 0.03514837f, -0.06109387f, 0.03303548f, 0.02479673f, 0.00215972f, 
    -0.04424910f, 0.03599146f, -0.05593925f, -0.01990280f, 0.05292765f, -0.05514453f, -0.05225350f, -0.05348479f, 
    -0.06139584f, -0.01433115f, -0.06236411f, -0.01519388f, -0.05212272f, -0.03597449f, -0.02191658f, 0.04553807f, 
    0.02821385f, 0.02516153f, 0.04131206f, -0.02929308f, -0.02565143f, 0.03144971f, -0.06334116f, -0.01588997f, 
    0.04031899f, 0.02362094f, 0.03849247f, -0.05238272f, -0.00838907f, 0.01698290f, -0.01043404f, -0.05764631f, 
    -0.02088516f, 0.04011207f, -0.01516110f, -0.02223558f, -0.05163842f, -0.05171604f, -0.05353552f, -0.01955997f, 
    -0.04050323f, 0.01974464f, 0.01485564f, 0.01531004f, 0.02398703f, -0.03249546f, 0.01419189f, -0.05719427f, 
    0.04049122f, -0.05878428f, 0.00992334f, 0.05579809f, -0.03645061f, -0.04315249f, 0.02022750f, -0.02137860f, 
    -0.01869608f, -0.00301211f, 0.01869915f, -0.03689095f, 0.02227178f, 0.03292862f, -0.03283160f, -0.03332654f, 
    0.02615551f, -0.03179858f, 0.01691775f, -0.03870620f, 0.02027186f, -0.04518120f, 0.03685005f, 0.01075550f, 
    0.02030067f, -0.01121493f, -0.02222989f, -0.02028109f, 0.04173958f, 0.01641915f, -0.06359362f, 0.02296592f, 
    -0.02114629f, -0.01925269f, -0.05979067f, -0.04098707f, 0.02135181f, -0.03038112f, 0.04222996f, 0.05367588f, 
    -0.00691927f, -0.00213793f, -0.01615688f, -0.01803873f, -0.03819738f, 0.03647956f, -0.00859353f, 0.04561688f, 
    -0.06396167f, 0.01752614f, 0.02799873f, 0.00514000f, -0.01953812f, 0.00028173f, -0.02487983f, 0.00176916f, 
    -0.04864243f, -0.00861401f, -0.06020732f, -0.00604451f, -0.03112190f, -0.00231350f, 0.02088595f, -0.01334400f, 
    -0.00189430f, -0.04885555f, 0.03321442f, 0.00559379f, -0.05417921f, -0.02420366f, -0.02947951f, -0.04486914f, 
    0.02708106f, -0.05739971f, -0.00781933f, 0.01222962f, -0.05945499f, 0.03699575f, -0.00334943f, -0.04677602f, 
    0.00277432f, 0.03048340f, -0.00845864f, 0.00809603f, 0.04434862f, 0.00574007f, -0.00302102f, -0.02206886f, 
    -0.03925096f, -0.05541141f, 0.01531213f, -0.01120043f, 0.00970337f, -0.00935131f, -0.03900040f, -0.05084186f, 
    0.02698547f, -0.04540961f, 0.00486602f, 0.01262002f, -0.01173022f, -0.04395672f, -0.01223778f, -0.00639008f, 
    0.03669766f, -0.04958441f, -0.04810509f, 0.01729297f, -0.01831475f, -0.03006892f, -0.00225782f, 0.03087733f, 
    -0.02317563f, -0.01122129f, 0.03507126f, -0.01263955f, 0.01636782f, -0.05717498f, -0.00631539f, -0.05546182f, 
    0.02803436f, -0.03536491f, -0.02448857f, -0.00378207f, -0.00626402f, 0.04600580f, 0.01871112f, -0.06379190f, 
    0.01256838f, 0.02366414f, 0.03948419f, -0.00022808f, -0.05225209f, -0.05215873f, 0.02243460f, -0.02717576f, 
    -0.02445727f, -0.03659789f, -0.00162719f, -0.00127578f, 0.01527826f, 0.01314764f, -0.03108015f, 0.01932976f, 
    -0.03254233f, 0.00800328f, 0.02778244f, 0.01250061f, 0.01581915f, 0.04956171f, 0.00714003f, -0.04187557f, 
    -0.04220545f, 0.02235433f, -0.01428704f, 0.06037077f, 0.04703617f, 0.00492265f, 0.01343169f, 0.03478023f, 
    0.01483975f, -0.03995982f, -0.00245073f, -0.00954797f, -0.06654447f, 0.06037973f, -0.00892728f, 0.04281438f, 
    0.01540048f, -0.03099157f, -0.04323190f, -0.06467488f, 0.00756254f, -0.02346246f, -0.00527587f, -0.03314605f, 
    0.01179719f, 0.01515664f, -0.00354579f, 0.01857686f, -0.05425181f, 0.01675392f, -0.02604144f, -0.01015441f, 
    0.03673788f, -0.05237144f, -0.00794089f, -0.01951732f, -0.02254336f, -0.04432860f, 0.01444047f, -0.03273310f, 
    -0.05696983f, 0.04302761f, 0.02422385f, 0.03120317f, -0.06683416f, -0.03627896f, -0.05831383f, -0.01830462f, 
    -0.03189163f, -0.06126879f, -0.03904635f, -0.00104503f, 0.00627348f, -0.04069410f, -0.01887251f, -0.05279362f, 
    0.02618169f, -0.02068025f, -0.04279314f, 0.03731809f, -0.00837144f, -0.00945027f, -0.05127235f, 0.01710076f, 
    0.03552369f, -0.04445157f, 0.00316836f, 0.01211750f, 0.01172940f, 0.03180919f, -0.05907335f, 0.02716385f, 
    -0.06235781f, -0.03302918f, 0.02812982f, -0.02077177f, -0.04481080f, -0.01889558f, -0.02249364f, 0.00270358f, 
    0.05247647f, -0.00150066f, -0.04847021f, 0.00735372f, -0.02016804f, -0.02701439f, 0.01510216f, 0.00359557f, 
    0.04751714f, -0.03232943f, -0.03744408f, -0.02468424f, -0.00221802f, -0.03710540f, -0.00590560f, -0.04800221f, 
    -0.00221784f, 0.02671485f, -0.01556550f, -0.04622860f, -0.01999520f, -0.02207729f, -0.02849953f, 0.04789188f, 
    0.04647543f, -0.03486324f, -0.03537006f, -0.00319219f, -0.04175543f, 0.02188821f, 0.04159790f, -0.01753608f, 
    -0.01321898f, -0.00394009f, -0.05761601f, -0.03380321f, -0.00637300f, 0.00234284f, -0.00138581f, 0.03897312f, 
    -0.02075883f, -0.06156544f, -0.04633563f, -0.02294355f, -0.03929817f, -0.01941917f, 0.02120524f, -0.04622677f, 
    0.03680874f, -0.05642706f, 0.02931321f, 0.02182134f, 0.02890455f, -0.01616014f, -0.00526686f, 0.05580783f, 
    -0.03764483f, -0.01652099f, 0.04792730f, -0.03092989f, 0.05056372f, -0.02659049f, -0.06718476f, 0.01399484f, 
    0.02435403f, 0.03034924f, 0.03749850f, 0.01979716f, 0.00559449f, -0.04051347f, -0.00165315f, 0.02764314f, 
    -0.04443370f, 0.04345172f, -0.06531591f, -0.00203832f, 0.01750936f, -0.04584461f, -0.03736132f, -0.03184079f, 
    -0.03928676f, 0.00572478f, -0.02982792f, 0.05109145f, -0.02000457f, 0.03196831f, 0.01115553f, 0.00072598f, 
    -0.01716777f, -0.06285822f, -0.01921293f, 0.06234299f, 0.00627226f, -0.06368791f, -0.03606815f, 0.04724246f, 
    0.02440356f, 0.02823376f, 0.00266573f, -0.01123761f, -0.04446052f, -0.00061882f, -0.03872989f, -0.05999958f, 
    -0.00505752f, 0.01369067f, 0.00386100f, -0.00651661f, 0.00767690f, 0.03731692f, 0.01305321f, 0.01642662f, 
    -0.00951901f, 0.03177546f, -0.03197359f, 0.01297542f, -0.04886366f, 0.00668289f, 0.03067476f, 0.02634711f, 
    0.03655414f, -0.03163782f, 0.04305015f, 0.04653853f, 0.03449576f, 0.03650789f, -0.02531441f, 0.00429987f, 
    -0.04624141f, -0.02834255f, 0.05911534f, -0.00014856f, -0.01143418f, -0.04687600f, 0.01383328f, 0.02773645f, 
    -0.05034234f, 0.02453793f, 0.00358936f, -0.04804008f, -0.01029974f, 0.02305054f, 0.01742406f, 0.03362996f, 
    0.01138792f, 0.03756958f, 0.03103482f, -0.05328758f, -0.04541744f, 0.03461031f, -0.05330248f, -0.04515476f, 
    0.01868627f, -0.05893635f, 0.00005349f, 0.04061787f, -0.04521891f, 0.04938842f, -0.00846323f, -0.03604446f, 
    -0.01965764f, -0.05540826f, 0.01368727f, 0.00341289f, 0.03537747f, 0.01564600f, -0.01534282f, 0.00313930f, 
    -0.03305411f, 0.01896292f, -0.01835498f, -0.02726514f, 0.04321216f, -0.01980997f, -0.01939104f, 0.03152639f, 
    0.01814040f, -0.02666274f, -0.04225333f, -0.03158620f, -0.01186386f, -0.01070223f, 0.00891140f, -0.04059352f, 
    -0.00357314f, 0.03877091f, -0.04005828f, 0.05049161f, 0.04025740f, -0.06367793f, 0.04954866f, -0.03311520f, 
    0.00079403f, 0.02292734f, 0.01513170f, -0.01185958f, -0.01215926f, -0.02484896f, -0.03113814f, 0.02380213f, 
    0.00549293f, -0.03073120f, -0.02014201f, -0.05128771f, -0.01555434f, 0.02093870f, 0.02600624f, -0.02498017f, 
    -0.04473710f, 0.03008781f, -0.02358879f, 0.00176313f, 0.02188869f, 0.02650590f, -0.05757647f, -0.00330705f, 
    -0.01286237f, 0.03493923f, -0.00874709f, 0.00954177f, 0.03149235f, 0.04644545f, 0.01001744f, -0.01260058f, 
    -0.04582265f, 0.04170549f, 0.04084194f, 0.00812058f, 0.04497286f, 0.02430212f, 0.04184635f, 0.01824421f, 
    0.00816446f, -0.01935367f, 0.03735226f, -0.05337719f, -0.00940796f, -0.01139154f, 0.00982373f, -0.02011341f, 
    -0.00572046f, -0.01287038f, 0.00828281f, -0.00923682f, 0.04229760f, -0.05150240f, 0.02043052f, 0.01446812f, 
    -0.06114372f, -0.04768308f, 0.04618153f, -0.01113229f, 0.01486772f, -0.03826102f, -0.02920379f, 0.01638780f, 
    -0.01851599f, -0.04323917f, -0.03609609f, -0.04268106f, 0.02710313f, 0.01791968f, -0.05641941f, 0.01445830f, 
    0.05239664f, -0.04548285f, -0.04308254f, 0.01342129f, -0.01606982f, -0.02484958f, -0.03704049f, 0.04552042f, 
    -0.01132137f, -0.05458364f, 0.05240245f, -0.04301383f, -0.05159213f, 0.03494614f, -0.05098178f, -0.03623500f, 
    0.00141098f, -0.01490752f, 0.00277012f, 0.01233017f, -0.02578393f, 0.00435473f, -0.05601491f, -0.05173209f, 
    0.03137571f, 0.03466573f, -0.05581627f, -0.04408561f, -0.04011883f, -0.02148737f, -0.06341835f, -0.03473554f, 
    0.03469573f, -0.00700056f, -0.05434199f, 0.01605723f, -0.05117612f, -0.01458005f, -0.02604602f, -0.00713405f, 
    -0.00542936f, 0.00928627f, -0.03507355f, 0.03147647f, 0.05194567f, -0.04534502f, 0.02358512f, 0.00286632f, 
    0.03145071f, -0.04314894f, -0.04211888f, 0.03313567f, 0.03069213f, 0.02899969f, -0.00793876f, 0.04857641f, 
    0.04738552f, -0.02450592f, -0.04709950f, -0.00833177f, -0.00232178f, -0.06055347f, 0.04835501f, 0.05883089f, 
    -0.05895371f, -0.00237252f, 0.02958481f, -0.00023870f, -0.04703918f, 0.00962715f, 0.02057371f, -0.02303405f, 
    0.01146090f, -0.04723392f, -0.05329768f, -0.04142473f, 0.02203630f, -0.02217187f, 0.00099431f, -0.04906225f, 
    -0.01182800f, 0.04182632f, -0.01972507f, -0.05124489f, -0.02513793f, -0.05416764f, 0.03166883f, 0.03180496f, 
    -0.05234185f, -0.02265709f, 0.03048076f, -0.05766694f, 0.00154044f, -0.00303538f, -0.00597805f, 0.03158187f, 
    -0.01499445f, -0.03349662f, -0.03774317f, 0.04396191f, 0.04996805f, 0.04310360f, -0.04475909f, 0.02445902f, 
    0.01838242f, -0.01104169f, -0.04428145f, -0.04957611f, -0.05555299f, -0.00163374f, -0.05731729f, 0.01455749f, 
    -0.03002317f, 0.00470284f, 0.04911852f, 0.04305375f, 0.04869203f, -0.02941122f, -0.04607322f, -0.02230356f, 
    0.01576611f, 0.01599585f, 0.04893991f, -0.03418887f, -0.04566786f, -0.03600786f, -0.04705877f, -0.01411817f, 
    -0.05577255f, 0.04708116f, 0.03194138f, -0.00691403f, 0.02389918f, 0.03683067f, -0.03076634f, -0.02164011f, 
    -0.01118173f, -0.04684764f, 0.01240671f, 0.03716754f, -0.02698391f, -0.01123229f, 0.00604695f, -0.03416218f, 
    -0.01698541f, 0.00703672f, 0.05394387f, 0.01540380f, 0.03628555f, -0.05498372f, 0.01938234f, -0.00080463f, 
    0.00302287f, 0.03271935f, -0.01598867f, -0.03491434f, -0.03168693f, -0.03399840f, -0.03571158f, 0.03689568f, 
    -0.01997717f, -0.02614515f, -0.03242934f, 0.04351424f, -0.01688892f, 0.04937808f, -0.00093614f, 0.02917378f, 
    0.02224102f, 0.00215810f, -0.02366078f, 0.04165271f, -0.05895460f, -0.00655650f, -0.04985573f, 0.04702147f, 
    0.00283009f, -0.00419054f, 0.05075727f, -0.02333890f, 0.04653882f, 0.04884897f, 0.01807851f, 0.02487302f, 
    -0.04934170f, 0.00803130f, 0.00877376f, -0.01170707f, -0.03248326f, 0.01919741f, -0.00912764f, -0.02617142f, 
    0.05385750f, -0.02846524f, 0.04332823f, -0.03799990f, 0.01640812f, -0.00861136f, 0.00762718f, 0.02370834f, 
    0.03965417f, 0.14813957f, -0.00202838f, 0.06682545f, 0.04124736f, 0.04283429f, -0.12553492f, 0.03317812f, 
    -0.15574941f, -0.17305066f, -0.03117289f, 0.15187457f, -0.00234696f, 0.02828426f, 0.11489239f, 0.02223811f, 
    0.00251008f, 0.05819561f, 0.00370870f, 0.07456334f, 0.05335684f, -0.01877152f, -0.10453387f, 0.16204289f, 
    0.00343589f, 0.10622874f, 0.05826670f, 0.19981420f, -0.35485184f, -0.13407235f, -0.12200832f, 0.10631622f, 
    0.03859744f, 0.03849912f, 0.27598849f, 0.08082059f, -0.10786211f, -0.10637879f, -0.13417277f, 0.02974833f, 
    0.00153067f, 0.13112713f, -0.12152620f, -0.00503588f, 0.20962088f, -0.12397813f, -0.12537687f, 0.12564912f, 
    0.00574219f, 0.07562821f, -0.19463849f, -0.21982913f, -0.00344746f, -0.22298884f, 0.13935292f, 0.03000864f, 
    0.03439192f, 0.02813157f, -0.00599086f, 0.16470376f, 0.11938612f, -0.05283312f, 0.02588615f, -0.00104602f, 
    0.11603054f, -0.17946097f, -0.04100340f, 0.13747510f, 0.10809242f, -0.03808232f, 0.02070178f, -0.03776349f, 
    -0.29309750f, -0.20494285f, -0.16448826f, 0.03053779f, 0.01102848f, 0.04125893f, -0.16599517f, -0.13938814f, 
    -0.11433608f, 0.06947599f, -0.22755487f, 0.12882037f, 0.00967343f, -0.07659689f, 0.04853922f, 0.02107294f, 
    0.13610919f, -0.01205603f, 0.24131574f, -0.09022180f, 0.00252103f, -0.08359804f, -0.01863575f, -0.05760310f, 
    0.10252209f, 0.12963597f, 0.03925896f, 0.18329270f, 0.26557922f, 0.06835832f, -0.02413955f, -0.01972327f, 
    0.07234464f, 0.02723290f, 0.03756149f, 0.06944317f, 0.32320198f, 0.07311858f, 0.18025140f, -0.07106928f, 
    -0.17009825f, 0.06511799f, -0.03186052f, 0.03278288f, 0.08531265f, 0.08088513f, 0.23591292f, 0.05428433f, 
    0.02956417f, 0.00429079f, 0.13970919f, -0.03669539f, -0.07086785f, 0.03963017f, -0.05890381f, 0.11080628f, 
    -0.08227404f, 0.06060382f, 0.00039193f, 0.02554840f, 0.08926757f, -0.04581287f, 0.17745934f, 0.26156145f, 
    0.18551059f, 0.05868122f, -0.13485716f, 0.05164406f, 0.10918226f, -0.00279996f, 0.13032110f, 0.17158267f, 
    -0.21551368f, -0.30615729f, -0.28593755f, 0.05924559f, 0.01958429f, 0.02378262f, 0.03902465f, -0.05472309f, 
    -0.14186704f, -0.22685684f, 0.15159361f, -0.03906607f, 0.09696437f, 0.04737039f, -0.03180658f, -0.13087164f, 
    -0.09056336f, -0.08680680f, -0.14161032f, -0.00186792f, -0.16692339f, 0.06173576f, -0.07658609f, 0.00566597f, 
    0.02917423f, 0.05934896f, 0.17263836f, -0.22604017f, 0.25299570f, -0.18328738f, -0.00431948f, -0.10251743f, 
    0.08234676f, 0.00559254f, 0.01826648f, 0.20241112f, 0.00339934f, 0.16143639f, -0.05970689f, 0.08179235f, 
    -0.10546285f, -0.07079247f, 0.02800800f, 0.07909241f, 0.04336086f, -0.29004261f, -0.18122736f, 0.11873801f, 
    -0.01238858f, 0.04458264f, -0.07965026f, -0.00015786f, -0.00311871f, -0.05689600f, 0.04913438f, 0.11168364f, 
    -0.12727199f, 0.03433382f, 0.00783991f, -0.09334596f, -0.03831948f, 0.06073058f, -0.09317744f, 0.02861424f, 
    -0.14870752f, -0.15726967f, 0.03042797f, 0.06831107f, 0.07487199f, -0.26072639f, 0.00551337f, 0.10055255f, 
    0.51191097f, -0.10761621f, -0.05690199f, 0.03506968f, -0.06541304f, -0.20206843f, -0.05711149f, -0.06042376f, 
    0.13015431f, 0.19034201f, 0.07195392f, 0.22576506f, -0.01494977f, -0.00174494f, 0.11691421f, -0.02346826f, 
    0.05838334f, 0.12213182f, 0.35692140f, -0.01080469f, -0.08244005f, 0.02189395f, 0.00732456f, 0.01870878f, 
    -0.13893262f, -0.02136082f, -0.01099072f, -0.30007464f, -0.37779644f, -0.25861287f, 0.06051039f, 0.04293924f, 
    0.03001394f, -0.10002396f, 0.04939568f, 0.08353004f, -0.02531706f, -0.02936348f, -0.02759710f, -0.07724362f, 
    0.05249788f, 0.05471857f, 0.00115612f, 0.01279167f, 0.03738077f, 0.04814763f, -0.27436954f, -0.19171824f, 
    -0.08792466f, 0.00447859f, 0.00838955f, 0.21329077f, -0.06646197f, 0.06054522f, 0.05232512f, 0.10428088f, 
    -0.06781289f, -0.01295669f, 0.07748397f, -0.05836621f, -0.01880377f, 0.03353854f, 0.06606169f, -0.09145550f, 
    0.04169217f, -0.00539207f, -0.07983828f, -0.05519531f, 0.17625377f, -0.08740409f, 0.03550231f, 0.11048003f, 
    0.00193480f, -0.03523223f, -0.03233128f, -0.05524709f, -0.00861898f, 0.05748220f, -0.01404476f, 0.01914825f, 
    0.03369695f, 0.02556819f, 0.00778538f, 0.03972341f, 0.00639144f, 0.01393078f, 0.01573138f, 0.00828781f, 
    0.00573610f, -0.03100209f, -0.01552747f, 0.02685536f, -0.00938246f, 0.01099135f, 0.02570967f, 0.04454773f, 
    -0.04236745f, -0.04535332f, 0.03622802f, 0.01020199f, -0.05950860f, -0.00748942f, -0.01708667f, -0.03280663f, 
    -0.05351602f, 0.01787291f, -0.04838116f, 0.03866081f, -0.06244810f, 0.03412121f, 0.02080943f, -0.03218272f, 
    0.03854629f, -0.02426746f, -0.02166722f, -0.05413101f, 0.05050706f, 0.02398740f, 0.00023670f, 0.00777213f, 
    -0.00230629f, 0.00417015f, -0.00835735f, -0.02965118f, -0.04508154f, 0.03908871f, 0.05827625f, 0.01644376f, 
    0.01700787f, -0.04187373f, 0.03063488f, -0.05742405f, 0.02560308f, 0.03500050f, -0.00451141f, 0.01403395f, 
    0.00481671f, -0.04983655f, 0.00718648f, -0.06249649f, -0.00402307f, -0.02764063f, -0.03190767f, -0.04599637f, 
    -0.02335268f, -0.02062366f, -0.03126523f, -0.00975081f, -0.00019665f, -0.04204599f, 0.01177894f, -0.05894974f, 
    0.04252919f, 0.01580113f, -0.00856697f, 0.00923125f, 0.04135220f, -0.01902609f, 0.03200405f, -0.00559887f, 
    -0.00840093f, -0.02794781f, -0.04517430f, 0.02332689f, -0.01228235f, -0.02258962f, -0.03500701f, -0.03566254f, 
    -0.02734337f, 0.04292825f, 0.03100386f, 0.04309320f, -0.02113259f, -0.02270053f, 0.02500142f, -0.04121102f, 
    -0.04251213f, 0.00682842f, -0.06675222f, -0.00181245f, 0.03832017f, 0.03523579f, -0.00702996f, 0.00070801f, 
    -0.04911548f, -0.05804374f, 0.02403364f, -0.03603689f, -0.00227322f, 0.02242883f, -0.06532967f, -0.00306790f, 
    0.00042334f, 0.02303034f, 0.04237940f, -0.02031706f, -0.05475313f, 0.01504816f, 0.02457657f, -0.06032880f, 
    0.01556112f, -0.02513664f, 0.02156710f, 0.01922943f, -0.04214123f, -0.06250504f, -0.05100210f, 0.00633956f, 
    -0.04596636f, -0.00405867f, 0.04799870f, -0.05017776f, 0.02343473f, -0.05771962f, -0.06396256f, 0.03767171f, 
    -0.03551026f, 0.02097673f, 0.02852210f, -0.05179836f, 0.04128369f, -0.02111516f, -0.01218139f, 0.03797462f, 
    0.00074860f, -0.04863885f, 0.02067333f, 0.04680466f, 0.01027181f, 0.03212579f, 0.01194946f, -0.03707336f, 
    0.01508629f, 0.03416000f, 0.03256296f, 0.04684157f, -0.04504617f, -0.01202448f, -0.02951469f, -0.05163809f, 
    -0.01345166f, -0.02967433f, 0.03640828f, -0.00565849f, 0.02038624f, -0.00756515f, 0.04593511f, -0.02920363f, 
    -0.01061299f, 0.04989446f, 0.01779094f, -0.00858774f, 0.01705969f, 0.00043718f, -0.05631761f, -0.00783347f, 
    0.04720967f, 0.03168377f, -0.01851918f, 0.02704748f, -0.04241041f, -0.01387843f, 0.04757285f, 0.01295212f, 
    -0.03161967f, 0.00190940f, -0.06182297f, -0.02883262f, 0.01217719f, 0.02388071f, -0.00224676f, 0.01235079f, 
    -0.04490371f, -0.03462690f, 0.02424322f, -0.05439368f, -0.02993901f, 0.02595872f, -0.01000834f, -0.06167899f, 
    0.00933361f, -0.06905490f, -0.03382373f, -0.01673462f, 0.04308197f, -0.01009480f, -0.00384400f, -0.03678909f, 
    -0.06200488f, 0.01339324f, -0.01250798f, 0.01562265f, -0.01303715f, 0.01060714f, -0.06858694f, 0.02184648f, 
    -0.03338701f, 0.02959251f, -0.02540244f, 0.03298911f, -0.01889527f, -0.00049018f, 0.00905139f, 0.03443407f, 
    -0.06136232f, 0.00841255f, -0.03998092f, -0.03479448f, 0.00481182f, -0.04491034f, -0.05987401f, 0.01832298f, 
    -0.03865489f, -0.05654725f, -0.03768382f, -0.01586241f, -0.00109153f, -0.03708347f, 0.00033616f, -0.02577487f, 
    0.02823135f, -0.02994926f, 0.01935974f, 0.04975970f, -0.04146599f, 0.00298168f, -0.02874898f, -0.03733173f, 
    -0.04150667f, 0.02904785f, 0.00657672f, 0.01356651f, -0.02194925f, -0.05410173f, -0.01104336f, 0.05076478f, 
    -0.00349879f, 0.05143105f, -0.01890644f, -0.03019633f, 0.00135892f, 0.01074917f, 0.00890544f, 0.04879516f, 
    -0.05100309f, 0.03566007f, 0.00841111f, -0.04664199f, 0.04002341f, 0.01138070f, 0.03378496f, -0.00790507f, 
    -0.02314204f, -0.04167752f, -0.02151267f, 0.01751188f, 0.03035055f, -0.03302718f, 0.04495801f, -0.03045876f, 
    0.01722799f, 0.03202076f, -0.01003220f, -0.03475173f, -0.03744965f, 0.04696246f, 0.05101720f, -0.01985456f, 
    -0.02532871f, 0.01795560f, -0.01964157f, 0.03262382f, -0.03886041f, 0.01737132f, 0.02621631f, 0.05363622f, 
    0.03059140f, 0.01008838f, -0.04632935f, -0.00509548f, 0.01044782f, -0.04601845f, 0.02773520f, -0.03072761f, 
    0.03895219f, -0.05722979f, 0.04105153f, -0.05266266f, -0.03106739f, -0.05340303f, 0.01157772f, -0.00377425f, 
    0.01793876f, -0.02857381f, -0.05017396f, 0.00102413f, 0.02452740f, -0.05614083f, 0.05073741f, -0.02985364f, 
    -0.03494320f, -0.02631440f, -0.00769765f, -0.04477591f, -0.03963803f, -0.01864246f, -0.04777408f, -0.03542948f, 
    -0.02274883f, -0.03081325f, -0.05952503f, 0.03340904f, -0.05236134f, 0.00836763f, -0.04521599f, -0.02911409f, 
    0.00639578f, -0.02913504f, 0.04275884f, -0.04634392f, -0.05633899f, -0.02863220f, 0.03225290f, -0.06356624f, 
    0.04416659f, 0.02672142f, -0.02412977f, -0.04843188f, -0.04803719f, -0.01164694f, -0.00549759f, 0.02694050f, 
    -0.02233810f, 0.02758826f, 0.01192101f, -0.05569810f, -0.00708570f, -0.03783521f, -0.00464077f, -0.00701161f, 
    -0.00551071f, 0.01201237f, 0.03096220f, 0.03574529f, 0.00872705f, 0.02305090f, 0.02968916f, -0.00018116f, 
    -0.04186034f, 0.04013925f, -0.02897074f, -0.05791974f, 0.00278547f, 0.04714984f, -0.01956332f, -0.05490325f, 
    -0.01591359f, -0.02639762f, -0.04142898f, 0.01953955f, -0.03840522f, 0.00086452f, -0.06321121f, -0.05162293f, 
    0.00578239f, 0.05667497f, -0.03257548f, -0.01875955f, 0.00233751f, -0.04687624f, 0.02994315f, -0.05278436f, 
    -0.02340752f, -0.03796164f, -0.03706795f, 0.03459018f, 0.02494167f, -0.02407699f, 0.02223026f, -0.04369905f, 
    0.04991574f, -0.01910084f, 0.02206993f, 0.00037083f, 0.03159469f, -0.03888870f, -0.00673963f, -0.01582806f, 
    -0.04302090f, -0.00714562f, -0.00549023f, -0.02979373f, -0.01791441f, -0.01237532f, 0.02745574f, -0.00892542f, 
    -0.03153462f, -0.05006169f, -0.04533940f, 0.02801593f, -0.03334255f, -0.05505768f, -0.02108574f, 0.02861259f, 
    -0.02042096f, 0.02590804f, -0.04320535f, -0.01097544f, 0.03045042f, -0.00707372f, -0.03285831f, 0.02957492f, 
    -0.00898285f, 0.04137066f, 0.03828400f, 0.00836736f, -0.06235387f, 0.03232760f, 0.03680975f, -0.05647916f, 
    -0.00798645f, 0.02573414f, -0.00529756f, -0.03176892f, -0.03837021f, -0.01742194f, 0.04882672f, -0.01307502f, 
    -0.03971465f, 0.00464768f, -0.01589854f, 0.00059707f, 0.04268283f, 0.04109093f, -0.03140170f, -0.02495412f, 
    0.05197630f, -0.00197043f, 0.04823321f, 0.04693260f, 0.04696117f, 0.03561144f, -0.02767968f, 0.03872172f, 
    0.05139450f, 0.04939349f, -0.03820870f, -0.01407719f, -0.00619387f, 0.05274937f, -0.04622599f, 0.02723806f, 
    -0.03067005f, -0.03973418f, -0.01207177f, -0.03309532f, -0.00681193f, -0.04985654f, -0.00069686f, -0.06194564f, 
    -0.04545687f, -0.01802243f, 0.01798305f, -0.04539194f, -0.06199805f, -0.04803428f, -0.01341736f, 0.03738446f, 
    -0.00189185f, -0.04990629f, -0.00527026f, -0.03075953f, 0.00826767f, -0.04261153f, -0.05011212f, 0.03603742f, 
    0.01060196f, -0.04491862f, 0.03320295f, -0.06175155f, -0.00570764f, -0.05474806f, -0.02352562f, 0.03655476f, 
    -0.03553305f, 0.02609216f, 0.01601497f, 0.00721566f, 0.03446979f, -0.02063812f, -0.05300748f, 0.00127937f, 
    0.03963903f, 0.02374657f, 0.01866032f, -0.00413238f, -0.00226703f, -0.00906588f, 0.03928610f, -0.00931072f, 
    -0.05794775f, -0.00193656f, -0.01787265f, -0.04816955f, -0.00235034f, 0.03975693f, -0.05332629f, -0.03422222f, 
    0.02557633f, -0.03271748f, 0.00436663f, 0.00705745f, -0.03016286f, -0.01279853f, -0.01464287f, 0.02611319f, 
    -0.00951269f, -0.03995568f, -0.05434353f, -0.04927652f, -0.01657036f, 0.04139061f, -0.01531855f, 0.00260856f, 
    0.01776247f, -0.04378234f, -0.01299035f, -0.05214806f, -0.05461724f, 0.05039936f, -0.05177691f, 0.05226217f, 
    -0.06027614f, 0.00362078f, 0.02932212f, -0.01126009f, 0.01955961f, -0.04228283f, 0.01790386f, -0.03661848f, 
    -0.04590309f, 0.04716082f, 0.01273137f, -0.00050257f, 0.02836809f, -0.01525831f, 0.01352672f, -0.05697626f, 
    -0.05814245f, 0.04642840f, -0.04280427f, 0.04002774f, -0.03405553f, 0.04935045f, 0.03324093f, -0.04933327f, 
    -0.04700768f, -0.03541033f, 0.00271607f, 0.06146861f, 0.03608092f, 0.04016605f, -0.05679670f, 0.04755994f, 
    0.00745089f, 0.02707066f, -0.01727342f, 0.01339065f, -0.05851175f, 0.04137820f, -0.00095742f, -0.03817572f, 
    0.05239736f, -0.03600910f, 0.02660027f, -0.01218254f, -0.01609890f, -0.02475684f, -0.04366677f, -0.03526160f, 
    -0.04825024f, -0.03733510f, -0.06420501f, -0.01045729f, 0.00046379f, -0.01328793f, 0.03311450f, -0.04471533f, 
    -0.01386118f, -0.03285421f, -0.05507661f, 0.04720989f, -0.02217380f, -0.00636265f, 0.01028977f, 0.04502946f, 
    -0.02059301f, -0.03233792f, 0.02844317f, 0.01734030f, -0.03699993f, -0.04098464f, -0.06207342f, 0.02393358f, 
    -0.00656378f, -0.03371873f, 0.03567467f, -0.06128661f, 0.00158249f, 0.04161843f, 0.04236538f, -0.02362326f, 
    -0.02340784f, -0.00139327f, -0.06021458f, 0.02731158f, -0.05196399f, -0.05399827f, -0.05205830f, -0.00240710f, 
    -0.04036444f, -0.03090888f, -0.04184718f, -0.00424068f, -0.03000949f, 0.03541960f, 0.00103192f, -0.01289098f, 
    0.01356736f, -0.03824203f, 0.02359917f, -0.04383834f, -0.02261727f, -0.01021226f, 0.04732529f, 0.01891122f, 
    -0.02124793f, 0.04693978f, 0.01632181f, 0.04073489f, -0.03804922f, -0.01873775f, 0.02534297f, 0.03881296f, 
    -0.06366651f, 0.02251400f, -0.05839445f, 0.00686889f, 0.01879452f, -0.05158384f, 0.02946699f, 0.04028163f, 
    0.02140241f, 0.04862802f, 0.00658169f, 0.03946818f, -0.02475060f, 0.02958234f, 0.01135603f, 0.02153073f, 
    -0.01557959f, -0.02811809f, 0.04123169f, -0.04036031f, -0.00338821f, 0.05181672f, -0.01640572f, -0.00531967f, 
    0.02496728f, -0.06271735f, -0.04705032f, 0.03939949f, 0.03344202f, 0.00224142f, -0.00312603f, 0.02709836f, 
    0.00012198f, 0.00247774f, -0.01951690f, 0.02739724f, -0.00934461f, 0.02695658f, -0.04197373f, -0.04717792f, 
    -0.01938305f, -0.05271954f, -0.03912637f, 0.00177864f, 0.05587221f, -0.04044316f, 0.03423160f, -0.05528542f, 
    -0.04897930f, -0.00075904f, -0.04248489f, 0.00667062f, 0.00253643f, -0.00085514f, -0.06450238f, 0.03499587f, 
    -0.01750666f, -0.00731128f, -0.03235717f, -0.06002128f, -0.05626023f, -0.03932990f, 0.02779772f, 0.04523728f, 
    0.03813070f, 0.02984959f, -0.00800417f, 0.03904141f, 0.00620339f, -0.03506551f, -0.06169197f, 0.05325334f, 
    0.04486718f, -0.05923686f, 0.02125233f, -0.01086504f, -0.06639161f, 0.00636978f, 0.04604068f, 0.05124829f, 
    0.03618178f, -0.05028790f, -0.02429052f, -0.05838127f, -0.05243584f, 0.02081266f, -0.00805534f, 0.04329338f, 
    -0.00007551f, -0.02945580f, -0.03755064f, -0.04779987f, 0.03794344f, 0.00322513f, -0.00661495f, -0.00149082f, 
    0.02625278f, 0.03297912f, 0.00148692f, -0.01146772f, -0.01119452f, -0.00676476f, -0.06436696f, 0.01667694f, 
    0.05270277f, -0.00509328f, 0.01646041f, -0.04999494f, -0.04045646f, -0.04996638f, -0.02025097f, -0.03646352f, 
    -0.02903288f, 0.01773046f, 0.02676892f, 0.01205082f, 0.00066172f, 0.01343943f, 0.03003477f, 0.02961649f, 
    0.04858921f, -0.06258745f, -0.02082866f, -0.01534793f, 0.01859311f, -0.05290857f, 0.03306215f, -0.03541240f, 
    0.04425990f, -0.01425125f, -0.06149597f, 0.00735579f, -0.06249958f, 0.02527792f, -0.04906965f, -0.04314515f, 
    0.01567535f, 0.00829446f, -0.05031835f, -0.00949717f, -0.00047266f, -0.05897120f, -0.00004393f, 0.01140625f, 
    -0.05139090f, -0.02594486f, -0.02302398f, 0.01365450f, 0.02295051f, 0.05738698f, -0.00209769f, -0.03967544f, 
    -0.04713646f, 0.01348895f, 0.03159619f, 0.02460504f, -0.01573724f, 0.04948606f, -0.03025109f, -0.05598796f, 
    0.04357054f, -0.06888322f, -0.05585979f, 0.01788178f, -0.04782383f, -0.03825997f, -0.06095021f, -0.01063203f, 
    0.05104841f, 0.04245303f, -0.01068041f, 0.04825233f, 0.03069038f, 0.03189115f, 0.01371586f, -0.00685789f, 
    0.02148885f, 0.03898774f, 0.04251536f, -0.00077773f, 0.04771560f, 0.01934747f, 0.05007538f, 0.03225094f, 
    -0.05032071f, -0.01070818f, -0.01489060f, -0.04925279f, 0.00193789f, -0.05013661f, 0.01464415f, 0.01443848f, 
    0.12092637f, 0.27164918f, 0.06780338f, 0.14647360f, 0.01236357f, 0.06055232f, -0.13154437f, 0.09366804f, 
    -0.00551442f, 0.06817064f, -0.01269265f, -0.04598665f, 0.01752482f, -0.13163123f, 0.07965535f, 0.05844845f, 
    -0.06997482f, 0.09066870f, -0.16123781f, -0.03914200f, -0.03262635f, 0.03681159f, 0.17941642f, 0.02065743f, 
    -0.10372418f, -0.15181135f, -0.09031599f, 0.07001431f, -0.11369623f, 0.09844244f, -0.09207901f, 0.01850354f, 
    -0.20107293f, -0.12396862f, 0.09664788f, 0.08002922f, -0.48639575f, 0.02615052f, -0.18446055f, 0.05530765f, 
    0.07841556f, 0.03730312f, -0.05849993f, -0.15021625f, -0.02368744f, -0.06784815f, -0.16692801f, -0.06571205f, 
    0.10007537f, -0.01658011f, -0.05059661f, -0.04235437f, -0.09812042f, -0.09981740f, -0.43823677f, -0.07086305f, 
    -0.08370560f, 0.03087084f, 0.04597861f, 0.14708319f, 0.15216297f, 0.07643072f, 0.06905668f, 0.18052174f, 
    0.22105896f, -0.11317528f, 0.20303823f, -0.07037143f, -0.10633907f, -0.04151805f, -0.01342379f, 0.12004223f, 
    -0.06000778f, -0.14942783f, -0.19578066f, -0.08953679f, 0.16832796f, 0.02083847f, -0.17987120f, -0.04501471f, 
    -0.12946853f, 0.02393786f, 0.10983133f, 0.05917710f, -0.04695252f, -0.16848375f, -0.03824349f, 0.03125643f, 
    0.04685452f, 0.15512115f, 0.11209885f, 0.03090461f, -0.13851015f, -0.14820254f, -0.00155488f, -0.01239336f, 
    0.10774298f, 0.10123454f, 0.08258516f, 0.30329213f, 0.13918218f, -0.02319656f, 0.04816680f, 0.11519761f, 
    -0.06356110f, -0.07452740f, 0.11019399f, -0.14573348f, 0.46438831f, 0.25240752f, -0.13605238f, 0.03504550f, 
    -0.17073701f, -0.07280127f, 0.02682673f, 0.06405723f, 0.00150946f, -0.11164513f, -0.07079130f, 0.00124454f, 
    0.06126799f, -0.00245655f, 0.12328758f, 0.11844938f, 0.03225261f, 0.09779315f, -0.13294838f, 0.02618863f, 
    0.25345343f, 0.00908585f, 0.02449733f, -0.02936985f, 0.07990226f, 0.04503018f, 0.01108806f, -0.00145406f, 
    0.08310597f, -0.13422894f, 0.01742581f, 0.05599250f, -0.02971146f, 0.00394531f, -0.01473319f, -0.03436742f, 
    0.10312886f, -0.14144051f, -0.04476218f, 0.05840397f, 0.08142153f, -0.04852661f, 0.03425597f, 0.01425344f, 
    0.08351809f, -0.46475211f, 0.09269854f, 0.01056391f, 0.01077569f, 0.13665657f, 0.08449219f, -0.00515344f, 
    0.00342388f, -0.00408908f, -0.07730121f, 0.11130907f, -0.08243033f, 0.08735313f, 0.08868171f, -0.00247992f, 
    0.03846077f, 0.01155120f, 0.03278994f, -0.40299782f, 0.09882230f, -0.05018634f, -0.08669068f, 0.07829260f, 
    0.02134659f, 0.03781713f, 0.10235492f, -0.09755597f, -0.16890314f, 0.03005737f, -0.04383744f, 0.07510462f, 
    -0.02332757f, -0.03187887f, -0.01695418f, 0.05174486f, 0.03341480f, -0.22565471f, 0.04060733f, 0.03730669f, 
    0.02890446f, 0.04399456f, -0.01903328f, 0.10683734f, 0.05833716f, -0.00677046f, 0.23297971f, 0.05426153f, 
    -0.18615244f, 0.07349700f, -0.00814288f, 0.11498147f, -0.09460291f, 0.09908742f, -0.00487487f, -0.24155554f, 
    0.10599994f, -0.07478536f, 0.01565519f, 0.06096916f, 0.06385102f, 0.08922265f, -0.07766407f, -0.09002365f, 
    -0.04654351f, -0.15459511f, -0.07919098f, 0.06946321f, 0.09723239f, 0.11331201f, -0.08527973f, -0.13456191f, 
    0.05865414f, 0.26703811f, -0.02907428f, -0.01477205f, -0.12259118f, -0.01554724f, -0.09255324f, 0.05167786f, 
    -0.06756449f, -0.04816234f, 0.23014463f, 0.02578391f, -0.08780143f, 0.02023132f, 0.13194312f, -0.03632150f, 
    0.03617020f, 0.09350602f, -0.08452932f, 0.06995787f, -0.23180605f, -0.02258254f, -0.01286765f, 0.06861111f, 
    0.15012732f, -0.08504548f, -0.10158772f, -0.00193501f, 0.05749793f, 0.25600573f, 0.10971239f, 0.12055893f, 
    -0.08311375f, 0.05235757f, 0.01602828f, 0.06091744f, 0.01433071f, 0.07507432f, -0.15759742f, -0.12534487f, 
    -0.19628614f, -0.03987658f, 0.19426158f, 0.13618608f, -0.11853071f, 0.12015496f, 0.16206552f, 0.12261763f, 
    -0.03012001f, -0.00206226f, -0.02849734f, 0.06665232f, 0.04897465f, -0.04704617f, 0.01767301f, -0.48143092f, 
    -0.04653756f, -0.16263925f, -0.01253989f, 0.09195596f, -0.03045766f, -0.02245389f, 0.00205984f, 0.09160621f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.01793328f, -0.05444787f, 0.15010875f, -0.02452410f, -0.01369264f, 0.08575767f, -0.00736754f, 0.02477364f, 
    -0.05640619f, -0.05895625f, -0.03904653f, 0.10342338f, -0.11660082f, 0.12042131f, 0.22496018f, 0.06232790f, 
    0.01465242f, 0.02258011f, 0.05349193f, -0.03914353f, -0.00472779f, 0.07719125f, -0.03562917f, 0.02946160f, 
    0.04830116f, 0.02925604f, -0.03386632f, 0.12699607f, -0.06445804f, -0.04309648f, -0.00041263f, 0.14504963f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03449738f, 0.40342265f, 0.19160973f, 0.09065332f, 0.10879160f, 0.14557077f, -0.42929897f, -0.15869322f, 
    0.27796176f, -0.14130308f, 0.15934427f, 0.27135399f, -0.02590290f, -0.17106541f, 0.26905042f, 0.01058486f, 
    -0.17498887f, -0.03330780f, 0.49501863f, -0.00483435f, -0.08079606f, -0.05697437f, -0.01020742f, -0.05253997f, 
    -0.01077421f, 0.07585711f, 0.03023583f, -0.19652613f, -0.03058360f, 0.06246069f, -0.06509407f, -0.29645613f, 
    0.01165529f, -0.15666015f, -0.15566468f, 0.03954773f, -0.09691674f, -0.03984210f, -0.01479753f, 0.17509821f, 
    -0.15980290f, -0.01680321f, 0.13619049f, -0.03748640f, -0.14838186f, 0.07123244f, -0.09192319f, -0.03502648f, 
    -0.01495015f, 0.10385839f, -0.15043062f, -0.10247721f, -0.16673850f, -0.09183238f, 0.07671951f, 0.13307413f, 
    0.13449626f, 0.06123203f, 0.00294044f, 0.09420534f, -0.16740660f, -0.13017267f, -0.05494057f, 0.01290938f, 
    0.16464268f, 0.11391920f, 0.05089676f, 0.43396756f, 0.34311488f, -0.04710804f, 0.26662686f, 0.13777718f, 
    -0.18772569f, -0.04165984f, 0.09904245f, -0.23810773f, -0.15127586f, 0.18573956f, -0.22796340f, 0.03099015f, 
    0.13920231f, 0.05472671f, -0.18511216f, 0.13664703f, -0.18188104f, 0.36335891f, 0.14521074f, -0.16701816f, 
    0.12511688f, -0.12736380f, 0.08176220f, -0.24756150f, -0.16302931f, 0.12690254f, -0.13693321f, 0.03488325f, 
    0.04445099f, -0.28640234f, 0.13153337f, -0.10932802f, -0.08528217f, -0.23664989f, 0.44685975f, -0.11880385f, 
    -0.18990508f, -0.16543321f, -0.10380526f, -0.01747340f, -0.02439875f, 0.25374398f, -0.12431460f, 0.16942355f, 
    -0.10873765f, -0.05347266f, -0.37455919f, 0.12740441f, 0.21448144f, 0.17698687f, 0.08831111f, -0.00238011f, 
    0.02849195f, 0.05934820f, 0.14556617f, 0.17023264f, -0.11403630f, -0.14134228f, -0.09272005f, 0.14046662f, 
    -0.15913895f, 0.08925308f, -0.14106312f, 0.38497007f, -0.09833856f, 0.26683733f, -0.30943525f, -0.06861718f, 
    0.09866165f, 0.14153878f, 0.03041672f, 0.14070055f, 0.02331816f, -0.03106080f, 0.15256074f, 0.20747633f, 
    -0.14865555f, 0.08788852f, -0.21416198f, 0.41846436f, 0.12208906f, -0.13241118f, -0.03986159f, -0.01032023f, 
    -0.07928526f, 0.06953113f, 0.12351064f, 0.28944546f, -0.09414032f, -0.02125618f, 0.15873310f, -0.08860698f, 
    0.12599188f, 0.27659383f, 0.20428838f, -0.35490736f, 0.32246867f, 0.08016751f, 0.41844293f, -0.06937820f, 
    -0.01770463f, -0.10855566f, 0.08805897f, 0.05940793f, -0.15854298f, 0.26252657f, -0.14995360f, 0.06765801f, 
    -0.08075637f, 0.16242990f, -0.28125405f, 0.08549273f, 0.34027779f, -0.21824981f, 0.12088265f, 0.16920221f, 
    0.13370429f, 0.04662200f, 0.13001920f, -0.10960687f, 0.12514886f, 0.08917256f, 0.08147492f, 0.08603015f, 
    -0.11266767f, 0.16962484f, 0.04233573f, 0.04672024f, 0.29555207f, 0.03683371f, 0.26036388f, 0.05420592f, 
    0.11501389f, 0.08201353f, 0.16812460f, -0.27611467f, 0.00447154f, 0.03040336f, 0.13754261f, -0.40056029f, 
    0.13922760f, -0.12611647f, 0.35506147f, 0.13950695f, 0.04969088f, 0.27241442f, 0.03725401f, 0.13195686f, 
    0.08394636f, 0.10413595f, 0.03263068f, -0.20441815f, 0.07116779f, 0.08900911f, 0.16428103f, -0.18263552f, 
    0.08945794f, -0.04862593f, -0.05154320f, -0.04016780f, -0.06743620f, -0.07108806f, -0.16954803f, -0.14431979f, 
    0.38466311f, -0.03062145f, -0.11892161f, 0.04523785f, -0.14480425f, -0.15027113f, 0.61157036f, -0.03081854f, 
    -0.06698669f, 0.12480021f, 0.09690279f, -0.36043721f, 0.19154952f, 0.05214760f, 0.14305030f, -0.02742011f, 
    -0.11144109f, -0.02307971f, -0.00371809f, 0.30784979f, 0.02040465f, 0.11571203f, 0.16957104f, 0.30170664f, 
    -0.15824902f, -0.22342257f, 0.13101789f, 0.38760319f, 0.30377969f, -0.16510275f, -0.40952745f, 0.15276994f, 
    0.10922222f, 0.07042317f, 0.07486046f, -0.29582024f, -0.10428901f, 0.42394236f, -0.28402632f, -0.23724733f, 
    -0.15863623f, 0.07171238f, 0.24535528f, 0.26788446f, -0.05679410f, -0.00043473f, 0.08873976f, 0.08075114f, 
    -0.06017233f, 0.10002728f, -0.02832954f, 0.04972047f, 0.05406680f, 0.02079620f, 0.11411600f, 0.19600052f, 
    -0.12802623f, 0.10490962f, 0.29894173f, -0.08672373f, 0.00847678f, -0.14121817f, 0.23681936f, 0.09670742f, 
    -0.06128482f, -0.05579817f, 0.04302959f, 0.04425642f, 0.18522751f, 0.31861475f, 0.44212908f, -0.04393556f, 
    -0.07355183f, -0.12935033f, 0.30232948f, -0.23818047f, -0.17884666f, 0.21859017f, 0.07234860f, -0.00224676f, 
    0.17158720f, 0.09402675f, 0.17609596f, -0.28435159f, 0.17010742f, -0.15971699f, -0.03042577f, -0.24000914f, 
    0.12705402f, 0.17438506f, 0.29084396f, -0.00537977f, 0.06859243f, -0.22390647f, -0.21350165f, 0.04290421f, 
    -0.05123773f, -0.15017724f, -0.02724614f, 0.19525699f, -0.02361798f, 0.46757179f, 0.13938087f, 0.09577806f, 
    0.03054457f, -0.10222059f, 0.10675433f, 0.42136192f, -0.20496969f, 0.22077496f, 0.15436177f, -0.11788272f, 
    0.12884007f, 0.02458058f, 0.16981976f, -0.25358886f, 0.08882145f, 0.10589191f, 0.10256263f, -0.18000904f, 
    -0.03855803f, 0.06636930f, 0.17779799f, 0.04658104f, 0.32012713f, -0.05004492f, -0.07873164f, -0.06879617f, 
    0.20321809f, 0.09210434f, -0.09026696f, -0.07118735f, -0.18341114f, -0.31854296f, 0.16346028f, -0.22841519f, 
    -0.13266732f, -0.00301212f, -0.09238482f, -0.25310308f, 0.24868822f, 0.17061965f, -0.11630565f, 0.17771606f, 
    -0.04169885f, -0.06317078f, 0.16865510f, 0.08348203f, 0.02245494f, 0.04842575f, 0.09318525f, 0.18015641f, 
    0.03104300f, -0.26693359f, 0.06929976f, 0.07704688f, -0.19066870f, -0.25439292f, -0.32052031f, 0.05424178f, 
    0.10175712f, -0.04007146f, 0.10441773f, 0.13910019f, 0.08819645f, 0.41231832f, -0.34674412f, 0.11903103f, 
    0.16507703f, -0.00762302f, 0.31706259f, 0.04014500f, 0.26254109f, -0.27347970f, -0.01606428f, -0.00490238f, 
    0.04585045f, 0.03331053f, 0.12805924f, 0.31256622f, 0.17192598f, -0.13635203f, 0.14617316f, 0.14037365f, 
    -0.12241708f, -0.26016721f, 0.21744764f, 0.41295660f, 0.03082528f, -0.09252586f, 0.38593614f, 0.12251876f, 
    -0.24486643f, -0.01577873f, -0.16279529f, -0.08982551f, -0.16013534f, 0.13512070f, 0.00403373f, -0.03749547f, 
    -0.17457341f, -0.08755595f, -0.10289675f, -0.00909899f, -0.33570075f, 0.26740199f, -0.03838619f, -0.00959656f, 
    -0.16509095f, 0.00547193f, -0.14453870f, 0.13551275f, 0.14080638f, 0.12865841f, -0.16525142f, -0.09758735f, 
    0.13627492f, -0.08058792f, -0.10287251f, 0.33853075f, -0.19563539f, 0.28140759f, 0.13847716f, 0.11561155f, 
    -0.27158982f, 0.16137891f, 0.02723961f, 0.24593106f, -0.05132526f, 0.01160105f, -0.45313945f, 0.14727625f, 
    -0.13138153f, -0.03771861f, 0.25740501f, 0.26435697f, 0.06610961f, 0.08443012f, -0.11069678f, -0.07842212f, 
    -0.16318777f, -0.16846688f, -0.04978396f, 0.07861999f, -0.15999331f, 0.12245505f, 0.06618895f, -0.01681754f, 
    0.11715659f, -0.02450286f, 0.25602987f, -0.01434619f, -0.19090900f, -0.38487822f, 0.04166717f, 0.09180896f, 
    0.05095154f, 0.01158543f, -0.01875663f, 0.06648684f, 0.33382422f, 0.19770679f, -0.04196785f, 0.03430199f, 
    0.11054032f, -0.13908666f, -0.09598500f, 0.45642665f, -0.21523638f, 0.24597794f, 0.02595543f, -0.07323254f, 
    -0.14598292f, -0.03300671f, -0.15897949f, 0.13587092f, -0.05061416f, 0.08191635f, 0.10757736f, -0.12637779f, 
    0.14553115f, 0.23869388f, 0.28014338f, -0.11284912f, 0.02657747f, 0.13663480f, 0.02326007f, -0.08540280f, 
    0.24174325f, 0.07997271f, 0.11020833f, 0.00101321f, -0.16323088f, -0.06400784f, 0.30540165f, -0.21586442f, 
    0.05634898f, -0.07353843f, 0.25304341f, -0.11948346f, -0.07209317f, -0.17560595f, -0.16227415f, -0.05938140f, 
    -0.13715133f, -0.02168110f, 0.10705733f, -0.05625390f, 0.09796546f, 0.05673916f, 0.09648862f, -0.25896189f, 
    -0.02159607f, -0.11406697f, -0.14836568f, -0.08287349f, -0.09217592f, 0.10485630f, -0.04565569f, 0.08838242f, 
    -0.17320074f, -0.14926162f, -0.08828036f, 0.08035930f, 0.06865522f, 0.16387302f, -0.06574802f, 0.11312672f, 
    -0.12410912f, 0.02336444f, -0.11493842f, -0.04234842f, 0.04109779f, 0.02243632f, 0.05837345f, 0.12570360f, 
    -0.09543134f, -0.08622728f, -0.09908193f, -0.08366321f, -0.12785207f, -0.06737705f, -0.00792085f, -0.12795360f, 
    -0.01127015f, 0.38163906f, -0.01277874f, -0.09628029f, -0.01559866f, -0.08395541f, 0.33198419f, -0.06010060f, 
    -0.04904187f, -0.08391783f, 0.10987180f, 0.47459745f, 0.39688596f, 0.02818552f, 0.07490759f, -0.00836729f, 
    0.14463502f, 0.15978846f, -0.06874913f, 0.27679968f, -0.03603537f, -0.03983203f, 0.11651474f, 0.12746418f, 
    0.11993431f, 0.09205431f, 0.16456407f, 0.12795311f, 0.00553191f, -0.13516189f, 0.00392979f, -0.13076198f, 
    -0.16871539f, 0.18711039f, 0.04702678f, -0.17907268f, -0.21092539f, 0.40525386f, -0.07643499f, 0.02612538f, 
    0.42568138f, -0.17155617f, 0.04805759f, 0.42924914f, 0.38893467f, -0.20082708f, 0.43832383f, 0.02333462f, 
    -0.16564082f, 0.05572819f, 0.27731964f, -0.24827191f, 0.16372494f, -0.02253345f, -0.15692197f, 0.10291455f, 
    0.06248182f, 0.08680236f, 0.03049362f, -0.07452787f, 0.05230279f, 0.11000837f, -0.11096901f, -0.11786196f, 
    -0.14295077f, 0.35883778f, 0.28193793f, -0.29298139f, 0.39123216f, -0.04919773f, 0.14360426f, -0.16830447f, 
    -0.05003288f, 0.02423817f, 0.01907874f, 0.19348487f, -0.10781998f, -0.12329924f, -0.26652789f, -0.44026047f, 
    0.16400005f, 0.10009211f, -0.19286312f, 0.49373198f, 0.24770680f, -0.06164859f, -0.09673785f, -0.17285539f, 
    0.01318887f, -0.11346028f, -0.15544993f, 0.18356648f, -0.16645089f, 0.16764395f, -0.16296230f, 0.02615232f, 
    0.08577589f, 0.02124027f, 0.24870870f, -0.03917988f, 0.31725979f, -0.06544898f, -0.54287934f, -0.13801788f, 
    0.16126804f, -0.04216139f, -0.02192182f, -0.08736463f, 0.09968295f, 0.18428563f, -0.37976307f, -0.19710869f, 
    0.15690067f, -0.06295036f, 0.20923418f, 0.05406676f, -0.01743906f, -0.17838819f, 0.11247928f, -0.14397405f, 
    0.08073505f, 0.11014361f, -0.06268296f, 0.22172742f, -0.06961577f, 0.15465547f, 0.05099236f, 0.19760142f, 
    -0.08835621f, 0.28265834f, 0.06318569f, 0.08737054f, 0.12411760f, 0.21950379f, 0.63545269f, 0.02660237f, 
    -0.23358096f, 0.16551881f, 0.07542276f, 0.14341323f, 0.09200543f, -0.08468363f, 0.09793685f, 0.11992880f, 
    -0.03436215f, 0.01733328f, -0.12143060f, 0.10248553f, 0.15462962f, -0.10304226f, -0.04279134f, -0.07682297f, 
    0.04294566f, -0.14296539f, -0.02413897f, -0.13795169f, -0.14512083f, -0.13768475f, -0.06912103f, -0.36098900f, 
    -0.14201498f, 0.00845301f, 0.10855041f, 0.32312125f, -0.36833730f, 0.18197933f, 0.12890887f, 0.06170026f, 
    -0.03762686f, 0.10338710f, 0.17326649f, 0.32284915f, 0.20932834f, -0.20070235f, 0.11179436f, 0.10589365f, 
    -0.00226133f, 0.01502141f, -0.29165486f, -0.08705201f, 0.04127033f, 0.20473456f, -0.03369794f, 0.07689224f, 
    -0.14873271f, -0.13727400f, 0.06481956f, 0.10487004f, 0.15074529f, -0.07422735f, -0.13412842f, -0.04692579f, 
    0.15233964f, -0.15626122f, -0.07552817f, 0.03124405f, -0.14885847f, 0.11654712f, -0.13093208f, 0.00944469f, 
    -0.04764686f, 0.05670894f, -0.13121846f, -0.05678974f, -0.04758626f, -0.18198591f, 0.03060791f, -0.16931126f, 
    0.08649275f, 0.07352301f, -0.02128811f, 0.10330459f, -0.07753082f, -0.13727091f, -0.15829359f, -0.00508538f, 
    0.03014437f, 0.01424875f, 0.12411608f, -0.09367324f, -0.04759924f, 0.02847390f, 0.11908029f, -0.14000864f, 
    -0.05449056f, -0.21970533f, -0.10934802f, 0.17619599f, 0.12560523f, 0.15175298f, -0.08799909f, 0.11809149f, 
    -0.19295225f, 0.11526699f, -0.11728702f, 0.21852389f, 0.14574566f, 0.46562412f, -0.05915930f, 0.06083709f, 
    0.06527323f, -0.09418925f, -0.11259788f, 0.12871087f, -0.08353922f, 0.23070619f, 0.16037913f, 0.02690528f, 
    0.02215936f, 0.01334734f, -0.09591453f, -0.13630442f, 0.12211365f, -0.02283569f, -0.05850092f, -0.12842348f, 
    -0.14135385f, -0.20097682f, 0.02782520f, -0.28527257f, 0.11081398f, 0.20495944f, -0.24424838f, -0.15424778f, 
    0.33102173f, 0.02536199f, -0.02077818f, 0.01859503f, -0.34108138f, -0.22228569f, 0.21927644f, 0.17187455f, 
    -0.16299027f, -0.03341153f, 0.28632611f, -0.28343314f, 0.32297027f, -0.19551209f, 0.04904116f, 0.09721694f, 
    0.06744620f, -0.05677713f, -0.15872079f, -0.01335681f, -0.00147989f, 0.11951770f, 0.08118589f, 0.36382931f, 
    -0.12426145f, 0.12276387f, -0.13766581f, -0.04225824f, -0.15573134f, 0.17875199f, -0.41103622f, -0.12308970f, 
    0.16401868f, 0.04294286f, 0.01396837f, 0.27030665f, 0.53561771f, 0.41003141f, 0.04574350f, 0.26562372f, 
    0.13945602f, 0.03379857f, -0.10638044f, 0.18378374f, 0.24263045f, 0.06422787f, -0.00379025f, -0.10348480f, 
    -0.03197124f, 0.12968089f, -0.01311550f, 0.28555167f, -0.14787263f, -0.16343337f, 0.09592833f, -0.30880833f, 
    -0.11710430f, 0.10462895f, 0.22109972f, -0.15337063f, 0.26707947f, -0.06441927f, 0.13826230f, -0.08057217f, 
    0.00385535f, 0.16868271f, -0.13513784f, 0.08059753f, 0.18876526f, -0.17985797f, -0.26354948f, -0.37854731f, 
    0.02819685f, 0.00603062f, 0.16904575f, 0.09098508f, 0.21220675f, -0.32686061f, 0.13615780f, -0.12283356f, 
    0.03018540f, 0.15089172f, -0.12390520f, 0.27490360f, -0.01413772f, 0.01464757f, -0.09316096f, 0.18915562f, 
    -0.02599406f, -0.22546594f, 0.18910320f, 0.24150866f, 0.18354724f, 0.06686233f, -0.08853854f, 0.13346680f, 
    -0.12293835f, 0.11770204f, -0.06509872f, -0.24711196f, -0.08308424f, 0.18115652f, 0.18015553f, 0.28779092f, 
    -0.10068571f, -0.10503720f, 0.43664312f, -0.17569809f, -0.34546521f, 0.07283559f, -0.10362228f, 0.09117045f, 
    0.02532094f, -0.00432133f, 0.11972333f, -0.34037840f, -0.11044839f, -0.16769542f, -0.15675558f, -0.04174872f, 
    -0.16133223f, 0.01094905f, 0.11510707f, 0.21576799f, 0.40362221f, -0.11422260f, 0.36315465f, -0.08280048f, 
    -0.07994315f, -0.07089134f, 0.00235142f, -0.34703201f, -0.57662416f, -0.13903338f, -0.11515472f, -0.22056855f, 
    0.11409174f, -0.16381252f, -0.02497477f, 0.20798029f, -0.05370050f, -0.03062078f, 0.11994728f, -0.00040156f, 
    0.14134961f, -0.08050343f, -0.11889338f, 0.37909579f, 0.14507620f, 0.04639443f, 0.11872084f, 0.25512481f, 
    0.00004080f, 0.06236434f, 0.04501809f, 0.33150646f, -0.01567359f, 0.08981742f, -0.13059728f, 0.02205968f, 
    0.01944694f, -0.13137718f, 0.09199997f, 0.16804615f, 0.76460499f, 0.15588671f, -0.14704664f, -0.08576708f, 
    -0.13169199f, 0.15299743f, 0.17819704f, 0.34250805f, -0.21319458f, 0.02867999f, -0.14580370f, -0.15787438f, 
    -0.04643234f, 0.00226986f, -0.14031053f, -0.00375293f, -0.11218741f, 0.09370954f, 0.05974308f, -0.29212645f, 
    0.14317007f, -0.11400056f, 0.04082821f, 0.29456627f, 0.00606795f, 0.03519204f, 0.01156474f, -0.05595287f, 
    -0.22612104f, 0.09770625f, 0.04236792f, -0.11873287f, -0.33576387f, 0.13828735f, 0.08007311f, 0.20951688f, 
    0.09511973f, -0.10049953f, -0.05709085f, -0.07642163f, 0.09757718f, 0.31342337f, 0.05295075f, -0.16362317f, 
    -0.10237680f, -0.16097669f, 0.11035100f, -0.25286242f, -0.16097444f, -0.10167091f, 0.05747232f, -0.04925471f, 
    0.00116237f, 0.05087396f, -0.05941351f, -0.27434674f, 0.13902424f, 0.31920302f, 0.00529979f, 0.11658733f, 
    0.45661950f, -0.11889995f, 0.14144409f, -0.04178628f, 0.57286471f, 0.01780043f, 0.24363749f, -0.08534399f, 
    0.11490078f, -0.04803670f, -0.22562319f, -0.06173710f, 0.09839453f, -0.36009279f, 0.07657044f, 0.15114278f, 
    0.16713588f, -0.11028349f, 0.14620942f, 0.02233587f, 0.15083170f, -0.12742263f, -0.14544803f, 0.20044315f, 
    -0.05343594f, -0.04006783f, -0.02134393f, -0.07449178f, -0.18174790f, 0.05487929f, 0.02934380f, -0.01600626f, 
    -0.15139465f, 0.13949762f, -0.09061680f, -0.11823603f, -0.12296775f, -0.06569996f, 0.01051654f, 0.06323784f, 
    -0.10171566f, -0.03506966f, 0.05335056f, -0.10555150f, -0.17642982f, -0.11865429f, 0.00100114f, -0.09078134f, 
    -0.14791819f, 0.04865792f, 0.16279243f, -0.09570003f, 0.02686012f, -0.09932838f, -0.01662337f, 0.04991762f, 
    -0.11034011f, 0.44496703f, 0.15968382f, -0.13059118f, 0.19989124f, 0.11370152f, 0.04792934f, 0.08839827f, 
    0.03942598f, 0.08194993f, -0.07437659f, -0.09379218f, 0.17667232f, -0.36681134f, 0.38818645f, -0.41768607f, 
    -0.11736120f, 0.05397862f, 0.19330283f, -0.09780882f, 0.12936530f, 0.00240432f, -0.02504583f, -0.18166128f, 
    -0.14512314f, -0.18039939f, -0.04518307f, -0.00077384f, -0.14488471f, -0.12945646f, 0.11285956f, -0.03330138f, 
    0.09319867f, -0.34135631f, 0.13034911f, 0.22745016f, -0.37617707f, -0.03810116f, -0.10026885f, -0.01349886f, 
    -0.37562484f, -0.16920361f, -0.01478874f, 0.34265924f, -0.18459488f, 0.16797926f, 0.03040063f, 0.31166789f, 
    0.14902668f, 0.07892793f, -0.06521297f, 0.04877147f, -0.46987829f, 0.04407299f, -0.17430499f, 0.15649940f, 
    -0.02600108f, -0.11113974f, -0.14737493f, 0.28779167f, -0.12181869f, -0.06553534f, 0.08157843f, -0.62759763f, 
    0.16409047f, -0.29627350f, 0.11423632f, -0.11366916f, -0.01161310f, -0.06983121f, 0.21854985f, -0.13010709f, 
    -0.39600280f, -0.00260967f, -0.17271702f, -0.15300415f, -0.39307031f, 0.67239064f, 0.01236505f, 0.27770299f, 
    -0.10036005f, 0.17283544f, 0.04530661f, -0.11554046f, -0.01210602f, 0.22273076f, 0.07267777f, -0.03168529f, 
    -0.16007239f, 0.11615796f, 0.12538695f, -0.15134797f, -0.10029869f, 0.08026481f, -0.07899655f, -0.11889884f, 
    0.07894686f, -0.21593674f, 0.05807518f, 0.35068324f, -0.02417418f, -0.08060729f, -0.47042885f, -0.06771696f, 
    0.09277789f, 0.09036838f, -0.17943063f, -0.02978365f, 0.03099629f, -0.14263119f, 0.03395299f, -0.19023369f, 
    -0.16563970f, -0.07792479f, 0.33655414f, 0.11290716f, -0.17382607f, 0.37703860f, 0.06030712f, 0.07268918f, 
    -0.12658304f, 0.00817910f, -0.04440979f, -0.02450973f, 0.14516512f, 0.09426391f, -0.17980561f, 0.32400081f, 
    -0.06000338f, -0.25922287f, -0.06737706f, 0.33180243f, -0.13626966f, 0.30113617f, -0.13446808f, 0.07096408f, 
    -0.18805031f, -0.00097452f, -0.02074297f, -0.03114270f, -0.08230591f, -0.16405807f, -0.35704634f, 0.29977724f, 
    0.02347887f, -0.12672180f, 0.35906807f, 0.15191492f, 0.01808803f, 0.01646923f, 0.06440344f, -0.03384064f, 
    0.05978716f, -0.08865016f, -0.07996019f, -0.02779441f, 0.10690478f, -0.05786305f, 0.08015572f, 0.34541592f, 
    -0.12127813f, -0.09573893f, -0.09177170f, 0.31896538f, -0.07823805f, 0.45630494f, 0.07652298f, 0.08548097f, 
    0.03095849f, -0.02439964f, -0.08855802f, 0.12232438f, 0.05588324f, -0.39210880f, 0.13609119f, 0.24436237f, 
    0.10524180f, 0.14122459f, 0.15048639f, 0.04300969f, 0.07994664f, 0.18914473f, -0.01265878f, 0.00895274f, 
    -0.01868884f, -0.05174366f, 0.05501041f, -0.17147677f, -0.15424056f, -0.01420731f, 0.13398015f, -0.06604779f, 
    -0.10299233f, -0.24183175f, -0.12324049f, 0.41808158f, -0.06107225f, 0.12454533f, 0.22420828f, -0.00354685f, 
    0.03678335f, -0.00151943f, -0.08942339f, -0.19450694f, 0.21983738f, -0.15439956f, 0.22457670f, 0.18736602f, 
    0.10908338f, -0.01585338f, 0.13398473f, -0.14385058f, -0.05983252f, 0.33934036f, -0.09552069f, -0.11698347f, 
    -0.08981413f, -0.07036746f, 0.00077524f, -0.02684550f, -0.10457289f, -0.00556962f, 0.06936650f, -0.03457198f, 
    -0.10589138f, -0.03154640f, -0.12812215f, -0.16743080f, -0.07259237f, -0.10997197f, 0.08511423f, -0.04031355f, 
    -0.18357313f, -0.07532723f, -0.08070806f, -0.17602012f, 0.01966280f, -0.15782361f, -0.00599840f, 0.10954744f, 
    -0.08483274f, -0.01379049f, 0.01794211f, 0.03878294f, -0.01881680f, 0.08036002f, 0.13756965f, 0.14604232f, 
    -0.13270181f, -0.17371215f, 0.10699985f, -0.13694222f, -0.05326577f, -0.04286775f, -0.08378403f, -0.08812218f, 
    -0.11733649f, -0.15529920f, 0.11475733f, 0.20087974f, 0.25671721f, -0.03209491f, -0.13217787f, -0.04050104f, 
    -0.19883287f, 0.08849154f, -0.16918786f, -0.21444120f, -0.22984479f, 0.00884495f, -0.20345081f, 0.02674650f, 
    -0.03340860f, -0.05069809f, 0.18256019f, -0.05161246f, -0.10220371f, 0.14153573f, 0.17601812f, -0.15128012f, 
    0.15450796f, -0.17459910f, -0.02764871f, -0.26100621f, -0.00853632f, -0.12279577f, 0.09320913f, 0.19195995f, 
    -0.17239955f, 0.23082724f, 0.14439951f, 0.04950056f, 0.28796464f, 0.34103701f, 0.51382035f, -0.09134984f, 
    -0.22152790f, 0.02904995f, -0.08515186f, 0.01866921f, -0.48168486f, -0.38819757f, -0.14622252f, 0.12702952f, 
    -0.05285214f, -0.09530968f, -0.16981186f, -0.10716932f, 0.08181344f, -0.30402419f, -0.15143985f, 0.15388927f, 
    0.09310871f, 0.02375287f, -0.14506458f, 0.13060863f, -0.04708234f, -0.01438116f, -0.07021455f, 0.06971333f, 
    -0.08644958f, -0.11793774f, -0.04838594f, 0.03549920f, -0.26719406f, 0.16050875f, -0.12253295f, -0.04866260f, 
    0.14295873f, 0.07029179f, -0.11698130f, 0.04707047f, 0.13442537f, 0.40899613f, 0.43396759f, 0.24728039f, 
    -0.14590420f, -0.09223540f, -0.18349440f, -0.19433282f, 0.12067055f, 0.27869976f, -0.14313135f, -0.15911607f, 
    0.17662503f, 0.05597552f, 0.11927196f, -0.05286703f, 0.07701895f, 0.05707029f, -0.09197204f, -0.04627658f, 
    -0.16872150f, 0.02617473f, 0.18683012f, -0.16002293f, 0.02128697f, -0.15848567f, 0.01706781f, -0.08376765f, 
    0.08248705f, 0.00007501f, -0.04636206f, 0.16112004f, 0.51799065f, 0.43112549f, -0.03232237f, -0.05762943f, 
    -0.08915778f, -0.05910475f, 0.20924617f, 0.23204829f, -0.16553220f, 0.13846451f, -0.06513856f, -0.11736437f, 
    -0.06456406f, -0.13119833f, 0.16607735f, -0.21049950f, 0.17988163f, 0.04338741f, -0.13518618f, -0.23315950f, 
    0.13420174f, -0.04532862f, 0.14641382f, 0.17709850f, -0.07919785f, 0.10908018f, -0.12448024f, 0.13635913f, 
    0.05465357f, -0.01347602f, -0.08407253f, -0.12913381f, -0.04557011f, 0.05166677f, -0.32768935f, -0.05170995f, 
    -0.09985805f, 0.16321470f, -0.12132489f, 0.32863244f, 0.29407766f, -0.29261902f, -0.10202957f, -0.03305775f, 
    0.11838702f, -0.03612959f, -0.04035113f, 0.27273911f, 0.16565126f, 0.12293819f, 0.02660275f, 0.33542061f, 
    0.00877519f, -0.11790311f, 0.10783022f, -0.16261742f, 0.14827800f, 0.12131331f, -0.53784949f, 0.09055078f, 
    0.38075143f, -0.12513053f, 0.10231403f, -0.13917388f, 0.26599759f, -0.19689369f, -0.13816440f, -0.05962718f, 
    -0.15590534f, -0.01524217f, 0.44090599f, -0.04605925f, 0.16490687f, 0.03959290f, 0.02276670f, -0.11643947f, 
    0.11110494f, -0.17144351f, -0.03120170f, -0.06741983f, -0.16279830f, -0.14664130f, -0.07881229f, 0.17072321f, 
    -0.10625238f, 0.07771955f, -0.14967418f, 0.11181970f, 0.12722391f, 0.17905273f, -0.16384889f, -0.01265009f, 
    0.39582875f, -0.08027385f, 0.02096651f, 0.07376564f, 0.49406481f, 0.08996714f, 0.27530479f, 0.22487719f, 
    0.10493658f, 0.00672858f, -0.25775787f, -0.01756913f, 0.39555687f, -0.26675904f, -0.03376426f, -0.11669893f, 
    -0.09441236f, -0.12012642f, 0.07689398f, -0.07431705f, -0.00244900f, 0.10644089f, 0.12671277f, -0.00757317f, 
    0.11199920f, 0.34745771f, 0.00721694f, -0.06252777f, 0.23029111f, 0.27702183f, 0.35817009f, 0.10049570f, 
    0.09550308f, 0.13528590f, -0.01970730f, 0.27980974f, -0.01640375f, -0.23129562f, 0.37286443f, -0.08416040f, 
    -0.06591035f, 0.16776563f, 0.27860805f, -0.28081390f, 0.22113660f, -0.23305751f, 0.13098368f, 0.00499638f, 
    -0.14478984f, 0.14277409f, 0.13718453f, -0.01362468f, -0.07090691f, 0.09801793f, -0.02763206f, -0.29808831f, 
    -0.11932665f, 0.18223383f, 0.16489030f, -0.11547329f, -0.33535203f, -0.12523890f, -0.05828280f, 0.06015079f, 
    -0.32342288f, -0.11645529f, 0.03274050f, 0.52349085f, 0.28435636f, 0.17003216f, -0.15910320f, 0.00971621f, 
    -0.08623222f, -0.02727331f, 0.16568251f, 0.18386844f, 0.14618614f, -0.22383155f, -0.03162596f, 0.15135559f, 
    0.06504508f, 0.15515459f, 0.01773380f, 0.19192778f, -0.03789395f, 0.02004525f, -0.01509269f, -0.41655043f, 
    0.04649314f, -0.23825163f, -0.11458095f, 0.27641192f, 0.00366846f, -0.15409085f, 0.08285412f, 0.13787723f, 
    -0.27985236f, -0.06581295f, 0.13776982f, 0.16093558f, 0.26544243f, 0.36327407f, -0.08501862f, 0.37281281f, 
    0.06904497f, -0.00012142f, 0.16988426f, 0.32953471f, -0.15408033f, 0.05024594f, 0.09769581f, 0.01697654f, 
    0.07118746f, 0.10457690f, 0.07732952f, 0.08379454f, 0.13841143f, -0.04608692f, 0.15956859f, 0.06990413f, 
    0.10258466f, -0.04665164f, -0.07213541f, 0.12279060f, -0.24864869f, -0.01134717f, -0.37687942f, 0.02230196f, 
    0.26382256f, -0.05538496f, -0.02274644f, 0.08447046f, 0.74860102f, 0.13148072f, 0.24451667f, 0.01727203f, 
    0.01657020f, 0.12207143f, 0.44252777f, -0.00227279f, -0.26908854f, 0.22553918f, -0.06965175f, -0.17789932f, 
    -0.17074649f, -0.15004371f, 0.00605874f, 0.25926337f, 0.06266783f, 0.13714236f, 0.16465741f, -0.04526335f, 
    0.16579583f, -0.06548905f, -0.07849500f, -0.21789086f, -0.37762636f, -0.07016265f, -0.13968505f, -0.03992662f, 
    0.27260691f, 0.04468686f, -0.00627815f, 0.39362586f, 0.46918672f, 0.11735402f, 0.16087717f, 0.19211704f, 
    0.12854612f, 0.08729240f, -0.09087206f, -0.09495061f, 0.15088060f, -0.00341060f, -0.06737071f, 0.08292083f, 
    -0.09870347f, -0.02590094f, 0.05245943f, 0.25759906f, -0.05112340f, -0.08129147f, 0.02317115f, 0.27390721f, 
    0.17514014f, 0.14285927f, 0.25183296f, -0.42157161f, 0.25819013f, -0.11505409f, -0.15278317f, 0.10063487f, 
    0.00526882f, -0.10928182f, -0.04117543f, 0.14705187f, -0.04753210f, 0.37970865f, -0.16685833f, 0.03732419f, 
    -0.08911924f, 0.13908388f, 0.11762381f, 0.28679857f, 0.23535308f, 0.03738934f, 0.06622092f, 0.09448962f, 
    -0.15762451f, -0.05947265f, 0.07163110f, -0.17885736f, 0.07266741f, 0.11913170f, 0.15912789f, -0.27726886f, 
    0.00285372f, 0.08990233f, 0.17009090f, -0.05499420f, 0.12441888f, -0.30577344f, -0.09926565f, -0.05267274f, 
    0.26109576f, 0.01192861f, 0.03961731f, -0.13714668f, -0.00341261f, 0.50925207f, -0.15117958f, -0.07996673f, 
    0.15644266f, -0.12968580f, -0.18646525f, 0.18745044f, 0.20329973f, 0.26000315f, -0.08380098f, -0.01637384f, 
    -0.16001093f, 0.11642617f, 0.07718813f, -0.27834922f, -0.02564861f, -0.15860486f, -0.12479979f, -0.10231561f, 
    0.03355319f, -0.17004089f, -0.08236502f, 0.30275509f, -0.28263023f, 0.38641161f, 0.17037798f, 0.11335912f, 
    0.18274038f, -0.16464780f, -0.10887579f, 0.31069300f, -0.06605406f, -0.27146167f, 0.41570812f, 0.24462654f, 
    0.07214253f, -0.05704461f, 0.12929712f, -0.17548886f, -0.26196232f, 0.22207151f, 0.15915705f, -0.01493797f, 
    -0.16259961f, -0.14020285f, -0.13205570f, -0.16129465f, -0.02737820f, 0.08018499f, 0.16744331f, 0.09891845f, 
    0.16505501f, 0.28797200f, 0.01653918f, -0.11098750f, 0.20578858f, 0.05895654f, -0.04217896f, 0.13883197f, 
    -0.01839846f, 0.17027685f, -0.08056334f, 0.27842423f, -0.21900238f, -0.26535618f, 0.15866461f, 0.07523146f, 
    -0.05593190f, 0.13286625f, 0.36216465f, 0.12793705f, -0.10975701f, 0.25346228f, 0.13017780f, -0.01185998f, 
    0.08072622f, -0.01463320f, 0.02471782f, -0.15797254f, -0.17017993f, 0.15327333f, 0.14737497f, -0.12794575f, 
    0.07733802f, -0.19641337f, 0.25717106f, 0.00348383f, -0.02103947f, 0.04533858f, 0.54284555f, 0.06873638f, 
    -0.24259977f, -0.11504543f, -0.05374125f, 0.00990642f, -0.15675236f, 0.30225015f, -0.22781545f, 0.09607743f, 
    0.08824965f, 0.01678178f, -0.34188497f, 0.16705535f, 0.01820738f, 0.19343343f, -0.03904548f, 0.16645724f, 
    0.03368684f, 0.00261201f, -0.15641551f, -0.31899756f, -0.00228822f, 0.10797114f, -0.02319092f, 0.12202256f, 
    -0.00047547f, 0.11596770f, -0.11799711f, 0.08265815f, -0.10851069f, -0.08270422f, -0.09343224f, -0.09463295f, 
    0.06342450f, 0.15307085f, 0.06551662f, -0.12322937f, -0.10124660f, 0.01743597f, -0.07681054f, -0.11730467f, 
    0.00301251f, 0.01074034f, -0.03150052f, 0.12401005f, -0.13059305f, -0.01925811f, 0.12010983f, -0.03284782f, 
    -0.04231752f, 0.10084906f, -0.09450904f, -0.02200734f, 0.05086282f, -0.08038907f, -0.05923668f, 0.04520865f, 
    0.14767827f, 0.02822070f, -0.19781962f, 0.06152413f, -0.03956568f, 0.03209393f, -0.01513954f, 0.05433764f, 
    -0.19077682f, -0.16711980f, -0.07445218f, -0.11930212f, -0.02005880f, -0.02476343f, -0.09463797f, -0.05360690f, 
    -0.10329288f, -0.03278753f, -0.07255945f, 0.11244500f, 0.01832944f, 0.02811044f, -0.10838249f, 0.03061151f, 
    -0.12724514f, 0.11612426f, 0.08841170f, 0.05229374f, 0.13609059f, -0.12547335f, 0.16268992f, -0.10494610f, 
    0.03024476f, -0.01869816f, -0.13992937f, 0.26003981f, 0.06136350f, -0.27753341f, 0.40239966f, 0.18010871f, 
    -0.01653991f, -0.07532442f, -0.07824447f, -0.00975850f, 0.66282696f, 0.18353146f, 0.12754855f, 0.21772510f, 
    -0.06195636f, 0.11031768f, 0.02249555f, 0.03342685f, 0.01089412f, 0.10018806f, 0.02289109f, -0.01591293f, 
    0.11141106f, -0.04513983f, -0.13529387f, 0.22219852f, -0.02382935f, 0.16126537f, 0.03892605f, -0.10911570f, 
    -0.10879969f, 0.27501947f, 0.08435863f, -0.26850438f, 0.25264537f, -0.02116072f, 0.18426354f, 0.03766104f, 
    -0.06008703f, -0.05367544f, 0.14385678f, 0.13828579f, -0.35198978f, 0.25855491f, -0.27892935f, 0.12707834f, 
    0.07798386f, 0.04555047f, -0.39594015f, 0.38126609f, 0.36408156f, 0.08761530f, -0.04517200f, -0.06160476f, 
    0.15039033f, -0.07726296f, 0.10033395f, 0.06458346f, 0.00048931f, -0.04174715f, -0.14893430f, 0.05790351f, 
    0.06673058f, 0.11139256f, 0.10702650f, 0.23977919f, 0.12646757f, 0.35190102f, 0.23216073f, -0.06838991f, 
    -0.14099789f, 0.00492195f, 0.16534881f, -0.00584492f, -0.14689329f, -0.04340792f, 0.46733233f, 0.32149979f, 
    -0.16515967f, 0.12253016f, -0.05630918f, -0.20118108f, -0.20834546f, 0.17480519f, -0.11944912f, 0.07679886f, 
    -0.14121550f, -0.02035966f, -0.13814424f, -0.26510805f, 0.06079626f, 0.09621662f, 0.02919957f, -0.26387399f, 
    -0.16518445f, -0.04468848f, 0.20792624f, -0.08349784f, 0.31652799f, 0.08873546f, 0.35291910f, -0.07406234f, 
    -0.05675429f, 0.01668519f, -0.01183874f, -0.07633453f, -0.39954126f, -0.10307007f, 0.29484478f, -0.07862551f, 
    0.05387355f, -0.12041890f, 0.43373567f, -0.38384846f, 0.09443512f, -0.01511486f, 0.13936459f, -0.07063909f, 
    -0.01338782f, -0.06756495f, -0.03731364f, -0.17466258f, -0.14432634f, -0.11341856f, -0.16345166f, -0.04762749f, 
    -0.01974475f, -0.15115833f, -0.06621864f, -0.00469088f, -0.39905965f, -0.07685400f, -0.27384314f, 0.15509641f, 
    -0.04558827f, -0.08701203f, 0.17386481f, 0.28671262f, 0.29129195f, 0.08554822f, -0.29899144f, 0.41614029f, 
    0.12391970f, 0.14344016f, 0.36962759f, 0.04808897f, -0.05018450f, 0.16671312f, -0.11410720f, -0.11262902f, 
    -0.09268813f, 0.05292386f, 0.11892828f, 0.18111773f, 0.06350987f, 0.17562719f, 0.16492786f, 0.33683267f, 
    0.04959008f, 0.06519683f, 0.10342854f, 0.41975406f, -0.17689954f, -0.03109312f, -0.07173180f, -0.17180589f, 
    0.01740284f, 0.01547957f, 0.11251184f, 0.21095504f, -0.05721933f, -0.01837561f, -0.40775615f, -0.14431661f, 
    0.10401342f, 0.00842221f, 0.10311870f, 0.37843257f, -0.14777760f, 0.06453896f, 0.10243684f, 0.15167309f, 
    0.08012398f, 0.13838294f, 0.03066942f, 0.05536751f, 0.17069358f, 0.07585699f, -0.10033336f, 0.24478506f, 
    0.04529409f, 0.03414920f, 0.14306056f, 0.13306466f, -0.25042987f, 0.40803894f, 0.24703974f, -0.00040925f, 
    0.40680823f, -0.07167889f, 0.14282174f, 0.04227256f, 0.14457308f, -0.34554580f, 0.30641037f, -0.06857903f, 
    0.11478622f, 0.08638205f, -0.17059679f, -0.34829116f, 0.17237090f, 0.13150604f, 0.13457802f, 0.10078766f, 
    -0.14827599f, -0.09823751f, 0.12546144f, 0.03520726f, 0.07441879f, 0.08394921f, -0.01832907f, 0.08291129f, 
    0.13982400f, 0.03374318f, -0.03977128f, 0.18120404f, -0.17046575f, -0.06005318f, 0.08113843f, -0.02366631f, 
    -0.12176573f, 0.05039842f, -0.15592033f, 0.23410064f, -0.05094102f, -0.05596623f, -0.40522408f, 0.20048963f, 
    0.15968047f, 0.17974843f, 0.15295951f, 0.26750055f, 0.29546574f, -0.25046393f, -0.07853454f, -0.01253911f, 
    -0.01448475f, -0.07569581f, -0.00935589f, 0.31011680f, 0.00688037f, 0.04778689f, -0.12152465f, 0.30522743f, 
    -0.04158394f, -0.13244842f, -0.03142437f, 0.41698474f, -0.20865007f, 0.07823487f, 0.02892707f, 0.13683541f, 
    -0.02909373f, -0.13314015f, 0.13149264f, -0.07481783f, 0.32642153f, -0.33071429f, -0.17276552f, -0.16126750f, 
    0.13983355f, -0.00617581f, 0.23446351f, 0.21062632f, -0.14933072f, 0.21729191f, -0.11307096f, -0.01619376f, 
    0.09300140f, -0.08360318f, -0.08049652f, 0.14941810f, 0.16222763f, 0.07321481f, 0.00360083f, 0.24729261f, 
    0.08058376f, -0.01874754f, -0.06363890f, 0.28433424f, 0.11375898f, 0.47105110f, -0.10134047f, -0.15322816f, 
    -0.17870864f, 0.13471769f, 0.07952886f, 0.20295633f, -0.32125431f, -0.30171275f, -0.22691457f, 0.13623847f, 
    0.14599192f, 0.06610539f, 0.11617062f, 0.05498722f, 0.03307148f, 0.11813082f, -0.01071472f, 0.05817628f, 
    -0.13662000f, -0.15622818f, -0.00290880f, -0.01699417f, -0.10270926f, -0.03117988f, -0.15009736f, 0.07360532f, 
    0.14572732f, -0.06173804f, 0.27069196f, 0.14570312f, 0.18528333f, 0.04972137f, -0.38001099f, 0.08269703f, 
    0.03708683f, -0.05954913f, -0.17446779f, -0.31399360f, -0.25576434f, 0.07869308f, 0.44914514f, -0.10123884f, 
    0.12850888f, -0.15948020f, 0.25007817f, -0.31280404f, -0.11089865f, -0.07076922f, -0.15935124f, -0.05015791f, 
    -0.02266929f, 0.09589444f, -0.04092566f, 0.07485984f, -0.05381862f, 0.08373346f, -0.11884824f, 0.11106557f, 
    0.13914348f, 0.01886806f, -0.18647815f, -0.08703230f, -0.09644448f, 0.12477297f, -0.03397238f, 0.01643016f, 
    -0.07203832f, -0.05449700f, -0.12277247f, 0.01506246f, 0.12105994f, -0.08024547f, -0.11495146f, 0.03706934f, 
    -0.13331696f, -0.12260640f, -0.01098190f, -0.15928622f, 0.13350081f, -0.01036407f, 0.01853730f, 0.05310415f, 
    -0.08681518f, -0.14542130f, 0.01760655f, 0.12113594f, 0.13222988f, -0.06629164f, 0.13126245f, -0.16915861f, 
    0.15995172f, 0.11405671f, -0.15101749f, 0.05737205f, 0.02086193f, 0.06148312f, -0.10336967f, 0.11811747f, 
    -0.02631076f, 0.10994776f, 0.05186878f, -0.00137680f, 0.06272290f, -0.16124196f, -0.15430060f, -0.08289520f, 
    -0.13884988f, 0.06135186f, -0.13419290f, 0.03601953f, -0.12042440f, -0.03044414f, 0.03048163f, 0.15301268f, 
    -0.15163498f, -0.10591766f, -0.04924693f, -0.08051156f, -0.06212467f, 0.11689976f, 0.08021061f, 0.04441274f, 
    0.16151594f, 0.19122174f, -0.17931655f, 0.06971760f, 0.29467431f, 0.22424696f, -0.04720563f, 0.04984434f, 
    0.29181579f, 0.08017500f, 0.17019236f, 0.08510706f, 0.42129767f, -0.20583458f, 0.00242253f, -0.07476853f, 
    0.03639300f, 0.08979099f, 0.03026162f, 0.28125364f, 0.20621562f, -0.50407624f, 0.00140568f, -0.08288254f, 
    -0.11213025f, -0.09948439f, -0.09730051f, -0.00211925f, 0.17479202f, 0.05791495f, -0.15475158f, -0.11537308f, 
    -0.05895915f, -0.19959563f, 0.14615735f, 0.18170929f, 0.04890958f, 0.35605675f, 0.08045920f, -0.09622434f, 
    0.22419097f, -0.05856478f, -0.06168750f, -0.19723427f, -0.32667956f, 0.03168402f, 0.30208585f, 0.13090217f, 
    0.06022326f, -0.05383089f, 0.13410462f, -0.25777790f, -0.07821719f, 0.31875780f, 0.11966942f, -0.09918413f, 
    -0.06113100f, -0.01216703f, -0.12262860f, -0.27531704f, 0.12739943f, 0.06393471f, 0.14203085f, -0.03700574f, 
    -0.03919490f, -0.05885597f, -0.15462770f, -0.05934232f, -0.00065159f, -0.06439198f, 0.03425995f, -0.09957346f, 
    -0.07815863f, -0.11693344f, -0.14104274f, 0.09446009f, 0.00212329f, -0.12092643f, -0.10850459f, 0.02241083f, 
    -0.02932352f, -0.01839935f, 0.00424219f, -0.17167638f, -0.17663151f, -0.02626952f, 0.03998528f, -0.10117189f, 
    -0.06705749f, 0.05727280f, -0.06385947f, -0.11915599f, 0.04587408f, 0.11095046f, 0.12159736f, -0.02306200f, 
    -0.07511161f, -0.11506867f, -0.15161890f, -0.07831389f, -0.02185981f, -0.12935708f, -0.12771311f, -0.13145967f, 
    -0.03223258f, -0.00089432f, 0.06459126f, 0.30515337f, 0.48767966f, -0.06507102f, -0.36453959f, 0.17879348f, 
    0.09799301f, 0.03335545f, 0.37060669f, 0.19058487f, 0.15634203f, 0.07853274f, -0.15786079f, 0.07282253f, 
    -0.11260780f, -0.11200365f, 0.07901228f, 0.18863031f, -0.12243770f, -0.06407749f, -0.02950718f, 0.20911087f, 
    0.16348924f, 0.25447294f, 0.19513249f, -0.12427124f, 0.16349995f, 0.27788609f, 0.56111884f, 0.10910083f, 
    -0.05530572f, 0.14714064f, 0.06685149f, -0.02392847f, -0.31044647f, -0.27181411f, 0.28447863f, -0.07206539f, 
    -0.09810403f, 0.06978087f, -0.26385400f, -0.24981387f, 0.24706604f, -0.25233203f, -0.09554105f, 0.03254914f, 
    -0.16277526f, 0.00621649f, -0.14501397f, -0.03273831f, 0.04569471f, -0.06309313f, -0.03237650f, 0.08307938f, 
    -0.01763541f, 0.01530317f, -0.07192045f, -0.03811832f, 0.18919192f, 0.14780323f, 0.50676978f, 0.10770044f, 
    -0.11715727f, -0.15437672f, 0.11377219f, 0.18758200f, -0.60045266f, -0.42687109f, 0.00194422f, 0.26830047f, 
    -0.00819621f, -0.08110236f, -0.08170944f, -0.13067724f, 0.33399794f, -0.34275943f, 0.05718289f, -0.16747078f, 
    0.10384922f, 0.01589705f, 0.00418742f, 0.32908082f, 0.16500783f, -0.14248322f, 0.10068062f, 0.45944712f, 
    0.03845451f, -0.28124112f, 0.26364857f, 0.04377676f, -0.09447033f, -0.08609721f, -0.32915777f, 0.12818913f, 
    0.09437764f, 0.12288813f, -0.10771655f, -0.15263370f, -0.15970798f, 0.32407477f, -0.46052724f, 0.04027607f, 
    -0.15168591f, -0.10343497f, 0.07351784f, 0.21226977f, -0.16659074f, 0.04451966f, 0.03659421f, -0.11948020f, 
    0.01871232f, -0.00550361f, 0.00678379f, 0.15286644f, -0.04477348f, -0.07390578f, -0.16105849f, 0.09831274f, 
    -0.02903899f, 0.13240413f, -0.01961075f, -0.00772365f, 0.38701677f, 0.33388877f, 0.06569073f, 0.10420587f, 
    -0.25206000f, 0.12149561f, -0.06280763f, 0.11780927f, 0.02668140f, 0.13901441f, -0.19069877f, 0.06403843f, 
    -0.13824062f, 0.14146014f, -0.01331083f, 0.31559786f, 0.22309716f, -0.26781002f, 0.10819814f, 0.08467719f, 
    0.16598049f, 0.00318864f, -0.12205143f, -0.11283103f, 0.15320760f, -0.06790711f, -0.15169793f, -0.15473606f, 
    0.03985300f, 0.22936678f, 0.09533741f, -0.12068106f, 0.27157456f, 0.30869082f, 0.42949104f, 0.06853766f, 
    0.10342428f, -0.09390379f, -0.05215296f, -0.28577343f, 0.25546116f, -0.06095292f, 0.34905237f, 0.09952647f, 
    0.07549156f, -0.10888797f, -0.06346206f, -0.38634640f, 0.06411009f, -0.26170897f, -0.17378938f, 0.07547012f, 
    0.08097920f, 0.13261995f, -0.10157149f, 0.09485590f, 0.02499700f, 0.03014334f, -0.00768971f, -0.23786183f, 
    0.13111794f, -0.11960957f, -0.09483737f, 0.03757945f, 0.10809918f, -0.16679700f, -0.04119157f, 0.03737416f, 
    -0.11989462f, 0.07708758f, 0.01313695f, 0.11791953f, 0.03138737f, -0.03713574f, 0.00564511f, 0.13648719f, 
    0.11923498f, 0.10172053f, -0.06190411f, -0.06383465f, -0.02915042f, -0.11443792f, 0.00692264f, 0.11195373f, 
    -0.17879088f, -0.17938496f, -0.00660515f, -0.07984207f, -0.09150772f, -0.14169811f, 0.01167384f, -0.18226171f, 
    -0.04329901f, 0.00134838f, 0.16384591f, 0.27176884f, -0.26312920f, -0.13020021f, -0.26993701f, 0.16779564f, 
    0.22305787f, 0.16385220f, -0.08767701f, 0.32228088f, -0.13021892f, -0.01761483f, -0.19223246f, 0.15107392f, 
    0.12170075f, 0.16306335f, -0.09649736f, 0.27514622f, -0.32375592f, 0.32277051f, -0.07439802f, -0.07961075f, 
    0.09262329f, 0.14303657f, -0.09711626f, 0.02793223f, -0.11711848f, -0.06143959f, -0.15294991f, 0.02140263f, 
    0.03687732f, -0.13054161f, 0.07360965f, 0.31084687f, 0.36025119f, -0.00398533f, -0.23131910f, 0.07740500f, 
    0.14293048f, 0.02965127f, 0.07741444f, -0.34440559f, -0.31095177f, 0.35417816f, 0.21833864f, -0.03789279f, 
    0.09546594f, -0.05386891f, -0.22705103f, 0.05039197f, -0.23877625f, 0.40924147f, -0.14242192f, 0.11446091f, 
    -0.15007040f, -0.03559468f, 0.00189117f, -0.14580686f, -0.08876797f, -0.03024645f, -0.11162917f, 0.09389310f, 
    -0.15430376f, -0.20824160f, -0.09392104f, 0.42352295f, -0.13314743f, 0.17645068f, -0.09566507f, 0.16465093f, 
    -0.05700276f, -0.08810276f, 0.12243887f, 0.10353142f, -0.08206201f, 0.25583130f, 0.00199571f, 0.38113090f, 
    0.08064736f, 0.15180703f, -0.07072397f, 0.04081500f, -0.33464074f, 0.38158396f, -0.03971544f, -0.12501349f, 
    -0.03870052f, -0.08802814f, -0.16675329f, -0.17980891f, -0.02171890f, -0.17011073f, -0.08221303f, -0.07842217f, 
    0.04200627f, 0.23215814f, 0.14365502f, -0.13977854f, -0.16658656f, 0.21919711f, 0.63390845f, -0.08609551f, 
    -0.12252761f, 0.03095033f, -0.13732499f, 0.29608065f, 0.06389632f, -0.24234042f, -0.00404896f, 0.11559330f, 
    -0.16302998f, 0.00701624f, -0.29584107f, 0.06525343f, 0.23180829f, 0.03518037f, -0.12507766f, -0.03469924f, 
    -0.07181157f, -0.15722500f, -0.01971460f, -0.09208544f, 0.01303009f, -0.15595111f, -0.03593521f, 0.03694597f, 
    0.11112048f, -0.13396803f, -0.17874096f, -0.04179488f, -0.00329552f, -0.04873984f, -0.03407394f, 0.12518141f, 
    0.09193753f, 0.08319796f, 0.04484035f, -0.03587140f, 0.04054245f, -0.08272883f, 0.09839700f, 0.15352261f, 
    0.01685332f, 0.12385711f, -0.12882824f, 0.09990641f, -0.16355179f, 0.07236106f, -0.15494236f, -0.11210005f, 
    0.13664785f, -0.15101220f, 0.12200623f, -0.04424171f, 0.04327194f, -0.07395090f, -0.08642369f, -0.13746376f, 
    0.02067008f, -0.10027934f, 0.00549016f, 0.05899289f, -0.30112109f, -0.25682268f, 0.32381415f, 0.08797833f, 
    0.27257568f, 0.05825963f, -0.00310715f, 0.08756079f, 0.64581639f, 0.20968691f, 0.30090088f, 0.03816145f, 
    -0.05054666f, 0.11443671f, 0.32551086f, 0.10223113f, -0.22921459f, 0.34251565f, 0.09762391f, 0.12745486f, 
    0.03511016f, -0.10703965f, -0.04829049f, -0.09489578f, -0.13998950f, -0.07355320f, -0.12611279f, 0.00369273f, 
    0.04784542f, 0.24719879f, -0.02130894f, 0.08288077f, 0.40374532f, 0.09468002f, 0.20130609f, 0.05112544f, 
    -0.11033074f, 0.04502863f, 0.15036885f, -0.30199963f, -0.25825593f, 0.06577326f, -0.08831190f, -0.00984661f, 
    -0.00995887f, -0.12028197f, -0.17638895f, 0.18099454f, 0.05779791f, 0.12399355f, -0.04872580f, 0.18471691f, 
    -0.15472184f, 0.06222234f, 0.10312004f, -0.20598647f, -0.15115345f, -0.13796213f, 0.05495272f, 0.04444776f, 
    -0.04342251f, 0.31291208f, 0.00014771f, -0.25169855f, 0.05755392f, 0.13104403f, -0.33603162f, 0.15371664f, 
    0.24588133f, 0.13896833f, -0.15731719f, 0.37987545f, -0.11247099f, 0.14895187f, 0.17556588f, -0.10963807f, 
    0.13783433f, -0.01606547f, -0.18654065f, -0.00274731f, 0.16025285f, 0.03024834f, 0.01871400f, -0.07658624f, 
    -0.03144943f, 0.03504666f, -0.10795991f, 0.24853510f, 0.06193705f, -0.09672404f, -0.14361456f, 0.03557071f, 
    -0.12096170f, -0.01493168f, -0.25772858f, 0.14818066f, -0.17013314f, -0.08211844f, -0.24225585f, 0.16200456f, 
    -0.15272418f, 0.15836859f, 0.17315383f, 0.32817087f, 0.11489609f, -0.06351866f, 0.54389954f, 0.11430638f, 
    -0.15024659f, 0.10901775f, 0.12804842f, -0.00089669f, -0.19337052f, 0.28460944f, 0.07287405f, 0.06574882f, 
    -0.16118571f, 0.13907161f, -0.01772811f, 0.35120824f, -0.02132035f, -0.02736970f, 0.16540365f, 0.02346655f, 
    -0.17612651f, 0.00113849f, 0.36472625f, -0.20580989f, -0.09722378f, -0.39551735f, -0.33009681f, 0.08251984f, 
    0.26104882f, 0.06660233f, 0.06049602f, -0.07663262f, 0.05775860f, 0.41781539f, 0.33339286f, -0.24634080f, 
    -0.17571487f, -0.08894505f, 0.06255472f, -0.08097158f, -0.17453931f, 0.23874259f, 0.11059950f, -0.06728439f, 
    0.02938516f, -0.02479779f, -0.02101682f, 0.09066935f, -0.16046400f, 0.05253139f, -0.17186944f, -0.00606990f, 
    0.16552475f, -0.14815061f, -0.07038172f, -0.18795212f, 0.15324679f, -0.18089069f, 0.03751412f, -0.14980090f, 
    0.00245930f, -0.04514265f, -0.02438403f, 0.02667343f, 0.09873079f, 0.11050160f, -0.09014854f, -0.12501757f, 
    0.15028393f, -0.00672942f, -0.03205119f, -0.05934804f, -0.03516549f, -0.05894309f, -0.17602402f, -0.13822022f, 
    -0.10097059f, 0.07239047f, 0.04659378f, -0.08321162f, -0.04245537f, -0.00899589f, -0.02343543f, -0.15815520f, 
    -0.14543925f, 0.13516206f, 0.25940222f, -0.23812655f, 0.23628844f, -0.26258573f, 0.22980869f, -0.13913406f, 
    -0.09820637f, -0.05979570f, -0.06850027f, 0.06443431f, -0.37611496f, -0.12357178f, 0.22560492f, -0.18966544f, 
    -0.00484668f, 0.06707384f, 0.16091184f, 0.15979970f, 0.01492063f, 0.13884307f, -0.14938311f, 0.06244649f, 
    0.01330441f, 0.12652619f, 0.02630005f, -0.03513074f, -0.10188887f, 0.16650672f, -0.12348136f, -0.13472147f, 
    0.00328275f, 0.00608292f, 0.00876584f, 0.04242631f, -0.18236656f, 0.27050179f, 0.50638062f, -0.04739685f, 
    -0.08600691f, -0.07484844f, -0.10731702f, 0.05661067f, -0.07621799f, 0.14749002f, 0.08951066f, 0.46454078f, 
    0.11001148f, 0.04040494f, 0.31595963f, -0.22749761f, 0.08935851f, -0.04424316f, 0.02188417f, -0.11763264f, 
    0.00223860f, -0.11320890f, -0.14270797f, -0.15795283f, 0.03373035f, 0.06173708f, -0.05920988f, -0.28139767f, 
    0.15164059f, 0.29199696f, 0.30528277f, -0.10170472f, 0.31477004f, -0.04281355f, 0.24310710f, 0.03286185f, 
    -0.07960058f, -0.03291541f, 0.09553804f, -0.30737221f, -0.51515007f, 0.08971737f, 0.23932892f, -0.25339505f, 
    -0.06994192f, -0.02588174f, -0.33827943f, 0.27371836f, 0.07753483f, 0.00794939f, -0.10300078f, 0.03763280f, 
    0.13098738f, 0.15883069f, 0.12216059f, 0.10934713f, 0.12247466f, 0.01037539f, 0.04297248f, -0.18969885f, 
    0.14962637f, -0.25172204f, -0.14625123f, 0.22316556f, 0.00889422f, 0.36265227f, -0.13661958f, -0.04569886f, 
    0.01892765f, -0.16954449f, -0.16959706f, 0.02149208f, -0.32819113f, 0.18233916f, -0.27566260f, 0.30385685f, 
    -0.04300442f, -0.05567698f, -0.28353164f, 0.05256326f, 0.21832222f, 0.10774449f, 0.11793686f, -0.01692037f, 
    -0.06231216f, -0.15374337f, -0.02750064f, 0.13640854f, -0.03356630f, 0.14851347f, -0.15255745f, 0.36006266f, 
    0.11562049f, 0.10283685f, 0.19634494f, -0.40160641f, 0.26426691f, -0.15763871f, 0.17467219f, 0.15303074f, 
    0.30385804f, 0.02007290f, 0.04225311f, -0.16308373f, -0.37311497f, -0.21966982f, 0.24376589f, -0.01114479f, 
    0.00795291f, 0.13578175f, 0.11342727f, -0.37477115f, 0.31769559f, -0.00850719f, 0.08497303f, 0.05637252f, 
    -0.12937199f, -0.13970077f, 0.10511442f, 0.05250369f, 0.15788947f, -0.04340882f, -0.15540478f, 0.28484362f, 
    -0.02420881f, -0.14729430f, -0.03161952f, -0.16067375f, -0.08406122f, -0.12392059f, -0.13073575f, 0.13531762f, 
    -0.04845353f, 0.11558016f, -0.07477504f, 0.00530958f, -0.17016871f, 0.10613207f, 0.06947023f, -0.11960128f, 
    0.07234894f, -0.15376471f, -0.17409493f, -0.06122433f, 0.06451313f, 0.06301507f, -0.03546099f, 0.02056931f, 
    -0.08582573f, -0.02364624f, 0.07562856f, -0.04623616f, -0.11186275f, -0.14473194f, -0.09290598f, -0.03820458f, 
    0.01543349f, -0.25032020f, -0.21049444f, 0.18487240f, -0.14664318f, 0.28369480f, -0.33579075f, 0.02260999f, 
    0.03340324f, 0.10296197f, -0.11048257f, 0.13535352f, 0.34953943f, 0.00275182f, 0.41214365f, -0.02878959f, 
    0.08910683f, 0.08920170f, 0.39317462f, -0.07449612f, 0.03320895f, 0.10513896f, -0.05817445f, 0.03289883f, 
    -0.10000286f, -0.03189953f, 0.10126111f, -0.04795942f, -0.13246119f, 0.01791584f, -0.06912326f, -0.11027981f, 
    -0.02287248f, -0.06729096f, 0.24597853f, 0.05917096f, -0.01143006f, 0.05553137f, -0.16757092f, 0.02800306f, 
    -0.04156542f, -0.11932091f, -0.16848737f, -0.05887823f, 0.28582078f, -0.12488580f, -0.17179810f, -0.44368589f, 
    0.08522367f, 0.04199649f, 0.24656035f, 0.36252356f, 0.22197925f, -0.26380998f, 0.00247670f, -0.06558334f, 
    0.08938586f, 0.01004962f, 0.16237178f, 0.02079455f, 0.01056286f, -0.02415573f, -0.05939380f, -0.17343201f, 
    0.08245260f, -0.27788568f, 0.05316659f, 0.39479351f, -0.14981671f, -0.04862281f, 0.33189270f, 0.01098955f, 
    -0.07664369f, 0.02561845f, 0.02353729f, -0.10500771f, -0.20811145f, -0.24544038f, -0.10731980f, 0.08870114f, 
    -0.02904477f, -0.18351080f, 0.23965730f, 0.11576577f, -0.03719618f, 0.18964876f, 0.05440823f, 0.06754274f, 
    0.04075177f, 0.05446058f, -0.03281856f, 0.10402788f, 0.15972625f, 0.14891101f, 0.01365195f, 0.28616872f, 
    -0.14371948f, -0.07935911f, -0.14802036f, -0.18909399f, -0.11092945f, -0.17564945f, -0.06555130f, -0.07893649f, 
    0.14953656f, 0.16904460f, -0.03085628f, -0.01502580f, 0.06521045f, -0.15354753f, 0.11675879f, -0.01860840f, 
    -0.08778818f, -0.06907047f, -0.01483867f, -0.05932918f, 0.03975714f, 0.12561680f, -0.17735663f, 0.12088222f, 
    0.04115626f, 0.15874580f, 0.02613602f, -0.08534150f, 0.08415503f, -0.10956490f, 0.13089059f, 0.04569909f, 
    -0.06498839f, 0.30677029f, -0.08126019f, 0.13056695f, 0.11273096f, -0.04957982f, 0.16584867f, 0.15991630f, 
    -0.05115417f, 0.16325471f, 0.16525488f, -0.32750475f, -0.04513286f, 0.10724084f, 0.05365943f, 0.06597015f, 
    -0.06973319f, -0.08557776f, -0.20937455f, 0.11087790f, -0.12772915f, 0.29943082f, -0.01979078f, 0.10355989f, 
    -0.08891018f, 0.14751863f, 0.01834716f, 0.05716469f, 0.06576638f, -0.08181152f, 0.13925907f, -0.08211641f, 
    0.06937981f, 0.10737035f, -0.03175649f, 0.04335931f, 0.24596886f, -0.11764682f, 0.04251064f, -0.15854484f, 
    0.18085159f, 0.08780633f, 0.05860430f, -0.48584616f, 0.29515034f, -0.27339536f, 0.08067345f, 0.20607349f, 
    -0.10994086f, 0.15727977f, -0.27617589f, -0.17676564f, -0.07545542f, -0.22297792f, 0.15210146f, 0.00125792f, 
    0.07349229f, 0.08295102f, 0.08747006f, 0.05114373f, 0.11422107f, 0.04960255f, -0.02090345f, 0.15477426f, 
    0.12904873f, 0.08199555f, 0.05734470f, -0.10011929f, 0.02446687f, 0.07712374f, 0.10869851f, 0.09267734f, 
    -0.08136350f, -0.02791807f, 0.14472604f, -0.24695934f, -0.32861006f, -0.30258957f, -0.04998244f, 0.23036051f, 
    0.15113534f, 0.15644801f, -0.33389711f, 0.12054008f, 0.12316020f, -0.16305186f, -0.11398322f, 0.02737219f, 
    -0.11508626f, -0.04936491f, 0.08605939f, 0.37839323f, -0.08440830f, 0.06188668f, -0.17030028f, 0.28229627f, 
    -0.11233203f, 0.07747005f, -0.17381054f, 0.38859889f, -0.16011979f, 0.09228051f, -0.29105097f, 0.14120930f, 
    -0.12119743f, -0.01236422f, 0.13382292f, 0.18905036f, 0.09281916f, 0.09030270f, 0.33795235f, 0.13289955f, 
    0.01434632f, 0.09600209f, -0.06956240f, -0.24225388f, -0.21598749f, 0.10570971f, 0.10835647f, 0.00912437f, 
    -0.00542245f, 0.12231310f, 0.11782301f, 0.15868199f, -0.15221103f, 0.06836823f, -0.13527298f, 0.27290168f, 
    0.14557686f, -0.03067602f, 0.29161769f, -0.21237993f, 0.23174791f, -0.45105621f, -0.10231995f, -0.10415138f, 
    0.17176111f, -0.06940325f, 0.02295254f, -0.04370720f, -0.26017430f, 0.28791201f, 0.35500145f, -0.25294027f, 
    0.07807026f, -0.15192965f, 0.11132692f, 0.05074704f, -0.19118804f, 0.15044664f, -0.12587345f, -0.04532019f, 
    -0.10956495f, -0.13646047f, 0.15550590f, -0.17453706f, 0.15647952f, -0.16842957f, 0.11643668f, 0.20317417f, 
    0.06600801f, -0.22701487f, -0.04379112f, 0.14909862f, -0.08313966f, 0.02989391f, -0.02184402f, 0.13676588f, 
    -0.07305483f, 0.15718597f, -0.06993324f, -0.05502459f, 0.03218336f, -0.16110748f, -0.15586671f, 0.05706304f, 
    -0.02739914f, 0.02607465f, -0.14463286f, -0.04820620f, 0.25239438f, 0.07658387f, 0.15587316f, -0.13993266f, 
    -0.06361582f, -0.15172541f, -0.15228017f, -0.18738608f, -0.09924862f, -0.04008987f, -0.12091079f, 0.05277492f, 
    -0.02530370f, 0.10849481f, 0.21320190f, -0.40595379f, 0.01785714f, -0.23344481f, -0.03851840f, 0.05267612f, 
    0.04493403f, 0.11574467f, -0.03994253f, -0.13517748f, -0.17427380f, 0.28932863f, 0.23213212f, -0.20834148f, 
    -0.07357784f, 0.04135434f, -0.18954431f, 0.26121247f, 0.16157022f, -0.13003108f, -0.04372285f, 0.17663914f, 
    0.05846767f, 0.16365319f, -0.17225049f, 0.14107431f, 0.04631610f, -0.09028632f, -0.14079539f, 0.30993485f, 
    -0.02368708f, 0.16805832f, -0.05339975f, -0.14746472f, -0.11506500f, 0.11697802f, -0.14247872f, -0.13247100f, 
    -0.06594905f, 0.07197356f, 0.05029086f, -0.05393314f, -0.04891568f, 0.06230703f, -0.09352873f, -0.12361676f, 
    -0.04706711f, -0.16405787f, -0.07331396f, 0.01514843f, -0.07333622f, -0.11538663f, 0.00422609f, 0.11695264f, 
    0.04689617f, -0.10086653f, -0.16087323f, 0.08726948f, 0.15095960f, 0.02882684f, 0.13104209f, -0.06242710f, 
    -0.05929153f, 0.50604457f, -0.10277683f, 0.31613693f, -0.11654118f, -0.10556382f, -0.17200378f, -0.05524497f, 
    -0.15288976f, -0.11904948f, -0.04762531f, 0.51192349f, -0.10392657f, -0.20372863f, 0.09968070f, 0.09092643f, 
    0.13876107f, -0.16436063f, -0.14676198f, 0.35681203f, -0.09601775f, 0.09046064f, -0.00609300f, 0.00102577f, 
    -0.00797026f, 0.07326385f, -0.10751417f, 0.33907080f, 0.15036975f, -0.04866041f, -0.05324173f, -0.03645299f, 
    -0.07085551f, -0.00062664f, 0.23157872f, 0.03509458f, 0.01551964f, -0.34192806f, 0.13648203f, -0.04021219f, 
    0.34571218f, -0.04644850f, -0.07855118f, -0.29783171f, 0.45202854f, 0.11074702f, 0.29181010f, -0.18207945f, 
    -0.02859393f, -0.15614289f, 0.41085535f, -0.39367381f, 0.06390760f, 0.21280408f, -0.13385072f, 0.00296107f, 
    -0.03131410f, 0.08628360f, 0.04865599f, -0.05558305f, -0.14709757f, 0.03970241f, -0.02998091f, -0.18307824f, 
    -0.14184782f, -0.17036606f, 0.21610166f, 0.30079994f, 0.28729579f, 0.07185974f, 0.29666403f, -0.07067643f, 
    -0.20333977f, -0.13462126f, 0.13775687f, -0.47071603f, -0.36473304f, 0.13082157f, 0.09765207f, 0.20316079f, 
    -0.10526156f, -0.03458400f, 0.05672998f, -0.07152382f, -0.26577377f, 0.12504013f, -0.08022384f, 0.06861320f, 
    0.00904166f, 0.02048411f, -0.03809977f, 0.19366625f, -0.17057192f, -0.04166493f, -0.01252586f, 0.06748945f, 
    0.03015815f, 0.01960639f, 0.17001387f, 0.03338261f, 0.17638485f, -0.24753621f, 0.49845511f, 0.07456122f, 
    -0.08346793f, -0.10855126f, 0.13848296f, -0.03398709f, 0.22238368f, -0.01905900f, -0.08582298f, -0.42376971f, 
    0.09496091f, -0.16938405f, 0.00667569f, 0.31655666f, -0.15801220f, 0.28746435f, 0.02492823f, 0.15341672f, 
    -0.13046750f, 0.12904701f, 0.02882662f, 0.08064380f, -0.00064199f, 0.15576766f, -0.13191062f, -0.00886151f, 
    -0.03426204f, 0.16910683f, -0.20249005f, -0.04078839f, 0.10994084f, -0.28331754f, 0.10536008f, 0.09975103f, 
    -0.22379240f, -0.12661861f, 0.14805382f, -0.05986831f, 0.00173827f, 0.03067519f, 0.11779805f, 0.07626068f, 
    0.03014646f, 0.11708137f, -0.11737362f, 0.31908399f, -0.08583810f, 0.11901629f, 0.15909900f, -0.17264791f, 
    0.05838339f, -0.17280360f, 0.06405316f, 0.26057687f, -0.11259861f, 0.11126962f, -0.05551208f, 0.36301824f, 
    0.02070552f, -0.11573119f, -0.13379557f, 0.14523797f, -0.17568302f, 0.05859724f, 0.35534734f, 0.11935022f, 
    -0.12243703f, -0.02489365f, -0.01932800f, 0.25554052f, -0.11269007f, 0.10660176f, -0.01820693f, 0.49588317f, 
    -0.11326195f, 0.04641657f, 0.09170716f, 0.26508048f, 0.21808974f, -0.29145855f, -0.16721793f, 0.15051748f, 
    0.07434262f, 0.14508753f, 0.05849169f, 0.31053883f, -0.01927765f, 0.05514856f, -0.07022201f, 0.22452034f, 
    0.07435218f, 0.09204502f, 0.28457773f, -0.43424377f, 0.22374779f, -0.00358034f, -0.15044998f, 0.11824834f, 
    0.22678770f, -0.12626745f, -0.03243532f, 0.18610197f, 0.00611201f, 0.17447755f, 0.28874651f, -0.30228233f, 
    0.06156493f, -0.00134924f, 0.15838794f, 0.00035917f, 0.10100989f, -0.18565714f, 0.09583009f, -0.13608365f, 
    0.13153376f, -0.08546814f, -0.14079238f, -0.14507779f, 0.13566734f, 0.16061036f, -0.00726050f, -0.01907224f, 
    0.10971450f, 0.05175667f, -0.02163166f, -0.07753844f, 0.22614101f, 0.25107628f, 0.26153868f, 0.02852309f, 
    0.08903929f, 0.01927289f, 0.09150838f, 0.21974401f, -0.12374341f, 0.22835644f, -0.41472635f, 0.21311405f, 
    -0.05904923f, 0.08659386f, -0.35310215f, 0.29142529f, 0.22805506f, -0.14710124f, 0.15667799f, 0.03546560f, 
    -0.04604149f, -0.02720747f, 0.05126798f, 0.07448906f, -0.10389177f, -0.03541553f, 0.09174878f, 0.24927652f, 
    -0.11796107f, 0.31854185f, 0.21101531f, 0.10622486f, -0.08743898f, 0.05902646f, 0.03084008f, 0.14887598f, 
    0.37120458f, 0.02520011f, -0.07512464f, 0.17968032f, 0.14135617f, -0.49388409f, 0.03632757f, -0.19971491f, 
    -0.16221881f, -0.15851361f, -0.00964371f, -0.19036153f, 0.34334266f, -0.12607659f, -0.04867501f, 0.06628299f, 
    0.05118318f, -0.05047340f, 0.00822259f, -0.06047545f, -0.06961375f, -0.01048327f, 0.02757485f, 0.17541502f, 
    -0.10773817f, -0.15716973f, 0.09411819f, 0.38408563f, -0.00334728f, 0.00955452f, 0.08807639f, 0.09476236f, 
    0.26647609f, -0.02747321f, 0.12463722f, -0.30797014f, -0.32902840f, -0.24039075f, 0.60812426f, -0.09917510f, 
    -0.05621877f, -0.11339253f, -0.22391967f, -0.20436899f, -0.08809509f, 0.27956209f, 0.04248973f, -0.17002593f, 
    0.14489140f, -0.07863259f, -0.04713029f, 0.18365255f, -0.10866478f, 0.03902151f, 0.08556469f, 0.13679677f, 
    -0.10317126f, -0.00992432f, 0.11803778f, 0.11993200f, -0.29680145f, -0.22127116f, -0.10785445f, -0.05174809f, 
    0.01140950f, 0.13167879f, 0.06158113f, 0.18394850f, 0.32550827f, -0.07435690f, -0.03320356f, -0.09678068f, 
    0.03745259f, 0.02096599f, 0.33584261f, 0.11102740f, -0.16652572f, 0.06600480f, 0.17394198f, -0.16569079f, 
    -0.00206100f, 0.00918582f, 0.15294056f, 0.17423709f, 0.00033922f, 0.06302825f, 0.12101417f, 0.21103418f, 
    0.11143869f, -0.08845118f, 0.20236352f, -0.03276760f, 0.37605104f, 0.21256779f, -0.12117355f, 0.15749769f, 
    -0.12191951f, -0.03403615f, -0.00028683f, -0.00405211f, -0.34494486f, -0.35533884f, -0.30755278f, 0.03710863f, 
    0.07747316f, 0.03814254f, -0.06551760f, -0.00514032f, 0.12823106f, -0.39256811f, 0.12839036f, -0.02627268f, 
    0.03785048f, -0.13230886f, 0.03681847f, -0.23229401f, 0.08353320f, -0.15204231f, -0.06210985f, 0.13861941f, 
    0.01980141f, -0.16741218f, 0.13318749f, -0.08298800f, -0.30506939f, -0.15199159f, 0.13971610f, 0.08574007f, 
    -0.02389199f, -0.04829763f, 0.16735001f, 0.00150369f, 0.03468288f, -0.20096746f, -0.36463794f, 0.34933451f, 
    -0.15517275f, 0.04130482f, -0.17631355f, -0.17058720f, 0.18076777f, -0.16236158f, -0.16836713f, -0.11544608f, 
    -0.08528301f, 0.16114923f, 0.01026737f, 0.20749639f, -0.03721800f, 0.04493859f, -0.06942764f, 0.30739868f, 
    -0.16786048f, 0.12625851f, -0.16552407f, 0.16270806f, -0.11610963f, -0.17015491f, -0.10448571f, 0.01939046f, 
    -0.11713693f, 0.04527324f, 0.01127383f, -0.13124944f, 0.01458489f, 0.05661539f, -0.09794666f, 0.05191834f, 
    0.09293708f, -0.07813347f, -0.11731479f, 0.12053072f, -0.11471512f, -0.19037290f, 0.05801313f, 0.11506324f, 
    0.10663995f, -0.11166082f, 0.11498069f, -0.17443536f, 0.01312664f, -0.10199714f, -0.06969691f, 0.02076154f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19373491f, 0.12684761f, -0.03173568f, 0.26603234f, 0.05687606f, -0.01271561f, -0.07401339f, 0.28653747f, 
    0.05968506f, -0.04503303f, 0.03231496f, -0.01870078f, 0.12654300f, -0.08200499f, 0.10837546f, 0.00030441f, 
    0.13491322f, -0.02877361f, 0.04280075f, 0.03731900f, -0.00333763f, -0.11162540f, -0.18770535f, 0.09715920f, 
    -0.03830354f, -0.02042277f, 0.06179300f, -0.14471182f, -0.22286728f, -0.04258725f, -0.01322617f, -0.10475171f, 
    -0.10535243f, -0.21818392f, -0.03128242f, -0.14518657f, 0.28696135f, -0.05857066f, 0.06766332f, -0.15548152f, 
    -0.03526357f, -0.10551780f, -0.04767337f, 0.10936929f, 0.09881662f, 0.22951120f, 0.06003534f, 0.01091557f, 
    0.06382591f, -0.11000738f, 0.02229003f, 0.16049372f, 0.01197118f, 0.07449321f, 0.18900490f, 0.14753896f, 
    0.11872811f, 0.11203597f, -0.17700443f, 0.14486095f, 0.12863255f, -0.19214009f, -0.10666088f, 0.12029354f, 
    0.11684678f, 0.08299427f, 0.07073481f, 0.06520237f, -0.01289627f, 0.10760234f, -0.04650574f, 0.06906886f, 
    0.15796137f, -0.06537954f, -0.12618126f, -0.33286458f, 0.25869685f, -0.12202958f, -0.19539867f, 0.19406334f, 
    0.10935774f, 0.15159333f, -0.07859412f, 0.09144386f, -0.08954861f, 0.16827734f, 0.05578263f, -0.08408288f, 
    0.01829397f, -0.04943780f, 0.27242720f, -0.09864350f, 0.02925260f, 0.14231203f, 0.16055721f, -0.06247409f, 
    0.23689404f, 0.20762345f, 0.12249692f, 0.19940898f, 0.16014318f, 0.01707057f, 0.13235739f, 0.06514220f, 
    0.02944414f, 0.00388682f, 0.05166763f, 0.16352205f, 0.23955385f, -0.04053393f, 0.25800833f, -0.09196451f, 
    0.23352659f, -0.12082493f, -0.04383815f, 0.07846494f, 0.12859075f, 0.16055776f, -0.13789940f, 0.05144066f, 
    0.23944999f, -0.16559757f, 0.11673114f, 0.32044438f, 0.18911350f, -0.12005520f, 0.05979941f, -0.02438249f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.39236826f, -0.02041442f, -0.20632993f, -0.34416902f, -0.39648855f, -0.30180830f, 0.27769893f, 0.01217060f, 
    0.22360356f, 0.08933874f, -0.01261073f, 0.03341253f, 0.15959403f, -0.13585337f, 0.01470146f, -0.00372619f, 
    0.21670429f, -0.07310882f, -0.16183949f, 0.04231081f, -0.07155983f, 0.27215034f, -0.31401080f, -0.24436933f, 
    0.00531225f, -0.23908341f, 0.14949489f, -0.31660900f, 0.17139629f, 0.17763919f, 0.00318816f, 0.06178221f, 
    -0.31672928f, -0.82091075f, 0.03930000f, 0.18353249f, -0.80851078f, -0.52937996f, 0.31201515f, 0.22007693f, 
    0.05203589f, 0.00114169f, 0.04366443f, 0.34023178f, -0.16561805f, -0.27290711f, 0.09533686f, -0.02654739f, 
    0.37051976f, -0.61658198f, -0.12114029f, 0.13061932f, -0.05968954f, 0.20467539f, -0.10390329f, 0.12019996f, 
    -0.07818761f, -0.02688798f, 0.23653471f, -0.29114151f, 0.05502627f, -0.00956828f, -0.09166515f, -0.41649479f, 
    -0.18415430f, 0.25528359f, 0.13925201f, 0.11715772f, -0.10898872f, -0.00569165f, 0.25592688f, 0.05926525f, 
    0.16632862f, 0.06407750f, -0.03606283f, -0.49335447f, -0.00827264f, -0.04261183f, 0.23440897f, -0.42412370f, 
    -0.05933903f, 0.11263552f, -0.25824472f, -0.16064562f, -0.02345168f, -0.03246265f, -0.17421058f, -0.26330125f, 
    -0.34606478f, 0.03685352f, 0.14004993f, 0.14005883f, -0.20524828f, -0.06270863f, 0.09400105f, 0.02871742f, 
    0.09102158f, -0.04606321f, -0.34527484f, -0.28863987f, 0.02421576f, 0.00440329f, 0.01593435f, 0.27062801f, 
    0.12010351f, -0.03839089f, -0.26518640f, -0.31026772f, -0.57203537f, 0.07907787f, 0.12567143f, -0.04497876f, 
    -0.25199333f, -0.05696226f, -0.11753187f, 0.23591536f, -0.00160234f, 0.05928537f, -0.05860889f, -0.15272616f, 
    0.18733521f, -0.42554927f, 0.06085308f, -0.15959884f, 0.22736418f, -0.00404853f, -0.21817563f, -0.00848202f, 
    -0.02735687f, -0.03726428f, 0.16847235f, -0.07755155f, 0.32640097f, -0.49258056f, -0.05816451f, 0.02041863f, 
    0.14058445f, -0.10076876f, -0.07072718f, -0.04682681f, -0.02185871f, 0.20170647f, 0.12943289f, 0.02277763f, 
    -0.21516110f, 0.05632855f, -0.17087024f, -0.07088302f, -0.30734810f, -0.06706640f, -0.16338448f, 0.17808466f, 
    -0.03537945f, 0.10498709f, -0.25964960f, 0.10889217f, -0.24393995f, 0.06230129f, -0.03742439f, 0.15706240f, 
    0.07344159f, 0.04354832f, 0.06119287f, -0.19151585f, 0.23736946f, -0.17446122f, 0.21962290f, 0.17082641f, 
    0.20036210f, 0.27069262f, -0.01093799f, 0.08483351f, -0.27013409f, 0.06813534f, -0.13919623f, 0.00445020f, 
    -0.00988446f, 0.13943428f, -0.59871447f, -0.41375253f, 0.09058945f, 0.20183012f, -0.02453986f, -0.59289366f, 
    -0.15494800f, 0.23509514f, -0.14297862f, -0.11386025f, -0.07189310f, -0.00473358f, 0.06203217f, -0.27376816f, 
    0.10142050f, -0.25762665f, 0.06747951f, 0.13745672f, 0.06998880f, -0.11347439f, 0.26548848f, 0.17222783f, 
    0.08383414f, 0.01503636f, -0.01156593f, 0.27762708f, 0.06856748f, -0.00890621f, -0.12706842f, -0.48616722f, 
    -0.28654999f, 0.13287961f, 0.02354709f, -0.12178379f, -0.01135741f, 0.20567366f, 0.17876858f, 0.34308022f, 
    -0.21715406f, -0.04006679f, 0.07504905f, -0.12301909f, -0.08668663f, 0.20047058f, -0.02652328f, 0.00619196f, 
    -0.16852105f, -0.07151450f, -0.22089286f, 0.17821224f, -0.34029400f, -0.07696883f, 0.13158052f, 0.16596460f, 
    0.10139448f, -0.05668911f, 0.01046931f, -0.28810513f, -0.21774952f, 0.30772051f, -0.22811696f, -0.06455954f, 
    -0.56595135f, 0.05722309f, 0.01276159f, -0.04189269f, 0.10446507f, -0.02130750f, -0.09720741f, 0.01081011f, 
    -0.64688426f, -0.14504510f, -0.08725335f, 0.31582704f, 0.07420640f, -0.14214821f, -0.34537706f, -0.02790970f, 
    -0.53003418f, -0.06583748f, -0.17597698f, 0.22258170f, 0.14025110f, -0.11424530f, -0.39515388f, 0.08011507f, 
    0.12992884f, -0.40486112f, -0.03789703f, -0.07905202f, 0.23971690f, 0.07415365f, 0.02575221f, 0.14819600f, 
    -0.55544245f, -0.06822050f, 0.13914764f, -0.83698648f, 0.16531757f, 0.17761277f, -0.36732897f, -0.07797037f, 
    0.06672873f, -0.19789070f, -0.04504611f, -0.04013840f, 0.17678232f, -0.19829997f, 0.33194143f, -0.08811221f, 
    -0.29546833f, -0.66320354f, 0.02143134f, -0.18901023f, -0.11290696f, -0.37383968f, 0.10868596f, 0.11842147f, 
    -0.35128328f, -0.11881988f, 0.03482696f, -0.22611806f, -0.03291174f, -0.20744227f, -0.12952620f, 0.16799031f, 
    -0.17389153f, -0.58887947f, -0.87313634f, 0.06807281f, 0.22187638f, 0.11972815f, 0.18270843f, -0.34044078f, 
    -0.42792287f, -0.24437521f, -0.24632940f, -0.14320207f, 0.06754774f, -0.02568643f, 0.18742478f, 0.06293044f, 
    -0.50202811f, -0.31546715f, 0.19443212f, 0.15661947f, -0.46872115f, 0.33556935f, 0.17508537f, -0.02399947f, 
    -0.05039420f, -0.03936845f, 0.02529373f, -0.41033685f, -0.58056521f, -0.07646918f, 0.30412272f, -0.13244037f, 
    0.28181636f, 0.12432487f, -0.22478011f, -0.37914997f, -0.02207820f, -0.01002230f, -0.16516151f, -0.25553381f, 
    -0.15789798f, -0.06518139f, 0.00552888f, -0.05201842f, 0.06484342f, 0.25305563f, -0.02991125f, 0.06863389f, 
    0.04700409f, -0.46280408f, -0.09133271f, 0.11980021f, -0.02088865f, -0.07399519f, -0.31238803f, -0.19900037f, 
    0.16700561f, -0.02476331f, -0.11181913f, 0.32692266f, 0.44220930f, 0.00784760f, -0.01747541f, 0.02741243f, 
    0.30963016f, -0.01260311f, 0.18165669f, -0.25182852f, 0.12424688f, 0.17378677f, 0.48483193f, 0.23273729f, 
    -0.38845894f, 0.04858565f, -0.44541612f, -0.00413197f, 0.17505327f, -0.26983258f, 0.21691415f, -0.05311575f, 
    0.15008497f, -0.02906590f, -0.05356740f, -0.26774153f, 0.20064461f, 0.18871719f, 0.09582558f, -0.03674119f, 
    0.09190237f, -0.32723811f, -0.21779644f, 0.13862586f, -0.28497925f, -0.45863628f, -0.06483371f, -0.47659925f, 
    0.15299819f, -0.07307488f, -0.25372601f, -0.13848241f, 0.23396204f, 0.18774369f, 0.12203138f, -0.29400581f, 
    -0.08836578f, -0.29718825f, 0.19015241f, -0.10074443f, 0.09871095f, 0.01913918f, 0.28825811f, -0.41158509f, 
    0.02175393f, 0.00971847f, 0.05591495f, 0.16199583f, -0.60991520f, -0.14470911f, -0.23558685f, -0.03471401f, 
    0.00567899f, -0.29893181f, 0.05924467f, 0.09362806f, 0.27657217f, -0.28652975f, -0.33200797f, 0.12590143f, 
    0.05043375f, 0.03832202f, 0.13576283f, -0.17863308f, -0.41784334f, -0.58608663f, -0.49288529f, 0.18461609f, 
    -0.08348426f, -0.26655328f, 0.26076436f, -0.14415012f, -0.00268213f, 0.00037661f, -0.39071321f, 0.17140117f, 
    0.11432958f, 0.22420865f, -0.45353854f, -0.18998492f, -0.06602592f, -0.05554408f, -0.34417698f, 0.20680639f, 
    0.22304814f, 0.02836498f, -0.04260002f, 0.12555735f, -0.00217788f, -0.07861777f, -0.36528999f, 0.24944657f, 
    0.23113197f, -0.10365319f, 0.39612967f, 0.19353098f, -0.03599910f, -0.36927134f, 0.08358005f, -0.23465572f, 
    -0.07285649f, 0.06607721f, -0.79364109f, 0.34066480f, 0.14625798f, 0.04090513f, -0.30535105f, -0.02796309f, 
    0.05671282f, -0.04825314f, 0.37135890f, 0.13638531f, 0.12547258f, -0.07575027f, -0.27274626f, 0.14190793f, 
    -0.20931160f, 0.02996284f, -0.12273203f, -0.09497895f, 0.10225896f, 0.04588954f, -0.12311345f, -0.01466878f, 
    0.00709943f, -0.03694157f, 0.00516559f, -0.24016158f, 0.09933206f, -0.30168134f, -0.15206261f, -0.02749031f, 
    0.13889520f, 0.11564696f, -0.00159681f, -0.02995048f, -0.43709046f, 0.39195713f, -0.37824982f, -0.05662117f, 
    0.03697726f, 0.07499781f, -0.10108758f, 0.09745770f, -0.02020947f, 0.07113210f, 0.04244166f, 0.15319850f, 
    -0.05594876f, 0.02036305f, 0.08165486f, 0.14450890f, -0.22678895f, -0.08971875f, -0.36627039f, 0.17293021f, 
    0.17654024f, -0.05504342f, 0.09718257f, -0.01244410f, 0.30837494f, 0.05187939f, -0.10531887f, 0.09264239f, 
    -0.08492343f, -0.32228905f, -0.01423487f, -0.16500750f, 0.05597649f, -0.22099614f, 0.07175232f, -0.12537917f, 
    -0.29450044f, -0.04419728f, -0.06798784f, 0.21096526f, -0.33982983f, -0.75905675f, -0.00163197f, -0.51720816f, 
    -0.32063133f, -0.24859987f, -0.05030802f, -0.26389137f, -0.15600966f, -0.02084879f, 0.04207538f, -0.03467611f, 
    -0.01990609f, -0.14294475f, -0.25488821f, -0.09282599f, -0.32799906f, -0.15553106f, 0.08686332f, 0.16739546f, 
    0.19507703f, -0.10873202f, 0.08294053f, 0.10021582f, -0.04074626f, -0.06992753f, -0.16406167f, 0.21047476f, 
    -0.02954932f, -0.06161760f, -0.23642664f, -0.02930946f, 0.08218005f, -0.16737281f, -0.14266805f, -0.24339594f, 
    0.10422906f, -0.00163317f, 0.01474587f, -0.97914106f, -0.03726251f, -0.05308454f, -0.34284571f, 0.15879455f, 
    -0.18869819f, 0.05559666f, -0.31200197f, -0.04201366f, 0.02019801f, 0.15011364f, 0.04136169f, -0.48811191f, 
    0.08386386f, -0.06314190f, 0.04518134f, -0.02079163f, 0.27022442f, -0.02394786f, 0.28279224f, 0.03104203f, 
    0.23028687f, -0.44590390f, 0.36308810f, -0.20603068f, 0.19046468f, -0.02307149f, -0.57363874f, -0.09060186f, 
    -0.13983524f, 0.01564520f, 0.06598534f, -0.37725216f, -0.09080196f, -0.37708977f, 0.25958645f, -0.07025640f, 
    0.33644751f, -0.04676591f, 0.19769062f, 0.07578715f, -0.09445330f, 0.20542015f, -0.11161984f, -0.19330217f, 
    0.33438301f, -0.11080345f, 0.13210525f, 0.24518932f, 0.05210866f, -0.84255075f, -0.41144240f, 0.01387313f, 
    0.17059693f, 0.03161396f, -0.43453422f, -0.07279306f, -0.11025760f, -0.22972274f, -0.04029773f, 0.20930173f, 
    -0.29183778f, 0.22822884f, 0.01388514f, -0.01975826f, -0.10361789f, -0.09152601f, -0.22423655f, -0.03197648f, 
    0.20011690f, -0.01656077f, -0.00732590f, 0.32926130f, -0.56080967f, -0.22254853f, 0.04553209f, -0.01225446f, 
    -0.07157650f, -0.11031358f, 0.22785312f, 0.03252769f, -0.32245380f, 0.16713913f, -0.47226235f, -0.11793534f, 
    -0.08649676f, 0.23184149f, 0.07759038f, 0.06459130f, 0.46006685f, 0.21411878f, -0.12017684f, -0.25245091f, 
    0.06848507f, 0.11445534f, -0.04540516f, -0.57444376f, 0.04356615f, 0.18542358f, 0.06403548f, -0.45435765f, 
    0.09567305f, 0.23016329f, 0.30642518f, 0.21828043f, -0.03858272f, 0.20464329f, 0.17336534f, -0.16146445f, 
    -0.18143408f, 0.25261265f, 0.01528667f, -0.22420363f, -0.03660494f, -0.03179121f, 0.07234582f, -0.41963589f, 
    0.27419421f, 0.20307671f, 0.02455812f, -0.41412145f, 0.05005423f, -0.33299127f, -0.24469832f, -0.16044368f, 
    0.18265952f, -0.07172454f, -0.02934058f, 0.24815992f, 0.11498985f, -0.02969038f, -0.22825123f, 0.01951635f, 
    -0.04954997f, -0.20271488f, -0.28798226f, 0.24226537f, -0.07152045f, -0.14451604f, -0.10816409f, -0.01660586f, 
    -0.04398434f, 0.03468091f, 0.19805464f, -0.58016616f, 0.03764481f, 0.10482044f, 0.09379234f, 0.04658466f, 
    0.10428794f, 0.33584648f, -0.15132442f, -0.26802549f, 0.12932475f, -0.00255727f, 0.46668762f, -0.37680262f, 
    -0.15136135f, -0.04206483f, -0.30483818f, 0.28283906f, 0.04846827f, -0.04502249f, 0.05631186f, -0.09455477f, 
    -0.15114200f, -0.06458627f, -0.21718195f, 0.19641986f, 0.04824894f, -0.22018383f, -0.37828198f, 0.03556447f, 
    0.10315387f, -0.52089435f, -0.08656696f, 0.16752516f, 0.02254014f, -0.60297436f, 0.25457203f, 0.03864469f, 
    -0.21929684f, -0.07497513f, 0.46587110f, 0.18230939f, -0.44593444f, 0.02366603f, 0.17582883f, -0.06841715f, 
    0.19268711f, 0.17924745f, 0.17465405f, 0.04136437f, -0.17862909f, 0.17709228f, -0.13359565f, 0.04634001f, 
    -0.14050959f, -0.04827800f, -0.29068288f, -0.48001650f, -0.20643061f, -0.08955026f, -0.00842034f, -0.15381961f, 
    0.05624937f, 0.17162937f, -0.20363842f, -0.44897273f, -0.32444015f, 0.22946647f, 0.06503465f, -0.19145137f, 
    0.35992229f, -0.69501173f, 0.05238466f, -0.22893982f, -0.74863839f, 0.39544538f, 0.10418294f, -0.04509440f, 
    -0.00999535f, 0.17107454f, 0.01244486f, 0.51434743f, -0.09023804f, 0.07714771f, 0.09611864f, -0.22173512f, 
    -0.15941124f, -0.24270341f, -0.60823733f, -0.88096112f, 0.05679973f, -0.09782500f, -0.28675851f, 0.09191731f, 
    0.30664495f, -0.01251367f, 0.00483229f, 0.30745411f, -0.00041272f, 0.02585790f, 0.00819763f, 0.06681521f, 
    0.21872094f, 0.11963666f, -0.11890633f, -0.07754701f, -0.14902011f, -0.42199919f, -0.12250809f, -0.01898722f, 
    0.03729725f, -0.07862405f, 0.02291837f, -0.14365785f, 0.25936350f, -0.03855349f, -0.25744367f, -0.12699646f, 
    -0.18868829f, 0.06073111f, -0.14080259f, -0.07004192f, -0.06607585f, 0.02692009f, 0.39352041f, 0.22696492f, 
    -0.04646549f, 0.07991042f, 0.12379853f, 0.21940187f, -0.27460110f, -0.36965576f, 0.11729883f, 0.00626038f, 
    0.10790014f, 0.04865013f, 0.16231246f, 0.12906027f, 0.07411785f, 0.03017257f, -0.57685679f, -0.67926276f, 
    0.12071764f, -0.01381284f, 0.19239879f, -0.05326113f, -0.16438684f, -0.35244089f, 0.25489375f, 0.06095337f, 
    -0.01955510f, -0.04321074f, -0.79303151f, 0.04404711f, 0.18098018f, 0.09568043f, -0.04755202f, -0.13122393f, 
    -0.06824107f, -0.00869477f, -0.36865401f, 0.22288382f, -0.06236259f, 0.41288626f, -0.03423711f, 0.01286581f, 
    0.03121983f, 0.02349950f, -0.19691123f, -0.15520731f, 0.05955867f, 0.07020167f, 0.16258432f, 0.07033949f, 
    -0.09276739f, -0.05424719f, -0.18068881f, 0.09614632f, -0.14143294f, -0.16770497f, -0.27109006f, -0.07223657f, 
    -0.05174154f, 0.04412885f, 0.16627473f, 0.14735240f, 0.11486712f, 0.09497748f, 0.12994324f, -0.09771054f, 
    -0.02544235f, 0.12442476f, -0.05042805f, 0.24716775f, 0.10692120f, -0.39376834f, -0.27936929f, 0.14600144f, 
    -0.03712995f, 0.18821289f, 0.02863785f, 0.19795687f, 0.28122872f, -0.40948790f, -0.17496032f, -0.32739255f, 
    0.00557036f, -0.04379367f, -0.01187760f, -0.23052199f, -0.24300653f, -0.00577481f, 0.10722195f, -0.00695984f, 
    0.04955588f, 0.24196321f, 0.29136643f, 0.16717377f, 0.09832157f, 0.15649839f, 0.11334765f, 0.00854471f, 
    0.12559681f, -0.24531785f, -0.07205046f, -0.46033427f, -0.07895631f, -0.01099410f, 0.13857816f, -0.05417588f, 
    -0.19841939f, -0.27622333f, -0.17717026f, -0.27661219f, 0.11671145f, -0.25401589f, -0.00435922f, -0.27935657f, 
    -0.17144272f, -0.08000141f, 0.08354747f, 0.31395760f, -0.16209894f, -0.08451431f, 0.10402479f, 0.03910693f, 
    -0.18062495f, -0.55505669f, 0.10622861f, 0.19418716f, 0.04359234f, -0.29117766f, -0.16598761f, 0.15334919f, 
    -0.03936658f, -0.10823609f, 0.08928841f, -0.05914997f, 0.09623734f, 0.43442509f, -0.08618373f, -0.03403102f, 
    -0.33846468f, -0.27657235f, -0.09292297f, -0.23621909f, 0.01451673f, 0.03209951f, -0.02729808f, 0.15602979f, 
    -0.35761952f, -0.02590143f, 0.25513667f, 0.11112855f, -0.50195616f, 0.11094135f, -0.28970003f, -0.07662896f, 
    -0.07687465f, 0.01589292f, 0.03731386f, 0.12598558f, -0.40062940f, -0.02272773f, 0.21691269f, -0.23303124f, 
    0.08981796f, 0.07344347f, 0.12417537f, -0.20500250f, -0.10748639f, -0.07192871f, -0.38859656f, 0.02728769f, 
    0.15077218f, 0.04173038f, 0.04011725f, -0.05192597f, 0.17671543f, -0.02830804f, -0.08294159f, -0.36197376f, 
    -0.47415903f, -0.12188108f, 0.17213853f, -0.31241211f, -0.18428555f, -0.10404314f, 0.21379645f, 0.05325404f, 
    -0.29362211f, 0.11506976f, 0.32351032f, 0.13263866f, -0.02033805f, -0.44040313f, 0.19691281f, 0.14411031f, 
    0.07841195f, 0.26221359f, -0.25726643f, 0.09902155f, -0.26663560f, -0.05419486f, -0.51166523f, 0.11686472f, 
    -0.01937811f, -0.32469437f, 0.02181420f, -0.25725377f, 0.07614477f, -0.20731336f, -0.06310562f, 0.15910162f, 
    0.30968109f, -0.05080435f, -0.00233235f, -0.51307207f, -0.07116754f, -0.03481305f, 0.07789352f, -0.25986212f, 
    -0.20951590f, 0.00357196f, -0.04155149f, 0.18834963f, 0.13213633f, 0.03436528f, 0.08890232f, 0.10759193f, 
    -0.15392478f, 0.32949862f, 0.42154512f, 0.12094507f, -0.00164985f, -0.02983653f, -0.02402847f, 0.15111174f, 
    0.13178356f, -0.30604687f, 0.17893104f, 0.12448092f, -0.12752429f, 0.09234440f, 0.04833136f, 0.22670744f, 
    -0.58444595f, -0.00074458f, -0.00289762f, -0.12462616f, -0.15452185f, -0.04634495f, 0.26029730f, -0.25857636f, 
    -0.04689017f, -0.14807287f, 0.14820747f, -0.38354495f, -0.03720001f, 0.17315343f, -0.24966510f, 0.31980926f, 
    0.25525758f, -0.08793267f, 0.09158836f, 0.04213078f, 0.08598969f, 0.09206561f, -0.42462841f, 0.03585656f, 
    -0.02126929f, 0.18379065f, -0.50846356f, 0.10147735f, -0.41396588f, 0.07879556f, 0.04430442f, -0.56846708f, 
    -0.05361345f, -0.02590344f, -0.11709145f, 0.13626367f, -0.49858463f, -0.08486196f, -0.42887110f, 0.05181012f, 
    -0.66057074f, 0.06235219f, 0.31950328f, -0.46917373f, -0.21098579f, -0.12075276f, 0.07591122f, 0.15166673f, 
    -0.19624308f, 0.11699989f, -0.16975378f, -0.60270935f, 0.01020274f, -0.39111581f, -0.31135517f, 0.07462092f, 
    -0.10111361f, -0.08338232f, -0.05696438f, 0.15573753f, 0.02330491f, 0.17828509f, -0.13496558f, -0.35712168f, 
    0.20896739f, 0.08963294f, 0.18442902f, -0.24596623f, 0.36429501f, -0.05495622f, 0.12057468f, 0.21965702f, 
    -0.06308120f, 0.06507342f, 0.05427291f, -0.23316273f, 0.04315739f, 0.18977737f, -0.03585228f, -0.14738333f, 
    0.00833458f, 0.30603617f, -0.18629664f, 0.36040610f, -0.01837972f, 0.03517681f, -0.26318568f, 0.18313813f, 
    -0.06483004f, 0.02136675f, -0.08259679f, -0.36650756f, 0.36663213f, 0.41517329f, -0.21129352f, -0.14249824f, 
    -0.56397581f, -0.36606562f, -0.02991414f, -0.25581357f, -0.47386968f, 0.06019098f, 0.24281859f, 0.10128945f, 
    -0.04226201f, 0.24518180f, -0.69218147f, 0.39028069f, 0.15818635f, 0.00184075f, 0.12096290f, 0.46121174f, 
    0.31719729f, -0.59845549f, -0.27743757f, 0.15964451f, -0.03067872f, 0.04788404f, 0.03251511f, 0.20347372f, 
    -0.18346168f, -0.27251229f, 0.09562572f, 0.01144310f, -0.36303532f, 0.07639033f, -0.29558718f, -0.26031134f, 
    -0.03204227f, -0.05730776f, -0.03619504f, 0.05307425f, -0.18438859f, -0.02390290f, 0.01687944f, -0.41672137f, 
    -0.65988529f, 0.33786890f, 0.17788889f, -0.07088050f, 0.03234538f, 0.05258191f, -0.01995778f, -0.10020395f, 
    -0.15590873f, -0.01829597f, 0.05715117f, -0.01284915f, 0.04134420f, -0.46048453f, 0.19222160f, -0.06271877f, 
    -0.01228795f, 0.04592322f, 0.06979842f, 0.00377889f, -0.19041358f, 0.04718351f, -0.39974189f, -0.03377117f, 
    -0.23510355f, -0.07887518f, -0.21639112f, 0.45170939f, -0.54450876f, -0.67939252f, 0.04653886f, 0.07476430f, 
    0.10046539f, 0.03594782f, -0.22286378f, -0.01326150f, -0.04109055f, 0.01152257f, -0.43814945f, 0.08811638f, 
    0.15435213f, 0.14032760f, -0.27934855f, -0.48758474f, 0.00497390f, -0.28924450f, 0.08314239f, -0.05920061f, 
    -0.36009663f, 0.06579385f, -0.45422611f, 0.17725110f, 0.06945132f, 0.09640677f, -0.45622176f, 0.28000998f, 
    -0.15408665f, -0.53332746f, -0.56402016f, 0.08375514f, 0.18156272f, -0.31822044f, 0.00519820f, -0.34918353f, 
    -0.19912772f, -0.02717324f, -0.36381340f, 0.04443453f, -0.14962223f, 0.04079905f, -0.18778554f, 0.11493995f, 
    0.07352082f, 0.01698665f, 0.34178305f, -0.12460221f, 0.00847538f, -0.25411633f, -0.08541141f, -0.67379194f, 
    -0.06731441f, 0.03722005f, 0.05903160f, -0.17795779f, -0.56699359f, -0.05256481f, -0.07876908f, 0.23456249f, 
    0.10913512f, -0.02013401f, 0.02698178f, -0.09089180f, 0.13228978f, 0.10396203f, -0.47687417f, 0.24753855f, 
    0.13647136f, 0.14624052f, -0.25319013f, -0.16447157f, -0.13274619f, -0.25546595f, 0.39540768f, -0.25633520f, 
    -0.17849372f, 0.11691799f, -0.48560295f, 0.03005467f, 0.04064617f, -0.06483390f, -0.18125561f, 0.10416786f, 
    -0.18587865f, -0.10478203f, 0.22838734f, -0.02714121f, 0.24628089f, 0.29555732f, 0.02628536f, 0.06430554f, 
    0.01954794f, 0.07915039f, -0.02701133f, -0.23739357f, 0.07189923f, -0.02862790f, 0.11855800f, 0.10417861f, 
    0.38921815f, 0.01855903f, -0.16979831f, -0.01403081f, 0.02287493f, -0.00035151f, -0.29748756f, -0.05015395f, 
    0.14732099f, 0.06338346f, -0.18206373f, -0.37342089f, 0.06679972f, -0.15382919f, -0.35455912f, 0.04363180f, 
    -0.37544531f, 0.01803833f, -0.39816925f, 0.39091671f, 0.18463521f, -0.02840291f, -0.07887496f, -0.21569663f, 
    0.04722580f, 0.02612134f, -0.01295615f, 0.01974278f, 0.29282355f, 0.00387717f, -0.32184818f, 0.10655358f, 
    -0.01050681f, -0.01161511f, -0.22303393f, -0.14939117f, -0.14195324f, -0.58482033f, 0.12876226f, 0.16527730f, 
    -0.10852150f, 0.25864318f, 0.23877309f, 0.08449426f, -0.04309354f, -0.07154226f, 0.50050986f, 0.05698710f, 
    -0.25080377f, 0.00220663f, 0.16307634f, 0.19731477f, -0.18928666f, 0.15517862f, 0.15817548f, -0.29764003f, 
    -0.36318782f, 0.02485297f, -0.23975509f, -0.02206744f, -0.34351328f, 0.21022327f, 0.09650522f, -0.01521500f, 
    0.04109208f, 0.01043438f, 0.11365870f, -0.24498290f, 0.13533689f, -0.33431086f, 0.41521862f, 0.13487688f, 
    -0.04986206f, -0.38141835f, -0.28683844f, -0.55373091f, 0.13344534f, -0.07603219f, 0.28764567f, -0.12874337f, 
    -0.09287848f, -0.23158714f, 0.07900408f, 0.11755617f, -0.74145132f, -0.02695639f, -0.46198931f, -0.08818869f, 
    0.00464473f, 0.13603216f, -0.01963263f, -0.31088969f, 0.33046320f, -0.30182940f, -0.11867558f, 0.01087214f, 
    -0.38815191f, -0.20185158f, 0.16219510f, 0.01952832f, -0.00851683f, -0.47279790f, -0.29754549f, -0.20399615f, 
    -0.20280854f, 0.01673905f, -0.05727677f, 0.24631503f, 0.02585246f, -0.07430431f, 0.12703942f, 0.07651361f, 
    0.16079119f, 0.20729743f, -0.22162350f, 0.02021647f, 0.07128496f, 0.04865906f, 0.08349339f, 0.04301838f, 
    -0.18489498f, -0.05197548f, -0.10500725f, -0.19514863f, -0.07219933f, -0.08626679f, -0.22064629f, 0.30165344f, 
    0.26908836f, -0.23244995f, 0.09499640f, 0.23167266f, -0.09302038f, -0.18251590f, -0.39983392f, -0.34014976f, 
    0.24619450f, -0.10639024f, 0.01556155f, 0.14016350f, -0.41887736f, -0.70754677f, -0.44540936f, -0.00566094f, 
    0.07573915f, 0.28445593f, 0.21726002f, -0.18053518f, -0.00080829f, 0.05814508f, -0.39810669f, -0.11739564f, 
    0.16658272f, -0.07278717f, 0.19644263f, -0.00068524f, -0.01871074f, -0.40757269f, -0.24611270f, -0.14979522f, 
    -0.23439035f, 0.02181211f, -0.15960303f, 0.03451214f, 0.13493042f, 0.35751069f, -0.11379978f, 0.12251230f, 
    -0.17186074f, 0.08396116f, 0.08667505f, 0.03246843f, -0.03521361f, -0.27443862f, 0.00966023f, 0.06067291f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.02721512f, -0.05236221f, -0.08102799f, -0.04914848f, 0.18906842f, -0.00433694f, 0.02464404f, -0.20219843f, 
    -0.12979682f, 0.06983144f, 0.07621846f, 0.03684958f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
