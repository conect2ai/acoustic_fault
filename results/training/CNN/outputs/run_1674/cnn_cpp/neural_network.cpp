#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.74143904f, -0.74279869f, -0.51186728f, -0.56650621f, -0.25765637f, -0.73344880f, -0.77859694f, -0.36232492f, 
    -0.23484910f, -0.72388172f, 0.13686121f, 0.32916147f, -0.02110772f, -0.20492513f, -0.26985529f, 0.27188927f, 
    0.06139630f, -0.09838790f, 0.24990267f, 0.05017949f, 0.11284037f, 0.01006929f, -0.18434682f, -0.08306316f, 
    0.02553139f, 0.53277177f, -0.12949243f, -0.65812773f, -0.36771792f, -0.68653828f, -0.09018146f, -0.16683871f, 
    -0.07139701f, 0.26789817f, -0.07198856f, 0.21876822f, 0.30948818f, 0.26966488f, 0.09891181f, -0.05117563f, 
    0.03506137f, -0.30006668f, -0.15487483f, -0.27098978f, -0.33038172f, -0.28523105f, -0.18632643f, -0.11780601f, 
    -0.42520967f, -0.63442683f, 1.18617058f, 0.21689139f, 0.17566603f, 0.11235817f, 0.09303274f, -0.05508731f, 
    -0.29697666f, 0.04943621f, -0.06384061f, -0.60893697f, -0.15046364f, 0.34267429f, 0.17922637f, -0.27083910f, 
    -0.18756877f, -0.06036474f, -0.06401668f, 0.37125707f, -0.17084222f, -0.22142641f, -0.18297032f, 0.08183867f, 
    -0.08533020f, 0.12157209f, 0.04281427f, -0.18884429f, -0.22854798f, 0.15259886f, -0.25219917f, -0.09072220f, 
    -0.08110574f, 0.27197903f, 0.55547017f, -0.28527847f, -0.04108389f, 0.04801280f, 0.18909651f, -0.08706246f, 
    0.35252005f, -0.22485426f, -0.21602534f, -0.30330363f, 0.00861657f, -0.07812243f, 0.45993724f, -0.09639926f, 
    -0.42474893f, 0.22309081f, 0.47640347f, -0.02005762f, 1.36966193f, -0.62904531f, -0.59534663f, -0.77712697f, 
    -0.91480726f, 0.98748732f, -0.16203640f, 0.26198408f, 0.23489410f, 0.10432888f, -0.10526422f, 0.27822638f, 
    0.02878148f, 0.01519042f, -0.23529911f, -0.14334232f, 0.00257665f, 0.20943783f, -0.10894650f, -0.11250824f, 
    -0.04612084f, -0.04870710f, -0.08201614f, -0.03892614f, 0.16040996f, 0.27990562f, -0.51639771f, 0.09692518f, 
    0.49316174f, -0.29045522f, -0.64920998f, -0.80376220f, -0.80124313f, -0.79664940f, -0.93447602f, 0.40912604f, 
    0.48134089f, -0.14691073f, 0.00628428f, -0.15535673f, 0.03254237f, 0.14043920f, -0.12181824f, 0.06555191f, 
    -0.00175132f, -0.36922264f, -0.01289303f, -0.19957907f, -0.10603774f, -0.11686817f, -0.59283340f, 0.02542140f, 
    0.21748883f, 0.10650267f, 0.02631661f, -0.10198312f, 0.01585646f, 0.12533209f, 0.40199387f, -0.11297203f, 
    0.43114230f, -0.27367121f, 0.29324991f, -0.50264990f, -0.17430988f, 0.03981959f, -0.24576108f, -0.23757069f, 
    -0.45421249f, 0.37910119f, 0.04999138f, 0.31434399f, 0.45691779f, -0.00737128f, 0.24400367f, -0.86648065f, 
    0.07045513f, -0.34525555f, -0.41231158f, 0.24565916f, 0.18092982f, -0.21496861f, -1.19798720f, -1.08151150f, 
    -0.63105202f, -0.30727428f, -0.03849604f, -0.23125742f, -0.48614058f, -0.20458293f, -0.19214407f, -0.82420003f, 
    -0.48952436f, 0.04281076f, -0.54334998f, 0.13686374f, -0.26958743f, -0.12689653f, 0.10139691f, 0.07693292f, 
    1.01709771f, -0.21703105f, -0.34870765f, -0.35297176f, -0.20172644f, 0.47519180f, 0.19580755f, 0.56114620f, 
    0.10121638f, -0.31330395f, -0.38692170f, -0.12971170f, -0.10390239f, -0.42253661f, 0.46618295f, 0.20065717f, 
    -0.06627877f, -0.20164007f, -0.36459950f, -0.51946622f, 0.26647347f, -0.22409618f, -0.46884272f, -0.02392308f, 
    -0.24476331f, -0.68902677f, -0.43553117f, -0.36024374f, 0.13016579f, 0.27028286f, -0.40932789f, -0.80054265f, 
    -0.45652249f, 0.44965202f, 0.24365583f, 0.04321561f, -0.34398377f, -0.12910208f, -0.15006891f, -0.45801443f, 
    -0.00465950f, -0.30848619f, 0.16136271f, -0.54522890f, -0.76975447f, 0.07049993f, 0.23808880f, 0.05620911f, 
    0.20048837f, 0.31383055f, 0.15629101f, 0.02376275f, -0.04897280f, 0.12299950f, 0.13879736f, 0.45016000f, 
    0.29163080f, 0.25538453f, 0.11756474f, 0.24686830f, 0.24825040f, -0.03178765f, -0.25498977f, 0.20420188f, 
    0.17991921f, 0.17071012f, -0.18276459f, 0.04020577f, 0.20239039f, -0.17119731f, 0.42324927f, -0.08183821f, 
    0.02203445f, -0.05738695f, -0.22858472f, -1.12070417f, 0.89522725f, -0.33753118f, -0.90057993f, 0.22957067f, 
    -0.28330490f, 1.03714669f, 0.08905237f, -0.05767586f, -0.32514665f, -0.49743679f, 0.22525328f, 0.16968310f, 
    -0.71471947f, -0.15660670f, 0.47444141f, 0.08039182f, -0.15225188f, -0.05183133f, 0.18948554f, 0.19132553f, 
    0.19761907f, -0.34256217f, -0.11814027f, -0.18911937f, 0.29339236f, 0.44391006f, 0.02898810f, 0.17828058f, 
    0.06370170f, 0.14998442f, 0.21903138f, 0.15475088f, -0.04762717f, -0.03461496f, -0.00554506f, -0.05818134f, 
    -0.21226650f, 0.04484185f, -0.06419190f, 0.24750961f, 0.03578180f, -0.08969416f, -0.00243382f, -0.29198307f, 
    -0.10035255f, 0.33320975f, -0.05901643f, -0.23677845f, -0.39656302f, -1.23291111f, 0.17560893f, -0.27271304f, 
    0.55669421f, 0.65063685f, -0.33314833f, -0.09838470f, -0.30067143f, 0.46310365f, 0.67536235f, 0.30939293f, 
    0.04440237f, -0.06115213f, -0.36671141f, 0.09701090f, 0.03378069f, 0.32060996f, 0.34627968f, -0.34385553f, 
    -0.31504923f, 0.19473788f, -0.09465631f, -0.13091753f, 0.26434302f, -0.35623854f, -0.19223011f, -0.02467790f, 
    -0.23191297f, 0.41798663f, 0.14345773f, 0.23056281f, 0.25261289f, -0.01289410f, -0.14898716f, -0.04947367f, 
    0.43053919f, -0.21552169f, -0.36835617f, -0.14785911f, 0.60323739f, -0.10034673f, -0.16146603f, -0.19750947f, 
    -0.20538686f, 0.17557321f, 0.10850929f, -0.02235617f, -0.08626025f, 0.19155899f, -0.30400559f, -1.07587981f, 
    -0.80996501f, -0.52389991f, -0.20526482f, -0.10245040f, 0.71666765f, 0.21483839f, 0.34441698f, 0.59599566f, 
    0.35661784f, 0.21405435f, 0.04631770f, 0.02986007f, 0.19171999f, -0.24768068f, 0.00271653f, 0.02730007f, 
    0.24979268f, -0.22628313f, -0.06316389f, -0.10065489f, 0.11864477f, -0.02021238f, 0.04704523f, -0.18747702f, 
    -0.85693383f, -0.68180418f, -0.67513955f, -0.21232118f, -0.02673767f, -0.15407075f, 0.04689678f, 0.02152142f, 
    -0.26098076f, 0.01638656f, -0.72989911f, -0.80953699f, -0.38112578f, 0.89784056f, -0.44807193f, 0.41943550f, 
    0.04505369f, 0.01576571f, -0.27331382f, -0.01291367f, -0.06861212f, -0.17999685f, 0.02809602f, -0.30538332f, 
    -0.09169288f, -0.20013021f, -0.38222075f, -0.74365520f, -0.97481096f, -0.20285730f, -0.01571294f, -0.16423038f, 
    0.29974625f, 0.10911588f, 0.02597061f, -0.25963935f, -0.29551661f, -0.19192064f, 0.07819387f, 0.25550011f, 
    0.18910286f, -0.25657326f, -0.03514851f, 0.10463683f, -0.25027338f, -0.25379908f, -0.16151343f, -0.44014964f, 
    -0.11207179f, -0.40696192f, 0.33296943f, 0.46289665f, -0.66220713f, -0.09367839f, -0.21750908f, -0.42402366f, 
    0.15286399f, 0.00982929f, 0.17930920f, 0.17469133f, 0.22573628f, 0.65997064f, -0.45966882f, -0.64561230f, 
    -0.02564202f, 0.04618410f, 0.13964200f, -0.01210811f, -0.25234956f, 0.10132804f, -0.28799644f, -0.09416896f, 
    -0.09810343f, -0.33783188f, -0.51298004f, -0.11359423f, -0.21525303f, 0.06354979f, 0.10217244f, 0.30388659f, 
    0.01191232f, 0.10280394f, 0.21852508f, 0.45942789f, 0.04266241f, -0.41287291f, 0.07434322f, 0.46618515f, 
    -0.13150235f, -0.21548077f, -0.30122510f, -0.28930938f, 0.24148943f, -0.09025279f, -0.39792016f, 0.11064181f, 
    0.35200471f, 0.00424939f, -0.28856698f, 0.07164524f, 0.02550143f, 0.58353865f, 0.29672882f, -0.63502181f, 
    -0.78017235f, 0.05999481f, -0.04807817f, 0.20435986f, 0.04006061f, -0.37120861f, 0.18887447f, -0.24283952f, 
    0.69068968f, -0.38154820f, -0.15988345f, 0.20803544f, 0.05001930f, -0.21479605f, -0.01697407f, -0.52769911f, 
    0.01019530f, 0.09336267f, 0.18426196f, 0.18441400f, 0.52765334f, 0.84026760f, 0.92602515f, 0.11057884f, 
    -0.46681094f, 0.31395540f, -0.44880781f, 0.21455804f, 0.15177996f, -0.65754110f, -0.72232878f, -0.20360979f, 
    0.02923631f, -0.21923463f, -0.04820623f, -0.11958745f, 0.12534569f, 0.25837427f, 0.37388131f, 0.23963930f, 
    -0.02969655f, -0.26235792f, -0.09592690f, -0.10431767f, 0.05192637f, -0.19487613f, -0.69588608f, -0.76245505f, 
    -0.55247331f, 0.15614775f, 0.22011258f, 0.29409111f, -0.02784981f, -0.29055560f, 0.11257119f, -0.50694484f, 
    0.29548237f, 0.44391018f, 0.40467373f, 0.31006891f, -0.02060573f, 0.20510894f, -0.23032059f, 0.06120923f, 
    0.09231815f, -0.06248568f, -0.30423254f, 0.10719058f, 0.02726940f, 0.04064363f, -0.30253279f, 0.05502492f, 
    -0.42023849f, -1.20795262f, -0.80419058f, 0.04502027f, 0.42257684f, 0.17464153f, -0.39803281f, -0.31352669f, 
    -0.35471165f, 0.49291453f, 0.46403059f, 0.47560346f, -0.10258875f, -0.04661842f, -0.36828822f, -0.47645363f, 
    -0.30768880f, -0.00517407f, -0.06318478f, 0.44750363f, -0.21231061f, -0.21480218f, 0.40924892f, 0.18008603f, 
    -1.34646559f, -0.21580462f, -0.36361492f, -0.95943749f, -1.01521957f, 0.80977267f, 0.26180425f, -0.31553608f, 
    -0.17388441f, 0.70097768f, -0.12165036f, 0.22718564f, 0.01769485f, 0.05117213f, -0.34854734f, 0.15784517f, 
    0.00436086f, -0.24547720f, 0.04944097f, -0.05367752f, -0.00748861f, 0.11022298f, -0.20908281f, -0.08254724f, 
    -0.15686122f, -1.42562807f, -0.96724719f, -0.07333364f, 0.89230770f, 0.62626714f, 0.70400226f, 0.55281126f, 
    0.32346684f, 0.00427525f, -0.12990278f, 0.17944266f, -0.08973729f, -0.21207468f, 0.47660390f, -0.34330359f, 
    0.09324633f, -0.17919499f, -0.17750536f, -0.07308301f, -0.01203798f, -0.23773377f, 0.22464034f, 0.32407406f, 
    0.03851124f, -0.23113899f, -0.20452313f, -0.04758828f, -0.00196982f, 0.40931058f, 0.34958354f, -0.82483453f, 
    -0.38863802f, -0.23221825f, 0.46119976f, 0.07819420f, -0.03025510f, -0.11197020f, -0.20194301f, 0.51711506f, 
    0.06484852f, 0.13855001f, 0.31525388f, -0.08722052f, -0.22837137f, -0.51862884f, -0.15798275f, 0.16584535f, 
    0.33638075f, 0.09675410f, -0.03482457f, 1.12416530f, 0.90379030f, -0.10331951f, -0.19412909f, -1.17214847f, 
    0.17266551f, -0.42846945f, 0.12940595f, 0.07728878f, -0.08394568f, 0.09650820f, 0.05974548f, -0.09203812f, 
    0.44835395f, -0.33887154f, -0.00766173f, -0.02914658f, -0.01787908f, -0.12921779f, 0.09928323f, 0.32218423f, 
    -0.15318607f, -0.12501523f, -0.03622388f, 0.02200956f, -0.51741719f, -0.48368081f, 0.25356224f, 0.35275877f, 
    -0.06055425f, 0.25362411f, 0.15076289f, -0.54666787f, 0.13082156f, 0.55835450f, -0.24196111f, 0.13320200f, 
    0.07702317f, -0.14816894f, 0.24196179f, -0.42194825f, 0.03072060f, -0.19623283f, -0.21604793f, -0.23390760f, 
    0.31663460f, 0.17351715f, 0.12744287f, 0.34636739f, 0.11857679f, -1.00203347f, -0.45242071f, -0.35714781f, 
    -0.78669000f, -0.74114507f, 0.49519247f, 0.16121371f, -0.40927443f, -0.15445724f, 0.17378125f, -0.47618076f, 
    -0.49127334f, -0.56408697f, -0.49637559f, -0.19675915f, -0.00652791f, -0.02558372f, -0.27772290f, 0.00913189f, 
    -0.26496083f, -0.01138383f, -0.25186235f, 0.09491936f, 0.14073554f, 0.03153957f, -0.34408286f, 0.91264004f, 
    0.79736888f, -0.40595523f, -0.06265476f, -0.73454773f, -0.80153370f, -0.04134933f, 0.35866290f, 0.08479361f, 
    0.05531171f, -0.53768861f, -0.11894526f, 0.54321629f, -0.22887594f, -0.08605901f, -0.09134425f, -0.22339098f, 
    0.10708580f, 0.03636491f, -0.07140058f, -0.04968472f, -0.10688895f, -0.24077809f, -0.06729199f, -0.92946166f, 
    -0.22954170f, 0.66826403f, -0.68328536f, -0.40989968f, 0.17747824f, 0.05911475f, 0.06916887f, 0.40278104f, 
    0.53474069f, 0.08770739f, 0.15548252f, 0.17374557f, 0.07273936f, -0.29575875f, -0.23795021f, -0.27717412f, 
    -0.31848842f, 0.04337977f, 0.16221531f, -0.21914022f, 0.05887478f, 0.30266356f, -0.21758409f, -0.58239692f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.31112462f, -0.19334763f, 0.17857905f, 0.26973972f, 0.20381451f, -0.07325762f, 0.10944043f, -0.06182922f, 
    0.50107986f, 0.32782200f, 0.13476627f, 0.35855660f, 0.04528951f, 0.14957044f, 0.57605219f, 0.10325251f, 
    -0.20919225f, -0.11434428f, -0.04859779f, 0.20678341f, 0.20300786f, 0.09999516f, 0.17441089f, 0.47331184f, 
    0.08158284f, 0.41275761f, 0.31006193f, 0.53235078f, 0.22952983f, -0.59328854f, 0.34973451f, 0.15955473f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.46123281f, 0.30795598f, 0.07678797f, -0.24939771f, 0.13886435f, 0.14914861f, 0.10243847f, 0.12190095f, 
    -0.03566761f, -0.00385742f, -0.00998534f, 0.04017733f, 0.15271269f, -0.13713813f, -0.12562838f, 0.09616053f, 
    0.06169698f, -0.02005854f, -0.03260793f, 0.04089579f, -0.12175021f, 0.14251189f, 0.00756735f, 0.37107724f, 
    -0.56897092f, -0.18470106f, -0.47123259f, 0.11528214f, 0.07864869f, 0.03493070f, -0.03639394f, 0.00693928f, 
    0.03374816f, 0.05769090f, -0.07804318f, -0.01361386f, 0.04334361f, -0.25589052f, -0.01082585f, 0.07441240f, 
    0.07651994f, -0.11846098f, 0.04797104f, -0.07667588f, -0.04455587f, -0.06990011f, -0.17151877f, -0.04813644f, 
    -0.11103714f, -0.52174282f, -0.42655230f, 0.04402213f, 0.05181361f, 0.01144218f, -0.11422781f, 0.02798071f, 
    -0.06171086f, 0.07651405f, -0.05876622f, 0.00540241f, 0.35407808f, 0.19620271f, -0.13306710f, -0.24330053f, 
    0.01564679f, -0.17619616f, -0.07421795f, 0.18670337f, 0.02750734f, 0.05950806f, -0.06299862f, -0.01361073f, 
    -0.15432940f, 0.03647242f, 0.03955422f, -0.21644042f, 0.11410829f, -0.15506093f, 0.10669259f, -0.02169094f, 
    -0.11571880f, -0.08353765f, -0.03307368f, -0.12345115f, 0.40814281f, 0.37706307f, -0.57495743f, -0.06726295f, 
    0.06441765f, -0.04619857f, 0.01177386f, -0.00089622f, -0.15755597f, -0.10059714f, -0.09412839f, -0.28559697f, 
    -0.34558293f, -0.51050335f, -0.35635972f, 0.09897786f, 0.00067916f, -0.00819271f, -0.01135760f, -0.06382453f, 
    0.01250161f, -0.10483786f, 0.02941365f, -0.08374211f, 0.12826771f, 0.25230077f, 0.15013041f, -0.29280245f, 
    0.10608866f, 0.11314588f, -0.07744943f, -0.35098779f, -0.06734597f, -0.09784636f, -0.21525772f, -0.11891434f, 
    -0.01895379f, 0.02497639f, 0.00050624f, 0.01149727f, 0.00949304f, 0.02969932f, 0.04050442f, -0.02700043f, 
    -0.36485618f, -0.25145549f, -0.32301620f, -0.12286588f, -0.39313209f, 0.15719981f, -0.16541967f, -0.05119342f, 
    -0.13686790f, 0.28777170f, -0.14639199f, -0.10364708f, -0.07124614f, 0.05859136f, 0.12857603f, -0.01708183f, 
    -0.14324819f, -0.17440492f, 0.01460161f, 0.07367859f, 0.09309602f, 0.03317087f, 0.00515696f, -0.03572550f, 
    -0.01554918f, 0.00116197f, -0.09380973f, 0.02919929f, -0.22087948f, 0.35732821f, 0.26554403f, 0.00681695f, 
    -0.09829919f, 0.05607393f, 0.05992122f, 0.02442562f, -0.20210439f, 0.03750366f, -0.04981578f, -0.06242362f, 
    -0.48471615f, -0.36714992f, -0.10028055f, -0.12218338f, -0.03998534f, -0.00359278f, -0.01885474f, 0.02077286f, 
    -0.07069966f, -0.05310985f, -0.03338053f, -0.26641029f, 0.25293550f, 0.12290798f, 0.13437775f, 0.00013266f, 
    0.10785698f, 0.15293992f, 0.12676470f, 0.01636866f, -0.06355216f, 0.14925848f, -0.00855112f, 0.03507610f, 
    0.36030108f, 0.13927071f, 0.06412008f, -0.10238747f, 0.17294921f, 0.29580289f, 0.21322532f, 0.11863735f, 
    -0.05591194f, 0.04372268f, 0.07260996f, -0.08804113f, 0.24107398f, 0.07954972f, 0.05037864f, 0.00426941f, 
    -0.01695163f, 0.16767319f, -0.10097298f, 0.12246227f, -0.13787349f, -0.05177638f, 0.01084302f, -0.01633593f, 
    -0.04431589f, 0.02740002f, -0.00919731f, 0.12238666f, -0.01180290f, -0.06249998f, -0.18008009f, -0.04193675f, 
    -0.17103265f, 0.01141627f, -0.16055386f, 0.21492034f, -0.29365301f, 0.28690794f, -0.24600679f, -0.06408705f, 
    0.08732671f, -0.03136414f, 0.06839179f, 0.05206294f, -0.00674749f, 0.10075850f, 0.08554323f, -0.17488146f, 
    0.14554138f, -0.21057947f, -0.00565470f, -0.02387963f, -0.03068001f, -0.02159840f, -0.17094418f, -0.02840875f, 
    -0.00794220f, -0.16184957f, -0.11162129f, -0.11019241f, -0.12755048f, -0.05702939f, -0.30204374f, 0.22968690f, 
    0.04300900f, -0.02152597f, -0.15949638f, -0.16905865f, -0.03419457f, 0.10636924f, 0.04076244f, 0.02636893f, 
    0.24774589f, 0.23056743f, -0.00787269f, 0.04382313f, 0.00450610f, 0.02338433f, 0.09003282f, -0.06066815f, 
    -0.06061276f, -0.04032458f, -0.00646365f, -0.01907285f, 0.24136524f, 0.27686805f, -0.52662128f, -0.21404432f, 
    0.14233431f, 0.12098935f, -0.15686336f, -0.33673421f, -0.14301339f, -0.36082754f, -0.14121012f, -0.05268942f, 
    0.25967294f, -0.00219210f, -0.12237384f, -0.26833820f, 0.01195669f, 0.36207783f, 0.01934106f, -0.02396119f, 
    -0.02435141f, -0.00484806f, 0.02592904f, 0.08573718f, 0.81732863f, -0.41086039f, -0.28059202f, -0.01216490f, 
    0.07258736f, 0.08353736f, 0.04027038f, 0.06054269f, -0.04748697f, -0.11587471f, -0.16102949f, -0.04134360f, 
    -0.06941190f, 0.17478921f, 0.14593194f, -0.24183974f, -0.12253460f, -0.10433400f, -0.04933330f, -0.05835291f, 
    0.03815249f, -0.05187438f, -0.17031603f, -0.04666293f, -0.35153002f, -0.98007917f, -0.64695710f, 0.18849505f, 
    0.02766813f, 0.07887673f, -0.16436297f, -0.04388146f, -0.14502037f, -0.01069992f, -0.13816766f, 0.04573079f, 
    -0.02383251f, 0.04558948f, 0.11264876f, -0.10760019f, -0.11541735f, 0.02574440f, 0.04305288f, -0.02859232f, 
    -0.00744884f, -0.06514934f, -0.13251750f, -0.27125669f, 0.21353850f, 0.28115988f, -0.14384703f, -0.09487162f, 
    0.21212131f, 0.28601232f, 0.14425686f, 0.19070445f, -0.05078815f, -0.02020149f, 0.00505539f, -0.02295064f, 
    -0.58778536f, 0.29552186f, 0.26469108f, -0.14382762f, 0.08389508f, 0.03713057f, -0.24986020f, -0.03138534f, 
    -0.01247627f, -0.09294377f, -0.11265268f, 0.01864710f, -0.02121064f, -0.36982816f, 0.07562928f, -0.01187991f, 
    -0.00025857f, 0.04067098f, 0.00120070f, 0.15865789f, -0.05215098f, 0.02272520f, -0.00870256f, -0.06218518f, 
    -0.10259181f, 0.16446212f, 0.08132356f, 0.20208789f, -0.36421508f, -0.01503514f, -0.28892183f, -0.28173622f, 
    -0.05136469f, -0.02680482f, -0.06308646f, 0.02366607f, 0.00216037f, -0.17654823f, -0.11836613f, -0.15616217f, 
    -0.02555637f, 0.01633782f, -0.00547410f, 0.09594123f, -0.01855689f, -0.27940467f, -0.14931044f, -0.05588491f, 
    0.61711389f, 0.23182583f, 0.22997169f, -0.14434490f, 0.02554782f, -0.05193390f, -0.04351452f, -0.17392766f, 
    -0.03061455f, 0.02333867f, -0.00503597f, 0.20626524f, 0.00621540f, -0.12605274f, -0.08949246f, -0.16786703f, 
    0.04739896f, 0.08273032f, 0.21631670f, -0.16449977f, 0.19630358f, -0.11576072f, 0.01600507f, 0.01325992f, 
    0.94077647f, -0.22378688f, -0.23537415f, -0.36209762f, 0.06179843f, 0.03825522f, -0.07999928f, -0.00737729f, 
    0.10753268f, 0.09475072f, 0.05728833f, 0.02851307f, -0.11082826f, 0.13513239f, -0.36651462f, -0.42345190f, 
    -0.23772989f, -0.00872697f, -0.08827939f, 0.06478792f, 0.05090792f, 0.02368603f, -0.12574458f, 0.16830133f, 
    -0.15015587f, 0.05851664f, -0.07623515f, -0.00419160f, 0.10746857f, 0.07167904f, 0.02914885f, -0.05150332f, 
    -0.05724199f, 0.07424145f, -0.19101369f, 0.23986937f, 0.11257654f, -0.38289034f, 0.09671470f, 0.25279352f, 
    -0.18653640f, -0.01199124f, -0.01953590f, 0.09018008f, 0.03296265f, -0.03348788f, 0.02963248f, 0.08120679f, 
    0.83504748f, -0.12730615f, 0.37937614f, 0.27722049f, -0.01971922f, 0.03390161f, 0.00149389f, -0.11863622f, 
    -0.17782053f, -0.05486321f, -0.47302738f, -0.27874416f, -0.34692225f, 0.09009103f, -0.42003286f, -0.06413247f, 
    0.05167888f, 0.08146773f, 0.02454117f, 0.14622921f, 0.03907430f, 0.14689767f, -0.07187384f, -0.26347968f, 
    0.11832837f, 0.07336643f, 0.03408892f, 0.15567188f, -0.08080465f, -0.03030852f, -0.08648619f, 0.02734946f, 
    0.18333417f, 0.00047457f, 0.11791735f, 0.02919738f, -0.21867715f, -0.46527764f, -0.29309887f, -0.15348393f, 
    -0.21134755f, -0.05958219f, -0.01494065f, -0.03807392f, -0.05540383f, -0.08579583f, -0.18111528f, 0.09106994f, 
    0.05206336f, 0.13092104f, 0.09919442f, 0.13185419f, -0.06110561f, 0.01362649f, -0.01566068f, -0.01748490f, 
    0.05636030f, 0.13108273f, 0.04297134f, 0.16665654f, -0.17568551f, 0.13001996f, 0.08786294f, 0.01509371f, 
    0.07840458f, 0.02798154f, -0.10069714f, 0.00301565f, -0.09915571f, -0.35622057f, -0.40663096f, 0.22727232f, 
    0.14006969f, -0.17966978f, 0.11290603f, -0.01839947f, -0.01467522f, 0.04263001f, -0.02807536f, 0.04518801f, 
    0.08452865f, 0.08319826f, 0.13949348f, 0.06046168f, -0.03829031f, -0.10477538f, -0.22176629f, -0.12486621f, 
    -0.07949138f, -0.01796773f, 0.08167530f, 0.01385225f, -0.08331850f, 0.01136304f, -0.04818597f, -0.01617889f, 
    0.02696659f, 0.10851558f, 0.26740178f, 0.13411359f, 0.30581328f, -0.24800923f, 0.07144788f, -0.20704636f, 
    0.01429190f, -0.08870391f, 0.04844731f, -0.15838234f, -0.00988639f, -0.03612046f, -0.02581926f, 0.16473594f, 
    0.13452782f, 0.08820486f, -0.28275618f, -0.26246548f, 0.03739757f, 0.02241103f, -0.01534918f, -0.09712214f, 
    -0.10228226f, -0.24472472f, 0.14851034f, -0.08504792f, -0.04139617f, 0.03396047f, -0.12151282f, 0.01126534f, 
    0.20901953f, -0.37184298f, -0.37258238f, 0.28360081f, 0.01863974f, 0.25650004f, 0.19761769f, 0.24969594f, 
    -0.11253561f, 0.05901408f, -0.02975626f, 0.03290834f, -0.03091747f, 0.03444390f, -0.05414790f, -0.02913522f, 
    0.19572990f, -0.06834704f, 0.06995828f, -0.26745746f, 0.03150420f, 0.16368891f, 0.16749269f, -0.10309669f, 
    -0.04377495f, 0.09856669f, -0.19317600f, -0.03903632f, 0.22024284f, -0.09817596f, -0.17888440f, -0.06322485f, 
    -0.08313307f, -0.40116462f, 0.07603268f, -0.07920277f, -0.04868528f, 0.00065656f, 0.04009843f, 0.07831296f, 
    -0.14710164f, -0.12431417f, -0.16397884f, 0.01420005f, 0.05790558f, 0.02841896f, 0.18964444f, 0.18216822f, 
    -0.11837386f, 0.00570804f, 0.11099566f, 0.03675368f, -0.04899012f, -0.42475972f, -0.16940117f, 0.14520104f, 
    0.11634240f, 0.26556584f, 0.10925082f, 0.26614705f, 0.14867866f, 0.06483378f, 0.00660683f, 0.09024948f, 
    0.16348606f, -0.04426727f, -0.15943384f, 0.12312214f, 0.04926073f, 0.19557901f, -0.22372167f, -0.13671274f, 
    -0.11578721f, -0.06248901f, 0.00322608f, -0.03891905f, 0.07812490f, -0.31346092f, 0.08840812f, 0.23709553f, 
    -0.13709980f, -0.00877886f, 0.06779867f, 0.04812125f, -0.04408780f, 0.12957186f, 0.02917236f, 0.13098368f, 
    -0.26539022f, 0.08071466f, -0.10281533f, -0.04901290f, 0.15930554f, -0.07085781f, 0.12870558f, 0.00774644f, 
    -0.05367801f, 0.05717478f, -0.02577989f, 0.02449037f, 0.52759743f, -0.14200154f, 0.21352488f, -0.53533202f, 
    0.04537833f, -0.14107457f, 0.00063773f, 0.12003231f, 0.00837333f, -0.11970346f, -0.00305427f, -0.04985956f, 
    -0.15248224f, 0.12965456f, -0.08209430f, -0.01183461f, -0.07595856f, 0.02534894f, 0.07515061f, 0.12295329f, 
    -0.04920511f, -0.01712505f, 0.06183579f, 0.01539760f, 0.60351980f, 0.46496898f, 0.41115928f, -0.08700059f, 
    -0.07556587f, 0.07209761f, 0.04637208f, 0.05463582f, 0.03901758f, 0.00139712f, -0.01899517f, -0.14632353f, 
    0.17329207f, -0.16401981f, 0.05491109f, -0.21295981f, 0.08876202f, -0.07222096f, -0.02390394f, 0.14080474f, 
    0.04570146f, -0.05136112f, -0.00081127f, -0.02804336f, -0.10248033f, 0.21424484f, -0.21871775f, -0.12106867f, 
    0.01709964f, -0.03456955f, -0.01712599f, 0.07160316f, -0.19289774f, -0.03972518f, -0.16667685f, -0.29472563f, 
    -1.04526174f, -0.26908556f, -0.71658254f, -0.23166813f, -0.03924079f, -0.10684891f, 0.02988189f, 0.03990117f, 
    0.06918807f, -0.00439492f, 0.00931955f, -0.00743938f, -0.03397410f, 0.22638108f, -0.01834704f, 0.07245879f, 
    -0.06085047f, 0.00007867f, 0.08444739f, -0.20840575f, 0.04298291f, 0.05209288f, 0.09487880f, 0.15674092f, 
    -0.87005693f, 0.00311016f, 0.29974827f, -0.07361060f, -0.12417861f, 0.00766062f, 0.03323333f, -0.03727981f, 
    -0.00317282f, 0.00657815f, 0.08670922f, -0.08059831f, 0.08188052f, 0.14548326f, -0.05391696f, -0.03259482f, 
    -0.07091938f, -0.05830767f, 0.03172449f, -0.02217256f, -0.08073314f, -0.00908534f, -0.02787793f, -0.07749221f, 
    -0.50116587f, 0.72523272f, -0.03815285f, 0.05841636f, -0.02356646f, 0.00422844f, 0.03868976f, -0.21937060f, 
    0.03916989f, 0.02035977f, 0.06402650f, 0.16362387f, -0.69085073f, -0.29144424f, -0.50950193f, -0.08860334f, 
    0.05068989f, 0.07919419f, -0.08170145f, -0.10143223f, 0.03588714f, -0.09936019f, -0.03505545f, -0.06706014f, 
    0.09706044f, -0.08517234f, -0.38130993f, -0.21857831f, 0.18035156f, -0.03237265f, -0.03128268f, 0.03722048f, 
    0.02457057f, -0.05548193f, -0.07299409f, 0.05389702f, -0.26427770f, -0.46784469f, -0.22277445f, -0.57755363f, 
    0.26986933f, -0.19667076f, -0.20951696f, -0.09447152f, -0.03284586f, -0.07366849f, 0.08425978f, -0.10454012f, 
    -0.26041800f, 0.04991875f, 0.16882837f, 0.01609283f, -0.04154925f, 0.03112508f, 0.02694649f, -0.00497034f, 
    0.03334567f, 0.14634095f, 0.03520793f, 0.17054492f, 0.11708754f, 0.22190632f, -0.11101840f, -0.12002145f, 
    0.05259495f, 0.13168404f, 0.12702896f, 0.01908670f, -0.00429244f, -0.08607326f, 0.02421559f, -0.01960125f, 
    -0.04684468f, -0.08692774f, -0.01487105f, 0.05586926f, -0.02574609f, 0.01332413f, 0.05081163f, 0.07823643f, 
    -0.23687828f, -0.21172221f, 0.04483796f, 0.08241901f, 0.43712348f, -0.10985412f, 0.05614220f, 0.12911300f, 
    -0.01803967f, -0.26437223f, 0.08615318f, 0.02389695f, 0.06484652f, -0.00449232f, -0.00525052f, -0.06409552f, 
    -0.03524714f, -0.08692329f, -0.01287777f, 0.00395406f, -0.02587943f, -0.06119148f, -0.01596354f, 0.00765180f, 
    -0.11763374f, -0.21898878f, 0.03995614f, 0.13668746f, 0.19374855f, -0.22879705f, -0.16276509f, 0.10585847f, 
    0.12991463f, 0.03561616f, -0.02862764f, 0.08749132f, 0.10232895f, 0.02163134f, -0.12589318f, 0.20928234f, 
    0.20220593f, -0.01141683f, 0.16724591f, -0.00542561f, -0.00983028f, -0.03305026f, 0.09990042f, 0.08872420f, 
    -0.22255145f, 0.21704827f, -0.09031647f, 0.08394869f, -0.23269521f, 0.15221389f, 0.25616881f, 0.20797467f, 
    -0.06403320f, -0.05812515f, 0.01149330f, 0.07973886f, 0.06978497f, -0.15379770f, -0.07862630f, 0.13100106f, 
    -0.52732158f, -0.47308156f, 0.66030610f, 0.28286800f, -0.07016600f, 0.12455568f, -0.08931919f, -0.00040201f, 
    0.08519640f, -0.01474017f, 0.08362252f, -0.04508348f, -0.42624778f, 0.09503972f, 0.29047906f, 0.18874305f, 
    0.08784508f, -0.02679028f, 0.21231216f, 0.09581482f, -0.09866526f, 0.03358268f, 0.06409079f, -0.11420052f, 
    -0.02253488f, 0.03368581f, 0.02065541f, 0.02006277f, -0.04084501f, 0.01686752f, -0.02225214f, -0.39045954f, 
    0.08214414f, 0.11222005f, -0.17376710f, 0.34706497f, -0.11521561f, 0.00148661f, -0.46642414f, 0.16429219f, 
    -0.07127446f, 0.00205600f, 0.04996388f, 0.00023465f, 0.00824478f, -0.23918693f, 0.30403480f, -0.24411876f, 
    -0.02600300f, -0.15184614f, -0.09939660f, -0.12678055f, -0.12360550f, -0.07545196f, -0.06696782f, -0.00062999f, 
    0.00126548f, -0.09632766f, -0.12155347f, 0.03591571f, -0.30560169f, -0.32241908f, 0.30211389f, -0.64773631f, 
    0.07733277f, -0.13985240f, 0.04259377f, -0.20914803f, -0.00238048f, -0.13012286f, -0.01540820f, 0.01234791f, 
    0.00605591f, -0.05966997f, 0.08346850f, 0.09421441f, 0.01426474f, -0.06749156f, -0.01235851f, 0.12296411f, 
    0.03385031f, 0.06375835f, 0.08862054f, -0.02163326f, 0.06689482f, -0.23931029f, 0.21570423f, -0.07279744f, 
    0.02243468f, -0.11194383f, 0.09766493f, 0.18957920f, 0.06401107f, 0.02024034f, -0.04692045f, -0.11583086f, 
    0.67631465f, 0.29500937f, 0.53821278f, 0.48506212f, -0.03331588f, -0.13463691f, -0.01693262f, 0.18482038f, 
    0.15876329f, 0.05220696f, 0.05904585f, 0.18398537f, -0.28399763f, -0.23693278f, 0.11971836f, 0.14415208f, 
    -0.01553048f, -0.02526311f, 0.10235515f, 0.05601592f, 0.02240181f, -0.00312418f, -0.01529300f, -0.15836772f, 
    -0.19400766f, -0.35406867f, -0.06062679f, 0.24117890f, -0.31504276f, 0.03551782f, 0.15662350f, -0.12658149f, 
    0.04939731f, -0.07840143f, 0.03676130f, 0.15901475f, -0.60955453f, 0.37541074f, 0.28240627f, -0.68456179f, 
    -0.08841423f, 0.00179789f, -0.11509863f, 0.02493160f, 0.03212649f, -0.05886788f, -0.06468319f, 0.11021631f, 
    0.06812499f, -0.32634658f, 0.02232856f, 0.00215601f, 0.17005689f, -0.00992970f, -0.11434943f, 0.06685635f, 
    -0.02359419f, -0.08908180f, -0.05823964f, -0.03556789f, -0.41836047f, 0.05579316f, 0.67617249f, 0.35304892f, 
    -0.19662076f, -0.08046857f, -0.13011615f, -0.19063354f, -0.00748526f, -0.07367033f, -0.03658851f, -0.11174186f, 
    -0.15244541f, -0.05588830f, 0.12391755f, -0.03955666f, -0.05286578f, -0.02213403f, -0.05210521f, 0.05343904f, 
    -0.03316239f, 0.02360955f, 0.03828831f, -0.00055479f, 0.34565979f, 0.30226570f, -0.11127321f, 0.25011212f, 
    0.05990378f, -0.01831404f, 0.03165474f, -0.05568805f, -0.04025601f, -0.08040875f, 0.26406956f, -0.01550663f, 
    -0.07668499f, -0.26903927f, -0.19929691f, -0.07316582f, 0.02568259f, 0.02279710f, -0.06270085f, 0.03539328f, 
    -0.06968984f, -0.04748286f, -0.03494181f, -0.17739229f, -0.19611974f, -0.03873955f, -0.09288196f, 0.25341904f, 
    -0.00506909f, 0.07924270f, -0.00316706f, 0.07134985f, 0.07910813f, 0.10924645f, 0.11553852f, 0.16258270f, 
    -0.36827987f, -0.16841324f, 0.44977227f, 0.25904992f, -0.03384894f, -0.15609582f, 0.04804966f, -0.26388741f, 
    0.00423047f, 0.13567233f, -0.13137344f, -0.00274348f, -0.20997591f, -0.04340863f, -0.15287127f, -0.19549705f, 
    0.10596748f, -0.05418180f, -0.04264921f, -0.02150969f, -0.16479060f, 0.02954086f, -0.22049075f, -0.09220918f, 
    -0.69736582f, -0.09027532f, 0.09831856f, 0.27181953f, 0.00317545f, 0.11226562f, -0.05768006f, -0.16999802f, 
    0.00296272f, -0.00842710f, 0.06219614f, 0.12777890f, -0.05117584f, -0.13812169f, -0.00080247f, 0.26816562f, 
    0.11320414f, 0.12403296f, 0.07920551f, 0.12191866f, 0.16573702f, 0.07283580f, -0.01555888f, 0.04684564f, 
    0.34529790f, -0.18935458f, 0.25349802f, -0.07126877f, 0.03863307f, 0.06933708f, -0.11065484f, 0.09441032f, 
    0.10350161f, 0.33631799f, 0.08070687f, -0.21288876f, -0.07108588f, -0.04636323f, 0.02832054f, 0.15261179f, 
    0.03294606f, 0.07544379f, -0.03222605f, -0.05887950f, -0.18140842f, -0.10704025f, -0.07653926f, 0.04820423f, 
    -0.27758092f, 0.27284923f, -0.17557152f, 0.06654840f, 0.19352928f, 0.08377501f, 0.12021977f, -0.04991179f, 
    -0.19426459f, 0.03977129f, -0.13954194f, 0.06256302f, 0.15582350f, -0.04947950f, -0.03146573f, 0.07344099f, 
    -0.07705899f, -0.13206530f, -0.04720668f, -0.05843192f, -0.00652585f, 0.17802347f, -0.08637474f, 0.06548090f, 
    -0.15460321f, -0.21300742f, -0.64973271f, -0.21112803f, -0.02456600f, 0.03348772f, 0.00206884f, -0.03995033f, 
    -0.28211734f, -0.26661310f, 0.07448389f, -0.17229447f, 0.90810448f, -0.26492119f, 0.05467992f, -0.01685446f, 
    0.01517161f, -0.18211509f, -0.02642011f, -0.21059702f, -0.23663925f, -0.05498266f, 0.01244475f, 0.18872663f, 
    -0.42485547f, -0.37844962f, -0.29543066f, -0.02861616f, -0.01931176f, -0.00181829f, -0.23867682f, 0.26446053f, 
    -0.15201391f, 0.03381361f, 0.14638652f, 0.01412416f, 0.44116724f, 0.02704117f, 0.05232115f, -0.94644374f, 
    0.07292110f, 0.05474263f, -0.07226650f, -0.16580285f, -0.13537078f, 0.19951494f, -0.26690403f, -0.01595817f, 
    0.00251279f, -0.01043765f, -0.33842179f, -0.31622002f, -0.11119802f, -0.26691326f, -0.12181903f, -0.05124009f, 
    -0.16425531f, -0.02155231f, 0.04402744f, -0.04459653f, 0.15312555f, -0.25565585f, 0.04868799f, -0.12075873f, 
    0.36788827f, 0.20444672f, 0.10839892f, 0.01363277f, -0.04110429f, 0.02809547f, -0.08924513f, 0.03308174f, 
    0.05025607f, -0.06801523f, -0.23174112f, 0.08741827f, -0.04030545f, 0.07011760f, -0.02900208f, -0.07606011f, 
    -0.07663877f, 0.04800493f, -0.04856703f, -0.00179963f, 0.11788110f, -0.10065959f, -0.15713748f, 0.25974742f, 
    0.03646708f, -0.08176004f, 0.04908996f, -0.00327291f, 0.10720061f, 0.04745498f, 0.12698609f, 0.11481266f, 
    0.01794303f, 0.06504292f, -0.28393254f, -0.19158502f, -0.13706046f, 0.05871885f, -0.01196251f, 0.19134802f, 
    0.04805870f, 0.15478501f, -0.08749466f, 0.05322834f, -0.00809202f, -0.20428862f, -0.13200268f, -0.16162370f, 
    0.24878184f, 0.13369574f, -0.05319892f, -0.02701142f, -0.01519556f, 0.06985425f, -0.10457566f, 0.00711126f, 
    0.26464775f, 0.22105426f, 0.22342193f, 0.46312273f, -0.03330294f, 0.03782501f, -0.42987853f, -0.00105960f, 
    0.01205917f, 0.20357820f, 0.14076491f, -0.05572601f, 0.33726731f, -0.05659345f, 0.74638218f, 0.44957039f, 
    -0.26626486f, 0.02227582f, -0.21080483f, 0.12349453f, 0.11189622f, 0.00009965f, -0.04554825f, 0.17786282f, 
    -0.43371108f, 0.07040518f, -0.54548275f, -0.11557474f, 0.03492070f, 0.11588291f, -0.02650797f, 0.11984178f, 
    -0.07214396f, -0.03464538f, -0.03606625f, -0.00334479f, -0.13736363f, 0.10443948f, -0.07573545f, 0.28379709f, 
    0.13849051f, -0.01996249f, 0.06389322f, -0.04766872f, -0.04737004f, 0.15475260f, 0.16796273f, -0.00917942f, 
    0.29282963f, -0.20212428f, 0.06168316f, 0.36076695f, 0.10580599f, -0.01194593f, -0.03521594f, -0.22770841f, 
    -0.09873872f, 0.02765027f, 0.01487622f, 0.17494519f, -0.53948253f, 0.84715980f, -0.21146284f, -0.67725521f, 
    0.09387050f, 0.19980685f, -0.16351442f, 0.17282036f, -0.44101337f, -0.19916846f, 0.07771722f, 0.05970364f, 
    0.38298300f, -0.13782938f, -0.23491192f, -0.05260583f, -0.21939354f, -0.23334461f, -0.08776399f, 0.21002248f, 
    -0.17814998f, -0.11018154f, 0.07630195f, -0.02899762f, -0.73723978f, -0.00554482f, 0.11024252f, 0.02337361f, 
    -0.06742915f, 0.04195882f, -0.18111502f, -0.12177576f, 0.03614980f, 0.02830624f, -0.11289918f, -0.04798490f, 
    -0.05025569f, 0.09496817f, 0.00717332f, -0.20580325f, 0.17646632f, -0.05284215f, -0.09564352f, -0.17379044f, 
    -0.11126152f, 0.22719817f, -0.31037509f, 0.22452290f, 0.21622348f, -0.14646675f, 0.11915437f, 0.26707387f, 
    0.08296842f, -0.01381866f, -0.09205119f, -0.03474357f, -0.06603959f, -0.03296273f, 0.08617261f, 0.14838371f, 
    0.00360707f, -0.35095167f, 0.35613951f, -0.60220033f, -0.48105714f, 0.22365254f, -0.01829806f, -0.07283350f, 
    0.08436357f, -0.06958262f, 0.13975176f, -0.17637409f, 0.66522437f, -0.11404644f, 0.27514264f, 0.07594436f, 
    -0.03892334f, 0.12877215f, -0.19834924f, -0.00990210f, 0.08140325f, 0.06145773f, -0.12735435f, -0.13664761f, 
    0.07038701f, 0.00987792f, 0.19134846f, 0.19645050f, -0.19066679f, -0.08292377f, 0.02772838f, 0.09121934f, 
    0.12372924f, 0.06717779f, -0.00115661f, 0.03354989f, -0.10308181f, -0.04323964f, 0.22447614f, 0.06286497f, 
    0.01334599f, 0.00981055f, 0.03596417f, -0.07805716f, 0.41416860f, 0.09479448f, 0.09305696f, 0.03315355f, 
    0.32899329f, 0.05259789f, -0.06278986f, -0.21481586f, 0.02377931f, -0.02237435f, 0.20451301f, 0.12913442f, 
    0.04329454f, -0.01151316f, 0.01429827f, -0.16358884f, 0.01755095f, 0.01902113f, 0.07563516f, -0.14984389f, 
    -0.14331634f, -0.21679062f, -0.11746559f, -0.10849767f, -0.25223467f, -0.31935951f, -0.03863699f, 0.12379824f, 
    -0.11017481f, -0.04529455f, 0.01936746f, 0.00967901f, 0.15287043f, -0.02284173f, -0.09111997f, -0.01940992f, 
    -0.09450113f, -0.17869651f, -0.16368969f, 0.02312493f, 0.22100347f, 0.19839458f, 0.53027165f, 0.17648335f, 
    0.07992201f, 0.10521476f, 0.05756040f, 0.11109703f, 0.00404108f, -0.08643995f, 0.05720948f, -0.12095464f, 
    0.15448222f, -0.04167038f, 0.07313442f, 0.05502681f, -0.07934283f, -0.06728011f, 0.07216442f, -0.00349676f, 
    0.02152657f, -0.13250566f, -0.14503860f, -0.19595709f, 0.12189143f, -0.00890275f, 0.18109423f, 0.22017372f, 
    0.19098240f, 0.06712405f, -0.00744256f, 0.07403543f, -0.06709062f, 0.09425532f, -0.04502482f, 0.09820947f, 
    -0.05301885f, -0.25059405f, -0.53755468f, -0.31965366f, -0.01220623f, 0.03643763f, -0.12446960f, 0.00060560f, 
    0.11419538f, 0.06518222f, 0.07786711f, 0.22131810f, -0.10736828f, 0.00691365f, 0.11267348f, 0.10652635f, 
    -0.02896925f, 0.04582360f, -0.22510487f, -0.11599869f, -0.14865185f, -0.32417133f, 0.04349182f, -0.01294370f, 
    0.13562913f, 0.03674871f, -0.06080735f, -0.04825583f, 0.09856529f, 0.05772732f, 0.04455175f, 0.03980791f, 
    0.02648059f, 0.02259538f, -0.23301759f, 0.09148122f, 0.02254450f, -0.30223688f, 0.00965534f, -0.02878865f, 
    -0.05781956f, -0.34410456f, -0.10192978f, -0.02663550f, 0.15194821f, -0.04735101f, 0.05168038f, -0.41232616f, 
    -0.00256454f, 0.06604058f, 0.02300916f, -0.06605666f, 0.06980587f, 0.02798644f, 0.09476489f, -0.04570648f, 
    0.19565487f, -0.05686635f, 0.01757538f, 0.10738933f, -0.08811139f, -0.01184571f, -0.31921503f, 0.02160320f, 
    -0.06769804f, -0.09876171f, 0.03916251f, -0.09342069f, 0.04342641f, 0.15707020f, 0.07633628f, -0.00837075f, 
    -0.15834361f, -0.18768537f, -0.18180035f, -0.02848578f, 0.04706791f, -0.03587895f, 0.02030942f, -0.09742131f, 
    -0.09458843f, -0.17093675f, -0.16639742f, -0.04292127f, 0.21017505f, -0.03031681f, -0.00329577f, 0.12965997f, 
    -0.06400940f, -0.01328186f, -0.02469967f, 0.10324371f, 0.05462750f, -0.10098442f, -0.13282596f, -0.06136320f, 
    -0.32343441f, -0.02259940f, 0.11516465f, -0.17884386f, -0.13857348f, 0.07902966f, 0.04365589f, 0.00449979f, 
    -0.00975348f, 0.05020308f, -0.01925542f, 0.11566965f, -0.15439019f, 0.08109600f, 0.17403698f, 0.12333356f, 
    -0.14603744f, 0.01804969f, -0.07063698f, -0.10856830f, -0.02421000f, 0.00688269f, 0.01083047f, 0.26697612f, 
    0.01892587f, -0.04013996f, -0.20965324f, -0.07553760f, 0.09534770f, -0.13848256f, 0.17788661f, -0.01625488f, 
    0.08617878f, -0.12820995f, 0.36394000f, 0.05429788f, -0.21933049f, -0.27869660f, 0.10772816f, -0.19969049f, 
    0.01196453f, 0.02448023f, 0.10999108f, 0.02941238f, -0.12496372f, -0.33956265f, -0.13377522f, -0.17449820f, 
    -0.01593951f, 0.11548464f, -0.13535656f, 0.02519168f, 0.09211797f, -0.12901318f, -0.02898656f, -0.06611554f, 
    -0.06999425f, -0.13143328f, -0.02783961f, -0.26353818f, 0.29305425f, 0.50428146f, -0.47911635f, 0.23599155f, 
    0.05349853f, 0.14748362f, 0.01721211f, 0.07475527f, 0.17102388f, -0.05103481f, 0.10192385f, -0.09676008f, 
    0.19585247f, -0.04686569f, 0.27549988f, 0.12700005f, -0.01867035f, -0.01431593f, -0.10670599f, 0.07463589f, 
    0.07717974f, -0.14324667f, -0.06879937f, 0.11380853f, 0.36895084f, 0.10885669f, 0.10489721f, 0.13551871f, 
    -0.18043469f, -0.07281110f, -0.30421618f, -0.20473151f, -0.03189026f, -0.07325401f, -0.08996480f, -0.01471906f, 
    0.12061162f, 0.20863613f, 0.21578166f, 0.21703495f, -0.16956146f, -0.16928685f, 0.04053050f, -0.08097075f, 
    -0.01839546f, -0.01298438f, 0.04278882f, -0.00441943f, 0.40484333f, -1.02135658f, 0.27039865f, -0.14092611f, 
    -0.09913205f, -0.01770544f, 0.01654868f, 0.01404428f, 0.01290344f, 0.15802988f, -0.08687096f, 0.02782733f, 
    -0.20324601f, 0.06800340f, 0.06045259f, 0.15083466f, -0.32460859f, 0.12287172f, -0.04951591f, 0.01945321f, 
    0.03644016f, -0.09914732f, -0.07642998f, -0.07746602f, -0.27548751f, 0.05549820f, -0.66357297f, 0.13429680f, 
    0.04168100f, 0.10050691f, -0.18974262f, -0.04524205f, 0.01209778f, 0.11054324f, -0.03449391f, 0.00980274f, 
    0.25966477f, 0.05277468f, -0.21160376f, 0.14008489f, -0.06244485f, 0.07828438f, 0.08554887f, -0.06006016f, 
    -0.11354239f, -0.03372589f, -0.07829785f, -0.28632537f, -0.32015389f, -0.14516202f, -0.10468946f, 0.24379441f, 
    -0.07002524f, -0.06164921f, -0.03724405f, -0.15237918f, -0.10795179f, 0.07177991f, 0.03947384f, 0.02714643f, 
    0.15920690f, -0.22887875f, -0.43014532f, 0.51853049f, -0.03654420f, -0.01210616f, -0.12469520f, -0.18932939f, 
    0.11794379f, -0.06310444f, 0.02082376f, 0.16147648f, -0.29566097f, 0.33114484f, -0.23238747f, -0.20205870f, 
    0.04180327f, -0.06739198f, 0.14029010f, -0.07854858f, -0.04127562f, -0.11253300f, 0.03908508f, 0.18918347f, 
    0.06588589f, 0.13298941f, 0.26080048f, 0.03411185f, 0.44768173f, 0.18958326f, 0.22958042f, -0.02385784f, 
    0.00574698f, -0.05141823f, 0.01931775f, 0.08782397f, 0.22936365f, -0.11533048f, -0.17191273f, -0.14940174f, 
    0.04523102f, 0.01880593f, 0.01336014f, -0.07777946f, -0.32051736f, -0.18740858f, 0.02334759f, -0.36560795f, 
    -0.17377721f, -0.34129527f, -0.61729860f, 0.24665400f, 0.01163690f, 0.15416618f, -0.03077293f, 0.06808861f, 
    0.01702183f, -0.14161249f, 0.03358818f, -0.08117841f, 0.05253113f, -0.07271131f, -0.09723842f, 0.29104394f, 
    -0.01789394f, 0.12924683f, -0.20426854f, 0.12481187f, 0.12479760f, 0.30849585f, 0.10601796f, -0.10130616f, 
    -0.14754368f, -0.19254944f, -0.21285303f, -0.17951797f, -0.09918538f, 0.06418063f, 0.00923460f, 0.03244992f, 
    0.07808629f, -0.25035584f, 0.07279908f, -0.16861582f, 0.11925416f, 0.02709596f, 0.16753298f, -0.01461787f, 
    0.11359595f, -0.06746966f, -0.21263069f, -0.35778090f, -0.03728933f, -0.03631133f, 0.02936978f, -0.01581726f, 
    -0.08961914f, -0.07465841f, 0.01275089f, 0.24980155f, -0.04372515f, -0.10974365f, 0.05970173f, 0.00867996f, 
    0.02933758f, -0.04705320f, 0.18473972f, 0.05627326f, -0.11317592f, 0.51541066f, 0.22739987f, -0.44985813f, 
    0.06812175f, -0.01021124f, 0.01283552f, 0.04129300f, 0.13439155f, 0.06889205f, -0.12044586f, 0.00258223f, 
    -0.22093858f, -0.06416265f, 0.09316313f, -0.22041163f, 0.00755956f, 0.04894578f, 0.04647717f, 0.17058887f, 
    0.18536901f, -0.31599018f, 0.09935425f, -0.23385333f, 0.19278726f, -0.08482674f, 0.35957670f, -0.07931021f, 
    -0.09839471f, -0.01755183f, 0.10774681f, 0.01675113f, 0.13624234f, -0.12567618f, 0.00384126f, 0.34552038f, 
    -0.10494190f, -0.10592106f, -0.05705131f, -0.04349013f, -0.02146213f, -0.05571121f, -0.03837877f, -0.03525305f, 
    0.11988541f, 0.27712911f, 0.10103489f, 0.04545732f, -0.54862595f, 0.77470714f, -0.16854417f, 0.01608704f, 
    0.36635548f, 0.04419736f, 0.06332064f, 0.20911293f, -0.00267836f, -0.09837397f, 0.05781397f, 0.15754956f, 
    -0.03560426f, -0.18550965f, -0.07390770f, 0.04270540f, -0.03530527f, 0.05317440f, 0.02520131f, 0.04008383f, 
    0.07377645f, -0.07662672f, -0.09189911f, -0.37069994f, -0.44312814f, -0.23110461f, 0.15479775f, 0.23907158f, 
    -0.19162081f, -0.23591413f, 0.05768495f, 0.19272709f, -0.06071587f, -0.21313649f, 0.43728891f, 0.02927179f, 
    0.08822811f, 0.15764946f, 0.12114871f, 0.26893392f, 0.13894431f, 0.01697441f, 0.02430665f, 0.07032542f, 
    0.16853705f, 0.07848796f, -0.20287733f, 0.13695320f, -0.61143631f, -0.45434228f, -0.26799992f, -0.12603754f, 
    0.03929187f, -0.03264895f, -0.10488375f, -0.03898613f, 0.02811348f, -0.17889191f, 0.18998475f, 0.01227145f, 
    0.01067384f, 0.02777467f, 0.06135880f, 0.01044404f, -0.04439396f, -0.13606057f, -0.23647034f, 0.10757130f, 
    0.02087022f, 0.07185424f, -0.16029240f, 0.08555920f, 0.12163133f, 0.18039864f, 0.03665026f, -0.26140332f, 
    0.03769930f, -0.23808664f, 0.02032572f, 0.06630466f, 0.01126380f, -0.26220232f, -0.15973940f, -0.08265486f, 
    0.31988391f, 0.21238217f, -0.23479640f, -0.01209458f, -0.00168787f, -0.13711073f, -0.14209275f, 0.10472312f, 
    -0.11701260f, -0.20363417f, -0.02586803f, -0.43443164f, 0.03785088f, -0.32339910f, 0.10427070f, -0.06337557f, 
    0.00086597f, -0.07991060f, 0.00705544f, -0.09197824f, 0.06942876f, 0.16647567f, 0.23467582f, 0.12058706f, 
    -0.22347207f, 0.09599930f, -0.35581413f, 0.08443734f, 0.06828263f, 0.08973078f, -0.04919057f, -0.05441373f, 
    0.08284030f, -0.00124710f, 0.18079948f, 0.13473445f, -0.17181203f, 0.00953042f, -0.37751436f, -0.06298941f, 
    -0.03349857f, 0.18201220f, -0.03377480f, 0.16108911f, -0.01164284f, -0.00340968f, -0.01773158f, -0.07688198f, 
    0.09320572f, 0.06908679f, 0.01221207f, -0.17970872f, 0.13642025f, -0.00718014f, -0.00247664f, -0.22811070f, 
    0.15348059f, -0.02055830f, -0.01947795f, 0.01695421f, -0.16373356f, 0.04342555f, 0.03696895f, -0.28974164f, 
    -0.05462242f, 0.12752822f, 0.10552292f, -0.03139819f, 0.08755972f, 0.04291092f, 0.02000664f, -0.01995624f, 
    -0.65922886f, 0.01569267f, -0.05454048f, -0.51516312f, 0.11287015f, -0.06290799f, 0.10926770f, 0.15836468f, 
    0.00720428f, -0.10874341f, -0.05316121f, -0.11329199f, -0.21850210f, 0.00978856f, 0.01535417f, 0.00670570f, 
    0.11029930f, -0.05285009f, -0.02636328f, -0.08881828f, 0.11657012f, -0.08269880f, -0.07402951f, -0.17423752f, 
    -0.06611440f, -0.30379364f, 0.30599588f, 0.04706587f, -0.06946207f, 0.22448319f, -0.25336379f, 0.03708115f, 
    0.00877313f, 0.10609273f, 0.13914654f, 0.01651698f, 0.50288194f, -0.07719267f, -0.69472057f, 0.33480948f, 
    -0.00245869f, 0.14205474f, 0.03190493f, -0.07159580f, 0.06362864f, 0.04131037f, 0.04564619f, -0.18232037f, 
    -0.02025022f, -0.22838795f, 0.18263952f, 0.00557708f, -0.12072693f, -0.15444572f, -0.04161917f, -0.03864369f, 
    0.17724815f, 0.12265994f, 0.12014219f, -0.11228515f, -0.24207965f, 0.05118537f, -0.02416242f, -0.30599064f, 
    0.05994956f, -0.10633302f, 0.02477468f, 0.08894006f, 0.00099809f, -0.01476333f, -0.01033285f, 0.14157529f, 
    -0.43128529f, 0.00873822f, 0.15638424f, 0.43144283f, 0.17530166f, -0.03865787f, 0.02776214f, -0.06770181f, 
    0.01052610f, 0.12428732f, -0.08969696f, 0.00550636f, -0.56048846f, -0.59708452f, 0.06093608f, 0.07720043f, 
    0.04842212f, -0.02048745f, 0.06484656f, 0.04188609f, 0.07962269f, 0.09272113f, 0.17740576f, 0.05473346f, 
    -0.67100185f, -0.94711685f, -0.24436130f, -0.25408262f, -0.47764373f, -0.08139195f, -0.09298250f, -0.27409512f, 
    -0.00524324f, -0.00435292f, 0.01059801f, -0.06165844f, 0.19257012f, 0.36157358f, -0.01802509f, -0.15227515f, 
    -0.03184411f, 0.04096143f, -0.01670992f, 0.11821462f, 0.12493242f, 0.25782791f, 0.01120594f, 0.04880990f, 
    -0.23999776f, -0.27019918f, 0.09937712f, -0.44319892f, 0.07759159f, 0.04870137f, 0.08799561f, -0.08748116f, 
    -0.04155647f, 0.02436581f, -0.09841999f, 0.02734458f, -0.16141541f, -0.02023415f, 0.41080618f, 0.24001177f, 
    -0.28030747f, -0.08597850f, -0.24891995f, 0.08062440f, -0.10989360f, -0.11987896f, -0.16560717f, 0.06979031f, 
    0.15400776f, 0.46966031f, 0.10954742f, 0.10719219f, 0.04250728f, -0.05927152f, 0.13309713f, 0.06082208f, 
    0.13442613f, 0.17624532f, -0.01886692f, 0.18025166f, -0.44101155f, -0.48143354f, -0.44612166f, 0.09528871f, 
    -0.01255226f, 0.05746927f, 0.06056141f, -0.53122526f, 0.05637863f, -0.03013134f, 0.01980831f, 0.02221887f, 
    -0.01255826f, -0.27825001f, 0.22819860f, 0.29611099f, -0.26536745f, -0.06624960f, -0.12860037f, 0.00206365f, 
    -0.06306112f, -0.07571079f, 0.19387336f, -0.37631539f, -0.86305529f, -1.21306789f, -0.81413347f, 0.33685693f, 
    0.09810923f, -0.13147211f, -0.02337232f, -0.27095214f, 0.05257264f, 0.11716403f, 0.07050947f, -0.01498024f, 
    0.15266010f, 0.31564316f, 0.03339641f, -0.24358959f, -0.05528796f, -0.05943439f, 0.13956752f, 0.05935604f, 
    0.07997044f, 0.10371976f, 0.31451112f, 0.23005791f, -0.28026205f, -0.89936554f, -0.40987867f, -0.28032044f, 
    -0.33674526f, -0.28469071f, 0.08824990f, 0.13081770f, -0.03385567f, 0.11778864f, 0.02633833f, -0.14983676f, 
    -0.01805645f, 0.03519301f, -0.05940596f, -0.00895903f, 0.04497050f, 0.02873384f, -0.05615477f, -0.07435685f, 
    -0.08301303f, -0.09040143f, -0.08511622f, -0.16599697f, -0.11682446f, -0.24294496f, 0.41457564f, -0.22231390f, 
    -0.01730069f, 0.07849652f, 0.05118487f, 0.16837975f, 0.09243948f, 0.13882324f, -0.06241724f, -0.14666997f, 
    0.11836288f, 0.03883582f, -0.08874958f, -0.12403505f, -0.02880190f, 0.02233703f, -0.00684663f, 0.05960573f, 
    -0.11833274f, -0.13142429f, -0.13744590f, -0.33234656f, 0.22920707f, -0.18644015f, 0.03881441f, 0.01865601f, 
    -0.03175787f, -0.06783769f, 0.01115390f, 0.15763940f, 0.23688026f, 0.26714122f, -0.00231008f, -0.15213309f, 
    0.04179033f, 0.02586373f, -0.00608657f, 0.16662048f, 0.03689088f, 0.12979808f, 0.02465450f, 0.04036761f, 
    -0.04077233f, -0.29454720f, 0.27032775f, -0.13942687f, -0.50654447f, 0.31112790f, 0.40222484f, 0.00249478f, 
    -0.10307493f, -0.01897687f, -0.09509788f, -0.05591748f, -0.11657074f, 0.16510157f, -0.05664342f, 0.10289512f, 
    -0.18461102f, -1.24644136f, -0.67292029f, -0.59180725f, -0.18167983f, -0.09903029f, 0.12761466f, -0.18911751f, 
    -0.03573134f, -0.01677769f, 0.01965597f, 0.06925997f, -0.26507652f, 0.05714234f, -0.45719516f, 0.03971051f, 
    -0.10439347f, 0.17320779f, 0.17270908f, 0.05282905f, 0.08571599f, 0.03854055f, 0.02000967f, 0.08653597f, 
    0.17514834f, 0.11573095f, -0.12774055f, 0.09325279f, -0.00599580f, 0.13173433f, -0.06858478f, 0.03086679f, 
    0.14292334f, 0.32801229f, 0.33661270f, -0.00673762f, -0.11574049f, 0.17332840f, -0.00036612f, -0.52391750f, 
    0.04386878f, -0.09955224f, -0.05941771f, -0.02868817f, 0.00058908f, 0.07296358f, -0.24005897f, 0.36155117f, 
    -0.07325094f, -0.12471034f, 0.14007369f, -0.20502427f, -0.02712694f, -0.46694207f, 0.02160286f, 0.05234633f, 
    -0.08163061f, 0.08813609f, -0.09518588f, -0.12272839f, -0.26133534f, -0.52846128f, -0.09709698f, -0.35365379f, 
    0.12676573f, 0.27444693f, 0.27537975f, -0.17382012f, 0.04857105f, 0.04888354f, 0.04740526f, 0.05693527f, 
    -0.50916213f, 0.22853772f, 0.18817049f, -0.19144325f, -0.12746377f, -0.09621270f, -0.17348228f, -0.03579239f, 
    0.01230288f, 0.11695541f, -0.04484897f, 0.00792048f, -0.68149233f, 0.56272948f, 0.33655038f, -0.06065690f, 
    -0.15460162f, -0.23946096f, -0.16408411f, -0.11945064f, -0.15973669f, 0.05064296f, -0.08341657f, 0.06617373f, 
    -0.74363452f, -0.04582686f, 0.74470508f, 0.29526505f, 0.03596832f, -0.11968467f, 0.19138272f, -0.01180564f, 
    0.02948261f, 0.11216577f, -0.03305082f, -0.07389604f, -0.21363074f, 0.02573429f, 0.30139750f, -0.12792845f, 
    -0.00130842f, 0.00690457f, -0.14701161f, 0.03752278f, 0.10203850f, 0.12536271f, 0.07777612f, 0.05003739f, 
    -0.04007332f, 0.01418983f, -0.24408974f, -0.10212748f, -0.17039376f, 0.05273977f, -0.14693236f, 0.11719004f, 
    -0.09202535f, -0.05643176f, -0.07420194f, -0.12737019f, 0.74034125f, 0.10845909f, 0.08510705f, -0.61384118f, 
    0.02810739f, -0.02449321f, 0.19495510f, -0.00308616f, 0.11053325f, 0.10789280f, 0.00713139f, -0.03502605f, 
    -0.19820289f, -0.21414828f, -0.09231920f, 0.27755395f, 0.01949664f, 0.06490150f, -0.08963021f, 0.06102993f, 
    -0.00147178f, 0.10261567f, 0.00776838f, -0.03195417f, -0.59821481f, -0.95901024f, -0.57634425f, 0.13174729f, 
    -0.10060842f, -0.13217668f, 0.09406117f, -0.15991426f, -0.10433637f, -0.04297942f, 0.09152667f, -0.03195870f, 
    0.13202389f, -0.08994056f, -0.38903886f, -0.12233026f, -0.09057888f, 0.24278282f, 0.15570608f, 0.10676503f, 
    -0.08701540f, 0.04103084f, 0.02622896f, 0.03574938f, 0.05057033f, 0.12153031f, 0.34136164f, 0.09839428f, 
    -0.05847922f, 0.06445596f, -0.13074119f, -0.00233795f, 0.05942275f, 0.11545558f, 0.20236297f, 0.15257764f, 
    -0.13960102f, -0.49755999f, -0.38129580f, 0.31454170f, -0.02121894f, 0.07356822f, 0.02532369f, 0.16852203f, 
    0.09781188f, -0.00401432f, -0.03839208f, -0.02345310f, -0.14986302f, -0.33232641f, -0.07403518f, -0.02160965f, 
    -0.03507237f, 0.01494519f, 0.05489184f, 0.02302902f, 0.18889761f, 0.18146008f, 0.08917098f, -0.13900410f, 
    -0.14978923f, 0.08908936f, -0.06200302f, -0.22211237f, -0.00406917f, -0.18154380f, -0.04219861f, 0.03561239f, 
    0.05769634f, -0.01938853f, 0.04133488f, -0.08857827f, -0.08626749f, 0.28524330f, -0.49795854f, 0.04060851f, 
    -0.05986722f, 0.03497937f, 0.07436841f, -0.01441829f, -0.13628510f, 0.07083116f, -0.06795377f, 0.01634169f, 
    -0.18300577f, -0.28744611f, 0.18682228f, -0.13900390f, -0.19018486f, 0.00657527f, 0.05539119f, -0.01598425f, 
    -0.05634243f, 0.05615433f, -0.08127234f, -0.12188887f, -0.77894938f, -0.31734201f, 0.31128663f, 0.22333756f, 
    0.06838012f, -0.04582716f, 0.20793369f, 0.13378316f, 0.00939862f, -0.11590327f, 0.01482562f, -0.06465567f, 
    0.16995689f, 0.10746440f, -0.13223979f, 0.03646039f, 0.12380879f, -0.05054675f, 0.05980927f, 0.01957045f, 
    0.00132857f, 0.13066383f, -0.04363082f, -0.01753226f, -0.70541292f, 0.02728351f, 0.77603626f, 0.21522152f, 
    -0.00830566f, -0.15923329f, -0.06531031f, 0.15636891f, -0.23401095f, -0.09126431f, -0.06133468f, 0.04520022f, 
    -0.22894955f, -0.07029360f, -0.08553146f, 0.18292756f, 0.00629130f, -0.03385969f, 0.05041013f, -0.12238891f, 
    -0.06049582f, -0.09710992f, 0.10273300f, -0.00812635f, 0.17062470f, -0.79025984f, 0.45280984f, 0.40367174f, 
    -0.11151247f, 0.06124533f, -0.26920024f, -0.03881073f, -0.05335097f, -0.01151880f, 0.01544359f, -0.05533959f, 
    0.09058852f, 0.07663795f, 0.09274969f, -0.14412725f, -0.04866064f, -0.03971550f, -0.01099333f, -0.11546252f, 
    -0.15321966f, -0.21197681f, -0.12437379f, -0.14234924f, -0.19886625f, 0.20408455f, -0.46429455f, 0.46756166f, 
    0.20783776f, 0.03116256f, 0.22627017f, -0.28131500f, -0.01206912f, -0.11010501f, -0.07638489f, 0.06234470f, 
    0.05124334f, 0.05862643f, 0.06404079f, 0.02152674f, -0.02914872f, 0.00507775f, -0.05479794f, -0.00618587f, 
    0.05901810f, -0.19254623f, -0.08239977f, -0.03569131f, 0.52301878f, -0.12026642f, 0.08547068f, -0.24046445f, 
    0.04245988f, 0.04597971f, -0.04144789f, -0.13630001f, -0.24345833f, -0.03567768f, -0.22603026f, -0.32554162f, 
    0.10137149f, -0.13733181f, 0.01050772f, -0.33481464f, 0.05928037f, 0.03947981f, -0.01756319f, -0.03403597f, 
    0.08456185f, 0.02280917f, -0.20539762f, -0.26511151f, 0.57051867f, 0.08286195f, -0.26316106f, -0.49893016f, 
    -0.09861374f, -0.05410202f, -0.09277917f, 0.04523082f, 0.02421257f, 0.12711452f, 0.00744214f, 0.06250829f, 
    -0.05341606f, -0.47800082f, -0.32109585f, -0.59215117f, 0.08985501f, 0.06451087f, 0.06223698f, 0.10363162f, 
    0.06404545f, 0.04836067f, -0.07599059f, -0.08520763f, -0.54391325f, -0.29516587f, -0.47317639f, -0.30192250f, 
    0.07902091f, 0.06505681f, 0.33607066f, 0.04940055f, 0.03972902f, -0.01633561f, -0.09495458f, 0.02175373f, 
    0.00785750f, 0.07141028f, 0.18463214f, -0.05939344f, 0.01454606f, 0.05261373f, 0.01214945f, -0.19265392f, 
    0.04891979f, 0.06512140f, 0.14204696f, -0.20613784f, 0.16072941f, -0.08142275f, -0.24956012f, -0.19285761f, 
    0.02012665f, 0.08586678f, 0.02320713f, -0.00848529f, -0.01837522f, -0.01059471f, -0.23393533f, -0.36770019f, 
    -0.23445876f, 0.39522263f, -0.11872561f, 0.26600239f, -0.33205348f, 0.20609491f, 0.09102588f, 0.14668827f, 
    0.00631496f, 0.05187105f, 0.08190307f, 0.10312616f, -0.25240430f, 0.34296834f, 0.03213061f, -0.06045448f, 
    -0.00099431f, -0.23365243f, 0.04813932f, 0.06408706f, -0.00437023f, 0.08581205f, 0.12490833f, 0.14167081f, 
    0.25403199f, -0.17464767f, -0.04386954f, -0.20450896f, 0.07344595f, 0.07531502f, 0.00972264f, 0.02673885f, 
    -0.03849857f, 0.16213626f, 0.19024564f, 0.04379556f, -0.92028660f, -0.56306463f, 0.38000774f, -0.17169875f, 
    0.05679226f, -0.19952691f, 0.04345743f, -0.10195501f, -0.08957468f, -0.04945083f, -0.05261850f, 0.08262436f, 
    0.33590257f, -0.74963826f, -0.43584701f, -0.71752840f, -0.08091677f, -0.04324078f, -0.19012754f, 0.22174171f, 
    0.12268826f, 0.05816962f, 0.03808144f, 0.07805493f, 0.36685663f, 0.20084007f, -0.27516827f, -0.47262278f, 
    0.07217628f, 0.06402972f, -0.02328713f, -0.01897205f, -0.00612347f, 0.15325765f, -0.02761154f, -0.26175505f, 
    -0.01428373f, -0.11884677f, 0.10453787f, 0.04251710f, -0.03431623f, 0.06210611f, -0.01397272f, -0.01118874f, 
    0.04621724f, -0.02436285f, -0.08218753f, -0.07941213f, -0.22324519f, 0.20388362f, -0.15760773f, 0.10804321f, 
    0.01487697f, -0.03488031f, 0.06491921f, 0.03587003f, 0.00417462f, -0.01969941f, 0.09710079f, -0.02344832f, 
    0.29534331f, -0.06984589f, 0.17056602f, -0.18330282f, -0.12322296f, 0.07344318f, 0.00795812f, 0.13788892f, 
    0.08545031f, 0.14090164f, 0.04278718f, -0.03772340f, -0.44909385f, -0.42854014f, -0.33009684f, -0.51689631f, 
    0.01276321f, 0.10197444f, -0.11496424f, 0.25365692f, 0.04419384f, -0.06122441f, -0.04219730f, 0.09058064f, 
    -0.04494905f, 0.07366591f, -0.02917323f, -0.13637832f, -0.08986595f, 0.04762702f, -0.14827956f, -0.04470736f, 
    0.02062997f, 0.09576757f, 0.00502454f, 0.05195352f, 0.36643422f, -0.14147626f, -0.16506067f, -0.22484447f, 
    0.01848017f, 0.09518927f, -0.14196886f, 0.01332645f, 0.00114291f, -0.10517386f, -0.03556306f, -0.02346940f, 
    0.26864368f, -0.22803150f, -0.33800235f, -0.20984654f, -0.02928292f, -0.09949039f, 0.07948850f, -0.02873653f, 
    -0.05272364f, -0.08455145f, -0.06976257f, -0.06856691f, -0.20408124f, -0.15088806f, -0.17881468f, -0.04577566f, 
    -0.00555051f, 0.09818976f, -0.04305702f, 0.02097136f, -0.34429163f, -0.08592363f, -0.52853012f, -0.62642086f, 
    -0.41180903f, 0.08653544f, 0.06108160f, 0.08667283f, 0.01561725f, 0.01778223f, -0.21737722f, -0.02243918f, 
    0.06911177f, 0.00164956f, 0.00811457f, 0.16407631f, 0.15661956f, 0.01299046f, -0.03479153f, 0.16177593f, 
    -0.09734747f, 0.07408892f, 0.10567672f, 0.13292232f, 0.18924072f, -0.02220855f, 0.18841545f, -0.08308043f, 
    -0.21211830f, -0.06673496f, 0.01267282f, 0.36786717f, 0.06200939f, 0.03735158f, 0.04573302f, -0.11904139f, 
    0.02692367f, 0.27116343f, -0.05995394f, 0.26866436f, 0.24992397f, 0.10843474f, -0.08656850f, -0.00976582f, 
    -0.00872886f, 0.09737953f, -0.07160014f, -0.12779567f, 0.00485581f, -0.01175756f, -0.07064266f, -0.02624578f, 
    0.03658423f, -0.05517878f, -0.09093550f, -0.04897937f, -0.10358394f, 0.06307967f, -0.03280153f, -0.01716386f, 
    0.09578269f, 0.14687282f, 0.17500663f, 0.17513551f, 0.00696886f, -0.38786101f, -0.57208544f, -0.62923527f, 
    0.00588507f, -0.22773141f, 0.07579135f, -0.15572084f, 0.20117615f, 0.04221684f, 0.07243975f, -0.03140194f, 
    -0.36130810f, -0.21278870f, 0.31487042f, 0.08785862f, 0.00729903f, -0.01396415f, -0.09852043f, -0.01893614f, 
    0.16626641f, 0.12449107f, -0.14544386f, -0.15215048f, 0.22769037f, -0.30862457f, -0.39874294f, -0.16881029f, 
    0.42019650f, 0.11287730f, 0.04729235f, 0.29935303f, 0.24104694f, 0.16936922f, 0.05769742f, 0.28683636f, 
    -0.11874992f, -0.09531938f, 0.09123094f, -0.19618648f, -0.00260033f, 0.02895143f, 0.08158670f, -0.05411032f, 
    0.14390685f, 0.04345853f, 0.06280313f, 0.09254776f, 0.14217471f, -0.04663983f, -0.22903940f, 0.08040354f, 
    -0.16865847f, 0.24738511f, -0.05797299f, 0.07280777f, -0.03974888f, 0.13107069f, -0.07154813f, 0.02684394f, 
    -0.33691737f, 0.06843381f, 0.14132649f, -0.08346435f, -0.03376568f, -0.08441579f, 0.00443486f, -0.06513364f, 
    -0.14274742f, -0.00660298f, 0.00131759f, 0.05437183f, 0.47193295f, -0.10511219f, -0.19754910f, -0.31134459f, 
    0.09023128f, -0.06381532f, 0.11500757f, -0.14561604f, 0.08693019f, 0.04991009f, 0.04540904f, -0.03947724f, 
    0.01567881f, -0.14934219f, 0.14983550f, -0.34103963f, -0.07834762f, -0.00847515f, 0.03285808f, 0.05929739f, 
    0.01696970f, -0.14695564f, 0.08088551f, 0.06361906f, -0.25611258f, -0.41579151f, -0.31862164f, -0.16491076f, 
    -0.10379868f, -0.00624104f, 0.11292005f, 0.05704264f, 0.17836554f, 0.09582904f, -0.09095675f, -0.06209582f, 
    0.34626126f, -0.21272922f, -0.71878433f, -0.08530527f, -0.07587065f, 0.12637258f, 0.06839129f, 0.14842375f, 
    0.03480238f, -0.15921055f, -0.16747116f, -0.03752366f, 0.20396648f, -0.45093152f, -0.44974738f, -0.00194203f, 
    0.12815820f, 0.09066774f, 0.10968777f, -0.05820411f, -0.05446427f, -0.13320412f, -0.12479604f, -0.24623138f, 
    -0.46256191f, -0.10207433f, 0.10504870f, 0.04545665f, -0.06798583f, 0.09209789f, 0.25075209f, 0.03542550f, 
    -0.36495200f, -0.12321878f, -0.52223682f, -0.38056040f, -0.04964057f, 0.01925888f, -0.11607603f, -0.01126419f, 
    -0.05112223f, -0.12887250f, 0.08968731f, -0.09610576f, -0.07126842f, 0.03640964f, -0.16272891f, 0.20743276f, 
    -0.42986056f, -0.05343853f, -0.06058536f, 0.20778930f, 0.16743003f, 0.04637098f, 0.06792400f, 0.12117660f, 
    0.04297352f, 0.04173921f, 0.14872497f, 0.23568675f, -0.66439098f, 0.00470873f, 0.33357683f, 0.20515661f, 
    -0.12577778f, 0.11685541f, -0.15921164f, -0.28533292f, -0.06002166f, -0.17679007f, -0.10330446f, -0.03285335f, 
    -0.03921200f, -0.25178856f, -0.18309896f, -0.10276533f, -0.21262281f, 0.00018032f, 0.02658518f, 0.13568984f, 
    0.11130430f, -0.02586738f, -0.07435253f, -0.08954564f, 0.13136463f, -0.78975362f, -0.40814042f, -0.24969620f, 
    -0.06701573f, 0.02317183f, 0.24743268f, 0.06540205f, -0.08422220f, 0.06591790f, 0.26774868f, 0.01238685f, 
    -0.29100493f, -0.74465156f, -0.67571706f, 0.61018515f, 0.06406913f, 0.22110966f, 0.17458177f, 0.08465977f, 
    -0.25978559f, -0.06752937f, -0.12984167f, -0.11641668f, -0.07257688f, -0.17782983f, -0.43084306f, -0.61609179f, 
    -0.14870305f, -0.01164875f, 0.09833321f, 0.01879800f, 0.08317424f, -0.01513845f, 0.07648875f, 0.07782626f, 
    0.21151513f, 0.07780078f, -0.02241955f, -0.16348657f, 0.28369758f, -0.05661027f, -0.01588439f, -0.07285120f, 
    0.20505178f, 0.22046827f, 0.27273825f, 0.22817869f, -1.17366540f, 0.17279923f, 0.33325601f, 0.28444484f, 
    0.11927546f, -0.00449619f, -0.28771237f, 0.11099751f, -0.17959528f, -0.14333904f, 0.14392923f, -0.02612339f, 
    -0.01625848f, -0.13309281f, -0.15639269f, -0.00764057f, 0.13611862f, 0.04511783f, 0.05211992f, 0.08053411f, 
    0.08827619f, 0.09399823f, 0.22036047f, 0.21230942f, -0.15847504f, -0.37143445f, -0.36209583f, 0.22580369f, 
    -0.05241105f, 0.01330179f, 0.02637550f, 0.06740318f, 0.11420719f, 0.04394213f, 0.06159459f, 0.05214798f, 
    0.30845624f, 0.31381375f, 0.04063234f, -0.02695450f, 0.20813957f, -0.09210066f, 0.02560534f, 0.05716980f, 
    -0.13265792f, 0.01372644f, 0.11187588f, -0.07941237f, -0.15068217f, 0.18932930f, -0.06186412f, 0.25501889f, 
    -0.06753213f, 0.19834459f, -0.01379607f, 0.08240679f, -0.00804855f, -0.06227192f, 0.14978537f, -0.20787230f, 
    -0.73027700f, -0.13834390f, 0.18077619f, 0.13395055f, -0.02853173f, -0.29752892f, 0.07928743f, 0.14503753f, 
    0.02165906f, 0.02643029f, 0.10539547f, 0.00434932f, 0.00955522f, 0.18845187f, 0.54825222f, -0.11925992f, 
    0.00796856f, -0.17611958f, -0.04181706f, 0.06120688f, 0.05907406f, 0.18906884f, 0.07548971f, 0.11872856f, 
    0.12870203f, -0.39483216f, -0.34046710f, 0.12232713f, 0.16902603f, 0.03220323f, 0.08966727f, 0.09824812f, 
    0.06215184f, -0.20831320f, -0.12286148f, -0.18546201f, -0.08132859f, 0.11258315f, -0.06845288f, -0.16235793f, 
    0.22311504f, -0.14231059f, -0.08942558f, -0.00068566f, -0.12181352f, -0.19827865f, 0.19763108f, 0.04335509f, 
    0.22538321f, 0.09629018f, 0.76156306f, -0.88345087f, -0.06975052f, -0.28895193f, -0.09412129f, 0.12766960f, 
    -0.21430607f, 0.13563898f, 0.08961540f, -0.06203989f, 0.26059467f, -0.27564877f, -0.42502043f, -0.07274887f, 
    0.01687951f, -0.02850732f, 0.27215821f, 0.36181772f, -0.01004967f, 0.07270606f, 0.07804440f, -0.06849809f, 
    -0.37722036f, 0.20155236f, -0.07942521f, 0.05003851f, 0.06490170f, -0.05490855f, -0.13339545f, 0.14539930f, 
    -0.03405609f, -0.10870284f, -0.17042641f, -0.18414728f, -0.44347653f, -0.28580147f, 0.25002033f, -0.31080782f, 
    -0.43065965f, 0.21741568f, 0.14762641f, 0.08748560f, 0.08425806f, 0.05237924f, 0.06614120f, 0.03038040f, 
    0.05439372f, -0.08634287f, -0.16517045f, -0.05722760f, 0.07443614f, -0.13408525f, 0.06699748f, -0.04504809f, 
    -0.05942494f, 0.05833267f, 0.05723801f, 0.06675476f, 0.13230580f, 0.17280689f, 0.14515325f, 0.25193554f, 
    -0.07111342f, -0.08862870f, 0.07992988f, -0.09341584f, 0.07987344f, 0.12885109f, -0.14547315f, -0.08502175f, 
    -0.03919049f, -0.15653589f, 0.15630974f, 0.09860857f, 0.03935878f, 0.14370239f, 0.04618691f, -0.00734875f, 
    0.15207066f, -0.00491636f, 0.07030764f, -0.13039829f, -0.79799938f, 0.37361366f, -0.00537326f, -0.47809270f, 
    0.01968567f, -0.18766657f, -0.15617633f, -0.16741356f, 0.07028298f, 0.03047812f, -0.01252287f, 0.05587572f, 
    -0.12281878f, -0.14707199f, -0.10553749f, -0.05339907f, 0.08345781f, 0.14487094f, 0.08051280f, 0.02575808f, 
    0.22433220f, 0.13583843f, 0.11251207f, 0.07535840f, -0.33182767f, -0.13726586f, 0.26132190f, 0.36187902f, 
    0.10153078f, 0.11958607f, -0.06250344f, -0.48418808f, 0.16522244f, 0.08037913f, -0.01204170f, 0.00029164f, 
    0.07325458f, -0.23439275f, 0.17428392f, 0.10054317f, 0.03240581f, 0.02920417f, -0.18550418f, -0.15454054f, 
    -0.12677602f, -0.10163401f, 0.14995559f, -0.09905765f, 0.39439514f, 0.24167214f, 0.32430092f, 0.46340609f, 
    0.12400354f, -0.06064050f, -0.26165590f, -0.15451428f, 0.04530227f, -0.03401212f, 0.00181308f, 0.11425475f, 
    0.06484866f, 0.11895125f, -0.31710187f, 0.51563561f, -0.13617961f, 0.08042666f, -0.08920217f, 0.06898001f, 
    0.17460291f, 0.00530933f, 0.01147432f, 0.02924166f, 0.03810443f, -0.02410215f, 0.29176518f, 0.03220484f, 
    -0.06587378f, -0.10294975f, 0.12399592f, -0.00690109f, 0.06226793f, 0.11183048f, 0.13705385f, 0.13699481f, 
    -0.14795001f, -0.13910145f, 0.27861521f, -0.51411688f, 0.02091206f, 0.12477574f, 0.07780458f, 0.24617879f, 
    0.12201067f, 0.11553353f, -0.00609381f, -0.08206644f, 0.06075311f, -0.16124620f, 0.13536566f, 0.55795205f, 
    0.07095352f, -0.09513167f, 0.01751855f, -0.02815318f, 0.06361689f, -0.14316685f, -0.33857074f, 0.08365270f, 
    -0.30272502f, 0.36737156f, -0.44804275f, -0.23589191f, -0.18113080f, -0.19449288f, 0.25315011f, 0.13441347f, 
    0.07106961f, -0.19796447f, -0.19510143f, -0.29354736f, 0.01006843f, -0.04420798f, -0.34411925f, -0.28056267f, 
    0.17999737f, -0.13236466f, 0.22086133f, 0.16742028f, 0.00107129f, -0.05708716f, -0.12818943f, 0.01647851f, 
    0.18243535f, -0.14703643f, 0.28238893f, 0.37639418f, 0.01113488f, -0.09803542f, -0.24630827f, -0.11516888f, 
    0.00989411f, -0.05075461f, -0.07546530f, -0.01827795f, 0.09076459f, 0.24648274f, 0.57058728f, -0.41010955f, 
    0.02468200f, -0.41088408f, -0.15445040f, -0.04660857f, -0.17715783f, 0.02635512f, -0.04920083f, 0.11321215f, 
    -0.35598585f, -0.07165585f, -0.23925892f, -0.88163733f, -0.58299935f, 0.06964938f, -0.00014448f, -0.14243729f, 
    0.22513643f, -0.01032227f, 0.06150230f, -0.01526485f, -0.26325613f, 0.23811473f, 0.20941406f, 0.74513942f, 
    0.13356549f, 0.11396875f, -0.34230593f, -0.10536153f, -0.09228852f, -0.06154824f, 0.17384087f, -0.00108748f, 
    0.12235890f, -0.14624168f, -0.36687049f, 0.06267143f, 0.34672272f, -0.16469161f, 0.05311435f, 0.04627703f, 
    0.05037516f, -0.11422914f, -0.09290722f, -0.19492765f, -0.41191503f, 0.44108376f, -0.65423477f, -0.19651684f, 
    -0.05097836f, -0.05868141f, 0.26516151f, -0.02116459f, 0.06393673f, 0.02759442f, -0.07215126f, 0.04844820f, 
    0.20562388f, -0.09028196f, 0.05331515f, 0.04117936f, -0.00297532f, 0.01986458f, -0.32788047f, -0.19398831f, 
    -0.16339344f, -0.17262694f, -0.18160693f, 0.01163028f, -0.15348287f, -0.04299008f, -0.19131325f, -0.24388950f, 
    -0.08289885f, 0.03749156f, -0.11796448f, -0.00450882f, 0.13744050f, -0.02570613f, 0.00794008f, -0.07903830f, 
    -0.33575922f, 0.24206451f, -0.95571178f, 0.05428211f, 0.09248057f, 0.02808307f, 0.25024930f, -0.11372554f, 
    0.05293845f, -0.06942154f, -0.02899818f, 0.01062344f, -0.24310254f, 0.27452755f, 0.04782546f, 0.05196227f, 
    -0.13408321f, -0.13753498f, -0.13540597f, -0.19669102f, -0.02874530f, -0.00497471f, -0.14313848f, 0.19382624f, 
    -0.27487314f, -0.13627672f, -0.40579018f, 0.02077609f, -0.09493314f, 0.01364370f, -0.26626533f, 0.05600351f, 
    0.03221928f, 0.14142238f, -0.08689678f, 0.02082613f, -0.17009485f, -0.04024309f, -0.16145152f, -0.00129561f, 
    0.11376109f, -0.14451882f, 0.01506006f, 0.13570009f, -0.35430667f, -0.64383507f, -0.53465205f, -0.23950851f, 
    -0.50946164f, 0.21490164f, -0.05948428f, -0.06875934f, -0.14253561f, -0.09054969f, -0.30832759f, 0.34436673f, 
    -0.13053334f, 0.04408848f, 0.10977831f, 0.05592823f, -0.07479542f, -0.10126646f, 0.39272997f, -0.06795118f, 
    -0.14495736f, 0.09693266f, -0.17315586f, 0.09057201f, 0.15842520f, 0.10224245f, 0.21149674f, -0.02076323f, 
    -0.38510150f, 0.15097572f, -0.22782159f, 0.60418886f, -0.03236517f, -0.11762268f, -0.09510931f, 0.20671611f, 
    -0.04082006f, -0.04209616f, -0.11240367f, -0.34103200f, -0.38587368f, -0.17310765f, -0.01942948f, -0.11244219f, 
    0.09711188f, 0.12141092f, -0.11585568f, -0.12710896f, -0.05617043f, 0.12965052f, 0.02748615f, -0.14421231f, 
    0.24507211f, -0.03684093f, 0.38720977f, 0.06307938f, -0.46161422f, 0.06450249f, 0.07571342f, 0.24177784f, 
    0.12841325f, -0.16154183f, 0.28357312f, 0.32819650f, 0.04088552f, -0.37245640f, -0.09982324f, 0.08161414f, 
    -0.13442713f, 0.02697800f, 0.13011609f, 0.13110194f, 0.30197352f, 0.11229863f, -0.04815393f, 0.01209739f, 
    -0.16663828f, 0.46887389f, -0.18388468f, -0.04526040f, 0.10200734f, -0.04358258f, -0.23360929f, 0.17990141f, 
    -0.14862679f, -0.27405316f, -0.25245434f, -0.31275186f, -0.25052765f, 0.27999508f, -0.11330163f, -0.11783336f, 
    -0.11865371f, 0.24471848f, 0.25356367f, 0.06045187f, -0.11525664f, 0.06240038f, 0.03715950f, 0.07957520f, 
    -0.32631722f, -0.11931741f, -0.18893361f, -0.22167900f, -0.11755201f, -0.10683056f, -0.16924800f, 0.00304168f, 
    -0.04274356f, 0.14446922f, -0.02303024f, -0.03355409f, 0.59667695f, -0.59269261f, 0.59596199f, 0.20353419f, 
    -0.18861195f, 0.15353328f, 0.06794170f, 0.18010865f, -0.23323607f, -0.06725120f, -0.16150688f, -0.10823087f, 
    0.08359952f, -0.23015289f, -0.26993951f, -0.38437217f, -0.28534195f, -0.21818741f, -0.06340407f, 0.01214105f, 
    -0.23590556f, -0.01567722f, -0.19699162f, -0.13040613f, -0.53490955f, -0.08221132f, -0.35927969f, -0.18891844f, 
    0.00261526f, 0.14328000f, 0.01206167f, 0.07935281f, -0.08771432f, -0.29357305f, 0.06219154f, -0.24210379f, 
    -0.01406810f, 0.37471783f, -0.05059446f, 0.23375849f, -0.15224323f, 0.26696724f, 0.06017894f, -0.06557363f, 
    -0.01481587f, 0.14596714f, -0.03619630f, 0.03177983f, -0.05847686f, 0.18309367f, -0.16653568f, -0.02878476f, 
    0.08341186f, -0.20931064f, -0.02136313f, -0.10542815f, -0.10858507f, 0.06104334f, 0.13780445f, -0.08632150f, 
    -0.31886849f, 0.37563556f, -0.18872145f, 0.19350851f, -0.08778818f, -0.10488281f, -0.04538944f, 0.23455949f, 
    -0.12479800f, 0.17331453f, -0.08378349f, -0.13198648f, -0.07818188f, 0.03662392f, -0.16925380f, 0.06046059f, 
    -0.22292082f, -0.02694983f, -0.10930436f, -0.03806356f, 0.13168705f, 0.14316191f, -0.14081642f, -0.31650892f, 
    -0.13631497f, 0.24323691f, 0.25262189f, 0.19746512f, 0.01145804f, -0.07695833f, -0.01308608f, 0.14629035f, 
    -0.28148243f, -0.15846327f, -0.23627181f, -0.04801989f, -0.23177405f, 0.21887571f, 0.18381564f, -0.05644001f, 
    -0.22010966f, 0.02717745f, 0.04905776f, 0.09012122f, 0.09084370f, -0.06334420f, 0.19138569f, 0.23975082f, 
    0.44557717f, -0.34379321f, 0.51257724f, 0.21471757f, -0.02814643f, 0.10641026f, 0.01726166f, -0.03434870f, 
    0.11440425f, -0.04387841f, 0.17766047f, 0.39076480f, 0.00436632f, -0.40155455f, 0.08173495f, -0.14565030f, 
    0.05665607f, -0.01690802f, -0.09791891f, -0.15064579f, -0.21188268f, -0.03279143f, -0.10362668f, -0.14079145f, 
    -0.49423245f, 0.27032819f, -0.03007273f, -0.03417084f, 0.06254307f, 0.11560876f, 0.16567476f, 0.07135923f, 
    -0.08891447f, 0.02344643f, 0.06004658f, 0.12144092f, 0.09550545f, -0.04020078f, 0.05694785f, 0.22309791f, 
    -0.09723102f, 0.11042424f, 0.03537982f, -0.01222967f, 0.02050359f, -0.08133850f, -0.00338342f, -0.02064993f, 
    0.16332650f, 0.01237595f, 0.06851564f, -0.11711852f, 0.27941692f, -0.31965262f, -0.04720179f, 0.11171365f, 
    -0.23465891f, 0.07597304f, 0.00907610f, -0.15291263f, -0.34164149f, 0.60026860f, 0.02255055f, -0.31616592f, 
    -0.00200170f, -0.07461210f, 0.08114702f, 0.03940403f, -0.08518733f, 0.16563901f, -0.15977502f, 0.17085896f, 
    -0.58815414f, 0.38648057f, -0.18445730f, -0.05056130f, 0.00877089f, 0.10367209f, 0.21309043f, 0.02016963f, 
    -0.19945855f, 0.14945485f, -0.05790063f, 0.00251559f, 0.22180900f, -0.05267485f, 0.09029180f, 0.35228205f, 
    -0.03365332f, -0.10969865f, 0.32902324f, -0.06821773f, -0.04095930f, 0.06500185f, 0.00278014f, -0.06219969f, 
    -0.41955802f, 0.22948566f, -0.01945836f, -0.04122958f, 0.04119181f, 0.18494932f, -0.07623900f, -0.13803662f, 
    -0.00719391f, 0.16766550f, 0.34282508f, 0.24160402f, -0.05681624f, -0.38251054f, 0.02560418f, -0.05405302f, 
    -0.03667864f, 0.03162866f, 0.00054868f, 0.07813361f, 0.04890703f, -0.01704991f, -0.09236298f, -0.19958276f, 
    -0.17764476f, 0.23963311f, -0.33689600f, -0.11520867f, -0.51635909f, -0.15965144f, 0.15966177f, -0.10981753f, 
    -0.16621317f, 0.19167368f, -0.23232156f, -0.02042550f, 0.33455494f, 0.11196587f, 0.40938228f, -0.38178310f, 
    0.02615023f, -0.15708512f, 0.18007000f, 0.12393548f, -0.20031542f, -0.12362599f, -0.48634231f, -0.04092019f, 
    0.22752936f, -0.28332052f, 0.20896232f, -0.23616695f, 0.07829041f, -0.10232112f, 0.09362283f, -0.18156677f, 
    0.06302261f, 0.06333597f, -0.03391164f, -0.13509007f, -0.24905957f, -0.31389380f, -0.10573465f, 0.03173561f, 
    -0.07948685f, 0.05102075f, -0.03305707f, 0.05959066f, -0.03771837f, 0.20470990f, 0.16528268f, -0.03125987f, 
    0.53965974f, 0.36885116f, 0.22346874f, 0.24623832f, -0.14088878f, 0.02193791f, -0.08892727f, 0.22318187f, 
    -0.14263642f, 0.15449247f, 0.05784287f, -0.08666679f, 0.11179494f, 0.17547548f, 0.27926955f, 0.00650531f, 
    0.24925560f, 0.18169494f, 0.02333771f, 0.10852122f, -0.12691627f, 0.15841149f, -0.15772653f, -0.00295853f, 
    -0.54239601f, -0.31575707f, 0.19298385f, 0.35885397f, 0.08924012f, 0.14852569f, 0.06858354f, 0.17371759f, 
    -0.22344717f, -0.05615341f, 0.03435190f, -0.00430101f, -0.19597220f, -0.27251863f, 0.24294506f, 0.09620700f, 
    -0.31260777f, -0.19068488f, -0.13597882f, 0.00816131f, -0.05959680f, 0.03982053f, 0.09397822f, 0.16359265f, 
    -0.14131084f, -0.16654593f, 0.14885350f, -0.38646337f, 0.00356596f, 0.01845879f, -0.23085408f, -0.11035930f, 
    -0.13221994f, -0.19918491f, -0.02439038f, -0.52768999f, -0.65613699f, -0.69792002f, -0.12864271f, 0.34363043f, 
    -0.19333084f, -0.10417639f, -0.15459356f, -0.42187545f, 0.05184766f, 0.08571581f, 0.05928075f, -0.02592998f, 
    -0.08829068f, 0.07720753f, -0.02866128f, -0.00219913f, -0.13399309f, -0.07043299f, 0.13360225f, 0.07225396f, 
    -0.06127985f, 0.12285924f, 0.07353095f, 0.08002040f, -0.00678687f, -0.39337957f, -0.00856637f, 0.25082290f, 
    0.00255797f, -0.24702990f, -0.21220127f, -0.01260532f, -0.08389252f, 0.11058687f, 0.08124316f, -0.18547487f, 
    -0.27687407f, -0.01868349f, -0.17502792f, 0.00894216f, -0.02290900f, -0.00309593f, 0.13316871f, -0.02114939f, 
    0.07723730f, 0.01324883f, 0.06084441f, 0.16808702f, 0.04982337f, 0.19317278f, 0.27846450f, 0.30881193f, 
    -0.00704399f, 0.23714522f, -0.15186398f, 0.18184046f, -0.06094468f, -0.08851147f, 0.29745543f, -0.02445914f, 
    0.07686483f, 0.13814449f, -0.18241599f, -0.04272314f, -0.01618085f, 0.11871456f, 0.01495139f, 0.09840132f, 
    -0.07116119f, 0.06651985f, 0.14105670f, -0.09175398f, -0.46746698f, -0.02732160f, -0.40824994f, 0.00676622f, 
    -0.13106166f, 0.11354944f, 0.06192962f, 0.15927537f, 0.00765689f, 0.17010583f, 0.31493688f, -0.18937966f, 
    -0.28117734f, 0.55684787f, -0.45954773f, 0.19215308f, -0.03138186f, -0.09508549f, 0.18168466f, 0.15529290f, 
    0.06051867f, -0.03356154f, 0.12584023f, 0.08478784f, -0.40078562f, -0.28162575f, -0.02087645f, 0.14022115f, 
    0.09107546f, -0.04778710f, -0.01415504f, 0.02396133f, -0.24911512f, -0.02730110f, 0.03161954f, -0.04667816f, 
    0.24237908f, -0.02410285f, -0.05431723f, -0.18232787f, -0.15860116f, -0.02923015f, 0.23375274f, -0.10699090f, 
    -0.00313510f, 0.02268185f, 0.07909130f, -0.03817201f, -0.02984617f, -0.16940060f, 0.26407328f, -0.51369488f, 
    0.01307169f, -0.20331395f, -0.00509181f, 0.13790469f, 0.20280795f, 0.08045018f, 0.17062426f, 0.07210280f, 
    0.26607889f, -0.02773602f, -0.17571218f, 0.40906793f, 0.07785946f, 0.32747555f, 0.10249059f, 0.05987008f, 
    0.05566108f, 0.36964223f, 0.18576261f, -0.01717956f, 0.14009945f, -0.16746660f, -0.08118471f, 0.08204965f, 
    -0.03750921f, 0.03692057f, 0.03763258f, 0.05801180f, 0.07529495f, 0.07829487f, 0.06648103f, -0.32469767f, 
    -0.12057945f, -0.17654499f, 0.51100504f, -0.41796911f, 0.02713402f, 0.09794400f, -0.01446044f, -0.00749167f, 
    -0.12191413f, -0.05470382f, 0.00293008f, -0.35801226f, 0.56326789f, 0.31995162f, 0.28976092f, -0.16557047f, 
    -0.08648807f, 0.18284886f, -0.45952210f, 0.09296007f, -0.03400482f, 0.00924230f, 0.09014738f, -0.12702584f, 
    -0.28795806f, -0.32458735f, 0.09913193f, 0.31648847f, 0.09987859f, -0.01124080f, -0.08412060f, -0.22472809f, 
    -0.13430719f, -0.08187962f, -0.05424699f, -0.20231505f, -0.54758346f, -0.34476656f, -0.29376331f, 0.13726178f, 
    -0.15087394f, -0.13006151f, 0.00482345f, 0.23363975f, 0.07621876f, 0.02644169f, -0.06729583f, -0.25148818f, 
    -0.12017736f, 0.69538409f, -0.43870091f, -0.39236620f, -0.13410924f, -0.26048079f, 0.09826180f, -0.03437849f, 
    0.05057711f, -0.06779972f, -0.10466973f, -0.05667227f, -0.59974873f, -0.29677257f, -0.44509402f, 0.43149641f, 
    0.22276211f, -0.00049007f, -0.11231764f, -0.04565198f, -0.03471822f, -0.11102691f, 0.10959687f, 0.14869958f, 
    0.51066929f, -0.11543331f, -0.02574642f, 0.05692030f, 0.07050844f, 0.02664410f, -0.15523097f, 0.19631694f, 
    -0.12914342f, -0.11359318f, 0.08663321f, -0.20251355f, 0.02991462f, -0.64059246f, 0.83730870f, 0.23724854f, 
    0.05368191f, 0.14282523f, 0.07417906f, -0.04886406f, -0.23884395f, -0.02540771f, 0.12027779f, 0.16340157f, 
    -0.48386139f, 0.21649027f, -0.45469880f, 0.04735558f, 0.20478100f, -0.26469105f, 0.21707998f, -0.16416128f, 
    -0.07737531f, -0.28846565f, -0.37965351f, -0.05829226f, -0.05988122f, -0.03239297f, -0.26517248f, -0.32043484f, 
    -0.00407716f, 0.15002882f, 0.10628309f, -0.26190871f, -0.02833918f, -0.01898529f, -0.03994171f, 0.00253524f, 
    0.62219542f, -0.25690249f, 0.66086906f, 0.08225285f, 0.18730603f, 0.03598899f, 0.05307483f, 0.17386431f, 
    0.03087464f, -0.02415588f, 0.05303798f, 0.05345414f, 0.20176665f, -0.23131089f, -0.14595401f, -0.13073370f, 
    0.02874303f, 0.04852813f, 0.13999766f, -0.23145595f, 0.06319962f, 0.11617675f, 0.01280001f, 0.08375636f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15653330f, 0.06555659f, 0.07838745f, -0.09341130f, -0.10324158f, 0.08884045f, 0.02933810f, -0.18112426f, 
    0.14859343f, 0.00074772f, 0.00503007f, -0.01811795f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
