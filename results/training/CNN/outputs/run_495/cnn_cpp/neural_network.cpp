#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.10883707f, -0.23353931f, -0.38353145f, -0.17628071f, -0.34617722f, -0.22901393f, 0.84271795f, -0.48499319f, 
    0.43052024f, -0.08393382f, 0.31110027f, 0.17532866f, -0.10403737f, -0.00033765f, 0.05458649f, 0.13962992f, 
    0.23315807f, 0.24206617f, 0.08978570f, -0.02840190f, 0.35417789f, 0.32102612f, 0.26013243f, -0.05161295f, 
    -0.00367940f, -0.62412947f, -0.59097266f, 0.22224195f, 0.27416074f, 0.51169580f, -0.40213501f, 0.36015832f, 
    0.48246655f, -0.00658038f, -0.10205324f, -0.06559570f, -0.18974239f, 0.32037088f, 0.11095361f, 0.22286506f, 
    0.31816053f, -0.05100440f, -0.44744098f, -0.16656615f, 0.27156618f, -0.05266121f, 0.06352549f, 0.15762725f, 
    0.24241334f, 0.14638287f, 0.89751655f, 0.65876895f, 0.41852817f, 0.51975852f, 0.60050279f, -0.44950816f, 
    0.09868755f, 0.23621193f, 0.11697436f, -0.07365550f, 0.15896118f, -0.19190428f, -0.26478630f, -0.13076058f, 
    0.14359513f, -0.10165205f, -0.04165863f, 0.11709861f, 0.17843629f, 0.17420721f, 0.18544008f, -0.11528718f, 
    0.15817052f, 0.48725736f, 0.15588860f, -0.12818766f, 0.84655517f, -0.68598002f, -0.40970397f, 0.75783271f, 
    0.14809881f, -0.35321417f, -0.04018809f, -0.15513499f, 0.46212173f, 0.34092420f, -0.19982739f, -0.05273091f, 
    -0.15641232f, 0.15326543f, 0.07437377f, 0.34393156f, 0.18705977f, 0.41213256f, 0.06764551f, -0.18894298f, 
    -0.08625142f, -0.13092606f, -0.03129576f, 0.02651328f, 0.83056039f, -0.12469812f, 0.66461915f, -0.38961002f, 
    0.27919725f, 0.45517039f, -0.52759778f, 0.34174368f, 0.43650702f, 0.30027857f, -0.09260885f, -0.09027685f, 
    -0.22511201f, 0.00632005f, 0.19341327f, -0.26546061f, 0.01260426f, 0.03447410f, -0.01775413f, -0.35122931f, 
    0.26231039f, 0.09914497f, 0.02270097f, 0.03920211f, 0.17826171f, -0.49173373f, 0.71393782f, 0.16949463f, 
    -0.62106389f, -0.55481470f, 0.68408614f, 0.44805443f, -0.48509184f, -0.01523383f, -0.05588095f, 0.11357312f, 
    0.27674371f, 0.03940688f, 0.25814334f, 0.00548386f, -0.10922405f, -0.16575360f, -0.29458088f, -0.00139539f, 
    -0.35799888f, -0.04988138f, 0.11495953f, 0.24738331f, 0.06668707f, 0.34681034f, 0.25383812f, -0.46395877f, 
    -0.64077157f, -0.14696315f, -0.01724509f, -0.87138557f, 0.00849038f, -0.11639348f, 0.01774174f, 0.16149808f, 
    0.13279040f, 0.48742563f, 0.25387701f, 0.39394349f, 0.28092629f, -0.09052856f, -0.19906187f, -0.41196552f, 
    -0.15132904f, -0.01379407f, -0.12741007f, -0.03630292f, -0.06170087f, 0.19238040f, -0.20425685f, 0.09330976f, 
    0.51311761f, 0.75471461f, 0.42435989f, 0.52644867f, 0.33141005f, 0.24229951f, -0.02005462f, 0.16160771f, 
    -0.22902760f, 0.10409124f, -0.32823521f, -0.09541832f, 0.03636487f, -0.02258519f, -0.02142035f, -0.18199041f, 
    0.09865528f, -0.17200187f, -0.13087919f, -0.29470634f, -0.27284288f, -0.32388401f, 0.07259917f, -0.27456403f, 
    -0.13869892f, 0.57823759f, -0.69680983f, -0.80232435f, -0.20606036f, 0.33715728f, -0.16218109f, 0.33327916f, 
    0.52549422f, 0.28669313f, -0.10398775f, 0.03965341f, -0.24842155f, -0.03464611f, -0.38546586f, 0.22334519f, 
    0.03903138f, -0.14230530f, 0.06387632f, 0.23715045f, 0.19011582f, -0.13306615f, -0.34491503f, -0.21503551f, 
    -0.02440029f, -0.54889625f, -0.19182573f, -0.54702002f, 0.18984401f, 0.03132506f, 0.17164934f, 0.55653822f, 
    -0.59597993f, 0.20738418f, -0.64856714f, 0.03337406f, 0.14096382f, -0.26941672f, 0.28357729f, 0.32548568f, 
    0.09889489f, -0.33667639f, -0.06023140f, 0.02544983f, 0.11898834f, 0.18902576f, 0.25209442f, 0.14487338f, 
    0.06871542f, 0.15264761f, -0.81149995f, -0.37506285f, -0.37010396f, -0.54179460f, -0.43499172f, -0.03269586f, 
    -0.00645944f, 0.56391495f, 0.74110675f, -0.16839740f, 0.03203314f, 0.12803805f, 0.40864101f, 0.26109430f, 
    0.17327246f, -0.04772455f, -0.27436355f, 0.08930709f, -0.16470133f, 0.13212937f, 0.20113142f, -0.32020867f, 
    0.03620169f, -0.27396971f, -0.27771351f, 0.29181954f, 0.63552821f, 0.36428729f, -0.10435638f, -0.34030840f, 
    -0.30875000f, -0.25796413f, -0.76651472f, -0.61872727f, -0.28039145f, 0.18988073f, 0.27295777f, 0.35218620f, 
    0.24970050f, -0.21018365f, 0.24104597f, -0.35680360f, 0.32610860f, 0.21184170f, -0.34008896f, 0.01019560f, 
    -0.09054864f, -0.19531393f, -0.23633394f, 0.15753500f, -0.48060417f, -0.91347831f, -0.81075442f, -0.57704836f, 
    -0.02743337f, -0.32760048f, 0.44572088f, 0.45832172f, 0.29121548f, 0.49023515f, -0.08142342f, -0.26979348f, 
    -0.05680183f, -0.10273776f, -0.17953621f, -0.07039531f, 0.03168110f, 0.00226451f, -0.05232215f, -0.16776527f, 
    -0.08893716f, -0.00482015f, 0.06129058f, 0.11192542f, 0.05115227f, -0.26560053f, 0.68174219f, 0.07752202f, 
    -0.47942749f, 0.69546640f, 0.59403127f, -0.12462353f, -0.25843453f, -0.27517572f, -0.56042171f, -0.00185265f, 
    0.12700607f, 0.34727219f, 0.22145753f, 0.04911521f, 0.03217080f, 0.17507735f, 0.33129001f, 0.01449701f, 
    0.29617628f, 0.07833273f, -0.20577425f, -0.03088832f, 0.11448730f, 0.14853479f, 0.30725119f, 0.51516515f, 
    0.85227346f, -0.19085440f, -0.71690041f, 0.03625523f, -0.77870244f, 0.00005032f, -0.20892228f, 0.30779272f, 
    0.03998331f, 0.05612287f, -0.17526536f, 0.03903434f, 0.10600865f, 0.18910351f, 0.30124775f, -0.16539031f, 
    -0.13252179f, -0.24005318f, -0.17563114f, -0.15947320f, -0.21088852f, -0.18620427f, -0.16829753f, -0.53943568f, 
    0.12556797f, -0.52173024f, -0.48477662f, -0.67349064f, 0.17664190f, 0.23277099f, 0.37123588f, 0.31567359f, 
    0.24568477f, -0.25946441f, 0.06176548f, -0.32159400f, 0.12540843f, -0.20747684f, 0.30677557f, -0.16626477f, 
    0.27445725f, 0.16620722f, 0.27194399f, 0.10150934f, 0.11524045f, 0.19835144f, -0.16658892f, 0.37881511f, 
    -0.17551564f, -0.63527685f, -0.29354319f, 0.60331643f, 0.62742716f, 0.83177984f, 0.61756074f, -0.18021466f, 
    0.29709908f, -0.10599934f, 0.05383654f, 0.32786673f, 0.06360529f, 0.01607737f, -0.08241541f, -0.33160114f, 
    -0.03737835f, -0.34650493f, -0.43741977f, 0.07366678f, -0.07533213f, -0.20574848f, -0.03494395f, -0.04657755f, 
    -0.03123871f, 0.35453084f, 0.53670287f, -0.68778729f, -0.22036411f, -0.07715185f, -0.44886896f, -0.53226393f, 
    0.31094459f, -0.26411659f, -0.36778933f, -0.48933592f, -0.33631140f, 0.08204358f, -0.00154338f, -0.64294159f, 
    -0.22755711f, -0.01458548f, 0.19040129f, -0.22723193f, -0.21044266f, 0.17840657f, -0.07889146f, 0.09341817f, 
    -0.05918690f, 0.14132535f, -0.28064132f, -0.45072508f, -0.07313353f, -0.56205112f, -0.62987840f, -0.00937496f, 
    -0.68276316f, -0.32754639f, -0.45555711f, 0.24466980f, 0.43687624f, 0.03327608f, -0.19299467f, 0.09324536f, 
    0.04636365f, -0.20796661f, 0.08915170f, 0.06164737f, 0.00486552f, 0.50736654f, 0.25070721f, 0.22983374f, 
    -0.14590701f, 0.06780423f, 0.22877257f, 0.31507611f, 0.25216672f, 0.56980002f, 0.87123871f, 0.19973689f, 
    0.00929707f, 0.41622785f, 0.27680510f, 0.12005276f, 0.44248670f, -0.10913450f, -0.30845475f, -0.32070741f, 
    0.17802151f, -0.03050953f, -0.26649523f, 0.20434512f, 0.10411680f, 0.02099771f, -0.30979612f, 0.18251097f, 
    -0.30744472f, -0.46189368f, -0.19100519f, 0.10824702f, 1.07701612f, 0.81972092f, -0.02059383f, -0.70356095f, 
    -0.68715131f, -0.22776316f, 0.39463562f, -0.21605593f, 0.05979667f, 0.58953607f, 0.21817368f, 0.15972905f, 
    -0.00368253f, 0.14052033f, 0.17530525f, -0.08405687f, 0.13167936f, 0.05295163f, 0.00665044f, 0.28016576f, 
    0.23036203f, -0.03229544f, 0.05439357f, -0.09989915f, 0.24601200f, 0.35157904f, 0.21543439f, -0.66348362f, 
    -0.34798893f, -0.33645260f, 0.61561018f, -0.45474124f, -0.05799391f, 0.12515028f, -0.02500759f, -0.41817367f, 
    -0.32581028f, -0.38374567f, -0.07872427f, -0.01190111f, 0.34428000f, -0.02984953f, -0.55399299f, -0.04497115f, 
    0.24852620f, -0.15755381f, -0.04775438f, -0.00294515f, -0.12438763f, -0.17437102f, 0.70651126f, -0.22476964f, 
    -0.42325529f, 0.70862746f, 0.46026525f, -0.62905222f, -0.68356907f, -0.50820637f, 0.01013294f, 0.18667637f, 
    -0.44820893f, -0.07415814f, 0.10661773f, -0.16023980f, 0.08202881f, -0.15926376f, -0.31202057f, 0.05804629f, 
    0.22651002f, 0.10113671f, 0.20222054f, 0.09380239f, -0.15979421f, -0.16699825f, -0.03159922f, -0.47959301f, 
    -0.37644070f, -0.74163413f, 0.01916797f, -0.05497022f, -0.39054069f, -0.15014760f, 0.07246430f, 0.03849840f, 
    0.22139415f, 0.31960490f, 0.30434963f, 0.16526452f, -0.33833486f, -0.16020721f, -0.08139889f, -0.05380351f, 
    0.59354830f, -0.37547103f, -0.53426701f, 0.18852635f, 0.28970248f, -0.25263092f, 0.08695981f, 0.20057172f, 
    0.34906319f, 0.87321401f, -0.30962539f, 0.57299292f, -0.33002168f, 0.20921355f, 0.33741146f, -0.58621603f, 
    0.46340281f, -0.05238678f, 0.52831805f, -0.07308565f, 0.15197356f, -0.35443866f, -0.14012799f, 0.07045773f, 
    -0.28160638f, -0.00939855f, 0.18082787f, -0.06790292f, 0.03527341f, -0.23204979f, 0.36976302f, -0.12165634f, 
    0.03895923f, -0.32617065f, -0.30712429f, 0.58650076f, 0.10774113f, 0.31512499f, -0.71408075f, -0.11061762f, 
    -0.05706364f, -0.64209151f, -0.59781641f, 0.20790879f, 0.42822421f, 0.26133132f, 0.20041877f, -0.33151162f, 
    -0.34402868f, 0.13667467f, 0.25515458f, -0.35575867f, 0.16993612f, -0.00904083f, 0.01230508f, -0.13271795f, 
    0.33278888f, -0.28511906f, 0.66780239f, -0.57415658f, -0.40249926f, 0.57388765f, 0.56981808f, 0.33747903f, 
    0.40389499f, 0.13123298f, 0.45101205f, 0.09225059f, 0.03971665f, 0.08362565f, -0.43266487f, 0.22843981f, 
    -0.09438342f, -0.16359559f, -0.34611186f, -0.03748154f, 0.23233710f, -0.19376537f, -0.03645374f, 0.12516105f, 
    0.04033150f, 0.11921488f, -0.13218249f, 0.59571785f, -0.35469747f, 0.71866751f, 0.53872609f, -0.51288587f, 
    -0.79238981f, 0.06220073f, -0.47084665f, -0.22869405f, -0.54613680f, -0.06971608f, 0.23737544f, 0.05444557f, 
    0.21886207f, 0.20461398f, -0.42860121f, -0.17677219f, -0.27887547f, 0.03636665f, -0.01695792f, 0.08401635f, 
    0.21244924f, -0.03833692f, 0.02528993f, 0.22709477f, 0.42615327f, 0.48950592f, 0.14249088f, 0.12303693f, 
    0.58695436f, -0.28848764f, -0.75717658f, -0.15397280f, 0.15477389f, 0.06869204f, -0.35951653f, -0.20240968f, 
    0.10941651f, 0.26054135f, -0.23478433f, 0.23921658f, 0.32150596f, -0.21432143f, 0.27630660f, 0.32986322f, 
    0.28675875f, 0.29519242f, 0.35456827f, -0.26847228f, -0.35039887f, -0.82212371f, 0.51360220f, 0.28971329f, 
    0.25441495f, 0.53809780f, 0.15909663f, 0.99717140f, 0.51644391f, 0.01828193f, 0.58990610f, -0.47059271f, 
    -0.15218219f, 0.27529755f, -0.22759442f, 0.23709141f, 0.01432773f, 0.03420705f, 0.05183802f, 0.05396562f, 
    -0.20075864f, 0.27843183f, 0.03142257f, -0.08018716f, -0.07161557f, -0.02676898f, 0.88365823f, 0.54562473f, 
    -0.36668745f, 1.06242669f, 0.67845625f, 0.73697156f, 0.19188339f, -0.70886022f, 0.25988093f, -0.25956228f, 
    -0.25170410f, 0.08245134f, -0.11535991f, 0.30614960f, -0.18070419f, 0.19282600f, 0.08224303f, 0.14106697f, 
    -0.04778010f, -0.07133719f, 0.13940822f, 0.02429164f, 0.05846659f, -0.05851414f, 0.37715146f, 0.56256264f, 
    0.73201758f, 0.66547000f, 0.31150660f, 0.70259953f, -0.57464957f, -0.64202613f, -0.23651746f, -0.46184102f, 
    -0.19503874f, 0.44768363f, 0.27583376f, -0.19221911f, 0.24851777f, -0.12854353f, 0.26174179f, -0.04923031f, 
    0.02848924f, -0.06203250f, 0.21340835f, -0.13167375f, 0.13984109f, 0.13184699f, -0.02334021f, 0.28993344f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17725632f, 0.07982390f, 0.04928031f, 0.12979323f, 0.13448289f, -0.03469781f, -0.11016136f, 0.17042172f, 
    0.19062373f, 0.05987228f, -0.01957529f, 0.34757784f, 0.02661999f, 0.14036343f, 0.18553059f, -0.03628932f, 
    0.23197377f, 0.05813520f, 0.18251604f, 0.03736418f, 0.20980074f, 0.12629528f, 0.31145793f, 0.29873466f, 
    0.15706097f, -0.02250851f, -0.03896189f, 0.16965409f, 0.11244463f, 0.07493121f, 0.12824923f, 0.13940595f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03061591f, -0.03601003f, -0.03701147f, -0.02549974f, -0.05176933f, 0.01997700f, -0.00100636f, -0.03063545f, 
    0.03210617f, -0.04310317f, -0.04159221f, -0.04600557f, 0.00718808f, 0.00538603f, -0.04296346f, -0.01758733f, 
    0.03020018f, 0.02088439f, 0.03507417f, -0.03343187f, -0.02858832f, -0.05138917f, -0.02875118f, -0.00291000f, 
    0.00272319f, 0.00685356f, -0.00654455f, 0.03304857f, -0.01150168f, 0.00628946f, -0.02973740f, -0.03334481f, 
    -0.01160276f, 0.03922480f, -0.03184007f, 0.02323451f, 0.01698615f, 0.01953981f, -0.01887273f, 0.02953008f, 
    0.01944326f, 0.03409511f, 0.01903347f, -0.05757417f, -0.00422189f, -0.01192186f, 0.02369882f, -0.00590441f, 
    -0.03305437f, 0.00619784f, -0.02974916f, 0.03242135f, -0.05601555f, 0.02241283f, 0.01418216f, -0.03868505f, 
    0.00313533f, -0.02563989f, 0.00478540f, 0.03667472f, -0.01132148f, 0.03578072f, 0.01692726f, -0.02414137f, 
    0.03172950f, 0.02352457f, 0.02863369f, 0.04044301f, -0.05089494f, -0.02321896f, -0.04710093f, -0.01760049f, 
    -0.01307436f, -0.05463155f, 0.03039912f, -0.04109924f, 0.03272686f, -0.05035821f, -0.01635407f, 0.04091771f, 
    -0.03410687f, -0.02638111f, 0.01354868f, 0.01320866f, -0.04947746f, -0.02226589f, -0.03866122f, -0.02313247f, 
    0.02686005f, 0.02146165f, 0.00183125f, -0.05246190f, 0.00782229f, 0.04808287f, 0.00702539f, -0.03293641f, 
    -0.02743286f, -0.03131725f, 0.02375412f, -0.01014304f, -0.05502000f, -0.02288359f, -0.05007631f, 0.01500364f, 
    -0.05913364f, 0.04846573f, -0.01264783f, -0.04218645f, -0.01663546f, 0.03984192f, -0.01927639f, -0.01529284f, 
    0.02470673f, 0.01887148f, 0.02639769f, -0.00756220f, -0.04186247f, -0.03169246f, -0.02754731f, -0.04539302f, 
    -0.00061530f, -0.00093992f, 0.02197240f, 0.03842269f, -0.02387177f, 0.05187812f, -0.04859703f, 0.01475206f, 
    0.04010032f, -0.05597046f, -0.00204480f, 0.04171051f, -0.04583433f, -0.05836929f, -0.04564729f, 0.01348862f, 
    -0.01882488f, 0.02563177f, 0.04037490f, -0.01757255f, 0.02801590f, 0.03914373f, 0.00676022f, -0.01063558f, 
    -0.02333707f, 0.00796604f, -0.03350302f, 0.00389091f, -0.05483151f, 0.03846461f, 0.05009347f, 0.01458656f, 
    0.03946738f, 0.02144492f, -0.00257095f, 0.02275259f, 0.01729215f, 0.00069937f, -0.03984955f, -0.02219924f, 
    0.04098971f, -0.03241574f, -0.05849574f, -0.02016135f, -0.04192529f, -0.00381226f, -0.02492201f, 0.03845353f, 
    0.02472727f, 0.00237060f, 0.02874414f, -0.02023358f, -0.05347176f, 0.00080070f, 0.02447357f, -0.01140359f, 
    -0.00998625f, -0.02496196f, 0.00038744f, -0.04683642f, -0.04138717f, 0.03532590f, -0.02545726f, 0.03472084f, 
    0.03115326f, -0.02924839f, -0.04947603f, 0.02508207f, 0.00279972f, -0.05273937f, -0.00124807f, -0.00230520f, 
    0.00772362f, 0.02699634f, -0.00126501f, -0.04227922f, 0.00157945f, -0.03404928f, -0.05491167f, 0.02801118f, 
    0.02450217f, 0.05190503f, -0.02740776f, 0.04226071f, -0.04134158f, 0.00629564f, 0.02648424f, -0.00861090f, 
    -0.00076933f, 0.03431307f, -0.03841264f, -0.02085946f, -0.02184523f, -0.01522813f, 0.00948709f, -0.03514383f, 
    0.02561821f, -0.04057618f, 0.01657871f, -0.03455883f, -0.05136687f, 0.00109823f, -0.04714922f, 0.00909657f, 
    0.03289252f, 0.01809301f, 0.04858749f, 0.02725152f, 0.04139977f, -0.03076879f, 0.01579730f, 0.00140933f, 
    0.02342651f, -0.04225914f, -0.02441501f, 0.03494769f, 0.00795301f, 0.00919336f, 0.02619540f, 0.01271270f, 
    0.00214172f, -0.03143192f, -0.03376956f, 0.03760695f, -0.03645842f, -0.04518537f, -0.04427074f, -0.03091743f, 
    0.03397306f, 0.02747037f, -0.02626634f, -0.02172627f, -0.06011479f, -0.01106990f, -0.04383255f, -0.05879266f, 
    -0.00090011f, -0.04577283f, 0.01748152f, -0.02715219f, -0.05167993f, -0.01166077f, -0.00636633f, -0.00805833f, 
    0.00723317f, 0.03707209f, -0.02271094f, 0.01695992f, 0.00317675f, -0.02825543f, -0.02656278f, 0.04704693f, 
    -0.03679417f, -0.05185052f, -0.03179423f, -0.00727892f, 0.00520798f, 0.01212615f, 0.00436841f, 0.02513952f, 
    -0.04643163f, 0.00968476f, 0.00686295f, 0.03481308f, 0.00052965f, -0.04946113f, -0.00716197f, 0.03705187f, 
    0.05327676f, -0.03889353f, 0.01741743f, 0.01474305f, -0.03838725f, -0.00364981f, -0.01908278f, -0.04552631f, 
    0.03988819f, 0.00938084f, -0.02971275f, -0.03192126f, 0.00299377f, 0.00609872f, -0.02931263f, 0.01483162f, 
    -0.02970790f, 0.04174310f, -0.00397058f, -0.03052443f, 0.04119709f, -0.04337045f, -0.00402354f, -0.04805318f, 
    0.02575884f, -0.01457713f, -0.01436879f, 0.02810333f, 0.04473220f, 0.02463926f, 0.03163560f, -0.00596346f, 
    0.02729012f, -0.03806910f, 0.05294776f, -0.02220608f, 0.03999992f, -0.03700706f, 0.00512336f, 0.01225980f, 
    -0.00474705f, 0.02084760f, -0.06076632f, 0.01024515f, 0.00516914f, -0.02194541f, 0.03611920f, -0.02051961f, 
    -0.03496201f, 0.02251870f, 0.01986794f, -0.00162814f, -0.05122337f, -0.05444670f, 0.04270710f, -0.02533924f, 
    0.01261355f, 0.00001378f, 0.00868247f, -0.01915904f, 0.04391688f, 0.01656813f, -0.01668414f, -0.01842912f, 
    0.03839779f, -0.02671534f, -0.02394640f, -0.05396673f, -0.01800560f, 0.04251454f, -0.00912775f, -0.05971678f, 
    0.04411240f, -0.02526174f, -0.02209036f, -0.02316860f, -0.04107508f, -0.04760782f, -0.03702971f, -0.00120190f, 
    0.03102887f, -0.04310154f, -0.05828595f, -0.00109239f, -0.02660182f, -0.04334261f, -0.01711623f, -0.05949220f, 
    0.01551374f, -0.00654620f, -0.00585298f, -0.00119691f, 0.00825628f, 0.02368381f, -0.05422974f, -0.04873975f, 
    0.06957197f, 0.10446579f, 0.09217152f, -0.04373587f, 0.01777538f, 0.00318737f, -0.04770743f, -0.08654889f, 
    -0.15694025f, -0.04116536f, -0.08656465f, 0.00787574f, 0.22676960f, -0.00351995f, -0.08216071f, 0.08582357f, 
    -0.00459083f, -0.08147611f, -0.09830601f, 0.05913201f, 0.11677792f, 0.01292473f, 0.07173980f, -0.11476807f, 
    0.00513481f, -0.02637320f, -0.05943673f, -0.22194192f, 0.11842701f, -0.09735614f, -0.11943304f, -0.16034287f, 
    -0.17059435f, -0.15039815f, 0.21246323f, -0.18926843f, 0.11103099f, -0.04358612f, 0.25871781f, 0.06643584f, 
    0.03880066f, 0.03066281f, 0.04399576f, -0.09240840f, 0.03993504f, 0.11346173f, -0.07533626f, -0.05788251f, 
    0.10404098f, -0.02569055f, -0.18349794f, -0.13588311f, -0.06481906f, -0.01130036f, -0.01337491f, -0.24123940f, 
    -0.10165251f, 0.00640491f, 0.00988451f, 0.10033420f, 0.42932895f, 0.08134913f, 0.17072074f, 0.11809795f, 
    -0.00388774f, 0.05306057f, -0.05308219f, 0.06459899f, 0.12940383f, 0.21239869f, 0.15354307f, 0.13522816f, 
    -0.10452425f, 0.03295760f, -0.02756697f, -0.04280106f, -0.02386690f, 0.01325452f, 0.03855038f, 0.09362686f, 
    -0.04665454f, -0.03789099f, 0.16793276f, 0.06073264f, -0.10167803f, -0.18690424f, -0.01338089f, -0.16879381f, 
    -0.00040649f, -0.09725606f, 0.07116031f, -0.07025082f, 0.11627636f, 0.09714636f, 0.11771329f, -0.03965201f, 
    0.10711895f, 0.12236552f, 0.00954008f, 0.00067985f, 0.14662890f, 0.14071739f, 0.18655834f, 0.00839557f, 
    -0.01920773f, 0.09530179f, -0.03497088f, -0.01481847f, 0.13606821f, -0.02715884f, 0.20781972f, 0.10504445f, 
    -0.00960293f, -0.10265113f, -0.12247965f, -0.02883070f, 0.05347963f, -0.05273092f, 0.05889479f, -0.14420199f, 
    0.09111848f, -0.03620981f, -0.23260173f, -0.00799620f, -0.10272481f, 0.00340517f, 0.13212802f, 0.07624888f, 
    0.11835991f, -0.05279687f, -0.19311729f, -0.03443375f, 0.08282515f, 0.15875763f, 0.07143568f, 0.08271325f, 
    -0.00516759f, 0.00906676f, 0.03072269f, 0.06184493f, -0.11306852f, 0.08514965f, -0.11836880f, -0.10794045f, 
    0.09954076f, 0.23497491f, -0.09327712f, -0.09567849f, -0.01565545f, 0.04374773f, 0.06073564f, 0.05683286f, 
    -0.13514599f, 0.20315540f, 0.13975066f, 0.00931692f, -0.00730374f, -0.07321280f, 0.24776842f, 0.15485331f, 
    0.10146278f, -0.12277712f, -0.04956647f, -0.08810066f, 0.08253698f, -0.16259095f, -0.21644087f, 0.01590700f, 
    -0.01371210f, 0.11016206f, 0.06153377f, 0.29298019f, -0.01124065f, 0.12056476f, 0.18677962f, 0.17565121f, 
    -0.07329912f, -0.00403272f, -0.03182526f, 0.12489315f, 0.24973564f, 0.13792551f, 0.02903591f, 0.05633173f, 
    -0.04737904f, 0.04625594f, -0.00671975f, -0.04141801f, -0.17145246f, -0.09129031f, 0.10112640f, -0.15892802f, 
    -0.14083742f, 0.09199454f, 0.11531358f, -0.04458138f, 0.02581119f, -0.08195363f, 0.00238107f, 0.11745095f, 
    0.12652139f, 0.25443485f, 0.04680544f, -0.07831548f, -0.02614647f, 0.24680845f, 0.11628181f, 0.14403899f, 
    0.04158000f, 0.08195227f, 0.04110390f, -0.00580269f, -0.04590315f, 0.23288143f, -0.00960025f, 0.24220188f, 
    -0.02579740f, -0.28273070f, 0.05944202f, -0.04760847f, -0.04085937f, -0.06938771f, 0.06259001f, -0.21760602f, 
    -0.05973171f, -0.09046832f, -0.04421686f, 0.01205780f, -0.14482336f, -0.12034289f, -0.04124640f, -0.18156381f, 
    0.02211822f, 0.03154602f, 0.12201400f, -0.22164363f, -0.00636277f, -0.03883863f, 0.01566373f, 0.07714929f, 
    -0.33121768f, 0.09002041f, 0.14087409f, 0.01864791f, 0.08066177f, -0.02717739f, -0.02826700f, -0.02520241f, 
    0.03883916f, 0.05030273f, -0.05612704f, 0.12219459f, 0.15232685f, 0.16692057f, 0.18453969f, 0.04571155f, 
    0.07259794f, 0.11689977f, -0.00150701f, 0.09283329f, 0.01208379f, -0.03567910f, 0.06595784f, 0.07836454f, 
    0.09701443f, 0.14311469f, -0.02543466f, -0.07716881f, 0.17456417f, 0.15116867f, 0.09735595f, -0.18305106f, 
    -0.02607204f, -0.02697968f, 0.09148218f, 0.10055421f, 0.06603625f, -0.10892095f, 0.07573722f, 0.05334990f, 
    -0.10094249f, -0.11370325f, 0.01191168f, -0.16982299f, -0.05923998f, 0.27851808f, -0.12602019f, -0.13860001f, 
    0.08259086f, 0.21612202f, -0.08365757f, -0.18629335f, 0.00502871f, -0.07636707f, -0.12853155f, 0.00339084f, 
    -0.02587414f, -0.03017017f, 0.14215590f, -0.08218569f, 0.33564448f, 0.07194729f, -0.17451173f, 0.18795323f, 
    0.01636167f, 0.04921689f, 0.00324912f, 0.02160910f, -0.04365638f, -0.02850343f, -0.05660539f, -0.12168984f, 
    -0.19287324f, 0.16130339f, -0.07342046f, -0.09360742f, 0.12110964f, -0.01395591f, -0.00858956f, -0.06391301f, 
    0.02956936f, -0.07558375f, 0.29616481f, 0.00206267f, 0.40871614f, 0.24267304f, -0.09405631f, 0.08081529f, 
    0.03759235f, -0.01911094f, -0.05053963f, 0.01055298f, 0.01363256f, -0.03028071f, -0.15035230f, 0.09031408f, 
    -0.00765232f, 0.13133313f, 0.00331752f, -0.06809052f, 0.10278376f, 0.24451362f, -0.13081245f, -0.06763986f, 
    0.04067749f, -0.05699957f, 0.04152711f, -0.02040327f, 0.06787848f, -0.20081927f, 0.09661026f, -0.11339847f, 
    0.07287303f, -0.12059636f, 0.02108013f, -0.06470598f, -0.03073021f, -0.19105631f, -0.08633369f, 0.23391327f, 
    -0.21013178f, 0.07785658f, -0.09332991f, -0.01811966f, 0.07944027f, -0.08076670f, -0.01625484f, -0.10462636f, 
    -0.04499796f, -0.06251173f, -0.11952998f, 0.01224626f, 0.16455656f, 0.04628001f, -0.09713358f, -0.11911453f, 
    -0.03056980f, 0.07026482f, -0.16105118f, 0.02504904f, -0.04936901f, -0.01803013f, 0.08901235f, -0.15291759f, 
    0.02893934f, -0.05838616f, -0.00920996f, 0.03151900f, -0.04620990f, -0.01437696f, -0.00439251f, 0.03666867f, 
    0.03267463f, -0.03920445f, 0.03345633f, -0.04027832f, -0.02868771f, 0.01149615f, -0.04155711f, 0.00928752f, 
    0.00064849f, -0.01255423f, -0.05946801f, 0.02720504f, -0.01106204f, -0.01658995f, -0.01611785f, -0.02629187f, 
    -0.00867341f, -0.04684239f, 0.00727496f, 0.01972545f, -0.02386974f, -0.04451924f, -0.00245450f, -0.01748611f, 
    -0.02130695f, 0.00615664f, 0.00736606f, 0.00886601f, 0.02391532f, -0.01506476f, 0.01545115f, -0.05391236f, 
    0.03541027f, -0.04048060f, -0.01036866f, -0.02728129f, -0.05719333f, -0.02936788f, -0.00401529f, -0.02491822f, 
    0.03025336f, -0.03132812f, -0.01545248f, -0.01252481f, 0.00103678f, -0.02430756f, 0.02920925f, 0.01663291f, 
    0.01037181f, 0.00712768f, -0.03349334f, 0.03106128f, -0.01550767f, -0.00820279f, 0.03865507f, -0.05295023f, 
    -0.04335334f, -0.05195788f, 0.03482594f, -0.05672570f, -0.02149036f, -0.04888453f, 0.00452094f, 0.03022891f, 
    0.02141061f, -0.04873029f, -0.02481120f, 0.04024313f, 0.02676653f, -0.02188072f, 0.03605212f, 0.00984073f, 
    -0.01148812f, -0.01323557f, -0.04203237f, 0.03473626f, 0.03183148f, -0.05865899f, 0.04383606f, -0.01135401f, 
    -0.01467225f, 0.03874648f, -0.02555516f, 0.04907699f, -0.01609108f, -0.00475548f, 0.01023878f, -0.03493126f, 
    0.03440567f, 0.00931377f, -0.03081959f, -0.03572896f, -0.04247600f, -0.04338048f, 0.01329602f, 0.01460780f, 
    -0.00526494f, -0.04363512f, 0.02659408f, 0.00171034f, -0.03185767f, -0.03413751f, -0.03784293f, 0.04929973f, 
    -0.03054785f, 0.03370968f, 0.02937303f, 0.01503616f, 0.00257203f, -0.00264115f, -0.01444992f, -0.00614492f, 
    0.04224501f, -0.03692312f, -0.04453053f, -0.04050483f, -0.00701653f, 0.02512651f, -0.03933997f, -0.00708963f, 
    0.02933603f, 0.03146616f, 0.00299373f, 0.02663475f, 0.03346291f, -0.04006918f, -0.04873657f, -0.02371608f, 
    -0.01765421f, -0.05341270f, 0.03691075f, -0.04999385f, -0.05405167f, -0.04160715f, 0.02767215f, 0.00584018f, 
    0.03686275f, -0.04531728f, -0.03170010f, 0.02615006f, -0.00275511f, -0.04484240f, -0.04238772f, -0.01164335f, 
    0.02242837f, -0.03489128f, -0.04162511f, 0.01621858f, 0.02038222f, -0.04472397f, -0.05733849f, -0.03575775f, 
    -0.03318472f, 0.01630206f, -0.02539085f, 0.00301431f, 0.03684170f, -0.04504182f, -0.02984512f, -0.04824409f, 
    0.04091781f, -0.04131250f, -0.04687711f, 0.03706134f, 0.02174093f, 0.03658075f, 0.01189841f, 0.02266783f, 
    -0.03923494f, -0.01182203f, 0.03326384f, -0.00032316f, -0.02015639f, -0.04989912f, -0.02795746f, -0.02985512f, 
    -0.01562225f, 0.04058751f, -0.03839582f, 0.03374685f, -0.02032351f, 0.01412622f, -0.04051990f, -0.01285425f, 
    -0.03341730f, -0.02272510f, 0.03628131f, -0.04302344f, -0.02627747f, -0.05748349f, 0.02474817f, 0.03885085f, 
    0.02053118f, 0.04914868f, 0.00367182f, 0.00826609f, 0.05204325f, -0.03231757f, 0.02787727f, 0.04441387f, 
    0.01296471f, 0.00556055f, 0.01291439f, -0.05647025f, -0.05640670f, -0.04807979f, -0.00010816f, 0.03755270f, 
    -0.03891693f, -0.03210159f, -0.03808927f, -0.00403078f, -0.02014638f, -0.00021408f, -0.03773278f, -0.00622681f, 
    0.00685341f, 0.01770225f, -0.04176046f, 0.03103822f, 0.01702118f, -0.03546521f, -0.01919643f, -0.00607176f, 
    -0.00615680f, -0.00653755f, 0.00260770f, 0.01225336f, 0.03119512f, -0.00281391f, -0.01444464f, 0.03461533f, 
    -0.00494189f, 0.02551289f, -0.02327318f, -0.03286743f, -0.01778752f, -0.03017576f, 0.02501019f, -0.03690607f, 
    0.04369151f, -0.01314394f, -0.05166133f, 0.02085543f, 0.03574597f, 0.01653067f, 0.01478931f, 0.00805798f, 
    0.02691756f, 0.02618260f, -0.01645959f, 0.04031975f, -0.00500139f, -0.00806143f, 0.04331155f, -0.03692023f, 
    0.00977262f, -0.00046102f, -0.01741247f, -0.03938451f, -0.01996174f, 0.01478179f, -0.01480250f, -0.01840700f, 
    -0.05085006f, 0.01410943f, 0.03652842f, -0.03229099f, -0.02801452f, 0.04141650f, 0.04397054f, 0.02545850f, 
    -0.00566647f, -0.00713279f, -0.05273100f, 0.02739634f, 0.00575253f, 0.04239053f, -0.01461800f, -0.01165834f, 
    0.03840210f, -0.01730872f, 0.03280244f, -0.01602917f, 0.03160759f, 0.01988938f, 0.01222621f, 0.01818971f, 
    0.00823866f, -0.01085450f, -0.00466545f, -0.04176762f, -0.03220418f, -0.00505596f, 0.01093064f, 0.02551525f, 
    0.01168512f, -0.04674613f, -0.03542162f, -0.02174708f, 0.00347256f, 0.02682290f, 0.02220546f, 0.00768975f, 
    -0.02212482f, 0.02573760f, 0.03238715f, -0.02180048f, -0.03902429f, -0.00015982f, 0.04449192f, 0.02623039f, 
    -0.03960669f, -0.05211541f, -0.00391804f, 0.03789498f, -0.03042299f, 0.04137221f, -0.03939122f, -0.00268083f, 
    -0.02512763f, -0.04839508f, -0.04624256f, 0.02233556f, 0.01102142f, -0.00571983f, 0.04132909f, 0.04251433f, 
    -0.00638834f, -0.03486472f, 0.01242929f, 0.00456916f, 0.03191088f, -0.01072386f, 0.02866673f, -0.00623555f, 
    -0.03494856f, -0.02448356f, 0.03980875f, 0.02151842f, 0.02453104f, -0.00127819f, 0.03837461f, 0.03100365f, 
    -0.04459008f, -0.00935236f, -0.02262987f, 0.02360045f, -0.00154666f, 0.00102565f, -0.02620294f, -0.00664548f, 
    0.03599303f, -0.01969890f, 0.01343391f, -0.02853777f, -0.02549274f, -0.04255520f, -0.02406300f, -0.04687719f, 
    0.02279226f, 0.03917556f, -0.05461567f, 0.03440224f, -0.05121907f, -0.00223664f, -0.05206763f, -0.05051098f, 
    0.00852271f, -0.01929189f, -0.05311671f, 0.00930934f, -0.03177155f, 0.04467706f, -0.01766570f, -0.05324947f, 
    -0.02078887f, 0.01254171f, -0.03906752f, -0.01794918f, 0.01746270f, -0.00089198f, -0.00669620f, 0.01777140f, 
    0.04314638f, -0.03343008f, -0.02610508f, 0.02377593f, 0.02608599f, 0.01847288f, -0.04361158f, 0.02345834f, 
    0.01411064f, -0.05331001f, -0.03065560f, -0.02850549f, 0.02605373f, -0.00593346f, -0.04230046f, 0.00617803f, 
    0.02793953f, -0.00507250f, -0.01953187f, 0.00207796f, 0.01513294f, 0.03641516f, -0.04111538f, -0.05257082f, 
    -0.04535786f, -0.04934364f, -0.01168929f, -0.02110272f, 0.01739107f, -0.05223392f, -0.00358945f, 0.01080659f, 
    0.02176646f, 0.03919073f, -0.01201947f, -0.03438532f, 0.04250630f, 0.01812872f, -0.02050238f, -0.03994630f, 
    -0.01588423f, 0.04063074f, -0.05800377f, -0.01549248f, -0.02565894f, -0.00611217f, -0.02925102f, 0.01544041f, 
    0.00974441f, 0.02765722f, -0.01350549f, -0.03009205f, -0.05714126f, 0.01067200f, -0.01385253f, -0.00558728f, 
    0.00243008f, 0.03606372f, 0.01576506f, 0.01233948f, -0.00023439f, 0.01697653f, 0.01279241f, -0.03571270f, 
    -0.02529537f, -0.00238481f, 0.00071190f, 0.04297735f, -0.02755156f, -0.05623109f, -0.01025577f, -0.03775860f, 
    -0.01734017f, 0.02865286f, 0.01005075f, 0.02342463f, -0.04596606f, 0.00442178f, 0.01260991f, 0.04376081f, 
    -0.04059098f, 0.01485791f, -0.03394541f, -0.01999124f, 0.02344593f, 0.03163780f, 0.02945326f, 0.04075279f, 
    0.02851686f, -0.05847204f, 0.00210006f, -0.00337835f, -0.03191734f, -0.04993400f, -0.02898083f, -0.03324898f, 
    0.02183879f, -0.04190803f, 0.01561687f, -0.00655714f, -0.00675450f, -0.04492185f, -0.03477827f, -0.04930070f, 
    -0.00942176f, -0.02870668f, -0.03639840f, -0.03969055f, -0.00317247f, 0.02033909f, 0.01358305f, 0.02524320f, 
    0.00193799f, -0.01177687f, -0.04703338f, -0.04434482f, 0.05188717f, 0.04020726f, 0.03116305f, -0.00603505f, 
    -0.04086314f, 0.00934147f, -0.00259772f, 0.04907834f, -0.05746245f, -0.01902023f, -0.03501052f, -0.05219030f, 
    -0.04467713f, -0.04768936f, 0.01841724f, -0.04789955f, -0.00805756f, -0.04287354f, 0.01338676f, -0.00511489f, 
    0.00344429f, -0.03003170f, 0.01992355f, 0.03003111f, -0.00123396f, 0.01783645f, 0.02094601f, -0.00069099f, 
    -0.03517228f, -0.02755251f, -0.00736811f, -0.02510411f, 0.00210735f, -0.02006684f, -0.04303696f, -0.03769525f, 
    -0.00918843f, -0.03022810f, -0.05693698f, 0.01969060f, -0.03783316f, 0.04062584f, 0.00814190f, 0.01928579f, 
    -0.05190216f, -0.03574023f, 0.04043003f, -0.02463308f, 0.01577298f, 0.00470409f, -0.01594719f, -0.03359844f, 
    -0.00687362f, -0.03040845f, 0.00629327f, -0.01575243f, -0.05459368f, -0.02618656f, 0.03339929f, -0.04083106f, 
    -0.05323399f, 0.04022624f, -0.00624058f, 0.02836438f, -0.01605836f, 0.04178007f, -0.04433329f, 0.02787072f, 
    0.01099706f, 0.01095487f, 0.04431722f, -0.00678086f, 0.00039764f, -0.03929181f, 0.02886674f, 0.02693688f, 
    0.04488099f, -0.02370889f, 0.03625163f, -0.02104119f, -0.05694738f, 0.01821759f, -0.01120109f, 0.04322259f, 
    -0.00950180f, -0.05219464f, 0.04207467f, -0.01528625f, 0.00309304f, -0.03176891f, 0.02406825f, -0.02058639f, 
    0.03264886f, 0.01633629f, -0.01321423f, -0.03892958f, 0.02690358f, -0.03421314f, 0.00564797f, 0.00426663f, 
    -0.00325690f, 0.01515643f, -0.01240304f, 0.02524122f, -0.01433986f, 0.04087676f, -0.05546561f, -0.01686058f, 
    -0.00043678f, -0.05577655f, -0.00140929f, -0.02974547f, -0.03120260f, -0.02835881f, -0.03246408f, 0.00502857f, 
    -0.05233718f, -0.00386050f, -0.04643920f, 0.01580388f, 0.01027340f, -0.05869522f, -0.05583670f, -0.05086704f, 
    -0.03918284f, -0.05503798f, 0.01999790f, -0.05295815f, -0.04524394f, -0.01759356f, -0.01808744f, -0.01453492f, 
    0.00027277f, 0.03019249f, 0.02302288f, -0.05097172f, -0.04749575f, -0.00377766f, -0.02422543f, -0.05236305f, 
    -0.01606097f, 0.00379679f, -0.03877041f, 0.03056262f, -0.02006541f, -0.00314541f, -0.03661486f, 0.02132814f, 
    -0.00756500f, 0.00613359f, 0.04654678f, -0.00585580f, -0.05801114f, -0.03529255f, -0.01333715f, 0.02650239f, 
    0.01000260f, -0.03075528f, 0.00079130f, -0.00662518f, 0.04097820f, -0.03915989f, -0.00998105f, 0.02895130f, 
    -0.04662922f, 0.01138677f, -0.05160600f, -0.00546534f, -0.01900579f, 0.02622621f, -0.05640319f, 0.03619219f, 
    -0.05305530f, -0.03141205f, 0.04327618f, 0.01747476f, 0.03529652f, 0.02266685f, 0.00296067f, -0.04679269f, 
    -0.02992644f, -0.03914518f, -0.01353004f, 0.04489091f, 0.01297875f, -0.01425649f, -0.04841081f, -0.02877433f, 
    -0.03823221f, -0.05233487f, -0.02209032f, 0.02025887f, -0.01991319f, 0.00658282f, -0.02169817f, 0.02513604f, 
    0.01984404f, -0.00967113f, -0.01430792f, -0.04377976f, -0.01822294f, -0.00656534f, -0.01250962f, -0.02593464f, 
    0.02475441f, 0.02745659f, -0.03669466f, 0.01940665f, 0.02981496f, 0.03316400f, 0.03260709f, -0.03385169f, 
    0.00107176f, -0.03380672f, 0.01832207f, 0.03363878f, -0.04383154f, -0.01014493f, -0.03145751f, 0.00091391f, 
    -0.05540273f, 0.00438306f, -0.01809701f, 0.03345546f, -0.05505654f, -0.01941679f, 0.02736121f, -0.04623255f, 
    0.01173481f, -0.02613289f, -0.02289867f, -0.04499575f, -0.00649667f, 0.02451448f, 0.00415269f, -0.02800997f, 
    0.00208915f, 0.00851492f, -0.01438424f, 0.03352971f, -0.03857413f, 0.02779551f, -0.01669078f, 0.03259579f, 
    -0.01097215f, 0.03233976f, -0.04001556f, -0.02624626f, -0.01015104f, -0.03627118f, -0.05344390f, 0.02877524f, 
    0.00667030f, -0.02874102f, -0.04069807f, 0.03343021f, -0.01813247f, 0.02594401f, 0.01588943f, -0.02025546f, 
    -0.01430703f, -0.02636108f, 0.01138344f, -0.04670565f, 0.01102322f, 0.03244474f, 0.02905429f, -0.00188042f, 
    0.03548976f, -0.03781987f, 0.01999369f, -0.00050775f, -0.03933330f, 0.00040699f, -0.05517093f, 0.01773771f, 
    0.01631984f, -0.04751679f, 0.00211949f, -0.00446270f, -0.03923297f, 0.02112930f, 0.01365728f, -0.01252862f, 
    0.02620192f, 0.03800391f, -0.04208175f, -0.01064450f, 0.02487495f, -0.02576874f, 0.03061644f, 0.02220616f, 
    -0.04618708f, -0.03868541f, 0.01002296f, 0.03470712f, 0.04123990f, 0.01426541f, -0.04801682f, -0.01052541f, 
    -0.00616137f, -0.04607962f, -0.05280737f, 0.04282717f, -0.01485590f, -0.00532350f, 0.01084079f, 0.01064628f, 
    -0.04517408f, 0.04022595f, -0.02386276f, -0.03716464f, -0.04728086f, -0.03050883f, 0.01042838f, 0.02329033f, 
    0.02267522f, 0.03989354f, 0.04016341f, -0.01416335f, 0.03631077f, -0.04587289f, 0.01114751f, 0.00645267f, 
    -0.02642467f, 0.00875748f, -0.02054338f, -0.04087451f, 0.00895535f, -0.01689182f, -0.04219774f, -0.04294999f, 
    0.03086496f, -0.01983463f, -0.05679931f, 0.00408140f, -0.03052705f, -0.05163636f, -0.01830459f, -0.05639264f, 
    0.01432328f, -0.04215939f, 0.03200518f, 0.00900326f, 0.03920754f, 0.01239703f, -0.01753641f, 0.03199933f, 
    -0.05543774f, 0.00126048f, 0.03118434f, 0.00544057f, -0.00783799f, -0.00505532f, 0.04284373f, 0.01677511f, 
    -0.03893457f, 0.02482512f, 0.01143931f, -0.01064173f, 0.00748513f, 0.03579091f, 0.00271001f, -0.03076100f, 
    -0.02430613f, 0.03464309f, -0.03856973f, 0.03151425f, 0.00749913f, -0.00221724f, -0.03508826f, -0.00285396f, 
    -0.05508216f, 0.02464574f, 0.03861413f, -0.02896120f, -0.01272575f, -0.04854637f, -0.00505023f, -0.05328437f, 
    -0.04096399f, 0.01962791f, 0.01311048f, -0.04763525f, -0.04962154f, -0.04116735f, 0.03293959f, 0.00925895f, 
    -0.05416877f, 0.04279630f, -0.02595587f, -0.01957292f, 0.00719645f, -0.04261387f, -0.03288758f, -0.04734899f, 
    0.00870257f, 0.00535800f, 0.02328236f, -0.03013149f, 0.01185116f, 0.00119036f, 0.03831311f, -0.05310908f, 
    -0.01028159f, -0.05676834f, -0.01827699f, 0.04360838f, 0.00311428f, 0.03309750f, -0.03550121f, -0.04680756f, 
    0.02208413f, -0.03479998f, 0.00209111f, -0.04427667f, -0.02706184f, 0.03429205f, -0.05602819f, 0.02197354f, 
    0.00552144f, -0.02963152f, -0.02993967f, 0.02525626f, 0.01612087f, 0.00436395f, -0.01722385f, -0.05339881f, 
    0.00499775f, 0.00536613f, 0.00005921f, -0.03750607f, 0.01232329f, 0.02038084f, 0.00932148f, 0.00657640f, 
    0.03907154f, -0.05536476f, -0.04942047f, -0.00716283f, 0.02899093f, -0.05086189f, -0.03779184f, -0.03564344f, 
    -0.00266953f, 0.02039540f, -0.00093772f, 0.01663692f, -0.01529668f, -0.04685556f, 0.01036545f, -0.01308344f, 
    -0.04782665f, -0.00243420f, -0.03597408f, 0.00088227f, 0.02576185f, -0.00925214f, -0.02183576f, 0.04286908f, 
    -0.02627263f, -0.04596815f, -0.04213747f, -0.01425020f, -0.00585148f, 0.02904513f, -0.04495924f, -0.01845689f, 
    0.03835490f, -0.02071062f, -0.05102955f, 0.03824692f, 0.01024872f, -0.03740542f, -0.01719903f, -0.02246246f, 
    -0.01218761f, -0.03842935f, -0.04554838f, -0.05190754f, 0.03172725f, -0.01226724f, -0.01441339f, -0.02502712f, 
    -0.03968009f, -0.02537540f, -0.02091991f, 0.01079620f, 0.04092727f, -0.01590244f, 0.02217777f, 0.00471818f, 
    -0.04454116f, 0.02257343f, -0.01061814f, 0.03466366f, 0.00290125f, -0.04571736f, -0.04333144f, -0.00632248f, 
    0.01158630f, -0.01830165f, 0.01245737f, -0.03421601f, 0.02304797f, 0.01509787f, 0.00743621f, -0.02684294f, 
    -0.04359736f, 0.01433081f, -0.02914548f, -0.04903546f, -0.05657122f, 0.01320403f, -0.02189540f, 0.00671433f, 
    0.02565269f, -0.00474620f, -0.01219848f, 0.02875905f, -0.02419811f, -0.02589251f, -0.01888117f, 0.01973565f, 
    0.02937105f, -0.01173959f, -0.01285456f, -0.03765323f, -0.04805442f, 0.03336790f, -0.00760979f, -0.04847483f, 
    -0.03511997f, 0.01510691f, 0.03951854f, -0.03482965f, -0.05500186f, -0.03022452f, -0.05585969f, -0.01334302f, 
    -0.04030955f, -0.01903106f, 0.01251132f, -0.02083119f, 0.03652301f, 0.04356826f, 0.01976943f, -0.00736972f, 
    0.04375548f, 0.00048288f, -0.00476179f, -0.02813011f, 0.01513367f, -0.02514725f, -0.02702417f, -0.05288703f, 
    0.01386053f, 0.00857884f, -0.04009686f, -0.03897514f, -0.05382067f, 0.01882068f, -0.00604988f, 0.03917669f, 
    0.04088974f, -0.03919626f, -0.00531849f, 0.00177141f, -0.00698335f, -0.01371325f, -0.03835881f, 0.03616124f, 
    -0.03448413f, 0.01714138f, -0.04112810f, 0.00670125f, -0.01456496f, -0.05226638f, 0.03110870f, 0.02370965f, 
    0.02505214f, 0.02961416f, 0.01428524f, -0.01928818f, -0.05169314f, 0.02212931f, -0.05283872f, 0.01008774f, 
    0.01590791f, -0.03522348f, -0.05701862f, 0.03183715f, -0.01182798f, 0.04106478f, -0.02578496f, 0.04042055f, 
    -0.01362454f, -0.05071801f, -0.03253919f, -0.04561186f, 0.00942124f, 0.02585907f, -0.02189776f, -0.04333849f, 
    0.00621236f, -0.01035623f, 0.04384711f, -0.01924258f, -0.03617898f, -0.04618121f, 0.01299864f, 0.00220748f, 
    -0.04712998f, 0.03184466f, -0.04064832f, 0.04111890f, -0.05590281f, 0.01604925f, 0.04131750f, 0.03306304f, 
    0.00193582f, 0.02733517f, -0.03083893f, 0.03940650f, 0.04166036f, 0.02133710f, 0.00366402f, -0.00818412f, 
    -0.00022545f, 0.03476202f, 0.02343174f, -0.03679725f, -0.00368109f, -0.01726818f, 0.00809370f, 0.00024018f, 
    -0.02015838f, -0.04772060f, 0.01131548f, 0.02552329f, -0.00753879f, 0.00803724f, -0.00408146f, -0.05490996f, 
    -0.22454295f, 0.18299039f, 0.15247947f, 0.13675854f, -0.02962924f, 0.09508892f, 0.02335157f, 0.03849503f, 
    0.06799333f, 0.02987576f, 0.04890843f, 0.02322432f, 0.03359839f, -0.01440496f, -0.10044932f, 0.00277358f, 
    -0.05050438f, -0.01235593f, 0.07574867f, 0.13563465f, -0.02775749f, 0.05956923f, 0.08306070f, 0.04220580f, 
    -0.16458365f, -0.29022011f, 0.04744253f, -0.17570154f, -0.06191596f, 0.05578541f, -0.06453833f, -0.09705449f, 
    0.00226903f, 0.07650229f, 0.04917259f, -0.12159159f, -0.09509552f, 0.09490264f, 0.09529407f, -0.05083098f, 
    -0.02665256f, 0.02097883f, -0.06977053f, 0.05795046f, 0.05701332f, -0.02577132f, 0.01399754f, 0.01160107f, 
    0.25134405f, -0.15662123f, -0.09242646f, -0.05499198f, 0.10278095f, -0.00688200f, -0.00038673f, -0.14181797f, 
    0.04039341f, -0.00393229f, 0.02113196f, 0.03573450f, -0.03750682f, 0.12841362f, 0.22665961f, 0.13943854f, 
    0.09036618f, 0.01409849f, 0.05037350f, 0.06248923f, -0.02556256f, 0.03149766f, 0.02400754f, -0.01992127f, 
    -0.21453236f, -0.08494630f, -0.01218145f, 0.20461687f, -0.00745771f, 0.00773830f, -0.01949457f, 0.04576999f, 
    -0.01564915f, -0.04370040f, 0.13500775f, 0.09480207f, -0.28114799f, 0.02225433f, -0.00912494f, -0.05190344f, 
    -0.01485314f, 0.02057679f, 0.11228544f, -0.03622021f, -0.01662308f, -0.10948442f, 0.05258220f, -0.06101590f, 
    0.31884298f, 0.10710081f, 0.06934599f, 0.02251565f, 0.12624775f, -0.01889494f, -0.07727184f, 0.03235034f, 
    -0.07655059f, -0.02330630f, 0.00678957f, 0.04238601f, -0.24281864f, 0.14857242f, 0.17874768f, 0.10413218f, 
    0.06961064f, 0.05072962f, 0.22782739f, 0.09057493f, 0.01109032f, 0.09606064f, 0.12808755f, -0.00081426f, 
    0.09611085f, -0.04279841f, -0.05089902f, 0.12574704f, 0.14694230f, -0.02045693f, -0.13088080f, -0.02972401f, 
    0.08168887f, 0.03641590f, -0.02335935f, 0.02191802f, -0.06396223f, -0.01269346f, 0.11369375f, 0.12000956f, 
    -0.09550649f, -0.06126017f, -0.04314540f, 0.03450764f, -0.11469350f, 0.05334337f, 0.03365210f, -0.04363725f, 
    -0.11912209f, 0.07647175f, -0.01042930f, 0.01738019f, 0.14481229f, 0.13452533f, 0.02541279f, 0.00291810f, 
    -0.06162541f, 0.07203110f, -0.01256667f, 0.03373535f, -0.03355004f, 0.08653334f, 0.04891814f, -0.11942693f, 
    0.05021528f, -0.03244183f, 0.02687876f, 0.10385111f, 0.00277290f, -0.00278567f, 0.06847151f, -0.08173802f, 
    -0.02909536f, -0.14238648f, 0.07880812f, 0.15530865f, 0.12163974f, -0.01513500f, 0.00967934f, 0.01064042f, 
    -0.02499348f, 0.08840858f, -0.03529771f, 0.04910375f, 0.09177944f, 0.10126792f, 0.15280373f, -0.00850156f, 
    0.18946597f, 0.11892720f, 0.17859580f, 0.03328213f, 0.01504401f, -0.00949964f, -0.00929217f, 0.07875192f, 
    -0.41019627f, 0.44978285f, -0.05233715f, -0.14341857f, -0.04660527f, -0.06309482f, 0.02446805f, 0.03036251f, 
    0.13780090f, 0.05494506f, 0.05197925f, -0.02663386f, 0.19491190f, -0.11186933f, 0.23545118f, 0.30234611f, 
    -0.05826401f, 0.06298561f, 0.00191418f, 0.00292558f, -0.13915466f, 0.05036259f, -0.04428060f, 0.13028747f, 
    0.21417268f, 0.06900412f, -0.03679480f, 0.35925293f, 0.22162862f, 0.00941725f, 0.05054307f, 0.04879895f, 
    -0.03549683f, -0.04743479f, 0.04132278f, 0.04580921f, -0.28381345f, 0.06517769f, 0.05919204f, 0.07545014f, 
    -0.04032417f, -0.04156942f, -0.05707792f, 0.00974051f, -0.09273403f, 0.00608764f, 0.10801090f, 0.04786355f, 
    -0.31796536f, -0.17705432f, 0.06818361f, -0.00975123f, 0.03068351f, 0.08000200f, 0.02164522f, 0.05415102f, 
    0.04809094f, -0.06073738f, -0.00392315f, -0.04562457f, 0.04620064f, 0.29669753f, 0.07629216f, 0.11912118f, 
    0.01424776f, 0.12164444f, -0.04964909f, 0.13238038f, 0.10934547f, 0.06453688f, -0.02284671f, 0.05448583f, 
    0.05524435f, -0.12686631f, 0.08041901f, 0.06031281f, 0.02026763f, -0.03415389f, -0.00978755f, -0.04295163f, 
    -0.02058091f, 0.01101110f, 0.12346856f, -0.03097522f, -0.06923708f, 0.03743028f, 0.09388235f, 0.03677303f, 
    0.01537996f, -0.00687175f, 0.07595925f, 0.00049932f, 0.05988616f, 0.05611815f, 0.12344324f, -0.11074720f, 
    -0.47453582f, 0.30182287f, 0.10418764f, -0.12265241f, -0.00881210f, 0.02302786f, -0.03029842f, 0.00245231f, 
    0.05011101f, -0.05851456f, 0.01498605f, -0.16402833f, 0.10967822f, -0.23583803f, 0.32722437f, 0.03911243f, 
    0.05249296f, -0.00706040f, -0.01474542f, -0.07950570f, 0.03840035f, 0.02405578f, 0.03911968f, 0.25408140f, 
    -0.25331846f, 0.31526303f, -0.16170037f, -0.10776684f, 0.08056311f, -0.10697144f, 0.00177184f, -0.11414447f, 
    0.00176007f, -0.07289598f, 0.08786618f, -0.05015675f, -0.02093259f, -0.01940624f, 0.19149579f, 0.21173424f, 
    -0.05386634f, 0.01002016f, 0.08352803f, -0.03043265f, -0.19721250f, -0.09796710f, -0.03389502f, 0.13667721f, 
    -0.01533230f, -0.06685232f, 0.13880941f, 0.01495776f, 0.02514338f, 0.12432201f, -0.03280268f, -0.05697111f, 
    0.09374800f, 0.08210389f, 0.01341966f, 0.09050809f, -0.04894383f, 0.10772605f, 0.08855298f, -0.05954090f, 
    -0.05318351f, -0.03004859f, -0.03357642f, -0.19955292f, 0.05916233f, -0.06304958f, 0.02099567f, 0.00056737f, 
    -0.25142810f, 0.44060355f, -0.12035324f, -0.11489383f, -0.03653754f, 0.05801436f, 0.07656294f, -0.02240608f, 
    -0.00772596f, -0.04164425f, -0.00329984f, 0.11549524f, -0.33769441f, -0.16496508f, 0.12562005f, -0.08930391f, 
    -0.12576219f, -0.02392737f, -0.07141681f, 0.02411716f, 0.01976166f, 0.07233120f, 0.04982332f, 0.02328754f, 
    -0.11746348f, 0.19481739f, 0.13377690f, -0.00470656f, -0.05474653f, 0.08822848f, 0.07720049f, -0.05740535f, 
    -0.04272186f, 0.03317282f, 0.01951730f, 0.05022120f, -0.16292936f, 0.20947698f, 0.11381658f, 0.15663433f, 
    0.08036506f, -0.14918926f, 0.04324566f, 0.17365591f, -0.07558320f, 0.03847909f, -0.07898600f, -0.04729329f, 
    -0.21184716f, -0.16837433f, 0.21357921f, -0.11454721f, -0.01688334f, 0.02070542f, 0.02061605f, -0.01338075f, 
    0.01120154f, 0.06750415f, 0.01052544f, -0.10983880f, 0.05089531f, 0.26209313f, -0.23449881f, 0.08586680f, 
    -0.10801673f, 0.10106948f, 0.02892938f, -0.03208973f, 0.04664310f, 0.03017808f, -0.03519318f, -0.03947659f, 
    -0.24502513f, -0.19757612f, -0.06432307f, 0.06007738f, 0.04394414f, -0.02712227f, 0.03908226f, 0.00686922f, 
    -0.04763690f, 0.10387523f, 0.05065763f, -0.00558162f, 0.18502995f, -0.08216719f, 0.09339214f, 0.19217756f, 
    0.01888206f, 0.02014798f, 0.07056509f, 0.04244979f, -0.04090786f, -0.00471176f, -0.12594025f, -0.09606879f, 
    -0.19610570f, 0.09949596f, -0.06716246f, 0.15838651f, 0.08624934f, 0.00118356f, -0.03354827f, 0.05817136f, 
    0.05613581f, -0.05681036f, 0.20464873f, 0.11541799f, 0.02495067f, -0.04596809f, 0.09708612f, -0.04287067f, 
    -0.14410585f, 0.02332095f, 0.07167760f, 0.06865283f, -0.03583352f, -0.00410396f, 0.15813966f, 0.00834502f, 
    0.06727213f, -0.11668228f, -0.12366214f, 0.17301463f, -0.02958036f, 0.10378744f, 0.04740211f, -0.06981114f, 
    0.01337577f, 0.02303777f, 0.08496746f, 0.02704637f, 0.05630001f, 0.19911388f, 0.14927909f, -0.10589036f, 
    0.12928218f, 0.00153880f, -0.02623298f, -0.02570316f, -0.10064030f, -0.11750744f, 0.13637236f, -0.19584018f, 
    -0.20789064f, -0.16744724f, -0.14275903f, -0.16279472f, -0.00515848f, 0.05200584f, -0.20722061f, -0.09780540f, 
    0.02315441f, 0.03652266f, -0.00446185f, 0.09073913f, 0.04086792f, -0.00609824f, 0.04331539f, 0.27394319f, 
    0.02737728f, 0.01978108f, 0.07529550f, 0.02379101f, 0.00811836f, -0.06875523f, -0.06388455f, 0.09486988f, 
    -0.30918321f, -0.12557870f, -0.12815161f, -0.02136566f, -0.00851493f, -0.05719160f, 0.04039525f, 0.03235923f, 
    -0.01512458f, 0.01260659f, 0.14876281f, 0.00770731f, 0.33229053f, 0.00651645f, 0.00687708f, 0.05950839f, 
    0.04318435f, 0.03639521f, 0.00201998f, 0.04034242f, -0.05545935f, -0.03606765f, -0.05286811f, -0.09332152f, 
    0.25402009f, -0.27170339f, -0.01815796f, 0.22567640f, 0.00536406f, 0.15070704f, 0.14135244f, 0.07126518f, 
    0.00481475f, 0.16155608f, 0.03922885f, -0.00194502f, -0.12730183f, -0.06405640f, -0.05947957f, -0.03752148f, 
    -0.13437979f, 0.01347160f, 0.04705762f, -0.05131467f, -0.10287968f, -0.04475274f, 0.06781323f, 0.09614418f, 
    -0.13781267f, 0.03658170f, -0.12879519f, -0.10965113f, 0.01262922f, -0.05020310f, 0.13919204f, 0.07476858f, 
    0.11274334f, -0.05890785f, 0.14321236f, 0.04750907f, 0.19735913f, -0.06607094f, 0.07849913f, 0.22915991f, 
    0.01473744f, -0.00796021f, 0.18890867f, -0.00300750f, -0.06649567f, 0.05302658f, -0.00038568f, 0.17842053f, 
    0.22541927f, 0.02053818f, -0.06372932f, 0.04743288f, 0.08071826f, -0.06015432f, -0.02097260f, 0.00217249f, 
    -0.01317446f, -0.05386836f, -0.05075662f, -0.04212197f, -0.16094138f, 0.02826075f, 0.04423349f, 0.04050508f, 
    -0.10560131f, -0.03918949f, 0.10669835f, 0.13289502f, -0.06053268f, 0.09376100f, 0.18546121f, 0.11455170f, 
    -0.42837209f, -0.23927118f, -0.01268600f, 0.13947721f, -0.10638639f, 0.05667993f, -0.07757720f, 0.03065362f, 
    0.08663826f, -0.09933422f, -0.06610072f, 0.02734394f, -0.01309614f, 0.12092566f, -0.04384233f, 0.29831561f, 
    -0.03686676f, 0.24815038f, -0.05247617f, 0.18147631f, 0.12802149f, 0.06372246f, 0.07193471f, 0.02070601f, 
    0.21287546f, 0.08977080f, 0.15312390f, 0.13723001f, 0.08816522f, 0.09934663f, 0.07409723f, -0.01200480f, 
    0.09556576f, -0.14050153f, 0.09971133f, 0.02824228f, 0.04479235f, 0.09046326f, -0.01273481f, -0.02516325f, 
    -0.04492022f, -0.03628414f, 0.15163714f, -0.01168120f, -0.00237816f, 0.13698336f, -0.02104319f, 0.04366865f, 
    -0.12031544f, 0.16310605f, -0.01053366f, -0.03742992f, -0.03213341f, 0.11525893f, 0.01692812f, -0.01267237f, 
    0.07935756f, -0.03011067f, 0.02855273f, 0.00988834f, -0.11911549f, 0.00207582f, 0.30037808f, 0.21055999f, 
    0.03883795f, 0.02173141f, 0.05813079f, 0.05054887f, -0.09320273f, 0.09906490f, -0.11419002f, 0.22915457f, 
    -0.11951818f, 0.02664328f, -0.07885170f, -0.29045233f, 0.08776663f, 0.01056553f, 0.10466953f, -0.07852020f, 
    0.01252393f, -0.06426543f, 0.13758515f, 0.04979441f, -0.26196373f, 0.12821227f, 0.23274863f, 0.01569544f, 
    0.04671070f, 0.01567402f, 0.03102778f, -0.02106922f, -0.10808080f, -0.06492692f, 0.16455849f, -0.00165917f, 
    0.14845470f, -0.00585084f, 0.03757302f, 0.20177640f, 0.00930234f, 0.12008117f, -0.07838602f, -0.08310471f, 
    0.08749849f, 0.00272770f, 0.07093555f, -0.08601461f, -0.56128806f, -0.00983295f, 0.03803875f, -0.02775501f, 
    -0.11989372f, -0.06576713f, 0.08003660f, 0.12398101f, 0.04899572f, -0.07712247f, -0.18281049f, 0.01642273f, 
    0.43194628f, 0.17655930f, -0.14886062f, 0.03202303f, -0.10661566f, 0.04735148f, 0.13050947f, -0.07330137f, 
    0.03983345f, -0.08238552f, -0.00506852f, 0.13968664f, -0.20392081f, -0.17673911f, 0.03823280f, 0.26266024f, 
    -0.12843038f, 0.02948728f, 0.04850503f, -0.03226183f, -0.01048075f, -0.08533788f, -0.00898984f, -0.12448160f, 
    0.09644615f, 0.21312292f, 0.13787365f, -0.14360455f, 0.02524458f, 0.01731328f, 0.03503962f, -0.04847430f, 
    -0.03593171f, -0.01472961f, 0.07245436f, 0.00977614f, -0.19311920f, 0.01870785f, 0.13256900f, -0.03827865f, 
    0.09672748f, 0.02972866f, 0.02056013f, 0.08351252f, 0.00500903f, 0.05487217f, 0.03119698f, 0.04237250f, 
    0.05709412f, 0.01440292f, 0.04254052f, -0.07011411f, 0.24215329f, 0.07539853f, 0.00510943f, -0.08219925f, 
    0.02438181f, -0.03717617f, 0.05478966f, -0.03342481f, -0.15768299f, 0.25490665f, -0.08916041f, 0.28934231f, 
    0.13409112f, 0.06871936f, -0.13955085f, -0.02524227f, -0.11136267f, 0.00883697f, 0.03825545f, -0.00459439f, 
    0.03381940f, 0.02047802f, -0.19095448f, 0.06884852f, 0.05471338f, 0.00011808f, -0.12864102f, 0.03039706f, 
    -0.04682653f, 0.00622288f, 0.07576746f, -0.01982438f, 0.38526478f, 0.04349262f, -0.10190501f, 0.20948049f, 
    0.06848022f, 0.06675970f, 0.08203362f, 0.05188590f, 0.00867585f, -0.08896832f, 0.01948449f, 0.04222148f, 
    -0.16947046f, 0.27031028f, -0.10601602f, -0.01054454f, 0.08757596f, -0.01635190f, -0.02143349f, 0.09332475f, 
    0.13620998f, 0.03074332f, 0.14389232f, 0.13638991f, 0.04496699f, 0.01468208f, 0.03411741f, 0.07847469f, 
    -0.01078427f, -0.00523268f, -0.00967145f, -0.06169763f, 0.03428439f, 0.06729230f, 0.06000192f, -0.03530526f, 
    0.01733974f, 0.21531692f, -0.20165451f, 0.32815379f, 0.04361935f, 0.08637158f, -0.04975323f, -0.10691179f, 
    -0.00327010f, -0.01880138f, 0.08347563f, 0.09177914f, -0.07525507f, -0.02516247f, 0.17634822f, -0.11260200f, 
    0.11173230f, -0.11077053f, -0.08610988f, -0.00601051f, 0.06437621f, -0.00431784f, 0.13709545f, -0.00054512f, 
    -0.15314914f, -0.15232694f, 0.08142128f, 0.01262440f, 0.15707575f, 0.05648835f, -0.05314313f, -0.19980788f, 
    -0.02274938f, 0.07194972f, 0.06917802f, 0.02625999f, 0.12337529f, -0.10674009f, -0.23217686f, 0.17310169f, 
    -0.03593293f, -0.13795245f, 0.05717244f, 0.03489229f, 0.02993183f, -0.02861147f, 0.08859589f, 0.00582108f, 
    -0.52058667f, 0.05309138f, 0.21025896f, -0.01991109f, 0.02658417f, -0.02598374f, 0.04405416f, -0.04775737f, 
    -0.04943335f, 0.02418320f, 0.05307489f, -0.00135020f, 0.00167998f, -0.03951188f, 0.07547939f, 0.31724349f, 
    0.14792894f, 0.04308673f, -0.15328529f, 0.00893134f, 0.03782748f, 0.03132385f, 0.05859103f, 0.03134114f, 
    0.23155339f, -0.07724829f, -0.12131999f, -0.08816865f, 0.04920020f, 0.09660435f, -0.08459995f, -0.03467777f, 
    0.19062750f, 0.06297503f, -0.15231746f, 0.07434434f, 0.02690984f, 0.09343471f, 0.02262272f, 0.13766159f, 
    0.03640933f, 0.03913921f, -0.01094730f, -0.13274454f, -0.16593380f, -0.12803084f, 0.02849590f, -0.09361020f, 
    -0.12215955f, -0.19142492f, 0.10355158f, -0.12862918f, -0.09783448f, -0.05236312f, 0.10406227f, 0.02785342f, 
    0.14583980f, -0.01248542f, -0.02895175f, 0.05915965f, -0.00207416f, 0.32111195f, -0.04505067f, 0.18613192f, 
    0.14829695f, 0.03908239f, 0.01456372f, -0.07843132f, 0.01084602f, -0.05760662f, 0.09540841f, -0.09120049f, 
    0.09190859f, -0.01275758f, -0.11000089f, 0.07691056f, -0.12557685f, -0.05686866f, 0.02319758f, -0.08447981f, 
    -0.06016190f, -0.00623150f, -0.05783443f, -0.05361322f, 0.17060694f, 0.04868927f, -0.03699012f, -0.06718966f, 
    -0.00916575f, -0.08691168f, -0.04488454f, 0.05283401f, -0.02847146f, -0.05256865f, 0.01552470f, 0.11294422f, 
    0.07994949f, 0.13690206f, -0.25412586f, 0.15338680f, 0.00546443f, 0.01901443f, -0.15507112f, -0.02171558f, 
    0.12849796f, -0.04031419f, 0.02790459f, -0.00150026f, 0.13392796f, 0.31391022f, -0.03265477f, 0.12319661f, 
    -0.02333483f, 0.01755234f, -0.18080997f, 0.06582057f, 0.03302211f, 0.07476942f, 0.00395403f, 0.06362768f, 
    -0.10272563f, 0.17688560f, -0.08306538f, 0.09189932f, 0.05972119f, -0.07563191f, -0.01652776f, 0.04420801f, 
    0.09689595f, -0.04634675f, 0.09628160f, -0.10363118f, -0.18696636f, 0.10541997f, 0.07674637f, -0.04530532f, 
    0.08796556f, -0.03875542f, 0.01145189f, -0.02174860f, -0.02690929f, 0.10239196f, 0.00867877f, -0.03500011f, 
    -0.07462408f, 0.16763431f, -0.00845364f, -0.10373404f, 0.05295192f, -0.00063421f, -0.09759216f, -0.03329880f, 
    0.02062447f, 0.02136529f, -0.03758366f, -0.02203966f, -0.05036746f, -0.31119779f, 0.03729571f, 0.06538444f, 
    0.06265261f, 0.00600913f, 0.02860758f, -0.00206686f, 0.01594212f, 0.04406028f, 0.01628511f, 0.05494735f, 
    -0.11025812f, -0.08214623f, 0.07347219f, -0.13826247f, -0.00947382f, 0.03287758f, 0.05915115f, -0.08119167f, 
    -0.12803189f, -0.04945198f, 0.10952455f, -0.08514637f, 0.31765547f, -0.12552853f, 0.06744460f, -0.01130374f, 
    0.16828170f, -0.10626554f, 0.02873843f, 0.01595473f, -0.07727963f, -0.02303075f, 0.12685448f, -0.07635383f, 
    0.00226541f, 0.09791256f, -0.14010644f, 0.10570803f, -0.00575409f, 0.02800659f, -0.06137754f, 0.07494663f, 
    0.09736069f, 0.07413622f, 0.09932511f, -0.04111434f, -0.17101699f, -0.04402012f, 0.08385290f, 0.06711515f, 
    -0.05720540f, -0.04221608f, 0.00195128f, 0.04890336f, -0.02189220f, -0.13061956f, -0.07084633f, -0.13403724f, 
    0.15459330f, 0.18868592f, 0.16716419f, 0.02111780f, -0.05314685f, 0.10338384f, 0.07072234f, -0.06936860f, 
    0.10120151f, -0.02899889f, 0.08029754f, 0.05678929f, -0.02980541f, -0.06253988f, -0.14345542f, 0.09921048f, 
    -0.01940990f, -0.00270334f, -0.05019404f, 0.07148350f, -0.00984469f, -0.05997133f, 0.04279888f, 0.02370458f, 
    -0.18410341f, -0.00867937f, 0.01785079f, 0.14542855f, 0.18681102f, 0.01938279f, 0.00509468f, 0.00415334f, 
    -0.03611002f, 0.06164676f, -0.05809033f, -0.07845502f, 0.09528940f, -0.17114408f, -0.13378233f, -0.14269939f, 
    0.04378032f, 0.12440468f, -0.02836702f, 0.04894667f, 0.02688659f, -0.01430154f, 0.01434802f, -0.03795156f, 
    0.22220141f, 0.12863325f, 0.27619123f, -0.01225503f, 0.07630629f, -0.07273174f, -0.07782358f, -0.11208089f, 
    0.02689006f, -0.00035839f, 0.09941757f, 0.00592897f, -0.16183990f, -0.13159339f, 0.24641660f, -0.09418987f, 
    0.05701347f, -0.03314397f, -0.00143721f, 0.00665015f, 0.01914860f, -0.02003011f, -0.03808686f, -0.10452455f, 
    0.55704302f, 0.09204409f, -0.02715670f, 0.10287245f, 0.07821073f, -0.03079736f, 0.00302376f, 0.04335509f, 
    0.07258675f, -0.01398805f, 0.06035526f, 0.02685539f, -0.03096557f, -0.00102000f, 0.03387397f, 0.07197100f, 
    0.04106504f, 0.06794065f, 0.12785064f, -0.04127820f, -0.09903720f, 0.02228943f, -0.05363877f, 0.09012280f, 
    -0.20109072f, -0.10230240f, 0.02108767f, 0.04088597f, -0.08343357f, -0.10732252f, -0.02765793f, -0.03131181f, 
    0.00413125f, -0.02528452f, 0.01174904f, 0.02631572f, 0.15739369f, 0.22513689f, 0.11424085f, -0.09604016f, 
    -0.02660346f, -0.00566211f, 0.03369683f, 0.01865651f, -0.03017373f, 0.08205131f, 0.04947692f, 0.01722558f, 
    0.15054503f, -0.07667248f, -0.00740802f, -0.00440520f, 0.10474575f, -0.03871531f, 0.09256284f, 0.07387870f, 
    0.07281183f, 0.01733987f, 0.19593555f, 0.02015408f, -0.37257063f, -0.17654309f, 0.09510898f, 0.13953449f, 
    0.15166365f, 0.06651799f, 0.09124281f, -0.09170749f, -0.00334727f, 0.01497522f, 0.03182999f, -0.06338528f, 
    -0.06585960f, -0.10431262f, -0.13550353f, 0.12272821f, 0.23673603f, -0.08628459f, -0.00546101f, 0.02540241f, 
    0.11359754f, 0.06793097f, -0.13077572f, 0.00573075f, -0.08706029f, 0.07851247f, 0.18664338f, -0.04046512f, 
    -0.08872034f, -0.07848351f, -0.04484772f, 0.02444760f, 0.00862792f, 0.03178177f, -0.11185865f, -0.07078376f, 
    -0.28735483f, -0.06150942f, -0.06345008f, -0.13574518f, 0.14316763f, 0.15078266f, -0.01105725f, 0.04474410f, 
    -0.08833402f, 0.01066714f, 0.08840093f, 0.05347469f, -0.19846757f, 0.03776092f, -0.01292647f, -0.00789679f, 
    -0.08053562f, 0.02994880f, 0.05135453f, 0.07546342f, -0.00205744f, -0.09058982f, -0.02813962f, -0.08544604f, 
    0.08629086f, 0.14102989f, 0.06622055f, 0.04759328f, 0.01944150f, -0.01743248f, 0.04012835f, 0.02236146f, 
    0.03559805f, 0.12764794f, 0.03289232f, -0.04626521f, 0.18327467f, -0.00735908f, -0.01829530f, -0.01963604f, 
    0.18714908f, -0.07180680f, 0.06848829f, -0.04600172f, 0.02085713f, -0.09035893f, -0.04990380f, -0.00771027f, 
    -0.40491095f, 0.11991986f, -0.00664159f, -0.23297973f, 0.01225450f, 0.02511794f, -0.00512265f, 0.12555376f, 
    0.03224262f, 0.02958049f, 0.09406813f, -0.00509842f, -0.05870446f, -0.06324150f, 0.01235678f, 0.20686434f, 
    -0.04125638f, -0.04084288f, -0.03237851f, -0.11155777f, -0.06796844f, 0.01795371f, 0.01517139f, -0.08929586f, 
    -0.14553943f, -0.08410630f, -0.01855497f, 0.18492846f, 0.03498036f, -0.03054017f, -0.00516328f, -0.05355662f, 
    -0.08419708f, 0.00420809f, -0.06880509f, -0.08562168f, 0.28363913f, 0.20988604f, 0.15744649f, -0.12419275f, 
    0.10291882f, 0.03745780f, 0.04698999f, 0.03073387f, 0.09382876f, 0.08300504f, 0.01745166f, 0.04999230f, 
    0.25226006f, 0.08994260f, 0.05889822f, 0.15114760f, 0.04459772f, -0.08883289f, 0.15688837f, -0.00807497f, 
    0.02311766f, 0.01987003f, -0.05039544f, -0.17980987f, 0.07634937f, 0.26814508f, -0.00613412f, -0.02549668f, 
    -0.01829395f, -0.03546690f, 0.02528660f, 0.09644825f, 0.08871710f, 0.04580355f, 0.07424556f, -0.02211958f, 
    -0.18385322f, -0.03496384f, -0.06982896f, -0.04281101f, -0.13203919f, -0.07418997f, 0.10339136f, -0.04109338f, 
    0.01231269f, -0.04737493f, 0.02899553f, 0.09132733f, -0.21789390f, -0.12055537f, -0.00895674f, -0.05640956f, 
    -0.04840313f, 0.01914301f, -0.03211156f, -0.03348551f, -0.05134014f, 0.05745637f, -0.01092143f, -0.10049427f, 
    -0.37708804f, 0.21953115f, 0.38098276f, 0.00732608f, 0.08340781f, -0.00655982f, 0.05247945f, -0.05488218f, 
    -0.01194164f, -0.07419659f, 0.10016509f, -0.01637577f, 0.12976272f, -0.19073290f, -0.04259713f, -0.01959724f, 
    -0.04018461f, 0.02828818f, 0.01391800f, -0.03845013f, 0.03158562f, 0.01440585f, 0.00461674f, 0.08868050f, 
    0.08320297f, 0.19110356f, -0.10520888f, -0.21335439f, 0.05625344f, 0.05515061f, -0.02929938f, -0.00638615f, 
    0.01134059f, -0.06453535f, 0.06274649f, 0.15067564f, 0.21942139f, -0.09088231f, -0.00001327f, 0.08337276f, 
    -0.02689900f, -0.07318915f, 0.05757238f, -0.09150277f, -0.19791891f, -0.08800965f, -0.02382498f, 0.05574330f, 
    0.07943697f, 0.05992308f, 0.33067068f, -0.01156697f, -0.16656768f, 0.05665204f, -0.00681077f, -0.04405046f, 
    0.02537122f, 0.05384622f, -0.07294443f, 0.05764449f, 0.37141860f, -0.10095216f, 0.07721230f, 0.04927871f, 
    0.10332748f, 0.12687850f, 0.11248495f, -0.18626827f, 0.01670201f, -0.03571772f, 0.17112564f, 0.11359124f, 
    -0.34939775f, 0.51430082f, 0.05798007f, -0.10743988f, 0.09094354f, 0.07913996f, 0.03490596f, -0.01234327f, 
    -0.05902883f, 0.03434436f, -0.14015263f, 0.04225223f, -0.02053585f, 0.24799909f, 0.28790087f, -0.16412570f, 
    -0.12316415f, -0.09710835f, -0.06897297f, -0.14365034f, 0.04967011f, 0.00931072f, -0.03853168f, 0.02842579f, 
    0.03151635f, -0.01851797f, 0.03514128f, 0.02603985f, 0.00158585f, 0.01763676f, -0.01615089f, -0.05142673f, 
    -0.01062362f, 0.00751245f, -0.00660290f, -0.03557507f, -0.02691422f, 0.03036732f, -0.04430338f, -0.00024479f, 
    0.01188541f, -0.04506065f, 0.03489980f, -0.02463202f, -0.02839780f, -0.02974806f, -0.03784385f, -0.03667188f, 
    0.02477082f, -0.00680199f, -0.02796356f, 0.00273323f, 0.03120317f, 0.00210604f, 0.03044328f, 0.04866563f, 
    -0.03741533f, -0.00156914f, -0.03738280f, -0.05223751f, -0.02502595f, -0.04611219f, -0.04198572f, 0.00580108f, 
    -0.00304703f, 0.04483232f, -0.02831791f, -0.00093066f, 0.01262776f, 0.01860039f, -0.04655008f, 0.00876744f, 
    0.00012580f, -0.03320039f, -0.03493868f, 0.00403749f, 0.02530273f, 0.02375553f, -0.01280426f, 0.03448778f, 
    0.03183658f, 0.01921221f, -0.04356239f, -0.04363072f, -0.05591889f, 0.02928092f, -0.03430101f, -0.00946189f, 
    0.03828252f, -0.04186444f, 0.00824716f, -0.05425809f, 0.00670660f, 0.02370769f, -0.01044197f, -0.00104824f, 
    -0.03094606f, -0.03407167f, 0.03965044f, 0.00700269f, -0.04044927f, 0.04350763f, -0.05010206f, 0.01893107f, 
    -0.04709680f, -0.04606513f, 0.01288710f, 0.04417937f, 0.00302978f, -0.01586415f, -0.01357057f, 0.03705193f, 
    0.00799520f, -0.03620783f, -0.00117331f, -0.04504829f, -0.05640149f, -0.00125186f, 0.02243108f, -0.04744991f, 
    0.00568358f, -0.03041109f, -0.02876279f, 0.02745960f, -0.01816093f, 0.02490505f, 0.01313394f, 0.02473973f, 
    0.04419885f, 0.02394237f, -0.05656210f, 0.00172514f, 0.04157971f, -0.00234733f, 0.00298227f, 0.00416919f, 
    0.01404724f, -0.01310541f, 0.00055073f, -0.01818811f, -0.00183108f, 0.04087615f, 0.03847766f, -0.00644058f, 
    -0.02004556f, -0.02119654f, -0.04908574f, 0.00392015f, -0.02299067f, 0.03749895f, 0.03692544f, -0.00991270f, 
    0.03005199f, 0.04157606f, -0.05568989f, -0.05525104f, 0.00944921f, -0.01554296f, -0.04305607f, -0.03428478f, 
    -0.04805949f, 0.03924447f, -0.05436811f, -0.03582871f, -0.02390600f, 0.01779912f, -0.03542755f, -0.01784040f, 
    0.02922919f, -0.04159291f, -0.03495631f, -0.03120116f, -0.04849545f, -0.04928893f, 0.02793628f, 0.04016092f, 
    -0.02353069f, 0.00848199f, 0.00557670f, -0.05677650f, -0.04903101f, 0.02231948f, -0.01648473f, 0.03907892f, 
    0.02528339f, 0.01928257f, 0.00716518f, 0.01083230f, -0.00566950f, -0.00216008f, 0.01986395f, 0.01523288f, 
    0.01365996f, 0.01278610f, -0.04739166f, 0.04286636f, -0.03708700f, -0.04114574f, -0.04903991f, -0.02316387f, 
    0.02687423f, -0.00890660f, 0.00717169f, 0.03731252f, -0.04759698f, -0.02470908f, -0.05269249f, -0.03434689f, 
    -0.04459481f, -0.04779243f, -0.01438455f, -0.02371853f, -0.03241424f, -0.01331912f, 0.03372156f, -0.04534916f, 
    0.02021733f, 0.03577081f, -0.00026239f, 0.01708957f, -0.05276504f, 0.00266137f, 0.01536744f, -0.01233465f, 
    -0.01967975f, 0.02744708f, 0.03380504f, -0.01016277f, -0.00685190f, -0.03092901f, 0.03714493f, -0.03010286f, 
    -0.02891576f, -0.00804466f, 0.03836003f, -0.01211489f, 0.02159005f, -0.05562547f, 0.01057849f, 0.02398526f, 
    0.03072975f, -0.04888340f, 0.02167074f, -0.03738466f, 0.01397095f, 0.02028617f, 0.02140103f, -0.04278683f, 
    0.00902748f, -0.02845451f, 0.01389079f, 0.03202259f, -0.01949639f, 0.00070247f, -0.03267947f, 0.00636061f, 
    0.03330639f, 0.04389620f, -0.04291191f, -0.04663781f, -0.00683209f, -0.04196317f, 0.03392400f, 0.01109851f, 
    -0.00888477f, -0.02284474f, 0.00032953f, -0.01211333f, 0.04101001f, -0.00071219f, 0.00006565f, -0.01628029f, 
    -0.01521090f, 0.02116136f, 0.03719509f, -0.02917613f, 0.02674209f, -0.04231991f, 0.01373612f, -0.02965013f, 
    -0.00472278f, 0.00338636f, -0.00767648f, 0.00913089f, 0.02738693f, -0.05078921f, -0.01188619f, 0.02648411f, 
    0.03225671f, -0.05467097f, -0.01217256f, 0.01919404f, 0.00970145f, 0.02833992f, -0.01959356f, 0.02442918f, 
    0.04133363f, -0.02937881f, 0.04397954f, -0.03515989f, -0.02274151f, -0.02613188f, -0.01794394f, 0.03753448f, 
    -0.04160911f, -0.01510169f, -0.03240119f, -0.00652319f, 0.01547971f, -0.05075130f, 0.03934839f, -0.03168886f, 
    0.00971304f, -0.01374076f, 0.01079375f, -0.01037325f, -0.03226390f, 0.00298130f, -0.03005894f, -0.03411284f, 
    -0.00789724f, -0.03099137f, -0.02471462f, 0.00221213f, 0.01560086f, 0.00082392f, 0.01183764f, -0.05079156f, 
    0.02415081f, 0.02546992f, -0.03371805f, -0.03262507f, 0.01030150f, -0.00451816f, 0.04400181f, -0.00882888f, 
    0.02036895f, 0.04310814f, -0.03631379f, -0.03112954f, 0.00568686f, -0.02849622f, -0.02383011f, 0.01518945f, 
    -0.01232331f, -0.05496716f, -0.00877269f, -0.04650205f, -0.04432790f, -0.01968387f, 0.04306209f, -0.00679817f, 
    0.00401006f, -0.04011226f, -0.03054067f, 0.04291970f, 0.04149196f, -0.02410649f, -0.04326360f, 0.03951174f, 
    0.03877432f, -0.01905886f, -0.03525290f, 0.01544865f, -0.00196412f, -0.04297519f, 0.00118910f, 0.00381755f, 
    -0.03167103f, 0.01435985f, 0.00892700f, -0.04984520f, -0.02567946f, 0.01507534f, -0.04067046f, -0.04739027f, 
    0.02141546f, 0.01543758f, -0.02447735f, 0.04910342f, -0.05027278f, -0.01801202f, -0.01174198f, -0.00911267f, 
    -0.02678427f, 0.01858454f, -0.01281877f, 0.00000011f, 0.01675101f, -0.02597426f, -0.02391993f, 0.02465177f, 
    -0.01982076f, -0.02170841f, -0.04688569f, 0.01265524f, 0.03744016f, -0.03037872f, -0.00363763f, 0.00347957f, 
    -0.03840065f, -0.01790928f, -0.04811675f, -0.03221729f, -0.05071716f, -0.02947900f, 0.02184390f, -0.04230582f, 
    0.07142937f, 0.17526558f, 0.20453118f, -0.10172670f, 0.02807918f, -0.04126108f, 0.08197820f, -0.08812182f, 
    -0.11870393f, -0.00853335f, 0.05844283f, -0.11360028f, 0.12041263f, 0.09057348f, 0.01457412f, 0.16044204f, 
    0.05406139f, -0.04967161f, -0.00127329f, 0.15902020f, 0.08823512f, -0.01187670f, 0.03200857f, -0.04687927f, 
    -0.07083973f, 0.06211198f, -0.01081323f, -0.20768832f, 0.02909632f, -0.05234298f, 0.02174607f, 0.06905487f, 
    0.00553960f, -0.05400514f, -0.03410738f, -0.20494613f, 0.18216877f, 0.02276708f, -0.01377834f, 0.29417056f, 
    0.08984090f, 0.09438708f, 0.13471200f, 0.10172166f, -0.02476680f, 0.10061526f, -0.11547641f, -0.08872729f, 
    -0.20269686f, -0.05438184f, -0.07843242f, -0.01255536f, 0.00245239f, -0.00288640f, -0.02674673f, -0.02103996f, 
    -0.13602746f, 0.10956487f, 0.00536113f, 0.04285958f, 0.28735739f, -0.17412038f, 0.11012907f, 0.15476634f, 
    -0.01555342f, 0.06084561f, -0.02221056f, -0.00345271f, -0.02637008f, 0.12181447f, 0.04170534f, -0.03787419f, 
    -0.08942518f, 0.06549674f, -0.00096477f, -0.00181500f, 0.00430648f, 0.10004743f, -0.05257758f, 0.08608508f, 
    0.07168699f, 0.00199001f, 0.09387796f, 0.02838085f, 0.03685987f, -0.13935617f, 0.00421002f, -0.22339369f, 
    -0.14842409f, -0.04780497f, 0.11545780f, 0.11927619f, 0.05021618f, 0.03930513f, 0.00392354f, 0.01269114f, 
    -0.03258546f, 0.01917298f, -0.00474572f, 0.26572677f, 0.02684282f, 0.04721060f, 0.29867503f, -0.02728916f, 
    -0.09369601f, 0.04328758f, 0.08265912f, 0.04730880f, 0.09672572f, 0.08956587f, 0.20019002f, 0.03747991f, 
    0.03619102f, -0.02261368f, -0.03026234f, -0.06621896f, -0.06937065f, -0.06195210f, 0.07904430f, -0.16330466f, 
    -0.00535676f, 0.09843815f, -0.13650453f, -0.01516721f, -0.06346159f, 0.04640896f, -0.07465146f, -0.06177207f, 
    0.00124347f, 0.01780990f, -0.05792042f, -0.02819625f, 0.12868494f, 0.03983321f, 0.07942386f, 0.11808115f, 
    -0.04408754f, -0.00797141f, 0.10546628f, -0.07454909f, 0.03066949f, 0.00008423f, -0.21631111f, -0.08866601f, 
    -0.05616564f, 0.08149821f, -0.09388021f, -0.01146214f, -0.03964527f, -0.07175197f, -0.00936215f, 0.12366258f, 
    0.00447358f, 0.06213417f, 0.16087361f, 0.12566957f, 0.05476660f, -0.07470065f, 0.13229460f, 0.17855939f, 
    0.09992819f, 0.02082014f, 0.11124054f, 0.01516490f, -0.01434576f, -0.12054298f, -0.05237360f, 0.00893373f, 
    0.10487241f, -0.05640423f, 0.09627073f, 0.17992756f, -0.03270048f, 0.06175835f, 0.14096217f, 0.10239380f, 
    0.08163447f, 0.09173131f, -0.02902043f, -0.07152928f, 0.13196696f, 0.14261743f, 0.07980870f, 0.19879486f, 
    -0.18435670f, 0.02109466f, -0.05386896f, -0.10750413f, -0.17975233f, -0.11055457f, 0.12406050f, -0.08019754f, 
    -0.04126377f, -0.01987317f, 0.00846246f, -0.01822740f, 0.04064173f, -0.02790563f, 0.05426464f, 0.04120892f, 
    0.11346614f, 0.05895478f, 0.06569007f, 0.08723023f, 0.10587374f, 0.19847053f, 0.01229881f, 0.15533172f, 
    -0.01536493f, -0.03110225f, 0.15627672f, -0.10613772f, 0.00020090f, 0.13770674f, -0.04221719f, 0.15076329f, 
    0.12514690f, -0.06037704f, -0.07509060f, 0.00049868f, -0.05156423f, -0.00943056f, 0.03941617f, -0.10959816f, 
    -0.01194499f, -0.09408873f, -0.00404763f, -0.13125946f, -0.20469755f, -0.06210196f, -0.00090467f, -0.23806667f, 
    -0.03072545f, 0.01296783f, 0.19063139f, 0.00519343f, -0.01590800f, 0.00892741f, -0.01498375f, 0.13992698f, 
    -0.34763801f, -0.01752740f, 0.14815217f, 0.20171940f, -0.02098161f, 0.05285274f, -0.03664529f, 0.05181426f, 
    0.07715866f, -0.02152098f, -0.06401879f, -0.06967095f, 0.02052105f, 0.12034672f, -0.02904545f, 0.23043254f, 
    -0.01652294f, 0.08402862f, -0.00543937f, 0.13236965f, 0.01778874f, -0.11111933f, 0.09611725f, 0.17360447f, 
    0.06447261f, 0.24723674f, 0.03723283f, 0.03796047f, 0.18901983f, 0.12142464f, 0.02736449f, 0.01611554f, 
    0.07137881f, -0.12506148f, -0.00761441f, 0.07369359f, 0.04210282f, 0.05180397f, 0.01882328f, -0.03181919f, 
    -0.03354482f, -0.19655709f, 0.24865353f, -0.18809654f, -0.06080535f, 0.24329814f, -0.05523625f, -0.03730924f, 
    -0.07379498f, 0.10808980f, 0.10368855f, -0.14020197f, 0.01097941f, 0.08174742f, -0.02473255f, 0.04217454f, 
    0.01491345f, 0.07273960f, 0.07710809f, 0.06532577f, 0.01265892f, 0.09601839f, 0.05701490f, 0.19300161f, 
    -0.05737433f, 0.08429093f, 0.05930771f, -0.00845058f, -0.03396516f, 0.01368568f, -0.09176783f, -0.00028080f, 
    -0.26878473f, -0.01973207f, -0.06113702f, -0.13274994f, 0.08317732f, 0.07550006f, 0.09764657f, 0.06433713f, 
    -0.08075378f, -0.01597620f, 0.13082793f, 0.04473896f, 0.13978450f, 0.23389785f, 0.08519842f, -0.06277888f, 
    0.02926191f, -0.04051411f, 0.06425115f, 0.04745654f, 0.03757871f, -0.01274020f, -0.03419476f, -0.00157746f, 
    0.14371094f, 0.21796474f, -0.09645624f, 0.09014699f, 0.01581972f, 0.19026105f, -0.05947414f, 0.00898589f, 
    0.07939507f, -0.00984514f, 0.04579126f, -0.05068292f, -0.26894441f, -0.14948763f, 0.01883090f, 0.03788142f, 
    -0.04316467f, 0.00562542f, 0.14888310f, 0.10008352f, -0.08328682f, -0.08960164f, -0.11317683f, 0.14866734f, 
    0.01524394f, 0.15718473f, -0.08910330f, -0.11228361f, -0.00163857f, 0.00056537f, 0.13545914f, -0.01512375f, 
    -0.04674583f, 0.00841606f, -0.10674898f, -0.04906690f, 0.05996288f, -0.01389730f, -0.20481367f, 0.00572715f, 
    -0.09173594f, -0.06336363f, 0.06000117f, 0.08778417f, 0.00451568f, 0.01622288f, 0.05113189f, -0.12423760f, 
    0.02160135f, -0.01125200f, 0.00241697f, -0.03371578f, 0.01366142f, -0.04510641f, 0.02306233f, -0.00124826f, 
    0.01857360f, -0.04638717f, 0.01689972f, 0.01898801f, -0.02976810f, 0.02057262f, -0.00596067f, -0.02604608f, 
    -0.03214882f, 0.04280021f, -0.02857280f, -0.03262859f, -0.01015326f, 0.00698711f, 0.01788500f, 0.04374166f, 
    0.01649285f, 0.03334609f, -0.00939895f, -0.03621097f, -0.04165632f, -0.01339919f, -0.04831551f, -0.01393075f, 
    0.03353070f, 0.04219791f, 0.01123965f, 0.02592508f, 0.00345012f, 0.03279977f, -0.02552670f, -0.01639501f, 
    -0.03296480f, -0.05257186f, -0.04777804f, -0.04570372f, -0.02058319f, -0.02442160f, 0.03719193f, -0.01261917f, 
    0.02834158f, -0.03704844f, 0.03582474f, 0.00059459f, 0.00179069f, -0.01389677f, -0.02459714f, 0.03384870f, 
    -0.00377461f, -0.00560572f, -0.05550495f, -0.00899846f, 0.04068251f, 0.01593238f, -0.02421238f, -0.04495451f, 
    -0.04502270f, 0.01296844f, 0.01781401f, -0.04390239f, -0.01667430f, -0.05174667f, 0.01021270f, -0.04662067f, 
    -0.01204085f, -0.00731331f, -0.04864291f, -0.05385884f, -0.00095841f, -0.04406959f, 0.00031614f, 0.02370460f, 
    -0.01179368f, -0.01220141f, -0.04427646f, -0.01692900f, 0.01733828f, -0.01441594f, -0.05476884f, -0.03048300f, 
    -0.00485156f, 0.03917377f, -0.02566103f, -0.01595071f, -0.03024104f, -0.04060228f, 0.00764338f, 0.00690967f, 
    0.02245337f, -0.03849775f, -0.04805310f, -0.02316697f, 0.00154727f, 0.01980952f, 0.01805733f, -0.01188095f, 
    0.00069711f, -0.04199841f, -0.04232473f, 0.01644523f, 0.03456561f, 0.02134272f, -0.05555335f, -0.02821374f, 
    -0.04621623f, -0.04518348f, -0.01801723f, 0.02233344f, 0.00473749f, -0.03497100f, -0.02110826f, 0.00861523f, 
    -0.00200670f, 0.03006165f, 0.04039798f, -0.02975046f, -0.01182117f, -0.04739424f, 0.02591895f, 0.03540658f, 
    0.03627558f, 0.01959032f, 0.00673084f, -0.03015016f, 0.03610247f, -0.05432055f, 0.04548640f, -0.02557561f, 
    0.00181894f, 0.04160550f, -0.04066699f, 0.03878883f, -0.00183281f, 0.01645454f, 0.00591378f, -0.00584857f, 
    0.03914172f, 0.02450693f, 0.04103954f, -0.04249771f, 0.01156624f, -0.02013637f, -0.05068085f, -0.03063517f, 
    -0.05442487f, -0.00730846f, 0.00234502f, -0.02248352f, 0.00197567f, -0.00247487f, 0.04150163f, 0.01880079f, 
    -0.04507035f, -0.01557962f, 0.00814590f, -0.01161586f, 0.01258211f, -0.01704985f, 0.00028930f, -0.00712114f, 
    -0.00094471f, -0.02613016f, 0.02667743f, -0.02131622f, 0.01923586f, -0.02797555f, -0.01145171f, -0.04859049f, 
    -0.05214852f, 0.03744572f, -0.05225400f, 0.00173776f, -0.04016249f, -0.01572538f, 0.03256963f, -0.00601877f, 
    0.04478911f, 0.02488409f, 0.01419588f, -0.01756145f, 0.02915996f, -0.02150256f, -0.02539365f, -0.05001164f, 
    -0.04643426f, -0.02065506f, -0.02399923f, 0.00037169f, -0.00671917f, -0.05399321f, 0.01306723f, 0.01630522f, 
    -0.03950371f, 0.00700754f, 0.02842531f, 0.01058955f, -0.00092577f, -0.03214467f, -0.03766508f, 0.00285146f, 
    -0.01875580f, -0.04635449f, 0.03213315f, -0.05465842f, 0.00411136f, -0.01106250f, -0.04799302f, 0.00056656f, 
    0.02715732f, -0.02933016f, -0.01828551f, 0.00060236f, -0.02368923f, -0.01719356f, 0.00281507f, -0.03690703f, 
    -0.04262189f, -0.00506608f, -0.02469314f, 0.03043224f, 0.02150724f, -0.04342289f, -0.00747757f, -0.00555041f, 
    -0.00137715f, 0.04555240f, 0.00161076f, -0.00521908f, 0.00935325f, -0.04241198f, -0.05216024f, -0.01094397f, 
    0.02782679f, -0.04758064f, 0.03602833f, -0.04922362f, -0.04615457f, -0.04184943f, -0.05325864f, 0.02627488f, 
    -0.03092811f, -0.03788234f, -0.00744268f, -0.03968892f, 0.04455129f, 0.00168860f, 0.00545447f, 0.00335780f, 
    -0.03091787f, -0.01400299f, -0.00601272f, 0.04395936f, 0.02723947f, 0.02581188f, 0.03093222f, 0.01326709f, 
    -0.04501641f, 0.03639674f, -0.05579442f, -0.04825900f, -0.00982924f, -0.04021209f, -0.02367129f, 0.01470084f, 
    0.04195240f, 0.00922123f, 0.03520838f, -0.00651792f, 0.02848327f, -0.03254173f, 0.03058561f, -0.05079219f, 
    -0.03324937f, -0.04918262f, 0.00611933f, 0.00294624f, -0.01167499f, -0.04096605f, -0.01433969f, -0.05494405f, 
    -0.03529970f, 0.00351069f, -0.03229377f, 0.02161554f, -0.01816689f, -0.01663669f, 0.02031581f, -0.03520026f, 
    0.04045244f, 0.02727952f, -0.03005737f, 0.01928507f, 0.02214473f, -0.03023120f, -0.03961876f, 0.03223024f, 
    -0.02622361f, -0.03304483f, 0.01200701f, 0.02875432f, 0.02658712f, 0.00774308f, -0.03043749f, -0.03715120f, 
    -0.05246425f, -0.00717838f, -0.01276478f, -0.05054360f, -0.02161288f, -0.05173774f, -0.01285402f, -0.03969118f, 
    0.00163227f, -0.05160641f, 0.04417443f, 0.01493130f, 0.03027028f, -0.02640256f, 0.03826023f, 0.00645013f, 
    0.03896978f, 0.00606436f, 0.00373464f, 0.02663537f, -0.01827173f, -0.02811344f, 0.01917737f, -0.05275564f, 
    0.01928231f, 0.01081258f, -0.03422120f, 0.03960369f, 0.00537599f, -0.02104524f, -0.02353096f, -0.04808288f, 
    -0.04795440f, -0.02835978f, -0.00474481f, -0.01971452f, -0.00317571f, 0.01740238f, -0.00499822f, -0.02379753f, 
    -0.05374572f, 0.03002124f, -0.02219064f, 0.02957492f, 0.02406012f, 0.02283443f, -0.01930437f, -0.02722600f, 
    0.04387606f, -0.01229698f, -0.03923134f, 0.04537901f, 0.01293235f, 0.03553871f, -0.04977886f, -0.02201366f, 
    0.01257550f, 0.02204150f, 0.03775591f, 0.01834893f, -0.04241609f, -0.02220351f, -0.02228044f, -0.04851650f, 
    -0.03900567f, 0.00387810f, 0.03558287f, 0.03997892f, 0.02322297f, -0.00207189f, -0.02465501f, -0.02904406f, 
    -0.05459748f, -0.01681008f, 0.02220709f, -0.02260311f, -0.04250563f, 0.02965874f, 0.01175077f, 0.01894738f, 
    -0.00066398f, 0.03155138f, 0.03014808f, 0.00468009f, 0.02241678f, 0.04329367f, 0.04127140f, -0.01433384f, 
    -0.03548581f, 0.00851954f, -0.00162491f, -0.00961640f, -0.03923096f, -0.04792445f, -0.04065232f, -0.02697817f, 
    -0.02291743f, -0.04733427f, -0.00807367f, 0.00713233f, -0.03750771f, -0.04623661f, -0.05382509f, 0.00445916f, 
    0.02627899f, -0.01170249f, 0.04828907f, -0.03754027f, 0.02988135f, 0.02810177f, -0.02217109f, -0.03638437f, 
    -0.00592046f, -0.04094844f, -0.01657194f, -0.03260189f, -0.04683508f, -0.04860260f, -0.01837391f, -0.04813425f, 
    0.03610514f, 0.03855268f, -0.04836881f, -0.01149953f, -0.02854489f, 0.00673466f, -0.01240129f, -0.01771551f, 
    0.02223613f, 0.02786713f, -0.02353360f, 0.03570754f, 0.03918980f, 0.02618174f, -0.01155437f, 0.03410505f, 
    0.04485383f, 0.00025466f, 0.03162052f, -0.04521138f, -0.03242221f, 0.03040648f, 0.03210701f, 0.03732778f, 
    -0.04297122f, -0.01578553f, -0.05152841f, -0.00525300f, 0.03876682f, -0.01973244f, -0.03324777f, -0.00742526f, 
    -0.03018926f, 0.02967073f, 0.04071340f, 0.01063056f, -0.03368373f, -0.05576116f, -0.02636534f, -0.00961563f, 
    -0.03056812f, -0.00823796f, -0.00716532f, -0.00751163f, 0.02376472f, 0.01231860f, 0.00137274f, -0.03323889f, 
    -0.04403418f, 0.02191137f, 0.00739996f, 0.03841089f, 0.02818794f, -0.01588486f, -0.03375331f, 0.02876644f, 
    -0.03413348f, 0.01004525f, 0.01719119f, -0.03104852f, -0.02681587f, -0.03028778f, 0.02227594f, 0.02042875f, 
    0.00214444f, 0.00760423f, -0.02468170f, 0.03881230f, 0.04422476f, -0.00687851f, 0.00713382f, -0.02974297f, 
    -0.04024060f, 0.03511755f, 0.04342707f, 0.02854554f, -0.02537276f, -0.01383259f, 0.04962917f, 0.01995757f, 
    -0.02700959f, -0.02880161f, 0.03906836f, 0.01296825f, -0.03232325f, 0.03062090f, -0.04873756f, -0.03056666f, 
    -0.01755388f, -0.01382974f, -0.00653137f, -0.02507171f, -0.05616444f, 0.01299212f, 0.01649794f, -0.03347352f, 
    0.01148502f, -0.00373848f, 0.04027503f, -0.02721573f, -0.00284262f, -0.02211766f, -0.02752605f, 0.00645546f, 
    -0.00873709f, -0.04193586f, -0.05768650f, -0.01992917f, 0.02005353f, 0.03459595f, -0.02665907f, -0.01093788f, 
    -0.00727656f, 0.00935424f, 0.00274433f, -0.01771340f, -0.01785518f, 0.04147274f, -0.02757052f, 0.00741881f, 
    -0.00157517f, 0.04619740f, -0.00839271f, -0.04500179f, 0.04545338f, 0.03519962f, 0.03984344f, 0.01199468f, 
    -0.00669652f, -0.01511699f, -0.04279226f, -0.02149033f, -0.00701223f, -0.02013276f, -0.03207159f, 0.03656835f, 
    -0.01918959f, -0.05445119f, -0.01246488f, -0.04175389f, 0.02259307f, 0.01982873f, 0.01530336f, -0.00008893f, 
    -0.02365205f, 0.02879073f, -0.00239814f, 0.03303616f, 0.03000400f, -0.05044115f, 0.02806654f, -0.03563909f, 
    0.00991254f, 0.01121357f, 0.03928909f, -0.02095452f, -0.00190170f, 0.00375413f, 0.03538949f, -0.03680595f, 
    0.01223991f, -0.01535431f, 0.02420647f, 0.02227575f, 0.03417014f, -0.04014605f, -0.00150146f, 0.00154393f, 
    0.01876948f, -0.02119251f, -0.02464273f, 0.04944454f, 0.00613768f, 0.00181194f, 0.02009651f, -0.02389587f, 
    -0.02590789f, 0.03571386f, -0.02879362f, -0.03179311f, -0.03989111f, -0.01646316f, 0.03329933f, -0.00335689f, 
    -0.00277626f, -0.04810274f, 0.00765120f, 0.01908784f, -0.02240910f, 0.01374576f, -0.00022142f, 0.00949094f, 
    -0.02474033f, 0.03878419f, -0.00295692f, 0.02811156f, -0.03361912f, 0.03939580f, 0.01266106f, -0.02315418f, 
    -0.05097364f, 0.03909758f, -0.02804446f, 0.03032262f, -0.00761069f, 0.02630672f, -0.03697279f, 0.03830322f, 
    -0.02584851f, 0.01857639f, -0.03935184f, 0.03410238f, 0.04006698f, -0.01621430f, -0.01356988f, -0.02926973f, 
    0.02293987f, -0.02244531f, -0.00021993f, 0.02031392f, -0.01216124f, -0.02734328f, 0.01951718f, 0.00484690f, 
    0.05458685f, 0.01307533f, 0.01704825f, 0.01051591f, 0.00366499f, -0.02565838f, -0.02811441f, 0.00654456f, 
    0.00298372f, 0.04093395f, 0.04610625f, -0.03276127f, -0.02318480f, -0.00818408f, -0.04351749f, -0.02757168f, 
    -0.03046948f, 0.03593484f, 0.00162088f, -0.03408943f, -0.03756705f, -0.02944866f, 0.01776862f, 0.02897458f, 
    -0.00570803f, -0.05120908f, -0.04266703f, -0.05977157f, -0.03721850f, -0.04241712f, 0.02969079f, -0.02642451f, 
    -0.06046744f, 0.01647115f, -0.03156032f, 0.04300853f, -0.02478785f, 0.00472218f, -0.00351406f, -0.01832004f, 
    0.01668088f, -0.01847714f, -0.04689484f, -0.00198854f, -0.05434609f, -0.02938471f, -0.01674365f, 0.04175669f, 
    -0.05265727f, 0.03435666f, 0.00553441f, -0.04597327f, -0.02030778f, -0.04359930f, -0.03531702f, -0.00011249f, 
    -0.02209153f, 0.00897487f, -0.03375392f, 0.00620948f, -0.05041857f, -0.04533911f, 0.02272508f, 0.01835165f, 
    -0.00409575f, -0.02056312f, -0.01777701f, 0.04691904f, -0.00637795f, -0.00643687f, -0.04915075f, -0.02097836f, 
    0.04647189f, 0.00257366f, -0.02667090f, -0.05515814f, -0.03924017f, -0.04064185f, -0.03633584f, 0.03043714f, 
    -0.00945271f, -0.03741796f, -0.01175699f, 0.01763832f, 0.03744752f, 0.01661456f, -0.03554738f, -0.02938217f, 
    0.03643323f, -0.02869146f, -0.04198271f, -0.01320883f, -0.02109865f, -0.00932049f, -0.02789917f, 0.03491662f, 
    0.02714328f, 0.01021472f, 0.01569858f, -0.02119778f, -0.03297824f, 0.00817562f, 0.00823876f, 0.02256303f, 
    -0.00865229f, -0.03193440f, -0.02319345f, -0.04733820f, 0.01066686f, -0.05706214f, -0.02845826f, -0.05515568f, 
    -0.00165797f, -0.11184969f, -0.16222633f, 0.13586050f, 0.00908860f, 0.05629301f, -0.05507372f, 0.00810433f, 
    -0.02670987f, 0.05850900f, 0.00922971f, 0.04996235f, -0.05194427f, -0.05379443f, 0.09661313f, 0.14988002f, 
    0.00199514f, 0.04189687f, -0.05175297f, -0.14430372f, 0.05003534f, 0.10380404f, -0.04985425f, -0.06398693f, 
    -0.05120753f, 0.01008120f, 0.11799498f, 0.13384081f, -0.13208862f, -0.07786265f, -0.04368797f, 0.00233333f, 
    -0.08823129f, -0.00476269f, -0.03822754f, 0.07717873f, 0.06274279f, 0.10824020f, 0.27354813f, -0.28104851f, 
    -0.06117082f, 0.05292284f, -0.02494938f, 0.08912870f, 0.18864045f, -0.03855862f, 0.02997055f, -0.02974815f, 
    0.24321020f, 0.06355138f, 0.05421663f, 0.01846785f, -0.13898551f, 0.03820284f, 0.07747278f, 0.05769008f, 
    0.02852072f, -0.02775226f, 0.05187485f, -0.03974379f, 0.01120863f, 0.14319216f, 0.25003406f, -0.02717315f, 
    -0.06487232f, -0.01450612f, 0.08957918f, 0.03344638f, 0.14434862f, 0.02619714f, -0.01572561f, 0.14174919f, 
    -0.08318444f, -0.06088208f, 0.04407086f, 0.11967067f, -0.05639635f, -0.00748081f, 0.00963831f, -0.00989180f, 
    -0.01168080f, 0.09640600f, 0.06217728f, 0.10817077f, -0.02600056f, -0.03529064f, 0.02984877f, 0.06864794f, 
    -0.14433351f, -0.06638948f, 0.02179315f, 0.10075791f, 0.09929193f, 0.02398366f, -0.03217495f, -0.04742728f, 
    -0.14780642f, 0.02003614f, 0.09686144f, -0.46880111f, 0.06697249f, -0.01891742f, 0.06671134f, 0.04079077f, 
    0.05691409f, -0.01295550f, 0.05495893f, 0.02310995f, -0.19438827f, 0.17279397f, -0.06036152f, 0.35324496f, 
    -0.04044169f, 0.15669237f, 0.02100664f, 0.05659335f, -0.03864004f, 0.08811151f, -0.03114012f, -0.02649891f, 
    0.15821160f, -0.05303982f, 0.05414283f, -0.04566823f, -0.06320211f, 0.02444687f, 0.16334839f, 0.06107254f, 
    0.04573556f, -0.11210147f, 0.07936816f, 0.09002075f, 0.04507814f, 0.07320525f, 0.02295079f, -0.06130386f, 
    -0.01596951f, 0.03554152f, -0.04665198f, 0.02688054f, -0.03250671f, 0.16455236f, -0.05262514f, 0.01709380f, 
    0.17705338f, 0.22487767f, 0.08807430f, -0.35442850f, 0.00388518f, 0.07440101f, -0.02215853f, -0.04491041f, 
    0.00488440f, 0.05077593f, -0.06510241f, 0.11569229f, 0.11357970f, 0.03803283f, -0.02229910f, -0.16008319f, 
    -0.10060886f, -0.06170319f, -0.03835010f, 0.03501720f, 0.21500485f, 0.05344883f, -0.14432821f, 0.08285969f, 
    -0.12200388f, 0.22420150f, -0.06700381f, 0.13752483f, 0.03197904f, -0.12782608f, 0.09042221f, 0.05935352f, 
    -0.00916739f, -0.00637443f, 0.09358355f, 0.05064994f, -0.06612644f, -0.07892630f, 0.01357572f, -0.31860581f, 
    0.06079194f, 0.05271517f, 0.15308079f, 0.03286756f, 0.04926820f, -0.03230911f, 0.07377065f, 0.10544523f, 
    0.19357155f, 0.08366938f, -0.12320209f, 0.19292100f, 0.03795632f, 0.07284129f, -0.04541915f, -0.05748766f, 
    0.01322462f, 0.12198738f, 0.13410276f, -0.03008676f, 0.10261843f, 0.02952053f, 0.11477064f, -0.11925991f, 
    -0.00469337f, 0.01424608f, -0.10815161f, 0.03340136f, 0.09526520f, 0.09184888f, 0.01443979f, 0.02360245f, 
    -0.17575930f, 0.18514743f, -0.01922804f, -0.10208634f, 0.04937470f, 0.04449967f, 0.09259363f, 0.02733542f, 
    -0.00548716f, -0.02506556f, 0.02103817f, 0.03345923f, 0.03096242f, -0.04514468f, -0.04481711f, 0.10728481f, 
    -0.07196575f, -0.06097258f, 0.10991308f, -0.09026109f, 0.14130126f, -0.03706000f, 0.00568758f, -0.17164996f, 
    0.15859509f, 0.15522878f, -0.04894724f, -0.11118353f, 0.02566534f, 0.04032528f, 0.03012737f, 0.05722199f, 
    -0.02596458f, 0.02379275f, 0.08060772f, 0.07209668f, 0.20046712f, -0.01370597f, 0.08215669f, -0.17159902f, 
    -0.12989265f, -0.06945731f, 0.01657796f, 0.09634144f, -0.01269637f, -0.06709674f, 0.07038351f, 0.00362675f, 
    0.21417557f, -0.07989541f, 0.09972390f, -0.01366692f, -0.08282837f, 0.02459885f, 0.04240111f, 0.03098528f, 
    -0.15884420f, -0.02569833f, -0.00467174f, 0.13434541f, -0.04710555f, -0.03518365f, -0.17157514f, -0.04452698f, 
    -0.11317919f, -0.01794589f, 0.00726286f, 0.06453578f, -0.09542123f, 0.03850777f, -0.17245923f, -0.03320788f, 
    0.09693350f, 0.11145054f, -0.10183534f, 0.23909505f, 0.02818456f, 0.06101916f, 0.00095417f, 0.09021554f, 
    -0.05873308f, 0.05402670f, -0.04253909f, 0.03146555f, -0.13710786f, 0.09389701f, -0.01696742f, -0.01487946f, 
    0.05085789f, 0.12966947f, -0.00583672f, 0.09058186f, 0.04277410f, -0.11047655f, -0.02683381f, -0.11420282f, 
    0.43636176f, -0.03072076f, 0.01102551f, 0.28089738f, -0.05785952f, 0.02025925f, -0.06418984f, 0.01131937f, 
    -0.02341539f, 0.15790649f, 0.09105676f, 0.10429062f, 0.26477742f, -0.05066347f, -0.17589667f, 0.05323055f, 
    -0.02393059f, 0.04390964f, -0.03019433f, -0.03751170f, 0.06802008f, 0.02921675f, -0.07291244f, 0.21343735f, 
    0.01389416f, -0.03396064f, -0.00827639f, -0.17948762f, 0.01205320f, 0.06247126f, -0.06593343f, 0.05960672f, 
    -0.06806233f, -0.14969714f, -0.08662442f, -0.01339596f, 0.14617983f, -0.11236212f, 0.11303437f, -0.01763321f, 
    0.02483826f, 0.07241094f, -0.03386749f, -0.12901500f, 0.00534139f, 0.08365168f, 0.03137302f, 0.14913335f, 
    -0.25479582f, 0.02472606f, -0.08199406f, 0.19080192f, -0.06029334f, 0.00745923f, -0.10773003f, 0.05453487f, 
    -0.12548554f, -0.00758229f, -0.03676283f, -0.02170185f, 0.02538771f, -0.10272494f, 0.05773127f, -0.19789283f, 
    0.02841811f, -0.00093608f, -0.04246387f, 0.11737967f, 0.13527128f, 0.02347983f, -0.10431646f, -0.11118083f, 
    -0.03292149f, 0.00298882f, 0.01337291f, 0.02406771f, -0.00772827f, -0.05689586f, 0.00912815f, 0.00349108f, 
    -0.01293957f, -0.02798397f, -0.01935878f, 0.03149779f, -0.05633819f, 0.01678637f, -0.04026794f, -0.02264895f, 
    0.02023654f, -0.05140518f, -0.01475759f, -0.03722176f, -0.00998474f, 0.00122229f, -0.00481320f, -0.03303201f, 
    0.04222167f, -0.03592104f, -0.04909517f, 0.00508576f, -0.05317200f, 0.03076580f, -0.02660715f, 0.01792311f, 
    0.00612255f, -0.03585685f, 0.01477757f, -0.02884794f, -0.03197819f, -0.00293646f, -0.00664719f, 0.01976548f, 
    -0.00757117f, -0.04626877f, 0.02691309f, 0.03075679f, -0.01396781f, 0.03847237f, -0.02988313f, -0.05254358f, 
    0.00155651f, 0.00977033f, 0.02763666f, -0.01327222f, -0.03850420f, -0.01644284f, -0.00871992f, -0.03661385f, 
    0.04413815f, -0.05467620f, -0.03918380f, -0.03217778f, -0.03970638f, 0.00844616f, 0.00174760f, 0.02947159f, 
    -0.00137387f, -0.03006313f, -0.00353291f, 0.02049818f, -0.02765468f, -0.01408068f, -0.02312043f, 0.00106670f, 
    -0.04977297f, -0.01841588f, 0.04132505f, -0.04164938f, -0.01453926f, -0.04728993f, -0.04341403f, -0.02015749f, 
    -0.05330315f, 0.03346459f, 0.03521508f, -0.03398594f, -0.02069058f, -0.02919551f, 0.00417681f, -0.04106295f, 
    -0.03372997f, -0.05637724f, -0.00636714f, 0.00573560f, 0.00592549f, 0.00463975f, 0.00160616f, 0.01175308f, 
    0.02901951f, -0.04459463f, -0.01505374f, -0.00444782f, -0.01021191f, -0.00646621f, -0.01635165f, -0.05016413f, 
    -0.03382201f, 0.02046938f, 0.03964366f, 0.00615426f, -0.00523151f, 0.04191560f, 0.03670404f, -0.00807605f, 
    -0.01712673f, 0.04377757f, -0.00961825f, -0.00276691f, -0.03911128f, -0.04562550f, 0.03039637f, 0.00476355f, 
    0.01169299f, -0.01711787f, -0.00857832f, 0.00711255f, 0.03796950f, -0.01836316f, -0.05534445f, -0.03319245f, 
    0.00092267f, -0.05127447f, -0.01782924f, 0.04439049f, 0.04070654f, -0.04444631f, -0.02254961f, 0.02032019f, 
    -0.03516965f, -0.00373149f, -0.04610059f, -0.02709827f, -0.04064227f, -0.02959114f, -0.00367544f, -0.04706471f, 
    -0.01953808f, -0.04398288f, -0.02516191f, -0.00017920f, -0.02307285f, -0.02087245f, -0.05416423f, -0.01982108f, 
    -0.00368165f, 0.02221696f, 0.01474209f, 0.00508385f, -0.00284435f, 0.02663087f, -0.01765118f, -0.00971121f, 
    0.03968082f, -0.00897740f, -0.05325121f, 0.00669430f, 0.00283891f, 0.02898578f, -0.03677685f, 0.00348470f, 
    0.00312034f, -0.03010686f, 0.02403776f, -0.04506470f, -0.03408676f, 0.01042704f, -0.01929320f, -0.03690641f, 
    0.02115035f, 0.02638842f, 0.04274204f, -0.04578928f, 0.03096013f, -0.03197295f, 0.01429211f, 0.03986882f, 
    0.01004401f, -0.05114769f, -0.00753809f, -0.04684768f, -0.02149837f, 0.00167903f, -0.05386459f, -0.03046498f, 
    -0.04437288f, -0.01019451f, -0.01182459f, -0.01389518f, 0.01667120f, -0.02750912f, 0.02611519f, -0.04270719f, 
    -0.01578202f, -0.00853505f, 0.02252712f, 0.03975649f, -0.00636316f, -0.02756249f, -0.00009595f, 0.00168481f, 
    0.00295587f, -0.01806419f, -0.05247021f, -0.00643775f, 0.04115929f, 0.03844246f, -0.03242888f, -0.05279094f, 
    0.03249309f, -0.00216644f, -0.02304193f, -0.03716478f, -0.02909642f, 0.02253089f, 0.00262606f, 0.04484480f, 
    -0.03453913f, 0.02262682f, 0.03156952f, 0.00961206f, 0.00397359f, -0.03268024f, -0.01665980f, -0.01184051f, 
    0.01219351f, -0.02611713f, 0.03493213f, -0.02699848f, 0.01736940f, 0.00792090f, -0.04945695f, -0.04713878f, 
    0.03248718f, -0.03016531f, 0.00331769f, 0.02631799f, 0.02602982f, -0.01031648f, -0.03167830f, -0.02895985f, 
    -0.03091881f, 0.00929690f, 0.02533262f, -0.00322272f, -0.01516660f, 0.01309510f, 0.02745620f, -0.03255173f, 
    0.01032053f, 0.03552588f, -0.05375454f, -0.03110090f, 0.04485704f, 0.01285341f, 0.00699660f, -0.01544923f, 
    0.01663601f, 0.02584207f, 0.03652830f, -0.04226644f, 0.02564332f, -0.02949342f, 0.03989539f, 0.03408321f, 
    -0.04091435f, -0.03443031f, 0.00235430f, -0.00678187f, 0.02704487f, -0.02447578f, -0.00443181f, -0.00217203f, 
    -0.01161131f, 0.01121539f, -0.01628230f, -0.03174611f, 0.01428848f, -0.04957808f, 0.03481542f, -0.02079774f, 
    -0.04505794f, -0.00633938f, 0.04382742f, -0.04808754f, -0.04979263f, 0.02615226f, 0.01236805f, -0.05559329f, 
    -0.05365922f, -0.05473232f, -0.04625132f, 0.03065789f, 0.00121271f, 0.03665244f, 0.00838493f, -0.03127755f, 
    0.02811528f, -0.02942900f, -0.05391132f, 0.01688109f, 0.03070357f, 0.02268751f, 0.00258032f, -0.00291703f, 
    -0.00251027f, 0.04434961f, -0.01835484f, 0.02952690f, 0.00868081f, -0.01855889f, -0.00832795f, 0.00961590f, 
    0.00552432f, -0.04100266f, -0.00272997f, -0.01786316f, -0.01877663f, -0.04771472f, 0.02418765f, 0.01649200f, 
    -0.01834361f, -0.03431781f, -0.02290046f, 0.01235562f, 0.00932290f, 0.02391939f, -0.05043346f, -0.02031977f, 
    -0.02350804f, 0.04075128f, -0.03430846f, -0.03561545f, 0.03272345f, -0.02044800f, 0.04091538f, -0.00724621f, 
    0.03591463f, -0.04686221f, -0.04341404f, 0.02532032f, 0.01119107f, -0.02605667f, 0.03251436f, 0.00921167f, 
    0.01267519f, -0.00998513f, -0.02170410f, -0.05169956f, 0.00494384f, 0.04031036f, 0.04221176f, -0.03751096f, 
    0.01680218f, -0.04870575f, 0.02657356f, 0.04378823f, 0.02279229f, -0.04267712f, -0.05597727f, 0.01410742f, 
    0.00392595f, -0.03745329f, -0.04357990f, 0.02619201f, 0.01946002f, -0.00383893f, -0.04455213f, 0.01355163f, 
    -0.02652656f, -0.02646419f, -0.00223579f, -0.00001427f, -0.02679872f, 0.01869351f, -0.04091413f, -0.03183229f, 
    0.26968905f, -0.09249474f, -0.03022032f, -0.01286765f, 0.06002782f, -0.00136684f, 0.07297412f, 0.06843595f, 
    0.12965460f, -0.06644387f, 0.09812424f, 0.00673126f, -0.10098871f, -0.04495720f, 0.05618269f, -0.12317058f, 
    0.01401212f, 0.06033298f, -0.03888301f, -0.03179120f, 0.03228346f, 0.11468819f, 0.04611260f, 0.03699305f, 
    0.03274325f, 0.08140424f, -0.24345075f, -0.03564357f, 0.08058580f, 0.08655882f, 0.00672440f, -0.04828521f, 
    0.00144284f, -0.01296697f, 0.02894918f, 0.29111868f, -0.20599239f, 0.06850623f, 0.00164262f, 0.17823385f, 
    0.15155843f, -0.09655081f, -0.08190816f, -0.07076376f, -0.06904329f, 0.01734155f, 0.06851079f, 0.06373651f, 
    -0.07155167f, 0.06777178f, 0.00533448f, 0.11297308f, -0.08687159f, -0.01446657f, -0.04450298f, 0.08626790f, 
    0.10647549f, -0.08249874f, 0.05090302f, -0.00557848f, -0.16414379f, -0.08686478f, -0.18907452f, -0.02154993f, 
    -0.06765252f, 0.01204314f, -0.01476864f, 0.01097806f, 0.02008495f, -0.07864215f, 0.05913649f, -0.03515660f, 
    0.25965717f, 0.05065261f, -0.07971220f, -0.31897703f, 0.07379983f, 0.05039452f, 0.04332520f, -0.04466095f, 
    0.05981530f, 0.03893233f, -0.10304351f, -0.00148783f, -0.04578231f, -0.02268356f, 0.01474171f, 0.06200876f, 
    0.12747186f, 0.03924568f, -0.17275925f, -0.15734397f, -0.01624137f, -0.01939457f, -0.08204801f, 0.04512107f, 
    0.03650204f, 0.15505794f, 0.05549052f, 0.06695683f, 0.05246133f, 0.06973612f, -0.12832114f, -0.06183781f, 
    0.06327464f, -0.02974571f, -0.19033325f, -0.01940646f, 0.27333319f, -0.03152157f, -0.07682148f, 0.08532245f, 
    -0.13595437f, 0.01069851f, 0.02361175f, 0.03514619f, 0.09339802f, 0.14335452f, -0.01556400f, 0.13972682f, 
    0.11683545f, 0.08266684f, 0.18213567f, 0.01907785f, 0.03780265f, 0.05896542f, 0.14234099f, -0.08499559f, 
    -0.13236478f, 0.11990266f, 0.09090671f, -0.02817840f, 0.14258808f, -0.07868613f, -0.21794142f, 0.03604742f, 
    0.00117758f, -0.03008438f, 0.04461055f, 0.03645027f, -0.01612517f, -0.04504134f, 0.25840491f, 0.07968248f, 
    0.25450894f, 0.05804992f, 0.26795366f, 0.04216168f, 0.05775468f, 0.03300326f, 0.08633799f, -0.14303850f, 
    -0.02224871f, -0.07959422f, -0.13337609f, -0.09626300f, -0.19903252f, -0.13281928f, 0.11152492f, 0.34621409f, 
    0.02970659f, 0.04140466f, -0.04247507f, 0.00225509f, 0.05989613f, 0.10107810f, 0.14818367f, 0.10609979f, 
    -0.12852977f, 0.11765720f, 0.02337944f, -0.06840411f, 0.16770290f, -0.08159383f, -0.13418134f, -0.11846752f, 
    0.06118124f, -0.15226351f, -0.03773876f, 0.05580235f, 0.05493063f, 0.12171755f, 0.05127682f, 0.19582355f, 
    0.10449781f, 0.10867257f, -0.09156616f, -0.02354740f, 0.04328134f, 0.14922686f, -0.08292141f, -0.12466580f, 
    0.30515996f, -0.17483598f, 0.25390613f, -0.01619310f, -0.00214668f, 0.06301358f, 0.06948293f, 0.01126002f, 
    -0.08794662f, -0.00470329f, -0.13940622f, 0.04888539f, -0.18640344f, 0.22326103f, 0.00706900f, -0.03753199f, 
    0.09170984f, 0.10185929f, -0.05283912f, 0.03357420f, 0.14249694f, -0.20665222f, 0.08700629f, -0.24323772f, 
    -0.07029980f, 0.09602869f, 0.05827028f, 0.23149954f, -0.03051784f, 0.03401388f, -0.00345804f, -0.03167188f, 
    0.07496140f, 0.10752734f, 0.07227801f, 0.10862157f, 0.17908183f, -0.02505797f, -0.09677099f, -0.18817191f, 
    0.06970759f, -0.00002877f, -0.16522807f, -0.04813804f, 0.02400230f, -0.09184355f, -0.04155134f, -0.05899305f, 
    0.41488308f, 0.17648809f, -0.17547849f, -0.00016662f, 0.15001626f, -0.04575215f, 0.02939956f, 0.04165809f, 
    -0.05368627f, 0.05770042f, 0.13028790f, 0.05784344f, 0.07119898f, -0.11803503f, 0.10154468f, -0.11362133f, 
    0.07449720f, -0.13282578f, 0.00592189f, -0.14829354f, -0.04060524f, 0.07460952f, -0.05185539f, -0.06882030f, 
    -0.14781412f, -0.02141280f, -0.12782381f, -0.06066995f, -0.01840093f, -0.10016198f, -0.00741526f, 0.05755006f, 
    0.03918961f, 0.15407671f, -0.04245057f, -0.05613044f, 0.02773150f, 0.11353811f, 0.08644216f, 0.06408428f, 
    0.09501877f, 0.09081027f, -0.20662504f, -0.04446357f, 0.06912411f, -0.10672922f, 0.13438672f, 0.04873214f, 
    0.20340414f, -0.28491083f, -0.00439083f, 0.04255775f, 0.11210578f, -0.08189844f, -0.02458103f, 0.02224158f, 
    0.07477530f, 0.09250920f, -0.04033058f, 0.08179540f, 0.05906660f, -0.02535061f, -0.15896687f, 0.01499864f, 
    0.01770134f, -0.06547489f, -0.01874146f, 0.07418839f, 0.04341209f, -0.00739346f, 0.17031886f, -0.09247419f, 
    -0.02977853f, -0.34496537f, 0.05049208f, 0.01992633f, -0.04896501f, -0.06254758f, -0.08319740f, 0.00979061f, 
    0.04755570f, 0.01349418f, -0.14719512f, -0.13862853f, 0.21590856f, -0.16122049f, -0.02551264f, -0.01496937f, 
    0.05548951f, 0.00737582f, -0.06393871f, 0.22162850f, 0.02409209f, 0.01699315f, -0.05058809f, -0.09520950f, 
    -0.13435829f, 0.07627263f, -0.05133494f, -0.02178022f, 0.05663504f, -0.31052363f, 0.04425548f, 0.08879688f, 
    -0.06338742f, 0.06021224f, 0.09860010f, 0.11897281f, -0.01818438f, 0.06150045f, -0.11983398f, -0.10461722f, 
    0.08006845f, 0.01662874f, -0.12163930f, 0.11644565f, 0.05911358f, 0.07453972f, 0.13114040f, -0.14198922f, 
    -0.14512898f, -0.31049845f, 0.23696619f, -0.07199667f, 0.00407382f, 0.00367948f, 0.00671930f, -0.05383027f, 
    0.14654876f, 0.07823747f, 0.11046010f, -0.01787568f, 0.27676946f, 0.11414050f, -0.17165399f, 0.04455614f, 
    0.13101256f, 0.04834072f, -0.00138454f, -0.01596736f, -0.08296243f, 0.02946094f, 0.00352064f, 0.25201207f, 
    0.08581625f, 0.19841807f, 0.16128491f, -0.05204795f, 0.07820059f, -0.02713921f, 0.06568121f, -0.06879327f, 
    -0.11137817f, 0.10768247f, 0.17062709f, -0.04201875f, 0.09942063f, -0.15061475f, 0.12253523f, -0.03942252f, 
    0.04221739f, 0.00969712f, 0.07773799f, 0.11134524f, 0.09792580f, 0.04392357f, 0.07859892f, 0.02965821f, 
    -0.28010795f, 0.03006084f, -0.00419788f, -0.14618540f, 0.18493016f, 0.07380060f, 0.00612552f, -0.04080454f, 
    0.06117910f, 0.06401612f, 0.00859545f, 0.04377205f, -0.25772199f, 0.17488585f, -0.15033303f, 0.29805663f, 
    0.17968608f, 0.00278273f, -0.04851303f, 0.09510151f, -0.04779444f, 0.07055760f, 0.00413349f, 0.00927334f, 
    -0.23299207f, 0.15099528f, -0.17268740f, 0.04525594f, -0.03363388f, -0.00682796f, -0.05527254f, -0.05152890f, 
    -0.10993879f, 0.08966255f, 0.00979578f, -0.08688057f, 0.26920968f, 0.06637611f, -0.13020141f, 0.28065845f, 
    0.18210846f, -0.06582617f, 0.09618051f, 0.06675154f, 0.06167420f, 0.09546967f, 0.13898450f, -0.05259601f, 
    -0.02052046f, 0.18875097f, -0.03392441f, -0.08569453f, 0.07261769f, 0.07778734f, -0.02675831f, -0.03952390f, 
    0.14483413f, -0.08811367f, 0.08047055f, 0.09719423f, -0.07722221f, -0.03433174f, -0.08447775f, -0.17039503f, 
    0.05204755f, -0.05966280f, -0.07487606f, -0.06266021f, 0.02211912f, 0.03047950f, 0.12277344f, 0.05756313f, 
    -0.14242971f, 0.21582454f, -0.01291148f, 0.31874204f, 0.04401770f, 0.02060688f, 0.06164587f, -0.01319271f, 
    -0.02649059f, -0.02698484f, 0.05514863f, 0.06339704f, 0.11980879f, -0.01611044f, 0.20982793f, 0.07601453f, 
    0.07103412f, -0.03015078f, -0.00473590f, -0.02830777f, 0.00922299f, -0.00052393f, 0.08470911f, 0.12644601f, 
    0.12156915f, -0.06671585f, 0.02919435f, 0.00528366f, 0.09130083f, 0.08640804f, -0.00444138f, -0.07858002f, 
    -0.06211380f, 0.07802516f, 0.04711140f, 0.04700038f, 0.12531205f, -0.08008602f, -0.13974111f, 0.07904905f, 
    0.05418505f, -0.08599288f, 0.01739227f, 0.05614844f, 0.04700664f, 0.03576728f, 0.06705616f, -0.03888177f, 
    -0.27258450f, 0.05759338f, 0.27527615f, 0.01229835f, 0.01169916f, 0.00380266f, 0.09603868f, -0.10344215f, 
    0.01181688f, 0.05160572f, 0.04085970f, 0.01076744f, 0.03707344f, -0.01081984f, -0.12398699f, 0.22063778f, 
    0.08811612f, 0.00898236f, -0.17571263f, 0.08194159f, 0.19050044f, 0.03574917f, 0.05745494f, -0.02680374f, 
    -0.03271627f, 0.00725753f, -0.01176930f, 0.09368654f, 0.18021855f, -0.00085894f, -0.07996485f, 0.03190012f, 
    0.07820831f, 0.03191584f, -0.08657175f, 0.12605108f, 0.03655702f, 0.09046884f, 0.08512671f, 0.24196258f, 
    -0.06302980f, 0.07328309f, -0.10358623f, -0.09561557f, -0.18235183f, -0.06770199f, 0.06015971f, -0.07559370f, 
    0.14365485f, -0.14670546f, 0.07441378f, -0.06360323f, -0.16000967f, -0.11169872f, 0.03863737f, 0.06035210f, 
    0.16776715f, -0.08623116f, -0.02915161f, 0.12797867f, 0.01477402f, 0.23453687f, 0.01618024f, 0.11180069f, 
    0.00251045f, 0.04655392f, -0.00900447f, -0.07064345f, 0.05330950f, -0.00355521f, 0.04736640f, 0.02951464f, 
    0.28319830f, 0.12320644f, 0.00574580f, 0.05815354f, -0.06294142f, 0.02929715f, 0.05612570f, -0.07214751f, 
    -0.02146002f, 0.05290122f, -0.09710769f, -0.04921474f, 0.03912466f, -0.01981351f, -0.00291204f, -0.21467493f, 
    0.04082961f, -0.12922993f, -0.05485450f, -0.05723897f, -0.03517204f, -0.03207289f, 0.01852376f, 0.07487532f, 
    -0.17614155f, 0.07122662f, -0.16094695f, 0.38771176f, 0.17695928f, 0.05567252f, -0.18531881f, -0.01557807f, 
    0.21096140f, -0.03715935f, 0.03822368f, -0.01803849f, 0.00509290f, 0.25626829f, -0.07462087f, 0.15982880f, 
    0.02117599f, 0.13580582f, -0.09437370f, 0.06369046f, 0.13333192f, -0.05099717f, -0.01534374f, 0.10099332f, 
    -0.05231709f, 0.26015595f, -0.07086069f, 0.00299080f, -0.00014175f, 0.03058009f, 0.10413782f, 0.04053734f, 
    0.03556770f, -0.01497986f, 0.03950984f, -0.01597334f, -0.03296511f, 0.13109951f, 0.16403276f, -0.07021113f, 
    0.09374330f, -0.13199931f, 0.07195790f, -0.02503041f, -0.12475337f, 0.21179371f, 0.16018161f, 0.00613565f, 
    -0.37364385f, 0.12175170f, 0.03406443f, 0.01438079f, 0.14028504f, 0.03509064f, -0.01251880f, 0.02930758f, 
    0.10371350f, 0.09954595f, 0.11501122f, 0.06140097f, 0.26528552f, -0.14215001f, 0.07642953f, -0.01361727f, 
    0.07817721f, 0.12510353f, 0.03553206f, 0.11719658f, 0.08548300f, 0.09860455f, 0.01349332f, -0.02334218f, 
    0.02732566f, -0.17270261f, 0.14931571f, -0.07709447f, 0.01300029f, -0.05031983f, 0.06804140f, -0.06877983f, 
    -0.12923025f, -0.00320563f, 0.12403274f, 0.00146224f, 0.23691416f, -0.05171921f, 0.13732176f, -0.17425670f, 
    0.18919688f, -0.11691698f, 0.04091074f, 0.02320847f, 0.08937603f, 0.06451371f, 0.11672454f, 0.03736675f, 
    -0.20444265f, 0.08133371f, -0.05809338f, -0.03159617f, -0.00291849f, 0.00806517f, -0.12210891f, 0.07110319f, 
    0.00748380f, 0.12329398f, 0.14394031f, -0.08495769f, 0.01483864f, -0.16120926f, -0.05340296f, 0.09735232f, 
    -0.02581245f, -0.00985825f, 0.00082966f, -0.01489179f, -0.10976139f, -0.05831242f, -0.04378109f, 0.03236565f, 
    -0.38302743f, 0.27374491f, 0.03879962f, -0.05156032f, -0.04354781f, 0.00304251f, 0.08847858f, -0.08502915f, 
    0.13136718f, -0.02017916f, 0.12977813f, 0.00066979f, -0.19837306f, 0.04579872f, -0.14711060f, -0.19564824f, 
    0.04835069f, -0.02493748f, -0.09441236f, 0.03606768f, 0.03930068f, 0.02874390f, 0.07193440f, -0.00213386f, 
    -0.10226851f, -0.18066701f, -0.06367831f, 0.01087759f, 0.10792358f, -0.02006176f, -0.04462767f, 0.08564710f, 
    0.10592304f, 0.05209541f, -0.04989856f, -0.10166638f, 0.19401325f, -0.11870785f, -0.20448467f, -0.07103660f, 
    -0.03510744f, 0.03064508f, 0.01495767f, -0.08149786f, 0.07174983f, -0.06650016f, 0.03411946f, -0.11783428f, 
    0.21339427f, 0.22001068f, 0.11497776f, -0.06344006f, -0.12112758f, -0.02491644f, 0.06856418f, 0.12138955f, 
    0.04892879f, 0.01335904f, -0.02092375f, 0.02214581f, -0.07346966f, -0.21690334f, 0.01556842f, -0.10444603f, 
    -0.00053097f, -0.10153119f, 0.16997102f, -0.01356926f, -0.02195789f, 0.02436831f, -0.03273037f, 0.01867676f, 
    -0.22296786f, 0.19274899f, 0.13832349f, 0.05642205f, -0.06018895f, -0.06999745f, 0.00540114f, 0.11384704f, 
    -0.00958417f, 0.06959772f, 0.02240574f, 0.03180749f, -0.27843383f, -0.06489675f, -0.13238652f, -0.05186036f, 
    -0.05202219f, -0.09775348f, -0.06916423f, -0.00637487f, -0.10259108f, 0.04599352f, -0.11166963f, -0.09053221f, 
    0.34876943f, -0.10472538f, 0.10144736f, 0.02178241f, -0.03399462f, 0.09759104f, -0.00248183f, -0.11954296f, 
    -0.03115251f, -0.02417576f, -0.19367857f, -0.12751716f, 0.21411477f, 0.14851508f, 0.00578120f, -0.07103216f, 
    0.02336103f, 0.06090832f, 0.04059000f, 0.01447975f, -0.06599015f, 0.02934735f, -0.09243139f, 0.10985016f, 
    -0.12574553f, -0.16966553f, 0.07180665f, 0.02507773f, -0.01514996f, -0.09958803f, 0.13244073f, 0.05487908f, 
    0.14706740f, -0.01840833f, 0.07381451f, 0.07096145f, -0.06616375f, -0.08936914f, -0.10238761f, 0.03367006f, 
    0.07167550f, 0.12391916f, 0.00866300f, 0.03113876f, -0.07873715f, 0.00256534f, -0.11756308f, 0.03146044f, 
    0.06818299f, 0.19911520f, 0.07287586f, 0.14289013f, -0.01759435f, -0.01662598f, 0.10618655f, 0.07948171f, 
    0.08908308f, 0.02414701f, -0.01703491f, 0.02450259f, -0.19412285f, -0.07080035f, 0.18570429f, -0.10458854f, 
    0.02811467f, 0.13358662f, 0.00670291f, 0.04319443f, 0.08452626f, -0.02783858f, -0.03384870f, 0.06510345f, 
    0.18710230f, -0.10669143f, -0.01655691f, 0.20052063f, 0.01295264f, 0.00609807f, -0.00592502f, 0.11712763f, 
    0.07651608f, 0.03662667f, 0.05787967f, 0.12258277f, -0.23416205f, -0.04809028f, -0.07182446f, -0.15570965f, 
    -0.05101786f, -0.01299489f, 0.04943648f, -0.10239676f, -0.07570061f, -0.05660698f, -0.11751446f, -0.03388593f, 
    -0.17084974f, 0.11902168f, -0.00173002f, -0.04480966f, 0.03664124f, -0.02997468f, 0.07391706f, 0.00226918f, 
    0.00772310f, -0.02467514f, 0.09866934f, -0.10809422f, 0.06646976f, -0.02300884f, -0.05726900f, 0.21102813f, 
    0.00793858f, -0.07795480f, -0.02389907f, 0.06629877f, 0.15352777f, 0.05690931f, 0.00550570f, 0.03389629f, 
    0.20204245f, -0.11199112f, -0.03474538f, -0.05948673f, -0.10003332f, 0.00171977f, -0.07142659f, 0.14753693f, 
    -0.05532726f, -0.08074972f, -0.02832607f, 0.03468730f, -0.04105197f, -0.16774552f, -0.20912285f, -0.12048516f, 
    -0.01564502f, -0.11633567f, 0.11053885f, -0.02152086f, -0.06539948f, -0.07351486f, 0.01503951f, 0.06384721f, 
    -0.18239190f, 0.05616799f, 0.18648386f, 0.06192439f, 0.00007245f, 0.06017749f, 0.06292852f, 0.10133692f, 
    0.07505242f, 0.01051768f, -0.00960747f, 0.03884552f, 0.25199547f, 0.11866094f, 0.14215574f, -0.01764267f, 
    0.08315204f, 0.11659528f, 0.12566108f, 0.07869671f, 0.09845182f, 0.08006308f, -0.05866199f, -0.00811517f, 
    0.18762366f, -0.04282618f, 0.18799213f, -0.03244986f, 0.01468399f, -0.12797350f, 0.11184336f, -0.09891557f, 
    -0.03726381f, -0.03193253f, -0.03765320f, -0.11381382f, -0.06491684f, -0.15380469f, -0.03093950f, -0.03293268f, 
    0.09014352f, 0.10945206f, 0.10266502f, 0.03772014f, 0.04409883f, -0.02227219f, 0.08095197f, -0.00287848f, 
    -0.03313783f, -0.01073069f, 0.02115079f, -0.00806564f, -0.04752468f, 0.05578299f, 0.11846982f, -0.02816403f, 
    -0.06023782f, -0.04739712f, -0.08462182f, 0.05213014f, 0.16727600f, -0.10597728f, -0.00179174f, 0.02293429f, 
    0.05225933f, 0.07603730f, 0.00138009f, 0.05881603f, 0.00732311f, -0.01943733f, 0.01089875f, 0.08392059f, 
    0.02892897f, -0.13516352f, 0.18500145f, 0.11454954f, -0.02936960f, 0.04152672f, 0.09990355f, 0.04624014f, 
    -0.04827304f, 0.01783100f, 0.07304432f, 0.11234425f, 0.14682060f, 0.09706415f, -0.07538678f, -0.00820688f, 
    -0.01638635f, 0.06605614f, 0.00888525f, -0.00785932f, -0.01101042f, 0.02480630f, 0.00685641f, -0.07012192f, 
    0.19191690f, -0.04612616f, 0.12814310f, -0.06632558f, -0.06751787f, 0.13014483f, -0.04321682f, 0.05421683f, 
    0.05202418f, 0.05542726f, -0.10344512f, 0.09227820f, -0.22992003f, 0.07496676f, -0.06939602f, -0.06447273f, 
    0.00412378f, 0.10084933f, 0.03724684f, -0.00502640f, 0.02293403f, 0.02770363f, 0.12715679f, -0.07758930f, 
    -0.04261507f, 0.03073628f, 0.16191041f, -0.00963321f, -0.13499875f, 0.08027287f, 0.15050878f, -0.01684629f, 
    -0.22731210f, -0.13223621f, 0.01193319f, 0.08571726f, 0.20749041f, -0.00867011f, 0.02423088f, 0.09195625f, 
    0.04131501f, 0.11670812f, 0.05743561f, 0.11465543f, -0.01850816f, 0.12758550f, 0.11286985f, 0.14177199f, 
    -0.00519416f, -0.14425638f, 0.02520226f, -0.16505298f, -0.02855732f, 0.02142366f, -0.01975787f, 0.05053036f, 
    0.00719792f, 0.05010314f, -0.06131992f, -0.14932719f, -0.03141506f, 0.24961486f, 0.20530197f, -0.08041635f, 
    -0.00834231f, -0.06141217f, 0.02126986f, -0.06189563f, -0.05730077f, -0.03359854f, -0.01919764f, 0.03080345f, 
    -0.03561998f, 0.11093543f, 0.15724505f, 0.08130813f, -0.05770501f, -0.03031807f, -0.06346350f, 0.05947031f, 
    -0.02792838f, -0.04485032f, -0.05925813f, 0.14010771f, 0.23550479f, -0.14854659f, 0.14536081f, 0.10195829f, 
    0.05866443f, 0.02389557f, 0.00320155f, -0.15437180f, 0.09135745f, 0.05038989f, 0.03213265f, -0.00229659f, 
    -0.22379787f, 0.00160959f, 0.18365724f, -0.04094534f, -0.00200769f, 0.00271673f, -0.01010146f, -0.01324463f, 
    -0.22533779f, -0.09074623f, 0.06315974f, 0.04533437f, -0.12384479f, 0.29877073f, 0.19978842f, -0.14955164f, 
    -0.07156666f, -0.01055844f, -0.07318678f, -0.02910451f, 0.01409517f, -0.10545219f, 0.05124502f, 0.00128738f, 
    0.20381816f, 0.28436741f, -0.08338795f, 0.03057997f, -0.13236217f, 0.10319208f, -0.04818983f, 0.00224435f, 
    -0.08000787f, 0.00388433f, 0.06126639f, 0.01671985f, 0.43933457f, 0.29666793f, 0.20463154f, 0.13148098f, 
    0.03390136f, -0.00583132f, 0.05361650f, 0.04544286f, -0.01035020f, 0.01289454f, 0.06833504f, 0.15818563f, 
    -0.15837465f, 0.08875291f, 0.02113875f, 0.10216145f, -0.18317196f, -0.10258818f, 0.09880412f, 0.06681477f, 
    0.14558132f, 0.01967592f, 0.28537145f, 0.13420662f, 0.18230218f, -0.04755987f, 0.23876250f, 0.25971204f, 
    -0.06437572f, 0.04364024f, 0.09429566f, -0.04874352f, 0.01827847f, 0.06767282f, 0.05543342f, -0.08655270f, 
    -0.10136537f, 0.24938062f, -0.07004457f, -0.02649977f, 0.09241552f, 0.12351611f, -0.03751934f, -0.03281501f, 
    -0.09473729f, 0.00814077f, 0.03908109f, 0.00733351f, -0.09414443f, 0.07424766f, 0.11302905f, 0.00671610f, 
    0.06224795f, -0.09738321f, 0.03398436f, -0.03065376f, 0.02687539f, 0.04414109f, 0.04887465f, -0.05775833f, 
    -0.21411093f, -0.19955783f, -0.04442364f, 0.03456462f, 0.03149584f, -0.09903281f, 0.04826211f, 0.00746671f, 
    0.09293395f, 0.07416423f, 0.11367854f, 0.01577231f, -0.08754630f, 0.15214102f, -0.12455122f, 0.11413550f, 
    -0.02605590f, -0.00974594f, 0.02306223f, -0.09694769f, -0.14042938f, 0.09077283f, -0.12302063f, -0.11110907f, 
    -0.16552725f, -0.04405265f, 0.03642486f, -0.09510073f, -0.01882418f, 0.10951699f, -0.03993746f, -0.04998027f, 
    -0.14736016f, 0.00206687f, -0.06245224f, 0.01987984f, 0.23170939f, 0.06637587f, 0.25541994f, -0.00098098f, 
    -0.03428736f, -0.09881929f, 0.00808119f, -0.02413242f, 0.06391578f, -0.08449059f, -0.02418911f, 0.01432231f, 
    0.01971767f, 0.12152584f, -0.19214737f, 0.13439587f, 0.00861256f, 0.03873875f, 0.11220016f, 0.18847077f, 
    0.05471903f, 0.07876417f, -0.07239437f, -0.07878359f, 0.00685208f, 0.09521879f, 0.03213504f, 0.00334417f, 
    0.08726161f, 0.03831742f, 0.05708787f, -0.04512655f, -0.08924782f, -0.15109722f, 0.05150721f, 0.17257750f, 
    -0.26381120f, -0.03202149f, 0.18298066f, -0.00513285f, -0.02181095f, 0.05969931f, 0.00538828f, -0.07644040f, 
    0.12790945f, 0.14669305f, 0.12151735f, -0.05820720f, 0.07226528f, -0.16016959f, -0.05504964f, 0.04638439f, 
    0.08303969f, -0.05279540f, -0.08774203f, 0.00783997f, -0.05114423f, 0.18198837f, 0.05322447f, 0.00425080f, 
    -0.22277607f, -0.04535897f, 0.04615910f, -0.11050596f, 0.09429250f, -0.08238868f, 0.03651377f, -0.10053658f, 
    -0.04450782f, -0.07233773f, -0.03175811f, 0.05716227f, 0.14016080f, -0.06156064f, 0.17758954f, 0.16551092f, 
    0.01182127f, 0.02590630f, 0.02968975f, -0.08672557f, 0.08431488f, -0.00976851f, 0.01443336f, -0.09480314f, 
    0.04240223f, 0.21408829f, -0.17758049f, -0.07722792f, -0.11882111f, 0.06791709f, 0.01528515f, -0.02812048f, 
    -0.10586349f, -0.08036433f, 0.09747609f, 0.00390633f, 0.10325212f, 0.41652268f, 0.00702215f, -0.01716019f, 
    -0.08391593f, 0.04764844f, -0.11245940f, 0.20029315f, 0.03241179f, 0.04713999f, 0.02984472f, 0.02384002f, 
    -0.04142317f, -0.01549375f, -0.07690784f, -0.16067283f, -0.01655155f, -0.05271449f, 0.07293305f, -0.09157179f, 
    -0.07307632f, 0.05370225f, 0.11895753f, -0.02027592f, -0.17118442f, -0.17779431f, 0.15441296f, 0.12529263f, 
    -0.11027230f, -0.07095940f, -0.08486860f, 0.00039635f, -0.07896194f, 0.08481159f, -0.10929520f, -0.05936551f, 
    0.23418576f, 0.38324699f, -0.05572887f, 0.06338700f, 0.02240471f, -0.03778974f, -0.02073036f, -0.08016390f, 
    -0.06580390f, -0.06659688f, 0.02652815f, -0.08946189f, 0.15589225f, -0.13973570f, 0.01791893f, 0.16757548f, 
    0.06137919f, 0.09801839f, 0.16176705f, -0.01921338f, -0.03535824f, 0.01688718f, -0.07085603f, 0.11275841f, 
    -0.04136234f, 0.29364657f, 0.07552526f, -0.08858828f, 0.08942807f, 0.05112428f, -0.10492905f, -0.00925090f, 
    0.03484038f, -0.01459579f, 0.28772190f, -0.04229764f, 0.31122518f, 0.01236907f, -0.15536262f, -0.06799094f, 
    -0.11228012f, 0.03680329f, 0.10662182f, -0.00012132f, -0.07395548f, -0.04479516f, -0.03144499f, 0.12250052f, 
    -0.10595872f, 0.07070655f, 0.01291313f, -0.10124332f, 0.04842043f, 0.17731474f, -0.03876551f, -0.04758044f, 
    0.00752932f, 0.09111459f, 0.04939707f, -0.06089885f, 0.34755069f, -0.15184888f, 0.29310775f, 0.01294524f, 
    0.01824541f, -0.12803464f, -0.09701835f, -0.22571407f, 0.03029388f, -0.08167265f, -0.03839112f, 0.07752515f, 
    -0.03178477f, 0.30420554f, 0.02373911f, 0.09020112f, 0.09833008f, 0.00797748f, 0.05278352f, -0.10255856f, 
    -0.03911550f, -0.08528326f, -0.06650402f, 0.12871319f, -0.10764644f, -0.07741506f, -0.00725716f, 0.03940142f, 
    0.00490309f, 0.13262887f, -0.02131596f, 0.03222511f, 0.09592684f, -0.10272270f, -0.01131541f, -0.02506503f, 
    0.00287321f, -0.18256168f, -0.19305997f, 0.06195363f, -0.00596463f, -0.01673989f, -0.10502651f, 0.01738215f, 
    0.07814894f, -0.01495531f, -0.03376509f, 0.05346207f, 0.18979900f, -0.04502317f, 0.06401972f, 0.02960616f, 
    0.00015798f, 0.10493444f, -0.05158464f, -0.11750529f, 0.03114897f, -0.01488277f, -0.00453975f, 0.03964880f, 
    0.12331662f, 0.07412552f, 0.02708593f, 0.19820334f, -0.02664347f, 0.02214473f, 0.02959798f, 0.00500780f, 
    -0.11028821f, 0.03318949f, 0.00674476f, 0.12204070f, 0.07295196f, -0.10003778f, 0.15536898f, -0.25586134f, 
    -0.05889748f, 0.02448154f, 0.04325820f, 0.06122958f, 0.09966770f, -0.04372462f, 0.10437258f, 0.07556104f, 
    0.23484957f, 0.26778600f, 0.16889842f, 0.02961416f, -0.07036060f, 0.11901863f, 0.00424062f, 0.01685266f, 
    0.11837017f, 0.00391158f, 0.06856208f, 0.03925195f, -0.02299533f, 0.12396687f, 0.11607437f, -0.15605959f, 
    0.01417942f, 0.08720946f, -0.05656963f, 0.08674576f, 0.11135410f, 0.00076544f, 0.09790802f, 0.12294453f, 
    -0.05154950f, -0.05369281f, 0.00590688f, -0.02349660f, 0.00020790f, -0.05102442f, 0.06309051f, 0.01370911f, 
    0.01631030f, 0.09134964f, -0.09044384f, 0.01614117f, 0.15382934f, 0.01160364f, 0.01056295f, 0.16109359f, 
    0.01891530f, 0.00235481f, 0.00428755f, 0.06437771f, 0.15429690f, 0.04827901f, 0.05142372f, -0.00080220f, 
    -0.22306935f, -0.03474449f, 0.11071917f, -0.21950811f, -0.01385997f, -0.02486891f, 0.08762345f, 0.14094724f, 
    0.01015036f, -0.00651646f, 0.02173250f, 0.05800863f, -0.03956823f, -0.14756833f, -0.12905496f, 0.14150026f, 
    0.03730042f, 0.03619406f, 0.01459820f, 0.02662189f, 0.02609319f, 0.02618350f, -0.10116360f, 0.04481137f, 
    -0.01624849f, -0.09078357f, 0.02328358f, 0.00571435f, -0.05885185f, 0.01781236f, 0.15558331f, 0.21001728f, 
    0.08532746f, 0.01372348f, 0.06235934f, -0.12231483f, 0.03805785f, 0.14155169f, 0.00516263f, -0.19824532f, 
    0.07461592f, 0.07723386f, -0.04665105f, 0.01354827f, 0.00293329f, 0.13031912f, -0.01306775f, -0.05389925f, 
    0.14258900f, -0.09156094f, 0.02055705f, -0.05506561f, -0.09098950f, 0.01965719f, -0.02987676f, 0.08637336f, 
    0.02994815f, 0.07080290f, -0.09434340f, 0.00927186f, 0.04177829f, 0.06169135f, -0.02910304f, -0.17850053f, 
    -0.03809385f, -0.04791988f, 0.03092994f, 0.01756699f, 0.10007371f, -0.01516801f, -0.06311773f, 0.09456517f, 
    0.03810078f, 0.27447063f, 0.07617409f, -0.11951269f, -0.02682036f, 0.00643908f, -0.03582674f, 0.04834228f, 
    0.05536934f, -0.03051749f, 0.12242399f, 0.04031825f, -0.12776601f, -0.12488900f, 0.01681989f, -0.13020253f, 
    -0.03430897f, 0.02954211f, -0.02692290f, 0.10887951f, 0.06678556f, 0.00913640f, 0.05750449f, 0.04059823f, 
    0.18150721f, 0.12670879f, 0.02996325f, 0.24579252f, 0.07014324f, 0.04667480f, -0.06818487f, -0.01562182f, 
    -0.03913885f, 0.16702726f, 0.09317306f, 0.05816935f, -0.18569070f, -0.19242960f, -0.01995497f, -0.21289206f, 
    0.02620394f, -0.04836947f, -0.01753375f, 0.11692842f, 0.06604817f, 0.12570214f, 0.11397411f, 0.03710898f, 
    -0.21846391f, -0.12081569f, 0.07613549f, -0.30045718f, 0.06977159f, 0.06482556f, 0.07400920f, 0.02078353f, 
    -0.04561513f, 0.07700194f, -0.00672391f, 0.08009239f, 0.08359156f, -0.04052824f, 0.00268774f, 0.14568080f, 
    0.12310701f, -0.04493343f, 0.01744101f, -0.04330360f, 0.05451448f, 0.05936244f, -0.05472936f, -0.11084370f, 
    0.37936735f, 0.24865711f, 0.02222849f, -0.00126031f, 0.03841891f, 0.03321422f, 0.06059893f, -0.01086342f, 
    -0.10113280f, 0.03111623f, 0.07855871f, 0.02440988f, -0.09865551f, -0.03994352f, 0.03901905f, -0.26594767f, 
    -0.01064421f, -0.09158868f, 0.07105736f, -0.02854279f, 0.01946521f, -0.05349652f, -0.00998338f, 0.02898531f, 
    -0.21691133f, -0.07795513f, 0.03089796f, -0.07386488f, -0.05632743f, -0.03821317f, 0.02688869f, 0.00551454f, 
    -0.09080061f, 0.17572384f, 0.03512571f, 0.12842630f, 0.02281459f, -0.19588614f, -0.02862124f, 0.12179597f, 
    0.01145615f, 0.05637176f, -0.00097429f, 0.10638169f, 0.00151131f, -0.07682829f, -0.05442780f, 0.06788593f, 
    0.40544385f, -0.03925534f, -0.07208765f, 0.16902839f, 0.04670414f, 0.06835561f, 0.04108078f, 0.02947183f, 
    -0.02119491f, 0.04417506f, -0.05558727f, 0.03279391f, 0.06711707f, 0.23732717f, -0.30275089f, -0.10721484f, 
    -0.00976270f, 0.10640852f, 0.08535938f, 0.04569840f, 0.08079026f, -0.01707384f, 0.07607856f, -0.03680952f, 
    0.25042227f, 0.10199092f, 0.06813420f, 0.19861861f, 0.08112148f, -0.04379206f, -0.04289914f, 0.14457010f, 
    0.03769845f, 0.06612885f, 0.09412090f, 0.17227587f, 0.01349824f, 0.02020005f, -0.19998910f, -0.02232967f, 
    0.00739345f, 0.06609704f, -0.02240135f, -0.00882608f, 0.14420560f, 0.10579167f, -0.05300696f, 0.14281324f, 
    -0.05969716f, -0.04857538f, 0.06048053f, -0.13136128f, 0.09228332f, 0.08325698f, 0.06705841f, -0.01643135f, 
    -0.02475256f, -0.02183975f, -0.03935007f, -0.00532099f, 0.48781440f, -0.04315114f, 0.07625592f, -0.00020051f, 
    0.10544585f, 0.08333209f, -0.01809047f, -0.02582765f, 0.03595379f, 0.13706756f, 0.13290679f, 0.13862920f, 
    -0.11740339f, -0.06748722f, 0.04349521f, 0.14126703f, 0.14886346f, 0.00609766f, -0.02625882f, 0.04167328f, 
    -0.01050914f, 0.00480086f, -0.00740373f, -0.11156677f, 0.19274072f, 0.11101102f, 0.11707147f, -0.21786648f, 
    0.16647266f, 0.08670425f, -0.03506305f, 0.01187938f, 0.16405664f, 0.05640888f, -0.04689205f, 0.04860390f, 
    0.01701727f, -0.02423772f, -0.03340458f, 0.05243350f, 0.00767845f, 0.04768248f, -0.02841354f, -0.03332818f, 
    0.04325518f, -0.02820528f, 0.01402908f, -0.05396588f, -0.01541845f, 0.06544689f, -0.03574829f, -0.07461085f, 
    0.00880853f, 0.03849133f, 0.00275310f, 0.02734627f, 0.02672025f, 0.05045918f, -0.02691532f, 0.02147492f, 
    -0.02923600f, 0.03306545f, -0.03659827f, 0.00049264f, -0.01198604f, -0.01230003f, 0.04655846f, -0.03401751f, 
    0.00889387f, 0.01289169f, 0.02094377f, -0.00381007f, 0.04582655f, 0.02311686f, 0.04239691f, -0.01894349f, 
    0.00211425f, 0.01381289f, 0.01587536f, 0.01528964f, 0.01349994f, -0.02577845f, 0.03018399f, -0.01698830f, 
    -0.04863603f, 0.02361998f, -0.04085974f, 0.03222585f, -0.00799188f, 0.01423858f, -0.04509760f, -0.03915578f, 
    0.02987731f, -0.05724226f, 0.02854603f, -0.01577587f, -0.01077474f, -0.03530977f, 0.01593339f, -0.02201783f, 
    0.03476517f, 0.02750562f, -0.05616238f, -0.05293191f, -0.03047253f, 0.00183026f, -0.00629080f, -0.02217972f, 
    -0.06481540f, 0.00242317f, -0.02539384f, -0.05460220f, -0.02508282f, 0.01081969f, -0.04040102f, -0.03262388f, 
    0.00633171f, 0.01287292f, 0.02163044f, -0.00959638f, 0.02445622f, 0.00409303f, 0.03290416f, -0.01984452f, 
    -0.02761240f, 0.02685831f, -0.03769817f, -0.00076306f, 0.04297141f, 0.01377989f, -0.00806157f, -0.02423053f, 
    -0.03615891f, 0.02632752f, -0.02020927f, 0.00045726f, -0.03520705f, 0.05124876f, 0.01093238f, 0.03939120f, 
    0.00601251f, -0.05743829f, -0.02038672f, -0.03298562f, -0.01058636f, 0.00272409f, 0.03938648f, 0.03764904f, 
    0.04787569f, 0.04004148f, -0.03900744f, -0.05709333f, -0.02156270f, 0.03571296f, -0.02088789f, -0.02507928f, 
    -0.06872109f, 0.02384771f, 0.01793050f, 0.04979626f, 0.05238508f, -0.03452869f, 0.01780038f, -0.00663054f, 
    -0.01599009f, -0.05309078f, 0.04784636f, 0.04735656f, -0.01662670f, -0.02756023f, -0.04508349f, -0.03700078f, 
    -0.03379149f, 0.00183328f, -0.02493094f, -0.06955113f, 0.02632463f, -0.03387663f, -0.02905975f, 0.02912149f, 
    -0.02601584f, -0.03301277f, -0.05783308f, -0.04062347f, 0.00556098f, -0.02863783f, 0.00437017f, -0.04851360f, 
    -0.04439777f, 0.01533297f, 0.01533228f, -0.03836638f, -0.05512898f, -0.01046840f, 0.03008371f, -0.00051316f, 
    -0.00111075f, -0.04688491f, -0.00479856f, -0.00725023f, -0.02065837f, -0.01418063f, -0.03778650f, -0.01303994f, 
    -0.02822154f, 0.04051809f, -0.01612370f, 0.03326152f, -0.02729930f, 0.03888934f, -0.04415621f, 0.00661641f, 
    -0.01009266f, -0.05162781f, 0.01335055f, -0.03967772f, -0.01712751f, -0.01583356f, -0.02096658f, 0.03176789f, 
    0.01318664f, -0.00596316f, -0.00081130f, -0.03826319f, 0.00883534f, -0.04157390f, 0.04192808f, 0.01503846f, 
    0.02436210f, -0.01417870f, 0.00419365f, -0.05565861f, -0.02293929f, 0.03073654f, -0.03731593f, -0.03375878f, 
    -0.04235793f, -0.00704610f, -0.00364535f, -0.03399450f, -0.04677644f, 0.01210559f, 0.01610294f, -0.01700057f, 
    -0.02124019f, -0.02729248f, -0.05487600f, 0.02717592f, -0.05349810f, -0.06219202f, 0.00971789f, 0.01334796f, 
    0.00900967f, -0.06428993f, 0.01749801f, -0.03888865f, -0.03702050f, -0.00643123f, -0.03253735f, -0.04061593f, 
    -0.00632323f, 0.03610169f, -0.04599440f, 0.02665574f, -0.03906526f, -0.01691201f, 0.01509868f, -0.01508419f, 
    0.01000933f, -0.03079350f, -0.03281184f, 0.03453513f, 0.00507005f, 0.03189494f, -0.04505754f, 0.04198298f, 
    0.00689248f, 0.03150925f, -0.04352600f, 0.02588264f, -0.00888277f, -0.00845138f, -0.04435058f, 0.03466819f, 
    0.01190222f, 0.05027799f, 0.04461769f, -0.05836571f, -0.00810862f, -0.07398668f, -0.02569209f, -0.05569661f, 
    0.01062354f, 0.01799618f, -0.05781456f, -0.05783354f, -0.04266628f, 0.03365760f, -0.02669806f, 0.00309829f, 
    -0.00999599f, 0.04512895f, -0.02720487f, 0.02025603f, -0.03548625f, -0.00401207f, -0.04633898f, -0.00736058f, 
    0.02806580f, 0.03002349f, -0.04430807f, 0.03544482f, 0.01336311f, 0.01646252f, -0.00375999f, -0.03322294f, 
    0.04525005f, 0.00561850f, -0.02628306f, -0.00571548f, 0.01574415f, -0.01020676f, -0.05428838f, 0.00624406f, 
    -0.03177043f, -0.05545939f, -0.03393227f, -0.05972899f, -0.01643664f, 0.01684721f, -0.01783761f, 0.02154623f, 
    -0.03637098f, 0.03159551f, -0.03085921f, -0.02975605f, 0.02052747f, 0.02698022f, -0.06208038f, -0.00859886f, 
    -0.05251289f, -0.00556956f, -0.03441084f, 0.02397043f, -0.02258625f, -0.02959658f, -0.04891887f, -0.04737652f, 
    0.00700548f, -0.02980339f, -0.04689241f, -0.00985974f, -0.02539355f, -0.04822269f, -0.06141680f, 0.00023117f, 
    0.00919603f, 0.00230262f, -0.03455741f, 0.03687274f, 0.01383462f, -0.03753235f, -0.06430340f, -0.05471672f, 
    -0.03389354f, -0.00759334f, 0.00188173f, 0.01205269f, 0.02776101f, -0.01718701f, 0.00360529f, 0.03956186f, 
    -0.00553222f, -0.04667236f, 0.00980970f, -0.04042563f, -0.05732300f, 0.01745133f, -0.06387453f, 0.03226142f, 
    -0.06465883f, -0.03797526f, 0.03224719f, 0.02456327f, -0.03986936f, 0.00652477f, 0.04498813f, -0.06704112f, 
    0.01275566f, -0.01356564f, 0.01454920f, 0.02771342f, 0.04504247f, 0.00724471f, 0.03879473f, -0.03522547f, 
    -0.03712154f, -0.01882186f, 0.01149022f, 0.02753665f, 0.02801287f, 0.05094122f, 0.00181288f, -0.05013405f, 
    -0.00407588f, 0.04675204f, -0.05358466f, -0.03807198f, -0.05228894f, 0.01746113f, 0.02990717f, -0.03175799f, 
    -0.05549549f, -0.01831927f, -0.02683848f, -0.02195273f, -0.00232001f, 0.01484449f, -0.01952990f, -0.04716239f, 
    0.18350437f, -0.03174073f, -0.07199097f, -0.03580770f, -0.10890091f, 0.07643630f, -0.07203373f, -0.01639426f, 
    -0.03293886f, -0.01604700f, -0.02875028f, 0.09080908f, -0.06692375f, 0.05614904f, 0.01378036f, 0.15006877f, 
    0.04063926f, 0.04613108f, -0.05578656f, 0.02620772f, -0.11161834f, -0.06867325f, -0.07699130f, 0.04128017f, 
    0.35515603f, 0.00269117f, -0.10300684f, 0.39037666f, -0.00325871f, -0.05724500f, 0.01455911f, 0.06520367f, 
    0.06632279f, -0.02061504f, -0.10537209f, -0.04939734f, 0.32820848f, -0.12699823f, -0.20563799f, 0.04781079f, 
    -0.01763903f, 0.03755618f, -0.05920703f, 0.07408240f, 0.08410761f, -0.08498096f, -0.00592123f, -0.11836693f, 
    0.11305165f, -0.01986354f, 0.01810218f, -0.19216056f, 0.10894526f, -0.01980235f, 0.10505097f, -0.08022880f, 
    0.01067981f, -0.03981681f, -0.03903129f, -0.03976663f, 0.12246618f, 0.05284774f, 0.03211572f, -0.34714413f, 
    0.09215081f, -0.02278957f, -0.05865779f, 0.00051975f, 0.19497007f, 0.06381974f, -0.02354595f, 0.06914157f, 
    0.20547077f, 0.04041786f, -0.05094897f, -0.04801372f, 0.04440103f, -0.01828405f, 0.01704638f, 0.04380723f, 
    -0.06260985f, 0.19656354f, -0.08647023f, -0.13427034f, 0.13779680f, -0.01799222f, -0.20146856f, 0.17349324f, 
    -0.03535205f, 0.04909834f, 0.03014910f, 0.11081055f, 0.03238489f, 0.05058093f, 0.02818892f, 0.03036279f, 
    -0.17282133f, -0.03963164f, 0.12744574f, -0.07444810f, -0.08995483f, 0.00171409f, 0.14233032f, 0.13358559f, 
    0.05200764f, 0.08991890f, 0.04557374f, 0.01544485f, -0.03675947f, -0.06354064f, -0.20518674f, -0.13769968f, 
    -0.03683955f, -0.05732344f, -0.01168129f, 0.05453086f, -0.01344723f, -0.11926214f, -0.13648763f, 0.07132822f, 
    0.19759655f, 0.36964977f, 0.22865501f, 0.14253430f, -0.06359986f, 0.12276675f, 0.03308176f, 0.16776589f, 
    -0.01056771f, -0.24661812f, -0.00511746f, -0.11521516f, 0.07803298f, -0.06698597f, -0.05813961f, -0.19736268f, 
    0.08384369f, 0.03793451f, 0.07284561f, -0.02849580f, 0.17168808f, 0.01387839f, 0.10064620f, 0.00949505f, 
    0.18860309f, 0.05041916f, 0.18497628f, 0.38712269f, -0.07140733f, -0.08609631f, -0.01920228f, 0.15694462f, 
    0.11593404f, 0.02122070f, 0.11078525f, -0.03255335f, 0.06190530f, 0.26162019f, -0.16287687f, -0.13088495f, 
    -0.04084986f, 0.07438878f, -0.08215281f, -0.01059708f, -0.08186776f, 0.08105922f, 0.03328061f, -0.05152255f, 
    0.28535247f, -0.11954437f, 0.02947392f, -0.29690319f, -0.15217422f, 0.08841362f, -0.00671400f, -0.00646420f, 
    0.02888135f, 0.05737713f, 0.15291005f, 0.14155322f, -0.22851543f, -0.09111390f, 0.09718788f, -0.06050414f, 
    -0.00085560f, -0.00989529f, -0.02486675f, 0.09797095f, 0.11576532f, 0.05190136f, 0.06152310f, 0.00737000f, 
    0.11370406f, 0.05404210f, -0.15861115f, 0.15276335f, 0.17076445f, 0.03925091f, -0.03899069f, -0.15438569f, 
    -0.12244592f, 0.04668591f, 0.10190520f, 0.00570753f, 0.05162262f, 0.09214769f, -0.06823764f, -0.21162789f, 
    -0.09857590f, -0.00784828f, 0.04715187f, 0.11063726f, 0.03482689f, -0.04677173f, -0.01251283f, 0.05870271f, 
    0.18878937f, -0.08602688f, 0.21068513f, -0.25581774f, -0.02473249f, 0.23335917f, -0.04711243f, 0.13029782f, 
    0.05986937f, 0.01868828f, 0.08959863f, -0.04639110f, 0.02601055f, -0.10085648f, -0.11495854f, 0.24306531f, 
    -0.06588116f, -0.02699034f, 0.04826577f, 0.07696397f, 0.02963652f, 0.03137422f, 0.11559226f, 0.03031175f, 
    0.30187881f, 0.02187645f, 0.11624053f, -0.19782220f, 0.00106320f, -0.01424078f, 0.01508456f, -0.01665661f, 
    0.07647580f, 0.00281362f, -0.10494163f, 0.13347091f, -0.09405875f, -0.17089583f, 0.02987457f, -0.05692305f, 
    0.02921074f, -0.11605751f, 0.05470777f, 0.02834421f, -0.02852975f, -0.15925594f, 0.03045791f, -0.00097115f, 
    -0.00647980f, 0.02451138f, 0.05363804f, 0.32748786f, 0.04955164f, -0.03441229f, -0.03374451f, 0.01038282f, 
    0.10449728f, 0.03289303f, -0.02114788f, -0.02244780f, 0.09812067f, -0.01522737f, -0.05857464f, 0.01446554f, 
    -0.02178303f, 0.03622289f, 0.10040406f, 0.03544764f, 0.12773356f, -0.09958439f, -0.07406570f, -0.01563604f, 
    0.18831727f, -0.21949427f, -0.09289403f, 0.03090262f, -0.05859915f, 0.13428473f, -0.04390290f, 0.04785974f, 
    -0.11490992f, 0.02463231f, 0.01733988f, 0.00397072f, -0.34096146f, 0.03520675f, -0.09880261f, -0.11535134f, 
    -0.03201681f, 0.02361057f, -0.14829114f, -0.10392214f, -0.01833473f, 0.07902123f, 0.04534983f, -0.20372011f, 
    0.21697915f, 0.00331758f, -0.05156876f, 0.40813765f, -0.00149853f, 0.06511500f, 0.04011987f, 0.04836285f, 
    -0.04361608f, 0.08003097f, -0.05632757f, 0.00641846f, -0.10595468f, -0.08218820f, -0.15603191f, 0.01727692f, 
    -0.03703352f, 0.02773586f, -0.15554474f, -0.12126097f, 0.23342523f, 0.12334604f, -0.02920739f, 0.07792725f, 
    0.12715572f, -0.09035752f, -0.17712662f, 0.18084918f, -0.14304598f, 0.08737181f, -0.05534682f, 0.04872659f, 
    0.10066492f, -0.09339558f, -0.09001476f, 0.05645577f, 0.28889477f, 0.14409797f, -0.11161856f, 0.09597516f, 
    -0.00148508f, 0.01779973f, 0.08172861f, 0.08509418f, -0.05924405f, 0.12117349f, 0.05081194f, -0.01961148f, 
    0.43555641f, -0.02335020f, 0.02936257f, 0.24974966f, -0.06529783f, -0.02825102f, -0.02344936f, 0.03026569f, 
    -0.15793394f, -0.00176556f, 0.07178794f, -0.12926731f, 0.04647824f, -0.22934020f, -0.00773178f, 0.15878007f, 
    0.15155335f, -0.03888565f, -0.04229316f, -0.04011330f, 0.04440219f, 0.15812419f, 0.04457585f, -0.14912800f, 
    0.03474394f, -0.03131222f, 0.00230849f, -0.02471028f, -0.02138883f, -0.04443099f, -0.01277746f, 0.05700050f, 
    -0.01987801f, 0.03717762f, 0.03985063f, 0.02227205f, 0.01706942f, -0.04981177f, -0.00547590f, -0.04120445f, 
    0.03331028f, 0.01144749f, 0.05954636f, 0.00752034f, -0.04191898f, 0.05979569f, -0.05093077f, 0.04369342f, 
    -0.01122377f, 0.02665279f, -0.02158679f, 0.02175127f, 0.01715965f, -0.03434999f, -0.02070614f, -0.04554749f, 
    0.03005139f, -0.05288437f, 0.03674511f, -0.02535060f, -0.00527525f, -0.07265174f, -0.01077608f, 0.00711468f, 
    0.02909604f, -0.04416675f, 0.00960197f, -0.00597724f, 0.01469181f, 0.05221382f, 0.04407804f, -0.01822491f, 
    -0.03696216f, 0.03126574f, -0.04326199f, 0.02849851f, -0.00860161f, 0.02295165f, 0.05453590f, -0.00350237f, 
    0.03602814f, 0.00992905f, -0.01297307f, -0.00941264f, 0.03449847f, -0.00732675f, 0.06237049f, 0.02355481f, 
    -0.00179170f, -0.05816825f, 0.01389488f, 0.03255520f, -0.01173076f, -0.02733509f, -0.03696181f, -0.00375794f, 
    0.04278350f, 0.02046928f, 0.01289540f, 0.01404312f, -0.03891164f, -0.04362215f, 0.01558704f, 0.04696035f, 
    -0.06279059f, 0.02787201f, -0.00265315f, 0.03491440f, -0.03049731f, 0.00179335f, -0.04253800f, -0.07237345f, 
    -0.02080782f, -0.03118184f, -0.00963153f, -0.00329515f, 0.00589049f, -0.04402557f, 0.02085063f, 0.00550306f, 
    -0.01244169f, -0.02705085f, 0.00491927f, -0.06902953f, 0.03535778f, 0.02840967f, -0.03054185f, -0.01661225f, 
    -0.03342488f, 0.04750562f, -0.04193256f, -0.03595403f, 0.04336914f, -0.05748802f, -0.04297177f, 0.05807045f, 
    -0.05489275f, -0.04059909f, -0.04009348f, -0.04819358f, -0.01390653f, 0.04557552f, -0.00743156f, -0.01961085f, 
    -0.00611205f, -0.02660179f, 0.05570978f, 0.06133456f, 0.00536389f, -0.06606530f, -0.01457790f, -0.04514793f, 
    -0.04756398f, -0.00238639f, -0.02219177f, -0.06027842f, 0.00587021f, -0.02062160f, -0.04217587f, -0.07277267f, 
    -0.00565756f, 0.01337034f, 0.02847091f, -0.02689955f, 0.03174086f, -0.01211673f, -0.01457454f, -0.01482719f, 
    0.04162056f, -0.03691704f, -0.01572526f, -0.03838551f, -0.01844922f, -0.00286245f, 0.03432035f, -0.00267685f, 
    0.01210745f, 0.04528587f, -0.01962814f, 0.01997696f, 0.01912786f, -0.04903646f, 0.00507605f, 0.01992023f, 
    0.01463855f, 0.02648101f, 0.00599887f, -0.01882605f, -0.04644149f, -0.02307699f, 0.01434760f, -0.02884877f, 
    -0.01642068f, 0.04865028f, 0.02162456f, -0.02418991f, -0.02820333f, -0.03593039f, 0.00958960f, -0.01572890f, 
    0.03233813f, 0.00174543f, -0.03146612f, -0.02684374f, -0.05807346f, 0.05137222f, 0.00292807f, 0.07015122f, 
    -0.00946435f, 0.01171387f, -0.04235499f, 0.00616401f, 0.04090614f, -0.02664470f, -0.04875149f, -0.00221936f, 
    0.01016666f, -0.02010169f, 0.01027980f, -0.02421655f, 0.02288785f, 0.03843033f, -0.05128692f, -0.02923332f, 
    -0.01484100f, -0.02681391f, -0.04951439f, 0.07084851f, 0.00890213f, -0.05454337f, 0.02822398f, -0.04521165f, 
    0.04956110f, -0.01745629f, -0.00301030f, 0.01971861f, -0.03901756f, -0.07382115f, 0.01605520f, 0.01475071f, 
    0.01244836f, 0.02577749f, -0.02476231f, 0.05113887f, -0.03662104f, -0.04139392f, 0.04580189f, -0.02875362f, 
    0.02048483f, -0.00302924f, -0.04367313f, 0.00297587f, -0.00563930f, 0.00275269f, -0.01017217f, -0.04378726f, 
    -0.02534234f, 0.03870721f, -0.03787355f, -0.01376188f, 0.03487436f, -0.02292648f, 0.00629619f, 0.04039556f, 
    -0.03395519f, -0.03356905f, -0.02521028f, -0.03990159f, -0.03784818f, -0.02801806f, 0.02407203f, -0.00618015f, 
    0.00489074f, 0.01356696f, -0.00658395f, -0.01804171f, 0.04286933f, -0.03599852f, 0.01478493f, 0.01224512f, 
    -0.02681499f, -0.03859355f, 0.02481511f, -0.00258133f, 0.02675229f, 0.02938415f, -0.00817764f, 0.00810756f, 
    -0.03038287f, -0.02359943f, -0.04460927f, -0.07951508f, 0.01150791f, -0.00825909f, 0.03867351f, 0.02797731f, 
    -0.00438085f, -0.03705067f, -0.03803888f, 0.02013456f, 0.03260544f, -0.06453034f, 0.02948422f, 0.01576832f, 
    -0.03310867f, -0.01278520f, 0.00818829f, -0.02271736f, -0.03479564f, -0.05651093f, 0.04121992f, 0.00043366f, 
    -0.04462503f, -0.01218835f, 0.01247452f, -0.01538614f, 0.03114163f, -0.05829419f, 0.02218408f, 0.04169176f, 
    0.01178391f, 0.01339126f, -0.00973475f, 0.03903350f, -0.02931577f, -0.03978094f, 0.00212295f, -0.03281374f, 
    0.05447327f, 0.03376328f, -0.00815842f, -0.02017593f, 0.00747137f, -0.06060908f, -0.03078138f, 0.03340674f, 
    -0.02887692f, 0.02990332f, -0.05119523f, 0.00819901f, -0.02893833f, -0.05034820f, -0.02620692f, 0.02286378f, 
    -0.05667109f, 0.00172293f, -0.02574008f, -0.02948911f, -0.03249817f, -0.00348333f, -0.00375806f, -0.05722156f, 
    -0.05701932f, 0.04234975f, 0.05943256f, 0.00928283f, -0.06954700f, -0.01434378f, -0.05079058f, -0.00977235f, 
    -0.05675568f, -0.03764671f, 0.02725348f, -0.07050165f, 0.02049153f, 0.01929833f, -0.03669145f, -0.04934148f, 
    0.03396003f, -0.02857940f, -0.02521138f, 0.04103674f, 0.00012423f, -0.01298497f, -0.01103569f, -0.00597908f, 
    -0.05240190f, 0.03033565f, -0.03949356f, 0.04006482f, -0.04293151f, -0.02433822f, 0.06166335f, -0.03454014f, 
    -0.08295445f, 0.00522219f, 0.03593488f, -0.09208654f, -0.01874803f, 0.02488018f, -0.03017035f, 0.06162790f, 
    -0.00643259f, -0.05674005f, -0.00715866f, 0.03047694f, 0.02570277f, -0.02313056f, 0.02165503f, -0.09446871f, 
    0.00180667f, 0.03238106f, -0.01132234f, -0.03788070f, 0.03827469f, 0.02920984f, -0.04113476f, 0.05987520f, 
    -0.00894612f, 0.04295817f, -0.02223968f, 0.00166882f, -0.03358342f, 0.00891452f, -0.01036909f, -0.03464644f, 
    0.00208948f, -0.02082614f, -0.04893018f, -0.03687740f, -0.04234380f, 0.02817607f, 0.03073882f, 0.03199542f, 
    0.02267141f, -0.04137710f, 0.01813561f, -0.00086390f, -0.03565144f, -0.02324448f, -0.02991317f, -0.00233189f, 
    -0.03447084f, 0.01385020f, 0.01917564f, 0.01084237f, 0.02465357f, 0.01886064f, -0.02466543f, -0.01506117f, 
    -0.00551309f, -0.02279572f, -0.04393522f, 0.01599706f, -0.00939528f, 0.02290447f, 0.03666025f, -0.02624280f, 
    -0.01626461f, 0.02950724f, 0.01943846f, -0.03533199f, 0.02741934f, -0.03831340f, -0.01247351f, -0.03123591f, 
    0.01605049f, 0.00789780f, 0.02168075f, -0.00566738f, -0.03104938f, 0.01985710f, 0.03164136f, -0.03469379f, 
    -0.02714032f, 0.02087321f, -0.04838294f, 0.01560388f, 0.02439045f, 0.03361897f, 0.02440069f, -0.02053648f, 
    0.02300777f, 0.03043441f, 0.00618370f, -0.00236735f, 0.01098453f, -0.00296988f, 0.01243481f, 0.01306985f, 
    -0.04185677f, -0.04653279f, -0.02436373f, -0.04122616f, 0.02373903f, -0.05913215f, 0.01082864f, 0.03531819f, 
    0.04199407f, -0.00763844f, -0.05383792f, 0.01288436f, 0.02594753f, -0.04128394f, -0.03167399f, -0.03312422f, 
    -0.03179420f, 0.04054409f, -0.03393403f, 0.01228907f, -0.03037173f, 0.03841629f, -0.04404800f, -0.01004477f, 
    -0.01020725f, -0.04366201f, -0.03916850f, -0.00343023f, 0.03850880f, 0.02609831f, -0.02764605f, -0.00183495f, 
    -0.01854861f, 0.02941020f, -0.01878570f, -0.00413302f, 0.03015651f, -0.03323807f, -0.03779754f, -0.03367535f, 
    0.02565041f, -0.01301189f, 0.05854315f, -0.04593234f, -0.03431437f, -0.00363344f, 0.03481462f, -0.03784635f, 
    -0.01781691f, 0.05456700f, -0.03260916f, 0.01994915f, -0.00339002f, 0.01288086f, 0.01490979f, -0.00936760f, 
    -0.01275713f, -0.00968551f, -0.00890927f, -0.02167308f, 0.04016322f, 0.04028659f, -0.03278397f, -0.02983859f, 
    0.00158822f, -0.00422716f, 0.00377952f, 0.02239922f, 0.03804805f, 0.04194603f, 0.00926226f, -0.04703438f, 
    -0.00700344f, -0.04229052f, -0.05224996f, 0.02026879f, 0.02205388f, 0.04523460f, -0.02255464f, 0.02229038f, 
    0.03160912f, 0.03526889f, 0.04948744f, -0.00013279f, -0.05593172f, 0.02787711f, -0.03216672f, -0.04333452f, 
    -0.04288045f, -0.01050656f, -0.00623554f, -0.04091130f, 0.00852046f, -0.01422345f, 0.01141286f, 0.00436542f, 
    0.00208864f, -0.05241006f, 0.02810897f, -0.01614998f, -0.03441432f, 0.02084836f, 0.03351304f, -0.04838189f, 
    0.02006861f, 0.00508954f, -0.05144974f, -0.01550771f, -0.04264859f, -0.01500722f, -0.01627555f, 0.02070069f, 
    0.03422876f, -0.02592838f, -0.00493895f, 0.00105295f, 0.02266673f, -0.03389858f, -0.04897574f, -0.02192999f, 
    0.00439308f, 0.01146046f, 0.02830208f, 0.03733889f, -0.01849217f, 0.04140440f, 0.01140534f, -0.00141510f, 
    -0.04481285f, 0.02993584f, -0.01732337f, 0.02426335f, -0.03626943f, -0.02252204f, -0.04724059f, 0.01825579f, 
    0.01566994f, -0.05754796f, 0.03884736f, 0.01757055f, 0.00400448f, -0.04651868f, -0.00791955f, 0.00557864f, 
    -0.05313117f, 0.01770717f, -0.01695220f, 0.02916223f, -0.03082120f, 0.00608150f, -0.03285559f, -0.01356908f, 
    0.03728851f, -0.01825855f, 0.00189933f, -0.03067646f, 0.01469800f, 0.03225522f, 0.00614884f, 0.01199950f, 
    0.03721251f, -0.02237664f, 0.04542627f, -0.01390823f, -0.05562305f, 0.02978047f, -0.04138831f, 0.00672257f, 
    -0.02883524f, -0.03056758f, 0.00252455f, -0.03461887f, 0.04009220f, 0.03251048f, 0.02558315f, 0.03443836f, 
    -0.04046795f, -0.00418817f, -0.05770616f, 0.00201920f, -0.01677978f, 0.01091674f, -0.03108404f, 0.03037568f, 
    -0.00480494f, -0.00478483f, -0.03242345f, -0.05395819f, 0.04369779f, 0.02956862f, -0.05640266f, 0.01160574f, 
    -0.03291112f, 0.03510451f, -0.01059502f, -0.03485862f, -0.04838869f, -0.04573471f, -0.01984691f, 0.00301096f, 
    -0.05103284f, 0.03875205f, -0.04348449f, -0.05624189f, -0.00618730f, 0.03298556f, -0.00910327f, -0.04878210f, 
    0.00245823f, -0.01931825f, -0.05689749f, -0.00231198f, -0.04407930f, -0.05158519f, 0.01747739f, -0.03829290f, 
    0.03903365f, -0.02349338f, 0.01370984f, 0.02575843f, 0.04232906f, 0.00189228f, 0.01973082f, -0.04797783f, 
    0.03937522f, -0.04629158f, 0.00112200f, -0.02269244f, 0.04011033f, 0.03357176f, 0.00401304f, 0.04631526f, 
    0.03798619f, -0.00358770f, 0.03897720f, -0.02976031f, -0.03823762f, -0.03971281f, -0.02801321f, 0.01062133f, 
    0.02944686f, -0.05163450f, -0.03375117f, -0.00100780f, -0.00665062f, -0.02898340f, 0.02958707f, 0.02984317f, 
    -0.06030241f, 0.00831942f, 0.00868386f, -0.04544155f, -0.04509920f, -0.02830882f, 0.03277523f, 0.01736571f, 
    0.00093501f, 0.00313610f, -0.01387907f, 0.03632497f, -0.05323831f, 0.04210197f, 0.00143326f, -0.05667813f, 
    -0.00697927f, -0.00148782f, 0.02281678f, -0.04162165f, -0.03658551f, -0.05086118f, 0.05050296f, 0.01084444f, 
    0.03866461f, -0.03948471f, 0.04609948f, 0.00268302f, -0.04578147f, 0.01055620f, -0.01771442f, 0.00247743f, 
    -0.04799047f, 0.00292347f, 0.01884554f, 0.04645906f, 0.04079891f, -0.05690800f, -0.00319241f, -0.04432046f, 
    0.04167240f, 0.03866068f, -0.04505918f, -0.00511879f, 0.04035800f, 0.04347406f, 0.00320598f, -0.02983431f, 
    0.03096000f, -0.01739466f, -0.01353753f, 0.04513028f, 0.00676467f, -0.02807906f, -0.00199132f, 0.00151026f, 
    0.01926492f, -0.03893823f, 0.03419305f, -0.04465659f, -0.03600136f, 0.00527165f, 0.01519187f, -0.03360622f, 
    -0.23274383f, -0.08696183f, -0.07790468f, 0.10296348f, 0.10440967f, 0.06913307f, -0.02715218f, 0.09059602f, 
    0.18839701f, 0.08953746f, -0.13754745f, 0.09278642f, -0.11917119f, 0.06797221f, -0.11493129f, -0.02963748f, 
    -0.10372964f, 0.07522032f, 0.02576785f, 0.12063439f, -0.05306175f, 0.00502175f, 0.01186054f, 0.16003247f, 
    0.20750652f, -0.08644628f, 0.05219943f, 0.13953595f, -0.00301300f, 0.01364353f, -0.00843020f, -0.11529956f, 
    0.09965326f, -0.03189189f, -0.00893278f, 0.00419987f, 0.04878441f, -0.23487240f, 0.00955317f, -0.11583539f, 
    -0.06205954f, -0.01943169f, -0.11832676f, 0.00530206f, -0.00135743f, 0.06037721f, 0.06665313f, -0.01875288f, 
    0.45185795f, -0.11434795f, 0.08085372f, -0.00577553f, 0.10071757f, -0.01699228f, -0.00079956f, -0.05690629f, 
    0.13526002f, -0.05936608f, -0.08067069f, 0.04007531f, -0.31070939f, -0.05596483f, 0.03665681f, -0.09777516f, 
    0.00702429f, 0.05469743f, 0.01138622f, -0.01082716f, 0.00093249f, -0.06679233f, 0.00882382f, 0.05828553f, 
    -0.33625865f, -0.24293460f, 0.03212464f, 0.11517675f, 0.06992605f, -0.04619144f, 0.00352819f, 0.00177751f, 
    -0.03570535f, 0.03005208f, -0.00015137f, 0.04690263f, -0.01800025f, 0.05707505f, -0.06966126f, 0.07157799f, 
    0.07652758f, 0.12916757f, 0.00964537f, -0.03672735f, 0.07251003f, -0.10464216f, -0.04478606f, -0.03065308f, 
    0.33158869f, -0.10466832f, 0.09058385f, -0.09919475f, 0.04461619f, 0.02390820f, -0.15756625f, 0.06658884f, 
    -0.00387995f, -0.05226356f, -0.01391220f, 0.06582396f, -0.37583104f, -0.10485565f, -0.02610511f, -0.00139191f, 
    0.00683938f, 0.05538485f, 0.19822448f, 0.04156539f, 0.00426773f, 0.14057380f, 0.04650944f, 0.03221543f, 
    -0.12136906f, -0.11936887f, -0.00421775f, 0.19778219f, 0.18631735f, -0.04098326f, -0.09202524f, 0.14884958f, 
    0.11609652f, 0.05038469f, -0.06456603f, -0.04206079f, -0.12863888f, 0.05389734f, 0.19228472f, -0.07624900f, 
    0.05658091f, 0.00912449f, -0.03463808f, 0.07635842f, 0.02090806f, 0.00928170f, 0.08995032f, 0.04020607f, 
    -0.17909513f, -0.04760562f, -0.13680750f, 0.05621994f, 0.10473825f, 0.03317999f, -0.00655539f, 0.12177899f, 
    0.06272185f, -0.02063017f, -0.09639289f, -0.02811914f, -0.24028854f, 0.11153539f, -0.05988071f, -0.16907470f, 
    -0.01595805f, -0.03911825f, 0.00892311f, 0.02561516f, -0.06698412f, 0.12436321f, 0.12546675f, 0.03540302f, 
    0.19159439f, -0.10160428f, 0.18015119f, -0.17791826f, 0.00259583f, 0.02163944f, -0.07755304f, -0.01936825f, 
    0.00390439f, -0.04452847f, 0.07590132f, 0.03610436f, -0.03703886f, -0.14838922f, 0.00430676f, -0.21302354f, 
    0.18982828f, -0.02853044f, 0.06963863f, 0.09769755f, 0.18060412f, 0.07003809f, -0.01276909f, 0.09417689f, 
    -0.46411449f, 0.43258435f, 0.02594183f, -0.03731385f, 0.10486536f, -0.05373220f, -0.07693529f, -0.00341924f, 
    -0.08749727f, 0.11866322f, -0.01981378f, -0.01701326f, -0.00281201f, -0.14926675f, 0.14231439f, 0.09722470f, 
    -0.06086213f, 0.06680796f, 0.03652544f, 0.02050005f, -0.08185761f, -0.06929930f, 0.00521171f, -0.00969998f, 
    0.04181739f, -0.12264172f, -0.01819693f, 0.14736646f, 0.10946047f, 0.01951184f, -0.03599362f, 0.03874189f, 
    -0.03202059f, 0.09856760f, 0.05084650f, 0.13680832f, 0.01524466f, 0.06016539f, 0.03173449f, 0.14262147f, 
    0.07435762f, -0.01035079f, -0.05096933f, 0.07116990f, -0.02859764f, -0.00683977f, -0.02916020f, -0.07478885f, 
    0.27002656f, -0.08956913f, 0.16109131f, -0.10723221f, -0.01617639f, 0.08044746f, 0.09722904f, -0.02989300f, 
    -0.09704746f, 0.00115085f, 0.03061207f, 0.00117060f, -0.06214236f, 0.09640098f, 0.08689262f, -0.04533049f, 
    0.12968263f, -0.02354681f, 0.07732882f, 0.00271195f, 0.07797007f, 0.11202516f, 0.01758934f, -0.01722879f, 
    -0.26995018f, -0.22190285f, 0.12733087f, 0.04055196f, -0.08309223f, -0.07528052f, 0.06039615f, -0.00467522f, 
    0.04501015f, 0.11749229f, 0.06012047f, 0.04718578f, -0.12315253f, -0.08641329f, -0.06213308f, 0.15077318f, 
    0.02912749f, 0.20503856f, 0.07145221f, 0.11908035f, 0.11500529f, -0.16204099f, 0.02938552f, -0.05494050f, 
    -0.16285911f, 0.06740852f, 0.06913608f, -0.08110410f, -0.07555892f, -0.05076412f, 0.05010418f, -0.01665420f, 
    -0.00838275f, -0.10990444f, -0.05821367f, -0.12888977f, -0.10017761f, -0.10765900f, -0.02591169f, -0.09414434f, 
    -0.00751730f, -0.15244444f, -0.00957503f, -0.02482527f, -0.01870796f, -0.04236843f, 0.16256930f, 0.16234349f, 
    -0.19813325f, 0.36001322f, -0.19777189f, 0.00903403f, 0.07684390f, -0.07302283f, 0.04377433f, -0.10885072f, 
    0.05009397f, -0.01578927f, -0.10194164f, 0.00159546f, -0.23937614f, -0.09144245f, 0.07387455f, 0.17211372f, 
    -0.04567884f, 0.05386801f, -0.04449281f, -0.05047056f, -0.07059038f, -0.10662203f, 0.07253321f, 0.00508379f, 
    0.07840312f, -0.11712378f, 0.23201871f, 0.10184036f, -0.05226675f, -0.00919887f, 0.11351164f, -0.04560480f, 
    0.10365082f, 0.05201922f, -0.08426270f, 0.16447623f, 0.11618364f, 0.17134131f, 0.04696585f, -0.02288755f, 
    0.01809116f, 0.03530343f, 0.01498986f, -0.12740797f, 0.09465566f, 0.05121324f, 0.15142244f, -0.03144994f, 
    0.01754921f, 0.20351468f, -0.02319790f, -0.14445260f, 0.10138499f, 0.06728798f, 0.08642844f, 0.03725457f, 
    -0.00354105f, 0.02679601f, -0.01636702f, 0.06202658f, -0.04407429f, -0.02581560f, 0.20274597f, -0.10020033f, 
    -0.02825727f, 0.03545382f, -0.00911725f, -0.03850190f, 0.00588151f, 0.00818229f, 0.00971636f, 0.09891608f, 
    -0.03239423f, -0.03687715f, -0.04263005f, -0.02568600f, -0.02798608f, -0.02932757f, -0.04393774f, 0.02199682f, 
    -0.03331527f, -0.05959282f, 0.02359690f, -0.04797651f, 0.02681732f, -0.05175857f, -0.01604200f, 0.03993749f, 
    -0.00927170f, 0.00166172f, -0.01868026f, -0.00157491f, 0.04936282f, -0.03826228f, -0.03072073f, 0.02912464f, 
    0.02345993f, -0.04144993f, -0.02157058f, 0.03106930f, 0.00241351f, 0.03728294f, 0.03584845f, -0.00804952f, 
    0.02031704f, 0.01099319f, -0.05384254f, 0.01550101f, 0.02405413f, 0.01822639f, -0.03177246f, -0.00938311f, 
    0.03858348f, -0.04239813f, 0.03640741f, -0.00359647f, -0.00853227f, -0.02089772f, 0.03961970f, -0.02734474f, 
    0.02980085f, -0.00250038f, -0.03724971f, -0.05865990f, -0.01613193f, -0.00807747f, -0.04982575f, 0.03485577f, 
    0.04011630f, -0.05357672f, -0.00941773f, -0.02960827f, 0.02373527f, -0.00091887f, -0.03171313f, -0.03328456f, 
    -0.00838460f, -0.03962912f, 0.01101661f, 0.00311668f, -0.02078724f, -0.04241417f, -0.02356356f, -0.02487370f, 
    0.00138048f, -0.01500795f, -0.01787878f, 0.03813371f, 0.01129576f, -0.03775683f, -0.05427577f, -0.02900965f, 
    -0.04031828f, -0.00854823f, 0.01423814f, 0.02795636f, -0.05694937f, -0.00488139f, 0.02087979f, 0.02528344f, 
    -0.05570884f, -0.02421595f, -0.02613608f, 0.03702417f, 0.01332952f, 0.03502216f, 0.02800087f, 0.00764777f, 
    -0.00961682f, 0.03128109f, 0.03472490f, -0.01708857f, -0.04743975f, 0.03888116f, -0.02824198f, 0.01380059f, 
    -0.04766998f, -0.00820421f, -0.00769245f, -0.05549429f, 0.02159301f, 0.02672173f, -0.05148028f, 0.04360704f, 
    -0.03335308f, -0.04923072f, -0.02692271f, 0.01278236f, 0.03214375f, -0.05843034f, -0.04366187f, 0.00387832f, 
    -0.00056160f, -0.02105940f, -0.02214816f, 0.01494364f, -0.02467619f, -0.00489851f, -0.00724716f, -0.01746201f, 
    0.02848727f, 0.00303771f, -0.05880886f, 0.01015905f, 0.02842296f, -0.04546418f, 0.00019543f, -0.01625990f, 
    -0.02625485f, 0.04037765f, -0.00820846f, -0.04903859f, -0.00151415f, 0.00299167f, 0.00750865f, -0.01969765f, 
    0.03267819f, 0.01399290f, -0.00750891f, -0.05379790f, 0.01089143f, 0.04170030f, -0.01843852f, -0.04967916f, 
    0.04181723f, -0.03842905f, 0.02810860f, -0.03381653f, 0.03987319f, 0.02161209f, -0.02027275f, -0.04112849f, 
    -0.04149058f, 0.01375694f, 0.01480484f, -0.03109408f, 0.00015231f, 0.01161252f, -0.03499620f, -0.01348616f, 
    0.02076597f, -0.05378227f, -0.03135727f, -0.02187400f, -0.05896694f, -0.05750611f, -0.04291938f, 0.02546194f, 
    0.03914945f, 0.01879181f, 0.02184098f, 0.00700711f, 0.03388820f, 0.00982065f, -0.02783205f, 0.03184969f, 
    0.02374615f, 0.03647784f, -0.02622145f, 0.02481635f, 0.02998152f, -0.04599742f, -0.05178327f, 0.01827097f, 
    0.03992720f, -0.03126689f, -0.03268497f, -0.03286439f, -0.02894685f, 0.02532887f, 0.00862949f, -0.05363610f, 
    0.03141582f, -0.01426832f, 0.01620846f, -0.03248132f, 0.03915220f, -0.02560006f, 0.01809875f, -0.01763737f, 
    -0.02962205f, -0.02708905f, 0.03805268f, -0.00529823f, 0.04585676f, 0.03304041f, -0.03092866f, -0.02569791f, 
    0.01966488f, 0.02419015f, -0.02235272f, 0.00265456f, 0.00701407f, 0.02695313f, 0.02795302f, 0.00484932f, 
    0.01895159f, -0.00320646f, -0.04825210f, 0.03733494f, -0.03850261f, -0.04498816f, 0.03514411f, -0.05574945f, 
    0.01877324f, 0.04142712f, 0.02709152f, -0.05532473f, -0.03746358f, 0.01575579f, 0.02916353f, 0.02439834f, 
    0.00774715f, -0.00341626f, 0.03440515f, -0.03900859f, 0.03844190f, 0.03340551f, -0.02131468f, -0.03590977f, 
    -0.05880899f, 0.02040461f, -0.01679981f, -0.03270148f, 0.01671632f, -0.05863121f, -0.02323123f, -0.02435087f, 
    -0.03378253f, 0.03802730f, -0.03692138f, -0.04205425f, -0.02114232f, -0.00739689f, 0.02227238f, -0.00769327f, 
    -0.05089453f, 0.01956788f, 0.02059561f, -0.05007278f, -0.04517310f, -0.04460267f, -0.01428936f, -0.01838874f, 
    -0.04460414f, 0.03013400f, -0.04908060f, 0.00834548f, 0.01746343f, 0.03489203f, 0.02396007f, -0.00129966f, 
    0.04269265f, -0.00169592f, -0.02618543f, 0.02686875f, 0.03172005f, -0.01322952f, 0.00324103f, 0.00452282f, 
    -0.05696681f, 0.04129805f, 0.01239661f, 0.00828681f, -0.00898479f, -0.05266280f, 0.02364651f, -0.02698167f, 
    0.02035130f, 0.03059744f, -0.02140572f, -0.00089259f, -0.04209265f, -0.03479620f, -0.04290340f, -0.01157625f, 
    -0.01643010f, -0.03454041f, -0.03565658f, -0.03985753f, -0.03787079f, 0.01689199f, -0.00476235f, -0.01428938f, 
    -0.05558906f, -0.02552075f, 0.03683469f, -0.04681790f, 0.02700079f, -0.04645506f, -0.05987684f, -0.03804415f, 
    0.00674334f, -0.00075114f, -0.03587165f, -0.05661690f, 0.01911716f, -0.01897452f, 0.00319504f, 0.00236747f, 
    -0.00066174f, 0.02730195f, 0.00741864f, -0.03548884f, -0.03151963f, -0.04349142f, -0.02274889f, -0.00606427f, 
    0.03810005f, -0.00634969f, -0.04798774f, -0.04096733f, 0.03165037f, 0.03872547f, 0.00109899f, -0.00984913f, 
    -0.01087975f, 0.01244592f, -0.00385296f, -0.01190399f, -0.03276160f, 0.00841510f, 0.02582874f, -0.01547265f, 
    -0.05831311f, -0.01388254f, -0.04973834f, -0.01834528f, 0.00346573f, -0.04079026f, 0.01849549f, -0.00380258f, 
    0.03976814f, -0.01318447f, 0.02876717f, -0.04756975f, 0.02833572f, -0.03563796f, -0.01553034f, -0.00178098f, 
    -0.03673401f, 0.01884925f, -0.01670678f, -0.04139858f, -0.03753451f, -0.02081662f, 0.03850929f, -0.04864258f, 
    -0.04485604f, -0.03013645f, -0.04397658f, 0.02340580f, 0.02882191f, 0.00132018f, -0.02987760f, 0.03468142f, 
    0.05278154f, -0.08872411f, -0.04181856f, 0.01025590f, 0.00349821f, 0.01590667f, 0.04674703f, 0.05830848f, 
    -0.04452710f, 0.03799661f, 0.09418764f, -0.01257673f, 0.22205420f, 0.04661638f, 0.17362529f, 0.05545108f, 
    0.14242576f, -0.16975957f, 0.06662596f, 0.04486375f, -0.05242277f, -0.08095171f, -0.02348473f, 0.10586785f, 
    -0.23002325f, -0.12928456f, -0.06075215f, 0.04992898f, 0.12776437f, 0.09476874f, 0.02923217f, 0.00302245f, 
    0.01179350f, 0.00028009f, -0.04839573f, -0.00878394f, 0.20323882f, 0.13262632f, -0.42205435f, 0.09707857f, 
    0.04220775f, -0.04199700f, 0.00509032f, 0.08835986f, -0.05249028f, -0.08893091f, -0.01530711f, -0.05545669f, 
    -0.30647153f, 0.00599369f, -0.10729779f, -0.06879137f, 0.13301818f, 0.05682646f, 0.07551149f, -0.04353238f, 
    0.07985342f, -0.01392090f, 0.02428850f, 0.01860415f, -0.03827368f, -0.01098562f, 0.07011136f, -0.01507532f, 
    0.22522378f, -0.11123206f, 0.01216858f, 0.04970274f, 0.11857314f, 0.11111815f, -0.06394417f, -0.02065266f, 
    0.20149617f, 0.21576771f, -0.12717067f, -0.03679318f, 0.10738387f, 0.08182635f, 0.01888515f, 0.04877427f, 
    0.01694656f, 0.01644103f, -0.18084869f, -0.09814800f, -0.02113745f, 0.01694841f, -0.10806116f, -0.06687775f, 
    0.19958009f, 0.03555154f, -0.16627075f, 0.04073467f, 0.02916725f, 0.05842805f, 0.08338065f, 0.11337380f, 
    -0.38612503f, 0.02219302f, 0.10733689f, 0.16816033f, -0.13603987f, 0.08641530f, 0.04135133f, 0.23208582f, 
    0.01818340f, 0.02822702f, 0.02178541f, -0.03697339f, 0.40054977f, 0.08260634f, -0.04380998f, 0.00778254f, 
    0.04952015f, -0.03551184f, 0.01301157f, -0.11170676f, -0.05308780f, -0.07135875f, -0.01610259f, 0.11794721f, 
    0.09173821f, 0.14076930f, 0.11189026f, -0.04534205f, -0.05216908f, 0.14266765f, -0.04433810f, 0.16757213f, 
    -0.03308195f, -0.06693521f, 0.10303524f, -0.01256379f, 0.22445115f, -0.17097403f, -0.11011036f, -0.02510735f, 
    0.16235353f, 0.04835603f, 0.02901819f, -0.02763411f, 0.16002925f, -0.02257957f, 0.03843635f, 0.02065527f, 
    0.25576100f, -0.14845271f, 0.12151306f, 0.39241111f, -0.11087625f, -0.14165166f, 0.10728297f, 0.18859950f, 
    0.03520529f, -0.02731138f, 0.04485346f, -0.06627443f, 0.46577910f, 0.19987431f, -0.20819084f, 0.01520159f, 
    -0.01807554f, 0.05854375f, -0.14157817f, 0.01892399f, -0.11980667f, 0.03461114f, 0.02797734f, -0.15451454f, 
    0.41626987f, -0.21351893f, 0.07047340f, -0.03519769f, 0.00154869f, 0.24128273f, 0.00772117f, 0.03450983f, 
    0.01396784f, 0.04831942f, 0.06447425f, 0.11117990f, -0.35950774f, -0.10427220f, 0.22641125f, 0.17347650f, 
    -0.14911979f, 0.04468318f, -0.07023858f, 0.07593404f, -0.00984587f, 0.07650720f, 0.03346510f, 0.03980255f, 
    0.39033556f, -0.03999671f, -0.17045370f, 0.03798892f, 0.13607585f, -0.08173580f, 0.07691334f, 0.00588166f, 
    0.02527322f, -0.07889549f, 0.09850718f, 0.04948655f, 0.04661840f, -0.07252296f, -0.12182670f, 0.05109030f, 
    -0.08466019f, 0.02359424f, 0.09663758f, 0.16484056f, 0.08445529f, 0.02868938f, 0.02766112f, 0.12273991f, 
    0.41902107f, 0.21782260f, 0.16479196f, -0.19561027f, 0.00645252f, 0.09589325f, -0.07076502f, 0.07042083f, 
    0.09266687f, 0.03153062f, 0.05405090f, -0.04330480f, -0.17595252f, -0.08532459f, -0.12584323f, 0.03117519f, 
    -0.00292866f, 0.00443028f, 0.01051842f, 0.11142037f, 0.00147420f, 0.07181728f, 0.13487472f, 0.05796682f, 
    0.16060387f, -0.08422866f, 0.02745267f, 0.25533256f, 0.02578500f, 0.11460221f, -0.10351013f, -0.00584380f, 
    0.11827514f, 0.03166190f, -0.10240284f, 0.04692680f, -0.25366220f, 0.05355586f, -0.01332649f, 0.22595653f, 
    0.07662499f, 0.11546672f, 0.08849660f, -0.02288192f, 0.09895068f, -0.02919169f, 0.09504043f, 0.07996365f, 
    -0.07545232f, 0.23004273f, 0.14124857f, 0.11178976f, 0.07402410f, 0.04546310f, 0.07633471f, -0.01566441f, 
    0.15617017f, 0.02166560f, 0.01831905f, -0.01743417f, 0.22664276f, 0.16810697f, 0.06707548f, 0.03573863f, 
    0.05810579f, 0.02392863f, 0.15948296f, 0.00336953f, 0.06439810f, -0.08042945f, 0.08584999f, 0.09992962f, 
    -0.06351093f, -0.25650555f, -0.05587171f, 0.00271415f, 0.01816476f, 0.05587603f, -0.01486307f, -0.00452981f, 
    0.09266776f, 0.15026917f, -0.01645379f, 0.06884620f, -0.00410127f, 0.27756083f, 0.18475665f, -0.05597857f, 
    0.08294598f, 0.03245787f, -0.08696067f, 0.17686175f, -0.01638278f, 0.11889516f, -0.08811967f, -0.05142755f, 
    0.13609877f, -0.12498775f, 0.06627928f, -0.05011887f, -0.03642510f, 0.01896463f, 0.12077458f, 0.02536545f, 
    -0.02109930f, 0.07366660f, -0.03211078f, 0.05032998f, -0.34705278f, 0.01575667f, 0.16138311f, -0.16259637f, 
    0.06196417f, -0.01851615f, -0.04435000f, -0.00089694f, 0.18927012f, 0.05604642f, 0.11115908f, 0.07665031f, 
    -0.03910724f, -0.11770555f, -0.20605850f, 0.27491286f, -0.00798353f, 0.09110475f, -0.02908547f, -0.06738929f, 
    0.01482678f, -0.00791196f, -0.05584938f, 0.04691675f, 0.05753243f, -0.00211601f, -0.16201618f, -0.03927686f, 
    -0.02641807f, 0.01947620f, 0.02645086f, 0.18882293f, -0.09178201f, 0.08593161f, -0.01285840f, 0.02116704f, 
    0.09171464f, -0.04636405f, -0.03816432f, -0.00692861f, 0.10829428f, -0.06274629f, 0.04725245f, -0.06762632f, 
    0.01040829f, -0.04517305f, 0.08488966f, -0.04516720f, -0.13918424f, -0.21383741f, 0.01505187f, 0.12075851f, 
    0.16504215f, 0.01978411f, 0.01386784f, -0.07504655f, 0.00027106f, 0.04864402f, 0.01093944f, -0.14058450f, 
    0.00779546f, 0.00386975f, 0.03964149f, -0.00132894f, -0.00981207f, 0.03712120f, -0.03282377f, -0.02826845f, 
    -0.05448939f, -0.00585542f, -0.02565031f, -0.04757335f, -0.00695464f, -0.03107349f, -0.01943718f, -0.02718638f, 
    -0.01594791f, 0.00882515f, 0.03897372f, 0.01959221f, -0.02296881f, -0.05271020f, 0.02498611f, -0.01774115f, 
    -0.00257913f, -0.05460377f, -0.01304991f, -0.05389319f, -0.02518323f, 0.02855008f, 0.04160896f, -0.00787570f, 
    -0.05207307f, -0.01166083f, -0.05163847f, -0.03073009f, 0.01404532f, 0.03203012f, -0.04430122f, 0.04138517f, 
    -0.03911376f, -0.01514850f, -0.05031491f, 0.01558221f, 0.00440994f, -0.03923577f, -0.01764300f, -0.03202776f, 
    -0.02785368f, -0.01077935f, -0.04159104f, -0.03347165f, 0.03543545f, 0.00108900f, -0.03713191f, -0.01419773f, 
    0.04351900f, 0.00364628f, -0.00855885f, -0.04834500f, -0.05139899f, 0.02695402f, -0.02915203f, -0.04305692f, 
    0.02321142f, 0.03349098f, -0.03904906f, -0.02194840f, 0.04300708f, 0.03801166f, 0.03514586f, 0.03834394f, 
    0.00302776f, 0.00473025f, -0.03393146f, 0.01817825f, -0.05567408f, 0.00473882f, -0.02101049f, 0.03505680f, 
    0.01038399f, -0.01647189f, 0.03488586f, -0.04552433f, 0.00463313f, -0.02476462f, -0.00434281f, 0.02255654f, 
    -0.03425127f, -0.01983633f, 0.01943180f, 0.03059564f, -0.03452570f, 0.04305881f, 0.01395364f, -0.03199086f, 
    -0.03194510f, -0.01710939f, -0.04758568f, 0.00059928f, -0.01508914f, 0.02983212f, 0.02320545f, 0.00952252f, 
    -0.03669332f, -0.00950055f, 0.00958852f, -0.04160705f, 0.02272590f, 0.01118017f, 0.03153972f, -0.00664340f, 
    -0.03102519f, -0.03512301f, -0.01010997f, -0.01760595f, 0.00572634f, -0.04171418f, 0.04002685f, -0.01993648f, 
    -0.03939164f, -0.01537823f, -0.01657952f, 0.03835815f, -0.04034568f, 0.01092143f, -0.03589875f, -0.02481862f, 
    -0.05230163f, 0.01976129f, -0.02506661f, -0.02383757f, -0.05535976f, 0.04057730f, -0.00058642f, 0.00845256f, 
    -0.03179556f, -0.04225295f, 0.01400194f, -0.02984322f, 0.02195745f, 0.02533536f, -0.02750941f, -0.00360143f, 
    -0.04800561f, -0.01189515f, -0.00770138f, 0.01353405f, -0.03432900f, 0.02263226f, -0.00912753f, 0.01353407f, 
    0.00279889f, -0.04553583f, 0.02978733f, 0.03722635f, 0.01208476f, 0.00333747f, -0.04386029f, -0.04403510f, 
    -0.05097529f, 0.02491864f, 0.04108508f, 0.04073408f, 0.01797825f, -0.02800635f, 0.02982434f, 0.01676281f, 
    -0.00550924f, 0.00523484f, -0.04751090f, -0.04272766f, 0.03645908f, 0.00426417f, -0.04017160f, -0.03838668f, 
    -0.01640607f, 0.00197640f, -0.04789117f, 0.04339408f, 0.02320400f, -0.00004604f, 0.00431498f, 0.02499497f, 
    0.04053299f, 0.00124919f, 0.03911689f, 0.00284408f, -0.04145822f, 0.01628644f, 0.03600829f, 0.04253487f, 
    -0.02771802f, -0.05477113f, -0.04995417f, -0.05045648f, -0.04192105f, -0.04995695f, -0.00141792f, -0.02109949f, 
    0.01138729f, 0.01860071f, 0.01043697f, 0.03149868f, 0.00219850f, -0.05242050f, 0.02938816f, 0.00714353f, 
    0.04088318f, 0.00087387f, 0.00825654f, -0.03624319f, -0.02992173f, -0.00166451f, -0.01329353f, 0.02586760f, 
    -0.01879277f, 0.04220871f, -0.01863511f, -0.05187137f, -0.00040244f, -0.00218192f, -0.01713104f, -0.04848330f, 
    -0.02724434f, -0.03162106f, -0.05439572f, 0.04071032f, -0.05609220f, -0.00437079f, -0.03058102f, 0.01293327f, 
    -0.03878983f, 0.01100045f, 0.02497687f, 0.03992801f, -0.02479114f, 0.04189047f, 0.02518237f, 0.01649528f, 
    -0.04708886f, 0.03458778f, 0.00071405f, -0.01626860f, 0.00991678f, -0.04776827f, 0.00112402f, -0.03276143f, 
    -0.03251587f, 0.01005347f, -0.03647048f, -0.03147343f, 0.03880059f, -0.01229185f, 0.00030763f, -0.04663579f, 
    -0.03600325f, 0.02852259f, -0.04864396f, 0.00510189f, -0.02132419f, -0.03074734f, 0.03967400f, -0.05468402f, 
    0.02705879f, -0.04599516f, -0.03718751f, 0.02928192f, 0.00770783f, -0.01430216f, -0.02199970f, -0.05498869f, 
    -0.03811498f, -0.04517211f, 0.02425102f, 0.02899160f, 0.02109719f, 0.00617198f, -0.00419961f, 0.03465258f, 
    -0.01280400f, 0.04362793f, -0.03842057f, -0.05320397f, -0.05272470f, -0.00162118f, 0.00716716f, -0.00372111f, 
    -0.05313927f, 0.02491197f, 0.00602499f, 0.00729700f, 0.00334709f, -0.00945575f, -0.03481860f, 0.00540465f, 
    -0.00659694f, 0.03009550f, 0.00814792f, -0.03345445f, 0.02651281f, -0.04231334f, -0.04196305f, -0.03427733f, 
    0.00424438f, 0.04414950f, -0.04213151f, 0.00667510f, 0.00079888f, 0.02628736f, -0.03651101f, -0.03779859f, 
    -0.00279466f, 0.04300394f, 0.01285669f, -0.04772278f, -0.01628307f, 0.02826622f, 0.02885946f, 0.04119594f, 
    0.00701724f, 0.00632148f, -0.02328517f, -0.01761284f, -0.04524173f, -0.04258218f, 0.01251733f, 0.01108268f, 
    0.02059264f, 0.00254168f, -0.05535313f, 0.03354102f, -0.02476927f, 0.01770503f, 0.01450841f, 0.02268157f, 
    -0.01862964f, -0.03938313f, -0.01899234f, 0.00931296f, -0.03718804f, -0.03369381f, 0.03234125f, -0.03459595f, 
    0.04843565f, -0.02680208f, -0.00897447f, 0.01832014f, 0.03093132f, -0.01395500f, 0.01130847f, -0.04013657f, 
    0.03610390f, -0.03377895f, 0.00748138f, -0.03339906f, -0.05409997f, -0.02889027f, -0.00189833f, 0.03325651f, 
    0.00921031f, -0.02975971f, 0.02302564f, -0.01250993f, -0.04767586f, -0.00507874f, -0.05757068f, -0.03997673f, 
    0.01190181f, -0.00898065f, -0.03906323f, -0.02951963f, -0.00011356f, -0.01777496f, 0.02488742f, 0.01499327f, 
    -0.00340904f, -0.00794551f, 0.01522982f, 0.03393892f, 0.02707135f, -0.04063541f, 0.01355001f, -0.03244016f, 
    -0.26071829f, -0.06560706f, -0.09222709f, 0.10608938f, 0.07103837f, 0.16359347f, 0.01399188f, -0.09351079f, 
    -0.02834412f, 0.21877521f, 0.00335570f, -0.02983509f, -0.08077928f, 0.09013014f, -0.10850573f, 0.05624900f, 
    -0.04701517f, 0.00050637f, 0.13057517f, 0.20873110f, 0.04585996f, 0.01760798f, 0.05845679f, -0.08294036f, 
    0.02940869f, -0.02435219f, 0.19528851f, -0.10323250f, -0.03246041f, -0.07263888f, -0.08198999f, 0.04854554f, 
    0.18349890f, 0.08120086f, -0.06365752f, -0.17849576f, 0.15994824f, -0.09376603f, 0.03413957f, -0.08022132f, 
    -0.00263883f, 0.13933332f, 0.19382022f, 0.12864937f, 0.02934170f, 0.16462708f, -0.03878236f, -0.00975388f, 
    0.15727477f, -0.17474692f, 0.09381556f, 0.07022227f, 0.03548398f, -0.05617165f, -0.00567907f, 0.03549175f, 
    0.03628841f, 0.08945435f, -0.07528543f, -0.01901225f, -0.06434543f, -0.14878055f, 0.13408601f, 0.12763047f, 
    0.00428487f, 0.10713078f, 0.01605341f, 0.03859451f, 0.03553820f, 0.12580225f, -0.03449098f, -0.03041458f, 
    -0.44363424f, -0.19721365f, 0.11686578f, 0.30262545f, 0.07161248f, 0.01044583f, -0.03164854f, -0.03731577f, 
    0.01396385f, 0.02199369f, 0.04579315f, 0.08333945f, 0.01084562f, 0.10256925f, -0.05159981f, -0.20797087f, 
    -0.14822394f, -0.00285685f, 0.17855603f, 0.22529307f, 0.14495122f, -0.02734568f, 0.04346350f, 0.08192958f, 
    0.02665486f, -0.35139608f, 0.02892997f, -0.14328562f, 0.05347074f, 0.09150879f, 0.11832207f, 0.05156762f, 
    0.06769369f, 0.10531499f, 0.22875714f, 0.11066225f, -0.35128263f, 0.06429739f, -0.00500506f, 0.22511669f, 
    0.16062908f, 0.15745793f, 0.13023712f, -0.07045852f, -0.02139333f, -0.02984077f, 0.10537558f, -0.14993797f, 
    -0.04373208f, -0.22429848f, -0.03843714f, -0.04752513f, -0.00489548f, 0.00020625f, -0.06371254f, 0.07273460f, 
    0.21792772f, -0.05389892f, 0.01625675f, 0.12005238f, -0.00262034f, 0.06770302f, 0.32742420f, -0.03197702f, 
    -0.04372554f, 0.03066708f, -0.01892143f, 0.06501976f, 0.08051283f, 0.04147901f, -0.15070033f, 0.08406598f, 
    -0.19598256f, -0.05946173f, -0.20585792f, -0.27533075f, 0.10322180f, -0.04622563f, 0.01869912f, 0.13944726f, 
    0.05436631f, 0.03168187f, 0.13504438f, 0.11882352f, 0.08608215f, -0.09515408f, -0.17179586f, -0.12663521f, 
    -0.04334728f, 0.08987686f, 0.06012876f, 0.04415019f, 0.06962018f, -0.08055663f, -0.04731734f, -0.06814862f, 
    0.16971438f, 0.02243129f, 0.22445470f, 0.17730618f, -0.04866541f, -0.07586492f, 0.03459211f, 0.08837078f, 
    -0.03916693f, 0.18235146f, 0.12275389f, 0.08523732f, 0.01486340f, -0.20466301f, -0.06417371f, -0.23717368f, 
    -0.11480477f, 0.01552070f, 0.06724741f, -0.01713336f, 0.04720790f, -0.00916336f, 0.05353243f, 0.04465400f, 
    -0.18255156f, 0.18001683f, -0.23286259f, 0.04811206f, -0.00112686f, -0.02525611f, 0.05638941f, 0.15029122f, 
    0.10337362f, 0.05031063f, 0.13510056f, 0.06064709f, 0.20406725f, -0.02641111f, 0.15853705f, 0.18214974f, 
    -0.01808868f, -0.06028923f, 0.05937039f, -0.14927115f, -0.05658519f, 0.10804217f, -0.07202454f, 0.21816866f, 
    0.17994256f, -0.08118100f, -0.19674800f, 0.03168121f, 0.04035968f, 0.11245899f, 0.08301638f, 0.07554866f, 
    -0.06511882f, 0.01870516f, -0.03927207f, 0.03862710f, 0.02864716f, 0.06605028f, 0.12817033f, -0.02600647f, 
    -0.05658836f, -0.10157020f, 0.06113154f, 0.10240500f, 0.04400835f, 0.06426717f, 0.00600105f, 0.09906785f, 
    -0.18418138f, -0.16291901f, 0.18594569f, 0.36190248f, 0.11688324f, 0.02314117f, -0.00841381f, 0.05944827f, 
    0.10834224f, 0.07072657f, -0.11776041f, -0.05251868f, -0.00285801f, 0.00140250f, 0.03690048f, 0.03766339f, 
    -0.03191569f, 0.06129926f, 0.05013077f, 0.07064112f, 0.09242315f, -0.01183884f, 0.09101360f, 0.12986237f, 
    0.07663170f, -0.01870007f, 0.09479250f, 0.10953937f, -0.07421947f, 0.13460740f, 0.15362169f, 0.05340333f, 
    -0.00418595f, -0.03048187f, 0.06201532f, 0.20295842f, -0.05504503f, 0.07296412f, -0.05726977f, -0.08348174f, 
    -0.07288083f, 0.01883153f, 0.15553078f, 0.00937166f, -0.08238130f, 0.10415220f, 0.01471931f, -0.03788259f, 
    -0.26531872f, 0.15472358f, 0.12518355f, 0.05085725f, 0.05787539f, 0.14615938f, 0.01342683f, 0.07966407f, 
    0.04803937f, 0.06307057f, 0.03494156f, -0.01185315f, -0.07317727f, 0.11286070f, 0.11562333f, -0.17478852f, 
    0.06339243f, 0.06726073f, -0.01765209f, 0.05522170f, 0.04803804f, -0.00977597f, -0.02229879f, 0.21006736f, 
    -0.00710689f, 0.07371549f, -0.01302313f, -0.12865402f, 0.13564889f, 0.01689730f, 0.13142909f, -0.04343877f, 
    0.02821226f, 0.05936223f, 0.08112201f, 0.17288479f, -0.13602470f, 0.03900656f, 0.18580036f, 0.02389923f, 
    0.03313462f, -0.06693402f, -0.02526035f, -0.09836509f, 0.01293770f, -0.03129930f, 0.13086234f, 0.12605813f, 
    0.16651165f, 0.08921362f, 0.25340807f, -0.02834698f, -0.01503164f, 0.13882363f, -0.04829212f, 0.06406103f, 
    0.02811316f, 0.01291834f, -0.03639018f, 0.07288850f, -0.16081859f, -0.12979016f, 0.08187874f, 0.02428704f, 
    0.03337473f, 0.15175690f, 0.17798483f, 0.02157876f, -0.02819925f, -0.01591275f, 0.01339500f, 0.16919509f, 
    -0.15388542f, 0.27857906f, -0.12961657f, 0.01186712f, -0.06594132f, 0.03608536f, 0.07094895f, 0.13886338f, 
    0.02857057f, 0.00472285f, -0.08650518f, -0.01521543f, -0.04542328f, 0.09767989f, 0.20394829f, -0.32550389f, 
    -0.12111938f, -0.10120235f, -0.00571882f, 0.07979482f, 0.18683675f, 0.03970911f, -0.00664893f, -0.04454939f, 
    0.14102177f, -0.04826013f, -0.03125308f, 0.02503580f, -0.01072270f, -0.01100972f, -0.00460530f, 0.09829421f, 
    0.14736718f, -0.07933918f, 0.00566333f, 0.11062759f, -0.06645972f, 0.01766532f, -0.01746859f, -0.13416041f, 
    -0.01389717f, 0.06363730f, 0.03602429f, -0.10069709f, -0.04962573f, 0.14925177f, -0.02285089f, 0.15062279f, 
    -0.15965192f, 0.00546824f, -0.11551677f, 0.00131179f, -0.02956240f, 0.12406344f, 0.01478480f, -0.05269315f, 
    -0.07424157f, -0.04070865f, 0.10618132f, 0.27621251f, -0.22533643f, 0.01942220f, 0.15489615f, -0.10203111f, 
    0.05510346f, -0.12331291f, -0.10511180f, -0.05967488f, 0.00285288f, -0.01977036f, 0.10955621f, 0.08202658f, 
    0.10730262f, -0.05605654f, 0.07230110f, 0.05630484f, -0.01226894f, 0.02761794f, 0.01193694f, 0.07470664f, 
    0.04985284f, -0.03738675f, 0.09495524f, 0.05795087f, -0.42269295f, 0.01446727f, -0.05691265f, -0.03483462f, 
    -0.13019921f, -0.00888289f, 0.06684064f, -0.00310475f, -0.04857770f, -0.12669778f, 0.05820995f, -0.08827285f, 
    0.21048956f, -0.09153725f, 0.07768352f, -0.13422900f, 0.03871759f, 0.00123522f, 0.09844693f, -0.00962604f, 
    -0.04811684f, 0.02581432f, -0.15561257f, 0.03885408f, -0.20953500f, 0.04429297f, 0.04142905f, 0.14771143f, 
    0.09022330f, 0.10598281f, -0.06664859f, -0.14823972f, -0.04767800f, -0.07637953f, -0.12525879f, -0.05147541f, 
    0.30167672f, 0.10400215f, 0.07909749f, -0.14359812f, 0.11354696f, 0.05509071f, -0.22054970f, -0.07465103f, 
    0.09476259f, -0.02149821f, -0.17816241f, -0.08864319f, 0.14430454f, 0.10754333f, -0.02932394f, 0.02746168f, 
    -0.08210400f, 0.08270964f, 0.12959151f, 0.07064276f, 0.06075469f, 0.19427884f, -0.06247301f, 0.09138613f, 
    0.11021898f, 0.01402152f, -0.01965660f, -0.04316169f, 0.03925906f, -0.01571891f, 0.17157412f, -0.09157973f, 
    -0.14340588f, 0.14652966f, 0.06962067f, 0.03451328f, 0.05586917f, -0.00010568f, -0.01626228f, 0.11240198f, 
    -0.05164324f, 0.02574110f, 0.00135026f, 0.04903137f, -0.13733305f, -0.06852779f, 0.12998961f, 0.04526822f, 
    0.40915260f, 0.08445282f, 0.05936082f, -0.11558683f, 0.14727752f, 0.19663200f, 0.10555895f, -0.13489705f, 
    0.00844602f, -0.01896735f, -0.18241288f, -0.14253241f, -0.08369189f, -0.07158726f, 0.20909357f, 0.09223742f, 
    0.01393514f, 0.03576175f, 0.06621938f, 0.04249024f, 0.03457419f, 0.15436731f, 0.08866984f, 0.12689210f, 
    -0.29838619f, 0.10952928f, -0.07369531f, 0.10921580f, 0.11529884f, -0.11359764f, -0.08124465f, -0.06776626f, 
    -0.07540733f, -0.18304735f, 0.02432027f, -0.03915839f, 0.17591007f, 0.12995814f, -0.05094520f, -0.01732818f, 
    0.13418896f, 0.11874125f, 0.02985906f, 0.05131846f, 0.09894536f, 0.09051042f, -0.10293512f, -0.03922012f, 
    0.07736460f, 0.03281707f, 0.25413579f, -0.06923883f, 0.01031631f, -0.00095336f, 0.03631842f, 0.00953853f, 
    -0.07784777f, 0.01705679f, -0.06244392f, -0.02050314f, -0.05768552f, -0.00508647f, 0.07325671f, -0.01724890f, 
    0.09642890f, 0.12134054f, -0.10112592f, 0.15893382f, 0.02731278f, -0.15436138f, 0.06482303f, -0.08240394f, 
    -0.17151248f, 0.20535859f, 0.05311054f, 0.32885724f, 0.09937176f, -0.02308654f, -0.03960875f, 0.00157392f, 
    0.09747075f, 0.13486373f, 0.05406187f, 0.13648401f, -0.03541914f, 0.02234047f, -0.04635397f, 0.02776068f, 
    0.06418955f, 0.01670700f, -0.19148038f, -0.12283448f, -0.07583715f, -0.05063999f, -0.05836345f, -0.10732581f, 
    0.15591659f, 0.04170977f, -0.13045877f, -0.23568709f, 0.02565998f, -0.00872282f, 0.12956008f, 0.04369340f, 
    -0.17183505f, 0.02465144f, 0.10674173f, 0.13538773f, 0.10975256f, -0.13625936f, 0.17363805f, -0.13304132f, 
    0.00533103f, -0.07808633f, 0.03452449f, -0.19939432f, -0.07589612f, 0.09335418f, -0.18099336f, -0.07874817f, 
    0.15160717f, -0.15193877f, -0.03189471f, -0.07299961f, -0.02434792f, -0.09384674f, -0.05110111f, 0.09462585f, 
    -0.06352786f, 0.18668011f, 0.01700071f, -0.05949420f, 0.07173772f, 0.06072266f, -0.01340623f, 0.09345889f, 
    0.09938609f, 0.19718967f, -0.27713123f, 0.01085941f, 0.09040722f, -0.12381057f, 0.06999156f, 0.09106524f, 
    0.12283320f, -0.11460551f, -0.02643416f, 0.05860437f, -0.00903331f, -0.08766727f, -0.01211861f, -0.00849660f, 
    0.06843336f, -0.08430059f, -0.05985647f, -0.01955523f, 0.13889176f, 0.11388844f, 0.01650230f, 0.10693249f, 
    -0.01382798f, -0.08868297f, -0.04415234f, 0.05804662f, 0.02280582f, -0.01690489f, 0.09863421f, -0.05399718f, 
    0.01341590f, -0.19109540f, 0.05719816f, -0.00605579f, -0.01339136f, -0.10629276f, -0.08841676f, 0.01486399f, 
    0.14625128f, 0.04646190f, -0.08687714f, -0.09846142f, 0.06476068f, 0.01331588f, 0.07727855f, 0.23675027f, 
    -0.01366661f, 0.03816083f, 0.00289190f, 0.13505465f, 0.00532116f, 0.05082219f, -0.08796440f, -0.07525364f, 
    -0.01012593f, -0.04461411f, 0.02417425f, -0.08866215f, 0.15311350f, -0.21344583f, 0.14361681f, 0.07764713f, 
    0.03846490f, 0.07524320f, 0.06014128f, 0.11715546f, -0.14226541f, 0.24412847f, 0.00194452f, -0.15270078f, 
    0.06227463f, -0.03902142f, -0.19442056f, -0.04082963f, 0.12445872f, 0.10368212f, 0.09368803f, -0.11782736f, 
    -0.12655707f, -0.33150196f, 0.12274002f, -0.01893956f, 0.03044499f, -0.04621220f, -0.03907030f, -0.03250154f, 
    0.12079290f, 0.08134294f, 0.06436785f, 0.06517574f, 0.11441408f, 0.04392923f, -0.01000504f, 0.10578095f, 
    0.03517037f, 0.04595252f, -0.04059437f, -0.03858015f, -0.10218261f, 0.02792190f, -0.03406147f, 0.26552197f, 
    -0.00912009f, 0.00542283f, -0.02522958f, -0.02880024f, -0.01782257f, -0.04666844f, -0.02661795f, -0.04503437f, 
    0.00333999f, -0.03046643f, -0.04899494f, 0.05107476f, -0.02318704f, -0.03727632f, -0.02813854f, -0.01989106f, 
    0.04443285f, 0.02707256f, 0.02138723f, 0.03072901f, -0.02652058f, -0.02446203f, -0.00852577f, 0.01810891f, 
    -0.04251127f, -0.03267872f, 0.04101562f, -0.03190906f, -0.02139793f, -0.05181680f, 0.02769326f, -0.00746015f, 
    -0.01443016f, -0.00151059f, 0.05286644f, 0.02759253f, 0.02037086f, -0.02766186f, -0.01479289f, -0.01671379f, 
    -0.02184701f, 0.03568558f, 0.03418475f, -0.04031554f, -0.04505282f, -0.03973359f, 0.04303204f, -0.01460781f, 
    -0.02090166f, 0.01296274f, 0.00679281f, -0.02964035f, 0.02068084f, -0.04949725f, -0.01202951f, 0.01180369f, 
    0.02517203f, -0.03333538f, -0.04395987f, -0.05518276f, -0.03127474f, 0.01945646f, -0.02413355f, -0.04390404f, 
    0.03550183f, -0.04271742f, -0.03379793f, 0.01315918f, -0.00246206f, -0.04897616f, -0.02491185f, -0.00055696f, 
    -0.01807771f, 0.01428872f, 0.03234492f, 0.00920400f, -0.03853227f, -0.05650496f, -0.04057620f, -0.05372785f, 
    0.02831474f, 0.01962510f, 0.00047639f, -0.00736808f, -0.04386247f, -0.01377635f, -0.01029279f, 0.02471238f, 
    0.03480591f, 0.02443694f, -0.05012803f, 0.01230863f, -0.03673571f, 0.03489391f, 0.00647884f, 0.03269003f, 
    -0.03285449f, -0.00541868f, 0.00189073f, 0.02113414f, 0.03653537f, -0.04739928f, -0.04144206f, -0.03533527f, 
    0.01842007f, -0.00061051f, -0.04212637f, -0.00392266f, -0.04725847f, -0.03591525f, -0.02506820f, 0.05034232f, 
    -0.05746403f, 0.00562949f, 0.05085388f, 0.04208975f, -0.00467187f, 0.00678245f, 0.01651490f, 0.01483595f, 
    -0.01115432f, 0.03850354f, -0.02514711f, 0.04118397f, -0.03955603f, -0.02469409f, -0.03644830f, 0.02923969f, 
    0.03622915f, -0.00891796f, 0.00578394f, -0.00064369f, -0.03855700f, 0.01577198f, -0.00143264f, 0.04542402f, 
    -0.04444109f, 0.03552079f, -0.03846546f, -0.00221146f, -0.00579481f, -0.01953944f, -0.00182207f, 0.00753371f, 
    -0.01770619f, -0.00284368f, -0.04458122f, 0.02771883f, -0.02000203f, 0.00334675f, 0.03994608f, 0.03199305f, 
    -0.04158397f, 0.03902359f, -0.00568920f, 0.01124254f, -0.01151145f, 0.00349219f, 0.02722812f, 0.03937632f, 
    0.02607662f, -0.00039482f, -0.01018156f, 0.00252611f, 0.04058576f, -0.04054349f, -0.04643410f, 0.00355073f, 
    -0.00338146f, 0.02187041f, -0.02620949f, 0.03077840f, 0.03128435f, 0.01219030f, -0.04889614f, 0.02717276f, 
    0.00491623f, -0.03160436f, -0.05763303f, 0.00877328f, -0.01670554f, -0.05732265f, -0.03939134f, 0.01268060f, 
    0.03944468f, -0.04667568f, 0.00376612f, 0.01728746f, -0.00183169f, 0.04013108f, -0.00879363f, -0.01101163f, 
    -0.05739019f, 0.03961176f, 0.02540222f, 0.00436067f, -0.03583776f, -0.04592680f, -0.05290895f, 0.02668937f, 
    -0.03616640f, 0.00834224f, 0.00162411f, -0.04567730f, 0.03999868f, -0.04802957f, -0.02550464f, 0.03646601f, 
    0.00247661f, -0.03232265f, -0.00440468f, 0.04130316f, 0.03590802f, -0.01345394f, 0.00417993f, -0.02861501f, 
    -0.02246431f, -0.04122397f, -0.02290883f, 0.00112690f, -0.05337961f, -0.04006463f, -0.00031690f, -0.01998020f, 
    -0.03579289f, -0.01638781f, -0.05576088f, -0.04734718f, 0.00061211f, -0.01059733f, 0.00836302f, -0.02996291f, 
    -0.03690866f, -0.03390331f, 0.03736270f, -0.00709175f, 0.01288419f, -0.01942689f, 0.02840849f, 0.00947754f, 
    0.03522413f, 0.04185928f, 0.03469541f, -0.01574618f, 0.00691611f, 0.02513443f, -0.04128052f, 0.02602787f, 
    0.00382333f, 0.00994547f, -0.03143506f, -0.00506853f, -0.01597449f, -0.03756236f, -0.00083173f, 0.02193203f, 
    -0.04407886f, -0.03725465f, -0.03772292f, 0.03180088f, 0.01322887f, 0.01979154f, -0.02668871f, -0.02105174f, 
    0.03073062f, -0.02225267f, -0.01275686f, -0.02870468f, -0.01520506f, -0.02052131f, -0.01064312f, 0.01335387f, 
    0.00687482f, 0.02495785f, 0.00708892f, -0.02853021f, -0.03173443f, -0.05296929f, 0.00187116f, 0.05079243f, 
    0.03630029f, -0.04637272f, -0.05789490f, 0.04364762f, -0.00259152f, -0.03205604f, -0.04060056f, -0.04059201f, 
    -0.00046157f, -0.05405230f, 0.02580789f, -0.04416195f, 0.02072590f, -0.01929209f, 0.04583085f, 0.02598699f, 
    -0.02716321f, -0.00418243f, -0.04922372f, 0.04073783f, 0.03272623f, -0.02171417f, -0.02141242f, -0.05795486f, 
    0.02576988f, 0.02283082f, 0.04394698f, 0.02363606f, 0.02172941f, 0.03322210f, 0.01170877f, 0.02413979f, 
    -0.03833182f, 0.00358648f, -0.05368567f, -0.01547609f, -0.01744708f, 0.02388386f, -0.02493613f, -0.04166880f, 
    0.03336396f, -0.02490814f, 0.04221541f, 0.02956393f, -0.03844827f, 0.00999388f, -0.02625095f, -0.02677982f, 
    0.02897358f, -0.02295369f, 0.02824431f, 0.03484120f, 0.03471696f, -0.00658772f, -0.00683750f, 0.03319183f, 
    -0.00043199f, -0.03359863f, -0.05723559f, -0.04106876f, -0.02467745f, -0.03009535f, -0.04227134f, 0.03744626f, 
    0.02475686f, 0.03142312f, -0.01317105f, 0.01403890f, 0.04244004f, -0.01343527f, -0.04089718f, -0.02571329f, 
    -0.04139876f, 0.01182739f, 0.02105067f, -0.02047633f, 0.02704458f, -0.03139862f, 0.00554766f, 0.00652853f, 
    0.02880191f, 0.02720523f, -0.03648316f, -0.01204818f, -0.02088964f, 0.00968948f, -0.03503707f, -0.03019132f, 
    0.00303938f, -0.03528346f, -0.04113682f, -0.03054884f, -0.01972756f, -0.01129211f, -0.01892586f, 0.00355126f, 
    0.00526194f, -0.03091203f, -0.04164971f, 0.00420470f, 0.04241686f, -0.01546608f, -0.00753407f, -0.04388122f, 
    -0.28724387f, -0.02478819f, 0.10367178f, 0.11537352f, 0.04132996f, -0.00495265f, -0.03181054f, 0.09390636f, 
    0.05711272f, -0.04943085f, 0.04361089f, 0.03939786f, 0.44478771f, -0.13799678f, -0.22206481f, -0.09903097f, 
    0.04345556f, 0.06121945f, 0.10933127f, -0.06586017f, 0.02677727f, 0.01869550f, 0.01708748f, 0.04080572f, 
    -0.08101168f, -0.01097083f, 0.06019663f, -0.14870358f, -0.00369421f, 0.01496907f, 0.02771659f, -0.06978872f, 
    -0.04869501f, -0.02524993f, 0.04614607f, -0.01985869f, -0.04334254f, -0.06304456f, -0.15130842f, -0.07932615f, 
    0.04499257f, -0.08324482f, 0.03311196f, 0.05836498f, -0.02943053f, -0.05387897f, 0.05496456f, 0.00330584f, 
    -0.06512494f, 0.29069108f, -0.02833181f, 0.08461203f, 0.04060484f, 0.04090730f, -0.01720094f, -0.06956329f, 
    0.00726915f, 0.01670474f, -0.02682632f, 0.06696262f, -0.10987151f, 0.15073480f, 0.13356218f, -0.00076947f, 
    0.12176041f, -0.06634796f, -0.05352261f, 0.00435033f, -0.04147004f, -0.02988536f, -0.03361690f, -0.12508973f, 
    0.16487157f, 0.04560724f, 0.02586116f, 0.05167894f, -0.04032578f, 0.00996143f, 0.00001226f, -0.05680992f, 
    -0.02368507f, -0.09081526f, -0.09968487f, -0.06999779f, 0.04499772f, 0.16654225f, 0.05747502f, -0.02555256f, 
    0.21904407f, 0.06149260f, 0.04110217f, -0.02477836f, -0.01360547f, -0.03338650f, -0.08143287f, -0.01472776f, 
    0.03428593f, 0.13651787f, 0.16473742f, 0.17267375f, 0.03291309f, -0.06304610f, -0.01060271f, 0.13638589f, 
    -0.00241050f, 0.01797541f, -0.01895647f, 0.00908803f, -0.01258525f, -0.16155227f, 0.03636350f, 0.06637619f, 
    0.06611128f, -0.07111361f, 0.13445745f, -0.05768075f, -0.01960849f, -0.01178956f, 0.00291116f, 0.03735869f, 
    0.06683769f, 0.10066795f, 0.07097855f, 0.17232148f, 0.17420994f, -0.04839903f, -0.04101769f, 0.13417506f, 
    0.10719313f, 0.07252099f, -0.03552305f, 0.00807371f, -0.24961303f, -0.13326578f, 0.06903639f, -0.04945580f, 
    0.07352525f, 0.04822149f, -0.05428294f, 0.03589817f, 0.02762136f, 0.02824000f, 0.06048753f, -0.06708408f, 
    0.04750954f, -0.19231343f, 0.05803893f, 0.38594538f, 0.03302937f, 0.16507170f, 0.02610004f, 0.14677104f, 
    0.04057296f, -0.04366923f, -0.07862340f, -0.06157194f, -0.03749495f, 0.16323836f, -0.06885567f, -0.21629059f, 
    -0.04176970f, -0.07275833f, -0.10208698f, -0.00145236f, -0.09375950f, -0.03219191f, 0.02368973f, -0.17246446f, 
    0.06445332f, -0.12939744f, 0.07240684f, -0.13515209f, 0.08014336f, 0.15590781f, 0.01780905f, 0.08042014f, 
    -0.07616860f, 0.04916995f, 0.01685297f, -0.01050591f, -0.04326173f, 0.01668745f, 0.18742436f, 0.31597102f, 
    0.16138138f, -0.07737987f, -0.04649487f, 0.03474223f, 0.10500036f, 0.02481288f, -0.03834709f, 0.06001184f, 
    -0.14175037f, 0.12069351f, -0.01471660f, -0.15815702f, -0.01335766f, -0.03987728f, -0.04084304f, 0.07299260f, 
    0.03831008f, -0.13496169f, -0.02816919f, -0.04366221f, -0.02112992f, -0.28427121f, -0.09278596f, 0.16899620f, 
    -0.03940367f, -0.01426812f, 0.04182834f, 0.07132942f, -0.11907441f, 0.07242504f, 0.04128665f, 0.12750258f, 
    0.03561451f, 0.20358035f, 0.16458231f, 0.15707397f, 0.18795994f, -0.03941522f, 0.01768988f, 0.07182111f, 
    0.03836682f, 0.03864687f, -0.01557877f, 0.05432395f, -0.03587792f, 0.17869855f, 0.11411055f, 0.04808569f, 
    0.04835179f, 0.06752346f, 0.00437742f, 0.02380791f, 0.02100784f, 0.03612773f, -0.01290338f, -0.00466074f, 
    0.06303210f, -0.07954834f, 0.14842209f, -0.02846104f, 0.01981210f, -0.01220802f, 0.07287035f, -0.09185094f, 
    -0.01197063f, -0.11752916f, -0.01066466f, -0.10907835f, -0.12595825f, 0.34691024f, -0.03767276f, 0.14718376f, 
    0.12503114f, 0.06048474f, 0.06401826f, 0.10004440f, 0.13979112f, 0.02869656f, 0.00053302f, -0.03840274f, 
    -0.19990098f, -0.04215493f, 0.01472636f, -0.19321021f, 0.00934101f, 0.02045284f, 0.12638098f, -0.08948486f, 
    -0.02735173f, -0.01551500f, 0.00544674f, -0.07029845f, 0.13893463f, -0.11439431f, 0.17633574f, 0.13830385f, 
    0.05944332f, 0.12770136f, -0.04250781f, 0.03369856f, 0.03319028f, -0.03788678f, 0.12239317f, 0.06467149f, 
    -0.36414140f, 0.12950769f, 0.20961514f, -0.08092804f, -0.04178026f, -0.06742318f, 0.06080316f, -0.03221860f, 
    0.02980974f, 0.01664629f, 0.00898093f, -0.08862185f, 0.30756822f, -0.15857953f, 0.14829248f, 0.00733278f, 
    -0.05797688f, -0.04448845f, 0.00742489f, -0.01784757f, 0.00515261f, 0.11104985f, -0.06090402f, 0.09264361f, 
    -0.06388050f, 0.35857379f, -0.01888011f, -0.17757772f, 0.01258175f, 0.00045878f, 0.00382731f, -0.03394794f, 
    0.04829242f, -0.02363369f, 0.00327751f, 0.06258724f, -0.20431280f, 0.12621902f, -0.03372515f, -0.11523254f, 
    -0.11616333f, 0.03411074f, 0.10986297f, -0.05339695f, -0.04520416f, -0.02315572f, 0.06281789f, 0.03987554f, 
    -0.14522019f, -0.09048727f, 0.16793334f, 0.03714617f, -0.09406878f, 0.13749960f, 0.11453126f, -0.13062763f, 
    -0.04379433f, 0.06637219f, 0.02699065f, 0.05758008f, 0.43429342f, 0.05221146f, 0.03756575f, 0.03429393f, 
    0.03041312f, 0.05942303f, 0.05413825f, -0.09261848f, 0.00169487f, -0.01386135f, 0.07007688f, 0.02395943f, 
    -0.15759511f, 0.33309680f, -0.00385863f, -0.27371368f, 0.13636293f, 0.00890712f, 0.07116083f, -0.08477542f, 
    -0.07489489f, -0.03386899f, 0.00871574f, 0.07246221f, -0.32317144f, 0.03282636f, 0.15478174f, 0.01015639f, 
    -0.01379160f, 0.02657416f, 0.05609834f, -0.15312269f, -0.09276028f, -0.01285811f, 0.05760700f, 0.03349055f, 
    0.03427626f, 0.03585887f, -0.00136797f, -0.03086093f, 0.02968563f, -0.04354253f, 0.03513799f, 0.02533468f, 
    0.02367767f, -0.05233737f, -0.00436521f, 0.03371922f, 0.01995447f, -0.03348457f, 0.04610534f, -0.00881288f, 
    0.00089698f, -0.04250326f, 0.00065311f, -0.02533229f, -0.03669793f, 0.04179686f, 0.02041472f, -0.03630031f, 
    0.03866862f, 0.02080845f, -0.04296746f, -0.03046673f, 0.03846630f, -0.03268524f, -0.01560492f, -0.00314455f, 
    -0.00200132f, -0.05013760f, 0.01963204f, -0.04765385f, -0.04805690f, -0.00499202f, -0.00323178f, -0.01472579f, 
    -0.01507598f, 0.01183796f, 0.00808017f, -0.00317816f, -0.00320136f, -0.02936589f, 0.00332621f, 0.00381552f, 
    0.03879578f, -0.03764595f, -0.04779735f, -0.03648115f, 0.00313720f, -0.02054577f, -0.03198744f, -0.03029652f, 
    0.02159902f, 0.04223476f, 0.01492819f, -0.01938965f, 0.01105205f, 0.01310363f, 0.00229753f, -0.01431488f, 
    -0.01017332f, -0.04221737f, 0.03307981f, 0.00687120f, 0.03822829f, -0.02135337f, 0.02683481f, -0.03730872f, 
    -0.04979095f, -0.05724987f, -0.02533066f, -0.01496066f, 0.00626060f, 0.01661440f, 0.01327672f, -0.04235505f, 
    -0.01954556f, 0.01094135f, 0.04570853f, 0.03901244f, -0.02720033f, 0.02253409f, -0.01289150f, -0.02665711f, 
    -0.02454245f, -0.01321431f, 0.03811797f, -0.00889188f, -0.05372206f, -0.04698929f, 0.00506294f, 0.00150111f, 
    -0.04054297f, -0.00442084f, 0.02519350f, -0.04694858f, -0.01775203f, -0.00083028f, -0.03284106f, -0.05254718f, 
    -0.00925792f, 0.01935487f, 0.02814319f, -0.02795110f, 0.04453658f, -0.05111618f, 0.01588449f, -0.02500699f, 
    -0.00826895f, 0.02659477f, -0.02533104f, -0.02869991f, 0.03444289f, -0.04292496f, -0.03101742f, -0.01685782f, 
    -0.03105026f, -0.04477224f, -0.02282545f, -0.00515044f, -0.06105355f, 0.03303370f, 0.01444812f, -0.01808000f, 
    -0.05142281f, 0.01061411f, 0.04729322f, 0.00990316f, 0.02199326f, 0.04286537f, 0.03399360f, -0.04426461f, 
    -0.03078457f, -0.04931464f, 0.00017215f, -0.00097454f, 0.00801672f, -0.04949122f, 0.00925148f, 0.00105679f, 
    -0.03876387f, 0.00736142f, 0.03778775f, -0.04961225f, -0.00615399f, 0.03242287f, -0.01073238f, -0.04669455f, 
    -0.00097386f, -0.02347472f, 0.01263812f, 0.00603230f, 0.00376379f, -0.03083016f, -0.02412896f, -0.00308312f, 
    0.02093715f, 0.00418468f, -0.03966704f, 0.00375527f, 0.04698221f, 0.01522779f, 0.03544865f, -0.03989315f, 
    -0.00993271f, 0.04062406f, -0.00779775f, -0.00746231f, -0.03424031f, -0.00676893f, -0.00415789f, 0.00794215f, 
    -0.01809383f, 0.00332844f, -0.04396978f, 0.01544772f, -0.05725611f, -0.03214830f, 0.03858064f, -0.02599057f, 
    -0.01011933f, -0.05695389f, 0.03734903f, 0.02550936f, 0.03370066f, 0.00096317f, 0.00528312f, -0.00666836f, 
    0.02651171f, 0.00592613f, -0.00090100f, -0.01665924f, 0.00493982f, 0.03871034f, -0.04702305f, 0.04278330f, 
    0.02358579f, -0.00419463f, -0.05126206f, 0.04049176f, -0.02388982f, 0.01679023f, -0.02282785f, -0.05469140f, 
    0.01596094f, -0.01164131f, 0.01436503f, -0.03384615f, 0.00112267f, -0.01911327f, -0.03639108f, -0.00001711f, 
    0.02385951f, -0.01642459f, -0.01410661f, 0.03260203f, 0.02458872f, 0.02267452f, -0.00886954f, -0.02885322f, 
    -0.03438736f, -0.01469601f, -0.03322280f, -0.00487522f, 0.03202660f, 0.00899047f, 0.00240513f, 0.05411584f, 
    -0.01283128f, -0.02826958f, 0.02708108f, -0.05601025f, -0.03005853f, -0.02080655f, -0.00511914f, -0.04662574f, 
    -0.00220104f, 0.00546729f, -0.05257780f, -0.00721836f, 0.00243141f, -0.02418414f, 0.00768571f, -0.03542634f, 
    0.03394370f, -0.04500000f, 0.04119922f, -0.02144459f, -0.01580977f, -0.02191246f, 0.02787487f, -0.05484443f, 
    0.00780769f, 0.02991154f, -0.03114373f, 0.01412362f, 0.01711171f, 0.02152401f, 0.01909138f, 0.03785265f, 
    0.02783019f, -0.00188827f, 0.01030800f, -0.04312716f, -0.04039617f, 0.00467490f, -0.05532930f, -0.01947957f, 
    -0.03605069f, -0.00767430f, -0.01272896f, -0.01711173f, -0.05024508f, 0.02005449f, -0.02438553f, 0.01047217f, 
    0.00034892f, -0.02682919f, -0.04513054f, 0.02732008f, -0.00402229f, 0.03165455f, -0.05154318f, -0.02465035f, 
    -0.01240756f, 0.03119048f, -0.01417202f, -0.00612183f, 0.00081928f, 0.02204615f, 0.03966932f, 0.04114807f, 
    -0.02575527f, -0.04843764f, 0.03662999f, -0.02287257f, 0.00804392f, -0.00504560f, 0.01891753f, -0.02047533f, 
    -0.00922029f, -0.00411688f, -0.02791364f, -0.03245506f, 0.02263594f, -0.00161036f, 0.02853975f, -0.04060517f, 
    -0.01013635f, 0.04578664f, -0.04865856f, -0.03892112f, -0.00938477f, 0.00616564f, -0.01507434f, -0.00429549f, 
    -0.04790368f, -0.03487337f, 0.01315182f, 0.02190093f, -0.02974811f, -0.03313355f, 0.03260370f, -0.03439024f, 
    -0.00523373f, -0.02951824f, -0.00288774f, -0.00872151f, 0.00829564f, 0.04093894f, 0.01246862f, -0.01302432f, 
    0.02134009f, -0.04360759f, 0.00779521f, -0.02640403f, 0.01590729f, 0.00676863f, 0.02500543f, 0.04428029f, 
    -0.01257342f, 0.03272562f, 0.00477500f, 0.01693180f, -0.02403863f, -0.01334534f, 0.00253572f, 0.01664204f, 
    0.03995998f, 0.02169445f, -0.01390201f, -0.04128528f, 0.03684547f, -0.00075611f, -0.04059651f, -0.05502536f, 
    -0.00770706f, 0.01044700f, 0.00929939f, -0.04755817f, -0.03324056f, -0.00669123f, 0.01602395f, 0.02705895f, 
    -0.04556311f, 0.02399211f, -0.04280290f, 0.02438955f, -0.03347880f, -0.01372684f, 0.03877919f, 0.01599122f, 
    0.02282090f, -0.00229730f, -0.03240606f, -0.02138714f, 0.04024067f, 0.04806163f, -0.04007286f, 0.00534219f, 
    0.19680491f, -0.08172121f, -0.09953372f, -0.01120016f, -0.05880029f, -0.00912851f, 0.06599467f, 0.04733710f, 
    0.01491678f, 0.02405161f, 0.08361921f, 0.08989758f, -0.05225206f, -0.08934955f, 0.22466500f, 0.03535578f, 
    -0.05991472f, -0.06181224f, 0.02492628f, -0.08881423f, -0.02458343f, 0.00124545f, -0.02660532f, 0.01582945f, 
    -0.24915789f, 0.04083288f, 0.16071427f, 0.11364163f, -0.06743745f, 0.00952550f, 0.05780821f, -0.00903037f, 
    -0.06417446f, 0.05852709f, 0.05864306f, 0.13169275f, -0.09296804f, 0.32774690f, -0.06837944f, -0.13759482f, 
    -0.04536715f, 0.00143173f, -0.07708219f, -0.08806147f, 0.14454877f, -0.01606418f, -0.02613245f, 0.11372716f, 
    -0.36478209f, 0.07807279f, 0.06069435f, 0.10596940f, -0.14798027f, 0.02397292f, 0.02009167f, -0.03245814f, 
    -0.05032175f, 0.04728634f, 0.12778275f, -0.02803517f, 0.02466635f, 0.08437406f, -0.18577501f, 0.01883596f, 
    0.02134039f, -0.10395215f, 0.02526430f, 0.08746901f, -0.06884057f, -0.09151629f, -0.04558939f, 0.04818365f, 
    0.34585544f, 0.12183132f, -0.06935129f, -0.01309259f, 0.06172693f, -0.01921940f, 0.04126134f, 0.05749411f, 
    0.02354700f, 0.02179846f, -0.04108296f, 0.05707048f, 0.06001016f, 0.01651252f, 0.17596281f, 0.16658616f, 
    0.04790363f, -0.09005425f, -0.05626431f, -0.02500549f, -0.12251207f, -0.00807738f, 0.05348311f, 0.02718715f, 
    -0.24136807f, -0.00896881f, -0.10148159f, -0.10101090f, -0.03252459f, 0.04568861f, -0.05596564f, 0.05875700f, 
    0.11742126f, 0.03748504f, -0.04783579f, -0.02179962f, 0.23581970f, 0.13202734f, -0.09390111f, -0.08580984f, 
    0.03828785f, 0.11610013f, -0.04543112f, 0.00658352f, -0.01227435f, 0.00212764f, -0.00428599f, 0.02025500f, 
    0.14279337f, -0.05986817f, 0.13245639f, -0.21388343f, -0.11291677f, 0.10778763f, 0.07263926f, -0.07445528f, 
    -0.12280447f, -0.03471765f, 0.19336359f, 0.11646804f, 0.03411771f, -0.01829353f, -0.12787397f, 0.03017862f, 
    0.06603473f, 0.02798065f, 0.00363571f, -0.01537610f, 0.08130539f, -0.06117772f, 0.09017833f, 0.06126741f, 
    0.18560664f, -0.02261838f, 0.13015057f, -0.13929915f, -0.05022468f, 0.02082717f, -0.00294890f, -0.12830952f, 
    -0.00274658f, -0.10419744f, 0.02177975f, -0.00356316f, 0.25390482f, 0.06462543f, -0.05711978f, -0.07488144f, 
    -0.01584725f, -0.02031522f, -0.02672972f, -0.02978225f, 0.16836792f, 0.01004740f, 0.03115471f, 0.04227481f, 
    -0.20354941f, 0.11192873f, -0.28912941f, 0.25664160f, 0.11565901f, 0.02804822f, -0.01114130f, -0.07616934f, 
    0.02145421f, 0.00049056f, 0.02915904f, 0.05551872f, -0.05623442f, -0.04230155f, -0.11162514f, -0.09349062f, 
    -0.06614573f, 0.02774852f, 0.00446751f, 0.04232632f, 0.10059850f, 0.04435584f, -0.03665406f, 0.12988980f, 
    0.48061743f, -0.26376817f, 0.03021781f, 0.01897588f, -0.05324028f, 0.09788087f, 0.13031061f, -0.06236103f, 
    0.03738819f, -0.11358567f, 0.03993750f, -0.01374302f, -0.02350537f, -0.02615790f, -0.04480166f, -0.14568491f, 
    -0.06513920f, 0.09595061f, -0.05245547f, 0.08266691f, 0.13587707f, -0.01096922f, -0.01411066f, -0.04249414f, 
    -0.00385544f, 0.34080297f, 0.05067815f, -0.11920714f, -0.01073576f, 0.11119255f, 0.04219965f, 0.09240431f, 
    0.11323521f, 0.04384988f, 0.01464546f, 0.01637664f, 0.13327120f, -0.05778734f, 0.04555639f, 0.14085820f, 
    0.03948585f, -0.02663445f, -0.06698674f, -0.07572020f, 0.03671508f, 0.01865251f, 0.14812861f, -0.02937553f, 
    -0.04973193f, -0.03467340f, -0.30039182f, 0.02220090f, 0.05719982f, 0.02510276f, -0.00283897f, 0.03156618f, 
    0.00579384f, -0.01578039f, 0.01137646f, 0.13070324f, -0.00406634f, -0.24439776f, -0.06941195f, -0.01499185f, 
    -0.14114912f, 0.06904444f, 0.01436745f, -0.06747065f, 0.09772977f, 0.03728846f, -0.01360002f, -0.09798139f, 
    0.29679853f, -0.06228551f, 0.11611122f, 0.08297038f, -0.10643228f, 0.08586027f, -0.00351297f, 0.04103177f, 
    0.01340131f, -0.00279612f, -0.00937614f, -0.04710291f, 0.12686284f, 0.14342974f, 0.01190744f, -0.06430886f, 
    0.04780650f, 0.01710288f, -0.15436269f, 0.05927494f, -0.05818614f, -0.08575410f, 0.10917855f, 0.14981024f, 
    0.29050529f, -0.16687910f, -0.14444825f, 0.25587097f, 0.09034941f, -0.00791090f, -0.07076876f, -0.00936260f, 
    0.03006038f, 0.05963533f, -0.10402806f, 0.21187492f, -0.04911125f, 0.22200420f, 0.21080425f, 0.09115540f, 
    0.08904211f, 0.07870513f, -0.02690077f, 0.05243019f, -0.03434071f, 0.01807706f, -0.00795179f, 0.05012306f, 
    0.46575040f, -0.29215792f, 0.21824569f, 0.08165728f, -0.08622790f, -0.01166114f, -0.00445121f, -0.01723779f, 
    0.07039540f, 0.05417809f, 0.00279877f, 0.04287512f, -0.04585927f, -0.11515984f, -0.00133661f, -0.03726270f, 
    0.11084618f, 0.00762391f, 0.01293975f, -0.03056127f, 0.08540596f, 0.06513841f, 0.11708724f, -0.01784873f, 
    -0.06489884f, -0.05359389f, -0.11356271f, 0.00569648f, -0.04857871f, -0.12205259f, 0.04715141f, 0.02350577f, 
    -0.05976974f, -0.08374359f, 0.11843870f, -0.00242306f, -0.09275632f, 0.05765411f, -0.03958861f, 0.06526410f, 
    -0.02034687f, -0.00418824f, -0.17747414f, 0.12147595f, -0.00908950f, 0.07618337f, -0.02719184f, -0.11184559f, 
    0.20241968f, -0.31173506f, 0.07128204f, 0.23176335f, -0.07452655f, -0.05685071f, -0.06745635f, -0.03266215f, 
    0.12976865f, -0.04311674f, 0.07304619f, 0.02761242f, -0.12755410f, -0.03355896f, 0.10173992f, 0.19671662f, 
    0.12875350f, 0.04081275f, -0.05715308f, -0.01016212f, 0.00299971f, 0.03892810f, -0.00794037f, 0.03667746f, 
    -0.03527809f, -0.05599220f, 0.01663587f, 0.02623477f, 0.02740874f, 0.01164584f, 0.02760947f, 0.00524154f, 
    -0.04124847f, 0.01414117f, 0.01568705f, -0.00675252f, -0.05336717f, 0.00643562f, 0.01894731f, 0.01005129f, 
    -0.01335028f, 0.03983263f, 0.03765525f, -0.00823433f, 0.02889065f, 0.04209393f, 0.03456841f, -0.00335931f, 
    0.03829326f, -0.00041400f, 0.02941444f, -0.01024104f, -0.04488353f, 0.03929776f, 0.03709412f, -0.04828246f, 
    -0.02299262f, 0.03982458f, -0.05390801f, 0.00779105f, 0.01916280f, -0.03382822f, -0.04937696f, 0.00828852f, 
    -0.01187589f, 0.02842943f, 0.00662307f, 0.00817655f, -0.02806379f, -0.05350288f, -0.05615598f, 0.00269326f, 
    -0.04162237f, 0.03530739f, -0.01615944f, 0.03602492f, 0.01722135f, 0.00909275f, -0.05308726f, 0.00836832f, 
    -0.02042115f, -0.00110106f, 0.04420367f, 0.00956630f, -0.04592172f, -0.03390739f, -0.04828856f, -0.01315045f, 
    0.00329492f, -0.03675953f, -0.04523856f, -0.02109178f, -0.01907001f, -0.02827637f, 0.02548160f, -0.01207620f, 
    -0.00735135f, -0.00707511f, 0.03061350f, -0.00406437f, 0.02078832f, -0.05434873f, 0.03451155f, -0.05432256f, 
    0.04082035f, -0.01479978f, -0.02395691f, 0.04065113f, -0.02112880f, -0.03463549f, 0.01610185f, -0.02387971f, 
    -0.03998542f, -0.01199727f, -0.01758063f, 0.03065436f, -0.04372938f, -0.01319894f, -0.00090133f, -0.00046192f, 
    -0.03854419f, -0.01756919f, -0.04202932f, 0.00620882f, -0.04065457f, -0.03867930f, -0.04984313f, 0.03760986f, 
    0.03502360f, -0.01634598f, 0.01109884f, -0.00335730f, 0.02720739f, 0.00914492f, -0.01020489f, -0.02761078f, 
    -0.02793446f, 0.02909917f, -0.04491585f, 0.00335330f, -0.05550146f, 0.00492282f, -0.01526599f, -0.05154759f, 
    -0.02176113f, -0.04216389f, -0.01247764f, -0.02357268f, -0.02008166f, -0.02906238f, 0.02325365f, -0.02111527f, 
    -0.03007631f, 0.00356027f, -0.00992040f, 0.01612599f, -0.03705709f, -0.01264612f, 0.00587037f, -0.04489496f, 
    -0.03151482f, -0.02494439f, 0.02678171f, -0.04681911f, -0.04039483f, 0.03268938f, 0.01988675f, -0.02043298f, 
    -0.00133531f, -0.00898441f, 0.02004599f, 0.02983437f, -0.04840631f, -0.02720887f, -0.04389757f, 0.00530707f, 
    -0.04130755f, 0.04294942f, 0.02339585f, -0.04090945f, 0.04352074f, 0.00175310f, 0.00102412f, -0.00210499f, 
    0.00298203f, 0.01066089f, -0.01719764f, -0.04568913f, -0.02071521f, 0.00653589f, -0.04838588f, -0.02090042f, 
    -0.04514729f, -0.03062482f, 0.02075294f, 0.00537058f, -0.00137195f, -0.04116733f, 0.03169098f, -0.02577393f, 
    0.04528020f, -0.03214209f, 0.04196706f, -0.03057981f, 0.03604241f, -0.00126869f, -0.05405258f, -0.05446179f, 
    0.04139868f, 0.00667727f, 0.02846862f, -0.05235785f, -0.00156837f, 0.04000130f, 0.00814360f, 0.02956507f, 
    -0.00095027f, -0.04164840f, -0.01124946f, 0.00637969f, 0.03679082f, -0.03219077f, -0.02366018f, 0.01833655f, 
    -0.04925675f, -0.01675985f, -0.00913976f, -0.03778048f, 0.02403155f, 0.01269617f, -0.04920484f, 0.02756931f, 
    0.00845339f, 0.02673314f, 0.01629216f, -0.05508192f, -0.02305920f, 0.01028704f, -0.02943474f, -0.01171848f, 
    0.01818096f, 0.02050779f, 0.04159634f, -0.05199706f, 0.01997770f, -0.04994901f, 0.00075817f, -0.01736297f, 
    0.03547427f, -0.05523054f, -0.00950375f, 0.00355010f, 0.01123148f, 0.02778981f, -0.03016925f, 0.02875689f, 
    0.02492421f, -0.00764996f, -0.00047776f, -0.01959093f, 0.01140205f, -0.04755287f, -0.00288241f, -0.00912545f, 
    -0.00517593f, -0.03262139f, 0.03963255f, -0.04940873f, -0.05028493f, -0.02787227f, -0.01835277f, -0.03721178f, 
    0.03066608f, 0.00335695f, 0.01023109f, -0.02727144f, 0.01049444f, -0.03895665f, 0.01799298f, 0.00175945f, 
    -0.05609034f, -0.00289957f, -0.02847157f, -0.04519327f, -0.01019704f, -0.04971914f, 0.02394466f, -0.02340580f, 
    0.02231288f, 0.03815983f, 0.02942493f, -0.05256065f, 0.03225102f, -0.02472483f, -0.03393054f, -0.01457785f, 
    0.02932890f, -0.02947292f, -0.01631832f, -0.02750301f, -0.00204576f, -0.00319949f, -0.03298132f, 0.02700612f, 
    -0.05142390f, -0.00712265f, -0.02403216f, 0.01603778f, -0.01090407f, -0.04307113f, 0.00299404f, -0.02059305f, 
    0.02972671f, -0.01759098f, -0.01975258f, -0.04752511f, 0.00633214f, -0.01413604f, -0.00634266f, -0.04290808f, 
    -0.03029173f, -0.00298297f, -0.00902105f, 0.04394765f, -0.05479260f, -0.00579055f, -0.03999428f, 0.02983853f, 
    0.03572331f, -0.03368115f, 0.00799003f, -0.01355193f, 0.00297055f, -0.03366650f, 0.03839976f, -0.01957180f, 
    0.01640666f, -0.02056637f, 0.04190002f, 0.02120082f, 0.02275905f, 0.02962252f, -0.02885646f, -0.05558943f, 
    0.02171442f, -0.02401793f, -0.03434749f, -0.02755398f, 0.00057843f, -0.05334629f, 0.03143212f, 0.01074438f, 
    0.04515982f, 0.02891471f, 0.03862506f, -0.02002253f, -0.00841676f, -0.05418978f, 0.03691838f, 0.03858219f, 
    -0.04253943f, -0.02926400f, 0.03595101f, 0.02900973f, -0.02569524f, -0.02972304f, -0.05398693f, -0.01973154f, 
    -0.03088910f, -0.01417201f, -0.05598695f, -0.03240970f, -0.01497326f, -0.04520044f, 0.02831520f, -0.05465191f, 
    0.02615050f, 0.04495667f, 0.01815057f, 0.01974436f, -0.01027580f, -0.02447865f, 0.01967507f, -0.01676326f, 
    0.00527157f, -0.00130196f, 0.03291577f, 0.00057809f, 0.01416238f, -0.03005829f, -0.03363319f, 0.01372055f, 
    -0.02968911f, -0.02154044f, -0.01063699f, 0.04262272f, -0.00309885f, -0.00065982f, -0.01031705f, 0.00957864f, 
    -0.03898999f, -0.05108883f, -0.05176358f, -0.05024718f, -0.03335046f, -0.00651944f, 0.03429729f, 0.01159599f, 
    0.02295466f, -0.02218197f, -0.01244747f, -0.18209249f, -0.04326215f, 0.01218965f, 0.01680397f, 0.05090755f, 
    0.06841507f, -0.08164056f, 0.00976007f, 0.07229315f, 0.06546149f, -0.07279018f, -0.11705948f, 0.09891277f, 
    -0.05059393f, 0.01724960f, 0.05098477f, 0.04091647f, 0.11123192f, -0.03179191f, 0.07997572f, -0.08382827f, 
    0.04931091f, 0.06433904f, 0.06424124f, 0.09614526f, -0.06124877f, -0.13840069f, -0.03910873f, 0.06543258f, 
    0.05859961f, 0.15041073f, 0.13615398f, 0.00480890f, 0.04526893f, -0.06459031f, 0.21435370f, -0.11333440f, 
    0.04571218f, -0.00581721f, 0.14291804f, -0.09513314f, 0.07099333f, 0.12107966f, 0.02030541f, 0.14585258f, 
    -0.12303834f, -0.04779016f, 0.15519416f, -0.00373772f, 0.03548917f, 0.07079669f, -0.00668046f, -0.08773839f, 
    -0.01497238f, 0.15759186f, 0.04046383f, -0.02401056f, 0.15532023f, 0.03271998f, -0.16407833f, -0.17807777f, 
    -0.10769454f, 0.01905675f, 0.02415045f, -0.00477864f, -0.07234666f, 0.00173922f, 0.05090822f, -0.09287557f, 
    0.15157031f, -0.14264379f, 0.01910049f, -0.03400647f, 0.02829100f, 0.06701510f, 0.02958052f, -0.02840308f, 
    0.01372888f, -0.06599137f, 0.03014378f, -0.05079908f, -0.10549760f, -0.10685763f, 0.03658385f, -0.02142110f, 
    0.03923842f, -0.07658427f, 0.03676864f, 0.01470204f, 0.02249692f, 0.04068556f, -0.01053920f, 0.01569329f, 
    0.08019961f, -0.05597278f, -0.06081128f, -0.08162160f, 0.00552238f, -0.12183854f, 0.11312687f, 0.03092949f, 
    -0.03023527f, -0.03961278f, -0.05628800f, -0.03248854f, 0.11828054f, -0.04817043f, -0.00900885f, -0.18375626f, 
    0.00531715f, 0.04694153f, -0.03212604f, 0.07973501f, 0.08707801f, -0.00179373f, 0.01479299f, -0.04768602f, 
    0.11220711f, -0.07628736f, -0.12012424f, -0.29462779f, -0.13229395f, 0.08140919f, 0.08964460f, -0.00606071f, 
    -0.05469531f, 0.13494764f, -0.03375486f, 0.08819531f, -0.18453680f, 0.23078874f, 0.19850636f, -0.08222545f, 
    -0.02625229f, 0.12557538f, 0.01624260f, 0.01711071f, -0.06854385f, 0.00624371f, -0.03317238f, 0.03456131f, 
    -0.02378379f, 0.02335976f, -0.06483987f, -0.04416836f, 0.03902366f, 0.01022650f, -0.01130847f, -0.00669639f, 
    0.04968823f, -0.00597080f, -0.05194639f, 0.09022250f, -0.13035537f, -0.07451171f, 0.11273577f, -0.23289558f, 
    0.04551921f, -0.02251583f, 0.11055310f, 0.04522590f, 0.09370598f, 0.02719040f, 0.02510965f, 0.19670093f, 
    -0.56740290f, 0.23391902f, -0.02449917f, 0.20693818f, 0.02055887f, -0.10136805f, 0.03015799f, -0.11172275f, 
    -0.02211047f, 0.00631363f, 0.03276622f, -0.04676964f, 0.28587714f, 0.08646812f, -0.11275699f, -0.02248330f, 
    -0.09492115f, -0.04651748f, 0.08330082f, -0.03412349f, -0.00050409f, -0.00086741f, 0.02262145f, 0.02356222f, 
    0.11419298f, -0.04836856f, 0.04969133f, 0.08406499f, -0.06491657f, -0.00388347f, -0.09965024f, 0.03046264f, 
    0.12911923f, -0.02083150f, 0.03183195f, 0.05407768f, -0.19920729f, -0.05612614f, 0.09625518f, -0.22427352f, 
    -0.01943568f, 0.09924350f, -0.00741311f, -0.07194949f, -0.03167711f, 0.04004588f, -0.00694361f, -0.02909731f, 
    -0.18987647f, -0.06227527f, 0.10935593f, -0.12146290f, 0.00463621f, 0.00585506f, 0.10561220f, 0.01191148f, 
    0.00326846f, 0.05670838f, -0.00242777f, 0.05797020f, -0.04652642f, -0.07416619f, -0.08617497f, 0.18129903f, 
    0.10758653f, 0.07657225f, -0.06428021f, -0.01870343f, -0.06060532f, 0.05351002f, 0.06296670f, 0.04573362f, 
    -0.58826530f, 0.01384043f, 0.04876939f, 0.00796080f, -0.01339464f, -0.01775439f, 0.09449966f, 0.02869753f, 
    0.03596126f, 0.05491912f, 0.09857926f, 0.09204742f, -0.14838667f, -0.25227225f, 0.00748595f, -0.18944921f, 
    -0.01500148f, 0.04354632f, 0.06020437f, -0.06305069f, -0.05368644f, -0.05277765f, -0.03645820f, -0.06241792f, 
    0.13528426f, -0.22891951f, 0.22453332f, 0.17329229f, 0.02985588f, 0.12095710f, 0.00939630f, 0.06556132f, 
    0.07436332f, 0.13286246f, -0.02308678f, -0.00090899f, 0.09407315f, -0.06084218f, -0.04500148f, -0.01738213f, 
    0.02276984f, -0.04130541f, -0.02610751f, 0.14426391f, -0.00867772f, 0.04678501f, 0.03684704f, 0.03284269f, 
    0.25608408f, 0.03885594f, -0.17988554f, 0.03487130f, 0.02838423f, 0.00193630f, 0.06740069f, -0.04080305f, 
    0.09845965f, 0.06196567f, 0.10626677f, 0.05870945f, 0.22423862f, 0.22810085f, 0.01279694f, 0.00042836f, 
    0.04789361f, 0.05109399f, 0.07199252f, -0.06055338f, 0.12960882f, -0.06888147f, 0.07259955f, 0.05176224f, 
    0.10401880f, -0.02282628f, 0.01045300f, 0.18716259f, 0.10637568f, -0.03033859f, -0.00742670f, 0.11955997f, 
    0.10490753f, -0.01931925f, 0.09334920f, 0.08559585f, -0.09321969f, 0.04623518f, 0.09856381f, 0.10343923f, 
    -0.00544742f, 0.09323847f, 0.02518473f, -0.05893277f, 0.01573612f, 0.12960304f, -0.08473031f, -0.14199303f, 
    -0.14629093f, -0.01181533f, 0.10896862f, -0.12644836f, 0.07644283f, 0.01717985f, 0.06934367f, -0.02584224f, 
    0.00550926f, 0.04992867f, 0.11172363f, -0.08792359f, 0.21922427f, 0.08946844f, -0.05856439f, 0.11585020f, 
    0.03897537f, -0.07819510f, -0.06075956f, -0.02840410f, 0.05953578f, 0.06447263f, -0.10032274f, -0.00816714f, 
    0.08685889f, -0.45374957f, -0.00279291f, 0.23979367f, 0.04110728f, -0.01000097f, 0.01268106f, 0.00990012f, 
    0.21841605f, 0.10720523f, 0.07457971f, 0.02717706f, 0.00315555f, 0.25731805f, 0.10073756f, 0.00892020f, 
    -0.00271188f, 0.00965033f, 0.01156957f, 0.01043925f, 0.13120905f, 0.03054531f, -0.05800463f, 0.13205950f, 
    0.00330581f, -0.04070592f, -0.05005214f, -0.00792134f, -0.02188579f, -0.00700508f, -0.00476931f, 0.03917219f, 
    -0.04747548f, -0.04221689f, -0.02573979f, -0.04208172f, 0.03812009f, -0.01261180f, -0.02123252f, 0.00228202f, 
    -0.03670597f, -0.01994329f, 0.00291765f, 0.02199538f, 0.01931679f, 0.00142136f, 0.03636568f, -0.03715245f, 
    0.01147371f, 0.01031051f, 0.04840085f, 0.04514562f, 0.00586541f, -0.00941474f, -0.04552379f, 0.03077260f, 
    -0.05012973f, -0.04320406f, 0.02608180f, 0.03096179f, 0.01932959f, -0.05013659f, 0.02326678f, -0.03238107f, 
    0.04121323f, -0.04474219f, -0.02114784f, 0.00162673f, -0.03006555f, -0.03773681f, 0.04322294f, 0.00679084f, 
    -0.04430999f, 0.00430565f, 0.01314412f, -0.00300714f, -0.03439125f, -0.01546420f, 0.03316420f, 0.03369465f, 
    0.01642680f, -0.03321271f, 0.01824388f, 0.01868908f, 0.00569871f, 0.03355681f, -0.03219309f, -0.00100612f, 
    -0.01731886f, 0.02393615f, 0.03256075f, 0.02680314f, 0.00926912f, -0.01993665f, 0.02971904f, -0.03952679f, 
    -0.00101606f, 0.02431078f, 0.00794309f, -0.02382486f, -0.02281685f, 0.00030287f, -0.02713207f, -0.03051866f, 
    -0.00846703f, 0.02510253f, 0.00039659f, -0.01254187f, -0.03124821f, -0.03743184f, -0.04726295f, 0.00808273f, 
    0.04775731f, 0.01895173f, -0.02070018f, -0.04759148f, -0.04117369f, -0.03936975f, -0.00386875f, 0.04372212f, 
    0.00583606f, 0.03896068f, -0.05054449f, 0.00661894f, -0.03480447f, -0.04235946f, 0.00272450f, -0.02853224f, 
    0.01222293f, -0.05052789f, 0.00492341f, -0.05951329f, 0.03113269f, -0.03150733f, -0.00456488f, -0.01616069f, 
    0.01911488f, 0.02803945f, 0.03200825f, 0.02408167f, -0.05530697f, 0.02953914f, -0.05720281f, -0.01021657f, 
    -0.01143030f, -0.05238299f, 0.04112205f, -0.02676457f, 0.01674520f, -0.05206988f, -0.03173161f, -0.04020195f, 
    -0.04533942f, 0.01213115f, -0.01793008f, -0.04165474f, 0.02761821f, 0.00392974f, -0.00789736f, -0.00856147f, 
    -0.01960162f, -0.05421164f, -0.03541183f, -0.00576471f, -0.05412943f, -0.05053424f, -0.05847849f, -0.03964769f, 
    0.01065577f, 0.03395360f, 0.04375879f, 0.01332795f, 0.03994303f, -0.05741464f, 0.03267858f, 0.02092553f, 
    0.03271487f, -0.00447736f, -0.05301461f, 0.02425555f, -0.02536998f, -0.04484282f, -0.03198190f, -0.00878192f, 
    0.03342796f, -0.01610687f, 0.02197642f, -0.00534380f, -0.04081424f, 0.03264148f, -0.01199438f, 0.04021472f, 
    0.01995147f, 0.00045513f, 0.03247625f, -0.03579711f, 0.00426347f, -0.03855246f, 0.03883982f, -0.05299529f, 
    0.03650242f, -0.01593954f, 0.02397904f, 0.02771560f, 0.00776879f, 0.02906925f, -0.05454304f, 0.03775123f, 
    -0.01318407f, 0.02507046f, 0.00452286f, -0.01985478f, 0.02983391f, -0.00616961f, -0.02300272f, -0.01652478f, 
    -0.04175417f, 0.04427780f, -0.04474059f, 0.02348780f, 0.03847609f, -0.04019408f, 0.04414141f, 0.02156051f, 
    0.01146217f, -0.03451555f, 0.03785058f, 0.01926765f, -0.01828059f, 0.01833916f, -0.03797554f, -0.02415231f, 
    -0.02437916f, 0.01938353f, 0.03474781f, -0.00891080f, -0.00294772f, -0.04792435f, 0.02886531f, 0.00337733f, 
    0.01736918f, 0.02712471f, 0.04234430f, -0.04341920f, 0.01560014f, -0.02285924f, -0.01816248f, -0.05213507f, 
    -0.03229577f, 0.00091719f, -0.00375790f, -0.03053745f, -0.02828353f, -0.03551294f, -0.04461883f, -0.04987159f, 
    -0.03524968f, 0.03335463f, -0.00181099f, 0.00902977f, -0.05214620f, 0.03911502f, -0.02716821f, -0.00656227f, 
    0.04542193f, 0.00062577f, -0.04748303f, -0.03273663f, -0.02470954f, 0.02584781f, 0.01702760f, -0.01729502f, 
    -0.03142267f, -0.02746809f, -0.03166537f, 0.02645324f, -0.05344912f, 0.02082721f, 0.00466691f, 0.04264240f, 
    0.00077419f, -0.04903735f, -0.01413001f, 0.03338120f, -0.02160485f, -0.03210941f, 0.00247351f, -0.05509809f, 
    -0.03822590f, -0.01740521f, -0.00029144f, -0.04210412f, -0.02552022f, -0.04147704f, 0.00720129f, 0.02416434f, 
    -0.03473762f, 0.02485288f, 0.02570886f, -0.01726927f, -0.04603353f, 0.00545383f, 0.03923744f, -0.03677030f, 
    -0.00231621f, -0.02869119f, -0.02761110f, 0.01614323f, 0.01962246f, -0.04061005f, 0.03388898f, -0.05481243f, 
    -0.04217971f, 0.03423970f, 0.03517031f, -0.00754847f, 0.00884156f, 0.03619063f, 0.00949436f, 0.04449431f, 
    0.04525781f, -0.04009914f, 0.01308073f, -0.02564826f, 0.04165761f, -0.00973068f, 0.03487539f, 0.02359406f, 
    0.00526858f, -0.01028533f, -0.04845708f, 0.04438550f, 0.03654870f, -0.05600604f, 0.02451330f, -0.00328384f, 
    -0.01324970f, -0.00160067f, 0.02850940f, -0.01837420f, 0.00555428f, 0.03816378f, 0.00092751f, -0.02210312f, 
    -0.04841705f, 0.02343557f, -0.03796110f, 0.00343495f, 0.03350090f, 0.00915129f, -0.01621987f, -0.04599647f, 
    0.02904710f, -0.00073780f, -0.05205529f, -0.05429552f, 0.01859172f, -0.03076615f, -0.03092534f, 0.04501785f, 
    -0.01331034f, 0.02895302f, -0.03052694f, 0.00959621f, 0.03933406f, 0.04371100f, -0.02078523f, 0.02981344f, 
    0.01339251f, 0.01714528f, 0.03223185f, 0.01610200f, 0.00899842f, 0.04798149f, 0.02776794f, 0.02149293f, 
    0.01623408f, 0.01064103f, -0.01458733f, -0.00612552f, 0.01317332f, -0.05169787f, 0.04348848f, 0.03267513f, 
    -0.02788422f, -0.00033390f, -0.01071737f, 0.00692231f, -0.01644762f, -0.04998754f, -0.02628207f, 0.00295764f, 
    0.01393265f, -0.01444048f, 0.00455813f, 0.01177288f, 0.00925114f, 0.02222145f, 0.03502356f, -0.00188506f, 
    -0.00267784f, -0.04805813f, -0.01880795f, 0.00006910f, 0.00245407f, -0.05222783f, -0.00733510f, -0.00431396f, 
    0.06383995f, -0.23588493f, -0.14181390f, -0.02568427f, 0.12476741f, -0.06712998f, -0.03131186f, -0.02287697f, 
    0.16386452f, 0.02459949f, 0.02641078f, -0.00234609f, -0.13519716f, 0.12251589f, -0.07373368f, -0.03223373f, 
    -0.00774521f, 0.02923787f, 0.05105944f, -0.08963297f, 0.04325368f, 0.02555429f, -0.02718014f, -0.00453747f, 
    0.19813369f, 0.22725019f, -0.05711541f, 0.06956875f, -0.03105261f, 0.01071078f, -0.00093679f, 0.04110749f, 
    0.07210007f, 0.07701958f, -0.00202302f, 0.19248547f, 0.00725413f, -0.23549500f, 0.21887250f, -0.05891678f, 
    0.06765112f, 0.03611822f, 0.05173634f, -0.03128541f, -0.04942280f, 0.11401209f, 0.08020530f, 0.06713966f, 
    0.17318659f, 0.03956910f, 0.20189486f, 0.10794821f, -0.06351674f, -0.06831813f, 0.06521713f, 0.15521781f, 
    0.09380627f, -0.01051315f, 0.08732048f, 0.01603175f, -0.22245748f, -0.11829863f, -0.13558805f, -0.13250238f, 
    -0.11187191f, 0.06187210f, -0.07564889f, -0.02543558f, -0.01761658f, -0.01671557f, 0.08446966f, -0.00692024f, 
    0.01281843f, -0.13680907f, 0.04649064f, -0.04358716f, 0.02510823f, -0.02062651f, 0.06794529f, -0.03077061f, 
    -0.02922495f, 0.07559866f, -0.06244588f, 0.00270733f, 0.12091453f, 0.03062451f, 0.02267664f, 0.01832770f, 
    0.05823132f, 0.02668506f, -0.00462354f, -0.02417301f, 0.05805872f, 0.00533138f, -0.03681163f, 0.02480922f, 
    0.00001134f, -0.11951308f, 0.10637356f, -0.24133599f, -0.00957837f, 0.04303192f, -0.09747869f, -0.03441474f, 
    0.04850666f, 0.03104142f, -0.11466046f, 0.02250729f, 0.02515061f, -0.11477844f, -0.18555598f, -0.01650902f, 
    -0.02667992f, 0.07068523f, 0.04331078f, 0.06983774f, 0.03455663f, 0.11289009f, -0.07749854f, -0.01133453f, 
    -0.03705815f, -0.00168528f, 0.09146219f, -0.04330197f, -0.04111838f, -0.03284000f, 0.16845536f, 0.08257896f, 
    0.02212049f, 0.10044897f, 0.02453269f, 0.00088439f, 0.05534629f, 0.09169780f, 0.02073266f, -0.09285197f, 
    0.01930005f, 0.03737348f, 0.06834515f, -0.00740843f, 0.04047130f, -0.04466246f, 0.03854950f, 0.13242830f, 
    0.20622548f, -0.04811163f, -0.07487833f, -0.12862390f, -0.01603069f, -0.00039052f, -0.00428755f, 0.01351616f, 
    0.11503231f, -0.00594712f, -0.01702145f, 0.05561693f, -0.20165722f, -0.15400837f, 0.09530384f, 0.07602790f, 
    -0.08276986f, 0.05288685f, 0.09363083f, -0.03320493f, 0.08283644f, 0.11796337f, -0.01382687f, 0.19594748f, 
    -0.11342498f, 0.27248824f, 0.10464741f, -0.05658459f, -0.02665563f, -0.07514300f, -0.06702950f, -0.07287478f, 
    -0.00054863f, -0.09443285f, 0.07791788f, -0.02940777f, 0.04119996f, -0.09412976f, -0.05668201f, -0.09135789f, 
    0.04122524f, -0.01225762f, 0.00419811f, 0.05722962f, 0.10624113f, 0.13161281f, -0.09590273f, 0.01916664f, 
    0.24162941f, -0.10250662f, 0.16253440f, 0.10468625f, 0.04372095f, 0.10054360f, -0.05016133f, 0.08945839f, 
    -0.02738656f, 0.05986940f, -0.03420343f, 0.09336293f, -0.13488494f, 0.09897453f, 0.01795953f, -0.09692369f, 
    0.13655968f, 0.08680761f, -0.00395486f, 0.05209119f, 0.12885043f, -0.06728286f, 0.02976060f, -0.08572575f, 
    -0.23018251f, -0.07218470f, -0.04889629f, -0.07297124f, -0.00018920f, 0.08541605f, -0.00663229f, 0.05779303f, 
    0.04526009f, 0.11331709f, 0.01381033f, 0.08837370f, 0.25857669f, -0.00186334f, 0.03325365f, -0.00294625f, 
    0.13502246f, 0.04038596f, 0.00530826f, 0.03178522f, 0.00219070f, -0.03222952f, -0.07290179f, -0.03775270f, 
    0.39963943f, 0.11353481f, 0.01835800f, -0.05040292f, 0.06749414f, -0.07720926f, 0.08930350f, -0.00221415f, 
    -0.05482281f, 0.06855671f, 0.07156267f, 0.03893162f, 0.02859765f, -0.23313487f, 0.02411256f, -0.26994672f, 
    0.08357574f, -0.18436225f, 0.09657663f, -0.17244358f, -0.11129683f, -0.01794433f, 0.02021777f, -0.04608983f, 
    -0.08132106f, -0.12310668f, 0.00884879f, -0.02631380f, -0.04350556f, -0.05150625f, 0.03062719f, 0.13855854f, 
    -0.04015906f, 0.19489834f, -0.03655265f, 0.11804266f, 0.02901288f, 0.02107609f, -0.09704952f, 0.05242890f, 
    0.07463708f, 0.18992029f, -0.09349474f, 0.01252013f, 0.05119076f, -0.10272578f, 0.00173957f, 0.03035809f, 
    0.48921365f, -0.23129828f, -0.01163076f, 0.05445286f, 0.06842293f, -0.02817142f, 0.07509249f, 0.01521007f, 
    0.00035635f, 0.00959622f, -0.06081074f, 0.06294854f, 0.04203110f, 0.26769429f, -0.21470696f, -0.01306551f, 
    0.04902470f, 0.04082355f, 0.00402161f, 0.07854854f, 0.03377746f, -0.06571180f, 0.12730309f, -0.00313470f, 
    0.06879652f, -0.13544981f, 0.02506588f, 0.08570918f, 0.02999651f, 0.03048898f, -0.06899557f, 0.04568130f, 
    0.09939607f, 0.10070973f, -0.11797525f, 0.07154471f, -0.01813693f, 0.04082791f, -0.07515408f, 0.07493075f, 
    0.04039405f, 0.07674478f, -0.05562636f, 0.07930761f, 0.05088758f, 0.11215739f, -0.07634167f, -0.04047178f, 
    0.04946743f, 0.15435530f, 0.08280366f, -0.03919072f, 0.09918885f, -0.18591075f, 0.12863803f, 0.10647698f, 
    0.01299483f, -0.04339228f, -0.01608560f, 0.06893498f, 0.08039045f, 0.01303126f, 0.00449642f, 0.02943706f, 
    0.11479530f, 0.04605648f, 0.03305113f, 0.05852560f, 0.09948590f, 0.03601437f, 0.12630534f, 0.02180769f, 
    -0.05158322f, -0.47822419f, 0.15493377f, -0.02328747f, 0.10122946f, 0.03170660f, -0.09552896f, 0.08190911f, 
    0.10670859f, 0.12710229f, -0.01781267f, -0.03262109f, 0.38898835f, 0.32622251f, 0.05619816f, -0.05932484f, 
    0.05276268f, 0.01171650f, 0.01572461f, 0.07593749f, 0.03717119f, -0.00490413f, 0.03039095f, 0.14545532f, 
    -0.03703306f, -0.01016071f, -0.05559645f, 0.01269217f, -0.02953157f, -0.05520523f, -0.03811653f, -0.02507116f, 
    0.01086880f, -0.02196006f, -0.04770442f, 0.04209987f, -0.03934467f, -0.02771196f, -0.04431732f, 0.02784291f, 
    -0.02723962f, -0.02766297f, -0.00691652f, 0.04157954f, 0.02449563f, 0.00937428f, 0.01861973f, 0.02965587f, 
    -0.00740323f, -0.00729750f, -0.01237284f, -0.05613152f, -0.02861870f, 0.01274429f, -0.03421827f, -0.03397539f, 
    -0.04089532f, 0.04009890f, 0.01506162f, -0.03003750f, -0.00819385f, -0.02591340f, -0.03221809f, 0.01959002f, 
    -0.03302612f, -0.02746621f, -0.00001274f, -0.03045501f, 0.03148551f, -0.04007796f, 0.02350443f, 0.03937250f, 
    0.01910624f, 0.02313336f, -0.00143789f, 0.04187075f, 0.01107889f, -0.02918868f, 0.03465138f, 0.01455019f, 
    -0.02507942f, -0.04715541f, 0.02845712f, 0.00407267f, -0.04980707f, 0.01672194f, -0.02225113f, 0.00830713f, 
    0.00725576f, -0.05579179f, -0.03257596f, 0.02545773f, -0.05196264f, 0.04260128f, 0.03416067f, -0.01304167f, 
    -0.02049451f, 0.03843741f, 0.03007721f, -0.04134022f, -0.02863034f, -0.05561022f, -0.02923099f, -0.04588619f, 
    0.02671425f, -0.00355599f, 0.01546476f, 0.02441250f, 0.00356373f, 0.02649204f, 0.01078409f, 0.01858847f, 
    0.00729369f, -0.04051866f, 0.03612729f, 0.01318636f, 0.03116385f, 0.03377295f, 0.03313701f, 0.02404297f, 
    -0.03121004f, 0.02758209f, 0.02142791f, -0.01980174f, 0.01342194f, 0.02286238f, -0.03600333f, -0.00220109f, 
    -0.01478209f, -0.04861538f, -0.02489529f, -0.02341658f, -0.03059202f, 0.03059719f, -0.02018340f, 0.01061962f, 
    0.04637053f, 0.03509605f, -0.04765899f, 0.02125623f, 0.01221739f, -0.03871940f, -0.05128475f, -0.01640488f, 
    -0.04171101f, 0.02233736f, -0.02508172f, 0.01641493f, 0.03271658f, 0.00476595f, 0.03124812f, -0.00744240f, 
    0.02332662f, 0.00674532f, -0.05923950f, 0.00115866f, -0.03815054f, 0.00888778f, -0.00176525f, 0.04109298f, 
    -0.00217926f, 0.03803988f, 0.00229428f, 0.02995012f, -0.01452609f, -0.04705006f, -0.03000231f, -0.04491517f, 
    0.00388258f, -0.03124608f, -0.04557201f, -0.03028614f, 0.01351255f, -0.00816918f, 0.00711205f, -0.04214389f, 
    0.03731420f, 0.00766660f, -0.05353289f, -0.01065521f, 0.04179757f, -0.00897189f, -0.00615787f, -0.06157235f, 
    0.03652292f, -0.03740115f, -0.05150262f, -0.04333084f, 0.00029754f, 0.03303022f, 0.01553802f, -0.00225356f, 
    0.03146707f, 0.01627302f, -0.02712451f, 0.00916988f, 0.01279208f, 0.02788272f, -0.04569861f, 0.00381674f, 
    0.01774122f, 0.04150740f, -0.01798036f, 0.03835694f, 0.03433690f, -0.01452931f, 0.03144916f, -0.04636764f, 
    -0.04576531f, 0.03432501f, -0.05296731f, 0.02588541f, 0.01221237f, 0.00767276f, -0.04457092f, 0.02541175f, 
    0.01191052f, -0.00573829f, -0.01511658f, 0.02633295f, -0.01078002f, 0.01855529f, -0.03222427f, 0.03830231f, 
    0.00824729f, -0.05173129f, -0.03961182f, -0.01492989f, -0.01084384f, -0.05803952f, -0.00923686f, -0.03570596f, 
    0.04171520f, 0.00958415f, -0.00153933f, 0.01054395f, -0.05761612f, -0.00227864f, -0.00886637f, -0.00605372f, 
    -0.02253799f, 0.00237032f, 0.01674007f, -0.01663019f, -0.00006019f, 0.00614147f, -0.00381797f, 0.03076852f, 
    0.01007142f, 0.01407091f, -0.00493666f, 0.00644673f, -0.00986454f, 0.01502751f, 0.02162201f, 0.00998132f, 
    -0.03875755f, -0.05796001f, -0.00488028f, -0.04497319f, 0.03729653f, -0.01810339f, -0.01895455f, -0.03828559f, 
    0.01594200f, -0.00126744f, 0.04197753f, 0.01600536f, -0.02770312f, 0.03379868f, -0.05764272f, -0.05817590f, 
    0.00117579f, -0.04809988f, -0.01153735f, -0.04820955f, 0.02150463f, 0.00543233f, -0.04687056f, -0.01901813f, 
    -0.03628156f, 0.02425930f, -0.04227199f, -0.01450063f, -0.04926725f, 0.00182013f, -0.01594735f, -0.05487155f, 
    0.03073667f, 0.01928961f, 0.00107426f, -0.04987046f, 0.02491015f, -0.02228485f, -0.00915737f, 0.04019529f, 
    -0.00195950f, -0.04032734f, -0.00055085f, 0.00580445f, -0.01910357f, -0.04016717f, -0.02714795f, -0.03004199f, 
    -0.01442075f, -0.01976375f, -0.02370817f, 0.01132928f, 0.00595308f, 0.00543909f, -0.00690644f, -0.05121999f, 
    -0.02728209f, -0.01925426f, 0.01842392f, 0.00574977f, 0.01207791f, 0.03285484f, -0.02927124f, -0.02130106f, 
    -0.02457031f, 0.02975770f, 0.00326667f, 0.01759266f, 0.03277628f, 0.00886450f, -0.04615705f, -0.04726060f, 
    -0.05158060f, -0.00636108f, 0.00169312f, -0.03057181f, 0.01249833f, -0.03443722f, 0.00531361f, 0.03991938f, 
    -0.00605717f, -0.02774650f, -0.01168418f, -0.04000071f, -0.01596073f, -0.02685367f, 0.02472848f, 0.03466036f, 
    0.03473650f, -0.01068488f, 0.01074647f, -0.01844736f, 0.04214910f, -0.03488775f, -0.03200258f, -0.02103514f, 
    -0.04831701f, 0.04043630f, -0.00369527f, -0.03221946f, -0.00600206f, -0.01643043f, -0.03288855f, 0.00015108f, 
    -0.05005627f, -0.04783967f, 0.02200280f, -0.04267066f, 0.04962370f, 0.01327960f, -0.04251513f, -0.02646359f, 
    0.03207797f, -0.04793726f, -0.05269274f, -0.05835367f, -0.04719076f, -0.03312636f, -0.03778492f, -0.00101412f, 
    -0.01831404f, 0.00485653f, -0.05584100f, -0.04452921f, -0.05085886f, -0.03363901f, -0.06016123f, -0.03055540f, 
    -0.00462217f, 0.04623200f, -0.00396040f, -0.04394650f, -0.02029863f, -0.01620006f, 0.01271909f, -0.04931369f, 
    0.00414064f, -0.01540255f, -0.01623929f, -0.02382270f, 0.00880522f, 0.03899564f, 0.01181609f, 0.02908303f, 
    0.02860628f, -0.05112216f, 0.00369969f, -0.02967487f, 0.02837260f, 0.02521876f, -0.02321636f, -0.01458935f, 
    0.13786656f, 0.04093273f, 0.03292322f, 0.03351097f, -0.09705614f, -0.19263914f, -0.04657383f, 0.12518799f, 
    0.03334455f, -0.11923941f, -0.01002289f, 0.05673434f, 0.16706210f, 0.11532389f, 0.07423630f, 0.05228617f, 
    0.14504081f, -0.08306154f, 0.00990433f, -0.03751270f, -0.03780956f, 0.08026300f, 0.00069484f, 0.12287562f, 
    -0.16038530f, -0.18401536f, -0.31932306f, -0.02956972f, 0.18817307f, 0.13075823f, 0.00827631f, -0.10472323f, 
    -0.05260975f, -0.00262863f, 0.03013502f, 0.08075418f, 0.12711138f, 0.03803996f, -0.09060248f, 0.16365086f, 
    0.06807889f, 0.03924076f, -0.06481491f, 0.08141950f, -0.10040904f, 0.07155838f, 0.01200915f, 0.01527631f, 
    -0.00756336f, -0.05915405f, -0.19273509f, -0.03296578f, 0.16763744f, 0.10733636f, 0.02033819f, 0.04433127f, 
    0.15633532f, -0.06708765f, 0.08557857f, 0.11807326f, 0.02902808f, 0.15866007f, 0.09574966f, -0.00934797f, 
    0.07768153f, -0.01914248f, -0.03446886f, 0.02778360f, 0.14133629f, -0.02148704f, 0.08175965f, 0.02320072f, 
    -0.13263437f, 0.06531236f, -0.09023258f, -0.16224699f, 0.08233047f, 0.00404779f, -0.05620584f, 0.05327186f, 
    0.06569644f, 0.03191390f, -0.06802753f, 0.00174049f, -0.11226559f, -0.18084192f, -0.17969841f, -0.08941396f, 
    0.21645035f, 0.02073924f, -0.19702433f, -0.06883910f, 0.09097212f, 0.04720699f, -0.02381802f, -0.02793772f, 
    -0.13303664f, 0.14471422f, 0.12991218f, 0.06727292f, -0.03048268f, 0.15448469f, -0.02725189f, 0.12327293f, 
    -0.07937323f, -0.00051944f, -0.16401219f, 0.01841676f, 0.28078440f, 0.02361550f, 0.06584997f, 0.13784122f, 
    -0.17946561f, -0.17469661f, -0.01017755f, 0.02571072f, -0.04273304f, 0.03329251f, 0.07619499f, 0.05826620f, 
    -0.05165545f, -0.06329322f, -0.05283409f, -0.02059416f, -0.13355239f, -0.07445763f, -0.01701411f, 0.07644213f, 
    -0.07080628f, -0.00855215f, 0.00553734f, -0.18654476f, 0.24218012f, -0.04779476f, -0.22605161f, 0.07319698f, 
    0.05018646f, 0.04350962f, 0.05326678f, -0.07806015f, 0.01728852f, 0.00504611f, 0.11831535f, -0.04880090f, 
    0.23053209f, -0.11134315f, -0.08854868f, 0.16396363f, -0.17510164f, -0.13106956f, 0.05133939f, 0.04241199f, 
    -0.02979863f, -0.00413371f, -0.03496258f, -0.17533313f, 0.25245234f, 0.09386150f, 0.17666847f, 0.15836586f, 
    0.10436967f, 0.04537671f, -0.02449211f, 0.15006460f, -0.05635498f, 0.09104094f, 0.08686613f, 0.05675489f, 
    0.31763241f, -0.14521489f, 0.13691507f, -0.07142780f, -0.02677135f, 0.14951855f, -0.03617214f, 0.05066282f, 
    0.04692130f, -0.02984530f, -0.00959168f, 0.08371136f, -0.22564064f, 0.01469155f, 0.16277967f, 0.01200348f, 
    -0.07499601f, 0.06446148f, -0.08573645f, 0.00503626f, -0.09262521f, 0.02942958f, -0.04226905f, -0.07945972f, 
    0.06327564f, 0.16755548f, 0.06528927f, 0.01079208f, 0.19559003f, -0.02467501f, -0.06872660f, -0.03877953f, 
    -0.03011120f, 0.08339752f, -0.05633687f, 0.06251206f, -0.17288525f, 0.02741223f, 0.07092308f, 0.05081610f, 
    0.08285832f, 0.05649471f, -0.01856068f, 0.14724389f, 0.15829195f, -0.03144230f, 0.00966936f, 0.03516337f, 
    0.13152358f, -0.03916558f, 0.11759038f, -0.07604622f, 0.00856002f, -0.02895017f, -0.06860479f, -0.10705089f, 
    -0.02205270f, 0.03167870f, 0.04223258f, 0.01779730f, -0.25157243f, -0.10925105f, -0.22036731f, -0.11767384f, 
    0.03537502f, -0.03725570f, -0.07767563f, -0.09266374f, 0.00730972f, -0.06432147f, 0.06835905f, 0.07080832f, 
    0.28485146f, 0.21332462f, 0.02954544f, -0.01759261f, -0.04120802f, 0.12104739f, 0.02502958f, 0.03809162f, 
    0.08059042f, 0.01016118f, 0.04839547f, 0.12000323f, -0.15984827f, 0.10097824f, 0.12368733f, 0.04500696f, 
    0.10064182f, -0.06547539f, -0.03056346f, -0.12280212f, 0.07220343f, 0.03525073f, -0.04631817f, 0.02696727f, 
    -0.26760170f, 0.07945415f, -0.01056067f, -0.11097007f, 0.16565341f, -0.02959477f, -0.08686753f, -0.04753688f, 
    0.17714629f, 0.11261068f, 0.13200788f, -0.14514615f, 0.04954008f, 0.06095408f, 0.07551309f, 0.16930892f, 
    0.01048347f, 0.09622238f, -0.07842907f, -0.13746107f, 0.11517067f, -0.03362721f, 0.08039853f, 0.04005262f, 
    0.19544043f, 0.00803996f, -0.05465598f, -0.22182648f, 0.01692958f, -0.00243421f, 0.00713118f, 0.00461779f, 
    0.01529020f, -0.01340350f, 0.01984384f, -0.02004117f, -0.01995986f, 0.03126724f, -0.09652258f, 0.14265706f, 
    -0.00392967f, -0.09772950f, 0.05234544f, 0.06792095f, -0.02976471f, 0.11401930f, -0.07546613f, 0.04152111f, 
    -0.35391715f, 0.03961339f, -0.19429891f, -0.00668565f, 0.02382258f, -0.08942997f, -0.00016999f, 0.00562089f, 
    -0.01733691f, 0.02430974f, -0.04028704f, 0.05038994f, -0.18847719f, 0.14555249f, -0.03800559f, -0.11915458f, 
    0.03777939f, 0.00194117f, 0.02330065f, 0.16953982f, 0.05441463f, 0.02997788f, 0.02065469f, 0.06177973f, 
    0.01429170f, -0.07043438f, -0.17963633f, 0.18682988f, 0.11559033f, -0.05549633f, -0.05569218f, 0.00332048f, 
    0.20320708f, 0.15872557f, 0.03397742f, 0.05753032f, 0.02341744f, -0.02003602f, -0.22460970f, -0.24066547f, 
    0.01454003f, -0.07583738f, -0.02919748f, -0.04076683f, 0.10355342f, 0.01513018f, 0.12037164f, -0.05515890f, 
    0.09491325f, -0.14166248f, -0.12029777f, -0.17930339f, 0.25325236f, 0.00219541f, 0.09676329f, -0.01888383f, 
    -0.00941362f, -0.05265485f, 0.14212555f, 0.16047329f, 0.05015999f, -0.15167551f, -0.17807844f, 0.10387830f, 
    0.18286176f, 0.15151419f, 0.01794600f, -0.05104355f, -0.05064984f, 0.12713899f, 0.10447536f, 0.06961390f, 
    -0.16797437f, -0.04037621f, -0.04836733f, -0.00101662f, 0.09890365f, 0.04080619f, 0.07060429f, 0.05169639f, 
    0.22873761f, -0.00212206f, -0.08002955f, 0.05911529f, -0.16964146f, 0.14363684f, 0.01000523f, -0.06677970f, 
    -0.02883215f, -0.06927385f, 0.17355141f, -0.01413333f, -0.11136499f, 0.03527069f, -0.06690325f, 0.07849006f, 
    -0.12803243f, -0.08421752f, 0.20821112f, 0.01482200f, 0.01075873f, 0.07435165f, -0.00761196f, -0.01789632f, 
    0.10027537f, 0.10392249f, 0.11211754f, 0.11371785f, -0.12148463f, 0.10665051f, -0.06254019f, -0.15311402f, 
    0.00560496f, -0.04662798f, -0.04479437f, -0.09947792f, 0.00224858f, -0.01137203f, 0.11223830f, 0.04734363f, 
    0.04180682f, -0.03969607f, 0.05966160f, 0.11960465f, -0.01975391f, -0.04136677f, 0.02269486f, -0.03716552f, 
    0.12352165f, 0.04281210f, 0.07402873f, 0.05016498f, -0.24877815f, -0.06269834f, -0.12993968f, -0.05115844f, 
    -0.03424717f, 0.01108513f, -0.03215209f, 0.08236189f, -0.12127548f, -0.15684643f, -0.05096985f, -0.09210148f, 
    -0.11667131f, -0.05131521f, 0.02346553f, 0.08511594f, 0.06549850f, -0.05380660f, 0.09658166f, 0.04138834f, 
    -0.04121751f, -0.03377838f, -0.07277783f, 0.06382447f, -0.00697238f, 0.10204938f, 0.13993698f, 0.06058627f, 
    0.08067980f, 0.05056316f, 0.02888673f, 0.01129021f, -0.12422368f, -0.04707631f, 0.01691823f, -0.04337750f, 
    0.20511304f, -0.11525469f, 0.00775375f, -0.01362478f, -0.03404844f, 0.06391955f, -0.24237467f, -0.06996753f, 
    0.04656512f, -0.02658354f, -0.01215341f, 0.02026098f, -0.02529269f, 0.01328417f, -0.08441412f, -0.00731632f, 
    0.10705207f, 0.09716766f, 0.08901959f, 0.00265161f, 0.04524309f, 0.14227287f, 0.04532047f, -0.00831741f, 
    -0.19431813f, -0.19379602f, -0.02016542f, -0.08166083f, 0.11758681f, -0.02842137f, -0.12158737f, -0.05304313f, 
    -0.01873409f, 0.11989199f, 0.07285917f, 0.13712560f, -0.08278951f, 0.06438282f, 0.13457942f, 0.11381304f, 
    0.01051551f, 0.10970808f, -0.01286484f, 0.02151289f, -0.05252757f, -0.07160117f, 0.18434252f, 0.14985904f, 
    -0.05928250f, -0.22445971f, -0.20778243f, -0.07340244f, 0.12541980f, 0.01430986f, 0.03064964f, -0.04368561f, 
    0.02682194f, -0.04439251f, -0.12613109f, -0.03822262f, 0.13635966f, -0.12611029f, 0.06651095f, -0.09707907f, 
    -0.04905488f, 0.00786858f, 0.02651324f, -0.01496860f, 0.05432199f, 0.05193266f, 0.16684270f, -0.01260456f, 
    -0.05406030f, -0.02922558f, 0.04237260f, 0.13203646f, 0.09583019f, 0.00095922f, -0.04579969f, -0.07123175f, 
    -0.07141363f, 0.03669287f, 0.08419908f, 0.03531371f, 0.03800591f, -0.11749221f, -0.13665026f, -0.09576049f, 
    0.06275810f, 0.01551372f, 0.01738480f, 0.00515347f, 0.09995411f, 0.02586549f, -0.12575153f, 0.12677331f, 
    -0.11247382f, 0.07593998f, 0.05059126f, -0.08484071f, -0.05291359f, -0.03432818f, 0.05114694f, 0.10526052f, 
    0.08651629f, -0.02530215f, 0.02738068f, -0.03593934f, -0.00434075f, -0.20849375f, 0.06219139f, 0.05786906f, 
    0.05363297f, 0.09503638f, 0.02846713f, 0.10864574f, 0.02206959f, -0.12550308f, -0.00188429f, -0.03322984f, 
    -0.01038257f, 0.03295001f, -0.10895066f, 0.19466293f, 0.16741909f, 0.00982179f, 0.01308187f, 0.09595874f, 
    0.09210753f, 0.12809764f, 0.03443353f, 0.13566299f, 0.06699710f, 0.15981409f, 0.07175986f, 0.16165316f, 
    0.00494391f, 0.04401962f, -0.17563008f, 0.04023300f, -0.05605813f, -0.03950177f, 0.11458118f, 0.06731989f, 
    0.07491345f, -0.16305624f, -0.14910156f, -0.02040553f, -0.06168383f, -0.03423610f, 0.06480323f, -0.02465652f, 
    -0.06406507f, 0.02454506f, 0.01669043f, 0.03504466f, -0.07217167f, -0.02409149f, 0.05498225f, -0.02639755f, 
    0.11712783f, 0.03379897f, 0.06763363f, -0.05901831f, 0.07915473f, 0.23729743f, -0.05360457f, -0.06751362f, 
    0.04991471f, -0.26314670f, 0.09099035f, -0.06306650f, -0.07343224f, -0.04817140f, 0.04177169f, 0.00805475f, 
    0.04277535f, 0.03691986f, 0.11059994f, -0.07412061f, -0.07856296f, 0.09560991f, 0.02505857f, 0.00429849f, 
    0.06031129f, 0.19344370f, -0.15781634f, 0.15442438f, 0.09578346f, -0.16704533f, 0.20449246f, 0.04327936f, 
    -0.05310511f, 0.03383024f, -0.03485690f, 0.03252557f, 0.06059419f, -0.05125620f, 0.03430074f, -0.06558274f, 
    0.14079474f, -0.05385101f, -0.11424509f, -0.00767878f, -0.06480627f, -0.01468272f, 0.17911787f, -0.02200865f, 
    0.08447506f, -0.06396212f, -0.02988072f, 0.02305191f, -0.01330905f, 0.05529848f, 0.06471015f, 0.22457850f, 
    -0.08139849f, 0.01870125f, 0.02398755f, -0.19098993f, 0.08436666f, -0.10814565f, 0.06506231f, -0.02552120f, 
    0.17316118f, -0.09186078f, 0.00111953f, -0.04799510f, -0.28008458f, -0.02248432f, 0.15541565f, 0.10293458f, 
    -0.01654891f, 0.03104064f, 0.05839072f, 0.10267260f, -0.17408217f, -0.08358615f, 0.13328677f, -0.01849397f, 
    0.01349617f, -0.05375512f, 0.17438394f, 0.09028835f, 0.06588443f, -0.13107529f, 0.16995035f, -0.02629765f, 
    0.03954853f, 0.17437081f, 0.08068287f, 0.09789077f, -0.25476229f, 0.24380119f, 0.03554728f, -0.02135457f, 
    0.01534363f, 0.03469744f, -0.00421713f, 0.01728947f, 0.08719650f, 0.07158468f, -0.01110206f, -0.14279175f, 
    0.20101796f, -0.12239818f, 0.02188250f, 0.01054201f, 0.01575342f, 0.03773611f, 0.01029863f, -0.02579989f, 
    0.18321057f, -0.01466233f, 0.06795555f, 0.17488053f, -0.13712092f, 0.13794032f, 0.21077013f, 0.18524687f, 
    -0.02434453f, 0.05549432f, 0.05095005f, -0.02724203f, 0.01943099f, -0.07851300f, 0.02530875f, 0.19368394f, 
    -0.04071913f, -0.04456521f, -0.02044647f, -0.02950968f, -0.01890251f, 0.00985789f, -0.04574735f, 0.03648730f, 
    0.02520569f, -0.02728154f, 0.00574572f, 0.02148874f, -0.04933379f, 0.00011175f, -0.03831281f, 0.02815416f, 
    -0.01274908f, -0.00577793f, 0.02820031f, 0.00643673f, -0.04706835f, -0.04669261f, -0.04746223f, 0.03889601f, 
    -0.02358656f, -0.04435009f, 0.00423948f, -0.02492917f, -0.00545406f, -0.02943128f, -0.03372375f, 0.02308719f, 
    -0.03881267f, 0.03251431f, -0.02250366f, 0.03681118f, -0.00568037f, -0.00342557f, -0.01790700f, 0.01152595f, 
    -0.01267694f, 0.04444842f, 0.00419680f, 0.03211164f, 0.02516854f, -0.03269251f, 0.03502906f, -0.03345378f, 
    -0.01533626f, -0.04951439f, 0.00109398f, -0.05506110f, -0.03520226f, 0.02923970f, 0.00873990f, -0.05328264f, 
    0.01691876f, -0.05653314f, -0.02430828f, -0.04252714f, 0.02807193f, 0.03130072f, -0.03952033f, 0.00567171f, 
    -0.02889455f, -0.05139820f, 0.00956467f, -0.04443866f, -0.00750991f, 0.03862620f, 0.01064230f, -0.00996301f, 
    -0.05571908f, 0.00357209f, -0.01398441f, 0.03894899f, -0.04047886f, 0.03138600f, 0.01498920f, -0.04353895f, 
    -0.03429031f, 0.00045665f, 0.00272956f, -0.00692592f, 0.02675671f, 0.02455964f, -0.01044491f, -0.02370044f, 
    -0.01660042f, -0.01084833f, -0.04650564f, 0.02618488f, -0.00459670f, -0.00939062f, -0.03399064f, -0.04715641f, 
    -0.02283991f, 0.00969974f, -0.03519079f, 0.02765122f, 0.03499280f, -0.02755767f, -0.04896192f, 0.00185159f, 
    0.00660021f, -0.03472765f, 0.04413498f, -0.05472724f, 0.02651730f, -0.02296976f, 0.04117909f, -0.01398098f, 
    0.00277757f, -0.01408584f, 0.02572080f, -0.02303081f, -0.05108574f, -0.04125468f, 0.02669727f, 0.03725564f, 
    -0.01415026f, -0.03699017f, 0.01089569f, -0.04279980f, -0.03529351f, -0.05167096f, 0.02755816f, -0.02010699f, 
    -0.05247858f, 0.01174127f, -0.03506872f, 0.02571505f, -0.00804109f, -0.03939507f, -0.00777244f, 0.04335356f, 
    -0.04888508f, -0.02845642f, -0.00119033f, -0.04344722f, 0.01249910f, -0.05116120f, -0.02224812f, 0.03881339f, 
    0.03241489f, 0.00150020f, -0.02507882f, 0.02157672f, -0.05002235f, -0.00315109f, 0.00607620f, -0.03285369f, 
    -0.01751695f, 0.01299982f, -0.02096815f, 0.01787722f, 0.04013133f, -0.01105479f, -0.03149570f, -0.02053728f, 
    -0.01697603f, 0.03513822f, -0.05499044f, 0.01226221f, 0.00626329f, 0.04282124f, -0.05308565f, -0.03480552f, 
    -0.00089141f, -0.02862245f, 0.03891634f, 0.02058782f, -0.02312388f, -0.01919358f, -0.01732013f, -0.00993976f, 
    -0.00386236f, 0.02834624f, -0.00605909f, -0.02901976f, 0.03424098f, -0.04702220f, -0.02460622f, -0.02433103f, 
    0.02790263f, 0.00526644f, -0.02700650f, -0.01944761f, 0.01455859f, 0.01711199f, 0.02017504f, -0.05400596f, 
    0.00296074f, 0.01206210f, 0.03519141f, 0.04241251f, -0.02177922f, -0.00993968f, -0.01877466f, -0.01273211f, 
    0.04283718f, 0.00820700f, 0.02918134f, 0.03764608f, -0.00741515f, 0.01970671f, 0.00425166f, -0.02778262f, 
    0.00335257f, -0.04821095f, -0.05461319f, -0.01626284f, -0.00106102f, 0.03198904f, -0.04192580f, -0.03644150f, 
    -0.02970518f, -0.01424786f, -0.01329824f, -0.05169638f, -0.05000531f, 0.00734790f, 0.01923751f, -0.02821148f, 
    -0.05081890f, -0.02894274f, -0.01007514f, -0.01679458f, -0.05161389f, 0.00355349f, 0.01998082f, -0.05519418f, 
    -0.00093667f, -0.00206024f, 0.01529029f, -0.03558353f, 0.02327362f, -0.00005804f, -0.01988256f, 0.01991768f, 
    -0.01681210f, 0.03623940f, -0.00751882f, -0.02216111f, -0.04030488f, -0.00466694f, -0.04252343f, 0.02158002f, 
    -0.03007226f, -0.03921286f, 0.03775300f, -0.03043180f, -0.05420765f, 0.04322746f, 0.04323823f, 0.00938639f, 
    -0.03860807f, 0.02123743f, -0.01791149f, 0.01174974f, 0.03630579f, 0.01174613f, -0.01809192f, -0.03195680f, 
    -0.02062656f, 0.02886840f, -0.02750614f, 0.00300149f, 0.01996428f, -0.00210628f, -0.04428699f, 0.02055798f, 
    0.01139135f, -0.00514682f, -0.04058232f, 0.02026733f, -0.05431836f, -0.01718824f, -0.02694517f, -0.02735313f, 
    -0.02644617f, 0.02928768f, -0.02979930f, -0.03787640f, 0.02486477f, 0.03071637f, 0.03111295f, -0.02432716f, 
    -0.02424774f, -0.00988033f, -0.03249718f, 0.00846945f, 0.01220543f, -0.03947518f, -0.02876059f, -0.00201744f, 
    -0.05068733f, 0.01070739f, 0.03457180f, 0.00853793f, -0.00022004f, -0.03548803f, -0.02902116f, -0.00940760f, 
    -0.04330378f, 0.02393706f, 0.00593527f, -0.04583386f, -0.01611111f, 0.03296291f, -0.05461381f, -0.02011738f, 
    -0.01895415f, 0.02085466f, -0.01499133f, 0.00438497f, 0.00796239f, -0.05138669f, -0.01450879f, 0.00746795f, 
    -0.01181953f, -0.05051690f, -0.05187367f, 0.01739980f, -0.00044959f, -0.00244555f, -0.04384953f, -0.01579503f, 
    0.00588002f, 0.01269421f, -0.01997198f, 0.02695020f, -0.04148678f, 0.03031381f, 0.03059584f, -0.03510262f, 
    -0.01333180f, 0.02901943f, -0.00228074f, 0.02076304f, -0.00351799f, 0.00264299f, -0.04640562f, -0.00062711f, 
    -0.03460376f, 0.02897038f, 0.01985194f, -0.01613677f, 0.02974238f, 0.01511295f, -0.03826238f, -0.04584633f, 
    -0.00453198f, 0.03784920f, 0.01036763f, 0.02723839f, -0.04950224f, 0.03952337f, -0.04006032f, 0.00839499f, 
    -0.02063718f, -0.05693334f, 0.02452619f, 0.02013399f, -0.01745643f, -0.00487707f, 0.02255080f, 0.01122429f, 
    0.00340429f, 0.00153517f, 0.00614057f, 0.01227282f, -0.03031098f, 0.04165434f, -0.04974243f, -0.01165269f, 
    0.01884215f, -0.01913797f, -0.02041151f, -0.02059609f, -0.03099087f, 0.00897617f, 0.00060419f, -0.03434104f, 
    0.03015828f, -0.24551560f, -0.15796933f, 0.12918569f, 0.09262478f, -0.00986524f, 0.04171964f, 0.03125282f, 
    0.07424983f, 0.00180103f, -0.01164019f, -0.01335759f, -0.28594354f, 0.24539648f, 0.03571536f, -0.01489066f, 
    -0.01690520f, -0.03840705f, 0.01532781f, -0.02315634f, -0.02423079f, 0.17221716f, -0.09866055f, 0.09622529f, 
    -0.21171494f, -0.02160935f, -0.06050632f, -0.02736318f, -0.02067062f, 0.05779592f, 0.06500055f, -0.00194314f, 
    -0.04918967f, -0.02709930f, 0.01780337f, 0.26336896f, -0.03954358f, 0.00292124f, 0.15764444f, -0.12434265f, 
    0.05334469f, 0.03044407f, -0.02776387f, -0.07902957f, 0.08258699f, 0.03643507f, 0.03824304f, 0.15176247f, 
    0.05557123f, -0.20192149f, 0.12736112f, 0.09326994f, -0.12699038f, 0.00871632f, 0.00823669f, 0.08314274f, 
    0.11667268f, -0.04953340f, 0.10808744f, 0.09496095f, -0.53123605f, -0.23275860f, 0.02187341f, 0.06441323f, 
    -0.19473071f, 0.01330861f, -0.04957943f, 0.10891140f, -0.04277091f, -0.04144355f, -0.02293717f, -0.03831849f, 
    0.01388810f, -0.13076112f, 0.05990995f, -0.01457345f, 0.09165738f, -0.08050839f, 0.10261615f, 0.03852246f, 
    -0.00902038f, 0.01200625f, -0.03359015f, 0.05331940f, -0.09084836f, -0.09635727f, 0.12832883f, -0.04767512f, 
    -0.05083979f, 0.09493203f, -0.05369931f, -0.03061741f, -0.02420293f, -0.04291487f, -0.06513143f, -0.01028697f, 
    0.09550803f, -0.16926435f, 0.08956484f, -0.31286567f, 0.11736894f, 0.15845215f, -0.12111012f, -0.06120190f, 
    0.12186749f, 0.03623949f, -0.11186787f, -0.03412745f, 0.24360237f, 0.18208654f, -0.08120988f, 0.20088945f, 
    0.00785212f, 0.15023635f, 0.08618907f, 0.10369244f, -0.00632132f, 0.17313708f, 0.00714462f, -0.02476432f, 
    0.01657957f, -0.05631565f, -0.04438356f, -0.08856740f, -0.05984657f, 0.00079002f, 0.06020164f, -0.05113268f, 
    -0.08732846f, 0.04850928f, 0.03682365f, 0.05891597f, 0.15018697f, 0.04656633f, 0.10905457f, 0.20662999f, 
    0.01451879f, 0.00955157f, 0.05610180f, 0.02462419f, 0.00686766f, -0.00808054f, 0.10225402f, 0.18779995f, 
    0.41661647f, 0.05221409f, -0.24792750f, -0.32584730f, 0.08020135f, 0.09540291f, 0.03030746f, -0.10517967f, 
    -0.04651406f, -0.02080326f, -0.12756816f, -0.02886477f, 0.10563917f, -0.21426329f, 0.20594756f, 0.15881579f, 
    -0.06722690f, 0.02790671f, 0.14712539f, 0.04360747f, 0.09856976f, 0.06867358f, 0.06241056f, 0.10579757f, 
    -0.11309195f, 0.19233742f, 0.01524844f, 0.26113334f, 0.06964593f, -0.11648942f, 0.00572667f, -0.03787195f, 
    -0.02777026f, -0.12791866f, 0.02792086f, -0.00663714f, 0.06622040f, -0.07045586f, -0.10506979f, -0.32043335f, 
    -0.03454955f, 0.09255773f, 0.07760480f, 0.01823816f, 0.08657258f, 0.10429621f, -0.03988473f, 0.01791442f, 
    0.13543884f, 0.07667361f, 0.11764205f, 0.00261430f, -0.02747384f, 0.03282308f, 0.05968017f, 0.04116582f, 
    -0.08151287f, 0.05714657f, -0.00945268f, 0.00284505f, 0.07077164f, 0.11054978f, 0.19287905f, 0.15509079f, 
    0.08302566f, 0.14501722f, -0.02397708f, 0.06309880f, 0.11634036f, -0.10205345f, -0.05127193f, -0.01466468f, 
    -0.06383119f, 0.05600151f, -0.12509538f, 0.20313258f, 0.08747047f, -0.04606330f, -0.04714897f, -0.01471677f, 
    0.04913234f, 0.05587403f, 0.07805765f, 0.06241911f, -0.10170737f, -0.03868860f, -0.01933807f, -0.11683672f, 
    -0.06496576f, -0.05385346f, -0.12890634f, -0.07548754f, -0.02020956f, -0.08583444f, 0.04034243f, -0.05928069f, 
    0.21850002f, -0.04510305f, 0.00610446f, -0.06210187f, 0.03329736f, -0.08012047f, 0.06273124f, 0.06350578f, 
    -0.09207723f, 0.12612313f, 0.09719272f, 0.09636224f, 0.24644831f, -0.23558444f, 0.16703290f, -0.03026156f, 
    -0.01742220f, -0.00948914f, 0.09131975f, -0.14596780f, -0.02208943f, 0.13151658f, -0.01820322f, -0.07500170f, 
    0.29366073f, -0.12412222f, 0.06121706f, -0.09357078f, 0.00283474f, -0.05279402f, 0.01596981f, 0.06916359f, 
    -0.03396079f, 0.11795235f, 0.03394131f, 0.04088877f, 0.00845097f, 0.13399899f, -0.05520225f, -0.01975500f, 
    0.05529762f, 0.15381247f, -0.08488377f, 0.01224381f, 0.03099319f, -0.05548244f, -0.00030922f, 0.06945089f, 
    0.22501184f, -0.19067560f, -0.05242673f, 0.05148637f, -0.01257681f, -0.04543651f, 0.05091530f, 0.10338432f, 
    0.05779887f, -0.06221082f, -0.07628578f, 0.06935009f, -0.08268537f, 0.33381087f, 0.06223218f, 0.08927333f, 
    0.05910110f, -0.09935718f, 0.00463647f, 0.18364562f, 0.01302880f, -0.01450174f, 0.01444173f, 0.08352615f, 
    0.01616214f, -0.19761756f, 0.03398017f, -0.02961353f, 0.03090598f, -0.08079850f, 0.02366157f, -0.07545812f, 
    0.20130122f, 0.07622715f, -0.04287941f, -0.04979284f, -0.03036456f, 0.13565713f, 0.13613009f, 0.11303840f, 
    0.06971104f, 0.07200646f, 0.01082420f, 0.14933541f, -0.05445284f, -0.00501755f, -0.01220012f, 0.02585098f, 
    0.09737412f, 0.16887946f, 0.12652217f, -0.05645324f, 0.15453067f, -0.15551932f, 0.09388844f, 0.11397742f, 
    0.00632145f, -0.07155038f, 0.07124534f, 0.10197560f, -0.50366420f, 0.11290498f, 0.04600775f, -0.28257194f, 
    0.10736269f, 0.06977400f, -0.03105021f, 0.07993276f, 0.12976910f, 0.03286532f, 0.06388956f, -0.04646428f, 
    -0.07629038f, -0.39669910f, 0.03841803f, 0.03256659f, 0.01107949f, -0.05525446f, -0.05571826f, 0.05580750f, 
    0.10712069f, 0.04892674f, 0.04948438f, 0.09785399f, 0.29512882f, 0.04564666f, 0.07664338f, 0.01823547f, 
    -0.03581826f, 0.09784254f, 0.09698479f, 0.04892148f, -0.05812801f, 0.00000220f, 0.02427864f, 0.20779750f, 
    -0.02739218f, 0.02889047f, -0.04195773f, -0.06096833f, -0.03917974f, -0.00124571f, 0.01725665f, -0.01002490f, 
    0.04004531f, 0.00106211f, 0.03432499f, 0.01231001f, 0.02405372f, 0.00114301f, -0.05526608f, -0.04082463f, 
    -0.01728721f, 0.03548331f, 0.02323364f, 0.03332559f, 0.02207390f, -0.00547591f, -0.03281543f, 0.02566024f, 
    0.03271887f, 0.00858023f, 0.02788177f, 0.03076600f, -0.03514897f, 0.02995820f, -0.03287243f, -0.05071124f, 
    -0.04830054f, 0.02780484f, 0.02005997f, -0.05549707f, -0.04574507f, 0.03728452f, -0.01529927f, -0.01295696f, 
    -0.04321140f, 0.00568243f, 0.01715961f, -0.01728388f, -0.01427570f, 0.01766093f, -0.04586279f, 0.03178028f, 
    -0.05163822f, 0.01317201f, -0.03867113f, -0.00829564f, -0.04657458f, 0.03360419f, -0.01479501f, -0.03273810f, 
    -0.02629142f, 0.00782924f, 0.01374597f, 0.00976633f, 0.02799033f, -0.00194080f, -0.01003640f, -0.02327154f, 
    0.03591606f, 0.03139570f, 0.02793505f, -0.04059531f, 0.01682639f, -0.01693988f, -0.03124079f, -0.06184348f, 
    0.03594425f, 0.02630224f, -0.03402413f, -0.00068105f, -0.05421733f, -0.00529757f, 0.02645147f, -0.03730261f, 
    -0.03304723f, 0.00147456f, -0.03704685f, 0.00463641f, -0.02554828f, 0.03758517f, -0.02990906f, -0.04295714f, 
    -0.00460368f, 0.02410012f, 0.02050549f, -0.04714684f, -0.00509019f, 0.00100530f, 0.01290535f, 0.01133363f, 
    -0.02881700f, 0.03627478f, 0.01984352f, -0.03297001f, -0.02680619f, -0.03787764f, 0.01665760f, -0.01802926f, 
    -0.02813072f, 0.01681441f, -0.00841173f, -0.04588522f, -0.05523402f, -0.05596042f, 0.00323912f, -0.01282006f, 
    0.02572311f, -0.03787696f, 0.03805819f, -0.00187345f, 0.02206948f, -0.05747625f, -0.00471954f, -0.03402421f, 
    -0.04988250f, -0.05776353f, 0.00990142f, 0.00381896f, -0.02639252f, 0.00898472f, -0.02783483f, -0.02203539f, 
    0.00902113f, -0.00397477f, -0.04952861f, 0.00648847f, -0.04953166f, -0.02585395f, -0.05086837f, 0.03730595f, 
    0.00993102f, 0.00080290f, -0.01623023f, -0.04118574f, -0.03397537f, -0.01601965f, -0.02421853f, 0.03800361f, 
    0.00140924f, 0.01234055f, -0.00039713f, -0.00649565f, 0.00951506f, 0.01672458f, -0.03520785f, 0.02907938f, 
    -0.01613618f, -0.05955167f, -0.05100022f, -0.01241533f, -0.00433243f, -0.02515468f, 0.00980873f, -0.00245372f, 
    -0.02383695f, -0.01715809f, 0.00831226f, 0.01555464f, -0.02736949f, -0.02873272f, 0.00971986f, 0.03401137f, 
    -0.03085978f, 0.00208793f, -0.04956481f, -0.02257821f, 0.01338017f, -0.04330241f, 0.01231592f, -0.00402599f, 
    -0.01983742f, -0.00613161f, -0.00937197f, -0.02832827f, -0.05148487f, -0.04261094f, -0.03631188f, -0.00026009f, 
    -0.04449569f, -0.02961023f, -0.01529361f, 0.00737765f, -0.00265872f, -0.00228229f, -0.04617630f, -0.05083684f, 
    -0.03329156f, -0.01860054f, -0.04561838f, -0.03747958f, 0.02646969f, -0.03881352f, 0.02066994f, -0.04682047f, 
    0.01066361f, 0.04217775f, 0.00651273f, -0.04329944f, 0.04124286f, -0.04438992f, 0.00627683f, 0.01194139f, 
    -0.01938336f, -0.04987174f, -0.04753349f, 0.02830974f, 0.00422974f, 0.02349022f, 0.01175964f, 0.04004633f, 
    0.00590485f, -0.01720573f, 0.04070888f, 0.00499869f, 0.03121896f, -0.01768781f, -0.05505280f, -0.04218359f, 
    0.00815098f, -0.05546540f, -0.04774647f, -0.03844068f, 0.00299371f, -0.02832843f, -0.04911615f, 0.02994619f, 
    -0.05076879f, -0.02878959f, 0.01992862f, 0.03252552f, -0.04087046f, -0.00633263f, 0.00214402f, 0.00835759f, 
    0.00557902f, -0.05155215f, -0.02188184f, 0.00348571f, -0.00621926f, 0.00230902f, -0.05867465f, -0.01715446f, 
    0.03213617f, -0.02549918f, 0.03192329f, -0.05788980f, 0.00544194f, -0.00975291f, -0.05629687f, 0.00801022f, 
    -0.05428028f, -0.02228183f, -0.05505097f, -0.03217822f, 0.00124517f, 0.03310085f, -0.01828172f, 0.03719947f, 
    -0.02994644f, -0.00507366f, -0.01174763f, -0.00721807f, -0.01698509f, -0.04402319f, 0.00687032f, -0.04729219f, 
    0.01991079f, 0.01855031f, -0.00898653f, 0.01149612f, -0.05166258f, 0.01471171f, -0.01412927f, -0.00173680f, 
    -0.02103125f, 0.01386490f, -0.02204848f, 0.00866598f, -0.01019203f, -0.05959446f, -0.04571142f, -0.04568657f, 
    0.01657182f, 0.03229849f, -0.01244591f, -0.02547372f, -0.00448783f, -0.01706438f, 0.00545480f, -0.00883646f, 
    -0.03199796f, -0.05561041f, 0.03362007f, -0.00375901f, 0.00308230f, -0.02306076f, -0.04950748f, -0.03173355f, 
    -0.03404198f, -0.02605970f, 0.01808011f, -0.01817529f, 0.03589704f, -0.03347284f, 0.02690666f, -0.00891924f, 
    -0.00163855f, 0.02671439f, -0.01751125f, 0.02150313f, 0.03264549f, -0.05760521f, -0.05513754f, -0.05715354f, 
    -0.02806114f, -0.05900695f, 0.01248251f, -0.03870586f, -0.02681451f, -0.03046065f, -0.00281835f, 0.02996040f, 
    -0.03693430f, -0.00598712f, -0.04006404f, -0.01511559f, 0.01453537f, 0.02574918f, 0.03170124f, -0.04917001f, 
    0.02021562f, 0.01781510f, -0.05880314f, 0.02036840f, 0.00248824f, 0.02237234f, 0.03067660f, -0.04769736f, 
    -0.00254384f, 0.02924216f, -0.02900837f, -0.03008095f, 0.00713875f, -0.05239242f, -0.01292144f, 0.00381199f, 
    -0.01750121f, 0.02773406f, 0.00208821f, 0.00939587f, -0.04093741f, -0.00266338f, 0.01772487f, -0.00740120f, 
    0.01961347f, 0.02973044f, 0.03436618f, -0.01986548f, -0.02113310f, -0.03654645f, -0.03670267f, 0.02023070f, 
    -0.00216116f, -0.01830109f, 0.01792421f, -0.00552741f, 0.00900512f, 0.02969677f, 0.02970786f, 0.01681153f, 
    0.01442951f, -0.01579296f, 0.03853600f, -0.05628388f, 0.02591169f, -0.01743810f, 0.00285419f, 0.03208880f, 
    -0.05045960f, -0.02604906f, -0.03965305f, -0.05576249f, -0.04268706f, 0.01921759f, -0.03715323f, -0.05290932f, 
    -0.04996342f, -0.01597515f, 0.00526161f, 0.01903651f, 0.03140077f, -0.01603945f, 0.03715368f, 0.03317142f, 
    0.01370686f, -0.00908351f, 0.02848668f, -0.03239239f, 0.02991961f, -0.00321189f, 0.03638268f, -0.00423476f, 
    -0.00983301f, 0.00281602f, -0.00432769f, 0.03486877f, -0.03918105f, -0.05499399f, -0.05278664f, 0.03020293f, 
    0.00945270f, 0.02756206f, -0.04943516f, 0.04249898f, -0.05159661f, 0.03712640f, -0.04232344f, -0.02241127f, 
    0.01277319f, 0.03349489f, -0.02145860f, 0.03551549f, -0.02954824f, -0.04664968f, 0.03592319f, -0.00063202f, 
    -0.01007504f, 0.03151018f, -0.05270425f, -0.04433668f, 0.03017124f, 0.00543157f, 0.00384017f, -0.04199653f, 
    -0.03464076f, -0.01355884f, 0.03493472f, -0.04570536f, 0.04443148f, -0.05554456f, -0.01817995f, -0.01138222f, 
    -0.04601222f, -0.04106957f, 0.00425250f, -0.02461843f, -0.03120483f, 0.04134893f, -0.02913155f, 0.01299185f, 
    -0.02596629f, 0.04232558f, 0.00495679f, -0.00467071f, -0.01424885f, 0.00484163f, 0.02935097f, 0.02328641f, 
    0.04424166f, -0.02365655f, 0.00688250f, -0.05453141f, 0.03887271f, -0.01167643f, 0.01396704f, -0.00876354f, 
    -0.04885127f, 0.02506592f, 0.01824846f, -0.02045297f, 0.01291614f, 0.03057885f, 0.00060824f, -0.00572081f, 
    -0.04788385f, -0.04297439f, -0.02396364f, 0.01471044f, 0.03985832f, 0.02294777f, 0.04300642f, -0.04621614f, 
    -0.04176589f, -0.02639052f, 0.02909475f, -0.04682320f, -0.05439796f, -0.03544722f, -0.05475991f, -0.04964383f, 
    -0.05239043f, -0.01395569f, -0.04416730f, -0.01435142f, 0.01877446f, 0.03086416f, -0.00103261f, -0.04738044f, 
    0.02446149f, 0.03054013f, -0.02403238f, 0.00298046f, 0.01491995f, 0.02612838f, 0.02292801f, -0.02828986f, 
    0.00990704f, -0.04003659f, -0.01000414f, -0.05423806f, -0.04975792f, -0.03271555f, -0.01911637f, -0.01648440f, 
    -0.00750089f, 0.04425083f, -0.03473706f, -0.00086700f, -0.03624202f, 0.00983580f, -0.03202048f, -0.03350148f, 
    0.01526051f, -0.00609709f, -0.04591862f, 0.01303653f, -0.01855866f, -0.01463241f, -0.02513396f, 0.03828234f, 
    0.02453254f, 0.00681293f, -0.02785417f, -0.02946790f, -0.00165065f, -0.02169271f, -0.01065330f, -0.02719406f, 
    -0.00843263f, 0.03830736f, -0.05646637f, 0.03591169f, -0.02935607f, -0.02214473f, -0.00104636f, -0.02521446f, 
    -0.02884061f, -0.02628297f, -0.00295221f, 0.01990187f, 0.00079162f, -0.01263700f, 0.04062292f, 0.00068987f, 
    -0.00667320f, 0.00244421f, 0.01818780f, -0.04773858f, 0.03913296f, -0.03846254f, 0.00697520f, 0.04530767f, 
    -0.01376870f, 0.00334059f, -0.03966920f, 0.02103926f, -0.00501746f, 0.01701707f, 0.04533680f, -0.00638959f, 
    -0.02561652f, -0.02515573f, -0.05158631f, 0.02249897f, -0.01139169f, -0.01630413f, -0.01498474f, 0.03237146f, 
    0.01317293f, -0.05454127f, -0.00427502f, 0.02000377f, 0.02234971f, -0.05361843f, 0.00512053f, -0.01451780f, 
    -0.01478032f, 0.05009725f, -0.02584188f, -0.01800397f, 0.04151192f, -0.03161517f, -0.03693125f, 0.00221190f, 
    -0.05539463f, 0.00384643f, -0.04320614f, 0.04457888f, -0.04466251f, -0.01307538f, 0.04559654f, -0.00346647f, 
    0.03059595f, 0.02349987f, -0.00935665f, -0.05392267f, -0.02163873f, -0.02703464f, -0.02570411f, 0.02425171f, 
    0.00153570f, 0.02428907f, -0.05550525f, -0.02238689f, 0.01685801f, -0.00749409f, 0.00816099f, 0.01351898f, 
    -0.00288561f, 0.00926857f, -0.03765203f, 0.02707664f, -0.01820569f, 0.03763307f, 0.01303210f, 0.03449487f, 
    0.01790410f, 0.00143130f, -0.01172609f, -0.03666532f, -0.00145425f, -0.02876910f, -0.02811742f, 0.02448382f, 
    -0.02884061f, -0.03460132f, -0.05362296f, -0.05320304f, 0.01327312f, 0.02038176f, 0.00954434f, -0.01438769f, 
    -0.00161250f, 0.01396200f, -0.02723020f, -0.04879784f, 0.02801971f, -0.03104624f, -0.01279019f, -0.05336078f, 
    0.02736348f, 0.02120086f, 0.00865922f, -0.01876351f, -0.00446464f, -0.03768066f, -0.03637888f, 0.00259613f, 
    -0.04638502f, -0.00202404f, -0.02795792f, -0.03200763f, 0.00884697f, -0.01361239f, 0.03239496f, 0.01100956f, 
    -0.02194664f, 0.01625475f, 0.04418804f, -0.05038222f, 0.04498052f, 0.01115333f, 0.02491492f, -0.04267459f, 
    -0.01991347f, 0.00681897f, -0.04148070f, -0.03398896f, -0.01448874f, -0.05070082f, 0.02309646f, 0.03570262f, 
    -0.00564836f, 0.00135086f, -0.01240283f, -0.03122276f, -0.04889613f, -0.03211910f, -0.01300803f, 0.00148386f, 
    0.00703553f, 0.03265636f, -0.04715866f, -0.03304844f, 0.01133151f, -0.02198423f, -0.00943985f, -0.01382661f, 
    -0.03114774f, -0.05469421f, -0.00169951f, 0.01544182f, 0.00057757f, 0.01874723f, -0.02238144f, -0.03060683f, 
    0.04221865f, 0.01236602f, -0.04299486f, 0.02190005f, -0.01223014f, -0.05267265f, 0.01342599f, -0.01471282f, 
    0.03708677f, -0.03509960f, -0.03087042f, -0.02092998f, -0.00853392f, 0.04230152f, -0.02309159f, -0.04076226f, 
    -0.04438415f, -0.03332799f, -0.04222241f, 0.03124146f, 0.02304622f, 0.04274848f, -0.04045179f, 0.02759140f, 
    -0.03362316f, -0.00795958f, -0.00313530f, -0.01752715f, -0.02725925f, -0.00019061f, -0.00342064f, -0.01860499f, 
    -0.02573263f, -0.01270090f, -0.05275322f, 0.03869696f, -0.03655616f, -0.03379567f, 0.04942023f, -0.00391256f, 
    0.02765532f, 0.01987338f, 0.00617253f, -0.01239322f, -0.03847416f, 0.03928376f, -0.04039684f, -0.00712305f, 
    0.00904559f, -0.02522878f, 0.04406458f, 0.03073262f, 0.01793377f, -0.02268350f, 0.04337337f, 0.02426387f, 
    0.10235105f, 0.05394834f, -0.09138536f, -0.07707942f, -0.02548529f, -0.00159224f, 0.02230704f, 0.01678245f, 
    0.11065369f, -0.01612096f, 0.07978401f, -0.05021875f, -0.08174433f, -0.10709943f, 0.02106037f, -0.11676966f, 
    -0.00531184f, 0.08829122f, 0.11299825f, -0.08840839f, -0.01675914f, 0.02811378f, 0.03431679f, 0.03333243f, 
    0.27382857f, 0.21201794f, 0.11285274f, 0.09623589f, -0.03263805f, -0.05503204f, -0.02485157f, 0.02341856f, 
    0.12535781f, 0.14603399f, 0.10107199f, 0.18348865f, -0.23165560f, 0.08902498f, 0.15541252f, 0.08310272f, 
    0.10601725f, -0.02212119f, -0.07605261f, -0.14680889f, 0.03939600f, 0.06036213f, 0.13277470f, 0.08659653f, 
    -0.08780328f, 0.11904921f, 0.17444655f, 0.11439865f, -0.06233802f, -0.01179240f, -0.03394233f, -0.01112284f, 
    -0.05785275f, -0.01746669f, 0.10254613f, -0.05441263f, 0.08611130f, 0.03039125f, -0.22710380f, -0.06739412f, 
    -0.08135053f, -0.02059911f, 0.08403424f, -0.06569253f, -0.16925566f, -0.17652382f, -0.00357630f, -0.03369928f, 
    0.24152003f, -0.05515137f, -0.02788613f, -0.09341551f, 0.01666534f, -0.02080385f, 0.08892738f, 0.00074659f, 
    0.01694905f, 0.01920652f, -0.07319780f, 0.01185279f, 0.07949533f, 0.11306278f, 0.11652759f, 0.23782486f, 
    0.07837559f, 0.05730821f, -0.04714026f, -0.08108525f, -0.06985349f, -0.00520756f, -0.03509888f, 0.05776729f, 
    0.14454052f, 0.09923871f, -0.13105421f, 0.00511003f, -0.04290512f, -0.05868483f, -0.17422736f, -0.13487279f, 
    0.11845101f, -0.02583241f, -0.06435046f, -0.02773018f, -0.10697327f, -0.09179561f, -0.10860110f, -0.27411610f, 
    -0.06716756f, 0.06686513f, -0.06374609f, 0.12887342f, 0.08887907f, 0.07441660f, -0.04347135f, 0.13321754f, 
    0.10940309f, 0.07855552f, 0.08048005f, 0.00048276f, 0.01529188f, 0.04304485f, 0.03539434f, -0.13701977f, 
    -0.10983561f, 0.14068763f, 0.02222683f, 0.10893477f, -0.11530475f, -0.03343305f, -0.10816572f, -0.16540651f, 
    -0.08767382f, 0.09498375f, 0.01721155f, -0.03536326f, 0.00876760f, -0.12554665f, 0.19782209f, 0.09184341f, 
    -0.07131821f, 0.03398852f, 0.20756032f, 0.00087344f, 0.11592522f, 0.00700112f, 0.01294432f, -0.14096041f, 
    0.07530731f, -0.03426986f, -0.01129720f, -0.00685363f, -0.21098223f, -0.04112621f, 0.09351417f, 0.00896617f, 
    -0.04639491f, 0.00993874f, 0.03306486f, -0.09457332f, 0.09841622f, 0.01865034f, 0.18191442f, 0.15873221f, 
    -0.38930964f, 0.17368476f, -0.16832221f, -0.08185289f, 0.06584175f, -0.04404704f, -0.03866399f, -0.18673956f, 
    0.03585557f, -0.03667540f, -0.02716307f, -0.00658032f, 0.26094440f, 0.04998003f, -0.17100772f, 0.00014149f, 
    0.06523652f, -0.01431936f, 0.01446974f, -0.01344229f, 0.14905740f, 0.05234542f, -0.06629512f, -0.02056496f, 
    0.14957409f, -0.12166537f, 0.27563584f, -0.07213025f, -0.06051248f, 0.09389156f, -0.04305485f, 0.05204051f, 
    0.01233366f, -0.11750124f, -0.01868883f, 0.03598851f, -0.23008491f, -0.01046653f, -0.10008833f, -0.20681684f, 
    0.05965947f, 0.15144086f, -0.00349364f, 0.06114481f, 0.02391913f, -0.19153830f, 0.03104801f, -0.19896272f, 
    -0.29100049f, 0.02601498f, 0.07529660f, 0.11432295f, -0.03182007f, 0.00542328f, -0.00696104f, 0.03099183f, 
    0.09844022f, 0.04936443f, -0.04003343f, 0.07930290f, 0.44541207f, 0.20580091f, 0.06049489f, 0.20927030f, 
    0.09386104f, 0.07881123f, -0.12867187f, -0.02317246f, 0.02043950f, -0.02828106f, 0.07051624f, -0.06962746f, 
    0.13830781f, 0.02487407f, -0.19898327f, -0.17191316f, 0.03101373f, 0.00393517f, 0.11872119f, -0.08322852f, 
    -0.02500203f, -0.02320657f, 0.08794697f, 0.06308521f, 0.05627774f, -0.21301933f, -0.06380147f, -0.09942150f, 
    -0.01715843f, -0.08389194f, -0.01582841f, -0.03439822f, -0.03819837f, 0.05298484f, -0.15193318f, -0.03009411f, 
    0.09874688f, -0.13998045f, -0.10750549f, 0.03276162f, -0.04159606f, 0.04059558f, -0.13010161f, 0.15914799f, 
    0.04776973f, 0.10291393f, 0.01787434f, -0.09009921f, -0.06733736f, 0.08535398f, 0.01082885f, -0.14344980f, 
    0.09803141f, 0.03246116f, -0.13772024f, 0.16556777f, 0.06731908f, -0.04435211f, 0.16557704f, 0.05701479f, 
    0.25168860f, 0.00627152f, 0.04037118f, 0.18274480f, 0.12295979f, -0.10238487f, -0.01572074f, -0.00393677f, 
    0.04189076f, -0.01448930f, -0.03848016f, 0.05383352f, -0.01669354f, -0.19579901f, -0.06767935f, -0.14775142f, 
    0.02472161f, -0.02175062f, -0.03563199f, -0.01435519f, 0.10734889f, -0.03323092f, 0.11214311f, -0.00070277f, 
    0.31922504f, -0.17206939f, 0.19950436f, 0.17932552f, -0.10243679f, -0.06208983f, -0.04066115f, 0.02395443f, 
    -0.00434049f, -0.00765944f, -0.07016318f, -0.08128693f, 0.02705774f, -0.14406916f, -0.04969051f, 0.05507055f, 
    0.07641426f, 0.03072045f, -0.05537340f, 0.06642899f, -0.04526133f, 0.08555786f, -0.03163316f, -0.15954453f, 
    -0.10262728f, -0.04677365f, 0.06276000f, 0.03293897f, -0.01918605f, -0.23070753f, 0.14795481f, 0.07631739f, 
    -0.03369723f, 0.01107149f, 0.12016631f, 0.00196078f, 0.11132868f, 0.34725025f, 0.08095473f, 0.17903905f, 
    -0.05266010f, 0.06723089f, -0.11203450f, -0.05695327f, 0.06974219f, 0.06236034f, 0.06844423f, -0.21145786f, 
    0.22456124f, -0.19372113f, 0.28578123f, 0.17809983f, -0.07784650f, -0.01050736f, -0.13709305f, 0.02755089f, 
    0.13988526f, 0.08542886f, 0.07652941f, 0.07146107f, 0.09474419f, 0.25209659f, 0.04250748f, 0.06967897f, 
    0.05453700f, 0.00835643f, -0.04814713f, 0.04638475f, -0.08390288f, -0.02800130f, 0.00742583f, 0.29302108f, 
    -0.01962064f, -0.03390017f, 0.01732505f, 0.04243686f, -0.05015589f, 0.03518926f, 0.03707330f, -0.04980310f, 
    -0.01040942f, -0.03225220f, -0.05894956f, -0.03014936f, -0.05203582f, -0.00087662f, 0.03514091f, 0.02800703f, 
    -0.00789455f, -0.02384294f, 0.01767445f, 0.00759915f, 0.02245079f, -0.02796390f, -0.00126569f, 0.01736944f, 
    0.00892831f, 0.01359181f, -0.02720433f, 0.02368762f, -0.05890166f, -0.05597290f, -0.00143553f, -0.02682623f, 
    0.03541379f, -0.03010829f, 0.01467061f, 0.03998828f, -0.05080412f, 0.03126514f, 0.02012357f, -0.01825159f, 
    0.02407981f, -0.04843562f, -0.05055161f, 0.00388263f, -0.03411711f, -0.00100330f, 0.02868584f, 0.01931008f, 
    0.03452139f, -0.02962387f, -0.00175865f, 0.01321213f, -0.02182487f, -0.04988708f, -0.02597071f, -0.01187839f, 
    -0.03762287f, -0.02019136f, 0.04035309f, -0.01968277f, -0.01123034f, -0.03911541f, -0.00487570f, 0.02554158f, 
    -0.01508584f, 0.02750868f, -0.04896111f, 0.04063088f, 0.01558591f, 0.02276178f, 0.02300761f, 0.01158099f, 
    -0.03340317f, -0.03332800f, -0.03515884f, -0.02821714f, -0.01567966f, -0.04651884f, 0.00146725f, -0.03644582f, 
    0.02151477f, -0.02052233f, 0.01215015f, -0.04117644f, 0.01403066f, 0.03546368f, 0.02571802f, -0.05362558f, 
    -0.04430754f, -0.04254165f, -0.00622843f, -0.02778607f, 0.04069585f, -0.00784064f, 0.02501499f, 0.01398032f, 
    0.02714806f, -0.05683412f, -0.04350125f, -0.01162169f, 0.03196957f, -0.05419996f, 0.00533406f, 0.01263543f, 
    0.01747945f, 0.00704319f, 0.01753427f, -0.02699286f, -0.04547993f, -0.00533586f, -0.01693522f, 0.00511777f, 
    -0.05247614f, -0.03784266f, 0.00139925f, 0.00950858f, 0.02198270f, -0.04945894f, 0.01794984f, 0.03236816f, 
    0.00066448f, -0.05341031f, -0.03239674f, -0.01345273f, -0.02684323f, -0.00607349f, -0.03481944f, -0.00590994f, 
    -0.01820982f, 0.02296617f, -0.04619933f, 0.03222446f, -0.00696919f, -0.00367653f, -0.02191818f, -0.03857822f, 
    -0.04118763f, -0.00187070f, -0.02797732f, -0.02292423f, 0.01221990f, 0.03459070f, 0.04007228f, -0.00682116f, 
    -0.02341660f, -0.05780084f, -0.00736928f, -0.03400608f, 0.02341933f, 0.01904237f, 0.03371406f, -0.00440933f, 
    -0.00630658f, 0.01891340f, -0.02157166f, -0.02533034f, 0.01400482f, -0.02876146f, 0.01402873f, 0.01272064f, 
    -0.03527061f, -0.01195525f, -0.04837081f, -0.02481015f, -0.04139938f, 0.01683234f, 0.02446932f, -0.05838386f, 
    -0.03360155f, -0.01929748f, -0.05174306f, -0.01226490f, 0.02264089f, 0.03124966f, -0.01567633f, -0.05414511f, 
    -0.03454554f, 0.01824515f, 0.02482996f, -0.04271850f, -0.01537089f, -0.04400957f, -0.05220471f, -0.01581167f, 
    -0.02988080f, -0.02237920f, 0.00698227f, 0.00325592f, -0.03272167f, 0.04104488f, 0.03745393f, -0.04633959f, 
    -0.00720534f, 0.02002092f, 0.04059392f, -0.01269680f, 0.01605773f, 0.03926928f, 0.02344551f, -0.03191163f, 
    -0.02514841f, -0.04232546f, 0.02071908f, 0.01197346f, -0.05356542f, 0.02112116f, -0.00004153f, -0.04633970f, 
    0.02525004f, -0.01370453f, -0.02124285f, 0.02833291f, 0.02036629f, 0.00268675f, 0.00740863f, 0.01480101f, 
    0.01760713f, 0.00456476f, -0.04016707f, -0.05319640f, 0.00147588f, -0.03910659f, 0.03577882f, 0.03707734f, 
    -0.00690489f, 0.01698214f, -0.03125581f, 0.02225150f, -0.01731495f, 0.00773517f, -0.00917405f, 0.03316935f, 
    0.02195910f, -0.01862192f, -0.05323844f, -0.05128688f, -0.04530456f, 0.01802425f, 0.01755805f, -0.03386547f, 
    0.01759475f, 0.00250291f, 0.02105167f, 0.04006870f, 0.03829898f, -0.05683917f, -0.02868769f, -0.01330462f, 
    0.00445354f, 0.03584412f, -0.02376514f, 0.02072740f, -0.04050466f, -0.02970455f, -0.02398545f, 0.02887674f, 
    0.03945329f, -0.00575706f, -0.03230786f, -0.04262679f, 0.01445189f, -0.02136980f, -0.02915945f, -0.04488580f, 
    0.00587666f, 0.04097811f, -0.01630409f, -0.05374862f, -0.01265317f, -0.02850533f, -0.02458965f, 0.03833335f, 
    -0.04123707f, -0.02315360f, -0.00039089f, 0.03444939f, -0.05480415f, -0.01309337f, -0.03293802f, -0.05106858f, 
    0.02848726f, 0.03295530f, -0.00719381f, 0.03646779f, -0.00693543f, 0.02693970f, 0.02715467f, -0.05683673f, 
    -0.02483528f, 0.03842834f, 0.03139753f, 0.00789266f, -0.00052388f, 0.02153486f, 0.03149272f, 0.01755995f, 
    -0.02247671f, -0.05276694f, -0.00970670f, -0.05095237f, -0.03514621f, 0.00995845f, -0.02927851f, -0.00630240f, 
    -0.02094739f, -0.03104838f, -0.01007455f, 0.03837711f, -0.02670321f, -0.00329482f, 0.00670941f, 0.03126558f, 
    0.03162831f, -0.04524579f, 0.00682598f, 0.01461243f, 0.02098892f, 0.04079802f, -0.05453672f, -0.02632423f, 
    -0.03884819f, 0.02707021f, 0.01859763f, -0.02939469f, 0.00535127f, -0.01636239f, 0.00780573f, -0.00131525f, 
    0.00494428f, 0.01795816f, -0.03432797f, -0.00599150f, 0.03339661f, -0.04725219f, -0.03214292f, -0.03150975f, 
    0.01297208f, 0.01166364f, 0.02428242f, -0.02299181f, 0.03238655f, 0.00124691f, 0.02588494f, 0.03150922f, 
    0.02082212f, 0.04241449f, -0.01803026f, 0.02992250f, -0.03387499f, -0.01019657f, 0.02543054f, 0.03234712f, 
    -0.02201643f, -0.00761451f, -0.01407715f, -0.00156508f, -0.00554340f, -0.01865312f, -0.05466096f, -0.03765353f, 
    -0.03691787f, -0.05036073f, -0.03775574f, -0.04108696f, -0.02987569f, -0.02366950f, -0.05697333f, 0.01645573f, 
    -0.02380551f, -0.03817817f, -0.04737780f, -0.02083242f, -0.04461601f, -0.01311703f, -0.04656716f, -0.03512961f, 
    0.02281703f, 0.02533174f, -0.01987313f, 0.01206382f, -0.01987058f, -0.02727110f, 0.00846918f, -0.03760969f, 
    -0.04880600f, -0.04077061f, 0.03883298f, 0.00745591f, 0.03965592f, 0.00021652f, -0.00372720f, 0.00322377f, 
    -0.03955529f, -0.00223193f, -0.00175129f, 0.02954586f, -0.02107315f, -0.01396082f, -0.00898305f, 0.02274721f, 
    0.02717544f, -0.03697589f, 0.03167448f, -0.04585402f, -0.04745135f, -0.00981894f, -0.02773794f, -0.00968526f, 
    -0.04311372f, 0.03462601f, -0.03445120f, -0.02410005f, 0.02389804f, 0.02803899f, 0.03832466f, -0.03004574f, 
    -0.04488014f, -0.02599202f, -0.00217223f, -0.05154322f, -0.03166355f, 0.03312436f, -0.01138519f, 0.03514726f, 
    0.03616199f, 0.02768193f, -0.04053177f, -0.02075623f, 0.00462171f, -0.01908694f, 0.02439843f, 0.04007414f, 
    -0.02592094f, -0.04126253f, -0.00806997f, 0.01771485f, -0.01544838f, 0.02740923f, -0.05730976f, 0.00373001f, 
    0.02562705f, 0.02547763f, -0.02007065f, -0.05268914f, 0.00138051f, 0.02345338f, 0.00113170f, -0.00524140f, 
    0.02742800f, -0.03167919f, -0.03224380f, -0.01697835f, 0.01053096f, -0.03968120f, 0.03400804f, 0.00399624f, 
    -0.02842741f, 0.03231291f, -0.00138945f, 0.01165562f, 0.00641567f, -0.05342345f, 0.04060024f, 0.00783595f, 
    -0.05794964f, -0.01920329f, 0.04358806f, -0.02866324f, -0.01790572f, -0.02578769f, -0.00243194f, 0.02823420f, 
    -0.02001719f, 0.01712040f, 0.00139172f, -0.03454051f, 0.02284748f, -0.04102962f, -0.01627252f, -0.00209770f, 
    -0.01659096f, 0.02452370f, -0.01270735f, -0.02128679f, -0.00069885f, -0.05606939f, -0.02840850f, -0.01791068f, 
    -0.05587059f, 0.00303576f, -0.00375586f, -0.02845905f, -0.01724030f, -0.01799945f, -0.01489319f, -0.01535406f, 
    0.00918318f, 0.02534691f, -0.02387255f, 0.02442588f, 0.01055391f, 0.01900517f, 0.03698273f, -0.01126683f, 
    -0.04363991f, -0.00730312f, -0.04743594f, -0.02728412f, 0.00988284f, 0.03517311f, 0.05202305f, 0.02554097f, 
    -0.03840598f, -0.00252065f, 0.03728045f, -0.05412332f, 0.00313317f, -0.01243292f, -0.00869891f, -0.02964091f, 
    -0.01072199f, -0.04866509f, 0.03355730f, -0.01735806f, 0.00215499f, -0.01269006f, 0.01551299f, -0.06123012f, 
    0.04925910f, 0.00774561f, -0.02003798f, 0.03271525f, 0.02737040f, -0.04356400f, -0.03124830f, -0.02488893f, 
    -0.05182773f, 0.01598102f, 0.03474495f, 0.01675465f, 0.01687349f, -0.03819476f, -0.02810742f, -0.02088152f, 
    0.03167428f, -0.00862884f, -0.00142857f, 0.03967993f, -0.00125327f, -0.02713858f, -0.02880890f, 0.03322259f, 
    -0.03999924f, 0.03013804f, -0.02021395f, -0.04184503f, 0.05031865f, 0.03811529f, 0.02331707f, 0.01116373f, 
    -0.00422638f, -0.03560206f, -0.00064995f, 0.01104271f, 0.04434745f, 0.02819200f, -0.04045849f, -0.01684055f, 
    -0.00600179f, 0.01386989f, 0.00468705f, 0.01661954f, -0.04452447f, -0.04090776f, -0.03478981f, 0.04026664f, 
    -0.03632976f, 0.00784285f, -0.01724453f, -0.06280945f, -0.02775726f, 0.01044427f, 0.02304955f, -0.04976001f, 
    -0.01802641f, 0.00004234f, -0.03464153f, -0.02629783f, 0.01812456f, 0.00692491f, 0.00859327f, -0.04501623f, 
    -0.04016001f, -0.02268873f, -0.00656899f, 0.02266421f, 0.04361423f, 0.01100666f, -0.02125754f, -0.03695970f, 
    -0.03968238f, 0.01860369f, 0.03377609f, 0.02492731f, 0.02695335f, -0.04973793f, 0.03535138f, 0.03665232f, 
    0.00740797f, -0.01302199f, -0.05589598f, -0.00456696f, 0.01224127f, 0.00835907f, 0.01173110f, -0.01493927f, 
    -0.02412251f, 0.00194441f, -0.05296614f, -0.03779866f, 0.01621750f, -0.00367372f, 0.03873258f, -0.01754966f, 
    0.01616969f, -0.00944956f, 0.00654986f, -0.03560197f, -0.05869900f, -0.01272634f, 0.02320355f, 0.00480018f, 
    -0.00474739f, 0.03142139f, -0.00975324f, -0.00770997f, 0.03394179f, 0.01734539f, -0.03171793f, -0.03192764f, 
    -0.04301992f, 0.01312680f, 0.00188494f, -0.01013521f, 0.01002933f, 0.02281975f, -0.01654106f, -0.03402276f, 
    0.04180226f, -0.02229884f, -0.01736533f, -0.00952457f, -0.05438375f, -0.03239587f, -0.01651098f, 0.03285963f, 
    -0.05118783f, -0.03325967f, 0.00811620f, 0.02601285f, -0.01833789f, 0.01441021f, 0.01530758f, -0.01703757f, 
    0.02994157f, 0.00840143f, -0.03844623f, -0.01931188f, 0.03567867f, -0.04004028f, 0.01462877f, 0.01674256f, 
    -0.00805425f, 0.02152656f, 0.00913155f, 0.01445539f, -0.02945941f, 0.00305829f, -0.03827475f, -0.04445262f, 
    -0.03108042f, -0.02576890f, 0.02324438f, -0.02048347f, 0.03087267f, 0.04235282f, 0.04154204f, 0.00449610f, 
    0.03926282f, 0.01709267f, 0.00505074f, 0.02616575f, 0.02367512f, -0.02862102f, -0.00446185f, 0.02422609f, 
    0.02718202f, -0.02963234f, 0.02492380f, -0.04391793f, -0.01360788f, 0.02923121f, 0.02823908f, -0.05395660f, 
    -0.04246785f, -0.03596303f, -0.02919739f, -0.05312207f, -0.01345999f, -0.01538966f, -0.03969476f, -0.05658140f, 
    0.00048427f, 0.00688385f, -0.05380250f, 0.00677477f, 0.03242947f, -0.04210145f, -0.03118357f, 0.01785481f, 
    -0.01154707f, -0.02753732f, 0.01453304f, -0.03287657f, -0.03446090f, 0.00136566f, -0.04985481f, -0.02766144f, 
    0.00350566f, 0.01377062f, -0.00711848f, -0.02394243f, -0.00686854f, -0.02278823f, 0.02789164f, 0.02382353f, 
    0.01902018f, 0.00432238f, -0.01173032f, 0.03476803f, -0.00386362f, 0.03290734f, -0.02579870f, 0.02244494f, 
    -0.05954657f, -0.01393784f, 0.04347206f, -0.02039599f, -0.01483373f, 0.03098741f, -0.02965971f, 0.01694155f, 
    0.01606125f, -0.02805028f, 0.02004984f, 0.03628304f, -0.01463150f, 0.00679021f, -0.04658439f, -0.00161425f, 
    0.03352644f, 0.02718607f, -0.04116847f, -0.05923746f, -0.01341134f, -0.00349826f, -0.02850825f, 0.04703047f, 
    0.05842621f, 0.23537852f, 0.26415601f, -0.15614025f, -0.03001163f, 0.00302499f, 0.14647143f, -0.04546187f, 
    -0.00080869f, -0.04044554f, 0.04145207f, -0.08033582f, -0.05463530f, 0.14870672f, -0.17765310f, -0.02667524f, 
    0.04453212f, 0.04279363f, 0.03122017f, 0.21325925f, -0.01921413f, -0.04286644f, 0.14789648f, 0.03988352f, 
    0.08664547f, -0.05192070f, -0.08726412f, -0.10767332f, 0.13361315f, 0.04964475f, 0.04121887f, -0.03605702f, 
    0.11939817f, 0.06011412f, 0.01662267f, -0.17889091f, 0.01053489f, -0.07346544f, -0.01034125f, 0.37092933f, 
    0.13226527f, 0.06276986f, 0.07019349f, 0.04975109f, -0.11759130f, 0.11712974f, 0.01685495f, 0.03967094f, 
    -0.09923417f, -0.17643155f, -0.13235952f, -0.02901207f, 0.13362876f, 0.01435917f, -0.01905888f, -0.05168619f, 
    -0.05240361f, 0.01512698f, -0.08854790f, 0.07040109f, 0.03195881f, -0.16217163f, -0.15547957f, 0.10319669f, 
    0.01945716f, -0.00470660f, 0.01602997f, -0.01265093f, -0.01006228f, -0.02001159f, 0.01391973f, -0.09015462f, 
    0.05703831f, 0.01497513f, 0.00771578f, -0.09092645f, 0.09175843f, 0.08041601f, -0.01796487f, 0.09065435f, 
    0.02560103f, -0.01905210f, 0.07995558f, 0.03635785f, -0.15293090f, -0.04548149f, -0.12524305f, -0.19584519f, 
    0.00629743f, 0.04695068f, 0.04852429f, 0.00486579f, -0.01962349f, -0.02957736f, -0.06647415f, 0.03511298f, 
    0.34708333f, 0.12201551f, -0.03446700f, 0.35036531f, 0.02847234f, -0.00402267f, 0.01296971f, -0.12219632f, 
    -0.03965044f, -0.00027852f, 0.01229001f, -0.03179895f, 0.02961266f, -0.06459340f, 0.16266184f, -0.23176962f, 
    0.00068435f, -0.10709547f, -0.00958573f, 0.03173963f, 0.02448915f, -0.03963206f, 0.14874849f, -0.03102316f, 
    0.03860144f, 0.10355437f, -0.07377957f, 0.07996384f, 0.08300686f, 0.00957063f, -0.09951300f, -0.13816382f, 
    0.00602087f, 0.04125311f, -0.10761605f, 0.03550833f, 0.01293073f, -0.09438045f, 0.02232092f, 0.16780555f, 
    -0.06857158f, -0.02372257f, 0.08425239f, -0.04756792f, -0.02330799f, -0.07419558f, 0.08989697f, -0.05579781f, 
    -0.12275907f, 0.14456770f, 0.05332078f, 0.21959947f, 0.04099882f, 0.02210768f, 0.08756040f, 0.04910143f, 
    -0.00863151f, 0.05422720f, 0.04875870f, -0.04845663f, -0.24188262f, -0.06213889f, 0.09663262f, 0.22219008f, 
    0.12008444f, 0.03765397f, -0.00652795f, 0.10434201f, -0.07438235f, 0.05761130f, 0.08817241f, 0.03777239f, 
    -0.03544664f, -0.24670181f, 0.06784223f, 0.01542453f, 0.03022430f, 0.10498809f, -0.02682405f, -0.07603247f, 
    -0.03283830f, 0.02358586f, -0.15434849f, 0.07969499f, 0.20088460f, 0.14866677f, 0.08484710f, 0.22752273f, 
    -0.00218637f, 0.02696770f, -0.00371581f, -0.03453366f, -0.15600537f, 0.01638447f, 0.09841595f, -0.11251093f, 
    -0.27937144f, 0.02475701f, 0.13474376f, -0.10500134f, -0.02254937f, -0.05567409f, 0.02167690f, 0.05048477f, 
    0.04987955f, 0.00434813f, -0.05474414f, 0.00447705f, 0.00663467f, 0.23615080f, -0.01037031f, 0.17920023f, 
    0.02303226f, 0.04854092f, 0.11121798f, -0.11859477f, -0.11801371f, -0.08395274f, -0.04693357f, 0.02447580f, 
    0.15080398f, 0.01285360f, -0.01414867f, 0.23161492f, 0.02838461f, -0.00370718f, 0.01698004f, -0.06704026f, 
    0.03750616f, 0.04884924f, -0.04070918f, -0.04468158f, -0.11248213f, 0.02446199f, -0.01864438f, -0.13149628f, 
    0.05609260f, 0.02299854f, 0.05821356f, 0.07746140f, -0.16615184f, -0.02673831f, -0.03552865f, 0.16592376f, 
    -0.29349104f, -0.14632486f, 0.09255904f, -0.01033171f, 0.04450662f, 0.00428517f, 0.02333590f, 0.05295202f, 
    0.08764821f, -0.00445927f, 0.03212954f, -0.04794912f, -0.02923214f, 0.03658129f, 0.04736494f, 0.16986981f, 
    0.06499567f, 0.09008292f, 0.00926680f, -0.04076844f, 0.00195949f, 0.05346155f, -0.02597051f, -0.00626490f, 
    0.03263129f, 0.09124686f, -0.02032568f, 0.09100685f, 0.10247966f, 0.05179179f, -0.04877228f, 0.01606150f, 
    0.07975899f, -0.02739123f, 0.05504262f, -0.00333221f, 0.01868016f, 0.06612614f, 0.10779656f, 0.00130935f, 
    0.12578985f, 0.01993659f, 0.12681209f, -0.03120532f, 0.04454384f, 0.13286409f, 0.15115346f, 0.00762068f, 
    -0.32054806f, 0.01747520f, 0.09531631f, -0.27428669f, -0.01131177f, -0.04150004f, 0.03024896f, -0.06409591f, 
    0.06120146f, -0.02589208f, 0.08018181f, -0.07588606f, 0.02484512f, -0.20500824f, 0.07733307f, 0.03078476f, 
    -0.04685123f, -0.00925719f, -0.00973695f, -0.09291423f, 0.06088787f, 0.06763816f, 0.06361094f, 0.00616535f, 
    -0.42010716f, 0.01801493f, -0.09269999f, -0.08364695f, 0.03950856f, 0.02005952f, 0.00664450f, 0.00480279f, 
    -0.02924533f, -0.05393784f, -0.04515776f, -0.06688432f, 0.02439540f, 0.09107972f, 0.21798985f, 0.10970841f, 
    0.03219015f, 0.00078193f, 0.04431877f, 0.02939982f, -0.00450103f, 0.04036367f, -0.06075199f, -0.19828403f, 
    0.12285003f, 0.03320152f, -0.05085039f, 0.14338890f, 0.03362305f, -0.00493638f, -0.07381605f, 0.05757023f, 
    0.09291908f, 0.11063708f, 0.08127691f, 0.02172918f, -0.31154981f, 0.12129593f, -0.05909287f, 0.06933516f, 
    -0.04181084f, -0.02325659f, 0.07971124f, 0.06164327f, -0.00336387f, -0.05218309f, -0.08991526f, -0.00027750f, 
    0.18620382f, 0.09925293f, 0.10646407f, -0.11687528f, 0.01058325f, 0.03013045f, 0.14250319f, 0.00380581f, 
    0.04291913f, 0.10072868f, -0.00581509f, 0.06064358f, -0.05558026f, -0.03911440f, -0.10696181f, 0.16638571f, 
    -0.00277725f, -0.00284399f, -0.03388347f, 0.03248376f, -0.07866801f, 0.05608287f, 0.06802641f, 0.08083211f, 
    -0.23498051f, -0.03259747f, -0.06185230f, 0.08097585f, 0.15929544f, 0.02544308f, 0.08480769f, -0.05995837f, 
    -0.02216003f, 0.05940488f, -0.04486178f, -0.08891673f, -0.15106657f, 0.09036971f, -0.00460617f, -0.27067161f, 
    0.08085719f, 0.02243555f, 0.05293813f, 0.17616749f, 0.04862886f, 0.00462111f, -0.02411438f, -0.04729743f, 
    0.07668024f, 0.22768322f, 0.17142016f, -0.09836522f, 0.16951391f, 0.12016323f, 0.04172380f, -0.10340285f, 
    0.18225351f, 0.08926612f, 0.00914685f, 0.10710442f, -0.25093555f, -0.13540733f, -0.15422684f, 0.07705079f, 
    0.06397935f, 0.05759083f, 0.01479334f, -0.01279132f, -0.06253823f, 0.06248032f, -0.03698228f, -0.08987191f, 
    0.05568468f, 0.07341602f, 0.00514356f, 0.12853268f, 0.08686173f, -0.14801857f, -0.02557614f, 0.05777135f, 
    0.18280986f, -0.00764054f, 0.09585863f, 0.00453801f, -0.38323572f, -0.32937968f, -0.16459323f, 0.16711330f, 
    -0.01909089f, 0.03840672f, 0.07189226f, -0.03333011f, -0.04238052f, -0.07028894f, -0.02943887f, -0.05416971f, 
    -0.25095636f, -0.10773483f, -0.08092646f, -0.03963966f, 0.08060451f, 0.01762467f, -0.03793872f, 0.01637315f, 
    -0.06372485f, -0.01832153f, -0.05099233f, 0.04739880f, 0.16427481f, 0.19289207f, 0.07302934f, -0.12435771f, 
    -0.00653887f, 0.06229469f, -0.01254743f, -0.05128484f, 0.00971108f, 0.07364642f, 0.10357499f, 0.10262226f, 
    0.00107101f, -0.29824546f, -0.08503485f, 0.15852909f, 0.02976715f, 0.05805496f, 0.01093129f, 0.01371962f, 
    0.08504729f, 0.00665852f, 0.05231832f, 0.06830656f, -0.15793164f, -0.08131173f, 0.02798635f, -0.03877746f, 
    0.18354508f, 0.14712217f, -0.01650229f, -0.07813565f, 0.00515472f, 0.03828259f, 0.03576277f, -0.04970466f, 
    -0.34115848f, -0.21969077f, -0.18963018f, -0.07069715f, 0.16662109f, 0.08207371f, -0.03504482f, 0.00653875f, 
    0.01338584f, 0.08920696f, 0.06210142f, 0.02207560f, 0.13392283f, 0.00278331f, 0.17535920f, 0.21247000f, 
    0.02625574f, -0.07005614f, -0.03854091f, 0.09686974f, 0.12148705f, -0.02274534f, 0.02975909f, 0.07723864f, 
    -0.40519494f, -0.26559600f, -0.29694545f, -0.21893120f, 0.15715460f, 0.02248273f, 0.01480959f, 0.05157311f, 
    -0.04267064f, -0.05691140f, 0.04708372f, -0.06307531f, -0.09146269f, -0.17820913f, -0.06779803f, 0.27396792f, 
    -0.01472509f, 0.12411776f, 0.07069673f, 0.13975674f, 0.01977607f, -0.00332074f, 0.04172358f, -0.04299536f, 
    0.20696300f, 0.06307136f, 0.12499732f, 0.01796410f, 0.01764364f, 0.02076518f, -0.03510259f, -0.10866959f, 
    0.11645599f, 0.12606467f, 0.10017460f, -0.02030151f, -0.13697554f, -0.10638545f, -0.23094958f, 0.01360239f, 
    -0.00754677f, 0.08447968f, -0.02506658f, -0.06611561f, 0.01817522f, 0.06162417f, -0.10067184f, 0.01846082f, 
    -0.09221633f, -0.10898170f, 0.07561301f, -0.25814331f, 0.00089639f, 0.01584055f, 0.07319053f, 0.02829886f, 
    0.01537435f, -0.07965287f, 0.08998165f, 0.09268256f, -0.06115901f, 0.10529745f, 0.07506739f, 0.25509709f, 
    0.04822368f, -0.07797516f, 0.06988998f, -0.10406655f, -0.00233130f, -0.19002107f, 0.11138464f, -0.05518140f, 
    0.02947028f, -0.02253888f, -0.23671596f, 0.28904998f, 0.03854511f, 0.00941356f, 0.00508335f, 0.02199022f, 
    -0.02919100f, 0.05755204f, -0.11951840f, -0.03192240f, 0.26529315f, 0.18304206f, 0.17549707f, -0.22956622f, 
    -0.00088567f, 0.07609733f, -0.05941837f, 0.13740495f, 0.02696964f, 0.08136453f, -0.00222352f, 0.12553638f, 
    0.20635948f, -0.02886991f, -0.07818402f, 0.25057450f, 0.14119773f, -0.07449570f, 0.02086610f, 0.06191385f, 
    0.09662728f, 0.08750060f, -0.01612364f, -0.15585825f, -0.02100552f, 0.00777358f, 0.06016352f, 0.16415907f, 
    -0.00640321f, -0.03581101f, 0.09987690f, -0.00830312f, 0.10165299f, 0.15397984f, 0.02523913f, 0.07955075f, 
    -0.09699824f, 0.05966369f, -0.05374068f, -0.06967744f, -0.06579649f, -0.07957347f, 0.02274773f, 0.01796076f, 
    -0.00146356f, 0.00650716f, -0.00229857f, -0.04768541f, -0.15140435f, 0.06401692f, -0.06879314f, -0.16825667f, 
    0.07704558f, 0.14563318f, -0.01964264f, 0.04412521f, 0.02978571f, 0.01070136f, 0.17188257f, 0.06397320f, 
    -0.23746264f, -0.09369985f, 0.21687876f, 0.03401127f, 0.04703210f, 0.08473049f, 0.08071139f, -0.07994808f, 
    0.07890922f, -0.03320674f, -0.00585119f, -0.02055021f, -0.10620368f, -0.05808011f, 0.07696588f, 0.02122237f, 
    -0.01015707f, -0.00525852f, -0.07138816f, 0.13284774f, 0.01668253f, 0.00575970f, -0.02268242f, 0.06678744f, 
    -0.07723065f, -0.11837605f, 0.03364819f, -0.35813168f, 0.07501712f, 0.01550949f, 0.07469684f, 0.03658184f, 
    0.01964981f, -0.01118572f, -0.03224155f, 0.07485306f, 0.04553469f, -0.04857308f, 0.23067354f, -0.02393496f, 
    0.02238657f, -0.07648330f, 0.03544817f, 0.02016727f, -0.16741930f, -0.08815546f, 0.07017734f, -0.10954990f, 
    0.10241824f, 0.13173577f, 0.20435734f, 0.09981567f, -0.16246247f, -0.15162313f, -0.00760049f, 0.07396279f, 
    0.03781860f, 0.11697136f, -0.00817282f, 0.10460280f, -0.23694330f, -0.00406408f, -0.06051208f, -0.15188621f, 
    0.09476615f, 0.14973754f, 0.05920599f, 0.11419268f, 0.01530711f, 0.03372514f, 0.14255331f, -0.03737455f, 
    0.00812448f, 0.16576678f, 0.10653661f, -0.19321941f, 0.03723344f, 0.07878276f, -0.02059900f, -0.06223807f, 
    0.12770100f, 0.05013025f, -0.00550277f, 0.00034919f, 0.06565996f, 0.26732728f, 0.13529599f, 0.09495612f, 
    -0.04491724f, -0.04034225f, -0.05687249f, -0.09786993f, -0.06542816f, -0.06075474f, 0.03449680f, 0.13463227f, 
    -0.04769596f, 0.01728612f, -0.04751101f, -0.05277799f, 0.02887066f, -0.05519566f, 0.04072886f, -0.03969607f, 
    -0.04232744f, -0.05471554f, -0.05047794f, 0.00003145f, -0.05037507f, -0.03092051f, -0.04016254f, 0.01127268f, 
    0.00938636f, -0.03804329f, -0.05085840f, 0.01524236f, -0.01758312f, 0.01344020f, -0.01150976f, 0.03924361f, 
    0.00265193f, -0.04714140f, 0.02704485f, 0.03374698f, -0.01596161f, 0.01899305f, -0.02818685f, -0.01588141f, 
    -0.02987674f, 0.00728576f, -0.01699141f, -0.00836775f, -0.00956849f, 0.02980966f, -0.00202341f, 0.01678324f, 
    0.04354122f, 0.01195755f, -0.01668464f, -0.03685196f, 0.03356704f, 0.03569480f, -0.02894624f, -0.03706074f, 
    -0.05538240f, -0.04956140f, 0.02438354f, -0.02721886f, -0.05175308f, -0.03541945f, 0.01599138f, 0.01016458f, 
    -0.01791645f, -0.00112213f, -0.01450548f, 0.03889708f, 0.01015993f, 0.00614015f, -0.01304173f, -0.03723604f, 
    0.03372704f, -0.00801382f, -0.04445644f, -0.05058124f, -0.00334561f, 0.03145021f, -0.01688460f, 0.00456601f, 
    -0.00242490f, 0.03522272f, -0.03647232f, -0.04615967f, -0.02231660f, 0.01152543f, -0.01445602f, -0.04402960f, 
    0.03421076f, 0.03355772f, 0.00686179f, 0.00961269f, -0.05557333f, -0.00451689f, -0.05193563f, 0.03816969f, 
    0.02387929f, -0.04485714f, 0.02326634f, 0.03786664f, -0.04855188f, 0.02048253f, 0.03004689f, 0.02624906f, 
    -0.04259659f, -0.00456570f, -0.00464508f, 0.00589334f, -0.00720395f, 0.02216532f, -0.05030742f, -0.00330704f, 
    -0.02955256f, -0.04978104f, 0.04039028f, 0.03833711f, 0.02558192f, -0.05592933f, 0.01760744f, -0.04375203f, 
    0.04013223f, -0.02868575f, -0.05312121f, -0.04922741f, -0.05572864f, -0.04607342f, 0.03562418f, 0.04048913f, 
    0.00782157f, -0.04565530f, 0.01325230f, 0.04425456f, 0.02134682f, 0.04237841f, -0.03780654f, -0.00828723f, 
    -0.04526446f, 0.02611906f, -0.02516130f, 0.01139434f, 0.02431316f, -0.03712519f, 0.00387383f, 0.02364166f, 
    -0.00319910f, -0.05044710f, 0.02655699f, -0.00738632f, 0.02228221f, -0.05205761f, -0.03055237f, -0.04687671f, 
    -0.04211408f, -0.03154940f, 0.02389660f, -0.04512746f, -0.04102266f, -0.02911006f, 0.04350615f, 0.03523451f, 
    -0.01007729f, 0.02832830f, 0.03017815f, -0.01103673f, -0.04475965f, -0.05110916f, 0.01353805f, -0.00990199f, 
    0.04088866f, -0.00686545f, -0.05568026f, 0.03939330f, -0.03503653f, 0.02490396f, 0.02325093f, 0.03479446f, 
    -0.01569425f, -0.02441619f, 0.03230939f, 0.00008252f, 0.02120002f, -0.00724098f, 0.00697299f, 0.00290822f, 
    -0.02586460f, 0.03157417f, -0.01475944f, 0.01408772f, 0.01509522f, -0.00977777f, -0.01786027f, -0.00390205f, 
    0.00805587f, -0.02443176f, -0.01500330f, 0.02629749f, -0.04795554f, -0.02978514f, 0.01040772f, 0.04350608f, 
    0.04362473f, -0.03642508f, -0.00510720f, -0.01856952f, 0.04224609f, -0.05386859f, -0.05220750f, 0.02938586f, 
    -0.02579342f, -0.02492418f, 0.00870647f, -0.02640389f, 0.03479026f, -0.00751303f, -0.04839942f, -0.04355519f, 
    -0.04320064f, -0.02260644f, -0.03934849f, -0.01178680f, -0.02541630f, -0.02513481f, 0.01162258f, 0.03307268f, 
    -0.01932379f, -0.04447626f, -0.03840972f, 0.03710064f, 0.03508176f, -0.01480423f, 0.00997483f, 0.01900506f, 
    -0.04249555f, -0.03449265f, -0.02857910f, -0.05358679f, -0.02817613f, 0.00674295f, -0.05577432f, 0.00259547f, 
    -0.03258903f, -0.03933667f, 0.02343522f, 0.01552768f, -0.04847180f, -0.02810301f, -0.04185462f, 0.03509556f, 
    0.00878299f, -0.00772676f, -0.03648227f, 0.01247374f, 0.00312154f, -0.04665793f, -0.02233954f, 0.01473014f, 
    -0.02550364f, 0.00184279f, 0.01280688f, -0.03730177f, 0.01213978f, 0.02832046f, 0.04282456f, 0.02170509f, 
    -0.01970136f, -0.05548583f, -0.01789816f, 0.01757324f, -0.00643177f, -0.02286706f, 0.02387129f, -0.02200145f, 
    -0.00873238f, -0.00521594f, 0.02353928f, -0.05607811f, -0.01450103f, 0.04134727f, -0.00970133f, 0.01663114f, 
    -0.02984273f, -0.04481738f, -0.02780900f, -0.00854958f, -0.04415001f, 0.01062953f, -0.00521753f, -0.00744262f, 
    0.03246947f, -0.02794824f, -0.02775367f, -0.01337650f, -0.01802079f, -0.02354962f, 0.01287118f, -0.02852139f, 
    0.00662332f, -0.01698285f, -0.04658324f, -0.02540797f, -0.04594004f, 0.00645595f, 0.03136086f, -0.05581063f, 
    -0.02080048f, -0.02944917f, 0.02308487f, -0.03324809f, 0.03736566f, 0.00351277f, 0.00627715f, -0.02966820f, 
    -0.04893152f, -0.01738690f, 0.03248758f, -0.02553743f, 0.02070403f, 0.00101855f, -0.02962088f, -0.04405144f, 
    0.01852412f, -0.03621291f, 0.01022459f, -0.04185071f, 0.04220149f, 0.03582269f, -0.03131381f, -0.03590791f, 
    0.04160523f, 0.04461902f, 0.03410504f, 0.01843148f, -0.02959795f, -0.04117109f, 0.01319451f, -0.04995283f, 
    -0.03353887f, 0.02963829f, 0.02168414f, -0.02044493f, -0.02611698f, -0.03287816f, -0.03125622f, -0.02668230f, 
    -0.04629551f, -0.01614487f, -0.04732616f, 0.02831354f, 0.02456761f, 0.00065062f, -0.01883244f, -0.01180898f, 
    0.02722957f, -0.05257114f, -0.05346010f, 0.01260729f, -0.00592199f, -0.02217697f, 0.05017154f, -0.04773611f, 
    0.00581872f, 0.00418035f, -0.00129486f, 0.01673204f, -0.01080610f, -0.03823805f, -0.03511833f, -0.00197692f, 
    0.01314826f, 0.01198987f, 0.01610047f, -0.04767924f, 0.03314653f, 0.02112281f, 0.02864700f, -0.01369579f, 
    0.01027889f, 0.03598623f, -0.00001619f, 0.00009263f, -0.03081173f, -0.01060881f, -0.02221793f, 0.04496896f, 
    0.03480686f, -0.04089992f, -0.02425482f, 0.03970464f, 0.01744675f, -0.02330239f, 0.01197598f, 0.01778805f, 
    -0.03645111f, 0.02569833f, -0.04635139f, -0.03092069f, 0.00190105f, 0.01319337f, -0.03197388f, -0.00168032f, 
    0.02483845f, -0.04690911f, -0.01548315f, 0.04022583f, 0.03225131f, -0.03545441f, -0.04093464f, 0.03261326f, 
    0.04749754f, -0.05963602f, -0.05289036f, -0.05942758f, -0.03050927f, 0.01303954f, 0.00510240f, -0.04800068f, 
    -0.01882168f, 0.01478108f, -0.02737066f, -0.00018003f, 0.02700763f, 0.01591368f, -0.02678075f, -0.03851429f, 
    0.01700149f, -0.02852533f, -0.01318076f, -0.02590680f, -0.00086357f, -0.02810543f, -0.05753703f, -0.00618473f, 
    -0.01023578f, 0.02602423f, 0.00336863f, -0.05659398f, 0.00172241f, -0.03365453f, 0.03994237f, 0.03379926f, 
    -0.05160930f, 0.02798535f, -0.02146238f, -0.02689829f, -0.00470848f, 0.02774829f, 0.00440362f, 0.01356790f, 
    0.01634738f, -0.04288357f, 0.00620680f, -0.04553725f, 0.04226802f, 0.00338126f, -0.02172788f, -0.01082968f, 
    -0.02318623f, -0.05223331f, 0.03314446f, 0.02487190f, 0.01218416f, -0.01138885f, 0.02142557f, -0.00847004f, 
    -0.02528382f, -0.02399519f, -0.03484772f, -0.03563720f, 0.02264340f, -0.00435603f, -0.02297386f, -0.00839236f, 
    0.00655188f, -0.00891749f, -0.01440230f, 0.02704895f, -0.05018013f, 0.00286660f, -0.03103034f, -0.04179623f, 
    -0.04386561f, -0.01049505f, -0.00660929f, -0.00295660f, -0.04263842f, -0.01858457f, 0.03555961f, -0.03964213f, 
    -0.04169637f, -0.01587294f, 0.02899056f, -0.04055805f, 0.02046706f, 0.02797788f, -0.04815333f, 0.02388739f, 
    0.01729436f, 0.01714194f, -0.02237540f, -0.01915294f, -0.00044487f, 0.02796656f, 0.03757565f, 0.01635997f, 
    -0.03877120f, -0.02989056f, -0.03733929f, -0.03605158f, 0.00174585f, 0.00677391f, -0.01404840f, -0.02731645f, 
    0.03695625f, -0.00282807f, -0.00118279f, -0.03658495f, 0.01623455f, 0.04226654f, 0.03241649f, 0.04414629f, 
    0.00471913f, 0.01629509f, 0.01618391f, 0.03912764f, -0.05367021f, -0.00457329f, 0.01619046f, -0.01867827f, 
    0.03322955f, -0.02305019f, 0.02823819f, -0.03264990f, -0.05889035f, 0.01175110f, 0.01222536f, 0.03103246f, 
    -0.05276476f, 0.00287239f, -0.00676997f, -0.04720144f, -0.01056447f, -0.02046466f, 0.03480275f, 0.02822264f, 
    -0.04329460f, -0.05053231f, 0.02269396f, 0.01005122f, 0.01062887f, 0.04196346f, -0.01057420f, 0.03408499f, 
    0.01223302f, -0.02250420f, 0.01868053f, -0.04701469f, 0.02405617f, 0.00080011f, -0.01144500f, -0.04802283f, 
    0.01076688f, -0.03262252f, -0.04881358f, -0.01112865f, 0.01712968f, -0.02770249f, 0.01853660f, -0.00827791f, 
    0.04257281f, -0.01446816f, -0.03783496f, -0.03436102f, -0.02486802f, 0.02473093f, 0.01943877f, 0.03810919f, 
    0.03347519f, -0.00426058f, 0.03830715f, 0.01502569f, 0.00193431f, -0.05867766f, -0.05718094f, 0.00485142f, 
    0.01917608f, -0.05605688f, 0.02912738f, -0.04852144f, 0.04136773f, -0.03989961f, 0.02428917f, -0.01300854f, 
    -0.04227127f, -0.00822685f, -0.05978405f, -0.04872457f, 0.03763987f, 0.02884696f, 0.00598697f, 0.02916041f, 
    -0.05865012f, -0.00293923f, -0.01243553f, 0.00157877f, 0.00730876f, -0.00250351f, -0.01497756f, 0.03561059f, 
    -0.05915572f, 0.03459263f, 0.02312067f, 0.02393216f, -0.03375487f, 0.00833592f, 0.03071861f, 0.00393929f, 
    -0.05399206f, 0.03434458f, -0.00719475f, 0.03285404f, 0.03066956f, -0.01025759f, -0.01235975f, -0.04263159f, 
    0.01086901f, -0.02893872f, -0.05528171f, 0.03527559f, -0.04329873f, 0.00597381f, 0.02830784f, -0.03563739f, 
    0.02134996f, -0.05715471f, -0.04789984f, 0.02324708f, 0.03017852f, 0.03040460f, -0.05687628f, -0.01157898f, 
    -0.05650017f, -0.04973788f, -0.00082142f, -0.00135177f, -0.00107129f, 0.02057413f, -0.02034287f, 0.00837886f, 
    -0.01750264f, -0.03646444f, -0.02540079f, -0.05848060f, -0.00171226f, -0.05270680f, -0.02694767f, -0.04387585f, 
    -0.05323608f, -0.00905863f, 0.00526667f, -0.04387867f, 0.02718326f, -0.00786429f, 0.01414152f, -0.04551010f, 
    0.00637419f, 0.02027276f, 0.02977542f, 0.02357372f, -0.00699856f, -0.00313877f, 0.00243516f, 0.02849688f, 
    -0.00217226f, 0.04032121f, -0.00883521f, 0.02098792f, 0.02950566f, -0.00339841f, -0.01725877f, 0.01187765f, 
    0.03412599f, -0.03028963f, -0.00309215f, 0.00746670f, 0.01507901f, -0.01615848f, -0.04941618f, -0.03937761f, 
    -0.03955706f, 0.02609485f, 0.00368130f, -0.02587670f, -0.00128848f, 0.00840161f, 0.03411616f, -0.01320806f, 
    -0.01946969f, -0.04125371f, 0.03739761f, -0.01956872f, -0.04613271f, -0.02186246f, 0.00249544f, 0.03391565f, 
    0.01357220f, -0.05020614f, 0.01535531f, -0.01614454f, -0.05354430f, 0.04034150f, -0.04083410f, 0.02361293f, 
    -0.05142582f, 0.04135209f, 0.04247309f, 0.02871612f, -0.03357645f, -0.01026277f, -0.00762607f, 0.01483464f, 
    0.01598978f, 0.00762106f, -0.03026317f, 0.03550373f, 0.00749373f, 0.03704062f, 0.04214886f, 0.01792134f, 
    -0.00124114f, -0.00033242f, -0.05938264f, -0.01029404f, 0.03990600f, 0.00195728f, -0.01727563f, 0.04390504f, 
    0.01360500f, 0.03162850f, -0.03435205f, -0.01217827f, -0.02795514f, -0.00426238f, 0.00424194f, 0.02907566f, 
    -0.01244173f, 0.04143993f, 0.04007268f, 0.03459407f, -0.03997251f, -0.03109526f, -0.01636016f, -0.00391386f, 
    0.03305143f, -0.04711242f, -0.03742703f, -0.00158547f, -0.04076682f, -0.04087821f, 0.02481057f, -0.03422682f, 
    0.02162834f, 0.01474713f, 0.01849237f, -0.03640233f, -0.04430615f, 0.01505814f, -0.05233048f, -0.05793775f, 
    -0.05087590f, 0.03495571f, -0.02019622f, -0.01846766f, -0.01320377f, -0.02657067f, -0.05808363f, -0.03830672f, 
    -0.05410292f, -0.01411443f, -0.02327288f, -0.02546263f, 0.01447752f, -0.00951857f, -0.06856196f, -0.00100273f, 
    0.03824813f, -0.04676710f, -0.02639136f, -0.03781397f, -0.02871448f, -0.05117367f, -0.06726272f, -0.06726039f, 
    -0.00482376f, -0.04761435f, -0.02712539f, -0.06698158f, 0.02450067f, 0.00593354f, 0.01448071f, 0.01192946f, 
    -0.01074277f, -0.01018455f, -0.02566598f, -0.04584290f, -0.03093301f, -0.02565869f, -0.04726199f, 0.04151482f, 
    -0.03482557f, -0.02129762f, 0.00057583f, -0.03743223f, 0.00490787f, -0.01642204f, 0.01318595f, 0.00541274f, 
    -0.03808158f, -0.03156940f, -0.02817025f, -0.03504380f, -0.06450748f, 0.01989777f, 0.01304838f, -0.05413344f, 
    0.01290963f, -0.06568321f, 0.00496982f, -0.03374607f, -0.02994682f, -0.03234361f, -0.05456653f, -0.03149845f, 
    -0.06735878f, 0.01953888f, -0.06112602f, -0.05903321f, -0.03666151f, 0.01476270f, 0.01480541f, -0.04661577f, 
    -0.01185286f, 0.01762851f, 0.01825242f, -0.01896862f, 0.02796928f, -0.00154756f, 0.01222017f, -0.05966818f, 
    -0.02510835f, -0.06630746f, 0.01088493f, -0.01609869f, 0.00975201f, -0.03589151f, 0.00060334f, -0.04566187f, 
    0.03224173f, -0.04764090f, -0.06465027f, 0.02776130f, 0.00825567f, 0.00154078f, -0.01954680f, -0.01816129f, 
    0.01674916f, -0.04152571f, -0.03182493f, 0.00961117f, -0.05555483f, -0.01750346f, -0.00376800f, -0.04854585f, 
    -0.06290486f, -0.06153899f, -0.06044174f, -0.02093533f, -0.04939660f, -0.01595992f, 0.01686163f, -0.03437362f, 
    0.00263045f, 0.00588791f, -0.04316259f, -0.06786265f, -0.02670970f, -0.03975481f, -0.06225520f, 0.00405602f, 
    0.02274951f, -0.05712762f, -0.00769459f, 0.00036467f, -0.04127258f, -0.03102215f, -0.03781781f, 0.02439586f, 
    -0.02194334f, -0.00131542f, -0.00482405f, -0.01769878f, 0.02047493f, -0.03030556f, -0.06844733f, 0.01734036f, 
    -0.04824166f, -0.00221310f, -0.03498526f, 0.00258712f, -0.02907121f, -0.04094182f, -0.01264893f, -0.02029184f, 
    -0.01261733f, 0.01357288f, -0.00226766f, -0.03532100f, -0.03170844f, -0.00881712f, -0.04711641f, 0.00336475f, 
    0.02296719f, -0.00984720f, 0.01477113f, -0.03981440f, 0.02843891f, -0.01589426f, -0.01108079f, -0.00312541f, 
    -0.04138765f, -0.03072808f, -0.01790992f, -0.05098050f, -0.03570763f, 0.00723777f, 0.02752575f, 0.01886770f, 
    -0.05694937f, -0.03407729f, -0.06873048f, -0.04270186f, 0.00644558f, -0.00359270f, -0.04375074f, -0.04099404f, 
    -0.02419699f, -0.02612452f, -0.05814906f, -0.03459356f, -0.03407476f, 0.00656042f, -0.01504804f, 0.03295108f, 
    -0.00419221f, -0.03338271f, -0.02835986f, -0.00543351f, -0.04633320f, -0.01112469f, 0.00557472f, -0.02973013f, 
    -0.02121699f, -0.02326697f, 0.00176142f, -0.03956846f, -0.04991951f, 0.01436467f, -0.06418553f, -0.03157102f, 
    0.00406011f, -0.01614058f, -0.03924592f, -0.03740991f, 0.04727857f, -0.05619350f, 0.00062082f, -0.06792813f, 
    -0.00464932f, 0.00298086f, 0.02195638f, -0.02556601f, -0.04812897f, -0.04148715f, -0.03854559f, -0.03510249f, 
    -0.03377101f, 0.01186656f, -0.05023517f, 0.00551862f, -0.02407249f, -0.00639467f, 0.02211414f, -0.03387814f, 
    0.01072697f, 0.01500752f, -0.03431376f, 0.02103588f, 0.00683105f, -0.01978855f, -0.01871806f, 0.00935917f, 
    -0.03549869f, -0.06552741f, -0.03678723f, -0.04067577f, -0.03791351f, -0.01190558f, -0.00724342f, 0.00967506f, 
    0.03239844f, -0.05750767f, -0.02654517f, 0.03190827f, -0.06586325f, 0.00427643f, -0.00424263f, 0.01924763f, 
    -0.04672211f, 0.02689357f, 0.01487587f, -0.04561957f, 0.02724043f, -0.02507677f, 0.02876914f, -0.00498532f, 
    -0.05715529f, 0.00903123f, -0.04334370f, -0.01215824f, 0.00415613f, -0.03956540f, -0.04640251f, -0.00019615f, 
    0.02403988f, -0.00745033f, -0.02025027f, -0.06016087f, -0.05031063f, 0.00728421f, -0.06201956f, 0.01927550f, 
    0.00749346f, -0.03395909f, -0.06443304f, -0.04660577f, 0.01100179f, -0.01075653f, 0.01533169f, 0.00111679f, 
    -0.06874153f, 0.00174583f, -0.02082655f, 0.02561377f, 0.00027709f, 0.00058011f, -0.00977750f, 0.01916405f, 
    -0.06812005f, -0.03163728f, -0.03569258f, -0.04968452f, -0.06059321f, -0.03387509f, -0.04689386f, 0.02692265f, 
    0.01777834f, -0.01274825f, -0.01723091f, -0.00791194f, 0.03185923f, -0.02286101f, -0.04137233f, -0.02902992f, 
    -0.02696143f, 0.00854109f, -0.05471352f, -0.05714604f, 0.01693339f, -0.05210818f, -0.03183190f, -0.06774031f, 
    -0.05757265f, -0.00496570f, -0.02319945f, -0.02814461f, -0.01881464f, 0.02984421f, -0.05796786f, -0.06038895f, 
    -0.03314779f, 0.01062181f, -0.04305909f, 0.01679606f, -0.03560312f, -0.06647323f, -0.04818881f, -0.03597838f, 
    -0.00393230f, -0.00148611f, -0.05082565f, -0.05643181f, -0.01498702f, 0.00582549f, 0.00527800f, -0.01296424f, 
    0.00084532f, -0.06102683f, -0.00850039f, -0.02239853f, -0.03666379f, 0.02575381f, -0.04230054f, 0.03022353f, 
    0.02508070f, -0.00230299f, -0.03339562f, -0.00437628f, -0.00499123f, -0.06359319f, -0.01260991f, -0.01995398f, 
    -0.01276337f, -0.02231570f, -0.01520840f, -0.00802943f, 0.01314348f, 0.01857959f, -0.03494049f, -0.03758475f, 
    0.00708544f, 0.01935158f, 0.01295928f, -0.00805653f, -0.04315503f, 0.01600650f, -0.04353871f, -0.02487458f, 
    -0.04227277f, 0.00720349f, -0.02115449f, -0.02262546f, -0.03279218f, -0.06391141f, 0.03205412f, -0.01086427f, 
    0.01452649f, -0.04413325f, -0.03870707f, -0.02691790f, 0.02125177f, 0.00043944f, -0.05933059f, -0.02490125f, 
    -0.05679458f, -0.00996537f, -0.00840970f, 0.00480357f, -0.01250733f, -0.02364432f, 0.01389682f, 0.03931440f, 
    0.25105107f, 0.11359681f, -0.00235767f, -0.03144109f, -0.02600457f, 0.08867700f, 0.03100266f, -0.05236950f, 
    0.06234635f, -0.09963657f, -0.05330720f, -0.02789810f, -0.36204132f, 0.21058437f, 0.05470064f, 0.00837039f, 
    0.01510371f, 0.05881053f, -0.05286188f, 0.05054731f, -0.07307046f, 0.07737809f, -0.04447448f, 0.10546135f, 
    0.35539034f, 0.11411370f, -0.09147918f, 0.14210854f, -0.06691237f, 0.00707866f, 0.09552316f, 0.06317061f, 
    0.11411724f, -0.03876084f, 0.03944784f, -0.02927781f, 0.11154105f, -0.00659280f, 0.06082898f, 0.20961234f, 
    0.03246537f, 0.02375057f, -0.05126691f, -0.07866864f, 0.03653517f, 0.00796848f, -0.08177865f, 0.01244891f, 
    0.12951048f, -0.23385228f, -0.08752024f, -0.10131848f, 0.04276800f, -0.10462055f, 0.00528366f, -0.01723797f, 
    -0.01236569f, -0.09793808f, 0.08907364f, 0.03848774f, -0.13525240f, -0.14785972f, -0.05477408f, 0.00086000f, 
    -0.07207671f, 0.02961701f, -0.02742707f, 0.00905507f, -0.04229108f, -0.00220295f, -0.10111760f, 0.03540037f, 
    0.23707354f, -0.10096064f, 0.14230710f, -0.00801693f, -0.01183906f, -0.01608871f, 0.11024640f, 0.14234494f, 
    -0.04849122f, 0.14766666f, 0.08856458f, 0.05098255f, 0.09172127f, 0.03171318f, -0.00889877f, 0.16222969f, 
    -0.08779688f, 0.07545842f, 0.12900697f, -0.05927782f, -0.06232686f, 0.03133659f, -0.06173987f, -0.00861244f, 
    0.37516811f, -0.00927713f, -0.00786363f, -0.02889128f, 0.04347259f, 0.02018057f, -0.00186961f, -0.17497399f, 
    0.06253219f, 0.02487769f, -0.03734250f, -0.04030431f, -0.04070778f, 0.08160324f, 0.06094606f, -0.21011618f, 
    -0.01082179f, 0.05670062f, -0.05848733f, 0.09828626f, -0.00440543f, -0.00061989f, 0.01970468f, -0.02167363f, 
    0.03887072f, 0.21945676f, 0.01171886f, 0.12689443f, 0.04870170f, 0.09906157f, 0.02096443f, -0.08198880f, 
    -0.00912127f, -0.02365716f, -0.04556457f, -0.00569321f, 0.03051121f, -0.00510103f, -0.03982959f, 0.17833959f, 
    -0.02645434f, -0.08119150f, 0.04490355f, -0.05481825f, 0.03659450f, -0.11476470f, 0.12577944f, 0.10509489f, 
    0.13108435f, 0.17572965f, 0.00022497f, 0.10447446f, 0.08952269f, 0.08735862f, 0.07869252f, -0.00364237f, 
    -0.02505911f, 0.02367164f, 0.06020852f, 0.01052680f, -0.11756783f, -0.07052016f, 0.21375503f, 0.23537304f, 
    0.01829182f, 0.12526722f, 0.11197731f, -0.05617132f, -0.11923835f, 0.04936302f, 0.04660402f, 0.05120636f, 
    0.12253618f, -0.08320899f, -0.06263181f, -0.04883946f, -0.06099002f, 0.01600049f, 0.01961364f, -0.00807205f, 
    0.08780140f, 0.00928088f, -0.02548560f, 0.00936387f, 0.07063189f, 0.13255422f, -0.13239343f, -0.05676632f, 
    0.22464179f, -0.03769007f, 0.01016258f, -0.00873547f, 0.05387348f, 0.08116707f, -0.05021619f, -0.10904327f, 
    -0.11495606f, -0.05997868f, 0.15402865f, -0.18655361f, 0.05537040f, 0.12565550f, 0.08969098f, -0.14152043f, 
    -0.09526832f, 0.06962968f, -0.07762701f, -0.00978313f, 0.15558717f, 0.33713311f, 0.09853920f, 0.00707400f, 
    0.05846131f, 0.02818970f, 0.07231418f, 0.02030848f, -0.01077713f, -0.10323525f, -0.06140133f, -0.06536034f, 
    -0.05993051f, -0.00801178f, -0.00886321f, 0.30541995f, -0.13146943f, -0.01665037f, -0.09889694f, 0.10320794f, 
    0.17299524f, 0.01584755f, 0.06587426f, 0.02447928f, 0.14707358f, 0.09141740f, -0.13515022f, -0.01685620f, 
    -0.12367236f, 0.08378030f, 0.06802570f, 0.07481898f, -0.01605903f, -0.02767462f, 0.04386999f, 0.06668588f, 
    0.26988953f, -0.05915584f, 0.01983498f, -0.37140426f, -0.05181792f, -0.07165847f, -0.00358767f, 0.05978801f, 
    -0.06023331f, 0.05208118f, -0.03664352f, 0.05022407f, 0.34594309f, -0.12246451f, 0.07926874f, 0.13327712f, 
    -0.01724796f, -0.05987322f, 0.06573176f, 0.00701815f, -0.09824176f, 0.12835494f, 0.06710684f, -0.00941448f, 
    0.30314985f, 0.00239039f, -0.13517313f, 0.14691627f, 0.04088756f, -0.05387009f, -0.07814988f, 0.01472352f, 
    0.06338850f, -0.03652988f, -0.02693777f, -0.02059973f, 0.00715218f, 0.13903844f, -0.11842604f, -0.03127724f, 
    0.00827795f, 0.14114182f, -0.08054585f, -0.03757668f, 0.20101918f, 0.00489060f, 0.01113229f, -0.03998288f, 
    0.19686130f, -0.09825473f, -0.03076021f, -0.15144368f, -0.12246777f, -0.07965524f, -0.04572091f, 0.03870684f, 
    -0.15356703f, -0.03554898f, -0.04862233f, -0.06505824f, -0.34694946f, -0.14224337f, 0.06098358f, 0.19442455f, 
    -0.06118018f, -0.08998790f, -0.05781275f, -0.05513372f, -0.05939252f, -0.02833904f, 0.02205139f, -0.04457943f, 
    -0.10079855f, -0.11132310f, 0.02496083f, 0.11122917f, -0.06791145f, 0.06939721f, 0.01435962f, 0.00155779f, 
    0.01389375f, -0.05196067f, -0.14118278f, -0.21188019f, 0.15492272f, -0.00244496f, 0.09033044f, 0.24792238f, 
    -0.03250068f, -0.07069458f, -0.01416091f, 0.09881997f, -0.04946770f, -0.03711559f, -0.11403017f, -0.15653229f, 
    0.29524940f, 0.13777360f, -0.11698703f, 0.17797861f, -0.02402540f, -0.14003772f, 0.01310548f, 0.15669124f, 
    0.05668719f, -0.10093463f, -0.00033433f, 0.09445158f, -0.53883994f, 0.19959380f, -0.01143009f, -0.14453556f, 
    0.00691224f, 0.05437632f, 0.10317788f, 0.04157973f, 0.14565015f, -0.03579955f, 0.05074763f, -0.09241924f, 
    0.51929075f, -0.13650265f, 0.13988140f, 0.09191342f, -0.13839318f, 0.00959071f, -0.01095141f, -0.03949603f, 
    -0.06506858f, 0.11447952f, 0.00905517f, 0.05430208f, 0.15652239f, -0.15381934f, -0.04464329f, 0.41319939f, 
    -0.06473857f, -0.06212585f, -0.00508456f, 0.08334890f, -0.08093334f, -0.02324488f, 0.01138112f, 0.08619720f, 
    0.09362018f, 0.05718576f, 0.06552714f, -0.11076664f, 0.04227516f, 0.04507609f, -0.00742825f, 0.04063704f, 
    0.04648762f, -0.05182601f, -0.11368644f, 0.06994762f, -0.20759621f, 0.08886989f, 0.03175146f, 0.23262180f, 
    0.05732678f, 0.09133015f, 0.01738004f, -0.08839639f, -0.12420084f, -0.05367083f, -0.09393948f, 0.01271480f, 
    0.48572421f, 0.23317884f, 0.20778148f, 0.22751133f, -0.03341235f, -0.02994745f, 0.06205351f, 0.08146761f, 
    0.07717427f, 0.03395712f, 0.06936254f, -0.07378868f, 0.13823687f, -0.04236406f, 0.07716145f, -0.09485628f, 
    -0.15441775f, 0.05066970f, -0.00312175f, -0.06355305f, 0.03398105f, -0.03636044f, -0.02716602f, -0.06789988f, 
    0.00975904f, 0.00275479f, 0.12045298f, -0.02636755f, 0.01865785f, -0.00067304f, 0.05039878f, 0.00484416f, 
    -0.04159110f, -0.06456908f, 0.03358209f, 0.07109861f, 0.34217525f, -0.00897362f, -0.17416973f, -0.19907255f, 
    -0.08125710f, 0.05021226f, 0.04095946f, -0.00817752f, -0.11539172f, -0.05445337f, -0.16269539f, 0.04080544f, 
    0.16202039f, 0.07202702f, -0.01352909f, 0.06120243f, -0.03918029f, -0.01995491f, 0.03173383f, 0.06557488f, 
    -0.04066972f, 0.10899066f, 0.16322368f, -0.07109360f, 0.44955367f, 0.11002475f, 0.09177046f, 0.34312242f, 
    -0.04665788f, 0.07045159f, 0.10936788f, 0.06537137f, -0.01759427f, 0.05072481f, 0.09608228f, 0.04683903f, 
    0.10359764f, -0.09433837f, -0.04785674f, 0.05610134f, 0.00869951f, 0.04980373f, 0.02338325f, -0.10581637f, 
    0.06878129f, 0.03076259f, 0.07586886f, -0.05902236f, -0.21266685f, -0.01831604f, -0.01277746f, -0.31331655f, 
    0.10102814f, -0.02303394f, -0.15510252f, 0.04681724f, 0.07596048f, -0.06097228f, -0.00698590f, -0.05908632f, 
    -0.18249138f, 0.16037446f, -0.03632243f, 0.07726182f, -0.03548724f, 0.10572837f, -0.02699650f, 0.01399203f, 
    0.07975838f, -0.04464495f, -0.02252965f, 0.04398693f, -0.17009415f, 0.08033334f, -0.02912623f, 0.01411989f, 
    0.01944335f, 0.03494151f, 0.01838690f, -0.05975982f, 0.07257538f, -0.02670562f, 0.03428484f, 0.10638356f, 
    -0.18943956f, 0.01990480f, -0.10245211f, 0.17660278f, 0.04775665f, 0.03871112f, -0.04255213f, 0.14973928f, 
    0.07234674f, -0.00821693f, 0.11905888f, 0.10403334f, -0.12981425f, 0.07939051f, 0.13540214f, -0.02585376f, 
    0.04148469f, 0.07424127f, 0.11571974f, -0.11262728f, -0.02960170f, -0.01996959f, 0.02847396f, 0.03544513f, 
    0.10228398f, 0.03124446f, -0.18790625f, -0.14858034f, -0.18459563f, 0.11107463f, 0.08354723f, 0.04738849f, 
    0.14477229f, 0.06945852f, -0.01828902f, -0.05145082f, -0.00991292f, 0.05645556f, -0.14786795f, 0.01159963f, 
    0.11930189f, -0.08448023f, 0.02179778f, -0.04197583f, 0.13573386f, 0.01924089f, -0.02426309f, 0.02078593f, 
    -0.16031763f, -0.12952474f, 0.00061024f, -0.07552151f, 0.02498506f, 0.08176383f, 0.03018697f, -0.04977053f, 
    -0.04902318f, 0.04263400f, 0.01986105f, 0.01541216f, 0.07583047f, -0.01937532f, -0.06397267f, -0.11690287f, 
    0.05700791f, -0.12644102f, 0.14735617f, -0.04418481f, -0.07831765f, -0.07405467f, -0.00216458f, -0.04212008f, 
    -0.25396374f, -0.18773666f, 0.04643905f, -0.14119887f, -0.02297871f, 0.08939664f, 0.00392611f, 0.10217751f, 
    0.09351771f, -0.04089475f, 0.00358611f, 0.04851812f, 0.28690535f, 0.09977429f, 0.04309088f, 0.22585931f, 
    -0.05127559f, 0.12389819f, 0.18097702f, 0.05827000f, 0.09485082f, 0.08365304f, 0.10625470f, 0.05412438f, 
    0.26217800f, 0.05254075f, -0.02628641f, -0.37334943f, -0.14930697f, -0.03223468f, 0.07476606f, -0.01444083f, 
    -0.09870159f, -0.05431322f, -0.01537602f, -0.01079534f, 0.10807892f, -0.11172684f, -0.06880780f, -0.00904865f, 
    0.01299992f, 0.02129795f, 0.02386616f, 0.09412313f, -0.14180456f, 0.04015272f, 0.14957643f, -0.01793374f, 
    0.12261558f, -0.09511562f, 0.00500243f, 0.14469764f, -0.02402826f, 0.01678075f, -0.02722569f, -0.03268744f, 
    0.09282541f, -0.05650918f, -0.02047702f, 0.04905017f, 0.03249878f, -0.07148838f, -0.01816485f, -0.00412456f, 
    -0.02399916f, 0.02167771f, 0.05222725f, 0.07490676f, 0.10142994f, -0.04454165f, -0.07393090f, 0.01817467f, 
    0.48642069f, -0.03133212f, -0.02940811f, 0.00108968f, -0.07507920f, 0.02052560f, -0.03566473f, -0.08342595f, 
    -0.14305089f, 0.05436908f, -0.01327538f, -0.06815649f, -0.27352628f, -0.14623508f, -0.02373622f, 0.23931894f, 
    -0.01804749f, 0.03003420f, 0.01695202f, -0.16141158f, -0.12299103f, -0.00826393f, 0.02334473f, 0.01971633f, 
    0.11483891f, 0.06606296f, 0.08138960f, 0.08198044f, -0.02694547f, 0.10235645f, 0.04603200f, 0.10412371f, 
    0.00106176f, -0.02336668f, 0.02021385f, -0.00165761f, -0.03066558f, 0.02652685f, -0.06400762f, 0.08386769f, 
    -0.06443581f, 0.00815149f, -0.08909667f, 0.00508126f, 0.02414163f, 0.02617108f, 0.01141116f, -0.19070511f, 
    0.25911310f, 0.04691111f, -0.03184681f, 0.14175895f, -0.03638325f, 0.03671502f, 0.07107190f, -0.01645192f, 
    0.08315815f, -0.07329734f, -0.04723445f, -0.05270615f, -0.12714325f, 0.12868553f, 0.05488238f, 0.13738774f, 
    -0.00127260f, -0.01556523f, 0.16601214f, 0.09183066f, 0.04392934f, -0.06582657f, -0.06148905f, -0.06500095f, 
    0.76851994f, -0.15565996f, 0.09876092f, 0.18219544f, -0.05417813f, 0.07497779f, 0.03438630f, 0.04620315f, 
    0.01249496f, 0.06617855f, -0.01267002f, -0.00935975f, 0.18229109f, 0.02026070f, 0.13499962f, 0.40906632f, 
    -0.07689302f, -0.00283236f, -0.00737224f, -0.02672389f, -0.04914541f, -0.02423498f, 0.02832491f, -0.04083074f, 
    -0.04810101f, -0.14270455f, 0.02030035f, 0.02940203f, 0.09931888f, -0.09923279f, -0.03599969f, -0.06956297f, 
    0.05723056f, 0.01306202f, -0.02722247f, -0.03973419f, 0.11664898f, -0.03102957f, 0.08655905f, -0.13645850f, 
    0.16871929f, -0.05594968f, 0.01026470f, -0.09971508f, 0.00616941f, 0.05199112f, 0.00299334f, -0.02569467f, 
    0.06957079f, 0.15242212f, -0.04475137f, -0.06042579f, 0.27223948f, 0.10684603f, 0.01654651f, -0.06182690f, 
    -0.01423016f, -0.02535184f, -0.06011775f, 0.08938631f, -0.08279189f, -0.00574560f, -0.10550971f, 0.12477037f, 
    0.07678510f, -0.01739378f, -0.06475323f, 0.01648038f, -0.15360434f, 0.05944973f, 0.02795632f, 0.01362436f, 
    0.11224144f, 0.33639267f, -0.01987593f, 0.12422930f, -0.00009853f, 0.00093203f, -0.04416203f, 0.15425918f, 
    0.09169225f, -0.05748211f, 0.06569124f, -0.01943745f, 0.03538352f, -0.11608276f, -0.00780880f, 0.18325794f, 
    0.09500202f, -0.00609581f, -0.02627746f, 0.02832519f, 0.06793196f, -0.03288588f, 0.16382611f, 0.01778828f, 
    -0.23196776f, 0.14395139f, -0.06554127f, -0.16383190f, 0.00450858f, -0.05288298f, 0.03161816f, -0.04067071f, 
    0.03228385f, -0.05650027f, -0.05297603f, 0.00427508f, 0.19908027f, 0.10774449f, 0.07898518f, -0.02546142f, 
    0.21714824f, -0.02241541f, -0.10308010f, -0.09690329f, 0.10507572f, 0.13965435f, -0.01725619f, 0.06134972f, 
    -0.15991025f, 0.08411041f, 0.04681609f, 0.28130588f, 0.03542653f, 0.13827834f, -0.12017053f, 0.03968596f, 
    0.00813808f, 0.05937276f, -0.02483669f, 0.04070453f, 0.06842303f, -0.27632976f, -0.10947149f, 0.04716385f, 
    0.00761590f, -0.05371940f, 0.02807719f, -0.17239361f, 0.09091423f, 0.03750685f, -0.02224828f, 0.12258429f, 
    -0.23837608f, -0.16861330f, 0.07111774f, 0.10306282f, 0.15390114f, -0.10675892f, 0.04000884f, 0.11126850f, 
    0.04931571f, 0.12704255f, 0.06368420f, -0.05920894f, 0.28018993f, -0.06607198f, -0.17002028f, 0.05020935f, 
    0.08762014f, -0.01190541f, 0.05610590f, 0.03162046f, 0.07035537f, 0.02273683f, 0.09786988f, 0.01374407f, 
    -0.08032455f, -0.19290541f, 0.05015078f, 0.04515403f, 0.01814053f, 0.00682179f, -0.01724595f, 0.08528774f, 
    -0.01508056f, 0.01079025f, 0.03599924f, -0.05303799f, 0.02608643f, -0.00939266f, 0.01472712f, 0.24779196f, 
    -0.04080549f, -0.01340329f, -0.09944957f, 0.03498962f, -0.03772674f, 0.01763343f, 0.05819033f, -0.04579756f, 
    0.37190303f, 0.09888321f, 0.22761321f, -0.14723773f, 0.03045839f, 0.08259791f, -0.14348333f, 0.05112592f, 
    0.13783564f, -0.04173856f, 0.04586584f, -0.00215807f, -0.13063082f, -0.10191394f, 0.11001841f, 0.27476674f, 
    -0.02516443f, 0.02721065f, -0.12057530f, -0.03180170f, -0.08798608f, -0.04843616f, -0.08659571f, -0.01705380f, 
    0.00914977f, -0.04522390f, 0.16942817f, -0.00814936f, 0.04010933f, -0.07554317f, 0.04449283f, 0.05970338f, 
    0.06160871f, -0.00564604f, -0.00084784f, 0.08069733f, -0.26533353f, -0.01034170f, -0.20241076f, 0.09799530f, 
    0.10382995f, 0.02866805f, 0.05201649f, 0.03196132f, 0.13043895f, -0.02269386f, 0.14324394f, -0.03621882f, 
    -0.05987007f, -0.14464344f, -0.08895335f, -0.11269755f, -0.03317901f, -0.05637114f, -0.06957761f, -0.12691255f, 
    0.03819305f, 0.07284921f, 0.00803062f, -0.01979934f, 0.21766320f, 0.07838649f, 0.12488572f, -0.16555096f, 
    0.08767570f, 0.00823271f, -0.08227021f, 0.07045522f, 0.10654911f, 0.02058891f, -0.08281762f, -0.00659772f, 
    0.61468601f, 0.20619029f, 0.02269543f, 0.29279229f, 0.06444161f, 0.08654606f, 0.04507941f, 0.00334736f, 
    -0.03909091f, -0.01134468f, 0.06745044f, -0.13278627f, -0.22300540f, 0.30967540f, 0.00329480f, -0.04229759f, 
    0.16359806f, -0.02178918f, -0.01884468f, -0.01474867f, 0.08907832f, 0.04822670f, 0.02877627f, 0.08840802f, 
    -0.46697709f, 0.18628736f, -0.17498684f, -0.29938567f, -0.03141370f, -0.09883069f, 0.06841163f, -0.02529168f, 
    0.09186544f, 0.06889833f, -0.00990963f, -0.03896288f, -0.12996143f, -0.11646333f, 0.09403711f, 0.02922841f, 
    0.06431898f, 0.14606245f, 0.04778794f, -0.11501800f, 0.04893258f, -0.05302617f, 0.03112355f, 0.05365704f, 
    0.03178589f, -0.00306556f, 0.11307358f, 0.00540125f, 0.05308622f, 0.04851330f, -0.00406059f, -0.03548325f, 
    0.06155440f, 0.05492123f, -0.02899650f, -0.02532268f, 0.14044718f, -0.09905345f, -0.19668746f, -0.03110487f, 
    0.01196634f, 0.04913868f, 0.09550297f, 0.14482506f, 0.04319303f, 0.05708609f, -0.02472211f, 0.07760099f, 
    -0.20241341f, 0.05445226f, 0.07055049f, -0.20519517f, 0.00901359f, -0.02309265f, 0.00401636f, 0.04077500f, 
    -0.00700351f, -0.00597565f, -0.00019905f, 0.11204657f, 0.02431178f, -0.01307000f, -0.05413697f, -0.26482573f, 
    0.10712360f, -0.05727300f, -0.00183599f, 0.08504401f, -0.02728412f, -0.03381215f, 0.10818127f, 0.01742308f, 
    -0.10085543f, 0.09009392f, 0.04704415f, 0.08160301f, -0.00197363f, -0.08369838f, -0.01770006f, -0.03331922f, 
    -0.02661974f, 0.06699086f, -0.03165116f, 0.04911281f, 0.27250677f, -0.19057652f, 0.06951887f, -0.08223707f, 
    0.10494027f, 0.01932434f, 0.00843120f, 0.00803933f, -0.06399672f, -0.05368604f, 0.05574514f, -0.01263710f, 
    -0.16740422f, 0.14491346f, 0.11359496f, -0.21634024f, 0.21898235f, 0.08688218f, 0.00584211f, -0.12927575f, 
    0.03639874f, -0.06782822f, -0.05614269f, -0.08792750f, 0.20296173f, 0.15307672f, -0.05352645f, -0.05279772f, 
    0.09161995f, 0.12070920f, 0.03843946f, -0.03501667f, -0.01755407f, -0.02116857f, 0.10727774f, 0.05697916f, 
    0.04764530f, 0.15258560f, 0.01940081f, 0.03500743f, -0.08921225f, 0.06168079f, -0.02004573f, 0.11098266f, 
    0.15210444f, 0.01018308f, -0.14255592f, 0.06096112f, -0.25639009f, 0.01430997f, -0.02455796f, 0.04017686f, 
    -0.08570975f, 0.03949954f, 0.01398984f, -0.00875854f, -0.09850346f, -0.01772535f, -0.09452160f, 0.14799869f, 
    0.28988218f, -0.11573643f, 0.10912564f, 0.21068504f, -0.12694699f, -0.01895849f, -0.02979955f, -0.06866580f, 
    0.04911320f, 0.00539618f, 0.11585269f, -0.12288576f, 0.00688965f, 0.04448707f, 0.13414836f, -0.05565336f, 
    -0.08235213f, 0.00825264f, -0.09784780f, -0.07693642f, 0.08577145f, -0.06758656f, 0.01584427f, 0.02822943f, 
    0.26927394f, -0.18375634f, -0.04464302f, -0.04529085f, 0.12219285f, -0.03256064f, -0.00312737f, -0.07963164f, 
    0.05637605f, -0.13545720f, 0.02092940f, 0.02976673f, -0.00323152f, 0.17855735f, 0.02769923f, -0.18291461f, 
    0.04536472f, 0.03491438f, 0.06877635f, -0.00132927f, 0.01974438f, -0.02142375f, -0.09587862f, 0.02212988f, 
    0.07217030f, -0.09776803f, 0.03899444f, 0.17322293f, -0.01107626f, -0.00770036f, 0.02492201f, 0.07293436f, 
    -0.10747632f, 0.15899532f, 0.07147098f, -0.00496871f, 0.03460998f, 0.13933237f, -0.00513938f, 0.25656414f, 
    -0.03468088f, 0.08564662f, 0.17981784f, 0.02294147f, -0.06273930f, -0.08932035f, 0.05061236f, -0.06626339f, 
    0.40208340f, 0.06926609f, -0.09172862f, -0.07455081f, 0.05432181f, -0.05287914f, -0.13133524f, -0.02239508f, 
    0.06345018f, -0.01301676f, 0.00879611f, -0.02951665f, -0.34661368f, 0.20626406f, 0.04089891f, -0.20246898f, 
    -0.00136542f, 0.05303689f, 0.02063451f, 0.09329394f, 0.02769586f, -0.01944245f, -0.02547050f, -0.02483405f, 
    0.09029877f, 0.19685815f, -0.01604590f, 0.13354547f, 0.19235380f, 0.01501295f, -0.03597209f, -0.00165234f, 
    0.03390337f, -0.04166148f, -0.02009685f, 0.01678436f, -0.26522100f, -0.03445217f, 0.05911147f, 0.05160488f, 
    -0.08014759f, -0.05976466f, 0.01052697f, 0.04284715f, 0.03661733f, -0.06570312f, 0.05194654f, 0.05550097f, 
    -0.15416171f, 0.19777122f, 0.02644335f, 0.15793686f, 0.18183665f, 0.12515046f, 0.08837911f, 0.05922464f, 
    0.01805766f, -0.00553167f, -0.01648213f, 0.04009729f, -0.12217423f, 0.17655699f, 0.06409027f, -0.17076753f, 
    -0.01624380f, -0.00461668f, 0.08060350f, -0.06876060f, -0.10225743f, 0.08757883f, 0.12100602f, 0.04090573f, 
    -0.00370222f, -0.16439764f, -0.14706044f, -0.04025960f, -0.02930195f, -0.03927023f, 0.01294606f, -0.01065418f, 
    0.01807399f, 0.06675694f, -0.04375342f, 0.00576526f, -0.00321125f, 0.08277999f, -0.04961706f, -0.18444946f, 
    0.32725555f, -0.01691540f, 0.13565370f, 0.02835098f, 0.13474461f, 0.07687008f, -0.09509686f, 0.11616053f, 
    -0.25892645f, 0.22699875f, -0.05558815f, -0.09341186f, 0.04305791f, 0.09769017f, -0.00825110f, -0.09867858f, 
    -0.05267050f, -0.02626038f, -0.00643987f, -0.08108475f, 0.24377766f, -0.06858167f, 0.12172031f, -0.01185675f, 
    -0.11399975f, -0.01751223f, 0.03540077f, 0.06269879f, -0.15925099f, -0.02396301f, -0.03206165f, -0.02467702f, 
    -0.05409418f, 0.07679650f, 0.06656427f, 0.29096106f, 0.03490791f, 0.03120001f, 0.03259115f, 0.08883860f, 
    0.01968439f, -0.04758235f, 0.04173324f, 0.06705084f, -0.00633506f, 0.04684597f, -0.03651604f, 0.31331369f, 
    -0.08847877f, 0.07361170f, 0.06216352f, 0.01753425f, 0.01629251f, 0.02161905f, 0.09811732f, 0.03117052f, 
    -0.04304763f, -0.08452591f, -0.06181701f, -0.44714099f, -0.10417108f, -0.00718033f, 0.08312812f, 0.01421936f, 
    -0.06221186f, -0.03894238f, 0.00236831f, 0.08497961f, 0.28806552f, 0.03950141f, 0.05938715f, 0.03273556f, 
    0.01307632f, 0.01073131f, 0.01577699f, 0.10793673f, -0.04047062f, 0.14733237f, 0.03128682f, -0.13351585f, 
    0.21159609f, -0.21576124f, 0.00591807f, 0.24051532f, -0.00488820f, -0.01875797f, -0.08661405f, 0.00941549f, 
    -0.00306283f, -0.00946522f, 0.05722164f, -0.02982462f, 0.00869297f, 0.08508523f, -0.10236254f, 0.03443389f, 
    0.02940414f, 0.14841889f, -0.07571458f, 0.09860630f, 0.11980928f, -0.08370028f, 0.07194556f, -0.00363941f, 
    -0.06813550f, 0.13546652f, -0.10776990f, -0.08075964f, -0.08941129f, -0.02747758f, -0.00434722f, -0.03445008f, 
    -0.10858951f, -0.04355163f, 0.00010276f, -0.12249778f, -0.22497955f, -0.27520356f, 0.27045807f, 0.10362842f, 
    0.02942789f, -0.17333448f, -0.09111837f, -0.21694940f, -0.08603206f, 0.00528522f, 0.00122969f, 0.06823030f, 
    0.07086506f, 0.25090823f, -0.11208773f, 0.22004247f, -0.07255325f, 0.02289470f, 0.01484613f, -0.07384647f, 
    -0.00832834f, -0.06660249f, -0.09173727f, -0.10464398f, 0.04803294f, -0.14558259f, 0.01456447f, 0.31923604f, 
    -0.17926881f, 0.02233480f, -0.02417448f, -0.08568437f, -0.14079492f, -0.04473416f, -0.01556614f, -0.09934919f, 
    0.18617833f, -0.13821974f, 0.00171584f, 0.14867799f, -0.03505582f, 0.02119368f, 0.05364109f, -0.00311798f, 
    0.05186472f, -0.00696012f, 0.01001731f, 0.04485853f, -0.17385136f, 0.34724692f, 0.15083317f, 0.01558096f, 
    -0.07488973f, 0.02655105f, 0.02135130f, -0.06493337f, 0.12340234f, 0.04093395f, -0.02169762f, -0.12203375f, 
    0.50003868f, 0.13871324f, 0.06156867f, 0.15018524f, -0.16091116f, 0.09430654f, 0.02872044f, 0.06580682f, 
    -0.04587976f, 0.08462100f, 0.01632108f, 0.10790693f, -0.08993497f, -0.19489445f, 0.14219610f, 0.30249450f, 
    -0.07060200f, -0.04040679f, 0.02256830f, -0.02655510f, -0.03330608f, 0.01131657f, 0.05242071f, 0.07185967f, 
    0.15548080f, -0.08279465f, -0.00338466f, -0.04507897f, 0.10821578f, -0.04856799f, -0.01882016f, -0.09803002f, 
    -0.12006787f, 0.00319580f, -0.01507679f, -0.11947944f, 0.17685023f, 0.02095061f, -0.16979647f, 0.09473371f, 
    0.04285829f, 0.10730893f, -0.06746595f, -0.03043102f, 0.02517565f, -0.01633568f, 0.03378500f, -0.14465491f, 
    0.30071306f, 0.31090131f, 0.02932104f, 0.01379478f, 0.02537064f, -0.13795796f, -0.02966115f, -0.00017785f, 
    -0.04214612f, -0.13487253f, 0.06190556f, -0.05771646f, 0.14840890f, -0.18784235f, 0.26678210f, 0.11532518f, 
    0.07829770f, -0.08107792f, 0.02077833f, 0.01415433f, 0.01408888f, 0.08186495f, -0.13017431f, -0.09271488f, 
    0.09747298f, 0.18762603f, 0.02899198f, -0.07618645f, -0.09450202f, 0.07060377f, -0.01878429f, -0.03990562f, 
    0.00264398f, -0.02296253f, 0.09003540f, 0.12647542f, 0.29258969f, -0.09002746f, 0.01818907f, -0.04148107f, 
    -0.10760684f, 0.09366032f, 0.07139424f, 0.04268574f, 0.00752463f, 0.12786481f, 0.13795452f, 0.15991636f, 
    0.13055925f, 0.01209255f, -0.07922224f, -0.27058038f, -0.05789397f, -0.00546959f, 0.10994794f, 0.00772719f, 
    -0.03130495f, -0.05477639f, 0.04415774f, -0.02598040f, 0.32721156f, -0.05010073f, 0.03955815f, -0.10719705f, 
    -0.02382481f, -0.09437521f, -0.02164722f, -0.06846748f, 0.12263997f, 0.14017162f, 0.02985652f, 0.03757169f, 
    -0.09591046f, -0.13160077f, 0.02183908f, 0.11494771f, 0.01613665f, 0.08776811f, 0.25017855f, 0.05496659f, 
    0.04118744f, 0.14310218f, 0.09872515f, 0.02627821f, 0.05717023f, -0.21662050f, -0.00620930f, -0.06343304f, 
    0.08182313f, -0.03718518f, -0.17209178f, -0.04600621f, -0.10581870f, -0.05465642f, -0.01952366f, -0.12135441f, 
    -0.03183256f, -0.01048442f, -0.22823842f, -0.09504359f, -0.15982644f, 0.04760628f, 0.15347531f, 0.07034898f, 
    0.02081163f, -0.02892395f, -0.24098496f, -0.06573452f, 0.04788812f, 0.10500947f, 0.03533102f, -0.00394202f, 
    0.01572525f, -0.02740524f, 0.09137470f, -0.02467202f, 0.01430920f, 0.04397472f, -0.14032902f, -0.05307128f, 
    0.10822776f, 0.06993829f, -0.18122874f, 0.05508158f, -0.05118745f, -0.00662867f, 0.00753925f, 0.13746782f, 
    -0.10335458f, 0.07501223f, 0.19433923f, 0.07311510f, 0.00543177f, -0.08071793f, 0.15556692f, 0.22007255f, 
    0.07723854f, -0.11582690f, 0.01735935f, -0.04823769f, -0.04579614f, -0.20367379f, -0.21319084f, 0.05465136f, 
    0.03430628f, 0.17754388f, 0.04889881f, 0.07440221f, -0.18559387f, 0.11560850f, 0.14826520f, 0.08713129f, 
    0.03228382f, 0.04368669f, 0.07101417f, 0.01043981f, 0.21500672f, 0.07237950f, -0.04946243f, 0.22678797f, 
    -0.19143109f, -0.05166027f, -0.02622178f, -0.04122491f, -0.10426423f, -0.08390461f, 0.00582353f, -0.09655837f, 
    0.09649900f, -0.23810188f, -0.00583282f, -0.06597379f, 0.03433501f, 0.02894067f, -0.02422772f, 0.04324102f, 
    0.03415271f, 0.11184140f, 0.09308936f, 0.03717997f, -0.16791178f, 0.22244138f, -0.12513702f, -0.00843287f, 
    0.08201940f, -0.02663413f, 0.01004281f, -0.12920198f, 0.05161972f, 0.09696580f, 0.06805918f, 0.03756930f, 
    -0.25931421f, -0.37096569f, 0.12305206f, -0.20732166f, -0.11280977f, -0.01619958f, -0.01099978f, -0.18361384f, 
    0.06054318f, -0.11632721f, -0.06093609f, -0.23018646f, 0.23941478f, -0.03398651f, 0.04953116f, -0.18452442f, 
    -0.00756594f, 0.09206430f, 0.13116571f, -0.04240740f, 0.06502851f, 0.06840116f, -0.10128668f, 0.14271304f, 
    0.06456211f, 0.13052683f, 0.08983412f, 0.12519100f, -0.01542189f, -0.06040085f, 0.09134862f, 0.03391019f, 
    -0.03744928f, -0.00166418f, -0.01869736f, -0.06465721f, 0.18476827f, -0.12138490f, 0.08879569f, -0.01082383f, 
    0.03925784f, 0.00365663f, 0.06872679f, 0.06496684f, -0.08391052f, -0.15434027f, 0.17638431f, 0.07049645f, 
    -0.03541174f, 0.27180091f, -0.16920117f, -0.03901618f, 0.13817197f, 0.07025396f, 0.02888079f, -0.05275189f, 
    0.03069571f, -0.03960788f, -0.05107649f, 0.14225461f, 0.06169659f, -0.14333934f, -0.06076634f, -0.06269011f, 
    -0.08191377f, -0.19990441f, 0.04682460f, -0.14020653f, -0.00502016f, 0.19649649f, -0.28095797f, -0.14805423f, 
    0.36539960f, -0.03367222f, 0.12682770f, -0.01079229f, 0.05986787f, -0.03796656f, -0.05186995f, -0.04425607f, 
    -0.01813958f, 0.01645510f, 0.14623508f, 0.05446782f, 0.11715150f, 0.11289978f, -0.26974475f, 0.14383408f, 
    -0.04135989f, 0.15073699f, -0.08543028f, -0.04130303f, -0.02332441f, 0.00558562f, -0.01502910f, -0.13066050f, 
    0.05225646f, -0.06390619f, -0.04425244f, -0.08744315f, 0.06038132f, 0.03330880f, -0.03243220f, 0.09737585f, 
    0.04517758f, 0.03063203f, 0.18770927f, 0.07672694f, 0.22859231f, 0.17990208f, -0.17543930f, -0.01721676f, 
    0.10013468f, -0.14843802f, -0.10136115f, -0.04125598f, 0.00603894f, 0.09220275f, -0.11253420f, 0.06365958f, 
    0.02025961f, 0.25053847f, 0.00224577f, -0.09615946f, -0.06380481f, 0.21657136f, -0.06205900f, -0.14304885f, 
    -0.01216870f, -0.16424568f, 0.02633941f, -0.04197838f, 0.24051569f, -0.24904458f, -0.14518195f, -0.07087599f, 
    0.02871760f, 0.04519423f, 0.05388777f, 0.05325336f, -0.07380286f, -0.04565918f, -0.04060053f, 0.18834317f, 
    0.06130921f, -0.06627291f, 0.07151491f, -0.03691446f, 0.11783614f, -0.09450301f, -0.07917936f, -0.10478555f, 
    0.02551596f, 0.01398106f, -0.04633973f, -0.09537994f, 0.36950061f, 0.21944742f, -0.00402074f, 0.03738194f, 
    -0.02207673f, -0.11739943f, -0.08791067f, -0.02306021f, -0.02464648f, -0.04293778f, -0.04908997f, -0.13590084f, 
    0.08987796f, 0.05644026f, 0.08643951f, -0.05394823f, -0.04394729f, 0.01666830f, -0.00411420f, 0.01197715f, 
    -0.11375163f, 0.02238008f, 0.11302148f, -0.03303721f, 0.24255097f, -0.05541372f, -0.00380267f, 0.13769421f, 
    -0.05935901f, -0.08527035f, 0.02792221f, -0.03814217f, 0.02720387f, -0.10478811f, 0.08365539f, -0.14276755f, 
    -0.16563898f, 0.10934159f, 0.13799694f, -0.03098652f, -0.05644082f, -0.05217132f, 0.03028945f, 0.07848901f, 
    0.00630045f, 0.06744429f, -0.05773884f, -0.01707622f, 0.10839587f, 0.06591725f, -0.10992286f, 0.02423191f, 
    0.04382651f, -0.03922920f, 0.21896909f, 0.09327500f, 0.00058941f, -0.04772511f, -0.12474951f, -0.06467866f, 
    -0.57177925f, 0.03299369f, 0.03664576f, 0.00640443f, -0.04233283f, 0.02296119f, 0.03722728f, -0.00687738f, 
    -0.09265804f, 0.09374063f, -0.02110482f, 0.00969750f, 0.03333556f, -0.00983576f, -0.05907870f, 0.02593983f, 
    0.06166019f, -0.08412819f, 0.02975030f, 0.02343812f, -0.06209547f, 0.10237269f, -0.08314597f, -0.11954879f, 
    0.46776411f, 0.17360930f, -0.01364654f, -0.01002950f, 0.03880090f, 0.10170253f, 0.03209614f, -0.00995302f, 
    -0.02228864f, -0.03105891f, -0.04788354f, -0.03742616f, 0.08222795f, 0.06186639f, -0.04755308f, -0.12544827f, 
    0.05752197f, -0.02186814f, 0.09329227f, 0.06929282f, 0.02204436f, 0.02605268f, -0.03953578f, 0.05926916f, 
    -0.28631619f, -0.00069299f, -0.05833701f, 0.18399452f, -0.07447137f, -0.06939391f, 0.20795345f, 0.07965021f, 
    0.10454276f, 0.04006823f, 0.14326203f, -0.04977182f, 0.33890858f, 0.06775504f, -0.02702738f, -0.06526580f, 
    -0.00132408f, -0.00704494f, -0.07661860f, -0.04527457f, -0.07232156f, -0.10242118f, -0.03741682f, -0.05558452f, 
    0.28264168f, 0.33633643f, -0.02012583f, -0.09168226f, -0.14796574f, 0.04521615f, 0.04834708f, 0.02024017f, 
    -0.01637788f, -0.04982724f, -0.06910353f, 0.04123640f, -0.14486173f, -0.02535999f, 0.08803601f, -0.02186452f, 
    0.08933749f, 0.05478475f, -0.02008125f, -0.05238942f, 0.10162318f, 0.08235984f, -0.08082802f, 0.01317747f, 
    0.21206696f, -0.12956885f, 0.07261726f, 0.33098161f, -0.16868715f, -0.11380530f, 0.00179083f, 0.09787745f, 
    0.05026006f, -0.02074351f, 0.18318594f, 0.08909204f, 0.13331927f, 0.12644145f, -0.06758405f, -0.13732256f, 
    0.02178076f, -0.02078715f, -0.05742915f, -0.00888288f, -0.04664673f, -0.10017502f, -0.08942452f, -0.12306357f, 
    -0.15424810f, -0.07580851f, -0.07702700f, 0.19283988f, 0.04987143f, 0.11845079f, 0.11236412f, 0.00054928f, 
    -0.01145909f, 0.04048125f, 0.06741408f, 0.01472985f, -0.00141547f, 0.00467242f, 0.00924174f, 0.21382847f, 
    -0.22034322f, -0.03141406f, 0.00380381f, 0.03640497f, 0.02357325f, 0.04353199f, 0.05291415f, 0.02400601f, 
    0.43783000f, -0.26761326f, -0.12992235f, 0.01033635f, -0.10923309f, -0.00183832f, 0.05328003f, 0.07071301f, 
    0.03397868f, -0.15915453f, 0.01081184f, 0.02323139f, 0.08071411f, -0.09087678f, -0.19957954f, -0.04909225f, 
    -0.07938040f, -0.07767190f, 0.16304708f, -0.05850523f, 0.00875919f, 0.11465893f, -0.05215320f, 0.10258552f, 
    0.07577542f, 0.18592224f, 0.20318449f, -0.16830498f, -0.03381111f, 0.09493275f, -0.00729508f, 0.12600823f, 
    0.07816578f, -0.03849648f, -0.05704460f, -0.14175782f, -0.08115885f, -0.00627453f, -0.00060160f, -0.00180724f, 
    -0.05122345f, 0.04648791f, 0.14433755f, 0.10330390f, 0.04042488f, 0.11982341f, 0.03884055f, 0.04492419f, 
    -0.45024917f, -0.14367816f, 0.03021843f, 0.16004975f, 0.03362045f, 0.04752618f, -0.02879697f, -0.02182952f, 
    0.06894354f, 0.03542262f, -0.03141111f, -0.06872899f, -0.14741495f, -0.17316230f, -0.04605266f, 0.20334248f, 
    0.01542279f, 0.15267114f, 0.03266845f, 0.06664224f, 0.03504810f, -0.10113691f, 0.13094868f, 0.11043909f, 
    0.15556213f, 0.16790116f, 0.16861433f, 0.05831032f, 0.03405490f, 0.16007073f, 0.12180328f, -0.03704812f, 
    0.03104853f, -0.06698193f, -0.02994744f, 0.09169790f, 0.29469618f, 0.05186832f, 0.10818159f, -0.05454770f, 
    -0.01096843f, -0.11642220f, 0.11912766f, 0.05812363f, -0.09947614f, 0.08077586f, 0.01304191f, 0.12691584f, 
    0.00119204f, -0.14712813f, 0.00898051f, 0.11194429f, 0.03396482f, 0.03023688f, 0.00307223f, 0.03297643f, 
    0.01975420f, 0.14851335f, 0.07740476f, 0.17447306f, 0.12581122f, 0.22121315f, 0.19835275f, 0.03600254f, 
    -0.00421816f, 0.13014714f, -0.03508136f, -0.03043365f, -0.00944143f, 0.05700966f, -0.12501776f, -0.12338264f, 
    0.32933450f, -0.15658735f, 0.17051890f, -0.09423875f, -0.02534119f, 0.09421208f, 0.06006868f, 0.04664099f, 
    -0.00685767f, -0.00287266f, 0.04104318f, 0.06484322f, -0.20635384f, 0.17579417f, 0.02898790f, -0.15834641f, 
    0.09890208f, 0.00333513f, 0.00516588f, -0.02305824f, 0.13985620f, 0.10597946f, 0.06303152f, -0.00881957f, 
    -0.15511999f, -0.00603011f, -0.03910841f, 0.05298527f, -0.01948004f, 0.13772799f, 0.04782320f, -0.10746759f, 
    -0.16701469f, -0.09950348f, -0.00647515f, -0.02439059f, 0.00297417f, -0.04252221f, -0.10162582f, 0.20166823f, 
    -0.01074396f, 0.02596419f, 0.09429424f, 0.16097300f, -0.07640764f, 0.03135080f, -0.09567098f, 0.10564158f, 
    0.04894548f, -0.17514621f, -0.09213312f, -0.04370372f, -0.07563912f, -0.04048304f, -0.03738283f, 0.09728117f, 
    0.02170070f, -0.00393562f, 0.02646367f, -0.02291818f, -0.12750173f, 0.13745837f, 0.02173571f, 0.10268170f, 
    0.08240985f, -0.02484502f, 0.06079248f, -0.03221913f, -0.02065913f, 0.02883074f, 0.01159509f, -0.19689266f, 
    0.02582002f, 0.00406959f, 0.00542796f, -0.03232913f, 0.02164735f, -0.05085519f, -0.04649949f, -0.04193135f, 
    0.03550988f, 0.03423611f, 0.00725739f, -0.00355902f, -0.02463925f, 0.02219407f, -0.00175824f, -0.02100746f, 
    -0.00164148f, 0.00035897f, -0.03795423f, -0.04792966f, -0.02230315f, 0.04833639f, -0.03314934f, 0.03527243f, 
    -0.01462543f, -0.01514565f, -0.01856711f, 0.01167502f, -0.02064437f, 0.04226196f, -0.00889943f, -0.00608409f, 
    0.02752401f, 0.04640870f, -0.01393034f, -0.02973656f, 0.03482481f, 0.02641259f, -0.03211555f, 0.00904550f, 
    -0.04661236f, -0.03818637f, -0.00787270f, -0.02927758f, -0.00516797f, 0.01829381f, -0.01805645f, -0.00895290f, 
    -0.03493831f, -0.00993267f, -0.02616202f, -0.00269402f, 0.03216407f, 0.02964504f, 0.00769906f, 0.03282335f, 
    -0.00603561f, -0.03487244f, -0.00942707f, -0.02832758f, -0.01194000f, -0.01109768f, 0.01690343f, -0.00633529f, 
    0.01073406f, 0.03916736f, -0.02060016f, 0.02649988f, 0.01854050f, 0.00512206f, -0.02738176f, -0.01456674f, 
    0.00060663f, -0.01817597f, 0.01816430f, -0.00315882f, -0.02936809f, -0.05057770f, 0.01234616f, 0.03977981f, 
    0.02618326f, 0.03148304f, -0.02036720f, 0.04751809f, -0.01611361f, 0.01578373f, -0.01040394f, -0.01033241f, 
    -0.01314772f, -0.02517481f, 0.02316364f, -0.05076512f, 0.00054052f, -0.00320619f, 0.02067307f, 0.03387772f, 
    -0.02342988f, -0.02653402f, 0.02569481f, -0.02166735f, -0.04926984f, 0.03129206f, -0.02042015f, -0.02224634f, 
    0.04131365f, -0.02247610f, 0.02438604f, 0.00497024f, -0.03536108f, -0.03350034f, 0.02511656f, 0.00528600f, 
    -0.04893392f, -0.03532625f, 0.01720341f, -0.01535293f, -0.00996252f, -0.00682517f, 0.02403116f, 0.03909173f, 
    -0.04332456f, -0.04661809f, 0.02691047f, -0.02463325f, 0.02818128f, -0.00577419f, 0.04839975f, -0.04942867f, 
    -0.02474615f, 0.02532681f, 0.02474766f, 0.01218767f, -0.04321230f, -0.01961524f, -0.01350624f, -0.00690005f, 
    -0.05083406f, -0.01609273f, 0.04741798f, 0.03471525f, -0.04133935f, 0.01841571f, -0.04628851f, -0.04670312f, 
    -0.02712225f, 0.04554788f, 0.05074473f, 0.04666043f, 0.03700813f, -0.01601794f, 0.00931388f, -0.04231010f, 
    -0.03050299f, -0.01647597f, -0.03810216f, -0.04457838f, 0.03079067f, 0.00051779f, 0.01989079f, -0.01559219f, 
    0.04413275f, -0.04174341f, -0.01825737f, -0.02569143f, 0.03622974f, -0.04041076f, -0.03085769f, 0.02758787f, 
    0.04689837f, -0.00202708f, 0.03959032f, 0.04199184f, -0.03601757f, -0.02696057f, -0.01893648f, 0.04559718f, 
    -0.03502557f, 0.02442377f, -0.01392217f, 0.04665983f, 0.03375681f, -0.03828996f, 0.04126161f, -0.03915062f, 
    0.04159869f, -0.03141719f, 0.00719704f, 0.03404205f, 0.03562365f, -0.04063422f, -0.02122973f, -0.01097709f, 
    -0.00666787f, -0.04925467f, -0.01054401f, 0.01924592f, -0.03832696f, -0.02822170f, -0.03071221f, 0.02785351f, 
    0.02017109f, 0.01724454f, -0.01845180f, 0.00570303f, -0.00368076f, 0.00948053f, 0.04017524f, -0.00381296f, 
    -0.02672264f, -0.04285429f, 0.02531481f, -0.01646095f, 0.00406382f, -0.01718419f, -0.04257453f, -0.04831589f, 
    0.04698714f, 0.04935327f, -0.01007343f, -0.00393441f, 0.03058536f, -0.03259538f, 0.00595441f, -0.03002083f, 
    0.04101715f, 0.00325687f, 0.01028525f, 0.00556865f, -0.00202868f, -0.02141142f, -0.04937146f, 0.03746554f, 
    -0.00287688f, 0.02839616f, -0.01052358f, -0.02133453f, 0.00412749f, -0.01979136f, -0.04145888f, -0.04953860f, 
    0.03602148f, 0.01208665f, 0.03950178f, -0.01536149f, -0.03978694f, 0.00897908f, -0.00757320f, -0.01755932f, 
    -0.00515471f, 0.01037021f, -0.00498307f, -0.03509576f, 0.00902447f, -0.00760923f, -0.01129412f, -0.02519162f, 
    0.00597760f, 0.04754666f, -0.01823144f, 0.02857290f, 0.04493706f, -0.04289044f, -0.00773346f, 0.01629978f, 
    0.04485065f, -0.04897686f, -0.04470889f, -0.01618663f, 0.04458598f, 0.04441805f, 0.02516066f, 0.02096752f, 
    -0.04121545f, 0.00629028f, -0.00403211f, -0.03832154f, 0.00083665f, -0.03920128f, -0.00044778f, 0.01932505f, 
    0.00960196f, -0.02000726f, -0.02051999f, 0.03823217f, -0.04128371f, -0.01483232f, -0.02551754f, -0.04732326f, 
    -0.02005897f, -0.04210037f, -0.02860236f, 0.04147535f, 0.02249182f, -0.01990500f, -0.01646637f, -0.04076595f, 
    -0.02665585f, -0.03372009f, 0.00954632f, -0.03527657f, -0.00222288f, 0.00277746f, -0.04082136f, 0.03513050f, 
    -0.00955746f, 0.03696129f, 0.02271811f, 0.04015751f, -0.02549272f, 0.03109971f, 0.03577406f, -0.02910454f, 
    -0.00700569f, 0.04299570f, -0.00262689f, -0.00124249f, -0.00239502f, -0.04257825f, 0.03340733f, -0.05100371f, 
    0.01396507f, -0.03231829f, -0.03628984f, 0.03746562f, -0.04624566f, 0.04775147f, -0.03566277f, -0.01911220f, 
    0.02340147f, -0.05068794f, 0.02728002f, 0.00312996f, -0.02744388f, -0.02337136f, 0.02686486f, 0.00165966f, 
    -0.02131162f, 0.00822705f, -0.01031787f, -0.00080155f, -0.00654773f, -0.00980355f, -0.02917991f, -0.00756885f, 
    0.01361036f, -0.02398674f, 0.00217292f, 0.01278397f, -0.02043169f, -0.02081157f, 0.04346614f, 0.03809552f, 
    0.03421428f, 0.00975982f, 0.00044756f, -0.03013989f, 0.02087021f, 0.04955691f, -0.02179660f, -0.04786444f, 
    0.02147442f, 0.00919063f, 0.00582915f, 0.01150163f, -0.02079640f, -0.00241894f, 0.04840823f, -0.03897785f, 
    0.05098718f, -0.01734695f, -0.03520471f, 0.03614391f, 0.00177514f, -0.04155523f, -0.00651613f, -0.00205602f, 
    -0.02198457f, -0.02602044f, -0.04053606f, 0.01144669f, 0.03962667f, -0.03479819f, -0.03921147f, 0.00471932f, 
    0.04556424f, 0.19378722f, 0.01110717f, -0.14701127f, -0.00889665f, 0.10725790f, 0.04600845f, -0.02220055f, 
    -0.05565373f, -0.06788197f, 0.00618910f, 0.06970145f, -0.06555593f, 0.11101640f, -0.24212731f, 0.23097628f, 
    -0.06026646f, -0.01561679f, -0.10129729f, 0.13323306f, -0.05357216f, -0.11493915f, 0.21468118f, 0.08269197f, 
    0.16654295f, -0.16937687f, -0.03940856f, 0.07606900f, -0.13427588f, -0.27208847f, -0.26360941f, -0.13968772f, 
    0.01155571f, -0.05079705f, 0.01865102f, -0.22687261f, 0.14750029f, -0.13387105f, 0.02052031f, -0.03691006f, 
    -0.01071190f, -0.01757254f, 0.06101633f, 0.05893160f, 0.14537880f, 0.03505654f, 0.01979264f, -0.02034794f, 
    0.19462951f, -0.37960562f, -0.19887328f, -0.36863741f, 0.19114850f, -0.03462841f, -0.09549481f, -0.20138176f, 
    -0.08310725f, -0.08778712f, -0.00570248f, 0.06374602f, 0.27733320f, 0.18303420f, 0.11995435f, -0.31342980f, 
    0.09313348f, -0.06918976f, 0.00511868f, -0.01997195f, 0.08605921f, 0.05803176f, 0.02247677f, 0.09114781f, 
    0.03827047f, -0.00798319f, -0.06177824f, 0.12627441f, -0.01646567f, -0.01863676f, 0.01131870f, 0.09694851f, 
    -0.13979989f, 0.05742890f, 0.03908972f, -0.05581838f, -0.12626836f, 0.01609724f, -0.23946109f, -0.01512278f, 
    0.02579151f, -0.02551703f, 0.02232723f, 0.01866408f, -0.01174881f, -0.10544238f, 0.07472796f, 0.01756902f, 
    0.33535913f, 0.04921535f, 0.02758146f, 0.06347413f, 0.04904287f, 0.02056095f, 0.12144790f, -0.00580579f, 
    -0.07702713f, 0.04473376f, 0.09042548f, 0.01216634f, -0.15080947f, 0.09332878f, -0.03435021f, -0.22811714f, 
    0.12431397f, -0.16046599f, 0.00317328f, 0.03725426f, 0.07957964f, -0.13471100f, 0.07105023f, 0.10454967f, 
    0.35293838f, 0.23916145f, -0.22101095f, 0.04110340f, 0.01197099f, 0.05339548f, 0.09340197f, 0.18349656f, 
    0.01451049f, -0.17731051f, -0.07897535f, -0.06345208f, -0.08450913f, 0.07438407f, 0.23095508f, -0.01729196f, 
    -0.04006799f, 0.07269918f, 0.12170245f, 0.01065005f, 0.02680843f, -0.02457858f, -0.03457734f, -0.02690858f, 
    0.07015884f, 0.13112497f, -0.05941131f, 0.35353968f, 0.16052067f, 0.10082338f, 0.11053205f, 0.15408553f, 
    -0.00305737f, 0.11201534f, 0.13225396f, 0.15311809f, -0.21389760f, 0.13318199f, -0.05682915f, -0.35725430f, 
    0.05178346f, -0.08467889f, -0.00844570f, 0.03474731f, -0.08034813f, -0.03596755f, -0.04052637f, 0.03711772f, 
    -0.02024154f, -0.15821731f, 0.10734350f, -0.06876410f, -0.13669339f, 0.15692912f, 0.06959134f, 0.00416684f, 
    -0.02252843f, 0.04278357f, 0.05818658f, 0.20680283f, 0.16860959f, 0.11673218f, 0.11720642f, -0.02805497f, 
    0.04976877f, 0.04458750f, 0.11419564f, -0.01388831f, -0.07034271f, -0.06247421f, 0.04722094f, -0.08515336f, 
    -0.28827482f, 0.28857180f, -0.15756035f, -0.16191395f, 0.19357373f, -0.03244832f, -0.05479389f, 0.06507572f, 
    0.16696687f, -0.01023682f, 0.04667130f, -0.04649064f, 0.28192621f, 0.10663696f, 0.13689774f, 0.02582598f, 
    -0.10182817f, 0.04788196f, 0.13774194f, -0.09145768f, -0.07901505f, 0.17926592f, 0.02943860f, 0.15814334f, 
    0.26136798f, -0.13794838f, 0.24598907f, 0.00097589f, 0.13658513f, 0.06968214f, 0.01447820f, 0.02936388f, 
    -0.00681925f, -0.00056117f, -0.02717105f, 0.07068712f, -0.25215733f, -0.07311679f, -0.22699176f, 0.21740869f, 
    -0.08223990f, -0.07384802f, -0.02986517f, -0.04580061f, -0.11886270f, 0.03759674f, 0.24074538f, 0.11758456f, 
    -0.45098099f, -0.24610020f, 0.11094691f, -0.17741854f, -0.14067428f, 0.00719321f, 0.02109285f, -0.03046124f, 
    0.04413437f, -0.12185885f, -0.09333370f, 0.08218376f, 0.10293817f, 0.02989615f, 0.11823490f, 0.11801909f, 
    0.06496440f, 0.09826775f, 0.10602865f, 0.13072298f, 0.08415537f, -0.00919608f, 0.11042368f, 0.07193925f, 
    0.16272937f, -0.03373377f, 0.20701212f, 0.36193043f, 0.17158131f, 0.14323092f, 0.01236386f, -0.03753198f, 
    0.11018097f, 0.05831929f, 0.10400148f, 0.14198552f, 0.06817151f, -0.02777780f, 0.07075221f, 0.02129365f, 
    0.05747528f, -0.10775756f, 0.09323182f, 0.07787451f, 0.09842335f, 0.12479399f, 0.04105344f, 0.01653834f, 
    -0.08460383f, 0.00648395f, -0.18747252f, -0.26277265f, -0.04993936f, -0.02507750f, -0.09751596f, -0.00941736f, 
    -0.07806541f, -0.00747312f, 0.05079586f, -0.04549677f, -0.04618668f, -0.01193159f, 0.06251545f, 0.03468905f, 
    0.00827267f, -0.02741310f, -0.04166556f, -0.15591446f, 0.01416188f, -0.00074048f, 0.04629890f, -0.04063019f, 
    -0.10048892f, 0.16112377f, -0.20494530f, 0.07466139f, 0.02756153f, -0.01969500f, -0.00809627f, -0.14897726f, 
    -0.01433350f, -0.06227741f, 0.03443573f, 0.00501607f, -0.08684710f, 0.06842845f, 0.06379841f, 0.23004717f, 
    -0.09678589f, 0.10897794f, -0.13416421f, -0.20302381f, 0.10415040f, 0.03243076f, -0.10639419f, 0.05097913f, 
    0.15939127f, -0.15528502f, 0.01769275f, 0.18081579f, 0.00069577f, 0.09991222f, -0.23304361f, -0.08258606f, 
    0.04054436f, -0.01577108f, 0.00518581f, -0.00729389f, 0.12489261f, 0.12500946f, -0.21694510f, -0.03308149f, 
    -0.06467103f, -0.07074495f, 0.00718137f, -0.13586886f, -0.03271193f, 0.03334462f, -0.00284167f, 0.06135230f, 
    0.24103159f, 0.02140861f, -0.06268390f, 0.00352810f, -0.00483090f, -0.06656186f, -0.14775774f, -0.06235230f, 
    -0.05801567f, -0.12915204f, 0.02972698f, 0.10095734f, -0.03433437f, -0.10631231f, 0.04731610f, 0.07050972f, 
    -0.01477458f, -0.09882276f, -0.06910621f, -0.01551749f, 0.01139984f, 0.11339813f, 0.06511790f, -0.08450743f, 
    0.03521012f, 0.08654974f, 0.09949332f, 0.04713149f, -0.05042180f, 0.04939204f, -0.00223890f, 0.00418812f, 
    -0.02900561f, -0.03116672f, 0.05440260f, 0.05551721f, 0.22826879f, -0.07562888f, -0.12577336f, 0.01924438f, 
    -0.06379654f, 0.05966619f, -0.03304525f, 0.03874809f, 0.08445784f, -0.02288681f, 0.10374543f, 0.04508039f, 
    0.06544871f, -0.18028884f, -0.11620589f, 0.03900862f, -0.07271294f, -0.05453332f, -0.06509993f, 0.03924614f, 
    -0.05941973f, 0.00316720f, 0.02611664f, -0.09017330f, 0.18137550f, -0.13395377f, 0.11267395f, 0.06945431f, 
    0.03063881f, -0.02358552f, 0.18449518f, 0.06158270f, 0.07280386f, 0.05307276f, 0.06188865f, 0.01625015f, 
    0.14027700f, -0.12505043f, -0.03406873f, -0.17215486f, 0.13591276f, 0.08242454f, 0.02335613f, -0.06028533f, 
    -0.00848003f, 0.02110286f, -0.02681104f, 0.02953454f, 0.03700175f, 0.10040963f, 0.11544479f, -0.06661130f, 
    0.00408411f, 0.04958916f, 0.01078152f, -0.05597007f, 0.18612365f, 0.13403696f, 0.16338761f, 0.03651421f, 
    0.09048440f, -0.16021672f, 0.05958134f, -0.00891156f, -0.02508171f, 0.06237417f, -0.06685270f, -0.01265711f, 
    -0.07693372f, 0.00809532f, 0.03708003f, -0.09812927f, -0.24316940f, -0.12519453f, -0.17737526f, -0.18935390f, 
    0.06151783f, -0.05213946f, -0.03466048f, 0.04145969f, 0.05418225f, -0.00411443f, -0.06716004f, 0.00584164f, 
    0.15862231f, 0.06285999f, 0.09704936f, -0.04761174f, 0.00482658f, -0.07580829f, 0.22432499f, 0.11210410f, 
    -0.07341798f, 0.00808517f, -0.04499199f, -0.03277772f, 0.00774890f, -0.05113192f, 0.07051615f, 0.16436023f, 
    -0.07847176f, -0.04575944f, 0.10637064f, 0.06194231f, -0.00674168f, 0.05819333f, 0.02326250f, 0.00970745f, 
    0.29832378f, 0.24429247f, -0.06860428f, 0.03701119f, -0.02251512f, -0.02341968f, 0.10611178f, 0.15581615f, 
    0.02645694f, -0.05669465f, -0.08520856f, -0.04635762f, -0.05799855f, 0.09555639f, 0.12751025f, -0.14535461f, 
    -0.00476962f, 0.04132655f, -0.00579636f, 0.01655588f, -0.06625869f, 0.08386795f, -0.12784222f, -0.08923978f, 
    0.20073193f, 0.25359046f, 0.05794869f, 0.14242673f, 0.01544687f, 0.04452075f, -0.02884238f, 0.05498518f, 
    0.05071744f, 0.10387862f, 0.02173485f, 0.06945406f, -0.19978772f, 0.16139673f, -0.08289211f, -0.19725905f, 
    0.08278734f, -0.05330447f, 0.03152569f, 0.11927800f, -0.00130196f, 0.07336612f, -0.01948273f, 0.09845358f, 
    -0.15089744f, 0.04190848f, 0.11632002f, 0.02071120f, 0.00117320f, -0.07105161f, 0.04033642f, -0.02526951f, 
    -0.12569502f, -0.07907423f, -0.02419971f, 0.03997220f, 0.20081739f, 0.10820151f, 0.18355843f, 0.08066071f, 
    0.08899972f, 0.05882686f, 0.02486541f, 0.02713449f, -0.08839313f, 0.04882068f, 0.12126999f, -0.06105959f, 
    -0.08290566f, 0.21194746f, -0.08049419f, 0.13180253f, 0.12604184f, 0.02711811f, -0.11561664f, -0.04150231f, 
    0.02717112f, 0.10001782f, -0.00574734f, -0.00456563f, -0.07704590f, 0.08329397f, 0.14024508f, -0.04451342f, 
    -0.15744382f, 0.04755916f, -0.05170841f, 0.02192250f, -0.00645447f, 0.16417027f, -0.04299652f, 0.02444250f, 
    0.15744454f, 0.05717454f, 0.14787278f, -0.03729418f, 0.04141903f, 0.09702290f, 0.09826175f, -0.07184746f, 
    -0.10602970f, 0.01791460f, -0.01996788f, -0.01711049f, -0.33088398f, -0.12721322f, -0.15365614f, -0.00520650f, 
    0.09095185f, -0.03597087f, 0.02812414f, -0.07713039f, -0.04449705f, 0.02823820f, -0.02508612f, 0.00528067f, 
    -0.32315153f, 0.04356694f, 0.27839389f, -0.08156299f, 0.05630495f, 0.04478859f, 0.08355667f, 0.02118339f, 
    0.06595508f, 0.04474636f, 0.03361813f, 0.06055691f, -0.03394498f, -0.01525971f, 0.09643962f, -0.04635376f, 
    -0.01673038f, -0.01205206f, 0.06446203f, 0.01457236f, -0.06656510f, -0.15868573f, -0.02965995f, 0.07239614f, 
    -0.07312685f, 0.01251817f, 0.02971409f, 0.12749098f, 0.04969123f, 0.06433563f, 0.01227512f, 0.07751016f, 
    -0.05783055f, -0.01001655f, -0.03608095f, 0.07334825f, 0.09958079f, 0.00171572f, -0.02431422f, 0.02851048f, 
    0.01139794f, -0.07119376f, 0.04328708f, -0.00407717f, -0.03103633f, 0.07833024f, -0.03366183f, -0.05846216f, 
    -0.23124622f, 0.08041658f, -0.03532266f, -0.06418321f, 0.00324409f, 0.05048184f, 0.08889116f, 0.07985400f, 
    0.02977616f, -0.01645905f, 0.11424144f, -0.03660425f, 0.15362388f, 0.12425501f, -0.19475445f, -0.17831230f, 
    -0.09456198f, 0.06439959f, 0.04744234f, -0.01633107f, 0.09940521f, -0.08083334f, -0.00057817f, -0.08606697f, 
    -0.10261917f, 0.17005414f, -0.07623047f, 0.23246984f, 0.07439340f, 0.03894734f, -0.02007709f, 0.05958313f, 
    -0.01715155f, 0.00234421f, -0.04477790f, 0.02278226f, 0.14749721f, 0.01741760f, -0.02032526f, 0.13021550f, 
    -0.06780489f, 0.10466747f, -0.06124900f, -0.07451139f, 0.09222878f, 0.13354716f, -0.18486173f, 0.08655047f, 
    -0.06825468f, -0.06354158f, -0.06095656f, -0.13845456f, 0.06005178f, 0.13370667f, -0.08784208f, 0.04893726f, 
    0.09407216f, -0.00565612f, -0.08359490f, 0.04535991f, 0.37486783f, -0.04706284f, -0.03502391f, -0.00406551f, 
    0.02331530f, 0.01323804f, 0.01452440f, -0.10797565f, -0.00898194f, 0.08219279f, 0.00739844f, 0.11918543f, 
    -0.34550115f, 0.08038325f, -0.05500634f, -0.03084995f, 0.11049844f, 0.01657524f, 0.02179490f, 0.10757369f, 
    -0.06612458f, 0.02583634f, -0.00318274f, -0.09372536f, -0.03241152f, -0.00593007f, -0.03252552f, -0.26031870f, 
    0.00363643f, -0.10783599f, -0.00758277f, -0.00452470f, 0.13222431f, 0.09222200f, 0.00599665f, -0.05643997f, 
    -0.04475196f, -0.01340523f, 0.02788724f, -0.03092807f, -0.00550024f, 0.00374379f, -0.02633951f, 0.02509444f, 
    0.00454019f, -0.03164696f, 0.01119516f, 0.02291436f, 0.03527482f, -0.05329989f, -0.02094025f, -0.01786474f, 
    -0.03670308f, 0.03385297f, -0.01564533f, 0.02129289f, 0.01998051f, 0.02923879f, 0.01623752f, -0.04668438f, 
    -0.01262058f, -0.05538742f, -0.00838758f, -0.03674360f, -0.00218252f, 0.00309521f, -0.01536546f, -0.01504150f, 
    -0.05041513f, 0.00656122f, 0.02399590f, 0.03662675f, 0.01050005f, 0.03606145f, 0.00725387f, 0.01601084f, 
    -0.01767042f, -0.03297612f, 0.02897149f, 0.02006633f, -0.02072233f, 0.01153107f, 0.01573282f, 0.00625413f, 
    -0.03597390f, -0.05151598f, 0.01857021f, -0.02190299f, 0.02958170f, -0.01791778f, -0.02379850f, 0.01783025f, 
    0.00288175f, -0.04120748f, 0.01609616f, -0.02250961f, -0.04250551f, -0.02789311f, -0.02099447f, 0.02500442f, 
    -0.00544264f, -0.01233567f, -0.04623047f, -0.01988553f, 0.01719492f, -0.04910890f, 0.01238456f, -0.01925380f, 
    0.03366782f, -0.02270198f, 0.02595398f, 0.03028542f, -0.04212175f, 0.01263024f, -0.04844790f, 0.03319973f, 
    -0.00122902f, -0.05542393f, 0.01590332f, -0.01825382f, -0.03619628f, 0.03126275f, -0.03299563f, 0.01992147f, 
    -0.06022891f, -0.03184367f, -0.00860371f, -0.01715231f, -0.04028332f, -0.05071105f, -0.02673365f, -0.02156765f, 
    0.03657811f, -0.01869284f, 0.00688952f, 0.00280130f, -0.01219607f, 0.01451546f, 0.02641223f, -0.03810703f, 
    -0.00380181f, -0.03028873f, -0.01359306f, 0.03842563f, 0.01925150f, -0.03794187f, -0.02038682f, -0.00413164f, 
    0.03615398f, 0.00839926f, -0.01987538f, 0.00162312f, -0.00789058f, -0.04282278f, -0.02496226f, 0.01651870f, 
    -0.05361361f, 0.01256110f, 0.01780953f, 0.02687139f, -0.03855520f, -0.05150686f, -0.04805601f, -0.00634977f, 
    0.04066916f, -0.01467886f, -0.01803117f, 0.02278252f, 0.01209219f, 0.02654592f, -0.02966321f, 0.02002743f, 
    -0.01801233f, 0.03882440f, -0.04890436f, -0.01248478f, -0.01293972f, -0.00747637f, -0.01203567f, -0.05069409f, 
    -0.04622452f, -0.01404246f, 0.02893747f, 0.04293367f, -0.03587488f, -0.00425089f, -0.02044579f, 0.03535423f, 
    -0.05411500f, 0.02641544f, -0.01207055f, 0.04092765f, -0.02115996f, 0.02063250f, -0.03252205f, -0.02345566f, 
    -0.01703894f, 0.01489672f, 0.00600231f, 0.01451362f, -0.04548094f, -0.04321721f, -0.02807362f, -0.03823904f, 
    -0.01132486f, 0.00728870f, -0.05108514f, -0.03978915f, 0.02036518f, 0.02362509f, 0.01102047f, -0.00323909f, 
    0.00887027f, -0.02335497f, 0.01606520f, 0.00174724f, -0.01258611f, 0.03309337f, -0.02243876f, -0.02227284f, 
    -0.05020251f, 0.01904436f, -0.03492302f, 0.02211387f, -0.01770416f, 0.03333946f, 0.03630948f, 0.02409238f, 
    -0.05879153f, 0.01519457f, -0.04056107f, 0.01247893f, 0.03690977f, -0.02936667f, -0.03696354f, 0.04121881f, 
    0.04362412f, -0.04293606f, -0.03433557f, -0.02951509f, 0.00067140f, -0.05827983f, -0.03122978f, -0.02613885f, 
    0.01903706f, -0.03004239f, -0.02440121f, -0.02922809f, 0.01932839f, -0.04812708f, 0.00354737f, 0.01421410f, 
    -0.04378597f, 0.00602219f, 0.02762073f, 0.03148945f, -0.00585244f, -0.04932182f, -0.02349800f, -0.00874273f, 
    -0.00466568f, -0.02638411f, -0.02647852f, 0.03793569f, -0.05535773f, -0.02476431f, 0.02913945f, 0.00767639f, 
    -0.05704189f, -0.03615594f, -0.00981420f, -0.03738242f, -0.03274285f, 0.02314102f, -0.00357753f, 0.01196899f, 
    -0.02077740f, 0.02132214f, -0.03122301f, -0.02086802f, 0.00331355f, 0.03377475f, -0.04184974f, 0.02769048f, 
    -0.00056284f, -0.03495525f, 0.01410171f, 0.02262172f, 0.01123980f, -0.01808311f, 0.02737268f, -0.05436162f, 
    0.01887150f, -0.04872215f, -0.04416250f, -0.00964652f, -0.03089267f, -0.00966848f, -0.01634835f, 0.00557638f, 
    -0.05440508f, -0.02659024f, 0.03782205f, 0.00219169f, -0.02018698f, -0.02133383f, -0.02260136f, 0.04084941f, 
    -0.01174316f, -0.02070761f, 0.01977269f, 0.03901076f, -0.05286696f, -0.03376048f, -0.02586729f, -0.01705190f, 
    -0.02599374f, -0.04289744f, -0.04858467f, -0.03685267f, 0.00611807f, -0.03804847f, -0.05902371f, -0.03626262f, 
    0.03312340f, -0.00441711f, -0.05911233f, -0.00822777f, -0.03562852f, 0.01498152f, 0.00253184f, 0.00918498f, 
    -0.05149887f, -0.04877006f, 0.01554198f, -0.02201040f, 0.02945838f, 0.00552509f, -0.00307238f, -0.00927328f, 
    -0.00757378f, -0.00093079f, 0.03779263f, -0.00538909f, -0.00091263f, -0.04119366f, -0.05715223f, -0.04864456f, 
    -0.01179247f, 0.02232830f, -0.03638653f, -0.02696511f, 0.02418354f, -0.04626684f, 0.01973351f, -0.01743373f, 
    0.01167211f, 0.03078116f, -0.02547264f, -0.02258026f, 0.03856016f, -0.01796798f, -0.01322509f, -0.02590691f, 
    -0.03419402f, -0.01482014f, 0.03362834f, 0.04112557f, 0.01182782f, -0.05634728f, 0.00017789f, -0.01700991f, 
    -0.00948040f, 0.01565449f, -0.00119676f, -0.04644722f, -0.01622876f, 0.02150134f, -0.05160431f, 0.00945607f, 
    -0.04815286f, -0.05334450f, -0.01976599f, 0.02792482f, 0.01946504f, 0.03888065f, 0.03062735f, 0.00265806f, 
    -0.02445745f, 0.03999340f, -0.02319347f, 0.02770558f, 0.03119862f, 0.01401574f, 0.02630633f, 0.03778390f, 
    0.01543576f, 0.01594643f, 0.03594982f, 0.01742947f, -0.03026725f, 0.00639450f, 0.02735244f, -0.04725730f, 
    -0.02337032f, 0.03311155f, 0.00769433f, -0.02945916f, 0.03546181f, -0.02762322f, 0.02937405f, -0.04781012f, 
    0.01110075f, 0.03148581f, -0.05648240f, -0.05183635f, 0.01243408f, -0.01175799f, 0.03340031f, 0.00970585f, 
    -0.00840885f, -0.03305173f, 0.03993758f, -0.05624064f, 0.00083602f, -0.04877052f, -0.00586778f, 0.03883890f, 
    -0.04322340f, 0.03996294f, -0.01017865f, 0.01334581f, -0.01206517f, 0.00088071f, 0.01138308f, -0.02177945f, 
    0.03339141f, -0.05274913f, -0.03867849f, 0.02532918f, -0.02006220f, -0.01477277f, -0.02134173f, -0.03025140f, 
    -0.02230025f, 0.00419143f, -0.05645601f, 0.00407816f, 0.01481736f, -0.00071590f, -0.04432225f, 0.00162809f, 
    0.02884520f, -0.00078567f, 0.04367779f, 0.04267918f, 0.01979082f, 0.00119621f, -0.04479187f, -0.04008653f, 
    0.03098426f, 0.02391446f, -0.05248267f, 0.00294046f, -0.04372555f, -0.04583350f, -0.04060487f, -0.04390464f, 
    -0.05548625f, 0.02209359f, -0.02664404f, 0.02218857f, 0.01688707f, 0.04172219f, -0.05396084f, -0.00567210f, 
    -0.00560223f, 0.04141218f, 0.03083235f, -0.03499551f, 0.00006190f, -0.00968387f, -0.05611995f, -0.00637386f, 
    -0.03292551f, -0.05346757f, -0.04270211f, -0.00933307f, -0.03352732f, 0.01298696f, -0.05195072f, -0.04594659f, 
    0.00351406f, 0.02989621f, 0.04056270f, 0.02542910f, 0.01842118f, -0.01237187f, 0.00063480f, 0.02831985f, 
    -0.05642151f, -0.03558487f, 0.01525945f, 0.04034672f, -0.02392776f, 0.02443081f, -0.02090108f, 0.03696771f, 
    -0.05144826f, 0.03606239f, 0.00386789f, -0.05226119f, 0.01341850f, -0.01401748f, 0.02628629f, -0.04535950f, 
    0.00111966f, 0.00857336f, 0.03928338f, -0.00826470f, 0.00041803f, -0.02570361f, 0.04306572f, 0.03762597f, 
    0.02568784f, 0.00655258f, -0.03667664f, -0.02621664f, -0.05249389f, 0.03110681f, 0.04598961f, -0.02106368f, 
    -0.00994682f, 0.01395688f, -0.05156467f, 0.00634564f, -0.04772373f, -0.01944870f, -0.02024838f, 0.01814818f, 
    -0.03385007f, -0.00327925f, 0.00404218f, 0.04093079f, -0.02561802f, 0.00778462f, -0.04043800f, 0.03986693f, 
    0.02901408f, -0.01886513f, -0.00153942f, -0.01672998f, -0.01041011f, -0.05262814f, 0.01929216f, 0.01730413f, 
    -0.02964176f, -0.04522984f, 0.03532983f, 0.01387717f, 0.00021795f, -0.05590365f, 0.01277400f, -0.05686769f, 
    -0.04123297f, -0.05310829f, 0.00203688f, 0.00899404f, 0.03798441f, 0.00151383f, -0.02441890f, 0.00112857f, 
    -0.00891672f, 0.02973503f, 0.01622289f, 0.00183346f, 0.00584739f, -0.02470118f, -0.01250101f, -0.03576696f, 
    0.01824701f, 0.04032261f, -0.03751882f, 0.03149932f, 0.03734450f, -0.03986577f, -0.02490971f, -0.03792390f, 
    0.01555436f, 0.01842912f, 0.01626440f, 0.03263652f, 0.01561512f, 0.01771274f, 0.00103560f, 0.00702167f, 
    -0.05647401f, -0.04093346f, 0.01030142f, -0.04318077f, 0.03500782f, -0.01383937f, 0.03312249f, 0.00205355f, 
    0.02203839f, -0.05195307f, -0.00896555f, 0.02276678f, -0.05633832f, -0.01516072f, 0.00228271f, -0.02661646f, 
    0.01028366f, 0.03648726f, -0.01516516f, 0.03224494f, 0.03933968f, -0.03582021f, 0.00961063f, 0.03898517f, 
    -0.04375804f, -0.02951373f, 0.04150099f, -0.05103582f, -0.00959030f, -0.01396272f, -0.03575272f, -0.01086915f, 
    0.02805494f, 0.01036557f, -0.03271143f, 0.01289915f, -0.02394771f, -0.05219328f, 0.03166302f, -0.01986490f, 
    0.04050312f, -0.04261896f, -0.02979265f, 0.01720994f, -0.00862435f, -0.03340920f, -0.03221429f, -0.01891357f, 
    -0.00528361f, -0.01567121f, -0.03053963f, -0.05795935f, -0.02541476f, 0.03038601f, -0.01335821f, 0.03728879f, 
    0.00037039f, -0.04005196f, 0.02842788f, -0.01676274f, 0.02167481f, 0.02935582f, -0.03727825f, -0.04793520f, 
    0.03777567f, -0.04723229f, -0.03924831f, -0.04577801f, -0.04812812f, -0.02100221f, 0.01321947f, -0.03212206f, 
    -0.03783292f, -0.03911841f, -0.02248292f, -0.01362520f, 0.04175666f, -0.05006859f, -0.03489758f, 0.01470929f, 
    -0.05514932f, 0.01781457f, -0.05581786f, -0.01346091f, -0.05551876f, -0.02060643f, 0.01317192f, -0.03439427f, 
    -0.03064135f, -0.02056027f, 0.03397489f, -0.01334324f, -0.04198522f, -0.02703758f, 0.00198528f, 0.03576106f, 
    0.02142782f, -0.05838997f, 0.03517653f, -0.05751653f, 0.03945508f, 0.02875653f, -0.03528538f, -0.04762136f, 
    0.02322949f, -0.02530716f, -0.01732123f, 0.02559427f, 0.01100568f, 0.02933106f, 0.01772044f, 0.04178761f, 
    -0.01422240f, 0.01573538f, -0.01024127f, -0.03744889f, 0.02784603f, 0.04008075f, 0.01896178f, -0.01588430f, 
    -0.01396817f, -0.01152828f, -0.04313402f, -0.04747340f, 0.03104674f, 0.01604527f, -0.01744608f, -0.01137235f, 
    -0.00008032f, -0.02170951f, -0.04578236f, 0.01231338f, -0.03816165f, -0.02142107f, 0.03270551f, -0.04004121f, 
    -0.00439695f, -0.05486607f, -0.04958311f, -0.05098500f, -0.04355178f, 0.03387558f, 0.01204318f, -0.05293320f, 
    -0.00158896f, 0.03848988f, 0.01937385f, 0.00506917f, -0.01616842f, -0.02041519f, 0.02887804f, -0.02820634f, 
    0.02926874f, 0.04400476f, -0.03731041f, -0.03848178f, -0.03709424f, -0.02007169f, 0.03334640f, -0.01333523f, 
    -0.01851742f, 0.03457883f, 0.00157983f, 0.01098846f, -0.05600672f, -0.02870803f, -0.00398864f, -0.02945159f, 
    -0.03530888f, -0.04122084f, -0.04677590f, -0.04654318f, -0.03921553f, -0.05621771f, -0.00589719f, 0.00587824f, 
    0.01183771f, -0.05408447f, -0.03638502f, -0.03061016f, -0.04022691f, -0.00994973f, -0.05402201f, 0.00343641f, 
    -0.05230343f, 0.03143629f, 0.03246952f, -0.03213147f, 0.01387495f, -0.02221377f, 0.03527329f, 0.00538667f, 
    0.00126172f, -0.03752433f, 0.03167169f, -0.03629095f, 0.00225381f, -0.01705477f, 0.00596520f, -0.03582435f, 
    0.04162437f, -0.04283038f, 0.00365458f, -0.02134873f, -0.03615277f, 0.00927538f, -0.00587457f, 0.03042063f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01589773f, -0.02072566f, 0.00772597f, -0.01174089f, -0.04491602f, 0.05433850f, 0.06787798f, 0.01817274f, 
    -0.06530258f, -0.00388181f, 0.03453523f, 0.00550038f, -0.03035579f, -0.05097153f, 0.02451921f, 0.07612576f, 
    0.01040041f, 0.02388258f, -0.07616341f, 0.05190999f, -0.05785945f, 0.02966606f, -0.03441958f, -0.01564368f, 
    0.01262978f, 0.01812345f, 0.05153259f, 0.03342557f, 0.08168238f, 0.07372457f, -0.00309438f, 0.04691740f, 
    -0.02635609f, 0.06387759f, -0.02181874f, 0.00589436f, 0.04345997f, 0.05236815f, -0.00814657f, 0.07727471f, 
    0.03596385f, -0.03237079f, 0.12807384f, 0.03647807f, -0.01061989f, -0.03776722f, 0.02444107f, -0.04036329f, 
    0.00411427f, 0.01758029f, 0.03446571f, 0.02704217f, -0.03128531f, -0.06281668f, -0.05499648f, 0.03516824f, 
    -0.02984616f, -0.01661979f, 0.05314286f, 0.02149738f, 0.05259007f, 0.03566221f, -0.04034521f, -0.03652090f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.10235437f, 0.33235624f, 0.06678483f, -0.03205863f, -0.09634432f, -0.00293335f, -0.17240760f, -0.12376520f, 
    0.09367612f, -0.03689261f, -0.03081699f, 0.02159561f, -0.03210034f, 0.29818571f, 0.00209713f, -0.23242383f, 
    -0.32098579f, -0.09995982f, 0.12055765f, 0.10572655f, -0.06958804f, 0.08820204f, -0.11603359f, -0.07981104f, 
    0.04637257f, -0.10756013f, -0.43873876f, -0.09481935f, 0.08333354f, -0.04738291f, -0.06452703f, -0.42956215f, 
    0.07938654f, -0.07887968f, 0.06302937f, 0.30978012f, 0.00563593f, 0.10518695f, -0.09745003f, -0.37422231f, 
    -0.09797364f, 0.07494505f, 0.00128748f, -0.08859928f, 0.00262476f, 0.12868951f, -0.08825884f, 0.05661846f, 
    -0.08687039f, -0.28837323f, -0.06716262f, -0.06667602f, -0.02231040f, 0.16348112f, 0.23898382f, -0.41301373f, 
    0.32224271f, 0.16476087f, -0.25977513f, 0.02875338f, 0.33122748f, 0.26218644f, 0.00672456f, 0.11819062f, 
    0.07662395f, -0.63557214f, -0.04089480f, -0.09037059f, -0.07983211f, -0.29317477f, -0.31943801f, -0.38108236f, 
    -0.02468235f, -0.07387256f, -0.34702954f, 0.07860506f, -0.04288407f, 0.19937557f, -0.12257735f, 0.11733290f, 
    -0.39729258f, 0.26827866f, -0.17286140f, 0.14799827f, -0.14126514f, 0.30866262f, 0.08748722f, -0.05229093f, 
    0.08891733f, -0.05419134f, 0.10325039f, -0.06292122f, -0.05175787f, 0.17277846f, -0.05395575f, -0.00774085f, 
    0.01528080f, 0.19518241f, 0.00770982f, -0.06740129f, -0.07323453f, 0.21607688f, 0.09340344f, -0.11870660f, 
    0.07193633f, -0.05277264f, 0.19638924f, -0.07147749f, -0.11356581f, 0.17680605f, 0.07889519f, 0.01370725f, 
    -0.41369507f, 0.09981411f, -0.05755894f, 0.12305652f, 0.11351527f, 0.21124998f, 0.18212253f, -0.04947946f, 
    0.17476313f, -0.11568614f, 0.03273398f, 0.11776452f, -0.27727416f, -0.15102379f, 0.04680806f, -0.09854329f, 
    -0.07933614f, 0.22955832f, -0.07222392f, -0.01065843f, 0.00902317f, -0.48518649f, -0.30532527f, -0.27602157f, 
    -0.14605704f, 0.05215473f, 0.07328301f, 0.00639666f, 0.06887375f, -0.34661362f, 0.01433367f, 0.04423090f, 
    -0.23564044f, 0.30769554f, 0.14709273f, 0.13548999f, 0.03553091f, 0.08927105f, 0.10154255f, 0.11069864f, 
    -0.31131577f, 0.04836513f, 0.06347436f, 0.02187497f, -0.31884974f, -0.04444046f, 0.08022646f, 0.28356671f, 
    -0.05853567f, -0.07289410f, 0.03418763f, 0.25033152f, 0.00643802f, 0.12306838f, -0.13167663f, 0.10355819f, 
    -0.21926509f, -0.12963502f, -0.28631672f, -0.01646402f, -0.01513505f, 0.10084260f, 0.09281511f, 0.09301197f, 
    0.07672195f, -0.49963832f, 0.05351164f, 0.02393672f, 0.05268679f, -0.05760438f, 0.24643333f, 0.15503876f, 
    -0.29442415f, 0.39482155f, 0.38735288f, 0.02112381f, 0.02248886f, 0.10891137f, -0.05219678f, 0.06182491f, 
    -0.00698105f, 0.18648607f, 0.04255931f, 0.11278942f, 0.01070952f, 0.08936518f, 0.34389606f, -0.04840720f, 
    -0.61782765f, -0.01377040f, 0.13939451f, 0.06221062f, 0.06076247f, 0.09445393f, -0.05918287f, -0.31422991f, 
    -0.10032476f, -0.50467610f, 0.22014074f, -0.15347594f, 0.07316218f, 0.08136268f, -0.13507564f, -0.09197984f, 
    -0.45582765f, 0.07469898f, 0.28669444f, -0.07927903f, 0.00368046f, -0.08491138f, 0.09142774f, -0.13873345f, 
    0.01079009f, 0.26455984f, 0.05729534f, -0.05474117f, 0.01955761f, -0.25177166f, 0.04721409f, 0.20490396f, 
    0.08293883f, -0.05659140f, 0.15430787f, -0.06733963f, -0.07046475f, -0.53511918f, -0.07379967f, -0.11471390f, 
    -0.06085180f, -0.50063187f, -0.03857627f, -0.06481968f, -0.06555964f, 0.08872966f, 0.02536594f, -0.38859978f, 
    0.12887645f, -0.31891930f, 0.24894130f, 0.05179206f, 0.14018211f, -0.13502209f, -0.10415103f, 0.08520833f, 
    -0.12003063f, -0.18600029f, 0.09206398f, 0.10073157f, 0.09439724f, 0.12648693f, 0.16743959f, 0.07564458f, 
    0.10336920f, -0.09962499f, 0.02797855f, 0.11057529f, 0.06147552f, -0.37123668f, 0.10361072f, -0.38949999f, 
    -0.07724921f, 0.07209898f, -0.21247256f, -0.19404298f, -0.08889852f, 0.23833418f, -0.08269303f, -0.04120513f, 
    0.23720141f, -0.09625336f, 0.15968587f, -0.11080091f, 0.12225092f, -0.45963487f, -0.02989710f, 0.25019237f, 
    -0.00384569f, -0.18465172f, 0.05265842f, -0.06721791f, 0.11127059f, -0.16102593f, 0.04414897f, -0.12180696f, 
    0.10581339f, 0.05789555f, -0.33650553f, -0.05166689f, 0.01843173f, -0.04096838f, -0.06414203f, 0.00652648f, 
    0.26733643f, 0.14972621f, -0.00790095f, -0.08540106f, 0.09683058f, 0.07226192f, 0.19945906f, -0.08437534f, 
    0.30285606f, -0.24513374f, 0.14720216f, 0.10537903f, 0.35740638f, -0.05859841f, -0.05797659f, 0.05210969f, 
    -0.00324463f, -0.00245719f, -0.03820692f, -0.04590822f, -0.01337005f, 0.14518958f, 0.00502410f, 0.11567922f, 
    0.19314247f, 0.03256238f, -0.13926312f, -0.09422629f, -0.10675257f, -0.20106153f, -0.02446879f, 0.09126880f, 
    -0.16883236f, -0.01941997f, 0.16497266f, -0.09881358f, 0.01200714f, -0.56613272f, 0.06746521f, -0.01771478f, 
    0.27959484f, -0.02914795f, -0.27526957f, 0.02058922f, 0.01209990f, 0.27789703f, -0.02193732f, 0.13258421f, 
    -0.11353408f, -0.13221316f, 0.07452973f, -0.05753459f, -0.04837531f, 0.10202935f, -0.09718535f, 0.09040313f, 
    0.34275752f, 0.06830631f, 0.24149245f, -0.09921104f, -0.11353312f, 0.13326675f, -0.01087889f, 0.10146876f, 
    0.08036006f, 0.31678399f, -0.01592577f, 0.10240892f, -0.05933530f, 0.15478644f, 0.06228153f, 0.16783234f, 
    0.12327285f, -0.19726381f, -0.55064607f, 0.06584157f, -0.27749512f, -0.38845757f, 0.05232849f, -0.08480953f, 
    -0.04814992f, 0.09126743f, 0.07157993f, 0.05868292f, -0.07565337f, -0.16664109f, 0.05890833f, 0.12337390f, 
    0.24931851f, -0.03618866f, 0.13587551f, 0.06338321f, 0.06310534f, 0.13469400f, -0.05769274f, -0.15946062f, 
    0.25608954f, 0.20146972f, 0.14725670f, -0.01187064f, -0.07832801f, -0.41036412f, 0.05492748f, -0.01230509f, 
    -0.43475261f, 0.11021126f, 0.02067743f, -0.12336845f, 0.17684032f, -0.38943860f, -0.09207363f, 0.00056785f, 
    -0.12372325f, 0.20933454f, 0.06862310f, 0.04274012f, -0.11600826f, -0.00074310f, 0.04185089f, -0.40860486f, 
    -0.04514211f, -0.04104077f, -0.07666904f, 0.03035044f, 0.10643173f, 0.00372538f, 0.02907495f, 0.01601430f, 
    -0.22230700f, 0.29106104f, 0.09860162f, -0.03492414f, -0.06970877f, -0.37752417f, -0.04950342f, 0.12741157f, 
    -0.61605662f, 0.27730978f, 0.41440871f, 0.08210593f, -0.62577182f, -0.26078939f, 0.10007444f, 0.07069935f, 
    -0.06770821f, 0.22822568f, 0.01729064f, 0.07960023f, -0.06544171f, 0.29540122f, -0.12645218f, 0.25043985f, 
    0.16841641f, -0.02481702f, 0.06265410f, -0.00589720f, 0.08185706f, 0.02115372f, -0.03225674f, 0.07812957f, 
    0.27544406f, -0.14366235f, 0.16502386f, -0.39806569f, -0.09579446f, -0.16479252f, -0.08476894f, 0.05171515f, 
    -0.30384284f, 0.04410549f, -0.01777899f, 0.06145607f, -0.17730659f, 0.09628188f, -0.07700650f, 0.26217264f, 
    -0.07693075f, -0.10428707f, -0.10883674f, -0.51209360f, -0.11631881f, -0.39100403f, -0.03593023f, -0.02274842f, 
    -0.35156581f, 0.04402760f, -0.19303079f, 0.10370395f, -0.02013499f, 0.10988455f, -0.06697866f, 0.02369765f, 
    0.27757794f, -0.13831989f, -0.09855725f, -0.05800036f, 0.03459162f, 0.20448823f, -0.29711083f, -0.18628743f, 
    0.26604205f, -0.17910963f, -0.02716610f, 0.03867115f, 0.12638681f, 0.20621748f, 0.09060626f, 0.05452772f, 
    -0.02836246f, -0.22869883f, -0.02584331f, -0.06559832f, 0.06091658f, -0.26657087f, -0.27125040f, 0.42461967f, 
    -0.14533670f, 0.02151909f, -0.43845654f, 0.10554004f, -0.08620436f, 0.00325437f, -0.02579091f, 0.22345965f, 
    0.21701041f, -0.29248074f, 0.27318633f, 0.17727178f, -0.09942014f, 0.22475013f, 0.00343689f, -0.11163143f, 
    -0.18568313f, -0.08271257f, 0.15097795f, -0.05247114f, -0.32573089f, 0.03472961f, 0.09156101f, -0.04295564f, 
    0.12691902f, 0.29290426f, -0.09915569f, 0.04092320f, 0.03041596f, 0.02210843f, 0.00132641f, 0.13271680f, 
    0.03191052f, -0.06559502f, -0.29300368f, 0.08430721f, 0.06086857f, 0.33168268f, -0.05333691f, -0.01819192f, 
    -0.27495071f, -0.27375615f, 0.00082238f, 0.02258391f, -0.09754346f, -0.17524362f, 0.07157265f, 0.25998488f, 
    -0.03121901f, -0.35360533f, -0.24718526f, 0.04487485f, -0.36303914f, -0.27457684f, 0.02329447f, 0.12948821f, 
    -0.04085260f, 0.21819463f, 0.11027625f, 0.09656255f, -0.08053796f, 0.15860566f, -0.17556158f, -0.24393485f, 
    0.28523481f, 0.05312221f, -0.01332393f, -0.09303419f, -0.05722254f, 0.24021518f, -0.03518449f, -0.34482920f, 
    -0.07785078f, -0.01369791f, 0.25278214f, 0.28224742f, 0.05280382f, 0.10081428f, 0.12413073f, -0.08326863f, 
    0.32595387f, -0.05680136f, 0.12786783f, -0.05339702f, 0.16347747f, -0.30702904f, 0.05787234f, 0.35020989f, 
    0.10342255f, -0.47287461f, 0.05166706f, -0.23635966f, -0.10735476f, -0.01352393f, 0.11113901f, 0.22087127f, 
    -0.13503097f, -0.08910359f, -0.18428414f, -0.06512462f, 0.10488113f, -0.64742833f, -0.08872587f, -0.09728723f, 
    -0.29935730f, -0.05838953f, 0.08226743f, -0.04857143f, -0.11481696f, -0.55696249f, -0.27202958f, 0.29537815f, 
    -0.32730410f, -0.01347403f, -0.23163807f, 0.04085056f, 0.06543661f, 0.28958732f, -0.11297233f, -0.01766470f, 
    -0.07322423f, 0.01426353f, -0.08059332f, -0.11571962f, 0.00002121f, 0.03248765f, -0.19174346f, -0.35139772f, 
    -0.39378512f, -0.12141317f, -0.05860507f, 0.02209574f, 0.04284479f, -0.09132719f, 0.00826945f, 0.21922313f, 
    0.12891316f, 0.05282530f, -0.63104546f, -0.02597179f, -0.04873762f, -0.14390919f, 0.00006600f, 0.05914545f, 
    -0.10494544f, -0.02817103f, 0.18157136f, -0.09596554f, 0.02035487f, 0.30700526f, 0.00784428f, 0.02284438f, 
    0.07449102f, 0.12754107f, -0.12675352f, 0.36368689f, -0.08121311f, 0.14331421f, 0.00843017f, 0.13581294f, 
    0.10467149f, -0.12766556f, 0.25828135f, 0.01458668f, -0.03041784f, 0.12548772f, 0.08895130f, 0.06218112f, 
    0.15961325f, -0.15879013f, -0.08949467f, 0.10957808f, -0.03669337f, -0.23917736f, -0.73810077f, -0.16548473f, 
    -0.40563127f, -0.65730101f, 0.22817984f, 0.02136616f, 0.08969030f, 0.34306288f, -0.03080086f, 0.02733582f, 
    -0.01782341f, 0.19835719f, -0.11527724f, -0.09765808f, -0.03799872f, -0.31338856f, -0.02839355f, 0.32613444f, 
    -0.23194683f, -0.00576763f, 0.23802800f, 0.06346144f, -0.09735100f, -0.21734051f, -0.11451724f, 0.20639230f, 
    0.06888372f, -0.25114608f, -0.30262575f, -0.10472444f, 0.04819771f, 0.22015575f, -0.02255974f, 0.08928985f, 
    -0.25460023f, -0.08218638f, 0.16546246f, 0.01409168f, -0.00641604f, -0.11587042f, -0.00325195f, -0.56976479f, 
    -0.09342278f, -0.17795996f, 0.07931118f, -0.32934552f, 0.08945323f, 0.13040221f, -0.04549541f, 0.25648713f, 
    -0.24437179f, -0.10296298f, 0.11996013f, 0.05365453f, -0.04973594f, -0.18766603f, -0.10260822f, -0.11946663f, 
    0.25571525f, 0.17423843f, 0.01428264f, 0.08017352f, 0.02347325f, 0.36110705f, 0.06372771f, 0.28472680f, 
    -0.33454159f, 0.27347243f, -0.18130149f, -0.02290337f, -0.07662033f, -0.11272387f, -0.01769057f, -0.05111719f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.15315446f, 0.11132908f, -0.12714902f, 0.06980289f, -0.11753340f, 0.10181960f, 0.08364716f, -0.19926916f, 
    -0.07751353f, 0.08769324f, 0.07346791f, 0.12359238f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
