#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.76865512f, 0.45555454f, -0.37826809f, -0.28681168f, -0.08898652f, -0.69362438f, -0.27960977f, 0.14849466f, 
    0.04202027f, 0.42229694f, -0.11105503f, 0.14244510f, 0.28179583f, -0.21827814f, -0.10276439f, -0.07256025f, 
    0.24198574f, 0.15968023f, -0.13730496f, -0.16904083f, -0.02495468f, -0.06480081f, -0.04307350f, 0.23296566f, 
    -0.30353189f, 0.44631138f, 0.55079848f, 0.34873235f, -0.04577683f, -0.60304987f, -0.25661075f, -0.54160470f, 
    0.02284371f, 0.29982319f, 0.17974111f, 0.26601794f, -0.19046882f, 0.10173377f, 0.00067806f, -0.17697923f, 
    0.04029870f, 0.10960467f, -0.24608204f, 0.01467129f, -0.18262947f, -0.02649110f, -0.05906990f, -0.16762863f, 
    0.01500372f, 0.24117438f, 0.20507647f, -0.01136986f, 0.03951601f, -0.38033453f, -0.43878165f, 0.46267819f, 
    -0.27178457f, 0.07910964f, 0.19233035f, 0.11370294f, -0.05777935f, 0.18797049f, -0.17796162f, 0.10161036f, 
    -0.04072979f, 0.11993945f, -0.00100947f, 0.18108837f, -0.06099444f, -0.23911671f, 0.18746208f, 0.10433916f, 
    -0.23936263f, 0.24719062f, -0.25999922f, 0.07883120f, -0.91843051f, -0.72294265f, -0.36705187f, -0.17244020f, 
    -0.14743336f, 0.23211187f, 0.32547402f, 0.16926831f, 0.17347935f, 0.03784800f, 0.34047583f, 0.29494435f, 
    -0.19523069f, 0.26160526f, -0.16615176f, -0.26097882f, -0.03536600f, 0.00048087f, 0.13597357f, -0.01425736f, 
    -0.29489017f, 0.01488206f, 0.07719811f, -0.14207920f, -0.65744162f, 0.12073900f, 0.44624048f, 0.47564477f, 
    0.22267780f, 0.15984260f, -0.37181172f, 0.16469131f, 0.20757110f, -0.11637807f, -0.42596766f, -0.05520680f, 
    0.30834568f, 0.01267677f, 0.13030778f, -0.21372291f, -0.10694447f, 0.00517728f, -0.16555037f, 0.32860702f, 
    -0.30897921f, 0.01533678f, 0.16322070f, 0.04524907f, 0.02946701f, -0.26872420f, -0.49375677f, -0.26036587f, 
    -0.14940943f, -0.08408498f, -0.51342732f, -0.55530256f, -0.63703126f, -0.45559356f, -0.19723685f, 0.62238485f, 
    0.11999197f, 0.50188833f, 0.15243858f, 0.20659645f, -0.21585856f, -0.38576478f, -0.09700068f, -0.36560693f, 
    -0.18428750f, 0.19748048f, 0.07913273f, -0.24299408f, -0.32592496f, -0.05401865f, 0.16153467f, 0.41775516f, 
    0.29204628f, 0.15019564f, 0.03860828f, -0.20276803f, -0.39466578f, 0.20203333f, 0.06627435f, -0.17316385f, 
    -0.28152865f, 0.10668750f, -0.20275100f, 0.28620267f, -0.38824239f, 0.23069943f, 0.10709827f, 0.09730015f, 
    -0.15539677f, 0.02646049f, -0.29942203f, -0.15713874f, -0.13138291f, -0.11386648f, -0.32365143f, 0.75399357f, 
    0.12180950f, -0.28720835f, -0.14229637f, 0.27031016f, -0.25052887f, 0.16983339f, -0.33620852f, -0.31775329f, 
    -0.24714477f, 0.09765908f, 0.31529605f, -0.00660534f, 0.14878613f, 0.11881329f, -0.03070023f, -0.13554919f, 
    0.07288327f, 0.19755378f, -0.14338467f, 0.26176032f, -0.31069598f, -0.04023631f, 0.14501648f, -0.25121966f, 
    -0.51232964f, 0.02367825f, 0.24670190f, 0.11576311f, -0.10379567f, 0.10423437f, -0.02959670f, 0.00018731f, 
    0.04586334f, 0.22040412f, 0.03360948f, 0.17021133f, -0.26167691f, -0.15613334f, 0.08394154f, -0.16357045f, 
    0.03799159f, -0.12735252f, -0.03378624f, -0.48722729f, 0.22086349f, 0.27899179f, 0.22093637f, 0.24534926f, 
    0.22573397f, 0.37515268f, -0.41695243f, -0.38415056f, 0.28775468f, 0.22980998f, 0.79209489f, -0.24062254f, 
    -0.30800822f, -0.56265670f, -0.28751329f, -0.06587364f, 0.11504039f, -0.18106069f, -0.02196981f, -0.16338734f, 
    0.23344629f, 0.10146750f, 0.16958384f, -0.16854225f, 0.01743321f, -0.42329183f, -0.23384461f, -0.17612092f, 
    0.18841146f, -0.13621834f, -0.27031234f, 0.23825160f, -0.11032994f, 0.19355167f, -0.05442753f, -0.41393951f, 
    -0.02771783f, -0.16593625f, 0.05285162f, -0.31607294f, 0.46919680f, -0.14428622f, -0.05804651f, 0.07739430f, 
    0.03603978f, 0.13751140f, -0.17201693f, -0.10501412f, -0.25012004f, 0.01584403f, 0.06173655f, 0.23836483f, 
    0.00570603f, 0.08624141f, 0.44304124f, 0.53491729f, -0.84540087f, -0.38380018f, 0.60563362f, 0.19962956f, 
    -0.27488023f, 0.40800276f, -0.27995214f, 0.05751785f, 0.08483327f, -0.17541002f, 0.13737221f, 0.00023563f, 
    -0.31719965f, 0.32834166f, 0.00210933f, -0.04185211f, 0.13116297f, -0.11364438f, -0.10419481f, 0.16054192f, 
    -0.13927096f, -0.01333443f, 0.10940777f, -0.05188319f, 0.47445825f, -0.32427341f, 0.04424011f, -0.36209163f, 
    -0.03710315f, 0.09565003f, 0.51739055f, 0.19002773f, -0.23784003f, -0.33094886f, 0.11652521f, -0.03154711f, 
    0.06619762f, -0.03450423f, -0.02796583f, -0.22496295f, -0.08972233f, 0.31279245f, -0.18671151f, -0.00310158f, 
    0.48974094f, -0.15635021f, -0.46826521f, 0.27294046f, -0.20828372f, 0.87148428f, 0.49796480f, 0.28090939f, 
    -0.86106968f, -0.99474907f, -0.01712889f, 0.42251348f, 0.22544420f, -0.08564436f, -0.29500040f, -0.42455363f, 
    0.20315343f, 0.15008122f, -0.08295669f, 0.33397925f, 0.03662309f, 0.00674123f, 0.20918643f, -0.20998408f, 
    0.01953651f, 0.03515504f, -0.19667068f, 0.11011107f, -0.17729433f, 0.11464049f, -0.94304210f, -0.69731343f, 
    -0.22005916f, 0.04242128f, 0.36102551f, 0.42930457f, 0.37933093f, 0.01925144f, 0.23726088f, 0.33919904f, 
    0.13612524f, 0.05341576f, -0.22241804f, 0.03322450f, 0.15005524f, -0.18954648f, -0.04364198f, -0.02016514f, 
    0.27395260f, -0.14220940f, -0.01811751f, -0.16744654f, -0.04028985f, -0.01941701f, 0.22883314f, 0.48206195f, 
    -0.18482889f, -0.37691221f, -0.38575807f, -0.57331431f, 0.60015982f, -0.03991168f, 0.22473291f, 0.10435470f, 
    -0.07529757f, 0.06498134f, 0.21334413f, 0.25106898f, -0.37384018f, -0.00971743f, -0.22350505f, -0.11036756f, 
    0.21598749f, -0.02577132f, 0.10493245f, -0.14203876f, -0.08932854f, 0.18259825f, 0.32849124f, -0.13707182f, 
    -0.96010464f, -0.16175938f, 0.37676775f, 0.55463314f, 0.08360173f, 0.63478488f, 0.21426387f, 0.17292479f, 
    -0.45861304f, -0.02336257f, -0.42682281f, -0.19566514f, -0.23066194f, -0.19844393f, -0.12748468f, 0.16768949f, 
    0.11764013f, -0.00905685f, 0.27457646f, 0.10527921f, -0.13768739f, -0.19560744f, -0.19633368f, -0.09857509f, 
    -0.09769386f, 0.57123554f, -0.19216630f, -0.04551166f, -0.84233522f, -0.61968863f, -0.11632789f, 0.14758956f, 
    0.17241247f, 0.25646275f, -0.01637721f, -0.04074350f, -0.31466952f, 0.07186570f, -0.14235702f, 0.20447677f, 
    0.03846165f, -0.07825644f, -0.23027517f, -0.27132624f, -0.00741019f, -0.36896685f, -0.33705002f, -0.15977843f, 
    -0.35851297f, -0.43929499f, -0.27888486f, -0.41414690f, -0.23905993f, -0.22948802f, -0.44182169f, -0.31512785f, 
    -0.28148538f, -0.14265426f, -0.21138036f, -0.03454994f, 0.10500155f, -0.09019105f, 0.08456954f, 0.29978448f, 
    0.26377118f, -0.11276945f, -0.06204417f, 0.02880218f, -0.08620737f, -0.15843926f, -0.10857769f, -0.23306881f, 
    -0.09392845f, -0.25380960f, -0.28132245f, -0.76332992f, -0.60113031f, 0.05427409f, 0.26850417f, -0.36533332f, 
    0.38769031f, 0.26680860f, 0.19008632f, 0.08715563f, 0.03627846f, 0.22091953f, -0.19218609f, 0.12520121f, 
    0.46484262f, -0.30373850f, -0.19148943f, -0.28396952f, -0.19787438f, -0.00503236f, -0.12467037f, 0.11055591f, 
    0.10547625f, 0.42002276f, -0.14513527f, -0.09934230f, 0.43399379f, 0.24016221f, -0.59344715f, -0.38775992f, 
    0.01515838f, -0.42778641f, -0.39475110f, -0.10830761f, -0.17547370f, 0.24435520f, 0.21871524f, 0.45821932f, 
    0.37953612f, 0.23553216f, 0.15544650f, 0.06049211f, -0.08322527f, -0.32906955f, -0.21912518f, 0.03672386f, 
    -0.05053449f, 0.06906311f, -0.05436062f, 0.05698487f, -0.06994141f, 0.17553338f, -0.34289351f, -0.18271528f, 
    0.23645389f, 0.36288771f, -0.00955352f, -0.59347558f, -0.46587479f, 0.30940515f, 0.64755517f, -0.20253515f, 
    -0.00108593f, 0.37418559f, 0.22407620f, -0.31771004f, 0.00077154f, -0.26842925f, 0.30719736f, 0.01099249f, 
    -0.33651429f, 0.07436816f, -0.14670686f, -0.11138304f, 0.26077375f, 0.16142818f, 0.34974357f, -0.28315732f, 
    -0.41918930f, -0.22190589f, 0.41354445f, 0.06331390f, 0.25125939f, -0.07345697f, 0.30567217f, -0.40721458f, 
    -0.23339933f, 0.48832992f, -0.18867113f, -0.27234477f, -0.01834217f, -0.09253726f, 0.23165466f, -0.19728340f, 
    -0.20162153f, -0.11345604f, 0.00208511f, -0.03644058f, 0.12773177f, 0.26007205f, 0.28239587f, -0.23421250f, 
    0.01091168f, -0.05786305f, 0.44763404f, 0.57785958f, 0.43353602f, -0.10462821f, 0.06089197f, 0.04675026f, 
    0.35297674f, 0.16909224f, 0.36824542f, -0.10815555f, -0.34049040f, -0.16111635f, -0.00748100f, -0.28301287f, 
    0.01493287f, -0.20624246f, -0.29310662f, -0.18020099f, 0.17625523f, -0.09385073f, -0.11060211f, 0.08986467f, 
    0.37369466f, 0.31109309f, 0.21305169f, 0.20357181f, -0.29790431f, 0.06541689f, -0.15273201f, -0.17565666f, 
    0.13181837f, -0.30075976f, -0.29655445f, -0.18260233f, -0.14702848f, 0.31924474f, 0.22028045f, 0.44705656f, 
    -0.13850932f, -0.20510127f, 0.02746186f, -0.07774644f, 0.23536608f, 0.10805473f, -0.05056202f, -0.30271515f, 
    -0.34821516f, -0.45946610f, -0.49547195f, -0.94808471f, -0.77080268f, -0.64153624f, 0.69251710f, 0.68443048f, 
    0.03175021f, -0.26443228f, 0.03448586f, 0.14649719f, -0.13585724f, -0.35875532f, -0.22591348f, -0.39405763f, 
    -0.23092765f, 0.16845405f, 0.06333084f, 0.34103024f, -0.30971581f, 0.14091265f, -0.16838574f, 0.00657398f, 
    0.03847471f, -0.24376413f, 0.14798753f, -0.26357913f, 0.03862484f, 0.14613481f, -0.06992723f, 0.25664833f, 
    0.18601975f, 0.12573472f, -0.04201747f, -0.25774696f, 0.24701969f, 0.12065638f, -0.21241258f, 0.10372223f, 
    -0.16341940f, -0.24596572f, 0.28845802f, -0.07652916f, 0.02724628f, -0.06902451f, -0.09017935f, 0.02070685f, 
    -0.23863165f, 0.13948536f, 0.22907734f, 0.07479003f, 0.00888763f, -0.52218366f, -0.58445156f, -0.43206811f, 
    -0.23912373f, -0.15987581f, 0.32379124f, -0.26079619f, -0.38474661f, -0.19606313f, -0.28021005f, 0.28255934f, 
    0.12995417f, -0.04026198f, -0.27912974f, -0.11455681f, -0.16767593f, -0.16049315f, 0.07279609f, 0.41816962f, 
    0.32108468f, 0.21297047f, 0.07930841f, 0.34066314f, -0.47816360f, -0.39370137f, -0.66490912f, -0.78867370f, 
    -0.03926648f, -0.33672160f, -0.23843338f, 0.13853474f, 0.16414677f, -0.47928241f, 0.25487706f, -0.24988449f, 
    -0.17746995f, -0.21459825f, -0.19484513f, -0.49406421f, -0.35530907f, -0.01582768f, -0.33054847f, -0.57905841f, 
    -0.20910418f, 0.21389470f, 0.29075769f, 0.09459279f, 0.23125030f, -0.36368304f, -0.21630621f, 0.27022168f, 
    0.30390579f, -0.04491880f, 0.23891929f, 0.12401623f, -0.02397653f, -0.19724055f, -0.46164447f, 0.05520948f, 
    0.03912519f, -0.23452261f, 0.17662455f, 0.16839175f, -0.07742875f, 0.10444180f, 0.20735158f, -0.14019214f, 
    -0.21570586f, 0.10269476f, 0.09721228f, -0.33060426f, 0.12385815f, 0.27039406f, -0.69613504f, -0.30863717f, 
    -0.45864627f, -0.42177054f, 0.05168077f, 0.37139970f, 0.30427682f, 0.32267708f, 0.34806392f, 0.43470344f, 
    0.19054531f, 0.12879346f, 0.03273414f, 0.14203958f, -0.36745495f, -0.19267716f, 0.08194748f, 0.12924361f, 
    -0.21159704f, -0.00908600f, -0.11415762f, 0.11105099f, -0.09387124f, -0.09774866f, -0.00435859f, -0.89043546f, 
    -0.32248539f, -0.88198650f, -0.65056503f, -0.43220860f, -0.39467752f, -0.48890689f, -0.37823442f, 0.42610359f, 
    0.63390100f, -0.19570395f, -0.22487111f, -0.04427529f, -0.64271611f, -0.14038856f, 0.31500790f, 0.17247264f, 
    -0.34259546f, 0.09936746f, 0.20218229f, 0.05875870f, -0.06340309f, -0.24219334f, -0.14558324f, -0.22356914f, 
    -0.67724043f, -0.08965320f, -0.36846095f, 0.13413475f, 0.32248992f, -0.27339154f, -0.32011831f, 0.10435361f, 
    0.54661751f, -0.35850510f, 0.24150835f, 0.02893890f, -0.02405454f, 0.23187280f, 0.07642963f, -0.07168180f, 
    -0.02272065f, -0.01610800f, 0.04533628f, 0.01827349f, -0.01269362f, 0.04070911f, 0.20001343f, 0.15962118f, 
    -0.11140820f, -0.98226261f, 0.20708768f, -0.10252822f, -0.44466430f, 0.09789142f, 0.12305545f, -0.42167798f, 
    -0.63540035f, -0.61248386f, -0.59189534f, -0.05240196f, 0.01019851f, -0.31892240f, -0.62437940f, -0.29420885f, 
    -0.06302387f, -0.47519687f, -0.29564214f, -0.20341119f, 0.03522024f, -0.04076600f, 0.10669114f, -0.10515953f, 
    -0.05865215f, -0.08858217f, 0.22601856f, 0.25345865f, 0.41100284f, 0.37663537f, 0.31820774f, -0.06625416f, 
    0.04309399f, -0.00531099f, 0.16352624f, 0.10348595f, -0.02215029f, 0.38794279f, -0.18550202f, -0.29510039f, 
    0.13090639f, -0.19334474f, 0.15464064f, -0.02268171f, -0.18954341f, 0.18378088f, 0.29048064f, -0.10333276f, 
    -0.09409345f, 0.06384161f, -0.15319638f, 0.30295771f, 0.02585104f, 0.34697425f, 0.33284223f, -0.39600036f, 
    0.44556126f, -0.32238850f, -0.09801807f, 0.21925677f, -0.21974395f, 0.03706132f, -0.16942656f, -0.10746234f, 
    0.14011984f, -0.20892984f, -0.10321902f, -0.03164301f, 0.08670574f, -0.13382256f, 0.03696990f, 0.01041575f, 
    0.13688901f, 0.02785972f, -0.02299292f, -0.33256310f, 0.27327421f, -0.58684713f, 0.00365747f, 0.66651285f, 
    0.62143117f, -0.69869113f, -0.61647487f, -0.35516730f, -0.29467106f, 0.45632026f, 0.00365682f, 0.03511180f, 
    -0.03607529f, 0.14451368f, 0.11351035f, 0.25075692f, 0.06889762f, -0.21164121f, 0.28411210f, -0.02396953f, 
    -0.02135577f, 0.07848203f, 0.03460791f, 0.15319796f, -0.17293228f, -0.66307139f, -0.19902220f, 0.39615008f, 
    0.36173368f, 0.17954969f, 0.52680939f, -0.23466644f, -0.40943265f, -0.54248536f, -0.32811350f, 0.28267053f, 
    -0.42543629f, -0.25868085f, -0.28425401f, -0.05524853f, -0.20481417f, 0.09429595f, -0.06115532f, 0.22729716f, 
    0.25047991f, 0.29828399f, -0.11697338f, -0.03569371f, 0.09742776f, -0.17593046f, -0.06792250f, -0.41862965f, 
    -0.68309712f, -0.56965244f, -0.30549443f, -0.25289062f, -0.60584396f, -0.49279392f, -0.70042247f, -0.49186203f, 
    0.21503389f, 0.17774804f, 0.25863904f, -0.15867886f, 0.06652459f, 0.15919569f, 0.22203358f, 0.25549662f, 
    0.01453688f, 0.13668686f, -0.13650514f, -0.07523209f, 0.42395419f, -0.13281676f, -0.14095408f, -0.25102106f, 
    0.11371480f, -0.32144237f, -0.09411841f, -0.06380212f, -0.29252511f, 0.24266437f, -0.12640011f, 0.65708280f, 
    -0.29271060f, -0.46056023f, -0.52358586f, 0.53923577f, -0.15206355f, 0.29282433f, -0.28150293f, 0.24645935f, 
    0.03261126f, -0.34819669f, 0.13881914f, -0.12804796f, 0.28005245f, -0.09677993f, -0.28252554f, 0.05812053f, 
    0.75287533f, -1.00739646f, -0.77048063f, 0.06480097f, 0.32075107f, -0.00642047f, 0.55199522f, -0.62997174f, 
    -0.27083862f, -0.07354429f, 0.15520385f, 0.09942152f, 0.12322654f, 0.02481998f, 0.13003352f, 0.17881922f, 
    -0.32820776f, -0.38701740f, 0.17526340f, -0.30479789f, 0.23194018f, -0.26439333f, 0.03509629f, 0.29940143f, 
    0.09007262f, 0.11361687f, -0.69107246f, -0.29295251f, -0.10541135f, 0.48977932f, 0.38496047f, 0.09658028f, 
    0.26352787f, 0.01305518f, -0.38636449f, -0.23250833f, 0.21444142f, -0.21347439f, 0.26205048f, 0.01011930f, 
    -0.02184169f, -0.29190856f, -0.15863520f, 0.30902767f, -0.15385595f, 0.10716851f, 0.11172749f, -0.20232719f, 
    0.11103510f, -0.08318721f, -0.45113909f, -1.00390553f, -0.15019217f, 0.72617620f, 0.76640332f, -0.35081568f, 
    -0.08971445f, -0.59268820f, -0.09656506f, -0.29722458f, -0.03508997f, -0.46074951f, 0.54226071f, -0.05281480f, 
    -0.31935188f, 0.12873687f, -0.05969423f, -0.13436055f, 0.13457048f, -0.23283666f, -0.06935264f, -0.02928450f, 
    -0.21804921f, -0.18266831f, 0.40633041f, -0.31343934f, 0.36285985f, 0.41759688f, 0.08940960f, -0.34204113f, 
    0.20084806f, 0.18747954f, 0.11898828f, 0.08789103f, -0.16246936f, -0.42580605f, -0.05636528f, 0.12736070f, 
    -0.07509062f, 0.17050111f, 0.12810613f, -0.26914105f, -0.41903591f, 0.26725677f, 0.35081699f, -0.07575916f, 
    -0.10387840f, 0.12990436f, -0.32502681f, -0.13811249f, -0.89662516f, 0.53088129f, 0.25555155f, -0.37422416f, 
    -0.42761621f, 0.48107830f, 0.21692234f, 0.09736427f, -0.15285847f, -0.00309005f, 0.02220170f, -0.02332963f, 
    0.14547113f, -0.37946805f, -0.07856427f, 0.10718769f, 0.06466219f, -0.00819177f, 0.18911920f, 0.03178904f, 
    -0.00131249f, 0.18378706f, -0.04592158f, -0.15725328f, -0.14159194f, -0.04975659f, -0.22703661f, -0.48997805f, 
    0.21384411f, 0.10567196f, -0.31550422f, -0.33809912f, 0.06830633f, 0.21485369f, 0.43844584f, -0.29008603f, 
    -0.33960679f, 0.05987613f, -0.06361219f, -0.32918558f, 0.05133256f, 0.19893335f, -0.53985190f, -0.18977028f, 
    -0.50862688f, -0.15248120f, -0.17888632f, -0.05127804f, -0.29340702f, -0.24512787f, 0.09529361f, -0.26683497f, 
    0.06788894f, 0.09692052f, -0.42020121f, -0.05013260f, -0.03428945f, -0.29308990f, 0.11003026f, 0.30945089f, 
    0.29906657f, -0.12218179f, -0.33646598f, -0.10004836f, -0.18326327f, -0.29300886f, 0.02048608f, 0.16007929f, 
    0.21738042f, -0.14465907f, -0.17176656f, -0.18940705f, -0.24039520f, -0.33921409f, -0.59666675f, 0.54002130f, 
    0.07932351f, 0.39974767f, 0.26229423f, -0.65999782f, -0.24402100f, -0.52420717f, -0.52515429f, -0.33578143f, 
    -0.53320289f, 0.39984819f, -0.28625360f, -0.18116863f, 0.16268609f, -0.32668644f, -0.16849965f, 0.04929205f, 
    0.21999490f, 0.21462224f, 0.07462533f, 0.09218489f, -0.31802917f, -0.24850935f, 0.39116809f, 0.35184625f, 
    0.15860029f, -0.86226737f, 0.52988458f, -0.16861334f, 0.25133964f, -0.27247927f, -0.39975712f, 0.57215476f, 
    0.15867926f, -0.27919224f, 0.02140174f, -0.30596238f, -0.12105150f, -0.17826308f, 0.28080681f, 0.08922496f, 
    -0.06454129f, 0.04167020f, -0.25199914f, 0.00018549f, 0.00207317f, -0.17173670f, -0.11886915f, 0.30819064f, 
    0.11280136f, -0.32827520f, -0.12061013f, 0.15014812f, -0.38027662f, -0.51350337f, -0.76290208f, -0.39292374f, 
    -0.08793753f, -0.39305305f, -0.69536150f, -0.27202895f, -0.19640291f, -0.19720693f, 0.03201947f, -0.30851755f, 
    0.08010881f, -0.35860798f, 0.02406049f, -0.37652069f, -0.24001837f, -0.05305033f, 0.02101481f, -0.22338603f, 
    0.12688588f, 0.14333072f, 1.12735891f, -0.12581815f, -0.18468748f, -0.10684532f, -0.57150722f, 0.23476800f, 
    0.13106236f, 0.14253919f, 0.04584502f, 0.07619962f, 0.17760505f, 0.08905472f, -0.10422360f, -0.34467182f, 
    -0.21025637f, 0.03548266f, -0.21754755f, -0.06391121f, -0.01531163f, -0.33411118f, -0.35292858f, -0.00230238f, 
    -0.21015199f, -0.43378058f, -0.52318889f, -1.29761600f, -0.15677731f, -0.33343059f, -0.15499143f, -0.24548353f, 
    -0.01403468f, 0.08148327f, -0.14570910f, 0.34046373f, 0.56354547f, 0.36579356f, 0.00647128f, -0.03489385f, 
    -0.00757735f, -0.18238612f, -0.37717587f, -0.32163045f, -0.24866888f, -0.10245555f, 0.25364128f, 0.01041690f, 
    -0.06446035f, -0.01985875f, 0.14557751f, -0.22200187f, -0.48566970f, -0.18671730f, 0.38695100f, 0.57852167f, 
    -0.22757785f, 0.08086897f, -0.00628125f, -0.11287444f, 0.19607313f, 0.27113357f, -0.22085986f, -0.08667508f, 
    -0.26667327f, -0.16052459f, -0.04955684f, 0.19306824f, -0.10802627f, 0.11030212f, -0.14645411f, -0.14663854f, 
    -0.45706400f, -0.26811925f, -0.30565387f, -0.39339596f, -0.66511315f, 0.07905300f, -0.33901438f, -0.06151564f, 
    -0.29729295f, -0.16050597f, -0.08188194f, 0.12958865f, 0.18634127f, 0.15301007f, 0.16124053f, 0.05113564f, 
    -0.19338617f, 0.20131323f, -0.06056369f, 0.03451173f, -0.25018486f, -0.13234191f, -0.32541910f, 0.24234043f, 
    0.05799114f, 0.08228073f, 0.05861611f, -0.00600303f, -0.01441444f, 0.51557410f, 1.11927092f, -0.08801692f, 
    -0.11649571f, 0.16859879f, -0.49810809f, 0.54080671f, -0.22059864f, 0.07841799f, -0.73988038f, -0.70636737f, 
    -0.16110264f, -0.11651840f, -0.15729077f, 0.00143774f, -0.25721422f, 0.26565763f, 0.15766515f, 0.18160121f, 
    -0.02308171f, 0.08492202f, -0.29426533f, 0.00631687f, -0.04162491f, -0.00325992f, 0.08308800f, -0.87099814f, 
    -0.74978065f, -0.50917751f, -0.63198847f, -0.77430040f, 0.61692119f, 0.10097113f, -0.51169038f, -0.30802405f, 
    0.44325003f, -0.09859024f, -0.18384428f, -0.17273755f, 0.23065262f, -0.21379896f, -0.10254422f, -0.40042698f, 
    -0.20765719f, -0.17839374f, -0.39933342f, -0.23351370f, 0.17847176f, -0.18785688f, 0.12096695f, 0.08257441f, 
    0.29138166f, -0.07177952f, 0.00710827f, -0.34528577f, -0.27105978f, 0.27944288f, 0.21132877f, -0.14001682f, 
    -0.10936376f, 0.49904963f, -0.03618225f, 0.45656148f, -0.37627766f, -0.30433860f, 0.16721749f, 0.03351540f, 
    0.12646575f, -0.00143727f, 0.02425835f, -0.46046886f, 0.14867137f, -0.22073583f, 0.06864286f, -0.08805972f, 
    0.07767861f, 0.16248536f, 0.36911356f, 0.27374610f, -0.49332669f, -0.18823025f, 0.03147200f, 0.33661905f, 
    0.22708561f, 0.02910921f, 0.10592498f, -0.26974916f, -0.17678511f, -0.24593060f, -0.33006185f, -0.06403868f, 
    0.06899126f, -0.09228009f, -0.01180017f, 0.01808098f, -0.06100267f, -0.01076435f, 0.07509581f, -0.33177716f, 
    0.05250547f, 0.31969562f, -0.31404588f, -0.20629571f, -0.53900981f, -0.36490235f, -0.62114722f, 0.21205759f, 
    0.40201858f, 0.05440854f, -0.26256931f, -0.03601183f, -0.12348721f, -0.09537564f, -0.11745638f, -0.46811530f, 
    -0.20506486f, 0.22137791f, 0.39024457f, 0.01815956f, -0.12962151f, -0.09239297f, 0.05156364f, 0.04765871f, 
    -0.18139042f, -0.11695460f, 0.15650779f, -0.63086057f, 0.64077246f, -0.49627256f, -0.33392620f, -0.63030183f, 
    -0.29214078f, -0.07446551f, 0.11289518f, 0.38862756f, 0.36473918f, 0.39404306f, 0.18072557f, -0.02181723f, 
    0.11673217f, -0.23631819f, 0.20666884f, 0.12608597f, 0.07072704f, -0.09834489f, -0.04150720f, -0.13275111f, 
    0.09654520f, -0.06766024f, -0.26444647f, 0.20400774f, -0.75527972f, -0.53457129f, 0.13029516f, 0.79651392f, 
    0.17335075f, 0.22491297f, 0.35570678f, -0.32421023f, 0.08035260f, -0.18263592f, -0.49696895f, -0.14703549f, 
    0.14979810f, 0.13603337f, 0.10426082f, 0.20638591f, 0.02096885f, -0.13956825f, 0.07114115f, -0.06344081f, 
    0.00289821f, -0.24979997f, 0.05591607f, 0.21378575f, 0.09932227f, -0.79809165f, 0.52484679f, 0.13768616f, 
    -0.10243656f, -0.04633191f, 0.40194127f, 0.57857078f, -0.28248486f, -0.38333276f, -0.16011298f, 0.07556944f, 
    -0.00454250f, -0.12762700f, 0.02904232f, 0.17376481f, 0.16197287f, -0.21647368f, -0.13052739f, 0.06874802f, 
    0.17958489f, 0.06858263f, -0.05790891f, -0.15934186f, -0.07487867f, -0.29847822f, -0.16464435f, 0.38081658f, 
    0.12914971f, 0.36928123f, -0.05863455f, -0.47439519f, -0.55219799f, 0.32486808f, 0.00906952f, -0.00808176f, 
    0.01150207f, -0.04675378f, -0.17341909f, -0.06660075f, 0.05889522f, -0.00873938f, 0.27449325f, -0.05346695f, 
    -0.04254122f, -0.28778067f, -0.29299560f, -0.11851618f, 0.02763161f, -0.38692302f, -0.43711561f, 1.05968368f, 
    0.14452638f, -0.48055962f, -0.06913957f, -0.27737439f, -0.02651971f, -0.34634659f, 0.82729775f, -0.70345014f, 
    -0.72307348f, -0.03986477f, -0.00823280f, -0.14698938f, -0.01278072f, 0.18012293f, 0.25655791f, -0.22254165f, 
    -0.03044055f, 0.01222757f, 0.00246763f, 0.08781540f, -0.10247210f, 0.14440921f, 0.10619599f, 0.02399550f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25454670f, 0.37993643f, 0.07505281f, 0.37248191f, 0.27380311f, -0.04593438f, 0.00373989f, -0.05247397f, 
    0.08512722f, -0.00515986f, 0.08403367f, 0.07290474f, 0.33026791f, 0.38819936f, 0.24323083f, 0.15792765f, 
    -0.07024613f, 0.05774738f, -0.15252466f, 0.21447602f, 0.06849104f, 0.16122112f, 0.14639296f, -0.14421454f, 
    0.05438992f, -0.42447373f, 0.23615246f, -0.11677871f, -0.24476510f, 0.27090317f, 0.07983003f, 0.17250702f, 
    0.27149653f, -0.18792892f, 0.00053760f, 0.31903252f, 0.23891246f, 0.11271849f, -0.17903554f, 0.10621076f, 
    0.36901927f, 0.28203595f, 0.37832007f, 0.11947080f, 0.02449847f, -0.19586307f, 0.06499291f, 0.21205087f, 
    0.16022812f, 0.04984827f, 0.05053620f, 0.42419228f, -0.12491627f, 0.21301989f, 0.04794257f, -0.18934484f, 
    0.21099217f, 0.20728032f, -0.25446814f, 0.13911857f, 0.00857546f, 0.16880736f, 0.07817339f, 0.17421314f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.44261870f, 0.12543698f, -0.15004869f, -0.01172477f, -0.05114541f, 0.13016154f, -0.10155118f, -0.24322432f, 
    -0.05906580f, -0.07684567f, 0.01951746f, 0.13757715f, -0.39555043f, -0.58792424f, 0.09584939f, -0.18497187f, 
    0.04475084f, -0.00101539f, -0.02843546f, -0.01232696f, -0.02954555f, -0.06023369f, -0.09573957f, -0.01259159f, 
    0.02547247f, -0.15693215f, 0.00572375f, 0.05928576f, -0.03987714f, 0.04680758f, -0.21538492f, -0.05304066f, 
    0.00255809f, -0.00244423f, -0.02483091f, 0.06114077f, 0.17095092f, 0.09111035f, -0.06970018f, 0.02673887f, 
    0.10883021f, 0.00617909f, 0.03766694f, -0.08406023f, 0.00513942f, -0.06830826f, -0.04391579f, 0.07109305f, 
    -0.43441844f, -0.17782062f, 0.12303509f, -0.03478028f, 0.02990621f, -0.00966590f, 0.05423878f, 0.00287415f, 
    -0.02972946f, -0.02599920f, 0.02738790f, -0.10008998f, 0.28466317f, 0.29376563f, -0.08271696f, -0.22408523f, 
    -0.02702860f, -0.01736490f, -0.00886463f, 0.01625938f, 0.02919677f, -0.06559820f, -0.01372095f, -0.05327280f, 
    -0.25565338f, -0.03712823f, 0.03104517f, -0.00280160f, 0.02307777f, 0.00615300f, -0.01712889f, 0.03833318f, 
    -0.05496684f, 0.05790235f, -0.10549274f, 0.02791780f, 0.06626141f, 0.05370165f, -0.23502785f, -0.01450595f, 
    -0.13329676f, -0.15586202f, -0.19128969f, -0.18486403f, -0.04217146f, 0.07135963f, 0.00744400f, -0.03842168f, 
    0.01617227f, 0.01201831f, 0.13675182f, -0.03177103f, -0.05528932f, -0.00903186f, 0.00147730f, 0.00369836f, 
    -0.08317469f, -0.08326028f, -0.09708313f, -0.06814592f, 0.16604401f, -0.14055221f, -0.22821499f, 0.11856472f, 
    -0.14139307f, -0.08387920f, -0.09766900f, -0.05562405f, -0.18049565f, -0.02259418f, -0.04214140f, -0.02394583f, 
    0.01570062f, 0.14588512f, 0.09897717f, -0.08171014f, -0.06101329f, 0.14173667f, -0.03404690f, -0.20108236f, 
    -0.00835120f, 0.03790987f, -0.06029303f, -0.14918646f, 0.03693018f, 0.11360810f, 0.01708361f, -0.03991182f, 
    -0.10582891f, -0.04308153f, -0.00019994f, -0.15700538f, 0.04190549f, -0.00132698f, -0.17092887f, -0.07417504f, 
    -0.14277300f, -0.36568063f, -0.54313868f, 0.07963616f, -0.01876866f, -0.03042071f, -0.23335677f, -0.04190524f, 
    -0.08063383f, -0.21598554f, -0.17871948f, -0.00792285f, 0.02801309f, -0.55255520f, 0.11590573f, 0.12249025f, 
    -0.03729266f, -0.08197126f, -0.28909791f, -0.20067741f, -0.12644902f, -0.14972961f, -0.00112173f, -0.14500667f, 
    0.29469818f, 0.15440586f, -0.09511188f, -0.05121444f, 0.04557014f, 0.08339114f, 0.07412200f, 0.00681619f, 
    -0.03363770f, -0.01886898f, -0.04874441f, -0.02442333f, 0.13577683f, -0.34856981f, -0.34035349f, 0.02537344f, 
    0.07648873f, 0.00494834f, -0.22908968f, -0.06719827f, 0.11345384f, -0.03796756f, -0.00445133f, 0.06801265f, 
    0.62927717f, 0.27774525f, -0.19183809f, -0.41329229f, 0.01582866f, -0.02018002f, 0.11389677f, 0.07511721f, 
    -0.05193556f, 0.02361188f, 0.05782233f, -0.02788440f, -0.11601047f, -0.14641866f, 0.04273086f, 0.04324768f, 
    0.02361621f, 0.01302433f, -0.09260568f, -0.04423711f, -0.04196986f, 0.03128551f, 0.11481894f, 0.03238136f, 
    0.17376237f, 0.08915810f, -0.04274866f, -0.15635726f, 0.03236630f, 0.04968983f, -0.06846105f, -0.00867452f, 
    -0.05694231f, 0.04110158f, 0.06631480f, 0.08810145f, 0.13695978f, -0.02995993f, -0.12125366f, -0.07012606f, 
    0.07240521f, 0.00422584f, -0.04183787f, 0.02308538f, 0.05364795f, -0.10657842f, -0.10693166f, -0.06997963f, 
    0.22872044f, 0.22461875f, -0.11188614f, -0.04742621f, -0.03811598f, -0.03203963f, 0.03257653f, -0.03335895f, 
    -0.14307038f, 0.15519445f, -0.01654661f, -0.01493436f, -0.18407744f, 0.17802374f, -0.02271364f, -0.14082250f, 
    -0.00222327f, 0.01057297f, -0.00638632f, -0.01777738f, -0.00880578f, -0.11336190f, 0.03694002f, 0.06199137f, 
    -0.00681964f, 0.00782588f, -0.30184147f, -0.03601127f, -0.01260143f, 0.02249082f, -0.02398989f, -0.01329109f, 
    -0.08589901f, -0.08548804f, 0.00851050f, -0.20345804f, -0.21857096f, 0.03088371f, 0.21279675f, 0.01456491f, 
    0.01435828f, 0.00029753f, 0.04880754f, 0.06460697f, -0.02449467f, 0.06419385f, -0.00641725f, 0.00084609f, 
    -0.30546719f, -0.36648613f, -0.07453310f, -0.02129746f, 0.02424416f, 0.01079454f, -0.08801394f, -0.04889315f, 
    0.00760416f, 0.00789271f, 0.02771378f, -0.05328220f, 0.28513929f, 0.04135245f, -0.42834225f, -0.04062638f, 
    0.03093107f, 0.22140980f, 0.13838080f, 0.10005783f, 0.03376364f, 0.06572928f, -0.04156950f, 0.01120441f, 
    -0.10444356f, -0.06630084f, -0.03715319f, -0.00857536f, -0.03810259f, 0.02827480f, -0.02452691f, 0.01493396f, 
    -0.09974484f, -0.14300521f, -0.06812554f, -0.10084649f, 0.14589040f, 0.07186972f, -0.07536578f, 0.00164816f, 
    0.13361786f, 0.04305694f, -0.05403198f, -0.09719450f, 0.01035486f, -0.05485050f, 0.00734407f, -0.02016159f, 
    0.25065753f, 0.10220698f, -0.03019581f, -0.10628497f, 0.15745293f, 0.25532052f, -0.03485951f, -0.10929993f, 
    -0.04054613f, -0.18418929f, -0.21533112f, -0.02961491f, -0.06197541f, -0.08936287f, 0.01752011f, -0.08087414f, 
    -0.24059047f, -0.17430238f, -0.00620180f, 0.03220685f, -0.02035906f, -0.17159604f, -0.03113062f, -0.03890272f, 
    -0.02355484f, 0.05327727f, -0.03982949f, 0.03691533f, 0.06133371f, 0.07779127f, 0.07820395f, 0.02361588f, 
    -0.04673538f, 0.13660571f, -0.02500569f, -0.13473004f, 0.22494534f, 0.23708011f, 0.08076254f, -0.10153191f, 
    0.17574091f, 0.25007030f, 0.06968421f, -0.03197967f, 0.03121465f, 0.05207038f, 0.03999279f, 0.04229557f, 
    0.07994501f, 0.10734571f, 0.11441540f, -0.06694830f, -0.10962670f, 0.04627765f, -0.07251367f, -0.15241854f, 
    -0.04945991f, -0.08471107f, -0.10040211f, -0.01471690f, 0.23690383f, 0.34180671f, -0.19421016f, -0.11286257f, 
    -0.00194144f, 0.17749347f, 0.01544509f, 0.06409976f, -0.07864382f, -0.07598615f, -0.11024910f, -0.08134060f, 
    -0.25825542f, -0.12099256f, -0.06472041f, 0.07484896f, -0.02104831f, 0.04866972f, 0.04124473f, 0.00830148f, 
    -0.03229196f, 0.02284992f, -0.01715124f, 0.01352823f, -0.30463117f, -0.35151443f, -0.12158670f, -0.10616686f, 
    0.01590848f, -0.03096507f, -0.01426159f, 0.05627879f, -0.02369080f, 0.01054985f, -0.05029985f, 0.02143118f, 
    -0.08954382f, 0.23089866f, 0.15178423f, -0.15510869f, -0.07683548f, -0.05715304f, -0.25971404f, -0.25424030f, 
    -0.00165048f, 0.00102183f, -0.00526299f, 0.05257022f, 0.36733258f, 0.13564068f, -0.22864281f, -0.23478451f, 
    0.00190473f, 0.06240690f, 0.03834425f, 0.02031848f, -0.00851811f, 0.01603094f, -0.02940476f, -0.02762916f, 
    0.37691784f, 0.18971293f, -0.20517696f, -0.02693508f, 0.15918672f, 0.08330381f, -0.01692577f, 0.08724747f, 
    0.00187827f, 0.04457056f, 0.06764114f, 0.03853667f, -0.18187281f, -0.08715524f, 0.26215786f, -0.19688687f, 
    -0.29320022f, 0.03282778f, -0.08648232f, -0.14131887f, -0.04476583f, -0.05570210f, -0.03124679f, -0.02751539f, 
    0.10798240f, 0.31594962f, -0.25646815f, -0.07747453f, 0.07396089f, -0.04529502f, -0.05867664f, -0.37312505f, 
    -0.10454713f, -0.12602174f, -0.19321582f, -0.00511777f, 0.07128797f, -0.07136266f, -0.27194899f, -0.07008143f, 
    -0.00901833f, 0.02237029f, 0.01872036f, -0.13167636f, -0.19064622f, -0.03193948f, -0.18654354f, -0.17844363f, 
    0.44720393f, 0.11088635f, 0.07405740f, -0.23048407f, 0.12593542f, -0.06518100f, 0.07415313f, -0.00853683f, 
    -0.00718271f, -0.00612530f, -0.12095976f, -0.09237561f, -0.53409719f, -0.29902631f, 0.04786361f, 0.04053335f, 
    0.04659307f, 0.00882753f, 0.05102257f, -0.01527101f, -0.01251324f, -0.02397553f, -0.04018668f, -0.17940813f, 
    -0.09932313f, 0.09054151f, -0.03035347f, -0.08542716f, -0.16988778f, 0.10491887f, 0.05315442f, -0.05112682f, 
    0.08080765f, 0.00470003f, -0.02224599f, -0.01296439f, 0.09334892f, 0.22152391f, 0.27176321f, 0.09044041f, 
    -0.02869496f, 0.02941157f, 0.03414553f, -0.01022180f, -0.13442287f, -0.09962142f, -0.02206454f, 0.11730547f, 
    0.04563620f, 0.08891395f, 0.02904774f, -0.03560876f, 0.09332462f, -0.09675897f, -0.05158894f, -0.02406891f, 
    0.05995671f, 0.05222027f, 0.06892046f, 0.20400204f, 0.07579759f, -0.08032324f, -0.19452110f, -0.35160673f, 
    0.13558014f, -0.08969229f, -0.03894925f, -0.10980828f, 0.02383387f, 0.00434002f, 0.03217186f, 0.05071958f, 
    -0.08729206f, -0.42034674f, 0.26377460f, -0.33748332f, -0.17397018f, 0.11352756f, 0.03346520f, -0.08947864f, 
    0.02387286f, -0.02612564f, -0.00587028f, 0.02783888f, 0.10181815f, 0.16354604f, -0.01137858f, -0.14724846f, 
    -0.00665381f, 0.07644473f, -0.02624530f, 0.13475572f, -0.01486926f, -0.08387996f, -0.00076743f, -0.11596786f, 
    -0.36430937f, -0.38296553f, -0.28113091f, 0.05735124f, 0.03271941f, 0.01277024f, 0.04689836f, 0.03734380f, 
    -0.19336914f, -0.03845699f, -0.06793890f, 0.17264697f, 0.25134787f, 0.12017081f, 0.06094350f, -0.12773407f, 
    0.02036759f, 0.07868946f, 0.02622513f, 0.04964130f, -0.01825908f, -0.07458905f, 0.01242778f, -0.08314598f, 
    -0.10050936f, 0.05386202f, 0.14596938f, -0.08114713f, 0.04625430f, 0.00238473f, 0.03891408f, 0.08835433f, 
    -0.07040670f, 0.12807508f, 0.04164314f, 0.17828757f, -0.07052492f, 0.04538299f, 0.09695186f, 0.03654550f, 
    0.03403872f, -0.06058435f, -0.03808585f, -0.08387768f, -0.05914124f, -0.13620435f, -0.08863144f, -0.03521312f, 
    0.05892482f, -0.29010165f, -0.26159123f, -0.09343414f, -0.08734220f, 0.00770103f, -0.02072486f, -0.01175817f, 
    -0.04419325f, 0.12498916f, 0.03946079f, 0.02751308f, 0.22505161f, 0.09378362f, -0.09869300f, -0.10225169f, 
    0.04704180f, 0.09150413f, 0.02737971f, -0.00802412f, -0.08489548f, -0.05137166f, -0.03731996f, -0.02433051f, 
    -0.11102283f, -0.16227601f, -0.06684783f, 0.07374152f, -0.04271443f, 0.04192114f, -0.03416108f, -0.06583473f, 
    -0.13021135f, 0.02954498f, -0.08789287f, -0.12848321f, -0.23054469f, -0.03649114f, -0.01778272f, 0.00692919f, 
    0.02211597f, 0.02385160f, -0.01132204f, 0.06514154f, 0.08942433f, -0.02224195f, -0.03392185f, -0.03526399f, 
    0.16866578f, 0.12383043f, -0.16336134f, -0.09764037f, 0.12572086f, 0.13170500f, -0.04285044f, 0.15347287f, 
    0.05115402f, 0.05416055f, 0.04869439f, -0.01695056f, 0.12829939f, -0.08033295f, 0.14557752f, -0.03613177f, 
    0.01574910f, 0.01720229f, -0.00508603f, 0.01144704f, -0.02478553f, -0.00278565f, 0.02833525f, -0.02961351f, 
    0.40171134f, 0.01006627f, -0.01444305f, -0.07849325f, 0.00092538f, -0.10818738f, 0.02152921f, -0.08159976f, 
    -0.16721031f, -0.07616841f, 0.01562691f, -0.03769492f, -0.00366610f, -0.04797269f, -0.13452396f, 0.04145823f, 
    -0.04144525f, 0.10118520f, 0.00748178f, -0.03777187f, -0.18137737f, -0.04990637f, 0.07731397f, 0.02210858f, 
    -0.34602979f, -0.07194679f, 0.22141382f, -0.10191043f, 0.03237195f, -0.03436978f, -0.03665325f, 0.03729365f, 
    -0.08036208f, -0.01383501f, -0.05224256f, 0.05662845f, 0.15432832f, -0.03963681f, -0.22488308f, -0.07861160f, 
    -0.05674244f, -0.00753380f, 0.13357672f, -0.00250465f, 0.02163115f, 0.14531016f, -0.03553966f, -0.01290916f, 
    -0.00349643f, -0.25889659f, 0.29503426f, -0.00732002f, 0.17844062f, -0.15673481f, 0.03974878f, 0.00881400f, 
    0.05137528f, -0.06846872f, -0.02490414f, 0.08076393f, 0.13918182f, 0.20483534f, 0.33422932f, -0.25426137f, 
    0.07236474f, -0.00025413f, 0.03964167f, -0.02400812f, 0.01202069f, -0.02011104f, -0.00284528f, 0.02692777f, 
    0.07403365f, -0.07973819f, 0.07687200f, -0.11215144f, -0.02247800f, 0.00519469f, -0.01391791f, 0.05584919f, 
    -0.20737238f, -0.02505338f, 0.08043364f, -0.05215903f, -0.01282205f, -0.22027366f, -0.16004224f, -0.00758173f, 
    -0.02535611f, 0.10532159f, 0.02684088f, -0.07753130f, 0.11439715f, 0.05038057f, -0.01406761f, -0.01913161f, 
    0.03746863f, 0.07391566f, -0.00177360f, 0.01114360f, -0.01116721f, -0.01600341f, -0.01058201f, -0.03454242f, 
    -0.04937211f, 0.11359670f, 0.01235881f, 0.02161327f, -0.41776243f, -0.14309469f, -0.19532284f, 0.04605198f, 
    -0.10814776f, 0.00946522f, 0.06014551f, 0.15398194f, -0.01767533f, -0.11510777f, -0.02041086f, 0.09012022f, 
    0.03635379f, 0.02499315f, 0.07926093f, 0.03023608f, 0.01295945f, -0.01729138f, -0.03487899f, 0.03564629f, 
    0.02462477f, 0.03110690f, -0.02087576f, 0.06471688f, 0.07883620f, 0.04635107f, -0.08006375f, -0.02007791f, 
    -0.10070922f, -0.12354908f, 0.00486949f, -0.06627019f, -0.03466272f, -0.17531449f, 0.00923915f, 0.12651677f, 
    -0.05532396f, 0.01475336f, 0.08044455f, -0.00108043f, 0.05155860f, 0.01170895f, 0.05337518f, 0.02969910f, 
    -0.05576570f, -0.02982817f, 0.05259186f, -0.00002590f, 0.23742256f, -0.02968154f, -0.26270980f, -0.01061383f, 
    0.10665604f, 0.01991581f, 0.04417719f, 0.10760638f, 0.18522181f, 0.02628781f, -0.12409499f, 0.05277745f, 
    -0.04374593f, -0.00259720f, -0.07036841f, -0.04510809f, 0.10434625f, 0.05534235f, 0.00157882f, -0.17496844f, 
    -0.09080096f, 0.01637783f, 0.04160760f, 0.10541696f, 0.29942164f, -0.01175142f, -0.10788067f, 0.00175222f, 
    -0.17350757f, 0.08722895f, -0.03906141f, 0.04754424f, -0.04521858f, -0.07741781f, 0.04796259f, 0.10046604f, 
    0.42770860f, -0.26773757f, 0.33533081f, -0.11339065f, -0.02048675f, 0.01139109f, -0.00526336f, -0.02528566f, 
    -0.02616692f, 0.08838516f, 0.21196993f, 0.10348434f, 0.53210479f, -0.28591999f, 0.03869779f, -0.13983005f, 
    -0.08409680f, 0.11917043f, 0.08972447f, -0.00653798f, 0.03137854f, 0.16580793f, -0.06863859f, 0.04059683f, 
    0.11992583f, 0.01927483f, -0.12439843f, -0.05584544f, -0.02540163f, -0.00463027f, 0.01387159f, 0.03467637f, 
    0.09407720f, -0.01527139f, -0.02041631f, -0.01704544f, 0.33243912f, -0.00785375f, -0.13301583f, -0.19599551f, 
    0.13187732f, 0.02000105f, 0.15018183f, 0.11362436f, -0.05447397f, 0.10981350f, -0.07485347f, -0.05581680f, 
    0.14465091f, -0.13257773f, -0.03939366f, 0.18656226f, -0.02796682f, -0.00939749f, -0.11224604f, -0.00155080f, 
    0.20989174f, -0.12953259f, -0.00926776f, -0.00391173f, 0.12193947f, -0.05286027f, 0.04321517f, -0.08044023f, 
    0.03028527f, -0.00629604f, -0.07487558f, -0.05811319f, -0.05463266f, -0.10312483f, -0.16866601f, -0.23461546f, 
    -0.07657848f, 0.04470354f, 0.14536543f, -0.14304952f, 0.04002575f, -0.04736512f, 0.05152350f, -0.02205017f, 
    -0.00861392f, -0.03038273f, 0.00226139f, -0.07677940f, -0.16354024f, -0.08690666f, -0.02576790f, -0.29348010f, 
    -0.11522989f, -0.03288334f, 0.07535815f, 0.05026313f, -0.18701318f, 0.03055401f, 0.10998548f, 0.05539234f, 
    -0.18811585f, -0.23777358f, -0.18977162f, -0.03807666f, 0.05572386f, 0.04274539f, 0.04228808f, 0.10405882f, 
    0.21665061f, -0.10671188f, -0.08414169f, 0.04259516f, -0.33485305f, 0.18745542f, 0.03932608f, 0.06731026f, 
    0.03715278f, -0.01849816f, -0.06706798f, -0.04210449f, 0.02121351f, 0.01612818f, 0.07978640f, 0.03979528f, 
    0.26018873f, -0.02834946f, -0.19289236f, 0.16624473f, 0.02139886f, 0.04540559f, 0.08596569f, -0.03083755f, 
    -0.00094501f, 0.08230671f, -0.06746483f, 0.06181712f, 0.33172476f, 0.21442594f, 0.22146383f, 0.45885754f, 
    -0.05247703f, 0.02571511f, -0.03943365f, -0.00167070f, -0.02845332f, 0.10271160f, -0.10412405f, 0.11432482f, 
    0.14009032f, 0.11540166f, -0.00606239f, -0.02245769f, 0.01502070f, -0.10388691f, -0.04754927f, 0.05331671f, 
    -0.02242866f, 0.01935474f, 0.12061722f, -0.15463836f, 0.45158309f, 0.13414915f, 0.14620464f, -0.18796687f, 
    -0.08845759f, -0.23473276f, -0.08243286f, -0.02968963f, -0.03367781f, -0.07388330f, -0.09713200f, 0.02112829f, 
    0.06648228f, -0.00245338f, -0.05928780f, 0.10316874f, -0.00901394f, 0.02443619f, 0.04917268f, -0.08329088f, 
    0.15859488f, 0.05080721f, -0.08405634f, 0.06780295f, 0.07339478f, 0.18505491f, 0.23421425f, 0.15350780f, 
    -0.03603981f, -0.03438470f, 0.15335603f, 0.05716627f, -0.10626341f, -0.02062938f, -0.02373360f, 0.02105171f, 
    -0.11713934f, 0.22765939f, 0.01519071f, -0.11845396f, 0.11519841f, 0.13547952f, 0.19716871f, 0.28913906f, 
    -0.02022634f, 0.04292743f, -0.15230216f, -0.03899232f, -0.08187021f, -0.05487585f, 0.03447843f, 0.02568244f, 
    0.10942747f, -0.01244383f, 0.00941640f, -0.03069182f, 0.15345474f, -0.01555514f, 0.07554551f, 0.01646488f, 
    0.11300213f, -0.09399883f, -0.10443059f, -0.05027755f, -0.04833110f, -0.00875060f, -0.01783365f, -0.02890793f, 
    -0.03041082f, -0.03568612f, -0.11078306f, 0.12493224f, 0.04904684f, 0.16803139f, -0.06889659f, 0.08199594f, 
    -0.02190670f, 0.03012474f, -0.39326391f, -0.35848469f, -0.00497525f, -0.06154326f, -0.03004567f, -0.02169582f, 
    -0.28895503f, -0.10266992f, -0.07267451f, 0.07606361f, 0.18675688f, 0.10858187f, 0.13268663f, -0.05527357f, 
    -0.08605528f, -0.03741866f, 0.07367375f, 0.01467528f, 0.03548934f, -0.00333404f, -0.07854676f, 0.29936033f, 
    0.04230935f, 0.08164129f, -0.08830575f, 0.01561430f, 0.00418331f, 0.07195204f, -0.04071623f, -0.00246586f, 
    0.18817276f, 0.13578302f, 0.10930459f, 0.18001130f, 0.00443943f, -0.00786913f, -0.03537863f, 0.01015299f, 
    0.06472278f, 0.03831449f, -0.04841797f, 0.02637819f, 0.21148090f, 0.22092094f, -0.00598830f, 0.02412908f, 
    -0.02063205f, -0.06578244f, -0.00910532f, 0.01372149f, -0.01674029f, 0.04832980f, 0.06758979f, -0.02486699f, 
    -0.33161893f, 0.23281489f, -0.18328679f, 0.00373852f, -0.05862573f, -0.04175696f, 0.06143769f, -0.07204641f, 
    -0.13365087f, -0.02160224f, 0.05654008f, -0.00939533f, 0.01395244f, -0.06132850f, -0.31598774f, -0.36515501f, 
    0.03198422f, -0.06964664f, -0.08391020f, 0.00670684f, 0.01388378f, -0.04764051f, 0.00342020f, 0.01825415f, 
    0.03277651f, 0.04453355f, 0.08271303f, 0.11786971f, -0.11668587f, 0.05823240f, -0.06754002f, -0.10780381f, 
    -0.03024520f, 0.00527859f, -0.02644639f, 0.00382328f, -0.48411068f, -0.07433809f, -0.21214476f, -0.08736470f, 
    0.13187075f, 0.00751229f, -0.04793211f, -0.06115099f, -0.16341306f, 0.10014299f, -0.06491353f, -0.20765136f, 
    0.18744592f, -0.28076208f, -0.14339623f, 0.04166761f, -0.06203903f, 0.18397507f, 0.05496337f, 0.09162878f, 
    0.11108218f, -0.06309793f, 0.14737503f, 0.07632234f, 0.26475322f, -0.08478516f, 0.03729333f, 0.24194768f, 
    -0.08731939f, 0.04442156f, 0.02532121f, -0.08359672f, 0.06500569f, -0.00415155f, 0.13227753f, 0.06390659f, 
    -0.48799488f, -0.09898073f, -0.32366759f, 0.07938426f, -0.07355637f, -0.11864756f, 0.31565219f, 0.05455177f, 
    0.07530256f, -0.05812288f, 0.02239262f, -0.01472773f, 0.09058005f, 0.12506570f, 0.10351665f, 0.06280097f, 
    -0.02443445f, -0.03044514f, -0.06086588f, 0.00511787f, -0.10428149f, 0.18670045f, 0.24815373f, -0.34563413f, 
    0.02264964f, -0.02194765f, -0.03949237f, -0.06293076f, 0.02334722f, 0.07075148f, -0.08515711f, -0.11083903f, 
    -0.15306547f, 0.02424529f, -0.05184934f, 0.05973355f, -0.21570511f, 0.07378296f, -0.33685461f, 0.08450308f, 
    -0.00311793f, 0.05278671f, -0.05593784f, 0.02320710f, 0.03599415f, 0.02634978f, -0.27561978f, -0.12572812f, 
    -0.01249194f, 0.07324428f, 0.00718436f, -0.10492221f, -0.03215560f, -0.01478634f, -0.11424978f, -0.00855050f, 
    -0.12961116f, -0.22716258f, 0.00186597f, -0.24501641f, -0.04677684f, 0.09475116f, -0.13053782f, -0.45007887f, 
    -0.12185923f, -0.09216776f, -0.13920711f, -0.08803512f, -0.00476526f, -0.11036495f, 0.01189025f, 0.02428664f, 
    -0.66303700f, 0.27409267f, -0.07965887f, -0.04005368f, -0.19666485f, 0.10975824f, 0.00591627f, -0.27024069f, 
    0.15110880f, 0.05074646f, -0.00768405f, 0.00391493f, -0.05987187f, 0.04473530f, 0.13583794f, -0.03411743f, 
    -0.03461232f, 0.08035514f, -0.05361522f, 0.05888310f, 0.02108088f, 0.07114714f, 0.00415323f, 0.02853984f, 
    0.41430831f, -0.02005609f, 0.14572860f, -0.01330867f, -0.06012009f, -0.04591188f, -0.04585513f, 0.00920888f, 
    -0.11048516f, -0.14806885f, -0.16493529f, -0.10271508f, -0.03015707f, 0.01508385f, -0.34715962f, -0.17863846f, 
    0.06711105f, 0.07041108f, 0.01123432f, -0.04584799f, -0.11459376f, -0.00460231f, -0.09586964f, -0.00993761f, 
    -0.02250251f, 0.07715470f, 0.00033648f, -0.01066431f, -0.03898988f, 0.02142549f, -0.04759032f, 0.01965960f, 
    -0.30574253f, -0.26628336f, -0.24696001f, -0.38634947f, -0.02430713f, 0.05065997f, -0.04263123f, -0.06451524f, 
    0.04354118f, 0.10611448f, 0.06836508f, -0.03884702f, -0.08277697f, 0.04244321f, 0.01166014f, -0.10878710f, 
    0.56622183f, -0.09114744f, -0.28820553f, -0.09416806f, -0.14946027f, -0.02882004f, -0.07961246f, -0.10960392f, 
    0.05478359f, 0.01740708f, -0.06505775f, 0.05931593f, 0.36063516f, 0.17963967f, 0.13913336f, 0.20240867f, 
    0.05356938f, 0.05615787f, 0.04358948f, 0.04509756f, 0.02287306f, -0.01024962f, 0.06725181f, -0.10536514f, 
    0.28801411f, -0.05614939f, 0.11489514f, -0.20524284f, 0.04696320f, 0.01978888f, -0.02088298f, -0.00272355f, 
    0.01264411f, -0.02393922f, -0.15093619f, -0.15122867f, 0.26743799f, 0.18856484f, 0.24977346f, 0.09793756f, 
    -0.07599729f, 0.02195458f, 0.01170075f, -0.01891320f, 0.02831321f, 0.01119001f, -0.00940474f, 0.00721731f, 
    0.34300321f, 0.15167104f, 0.04150149f, -0.10980533f, 0.08000387f, 0.07693939f, -0.15363505f, -0.12823217f, 
    0.03579341f, -0.04212968f, -0.16141373f, -0.03461719f, -0.41908813f, -0.18770669f, 0.08229077f, -0.13352326f, 
    0.03233287f, 0.16769104f, -0.33377230f, -0.31159565f, 0.02212759f, 0.02890747f, -0.09882601f, 0.04536839f, 
    -0.09593590f, -0.14511688f, 0.09928326f, 0.00802101f, 0.01817129f, -0.00018590f, 0.06158883f, 0.02850092f, 
    0.24795254f, -0.02452209f, 0.06843524f, -0.01956320f, 0.11081458f, -0.10458273f, -0.04025782f, 0.00814334f, 
    0.06585937f, -0.04836523f, -0.04896237f, 0.03501569f, -0.21274003f, -0.07427822f, 0.21883515f, 0.08922155f, 
    -0.22869849f, -0.00946707f, 0.11225342f, -0.09309781f, 0.00807102f, -0.03275054f, -0.01148105f, 0.08013275f, 
    -0.04373558f, 0.13580558f, -0.34968355f, -0.08863953f, 0.45263663f, 0.04678470f, 0.02648225f, 0.01996592f, 
    -0.42307523f, 0.05669488f, 0.07337241f, -0.19688308f, -0.09110393f, 0.05389237f, -0.06124651f, 0.03763866f, 
    -0.31547135f, -0.05679571f, 0.17895482f, 0.15762410f, -0.01214720f, -0.05964838f, -0.01315093f, -0.24156958f, 
    0.03238497f, 0.05902014f, 0.03828883f, 0.08500133f, -0.26590201f, 0.14974953f, 0.18795362f, -0.15869066f, 
    0.02272539f, 0.05491117f, -0.05479749f, 0.07231715f, 0.03938877f, 0.00135059f, -0.09172893f, 0.05046884f, 
    -0.08529563f, 0.20520787f, -0.01422260f, 0.06223807f, 0.09650485f, 0.00271543f, 0.09770592f, 0.08741180f, 
    -0.00864606f, -0.02171599f, -0.04568845f, 0.13680671f, 0.02874610f, 0.18035948f, 0.24582967f, 0.15739709f, 
    -0.09042022f, 0.00623515f, 0.04946875f, 0.00023804f, -0.12899999f, 0.12445556f, 0.05447523f, -0.02398253f, 
    -0.18358678f, 0.36146846f, -0.33640519f, -0.14265071f, 0.00088791f, 0.00195648f, 0.04092772f, 0.02412429f, 
    0.01934868f, 0.05365495f, 0.04556941f, -0.08034369f, -0.43938097f, -0.49745890f, -0.31359619f, -0.18325682f, 
    0.12682152f, 0.05802417f, -0.17354043f, -0.00505982f, -0.06564895f, 0.00498010f, -0.00060613f, -0.00840214f, 
    -0.07752325f, -0.10453756f, -0.09107590f, -0.07174635f, -0.04703461f, 0.02523021f, -0.00798305f, -0.02328884f, 
    -0.02772792f, -0.07612692f, -0.03321856f, 0.07861372f, -0.22477347f, -0.01766846f, 0.09648777f, -0.05059811f, 
    -0.11190698f, -0.16190062f, -0.34269902f, -0.02313495f, 0.04078159f, -0.07463843f, -0.01821441f, 0.01261672f, 
    -0.02060927f, -0.06438213f, -0.05033494f, 0.06317285f, 0.14397976f, 0.00797396f, -0.02877793f, 0.00220217f, 
    -0.06478591f, -0.05204210f, -0.00995507f, 0.05405838f, -0.16371094f, -0.00387314f, -0.12261889f, -0.10907045f, 
    0.07957305f, -0.05629909f, 0.06083967f, -0.08774786f, -0.02448848f, -0.06791113f, -0.07120118f, -0.00153100f, 
    -0.08350800f, -0.06846465f, -0.11687774f, -0.06157704f, 0.15008205f, 0.01893106f, -0.10743129f, 0.03321020f, 
    -0.00083029f, 0.03903252f, -0.07462388f, 0.02597486f, -0.08692463f, -0.16583741f, 0.07601254f, 0.22726680f, 
    -0.15260072f, 0.07041927f, -0.00040245f, -0.10129680f, -0.00225493f, -0.05596295f, -0.03960840f, 0.02259094f, 
    0.11616636f, -0.08898404f, 0.01282172f, -0.26196700f, -0.00839956f, -0.10372022f, 0.05491495f, 0.09413335f, 
    0.01997318f, 0.12894860f, 0.10627680f, -0.10807297f, -0.13277739f, 0.18837526f, 0.06932846f, -0.28205639f, 
    -0.01383805f, -0.02856265f, -0.04352843f, -0.13928635f, 0.04059115f, 0.08266726f, -0.01589653f, -0.12191023f, 
    -0.16331926f, -0.12535532f, 0.33370575f, 0.13962340f, -0.00153387f, 0.06567883f, -0.01366885f, 0.15801051f, 
    -0.10231838f, -0.00470732f, 0.00687978f, 0.01732049f, -0.28221110f, 0.28556284f, 0.15710096f, -0.01998804f, 
    -0.04850076f, -0.07236277f, -0.03336866f, -0.14695360f, 0.02782800f, 0.10059980f, -0.00306444f, -0.11230993f, 
    0.08482191f, -0.04976267f, -0.29850796f, -0.00219494f, 0.04699570f, 0.01027961f, -0.08980058f, -0.00853542f, 
    0.06545150f, 0.07356630f, -0.07175740f, -0.06842423f, -0.06523946f, 0.19785906f, 0.02852799f, 0.08110327f, 
    0.03876595f, 0.01895574f, 0.10575225f, -0.18340433f, 0.08144315f, 0.23189233f, 0.01865429f, 0.19633116f, 
    -0.02239510f, -0.13488401f, 0.09320146f, 0.05592267f, 0.00253187f, 0.05765404f, 0.05217722f, -0.08910232f, 
    -0.02746066f, 0.07963809f, 0.05756665f, 0.00409097f, 0.04891725f, 0.10885653f, 0.35672155f, 0.06484871f, 
    0.05525745f, -0.02124912f, 0.08643283f, 0.02241817f, -0.04342861f, -0.11222569f, 0.13427444f, -0.16178535f, 
    -0.08761904f, -0.07386988f, -0.05906555f, 0.17567635f, -0.01732188f, -0.00616605f, -0.07652078f, -0.17336643f, 
    0.07017937f, 0.00868268f, -0.07370697f, 0.03060972f, -0.34284705f, 0.04743656f, -0.06932921f, 0.12556186f, 
    -0.00197531f, 0.00120617f, 0.02596173f, 0.04448693f, -0.04728457f, -0.07533030f, 0.22157922f, -0.17650318f, 
    0.05553317f, 0.00065621f, -0.00446347f, -0.04337908f, -0.12853824f, -0.08727366f, 0.03083389f, -0.06266276f, 
    0.00652592f, -0.00600473f, -0.24871127f, 0.09677021f, -0.26758951f, -0.32071063f, -0.53566998f, -0.03087509f, 
    -0.01189794f, -0.02018723f, -0.02447508f, 0.00949674f, -0.02458513f, -0.11130595f, -0.00962652f, 0.02179127f, 
    -0.18575527f, 0.03068083f, -0.25456542f, -0.01985802f, 0.01384141f, 0.03784701f, -0.14127545f, -0.06972542f, 
    -0.03846981f, -0.00653746f, -0.00157706f, 0.09261388f, -0.33136144f, 0.17766531f, 0.69050533f, -0.11246152f, 
    -0.17528026f, -0.08958371f, 0.00800152f, -0.07663800f, 0.02164776f, 0.00248367f, 0.05826057f, -0.06563231f, 
    -0.06591649f, 0.00627830f, -0.03822302f, -0.04012706f, -0.04573968f, -0.06708392f, 0.00828653f, 0.11887853f, 
    -0.08992024f, -0.05605881f, -0.00188947f, 0.03092657f, -0.15017416f, -0.05780616f, -0.09142568f, -0.08785356f, 
    -0.13882209f, 0.14949651f, 0.09590620f, -0.16130283f, 0.04124951f, -0.05645772f, -0.01921481f, -0.10850273f, 
    -0.53979951f, 0.28372529f, 0.13306038f, -0.36774716f, -0.19939815f, -0.05854028f, -0.02141501f, -0.13326694f, 
    -0.11633033f, -0.05751161f, -0.01217251f, -0.08173020f, -0.04362936f, 0.02574221f, -0.06479274f, 0.11279388f, 
    0.05176722f, 0.02333760f, -0.12924720f, 0.14153433f, -0.04115307f, -0.01831269f, -0.02471896f, -0.00990547f, 
    -0.07300247f, 0.18211642f, 0.11003627f, 0.15225826f, 0.01647319f, 0.00185075f, 0.02312155f, 0.03930779f, 
    0.02201716f, -0.15546103f, 0.12824942f, 0.08960175f, 0.00028864f, 0.34815374f, -0.08769003f, 0.42058939f, 
    -0.01416097f, -0.05085473f, 0.15618557f, 0.03827237f, -0.01782605f, 0.02412667f, 0.00536444f, 0.08389621f, 
    -0.07395820f, -0.03097594f, -0.11167800f, 0.09378833f, -0.07458879f, -0.00066387f, 0.01599179f, 0.08019571f, 
    -0.00988796f, 0.05494766f, 0.01348324f, 0.00945966f, -0.45817146f, -0.24715188f, -0.16266818f, -0.16795553f, 
    0.13310859f, -0.04237797f, -0.08695661f, 0.01506780f, -0.05917818f, -0.00366708f, -0.05897291f, -0.00216587f, 
    -0.12231500f, -0.00688841f, -0.03407135f, -0.05517687f, -0.00039552f, -0.05326550f, -0.00049171f, 0.05280961f, 
    -0.00349164f, -0.04375782f, -0.06920893f, 0.07740188f, -0.22164415f, 0.31915584f, -0.09981588f, -0.27356565f, 
    0.04708064f, -0.02808720f, -0.02830349f, 0.01176646f, -0.00605324f, 0.01554381f, 0.03152444f, -0.02040952f, 
    -0.13508335f, -0.05325028f, -0.15751930f, 0.18421613f, -0.18134382f, 0.00828128f, -0.09905972f, 0.07333196f, 
    -0.01844832f, -0.01354026f, 0.00807528f, 0.01922710f, -0.00116635f, 0.28766701f, -0.28632203f, -0.21303584f, 
    0.11984131f, -0.16300273f, 0.22295876f, 0.20207617f, -0.02318594f, 0.01576919f, -0.04205232f, 0.02875137f, 
    -0.41032764f, -0.31643274f, -0.22882384f, -0.25510895f, -0.09481072f, -0.03680886f, 0.15079270f, -0.14429536f, 
    0.02810689f, 0.02152896f, 0.03378769f, -0.00144080f, -0.16903532f, -0.09949329f, -0.26018244f, 0.16964890f, 
    0.04281544f, 0.00472658f, 0.02752118f, -0.14486955f, 0.10771324f, -0.02283739f, -0.00407835f, -0.07319824f, 
    -0.07817490f, -0.02715765f, 0.13968433f, -0.10071412f, 0.00200957f, 0.04258797f, -0.11018461f, 0.09212162f, 
    0.00291271f, -0.04059912f, 0.08717936f, -0.07298144f, -0.02079985f, 0.05745942f, 0.06490839f, 0.08156108f, 
    -0.03080078f, -0.03626728f, 0.03882342f, 0.13613434f, 0.12541097f, -0.01860246f, 0.02695703f, -0.02503627f, 
    0.08589592f, 0.35262984f, -0.30636173f, 0.10585725f, 0.00233644f, 0.02490906f, -0.01222711f, 0.16922049f, 
    0.05169623f, 0.03808612f, 0.07827976f, -0.14439598f, 0.14705542f, 0.02830945f, -0.26404166f, -0.02209827f, 
    -0.05180191f, -0.00254139f, -0.01919235f, -0.01734045f, -0.16796176f, 0.05594216f, 0.12356243f, -0.00493545f, 
    0.19880226f, -0.03578291f, 0.00318355f, 0.07247647f, 0.12338354f, -0.32033935f, -0.13393755f, 0.00938307f, 
    0.02899795f, 0.06473090f, 0.12951565f, 0.02061605f, -0.31875384f, -0.05337105f, -0.01362750f, 0.08025987f, 
    -0.01821831f, 0.01285107f, 0.00129286f, -0.07435925f, -0.00855454f, -0.04531201f, -0.03313494f, 0.12008869f, 
    0.02878878f, 0.06736422f, -0.00518547f, 0.00516273f, -0.04163330f, 0.01507082f, 0.01369017f, -0.04671002f, 
    0.06562713f, 0.03755576f, 0.07118904f, 0.15834062f, -0.65119416f, 0.15457088f, 0.17985763f, -0.32030055f, 
    0.11675381f, -0.04055901f, 0.03902006f, -0.02411033f, 0.02758318f, -0.02956326f, 0.06714600f, 0.01234087f, 
    0.19638066f, 0.13562740f, -0.44818300f, 0.24230623f, -0.06762546f, -0.10945736f, 0.03996956f, -0.10013080f, 
    0.04656173f, 0.05778762f, 0.11728545f, -0.00271964f, -0.42863622f, -0.30090877f, -0.30262986f, -0.38355896f, 
    0.05166635f, 0.00059034f, -0.01169530f, -0.08703611f, -0.01181882f, -0.08036561f, 0.02029639f, -0.00332864f, 
    -0.18954283f, 0.14050713f, -0.00867398f, -0.01357529f, -0.00535915f, -0.04870142f, -0.00838618f, -0.07638725f, 
    0.11773738f, 0.06760793f, 0.10723453f, 0.16790423f, 0.35389769f, 0.25044233f, 0.09015517f, 0.30586356f, 
    0.03077732f, -0.01055087f, 0.03246470f, 0.12070456f, 0.04733661f, -0.03562516f, 0.02097439f, -0.04204274f, 
    0.05017451f, -0.08207155f, -0.02464155f, -0.01516235f, 0.03252894f, -0.00978053f, -0.00125928f, -0.04451478f, 
    0.03671988f, 0.14139302f, 0.00603214f, 0.09596596f, -0.01010904f, 0.12437434f, -0.02450718f, 0.03173252f, 
    -0.00159016f, 0.14452259f, -0.10201684f, 0.11881395f, -0.03941520f, -0.06963503f, -0.01922747f, 0.00456053f, 
    -0.58680284f, 0.04363992f, -0.08886646f, -0.29968333f, -0.13977435f, -0.12497357f, -0.05811406f, -0.18933085f, 
    0.05901421f, -0.00175819f, -0.02062993f, 0.04004003f, 0.02692013f, 0.07895293f, 0.54222393f, 0.41474056f, 
    0.04954061f, 0.02990289f, -0.04821806f, 0.10821028f, 0.02931644f, -0.10331034f, 0.01374269f, -0.00087125f, 
    0.03865413f, -0.00422198f, 0.10454326f, -0.06978853f, 0.03555994f, 0.05847631f, -0.07563122f, -0.03556245f, 
    0.00407834f, -0.00919170f, -0.04111382f, 0.14064352f, 0.10600542f, -0.08175754f, 0.14089406f, -0.14156725f, 
    0.01301267f, -0.02364615f, -0.04327107f, 0.09084394f, -0.06597324f, -0.06965240f, -0.02467493f, -0.09078882f, 
    -0.11973983f, 0.12066999f, 0.33730942f, 0.11226489f, -0.00206284f, -0.01318000f, 0.00004943f, -0.09354450f, 
    0.07434655f, -0.03606247f, -0.01277596f, 0.04424536f, 0.41357949f, 0.28457910f, -0.14597376f, 0.04953847f, 
    -0.03270960f, 0.12912054f, -0.07529192f, -0.01192732f, 0.10180399f, -0.02972104f, -0.03929861f, 0.11923258f, 
    0.05305625f, 0.06341948f, -0.04843050f, 0.13726556f, -0.01138389f, -0.12934788f, -0.02283883f, 0.02654127f, 
    -0.04408428f, -0.01996070f, 0.01667007f, -0.05333996f, 0.19022909f, -0.00394924f, 0.07597718f, -0.05432338f, 
    0.04033219f, -0.03716242f, -0.02015590f, 0.02558228f, -0.03073271f, 0.17512526f, 0.00493498f, 0.10174596f, 
    -0.06235525f, 0.01259479f, -0.09224358f, 0.07350881f, -0.02927446f, -0.02745609f, 0.00542023f, -0.07148594f, 
    0.03819474f, -0.06784882f, -0.06490327f, 0.09177512f, -0.85410804f, -0.03442156f, 0.13698307f, -0.08140316f, 
    -0.03668085f, 0.03730404f, -0.01306945f, -0.30020186f, 0.01982838f, -0.01732575f, -0.05318347f, 0.03912824f, 
    -0.32488516f, 0.15379955f, -0.04975266f, 0.02988078f, -0.35175854f, -0.15507007f, 0.05840583f, -0.09015814f, 
    -0.06181067f, 0.06217133f, -0.16848662f, 0.06097301f, -0.12303416f, -0.06514198f, 0.10349827f, -0.17777212f, 
    -0.18509033f, 0.00458416f, -0.25725466f, -0.12046305f, -0.05460493f, 0.14428686f, -0.08934037f, -0.08896214f, 
    -0.23068394f, -0.18179137f, -0.06685200f, 0.12036000f, 0.03327947f, 0.02376055f, -0.04411889f, 0.05582207f, 
    -0.04092691f, 0.02087180f, -0.02446314f, -0.01205327f, -0.25013262f, 0.01151516f, -0.06981509f, 0.06112503f, 
    0.06394543f, -0.06218288f, 0.05340636f, -0.14421594f, 0.04797760f, 0.01261105f, -0.01571789f, -0.06009856f, 
    0.08639730f, 0.41920960f, 0.07360271f, -0.39711058f, 0.00998367f, 0.00361799f, -0.11357115f, 0.22856505f, 
    -0.11952857f, 0.05186193f, -0.06176879f, -0.18653436f, 0.05078631f, -0.07824118f, -0.10266556f, 0.09610166f, 
    0.12157817f, 0.03988750f, 0.06046236f, 0.16609679f, 0.01393618f, -0.03243979f, 0.04629941f, -0.04200505f, 
    0.18937185f, 0.04420585f, 0.27557775f, -0.34117922f, -0.39478946f, -0.14327592f, 0.01985714f, 0.14712404f, 
    0.16932897f, 0.16411571f, 0.16615885f, 0.08198246f, -0.34314123f, 0.29320619f, 0.43003583f, 0.51873839f, 
    0.04085371f, 0.19186541f, 0.10213140f, -0.01800839f, 0.00084890f, -0.04185588f, 0.16415438f, 0.10096260f, 
    0.32596540f, 0.02730667f, -0.00385714f, 0.07644010f, 0.08044851f, -0.00954908f, 0.04782706f, -0.17287570f, 
    0.10325559f, 0.10352780f, -0.05622336f, 0.27277848f, -0.11459327f, 0.34908924f, -0.09301113f, 0.31641155f, 
    -0.06423470f, -0.02198827f, -0.01732411f, 0.00515113f, -0.05712026f, 0.12881061f, 0.03723630f, 0.09398916f, 
    0.19139461f, -0.06226076f, 0.00296750f, -0.13103391f, 0.15798275f, 0.03872550f, 0.00380026f, 0.06237251f, 
    0.09234862f, 0.01721201f, 0.18662146f, -0.14930941f, -0.30137846f, 0.68013012f, -0.17995228f, 0.00846642f, 
    -0.07404460f, -0.17810023f, 0.04120644f, -0.26723626f, 0.10995334f, 0.21311019f, -0.03164251f, -0.31814179f, 
    -0.34770703f, 0.49263132f, -0.17339690f, 0.14124610f, 0.03441332f, 0.02662503f, 0.09477208f, -0.11482191f, 
    -0.08647854f, 0.10679893f, 0.03703725f, -0.19433387f, -0.31367311f, -0.13109790f, 0.12664944f, 0.26944217f, 
    -0.06464211f, -0.01853143f, -0.19806534f, 0.09520700f, -0.00695194f, -0.02345568f, -0.02100302f, 0.04626810f, 
    -0.26166213f, 0.12545678f, -0.19624563f, -0.23217036f, 0.27572694f, -0.01136033f, 0.08573616f, -0.12568222f, 
    -0.30276656f, -0.06614377f, -0.05593910f, -0.10254581f, -0.50078803f, -0.07454654f, -0.00402931f, 0.23445329f, 
    0.10967459f, 0.00148162f, 0.06202414f, -0.02194426f, 0.10957488f, -0.13235405f, 0.03159611f, 0.02404077f, 
    -0.08863977f, 0.65348637f, 0.04060329f, -0.06419238f, 0.23005661f, 0.08014818f, -0.00472525f, 0.19268204f, 
    -0.23645914f, -0.11200827f, 0.14182670f, 0.10231891f, 0.01218735f, -0.17692584f, -0.00502969f, 0.11266558f, 
    -0.14136630f, 0.06100356f, 0.03173405f, -0.04320431f, -0.01372245f, 0.07559460f, 0.01404158f, 0.12634465f, 
    -0.01413849f, -0.12122125f, -0.02545059f, 0.18233851f, 0.02335322f, 0.04824563f, 0.06184502f, 0.03238354f, 
    -0.05593769f, -0.03610170f, 0.08274488f, 0.00604231f, -0.07289004f, -0.01999816f, 0.13515469f, -0.06715439f, 
    0.07124064f, 0.02468621f, -0.11926730f, 0.02403348f, -0.04749261f, 0.01013725f, 0.10745119f, 0.03897009f, 
    -0.24522673f, -0.04877023f, 0.01673105f, 0.21981311f, 0.03169097f, 0.00553519f, 0.04102477f, 0.07358143f, 
    -0.06031665f, -0.05848145f, 0.08425158f, -0.11874650f, -0.07377649f, -0.21843190f, -0.27919218f, -0.24984139f, 
    0.08112612f, -0.22141625f, -0.25797209f, -0.18791248f, -0.05005681f, 0.00608844f, -0.12907791f, -0.11491694f, 
    -0.07492380f, 0.20289689f, -0.09914133f, 0.08416018f, -0.03274326f, -0.13997442f, 0.08001137f, -0.16296236f, 
    -0.18990466f, 0.05897813f, -0.09080805f, 0.05864143f, -0.13340354f, 0.06617266f, -0.10587742f, -0.31905785f, 
    0.13042234f, -0.02740677f, -0.02240678f, 0.05536747f, -0.12409028f, 0.11034051f, -0.00434508f, -0.05499656f, 
    -0.25433084f, -0.02014342f, 0.15692219f, 0.13847458f, -0.10783824f, -0.00260359f, -0.05156346f, -0.00322792f, 
    0.04709849f, -0.11718191f, 0.21685997f, 0.05311547f, 0.10784625f, -0.10705935f, -0.00097740f, 0.28924644f, 
    0.16272298f, 0.02278835f, -0.02602248f, -0.07647141f, 0.06138553f, 0.01298927f, 0.14646907f, 0.11448270f, 
    -0.38370612f, 0.08687264f, -0.21062617f, -0.08619515f, 0.00354690f, -0.38080195f, -0.05948072f, -0.01295688f, 
    -0.19468750f, 0.10611659f, -0.07212550f, 0.18197265f, 0.11512284f, 0.00730163f, -0.00398486f, 0.29644704f, 
    0.00588601f, 0.01767722f, 0.01541562f, 0.00031822f, 0.08971980f, 0.06591942f, -0.01855256f, -0.08429608f, 
    0.16853783f, -0.03424595f, -0.03269878f, 0.26773119f, 0.05679134f, -0.02039090f, 0.06288528f, -0.01261549f, 
    -0.05980442f, 0.02984680f, 0.04578789f, -0.00301538f, 0.01743325f, 0.28998628f, -0.23763625f, 0.04440037f, 
    -0.08235975f, -0.17024300f, -0.01592913f, 0.14739437f, -0.15020908f, 0.05268102f, -0.19804685f, 0.10605750f, 
    0.23573112f, -0.30443192f, -0.12652834f, -0.06949320f, 0.28403056f, 0.14718542f, 0.08920831f, 0.01216966f, 
    -0.06331403f, -0.06225698f, -0.15309280f, 0.03862380f, 0.27334806f, -0.18542799f, -0.08883815f, 0.06952639f, 
    -0.03693599f, -0.10711174f, 0.06141543f, -0.09987056f, 0.00945020f, 0.05261765f, 0.02339274f, 0.20834981f, 
    0.26975480f, -0.24163006f, -0.25621569f, -0.41693786f, -0.01198297f, 0.07008301f, -0.04353137f, 0.05554564f, 
    0.02385434f, -0.13870470f, 0.16573787f, -0.11563443f, 0.06294987f, -0.20654599f, 0.02871931f, -0.00091179f, 
    0.06707967f, 0.09901559f, 0.02927527f, 0.02476371f, -0.06682725f, 0.00828613f, -0.12233873f, -0.03253013f, 
    -0.16689256f, -0.48450774f, -0.12711048f, -0.18734279f, -0.37932724f, -0.13789709f, 0.01552082f, -0.28138858f, 
    0.04056884f, 0.07052025f, -0.17877923f, 0.08448204f, -0.35521862f, -0.08092038f, 0.22874342f, -0.04131256f, 
    -0.10631618f, 0.06956226f, -0.05691767f, -0.08327206f, 0.00255589f, 0.00034540f, -0.02737808f, -0.00337873f, 
    0.01221313f, 0.03283101f, -0.44353789f, 0.23416629f, -0.10228231f, -0.18165532f, 0.07992868f, -0.13294052f, 
    -0.07131384f, -0.15685229f, 0.01655179f, 0.17629823f, -0.25559342f, 0.21502899f, 0.11407240f, 0.07471488f, 
    -0.14386000f, 0.01095310f, 0.03211338f, -0.03991966f, 0.01089525f, 0.02142514f, 0.18290128f, 0.17271826f, 
    -0.11759558f, -0.16867292f, -0.11364065f, 0.16359289f, 0.12468901f, 0.06178962f, 0.12893981f, -0.10139343f, 
    0.08094414f, -0.02137884f, -0.04312037f, 0.03084768f, 0.47756124f, 0.02385718f, -0.30174303f, -0.25087988f, 
    0.02510694f, -0.10961945f, -0.26141065f, 0.18242987f, -0.11147931f, 0.20015100f, -0.19002998f, -0.16184351f, 
    -0.22784504f, 0.21813507f, -0.18273979f, 0.17137943f, 0.06808199f, -0.05123364f, 0.08575120f, -0.08422414f, 
    -0.11710536f, -0.00480316f, 0.12350460f, -0.17749801f, -0.09518431f, 0.35658935f, -0.24494596f, -0.09348596f, 
    0.10173354f, -0.04573508f, 0.02181741f, -0.05351597f, -0.06439548f, -0.09642982f, 0.13384813f, 0.00686784f, 
    -0.26027852f, 0.35722369f, -0.32405794f, 0.08540925f, 0.04130096f, -0.05162602f, -0.04826697f, 0.04483604f, 
    -0.11548167f, -0.15507776f, 0.11194484f, -0.08098760f, 0.39574978f, 0.07028595f, 0.21782947f, 0.02073078f, 
    -0.11511287f, 0.14813156f, -0.09954494f, -0.01770484f, -0.03679483f, -0.24087420f, 0.15654776f, -0.09531610f, 
    0.84694892f, 0.01039524f, 0.29193273f, 0.29320097f, 0.21416561f, -0.00338146f, -0.14204717f, -0.03684066f, 
    -0.21047638f, 0.04409133f, 0.16192061f, 0.01081067f, 0.06831255f, -0.04158904f, -0.13279578f, -0.03689048f, 
    -0.05920910f, 0.01926478f, -0.12994809f, -0.07941322f, 0.02822802f, 0.00107353f, 0.14405002f, -0.00711085f, 
    -0.09711054f, -0.09547059f, -0.03067464f, 0.12205974f, -0.05168569f, 0.10333253f, -0.04585558f, -0.05009523f, 
    0.03032657f, -0.00508941f, 0.11675699f, 0.09086037f, -0.11852828f, -0.18894273f, 0.13567725f, 0.26692238f, 
    -0.14325522f, -0.12231477f, 0.13767672f, -0.00522765f, 0.03859229f, 0.09063939f, -0.10540155f, -0.15839431f, 
    -0.59842747f, 0.43773538f, -0.19927050f, -0.56708461f, 0.04634586f, -0.13871618f, -0.34406957f, -0.06350116f, 
    -0.14901847f, 0.05733334f, -0.30842286f, -0.13215025f, 0.09588936f, -0.17270382f, 0.13187566f, 0.06825837f, 
    -0.09491853f, -0.00151929f, 0.12018910f, 0.00453881f, -0.05553850f, -0.03144138f, -0.01413661f, -0.07414225f, 
    -0.61287886f, 0.06472146f, -0.08688696f, 0.10914525f, -0.05587463f, 0.10099123f, -0.05754265f, 0.04902345f, 
    -0.00223140f, 0.18032695f, 0.04781491f, -0.03775943f, 0.19548623f, -0.08440756f, -0.01944328f, -0.02559860f, 
    0.07403283f, -0.02769400f, -0.03567811f, -0.08685328f, -0.08780938f, -0.00158296f, -0.04249646f, -0.03132959f, 
    0.00978615f, 0.28947619f, 0.03584291f, 0.16392475f, 0.04724422f, -0.00930650f, 0.04938597f, 0.03580346f, 
    0.00951099f, 0.02289508f, 0.07670030f, -0.08862580f, -0.07417610f, 0.08464208f, -0.00559726f, 0.16746414f, 
    0.05816194f, 0.01896203f, -0.02119486f, -0.11897090f, 0.04862055f, 0.02441477f, 0.11304796f, 0.01530154f, 
    -0.27522749f, 0.05638900f, 0.15674944f, 0.41122398f, 0.04841808f, -0.00376181f, 0.00433055f, -0.04728297f, 
    0.07759207f, -0.00935428f, -0.10159107f, -0.01994646f, -0.12404813f, -0.13171396f, -0.02983326f, 0.23885670f, 
    0.07103878f, -0.04832444f, -0.06890758f, 0.01021569f, 0.00654127f, 0.09844942f, 0.00383035f, 0.01832714f, 
    -0.28148338f, -0.21555921f, -0.25704047f, 0.15475322f, -0.03118558f, 0.05057839f, -0.07088721f, -0.02697892f, 
    0.02464686f, -0.02641121f, -0.05775364f, 0.06422647f, 0.32883745f, -0.14483139f, 0.08193860f, 0.12124347f, 
    -0.03476390f, -0.07977682f, 0.02563451f, 0.02986173f, -0.14171141f, -0.09097685f, 0.10275398f, -0.01125649f, 
    0.01661720f, -0.14202687f, 0.01585684f, 0.19377421f, -0.00790507f, -0.14949076f, -0.08386226f, 0.01431663f, 
    -0.06448799f, 0.03186535f, -0.11079402f, 0.16860177f, 0.28543362f, -0.02516843f, -0.06243538f, 0.39555869f, 
    0.09650788f, -0.00292636f, -0.09042094f, -0.24796167f, -0.15808168f, -0.00375575f, 0.02378107f, -0.01546109f, 
    -0.52234185f, 0.84886247f, -0.25763708f, -0.06431510f, -0.02467709f, -0.02873812f, -0.00843794f, -0.17246452f, 
    -0.36921027f, -0.00117025f, -0.21576113f, 0.09737624f, 0.12400080f, 0.33468851f, -0.12301759f, -0.01988602f, 
    0.01358629f, 0.03065425f, 0.05587576f, -0.28855497f, -0.16587900f, -0.17702402f, 0.05841962f, -0.15233679f, 
    0.17504860f, 0.01565873f, -0.04727012f, -0.13473324f, -0.08210292f, 0.01559302f, -0.07961454f, 0.04690250f, 
    -0.02546198f, 0.05019583f, -0.03556153f, 0.01406598f, -0.19322877f, -0.07656958f, 0.07524651f, 0.33260915f, 
    0.16044931f, 0.05234081f, -0.06806082f, -0.03882519f, 0.09820179f, -0.15743491f, 0.09470771f, -0.08217268f, 
    0.05272816f, -0.15613472f, -0.11133265f, -0.02223497f, -0.03550878f, -0.14330389f, -0.10895764f, -0.10660550f, 
    0.03270342f, 0.06717290f, -0.06248263f, -0.11048145f, -0.34089583f, -0.09012969f, -0.21746683f, 0.14829120f, 
    -0.01535683f, -0.02347791f, 0.00281383f, 0.04008867f, 0.04027065f, -0.00154445f, -0.00971244f, 0.01009077f, 
    0.04370737f, 0.10536051f, 0.02664324f, 0.07629694f, -0.00197403f, -0.07581028f, -0.09204328f, -0.04168687f, 
    0.00647439f, -0.05055432f, -0.09906920f, -0.00857368f, 0.03516830f, 0.01349674f, 0.04499206f, -0.03874605f, 
    0.00931623f, -0.03402207f, -0.05314094f, 0.01381866f, 0.05040456f, -0.00171145f, -0.07655014f, 0.03077448f, 
    -0.06022655f, -0.26656893f, 0.06580909f, 0.09670810f, 0.06225794f, -0.01905286f, 0.03585485f, 0.07135665f, 
    -0.06990402f, -0.05746899f, -0.01522062f, 0.12714648f, 0.17267431f, 0.24632673f, 0.35128099f, 0.16587003f, 
    0.02574131f, -0.05484772f, -0.08663980f, -0.01866327f, 0.13343391f, 0.21665680f, 0.01471094f, 0.05727591f, 
    0.14225906f, -0.02585008f, 0.01395074f, 0.11847901f, 0.07000826f, 0.01943177f, 0.00703852f, -0.06182864f, 
    0.08580653f, 0.05682837f, 0.04077912f, 0.04749618f, 0.09590776f, 0.05010473f, -0.02780766f, 0.03807015f, 
    0.18509446f, -0.02319643f, 0.16907138f, -0.04261753f, 0.16195838f, 0.06548475f, -0.01448356f, -0.00899055f, 
    0.08856314f, 0.13566600f, -0.05108520f, 0.07422062f, 0.07595095f, -0.02630549f, 0.09950654f, -0.04622981f, 
    -0.08546949f, -0.12873501f, -0.14555435f, -0.18897006f, -0.02624645f, -0.14806260f, 0.24132173f, -0.28186327f, 
    0.00511907f, 0.13678612f, -0.06958974f, 0.00217156f, -0.03274295f, 0.08002753f, -0.10640661f, -0.09751809f, 
    -0.02797573f, 0.00624103f, 0.11565840f, 0.11346654f, -0.02951155f, -0.24521504f, -0.07745214f, 0.17823100f, 
    -0.03956723f, -0.00819801f, -0.10613647f, -0.07403676f, 0.08103655f, -0.27342337f, 0.05288823f, -0.16825154f, 
    -0.03379815f, 0.05601451f, -0.07901963f, -0.01171974f, -0.10803957f, -0.03932577f, -0.12585039f, -0.00207705f, 
    -0.09164286f, -0.16806072f, -0.09636878f, -0.03746998f, 0.03393025f, -0.06995630f, 0.05414153f, -0.12748875f, 
    0.04928163f, 0.01085986f, -0.24266301f, -0.17419541f, -0.13184670f, 0.20464602f, -0.31559741f, -0.05019338f, 
    0.11755785f, -0.03329720f, -0.22149014f, -0.23251927f, -0.04919161f, 0.10012458f, 0.05019673f, -0.07784480f, 
    0.03643759f, -0.12621206f, -0.10013780f, 0.07158032f, -0.10421826f, 0.03053419f, -0.06438987f, 0.02086998f, 
    -0.00242843f, -0.05867728f, -0.12435170f, -0.13830294f, -0.06997107f, 0.04442905f, 0.02017275f, 0.03056098f, 
    0.04415591f, -0.11594869f, -0.05885614f, -0.18748334f, -0.04958711f, -0.13619240f, 0.01271285f, 0.10949972f, 
    -0.06168815f, -0.44648740f, 0.06004346f, 0.04381498f, 0.00321571f, 0.07326804f, 0.14368543f, -0.12802637f, 
    -0.14129493f, 0.07431421f, -0.11788321f, 0.06128917f, -0.14935079f, 0.05865129f, -0.04038263f, -0.01897085f, 
    -0.01726397f, -0.08194706f, -0.00948086f, -0.02788539f, -0.02342371f, -0.02979722f, 0.06966083f, 0.28462726f, 
    0.02317499f, 0.11872890f, 0.10391435f, 0.21594298f, -0.12366909f, -0.04603892f, 0.01081550f, 0.00031892f, 
    0.07877988f, 0.07382499f, -0.00187516f, 0.10571868f, 0.33743981f, -0.10188724f, -0.00604271f, 0.12665161f, 
    -0.13539946f, -0.03107675f, 0.02641686f, -0.08281834f, -0.00052862f, -0.05914445f, -0.21150777f, -0.06922852f, 
    0.04413478f, 0.06809492f, 0.16463104f, -0.00836876f, -0.01660950f, 0.11096399f, -0.03648604f, 0.02850047f, 
    0.11652923f, 0.03500913f, 0.07732713f, -0.02781536f, -0.07857276f, -0.04476972f, -0.14616080f, 0.02073831f, 
    -0.07782748f, 0.07389624f, -0.01335679f, 0.01532974f, -0.04107077f, -0.02051236f, -0.11914334f, 0.05170117f, 
    0.13531213f, -0.10810884f, 0.10546274f, 0.06786451f, -0.05401992f, 0.09676696f, -0.10322753f, 0.02283770f, 
    -0.08920061f, -0.09812236f, -0.07999405f, -0.27819985f, -0.09188880f, -0.16239633f, -0.31879002f, -0.09847440f, 
    0.03001693f, 0.05547426f, 0.05561223f, 0.02661401f, -0.07237349f, -0.09270090f, -0.00873390f, -0.02066804f, 
    0.12981489f, 0.19824804f, -0.11634506f, 0.07221779f, 0.06601010f, 0.01972292f, -0.09985876f, -0.06271771f, 
    0.09436733f, 0.05358459f, -0.14709929f, 0.05484764f, -0.23518863f, 0.09407969f, 0.10886622f, 0.16374290f, 
    0.02867734f, 0.02396808f, -0.12706943f, -0.11260922f, -0.03175642f, -0.00058818f, -0.00380302f, 0.07097407f, 
    0.14253172f, -0.05665455f, 0.04474358f, -0.03499474f, 0.10248069f, 0.04171332f, -0.00994850f, -0.01940062f, 
    -0.01248728f, -0.08934180f, 0.05538984f, -0.29076621f, 0.01440058f, 0.01918423f, 0.08736756f, -0.04337733f, 
    -0.08897240f, -0.03503591f, -0.08277634f, 0.01114173f, 0.09874791f, -0.01937407f, -0.00215232f, -0.01346569f, 
    0.00355644f, 0.00683345f, 0.23953889f, 0.17978303f, 0.03505416f, 0.02297596f, -0.12850499f, -0.02146192f, 
    0.00742921f, 0.00874412f, 0.04266726f, -0.00359735f, 0.10889213f, -0.13446811f, 0.01602285f, 0.02536974f, 
    0.21484074f, -0.09273297f, -0.05600909f, -0.02337077f, -0.07491394f, 0.09307028f, -0.06770681f, -0.19591089f, 
    0.08660014f, 0.03388694f, 0.06420509f, 0.05323879f, -0.04119592f, -0.01296263f, 0.05488332f, 0.09151470f, 
    0.01694906f, -0.10591123f, -0.05794608f, -0.03228927f, -0.19253251f, -0.01453058f, -0.02033840f, 0.05467575f, 
    -0.13219428f, 0.01121384f, 0.00616114f, 0.01575977f, -0.00361155f, -0.05952419f, -0.03024434f, -0.05066880f, 
    -0.04951388f, -0.05145863f, 0.04643207f, -0.04289186f, -0.09208594f, -0.17735700f, -0.12084464f, 0.14226879f, 
    0.10192918f, 0.01421768f, -0.08735909f, 0.04014454f, 0.03886186f, -0.09151974f, 0.03438349f, 0.15941398f, 
    0.12867369f, -0.16879618f, 0.00930183f, -0.08439697f, -0.00619809f, -0.07803995f, 0.03885587f, 0.16617744f, 
    0.01262668f, 0.00581370f, 0.06813449f, 0.09495050f, 0.09565913f, 0.04427614f, 0.08606569f, 0.04703914f, 
    0.05815878f, 0.00000774f, 0.02281564f, 0.06668070f, 0.04485451f, -0.30163905f, -0.05574295f, -0.03976931f, 
    0.09433481f, 0.03819794f, 0.02048370f, 0.01445594f, 0.05866607f, 0.01222211f, -0.03887029f, -0.02931497f, 
    0.09384470f, -0.13489421f, 0.29684031f, 0.08959570f, -0.27689365f, -0.00190042f, -0.04694160f, 0.15795825f, 
    0.00359177f, 0.02585377f, 0.01164897f, -0.01081181f, 0.02506478f, -0.22061230f, 0.12683623f, 0.23613212f, 
    0.10953633f, -0.07735676f, -0.03198205f, -0.13522153f, -0.07353681f, -0.01656958f, -0.06947222f, 0.00500577f, 
    0.08946393f, 0.21056993f, 0.32276189f, 0.09961639f, -0.13146788f, -0.21417899f, -0.19296971f, 0.04407122f, 
    0.04654714f, 0.00920218f, 0.03818315f, 0.02231491f, -0.27615470f, -0.25680700f, 0.09619306f, -0.30524942f, 
    -0.03430978f, -0.09431205f, -0.02080969f, -0.01300554f, -0.12251625f, -0.20148355f, 0.04317095f, 0.00228465f, 
    0.27300900f, -0.20768550f, 0.00352191f, 0.08404197f, -0.14484663f, -0.04243532f, -0.20839241f, -0.05318064f, 
    -0.11597083f, -0.10018741f, -0.12068579f, 0.08322670f, -0.13824663f, -0.35875431f, 0.13730037f, -0.05637543f, 
    -0.18586841f, 0.03000152f, -0.12470153f, -0.02275784f, 0.09523547f, -0.15449397f, -0.29998320f, 0.04146171f, 
    0.10812712f, -0.26347417f, 0.22462963f, -0.12850550f, -0.11042125f, 0.07354236f, -0.29123157f, -0.03244492f, 
    -0.23380402f, -0.06324259f, -0.01015732f, 0.04458614f, 0.18868855f, -0.19487269f, -0.05237139f, -0.08717640f, 
    0.08627626f, 0.00222592f, 0.05402894f, -0.01530587f, -0.09206953f, 0.10780702f, -0.24501914f, 0.05815754f, 
    0.22087732f, -0.13607377f, -0.05877886f, 0.04135732f, -0.11954407f, -0.27643436f, -0.06023440f, -0.10790706f, 
    0.00466220f, 0.06039813f, 0.03384851f, -0.11901083f, -0.02490353f, -0.02269339f, 0.03242592f, -0.04545817f, 
    -0.03308224f, 0.03859331f, -0.00183192f, 0.06007259f, -0.06580329f, 0.07459524f, 0.12589736f, 0.15150793f, 
    0.03352528f, -0.02174222f, -0.09650258f, 0.00599771f, 0.02902970f, 0.01947925f, 0.00321637f, -0.09892942f, 
    0.12627597f, 0.10289271f, -0.03453211f, 0.17353040f, 0.03359720f, 0.14406207f, 0.19483238f, 0.22102852f, 
    0.00304916f, 0.13871269f, -0.19776721f, 0.24601151f, -0.01039639f, -0.02320499f, -0.07320211f, 0.00158440f, 
    -0.27141577f, -0.08180042f, -0.04232581f, -0.03367179f, -0.23720580f, -0.04299556f, -0.01096519f, 0.09300730f, 
    -0.22604428f, 0.07205531f, -0.10122364f, -0.12486773f, -0.00133884f, 0.16575918f, 0.01899729f, 0.17241123f, 
    -0.00687576f, -0.04943766f, -0.02171833f, 0.03822929f, 0.01136488f, -0.02806967f, 0.01489345f, -0.00716759f, 
    0.08848115f, -0.15526089f, -0.03353845f, -0.08683457f, 0.05620397f, -0.04749571f, 0.00850922f, -0.04214032f, 
    0.18872049f, -0.03291672f, -0.05178908f, 0.22174628f, -0.02129301f, 0.16469444f, -0.01607395f, 0.16935658f, 
    -0.11279721f, -0.05714251f, -0.02882128f, -0.11233050f, -0.01278496f, 0.02248086f, -0.10191054f, 0.09559213f, 
    -0.00102707f, -0.05233128f, -0.07126345f, -0.07465358f, 0.00604230f, -0.00393705f, 0.00089651f, -0.05994957f, 
    0.08238562f, 0.22037625f, 0.12948436f, 0.26143968f, 0.11279396f, 0.00412196f, -0.00789941f, -0.07776481f, 
    -0.16565616f, -0.04457641f, -0.17236029f, 0.06410386f, 0.03449261f, -0.11446662f, -0.03992969f, -0.04767989f, 
    0.07190435f, 0.18559255f, 0.15126331f, -0.08595667f, 0.26741543f, 0.03527134f, 0.11371712f, 0.17991543f, 
    -0.00440964f, -0.04896763f, 0.01834032f, -0.09834754f, 0.00298933f, 0.17536323f, 0.02308105f, 0.14079054f, 
    -0.05209319f, -0.05577653f, -0.00189719f, -0.13174736f, -0.04786650f, -0.02295236f, 0.04961375f, 0.07812095f, 
    0.05637351f, 0.03253359f, -0.25445968f, 0.09350058f, 0.00143877f, -0.07195822f, 0.11410959f, -0.00940989f, 
    -0.09366685f, -0.19931898f, -0.07572193f, -0.03845010f, -0.06924391f, -0.00506446f, -0.30278248f, -0.22311096f, 
    0.10960917f, -0.01011432f, 0.01666717f, 0.08535422f, -0.02842620f, 0.07057549f, -0.02162041f, -0.16715173f, 
    -0.05379296f, -0.03501311f, 0.03140649f, 0.05991649f, -0.07059623f, -0.00108604f, 0.04990353f, -0.08248634f, 
    0.03176973f, -0.01923917f, 0.08452939f, -0.07706042f, 0.08260106f, 0.08658815f, 0.01808473f, 0.04254519f, 
    -0.05767107f, 0.10424719f, 0.01586559f, 0.06284197f, 0.10955252f, -0.08598530f, 0.07489139f, -0.11407688f, 
    0.17645660f, -0.55702263f, 0.03485729f, -0.07438354f, -0.01966573f, 0.14458360f, 0.02186760f, 0.09634592f, 
    -0.19433358f, 0.06808266f, -0.00332084f, -0.05584387f, 0.04651468f, -0.11275057f, 0.03878276f, 0.08692060f, 
    0.00966792f, -0.04124461f, -0.06689008f, 0.03814319f, -0.02585847f, 0.06637460f, -0.11762632f, 0.18920782f, 
    0.14548792f, -0.01324866f, -0.10843134f, 0.20532221f, -0.06638529f, -0.11113168f, -0.00856624f, -0.19918491f, 
    0.11893810f, -0.19660300f, 0.19153264f, 0.19874568f, -0.00017314f, 0.15406878f, 0.01279064f, -0.07454701f, 
    0.02256367f, 0.07613220f, 0.06077019f, -0.05311047f, -0.03288782f, -0.05092110f, 0.00334144f, -0.00582899f, 
    0.46633342f, -0.01034047f, -0.21353382f, -0.05185893f, 0.06440891f, 0.23541497f, -0.19179261f, 0.10619868f, 
    0.03395836f, -0.02941370f, 0.05052787f, -0.16750093f, 0.26178172f, -0.03719975f, -0.32569700f, 0.31371924f, 
    0.02954152f, -0.05443726f, -0.04057070f, 0.04709798f, -0.03679338f, -0.02890386f, 0.06898660f, 0.10088083f, 
    -0.04440595f, -0.02840602f, -0.33030596f, -0.17851694f, -0.00677805f, 0.07878522f, -0.06284790f, -0.03645546f, 
    0.14968127f, -0.08020196f, 0.11340004f, -0.09080158f, 0.16456640f, -0.18072954f, -0.14270061f, -0.05446775f, 
    0.03332812f, -0.04765428f, 0.00080115f, 0.13104160f, -0.01319880f, -0.05392269f, 0.05586665f, -0.06531063f, 
    -0.08087343f, -0.48545572f, 0.22327557f, 0.38939798f, -0.09308951f, -0.00299315f, -0.10797662f, -0.06292929f, 
    0.04079796f, -0.15639526f, -0.02032080f, 0.02198019f, 0.20508695f, 0.04856971f, 0.14443178f, -0.01895540f, 
    0.04823425f, 0.01300139f, -0.02696192f, -0.12861638f, -0.17909499f, -0.14646375f, -0.00561772f, -0.00065365f, 
    -0.03316809f, -0.09724807f, -0.11970849f, 0.15891951f, -0.01894095f, 0.02342646f, 0.01195922f, -0.13864878f, 
    0.02558479f, -0.09738787f, 0.07275514f, -0.27610037f, -0.00169559f, -0.10650601f, -0.05594184f, -0.20651387f, 
    0.13424841f, 0.00852366f, -0.03033814f, 0.17784068f, -0.10618502f, 0.02049726f, 0.02304530f, -0.15191925f, 
    -0.11529793f, -0.11842469f, 0.00264608f, -0.03426051f, -0.31615797f, 0.00827794f, -0.10979602f, 0.00093831f, 
    0.09384329f, 0.02830432f, 0.08117291f, 0.12215801f, -0.06006854f, 0.14310871f, 0.02091271f, -0.22341095f, 
    -0.18265435f, -0.14104897f, -0.07463922f, -0.22752762f, -0.10207143f, -0.15323280f, 0.01260349f, -0.05665125f, 
    0.04118374f, 0.01144056f, 0.07765200f, -0.06631249f, -0.04177973f, 0.16854116f, 0.07068663f, 0.09870859f, 
    0.10630932f, -0.04123642f, -0.02521857f, 0.14302565f, 0.02107531f, -0.12154256f, 0.18528147f, -0.01173611f, 
    0.25294745f, -0.05087776f, 0.09036630f, -0.01713530f, 0.09174470f, -0.01462298f, 0.10093846f, -0.04807631f, 
    -0.00379882f, 0.03934165f, -0.34972361f, -0.21665460f, -0.01253757f, 0.04544465f, -0.01264811f, 0.10559919f, 
    0.07112721f, -0.14955881f, 0.09044296f, 0.06643181f, -0.11598394f, -0.00188553f, -0.57569808f, 0.11455018f, 
    0.06714520f, -0.04384581f, -0.00274357f, 0.15693258f, 0.11557273f, -0.23403253f, 0.01439126f, -0.02467125f, 
    -0.49528867f, -0.20688768f, 0.05096983f, -0.12334400f, -0.02901212f, 0.01094517f, 0.05263680f, -0.00572742f, 
    0.13498199f, 0.01085840f, -0.09783337f, 0.16058756f, -0.00193525f, -0.11151443f, -0.17654911f, -0.19629398f, 
    -0.10332122f, 0.16455862f, -0.25427249f, -0.08516172f, 0.12125129f, -0.05089926f, 0.16159271f, -0.17491560f, 
    -0.49182764f, -0.00511570f, 0.01782701f, -0.18196394f, -0.01710025f, -0.18195063f, -0.12692571f, 0.12105452f, 
    -0.18389827f, -0.03978985f, -0.08010135f, -0.13799819f, 0.17048348f, -0.16129886f, -0.22328261f, -0.07651986f, 
    0.02106925f, 0.01357477f, 0.00207995f, 0.11661523f, 0.06263709f, -0.07150507f, -0.03829225f, -0.30631232f, 
    0.09948060f, -0.00231722f, 0.06806778f, -0.02041186f, 0.06574876f, 0.02335334f, -0.15775238f, -0.09799358f, 
    -0.03049562f, -0.06995153f, -0.06114662f, -0.06907215f, -0.21474274f, -0.02513447f, -0.24762513f, -0.00361636f, 
    0.07190545f, -0.00720779f, -0.08994631f, 0.00497512f, 0.26415116f, 0.15978168f, -0.00137208f, -0.17911267f, 
    0.15614888f, 0.06897765f, 0.05142869f, -0.08233389f, -0.00837430f, -0.06814758f, 0.01722489f, -0.18159808f, 
    -0.23075509f, 0.05341557f, -0.04954033f, -0.08905059f, 0.27475321f, -0.13802813f, 0.23895073f, -0.17084973f, 
    -0.23660590f, -0.07962096f, 0.08395880f, 0.05469869f, 0.04892543f, 0.03131497f, 0.07734131f, 0.09722403f, 
    -0.19091922f, 0.03568109f, 0.14121470f, -0.15590394f, -0.02120410f, 0.03372480f, -0.00829944f, -0.09208291f, 
    0.06286590f, -0.10313004f, 0.20879963f, 0.17994563f, -0.14037272f, -0.00005941f, 0.04504233f, -0.20675169f, 
    -0.03751790f, -0.00254188f, 0.03119477f, -0.00777229f, 0.14864293f, -0.13954194f, 0.13163753f, 0.07907241f, 
    -0.03902916f, -0.21179304f, -0.03706718f, 0.10866399f, 0.04227666f, 0.13094911f, 0.08230335f, 0.08281080f, 
    -0.04176106f, 0.11721402f, -0.00404213f, -0.17154539f, -0.35286486f, 0.12079240f, -0.24703704f, -0.38827851f, 
    -0.12439582f, 0.00187386f, -0.02950298f, 0.07551854f, -0.00104651f, -0.01535313f, -0.00311685f, -0.08601522f, 
    -0.01055095f, -0.02147461f, 0.01554374f, 0.01672182f, -0.01303399f, 0.03781200f, -0.01033489f, -0.04372593f, 
    -0.00989458f, 0.01511724f, 0.02762539f, 0.15832858f, 0.04387658f, -0.00861912f, -0.13927487f, -0.15466158f, 
    0.19451542f, 0.10197888f, -0.08587301f, 0.02006458f, 0.05985091f, 0.09920888f, 0.01374642f, 0.00629361f, 
    0.03685343f, -0.00228201f, -0.08333401f, -0.00439763f, -0.17044744f, 0.01514301f, 0.00304446f, -0.25877845f, 
    0.14201117f, 0.01519685f, 0.09862094f, -0.01561185f, 0.10549857f, 0.02824440f, 0.05192306f, -0.05961742f, 
    -0.19265312f, 0.21713009f, 0.04686145f, -0.00964298f, -0.01006059f, -0.00540446f, -0.00544299f, 0.16627839f, 
    -0.40593988f, -0.28187796f, -0.16800000f, -0.05205435f, 0.02341335f, -0.03580714f, -0.05541874f, -0.01575132f, 
    -0.04262125f, -0.08905872f, 0.18078096f, 0.11283998f, -0.12526944f, -0.03689831f, 0.20210592f, -0.03164643f, 
    0.11974349f, -0.04778417f, 0.10416858f, 0.26243025f, -0.02953877f, -0.07314214f, 0.06292123f, 0.04101061f, 
    0.06454809f, 0.05424766f, 0.05261844f, 0.01726752f, -0.26337588f, -0.01751245f, 0.18371975f, -0.07541648f, 
    -0.02514407f, 0.11946546f, -0.00139860f, 0.01098536f, -0.12466165f, 0.30105919f, 0.20690583f, -0.11346804f, 
    -0.20393287f, 0.01899111f, 0.15274377f, -0.00379773f, 0.09398468f, -0.02657711f, 0.00101634f, -0.02644036f, 
    -0.18929754f, -0.15058906f, -0.05121277f, 0.07235150f, 0.03233291f, -0.03250296f, -0.08973451f, 0.06914746f, 
    -0.03196759f, -0.06768206f, 0.10854334f, -0.08862606f, 0.12215606f, -0.17591782f, -0.08585068f, 0.01714001f, 
    -0.00413217f, 0.10648206f, -0.03137350f, -0.04970809f, -0.00136090f, -0.07321932f, -0.00895905f, -0.03229668f, 
    -0.00255278f, -0.25299701f, 0.30945852f, -0.08457957f, 0.27618104f, -0.00549136f, 0.10461219f, 0.08814684f, 
    0.16011731f, 0.06924782f, -0.04367666f, 0.04284903f, -0.17494802f, 0.12612012f, 0.21191573f, 0.13134779f, 
    -0.05205220f, 0.02563920f, 0.17713685f, 0.25319019f, 0.06806952f, 0.08097603f, 0.00377630f, -0.03350549f, 
    0.08114637f, 0.08701295f, 0.01875883f, -0.17763205f, 0.23381251f, 0.19648309f, 0.13725244f, 0.00908681f, 
    -0.07600919f, -0.02299984f, 0.07299060f, 0.04109341f, 0.40739903f, -0.01134256f, -0.06526088f, 0.28596461f, 
    0.01800283f, -0.08809561f, 0.06272957f, 0.13260624f, 0.20169850f, -0.07256277f, 0.13698192f, 0.09591918f, 
    0.00872772f, 0.12817776f, 0.22368525f, -0.40782794f, 0.10645258f, -0.06989373f, 0.12387080f, 0.00528628f, 
    0.10735413f, 0.12192110f, -0.07387988f, -0.06101569f, 0.00961428f, 0.12911266f, 0.03785255f, -0.39803830f, 
    0.02229821f, -0.00895067f, 0.00019518f, 0.06384502f, 0.02582821f, 0.16102156f, 0.09361535f, -0.04325034f, 
    0.19202629f, 0.07156681f, 0.26279610f, -0.07873345f, -0.07231252f, 0.01830683f, -0.11032146f, -0.06956867f, 
    0.05040092f, 0.07330821f, -0.03920327f, 0.18112202f, -0.40242141f, -0.10277364f, -0.23022251f, 0.10552170f, 
    -0.01180958f, -0.02019870f, -0.01391381f, 0.02271795f, 0.07134553f, -0.15639859f, -0.19035532f, 0.16428341f, 
    -0.38814831f, 0.15605597f, -0.13819432f, -0.08148889f, 0.04567756f, -0.05947548f, 0.13522589f, 0.23763275f, 
    0.11497991f, -0.04159842f, -0.00136392f, 0.04861011f, 0.27453983f, -0.09115017f, 0.41006723f, -0.07880134f, 
    0.06141875f, -0.02286491f, 0.05600546f, 0.05873446f, 0.07127492f, -0.23924024f, -0.22057271f, -0.04830007f, 
    -0.00490313f, -0.03463881f, -0.04066947f, -0.08302368f, -0.01675965f, 0.01042434f, 0.03126485f, 0.04943595f, 
    -0.19849314f, -0.16977920f, -0.13612001f, -0.20337628f, 0.21306323f, -0.01626034f, -0.21455252f, 0.09847918f, 
    -0.00525629f, 0.22179233f, 0.14551577f, -0.05617919f, 0.01005958f, 0.04710835f, 0.05260258f, 0.04611781f, 
    0.85862076f, -0.60972303f, 0.10072517f, 0.12411260f, 0.20360167f, 0.01112295f, -0.07968574f, 0.09134822f, 
    -0.07922047f, -0.17360994f, 0.03350126f, 0.10651430f, 0.20189832f, 0.11380176f, 0.11221963f, 0.10369438f, 
    0.27895045f, 0.08658310f, 0.01412263f, 0.04745342f, 0.11795835f, 0.02461956f, 0.05988496f, 0.04081127f, 
    0.22805896f, -0.11829068f, -0.32100031f, -0.01850496f, 0.03573181f, 0.06510835f, 0.04920251f, 0.07192855f, 
    -0.05319701f, -0.30687413f, -0.14084849f, -0.42527315f, -0.41257215f, -0.12296453f, 0.17625871f, -0.00426248f, 
    -0.06326053f, 0.00785250f, 0.00943839f, 0.12015742f, 0.08194762f, 0.02535873f, 0.10506134f, -0.04491989f, 
    0.00315762f, -0.22204703f, -0.04122920f, -0.00297096f, 0.00581993f, -0.01688071f, 0.01775205f, -0.00476917f, 
    -0.21030480f, -0.46506590f, -0.37230110f, -0.34857848f, -0.01603334f, -0.21396580f, 0.03832220f, 0.09196525f, 
    -0.00995917f, -0.00216723f, -0.07401011f, -0.07257099f, 0.13947067f, 0.19093080f, -0.00736298f, 0.17209329f, 
    -0.08487655f, 0.15909860f, -0.29517981f, -0.16607660f, 0.03295477f, 0.03508072f, 0.05273118f, 0.08099565f, 
    -0.04401608f, -0.01278726f, 0.09800592f, -0.07018489f, -0.25482184f, -0.11837330f, 0.00175421f, -0.37219840f, 
    0.05616034f, 0.07584674f, -0.02793609f, 0.02880399f, 0.05723565f, -0.03920992f, -0.17059465f, -0.01841603f, 
    -0.21483733f, 0.11823832f, -0.18389456f, -0.09547060f, -0.05991974f, -0.05462963f, -0.01899408f, 0.13246091f, 
    0.14336656f, -0.01887734f, 0.25860822f, 0.15173972f, -0.20336112f, -0.06652734f, -0.45895711f, 0.05077217f, 
    0.08235810f, -0.04278393f, -0.05858450f, -0.02751307f, 0.14022547f, -0.04579983f, -0.02449159f, 0.22164035f, 
    -0.15379186f, 0.11113575f, -0.03948775f, -0.13166609f, 0.12752688f, -0.14010005f, -0.07219122f, 0.07711361f, 
    -0.05658907f, -0.06307460f, 0.12198839f, 0.11408142f, -0.03669417f, -0.01292125f, -0.18679632f, 0.06527252f, 
    0.06726772f, -0.18962808f, 0.06037560f, 0.28395194f, -0.15314931f, -0.19066364f, 0.03284318f, 0.04992663f, 
    -0.00459284f, -0.13441929f, 0.08199838f, 0.05323517f, -0.15816906f, -0.23951852f, -0.17426546f, 0.02084960f, 
    0.03937260f, -0.02336297f, -0.07887625f, 0.02585431f, -0.23321374f, 0.27040529f, -0.02967911f, -0.06666394f, 
    0.04421017f, 0.02226244f, 0.03504527f, 0.08575591f, 0.50755596f, 0.01980333f, -0.14715621f, -0.20321843f, 
    0.03072349f, -0.08403467f, -0.05965491f, 0.06547265f, 0.06428284f, 0.04465951f, 0.03159293f, -0.01849671f, 
    0.08648046f, 0.00293920f, 0.12149734f, -0.28447673f, -0.02428450f, -0.04569966f, -0.02123069f, -0.25241145f, 
    0.25783885f, 0.01368427f, -0.08921359f, 0.20179814f, 0.07040137f, -0.03823107f, 0.03689170f, -0.00858215f, 
    0.48912647f, -0.00442315f, -0.50902539f, -0.28098711f, -0.13181598f, -0.00557491f, 0.16214813f, 0.27631852f, 
    0.03732679f, 0.18887433f, -0.13904041f, -0.09983294f, 0.29849467f, -0.02271293f, -0.24533141f, -0.17419399f, 
    -0.04917306f, 0.00215159f, 0.11302504f, 0.01931895f, 0.00042684f, 0.12509039f, -0.04149986f, -0.16384101f, 
    0.24798225f, 0.13889551f, -0.05627939f, 0.06212519f, 0.10841272f, -0.02141307f, 0.00718185f, 0.04814469f, 
    0.13026519f, 0.03083344f, -0.04228938f, -0.08139107f, -0.17820437f, 0.53143293f, 0.12946789f, 0.05044630f, 
    -0.14959067f, 0.00916619f, -0.06178556f, 0.08917633f, 0.04618681f, -0.05793711f, -0.01627462f, 0.11886863f, 
    -0.12898034f, -0.02787519f, -0.07913788f, 0.25353688f, 0.00273000f, 0.09035512f, -0.04316942f, 0.10316519f, 
    -0.01514189f, -0.06983203f, -0.02171593f, 0.08988956f, -0.55543017f, -0.43176380f, 0.07791644f, -0.15311852f, 
    -0.06754319f, -0.01430673f, -0.08867186f, -0.19339943f, -0.01102070f, -0.08652670f, 0.03424207f, 0.07195250f, 
    0.00656188f, -0.00881875f, -0.12344877f, -0.12730742f, -0.03173332f, 0.06168782f, 0.00219977f, 0.12530585f, 
    -0.07273406f, 0.02098880f, -0.00782126f, -0.05297498f, 0.06183366f, 0.00648980f, -0.14025655f, 0.05754295f, 
    0.09119508f, 0.05585434f, 0.17084804f, -0.12764284f, 0.06436507f, -0.01786346f, -0.03038598f, -0.01215050f, 
    -0.07448046f, -0.08849934f, -0.02249685f, 0.09010447f, -0.16085167f, -0.14590333f, -0.06115783f, -0.03496532f, 
    0.02061789f, 0.04938059f, -0.02000753f, -0.17528294f, -0.24101222f, -0.25711641f, 0.15870626f, 0.09406256f, 
    0.09051509f, 0.07806311f, 0.09907804f, -0.14472461f, -0.05924601f, 0.04503556f, 0.05713062f, 0.01723794f, 
    -0.08578721f, -0.20292865f, -0.00508583f, -0.16233346f, -0.07425801f, -0.24659176f, 0.14425763f, 0.06865209f, 
    -0.00559794f, -0.06420911f, 0.01205633f, -0.12475992f, -0.22546931f, 0.06484658f, -0.14457670f, 0.15211737f, 
    -0.01386144f, 0.10097281f, -0.07127084f, 0.06156310f, 0.03976261f, -0.04795887f, 0.03180651f, -0.10546453f, 
    0.07094408f, 0.11437637f, 0.11307188f, -0.08377991f, 0.06384425f, -0.02699325f, 0.04173381f, -0.05196155f, 
    -0.03076864f, 0.07002638f, -0.12236387f, 0.18633366f, 0.51132512f, 0.04379154f, 0.17429985f, -0.18248670f, 
    0.02883990f, -0.10074206f, 0.20764734f, -0.05377913f, 0.07820317f, -0.05182414f, -0.06934026f, 0.15370105f, 
    -0.37786493f, 0.09192991f, 0.27852923f, 0.05626104f, -0.08957805f, -0.12265556f, 0.03804282f, 0.03096259f, 
    -0.02910480f, 0.09836037f, 0.13245875f, 0.01825990f, 0.04513418f, 0.34186399f, -0.07289006f, 0.09976323f, 
    -0.10516470f, -0.06445229f, -0.14342661f, -0.09783939f, -0.07308506f, -0.11804207f, -0.13406903f, 0.04346585f, 
    -0.11580294f, -0.00570298f, 0.00734028f, 0.12996095f, 0.06032842f, 0.02838985f, -0.01438559f, -0.13711773f, 
    -0.08826146f, 0.14888771f, 0.08254847f, 0.02445814f, 0.24488090f, 0.21812248f, -0.09992500f, 0.18869548f, 
    -0.06329703f, 0.00486857f, -0.03279647f, 0.05529570f, 0.01230177f, -0.00482111f, 0.07623464f, 0.02814883f, 
    -0.29686120f, -0.25343800f, -0.22774713f, -0.12890002f, -0.25480437f, 0.05478409f, 0.06958243f, -0.25675538f, 
    0.05195453f, -0.00825791f, 0.03769329f, 0.05448283f, -0.35549551f, 0.14549591f, 0.34890732f, -0.27698827f, 
    -0.02430106f, -0.04427120f, -0.10516016f, -0.04359381f, 0.02042058f, 0.06078732f, -0.00012085f, 0.20023942f, 
    0.30129841f, 0.25404027f, -0.22351305f, -0.08420669f, -0.01058264f, -0.05655378f, -0.12130844f, 0.14132521f, 
    0.02044542f, -0.07715443f, 0.00041873f, 0.00307512f, 0.08638659f, -0.05340189f, -0.32163006f, 0.06766387f, 
    -0.11988190f, -0.00705294f, 0.06707728f, 0.15896691f, 0.02560352f, 0.09606971f, -0.29852203f, -0.02226615f, 
    -0.27988717f, -0.10627966f, 0.13295339f, -0.08628540f, 0.00669274f, -0.09953404f, -0.03893101f, 0.03791475f, 
    0.00441343f, 0.04138992f, 0.03410207f, -0.07750846f, 0.08790168f, -0.15765554f, 0.07462586f, 0.02515266f, 
    0.04661277f, -0.02287039f, -0.05133766f, 0.05817032f, 0.00238360f, -0.03858471f, -0.06408659f, -0.02934135f, 
    0.02165063f, -0.05838043f, -0.02729517f, 0.03538197f, -0.04577842f, 0.10700604f, 0.16618177f, -0.12668537f, 
    0.05226567f, -0.04246832f, 0.03376404f, -0.05644828f, -0.85079497f, -0.14761068f, 0.34242374f, 0.12873781f, 
    0.00984841f, -0.06532309f, 0.08284421f, -0.13125305f, 0.00610006f, 0.06193416f, 0.10341524f, -0.06848711f, 
    -0.06311786f, 0.03315153f, 0.13554108f, -0.09024883f, 0.13229539f, -0.00078059f, 0.01780135f, -0.03195849f, 
    -0.05053264f, -0.09659877f, -0.00812050f, -0.06442629f, -0.39468852f, -0.10435615f, -0.27605295f, -0.29195970f, 
    -0.06410781f, -0.27790904f, -0.26761541f, -0.06224292f, -0.01253281f, -0.05309591f, -0.04885677f, 0.01678065f, 
    -0.64723772f, -0.55002332f, -0.06307624f, -0.10812429f, -0.16478732f, -0.25796261f, -0.10033715f, -0.07580877f, 
    -0.08507618f, -0.03941523f, 0.09808929f, -0.10090373f, -0.06329884f, -0.09242510f, 0.10705261f, 0.07747610f, 
    0.03504528f, 0.02355227f, 0.00692934f, -0.21956435f, 0.02486351f, -0.03126447f, 0.05927308f, -0.03084567f, 
    -0.27143884f, 0.20955423f, 0.27911362f, 0.03805662f, -0.00828199f, -0.03489325f, -0.01587750f, 0.03444094f, 
    -0.09882543f, 0.10623480f, -0.04735598f, 0.07357380f, -0.53509349f, -0.71589226f, -0.27958873f, 0.21420699f, 
    -0.09528863f, 0.05864853f, -0.09069683f, 0.09873128f, -0.00057325f, 0.00077362f, 0.04084065f, -0.02658470f, 
    -0.20305257f, 0.08073204f, -0.02190254f, -0.06527574f, -0.16956925f, -0.13350502f, -0.21163550f, -0.00717321f, 
    -0.03313181f, -0.09836493f, -0.03684768f, -0.09370581f, -0.35205826f, -0.50442165f, -0.28363997f, 0.06393750f, 
    0.06859890f, -0.06444184f, -0.06532692f, -0.24585474f, -0.05831264f, -0.05453897f, 0.08747853f, 0.03287542f, 
    -0.11641115f, -0.03458699f, -0.12876230f, -0.02939821f, 0.02902851f, 0.01328637f, 0.01818124f, -0.00855917f, 
    -0.07256316f, -0.10595331f, -0.03468153f, -0.03673362f, -0.04176805f, 0.08354308f, 0.01019233f, -0.13647212f, 
    -0.01324751f, 0.07108866f, -0.02310037f, -0.12362839f, 0.02198817f, -0.02533449f, 0.05087082f, -0.02494647f, 
    -0.13116303f, -0.33219483f, -0.26275569f, 0.13632511f, -0.00433707f, -0.00912371f, 0.02374119f, 0.09026127f, 
    0.03773011f, -0.05012480f, 0.02973465f, -0.06455244f, -0.19415076f, -0.36127874f, 0.12905298f, 0.33967856f, 
    0.11157490f, 0.16852248f, -0.08389394f, -0.22933199f, -0.05296150f, -0.00595741f, 0.10810238f, 0.01772523f, 
    -0.50382739f, -0.39262372f, -0.30135590f, -0.21765946f, -0.28511128f, -0.13797131f, -0.36063582f, -0.23368268f, 
    0.06957576f, -0.00504376f, -0.00611063f, -0.01494742f, -0.27141160f, 0.14392947f, 0.00877794f, -0.02204306f, 
    -0.02548061f, 0.07687413f, 0.03489855f, 0.07282848f, 0.11429485f, 0.10437641f, 0.03871882f, 0.32972559f, 
    -0.16117139f, 0.39319316f, 0.03302218f, 0.27247569f, 0.13051911f, -0.01504774f, -0.03929313f, 0.00728925f, 
    0.06102710f, 0.12577012f, 0.01206837f, -0.07676320f, -0.19186336f, 0.06488949f, 0.10384828f, -0.07981813f, 
    0.03157171f, 0.04414624f, 0.02384906f, 0.00900793f, -0.02035537f, 0.05475380f, 0.11646003f, 0.01896676f, 
    -0.05252370f, -0.36190939f, -0.16659805f, 0.23979755f, 0.03656947f, -0.14983775f, -0.00462192f, -0.08611964f, 
    -0.01136825f, 0.04219740f, 0.00193597f, 0.12534152f, -0.02888161f, 0.03297950f, -0.04042909f, 0.00039930f, 
    0.02562588f, 0.02026834f, 0.00208936f, -0.10873580f, 0.10428203f, -0.14612706f, 0.16649242f, 0.02538822f, 
    -0.05448690f, -0.11726368f, 0.16077411f, -0.01106059f, -0.07542878f, 0.08128067f, 0.15723974f, -0.17159663f, 
    -0.03502673f, 0.04008983f, -0.15598376f, 0.04118873f, -0.00365389f, -0.09438451f, -0.33143595f, -0.36185083f, 
    -0.03278784f, -0.05109931f, -0.00881298f, 0.06535663f, -0.10371991f, 0.19080830f, 0.03522388f, 0.18821433f, 
    -0.00999773f, -0.01775567f, 0.06451928f, 0.11570411f, 0.01491524f, 0.08983546f, 0.04337071f, -0.04335686f, 
    0.01408104f, 0.20721987f, 0.06112890f, -0.02937730f, 0.10161860f, -0.52472550f, -0.26040933f, -0.27979192f, 
    0.08654745f, -0.09918026f, 0.13432731f, -0.16258782f, 0.03201817f, -0.01439987f, -0.02381998f, 0.07227274f, 
    0.31157020f, -0.02063644f, -0.23115791f, 0.08701219f, -0.08212628f, 0.08823721f, 0.04913485f, 0.21889807f, 
    -0.07139018f, -0.10400847f, 0.14931290f, 0.12874566f, -0.55355400f, -0.65254503f, -0.41753125f, -0.60301220f, 
    -0.06715505f, -0.06285688f, -0.10058486f, -0.31986660f, -0.01254805f, -0.04932417f, -0.04354158f, -0.00673752f, 
    0.09689281f, 0.14366800f, -0.08155224f, -0.00845905f, 0.00064762f, -0.02070718f, 0.03807437f, -0.02512404f, 
    0.10097962f, 0.19814518f, 0.18741354f, 0.08842205f, -0.38093123f, 0.05184969f, 0.36756140f, 0.22743747f, 
    -0.09026283f, 0.05761134f, -0.01287364f, -0.00865408f, 0.00547844f, 0.11923168f, 0.12879489f, 0.09644555f, 
    -0.00966421f, -0.01287459f, -0.10202877f, -0.01081032f, -0.04319096f, 0.02680638f, -0.02301659f, 0.09062503f, 
    0.23311768f, 0.16754824f, 0.15538302f, 0.00632742f, -0.06620388f, 0.14930147f, 0.03734933f, 0.23644353f, 
    -0.10513268f, -0.17278378f, 0.00411796f, 0.08392718f, 0.00767178f, 0.01569572f, -0.07645408f, 0.03945758f, 
    -0.20634080f, -0.38864982f, 0.30856946f, -0.21159808f, -0.04322975f, -0.09172902f, 0.14450999f, -0.28448623f, 
    0.01292111f, -0.00922907f, 0.02977762f, 0.05529011f, -0.36496177f, -0.27987587f, 0.23151928f, 0.10681356f, 
    0.05563342f, -0.16121776f, 0.04705535f, -0.10049382f, -0.10672662f, 0.10279728f, 0.04525064f, 0.00292438f, 
    0.18302007f, -0.08312303f, 0.04038559f, 0.23386787f, 0.03944984f, 0.00279335f, 0.18923202f, 0.03460629f, 
    0.00453484f, 0.10065417f, 0.03100319f, 0.02416120f, -0.07853459f, 0.10403881f, -0.01858100f, -0.09199582f, 
    0.02382670f, -0.00540704f, 0.04886459f, -0.06264272f, -0.01254570f, -0.00819578f, -0.01530705f, -0.01435768f, 
    -0.50903922f, -0.14605758f, -0.01177839f, 0.00590788f, -0.08502814f, -0.08447298f, 0.09140574f, -0.06528451f, 
    0.01456752f, 0.05701215f, 0.04222329f, -0.01174817f, -0.01676636f, 0.09432071f, 0.15554011f, 0.13940828f, 
    -0.11267855f, -0.07112897f, 0.18403621f, 0.32658604f, 0.10404089f, 0.15046106f, -0.09055152f, -0.19319634f, 
    -0.15618590f, -0.16592489f, 0.01279332f, 0.15484977f, 0.00794347f, 0.14142962f, -0.03506988f, 0.03243057f, 
    -0.02624651f, 0.01063413f, 0.00334599f, 0.11092430f, -0.03154545f, -0.11006617f, 0.10083148f, 0.07325665f, 
    -0.01815552f, 0.02713121f, 0.10313924f, -0.02922275f, 0.07645381f, -0.01464077f, 0.11478904f, -0.01119610f, 
    0.07115462f, 0.03506092f, -0.20772199f, -0.05021910f, -0.05036446f, 0.05949955f, 0.04160971f, 0.09056341f, 
    -0.07393552f, 0.13191034f, 0.07204627f, 0.00463618f, 0.29724088f, -0.02348334f, 0.16604325f, -0.41344243f, 
    -0.08641802f, -0.03659305f, -0.00739046f, -0.08837277f, 0.02809696f, 0.00981830f, 0.03461474f, -0.08471465f, 
    -0.31364623f, -0.17267063f, 0.02086104f, -0.07743495f, -0.08222676f, 0.01444085f, -0.02557445f, -0.02305218f, 
    0.09012972f, -0.03985159f, 0.07522667f, 0.03454381f, -0.13398460f, -0.04320391f, 0.03342395f, 0.00140338f, 
    0.02146130f, 0.07909884f, -0.08583158f, -0.04732852f, 0.03129270f, -0.04106968f, 0.00954586f, 0.03874630f, 
    0.01257445f, -0.03595311f, 0.04749156f, -0.01827590f, -0.03791294f, 0.01592187f, -0.04521988f, -0.05955178f, 
    0.12003078f, 0.07564368f, -0.01984880f, -0.02692726f, -0.04406733f, -0.54368687f, -0.31816483f, -0.15460585f, 
    -0.01350835f, -0.03245938f, 0.02991411f, -0.02197831f, -0.05207708f, -0.01620672f, 0.01903387f, 0.02249047f, 
    0.08935043f, 0.01529520f, -0.06558240f, -0.16563457f, -0.04058994f, -0.00639071f, 0.01811804f, -0.03421905f, 
    -0.00943232f, 0.06752589f, 0.00926490f, -0.09869003f, -0.20671895f, -0.28897962f, 0.17726780f, 0.32842097f, 
    0.16942666f, 0.13838814f, 0.13899466f, 0.05852986f, 0.07638620f, 0.00278299f, -0.00649222f, -0.01147719f, 
    0.07263137f, 0.07269534f, 0.02916161f, -0.01295909f, 0.01695215f, -0.05537474f, -0.00341923f, -0.01959807f, 
    -0.02077752f, -0.05626222f, 0.03040859f, 0.04850694f, -0.07522611f, 0.02753770f, 0.09207252f, 0.01908269f, 
    0.02578770f, -0.09115861f, -0.01711589f, 0.16368531f, 0.04673448f, 0.09076733f, 0.06208218f, 0.02160735f, 
    0.10565458f, 0.00335520f, -0.05441930f, -0.03043086f, -0.07232113f, 0.02128498f, 0.03495191f, 0.08535177f, 
    0.01019359f, -0.00074404f, -0.00786040f, -0.02828639f, 0.15351689f, -0.09468094f, 0.19783378f, -0.27443764f, 
    -0.08073652f, -0.04617413f, -0.08984338f, 0.04335323f, -0.15909809f, 0.01341627f, 0.11311345f, -0.01797152f, 
    -0.05542400f, 0.12985750f, 0.03244772f, 0.15974717f, -0.11038163f, -0.14821836f, 0.01252809f, -0.03438929f, 
    0.03089010f, -0.01309389f, -0.03719820f, 0.00527108f, 0.03691399f, -0.18271935f, 0.18293852f, -0.27183524f, 
    -0.05616716f, -0.07728899f, 0.04436102f, 0.02242920f, 0.00721197f, 0.08512039f, 0.05845993f, -0.04628305f, 
    -0.25655854f, 0.20680623f, 0.05445186f, 0.15241852f, 0.01965251f, -0.04631412f, -0.05268097f, -0.05270040f, 
    -0.13923752f, 0.06734348f, -0.11517326f, -0.08937734f, -0.27422729f, 0.29555118f, -0.06934462f, 0.25752100f, 
    -0.07968390f, 0.05427569f, 0.09658123f, 0.10060132f, -0.08792531f, 0.01203342f, -0.00910901f, -0.12525217f, 
    0.40608317f, -0.05102148f, -0.25264150f, -0.21663076f, -0.03591783f, 0.01743338f, -0.02566968f, -0.05551681f, 
    0.03528951f, 0.03979203f, -0.01471568f, -0.12933902f, -0.11904150f, -0.01708249f, 0.01124626f, 0.10994638f, 
    -0.21267028f, -0.03900618f, 0.11137895f, -0.01281724f, 0.05387646f, -0.07678813f, 0.00973711f, 0.02009024f, 
    0.15878063f, -0.06997912f, -0.06392666f, 0.13215591f, 0.03734003f, -0.05379065f, -0.06141594f, -0.04773170f, 
    -0.12103724f, 0.01484174f, 0.04492427f, 0.01957640f, 0.00522772f, -0.06146621f, -0.09878142f, 0.06588265f, 
    -0.05468559f, 0.00969149f, 0.05903273f, 0.06273849f, 0.04366116f, -0.00597264f, -0.03087427f, 0.00082338f, 
    -0.21509607f, -0.26578677f, -0.19326541f, 0.04777567f, 0.07651524f, 0.15904653f, 0.08696500f, 0.05348399f, 
    0.05664822f, -0.02952512f, -0.00969299f, -0.06671277f, 0.34812695f, 0.00962704f, -0.30106762f, -0.53452116f, 
    0.02438546f, -0.03840871f, -0.06455924f, 0.06167419f, -0.04233281f, 0.12624672f, 0.02061439f, 0.00191003f, 
    -0.30115694f, -0.19604652f, -0.06137188f, 0.13058735f, 0.03744949f, 0.00970928f, -0.00376388f, 0.01513407f, 
    0.01380243f, -0.02554098f, 0.08536402f, -0.00542960f, 0.07873746f, -0.17064565f, 0.25753558f, -0.08953233f, 
    0.05491222f, -0.03578572f, -0.06353865f, -0.04937237f, 0.01304034f, -0.04606910f, -0.04676050f, -0.04420460f, 
    -0.05646934f, -0.03425855f, 0.03532394f, -0.08577637f, -0.01775267f, 0.02597813f, 0.11080749f, 0.00915451f, 
    0.03995791f, -0.01361280f, -0.02394933f, -0.07525872f, 0.13546084f, -0.03730925f, 0.13295904f, -0.35492468f, 
    0.04459395f, -0.01270565f, 0.05183208f, -0.02339666f, 0.04676870f, -0.08462351f, -0.03049446f, -0.37200660f, 
    -0.01070554f, 0.14688069f, 0.00187147f, 0.00841608f, -0.05166676f, -0.05644920f, -0.01723497f, 0.01710937f, 
    0.00891436f, 0.01465728f, 0.00381423f, 0.07578841f, -0.31929088f, -0.45929578f, -0.18333812f, -0.10024542f, 
    0.04649498f, 0.02233934f, 0.07987376f, 0.13136835f, 0.09292757f, -0.00818528f, 0.02947649f, -0.02872538f, 
    0.03091417f, 0.03534236f, -0.04470063f, -0.06878013f, 0.02491561f, 0.04539392f, -0.04161086f, -0.00575193f, 
    -0.03543185f, -0.07736705f, -0.08159430f, -0.07064592f, -0.31020665f, 0.07153793f, -0.30213928f, 0.09544794f, 
    0.12078953f, -0.02197458f, 0.20447376f, 0.01751919f, 0.02002998f, 0.01294995f, 0.01049390f, 0.08094464f, 
    -0.18116035f, -0.32454821f, -0.42458135f, 0.12078960f, 0.00623876f, -0.11397903f, -0.07051642f, -0.04931378f, 
    -0.00419943f, 0.01471108f, 0.01663762f, 0.04586350f, 0.07266882f, 0.04990782f, -0.00321389f, -0.06039353f, 
    -0.07081164f, 0.02073801f, -0.04233633f, 0.01238130f, -0.04855896f, 0.02531663f, -0.04032236f, -0.06914310f, 
    0.25117624f, 0.10524615f, -0.09463558f, -0.14760858f, -0.03239257f, -0.01014739f, -0.01330488f, -0.09002732f, 
    0.06420712f, 0.00092292f, -0.14050569f, -0.11182831f, 0.01338115f, -0.29598966f, -0.34359053f, -0.28859934f, 
    -0.10751746f, 0.08233438f, 0.08838884f, 0.14394252f, 0.00500099f, -0.03087596f, -0.09966598f, -0.04540275f, 
    0.27134103f, 0.03036502f, -0.03991976f, 0.03654306f, -0.01793244f, -0.02372141f, -0.17417501f, -0.15214628f, 
    -0.03633776f, 0.02824079f, -0.01931142f, -0.00775484f, -0.16148621f, -0.10375258f, 0.35038793f, 0.13743049f, 
    -0.01036076f, -0.12716399f, 0.00065517f, 0.10659873f, -0.10311217f, -0.10806426f, -0.00620269f, -0.01929512f, 
    0.07135843f, -0.00111596f, 0.06258800f, -0.15952903f, 0.05771369f, -0.01277338f, -0.01030418f, -0.02913308f, 
    0.03900272f, 0.05865738f, 0.01564950f, -0.04280910f, 0.03584039f, -0.02939995f, -0.06763973f, -0.08613505f, 
    -0.01003293f, -0.03114381f, -0.04824112f, -0.01896861f, 0.02988885f, 0.00620085f, 0.07417069f, 0.00000397f, 
    0.04775172f, -0.24092790f, 0.02357782f, -0.07989684f, -0.03121461f, 0.05096206f, 0.04399451f, -0.25119430f, 
    0.05849467f, 0.02190899f, -0.01856182f, 0.05228589f, -0.04481627f, -0.20473346f, 0.11595133f, -0.15494308f, 
    -0.26365381f, 0.13325603f, -0.16901644f, -0.00719952f, -0.01865875f, 0.05957505f, 0.00912086f, -0.02268779f, 
    -0.32502338f, -0.26752645f, -0.13865340f, -0.02933686f, 0.21297678f, 0.04030748f, 0.02148870f, 0.07905848f, 
    0.02934058f, -0.00894733f, -0.00916511f, -0.02786447f, -0.05987210f, -0.08696748f, -0.06984525f, 0.12657535f, 
    -0.09510195f, 0.05258961f, 0.11043499f, -0.21477777f, -0.02672102f, 0.01634237f, -0.03051142f, -0.07158184f, 
    -0.53722954f, -0.62080741f, 0.73034298f, -0.15460420f, 0.10760406f, -0.10077212f, 0.11039978f, -0.07845043f, 
    -0.01208442f, 0.08992238f, 0.04004735f, 0.03326170f, -0.00252996f, -0.01057704f, -0.18908647f, -0.13372101f, 
    0.05910255f, -0.01752858f, 0.01817879f, -0.00104524f, -0.02666983f, 0.01975138f, -0.12638733f, -0.05717446f, 
    0.06879673f, -0.33826894f, 0.38490960f, -0.25426120f, -0.00728330f, 0.09115052f, 0.03198540f, 0.05742000f, 
    -0.06760599f, -0.05415816f, -0.05368210f, -0.07903334f, 0.08134141f, 0.15567885f, -0.10580002f, 0.13140707f, 
    0.05277857f, 0.04358489f, 0.00813126f, -0.04469274f, -0.09063204f, 0.17950276f, -0.10260338f, 0.07685307f, 
    0.10454556f, 0.08159033f, 0.02715907f, 0.07617787f, -0.01137123f, 0.03079940f, -0.10774665f, -0.01940355f, 
    0.06342062f, -0.08592077f, 0.01435938f, 0.01750589f, 0.14549790f, -0.26429474f, 0.12550971f, 0.09599341f, 
    0.00049014f, -0.04870573f, -0.00610747f, -0.04053124f, 0.03815715f, 0.03601914f, -0.02358499f, 0.01045013f, 
    0.02236526f, -0.32435402f, 0.13602751f, -0.15615271f, -0.07232773f, 0.01444073f, -0.05792306f, 0.00022445f, 
    0.04415850f, 0.00405348f, 0.00015878f, 0.05270874f, -0.32142377f, 0.05293143f, 0.04886194f, 0.02494437f, 
    -0.08122836f, -0.02304352f, -0.09312124f, 0.09240997f, -0.02959871f, 0.04222269f, 0.04789182f, 0.01502513f, 
    0.13340607f, 0.08586571f, -0.14149065f, 0.04856430f, 0.07910237f, 0.07322878f, -0.06150272f, -0.26003891f, 
    0.00009338f, 0.14933258f, -0.16075270f, -0.03321723f, -0.42194244f, 0.17150095f, -0.27972725f, 0.63464230f, 
    0.11338174f, 0.05887206f, 0.02159633f, 0.03585399f, -0.02741648f, -0.08658028f, -0.12738402f, -0.05078126f, 
    -0.08965769f, -0.03321994f, 0.14937265f, 0.06536032f, 0.02938851f, -0.03922760f, 0.05718362f, -0.02167470f, 
    0.10008790f, 0.14231943f, 0.12145852f, -0.03205478f, 0.58872169f, -0.53524655f, -0.48527458f, -0.47258231f, 
    -0.03754444f, -0.19320580f, -0.22149822f, 0.08887042f, 0.03106336f, 0.00963328f, -0.10143524f, 0.01724811f, 
    0.17023614f, -0.12989531f, 0.11888538f, 0.02838463f, 0.04166536f, -0.04330141f, -0.05126873f, -0.06130459f, 
    0.03155646f, 0.04137697f, 0.01713644f, 0.03420129f, 0.07014767f, -0.06967437f, -0.08738118f, -0.10332306f, 
    -0.06389182f, 0.03658569f, 0.03870747f, -0.02084566f, -0.04605327f, 0.02826183f, -0.03043560f, 0.01110020f, 
    -0.19607769f, 0.31120861f, 0.05619979f, -0.31632730f, 0.07479759f, -0.02091013f, 0.16603129f, 0.01597140f, 
    -0.08942738f, -0.03679994f, 0.02230861f, 0.05672792f, 0.02895723f, -0.36026680f, -0.13218959f, -0.33634299f, 
    0.05050878f, -0.02001995f, -0.09257183f, 0.09211330f, 0.00564254f, 0.11036267f, -0.02531390f, 0.15036394f, 
    -0.14443144f, -0.09487797f, 0.20297842f, 0.04966718f, 0.04933688f, 0.00891489f, -0.05766493f, -0.00529959f, 
    -0.00492446f, -0.03202584f, -0.02584671f, -0.21140775f, -0.05502070f, 0.01336049f, -0.03765449f, 0.03462064f, 
    0.05932055f, 0.10338150f, 0.00316015f, 0.00088561f, -0.01843013f, 0.00641860f, 0.00898938f, 0.00911959f, 
    -0.36474165f, -0.32011616f, -0.15321130f, -0.17602399f, -0.00392713f, -0.09906033f, 0.11603072f, 0.06287678f, 
    0.03838183f, 0.04401150f, -0.07438584f, -0.05305994f, 0.26366904f, -0.05304232f, -0.12792359f, 0.01041310f, 
    -0.04560631f, -0.05790634f, -0.01300076f, -0.07996331f, 0.04713448f, 0.08518774f, 0.08883949f, 0.05337068f, 
    0.32602113f, -0.02534090f, -0.05451990f, -0.28526986f, -0.07004259f, -0.00792381f, 0.09874893f, -0.13883352f, 
    -0.07261569f, 0.12903178f, 0.06990699f, -0.07093013f, 0.16460529f, 0.02534695f, -0.03612616f, 0.05315423f, 
    -0.00444695f, -0.00657375f, 0.07164932f, -0.03157530f, -0.01423050f, -0.10848869f, -0.06539166f, -0.03056370f, 
    0.14207512f, -0.08410948f, 0.00719836f, 0.02863198f, -0.00077317f, 0.05004734f, -0.00821814f, -0.07634670f, 
    0.06088641f, -0.13971032f, -0.06006764f, 0.03291943f, -0.22847867f, 0.62374824f, -0.29909670f, 0.04463629f, 
    0.11630830f, -0.13860942f, 0.10270686f, -0.01454657f, 0.01172290f, 0.02308274f, -0.01318073f, -0.04277706f, 
    -0.39346597f, 0.06954449f, -0.16067284f, 0.15083487f, 0.08152054f, -0.05168366f, 0.05823417f, 0.09258282f, 
    -0.07842986f, -0.08796058f, 0.00387203f, 0.05001420f, -0.20188534f, 0.14724040f, -0.01035358f, 0.23395249f, 
    0.07451575f, -0.08996308f, -0.11647220f, 0.02621468f, 0.00582193f, 0.01980706f, 0.16752256f, -0.02951976f, 
    -0.17507948f, -0.07720654f, 0.03162151f, 0.10823703f, 0.06952145f, 0.01024621f, -0.02257142f, 0.01329602f, 
    0.06190451f, 0.08421034f, -0.04769021f, 0.00347019f, 0.03901923f, -0.23121756f, -0.11909226f, 0.01519752f, 
    -0.03610876f, 0.07772925f, 0.08777880f, 0.08640917f, 0.06072371f, -0.20761533f, 0.06879215f, -0.00438484f, 
    0.33647048f, 0.12555042f, 0.04712057f, -0.19854014f, 0.01672819f, -0.09288409f, -0.03382627f, -0.06813463f, 
    0.04631998f, -0.03129340f, -0.03396698f, 0.15862444f, 0.30067605f, -0.24184160f, -0.42758378f, -0.44428107f, 
    -0.03891255f, -0.07317001f, 0.11387426f, 0.08256541f, -0.08640496f, 0.07662527f, 0.02227504f, -0.08742972f, 
    -0.17419860f, -0.03733049f, -0.05190960f, -0.09944699f, -0.01730241f, -0.06517962f, -0.07708185f, -0.06349681f, 
    -0.13838221f, -0.24305086f, -0.19208404f, -0.12363128f, -0.14955722f, -0.01793769f, 0.01926585f, -0.04369897f, 
    -0.03192796f, -0.17936370f, -0.08351520f, -0.13930902f, -0.05964551f, 0.03164817f, -0.04043106f, 0.05555013f, 
    -0.01706401f, 0.03563286f, -0.03933374f, -0.01503837f, 0.08393365f, -0.01280952f, -0.07081459f, 0.01362133f, 
    0.09808336f, 0.13071539f, 0.10865290f, 0.18340307f, -0.04232197f, 0.17923415f, -0.09056895f, 0.06912004f, 
    0.05380063f, -0.05209367f, 0.06165377f, -0.04105914f, 0.15066831f, -0.07709303f, 0.00254972f, 0.04029786f, 
    0.08025862f, -0.04183237f, -0.06771192f, -0.06958530f, 0.01687219f, -0.00923096f, -0.11918746f, -0.00143626f, 
    0.06817978f, 0.14975473f, 0.19756764f, 0.11571576f, 0.05917985f, -0.22802879f, -0.08451983f, -0.09859890f, 
    -0.00971786f, 0.13047187f, 0.04255252f, -0.27387241f, 0.04583416f, 0.04150072f, -0.01288955f, 0.11597311f, 
    -0.04128857f, 0.04919310f, 0.12909290f, 0.21265972f, -0.06844786f, 0.05367589f, -0.02400043f, -0.03836337f, 
    0.02082214f, 0.03033931f, 0.09873962f, 0.09229764f, -0.53952295f, -0.12615642f, 0.17253928f, 0.16995025f, 
    0.08203110f, 0.04196210f, -0.14058399f, 0.12492196f, -0.06828950f, -0.02697140f, 0.01733300f, 0.18435790f, 
    -0.00391795f, -0.14896414f, -0.28540352f, -0.16435526f, -0.10187405f, -0.04052396f, 0.05358338f, 0.06178652f, 
    0.12653445f, 0.01511905f, 0.17864941f, 0.02074454f, -0.25832629f, -0.12504333f, 0.09343570f, 0.29049253f, 
    -0.02770351f, 0.06074334f, 0.16789816f, 0.12489664f, -0.00187875f, -0.00089520f, 0.04005435f, 0.06705949f, 
    0.11290342f, 0.10357282f, -0.03252061f, -0.11060169f, -0.05173860f, -0.04286399f, -0.03122653f, 0.13553333f, 
    0.01068627f, -0.00258125f, -0.11797597f, -0.05950094f, -0.11240084f, -0.05831680f, 0.02064720f, 0.05609018f, 
    0.08040418f, 0.03383778f, -0.02726213f, 0.06787346f, -0.29743963f, -0.16352229f, -0.12319334f, -0.38085151f, 
    0.09473103f, -0.10955823f, -0.15092175f, -0.12648781f, 0.11081915f, 0.03207244f, 0.12461976f, 0.14900962f, 
    -0.10449494f, -0.14685547f, -0.13246177f, -0.08744418f, -0.09781088f, -0.20575817f, -0.14920595f, -0.04783272f, 
    -0.00709245f, 0.13543877f, 0.01192205f, 0.02731240f, 0.15183134f, -0.00712677f, 0.06585132f, 0.09134490f, 
    -0.13375951f, -0.17147897f, -0.11077113f, -0.00784053f, -0.03743871f, -0.02343770f, -0.07659695f, 0.03935643f, 
    -0.10349118f, 0.04598705f, 0.08205985f, -0.07946565f, 0.31568787f, -0.18719961f, -0.05215903f, -0.17251390f, 
    0.14525759f, -0.06379013f, 0.05157175f, -0.06851900f, 0.02659214f, 0.14664072f, 0.06044864f, 0.10483579f, 
    -0.10376592f, -0.14455953f, -0.03501872f, 0.00155026f, -0.00518438f, 0.01407233f, -0.02626326f, 0.01407142f, 
    0.10973129f, 0.14514197f, 0.07735618f, 0.19527960f, 0.02928458f, -0.12544912f, -0.22806448f, -0.40268546f, 
    -0.06905500f, -0.12530261f, 0.02582321f, -0.06272198f, -0.03624514f, 0.12522487f, -0.01897819f, 0.13555476f, 
    -0.35246614f, -0.18391441f, 0.30045533f, 0.01044954f, 0.02421172f, 0.04355502f, -0.00990505f, -0.12937517f, 
    -0.10183141f, -0.03304144f, 0.00917668f, -0.09860907f, 0.06642475f, -0.23973656f, -0.16215768f, 0.11845993f, 
    0.06379525f, 0.18654704f, -0.01531338f, 0.07602696f, -0.09360031f, -0.02136425f, -0.03893816f, -0.00659732f, 
    -0.07890823f, 0.07044072f, 0.05767727f, -0.03938622f, -0.07865321f, -0.01166728f, 0.04253542f, 0.03096764f, 
    0.11560256f, -0.01027726f, 0.04052258f, 0.07431307f, -0.35751253f, -0.48409072f, -0.05861924f, 0.12265809f, 
    0.02668107f, 0.00887204f, 0.09543558f, 0.06600588f, -0.10397630f, 0.04022848f, 0.08710255f, 0.05925886f, 
    -0.35236758f, -0.53705508f, -0.55643737f, -0.33042869f, 0.03150990f, -0.01872774f, 0.12882626f, 0.15353695f, 
    0.09295595f, 0.04241259f, 0.02702007f, 0.18459332f, -0.00666736f, 0.07054352f, -0.03545692f, -0.05332313f, 
    -0.10509571f, -0.03197628f, -0.00101519f, 0.05012695f, 0.08227240f, 0.07261354f, 0.05442738f, 0.09876495f, 
    -0.29704601f, -0.22998257f, -0.09185990f, -0.10887544f, 0.00221649f, 0.02638837f, 0.03580327f, -0.01641034f, 
    0.09234987f, 0.17930637f, -0.08232621f, -0.04621098f, 0.07215488f, -0.32512194f, -0.42045859f, 0.06171139f, 
    0.07382715f, 0.02091369f, 0.18931907f, 0.02945477f, -0.06601767f, -0.07775718f, -0.01071098f, -0.08071543f, 
    0.18764254f, -0.03303623f, -0.08713932f, -0.06258465f, 0.12287185f, 0.03994703f, 0.03595132f, 0.01957681f, 
    0.03659046f, -0.01051503f, 0.04110619f, 0.11500648f, 0.19406857f, -0.18011557f, -0.36695850f, -0.35449293f, 
    -0.26213038f, -0.26000461f, 0.01589523f, -0.17058061f, -0.02740721f, 0.01111721f, 0.01813351f, -0.04513214f, 
    -0.02882905f, 0.14701626f, 0.11622889f, -0.15410441f, -0.04242899f, -0.01883021f, -0.00990531f, -0.07782982f, 
    -0.06678403f, -0.05520200f, -0.04041433f, -0.03421124f, -0.19137724f, 0.12635955f, 0.09184744f, 0.02161143f, 
    -0.02801539f, -0.10460503f, -0.06847136f, -0.06294550f, -0.09123842f, 0.07473921f, -0.09939276f, -0.00132240f, 
    0.47237375f, 0.03720689f, 0.09155349f, 0.01399431f, -0.02104307f, -0.00364438f, -0.01602907f, -0.22467579f, 
    0.07358299f, 0.05817190f, 0.05722579f, -0.05928510f, 0.29090989f, 0.29446390f, 0.00404494f, -0.31937313f, 
    0.05382233f, -0.10432494f, 0.00550155f, -0.14650282f, 0.03280569f, -0.01307503f, -0.00943233f, -0.00996494f, 
    -0.19672211f, -0.28169891f, -0.35071483f, 0.09819780f, -0.14753230f, 0.03776844f, 0.00072531f, 0.14051704f, 
    -0.04679412f, -0.06496333f, -0.06028896f, -0.00758070f, 0.04008014f, 0.00327230f, -0.07284140f, 0.09016199f, 
    0.22460601f, 0.06638455f, 0.17964470f, 0.10767228f, 0.00199368f, 0.04819486f, -0.02600844f, 0.21659695f, 
    0.47508669f, -0.45406955f, -0.05039118f, -0.10975727f, -0.00088689f, 0.10312026f, -0.11670791f, -0.15294652f, 
    0.00649632f, 0.09664328f, 0.13989232f, 0.05684401f, 0.21391472f, -0.15676896f, -0.08246993f, -0.22231463f, 
    -0.13970508f, -0.05124300f, 0.04460473f, 0.00523707f, -0.03923757f, -0.05470277f, 0.06237184f, 0.01020622f, 
    0.57311672f, 0.19960169f, -0.08439352f, -0.09397885f, 0.06055249f, 0.14083539f, 0.06072213f, -0.14732727f, 
    0.09641016f, 0.15342474f, 0.05326409f, 0.08619953f, -0.05501901f, -0.04796699f, 0.12286353f, 0.01162790f, 
    -0.07981398f, -0.03450833f, -0.00917880f, 0.04063696f, -0.10228226f, -0.02919464f, 0.07882942f, -0.08430311f, 
    -0.07409796f, -0.06778967f, -0.08318385f, 0.05628694f, -0.02460565f, 0.06221133f, -0.01971397f, 0.18928181f, 
    0.06127464f, 0.03977891f, -0.10998711f, -0.11466239f, 0.05792320f, -0.05450695f, -0.08922359f, -0.14190915f, 
    0.00784105f, 0.00551983f, 0.01681144f, -0.03640168f, 0.15830337f, 0.04291212f, -0.14849769f, -0.36060411f, 
    0.01671906f, 0.00701711f, 0.00901507f, 0.03851308f, 0.09556215f, 0.05769528f, 0.06000675f, 0.08140875f, 
    -0.18523215f, -0.03821222f, -0.26766127f, -0.49838430f, -0.03855686f, 0.19249471f, 0.14906612f, 0.17959704f, 
    0.05976786f, -0.05059958f, -0.03712117f, -0.14639719f, 0.06449534f, 0.01888726f, 0.10893908f, -0.01155513f, 
    0.54043353f, 0.08397134f, -0.08181284f, -0.03507983f, 0.20398957f, -0.19801386f, -0.11345565f, 0.18124692f, 
    0.26144400f, -0.11418422f, 0.03828133f, 0.08734274f, -0.22575136f, -0.16053724f, -0.19852298f, -0.21380547f, 
    -0.18916345f, -0.19926675f, -0.25456637f, -0.01430106f, 0.05712149f, 0.06528307f, 0.04877038f, 0.04660220f, 
    -0.47332531f, 0.08039356f, 0.02224134f, 0.07380885f, -0.01451510f, -0.04211296f, -0.06337674f, -0.00960568f, 
    0.00608642f, -0.05032340f, -0.24447158f, -0.22489712f, -0.01690832f, -0.27369902f, -0.41729486f, -0.06541167f, 
    0.12305828f, 0.15804385f, 0.21192607f, -0.04335003f, 0.00325736f, -0.12632637f, 0.08926846f, -0.05449965f, 
    -0.04258240f, 0.02926039f, -0.01914252f, -0.04949380f, -0.01330560f, -0.04675956f, 0.03758283f, 0.04217474f, 
    -0.10287230f, 0.08728610f, -0.05032041f, -0.26981640f, 0.07137948f, -0.03621905f, -0.04621400f, -0.01563329f, 
    0.01033539f, 0.01187905f, 0.08712157f, 0.03511667f, 0.00519574f, 0.07974990f, 0.08864772f, 0.06256365f, 
    -0.57456964f, 0.01065543f, 0.12534606f, 0.25599140f, 0.01183737f, 0.07677809f, -0.09421454f, -0.23818058f, 
    0.07171558f, -0.05907883f, -0.01468178f, -0.00564938f, -0.35241020f, -0.45179754f, -0.40294555f, 0.04575066f, 
    -0.03225379f, 0.13588263f, 0.15422946f, 0.04509467f, 0.00060919f, 0.01312140f, 0.04682085f, -0.03904861f, 
    -0.24450718f, -0.17222419f, 0.14743061f, 0.16883177f, -0.01495082f, 0.04994711f, -0.06161139f, 0.02815744f, 
    -0.00192015f, -0.00903600f, -0.07966056f, 0.01831092f, -0.21922676f, 0.07536172f, 0.15935372f, 0.15146798f, 
    -0.07172733f, -0.07677837f, -0.10751146f, -0.07177336f, 0.03722945f, 0.02979014f, 0.09710294f, -0.00762359f, 
    -0.04880471f, -0.25915790f, -0.20533887f, 0.09176154f, -0.08201067f, 0.15347324f, 0.05299275f, -0.09023742f, 
    -0.08760347f, -0.02884375f, -0.07837730f, -0.01006396f, -0.07321142f, -0.08956786f, -0.20323968f, -0.09598698f, 
    0.06155978f, 0.05671151f, 0.07117712f, 0.16509542f, -0.03438640f, -0.05000247f, -0.02733987f, -0.02932504f, 
    0.16672485f, 0.02849991f, -0.08964908f, -0.06372005f, 0.04664771f, -0.01334543f, 0.03285801f, -0.02520283f, 
    0.18660904f, 0.07327178f, -0.03593367f, 0.00777911f, -0.08245529f, -0.20062064f, 0.03650490f, -0.06495205f, 
    -0.01759670f, -0.00415817f, 0.00254491f, 0.03714781f, -0.04776349f, -0.00209717f, -0.12364379f, -0.06261189f, 
    0.12051938f, 0.20420974f, -0.09040298f, -0.04813655f, 0.07878911f, -0.02625177f, 0.03366489f, 0.01805077f, 
    -0.04421025f, -0.01317958f, -0.13040844f, -0.05950126f, -0.55076003f, -0.17657667f, -0.06533826f, 0.16428483f, 
    0.02994536f, 0.16661490f, -0.20174216f, 0.02343353f, 0.07146750f, -0.01491869f, 0.13753317f, 0.02462634f, 
    -0.31753719f, 0.34596339f, 0.09566890f, -0.14945112f, 0.08150627f, -0.08618991f, 0.13736878f, -0.17724146f, 
    0.08779150f, -0.03468239f, -0.01982339f, -0.00816554f, -0.24757278f, 0.15268268f, -0.55308378f, 0.08069631f, 
    -0.02111716f, 0.02554468f, 0.17976135f, -0.07120518f, -0.00407610f, 0.06295941f, -0.05668619f, -0.00434055f, 
    0.03590549f, 0.13226412f, 0.04308833f, -0.29409242f, -0.15934199f, 0.06261586f, 0.08452038f, -0.12660140f, 
    0.15003327f, 0.09451565f, -0.01151898f, 0.04056066f, 0.07850606f, 0.02215071f, 0.45819011f, -0.17673361f, 
    0.05373603f, -0.19504668f, -0.05381376f, -0.11212354f, -0.12497076f, -0.05282040f, 0.05206883f, 0.08861996f, 
    -0.32547724f, -0.11414858f, -0.02878754f, 0.01295365f, 0.10811292f, 0.10088470f, 0.05469844f, -0.00849943f, 
    -0.03134974f, -0.14652561f, 0.04593361f, 0.03002333f, 0.10332041f, 0.15044558f, 0.07285479f, 0.03494006f, 
    -0.12580080f, -0.14946862f, 0.16768910f, 0.05515523f, 0.07310066f, 0.04727623f, 0.01207718f, -0.05612179f, 
    -0.09422719f, -0.01049417f, -0.34873557f, 0.07792204f, 0.15276045f, 0.00865161f, 0.22482732f, -0.00237238f, 
    0.08358256f, 0.00743188f, 0.06397100f, 0.02384207f, 0.13841227f, 0.04279451f, 0.10423052f, -0.47722784f, 
    0.01597939f, 0.02190674f, 0.09218767f, 0.06973937f, 0.07744254f, 0.02990847f, -0.15322052f, 0.01418509f, 
    0.12515363f, 0.05192214f, 0.01303322f, 0.01485873f, -0.02282337f, 0.11271276f, 0.01156428f, -0.00680655f, 
    0.07099660f, -0.04062577f, -0.11853024f, -0.09493262f, 0.18872410f, -0.26801297f, 0.00943949f, -0.16117659f, 
    0.08487515f, 0.10676741f, -0.02480862f, 0.30850747f, 0.05837188f, 0.05885386f, 0.06900606f, -0.12454581f, 
    -0.08006193f, 0.03941254f, -0.15626776f, -0.02684525f, 0.02202030f, -0.06769250f, -0.09232958f, -0.00805701f, 
    0.03401702f, 0.02601782f, -0.13558702f, -0.16948412f, 0.02906505f, -0.45561519f, 0.07111260f, -0.44977757f, 
    0.01856833f, -0.24005082f, 0.01350512f, -0.03698282f, -0.16848494f, -0.23127215f, -0.19626622f, 0.00699074f, 
    -0.12583487f, -0.04558306f, 0.10952694f, -0.09197313f, 0.00987969f, 0.01910771f, -0.05008002f, -0.07457653f, 
    0.13747278f, 0.03024044f, -0.21381429f, 0.13439979f, -0.33707979f, 0.31671757f, -0.21914750f, -0.45308739f, 
    0.01067394f, -0.10328161f, 0.14708436f, 0.00733471f, 0.01287103f, 0.01277543f, 0.01049779f, 0.15406221f, 
    0.27828288f, 0.05887147f, 0.35874301f, 0.40571523f, 0.16228113f, -0.07007375f, -0.19693759f, -0.17775171f, 
    -0.12962911f, -0.12943242f, 0.01063959f, 0.03894156f, 0.08730671f, 0.02025764f, 0.33716983f, -0.53282166f, 
    0.14378907f, -0.10027770f, 0.02861908f, 0.06013091f, -0.13152480f, 0.02362719f, -0.00041732f, 0.07692277f, 
    -0.32146555f, -0.10398421f, -0.05822257f, 0.15026788f, -0.04279489f, 0.10297474f, -0.03451802f, 0.05771795f, 
    0.26934728f, -0.07200794f, 0.07679924f, 0.11145733f, -0.00675649f, 0.15050836f, 0.12672661f, -0.26447451f, 
    0.00899495f, -0.08163974f, 0.04233763f, 0.00402672f, 0.03868263f, 0.07168671f, 0.15294103f, 0.13665023f, 
    0.00829639f, 0.12646361f, 0.01005691f, 0.08011778f, -0.08882707f, -0.19391690f, 0.03497602f, 0.07660829f, 
    -0.01190631f, -0.00352315f, 0.07628272f, 0.05279656f, 0.09046803f, 0.21544348f, -0.10329416f, 0.41523945f, 
    -0.00427626f, 0.00026569f, -0.19093357f, -0.01458606f, -0.10278586f, -0.28665301f, -0.03948224f, 0.00786583f, 
    0.04061357f, 0.33828551f, 0.32485446f, -0.23113477f, -0.04981761f, -0.17200199f, 0.11860070f, -0.04742492f, 
    0.10934990f, -0.06570569f, 0.09529314f, -0.03205367f, 0.16623497f, -0.36647320f, 0.26442385f, 0.15850738f, 
    0.15481177f, -0.03157454f, 0.07730670f, -0.14748091f, 0.02328491f, -0.02924931f, -0.24536808f, 0.01332729f, 
    0.02458565f, 0.02933634f, 0.02140970f, -0.21288238f, 0.15802521f, -0.22533549f, 0.00909758f, -0.00787900f, 
    -0.13571851f, -0.02505708f, -0.02630500f, -0.15159354f, -0.09349147f, -0.35563639f, 0.27638724f, 0.22085023f, 
    0.00850611f, 0.03319553f, -0.09849816f, -0.09913351f, 0.07147333f, 0.17548744f, 0.08657598f, -0.19707070f, 
    0.01684222f, 0.04625704f, -0.34161997f, -0.17431492f, 0.11655846f, 0.04395782f, 0.19273908f, 0.07232963f, 
    0.05526082f, -0.10790826f, -0.06825759f, 0.16664512f, 0.25326258f, -0.40345737f, -0.03495774f, -0.38434058f, 
    0.01498685f, -0.00908511f, -0.06783900f, 0.03006293f, 0.09912664f, -0.02779872f, -0.01938120f, 0.03393291f, 
    -0.00219509f, -0.10285704f, -0.04438752f, 0.00973443f, 0.01786696f, 0.07467417f, -0.09369777f, 0.13658465f, 
    0.02231967f, 0.10332995f, -0.09352073f, -0.07634476f, -0.00959841f, 0.10174395f, -0.13662516f, -0.36333612f, 
    -0.09066089f, -0.23057310f, 0.04583932f, 0.04178201f, 0.01110039f, -0.01050056f, -0.00574755f, 0.02177146f, 
    -0.02543375f, -0.04998124f, 0.25766468f, -0.08628055f, 0.17837483f, -0.31389689f, -0.01741720f, 0.03617799f, 
    -0.04428078f, 0.00427758f, -0.00946025f, 0.00490501f, 0.01165296f, -0.01637391f, -0.02241675f, 0.03716991f, 
    -0.05406307f, 0.13350773f, -0.10588230f, 0.08649218f, -0.13905367f, -0.02772814f, -0.12439175f, -0.04217654f, 
    0.31449813f, 0.04282652f, 0.24325244f, 0.22777723f, 0.06895405f, -0.16082467f, -0.14343676f, -0.18725008f, 
    0.04047268f, 0.05941221f, 0.02442268f, 0.08308192f, -0.23657595f, 0.06462408f, 0.23044977f, -0.13908908f, 
    -0.08532146f, -0.13147147f, -0.07138932f, -0.12709185f, 0.05503891f, 0.06943119f, 0.06015337f, -0.01194665f, 
    -0.04687296f, 0.06601606f, 0.04864177f, 0.18809801f, 0.31280753f, -0.19755979f, -0.02244118f, -0.01624449f, 
    0.06691525f, -0.06129444f, 0.00559187f, 0.08811761f, -0.41127533f, -0.06176506f, 0.26111954f, -0.14436221f, 
    -0.21370564f, -0.01013353f, 0.07391692f, -0.01384302f, 0.07736343f, 0.01218080f, 0.10833508f, 0.03916271f, 
    -0.05260442f, -0.28790796f, -0.21381998f, -0.03164005f, 0.00809846f, 0.18397297f, 0.12337390f, 0.05904909f, 
    0.12004635f, 0.00755583f, 0.03121998f, -0.01854793f, 0.02212208f, -0.26433223f, -0.17845663f, 0.01003421f, 
    0.02093684f, 0.14376780f, 0.08725069f, 0.06674311f, -0.03604800f, -0.07972517f, -0.03429321f, 0.03508930f, 
    0.30330369f, -0.42865255f, -0.07139254f, -0.03913630f, 0.22309445f, 0.08773008f, 0.10097880f, -0.09578703f, 
    0.01376503f, -0.05967996f, -0.03588366f, -0.05003124f, -0.30866793f, -0.46403942f, 0.00629071f, -0.19401009f, 
    -0.05236365f, 0.02420323f, -0.18819508f, -0.06954587f, -0.01015605f, -0.04810378f, 0.00916622f, 0.00340769f, 
    -0.05944733f, 0.08122220f, 0.29874489f, -0.19891872f, -0.19389616f, 0.00858901f, 0.13822058f, 0.22861934f, 
    -0.01089181f, 0.04538058f, 0.03869143f, -0.01507530f, -0.02816392f, 0.09808545f, -0.42256641f, -0.07436816f, 
    0.12081362f, -0.16969833f, -0.06170918f, -0.08444781f, 0.08859203f, -0.00220743f, -0.09900902f, -0.04710744f, 
    0.11866323f, -0.27733764f, 0.24655938f, -0.42382264f, -0.04663700f, -0.20277181f, -0.05812701f, -0.08282828f, 
    -0.13248093f, 0.01752324f, -0.06817230f, 0.06997229f, -0.02552057f, -0.03330657f, 0.05001143f, 0.18900344f, 
    0.20203085f, -0.15513854f, -0.11892920f, 0.04049251f, -0.06348970f, 0.04175226f, -0.08955119f, 0.09512726f, 
    -0.63609385f, -0.52112049f, -0.12792522f, -0.06462964f, 0.08305790f, 0.10866871f, -0.03780122f, 0.17244101f, 
    -0.02345701f, 0.03171475f, -0.04962029f, -0.02243261f, -0.28107673f, 0.15179589f, 0.09604398f, 0.07924464f, 
    0.05621381f, 0.00653092f, -0.06695393f, 0.13411629f, -0.02279352f, -0.08141971f, -0.06018436f, 0.32815287f, 
    -0.29675773f, 0.08089043f, -0.26114407f, -0.08240359f, -0.07772210f, 0.04933938f, 0.01831466f, -0.04311569f, 
    0.24347904f, -0.05860302f, -0.05494078f, -0.05019385f, 0.00606306f, -0.02018086f, -0.00758674f, 0.30052575f, 
    0.07709347f, 0.02061398f, -0.06778573f, -0.13698716f, 0.10157931f, 0.08461975f, 0.08676548f, -0.02234672f, 
    0.03845290f, -0.06503468f, 0.09539937f, 0.00845239f, -0.11656626f, 0.00886559f, -0.05471694f, -0.00908564f, 
    0.13220920f, 0.00548242f, 0.14252792f, 0.14380501f, -0.10902901f, -0.05871604f, -0.35643524f, 0.09483609f, 
    -0.05063660f, 0.08047706f, 0.09590969f, 0.11535176f, -0.08329402f, -0.00241744f, -0.04422492f, -0.06566103f, 
    -0.41650859f, 0.23197816f, -0.34392282f, 0.07669213f, 0.12872995f, -0.14356844f, -0.14020456f, -0.08685325f, 
    -0.07198213f, 0.01302117f, -0.03442670f, -0.23670214f, -0.31792638f, 0.23275232f, -0.12128831f, 0.11473923f, 
    -0.06730225f, -0.06773541f, 0.11499776f, 0.11717758f, 0.03578471f, 0.04999508f, 0.10441220f, -0.01667870f, 
    0.09465400f, -0.06347834f, 0.24988797f, -0.16939238f, -0.00351793f, 0.01561842f, 0.06504100f, 0.02513135f, 
    0.04133759f, 0.15745889f, 0.15629216f, 0.15569089f, -0.23888364f, -0.01320905f, 0.24577980f, -0.01736505f, 
    -0.09578709f, -0.10234796f, -0.16773881f, -0.12112799f, -0.05255507f, -0.10888640f, 0.00517231f, 0.10126265f, 
    0.10533769f, -0.01267244f, 0.05196606f, 0.10817823f, -0.04613128f, 0.05391111f, -0.00383704f, 0.10559367f, 
    0.15104815f, 0.05546482f, 0.22132996f, 0.18131202f, 0.19032249f, 0.12687767f, 0.07910345f, -0.24446118f, 
    0.12315083f, -0.23190951f, 0.02431998f, 0.00537727f, -0.13676876f, -0.02209634f, 0.03934702f, 0.01627297f, 
    0.12273069f, -0.18853615f, -0.08557785f, -0.13868646f, 0.12929998f, -0.02433172f, -0.02747717f, 0.21657526f, 
    0.03050414f, -0.05915641f, -0.03191879f, -0.10094927f, -0.08630650f, -0.14893448f, -0.20153421f, -0.33728290f, 
    -0.40206897f, 0.03176558f, 0.01848967f, -0.00062736f, 0.05922910f, 0.01326985f, 0.01244030f, -0.00918336f, 
    0.24678232f, -0.09695090f, 0.29806843f, -0.45886898f, -0.06487108f, 0.01065948f, -0.09053478f, -0.04768756f, 
    -0.02131873f, 0.08448417f, -0.00549968f, -0.06755617f, 0.02563694f, -0.15314162f, -0.15925722f, -0.05221354f, 
    -0.03255527f, -0.03821395f, 0.10142376f, -0.03095720f, -0.07978388f, 0.04992557f, -0.03289320f, -0.08106179f, 
    -0.04377466f, -0.00141668f, -0.05374972f, -0.31836811f, -0.00300371f, 0.04034069f, 0.02040580f, 0.12298713f, 
    0.07948009f, 0.08237734f, -0.03061989f, -0.06839099f, -0.33248186f, 0.25038189f, 0.13328342f, -0.19437861f, 
    0.01357008f, -0.25451842f, 0.09396135f, -0.24583800f, -0.01370230f, 0.10659565f, 0.13697328f, 0.01623655f, 
    -0.16005437f, 0.03519621f, -0.26815951f, 0.08031431f, -0.10254595f, 0.18497486f, -0.06494713f, 0.14743625f, 
    0.04535228f, -0.06557490f, -0.10602328f, -0.02135796f, -0.15233620f, 0.04221341f, 0.04432085f, -0.01641866f, 
    -0.12276293f, 0.06577719f, -0.16718899f, -0.07510126f, 0.01801689f, 0.02967558f, 0.09047470f, 0.06354539f, 
    0.11500182f, -0.08519136f, -0.20355672f, 0.14644481f, 0.02980390f, 0.12134103f, 0.06969239f, 0.04067807f, 
    0.06891945f, 0.03301227f, 0.14959227f, -0.00223999f, -0.09733358f, -0.10740381f, -0.25284150f, -0.13143481f, 
    0.09950536f, -0.14652386f, 0.08373433f, 0.09537237f, -0.07288931f, -0.00277736f, -0.02068620f, -0.07385438f, 
    -0.20949610f, 0.28950271f, -0.17461585f, 0.13739882f, -0.11742459f, -0.08914121f, 0.00461872f, 0.16094375f, 
    -0.09910095f, -0.01307553f, 0.10244379f, 0.00179167f, -0.01499627f, 0.02896569f, -0.26784590f, -0.03714936f, 
    -0.13197722f, 0.01144007f, 0.06237892f, -0.13265161f, -0.01627981f, -0.01475275f, 0.05627577f, 0.12161250f, 
    0.06292050f, -0.00472646f, 0.10093157f, 0.33270743f, -0.01383432f, 0.02655396f, 0.08293802f, -0.07485680f, 
    -0.08867233f, -0.05490151f, 0.04582967f, -0.05603980f, -0.34595048f, 0.21565859f, 0.00445558f, 0.02040973f, 
    0.00269148f, 0.06311704f, -0.16875032f, 0.07389498f, 0.04305306f, -0.00461441f, -0.05375864f, -0.06454727f, 
    -0.27204517f, -0.15254804f, 0.05303533f, -0.06479006f, -0.30213282f, -0.01629723f, 0.02994533f, 0.00672217f, 
    0.10568725f, 0.01714535f, 0.01665862f, 0.00538267f, -0.20669240f, -0.11034775f, -0.02314276f, 0.15994288f, 
    0.02360315f, 0.11236453f, -0.01163833f, -0.06954399f, -0.04807232f, 0.13869084f, -0.02785073f, -0.01062579f, 
    -0.07160585f, 0.07288250f, 0.09166954f, -0.12778805f, -0.06341564f, -0.09307648f, -0.08023741f, -0.09267005f, 
    -0.12189870f, 0.01483740f, -0.10763793f, -0.14801607f, -0.25015062f, -0.28010052f, 0.24830791f, -0.02622254f, 
    -0.07359833f, 0.17796743f, -0.18433808f, 0.05959956f, -0.10901969f, -0.05880721f, 0.01107475f, -0.21661329f, 
    0.02190119f, 0.02961998f, -0.01563263f, -0.10526136f, -0.10407863f, 0.02259302f, 0.00145421f, -0.00135027f, 
    0.04992694f, 0.09622917f, 0.12351796f, 0.18422286f, -0.04808754f, 0.14673050f, 0.09655510f, 0.26886702f, 
    -0.05074945f, 0.06551686f, -0.22835329f, -0.07832076f, -0.09156967f, -0.30635151f, 0.06222663f, 0.03801368f, 
    -0.02611750f, 0.08497572f, 0.00677490f, 0.09468215f, -0.16863556f, 0.10896033f, 0.15719874f, 0.05813369f, 
    0.05554712f, 0.03059227f, 0.19948304f, 0.15596411f, -0.74327534f, 0.56336755f, 0.08605709f, 0.14162485f, 
    0.07885079f, 0.08876099f, -0.12957282f, 0.13903856f, -0.04203047f, -0.13426723f, 0.12877247f, 0.20885634f, 
    0.11285193f, 0.12417355f, 0.15548152f, 0.23997295f, -0.08412867f, 0.10043387f, -0.01822142f, 0.22189464f, 
    0.03043744f, -0.14168432f, 0.02206456f, -0.05451272f, -0.09021209f, -0.11198087f, 0.29204226f, 0.10872071f, 
    -0.01216657f, 0.02428374f, 0.00334236f, 0.09136759f, -0.14429669f, 0.03062966f, 0.05440864f, 0.02541993f, 
    -0.00770851f, 0.14508303f, 0.01527960f, -0.12735501f, 0.02231179f, -0.02182742f, -0.01364368f, -0.04016454f, 
    0.01660021f, 0.15427816f, 0.06360634f, -0.06356227f, -0.05850803f, -0.09609849f, -0.01308439f, 0.41633132f, 
    -0.09618171f, 0.06188539f, -0.08449121f, 0.04858945f, -0.03618263f, 0.02916256f, 0.06769443f, 0.05519736f, 
    0.14603658f, -0.38395616f, 0.24373733f, -0.03862826f, -0.18445851f, 0.09769528f, -0.12591656f, -0.19292922f, 
    -0.10382688f, 0.00288564f, -0.06828474f, -0.07689756f, -0.01045168f, 0.06578475f, 0.05178359f, 0.05671594f, 
    0.01168659f, -0.12055819f, -0.00927384f, 0.08679985f, -0.05437090f, 0.00003188f, -0.29821461f, -0.41248307f, 
    -0.12970597f, 0.02971760f, -0.11113415f, -0.07117294f, 0.02400968f, -0.04056424f, -0.05586512f, 0.02374342f, 
    -0.03041228f, -0.03792509f, -0.10490262f, -0.12994173f, 0.12699103f, 0.38826028f, 0.02548942f, -0.02121890f, 
    -0.00286253f, -0.05072867f, 0.01370596f, 0.07905675f, -0.01949989f, 0.14279298f, -0.02613451f, 0.11480489f, 
    -0.35547271f, -0.16842793f, 0.06581727f, -0.00183882f, 0.04706258f, 0.14392096f, 0.11177521f, -0.01005638f, 
    -0.16791409f, -0.02519340f, -0.05474301f, -0.01877260f, -0.54908472f, 0.26844785f, -0.42188072f, -0.04660312f, 
    -0.12879124f, 0.16340341f, 0.03631267f, -0.07935240f, 0.01846589f, 0.06344745f, 0.05026418f, 0.11074229f, 
    -0.03746790f, 0.26634651f, 0.21092673f, 0.10597965f, -0.04348119f, -0.07138680f, -0.10359015f, 0.07916492f, 
    0.03524079f, -0.03075231f, 0.22724189f, 0.18122745f, -0.38413051f, 0.20128149f, -0.10155772f, 0.06146167f, 
    0.01386534f, 0.00818110f, 0.06632262f, 0.01079622f, 0.02181784f, -0.15448807f, 0.06479374f, 0.11146404f, 
    0.05558820f, -0.03349754f, 0.06144689f, -0.06280195f, -0.19109128f, -0.13773745f, -0.09071717f, -0.19178209f, 
    -0.08711201f, -0.13569877f, -0.47002769f, -0.05894056f, 0.11107525f, -0.44361353f, -0.09015467f, 0.23221421f, 
    0.04854875f, -0.19502956f, 0.08441632f, 0.03314846f, -0.12369595f, 0.14304049f, -0.29530576f, -0.16743495f, 
    0.03856688f, 0.01450208f, 0.02524935f, 0.02334299f, -0.01360428f, -0.01569960f, -0.05902083f, 0.03672254f, 
    -0.01234635f, 0.09733438f, 0.18632069f, -0.01363002f, 0.07902503f, -0.12115458f, 0.15345691f, 0.06939081f, 
    -0.10116059f, 0.08276103f, 0.01255220f, 0.07779942f, 0.11297484f, 0.00170046f, 0.08782147f, 0.08397312f, 
    0.02780013f, -0.10966086f, -0.26050511f, 0.11922669f, -0.19126748f, 0.04512275f, 0.03075217f, 0.04773429f, 
    0.08725092f, 0.00256427f, 0.08658919f, 0.12122706f, 0.00119369f, 0.17170314f, -0.00217311f, -0.03085724f, 
    -0.11730441f, 0.01622242f, 0.00763151f, 0.08900711f, 0.00732066f, 0.04300581f, 0.19451228f, 0.10760730f, 
    0.04906183f, 0.12145206f, -0.04781140f, -0.07667521f, 0.02169056f, -0.06120738f, -0.00433012f, -0.08084954f, 
    -0.06962542f, 0.03827007f, 0.00110586f, -0.18784304f, -0.12898499f, -0.07719443f, -0.04540173f, -0.02007625f, 
    -0.04681163f, -0.10267266f, -0.19786842f, 0.01361753f, -0.02647352f, 0.11874868f, -0.09416648f, -0.18397047f, 
    -0.32978293f, 0.25984624f, -0.11255955f, -0.04486725f, -0.05012757f, 0.02697218f, 0.08035368f, 0.00351153f, 
    -0.03195797f, 0.08675629f, -0.04434992f, 0.13083470f, 0.11933587f, -0.51971489f, -0.03434094f, -0.09763505f, 
    -0.00356101f, -0.06422874f, -0.02427396f, 0.17900202f, 0.06610908f, 0.04180246f, 0.04259680f, -0.10250683f, 
    -0.23209928f, -0.28669703f, -0.12794746f, -0.27422595f, -0.13555178f, -0.19525665f, -0.20935209f, -0.08463226f, 
    -0.06867114f, 0.01191802f, 0.06256684f, -0.18122435f, 0.03976085f, 0.12674677f, -0.12475084f, 0.24788770f, 
    -0.09668969f, -0.01007367f, 0.08141190f, -0.09350491f, -0.05212396f, 0.13143933f, -0.07668532f, -0.01745976f, 
    -0.63736904f, 0.09049956f, -0.20010722f, -0.08832905f, 0.04315345f, 0.13517189f, -0.12013168f, 0.05452022f, 
    -0.08462502f, 0.00695056f, 0.04529589f, -0.05205321f, -0.15403239f, -0.34768331f, -0.03364426f, -0.02486313f, 
    0.05745442f, 0.06771880f, -0.13789108f, -0.12588842f, -0.02984459f, -0.00201721f, -0.07634684f, -0.06940620f, 
    -0.14194237f, -0.23775271f, -0.27112624f, 0.14573358f, 0.04370196f, -0.25441590f, -0.05075996f, 0.08673707f, 
    -0.07989967f, 0.03713135f, -0.00859205f, 0.04674090f, 0.00603755f, 0.34464985f, 0.52806097f, 0.18580261f, 
    -0.13236450f, 0.07467677f, 0.12098215f, 0.06905239f, -0.03418218f, 0.07429907f, -0.00503597f, -0.07348973f, 
    -0.20198745f, 0.32438904f, 0.00163179f, 0.28488705f, 0.00826862f, 0.20760812f, -0.18103203f, 0.06708620f, 
    0.02112933f, 0.03164244f, -0.08771488f, 0.04447392f, -0.08213335f, 0.14473553f, 0.15475336f, 0.26750070f, 
    -0.09713638f, 0.06005080f, 0.12726264f, 0.05757153f, 0.00777833f, -0.01847750f, 0.00796797f, -0.07404104f, 
    -0.44070742f, 0.13542980f, 0.04217364f, 0.17517442f, -0.08340377f, 0.19119929f, 0.04935157f, -0.01701113f, 
    0.06716635f, -0.01418287f, 0.19722776f, 0.07630721f, 0.27728865f, -0.38423461f, 0.10303632f, -0.20763400f, 
    -0.09884568f, 0.11377349f, 0.05369283f, 0.00120159f, 0.11553092f, 0.00940826f, -0.37576506f, -0.18872361f, 
    0.47901216f, -0.42450738f, 0.26912519f, 0.16536269f, -0.00712433f, 0.10880874f, 0.02190897f, 0.00976707f, 
    -0.24902651f, -0.12301657f, -0.10512842f, -0.13903829f, -0.26899070f, 0.21347819f, -0.18224230f, -0.17439072f, 
    0.02561798f, -0.01681145f, 0.06594711f, 0.02952603f, -0.17003182f, -0.10205329f, -0.06669002f, -0.23597071f, 
    -0.03895410f, 0.12192790f, -0.03952249f, -0.07210162f, 0.04369773f, -0.04426550f, -0.01336120f, 0.00072953f, 
    -0.08790069f, -0.02549361f, -0.24286337f, -0.39729282f, -0.05959741f, -0.22174220f, -0.05069689f, -0.06663094f, 
    0.09059346f, -0.01410749f, -0.10186540f, -0.10656810f, 0.10670282f, 0.09015705f, 0.07086044f, -0.02985142f, 
    -0.51711047f, 0.22684421f, 0.30049646f, 0.14923772f, 0.00767151f, 0.05580117f, 0.16366571f, 0.37748912f, 
    0.19983190f, -0.10968682f, 0.16770582f, 0.14662150f, -0.00370212f, -0.11202510f, -0.08425879f, -0.03606955f, 
    -0.12543337f, 0.13494405f, 0.03336341f, -0.02709027f, 0.00540825f, 0.09414847f, -0.01226428f, 0.08136081f, 
    -0.09670347f, 0.10084270f, -0.08697669f, 0.02571176f, -0.01509897f, -0.09943347f, -0.06697498f, -0.00143953f, 
    -0.21576683f, -0.26545531f, -0.20435333f, -0.28977853f, -0.01249527f, 0.08547429f, 0.10371161f, -0.19972885f, 
    0.05689820f, 0.00334544f, -0.04624873f, 0.07070942f, -0.03564897f, -0.02879693f, -0.10826859f, -0.22120368f, 
    -0.15778595f, 0.01649190f, 0.05232922f, -0.19429269f, 0.00975005f, 0.09282141f, -0.00615666f, 0.06109290f, 
    -0.07256969f, -0.18366604f, -0.10728297f, -0.06267484f, 0.02393818f, -0.03485505f, 0.14696714f, 0.06142887f, 
    -0.13298555f, 0.01296697f, 0.08784851f, 0.02021526f, 0.15532936f, 0.03706590f, 0.17328361f, 0.01949065f, 
    -0.11668067f, -0.24971868f, -0.08500648f, 0.23323156f, -0.06557363f, 0.16788360f, -0.16873857f, 0.07754585f, 
    -0.05738686f, -0.00507719f, 0.03038540f, 0.06283350f, -0.04295723f, 0.13134679f, -0.28804341f, -0.02762827f, 
    -0.04574625f, -0.02026729f, 0.08014093f, 0.06293837f, 0.05655178f, 0.02724711f, -0.14980698f, -0.16340025f, 
    -0.12899858f, 0.12114544f, 0.19171995f, -0.01576313f, -0.02554472f, -0.08434189f, -0.03534555f, 0.04700268f, 
    -0.15541922f, -0.05493898f, 0.07714695f, -0.05944419f, 0.05551882f, -0.14386766f, 0.15910059f, -0.00114884f, 
    -0.16375655f, -0.00436068f, 0.09821872f, -0.07843089f, 0.09700160f, 0.01626390f, -0.07260427f, 0.02731615f, 
    0.05384236f, -0.36936450f, 0.06613790f, 0.11633971f, -0.10949957f, 0.10607713f, 0.04977527f, -0.02361014f, 
    -0.06345697f, -0.09324904f, -0.05779860f, -0.10328980f, 0.19094938f, 0.01893623f, -0.04695843f, -0.14167096f, 
    -0.11206597f, 0.14254534f, 0.28931019f, 0.05622543f, -0.03270570f, -0.04615847f, -0.01479543f, 0.04678627f, 
    -0.40414184f, 0.09482357f, 0.24892956f, 0.02185460f, 0.04648579f, 0.17746265f, -0.00078870f, 0.00655912f, 
    0.02013580f, -0.01154315f, 0.15323658f, 0.10975470f, 0.32899380f, -0.15017475f, 0.30181232f, -0.18355481f, 
    -0.02298406f, 0.01116845f, 0.02303829f, 0.05700360f, -0.03721946f, -0.04202014f, -0.14258195f, -0.05208397f, 
    -0.11058578f, -0.08501378f, 0.09195518f, -0.12474783f, -0.14693207f, 0.03829550f, 0.11545002f, 0.00782643f, 
    -0.12160373f, -0.07282300f, -0.15783726f, -0.11365524f, -0.05536215f, -0.28094187f, 0.11386278f, 0.17602195f, 
    0.00618561f, -0.10573936f, -0.13338110f, 0.04063140f, 0.04857929f, 0.05750048f, -0.01218695f, 0.05736291f, 
    0.46703896f, -0.22938956f, 0.51306802f, 0.21527630f, -0.02536906f, 0.21219358f, -0.05760150f, 0.18099332f, 
    -0.22259456f, 0.01506660f, 0.02320158f, -0.11470750f, 0.31375638f, -0.20972632f, 0.30393687f, 0.11040086f, 
    -0.02360916f, -0.03576117f, -0.00076521f, -0.04718913f, -0.15127873f, 0.03927761f, 0.02369567f, -0.04508246f, 
    -0.09733672f, -0.08505490f, 0.09107147f, 0.02553620f, -0.08597124f, -0.04855951f, 0.19254147f, -0.00576466f, 
    -0.06971886f, 0.01289128f, -0.11092616f, -0.04671737f, -0.18302681f, -0.28252250f, -0.10012354f, 0.08429094f, 
    -0.02048977f, -0.00919811f, 0.00160557f, 0.02266631f, -0.07309612f, 0.11451951f, -0.06529681f, -0.05181079f, 
    0.12019408f, 0.06029037f, 0.00345767f, -0.21184881f, 0.14744444f, -0.00942186f, -0.01450456f, 0.02711024f, 
    -0.03961317f, 0.09958981f, -0.03501621f, 0.03570796f, -0.43562862f, -0.37310332f, -0.27033553f, 0.13306960f, 
    -0.01374089f, -0.10206193f, -0.02488304f, -0.17381361f, 0.02961356f, -0.00715432f, 0.05316301f, -0.04760359f, 
    0.30186874f, -0.11174022f, 0.11999892f, -0.08797388f, -0.02078758f, -0.09421704f, -0.03704994f, -0.00480081f, 
    -0.05184508f, 0.11349212f, 0.01668437f, 0.05058391f, 0.25343749f, -0.01314324f, -0.07529139f, 0.23584656f, 
    -0.08512987f, 0.32919306f, -0.09830888f, 0.13925862f, -0.13256067f, 0.05360847f, 0.00579446f, 0.07036065f, 
    -0.19064486f, 0.01652157f, -0.25217944f, -0.09995246f, 0.13373956f, -0.04665313f, 0.01863436f, -0.13884784f, 
    -0.19549814f, -0.11155400f, -0.20309421f, -0.15505177f, -0.42524233f, 0.22448361f, 0.01009586f, 0.23483786f, 
    -0.08126518f, -0.02151921f, 0.14634544f, 0.07189565f, -0.11584639f, 0.10138585f, 0.03455292f, 0.08431284f, 
    0.12150129f, -0.08963322f, -0.05089327f, 0.07114889f, 0.03496417f, -0.03993572f, -0.14928596f, 0.08840657f, 
    0.04389275f, -0.05364765f, -0.09168443f, -0.23034440f, -0.34520993f, 0.03069108f, -0.30774063f, 0.37691897f, 
    0.07949857f, -0.10465913f, 0.21527112f, 0.34557435f, 0.00237950f, 0.11497861f, 0.00100736f, 0.01826816f, 
    -0.21744545f, 0.14790772f, -0.03246331f, 0.14497656f, -0.07481074f, -0.03679356f, 0.09142184f, -0.01684935f, 
    -0.10099803f, 0.05583411f, -0.01552608f, 0.02351613f, -0.10523658f, -0.01687257f, 0.17647982f, -0.01051810f, 
    0.03932320f, 0.10456827f, 0.07292317f, 0.00166073f, -0.10752147f, 0.07153190f, 0.06230178f, 0.03418696f, 
    -0.44514918f, -0.04062397f, -0.31993392f, 0.07484707f, 0.10109167f, -0.01425359f, -0.01429856f, -0.06192252f, 
    -0.04292952f, 0.04842576f, 0.09475254f, 0.06092712f, -0.15431723f, -0.04609302f, 0.31354734f, 0.14147657f, 
    -0.10320241f, -0.03076305f, 0.15199396f, 0.14068875f, -0.09415568f, 0.18966788f, -0.12613457f, -0.22196639f, 
    -0.24286960f, -0.01494108f, -0.04685513f, -0.25319302f, 0.05177695f, 0.03653299f, 0.17252029f, -0.16205706f, 
    0.01907930f, 0.02078540f, 0.05587234f, 0.11096891f, -0.17738210f, -0.06077494f, 0.05656157f, -0.17293985f, 
    -0.03230597f, -0.02163970f, -0.00087615f, -0.01376759f, -0.06086544f, 0.10341812f, 0.01423700f, 0.06451949f, 
    -0.04630195f, -0.11096887f, -0.11627926f, -0.17679349f, 0.02127401f, -0.14535475f, -0.13527820f, -0.02227335f, 
    0.00696315f, 0.06566450f, 0.02926064f, 0.00825988f, -0.29048279f, -0.42952248f, -0.11790925f, 0.39072660f, 
    0.09387027f, -0.00783273f, 0.03256822f, -0.07715430f, -0.10393835f, -0.14148307f, -0.10795897f, 0.00330396f, 
    0.14915611f, -0.25834489f, 0.23802572f, 0.09056956f, -0.04621815f, 0.05130840f, -0.07278346f, -0.00230431f, 
    0.02162214f, 0.02451502f, -0.01488516f, 0.02210981f, 0.23420162f, 0.07438394f, 0.05718312f, 0.21872914f, 
    0.13246167f, 0.04512638f, -0.05394609f, 0.03692723f, 0.01624979f, 0.00572951f, 0.00895721f, -0.13823874f, 
    -0.06450070f, -0.10993496f, -0.02624273f, 0.10624507f, 0.00928306f, 0.19835764f, -0.16937110f, 0.11044873f, 
    -0.20028965f, -0.09058213f, -0.03908139f, -0.27369118f, -0.26226935f, 0.13833421f, -0.35509753f, 0.04484183f, 
    -0.09479906f, 0.06870583f, -0.02342716f, 0.00161517f, -0.01966390f, 0.02441593f, 0.08087200f, -0.14391130f, 
    0.24304847f, 0.09568474f, 0.27310133f, -0.13806130f, 0.04471476f, -0.00638544f, 0.00887141f, 0.03932066f, 
    0.00297432f, 0.00531237f, 0.15235433f, 0.16713184f, -0.13463369f, 0.42188382f, -0.38053295f, 0.11292992f, 
    -0.01216577f, 0.07080863f, 0.07451694f, 0.02036374f, -0.08888467f, 0.03046052f, 0.08334988f, 0.03002066f, 
    -0.08868965f, 0.00500541f, 0.03152986f, 0.12860572f, 0.06719102f, -0.01923289f, 0.03032575f, 0.09627439f, 
    0.02914871f, -0.02208923f, 0.08404750f, 0.09361319f, 0.14081389f, -0.11805678f, 0.12036911f, -0.30614012f, 
    -0.11806911f, -0.03048280f, -0.09979932f, -0.05367786f, 0.02204190f, -0.05128705f, -0.11254629f, -0.09772974f, 
    -0.01780664f, -0.31796667f, 0.01414353f, -0.31049645f, 0.00245626f, -0.09209698f, -0.34317479f, 0.04074932f, 
    -0.08996014f, 0.06138740f, 0.06287922f, 0.00719429f, -0.11864213f, 0.09815719f, -0.06206146f, -0.00235280f, 
    0.11615461f, 0.00960749f, 0.10683304f, -0.02566082f, 0.04948488f, 0.00171588f, 0.03991078f, -0.04581284f, 
    -0.23576623f, -0.08941084f, -0.23849142f, -0.13518943f, -0.06241505f, -0.02171632f, -0.06329937f, 0.02611504f, 
    -0.07611748f, 0.00343918f, 0.12543203f, -0.02209805f, 0.16904053f, 0.15604436f, 0.11733051f, -0.62343866f, 
    0.02138217f, -0.17210782f, 0.15199925f, 0.01733032f, 0.03972525f, 0.04858774f, 0.11422702f, -0.02795498f, 
    0.17600855f, -0.20701212f, 0.15114555f, 0.08531092f, 0.18243331f, 0.10305335f, -0.05755438f, 0.07403642f, 
    0.00690877f, 0.05922109f, -0.07722540f, -0.14581281f, -0.28002378f, -0.46465120f, -0.01359688f, 0.05229051f, 
    -0.00733217f, 0.01823881f, -0.04572582f, -0.13606843f, 0.04113375f, 0.07909457f, -0.07927027f, 0.04244568f, 
    0.20575880f, 0.25029954f, -0.08328493f, 0.07085785f, -0.07584514f, -0.00700649f, 0.03249479f, 0.01703575f, 
    -0.08174708f, -0.00367624f, -0.13221927f, -0.01690534f, 0.07809664f, 0.00826586f, 0.25483608f, 0.18409754f, 
    0.02061302f, -0.10582131f, 0.01228484f, -0.00729890f, 0.02402333f, 0.00195607f, 0.00485447f, -0.04603593f, 
    0.28711861f, 0.18398345f, 0.00299190f, 0.00350874f, 0.06371173f, -0.05987815f, -0.00654088f, 0.17824967f, 
    -0.05316601f, 0.05431799f, 0.01127012f, 0.01967861f, -0.23092043f, 0.09296890f, 0.04690098f, 0.00042036f, 
    -0.08464307f, -0.02501731f, 0.01039898f, -0.07169836f, 0.05341977f, -0.08624025f, -0.00094133f, 0.05639977f, 
    -0.19662279f, -0.14888285f, -0.01400627f, -0.02323356f, -0.24149194f, -0.11222818f, -0.17021090f, -0.20850530f, 
    0.02757112f, 0.03165467f, -0.09915389f, -0.14929810f, 0.33329317f, 0.01793397f, 0.32380340f, 0.08423810f, 
    -0.06255428f, 0.21934035f, -0.00603677f, 0.04422906f, 0.02708840f, -0.03402326f, 0.15354675f, -0.00454975f, 
    -0.73995769f, -0.07629663f, -0.48283213f, 0.28810820f, -0.06104138f, -0.05996441f, 0.12167594f, 0.33501124f, 
    -0.13944848f, -0.00017228f, -0.03888883f, -0.01235988f, -0.32978478f, -0.16924663f, -0.07130637f, 0.15771888f, 
    0.08561790f, 0.05082427f, 0.00057624f, 0.03003350f, 0.02927467f, -0.14988866f, -0.02854078f, 0.01919418f, 
    -0.00788812f, -0.19683939f, 0.06329326f, 0.19319767f, -0.03213739f, 0.00715242f, -0.08829597f, -0.07514215f, 
    0.06504116f, -0.00340125f, 0.07497615f, -0.04978462f, 0.03504426f, -0.15006891f, 0.02847480f, -0.34195736f, 
    -0.00112373f, -0.04133230f, 0.03343619f, -0.09728762f, 0.14694373f, 0.03090159f, -0.10264684f, 0.08211199f, 
    -0.21352884f, -0.03776911f, 0.12316872f, -0.09035856f, 0.00992023f, 0.11641321f, 0.00548601f, -0.05029723f, 
    -0.00460787f, -0.07888533f, 0.05324164f, 0.00092548f, -0.14434302f, 0.06187749f, -0.01354596f, -0.09755968f, 
    0.05756466f, 0.02016054f, -0.02502344f, 0.05509508f, 0.02155791f, 0.01859450f, 0.19863650f, -0.01261713f, 
    0.02589303f, 0.06151975f, -0.17749909f, 0.13425076f, 0.02709552f, -0.04090165f, 0.13944374f, 0.00755790f, 
    -0.04286957f, 0.02331885f, 0.03475020f, 0.24424562f, 0.23209302f, 0.06681102f, 0.43204778f, 0.28005245f, 
    -0.02395817f, -0.16974717f, -0.03048499f, -0.14287937f, -0.01421114f, -0.07436788f, 0.01658535f, 0.01050408f, 
    0.20829862f, -0.18947865f, 0.42923611f, 0.06193606f, 0.16088119f, -0.10889301f, 0.09593181f, -0.16888711f, 
    -0.13733774f, 0.08278520f, -0.10171901f, -0.00637016f, 0.08158599f, -0.35055798f, 0.14265339f, -0.12985714f, 
    -0.17507781f, -0.24947590f, -0.02530266f, -0.09558465f, 0.02311116f, 0.03634301f, -0.01398382f, 0.02568661f, 
    -0.07513002f, -0.00554166f, -0.11838963f, 0.06404147f, -0.01732342f, 0.06177472f, 0.02922657f, 0.12385115f, 
    -0.16101374f, 0.10219705f, 0.22200963f, -0.00754183f, -0.17911527f, -0.27999696f, -0.31427988f, -0.08001988f, 
    0.05165958f, -0.18317457f, 0.01461348f, 0.06947178f, 0.14599159f, 0.12583435f, 0.03999142f, -0.00441626f, 
    -0.07726348f, -0.03995536f, -0.18408215f, 0.02764685f, 0.05427726f, -0.07156397f, 0.09301330f, 0.00335945f, 
    0.21606861f, 0.00131051f, 0.12764907f, 0.13817248f, 0.02551640f, -0.13448009f, 0.02286413f, -0.09382832f, 
    0.10223020f, 0.01769164f, 0.11512376f, -0.00582918f, -0.08966707f, -0.14261697f, -0.13319577f, -0.14482449f, 
    0.05275213f, 0.25432590f, 0.19761935f, 0.08797201f, -0.22151086f, -0.07967412f, -0.09006874f, 0.03770135f, 
    -0.04812337f, 0.02678175f, -0.00090464f, -0.06275645f, -0.17930067f, 0.31718266f, -0.33649102f, -0.27357432f, 
    -0.04701393f, -0.24162251f, 0.05595684f, 0.01977759f, -0.03875276f, 0.05891090f, -0.02057989f, 0.04755108f, 
    -0.23452103f, 0.37955552f, -0.28989631f, 0.08781022f, 0.03275253f, 0.01503080f, 0.10537782f, -0.04852853f, 
    -0.17732312f, 0.03260908f, 0.02594499f, 0.16039678f, 0.01750773f, -0.12948824f, 0.03138570f, -0.07571799f, 
    -0.03940625f, -0.03307842f, -0.07056011f, 0.01527470f, -0.12219793f, -0.05339630f, -0.00895963f, -0.08346169f, 
    -0.11176543f, 0.15604717f, 0.02208326f, 0.15971299f, -0.08680882f, 0.10457568f, 0.01026462f, 0.08503204f, 
    0.00835189f, 0.04371483f, 0.09667781f, -0.03622649f, 0.04247722f, -0.17055531f, 0.04566461f, -0.16411360f, 
    0.00007053f, -0.16945651f, 0.00114066f, -0.00429248f, -0.00884080f, 0.09917140f, 0.01984999f, -0.17535590f, 
    -0.34518492f, -0.07230198f, -0.07310741f, 0.08083898f, 0.22713628f, -0.08938801f, 0.29455709f, -0.07841858f, 
    -0.07407832f, -0.00828477f, -0.01850462f, 0.10555777f, -0.26749682f, 0.02657319f, -0.09507545f, 0.07844014f, 
    -0.06273335f, -0.00677802f, 0.06207377f, -0.07396908f, -0.05410369f, 0.06885307f, -0.04023313f, 0.00914320f, 
    0.21325810f, 0.04181268f, 0.09858450f, -0.06632322f, 0.04181413f, 0.02683710f, -0.03465799f, 0.11439973f, 
    -0.00011448f, 0.06836095f, 0.11468136f, 0.02208799f, 0.27750191f, -0.19884567f, 0.30612803f, -0.08093940f, 
    -0.06782409f, -0.01224260f, -0.09929077f, 0.10236745f, -0.01327596f, 0.02128438f, -0.04822918f, -0.01255484f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.16472031f, 0.10981020f, 0.05278336f, -0.10695218f, -0.10113455f, 0.08132085f, 0.00263288f, -0.14376953f, 
    0.04109202f, 0.01190136f, 0.05275173f, -0.01659811f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
