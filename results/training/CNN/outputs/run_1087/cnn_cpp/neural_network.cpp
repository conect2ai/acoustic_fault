#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.29705250f, -1.03316188f, -0.62809372f, 0.55791777f, 0.85926563f, 0.66773075f, -0.04777892f, -0.39092413f, 
    -0.29733148f, -0.28999588f, 1.13633680f, -0.47809824f, -0.48116586f, -0.14858085f, 0.29900578f, 0.82524008f, 
    -0.10941730f, -0.06352179f, 0.46463445f, 1.08159101f, -1.06536877f, -0.75944555f, -0.95562828f, -0.43977118f, 
    -0.15552418f, 0.13428369f, 0.20341466f, -1.02715456f, -0.54019326f, -0.29822868f, 1.11795580f, 0.12009750f, 
    -0.75333691f, -0.17268875f, -0.58994901f, -0.28130412f, -0.30436686f, 0.33245170f, 1.08327031f, 0.52162600f, 
    0.70880324f, -0.60090518f, -0.30642846f, -0.37002224f, 0.08212995f, -1.54550385f, 1.15784907f, -0.61261642f, 
    -0.65993494f, -0.01299242f, -0.18932706f, -0.25263011f, -0.10925461f, -0.22251676f, -0.89831412f, -0.04951849f, 
    -0.00025557f, -0.51156229f, 0.09460589f, -0.79093254f, 0.27306488f, 0.17057461f, 0.82547319f, 0.86467922f, 
    0.22649467f, -0.41602194f, 0.11844453f, 0.58788794f, -0.58444870f, 0.45490098f, 0.44630772f, 0.51908374f, 
    -0.66516209f, -0.25300902f, 0.19748485f, -0.58321637f, -0.95748967f, -0.51487279f, -0.25722817f, 1.07633173f, 
    -0.23448142f, -0.14588572f, 0.78236264f, -0.20321949f, 0.08439506f, -0.60468608f, 0.87251413f, 0.30193305f, 
    -0.53788096f, -0.24059972f, 0.33695120f, 0.11633394f, 0.54684621f, 0.89120716f, -0.88989329f, -0.31155449f, 
    -0.22656703f, -0.37249732f, -0.22125116f, 0.76668578f, 0.19510984f, 0.12202671f, -0.86075431f, -0.32033247f, 
    -0.31232539f, -0.23679811f, 0.48199487f, 0.51804996f, -0.92904079f, -0.87950456f, -0.58202463f, -0.32568079f, 
    -0.25115284f, -0.23711933f, 0.37005246f, -0.26370767f, -0.04106684f, 0.70898074f, 0.64883775f, 0.42928949f, 
    0.02848098f, -0.29571500f, 0.13595669f, 0.01977425f, 0.78175622f, -0.71778303f, -0.53566736f, 0.07696289f, 
    0.07010142f, 0.74469578f, 0.76796937f, 1.09404433f, -0.12637258f, 0.18957557f, 0.25523198f, 0.27980125f, 
    -0.13003992f, -0.88656723f, -0.21914464f, 0.53091878f, -0.73869270f, -0.40471712f, -0.49033782f, -0.48134083f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.11915801f, 0.49541855f, -0.00294135f, -0.24933751f, 0.66552502f, 0.71605647f, 0.38178277f, 0.36667877f, 
    -0.02414671f, 0.24816072f, -0.14684005f, 0.65246797f, -0.27187160f, 0.17898734f, 0.01010228f, 0.52984667f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.80392760f, -0.09550067f, 0.08205719f, 0.02611191f, 0.08032390f, -0.24653004f, 0.06187424f, 0.09407932f, 
    0.08158097f, 0.76389420f, -0.07204414f, 0.06622651f, 0.11467290f, 0.17157270f, 0.22426714f, 0.11425580f, 
    0.02136557f, 0.29345092f, 0.05109779f, -0.31352332f, -0.40331581f, -0.17966436f, 0.16965190f, -0.03555404f, 
    0.06183926f, -0.04782578f, -0.07756399f, 0.02470803f, -0.37818345f, 0.01623981f, -0.28298444f, 0.04009294f, 
    -0.16320080f, 0.01605546f, -0.08808002f, 0.12222210f, 0.35810834f, 0.19279784f, 0.18599242f, -0.23715198f, 
    0.15247759f, 0.05246624f, -0.01222865f, 0.17309558f, 0.12153536f, 0.27162543f, -0.42020836f, -0.59825486f, 
    0.00960295f, 0.06186063f, 0.09221917f, 0.00919644f, -0.01298408f, 0.22164688f, -0.58279198f, -0.12523322f, 
    0.12218832f, 0.15051174f, 0.06859209f, -0.08917532f, 0.18479390f, -0.07679223f, -0.08744190f, 0.03818639f, 
    0.37663755f, -0.04488661f, 0.08246741f, 0.07272631f, 0.18285464f, -0.03045246f, 0.02392463f, 0.08681775f, 
    -0.42163453f, -0.82818145f, -0.06725518f, 0.01995549f, -0.07189095f, -0.08829989f, -0.07090937f, -0.08292480f, 
    -0.13575774f, 0.09315000f, 0.39782020f, 0.23592164f, 0.22398727f, -0.13200778f, 0.04207949f, 0.05529225f, 
    0.16122839f, 0.30620363f, 0.31088069f, 0.35851443f, 0.06063410f, 0.11600757f, 0.23320435f, -0.07184739f, 
    0.30565926f, -0.00181215f, 0.19729145f, 0.33909553f, -0.12688784f, -0.40144381f, 0.13809191f, -0.03948429f, 
    -0.08522394f, 0.05082818f, 0.12349825f, 0.07469098f, -1.03627419f, 0.33989471f, -0.05453935f, -0.10617276f, 
    0.26478904f, -0.01607145f, -0.19935860f, -0.09674855f, -0.00769414f, 0.24408846f, -0.07487106f, -0.07164624f, 
    0.08867770f, -0.00567073f, -0.07053811f, 0.09895027f, -0.08967727f, 0.12835351f, -0.16490546f, 0.02202288f, 
    -0.09268179f, -0.30800885f, -0.09211515f, -0.26847422f, -0.05299289f, -0.09065905f, 0.00852506f, -0.48666567f, 
    -0.18702759f, -0.05916430f, 0.05076062f, 0.26961789f, -0.14254896f, -0.03304141f, 0.01297886f, 0.34268963f, 
    -0.25337270f, -1.06706083f, -0.70856214f, 0.01102210f, -0.15740667f, -0.13319464f, 0.08347914f, -0.23603265f, 
    -0.00616295f, -0.19133818f, 0.03018478f, -0.06962465f, 0.15179875f, -0.02913098f, -0.11022537f, -0.17610735f, 
    0.31044617f, -0.15533581f, -0.28473595f, -0.30661893f, -0.13645948f, -0.01474585f, -0.20114072f, 0.03221427f, 
    -0.06107832f, 0.03357543f, -0.01967881f, -0.15688635f, 0.15063471f, -0.32471946f, -0.23072170f, 0.08927440f, 
    -0.06462403f, 0.24772426f, 0.03088263f, 0.13423747f, 0.24106634f, 0.21763682f, 0.30790520f, 0.14403683f, 
    -0.08281851f, 0.09914181f, 0.00200743f, -0.11325852f, -0.03534478f, -0.25588220f, -0.13819149f, -0.68952316f, 
    0.00332877f, -0.08311369f, 0.08567081f, 0.11078805f, 0.03472259f, -0.02538500f, -0.26442423f, -0.31950963f, 
    -0.32021841f, 0.21609108f, 0.12358323f, 0.15683703f, 0.05654060f, -0.23419796f, 0.05209336f, 0.25480601f, 
    0.12648070f, -0.04646932f, -0.08743203f, 0.10225032f, 0.06638329f, 0.23542844f, 0.00184118f, -0.26065725f, 
    0.05770067f, -0.09472802f, 0.04257054f, -0.00335894f, 0.02846147f, -0.05085175f, 0.00277116f, 0.07704204f, 
    0.04167270f, 0.06613894f, 0.14829914f, 0.35131577f, 0.03829086f, 0.03714946f, -0.09560147f, -0.07324485f, 
    0.03758408f, 0.01615220f, 0.22094776f, -0.04117605f, 0.07239098f, 0.11017995f, 0.02025358f, 0.03402750f, 
    -0.01377143f, 0.11177927f, 0.18306088f, 0.52146626f, 0.38055706f, 0.44701180f, 0.01672822f, 0.24754500f, 
    0.14197697f, 0.05071857f, -0.06803857f, 0.13635670f, 0.35612568f, -0.05246226f, -0.80613095f, -0.13302250f, 
    0.13414750f, 0.04799955f, 0.12944463f, 0.02811047f, 0.06068037f, 0.23191358f, 0.16482505f, 0.28545073f, 
    0.05934635f, -0.02273794f, -0.03084607f, -0.03237293f, 0.20286842f, 0.07399473f, 0.05343521f, -0.22326013f, 
    0.00869810f, -0.28868964f, -0.11980584f, -0.34794280f, -0.05519586f, -0.23146267f, 0.04015534f, -0.00178084f, 
    -0.12284653f, -0.20949014f, -0.12493762f, 0.12762471f, 0.07713802f, 0.19098885f, 0.02162759f, 0.00189825f, 
    -0.04787690f, -0.07323879f, 0.10252336f, -0.09108197f, -0.00421232f, -0.07444707f, 0.01523698f, -0.12734085f, 
    -0.07028959f, 0.02938112f, 0.03545712f, -0.00710762f, 0.02841075f, 0.04655402f, -0.03883519f, -0.04771652f, 
    -0.04197115f, -0.02708844f, -0.01188361f, -0.08140560f, 0.05017393f, 0.07008263f, -0.07798830f, -0.09493839f, 
    -0.01127984f, -0.09559344f, 0.03325710f, 0.03157541f, 0.02278716f, -0.00599079f, -0.04225814f, -0.03839123f, 
    -0.03209421f, 0.06718742f, 0.04792337f, -0.03484307f, -0.05955833f, 0.03190541f, -0.08420082f, -0.01514244f, 
    0.04594048f, -0.01995561f, 0.04634629f, -0.08419322f, 0.00319860f, -0.08414295f, -0.00909174f, -0.07215656f, 
    0.07433722f, 0.07737502f, -0.04573347f, -0.02749482f, 0.00453046f, 0.03580595f, -0.02217534f, -0.04401329f, 
    -0.03488747f, -0.02233004f, -0.05511143f, -0.07344802f, -0.04714236f, -0.11231636f, -0.09409779f, -0.06265810f, 
    -0.04477005f, 0.04986752f, 0.05908524f, -0.04934929f, 0.00689193f, -0.07483322f, -0.01188397f, -0.00642791f, 
    0.01076608f, -0.06063339f, 0.00051252f, -0.02234567f, 0.04334123f, -0.03797312f, -0.05148239f, -0.05898529f, 
    -0.05413915f, -0.01614975f, -0.06492966f, 0.05875584f, -0.06010326f, -0.08217281f, -0.08564285f, 0.06597164f, 
    0.03291903f, 0.02840748f, 0.02527831f, -0.02686191f, -0.03486220f, 0.04701696f, -0.04916390f, -0.01102292f, 
    -0.07246008f, -0.06220730f, -0.06949812f, -0.06783255f, -0.09193601f, 0.01935324f, -0.08508586f, -0.02183688f, 
    0.02106162f, -0.04526313f, 0.06365035f, -0.06621359f, -0.09756812f, -0.07257387f, 0.02455855f, -0.03460164f, 
    -0.04281185f, 0.05245811f, -0.01297219f, -0.00501942f, -0.07084423f, -0.06096737f, 0.00010321f, 0.01979877f, 
    0.03024271f, -0.03335531f, 0.02587281f, -0.05678494f, -0.00468803f, -0.08785615f, -0.03812487f, 0.06771303f, 
    -0.05456453f, 0.05311174f, 0.00175332f, 0.06072099f, 0.05583842f, 0.04566618f, 0.04853724f, 0.04926854f, 
    -0.05271669f, -0.07064052f, -0.05269140f, -0.03946308f, -0.02925512f, -0.00307848f, 0.01822473f, 0.04244831f, 
    -0.13652095f, 0.02960299f, 0.04317658f, 0.16440254f, -0.25375494f, 0.01361411f, -0.28497761f, -0.30224085f, 
    -0.14785525f, 0.18550208f, 0.12859504f, 0.23036273f, 0.32282689f, 0.12442686f, 0.28129357f, 0.07222211f, 
    0.15396571f, 0.23611987f, 0.13011099f, -0.05716727f, -0.21032079f, 0.18417953f, 0.10332277f, 0.27559531f, 
    0.06136042f, 0.39263061f, -0.20058669f, -0.09505820f, 0.03535164f, 0.13250832f, 0.08852450f, 0.07944059f, 
    -0.13466638f, -0.41269606f, -0.26838133f, -0.11955821f, -0.04962095f, 0.16927490f, 0.09366781f, 0.13092197f, 
    0.08573318f, 0.11093667f, 0.21259108f, 0.17898253f, -0.22625719f, -0.02636276f, 0.10928153f, 0.39607123f, 
    0.27551374f, 0.10952597f, 0.14936194f, 0.02370194f, -0.03819900f, 0.00187323f, 0.10854172f, 0.21590865f, 
    0.24964881f, -0.22370693f, -0.15114775f, 0.12238427f, 0.26392508f, 0.14120863f, 0.23213892f, -0.10630315f, 
    -0.02379692f, 0.08622193f, 0.04064431f, 0.05520306f, 0.20758520f, 0.10568948f, 0.12411116f, 0.36636543f, 
    -0.30167541f, -0.20804237f, -0.10808957f, -0.18641761f, -0.01061023f, 0.07960620f, 0.28218126f, 0.17614980f, 
    0.05116098f, 0.23021267f, -0.04227029f, -0.04814237f, 0.03946590f, 0.34495643f, 0.16738714f, -0.23198581f, 
    -0.08560668f, -0.02387684f, -0.19203293f, -0.10645700f, 0.05053589f, -0.28323704f, -0.04833969f, -0.02490093f, 
    -0.25414357f, -0.40193757f, -0.41588271f, 0.33319110f, -0.18524046f, 0.28243503f, 0.36851510f, 0.18087819f, 
    0.03765788f, 0.32100156f, 0.08017703f, 0.34923205f, -0.49766380f, 0.04326043f, 0.10525125f, -0.21410529f, 
    -0.14972404f, 0.09957033f, -0.12656432f, 0.17210761f, -0.15397386f, -0.10248434f, 0.20687221f, 0.20130223f, 
    -0.01533150f, -0.02284826f, 0.13016419f, -0.05660366f, 0.00615289f, 0.04003473f, -0.18049078f, -0.10357345f, 
    -0.28836977f, 0.15899143f, 0.25396785f, 0.03349714f, -0.00430407f, 0.00622186f, -0.13252266f, 0.09330428f, 
    0.12396405f, -0.12211543f, 0.11295415f, 0.04669550f, 0.02263336f, -0.20575567f, -0.04425027f, -0.00988651f, 
    0.02309637f, -0.25365284f, -0.25057152f, -0.26358691f, 0.06747372f, -0.19667323f, -0.07749525f, -0.31155306f, 
    -0.19298770f, 0.19430490f, -0.05321975f, 0.06006929f, -0.13415748f, -0.01997380f, -0.07590586f, 0.05815347f, 
    0.34121093f, 0.42688078f, -0.89448243f, -0.24574418f, -0.09301408f, 0.21580087f, 0.05305763f, 0.29025427f, 
    -0.03331125f, -0.03604058f, 0.12262663f, -0.05984695f, 0.08845007f, -0.59105867f, -0.05352864f, -0.16121879f, 
    -0.04380884f, -0.19860034f, -0.03844808f, -0.15305161f, -0.24121910f, 0.23529589f, 0.13314293f, -0.05664446f, 
    0.12202100f, -0.03985413f, -0.08091961f, 0.03641953f, -0.21202259f, 0.93724823f, 0.17983209f, -0.03736341f, 
    0.10437866f, 0.14143957f, 0.14289171f, -0.06294675f, 0.03594818f, -0.18505049f, 0.23427552f, -0.08213960f, 
    -0.05164218f, -0.11405344f, -0.03203348f, 0.21717180f, 0.30917969f, 0.19009081f, 0.26354003f, -0.17371061f, 
    -0.00383045f, -0.04549699f, 0.00216052f, -0.19998397f, 0.05006548f, 0.11532697f, 0.24260852f, 0.11114446f, 
    0.35032797f, -0.10673452f, -0.30655423f, 0.22549075f, -0.01412371f, 0.07828027f, 0.18324062f, 0.03292670f, 
    0.18961929f, -0.01904465f, 0.02144970f, 0.17817874f, 0.05705565f, 0.00368613f, -0.03409291f, -0.13786420f, 
    -0.03015494f, -0.26709801f, -1.31531966f, -0.21828696f, 0.12168977f, 0.02541632f, 0.10649040f, 0.08399437f, 
    0.15009679f, 0.01758696f, -0.04891409f, -0.01525703f, -0.04295638f, 0.10853101f, -0.07185652f, 0.20479125f, 
    0.05486439f, 0.18443675f, 0.29939163f, 0.33558816f, 0.15930624f, -0.13897833f, 0.11621659f, -0.21359317f, 
    -0.11971755f, 0.02165277f, 0.02538308f, 0.09659886f, 0.05051373f, -0.41184846f, -0.14089537f, 0.21478719f, 
    -0.08265641f, -0.06045702f, -0.04312430f, 0.03806222f, 0.13572782f, 0.01815146f, -0.27462634f, -0.20781903f, 
    0.03369271f, 0.11972327f, 0.14721473f, 0.07455031f, -0.00872780f, -0.03993973f, 0.11107019f, 0.16878593f, 
    0.06663103f, -0.04936465f, -0.18015949f, -0.06607417f, 0.03328316f, -0.04012664f, -0.05296680f, -0.08647261f, 
    -0.75786191f, -0.17127518f, -0.24959835f, 0.13352862f, 0.00489820f, -0.11334282f, -0.33436230f, -0.01099252f, 
    -0.15419430f, -0.18834330f, -0.01501636f, -0.29141164f, -0.18089083f, -0.37299517f, 0.54801315f, 0.00577081f, 
    0.27287346f, -0.02152576f, -0.09994613f, -0.00296088f, -0.42197287f, 0.02715071f, -0.16376814f, 0.19340697f, 
    0.05325947f, -0.11449667f, 0.05478546f, -0.53613073f, -0.16804883f, 0.40831047f, 0.10552414f, 0.08763227f, 
    -0.41488394f, -0.08193289f, 0.11904296f, 0.01575595f, -0.26348943f, 0.02176267f, 0.22995707f, -0.02402228f, 
    0.07740057f, -0.27943996f, 0.17051987f, 0.12929039f, -0.04686331f, -0.36028540f, 0.19311404f, 0.01041632f, 
    -0.12735158f, 0.07446349f, 0.27976382f, 0.04868282f, 0.00546287f, 0.08729973f, -0.38077435f, 0.14466783f, 
    0.42540899f, 0.25607648f, 0.18948802f, -0.17180799f, 0.12621675f, 0.07433750f, 0.03871848f, -0.00387811f, 
    -0.00889534f, -0.07210509f, 0.11651741f, 0.12445132f, 0.06629011f, 0.18722303f, 0.29868239f, 0.09836096f, 
    -0.13364631f, -0.00837255f, 0.45683482f, 0.07173854f, -0.07028513f, -0.35403121f, 0.12567820f, 0.14691997f, 
    0.11473120f, -0.06001318f, 0.39639071f, 0.15807712f, -0.08538056f, -0.34852386f, 0.25819582f, -0.07069907f, 
    0.08768237f, 0.18909515f, -0.26026121f, -0.06159930f, 0.60689735f, -0.22455738f, -0.19385256f, -0.32742569f, 
    0.00633170f, -0.20635679f, -0.05441992f, 0.42066613f, 0.16156049f, 0.27780652f, 0.02312368f, 0.09588443f, 
    0.18073624f, 0.10851712f, 0.23062728f, 0.09093510f, -0.39982313f, 0.24065204f, -0.00405689f, -0.18190612f, 
    -0.00476383f, -0.15152866f, -0.10459770f, 0.10214301f, 0.06422455f, 0.16921307f, 0.31255805f, 0.57293159f, 
    0.01562085f, -0.10471720f, -0.21942160f, 0.11443689f, 0.15158030f, 0.11079569f, -0.10684466f, -0.11641189f, 
    -0.12891750f, -0.13691370f, -0.04576860f, -0.23246925f, -0.05439311f, -0.07334248f, -0.06130810f, 0.02379613f, 
    0.06481740f, 0.05576241f, 0.06341656f, 0.02258030f, -0.20040886f, -0.09001970f, 0.00286115f, -0.18226144f, 
    -0.11806184f, -0.34923559f, 0.29066378f, 0.04956565f, 0.03047075f, -0.19471601f, -0.08373577f, -0.10721376f, 
    0.10001060f, -0.33392233f, 0.11765182f, -0.58138084f, 0.10299481f, 0.07639002f, 0.27127129f, 0.19617625f, 
    0.18982171f, 0.01870727f, 0.19367315f, -0.12023951f, -1.30714881f, -0.12898862f, -0.08360481f, -0.03244681f, 
    -0.01128367f, -0.03531902f, -0.03543805f, -0.14852917f, -0.03136156f, -0.24704121f, -0.36660540f, -0.16985336f, 
    -0.15009139f, 0.10211118f, 0.12411504f, -0.08046021f, -0.56308359f, -0.02403927f, 0.31390363f, 0.04990042f, 
    -0.07837874f, -0.05826462f, 0.10365031f, 0.12132844f, 0.13141151f, -0.58957952f, 0.22787894f, -0.19464152f, 
    0.18079215f, 0.20503059f, 0.19251432f, 0.19050984f, 0.06697650f, 0.13677742f, -0.45507482f, -0.06150838f, 
    0.09171382f, 0.09968647f, -0.02014973f, -0.05922548f, 0.11166082f, 0.03088388f, 0.10138208f, 0.22912887f, 
    0.04097918f, -0.00494780f, -0.02408396f, -0.09273875f, 0.14945489f, 0.14807555f, 0.18661544f, 0.02863173f, 
    -0.24011917f, -0.10762465f, 0.03696663f, -0.38642463f, -0.10130920f, -0.18138775f, -0.00977569f, 0.05095922f, 
    -0.03143502f, -0.14252841f, -0.40647632f, 0.07397798f, -0.12088525f, -0.07922911f, 0.10945107f, 0.24058168f, 
    0.03622454f, 0.20837528f, -0.49611455f, -0.53238857f, -0.04883544f, 0.01366441f, -0.09855590f, -0.12565114f, 
    0.00947483f, -0.15329604f, 0.02026205f, 0.64342535f, -0.20016105f, -0.27707446f, 0.27282193f, 0.22813253f, 
    0.21320774f, -0.02871064f, 0.04560233f, 0.10259893f, -0.12564348f, 0.01235625f, 0.58322680f, 0.33291876f, 
    -0.00740524f, -0.05183636f, -0.09643092f, 0.04679612f, -0.09745197f, 0.06300816f, -0.34623682f, -0.39677933f, 
    -0.15693803f, 0.15208627f, -0.08281616f, -0.11176841f, 0.00689073f, -0.01564529f, -0.33653513f, 0.22187413f, 
    0.12141757f, -0.06079190f, -0.12812480f, -0.14906481f, 0.10519381f, 0.18181810f, 0.14125746f, 0.18315449f, 
    -0.17964959f, -0.10793620f, 0.05339089f, 0.20828387f, 0.32491216f, 0.21067388f, 0.02677407f, 0.18331616f, 
    -0.12161507f, -0.71350127f, -0.31403172f, 0.13118660f, -0.02327851f, 0.12831312f, -0.03563271f, 0.11084054f, 
    -0.08547469f, 0.06558919f, -0.09686210f, -0.34919611f, 0.17984705f, 0.15194325f, 0.19065911f, -0.03185839f, 
    0.35422102f, 0.09107166f, 0.40688851f, 0.22988045f, -0.43646827f, -0.03736908f, 0.04585551f, -0.09395090f, 
    -0.02122483f, -0.08304314f, -0.14503676f, 0.06660175f, 0.01652295f, 0.17527951f, 0.01621927f, 0.00328265f, 
    -0.05275240f, 0.18545626f, -0.15786247f, 0.17934594f, -0.20833674f, -0.41436836f, -0.34076628f, 0.09087944f, 
    0.09734622f, -0.06513565f, 0.23970191f, 0.08913881f, -0.10015780f, -0.28942442f, 0.10961565f, 0.26918489f, 
    -0.13743708f, -0.04705624f, 0.22455041f, 0.12648726f, -0.03848556f, -0.06075688f, 0.15708347f, 0.29317182f, 
    0.54744726f, -0.09719283f, -0.17495297f, -0.11376113f, 0.16161636f, -0.10120720f, 0.11983572f, -0.25119537f, 
    0.04176741f, -0.35356870f, 0.02822399f, -0.00116774f, 0.17614990f, 0.30088297f, 0.04759731f, 0.10834042f, 
    0.10291146f, 0.43204921f, 0.83397216f, -0.12654415f, 0.05927619f, -0.00318580f, 0.05084164f, 0.20884833f, 
    0.12491339f, 0.04142979f, 0.08970735f, -0.57268840f, -0.04852578f, -0.25039151f, -0.07036775f, 0.01330063f, 
    0.17897601f, 0.11518196f, -0.25147623f, -0.21118346f, -0.51022780f, -0.07891107f, -0.06843872f, -0.12253952f, 
    0.11728494f, -0.01025266f, -0.04176110f, -0.24539627f, -0.34563670f, 0.00727751f, -0.00761329f, 0.07421431f, 
    0.02171692f, 0.01650187f, -0.16011612f, 0.18109536f, 0.22867416f, 0.15792425f, 0.41005975f, 0.19499840f, 
    0.04527963f, 0.42869136f, 0.06202988f, 0.05479353f, 0.04255279f, -0.25025234f, -0.32613292f, 0.02865725f, 
    0.12732688f, 0.15161875f, -0.17125852f, -0.11429233f, -0.06161261f, 0.11394340f, 0.16997975f, -0.37944075f, 
    -0.36298543f, -0.02269028f, 0.00624630f, 0.15883255f, 0.12818515f, 0.18522717f, 0.26308185f, 0.20629536f, 
    0.41694447f, 0.29162306f, 0.09226792f, -0.07526685f, 0.03792880f, -0.08198431f, 0.04913720f, -0.09867129f, 
    -0.59595501f, -0.24865581f, -0.20694619f, 0.06992268f, -0.00902910f, 0.17861716f, 0.11552933f, 0.18710914f, 
    0.17253692f, 0.28759241f, 0.12701322f, -0.01956338f, -0.16400470f, 0.11454108f, -0.12348484f, 0.21393104f, 
    0.00194912f, 0.08210754f, 0.44465610f, 0.10245656f, -0.08148708f, 0.00417294f, 0.01851629f, -0.10121603f, 
    0.04464488f, -0.07839412f, -0.03859683f, -0.38951740f, -0.21235788f, -0.12788978f, 0.20684440f, 0.04424123f, 
    -0.14255138f, 0.16634627f, 0.04220233f, 0.18057396f, 0.29416111f, -0.05233984f, -0.13584669f, 0.21891369f, 
    0.14535460f, 0.16257317f, 0.09344356f, 0.02981853f, -0.02207168f, 0.35260409f, 0.20763871f, 0.25512037f, 
    0.09725361f, 0.10441860f, 0.22839080f, 0.09474975f, 0.09251966f, 0.42783248f, 0.02969360f, -0.04532860f, 
    -0.11570198f, -0.07210530f, 0.08503740f, 0.16795166f, 0.04868485f, -0.06864262f, -0.29156250f, 0.02975173f, 
    0.25420988f, 0.10662823f, 0.10391568f, 0.01526757f, -0.05658835f, -0.13320145f, -0.21018121f, -0.22705588f, 
    0.19311845f, -0.18435797f, -0.06799386f, 0.36454639f, 0.05818245f, 0.18714818f, -0.12786052f, -0.20066370f, 
    -0.10563169f, -0.04401200f, -0.15795965f, -0.12542054f, -0.12427137f, 0.09435759f, 0.18646377f, 0.27827245f, 
    0.44725335f, 0.18194225f, 0.46738771f, 0.20532967f, 0.49752375f, 0.03474519f, 0.05236359f, 0.00060261f, 
    0.13169844f, 0.30210894f, 0.02783490f, 0.07937060f, 0.24360746f, 0.02654484f, 0.06325902f, -0.15379626f, 
    -0.15633465f, -0.00910897f, -0.05482687f, -0.14463857f, 0.13204364f, -0.25943512f, 0.20403001f, 0.30315235f, 
    -0.00068380f, 0.00502092f, 0.18075283f, -0.07351626f, -0.14305496f, 0.16057709f, 0.09078300f, -0.04695076f, 
    0.07939552f, 0.05497607f, 0.06192785f, 0.04843944f, -0.23311365f, 0.04884451f, -0.18151717f, -0.34519815f, 
    0.02490495f, 0.15245007f, 0.16054885f, 0.26524386f, 0.04029768f, 0.18460611f, 0.04234136f, 0.22790779f, 
    0.13701707f, 0.31808364f, 0.07550817f, 0.17681189f, 0.00412640f, 0.07307004f, 0.26787820f, 0.43063697f, 
    -0.00011241f, -0.08960626f, -0.06225462f, 0.03302844f, -0.02437348f, -0.03111349f, -0.08196519f, -0.06098945f, 
    -0.06595867f, -0.02282923f, 0.02037931f, -0.08938411f, -0.01938900f, -0.00485635f, -0.05232727f, -0.05569768f, 
    0.05237527f, 0.04071239f, -0.08067633f, 0.02480455f, -0.01891687f, -0.01379656f, -0.01536912f, -0.07585267f, 
    -0.02701394f, 0.04174795f, -0.05208360f, 0.01842395f, 0.06153996f, -0.05148198f, 0.02218709f, 0.02864027f, 
    -0.05714716f, -0.03372325f, 0.05229915f, -0.02425809f, -0.07396415f, -0.00858871f, -0.07593648f, -0.02880373f, 
    -0.01815644f, 0.06204019f, 0.00549591f, 0.01220298f, 0.05125116f, -0.08544082f, -0.02300331f, 0.05413243f, 
    0.06738243f, 0.03436999f, 0.05478356f, -0.09216437f, 0.04026395f, -0.09367535f, -0.03686651f, 0.04314293f, 
    -0.00605960f, -0.00758941f, 0.02422731f, 0.07059974f, -0.00591433f, -0.03373563f, -0.03490346f, 0.01613238f, 
    -0.04549713f, -0.02228615f, -0.03770657f, -0.04903860f, -0.02031540f, 0.00373875f, 0.03262593f, -0.00123847f, 
    0.01675393f, -0.04079869f, -0.00290481f, -0.06432171f, -0.03397981f, -0.03847009f, 0.01963195f, 0.07136454f, 
    -0.03770857f, 0.07221305f, -0.06205784f, -0.06811523f, -0.04457532f, -0.06337661f, -0.03250936f, 0.02634712f, 
    -0.06728797f, -0.06520227f, 0.04412771f, 0.02369368f, 0.05182208f, 0.02926307f, -0.01831917f, 0.06048911f, 
    -0.03483161f, -0.07915908f, -0.04748432f, -0.01872914f, 0.07151531f, -0.05724513f, -0.04481127f, 0.06539656f, 
    0.02808100f, 0.06367865f, -0.03129621f, -0.08140096f, -0.02993686f, -0.02962036f, 0.04717496f, -0.08728139f, 
    -0.08106469f, -0.07308904f, -0.05178541f, 0.05882929f, -0.06187326f, -0.03581814f, -0.05993085f, -0.07345968f, 
    0.02532329f, -0.08350252f, 0.06428234f, -0.04691030f, -0.05003813f, 0.01184094f, -0.00182653f, 0.02502496f, 
    0.06760930f, 0.04321930f, -0.02338620f, -0.02611276f, 0.06703520f, 0.01683919f, -0.07846273f, -0.04738408f, 
    0.04982064f, 0.07452886f, -0.02542719f, -0.01552413f, -0.02939266f, -0.04194811f, 0.01174068f, -0.03655486f, 
    0.29883394f, -0.12351175f, 0.00239256f, -0.13847202f, -0.21282779f, 0.09837434f, -0.15740255f, 0.03288874f, 
    0.24043891f, -0.02300708f, 0.21609598f, 0.03697912f, 0.02086059f, 0.18132533f, 0.27037838f, -0.19195652f, 
    -0.05631861f, -0.02377535f, 0.09078597f, 0.20902739f, 0.24514061f, 0.21918151f, -0.07769394f, -0.01462888f, 
    0.14374031f, 0.03824411f, 0.06672362f, 0.45167884f, -0.40217817f, -0.14315091f, -0.13152963f, 0.07110520f, 
    -0.12845498f, -0.00778542f, 0.19586945f, 0.08283389f, -0.00826254f, 0.31617069f, -0.66231573f, -0.05627745f, 
    0.20209268f, -0.12685695f, 0.21690255f, 0.08819757f, -0.14279194f, 0.08754940f, 0.11044043f, -0.14639354f, 
    -0.12503418f, -0.10011138f, 0.08603055f, -0.12856984f, 0.03751281f, 0.16546698f, -0.14081381f, 0.08702657f, 
    -0.13247050f, 0.25728408f, 0.06491598f, 0.10496828f, 0.03322486f, -0.08138196f, -0.24196419f, 0.08650658f, 
    0.13026644f, 0.13113238f, 0.31069094f, 0.19166665f, 0.46066478f, -0.13847312f, 0.09500641f, -0.21740313f, 
    -0.16048732f, 0.04344723f, 0.13596117f, -0.11319008f, -0.19920292f, -0.00867248f, -0.17197227f, -0.23676984f, 
    -0.07973221f, -0.48506552f, 0.10615914f, 0.14888519f, -0.15750530f, 0.21541382f, 0.31804296f, 0.05980191f, 
    0.15569770f, 0.14258859f, -0.50359553f, 0.12361596f, 0.40382496f, -0.01484858f, 0.00202687f, -0.00251933f, 
    0.01778891f, 0.10878057f, -0.11355755f, -0.11906563f, 0.27038878f, 0.02545266f, -0.05617377f, 0.29402745f, 
    0.10788395f, 0.07509532f, -0.04221378f, -0.11800011f, -0.00754308f, -0.23340885f, -0.41207930f, 0.12865564f, 
    -0.01674907f, 0.06273154f, 0.07901201f, 0.02317847f, -0.15900233f, -0.01218528f, 0.04003264f, -0.12453417f, 
    -0.19256364f, -0.01655373f, 0.07162099f, 0.25072950f, 0.20423125f, 0.02043177f, 0.20279163f, 0.53633851f, 
    0.08219691f, 0.10795574f, 0.01503722f, 0.02462537f, -0.20211378f, -0.57145303f, -0.45873770f, 0.00962261f, 
    -0.52896750f, 0.17884816f, 0.21483909f, 0.11173852f, 0.01483284f, -0.10809509f, 0.06633966f, 0.31722182f, 
    -0.26196483f, 0.52314121f, 0.28665790f, 0.12805414f, -0.00275977f, 0.02367176f, -0.18781097f, -0.04805994f, 
    0.33079407f, 0.17316103f, -0.16226609f, -0.45464903f, -0.01382252f, -0.08995965f, -0.31192720f, 0.22647753f, 
    0.07668892f, 0.08145383f, 0.19435719f, -0.09878196f, 0.52544934f, -0.19956049f, -0.24968435f, -0.52022487f, 
    0.03027366f, 0.04279300f, -0.06371678f, -0.11637268f, 0.25517678f, 0.18697982f, 0.09707473f, -0.03182700f, 
    0.32651499f, 0.13012837f, 0.01691963f, 0.15971321f, 0.14321038f, 0.08641411f, -0.17906392f, -0.11426841f, 
    -0.00851873f, 0.16585690f, 0.10770091f, 0.00911596f, 0.08552111f, 0.53701156f, -0.17733757f, -0.05296127f, 
    0.23430964f, -0.17983893f, 0.10001807f, -0.09608582f, -0.10287179f, 0.22667989f, -0.01651499f, -0.08972935f, 
    -0.05736375f, -0.00656886f, 0.09308411f, 0.07732059f, -0.08661618f, -0.12315951f, 0.17798035f, -0.18092392f, 
    0.10088081f, -0.44269502f, -0.02500771f, 0.30457121f, -0.18687914f, -0.02798516f, 0.11711495f, -0.13565424f, 
    0.15309608f, -0.08883616f, 0.04118290f, 0.17261608f, -0.03326708f, -0.03939474f, 0.19390894f, -0.08147607f, 
    -0.13758650f, -0.24992941f, -0.11501193f, -0.46378458f, -0.10425021f, 0.38646954f, -0.10153051f, 0.20285293f, 
    0.24119417f, 0.07104331f, -0.14293915f, 0.01143492f, -0.13777462f, -0.15817824f, -0.08381385f, -0.10618881f, 
    0.15275824f, 0.09923566f, 0.00998138f, 0.31732917f, 0.19794522f, 0.08072378f, 0.19003627f, 0.08587240f, 
    0.09594718f, 0.09007000f, -0.03166205f, -0.11095051f, -0.19510324f, -0.14766175f, 0.43676475f, 0.13290080f, 
    0.21461730f, -0.29728648f, -0.14538637f, 0.05042151f, -0.13463393f, 0.11396071f, 0.09407511f, -0.57609540f, 
    -0.28128231f, -0.32313529f, -0.33893722f, 0.06803875f, 0.06367695f, 0.16403452f, -0.21505906f, -0.61066020f, 
    -0.57963526f, -0.03109772f, 0.12024604f, -0.13547224f, 0.01842819f, -0.11934619f, 0.13755713f, 0.18754536f, 
    0.14195389f, 0.26756462f, -0.12516101f, 0.22932965f, 0.24425401f, -0.00827984f, 0.12442707f, 0.06126651f, 
    -0.18983728f, -0.90267920f, -0.23381315f, 0.12911969f, 0.01702794f, 0.15776023f, -0.10535289f, -0.03909695f, 
    0.08709648f, 0.09573344f, 0.78829986f, 0.06578539f, 0.20507380f, 0.08085418f, -0.21320170f, 0.01218443f, 
    0.32831231f, -0.26421848f, -0.15421942f, 0.40454364f, 0.09320033f, 0.17187542f, 0.35003135f, -0.10034578f, 
    0.10404713f, 0.12583448f, -0.13691629f, -0.47906950f, -0.68153608f, -0.60520071f, -0.06472376f, -0.18734187f, 
    0.20420930f, -0.08179049f, -0.04394662f, 0.22039013f, -0.06338778f, 0.06872468f, -0.26112503f, -0.04175926f, 
    -0.21379553f, -0.05583903f, 0.18601105f, 0.05299535f, -0.08657883f, 0.02152603f, 0.13619708f, 0.21904986f, 
    -0.05643137f, 0.00948981f, 0.17070983f, 0.08708344f, 0.12203271f, 0.08776580f, 0.01462869f, -0.18473306f, 
    0.20325123f, 0.24225894f, 0.14696366f, -0.01459737f, 0.01578762f, -0.04224306f, -0.10762468f, -0.00389754f, 
    0.21070084f, 0.24671638f, -0.18083161f, -0.05210711f, -0.13082372f, -0.15118991f, 0.05025931f, 0.11428002f, 
    -0.23033200f, -0.16826589f, 0.08273155f, 0.04813806f, 0.27217340f, 0.00785741f, 0.20366265f, -0.14522000f, 
    0.34820420f, 0.18124886f, 0.27385932f, -0.04058984f, -0.07457983f, 0.26090589f, -0.09808639f, 0.14216864f, 
    -0.26177672f, 0.00305538f, 0.01918200f, 0.14479983f, 0.11119453f, 0.13247631f, -0.39720577f, -0.05095959f, 
    0.03565764f, -0.37961492f, 0.10874357f, -0.01461890f, 0.05010485f, 0.71623945f, -0.13496371f, 0.17302114f, 
    -0.13356373f, 0.01738140f, 0.01326379f, 0.01872657f, -0.08064119f, -0.45651093f, -0.06932496f, 0.20214504f, 
    0.03660284f, 0.29371291f, -0.16290982f, -0.27046490f, 0.09687240f, -0.03131660f, 0.52230668f, -0.10657135f, 
    0.00304916f, 0.19598693f, -0.26459613f, -0.18060499f, -0.04378888f, 0.22977348f, 0.05533224f, -0.30917346f, 
    -0.22700508f, -0.17129065f, -0.15405607f, -0.11648782f, 0.12257476f, 0.00861818f, 0.09394612f, -0.23368889f, 
    0.01875910f, 0.03420860f, -0.04852441f, -0.12204746f, 0.06194136f, 0.13506024f, 0.50724858f, -0.09654139f, 
    -0.08666036f, -0.01735523f, -0.03837505f, -0.01192021f, -0.03769233f, -0.05561302f, -0.04783454f, 0.01628527f, 
    0.04770948f, -0.06252222f, -0.00022531f, -0.02235110f, -0.05261673f, -0.01029145f, -0.08362098f, -0.03625751f, 
    -0.03835164f, -0.01005608f, -0.05557692f, 0.04321190f, -0.06558485f, -0.05347864f, 0.05454425f, 0.00208265f, 
    0.00916195f, -0.01064970f, 0.01298932f, 0.03171366f, 0.07135081f, -0.02271882f, -0.07258701f, -0.05931333f, 
    0.06185773f, 0.05300388f, -0.05541013f, -0.00854948f, -0.08278739f, -0.05612490f, -0.05387441f, -0.04558050f, 
    -0.04938563f, -0.04060052f, -0.07014708f, 0.03094742f, 0.05211911f, -0.00768786f, 0.03773355f, -0.05603505f, 
    -0.00251134f, -0.04128675f, -0.08087213f, 0.00057082f, 0.03174081f, -0.02164276f, -0.07650159f, -0.00096904f, 
    -0.06486582f, 0.03981438f, -0.02472738f, 0.02470284f, 0.06561852f, -0.04687902f, -0.00468997f, -0.00423772f, 
    -0.04406834f, 0.01963504f, 0.01292570f, 0.01733332f, -0.04651757f, 0.06113056f, 0.04648623f, 0.00566011f, 
    -0.00265365f, 0.05121195f, -0.03071898f, -0.06109761f, 0.06468278f, 0.06219781f, -0.01333020f, 0.04221285f, 
    0.00848906f, -0.06517357f, 0.00159675f, -0.05547626f, 0.03105832f, -0.05893622f, -0.01102087f, -0.04402920f, 
    -0.05035423f, -0.02399176f, -0.00575295f, -0.02055151f, -0.03085887f, -0.07728314f, -0.01271084f, -0.02917124f, 
    0.05844967f, 0.01853529f, 0.06881934f, -0.03512749f, 0.00095144f, 0.04947758f, -0.00884965f, -0.00292111f, 
    -0.06464999f, -0.05135654f, 0.04096496f, 0.02115655f, -0.00111239f, -0.01432119f, -0.00855084f, 0.05658976f, 
    -0.07440329f, -0.00027698f, 0.00350346f, -0.02328076f, 0.04288965f, -0.05637146f, -0.03761295f, 0.04786898f, 
    0.00832607f, 0.01160715f, -0.06584543f, -0.03675319f, 0.00397380f, -0.05937090f, -0.06907883f, 0.02472867f, 
    0.05192971f, -0.03564111f, -0.09117728f, -0.01034738f, -0.05894334f, 0.05510339f, -0.06694233f, 0.03220538f, 
    -0.06563756f, -0.01274110f, -0.04833069f, -0.04924237f, 0.03902609f, -0.05863038f, 0.03361441f, -0.08729999f, 
    0.38641977f, -0.38413170f, -0.10706315f, 0.19002664f, -0.00781851f, 0.21862799f, -0.00983774f, -0.01831327f, 
    -0.02723992f, -0.25211856f, 0.04715414f, -0.09134673f, -0.05438486f, 0.17891540f, -0.01764798f, 0.10869271f, 
    0.09081364f, 0.04358770f, 0.29175609f, 0.47434774f, -0.28463811f, -0.29610282f, -0.07350750f, 0.05886866f, 
    0.01946136f, -0.06280973f, 0.01476544f, 0.73786378f, -0.07919714f, -0.60481137f, -0.17224610f, 0.03909499f, 
    -0.07697554f, 0.09631023f, -0.08488726f, 0.02648402f, -0.35068661f, -0.14411385f, 0.22464031f, 0.07350057f, 
    -0.08141635f, -0.06088988f, -0.07126122f, -0.00885823f, 0.00587398f, 0.12119879f, -0.14920747f, -0.39483318f, 
    -0.10654988f, 0.14761850f, 0.02776187f, -0.02045035f, -0.10102121f, -0.06803309f, 0.15513667f, 0.21548401f, 
    -0.35225779f, -0.00999377f, 0.00169992f, -0.02615141f, -0.00276221f, 0.11959176f, -0.01741725f, 0.23128623f, 
    0.34792489f, 0.41329131f, 0.00660583f, -0.10804509f, 0.07209156f, 0.11706252f, 0.07829346f, 0.02865405f, 
    0.10771071f, 0.36735246f, -0.09003115f, -0.12222054f, -0.11800577f, -0.04818872f, -0.13097787f, -0.09244902f, 
    0.03858472f, -0.15530550f, -0.12343697f, 0.06263815f, -0.12637340f, 0.11429598f, -0.04445098f, 0.05377120f, 
    0.26322126f, 0.17199621f, -0.20731978f, -0.22389114f, 0.20699136f, -0.12854867f, 0.02044098f, 0.05417255f, 
    -0.10864879f, 0.05592144f, -0.11147364f, -0.46992096f, 0.20932034f, 0.09404275f, 0.03104177f, 0.10638927f, 
    0.07931519f, 0.05343808f, -0.09051293f, 0.17349878f, 0.44342479f, 0.28716943f, 0.10137160f, 0.16207680f, 
    -0.03615743f, 0.06920654f, -0.03266410f, 0.08719835f, -0.04335399f, -0.31884792f, -0.04349130f, -0.01546807f, 
    0.08838870f, 0.14149176f, 0.02606561f, 0.01909549f, 0.11688931f, 0.09329478f, 0.50328779f, 0.23901623f, 
    0.16674472f, -0.35940480f, -0.37065879f, -0.83732575f, 0.05391891f, 0.09927303f, 0.00192764f, -0.04787007f, 
    -0.12099533f, -0.22874846f, -0.03225590f, 0.01049694f, 0.16474305f, -0.05354445f, -0.22785638f, 0.18260039f, 
    -0.42262676f, 0.03982285f, 0.21769042f, -0.08637805f, 0.16911194f, -0.00656054f, -0.00543625f, 0.01527406f, 
    0.00122227f, -0.10838300f, 0.08399279f, 0.06742680f, 0.05342269f, 0.10307056f, 0.32945904f, -0.06721757f, 
    0.18285942f, 0.01442683f, -0.51146984f, 0.00383145f, -0.45257530f, 0.09470049f, -0.16426383f, 0.08163010f, 
    -0.08984575f, -0.02591996f, 0.00900289f, 0.29553413f, 0.17223659f, 0.28655416f, -0.04765242f, -0.18412501f, 
    -0.23806953f, 0.10759884f, 0.04720900f, -0.05733122f, -0.00666614f, -0.56345755f, 0.13728830f, -0.03317787f, 
    -0.05713201f, -0.06005244f, 0.26561460f, 0.03900850f, -0.08614789f, -0.05992289f, 0.08643475f, -0.22076191f, 
    0.14935243f, 0.12959728f, 0.17126346f, 0.24051473f, 0.09821996f, -0.22309870f, 0.28794661f, 0.13419399f, 
    0.18801194f, 0.17150058f, 0.33257893f, 0.08980735f, -0.11549088f, -0.01851159f, 0.16394503f, -0.25450775f, 
    -0.16871822f, 0.21008097f, 0.03148154f, -0.27339503f, 0.14248079f, 0.03479342f, -0.03905823f, 0.37149453f, 
    -0.03549485f, 0.17461060f, 0.40947062f, -0.07892528f, -0.04689028f, -0.20431873f, 0.04183367f, -0.00952181f, 
    0.05737342f, -0.63766009f, -0.03725875f, 0.11026279f, -0.08061475f, -0.20694567f, 0.16937228f, 0.05644806f, 
    -0.03459968f, -0.00854668f, 0.09745399f, -0.55371475f, -0.63154948f, 0.00308381f, -0.20994915f, -0.19064902f, 
    -0.12628855f, -0.13240306f, -0.07740492f, -0.53081608f, -0.06009351f, -0.32191807f, 0.13073196f, -0.01046876f, 
    -0.02705091f, 0.06471943f, -0.01864104f, 0.20401588f, 0.25869778f, 0.31737474f, 0.05520227f, -0.20672558f, 
    0.09195236f, -0.27497286f, 0.14341785f, 0.25707120f, 0.08582564f, -0.03079694f, -0.00436642f, 0.46054465f, 
    0.01812098f, -0.25098065f, -0.06054504f, 0.02313509f, -0.00989220f, 0.06220661f, 0.51588422f, -0.10950700f, 
    0.26873446f, -0.22372583f, -0.04151819f, -0.51102650f, -0.02503671f, 0.02447748f, -0.14683416f, -0.05805773f, 
    0.25100929f, 0.42343456f, 0.04458317f, 0.04305983f, -0.03924423f, 0.09012906f, 0.15183611f, -0.17363229f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.32007551f, 0.18920438f, -0.06965622f, 0.23994794f, 0.06024401f, 0.14681974f, 0.76630151f, 0.03595930f, 
    0.28164336f, 0.01494353f, 0.00750189f, 0.38210261f, 0.09185717f, -0.08723801f, -0.11758278f, 0.18228050f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.51883054f, 0.23781075f, 0.10919161f, 0.21096028f, 0.58447516f, 0.43347982f, -0.67088675f, 0.23415892f, 
    -0.00019030f, 0.12739733f, 0.14119262f, 0.02153616f, 0.20964390f, 0.05229542f, -0.26751739f, -0.56161499f, 
    0.09746941f, 0.10663392f, -0.12155354f, 0.05595420f, -0.20229003f, -0.26690716f, 0.14920232f, 0.05839312f, 
    -0.11396971f, -0.24768883f, -0.17744230f, -0.11828503f, -0.18631610f, -0.23327467f, -0.02703372f, 0.00919864f, 
    -0.01829763f, -0.54249543f, 0.18989275f, -0.11313505f, -0.35185719f, 0.49962944f, 0.08893099f, 0.01506562f, 
    0.62378871f, 0.19481725f, -0.08867233f, 0.56243056f, -0.51576942f, 0.23299029f, -0.58732623f, -0.27113318f, 
    0.13584922f, 0.01827924f, 0.23708057f, -0.10929323f, 0.12337657f, -0.11464696f, 0.10554505f, -0.22902368f, 
    -0.13971587f, 0.22724769f, 0.11376764f, 0.08236848f, -0.11110014f, 0.05297872f, -0.17308493f, -0.09983567f, 
    0.23150933f, -0.09900962f, -0.21213184f, 0.02302952f, -0.64338064f, 0.31053182f, 0.69620699f, -0.11113152f, 
    0.12192927f, -0.18989228f, 0.44254881f, 0.51266062f, 0.19240598f, 0.22642782f, -0.76368612f, -0.12800764f, 
    -0.26091534f, 0.05655168f, -0.25393108f, 0.51265234f, 0.00283680f, 0.41563153f, 1.06481051f, 0.31088182f, 
    -0.15732159f, 0.23833637f, -0.59039021f, -0.06805263f, 0.10180105f, 0.25389054f, -0.36341968f, -0.12393036f, 
    -0.64925772f, -0.34977874f, -0.09531655f, -0.01741885f, -0.03570397f, -0.36214337f, 0.68311566f, 0.39409488f, 
    0.29118803f, -0.15171312f, -0.18295737f, 0.24281153f, -0.31375110f, 0.11440936f, 0.54976851f, 0.17124900f, 
    0.00827718f, -0.07383057f, -0.08790764f, -0.20732313f, 0.10380259f, 0.18908307f, 0.20473358f, -0.16262650f, 
    -0.24128857f, -0.12877291f, -0.24009052f, -0.23553398f, -0.01908773f, 0.17757112f, 0.12875456f, -0.19562867f, 
    0.05081347f, -0.45370606f, 0.07844437f, 0.05556419f, 0.11095133f, 0.11493706f, 0.24247724f, -0.49982664f, 
    0.10126778f, -0.14544180f, 0.35340017f, 0.68066615f, 0.47119313f, -0.03695353f, -0.07989004f, -0.12555237f, 
    -0.43764132f, 0.31913009f, -0.16479999f, 0.34673092f, 0.03190062f, 0.49556124f, 0.44226626f, -0.17049637f, 
    -0.18043754f, -0.21433020f, -0.22230420f, 0.20477419f, 0.44156078f, 0.09116110f, 0.15479971f, -0.09848764f, 
    0.27110273f, -0.32023275f, -0.01825666f, 0.15062976f, -0.14817429f, -0.24374446f, 0.93703270f, -0.33642697f, 
    -0.10718793f, -0.18962061f, 0.20537755f, 0.25694248f, 0.15105838f, -0.22297293f, -0.07625514f, 0.18863142f, 
    0.07668535f, -0.04185858f, -0.00185849f, -0.46794748f, -0.40991908f, -0.09325324f, -0.44819209f, 0.41383860f, 
    0.12855840f, -0.03808465f, -0.07437976f, 0.22599536f, 0.51830864f, -0.11848880f, 0.34296975f, 0.58006656f, 
    0.30045098f, 0.16995031f, 0.04069243f, 0.32759401f, -0.29940122f, 0.47628626f, -0.57652801f, 0.19131424f, 
    -0.35035500f, 0.20156465f, 0.12757388f, 0.26052362f, -0.14810292f, 0.04400082f, -0.25625277f, 0.63967484f, 
    0.25337344f, 0.55756402f, -0.14250939f, -0.19240694f, 0.05612290f, 0.66223228f, -0.37753460f, 0.07580785f, 
    -0.10702302f, -0.10705501f, 0.29543921f, 0.13318521f, 0.14109215f, -0.13616613f, -0.16091309f, -0.79366738f, 
    -0.05074660f, 0.51993185f, -0.06521785f, 0.44048262f, 0.59564066f, -0.24374042f, -0.06018201f, 0.60163838f, 
    -0.47775683f, -0.10172828f, -0.62869793f, 0.30934799f, 0.29914835f, -0.21249159f, -0.01953713f, -0.00578859f, 
    -0.40513471f, -0.41694614f, 0.17621279f, -0.22269863f, -0.02774013f, -0.28813520f, -0.12484033f, 0.24812697f, 
    0.00423459f, -0.00262330f, -0.22926000f, -0.16822718f, -0.49259892f, -0.03147537f, 0.93203020f, 0.23458859f, 
    -0.53295916f, -0.20217533f, -0.00851474f, -0.00916674f, -0.34364554f, 0.19356726f, 0.32943380f, 0.41352373f, 
    0.09376086f, 0.22990927f, 0.28374156f, -0.55884349f, 0.03448746f, -0.22194150f, 0.36632514f, 0.32183120f, 
    0.26051658f, -0.03168273f, -0.22930099f, 0.07305847f, -0.43796504f, -0.04729366f, 0.13200338f, 0.09697971f, 
    0.30141184f, -0.16775073f, -0.13326089f, -0.10671904f, -0.27356899f, 0.13327654f, 0.04684401f, -0.04852619f, 
    -0.06081320f, -0.31043801f, 0.25213832f, 0.57709742f, 0.32100466f, 0.16140160f, -0.32069519f, 0.43014270f, 
    -0.13087417f, -0.12392893f, -0.32372561f, -0.38148794f, -0.05311537f, 0.23792961f, 0.07032069f, 0.60656416f, 
    0.27299732f, -0.67346656f, 0.17340083f, -0.11995107f, -0.03031502f, -0.09852997f, -0.15014179f, -0.21098982f, 
    0.32821095f, 0.14423570f, 0.50674677f, 0.62122834f, 0.47266212f, -0.08270516f, 0.17314892f, -0.64571142f, 
    -0.06149169f, 0.21303277f, 0.03451144f, -0.09879106f, 0.60233939f, -0.13430479f, -0.39149588f, 0.08497903f, 
    -0.20530237f, -0.12316383f, 0.21863781f, -0.09675979f, 0.29590529f, -0.19551775f, 0.26678494f, 0.51346332f, 
    -0.09728244f, -0.17245397f, -0.17185426f, 0.11578569f, 0.07137421f, -0.08146155f, -0.18881923f, -0.19522822f, 
    -0.07070491f, 0.23914319f, -0.16724190f, -0.21473175f, -0.01799741f, 0.07161310f, -0.02442643f, -0.23841834f, 
    -0.49781597f, 0.10895125f, 0.16148272f, 0.09369345f, -0.35870728f, -0.11541352f, -0.33076420f, 0.42036894f, 
    0.29396173f, 0.19362056f, 0.15520175f, -0.16806841f, 0.13573503f, 0.15449926f, 0.55078703f, 0.34296516f, 
    0.26613116f, -0.48442444f, -0.25009820f, -0.02936978f, 0.53744519f, -0.49833465f, 0.02899953f, -0.12421544f, 
    0.38725403f, 0.23666456f, -0.00980712f, -0.01900580f, -0.50377101f, -0.10526103f, -0.22618662f, 0.66510111f, 
    -0.00064566f, 0.38919967f, -0.18261480f, 0.41567090f, 0.15422712f, 0.27847871f, 0.40095752f, 0.08898782f, 
    0.01367041f, -0.05417141f, -0.08872807f, -0.19686362f, -0.38467628f, -0.22425020f, -0.42785427f, -0.22007304f, 
    -0.29256523f, -0.00998475f, -0.16669916f, 0.46731314f, -0.19315131f, 0.38422605f, 0.20093374f, -0.29204676f, 
    0.21194197f, 0.02728122f, -0.11206752f, -0.32305568f, 0.13510370f, 0.20711145f, -0.26032546f, 0.35553789f, 
    0.20838225f, 0.31325802f, -0.04513041f, -0.32060841f, -0.05665222f, 0.35307169f, 0.26932618f, 0.01511397f, 
    0.08555012f, 0.11942223f, -0.05318013f, -0.17325595f, 0.31911477f, -0.19266689f, 0.24559283f, -0.23673490f, 
    -0.57044947f, -0.09141497f, 0.05737133f, -0.02188468f, -0.27271843f, -0.16482128f, 0.26053241f, 0.73451740f, 
    0.07667269f, 0.24360299f, -0.21187878f, -0.06958807f, -0.39163721f, -0.25076669f, 0.37011981f, 0.40409094f, 
    0.25605309f, 0.17717867f, -0.08886340f, 0.08268500f, -0.54247636f, -0.42839867f, 0.82943416f, 0.10819653f, 
    0.21868448f, -0.05503058f, -0.12927210f, -0.07614917f, 0.28477210f, 0.19998929f, 0.41156751f, -0.38782564f, 
    0.34547839f, -0.90371120f, -0.12618861f, -0.17738380f, -0.20114353f, 0.09866770f, 0.14692123f, 0.42023012f, 
    0.12588526f, 0.24982488f, 0.07346544f, -0.34176102f, 0.54118806f, -0.02346856f, -0.28023356f, 0.22450145f, 
    0.03062397f, -0.14236945f, -0.05053899f, -0.27484834f, -0.03064316f, -0.24657251f, 0.09267358f, 0.16229019f, 
    -0.12765718f, 0.01672199f, 0.14326461f, -0.11272339f, -0.03243241f, 0.09383494f, 0.15332350f, -0.22483514f, 
    0.34412244f, 0.48588100f, -0.21214642f, -0.16143420f, -0.11042726f, -0.11640025f, -0.26739550f, -0.07232202f, 
    -0.07291242f, -0.17332023f, 0.08676324f, -0.08143852f, 0.14881463f, -0.15924862f, 0.43812266f, -0.22680543f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01222325f, -0.21024098f, 0.34747064f, 0.12847629f, 0.48977128f, 0.31591031f, 0.07855526f, -0.21767151f, 
    0.05462712f, 0.01597740f, -0.12513632f, -0.07389653f, 0.33528703f, -0.05421859f, -0.26977342f, -0.31428868f, 
    0.08784658f, 0.04520561f, 0.15175664f, 0.26893851f, 0.05953688f, -0.05766612f, -0.11482435f, 0.50349140f, 
    0.12485445f, 0.17359059f, -0.44032681f, -0.04705082f, -0.33284831f, -0.41935471f, -0.10712779f, -0.30356255f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.14289173f, 0.06977187f, -0.16152796f, -0.12583299f, -0.85119349f, -0.54387271f, 0.24251300f, 0.04717284f, 
    -0.35421979f, -0.19091989f, 0.07247972f, 0.14903940f, -0.63671637f, 0.03809149f, -0.15132624f, 0.99869144f, 
    0.28210235f, 0.04437029f, 0.09665143f, -0.34157360f, 0.07474903f, -0.07755075f, 0.30453426f, 0.16889577f, 
    -0.31030953f, -0.13516267f, 0.22121343f, 0.25616542f, 0.15934302f, 0.22277603f, 0.09940831f, -0.02303576f, 
    -0.24844721f, -0.10374577f, -0.20382167f, -0.12158773f, -0.07933345f, 0.15530868f, 0.08715659f, -0.14423642f, 
    -0.22932781f, 0.05433120f, -0.05780877f, -0.08478908f, 0.54219294f, 0.27358404f, 0.38523760f, -1.16351962f, 
    0.00434141f, 0.07232574f, 0.18604726f, -0.59254521f, -0.04311606f, -0.05362362f, -0.04959371f, 0.33993128f, 
    0.25928226f, 0.05090889f, 0.23936057f, 0.09027110f, 0.07907089f, -0.83330387f, -0.09264742f, -0.00888189f, 
    -0.32104182f, -0.08065172f, 0.84357530f, -0.10662218f, 0.08574982f, 0.04195747f, -0.16355573f, -0.14055941f, 
    0.07285175f, -0.55945122f, -0.17421411f, 0.02858342f, -0.04732071f, -0.67513424f, -0.88052720f, -0.47919631f, 
    -0.88874173f, 0.18720330f, 0.02259003f, 0.17795292f, -0.16718712f, -0.14958097f, -0.08765665f, 0.72327304f, 
    -0.10996152f, 0.03621245f, -0.38984260f, -0.75108427f, -0.43730891f, 0.35113588f, 0.17550653f, 0.21013033f, 
    0.46434000f, -0.08735602f, 0.25017649f, 0.07007971f, -0.18295369f, -0.87381345f, 0.25861728f, 0.01284004f, 
    0.28047910f, -0.12730533f, -0.23623049f, 0.07205343f, -0.51408005f, -0.41260782f, -0.11589131f, 0.18853822f, 
    -0.11780173f, -0.19885038f, -0.27752185f, 0.52066886f, 0.30416143f, 0.12267932f, 0.31037590f, 0.22802064f, 
    -0.26077980f, -0.48394120f, -0.50810474f, -0.01704598f, -0.81375879f, -0.44485450f, -0.00094296f, -1.39741445f, 
    -0.05575591f, -0.13614890f, -0.07800318f, 0.09685554f, 0.03887586f, -0.38675627f, 0.05745246f, 0.04356159f, 
    -0.27112329f, -0.93351603f, -0.20722263f, 0.24761356f, 0.37001503f, -0.01330810f, -0.21185200f, -1.14628720f, 
    0.31603175f, -0.05086340f, 0.13205323f, -0.12124146f, 0.05940622f, -0.07793022f, 0.25668088f, -0.06921244f, 
    -0.09938279f, -0.44622383f, 0.10254595f, 0.20407975f, -0.05526092f, 0.50500238f, 0.14020757f, -0.06679067f, 
    0.41893762f, -0.04799386f, 0.08439702f, 0.11607044f, -0.28381130f, 0.53600109f, 0.24283071f, 0.16206013f, 
    -0.22312631f, 0.11252587f, -0.43466255f, -0.16849063f, -0.57995611f, 0.05559117f, 0.38740164f, 0.46301693f, 
    -0.10029953f, 0.01211902f, 0.15344299f, -0.11279001f, -0.22436881f, -0.04758280f, -0.02885821f, -0.37096268f, 
    0.13196839f, -0.07409934f, 0.11222906f, 0.11348449f, 0.07058287f, 0.11541719f, 0.05216755f, 0.18332300f, 
    -0.81025398f, -0.09168724f, 0.27390394f, -0.07270317f, 0.31929788f, -0.06226074f, -1.10851288f, -0.05471181f, 
    0.26421407f, -0.17447302f, 0.49770734f, -0.28633207f, -0.72261554f, -0.34097061f, -1.08293676f, 0.08309057f, 
    -1.05872428f, 0.10346197f, -1.42693400f, 0.47647029f, -0.47446826f, 0.01360026f, -0.90962547f, 0.08706658f, 
    0.05198598f, -0.04390960f, 0.04243311f, -0.82478881f, 0.33928499f, 0.41616195f, 0.01422460f, -0.41689068f, 
    -0.12897870f, 0.04851747f, -0.79421520f, 0.06665511f, -0.20180434f, -1.35154438f, -1.07459664f, -0.10989913f, 
    0.15082341f, 0.32703328f, 0.01724488f, 0.74296468f, 0.52728295f, -0.01635480f, 0.30659911f, 0.12737648f, 
    -0.26946467f, -0.17762138f, -0.02111382f, 0.27756435f, 0.12604758f, 0.04103038f, 0.02277405f, -1.00747979f, 
    -0.36672181f, -0.10234630f, -0.03558295f, -0.97878170f, -0.17018269f, 0.38491255f, -0.11482468f, -0.27779824f, 
    0.34590691f, 0.07503500f, -1.21580994f, -0.05450043f, 0.06753569f, 0.13888568f, -0.30915079f, -0.10339269f, 
    0.19596031f, 0.17739066f, 0.19312595f, -0.65050268f, 0.26742160f, -0.02148627f, 0.83844852f, -0.03567137f, 
    -0.94588476f, -0.14681955f, 0.25418603f, -0.01632373f, 0.23749776f, -0.02388668f, -0.62566358f, 0.10253698f, 
    0.24182740f, 0.02034171f, -0.40643838f, -1.41955006f, -0.26395303f, -0.64109778f, 0.17196217f, -0.23927765f, 
    -0.63917893f, -0.10975794f, -0.27286360f, 0.05833052f, 0.27667338f, 0.07268211f, 0.39710739f, -0.14940929f, 
    0.17612365f, 0.28715000f, 0.32576868f, 0.09248450f, -0.71373421f, -0.62438560f, -0.49240589f, -0.61566943f, 
    0.26156741f, 0.03606679f, -0.61119413f, 0.19326292f, -0.40753305f, -0.16655996f, 0.14139324f, -0.36237156f, 
    -0.22079569f, -0.03448214f, -0.08037060f, -0.31799358f, 0.50478297f, -0.26607215f, -0.03765198f, -0.26982206f, 
    0.15806389f, -0.17544228f, -0.81214678f, 0.00411670f, -0.07794935f, 0.19052549f, -0.44249493f, 0.12382776f, 
    0.05419039f, 0.25003305f, 0.00385089f, -0.31025648f, 0.10003192f, -1.06541145f, -0.10312951f, 0.61668485f, 
    0.46188629f, -0.37784761f, 0.34468728f, -0.40569296f, 0.26687428f, 0.07009472f, 0.14294891f, -0.23582838f, 
    -0.04984351f, 0.41083929f, -0.47439334f, -0.28121477f, -0.50109929f, 0.36824545f, -0.02306967f, -1.40161467f, 
    0.44741634f, 0.00547972f, 0.36073822f, -0.04949911f, 0.37141156f, 0.14684637f, -0.32612070f, -0.04648812f, 
    0.06508831f, 0.39215589f, -0.23290072f, -0.42658147f, 0.38195354f, 0.26834491f, -1.00805306f, 0.12494403f, 
    -0.04471841f, 0.01710031f, -0.22426249f, -0.02502091f, -0.49497554f, -0.08062100f, -0.19148456f, -0.54167694f, 
    0.08156634f, 0.19577329f, 0.01414414f, -0.47925532f, -0.51001859f, -0.61083281f, -0.05117584f, -0.61351848f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.37377527f, 0.24957924f, 0.55379248f, 0.25118354f, -0.25054964f, -0.20850790f, -0.15168798f, -0.02950347f, 
    0.23841551f, 0.18867919f, -0.09474596f, 0.01529233f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
