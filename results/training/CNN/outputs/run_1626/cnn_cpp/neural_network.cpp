#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.43239325f, -0.33208847f, -0.70647585f, 0.92680979f, -0.76388168f, -0.33500955f, -0.17371693f, -0.43078259f, 
    -0.62891895f, 1.03033423f, 0.13881397f, -0.33213151f, 0.44748750f, 1.04423010f, 0.63249868f, -0.81296933f, 
    0.37652475f, -0.44755369f, 0.29615903f, -0.03864162f, 0.50853699f, -0.27175644f, 0.54523063f, -0.48345691f, 
    0.79381555f, -0.46559429f, 0.45473534f, 1.15250802f, -1.36061072f, -1.04465592f, -0.06733175f, 0.51717627f, 
    0.68544549f, -0.50349396f, -0.17262164f, -0.21677418f, 0.96627969f, 1.23501599f, 0.94495738f, -0.44481727f, 
    -0.49743617f, -0.49658811f, -0.04438754f, -0.35368893f, -0.34137148f, -1.20067358f, -1.19625807f, -0.64742512f, 
    0.16084583f, -0.30222815f, -0.42689857f, -0.26200759f, -0.20367435f, -0.27007440f, -0.32647374f, -1.02142465f, 
    0.91096985f, -0.35921547f, 0.09712560f, 0.55640072f, 0.08847833f, 0.32075414f, -0.38885099f, -1.22830474f, 
    -0.31396651f, 0.55849111f, 0.60393679f, 0.87126976f, -0.05847280f, 0.34867999f, -0.11541672f, -0.15996167f, 
    0.86224562f, 0.36370030f, -0.02026044f, 0.05448845f, -0.03532867f, -0.24552034f, 0.46618807f, 0.72495931f, 
    -0.42560732f, -0.64418793f, -0.14873330f, 0.28792331f, -0.95609128f, -1.01822042f, -0.86193764f, -0.37921980f, 
    -0.57663250f, -0.60055006f, -0.75019854f, -0.50201792f, -0.49203312f, 0.87307197f, -0.55875605f, 0.20554225f, 
    0.62081718f, -0.13109934f, 0.52453470f, -1.24035072f, -0.25538608f, 1.28604686f, 0.72300869f, 0.37325677f, 
    -0.43062145f, -0.37152404f, -0.22836743f, 0.06005568f, -0.35307282f, 0.38243219f, -1.28341222f, 0.28561991f, 
    0.54141223f, 0.57955074f, -0.29972792f, -0.60444015f, -0.70523322f, -0.47066581f, 0.57870764f, 0.12279981f, 
    -0.50554359f, -0.62963933f, 1.56449246f, 0.08315245f, -0.63626802f, -0.40402395f, 0.94290155f, -0.68643868f, 
    -0.40772748f, 0.56999874f, 0.46036765f, 0.42946112f, 0.45145664f, 0.29224014f, 0.23515235f, -0.99216300f, 
    0.21390840f, -0.29949126f, -0.90787768f, -0.86684561f, -1.33785021f, 0.16478629f, 0.55602783f, 0.58728540f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.16753049f, 0.05438730f, -0.18208739f, 0.21799675f, 0.34095007f, -0.27700418f, 0.20652942f, 0.20059313f, 
    -0.00776997f, 0.31861657f, 0.32788980f, 0.19115236f, -0.13438621f, 0.22841288f, -0.00494425f, 0.16286305f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.21056913f, 0.16131571f, 0.19535471f, -0.33540317f, -0.16220252f, 0.11160718f, -0.00866730f, -0.07236642f, 
    0.29099104f, -0.06406014f, 0.08480387f, -0.05732861f, 0.12632543f, -0.29636401f, -0.00111571f, -0.06585425f, 
    -0.14290735f, 0.18364790f, -0.02726159f, -0.08257080f, 0.20837413f, 0.01283930f, 0.23793966f, 0.11497433f, 
    0.12705876f, -0.08871995f, -0.17451406f, 0.09995899f, -0.06643274f, -0.22478788f, 0.11931700f, 0.00629409f, 
    -0.05675067f, 0.00568745f, -0.03610934f, 0.04281394f, -0.05471356f, 0.04762790f, 0.15183929f, 0.16825676f, 
    0.11600024f, -0.04686393f, -0.13203746f, -0.28265616f, 0.20521308f, -0.07060321f, -0.25791731f, -0.09690266f, 
    0.02709470f, -0.13338369f, 0.00874603f, -0.08163670f, 0.00135539f, -0.08312555f, 0.02861141f, 0.10438835f, 
    0.04296867f, 0.15816183f, 0.09673951f, 0.07575070f, 0.55102336f, 0.14431290f, 0.00908549f, 0.04011500f, 
    0.03114145f, 0.06081518f, -0.19150463f, 0.22046557f, 0.03380876f, 0.14265376f, 0.22816318f, 0.13191691f, 
    0.09973108f, 0.02914055f, -0.02707550f, 0.17195451f, -0.10750058f, 0.02764486f, 0.09048928f, 0.10847420f, 
    -0.24297218f, 0.02247537f, -0.33771363f, -0.37092707f, -0.09157594f, -0.02856779f, 0.11796152f, -0.02038813f, 
    -0.09948459f, -0.02631131f, 0.02935452f, -0.07740819f, 0.06824209f, 0.03914975f, -0.11492721f, 0.04996683f, 
    0.01571924f, -0.03252379f, 0.47019845f, 0.01294363f, 0.13767555f, 0.06161786f, 0.26780215f, -0.08169140f, 
    -0.21196130f, 0.26518172f, 0.06830934f, 0.07116131f, 0.13874216f, 0.12083945f, 0.02400643f, -0.12108949f, 
    -0.04262034f, -0.07832225f, -0.01115289f, -0.14121799f, -0.12489057f, -0.01434272f, -0.23275128f, -0.06552354f, 
    0.04957066f, 0.10831538f, -0.08599462f, 0.24939701f, -0.03510152f, -0.00403512f, 0.05006220f, -0.23627652f, 
    -0.12229871f, 0.19072074f, 0.09872293f, -0.06250271f, 0.03591955f, -0.00006211f, 0.20974991f, 0.05238269f, 
    0.17556912f, -0.14036500f, 0.15558913f, -0.09440175f, -0.02584385f, -0.03438684f, 0.04044546f, 0.15574607f, 
    0.07781349f, -0.14016619f, 0.18693481f, -0.23690452f, 0.22413476f, -0.17082340f, 0.18465786f, -0.13826467f, 
    0.11424897f, -0.02110574f, 0.18177418f, 0.03866598f, 0.09033224f, -0.13203897f, 0.13613313f, 0.04409662f, 
    0.06074915f, -0.07964505f, -0.20875528f, -0.17273048f, 0.06101790f, 0.12515950f, -0.11218757f, -0.17166002f, 
    0.13590951f, -0.03321425f, 0.15367228f, -0.21030384f, -0.18745640f, -0.05497221f, -0.10634711f, 0.04598960f, 
    0.04704585f, -0.07048129f, 0.15012561f, 0.03346896f, -0.08400226f, 0.08428941f, -0.06002019f, -0.09034992f, 
    -0.14085153f, 0.13868403f, 0.01929808f, -0.02887364f, 0.14708571f, 0.06085102f, 0.08113626f, -0.04370686f, 
    -0.04601504f, 0.01990680f, 0.03568177f, -0.06952446f, 0.01599140f, 0.10509651f, 0.10777360f, -0.14605720f, 
    -0.28075397f, 0.01326815f, 0.05502693f, -0.41198131f, -0.06965554f, 0.01424606f, 0.00664995f, 0.00118391f, 
    0.03771027f, -0.18751198f, -0.03429070f, 0.04094664f, 0.18672074f, 0.13044488f, 0.08105323f, 0.00484319f, 
    0.13365799f, 0.03487633f, -0.03848965f, 0.09592857f, 0.10742155f, 0.23211116f, 0.22342031f, 0.02697456f, 
    0.09250966f, -0.23956589f, 0.18491979f, -0.40254810f, 0.30167276f, 0.07841986f, 0.10402720f, 0.06350551f, 
    0.10885878f, 0.05340709f, -0.02328544f, 0.20636646f, 0.27623597f, 0.04022385f, 0.14603017f, 0.14079265f, 
    0.10878452f, 0.09224098f, 0.06064514f, 0.13478743f, 0.10850232f, -0.10229984f, -0.19029593f, 0.01146589f, 
    0.09653863f, -0.04574271f, 0.17156234f, -0.07816822f, 0.11709192f, 0.02301550f, 0.21143585f, 0.13166574f, 
    0.17657529f, -0.09499156f, 0.26567256f, -0.03285001f, -0.54529142f, 0.50290591f, -0.33361703f, 0.22649562f, 
    0.00091065f, -0.07068470f, -0.03010801f, 0.12341142f, -0.09872559f, 0.08697797f, -0.03152683f, 0.13932216f, 
    0.14577638f, -0.01719495f, 0.00402739f, 0.00841943f, -0.02442085f, -0.16996370f, 0.21099645f, -0.00429547f, 
    0.08665014f, 0.10524973f, 0.32059991f, -0.23050553f, 0.14557937f, -0.02969796f, -0.19100346f, -0.10016077f, 
    -0.21892585f, -0.20124964f, 0.09775963f, 0.17199361f, 0.04773779f, 0.07229844f, 0.17842890f, -0.00227498f, 
    0.00666900f, -0.01669123f, 0.08226775f, 0.01107984f, -0.11867655f, -0.31199959f, -0.39751074f, -0.30299917f, 
    -0.24822900f, -0.01442729f, 0.11367540f, -0.19969253f, 0.06329687f, -0.32661363f, -0.03887441f, -0.15655155f, 
    -0.03135427f, 0.05426260f, 0.02253956f, -0.01553767f, 0.13895828f, 0.17313603f, -0.11875277f, 0.06041357f, 
    -0.05466026f, -0.69585127f, -0.32330373f, -0.04711381f, 0.11272168f, 0.20266859f, -0.12481128f, 0.09273446f, 
    0.26326281f, 0.00476070f, 0.00770992f, -0.07825439f, -0.03303351f, -0.03168926f, 0.06457888f, 0.04950402f, 
    0.10685929f, 0.21611126f, -0.04924906f, -0.04947446f, -0.23801956f, 0.06249761f, 0.23687316f, 0.10488136f, 
    -0.15864891f, -0.05246831f, 0.02003405f, -0.09283394f, -0.11635527f, 0.03942376f, -0.00289959f, 0.01775285f, 
    0.10958162f, 0.11012455f, 0.20732334f, -0.04494211f, 0.03446253f, -0.04286848f, 0.02333704f, 0.01555647f, 
    0.06915376f, 0.02438354f, 0.00728811f, 0.02882805f, -0.06995778f, -0.06072162f, -0.07681431f, -0.14114107f, 
    0.01870297f, 0.00661910f, -0.00602301f, -0.06984849f, -0.06883949f, -0.08710501f, -0.00702727f, 0.01663048f, 
    0.02223577f, -0.03053726f, -0.06121401f, -0.00537622f, -0.20779523f, -0.33916950f, -0.14652610f, -0.03455745f, 
    0.94523388f, -0.10968899f, 0.34625667f, 0.23900758f, -0.13080220f, 0.12476084f, 0.08231262f, -0.03054943f, 
    0.12003449f, 0.15067233f, -0.14837351f, -0.02061966f, 0.09017791f, 0.11795696f, 0.00584650f, -0.06397830f, 
    0.00074399f, 0.21405903f, 0.28128406f, -0.08753624f, 0.04207535f, -0.00560677f, -0.10704789f, -0.05858400f, 
    -0.00417215f, -0.09314087f, 0.00539461f, 0.02937766f, -0.03480071f, -0.12031478f, -0.02573957f, 0.02069745f, 
    -0.07177557f, -0.01948469f, -0.08603224f, 0.05775580f, 0.10829906f, -0.64922792f, -0.72785389f, -0.44857153f, 
    0.13679010f, -0.08075616f, -0.08398997f, 0.09911091f, 0.05702526f, 0.02039014f, -0.13121068f, -0.10817968f, 
    -0.16567367f, -0.13097322f, -0.05666945f, 0.07587801f, -0.13251096f, 0.05658493f, 0.15986820f, -0.06600665f, 
    0.37554821f, 0.12234545f, 0.00727989f, -0.27925602f, -0.07507335f, -0.08648820f, 0.04017562f, -0.04277366f, 
    -0.02237881f, 0.24757741f, 0.22297682f, 0.02514257f, 0.12894326f, 0.02020111f, 0.02202732f, -0.18492556f, 
    0.11555925f, -0.11590551f, 0.17398812f, -0.10018990f, 0.14418299f, 0.03510231f, 0.01912981f, -0.27142507f, 
    -0.17203514f, -0.14676642f, -0.13503671f, 0.04184457f, 0.04680674f, 0.11482825f, 0.18890749f, 0.02658691f, 
    0.13773505f, -0.00189468f, 0.04559194f, -0.07776141f, -0.04338853f, -0.03686974f, 0.05956992f, 0.08003862f, 
    0.05908701f, 0.13617805f, 0.12507240f, 0.01725403f, -0.04565558f, -0.02712660f, -0.07610311f, -0.03937976f, 
    -0.03047276f, -0.08685948f, -0.01166714f, -0.02540240f, -0.04873931f, -0.07079452f, 0.03817801f, 0.01092192f, 
    0.10626607f, 0.13847314f, 0.01943524f, 0.01872148f, 0.20417699f, -0.27877766f, -0.37048757f, -0.25750902f, 
    0.17068210f, 0.07854886f, 0.13934296f, 0.00764092f, 0.04364767f, -0.14636657f, 0.05363864f, -0.07090161f, 
    0.01830649f, 0.06984723f, 0.01678904f, 0.15111634f, 0.03312470f, 0.16811681f, 0.25859833f, 0.01753529f, 
    -0.09635936f, -0.01785800f, 0.06332991f, -0.20591629f, 0.09055061f, -0.01128223f, -0.00948023f, 0.14888145f, 
    0.13565770f, 0.27230653f, 0.12408580f, 0.04603287f, -0.10640992f, -0.23711608f, -0.04624743f, -0.04973463f, 
    0.01315146f, -0.07786243f, -0.01424300f, 0.03202109f, 0.44333601f, 0.08699559f, -0.20115252f, -0.08459735f, 
    -0.22875220f, -0.03480594f, -0.05989671f, -0.01057535f, 0.06867085f, 0.02738331f, 0.16015486f, 0.12973297f, 
    0.13533375f, 0.21308132f, 0.04570271f, 0.00025008f, 0.00720956f, -0.10641780f, 0.02749355f, 0.10350106f, 
    -0.35917112f, -0.20230381f, 0.14538482f, 0.07968109f, 0.48356366f, -0.26023763f, 0.04749420f, -0.17403069f, 
    0.03574016f, -0.13047859f, -0.02681730f, 0.03539709f, 0.14032540f, 0.17347208f, 0.03272644f, -0.00587762f, 
    -0.01316710f, -0.07669671f, 0.11116228f, -0.16487895f, 0.29416552f, 0.51480538f, 0.34054571f, 0.04511792f, 
    0.24009857f, -0.06514876f, -0.08658674f, -0.14752254f, 0.06976806f, -0.02518659f, -0.05317628f, 0.08174270f, 
    0.14567947f, -0.03095421f, -0.09167023f, 0.21490499f, -0.02541656f, -0.39723745f, 0.11191081f, -0.12510242f, 
    -0.13894780f, 0.08033176f, -0.04260057f, -0.06219795f, -0.01093980f, -0.09234509f, -0.05863062f, -0.01412001f, 
    -0.04359443f, 0.06887306f, 0.09648596f, -0.02832705f, -0.01028995f, 0.04654058f, 0.13567095f, -0.04477761f, 
    -0.02366792f, -0.02468313f, 0.07945011f, -0.06120947f, -0.08223587f, -0.81486529f, -0.66441196f, -0.30085465f, 
    0.00404196f, -0.14158423f, 0.00998003f, -0.14123088f, -0.11990958f, -0.36508322f, 0.07431217f, -0.02412988f, 
    -0.07962286f, 0.00247561f, 0.03986557f, -0.04113972f, 0.15392211f, 0.09326774f, 0.16907278f, 0.14375770f, 
    0.02790700f, -0.02453456f, -0.05413637f, -0.04657895f, 0.03818223f, -0.00788388f, 0.00821460f, -0.06064936f, 
    -0.01539177f, -0.02863662f, 0.02846751f, 0.01886045f, 0.01081509f, 0.04311101f, 0.00358893f, -0.04152158f, 
    0.03070510f, -0.05323037f, -0.06089835f, 0.02177113f, -0.01886521f, -0.05171409f, -0.02011009f, 0.01249741f, 
    0.01454816f, -0.06050980f, 0.02653896f, 0.01837043f, -0.01040483f, -0.00963321f, 0.02612902f, 0.03937848f, 
    -0.03219128f, 0.02181852f, -0.04631929f, -0.00374060f, -0.02705268f, 0.00127597f, -0.01227778f, -0.04726993f, 
    -0.03790342f, -0.04391357f, 0.04664643f, -0.05049800f, 0.02301416f, -0.01885181f, 0.03583096f, 0.04737250f, 
    -0.02429774f, -0.05945344f, -0.01766337f, 0.00104166f, 0.04891559f, 0.03757556f, -0.04250625f, 0.04720350f, 
    -0.03501309f, 0.03312619f, 0.01216675f, -0.02423787f, 0.00081938f, -0.03194314f, -0.02699846f, 0.01760305f, 
    0.04178319f, 0.01479370f, -0.03879185f, 0.02467555f, -0.05188345f, -0.05163344f, -0.03262890f, 0.02660561f, 
    -0.03053359f, 0.02651050f, -0.01943139f, -0.01930734f, -0.00659263f, -0.00098987f, 0.04820375f, 0.02049408f, 
    0.04142331f, -0.01752424f, -0.05815185f, 0.04518323f, -0.04569587f, 0.01706033f, -0.05825671f, 0.00805218f, 
    -0.00590669f, -0.03601741f, 0.03292589f, 0.04603110f, 0.04317114f, 0.02701809f, -0.04886921f, -0.00126867f, 
    -0.02961125f, -0.01338420f, -0.00737966f, 0.01720592f, 0.00679534f, -0.04815583f, -0.00804810f, -0.03714133f, 
    -0.03069790f, -0.05402233f, -0.05891820f, -0.00628728f, -0.06139759f, 0.02699081f, 0.02907640f, -0.04348367f, 
    0.01808825f, -0.02420319f, -0.03495523f, 0.02296281f, -0.01593514f, 0.03424823f, 0.00178577f, -0.06124103f, 
    -0.00397964f, 0.01230596f, -0.02361103f, -0.05175509f, 0.01493083f, 0.01485705f, 0.02180935f, -0.05325680f, 
    0.04831865f, -0.01777098f, 0.04516457f, 0.01736082f, -0.01611176f, 0.04037574f, -0.02674988f, 0.03120567f, 
    -0.00649713f, 0.02194780f, -0.04889596f, -0.00124668f, -0.01960951f, -0.03532366f, 0.03801798f, -0.01355191f, 
    0.03759151f, -0.04848680f, -0.01121082f, 0.02968789f, 0.04698632f, -0.01818474f, 0.04257510f, -0.00627160f, 
    0.01642437f, -0.04884117f, -0.00435739f, 0.02771590f, -0.04175188f, -0.03025199f, -0.03525943f, -0.05199465f, 
    0.01267171f, -0.02991839f, -0.02527529f, -0.04519578f, -0.00354075f, -0.05725854f, -0.03764004f, -0.04398401f, 
    -0.01173860f, 0.00094267f, -0.01647452f, -0.04665488f, -0.02667634f, 0.03765585f, 0.00523493f, 0.02638095f, 
    -0.04091294f, 0.00875500f, 0.04383099f, 0.00163070f, 0.02508243f, 0.00207828f, -0.05702492f, -0.00446613f, 
    -0.04722085f, 0.00179764f, 0.00247098f, -0.04960169f, 0.00309893f, -0.02293654f, 0.00968655f, 0.03139649f, 
    -0.05698648f, 0.02183782f, 0.02753957f, -0.03265739f, -0.02766971f, -0.06159014f, 0.04181334f, 0.04517351f, 
    -0.00174273f, 0.01194136f, -0.03907347f, 0.04519210f, -0.03235689f, -0.04798546f, -0.05334491f, 0.00147050f, 
    -0.00081912f, 0.04403583f, 0.00169828f, -0.04959265f, -0.03607148f, -0.00350505f, -0.01512009f, 0.01783988f, 
    -0.04070562f, -0.00111248f, -0.03488811f, -0.04247588f, -0.00186187f, -0.01588964f, -0.00826893f, 0.00772028f, 
    -0.02619527f, -0.02187181f, -0.05241647f, -0.05381341f, -0.04913904f, -0.01058534f, -0.04780265f, -0.03298317f, 
    0.00009934f, 0.00497814f, -0.05031990f, -0.02260814f, -0.00309484f, -0.03621737f, -0.05933675f, -0.05906555f, 
    0.02651788f, -0.05628962f, -0.00905078f, -0.04293493f, -0.05793263f, -0.01474631f, 0.02754370f, 0.04608383f, 
    -0.04112881f, -0.01395664f, -0.05353026f, 0.04280831f, 0.01872676f, -0.00628231f, -0.03088781f, -0.04197420f, 
    0.00202899f, -0.00035730f, -0.00229612f, 0.00094327f, 0.02910597f, 0.01639269f, 0.01896624f, 0.03860583f, 
    0.04685839f, -0.02829383f, -0.01757900f, -0.05785937f, -0.02466583f, -0.04341462f, -0.04162028f, -0.05991521f, 
    0.04675851f, 0.00141950f, -0.01547492f, -0.04676161f, 0.00064484f, 0.01130228f, -0.02325785f, 0.00085792f, 
    0.04585067f, -0.04896376f, -0.00468841f, 0.03931302f, 0.03146182f, -0.04482943f, 0.04595893f, -0.04979472f, 
    0.03437312f, -0.00458803f, -0.04825910f, 0.04045787f, -0.06186071f, 0.02578143f, 0.03496991f, -0.03321254f, 
    -0.01095906f, 0.00465617f, -0.00746558f, -0.02633233f, 0.02476111f, 0.01702893f, -0.04785139f, -0.01641457f, 
    -0.05842646f, 0.03305453f, 0.04911159f, -0.02518382f, 0.00595005f, -0.06125000f, -0.01885161f, 0.01531922f, 
    -0.00127505f, -0.01500859f, -0.00944420f, 0.03770174f, 0.03215823f, 0.04128992f, -0.02957973f, 0.01046544f, 
    0.11147259f, -0.17402396f, 0.18195611f, -0.16447106f, -0.01755686f, -0.08775971f, 0.14636058f, -0.03455733f, 
    0.00868610f, 0.07417440f, 0.01906552f, -0.14273421f, 0.03041265f, -0.03189171f, 0.03652539f, 0.02825134f, 
    0.13420348f, 0.01513635f, 0.09985594f, 0.37636617f, 0.19068632f, 0.01995504f, 0.00527014f, -0.26331344f, 
    -0.00597068f, 0.17939866f, -0.11868699f, 0.02960234f, 0.08541170f, -0.09568822f, 0.12923439f, 0.10959837f, 
    0.00661701f, 0.07081728f, 0.09110648f, 0.06902921f, 0.12860730f, 0.08570132f, 0.14074239f, 0.05214089f, 
    -0.35638139f, -0.37045014f, -0.29563689f, -0.33272597f, 0.20560953f, 0.11641232f, 0.25658545f, 0.07653070f, 
    -0.04761051f, -0.19601925f, 0.19286184f, 0.14733370f, 0.05944978f, 0.08529278f, 0.14509277f, -0.06166265f, 
    -0.04674562f, -0.18585020f, -0.05855956f, -0.40227014f, 0.22439231f, -0.07833167f, 0.41007081f, 0.15253986f, 
    -0.26074341f, 0.05730610f, -0.13690117f, -0.18502042f, -0.22040586f, -0.12025513f, -0.05573036f, -0.05429104f, 
    -0.09438964f, 0.08072001f, 0.18331739f, 0.06912147f, 0.11239591f, -0.08813958f, 0.07766890f, -0.06058726f, 
    -0.37958312f, -0.05598401f, -0.28161630f, 0.24425703f, 0.22259119f, 0.04371591f, 0.16670598f, 0.17668250f, 
    0.09145540f, 0.29387027f, -0.06127430f, -0.17127569f, -0.04652904f, 0.01771806f, -0.13111989f, 0.09145243f, 
    0.24471827f, 0.11078022f, 0.12495448f, 0.02397477f, 0.13152663f, -0.04380545f, 0.27492958f, 0.34164995f, 
    0.18327227f, -0.15759949f, 0.05931687f, 0.02815545f, 0.05258279f, 0.08607339f, 0.15996963f, -0.05296702f, 
    0.06931954f, 0.20578483f, 0.06207064f, 0.15814114f, 0.25061172f, 0.20752780f, 0.00698114f, 0.06959506f, 
    -0.16554865f, 0.27787676f, -0.11312093f, 0.23818810f, 0.34128350f, -0.07205150f, -0.15202081f, -0.30171767f, 
    -0.04354011f, -0.40260017f, -0.03419508f, 0.11981864f, 0.00101551f, -0.13072781f, 0.00858299f, 0.21933986f, 
    -0.21012704f, -0.35339889f, -0.08859557f, 0.08579981f, 0.23027402f, 0.13119312f, 0.30494681f, 0.37432611f, 
    0.32295081f, -0.12885372f, 0.06680536f, -0.30912036f, -0.02513934f, -0.31940669f, -0.04577016f, -0.02264357f, 
    0.04248461f, -0.07521679f, 0.06447835f, 0.13622759f, 0.03892709f, -0.28765851f, -0.08522922f, 0.04382077f, 
    -0.45686987f, -0.19017373f, -0.28747982f, -0.25045273f, 0.23782565f, 0.01025022f, 0.03078431f, 0.05647487f, 
    0.08640835f, -0.05321463f, 0.00608849f, 0.08256514f, 0.07088812f, 0.18832909f, -0.06195143f, 0.09022542f, 
    0.02970782f, -0.19843297f, -0.12631129f, -0.11073351f, 0.00042569f, 0.07582961f, -0.09202142f, 0.09495743f, 
    0.00893803f, 0.06160272f, 0.02692972f, 0.05345151f, 0.13294576f, 0.24954432f, 0.07767521f, 0.11437248f, 
    0.06030102f, 0.07384837f, -0.02674276f, 0.06585350f, 0.14596733f, 0.07080583f, 0.06880152f, 0.34106573f, 
    0.51183212f, 0.02380662f, -0.10455780f, -0.03142470f, -0.03703370f, -0.05872137f, -0.09571420f, -0.20372257f, 
    -0.05514555f, -0.27774391f, 0.06478362f, 0.12985563f, 0.08347753f, 0.07156631f, 0.02407403f, -0.03085994f, 
    -0.11315595f, -0.01831083f, -0.12332354f, -0.32183772f, -0.03515755f, 0.25782955f, 0.07738864f, 0.20741265f, 
    0.24293730f, -0.25929236f, -0.01868885f, -0.20003895f, 0.06668399f, -0.14899446f, 0.07463751f, 0.04189431f, 
    -0.02414757f, -0.12797602f, -0.00547095f, -0.08758305f, 0.05504517f, -0.09460750f, -0.11204967f, 0.17081927f, 
    0.04699513f, -0.19485310f, 0.22946759f, 0.22319330f, -0.19866006f, 0.14769575f, -0.10484549f, -0.11749009f, 
    -0.10687476f, -0.03158410f, 0.08560547f, 0.03671231f, 0.05253689f, -0.00625081f, 0.17787184f, 0.18694122f, 
    0.23683245f, 0.14426953f, -0.03136164f, 0.19995803f, -0.22610524f, -0.28006998f, -0.60051924f, -0.01990982f, 
    -0.15845135f, 0.04277099f, 0.03656642f, 0.15091145f, -0.11430162f, -0.13606969f, 0.08282348f, 0.03523619f, 
    -0.07520289f, -0.04989791f, -0.00732669f, -0.05779560f, 0.26119372f, 0.23377642f, 0.03596987f, 0.33405000f, 
    0.23385133f, -0.22771044f, 0.34471548f, -0.16334319f, 0.09736168f, -0.01753321f, -0.21503255f, -0.12787656f, 
    -0.14868291f, -0.30167791f, 0.16921817f, 0.15876347f, 0.01954144f, 0.12279268f, 0.04335555f, -0.10126319f, 
    -0.12430674f, -0.01023695f, -0.18804185f, -0.28217497f, 0.36482400f, 0.48218262f, -0.00871583f, 0.12363490f, 
    -0.02158809f, -0.06201304f, 0.00372422f, 0.07965891f, 0.12212066f, 0.56117272f, -0.04960669f, 0.08859865f, 
    0.00102937f, -0.04250953f, -0.09247264f, 0.07839445f, -0.17853564f, -0.18898225f, -0.04078402f, -0.37284747f, 
    0.14238398f, -0.00905058f, -0.41748723f, 0.17429076f, 0.00419574f, 0.08600079f, -0.11916249f, 0.11067442f, 
    0.17325459f, 0.12289527f, 0.08778228f, 0.00139820f, 0.03193341f, 0.08729652f, 0.19700843f, 0.22493152f, 
    -0.08598768f, 0.08047998f, -0.05385851f, 0.01854065f, -0.18776071f, 0.02418645f, 0.20637096f, -0.17721309f, 
    0.10987861f, -0.24751112f, 0.01229681f, -0.07650181f, -0.07534550f, -0.06275506f, -0.07900856f, 0.03649762f, 
    0.10980762f, 0.12969297f, 0.11497758f, 0.25161001f, 0.00068725f, -0.19096033f, 0.00098296f, 0.01581162f, 
    -0.00673807f, -0.05588975f, -0.19200312f, -0.03169055f, -0.02881994f, -0.00371524f, -0.02208306f, -0.02306399f, 
    -0.00494879f, -0.20939551f, -0.06689018f, -0.03766683f, 0.12986793f, -0.07072429f, 0.14961250f, 0.14673167f, 
    0.06445968f, 0.15575999f, -0.02625058f, 0.05421627f, 0.53404766f, -0.30498430f, 0.15567966f, 0.00111422f, 
    -0.15201877f, 0.04241642f, 0.01429438f, -0.19659968f, 0.16964877f, 0.05266008f, 0.01897494f, -0.00013424f, 
    -0.03233350f, 0.11744486f, 0.03293421f, 0.16425629f, -0.02283326f, 0.04598500f, -0.12730592f, -0.01053312f, 
    0.02750371f, 0.24753354f, -0.17065424f, 0.04633208f, -0.04750255f, 0.15544002f, -0.00948541f, 0.15817982f, 
    -0.05200619f, -0.12702793f, -0.18824060f, -0.08572540f, -0.05623029f, 0.00031808f, -0.01518200f, -0.02825700f, 
    0.01194141f, 0.01654343f, -0.02964053f, -0.20854959f, -0.36445877f, -0.02736113f, -0.12852098f, 0.09538337f, 
    -0.13821743f, 0.17925033f, -0.18344890f, 0.01878015f, -0.04631018f, -0.03837896f, 0.11129239f, -0.03232447f, 
    -0.01223756f, 0.01053939f, 0.02256747f, 0.01855580f, 0.04382848f, 0.01972048f, -0.05408661f, 0.12553777f, 
    0.01998360f, -0.03681917f, -0.04864918f, 0.24355935f, -0.27475792f, 0.13491111f, 0.12462573f, -0.13537796f, 
    0.14118913f, -0.04665858f, 0.31231982f, -0.11614177f, 0.20018971f, 0.05293358f, 0.16961819f, -0.00692926f, 
    0.13326274f, -0.04066308f, 0.07579736f, -0.02586159f, -0.19523270f, 0.04960821f, 0.03855123f, 0.28773233f, 
    -0.15203042f, -0.11912940f, 0.08071718f, -0.12388112f, 0.08851027f, -0.19566596f, 0.29021379f, 0.05621394f, 
    0.18452251f, 0.16248037f, 0.22311081f, 0.09023707f, -0.01970109f, 0.07221875f, 0.03751912f, -0.07496116f, 
    -0.02532257f, 0.15674339f, -0.10645520f, 0.02751599f, -0.02462025f, -0.06321669f, 0.18170601f, 0.04722311f, 
    0.00612601f, -0.06170592f, -0.04846563f, -0.05513712f, -0.00955054f, 0.03725483f, 0.11439496f, 0.05372342f, 
    0.28682983f, 0.07858316f, 0.07481320f, -0.01409409f, 0.13287309f, 0.10230301f, -0.10813932f, 0.05523825f, 
    -0.06776128f, 0.25084800f, -0.33000931f, 0.06227413f, 0.01810734f, 0.00150251f, 0.13194418f, 0.13323636f, 
    0.09923378f, 0.02778530f, 0.03947702f, 0.17601350f, 0.11986998f, 0.18585178f, -0.00036517f, -0.12233451f, 
    -0.16179062f, -0.12240984f, -0.16659102f, -0.06202482f, -0.20082633f, -0.07162149f, -0.08209600f, -0.07425973f, 
    -0.00764838f, 0.34161708f, 0.15816993f, -0.08295187f, -0.04567430f, 0.00019693f, -0.07503427f, 0.08955006f, 
    0.12872931f, 0.10012086f, -0.04566932f, 0.14811477f, -0.37299922f, 0.00202997f, 0.19022839f, 0.52945799f, 
    0.00458777f, 0.01231823f, 0.00768922f, -0.13463539f, 0.14749025f, -0.09579983f, 0.25132638f, -0.03659327f, 
    0.05763425f, 0.20427749f, 0.17988448f, 0.17563468f, 0.04550521f, 0.01021139f, -0.27637196f, -0.07421856f, 
    0.43867815f, 0.08459637f, 0.08870003f, 0.31326813f, 0.14705522f, -0.05681589f, -0.07798003f, -0.15937909f, 
    -0.01472465f, -0.12834564f, 0.05693711f, -0.02859719f, -0.09218410f, -0.08873168f, 0.04857862f, 0.36703417f, 
    0.12329362f, -0.07394765f, -0.13348523f, -0.16471307f, 0.02720001f, -0.08414407f, -0.20532326f, 0.14565386f, 
    0.14047892f, -0.01703250f, -0.11672542f, 0.06286468f, 0.14962706f, -0.09364160f, -0.14797053f, -0.05679960f, 
    0.02197245f, -0.08510386f, 0.26269922f, 0.07072955f, 0.00991655f, -0.05769087f, -0.04686071f, -0.02528731f, 
    -0.10759789f, -0.12169041f, 0.19731504f, -0.02030746f, -0.13840632f, -0.09562404f, -0.04890190f, -0.08176051f, 
    -0.06571019f, -0.07988616f, 0.21099645f, 0.27944019f, 0.15524861f, 0.04013273f, -0.01812670f, -0.07891475f, 
    0.04088890f, -0.06234043f, 0.08679701f, 0.15866548f, -0.19951642f, -0.08921824f, -0.12671204f, -0.11342916f, 
    -0.32356620f, -0.02989609f, -0.13925585f, -0.07671723f, 0.14332294f, -0.00119079f, -0.07209690f, -0.15824072f, 
    -0.02314405f, -0.02931106f, 0.01193342f, 0.10652369f, 0.21520412f, 0.08123249f, 0.21127552f, 0.22552034f, 
    -0.10529542f, -0.10065197f, -0.17077179f, 0.52961850f, 0.15009278f, 0.02882912f, -0.00917984f, -0.04008051f, 
    -0.03809343f, -0.05354824f, 0.00195308f, 0.00405063f, -0.00049441f, -0.01833595f, -0.05496328f, -0.05956271f, 
    0.24486232f, -0.00837553f, 0.02694571f, -0.05532955f, 0.31565279f, -0.03021828f, 0.23780221f, -0.10857270f, 
    -0.13019766f, 0.06238144f, -0.08228295f, -0.09024986f, -0.15633233f, -0.02714624f, -0.01012761f, 0.07218270f, 
    -0.03652302f, -0.08081188f, -0.01272592f, -0.06926923f, 0.01057197f, -0.04851211f, -0.04084627f, 0.04554836f, 
    0.04313134f, -0.13726600f, 0.00460154f, -0.02110678f, -0.04041646f, -0.20629129f, 0.10261814f, -0.03204281f, 
    0.01041775f, -0.01723487f, 0.02408784f, -0.00155147f, -0.08739146f, -0.04264133f, 0.04656105f, -0.04404091f, 
    0.00473387f, 0.06225835f, 0.01840988f, -0.06866801f, -0.20245121f, 0.18059641f, 0.10046274f, 0.06637767f, 
    0.16557206f, 0.00289504f, -0.05255342f, -0.00191097f, 0.13448644f, -0.11750294f, -0.06434114f, -0.09440434f, 
    0.11795697f, 0.15172531f, 0.04952117f, 0.03650679f, 0.03892372f, 0.05229441f, -0.02534345f, -0.06718526f, 
    0.39639497f, -0.28496006f, -0.51269329f, -0.19662499f, -0.08443713f, -0.14643285f, 0.05375526f, 0.13329037f, 
    0.00097507f, -0.04055534f, -0.02704018f, 0.00995380f, -0.05579516f, -0.13754793f, -0.01293724f, -0.01052660f, 
    0.00831307f, -0.07218894f, 0.04515709f, 0.07734546f, -0.21570030f, -0.08726668f, -0.11820699f, 0.27843091f, 
    0.10967243f, -0.30663997f, -0.12657861f, -0.22650215f, 0.11757474f, -0.07316957f, -0.07031647f, 0.05930401f, 
    0.07572650f, 0.00400900f, -0.07467223f, 0.08330354f, 0.04875720f, 0.00855503f, 0.27107275f, -0.19100726f, 
    -0.26140580f, 0.45422038f, 0.16827182f, 0.11073660f, -0.05317669f, -0.20188044f, -0.08814117f, -0.09716099f, 
    -0.07728026f, 0.05009858f, -0.00257992f, 0.20413154f, 0.22193226f, 0.09534819f, -0.03646308f, -0.04041366f, 
    -0.08420680f, -0.03978366f, 0.21396081f, 0.04156121f, 0.34445423f, -0.13129812f, 0.46468779f, 0.06603206f, 
    0.04381786f, -0.01741563f, -0.12941712f, -0.07488753f, -0.11569390f, 0.04547891f, 0.04706667f, 0.04628351f, 
    0.03582068f, 0.02935448f, -0.05298323f, 0.02958314f, -0.05825726f, 0.00669315f, -0.08453434f, 0.00647123f, 
    0.12651999f, -0.17162311f, 0.10618280f, -0.25990647f, -0.14505637f, 0.06422344f, -0.12043354f, 0.14628661f, 
    -0.10254955f, -0.01336272f, 0.06273175f, -0.04788766f, 0.05541364f, -0.15365405f, -0.02884526f, -0.09423986f, 
    0.06500793f, 0.08796789f, 0.07692679f, 0.02192963f, -0.19490984f, -0.17114562f, -0.40642339f, 0.20770998f, 
    0.21725771f, 0.08435351f, 0.07134884f, 0.10275726f, -0.06087743f, 0.02818827f, -0.07448631f, 0.02406016f, 
    0.05601366f, 0.08432928f, 0.05772025f, 0.19731475f, 0.07654286f, -0.05890561f, 0.06848645f, 0.12107772f, 
    0.06476212f, 0.11285058f, 0.28811908f, 0.33621967f, 0.08436233f, -0.08308499f, 0.01113333f, -0.00579689f, 
    -0.14976025f, 0.11228055f, 0.03013445f, 0.11638448f, 0.12525402f, 0.09642334f, -0.03683728f, 0.06007954f, 
    -0.01995236f, -0.09160463f, -0.00652949f, 0.08262508f, 0.22526528f, -0.27087924f, 0.22351044f, 0.15562680f, 
    -0.00426249f, -0.02134616f, 0.11673183f, -0.00770486f, -0.08442888f, -0.04619443f, 0.14215629f, 0.00704581f, 
    0.06273542f, 0.17760511f, -0.11335988f, 0.06922080f, -0.09036200f, -0.01347560f, 0.08174556f, 0.03864209f, 
    -0.27692485f, -0.09180897f, 0.23572323f, 0.10792387f, 0.03927464f, 0.13317227f, -0.09312650f, 0.10349707f, 
    -0.04225027f, 0.03693764f, 0.02605234f, 0.01701851f, -0.06858261f, 0.06624947f, -0.12121812f, 0.07467272f, 
    -0.10595685f, 0.11208423f, 0.15079616f, 0.31797674f, -0.17985806f, 0.02175043f, 0.06920801f, 0.16006762f, 
    0.13161714f, 0.00423670f, 0.04961380f, 0.06285297f, 0.01936708f, -0.12642033f, 0.05245983f, -0.02580316f, 
    0.06410006f, 0.04343145f, -0.01004272f, 0.07197525f, 0.01915399f, 0.03864489f, 0.06825975f, -0.00427172f, 
    0.00614661f, -0.04933107f, -0.02029886f, -0.03143915f, -0.03389544f, -0.00769519f, -0.07920700f, -0.07088611f, 
    -0.12701645f, -0.04768128f, 0.08631226f, -0.00459134f, 0.21471308f, 0.10441513f, 0.05808239f, -0.05176150f, 
    -0.05140975f, -0.16739161f, 0.05365125f, 0.04587813f, -0.47519684f, -0.06719711f, 0.08802357f, 0.26604241f, 
    0.22051713f, -0.11629198f, 0.03003943f, 0.09946883f, -0.00345084f, 0.13877335f, -0.01982994f, 0.02604870f, 
    -0.00632100f, -0.00089798f, 0.03043598f, 0.02170140f, -0.00082624f, 0.02781252f, 0.09800233f, -0.25403625f, 
    0.04816376f, 0.02483934f, 0.06173507f, -0.04119039f, -0.02506356f, -0.04235030f, 0.04789189f, -0.01547629f, 
    0.04345427f, 0.01061557f, -0.03294415f, 0.01554963f, -0.03891960f, 0.04127487f, -0.05209723f, 0.04046092f, 
    -0.01110258f, 0.01734463f, -0.00658444f, -0.05025220f, 0.04408677f, 0.03055405f, 0.02743350f, 0.03065382f, 
    -0.05265409f, -0.03750840f, 0.02830243f, 0.03817309f, -0.03786629f, 0.03756759f, 0.00144857f, -0.00258352f, 
    0.01590013f, -0.00535475f, -0.04593302f, -0.03020809f, -0.00821104f, -0.01139383f, 0.02732454f, -0.05757191f, 
    -0.00439049f, 0.01409321f, -0.06249171f, 0.00223914f, 0.02511076f, -0.06074966f, 0.03861371f, 0.02342194f, 
    0.02428677f, 0.03983986f, 0.00826843f, 0.00154499f, 0.01326319f, -0.01037579f, -0.03913137f, -0.05679433f, 
    -0.02463131f, 0.04314602f, 0.01477500f, -0.04017373f, 0.00769679f, 0.03282482f, -0.01466116f, -0.03960546f, 
    -0.05299190f, 0.01249874f, -0.04150263f, -0.00732367f, 0.04551261f, -0.02772055f, -0.05572883f, -0.00790887f, 
    0.03871385f, -0.02816399f, -0.05251279f, -0.04011455f, 0.02921488f, 0.01870642f, -0.04783413f, 0.01674433f, 
    0.02228317f, -0.04432508f, -0.05363607f, -0.04274840f, 0.02119904f, 0.02491596f, 0.01320967f, -0.00365845f, 
    -0.03350358f, 0.00993576f, 0.00040355f, 0.00373504f, 0.01772330f, 0.03790385f, -0.04999999f, -0.05561712f, 
    -0.04214632f, 0.02264106f, -0.06639841f, 0.00928076f, -0.02714181f, 0.03269977f, -0.03277117f, -0.01326418f, 
    -0.02139263f, 0.02106533f, 0.01597040f, -0.03006998f, 0.01136701f, -0.04393595f, 0.03375398f, 0.00665024f, 
    -0.01326807f, 0.02729057f, -0.01625509f, -0.03704413f, 0.03833874f, -0.05927663f, -0.02459906f, -0.02210223f, 
    -0.00211265f, -0.02477952f, -0.01097568f, -0.02370879f, -0.04242754f, 0.01513429f, -0.02592626f, -0.03295244f, 
    0.04115729f, 0.03835861f, 0.01505356f, -0.05116034f, 0.01823212f, 0.01951027f, -0.03403960f, 0.02449584f, 
    -0.03551213f, -0.01351589f, 0.02492140f, 0.01205293f, 0.03092902f, 0.02352894f, -0.03480839f, 0.02185346f, 
    0.00755939f, -0.04091367f, -0.00251882f, -0.06285366f, -0.01710917f, -0.04523500f, -0.01863579f, -0.04463068f, 
    0.03554047f, -0.06199116f, -0.03440498f, -0.05585755f, -0.03462446f, -0.02223160f, 0.04650772f, 0.04492600f, 
    -0.01356528f, -0.00910237f, -0.04035566f, -0.04243689f, 0.00896787f, 0.04382725f, -0.04814124f, -0.07124499f, 
    0.01902916f, -0.00380041f, 0.01725395f, -0.06488368f, -0.04483810f, -0.02324302f, -0.04422589f, 0.04038043f, 
    0.03498875f, -0.04635981f, -0.05810897f, -0.00451523f, -0.04318652f, -0.02445218f, -0.02653482f, 0.00827496f, 
    -0.00003750f, -0.02032076f, 0.00573391f, -0.04759875f, -0.03472315f, -0.04802372f, 0.01325755f, 0.03983524f, 
    0.00025995f, -0.04962225f, 0.03040951f, -0.02166168f, -0.05498777f, 0.03762538f, 0.04301054f, 0.02088286f, 
    -0.02945821f, 0.03681773f, 0.03333483f, -0.06680220f, 0.03211577f, 0.03887152f, -0.02685756f, -0.02129025f, 
    0.03430456f, -0.06776333f, 0.02966925f, -0.03849674f, 0.00718996f, -0.01806634f, 0.01502330f, -0.04370236f, 
    -0.04656367f, -0.00813193f, -0.02742323f, -0.02370812f, -0.03112163f, 0.02541351f, 0.03817707f, -0.06558696f, 
    -0.02514545f, 0.02224074f, -0.02733616f, 0.00301756f, 0.04025684f, -0.04302416f, -0.05435257f, -0.02864178f, 
    -0.00191048f, 0.03309986f, 0.03140338f, -0.00848421f, -0.02843841f, -0.03044992f, -0.05453192f, -0.02518905f, 
    -0.03722184f, 0.00310812f, -0.00711971f, -0.01890142f, 0.02004024f, 0.02170017f, -0.03179845f, -0.04690617f, 
    0.00033290f, -0.01014781f, -0.00275312f, 0.01950264f, 0.02135121f, 0.00780510f, 0.01236134f, 0.03314139f, 
    -0.06189350f, -0.06853019f, 0.04530900f, 0.02159932f, 0.03600866f, -0.02497548f, -0.02670730f, -0.00284082f, 
    -0.05959915f, 0.02013509f, -0.05894742f, -0.04421089f, 0.04850199f, 0.02878563f, -0.02926286f, -0.05121442f, 
    0.03992324f, -0.02527552f, 0.01899344f, 0.00347953f, 0.04626824f, -0.03463765f, 0.03316972f, 0.01907846f, 
    0.01125719f, 0.03809666f, 0.04379813f, 0.03477565f, 0.00770965f, -0.04198414f, -0.03595810f, -0.02601146f, 
    -0.04620606f, 0.04512873f, -0.00154403f, -0.04535777f, 0.01653180f, -0.02625489f, 0.01277302f, 0.01356572f, 
    -0.01708114f, -0.04687493f, -0.01604423f, -0.01288250f, -0.03267760f, -0.03751076f, 0.01159052f, -0.04088426f, 
    0.02991768f, -0.03363137f, -0.00932611f, -0.04260127f, 0.04660091f, -0.03988278f, -0.03230230f, 0.00228792f, 
    -0.02583185f, 0.01234269f, 0.02386292f, -0.02925025f, -0.01075924f, 0.00869399f, -0.03452552f, -0.02113090f, 
    -0.15814532f, -0.18387967f, -0.47446719f, 0.40612045f, 0.07662151f, 0.05462311f, 0.05499638f, -0.01739833f, 
    -0.15556318f, -0.10734117f, -0.10642750f, 0.03112671f, -0.12391052f, -0.07032955f, 0.05621198f, 0.08455584f, 
    0.00325517f, 0.20403205f, 0.23869118f, 0.28766760f, -0.11286481f, -0.18154252f, -0.03249856f, -0.27532193f, 
    -0.07639421f, -0.01974821f, 0.00673413f, -0.07447580f, 0.09932176f, -0.01876372f, 0.07422864f, 0.04803177f, 
    0.04674736f, 0.10951459f, -0.01429626f, -0.04029006f, 0.04075767f, -0.07079898f, 0.03728943f, -0.11260772f, 
    -0.02121983f, -0.33406928f, -0.06096148f, -0.01886427f, -0.16261385f, -0.18610123f, -0.09881049f, 0.00420560f, 
    -0.03422702f, 0.08149491f, 0.03175997f, 0.08866881f, 0.19397944f, -0.07663330f, -0.21465935f, 0.01012599f, 
    0.18104833f, 0.07847389f, 0.03144907f, -0.05348448f, -0.19577421f, 0.87279379f, 0.30992413f, 0.30553409f, 
    0.44033554f, -0.12237483f, 0.17767528f, -0.14902723f, 0.16084287f, 0.03710673f, 0.07103636f, -0.13555364f, 
    -0.01846285f, 0.08547618f, 0.07055187f, 0.06483285f, 0.11768746f, 0.07350920f, 0.02495999f, -0.04644810f, 
    -0.01539644f, -0.57286501f, 0.43140340f, -0.33046845f, 0.08233639f, -0.12926896f, -0.12502529f, 0.04120238f, 
    0.08268373f, -0.04207908f, -0.02055615f, -0.10675031f, -0.06767012f, 0.00907422f, 0.00698797f, 0.11486727f, 
    0.13436703f, -0.19868526f, 0.01255165f, 0.15022299f, -0.37982771f, 0.00322361f, -0.33868828f, 0.25975960f, 
    0.32095331f, -0.13912442f, -0.19732487f, -0.03100448f, -0.11152856f, -0.07909499f, -0.14501095f, 0.11621989f, 
    0.08698232f, 0.07541432f, -0.01702330f, 0.00498120f, -0.05744164f, 0.00155231f, -0.11495954f, 0.11280636f, 
    -0.19479227f, 0.32313603f, 0.31257805f, -0.06060972f, 0.42169511f, -0.12776610f, 0.21071383f, -0.01563125f, 
    -0.06388484f, 0.07067755f, -0.15238318f, 0.27176121f, 0.20610233f, 0.24769859f, 0.07146305f, 0.11920098f, 
    0.01484859f, 0.06402328f, 0.00456033f, 0.10995245f, 0.27919543f, -0.03644060f, 0.50544798f, -0.02657652f, 
    0.19641659f, 0.21276045f, -0.04356622f, 0.08225980f, -0.07304364f, 0.17884398f, -0.18654217f, 0.05371302f, 
    -0.01162848f, 0.12987289f, 0.08085337f, 0.03433320f, -0.05909969f, -0.02532738f, 0.06767390f, 0.04320138f, 
    0.05967727f, -0.23877932f, -0.16612227f, -0.03869914f, -0.22700246f, -0.09095971f, -0.07671387f, 0.04830159f, 
    0.06371170f, 0.01740066f, -0.14345852f, 0.00461994f, -0.00121970f, 0.04922878f, -0.07386541f, 0.05996148f, 
    0.00923269f, 0.06576209f, -0.02860327f, 0.09754582f, -0.12328394f, -0.23373269f, -0.43985635f, -0.25480998f, 
    0.32834250f, -0.08852015f, 0.11822420f, 0.11922459f, -0.03054280f, -0.06346786f, -0.13268265f, -0.06803009f, 
    0.05824783f, -0.05248187f, -0.01716393f, 0.08142001f, -0.11605629f, 0.04147123f, 0.09764696f, 0.26571885f, 
    -0.38811150f, 0.23506883f, 0.26294535f, 0.35722199f, 0.39562827f, 0.04471859f, -0.04468975f, 0.05899212f, 
    0.03981813f, 0.14443164f, -0.13188629f, 0.16450273f, 0.14435996f, -0.01669578f, 0.06720611f, -0.05253788f, 
    -0.09935550f, 0.01615474f, 0.00196594f, 0.00213602f, 0.32627016f, 0.66431677f, 0.39740452f, 0.09300587f, 
    0.36207712f, 0.22115451f, 0.01244391f, 0.14002645f, -0.23064056f, 0.08778325f, -0.08794084f, 0.04613523f, 
    0.07278673f, 0.01985961f, 0.15391631f, -0.11368971f, 0.00936988f, 0.00222697f, 0.12490145f, -0.14566620f, 
    0.38554108f, -0.15411472f, 0.34244573f, 0.09055915f, 0.13062179f, 0.18828733f, 0.08226229f, 0.00689511f, 
    0.02932218f, 0.06073488f, 0.06908374f, -0.06643841f, 0.13984935f, 0.08314560f, 0.01263364f, 0.07673215f, 
    0.00046057f, 0.08028833f, 0.00657306f, 0.13321362f, 0.52674150f, -0.29250747f, 0.02799245f, -0.18198568f, 
    0.03510329f, -0.07224539f, 0.11121881f, 0.02085782f, 0.13471164f, -0.00781930f, -0.05190984f, -0.16995032f, 
    0.02539265f, 0.02443137f, -0.04717321f, 0.27335989f, 0.17316936f, 0.12940323f, -0.03539502f, 0.11516846f, 
    -0.22929563f, 0.07702521f, -0.07352459f, 0.09764783f, -0.01822924f, -0.07649941f, -0.07954230f, -0.07738853f, 
    0.09091898f, 0.03103283f, -0.05513768f, -0.04157782f, 0.07654750f, -0.04662745f, -0.05825751f, -0.01068545f, 
    -0.14942285f, -0.03212008f, 0.04411466f, -0.06064719f, -0.23042631f, -0.34135932f, -0.34600580f, -0.12975883f, 
    0.39726275f, 0.08719180f, 0.00815762f, -0.07114346f, -0.06265544f, 0.14781916f, 0.04613796f, 0.07613824f, 
    -0.10400383f, 0.03305313f, -0.00679359f, -0.03994701f, -0.14386046f, 0.02252487f, 0.13120504f, -0.02628979f, 
    0.25256839f, 0.23984805f, 0.16775604f, -0.20883572f, -0.31845912f, 0.11580081f, 0.14377043f, 0.15365300f, 
    0.02108968f, 0.11064621f, -0.04304894f, -0.02705058f, -0.05123917f, -0.07373236f, 0.01044961f, 0.11118966f, 
    -0.01545293f, 0.00569152f, 0.03423642f, 0.13498911f, -0.00592460f, -0.33630157f, -0.33209676f, -0.04555089f, 
    0.07952414f, 0.03783945f, 0.03258413f, -0.04547295f, 0.17548259f, 0.11737274f, -0.10562391f, 0.32365763f, 
    0.08757084f, -0.02448482f, 0.13407068f, -0.00199889f, 0.00854839f, -0.00288726f, 0.23914830f, 0.02340016f, 
    -0.07979992f, -0.08838981f, -0.11108864f, 0.04156995f, -0.00620226f, -0.06955347f, 0.04160571f, 0.03064337f, 
    0.01278925f, 0.10811111f, -0.06456494f, 0.10041772f, 0.26456496f, 0.04105756f, 0.00359644f, -0.09250572f, 
    -0.08595819f, -0.00737418f, -0.00025336f, -0.10921294f, 0.45154479f, 0.06418570f, 0.13862966f, 0.29034373f, 
    -0.35658199f, 0.15242508f, -0.07672048f, -0.17991443f, -0.12254971f, -0.04582540f, 0.03918509f, -0.13413797f, 
    0.03694913f, 0.04545750f, 0.04926390f, 0.11644796f, 0.28087056f, 0.09865965f, -0.01252181f, -0.06468876f, 
    -0.21878900f, -0.05727541f, 0.09402905f, -0.02775485f, -0.30670273f, -0.14484581f, -0.09312636f, -0.06596196f, 
    0.17238629f, 0.17994608f, -0.06713358f, -0.02913005f, 0.07268132f, 0.13258448f, 0.01275111f, 0.05810596f, 
    0.20761175f, -0.02401088f, -0.00884870f, -0.12533559f, 0.34991476f, 0.23452574f, 0.21869180f, -0.03366495f, 
    0.01025609f, 0.16126187f, 0.16071361f, 0.30294690f, 0.02635969f, 0.03262370f, -0.00512574f, -0.14276826f, 
    -0.08480415f, 0.01145769f, 0.01314700f, -0.01508734f, 0.09213192f, -0.03142686f, -0.19844176f, -0.05874252f, 
    -0.21423005f, -0.08039089f, -0.10884962f, 0.00905723f, 0.34551629f, -0.07819739f, 0.10981357f, 0.23512875f, 
    0.02256279f, 0.08614480f, 0.06256877f, 0.15992266f, -0.20426434f, 0.23652014f, -0.31849319f, -0.00786009f, 
    -0.02137733f, 0.09626619f, -0.09519642f, 0.27173603f, -0.20609739f, -0.35748726f, -0.20262067f, 0.15655771f, 
    0.16159128f, -0.00560664f, 0.05801013f, 0.20432581f, 0.06137887f, 0.18788670f, 0.01228399f, 0.12981200f, 
    -0.03580803f, 0.16933773f, -0.15673476f, 0.01504166f, -0.07292217f, 0.00036061f, 0.04170335f, -0.04378351f, 
    -0.13978566f, -0.06872743f, -0.13003413f, 0.08726096f, -0.13547465f, -0.11339463f, 0.00330248f, -0.09085719f, 
    0.08873132f, 0.08473856f, -0.12892464f, 0.16630390f, 0.05846363f, 0.17886810f, 0.10220250f, -0.00916534f, 
    -0.01300939f, -0.14150862f, -0.03683684f, 0.00420565f, 0.12422264f, 0.20809104f, 0.01928387f, -0.44863757f, 
    -0.00171164f, -0.00496641f, -0.11633878f, 0.11238809f, 0.13014862f, 0.15245457f, -0.03518488f, -0.07656801f, 
    0.11318048f, -0.06166877f, -0.07581019f, -0.16180521f, -0.08012462f, 0.33728248f, 0.07039727f, 0.18036158f, 
    -0.04488445f, 0.08674518f, -0.10316886f, 0.06207877f, 0.13715464f, 0.05119117f, 0.07794861f, 0.20925595f, 
    0.11190765f, -0.18362652f, -0.08777852f, -0.06908210f, -0.01427415f, -0.07382683f, 0.00400384f, -0.06169288f, 
    -0.08094587f, 0.09137918f, -0.05280194f, -0.10028865f, -0.13217191f, -0.33132547f, -0.13905658f, 0.13240823f, 
    0.26092729f, 0.04360350f, -0.02831647f, 0.08996721f, -0.01646480f, -0.05623794f, 0.26115197f, 0.07758089f, 
    0.16781566f, 0.16217758f, 0.07980688f, 0.13683727f, -0.16648251f, 0.14811596f, 0.01276182f, -0.00399981f, 
    0.03726112f, -0.14019841f, 0.45769608f, 0.09640314f, -0.25759459f, -0.01920197f, -0.02782385f, -0.06245827f, 
    -0.13736473f, -0.06199616f, -0.02742187f, 0.01687922f, 0.42842326f, 0.07412646f, 0.06262626f, 0.31172377f, 
    0.24866989f, 0.00788075f, -0.07545484f, -0.24399754f, -0.29125935f, -0.15153724f, 0.19481772f, -0.18264052f, 
    0.18107377f, 0.04159235f, -0.12880664f, 0.09036489f, 0.00175491f, 0.07266360f, 0.14588372f, 0.00272654f, 
    -0.10499120f, 0.11956167f, -0.09396835f, 0.08556659f, 0.18721162f, 0.10645072f, 0.04862866f, 0.04789903f, 
    -0.12432669f, -0.20592958f, -0.10101803f, 0.14221935f, 0.04459954f, -0.07716218f, 0.03178946f, 0.09546031f, 
    0.10398842f, 0.03301914f, -0.05662064f, 0.10315925f, -0.13505323f, -0.20614308f, -0.11411323f, -0.12150505f, 
    -0.00503780f, 0.06120662f, -0.00609207f, 0.02679546f, 0.45597231f, 0.38795164f, -0.19898006f, -0.13687597f, 
    -0.07766326f, -0.02037029f, -0.10619081f, -0.22445165f, 0.06299941f, 0.16383281f, 0.02204005f, -0.00422197f, 
    0.04244039f, 0.04331838f, -0.00424764f, -0.08807441f, 0.03517908f, -0.03248858f, -0.10370851f, 0.04520838f, 
    -0.23999985f, -0.14689210f, -0.01524247f, 0.16706657f, 0.33203012f, 0.17662673f, -0.12650023f, 0.13671917f, 
    0.02102615f, 0.08015989f, 0.09785468f, 0.06915991f, -0.08752418f, 0.07819081f, -0.04183621f, -0.06950993f, 
    -0.05053669f, -0.05262354f, 0.02931732f, -0.09044590f, -0.27675018f, -0.04479714f, 0.26442656f, 0.00418718f, 
    -0.33638963f, -0.04179757f, -0.10044619f, -0.18696931f, -0.15069430f, -0.18112081f, 0.01787970f, 0.04348723f, 
    0.02762450f, 0.11796053f, 0.09578478f, -0.00485197f, -0.11824664f, -0.02122787f, 0.05768969f, -0.12383078f, 
    -0.18225828f, -0.02269118f, -0.04725713f, 0.00875364f, -0.19871041f, -0.07134921f, -0.16553284f, -0.19600299f, 
    -0.02471405f, -0.08427934f, 0.10099994f, 0.02508393f, 0.17740235f, -0.03642146f, 0.03582416f, 0.02648784f, 
    0.11223707f, -0.05553207f, 0.14175874f, 0.21969260f, -0.23004417f, 0.45011121f, 0.33971635f, 0.05532030f, 
    0.44961500f, 0.00712493f, 0.16372313f, 0.00339400f, -0.01914332f, 0.19536112f, -0.05628760f, 0.18252443f, 
    0.16572067f, 0.03235308f, 0.17100033f, -0.09217170f, -0.04523231f, -0.17054857f, -0.06130194f, -0.04415847f, 
    -0.51290900f, 0.16561976f, 0.66156232f, -0.06392790f, 0.22505805f, -0.08872374f, -0.19348784f, -0.13357487f, 
    -0.01050627f, -0.04190999f, -0.01295196f, 0.01190971f, -0.03828590f, 0.00341367f, -0.01128993f, 0.12786399f, 
    -0.24469467f, -0.06364410f, -0.10764144f, -0.18078028f, -0.37411720f, -0.16752580f, -0.22383964f, 0.19252160f, 
    0.26949969f, -0.10904232f, -0.15729642f, -0.13241915f, 0.28202945f, 0.02295482f, -0.02241728f, 0.05610943f, 
    -0.06671352f, -0.11626563f, -0.12701905f, -0.10794136f, 0.06254423f, 0.03586892f, -0.12714520f, -0.11689562f, 
    0.51559889f, 0.13228312f, -0.05108732f, -0.21583617f, -0.07276469f, 0.02995174f, 0.08085474f, -0.07599991f, 
    0.11772648f, 0.02764773f, 0.21496239f, 0.07319768f, 0.03084393f, -0.00831410f, 0.14026301f, -0.08854828f, 
    0.00436347f, 0.14102288f, 0.16163836f, 0.04686058f, 0.40577099f, 0.21154895f, 0.17998576f, -0.31024438f, 
    -0.13079581f, 0.18978846f, -0.03313671f, 0.01137525f, 0.06370053f, -0.16271414f, 0.18008105f, 0.11201096f, 
    0.03193782f, -0.01619769f, 0.19530717f, -0.08074600f, -0.10706785f, 0.05401921f, 0.12788248f, 0.05219139f, 
    -0.48736802f, -0.01593036f, 0.10815174f, -0.17308807f, -0.10840350f, -0.09230561f, -0.24259631f, -0.20801871f, 
    -0.16835369f, -0.11644488f, 0.12174562f, -0.02537224f, 0.00522030f, -0.05856275f, -0.04638331f, 0.11995538f, 
    0.06342403f, 0.17665690f, 0.00649964f, -0.04526033f, -0.05365650f, -0.16759685f, 0.08439728f, 0.31020862f, 
    0.04895146f, 0.05652997f, 0.18246071f, -0.00687920f, 0.15948473f, 0.08199784f, -0.06791859f, 0.02935967f, 
    -0.04613521f, -0.08215071f, -0.07392357f, 0.10691364f, 0.08657549f, 0.03576702f, -0.07901943f, -0.10767046f, 
    0.15458785f, -0.12537235f, -0.21312284f, 0.08452457f, 0.26274443f, 0.13225825f, 0.17204966f, 0.07365815f, 
    0.18538919f, 0.09459726f, -0.14193970f, 0.10677161f, 0.05697546f, 0.08858138f, 0.07248636f, 0.10752259f, 
    0.17313431f, 0.14315584f, 0.10024921f, 0.14299057f, 0.66214013f, 0.51677793f, 0.46496820f, 0.13426422f, 
    -0.07940602f, 0.05462759f, -0.11501941f, -0.12225559f, 0.04526453f, -0.15797013f, -0.05038923f, 0.08875397f, 
    0.13874869f, -0.05226960f, 0.15375732f, -0.01886973f, 0.04209572f, -0.11383232f, -0.03798833f, 0.01005568f, 
    0.21314257f, -0.06216119f, 0.16036196f, 0.08007270f, 0.23816714f, -0.01970623f, 0.05492285f, 0.08563896f, 
    -0.08868656f, -0.06878234f, 0.00919453f, -0.01482461f, 0.05481233f, -0.14122352f, -0.02449739f, -0.12772423f, 
    -0.22163445f, -0.18599124f, -0.07610644f, -0.22234413f, 0.54251623f, 0.04978731f, 0.02329490f, 0.09468947f, 
    0.00823046f, -0.03638973f, 0.07679038f, -0.01480915f, -0.00939778f, 0.06500050f, -0.03808020f, -0.05983777f, 
    -0.04026082f, 0.13856769f, 0.07199638f, 0.19454551f, 0.01317615f, 0.11007934f, 0.02958202f, 0.03374631f, 
    -0.23305897f, -0.03784831f, -0.11607289f, -0.16180548f, -0.04498103f, -0.00503875f, -0.12369940f, -0.10149942f, 
    -0.22017616f, 0.02953391f, 0.15434457f, 0.08318289f, 0.04707740f, 0.03904389f, 0.06830259f, 0.06593106f, 
    0.00493010f, -0.07639241f, 0.20822553f, -0.01589633f, 0.06469469f, -0.41074345f, -0.05821861f, 0.10300679f, 
    0.19544655f, 0.21533045f, 0.15235326f, 0.06466112f, 0.08745308f, 0.09470276f, -0.09284553f, -0.10424553f, 
    -0.06893985f, -0.04900802f, 0.00129287f, 0.10555829f, 0.13598743f, 0.05595624f, 0.12683213f, 0.26701176f, 
    0.08985670f, 0.21175709f, -0.13955095f, 0.52384818f, 0.17867750f, 0.17211828f, 0.01140187f, 0.07143740f, 
    -0.09311084f, 0.03356953f, 0.03707982f, 0.07386275f, 0.02303774f, -0.08492497f, 0.05272008f, 0.21631214f, 
    0.09816568f, 0.00752434f, 0.05433859f, 0.02842123f, 0.61127073f, 0.12876931f, 0.09372429f, 0.18693148f, 
    0.07178097f, -0.07325372f, -0.04047725f, -0.01546421f, -0.01429636f, -0.03847038f, -0.00304958f, 0.06886072f, 
    -0.04639455f, -0.03620253f, 0.00249664f, 0.04115802f, 0.03547217f, -0.13739394f, -0.06253477f, -0.11243617f, 
    0.12866043f, 0.13020933f, 0.14610511f, 0.14323795f, 0.00506364f, -0.19926748f, 0.11154476f, 0.01581526f, 
    -0.00368018f, -0.04557213f, -0.01394400f, 0.05758666f, 0.18710724f, -0.00931258f, 0.05472422f, -0.02771442f, 
    -0.04210427f, 0.19373812f, 0.03988588f, -0.15767808f, 0.18358532f, 0.36370552f, 0.00678453f, 0.25345922f, 
    -0.32415852f, -0.09584212f, 0.02454778f, -0.11764700f, 0.01268816f, -0.17368397f, 0.03408629f, -0.21823791f, 
    -0.03362948f, 0.03610075f, 0.14666724f, 0.18260759f, -0.07795026f, 0.11582727f, -0.08162548f, 0.02545449f, 
    0.70762837f, -0.08538829f, 0.14249068f, 0.06396300f, -0.13142326f, -0.12073481f, -0.07376765f, -0.07538875f, 
    -0.00557617f, -0.06829922f, -0.05923234f, -0.01554574f, 0.03391910f, -0.07852668f, 0.11609592f, 0.04577652f, 
    0.07431907f, -0.06734908f, 0.12926076f, 0.13803072f, 0.03229003f, 0.27698258f, -0.08068354f, 0.30590701f, 
    0.21692009f, -0.06089160f, -0.00758975f, -0.13534637f, 0.04532608f, 0.00307223f, -0.00268611f, 0.05982307f, 
    0.06640331f, -0.01132284f, 0.01559190f, 0.04485711f, 0.08939684f, 0.04284297f, 0.06067814f, 0.00385618f, 
    -0.45635322f, 0.24749346f, 0.02525862f, -0.00370453f, 0.11581893f, -0.11759486f, 0.05595797f, -0.04911845f, 
    -0.04265068f, -0.00498964f, -0.02862252f, 0.33347723f, 0.11695588f, 0.17554809f, -0.10423279f, 0.08754570f, 
    0.01191483f, 0.06770845f, -0.05877004f, 0.16635393f, 0.07258677f, -0.10667039f, 0.11570155f, 0.03585989f, 
    0.11062421f, 0.02860414f, -0.13511944f, 0.07428034f, -0.18943323f, 0.06583698f, -0.00076874f, 0.00470914f, 
    0.05030732f, 0.13773106f, -0.06953610f, -0.03023660f, -0.04252720f, -0.05679476f, 0.03109197f, -0.15039469f, 
    0.19938593f, 0.03035252f, 0.15925004f, 0.11705172f, 0.03509947f, 0.01272328f, 0.06141590f, 0.06908850f, 
    -0.07574524f, -0.07672228f, -0.11485309f, 0.02466992f, 0.13923699f, 0.11675002f, 0.17852421f, -0.01137104f, 
    0.14598513f, 0.12952513f, 0.03645206f, -0.00326320f, -0.13096289f, -0.09038973f, -0.30338034f, 0.11372734f, 
    0.24368313f, 0.14229344f, -0.10640823f, 0.02173572f, -0.01131382f, -0.02400647f, -0.12140021f, 0.04400779f, 
    0.04096201f, -0.08044486f, 0.12863292f, 0.00794476f, 0.02173355f, 0.09152376f, -0.19886397f, -0.09592486f, 
    -0.18319240f, 0.08213285f, -0.11601721f, 0.02787646f, -0.02833228f, -0.23123115f, -0.09998199f, 0.05356902f, 
    -0.03473885f, 0.00816020f, -0.06699625f, 0.07289757f, 0.11766142f, 0.05232834f, -0.06691868f, -0.01240421f, 
    -0.07674310f, -0.04855324f, -0.09056873f, -0.04956190f, -0.19467784f, -0.07094642f, 0.29141116f, 0.16074286f, 
    0.29696336f, 0.15806223f, 0.12445243f, 0.10125112f, -0.11094045f, -0.08138780f, 0.05713531f, 0.10455876f, 
    0.11984465f, 0.13987559f, 0.07666745f, 0.02154370f, 0.05947866f, 0.04272106f, 0.09483733f, -0.14120643f, 
    -0.19184302f, -0.00389105f, 0.20712677f, 0.09647883f, -0.27503479f, 0.19669537f, -0.00383004f, -0.02435862f, 
    -0.12799633f, -0.03429594f, 0.07100131f, -0.03556177f, 0.11419239f, -0.00114493f, -0.12089693f, 0.35189575f, 
    -0.20972680f, 0.06906622f, 0.06005581f, 0.09743580f, -0.08913203f, -0.17334853f, 0.35187942f, 0.11513344f, 
    0.25253963f, 0.02156644f, 0.03738670f, -0.04778252f, 0.06693055f, -0.09850892f, 0.00799778f, -0.05099902f, 
    -0.10628233f, -0.05304185f, 0.07749228f, 0.05594568f, 0.12595601f, 0.24838723f, 0.05468660f, -0.09117371f, 
    0.25035089f, -0.05928469f, -0.06028344f, 0.10304165f, -0.00346609f, -0.10523458f, 0.02275014f, -0.00578717f, 
    0.00324116f, 0.01788095f, 0.03357203f, 0.07838885f, 0.12265360f, -0.03475184f, -0.06873585f, -0.17915756f, 
    -0.05834761f, -0.12478648f, -0.14442365f, 0.01617268f, -0.46166804f, 0.06602629f, 0.10254274f, 0.22995561f, 
    0.28213534f, -0.04330746f, 0.03139040f, 0.01160560f, 0.04425145f, 0.23415224f, -0.04345436f, 0.13385449f, 
    -0.14638236f, -0.00349854f, -0.05219450f, -0.13754041f, -0.05688808f, -0.01734772f, 0.04892763f, -0.06331635f, 
    -0.02487276f, 0.05086837f, -0.00367324f, -0.03329843f, -0.04083566f, -0.03075194f, 0.01388393f, 0.04273790f, 
    0.03191055f, -0.04970939f, -0.00727444f, 0.00987692f, -0.01082063f, -0.04975425f, -0.04386237f, -0.02886146f, 
    -0.03988518f, -0.01689774f, -0.05113801f, -0.00983506f, 0.02784856f, 0.01539989f, 0.02949616f, -0.04607366f, 
    0.01544777f, -0.01152899f, -0.02488948f, -0.01310553f, -0.02256634f, -0.02216628f, 0.03849022f, -0.02461989f, 
    0.02264678f, -0.00271656f, -0.01379732f, 0.03410161f, -0.04832367f, -0.03385836f, 0.02459509f, -0.06067643f, 
    0.04117209f, -0.04972544f, 0.04203378f, 0.02523018f, -0.02765508f, -0.02798570f, -0.01000318f, 0.00507340f, 
    -0.02799784f, 0.03593003f, -0.04514046f, 0.00938363f, -0.05266998f, 0.01455027f, 0.01880458f, -0.05973306f, 
    0.03072302f, 0.04716046f, 0.04592929f, 0.03809448f, 0.02715172f, -0.03617517f, -0.02801402f, 0.02586725f, 
    -0.00923915f, 0.03830330f, 0.03437348f, 0.00593459f, 0.02180111f, -0.01027141f, 0.01733022f, 0.04959293f, 
    -0.02907715f, 0.02797618f, 0.01001909f, -0.01574257f, 0.02413236f, -0.02476731f, 0.03591904f, -0.02622693f, 
    -0.04012987f, 0.03301088f, -0.05518457f, -0.03731200f, -0.04716067f, -0.03621465f, 0.02172935f, 0.04837179f, 
    -0.00134829f, -0.02007382f, -0.04486257f, -0.02491615f, -0.00416179f, -0.05244919f, 0.04545034f, 0.02843731f, 
    -0.05923253f, 0.02784668f, 0.01167101f, -0.04160289f, -0.00859775f, 0.01024058f, 0.01719112f, 0.01608274f, 
    0.03376330f, -0.04920937f, 0.04800562f, 0.04182000f, 0.05281207f, -0.01805815f, 0.01127101f, -0.05480241f, 
    0.01384742f, -0.04448156f, 0.03646951f, -0.05058241f, -0.01918105f, 0.04399487f, -0.04648512f, 0.04233496f, 
    -0.02788104f, 0.04491553f, -0.05053219f, 0.01260691f, 0.00105023f, -0.00080636f, -0.04972669f, -0.06094873f, 
    0.02612122f, -0.03723093f, -0.03222526f, -0.05590644f, -0.06052703f, -0.04423826f, -0.04423835f, 0.01683860f, 
    -0.02434979f, -0.01071901f, 0.03907510f, -0.02330276f, -0.03793976f, -0.00702734f, 0.04124015f, 0.01996352f, 
    0.02183192f, -0.00494712f, 0.02696582f, -0.02999567f, -0.04927408f, -0.04238165f, -0.00644647f, 0.01597143f, 
    -0.03341490f, -0.02075719f, -0.02600872f, -0.00378715f, -0.02546457f, 0.02312957f, -0.04174372f, -0.01892442f, 
    -0.00966838f, 0.00617613f, -0.02653275f, 0.02573938f, 0.03737804f, -0.02826027f, -0.03859159f, 0.01505352f, 
    -0.00442121f, 0.04613256f, 0.03459139f, -0.04752044f, -0.05898121f, 0.02015007f, -0.03742920f, -0.04322726f, 
    -0.04047815f, -0.01009966f, -0.03690009f, 0.00821737f, 0.02264514f, -0.05254571f, -0.01707197f, -0.05441891f, 
    0.02402244f, 0.02639652f, -0.04937134f, -0.03961218f, 0.02152239f, -0.04361866f, -0.00687736f, -0.03821296f, 
    -0.04826448f, 0.03553233f, -0.04306116f, -0.04586957f, 0.05014463f, -0.03327435f, -0.02302276f, 0.00559790f, 
    -0.03013349f, 0.04543424f, 0.01766466f, 0.00626553f, 0.04027242f, -0.04683882f, -0.02488992f, -0.02678213f, 
    0.04588410f, 0.04154912f, 0.04092957f, 0.00351822f, -0.02926070f, -0.04598682f, 0.00384308f, -0.04029853f, 
    -0.03143530f, 0.00616248f, -0.04280014f, -0.02305226f, 0.01513921f, -0.02315892f, -0.00422070f, 0.00887773f, 
    -0.05440194f, -0.02773855f, -0.00726590f, -0.05271025f, -0.05017838f, 0.02221058f, 0.04712186f, -0.03162062f, 
    0.00145694f, 0.02610945f, -0.05485037f, -0.01562705f, -0.00270600f, -0.02781492f, -0.01304411f, -0.04232777f, 
    -0.03047755f, 0.00101999f, 0.03604569f, 0.02812445f, -0.03462501f, 0.02615490f, -0.03327791f, -0.04049555f, 
    -0.00942392f, 0.00863255f, 0.04067264f, -0.04672471f, -0.02685875f, 0.02603247f, -0.03345169f, -0.02244982f, 
    -0.02580231f, -0.03593650f, -0.05072910f, 0.02704208f, -0.04417677f, 0.00621472f, 0.01000052f, 0.04426083f, 
    -0.00877516f, -0.00746072f, -0.04133689f, -0.04650148f, -0.05380430f, 0.04488413f, -0.01001395f, 0.03062549f, 
    0.04350599f, -0.02257658f, -0.01950236f, 0.01168764f, 0.04451809f, -0.03767072f, -0.02364718f, -0.03215923f, 
    -0.03720465f, 0.03316642f, 0.04877282f, 0.00121685f, 0.00932304f, -0.01365264f, -0.02441895f, 0.03439019f, 
    -0.00603695f, 0.01093798f, 0.03980517f, -0.03601146f, -0.04098325f, -0.01828763f, -0.05222088f, 0.00811044f, 
    0.02249887f, -0.04009192f, -0.05000991f, 0.01418320f, -0.01061772f, -0.02117461f, -0.00457563f, 0.03455488f, 
    -0.02756287f, -0.03919527f, 0.03520831f, -0.05501445f, 0.02050359f, -0.00833080f, 0.04513624f, 0.00472957f, 
    -0.03738371f, -0.05653244f, 0.05248221f, 0.00961207f, 0.00164416f, -0.03671646f, -0.01770005f, -0.03771615f, 
    -0.31537828f, -0.39827958f, -0.14210664f, 0.02970633f, -0.07179243f, -0.25866207f, 0.00100491f, 0.11376295f, 
    0.03876843f, -0.02593617f, -0.07339889f, -0.08833868f, 0.06887885f, -0.06119085f, -0.05331322f, 0.15295172f, 
    0.17048417f, 0.11998882f, 0.13332970f, 0.04768584f, -0.40187204f, 0.03747494f, 0.13901938f, 0.09869729f, 
    -0.07652307f, -0.07821156f, -0.10445140f, -0.05806017f, -0.07832339f, -0.19717051f, -0.04684066f, 0.11296501f, 
    0.09165671f, 0.15487429f, 0.05859057f, 0.00045367f, -0.08646918f, 0.07253733f, -0.01975236f, -0.00953604f, 
    -0.19215076f, -0.13433157f, 0.04813953f, -0.03285150f, -0.30386063f, 0.08863685f, -0.11599701f, 0.08740158f, 
    0.03638874f, -0.01561140f, 0.02059409f, 0.06550056f, -0.10071861f, 0.05039458f, -0.10449954f, 0.05904180f, 
    0.10806892f, -0.08389403f, 0.13333119f, 0.18935959f, -0.58622706f, 0.15258084f, 0.06076140f, 0.05206412f, 
    0.23164158f, 0.29034689f, 0.00114324f, 0.19663934f, 0.11237726f, 0.06075168f, -0.05839570f, 0.18176247f, 
    0.12519488f, 0.00081087f, 0.13811392f, 0.07156312f, -0.03240197f, 0.14058399f, 0.14177665f, 0.10692236f, 
    -0.02288195f, -0.00632517f, 0.26483154f, -0.11407562f, -0.10716072f, -0.13448447f, -0.04985023f, 0.09458265f, 
    0.00446790f, -0.01178982f, -0.11560847f, 0.04448770f, -0.05088246f, -0.03351746f, -0.08808305f, -0.03610724f, 
    -0.04954535f, 0.00156364f, -0.04404054f, 0.09102929f, -0.35524198f, -0.19200818f, -0.39479280f, -0.15474844f, 
    -0.26365662f, -0.16866107f, -0.28187057f, -0.09252819f, 0.11967711f, 0.03334808f, 0.01056734f, 0.11591636f, 
    -0.02201544f, -0.04163386f, -0.10260774f, -0.00783993f, 0.03539759f, 0.08264181f, 0.03399407f, 0.07141431f, 
    0.30079344f, 0.35668081f, 0.30677530f, 0.02213300f, -0.12672442f, 0.20198573f, 0.01955273f, 0.15986666f, 
    0.08550441f, -0.04044256f, 0.12306535f, 0.13736221f, 0.08293507f, 0.01641931f, -0.01126719f, 0.02596504f, 
    -0.10342515f, 0.13995054f, 0.03485068f, -0.03623542f, 0.14836706f, 0.46575525f, 0.27878571f, -0.08607060f, 
    -0.06168584f, 0.02411487f, -0.02541282f, -0.03128893f, 0.13428147f, -0.05844366f, 0.04973254f, 0.10381533f, 
    0.02546084f, 0.06816214f, 0.15799533f, -0.04840468f, -0.03038961f, -0.03272405f, 0.09384526f, 0.12652901f, 
    -0.03274123f, -0.15748551f, 0.16652273f, -0.11866267f, -0.18874612f, -0.07158834f, 0.08803074f, 0.05552763f, 
    0.10845210f, -0.05203106f, -0.09048483f, -0.06086749f, 0.01967642f, -0.10428654f, -0.14391808f, 0.05365303f, 
    -0.05387469f, 0.18641423f, -0.14301725f, -0.01757436f, -0.13242611f, -0.15193850f, -0.04047472f, 0.14085796f, 
    -0.07261806f, -0.04982943f, 0.10060669f, 0.01920120f, -0.09355159f, -0.01227855f, 0.09370622f, -0.08899213f, 
    -0.07940970f, 0.02127086f, -0.19323212f, 0.17930910f, -0.05469364f, -0.01684884f, 0.08183856f, 0.09616780f, 
    0.06121170f, -0.20812862f, 0.42360771f, 0.29225826f, 0.18319915f, -0.03817236f, -0.05361333f, -0.12380476f, 
    0.11168098f, 0.15749672f, -0.04909272f, -0.00695264f, 0.04257057f, 0.04395326f, 0.14103098f, -0.01172827f, 
    -0.04680583f, 0.06595284f, 0.12508832f, -0.00544493f, 0.12630494f, 0.58371586f, 0.05200132f, 0.07122131f, 
    -0.02363107f, 0.01143697f, 0.08618756f, -0.00431530f, 0.03693348f, -0.08251189f, 0.08424795f, 0.17006621f, 
    0.11697630f, -0.00763974f, 0.13659227f, 0.06581061f, 0.08004966f, -0.09169417f, 0.18906729f, 0.14150520f, 
    0.49828529f, -0.00663135f, -0.13222221f, 0.05582452f, 0.27688867f, 0.14229938f, 0.11309303f, 0.18848285f, 
    0.03647184f, -0.08150519f, 0.00902003f, 0.04388029f, 0.07229626f, 0.06571057f, 0.10813586f, -0.13615955f, 
    0.03372813f, -0.00694472f, 0.15065917f, 0.09018612f, 0.47039661f, -0.32185671f, 0.33529708f, 0.24942574f, 
    -0.00685987f, -0.17168938f, 0.03844424f, 0.00133555f, -0.18291861f, 0.07847518f, 0.04186620f, -0.11896071f, 
    0.08798008f, 0.20974903f, -0.12584813f, 0.06263243f, 0.00536733f, 0.15007165f, 0.00942166f, 0.12367911f, 
    -0.36333624f, 0.09370371f, -0.07843268f, -0.09181543f, -0.00524390f, -0.13873911f, -0.10995396f, -0.00361058f, 
    0.08664475f, -0.02216821f, -0.11183251f, 0.04645374f, -0.01936656f, 0.11290415f, 0.16245063f, -0.04933628f, 
    -0.08185763f, -0.06894060f, 0.14202988f, 0.04379350f, -0.25959441f, -0.65824175f, -0.19496718f, -0.07015818f, 
    -0.11954135f, 0.02545214f, -0.01094848f, 0.11654788f, -0.02694689f, -0.13907737f, 0.13687401f, -0.02476034f, 
    -0.04119029f, -0.01217880f, -0.11802419f, 0.06956991f, -0.10426256f, -0.02570534f, 0.18023108f, 0.09516779f, 
    0.15165836f, 0.25444967f, -0.08253389f, 0.03711582f, -0.15724289f, 0.14490731f, 0.00862992f, 0.16314803f, 
    0.03161445f, 0.01806717f, -0.06965148f, 0.04293614f, 0.05399264f, 0.14773829f, 0.21070531f, 0.19963309f, 
    -0.08956196f, -0.22430734f, -0.09251045f, -0.07720520f, 0.05092914f, -0.00988591f, 0.10181288f, 0.03815743f, 
    0.14150764f, -0.17126660f, -0.08911032f, -0.06000854f, -0.11036919f, -0.02245358f, 0.07309913f, 0.18886636f, 
    0.06331784f, 0.02416141f, 0.17709322f, 0.05526920f, 0.01114459f, 0.07154896f, -0.09931177f, -0.09642588f, 
    0.10130341f, 0.10828035f, -0.01369536f, 0.09541368f, 0.05244235f, 0.04673801f, -0.04587641f, -0.11402775f, 
    -0.10432730f, -0.09230381f, -0.15443113f, -0.03092385f, 0.04094171f, 0.15026353f, 0.21219693f, 0.10326957f, 
    0.04124349f, 0.06572627f, -0.09782254f, 0.10427675f, 0.50547808f, -0.26016417f, -0.14525421f, 0.00966380f, 
    -0.08497661f, 0.11134084f, 0.06215126f, -0.10531826f, 0.16786325f, 0.17363364f, 0.10570361f, 0.02858779f, 
    0.05375870f, -0.12691499f, -0.07774179f, -0.01050880f, -0.02109497f, -0.01101661f, -0.01809890f, 0.04853475f, 
    0.32469174f, 0.26130310f, -0.02946622f, 0.12174585f, -0.05234436f, 0.11442700f, -0.06759991f, -0.08031453f, 
    -0.07747166f, -0.11366620f, -0.11524580f, -0.01111803f, -0.04717463f, -0.01452129f, -0.03976611f, 0.02249188f, 
    -0.11376701f, 0.06977541f, -0.07124595f, -0.03644410f, 0.11549359f, 0.20305121f, 0.18848066f, -0.13634682f, 
    -0.30560595f, 0.14389539f, 0.01646292f, 0.11900347f, -0.06865993f, 0.01930116f, -0.03174210f, -0.11507402f, 
    -0.04204489f, -0.09068164f, -0.03835196f, 0.02756945f, -0.04293474f, -0.08963990f, 0.11521936f, 0.06356085f, 
    0.20429449f, -0.36720353f, 0.08276878f, 0.11710882f, -0.15448561f, 0.02266793f, 0.04941093f, 0.31091815f, 
    0.21588032f, 0.21903278f, 0.20740360f, -0.11361537f, 0.12959930f, 0.06676687f, 0.01128760f, -0.05150193f, 
    0.10837754f, -0.04381924f, 0.09367597f, -0.04031276f, -0.18264121f, -0.24096549f, -0.10189284f, 0.05009611f, 
    0.02174219f, -0.15766650f, -0.00883445f, 0.07789366f, 0.11146140f, 0.00051931f, 0.25576797f, 0.25695053f, 
    0.03738139f, 0.23866662f, 0.14461994f, -0.01288974f, -0.08317773f, 0.07543033f, -0.04516996f, -0.15265387f, 
    0.15976007f, 0.05374730f, 0.02432107f, 0.12020940f, 0.02366207f, -0.00026385f, 0.15255493f, -0.03094393f, 
    -0.02709590f, 0.00981530f, -0.11735130f, 0.08001117f, 0.07139815f, -0.03197866f, 0.12010008f, -0.10442072f, 
    0.13148086f, 0.07095020f, -0.06331974f, 0.04665169f, 0.18027310f, 0.23606119f, 0.20305586f, -0.18138476f, 
    -0.16053748f, 0.24986263f, -0.08410747f, 0.06395822f, 0.05807110f, -0.06565672f, 0.08318275f, 0.01894741f, 
    0.07937085f, 0.03793084f, 0.15248534f, 0.11066227f, 0.06071474f, -0.00029416f, 0.00915041f, -0.13772638f, 
    -0.30646494f, -0.04739529f, -0.17190787f, 0.01695595f, -0.23785229f, -0.13323848f, 0.05262202f, 0.05200979f, 
    0.07583766f, 0.25771695f, 0.05733150f, 0.02853138f, -0.05078502f, -0.06983477f, -0.10278185f, -0.05941785f, 
    0.10926910f, 0.07427520f, -0.02775463f, 0.12964471f, -0.21314020f, -0.49247390f, 0.04668167f, 0.23119491f, 
    0.09620321f, 0.00514830f, -0.10865620f, 0.07617443f, 0.09472303f, 0.02721014f, 0.29502937f, 0.01059001f, 
    0.16099292f, 0.27852729f, 0.25867310f, 0.20946352f, -0.10146620f, -0.04606899f, 0.02636574f, 0.03781618f, 
    0.07468981f, 0.35098529f, -0.06156761f, 0.00173969f, 0.12990260f, -0.25621536f, -0.06838672f, -0.05259835f, 
    -0.13586675f, -0.13439646f, 0.03767998f, 0.06453566f, -0.03756186f, -0.08166484f, -0.14838813f, 0.08755036f, 
    -0.03863456f, 0.14187922f, -0.10632013f, -0.31185734f, -0.25986749f, 0.24019374f, 0.35516760f, 0.36112380f, 
    0.42213061f, -0.04874976f, -0.14839076f, -0.06895725f, -0.05302609f, -0.05643247f, -0.07579520f, 0.10147268f, 
    -0.05319917f, 0.00115102f, 0.03817962f, 0.20543446f, -0.18408735f, -0.09346969f, 0.09454431f, -0.10889075f, 
    0.00592937f, -0.05831117f, 0.01103674f, 0.08816478f, -0.00634161f, -0.00383044f, 0.05420343f, -0.00371189f, 
    0.05111667f, 0.01339078f, 0.20258252f, 0.18143757f, 0.15194923f, 0.02788448f, 0.08654349f, -0.14273807f, 
    -0.03088753f, -0.00491156f, -0.00688381f, 0.05831764f, 0.02687331f, 0.15565139f, 0.13786675f, -0.21739450f, 
    -0.42909980f, -0.08203763f, -0.03077369f, -0.12764736f, 0.09689628f, -0.32596144f, -0.09076389f, -0.05385209f, 
    -0.01187835f, -0.10602064f, 0.02431514f, -0.01085302f, 0.11726896f, 0.06833120f, 0.19209310f, 0.37698704f, 
    -0.03080685f, -0.05414161f, 0.00468318f, 0.01474162f, 0.03248761f, -0.04447053f, -0.00914112f, -0.03831248f, 
    0.02614625f, -0.01343077f, -0.00403791f, 0.04706151f, 0.00005270f, -0.00348030f, 0.00031867f, -0.03165912f, 
    0.02491955f, 0.04720192f, 0.04954737f, -0.05455545f, -0.01741565f, -0.02666289f, 0.02317802f, -0.00279473f, 
    -0.06175762f, 0.00097891f, 0.01799972f, 0.04285968f, -0.02327627f, -0.02090269f, -0.04527006f, 0.05822953f, 
    -0.02057656f, 0.01605685f, -0.05004457f, -0.01807252f, -0.02328215f, 0.00228278f, -0.02087457f, -0.01315285f, 
    0.03057286f, -0.04837340f, -0.04504210f, 0.04225676f, 0.04223548f, 0.00259251f, -0.04362036f, 0.01308455f, 
    0.00430686f, -0.04041854f, 0.03719532f, 0.02517205f, 0.02664844f, -0.01640631f, -0.02248231f, -0.02082721f, 
    0.03011170f, 0.00176014f, -0.04690675f, 0.00784682f, 0.01587694f, -0.00832807f, -0.01988699f, -0.01972515f, 
    0.01206263f, 0.04475632f, -0.03145273f, -0.02462615f, 0.01906645f, -0.03278972f, -0.00883272f, -0.03558385f, 
    0.03076329f, -0.00592409f, -0.01170739f, 0.06039600f, 0.00706952f, -0.06134759f, 0.02187824f, -0.04906173f, 
    -0.02140952f, 0.03985848f, -0.00457868f, -0.01968989f, 0.03592148f, -0.01377339f, -0.00576443f, 0.04129392f, 
    0.04603480f, 0.03024020f, -0.00769218f, -0.03428062f, -0.05626782f, -0.05161417f, 0.03525251f, -0.01033291f, 
    -0.01807928f, 0.04824682f, 0.01645981f, -0.05161448f, -0.02534340f, -0.05508902f, -0.01952006f, 0.01787062f, 
    0.01976231f, -0.05609445f, -0.04559975f, -0.00354178f, 0.00550897f, -0.01216101f, -0.04960716f, 0.01301855f, 
    -0.03959943f, 0.02486515f, 0.03491138f, 0.00997562f, 0.03271608f, -0.05698640f, 0.02701494f, -0.00329663f, 
    -0.01109828f, -0.01519656f, -0.04852390f, -0.02453838f, 0.03338465f, -0.02396581f, 0.05528617f, 0.04038647f, 
    -0.05577023f, 0.02477992f, 0.01281895f, 0.01201213f, -0.01595261f, -0.04438196f, 0.05393388f, 0.01801326f, 
    0.04189977f, 0.00187855f, -0.01708886f, -0.03549812f, 0.04172340f, 0.03575457f, 0.00793371f, -0.01714300f, 
    0.04475635f, 0.04784201f, -0.04721316f, 0.01611197f, 0.02321911f, -0.02734140f, 0.06001032f, -0.04908228f, 
    0.01798725f, -0.04359510f, -0.04110469f, 0.02672711f, -0.02983296f, 0.03028585f, -0.03991186f, 0.04424605f, 
    0.00042752f, 0.00907069f, -0.05592245f, -0.01192883f, -0.05418529f, -0.03836491f, -0.00306532f, -0.01448364f, 
    -0.03283521f, -0.05574979f, -0.05526477f, -0.04734417f, -0.02320902f, -0.00915579f, 0.02566397f, -0.02514632f, 
    -0.00669623f, 0.03538937f, 0.04364825f, 0.03741781f, 0.01248878f, -0.01041667f, 0.03272383f, -0.04456565f, 
    0.00228818f, -0.00077884f, 0.00990873f, 0.04113489f, -0.00740528f, -0.05419156f, -0.03651780f, -0.05251353f, 
    0.01616048f, -0.05621676f, -0.02140600f, -0.04314249f, 0.03921684f, 0.01062965f, -0.00409894f, 0.01645972f, 
    -0.02305679f, -0.04417813f, 0.02633027f, 0.04574034f, -0.04069080f, 0.00250964f, -0.00870293f, -0.04705574f, 
    0.02300235f, -0.05982422f, -0.02595259f, -0.04961444f, 0.02111793f, -0.05163925f, -0.04178218f, -0.03516460f, 
    -0.04039457f, 0.01377660f, -0.03116091f, -0.06035273f, 0.00846352f, -0.03778635f, -0.05522624f, -0.03903697f, 
    -0.04138836f, 0.02263213f, -0.01884512f, 0.04825496f, 0.01602337f, 0.01894194f, 0.02719585f, -0.03942055f, 
    0.03284658f, 0.03762702f, -0.03568467f, -0.02913738f, -0.04990170f, 0.01451689f, -0.05644135f, 0.01998277f, 
    -0.03904103f, -0.03056286f, 0.04213085f, 0.00271558f, -0.02880808f, 0.01471514f, -0.04316851f, -0.04862640f, 
    -0.03217658f, 0.00938561f, -0.00087560f, 0.03570502f, 0.00594724f, 0.00117811f, 0.03361310f, 0.03127784f, 
    0.00739196f, -0.00951887f, -0.04029205f, -0.05647234f, -0.04463828f, -0.01310524f, -0.04222881f, 0.02421372f, 
    -0.05083526f, -0.03607086f, 0.02730658f, -0.00785956f, 0.04333252f, -0.03608740f, -0.01634631f, 0.04803641f, 
    0.03730403f, 0.05287704f, -0.00743608f, -0.00855363f, 0.00193620f, 0.00895706f, 0.06023460f, -0.04244915f, 
    0.03377314f, -0.02944615f, -0.01871936f, -0.04101825f, 0.03072818f, 0.02942620f, 0.03096872f, -0.02962090f, 
    -0.02620723f, -0.03763157f, -0.00159977f, -0.03272622f, -0.03275644f, 0.04534975f, -0.00265355f, 0.04878683f, 
    0.02361211f, 0.01801425f, 0.04154190f, -0.02979991f, -0.04035695f, 0.01311281f, 0.04972338f, -0.03321135f, 
    0.04054274f, 0.00246256f, -0.02260813f, -0.01555192f, -0.04383975f, 0.04824010f, -0.01285066f, -0.03066703f, 
    -0.00311091f, -0.00320690f, 0.02138233f, 0.01062279f, 0.03985059f, 0.00433977f, -0.02650639f, -0.01421908f, 
    0.27592930f, 0.27237067f, -0.08850195f, -0.22537692f, 0.33165443f, 0.24359617f, 0.03386876f, 0.12604702f, 
    0.13160898f, 0.16996367f, 0.01977059f, 0.02370858f, -0.03967980f, -0.03668835f, 0.17747374f, -0.04883901f, 
    -0.11185783f, 0.07030831f, -0.02793669f, 0.03977022f, 0.16685921f, 0.04986991f, 0.09464403f, 0.24408615f, 
    -0.16775502f, -0.07385061f, 0.04414752f, -0.01327008f, 0.01181170f, -0.04293451f, 0.06239799f, 0.09486943f, 
    0.18565103f, 0.15857667f, 0.09394851f, -0.01885669f, 0.02790431f, -0.20754743f, 0.06121228f, -0.10469943f, 
    -0.08983948f, 0.18116076f, 0.11333022f, 0.12501024f, -0.15866631f, -0.22146486f, -0.04431634f, -0.15601571f, 
    -0.09946351f, -0.08571422f, 0.00280811f, 0.05658500f, 0.33990464f, -0.14198695f, -0.06104239f, 0.01817603f, 
    0.19657941f, 0.23210363f, 0.08615075f, -0.01088886f, 0.47427681f, 0.15666987f, -0.09424099f, 0.32689175f, 
    0.17652981f, 0.03519063f, 0.13533966f, 0.10730305f, -0.08092799f, 0.07400136f, -0.01437579f, -0.09347058f, 
    -0.06342590f, 0.07907810f, 0.11234213f, 0.05733418f, 0.02038935f, 0.10317853f, -0.03283400f, -0.05769084f, 
    -0.04134777f, 0.50728410f, 0.77590007f, 0.23333980f, -0.04885561f, -0.21036436f, -0.28769675f, -0.30406809f, 
    0.13011093f, -0.13368255f, -0.07445222f, -0.02319093f, 0.03629673f, -0.06179278f, -0.01292085f, 0.07205281f, 
    0.03767255f, -0.13010466f, 0.07441103f, -0.00779514f, 0.44883749f, 0.27602538f, -0.16558573f, -0.23825598f, 
    0.47915387f, 0.12339948f, 0.06165804f, 0.09622202f, 0.02973301f, -0.01498860f, -0.05616896f, -0.07040554f, 
    -0.08614401f, -0.01206201f, 0.16783945f, 0.03538876f, -0.02244605f, 0.05894604f, -0.07744081f, 0.12140051f, 
    0.10059875f, 0.04768155f, -0.41554752f, -0.45044175f, 0.05658149f, 0.07134589f, 0.04845092f, -0.03396270f, 
    -0.03955581f, -0.03174803f, 0.03428831f, 0.21826068f, -0.10292897f, -0.01100161f, 0.00312773f, 0.04443558f, 
    0.13422774f, -0.01168930f, -0.01085109f, 0.09208603f, 0.22827943f, 0.03768422f, -0.40460750f, -0.31334275f, 
    -0.28175569f, -0.01768631f, 0.04147179f, 0.17811605f, 0.02656213f, 0.03105051f, 0.00701521f, 0.06969210f, 
    0.20049264f, 0.01135776f, 0.03361224f, 0.07604951f, -0.04356707f, -0.07737453f, 0.16978472f, 0.02518686f, 
    -0.27269617f, 0.23060572f, 0.20345061f, 0.25868824f, -0.10659111f, -0.10214095f, -0.17387366f, -0.22942270f, 
    -0.10828756f, -0.14355408f, -0.06980713f, 0.09452197f, -0.04905931f, 0.15870774f, 0.10297377f, -0.02147375f, 
    0.27091765f, 0.14642721f, 0.08504138f, 0.05446577f, 0.30141088f, 0.23127240f, 0.16281581f, -0.25432503f, 
    0.22428668f, 0.03346952f, -0.16275066f, -0.10522898f, 0.01341582f, -0.07386159f, -0.02394369f, 0.01749348f, 
    0.06080149f, -0.00413376f, 0.10103036f, 0.06311336f, 0.04793774f, 0.14816032f, -0.17802253f, -0.20941392f, 
    -0.03946536f, -0.42530352f, -0.75949407f, -0.49652973f, 0.14539541f, 0.09694716f, 0.15907001f, 0.21775572f, 
    0.15436201f, 0.08825180f, -0.09132602f, 0.04461337f, -0.09659181f, -0.09193049f, -0.09531847f, 0.00634139f, 
    0.14310589f, 0.14818464f, -0.00007220f, -0.06672960f, 0.22796313f, 0.45306012f, -0.08879329f, -0.20811254f, 
    -0.02103237f, 0.06245579f, 0.01966152f, 0.08604690f, -0.01728803f, -0.05493392f, -0.06841782f, 0.13890138f, 
    0.19822486f, -0.04058984f, 0.13280849f, 0.08456006f, 0.05322533f, -0.05654641f, -0.00040973f, -0.07175168f, 
    0.24002314f, -0.11014693f, 0.22584456f, 0.10744813f, -0.11860209f, 0.05697078f, 0.05546804f, -0.03450103f, 
    -0.01596027f, -0.03958961f, -0.02533776f, -0.05376917f, 0.14894009f, 0.05806443f, -0.03308598f, 0.24955057f, 
    0.04424811f, -0.26784301f, 0.09686533f, 0.01442206f, 0.37993523f, 0.19847791f, 0.33582306f, -0.10326269f, 
    0.01813049f, 0.06321704f, -0.08092217f, -0.02141532f, 0.08203119f, -0.17076443f, -0.03118726f, -0.00517236f, 
    0.00682173f, -0.16440581f, 0.10684005f, -0.01924417f, 0.01490272f, 0.12706627f, -0.23379771f, -0.11882072f, 
    0.00640078f, -0.19232862f, -0.19789566f, -0.03635616f, -0.16484420f, -0.07622866f, 0.04622961f, 0.11306411f, 
    -0.10122664f, -0.09079428f, 0.12255055f, 0.15332961f, 0.03731283f, 0.01189886f, 0.00894656f, -0.03496318f, 
    0.09499421f, 0.07736342f, -0.04934312f, -0.06904752f, 0.41556641f, 0.04125264f, -0.30320391f, 0.00090404f, 
    0.23402694f, 0.18163997f, 0.09848841f, -0.11844742f, 0.19132894f, 0.23349978f, -0.12526754f, 0.02625344f, 
    -0.05621860f, 0.01033960f, -0.00205706f, 0.00030929f, 0.03870235f, 0.10193036f, 0.12744106f, 0.25227252f, 
    0.03232296f, 0.32982323f, 0.08710364f, 0.17724769f, -0.01263775f, 0.07363071f, 0.02125601f, -0.05462531f, 
    -0.04679579f, 0.15693849f, -0.09606916f, -0.12231371f, -0.09130818f, -0.23938572f, -0.01215583f, -0.06020177f, 
    0.19909145f, -0.20631345f, 0.01867963f, 0.07493218f, 0.50363868f, 0.02997081f, 0.04256311f, 0.04745205f, 
    -0.23687328f, -0.00716993f, 0.02872618f, 0.02829132f, 0.05016528f, 0.05140951f, 0.21928772f, 0.24968340f, 
    0.01455900f, 0.02143643f, -0.09386003f, -0.02283710f, 0.00186578f, -0.21684118f, 0.05804809f, -0.05203144f, 
    0.00535134f, -0.03046599f, 0.10108794f, 0.03112631f, 0.07854139f, -0.02160606f, 0.14937460f, -0.03055481f, 
    -0.01761865f, -0.02912716f, 0.06545091f, -0.00549678f, 0.08965868f, 0.09878365f, -0.05488424f, 0.01139400f, 
    -0.12129887f, 0.08090106f, 0.12923002f, -0.16430116f, 0.19477125f, 0.28518584f, 0.00262492f, 0.19486628f, 
    -0.44634682f, 0.11676084f, 0.09572697f, 0.10202240f, 0.04144303f, -0.05113906f, -0.17926848f, -0.18753058f, 
    -0.03912783f, 0.11749092f, 0.02456756f, 0.02573269f, 0.05881589f, 0.16158040f, 0.00657159f, -0.01350934f, 
    0.15233082f, 0.01042047f, 0.01838663f, 0.23203045f, 0.27996975f, -0.14585026f, -0.21468465f, -0.20517819f, 
    -0.08011169f, 0.00435849f, 0.06605410f, 0.08835755f, 0.01579703f, 0.04085741f, 0.08403908f, 0.06373776f, 
    -0.00533565f, 0.00670172f, 0.21633130f, 0.03058541f, 0.42343953f, 0.31798586f, 0.19922006f, 0.34398672f, 
    0.19248341f, -0.07889677f, 0.08462244f, -0.22967422f, 0.13096297f, 0.04839300f, -0.08007739f, -0.05964904f, 
    -0.08483178f, -0.09256003f, 0.04574629f, 0.04613590f, 0.08805098f, -0.12541370f, -0.11686487f, 0.05058488f, 
    0.07417949f, 0.03278438f, 0.04890914f, -0.10796554f, -0.09537724f, -0.11894395f, -0.22100368f, 0.15585348f, 
    -0.05078459f, 0.23547480f, -0.09240829f, 0.03224757f, 0.00591614f, -0.04930006f, 0.04851401f, 0.04221787f, 
    -0.11590701f, 0.15597443f, -0.02791484f, -0.09598453f, 0.56406701f, 0.01000999f, 0.15401424f, -0.05701207f, 
    -0.08476500f, 0.05094080f, -0.14970264f, 0.00300823f, -0.05979103f, -0.00661368f, -0.18806432f, -0.06014816f, 
    -0.01302353f, -0.14240769f, -0.00689699f, 0.02760376f, -0.08127285f, -0.00168379f, -0.02007819f, -0.06482107f, 
    0.00648120f, -0.07795379f, 0.07252479f, -0.03709538f, 0.00402092f, 0.13171752f, -0.04970913f, 0.01817125f, 
    -0.02734926f, -0.15217823f, 0.10251679f, 0.04554614f, 0.12450746f, 0.05048140f, -0.00325066f, -0.07525629f, 
    -0.04233531f, 0.00788480f, 0.12242445f, 0.01653464f, -0.23473498f, 0.03755892f, -0.16781913f, 0.14817500f, 
    0.00560815f, 0.09976143f, 0.07998064f, 0.00350446f, 0.11642732f, 0.18508740f, -0.00743786f, -0.01895233f, 
    -0.00289455f, -0.03548513f, 0.04444839f, -0.02337616f, 0.01100391f, 0.01349693f, -0.28449279f, -0.02724474f, 
    0.20615253f, -0.07996969f, -0.04140422f, -0.07682784f, -0.01124584f, 0.00082971f, -0.00560581f, 0.12987375f, 
    0.02953704f, -0.09807760f, -0.10919532f, -0.16296452f, 0.04220235f, 0.04492104f, -0.03606423f, 0.07918759f, 
    -0.04772141f, 0.01450825f, 0.02326935f, 0.06055941f, 0.68732613f, -0.20770960f, -0.10109256f, -0.15785308f, 
    0.05423084f, 0.05881837f, -0.09771280f, 0.01204700f, -0.02900690f, 0.19947545f, -0.06994507f, -0.03275348f, 
    0.00326175f, -0.04877314f, -0.15613902f, -0.01967224f, 0.00078643f, 0.10036764f, -0.13281913f, -0.14041914f, 
    -0.38565007f, 0.00032122f, 0.18836489f, -0.03643136f, -0.40602604f, -0.00098414f, 0.10196973f, 0.16648760f, 
    -0.02488228f, 0.09272051f, -0.07505279f, 0.00211403f, -0.11247510f, 0.05603285f, -0.11701569f, 0.17871700f, 
    -0.20825152f, 0.13452730f, 0.19104968f, 0.17602523f, -0.36280030f, 0.07768821f, 0.36151940f, 0.02358997f, 
    0.05640828f, 0.02314055f, -0.03150299f, 0.05091113f, -0.09293245f, 0.04544236f, 0.11098529f, 0.04346138f, 
    -0.11110730f, -0.00530027f, 0.31447914f, 0.06241415f, -0.14502929f, 0.41236484f, -0.07799724f, -0.00072924f, 
    0.19961186f, -0.05509314f, -0.06726543f, -0.03611803f, -0.09260064f, -0.01700282f, -0.00664985f, -0.06944004f, 
    0.03844170f, 0.00877805f, -0.10705604f, -0.12417107f, -0.22172096f, 0.08380057f, -0.13468380f, -0.06761795f, 
    -0.07110874f, -0.01965374f, 0.01526274f, 0.00074491f, 0.02903408f, 0.25679311f, 0.22820017f, 0.41946658f, 
    0.19501500f, 0.02169578f, 0.15593931f, 0.10377330f, 0.05304082f, 0.25215510f, 0.01614090f, 0.00938572f, 
    0.05836434f, 0.07778728f, 0.08154468f, -0.08357370f, -0.00132695f, -0.10961618f, -0.38692734f, 0.05281557f, 
    0.04072794f, 0.41457906f, 0.16527052f, 0.15221320f, -0.13635094f, 0.12519902f, 0.29408231f, 0.17927466f, 
    -0.00078916f, 0.17291540f, -0.01483106f, 0.08952465f, 0.02555039f, 0.11558927f, 0.07720119f, 0.12684968f, 
    -0.12111917f, -0.33153081f, 0.03064354f, -0.16816963f, 0.13474341f, 0.01840552f, -0.17834608f, 0.20306775f, 
    0.14481327f, -0.16298467f, -0.11784635f, -0.11699018f, -0.08813196f, -0.18574536f, -0.11863825f, -0.06123861f, 
    -0.07133537f, -0.04239279f, 0.09026574f, 0.01897670f, -0.00907311f, 0.19839829f, -0.07020424f, -0.14655246f, 
    -0.06028946f, 0.19774300f, 0.10318885f, 0.07631756f, 0.01743235f, -0.02794346f, -0.06465179f, -0.18802212f, 
    -0.20436798f, -0.19399066f, -0.32317489f, -0.08169397f, -0.01415373f, 0.15648323f, 0.12825555f, 0.02047068f, 
    -0.13540244f, 0.05848645f, -0.07968683f, 0.10227738f, 0.38617256f, -0.14331900f, -0.22335143f, 0.09157804f, 
    -0.30808216f, 0.19233601f, 0.04649552f, 0.00490271f, 0.18717469f, 0.07797205f, 0.08620201f, 0.12099063f, 
    0.02075918f, -0.05714314f, 0.04072366f, -0.04490935f, -0.01483767f, -0.04332294f, 0.05975319f, 0.03350595f, 
    0.20648111f, 0.28358084f, 0.30755845f, 0.24668644f, -0.08609111f, 0.11753542f, -0.10824888f, -0.21134350f, 
    -0.04603598f, -0.15875579f, -0.17169608f, 0.04511726f, -0.03856980f, -0.06389844f, -0.10663718f, -0.04260569f, 
    -0.12504613f, 0.19480360f, 0.00149346f, 0.01787746f, 0.30900493f, 0.29666424f, 0.28830615f, -0.19809374f, 
    -0.26683268f, 0.24151263f, 0.15277526f, 0.10064252f, -0.03455681f, 0.05242836f, 0.03101158f, -0.05831200f, 
    -0.02363996f, -0.13348483f, 0.02786142f, 0.00147253f, -0.10985211f, -0.14862235f, -0.03722272f, 0.10249504f, 
    0.24289940f, -0.43707132f, -0.03455294f, 0.02160168f, -0.16283761f, -0.01482299f, -0.04905180f, 0.35686976f, 
    0.17452572f, 0.07482537f, 0.06029559f, 0.00471063f, -0.03551946f, -0.02151814f, 0.07520264f, -0.18098381f, 
    0.04373997f, 0.20222983f, -0.06580287f, 0.06472450f, -0.05611921f, -0.08672847f, -0.35313347f, -0.08978347f, 
    -0.13685083f, -0.05212437f, -0.09438995f, 0.11205400f, 0.03632895f, -0.12263345f, 0.08619530f, 0.28928751f, 
    0.06425901f, 0.18068933f, 0.06793110f, -0.03387595f, -0.04039370f, 0.22457278f, -0.03259563f, -0.02848417f, 
    -0.00684777f, 0.11622713f, 0.22541556f, 0.15517670f, 0.04592431f, -0.02874428f, -0.05074999f, -0.17176986f, 
    -0.08293044f, -0.01172121f, -0.15131924f, 0.06313249f, -0.00448948f, -0.04751078f, 0.08230133f, -0.13113245f, 
    0.07806244f, 0.11130065f, 0.02671400f, 0.01720641f, 0.15832648f, 0.24233079f, 0.47632125f, -0.02634346f, 
    -0.21204296f, 0.13734014f, -0.00798517f, 0.06219358f, 0.17209080f, 0.07916496f, -0.05650802f, 0.04168804f, 
    0.04459333f, -0.02716201f, 0.01582881f, 0.03239658f, -0.10472214f, -0.15969357f, -0.16328114f, -0.22046925f, 
    0.08172920f, -0.18218105f, -0.33901459f, 0.06105921f, -0.34113905f, -0.06227747f, 0.03384787f, 0.01396535f, 
    0.00650858f, 0.13073424f, 0.17173359f, 0.18958773f, 0.05375901f, 0.03853017f, 0.02401212f, -0.04070531f, 
    -0.00942790f, 0.00736216f, 0.03997809f, 0.10036109f, -0.06654011f, -0.42875218f, -0.01789815f, 0.04038823f, 
    0.15132032f, 0.05369705f, -0.20128191f, 0.24092875f, 0.06937782f, -0.08083885f, 0.04451068f, 0.05692241f, 
    0.04396393f, 0.12699613f, 0.29469821f, 0.16734383f, -0.05426454f, 0.03743455f, 0.10405681f, 0.10822740f, 
    -0.05706954f, 0.26380691f, -0.22705989f, -0.10508984f, -0.07121483f, -0.16173320f, 0.11837713f, 0.11728656f, 
    -0.21665569f, -0.10507481f, -0.02324289f, 0.02513797f, -0.16659771f, -0.02790129f, -0.08497068f, -0.04382194f, 
    -0.16925734f, 0.06832638f, -0.07543172f, -0.29885295f, -0.11606991f, 0.06654635f, 0.60761464f, 0.33946145f, 
    0.31394380f, 0.03966307f, -0.05151313f, -0.14226860f, -0.01409721f, 0.05508364f, -0.11159849f, -0.01458669f, 
    -0.18420598f, 0.05015347f, 0.16611701f, 0.08383178f, -0.15291271f, 0.03379643f, 0.08139589f, -0.05184990f, 
    0.12133553f, -0.14501306f, -0.20791404f, 0.05614202f, -0.07955055f, -0.09584187f, -0.05721095f, -0.01630589f, 
    -0.08663629f, -0.11948058f, -0.06818566f, -0.04005708f, 0.08329406f, -0.03297222f, 0.00228308f, -0.15561867f, 
    -0.01089935f, 0.04722285f, 0.02488557f, 0.00127129f, 0.28345951f, 0.28343454f, 0.36229509f, 0.00046906f, 
    -0.33824819f, 0.04191398f, 0.11308428f, 0.03870723f, 0.21220970f, -0.07044432f, -0.11016356f, 0.11562676f, 
    0.05222948f, 0.02136450f, 0.07398944f, -0.07534103f, 0.06740107f, -0.11953909f, -0.02257593f, 0.44853598f, 
    -0.04227628f, -0.05868497f, -0.01995787f, 0.03146606f, 0.00684488f, 0.03984654f, 0.01579327f, 0.03560205f, 
    -0.05206710f, 0.01270080f, -0.03045968f, 0.00234052f, -0.05575474f, 0.02269260f, -0.04202950f, 0.03546889f, 
    -0.04669335f, 0.03938570f, -0.03590298f, 0.04085295f, -0.02757341f, 0.02448304f, -0.05875735f, -0.06009783f, 
    -0.05383285f, 0.00591128f, 0.03118263f, 0.00643477f, 0.01824693f, -0.02302497f, -0.01306180f, 0.04709617f, 
    -0.05744682f, -0.01918111f, -0.02161729f, 0.03018469f, 0.03524232f, -0.04004353f, 0.00415153f, 0.03646803f, 
    0.04089052f, -0.05831779f, -0.01338728f, 0.04711438f, -0.03918535f, 0.04666933f, -0.04434804f, -0.05783286f, 
    -0.03969359f, -0.04913542f, -0.02062217f, 0.01917084f, -0.03224954f, 0.00690287f, 0.00160208f, -0.02497097f, 
    -0.02698998f, 0.00517516f, -0.04620434f, 0.04988893f, 0.04625601f, -0.03476314f, 0.00081133f, 0.04209814f, 
    0.01785444f, 0.02615666f, 0.01587497f, -0.01579865f, 0.00234647f, 0.03391391f, 0.03701558f, 0.03221390f, 
    -0.04779135f, -0.02291501f, -0.00507751f, 0.01848112f, -0.01297855f, -0.00220265f, -0.01640728f, -0.01230999f, 
    0.03278434f, 0.00578640f, 0.02810259f, -0.02817727f, -0.00929302f, 0.02136070f, 0.03403845f, 0.03693587f, 
    -0.00475991f, -0.04779261f, -0.03241193f, -0.02994196f, -0.02451373f, 0.03570442f, 0.00253790f, 0.00149901f, 
    -0.05040472f, 0.02491692f, 0.04890280f, -0.05630218f, -0.02200492f, 0.04704711f, 0.01987676f, 0.04493803f, 
    -0.02463995f, -0.02833693f, -0.04977946f, 0.01951336f, -0.04170593f, -0.03390430f, -0.05355442f, 0.04943836f, 
    0.02426039f, 0.00518407f, -0.00346830f, -0.03452133f, -0.03351773f, -0.01546753f, -0.04649114f, 0.01927266f, 
    0.04829244f, 0.02839271f, -0.04188884f, 0.03310956f, -0.01358478f, 0.00457817f, -0.02975344f, 0.03860812f, 
    -0.02603442f, 0.04762606f, -0.05743967f, -0.03850186f, -0.04275725f, -0.04913899f, -0.05790002f, -0.04212435f, 
    0.02259113f, 0.03730281f, 0.04436781f, 0.03933010f, 0.01096358f, -0.00947788f, -0.00442407f, -0.03819301f, 
    -0.05813109f, -0.00444440f, -0.00458753f, 0.03427049f, -0.05516466f, -0.02235471f, -0.00630838f, -0.01138259f, 
    -0.03063935f, -0.04256069f, -0.05628914f, 0.00616535f, -0.05058338f, -0.04667494f, -0.01771689f, -0.05083658f, 
    0.00920046f, 0.01539391f, 0.01871179f, -0.05745636f, 0.02528525f, 0.00249984f, 0.01562586f, 0.02211556f, 
    0.01599707f, -0.01261226f, 0.02931200f, 0.02342073f, 0.04438562f, 0.01708502f, -0.04329560f, -0.02264011f, 
    -0.03902557f, 0.01891123f, -0.03311731f, -0.05939689f, 0.02975519f, -0.02663086f, 0.04247171f, -0.03696230f, 
    0.01873210f, -0.02002283f, -0.04218686f, -0.03392084f, -0.01305289f, -0.01339884f, -0.03332023f, -0.01371949f, 
    0.04395990f, 0.02038908f, -0.00229011f, 0.03300626f, 0.00855555f, -0.02820778f, -0.03806648f, 0.02076066f, 
    -0.02092855f, -0.01895429f, -0.00676498f, 0.00310399f, -0.01920984f, 0.00266368f, -0.05540501f, -0.04688015f, 
    -0.03077738f, -0.00660281f, -0.02985158f, -0.02641306f, -0.01275341f, -0.00689620f, -0.06195672f, -0.01442283f, 
    -0.03387749f, 0.04092426f, 0.02786502f, 0.01633076f, -0.00582174f, -0.03064633f, -0.01220630f, 0.06040176f, 
    0.00774061f, -0.00502237f, -0.02970268f, -0.04957484f, -0.00488597f, -0.01057502f, -0.00311147f, -0.02870658f, 
    -0.06032874f, -0.03852068f, 0.05089745f, -0.02622958f, -0.05188892f, -0.00086718f, -0.04334674f, -0.02377737f, 
    -0.03005844f, -0.01778951f, 0.02993411f, -0.04226160f, 0.04462769f, -0.00696954f, -0.04301098f, 0.03616476f, 
    -0.00098199f, -0.04008118f, -0.01772580f, -0.05795682f, -0.00109578f, 0.00926677f, -0.02877739f, -0.03888327f, 
    0.03888613f, 0.02365908f, -0.01433480f, -0.05116847f, 0.00189388f, 0.02803352f, -0.03045620f, 0.03288236f, 
    -0.00389284f, 0.03456055f, 0.02893922f, -0.02193401f, -0.03720788f, 0.02753074f, -0.00865434f, 0.04317010f, 
    0.03156323f, -0.05233372f, 0.05116880f, 0.02346522f, -0.00959637f, -0.00043007f, 0.01462192f, 0.03678724f, 
    -0.01549355f, -0.00273533f, -0.00245081f, -0.01849281f, 0.00786129f, 0.00908514f, 0.03777025f, -0.00048632f, 
    0.00561040f, -0.03462726f, 0.02662437f, -0.02029290f, -0.01537986f, -0.01989167f, 0.04000101f, 0.03776991f, 
    0.03971455f, 0.03849299f, -0.04806342f, 0.02136227f, -0.03631293f, 0.00696080f, -0.02141236f, 0.00547624f, 
    0.02684733f, 0.02313401f, -0.01648357f, 0.01349411f, 0.04512929f, 0.04171873f, 0.02736601f, -0.04804014f, 
    -0.05634708f, -0.00929759f, -0.05832190f, -0.01105181f, 0.00646434f, -0.02442811f, -0.05393074f, 0.03803797f, 
    0.07067833f, -0.47176751f, -0.21317811f, 0.01625338f, -0.09608432f, -0.09163924f, -0.03865726f, -0.33192739f, 
    0.13860054f, 0.30352783f, -0.07648613f, 0.05077441f, 0.13179696f, 0.13943626f, 0.17842051f, 0.00265164f, 
    0.15266043f, 0.21851848f, 0.13081402f, 0.11316949f, 0.13961197f, 0.04617816f, 0.13892533f, 0.04399820f, 
    0.12406238f, 0.00264299f, -0.08189086f, 0.10108244f, -0.02597280f, -0.10872209f, 0.02910815f, 0.08940890f, 
    0.04172063f, 0.10742367f, -0.00027562f, -0.02692572f, -0.13791171f, -0.09267323f, -0.20911828f, -0.04922911f, 
    0.15305501f, 0.02861558f, 0.07645370f, -0.00423694f, -0.01750046f, -0.03533971f, 0.02716566f, 0.12239388f, 
    0.01248784f, -0.05751579f, 0.04420606f, -0.04547049f, -0.07696409f, -0.10842378f, -0.07872637f, -0.01478117f, 
    -0.04941039f, -0.06363332f, -0.23044363f, -0.14130199f, -0.12245362f, -0.17046158f, -0.32960945f, 0.07536926f, 
    -0.20903245f, 0.07421207f, -0.13246590f, 0.14702286f, 0.07220166f, -0.13011196f, -0.05143923f, 0.05282572f, 
    0.09887032f, -0.09396928f, 0.17204775f, 0.05465863f, 0.07137031f, 0.32691652f, 0.05422978f, 0.24642584f, 
    0.82971191f, 0.11120884f, -0.13549447f, -0.01500207f, -0.11313361f, -0.22542199f, 0.15059672f, 0.12581217f, 
    -0.03384964f, -0.01994462f, -0.03690995f, -0.05366808f, 0.01229176f, 0.02465747f, -0.00842397f, -0.02166204f, 
    0.22325936f, -0.03610149f, -0.01324743f, 0.11838884f, -0.03329005f, -0.21322082f, -0.30782190f, -0.26330161f, 
    -0.31303999f, -0.02170592f, -0.02425648f, -0.22191565f, 0.02995959f, 0.11817987f, -0.05873860f, 0.02138677f, 
    -0.04638620f, -0.01692052f, 0.15451694f, 0.00405373f, -0.02452138f, 0.14020884f, 0.23292369f, 0.04315118f, 
    -0.17697302f, 0.29571733f, 0.20487969f, 0.18077558f, -0.18755177f, 0.05113817f, 0.07248642f, -0.00809254f, 
    -0.05660561f, 0.04422162f, -0.00588049f, 0.12401663f, 0.25212497f, 0.02111526f, -0.16996205f, -0.01449900f, 
    -0.01694518f, -0.15549932f, 0.04612872f, -0.03947844f, -0.06821574f, 0.21188992f, 0.07640508f, 0.10186838f, 
    -0.08239705f, -0.05723471f, 0.10214827f, -0.10656370f, -0.06267031f, 0.01339118f, 0.09389554f, -0.12847021f, 
    0.07097796f, 0.06160201f, -0.01825188f, 0.02169672f, -0.06029679f, -0.18993467f, -0.03994799f, -0.16551080f, 
    0.31768951f, 0.07899450f, -0.04053050f, 0.10032897f, 0.03954085f, -0.09885976f, 0.12688601f, 0.06852599f, 
    0.13878618f, -0.06057874f, -0.03630209f, 0.01293785f, -0.02793496f, -0.13512538f, -0.00920755f, 0.00685126f, 
    0.00176505f, -0.08259462f, -0.17429556f, -0.18765263f, -0.08626397f, -0.08040861f, -0.43117258f, 0.01511673f, 
    0.12103105f, 0.04523904f, 0.00693278f, 0.10435960f, 0.01518434f, 0.22551975f, -0.05149975f, -0.03050174f, 
    0.02347866f, 0.02576801f, 0.08308998f, -0.07154644f, -0.01602181f, 0.08957651f, 0.29799145f, 0.14338304f, 
    -0.15975001f, 0.12378386f, 0.20934846f, -0.05298515f, -0.27271080f, -0.17268670f, -0.13204975f, -0.11073928f, 
    -0.03932278f, 0.18093367f, 0.03273536f, -0.00595827f, 0.07826523f, -0.13413750f, 0.03524341f, -0.10591502f, 
    -0.00006202f, -0.17257155f, -0.05834376f, -0.07954618f, -0.34520960f, -0.05442676f, 0.01108793f, 0.06125222f, 
    -0.07406388f, -0.01438941f, 0.24895985f, 0.03597299f, -0.03603259f, -0.04741485f, 0.17159718f, 0.09738326f, 
    0.11773731f, 0.18121751f, -0.00007681f, 0.26384440f, 0.14569545f, -0.03211595f, 0.04003578f, -0.14276475f, 
    -0.19980094f, -0.07810929f, -0.24362694f, 0.05968713f, 0.08750218f, -0.02769324f, -0.01604691f, -0.05106422f, 
    -0.07517085f, -0.01575520f, -0.21001959f, -0.06608400f, 0.24607106f, 0.29427904f, 0.02238175f, 0.28629529f, 
    -0.00748349f, 0.02856535f, 0.19275381f, 0.25279343f, -0.03819151f, 0.06569042f, 0.27696219f, 0.06424429f, 
    0.26021349f, -0.05173771f, 0.01428878f, 0.02960109f, 0.04172434f, -0.02545135f, -0.11208242f, 0.08926290f, 
    0.17497946f, 0.00306372f, -0.08795167f, 0.10876218f, 0.21779002f, 0.00963212f, 0.22424097f, -0.00427847f, 
    0.16699317f, 0.09727497f, 0.10557277f, -0.01119399f, -0.00430904f, -0.02570418f, -0.08711114f, 0.04028853f, 
    0.01286759f, -0.04917858f, 0.02277372f, 0.13781083f, 0.23367848f, 0.00914860f, -0.03167270f, -0.07700774f, 
    -0.10604537f, -0.17228051f, -0.23224834f, -0.11981691f, -0.50336874f, 0.04546162f, -0.01478740f, -0.23702264f, 
    0.08979706f, -0.03019973f, -0.10143737f, -0.02322953f, -0.04936235f, -0.07676368f, 0.08802603f, -0.13316303f, 
    -0.13684723f, -0.13408871f, -0.05302352f, -0.14234546f, -0.19860455f, 0.13503319f, 0.05203127f, -0.25682455f, 
    0.41594785f, -0.00672745f, 0.09405450f, -0.38587046f, 0.20426793f, -0.08752383f, 0.00832104f, 0.10237896f, 
    -0.02485403f, 0.37395871f, 0.01154780f, 0.00780518f, 0.06900615f, -0.06055930f, 0.06618724f, -0.04390243f, 
    0.03075397f, 0.18819422f, 0.03684271f, 0.23302802f, -0.33363819f, 0.21335125f, 0.05590127f, 0.16897887f, 
    -0.01860358f, 0.20180473f, 0.01015106f, 0.33041248f, -0.06019856f, -0.38212851f, 0.08597029f, 0.04950593f, 
    -0.01660482f, 0.06849246f, -0.04969906f, 0.02073500f, 0.07793436f, -0.07852206f, -0.19674508f, 0.17783073f, 
    -0.05353766f, 0.13110334f, 0.14011073f, -0.26072818f, -0.33886912f, 0.03179543f, 0.19641334f, 0.24277279f, 
    -0.16681361f, -0.14583351f, 0.17362113f, 0.03747016f, -0.19379073f, -0.12644966f, -0.12037798f, -0.13542025f, 
    -0.07677512f, -0.02448481f, -0.39066181f, -0.18084118f, -0.17438242f, -0.43422446f, -0.40085316f, 0.16653247f, 
    -0.00192579f, 0.09840781f, -0.17201719f, 0.33624199f, 0.10107526f, -0.15613167f, -0.04677868f, 0.18395950f, 
    -0.06469462f, 0.15996043f, 0.19720517f, 0.05351647f, 0.06453697f, -0.00256725f, 0.13661754f, 0.06873886f, 
    -0.18684518f, 0.28156519f, -0.12163653f, 0.35710001f, -0.03808438f, 0.14531316f, 0.31202662f, 0.21085005f, 
    -0.14675526f, -0.00150140f, -0.07952815f, 0.03478265f, -0.09382994f, -0.13852274f, -0.07677549f, 0.16528751f, 
    0.22996300f, -0.00521149f, -0.06690427f, -0.00212215f, 0.54781121f, 0.16551231f, -0.29431143f, -0.46066496f, 
    0.07451776f, 0.12486647f, 0.11489524f, 0.05277673f, 0.10604455f, 0.19632274f, 0.03071932f, 0.16167019f, 
    0.09079182f, 0.09615117f, 0.12356707f, -0.05146120f, -0.00192409f, -0.04205060f, 0.15551324f, 0.00450211f, 
    -0.21169791f, 0.22131370f, 0.04753310f, 0.01082956f, -0.07179178f, 0.17801709f, -0.12882680f, 0.13011160f, 
    -0.02130734f, -0.44922689f, 0.06821333f, -0.03380854f, -0.00474665f, 0.04584686f, -0.05917902f, 0.07875303f, 
    -0.14966886f, -0.21565391f, 0.05614081f, -0.16046117f, 0.03417998f, 0.43279704f, -0.07683624f, -0.11285397f, 
    -0.16136116f, -0.39601353f, 0.04840490f, -0.20255448f, 0.02920341f, -0.29245487f, 0.08867744f, -0.10591230f, 
    0.01797130f, 0.05056756f, 0.05878374f, -0.09686980f, 0.02474566f, -0.14946730f, 0.03880041f, 0.10029942f, 
    -0.06274622f, 0.00591035f, 0.12102074f, -0.06809053f, -0.14094950f, -0.05218248f, 0.10943237f, -0.06776858f, 
    -0.13539226f, 0.04186742f, -0.11432493f, 0.05089702f, -0.05061735f, -0.08638382f, 0.07537602f, -0.08093061f, 
    -0.02862670f, -0.03299444f, -0.14249435f, 0.03372081f, 0.28988409f, 0.34410435f, 0.17894027f, 0.00078632f, 
    0.12206414f, 0.09354729f, -0.03252498f, 0.10047721f, 0.03131477f, 0.11459705f, 0.02924612f, -0.08790697f, 
    -0.07247751f, -0.10019656f, -0.22948276f, 0.01553045f, -0.02673076f, 0.08150169f, 0.18081321f, 0.06021502f, 
    0.57155067f, -0.04266014f, 0.08009495f, -0.33621553f, -0.07775905f, 0.00147458f, 0.03526908f, -0.22162834f, 
    -0.00543830f, -0.18133572f, 0.06696463f, -0.04406675f, 0.09556149f, 0.00525915f, -0.02416617f, -0.16590483f, 
    -0.06213428f, -0.11729871f, 0.08073547f, -0.27930784f, -0.03657046f, 0.20327887f, -0.34679884f, -0.22547285f, 
    -0.03638834f, -0.42309743f, 0.17444502f, 0.04999686f, 0.13085449f, -0.21492732f, 0.02846998f, -0.01374234f, 
    -0.21613757f, 0.03591704f, 0.04287929f, 0.01561416f, 0.03990781f, -0.02738159f, 0.11795580f, 0.17985867f, 
    0.30387989f, -0.05357584f, -0.35858661f, 0.30631486f, 0.21896803f, -0.00922832f, 0.09598065f, 0.04772473f, 
    -0.01830554f, 0.05873002f, -0.06929433f, -0.00756074f, 0.04575211f, 0.11186410f, 0.13858433f, -0.00462398f, 
    0.27377686f, -0.01768690f, -0.08189709f, 0.25682706f, 0.07985814f, 0.09189375f, 0.22373322f, 0.07817461f, 
    -0.03219109f, -0.03089040f, 0.04980188f, 0.11303296f, 0.00589318f, -0.26439238f, 0.05451894f, -0.02104265f, 
    0.06769708f, 0.00026187f, -0.06805947f, -0.12825499f, 0.19744760f, -0.00931211f, -0.06784024f, 0.08480217f, 
    -0.03414050f, -0.04877790f, 0.13845827f, -0.14993657f, -0.01140187f, -0.06239158f, -0.28697249f, -0.01063809f, 
    -0.16755812f, -0.27214390f, -0.08116555f, -0.04521694f, -0.03459252f, -0.02214086f, -0.01743296f, -0.30449703f, 
    -0.20724468f, -0.11378493f, -0.18032868f, -0.00843738f, 0.32168177f, 0.60468978f, 0.02897054f, -0.23447704f, 
    -0.03776152f, -0.06459539f, -0.03691383f, 0.30565032f, -0.03925754f, 0.34057254f, 0.08508004f, 0.06412421f, 
    0.00105239f, -0.12220041f, -0.12702210f, -0.07319579f, -0.27261028f, 0.01506259f, 0.04998514f, -0.21032909f, 
    -0.10792139f, 0.01989255f, 0.53081721f, -0.14387874f, -0.20007950f, 0.08263037f, -0.05846706f, 0.01907849f, 
    0.36345688f, -0.07997631f, 0.04921373f, -0.01817957f, 0.12625191f, 0.22860272f, -0.06201352f, -0.19819018f, 
    0.00279220f, -0.20958759f, -0.01718335f, -0.16785020f, 0.43197885f, 0.05392400f, 0.11271082f, 0.02593080f, 
    0.16621312f, -0.08396240f, -0.05334812f, 0.00236695f, -0.09171917f, -0.08262443f, 0.06328813f, -0.19709133f, 
    -0.08370022f, -0.00451815f, 0.17241271f, -0.17388064f, -0.09580555f, 0.07602208f, 0.12593047f, 0.02566638f, 
    0.08510393f, 0.11800079f, -0.00454793f, -0.02252916f, 0.25935513f, 0.15884814f, -0.08782361f, -0.15085492f, 
    0.00697013f, -0.03623614f, -0.00310465f, -0.19209811f, -0.14525534f, 0.10192426f, 0.16787213f, 0.05478239f, 
    -0.11991385f, -0.14053202f, 0.00047467f, -0.00495979f, 0.32151994f, -0.20296934f, 0.23656397f, -0.09571319f, 
    0.04518557f, 0.19222663f, -0.00433565f, 0.22463536f, -0.13007109f, 0.27392286f, 0.17054874f, -0.00214339f, 
    0.05701930f, -0.03194807f, -0.11816146f, -0.15386122f, -0.23952056f, -0.06872073f, -0.02020119f, 0.05503865f, 
    -0.10288117f, 0.15554684f, -0.22504939f, -0.00856415f, 0.18177731f, 0.17392148f, 0.06648868f, -0.09331359f, 
    0.02274475f, -0.05394734f, 0.01011189f, -0.03014676f, 0.12390152f, 0.02967098f, -0.00789441f, -0.06296042f, 
    -0.22241725f, 0.13905466f, -0.01725854f, -0.09537103f, -0.07565576f, -0.17168973f, 0.56481975f, 0.34162578f, 
    -0.18039647f, -0.02142814f, 0.02260473f, -0.09933704f, 0.21826006f, 0.08687007f, 0.12584379f, -0.03101840f, 
    -0.00020016f, -0.10381323f, -0.13202702f, -0.14569660f, 0.04044297f, 0.12870492f, 0.17882377f, 0.08486003f, 
    0.41296405f, -0.14531480f, -0.26148579f, 0.18213668f, -0.00310666f, -0.00978269f, -0.08110303f, -0.04287746f, 
    0.09922682f, 0.02205704f, 0.16591224f, -0.07747260f, -0.06484305f, 0.03504554f, -0.05061780f, -0.03821098f, 
    -0.01241616f, -0.04742412f, 0.13040130f, 0.04195734f, 0.11625209f, 0.02261961f, -0.04111574f, -0.03897404f, 
    0.07862107f, 0.02765438f, -0.00702984f, -0.07738079f, 0.16595785f, -0.14303857f, 0.13997108f, -0.04885607f, 
    -0.00039343f, -0.01149917f, 0.03344006f, -0.00595147f, -0.03263259f, 0.01191746f, 0.10500579f, -0.04326239f, 
    -0.04661624f, 0.08323862f, 0.00580955f, -0.13391227f, 0.23836260f, 0.19814864f, -0.08264246f, -0.03641133f, 
    -0.07441669f, -0.02183669f, 0.23667756f, -0.17511487f, -0.04547104f, 0.00222320f, 0.12424490f, -0.08578474f, 
    -0.01289939f, -0.10708750f, 0.13817807f, -0.06228985f, -0.02131708f, 0.01599626f, 0.25524509f, 0.33834970f, 
    -0.34900993f, 0.17735361f, 0.05806984f, -0.03679562f, 0.25992259f, 0.30855101f, -0.03688721f, 0.02969211f, 
    0.03116545f, -0.05775038f, -0.03990178f, -0.00816018f, 0.04618596f, -0.10956046f, -0.08373950f, 0.12149255f, 
    0.03199076f, -0.03061100f, -0.10788174f, -0.15754694f, -0.19555780f, -0.05366249f, -0.06346205f, -0.01225605f, 
    0.15530485f, -0.11404669f, 0.17248380f, 0.08875785f, 0.08117665f, -0.02559236f, -0.02210697f, 0.02527924f, 
    0.01014885f, 0.10840664f, 0.01444467f, 0.03727476f, 0.17898861f, -0.32845861f, 0.23871182f, 0.44828939f, 
    0.09445854f, 0.04441086f, 0.14464268f, -0.16096056f, 0.28009170f, -0.13651735f, 0.04968442f, 0.12806758f, 
    0.07683449f, -0.06336285f, -0.08660756f, 0.11035743f, -0.07518133f, -0.00558399f, 0.01129730f, -0.12583174f, 
    -0.38759807f, 0.22120105f, 0.03100794f, -0.04956602f, -0.00774141f, -0.00071220f, -0.12049059f, 0.17879182f, 
    -0.06471057f, 0.03644567f, 0.05635856f, -0.06408982f, -0.17844312f, -0.15942521f, 0.18899678f, -0.18996924f, 
    -0.17570388f, 0.11923648f, -0.09223745f, 0.08127965f, -0.52752382f, 0.34789380f, -0.25675544f, 0.32438472f, 
    0.05565113f, 0.11380702f, 0.12767039f, 0.11646839f, -0.21373361f, 0.09151414f, 0.03953476f, 0.15551679f, 
    0.12421654f, 0.13168707f, 0.01561817f, 0.00050040f, -0.23361684f, -0.12941168f, 0.17754887f, 0.06861439f, 
    0.22407325f, 0.10829040f, 0.07123456f, -0.07696520f, 0.06610998f, 0.06159718f, -0.03235902f, 0.00839600f, 
    -0.13214572f, -0.06526912f, 0.07557511f, -0.04005877f, 0.01162434f, -0.03975947f, 0.00781810f, -0.09711947f, 
    -0.05199086f, 0.04676218f, 0.03716828f, -0.02364758f, -0.10297649f, -0.21469879f, 0.31089154f, 0.29701999f, 
    -0.27935177f, -0.02460684f, 0.10415795f, -0.06328197f, 0.05654782f, -0.15597692f, 0.00241358f, 0.10544869f, 
    0.02716606f, 0.00593659f, -0.06749156f, -0.04756587f, -0.00819032f, -0.06609446f, 0.02203571f, 0.05102390f, 
    -0.13415790f, -0.22388206f, 0.13063867f, -0.08428137f, -0.01768073f, -0.22441900f, 0.00998705f, 0.02700786f, 
    0.04797865f, 0.08882288f, 0.03183497f, -0.08910675f, 0.00534324f, 0.12967812f, 0.14288688f, 0.37408170f, 
    0.06590799f, 0.17342643f, 0.00589305f, -0.02930949f, -0.53635663f, -0.01409370f, -0.14446361f, 0.11729112f, 
    0.09220111f, -0.03678424f, -0.02335784f, -0.09876801f, 0.00362728f, -0.12618408f, -0.13799223f, -0.10428693f, 
    0.15144274f, 0.15674517f, 0.17271365f, -0.04109458f, -0.06327145f, 0.28193882f, -0.05856487f, -0.01493009f, 
    -0.09916867f, 0.11999835f, 0.02319642f, 0.11969602f, -0.05732904f, 0.10634526f, -0.01882498f, -0.05374755f, 
    -0.08679395f, -0.04592291f, -0.14954154f, -0.02704090f, -0.07418874f, 0.09673983f, 0.07534958f, 0.11109079f, 
    0.05780043f, -0.03206682f, -0.03675124f, 0.08827844f, -0.43717769f, -0.62371027f, -0.12996553f, -0.16585484f, 
    0.21154526f, -0.03549264f, 0.14209276f, 0.11704415f, 0.12527713f, 0.13572215f, 0.02828764f, 0.02834160f, 
    -0.04360715f, 0.03804822f, 0.12216567f, 0.03641521f, -0.07031747f, 0.06875683f, 0.06381265f, 0.15649146f, 
    0.09314264f, 0.25942031f, 0.24285226f, 0.20933200f, -0.02987488f, 0.12400611f, 0.08973720f, 0.02765457f, 
    0.11575471f, -0.06977226f, -0.07274945f, 0.03498972f, -0.08725226f, -0.08590829f, -0.10813060f, -0.03522814f, 
    0.07761123f, 0.28104615f, -0.03571161f, 0.09043275f, -0.25128299f, -0.31344560f, -0.28190225f, -0.55145514f, 
    -0.39979127f, 0.07411005f, -0.11433726f, 0.19938286f, -0.14903764f, 0.06602436f, 0.04010364f, -0.03409318f, 
    -0.07257362f, -0.02549543f, -0.03054572f, 0.14844860f, 0.02235068f, 0.02960453f, -0.01542300f, 0.06879660f, 
    0.26827323f, -0.22901423f, -0.01664560f, 0.14668287f, -0.25055054f, 0.13308713f, 0.10834879f, 0.15469787f, 
    0.15405150f, 0.02310262f, 0.24846143f, -0.00490860f, 0.04486576f, 0.00813646f, 0.15551420f, -0.08102207f, 
    0.02569075f, 0.11890391f, 0.03270027f, -0.14307566f, -0.49007136f, 0.22214137f, -0.34321499f, -0.04448335f, 
    -0.21078198f, -0.08888394f, 0.12983179f, 0.11233761f, 0.04478638f, -0.00551078f, 0.25086960f, 0.07608667f, 
    0.02588130f, 0.03501855f, 0.02033847f, -0.09419012f, 0.05787468f, 0.04437554f, 0.08105496f, 0.10802831f, 
    0.10245376f, 0.12251494f, 0.01280465f, 0.17521955f, -0.02965202f, -0.03438935f, 0.05465193f, -0.04784487f, 
    -0.07320944f, 0.04682424f, -0.18412663f, 0.01847594f, -0.06303547f, 0.03376580f, 0.01899742f, 0.00169874f, 
    0.12273272f, 0.15078026f, -0.08691792f, 0.00326548f, 0.23999162f, -0.00938964f, 0.40387791f, -0.03842070f, 
    -0.03219386f, -0.06928964f, -0.12639932f, 0.05949591f, -0.09764220f, -0.13990158f, 0.20758153f, 0.01670320f, 
    -0.00370966f, 0.04802158f, -0.00052490f, 0.24499078f, 0.14140116f, -0.07789535f, 0.06996556f, -0.12355404f, 
    0.05393310f, -0.12919971f, 0.03026785f, 0.03708314f, -0.16341028f, -0.07798021f, 0.02012467f, 0.03661973f, 
    0.03991008f, 0.15034409f, 0.15623139f, -0.03838518f, -0.15315507f, -0.10592196f, -0.04507695f, -0.07283209f, 
    0.06221236f, -0.04608067f, -0.01586651f, 0.05775851f, -0.67925704f, -0.02187365f, -0.31469491f, 0.02797584f, 
    -0.14513749f, 0.18410352f, -0.04419886f, 0.13760448f, -0.03680412f, 0.07870966f, 0.15928237f, 0.03775681f, 
    -0.10909473f, 0.10629742f, 0.14807449f, 0.00527548f, -0.01907406f, -0.10409981f, 0.14904474f, 0.25761992f, 
    -0.01774926f, 0.09546350f, -0.25651717f, -0.06199693f, 0.37476879f, -0.16701393f, 0.11769370f, -0.09046220f, 
    0.03568058f, -0.04382236f, -0.08266263f, 0.08738212f, 0.02980134f, 0.08533333f, 0.15627432f, -0.31460646f, 
    -0.09719045f, 0.12683870f, 0.13976252f, -0.06507925f, 0.44967973f, 0.14378424f, 0.47108638f, 0.32635966f, 
    0.24179570f, 0.04850321f, 0.02422008f, -0.24428956f, 0.01186063f, 0.04362772f, -0.01999511f, -0.09136094f, 
    0.05713029f, 0.02832483f, -0.00220543f, 0.03370266f, 0.02060003f, -0.03612529f, -0.04141571f, -0.02426443f, 
    -0.30548254f, -0.08643877f, -0.17321253f, -0.01702142f, 0.01191698f, 0.00122622f, -0.01481477f, 0.07179777f, 
    0.02128266f, -0.01114943f, 0.02658843f, 0.03897045f, 0.09165312f, 0.18946248f, 0.06217661f, -0.03466595f, 
    -0.05396511f, 0.04851760f, -0.01502653f, -0.04635748f, 0.16747242f, -0.05377951f, 0.46043515f, -0.10765696f, 
    -0.17427263f, 0.02741011f, -0.05424564f, 0.03429411f, -0.03415593f, -0.24789740f, 0.10963438f, 0.07614262f, 
    -0.04716635f, -0.16182441f, -0.02053995f, 0.03529567f, -0.00362060f, 0.00359001f, 0.09175113f, 0.18833418f, 
    0.06831972f, -0.08591192f, 0.31400782f, 0.01033049f, 0.18794981f, -0.08556402f, 0.04413175f, 0.06571598f, 
    0.10395854f, 0.22812468f, -0.03424389f, -0.01383762f, -0.00962475f, 0.19222911f, -0.10941715f, 0.04481865f, 
    0.08845675f, 0.18911289f, 0.17103985f, 0.07506872f, -0.42989981f, 0.13878599f, -0.18916598f, 0.12995926f, 
    0.04387645f, 0.11593881f, 0.17566702f, 0.16925135f, 0.08765688f, -0.23217492f, 0.00657964f, -0.00101451f, 
    0.16301164f, 0.17112072f, 0.05110283f, -0.08032736f, -0.23088789f, -0.11796416f, -0.06381077f, -0.16797821f, 
    -0.20032384f, 0.14947543f, 0.15586963f, -0.20003758f, -0.54835731f, 0.16363500f, -0.00763838f, 0.10707981f, 
    -0.06273431f, -0.18642531f, 0.23808852f, 0.03445368f, 0.01098329f, -0.33776265f, -0.05845263f, -0.00645743f, 
    -0.05011345f, -0.27644074f, -0.19744039f, -0.20679224f, -0.12813003f, 0.08142805f, 0.15995006f, 0.04112780f, 
    0.11004530f, 0.02989278f, -0.07566292f, 0.14636296f, 0.13254938f, -0.11797255f, -0.25189254f, 0.01738635f, 
    0.05790055f, -0.00145523f, 0.18154220f, -0.00767249f, -0.00755148f, -0.00410630f, 0.19779539f, 0.12572920f, 
    0.04061993f, 0.25492758f, 0.62215686f, 0.25216323f, 0.12875828f, -0.12653612f, -0.00545825f, -0.13269676f, 
    0.06589419f, 0.12529351f, 0.06688891f, 0.01308749f, -0.09689983f, -0.06822935f, 0.05059339f, 0.05885658f, 
    0.12631926f, -0.04176544f, 0.01237956f, 0.00315758f, -0.07515496f, -0.03166740f, 0.03079991f, -0.02688515f, 
    0.13839360f, 0.12089934f, 0.04608930f, 0.03112431f, 0.11717524f, 0.17490081f, 0.05396087f, -0.02002279f, 
    -0.10370727f, 0.20566556f, 0.01715413f, -0.03572434f, 0.17468946f, 0.18191899f, 0.02964233f, 0.17292124f, 
    0.03737034f, 0.12890507f, -0.01831391f, -0.02862660f, -0.05126308f, 0.26708689f, 0.22360857f, 0.00442601f, 
    -0.10254294f, -0.24922730f, 0.12113501f, 0.01004032f, -0.05952871f, -0.11749540f, 0.08971570f, 0.01442379f, 
    -0.00722153f, 0.11744954f, -0.27848282f, -0.02095131f, -0.38068366f, 0.43911046f, -0.23685007f, -0.00349744f, 
    -0.15954281f, 0.11466626f, 0.42386070f, -0.09320054f, 0.08087795f, -0.18407708f, 0.02509287f, -0.07993787f, 
    0.11155077f, -0.00277573f, 0.12170359f, -0.06935323f, -0.00942614f, -0.08614609f, 0.12777013f, 0.11545714f, 
    -0.24173900f, 0.19909109f, 0.12417144f, 0.16748644f, -0.04595378f, -0.34294951f, 0.18665105f, -0.13888615f, 
    -0.12671065f, 0.07869690f, 0.02540662f, 0.05083216f, -0.16417082f, 0.08922647f, -0.21805318f, 0.02920293f, 
    -0.07344124f, -0.25432020f, -0.40747151f, -0.47978348f, 0.23819782f, 0.03360544f, 0.38745463f, 0.13715839f, 
    0.16064359f, -0.05561494f, -0.14926736f, 0.05628144f, 0.00046229f, 0.09438270f, 0.03317977f, 0.04988009f, 
    -0.10553499f, -0.06241035f, -0.15934211f, 0.01233057f, 0.09810071f, 0.10600536f, 0.04941658f, 0.11005986f, 
    0.15216120f, -0.35029513f, -0.06273262f, -0.08575617f, 0.12084375f, 0.12862314f, 0.00450220f, -0.11086289f, 
    -0.00715237f, -0.16709977f, -0.05220519f, -0.09063893f, -0.03965252f, -0.00276265f, -0.01237876f, -0.03592608f, 
    -0.04334449f, 0.10570239f, 0.04537189f, -0.41788539f, -0.34492883f, 0.57839936f, -0.06766457f, 0.11090259f, 
    -0.03174549f, -0.06809273f, 0.17383504f, -0.06790143f, 0.01714845f, -0.05165422f, -0.18773074f, -0.00642422f, 
    0.00903747f, 0.03745009f, 0.18415289f, 0.11917713f, 0.08455128f, -0.04730870f, 0.02810867f, 0.13477296f, 
    0.41191167f, -0.00689315f, -0.04941509f, 0.12404002f, 0.04258870f, 0.09453643f, 0.08078866f, -0.04129500f, 
    -0.03288713f, 0.07219508f, -0.18020943f, -0.10397428f, 0.21201552f, 0.07539845f, 0.22392160f, -0.08601825f, 
    0.19658926f, -0.12357657f, 0.13932903f, 0.12157992f, 0.65882140f, -0.33465067f, -0.02363001f, -0.16153033f, 
    -0.08509243f, -0.04294468f, -0.00130125f, -0.08188542f, 0.00033922f, 0.05250676f, 0.10981230f, -0.10301977f, 
    -0.02062058f, -0.02035373f, 0.01596895f, -0.06185996f, 0.23169905f, 0.04855281f, -0.09199001f, 0.26886901f, 
    -0.38100046f, -0.08383026f, -0.11621010f, -0.18607706f, -0.16995306f, -0.11278713f, 0.03432322f, 0.07511917f, 
    -0.32358363f, -0.21944329f, -0.13088463f, 0.16081795f, 0.04014084f, -0.02669483f, -0.04469754f, -0.05222325f, 
    -0.06519173f, -0.04201312f, -0.28691396f, -0.33111691f, 0.32126433f, 0.03724545f, 0.09889791f, 0.09249279f, 
    0.25241777f, 0.18815540f, -0.01243069f, 0.08202665f, -0.00388005f, 0.18549116f, -0.03615848f, -0.07947925f, 
    -0.23182835f, -0.13138664f, -0.16950479f, 0.03146334f, -0.20071808f, -0.03069914f, -0.07570065f, -0.17599550f, 
    -0.00714325f, 0.01359512f, 0.03203021f, -0.00016457f, -0.01942689f, -0.04711693f, -0.06226901f, -0.01748281f, 
    0.04142591f, 0.05039307f, 0.02218626f, 0.01509909f, 0.02040727f, 0.02261386f, -0.01520817f, 0.02905593f, 
    0.01232352f, -0.05103230f, -0.06581155f, 0.04642946f, -0.04768091f, 0.02857282f, 0.03464307f, -0.01106902f, 
    0.02613953f, -0.00665216f, -0.03623048f, 0.00536295f, 0.02714393f, 0.01158041f, -0.05183116f, -0.01531407f, 
    -0.04324938f, 0.00965481f, -0.00023476f, -0.04559234f, -0.02310512f, -0.04972589f, -0.04801943f, -0.05858551f, 
    -0.03357904f, -0.05722142f, -0.04286549f, -0.03924508f, -0.01393298f, -0.01079471f, 0.03302096f, -0.06012385f, 
    -0.02862602f, -0.05794103f, 0.02979021f, -0.03042825f, -0.04669599f, 0.00143492f, 0.04240425f, -0.00455113f, 
    -0.05127701f, -0.04851875f, -0.03115205f, 0.01051863f, -0.01247942f, -0.00005311f, 0.00219803f, -0.03832558f, 
    -0.01570474f, 0.02728257f, -0.01500489f, -0.04824764f, -0.04729972f, -0.02430262f, -0.00293505f, -0.00308710f, 
    -0.00908662f, -0.00736757f, 0.03954631f, 0.01307692f, 0.03976526f, -0.01308372f, 0.02757861f, -0.00788383f, 
    -0.06028815f, 0.00718618f, 0.00830192f, 0.02974455f, 0.04480321f, 0.04377120f, -0.04128976f, -0.05117539f, 
    -0.01803562f, -0.02767531f, -0.05105048f, -0.00484162f, 0.00749199f, -0.02748002f, -0.01755532f, -0.03054761f, 
    0.02532778f, -0.04453921f, -0.02693640f, -0.01608504f, -0.06134336f, -0.02851277f, 0.01380920f, 0.02923330f, 
    -0.01795095f, -0.01159296f, 0.00731218f, -0.03793365f, -0.05536369f, 0.03099716f, 0.01690697f, -0.03786806f, 
    -0.04175049f, -0.00757590f, 0.01673793f, 0.02176063f, -0.00422509f, -0.05488468f, -0.01544245f, 0.02941447f, 
    0.01558366f, -0.05746133f, -0.00672137f, -0.01779799f, -0.03370671f, 0.02039165f, 0.04077113f, -0.02121590f, 
    -0.00113270f, 0.00243126f, -0.04345935f, -0.04698631f, 0.03266243f, 0.01600290f, 0.04181713f, -0.05083258f, 
    0.04168897f, 0.00730444f, 0.00135562f, -0.06002421f, -0.06116948f, -0.04336743f, 0.00275248f, -0.03325095f, 
    -0.02679135f, 0.03943093f, -0.05735158f, 0.02794993f, -0.05116182f, -0.06039605f, -0.03775216f, 0.01585463f, 
    -0.00516422f, 0.02047277f, -0.02510306f, 0.01194047f, 0.04398575f, 0.04819721f, 0.02399275f, -0.04638213f, 
    -0.03634321f, 0.01160214f, 0.04229330f, -0.03895016f, 0.00296479f, -0.03962731f, 0.02886052f, -0.01573138f, 
    -0.04119930f, -0.06035767f, 0.03626606f, 0.03715556f, 0.00699917f, -0.05104572f, -0.04769116f, 0.03493346f, 
    -0.02196369f, 0.03584893f, 0.03490071f, -0.04577533f, 0.00242502f, 0.03442544f, -0.01742809f, 0.00202258f, 
    -0.03824646f, -0.03569654f, 0.03390358f, -0.04023066f, -0.04599523f, -0.04851570f, 0.01327210f, -0.01747829f, 
    -0.02943127f, -0.06407072f, -0.02256042f, -0.02420557f, 0.01204519f, 0.01809987f, -0.05420321f, 0.01199818f, 
    -0.02732557f, -0.00881784f, 0.03919436f, 0.02062554f, -0.03068417f, -0.04731787f, -0.04861778f, -0.02230804f, 
    0.00017103f, -0.02734659f, 0.02654409f, -0.05430732f, -0.02829270f, -0.04776269f, 0.04616199f, 0.00767125f, 
    -0.02151662f, 0.00861124f, -0.01701116f, -0.05616058f, 0.02098317f, -0.02114764f, -0.03581535f, 0.00697397f, 
    -0.03890514f, -0.01850016f, 0.02829975f, -0.06083450f, -0.03238047f, -0.05754611f, 0.03790661f, 0.03443391f, 
    -0.04809410f, -0.01542149f, 0.00329386f, -0.05440448f, -0.02443222f, 0.00049875f, -0.00091404f, 0.02992930f, 
    0.02252527f, -0.00141857f, -0.02353282f, 0.01028875f, 0.03646608f, 0.03377291f, -0.01661601f, 0.02062331f, 
    -0.01464244f, -0.01938033f, 0.02563547f, -0.03619310f, 0.01274559f, 0.00941448f, 0.03599296f, 0.02095111f, 
    0.04787159f, -0.02385582f, -0.04597797f, -0.03981952f, -0.04485980f, -0.03272357f, 0.01047570f, -0.00077159f, 
    0.01343336f, 0.03131495f, -0.04473267f, 0.02885604f, 0.01208386f, -0.04213108f, -0.02329357f, 0.01229428f, 
    -0.06193933f, 0.00592473f, -0.06301199f, -0.02823911f, -0.04184489f, -0.04231238f, -0.04826517f, 0.03573041f, 
    -0.06137840f, 0.01138720f, 0.04196340f, -0.01513619f, -0.00226845f, 0.04369944f, 0.04085942f, -0.05826939f, 
    -0.04327406f, 0.04332301f, 0.03752954f, -0.02124882f, -0.06087572f, 0.02591754f, 0.00616456f, 0.01708497f, 
    -0.03790314f, -0.02651617f, -0.03040528f, -0.00447936f, 0.00031671f, 0.02545895f, 0.02505546f, 0.01786297f, 
    -0.03703071f, 0.01931145f, -0.02524832f, 0.00120497f, 0.01756510f, -0.00008950f, -0.05570750f, 0.02718545f, 
    0.04430551f, -0.05171556f, -0.03068389f, -0.05423279f, 0.01401004f, 0.03365725f, -0.02436064f, -0.03820524f, 
    -0.14935374f, -0.10167526f, 0.21915093f, 0.11434366f, -0.21149544f, 0.02216479f, -0.04569617f, -0.14025696f, 
    0.09690677f, -0.14926910f, -0.00654133f, -0.03194725f, 0.06770517f, 0.04270231f, -0.17752624f, 0.08648846f, 
    0.31064922f, 0.06931456f, 0.05090618f, -0.03438738f, 0.24570237f, 0.06035464f, -0.18200694f, -0.32122841f, 
    0.17350978f, 0.01252197f, -0.11402828f, -0.09504196f, -0.00993928f, -0.01864132f, 0.00156349f, 0.10169040f, 
    -0.10116347f, -0.11349332f, 0.03163758f, 0.17294735f, 0.06014432f, 0.05974393f, -0.11575679f, 0.13018821f, 
    0.12725922f, -0.15454018f, -0.18875405f, -0.16449095f, 0.05419077f, 0.10546534f, 0.04891551f, -0.07376321f, 
    -0.09619821f, 0.04333941f, 0.11515433f, -0.00309489f, -0.11432264f, 0.06103275f, 0.18020895f, 0.16816948f, 
    -0.00530152f, -0.06458133f, -0.15977645f, -0.10162356f, -0.03795220f, -0.22356829f, 0.33181977f, -0.13857406f, 
    -0.19012056f, 0.00354036f, 0.00206675f, -0.15665187f, 0.07410345f, -0.11302973f, -0.08153921f, -0.03545028f, 
    0.20771252f, 0.09666373f, 0.02182570f, 0.01831499f, 0.10597324f, 0.00561938f, 0.08335739f, 0.08986638f, 
    0.81711763f, -0.09117144f, -0.59481090f, -0.05643629f, -0.01603633f, 0.06164153f, 0.24093337f, 0.18068263f, 
    -0.04680510f, 0.06857000f, 0.00720690f, -0.05938696f, -0.14365675f, -0.05129625f, -0.09093638f, -0.02610285f, 
    0.16651429f, 0.18431331f, 0.14548190f, 0.18439354f, -0.11035174f, -0.23235913f, 0.33491361f, 0.33651534f, 
    -0.22955117f, -0.16299267f, -0.01711695f, -0.08094274f, -0.11506885f, 0.03364437f, 0.02383720f, -0.00411888f, 
    0.07571910f, 0.07919162f, -0.02689668f, -0.00407933f, 0.07112983f, -0.01772257f, 0.06972422f, -0.02011674f, 
    -0.28698778f, 0.05138613f, 0.05872739f, 0.41809458f, 0.13820326f, -0.00528161f, 0.01127152f, -0.16362572f, 
    -0.13796973f, 0.03995004f, 0.01669708f, 0.12888417f, 0.15966213f, 0.12847440f, 0.05381588f, 0.07365809f, 
    -0.00941331f, -0.12101545f, -0.04978677f, 0.10940991f, -0.29502541f, -0.24341847f, 0.19115269f, 0.34552956f, 
    0.19471066f, -0.06030164f, 0.08573503f, -0.04985755f, -0.17645834f, 0.13432930f, 0.04598293f, -0.05905828f, 
    0.06426082f, 0.09317306f, 0.00065082f, 0.17126724f, 0.04645920f, -0.04984273f, -0.07336218f, -0.00877580f, 
    0.26075783f, -0.09690642f, -0.21714982f, -0.14370580f, 0.03257928f, 0.09723836f, 0.17099865f, 0.16254111f, 
    -0.04879941f, -0.01378936f, 0.06093261f, 0.03908458f, 0.01847261f, 0.00488765f, 0.07903291f, 0.14824887f, 
    0.03169283f, -0.16310622f, 0.03032732f, 0.02167784f, -0.18307972f, -0.12179245f, -0.17590457f, 0.18289813f, 
    -0.03378565f, 0.03755320f, -0.10499699f, 0.06350216f, 0.00026780f, 0.02924652f, -0.04864549f, -0.03185307f, 
    0.01996686f, 0.01788470f, 0.00137157f, 0.01691901f, 0.11205439f, 0.04414052f, 0.10161846f, 0.32771027f, 
    0.01027215f, 0.20607552f, 0.31960544f, 0.30170295f, -0.25335869f, -0.05210932f, -0.14172529f, -0.15653643f, 
    -0.11394961f, 0.10453304f, 0.13571675f, 0.03560995f, 0.18665910f, 0.12674434f, 0.08774772f, 0.13811173f, 
    -0.09173162f, -0.11047327f, -0.11909796f, -0.08871236f, -0.48735636f, -0.76600975f, -0.07663617f, 0.39310002f, 
    0.26449028f, 0.04844785f, 0.29314706f, -0.04765134f, -0.14468877f, 0.07297964f, 0.23996249f, 0.04344119f, 
    0.23233476f, 0.13491485f, -0.05312746f, 0.26844254f, 0.10395600f, 0.05456683f, 0.10221075f, 0.09221512f, 
    -0.50523072f, 0.23666705f, 0.09613017f, -0.08412659f, -0.02155778f, 0.00986787f, -0.08029768f, -0.08528230f, 
    0.05856852f, -0.02125679f, -0.03756307f, 0.12256958f, 0.00687041f, 0.02787360f, 0.07247923f, -0.02661882f, 
    0.11054920f, 0.24488826f, 0.16773526f, 0.26390409f, -0.25767452f, -0.02997889f, -0.44773427f, 0.13300063f, 
    0.06598468f, 0.07510096f, 0.04882693f, 0.10992497f, -0.02867466f, 0.02977352f, -0.01627796f, -0.07045107f, 
    0.02462132f, -0.13186021f, -0.09503872f, -0.02107084f, 0.13473415f, 0.07217412f, 0.14722607f, 0.26973593f, 
    0.02791516f, 0.05248589f, 0.15132010f, -0.08235028f, -0.02074973f, 0.00140980f, -0.05969470f, -0.09848952f, 
    -0.04274357f, -0.08775705f, 0.05592186f, 0.09057926f, 0.11933681f, 0.12539883f, 0.07530085f, 0.14341952f, 
    -0.02061621f, -0.08956977f, -0.12131311f, 0.02525044f, -0.20343685f, 0.14421163f, 0.19336084f, 0.38920128f, 
    0.00366495f, -0.14101306f, -0.14544012f, -0.07359768f, -0.09895094f, 0.04997181f, 0.07290673f, 0.00018638f, 
    -0.07930579f, -0.07467270f, 0.05548028f, -0.03115461f, -0.12551767f, -0.04923081f, -0.01292913f, -0.34464470f, 
    -0.22379394f, -0.12925136f, 0.33877754f, -0.23059040f, -0.08480337f, 0.01846626f, -0.00596003f, -0.18799181f, 
    0.17222494f, -0.10548101f, -0.02694219f, -0.07720274f, 0.03322391f, 0.10954667f, 0.01867695f, -0.10972267f, 
    0.41147953f, 0.01085761f, 0.11574843f, 0.21758316f, -0.26741949f, 0.13194473f, 0.03762584f, 0.02545900f, 
    -0.18336272f, 0.17500253f, -0.31368235f, -0.15051773f, -0.09649896f, 0.30831474f, 0.07506892f, 0.09658758f, 
    0.02820994f, 0.09353399f, 0.23770753f, 0.03351641f, 0.09362306f, 0.16730012f, 0.01703327f, 0.01590678f, 
    -0.02419884f, -0.10454337f, -0.02334397f, -0.02026452f, -0.02773961f, 0.38325885f, -0.15857862f, -0.02032726f, 
    -0.12928672f, 0.42409390f, 0.25550488f, 0.08799751f, -0.27720428f, 0.12749404f, 0.13293837f, 0.02750058f, 
    0.04127616f, -0.44855160f, -0.44680601f, -0.45156962f, -0.54992956f, -0.09863213f, 0.18341886f, -0.11552809f, 
    0.48195791f, -0.04783039f, 0.18553847f, 0.16800459f, -0.06705204f, -0.01477439f, 0.11486816f, -0.03704924f, 
    0.09751929f, 0.04623387f, -0.03411071f, 0.11064721f, 0.25848335f, 0.03114890f, 0.18701896f, 0.12708224f, 
    -0.18141180f, 0.03878801f, 0.12683442f, 0.07112126f, 0.37821159f, 0.21065070f, 0.16953711f, 0.01625878f, 
    -0.05335258f, -0.06824899f, -0.01497305f, -0.20772974f, -0.10439952f, -0.02768093f, -0.02834367f, 0.17358834f, 
    0.25715041f, 0.16606481f, 0.05047143f, 0.04911214f, 0.21082960f, -0.15686156f, 0.20564225f, -0.09574381f, 
    -0.05570805f, -0.12054058f, 0.07179011f, 0.02675332f, -0.05407235f, 0.10094340f, -0.02100310f, -0.09305266f, 
    -0.11502033f, 0.14524390f, 0.02035701f, 0.09469810f, 0.14101607f, 0.06943791f, 0.04825768f, 0.09820276f, 
    0.30265173f, 0.05028162f, 0.15004481f, -0.13624190f, 0.03731001f, -0.25947478f, -0.24274421f, 0.28618118f, 
    -0.17558961f, 0.06318635f, 0.17563243f, -0.11616221f, 0.04439151f, 0.13357095f, -0.00250607f, -0.15659191f, 
    -0.07547028f, -0.16964136f, -0.12787519f, -0.04427847f, 0.18648142f, 0.18943399f, 0.30528077f, -0.18886866f, 
    0.08931495f, -0.13175263f, -0.21092588f, 0.07785936f, 0.07072159f, 0.19375929f, 0.04600621f, -0.02071256f, 
    -0.03969160f, 0.11746414f, -0.00312080f, -0.15424635f, -0.02684926f, -0.21558285f, -0.22714026f, 0.13354190f, 
    0.03432687f, -0.20067307f, 0.07741334f, -0.13876094f, 0.00637726f, 0.21342915f, -0.01463256f, 0.06189923f, 
    -0.22120966f, 0.01906015f, 0.12772502f, -0.01820681f, -0.05066480f, 0.08937934f, -0.02758558f, 0.20448239f, 
    -0.25942612f, -0.19878204f, -0.26723629f, -0.31232372f, 0.03549731f, -0.10954206f, 0.14951429f, -0.01895836f, 
    0.04995697f, -0.06131415f, 0.17470372f, 0.06660901f, 0.06112279f, 0.00986271f, 0.03138438f, -0.07866852f, 
    -0.14807080f, 0.00240557f, -0.05870965f, 0.09400500f, 0.28292114f, 0.12607759f, 0.12172394f, 0.34709606f, 
    0.14673239f, 0.38304654f, 0.55684358f, 0.09530637f, 0.10588311f, -0.07146809f, -0.10320873f, -0.13642697f, 
    0.12338857f, -0.12221979f, 0.22015969f, -0.02855677f, -0.01979876f, -0.02987256f, 0.05516322f, -0.22067881f, 
    -0.13453448f, -0.15642409f, -0.25055692f, -0.35689789f, 0.50409311f, 0.02514105f, -0.11254437f, -0.09765933f, 
    -0.17235276f, -0.00555915f, -0.13279262f, 0.02611257f, -0.13593704f, 0.04928161f, 0.10340530f, 0.03297813f, 
    0.03014550f, -0.03496003f, -0.13252456f, -0.06389091f, 0.13531159f, -0.10616096f, 0.06567746f, 0.15014176f, 
    -0.30118427f, 0.00140876f, 0.03908652f, -0.06290873f, 0.38159186f, -0.00871155f, 0.03666341f, -0.01696078f, 
    0.25859541f, 0.05144713f, 0.01038133f, 0.08442474f, 0.16305043f, 0.17193571f, 0.17126612f, 0.06407928f, 
    0.35412547f, 0.11719722f, 0.22523308f, 0.12260071f, 0.11652822f, 0.26363081f, -0.06492830f, -0.05726108f, 
    -0.18817759f, -0.08656203f, -0.04390772f, 0.01974932f, -0.09999109f, 0.21196587f, 0.16293630f, -0.01665925f, 
    0.10583823f, 0.03681720f, -0.21963738f, 0.01769231f, 0.15907586f, -0.05352503f, 0.17884366f, 0.08631813f, 
    -0.21747229f, 0.39880481f, -0.08793406f, -0.26465309f, 0.19773503f, -0.21672557f, -0.28250059f, 0.16447999f, 
    -0.00919990f, 0.17984207f, 0.09851524f, 0.01401751f, -0.04589341f, 0.09464885f, 0.14321403f, -0.13049191f, 
    -0.44053575f, -0.25155300f, -0.36842087f, -0.49489033f, 0.14022031f, -0.14247151f, 0.08207511f, 0.05792995f, 
    -0.03794261f, 0.03337666f, 0.04872927f, 0.03821051f, -0.18647541f, -0.06969119f, 0.15667565f, 0.13976210f, 
    -0.06938422f, -0.03865352f, -0.01881828f, 0.00867469f, -0.31663337f, -0.29745841f, -0.30136561f, -0.12312390f, 
    0.08764533f, -0.04031925f, -0.04802137f, 0.00041699f, 0.03784734f, -0.11662535f, -0.04939314f, 0.02227415f, 
    0.07891633f, 0.14558519f, -0.00933825f, -0.12819585f, -0.04281315f, 0.12643194f, 0.06992786f, -0.02655068f, 
    0.15337852f, -0.13902023f, -0.04734720f, 0.04821548f, 0.01899133f, 0.19631544f, 0.30324191f, -0.06850550f, 
    -0.18898439f, -0.03586470f, -0.15985277f, -0.00316862f, -0.10392626f, -0.08340912f, 0.16363306f, 0.07626917f, 
    0.10336491f, 0.07967249f, -0.00109436f, 0.04505897f, 0.08322655f, 0.07577006f, 0.06440598f, 0.04997505f, 
    -0.06293962f, -0.07162748f, -0.07666322f, -0.07483000f, 0.00175304f, -0.01029350f, 0.12966980f, 0.01865744f, 
    -0.04069191f, -0.12121505f, 0.02394483f, 0.08192323f, -0.16597630f, 0.16731822f, 0.04786272f, 0.04627666f, 
    0.02762315f, 0.03292310f, 0.05088830f, -0.00706584f, -0.04728151f, -0.60218877f, -0.20004612f, -0.20472099f, 
    -0.24089135f, 0.21337220f, -0.16047035f, 0.06003841f, 0.14006150f, 0.02615956f, 0.00984256f, 0.07629344f, 
    -0.03772938f, 0.16471623f, -0.01376952f, 0.01625403f, 0.06514464f, 0.03055535f, 0.09452499f, 0.06654578f, 
    -0.20139019f, 0.22334108f, -0.68471783f, 0.34547204f, 0.11371253f, 0.09562343f, 0.04764023f, 0.12501349f, 
    -0.13912094f, 0.03260377f, -0.02800748f, -0.03394866f, -0.03404219f, 0.03914528f, -0.07802993f, 0.11146158f, 
    -0.07823497f, 0.05793608f, -0.08602617f, -0.17317745f, 0.26133403f, 0.04841080f, -0.05853438f, 0.00022276f, 
    -0.21728601f, -0.06823703f, 0.02112270f, -0.12154452f, 0.13773650f, -0.00803679f, 0.01801854f, -0.13274133f, 
    -0.03403001f, -0.09978259f, 0.00747547f, -0.03102551f, 0.01196816f, -0.12136110f, 0.13135192f, -0.00686230f, 
    0.24556871f, 0.12397218f, 0.12639643f, 0.16406102f, -0.29066655f, -0.10859879f, -0.31943616f, 0.06537633f, 
    0.11725062f, -0.07612867f, 0.06827942f, 0.01194556f, 0.00459599f, -0.06190967f, -0.02407556f, -0.00873970f, 
    -0.15135579f, -0.14423493f, 0.11294002f, -0.16053538f, 0.35832009f, 0.17852803f, 0.23976998f, 0.09344047f, 
    -0.15385279f, -0.28704667f, -0.19317098f, -0.27858192f, 0.01857697f, -0.09507684f, 0.11397266f, 0.13009231f, 
    -0.02465700f, -0.07031922f, -0.05134579f, 0.01141754f, 0.04465739f, 0.07547656f, -0.09319773f, 0.06295396f, 
    -0.14032099f, -0.10814784f, -0.01175504f, -0.14956926f, 0.07376701f, 0.07456472f, 0.05777612f, 0.16673250f, 
    -0.02308114f, -0.01055575f, 0.12976027f, -0.02273838f, 0.07909498f, -0.15094729f, -0.04444757f, 0.04497520f, 
    0.08027940f, 0.01280988f, 0.11980584f, 0.04833712f, -0.02574331f, 0.17054065f, -0.00064151f, 0.19421507f, 
    -0.11028238f, 0.15073395f, 0.10513312f, 0.05069255f, 0.02100322f, 0.18274949f, -0.05558557f, -0.06342213f, 
    -0.05948555f, 0.11239704f, 0.00860341f, 0.13147959f, 0.04335519f, -0.05081636f, 0.09430317f, 0.08607665f, 
    0.52371788f, -0.05293568f, 0.04186716f, -0.04814004f, -0.31700820f, -0.13113102f, 0.02905086f, -0.27672544f, 
    -0.03089486f, 0.06040155f, 0.22918370f, 0.00760459f, 0.06733865f, 0.10165529f, -0.06141629f, 0.06189127f, 
    0.00879556f, -0.01886973f, 0.10440101f, 0.11562108f, 0.42445672f, -0.33219928f, -0.11859470f, 0.07685192f, 
    -0.23794131f, -0.28233966f, -0.07264677f, -0.13461235f, 0.19045739f, -0.07523986f, 0.13204958f, -0.02365302f, 
    -0.15270334f, 0.02884716f, -0.16520628f, 0.11082919f, 0.00653341f, 0.01403597f, -0.10379395f, 0.19763249f, 
    -0.11785731f, 0.03578954f, -0.22061290f, 0.13293608f, -0.04238137f, -0.10677841f, -0.12525161f, 0.01202834f, 
    0.03584691f, 0.02648821f, -0.00598438f, 0.05852221f, -0.06398065f, 0.12158813f, -0.07072537f, -0.03826508f, 
    0.09803227f, 0.22888252f, -0.08725363f, 0.09131701f, -0.53599489f, 0.41124102f, 0.01050548f, 0.36326858f, 
    0.06435347f, -0.09260692f, -0.01418269f, 0.00430958f, -0.11300838f, -0.17384523f, 0.01660372f, 0.11598684f, 
    0.07969312f, 0.12054639f, 0.03986015f, 0.01863752f, -0.05264489f, 0.02973982f, 0.00960485f, 0.09524348f, 
    0.16639531f, -0.08218998f, 0.13980640f, -0.17062649f, -0.12696064f, -0.02131364f, -0.15363845f, -0.16300991f, 
    -0.05907691f, -0.08844442f, 0.14140643f, -0.00695828f, -0.02220630f, 0.13735776f, 0.01463516f, -0.07424604f, 
    -0.02975997f, -0.07535246f, 0.16364948f, 0.07526788f, -0.05334927f, 0.35400701f, 0.21901600f, 0.11770684f, 
    -0.22561355f, -0.15957719f, 0.13122718f, 0.26437172f, 0.12011530f, 0.13742340f, -0.09312756f, -0.07849146f, 
    0.09959235f, -0.07742444f, -0.05267155f, 0.08916028f, 0.05335079f, -0.12263378f, 0.20235072f, 0.00795054f, 
    0.17541367f, 0.12885600f, 0.20810358f, 0.27362365f, -0.20642653f, -0.06539664f, 0.18858641f, 0.04419687f, 
    0.09815013f, 0.13194683f, -0.09910852f, -0.09479158f, 0.06831890f, -0.01029542f, -0.00250386f, 0.28448641f, 
    0.14801949f, 0.08771760f, 0.05697547f, 0.15648897f, 0.46891680f, 0.08103982f, 0.00147423f, 0.06060049f, 
    0.04320752f, -0.01588972f, -0.10255256f, -0.06471158f, 0.02500080f, 0.02275667f, 0.00430747f, 0.13380313f, 
    -0.02094792f, -0.06522845f, 0.07634530f, 0.04336972f, 0.11162245f, -0.11570540f, -0.20095600f, 0.02311244f, 
    -0.06191968f, 0.06596290f, 0.14603084f, -0.02166364f, 0.03266005f, -0.10145050f, 0.05634804f, -0.07267585f, 
    -0.04966623f, -0.01620688f, -0.12192845f, 0.01200249f, -0.07530864f, 0.05357608f, 0.11600766f, -0.01988327f, 
    -0.11807424f, -0.06497671f, -0.09407641f, -0.23196045f, 0.14716594f, -0.41777679f, 0.03985230f, 0.11009265f, 
    -0.33686796f, 0.00245173f, -0.07358852f, -0.02151833f, 0.05460250f, -0.10467277f, -0.08238502f, -0.17388357f, 
    0.00682611f, 0.11639897f, 0.15268843f, 0.08598256f, 0.16177548f, -0.03059839f, -0.03534500f, 0.12658408f, 
    0.58460712f, 0.42628336f, 0.07368415f, 0.14535685f, -0.15434232f, -0.11186185f, -0.12503807f, -0.11990900f, 
    -0.09374061f, -0.00424596f, 0.05604664f, 0.00177762f, 0.05804789f, 0.02105138f, -0.04641109f, -0.01441601f, 
    0.16415995f, 0.00546751f, 0.03845126f, 0.08552489f, 0.35693201f, 0.07995524f, 0.28061363f, 0.17730612f, 
    -0.10820010f, -0.13494919f, 0.10322753f, -0.01980888f, 0.05813679f, 0.07317610f, -0.08979594f, -0.10816345f, 
    0.05588806f, -0.03175016f, 0.01358469f, 0.12965409f, 0.03754005f, -0.02056654f, 0.00271975f, -0.02100415f, 
    -0.09907973f, 0.06561241f, -0.08211590f, 0.11791636f, 0.04085864f, -0.03458064f, -0.17773090f, 0.12451486f, 
    -0.02521028f, -0.03690554f, -0.00764855f, 0.18322690f, 0.05163724f, 0.02402185f, -0.06395461f, -0.04374966f, 
    -0.04289515f, -0.27264288f, 0.05710791f, 0.11345898f, 0.07047859f, -0.27586704f, -0.04990477f, 0.17399275f, 
    0.07704162f, -0.13253023f, -0.02468892f, -0.02373241f, -0.09613651f, 0.06455983f, -0.01991517f, 0.00835489f, 
    -0.02491850f, -0.09359506f, -0.01009556f, -0.05130677f, -0.04792711f, -0.01710207f, -0.11125788f, -0.09695119f, 
    0.11285893f, 0.11576757f, 0.16175705f, 0.13017324f, 0.05402788f, -0.06612981f, 0.04803627f, 0.04069635f, 
    0.08365452f, -0.02337524f, -0.10977654f, -0.00265283f, 0.00435313f, -0.01091408f, 0.15408377f, 0.00959153f, 
    -0.02344061f, -0.20200001f, -0.03203792f, 0.04579322f, -0.03024540f, 0.01801668f, -0.07477283f, -0.04253129f, 
    -0.07696939f, 0.10348395f, -0.12229865f, 0.14694096f, 0.07605910f, 0.16781092f, -0.12659851f, -0.00717204f, 
    0.07142059f, 0.01747308f, -0.07470015f, 0.02958638f, 0.10649663f, 0.09558651f, 0.05243963f, 0.23069777f, 
    0.18523461f, -0.08142193f, -0.18499014f, 0.03831394f, -0.30083260f, -0.18529710f, -0.17797036f, -0.03719710f, 
    0.04517218f, -0.04210558f, 0.05386880f, -0.07385381f, -0.03660544f, -0.14153296f, -0.05071235f, 0.01689335f, 
    -0.13822241f, -0.14516929f, -0.23515257f, -0.12290561f, -0.15796177f, -0.60163313f, -0.33669218f, 0.24399798f, 
    0.27195203f, 0.07971922f, 0.07249688f, 0.15896168f, -0.05170999f, 0.03611089f, 0.04500894f, 0.04455430f, 
    0.16514833f, 0.07210584f, 0.05986357f, 0.06292506f, -0.15649435f, 0.02236605f, -0.00159591f, 0.07839970f, 
    -0.48010674f, -0.14080304f, 0.24476805f, -0.02538238f, -0.22306353f, -0.05330271f, 0.03213727f, -0.06325607f, 
    -0.04130280f, 0.05845319f, -0.06780107f, 0.06802150f, 0.04404462f, 0.09702176f, -0.02236920f, 0.27292559f, 
    -0.01631211f, 0.17466268f, 0.09514500f, 0.35529137f, -0.28839412f, -0.21863753f, 0.26413912f, 0.32161590f, 
    0.20845948f, 0.08856159f, -0.09238862f, 0.00638327f, -0.13169420f, -0.05325746f, 0.00584513f, 0.05518016f, 
    0.00311274f, -0.03467666f, -0.07622950f, -0.06382144f, 0.12592471f, 0.01099807f, 0.08947247f, 0.17742331f, 
    0.17165945f, -0.10100635f, 0.00453217f, 0.00864540f, -0.07936107f, -0.07070849f, -0.02798992f, 0.02878194f, 
    0.10170478f, -0.10080574f, -0.03577731f, -0.04829124f, -0.07967327f, 0.07125670f, 0.01596840f, -0.09857283f, 
    -0.10273135f, -0.07928403f, -0.19351818f, -0.10412625f, -0.03855913f, 0.27305505f, 0.10917159f, 0.12845951f, 
    -0.10386319f, 0.05170732f, -0.07019632f, -0.04127466f, -0.02579708f, 0.19267398f, -0.05371910f, 0.06747358f, 
    -0.07948998f, -0.08889748f, -0.11882830f, -0.01128494f, -0.12765795f, 0.01583311f, -0.07601788f, -0.13590817f, 
    -0.22932874f, -0.23078889f, 0.03768281f, 0.16949800f, 0.14389722f, -0.00654450f, -0.02097669f, 0.06343005f, 
    0.05667175f, -0.07261395f, -0.04854105f, -0.01390167f, 0.04443852f, 0.21450025f, -0.06297915f, 0.03558847f, 
    0.11588231f, 0.14713401f, 0.23831710f, -0.08921879f, -0.46468216f, -0.02176532f, -0.09566844f, -0.15990078f, 
    0.19123557f, 0.03156758f, -0.05652881f, -0.12603700f, -0.05876452f, -0.09388985f, -0.04705105f, -0.11332805f, 
    0.15342361f, 0.09366480f, 0.08285476f, 0.03190230f, -0.11778363f, 0.11479732f, -0.02296569f, -0.09265869f, 
    -0.02316918f, -0.14369041f, -0.16536114f, -0.00153011f, -0.01892441f, 0.22505926f, -0.07951626f, -0.03267261f, 
    -0.06284052f, 0.00383822f, 0.06342673f, -0.00254557f, -0.01326171f, -0.04249424f, 0.20105788f, 0.27034405f, 
    0.26817307f, -0.18676612f, -0.11464100f, 0.10602877f, -0.23845509f, 0.21739097f, 0.29870999f, -0.24043812f, 
    0.29006040f, 0.05824687f, 0.04769875f, -0.09502226f, 0.18363838f, 0.04066673f, -0.06173855f, 0.05346824f, 
    0.22543523f, 0.03039405f, 0.15049036f, -0.03426042f, 0.04272229f, 0.15235722f, -0.01033583f, 0.08431823f, 
    0.24913327f, -0.26902041f, 0.33369505f, 0.06941745f, 0.36847770f, 0.06043601f, 0.04375992f, 0.10672157f, 
    -0.00919673f, 0.04818476f, -0.16894884f, -0.02301235f, -0.03428518f, -0.15298030f, 0.08568338f, 0.02946346f, 
    -0.00260987f, 0.03228768f, -0.06349306f, -0.09349094f, -0.59069109f, -0.27073067f, -0.08855951f, 0.16396236f, 
    0.05646415f, 0.00192132f, -0.18073572f, -0.11679041f, 0.03760770f, 0.00668725f, 0.01204022f, 0.05339870f, 
    -0.00048839f, 0.03745838f, -0.10827309f, -0.16138251f, 0.10558464f, 0.08409747f, -0.02638146f, 0.17576565f, 
    0.13201432f, 0.08303668f, 0.04854284f, 0.17268696f, -0.11224619f, 0.17284791f, 0.24806727f, -0.10702717f, 
    -0.01974130f, 0.18158504f, 0.06803561f, 0.03372223f, 0.10912988f, 0.14102247f, 0.08127319f, -0.10337520f, 
    -0.00802351f, 0.08741150f, -0.07352071f, 0.02592232f, -0.60583532f, 0.42805377f, 0.14304604f, 0.02399876f, 
    -0.06032378f, 0.25147069f, 0.13384704f, -0.03315920f, -0.09059381f, -0.02554033f, 0.20693611f, 0.12599595f, 
    0.09257786f, 0.12005396f, 0.04098599f, -0.07386915f, -0.08223739f, 0.05793139f, 0.02971533f, -0.02072424f, 
    0.13043603f, 0.03676694f, -0.21008696f, -0.05345459f, 0.14563824f, 0.01715645f, 0.02674665f, 0.15454589f, 
    -0.20050822f, -0.05814668f, 0.02885421f, -0.10731132f, -0.01800553f, 0.01933256f, -0.00741381f, 0.23349114f, 
    0.10774831f, 0.00460900f, -0.14648311f, -0.21014349f, -0.07400416f, -0.27158672f, 0.11973470f, 0.27241647f, 
    0.03701847f, 0.01274720f, 0.06469246f, 0.15122715f, 0.05025011f, -0.04050393f, -0.02083168f, 0.03881546f, 
    -0.07643767f, -0.04465144f, 0.00707309f, -0.00387251f, 0.17516449f, 0.08319304f, 0.14081411f, 0.06643846f, 
    -0.29984188f, 0.00874827f, 0.17113787f, 0.26966026f, -0.03737562f, 0.08953419f, -0.13091275f, -0.08671913f, 
    0.05458580f, 0.22364467f, 0.11055017f, 0.05079306f, 0.06413035f, 0.07772642f, -0.02766407f, -0.03887947f, 
    -0.03100782f, 0.07435100f, 0.04966091f, -0.02374866f, -0.66082233f, 0.41988626f, 0.53154230f, 0.35005012f, 
    -0.23215066f, 0.07604510f, 0.04531047f, -0.16374665f, -0.17187011f, 0.05190242f, 0.05990578f, -0.06943314f, 
    0.04991189f, 0.09757768f, 0.17249796f, 0.06820343f, 0.05934970f, -0.03836140f, 0.01883392f, -0.05471187f, 
    0.15941091f, 0.24080265f, -0.17006956f, -0.08118454f, 0.31540626f, -0.03219114f, 0.02143750f, 0.00367859f, 
    0.05613770f, -0.00599149f, -0.09344131f, 0.01124393f, 0.08383726f, -0.13451342f, 0.23243609f, -0.14941181f, 
    0.06133622f, 0.21587497f, 0.13261956f, -0.04047386f, 0.54177529f, -0.12761374f, -0.39819872f, -0.00325738f, 
    0.03767097f, 0.00556132f, 0.08588287f, -0.12227671f, 0.00216460f, 0.12815090f, -0.02960892f, -0.13968098f, 
    -0.04102657f, -0.00016858f, 0.03668466f, 0.13700636f, 0.12835664f, 0.14378439f, 0.10738043f, 0.11172588f, 
    -0.28402507f, 0.02024100f, -0.05646851f, -0.16856191f, 0.01067636f, 0.04118613f, 0.01912332f, -0.02551588f, 
    -0.17270753f, 0.09997765f, 0.18789521f, 0.12158263f, 0.16999696f, 0.04980731f, 0.05767445f, 0.00533520f, 
    -0.13690715f, -0.01734236f, -0.07696204f, -0.12486252f, -0.23642066f, -0.31710076f, 0.11334480f, 0.05430610f, 
    0.21270372f, 0.12948652f, 0.02356798f, 0.08828726f, 0.06259944f, -0.09104721f, 0.03429827f, 0.02431607f, 
    -0.11492212f, -0.04169893f, -0.13823798f, 0.04405218f, -0.07994713f, 0.04562388f, 0.07757698f, 0.15173155f, 
    0.07439890f, 0.11042067f, 0.18265291f, 0.03532051f, 0.45368311f, -0.04729054f, 0.21489286f, 0.01692650f, 
    -0.03501161f, 0.18721348f, 0.00991781f, -0.07950498f, 0.04116577f, 0.35644904f, -0.04375561f, 0.00264627f, 
    0.12377935f, -0.02924413f, 0.06178548f, 0.13573076f, -0.36607736f, -0.12564391f, -0.66700172f, -0.07038907f, 
    -0.12750049f, 0.19444120f, -0.18455476f, -0.21350141f, -0.24667805f, 0.04238446f, 0.11183996f, 0.03028612f, 
    0.15409169f, 0.03026004f, -0.02294802f, -0.05272300f, 0.05169275f, 0.30431813f, -0.12378589f, 0.00240312f, 
    -0.42633176f, -0.26714176f, -0.27140400f, -0.00103223f, 0.01232370f, 0.32272655f, -0.01014148f, 0.03493144f, 
    -0.12250885f, -0.00699927f, 0.06099885f, 0.14551623f, -0.13372818f, 0.18245354f, 0.37540793f, 0.18053484f, 
    0.15390293f, -0.20544183f, -0.23122750f, 0.23133303f, -0.01382171f, 0.05516098f, -0.10074379f, -0.29112145f, 
    -0.04531788f, 0.17311212f, -0.10077784f, -0.09469141f, 0.06573716f, 0.03944951f, -0.07246039f, 0.19909146f, 
    0.08976600f, 0.08993528f, 0.12405531f, -0.12115587f, 0.05046120f, -0.14550108f, 0.01663297f, 0.00370390f, 
    -0.10285749f, -0.33186665f, -0.81353873f, 0.26681998f, 0.30500004f, -0.02666764f, 0.07336967f, 0.01283416f, 
    -0.01050222f, 0.08342523f, 0.06131197f, 0.12399391f, -0.12705877f, -0.09449851f, 0.14695495f, -0.08117434f, 
    -0.15613292f, 0.02364036f, -0.10557063f, -0.04306969f, -0.04491897f, 0.13377604f, 0.10333650f, -0.11608046f, 
    -0.01622577f, 0.12203946f, 0.12503687f, 0.13911188f, 0.02049386f, 0.16365083f, -0.04456879f, -0.12205729f, 
    -0.13670191f, 0.03015015f, -0.04512683f, -0.06760101f, 0.08807880f, -0.12476958f, 0.03007346f, -0.01131476f, 
    -0.03266165f, -0.42730063f, 0.27496463f, 0.04654915f, -0.31383392f, 0.13762029f, -0.07378122f, 0.24892165f, 
    0.15217608f, 0.07529632f, 0.01360079f, -0.06058572f, 0.00398432f, -0.06006780f, 0.09609161f, -0.19187601f, 
    -0.05134614f, 0.15003994f, 0.04062895f, -0.00147090f, -0.34739020f, 0.20476304f, -0.08172216f, -0.17063157f, 
    -0.23597208f, 0.01070270f, -0.10498862f, 0.06539854f, -0.10364315f, -0.04014448f, -0.02450388f, 0.07960339f, 
    -0.08697142f, 0.03907569f, 0.05407889f, -0.19548967f, 0.07794404f, 0.17743027f, -0.03853817f, 0.09598350f, 
    -0.23867542f, -0.29130092f, -0.44159162f, -0.24232250f, 0.28739828f, 0.08068062f, 0.06345250f, 0.13721105f, 
    -0.28712624f, 0.07341611f, 0.01543571f, 0.04252472f, 0.10977910f, -0.05329013f, 0.16619836f, 0.25747097f, 
    -0.07397817f, -0.01495010f, -0.10870855f, -0.11952358f, 0.17930947f, 0.27422553f, 0.61657232f, 0.37420219f, 
    0.04281024f, 0.06496792f, 0.41424364f, 0.12863490f, 0.22968706f, 0.26444453f, 0.05244901f, -0.03755819f, 
    -0.11371598f, 0.03759443f, -0.07073829f, -0.01528783f, 0.13148710f, -0.14617415f, 0.12322566f, 0.01315082f, 
    0.03318738f, 0.23030546f, 0.19804636f, 0.10095051f, -0.13193458f, 0.03929688f, 0.10894053f, -0.13548267f, 
    0.00254173f, 0.06423561f, 0.09877396f, 0.05791033f, -0.07266836f, 0.13288502f, 0.05797978f, 0.13171020f, 
    0.04133803f, 0.05252515f, 0.09325162f, 0.13396223f, -0.47456849f, -0.34698960f, 0.07240102f, -0.10670990f, 
    -0.47834408f, 0.02268039f, -0.05575416f, 0.11240347f, -0.17275430f, 0.00726523f, 0.10543223f, -0.01041863f, 
    -0.24629238f, 0.02167954f, 0.06006725f, -0.05387190f, -0.04492117f, -0.05070621f, 0.19146378f, 0.23296835f, 
    0.15725750f, 0.42926040f, -0.55796826f, -0.21416521f, 0.15681656f, -0.08555322f, -0.05221505f, -0.02641367f, 
    -0.01884576f, 0.07953739f, -0.10575135f, 0.09346108f, -0.01360083f, -0.00409685f, 0.07364070f, -0.28078544f, 
    0.03084916f, 0.09026597f, -0.12299074f, -0.22328170f, 0.19216102f, 0.02119010f, -0.02209678f, 0.01703824f, 
    -0.22888206f, -0.17155063f, -0.04664120f, -0.23572181f, 0.08944102f, 0.24857779f, 0.20172836f, 0.04191626f, 
    -0.01670336f, -0.08700994f, 0.01988631f, 0.04499145f, -0.05655314f, -0.04642884f, 0.12903465f, 0.09924565f, 
    0.11852258f, -0.23539105f, -0.41391590f, -0.11465289f, 0.03531076f, 0.18284690f, -0.08119665f, -0.05402136f, 
    -0.19454117f, 0.15886594f, 0.05080725f, 0.03221997f, 0.05326046f, 0.08622892f, 0.06395289f, 0.12350789f, 
    0.02544850f, 0.13618685f, -0.05486770f, 0.07584718f, 0.25778699f, 0.54429197f, 0.62327254f, 0.13549682f, 
    0.13887680f, 0.20922762f, 0.13741332f, 0.32388374f, 0.10162570f, 0.24081579f, -0.01814729f, -0.09766723f, 
    -0.06423180f, -0.11454971f, -0.08090157f, -0.00391008f, -0.04068104f, -0.01927362f, -0.12008543f, 0.12758569f, 
    0.23747909f, 0.24567580f, 0.23002012f, -0.21820872f, -0.24774902f, -0.00258009f, 0.11269432f, 0.06520144f, 
    0.04997173f, 0.17565309f, -0.03565989f, 0.04706441f, 0.07090621f, -0.14720902f, 0.11243127f, 0.11105686f, 
    -0.15289129f, -0.00951056f, 0.07553837f, 0.04539027f, 0.58238477f, -0.14773028f, -0.07787864f, 0.06997628f, 
    0.03329886f, -0.15502660f, -0.08180792f, 0.05852944f, -0.01075467f, -0.20101623f, 0.04705353f, 0.07518154f, 
    0.01917747f, 0.04190283f, -0.07989951f, 0.09507386f, -0.04461777f, 0.07126454f, 0.17850959f, -0.00673338f, 
    -0.05495401f, -0.08245632f, 0.02768887f, -0.19154151f, 0.08505720f, -0.18037803f, -0.01338775f, 0.05658080f, 
    -0.04527730f, -0.17789927f, -0.06019153f, -0.11005608f, 0.12463395f, -0.06026902f, -0.18441904f, 0.15050048f, 
    -0.10825045f, 0.19368269f, 0.19710934f, 0.00748803f, 0.58164048f, 0.24668378f, 0.00586411f, 0.37329561f, 
    -0.56402409f, 0.16564047f, -0.30456999f, 0.18243989f, 0.04144132f, 0.06633954f, 0.03910724f, 0.08063430f, 
    -0.04938612f, -0.08349537f, 0.07377910f, 0.10062817f, -0.16549960f, 0.09963289f, 0.08445662f, 0.17195879f, 
    -0.13406783f, -0.06923364f, -0.15202415f, -0.17861734f, -0.12180472f, -0.20138133f, -0.13163044f, -0.17731121f, 
    -0.13952582f, -0.04224679f, -0.05663447f, -0.08140835f, -0.01797114f, 0.14277408f, -0.13201773f, 0.09755947f, 
    -0.06592985f, -0.00714939f, 0.09335845f, -0.03603194f, 0.25255877f, 0.26010263f, 0.26890656f, 0.10421775f, 
    -0.23563571f, 0.19152495f, 0.09369556f, 0.09169322f, 0.28400940f, 0.14732449f, 0.09898134f, -0.03784632f, 
    0.01427820f, -0.23307736f, -0.02116122f, -0.03110649f, -0.05840569f, 0.00352071f, -0.01917770f, 0.04746374f, 
    0.00832413f, 0.03874255f, -0.04068131f, 0.08938504f, 0.19248620f, 0.03560480f, 0.07164274f, -0.08920913f, 
    0.14624521f, 0.00039698f, 0.04048540f, 0.03772338f, -0.10156428f, -0.07046208f, 0.00037514f, 0.10835376f, 
    0.02738059f, 0.03612006f, -0.11242043f, 0.07549759f, 0.19458018f, -0.03807789f, -0.00974467f, 0.05952831f, 
    0.05702063f, -0.11360477f, 0.12373725f, -0.26243061f, 0.15756141f, -0.18749687f, 0.09612761f, -0.02834166f, 
    0.09953440f, 0.16402900f, 0.26541936f, 0.10317419f, -0.03461077f, -0.07096010f, 0.10324626f, -0.10890662f, 
    -0.07732584f, -0.03184710f, -0.03408666f, -0.10933242f, -0.04939299f, -0.13858785f, -0.07899794f, -0.27298954f, 
    0.10698635f, -0.04062572f, 0.07328459f, 0.06523103f, -0.10237958f, 0.10229070f, -0.05908782f, 0.10851092f, 
    0.00628083f, 0.02435205f, 0.09188318f, 0.19292498f, -0.07415727f, 0.20948146f, -0.01576748f, -0.11622064f, 
    -0.25269464f, 0.23812541f, -0.04040423f, -0.05819892f, 0.08470277f, 0.10822271f, -0.07949163f, 0.01147092f, 
    0.01792711f, -0.05635315f, -0.05046156f, -0.03254516f, -0.08277349f, 0.15115981f, -0.10868953f, -0.09854249f, 
    -0.08150470f, -0.30489409f, -0.15547313f, -0.31714967f, -0.12647726f, -0.06527891f, 0.06686707f, -0.03467840f, 
    0.02225757f, -0.25734541f, 0.01795143f, -0.06115678f, 0.18948855f, 0.05612349f, 0.10196588f, -0.08746710f, 
    0.04540870f, 0.00702860f, 0.03453329f, -0.01699798f, 0.20066930f, 0.15319775f, 0.14997596f, 0.25540382f, 
    0.48744765f, -0.12794557f, 0.12771742f, -0.23143055f, 0.33612621f, -0.05451525f, 0.02009943f, 0.02526346f, 
    0.19304776f, 0.04388061f, 0.13213721f, 0.16220780f, 0.15151089f, 0.15286301f, -0.04596762f, -0.08759254f, 
    0.37463745f, 0.14193942f, 0.22848924f, 0.15761352f, -0.45737681f, 0.05830617f, -0.09022546f, 0.13712522f, 
    -0.16107924f, -0.12092738f, 0.05964058f, -0.04057707f, -0.06018907f, 0.07703342f, 0.06318881f, 0.18933359f, 
    -0.01678278f, 0.00350012f, 0.02080995f, 0.02439431f, -0.51064736f, 0.02274135f, 0.11040662f, 0.15285183f, 
    0.10420423f, -0.02553692f, -0.11842585f, 0.10104098f, -0.24405038f, -0.18084390f, -0.12110963f, 0.10672025f, 
    -0.09254705f, 0.08513377f, 0.01807456f, -0.02377893f, -0.05963550f, 0.24234496f, 0.06665055f, 0.04647127f, 
    0.19888377f, -0.07680754f, 0.16540515f, -0.12300100f, -0.14807266f, -0.14597042f, -0.09351905f, -0.12158950f, 
    0.02937353f, -0.33537194f, -0.03044837f, 0.13111451f, 0.05410573f, 0.12332469f, 0.09193648f, -0.08426629f, 
    -0.00658483f, 0.02956026f, -0.00700270f, 0.08829543f, -0.05467808f, 0.11655332f, -0.15025425f, -0.12190411f, 
    -0.35040712f, 0.02121897f, -0.04737470f, -0.08300441f, 0.18101527f, -0.01873471f, -0.11040591f, -0.17850988f, 
    0.00012756f, 0.03653625f, -0.07022795f, 0.01491042f, 0.08425054f, 0.00385798f, 0.03843508f, 0.02609975f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.05635103f, 0.04109280f, 0.02800621f, -0.08342148f, 0.20484087f, 0.12523785f, -0.06648057f, 0.00968498f, 
    -0.01901193f, 0.18811625f, 0.13982382f, 0.02143519f, 0.09124296f, 0.20125243f, -0.00785629f, 0.05989796f, 
    0.02611632f, 0.10343325f, -0.04071485f, 0.15556431f, -0.11065157f, 0.17120458f, 0.00960279f, -0.07444718f, 
    -0.01864005f, 0.13151588f, -0.01004427f, 0.04131234f, 0.07447063f, 0.17276451f, 0.07138776f, 0.11833502f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.06551921f, -0.14281815f, 0.07390230f, 0.10458401f, -0.41680828f, -0.54467064f, 0.07865785f, -0.18226989f, 
    0.30305505f, -0.59308547f, -0.35666373f, -0.08572946f, -0.29462361f, 0.15740593f, 0.05504351f, 0.07040703f, 
    0.09528124f, 0.22619183f, -0.16654246f, -0.00077757f, 0.52862489f, -0.30185395f, 0.06554668f, -0.05555643f, 
    0.12379204f, -0.40973529f, 0.19759671f, 0.10186954f, 0.11782262f, -0.69347298f, 0.11246414f, 0.26549998f, 
    0.17303431f, 0.07382584f, -0.13569716f, -0.02523579f, 0.02513002f, -0.01581287f, -0.05657673f, -0.09976121f, 
    0.09050182f, -0.08365247f, 0.36621937f, -0.14955778f, -0.70879257f, 0.21274917f, -0.14059663f, 0.20008938f, 
    0.14093371f, 0.24084316f, 0.00517901f, 0.34045056f, -0.73319840f, 0.17674761f, -0.53457236f, -0.62278253f, 
    -0.14338358f, -0.01365830f, -0.86450034f, -0.07429015f, 0.50164843f, -0.19388251f, -0.22279963f, 0.42949882f, 
    0.17904022f, -0.09421071f, -0.05806254f, 0.25380772f, -0.04814269f, -0.02000878f, -0.11225309f, 0.23887062f, 
    0.18321612f, 0.58347344f, -0.38009158f, 0.09572093f, 0.25696546f, -0.19338058f, 0.06515997f, -0.29780719f, 
    -0.15974338f, -0.21959010f, -0.14302963f, -0.56117445f, -0.98581302f, 0.14765753f, -0.35012701f, 0.26841542f, 
    -0.05677613f, 0.05061776f, 0.49200034f, -0.36608082f, -0.03759246f, 0.11148785f, -0.67959338f, 0.27067959f, 
    -0.19103026f, -0.32453269f, 0.16048819f, 0.17029759f, -0.25918049f, -0.22095042f, 0.09637326f, 0.35366482f, 
    -0.02987132f, 0.33043960f, -0.02907187f, -0.00065384f, 0.16551168f, -0.56423748f, -0.05484978f, 0.36195779f, 
    -0.05838214f, -0.22107536f, -0.13285592f, -0.04193323f, 0.17820485f, -0.49764314f, -0.19221866f, 0.46453518f, 
    0.16814940f, -0.46314502f, 0.00523662f, -0.46200284f, -0.75441968f, 0.28729337f, 0.11387683f, -0.22527675f, 
    -0.52134138f, -0.23499122f, 0.01438675f, 0.30580917f, -0.30200481f, 0.22277988f, 0.12077569f, -0.06595153f, 
    -0.12034968f, -0.20458622f, -0.05999556f, 0.09581171f, -0.58019191f, -0.19041058f, 0.12104481f, -0.16133574f, 
    0.25049475f, -0.05972115f, 0.05015492f, -0.85516500f, -0.00963461f, 0.19195873f, -0.02302530f, -0.06679651f, 
    -0.09904187f, 0.36810520f, 0.44133511f, 0.13337994f, 0.31090158f, -0.01939613f, 0.27173498f, -0.72129929f, 
    0.06297205f, -0.35026166f, -0.16281678f, -0.22121009f, 0.02811055f, -0.26031572f, 0.02433445f, -0.35147381f, 
    -0.20353080f, 0.04998831f, -0.26239651f, -0.16695540f, -0.14213111f, 0.26769912f, 0.03942766f, -0.19545576f, 
    -0.21154962f, 0.36405480f, -0.07456102f, -0.34201175f, -0.34291703f, 0.36610502f, 0.46892324f, 0.04084750f, 
    0.09764791f, 0.00060342f, -0.19485752f, 0.06654432f, -0.40994969f, 0.32188597f, 0.42596710f, -0.01707465f, 
    0.40038458f, 0.41266093f, 0.15857677f, -0.61739403f, -0.15046082f, 0.33389971f, -0.02158158f, 0.32331109f, 
    -0.39348069f, -0.28246158f, -0.04996726f, -0.00224202f, 0.14243284f, 0.00193555f, 0.01368876f, -0.66521156f, 
    -0.25582534f, -0.62039274f, 0.15326230f, 0.36455902f, -0.41470093f, 0.12650631f, -0.05789665f, -0.33921328f, 
    -0.04154852f, 0.30396649f, 0.48416764f, -0.12136661f, -0.29612288f, 0.21208504f, -0.45590353f, -0.42763332f, 
    0.07212964f, 0.09898753f, -0.02203385f, -0.39728549f, -0.47010079f, 0.14709909f, 0.16101059f, -0.58552521f, 
    -0.46847981f, 0.25121742f, -0.16606657f, -0.03234849f, 0.27438059f, -0.35527593f, -0.17559771f, 0.06445387f, 
    0.36153862f, -0.07335582f, 0.05308274f, 0.06695338f, 0.57962829f, 0.19143744f, -0.03801275f, 0.22366872f, 
    0.10563324f, -0.14541985f, 0.21186933f, 0.19728611f, -0.03129424f, -0.31860447f, -0.54855150f, 0.19763322f, 
    0.16288322f, 0.52094746f, -0.05581411f, -0.61862087f, 0.40093657f, -0.17703396f, 0.16302672f, -0.13840340f, 
    -0.08626157f, 0.49113974f, -0.46329817f, -0.13330184f, -0.04797199f, 0.33460671f, 0.03683184f, 0.39721298f, 
    -0.47521716f, 0.12478592f, 0.10504244f, -0.32307714f, 0.18045418f, -0.13776475f, 0.29693127f, -0.16011925f, 
    0.16451369f, -0.51287103f, -0.43882030f, 0.07390298f, -0.43164638f, -0.03747035f, -0.62444973f, -0.38452569f, 
    0.26587027f, -0.45554125f, -0.10981152f, 0.50011843f, 0.34693000f, 0.14440301f, -0.11488567f, -0.10547928f, 
    -0.12030096f, -0.52612138f, -0.09252679f, 0.05936718f, -0.05485609f, -0.04860917f, 0.04661859f, -0.64744723f, 
    -0.26935601f, -0.46301973f, 0.06932731f, 0.20772554f, 0.27091998f, -0.06950467f, -0.33030918f, 0.15196854f, 
    -0.00106979f, 0.41110212f, -0.24477908f, 0.26109737f, 0.21018016f, 0.01072429f, -0.16353206f, 0.24250782f, 
    -0.58697015f, -0.31788519f, 0.05941842f, -0.39682776f, 0.00320963f, 0.52089691f, -0.03821298f, 0.43171275f, 
    -0.27295756f, 0.44787297f, 0.32508445f, 0.04884897f, 0.35940468f, 0.11383554f, -0.03567062f, -0.18616170f, 
    0.23122354f, 0.20845017f, -0.00147752f, -0.23167928f, -0.01064451f, -0.65120888f, -0.36280802f, -0.79461730f, 
    -0.02800743f, -0.42958957f, -0.71201098f, 0.17730995f, -0.46659699f, 0.00724857f, 0.04255583f, -0.03189410f, 
    -0.59606004f, -0.04515592f, -0.00785115f, -0.76593995f, 0.03160192f, -0.05664146f, 0.03107476f, 0.11372370f, 
    0.03557280f, -0.47343281f, 0.34057131f, -0.06568407f, 0.11225640f, 0.18491624f, 0.14121075f, 0.00182723f, 
    -0.26134673f, 0.23579165f, 0.04784318f, 0.22758885f, -0.07588170f, -0.41438794f, 0.46983078f, 0.30167961f, 
    0.08791242f, 0.23978166f, -0.41950867f, -0.69918621f, 0.47628558f, 0.17386276f, -0.42665601f, -0.15026912f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12393785f, -0.06190348f, 0.01071706f, -0.02165580f, 0.14212121f, 0.00844842f, 0.12121125f, -0.03534882f, 
    0.05822612f, -0.13568787f, -0.12730491f, 0.04401391f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
