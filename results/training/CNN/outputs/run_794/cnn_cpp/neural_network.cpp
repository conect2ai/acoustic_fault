#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.19030905f, -0.17999427f, 0.05242566f, -1.02395034f, 0.35876018f, -1.23861420f, 0.53749549f, 0.45726591f, 
    -0.05340720f, -0.97656137f, -0.69426310f, 0.50270289f, -1.01501870f, -0.37590396f, 0.17048611f, 0.62883711f, 
    0.72307473f, -0.16450168f, 0.68271482f, 1.10181487f, 0.93442893f, -0.63185257f, 0.04467804f, -0.79112971f, 
    -0.27947199f, -0.57504517f, -0.34290761f, -0.28032017f, 0.32543695f, 0.60572076f, 1.28652918f, 1.17411435f, 
    -0.99205363f, 0.24724755f, -0.01797294f, -0.41031709f, -1.12133145f, -0.88846064f, -0.87441283f, 0.38694367f, 
    1.01647460f, -0.30054376f, 0.55332458f, -0.00188266f, 0.21977492f, -0.81877673f, -0.52243263f, 0.32339907f, 
    0.48932242f, 1.27179945f, 0.58395487f, -0.46307233f, -0.29929754f, -0.48602122f, -0.62265497f, -0.50710225f, 
    0.23312102f, -1.36059022f, 1.09130645f, -0.94235373f, -0.35713911f, -0.04389009f, 0.39353237f, -0.03958011f, 
    -1.11111832f, -0.67542952f, 1.26881278f, 0.81350988f, 0.66416723f, -0.32944015f, 0.05041342f, 0.02113612f, 
    0.79987514f, 0.43662342f, 1.12585914f, 0.65170705f, -0.72225016f, 0.46296793f, 0.36804605f, 0.51843965f, 
    0.44150257f, -0.62225819f, -0.67802793f, -1.13983214f, 0.25761968f, -0.41223934f, 0.32014102f, -0.74457526f, 
    0.11825290f, -0.04015835f, -1.32760179f, -0.81905776f, -0.45868000f, 0.23406331f, 1.00773084f, 1.13356316f, 
    0.64435649f, -0.39733559f, 0.36385539f, 0.99896234f, -0.57329684f, 0.82539368f, 1.17526913f, 0.31661150f, 
    -0.21471077f, -0.19168286f, -0.27338335f, 0.15973546f, 0.86526597f, 0.66394126f, -0.66938674f, -1.29980445f, 
    -0.97835553f, 0.87788320f, -0.14748482f, 0.09749936f, 0.12298121f, 0.11648675f, 0.69520569f, 1.46448874f, 
    -0.40578908f, -0.95311594f, -0.01157640f, 0.09733369f, -0.69506603f, 0.40556490f, 0.64703101f, 0.61007375f, 
    0.52243453f, 0.59920102f, 0.21401343f, 0.52012885f, -0.47831061f, -1.08830559f, -0.55354494f, 1.01734746f, 
    0.88665813f, 0.01754613f, 0.48114482f, 0.89054567f, 0.81839585f, -0.42556727f, 0.35200924f, 0.16464494f, 
    0.70070279f, 1.02674949f, 0.89916557f, 0.77652597f, 0.01915365f, -0.49348599f, 0.75391942f, -0.47302529f, 
    0.37862682f, 1.21928585f, -1.19164860f, -1.08386505f, 0.04143730f, -1.07474160f, -0.08461892f, 0.13010763f, 
    0.20944779f, 0.16809919f, 0.02310023f, 1.19062245f, -1.00554299f, 0.09872090f, 1.06874275f, 0.39424413f, 
    0.88975996f, -0.55610788f, 0.15800755f, -0.64495021f, 1.15867436f, -0.37990877f, 0.19915819f, -0.62525201f, 
    -0.26273215f, 0.90608805f, 0.40878901f, 0.37183809f, 1.26241338f, -1.19382417f, -0.13168377f, 1.13482666f, 
    -0.25518596f, -0.01859538f, -0.08886769f, 0.25106022f, -0.56431353f, 0.13602667f, -0.77792960f, -0.32877216f, 
    0.06469666f, 0.11819118f, 1.23907483f, -0.58873403f, -0.53097200f, -0.97083765f, 0.57848501f, 1.22424042f, 
    -1.17300057f, 0.27089626f, -0.09210280f, -0.34205055f, 0.52981496f, 0.13391565f, 0.16876398f, -0.86952633f, 
    0.06585331f, -0.66661680f, 0.01870920f, 1.07285511f, -0.06929192f, -0.20544358f, -0.12790699f, -0.88951457f, 
    -0.07538538f, 0.44097939f, -0.65721840f, -0.71219873f, -0.96069318f, -1.16670024f, -0.54912186f, -0.03158434f, 
    0.50150448f, 0.98507673f, 0.84747660f, 1.16156256f, 0.25177374f, 0.45435965f, 0.08625660f, -0.14559720f, 
    0.66318983f, -0.11129998f, -0.43492818f, -1.24196458f, 0.59827083f, 0.27102637f, 0.55924171f, -0.80468887f, 
    0.03124163f, -0.31507292f, -0.71089083f, -0.89992595f, 1.13665295f, -0.49566236f, 0.26916081f, -0.45915577f, 
    -1.02788246f, -0.33415759f, 0.15786700f, -0.48945940f, -0.92211592f, -1.06229055f, -0.81217140f, 0.54594237f, 
    -0.91440660f, -0.29919985f, 0.45727128f, -0.13234350f, 0.41522112f, 0.48528975f, 0.66908491f, 0.74895060f, 
    -1.14071286f, 0.25048909f, -0.19986685f, 0.53186655f, 0.34259444f, 0.35262999f, -0.92483234f, 0.47111478f, 
    0.86908436f, -0.18338284f, -0.58447224f, -1.06401098f, 0.05516101f, 0.19690594f, 0.02563336f, -1.33641529f, 
    1.27288377f, 0.51067185f, 0.95726663f, 0.07892378f, 0.20014083f, -0.35381752f, -0.38141203f, -0.31730747f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.23508774f, 0.10985358f, 0.38599652f, -0.34621969f, 0.12948227f, 0.01408313f, -0.15930158f, -0.19831303f, 
    -0.10475941f, -0.25557095f, 0.30754676f, 0.33214340f, -0.12609830f, -0.05395520f, -0.00733680f, 0.30571306f, 
    -0.00980098f, 0.22832461f, -0.06064340f, -0.02479465f, 0.18419339f, 0.08450338f, 0.21972494f, 0.09209529f, 
    0.28934559f, 0.51762813f, -0.32836807f, 0.06473924f, -0.09334230f, -0.13024445f, 0.29032665f, 0.20832375f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.07065062f, 0.03249332f, -0.29808447f, -0.00320569f, -0.20717752f, 0.00293195f, -0.03842963f, 0.11108903f, 
    0.02143015f, -0.29251945f, 0.02607812f, 0.02684501f, -0.08677581f, 0.09204506f, -0.00823953f, -0.01205412f, 
    0.15594779f, -0.01279287f, 0.62462425f, 0.27424890f, -0.06680503f, 0.12617895f, 0.10980283f, -0.01479420f, 
    0.06156536f, -0.07400148f, 0.10930643f, 0.00889391f, -0.40349668f, -0.10565700f, 0.07805680f, 0.05649305f, 
    -0.12702259f, -0.20897247f, 0.04837763f, -0.03421925f, -0.12372644f, 0.05660668f, -0.03764746f, 0.00977978f, 
    0.16823921f, 0.13232943f, -0.23116139f, -0.05374012f, 0.03298070f, -0.37903118f, 0.18913837f, 0.04430481f, 
    -0.03709404f, 0.04265013f, 0.13103117f, -0.37609333f, 0.01136345f, 0.12877637f, -0.32807404f, 0.10502353f, 
    -0.18016906f, -0.12749515f, 0.10490403f, -0.06439090f, -0.16237879f, -0.10725740f, -0.19268884f, -0.21491501f, 
    -0.24529067f, -0.34156325f, 0.13293350f, 0.16069520f, 0.06027757f, -0.03812533f, -0.06470539f, -0.13884701f, 
    0.10495614f, -0.09898294f, -0.03032313f, 0.13019910f, 0.03888028f, 0.14595769f, -0.05591869f, 0.10463419f, 
    -0.14485967f, 0.25632626f, 0.26237431f, -0.36257431f, -0.08678561f, -0.19449593f, -0.04101050f, 0.34551460f, 
    0.10982991f, 0.22075857f, -0.46300429f, 0.18635331f, 0.12071586f, 0.16538559f, 0.22504587f, 0.20589995f, 
    -0.09893304f, 0.10623021f, -0.06255794f, -0.51779121f, -0.31322062f, -0.01787116f, 0.01895369f, 0.10183552f, 
    0.09124127f, 0.25892285f, 0.07239272f, -0.06208051f, 0.05875711f, 0.28221360f, -0.04569058f, -0.07580628f, 
    -0.11275770f, -0.15209243f, 0.16553429f, 0.11777136f, 0.00406900f, 0.36439031f, 0.04061844f, 0.03309612f, 
    -0.00226748f, 0.08711004f, -0.17647177f, 0.04299856f, -0.14862724f, 0.06784867f, 0.04412208f, 0.08836581f, 
    0.07704008f, 0.17558284f, 0.04744089f, 0.30539003f, -0.02654895f, 0.00342048f, -0.03213055f, -0.05302665f, 
    0.06317464f, 0.05779409f, 0.16145061f, 0.09701005f, 0.07365321f, 0.05148997f, -0.07338084f, -0.01285115f, 
    0.43220720f, -0.17708388f, -0.00642156f, 0.08924226f, 0.00548185f, -0.12129167f, 0.16427465f, 0.14192726f, 
    0.06839422f, 0.14050011f, -0.17452817f, -0.45306188f, -0.00161622f, -0.24053654f, -0.14613399f, -0.00004810f, 
    0.18163650f, 0.07125198f, -0.28498283f, -0.06924552f, 0.28538427f, 0.06290755f, 0.13669983f, 0.02008835f, 
    -0.01440773f, -0.12100193f, -0.00960902f, 0.24304470f, 0.05923652f, 0.15138292f, -0.02842313f, 0.03513101f, 
    -0.02798020f, -0.00788812f, -0.00041657f, -0.23456374f, -0.27119252f, -0.58417588f, -0.26768756f, 0.13173699f, 
    -0.10065331f, -0.09101754f, -0.01937459f, 0.03071953f, -0.04429686f, 0.01237800f, -0.00456952f, -0.13724186f, 
    0.08631355f, 0.12181980f, -0.00650217f, -0.19384442f, -0.23924401f, 0.04532578f, 0.30735099f, 0.03342734f, 
    0.13636115f, 0.36697364f, -0.02369628f, -0.23666769f, -0.16101515f, 0.00073266f, 0.09280724f, -0.10911122f, 
    0.30871901f, 0.07542127f, 0.02139988f, -0.03040328f, 0.09499309f, -0.50605005f, 0.12600769f, -0.16556537f, 
    -0.09038833f, 0.11181162f, -0.17377554f, 0.17893690f, -0.07546107f, -0.21204828f, 0.05238904f, 0.06579798f, 
    0.16132581f, 0.33381960f, 0.15454867f, 0.19281831f, -0.04160760f, 0.04022263f, -0.03079507f, 0.08054392f, 
    0.13316436f, 0.08244256f, -0.32981181f, 0.08470896f, -0.09349827f, -0.12723133f, -0.21194036f, -0.13608892f, 
    -0.32892567f, 0.08252492f, -0.06567204f, 0.13510543f, 0.05114416f, 0.22325942f, -0.13593505f, 0.06583820f, 
    -0.09506705f, 0.08800873f, -0.08877373f, 0.15786518f, -0.06114983f, -0.01785773f, -0.34849963f, 0.04884664f, 
    0.00776719f, -0.08344292f, 0.22850296f, 0.02308534f, 0.03670351f, 0.46999130f, 0.15905331f, 0.17838043f, 
    0.11319543f, 0.16997661f, 0.15023224f, 0.07953288f, 0.09731442f, -0.36311403f, 0.23454608f, -0.03855737f, 
    0.10490134f, -0.18131286f, 0.08342038f, 0.00325478f, 0.15775223f, -0.07743227f, 0.22488315f, 0.06563630f, 
    0.05987377f, 0.25489596f, -0.08179933f, 0.11084893f, -0.14723139f, -0.10269301f, 0.02463840f, -0.00585379f, 
    -0.04814724f, -0.04068799f, -0.00989821f, 0.02448853f, -0.05487419f, 0.03064575f, -0.03545909f, -0.02516157f, 
    -0.02908659f, 0.02047179f, -0.01340990f, -0.06709148f, -0.01263823f, -0.00195794f, -0.00632920f, -0.04991285f, 
    0.04398599f, -0.04996643f, 0.03992264f, -0.05364387f, -0.05575125f, 0.04228617f, 0.04393988f, -0.05007721f, 
    -0.05565959f, 0.02109876f, -0.03568294f, 0.04686091f, -0.01693138f, 0.02546747f, 0.01640072f, 0.02729768f, 
    0.01154242f, -0.03615465f, -0.00197762f, -0.05360124f, -0.04475415f, -0.05249058f, 0.03183511f, -0.02470094f, 
    -0.04055823f, -0.01709232f, -0.00792089f, 0.00825247f, -0.03316265f, 0.00621188f, -0.01546571f, -0.01315112f, 
    0.03372521f, -0.06331208f, 0.03293301f, 0.03281834f, 0.01132277f, 0.00486183f, -0.02533973f, 0.02370161f, 
    0.03109933f, 0.00093540f, 0.02556777f, -0.05732839f, -0.01817149f, -0.03525679f, 0.04001747f, 0.03077201f, 
    0.01877940f, 0.04393728f, -0.02325580f, -0.04878562f, 0.04055645f, -0.04338657f, -0.01105381f, -0.00209699f, 
    -0.01909201f, 0.03075926f, 0.03537869f, -0.04171953f, 0.00156015f, -0.05384777f, 0.03443270f, -0.00619233f, 
    -0.02564257f, 0.05398371f, 0.04890515f, -0.03103896f, 0.03917517f, 0.01328822f, -0.01273095f, -0.02074865f, 
    -0.05052875f, 0.04697320f, -0.05693511f, 0.01547766f, 0.00272526f, -0.00708818f, 0.05097758f, -0.04618653f, 
    -0.01358323f, -0.01322773f, -0.06059151f, 0.02245483f, -0.00560690f, -0.03483506f, -0.00923997f, 0.02400701f, 
    0.01550447f, 0.01679791f, -0.01254938f, -0.02862523f, 0.04581222f, -0.00581089f, 0.01115691f, -0.04425508f, 
    0.02167406f, -0.02030591f, -0.01245523f, -0.04930825f, -0.02977909f, 0.03660986f, 0.04040488f, -0.04033995f, 
    -0.04119423f, 0.00376381f, 0.01706592f, 0.02720618f, -0.00744335f, 0.01978891f, -0.03749466f, -0.05405670f, 
    -0.01330158f, -0.06260029f, -0.04541934f, -0.05557024f, 0.03512382f, -0.02396373f, -0.01906719f, -0.02298363f, 
    -0.04750594f, 0.01853594f, 0.00777476f, -0.01373498f, -0.06228529f, -0.04140640f, 0.05119684f, 0.02520975f, 
    -0.05219745f, 0.00856240f, -0.04225440f, -0.02437600f, 0.03776037f, -0.04142712f, -0.05721603f, 0.01087299f, 
    -0.05354430f, -0.01105468f, 0.00276211f, -0.04508701f, -0.05109328f, -0.05329783f, 0.03901813f, -0.04971894f, 
    -0.05647670f, 0.03184457f, -0.06378641f, -0.05975385f, 0.02958157f, 0.04823586f, 0.02810690f, 0.04175859f, 
    0.04266081f, 0.02490089f, -0.03943498f, 0.01574531f, -0.05887622f, -0.03599757f, -0.06359689f, -0.00645661f, 
    -0.02684514f, -0.01727090f, 0.04928716f, 0.01869613f, -0.03644495f, 0.00518696f, 0.03528315f, 0.02217110f, 
    0.02082805f, 0.03243404f, 0.03542991f, -0.02896944f, -0.04138929f, -0.02902909f, -0.02694270f, -0.03929392f, 
    0.01548751f, -0.03707443f, -0.05370197f, -0.01023744f, -0.03353829f, 0.01249854f, -0.04845074f, 0.03140670f, 
    0.00720736f, 0.00190038f, -0.05179141f, 0.03264125f, 0.04615285f, 0.00087893f, -0.04534409f, -0.00677340f, 
    -0.02305894f, -0.02110503f, 0.01442951f, -0.05020866f, -0.00380601f, 0.01556209f, -0.05297777f, -0.01018259f, 
    -0.01330737f, 0.03398174f, -0.00835541f, -0.04796254f, 0.04499045f, 0.01663031f, -0.01866326f, -0.03400856f, 
    0.03217712f, -0.06551469f, -0.05538442f, -0.01615305f, -0.03708259f, 0.01049100f, -0.01168002f, 0.03862648f, 
    -0.01814842f, 0.03469940f, -0.00175201f, 0.03539214f, 0.01191499f, -0.00916166f, -0.01361834f, 0.01222543f, 
    0.04354874f, -0.06717169f, -0.01876931f, -0.03730169f, -0.02264237f, 0.04168130f, 0.00126069f, -0.03384833f, 
    -0.04703502f, -0.04131301f, -0.01214661f, 0.03421444f, 0.00159491f, -0.04598390f, -0.05105303f, -0.01629740f, 
    0.01480751f, -0.02012845f, 0.00317601f, 0.01275309f, -0.04517407f, -0.00890996f, 0.00076149f, -0.03985462f, 
    0.01670860f, -0.02827431f, 0.02696032f, 0.03130992f, 0.01425382f, 0.05383420f, 0.05007794f, -0.06337477f, 
    0.00556371f, -0.02069430f, 0.01219747f, -0.01895346f, -0.05220753f, 0.05221133f, 0.01994354f, -0.02242986f, 
    0.01324629f, -0.03595546f, -0.00178769f, -0.02018269f, -0.01350777f, 0.04426237f, 0.03540383f, -0.03356182f, 
    -0.05016010f, 0.00748106f, -0.05921447f, -0.01832125f, -0.00998032f, -0.05214931f, -0.02024884f, 0.02305097f, 
    0.01192317f, 0.05137927f, 0.00461585f, 0.02206377f, 0.02512249f, -0.00641255f, 0.04678937f, -0.01205580f, 
    -0.01536875f, -0.04383593f, 0.03996904f, -0.02686277f, 0.02435505f, 0.01009163f, 0.00826103f, -0.00063142f, 
    -0.05840632f, 0.03920427f, -0.05274112f, -0.03290167f, 0.01986393f, -0.05212662f, 0.00828446f, -0.01797293f, 
    -0.04444652f, -0.02658152f, -0.04404355f, 0.05029302f, 0.05425730f, -0.05050533f, -0.04557353f, -0.01734184f, 
    0.03205965f, 0.03438845f, 0.00441414f, -0.04699484f, -0.05460888f, 0.02926003f, -0.05342956f, 0.03652412f, 
    -0.03715070f, -0.06075575f, -0.04273803f, 0.01947023f, 0.03918374f, -0.04867384f, 0.02304083f, -0.07586808f, 
    -0.06876019f, 0.04410138f, -0.05510578f, -0.01992082f, 0.04635059f, 0.02542130f, -0.01791857f, -0.00465043f, 
    0.04559466f, -0.02837524f, -0.00599506f, 0.04941980f, 0.02046689f, 0.02582902f, 0.04315658f, 0.00950782f, 
    0.00578656f, -0.01508270f, -0.02181807f, 0.05249627f, -0.02459485f, -0.04937305f, 0.02372597f, -0.00844022f, 
    -0.00245020f, -0.03816444f, -0.07820015f, 0.03223370f, -0.01016127f, -0.03543417f, -0.03293734f, 0.00871153f, 
    0.01722084f, -0.05268393f, -0.03369912f, -0.03926415f, 0.00164377f, -0.05143336f, -0.05265123f, 0.04214540f, 
    -0.03083482f, -0.01405936f, 0.06062209f, -0.01507555f, -0.07087860f, 0.01589841f, -0.04453858f, -0.04324097f, 
    0.01201522f, -0.04972469f, 0.00150749f, 0.02771814f, 0.01438111f, 0.04185026f, 0.02091810f, -0.05809598f, 
    -0.01547231f, -0.02001846f, 0.00208013f, 0.04185148f, 0.03738056f, -0.01877638f, 0.04464754f, -0.06583291f, 
    0.04286395f, -0.06889782f, -0.07010116f, 0.04118103f, -0.03485395f, -0.01422255f, -0.02943811f, -0.07233968f, 
    -0.06739736f, 0.03663658f, 0.04394411f, -0.04029714f, -0.06626578f, 0.01484864f, -0.05654114f, -0.06610457f, 
    -0.03164194f, 0.02113027f, 0.02214489f, -0.02216992f, 0.00465200f, -0.06867896f, 0.01147372f, 0.03868369f, 
    -0.07095218f, -0.07085747f, -0.03145748f, 0.00648275f, -0.00698170f, -0.02024840f, 0.02451296f, -0.00237061f, 
    -0.01381447f, 0.03095903f, -0.04332959f, -0.00333610f, -0.01281671f, -0.04905584f, -0.04775235f, -0.01547557f, 
    -0.02465688f, -0.05099056f, -0.05471087f, 0.04032047f, 0.00875208f, 0.04410405f, -0.04557078f, 0.01768932f, 
    0.01276741f, -0.05911443f, 0.01700747f, -0.05375151f, 0.01232170f, -0.05761334f, 0.00789568f, -0.03095617f, 
    -0.01693671f, 0.01086309f, 0.00490395f, 0.05319320f, -0.02718802f, -0.00608511f, 0.04769797f, -0.05400496f, 
    -0.00385553f, -0.02493282f, -0.03727401f, -0.06600615f, 0.03462741f, -0.00044370f, 0.03002497f, 0.04465606f, 
    0.00983205f, 0.05019396f, -0.02228187f, 0.04200136f, -0.01986750f, -0.02467426f, 0.01992511f, -0.03693654f, 
    -0.02186640f, 0.00316755f, 0.03163206f, 0.00591405f, -0.01246286f, -0.04309081f, -0.00188402f, 0.01051648f, 
    0.01512266f, -0.05363868f, 0.00342124f, -0.03822833f, -0.01771745f, -0.04842636f, -0.04979099f, 0.03567931f, 
    -0.01163944f, 0.01582252f, -0.03913409f, 0.02772511f, -0.04208803f, -0.00189904f, 0.06000147f, -0.05281830f, 
    0.00765642f, 0.01141000f, -0.02119045f, 0.00189681f, 0.01050637f, 0.02687317f, -0.05244756f, 0.00230273f, 
    0.03225246f, 0.02627419f, -0.08228242f, 0.02816149f, 0.04742924f, -0.02202923f, -0.04477707f, 0.03191369f, 
    -0.06176700f, -0.05171151f, -0.05220127f, 0.03731365f, 0.02479900f, 0.00107797f, 0.04714362f, -0.03594744f, 
    0.03034548f, 0.03405767f, 0.04777849f, 0.00759096f, 0.03759031f, 0.01751639f, -0.01550040f, 0.03044468f, 
    0.03151092f, -0.00291114f, -0.04632970f, -0.03359637f, 0.02681986f, 0.01426336f, 0.05995806f, -0.04672047f, 
    0.06108697f, 0.03163270f, 0.02869545f, 0.01283581f, -0.00046348f, -0.00522586f, 0.02160817f, -0.05823021f, 
    0.02207199f, 0.04743215f, -0.05474040f, -0.03725709f, -0.03391119f, -0.06285167f, -0.01856989f, -0.07451890f, 
    -0.03406863f, 0.00603689f, 0.00134819f, -0.02270806f, 0.04347818f, 0.04121093f, -0.03420296f, -0.04410115f, 
    0.10236398f, 0.09845488f, -0.09416558f, 0.07310776f, -0.00105688f, 0.13123907f, 0.00351452f, -0.04966100f, 
    0.05231117f, 0.37329450f, -0.04703500f, -0.14510910f, 0.02774441f, -0.04763071f, 0.04735922f, -0.10412690f, 
    0.16058826f, 0.01381177f, 0.31256461f, 0.22766516f, -0.11283690f, 0.00992274f, -0.03695380f, 0.16738865f, 
    -0.10570757f, -0.14238651f, -0.05094234f, 0.32512811f, -0.57742286f, 0.00175230f, -0.09640012f, 0.17788732f, 
    0.02907222f, -0.05493001f, 0.02217730f, 0.15450476f, 0.20910123f, 0.15078005f, -0.01613875f, -0.18025352f, 
    0.04195730f, 0.04413787f, 0.14150262f, 0.07050904f, -0.21785563f, 0.17561524f, -0.29744241f, 0.00921760f, 
    0.07210837f, -0.13969666f, -0.12372267f, -0.07625926f, 0.06472848f, -0.04037192f, 0.27455330f, -0.06287407f, 
    -0.36794713f, 0.01363397f, 0.15570186f, 0.30241176f, -0.15210687f, -0.07204807f, -0.10919537f, 0.09089953f, 
    -0.33479923f, 0.10729942f, -0.40840849f, -0.06064496f, 0.06907059f, -0.08325080f, -0.08236933f, -0.11190987f, 
    -0.23004894f, 0.27737504f, 0.33145171f, -0.11598583f, 0.13814706f, 0.21934555f, -0.01994111f, 0.04088075f, 
    0.09131884f, 0.24527799f, -0.06598217f, -0.54448998f, -0.22983821f, 0.06615672f, 0.06400738f, -0.12657487f, 
    -0.11650424f, -0.12679398f, 0.21060555f, 0.07728526f, -0.00437438f, -0.05493076f, -0.03908926f, 0.08602843f, 
    0.02072347f, 0.01986163f, -0.10294216f, -0.45688337f, -0.19158502f, 0.20498765f, -0.05461207f, 0.03330096f, 
    0.09977268f, -0.00376122f, -0.04718578f, -0.05481602f, -0.14552505f, 0.40329772f, -0.12689978f, 0.08048825f, 
    -0.14638753f, 0.17797302f, -0.18048880f, 0.12942193f, 0.05817413f, 0.30147994f, 0.20534489f, 0.04968914f, 
    0.00141364f, 0.04672594f, 0.21662098f, -0.15097766f, -0.12291733f, 0.21367885f, 0.10541295f, -0.10059123f, 
    -0.03983130f, -0.10101944f, 0.02829301f, -0.13722469f, -0.03321340f, -0.03307395f, 0.07696092f, -0.23972711f, 
    0.00380880f, 0.02776657f, -0.04818486f, 0.00371432f, -0.07623217f, -0.12347619f, 0.10336437f, 0.12550999f, 
    -0.00742076f, 0.07207914f, 0.10175104f, 0.24429843f, -0.01894422f, -0.01216329f, 0.11346347f, 0.09484717f, 
    0.12942435f, -0.30146185f, -0.21665885f, -0.31729576f, 0.07486685f, 0.18440221f, 0.09871108f, 0.19695333f, 
    -0.09192620f, -0.13785692f, -0.18554521f, -0.17636129f, -0.01201909f, -0.11327498f, -0.13018778f, -0.02826868f, 
    0.12860490f, 0.10668647f, 0.12838727f, 0.16161706f, 0.07168796f, -0.18369350f, 0.02997122f, 0.11035106f, 
    0.10583189f, 0.08502065f, 0.07795712f, 0.00685446f, -0.72313559f, -0.24634743f, -0.17312871f, 0.02504092f, 
    0.16494919f, 0.18247776f, 0.05969885f, 0.06289528f, -0.03577185f, -0.02932986f, 0.08857122f, -0.01117996f, 
    -0.05409024f, -0.07788508f, -0.22997299f, -0.23898216f, 0.03121329f, -0.11515956f, 0.02989345f, -0.31362972f, 
    -0.10531947f, 0.28551140f, 0.03710947f, -0.13613260f, -0.06190061f, 0.10543530f, -0.03635078f, 0.02893203f, 
    -0.24059278f, -0.15319324f, -0.18978302f, 0.06093156f, -0.07927044f, 0.01176369f, -0.00503381f, -0.25351486f, 
    -0.02738032f, -0.14523099f, -0.02605016f, 0.17158133f, 0.12653020f, 0.05328539f, -0.19031733f, 0.01410392f, 
    -0.21299686f, -0.16548264f, 0.07888184f, 0.00417671f, 0.14500262f, 0.10676453f, 0.04331177f, -0.03499784f, 
    0.05212379f, 0.09152937f, 0.36182940f, -0.01452122f, 0.13554196f, -0.03837255f, 0.10079815f, 0.09342951f, 
    -0.06325972f, -0.02530989f, 0.05710983f, 0.04855326f, -0.33982611f, 0.09718379f, -0.13558863f, 0.13939127f, 
    0.13968864f, 0.07392233f, -0.09105183f, -0.22334705f, -0.02010585f, 0.26438791f, -0.15605243f, -0.22818881f, 
    0.05839558f, -0.15819013f, 0.16459368f, 0.17892869f, -0.17941302f, 0.40467116f, 0.30810320f, -0.09860487f, 
    0.05114319f, 0.03202045f, -0.03969401f, 0.25469777f, 0.12191631f, -0.03420595f, 0.42526531f, -0.11541847f, 
    0.05264305f, 0.10300390f, 0.08973191f, 0.28214404f, 0.06069307f, 0.12401421f, -0.04468285f, 0.20274864f, 
    -0.05289693f, -0.05844201f, -0.03488073f, -0.14798203f, -0.17456345f, -0.01033744f, 0.07817622f, 0.05766058f, 
    0.06015403f, 0.03932367f, 0.05238141f, -0.05051625f, 0.01462622f, 0.01782190f, 0.03367089f, -0.04972532f, 
    -0.00429918f, 0.02839544f, -0.00532275f, -0.01462888f, -0.05101881f, 0.02996332f, -0.01758162f, 0.02500074f, 
    0.01015195f, 0.05055791f, -0.01663141f, -0.05356012f, -0.03039661f, -0.01653925f, 0.03674297f, 0.03440597f, 
    0.01298305f, 0.04414511f, 0.05492992f, -0.02420720f, 0.03746016f, -0.03126518f, 0.01295493f, -0.05995449f, 
    -0.01638295f, 0.05054048f, 0.03844452f, -0.03445445f, -0.02425036f, -0.05853952f, -0.05486061f, -0.06256955f, 
    -0.02146614f, -0.05641198f, -0.03731883f, 0.02864378f, -0.01765071f, 0.03097103f, 0.02269535f, -0.01504519f, 
    -0.05756617f, 0.03391431f, 0.00934072f, 0.05082274f, -0.05421747f, 0.02539392f, -0.02163620f, 0.02949768f, 
    0.04993093f, 0.00712729f, 0.03998706f, -0.04512390f, 0.03340706f, -0.01909222f, -0.03875171f, -0.03695429f, 
    -0.05298851f, -0.00209845f, 0.01598980f, 0.03484992f, -0.01143946f, 0.02597247f, 0.02828977f, 0.02194599f, 
    0.01026317f, -0.05021368f, -0.03137220f, 0.01226399f, 0.01910440f, -0.04526126f, -0.03058390f, 0.05077165f, 
    -0.05233649f, -0.00142157f, -0.01013840f, 0.01921879f, 0.01820681f, -0.01377223f, -0.04909807f, 0.01926388f, 
    0.00515338f, -0.01129808f, -0.06589112f, 0.02348686f, 0.01185116f, 0.03851903f, -0.02748679f, -0.01371386f, 
    0.03770181f, 0.01740491f, -0.00592066f, -0.02074179f, -0.04038763f, 0.04491625f, -0.00626651f, 0.01204602f, 
    0.02275186f, 0.03052936f, -0.06111889f, -0.01094953f, 0.01391336f, -0.01282711f, -0.04925417f, -0.02138549f, 
    0.02113201f, -0.05424948f, -0.00946196f, -0.02339177f, 0.01363329f, -0.02729932f, -0.02790194f, -0.02718465f, 
    -0.04054634f, 0.04393496f, -0.01036858f, -0.03775152f, -0.01431512f, 0.04444495f, 0.03976126f, -0.05941161f, 
    -0.03102961f, -0.05236650f, -0.05141454f, 0.02243505f, 0.01593711f, 0.01399211f, -0.02728721f, -0.04684656f, 
    0.04776821f, -0.05259681f, 0.01471084f, 0.00203219f, 0.02239743f, -0.05542630f, -0.04017781f, 0.02757697f, 
    0.04748091f, 0.00093891f, -0.00682632f, 0.02922531f, 0.00267579f, -0.04077733f, -0.04999116f, -0.02204893f, 
    0.01067702f, -0.03361355f, -0.03441842f, -0.02488485f, 0.04700259f, -0.00700033f, 0.01055759f, -0.03938787f, 
    -0.02015881f, 0.01790442f, -0.05419757f, -0.05204693f, -0.00967488f, -0.05532350f, -0.05434322f, -0.04389805f, 
    -0.01547313f, -0.02287890f, -0.03993069f, -0.02438351f, -0.04515294f, 0.02762762f, 0.01597041f, 0.03345808f, 
    -0.00347782f, 0.01589499f, -0.02049239f, -0.05551218f, -0.05308406f, 0.05078492f, 0.04882977f, 0.03085518f, 
    0.03970540f, -0.04885703f, -0.00402100f, 0.01619382f, -0.02118481f, -0.03936398f, -0.04620851f, 0.05022906f, 
    -0.01454266f, -0.02073861f, -0.02613839f, -0.05059069f, 0.04556133f, -0.06154773f, -0.05855797f, -0.05544094f, 
    -0.06420765f, -0.02332851f, -0.03950118f, 0.03737759f, -0.00374038f, 0.01814779f, -0.05296796f, -0.00749382f, 
    -0.03328036f, 0.03035492f, -0.05945307f, 0.04052101f, -0.00218881f, 0.00962864f, 0.00403657f, -0.05952865f, 
    -0.04434089f, -0.05059013f, -0.00255449f, -0.01282050f, 0.02741800f, 0.00111050f, 0.00601580f, 0.01766098f, 
    -0.02791096f, -0.06590457f, 0.00286184f, -0.00418124f, 0.03525158f, -0.02296181f, 0.03484113f, 0.03648637f, 
    0.04026258f, 0.02728204f, 0.02617267f, 0.03101190f, 0.00362307f, 0.04068853f, -0.04273459f, -0.01621855f, 
    -0.04683244f, -0.01153842f, 0.01411359f, -0.04705950f, 0.00854865f, -0.01574476f, 0.00094036f, 0.04378368f, 
    -0.00169570f, 0.01990728f, -0.00535362f, 0.03760958f, 0.03737688f, -0.06321701f, 0.01654372f, -0.02553653f, 
    0.03078600f, 0.04827203f, 0.01451374f, 0.00107495f, -0.03045066f, 0.02606408f, -0.03021268f, -0.02407999f, 
    0.01757676f, -0.02297001f, -0.05883623f, -0.03133001f, 0.02685817f, -0.00307350f, 0.02611030f, -0.02714616f, 
    -0.05162126f, -0.00845166f, 0.00529579f, -0.00772364f, -0.01900527f, -0.00160767f, -0.05979921f, -0.01170674f, 
    -0.02680243f, -0.02776936f, 0.00109382f, -0.04598004f, -0.02872771f, 0.02577593f, 0.03124178f, 0.02671104f, 
    0.48085374f, -0.35386854f, -0.31454051f, 0.27866146f, 0.20700198f, -0.06122463f, -0.27712181f, -0.09194051f, 
    0.09540632f, -0.48610619f, 0.53202850f, 0.16334970f, 0.12480979f, -0.16869169f, -0.41721132f, 0.02328012f, 
    0.04953236f, 0.21872190f, -0.10458694f, -0.40180600f, -0.08704609f, 0.00362203f, 0.00353271f, 0.20960191f, 
    0.05035710f, -0.11175950f, 0.16585982f, 0.07967392f, -0.22270383f, -0.10215884f, -0.06798033f, -0.07591444f, 
    -0.14783922f, -0.04646727f, 0.09339258f, -0.03090815f, -0.38431624f, 0.31369826f, -0.01687283f, -0.06300016f, 
    -0.00999551f, -0.01719904f, 0.00859199f, 0.10831786f, 0.06718110f, -0.16979359f, -0.03620436f, 0.14516363f, 
    -0.00007809f, -0.12478840f, -0.00265778f, -0.07509303f, 0.07061305f, -0.08385611f, -0.30375433f, -0.02576591f, 
    -0.08786504f, 0.03948541f, 0.18006143f, 0.07937843f, 0.21969272f, -0.16345048f, -0.04540850f, 0.30194274f, 
    -0.04292259f, -0.06774738f, -0.05977298f, -0.00552407f, 0.00754058f, -0.31861573f, 0.01257137f, 0.01432408f, 
    0.17925431f, -0.20657036f, 0.41433790f, 0.23769704f, 0.05126994f, -0.20226012f, 0.12593031f, 0.25780252f, 
    0.06424523f, 0.19017330f, 0.21578392f, -0.27431831f, 0.24211848f, -0.06430294f, 0.01692287f, -0.17528208f, 
    -0.09407016f, 0.03653295f, -0.21013422f, 0.35431752f, 0.20022848f, -0.13286945f, -0.01339034f, 0.10282540f, 
    -0.02110896f, 0.02110272f, 0.11044122f, -0.00445670f, -0.04659677f, -0.06762412f, 0.01048128f, 0.14849243f, 
    -0.14463465f, -0.03003273f, 0.17156403f, -0.00065118f, 0.00629720f, 0.08620601f, -0.46070522f, -0.03645304f, 
    0.16699915f, -0.04367158f, 0.06152611f, -0.08402854f, 0.04330816f, -0.36845937f, -0.05593374f, 0.13333204f, 
    0.19603461f, 0.09693656f, 0.09063847f, 0.10932969f, -0.30714118f, 0.25389585f, -0.02647599f, -0.17020512f, 
    0.15792917f, 0.17342682f, -0.04923190f, -0.09847218f, 0.08552543f, 0.12876451f, 0.22166632f, -0.05353710f, 
    -0.40583786f, -0.02424273f, 0.14156225f, -0.01583906f, -0.18421450f, 0.10913439f, 0.03034084f, -0.26913947f, 
    0.40472406f, -0.51509070f, 0.37799677f, 0.23734264f, 0.03307603f, -0.32199818f, 0.08435099f, 0.08738074f, 
    0.15414205f, 0.65182871f, 0.44357583f, -0.29034346f, 0.13044177f, -0.24200512f, 0.15614393f, 0.06994447f, 
    -0.06642532f, -0.00407385f, 0.08668224f, -0.60325652f, 0.00300080f, -0.14864299f, -0.32873616f, -0.02075628f, 
    -0.06698197f, 0.19062667f, 0.23048989f, 0.23267168f, -0.03658158f, -0.29917145f, 0.16715051f, -0.24157318f, 
    -0.19704390f, -0.07004423f, 0.12493465f, 0.10938901f, 0.28898901f, 0.09552291f, 0.18309560f, -0.02968267f, 
    0.04548513f, 0.06305193f, 0.06133813f, -0.08166307f, 0.25605720f, 0.15053658f, -0.00991556f, 0.03128089f, 
    0.17442918f, -0.07756089f, 0.01580784f, 0.05618198f, 0.13010615f, -0.07783723f, 0.35497105f, 0.10548689f, 
    -0.08027480f, 0.14209586f, 0.00126928f, 0.03802319f, -0.14378384f, 0.09871811f, 0.23449759f, -0.19552714f, 
    -0.08075526f, 0.27122664f, -0.08486463f, -0.14809605f, -0.04051487f, 0.02968746f, -0.05758803f, -0.10376401f, 
    -0.01942708f, 0.20255721f, -0.19302873f, 0.07494582f, 0.00759220f, -0.02986802f, 0.00375138f, 0.02639423f, 
    0.04112309f, 0.07701154f, -0.20071255f, 0.18341738f, -0.00014166f, -0.14966264f, -0.09009363f, -0.02132764f, 
    -0.09554968f, -0.03469233f, -0.60892540f, 0.06841777f, 0.13156769f, -0.08404372f, 0.10494403f, -0.08021308f, 
    -0.11116803f, -0.07032501f, 0.36368716f, -0.05138878f, -0.03872271f, -0.21739252f, -0.09338795f, -0.05380965f, 
    -0.04914258f, 0.21070518f, -0.06737579f, 0.02775226f, -0.39940438f, 0.49306166f, -0.38085732f, 0.00606269f, 
    0.16947316f, 0.10632272f, 0.02871093f, 0.08722258f, 0.20370324f, 0.06111670f, -0.39999518f, 0.13799724f, 
    0.02011005f, 0.14931612f, -0.11171903f, 0.12800357f, 0.11834901f, 0.21820225f, -0.32395118f, 0.17433465f, 
    -0.21459918f, 0.07582115f, 0.03154287f, 0.04234237f, 0.07016224f, -0.05497986f, 0.00044772f, -0.23696446f, 
    -0.26780751f, 0.03335958f, -0.10226768f, -0.22911645f, -0.03157650f, 0.08466015f, -0.19633369f, 0.07541323f, 
    -0.00508687f, -0.21445240f, 0.01314341f, -0.12265629f, 0.00922140f, 0.02009385f, 0.06065102f, -0.08620889f, 
    0.02118030f, -0.08707557f, -0.38415596f, -0.19279115f, -0.04877415f, -0.16967426f, -0.03535621f, 0.05972153f, 
    0.01274930f, 0.08065552f, 0.18270294f, -0.22889410f, 0.09014695f, -0.03888818f, 0.19151475f, 0.22858806f, 
    0.01388939f, 0.14040940f, 0.11182175f, -0.43650559f, -0.13790417f, 0.27023473f, 0.00316694f, 0.08470079f, 
    -0.37653565f, 0.04854295f, -0.04311608f, -0.05565711f, -0.42776191f, -0.39360523f, -0.24660209f, 0.08724275f, 
    0.00713987f, 0.18338507f, -0.10784448f, -0.11414535f, -0.05463598f, 0.34048128f, 0.08224373f, -0.17800248f, 
    -0.04052671f, -0.09921555f, -0.03985899f, 0.14914224f, -0.01512294f, -0.15961812f, 0.07673620f, -0.18502659f, 
    -0.01704603f, 0.31876177f, -0.01356879f, 0.14545099f, -0.04503386f, 0.04533803f, -0.04517600f, 0.34970039f, 
    -0.35035297f, -0.05225257f, 0.12764677f, -0.02124149f, -0.17487350f, -0.06061545f, -0.08375289f, -0.13193744f, 
    -0.00808563f, 0.17696607f, 0.26009279f, -0.15236388f, -0.00735651f, 0.12963209f, 0.09359762f, -0.12961848f, 
    -0.05555134f, 0.11338366f, 0.19369169f, 0.31935808f, 0.17704654f, 0.15133528f, -0.09440481f, -0.05387887f, 
    0.19181703f, 0.10128381f, 0.15015845f, 0.05762641f, -0.35256249f, 0.09811252f, 0.06192182f, 0.09843729f, 
    0.01708782f, -0.05085417f, -0.06669889f, 0.16398244f, 0.15122326f, 0.15555131f, 0.02408761f, 0.11299220f, 
    -0.13836771f, 0.10897309f, -0.01281310f, 0.00474260f, -0.17708713f, -0.03313843f, -0.06376170f, -0.41455817f, 
    -0.11650602f, 0.01109026f, 0.08404593f, -0.10993895f, 0.07377767f, 0.05295879f, -0.02078472f, -0.18411165f, 
    0.00801862f, 0.08918658f, 0.21036020f, -0.09600230f, 0.11328871f, 0.24232370f, 0.02918412f, 0.15749049f, 
    -0.04213776f, -0.02246060f, 0.17125148f, 0.17550503f, 0.15444300f, 0.37346908f, 0.04742937f, 0.03426319f, 
    0.31687260f, -0.03558078f, 0.18474817f, -0.17556675f, -0.10227297f, 0.18124683f, 0.07020251f, -0.09189355f, 
    -0.26236153f, 0.06303125f, 0.31336415f, 0.02469701f, -0.04968339f, 0.05956897f, -0.14178811f, -0.09774096f, 
    -0.16333714f, -0.21445890f, -0.15780596f, -0.02777747f, 0.08535048f, -0.11379470f, 0.01019024f, 0.11316188f, 
    -0.09788383f, 0.12025383f, 0.36087319f, 0.13431676f, -0.07592653f, 0.00479388f, -0.21187913f, -0.29751715f, 
    -0.12061313f, 0.03846690f, -0.08568365f, -0.19457261f, -0.15973301f, 0.06234722f, 0.11079606f, 0.14142656f, 
    -0.16570111f, -0.12895450f, -0.30023018f, 0.05563335f, -0.05830283f, -0.09197576f, -0.02662705f, -0.03102939f, 
    0.03917472f, -0.03646039f, 0.13011280f, -0.23034045f, 0.08797365f, 0.13502517f, 0.12187197f, 0.13747656f, 
    -0.06634010f, -0.09179049f, -0.00894825f, 0.06409752f, 0.10248703f, -0.11966176f, -0.19890115f, -0.16021386f, 
    0.06714926f, -0.05968782f, -0.06562132f, -0.28209853f, -0.12259048f, 0.07835954f, -0.05620742f, 0.04877653f, 
    -0.18891647f, -0.40919495f, 0.04881174f, -0.00918712f, 0.05292960f, 0.27828577f, 0.02599989f, -0.12694441f, 
    -0.09249376f, -0.03560752f, -0.10501117f, -0.12875843f, -0.09984489f, 0.15020385f, -0.18975262f, 0.14773707f, 
    0.27122024f, -0.24052064f, 0.21826625f, 0.31495538f, 0.23246168f, 0.14039759f, 0.08400625f, 0.05580717f, 
    0.02527869f, 0.05909275f, -0.08615891f, -0.23083891f, -0.32643476f, 0.23228531f, -0.14585279f, -0.09276005f, 
    -0.00707527f, 0.08418056f, 0.05208353f, -0.15133575f, -0.27567467f, -0.34557700f, 0.09621238f, 0.02571486f, 
    0.00260464f, 0.12662166f, 0.10995274f, 0.01313172f, -0.10932525f, 0.16477744f, 0.19869988f, 0.31271970f, 
    0.13510145f, -0.06261030f, 0.12077185f, 0.10303201f, 0.07729043f, -0.01908272f, 0.07651576f, -0.06292517f, 
    -0.21718279f, 0.06644990f, 0.03225040f, -0.05580451f, -0.08486712f, 0.19509020f, 0.12970939f, -0.10366483f, 
    0.00385821f, 0.03372231f, 0.06304255f, -0.01458522f, -0.01407024f, 0.04659944f, 0.38235492f, -0.29145005f, 
    0.20495850f, -0.06425358f, 0.02485395f, 0.03880269f, 0.06427280f, 0.13221429f, 0.11325557f, -0.12378071f, 
    -0.31622741f, -0.39187592f, 0.30489868f, -0.21089220f, 0.07117829f, -0.07063534f, -0.01501276f, -0.26822993f, 
    -0.29018492f, -0.15555541f, -0.15921734f, 0.04242969f, 0.11662580f, -0.06646755f, -0.20122327f, -0.04997352f, 
    0.03729436f, -0.05284802f, -0.12658627f, -0.05347964f, 0.01340018f, -0.29841501f, -0.12454648f, 0.11745219f, 
    -0.04323627f, -0.14820737f, 0.02732137f, -0.25152460f, 0.03012487f, -0.09812084f, 0.11319203f, 0.05579412f, 
    0.14516045f, 0.03913707f, 0.23229873f, 0.07926206f, 0.35859552f, 0.42161313f, -0.19683468f, 0.03756798f, 
    -0.18518230f, 0.06933219f, 0.13642786f, 0.00429044f, -0.08115278f, 0.11228947f, -0.04424723f, 0.05569642f, 
    0.26732674f, 0.06878236f, 0.13181691f, -0.04310041f, -0.15358657f, 0.02139756f, -0.08590267f, 0.19562295f, 
    -0.22063348f, -0.00980962f, -0.02508261f, 0.07746243f, -0.16634156f, 0.04126410f, -0.14007333f, -0.20707862f, 
    -0.07394437f, 0.17355044f, 0.33228147f, 0.04593310f, -0.12292606f, 0.26152954f, 0.25999680f, 0.06611953f, 
    -0.14508821f, -0.11610643f, -0.08889167f, 0.01167043f, -0.14404377f, -0.07782988f, 0.11772378f, -0.08261648f, 
    0.10536133f, 0.24651401f, 0.48839188f, -0.06527077f, 0.04873268f, 0.30856013f, 0.10674545f, 0.11435480f, 
    0.21721885f, 0.06691536f, 0.17649965f, 0.14205293f, -0.04949649f, 0.06425931f, 0.19431798f, 0.04562189f, 
    0.09218317f, 0.05142190f, 0.03466723f, -0.18190995f, 0.04694596f, -0.04728098f, 0.02491805f, -0.01325689f, 
    -0.07254492f, 0.15298624f, -0.02522981f, 0.14160143f, 0.36475110f, -0.03446264f, -0.14809717f, 0.02347356f, 
    -0.12623504f, -0.07321174f, -0.03932460f, -0.07124593f, -0.00465613f, -0.28313503f, -0.24495840f, 0.14243044f, 
    -0.14200723f, -0.18139091f, 0.00983576f, 0.00589167f, -0.02550448f, -0.00000862f, -0.29451069f, 0.00448463f, 
    0.13197137f, -0.01876871f, 0.21555828f, 0.16038135f, -0.00306800f, -0.14497168f, 0.06982218f, 0.23297235f, 
    0.26941073f, 0.04630939f, -0.00229872f, 0.10289566f, -0.15574908f, -0.10087159f, 0.07471048f, 0.09661674f, 
    -0.41522735f, 0.00742870f, 0.03025832f, -0.07213953f, -0.13317619f, -0.10671160f, 0.06027953f, -0.03205352f, 
    0.14312215f, -0.16837618f, -0.02131363f, -0.09406338f, -0.03590946f, 0.03960277f, 0.03853467f, -0.05680153f, 
    -0.03868505f, -0.01740054f, -0.22400613f, 0.05208421f, 0.03598323f, 0.14983311f, 0.01598850f, -0.11734486f, 
    0.00720367f, 0.11925539f, -0.04785088f, -0.15403105f, 0.01739016f, 0.09569462f, -0.17965686f, 0.15994713f, 
    0.20214893f, 0.02238864f, -0.10685015f, -0.27204588f, -0.32436076f, -0.06987522f, 0.19001922f, -0.08946246f, 
    0.01139519f, -0.09079382f, -0.04133782f, 0.20599516f, -0.05849705f, -0.16696011f, 0.03360267f, 0.16990140f, 
    0.16912317f, 0.11264521f, -0.14421652f, 0.06931252f, 0.05857697f, 0.12029768f, -0.21215077f, 0.09520897f, 
    -0.02683010f, -0.17110251f, -0.02762733f, 0.09638245f, 0.05265768f, -0.05772624f, -0.29351580f, 0.28164101f, 
    0.00076326f, 0.21622995f, 0.20521700f, 0.05042279f, 0.02669863f, 0.13981064f, 0.02755766f, -0.03582069f, 
    0.04433206f, -0.33876714f, 0.04166285f, -0.22835861f, 0.02101403f, 0.10968145f, -0.24462944f, -0.08777917f, 
    -0.09224059f, -0.10250262f, 0.06156711f, 0.04658446f, -0.18060803f, -0.06481720f, 0.07898609f, 0.01229891f, 
    -0.14876084f, 0.19509228f, 0.61468059f, 0.22049657f, -0.01264615f, 0.06774795f, 0.00207686f, 0.28750005f, 
    -0.13757429f, 0.22952637f, -0.03497994f, -0.06783564f, 0.00758729f, 0.01150503f, -0.03796965f, -0.04361264f, 
    0.11906359f, -0.19543335f, 0.09029583f, -0.06269596f, 0.41646039f, 0.30359051f, 0.05448724f, -0.03426972f, 
    -0.00777038f, 0.03169913f, 0.19349417f, 0.00766076f, -0.01700899f, -0.35040116f, -0.15562081f, 0.11590019f, 
    -0.06659208f, 0.06572239f, 0.19069771f, 0.01169258f, -0.00048046f, 0.04547054f, -0.19478251f, 0.03813075f, 
    0.01245161f, 0.26125610f, -0.15298799f, -0.02111149f, 0.03907657f, 0.10047152f, 0.08887772f, -0.08394085f, 
    0.07127815f, 0.25307927f, 0.19670853f, 0.10719378f, 0.02709471f, -0.02219866f, 0.04066252f, 0.13932313f, 
    0.02775194f, 0.01020956f, -0.00631733f, -0.02897508f, 0.03755477f, -0.04306894f, 0.03083557f, -0.02055614f, 
    0.00230945f, -0.01149203f, 0.01066946f, 0.00536749f, 0.02115548f, -0.03425099f, 0.04030480f, -0.02545837f, 
    -0.03988996f, -0.06821522f, -0.05396966f, -0.00231753f, -0.01977950f, -0.02464486f, 0.02650895f, -0.06656002f, 
    -0.03404693f, 0.00414144f, 0.04037736f, 0.04794393f, 0.03188815f, 0.03546854f, -0.01121733f, -0.02901990f, 
    -0.01946288f, -0.00682052f, 0.03843031f, -0.00306411f, -0.02876455f, -0.01650963f, 0.03075813f, -0.03863758f, 
    -0.03613240f, 0.03394716f, 0.00448647f, -0.03737695f, 0.00734855f, -0.00966873f, 0.00865210f, -0.04935227f, 
    0.02402815f, 0.00194575f, 0.03427882f, -0.05678663f, -0.00975098f, 0.00743288f, -0.04281455f, -0.03970128f, 
    -0.05395187f, -0.02006541f, -0.05471230f, -0.05055846f, 0.01103053f, 0.04652411f, 0.04616185f, 0.04290032f, 
    -0.03746996f, 0.00103738f, 0.03403988f, -0.02874375f, 0.04378187f, 0.01155931f, 0.00719271f, 0.04874176f, 
    0.02880036f, 0.01909333f, 0.03627628f, -0.06635741f, -0.00762558f, -0.05517764f, -0.03227886f, -0.00530874f, 
    -0.05164634f, -0.00368511f, -0.05025789f, 0.00069914f, -0.06126419f, 0.02383321f, -0.04422536f, 0.01641542f, 
    -0.00489737f, 0.00473161f, -0.05251138f, 0.03200182f, 0.02125853f, -0.01580931f, 0.05201339f, -0.01386523f, 
    -0.02629206f, 0.03401463f, 0.02610531f, 0.00250727f, -0.05389013f, -0.06024124f, -0.02530152f, -0.04679988f, 
    0.00379918f, -0.04333100f, -0.01310051f, 0.00667294f, 0.01512367f, -0.00199100f, -0.05299712f, -0.04968171f, 
    0.03419852f, -0.03815986f, -0.04900206f, -0.05382363f, -0.01855867f, -0.05045903f, 0.02445164f, -0.04260106f, 
    -0.01233986f, -0.02814991f, -0.06278615f, -0.01304075f, -0.06072108f, -0.05241538f, -0.03968593f, 0.01215221f, 
    0.01309522f, 0.04820837f, 0.00808388f, 0.03771906f, -0.01859163f, 0.00790750f, -0.05736984f, 0.01949899f, 
    -0.02008375f, -0.03109515f, -0.01650563f, -0.05776650f, -0.06037711f, 0.03660830f, -0.00138332f, 0.03322581f, 
    0.01859023f, 0.02591383f, 0.02987774f, -0.05401659f, 0.04650846f, -0.04159471f, 0.00482673f, 0.00589449f, 
    -0.03005811f, -0.06915006f, -0.05665790f, -0.01273566f, -0.04663903f, 0.03964392f, 0.01005404f, -0.05594275f, 
    -0.04544190f, -0.04125622f, -0.04977737f, 0.02966156f, -0.01700681f, -0.05249586f, 0.01474954f, -0.01209917f, 
    -0.01176573f, 0.02787109f, 0.05169250f, -0.05493336f, -0.02206809f, -0.00412926f, 0.04300053f, -0.00487077f, 
    0.03146023f, -0.04086505f, 0.02901882f, -0.01553273f, -0.05368078f, 0.01737291f, -0.00813536f, 0.01378614f, 
    -0.03241077f, -0.05087862f, -0.00778301f, -0.05653420f, -0.00732069f, -0.05319107f, -0.01011629f, 0.02409033f, 
    -0.02031288f, -0.06584584f, 0.01392788f, -0.03723165f, -0.01608632f, 0.01742230f, -0.06619890f, -0.02655322f, 
    -0.04931935f, -0.03616263f, 0.01100469f, 0.03774574f, -0.00081685f, -0.01602105f, 0.02938434f, 0.00862054f, 
    -0.02889835f, 0.01904336f, 0.03521576f, -0.00252684f, 0.01149011f, 0.00322683f, -0.06005314f, -0.00594868f, 
    0.02730516f, -0.01080819f, -0.02658665f, -0.04045701f, 0.01153849f, -0.06558883f, -0.02209564f, 0.01344646f, 
    -0.04935813f, -0.03122307f, 0.04726972f, -0.02574783f, 0.02140137f, 0.03515995f, -0.05851465f, 0.02083141f, 
    0.03227620f, 0.02816766f, -0.06570953f, 0.00217150f, 0.00780475f, 0.04239318f, -0.03366142f, 0.03871778f, 
    -0.05634854f, 0.00419039f, 0.04599900f, 0.04880298f, 0.03915286f, 0.01527093f, -0.02836490f, 0.01819766f, 
    0.02586585f, -0.04744064f, 0.00565479f, 0.03709666f, 0.00784341f, 0.03551935f, -0.05713885f, 0.02699828f, 
    0.00540108f, -0.05376040f, 0.03133777f, -0.01343684f, 0.02519736f, -0.02623412f, 0.04057026f, 0.02683614f, 
    -0.04654413f, -0.05364139f, -0.02915400f, -0.01508340f, -0.00581166f, 0.01856031f, 0.02527438f, -0.03585045f, 
    0.02987030f, -0.03266054f, 0.01832887f, -0.03920312f, -0.02437785f, -0.05238198f, -0.03861805f, 0.01291947f, 
    0.04782286f, 0.02919741f, 0.00892606f, -0.03323547f, -0.01937827f, -0.05097307f, -0.04851486f, -0.06417733f, 
    -0.06514290f, 0.24742618f, -0.00341857f, -0.11407176f, -0.01210522f, 0.07000685f, -0.05258264f, -0.00463242f, 
    0.13358882f, -0.05681382f, -0.04642159f, 0.12852222f, -0.07422834f, -0.01143570f, -0.00801138f, 0.02647752f, 
    0.04208696f, -0.02880637f, -0.30889666f, -0.07144767f, 0.06792804f, 0.06174258f, 0.09232117f, 0.11327121f, 
    0.06037496f, -0.04872435f, -0.03190089f, 0.04304907f, 0.01897723f, 0.14424834f, -0.11820083f, 0.16258332f, 
    0.00053290f, 0.06100896f, 0.14964122f, -0.05167634f, -0.40166861f, 0.19659151f, 0.06291870f, -0.04651539f, 
    0.00368814f, 0.08973909f, -0.02365417f, 0.14513998f, -0.04730516f, -0.22251534f, 0.14573026f, 0.01598498f, 
    -0.15004934f, -0.28491205f, -0.03645974f, -0.04862526f, -0.04743561f, 0.09560963f, -0.52742487f, 0.30983910f, 
    0.22728017f, 0.34002230f, -0.00235665f, 0.33056757f, -0.10987002f, -0.11056789f, -0.17651780f, -0.01293754f, 
    0.01235433f, -0.37274727f, -0.21998647f, 0.01945835f, 0.05970841f, 0.06467413f, -0.00774867f, 0.12696926f, 
    -0.09812588f, 0.13524513f, -0.01490752f, 0.01343879f, -0.17599674f, -0.08136694f, 0.06315827f, 0.08157924f, 
    0.00958901f, -0.09782992f, 0.29486078f, 0.11315506f, 0.12105841f, 0.17705433f, -0.00148079f, -0.11275873f, 
    0.05823573f, -0.11909153f, -0.04639721f, 0.08355916f, -0.04616543f, 0.04072291f, -0.11710415f, 0.09413006f, 
    0.02533498f, -0.02658038f, 0.14550556f, -0.40714714f, -0.21564548f, -0.21817218f, 0.01416008f, 0.12361678f, 
    -0.07017681f, 0.08012591f, -0.03418016f, 0.00151022f, 0.16325833f, -0.38510606f, -0.03550679f, -0.16201943f, 
    -0.11498878f, 0.05693295f, -0.07056045f, -0.06845260f, -0.06088858f, 0.12998971f, -0.28436542f, 0.09363284f, 
    -0.18442723f, 0.17128028f, -0.17014843f, 0.01807211f, 0.08726711f, 0.05221216f, 0.15267186f, -0.18925540f, 
    -0.07829169f, -0.07808559f, -0.10664479f, -0.06736796f, 0.31523857f, -0.03911332f, -0.13194294f, 0.17326592f, 
    -0.14052862f, -0.06104749f, -0.24393438f, -0.02423583f, 0.07795940f, -0.18046676f, -0.03106848f, 0.19054423f, 
    -0.08278984f, 0.19546686f, 0.25261378f, -0.04147652f, -0.01063112f, 0.15747769f, 0.00409110f, 0.05869721f, 
    0.10461593f, 0.24304542f, 0.15525506f, -0.07486770f, -0.04629677f, -0.17806393f, 0.04988690f, 0.13842048f, 
    0.07389216f, 0.07047193f, -0.20974392f, 0.01412018f, -0.08310006f, 0.14602534f, -0.39251822f, -0.11255813f, 
    0.10201681f, -0.11985742f, 0.12724213f, 0.16635579f, 0.07085267f, -0.09158645f, -0.12698239f, 0.12069693f, 
    0.15416700f, 0.17287734f, -0.08892082f, 0.02776400f, -0.02152414f, -0.10924932f, -0.19625941f, -0.02991538f, 
    0.05104608f, 0.11631823f, -0.01494695f, -0.06486837f, 0.03976971f, -0.09230784f, -0.07958709f, 0.24657351f, 
    0.04898096f, 0.07012841f, -0.13604152f, 0.08353893f, -0.28437528f, 0.02595063f, -0.20479752f, -0.09141064f, 
    -0.31229600f, -0.05852283f, -0.05719871f, -0.04784815f, -0.04426136f, 0.03405180f, -0.09739254f, -0.10342312f, 
    0.33403629f, 0.14533626f, -0.03431412f, 0.00280883f, -0.01254597f, 0.04962850f, -0.04706029f, 0.19344200f, 
    0.05593838f, -0.00580158f, -0.07939155f, 0.02919477f, 0.02856893f, -0.19987413f, 0.01694213f, 0.03305759f, 
    0.01497727f, -0.31016278f, -0.01753911f, 0.22501305f, 0.07284059f, -0.00236180f, -0.10402359f, -0.03474941f, 
    0.17430338f, 0.04139816f, -0.50310802f, -0.01496957f, 0.28579348f, 0.04484670f, -0.04730737f, -0.03208990f, 
    -0.07959703f, -0.02471501f, 0.12883285f, 0.78437543f, 0.23716876f, 0.06281817f, 0.10106935f, 0.08310068f, 
    -0.08049624f, 0.04795340f, 0.10187764f, -0.15746184f, -0.21356264f, 0.08640026f, -0.16418037f, 0.00386863f, 
    0.01973144f, -0.00528743f, 0.06354504f, 0.14640447f, -0.06179602f, -0.18409747f, 0.17235222f, 0.18305250f, 
    -0.25994414f, 0.02871653f, 0.02526581f, 0.07974974f, 0.01554987f, -0.35772774f, 0.40844738f, -0.06326264f, 
    0.15848818f, -0.02143475f, 0.23273166f, -0.10356689f, 0.00995500f, -0.02835910f, 0.11023259f, 0.53836685f, 
    0.14224771f, 0.00710309f, 0.02336198f, -0.14186500f, 0.04472573f, 0.14838400f, 0.11898106f, -0.03785652f, 
    -0.18754530f, 0.27455464f, -0.25464997f, -0.38569638f, 0.20702718f, -0.30604106f, 0.24974616f, 0.25409260f, 
    0.25658008f, 0.03486918f, 0.05800235f, -0.06674194f, 0.12424641f, 0.00450457f, 0.02481178f, 0.08617482f, 
    -0.05861591f, 0.07310557f, -0.04567249f, -0.00619596f, 0.05650769f, 0.13877469f, 0.09346153f, -0.04141850f, 
    0.12664761f, 0.22550337f, 0.24749213f, -0.09378992f, -0.08122393f, -0.21198711f, 0.45402393f, -0.06236314f, 
    0.14831695f, -0.05531219f, 0.19590399f, -0.65776491f, -0.40373117f, 0.12929143f, 0.24044132f, 0.16778341f, 
    -0.03223962f, -0.03807148f, -0.12485343f, 0.17207055f, 0.18337658f, -0.01641037f, -0.05191999f, -0.04268726f, 
    0.21195994f, -0.07972318f, 0.28823641f, -0.01717934f, 0.02002301f, 0.17627954f, -0.02509219f, -0.06400842f, 
    0.21480486f, 0.05684390f, -0.06706188f, -0.09636176f, -0.04235257f, 0.13391855f, 0.21522057f, -0.18021545f, 
    0.08118299f, 0.10945219f, 0.09255989f, 0.02316524f, 0.10446422f, -0.02954502f, -0.20989165f, -0.03939836f, 
    -0.06371291f, -0.16441946f, -0.10863913f, -0.03945299f, 0.07578897f, -0.23953506f, -0.00663067f, -0.16502267f, 
    -0.30525768f, 0.04961064f, -0.22262891f, 0.38662496f, 0.17512226f, 0.15422004f, 0.10563084f, -0.22591680f, 
    -0.22029984f, 0.21948409f, -0.20520891f, -0.02857476f, 0.19361034f, 0.27728358f, 0.11287096f, -0.10294965f, 
    -0.05292482f, -0.12003901f, -0.15599483f, 0.16085778f, 0.18157153f, -0.50320625f, 0.01289452f, -0.19797501f, 
    0.29320854f, -0.12714501f, 0.25922421f, -0.47323552f, -0.02550507f, 0.04546252f, -0.34979463f, 0.10642206f, 
    0.28244582f, 0.26815307f, 0.36102453f, 0.02452608f, -0.39048094f, 0.07055020f, -0.13210870f, -0.01936794f, 
    0.10736775f, -0.16632585f, 0.03059445f, 0.24863915f, 0.06038074f, 0.03265760f, 0.15225115f, -0.01117579f, 
    -0.35095286f, -0.02274523f, -0.09185626f, 0.27617306f, 0.18215238f, 0.07396395f, -0.51640004f, -0.25544766f, 
    0.10063203f, -0.03699792f, 0.18545160f, 0.24508853f, 0.12141147f, -0.03809768f, 0.02196405f, -0.50746697f, 
    -0.26015908f, -0.22106299f, 0.11997917f, 0.12523393f, -0.07302333f, 0.14902443f, -0.28225160f, -0.12461332f, 
    -0.11716380f, 0.14594537f, 0.31673610f, -0.00316981f, -0.25585485f, -0.19373031f, 0.13295183f, 0.07102440f, 
    0.03128186f, 0.16408175f, -0.25223586f, 0.16266415f, 0.10221218f, 0.10111503f, 0.26664695f, 0.17130561f, 
    -0.10858379f, 0.02192745f, -0.16583525f, 0.09018845f, 0.18742292f, -0.02908911f, -0.16744252f, -0.00458396f, 
    -0.12622099f, -0.07829649f, -0.08575059f, -0.01180335f, 0.10537171f, 0.40357009f, 0.01794383f, -0.09574442f, 
    -0.18764615f, -0.14700966f, -0.12814632f, 0.06801358f, -0.08707570f, 0.15541403f, -0.08956192f, -0.04275791f, 
    0.06596375f, 0.03914224f, 0.27090439f, -0.08383152f, -0.04973776f, 0.36141697f, 0.17264591f, 0.09303243f, 
    -0.01327859f, 0.07079805f, -0.04814598f, 0.01052200f, -0.08555779f, 0.07540858f, -0.00214903f, -0.05434386f, 
    0.25733107f, 0.02223868f, -0.02871821f, -0.02540529f, -0.02399615f, -0.01455426f, 0.23171210f, 0.38419211f, 
    0.40580788f, 0.03078718f, 0.14914313f, 0.24685130f, 0.17212717f, -0.18966153f, -0.04303435f, 0.04659873f, 
    0.25064221f, -0.12633899f, 0.14084557f, -0.10396214f, 0.15757169f, 0.08318577f, 0.20049705f, 0.01102503f, 
    0.07572342f, -0.37872639f, 0.04946898f, -0.24613762f, -0.04359963f, 0.06525122f, -0.18833192f, -0.09096316f, 
    0.10802179f, -0.11356703f, 0.12676547f, 0.36393830f, 0.32950485f, 0.20361991f, -0.24586478f, 0.02811336f, 
    0.17603448f, 0.06375306f, 0.15787064f, 0.12225775f, -0.23174086f, -0.03226510f, 0.30693734f, 0.04745413f, 
    0.14428914f, -0.17006022f, 0.11980516f, 0.14856482f, -0.00611994f, -0.17740440f, -0.01485803f, -0.11696050f, 
    -0.09437417f, 0.03131806f, -0.06669477f, -0.09560446f, -0.14212282f, -0.13130043f, 0.14519615f, 0.11050256f, 
    0.04072653f, 0.11895401f, 0.03081411f, -0.16453508f, 0.04639557f, -0.03387947f, 0.20325328f, 0.26815730f, 
    0.21194589f, -0.11999564f, -0.08326717f, 0.05709062f, 0.35738671f, -0.03404808f, -0.07396379f, -0.17954263f, 
    -0.00718442f, 0.02217186f, -0.01912522f, -0.00410558f, 0.01163610f, 0.04131284f, -0.00229775f, 0.01231409f, 
    -0.04522267f, -0.01812312f, -0.06045946f, -0.05143685f, 0.03184282f, -0.03989481f, 0.04174880f, -0.01595750f, 
    -0.02990141f, -0.02433592f, 0.01239426f, 0.03340253f, 0.03344364f, 0.01735459f, -0.06317379f, -0.02115764f, 
    0.00719672f, -0.02328932f, 0.03757735f, -0.00592139f, -0.03091248f, 0.01867392f, -0.05693940f, 0.00370785f, 
    -0.00435441f, -0.01685967f, -0.04418085f, -0.00665659f, -0.03687379f, -0.02669206f, 0.05146868f, -0.00223018f, 
    -0.02878583f, -0.02190350f, 0.04599619f, -0.03087061f, -0.05776347f, -0.05804347f, 0.03599985f, -0.02070437f, 
    -0.03236005f, 0.05061432f, 0.01945067f, -0.05353461f, 0.02806013f, -0.00820131f, -0.03844718f, 0.03112307f, 
    -0.01074115f, -0.01507181f, 0.02532170f, -0.05845101f, -0.00303483f, -0.01242201f, -0.03264868f, -0.05284261f, 
    -0.02243785f, 0.05599106f, -0.04057588f, -0.00131732f, -0.01179067f, -0.04639038f, -0.03888315f, 0.04266561f, 
    -0.02579150f, 0.04916607f, -0.01383894f, -0.03434681f, 0.04189817f, 0.02878520f, 0.03445204f, 0.02397390f, 
    -0.03176889f, -0.03039725f, 0.03069620f, 0.01433903f, 0.00684754f, 0.00621182f, 0.02973635f, 0.03771551f, 
    -0.00305382f, 0.03536506f, -0.00348253f, -0.02901482f, -0.00960400f, 0.00613607f, 0.01965141f, -0.04913196f, 
    -0.05247261f, -0.02787387f, 0.01148533f, 0.04510158f, -0.02666295f, -0.00165185f, -0.01709075f, -0.03210192f, 
    0.04235343f, -0.02483517f, 0.03608531f, -0.00398955f, -0.06389099f, 0.03399816f, -0.01584956f, 0.05344092f, 
    0.04351812f, -0.03392737f, -0.05768600f, -0.03691056f, -0.06160911f, -0.06241874f, -0.05240624f, -0.06383157f, 
    -0.02150868f, 0.00050848f, -0.01471510f, 0.05271519f, 0.01693808f, -0.04682555f, 0.04777846f, 0.02538341f, 
    0.04937635f, 0.03234461f, 0.03632664f, -0.03584965f, -0.03691031f, 0.01788010f, 0.01296726f, -0.04615531f, 
    -0.04435435f, 0.02704590f, -0.03389374f, -0.05324430f, 0.04747505f, -0.05339447f, 0.00862972f, 0.04188957f, 
    0.04283128f, 0.01132663f, -0.05381982f, 0.04005780f, -0.02636254f, -0.05286595f, 0.02416422f, 0.00438349f, 
    -0.01758816f, -0.02585215f, 0.02219582f, 0.03713121f, 0.04713801f, -0.05154995f, 0.03003067f, -0.01469713f, 
    -0.03237880f, 0.03639623f, -0.03994321f, -0.01144075f, -0.06714401f, 0.04203205f, -0.05558848f, 0.02946939f, 
    0.01260048f, -0.05913790f, -0.01128330f, 0.00977122f, -0.01646473f, -0.04075661f, 0.05158452f, -0.03160928f, 
    -0.03982834f, 0.04968652f, 0.05231513f, 0.00850376f, -0.06227288f, 0.00722349f, -0.03204001f, -0.03717447f, 
    -0.04297389f, 0.05169139f, -0.05544855f, 0.02839915f, -0.05545525f, 0.01589592f, 0.02774612f, -0.05443007f, 
    0.04051758f, -0.00325098f, -0.05082443f, 0.01601665f, -0.01032533f, -0.01491600f, -0.00901196f, 0.03457491f, 
    0.03235028f, 0.04003506f, -0.01045791f, -0.04174666f, -0.01228758f, 0.02673855f, -0.04199386f, -0.04390629f, 
    -0.02035259f, 0.01766550f, -0.05610712f, -0.04396777f, -0.03617331f, -0.03843601f, 0.02690118f, -0.03495588f, 
    -0.05718156f, 0.01197390f, 0.02890751f, -0.03200434f, 0.04485838f, -0.02473297f, -0.02359025f, 0.04243763f, 
    -0.04945674f, 0.02357843f, -0.03982996f, 0.00739722f, 0.00126676f, -0.01638179f, 0.04972453f, -0.00635457f, 
    0.01259001f, 0.05235364f, 0.02566740f, -0.03307125f, -0.00317803f, -0.04077087f, -0.02924151f, -0.01634061f, 
    -0.04156557f, 0.01051993f, 0.01622889f, 0.02568245f, 0.03036566f, -0.02295639f, -0.00739361f, -0.02920909f, 
    0.00460753f, -0.04508862f, -0.03526939f, -0.00147474f, 0.04718998f, 0.01295427f, -0.03213666f, -0.05227957f, 
    -0.04831229f, -0.01447386f, -0.01996384f, -0.05229668f, 0.01229745f, -0.01217354f, -0.02024442f, -0.00307480f, 
    0.04524373f, 0.04971323f, -0.03336172f, 0.02517793f, -0.01576113f, 0.00276126f, -0.06126411f, 0.02555555f, 
    0.01814573f, -0.02883386f, -0.03882711f, -0.03716810f, 0.03013485f, 0.02235728f, -0.01395211f, -0.03818096f, 
    -0.06334724f, -0.00037489f, -0.02555962f, 0.00994226f, 0.01947726f, 0.00800800f, -0.02436052f, -0.06361425f, 
    -0.02453923f, 0.00171612f, 0.04539206f, 0.04964509f, -0.06097018f, 0.00567203f, 0.01426369f, -0.00872047f, 
    -0.04433877f, -0.05749686f, -0.00054836f, 0.03636604f, 0.01464602f, -0.06519293f, 0.02913395f, 0.04715199f, 
    0.00126932f, -0.06205153f, -0.04676265f, 0.03873620f, -0.06002427f, -0.03913151f, 0.02273629f, -0.06299777f, 
    -0.06551319f, -0.03659537f, 0.04399169f, -0.04137757f, -0.00775011f, -0.05931996f, 0.01901628f, -0.00213571f, 
    -0.04478931f, -0.01623546f, -0.03114720f, -0.06410677f, -0.05373972f, 0.05127795f, 0.04781596f, -0.01815399f, 
    -0.05432475f, 0.05329592f, -0.05505851f, -0.02900364f, -0.05248775f, 0.04788249f, 0.03108436f, -0.05472596f, 
    -0.03357696f, 0.02869763f, 0.03551175f, 0.01150344f, 0.00092158f, -0.06601012f, 0.04062872f, 0.01302037f, 
    0.04913682f, -0.03143001f, -0.01720446f, 0.02756093f, -0.04079319f, -0.03691792f, 0.00254584f, 0.03302080f, 
    0.04547382f, 0.00287649f, 0.05444588f, -0.01985917f, -0.04285247f, -0.05471244f, 0.02725668f, -0.01111669f, 
    -0.01395150f, 0.02430697f, -0.02069357f, 0.05136037f, 0.00157759f, -0.05527722f, 0.03327585f, 0.05191247f, 
    0.01636943f, 0.00692728f, 0.02301603f, 0.04281060f, -0.00483912f, -0.04468969f, -0.05635122f, -0.00429340f, 
    -0.04256386f, -0.03538199f, 0.02515804f, 0.02033357f, -0.00749563f, 0.03913922f, 0.00115501f, -0.06194743f, 
    0.00773568f, -0.02165036f, -0.00096617f, -0.05063407f, 0.00510707f, 0.01749908f, 0.01890850f, 0.02343032f, 
    -0.04463683f, 0.03220092f, 0.03045488f, 0.03693894f, -0.00434653f, -0.00169737f, 0.03566537f, -0.02466817f, 
    -0.04793955f, -0.05170585f, -0.00783650f, -0.04204190f, 0.01998077f, 0.00447807f, -0.00226022f, -0.01337819f, 
    0.00342715f, 0.04151844f, 0.00177771f, -0.05549853f, -0.04249003f, 0.01865421f, 0.03902680f, -0.04344099f, 
    0.03832624f, 0.06343786f, -0.03941976f, -0.00451180f, 0.01556827f, -0.04603237f, 0.03570807f, -0.02665739f, 
    0.04672631f, 0.01802531f, -0.00656394f, -0.05498310f, 0.01204260f, 0.01335231f, -0.02268047f, -0.04030466f, 
    0.00610662f, -0.05672349f, -0.00660347f, -0.04146525f, 0.00220321f, -0.02633102f, -0.05706693f, 0.01868945f, 
    -0.02388718f, 0.02062110f, -0.01893104f, 0.03981081f, 0.04731049f, -0.02688817f, -0.02014641f, -0.04534283f, 
    -0.06185465f, -0.00605540f, 0.03187545f, -0.05613090f, 0.01789350f, -0.01518352f, -0.04005441f, 0.03947248f, 
    0.00143310f, -0.03683844f, -0.01957971f, 0.00035011f, 0.05168941f, -0.00866045f, 0.01128859f, 0.01598968f, 
    0.01386541f, -0.04302501f, 0.03621307f, 0.02910801f, -0.03619698f, -0.05200445f, 0.03658939f, 0.03280516f, 
    -0.03512532f, 0.01803232f, 0.04253866f, 0.01692146f, -0.02992779f, -0.00244560f, 0.02687601f, -0.04734673f, 
    -0.02086984f, -0.00659212f, -0.06333936f, -0.05774061f, -0.06220294f, 0.04696112f, 0.03153650f, 0.00461074f, 
    0.00642412f, -0.04474208f, -0.01842055f, 0.00652466f, -0.04668752f, 0.04299070f, 0.01439894f, 0.05150697f, 
    -0.02735029f, -0.04688140f, 0.04597794f, 0.02647591f, 0.00631846f, -0.04129265f, 0.02109811f, -0.02570117f, 
    0.00323887f, -0.00863007f, -0.05481723f, -0.00229492f, 0.03651031f, 0.00553106f, 0.02850176f, 0.03063801f, 
    -0.00605189f, 0.02729331f, -0.01280246f, -0.06182344f, 0.01863587f, -0.03487303f, 0.04390008f, 0.00073888f, 
    -0.03677253f, -0.02149166f, 0.00508475f, -0.01940149f, -0.04910193f, 0.03072594f, 0.03930201f, 0.05810672f, 
    0.02051824f, 0.02909621f, -0.04426699f, -0.05162267f, 0.02635751f, 0.02916402f, -0.02847102f, -0.02394098f, 
    0.00580391f, -0.05330910f, 0.02146607f, 0.01700499f, -0.05289958f, -0.05321518f, 0.03470803f, -0.05314337f, 
    0.04186984f, 0.02925277f, -0.04323378f, -0.02579827f, 0.02730157f, -0.06454450f, 0.02672264f, 0.02198250f, 
    -0.05513531f, 0.03049704f, 0.01543075f, -0.00116893f, -0.02793470f, -0.01543812f, -0.04855124f, 0.01669678f, 
    -0.05592670f, -0.04731366f, -0.02527372f, 0.03706465f, 0.00484831f, -0.05065149f, -0.05209752f, -0.00927518f, 
    0.02287039f, -0.01231618f, -0.05625626f, -0.00244013f, -0.00747743f, -0.06675777f, 0.03122092f, 0.01680900f, 
    -0.53264356f, -0.06081381f, -0.03878855f, -0.10738027f, 0.04000031f, -0.25297186f, 0.07288007f, 0.06407052f, 
    -0.00264077f, -0.17004918f, 0.11096216f, 0.09191076f, 0.02347863f, 0.09186243f, -0.16070421f, -0.03814335f, 
    -0.02743339f, 0.08977056f, -0.01240443f, -0.07157171f, 0.03015393f, -0.05002426f, -0.13592879f, 0.20336609f, 
    0.01006741f, -0.16915692f, -0.12864545f, 0.44465196f, 0.27295932f, -0.04049891f, 0.02181479f, -0.03151619f, 
    0.26554734f, 0.16983615f, -0.04739138f, 0.16055290f, -0.00667118f, 0.07042383f, 0.03803127f, -0.02139426f, 
    0.01626100f, 0.03909151f, -0.02272608f, 0.11427575f, -0.02137869f, 0.16568868f, 0.20890673f, 0.01349476f, 
    0.11779502f, -0.00761434f, -0.00869684f, -0.12701327f, 0.26549107f, 0.15002047f, -0.20339373f, 0.31081316f, 
    0.11899503f, 0.23224106f, -0.00874982f, 0.11051118f, -0.12635674f, -0.31090382f, -0.35496339f, 0.37463176f, 
    -0.01605234f, -0.24083248f, 0.24294133f, 0.26013577f, 0.08646952f, -0.04199182f, 0.20227721f, 0.07155938f, 
    -0.04471689f, -0.35994336f, 0.11495664f, -0.03098593f, 0.04699183f, 0.12898082f, -0.04248193f, 0.07997963f, 
    0.01672001f, 0.26240116f, -0.28258821f, 0.30208826f, 0.07366639f, -0.17024957f, -0.13171422f, -0.25248471f, 
    -0.06744609f, 0.05262028f, 0.19648515f, -0.06873413f, 0.17874651f, 0.02297920f, -0.09239886f, -0.11601909f, 
    0.17126936f, 0.09051668f, 0.02643842f, -0.36506364f, -0.25232571f, -0.24159482f, 0.03395053f, -0.03908024f, 
    -0.08072437f, 0.00263829f, 0.06194627f, 0.03031366f, -0.07558391f, -0.28731713f, -0.17552923f, -0.40635023f, 
    0.11420393f, -0.19147851f, -0.00488717f, -0.04865990f, -0.20347278f, 0.09805162f, -0.64407349f, 0.27025506f, 
    0.06625470f, -0.14104788f, 0.04333323f, -0.03655647f, -0.07071841f, -0.02968315f, -0.21318857f, 0.08715517f, 
    -0.05704539f, -0.02340696f, 0.06583709f, 0.01493383f, 0.28863409f, 0.05561290f, -0.36180049f, -0.22393726f, 
    -0.09051738f, 0.02276491f, 0.02852605f, -0.22397752f, 0.11541665f, 0.14103119f, -0.05378294f, -0.04526733f, 
    -0.27580661f, -0.02266095f, 0.15698928f, 0.11973041f, -0.19396542f, 0.23168886f, -0.04652938f, -0.07818201f, 
    0.10213674f, 0.10587222f, 0.16922629f, 0.15359874f, -0.06392288f, -0.15001634f, -0.04573723f, 0.00158130f, 
    -0.02220725f, 0.14720865f, -0.22196434f, 0.19436179f, -0.07729965f, -0.02074623f, 0.20431040f, 0.08598711f, 
    -0.10952839f, 0.03849537f, 0.07480469f, -0.13106604f, 0.10677370f, 0.03110623f, -0.11485646f, -0.11519426f, 
    -0.24623813f, -0.13336127f, 0.00514619f, 0.03862911f, -0.07396977f, 0.04816931f, -0.16215113f, 0.09889180f, 
    0.23479223f, 0.00099177f, 0.08625111f, 0.12857431f, 0.07510696f, 0.15316103f, -0.39141321f, 0.11651787f, 
    0.18739517f, 0.16792323f, 0.12269884f, 0.04647659f, 0.18702975f, 0.25901261f, -0.01855608f, 0.37044185f, 
    -0.37265977f, -0.26839444f, 0.01318464f, -0.04324519f, -0.07722575f, -0.12918544f, 0.16920736f, 0.11234269f, 
    0.51278955f, 0.05923763f, 0.17395988f, -0.19310464f, 0.28254944f, -0.09184032f, 0.13066626f, 0.15533943f, 
    0.20662864f, -0.00643093f, 0.04207852f, -0.07081178f, 0.11403893f, -0.00911754f, -0.00277173f, -0.06624740f, 
    0.01872748f, -0.19539212f, -0.07232859f, 0.16043606f, -0.10456891f, -0.21332639f, 0.22782880f, 0.07280336f, 
    -0.16044843f, -0.16810931f, -0.01398229f, -0.02367596f, 0.31638891f, 0.04885356f, 0.08078748f, -0.11215068f, 
    -0.13926266f, 0.07314145f, 0.17535822f, 0.63321090f, 0.04769943f, -0.07824790f, -0.18046668f, -0.19410676f, 
    -0.12873003f, -0.11569966f, -0.15871118f, 0.02016145f, -0.06119261f, 0.01511032f, 0.17562832f, 0.00238266f, 
    -0.07808440f, -0.17081749f, 0.09286232f, -0.02748909f, -0.07072554f, -0.53182065f, -0.23112448f, 0.05713324f, 
    -0.22512124f, 0.01288400f, 0.11585657f, -0.10812153f, 0.05900355f, 0.03796984f, 0.25201035f, -0.04534181f, 
    0.05517854f, 0.16056715f, -0.36827222f, 0.07454082f, -0.12435028f, -0.12826891f, 0.03871803f, 0.31351352f, 
    0.16606452f, -0.20590712f, -0.15831989f, -0.11560273f, 0.04328188f, -0.04131062f, 0.07658967f, -0.04197746f, 
    0.53906125f, -0.17119288f, -0.64115602f, 0.09556105f, -0.17102604f, 0.04062514f, 0.01391290f, -0.10549640f, 
    0.11276400f, 0.06420413f, -0.11020177f, 0.07862788f, -0.26196018f, -0.10330781f, -0.08649117f, -0.11870240f, 
    -0.17416111f, -0.07415141f, -0.08916080f, -0.40925378f, 0.03571098f, -0.20419163f, -0.12821412f, 0.09241990f, 
    -0.28600115f, -0.11525148f, -0.11248843f, -0.05529363f, 0.33794662f, -0.01450977f, 0.07928973f, -0.22628528f, 
    0.06291395f, -0.07299462f, 0.00702835f, 0.32446784f, -0.07286751f, 0.04631716f, 0.49397680f, 0.06502764f, 
    0.10177122f, -0.00208480f, 0.00168101f, -0.13489079f, -0.04782386f, -0.00589793f, 0.11069891f, 0.01558717f, 
    0.21191449f, 0.23068535f, -0.04638154f, -0.17947704f, -0.07750769f, 0.17130744f, 0.35264122f, -0.01008962f, 
    0.18702741f, 0.18714832f, 0.03445166f, 0.09937005f, -0.25062525f, 0.08269422f, 0.12607254f, 0.14624554f, 
    -0.03266621f, 0.25192350f, 0.10649129f, 0.26029095f, -0.01119337f, 0.03707629f, 0.03215981f, 0.15606768f, 
    0.09429061f, -0.13274778f, -0.26366231f, 0.04438276f, 0.01453693f, -0.02895102f, -0.21545532f, 0.05806991f, 
    -0.15466146f, 0.27927339f, 0.14434335f, 0.46730053f, 0.05183006f, 0.25468913f, -0.11462370f, 0.13445278f, 
    -0.11063554f, -0.14752711f, 0.15283017f, -0.23500912f, 0.13201058f, 0.00131612f, 0.13308935f, -0.07873778f, 
    0.08238119f, 0.06234354f, 0.18881179f, -0.09887726f, -0.08176173f, -0.16556314f, 0.06581933f, -0.04164625f, 
    -0.12985808f, 0.05378047f, 0.01374529f, -0.01094596f, 0.22649859f, 0.21561556f, 0.04898469f, -0.12502420f, 
    -0.05780477f, 0.07305207f, -0.46304920f, 0.21800384f, -0.03074537f, 0.05678183f, -0.11069758f, -0.36241227f, 
    -0.07642597f, 0.11661838f, -0.03220241f, -0.11148966f, -0.01455664f, -0.05138067f, 0.39733419f, 0.08664346f, 
    -0.00345051f, -0.00997001f, -0.11923106f, -0.00096655f, -0.06589567f, -0.06739289f, 0.20231596f, 0.00111990f, 
    0.12539467f, 0.12373239f, 0.04006029f, -0.13745427f, -0.03106804f, -0.01667664f, 0.09049857f, 0.08794428f, 
    -0.20309131f, -0.12989397f, -0.10017040f, -0.02043124f, -0.16455953f, 0.05766086f, 0.07677025f, -0.11388842f, 
    0.02380931f, 0.42351934f, 0.06262188f, 0.11443429f, -0.04745688f, 0.00327484f, -0.04872803f, -0.30389097f, 
    -0.21594965f, 0.01348370f, -0.31219676f, -0.28928030f, 0.19007255f, 0.10512353f, 0.26075962f, -0.26789463f, 
    0.27215663f, -0.19448765f, -0.06746801f, -0.34844959f, -0.03968656f, -0.03527154f, 0.16109216f, -0.17354973f, 
    -0.03797625f, 0.05758878f, 0.12125722f, -0.15310124f, 0.21279529f, 0.00459009f, -0.40977320f, -0.07392587f, 
    0.03278613f, 0.01546429f, -0.15780747f, 0.21319011f, -0.02518739f, 0.15994172f, -0.04716203f, 0.04455171f, 
    0.11938296f, 0.07686090f, -0.15091743f, -0.26108491f, 0.04474984f, 0.00909582f, -0.21128468f, 0.39494210f, 
    0.11175890f, -0.03990316f, -0.08626499f, -0.26894382f, 0.11008702f, 0.00547124f, -0.06637606f, -0.12063373f, 
    0.26241052f, 0.13064876f, 0.26315588f, 0.22664645f, -0.04100119f, -0.03229887f, -0.01414353f, 0.05076539f, 
    -0.15109040f, -0.15348780f, -0.11153714f, -0.01267060f, -0.20583595f, -0.17467943f, -0.19274563f, 0.07944339f, 
    -0.27854040f, 0.09515405f, -0.47893465f, 0.22519338f, -0.04606793f, 0.08078543f, -0.14202929f, 0.09186323f, 
    -0.09180436f, -0.04850907f, 0.20135553f, 0.39630821f, 0.39946321f, 0.18117337f, 0.06558951f, 0.09921147f, 
    0.02329602f, 0.07166230f, 0.11563849f, -0.22406709f, 0.07985709f, -0.24947216f, -0.01180405f, -0.10574809f, 
    0.09521326f, -0.01310622f, 0.14234567f, -0.10030897f, -0.36305556f, 0.31195578f, 0.32885411f, 0.21484695f, 
    0.03609827f, 0.13294306f, 0.17680413f, -0.05068875f, -0.11183899f, 0.12810002f, 0.00273557f, -0.28388888f, 
    -0.09234386f, 0.13771091f, -0.16550520f, 0.12343582f, -0.18042888f, -0.00260495f, -0.00921865f, -0.18353291f, 
    -0.22282940f, -0.06724018f, -0.08771996f, -0.05352378f, -0.18012378f, -0.18642114f, -0.03212657f, -0.23830606f, 
    0.06209300f, -0.26388034f, 0.17440109f, -0.14494039f, 0.02694201f, -0.08048213f, 0.27843207f, 0.18556853f, 
    0.02065465f, -0.26851374f, 0.18185034f, 0.29129860f, 0.01230397f, -0.18828854f, 0.08307499f, 0.03130612f, 
    0.03861783f, 0.28757140f, 0.24399586f, -0.05408447f, -0.18780456f, -0.11671642f, -0.31332856f, 0.21759051f, 
    0.03565137f, -0.01170380f, 0.32915723f, -0.30238330f, 0.28770152f, 0.25281829f, -0.00478155f, 0.13250777f, 
    -0.13004534f, 0.01264900f, -0.01994728f, -0.13811488f, -0.10550088f, -0.30482233f, 0.04072473f, 0.19005357f, 
    -0.00882287f, 0.13276525f, 0.07695419f, -0.06192641f, 0.24173827f, 0.20438726f, 0.08011211f, -0.06037018f, 
    -0.07635149f, 0.11818218f, 0.10775083f, 0.15647052f, 0.15229262f, -0.12266590f, 0.07997909f, 0.04675737f, 
    -0.03552772f, 0.07346135f, -0.14924906f, 0.00061149f, 0.22093722f, 0.12546654f, -0.07221150f, 0.27011761f, 
    0.18011627f, -0.20472400f, -0.14655578f, 0.12547997f, 0.27157864f, 0.00436107f, 0.01671404f, 0.18415582f, 
    0.13867469f, 0.13571434f, 0.16991277f, 0.09654965f, -0.10584593f, -0.14947066f, 0.22644880f, -0.09812453f, 
    -0.78876972f, -0.56243217f, -0.23444104f, 0.10383125f, 0.09989101f, 0.22348958f, -0.03593903f, 0.01984219f, 
    0.00251046f, 0.08650654f, -0.11338058f, 0.14093773f, -0.28270760f, -0.03841451f, -0.18407406f, -0.04909053f, 
    0.18441741f, 0.04427620f, 0.32398322f, 0.13690208f, 0.13159701f, -0.08043146f, -0.05057614f, -0.34076217f, 
    0.07244975f, 0.30263326f, 0.05837324f, -0.67660105f, -0.11138874f, -0.34856194f, 0.08059078f, 0.24137485f, 
    -0.06410291f, 0.04029205f, 0.22627519f, 0.14230821f, 0.25091377f, -0.21066432f, 0.02418707f, -0.12243368f, 
    0.08926702f, -0.02422675f, 0.00135092f, -0.02002792f, -0.15058224f, 0.03175500f, -0.40027800f, 0.26874423f, 
    0.18132144f, 0.16221127f, 0.31304532f, 0.04306316f, -0.17155267f, -0.07245898f, -0.32351536f, -0.43399581f, 
    -0.12363584f, 0.17081402f, 0.20181344f, 0.13175415f, -0.11018732f, 0.15568268f, -0.02989878f, -0.55906510f, 
    -0.34177440f, -0.16677243f, 0.03506575f, 0.00354638f, 0.06033713f, 0.00800818f, 0.04355658f, 0.00728300f, 
    -0.44263029f, -0.26677814f, 0.09586534f, 0.01713727f, -0.15895398f, 0.15920213f, -0.03556930f, -0.35266498f, 
    0.01346735f, 0.20574147f, -0.09844857f, -0.05371442f, -0.16577347f, -0.12749998f, -0.12263804f, 0.03907886f, 
    0.10607261f, -0.14808595f, -0.13896370f, 0.09129176f, 0.01978070f, 0.15336743f, -0.09332334f, -0.10705077f, 
    0.24311031f, 0.32212591f, -0.18673557f, 0.19039162f, 0.23845576f, 0.25369108f, 0.17383926f, -0.12177224f, 
    0.10994920f, 0.16286394f, 0.00090238f, 0.00667209f, -0.18123849f, -0.17701827f, -0.03767764f, 0.03514554f, 
    0.03426869f, -0.18246959f, 0.02847252f, 0.13782021f, -0.04278758f, 0.15000919f, 0.02318234f, 0.06726109f, 
    0.08600423f, 0.13110109f, 0.00723336f, -0.13175906f, 0.15583040f, -0.08795468f, 0.16748045f, -0.16262306f, 
    0.17685610f, 0.07370692f, -0.05196753f, -0.03775372f, -0.15140076f, 0.04029472f, -0.01827024f, 0.07739975f, 
    -0.10258458f, -0.12638396f, -0.06332383f, 0.22391537f, -0.20622224f, 0.01065273f, 0.17546010f, -0.02359492f, 
    0.43391219f, -0.01569534f, 0.31644502f, 0.00624134f, 0.16357821f, -0.01486609f, 0.11753747f, 0.16821629f, 
    0.03920184f, -0.40221846f, -0.64037460f, -0.18993556f, -0.08281076f, 0.07480182f, 0.06113357f, 0.06208396f, 
    -0.05933772f, -0.19010226f, -0.47599754f, -0.08466655f, 0.03467191f, -0.27577281f, -0.01110389f, -0.00365816f, 
    -0.24521443f, 0.02432100f, 0.04017435f, 0.31581321f, -0.27632251f, 0.42970046f, -0.03914905f, 0.14764702f, 
    0.10254601f, -0.05270161f, 0.03204611f, 0.04572361f, -0.11795241f, -0.15239623f, -0.07999886f, -0.12911980f, 
    -0.03091960f, 0.07854560f, 0.03526611f, -0.26868153f, -0.12390729f, 0.29395553f, -0.19629005f, 0.10268649f, 
    0.09085954f, -0.04782042f, 0.20378099f, -0.03239010f, -0.11168382f, -0.10779038f, 0.16497038f, 0.02140470f, 
    0.31355989f, 0.00617630f, -0.04004082f, 0.05434315f, -0.13601647f, -0.06842135f, -0.01838993f, -0.16507263f, 
    0.00989708f, -0.07701012f, 0.36600927f, -0.04587689f, 0.03125804f, -0.28835857f, 0.02102946f, -0.05886526f, 
    0.04039175f, 0.03244777f, 0.02890321f, -0.00611955f, -0.00411188f, -0.01419806f, -0.02929607f, -0.02124882f, 
    -0.03080723f, 0.04732526f, -0.01105039f, 0.03666700f, 0.01132270f, 0.04024751f, 0.03965322f, -0.03220198f, 
    -0.04038546f, -0.06782600f, -0.00565085f, -0.02898093f, 0.01610796f, 0.04974840f, -0.03215273f, -0.04010058f, 
    0.00227051f, -0.03766380f, -0.03223215f, 0.04277853f, -0.01340292f, -0.00250741f, 0.02591169f, -0.06612710f, 
    -0.04787165f, -0.05081635f, -0.05654579f, 0.04337933f, -0.02582536f, -0.01128376f, -0.01697645f, -0.05084996f, 
    -0.04011897f, -0.01501789f, -0.05020361f, 0.00878383f, -0.02733636f, -0.03899804f, -0.05611957f, -0.04810796f, 
    -0.05433607f, -0.03624110f, -0.00654427f, 0.04233447f, -0.04901459f, -0.03027305f, -0.05493768f, 0.01762623f, 
    -0.03943619f, -0.05436643f, -0.00975047f, -0.05520706f, -0.01556831f, -0.00646504f, -0.01361317f, 0.00421272f, 
    -0.01263278f, 0.04962962f, -0.02423800f, -0.00185921f, 0.02317327f, 0.04387071f, 0.03326891f, -0.04207843f, 
    -0.00231973f, 0.01795338f, -0.06180228f, -0.00541957f, 0.03845778f, 0.01006542f, -0.05373980f, 0.02347693f, 
    -0.01133773f, 0.00594101f, 0.04012187f, 0.01009655f, -0.02279246f, -0.01461778f, -0.05121060f, -0.02714001f, 
    0.01244711f, -0.02764914f, -0.05251120f, -0.03547427f, -0.00779151f, 0.01014391f, -0.05168805f, -0.03580850f, 
    -0.02527199f, 0.02919066f, -0.04876239f, -0.06190118f, -0.05390245f, 0.00032529f, -0.04233149f, -0.04307823f, 
    0.03950526f, -0.03166005f, -0.04342793f, 0.02833866f, -0.00837742f, 0.01787906f, -0.00293721f, -0.04223397f, 
    -0.03606440f, 0.01548703f, 0.01923008f, 0.00625049f, -0.06313530f, -0.02962789f, 0.02985125f, -0.01327528f, 
    -0.05025882f, 0.01259558f, 0.03190245f, -0.05520073f, -0.05432848f, 0.03263070f, -0.02888171f, -0.05376465f, 
    -0.00248336f, 0.02426182f, 0.04545943f, 0.04069418f, 0.02543524f, -0.06021328f, -0.04693871f, 0.04199141f, 
    0.03422625f, 0.01902195f, -0.04907562f, -0.00489576f, -0.05452735f, -0.05634539f, -0.03405343f, 0.00382469f, 
    0.05814964f, -0.05472808f, 0.01793525f, 0.01252165f, 0.00749963f, -0.06395461f, 0.04574621f, -0.02030886f, 
    0.04460134f, -0.05126644f, -0.01329925f, -0.00423724f, 0.00101268f, 0.00438227f, -0.04655225f, 0.01651862f, 
    -0.04545682f, -0.05145275f, -0.02570988f, 0.05249799f, -0.04283397f, 0.00131766f, -0.03209295f, 0.01782375f, 
    0.02957555f, 0.00959522f, -0.02536160f, 0.04657273f, -0.01349205f, -0.01628398f, 0.01233645f, 0.00383482f, 
    -0.01055045f, 0.02428957f, -0.03142307f, -0.05483734f, 0.03346865f, 0.01494781f, 0.02877599f, 0.00906309f, 
    0.04092131f, 0.03440008f, -0.02149360f, 0.02752322f, 0.03547164f, 0.01254433f, 0.06028764f, 0.01720642f, 
    0.03530427f, 0.02234395f, 0.02471634f, 0.05446799f, 0.00437656f, 0.02651811f, 0.03156167f, -0.02296116f, 
    0.01730869f, 0.02208722f, -0.01809236f, -0.03603428f, 0.01709260f, -0.00595252f, -0.00478136f, 0.05761412f, 
    0.02354186f, 0.04833863f, -0.03768203f, -0.05352419f, 0.03067796f, 0.00523121f, -0.04147529f, -0.03506448f, 
    0.01742249f, -0.03964159f, 0.03423044f, 0.04260143f, -0.00577212f, 0.02961485f, 0.03872483f, 0.01834229f, 
    -0.01432385f, 0.06270768f, 0.03290972f, -0.01777624f, 0.05779463f, 0.04260966f, 0.03271143f, -0.03827851f, 
    -0.02060337f, 0.03327576f, 0.01349400f, 0.02853936f, 0.04537828f, -0.02469226f, -0.04267940f, 0.01415817f, 
    -0.00952392f, 0.05247607f, 0.05046146f, 0.04607450f, 0.04940446f, -0.04769656f, -0.03740398f, 0.02358905f, 
    -0.04297250f, -0.00852451f, -0.01323095f, -0.02559682f, -0.03700778f, -0.02535997f, -0.05545234f, -0.03008194f, 
    -0.02397835f, -0.03582007f, 0.03424030f, -0.01163481f, -0.05034335f, -0.01803420f, 0.01193375f, -0.03310126f, 
    -0.01305151f, 0.01030472f, -0.01254576f, 0.05332479f, 0.01782667f, -0.05086046f, 0.04524879f, -0.03587437f, 
    -0.06170936f, -0.04236691f, -0.03735305f, 0.04514091f, -0.01945980f, -0.03466856f, 0.03078729f, -0.03769973f, 
    0.05001114f, 0.01596650f, -0.04908357f, 0.01096995f, -0.01790941f, 0.00588181f, -0.04443797f, 0.02413071f, 
    0.14178319f, -0.00946549f, 0.07249410f, -0.18488438f, -0.25435120f, -0.10638269f, 0.06217229f, -0.05973817f, 
    0.00680855f, -0.39316240f, -0.20573361f, -0.09001883f, -0.03909790f, 0.17987750f, -0.05650889f, 0.12489790f, 
    0.12576737f, -0.20648493f, -0.09873918f, 0.41523275f, 0.27869391f, -0.01743076f, -0.05978383f, -0.09193642f, 
    0.12871507f, 0.21339212f, -0.06504352f, -0.23314282f, -0.18652041f, -0.01745661f, -0.03202460f, 0.07214127f, 
    0.05583339f, 0.11295885f, 0.02187699f, 0.00530764f, -0.21938244f, -0.04161562f, -0.21444558f, 0.08183803f, 
    -0.04712922f, 0.13899742f, 0.11614599f, -0.06596949f, -0.23902419f, 0.28499463f, 0.17196067f, -0.16373819f, 
    0.17882624f, 0.15538903f, 0.20269468f, 0.00720245f, -0.00942829f, 0.05595519f, -0.09484113f, -0.12352804f, 
    -0.16913190f, 0.06658325f, -0.02273413f, 0.13362950f, -0.14498813f, 0.01586197f, -0.10711595f, 0.05902645f, 
    -0.08146618f, -0.35148796f, 0.23663563f, 0.12361807f, 0.43380472f, -0.00888380f, 0.08316220f, -0.22469656f, 
    -0.08125688f, -0.00274933f, 0.33563644f, 0.01474205f, -0.02607473f, -0.04177278f, -0.07443325f, -0.21747871f, 
    -0.25415301f, -0.35852808f, -0.26947516f, -0.16321583f, -0.11912601f, 0.12471489f, -0.02020013f, -0.09537834f, 
    -0.03065006f, -0.05767740f, -0.16753323f, -0.25935066f, -0.15018642f, 0.24458748f, 0.08604707f, 0.26992562f, 
    0.13974802f, -0.16775309f, -0.07257019f, -0.15256785f, -0.03304731f, 0.03810267f, -0.03954190f, 0.12581782f, 
    0.07620692f, 0.11415475f, 0.02595858f, 0.15191133f, -0.40410671f, -0.01120473f, 0.20133598f, -0.12226213f, 
    -0.00743013f, -0.04654814f, -0.30534714f, 0.24204938f, 0.21557833f, -0.01937379f, 0.30360642f, 0.29808208f, 
    -0.17660153f, -0.10491430f, -0.18037118f, -0.08922376f, 0.09392621f, -0.04628856f, 0.12615107f, 0.01700117f, 
    0.24488904f, -0.07408917f, 0.03315828f, -0.07154643f, 0.45427361f, 0.13260692f, -0.09154647f, -0.04717289f, 
    0.03261440f, -0.00260595f, 0.14627334f, 0.16797365f, 0.11208367f, 0.13775750f, -0.03488993f, 0.05039358f, 
    0.07509982f, 0.11834512f, 0.19525771f, -0.05265451f, -0.04568041f, 0.19771335f, 0.02282367f, 0.10636179f, 
    -0.16269483f, -0.20684040f, -0.45063752f, -0.16213456f, -0.24183689f, -0.02374222f, -0.10247359f, -0.13668671f, 
    -0.04454637f, 0.01905225f, -0.32569748f, 0.15938115f, -0.21331412f, -0.20954442f, -0.01548682f, 0.06033214f, 
    0.03962556f, 0.00215444f, -0.11157539f, -0.14149208f, 0.15044871f, -0.23147792f, -0.14677197f, 0.15700048f, 
    -0.03571576f, -0.11950448f, 0.14576907f, -0.15696366f, 0.08558116f, -0.14115430f, -0.22538702f, -0.13571168f, 
    0.07109918f, 0.05033681f, 0.02600281f, 0.19557862f, 0.08574282f, 0.16984756f, 0.15248366f, -0.21223751f, 
    -0.04537057f, 0.10097888f, 0.13346758f, 0.13670745f, 0.09365351f, 0.26819411f, -0.21895808f, 0.01974827f, 
    0.27447698f, -0.29101625f, -0.00970661f, -0.19190194f, -0.10939828f, -0.00829849f, -0.13566805f, 0.32874897f, 
    -0.02035067f, -0.21379876f, 0.12091747f, 0.20631191f, 0.17139900f, 0.07903390f, -0.34146911f, -0.05206905f, 
    0.03623801f, 0.13001440f, 0.02262144f, 0.00041588f, 0.25317466f, -0.01813660f, 0.02824545f, 0.04091906f, 
    0.44158337f, -0.03526076f, 0.34876195f, 0.35611150f, 0.19790636f, -0.15748265f, 0.04347478f, 0.13857262f, 
    0.01937027f, -0.06432915f, -0.46795532f, 0.01842681f, -0.30819964f, 0.13786322f, 0.20975624f, -0.12800802f, 
    0.03898085f, 0.14003816f, -0.11722587f, -0.01259690f, 0.12941703f, 0.01920955f, 0.03732288f, 0.04113375f, 
    -0.24916972f, 0.10002036f, 0.12172636f, 0.07568907f, -0.81847370f, -0.17241696f, -0.36595643f, 0.17025538f, 
    0.05684272f, -0.12016419f, 0.03365335f, 0.03772027f, 0.05642467f, 0.11143045f, 0.34715030f, 0.07673385f, 
    -0.41563782f, -0.05341428f, 0.04519392f, -0.27819487f, -0.15605988f, -0.04179621f, 0.25697625f, 0.15056273f, 
    -0.00789485f, 0.08403657f, 0.21860306f, -0.01496519f, -0.07050964f, 0.32825238f, 0.12475375f, 0.50267738f, 
    0.01751077f, 0.23191173f, -0.14009322f, -0.05799069f, 0.01967550f, 0.09895190f, -0.02485863f, 0.04916792f, 
    0.05563571f, -0.04728561f, -0.00061023f, -0.05701106f, -0.06206142f, 0.00357616f, 0.02915530f, -0.02493968f, 
    0.02816480f, 0.00687697f, 0.00605107f, -0.06508040f, 0.00018827f, 0.04255350f, 0.01117038f, 0.00201728f, 
    -0.05628279f, -0.01676176f, 0.00340790f, 0.00365763f, 0.05082259f, 0.02936327f, -0.00335182f, 0.01518611f, 
    0.01903473f, -0.06759553f, 0.01683789f, -0.07060371f, -0.05186749f, -0.00813855f, 0.01215045f, -0.04422108f, 
    -0.07391804f, -0.04795538f, -0.00035619f, -0.05235581f, -0.02203199f, 0.04004662f, -0.00768692f, -0.03887320f, 
    0.00807056f, -0.03813864f, 0.01348841f, 0.03475000f, 0.04858800f, -0.01466641f, 0.00130157f, -0.06407510f, 
    -0.04938725f, -0.00738721f, 0.01463538f, 0.01645239f, -0.01614053f, 0.00569044f, 0.00239215f, -0.00541798f, 
    -0.01107792f, -0.00868540f, -0.02906641f, 0.01451667f, -0.05118652f, 0.02844676f, 0.04052169f, -0.01247925f, 
    -0.06255677f, 0.02706779f, 0.01693715f, -0.03094532f, 0.00284728f, -0.06059578f, -0.06108103f, -0.04955059f, 
    0.04778008f, -0.03837295f, -0.04299803f, 0.00847788f, -0.05332464f, 0.02040685f, 0.02069090f, 0.03198698f, 
    0.00243153f, -0.04656961f, -0.02731857f, 0.01830847f, -0.05428514f, -0.03905118f, -0.03618173f, 0.03614326f, 
    -0.01330008f, 0.01129699f, -0.05487463f, -0.02473165f, -0.03504855f, 0.02946377f, 0.00546419f, -0.07775697f, 
    -0.02086556f, -0.05424819f, 0.03815588f, -0.01756647f, -0.04672169f, -0.01918100f, -0.06396569f, 0.00473702f, 
    -0.00508695f, 0.00619193f, -0.00485377f, -0.02021693f, 0.02514650f, 0.01515241f, -0.00019729f, 0.01383178f, 
    -0.00940594f, -0.04986452f, 0.01244005f, 0.01776905f, 0.03866176f, -0.02543554f, -0.05707086f, -0.03638466f, 
    0.00054076f, 0.01133105f, -0.00703035f, -0.04118333f, -0.01985660f, -0.05943338f, -0.06247165f, 0.02802942f, 
    0.03957975f, 0.01310726f, 0.02360650f, -0.04329078f, 0.01624161f, 0.02411698f, -0.00092357f, -0.00779780f, 
    -0.03004814f, -0.00723871f, 0.05231264f, -0.05882424f, -0.00688782f, 0.01900596f, -0.04875709f, -0.05431473f, 
    0.01297947f, 0.05116436f, 0.02708040f, -0.01414396f, 0.01889307f, 0.03002751f, -0.04946911f, 0.03465408f, 
    -0.01146402f, -0.05516950f, -0.02290679f, 0.02198773f, 0.00778350f, 0.01245184f, 0.02665197f, -0.03868327f, 
    -0.04766669f, -0.01152860f, -0.01722967f, 0.01219782f, 0.03000147f, -0.03551520f, 0.00124628f, -0.05194775f, 
    -0.02500257f, 0.03081650f, 0.02044030f, -0.01350908f, 0.03432974f, -0.01784786f, -0.01874165f, -0.06755938f, 
    -0.01269967f, 0.02934014f, 0.03986917f, -0.05049164f, 0.02380213f, 0.02937730f, -0.06727339f, 0.00449259f, 
    -0.03601568f, -0.01056936f, -0.03226552f, 0.00817490f, -0.06147004f, -0.00402723f, -0.06022007f, -0.01942539f, 
    -0.00154934f, 0.03926719f, -0.05560520f, 0.02467905f, 0.01515071f, -0.03989001f, -0.04081944f, -0.03761991f, 
    -0.00958947f, -0.02900818f, -0.04086951f, -0.01491825f, 0.02926346f, -0.00014139f, -0.03080792f, -0.04057251f, 
    0.00126398f, 0.01907475f, -0.03636010f, -0.01847261f, -0.06447126f, -0.02856717f, 0.00900149f, 0.04099662f, 
    -0.03328609f, -0.00421757f, -0.03441104f, -0.05689259f, -0.02242037f, 0.03040605f, 0.03286641f, -0.04162423f, 
    -0.00228938f, 0.00640373f, -0.06403162f, -0.03610207f, -0.03486878f, 0.02823479f, -0.04351588f, -0.04037460f, 
    0.01823486f, 0.03469306f, 0.02610345f, -0.03617148f, -0.04107575f, 0.04473824f, -0.01875506f, -0.04152584f, 
    0.02134661f, -0.06656748f, -0.01315482f, -0.00832619f, -0.04684038f, -0.03838458f, -0.02785601f, -0.01092778f, 
    -0.03907993f, -0.04669382f, 0.04202173f, -0.05132911f, -0.05809958f, 0.02213870f, 0.00033683f, 0.03549422f, 
    0.00759500f, -0.05942067f, 0.04616521f, -0.00382700f, 0.04483718f, 0.00357449f, -0.04507414f, -0.01605259f, 
    0.05349271f, -0.00744825f, -0.06316467f, 0.01465179f, -0.06524516f, -0.04583451f, -0.01695077f, 0.04153239f, 
    0.04778306f, 0.04276239f, 0.02283773f, 0.00273587f, 0.01448197f, -0.02955388f, 0.02618849f, 0.03879622f, 
    -0.03141249f, -0.03937996f, -0.05906608f, 0.00340440f, -0.06490133f, 0.00404813f, -0.00352690f, -0.04753532f, 
    0.55444342f, -0.47342199f, 0.00366887f, -0.06473412f, 0.06522414f, -0.16495137f, 0.13862385f, 0.16867276f, 
    -0.05038537f, -0.84888643f, -0.05491449f, -0.23490740f, -0.18637738f, -0.22216578f, -0.03003182f, -0.06641459f, 
    -0.04546190f, -0.04362973f, -0.07733462f, -0.00317037f, -0.16741432f, 0.02902800f, -0.02067828f, 0.01663296f, 
    0.10803085f, 0.06694902f, 0.11969924f, -0.12162028f, -0.41657433f, 0.50903976f, -0.13724048f, 0.16268288f, 
    -0.04140432f, -0.09767010f, 0.08069089f, 0.06596451f, 0.38660133f, 0.26912981f, -0.18050702f, 0.05354153f, 
    0.09296498f, 0.02077334f, 0.20543317f, 0.08022426f, -0.14352308f, -0.06463870f, 0.38787326f, 0.10474669f, 
    0.05455390f, 0.01276806f, -0.17671131f, 0.06593417f, 0.05560656f, 0.04724935f, -0.27105051f, -0.21869159f, 
    -0.09688081f, 0.14104664f, 0.12911870f, 0.09397058f, -0.02025747f, -0.04460153f, -0.22139591f, 0.21304482f, 
    0.12717836f, -0.10267647f, 0.02789338f, 0.00098168f, -0.06956315f, 0.29923511f, -0.06428306f, 0.05787580f, 
    -0.16691720f, -0.06805106f, 0.13773216f, 0.22630310f, 0.01041023f, -0.00960931f, -0.15495540f, -0.01478916f, 
    0.12708111f, -0.10099334f, 0.22072485f, -0.08170455f, 0.05466649f, -0.18032652f, 0.14657611f, 0.24403320f, 
    -0.01325712f, -0.13222472f, 0.28182867f, 0.49337122f, -0.02684830f, -0.01765085f, -0.00503056f, -0.00322677f, 
    0.03649850f, 0.00496173f, 0.20013744f, 0.15641990f, -0.24587198f, 0.06713306f, 0.12330870f, 0.10223209f, 
    -0.00281940f, -0.15050030f, 0.09178822f, 0.09054025f, -0.13000725f, -0.41689426f, -0.25206077f, -0.10158849f, 
    -0.15869486f, 0.12909582f, 0.03059317f, -0.15477310f, 0.14293812f, -0.23294048f, 0.37750813f, 0.00530237f, 
    0.09542233f, -0.01077019f, -0.12336460f, -0.15899359f, 0.04952447f, -0.03369512f, 0.15747368f, -0.01615638f, 
    0.12407412f, -0.05217643f, 0.06956882f, 0.10209782f, 0.08795990f, 0.11053742f, -0.12386800f, -0.02903398f, 
    0.25659221f, 0.06298829f, -0.10128471f, -0.13809116f, -0.03271420f, 0.04127467f, -0.26881036f, -0.05293533f, 
    0.11857764f, -0.04673376f, 0.43764639f, -0.02855041f, 0.01940290f, 0.19322926f, -0.16456512f, 0.14306805f, 
    -0.13085455f, 0.05940974f, 0.09040199f, 0.28195640f, 0.05251056f, 0.14170307f, -0.10057757f, -0.01091114f, 
    -0.05701352f, -0.17116681f, 0.47992089f, -0.04614197f, -0.14602575f, -0.10663135f, 0.01186232f, 0.09007229f, 
    -0.13218318f, 0.08144064f, 0.01772838f, 0.18753618f, -0.20269750f, 0.03743010f, 0.21043713f, -0.15221982f, 
    0.08466409f, 0.04225835f, 0.16434444f, 0.16448864f, 0.46031234f, -0.27869573f, 0.17139214f, -0.02820797f, 
    0.01520219f, 0.02868721f, -0.20536131f, -0.10213891f, -0.09262171f, 0.00676225f, 0.15529332f, -0.03770676f, 
    0.15236069f, 0.00086794f, 0.07109855f, 0.16669059f, -0.06934053f, 0.02769214f, 0.24846385f, -0.50022322f, 
    -0.02267147f, -0.03216798f, 0.01398895f, -0.13520536f, -0.04903992f, 0.08121783f, 0.13107374f, 0.18217193f, 
    0.18700686f, -0.05788559f, 0.11932369f, -0.11311876f, 0.10083000f, 0.07462612f, -0.03470774f, -0.23493214f, 
    0.00122966f, -0.38359088f, -0.12714732f, -0.08664894f, 0.08459597f, -0.07626793f, 0.00501162f, 0.00856832f, 
    0.20521536f, -0.19728532f, 0.37099296f, 0.02433311f, -0.17921863f, -0.10314097f, -0.15655062f, -0.21694700f, 
    -0.13377638f, -0.03313013f, -0.46459344f, 0.01450302f, -0.21393821f, 0.06478951f, 0.23305884f, 0.04030168f, 
    0.09879343f, 0.14732972f, -0.09899758f, -0.01460146f, -0.47995085f, -0.58213770f, 0.02546828f, 0.11154915f, 
    -0.05851343f, 0.12194834f, -0.05882554f, 0.02197522f, -0.34043434f, 0.24507762f, -0.19901250f, 0.09799409f, 
    0.02943217f, 0.03102157f, 0.11327147f, -0.12805150f, -0.19122905f, -0.02161157f, -0.00753010f, -0.30502379f, 
    -0.04372310f, -0.17329769f, -0.13634247f, 0.05754743f, 0.20302679f, 0.05402011f, -0.57519782f, -0.11658075f, 
    -0.01291251f, -0.23616156f, -0.08693981f, -0.17063287f, -0.02623662f, -0.02711942f, 0.18161042f, 0.29790932f, 
    -0.16384384f, -0.00030727f, -0.18783779f, -0.00017507f, -0.03325273f, 0.10473958f, -0.07939427f, -0.09232139f, 
    -0.00561154f, 0.01991042f, -0.05038095f, -0.01752672f, 0.00059656f, -0.03468781f, -0.02059515f, -0.02698433f, 
    0.02827809f, -0.03145541f, 0.00064703f, -0.03501260f, 0.02448924f, 0.04049290f, 0.03304695f, -0.06409036f, 
    -0.01875620f, -0.04121060f, -0.02255588f, -0.02123214f, 0.01839426f, 0.01661110f, -0.05563053f, -0.00813200f, 
    0.02235156f, -0.01968770f, -0.04281356f, 0.05205019f, -0.05141811f, 0.02117907f, -0.00436172f, 0.00882179f, 
    0.04471046f, -0.03658320f, 0.02464519f, 0.00708176f, 0.00634797f, -0.05484609f, 0.04270406f, 0.00972055f, 
    -0.04025612f, -0.03262255f, -0.02640222f, 0.04885713f, -0.03354784f, 0.03243426f, -0.02386805f, -0.05130608f, 
    0.00640331f, -0.06249107f, 0.00693488f, -0.00033911f, -0.04810664f, 0.01793776f, -0.03256864f, 0.00546157f, 
    -0.04627639f, -0.04465743f, -0.02739532f, 0.01437237f, -0.02864681f, -0.02518154f, -0.03073386f, 0.00282739f, 
    0.05062386f, -0.01431983f, -0.05063109f, 0.04416008f, -0.02249447f, -0.04007181f, 0.01460468f, -0.00100233f, 
    -0.04845258f, 0.04323583f, 0.04799359f, 0.02731241f, -0.02225973f, -0.03501247f, -0.05065783f, 0.03920719f, 
    0.03358452f, 0.03148154f, -0.03059832f, -0.06409690f, 0.04920818f, -0.02804037f, -0.04169600f, 0.04265822f, 
    -0.02945569f, 0.03806560f, -0.02723765f, -0.04143408f, -0.01534120f, -0.00548253f, -0.05347485f, -0.03229256f, 
    -0.00927214f, 0.04850908f, 0.00038101f, -0.05045069f, -0.01789961f, -0.02125500f, 0.04344220f, 0.04877318f, 
    0.02807252f, -0.05170301f, -0.05721690f, -0.03997941f, -0.06286353f, -0.03360843f, -0.06074483f, 0.00418062f, 
    0.03232069f, 0.00845197f, -0.06222647f, 0.02535386f, 0.02430646f, 0.00614162f, -0.05167291f, -0.05996167f, 
    -0.02116428f, 0.01307120f, -0.06041444f, -0.06011822f, 0.04899286f, -0.02457541f, -0.02833208f, -0.00432070f, 
    -0.02875225f, 0.03476071f, 0.04797449f, 0.00465103f, -0.02076533f, -0.03981548f, -0.02443048f, 0.00136801f, 
    0.02799943f, 0.04050306f, -0.03599535f, 0.00689476f, 0.04095990f, -0.04884395f, -0.00706801f, 0.03854426f, 
    0.03460426f, 0.00757067f, 0.04886758f, -0.01410590f, -0.02783900f, 0.01339635f, 0.01174241f, -0.02896691f, 
    -0.00233082f, 0.05203316f, -0.03161576f, -0.06139062f, -0.03658523f, -0.05380142f, 0.03435084f, -0.01096368f, 
    -0.06038355f, -0.01281653f, -0.01475319f, -0.03674067f, -0.05127710f, -0.02562668f, -0.03780133f, -0.04754174f, 
    -0.03095565f, -0.01823007f, 0.00152542f, -0.03990157f, -0.00484739f, 0.04275423f, -0.05412265f, 0.02398831f, 
    -0.02273742f, -0.01214257f, 0.01733169f, -0.03463501f, 0.05104634f, 0.01502087f, 0.00163251f, 0.01000227f, 
    -0.05747527f, 0.00182042f, -0.03736207f, 0.03137067f, -0.02631245f, -0.04085943f, -0.06027608f, -0.03737775f, 
    0.04827918f, 0.02995860f, -0.01597197f, 0.04877998f, -0.05111807f, -0.00021888f, 0.05048439f, -0.00901640f, 
    0.01415233f, 0.02993188f, -0.02746126f, -0.03519079f, 0.04826546f, -0.02031459f, 0.01583688f, -0.02916811f, 
    0.05059507f, 0.01415655f, -0.06443741f, 0.01555815f, -0.06121632f, 0.04597142f, -0.03711297f, -0.05029196f, 
    0.01083885f, -0.06098578f, 0.00225410f, -0.00381903f, -0.00868088f, -0.00001381f, -0.03377385f, 0.05230440f, 
    0.00551308f, -0.01757376f, -0.00222588f, -0.06308804f, 0.00230353f, -0.04965515f, -0.02350277f, 0.01631192f, 
    -0.04233360f, 0.04371332f, -0.05307477f, 0.01147139f, 0.02208115f, -0.01491157f, -0.00125946f, -0.00137366f, 
    -0.03615208f, -0.02148694f, 0.05154593f, -0.02701106f, -0.04272075f, -0.06076857f, 0.02577604f, -0.01787415f, 
    0.03298127f, 0.03818946f, 0.05178500f, -0.01175581f, 0.05217345f, -0.03874927f, -0.05862819f, -0.05365776f, 
    0.02332665f, -0.00152876f, -0.01645867f, 0.00397854f, 0.01521976f, 0.00910323f, -0.04469371f, 0.00690836f, 
    -0.04319742f, -0.01090958f, -0.05567825f, 0.01257025f, 0.04226101f, 0.04649594f, 0.02814693f, 0.01499569f, 
    -0.01376479f, 0.03402200f, -0.00880967f, -0.01960137f, 0.00621665f, 0.01520917f, 0.01405353f, 0.00617517f, 
    -0.02219026f, -0.02744579f, -0.02540413f, 0.04803536f, -0.00427336f, 0.03297895f, -0.00685372f, -0.01201014f, 
    -0.43833765f, -0.32132974f, 0.06186739f, -0.17002667f, 0.12468256f, 0.04616447f, 0.02355196f, -0.19990216f, 
    -0.11643764f, 0.01643808f, 0.01856376f, -0.00298058f, 0.10402050f, 0.01848351f, -0.05211519f, 0.10005918f, 
    0.16623272f, 0.18176106f, -0.15177895f, 0.20851848f, -0.05734587f, -0.03457028f, -0.02151803f, 0.18664016f, 
    -0.13468343f, 0.07156736f, -0.01210975f, -0.14159136f, 0.12674230f, -0.41702592f, 0.03733028f, 0.00916032f, 
    0.05116557f, 0.17206955f, 0.08243896f, 0.18638732f, 0.33291608f, 0.03436581f, 0.26242712f, -0.02023018f, 
    0.17285411f, 0.19299647f, -0.08627166f, 0.04251909f, 0.09313705f, 0.13531475f, 0.19837132f, 0.09135784f, 
    -0.06512805f, 0.05889610f, -0.33338186f, -0.02692132f, -0.04066707f, 0.05211904f, -0.06362893f, -0.26870716f, 
    -0.15006752f, -0.04621084f, 0.00346842f, 0.28320840f, -0.14916186f, -0.12742433f, -0.02262001f, 0.34990409f, 
    -0.04537799f, 0.22450502f, -0.12880696f, 0.14819728f, 0.07600017f, -0.05274415f, -0.01943291f, 0.06698550f, 
    -0.03740642f, 0.19766372f, -0.25809821f, -0.06793741f, -0.13152619f, 0.20746097f, -0.04679734f, 0.08977050f, 
    0.05572998f, 0.45821926f, 0.14660594f, 0.36342302f, 0.20167783f, -0.10249004f, -0.00010009f, 0.25267860f, 
    -0.15716538f, 0.01016729f, 0.28939545f, 0.01173916f, 0.10157720f, 0.00492409f, 0.07417628f, 0.06251138f, 
    0.08561302f, -0.06578233f, 0.15365115f, 0.20741791f, -0.04436238f, -0.33755216f, 0.06154342f, -0.02849106f, 
    0.07287838f, 0.06602665f, 0.14961998f, 0.14067547f, -0.49868488f, -0.14547797f, 0.39181244f, -0.20246778f, 
    0.12757948f, -0.08541331f, -0.11068789f, 0.17288268f, 0.17562260f, -0.19699883f, 0.26877818f, -0.45046550f, 
    0.06254138f, 0.07630536f, 0.10907433f, -0.00816687f, -0.01907328f, 0.02665870f, 0.04632751f, -0.19904625f, 
    -0.19937234f, -0.04524441f, 0.09328425f, -0.08160134f, -0.09725659f, 0.09291787f, -0.15121438f, 0.15844670f, 
    -0.09791902f, 0.03701545f, 0.01368798f, 0.20695697f, -0.00633157f, 0.11968705f, 0.21776994f, 0.04129839f, 
    -0.06507883f, 0.50926363f, -0.29692218f, -0.18782419f, -0.09077284f, -0.13880393f, 0.10559034f, 0.04815748f, 
    0.05425203f, -0.18618976f, -0.19571158f, -0.02420022f, -0.11292720f, 0.05740377f, -0.04891572f, -0.02024172f, 
    0.06555678f, 0.04367909f, -0.20059720f, 0.27334830f, -0.02231474f, 0.10062396f, 0.14595810f, 0.09467461f, 
    0.12294016f, 0.00304535f, 0.04363615f, -0.11632140f, -0.18397903f, -0.06758240f, -0.13718773f, -0.04430622f, 
    -0.09322327f, 0.25248188f, 0.20303510f, 0.13329683f, 0.13565314f, -0.13898924f, -0.03151454f, 0.00218397f, 
    0.04995864f, -0.08797302f, 0.12416196f, -0.00007837f, 0.12782069f, 0.15311660f, -0.16678636f, 0.21002290f, 
    0.10410411f, -0.01923327f, -0.10909501f, -0.02300096f, 0.00318864f, -0.02887606f, -0.65997767f, 0.22731675f, 
    0.14113638f, -0.03711235f, 0.00800408f, 0.03870543f, 0.26844758f, -0.05399840f, 0.04562932f, 0.20122820f, 
    0.23993646f, 0.24644667f, 0.06724143f, -0.02735009f, -0.05054399f, -0.13371809f, -0.12122636f, -0.02775693f, 
    -0.35983694f, 0.08235222f, 0.07248884f, -0.01944188f, 0.02895898f, 0.00457614f, -0.08674952f, -0.01356375f, 
    -0.06436115f, 0.16529848f, 0.29179794f, -0.23059696f, 0.11097415f, 0.02064727f, 0.09007985f, 0.10154787f, 
    0.24170978f, 0.01036409f, -0.09809121f, -0.32709721f, 0.05617110f, -0.39521477f, -0.02237394f, -0.21080774f, 
    0.03391613f, -0.12474339f, -0.13291521f, -0.25583979f, -0.03999653f, -0.12758178f, -0.06875060f, 0.00720624f, 
    -0.05408180f, -0.04968751f, -0.02087038f, 0.06988537f, 0.21132934f, -0.02555639f, 0.04784827f, -0.13711326f, 
    -0.05263124f, 0.15769331f, 0.08640593f, -0.01473876f, -0.14799996f, -0.36631817f, 0.10099385f, -0.18674408f, 
    -0.27030095f, 0.07872274f, 0.08397955f, -0.17950462f, -0.22196171f, -0.04855871f, -0.00971880f, 0.09242343f, 
    -0.43344513f, -0.04096602f, -0.10911380f, 0.11324091f, -0.08991494f, 0.13974161f, 0.07260178f, -0.21424089f, 
    -0.01777229f, -0.21453951f, -0.11124619f, 0.32110044f, 0.10171992f, -0.14569214f, -0.10519809f, 0.08082246f, 
    -0.06656232f, -0.43602374f, 0.31274062f, -0.00655159f, 0.05599018f, 0.26408350f, -0.04884657f, -0.07171009f, 
    -0.04286071f, 0.06389614f, 0.33101770f, -0.11366384f, 0.02128500f, -0.02731279f, -0.07950573f, 0.17576562f, 
    0.10862073f, 0.04054520f, -0.19203122f, 0.16023278f, -0.01763541f, -0.00516868f, 0.10986067f, -0.01691333f, 
    0.02184215f, -0.16291584f, 0.00320495f, 0.09573935f, 0.12964663f, -0.27271724f, 0.11036561f, 0.02741999f, 
    -0.15108915f, 0.12405428f, 0.13616920f, 0.11269660f, 0.03903170f, 0.10861390f, -0.18775725f, 0.00567397f, 
    -0.14033322f, 0.05629413f, 0.10865075f, 0.09946052f, -0.12846111f, 0.33731267f, 0.13156711f, -0.25852990f, 
    -0.18256566f, 0.01128606f, 0.01016269f, 0.09443164f, 0.04406735f, 0.18005732f, 0.22088021f, -0.20853499f, 
    0.02739144f, 0.19662383f, 0.06973197f, 0.01664992f, -0.02145291f, -0.19851424f, -0.15549228f, 0.15689744f, 
    0.38251027f, -0.20781772f, -0.09663956f, 0.03869876f, 0.17301916f, 0.02130600f, 0.20543025f, 0.05628557f, 
    -0.24231409f, -0.24038015f, -0.00640471f, 0.12394067f, -0.05004843f, 0.01905230f, 0.08182748f, 0.01812176f, 
    0.02772007f, 0.18014544f, 0.38645107f, -0.04094484f, 0.30985311f, 0.01277757f, -0.15340917f, -0.13291880f, 
    0.09044475f, 0.11688494f, 0.00247069f, 0.09228465f, 0.11950071f, 0.24531530f, 0.20528467f, 0.02174595f, 
    0.17251843f, -0.03204291f, -0.01162847f, -0.19008198f, -0.07974988f, -0.11025730f, 0.13833344f, 0.02759917f, 
    -0.08912265f, 0.12847793f, -0.16842985f, 0.21291098f, 0.02047908f, 0.25483498f, -0.15136121f, 0.00639422f, 
    -0.05379099f, 0.18164721f, 0.09363003f, 0.03159855f, -0.03411159f, -0.39181906f, -0.05396884f, -0.17261659f, 
    -0.05949897f, -0.04704516f, 0.15976036f, 0.03111089f, 0.25413084f, 0.06171025f, -0.40115568f, -0.19107978f, 
    -0.47109887f, 0.22818412f, 0.09164357f, -0.00052710f, -0.09772237f, -0.23089361f, -0.21543603f, -0.17898123f, 
    0.11494010f, -0.03171073f, 0.15666918f, 0.05488597f, 0.04817069f, -0.00042751f, -0.12751229f, -0.04841280f, 
    -0.33175051f, -0.18826622f, -0.03897999f, 0.19158085f, 0.07356035f, -0.09163503f, 0.01742774f, 0.10913984f, 
    0.01648354f, -0.02474601f, -0.17252606f, -0.08454708f, -0.05572249f, -0.14589596f, -0.07391649f, 0.15533353f, 
    -0.06728742f, 0.02512473f, -0.28668538f, 0.14572756f, -0.00629602f, -0.02138053f, -0.30468896f, -0.08731550f, 
    0.01742727f, 0.32071275f, -0.01782868f, -0.20130642f, -0.01834705f, 0.22076270f, -0.06691880f, -0.01029486f, 
    -0.18679972f, -0.06129718f, -0.02574140f, 0.08811459f, -0.11881153f, -0.16596714f, 0.27728081f, -0.02587658f, 
    0.07985419f, 0.27708116f, 0.31942955f, -0.04713427f, -0.12318164f, 0.39042148f, 0.15079221f, -0.10903118f, 
    -0.27872798f, 0.09205112f, -0.02623932f, -0.05501537f, 0.32968256f, -0.02937373f, -0.36741012f, 0.09149240f, 
    0.24017575f, 0.17149056f, -0.19866811f, 0.00877821f, 0.03409527f, 0.04051048f, 0.08713988f, 0.31133300f, 
    0.20108338f, 0.31310737f, -0.11566863f, -0.21163219f, -0.04117928f, 0.22046690f, 0.12663108f, -0.10388382f, 
    0.15840395f, 0.01704838f, 0.12234998f, 0.05111995f, -0.20563516f, 0.14343721f, 0.02676364f, 0.14923410f, 
    0.15565452f, -0.44173595f, -0.05245436f, -0.34328973f, 0.09936523f, 0.03785645f, -0.08937540f, 0.07051269f, 
    -0.09542526f, 0.05060552f, 0.10043120f, 0.17496459f, 0.11537165f, -0.04671309f, 0.11859439f, 0.07487075f, 
    -0.05628794f, -0.02476752f, -0.02506008f, 0.00739059f, -0.36806911f, 0.03125438f, -0.14706896f, -0.00720270f, 
    -0.03488098f, 0.14218315f, -0.05840519f, -0.15875891f, 0.03433830f, 0.21592169f, -0.18313669f, -0.07194953f, 
    -0.02180517f, 0.05981127f, 0.09001586f, 0.20267947f, -0.08442277f, -0.03443791f, -0.04301769f, 0.03447203f, 
    -0.22805291f, -0.31194368f, 0.08739997f, -0.20179684f, 0.10001030f, 0.13113770f, 0.09089078f, -0.22543076f, 
    0.00584257f, -0.32755733f, 0.01383041f, 0.07364395f, -0.04986517f, 0.11149655f, 0.14081228f, -0.34040895f, 
    -0.19875483f, -0.07947166f, 0.10576719f, 0.00360936f, -0.14420588f, -0.04444005f, 0.04456614f, -0.01848344f, 
    -0.02551378f, 0.01523855f, 0.04604178f, -0.00152427f, -0.02699837f, 0.03707952f, -0.07261945f, 0.03311110f, 
    -0.02904030f, 0.00214704f, -0.01610968f, 0.01045641f, 0.00764884f, 0.04544418f, -0.00430362f, 0.00274568f, 
    0.01031541f, 0.03479740f, -0.04174247f, 0.02945155f, 0.00946527f, 0.03526491f, -0.06212246f, 0.00053862f, 
    -0.04615521f, -0.04505206f, -0.00152103f, -0.06180128f, -0.03801290f, -0.05051641f, -0.03589320f, 0.00794984f, 
    -0.00280062f, -0.01496762f, -0.00683592f, 0.04017934f, -0.05878592f, -0.00782766f, -0.01107613f, -0.00336629f, 
    -0.01167996f, 0.04306519f, -0.01334445f, -0.01501492f, 0.02567084f, -0.00890990f, -0.00617770f, 0.00855045f, 
    -0.00715254f, 0.02835677f, -0.04420837f, -0.00484397f, -0.06335927f, -0.04250413f, -0.03851722f, 0.04839113f, 
    0.04571467f, -0.02723739f, 0.02818913f, -0.02820776f, -0.01581738f, -0.06598885f, -0.06898526f, 0.00815403f, 
    -0.03833089f, -0.02366714f, 0.03013364f, -0.05197098f, 0.03573181f, -0.05172517f, -0.02178713f, 0.02763979f, 
    -0.03392356f, -0.01986763f, 0.01698128f, -0.01746106f, 0.04669460f, 0.00581207f, -0.04121786f, 0.02124500f, 
    -0.03399490f, 0.00257089f, -0.02944566f, -0.04587079f, 0.01547257f, -0.05621938f, 0.03748475f, -0.02643583f, 
    0.01729853f, 0.00603584f, 0.01591547f, -0.05008945f, 0.02762767f, -0.01401634f, -0.05666244f, -0.00779245f, 
    -0.06150512f, 0.02884066f, 0.03871170f, -0.05757176f, 0.01318308f, -0.04084247f, -0.04647874f, -0.05568937f, 
    0.03181395f, 0.03475052f, -0.05248950f, 0.00327319f, 0.02666840f, 0.01306677f, 0.02395458f, 0.02705881f, 
    -0.03818660f, -0.06335061f, -0.00548245f, -0.07343487f, -0.00725700f, -0.02133957f, 0.03980045f, -0.02504233f, 
    0.02759872f, 0.04590177f, -0.01634954f, -0.01353528f, -0.07147361f, -0.01382473f, 0.02325228f, 0.02104673f, 
    0.01373832f, -0.05522221f, -0.05987538f, 0.02866421f, -0.05839764f, -0.05182546f, -0.03817322f, 0.02134743f, 
    0.01510478f, -0.03205319f, -0.05732716f, -0.04464915f, -0.07233615f, -0.03190358f, -0.04170471f, 0.02354963f, 
    0.00313326f, 0.02240523f, 0.03943399f, -0.01285546f, 0.03540714f, 0.02239056f, -0.00456717f, 0.00932423f, 
    -0.01944091f, 0.05079969f, -0.01088342f, 0.03813127f, -0.04241148f, 0.02464317f, -0.00315248f, -0.03823088f, 
    0.00655894f, -0.06284527f, 0.00496269f, -0.07885485f, 0.02214540f, -0.00920315f, -0.06226088f, -0.03219497f, 
    0.03083344f, 0.01562937f, 0.01521164f, 0.04485867f, 0.03706528f, 0.00391940f, -0.04106456f, -0.02914442f, 
    0.02891826f, -0.06218001f, 0.02662696f, 0.05138161f, -0.05041545f, -0.03563107f, -0.01823444f, 0.01142195f, 
    -0.03049443f, -0.05894672f, -0.02951042f, -0.00492954f, -0.05711146f, -0.00418468f, -0.05870708f, -0.05913232f, 
    -0.04954272f, -0.05984508f, 0.01802861f, -0.02942113f, 0.02419050f, 0.03396402f, 0.00964019f, -0.06886083f, 
    -0.04101878f, 0.00816001f, -0.00509868f, -0.03478343f, -0.05824570f, -0.01510926f, 0.00062277f, -0.03689818f, 
    -0.03410188f, -0.00294195f, 0.00021945f, -0.02003272f, -0.01167990f, 0.03153737f, 0.01919689f, -0.04936597f, 
    -0.02897984f, 0.00348787f, 0.03878784f, -0.01565501f, 0.03227564f, -0.04020498f, -0.00846066f, -0.05991474f, 
    -0.02311828f, 0.03092211f, 0.04165218f, -0.06319467f, -0.02591987f, 0.01638540f, -0.06874368f, -0.02919278f, 
    0.05243290f, -0.04970358f, -0.04379898f, -0.03835109f, 0.02366127f, 0.00817771f, -0.04078761f, 0.04479266f, 
    0.01045633f, 0.01837346f, -0.02957919f, 0.04934043f, -0.02353567f, 0.03955449f, 0.00119390f, 0.03675120f, 
    -0.05278559f, -0.02453919f, -0.04335511f, 0.04098100f, -0.00214213f, 0.03882597f, -0.00913029f, -0.02182315f, 
    -0.03197210f, -0.06298798f, -0.01002043f, 0.01195673f, 0.01745265f, 0.01268481f, -0.02247307f, -0.03497783f, 
    0.00049425f, 0.02619326f, 0.01964840f, 0.02509861f, -0.06076156f, 0.03581956f, -0.00996958f, -0.04779353f, 
    -0.05531769f, -0.00135564f, -0.02420558f, -0.00161495f, -0.04667986f, 0.02053678f, 0.04133686f, -0.03134590f, 
    -0.04620436f, 0.02578865f, 0.00198319f, -0.03292116f, 0.01954429f, 0.04356319f, -0.00538102f, 0.03148607f, 
    0.25154656f, -0.03641551f, -0.22029319f, 0.03282000f, 0.15152960f, 0.11464931f, -0.01917359f, -0.08840144f, 
    -0.14144246f, -0.02573656f, -0.04575765f, -0.18728842f, -0.10116038f, 0.07403377f, -0.05385875f, 0.22375765f, 
    0.15315826f, -0.00153977f, 0.23091693f, 0.32435679f, 0.19942245f, 0.00815147f, 0.14197274f, 0.08225185f, 
    -0.14748909f, 0.00835281f, 0.08786728f, -0.44313750f, -0.17061883f, -0.20951600f, 0.22148129f, -0.16463286f, 
    -0.06001582f, 0.23681384f, 0.00064608f, -0.12850693f, -0.52861309f, -0.35326320f, 0.10235581f, 0.09059536f, 
    -0.00806052f, -0.01813076f, -0.09144046f, -0.17140017f, -0.22046003f, -0.20130950f, -0.20324479f, -0.32797971f, 
    0.00149527f, 0.08953492f, -0.08978700f, 0.11696351f, -0.01627556f, 0.08941343f, -0.24812640f, 0.23990452f, 
    -0.20218231f, -0.21683352f, 0.20088947f, 0.19016132f, -0.33189145f, -0.09457652f, -0.11517732f, -0.38020509f, 
    -0.14820442f, 0.31237563f, 0.11096278f, -0.04694157f, -0.01741343f, 0.11252072f, -0.26600012f, -0.10196020f, 
    0.13081944f, -0.22559763f, 0.12050766f, 0.12466243f, 0.19874018f, 0.13697828f, 0.22991683f, 0.01795785f, 
    0.20765905f, -0.39426109f, 0.08147676f, -0.07430901f, 0.04098257f, 0.05148892f, -0.17682517f, 0.02415358f, 
    0.21781100f, -0.08347117f, -0.66970587f, -0.18907203f, -0.18040653f, 0.14220600f, 0.06211771f, 0.13263707f, 
    0.02474536f, 0.14091608f, 0.02440083f, 0.05709184f, 0.01724888f, -0.11149445f, -0.15854205f, 0.20403315f, 
    0.01868358f, 0.00776114f, -0.09043697f, 0.22031118f, -0.01350932f, -0.15747356f, -0.21869510f, -0.02195702f, 
    -0.12098223f, 0.02011520f, -0.00443191f, -0.08974767f, 0.12136522f, 0.27329165f, 0.04793999f, 0.12577608f, 
    0.07737162f, 0.10195335f, -0.25864536f, 0.05104097f, -0.07870539f, 0.08026060f, 0.28968188f, 0.34361705f, 
    0.17811890f, 0.29818028f, 0.10961413f, 0.01227380f, -0.05351523f, 0.06066538f, 0.30275390f, 0.24943963f, 
    0.18824576f, 0.38228372f, 0.04631410f, 0.08143623f, -0.13522640f, 0.01920567f, -0.09444092f, -0.00496631f, 
    0.21805878f, -0.11144129f, 0.21917595f, -0.01286023f, 0.04404167f, 0.01430599f, 0.16348790f, -0.11008296f, 
    0.08139946f, 0.05527529f, -0.04917916f, -0.32629672f, 0.15559117f, -0.09048256f, 0.07772572f, -0.03239545f, 
    -0.00997556f, 0.17976983f, -0.42581543f, 0.00588050f, 0.31075537f, 0.04549450f, 0.02538201f, -0.13273320f, 
    0.30389720f, -0.06319746f, 0.11973321f, -0.27120218f, -0.07485659f, -0.20922481f, 0.17866668f, 0.09412427f, 
    -0.05192350f, 0.06474026f, -0.04274139f, 0.06323404f, -0.06956141f, -0.00167496f, -0.23825818f, 0.04311818f, 
    -0.16729757f, 0.16890199f, -0.13998896f, -0.00778568f, 0.00910787f, -0.33805755f, 0.03180452f, 0.03140063f, 
    0.32336640f, 0.07892169f, -0.13349809f, -0.03893144f, 0.07054251f, 0.06567521f, -0.13704999f, 0.14076415f, 
    0.15927292f, 0.13016376f, -0.16315377f, -0.10645561f, -0.04403475f, -0.02010810f, 0.06345606f, -0.62723100f, 
    -0.30269706f, 0.07618143f, 0.05186860f, 0.11721826f, -0.02027650f, 0.11003235f, -0.04666156f, -0.14095764f, 
    -0.18170820f, 0.24433291f, 0.12228037f, 0.07193334f, 0.13581127f, 0.09558159f, 0.17165050f, 0.02918030f, 
    -0.22229800f, 0.29280958f, 0.15576081f, 0.31220675f, 0.03545991f, 0.04066977f, -0.11712869f, -0.02070323f, 
    0.05345351f, 0.16504142f, -0.16924231f, -0.10752010f, -0.46556070f, -0.19570696f, -0.14565948f, -0.07174568f, 
    -0.05777586f, 0.23888282f, 0.09024476f, 0.01099019f, -0.00704629f, 0.21399584f, -0.02155998f, 0.21198882f, 
    -0.02246993f, 0.21811473f, -0.24343851f, -0.03558994f, 0.00495594f, -0.14663754f, 0.08167870f, 0.03003772f, 
    0.16017950f, -0.00075456f, -0.05223138f, -0.13645539f, -0.07421938f, -0.16621602f, 0.09165454f, 0.49469995f, 
    0.00144625f, 0.15894549f, 0.27353004f, 0.05801561f, 0.00265294f, -0.10797583f, -0.07613064f, 0.16944548f, 
    -0.11392634f, -0.05828903f, -0.02142978f, -0.00308216f, 0.01691477f, -0.06176021f, -0.09587559f, 0.11848480f, 
    -0.20062003f, -0.04499999f, 0.20288347f, 0.17523733f, 0.00291996f, 0.07005270f, 0.00935208f, 0.01005224f, 
    -0.10494938f, 0.45644242f, -0.24912329f, 0.08471730f, 0.20539688f, 0.03207192f, -0.05244884f, 0.07381534f, 
    0.18779163f, 0.09551383f, -0.17231813f, 0.13716313f, -0.01065950f, 0.02601654f, 0.09660698f, -0.09313365f, 
    0.01574274f, 0.07024181f, 0.12058537f, 0.17045853f, 0.18534532f, -0.02725270f, 0.08741909f, 0.14101918f, 
    0.18623178f, 0.04446947f, 0.19419517f, -0.40401965f, -0.50649762f, 0.12510933f, 0.08030378f, 0.11002313f, 
    0.04424124f, -0.07008062f, 0.04493950f, 0.13140510f, 0.55365008f, -0.10339881f, -0.05239843f, -0.00728046f, 
    -0.13534179f, -0.19937652f, -0.02002336f, 0.19957657f, 0.14005005f, 0.16310297f, -0.22002473f, 0.09947532f, 
    0.09964848f, -0.06707200f, 0.15971939f, 0.05027185f, 0.23249087f, -0.08728369f, -0.11226191f, -0.31300259f, 
    0.05775819f, 0.09581996f, 0.11915725f, 0.21069431f, -0.06929562f, 0.00747411f, 0.00012853f, 0.31578285f, 
    -0.09956760f, -0.00624508f, -0.02713992f, -0.34545285f, 0.06452558f, 0.05354338f, 0.09309115f, 0.02438599f, 
    -0.56262279f, 0.21622497f, -0.02412863f, -0.34024614f, -0.05620016f, -0.22384065f, -0.17542750f, -0.02010788f, 
    -0.08776221f, -0.42041799f, -0.24013948f, -0.00673291f, -0.27988771f, -0.12566626f, 0.10521931f, -0.05910329f, 
    -0.17965689f, 0.33755311f, 0.61654627f, -0.04511680f, -0.28741509f, -0.31314912f, -0.23653316f, 0.16352788f, 
    -0.14356302f, -0.04575064f, 0.01984931f, -0.11369111f, -0.14376085f, 0.03000089f, -0.01983988f, 0.24141759f, 
    0.19437554f, -0.01309206f, 0.07449642f, -0.08349990f, -0.48734209f, -0.19439477f, -0.09272821f, 0.07467873f, 
    -0.07350442f, -0.15595697f, 0.00410096f, -0.10887250f, 0.03225520f, 0.17087896f, 0.10873412f, -0.16721602f, 
    -0.16565505f, 0.11095376f, -0.11690817f, -0.08104847f, -0.02496514f, -0.03392427f, -0.40910810f, 0.00028241f, 
    0.14864999f, -0.01874620f, 0.10597854f, 0.04058471f, 0.04581578f, -0.16496982f, -0.21887067f, -0.51342720f, 
    0.13983360f, 0.18386714f, -0.11704031f, 0.10529701f, 0.20253232f, -0.08338806f, 0.13687991f, -0.20786560f, 
    -0.11880694f, 0.20962648f, -0.11557255f, -0.43742943f, -0.06377489f, 0.11676244f, 0.01762309f, 0.05266746f, 
    -0.05270858f, -0.01053613f, 0.28559920f, 0.18862885f, 0.15937522f, 0.05061759f, -0.02786648f, 0.06988955f, 
    -0.11834086f, -0.07128096f, -0.02461741f, -0.02088125f, 0.07199301f, 0.03310538f, 0.22096753f, -0.11428714f, 
    0.01864187f, 0.04592673f, 0.05441696f, -0.13118364f, 0.11384586f, 0.08246032f, 0.01416120f, 0.13110459f, 
    0.01846808f, -0.01804229f, 0.02867976f, 0.04787817f, 0.32519802f, 0.26610738f, 0.00670016f, 0.05173714f, 
    0.08498049f, 0.02263157f, 0.04603841f, -0.07276326f, -0.01918356f, 0.18318033f, 0.15173659f, -0.14877768f, 
    0.03913147f, -0.17733884f, 0.22343770f, 0.03348224f, -0.12473296f, 0.24134438f, 0.02190985f, -0.20338179f, 
    0.24151014f, 0.14937176f, 0.12050802f, -0.12045649f, -0.04628198f, 0.15433392f, 0.14773451f, 0.11888657f, 
    -0.41190827f, -0.36179250f, 0.01237896f, -0.10525265f, -0.02018038f, 0.11237352f, 0.18103819f, 0.09337789f, 
    -0.09682926f, 0.20839462f, -0.04791478f, 0.09119930f, 0.13387920f, 0.02935739f, -0.09062545f, 0.20224011f, 
    0.31045243f, -0.20910117f, 0.16059670f, 0.33401123f, -0.08983354f, 0.16055988f, 0.01941317f, -0.00572993f, 
    0.00675309f, -0.21968135f, 0.30395284f, -0.55750686f, -0.22802557f, -0.11662981f, -0.08399943f, -0.01804989f, 
    0.15608865f, 0.01946734f, -0.16691598f, -0.13370259f, -0.10254015f, -0.20865528f, 0.10995688f, 0.14443138f, 
    0.16769917f, 0.01527695f, 0.23468854f, 0.10565056f, 0.13263775f, 0.17513096f, -0.02235536f, 0.01546142f, 
    0.12309524f, 0.23253149f, 0.03973340f, 0.03753441f, -0.01497613f, -0.12667556f, 0.01451647f, -0.07720896f, 
    -0.08692721f, -0.20059593f, -0.16916306f, -0.00988034f, 0.00295338f, -0.21193360f, 0.27195609f, 0.20799263f, 
    -0.20815751f, -0.01518658f, 0.06657659f, 0.04813862f, 0.00705327f, -0.01324452f, -0.07347530f, 0.34365788f, 
    -0.14042968f, -0.45659140f, 0.11554480f, 0.26794362f, -0.06678547f, 0.22676952f, -0.10317709f, -0.17849000f, 
    -0.12098712f, 0.04310799f, 0.06360897f, 0.05778268f, 0.21668451f, 0.25387776f, -0.00551363f, 0.11955683f, 
    -0.14922696f, 0.15471576f, 0.28059664f, 0.18537758f, 0.14090639f, -0.25824410f, -0.19694078f, -0.21599120f, 
    0.10373376f, 0.37788874f, -0.45736286f, 0.25214851f, 0.21857560f, 0.14668708f, 0.21849899f, 0.08011304f, 
    -0.21554707f, 0.12049345f, -0.01179127f, -0.17195310f, 0.06646618f, -0.06680726f, 0.11130974f, 0.07934868f, 
    0.16676803f, 0.19028525f, 0.08740553f, 0.22324809f, 0.18042858f, 0.14350557f, 0.18964662f, -0.08758373f, 
    -0.10573819f, 0.02370793f, 0.19307028f, 0.03203961f, 0.11199047f, 0.21875809f, 0.17321286f, -0.14558803f, 
    -0.11283693f, 0.12040077f, -0.06066585f, 0.13067932f, 0.09375835f, -0.33842129f, -0.06246968f, -0.02484457f, 
    0.14380702f, -0.06985945f, -0.00721439f, 0.02425125f, -0.06811940f, -0.01307250f, 0.00630302f, 0.30715683f, 
    0.04305314f, -0.12692246f, 0.07525106f, 0.08054749f, -0.16052186f, 0.02001435f, 0.17694868f, 0.06342889f, 
    -0.57812649f, -0.28013429f, 0.12288325f, 0.22394532f, 0.08505318f, -0.07946728f, -0.18205008f, 0.01643612f, 
    0.04623593f, -0.01694404f, 0.15536681f, 0.19011088f, 0.19414297f, -0.07383226f, -0.04324990f, -0.19814873f, 
    0.01295593f, -0.03750468f, 0.32140353f, 0.20159896f, -0.09321031f, -0.08581990f, 0.00303716f, 0.01547028f, 
    0.06956964f, -0.01850360f, 0.03102306f, 0.04121341f, -0.01616856f, 0.08311511f, 0.10691632f, 0.11290658f, 
    -0.08770459f, 0.04085245f, -0.08655702f, 0.27971923f, -0.60405684f, -0.25271755f, -0.24273156f, -0.04502083f, 
    -0.07334730f, -0.00560349f, -0.08075499f, -0.25040615f, 0.15945500f, -0.29672152f, 0.01816333f, 0.11213325f, 
    0.23914717f, -0.04149193f, 0.05532016f, -0.20689677f, 0.08910343f, -0.16526978f, 0.25753909f, 0.11200082f, 
    0.28683180f, 0.05363383f, 0.20267458f, 0.05382657f, 0.04587272f, 0.22679828f, -0.11831339f, -0.25140288f, 
    -0.21371169f, 0.16624172f, -0.23679698f, -0.10761756f, -0.17842107f, 0.08119869f, -0.09480641f, 0.22999507f, 
    -0.61779928f, -0.06837125f, 0.19458413f, 0.12335523f, -0.05410944f, 0.04112439f, 0.11841983f, 0.01793750f, 
    0.00696717f, 0.18158899f, 0.00177445f, -0.04075224f, 0.00738886f, 0.02181584f, 0.36247224f, -0.02445585f, 
    -0.01393569f, 0.13876346f, 0.05496671f, -0.24615702f, -0.19260713f, 0.11598913f, -0.05994308f, -0.17552595f, 
    -0.22039236f, -0.07818764f, 0.21559764f, 0.22911952f, 0.07784458f, -0.52966225f, 0.09383787f, 0.10867861f, 
    0.06552808f, 0.14912817f, -0.11313280f, 0.02854334f, 0.06480135f, -0.05187935f, 0.03323591f, 0.07135776f, 
    0.11911399f, -0.00838200f, -0.20685445f, -0.09477926f, 0.12067208f, -0.02824169f, -0.14434014f, 0.30839238f, 
    0.21428411f, 0.10662736f, -0.08742436f, 0.04429068f, 0.04781225f, -0.08787826f, -0.40723935f, -0.29446432f, 
    -0.36595088f, -0.03878171f, -0.11447246f, -0.03580836f, 0.15851399f, -0.08833983f, 0.00976642f, -0.02078667f, 
    -0.08549819f, -0.26139379f, -0.03467543f, -0.00379938f, 0.04992545f, 0.12969236f, 0.00197912f, -0.21141450f, 
    0.14676385f, 0.07375748f, 0.10688740f, 0.26015162f, -0.05352869f, 0.24535917f, -0.37986705f, 0.09806217f, 
    0.02350291f, -0.62872869f, -0.20792520f, 0.13175237f, 0.17105418f, 0.13526794f, 0.06406438f, 0.07176561f, 
    -0.13045256f, 0.11093727f, 0.01932199f, -0.07709753f, -0.02984259f, -0.09482870f, -0.22250131f, -0.11643834f, 
    -0.08005829f, 0.02828048f, 0.07731404f, 0.30405501f, -0.11899863f, -0.26666600f, 0.10244149f, 0.10880657f, 
    0.01721431f, -0.03970039f, -0.05774274f, 0.07257226f, 0.11109668f, 0.21417890f, 0.18077995f, -0.28330365f, 
    0.09609810f, -0.13200170f, -0.05079518f, 0.26810282f, -0.07165769f, -0.24163204f, -0.15671518f, -0.09427893f, 
    0.26182538f, 0.01515739f, -0.01810876f, -0.15612456f, 0.04926596f, 0.01300282f, 0.23567557f, -0.07076668f, 
    -0.28037858f, -0.00985277f, -0.10585205f, -0.09449678f, 0.05112391f, -0.19647527f, -0.03466459f, 0.19537270f, 
    -0.04506847f, -0.17161097f, 0.18917564f, 0.03031711f, -0.13151063f, 0.18243332f, -0.16429351f, -0.07396192f, 
    0.08860260f, 0.33743444f, -0.01104596f, 0.15442865f, 0.16642235f, 0.12729418f, -0.01595016f, -0.04462319f, 
    -0.09318415f, 0.29753846f, -0.06706949f, -0.33156523f, -0.23228338f, 0.07958312f, -0.17941117f, 0.02155685f, 
    0.10943207f, -0.07552619f, -0.27106261f, -0.13097654f, -0.25510678f, 0.17787430f, 0.08220227f, 0.05051899f, 
    -0.08666656f, 0.12929755f, 0.09529434f, 0.26809970f, -0.13431805f, -0.04918056f, 0.12684380f, -0.05046187f, 
    0.06903178f, -0.02071408f, 0.14736009f, 0.20520616f, 0.30490837f, 0.07054685f, 0.36465567f, -0.15403059f, 
    -0.04072189f, -0.03723434f, 0.15521386f, 0.02365649f, 0.02186143f, 0.29237601f, 0.34544528f, -0.08149628f, 
    -0.15289593f, -0.33583558f, 0.28202105f, -0.04247740f, 0.07492525f, 0.20127165f, 0.24221075f, -0.07749978f, 
    -0.57903695f, -0.17392108f, -0.01621442f, -0.06872774f, -0.27259588f, -0.06237390f, -0.11064334f, 0.32075751f, 
    0.07012025f, 0.57910180f, -0.17550038f, -0.25580934f, 0.06695047f, 0.15322565f, 0.09395345f, -0.06287798f, 
    -0.13159512f, 0.14471565f, -0.05100068f, 0.08588213f, 0.09648541f, 0.10896404f, 0.02623380f, 0.00792603f, 
    -0.18701220f, -0.02496466f, -0.05729294f, 0.36933157f, -0.04005345f, -0.22537751f, -0.10228570f, 0.24098465f, 
    0.29307881f, 0.06819818f, 0.39632112f, 0.27893710f, 0.28554946f, -0.11966775f, -0.02693994f, 0.06799038f, 
    -0.06777607f, -0.17981032f, 0.19214350f, -0.25673774f, -0.10774962f, 0.10420645f, -0.05666839f, 0.05308506f, 
    0.02170387f, 0.06324086f, -0.05845762f, -0.00539173f, -0.35004708f, -0.09316278f, -0.36156261f, 0.10909739f, 
    -0.04251777f, 0.08408548f, -0.14765996f, 0.07178196f, -0.03341805f, -0.15067580f, 0.27460787f, -0.32680720f, 
    0.17794979f, 0.36448258f, -0.04289309f, -0.21998636f, -0.07564791f, -0.16193402f, 0.11945371f, 0.12140393f, 
    0.09721831f, 0.17217636f, -0.01249711f, 0.25402761f, 0.19039819f, 0.32758379f, 0.19301234f, 0.28809169f, 
    -0.16735546f, 0.03715993f, 0.07834665f, -0.05849059f, 0.13337751f, -0.17073086f, 0.09138643f, 0.17549878f, 
    0.13722338f, 0.01452578f, 0.15560475f, 0.07901091f, 0.12066112f, 0.10118671f, 0.15532938f, 0.03889881f, 
    -0.09164307f, -0.22914186f, 0.03233583f, 0.02782080f, -0.07821687f, 0.10634421f, -0.02504933f, 0.08208264f, 
    0.13550949f, -0.14499937f, 0.09808898f, 0.09216557f, -0.25062051f, 0.09956688f, -0.13926519f, -0.00669310f, 
    0.15101460f, 0.08421916f, 0.03751910f, -0.08258662f, 0.47994715f, 0.04080372f, -0.04206918f, 0.02124923f, 
    -0.06604724f, -0.24344277f, 0.03409187f, 0.03416201f, -0.41546646f, -0.02410598f, 0.00887557f, 0.00609966f, 
    -0.04005160f, -0.08408719f, -0.02394015f, -0.14125818f, -0.15749569f, 0.19554038f, 0.29200795f, 0.05824577f, 
    -0.25752673f, -0.03918335f, 0.00816934f, 0.10630529f, 0.14363195f, 0.21388251f, 0.42261776f, -0.30551153f, 
    -0.20960250f, 0.00790013f, 0.05774629f, -0.12464970f, 0.02773653f, 0.05087054f, -0.12659712f, 0.17026979f, 
    0.26468176f, -0.16276340f, -0.24638139f, -0.23181683f, -0.03865508f, 0.20102163f, 0.00624471f, 0.13524084f, 
    -0.35301292f, -0.13705528f, -0.32976064f, 0.10870035f, -0.07410384f, -0.18255839f, 0.24897604f, 0.19225618f, 
    -0.10208678f, -0.04670817f, -0.04425825f, -0.08517225f, 0.10231310f, 0.21328239f, 0.04393528f, -0.12237539f, 
    0.14524895f, -0.07094426f, -0.17886482f, -0.31185362f, -0.16146995f, -0.10717483f, 0.02280116f, -0.20909101f, 
    0.12240631f, -0.06781857f, 0.37685952f, -0.05370580f, -0.59711426f, -0.18980332f, -0.20886716f, 0.11615398f, 
    -0.10215963f, 0.04609007f, 0.05491927f, 0.05121317f, -0.08552804f, -0.13192250f, 0.44840783f, -0.31333154f, 
    -0.22642915f, -0.39217544f, -0.13684647f, 0.17456833f, -0.01030498f, 0.10726178f, 0.21939439f, 0.02410607f, 
    0.13505055f, 0.08268924f, 0.00624038f, -0.01286042f, -0.09025674f, -0.18538241f, 0.39070284f, -0.11356664f, 
    -0.47786161f, -0.16358681f, 0.00814543f, -0.08434819f, -0.02827038f, -0.11715496f, -0.03008975f, 0.50546443f, 
    0.05476890f, -0.12590162f, -0.13792433f, -0.02030103f, 0.18585458f, -0.04657588f, 0.03949352f, 0.02260659f, 
    -0.03621855f, 0.00116086f, -0.01514947f, -0.00372347f, -0.03405539f, 0.01575227f, 0.03256132f, 0.04758139f, 
    -0.05644920f, 0.02428125f, -0.04550797f, -0.01264786f, -0.00408545f, 0.02571076f, -0.02804221f, -0.02945645f, 
    -0.05449608f, 0.04408196f, 0.00995455f, -0.04753305f, 0.05770897f, 0.00912076f, 0.03320426f, -0.01704501f, 
    0.01918178f, -0.05669252f, -0.03721594f, -0.01015627f, -0.01839539f, -0.05604297f, -0.03792872f, -0.05549371f, 
    0.00562190f, -0.05432537f, 0.03785487f, 0.00212155f, -0.00946478f, -0.01788162f, 0.00891009f, 0.00680689f, 
    0.00349910f, 0.00757239f, 0.03220229f, 0.00811358f, -0.01544924f, 0.01939986f, -0.01216962f, -0.02361070f, 
    -0.00725450f, -0.03818977f, 0.02930769f, -0.00823495f, -0.06557749f, 0.02005407f, -0.05800734f, 0.03390576f, 
    -0.01868826f, -0.03074633f, -0.02484199f, 0.01532207f, -0.04587135f, 0.04481420f, -0.05282621f, -0.04798337f, 
    0.02654432f, 0.01789011f, -0.05876985f, 0.04285008f, -0.04734407f, -0.05086542f, 0.04371933f, 0.04790779f, 
    -0.00902179f, -0.03462960f, 0.00787973f, -0.02711730f, 0.01840819f, 0.02150076f, -0.04523859f, 0.04682212f, 
    -0.04308385f, -0.05528563f, 0.00864810f, -0.03685123f, -0.00755254f, -0.03817705f, 0.04648703f, -0.04482317f, 
    -0.05237987f, 0.00796449f, -0.02241834f, -0.02646773f, -0.01317319f, -0.03514133f, -0.03054855f, -0.03067375f, 
    0.02400358f, 0.00877137f, -0.00260198f, -0.06095238f, 0.01966275f, -0.05435415f, -0.06274625f, -0.02917363f, 
    0.01651011f, -0.04043551f, -0.02728080f, -0.06177973f, 0.04251586f, 0.01018825f, -0.03405916f, -0.00627132f, 
    -0.05654527f, -0.04198349f, 0.02058015f, -0.06532987f, -0.05949936f, 0.02444216f, 0.01805810f, 0.00610973f, 
    -0.02688373f, -0.03939326f, 0.00246313f, -0.04887079f, 0.01504319f, -0.01008621f, -0.04558619f, -0.03867687f, 
    -0.01451278f, -0.00272612f, -0.05665748f, 0.01074561f, 0.05040413f, 0.03339773f, 0.04750501f, -0.02745694f, 
    -0.05120461f, -0.04566186f, -0.04633017f, -0.04355089f, 0.00253291f, -0.06467418f, -0.05838165f, 0.04071619f, 
    0.03237223f, -0.01734052f, 0.04858467f, 0.02018677f, -0.05319050f, -0.04098254f, -0.00916798f, 0.00932397f, 
    -0.00650245f, -0.03885929f, 0.02654214f, 0.00157426f, -0.04496267f, -0.05219734f, -0.04194964f, -0.03634341f, 
    -0.01848631f, -0.00064676f, -0.01799346f, -0.01572536f, 0.00399754f, -0.05197084f, -0.03371905f, 0.01120928f, 
    0.04088121f, -0.01738575f, -0.01614661f, 0.00662981f, -0.04506195f, 0.00071421f, -0.05660616f, -0.02153337f, 
    -0.03918676f, -0.05494887f, 0.03748733f, 0.00767494f, -0.04655018f, -0.02418933f, -0.01646936f, -0.02724203f, 
    -0.00481904f, 0.01243687f, 0.02512782f, -0.01129931f, -0.01854248f, -0.00868659f, -0.02150127f, 0.00491042f, 
    -0.01178953f, 0.04143711f, 0.01750438f, -0.04922997f, 0.04148193f, -0.01110693f, -0.00664277f, -0.01126121f, 
    -0.02834853f, -0.01079878f, 0.04429624f, -0.01929843f, -0.04335727f, -0.02026216f, 0.00241064f, -0.00185465f, 
    0.04381587f, 0.00457264f, -0.04504276f, -0.00652089f, -0.03787653f, 0.00177368f, -0.00852465f, 0.01745401f, 
    0.01814027f, -0.03341596f, -0.05986678f, 0.03048391f, 0.02731565f, -0.03819784f, -0.01475926f, -0.06221263f, 
    -0.02842898f, -0.01012505f, -0.03641970f, -0.00371632f, 0.04276512f, -0.03548820f, -0.05834761f, -0.01873760f, 
    -0.00554095f, -0.05745690f, -0.02559654f, 0.00975784f, -0.01458897f, 0.00768984f, -0.00665058f, -0.00383429f, 
    0.02925641f, 0.01559669f, -0.05033500f, -0.02102620f, -0.04728117f, -0.00193688f, 0.00254341f, -0.03194103f, 
    -0.03954080f, -0.02171934f, -0.02460337f, -0.03362625f, 0.04601927f, -0.00183608f, 0.05106482f, -0.03258640f, 
    -0.00420396f, -0.04226933f, 0.01093763f, -0.02506185f, -0.00348600f, -0.02289264f, -0.00701731f, -0.03928806f, 
    0.00683083f, -0.05059709f, -0.02199881f, -0.04589953f, -0.03099849f, 0.01980400f, -0.00291007f, 0.00233869f, 
    -0.02157151f, -0.00458300f, -0.02183541f, 0.04382434f, 0.02539459f, -0.00140518f, -0.05957488f, 0.04911817f, 
    -0.06130203f, -0.05379839f, 0.04069665f, 0.00563527f, -0.03498188f, 0.04451333f, -0.00361104f, -0.06506870f, 
    0.33876839f, 0.23606338f, -0.28558394f, -0.16619593f, 0.12606324f, 0.16080913f, -0.03764187f, -0.22488260f, 
    0.11468489f, -0.25938454f, -0.23381838f, 0.03432843f, -0.15452552f, 0.20461912f, 0.09951313f, 0.03996514f, 
    0.06223471f, -0.03685975f, -0.01986817f, 0.09258494f, -0.01532159f, -0.03880770f, 0.01938591f, -0.06372253f, 
    -0.11958805f, 0.10378206f, -0.04324359f, -0.37737799f, -0.10799783f, -0.19536114f, 0.22438544f, 0.05152682f, 
    0.01613423f, -0.07524291f, -0.10672940f, 0.01084147f, -0.25439724f, -0.23869368f, -0.27291223f, -0.07763059f, 
    0.05941734f, -0.11285436f, 0.11812934f, -0.05784585f, -0.01089610f, 0.12920302f, -0.30739844f, -0.30956873f, 
    0.21207398f, 0.01477380f, -0.16526346f, 0.10096540f, 0.03203770f, -0.11935008f, -0.07752182f, -0.14349383f, 
    0.04954204f, 0.01779708f, 0.16403484f, -0.03149976f, 0.10067826f, -0.04771584f, -0.07643919f, 0.17186034f, 
    0.20308147f, -0.38742110f, 0.16494931f, -0.02745009f, 0.06849952f, -0.15648347f, 0.02922047f, -0.04454936f, 
    0.29667091f, 0.32255739f, 0.06564331f, -0.04019722f, -0.13874139f, -0.00841674f, 0.10110199f, -0.04895619f, 
    -0.10330725f, -0.86335880f, 0.29881182f, -0.27063644f, -0.16321932f, 0.03242579f, 0.01142543f, -0.12530251f, 
    0.03788861f, -0.13124366f, -0.11589647f, -0.19430867f, -0.18917631f, -0.08683833f, 0.04602338f, -0.02049598f, 
    -0.00984726f, -0.12736213f, -0.13624518f, 0.15156452f, -0.02676804f, -0.14057192f, -0.07787781f, 0.04008064f, 
    0.16500627f, 0.10199796f, 0.02787094f, 0.03962790f, 0.09730776f, 0.15962964f, 0.25940257f, 0.06737402f, 
    0.02720092f, 0.16755927f, 0.07462109f, 0.13611248f, 0.10549679f, 0.05026554f, 0.25198218f, -0.13263601f, 
    0.01518344f, -0.05955538f, 0.24479760f, 0.16429786f, 0.15330727f, -0.10226218f, 0.03564164f, 0.10049234f, 
    0.09513373f, 0.04441939f, 0.11049231f, 0.09859627f, -0.14232725f, 0.18275480f, -0.02411469f, 0.11851230f, 
    0.11697686f, 0.21158223f, 0.15193793f, -0.01729419f, 0.02265458f, -0.10595726f, -0.03160641f, -0.03433892f, 
    0.01788463f, 0.02058115f, 0.07609490f, -0.01463506f, 0.00130246f, -0.03014596f, 0.14493239f, 0.14428426f, 
    0.07342719f, -0.29435629f, 0.00329491f, -0.11051133f, -0.03470995f, -0.14059138f, -0.15647693f, -0.06358823f, 
    0.05894646f, -0.07360829f, 0.02119249f, -0.29367888f, 0.48086300f, -0.05071745f, -0.11441315f, 0.10751149f, 
    -0.26275110f, 0.19355361f, 0.01059249f, 0.03451008f, -0.17763157f, 0.07473007f, -0.08409601f, -0.03561385f, 
    -0.05429123f, -0.11135772f, 0.00872973f, -0.03259316f, 0.48498255f, 0.16433303f, -0.24666958f, -0.18160926f, 
    0.05579044f, 0.07653279f, 0.16096832f, 0.09819443f, 0.02929163f, 0.31172532f, 0.30029324f, -0.30776599f, 
    0.08046904f, 0.02015751f, -0.11191887f, 0.14485770f, -0.09454738f, -0.09327158f, 0.16371648f, 0.04799158f, 
    0.37685451f, 0.15315522f, -0.12741239f, -0.06383707f, 0.09882051f, 0.00152767f, 0.19764854f, -0.09463083f, 
    -0.49903455f, -0.21244055f, 0.04814441f, -0.03482439f, -0.04429661f, 0.14564976f, 0.02535615f, -0.14904359f, 
    0.12174959f, -0.08707003f, -0.32156530f, -0.03164561f, 0.01607146f, 0.22741485f, -0.25452781f, -0.03925253f, 
    0.16018859f, 0.19960262f, 0.20266536f, 0.16760541f, 0.02322047f, -0.03782002f, -0.00728795f, -0.03184310f, 
    0.04296028f, -0.03683403f, 0.03390349f, -0.17781164f, -0.27417183f, 0.33978844f, 0.01469579f, 0.20469761f, 
    0.31503040f, 0.04495898f, 0.02677418f, -0.13130407f, -0.30641493f, -0.08892938f, 0.02581308f, -0.00740550f, 
    0.07356913f, 0.06870309f, 0.14058284f, 0.01234270f, -0.49319729f, 0.27945301f, -0.18024015f, -0.07720219f, 
    0.08971034f, 0.14242439f, 0.07770890f, 0.01945869f, -0.15479703f, 0.41651213f, 0.16312508f, -0.08998898f, 
    -0.00465677f, 0.08228734f, 0.04764076f, -0.07849342f, -0.02572052f, -0.12157676f, 0.22556740f, -0.10289688f, 
    0.00534759f, 0.04172502f, 0.01277675f, 0.08289941f, -0.03514847f, 0.27894711f, -0.04795437f, -0.33892149f, 
    -0.30191845f, 0.14188927f, -0.18890359f, -0.08652037f, -0.14057381f, 0.03361859f, -0.09133486f, 0.06830692f, 
    -0.01107448f, 0.05009622f, -0.03654518f, -0.02153008f, -0.04982718f, 0.03776713f, -0.05840976f, -0.05023304f, 
    0.04733589f, -0.04400389f, 0.00633433f, -0.03290506f, 0.04942452f, 0.02569152f, 0.00073200f, -0.05368476f, 
    0.02797767f, -0.02771625f, 0.00600470f, 0.01289797f, -0.06033375f, 0.02000897f, 0.01972612f, 0.00780389f, 
    -0.05778541f, -0.04659005f, -0.03817473f, 0.03306953f, -0.01034792f, -0.02347811f, -0.05471043f, -0.04990924f, 
    -0.05575267f, 0.04879186f, -0.04089307f, 0.04482040f, -0.04333393f, 0.03103638f, 0.03283715f, 0.02515891f, 
    -0.06791708f, 0.04208546f, 0.01532829f, 0.00835172f, -0.01525665f, -0.03714433f, -0.02744104f, 0.01541697f, 
    -0.02499389f, -0.04047056f, -0.01167907f, -0.00230524f, -0.05763303f, -0.05727518f, 0.00209619f, -0.04770617f, 
    0.02679333f, 0.04838335f, -0.05742390f, 0.03686244f, 0.05313230f, 0.00935802f, 0.04607791f, 0.01023159f, 
    0.02512876f, -0.02338181f, -0.05993563f, -0.04447860f, -0.00634000f, 0.02339324f, -0.06488492f, -0.04645305f, 
    -0.01225971f, 0.03337622f, 0.01102462f, -0.00834743f, 0.03027182f, 0.01554691f, 0.02619861f, 0.01284961f, 
    -0.05583934f, -0.04560304f, -0.02628945f, 0.00303475f, -0.01896180f, -0.03521472f, -0.00266656f, -0.01928460f, 
    -0.06732216f, -0.00961446f, 0.01348649f, 0.03297742f, -0.01934254f, -0.05758100f, -0.02632850f, 0.01892195f, 
    -0.01837246f, -0.04192517f, -0.04842974f, 0.02902951f, 0.01621342f, 0.02314873f, -0.02838870f, 0.00163570f, 
    0.00155869f, 0.01250153f, -0.06349029f, -0.03635340f, 0.00007132f, -0.05028406f, 0.05333273f, -0.00968860f, 
    -0.05309316f, 0.03575719f, 0.01060018f, 0.00171600f, -0.04495819f, 0.04700402f, 0.00062241f, -0.06089839f, 
    0.03103080f, 0.03565001f, -0.03762683f, 0.04474496f, 0.00105792f, -0.04220620f, -0.01640740f, 0.02971199f, 
    -0.04064430f, -0.02717477f, 0.03906102f, 0.04363034f, 0.05155441f, 0.00250282f, 0.01603961f, 0.02659647f, 
    0.02367985f, -0.02312021f, -0.03892088f, 0.01739982f, -0.00047993f, -0.02794221f, 0.04883087f, -0.01713436f, 
    -0.03085490f, -0.05786425f, 0.00672231f, 0.05059890f, -0.02367812f, 0.01336887f, -0.03022893f, -0.05055129f, 
    -0.04414140f, -0.00927404f, 0.03250061f, -0.05500531f, -0.05555966f, -0.02066886f, -0.02281114f, -0.04798797f, 
    0.01333762f, -0.02477189f, -0.00853218f, 0.02735748f, -0.02926981f, 0.02254394f, -0.03134052f, -0.02979158f, 
    0.03243698f, -0.02716419f, -0.04653946f, -0.05981773f, -0.01557100f, -0.02031647f, 0.01626908f, -0.05905114f, 
    -0.05354561f, 0.03965808f, 0.00051003f, -0.01597203f, 0.02481726f, -0.00224620f, 0.01490414f, -0.06586669f, 
    0.00613504f, 0.01200821f, 0.04033133f, -0.01951675f, -0.03332416f, -0.03587901f, -0.00658981f, 0.01173910f, 
    -0.05630153f, 0.03135975f, -0.04429536f, 0.04868983f, -0.06067935f, -0.06592231f, 0.00474431f, -0.04946690f, 
    0.02340579f, 0.00506975f, 0.01545877f, -0.02300392f, -0.05529752f, 0.01361569f, -0.05446169f, -0.01910299f, 
    -0.05711419f, -0.02643668f, 0.02780077f, -0.01974804f, 0.02076792f, -0.03046217f, -0.01266855f, -0.06366289f, 
    -0.04564364f, -0.06160185f, -0.01549753f, -0.02347032f, 0.01341601f, -0.03399452f, -0.05796720f, -0.04586883f, 
    -0.03674590f, -0.02953778f, -0.06358687f, -0.03674619f, -0.02026928f, -0.04828801f, -0.04572152f, -0.03444437f, 
    -0.03317383f, -0.03303500f, -0.05237727f, -0.03596938f, 0.04632514f, -0.04922711f, 0.02661760f, -0.02394584f, 
    0.03211188f, 0.02167849f, 0.00468943f, -0.05048236f, -0.04268742f, 0.00119782f, -0.06315485f, -0.00903319f, 
    0.00477616f, 0.02204468f, -0.00754835f, 0.04720269f, 0.00529042f, -0.01776765f, -0.03143879f, 0.03526340f, 
    -0.04326281f, 0.03862706f, -0.05513122f, -0.05520995f, -0.01421267f, -0.05277757f, 0.00098698f, -0.01942677f, 
    -0.03086563f, 0.02604710f, -0.02783916f, 0.03759879f, 0.04741956f, -0.00517645f, -0.04952861f, 0.01581655f, 
    -0.05578868f, -0.03814654f, -0.03367871f, -0.01970011f, 0.00495960f, -0.04410089f, -0.01434188f, 0.01447433f, 
    0.03098108f, -0.05443100f, 0.02970314f, -0.00559099f, -0.01272847f, -0.04170139f, 0.02131217f, 0.05085632f, 
    -0.08187743f, -0.11220893f, 0.07882530f, 0.09322510f, 0.01537609f, 0.11291862f, -0.00534686f, -0.19979122f, 
    -0.06998818f, -0.24575734f, -0.40791550f, 0.00800625f, -0.01866720f, 0.02489972f, 0.17383759f, -0.11669724f, 
    -0.10106447f, 0.14811613f, 0.23119868f, -0.04578506f, 0.24334440f, -0.06606326f, -0.03601384f, 0.02251314f, 
    -0.14668362f, 0.04432439f, 0.03363818f, -0.13891189f, 0.22516645f, 0.08475616f, 0.01812767f, -0.08290964f, 
    -0.30949682f, 0.00731400f, 0.18749601f, 0.15419136f, 0.06932837f, 0.00799283f, -0.09263746f, 0.03015240f, 
    0.03512787f, 0.06405832f, 0.02111096f, -0.31177503f, -0.03889957f, 0.20471239f, 0.15980691f, -0.19462749f, 
    0.03471897f, 0.01256234f, -0.22481072f, -0.00318164f, -0.08913705f, -0.14148669f, -0.28829113f, -0.44776127f, 
    -0.05120881f, 0.21253040f, -0.06254357f, 0.14322861f, 0.09046652f, -0.00111900f, -0.34388039f, 0.26676852f, 
    -0.25032237f, -0.27580994f, -0.06259005f, -0.07887479f, -0.01484345f, 0.09384859f, 0.00244475f, -0.03241935f, 
    0.05747689f, 0.08768368f, -0.14063436f, -0.06754629f, -0.01999306f, -0.10537077f, -0.04984508f, 0.22790942f, 
    0.15470746f, -0.08507150f, 0.12348363f, -0.14108437f, 0.32481688f, -0.04387025f, -0.12452686f, 0.18621720f, 
    -0.14524268f, 0.15211953f, 0.02225274f, 0.29176304f, -0.34029907f, 0.01381135f, 0.09270149f, -0.06314204f, 
    0.02719170f, -0.00666377f, 0.02640294f, 0.07419963f, 0.16894911f, 0.11395693f, -0.09700973f, 0.07755445f, 
    0.12562954f, 0.16334167f, 0.07776597f, 0.06805996f, -0.04821084f, 0.16095339f, 0.02433952f, 0.22713901f, 
    -0.18796933f, 0.22794294f, 0.03727385f, 0.18075512f, -0.03473246f, 0.16894434f, 0.06210319f, 0.05992699f, 
    0.12172999f, -0.34384555f, -0.06122340f, -0.06643646f, -0.00023877f, 0.01887342f, 0.07764443f, -0.01639030f, 
    0.20592126f, -0.02898401f, -0.01187062f, -0.17158921f, 0.14490703f, 0.12689073f, 0.12430336f, 0.37519419f, 
    0.01007945f, -0.19095783f, 0.17617790f, -0.34074724f, -0.29281193f, -0.00827177f, 0.41570154f, 0.20413557f, 
    0.21610455f, 0.11173344f, -0.08257005f, -0.02278168f, -0.01196838f, -0.23411241f, 0.12000612f, -0.00276534f, 
    0.13258272f, -0.14607035f, -0.25806460f, 0.11413980f, 0.26345912f, 0.06369972f, 0.25384232f, -0.05270825f, 
    -0.10723704f, 0.06578176f, 0.12178685f, -0.01304279f, -0.48629466f, 0.05596407f, 0.05073447f, -0.18274543f, 
    0.03291496f, -0.11879516f, 0.22411375f, -0.16554192f, 0.00938993f, -0.23875928f, -0.14180224f, 0.20526882f, 
    0.06298487f, 0.21852186f, -0.14479944f, -0.08155681f, -0.00190103f, -0.18397389f, -0.05177576f, 0.11088581f, 
    -0.08096598f, 0.11424419f, 0.07073969f, 0.09291613f, 0.18592474f, 0.06196243f, 0.14718634f, -0.15538800f, 
    -0.03906779f, -0.03469483f, -0.19528319f, 0.30863768f, -0.20338035f, -0.15956950f, -0.06559775f, -0.03504498f, 
    -0.25662139f, 0.10355780f, 0.21029875f, 0.09619327f, -0.11909780f, -0.14065643f, 0.08108898f, 0.29500890f, 
    -0.09891420f, -0.37453923f, 0.05509677f, 0.01402185f, 0.08158302f, 0.10650381f, -0.18302591f, -0.13645513f, 
    -0.20474647f, 0.10584296f, -0.01664119f, 0.10117182f, 0.04058236f, 0.31108290f, -0.08017512f, -0.02311311f, 
    0.11029823f, 0.43840653f, -0.07413092f, 0.06453756f, 0.00632837f, -0.14315255f, 0.02589701f, 0.11026394f, 
    0.12179848f, 0.12801151f, -0.06893075f, 0.07264805f, 0.20770857f, 0.05945020f, 0.13580944f, -0.09799175f, 
    -0.10563828f, 0.10961788f, 0.03231524f, -0.20380504f, -0.16042753f, -0.03798578f, 0.19202836f, 0.01055143f, 
    0.03584558f, -0.00878989f, -0.07878233f, -0.09552691f, -0.12528940f, 0.09243341f, 0.25392127f, 0.30283263f, 
    0.00989274f, 0.02766016f, 0.08730126f, 0.04641876f, -0.22888939f, 0.04638180f, -0.33662221f, -0.29975495f, 
    -0.03095768f, -0.16859052f, 0.17016065f, 0.03383534f, 0.24153481f, 0.25332546f, -0.05654081f, 0.00765086f, 
    0.20374672f, -0.00532822f, 0.12856212f, 0.26412356f, 0.11958180f, -0.03505557f, 0.00044576f, 0.00798542f, 
    0.10748252f, -0.03068477f, 0.22197130f, 0.05392862f, -0.17799346f, 0.08842432f, -0.00493463f, 0.09512539f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.08432198f, -0.06195945f, 0.04903748f, 0.04331108f, 0.02308353f, 0.00758785f, 0.18452953f, 0.09116720f, 
    -0.00251284f, 0.02610380f, 0.03777639f, -0.00748038f, -0.02557915f, -0.01499896f, -0.17620336f, 0.00983595f, 
    -0.05906365f, 0.12619817f, 0.00274939f, -0.16421628f, -0.02882091f, 0.19986618f, 0.09294804f, 0.00990294f, 
    0.16208571f, 0.06571840f, 0.09753728f, -0.15478145f, 0.03814588f, 0.03655448f, -0.00545039f, 0.17126979f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.35142997f, 0.09104249f, -0.13529480f, -0.60434943f, -0.12685084f, -0.34821558f, -0.26702097f, 0.18551627f, 
    0.08903480f, 0.01934626f, -0.09675968f, 0.15239340f, -0.13722906f, 0.51985943f, -0.77410340f, -0.30022392f, 
    -0.08039937f, 0.38299653f, 0.06674059f, 0.63842982f, 0.15376624f, 0.11926620f, 0.27780789f, -0.14469153f, 
    -0.66048235f, 0.07413113f, -0.08152357f, -0.13508998f, -0.12628444f, -0.24820034f, -0.04906788f, 0.41986001f, 
    -0.39959732f, -0.03159463f, -0.08049279f, 0.07416839f, -0.05290150f, -0.15941934f, 0.45460883f, 0.43807900f, 
    -0.05064066f, -0.33728686f, -0.62197983f, 0.16016430f, -0.02865956f, -0.48738712f, 0.42880797f, -0.14783904f, 
    -0.07631623f, -0.04632410f, 0.10353486f, 0.65495610f, -0.14495784f, -0.00454250f, -0.67818642f, -0.02938787f, 
    -0.06202595f, 0.42947242f, 0.22158609f, -0.19482198f, -0.01758412f, 0.22194459f, -0.08795369f, 0.34846961f, 
    -0.12833761f, 0.12949324f, -0.15299350f, 0.58712327f, 0.05534471f, -0.22964522f, -0.16204815f, -0.69500422f, 
    0.10414902f, 0.16507424f, -0.00551890f, 0.07965716f, 0.05425064f, -0.83839208f, -0.06067259f, -0.19200893f, 
    0.16778404f, -0.03900932f, -0.13924474f, -0.49502546f, -0.14022885f, -0.00470956f, -0.16398391f, -0.10365670f, 
    -0.50062984f, 0.30628896f, -0.13530602f, 0.77442342f, 0.11761811f, 0.06082286f, 0.03946485f, -0.16760004f, 
    0.00003352f, -0.17312367f, 0.16410366f, 0.04472247f, 0.05431181f, 0.35053977f, -0.34346309f, -0.33205163f, 
    -0.16183627f, 0.63934845f, -0.02823998f, -0.08815695f, 0.01891031f, 0.74943423f, -0.69607741f, 0.55641127f, 
    -0.10423195f, -0.35664126f, -0.00956708f, -0.01182356f, -0.12135285f, -0.40949780f, -0.17300095f, 0.09369014f, 
    -0.11606996f, -0.21168518f, 0.33958960f, -0.10267004f, -0.00325153f, -0.17042707f, 0.08878025f, -0.64625812f, 
    -0.10657118f, -0.02936637f, 0.13348426f, -0.74523884f, 0.14242728f, -0.39995155f, -0.16583399f, 0.04396269f, 
    -0.16991049f, 0.52953190f, 0.32357919f, 0.02543244f, 0.00541374f, -0.07176986f, -0.80966336f, -0.05816885f, 
    -0.17052135f, 0.13304867f, -0.01969317f, -0.32959220f, 0.02132456f, 0.30218723f, -0.45294279f, 0.11185022f, 
    0.45290798f, -0.00637714f, 0.24519721f, -0.05226637f, 0.06763986f, -0.92920041f, -0.07470819f, -0.13021229f, 
    0.07514261f, 0.12634452f, 0.11200493f, 0.19893283f, -0.09698377f, -0.08764600f, 0.66937172f, 0.44682866f, 
    -0.05283037f, 0.31164339f, -0.22696654f, 0.05299662f, -0.15536334f, -0.15325648f, 0.15534104f, -0.48486024f, 
    0.09684957f, 0.32528019f, -0.05519554f, -0.55319697f, -0.12634063f, 0.06200486f, 0.23409460f, 0.16291678f, 
    -0.01450917f, -0.67419392f, -0.28156626f, -0.37134442f, 0.06192299f, 0.15754049f, 0.01394059f, 0.18808798f, 
    0.38099384f, -0.09067373f, -0.00778803f, 0.49151647f, -0.13389190f, -0.02974653f, -0.81650811f, -0.22377959f, 
    0.11415324f, 0.05403117f, -0.02697683f, -0.15713826f, -0.07546683f, -0.20639139f, -1.08538890f, -0.14512593f, 
    0.07634724f, 0.51500273f, 0.12180667f, -0.46873111f, 0.05597417f, -0.69710720f, -0.11364614f, 0.09421857f, 
    0.40727562f, 0.44446856f, -0.03599981f, -0.56289840f, 0.03488899f, 0.48640668f, -0.18205120f, -0.27973518f, 
    -0.38190401f, 0.06284001f, -0.14412205f, -0.48522484f, 0.00741817f, -0.41811797f, -0.01190727f, 0.22292551f, 
    -0.12069690f, 0.16300057f, 0.09840114f, -0.01643229f, 0.00072922f, 0.30048221f, 0.87796706f, 0.06196320f, 
    0.04189428f, -0.37765545f, 0.01605513f, 0.24673793f, -0.11131354f, 0.09240246f, 0.29508239f, 0.08144068f, 
    -0.15501545f, -0.52381539f, -0.18851362f, 0.11151267f, 0.14627336f, -0.06141960f, 0.02836837f, -0.40346062f, 
    -0.28085750f, -0.09811296f, -0.09883744f, 0.07637133f, 0.01958100f, 0.85431975f, -0.00729962f, -0.23811592f, 
    -0.07267285f, -0.12479301f, -0.30523950f, -0.07333937f, -0.06800541f, -0.40730229f, -0.08981763f, -0.38181493f, 
    -0.12154872f, -0.41844326f, 0.16420834f, 0.66236711f, -0.07841755f, -0.70431411f, -0.20211522f, -0.02371802f, 
    0.40941790f, -0.57350791f, 0.21994083f, 0.13313271f, 0.10045283f, 0.13440743f, -0.00678770f, 0.21443081f, 
    -0.42811519f, -0.10261198f, -0.11849480f, -0.64228469f, 0.03677279f, 0.22612478f, 0.26248044f, -0.63862336f, 
    -0.13200042f, -0.89380229f, 0.26292601f, 0.17184529f, -0.17470370f, 0.12321187f, 0.58179742f, -0.19167724f, 
    0.04549316f, 0.12365012f, -0.05679729f, -0.85733521f, -0.05065349f, 0.64693356f, 0.09124619f, 0.09705972f, 
    0.22988354f, 0.32270238f, -0.53958505f, -0.26942158f, -0.03157512f, 0.50548506f, -0.13530192f, -0.07573566f, 
    -0.27996686f, 0.06642148f, 0.10955673f, 0.39994723f, -0.02802273f, -0.11623365f, -0.51611525f, -0.26394707f, 
    -0.03149155f, -0.32129380f, -0.41161427f, 0.13440903f, 0.02552374f, -0.14657992f, -0.58005691f, 0.33261165f, 
    -0.10825032f, -0.85511166f, -0.16610570f, -0.47475946f, 0.02614410f, 0.36745310f, 0.74653459f, -0.11899478f, 
    0.08506701f, 0.11755151f, 0.69863272f, -0.07377746f, 0.08838280f, -0.01535448f, 0.14326844f, 0.02656223f, 
    0.97289437f, -0.14659107f, 0.06229231f, 0.29786474f, 0.09536334f, 0.26632634f, -0.21385504f, 0.16197982f, 
    -0.11902700f, -0.71294683f, 0.08449569f, -0.10963238f, 0.15934968f, -0.31652296f, -0.17553635f, 0.55293345f, 
    0.06739701f, -0.57582611f, -0.03343167f, -0.29877228f, -0.15209028f, -0.55560440f, 0.10703909f, -0.01549290f, 
    0.08290536f, -0.09245404f, -0.58583301f, 0.00957111f, -0.11858321f, -0.41615862f, -0.10003232f, -0.15139930f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01719145f, 0.05619935f, -0.06076346f, -0.21936806f, 0.26749727f, -0.09380934f, -0.06883197f, -0.32092130f, 
    -0.00235563f, 0.05791354f, 0.11318745f, 0.11141096f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
