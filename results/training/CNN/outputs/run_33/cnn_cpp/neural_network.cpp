#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.01421418f, 0.53470093f, 0.34649345f, -0.43355766f, -0.33244681f, -0.35166720f, 0.13999622f, 0.11087871f, 
    0.17094287f, 0.16153708f, -0.17368960f, 0.28270313f, -0.30843049f, 0.18911430f, -0.29858622f, -0.21604420f, 
    0.32642832f, 0.22200528f, -0.03973824f, -0.27261817f, 0.00166468f, -0.24354851f, 0.04161575f, -0.06067683f, 
    0.18065280f, -0.65238428f, -0.46580341f, -0.13502356f, -0.16548741f, -0.36772069f, 0.07617105f, 0.16735058f, 
    0.35506919f, -0.00957742f, 0.51371545f, 0.36667824f, 0.21135180f, 0.10572389f, -0.35006666f, -0.01747687f, 
    0.17076772f, -0.02941126f, 0.15632510f, 0.14819992f, 0.02982279f, -0.12939863f, 0.07166497f, 0.14480489f, 
    0.23231392f, 0.14211610f, -0.12513787f, 0.11772443f, -0.48430938f, -0.40951964f, -0.11167738f, 0.37318450f, 
    -0.51563972f, -0.42548794f, 0.23825206f, -0.32856041f, -0.41670036f, -0.28074139f, 0.29212245f, 0.10445341f, 
    -0.19934414f, -0.13481864f, 0.25344080f, 0.02415691f, 0.12597795f, -0.05309058f, -0.13700958f, 0.02929595f, 
    0.10098562f, -0.15030116f, -0.04378902f, -0.32341096f, -0.22043699f, -0.19199066f, 0.06303576f, 0.13353473f, 
    0.14613698f, 0.64753115f, 0.52905208f, 0.54462045f, 0.22298944f, -0.20094220f, -0.28784803f, -0.23855983f, 
    -0.22598088f, -0.04272194f, 0.30711406f, 0.15062791f, -0.19554880f, -0.23852539f, -0.11878490f, -0.14739777f, 
    -0.17886692f, 0.05215359f, -0.07837238f, -0.04589947f, -0.22361220f, -0.86505526f, -0.26807165f, 0.49973443f, 
    -0.11792057f, -0.13100135f, 0.86421365f, 0.54780596f, -0.36863068f, 0.15993451f, 0.01786560f, -0.03923153f, 
    0.03759430f, 0.15449651f, 0.00502485f, -0.27888241f, 0.09443573f, 0.12755515f, -0.00099483f, -0.15542574f, 
    0.05039322f, -0.06256134f, -0.07894655f, -0.16984388f, -0.12420899f, -0.02534950f, -0.55383825f, -0.51040137f, 
    -0.39330807f, -0.02703382f, 0.03687918f, -0.56819415f, -0.48068017f, -0.12354526f, -0.18112266f, -0.07409400f, 
    0.09508290f, 0.23152697f, 0.07764456f, 0.07519027f, 0.07437941f, 0.09450139f, -0.06288903f, -0.01325895f, 
    0.21905877f, 0.21159871f, 0.05412846f, 0.17126460f, 0.28033113f, -0.34036002f, -0.13005884f, 0.39878273f, 
    -0.36796570f, -0.00342975f, 0.48478705f, -0.26555181f, -0.61172634f, -0.21807791f, -0.29411978f, 0.14498067f, 
    0.33712509f, -0.13407071f, -0.30838585f, -0.26832303f, 0.07672808f, -0.10862555f, -0.47586057f, -0.38994464f, 
    -0.24617656f, -0.16226949f, 0.07345476f, -0.06299112f, 0.07893370f, -0.10216767f, -0.06429257f, 0.08250126f, 
    -0.46203569f, -0.72739661f, -0.79083121f, -0.20722178f, 0.55232346f, 0.21849373f, 0.16474663f, 0.34070247f, 
    0.12564786f, -0.25129095f, -0.00306368f, 0.08029283f, -0.01880976f, -0.11451849f, -0.08913905f, -0.07047685f, 
    -0.03020937f, 0.25923866f, 0.04106098f, 0.04161309f, -0.00196533f, -0.18341094f, -0.01994852f, 0.09622417f, 
    0.92643040f, 0.23608032f, 0.58266252f, 0.33051696f, 0.57200795f, 0.16276157f, -0.24534522f, -0.13401468f, 
    0.33504379f, 0.03253987f, 0.20838001f, 0.02107318f, -0.10445405f, -0.03625737f, -0.09272541f, -0.21155775f, 
    -0.15708764f, 0.05475930f, 0.00948753f, -0.06809293f, 0.21376683f, 0.19026251f, 0.17116359f, -0.15305860f, 
    0.15254503f, 0.72311205f, 0.33753514f, 0.36949474f, 0.81500626f, 0.72191858f, 0.05640140f, 0.14964896f, 
    -0.17222475f, 0.18819593f, 0.01874967f, -0.35791692f, 0.00538453f, 0.06552064f, 0.29576382f, -0.01233729f, 
    0.04347121f, 0.07774941f, 0.02407091f, -0.12819198f, -0.04166473f, -0.04054123f, 0.00456911f, -0.03677055f, 
    0.02105516f, 0.05364016f, -0.12649199f, 0.05778210f, 0.09945376f, 0.11839791f, 0.40703985f, -0.59157366f, 
    -0.34771481f, -0.05496681f, -0.17715590f, -0.26165137f, 0.31959137f, -0.14554282f, 0.09474936f, 0.34541407f, 
    0.26492429f, 0.07951041f, 0.21007453f, 0.15979145f, -0.10895951f, 0.32966235f, 0.21113893f, -0.01517128f, 
    -0.30937585f, 0.09311628f, 0.24519825f, -0.60525239f, 0.43781903f, 0.15858857f, 0.07762330f, 0.27073008f, 
    -0.57347721f, 0.55885822f, -0.08178352f, -0.60600460f, -0.25768191f, -0.10395376f, 0.09995739f, 0.20686051f, 
    0.33030051f, 0.31811050f, -0.00969957f, -0.13809754f, -0.00047374f, 0.07896106f, 0.07083724f, 0.00222317f, 
    0.08850047f, 0.20343205f, 0.30808717f, -0.10485953f, -0.29608274f, 0.88124299f, -0.07872777f, -0.64119649f, 
    -0.22656773f, 0.54150933f, -0.09852208f, -0.09015635f, -0.35937232f, 0.01334573f, 0.19905549f, 0.14931040f, 
    0.26934043f, 0.02050250f, 0.04595636f, -0.18657881f, -0.03807270f, 0.05148599f, 0.09310320f, -0.04223874f, 
    -0.01370277f, -0.10078434f, 0.02959111f, 0.06461217f, -0.07405876f, -0.18273935f, -0.53324306f, 0.24597928f, 
    0.51832348f, -0.05083509f, 0.62684721f, 0.58498889f, -0.29988456f, 0.25538105f, -0.34753045f, -0.05320330f, 
    0.25403854f, -0.06434371f, 0.22637521f, -0.10560399f, 0.03251355f, -0.09912186f, -0.27994901f, -0.17490660f, 
    0.01279697f, -0.00947984f, 0.16599770f, 0.27282426f, 0.05842384f, 0.29691076f, 0.69085246f, 0.84678662f, 
    0.57591474f, -0.02312755f, -0.65007854f, -0.72273117f, -0.19380550f, -0.26361531f, 0.10865105f, -0.22364037f, 
    0.35275379f, 0.13891014f, -0.14152616f, -0.07872477f, -0.01889086f, 0.01283731f, 0.10812365f, -0.19249059f, 
    -0.08322850f, 0.00206623f, -0.12834324f, 0.14258707f, 0.11624347f, 0.10510571f, -0.00469210f, -0.64254159f, 
    -0.02704457f, -0.20200901f, -0.34624776f, -0.18891908f, -0.55421561f, -0.18637849f, 0.42214370f, 0.28486243f, 
    -0.32214695f, -0.33081511f, 0.06938463f, -0.07124317f, 0.01140557f, -0.40821284f, 0.08505116f, -0.22493243f, 
    0.03219864f, -0.10070761f, -0.02196608f, -0.04290178f, -0.14569259f, -0.00399189f, -0.03184877f, -0.10914402f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03816822f, 0.12095718f, 0.21271244f, 0.02037918f, 0.03504294f, 0.37268233f, 0.14081176f, 0.03641031f, 
    0.24345054f, 0.14083713f, 0.17570801f, -0.02970011f, 0.00764196f, 0.19077785f, 0.29522660f, 0.15275931f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.11136991f, 0.09264679f, -0.03405666f, 0.06408246f, 0.15223311f, 0.10877812f, 0.02504882f, -0.00463201f, 
    0.17114948f, 0.09046981f, 0.13798606f, 0.05962185f, -0.16653906f, 0.09087630f, -0.00576829f, 0.07181428f, 
    0.10117301f, 0.05656418f, 0.18334325f, 0.08966701f, 0.06677255f, 0.06798236f, 0.10482540f, 0.05607533f, 
    0.22548366f, 0.13337284f, -0.13618246f, 0.16758667f, 0.05247853f, 0.16428703f, 0.05298406f, -0.00055421f, 
    0.00967395f, 0.04201860f, 0.12365615f, -0.00312312f, -0.10338650f, -0.15351076f, 0.09449995f, -0.19355701f, 
    -0.02395792f, -0.15603533f, 0.03718367f, -0.01848024f, -0.02095184f, 0.05277135f, 0.11849552f, 0.06849848f, 
    -0.06750848f, -0.14418675f, -0.03089499f, -0.09174200f, 0.07817681f, -0.07148349f, 0.06050479f, 0.06802037f, 
    -0.01883719f, 0.01301687f, 0.05664473f, -0.06104559f, 0.18412754f, 0.16162315f, -0.18636404f, 0.18214251f, 
    0.02195347f, 0.01395266f, -0.06492458f, 0.06355625f, 0.11688494f, 0.07694233f, 0.08302798f, 0.02406611f, 
    -0.02378831f, 0.03501445f, -0.22029500f, 0.22943401f, 0.13366632f, 0.01600461f, -0.07471649f, 0.12745613f, 
    0.00099736f, 0.15614371f, -0.07844346f, 0.12452344f, 0.02637718f, 0.06596047f, -0.07934968f, 0.16611809f, 
    0.03500723f, 0.05368986f, 0.09068976f, -0.08372150f, 0.12368173f, 0.00329271f, 0.02718639f, -0.03978032f, 
    -0.06640203f, -0.11021262f, -0.06857438f, -0.16889872f, 0.13134117f, 0.03291162f, 0.00696043f, -0.14751983f, 
    -0.01277999f, -0.09448054f, 0.00389155f, 0.03251173f, -0.17875198f, -0.09158510f, -0.01717709f, -0.01729470f, 
    0.01138978f, -0.03645390f, -0.08514328f, -0.16134408f, -0.04482599f, 0.03402475f, 0.03301328f, 0.03717727f, 
    -0.10847227f, -0.10815591f, 0.09525239f, 0.07511637f, -0.03245540f, -0.00726879f, -0.05701403f, 0.21723098f, 
    0.01910081f, 0.13548476f, 0.05899375f, 0.00821071f, -0.13853920f, 0.01586883f, 0.15301704f, 0.18938102f, 
    0.06758769f, -0.05458910f, -0.00065251f, 0.08587679f, -0.01919340f, 0.01413232f, 0.07726136f, 0.18304859f, 
    -0.01546876f, 0.03445226f, -0.10386250f, 0.26395464f, 0.05537274f, -0.00994638f, -0.02256729f, 0.02570865f, 
    0.14673313f, -0.03818834f, 0.06232689f, 0.08507731f, -0.09844862f, 0.07518403f, 0.10034484f, -0.15853226f, 
    0.04262299f, -0.02363894f, -0.04376249f, 0.09119593f, 0.11071067f, 0.04891670f, 0.00851029f, 0.13409871f, 
    0.28479451f, -0.12645723f, 0.24444664f, -0.05225423f, 0.25361171f, 0.03464746f, -0.07243931f, -0.08057859f, 
    0.04715196f, 0.14828001f, 0.06570604f, 0.13925478f, 0.02898465f, 0.05860626f, 0.12697163f, 0.05994950f, 
    0.09043832f, 0.13579133f, -0.00621596f, -0.08220886f, 0.02780749f, -0.09663384f, -0.02971709f, 0.01963815f, 
    0.04026567f, 0.03242823f, 0.03593685f, 0.04390403f, -0.01851354f, -0.03243032f, 0.06982855f, -0.00174593f, 
    -0.05681954f, 0.04219278f, 0.04926101f, -0.02975777f, -0.00130679f, -0.01189110f, -0.01753428f, -0.02046348f, 
    -0.03943868f, -0.05001494f, -0.06174182f, -0.00442897f, 0.06115676f, -0.00573736f, -0.00368658f, -0.02500823f, 
    0.01685240f, -0.06485877f, 0.05106590f, 0.00098193f, 0.02612754f, -0.01839895f, -0.06269272f, -0.06650627f, 
    0.04831615f, 0.00454792f, 0.04341845f, 0.02786901f, 0.03675343f, 0.04978279f, -0.01998448f, -0.02360210f, 
    -0.07405437f, -0.02733528f, 0.02505684f, -0.05390646f, 0.01714974f, 0.04259970f, 0.03283939f, -0.03378120f, 
    -0.02755000f, -0.06246759f, 0.03596322f, -0.05982975f, 0.04633360f, 0.05751626f, -0.03077421f, 0.02873926f, 
    0.01294786f, -0.05473040f, -0.04285035f, 0.02650942f, -0.06172684f, 0.02473659f, -0.00200631f, -0.03990664f, 
    0.02644499f, -0.05849496f, 0.00479721f, -0.02187434f, 0.02694497f, 0.01240825f, 0.00281312f, -0.06292149f, 
    0.02425680f, 0.02446094f, 0.02125748f, 0.04375490f, 0.03519861f, 0.04227281f, -0.06467496f, 0.06594893f, 
    0.05162987f, -0.06142032f, 0.01527803f, -0.05759633f, -0.00333677f, 0.05032658f, 0.05642102f, -0.06686217f, 
    0.03182146f, -0.04631170f, -0.06470472f, -0.04062740f, -0.04646079f, -0.00475882f, -0.04026818f, -0.03163340f, 
    0.05172068f, -0.06486355f, -0.04722600f, 0.00230119f, -0.02401939f, -0.02937062f, -0.06406962f, 0.03827819f, 
    -0.03424519f, -0.02565324f, -0.04806557f, 0.01140875f, -0.00633618f, -0.03719287f, -0.07615356f, 0.01153868f, 
    -0.00812769f, -0.00842518f, -0.04311629f, -0.07018165f, 0.06722777f, -0.07472000f, 0.05107446f, 0.04454234f, 
    -0.05260112f, -0.05530465f, -0.01599492f, -0.05353398f, 0.02810853f, 0.01908499f, -0.01877143f, 0.05249523f, 
    0.06644280f, 0.06444303f, 0.01287309f, -0.00892009f, -0.03930638f, -0.04868579f, -0.06832379f, -0.02557723f, 
    -0.06140011f, -0.01774877f, -0.05172287f, 0.00760665f, -0.05816826f, -0.05517352f, 0.02761540f, 0.06134525f, 
    -0.03746349f, 0.02129761f, 0.03131633f, -0.07109556f, -0.02281379f, 0.00648606f, 0.00934440f, 0.05491349f, 
    -0.06087356f, -0.00832582f, -0.06647836f, 0.03563849f, -0.03851032f, 0.03810073f, 0.06425741f, -0.01270976f, 
    -0.06201157f, 0.02622615f, -0.05713119f, -0.08234177f, -0.07850156f, -0.01790020f, -0.02763238f, -0.01577198f, 
    0.03104051f, 0.00243203f, 0.00695357f, -0.05605512f, -0.04398415f, 0.00998312f, 0.05627565f, 0.02716244f, 
    -0.05422257f, -0.05178242f, -0.03180407f, -0.06323812f, -0.01908085f, -0.03512041f, -0.05281724f, -0.05488683f, 
    0.03763518f, -0.05039132f, 0.06351757f, -0.02282760f, -0.01710698f, -0.04304007f, -0.07203083f, 0.02885458f, 
    0.06959837f, -0.03758401f, 0.05220083f, 0.10514283f, 0.01491982f, 0.08942535f, 0.04519690f, 0.03729591f, 
    -0.08755673f, 0.13911897f, -0.03222292f, 0.03495829f, 0.02648138f, -0.10466646f, -0.03745717f, -0.12782373f, 
    -0.04234962f, 0.08553199f, 0.01374253f, 0.09048168f, 0.04304306f, 0.05796652f, -0.11516604f, -0.14941975f, 
    -0.06867421f, -0.08465175f, 0.11697722f, -0.00631157f, -0.02594010f, -0.05465009f, -0.06625085f, -0.13135007f, 
    0.08668288f, -0.07272820f, -0.18386841f, 0.04112815f, 0.03857329f, 0.04957215f, -0.23798099f, -0.21137233f, 
    -0.02527671f, 0.01064012f, 0.07311526f, 0.12164286f, -0.01054902f, -0.03606971f, 0.06545959f, -0.00670619f, 
    -0.12773001f, 0.02611212f, -0.01891889f, -0.26136366f, 0.09658758f, 0.15252173f, 0.07793529f, 0.00677353f, 
    0.11111186f, 0.03070107f, 0.11889081f, -0.02317499f, -0.24027030f, -0.24267222f, -0.08966374f, 0.06307378f, 
    0.13090968f, -0.00024918f, -0.17967102f, 0.01616317f, 0.09302106f, -0.07718377f, 0.03414671f, 0.01105766f, 
    0.05405826f, -0.16645686f, -0.01619986f, -0.08283366f, 0.00192525f, -0.03110213f, 0.07040363f, 0.00195842f, 
    0.12171490f, 0.03825591f, 0.17724471f, 0.13755243f, -0.06202567f, -0.10805418f, -0.31244579f, -0.23090281f, 
    0.08223360f, -0.11551826f, -0.02214284f, 0.09330228f, 0.03962768f, -0.02884953f, -0.09559835f, 0.14242846f, 
    0.26306379f, 0.22838873f, 0.07413508f, -0.16735673f, 0.00811991f, -0.06034658f, 0.01256737f, -0.06446584f, 
    0.05134156f, -0.05556867f, 0.08901165f, 0.14313437f, 0.15315804f, 0.29028383f, 0.12868561f, -0.20215160f, 
    0.11016260f, 0.03433126f, -0.03319009f, -0.01458595f, 0.02181481f, 0.05892488f, -0.01981582f, 0.08841953f, 
    0.07687499f, 0.09301773f, 0.11980926f, 0.01113550f, -0.06813908f, 0.04502387f, -0.02583970f, 0.01942554f, 
    0.08448758f, -0.06576729f, -0.04098827f, -0.00659548f, 0.31623116f, -0.02813851f, -0.07743185f, 0.00825171f, 
    0.03366909f, 0.06079201f, -0.10260764f, 0.02998943f, -0.10058089f, 0.04475381f, 0.02821421f, 0.01367744f, 
    0.11519050f, -0.18696450f, 0.23028734f, 0.14110063f, 0.01185250f, 0.02410715f, 0.05949578f, 0.01154921f, 
    -0.01239704f, -0.15833671f, -0.03770233f, -0.02117180f, -0.01125632f, -0.03467873f, 0.16446221f, -0.01780315f, 
    0.00355337f, -0.02918757f, -0.05825334f, 0.01426404f, 0.03485084f, 0.07120438f, 0.00672633f, 0.04262985f, 
    0.13103767f, 0.31308255f, 0.00190857f, 0.09390765f, -0.01818408f, 0.11603301f, 0.08141331f, -0.02434500f, 
    -0.12420267f, 0.02485990f, 0.11142163f, -0.09701996f, -0.12144464f, -0.00063055f, -0.11766707f, 0.20518059f, 
    -0.03456916f, 0.01375774f, -0.07755569f, 0.03271830f, 0.05897634f, 0.03462993f, 0.07575782f, -0.07533657f, 
    -0.19013207f, 0.07121643f, 0.05557832f, -0.15806571f, -0.00729673f, -0.13560584f, 0.11905588f, -0.17298098f, 
    0.11539154f, -0.00180825f, -0.10608812f, -0.07396533f, 0.39402327f, 0.13596524f, 0.09876627f, 0.03175483f, 
    0.15240136f, 0.00065918f, -0.10690428f, -0.07113993f, -0.05116544f, 0.16395918f, -0.05455117f, -0.02739131f, 
    0.26311019f, 0.10175934f, 0.05872913f, -0.10519028f, -0.10919636f, -0.01871432f, 0.06047146f, -0.02619588f, 
    0.00260321f, 0.15160549f, 0.09853647f, 0.14585967f, 0.06838970f, -0.13471380f, 0.09656215f, 0.22790845f, 
    0.10229512f, 0.10390972f, -0.05829462f, 0.21451189f, 0.01518195f, 0.04193374f, 0.21504845f, 0.14584914f, 
    0.15909711f, -0.15180609f, 0.16446432f, 0.13975985f, -0.14388810f, 0.16310416f, 0.15420625f, 0.01361312f, 
    0.07716769f, 0.03347391f, 0.08166632f, 0.25512019f, -0.11083762f, -0.01608365f, 0.10880815f, -0.15133679f, 
    -0.07255722f, 0.23586713f, 0.16910683f, 0.02514396f, -0.14420861f, -0.13349077f, -0.02489415f, -0.10753036f, 
    -0.01467615f, -0.03648799f, 0.14703017f, -0.16302226f, -0.03387791f, -0.12931919f, -0.02673656f, -0.03865153f, 
    -0.00167295f, -0.02410454f, 0.22661591f, 0.05708065f, 0.21983629f, 0.17764916f, 0.14779426f, -0.09810176f, 
    0.02442549f, -0.18594214f, 0.20667236f, 0.08554492f, -0.04525736f, 0.03620809f, 0.01233342f, 0.03651401f, 
    0.13216206f, 0.35176557f, 0.12836625f, 0.06244887f, -0.19500417f, 0.04048860f, 0.03383093f, 0.11880454f, 
    -0.03480829f, 0.10312604f, 0.02499564f, 0.03308101f, 0.35830897f, 0.13774805f, -0.03684052f, 0.12566924f, 
    -0.18816052f, 0.01261322f, 0.07572762f, 0.22225015f, -0.04404715f, 0.09839728f, -0.05056018f, -0.11359134f, 
    -0.03753118f, 0.05594699f, -0.07967068f, 0.14764428f, -0.01651088f, 0.05590618f, -0.07448256f, -0.09610664f, 
    0.05057905f, -0.11093127f, -0.15316230f, -0.19509111f, -0.26428747f, 0.13473737f, -0.10712972f, 0.04457911f, 
    0.08268635f, -0.01694766f, 0.00916552f, -0.13286337f, 0.05425636f, -0.03180843f, -0.08489045f, -0.12836675f, 
    0.27801824f, 0.20490229f, 0.00304680f, -0.09824754f, 0.05395726f, 0.00585266f, 0.21898390f, 0.06445454f, 
    -0.10067488f, 0.02454867f, -0.11243851f, -0.02946387f, 0.22657722f, 0.03653985f, -0.01480562f, 0.00962533f, 
    -0.07505677f, 0.08621085f, -0.03904583f, 0.06763335f, -0.10158031f, -0.06805944f, 0.08955737f, -0.14059493f, 
    -0.38172922f, -0.13079983f, -0.14042127f, -0.13201724f, -0.03101118f, -0.05842567f, 0.05592291f, -0.06722957f, 
    0.05029081f, -0.00823305f, 0.10645517f, -0.16871221f, -0.03045425f, 0.21904594f, -0.13631168f, -0.19150303f, 
    -0.03988741f, -0.08190949f, -0.05463047f, 0.03660129f, 0.03811920f, 0.05589235f, -0.03560002f, -0.11200738f, 
    -0.21271190f, 0.09566581f, -0.11136902f, -0.00814503f, 0.09814886f, 0.08162558f, -0.01972833f, -0.00719945f, 
    -0.09553239f, -0.17291489f, 0.03087633f, -0.06830560f, 0.10085187f, 0.10748777f, 0.00599521f, -0.03607937f, 
    -0.05194578f, 0.01889433f, 0.13996372f, 0.03006935f, 0.14563084f, -0.06211251f, -0.03874642f, 0.07714032f, 
    -0.24134180f, -0.13851140f, 0.08610886f, -0.09960801f, 0.15446904f, -0.11047576f, 0.00961031f, -0.05950090f, 
    0.00671500f, -0.07026528f, -0.03309075f, -0.06187237f, 0.14498949f, 0.39341345f, -0.02205599f, -0.01932577f, 
    -0.04659562f, 0.07673211f, -0.05650836f, -0.13205431f, 0.05540084f, 0.01873529f, -0.13797930f, -0.09684984f, 
    0.16286066f, 0.27185315f, -0.12650008f, 0.02271995f, 0.01628437f, -0.06647025f, -0.10636367f, 0.09223219f, 
    0.02052394f, -0.05621263f, 0.02582758f, -0.13769542f, 0.03727531f, -0.17717704f, 0.10217341f, -0.02307146f, 
    0.01346024f, -0.00490884f, 0.06940167f, -0.16258338f, 0.00938808f, 0.05917604f, 0.04717640f, -0.03484656f, 
    0.19275840f, 0.02412743f, 0.12693043f, 0.10800412f, 0.03562373f, -0.05757899f, 0.04116308f, -0.13714415f, 
    0.01426215f, -0.03533366f, -0.17178842f, -0.10978411f, 0.15816320f, 0.09699267f, -0.05716327f, -0.20885631f, 
    -0.08992679f, 0.10249967f, 0.03287419f, 0.07990046f, -0.05532286f, 0.05575638f, 0.12718043f, -0.04326985f, 
    -0.13122389f, -0.23984239f, -0.01187458f, 0.14611909f, 0.07009895f, 0.06635193f, 0.07173514f, 0.05803800f, 
    0.03283972f, 0.12536506f, 0.02414130f, 0.00042123f, 0.05628397f, -0.23203054f, -0.09394790f, 0.23297586f, 
    0.05311458f, -0.05037447f, 0.05577511f, 0.04180405f, 0.08118640f, 0.09107699f, 0.03637005f, 0.05395221f, 
    0.05081661f, 0.14247134f, -0.03753389f, -0.05079105f, 0.10648359f, -0.03067767f, 0.05425659f, 0.09531679f, 
    -0.03478802f, 0.14120325f, 0.17077915f, 0.22496118f, 0.00979637f, 0.15353538f, -0.04904705f, -0.01711892f, 
    0.05194973f, 0.01186440f, 0.07643110f, -0.06640787f, 0.16402893f, 0.08277072f, 0.05664714f, 0.02438476f, 
    -0.10395300f, -0.02881936f, 0.00502838f, -0.19562520f, 0.12340940f, -0.04585092f, -0.00364763f, -0.11593325f, 
    -0.00195197f, -0.05056453f, 0.02700510f, -0.01122955f, -0.01893729f, 0.06994172f, -0.05449618f, 0.20889984f, 
    -0.09326810f, 0.15962264f, 0.17045861f, 0.04296607f, 0.05510427f, 0.09500210f, 0.01520523f, 0.01962733f, 
    -0.34718201f, 0.02533519f, 0.08645318f, 0.03805970f, -0.11783066f, 0.03947995f, 0.03044242f, 0.10402755f, 
    -0.03336607f, -0.02638548f, -0.05090660f, 0.08031377f, 0.00669507f, 0.10818547f, -0.06683788f, 0.00965018f, 
    0.00187941f, 0.14827029f, -0.05425930f, -0.02526745f, -0.02741508f, 0.08380663f, 0.03618155f, -0.04003004f, 
    -0.19048065f, 0.21787710f, -0.05648166f, -0.10373926f, -0.11927813f, 0.05212033f, 0.00200747f, 0.10200220f, 
    -0.03125504f, -0.08539617f, 0.07155664f, 0.09509747f, -0.00264438f, -0.08699839f, -0.08662090f, -0.10995349f, 
    0.05735043f, -0.07180830f, -0.11493771f, 0.04877211f, 0.03952879f, -0.04025025f, 0.06632914f, 0.22274269f, 
    -0.30532232f, -0.32324350f, 0.10146489f, -0.14640301f, 0.01410701f, 0.07423601f, 0.10740671f, 0.11361460f, 
    0.11526524f, 0.08227123f, -0.05023473f, -0.08747058f, 0.12652983f, 0.24765651f, -0.10651507f, 0.04552057f, 
    0.04077646f, 0.05827261f, -0.08025402f, 0.04897945f, 0.13874030f, 0.14218122f, 0.08004793f, 0.01141755f, 
    0.09706612f, -0.01234694f, -0.18065622f, 0.09253368f, 0.06955829f, 0.02286422f, -0.00009723f, 0.04536450f, 
    0.02701288f, -0.00414914f, 0.07037418f, -0.03743183f, -0.09769188f, -0.01290071f, 0.20384797f, 0.01881136f, 
    -0.02568603f, 0.09377277f, 0.08879575f, -0.08657977f, 0.10193335f, 0.02991485f, 0.08255931f, 0.01760391f, 
    0.30677745f, 0.16884491f, 0.23005109f, -0.15703282f, 0.10470808f, -0.05702429f, 0.13848230f, -0.10860993f, 
    0.08723906f, -0.03660526f, -0.11813001f, -0.12222012f, -0.13085631f, -0.15186939f, 0.05377740f, -0.24860515f, 
    0.09132249f, 0.07601182f, -0.05068967f, 0.22621308f, -0.02574049f, -0.03922615f, 0.10512044f, 0.04021301f, 
    0.23614994f, -0.23116864f, 0.05845465f, 0.35183266f, -0.00189189f, 0.05452721f, -0.04906061f, 0.01689470f, 
    0.10363851f, -0.05780392f, -0.04319139f, 0.07148532f, 0.24585521f, -0.18276763f, -0.08505885f, 0.33685559f, 
    -0.09594996f, 0.02570070f, -0.04033676f, 0.01966541f, 0.03767716f, -0.11916608f, -0.03279993f, 0.14587693f, 
    -0.05140200f, 0.14039330f, -0.09534189f, 0.00012299f, -0.05060877f, -0.03051802f, -0.00858134f, -0.04848254f, 
    -0.02260554f, 0.07895592f, 0.10710336f, 0.04723562f, -0.08771455f, 0.23940288f, -0.15537295f, -0.15346535f, 
    0.08387660f, 0.04625414f, 0.06034921f, -0.01663268f, 0.06926977f, -0.05097980f, -0.04669026f, -0.03767182f, 
    0.13950849f, 0.19967628f, -0.02523819f, -0.45875669f, -0.01149973f, 0.09026071f, 0.10953761f, -0.08054741f, 
    0.13442287f, 0.00792514f, 0.10425452f, 0.08852556f, 0.10097608f, -0.05811533f, -0.17739227f, 0.16722834f, 
    0.08096620f, 0.13393222f, -0.03589737f, -0.05214218f, -0.00435614f, 0.10161849f, 0.09127324f, 0.06325151f, 
    -0.03724819f, 0.12586437f, -0.25219151f, -0.02612985f, -0.07205289f, 0.04338959f, 0.00229172f, 0.00121473f, 
    0.15202734f, 0.02214658f, -0.11155530f, 0.06409771f, -0.18868956f, -0.00170762f, -0.06933037f, 0.04579179f, 
    0.02861480f, -0.09364369f, 0.06144309f, 0.17891078f, -0.06066688f, 0.02915821f, 0.01697982f, 0.04517629f, 
    0.04426419f, 0.23774292f, -0.13240321f, 0.06409048f, 0.03907453f, 0.06710220f, -0.02053065f, 0.06287491f, 
    0.04569438f, -0.16637208f, -0.02255835f, 0.07740141f, -0.05652269f, 0.03823526f, -0.04629533f, 0.11800677f, 
    -0.00368745f, -0.03305680f, 0.12729193f, 0.06137953f, 0.05468111f, -0.09580659f, 0.00462735f, 0.01756256f, 
    -0.28543547f, -0.21480587f, -0.10065416f, -0.07133517f, 0.07057133f, 0.03568095f, 0.10866568f, 0.05196723f, 
    0.03143403f, -0.08894075f, 0.10345784f, -0.01572963f, 0.15770866f, 0.11725640f, 0.02548978f, 0.04092497f, 
    -0.08628170f, 0.07268264f, -0.03424957f, -0.10959835f, 0.06575941f, 0.00225675f, -0.16129605f, -0.01557379f, 
    0.08328041f, 0.15941474f, -0.21282351f, 0.11653407f, 0.03846264f, -0.02377048f, -0.17797300f, 0.15149479f, 
    0.02219751f, -0.03882415f, 0.06740376f, -0.21529625f, 0.08631486f, -0.04436334f, 0.03038551f, 0.01476490f, 
    -0.04689592f, -0.11453883f, 0.08944513f, -0.00860954f, 0.17479876f, 0.20091245f, 0.10159113f, 0.17600538f, 
    0.02160565f, 0.06785630f, -0.07144931f, 0.03722201f, 0.06562849f, 0.18393806f, -0.00197065f, -0.01081123f, 
    0.00434460f, 0.03438766f, -0.19610126f, 0.00790983f, 0.13135195f, -0.09797347f, -0.03755532f, -0.00021411f, 
    0.10650720f, 0.15853238f, -0.06453215f, -0.01041378f, -0.00743904f, -0.01464736f, 0.14259566f, -0.14037441f, 
    -0.01382233f, -0.12501675f, 0.18753691f, 0.31030333f, -0.01366224f, -0.01089765f, 0.08825112f, 0.11161831f, 
    0.11669847f, -0.10354345f, 0.12123826f, 0.03510280f, 0.20303012f, -0.10874573f, 0.17362443f, 0.24017946f, 
    -0.03633362f, 0.11053535f, -0.03294270f, -0.06807181f, 0.08378376f, 0.04818647f, -0.04643669f, 0.01234988f, 
    -0.17161343f, 0.07835415f, -0.17590457f, -0.00691063f, 0.13260555f, 0.06728699f, -0.09101548f, 0.03611315f, 
    0.01194948f, 0.02115588f, -0.01852372f, 0.27718189f, -0.02792566f, 0.07797717f, -0.07624267f, -0.00794139f, 
    -0.07077383f, 0.02923260f, -0.06578678f, -0.12431686f, 0.04186029f, 0.03922823f, 0.03228591f, 0.04220923f, 
    -0.12538266f, -0.09955615f, 0.01430161f, -0.06331950f, 0.03490396f, 0.08755403f, -0.10246372f, -0.04101437f, 
    0.04281764f, 0.03573291f, 0.15579505f, -0.10059542f, -0.03359868f, -0.03035400f, -0.01559694f, -0.09542637f, 
    0.00993205f, 0.08578892f, 0.04941297f, 0.04617823f, 0.01218194f, 0.11293809f, 0.01706933f, 0.15263455f, 
    0.14398773f, 0.00969926f, 0.01946828f, -0.03858043f, 0.02246952f, 0.01271284f, 0.10100974f, -0.03297627f, 
    0.02673911f, 0.02838444f, -0.05579851f, 0.12895156f, -0.10890131f, 0.01840910f, 0.00161423f, -0.01447929f, 
    0.03644134f, 0.07139431f, -0.03600173f, 0.09704570f, -0.06905390f, -0.00907627f, -0.04290952f, 0.13020876f, 
    -0.10773091f, 0.22966208f, 0.04870457f, -0.17796002f, 0.01616907f, 0.06840552f, 0.13460559f, 0.01360427f, 
    0.08072831f, -0.08929545f, -0.00041186f, 0.00419506f, 0.24669400f, 0.27235264f, 0.22208109f, 0.01077160f, 
    0.04531271f, -0.01606881f, -0.03616846f, 0.12502952f, -0.06599026f, 0.10093145f, -0.04019020f, -0.07624798f, 
    0.28459722f, -0.10738735f, -0.13717753f, 0.10718816f, 0.06217074f, 0.06301731f, 0.07124200f, 0.01907125f, 
    -0.08976106f, -0.07789163f, 0.05863171f, 0.15818436f, -0.01236254f, 0.18689370f, 0.09124648f, -0.01997483f, 
    0.06562289f, -0.03363582f, 0.01397296f, -0.06407880f, -0.00378932f, 0.07338665f, 0.06614356f, -0.06147873f, 
    0.16704711f, 0.04316191f, 0.08170196f, 0.16792092f, -0.06679875f, 0.04905762f, 0.04258003f, 0.02587474f, 
    0.11387750f, -0.00732155f, -0.08424397f, -0.06152914f, 0.28534120f, 0.25838816f, 0.06931948f, -0.01797913f, 
    -0.05222711f, -0.08057421f, 0.01336343f, -0.05200567f, -0.03074004f, 0.00809750f, 0.01142345f, -0.04401818f, 
    0.16355251f, 0.10341544f, 0.06560265f, -0.00247578f, 0.10975204f, 0.00432530f, -0.11950761f, 0.04630082f, 
    0.14913620f, -0.09122077f, 0.00553924f, -0.01942197f, 0.39263543f, 0.25401425f, 0.11496056f, -0.06308550f, 
    -0.03506237f, 0.02725849f, 0.12526736f, 0.05086724f, -0.06158402f, -0.04594364f, 0.10710020f, -0.08098805f, 
    0.19611375f, -0.18288954f, -0.02525667f, 0.20699161f, 0.04358790f, 0.02707112f, -0.01908671f, -0.08943580f, 
    -0.03646418f, 0.11001480f, 0.09981064f, 0.01097935f, 0.08779579f, -0.24696958f, -0.07840478f, 0.21028000f, 
    -0.09294379f, -0.03791357f, 0.01154397f, -0.11215004f, 0.03476532f, -0.07193602f, -0.04404048f, 0.01439454f, 
    -0.13964826f, 0.02520468f, -0.05307135f, -0.02059213f, 0.16219372f, -0.00873744f, 0.03688400f, -0.12432621f, 
    0.02016195f, -0.05832055f, -0.05642235f, 0.01529584f, -0.25660980f, 0.20324041f, 0.05733712f, 0.04757863f, 
    0.10132493f, -0.00721926f, -0.11081693f, -0.07022598f, -0.03295062f, 0.01603071f, 0.03655516f, 0.01836926f, 
    0.18673068f, 0.05563925f, 0.03388283f, -0.08551545f, 0.05282615f, 0.03811502f, -0.04742185f, 0.11288881f, 
    0.08153356f, 0.05064521f, 0.02184007f, -0.09435598f, 0.14015289f, -0.08952383f, -0.08115797f, -0.00816882f, 
    0.03744577f, 0.11162134f, 0.02979296f, 0.05103109f, -0.08805706f, 0.11592902f, -0.00446012f, 0.06535962f, 
    0.28658447f, -0.01048862f, -0.21511826f, -0.12929954f, 0.01561618f, 0.06430370f, -0.06194507f, -0.03668354f, 
    0.01019140f, 0.09127688f, 0.08595538f, 0.13114785f, -0.09322150f, 0.33320129f, 0.10629426f, -0.01609084f, 
    -0.01970457f, -0.01332793f, 0.00300511f, 0.00372528f, 0.08797380f, -0.05376320f, -0.02396857f, -0.06469154f, 
    -0.10191581f, -0.00889254f, 0.17527260f, -0.04547706f, -0.22831197f, 0.15173440f, 0.04895141f, -0.08475077f, 
    0.06539718f, 0.12497088f, 0.00821894f, -0.06065334f, -0.01075944f, 0.21067126f, -0.01662376f, -0.03358917f, 
    -0.11594724f, 0.04330409f, -0.00119344f, 0.05642508f, -0.07421067f, 0.18222271f, -0.15052941f, -0.10024454f, 
    0.29299343f, -0.13298392f, -0.12479834f, 0.08843518f, -0.04108875f, 0.16279158f, 0.02092308f, -0.08911417f, 
    -0.01322572f, 0.11111010f, -0.05284972f, 0.13192068f, -0.23131855f, -0.13746926f, -0.20449269f, -0.11913358f, 
    0.10586935f, -0.12654057f, 0.06338780f, 0.12184197f, -0.07885785f, 0.07537244f, 0.09431184f, -0.12768596f, 
    0.04066513f, -0.18865350f, -0.08020779f, 0.17751445f, -0.00435240f, -0.02374401f, 0.08191530f, 0.10200487f, 
    0.00622947f, -0.06999499f, -0.00765552f, 0.13544008f, 0.38894209f, 0.16269089f, -0.09749509f, 0.13237770f, 
    0.04805882f, -0.11215287f, 0.02623279f, 0.07031330f, 0.01009683f, 0.11177433f, 0.13266338f, -0.06905890f, 
    0.12532912f, 0.19636032f, 0.02604414f, -0.00828114f, -0.07987504f, 0.04340848f, -0.06170987f, 0.02558815f, 
    0.13460420f, 0.07637776f, 0.10521508f, 0.05241606f, 0.24902947f, -0.04742314f, 0.02620919f, -0.00159624f, 
    -0.06050409f, -0.07518515f, 0.08413960f, 0.04124914f, 0.00058867f, -0.04998162f, -0.01702322f, -0.12672551f, 
    0.15305850f, -0.13404489f, -0.25330374f, -0.34709257f, 0.09902755f, -0.02307145f, 0.08756905f, -0.02093885f, 
    0.01688846f, 0.11334625f, 0.11549877f, 0.09689035f, -0.39079276f, -0.15141164f, -0.24460305f, -0.21928146f, 
    0.07890488f, -0.15915418f, -0.14196397f, 0.05599374f, 0.11933935f, -0.06560133f, 0.07426044f, 0.06466578f, 
    -0.00657728f, 0.11262664f, 0.11725457f, -0.03911199f, 0.02814099f, 0.03783716f, 0.07199895f, 0.15077601f, 
    0.03774064f, -0.05587885f, -0.08554086f, -0.01766545f, 0.01762204f, 0.02051773f, -0.03986790f, 0.03703007f, 
    0.10921017f, -0.00534629f, -0.05911938f, 0.20539893f, 0.04223261f, -0.17095469f, -0.02410712f, 0.12272918f, 
    -0.10244192f, -0.30821493f, -0.07671174f, -0.07690949f, -0.09721987f, 0.10365655f, -0.11705957f, 0.06198644f, 
    0.05118829f, 0.10435046f, 0.02740036f, -0.00873515f, 0.17011197f, 0.01475002f, 0.00559970f, 0.00788056f, 
    0.21508212f, 0.06293330f, -0.05606516f, 0.13054566f, 0.12916048f, 0.05168056f, 0.07968691f, 0.04053764f, 
    0.35659012f, 0.08312330f, 0.31178588f, -0.12553501f, 0.11927854f, -0.05283427f, -0.14187464f, -0.06070082f, 
    0.10094206f, 0.04605702f, 0.05009473f, 0.09391278f, -0.00390255f, 0.22117038f, 0.01754566f, -0.18499310f, 
    -0.21871990f, -0.13098581f, -0.03879428f, 0.00435816f, 0.22543053f, 0.02723646f, -0.04542584f, -0.09444290f, 
    -0.12396581f, 0.15818931f, -0.12498249f, 0.19694775f, 0.04989693f, 0.08165959f, 0.05812509f, -0.02255944f, 
    -0.03409941f, 0.01618402f, 0.12621164f, -0.15863268f, -0.09418422f, -0.13225774f, -0.07610171f, 0.02960935f, 
    -0.17668119f, -0.08935827f, 0.01955217f, -0.02774512f, -0.03174231f, 0.00905220f, 0.06479020f, 0.03946394f, 
    -0.14532985f, -0.06328330f, -0.02161675f, -0.14434330f, 0.07507837f, 0.04816649f, 0.01547937f, -0.01098560f, 
    -0.00898756f, 0.01215663f, -0.13124794f, -0.09782267f, 0.22991100f, -0.24862508f, -0.02119858f, -0.13646118f, 
    -0.08857982f, -0.07066967f, -0.05390631f, -0.00043453f, 0.03709864f, 0.00822603f, 0.00967163f, 0.06717059f, 
    0.46676242f, -0.13957991f, -0.09473977f, -0.10726658f, -0.05145785f, 0.04899575f, -0.05153182f, 0.04996393f, 
    -0.01098920f, 0.08921618f, 0.04235905f, -0.10288107f, -0.11688764f, 0.16410406f, -0.11729604f, -0.20706265f, 
    -0.07521596f, -0.04933756f, -0.05164783f, -0.04786009f, 0.18389936f, 0.16222109f, 0.00585369f, 0.04685644f, 
    -0.01056428f, -0.01013939f, -0.03515551f, -0.05968317f, 0.11882963f, 0.12348887f, 0.13266075f, 0.04728602f, 
    0.02274154f, -0.04913921f, -0.18475607f, 0.07370536f, -0.04364768f, 0.00285139f, -0.01249593f, 0.00752249f, 
    -0.16680411f, -0.06982350f, 0.04173144f, 0.07255054f, 0.03313171f, 0.03933942f, -0.02317877f, 0.05597329f, 
    -0.36026263f, 0.06682217f, 0.13896504f, -0.09371184f, 0.18020804f, 0.05303120f, 0.06444938f, 0.08130947f, 
    0.01725313f, 0.10219070f, 0.14250994f, 0.02787613f, -0.30111822f, 0.00394780f, -0.01070779f, -0.20966096f, 
    0.12415130f, 0.04024452f, -0.09803832f, 0.00664196f, 0.09190124f, 0.10820888f, 0.10427944f, -0.01237940f, 
    0.14996897f, 0.16126037f, -0.11816946f, 0.09288090f, 0.10545018f, 0.15654325f, 0.00935216f, 0.25185093f, 
    0.09524048f, 0.10906526f, 0.11967467f, 0.23019880f, 0.26263130f, 0.02706704f, -0.23034517f, 0.06211294f, 
    0.01044554f, -0.00963299f, -0.02347328f, -0.04104814f, 0.08583281f, 0.14663987f, 0.08507974f, 0.07948268f, 
    -0.04017575f, -0.05498082f, -0.25626466f, 0.01711764f, 0.01293900f, -0.00582947f, -0.00196621f, -0.10693999f, 
    0.02424923f, 0.00131491f, 0.14309134f, 0.01903759f, 0.34740493f, -0.18419206f, -0.06015117f, -0.00926047f, 
    -0.06451644f, -0.01840164f, -0.02238996f, -0.05288992f, 0.18199444f, 0.05834846f, -0.00487398f, 0.04462272f, 
    -0.22983876f, 0.15597609f, 0.30635715f, -0.13948272f, 0.25058478f, 0.06165797f, 0.07044910f, -0.05813285f, 
    0.11019264f, 0.06550650f, 0.06362826f, 0.12266637f, -0.24217208f, -0.14299129f, -0.06990159f, -0.22911759f, 
    -0.03052133f, -0.05859145f, 0.08194579f, 0.03246260f, -0.00390099f, -0.16878971f, -0.05633393f, 0.00091588f, 
    0.14064354f, -0.07785662f, 0.10211769f, 0.12645127f, -0.08519512f, 0.11593898f, 0.13370669f, -0.02071526f, 
    -0.00964309f, 0.19559625f, 0.01716407f, 0.07290320f, 0.00467252f, 0.11766555f, 0.06674935f, 0.07887593f, 
    -0.07725642f, 0.09549735f, 0.02948379f, -0.01008102f, -0.06357371f, 0.12814732f, 0.03926071f, -0.05694529f, 
    0.28313845f, 0.11226237f, -0.19947019f, 0.11000206f, -0.04927037f, 0.10472893f, -0.01345835f, -0.10395486f, 
    -0.03905850f, 0.06556302f, -0.03453839f, 0.09324209f, -0.16433275f, -0.17800081f, -0.05752090f, -0.01580471f, 
    0.04984372f, -0.21472427f, 0.12562430f, 0.15878089f, -0.08488867f, -0.12356658f, 0.09420447f, 0.02051951f, 
    0.00112966f, -0.16918878f, 0.06090712f, -0.03282008f, 0.03678967f, -0.00194557f, 0.12246358f, 0.04517363f, 
    -0.05663336f, 0.04032039f, -0.05964737f, 0.06619196f, 0.03908837f, 0.01533167f, -0.22631375f, -0.01644404f, 
    0.00141509f, 0.07712943f, -0.21350132f, 0.09642875f, -0.05799479f, -0.12229223f, 0.03834821f, -0.06304069f, 
    0.09255631f, 0.02176009f, -0.12750423f, 0.09936797f, 0.01387709f, 0.03929945f, 0.01942186f, 0.10524025f, 
    0.04691172f, 0.13433449f, 0.19522676f, 0.06172653f, -0.10184333f, 0.00943042f, 0.01634909f, 0.23045385f, 
    -0.08020186f, -0.15435636f, 0.02154594f, -0.07533100f, -0.01008121f, -0.06711023f, -0.04536837f, -0.04911302f, 
    -0.17920981f, 0.24499854f, -0.15418927f, -0.35026416f, 0.08599456f, 0.08175917f, -0.01414914f, -0.11453304f, 
    0.01494674f, 0.03995691f, 0.07891494f, 0.05728474f, -0.21414359f, 0.09203997f, -0.09568824f, -0.21417156f, 
    0.20354928f, -0.01555050f, -0.04261281f, 0.08281110f, -0.04238708f, 0.00175042f, -0.00802831f, -0.07052407f, 
    0.24385516f, 0.03387003f, 0.10645866f, 0.18497606f, 0.05577913f, 0.09374098f, 0.00638728f, 0.09798658f, 
    0.01130827f, -0.05649546f, -0.11357320f, -0.17153615f, 0.07871930f, 0.08489046f, 0.07669017f, 0.13283692f, 
    -0.02107498f, -0.03077121f, 0.01073955f, 0.09617086f, -0.00201246f, -0.08540824f, -0.00143694f, 0.14319243f, 
    0.02340896f, -0.16904676f, -0.08283278f, 0.21832643f, -0.08895244f, 0.00647214f, -0.06286400f, 0.05812572f, 
    0.05044057f, 0.03395829f, -0.04148064f, -0.01478957f, 0.23118773f, 0.10733364f, 0.02409609f, -0.08867870f, 
    -0.00635215f, -0.02063453f, -0.14048730f, 0.01350234f, 0.10904004f, -0.03095867f, -0.05298271f, -0.09592118f, 
    -0.00829540f, 0.03070334f, 0.22565028f, 0.01492682f, 0.10161226f, 0.00537976f, 0.06223230f, 0.00921655f, 
    0.10195918f, 0.05377648f, 0.10630550f, -0.13582754f, 0.15043309f, 0.10797244f, -0.05593811f, -0.08777186f, 
    -0.09192759f, 0.07882868f, 0.07670094f, -0.02213966f, 0.11401933f, 0.09432468f, -0.05560079f, -0.01582989f, 
    0.02259241f, -0.06555968f, -0.00357106f, -0.04651972f, -0.02233991f, -0.00438504f, -0.04774893f, 0.06470405f, 
    -0.05394431f, 0.01561250f, -0.07411864f, -0.06923017f, -0.04569495f, 0.02384330f, -0.00341386f, -0.03254353f, 
    0.01803258f, -0.05444172f, -0.02632878f, -0.04178310f, -0.02095293f, -0.04495294f, 0.06304127f, 0.01043875f, 
    0.05558249f, -0.07545394f, 0.02995075f, -0.04435261f, 0.00807728f, -0.00402473f, -0.03646950f, 0.02781826f, 
    0.03453521f, 0.00950057f, -0.04078315f, -0.02244305f, -0.04094121f, -0.01707109f, -0.01788687f, 0.04238249f, 
    -0.02217211f, -0.07105085f, 0.00334262f, -0.02789612f, 0.02857666f, -0.01330970f, 0.00228359f, -0.04857182f, 
    0.04511750f, -0.04554211f, -0.00737072f, 0.06300993f, -0.04295110f, 0.02622181f, 0.01843368f, 0.01562367f, 
    0.04862635f, -0.02975403f, -0.06564976f, 0.06352388f, 0.05804459f, -0.06752148f, -0.00130806f, 0.06492639f, 
    -0.07668706f, 0.04228575f, -0.05436335f, -0.00884548f, 0.03542330f, 0.00328142f, -0.04000272f, -0.03476949f, 
    -0.00088752f, -0.03051626f, 0.03898418f, 0.02675022f, 0.04514870f, 0.05721380f, -0.01965542f, 0.01796554f, 
    -0.05554269f, -0.00988913f, -0.00516773f, -0.06866024f, 0.02478269f, -0.05141938f, -0.01703340f, -0.04207276f, 
    0.05531560f, -0.05559390f, -0.03108831f, -0.05934718f, -0.07515526f, -0.01929672f, 0.02721372f, -0.01953829f, 
    -0.00893469f, -0.01850125f, -0.01206154f, -0.05385570f, -0.01271969f, -0.07683912f, -0.04953828f, 0.04146628f, 
    -0.04720481f, -0.05322096f, 0.00452844f, 0.02025925f, 0.00304959f, -0.07625483f, -0.00982883f, 0.03711425f, 
    -0.04257584f, -0.03984297f, -0.00686204f, -0.00013880f, 0.03738100f, 0.00274994f, 0.01748082f, -0.02567748f, 
    0.01580996f, 0.04558529f, 0.06075678f, -0.04572743f, -0.00554840f, 0.05779108f, -0.02880793f, 0.00414227f, 
    0.04097344f, 0.00566489f, 0.05820616f, 0.00726630f, 0.04893637f, -0.04329471f, 0.06109477f, -0.00306214f, 
    -0.02692856f, -0.07720249f, -0.00950011f, 0.06573660f, -0.01838634f, 0.00794288f, 0.06113543f, -0.06579477f, 
    -0.01426266f, 0.00804830f, 0.01020664f, -0.05374453f, -0.01847422f, 0.02790134f, -0.03755029f, 0.04809244f, 
    0.00291518f, -0.05161088f, -0.04605256f, 0.03025252f, 0.03357551f, -0.01760181f, -0.03416186f, -0.07424182f, 
    0.01290139f, 0.01596276f, 0.05004258f, -0.04105336f, -0.03302398f, -0.01727610f, -0.06726835f, 0.00022169f, 
    0.02684545f, -0.00355136f, -0.01276689f, -0.07058476f, -0.07349111f, 0.02306473f, -0.03644075f, -0.05146686f, 
    -0.04585477f, 0.00731386f, 0.03099089f, -0.07330415f, 0.01906467f, -0.01850354f, 0.06086719f, -0.03499097f, 
    -0.02960610f, 0.06604947f, -0.05641231f, -0.03021415f, -0.04046757f, -0.02097881f, -0.00649983f, 0.04051664f, 
    0.06144159f, 0.03251326f, -0.00822369f, -0.00183731f, -0.02677718f, -0.07595550f, -0.06039553f, -0.02786818f, 
    -0.03261327f, -0.02776378f, 0.06493247f, 0.06189261f, -0.06697691f, -0.05700124f, -0.05208059f, 0.02230892f, 
    -0.04225586f, -0.07075011f, 0.00251156f, 0.01042837f, 0.05090407f, -0.05669504f, -0.03261454f, -0.05217294f, 
    -0.04323047f, -0.00270436f, 0.03906540f, -0.02491820f, -0.07467227f, -0.00991877f, -0.05470172f, -0.01336289f, 
    0.03512811f, -0.07321426f, 0.00598047f, 0.04420301f, 0.02317066f, -0.04260149f, 0.02729058f, -0.05290453f, 
    -0.02690426f, -0.01755723f, -0.02436524f, 0.01749082f, -0.06323630f, -0.00140654f, -0.03596001f, -0.07057121f, 
    -0.06058294f, 0.06434825f, 0.06304786f, 0.06270111f, -0.04524306f, -0.01385768f, -0.07033213f, 0.06077402f, 
    0.00111843f, -0.06906814f, -0.00048026f, -0.06969569f, 0.03693158f, 0.01643435f, -0.01562081f, -0.04486766f, 
    -0.00872036f, -0.04290592f, -0.04499377f, -0.02063158f, -0.04349724f, -0.07163835f, -0.07675240f, -0.00408234f, 
    -0.03491476f, 0.05377137f, -0.07642236f, -0.01318714f, -0.01433540f, -0.01001318f, -0.06078515f, -0.02192666f, 
    -0.02025319f, 0.05207746f, 0.04661129f, -0.02064467f, -0.00878144f, -0.01565765f, -0.03475687f, -0.01814136f, 
    -0.04073012f, 0.01576074f, -0.03440546f, 0.05744014f, 0.05668682f, -0.06480319f, -0.05228266f, 0.04772449f, 
    0.05681822f, -0.07066939f, -0.04508470f, 0.03132150f, -0.02309383f, 0.05387295f, -0.01661344f, 0.03478131f, 
    0.00025140f, -0.02143696f, -0.02487404f, -0.06414244f, -0.00745381f, 0.03923453f, 0.03252073f, 0.05955964f, 
    -0.01602286f, -0.02478858f, -0.03862879f, -0.03341065f, -0.07516850f, 0.03814792f, 0.05186287f, 0.01048585f, 
    0.06649196f, -0.04080967f, -0.02907243f, 0.00558058f, 0.02238414f, -0.05172235f, -0.03443909f, 0.00370235f, 
    0.04308138f, -0.07516058f, 0.05392333f, 0.07026315f, 0.02323311f, -0.02913337f, 0.03409283f, 0.05893780f, 
    0.01745243f, 0.00483059f, 0.06115953f, -0.04332780f, 0.03149154f, -0.04633322f, 0.02614686f, 0.03006339f, 
    -0.06141197f, -0.01617382f, -0.06203264f, -0.01559557f, -0.02296607f, -0.00323685f, 0.01885435f, -0.01979115f, 
    0.00034600f, 0.05760632f, -0.02186898f, 0.02880469f, -0.07175943f, 0.06561555f, -0.02476388f, 0.01791634f, 
    0.01259132f, -0.05844527f, -0.05240457f, -0.03727648f, -0.03849993f, 0.02481463f, -0.07093856f, -0.00923990f, 
    0.02155605f, -0.00913765f, -0.00778891f, -0.04652030f, -0.01173134f, -0.04724357f, 0.03883593f, 0.03782667f, 
    -0.01472641f, -0.07151407f, 0.01605170f, -0.05540593f, 0.06384032f, 0.02971373f, 0.01462100f, 0.03954875f, 
    0.02858212f, -0.00640626f, -0.05879933f, 0.02455232f, -0.07491113f, -0.05780246f, -0.01502598f, 0.02503259f, 
    0.22152230f, -0.28078365f, 0.01396409f, -0.06033006f, 0.05915104f, 0.02244987f, -0.08047517f, 0.02904768f, 
    0.04461813f, 0.06229052f, 0.02798147f, -0.01876274f, -0.09233631f, 0.08423313f, -0.11385209f, 0.10307655f, 
    -0.00667445f, 0.20075163f, 0.20196737f, 0.08254169f, 0.08751373f, 0.13157773f, -0.01959049f, -0.20162205f, 
    -0.05432435f, 0.20121987f, 0.03897043f, -0.04319521f, 0.10782599f, 0.01077984f, 0.00666257f, -0.06660576f, 
    -0.06110617f, -0.01459259f, -0.00898219f, -0.01790694f, -0.08040240f, 0.23289442f, 0.10471547f, 0.02206516f, 
    0.05253019f, 0.10351959f, 0.00483536f, -0.13913958f, -0.02618203f, 0.00077378f, -0.02920725f, -0.07011346f, 
    -0.02309481f, 0.17483065f, 0.11213788f, -0.05789882f, 0.22256704f, 0.03340436f, -0.07600265f, 0.03863297f, 
    -0.03554337f, -0.05292987f, -0.06759515f, -0.00289419f, -0.08205230f, 0.02750651f, -0.08295960f, -0.00187416f, 
    -0.03429777f, -0.18085068f, -0.21731329f, 0.05115649f, 0.01612571f, 0.02327270f, -0.08662297f, -0.03909423f, 
    -0.17237364f, -0.24807604f, 0.12981915f, -0.06195208f, -0.04254223f, -0.03034373f, 0.04247566f, 0.02333665f, 
    -0.02421657f, 0.01301438f, 0.05756098f, 0.02406998f, 0.12473746f, 0.13152084f, 0.03922878f, 0.08908827f, 
    0.08334144f, 0.09859376f, -0.11973352f, -0.00501489f, 0.12045586f, -0.02958573f, -0.04526461f, 0.06711672f, 
    0.25806835f, 0.15604669f, -0.12708868f, -0.21297184f, -0.00068507f, -0.09966857f, 0.09453224f, 0.06427135f, 
    -0.09960730f, -0.05399653f, 0.00102920f, -0.02041613f, -0.18121140f, 0.21617420f, -0.13598280f, -0.23356196f, 
    0.09553770f, -0.05951874f, -0.02411505f, 0.03623908f, -0.02258445f, 0.04119916f, -0.01254452f, 0.03651716f, 
    0.10128387f, -0.21895660f, 0.09079286f, -0.17852238f, -0.07344270f, -0.11017689f, 0.04500497f, 0.03652807f, 
    -0.05825161f, 0.00075402f, 0.00046927f, 0.09516413f, 0.49504083f, -0.31360331f, -0.04367293f, 0.03078906f, 
    -0.06223182f, -0.02506773f, 0.05314265f, -0.00905336f, -0.03323255f, 0.06872828f, 0.01997456f, -0.02635453f, 
    -0.22438966f, -0.17319135f, 0.14671102f, 0.05026342f, 0.05768629f, 0.02240337f, 0.09706039f, -0.08926598f, 
    0.02311294f, 0.01206545f, 0.00303396f, 0.07306609f, -0.07848274f, 0.14379631f, 0.28600648f, 0.15945697f, 
    0.02969406f, 0.02472443f, -0.01538840f, -0.02596645f, 0.05255724f, -0.00454977f, -0.02656639f, 0.02579775f, 
    0.40593192f, 0.00126582f, 0.02981284f, 0.02107950f, -0.02344637f, -0.07302700f, -0.10290590f, 0.06682341f, 
    0.02184016f, -0.08584689f, 0.09337744f, -0.04433843f, 0.29983109f, 0.04571641f, 0.08473996f, 0.28772822f, 
    0.01079857f, 0.11096927f, -0.10734574f, -0.04521325f, 0.01361005f, 0.07995155f, -0.04846825f, -0.17324202f, 
    -0.02308578f, 0.03684359f, -0.06758834f, 0.05560388f, -0.00670696f, 0.05257615f, -0.01330965f, -0.04755579f, 
    -0.06458050f, 0.05425563f, -0.04393928f, -0.04277002f, 0.00367947f, 0.02704119f, -0.03921417f, 0.02913059f, 
    -0.02394626f, 0.00148991f, -0.02009733f, 0.05644174f, -0.08424184f, -0.00796071f, -0.04944878f, 0.06121475f, 
    -0.05978791f, -0.04904651f, -0.01130553f, 0.06070174f, 0.01166455f, 0.00255330f, 0.03027808f, 0.00907064f, 
    0.04408305f, -0.06723199f, -0.01865658f, -0.03432652f, 0.03081234f, 0.04748718f, -0.06432042f, -0.07051996f, 
    -0.01364481f, -0.08234482f, 0.03173263f, -0.02021937f, 0.03115888f, -0.02951490f, 0.01121573f, -0.04157772f, 
    -0.00879184f, 0.00261650f, -0.02086904f, 0.00576283f, -0.02545005f, 0.04399635f, -0.05416326f, -0.00752285f, 
    -0.02523950f, -0.05699933f, 0.02688520f, 0.01603900f, -0.04819297f, -0.00910714f, -0.02410746f, -0.01493888f, 
    -0.07725503f, 0.05587266f, 0.05885164f, -0.04522521f, 0.03792025f, -0.04597723f, -0.05859837f, -0.02375886f, 
    -0.05051148f, -0.06691395f, 0.01243676f, 0.04802382f, 0.00512685f, 0.02083806f, -0.04498405f, 0.02733152f, 
    -0.05131174f, -0.00543735f, -0.00154719f, 0.00088100f, 0.01812107f, 0.02806321f, -0.05212962f, -0.05462139f, 
    -0.06961247f, -0.00032744f, -0.05886144f, -0.04005699f, 0.07032731f, 0.06172932f, 0.00417792f, -0.03090835f, 
    0.02074926f, -0.04844303f, -0.01717139f, 0.01906763f, -0.06681827f, 0.00770488f, 0.03020606f, 0.04742093f, 
    -0.01485217f, -0.02320075f, -0.06486855f, 0.04500462f, 0.04473855f, -0.01422503f, -0.01123785f, 0.02331652f, 
    0.04680663f, -0.01634082f, -0.01489509f, 0.00423361f, -0.07158956f, -0.07776391f, -0.00845717f, 0.02840341f, 
    0.03838685f, -0.06274838f, -0.06837321f, 0.02478022f, 0.05474726f, -0.04213767f, -0.01419708f, 0.05583454f, 
    -0.02128955f, 0.06693481f, -0.02091984f, -0.06872389f, -0.05563285f, 0.03149635f, 0.03120490f, -0.00731187f, 
    -0.00520166f, 0.04341102f, 0.06093416f, 0.04049944f, -0.07882711f, 0.03724714f, 0.01976384f, -0.00071254f, 
    -0.00096067f, -0.07451627f, 0.04138473f, 0.04463605f, 0.04575907f, 0.00295761f, 0.02125327f, -0.04788594f, 
    -0.04910554f, -0.02052079f, -0.07806759f, -0.00106929f, -0.06773674f, 0.00531469f, -0.02500248f, 0.05423356f, 
    0.02949638f, -0.06598687f, -0.04848726f, -0.00314234f, 0.02863478f, 0.03666739f, -0.03980339f, 0.00671887f, 
    -0.03347483f, -0.04854301f, -0.04006502f, -0.03734263f, 0.01980966f, -0.03245001f, 0.02601106f, 0.03269489f, 
    0.02740943f, -0.00421056f, -0.04416037f, 0.00961245f, -0.05928434f, -0.03813979f, 0.04509691f, 0.02316420f, 
    -0.05093891f, 0.00202796f, -0.04802166f, -0.06586060f, -0.06153444f, 0.06598856f, 0.01567253f, -0.01574965f, 
    -0.02226374f, -0.05900821f, 0.02087262f, -0.01226803f, 0.04533526f, -0.02044113f, -0.06366156f, -0.07246032f, 
    0.01330647f, 0.06328810f, 0.00271240f, -0.06436209f, -0.06319000f, -0.05040134f, -0.06777968f, 0.02513192f, 
    0.01152850f, 0.01820226f, -0.02160104f, 0.03827271f, -0.01768806f, -0.02029732f, 0.02058931f, -0.04696559f, 
    0.02932143f, -0.01992626f, 0.03043370f, 0.03582578f, -0.06149449f, 0.05411153f, -0.03862864f, 0.03358185f, 
    -0.06838743f, 0.05654434f, -0.05488889f, -0.05497558f, 0.01692805f, -0.02794970f, 0.05438800f, 0.04583835f, 
    0.02140580f, -0.02004742f, -0.06062356f, -0.07328940f, -0.01737875f, -0.02027479f, -0.06509824f, -0.03848270f, 
    0.05954797f, -0.02919140f, -0.05673745f, 0.01137554f, -0.02580060f, 0.01508179f, -0.03303595f, 0.04633446f, 
    -0.00686783f, 0.00225570f, -0.04317582f, -0.07447497f, -0.07698578f, -0.03566356f, -0.03749486f, -0.04044468f, 
    -0.00846864f, 0.02300760f, 0.04099428f, 0.03095208f, 0.00925237f, -0.02622613f, -0.03043515f, 0.03777710f, 
    0.03799379f, 0.01618521f, -0.00580632f, -0.02629304f, 0.00163365f, 0.05168428f, -0.02663444f, -0.02601145f, 
    -0.00822083f, 0.03894811f, 0.02109659f, -0.05314730f, -0.03074395f, 0.00975781f, 0.00402493f, 0.05974230f, 
    -0.05729192f, 0.03320372f, -0.05390400f, -0.03293945f, 0.05674350f, -0.05175064f, -0.04941679f, -0.07049429f, 
    -0.01455409f, 0.00361402f, -0.05840021f, -0.02293028f, 0.01663785f, -0.00313720f, 0.04363204f, 0.03917782f, 
    0.03274935f, -0.02722951f, 0.05976223f, 0.04001326f, 0.02367219f, -0.01920738f, 0.01212279f, -0.05557440f, 
    -0.04008352f, -0.02310531f, 0.06531163f, -0.01761145f, 0.02205846f, 0.05465585f, -0.05541396f, -0.01976094f, 
    0.06400680f, 0.00693656f, 0.04447784f, 0.00990143f, 0.03037887f, 0.05333002f, -0.03076928f, -0.01968838f, 
    -0.06494835f, -0.06282640f, 0.03748568f, 0.05980093f, -0.00132539f, 0.02329970f, -0.04697819f, 0.02233689f, 
    -0.07427712f, -0.07188450f, -0.00610297f, -0.03554393f, -0.00223581f, 0.03312923f, -0.07203507f, -0.01693277f, 
    -0.04075114f, 0.02049132f, -0.04935161f, -0.00205008f, -0.02010729f, -0.01629972f, -0.06064990f, 0.00827096f, 
    -0.01884294f, -0.05081871f, -0.02751089f, -0.05152112f, -0.03474331f, -0.06116137f, -0.03288473f, 0.00301523f, 
    -0.00528716f, -0.06114624f, -0.07325941f, -0.02015761f, 0.04751398f, -0.01618632f, 0.06166617f, -0.07467461f, 
    -0.00280402f, -0.02500959f, -0.03953421f, 0.03628672f, -0.04865996f, -0.04880298f, 0.04868724f, 0.00797906f, 
    0.03591327f, -0.03750036f, -0.01986044f, 0.05657124f, -0.00300810f, 0.03146051f, -0.01797902f, -0.02205699f, 
    -0.05673486f, -0.07290831f, -0.02413635f, 0.02753876f, 0.03135307f, 0.03556744f, -0.01138250f, -0.04848405f, 
    -0.06850848f, 0.12923113f, -0.03440410f, -0.07445516f, 0.03748097f, 0.00892338f, 0.00081677f, -0.03497249f, 
    -0.16408639f, 0.06997696f, -0.13844562f, 0.18202697f, 0.11500023f, 0.06152184f, 0.05656977f, -0.25746661f, 
    0.00612789f, 0.06828789f, -0.11908895f, -0.03074300f, 0.15231493f, -0.07961732f, 0.07146183f, -0.00375087f, 
    0.30038008f, -0.10413221f, 0.03077300f, 0.21134150f, 0.03932893f, -0.03831462f, -0.00358828f, -0.03104679f, 
    -0.00190647f, 0.13754894f, 0.06528483f, -0.01784960f, -0.06397341f, 0.19461900f, -0.17832717f, -0.17388827f, 
    0.04683693f, -0.08846125f, -0.03256985f, 0.25336123f, -0.04718336f, 0.13464342f, 0.00058670f, -0.03640100f, 
    -0.18049544f, -0.05195680f, 0.02290729f, -0.20721072f, 0.03839414f, -0.03719202f, 0.11496685f, -0.04491258f, 
    0.04575913f, -0.11065947f, -0.00255956f, -0.06843940f, 0.00357514f, 0.03334567f, -0.00123441f, 0.20416754f, 
    0.10647175f, -0.03019004f, 0.01698287f, -0.13817194f, -0.07948779f, 0.00133898f, -0.05973508f, -0.01608033f, 
    0.25260961f, 0.24642003f, 0.09815448f, -0.01078888f, 0.08398315f, -0.20695554f, 0.14170291f, -0.06879731f, 
    0.17023362f, -0.05152495f, 0.23301648f, 0.02434667f, -0.03236725f, 0.08426434f, -0.13667648f, -0.05025518f, 
    0.00907617f, -0.05811417f, 0.12422638f, 0.14393568f, -0.04466968f, 0.13103905f, 0.02305487f, 0.09532375f, 
    0.11859023f, -0.15059447f, -0.15343985f, 0.02060062f, 0.06342171f, -0.03096911f, -0.06913877f, -0.29753870f, 
    0.03035815f, 0.15865090f, -0.03702394f, 0.06183781f, 0.04523320f, -0.21139364f, -0.17168428f, 0.16829711f, 
    0.06858890f, -0.17967144f, -0.13508585f, -0.12456968f, -0.05493806f, -0.11146507f, -0.05398673f, 0.21969056f, 
    -0.14864375f, 0.08658609f, 0.10249989f, 0.11091156f, 0.08204462f, -0.04672084f, 0.06620304f, -0.03145081f, 
    -0.04391313f, -0.09495501f, -0.08366333f, -0.21605538f, -0.14097863f, 0.10948315f, 0.24343668f, 0.07151440f, 
    0.15252976f, -0.06842429f, -0.09932671f, 0.07155094f, 0.05507114f, -0.07408483f, -0.04202057f, -0.07923894f, 
    0.39009541f, 0.13509442f, 0.32344741f, -0.17389813f, -0.16233639f, 0.11640713f, -0.02016821f, 0.07508443f, 
    0.01017627f, -0.09803814f, -0.11314952f, -0.11738313f, -0.15751953f, 0.18995786f, -0.14782247f, 0.02694140f, 
    -0.09542891f, 0.04519041f, -0.12904818f, -0.04101070f, -0.06916738f, -0.04347826f, 0.00134441f, -0.02608485f, 
    -0.09705397f, 0.08232340f, -0.22871824f, 0.10885854f, 0.00581043f, 0.12315465f, 0.01958605f, -0.05644619f, 
    0.01583205f, 0.07738698f, 0.11223422f, -0.17389227f, 0.02407537f, 0.19343831f, -0.05934397f, 0.19861844f, 
    -0.07131258f, -0.12291906f, 0.02561525f, 0.04438426f, 0.00685256f, 0.05475552f, 0.10150601f, 0.05980877f, 
    -0.06653132f, 0.01297290f, 0.11805177f, -0.09902707f, 0.11852464f, 0.01408531f, 0.08681805f, 0.00248188f, 
    -0.02052581f, 0.10809175f, -0.00559083f, 0.12861232f, 0.03565234f, 0.16226320f, 0.11300679f, -0.00628278f, 
    0.04036250f, 0.09881661f, 0.00470706f, 0.06123643f, 0.03661802f, 0.07750249f, 0.07445543f, -0.08307011f, 
    0.41558149f, -0.03764621f, 0.05490441f, 0.09635025f, -0.06048599f, 0.03235479f, -0.01902117f, -0.05833017f, 
    0.03895243f, 0.03835496f, 0.00511733f, 0.10343762f, -0.08069754f, 0.03407355f, -0.00962678f, -0.01743286f, 
    0.03594211f, -0.04864733f, 0.02725239f, 0.12569967f, -0.10626962f, 0.08154079f, 0.07696564f, -0.04338809f, 
    -0.22042915f, 0.06872912f, 0.08389606f, 0.05147719f, 0.03693316f, 0.01541096f, 0.01292266f, -0.02407004f, 
    -0.02755415f, 0.05780571f, -0.08344696f, 0.07255056f, 0.08106869f, -0.06527787f, 0.02359165f, 0.15179095f, 
    0.12212787f, 0.11454303f, -0.03822584f, -0.02174710f, -0.04078005f, -0.10372464f, -0.03150471f, -0.01978096f, 
    0.16146520f, -0.02855166f, -0.11196314f, 0.30313101f, -0.00411858f, -0.12114199f, -0.07608952f, -0.04440582f, 
    -0.12148634f, 0.01177156f, 0.18660004f, -0.04964803f, 0.00012104f, 0.01329777f, -0.16266593f, -0.03205297f, 
    -0.08671456f, -0.07872210f, 0.08472195f, -0.04286461f, 0.04866449f, 0.03192941f, 0.05061809f, 0.04712446f, 
    0.01587806f, -0.04440574f, -0.14786899f, -0.10132483f, 0.04964724f, 0.00392790f, 0.06120839f, -0.09344244f, 
    0.01582212f, -0.01085209f, -0.00315367f, -0.08548021f, 0.04651192f, 0.03576037f, -0.05705741f, 0.05823837f, 
    -0.09597678f, 0.02955974f, 0.01797181f, 0.07228450f, -0.08901813f, 0.10104777f, 0.03224959f, 0.06899128f, 
    -0.03515328f, 0.07480729f, 0.05552359f, 0.14563875f, -0.00974968f, -0.06244009f, -0.01285657f, -0.12480547f, 
    -0.00213819f, 0.07975284f, -0.00553929f, -0.12399245f, -0.37506384f, 0.03528957f, 0.30774248f, 0.02924783f, 
    0.14432585f, -0.06520674f, -0.03112428f, 0.14680894f, -0.11976404f, -0.09150468f, -0.00441800f, 0.03993395f, 
    0.04296494f, -0.07709061f, 0.01321555f, 0.19316238f, -0.00750984f, 0.02730623f, 0.13349986f, 0.09741513f, 
    0.08962428f, 0.05871999f, -0.18340723f, -0.05011661f, -0.22190115f, 0.33349946f, -0.11748254f, 0.07986345f, 
    -0.02081033f, 0.07119446f, 0.06668223f, 0.09043233f, 0.06083646f, 0.08750205f, -0.00380781f, -0.06744106f, 
    -0.27900296f, -0.17355028f, 0.06210323f, 0.14120626f, 0.00631476f, 0.15617524f, 0.01690545f, 0.00716500f, 
    0.00612356f, 0.08664031f, 0.00527127f, -0.13294330f, 0.23819035f, 0.14490390f, 0.07644390f, 0.06171301f, 
    -0.20115645f, 0.02180860f, 0.02267122f, -0.01923604f, -0.03341550f, 0.05572122f, 0.02396775f, 0.06271081f, 
    -0.00117844f, 0.03983096f, -0.07012887f, -0.02096737f, 0.05962949f, 0.02621593f, 0.05351667f, -0.04364600f, 
    -0.00665981f, -0.01116220f, -0.02599418f, 0.06581002f, -0.07025266f, -0.03637952f, 0.01432576f, 0.02001228f, 
    0.04528299f, -0.02812148f, 0.05433377f, 0.03265770f, 0.00140859f, -0.04446774f, -0.03412791f, -0.04010942f, 
    -0.04531344f, 0.05810928f, 0.03300336f, -0.03389700f, 0.04845931f, 0.02932484f, 0.01556717f, 0.06642642f, 
    -0.05841801f, -0.06698635f, 0.03808203f, -0.04749739f, 0.03866681f, -0.02749275f, -0.06281796f, 0.02060702f, 
    -0.06400757f, -0.02472125f, 0.03591479f, -0.00911157f, 0.06006643f, -0.02155867f, -0.06448409f, 0.05634972f, 
    -0.06916465f, -0.06945852f, -0.06770215f, -0.05631585f, -0.04841651f, -0.06574260f, -0.06904373f, -0.05632753f, 
    0.00824465f, -0.06205022f, 0.04711550f, 0.06500968f, -0.05197356f, 0.01299109f, -0.02228068f, 0.04823249f, 
    -0.06609640f, 0.02195235f, -0.01156627f, -0.04030907f, 0.03086154f, -0.04098934f, -0.00909127f, 0.02726382f, 
    0.03936960f, -0.04161852f, -0.06432666f, 0.00970919f, 0.04861403f, -0.02603557f, -0.03046068f, -0.05509112f, 
    0.00551793f, 0.00820267f, -0.05520707f, 0.02699320f, -0.07153485f, -0.06305841f, -0.03000504f, -0.05715568f, 
    0.01494154f, -0.07201090f, -0.02368766f, -0.03167316f, 0.03053138f, 0.05696608f, 0.05536734f, -0.01670949f, 
    0.01433937f, -0.03669731f, 0.04603129f, -0.01115467f, 0.03712514f, -0.06634317f, 0.01275893f, 0.05060836f, 
    -0.06381604f, -0.04466220f, -0.01976845f, 0.06826043f, -0.03369490f, 0.02114670f, -0.04462961f, -0.05211835f, 
    -0.01278444f, -0.06069941f, -0.06440344f, 0.03653308f, 0.04824766f, -0.01009345f, 0.05033938f, 0.01225423f, 
    0.03101420f, 0.05761967f, -0.03127500f, 0.03915127f, -0.02819265f, -0.06627096f, -0.00887410f, 0.07090133f, 
    -0.00945511f, -0.06832437f, 0.04485050f, -0.02697635f, 0.00705510f, -0.07037617f, 0.04840523f, -0.02302668f, 
    0.03924966f, -0.02364244f, -0.06981650f, -0.05745759f, 0.00645307f, 0.07108673f, 0.01678750f, -0.03004741f, 
    0.04550796f, 0.06673679f, 0.03251046f, -0.04838165f, -0.04457393f, -0.04900610f, 0.05195292f, -0.00511940f, 
    -0.00993275f, -0.02612848f, 0.02624024f, -0.04957543f, 0.03150879f, -0.03426138f, -0.00347132f, -0.00407457f, 
    0.03651588f, -0.02338195f, -0.04147811f, -0.02717594f, -0.00610602f, 0.06391963f, -0.06937685f, -0.01303135f, 
    0.05914702f, -0.00969204f, 0.03753709f, 0.02206347f, -0.03091492f, 0.06189444f, 0.00146342f, -0.05843361f, 
    -0.07043163f, -0.02413729f, 0.03345796f, 0.00597441f, -0.05103051f, 0.04243113f, 0.05024437f, -0.01071867f, 
    -0.04662108f, -0.04118546f, -0.05834403f, -0.06968144f, 0.03032774f, -0.00919670f, -0.00216732f, -0.02878683f, 
    0.05641362f, -0.07143191f, -0.03952174f, 0.01620870f, -0.05843277f, -0.01208579f, -0.03073162f, 0.03612926f, 
    -0.03672235f, -0.02005283f, -0.02999646f, -0.04559745f, 0.04642666f, -0.05747303f, 0.00955616f, -0.07174921f, 
    0.01109472f, -0.07961460f, -0.01783531f, -0.01736144f, 0.00949318f, 0.05592091f, 0.05384203f, 0.03254580f, 
    0.02143875f, -0.01649021f, -0.03396488f, -0.02653081f, -0.06452785f, -0.04545106f, 0.04540832f, -0.03320707f, 
    0.05182383f, -0.02972975f, 0.00101755f, 0.03140444f, 0.03791216f, -0.01761286f, 0.02788432f, 0.01609169f, 
    -0.02822644f, -0.04999219f, 0.02427728f, -0.02833296f, -0.04168224f, -0.05596710f, 0.06655169f, -0.07568578f, 
    -0.05601461f, -0.07252908f, 0.03656062f, -0.08383647f, 0.05895285f, -0.04772220f, -0.06928988f, 0.02219267f, 
    -0.06595517f, -0.03439054f, -0.04487652f, -0.01872492f, -0.05106425f, -0.05753089f, -0.07842516f, 0.05081434f, 
    -0.01479493f, -0.05645778f, -0.00607397f, -0.06676760f, 0.01488202f, -0.04841825f, 0.01343686f, 0.02689299f, 
    -0.03674965f, 0.05981014f, -0.01662664f, -0.01780328f, 0.01172682f, -0.03039687f, -0.02134268f, -0.02543996f, 
    0.03557809f, -0.03068306f, -0.00758345f, -0.03589358f, -0.01648516f, -0.03476804f, 0.00613371f, -0.08491170f, 
    0.06348305f, -0.03961828f, 0.00914707f, -0.07009910f, -0.01817846f, 0.02690803f, -0.04643888f, -0.02088782f, 
    -0.07521962f, 0.00367134f, 0.02181266f, 0.03878498f, -0.00543962f, -0.03932520f, 0.00885864f, 0.03968684f, 
    -0.04143685f, -0.07246318f, 0.03558368f, -0.03027800f, -0.01901685f, 0.05424852f, -0.07006243f, -0.00446824f, 
    -0.05767278f, -0.01869103f, -0.04516307f, 0.04334685f, -0.03412506f, 0.03157968f, -0.03067721f, -0.00314939f, 
    0.03399780f, 0.03739960f, -0.08699447f, 0.05660945f, -0.08437726f, 0.02542075f, 0.04220430f, -0.00971527f, 
    -0.05187720f, -0.05038477f, 0.04758092f, 0.00636641f, -0.00272848f, -0.01844981f, -0.06896945f, 0.03395652f, 
    -0.07721371f, 0.03313660f, -0.07768679f, 0.01506990f, -0.07434428f, 0.01005048f, 0.01603131f, 0.05561330f, 
    -0.08042832f, -0.02337636f, -0.02347286f, 0.04446930f, -0.01284371f, 0.00844942f, -0.04748528f, 0.00600768f, 
    -0.07411616f, 0.00847040f, -0.04562666f, 0.05394641f, -0.05034372f, 0.01161590f, 0.03469281f, -0.02927538f, 
    -0.01290223f, -0.05046526f, 0.01833633f, 0.00190744f, 0.03757124f, -0.08418810f, -0.05136173f, -0.03216954f, 
    -0.05300253f, -0.03508512f, 0.05922635f, -0.03984600f, -0.04702174f, -0.02904668f, -0.09108550f, -0.06164690f, 
    0.04044358f, 0.00529446f, -0.07884434f, -0.01211167f, -0.08133981f, -0.00563314f, -0.04775358f, 0.00643653f, 
    0.04522339f, -0.00664326f, 0.06481430f, -0.04648474f, -0.00791593f, -0.03101249f, 0.02839736f, 0.02616366f, 
    -0.08427700f, -0.07629376f, 0.29467285f, -0.09943438f, -0.21347292f, 0.11450327f, 0.02770419f, 0.16484389f, 
    -0.07779069f, 0.21766558f, -0.05695901f, 0.13975576f, 0.10997403f, 0.07302575f, 0.14599019f, -0.11468328f, 
    -0.07437251f, -0.01872955f, -0.13503338f, 0.02816661f, -0.03317751f, 0.01805260f, -0.03455882f, -0.12813954f, 
    0.08790344f, -0.10708220f, 0.05434923f, 0.06987650f, -0.03768549f, 0.01614143f, -0.15003096f, 0.13976812f, 
    0.12464973f, 0.09606587f, -0.04879024f, 0.15003608f, -0.10923555f, -0.04711545f, -0.22635064f, 0.14757618f, 
    0.08148204f, -0.20532605f, 0.09516261f, 0.18314716f, -0.08919571f, 0.02619829f, 0.13259184f, -0.02035506f, 
    -0.17011948f, 0.00742664f, 0.01174947f, 0.17002364f, 0.08010906f, 0.06164448f, 0.14382106f, -0.05748034f, 
    -0.02337891f, 0.03534483f, -0.06510213f, 0.01163146f, 0.17819308f, 0.03888868f, -0.03827310f, 0.18312669f, 
    0.02227724f, -0.06747309f, -0.17703840f, 0.05911061f, -0.05457434f, 0.05012452f, 0.07532627f, 0.08857803f, 
    0.20574652f, 0.02518577f, -0.13049659f, -0.06233546f, -0.04422224f, 0.04510183f, 0.00818570f, 0.06985004f, 
    0.16213904f, 0.08597448f, 0.28119624f, 0.03329791f, -0.15977670f, 0.02673549f, 0.04760281f, 0.22959022f, 
    0.03383517f, -0.11655208f, -0.08475759f, 0.08460989f, -0.06219180f, -0.03720612f, 0.06080772f, 0.09914418f, 
    0.08953522f, -0.15829314f, -0.30378807f, 0.13176638f, 0.06623167f, 0.16502006f, 0.07157201f, -0.03401469f, 
    0.04063370f, -0.08946602f, -0.07747548f, -0.10962375f, -0.05693093f, -0.07115499f, -0.10121460f, 0.05836992f, 
    0.12114744f, -0.01280568f, -0.00693652f, 0.01555163f, 0.06836583f, -0.08138725f, -0.08728093f, 0.02747330f, 
    -0.00911948f, 0.07167208f, -0.00971130f, 0.01445919f, 0.01829148f, -0.02582056f, 0.09971258f, -0.06253888f, 
    -0.08269496f, -0.11557061f, -0.15146342f, -0.13944677f, -0.06043158f, 0.21671622f, 0.11676100f, -0.04689664f, 
    -0.02157587f, -0.00909074f, -0.11586350f, 0.13056065f, -0.04626922f, -0.23484199f, -0.09120087f, -0.02576365f, 
    0.23399769f, -0.00153905f, 0.20512912f, -0.19442876f, -0.10960424f, 0.11420566f, 0.01062284f, 0.23234797f, 
    -0.02729842f, 0.07245652f, -0.11856210f, -0.07262800f, 0.07884063f, 0.06282916f, -0.09411348f, 0.05992518f, 
    0.14416601f, 0.03777329f, -0.01565503f, 0.07934833f, -0.03885434f, -0.00619547f, 0.02657126f, -0.11217075f, 
    0.23451230f, 0.06972446f, -0.20023321f, -0.02807072f, -0.17235352f, 0.11813462f, 0.10567608f, 0.15911226f, 
    0.05978070f, 0.00789494f, 0.06162157f, -0.10340530f, -0.02231795f, 0.12134495f, -0.08771669f, 0.13589272f, 
    -0.14115199f, -0.09672029f, -0.03693565f, -0.04333834f, 0.07093742f, 0.09215835f, -0.02008174f, 0.11139317f, 
    -0.13026445f, 0.12374205f, 0.16851406f, -0.12466194f, 0.05360348f, 0.00733334f, 0.09891081f, -0.01775575f, 
    -0.04634575f, 0.15582837f, 0.03138225f, 0.07434250f, 0.26342204f, -0.03973978f, 0.18640587f, -0.09135576f, 
    0.07310338f, -0.04212682f, -0.08557791f, 0.04465846f, -0.04762986f, -0.08265636f, 0.09540281f, 0.13836467f, 
    0.08122446f, -0.01777987f, 0.06174206f, 0.05420576f, 0.03220084f, -0.03017210f, -0.03642937f, -0.02156822f, 
    -0.00668578f, 0.07871155f, 0.01800564f, 0.11325260f, 0.14308619f, -0.09028480f, -0.12005284f, -0.07871920f, 
    -0.03293521f, 0.07791754f, -0.01885642f, 0.13571471f, -0.00614624f, 0.06353421f, 0.11419109f, 0.12526517f, 
    0.05254869f, -0.00163228f, 0.02697436f, -0.21495196f, -0.08937001f, 0.04881857f, 0.04983703f, 0.01729922f, 
    -0.05876695f, -0.08358607f, -0.08972147f, 0.12280955f, 0.01121799f, 0.08981337f, 0.03459965f, 0.16996129f, 
    0.11978560f, 0.05684815f, 0.01164954f, -0.05228747f, 0.06848383f, -0.00033562f, -0.16950141f, -0.00309559f, 
    0.17043379f, 0.17555237f, 0.06360449f, 0.14218885f, 0.18756032f, -0.06183658f, 0.08971631f, -0.08149976f, 
    0.07794859f, 0.08677376f, 0.18002072f, -0.14278163f, -0.03096951f, 0.17411852f, -0.10934196f, -0.08673919f, 
    -0.14605986f, 0.02066207f, 0.18573099f, 0.14232792f, -0.17118318f, -0.11769315f, 0.11925573f, 0.01058086f, 
    -0.24686550f, -0.26157096f, -0.12140780f, -0.00020147f, 0.10986005f, 0.01486347f, -0.08428521f, -0.26555386f, 
    0.01796557f, 0.10786141f, -0.06931103f, 0.13855837f, -0.08049040f, -0.18462043f, -0.26118812f, 0.15314379f, 
    0.03787422f, -0.16189545f, -0.16808224f, -0.12738509f, -0.05494076f, -0.10670892f, 0.07715290f, 0.06233787f, 
    0.17429812f, 0.04088740f, -0.00196977f, -0.06854201f, -0.01216619f, -0.05804246f, -0.09442332f, -0.09230244f, 
    0.09773891f, 0.13100193f, 0.14357209f, -0.10088604f, -0.16416194f, 0.08390608f, 0.08771313f, -0.04512758f, 
    0.18081863f, 0.04579368f, -0.03333858f, -0.01303811f, -0.06019877f, -0.03642011f, -0.00791183f, 0.07780483f, 
    0.18240200f, 0.35284659f, 0.00836861f, -0.24120347f, -0.03435122f, 0.03792380f, 0.13802530f, -0.04128351f, 
    -0.03604497f, -0.00602462f, 0.03702519f, -0.03759663f, -0.03293588f, 0.19798619f, -0.22574277f, -0.01989367f, 
    0.09878973f, -0.01029967f, -0.00829610f, 0.13016871f, 0.02522868f, 0.13915744f, -0.00779216f, -0.02859564f, 
    -0.39368781f, -0.10272725f, 0.12623788f, 0.06246160f, -0.04396517f, -0.00598340f, 0.11552931f, -0.11649611f, 
    0.06551106f, 0.01246013f, 0.07904516f, 0.05781604f, 0.22327788f, -0.01149820f, 0.03789724f, -0.00853869f, 
    -0.04595387f, 0.03953671f, 0.14732520f, 0.04434696f, -0.15172058f, 0.03169286f, 0.12556143f, 0.00644965f, 
    0.07070172f, -0.12021644f, -0.06642360f, 0.00150105f, 0.19989108f, 0.01228745f, -0.08186483f, 0.09686867f, 
    -0.04880670f, 0.01998314f, -0.04041124f, 0.06424230f, -0.16351630f, -0.01962032f, -0.12512220f, 0.03370832f, 
    0.08856431f, 0.00185365f, 0.17125387f, 0.00766859f, 0.18352927f, -0.12402581f, 0.00471435f, 0.13101627f, 
    -0.11325530f, 0.01527897f, 0.17690462f, -0.08671461f, -0.08912437f, -0.02804901f, 0.18574154f, 0.05272238f, 
    0.08161923f, -0.11016826f, 0.01920866f, -0.08176314f, 0.01078995f, 0.07825179f, -0.03879192f, 0.06653737f, 
    -0.00922563f, 0.17014132f, 0.00498292f, 0.02597754f, 0.10212213f, 0.03195782f, -0.15972865f, -0.00025800f, 
    -0.54563254f, 0.25123331f, -0.17184149f, -0.05661506f, 0.03917265f, -0.08386789f, -0.14517629f, 0.06267624f, 
    -0.04374768f, -0.02409649f, 0.03424876f, -0.10591801f, -0.13205522f, -0.11932164f, 0.11939892f, 0.18479916f, 
    0.05711816f, 0.09094576f, 0.24499826f, 0.01743433f, 0.11551905f, 0.07268353f, 0.05800674f, 0.14679138f, 
    -0.03581233f, 0.07061531f, 0.10868767f, 0.40967399f, -0.10592312f, -0.11485330f, 0.02775637f, 0.08283321f, 
    -0.04449809f, -0.05630662f, -0.12150896f, 0.06646634f, -0.24617964f, -0.15191054f, -0.18876241f, -0.12954460f, 
    0.08384787f, 0.06047713f, -0.01137407f, -0.03986312f, 0.11458167f, -0.03185049f, 0.19836640f, -0.07548780f, 
    -0.05910505f, -0.15826923f, 0.16262256f, 0.20474774f, 0.01138215f, -0.05212543f, -0.01624147f, -0.02677727f, 
    0.15340757f, -0.03101120f, -0.00526663f, 0.01332101f, 0.28258616f, -0.02218304f, 0.13156623f, 0.35456401f, 
    -0.04431823f, -0.03319052f, 0.05557420f, 0.05130070f, 0.03619412f, 0.03505982f, 0.04508808f, 0.02077790f, 
    -0.08398796f, 0.00322468f, 0.07224115f, 0.08167090f, -0.07556887f, -0.07051948f, -0.11459467f, 0.04818684f, 
    0.02328367f, 0.15232600f, 0.17488530f, 0.12248973f, -0.22861281f, 0.13960950f, 0.12061480f, 0.13538525f, 
    -0.03619602f, 0.00635914f, 0.15945166f, -0.02284097f, 0.01796930f, 0.04714022f, 0.10646865f, 0.13891923f, 
    -0.13964461f, 0.02528400f, -0.07246929f, 0.01185649f, 0.11164903f, -0.01684419f, 0.15218531f, -0.07387784f, 
    0.04482035f, 0.02728027f, 0.03292577f, -0.07446534f, -0.38405544f, 0.31858066f, -0.13352680f, -0.13318920f, 
    -0.00549856f, -0.01851514f, -0.00149206f, 0.07691070f, 0.07441826f, 0.00877744f, 0.02618235f, 0.04683946f, 
    -0.27454111f, -0.17555095f, 0.19595313f, 0.21286722f, -0.03824559f, -0.01955263f, 0.14483400f, -0.04641438f, 
    0.02295904f, 0.09302918f, -0.04786824f, 0.08599898f, 0.05379871f, -0.27187780f, 0.07998985f, 0.12419290f, 
    0.05410863f, 0.09765264f, 0.03554392f, 0.01865565f, -0.14291961f, -0.04275270f, 0.00246751f, 0.09025861f, 
    0.05221934f, 0.23831107f, -0.16091853f, -0.11373816f, 0.02858995f, -0.05648289f, 0.04139695f, 0.01536931f, 
    0.06512989f, -0.20196949f, -0.02319083f, -0.05605078f, 0.20931424f, 0.00568525f, 0.07170513f, 0.19813338f, 
    -0.08210454f, -0.09209040f, 0.03696973f, 0.11343262f, 0.05534306f, -0.12452281f, 0.03677157f, 0.05270413f, 
    -0.34660169f, -0.01830781f, 0.07045017f, 0.06608467f, 0.16581996f, -0.10291957f, 0.01697144f, 0.19455962f, 
    -0.10665593f, -0.07592402f, 0.11204851f, -0.04776189f, 0.09428361f, 0.13595556f, 0.05973495f, 0.11496478f, 
    -0.02789037f, 0.06061837f, -0.08734143f, -0.01716859f, 0.19200645f, -0.02851298f, -0.06282095f, -0.04288116f, 
    0.19025637f, 0.11825852f, -0.07887793f, 0.10158021f, -0.17661233f, -0.04055021f, -0.12051569f, -0.00683237f, 
    0.08415870f, -0.05708289f, 0.06727375f, -0.11463945f, -0.15885754f, 0.00599487f, 0.12678854f, -0.00363339f, 
    0.00226874f, -0.01457343f, 0.12789805f, -0.05763717f, 0.09608144f, 0.12993971f, 0.02664969f, -0.01686743f, 
    -0.05978644f, -0.21381307f, 0.08047257f, -0.10433394f, 0.12041718f, 0.09114861f, -0.00081101f, -0.09905452f, 
    0.06111582f, -0.04606032f, -0.09834769f, -0.05906331f, 0.14482953f, 0.13956325f, 0.19952525f, 0.00748546f, 
    0.05216599f, 0.01743229f, -0.02424901f, 0.12115742f, -0.01406550f, 0.00455007f, 0.00260643f, -0.00291892f, 
    0.09688429f, 0.07960419f, 0.23388088f, 0.31068587f, 0.06376963f, 0.03775170f, -0.04629520f, 0.03018620f, 
    -0.08822720f, -0.00594844f, 0.06240058f, 0.06502902f, 0.36647010f, 0.01775412f, 0.09005827f, 0.09802281f, 
    0.00530284f, 0.01168401f, 0.02150839f, 0.02972160f, 0.03862184f, 0.07448322f, -0.03962242f, 0.09023367f, 
    -0.05830072f, -0.06895333f, -0.23858537f, 0.05707097f, 0.14043714f, -0.04083988f, 0.02053506f, -0.08923780f, 
    -0.02735976f, -0.03265850f, 0.01000548f, 0.16453719f, -0.00485461f, -0.02134548f, -0.15858193f, -0.09853160f, 
    -0.01597764f, 0.14554772f, -0.02237688f, -0.20670295f, 0.11988259f, 0.07269590f, 0.07088102f, 0.00330771f, 
    0.12479437f, 0.19287321f, 0.07137362f, -0.27846721f, 0.09299775f, -0.02909429f, 0.01615355f, -0.04651322f, 
    -0.00644138f, 0.06495701f, 0.06639985f, -0.05626910f, 0.03162922f, -0.14703450f, -0.07414185f, -0.08965506f, 
    -0.17892542f, 0.01510831f, 0.04974190f, -0.09084564f, -0.09008294f, 0.03363771f, -0.05368692f, 0.03451569f, 
    -0.07351651f, -0.03749130f, -0.26811054f, -0.13363779f, -0.12442150f, -0.05211923f, 0.10605106f, -0.08619939f, 
    -0.09962904f, 0.04410110f, -0.02926526f, 0.06832258f, -0.23952103f, 0.01622745f, -0.12242012f, -0.07606928f, 
    0.14938857f, -0.01647122f, -0.06606505f, -0.01801421f, -0.00818472f, -0.05910327f, 0.03935200f, 0.04691477f, 
    0.06382339f, 0.14316179f, -0.14989182f, 0.12926535f, -0.10749753f, 0.11340781f, -0.12067357f, -0.01693016f, 
    0.05424382f, 0.04172336f, -0.01195367f, -0.03994827f, -0.27544078f, 0.02880386f, -0.06564967f, 0.03264562f, 
    -0.11402611f, 0.05752637f, 0.07616760f, 0.01699474f, -0.03755305f, -0.03439163f, -0.12978521f, -0.00748010f, 
    0.15294257f, -0.26122615f, -0.14062193f, -0.04478635f, -0.02327096f, 0.06766322f, 0.09861265f, -0.02615168f, 
    0.02478919f, -0.05874014f, 0.01097699f, -0.00019370f, -0.16390111f, 0.10902173f, -0.05896878f, -0.04054783f, 
    0.01337356f, -0.05098768f, 0.02071061f, 0.11286306f, -0.06671612f, -0.04457216f, -0.04860828f, -0.13871886f, 
    -0.35839745f, 0.23095502f, -0.17880970f, 0.08986332f, 0.13804175f, 0.08816919f, -0.00594132f, -0.02145231f, 
    0.03720339f, -0.13199024f, 0.08692090f, -0.01482863f, 0.14276139f, -0.07822353f, -0.02948052f, 0.08300829f, 
    0.05971475f, -0.16194323f, -0.00936078f, 0.11465348f, 0.14713877f, 0.19665191f, 0.10492941f, 0.05084909f, 
    0.08399171f, -0.04946969f, -0.00030981f, 0.11749235f, 0.06470877f, 0.07963284f, 0.06083853f, 0.08849979f, 
    -0.03199417f, 0.01380020f, -0.05941814f, 0.11258604f, 0.01147821f, -0.14405355f, -0.20424740f, -0.11342417f, 
    0.09052162f, 0.03366530f, -0.02636048f, -0.06039464f, 0.09149136f, -0.09044921f, 0.04254216f, 0.02622468f, 
    0.33280066f, -0.01850311f, 0.18749988f, 0.12367082f, 0.02756904f, 0.00654305f, -0.02467955f, 0.08218798f, 
    0.17900939f, -0.03480824f, 0.10705268f, 0.01946076f, 0.23426580f, 0.08857702f, 0.17349158f, 0.10256714f, 
    0.05344932f, 0.01065273f, 0.00147131f, 0.05707875f, 0.17970590f, 0.06083820f, -0.03106388f, 0.08380358f, 
    -0.03534649f, 0.10119171f, 0.08792269f, 0.03747626f, 0.04104382f, 0.04813729f, 0.02739250f, 0.03743795f, 
    -0.07856999f, -0.04580856f, -0.05723840f, 0.05613360f, -0.15657213f, 0.14736187f, -0.02319434f, 0.21817811f, 
    -0.05470967f, -0.00301038f, 0.01884305f, -0.01085127f, -0.00604902f, 0.03621633f, 0.03225406f, 0.14839472f, 
    0.02939429f, -0.19690368f, -0.08758362f, 0.22419618f, -0.00333387f, 0.06963535f, -0.04512413f, -0.05084657f, 
    0.09296630f, -0.00940657f, 0.13184258f, -0.05383579f, -0.04539850f, -0.01093174f, 0.10978431f, -0.03830301f, 
    -0.05423080f, 0.09531411f, 0.00039866f, 0.01400092f, 0.00480636f, 0.01482474f, 0.05148723f, 0.05684420f, 
    0.46296528f, 0.12595966f, 0.03420690f, 0.01935704f, 0.03799224f, 0.08631439f, -0.02467350f, -0.01656102f, 
    0.06361277f, 0.14136760f, 0.00325823f, -0.01400511f, -0.14573708f, 0.17501268f, 0.01439424f, -0.07459547f, 
    -0.01880936f, 0.04097207f, 0.00034678f, 0.01611014f, 0.10725135f, 0.10190988f, 0.05287084f, 0.04749046f, 
    -0.06257164f, -0.07509997f, -0.00982887f, -0.04748660f, -0.07839800f, 0.00409488f, -0.03528110f, -0.06286455f, 
    -0.06752405f, 0.04927887f, 0.00972222f, -0.00191070f, -0.01566535f, -0.03026810f, -0.03616462f, 0.05681277f, 
    -0.00397894f, -0.02601063f, 0.03638003f, 0.02361284f, 0.04244148f, -0.07382425f, -0.00944851f, 0.03599698f, 
    0.06368314f, 0.05393891f, -0.06688673f, 0.02468435f, -0.01068424f, 0.04851124f, -0.04730782f, -0.04050070f, 
    -0.07832430f, -0.03781116f, -0.02525401f, 0.03519217f, 0.04788716f, -0.02172775f, 0.01152158f, -0.04404651f, 
    0.01399245f, -0.00046497f, -0.04297990f, -0.04795510f, -0.01163609f, 0.02819387f, -0.05307835f, 0.01735071f, 
    -0.05912054f, 0.00545560f, -0.03291825f, 0.01178791f, -0.03207854f, -0.06015520f, -0.04527654f, 0.06269104f, 
    0.03824308f, -0.02126507f, -0.05338780f, -0.00634037f, 0.02981107f, 0.05808546f, -0.02426040f, 0.04570528f, 
    -0.05099237f, -0.03161633f, 0.02815921f, 0.04053459f, -0.06985158f, 0.02381894f, -0.05473765f, 0.04231334f, 
    -0.03019371f, -0.03508593f, -0.01926685f, 0.05039123f, -0.07130084f, 0.02292705f, -0.07670833f, 0.02170506f, 
    0.05559984f, -0.06471565f, 0.04651478f, 0.04341518f, -0.04852256f, -0.02111660f, -0.03617754f, -0.01852397f, 
    -0.04626956f, 0.02282473f, -0.00085244f, 0.05945916f, 0.03649763f, -0.00643282f, -0.05863303f, -0.03731434f, 
    0.04966387f, 0.04450856f, 0.05642578f, -0.07736028f, -0.06366835f, -0.04421536f, 0.03514729f, 0.02945183f, 
    -0.05621320f, -0.01821268f, -0.03977604f, -0.06734940f, 0.00093213f, -0.04948207f, 0.04651609f, -0.02401929f, 
    0.00173712f, 0.00579792f, 0.01244682f, 0.03377549f, -0.03690081f, 0.04716954f, -0.06074615f, -0.05719326f, 
    0.02605577f, 0.04453769f, 0.01696711f, -0.03744232f, -0.04376673f, -0.01235386f, -0.04218553f, -0.05785313f, 
    0.01956160f, 0.02726847f, -0.01974055f, -0.03912457f, -0.04808795f, 0.06327721f, -0.01169991f, -0.07471950f, 
    -0.02812663f, 0.04937457f, -0.05521020f, -0.04149763f, -0.06518740f, -0.05599394f, -0.05164006f, -0.04165514f, 
    -0.07084345f, 0.02507379f, -0.06599682f, -0.01184183f, -0.06002176f, -0.00818204f, 0.04325173f, -0.05219868f, 
    0.05815711f, -0.07532287f, 0.00666374f, 0.01843907f, 0.00595997f, 0.03764872f, -0.01835256f, -0.02924024f, 
    0.02882487f, 0.04169783f, 0.00197748f, -0.03000485f, 0.01374802f, -0.07665261f, -0.00550336f, 0.05300092f, 
    -0.01967127f, 0.05944415f, 0.00712930f, 0.00215907f, -0.04362841f, -0.06937919f, 0.04820814f, 0.02276313f, 
    -0.01153986f, -0.02339653f, 0.01856423f, 0.03945359f, 0.05263154f, 0.02684380f, 0.00590215f, -0.00473919f, 
    -0.06181215f, -0.07936208f, -0.06806861f, -0.00442725f, -0.04519549f, -0.05430284f, -0.05477698f, -0.03642844f, 
    -0.14413410f, 0.12832496f, -0.04785738f, 0.15614408f, 0.02721327f, -0.03378423f, 0.14991036f, -0.04283927f, 
    -0.04851817f, -0.09200782f, 0.00195541f, -0.08201332f, 0.11602311f, -0.11991004f, 0.04631980f, 0.03852745f, 
    -0.04588974f, -0.19642568f, -0.06424845f, -0.01642640f, -0.07905734f, 0.00431843f, -0.02396326f, 0.16870496f, 
    -0.06511272f, 0.15440437f, -0.00620850f, 0.12819988f, 0.04361808f, -0.01438250f, 0.02332661f, 0.04247408f, 
    -0.05680264f, 0.05615351f, -0.03178500f, 0.09794495f, 0.20716093f, -0.12739247f, 0.00323363f, -0.03034769f, 
    -0.00862383f, -0.00923529f, 0.04982444f, -0.01704296f, -0.00233259f, 0.04668280f, 0.04316721f, 0.05699581f, 
    0.72381514f, -0.19463782f, 0.00403399f, 0.00830622f, -0.15949745f, -0.04832594f, -0.02968084f, 0.09437896f, 
    0.12479670f, 0.05027662f, 0.04671888f, -0.03961756f, 0.16581967f, 0.15202720f, -0.05616510f, -0.14253545f, 
    0.01767260f, -0.01504243f, 0.11070763f, 0.00510860f, 0.07289360f, 0.10413272f, 0.02869715f, -0.00096095f, 
    -0.03411846f, 0.14751771f, -0.15145555f, -0.14008173f, -0.04583601f, 0.10863552f, -0.05454040f, -0.05859073f, 
    -0.06093082f, -0.05068592f, 0.02324993f, 0.07626029f, 0.27622452f, 0.09420651f, 0.16031902f, -0.01950212f, 
    -0.16902563f, -0.00773726f, 0.10554483f, 0.00856327f, 0.01613265f, 0.08485073f, -0.05723080f, 0.04852961f, 
    -0.27828956f, 0.11461852f, 0.06270146f, 0.03562400f, -0.10874757f, -0.01472310f, 0.04153327f, 0.07831514f, 
    -0.02347931f, -0.00855916f, 0.21467097f, 0.01133423f, -0.14768116f, -0.04998256f, 0.09501520f, -0.14950834f, 
    -0.02927512f, 0.09246375f, -0.00943382f, -0.00293642f, 0.06526493f, -0.10992694f, 0.02569879f, -0.07137505f, 
    0.14896587f, 0.14966962f, -0.07653000f, -0.07985285f, 0.05463856f, 0.13290475f, 0.05566663f, -0.03628391f, 
    -0.02799857f, -0.04894491f, 0.01419998f, 0.11507822f, 0.17819619f, -0.05147084f, -0.04413800f, -0.08907602f, 
    -0.01649604f, 0.04968598f, 0.01137462f, 0.00011330f, 0.05816967f, 0.05110104f, -0.15466465f, 0.07422303f, 
    0.00225887f, 0.00825352f, 0.06110088f, 0.04734493f, -0.06275561f, 0.03698011f, 0.02959365f, 0.12993731f, 
    -0.10958039f, 0.02361526f, 0.10644189f, -0.05661576f, 0.29481497f, -0.24558584f, -0.10232699f, 0.02450035f, 
    0.06929770f, 0.01935172f, 0.04724855f, 0.02456256f, 0.05435238f, 0.03035526f, 0.03879611f, -0.11880990f, 
    -0.31202829f, 0.11565670f, 0.00610305f, 0.04852523f, 0.15152551f, 0.06405772f, 0.02749533f, 0.05129740f, 
    0.01096410f, -0.07409503f, -0.07106191f, 0.03726471f, -0.02448010f, 0.02194663f, -0.00915604f, -0.25351912f, 
    0.11733410f, -0.05016172f, 0.21181093f, 0.11523972f, -0.04718598f, -0.02634890f, -0.04776881f, 0.01917375f, 
    0.12921663f, -0.01567415f, 0.07968191f, 0.05552694f, -0.02522877f, 0.04030227f, 0.03750538f, 0.00996272f, 
    0.06406143f, 0.15786321f, -0.03098029f, 0.16401382f, 0.17386515f, 0.08285920f, 0.25847688f, 0.03734527f, 
    0.10139270f, 0.02835974f, 0.03234761f, -0.02738862f, -0.09490358f, 0.14221331f, 0.02882792f, -0.12923253f, 
    0.32989520f, 0.30756104f, -0.01658648f, 0.17203911f, -0.00420709f, 0.09730303f, -0.10002685f, 0.03929673f, 
    -0.02519549f, 0.05855137f, 0.02078056f, 0.10682510f, -0.05381382f, -0.24163091f, 0.05306932f, 0.05099902f, 
    -0.03485496f, -0.16672079f, 0.05415627f, 0.16234952f, -0.04091730f, -0.05630219f, 0.09657501f, 0.12840348f, 
    0.07108467f, -0.15939710f, 0.21663776f, 0.03344462f, 0.07679735f, 0.00246022f, 0.12714921f, -0.05787481f, 
    0.06382951f, 0.07304223f, -0.15378195f, 0.03644226f, 0.02701251f, 0.12539451f, -0.18062203f, 0.03664028f, 
    0.04813201f, 0.02717330f, -0.18260233f, 0.08744138f, -0.08645516f, -0.01670454f, 0.00101937f, -0.03218342f, 
    -0.05972612f, 0.00097832f, -0.21987952f, 0.01807078f, 0.03134513f, 0.05585716f, -0.08292099f, 0.14559111f, 
    0.03476348f, 0.03828524f, 0.23788412f, 0.05226058f, -0.04667895f, 0.24802597f, 0.03904133f, 0.19341816f, 
    -0.06182522f, -0.05385383f, 0.04774637f, -0.10464119f, 0.09510140f, 0.01275250f, -0.00606742f, 0.10007776f, 
    -0.12430689f, 0.18177876f, -0.19766292f, -0.18015562f, 0.10097824f, 0.09513563f, 0.02306692f, -0.10086333f, 
    0.01970723f, -0.00289057f, -0.03209868f, -0.10366797f, -0.10087742f, 0.12865664f, -0.04588187f, -0.12226848f, 
    0.10561476f, 0.01055805f, 0.03014848f, -0.00302621f, -0.00875510f, 0.05826008f, 0.03933054f, -0.07741767f, 
    0.02519003f, -0.17674063f, 0.03895763f, 0.06595054f, 0.09197152f, 0.01720848f, 0.02947293f, -0.08431139f, 
    0.05004487f, 0.00169194f, -0.03881353f, -0.14195184f, 0.06573313f, -0.06975921f, 0.14719348f, 0.13087465f, 
    0.03189561f, -0.03119788f, 0.03611858f, 0.07238235f, -0.12798849f, -0.04551936f, -0.05728822f, 0.10982520f, 
    0.20782539f, 0.11287645f, 0.06323022f, 0.22795226f, 0.01038561f, -0.01673405f, -0.02550769f, 0.15867060f, 
    -0.02584794f, 0.04053451f, -0.09454439f, -0.02145255f, 0.11093236f, 0.06411066f, 0.14529960f, -0.11894949f, 
    0.05672786f, -0.13757417f, -0.02575517f, -0.03592506f, -0.01426539f, -0.05639466f, -0.03379228f, -0.03629211f, 
    0.08091597f, -0.12462613f, -0.03390601f, 0.06222153f, 0.01098009f, 0.06708196f, -0.01796974f, -0.01912373f, 
    -0.06584521f, -0.07622705f, 0.03495948f, -0.13694665f, 0.22310676f, 0.06301948f, 0.06176890f, 0.16303574f, 
    0.00250890f, 0.04453798f, 0.10473706f, -0.04094499f, 0.04924733f, 0.08265512f, 0.08122441f, 0.02833338f, 
    -0.16403770f, -0.15290350f, 0.14019847f, -0.01277329f, 0.06847130f, -0.10064667f, -0.08285269f, -0.03628007f, 
    -0.00268124f, 0.08064539f, -0.02799467f, -0.05861191f, -0.03371250f, 0.12606308f, -0.15685195f, -0.09969063f, 
    0.15653601f, 0.04244370f, -0.04659028f, -0.02157434f, 0.17659026f, 0.00075063f, -0.04659620f, 0.00560860f, 
    0.10741961f, -0.07656349f, 0.27523226f, -0.18728308f, -0.03900689f, 0.09676228f, 0.09445743f, -0.00840557f, 
    -0.04657731f, 0.11400943f, -0.06267031f, 0.00640309f, 0.13688239f, 0.28629625f, 0.01752838f, 0.09739704f, 
    0.01953227f, 0.19452426f, -0.09449899f, -0.09698423f, 0.07502510f, 0.01235377f, 0.00085475f, -0.01139913f, 
    -0.28374457f, 0.18152876f, -0.03144236f, 0.05255254f, 0.05510141f, 0.03323135f, -0.06632163f, -0.00517739f, 
    0.04874375f, -0.02724353f, 0.01825945f, 0.21639019f, -0.11022525f, -0.10543557f, 0.19822504f, 0.01332451f, 
    0.03982219f, 0.13309745f, 0.09493023f, -0.03620364f, -0.02686227f, -0.05001166f, -0.04596153f, -0.02923974f, 
    0.07297499f, 0.01003670f, 0.42773050f, -0.05499296f, -0.08449343f, -0.21937995f, -0.01260599f, -0.07835069f, 
    -0.04963510f, -0.12916122f, 0.02837294f, -0.04547300f, 0.13636576f, -0.08871177f, -0.10817049f, -0.34576038f, 
    0.14898129f, 0.02713850f, -0.03568066f, 0.05349945f, 0.06790523f, -0.00417221f, 0.06285241f, 0.09799097f, 
    0.25932732f, 0.08282384f, 0.10759863f, 0.04882960f, -0.09859416f, -0.07311247f, -0.05032295f, 0.08726028f, 
    -0.15852116f, 0.05607035f, -0.15664124f, -0.04503160f, 0.18850367f, 0.02026177f, -0.10410796f, 0.17494850f, 
    -0.01430203f, 0.03900435f, 0.02593371f, 0.15162595f, -0.07470232f, -0.01924139f, -0.07818016f, -0.03683895f, 
    -0.01929947f, 0.02610762f, 0.14938171f, -0.20782717f, -0.08471376f, -0.05593020f, 0.06112830f, -0.06807766f, 
    -0.01219175f, -0.05081763f, 0.14970782f, -0.02581468f, -0.04341226f, -0.03710041f, -0.14237896f, -0.04351988f, 
    -0.00586928f, -0.04984207f, -0.01207704f, -0.05846060f, 0.12349057f, 0.00130694f, 0.00504206f, 0.01818751f, 
    -0.13756996f, -0.03334251f, 0.10033721f, -0.19741929f, 0.05551720f, -0.02938444f, 0.20517112f, -0.06441636f, 
    0.02520553f, 0.02767882f, -0.06146315f, 0.03542452f, -0.13378167f, 0.11874330f, -0.04170059f, 0.30040324f, 
    -0.00644537f, 0.07844163f, -0.00309677f, -0.03495652f, -0.09760398f, 0.01308563f, 0.01610173f, 0.00197994f, 
    -0.18779975f, 0.11818511f, 0.13046634f, 0.01917996f, -0.11858708f, -0.07227923f, -0.07373209f, 0.00907987f, 
    -0.08199466f, -0.02716247f, 0.06944940f, -0.10781054f, 0.20069018f, 0.04821638f, 0.02117401f, 0.21585964f, 
    0.03840329f, -0.03554195f, -0.00520464f, 0.01504048f, 0.02362672f, -0.02140979f, 0.06201273f, -0.09876203f, 
    -0.06680794f, 0.00273510f, -0.04865286f, -0.03481032f, -0.07628305f, 0.05512097f, 0.05966523f, 0.01965217f, 
    0.04115978f, -0.03120253f, -0.07713611f, -0.04204991f, -0.05797895f, -0.04778326f, 0.06281332f, -0.05781241f, 
    -0.07293720f, 0.01522471f, -0.04454181f, -0.06841898f, -0.05546650f, 0.03936340f, 0.05972834f, 0.00532396f, 
    -0.04506717f, -0.00076140f, 0.02599188f, -0.04675953f, 0.05658346f, -0.04988788f, -0.01167309f, -0.02073875f, 
    -0.05176566f, -0.02645589f, -0.03759138f, -0.07549454f, -0.04241965f, -0.01404877f, 0.01509308f, -0.01785903f, 
    -0.07350121f, -0.05929204f, 0.01803873f, -0.01059212f, -0.05268636f, -0.04170991f, 0.02612283f, -0.02056339f, 
    0.04971899f, -0.05100736f, -0.00399317f, -0.01658644f, 0.03934935f, 0.03111929f, 0.04943036f, 0.03663810f, 
    -0.04189374f, 0.05030327f, 0.04562739f, 0.02403740f, -0.03223136f, -0.07176623f, 0.04697457f, -0.03216309f, 
    -0.02619413f, -0.03327794f, 0.04303227f, -0.00437426f, 0.04067668f, -0.01761187f, -0.01020640f, 0.06270770f, 
    -0.02667229f, -0.04886173f, 0.05292653f, 0.01731262f, 0.05728548f, -0.03911248f, -0.05804992f, -0.02166346f, 
    0.03481437f, 0.05737034f, 0.03242302f, -0.05677245f, -0.05118937f, -0.00085296f, 0.00758704f, 0.01532049f, 
    -0.07429586f, -0.05751991f, -0.05316658f, 0.04244040f, 0.00690843f, 0.01301462f, -0.05718689f, -0.04357294f, 
    -0.00785507f, -0.02644883f, -0.02505594f, 0.02102750f, 0.06226620f, -0.07313278f, -0.05728120f, -0.04712707f, 
    0.01158291f, 0.05318890f, 0.05697039f, 0.04101850f, 0.04569616f, 0.03901659f, -0.03453524f, 0.01658974f, 
    0.01405011f, -0.02307412f, -0.07567094f, 0.05850803f, 0.05205808f, 0.00950771f, 0.02736191f, -0.00615780f, 
    0.06159869f, -0.07299336f, -0.07925010f, 0.01971874f, -0.06724548f, 0.03870562f, -0.04029018f, -0.07096855f, 
    -0.04066606f, -0.02422007f, 0.01550012f, 0.05205391f, 0.06449848f, -0.03304737f, -0.07426760f, -0.03761360f, 
    -0.03563788f, -0.03109116f, 0.02589442f, -0.07487520f, 0.01614309f, 0.04122233f, 0.00109282f, -0.05712431f, 
    0.00606693f, -0.02892823f, -0.04969448f, -0.00822698f, -0.07240632f, -0.04471645f, -0.00932786f, 0.03096981f, 
    -0.01420744f, 0.02807520f, 0.05807382f, -0.00999799f, -0.01533634f, 0.00659961f, -0.01839370f, 0.04512432f, 
    0.02395659f, -0.03261365f, -0.01870821f, -0.03772803f, -0.00948526f, -0.05354217f, -0.01464109f, 0.01413008f, 
    -0.02998103f, 0.05117617f, -0.00083812f, -0.04689542f, 0.02110277f, -0.03546708f, -0.06762764f, -0.01013116f, 
    -0.00505322f, -0.01167415f, 0.00467723f, 0.00833863f, -0.00462938f, 0.02075989f, 0.00737511f, -0.00134753f, 
    -0.02123832f, 0.05710888f, 0.01152820f, -0.03712378f, 0.02997697f, -0.02611678f, -0.07566851f, -0.03383024f, 
    -0.09564321f, 0.01493263f, 0.21689196f, 0.08730903f, -0.14406404f, -0.06453025f, 0.01335241f, 0.11362638f, 
    -0.05027028f, 0.11999209f, 0.04791110f, 0.03306808f, 0.03692840f, -0.16156948f, 0.01064991f, -0.09134224f, 
    0.03608780f, -0.07479188f, -0.16469075f, 0.05288680f, 0.02500130f, 0.02368307f, -0.06220613f, 0.09219781f, 
    -0.00688075f, -0.04492977f, 0.12379508f, 0.00714935f, -0.09717526f, -0.07218635f, 0.03645490f, 0.16321816f, 
    0.01887343f, 0.07843048f, -0.15220957f, 0.11528591f, 0.07935176f, -0.03251875f, -0.09492081f, 0.05239113f, 
    0.06786823f, 0.00021839f, 0.03819190f, 0.12109490f, 0.07869879f, -0.00125738f, 0.04797295f, 0.02767270f, 
    0.21844605f, -0.12975962f, -0.00421542f, -0.02042018f, 0.05606294f, 0.07348665f, 0.05891911f, -0.04158240f, 
    0.02985555f, -0.01199580f, 0.02272231f, 0.15552619f, 0.00263932f, -0.12344607f, 0.00773274f, -0.05559278f, 
    -0.05394870f, 0.06313935f, -0.03142843f, 0.06170483f, -0.01622947f, -0.05421996f, 0.00077245f, 0.02726311f, 
    0.13270915f, 0.07046760f, 0.03534309f, -0.29563832f, -0.10857491f, 0.03479090f, 0.09621265f, -0.14552230f, 
    -0.10334804f, -0.02316041f, 0.23472227f, 0.02696542f, -0.05918632f, -0.05631202f, -0.04540034f, -0.12429308f, 
    0.11589162f, -0.11919221f, 0.02719044f, 0.03465313f, -0.06579477f, 0.16621090f, -0.07953061f, 0.11667332f, 
    0.14175338f, 0.24640200f, 0.12606302f, 0.05779540f, -0.08383331f, 0.08262720f, 0.01689722f, 0.14358038f, 
    -0.03869999f, 0.01366057f, 0.02033538f, -0.01820853f, 0.11419955f, 0.22317661f, 0.24120198f, -0.12596709f, 
    -0.00769251f, 0.06858175f, 0.10989905f, 0.04542147f, -0.00402147f, -0.04737410f, 0.03665532f, 0.05651428f, 
    0.07364552f, 0.19542183f, 0.05471838f, -0.01962067f, 0.04905414f, 0.12615803f, 0.11488762f, -0.10532255f, 
    -0.03062458f, -0.15426911f, -0.02150109f, -0.13689709f, 0.11193965f, 0.05198685f, 0.07434592f, -0.17763610f, 
    -0.06397275f, 0.13912934f, -0.06590246f, 0.00469781f, -0.05367732f, -0.09766123f, -0.07927094f, -0.08764183f, 
    0.25024641f, -0.04482942f, 0.28686917f, -0.10120779f, -0.08407603f, 0.07073179f, 0.06392600f, 0.18503857f, 
    -0.11795111f, -0.07124775f, 0.04208415f, 0.06123637f, 0.21296521f, -0.28591457f, -0.03846097f, 0.11285484f, 
    0.08148338f, 0.05493303f, 0.01280098f, -0.07980300f, -0.04439541f, 0.06478421f, -0.02169945f, -0.09801130f, 
    0.01242918f, 0.24353579f, -0.33820015f, 0.14939623f, -0.03515004f, 0.13471617f, 0.03206099f, 0.10517640f, 
    -0.07605354f, -0.00045918f, 0.08605171f, -0.18392889f, -0.02804061f, 0.03065673f, -0.07439796f, 0.09699611f, 
    -0.06199088f, -0.07797436f, 0.05428262f, 0.05957374f, 0.19816487f, 0.06733661f, 0.07349167f, 0.12527058f, 
    -0.02124823f, -0.08661801f, -0.04312284f, -0.07148279f, 0.04543035f, 0.02692678f, -0.07834228f, -0.03542862f, 
    0.01920077f, 0.05183310f, -0.06959320f, 0.03212676f, -0.09432378f, -0.07166803f, -0.00120476f, 0.01030139f, 
    -0.08408278f, 0.00454406f, -0.07673942f, 0.01095553f, -0.03932144f, 0.04854752f, 0.02711170f, -0.05436273f, 
    -0.05745799f, -0.06227227f, -0.00876170f, -0.00069606f, -0.03368095f, -0.04865919f, -0.01644040f, 0.00473672f, 
    -0.01682389f, 0.00128440f, -0.04679028f, -0.06158862f, -0.07293528f, -0.05149580f, -0.01114326f, -0.04633315f, 
    -0.06124938f, 0.07454076f, -0.06953660f, 0.03169765f, 0.04987752f, -0.07470554f, 0.04347395f, -0.03634460f, 
    0.04288511f, -0.09399641f, 0.03912374f, -0.04508634f, -0.03603781f, 0.04921532f, -0.06079661f, -0.06492891f, 
    -0.04341674f, -0.00634014f, 0.00496896f, -0.01870785f, -0.09433150f, -0.02997791f, -0.05637967f, 0.00911924f, 
    0.02982208f, -0.03639676f, -0.08071487f, -0.01093412f, -0.07983240f, -0.07147145f, 0.02763105f, -0.04281767f, 
    0.05500212f, 0.04115342f, -0.07000631f, -0.03055046f, 0.00912840f, -0.04686218f, 0.01104823f, -0.07882455f, 
    -0.03485207f, -0.09091192f, -0.06070028f, 0.01342141f, -0.09703485f, 0.05084454f, -0.02321080f, 0.02484222f, 
    0.05560286f, 0.06409353f, 0.01096869f, 0.02043981f, 0.05067174f, 0.05301047f, -0.05126208f, -0.03991599f, 
    -0.08679222f, -0.06952871f, -0.08473666f, -0.01040374f, -0.07774168f, -0.07496331f, -0.01914647f, -0.00226313f, 
    -0.01332540f, 0.02593874f, -0.02742622f, -0.01078565f, 0.01160040f, -0.00930000f, -0.08283319f, 0.02485090f, 
    -0.09617650f, -0.00289480f, -0.05561977f, 0.02384553f, -0.07675041f, -0.08529420f, 0.02778549f, -0.07024433f, 
    -0.00499766f, -0.05246730f, 0.03160341f, -0.01271888f, -0.05697989f, 0.03644510f, -0.04336036f, -0.09827981f, 
    -0.02052023f, -0.00707349f, 0.05557196f, 0.04433012f, -0.08865846f, -0.11384165f, -0.02274635f, 0.01965740f, 
    0.05547227f, 0.00972216f, 0.04085612f, 0.00479317f, 0.01652153f, -0.04308738f, 0.00876811f, -0.02227287f, 
    -0.06916933f, 0.05549071f, -0.09460073f, -0.09742907f, -0.06593093f, -0.00859508f, -0.04498821f, -0.05533474f, 
    -0.05296214f, 0.03745471f, -0.04179407f, -0.02117036f, -0.01755978f, -0.07377779f, -0.04969064f, -0.06536213f, 
    -0.02378376f, 0.05274933f, -0.05945795f, -0.04979150f, 0.05093467f, 0.04253735f, -0.04675356f, -0.04191696f, 
    0.02225456f, 0.03408482f, -0.01050807f, -0.07809041f, 0.01383376f, 0.01734709f, -0.04247089f, 0.03842074f, 
    0.00639557f, -0.04821283f, -0.09893202f, 0.00531063f, -0.06851209f, -0.01399819f, -0.04722720f, -0.09745259f, 
    0.05197741f, 0.05291290f, 0.02428881f, 0.00133049f, -0.06729444f, -0.00105857f, -0.02634420f, 0.05837118f, 
    -0.18530400f, 0.24180731f, -0.05919389f, -0.00976537f, -0.02161984f, -0.00301371f, 0.02139012f, -0.04305781f, 
    0.13115779f, -0.13386248f, -0.08552963f, 0.00472644f, 0.13196672f, -0.00484493f, 0.13537052f, 0.09098723f, 
    -0.12158338f, -0.00421145f, -0.06841759f, 0.02112663f, -0.12447464f, 0.05334385f, -0.04700224f, 0.06926385f, 
    0.15999518f, -0.09783276f, -0.09508763f, 0.11439218f, 0.04151032f, -0.06462424f, 0.00211064f, -0.01695585f, 
    -0.00292858f, 0.09549670f, 0.06235271f, 0.06341095f, 0.00145628f, -0.16870932f, -0.00067565f, -0.06247112f, 
    -0.03159821f, 0.03732564f, -0.02640908f, 0.05390275f, -0.07176771f, 0.07190558f, 0.02332707f, 0.06927504f, 
    0.32850453f, -0.12905276f, 0.10077749f, 0.08102904f, -0.09320433f, 0.02781432f, 0.06379811f, 0.11480533f, 
    0.06891049f, -0.06551719f, -0.02175589f, 0.08309964f, 0.20963754f, 0.26743975f, -0.00362605f, -0.11778641f, 
    -0.02524355f, 0.04039725f, 0.11824916f, 0.03306434f, -0.02371430f, 0.03868678f, 0.07274896f, 0.03147922f, 
    0.08770267f, 0.11987359f, -0.07735166f, 0.03936138f, 0.12009257f, 0.10964506f, 0.00573745f, -0.00101238f, 
    0.09799597f, -0.08523686f, -0.05842567f, 0.07161503f, 0.33256689f, 0.12945853f, 0.01237816f, 0.04858166f, 
    -0.18704499f, -0.06680551f, 0.15015751f, -0.07601624f, -0.09311485f, -0.05897240f, -0.04019570f, -0.11337709f, 
    -0.15742403f, -0.01679480f, 0.09791350f, 0.02823237f, -0.02552856f, 0.07864206f, -0.05536207f, 0.06457120f, 
    0.03149500f, 0.07043423f, 0.17472875f, -0.00550963f, 0.01316038f, -0.08373155f, 0.08280148f, -0.06916925f, 
    -0.04946373f, -0.00826556f, -0.02609036f, 0.03118571f, 0.10513350f, 0.02870679f, 0.05921889f, -0.00854738f, 
    -0.02703246f, 0.14490597f, -0.06427487f, 0.16937438f, 0.17467257f, 0.10133088f, -0.01569977f, -0.01681273f, 
    0.01836459f, -0.00823253f, -0.06512962f, 0.00434037f, -0.24115393f, 0.24223499f, -0.02394140f, 0.07238635f, 
    0.02782400f, 0.01021073f, 0.00778901f, -0.10269485f, 0.09133394f, 0.11045433f, -0.03223464f, -0.01316711f, 
    0.09415441f, 0.18612371f, -0.25799981f, 0.10157356f, -0.02684774f, -0.00593096f, 0.01707507f, 0.14458580f, 
    0.00755004f, 0.01308895f, -0.00023876f, 0.00906004f, 0.23357342f, -0.12026858f, -0.09185010f, -0.07807221f, 
    0.00686979f, 0.15079916f, 0.05794668f, 0.02167619f, 0.04634900f, -0.03123424f, -0.03286432f, 0.00785933f, 
    -0.11391915f, 0.05156229f, -0.08690634f, -0.06891404f, 0.10895215f, 0.09641967f, 0.05720483f, 0.05454204f, 
    0.10568336f, -0.00019134f, -0.09864321f, 0.08689449f, -0.23788330f, 0.22110437f, 0.06107255f, -0.33391607f, 
    -0.02481160f, 0.03020898f, 0.06423818f, 0.03122750f, 0.06725464f, -0.01541814f, -0.09405824f, -0.04066962f, 
    0.26788959f, -0.23579030f, 0.08399513f, 0.10307398f, -0.18017434f, -0.07844236f, 0.02452126f, 0.04701579f, 
    0.14560246f, -0.01107291f, 0.09227300f, 0.06704362f, -0.06940540f, -0.22115125f, -0.02873467f, 0.21277080f, 
    0.13020217f, -0.01878492f, -0.04175611f, 0.11986705f, -0.01400336f, -0.07846286f, -0.00878360f, -0.05568898f, 
    -0.24984802f, 0.04697119f, 0.04599484f, 0.05664955f, 0.00510729f, 0.03787119f, 0.03293589f, 0.17752460f, 
    0.02672803f, 0.01755525f, -0.05108378f, 0.07573713f, -0.06631899f, -0.18081601f, 0.06339632f, 0.15364859f, 
    0.25954103f, -0.00450727f, 0.05754522f, 0.01737999f, 0.03888438f, -0.06569775f, 0.02666691f, -0.02641651f, 
    -0.02122792f, 0.02795407f, -0.11868173f, 0.06140087f, 0.05913147f, -0.03116592f, 0.01132613f, 0.03134552f, 
    -0.01635038f, 0.02635316f, 0.05911674f, 0.05054866f, -0.04052129f, 0.15223818f, -0.07724664f, 0.02730164f, 
    -0.02971164f, -0.16168654f, 0.03112642f, 0.01433386f, 0.08731279f, 0.13303457f, 0.06004367f, 0.08667810f, 
    -0.27990887f, -0.20894440f, 0.02488813f, -0.29183125f, -0.05692708f, 0.14582473f, -0.00835485f, 0.01996778f, 
    0.02716750f, 0.04954458f, 0.18233757f, 0.09651271f, -0.07245380f, -0.13771135f, 0.29472864f, 0.16908966f, 
    0.21250235f, 0.07475110f, -0.13357179f, 0.14651492f, 0.06292084f, -0.00789104f, -0.00781551f, 0.04397750f, 
    0.26041070f, 0.26780951f, 0.11187206f, 0.02316573f, 0.05652832f, -0.06813905f, -0.00959335f, 0.03462330f, 
    -0.07237471f, -0.11329250f, -0.03637844f, 0.00647875f, 0.01699888f, 0.34314254f, 0.10822035f, -0.09927981f, 
    0.10584941f, 0.00875414f, 0.07533894f, 0.06607942f, -0.02458810f, -0.08026367f, 0.04676465f, 0.02993301f, 
    -0.01789489f, -0.33311805f, -0.06046148f, -0.27706623f, -0.03445999f, 0.04746597f, 0.10691792f, -0.04397981f, 
    0.01830322f, -0.11291402f, 0.06459936f, -0.10693724f, 0.35322380f, -0.26991856f, -0.19390997f, -0.08353677f, 
    -0.14472620f, 0.06891411f, -0.07121478f, 0.02137536f, -0.05992588f, -0.04150546f, -0.01179504f, 0.01915281f, 
    0.03591848f, -0.21831840f, 0.22659957f, -0.26093438f, -0.06802818f, 0.02728396f, -0.11053705f, 0.11062462f, 
    -0.00711400f, 0.09446634f, 0.07436468f, 0.03977499f, 0.12337746f, -0.11593082f, 0.14204717f, 0.01982871f, 
    0.14445177f, -0.01763853f, -0.01695950f, -0.09808243f, 0.04271277f, -0.03039948f, 0.01851873f, 0.12144545f, 
    0.59679204f, 0.06400601f, 0.01927945f, -0.11445267f, 0.08425882f, -0.11523151f, -0.01989940f, -0.08871126f, 
    -0.02441568f, -0.10824642f, 0.09067043f, 0.10458029f, 0.04750236f, -0.05582146f, -0.00784831f, 0.10471495f, 
    0.14722319f, -0.05061257f, -0.05390785f, 0.09472153f, 0.04130491f, -0.02440158f, 0.02073070f, 0.01564410f, 
    -0.09543534f, 0.07529428f, -0.13078645f, 0.12312489f, 0.07740269f, -0.05413250f, -0.13231006f, -0.01399766f, 
    0.01750226f, -0.07277222f, -0.00644310f, -0.07650690f, -0.01019269f, 0.07312354f, -0.09957694f, -0.10948402f, 
    0.00578027f, 0.06383720f, 0.04595178f, 0.07231733f, 0.13610633f, -0.00019995f, -0.00500393f, 0.02786320f, 
    0.29412413f, -0.08023521f, 0.06613353f, 0.13815285f, -0.07254560f, -0.07249710f, 0.16936818f, -0.00381305f, 
    -0.07551178f, -0.03304149f, 0.10703509f, -0.04769726f, -0.07125168f, 0.25753421f, 0.03937212f, -0.20310946f, 
    -0.05963428f, 0.06891742f, 0.04895230f, -0.22067270f, 0.05920444f, 0.01050526f, -0.05957989f, -0.10402656f, 
    -0.09596404f, 0.01356331f, -0.08204982f, -0.17422375f, 0.07111664f, -0.07478497f, -0.05957114f, 0.07214190f, 
    0.04320046f, -0.01740395f, 0.04133675f, -0.08921216f, 0.14991248f, -0.07154568f, 0.02491868f, 0.02167008f, 
    0.05558063f, -0.10153129f, 0.04799207f, 0.08444053f, 0.05426613f, 0.11294455f, 0.16613951f, 0.01410316f, 
    -0.09827901f, 0.09557606f, -0.09383512f, 0.27329385f, -0.03118580f, 0.07986134f, 0.00178041f, -0.01147636f, 
    -0.09793533f, -0.04557643f, -0.17250597f, 0.05122638f, 0.45158610f, -0.19743763f, -0.33505285f, -0.25575045f, 
    -0.04203073f, 0.07633759f, 0.03673403f, -0.12287280f, 0.13061121f, 0.02973165f, 0.05318902f, -0.07689884f, 
    0.03994292f, -0.15848912f, 0.14100967f, 0.04310733f, -0.17482004f, -0.01401190f, 0.08219448f, 0.17205077f, 
    0.10099827f, 0.02181364f, 0.06525527f, 0.00536212f, 0.18375710f, -0.01973106f, 0.15276758f, -0.04033791f, 
    -0.16743372f, 0.11674636f, 0.08206861f, 0.01727508f, 0.05856211f, 0.00412551f, -0.05310399f, -0.06709100f, 
    -0.20026086f, 0.13448982f, 0.15426204f, 0.01094248f, 0.08869582f, -0.01925136f, 0.04513921f, -0.05540520f, 
    -0.09623788f, 0.00396233f, 0.04552475f, 0.02904725f, -0.21171467f, 0.00539441f, 0.27754447f, -0.04672509f, 
    0.03470406f, -0.00848246f, -0.00245224f, -0.03592104f, 0.00409487f, 0.10775457f, 0.04962461f, 0.02213352f, 
    -0.16143002f, -0.13455597f, 0.11290655f, 0.35418269f, 0.02649668f, 0.00357705f, 0.05398742f, 0.04858219f, 
    0.01241954f, -0.04550999f, -0.03327432f, -0.03144161f, -0.19103684f, -0.07771626f, -0.00891165f, 0.12407167f, 
    -0.07518853f, 0.08372258f, 0.15462671f, 0.05721071f, -0.05021360f, -0.04441299f, 0.06384221f, 0.06150646f, 
    0.09742172f, 0.11029088f, -0.15561537f, 0.15556182f, -0.01639492f, 0.05803996f, 0.02928455f, 0.08175516f, 
    -0.06230177f, -0.03140908f, -0.04692262f, 0.07248496f, 0.03549078f, -0.04055125f, 0.20505606f, 0.08618683f, 
    0.06349467f, 0.06376626f, -0.01059727f, -0.08573354f, -0.01435990f, 0.03324678f, 0.07464548f, 0.06984138f, 
    0.22244228f, -0.19584504f, 0.23778251f, 0.05260537f, -0.01118393f, -0.00635124f, 0.08795167f, 0.05581362f, 
    0.04905192f, 0.15554528f, 0.00330539f, 0.04763367f, 0.13593169f, -0.10901747f, -0.01614764f, -0.13644689f, 
    0.25321835f, 0.08902623f, -0.00393336f, 0.03089768f, 0.01526661f, 0.10462978f, 0.10173113f, -0.01305000f, 
    0.02456139f, 0.29539508f, 0.01568704f, 0.15588012f, -0.00502676f, 0.17177776f, -0.07443943f, -0.00884424f, 
    0.13949695f, 0.05743457f, 0.02754464f, 0.06322274f, 0.13758303f, -0.16858529f, -0.04655744f, -0.01230217f, 
    0.06051911f, -0.10490959f, 0.06038183f, 0.04771713f, -0.03794603f, -0.01452074f, 0.14428106f, 0.05095588f, 
    0.27778545f, -0.25074708f, 0.15594392f, -0.09174659f, 0.09421711f, 0.03181506f, 0.13722382f, -0.01663756f, 
    -0.06655227f, 0.12261441f, 0.04391748f, 0.11765733f, -0.02127424f, 0.08165775f, -0.18637356f, 0.05424298f, 
    -0.01597225f, 0.09116349f, -0.16313411f, -0.02571999f, -0.04032417f, -0.03622168f, 0.00094140f, -0.06739168f, 
    -0.02315544f, -0.08725790f, -0.04019156f, -0.09607100f, -0.03442003f, 0.00581029f, -0.01789970f, 0.02234884f, 
    0.04902459f, 0.03789209f, 0.31977332f, -0.07056329f, -0.10116106f, 0.12227244f, 0.04443278f, 0.09548417f, 
    0.02742463f, 0.11606690f, 0.10097574f, 0.11420503f, 0.04238889f, 0.00744116f, -0.17002408f, 0.13688155f, 
    -0.01590046f, 0.20297240f, -0.16803911f, -0.27197936f, -0.01556603f, 0.05816881f, -0.03153972f, -0.17066087f, 
    -0.19054514f, -0.00898080f, -0.11758856f, -0.17951433f, -0.26861566f, 0.11262172f, -0.04849034f, -0.08035693f, 
    0.04832787f, -0.04140815f, -0.16110463f, -0.14898859f, -0.14587843f, -0.20044112f, 0.05911369f, -0.15383342f, 
    0.05295477f, -0.26686850f, 0.04074121f, -0.30111492f, -0.03436780f, -0.02174829f, 0.11387525f, -0.09016342f, 
    0.06143868f, -0.01580241f, -0.00486284f, -0.17322870f, 0.45639271f, -0.34274846f, 0.01123570f, -0.00136716f, 
    -0.03552190f, 0.08074584f, 0.03914383f, 0.04166481f, 0.08551463f, -0.07429365f, -0.16668141f, -0.01488379f, 
    0.11429948f, 0.22689909f, 0.11198749f, -0.06196762f, -0.07060621f, 0.06105781f, 0.13605492f, 0.05658340f, 
    0.05285194f, 0.08760954f, -0.05103664f, 0.12769212f, -0.01952193f, 0.03980108f, 0.18085310f, 0.19305177f, 
    0.19206451f, -0.13128909f, -0.04357851f, -0.01945982f, -0.03778248f, 0.03738980f, 0.05791364f, -0.05781522f, 
    0.18504705f, 0.02102829f, -0.00370811f, 0.10372359f, -0.00342555f, -0.00419740f, -0.06551341f, 0.04386545f, 
    -0.06424435f, -0.16275778f, 0.06193428f, -0.02885638f, 0.15643932f, -0.15323064f, 0.19018273f, 0.24972279f, 
    0.05657409f, 0.08332527f, 0.11796310f, 0.09067385f, -0.02043452f, 0.00228774f, 0.12730309f, -0.03075217f, 
    -0.00898162f, 0.03509706f, 0.03515735f, -0.03758068f, -0.01124567f, 0.02351094f, 0.02579616f, 0.04621272f, 
    -0.03255039f, -0.00912315f, -0.03513233f, -0.01510691f, -0.05700594f, 0.01102980f, 0.04359463f, -0.04046457f, 
    -0.04067031f, -0.03760844f, -0.04957032f, 0.04318124f, 0.01501261f, -0.04787047f, 0.01915431f, -0.05985329f, 
    -0.03099065f, -0.02711978f, -0.06461720f, -0.04467781f, -0.01996789f, 0.01777924f, 0.05951751f, -0.03818768f, 
    -0.03607424f, 0.03983952f, -0.00556393f, -0.04886251f, -0.07748789f, 0.00695887f, 0.04617394f, -0.01489145f, 
    -0.06324910f, -0.00005057f, -0.07197987f, 0.05001089f, -0.05533969f, -0.01799949f, -0.02607365f, 0.04989018f, 
    -0.03669703f, -0.01909683f, 0.05133628f, 0.05472434f, 0.05709044f, -0.03143690f, -0.07500005f, -0.01774006f, 
    0.01536254f, -0.04481068f, -0.05543296f, -0.00344676f, -0.02733237f, -0.01111995f, 0.03090609f, 0.03634654f, 
    0.03711238f, 0.05917611f, 0.04026355f, 0.05602536f, -0.00715703f, -0.04871561f, -0.06862535f, 0.04598320f, 
    -0.02744542f, 0.05738629f, -0.07106044f, 0.01755356f, 0.00330610f, -0.04128901f, -0.07338104f, 0.00346368f, 
    0.03587445f, -0.00270157f, -0.00108512f, -0.01843685f, -0.06808144f, -0.04543856f, 0.01032544f, -0.02578038f, 
    -0.02097184f, -0.05506020f, -0.06616442f, -0.00345179f, 0.05170413f, -0.06201871f, -0.04845871f, -0.06405789f, 
    -0.06340909f, -0.03875801f, -0.02199134f, -0.02100081f, 0.04996588f, -0.02263750f, -0.05985947f, 0.00945799f, 
    0.02394400f, -0.06429093f, -0.02262303f, 0.04505764f, -0.06345671f, 0.00234455f, -0.02345241f, 0.02531199f, 
    -0.06372004f, -0.02767126f, -0.05334584f, 0.04947284f, 0.03184967f, 0.01461125f, 0.00326996f, -0.06746490f, 
    -0.07072134f, 0.06308129f, -0.00568565f, 0.00612461f, 0.03407655f, -0.06747650f, -0.03658753f, 0.02133731f, 
    0.04848403f, 0.05789036f, -0.03384097f, 0.05307225f, 0.06395610f, -0.03668222f, 0.03743175f, -0.04736665f, 
    0.06483909f, -0.02622459f, 0.05537958f, -0.02884356f, 0.02362310f, -0.04297030f, 0.03901258f, 0.04688589f, 
    0.02428499f, -0.04605974f, -0.05467455f, 0.03630798f, 0.04049487f, 0.00316199f, -0.06832709f, -0.07537580f, 
    0.04099279f, 0.02653238f, 0.03579253f, -0.00189536f, -0.06455731f, 0.05002830f, 0.02308922f, 0.00784027f, 
    0.02400073f, -0.03397670f, 0.04578511f, -0.01960789f, -0.05915555f, -0.03782082f, -0.04428171f, 0.03653170f, 
    -0.02863457f, -0.06464381f, -0.04806615f, 0.00239260f, 0.00747359f, -0.04486222f, 0.01752930f, -0.06279732f, 
    -0.06757267f, -0.07053927f, -0.03343375f, 0.00870627f, 0.03922450f, -0.05401118f, -0.02107370f, -0.02795911f, 
    -0.04804255f, 0.00407479f, 0.05929630f, 0.02676528f, 0.02540175f, 0.04146980f, -0.03344204f, -0.02394982f, 
    0.05095617f, -0.06866293f, -0.03410881f, -0.05309159f, -0.01432287f, -0.01041194f, -0.03332018f, -0.06081617f, 
    -0.05950667f, 0.03081660f, 0.03355728f, -0.03784236f, 0.03460392f, -0.07493120f, 0.02298789f, -0.02401536f, 
    -0.03682399f, -0.02769496f, 0.03922333f, -0.07734960f, 0.01207615f, 0.00263373f, 0.05476552f, 0.05673143f, 
    -0.05714466f, -0.07597886f, 0.00908922f, 0.05833634f, 0.00578813f, -0.02584493f, 0.02397711f, -0.02604190f, 
    0.03707409f, -0.02165366f, -0.03239313f, -0.04317149f, 0.00146171f, -0.03522451f, 0.04674299f, -0.05001633f, 
    -0.02239411f, -0.07159076f, -0.04562474f, -0.02466966f, -0.02695268f, 0.01562790f, -0.05641985f, -0.01842046f, 
    -0.05957500f, 0.03117542f, 0.04717565f, 0.05189671f, -0.02811263f, -0.03881531f, -0.05385749f, -0.03904929f, 
    -0.00308603f, 0.01089417f, -0.05310059f, -0.06174445f, -0.01220636f, 0.04688639f, -0.04602452f, 0.06505690f, 
    -0.06079649f, -0.03572325f, -0.01120625f, -0.07351242f, 0.00909854f, -0.04210121f, 0.06451795f, 0.06392203f, 
    -0.01928242f, -0.05836658f, 0.01525864f, 0.05254624f, -0.06598976f, -0.05407283f, -0.03629057f, 0.00038985f, 
    0.04897394f, 0.02393084f, 0.06564109f, 0.06402308f, -0.05330586f, -0.00222026f, 0.01920434f, 0.03335918f, 
    -0.04000995f, 0.01675302f, -0.01253997f, -0.04229350f, -0.03174643f, 0.05564948f, -0.04547779f, -0.06338162f, 
    -0.02331786f, 0.01540285f, -0.00291825f, -0.00594346f, -0.00785723f, -0.03043468f, -0.03740358f, -0.03185258f, 
    -0.06220879f, 0.00406107f, -0.01593009f, -0.03061207f, 0.00819913f, -0.07653350f, 0.02108568f, 0.02333018f, 
    0.04263504f, 0.03180205f, -0.02067398f, 0.02191402f, -0.01929913f, -0.06945919f, -0.07493735f, 0.04962904f, 
    -0.07639139f, 0.01716386f, -0.06758826f, -0.05472607f, 0.04683943f, -0.02376666f, -0.03117143f, -0.02921023f, 
    -0.06720874f, 0.01825309f, 0.05633419f, 0.05334518f, -0.05229523f, -0.02161085f, -0.01898103f, -0.01682668f, 
    -0.02602225f, -0.01677521f, 0.02645143f, -0.04791224f, 0.05520412f, 0.06574006f, -0.02608974f, 0.04004177f, 
    -0.00368829f, 0.01599817f, -0.00209329f, -0.01754434f, -0.00059154f, 0.06578228f, 0.01618272f, 0.06336790f, 
    -0.05384447f, -0.00194760f, -0.06449170f, -0.03310410f, -0.06805532f, -0.01215295f, 0.02965562f, -0.07213588f, 
    -0.01207777f, -0.01984140f, 0.04576075f, -0.01833814f, -0.04420911f, 0.02264978f, 0.04780876f, -0.04874563f, 
    0.00170999f, 0.04858150f, 0.01317252f, 0.06259170f, -0.03828932f, 0.01525891f, -0.01511000f, -0.06404606f, 
    -0.06258016f, -0.02962506f, -0.02902797f, -0.01791513f, 0.04293218f, 0.04193844f, 0.00512930f, -0.03703222f, 
    0.00958158f, 0.03371326f, -0.04847078f, -0.05777841f, -0.04700219f, 0.03779206f, -0.03379770f, -0.03367900f, 
    0.09632093f, -0.07278941f, 0.01619282f, 0.19778137f, 0.05572079f, 0.02891959f, -0.08744607f, 0.15811652f, 
    -0.01996831f, 0.18273984f, 0.05530657f, 0.09760039f, -0.19254433f, -0.14571103f, -0.13004126f, 0.03320595f, 
    0.07842229f, -0.05048913f, -0.04071451f, 0.04429729f, -0.03979946f, -0.04429198f, 0.13463087f, -0.09716407f, 
    -0.03528037f, -0.01837259f, 0.03302784f, -0.03874475f, -0.13802984f, 0.04686472f, -0.04891277f, -0.11354954f, 
    0.05925608f, 0.13579832f, -0.06880890f, 0.06377542f, -0.09785654f, -0.13496755f, -0.04691182f, 0.04358055f, 
    -0.07959580f, -0.05090644f, -0.00628103f, 0.13780554f, 0.04936379f, 0.01616311f, -0.07825658f, 0.06535830f, 
    -0.22317943f, 0.00197276f, 0.07539278f, -0.18333432f, 0.03825558f, -0.06850711f, 0.13572940f, 0.04705735f, 
    0.08735648f, 0.09522240f, -0.05366357f, 0.09946230f, -0.01661463f, -0.24582727f, -0.16054021f, -0.02188352f, 
    0.07684409f, 0.18777838f, 0.03711439f, 0.12494799f, -0.05100475f, 0.07515773f, 0.15518767f, 0.04334247f, 
    -0.05771583f, 0.07605501f, -0.06188625f, 0.06350368f, -0.17757581f, -0.03873923f, 0.01984541f, 0.08592100f, 
    -0.10983748f, 0.06126792f, 0.20038375f, 0.22706738f, -0.26995802f, -0.19018826f, -0.04724996f, 0.01729721f, 
    0.01388258f, -0.11450510f, -0.00148539f, 0.00301564f, 0.07624914f, 0.04240587f, -0.11097336f, 0.03989765f, 
    -0.08122339f, 0.29272199f, 0.19701315f, -0.19489928f, -0.07894979f, -0.11988332f, -0.01146321f, 0.12320734f, 
    0.08523910f, -0.09773895f, 0.03020927f, 0.02640694f, -0.03403816f, 0.33702073f, 0.16134855f, -0.22353996f, 
    -0.01634018f, 0.05149230f, 0.07691912f, 0.13036430f, -0.08006717f, -0.00639260f, 0.00607169f, 0.00705358f, 
    0.11663355f, -0.00348790f, 0.03348965f, -0.05159181f, -0.10825564f, 0.01264523f, 0.02600974f, 0.01244255f, 
    0.02953257f, 0.06386394f, 0.05768514f, 0.03623754f, -0.02199312f, -0.11065038f, -0.01654382f, 0.04648403f, 
    -0.00799534f, 0.08896469f, 0.06872114f, 0.07018528f, -0.07968464f, -0.01476310f, 0.00338481f, -0.01187439f, 
    -0.08262811f, -0.29278350f, 0.01044572f, 0.25328353f, -0.00983865f, -0.01159567f, 0.01889804f, 0.03746258f, 
    -0.01307359f, -0.06588945f, -0.03320728f, -0.05265633f, -0.09743590f, 0.02308301f, 0.11336324f, 0.00030180f, 
    0.04919739f, -0.09813865f, 0.02653429f, 0.07728953f, -0.01042158f, -0.02727192f, 0.05431041f, -0.08153871f, 
    -0.24663870f, -0.05594786f, 0.09484418f, 0.24060416f, 0.03667598f, 0.03066841f, 0.14748482f, -0.02162210f, 
    0.02343336f, 0.04016742f, -0.00414889f, -0.11456048f, 0.19567584f, -0.04203158f, -0.11024379f, 0.02993584f, 
    0.09868526f, 0.10444757f, 0.01919758f, 0.09796488f, 0.00804064f, 0.05613166f, 0.03969323f, 0.06749653f, 
    0.02524498f, 0.17653830f, -0.10905464f, 0.01306375f, 0.20791180f, -0.01147071f, -0.01903247f, 0.07010845f, 
    0.10269385f, 0.01071455f, -0.02154290f, 0.12741280f, -0.19802497f, -0.01728651f, 0.08767101f, 0.10817762f, 
    0.06870982f, 0.13754514f, 0.17288873f, 0.00189420f, 0.06306340f, -0.14766519f, 0.14248323f, 0.10843641f, 
    0.19977842f, 0.04951961f, -0.08320899f, 0.30849251f, 0.03266989f, -0.00550682f, 0.05488276f, 0.04604168f, 
    0.00652655f, -0.06882379f, 0.16742167f, 0.04365314f, -0.12960158f, -0.16064209f, 0.12544724f, -0.21268661f, 
    -0.01394108f, -0.02314424f, 0.05854069f, -0.12902091f, -0.04562951f, 0.09512448f, 0.05740897f, 0.06031355f, 
    -0.31728175f, -0.11316915f, 0.01375854f, -0.18972513f, 0.10469371f, -0.06739103f, -0.00605629f, 0.03237215f, 
    0.01170946f, -0.00959991f, -0.04127249f, -0.10674971f, 0.04051553f, 0.18513648f, 0.01427681f, 0.15010014f, 
    0.05512602f, -0.08287814f, 0.10078859f, 0.15033613f, 0.02819207f, 0.07030486f, 0.00759730f, 0.02888400f, 
    -0.25151855f, -0.00375012f, -0.11366666f, 0.44187278f, 0.09769126f, -0.09955633f, -0.12225263f, 0.03868333f, 
    -0.07973666f, 0.09149955f, -0.11378064f, 0.10967664f, -0.06197886f, 0.04833693f, -0.16976728f, 0.01490729f, 
    0.09779897f, 0.14231507f, -0.02615772f, -0.01496202f, 0.04570621f, -0.10845178f, 0.12612709f, -0.03680964f, 
    0.00108404f, -0.10188595f, 0.08791612f, 0.07371310f, 0.00934271f, -0.00051832f, -0.13658831f, -0.15753965f, 
    0.05146401f, -0.10742034f, 0.12823132f, -0.03342645f, 0.23629975f, -0.06206208f, 0.15227051f, 0.10754894f, 
    -0.02888603f, -0.04725657f, -0.02359822f, -0.16173625f, 0.03557198f, -0.03057110f, -0.00155513f, 0.07066452f, 
    -0.17768595f, -0.08548401f, 0.03395784f, 0.12573279f, -0.03557958f, -0.02881373f, -0.08807652f, -0.01202216f, 
    -0.01323574f, 0.10227415f, 0.03315366f, -0.04852099f, -0.32780871f, -0.02053542f, 0.23996744f, 0.13275820f, 
    0.01437866f, -0.12208403f, 0.00114949f, 0.07143091f, 0.02168808f, 0.04642497f, 0.01308702f, 0.03124724f, 
    0.14913686f, 0.26279932f, -0.15133090f, 0.38963374f, 0.04737785f, -0.05974431f, -0.03761790f, -0.02291345f, 
    0.08924899f, -0.07027124f, 0.06034435f, -0.06247250f, -0.19392954f, 0.06905175f, 0.02700931f, -0.17545289f, 
    0.03462765f, 0.01723349f, 0.13555716f, 0.01532698f, 0.00195401f, -0.01687774f, -0.01782903f, 0.00002301f, 
    0.21133888f, -0.16162857f, -0.13443920f, 0.11935040f, -0.04684375f, 0.13685590f, -0.00399204f, -0.01602773f, 
    -0.02600617f, 0.12237117f, -0.01162647f, 0.05169687f, -0.04660028f, -0.11622667f, 0.22828177f, 0.10184646f, 
    0.10706829f, 0.05338959f, 0.00723857f, -0.14144757f, -0.08338070f, -0.02203847f, 0.07738588f, 0.11816623f, 
    0.14376341f, -0.16034956f, 0.06236914f, -0.02186200f, -0.01673537f, 0.12704138f, -0.11919080f, 0.05483660f, 
    0.10041796f, 0.07273810f, 0.06120416f, 0.06075051f, -0.08554119f, 0.21950060f, -0.10090254f, 0.08005495f, 
    0.02142938f, 0.11419382f, 0.05393267f, 0.07934634f, 0.07071310f, 0.00978991f, -0.00688241f, -0.07325385f, 
    0.05027278f, -0.04136439f, 0.02510692f, 0.10164443f, -0.05480774f, 0.01822101f, -0.01546628f, 0.02273554f, 
    0.07652078f, -0.11569492f, 0.06243759f, -0.08341145f, -0.18853053f, 0.10608965f, -0.13182762f, 0.10590144f, 
    0.08158065f, -0.06774322f, 0.00618365f, 0.11163220f, 0.09476528f, -0.02572316f, -0.04470085f, -0.05941507f, 
    -0.53368032f, 0.27031744f, -0.14283253f, 0.05397363f, 0.22198191f, 0.01984330f, -0.09981110f, 0.07297742f, 
    -0.12963587f, 0.02102197f, 0.02310690f, -0.06923504f, 0.07433677f, -0.24120778f, 0.11820485f, 0.29089555f, 
    0.04838544f, -0.03833003f, -0.08702296f, -0.02013113f, 0.05366096f, 0.13355774f, 0.02445663f, 0.02497685f, 
    -0.01154056f, -0.09568555f, -0.01596059f, 0.30177912f, -0.11092434f, 0.03064757f, -0.03471065f, 0.08509680f, 
    -0.02480903f, 0.06675930f, 0.05398477f, 0.08007073f, -0.11947202f, -0.22351938f, -0.06728212f, 0.05850062f, 
    0.14870133f, -0.06047340f, -0.10111628f, -0.03199864f, 0.04680743f, -0.01675824f, 0.04548164f, -0.01135620f, 
    0.10906594f, -0.12666139f, -0.10187297f, -0.03350179f, 0.00444607f, 0.02617408f, 0.06868825f, 0.00335130f, 
    0.09555496f, -0.03998246f, -0.14461176f, 0.03876112f, 0.11441340f, 0.07476656f, -0.08581481f, -0.00116042f, 
    -0.00157042f, 0.08781604f, -0.04575240f, 0.00901547f, -0.03438590f, -0.00885867f, 0.02521928f, 0.14698467f, 
    -0.07005531f, -0.05154906f, 0.14221480f, -0.05704218f, -0.08295733f, -0.07004781f, 0.03583656f, 0.00589577f, 
    -0.09605768f, 0.04791393f, -0.04502644f, 0.07330487f, -0.09677221f, 0.03226792f, 0.16518131f, 0.08387035f, 
    -0.00378783f, -0.03025791f, 0.03556051f, 0.08819997f, -0.11748219f, -0.07826842f, 0.02608022f, 0.18898389f, 
    -0.13886611f, -0.26346222f, 0.05416156f, 0.11112088f, 0.02431994f, 0.04771755f, -0.07071868f, -0.05720655f, 
    0.14058614f, 0.09705208f, -0.02106882f, -0.02280992f, -0.29868528f, 0.31724697f, 0.02722157f, -0.04642391f, 
    0.02938681f, -0.01566982f, 0.08719081f, 0.09052797f, 0.01946232f, -0.05656821f, -0.03263241f, 0.13779373f, 
    0.17382853f, -0.15585428f, 0.13958523f, 0.13886082f, -0.08798783f, 0.08747087f, 0.14427924f, -0.05477608f, 
    0.02160249f, -0.02921598f, 0.07809965f, -0.02717637f, 0.29808980f, -0.07557081f, -0.00856514f, 0.36771157f, 
    -0.08007349f, 0.00661093f, -0.05578426f, -0.02189825f, -0.04211504f, 0.08349625f, -0.04147292f, 0.02978496f, 
    -0.03803651f, 0.01549768f, 0.10661988f, -0.00902430f, -0.08721127f, -0.04082866f, 0.00499159f, -0.07897995f, 
    0.12523574f, 0.13316062f, -0.04568513f, 0.02311056f, -0.10199233f, 0.09982724f, 0.03484225f, -0.05340002f, 
    -0.14305657f, 0.04715073f, -0.10056541f, -0.06226557f, 0.04285366f, 0.12656817f, -0.08680269f, -0.10883538f, 
    0.43892813f, -0.21530765f, -0.18404897f, 0.02281899f, -0.14715204f, 0.01983980f, -0.02822837f, -0.09660737f, 
    -0.09792334f, -0.01823403f, 0.06540792f, 0.13835131f, -0.37761441f, -0.12282752f, 0.00765919f, 0.02461704f, 
    0.07073416f, -0.20926090f, -0.06046720f, 0.21180005f, -0.07356942f, 0.02694408f, 0.06964133f, -0.00104623f, 
    -0.36010453f, 0.01683102f, 0.07830440f, 0.05832280f, 0.00160015f, 0.07953889f, 0.07615159f, -0.08690611f, 
    0.10267794f, -0.06310251f, 0.03091349f, 0.04888529f, 0.16581056f, -0.00814840f, -0.03253139f, -0.06326385f, 
    0.04109335f, -0.10617279f, 0.08719327f, 0.08195801f, -0.01679520f, -0.02467832f, 0.03898440f, -0.02294265f, 
    0.02940882f, 0.02169431f, -0.09672526f, 0.08008530f, 0.03929004f, 0.09472085f, -0.01436511f, 0.12801376f, 
    -0.06201456f, 0.08169363f, 0.08064678f, 0.01633356f, 0.15920681f, -0.08921560f, -0.08273599f, -0.04322701f, 
    0.01933199f, -0.12946279f, 0.04717528f, -0.21520559f, -0.06307540f, 0.01204219f, 0.00397855f, -0.05535033f, 
    0.26802289f, 0.13397275f, 0.01641767f, -0.10222530f, -0.04009625f, 0.02707684f, 0.00741986f, 0.07023241f, 
    0.08793512f, 0.02491821f, 0.00543807f, -0.03286601f, 0.18384942f, 0.07947670f, -0.07422388f, -0.17199482f, 
    -0.07376149f, 0.04418898f, 0.01721342f, 0.11832300f, -0.00963366f, 0.06022792f, -0.02843830f, 0.03616365f, 
    -0.09679598f, 0.07535934f, 0.08932694f, 0.11958862f, 0.07848471f, 0.14337464f, 0.01404343f, 0.12612057f, 
    -0.11126046f, -0.09866165f, -0.10125308f, -0.14291076f, -0.33111900f, 0.18041635f, 0.17896385f, 0.11838166f, 
    -0.01852131f, 0.00186223f, 0.01629482f, 0.12433736f, -0.14242733f, -0.03009462f, 0.12097806f, 0.09810153f, 
    0.04938363f, -0.10269988f, -0.13375418f, 0.21287382f, -0.04839051f, 0.06355943f, 0.04317299f, 0.07221282f, 
    -0.03697146f, 0.01153419f, -0.14185749f, -0.00312468f, 0.09140047f, -0.04403698f, 0.06671494f, -0.07925019f, 
    -0.05947757f, 0.04823301f, -0.01046927f, 0.16000357f, 0.02010727f, -0.06348255f, -0.02310278f, -0.03419496f, 
    0.11478090f, 0.08309361f, 0.04810808f, -0.02528577f, 0.02376883f, 0.12104263f, -0.03971405f, -0.02000815f, 
    -0.03276415f, 0.03809165f, 0.04264689f, -0.19058226f, -0.05905040f, 0.35291240f, -0.03851485f, -0.16040024f, 
    -0.10597872f, 0.00359206f, 0.01802618f, -0.09022965f, 0.24002632f, 0.08010264f, -0.11145254f, 0.00932899f, 
    -0.06207819f, 0.02890871f, -0.03267364f, -0.12740910f, -0.07298686f, -0.04881719f, 0.05061402f, 0.02557078f, 
    -0.11264720f, -0.03180108f, 0.11981975f, -0.05382812f, 0.05297367f, 0.14227323f, -0.08480004f, -0.02634886f, 
    -0.24520488f, -0.02897819f, 0.04079570f, 0.14740677f, -0.00036031f, 0.06480469f, -0.09744692f, -0.11061110f, 
    -0.49941176f, -0.09510148f, 0.07927290f, -0.16459335f, 0.13565904f, 0.08814155f, -0.03561832f, 0.14801636f, 
    0.12030883f, -0.05362714f, -0.08319815f, -0.08013847f, 0.12315372f, 0.25846028f, -0.13922007f, -0.01905160f, 
    0.05832814f, 0.05186874f, -0.15360510f, -0.10190809f, 0.07376705f, -0.06986409f, -0.05312081f, -0.05607517f, 
    0.27849075f, 0.29949152f, -0.23768476f, 0.15926665f, 0.05516263f, -0.01515091f, -0.10288774f, 0.10349307f, 
    0.04697988f, 0.00034568f, 0.02295657f, -0.21692628f, -0.17513591f, -0.11315650f, 0.20749734f, 0.10827295f, 
    -0.07512099f, -0.11805896f, -0.00752837f, 0.03683571f, 0.10292479f, 0.07358909f, 0.04277936f, 0.15439942f, 
    -0.01617750f, -0.26884577f, 0.12278056f, -0.07835868f, -0.00293938f, 0.05794195f, 0.03180046f, 0.02300460f, 
    0.11099809f, 0.07452278f, -0.20005235f, -0.14831653f, -0.03991170f, -0.01172315f, 0.12246633f, -0.12411050f, 
    -0.00453092f, 0.02507939f, -0.17307545f, 0.16471596f, 0.05587277f, 0.00423050f, 0.10298660f, -0.05143973f, 
    0.10438035f, -0.02099718f, -0.07436957f, 0.13141148f, 0.21231088f, 0.09393968f, 0.03658080f, -0.05914571f, 
    -0.01229515f, -0.07128256f, 0.05017229f, 0.10658259f, -0.14429840f, -0.16336092f, -0.32503289f, -0.09137265f, 
    0.27189425f, 0.02146335f, -0.06330603f, -0.07561926f, 0.13679375f, -0.04030827f, 0.07667832f, 0.10242207f, 
    -0.01582533f, -0.07473700f, -0.17373751f, -0.11111108f, 0.02556521f, 0.01358222f, 0.02869246f, 0.13494281f, 
    -0.00210148f, 0.15061690f, 0.12883759f, 0.19712470f, 0.42562306f, -0.07225867f, -0.31910986f, -0.16300859f, 
    0.02479563f, -0.06274948f, 0.00618577f, 0.06871189f, 0.11814508f, 0.13363315f, 0.04237058f, 0.03574365f, 
    -0.11784154f, -0.00887448f, 0.18370807f, -0.36868304f, 0.11121627f, -0.00335943f, -0.04564666f, -0.05825085f, 
    0.08591921f, 0.11641999f, 0.13394408f, 0.12520200f, 0.09493950f, 0.00507875f, 0.08354361f, 0.19712748f, 
    0.00187560f, 0.07324833f, -0.03120262f, -0.04165271f, 0.06944071f, 0.10144263f, 0.08118518f, 0.13746670f, 
    0.19958937f, 0.09246067f, 0.13038553f, -0.30249843f, 0.06404008f, -0.01938723f, 0.04500992f, -0.11117923f, 
    0.08639178f, 0.00869019f, 0.07725812f, 0.14818649f, -0.09612595f, 0.06658071f, -0.10839597f, 0.10700142f, 
    -0.10721820f, -0.02912476f, -0.11956274f, 0.08505006f, -0.04227071f, -0.09370636f, 0.05706212f, -0.03632413f, 
    -0.08307590f, 0.14146741f, -0.09934244f, -0.00203313f, -0.05382871f, -0.05222804f, -0.10371591f, -0.08550565f, 
    -0.05635501f, 0.01070911f, 0.05195392f, -0.02843551f, -0.20045796f, 0.11507485f, -0.09395091f, -0.18824229f, 
    -0.09076232f, 0.04420487f, 0.05811437f, 0.19316274f, 0.11943665f, -0.02250419f, -0.09218962f, -0.05037746f, 
    0.10107082f, -0.19640930f, 0.04678395f, -0.03825248f, 0.00302407f, 0.05857066f, -0.07273617f, -0.02947665f, 
    0.02674051f, -0.11906390f, -0.04506739f, -0.02360583f, -0.08611187f, 0.43610463f, -0.00024970f, -0.14262845f, 
    0.06607348f, 0.03992458f, -0.04900585f, -0.02714630f, -0.00825689f, 0.11167048f, -0.08428734f, -0.18524051f, 
    -0.43879944f, 0.16901228f, -0.09398855f, 0.03367634f, 0.14150313f, 0.10810880f, -0.00334640f, 0.08456840f, 
    0.02423036f, -0.00549337f, 0.13671878f, 0.04666728f, 0.02185315f, -0.07396470f, 0.10287052f, -0.01110965f, 
    0.03200101f, -0.11211087f, -0.04159866f, 0.06384478f, -0.01632731f, 0.04396110f, 0.04348811f, -0.02302620f, 
    0.11591344f, 0.04599670f, 0.17606407f, 0.09642287f, -0.04044916f, -0.05625821f, 0.02886704f, 0.01189955f, 
    0.06074153f, -0.01165769f, -0.05018857f, -0.04317395f, 0.24191302f, -0.15169768f, -0.32042959f, -0.31813946f, 
    0.04952298f, 0.12051833f, 0.01019356f, 0.05394112f, 0.04855347f, 0.05447462f, -0.01434635f, 0.08078227f, 
    0.53881210f, -0.08804243f, -0.00725454f, 0.12797771f, -0.08825369f, -0.07431683f, 0.05154719f, 0.00737225f, 
    0.01730867f, 0.06713263f, 0.02968840f, 0.06906071f, 0.26116705f, -0.12732349f, -0.04234469f, 0.16627142f, 
    -0.04865172f, -0.02790424f, 0.09533720f, -0.02319150f, 0.06275506f, 0.09986846f, 0.00265330f, 0.11084636f, 
    -0.15551892f, 0.20053932f, 0.09323565f, -0.00894792f, 0.01711763f, -0.04303006f, 0.01427727f, -0.07874025f, 
    0.00256708f, 0.00823460f, -0.03012263f, 0.08291709f, -0.09528100f, 0.07099190f, 0.10170456f, 0.11338612f, 
    -0.01647116f, 0.09908453f, 0.01155357f, 0.00951555f, 0.02458235f, -0.00480597f, 0.08723861f, -0.06602687f, 
    -0.04433403f, -0.05822806f, 0.08854122f, -0.09758317f, -0.06560285f, 0.02911625f, 0.02185309f, -0.08376412f, 
    0.15442125f, -0.09142792f, 0.01331238f, -0.03395889f, -0.16750950f, -0.05207011f, 0.11751340f, 0.18430248f, 
    -0.02556110f, 0.15953372f, 0.12083697f, -0.00755019f, -0.07522471f, 0.04398932f, -0.00404334f, 0.02241544f, 
    0.34936762f, 0.32902384f, -0.24171522f, 0.03513763f, -0.12446754f, -0.00809294f, -0.17745177f, 0.06527375f, 
    0.00352706f, -0.00603528f, -0.07015510f, -0.00851787f, -0.14279626f, 0.30194944f, 0.13517874f, 0.03909284f, 
    -0.10879977f, -0.01837924f, -0.09685649f, -0.10299683f, 0.09383691f, 0.01482242f, -0.04744431f, -0.00371440f, 
    0.15976988f, 0.13443556f, -0.23605733f, -0.12631373f, 0.07807694f, 0.02740938f, 0.08046965f, 0.12257742f, 
    -0.01839129f, -0.17342587f, -0.03889022f, 0.07484610f, 0.09146277f, -0.05926725f, 0.14926773f, 0.23202036f, 
    -0.09328028f, -0.09248534f, 0.00726901f, 0.06249200f, 0.06400421f, -0.10099898f, 0.11919793f, 0.11460077f, 
    -0.39215109f, 0.00824420f, -0.06682927f, -0.22102422f, 0.05611634f, -0.15171273f, 0.01329442f, 0.09065780f, 
    0.00668083f, -0.12916403f, 0.07197714f, -0.01766947f, 0.09811188f, -0.02131580f, 0.17264199f, 0.18490365f, 
    -0.06996044f, 0.01651010f, 0.05282806f, -0.07005197f, 0.06083772f, -0.04273080f, -0.07708617f, -0.02297037f, 
    0.03479134f, 0.13330080f, 0.05879708f, 0.01754898f, -0.07993573f, -0.10353472f, -0.09022829f, -0.04925626f, 
    -0.03702283f, 0.02264981f, -0.11640799f, -0.22112986f, -0.36568099f, 0.03209326f, -0.08263735f, -0.00907327f, 
    -0.08404419f, -0.01514039f, 0.09825251f, -0.00567368f, 0.05376986f, 0.13533142f, 0.04380576f, 0.00485835f, 
    -0.07472260f, -0.13513187f, -0.15004891f, -0.00008741f, 0.19514897f, 0.06972641f, 0.03213939f, 0.05586785f, 
    0.11710627f, 0.01514207f, -0.13892426f, 0.10080843f, -0.11666708f, 0.20999499f, 0.16932352f, 0.24311942f, 
    0.00701810f, -0.01730176f, -0.16019346f, 0.01311641f, 0.02561402f, 0.04697421f, -0.02051206f, -0.17247292f, 
    0.11771183f, 0.11009301f, 0.18893901f, 0.29851490f, 0.08638340f, 0.12966704f, 0.04257081f, -0.07127059f, 
    0.06590934f, -0.06098265f, 0.02946825f, -0.04192394f, 0.22651188f, 0.07839146f, 0.07894582f, 0.38848272f, 
    0.09781867f, 0.12773193f, 0.08977933f, -0.05233160f, 0.03916029f, 0.07233122f, -0.01985254f, 0.04725631f, 
    -0.10361428f, -0.26444614f, -0.20765360f, 0.05843030f, 0.13357365f, -0.03204330f, -0.06687433f, 0.00980724f, 
    0.14118133f, 0.05397113f, 0.04966613f, 0.15381253f, 0.12017464f, 0.08612106f, -0.17527673f, 0.04364813f, 
    -0.01271945f, -0.00940010f, 0.03973836f, -0.04388111f, 0.10381228f, 0.13151886f, 0.07078869f, 0.02763022f, 
    0.29417506f, 0.30518371f, 0.00258611f, -0.05177434f, 0.09805066f, -0.01000079f, -0.08213205f, -0.13276444f, 
    0.06954134f, 0.03005176f, 0.07504480f, -0.01222485f, 0.10986952f, -0.11166900f, 0.03004548f, -0.11941728f, 
    -0.10562199f, 0.00507607f, -0.05426190f, -0.11180364f, -0.10538913f, -0.06631679f, -0.05790566f, 0.07883729f, 
    0.01669373f, -0.17507482f, -0.23583500f, -0.19904229f, 0.02367499f, -0.01456122f, 0.04544693f, -0.03066765f, 
    -0.02960219f, 0.08795429f, -0.04345448f, 0.05023747f, -0.30136055f, -0.22500907f, -0.23553558f, -0.04491031f, 
    0.09111390f, -0.05287213f, -0.13386311f, 0.04073422f, -0.11084964f, -0.07375851f, -0.05325498f, 0.11110342f, 
    -0.02187046f, 0.04210397f, 0.03144313f, 0.05235058f, -0.01690232f, 0.06032048f, -0.00559112f, -0.07691484f, 
    -0.02364309f, -0.03594546f, -0.06146466f, -0.00635385f, -0.03374432f, -0.02089426f, 0.05645123f, -0.07739512f, 
    -0.00663879f, -0.05666817f, 0.02489289f, -0.06403931f, 0.02243198f, -0.04592336f, 0.01922309f, 0.03629298f, 
    0.06623722f, 0.01512746f, -0.08253414f, -0.06869011f, -0.03988204f, 0.00402138f, 0.01705568f, -0.08149755f, 
    0.01983575f, -0.08010236f, 0.03845270f, -0.00000771f, -0.02924266f, -0.02490661f, -0.01900476f, -0.02220595f, 
    0.04109615f, -0.06719369f, 0.04036361f, -0.00378586f, 0.05068295f, 0.02825352f, -0.01497645f, 0.01897216f, 
    -0.04155059f, 0.02931080f, 0.02205941f, 0.02314476f, 0.05263612f, 0.05910507f, -0.06101698f, -0.04695483f, 
    -0.07294123f, 0.03511955f, -0.07028030f, -0.05898139f, -0.03966994f, -0.04652031f, 0.04158245f, -0.06361294f, 
    0.02963312f, 0.02880243f, -0.02660016f, -0.01527400f, 0.05206691f, -0.05574650f, 0.01593306f, -0.07320668f, 
    0.03868007f, -0.01169659f, 0.04319405f, -0.07823596f, 0.02901288f, 0.05862200f, -0.01622737f, -0.07218885f, 
    -0.05563004f, -0.06309807f, -0.00419554f, 0.02335725f, 0.02456970f, 0.03322596f, 0.05704079f, -0.04709260f, 
    0.01863975f, 0.05252458f, 0.01461898f, -0.07432629f, -0.02866245f, 0.01638325f, 0.04293237f, -0.04213057f, 
    -0.01611566f, -0.05379353f, 0.00650193f, -0.03403803f, -0.03086457f, -0.01613643f, -0.00437516f, -0.00380157f, 
    -0.01650752f, 0.05533421f, 0.03054759f, -0.02405537f, -0.05503828f, 0.04224804f, -0.07301907f, -0.02746034f, 
    -0.04881349f, -0.03062460f, 0.01876514f, 0.03601743f, -0.04725335f, -0.04567833f, -0.03807558f, 0.03516780f, 
    -0.00897048f, 0.05412211f, 0.06707819f, 0.00446141f, 0.01300189f, 0.00988799f, 0.00788030f, 0.02279394f, 
    -0.06185434f, -0.02914032f, 0.03056700f, 0.03161373f, 0.04243397f, -0.06083374f, 0.02172073f, 0.03195318f, 
    0.00951667f, 0.01804589f, 0.01972687f, 0.01911169f, 0.06255910f, 0.01395911f, 0.05096005f, -0.04237886f, 
    -0.02050618f, 0.06172672f, 0.04453924f, -0.03956980f, -0.04688874f, -0.04489738f, 0.02050688f, -0.02675934f, 
    0.03416425f, -0.03970981f, 0.06799335f, 0.00962770f, -0.01701784f, -0.02552485f, -0.03402759f, -0.00285265f, 
    -0.05575060f, 0.05480842f, 0.00435716f, -0.01702838f, 0.06841443f, -0.03175392f, -0.05814956f, 0.04774426f, 
    -0.02611807f, 0.00981249f, -0.03937211f, -0.01236297f, -0.04508219f, -0.05074127f, -0.07271378f, -0.01900869f, 
    -0.01851320f, -0.01891189f, -0.06423709f, 0.06572518f, -0.06525081f, -0.01242895f, -0.03001510f, -0.04993459f, 
    -0.06748341f, 0.02928663f, 0.02940087f, 0.00776457f, 0.05336355f, -0.03910476f, -0.06321192f, 0.01887309f, 
    0.06948888f, -0.21030849f, 0.21553145f, 0.09937722f, -0.03443323f, -0.06145185f, 0.11488922f, -0.01949994f, 
    0.00686395f, 0.17645563f, 0.02728276f, -0.05528801f, -0.03354986f, -0.02509967f, -0.11496414f, -0.09459563f, 
    -0.01278129f, 0.06125247f, -0.09710515f, 0.00202980f, -0.06070268f, 0.11459492f, -0.01585630f, -0.08168817f, 
    0.03602659f, -0.01412385f, 0.04340692f, -0.06779698f, -0.14595786f, 0.09279560f, 0.03015204f, -0.00127459f, 
    0.05257085f, 0.08268999f, -0.00732852f, 0.02658840f, -0.09184764f, -0.21123132f, -0.02458527f, 0.09368230f, 
    0.05207513f, -0.03681976f, -0.07050621f, 0.15782502f, 0.02591281f, -0.01502064f, 0.13864794f, 0.05578747f, 
    -0.14372741f, -0.08993522f, 0.11998159f, 0.05423419f, 0.08054690f, 0.03841017f, 0.11988885f, 0.05857432f, 
    0.07647283f, 0.06271356f, 0.07841915f, 0.19546285f, -0.08855469f, -0.05896404f, 0.07007571f, -0.08654021f, 
    -0.03684110f, 0.13416110f, 0.02821992f, -0.02911246f, 0.03145574f, -0.08738568f, -0.07035531f, -0.03328077f, 
    0.03798684f, 0.01165914f, 0.12423591f, -0.14334287f, -0.08512736f, -0.05299849f, 0.01124680f, -0.02835600f, 
    -0.04369933f, 0.05615186f, 0.19658841f, 0.12869522f, -0.21630967f, -0.14280595f, 0.09941798f, 0.04440630f, 
    0.11838502f, -0.08271149f, 0.07384880f, 0.09750316f, 0.05643290f, 0.01906905f, -0.02193530f, 0.07018580f, 
    0.02691733f, 0.33979696f, 0.06643323f, -0.09974810f, -0.01619888f, 0.00709000f, 0.06260677f, 0.09536605f, 
    -0.03739611f, 0.07631895f, -0.00756864f, 0.03407792f, -0.05912713f, 0.24605253f, 0.02080452f, -0.09328548f, 
    -0.00734979f, 0.03348026f, 0.05252967f, 0.14726546f, 0.00104432f, 0.06391847f, 0.00814579f, 0.07608873f, 
    0.14747702f, -0.04636894f, 0.10236336f, -0.07918896f, -0.08432701f, 0.11631823f, 0.01819064f, -0.00947195f, 
    0.03588454f, -0.00706074f, -0.07711681f, -0.12655364f, 0.13984799f, -0.07210697f, -0.04646754f, -0.05598737f, 
    -0.04874848f, 0.02459070f, 0.04976042f, 0.10162135f, -0.00806057f, -0.06582874f, -0.06817187f, -0.01158091f, 
    -0.00046806f, -0.17996578f, 0.08331022f, -0.06156915f, -0.10599555f, 0.11046999f, 0.10176654f, 0.10625943f, 
    -0.09921163f, 0.05359184f, -0.00977736f, 0.01897269f, 0.21021535f, 0.07669289f, -0.02546651f, 0.07868903f, 
    0.05680808f, -0.09737158f, -0.06282961f, 0.07784297f, 0.11093362f, 0.00587267f, 0.07207477f, -0.06243234f, 
    -0.12483114f, 0.08345596f, 0.11559020f, 0.01053593f, 0.11358519f, -0.04384141f, -0.03674349f, -0.11740153f, 
    0.06101915f, -0.01553220f, 0.07821086f, -0.04975649f, 0.13358828f, -0.02295605f, -0.07015726f, -0.10945205f, 
    -0.07525320f, -0.02264387f, -0.02872304f, 0.14397229f, 0.22230697f, 0.07785245f, 0.11664645f, 0.03409470f, 
    0.04919228f, -0.01060269f, -0.03598491f, 0.14238675f, 0.14846177f, 0.02323573f, -0.03669930f, 0.13300431f, 
    -0.00782938f, 0.03009997f, 0.10672666f, 0.06610278f, -0.25724626f, -0.13079515f, -0.12267180f, 0.07250492f, 
    0.14529735f, 0.02103534f, 0.04840602f, -0.00685080f, 0.11631788f, -0.14798871f, -0.00597887f, 0.05693306f, 
    -0.11483517f, -0.10686725f, 0.04968018f, -0.08121376f, -0.06902760f, -0.07947464f, 0.16497375f, -0.02982466f, 
    -0.00859061f, -0.05584858f, -0.04598694f, -0.06687068f, -0.01901456f, -0.04958873f, 0.01973040f, 0.00033862f, 
    0.05126461f, 0.12257545f, -0.00903099f, 0.01176433f, 0.08578625f, -0.05944752f, -0.09535980f, 0.03796540f, 
    -0.47329313f, 0.21590941f, -0.10982141f, -0.10299587f, 0.07547250f, 0.02617888f, -0.00471987f, 0.09298216f, 
    -0.09017180f, -0.03315774f, 0.10312705f, 0.00369969f, -0.13042770f, -0.22054404f, 0.07395165f, 0.02946299f, 
    0.12370399f, 0.01046401f, 0.10268392f, -0.02617352f, 0.06917784f, 0.03336126f, -0.01481412f, 0.01752388f, 
    -0.09947059f, -0.17589869f, 0.08733769f, 0.10898075f, -0.07299510f, -0.13361664f, 0.05593316f, -0.03493577f, 
    -0.09170493f, -0.00629421f, 0.04856957f, 0.13927485f, -0.24527968f, -0.32708323f, -0.13452001f, -0.11255889f, 
    0.15637127f, 0.06382739f, -0.08242477f, -0.07803013f, 0.07763133f, -0.08108614f, 0.03160816f, 0.04967055f, 
    0.08852649f, 0.14344329f, 0.22127993f, 0.05904770f, -0.07394993f, -0.06978767f, -0.04497677f, 0.07624329f, 
    0.10118348f, -0.01021868f, 0.06231931f, 0.00812833f, 0.35923973f, 0.28382006f, 0.24821496f, 0.09291011f, 
    -0.02689240f, 0.13667834f, -0.00914445f, 0.01038749f, -0.03773777f, 0.02830646f, -0.03811668f, 0.06948768f, 
    -0.01140987f, 0.00189016f, 0.18687049f, 0.03839174f, -0.15092203f, -0.03605947f, -0.00826688f, -0.07129934f, 
    0.01686850f, 0.11365933f, 0.15794230f, 0.09573767f, -0.16608393f, 0.07343350f, 0.11465962f, 0.02571165f, 
    -0.08514635f, 0.09761395f, 0.06652694f, 0.05742560f, 0.01320295f, 0.07826737f, 0.02143565f, 0.01742450f, 
    -0.11412978f, -0.15363002f, 0.06999482f, 0.16026923f, 0.00714662f, -0.06202212f, 0.09723987f, -0.11393056f, 
    -0.02713888f, -0.06132393f, -0.02869110f, -0.06740721f, -0.27679050f, 0.22794420f, 0.04106594f, -0.07964170f, 
    -0.06503616f, -0.00637206f, -0.02762835f, -0.02567835f, -0.03978656f, -0.08566640f, 0.01285045f, 0.02906347f, 
    -0.15493710f, 0.05894990f, 0.16970699f, 0.20537309f, -0.06202926f, -0.06908757f, 0.10586815f, -0.05352147f, 
    0.00556462f, 0.01320694f, 0.02531090f, -0.01640055f, 0.13239394f, -0.15283018f, -0.04367767f, 0.17418578f, 
    0.11002398f, 0.01125508f, -0.00437364f, 0.06347123f, -0.10026371f, 0.08375342f, 0.06694046f, 0.08296263f, 
    0.29447809f, -0.07483964f, -0.03788977f, 0.11550538f, 0.15042087f, 0.02941762f, -0.14303531f, 0.01277173f, 
    0.07485349f, 0.02909581f, 0.06886808f, 0.04387876f, -0.12730618f, -0.08795270f, 0.02962555f, 0.15274203f, 
    -0.05668933f, 0.16404212f, 0.14539285f, 0.03089496f, 0.07980949f, 0.03111538f, 0.06260448f, -0.04901256f, 
    0.08492368f, 0.19482124f, -0.06608419f, 0.06220254f, 0.10156187f, 0.02118817f, -0.06260981f, -0.08019590f, 
    -0.00544240f, -0.07037134f, 0.10418834f, -0.07869253f, -0.16959134f, -0.07768384f, 0.11470960f, -0.11317178f, 
    0.02381345f, -0.01977525f, 0.12612210f, -0.11744821f, -0.07977884f, -0.00851468f, -0.09519400f, -0.00542993f, 
    -0.31634516f, -0.04228214f, 0.09488649f, -0.16565016f, 0.18593948f, 0.03379629f, -0.00753807f, -0.04623962f, 
    0.05411083f, -0.00542992f, -0.00307817f, -0.06689875f, -0.11119170f, -0.01614779f, -0.06789517f, 0.17097086f, 
    0.11570789f, -0.14901315f, -0.11219232f, 0.15093617f, 0.05767847f, 0.00127998f, -0.04186313f, 0.03910455f, 
    -0.19710414f, -0.10764845f, -0.15498757f, 0.16910805f, -0.01693046f, 0.05837759f, -0.09643389f, 0.06849579f, 
    -0.02990367f, 0.22407342f, -0.01142433f, 0.05869287f, -0.13580550f, 0.10685603f, -0.07671130f, 0.16582613f, 
    0.04997931f, 0.19669712f, -0.13150913f, -0.10404187f, 0.10776754f, -0.07211012f, -0.02291146f, 0.04822626f, 
    -0.04488701f, -0.03935543f, -0.10953634f, -0.14030656f, 0.08896021f, 0.05849368f, -0.01164841f, -0.00642501f, 
    -0.04170455f, 0.02254773f, 0.04652162f, -0.04810700f, -0.13546421f, 0.07250627f, 0.10466001f, -0.17384279f, 
    0.11214562f, 0.02230579f, -0.00386903f, -0.06917974f, 0.00469461f, 0.07177288f, 0.00004068f, -0.03921722f, 
    -0.03949606f, -0.09412012f, 0.00166246f, 0.08866966f, 0.01961774f, -0.04508306f, 0.04232565f, 0.07503424f, 
    -0.07802010f, 0.07805144f, 0.06634827f, 0.05566375f, 0.05875773f, -0.18554100f, 0.13822040f, 0.28897080f, 
    -0.03337935f, -0.02709882f, 0.00341454f, 0.08425509f, 0.00370162f, 0.03565868f, 0.16802022f, 0.05677324f, 
    -0.07769697f, 0.04479378f, -0.09596654f, 0.44001126f, 0.11137912f, -0.04028843f, -0.14333449f, -0.10536005f, 
    0.06054663f, -0.07834272f, -0.02861910f, 0.06792266f, -0.19397072f, 0.01326383f, 0.23506895f, -0.13913946f, 
    -0.04253406f, -0.05736695f, 0.04297346f, -0.05566973f, 0.09274573f, -0.13818267f, -0.04883165f, 0.13133059f, 
    0.41126800f, 0.07681809f, 0.06449290f, 0.02679199f, 0.01874921f, -0.01185066f, 0.02492509f, 0.07803084f, 
    -0.03999415f, -0.01032717f, 0.01092957f, -0.01209128f, 0.06490843f, -0.04470619f, 0.15875204f, 0.26582870f, 
    0.08465193f, 0.09376071f, -0.07543371f, -0.15641052f, -0.05546395f, 0.05476205f, 0.04397779f, -0.01309719f, 
    0.07654445f, 0.02307449f, 0.06436708f, 0.05846605f, -0.09816678f, 0.27660444f, 0.11365163f, -0.01016489f, 
    -0.14700763f, 0.23091477f, 0.05691274f, 0.05411247f, 0.23168334f, 0.18882269f, 0.21858121f, 0.09012688f, 
    -0.18221037f, 0.02758306f, 0.03691188f, -0.01802454f, -0.05734244f, 0.08657870f, 0.09226537f, -0.14726132f, 
    -0.09621891f, 0.14332521f, -0.08767334f, 0.09481256f, 0.19883834f, 0.07678714f, -0.07715913f, -0.06504306f, 
    0.04389485f, 0.07007241f, -0.03887349f, -0.00896008f, 0.05042559f, 0.00452790f, -0.10522705f, 0.05716278f, 
    -0.03078347f, -0.13890022f, 0.10556494f, 0.18985285f, -0.00348690f, -0.06737867f, -0.03053745f, 0.10387523f, 
    0.15295093f, 0.11312068f, -0.02596459f, 0.07103240f, 0.06724849f, 0.06567351f, 0.03258207f, 0.12318191f, 
    -0.07929259f, 0.15142632f, -0.08625767f, -0.17952979f, 0.00452325f, -0.15165974f, 0.00366988f, 0.09966863f, 
    0.04858246f, 0.07837942f, -0.18338844f, -0.06965578f, -0.00621161f, 0.03668262f, -0.00969137f, 0.00724522f, 
    0.15479824f, -0.04843837f, -0.24543071f, -0.02868486f, 0.00737772f, 0.12038407f, 0.09265813f, 0.00223113f, 
    0.08835118f, 0.11505563f, 0.19146636f, 0.09492365f, -0.20561445f, 0.30895776f, 0.10382413f, 0.27701283f, 
    -0.10857722f, -0.09058776f, -0.00996775f, 0.04561350f, -0.10252357f, -0.07235842f, -0.03138519f, -0.09788817f, 
    -0.34525293f, -0.05955948f, -0.19545861f, -0.15956844f, 0.24486955f, 0.01710252f, -0.00982529f, -0.10792693f, 
    0.07295591f, -0.00830298f, -0.04817631f, 0.00788128f, -0.41541922f, -0.08786795f, -0.16501625f, -0.12198459f, 
    0.23034497f, 0.02267507f, 0.01765157f, -0.11389894f, 0.05031806f, 0.15536618f, -0.03396966f, 0.05945555f, 
    0.26646543f, 0.08409254f, -0.05513357f, 0.16481143f, -0.02017637f, 0.09237138f, 0.10273175f, -0.00373722f, 
    0.03991173f, 0.04102961f, -0.08919069f, 0.08701099f, 0.15162033f, 0.05808399f, -0.01014131f, 0.12244110f, 
    0.12014174f, 0.04458673f, -0.00747751f, 0.09367615f, -0.10304620f, -0.12214658f, -0.01871701f, 0.14848901f, 
    -0.00044276f, -0.03761657f, -0.06946298f, 0.00691309f, 0.06866287f, 0.16197601f, 0.00201922f, 0.10020421f, 
    -0.13476792f, 0.12954211f, -0.05943235f, -0.11472999f, 0.17386036f, 0.05247910f, -0.09441917f, -0.08584793f, 
    0.11815752f, -0.08092314f, -0.07034440f, 0.17196304f, 0.04407408f, 0.03379323f, -0.10726309f, -0.08247809f, 
    -0.32115340f, 0.00348335f, 0.18620789f, -0.03056814f, 0.02082482f, 0.02678714f, 0.17737119f, 0.00643907f, 
    0.03165532f, 0.05419345f, 0.09065740f, 0.00930131f, 0.10157836f, 0.10008616f, -0.17473388f, 0.15112156f, 
    -0.05393339f, 0.13281071f, -0.02139546f, -0.03584131f, -0.08641475f, 0.03098769f, -0.03996285f, 0.05830357f, 
    0.12954192f, 0.01696428f, 0.01249011f, -0.11333020f, -0.03902869f, 0.04383803f, 0.07379210f, 0.00505878f, 
    -0.05318365f, 0.06250021f, -0.06833624f, 0.12427089f, 0.07612734f, -0.07515102f, 0.28797472f, 0.08927067f, 
    0.04848715f, 0.08058239f, -0.06119903f, -0.10417057f, 0.00211383f, 0.03664296f, 0.18164042f, -0.05713106f, 
    -0.04761978f, 0.13315621f, -0.03498409f, 0.03736892f, 0.03019509f, -0.04527244f, -0.08307233f, -0.00229830f, 
    0.01947552f, -0.05979528f, 0.05699238f, 0.07978169f, -0.09635918f, -0.09463745f, 0.08757741f, 0.15807591f, 
    -0.01717449f, -0.17361234f, 0.00395202f, 0.15284432f, -0.03668835f, 0.02718478f, -0.00530690f, 0.07031154f, 
    -0.08794884f, 0.01283333f, 0.20314707f, -0.04198941f, 0.03160417f, 0.10780007f, 0.14548700f, -0.08199800f, 
    0.00265034f, 0.08541405f, -0.08854672f, 0.01966395f, -0.26677394f, 0.00060282f, 0.07952629f, 0.12747397f, 
    -0.01653058f, 0.20947887f, 0.05892781f, 0.09116499f, -0.00928300f, -0.13098723f, -0.13180178f, 0.02950130f, 
    0.09770159f, -0.01869386f, -0.04780362f, 0.08972012f, 0.10786186f, -0.01564134f, -0.01980737f, -0.01298344f, 
    0.12815565f, 0.10410819f, 0.21327442f, -0.05141179f, -0.29679605f, 0.25237399f, 0.09326652f, 0.34212515f, 
    -0.02779674f, -0.14030319f, 0.04531861f, 0.00860066f, -0.08018052f, 0.01268803f, 0.03583660f, 0.06120502f, 
    -0.07609682f, -0.01818825f, -0.00674150f, 0.19900046f, 0.08438139f, 0.03675622f, -0.05671147f, -0.03013389f, 
    0.07820233f, -0.07139164f, -0.18242633f, -0.08647346f, 0.13059227f, -0.08887782f, -0.03806897f, 0.23591591f, 
    0.02490047f, 0.07531224f, -0.04279825f, -0.06176336f, -0.04421394f, 0.04406000f, 0.00200208f, -0.03143939f, 
    0.04666827f, -0.12443893f, -0.11136056f, 0.27738801f, -0.03761961f, -0.04105479f, 0.02871622f, -0.04787404f, 
    0.07899691f, 0.01677115f, -0.12742180f, -0.10480613f, -0.10604552f, 0.27181685f, 0.16017859f, 0.07311616f, 
    0.12338768f, 0.01043768f, -0.08407135f, -0.06490283f, -0.10907483f, -0.02721792f, 0.09847313f, 0.03360090f, 
    0.34876725f, 0.30532640f, -0.05484983f, -0.05555983f, -0.04182915f, -0.03846942f, 0.07780218f, -0.03039946f, 
    -0.00559164f, 0.06134377f, 0.01113107f, 0.06013749f, 0.10517496f, 0.08947849f, -0.01871182f, -0.21827827f, 
    0.05808453f, -0.07134286f, -0.02334551f, -0.05173111f, -0.00157062f, -0.07553302f, -0.11582644f, -0.00287022f, 
    -0.18533710f, -0.17402349f, -0.05101793f, -0.10538335f, -0.07040190f, 0.04258116f, 0.06199951f, 0.03257975f, 
    0.03590810f, 0.00678090f, 0.00186941f, -0.11637799f, 0.00112262f, 0.05220500f, -0.09205278f, 0.04219737f, 
    -0.02935573f, -0.06093248f, -0.01970079f, -0.00998438f, 0.00941061f, 0.05655945f, -0.04314172f, 0.00974767f, 
    -0.00078717f, -0.06391247f, 0.11292676f, -0.19399476f, -0.00874499f, -0.00796619f, -0.04536117f, 0.08074531f, 
    0.06090801f, 0.14581671f, -0.03015138f, 0.10623548f, 0.01981980f, 0.16363662f, 0.00986858f, -0.09604355f, 
    0.21116735f, 0.04060687f, 0.05090969f, 0.08653643f, 0.01392566f, 0.10342441f, -0.05732176f, -0.16598526f, 
    0.26954344f, 0.11929740f, 0.08339616f, 0.15573649f, -0.03712243f, 0.01107991f, -0.02464564f, -0.01447996f, 
    0.05592818f, 0.02740193f, 0.01835607f, 0.02913682f, -0.05654066f, -0.06106091f, -0.04814139f, 0.02004310f, 
    0.13639595f, 0.03460777f, 0.12776977f, 0.08976711f, 0.01204152f, 0.10502370f, 0.14342444f, 0.04364095f, 
    -0.21820875f, 0.15767962f, -0.11032283f, 0.12362257f, -0.00189374f, 0.05197307f, 0.06543203f, 0.05909682f, 
    -0.02975197f, -0.01271413f, 0.01459375f, 0.16243835f, 0.20865922f, 0.03632354f, 0.04231256f, 0.30463848f, 
    0.01595118f, -0.01980441f, -0.03900102f, -0.00513259f, -0.09079166f, 0.02019198f, -0.01904503f, 0.00727896f, 
    0.04727291f, 0.03468036f, 0.10121597f, 0.08593825f, -0.03792065f, -0.12171893f, -0.12236878f, 0.12110020f, 
    0.04839836f, -0.04170525f, 0.19423121f, -0.07331636f, 0.17432947f, 0.03537221f, -0.02237614f, -0.09666856f, 
    0.06020073f, -0.03920632f, 0.08124368f, -0.02556136f, 0.08196008f, -0.05357147f, -0.07606374f, -0.02409739f, 
    0.29511145f, -0.19050869f, -0.19766530f, -0.06677546f, 0.04527664f, -0.09241693f, -0.07007584f, -0.20213167f, 
    -0.05678639f, 0.00496948f, -0.13170515f, 0.02815806f, 0.07099488f, -0.01555270f, -0.22030452f, 0.09312151f, 
    0.00601926f, -0.24082024f, -0.10488787f, -0.07362837f, 0.02687676f, -0.06549754f, 0.09377574f, 0.08434061f, 
    -0.13785060f, -0.16810068f, 0.19034049f, -0.08904970f, -0.06561656f, -0.19456147f, -0.00208281f, -0.07363614f, 
    0.14568247f, 0.07766291f, -0.04936318f, -0.10093991f, -0.20320652f, 0.00139383f, 0.01631070f, -0.05433982f, 
    -0.00457399f, 0.00707744f, -0.03123084f, 0.08779737f, -0.01925493f, -0.12137828f, 0.07448438f, 0.08065949f, 
    -0.06557675f, -0.02547106f, -0.00559453f, -0.06973200f, -0.07047072f, 0.07546415f, 0.06829444f, -0.00886819f, 
    0.17819893f, 0.12349536f, -0.13289890f, 0.05230472f, -0.20506647f, 0.29579231f, -0.06088881f, 0.01539181f, 
    0.06904685f, -0.07707260f, -0.00039189f, 0.16105063f, 0.10505553f, 0.04765601f, 0.11195429f, 0.06835482f, 
    0.14403398f, -0.13505863f, 0.08013234f, 0.09282217f, 0.01884094f, -0.11274789f, -0.10304265f, -0.12764628f, 
    0.02473981f, 0.05684444f, 0.10754751f, 0.06860439f, 0.38972861f, 0.07845163f, 0.05741515f, 0.15753904f, 
    -0.11650209f, 0.00594962f, -0.02219424f, 0.01232428f, 0.03598668f, -0.04567879f, 0.04661842f, 0.00523694f, 
    -0.02425239f, -0.07073465f, -0.07556947f, -0.02364159f, 0.06388275f, 0.06405725f, -0.02165575f, 0.04584645f, 
    -0.01377041f, -0.06631886f, 0.05516558f, 0.05925598f, -0.02593103f, -0.07009974f, -0.06365576f, 0.03251563f, 
    -0.01468968f, -0.04484126f, 0.02485736f, -0.06176990f, 0.04466682f, -0.02766569f, 0.05010573f, 0.04556116f, 
    -0.02709247f, 0.01686613f, -0.04423412f, 0.03214279f, -0.07703695f, -0.00613248f, 0.04673401f, -0.03338402f, 
    0.05173269f, -0.01901789f, -0.05124611f, -0.06803687f, 0.01563125f, -0.01933826f, -0.00101304f, -0.01296270f, 
    -0.00095557f, 0.01121415f, 0.06309222f, 0.01794146f, 0.03442396f, -0.07498925f, 0.04431920f, 0.02706632f, 
    -0.08035936f, 0.03526866f, -0.07201058f, -0.05344885f, 0.05491822f, 0.05090018f, -0.06594200f, 0.06543854f, 
    0.00329486f, -0.05950321f, 0.02887079f, 0.00304479f, -0.05756083f, 0.03945506f, -0.03591247f, -0.05922221f, 
    -0.02457946f, -0.02959854f, -0.00397708f, 0.05648297f, 0.00427444f, -0.00173372f, -0.04610488f, -0.01890712f, 
    -0.03075006f, 0.02118441f, -0.05576715f, -0.06859897f, -0.02769023f, 0.04679306f, -0.03293797f, 0.06627455f, 
    -0.00808402f, -0.02073351f, -0.07594440f, -0.00648610f, -0.06853995f, 0.02267101f, 0.02418468f, 0.00831912f, 
    0.07534195f, -0.04812507f, -0.04875789f, -0.06377807f, -0.05838487f, -0.04296146f, -0.07088249f, -0.01223284f, 
    -0.03607549f, 0.03508548f, 0.04176911f, 0.05550821f, -0.02037138f, 0.03397798f, -0.00356865f, -0.06722904f, 
    0.02443778f, 0.01553917f, -0.04403487f, -0.06607635f, 0.05352759f, -0.00275471f, 0.03632024f, 0.00782442f, 
    -0.06602444f, -0.02653415f, -0.00713547f, 0.01477722f, -0.04665650f, 0.00383141f, 0.00808572f, 0.01825949f, 
    0.03656486f, -0.06234241f, -0.01872223f, 0.06145356f, -0.05229020f, -0.00056812f, 0.04393078f, 0.05136232f, 
    0.01514756f, 0.03833888f, 0.01069396f, -0.04722634f, -0.06617257f, -0.05455655f, -0.05785060f, 0.05358877f, 
    0.06039537f, -0.04316386f, -0.01820971f, 0.03862887f, -0.03632193f, 0.04940013f, 0.04262949f, 0.01535121f, 
    -0.02484887f, -0.05504698f, -0.02057974f, 0.00961403f, -0.01745940f, 0.01249317f, -0.06618246f, 0.06603964f, 
    0.06041495f, -0.05418258f, -0.04875502f, -0.01943357f, -0.00589000f, -0.06715271f, -0.03140752f, 0.02628230f, 
    -0.03151104f, -0.05330629f, -0.01558555f, -0.01037089f, -0.00716996f, 0.02996368f, 0.03496488f, -0.02197724f, 
    0.05173548f, -0.00594877f, -0.00373578f, -0.08233698f, 0.01704902f, 0.00320526f, 0.04225064f, -0.00228842f, 
    -0.05168834f, -0.04960639f, 0.06208593f, -0.06432533f, -0.04562160f, -0.06253581f, -0.06862673f, 0.02761369f, 
    -0.05636991f, -0.06603448f, -0.00374550f, 0.00056223f, 0.00757604f, 0.02290883f, -0.00040558f, 0.07012581f, 
    0.05722659f, 0.01152582f, 0.00640980f, -0.00018783f, 0.02839410f, -0.04399399f, -0.04415543f, -0.07192887f, 
    -0.03525973f, -0.03166340f, 0.00092128f, -0.00437250f, -0.06951363f, -0.05318582f, 0.03704097f, -0.03369412f, 
    -0.02653608f, 0.01185532f, 0.00614119f, 0.00099710f, -0.05684863f, -0.06120547f, 0.02464678f, -0.01056020f, 
    -0.03818363f, -0.02505865f, -0.07612450f, -0.03730433f, -0.04439773f, -0.03689628f, 0.00521273f, 0.01405956f, 
    -0.04015258f, 0.06572565f, 0.02457889f, 0.04511591f, -0.03937968f, 0.06917932f, 0.05276308f, -0.02299233f, 
    0.03400045f, -0.03506810f, 0.03500161f, 0.04739035f, 0.03408315f, -0.02131905f, -0.00934773f, 0.04733280f, 
    -0.01830803f, -0.03144073f, -0.04471140f, 0.03196087f, 0.02151477f, -0.03611188f, -0.07324145f, -0.01468121f, 
    -0.05482607f, -0.07483447f, 0.01068888f, -0.05497918f, -0.01918811f, -0.05788045f, 0.03481623f, 0.00636940f, 
    0.04971395f, 0.00537829f, 0.02901548f, -0.03911669f, 0.01372823f, 0.06350429f, 0.06218750f, -0.04894260f, 
    0.00545854f, 0.00249042f, 0.01460169f, 0.03799988f, -0.04473624f, -0.00561738f, -0.07038070f, 0.01451183f, 
    0.05324958f, -0.01320770f, 0.04761718f, 0.02227385f, -0.03840057f, -0.03696959f, 0.02097440f, -0.01799524f, 
    -0.07827049f, -0.01481669f, 0.01053751f, -0.06808747f, 0.05197633f, -0.00584759f, -0.06121214f, -0.06111524f, 
    -0.03949038f, -0.05653322f, 0.05945170f, 0.02507856f, -0.05089692f, -0.00467652f, 0.00461798f, 0.03825521f, 
    0.01758832f, -0.02229917f, -0.03306569f, -0.00910346f, -0.01972635f, -0.06417457f, -0.01268513f, 0.06150140f, 
    -0.06573381f, 0.01016076f, -0.07781363f, -0.00527184f, 0.07416108f, -0.00430165f, 0.00337610f, -0.02868363f, 
    0.01192501f, -0.02788779f, 0.05214157f, 0.06068762f, 0.05252809f, 0.02986739f, -0.04301643f, -0.02295162f, 
    0.00834855f, 0.01166309f, 0.01905207f, -0.07013223f, -0.00832474f, 0.03061811f, 0.06800504f, 0.05181585f, 
    -0.06260885f, -0.03089281f, 0.01936446f, -0.04574944f, -0.06090799f, 0.06262095f, -0.05387961f, 0.02606045f, 
    0.02643987f, -0.05941980f, -0.04108084f, -0.02100652f, -0.04620128f, -0.02809485f, 0.06285831f, -0.06062996f, 
    0.03339990f, 0.06041564f, -0.01009572f, -0.00012850f, -0.06539651f, -0.05862044f, 0.03701172f, -0.04932253f, 
    0.04219522f, 0.03447056f, -0.07367527f, -0.02066904f, 0.00795052f, 0.04727823f, -0.00890392f, -0.02490362f, 
    -0.02673367f, -0.02243852f, -0.01202632f, -0.07792967f, 0.01637982f, 0.00886311f, 0.05411266f, 0.02915929f, 
    0.06174764f, -0.00291980f, -0.02654800f, -0.02591893f, -0.01828497f, -0.04169685f, 0.02293018f, -0.07207201f, 
    0.06949247f, -0.08138262f, -0.04238693f, -0.01133253f, 0.02165233f, 0.04924531f, -0.01092391f, 0.05197292f, 
    -0.03077472f, 0.18988852f, -0.17934501f, 0.19853966f, 0.16620901f, -0.00672669f, -0.11598977f, 0.02152278f, 
    0.02395449f, -0.10952045f, -0.02509698f, 0.03679135f, -0.06964870f, -0.14217564f, -0.07963947f, 0.08648936f, 
    -0.00493887f, -0.07936809f, 0.01689321f, -0.09052478f, 0.03224022f, -0.13513617f, 0.02501754f, 0.11273074f, 
    -0.18110520f, 0.03477495f, 0.08824586f, -0.04379384f, 0.07786060f, -0.02123291f, 0.04239497f, 0.08852476f, 
    0.01803919f, -0.10740244f, -0.02611849f, 0.01083168f, 0.14473063f, 0.03064989f, 0.07927246f, -0.01778758f, 
    -0.04662319f, 0.11851560f, 0.03411957f, -0.18549477f, -0.00356543f, -0.07697736f, -0.10065154f, -0.03367189f, 
    0.14400427f, -0.09236477f, -0.03319067f, -0.08435360f, -0.10220065f, 0.04219531f, 0.00537511f, 0.11244956f, 
    0.07507241f, 0.00739559f, 0.07696810f, -0.03113331f, -0.10362257f, 0.09792447f, 0.04837685f, -0.23485942f, 
    -0.06787474f, -0.13528524f, 0.00262910f, -0.04598865f, 0.10927067f, 0.10694666f, 0.03773186f, 0.00338167f, 
    -0.12414154f, 0.11751889f, 0.09883796f, -0.12135101f, 0.10591510f, 0.12456202f, 0.08067987f, -0.02343061f, 
    0.01877585f, -0.00677015f, -0.05260325f, 0.09439019f, 0.14791340f, 0.02707459f, -0.17682272f, -0.21283464f, 
    0.06969569f, 0.12367298f, -0.00706674f, -0.10534528f, -0.02496960f, -0.02819503f, 0.06223363f, 0.05530094f, 
    -0.04241687f, 0.10784666f, 0.30663925f, 0.23577477f, -0.03834829f, 0.03859529f, 0.01693065f, 0.10249263f, 
    0.01009137f, 0.03482978f, 0.26758829f, 0.02942118f, 0.22212353f, 0.03950209f, 0.36609510f, -0.02309776f, 
    0.03923630f, -0.00757772f, -0.05087734f, -0.00329328f, 0.03570348f, 0.02389160f, 0.04637488f, -0.02761770f, 
    0.05593621f, 0.15116154f, -0.05128215f, 0.09748453f, 0.03461539f, 0.06698294f, 0.04120235f, -0.04872035f, 
    -0.04972842f, -0.07769613f, 0.12646556f, 0.13891061f, 0.08136708f, -0.06860120f, -0.05140773f, 0.03872372f, 
    0.02645554f, 0.10813995f, 0.03076527f, -0.11945496f, 0.09069316f, 0.16210553f, -0.04801621f, -0.03853802f, 
    0.02050324f, 0.15006347f, -0.08115449f, 0.13360772f, -0.05198528f, 0.01141775f, -0.00871122f, 0.04766460f, 
    0.03001860f, -0.13173841f, 0.04658784f, 0.00939679f, 0.03002392f, -0.32364979f, 0.12177224f, 0.09117723f, 
    -0.06610531f, 0.00323901f, 0.09405876f, -0.05792188f, -0.06166525f, 0.05660504f, 0.06094104f, -0.04307147f, 
    -0.07139521f, 0.20469636f, -0.19551225f, 0.07384381f, -0.06741904f, -0.00870066f, -0.02947379f, 0.10154838f, 
    -0.03826564f, 0.07059105f, -0.01605582f, 0.09062131f, -0.19574207f, -0.08800601f, 0.01834484f, -0.10724854f, 
    0.13412075f, 0.02858892f, 0.09441309f, -0.04280182f, 0.02976305f, 0.01302951f, -0.01547093f, 0.09201428f, 
    -0.02254586f, 0.03233346f, -0.04359589f, -0.03446332f, -0.02500597f, -0.05829630f, -0.00317403f, -0.03745405f, 
    -0.06543452f, 0.05898477f, -0.01461787f, 0.06112379f, 0.05845820f, -0.02756732f, 0.04005895f, -0.00796074f, 
    0.05829102f, -0.02905157f, 0.00688209f, 0.05544383f, 0.04987825f, -0.04365313f, 0.02130435f, -0.02184032f, 
    0.05217003f, 0.03183175f, -0.00742499f, -0.05099722f, -0.03381050f, -0.04272771f, -0.05128802f, 0.06171163f, 
    -0.02130839f, -0.01140491f, 0.00816124f, -0.07562738f, 0.05311536f, -0.00967107f, -0.00009620f, -0.00154125f, 
    -0.01174964f, 0.04482741f, -0.04637934f, 0.01466682f, 0.00506181f, -0.05749075f, -0.07477362f, -0.00278501f, 
    0.02890486f, 0.05916083f, -0.00690448f, -0.00429976f, 0.01086953f, 0.05349062f, -0.02581197f, 0.04698882f, 
    -0.07680711f, -0.07083380f, 0.01697931f, -0.04787195f, 0.03341150f, -0.07146588f, -0.02696718f, -0.03390545f, 
    0.01549831f, 0.03432215f, -0.00233506f, -0.04985550f, 0.06035179f, -0.01666998f, -0.07382771f, -0.01891061f, 
    -0.07251668f, -0.05481376f, -0.04360747f, -0.01416451f, -0.03292482f, -0.05454213f, 0.06389865f, -0.07640430f, 
    -0.00750355f, -0.05236445f, -0.07240333f, -0.01377268f, 0.02596295f, -0.07146425f, 0.02364514f, -0.07465138f, 
    0.00030852f, 0.02456436f, 0.06125282f, -0.03172943f, -0.04257423f, 0.06027238f, -0.02024093f, -0.05509955f, 
    -0.03811029f, -0.06316502f, -0.05664740f, -0.04942716f, -0.06002242f, 0.05615787f, -0.06812736f, 0.02851135f, 
    -0.05292033f, -0.07627552f, 0.03063610f, 0.02168835f, -0.05871315f, -0.05698438f, 0.03604463f, 0.05363386f, 
    0.03278814f, -0.03602854f, 0.05925632f, -0.03019243f, 0.03765055f, -0.01616487f, -0.07624455f, 0.03611638f, 
    0.01163294f, -0.04000099f, -0.02073286f, -0.00971624f, 0.05965571f, -0.06606844f, 0.03801742f, -0.04510339f, 
    -0.04987048f, 0.00677749f, 0.06479410f, -0.03875286f, -0.05458348f, -0.03332236f, -0.02826530f, -0.03127824f, 
    0.03531696f, -0.01911978f, -0.04032812f, 0.04918719f, 0.02470245f, -0.06001890f, -0.02408971f, 0.03621303f, 
    -0.01387677f, -0.02705008f, 0.05223655f, 0.02486398f, 0.01883160f, 0.05226707f, -0.00414850f, 0.01437525f, 
    0.00548067f, -0.03842594f, -0.07786384f, -0.07543825f, 0.01087355f, -0.07087713f, 0.04422633f, -0.06832874f, 
    0.05277075f, 0.01314893f, -0.05738353f, 0.03818173f, -0.07081340f, -0.07478137f, 0.04179770f, -0.01981384f, 
    -0.04433786f, -0.06349216f, -0.01610189f, 0.00770154f, 0.01215575f, 0.03172892f, 0.00569730f, -0.04170993f, 
    -0.07204357f, -0.01443993f, 0.01757579f, -0.05727612f, 0.00529278f, -0.02541687f, 0.01651471f, -0.06359910f, 
    0.00510436f, -0.04365157f, -0.00362012f, -0.03636056f, 0.00479899f, 0.04963125f, -0.01283302f, -0.00944490f, 
    0.02889809f, 0.22179490f, -0.09421503f, 0.12822278f, 0.02462724f, -0.03879089f, 0.09224536f, 0.02767182f, 
    0.06820181f, -0.08725613f, 0.04375806f, -0.00757393f, 0.02541714f, -0.22917575f, -0.00477665f, 0.08245564f, 
    -0.05903982f, 0.00632348f, -0.07434992f, -0.05784026f, -0.12819707f, -0.04211838f, 0.08782964f, 0.10660830f, 
    -0.09038019f, -0.07500660f, -0.08497208f, 0.04407349f, -0.02807786f, -0.00945553f, 0.01577568f, 0.16928959f, 
    -0.09715149f, 0.07446001f, 0.12373233f, 0.09101412f, 0.01418142f, -0.28918266f, -0.02454035f, 0.02157480f, 
    -0.00568920f, 0.00227792f, -0.03175441f, 0.07779609f, 0.05049906f, -0.02978221f, 0.14259383f, 0.12318458f, 
    0.21069545f, -0.21404161f, 0.03999925f, -0.04688660f, -0.10640965f, 0.05741401f, 0.10673960f, 0.07964566f, 
    0.09003806f, -0.06911489f, 0.07484511f, 0.09905262f, -0.10615913f, 0.18008310f, -0.06261301f, -0.20597512f, 
    0.05192374f, 0.11539278f, 0.07629237f, 0.04353730f, 0.01435154f, -0.02273750f, -0.04518446f, 0.04230825f, 
    0.05143818f, 0.11252908f, -0.04657679f, -0.09879140f, 0.11607666f, 0.12386387f, 0.03630050f, 0.05461552f, 
    0.05427424f, 0.08607905f, -0.07868444f, 0.08524574f, -0.11620379f, -0.06272623f, 0.10096868f, -0.04290362f, 
    0.01782559f, 0.03835488f, 0.16834877f, -0.00875490f, -0.18008001f, -0.01438303f, 0.01411291f, 0.01844036f, 
    0.00932410f, 0.10735758f, 0.26835817f, 0.15562272f, -0.03489031f, -0.02746050f, -0.08201635f, 0.00896990f, 
    0.12913761f, 0.00293433f, 0.19604552f, 0.09919328f, 0.24597850f, -0.03882733f, 0.15026431f, 0.05164551f, 
    -0.12643901f, 0.03371156f, 0.00673886f, -0.01356211f, -0.01126757f, -0.00801797f, 0.12083023f, 0.07219354f, 
    -0.02923318f, 0.03309177f, -0.03898985f, 0.26705733f, 0.10208505f, 0.12019996f, -0.00375006f, -0.03433785f, 
    -0.02044190f, -0.06652322f, -0.05624587f, 0.03105694f, -0.30064595f, 0.12098358f, 0.07098601f, 0.05513638f, 
    -0.03089010f, 0.01060414f, 0.02248534f, -0.11522356f, 0.10339567f, 0.05217712f, -0.01427812f, -0.00825426f, 
    0.19695337f, 0.23008467f, -0.20968872f, 0.06110300f, 0.00476749f, -0.04784846f, -0.05520421f, 0.05867219f, 
    -0.13721190f, -0.10558137f, 0.01315004f, -0.01258334f, 0.34627488f, -0.26282206f, -0.09374726f, -0.21973851f, 
    -0.07272660f, 0.02087402f, -0.10689294f, 0.00358439f, -0.07127401f, 0.03613474f, 0.02826641f, -0.03590551f, 
    0.03886744f, -0.00735055f, -0.14462736f, -0.14807576f, 0.07051342f, 0.06880738f, 0.04651872f, -0.02123262f, 
    0.02127649f, 0.08592625f, -0.08331016f, 0.02776341f, -0.36087814f, -0.03752126f, -0.05692497f, -0.34593931f, 
    0.06265165f, -0.04082930f, 0.09706655f, 0.01484522f, 0.00206277f, -0.09308836f, -0.02682522f, 0.04311394f, 
    0.08677754f, 0.02003744f, -0.04559051f, 0.12165405f, 0.12823850f, 0.11911763f, -0.01599763f, 0.16052815f, 
    0.08001795f, 0.02409361f, 0.07880948f, 0.05131283f, -0.07535272f, -0.11376949f, 0.14300674f, 0.16376093f, 
    -0.05491424f, 0.06659617f, 0.04641130f, -0.01162645f, -0.03574507f, -0.01976384f, 0.08258259f, 0.00456013f, 
    0.25033721f, 0.15011074f, -0.10396267f, 0.20140477f, 0.03572889f, 0.01530500f, -0.03393721f, -0.07630455f, 
    0.08100657f, -0.05033322f, 0.01820141f, 0.00992885f, -0.11422855f, -0.29209468f, 0.02846939f, -0.01553408f, 
    -0.03593813f, -0.09121772f, 0.09636131f, 0.06787806f, 0.00380490f, -0.01478005f, 0.05802531f, 0.01001272f, 
    -0.07973029f, -0.15008533f, 0.09915285f, -0.01828526f, 0.11432948f, -0.04608709f, 0.08426201f, 0.00432759f, 
    0.01444819f, 0.05430100f, -0.04492828f, -0.06686009f, 0.15140060f, 0.25431150f, -0.15056379f, 0.09862577f, 
    -0.01631293f, -0.07786085f, -0.04120441f, 0.10539398f, 0.03449461f, 0.13017735f, 0.00160943f, 0.02944274f, 
    -0.09801819f, -0.01723709f, -0.26132870f, 0.22331806f, 0.18540403f, 0.02527249f, -0.20185664f, -0.00253271f, 
    -0.03343315f, 0.09557658f, -0.04664500f, 0.04481705f, -0.13249530f, 0.17678548f, -0.10258822f, 0.27973264f, 
    -0.08834066f, -0.01819115f, 0.07528071f, -0.13783339f, 0.02670950f, -0.05418061f, 0.04934811f, -0.00398977f, 
    -0.22358252f, -0.13608387f, -0.00604366f, -0.05863619f, 0.21401204f, 0.03831134f, -0.05474828f, -0.11590425f, 
    -0.03735777f, -0.02895043f, 0.05816041f, -0.02372642f, -0.15704072f, -0.01236487f, -0.00339591f, -0.05504782f, 
    0.13077469f, -0.06224417f, -0.08120912f, -0.19938937f, -0.01921794f, -0.04581824f, 0.00654722f, 0.02045689f, 
    0.01166907f, -0.13139114f, 0.01040013f, 0.15084991f, 0.05345155f, 0.07342532f, 0.03020508f, 0.00884572f, 
    -0.00317659f, 0.07885187f, -0.06033993f, 0.01661272f, -0.19466625f, -0.00311210f, 0.28188378f, 0.20740066f, 
    0.03241384f, -0.00902701f, 0.00885914f, 0.10032887f, -0.03969213f, -0.04337778f, 0.03598853f, 0.06640794f, 
    0.12964536f, 0.08059146f, -0.07886047f, 0.32720435f, -0.03107940f, -0.05239777f, -0.02369580f, 0.08585462f, 
    0.13751242f, 0.06901526f, -0.11631370f, 0.00247852f, -0.07799523f, 0.02510057f, -0.04226619f, -0.14487399f, 
    -0.01428872f, -0.02510526f, -0.02218678f, 0.04210659f, 0.21122806f, -0.14188011f, 0.02790015f, 0.05468138f, 
    0.05781354f, -0.16064931f, 0.10209881f, -0.05659585f, 0.12386814f, 0.17278241f, 0.06810062f, 0.04062481f, 
    0.08114173f, 0.02389159f, -0.04940085f, 0.00640131f, -0.01799552f, -0.05634500f, 0.01689866f, 0.05215527f, 
    0.08661198f, 0.00982553f, -0.01434877f, -0.19148251f, 0.02536918f, -0.15519996f, -0.01236097f, 0.01827411f, 
    -0.06800352f, -0.08559073f, 0.19047220f, -0.06339070f, 0.07615004f, -0.09469630f, -0.04255229f, 0.15970682f, 
    0.06985252f, 0.15736893f, 0.02408110f, -0.00946467f, -0.07114447f, -0.02018827f, -0.07318661f, -0.04727634f, 
    0.20645024f, -0.00582474f, -0.06450570f, -0.00866897f, 0.15720506f, -0.08602113f, 0.05996984f, 0.08142312f, 
    0.00310231f, -0.03316453f, 0.28702784f, 0.11328912f, -0.09244037f, -0.13111757f, 0.04016659f, -0.01255995f, 
    0.03564068f, 0.00194018f, -0.08888669f, 0.04567099f, -0.05945358f, -0.09628083f, -0.09371474f, 0.01474601f, 
    0.04956479f, 0.17056310f, 0.04603543f, 0.12478716f, 0.08806366f, 0.00095735f, -0.01917032f, 0.05835300f, 
    -0.40019968f, -0.02314145f, -0.09066502f, 0.03246114f, 0.07038066f, -0.05147133f, 0.04972354f, 0.01796020f, 
    0.03438984f, -0.03389703f, 0.13028461f, 0.07966752f, 0.02869596f, -0.10510404f, 0.13146915f, 0.12862282f, 
    0.04812517f, 0.17608720f, 0.12424257f, 0.02331828f, 0.08559365f, -0.05838648f, 0.04089908f, 0.09144560f, 
    0.02110755f, -0.02873039f, 0.06531890f, 0.07590836f, -0.15278290f, -0.04261335f, 0.04395092f, 0.00938580f, 
    -0.14414437f, 0.06248385f, 0.00828350f, 0.09178650f, -0.16300571f, -0.27532271f, -0.10263003f, -0.23570560f, 
    0.14539079f, -0.04593488f, 0.03716229f, 0.00669062f, -0.02645955f, 0.00291239f, 0.07492107f, 0.16188137f, 
    0.14245142f, 0.00359755f, 0.09315334f, 0.01077665f, -0.11072758f, 0.01023287f, 0.06519785f, 0.01865983f, 
    0.03788315f, 0.03944026f, -0.04756498f, -0.07188074f, 0.23187719f, 0.19331312f, 0.10706609f, -0.01530972f, 
    -0.13323161f, 0.12505956f, 0.03114810f, 0.08057919f, -0.05136300f, 0.05137311f, 0.09829237f, 0.06633582f, 
    -0.11616629f, 0.08516272f, 0.15356137f, -0.12279969f, -0.12920618f, 0.01818494f, -0.00462147f, -0.16109733f, 
    0.01164055f, 0.08686620f, 0.01036298f, -0.08333769f, -0.20639788f, -0.07239982f, 0.20880868f, -0.05412618f, 
    -0.00063452f, -0.03540029f, -0.01287309f, 0.03191909f, -0.02493640f, 0.01297846f, -0.02490191f, -0.03866344f, 
    0.10937129f, -0.04353473f, 0.14435986f, 0.09145548f, -0.00429895f, -0.00525902f, 0.14736617f, 0.07073691f, 
    0.04826759f, -0.04075819f, -0.01883313f, 0.01472050f, -0.28846863f, 0.22896793f, -0.13004272f, 0.05191850f, 
    0.12120721f, 0.06262375f, 0.08379856f, 0.09092060f, -0.05439831f, 0.02629425f, 0.02746319f, 0.00117819f, 
    -0.10532362f, -0.06036804f, -0.03153360f, 0.23934203f, -0.09268437f, 0.13976452f, 0.06170477f, -0.03285410f, 
    -0.04794069f, -0.03129007f, 0.04806064f, 0.04476802f, 0.16538657f, -0.21088019f, 0.00710028f, 0.24129730f, 
    0.05353961f, -0.05316893f, 0.05832322f, 0.06852303f, 0.03315645f, 0.00778294f, 0.14741613f, 0.03382057f, 
    0.01474628f, -0.11518797f, 0.06460512f, -0.09504726f, 0.08684157f, -0.02844196f, 0.14495908f, 0.04226007f, 
    -0.19130796f, 0.12771350f, 0.00375731f, 0.00103269f, 0.16687490f, 0.20497487f, -0.07272597f, 0.07187825f, 
    -0.07129031f, -0.01180342f, 0.00951102f, 0.02929170f, 0.07971136f, -0.02038024f, 0.03281783f, -0.08898752f, 
    -0.19172844f, -0.09543588f, 0.25103006f, -0.06268959f, 0.11321504f, 0.03607265f, -0.01056383f, 0.05304192f, 
    0.04816270f, 0.14324698f, -0.10174809f, 0.03771900f, 0.11186498f, 0.24344738f, -0.03446357f, 0.23474984f, 
    0.06082849f, 0.06302873f, 0.03458626f, 0.15796843f, 0.05348114f, -0.03660595f, -0.07877461f, 0.05891547f, 
    -0.09042250f, 0.29656160f, 0.00577969f, 0.02052356f, -0.02815332f, 0.10362887f, -0.00232059f, 0.03124664f, 
    0.07242417f, 0.08748195f, -0.04045489f, 0.04240877f, -0.33107182f, -0.40921971f, 0.19345006f, 0.10064881f, 
    0.07352353f, 0.21056950f, -0.03783062f, -0.11531428f, -0.05920839f, -0.02879300f, -0.05981975f, 0.03643374f, 
    0.12214932f, -0.18283360f, 0.22646222f, 0.05222110f, -0.08319025f, -0.05662933f, 0.05987179f, -0.06344582f, 
    -0.01460432f, -0.09009150f, 0.16448957f, 0.01513965f, -0.14462405f, 0.08264794f, -0.03963646f, 0.03282017f, 
    0.04827259f, -0.01410802f, -0.03456008f, 0.04400655f, -0.02656057f, 0.00140822f, -0.07110760f, 0.08164497f, 
    0.12524320f, 0.17740884f, 0.03852004f, 0.06319650f, -0.15461981f, -0.01864249f, 0.00932391f, 0.03073112f, 
    -0.13318315f, 0.09938464f, -0.06263300f, -0.05286181f, 0.10975957f, 0.13006696f, -0.06453568f, 0.14201832f, 
    0.03781113f, -0.02683027f, 0.13733543f, 0.03200486f, -0.10581385f, 0.09712818f, 0.03617802f, -0.10347409f, 
    0.13558494f, 0.01407911f, -0.09261785f, 0.04208297f, -0.02774921f, -0.05899161f, 0.01360204f, -0.17241634f, 
    -0.04472695f, 0.05932233f, -0.09145840f, 0.09696673f, 0.12994170f, 0.08540574f, -0.01813805f, 0.01551538f, 
    0.09319574f, -0.01132919f, 0.00871546f, -0.11122391f, 0.02593780f, -0.12482124f, -0.02257845f, 0.03079068f, 
    -0.00403013f, 0.08888689f, 0.23568720f, -0.16958408f, 0.01504343f, -0.00875243f, 0.12036970f, 0.00104054f, 
    -0.07443164f, -0.04754151f, -0.06201732f, -0.08064556f, -0.07948368f, 0.24429195f, 0.01779965f, 0.09104288f, 
    -0.02194292f, -0.08922838f, 0.02349387f, 0.01151407f, 0.02344086f, 0.06797557f, -0.09433597f, 0.02708204f, 
    -0.45841423f, -0.06593676f, 0.00966092f, 0.09231906f, -0.28648406f, -0.08917784f, 0.11422290f, -0.03238549f, 
    -0.05370586f, -0.09099535f, 0.10045526f, -0.06152898f, 0.26333559f, -0.02837522f, -0.21682277f, 0.30046004f, 
    -0.03789741f, 0.10936261f, -0.07862236f, 0.00668019f, -0.02407568f, 0.10347404f, 0.04981505f, 0.06499508f, 
    0.25369126f, -0.17942767f, 0.11669803f, 0.16110680f, -0.10780968f, -0.01993620f, 0.03779715f, -0.03636484f, 
    -0.01154188f, 0.07196844f, 0.05584218f, 0.07569840f, 0.07502911f, -0.16710572f, -0.04395439f, 0.02654554f, 
    0.15792543f, -0.08129396f, -0.05856996f, -0.07503813f, -0.10656493f, 0.05552635f, 0.03872306f, -0.02956975f, 
    -0.25146601f, -0.02729547f, 0.06004351f, -0.14250445f, -0.05478530f, 0.08325917f, 0.02728427f, -0.02038972f, 
    0.00242919f, 0.07631718f, -0.06355213f, -0.03202135f, 0.03058752f, -0.21954899f, -0.03631461f, 0.27526179f, 
    0.17036025f, 0.01163959f, 0.06553398f, 0.21919280f, 0.03250389f, -0.03802851f, 0.03861302f, 0.17593284f, 
    -0.05426404f, -0.03565348f, -0.04250588f, 0.00644344f, 0.00489570f, 0.14174889f, 0.08061589f, 0.00513880f, 
    0.02532398f, 0.10601817f, 0.08608713f, 0.22015879f, -0.33594635f, -0.08883847f, 0.07173743f, -0.13243029f, 
    0.01414526f, 0.16991372f, -0.07196883f, 0.03926280f, -0.01707543f, -0.00451587f, -0.09510152f, 0.05180475f, 
    -0.06539293f, -0.15365106f, 0.16329017f, -0.22731708f, -0.18429650f, -0.09008669f, 0.02318451f, 0.06613401f, 
    -0.00192868f, 0.03976716f, 0.25371248f, 0.07334287f, -0.31451330f, -0.00634600f, 0.14728275f, 0.16222286f, 
    0.14130643f, -0.08535945f, 0.04396870f, 0.12022595f, 0.00170896f, -0.04013582f, -0.07092378f, 0.05265514f, 
    0.04663097f, 0.24943896f, 0.13744430f, -0.03252015f, 0.03055608f, -0.09111194f, -0.02272801f, -0.01006752f, 
    -0.01711697f, 0.07698204f, -0.02686067f, -0.07679538f, -0.04674630f, 0.20015164f, 0.07340422f, 0.04357243f, 
    0.08216331f, 0.06940693f, 0.04634907f, 0.09640001f, -0.06528019f, 0.00596481f, 0.09621505f, 0.05964838f, 
    0.14910720f, -0.16823915f, -0.02947078f, -0.00951317f, -0.12757930f, -0.05062578f, 0.07710958f, 0.02786452f, 
    0.02874208f, -0.03345796f, -0.01434284f, -0.18352576f, 0.22180124f, -0.10870407f, -0.14550306f, 0.00297528f, 
    -0.03050178f, 0.07972702f, -0.02594893f, 0.04378262f, 0.03315749f, -0.13939323f, -0.06061345f, -0.01906368f, 
    0.13734344f, 0.05187502f, 0.04067843f, -0.32025278f, -0.03788617f, 0.08452445f, 0.02261260f, 0.00476199f, 
    -0.07137617f, 0.03149533f, 0.00759600f, 0.09280027f, 0.25946712f, -0.00308816f, -0.01863462f, -0.09781864f, 
    0.14134149f, -0.04168456f, -0.07315835f, -0.10134617f, 0.04788458f, 0.02656082f, -0.03117214f, 0.06307781f, 
    -0.17376620f, 0.07222907f, 0.21602747f, -0.08467010f, 0.00058067f, 0.00794097f, -0.02296192f, -0.19344212f, 
    0.09863296f, -0.07001332f, 0.15033233f, -0.02661474f, 0.06532661f, -0.03265551f, -0.09753929f, -0.01502623f, 
    0.04168753f, 0.03180562f, -0.05031966f, 0.16354658f, 0.06201394f, 0.05074722f, 0.13061596f, -0.02276218f, 
    0.02904742f, 0.00270891f, 0.00201525f, 0.05285019f, 0.17272958f, 0.03044555f, 0.02068955f, -0.14758252f, 
    -0.00124042f, -0.06194104f, -0.06302220f, 0.00948003f, 0.08026163f, -0.01585841f, 0.08376788f, 0.02029653f, 
    0.29709008f, 0.10329267f, 0.16701956f, -0.02022018f, 0.08299234f, -0.07762939f, 0.13804857f, 0.12651941f, 
    0.15094841f, 0.35969836f, 0.09103856f, 0.17111087f, 0.18050714f, 0.04436886f, 0.12923287f, -0.03605138f, 
    -0.08863784f, 0.09623674f, -0.04603012f, -0.09592010f, 0.18249264f, -0.06585273f, -0.01422426f, -0.05120360f, 
    -0.01373067f, 0.18914060f, 0.01624971f, -0.08706082f, 0.16695419f, 0.15187392f, -0.07137788f, 0.08675555f, 
    0.21317241f, -0.03497064f, -0.00563541f, -0.03300539f, -0.06497457f, 0.04457237f, 0.04440521f, 0.05893669f, 
    -0.11926959f, -0.05359749f, -0.03339005f, -0.06402883f, 0.25688577f, 0.14228554f, 0.09277236f, 0.08138572f, 
    0.15271646f, 0.21891722f, 0.07339185f, -0.10117772f, 0.01313869f, -0.07257417f, -0.08422869f, 0.04057333f, 
    0.10927419f, 0.16442445f, 0.02083530f, 0.16704713f, -0.04970858f, -0.06405921f, 0.04154420f, -0.04129759f, 
    -0.00926815f, -0.05849732f, -0.15115520f, 0.00447624f, 0.03210129f, 0.05406563f, 0.04163373f, 0.20173019f, 
    0.11463542f, 0.13704617f, 0.14612058f, -0.00892106f, -0.07576642f, 0.07819346f, 0.08034317f, -0.05733961f, 
    -0.75089252f, -0.24242951f, -0.10329923f, -0.10891365f, -0.13603592f, -0.06808996f, -0.05280854f, 0.01582292f, 
    -0.11314440f, -0.05329692f, -0.01848867f, 0.04949846f, -0.44821513f, -0.20560019f, -0.00072048f, -0.21072975f, 
    -0.16968654f, 0.02285895f, -0.07692788f, -0.02953154f, 0.01571672f, -0.09298915f, 0.00186776f, -0.04280393f, 
    0.17234574f, 0.13188238f, 0.09100620f, -0.00409550f, -0.07371661f, -0.07164194f, -0.03883753f, 0.05173019f, 
    0.03054756f, 0.18147306f, 0.06992006f, 0.00973689f, 0.09529833f, -0.04148797f, 0.06822856f, -0.07624564f, 
    0.03250635f, -0.03148280f, 0.08004001f, 0.14981100f, 0.04470484f, 0.07329240f, -0.13456383f, 0.06007494f, 
    -0.27322355f, -0.01840029f, -0.12384243f, 0.15875910f, 0.05914742f, -0.05398596f, 0.04725285f, -0.06771631f, 
    -0.11712344f, 0.09071489f, -0.04328761f, -0.16400041f, -0.25613925f, 0.11864132f, -0.25590521f, -0.05716900f, 
    0.00012401f, -0.16574559f, 0.11550783f, 0.05490066f, 0.08226414f, -0.05418527f, -0.00947721f, -0.10659558f, 
    -0.39932641f, -0.12428662f, 0.29250032f, 0.16610704f, -0.05382405f, -0.03739145f, 0.04553876f, 0.02237196f, 
    -0.01945847f, 0.00056175f, -0.14970392f, -0.00620088f, 0.39058763f, -0.05352807f, 0.23774770f, 0.05217423f, 
    0.18122250f, 0.23206502f, 0.09786579f, 0.04553532f, -0.09976396f, -0.02750332f, -0.01795887f, -0.01310332f, 
    -0.01666585f, 0.13376039f, -0.01978928f, -0.16976851f, -0.12028352f, 0.03049849f, 0.09106296f, -0.07016616f, 
    0.06567629f, -0.12175240f, 0.00384981f, -0.00794680f, 0.25949475f, 0.19886172f, 0.10978325f, 0.13972020f, 
    -0.05794133f, -0.05542493f, 0.02715413f, 0.10555184f, 0.04126579f, 0.00069048f, 0.02796387f, 0.04159082f, 
    -0.25525859f, -0.14835370f, -0.03243581f, 0.06286637f, 0.04427769f, -0.00359519f, 0.09495249f, 0.15620086f, 
    -0.03240807f, 0.01617366f, 0.11875393f, -0.00518954f, 0.02378746f, 0.15877843f, -0.11514220f, 0.12617944f, 
    0.03854382f, -0.04120757f, 0.00421859f, 0.01859225f, 0.10444574f, 0.09247059f, -0.02162445f, -0.01533329f, 
    0.09804320f, 0.18938807f, -0.09385315f, 0.21273899f, -0.08564921f, -0.00814091f, -0.04595108f, 0.07608042f, 
    -0.03560660f, 0.06301368f, 0.00799305f, -0.07950958f, 0.19432853f, 0.17627147f, 0.19393262f, 0.19829111f, 
    0.01866876f, -0.00651331f, 0.21125381f, -0.04139204f, -0.00556844f, 0.15775600f, -0.05208744f, 0.02182866f, 
    0.12323634f, -0.14754732f, 0.04408120f, -0.00960364f, 0.08229008f, 0.00783236f, 0.06841019f, 0.09901719f, 
    0.17169748f, -0.05568228f, -0.12348920f, -0.02344266f, 0.14494321f, 0.17259961f, 0.29765078f, 0.16121125f, 
    -0.06309810f, -0.01977691f, 0.02926791f, 0.11620863f, 0.00467962f, 0.08481197f, 0.08144907f, -0.20751345f, 
    0.13831063f, -0.20645350f, -0.07626560f, 0.31959921f, 0.08819517f, 0.08687273f, 0.07724149f, -0.07596859f, 
    -0.01048823f, 0.02478671f, -0.06289773f, 0.04826315f, 0.24533921f, -0.09861307f, -0.22749186f, 0.29332131f, 
    -0.10009321f, -0.00737246f, 0.01203824f, 0.02169848f, 0.11134388f, -0.06924912f, -0.11806221f, 0.08441610f, 
    -0.20272858f, -0.02587507f, -0.15491213f, -0.10219770f, 0.10607035f, -0.10164674f, -0.08406460f, -0.10657204f, 
    0.00094373f, 0.01713337f, -0.06231606f, 0.01507691f, -0.10895667f, 0.05912752f, -0.07359175f, -0.01434528f, 
    0.03502283f, 0.05724850f, -0.06634471f, -0.10234077f, -0.05136593f, -0.06349417f, -0.05481237f, -0.00018553f, 
    -0.02245259f, 0.01082884f, 0.06114836f, -0.29988119f, 0.05378959f, 0.06688789f, -0.02527397f, -0.00913011f, 
    0.06695733f, 0.23933801f, -0.01444707f, -0.16476549f, 0.02052693f, 0.17734112f, -0.02961105f, -0.09894114f, 
    0.00376425f, 0.14025633f, -0.08352689f, 0.09695478f, 0.02717394f, 0.05450909f, -0.03821710f, 0.16640273f, 
    0.15690708f, -0.21375720f, 0.06603885f, -0.22468925f, -0.00640839f, -0.13223362f, 0.03220920f, -0.05963296f, 
    0.04636753f, 0.05016010f, 0.13561246f, 0.15169151f, -0.14288819f, 0.25777024f, -0.09375408f, 0.01668237f, 
    -0.10334338f, -0.03907081f, -0.06241011f, 0.12597391f, -0.01825513f, -0.04796997f, -0.02186054f, 0.00938525f, 
    0.03537176f, -0.01643107f, -0.10566907f, 0.31016058f, 0.01450644f, 0.07016876f, -0.12857334f, 0.01657011f, 
    0.04032652f, 0.02289488f, 0.14375873f, -0.04715287f, -0.16967905f, -0.18810894f, -0.06281050f, 0.06249509f, 
    0.08749200f, -0.03408066f, 0.08643688f, -0.04114969f, 0.06468826f, -0.13022037f, 0.05167738f, 0.15938167f, 
    -0.09845709f, 0.06276878f, -0.02751114f, -0.03696722f, 0.03585554f, 0.08245108f, 0.07694714f, 0.08882655f, 
    0.11873641f, 0.07286786f, 0.05939597f, -0.04451754f, 0.19531406f, -0.26349151f, 0.03462241f, -0.19087033f, 
    0.04992408f, 0.07508343f, 0.12308073f, -0.10621692f, 0.01219312f, -0.03841029f, 0.05865677f, 0.07233375f, 
    0.19872585f, -0.20240392f, -0.07002680f, -0.01884872f, -0.06056124f, -0.14369644f, -0.01299624f, -0.04943451f, 
    -0.03923900f, 0.03504447f, 0.01326588f, -0.00029035f, 0.04356055f, 0.19993104f, -0.13975054f, -0.05006324f, 
    0.10797792f, -0.00896584f, 0.04492660f, -0.05771644f, 0.10897063f, 0.20993617f, 0.01339288f, 0.04494785f, 
    -0.12953131f, 0.13696982f, -0.03914698f, 0.12625243f, 0.04852167f, 0.12345993f, -0.00451601f, 0.04691952f, 
    -0.06474005f, 0.05838814f, -0.17483199f, 0.16669406f, -0.03650384f, -0.18769966f, 0.04973722f, -0.07352546f, 
    -0.05364850f, 0.14772046f, -0.03807208f, -0.04850673f, 0.03731043f, 0.02347384f, 0.09596937f, 0.01504130f, 
    -0.31459132f, 0.07349906f, 0.22583093f, -0.03985663f, -0.01153126f, 0.01742145f, 0.02119123f, 0.04955183f, 
    0.08530564f, -0.01595636f, 0.12026325f, 0.01595600f, -0.12874427f, 0.03274768f, 0.27752087f, -0.16359723f, 
    0.08188219f, 0.08877525f, -0.16566144f, -0.03538045f, -0.01789761f, -0.10593425f, 0.12433447f, -0.05171116f, 
    0.11915243f, -0.04524086f, 0.04183567f, -0.11449102f, 0.06781006f, 0.07179020f, -0.03915300f, 0.10503139f, 
    0.14500205f, 0.10517284f, 0.08688803f, 0.10567113f, 0.14109594f, -0.09477536f, -0.01851529f, 0.10123949f, 
    -0.00900622f, 0.04680243f, 0.02870597f, 0.05396453f, 0.09092984f, 0.15077946f, 0.02544425f, 0.15033519f, 
    -0.12916586f, 0.00855945f, -0.19480111f, 0.20041150f, 0.01816957f, -0.11163861f, -0.06724989f, 0.05972403f, 
    0.06458714f, -0.08253067f, 0.19040240f, 0.16149607f, -0.05111678f, -0.08467391f, -0.09864363f, -0.03705553f, 
    0.11809441f, -0.07087668f, 0.00314152f, -0.01906512f, 0.07908814f, 0.08314507f, 0.12210710f, 0.04534670f, 
    -0.12500045f, 0.08238027f, 0.23556310f, 0.08760155f, 0.24851806f, 0.05895445f, 0.06213396f, 0.00634691f, 
    0.00129490f, 0.01716201f, -0.04132606f, 0.08255275f, -0.03730990f, -0.23597589f, 0.07336655f, -0.15762174f, 
    0.17208095f, 0.01922285f, 0.13192235f, 0.16937688f, -0.07219776f, -0.03769038f, 0.02065575f, 0.11557469f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03281422f, -0.00837619f, 0.05770838f, -0.13404550f, 0.08689465f, 0.04724345f, 0.03224484f, -0.04700510f, 
    0.17547500f, 0.12953801f, 0.12471486f, -0.04678083f, -0.04955559f, -0.04402032f, -0.04162582f, 0.05036944f, 
    -0.06318624f, 0.03930449f, 0.02337820f, -0.02659244f, 0.01086106f, 0.00668694f, 0.01652234f, -0.02954136f, 
    0.05341033f, 0.04569034f, 0.09297021f, -0.04936400f, -0.09576627f, -0.05370756f, 0.02898584f, 0.01100990f, 
    0.01234934f, 0.01002531f, -0.05548929f, -0.08613899f, -0.07558283f, 0.01012226f, -0.02845557f, -0.03709002f, 
    0.05464632f, 0.07150736f, 0.01578011f, 0.00914327f, 0.03974059f, 0.04817052f, 0.04326301f, 0.04870299f, 
    0.05189821f, 0.10373744f, -0.06792551f, 0.05003389f, 0.04065470f, -0.06870080f, -0.04979401f, -0.02977172f, 
    0.02534512f, 0.03952312f, -0.03067648f, 0.01320172f, 0.05501580f, -0.01873785f, 0.06809026f, 0.17673258f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.00615387f, 0.06302489f, 0.17633910f, 0.22807123f, -0.19635585f, 0.09985412f, -0.24539931f, -0.01736551f, 
    0.00140241f, -0.19690821f, 0.13663003f, -0.03633852f, -0.06843261f, -0.20476793f, 0.03931472f, 0.11243325f, 
    0.65293002f, 0.26415002f, 0.02745797f, -0.02433170f, 0.29648450f, 0.29924095f, -0.00405708f, -0.15043369f, 
    0.12231486f, -0.03706789f, -0.10161509f, 0.14892893f, -0.04242114f, -0.10884664f, 0.03005183f, 0.05657539f, 
    0.07389550f, -0.11477133f, -0.22228594f, 0.12247001f, -0.07696512f, 0.06296459f, 0.07590058f, 0.17916854f, 
    -0.03772425f, 0.10928641f, -0.27005944f, -0.04035118f, -0.16222934f, 0.04160855f, 0.03803665f, 0.05050712f, 
    -0.13041596f, 0.04268561f, 0.35030112f, 0.21224235f, 0.05321730f, 0.08878762f, -0.14078446f, 0.12902477f, 
    0.07942434f, 0.11985594f, 0.09881011f, 0.03707556f, 0.16280994f, -0.28277028f, -0.12991212f, 0.05580524f, 
    -0.15204686f, -0.01144276f, -0.13426317f, -0.00940143f, 0.06047678f, -0.01339604f, -0.05800303f, -0.14927050f, 
    0.02384186f, 0.02305393f, -0.10743745f, 0.01176307f, -0.03465921f, -0.02449664f, -0.00474812f, -0.04135194f, 
    -0.05341183f, -0.11531096f, 0.03740871f, -0.02689203f, 0.01640400f, 0.05366715f, 0.04532244f, -0.02226893f, 
    -0.10296748f, -0.01107305f, 0.03862857f, 0.00822369f, 0.08651948f, -0.04733548f, 0.03268167f, 0.01789532f, 
    0.01106461f, -0.05320983f, 0.07332695f, -0.07760842f, -0.07571799f, -0.07711265f, -0.00414006f, -0.12295228f, 
    0.05486440f, 0.02218476f, 0.05182463f, 0.05800707f, -0.15259159f, -0.08955069f, -0.11666548f, 0.00003557f, 
    0.00231900f, 0.02018760f, -0.06962012f, -0.00484034f, -0.08136821f, 0.09429125f, 0.08393779f, -0.12294228f, 
    -0.11294191f, 0.06179639f, -0.11976206f, -0.07344502f, 0.05254566f, 0.09438640f, -0.09373400f, 0.03166780f, 
    0.01051124f, 0.09000247f, 0.08250427f, 0.26405406f, 0.00025149f, 0.01600846f, -0.03906084f, -0.02563531f, 
    -0.03095564f, 0.37892747f, 0.10633156f, 0.06307440f, -0.11357234f, 0.17874524f, -0.06212249f, 0.05671184f, 
    -0.34880006f, -0.24310872f, 0.04749221f, 0.07003397f, -0.10056996f, -0.04813442f, -0.28796160f, 0.22723748f, 
    -0.12163413f, 0.03648456f, 0.35061577f, 0.02798359f, 0.12152708f, -0.02377914f, 0.18974723f, 0.03844975f, 
    -0.03387824f, 0.29091942f, -0.20634371f, 0.32428330f, -0.06389887f, 0.00690690f, 0.08473180f, -0.38009858f, 
    -0.18894592f, -0.31987026f, 0.26327026f, -0.35719720f, 0.17027038f, -0.12208102f, 0.14722472f, 0.00615044f, 
    -0.26558903f, 0.09957793f, -0.11778945f, -0.15673986f, 0.01589086f, -0.05295652f, 0.17835708f, -0.07428726f, 
    0.17499581f, -0.07413717f, 0.08925945f, 0.12545101f, 0.36981875f, 0.16017181f, 0.01573647f, 0.20187578f, 
    0.17469795f, 0.02831408f, -0.37527636f, -0.10062040f, 0.18137482f, 0.06495418f, 0.10287010f, 0.09150237f, 
    -0.01063324f, 0.16344972f, 0.08325294f, -0.04097833f, 0.08494934f, 0.02984958f, -0.01362766f, -0.05166491f, 
    -0.04345627f, 0.04207568f, -0.10937531f, 0.06065731f, 0.04535470f, 0.19325383f, 0.09703473f, 0.10761984f, 
    -0.08860940f, 0.09325864f, -0.05344550f, -0.00393626f, -0.32771674f, -0.04538174f, -0.25073928f, 0.13785069f, 
    0.07103466f, -0.09236498f, -0.17697825f, -0.00017334f, -0.05431750f, 0.05856356f, -0.18105789f, 0.29043978f, 
    0.07020539f, -0.11231419f, 0.08390961f, -0.15120366f, 0.12900104f, 0.07874806f, -0.00295978f, -0.14082262f, 
    0.21556100f, 0.21106540f, 0.33123949f, -0.07398251f, -0.04497536f, -0.01401669f, 0.10095685f, -0.11023863f, 
    0.18303822f, 0.30323327f, -0.10998194f, -0.06983866f, -0.06393212f, 0.23869328f, 0.04745689f, 0.03091976f, 
    0.08594373f, -0.06967425f, -0.11352725f, 0.08188456f, 0.15854822f, 0.16853666f, 0.19788815f, 0.11073218f, 
    -0.07964510f, 0.28867540f, -0.12976208f, 0.05523120f, -0.09886685f, -0.38880944f, -0.00912140f, 0.09814420f, 
    -0.42253882f, -0.11362649f, -0.11262889f, -0.03034552f, -0.17853229f, -0.01799664f, 0.11577163f, 0.37436330f, 
    0.01359489f, 0.10299065f, 0.25222459f, -0.01577935f, -0.15537561f, -0.10555070f, -0.07814896f, -0.03439441f, 
    0.08061191f, 0.07129724f, -0.06838799f, -0.43822274f, 0.05189254f, 0.01812624f, -0.04688019f, -0.12809990f, 
    -0.15087967f, -0.10854884f, 0.20835504f, -0.35706365f, 0.17423904f, 0.10679875f, -0.15241158f, 0.05426028f, 
    -0.39021546f, -0.00990007f, -0.03602909f, -0.08149105f, 0.06281982f, 0.12090363f, 0.03643342f, -0.12817858f, 
    0.17639379f, 0.01626474f, -0.22777724f, -0.02385655f, -0.06908930f, 0.28374836f, 0.26094922f, 0.15423310f, 
    0.08195043f, -0.00747216f, -0.03756023f, 0.25140920f, 0.21085894f, 0.15120551f, -0.02990384f, 0.01259515f, 
    0.24182707f, 0.07261962f, -0.01379151f, -0.01462719f, 0.01723714f, -0.21171838f, -0.02961611f, -0.02553020f, 
    0.36052269f, 0.30717465f, -0.08300510f, -0.08936049f, -0.10885479f, 0.55570155f, 0.29486713f, -0.14292963f, 
    -0.11046383f, -0.11920545f, 0.09785462f, 0.00831181f, 0.24466799f, 0.10515997f, -0.08165013f, 0.04705493f, 
    0.16668843f, -0.28078899f, 0.02076243f, -0.14371748f, 0.01571919f, -0.04079989f, 0.16392422f, -0.05289198f, 
    0.15355758f, 0.16130885f, -0.24162132f, 0.16113961f, -0.15449238f, -0.11298092f, 0.18823551f, 0.06796519f, 
    -0.12688607f, 0.07724246f, -0.05107277f, 0.24631858f, -0.02448982f, 0.12497097f, -0.07687306f, -0.03206962f, 
    -0.10776914f, -0.09715465f, 0.18249987f, 0.29880834f, -0.09972008f, 0.12756792f, -0.10781972f, -0.03404881f, 
    0.24083415f, 0.01726044f, -0.10119940f, 0.18237844f, -0.15170874f, -0.26572582f, -0.21201174f, 0.02380851f, 
    0.36294612f, 0.11064243f, 0.34957418f, 0.05583501f, 0.06692315f, 0.09357669f, -0.11932448f, 0.04232923f, 
    0.11722270f, 0.15640520f, 0.08249302f, 0.04130171f, -0.03807297f, -0.04780832f, -0.22070530f, -0.17220460f, 
    0.09181586f, 0.08561476f, 0.24771038f, 0.12293751f, -0.09820721f, -0.07945355f, 0.07695968f, -0.01875211f, 
    0.23009273f, -0.11676679f, 0.01428027f, 0.05505203f, -0.09336486f, -0.02347719f, 0.15440488f, 0.14148897f, 
    -0.11671961f, 0.23820244f, -0.32628372f, -0.22472487f, -0.37701836f, 0.00498973f, 0.10545903f, 0.03036083f, 
    0.16304232f, 0.17554779f, -0.23078501f, 0.11724591f, 0.11096840f, 0.03077621f, -0.07858492f, -0.00686446f, 
    0.17331980f, 0.13219967f, -0.08010331f, -0.28264380f, -0.03115251f, 0.17274873f, -0.09880349f, 0.20507155f, 
    -0.00135947f, 0.05662294f, -0.21296073f, -0.08367443f, -0.04159898f, -0.06540256f, 0.13155057f, 0.25247347f, 
    0.41481331f, 0.15530182f, 0.28198311f, 0.10975616f, 0.05340807f, -0.04416106f, 0.10979708f, 0.12451710f, 
    0.16180064f, 0.19801027f, -0.03912088f, 0.11516791f, 0.26921165f, -0.08402949f, -0.13436337f, -0.24276856f, 
    0.20135270f, -0.02289416f, -0.00837338f, 0.11499968f, -0.18957011f, 0.00930641f, -0.11240946f, 0.07320178f, 
    0.30107385f, -0.07191190f, 0.02309477f, -0.24230705f, -0.08467994f, -0.01567307f, -0.13361718f, -0.09662293f, 
    0.14049689f, 0.27434936f, 0.12168771f, 0.09392431f, -0.32280996f, -0.00005991f, -0.00179269f, -0.35480940f, 
    -0.09871569f, 0.04429614f, -0.18542692f, 0.01170141f, 0.03577670f, -0.03725830f, -0.19641769f, 0.03480940f, 
    0.02646235f, 0.19690353f, -0.15191342f, -0.22126077f, -0.39016268f, 0.03435545f, 0.11138906f, -0.00951619f, 
    0.13263649f, -0.11023797f, 0.13503955f, -0.21594316f, -0.14890295f, -0.14161113f, 0.02242979f, -0.09184319f, 
    0.30498874f, 0.13868487f, 0.23581341f, 0.03393483f, -0.09606063f, 0.06417824f, 0.09040080f, -0.05384251f, 
    0.02487369f, 0.13549867f, -0.11547288f, 0.05748942f, 0.27504537f, -0.09414369f, 0.09034167f, -0.36765042f, 
    0.15718922f, -0.11765457f, -0.12442629f, 0.02641451f, -0.05620637f, -0.12647115f, 0.14366359f, -0.04085793f, 
    -0.19667290f, 0.08549238f, -0.14960207f, 0.16964123f, -0.06539374f, 0.02992910f, 0.15473123f, -0.21598773f, 
    0.29958588f, 0.26958486f, 0.13488190f, -0.08697351f, -0.14909984f, 0.04438322f, 0.04897572f, 0.06285292f, 
    0.06474182f, 0.20562568f, -0.04780912f, 0.17977427f, 0.11471798f, -0.02212014f, -0.18104252f, 0.02757128f, 
    -0.23856893f, 0.16169520f, 0.05907059f, 0.07056288f, 0.13513239f, -0.09751052f, -0.09545552f, 0.05086485f, 
    0.02441333f, 0.09933095f, -0.02118999f, -0.18559095f, 0.10350646f, -0.06257790f, 0.24448425f, 0.04897463f, 
    0.19353911f, 0.25495958f, -0.05606958f, 0.09598690f, 0.03307046f, 0.34870327f, -0.09595583f, 0.10695733f, 
    -0.44657901f, -0.18905105f, 0.06548171f, 0.06483854f, 0.04087869f, -0.22182882f, -0.19170976f, 0.21963528f, 
    0.19030626f, -0.02427240f, 0.07820568f, -0.08836289f, 0.02354072f, 0.02314967f, 0.00108441f, -0.05663208f, 
    -0.01153515f, 0.27808785f, -0.08791292f, 0.25480443f, -0.12083948f, 0.06505026f, -0.03752124f, -0.02999819f, 
    -0.13343130f, -0.25292397f, 0.57407206f, 0.06568129f, 0.10328830f, -0.03491104f, 0.15440543f, -0.09974444f, 
    0.16234376f, 0.04908839f, -0.15118536f, 0.05221806f, -0.05982715f, 0.09029979f, 0.25003225f, 0.10644291f, 
    0.02261348f, 0.01941062f, -0.16849014f, -0.13755652f, -0.01691194f, -0.01286918f, 0.13725899f, -0.01137674f, 
    0.10744257f, 0.06703287f, -0.17863151f, -0.05056182f, -0.20336731f, -0.19767547f, 0.09282029f, 0.29155347f, 
    0.30983773f, -0.41774580f, 0.07945764f, -0.11992960f, -0.01923423f, 0.16545548f, 0.04800153f, -0.09230906f, 
    -0.07169894f, 0.07096386f, 0.10525768f, 0.04952235f, 0.30501881f, -0.14189564f, -0.16020386f, -0.10623532f, 
    0.03269056f, 0.07121098f, 0.05371020f, 0.28418812f, -0.27616104f, 0.10634527f, -0.12463713f, -0.00971567f, 
    0.05738610f, 0.16443565f, 0.16012435f, 0.07088140f, -0.10475611f, 0.11965996f, -0.08887049f, 0.31568974f, 
    0.26651037f, 0.17299452f, -0.13018808f, -0.00026360f, 0.07226375f, 0.11675365f, -0.16191304f, -0.21707064f, 
    0.10437706f, 0.14412911f, -0.08460447f, 0.24687311f, 0.07549562f, -0.04246453f, -0.18685211f, 0.06493798f, 
    0.00180317f, 0.25493601f, -0.03565506f, -0.26304838f, -0.18687822f, -0.03510688f, 0.14583322f, -0.16242865f, 
    -0.00614515f, 0.12159142f, -0.06165569f, 0.06143845f, -0.00927611f, 0.01249610f, -0.07260873f, -0.14263348f, 
    -0.13287187f, -0.03794061f, 0.01452915f, 0.01771043f, -0.10299167f, -0.01735361f, -0.01034983f, -0.09488045f, 
    -0.09705067f, -0.12146673f, 0.10465202f, -0.03817262f, -0.07272411f, 0.02687919f, -0.08643855f, 0.04048963f, 
    -0.06304382f, 0.03379717f, 0.03767085f, 0.08766977f, -0.10739918f, 0.05223139f, -0.12325188f, -0.12184981f, 
    0.11160244f, -0.02265278f, 0.02417788f, -0.05784517f, 0.00647144f, 0.02894570f, -0.10964501f, -0.07768214f, 
    -0.14318110f, 0.03539587f, -0.02922570f, 0.08610928f, 0.03455350f, -0.02990635f, 0.08098651f, -0.05034462f, 
    0.00710945f, -0.07644157f, -0.06148023f, 0.05272637f, -0.04353052f, -0.09951510f, -0.10702033f, -0.10302326f, 
    -0.06740760f, -0.19831833f, -0.07001819f, -0.04964623f, 0.05234841f, -0.03180666f, 0.02394008f, 0.07050618f, 
    0.00719322f, 0.00836611f, -0.03618404f, 0.09533735f, -0.07323229f, -0.11358525f, -0.07777676f, 0.09503838f, 
    -0.06121298f, -0.04105998f, -0.09986790f, 0.09450770f, 0.01205713f, 0.05232137f, -0.07444863f, 0.08586635f, 
    0.08630573f, -0.00626770f, 0.07493213f, 0.08577141f, 0.09497607f, -0.03931514f, -0.11399961f, 0.00669067f, 
    -0.10255250f, -0.10946860f, -0.01976061f, -0.05882818f, -0.00592536f, -0.08491718f, 0.05170454f, 0.10075437f, 
    0.05438383f, -0.13610508f, -0.05677205f, 0.08663223f, 0.08319972f, 0.03565894f, 0.06097415f, -0.14423473f, 
    0.02653988f, -0.13225794f, -0.12512411f, -0.03588634f, 0.08146639f, 0.06197578f, -0.06997459f, -0.00793501f, 
    -0.11260266f, -0.12326051f, 0.03978386f, -0.06010420f, -0.01823189f, -0.10588478f, 0.00223645f, -0.03445850f, 
    0.09739019f, 0.00337686f, -0.04206863f, -0.09761485f, 0.00150347f, -0.12482122f, 0.05733465f, 0.06807098f, 
    -0.09250131f, -0.04175238f, -0.02020745f, 0.03045224f, -0.00231993f, 0.10397433f, -0.03233716f, -0.07653591f, 
    -0.04861698f, -0.09023117f, 0.04100517f, 0.05941892f, -0.06833909f, -0.09148785f, -0.00007084f, 0.06409371f, 
    -0.02391179f, -0.15228000f, 0.05351411f, 0.03202680f, -0.07287940f, 0.05097815f, -0.08968321f, 0.03565305f, 
    -0.13631360f, 0.08416846f, 0.06190801f, -0.12519990f, -0.09418323f, 0.10675125f, 0.00070768f, 0.00067964f, 
    0.02910031f, 0.04421367f, -0.13240162f, -0.06756914f, 0.07796946f, -0.10999662f, -0.13869454f, -0.10969524f, 
    -0.02062807f, -0.20113152f, -0.07118765f, -0.03690404f, 0.08993447f, -0.03699500f, -0.13386495f, -0.15460402f, 
    -0.01378873f, -0.10258306f, -0.05866892f, -0.05165542f, 0.03948557f, -0.05144125f, -0.03694974f, -0.04898921f, 
    0.08350845f, -0.10039205f, -0.12702359f, -0.05664273f, 0.09564956f, -0.02324870f, -0.05887369f, -0.11816271f, 
    -0.09270097f, 0.11402321f, 0.07999052f, -0.11504884f, -0.03687840f, -0.00357152f, -0.07116662f, -0.02663926f, 
    -0.10964720f, 0.05067564f, -0.04712868f, 0.01092646f, 0.11293714f, -0.09711538f, -0.02570331f, -0.07731596f, 
    -0.12106838f, -0.13077764f, 0.11672693f, 0.07774767f, -0.02070495f, 0.01659498f, -0.01214563f, 0.09865303f, 
    -0.04217520f, 0.10956730f, -0.02127871f, 0.06264713f, 0.10294802f, -0.00469477f, -0.13222653f, -0.10695161f, 
    0.04854320f, -0.07655686f, -0.04402566f, -0.05864228f, 0.05770649f, 0.03289522f, 0.02298483f, 0.10728554f, 
    0.10836035f, 0.11286882f, -0.07813495f, -0.09801282f, -0.01770756f, 0.01097996f, 0.07563548f, -0.13278458f, 
    0.09031306f, 0.08760889f, 0.07874423f, 0.02907381f, -0.09665616f, 0.11959792f, -0.10837881f, -0.12070301f, 
    -0.08942991f, -0.12941438f, 0.07948018f, 0.00699757f, -0.09011929f, -0.03006588f, -0.05404973f, -0.00981833f, 
    0.08909196f, 0.05191979f, 0.10304557f, -0.01790464f, 0.17498943f, -0.01491175f, -0.06580894f, 0.19374001f, 
    0.21374038f, -0.13346833f, 0.18812217f, 0.06091464f, 0.03550539f, 0.29806548f, -0.08720333f, 0.13003162f, 
    0.31456831f, -0.02101031f, -0.05720715f, 0.03883484f, 0.26811931f, 0.12676084f, -0.24937302f, -0.22712632f, 
    0.15506512f, 0.04332054f, -0.02836653f, 0.14161246f, 0.11584557f, -0.01613527f, 0.09920980f, -0.08124518f, 
    0.12020506f, 0.07559900f, 0.00889695f, 0.16184188f, -0.09545790f, -0.08951077f, -0.07683682f, -0.18206221f, 
    0.10574945f, 0.22225651f, 0.14682932f, 0.41200295f, -0.20473479f, -0.00688758f, 0.12427820f, -0.23808156f, 
    0.01064594f, 0.11886207f, 0.04212341f, 0.18204404f, 0.00871838f, -0.09329730f, -0.04920160f, -0.01299154f, 
    -0.23273608f, 0.04446432f, 0.02652635f, 0.14316833f, -0.04297269f, -0.20518094f, 0.00801652f, -0.16358863f, 
    -0.05260485f, -0.07901877f, -0.08272190f, -0.06386205f, -0.17162821f, 0.08860082f, 0.08909450f, -0.18841468f, 
    -0.15642239f, -0.16668548f, 0.03741658f, 0.02500443f, 0.08131550f, -0.12409872f, -0.03903259f, -0.05205446f, 
    0.08923162f, 0.06104700f, -0.10686532f, -0.01301179f, 0.03520559f, 0.04081724f, 0.05389946f, -0.16627803f, 
    -0.03759952f, 0.09340376f, -0.05501194f, -0.06524717f, 0.08347176f, 0.03078379f, -0.00941197f, 0.05333187f, 
    -0.03124539f, -0.11651688f, 0.09220409f, -0.06942353f, 0.04724604f, 0.09342501f, -0.07427479f, -0.03213390f, 
    0.07946108f, 0.04184777f, 0.02659984f, -0.06044041f, -0.15427917f, -0.12432533f, 0.01668796f, 0.04871721f, 
    -0.06183845f, -0.13564551f, -0.04190794f, -0.11325839f, -0.05022397f, -0.12896733f, 0.03097309f, -0.00608242f, 
    -0.00785357f, -0.07091831f, -0.02860875f, -0.11142958f, 0.00168866f, 0.12077449f, -0.13787532f, -0.04560072f, 
    0.11588221f, 0.06899948f, -0.07504575f, 0.09587578f, 0.01813944f, 0.09863161f, 0.09126644f, 0.18088105f, 
    0.22365138f, -0.12187635f, -0.17777295f, -0.00054016f, 0.05790599f, 0.39690802f, 0.05484743f, 0.03609088f, 
    -0.13789624f, -0.09808496f, -0.03407498f, 0.08076377f, -0.26282147f, -0.20004179f, -0.00383121f, 0.19298942f, 
    0.04781594f, 0.07269216f, 0.14947681f, -0.06976457f, 0.26376277f, -0.06661357f, -0.21001747f, 0.10379420f, 
    0.15976571f, 0.15227115f, 0.22911923f, 0.26575312f, -0.05014326f, -0.10404358f, -0.20113726f, 0.20051387f, 
    -0.02916856f, 0.03629550f, 0.29780027f, 0.40295565f, 0.05469982f, 0.08608762f, -0.08344156f, -0.02017312f, 
    0.03744193f, -0.27300733f, -0.28315589f, 0.13184044f, 0.04481254f, 0.11570968f, 0.13335909f, 0.10019910f, 
    -0.10922631f, -0.06516860f, 0.01219498f, -0.08078112f, -0.05656008f, -0.12404013f, 0.14126734f, 0.07423179f, 
    0.09291433f, 0.00303995f, -0.09651610f, -0.03360775f, 0.03539442f, 0.00693974f, -0.06735275f, 0.11808724f, 
    -0.10072266f, 0.18287136f, 0.02256066f, 0.11160304f, -0.00420228f, 0.26451987f, 0.07071729f, 0.02928440f, 
    -0.08668812f, -0.12399606f, -0.05358119f, -0.09625901f, 0.06598205f, 0.12452272f, -0.12336287f, 0.26996937f, 
    -0.15733102f, -0.01678527f, 0.15584318f, 0.26753137f, -0.22740601f, -0.09738091f, -0.09603709f, 0.08360004f, 
    0.10204443f, 0.18656297f, -0.16142875f, 0.40071648f, 0.00362708f, 0.10288674f, -0.21721126f, 0.11203816f, 
    -0.11141092f, -0.31403962f, 0.27898517f, -0.39729109f, 0.29263258f, -0.04539705f, -0.08598709f, -0.26516283f, 
    0.31916985f, 0.21433450f, 0.27937084f, -0.09358262f, 0.02379425f, 0.04939451f, -0.02082274f, 0.04967738f, 
    -0.07991111f, 0.18684109f, -0.13502872f, 0.07831711f, 0.20821814f, 0.38280675f, 0.05489418f, 0.14218682f, 
    -0.01127889f, -0.01458279f, 0.05215724f, -0.04368245f, -0.07091691f, 0.20484078f, -0.09673987f, 0.21964535f, 
    0.18762927f, 0.02817748f, 0.12484269f, -0.06938595f, -0.08255556f, 0.02164007f, -0.06172337f, -0.02503339f, 
    0.43674421f, -0.18974459f, -0.08487540f, 0.10810331f, 0.26936793f, 0.23418921f, -0.22508800f, 0.01643078f, 
    0.08281291f, 0.07282667f, 0.07019714f, 0.15182893f, 0.04605948f, -0.00185148f, 0.26457763f, -0.01552205f, 
    -0.07454156f, -0.00678825f, -0.19166692f, 0.30524504f, -0.12707739f, 0.04703644f, -0.15828273f, -0.13681538f, 
    -0.29916611f, -0.10867830f, 0.12752135f, 0.17492774f, -0.02058030f, -0.12836540f, -0.00018184f, -0.33776671f, 
    0.05856510f, -0.09806631f, 0.25008249f, -0.06482214f, -0.08139344f, -0.08544438f, 0.07121444f, 0.03083244f, 
    0.14022340f, -0.05930282f, 0.03143749f, -0.12146722f, 0.15116671f, -0.50751102f, 0.04830674f, 0.04366214f, 
    0.09693094f, 0.02835033f, -0.01293125f, 0.20046479f, -0.14025901f, -0.15965201f, 0.00524669f, 0.19535206f, 
    0.03986235f, -0.03078444f, 0.12190270f, -0.04003989f, 0.08165815f, -0.04665069f, -0.03737197f, 0.11334745f, 
    0.07049603f, 0.15395141f, -0.07936457f, 0.06259527f, -0.21272901f, 0.02890589f, -0.22807309f, -0.02742966f, 
    -0.01386203f, 0.05960485f, 0.30393574f, 0.29693958f, 0.09725852f, -0.07366269f, 0.10723612f, -0.01918248f, 
    0.12710978f, -0.00459431f, 0.23162168f, 0.35496020f, -0.05472393f, 0.06203051f, -0.01460984f, 0.16542281f, 
    -0.21845722f, 0.05261698f, -0.25422910f, -0.23939246f, -0.12629189f, -0.02336954f, -0.06707042f, -0.08591728f, 
    -0.03978322f, -0.13710296f, -0.27006796f, 0.12311441f, 0.06315789f, -0.01198319f, 0.14869310f, -0.12737882f, 
    0.10796514f, 0.15582058f, 0.08763006f, -0.23184434f, -0.25294372f, 0.22738262f, -0.19861147f, 0.19228339f, 
    0.14408056f, 0.09727307f, 0.15206555f, -0.17362852f, -0.16297042f, -0.05725221f, -0.00104582f, -0.14611803f, 
    -0.04792447f, 0.23976141f, 0.42123330f, 0.08767261f, -0.07197902f, 0.09205186f, 0.05758488f, -0.02367485f, 
    0.17424494f, 0.06736558f, -0.00000548f, -0.01606937f, 0.23726150f, -0.03057917f, -0.19870485f, -0.20096174f, 
    0.02883253f, -0.01163548f, 0.12642932f, 0.35431626f, -0.25634792f, -0.05162773f, 0.01744138f, -0.03454845f, 
    -0.00129172f, 0.17322931f, -0.15299419f, 0.40640083f, 0.06208324f, 0.07826316f, 0.25653419f, 0.02083043f, 
    0.08777715f, -0.07286147f, 0.04583461f, -0.27177846f, 0.21270150f, -0.00487092f, 0.20749222f, -0.16736421f, 
    0.25458920f, 0.36988497f, 0.19812411f, -0.17474245f, 0.07242433f, 0.10954864f, -0.05538401f, 0.04080230f, 
    0.11021507f, 0.14073786f, -0.01048408f, 0.07058474f, 0.09338538f, 0.11507778f, -0.10675018f, 0.04474243f, 
    0.03696241f, -0.06057407f, 0.20733500f, -0.21850413f, 0.21848011f, 0.47581717f, 0.13803750f, 0.00333335f, 
    0.31614360f, 0.28088596f, -0.05571321f, -0.02173016f, -0.04772031f, -0.20730332f, -0.10288031f, 0.04545267f, 
    -0.08691716f, 0.13755286f, -0.08184473f, 0.03052194f, 0.35923004f, -0.06683196f, 0.17010595f, 0.03276616f, 
    0.17033087f, 0.02091721f, 0.10715462f, -0.21667001f, 0.23408324f, 0.01720477f, 0.25571230f, 0.08371709f, 
    0.05473660f, -0.02557558f, 0.10692670f, -0.20509690f, -0.08581340f, 0.07462310f, 0.06113303f, -0.05717424f, 
    0.15469906f, -0.08537854f, 0.29787365f, 0.45097220f, -0.17986271f, 0.05977034f, 0.00337347f, 0.00888214f, 
    -0.20981869f, 0.13496636f, -0.28651574f, 0.09352733f, -0.04836372f, 0.04342937f, 0.19460264f, 0.11121302f, 
    0.04002295f, -0.14454955f, 0.18745992f, 0.00361385f, -0.05253700f, -0.15005815f, 0.08129972f, 0.16488002f, 
    0.10876446f, 0.07206039f, -0.00231089f, -0.21685055f, -0.02692771f, -0.01552367f, 0.01577117f, -0.23557426f, 
    -0.06366637f, 0.09719636f, -0.00381193f, 0.04356414f, -0.05894165f, -0.06357300f, -0.02813967f, 0.00985445f, 
    -0.37345061f, 0.03568014f, 0.05548599f, 0.03676836f, -0.10095417f, 0.12358158f, 0.42652553f, -0.05544435f, 
    0.08301914f, -0.05265723f, 0.15016693f, -0.00174988f, 0.11031526f, -0.10482047f, -0.11228927f, -0.07525332f, 
    -0.20958374f, -0.01732380f, 0.11842921f, 0.01932343f, -0.04373665f, 0.06928626f, 0.18267192f, 0.18788873f, 
    0.02683519f, -0.27826267f, 0.11407100f, -0.31367958f, 0.00571605f, -0.11791472f, 0.12010904f, 0.34469578f, 
    0.10916686f, 0.02299887f, -0.08822274f, 0.11248582f, 0.04552712f, 0.07849702f, -0.11465193f, 0.08960213f, 
    -0.12236199f, 0.14322576f, 0.27607194f, 0.08685595f, 0.06606960f, 0.81391495f, -0.13747028f, 0.26939821f, 
    -0.01557475f, -0.11787440f, -0.22065538f, 0.00832030f, 0.27658039f, 0.34979102f, 0.05646469f, 0.23602009f, 
    0.23935401f, 0.26731145f, -0.23735967f, 0.10706445f, -0.00332478f, -0.26105037f, 0.10949944f, 0.07972147f, 
    0.01345334f, -0.05298948f, -0.07121330f, -0.09170751f, -0.07413644f, 0.22297169f, 0.28891662f, 0.04018090f, 
    -0.01356818f, 0.11674489f, 0.05337504f, -0.21195465f, 0.05038272f, 0.00451450f, -0.19674586f, -0.00866027f, 
    0.21289977f, -0.05717792f, -0.06567927f, -0.21980530f, 0.03904916f, 0.00181316f, -0.25167611f, 0.07522143f, 
    -0.01260679f, -0.16067363f, 0.06338541f, 0.24215372f, 0.07133973f, -0.06873878f, 0.03486310f, -0.09699167f, 
    -0.15801705f, -0.03645359f, -0.07146948f, -0.03098275f, -0.01164276f, 0.05981851f, 0.04702349f, -0.09866892f, 
    0.07586512f, -0.01585612f, 0.08285502f, -0.15336491f, -0.13994631f, -0.00156535f, 0.18447359f, 0.13053846f, 
    0.22525357f, -0.07656430f, -0.34323031f, -0.02173701f, 0.08565307f, -0.13691285f, -0.06465324f, 0.04407245f, 
    0.24553868f, 0.33703896f, 0.35205761f, -0.01720875f, -0.08920357f, -0.11614937f, 0.02221306f, -0.02924361f, 
    0.02326322f, 0.13817188f, 0.09203416f, 0.08410595f, -0.16057812f, 0.28936180f, 0.03523812f, -0.30200401f, 
    -0.11026646f, -0.01448469f, 0.26091179f, 0.20310214f, -0.15933214f, -0.05223621f, -0.15238965f, -0.02673680f, 
    0.16863041f, -0.09551545f, -0.13268626f, 0.21919362f, 0.01814571f, 0.00930458f, 0.10801291f, -0.05171020f, 
    -0.02225549f, 0.18928918f, -0.13785802f, -0.27825278f, -0.01875014f, 0.12415095f, 0.00633692f, -0.21939853f, 
    -0.01347336f, 0.08525959f, 0.10941927f, -0.00257871f, -0.02127011f, 0.00316057f, -0.07442359f, -0.07276211f, 
    0.07603195f, 0.25169688f, -0.07514973f, -0.17658225f, 0.06574522f, 0.36390927f, 0.05282142f, 0.25417373f, 
    0.06739984f, -0.10605538f, 0.03571451f, -0.02287947f, -0.02373266f, -0.05508785f, 0.06680234f, -0.10871437f, 
    -0.05269468f, -0.08233161f, -0.09888217f, -0.10443750f, 0.10064620f, -0.06380203f, -0.03988551f, 0.06687090f, 
    0.00266963f, -0.01645711f, 0.05988809f, 0.07243921f, -0.03424068f, -0.12045982f, 0.05403949f, -0.06663123f, 
    -0.10729922f, -0.05422726f, -0.12042865f, 0.06353319f, -0.00751011f, -0.08438879f, -0.11419953f, -0.06906182f, 
    -0.10677272f, -0.08269070f, -0.04554003f, 0.01617694f, 0.04765628f, 0.05345453f, 0.05167961f, 0.04253361f, 
    -0.06630228f, -0.00655685f, 0.00511885f, -0.00968559f, 0.05489498f, -0.07362895f, -0.09369536f, 0.06843892f, 
    -0.01443464f, -0.02484280f, 0.02302036f, 0.08625874f, 0.11573628f, 0.01212405f, 0.05258210f, 0.07189754f, 
    -0.04334439f, -0.01286514f, -0.03507063f, 0.01562780f, -0.08610009f, -0.11776190f, -0.05484375f, 0.07115516f, 
    0.10610102f, 0.05347640f, -0.30751753f, -0.09867159f, -0.24667048f, 0.22466855f, 0.11395100f, 0.13048898f, 
    -0.13015343f, 0.12341528f, -0.17020510f, -0.07251398f, -0.03366740f, -0.39125371f, 0.06141076f, 0.12410286f, 
    0.06382625f, -0.21422915f, -0.12265427f, 0.09855282f, 0.08942459f, 0.05451092f, 0.16029218f, 0.18968375f, 
    0.07954998f, -0.03960903f, -0.14961548f, 0.01753622f, -0.13307066f, -0.01372005f, -0.01269574f, 0.01127004f, 
    0.03683285f, 0.12605502f, -0.18929733f, 0.11182676f, -0.11225194f, -0.11787389f, -0.26515511f, 0.33579797f, 
    -0.20355041f, -0.06174399f, 0.05734061f, -0.00435928f, 0.29186243f, -0.11393079f, -0.08451707f, 0.00784672f, 
    0.11768303f, -0.17607817f, 0.38592601f, -0.05976419f, -0.12029870f, 0.01970335f, 0.02120357f, 0.00441363f, 
    0.22534050f, 0.19182530f, -0.10323851f, -0.35806078f, 0.22051974f, -0.24427405f, 0.14082047f, 0.08477354f, 
    0.08630337f, -0.06047913f, -0.05618032f, -0.06529383f, 0.10147638f, 0.21063060f, 0.02047336f, 0.28343642f, 
    -0.09456558f, -0.21361111f, -0.15552682f, -0.01784713f, 0.03451822f, -0.07689083f, 0.13377479f, -0.00622122f, 
    0.46834096f, 0.22398941f, -0.03799985f, 0.05105521f, 0.12037223f, 0.06184814f, 0.13475445f, 0.02736879f, 
    0.20687430f, -0.07611287f, -0.16718419f, 0.01453290f, 0.16119067f, 0.09427999f, -0.02355800f, 0.07349823f, 
    -0.06961048f, -0.06282307f, 0.35138839f, -0.02844023f, -0.12324516f, 0.01384348f, -0.23491707f, 0.18120907f, 
    -0.02599531f, 0.16788460f, -0.10042258f, 0.59059209f, 0.01027211f, 0.01822600f, -0.16629596f, 0.01252719f, 
    0.01985123f, -0.12813719f, 0.14782222f, 0.11805969f, -0.05046311f, 0.04668700f, 0.05613296f, -0.08532055f, 
    0.07821462f, 0.03564506f, -0.01603668f, 0.03539461f, -0.34723943f, -0.17192028f, 0.18371737f, -0.06293514f, 
    0.15923195f, 0.06481983f, 0.26349470f, 0.06227992f, -0.27813393f, -0.23513824f, -0.02012933f, 0.07504439f, 
    0.06296074f, 0.08339652f, 0.16130139f, 0.09124239f, -0.09339263f, 0.04869726f, -0.12698184f, 0.11766883f, 
    -0.21559152f, 0.01205446f, 0.05036081f, 0.11933485f, -0.01270643f, -0.37702757f, -0.01365865f, -0.06049490f, 
    0.21327482f, -0.10553326f, 0.05397989f, 0.18509986f, -0.16274333f, -0.11855600f, -0.02122201f, 0.07827184f, 
    0.17321734f, 0.09531146f, 0.05850000f, -0.18221097f, -0.09690370f, -0.12547803f, 0.27635744f, 0.22241174f, 
    -0.00130497f, 0.38485315f, -0.22924948f, 0.11985891f, -0.06811630f, 0.09913616f, 0.03562875f, 0.15204015f, 
    0.30964991f, -0.09721629f, 0.19839822f, -0.20233989f, -0.01428661f, -0.11949759f, 0.18316042f, -0.07375014f, 
    0.26297620f, 0.25192580f, -0.04393030f, -0.07458942f, 0.10218646f, -0.40409192f, -0.13438527f, 0.09461700f, 
    -0.07186159f, 0.02063679f, -0.20400399f, 0.09889141f, -0.07076690f, -0.28425562f, -0.14559717f, 0.19008805f, 
    0.15908302f, -0.42944652f, -0.01067990f, 0.01044095f, -0.05944008f, -0.15009043f, -0.04621859f, 0.03850378f, 
    0.28208417f, 0.19676691f, 0.11121672f, -0.11264607f, 0.37491116f, 0.08528101f, -0.10089869f, 0.20276523f, 
    -0.16261162f, 0.12704988f, 0.20355737f, 0.19244346f, -0.23909718f, -0.03048956f, 0.07880816f, -0.08544926f, 
    0.13137683f, 0.09611697f, 0.14383233f, 0.10796296f, -0.01208803f, -0.10052057f, -0.14567618f, 0.24727304f, 
    0.05172038f, 0.07591969f, -0.30744624f, -0.27805158f, 0.05780776f, -0.04117450f, 0.01439015f, -0.25414824f, 
    -0.10131841f, 0.02284278f, -0.00481036f, 0.24611035f, 0.04932288f, -0.03924843f, -0.10445342f, -0.00474848f, 
    -0.10334200f, 0.09139674f, 0.15100643f, 0.06810078f, -0.18096806f, 0.23175992f, 0.24093102f, -0.15204160f, 
    -0.17478420f, -0.00570702f, 0.02482438f, 0.22988763f, 0.04695885f, 0.37477019f, 0.17648959f, 0.05974633f, 
    -0.27484182f, -0.21867795f, -0.30171490f, -0.10116243f, 0.01262471f, -0.19128005f, -0.10706911f, -0.05998069f, 
    0.06847578f, -0.08000667f, 0.05044219f, -0.07349043f, 0.13939546f, -0.03026076f, 0.25116321f, 0.39892811f, 
    -0.11388020f, -0.07080218f, 0.08149078f, 0.05605913f, 0.20071332f, -0.08568317f, 0.24326724f, -0.02420249f, 
    0.12551409f, 0.13503179f, -0.06134964f, 0.12441608f, -0.11142860f, 0.08215161f, -0.06589269f, 0.00754945f, 
    0.08794851f, -0.17087118f, -0.08963904f, 0.04484788f, 0.32357189f, 0.02500394f, -0.02110273f, 0.17414097f, 
    -0.12250215f, -0.05760943f, 0.37609237f, -0.09377092f, 0.08157731f, 0.01583843f, 0.24068981f, -0.10694255f, 
    0.16498965f, 0.01316935f, 0.29321131f, 0.27721575f, 0.15448791f, -0.03846053f, 0.20661750f, 0.03166421f, 
    0.11946145f, 0.11094911f, 0.19767156f, -0.31996718f, -0.10486702f, -0.08540498f, 0.00677574f, 0.07408687f, 
    0.12044071f, -0.14530720f, -0.02234576f, -0.06189391f, 0.05502090f, 0.53676254f, 0.11012186f, 0.04331869f, 
    -0.12850054f, -0.08373263f, -0.06640442f, 0.00458653f, 0.07920808f, 0.00506256f, -0.04295944f, -0.02609414f, 
    -0.03225998f, 0.06869075f, -0.07022074f, 0.22850935f, 0.13193397f, -0.06878154f, 0.08151728f, 0.06961336f, 
    -0.30897367f, 0.19346707f, -0.14725265f, 0.45953867f, 0.04722433f, -0.06242613f, 0.15007532f, -0.15649760f, 
    0.17076771f, -0.30925116f, 0.39756653f, 0.04576989f, 0.21759935f, -0.07458515f, 0.03192282f, 0.01806307f, 
    0.16646524f, 0.01069386f, -0.17244151f, 0.18553211f, 0.07145982f, -0.09566637f, -0.05442492f, 0.11830685f, 
    -0.31293190f, -0.06559470f, -0.07770249f, 0.09694174f, 0.09057530f, 0.01833795f, 0.02390361f, 0.01352801f, 
    -0.04402305f, -0.00561115f, 0.35101703f, 0.27322999f, -0.14984715f, 0.10113161f, -0.07527399f, 0.03686398f, 
    0.07155670f, -0.34705594f, 0.23368074f, -0.06323284f, 0.09925295f, 0.14357574f, 0.02204977f, -0.12390202f, 
    0.41678777f, 0.15429142f, -0.01981512f, 0.07407933f, 0.12471210f, 0.00615647f, -0.15467569f, 0.06651738f, 
    0.16944249f, -0.05676042f, -0.15476784f, 0.13875197f, 0.15453087f, -0.06264539f, 0.08964632f, -0.10141590f, 
    -0.08097441f, 0.14446855f, 0.07106210f, -0.09113095f, 0.02541332f, -0.07718779f, 0.04595802f, -0.05316763f, 
    0.04679568f, 0.36943075f, -0.05381000f, 0.29494902f, -0.14326373f, -0.04609336f, 0.24105425f, 0.16448042f, 
    -0.04171557f, 0.02281080f, 0.15534490f, 0.27018782f, -0.05792604f, 0.02352527f, -0.16023147f, -0.10702914f, 
    -0.01618866f, 0.01456642f, 0.08924641f, 0.10989866f, 0.00487721f, -0.44573143f, 0.13034461f, -0.24594241f, 
    -0.07485561f, -0.10319226f, -0.13358171f, 0.22791401f, 0.17295021f, 0.01474955f, 0.12394209f, 0.12998296f, 
    -0.19494234f, 0.16362120f, 0.16646913f, 0.03307363f, -0.06531064f, -0.15896966f, -0.00586378f, -0.07952713f, 
    0.08097769f, 0.02408651f, -0.02448429f, 0.10687718f, -0.12470085f, 0.15602726f, 0.07971514f, 0.19818810f, 
    0.03672585f, 0.10966779f, 0.10284052f, 0.00836238f, -0.03580168f, 0.08727603f, -0.22639360f, 0.03794689f, 
    0.13203235f, -0.17910388f, -0.08628801f, -0.36850896f, 0.03027248f, 0.09186382f, 0.01604075f, -0.12213930f, 
    -0.12451831f, 0.01558009f, 0.06916535f, -0.25867513f, 0.39945376f, 0.00522940f, -0.04463059f, 0.01080971f, 
    -0.15289655f, 0.29488638f, 0.26902521f, -0.13724273f, 0.06801470f, 0.05281402f, 0.01909344f, 0.05398186f, 
    0.16847321f, -0.08172745f, -0.24647483f, 0.24856286f, 0.18328586f, -0.05824396f, 0.08472858f, -0.11405527f, 
    -0.01506760f, -0.00559864f, 0.01599568f, 0.31076086f, 0.02991240f, 0.11372060f, -0.05674748f, 0.08999030f, 
    0.09082497f, 0.07117426f, -0.07112617f, 0.05258510f, -0.09977987f, -0.07532256f, -0.03524953f, 0.02234595f, 
    -0.29202145f, -0.12470259f, 0.09394367f, 0.10160297f, -0.00908597f, 0.08963742f, -0.10943810f, 0.10167067f, 
    0.04838683f, -0.09541920f, 0.17296028f, -0.08039184f, 0.12629594f, 0.04566263f, 0.12901540f, -0.02541804f, 
    0.15723887f, 0.23030439f, -0.11308973f, 0.04795584f, 0.11088760f, 0.02663765f, 0.13927633f, -0.11073893f, 
    -0.19667149f, -0.09139404f, 0.20537217f, -0.01786505f, 0.00797218f, -0.06405434f, 0.29314876f, 0.10427593f, 
    -0.25224864f, -0.08725598f, -0.06922460f, -0.03170288f, -0.04770188f, -0.04975368f, 0.22139335f, -0.02067375f, 
    0.27645352f, -0.23999591f, -0.01650200f, -0.02284350f, 0.36681467f, -0.05744565f, 0.02243392f, 0.15899545f, 
    -0.03087385f, 0.11512486f, 0.04630806f, -0.10775206f, -0.13021924f, 0.04153294f, 0.03431441f, 0.08806007f, 
    0.39911869f, 0.13445917f, 0.21816909f, 0.12839733f, -0.01816137f, 0.19641104f, 0.09882052f, 0.06581710f, 
    -0.41512898f, -0.08484601f, 0.01953922f, 0.05600787f, 0.17175801f, -0.10421693f, -0.06185855f, -0.21761279f, 
    0.07100783f, -0.11331239f, 0.00225798f, -0.07443821f, 0.20044525f, 0.00906335f, -0.00776315f, 0.01336313f, 
    -0.00995842f, 0.27086237f, -0.22579806f, -0.13941072f, 0.02454598f, 0.02114522f, 0.22322202f, -0.26157108f, 
    0.26782098f, 0.15454432f, 0.28418842f, -0.10066409f, -0.16813815f, -0.09997102f, 0.23990960f, 0.00622046f, 
    -0.06865645f, 0.19675691f, -0.02981747f, 0.16861629f, 0.00175225f, 0.07524254f, -0.16422051f, -0.05545738f, 
    -0.21128044f, -0.12574407f, 0.02712131f, 0.02805761f, 0.21386009f, 0.02788393f, 0.24052508f, 0.04422630f, 
    0.08124525f, -0.05443242f, -0.24123302f, -0.08735075f, 0.26719040f, 0.34811202f, 0.16665572f, 0.14492707f, 
    0.03907666f, 0.12495150f, -0.08001151f, 0.01535097f, -0.09575438f, -0.38882917f, 0.00731728f, -0.03652267f, 
    0.10681807f, 0.02579484f, -0.07881063f, 0.02506009f, 0.26141185f, 0.37961876f, -0.09344737f, 0.03119176f, 
    -0.00870079f, -0.07223167f, 0.27567595f, -0.10638899f, -0.01204095f, 0.04253016f, 0.13553701f, 0.09051531f, 
    0.14063230f, -0.04663454f, -0.19477306f, -0.03528668f, -0.00066371f, 0.06030640f, -0.17969349f, -0.17150535f, 
    -0.15914603f, -0.32295525f, 0.23616740f, -0.15155418f, 0.09065144f, 0.11082325f, -0.05698517f, -0.20124108f, 
    -0.32623172f, 0.26278836f, 0.19190250f, -0.10145023f, 0.11440496f, 0.08606769f, -0.00315700f, -0.10569304f, 
    0.08191986f, 0.04351855f, -0.09656945f, 0.10957789f, -0.08702340f, 0.28993112f, 0.13147061f, 0.15263273f, 
    0.09385739f, -0.05755568f, -0.11817453f, -0.38882771f, 0.17917967f, 0.08899854f, 0.22595954f, -0.06723357f, 
    0.18151635f, 0.36623722f, 0.14551525f, -0.04477155f, 0.04616579f, -0.15047947f, -0.09255786f, -0.00564992f, 
    -0.19196908f, -0.09324827f, 0.09089683f, -0.09946991f, -0.06661701f, -0.19225492f, 0.31513792f, -0.18541639f, 
    0.29838562f, -0.11299734f, -0.05039821f, -0.09338000f, -0.11491409f, 0.09353240f, -0.13201480f, 0.01008557f, 
    0.20825623f, -0.10111757f, 0.25952956f, -0.27191293f, 0.09865502f, -0.05597282f, 0.17057928f, 0.28253511f, 
    0.13845499f, 0.22066090f, 0.09301966f, 0.28595641f, 0.01682709f, -0.00707920f, -0.07893011f, 0.06413930f, 
    0.19610445f, 0.13091762f, -0.15740357f, -0.13830438f, 0.12780271f, 0.09833651f, 0.22162339f, -0.00100515f, 
    0.14614901f, 0.26142037f, 0.04657516f, -0.20359442f, -0.10042582f, -0.14189337f, -0.14066918f, 0.26880941f, 
    -0.06349348f, -0.06767899f, 0.02700718f, -0.01387874f, -0.05564206f, 0.04520052f, 0.00866805f, 0.01202183f, 
    -0.05983360f, -0.10279538f, 0.05623557f, 0.07036707f, -0.00264370f, 0.02453656f, -0.01016008f, -0.03991562f, 
    0.04706318f, -0.06168814f, -0.07743011f, -0.08233498f, 0.08603305f, 0.09698952f, 0.07349651f, -0.10368902f, 
    0.09268117f, 0.05210730f, 0.04705806f, 0.07457530f, -0.10940549f, -0.06943177f, -0.05100403f, -0.07336672f, 
    -0.09411435f, -0.05786881f, -0.12060938f, -0.09584679f, 0.07721724f, 0.10171555f, -0.14381182f, -0.07700071f, 
    -0.10537806f, -0.12327497f, -0.13019852f, 0.00466490f, -0.12393295f, -0.02168490f, -0.00923518f, -0.00480435f, 
    0.00720028f, 0.09244058f, -0.03022974f, 0.01190358f, -0.06227732f, -0.09017280f, 0.09775133f, -0.02284330f, 
    -0.17130573f, -0.07564424f, 0.02719779f, -0.11777336f, 0.01988278f, -0.02264810f, -0.12587328f, -0.03816902f, 
    -0.12562858f, 0.02864192f, -0.20521532f, 0.29830587f, 0.02411920f, 0.10662681f, 0.18818949f, -0.03267852f, 
    -0.13982840f, 0.17492031f, -0.06535586f, -0.09163724f, -0.07475796f, -0.03070086f, -0.02067530f, 0.08642466f, 
    -0.22153391f, -0.06937383f, -0.10682665f, -0.07930850f, 0.17168404f, 0.11526982f, 0.09182569f, 0.27030927f, 
    0.02523630f, -0.09360845f, 0.13877910f, 0.08991474f, -0.08545172f, 0.00535362f, 0.16835096f, -0.02048101f, 
    0.10853779f, -0.03642994f, -0.18219976f, 0.05464060f, 0.07090007f, 0.02629289f, -0.15547712f, -0.24656296f, 
    -0.16958122f, -0.11387793f, 0.10517814f, -0.30348974f, 0.41749081f, -0.12782402f, 0.06013689f, -0.17647287f, 
    -0.37111643f, 0.05460926f, 0.17133994f, -0.10907155f, -0.06794592f, -0.06871871f, 0.01369126f, -0.03542580f, 
    0.04625687f, -0.10918040f, -0.13274044f, 0.26765296f, 0.32093039f, 0.02803141f, 0.26886967f, 0.00393372f, 
    0.14438204f, 0.06433655f, -0.15827584f, 0.12244079f, 0.26534432f, -0.04337106f, 0.12395743f, 0.19074960f, 
    -0.06568498f, -0.26894090f, 0.04379978f, -0.01693122f, -0.06414537f, 0.08693021f, -0.11637852f, -0.03021044f, 
    0.55200130f, 0.29781058f, 0.07687114f, 0.12189557f, 0.04849276f, 0.44635439f, 0.26931885f, 0.22836739f, 
    0.09251662f, -0.02162681f, -0.17302923f, -0.01015362f, 0.06546717f, 0.03746425f, -0.18133353f, -0.11018243f, 
    0.02810922f, -0.24474536f, 0.14791803f, -0.10945126f, -0.03212107f, 0.00008490f, -0.18366180f, 0.29324219f, 
    0.23221484f, 0.01122898f, -0.01579988f, 0.15890937f, 0.22282521f, 0.04152115f, -0.16314662f, -0.10113697f, 
    0.11947554f, 0.17498790f, 0.18803060f, 0.09805193f, 0.07243986f, 0.07135917f, 0.07513977f, 0.07192693f, 
    -0.06180328f, 0.08737587f, -0.04516177f, 0.18758039f, -0.16211431f, -0.05184787f, 0.22996008f, -0.12324624f, 
    -0.04285389f, 0.01165166f, -0.02873345f, 0.10508027f, -0.04353488f, -0.08567118f, -0.04917041f, -0.06320181f, 
    -0.08021536f, -0.06951537f, -0.02644840f, -0.01301248f, -0.11860897f, -0.12471127f, -0.02004286f, -0.06377526f, 
    -0.08069139f, 0.08694965f, -0.11557002f, 0.00204932f, 0.08591940f, -0.08737665f, 0.01447126f, -0.01430086f, 
    0.01499135f, -0.05255070f, -0.09188341f, 0.02284761f, -0.11179522f, 0.06346837f, -0.08406360f, -0.05466136f, 
    -0.06240422f, -0.07579072f, 0.04981805f, -0.11277531f, 0.01723238f, -0.11328176f, -0.10048970f, 0.03900138f, 
    -0.04154297f, 0.06501565f, 0.09685418f, -0.09453721f, -0.11855717f, 0.06677463f, 0.02481007f, -0.12168069f, 
    -0.02692699f, -0.08282258f, 0.02696264f, -0.04394196f, -0.05452072f, 0.00485742f, -0.02051097f, -0.12215950f, 
    0.04540834f, -0.04944784f, 0.07426935f, 0.01343162f, 0.04835028f, 0.08064114f, 0.08474863f, 0.00444859f, 
    0.02149499f, -0.05391939f, -0.08079924f, 0.28560919f, -0.21872212f, -0.10411118f, -0.09415851f, 0.06682835f, 
    0.19895153f, 0.11824138f, 0.34320644f, 0.01258590f, -0.08141488f, -0.12330277f, 0.10489363f, -0.02457966f, 
    0.37442294f, 0.13212347f, -0.05212398f, 0.06905729f, 0.23210146f, 0.16553934f, -0.17142273f, -0.08175018f, 
    -0.20593092f, -0.09480583f, 0.25285000f, 0.25706917f, -0.15983276f, 0.10374620f, 0.19133392f, 0.07367598f, 
    0.10155878f, -0.02006620f, -0.30160308f, 0.31546506f, -0.11055871f, -0.11487555f, 0.17641059f, -0.15175955f, 
    -0.14667803f, 0.05936027f, -0.24000837f, -0.26964167f, -0.14149435f, 0.00394674f, 0.21051158f, -0.16878873f, 
    -0.09273834f, 0.31055889f, 0.23459996f, 0.08070461f, -0.07984009f, -0.03867386f, -0.06409948f, 0.02935999f, 
    0.12207338f, 0.18062332f, 0.06252287f, 0.09866266f, 0.20382744f, 0.25346643f, -0.07251990f, -0.06240129f, 
    0.23409054f, 0.02060875f, -0.00640992f, -0.02379573f, -0.09723956f, -0.23471996f, 0.00596446f, 0.00120371f, 
    0.02593911f, 0.18216874f, 0.10578956f, 0.08975817f, -0.07375634f, 0.23683636f, 0.06196013f, -0.01545709f, 
    -0.17378165f, 0.22821115f, 0.08972575f, -0.01601422f, -0.11114337f, -0.25384021f, 0.14816780f, -0.27743050f, 
    0.04020768f, 0.00453898f, 0.06940188f, 0.26582599f, -0.07763658f, 0.08911473f, 0.00752695f, -0.10057960f, 
    0.06591278f, 0.00504805f, 0.25336146f, 0.19353423f, -0.09020738f, -0.03523729f, 0.31442803f, 0.29041490f, 
    0.24522588f, 0.07190831f, -0.16282919f, -0.03629772f, -0.08500820f, 0.11361634f, 0.11761639f, 0.19967617f, 
    0.31713408f, -0.07225375f, -0.20628960f, 0.04142117f, -0.00410443f, -0.06308842f, 0.05115198f, 0.02012315f, 
    -0.10958280f, 0.17712474f, 0.02103369f, -0.19045021f, -0.12708403f, 0.08382582f, -0.06478658f, 0.28007668f, 
    -0.09509358f, 0.02387177f, 0.02490945f, -0.11132681f, -0.05948834f, -0.02019559f, -0.08124507f, 0.02090852f, 
    -0.10168278f, -0.12791505f, -0.04139521f, -0.09900579f, -0.01204672f, -0.06247079f, 0.04859988f, -0.07886533f, 
    -0.02481406f, -0.10172585f, 0.00723161f, 0.09652425f, 0.03694976f, 0.09596098f, 0.00599350f, -0.02542407f, 
    -0.09623006f, -0.05798078f, -0.06591275f, -0.00038684f, 0.00150574f, -0.07270665f, -0.10139135f, 0.02340661f, 
    -0.08112595f, 0.01958114f, 0.02570605f, -0.12866779f, 0.10695662f, -0.09392275f, -0.09173512f, -0.04545107f, 
    -0.01614706f, 0.04138309f, 0.03395984f, -0.09455288f, 0.07076874f, 0.10509883f, -0.02347709f, -0.09951711f, 
    0.06673542f, 0.03564836f, 0.12459327f, -0.11471847f, 0.05349270f, -0.06447822f, -0.08730345f, -0.03471676f, 
    0.04692447f, 0.05017724f, -0.02598310f, 0.00652116f, 0.02819929f, -0.01259525f, 0.10101677f, 0.09149922f, 
    -0.02477847f, 0.03129423f, 0.24676618f, 0.11686996f, 0.30524656f, 0.37843454f, 0.20725879f, 0.15677692f, 
    -0.22598982f, -0.23900205f, -0.30970827f, -0.09142533f, 0.08354490f, -0.03935787f, -0.03731789f, -0.08998226f, 
    0.22446074f, 0.24799950f, -0.09537545f, -0.08854967f, 0.12775537f, -0.04994528f, 0.32625294f, 0.12739834f, 
    0.10869682f, 0.07782093f, 0.13207437f, -0.22821748f, 0.32936123f, 0.00564012f, 0.28774109f, -0.04834289f, 
    -0.05851738f, -0.04135287f, 0.34924757f, -0.16450419f, 0.00330412f, 0.11821879f, 0.07523990f, 0.09864878f, 
    0.13715093f, -0.14309292f, 0.07930823f, 0.26175332f, -0.20105997f, -0.10715311f, 0.00769050f, 0.22768393f, 
    -0.29977581f, -0.13082737f, -0.18407612f, 0.12601486f, 0.11229435f, 0.00869409f, 0.16536409f, -0.06691594f, 
    0.01204569f, -0.19700323f, 0.22465284f, 0.29463744f, -0.07524041f, -0.03121434f, 0.11256113f, -0.09945116f, 
    0.11914550f, -0.03215118f, 0.19179513f, -0.14460582f, 0.20244259f, -0.05396365f, 0.24117364f, 0.01232092f, 
    -0.08432788f, 0.24775888f, -0.17006090f, -0.07133794f, -0.11281948f, 0.11730406f, 0.08200550f, 0.02138965f, 
    -0.52053708f, -0.12816826f, 0.03638397f, -0.01503554f, -0.20063090f, -0.26047984f, -0.03586133f, 0.41447249f, 
    0.15742542f, 0.10288319f, 0.18538392f, -0.09607285f, -0.18054119f, -0.11886833f, 0.03240021f, 0.02904127f, 
    0.17661053f, 0.03809034f, -0.08181093f, -0.17328762f, -0.09651332f, -0.09964782f, 0.00994508f, -0.09535765f, 
    0.00315504f, -0.27088299f, 0.21977040f, 0.07175872f, 0.20559639f, -0.04650364f, -0.16256914f, 0.17030303f, 
    0.13158305f, 0.17815869f, -0.15301540f, -0.26470664f, 0.04396578f, -0.02339485f, 0.25937584f, 0.06391084f, 
    0.19999278f, 0.07629935f, -0.11161418f, 0.05194234f, -0.00926162f, -0.00070388f, 0.16486895f, 0.06525940f, 
    0.03826541f, -0.00121792f, 0.09238016f, 0.00968398f, 0.11600799f, 0.03341010f, 0.16314487f, 0.05133829f, 
    -0.07575570f, -0.32822651f, -0.19727238f, 0.07760479f, 0.03996164f, 0.39583451f, -0.06601799f, -0.01934320f, 
    -0.14751600f, 0.03781995f, -0.12044369f, -0.03555857f, 0.16501293f, -0.12087479f, 0.26243967f, 0.10349119f, 
    0.07875735f, -0.04952291f, -0.27015102f, -0.00977978f, 0.24828592f, 0.00291346f, 0.02409533f, -0.09261622f, 
    -0.17754842f, 0.19074540f, -0.07408036f, 0.01675725f, 0.12509871f, -0.01136211f, 0.08732446f, -0.02991388f, 
    0.37546021f, -0.12131011f, 0.23777080f, 0.17696182f, 0.09434653f, 0.07929909f, 0.02532037f, 0.19996679f, 
    0.10377261f, -0.05304359f, 0.10419708f, 0.17433818f, -0.03553113f, 0.06610759f, -0.24938072f, -0.10161909f, 
    -0.14077601f, -0.21689478f, 0.06859946f, 0.34681851f, 0.12556808f, 0.15161924f, 0.08518051f, -0.14881186f, 
    0.05607207f, 0.01148059f, 0.13240637f, -0.03567778f, 0.04707423f, -0.15783013f, 0.01585881f, 0.08427318f, 
    -0.29549596f, -0.12224855f, -0.03781195f, 0.06678478f, -0.00615968f, 0.00299884f, -0.11447098f, -0.05011845f, 
    0.27419937f, 0.16108839f, 0.00774363f, -0.00462681f, 0.09611022f, 0.17642795f, 0.03973658f, -0.03188816f, 
    -0.04928517f, 0.11913306f, -0.01548863f, 0.23213778f, -0.02847379f, -0.06441710f, 0.23775338f, 0.05423805f, 
    0.12468164f, -0.15612420f, 0.13947310f, 0.28143242f, -0.06537597f, 0.00033537f, 0.20524684f, 0.32161096f, 
    -0.07255162f, -0.01588250f, -0.36088800f, 0.06324700f, -0.04661709f, 0.01372471f, -0.05455209f, 0.04122763f, 
    0.20450228f, 0.09412839f, 0.27420700f, -0.12845272f, -0.10755445f, 0.04429338f, 0.31251624f, -0.02038296f, 
    -0.01206294f, 0.13073769f, -0.05489418f, 0.12974469f, -0.26308608f, 0.24515322f, -0.35442859f, 0.03731267f, 
    -0.13099627f, -0.01526177f, -0.00328485f, 0.07553630f, 0.07806244f, -0.10670023f, 0.01535831f, 0.09954063f, 
    0.12262429f, 0.08738943f, -0.12164255f, -0.12414449f, -0.12213449f, -0.04123151f, -0.00891936f, 0.07190554f, 
    0.00005040f, 0.07850699f, -0.10512318f, -0.05398008f, 0.01855332f, 0.21154046f, 0.10082364f, -0.01993230f, 
    -0.13022335f, -0.03885496f, 0.15574680f, -0.08085893f, -0.10314456f, -0.01549160f, 0.04275104f, 0.08979382f, 
    -0.01662762f, -0.03603609f, -0.00732683f, -0.10089298f, -0.09189130f, -0.06754762f, -0.03326488f, -0.02175348f, 
    -0.05475995f, -0.00447067f, 0.00148069f, -0.08784607f, 0.10376942f, 0.05023253f, -0.00503091f, -0.03168070f, 
    -0.14366271f, 0.07934979f, -0.14232683f, -0.03511288f, 0.12007703f, 0.08307008f, -0.03240770f, -0.05545258f, 
    -0.02712357f, -0.02747510f, -0.04630924f, -0.04452384f, 0.05123302f, 0.09653366f, -0.05233877f, 0.00114214f, 
    -0.02648455f, -0.00250540f, -0.01408599f, 0.19851142f, -0.00228544f, -0.12544480f, -0.04247385f, -0.07255135f, 
    -0.13132316f, -0.13073495f, 0.06420883f, -0.04099726f, 0.08019944f, 0.18205720f, 0.04961674f, 0.10966857f, 
    -0.11285353f, 0.07760076f, -0.09841737f, -0.09222189f, -0.19524549f, 0.07408251f, 0.26795799f, -0.05309279f, 
    0.09414311f, 0.04131548f, -0.09556830f, 0.00915724f, 0.33168912f, -0.10314865f, -0.01252977f, 0.06948967f, 
    0.00948785f, -0.06669669f, -0.00825301f, 0.01247293f, 0.00931145f, 0.04618360f, 0.12169918f, -0.06773969f, 
    0.02140546f, -0.04674963f, -0.31039026f, -0.05515624f, -0.02767013f, 0.07995373f, 0.21705054f, 0.33461714f, 
    -0.06233340f, -0.07484198f, -0.03505859f, 0.20529173f, 0.07830049f, -0.06184007f, 0.04764753f, -0.04635155f, 
    0.04040386f, 0.02633356f, 0.28774107f, 0.29645890f, 0.25564617f, 0.28537422f, 0.06682149f, 0.00150252f, 
    -0.00957927f, 0.05234067f, 0.35280910f, 0.40907189f, 0.00501766f, 0.13267094f, -0.01060970f, 0.05870635f, 
    0.02312776f, -0.06499245f, 0.02420926f, -0.06945020f, -0.00162757f, 0.10501561f, -0.04230702f, 0.11519668f, 
    -0.03439966f, 0.06220573f, -0.10894106f, 0.06361003f, 0.26755232f, -0.18544999f, -0.15830977f, 0.08660243f, 
    0.15336610f, -0.00453975f, -0.05939774f, 0.14075156f, 0.10186599f, -0.06686459f, 0.37685129f, 0.04355612f, 
    0.04179086f, 0.20857607f, -0.14531557f, -0.08953444f, -0.10956316f, 0.08586194f, 0.09853344f, -0.10898162f, 
    0.01666377f, 0.33203614f, -0.10752228f, 0.18425755f, -0.10367266f, -0.00127850f, 0.28001571f, 0.04704252f, 
    -0.10898522f, 0.06694866f, 0.09282948f, -0.04425875f, 0.04447863f, -0.02857268f, 0.13238035f, -0.00269854f, 
    0.25168544f, -0.00017043f, 0.02674325f, 0.12800218f, 0.23224963f, -0.40512168f, -0.06037210f, -0.11865001f, 
    0.13787131f, -0.04357629f, 0.06265159f, 0.38064805f, -0.24061175f, -0.00258521f, 0.12733783f, 0.19930726f, 
    0.14491813f, -0.00006152f, 0.02077882f, -0.02883403f, 0.00562150f, -0.26644975f, 0.07810059f, -0.04794610f, 
    -0.09387483f, -0.04986896f, -0.03503191f, 0.07551059f, -0.10551291f, 0.04268660f, 0.03198456f, 0.03961057f, 
    0.17891741f, 0.01219670f, -0.05141323f, -0.03272953f, -0.03369952f, 0.00617115f, 0.02458482f, -0.07287223f, 
    0.26672438f, 0.18786369f, -0.12758090f, -0.26466778f, 0.05732822f, 0.09938443f, -0.10751062f, 0.15356396f, 
    -0.13335189f, 0.25425479f, -0.26768529f, -0.01864883f, 0.12102996f, 0.03121616f, 0.16875887f, -0.01235936f, 
    -0.03611940f, -0.27135807f, 0.24062204f, 0.09522264f, 0.08183625f, 0.07997536f, 0.03331896f, 0.10938405f, 
    0.38436484f, -0.07298495f, -0.07455537f, -0.23006976f, 0.13884352f, -0.43568438f, 0.09705194f, -0.00302374f, 
    -0.14385973f, -0.01509939f, -0.10628597f, 0.05651487f, -0.05602686f, -0.07333221f, -0.01875005f, -0.00231115f, 
    -0.04717575f, 0.09852752f, -0.10511082f, -0.02158521f, 0.07769722f, 0.09849257f, 0.09987461f, 0.08126917f, 
    0.00424971f, -0.01874402f, -0.05506670f, -0.10442791f, 0.06919970f, -0.05886567f, -0.05976511f, -0.00524581f, 
    -0.10965353f, -0.01522430f, -0.07005242f, -0.13023238f, -0.03676957f, 0.01166526f, -0.12154292f, -0.08592247f, 
    0.01760018f, 0.00705108f, 0.05005210f, 0.07539834f, -0.02941357f, -0.04060788f, -0.10819816f, -0.09676448f, 
    0.04292959f, -0.01797804f, -0.05554221f, -0.11144791f, 0.01939765f, -0.11153676f, -0.00200584f, -0.05667365f, 
    -0.00500601f, -0.04555691f, 0.07781155f, 0.01445678f, 0.04280422f, -0.06831651f, 0.08065791f, 0.05496553f, 
    -0.02069030f, 0.00534821f, 0.08749755f, -0.14047556f, -0.04282910f, -0.07028838f, 0.05118395f, -0.12276663f, 
    -0.01616244f, 0.05433011f, 0.31671381f, -0.23183471f, -0.19099410f, 0.13326600f, 0.04864786f, -0.26980016f, 
    -0.28255528f, 0.12269218f, -0.03836472f, 0.08809160f, 0.09700305f, -0.08191019f, 0.09053931f, -0.04313835f, 
    -0.34940228f, -0.07749131f, 0.08760086f, 0.06098963f, -0.12569089f, -0.14061022f, 0.35179859f, 0.03559560f, 
    0.08116336f, 0.03494604f, -0.01835723f, -0.16252796f, 0.01359224f, 0.12665439f, 0.11694815f, 0.09424320f, 
    -0.17857851f, 0.22904870f, 0.00943488f, -0.03818826f, -0.02341801f, -0.06188934f, 0.39982113f, 0.23405088f, 
    0.16887209f, -0.18683070f, -0.07631370f, -0.11467022f, 0.21094817f, 0.00672514f, 0.16820556f, 0.44085923f, 
    0.09296722f, -0.09418296f, -0.09115545f, -0.18142624f, -0.07398585f, -0.11310929f, 0.20218793f, 0.08711084f, 
    0.09155365f, 0.09696606f, 0.22607334f, 0.04752592f, 0.22416927f, 0.18011425f, -0.13974161f, 0.27431047f, 
    0.08695225f, -0.04790566f, -0.00019409f, 0.02502947f, 0.05049259f, -0.27397633f, -0.04874798f, -0.01190981f, 
    -0.11903364f, -0.04534494f, 0.08749758f, 0.03617238f, 0.05810454f, 0.22046137f, 0.03881229f, 0.09884494f, 
    -0.15604986f, 0.03453615f, -0.00261962f, -0.04868734f, -0.08981342f, 0.09362272f, 0.29776585f, 0.02949762f, 
    -0.02403047f, 0.03257248f, -0.22846265f, 0.05376559f, 0.12801725f, -0.06575432f, -0.20646134f, 0.12080978f, 
    -0.10973918f, 0.06523658f, -0.10525533f, 0.03324226f, 0.00739380f, 0.11267532f, 0.21015081f, 0.11085665f, 
    0.15145633f, -0.08174469f, 0.15003359f, -0.01923789f, 0.28108037f, 0.09894055f, 0.00000421f, 0.19643199f, 
    0.24547903f, 0.15511592f, 0.24492107f, 0.14299279f, -0.07012758f, 0.02193402f, -0.13985324f, -0.03222676f, 
    -0.24066217f, 0.07849875f, -0.01037062f, 0.06425943f, -0.01852846f, 0.34384233f, 0.08142357f, -0.02830845f, 
    -0.04718021f, -0.12154602f, -0.10514092f, 0.00304726f, 0.03162605f, 0.08276697f, -0.12102222f, -0.07724275f, 
    0.04458129f, -0.10428308f, 0.01229838f, 0.12484675f, -0.04540063f, -0.02778523f, -0.11034932f, 0.12031479f, 
    -0.14292546f, -0.06724955f, -0.11737907f, 0.01815771f, 0.05285255f, 0.08686121f, -0.09711235f, 0.09690645f, 
    0.08296152f, -0.00421188f, -0.10920050f, 0.00044215f, 0.04850300f, 0.10333888f, 0.02057318f, -0.04132169f, 
    -0.00771721f, -0.04713650f, -0.09232136f, 0.06901348f, 0.09761935f, 0.03268164f, 0.07756303f, -0.02059595f, 
    -0.09902201f, -0.05382761f, 0.08988430f, -0.03407441f, 0.04100826f, 0.07041613f, 0.07623610f, 0.08698426f, 
    -0.04199463f, -0.08748772f, -0.06211393f, 0.06587832f, -0.08136196f, -0.08290691f, -0.00181676f, 0.01941015f, 
    -0.13501008f, -0.13267016f, -0.13546118f, 0.03090706f, -0.00317522f, 0.01994148f, -0.05964882f, -0.13957004f, 
    0.18572125f, 0.04384491f, -0.36442733f, -0.10599937f, -0.01107549f, -0.19341768f, 0.05211737f, -0.01665182f, 
    0.07969773f, -0.12668891f, 0.18923457f, -0.09790933f, 0.04536667f, -0.10290185f, 0.04901968f, 0.02214958f, 
    0.02951088f, 0.13698022f, -0.00083281f, 0.04176451f, 0.11837965f, 0.23256986f, -0.03999011f, 0.02659722f, 
    -0.00762947f, -0.08604519f, 0.03225279f, 0.26789722f, -0.02639708f, 0.06926460f, -0.29514018f, 0.13632941f, 
    0.08583173f, 0.07237608f, -0.11479494f, 0.10522071f, -0.04830197f, 0.00685099f, -0.09063256f, 0.20294270f, 
    0.11706036f, 0.05605021f, -0.23306742f, -0.27587813f, 0.18827075f, 0.06566430f, -0.13120797f, -0.06078749f, 
    0.16569914f, 0.23129778f, 0.26719534f, 0.15179478f, -0.04290639f, -0.06214176f, -0.06800204f, -0.02418965f, 
    0.10778128f, 0.26292741f, -0.06787585f, -0.11197656f, 0.06752867f, 0.27099788f, 0.20148806f, 0.06026189f, 
    0.14320961f, 0.03183348f, -0.01279350f, -0.04148549f, 0.01237045f, 0.05115152f, 0.26312238f, 0.15092701f, 
    -0.04998743f, -0.02578196f, -0.06505738f, 0.04537039f, 0.12754264f, -0.28843188f, -0.09145536f, 0.03772590f, 
    -0.06606591f, -0.04177789f, 0.11798221f, -0.11457465f, 0.02677575f, -0.26531863f, 0.14144777f, 0.18076029f, 
    0.17821445f, -0.11567312f, 0.05716641f, -0.01342631f, -0.07822707f, -0.04977076f, 0.09651972f, -0.06238529f, 
    0.01146963f, 0.00548182f, 0.22140072f, -0.33616033f, -0.03278413f, 0.07088910f, 0.00078084f, 0.34196302f, 
    0.00964470f, 0.18788114f, -0.19244763f, 0.27750283f, 0.09205682f, -0.08152682f, -0.08252522f, 0.20733823f, 
    0.05115147f, -0.12304159f, -0.19228488f, -0.01504692f, -0.11514367f, -0.04902951f, 0.19891991f, -0.08277974f, 
    0.31822675f, 0.04878126f, 0.20692424f, -0.12298661f, -0.25337848f, -0.19555081f, 0.07371055f, 0.09528903f, 
    0.09787510f, -0.07286203f, 0.15224375f, 0.01281675f, -0.22550626f, 0.01905205f, 0.12848771f, -0.08662499f, 
    -0.10768509f, -0.19553521f, 0.05692402f, -0.11290937f, -0.07613011f, -0.18397655f, -0.10690282f, 0.07120302f, 
    -0.04490719f, 0.01514181f, -0.09843200f, -0.05472909f, 0.11624767f, -0.15345278f, 0.17466678f, 0.17557088f, 
    0.16404642f, -0.06779446f, -0.11964057f, 0.00206313f, -0.14937003f, -0.03496537f, 0.02629976f, 0.10638376f, 
    -0.02373031f, 0.03998902f, 0.00241390f, -0.34629074f, -0.08776890f, 0.03216569f, 0.16345023f, 0.31405383f, 
    0.25504738f, 0.31250343f, -0.20238888f, -0.13743238f, 0.23313518f, 0.07555760f, 0.01406107f, 0.14698425f, 
    0.17090896f, -0.00103834f, 0.25781697f, -0.13043186f, 0.08645575f, -0.03812162f, -0.08444642f, -0.12426690f, 
    0.12287289f, 0.17820185f, 0.18107112f, 0.01878418f, 0.05394116f, -0.13131978f, 0.11646879f, 0.00540352f, 
    0.01510720f, 0.03095353f, 0.10206519f, -0.13879868f, -0.01478727f, -0.11866184f, 0.01325655f, -0.12192546f, 
    -0.01347415f, -0.23347786f, -0.01073907f, -0.11530298f, -0.03460955f, 0.17437163f, 0.11331210f, -0.00447002f, 
    -0.19566789f, 0.15736017f, -0.08764014f, 0.07314827f, 0.05272822f, 0.03706669f, 0.27924478f, -0.12823197f, 
    0.08372274f, 0.10961008f, -0.34985432f, 0.11373919f, 0.23270173f, 0.03048877f, -0.16451515f, 0.08876321f, 
    -0.34456152f, 0.20191318f, -0.16637659f, 0.04983597f, -0.09082782f, 0.10279292f, 0.16579737f, 0.01044168f, 
    0.28427690f, -0.14917116f, -0.02720116f, 0.08679856f, -0.08692189f, -0.07468726f, 0.06595694f, 0.26758489f, 
    0.12603602f, 0.06445364f, -0.10537995f, 0.35708097f, -0.03710487f, 0.10297590f, -0.05301896f, -0.09119388f, 
    -0.28949115f, 0.03140012f, 0.14270960f, 0.23423634f, 0.21675228f, 0.06089123f, -0.03197656f, 0.09638417f, 
    -0.14257388f, -0.10412952f, -0.06829794f, 0.03126841f, -0.05944186f, 0.07067466f, 0.11233009f, -0.10775524f, 
    -0.03363272f, -0.10564847f, -0.11470634f, -0.11436814f, 0.00214110f, 0.07683024f, -0.10896303f, 0.09037503f, 
    0.06397221f, 0.02893359f, 0.10405812f, 0.06438862f, -0.09920029f, 0.07803020f, -0.06228029f, -0.08991080f, 
    -0.05124608f, 0.08893925f, 0.10435220f, -0.10461159f, 0.00370470f, -0.11361571f, -0.06223331f, -0.03434243f, 
    -0.04921744f, -0.04271397f, -0.06022113f, -0.01456444f, -0.08077651f, -0.08158806f, -0.06022551f, -0.01311039f, 
    0.01113178f, -0.09484247f, -0.04364586f, 0.02800435f, -0.04172366f, 0.05904306f, -0.08115504f, 0.09899537f, 
    -0.08227462f, -0.01913279f, -0.02183042f, 0.10861223f, -0.11995551f, -0.02265437f, 0.10147902f, -0.01346675f, 
    -0.11077638f, 0.00473640f, -0.08465385f, 0.01074592f, 0.00385338f, 0.04651012f, 0.01383110f, 0.00310813f, 
    0.23404922f, 0.05037625f, -0.10757522f, -0.09216288f, -0.10058552f, 0.25712559f, 0.00735580f, 0.10702551f, 
    0.08076967f, -0.29046908f, -0.07055232f, -0.09653135f, -0.07674779f, 0.00916606f, 0.10598803f, 0.04086861f, 
    0.08706214f, 0.08598428f, -0.01201892f, 0.07883795f, 0.11730791f, 0.15345313f, 0.18073051f, -0.04356924f, 
    0.04095976f, 0.05123046f, -0.34098950f, -0.05611546f, 0.01723255f, 0.12265222f, -0.17990445f, -0.05838856f, 
    -0.14562906f, 0.05637594f, -0.21410330f, 0.09264103f, -0.10912138f, 0.00766554f, 0.00381648f, 0.21568772f, 
    0.30385458f, -0.13425577f, 0.15890361f, 0.05448302f, 0.15385896f, 0.08641342f, 0.01973138f, 0.15954557f, 
    0.06121455f, -0.06154996f, 0.19499157f, 0.44106969f, 0.11227417f, -0.11249756f, -0.26964146f, -0.02288872f, 
    0.06220375f, 0.13762172f, 0.22246033f, -0.04634586f, -0.04610587f, 0.01038070f, 0.27691972f, -0.10069320f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.06300749f, -0.03822592f, 0.12197899f, 0.07971010f, 0.04768924f, 0.05852590f, 0.02346294f, 0.18677166f, 
    0.13296896f, 0.02237931f, 0.16667531f, -0.06408114f, -0.02294621f, -0.00184595f, 0.00092550f, 0.02950153f, 
    0.01503043f, -0.01872760f, 0.03926283f, 0.10858002f, -0.06322350f, -0.00025536f, 0.22217351f, -0.02802597f, 
    0.16095017f, 0.19072849f, -0.09038991f, -0.05527713f, 0.01591433f, 0.01501813f, -0.03105970f, -0.00302919f, 
    -0.05376734f, -0.03733982f, -0.01973137f, 0.12882088f, 0.08309191f, 0.07271960f, 0.24967243f, -0.13165000f, 
    -0.04651757f, -0.00745375f, -0.00226988f, 0.14597432f, 0.01166285f, 0.11184423f, 0.15500776f, 0.01132667f, 
    -0.00496669f, 0.05266425f, -0.01834404f, 0.11478008f, 0.11183024f, 0.05592945f, -0.00312542f, 0.14503917f, 
    -0.00025150f, -0.13519455f, -0.05174907f, 0.11608374f, 0.09765413f, -0.03056686f, 0.04009877f, 0.00362266f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.14669687f, 0.11785307f, -0.18745635f, -0.33509424f, -0.30990836f, 0.29372638f, -0.35376906f, -0.57249081f, 
    -0.16738315f, -0.05982342f, -0.54934067f, -0.09832190f, 0.08670592f, -0.00419615f, -0.06723789f, 0.18954392f, 
    0.02003279f, 0.31915680f, -0.55626941f, 0.10788929f, -0.19150643f, -0.60231894f, 0.09997919f, -0.25646412f, 
    0.14108147f, -0.35949844f, 0.04687734f, -0.42158169f, 0.30644655f, -0.29300481f, -0.47216821f, 0.15517353f, 
    0.02758728f, 0.20405361f, -0.11763939f, 0.10411934f, -0.05553332f, -0.08939752f, -0.15461594f, 0.09185965f, 
    -0.12157199f, 0.30716160f, -0.06591456f, -0.23939283f, -0.22203465f, 0.01364273f, 0.29348278f, -0.21406341f, 
    0.23606905f, -0.00412892f, 0.05336969f, 0.18163684f, 0.10785066f, 0.03018443f, 0.08422526f, -0.21704702f, 
    -0.09606631f, -0.07497851f, -0.56124502f, -0.09465102f, -0.18295702f, 0.07066809f, -0.01091516f, 0.22135238f, 
    -0.51238644f, -0.08645751f, 0.07727548f, -0.26044264f, 0.34326679f, -0.16099115f, -0.07246540f, 0.10791079f, 
    -0.32382292f, 0.09991320f, 0.34675956f, 0.09875866f, -0.05657278f, -0.08986711f, -0.00489136f, -0.19250587f, 
    -0.02325433f, 0.19621152f, -0.27134380f, -0.16319263f, 0.03064363f, -0.55655849f, 0.15776293f, -0.03933766f, 
    0.13254325f, -0.26926669f, -0.10791060f, 0.00723308f, 0.03711925f, -0.12048068f, 0.41370994f, 0.24591890f, 
    -0.20920584f, -0.02805363f, -0.08529303f, 0.18070269f, 0.01315902f, 0.08448455f, -0.02187423f, 0.01356791f, 
    0.08152649f, -0.12904075f, -0.05649410f, -0.10621615f, -0.13685954f, -0.01670819f, 0.19765902f, 0.15330610f, 
    0.05710945f, -0.31707311f, 0.03542192f, -0.04993111f, 0.09752385f, 0.22456403f, 0.00692811f, 0.19493115f, 
    -0.32599375f, 0.00112328f, -0.11266030f, 0.26930156f, 0.08063046f, -0.41549346f, 0.02181549f, 0.05759806f, 
    -0.08866151f, 0.04477871f, 0.24287814f, 0.02718500f, 0.06030415f, -0.11736084f, -0.29742453f, -0.10644000f, 
    -0.11304896f, 0.16564129f, -0.57410902f, 0.06519821f, 0.06882983f, -0.01423938f, -0.01163644f, 0.10489894f, 
    0.05904286f, -0.31072444f, 0.21132249f, 0.26537025f, -0.55251050f, 0.20749295f, 0.03538355f, -0.40586540f, 
    -0.08972757f, -0.10437326f, 0.02428982f, -0.19498882f, -0.16475445f, -0.19653745f, -0.33870512f, 0.21607117f, 
    0.02163495f, 0.02447312f, 0.33674008f, 0.07173816f, 0.00988144f, 0.27869788f, -0.21414001f, -0.06991972f, 
    0.27314311f, 0.08381965f, 0.07569921f, 0.34052187f, -0.55365193f, 0.08843716f, -0.02944156f, 0.20287831f, 
    -0.05982627f, 0.01190522f, 0.05680294f, -0.18102686f, 0.15751374f, -0.17728879f, 0.06728747f, -0.13668834f, 
    -0.09631971f, 0.05028050f, -0.11267488f, -0.26507479f, -0.12762746f, -0.42416617f, 0.06873573f, -0.58692187f, 
    0.29584840f, -0.10984880f, -0.54826874f, 0.04049631f, -0.24136679f, 0.08847862f, 0.07141415f, 0.07111197f, 
    -0.02086358f, -0.49889567f, 0.05471276f, -0.07680834f, 0.03899628f, 0.05557784f, -0.00555732f, 0.08487913f, 
    -0.02294852f, -0.35851383f, -0.09601290f, 0.12241393f, 0.04487997f, 0.10995687f, 0.10339004f, -0.07714427f, 
    0.01103834f, 0.06056994f, -0.07366662f, 0.23303591f, 0.20978034f, -0.18458621f, 0.22343622f, 0.08435775f, 
    -0.21957135f, 0.00670896f, -0.34680277f, -0.28466496f, -0.23970330f, 0.22232120f, -0.01311990f, -0.07851145f, 
    -0.22466269f, 0.17283012f, -0.01282782f, 0.22787718f, -0.04479155f, 0.00012631f, 0.11477592f, -0.40579534f, 
    -0.25074616f, 0.29294136f, -0.27762261f, -0.28199360f, -0.10272905f, -0.11691365f, -0.08849170f, -0.53496039f, 
    -0.22085428f, 0.06352067f, 0.10007799f, 0.08239914f, 0.05617568f, -0.35731661f, -0.13819264f, 0.09460715f, 
    0.28697681f, -0.10734855f, -0.35927618f, 0.01779051f, 0.06462383f, 0.12670441f, -0.00567547f, -0.28195789f, 
    0.08618956f, -0.43691057f, 0.02691897f, 0.03166489f, -0.11446968f, -0.00450054f, 0.07857934f, -0.15621895f, 
    -0.00953518f, -0.35168824f, -0.17561129f, -0.32342550f, -0.25790697f, -0.01561894f, -0.17011072f, 0.15805851f, 
    -0.18430261f, -0.03220954f, -0.07212582f, 0.15232347f, -0.08540687f, 0.06536906f, -0.01046895f, 0.07688451f, 
    -0.13157347f, 0.14601590f, 0.43203193f, -0.15171361f, 0.06800073f, -0.28833336f, -0.07128529f, -0.02937381f, 
    0.12449560f, 0.17602956f, -0.00389855f, 0.09822371f, -0.03220862f, 0.04281770f, -0.06251813f, -0.27319428f, 
    0.19227846f, -0.06211057f, -0.02121828f, 0.22461081f, 0.06117864f, 0.16321611f, -0.11164313f, 0.08392454f, 
    0.25642401f, -0.06360335f, 0.17659241f, -0.02076509f, 0.32508263f, 0.24766256f, -0.10775903f, 0.33109039f, 
    -0.33829519f, -0.06028990f, -0.14498851f, -0.04659748f, -0.23714100f, -0.09667891f, -0.23958765f, -0.21631046f, 
    0.05077653f, 0.13697672f, -0.07226746f, -0.15775046f, 0.01453081f, 0.02012786f, 0.02182053f, -0.00150320f, 
    0.05633107f, 0.10174902f, -0.02455328f, -0.28102359f, 0.01914116f, -0.06022387f, 0.11464298f, 0.27093595f, 
    -0.19551964f, -0.38130140f, -0.02372980f, -0.40986592f, 0.08584633f, 0.06184942f, -0.14055818f, -0.01463275f, 
    0.18359466f, -0.06776775f, -0.18058312f, -0.18515134f, -0.04217633f, -0.37169373f, 0.26918089f, -0.11397968f, 
    -0.35244873f, 0.08460244f, -0.05917250f, -0.62215567f, 0.13638106f, -0.09669153f, 0.17078504f, 0.20933361f, 
    0.18242119f, 0.23402718f, 0.04257060f, 0.05123556f, -0.10658616f, -0.45232719f, -0.08546655f, 0.30161867f, 
    0.20457438f, -0.09341031f, -0.23654801f, 0.18728612f, 0.16173805f, 0.20225640f, -0.05890931f, -0.12531678f, 
    0.23881245f, 0.09278361f, 0.22251269f, -0.30577832f, -0.23124827f, 0.05678401f, 0.32071903f, -0.11519279f, 
    0.02696268f, -0.09639520f, -0.32594013f, 0.02293858f, -0.06038882f, -0.12825704f, -0.03891551f, -0.09823690f, 
    -0.01329075f, -0.09780473f, -0.20348774f, 0.07088577f, 0.30545688f, 0.14038911f, -0.05250053f, 0.00522366f, 
    -0.36874565f, 0.10525792f, 0.05671889f, -0.45946547f, -0.37379280f, 0.32797310f, -0.07217518f, 0.02475099f, 
    -0.26727504f, 0.01248870f, -0.24086739f, 0.18992437f, -0.09601644f, -0.33631423f, 0.04988063f, 0.02581319f, 
    -0.25278291f, -0.46419173f, -0.06632943f, 0.24975696f, 0.18512370f, 0.05676723f, -0.03378696f, -0.08870328f, 
    -0.30030724f, 0.20463289f, -0.07512208f, 0.17928244f, 0.25218517f, 0.23236607f, 0.03675189f, 0.18517578f, 
    -0.26188475f, 0.11492296f, -0.19188918f, 0.07690790f, 0.06984332f, -0.19087723f, -0.06659146f, -0.68199980f, 
    0.02918748f, -0.05436171f, 0.06507227f, 0.05339490f, 0.09179725f, -0.13540195f, 0.16486135f, -0.16269043f, 
    -0.12929638f, -0.10335579f, 0.14240573f, -0.03743694f, -0.07282459f, -0.11588977f, -0.06746117f, -0.04505388f, 
    -0.03516863f, 0.22631067f, 0.28822029f, -0.16551182f, 0.27916163f, 0.09861898f, -0.67117602f, 0.06516519f, 
    -0.25581139f, 0.10258079f, 0.04293643f, -0.23450530f, 0.02549496f, -0.09753712f, 0.20261426f, -0.27634159f, 
    0.32429987f, -0.05864608f, 0.28642958f, -0.27472326f, -0.33476174f, -0.18791051f, -0.47835392f, 0.02884463f, 
    0.07736634f, 0.18974811f, -0.04981979f, 0.11354834f, 0.12202835f, 0.07024428f, -0.30575469f, 0.07368976f, 
    -0.09663992f, 0.17481622f, 0.19315554f, -0.06545019f, -0.36221606f, -0.08458629f, -0.11839461f, -0.28387627f, 
    0.18299191f, 0.01760701f, 0.25562543f, -0.25192487f, -0.17879665f, 0.02292991f, -0.10027159f, 0.16947968f, 
    -0.23498566f, -0.08332133f, -0.04614482f, 0.25824079f, 0.18521932f, -0.52966940f, -0.20559084f, -0.16010109f, 
    -0.42877862f, 0.19035801f, 0.05090829f, -0.03938266f, 0.04354933f, -0.07193070f, 0.04262338f, -0.27574438f, 
    -0.02786434f, 0.14772806f, 0.23711206f, 0.18249819f, -0.17855504f, -0.00495499f, -0.21849217f, -0.19501466f, 
    0.20076567f, 0.02936603f, -0.00500816f, 0.52252865f, 0.07153588f, 0.11439709f, -0.11159997f, 0.15288225f, 
    -0.20433693f, -0.38840190f, 0.18491748f, 0.01755789f, -0.46350154f, 0.11419699f, 0.15133329f, -0.00426038f, 
    0.07983686f, 0.09120803f, -0.09979872f, -0.28206572f, -0.14235598f, -0.05866880f, -0.28858611f, 0.11224695f, 
    -0.19730175f, 0.01367966f, -0.33193433f, -0.37086594f, -0.12934028f, 0.28076312f, -0.01472553f, 0.06953909f, 
    0.05233044f, -0.07919730f, 0.12844479f, 0.17799085f, 0.15082113f, -0.06342161f, -0.04116432f, -0.02731040f, 
    -0.05600563f, -0.00997822f, 0.32145551f, -0.20482208f, -0.37388447f, -0.20375712f, -0.02541802f, -0.28567895f, 
    0.25427747f, 0.21631204f, -0.10265435f, -0.06675653f, 0.05051114f, -0.17058587f, -0.02487515f, 0.03133836f, 
    -0.12110209f, -0.04897374f, 0.18260406f, 0.15748402f, -0.15662692f, 0.27097559f, -0.01970013f, 0.25297770f, 
    -0.35372680f, 0.04208707f, 0.01235542f, 0.06678530f, -0.41475895f, -0.20086262f, -0.41732943f, -0.01185820f, 
    0.41343892f, 0.02152781f, -0.69308496f, 0.08504895f, 0.31392244f, -0.07858270f, -0.26241007f, -0.13862228f, 
    0.13336663f, -0.36795345f, 0.07643478f, 0.17159264f, 0.01933479f, 0.05283118f, -0.15912387f, -0.25351480f, 
    0.21714881f, -0.20574619f, 0.03966830f, 0.02037875f, 0.06575532f, -0.24693757f, 0.03079840f, 0.09344233f, 
    0.08680727f, 0.03234303f, -0.06585474f, -0.57389075f, -0.09606779f, 0.27034971f, -0.00069582f, 0.12164489f, 
    -0.26777416f, -0.09642822f, -0.03776144f, 0.19716592f, 0.30150300f, 0.24384652f, 0.21099696f, 0.26258877f, 
    0.03302701f, 0.05969720f, -0.10000294f, 0.05367585f, 0.10214528f, -0.10677170f, 0.06214350f, -0.08732972f, 
    -0.10158053f, -0.04419805f, 0.06783323f, -0.28289375f, 0.00895647f, -0.02909818f, 0.16303441f, 0.32924205f, 
    0.33923945f, 0.33902878f, 0.09467429f, -0.38790524f, -0.12319787f, -0.31859839f, -0.16672520f, -0.45214197f, 
    -0.27048594f, -0.37672612f, 0.34495273f, -0.06321643f, 0.13803571f, 0.30064458f, 0.26072264f, 0.01626217f, 
    0.05448252f, 0.10892766f, -0.10781006f, 0.06054526f, 0.00679924f, -0.10424053f, -0.16662472f, 0.02376026f, 
    -0.39332625f, -0.19021867f, 0.28249213f, 0.00752144f, -0.47374085f, -0.23860402f, 0.06741112f, -0.29314271f, 
    0.09167802f, 0.06205305f, 0.15861215f, -0.09917887f, -0.33729830f, -0.07864060f, 0.04510261f, -0.09166697f, 
    0.03973844f, 0.02201792f, -0.39519608f, -0.12015128f, -0.22237355f, -0.21075690f, 0.14897691f, 0.33130589f, 
    0.21667463f, 0.15460557f, 0.25748384f, -0.11021840f, 0.00551646f, -0.13111128f, 0.05655126f, 0.24079612f, 
    -0.01720594f, 0.12191481f, -0.30722752f, 0.17233950f, -0.14398420f, 0.07635541f, 0.10266659f, -0.47629207f, 
    -0.08132108f, -0.09451496f, -0.00406297f, 0.15760452f, 0.12905288f, 0.24849576f, -0.19322541f, -0.41682258f, 
    0.10119453f, 0.23040619f, -0.36229599f, -0.18630877f, 0.18527353f, -0.26021171f, 0.15643680f, -0.06625942f, 
    -0.49710125f, 0.03564298f, 0.01735029f, -0.07884890f, 0.04154740f, -0.14192921f, -0.18939874f, -0.06374271f, 
    -0.04113907f, -0.21659039f, 0.00767899f, -0.35904524f, 0.14822510f, 0.24616598f, -0.09480780f, -0.39391407f, 
    -0.10965965f, 0.03147723f, -0.07187335f, 0.09980483f, 0.09834297f, -0.09887703f, -0.05840826f, 0.08258520f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.04981617f, 0.00240917f, 0.00856379f, 0.09345755f, -0.15060534f, -0.02460723f, -0.01033888f, -0.10270666f, 
    -0.00573716f, 0.01214784f, 0.17826842f, -0.01328681f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
