#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.60393375f, 0.66046965f, 0.40639713f, 0.27286047f, 0.12168986f, -0.24608745f, -0.09639338f, -0.30061874f, 
    -0.25968739f, -0.89355373f, 0.48420459f, -0.05167672f, 0.92500955f, -0.20925912f, -0.47102481f, -0.11775368f, 
    -0.08314668f, 0.20492047f, 0.53605080f, 0.77993190f, 0.57686949f, -0.35146683f, -0.10701091f, 0.00768578f, 
    0.16659360f, -0.03804071f, 0.05049667f, -0.75880718f, -0.48906827f, -0.33502707f, -0.49575236f, -0.27810863f, 
    -0.89483029f, -0.19288576f, -0.69662309f, -0.49377033f, 0.56298625f, -0.30015862f, 0.06142658f, -0.14903288f, 
    -0.31901330f, -0.20481658f, 0.29075623f, 0.43489000f, 0.14431974f, 1.20410013f, -0.74178559f, -0.89270842f, 
    0.62561017f, 0.95288074f, -0.15957394f, -0.45228732f, -0.07407267f, -0.17160286f, -1.08962214f, -0.41106126f, 
    0.12996304f, -0.17225051f, -0.20074348f, 0.16722752f, 0.45686755f, -0.05269876f, 0.66133666f, -0.76654518f, 
    0.65466464f, 0.16263650f, -0.35756174f, 1.16950607f, -0.78089786f, -0.33783093f, -0.25934434f, -0.15938009f, 
    -1.09409726f, -0.19013697f, 0.01795422f, -0.62071592f, -0.79417723f, 0.57443130f, 0.15110499f, -0.47351620f, 
    -0.39233002f, 0.63879490f, 0.60355639f, 0.18092123f, -0.41300103f, 0.18516555f, -0.27751005f, -0.72354078f, 
    -0.14329426f, -0.58814365f, -0.93137223f, -0.67182100f, -0.49018186f, 1.29733431f, -0.93109745f, -0.53558213f, 
    -0.44483811f, 0.08193079f, 0.06122123f, -0.21037376f, -0.30861342f, -0.36514857f, 0.28206602f, 0.18062435f, 
    -0.48192674f, 0.55970621f, 0.45017239f, 0.06686435f, -0.57692033f, 0.25191286f, 0.54406404f, -0.09716432f, 
    0.49128771f, -0.51850003f, -0.37124833f, 0.18208307f, 0.28628016f, -1.00508547f, -1.12305200f, -0.63219512f, 
    0.57251912f, 0.65794241f, 0.20325778f, 0.10255274f, -0.04810242f, 0.15555996f, 0.14681447f, -1.17595899f, 
    0.27622965f, 0.24330790f, -0.36016214f, -0.62291133f, -0.38005710f, -0.22180986f, -0.43843988f, -0.94295967f, 
    -0.55008531f, -0.25603974f, -0.31345668f, 0.04153656f, 0.05410964f, 0.24149975f, -0.53386104f, -0.76239520f, 
    -0.92262542f, -0.33400601f, 0.68054533f, -0.24187590f, 0.35183242f, 0.01722744f, -0.66682333f, 0.09110461f, 
    0.57049644f, 0.93910992f, -0.42262274f, -0.03055735f, -0.14985681f, 0.12762929f, 0.10730904f, -0.67333680f, 
    0.43143785f, 0.15595601f, 0.41970542f, -0.35393646f, 0.41578764f, 0.33886740f, 0.28623676f, 0.53928709f, 
    0.08520947f, -0.15051197f, 0.23908287f, 0.04220161f, -0.94232512f, 0.63858563f, -0.06756217f, 0.63176066f, 
    0.32375774f, -0.23836480f, -0.72995603f, -0.20403162f, 0.27689907f, 0.05418054f, 0.20588189f, -0.68464756f, 
    -0.93724442f, -0.54162925f, -0.34047094f, -0.55189258f, -0.38814920f, -0.90935415f, -0.42583108f, -0.05981100f, 
    -0.20664202f, -0.45619461f, -0.49350992f, 0.64941204f, -0.02772755f, 0.28457832f, -0.45247760f, -0.83422583f, 
    -0.16703385f, -0.92235231f, -0.99224728f, -1.09856057f, 0.26227093f, -0.03411420f, 0.63975018f, -1.10792816f, 
    0.33013031f, 0.14271526f, 0.30435365f, 0.70136768f, 0.58114886f, -0.16402993f, -0.30484164f, -0.50934297f, 
    -0.71595490f, 0.89631963f, -0.19099845f, -0.92509109f, -0.72545677f, -0.35968822f, -0.41654006f, -0.01979823f, 
    -0.75396025f, -1.13353634f, -0.93109030f, 1.13338637f, 0.02294015f, 0.50503814f, -0.07615561f, 0.22881675f, 
    0.00113599f, -0.35375884f, 0.30902651f, -0.46802950f, -0.79970258f, 0.74687308f, 0.10739846f, -0.06768497f, 
    -0.07599371f, 0.61516035f, -0.34556824f, -0.27005294f, -1.20771122f, -0.63782394f, 0.76908422f, 0.69345027f, 
    0.44005510f, 0.19863810f, -0.33287090f, -0.14515030f, 1.48784006f, -0.05614118f, -1.01317310f, 0.15235420f, 
    -0.62544221f, -0.84249389f, -0.19671898f, 0.26537728f, -0.48214865f, 0.47836983f, 0.54104209f, -0.74818999f, 
    -0.49244872f, 0.14715783f, 0.34219331f, -0.15588123f, 0.02896413f, 0.22617383f, 0.45479816f, 0.88949692f, 
    0.40678602f, -1.06301630f, -0.81275940f, -0.28268030f, 0.07436731f, 0.46634367f, 0.19027579f, 0.32560065f, 
    0.35878479f, 0.37032413f, -0.66521996f, 0.77095807f, -0.50409430f, -0.01970899f, 0.37156686f, 0.29323161f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08157842f, 0.02146791f, -0.03262145f, -0.42416042f, 0.18958804f, 0.19915834f, 0.19672796f, -0.09449182f, 
    0.20184477f, -0.00515446f, 0.15976082f, 0.19872457f, 0.36073059f, -0.01239191f, 0.39015478f, 0.18638271f, 
    0.38672015f, 0.28660157f, 0.11087015f, -0.04786171f, -0.08686204f, 0.38711005f, 0.33650813f, 0.26344612f, 
    -0.23310065f, -0.18617274f, 0.30422491f, 0.24779974f, 0.01533902f, 0.30909866f, 0.19251324f, 0.03120623f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.17152956f, -0.23753330f, -0.22160318f, 0.00772916f, 0.20913067f, 0.03552916f, -0.00107323f, -0.01452174f, 
    0.01691087f, 0.07553986f, 0.00715343f, 0.01237518f, 0.02338661f, 0.07151078f, 0.06348906f, 0.01706375f, 
    -0.05303167f, -0.11923960f, 0.02633908f, -0.02515519f, 0.13194035f, 0.31758800f, -0.76264840f, -0.25674111f, 
    -0.00218198f, -0.22488861f, 0.14682887f, -0.10162985f, 0.07877111f, -0.18416560f, 0.06192230f, -0.15967588f, 
    0.12484122f, -0.02451812f, 0.13816537f, -0.21649139f, 0.11325204f, -0.02631371f, -0.05366766f, -0.01202128f, 
    -0.12521636f, -0.15236144f, -0.07387666f, 0.05050439f, 0.08372317f, 0.08518772f, 0.01915809f, -0.02219213f, 
    0.00039836f, 0.03022827f, 0.05223717f, 0.08447758f, -0.01227520f, 0.03592226f, 0.10155349f, 0.04857323f, 
    0.00165817f, -0.14768682f, -0.00056173f, -0.02835554f, 0.51513928f, 0.29140714f, 0.15554400f, -0.35390326f, 
    0.02063307f, 0.28160086f, 0.29001197f, 0.20187068f, 0.06818262f, 0.11438228f, -0.00371406f, -0.03881386f, 
    -0.01407124f, -0.12448224f, -0.11398771f, -0.07949095f, -0.23504472f, -0.11668055f, 0.04182610f, 0.12891713f, 
    0.07720280f, 0.01162273f, -0.02172791f, -0.00847418f, 0.00003441f, -0.11545350f, 0.02875490f, -0.11258700f, 
    0.04472448f, -0.02280102f, -0.11127713f, 0.05133604f, -0.01171357f, -0.05008049f, -0.09226565f, -0.12904339f, 
    -0.07708822f, -0.06344191f, -0.14244805f, -0.00457783f, 0.06835002f, -0.53196913f, -0.74787498f, 0.15513341f, 
    -0.16609135f, 0.00664489f, -0.08771016f, 0.06719983f, -0.03568567f, 0.12010942f, -0.07413509f, 0.00751260f, 
    -0.22229561f, -0.07820063f, -0.07609165f, -0.04026958f, 0.13718866f, 0.08927397f, -0.09056228f, 0.04136258f, 
    0.25335780f, 0.30727875f, 0.19967775f, -0.29322833f, 0.02940567f, 0.07140905f, 0.09113507f, 0.15122509f, 
    0.03366415f, -0.20387724f, -0.03215260f, -0.21109301f, -0.11160818f, -0.05696172f, 0.05782821f, -0.01708680f, 
    -0.07931121f, -0.00381948f, 0.00552471f, -0.01078758f, 0.09363469f, 0.15534922f, 0.04185798f, -0.03970604f, 
    -0.09877379f, -0.07915254f, -0.12630190f, -0.05001233f, 0.10158504f, 0.03219054f, 0.10112237f, 0.06107258f, 
    0.01805701f, 0.12626420f, -0.06308741f, -0.13379206f, -0.20328079f, -0.06876010f, -0.32685310f, 0.00088617f, 
    0.25178069f, 0.21406446f, 0.30634931f, -0.29263568f, -0.05029028f, 0.00939144f, 0.26414579f, 0.03138342f, 
    0.08745965f, -0.09979542f, 0.02645896f, -0.07334240f, -0.03598705f, -0.13988632f, -0.05291329f, 0.01738642f, 
    -0.04867964f, -0.03882360f, -0.24351612f, 0.02338814f, -0.31344023f, 0.32247660f, 0.13174382f, 0.09904611f, 
    -0.15279000f, 0.06152503f, 0.01173738f, -0.06725627f, 0.01602782f, 0.07092183f, 0.03321071f, 0.01896233f, 
    -0.00659047f, 0.01896972f, 0.04526205f, 0.12681174f, 0.17001553f, 0.01315705f, 0.04314557f, 0.01772856f, 
    0.46603340f, 0.37076053f, -0.15620057f, -0.41695514f, -0.09132811f, -0.14179899f, 0.07207512f, 0.00927225f, 
    -0.24450006f, 0.09466924f, 0.00530435f, -0.00393010f, 0.03964245f, -0.04320365f, 0.07808255f, -0.04803029f, 
    0.02685856f, 0.00068901f, -0.14562541f, 0.01917665f, 0.09517652f, 0.15359826f, -0.09326088f, 0.01593854f, 
    0.01325193f, 0.01347817f, 0.05067644f, 0.02351850f, -0.03688472f, 0.00338799f, -0.05014943f, -0.10930593f, 
    -0.13445754f, 0.00468897f, -0.02201691f, -0.04119275f, -0.05139756f, -0.07593554f, 0.00899717f, -0.00628677f, 
    -0.25543413f, -0.28298628f, -0.04419424f, 0.02773916f, -0.05807136f, -0.08267750f, -0.19598109f, 0.02713764f, 
    0.01906964f, -0.09273006f, -0.06985987f, -0.02705065f, -0.08831353f, -0.25065589f, -0.14286096f, -0.15668038f, 
    -0.18793236f, -0.00998037f, -0.03530106f, -0.08934328f, 0.41385531f, 0.25306970f, -0.38480771f, -0.10895673f, 
    0.01301656f, 0.28673112f, 0.14770600f, 0.24811237f, -0.05862948f, 0.04524283f, -0.00415930f, -0.07013064f, 
    -0.12177071f, 0.04332716f, 0.07011259f, 0.03696368f, 0.07260367f, 0.03871083f, 0.01157803f, 0.01813511f, 
    0.30121943f, 0.02128765f, -0.09468727f, -0.35090521f, 0.04823946f, 0.12447531f, -0.07285490f, 0.16261235f, 
    -0.17541054f, 0.04026904f, -0.00266920f, 0.01509329f, -0.01083850f, -0.10790091f, -0.22384802f, 0.05115433f, 
    -0.06509285f, 0.05344456f, -0.06828493f, 0.09672630f, 0.35193089f, 0.21809377f, 0.18652843f, -0.23538208f, 
    -0.06307399f, 0.12267499f, 0.16673207f, 0.02081890f, 0.09397225f, 0.00379862f, -0.02319997f, -0.00642119f, 
    -0.02603365f, -0.04729252f, 0.02995017f, 0.07675299f, -0.11286824f, -0.10556944f, -0.12304600f, 0.03602692f, 
    -0.06967348f, 0.00068745f, 0.11809248f, -0.11310468f, -0.00092943f, -0.11096722f, -0.02457284f, 0.05974938f, 
    -0.04859282f, -0.15681170f, -0.27164912f, -0.11622560f, -0.10790285f, -0.16665180f, -0.07066794f, -0.12033807f, 
    0.02305227f, -0.02716070f, -0.00864744f, -0.08249777f, -0.99635857f, -0.40042913f, 0.27151003f, 0.01306976f, 
    -0.32204145f, -0.06903850f, 0.06442892f, -0.07349122f, -0.14840412f, -0.03797286f, 0.00448647f, 0.03254816f, 
    -0.09039617f, -0.13051960f, -0.02496150f, -0.27159640f, 0.04620173f, -0.16479354f, -0.08097565f, -0.02317483f, 
    -0.00421432f, -0.06022428f, -0.01324230f, 0.03793975f, 0.02153776f, -0.00745044f, -0.00754678f, 0.00684411f, 
    0.02001739f, 0.06973542f, -0.05256520f, -0.29626796f, -0.14489394f, -0.13954286f, -0.12951834f, -0.10940192f, 
    0.04141177f, 0.02591889f, -0.00248646f, -0.04493224f, 0.40260041f, -0.77092856f, 0.18344815f, -0.08866555f, 
    -0.04469529f, -0.01704652f, -0.08018720f, 0.10033973f, 0.05980663f, 0.03513817f, 0.13824309f, 0.14102064f, 
    -0.06100182f, 0.13137655f, -0.01162267f, -0.22566971f, 0.08904082f, 0.03286592f, 0.05973421f, 0.04986395f, 
    0.01861379f, 0.35250920f, 0.24319729f, -0.33020353f, -0.11767942f, -0.01392799f, -0.05002938f, -0.11342058f, 
    -0.11794074f, 0.00364239f, 0.00468255f, -0.08577652f, -0.01422543f, 0.01700638f, -0.00519869f, 0.11573277f, 
    0.01419504f, 0.16808042f, 0.08631884f, 0.03134272f, 0.36194009f, 0.36144695f, 0.15702759f, -0.40533975f, 
    -0.06243832f, 0.02064119f, 0.05766152f, -0.04406549f, 0.03367854f, -0.14982942f, 0.07358614f, -0.09804747f, 
    -0.06785495f, -0.00966185f, 0.02610876f, -0.00069082f, -0.01149863f, -0.02808564f, -0.02089055f, -0.08292730f, 
    0.30605528f, 0.35126069f, 0.01300672f, -0.47718859f, -0.24022387f, 0.05637671f, 0.04622631f, -0.02814914f, 
    -0.01115691f, 0.02498638f, 0.05524855f, -0.02571998f, -0.04641711f, 0.03717509f, 0.01466421f, -0.03090826f, 
    -0.06892210f, 0.03101229f, 0.07999024f, -0.11395339f, -0.17186600f, -0.42923766f, -0.02485216f, -0.08590466f, 
    -0.10691208f, -0.05263383f, -0.00037961f, 0.05499143f, 0.13455087f, 0.02276196f, -0.07098244f, 0.11551170f, 
    -0.01216501f, 0.03151149f, -0.08973130f, 0.08799785f, 0.05109455f, 0.09607458f, -0.02213350f, -0.02865815f, 
    -0.10251164f, 0.39246377f, 0.12786995f, -0.31049958f, -0.31971985f, -0.07186864f, 0.17274511f, -0.03915749f, 
    -0.00021665f, 0.04824295f, 0.05226168f, -0.08267514f, -0.05247189f, -0.00847584f, -0.00216584f, -0.12333094f, 
    0.01377067f, 0.00280138f, -0.09234755f, 0.25749335f, 0.41762134f, -0.15443364f, 0.15593299f, -0.43656158f, 
    0.11626802f, -0.03258821f, 0.09261194f, 0.22669691f, 0.09264847f, -0.01632179f, 0.06086662f, -0.08839833f, 
    -0.21178174f, 0.03353747f, -0.05223272f, 0.07159073f, 0.05805101f, 0.00370297f, 0.02706068f, 0.04320307f, 
    0.02535846f, -0.05484838f, -0.49155250f, 0.06509094f, 0.05376327f, 0.10156675f, 0.01848491f, -0.00386969f, 
    -0.17386232f, -0.09261513f, -0.22489947f, 0.02109229f, -0.03019664f, -0.09378133f, -0.08736419f, 0.00284363f, 
    0.05405597f, -0.06795622f, -0.09728768f, 0.05349511f, 0.27558067f, -0.28035337f, -0.56225681f, 0.00687863f, 
    -0.00052188f, 0.13058893f, 0.04754691f, 0.07470118f, -0.02490053f, 0.15949236f, -0.00145700f, 0.03922798f, 
    -0.10833844f, -0.10417242f, -0.01550225f, 0.08866249f, 0.08158275f, 0.03261033f, 0.01384315f, 0.03802543f, 
    -0.03657977f, 0.18393670f, -0.42524239f, -0.08981515f, -0.31716171f, -0.07487417f, -0.03322376f, -0.02242763f, 
    0.02353462f, 0.14180063f, -0.11261112f, -0.02179832f, -0.03177745f, 0.03875159f, 0.04392729f, -0.05862178f, 
    -0.01198800f, 0.13384522f, -0.01642470f, 0.20685254f, -0.55559188f, -0.23502642f, -0.10244700f, 0.10259555f, 
    -0.30524409f, -0.08391290f, -0.06701187f, -0.13871558f, -0.04666418f, 0.01411949f, 0.03152810f, -0.07736550f, 
    -0.28895086f, -0.03563591f, 0.14836711f, 0.01177022f, -0.00561727f, -0.05662702f, -0.08772388f, -0.16322494f, 
    -0.01208320f, 0.10695256f, -0.08838610f, -0.21922049f, -0.21454959f, -0.06362167f, -0.04693715f, -0.30421987f, 
    -0.08298052f, -0.15850684f, 0.03320323f, 0.02040263f, -0.03044441f, 0.06226845f, 0.03747214f, -0.00217946f, 
    0.07823910f, 0.07404160f, -0.11617237f, -0.04107210f, -0.04821252f, -0.00487640f, -0.03419581f, 0.13624610f, 
    -0.00802474f, -0.01424141f, -0.05922727f, 0.01461703f, 0.00897376f, 0.04615322f, -0.04934282f, 0.07854170f, 
    0.05275376f, -0.00636232f, -0.04218890f, -0.11042325f, -0.07119834f, -0.07955438f, -0.16577473f, -0.03486529f, 
    0.29179364f, 0.13123463f, 0.02198700f, 0.13303271f, 0.19566515f, -0.00769868f, -0.01250867f, -0.04658311f, 
    -0.00106000f, -0.00912145f, -0.00233913f, 0.05120247f, -0.01140206f, -0.05656738f, 0.01144626f, 0.02993327f, 
    0.05994822f, 0.04712398f, 0.08474243f, -0.04607229f, -0.33414111f, 0.35025710f, -0.03567562f, 0.07649979f, 
    0.22634897f, 0.24661170f, 0.03876218f, -0.09006487f, 0.00543497f, -0.15451248f, -0.07899447f, 0.00973161f, 
    -0.07737592f, -0.13801584f, -0.10002365f, 0.09522076f, 0.00409556f, 0.00793733f, -0.02893214f, -0.19205381f, 
    0.20513499f, 0.10347765f, 0.07544941f, 0.03739523f, 0.13532159f, -0.00962896f, -0.06942911f, -0.03251525f, 
    -0.04506393f, -0.08746612f, -0.00975886f, 0.03405147f, -0.00471659f, 0.02947835f, -0.04313461f, 0.05862281f, 
    0.13761763f, -0.12360741f, 0.01714640f, -0.02159804f, 0.32194075f, 0.24475893f, 0.24280678f, 0.23188530f, 
    0.28753740f, 0.07573689f, -0.16006826f, -0.03774212f, 0.04885099f, 0.06930750f, 0.06893501f, 0.01671716f, 
    0.05422803f, -0.05051288f, 0.05126409f, -0.09290802f, 0.00738125f, 0.17563996f, -0.10537943f, -0.00068544f, 
    -0.01869525f, 0.01843446f, -0.03460640f, -0.04844444f, -0.00884409f, 0.01760245f, -0.01195312f, -0.05621088f, 
    0.01120943f, -0.00137565f, 0.08955586f, -0.02495948f, 0.00394997f, 0.11190922f, 0.06240604f, -0.07708933f, 
    -0.00929669f, -0.01947370f, 0.06128569f, -0.04261838f, 1.37836254f, -0.20216429f, -0.00581571f, 0.20276566f, 
    -0.13374443f, -0.01623871f, -0.02194455f, -0.05678719f, 0.01035445f, -0.05137217f, 0.11307899f, -0.19084369f, 
    0.05116895f, -0.04665227f, -0.11283240f, 0.11432224f, -0.07586233f, -0.27991834f, -0.00604252f, 0.07736043f, 
    -0.55646378f, -0.10676476f, -0.19778644f, -0.04819409f, 0.14866634f, -0.03188400f, 0.15592201f, 0.33342940f, 
    0.10144966f, -0.03959343f, -0.16172753f, 0.07289666f, 0.11852462f, 0.02481431f, 0.01251812f, -0.08468585f, 
    -0.00657767f, 0.01261525f, -0.07207236f, 0.03501606f, -0.13707945f, -1.35676861f, -0.25949636f, -0.60634565f, 
    0.26295301f, -0.08701540f, 0.05520846f, -0.06333397f, -0.09289194f, -0.01363779f, 0.00057304f, 0.03714886f, 
    -0.01544596f, -0.07944262f, 0.02078352f, -0.14435796f, -0.05553425f, -0.20656745f, -0.16746928f, -0.07855355f, 
    -0.42297477f, 0.15595998f, -0.08822049f, 0.08693548f, 0.22283944f, 0.10215591f, -0.08237657f, 0.26543593f, 
    -0.06372196f, -0.16960506f, -0.05904387f, 0.04784030f, -0.01350001f, -0.08754110f, 0.07786594f, 0.08126171f, 
    -0.03321780f, 0.11786199f, -0.06809498f, -0.05114560f, 0.49683151f, 0.00231160f, 0.07789131f, -0.11496237f, 
    0.12693529f, -0.00085802f, -0.04415190f, -0.02989133f, -0.01144039f, -0.02062755f, -0.05605596f, 0.04633180f, 
    -0.01352956f, -0.00892933f, 0.06099957f, -0.05885103f, -0.18045552f, -0.28420702f, 0.01062708f, -0.01201498f, 
    -0.02721477f, 0.40227181f, 0.05291218f, 0.06625641f, 0.09580504f, -0.00590433f, 0.17045237f, 0.00770354f, 
    0.34130609f, -0.19289196f, 0.03647105f, -0.06512422f, 0.04350691f, -0.10711672f, -0.10611568f, 0.05497013f, 
    0.09924901f, 0.00704722f, -0.08858745f, 0.07220685f, -0.00648878f, -0.09018745f, -0.14267930f, -0.00219248f, 
    -0.09103312f, -0.02004735f, 0.00226883f, 0.02320240f, 0.09280881f, -0.01611501f, -0.11011311f, 0.14476417f, 
    -0.07445165f, 0.04079342f, -0.01452695f, -0.05328231f, -0.03749046f, 0.05124836f, 0.01332794f, 0.00760413f, 
    0.02697552f, 0.04988687f, 0.09385125f, 0.02047743f, 0.24132314f, 0.03145526f, 0.02795481f, 0.02879968f, 
    0.00299315f, 0.09539952f, 0.04331153f, -0.07700523f, 0.08758903f, -0.00847282f, 0.09767003f, -0.14959466f, 
    0.12871525f, 0.08816347f, -0.08333190f, -0.00697475f, 0.19634178f, -0.12928508f, 0.04385450f, 0.02337972f, 
    -0.13945423f, -0.02510877f, 0.07584513f, 0.23428549f, -0.06319762f, -0.30311614f, 0.08803747f, -0.04663173f, 
    -0.01627750f, -0.05294894f, -0.03293068f, 0.02650154f, -0.05465064f, -0.00495504f, -0.05551779f, -0.00582618f, 
    -0.15021013f, 0.07286034f, -0.07588959f, 0.00354111f, 0.03744389f, 0.12680344f, 0.07668179f, -0.04336884f, 
    0.11866316f, 0.11205854f, 0.06640261f, -0.02032848f, 0.11551720f, 0.03518077f, 0.05135153f, -0.10450329f, 
    -0.14265725f, -0.32287714f, -0.27157348f, -0.07473752f, -0.09119688f, 0.09471866f, 0.17288071f, -0.02885815f, 
    0.06520379f, 0.12408083f, -0.08581667f, 0.14395761f, 0.08171363f, 0.10303587f, -0.01305877f, 0.01090186f, 
    0.00677984f, -0.10118572f, 0.03419841f, 0.17307025f, 0.01168494f, 0.00674614f, -0.12738320f, 0.02691332f, 
    -0.46098098f, -0.03479498f, 0.17508332f, 0.10458457f, 0.02850694f, 0.02658609f, 0.04697091f, 0.27013230f, 
    -0.01355048f, 0.14002377f, 0.19546919f, -0.00196034f, 0.13184622f, 0.14734341f, -0.04373361f, 0.05422758f, 
    0.14326294f, -0.01810992f, -0.04890699f, -0.07312386f, 0.77591622f, 0.20164390f, -0.07487980f, -0.07058834f, 
    -0.01043738f, -0.01751864f, 0.07341100f, -0.07284473f, -0.06369165f, 0.11561408f, -0.10944247f, 0.08329017f, 
    0.01521049f, 0.03326188f, -0.13223578f, -0.05010517f, 0.19623290f, 0.13962269f, 0.09143929f, 0.07316481f, 
    0.19619253f, 0.07124802f, 0.09702883f, 0.07234269f, 0.08741755f, -0.07802319f, -0.01119838f, -0.02744393f, 
    -0.06278306f, 0.00130371f, 0.04418716f, -0.00044805f, -0.04117796f, 0.04497105f, -0.01632920f, -0.08429480f, 
    -0.06930529f, -0.02147370f, -0.05840906f, -0.03091318f, -0.12019043f, -0.12132917f, 0.34661210f, 0.08127760f, 
    0.24910843f, -0.09421180f, -0.03258913f, 0.04305631f, -0.06748514f, 0.01934912f, -0.00698978f, -0.00452497f, 
    0.02140624f, 0.03937310f, -0.08758190f, 0.23013616f, -0.09562805f, -0.08556306f, 0.06880739f, -0.17967239f, 
    -0.28040931f, -0.01687249f, -0.50148576f, -0.39213228f, -0.31089559f, -0.03505140f, -0.11543757f, -0.12518676f, 
    0.03470169f, 0.00430883f, -0.02435729f, 0.05060897f, 0.03760684f, 0.01035910f, 0.04796018f, -0.03872659f, 
    -0.09623060f, -0.26026151f, -0.19505081f, -0.32258135f, -0.36719671f, 0.02709855f, -0.20165826f, 0.09362477f, 
    0.17336088f, 0.01855210f, 0.09861094f, 0.08907150f, 0.00821407f, -0.00067054f, -0.05938954f, 0.01290656f, 
    0.07305658f, 0.02450344f, 0.00995218f, -0.03390835f, -0.03954262f, 0.05048675f, -0.08069917f, 0.02043598f, 
    -0.30021384f, 0.21427889f, -0.18584822f, 0.14210622f, 0.09987772f, -0.10429545f, 0.01356303f, 0.10406193f, 
    0.01666577f, -0.04244826f, -0.03521503f, -0.06605276f, 0.06742366f, 0.04852010f, 0.05609835f, 0.01103928f, 
    0.05989280f, 0.11610377f, -0.19259159f, 0.15054013f, -0.08548832f, -0.24017030f, 0.26387385f, 0.09731902f, 
    0.04136515f, 0.01737430f, -0.04947672f, -0.01372564f, -0.07287674f, -0.01317689f, 0.11549056f, -0.02009937f, 
    -0.08971082f, -0.02297001f, 0.17410631f, 0.17466532f, -0.03648394f, -0.14134744f, 0.16344818f, -0.13551579f, 
    -0.44222304f, -0.16321996f, -0.27405429f, -0.23336983f, -0.23427890f, 0.08400574f, 0.10603033f, -0.38718179f, 
    0.01802737f, -0.10165042f, -0.00445283f, 0.06562429f, -0.02775363f, -0.00983970f, 0.07290687f, -0.16635935f, 
    -0.06656142f, 0.00834441f, -0.15283172f, -0.59091663f, 0.12313959f, -0.33933160f, -0.14704664f, -0.06015295f, 
    0.24247678f, -0.23675041f, 0.02503359f, -0.02192263f, 0.11181302f, 0.04425330f, 0.10658044f, 0.05245074f, 
    0.05162442f, 0.02476829f, -0.29648510f, -0.05873357f, -0.05931170f, -0.04485693f, 0.01247448f, -0.17506106f, 
    0.54989833f, -0.04983113f, -0.40391275f, -0.10037268f, -0.21788318f, -0.01947452f, -0.01518010f, -0.01157005f, 
    0.21094818f, 0.04936988f, 0.15403844f, 0.04872536f, -0.04327620f, -0.02375018f, 0.04639943f, -0.07509986f, 
    -0.04176320f, 0.00896238f, 0.07233357f, 0.07177749f, 0.28596362f, -0.22680326f, -0.03056456f, 0.01721257f, 
    -0.23798752f, -0.02754241f, -0.06758130f, 0.04322403f, -0.04855792f, -0.09732214f, 0.07339139f, -0.13525756f, 
    0.05132675f, -0.08162356f, -0.10428619f, 0.03734052f, 0.00459530f, -0.02632573f, -0.01302161f, -0.04051570f, 
    0.43825987f, 0.16318223f, -0.52532136f, -0.10217456f, -0.91951632f, -0.19293752f, -0.50940251f, 0.02133448f, 
    -0.31773251f, 0.01663421f, -0.05270530f, -0.05158920f, -0.05375786f, 0.01711216f, 0.02587375f, 0.01323619f, 
    -0.09648947f, 0.03257488f, 0.13783827f, -0.09497105f, -0.05339280f, -0.17839397f, 0.30168864f, 0.10165925f, 
    -0.16478205f, 0.01405835f, 0.01771531f, 0.00044447f, 0.05134482f, 0.07928771f, -0.03630569f, 0.07099412f, 
    -0.09504977f, 0.30038860f, -0.17959513f, -0.23453282f, -0.05508058f, 0.06639731f, 0.15489486f, -0.01452076f, 
    -0.04600341f, -0.10989530f, 0.08906896f, -0.21968623f, -0.07197689f, 0.02501730f, -0.06443882f, -0.23575832f, 
    -0.11285625f, 0.00609848f, -0.02776999f, -0.04463343f, 0.02894259f, 0.09098973f, 0.02856421f, -0.00782073f, 
    0.05429345f, -0.15450408f, 0.13247348f, 0.09193098f, 0.12020614f, -0.00696528f, 0.07646092f, -0.03764013f, 
    -0.00860292f, -0.08481162f, -0.06198650f, -0.12432360f, -0.01073389f, -0.02528358f, -0.01174024f, 0.04474550f, 
    0.04520367f, -0.03587122f, 0.06306195f, -0.10198027f, 0.09577035f, -0.07614357f, 0.02707306f, -0.03733080f, 
    -0.34041557f, -0.11501750f, 0.04807287f, -0.79231805f, 0.00235035f, 0.03342205f, -0.02266309f, -0.04409878f, 
    0.04751863f, 0.00985007f, 0.00147833f, 0.03688083f, -0.00507006f, 0.00188963f, -0.02088389f, 0.05858293f, 
    -0.10649666f, -0.00581333f, 0.03991266f, -0.04204473f, 0.38717163f, -0.43687889f, 0.02013092f, 0.28245875f, 
    0.16947700f, 0.19836697f, -0.17916650f, -0.03046388f, 0.10558516f, 0.01952228f, -0.15445286f, 0.24517703f, 
    0.15020065f, -0.04393895f, -0.06389993f, -0.01290193f, -0.08375002f, -0.07663270f, 0.06725275f, -0.07449289f, 
    -0.34207186f, -0.21581471f, 0.16012754f, -0.25218195f, -0.00067298f, -0.01307170f, -0.02776830f, -0.02834074f, 
    0.00543940f, 0.07105862f, 0.05354750f, -0.05908425f, -0.01892509f, 0.06640211f, 0.00306637f, -0.13244367f, 
    -0.18753226f, -0.07268390f, -0.03036109f, -0.05542134f, -0.75537813f, -0.98425663f, -0.35309812f, 0.16153117f, 
    -0.47720850f, -0.16675624f, -0.01638986f, -0.02409505f, 0.04144176f, -0.03955051f, 0.00144903f, -0.04957794f, 
    -0.04660345f, -0.06964828f, -0.03871640f, -0.07260384f, 0.06647284f, 0.01776760f, -0.11072807f, 0.20799157f, 
    -0.09891839f, 0.03036936f, -0.03686690f, -0.00310353f, 0.01701772f, -0.00837267f, -0.05462023f, -0.07658965f, 
    -0.02894768f, 0.01209396f, 0.11692235f, 0.03491623f, -0.06544803f, 0.05161360f, -0.07696304f, 0.02730250f, 
    -0.04069103f, -0.01601524f, -0.04941590f, -0.03495023f, -0.37479064f, 0.16465297f, 0.29533949f, -0.24588449f, 
    -0.02711355f, 0.02110095f, -0.07000254f, 0.02169484f, -0.06082778f, 0.09217720f, 0.03177144f, -0.06060754f, 
    0.00690213f, -0.11184645f, 0.05951893f, 0.10969102f, 0.06994662f, 0.01365067f, 0.21902217f, -0.08616966f, 
    0.16933514f, -0.04013103f, -0.11574083f, 0.19644208f, 0.14600824f, -0.07240531f, -0.10339954f, -0.06369493f, 
    -0.13862267f, -0.00703976f, -0.02571886f, 0.02686695f, 0.09661781f, -0.00365302f, 0.01297469f, -0.05717863f, 
    0.00793745f, -0.00096169f, -0.10312792f, -0.01036428f, 0.12760273f, -0.07272323f, -0.43745467f, -0.29427049f, 
    0.19720863f, 0.11144683f, 0.00865579f, -0.05604012f, -0.02460777f, -0.01716685f, -0.07731848f, -0.03827762f, 
    0.07583860f, -0.12622477f, 0.03832704f, 0.24949795f, 0.13376914f, -0.26164898f, 0.29487658f, -0.04522549f, 
    -0.10486512f, 0.35298455f, -0.43598449f, 0.05745858f, 0.15701111f, 0.06610606f, 0.09038293f, -0.00916984f, 
    0.04294378f, 0.11425274f, -0.04039835f, 0.02519245f, 0.00854774f, 0.05533262f, -0.00751448f, 0.02966211f, 
    -0.00166882f, 0.03644396f, -0.28503278f, 0.13176867f, -0.08600806f, -0.31877568f, 0.24410783f, -0.36121181f, 
    -0.20504834f, 0.02410897f, -0.01130172f, 0.02662916f, 0.07845098f, 0.04804279f, 0.03711974f, -0.03560748f, 
    0.02099182f, 0.03715847f, 0.01426246f, 0.11471436f, 0.03993679f, 0.12731582f, 0.02940611f, -0.04253548f, 
    -0.06846582f, -0.34842953f, 0.37080216f, 0.58240598f, -0.17814583f, 0.20119986f, -0.01587276f, 0.03975717f, 
    0.21013333f, -0.15740107f, -0.01201830f, 0.07866796f, -0.04339152f, 0.03777856f, -0.09418534f, -0.06421959f, 
    -0.03736072f, 0.00660118f, 0.14059490f, -0.08972648f, 0.03358167f, 0.00003730f, 0.04435910f, -0.05122560f, 
    0.09182280f, 0.03103552f, -0.07537103f, -0.04069448f, 0.13334610f, -0.15656543f, -0.06138515f, -0.20895648f, 
    -0.03043261f, 0.04693013f, -0.02423695f, 0.07052665f, -0.12015431f, -0.11927959f, 0.02565424f, -0.07836612f, 
    0.26839972f, 0.17440747f, -0.04463016f, -0.04189843f, 0.16388492f, 0.07116175f, -0.02356033f, -0.00414495f, 
    0.03492031f, 0.15061089f, -0.05522683f, -0.03669748f, 0.14797015f, -0.03185440f, 0.04849330f, 0.11997928f, 
    0.05656275f, -0.02069233f, 0.07952219f, 0.04508614f, -0.13886072f, -0.08731613f, 0.74902606f, 0.29769829f, 
    0.32529673f, -0.14566322f, -0.06264039f, 0.06649832f, 0.27152860f, -0.05425832f, 0.01681114f, 0.04870536f, 
    0.07490714f, -0.08529609f, 0.02090080f, 0.02246971f, -0.01653689f, -0.02824961f, -0.00597012f, -0.06584333f, 
    -0.06629908f, 0.19418034f, 0.21866731f, 0.23748668f, -0.06186027f, -0.00184004f, -0.01713995f, -0.02156902f, 
    0.01066864f, -0.07033713f, -0.01069352f, 0.04632127f, -0.04811478f, -0.03748176f, 0.01792378f, -0.04797878f, 
    0.10318759f, 0.17582352f, 0.05613967f, 0.03031905f, -0.09588661f, 0.12904218f, 0.25942886f, 0.16018966f, 
    0.41603112f, 0.04084424f, 0.09312271f, 0.02905727f, 0.15835313f, 0.09664714f, -0.03472179f, 0.03458116f, 
    0.04112368f, 0.04567831f, -0.01650884f, 0.00889348f, 0.04312381f, 0.00946890f, -0.06615379f, 0.14107092f, 
    0.44789568f, 0.16848317f, -0.05857819f, 0.18022227f, 0.08314576f, -0.04232618f, 0.01153147f, -0.04020672f, 
    -0.10599085f, 0.03417730f, 0.00473385f, 0.02854618f, 0.07762093f, 0.01731216f, 0.01390423f, 0.01548294f, 
    -0.05403414f, 0.00076554f, 0.05354542f, -0.03243818f, -0.35602966f, 0.22801349f, -0.15126179f, -0.14992484f, 
    0.00168942f, -0.13703075f, 0.11982796f, -0.02312148f, -0.06256629f, 0.04014134f, -0.00267800f, -0.02669604f, 
    -0.08338990f, 0.02282068f, 0.02450923f, 0.11275829f, -0.28465614f, -0.23577535f, 0.09905508f, -0.01363108f, 
    -0.00280706f, -0.01869352f, -0.12010275f, -0.04867966f, 0.08622355f, -0.03650802f, 0.00075685f, 0.02731260f, 
    -0.00223481f, 0.05367069f, -0.17415872f, -0.00959433f, 0.13686007f, 0.02246064f, -0.02901088f, 0.00813095f, 
    0.04924421f, 0.10276094f, 0.04821088f, 0.01907220f, -0.05374886f, -0.03990325f, -0.09538399f, -0.04420331f, 
    0.09094971f, 0.03582819f, 0.00260589f, -0.06034308f, 0.02753138f, -0.01685685f, -0.02934531f, -0.04333771f, 
    0.08407587f, -0.07953677f, 0.04080969f, 0.01974680f, 0.20160294f, 0.11814071f, 0.01845991f, 0.08156824f, 
    -0.54918361f, -0.30625701f, 0.27609223f, -0.12005267f, -0.27120948f, -0.04168377f, -0.12075546f, -0.11603012f, 
    0.04921412f, -0.08311673f, -0.00266242f, -0.01254232f, -0.03931892f, -0.05704743f, -0.03451354f, -0.18127164f, 
    -0.04320121f, 0.26672757f, 0.01702167f, 0.13147596f, 0.07469513f, -0.01393255f, -0.09699883f, 0.07733618f, 
    0.01317342f, 0.03574402f, 0.01398635f, -0.04647140f, 0.09996178f, -0.06763154f, 0.00730828f, 0.05407105f, 
    0.07619435f, 0.04169205f, 0.01550430f, 0.00381290f, 0.00155433f, 0.03788281f, -0.09519821f, -0.01013853f, 
    -0.47106335f, -0.69709766f, -0.52593964f, -0.09622022f, -0.58647817f, 0.15082848f, 0.09233214f, 0.10468962f, 
    -0.08395390f, -0.12268126f, 0.05620764f, 0.07777476f, 0.05250008f, -0.02733273f, -0.06530328f, -0.00327466f, 
    0.03797771f, -0.03259977f, -0.28511184f, 0.00633488f, -0.05800147f, -0.14206797f, 0.02673965f, 0.01726732f, 
    0.21555085f, 0.02909675f, -0.04593463f, -0.06339593f, -0.00152755f, -0.01995822f, -0.00922420f, 0.01539388f, 
    -0.13612160f, 0.04180790f, 0.04918507f, 0.07966647f, 0.08267724f, 0.04754928f, -0.04447467f, 0.03685075f, 
    -0.13764499f, -0.70104122f, -0.13397335f, -0.26536939f, -0.15484749f, -0.01866347f, -0.02593434f, -0.17350695f, 
    -0.05145947f, -0.08376951f, -0.04746817f, -0.06940396f, 0.00184529f, 0.03833436f, -0.05614835f, -0.07183063f, 
    -0.08779167f, -0.03898812f, 0.14331792f, 0.28897929f, 0.66426563f, -0.07757547f, 0.23286782f, 0.04348141f, 
    0.41469917f, -0.05906051f, 0.08889282f, -0.16033393f, 0.06188802f, -0.00106697f, -0.04394581f, -0.04685528f, 
    -0.03801329f, -0.04660085f, -0.05564219f, 0.02287808f, 0.02211576f, -0.02602870f, -0.09216835f, 0.07162350f, 
    -0.07893375f, -0.15118222f, 0.38187122f, 0.04282496f, 0.07805517f, 0.03453025f, -0.09658457f, 0.03311222f, 
    0.18647246f, -0.21896805f, 0.06227938f, 0.04148885f, -0.15424389f, 0.03485914f, 0.01642900f, 0.04124010f, 
    -0.06945333f, -0.00079138f, 0.04276189f, -0.03465455f, -0.05716698f, 0.00224974f, 0.57753444f, 0.10783506f, 
    0.25979462f, -0.03467533f, -0.02422471f, 0.07945909f, 0.05568370f, -0.17902397f, 0.11611415f, -0.01030453f, 
    0.04251801f, -0.17500709f, 0.14531446f, 0.03719988f, -0.02890399f, 0.01350453f, -0.01095925f, -0.04586454f, 
    -1.17611027f, 0.53442442f, 0.34473377f, 0.02911208f, -0.70677412f, -0.08007703f, -0.02084547f, -0.43546993f, 
    -0.31404719f, 0.00622212f, 0.02226161f, 0.05496401f, -0.04067001f, -0.04024075f, 0.00673235f, 0.09833796f, 
    0.07696908f, 0.04253498f, 0.10957009f, 0.07041430f, -0.07407177f, 0.05723204f, 0.06181254f, 0.03321525f, 
    0.08198699f, -0.00728054f, -0.04166682f, 0.01020950f, -0.01984653f, 0.08645450f, -0.01174562f, -0.05464449f, 
    -0.00984424f, 0.00344763f, 0.00839897f, -0.10603064f, -0.07317231f, 0.06290860f, 0.13279277f, -0.03647550f, 
    -0.43052718f, -0.13428362f, 0.21108383f, -0.14363517f, -0.03831403f, -0.07794867f, 0.05316405f, -0.47868684f, 
    -0.22243184f, 0.08191800f, 0.05927517f, -0.02003443f, -0.01506913f, 0.04177917f, -0.00817662f, 0.05717708f, 
    -0.04338908f, -0.01172077f, -0.21768536f, -0.10512387f, -0.18043694f, -0.11291295f, 0.07538446f, -0.13485825f, 
    0.13058382f, -0.02779288f, -0.08196650f, -0.08396251f, 0.00195232f, 0.09139112f, -0.02184364f, -0.03995067f, 
    0.05939129f, -0.02490053f, -0.01415024f, 0.05002995f, -0.20900942f, -0.20650071f, 0.06207503f, 0.02747408f, 
    -0.99571747f, -0.11324584f, -0.07275069f, 0.01392952f, -0.23693812f, -0.06059082f, -0.07581327f, 0.03831890f, 
    0.17359273f, 0.18853040f, 0.02905626f, 0.00200890f, 0.04006026f, -0.08301031f, -0.01721280f, 0.08484328f, 
    0.10130253f, -0.05430709f, -0.07434525f, -0.03628122f, -0.06484165f, 0.38247442f, 0.13045886f, -0.17259209f, 
    0.12155014f, 0.20632902f, 0.37861153f, -0.14257185f, -0.17116559f, -0.00884785f, -0.16826810f, 0.05419331f, 
    -0.11371776f, -0.21320443f, 0.02249501f, -0.31253180f, -0.17907946f, 0.20356283f, 0.04791817f, -0.17176075f, 
    -0.46856734f, -0.29720157f, 0.06749371f, -0.34564602f, -0.14263956f, -0.19081962f, -0.17474654f, -0.15799394f, 
    0.12949663f, -0.05730870f, 0.01820030f, 0.07168540f, 0.05060354f, -0.00067556f, -0.03414443f, -0.00563800f, 
    0.07090909f, -0.03557711f, -0.06216319f, -0.10403512f, -0.02258714f, -0.05245082f, -0.18339093f, -0.02038343f, 
    0.17012091f, -0.04793619f, 0.11898778f, -0.02889293f, -0.03363336f, 0.22191237f, -0.08960904f, 0.04674720f, 
    -0.06648918f, -0.14269166f, -0.05467866f, 0.11527347f, -0.00099557f, -0.03242864f, 0.01738447f, 0.01471603f, 
    -0.31742576f, -0.13353881f, -0.15528634f, 0.07341358f, -0.24716358f, 0.08987035f, 0.01456864f, 0.17141576f, 
    -0.00306561f, 0.05296282f, -0.03495503f, 0.07354627f, -0.18216084f, -0.03058271f, -0.16226372f, 0.05091815f, 
    -0.12262855f, 0.13120474f, -0.07986563f, -0.25586447f, -0.38585821f, 0.88844025f, -0.41631830f, 0.19561346f, 
    0.03900891f, 0.07127908f, -0.05120897f, 0.19211563f, 0.03129389f, 0.03758124f, -0.07600629f, -0.15240088f, 
    0.05793900f, -0.09484419f, -0.03132610f, 0.01941592f, -0.14110470f, -0.08738461f, 0.01326538f, -0.06685047f, 
    0.26390889f, -0.13083038f, -0.18059751f, -0.29623204f, 0.29289085f, 0.16048756f, 0.10257089f, -0.13757929f, 
    0.03899641f, -0.21048276f, -0.11497904f, 0.14666185f, 0.11425249f, 0.02826344f, -0.12312628f, 0.16151348f, 
    0.09728309f, 0.07587821f, 0.14185876f, -0.07412899f, 0.90821445f, 0.53007215f, -0.25572377f, -0.40584958f, 
    -0.44756433f, 0.01146800f, 0.11611088f, 0.01643920f, -0.19252665f, 0.34477732f, -0.01078193f, -0.13751735f, 
    0.12589093f, -0.00910074f, 0.14052632f, 0.02083594f, 0.04835459f, 0.05555928f, 0.24025285f, -0.02352959f, 
    0.25548121f, -0.04055467f, -0.17079540f, -0.20376235f, 0.14349470f, -0.01534811f, 0.00501068f, -0.07422733f, 
    0.05028515f, -0.14501734f, -0.01143388f, -0.02772550f, -0.00533218f, -0.04444494f, 0.01784374f, -0.14730874f, 
    -0.04828976f, 0.05562112f, -0.10813446f, -0.01311694f, -0.11623437f, -0.18953049f, 0.55957818f, -0.05350539f, 
    0.06944552f, -0.16191952f, -0.14814112f, 0.00590160f, 0.26675624f, 0.07474956f, 0.06343195f, -0.05734205f, 
    0.10185429f, 0.10147040f, 0.19921701f, 0.02103589f, 0.03712945f, -0.15323405f, 0.11732285f, -0.03162996f, 
    -0.20967282f, 0.03305092f, -0.37011972f, -0.11220721f, 0.38915154f, 0.18547210f, 0.02127415f, -0.10589195f, 
    0.03560412f, -0.12893948f, -0.17715871f, 0.07633717f, -0.11628331f, 0.11195404f, 0.05900401f, -0.18634111f, 
    -0.02387713f, 0.27555630f, 0.13252388f, -0.00603031f, -0.30627957f, -0.18625453f, -0.37001300f, -0.02885156f, 
    0.28840885f, 0.10943605f, 0.03886842f, 0.10732957f, 0.02992542f, 0.03160210f, -0.03352866f, 0.00213434f, 
    0.08061639f, -0.00810729f, -0.13559504f, 0.12504761f, 0.06212004f, -0.03927634f, 0.05928735f, 0.00685913f, 
    0.21266998f, 0.53760612f, -0.08940846f, -0.52507830f, -0.07276450f, -0.14435424f, -0.09857047f, -0.00860285f, 
    -0.29060248f, 0.05921564f, -0.13551612f, -0.01111722f, -0.05179164f, 0.10080632f, 0.00536560f, -0.08211461f, 
    -0.05019419f, 0.00837833f, -0.05701564f, -0.04766149f, -0.34649837f, 0.18579030f, -0.05256414f, -0.06402705f, 
    0.36333391f, 0.31099284f, 0.02879101f, 0.00226273f, -0.23416385f, -0.02656110f, -0.19354939f, 0.05405151f, 
    0.09661512f, 0.10723463f, 0.06492171f, 0.01228278f, 0.00791799f, -0.02212717f, 0.05189885f, 0.12889472f, 
    -0.42490911f, 0.16504012f, -0.19421379f, 0.11876896f, 0.04293822f, -0.10345329f, -0.08711147f, -0.02967970f, 
    -0.08613779f, 0.10793114f, -0.16063559f, 0.06250332f, -0.05502245f, -0.00519122f, -0.00468882f, 0.04881282f, 
    -0.07766026f, 0.22961713f, -0.20178036f, -0.10309027f, 0.07107602f, -0.09265146f, -0.15060440f, -0.15932515f, 
    0.20138316f, 0.01212628f, 0.06019064f, -0.06276956f, -0.02654980f, -0.05929936f, 0.00125853f, -0.02011158f, 
    0.01738312f, 0.03194274f, 0.11986578f, -0.13491014f, 0.02600974f, 0.01528970f, 0.00547268f, 0.08413102f, 
    0.03650915f, 0.21607579f, -0.14501552f, -0.21806616f, 0.02162817f, 0.15135077f, -0.11503699f, -0.09929369f, 
    -0.22726755f, -0.14389406f, -0.12881330f, 0.01718463f, -0.16771133f, 0.00905044f, 0.08022278f, -0.02585818f, 
    -0.07554065f, -0.13926972f, -0.22787115f, -0.09534376f, -0.91727865f, 0.10564645f, 0.19849031f, 0.08734018f, 
    -0.29974645f, -0.00371486f, -0.21281415f, 0.22681652f, -0.10287972f, -0.38194439f, -0.10982767f, 0.09312848f, 
    -0.01443143f, 0.02933435f, 0.02734639f, -0.05018272f, -0.06640626f, 0.04645310f, -0.04053266f, -0.16593717f, 
    -0.44396302f, -0.25362691f, -0.18649353f, -0.16646703f, -0.28914216f, 0.22149594f, 0.11671257f, 0.05228418f, 
    -0.08884285f, -0.16218914f, -0.15943915f, -0.03757968f, -0.06616072f, -0.23725156f, -0.04846570f, -0.02911383f, 
    0.18968776f, -0.13217114f, -0.19432566f, -0.21168298f, -0.73028421f, 0.86956090f, -0.05381960f, -0.29360193f, 
    -0.33195877f, 0.15204662f, 0.12521084f, 0.06444529f, 0.02016766f, 0.13442165f, 0.10420301f, -0.13616517f, 
    0.20949580f, -0.10921044f, -0.02011706f, 0.03490147f, 0.16457039f, -0.05008734f, -0.00984890f, 0.04057328f, 
    -0.05955986f, -0.23660962f, 0.10455389f, -0.02203482f, 0.24981189f, -0.19035719f, 0.04439678f, 0.07706533f, 
    0.07355009f, 0.12168865f, 0.00766091f, 0.05317360f, -0.01727575f, -0.11927981f, 0.08420213f, -0.06383272f, 
    0.03985807f, 0.01067411f, -0.10533906f, -0.03598173f, 0.11489207f, -0.14386858f, -0.18182182f, -0.13801634f, 
    0.21909422f, 0.04061896f, 0.15153253f, -0.02022488f, 0.06044344f, 0.02725513f, -0.01690426f, 0.00620956f, 
    -0.00356461f, 0.04815627f, -0.12714329f, -0.00769320f, 0.01958768f, 0.09244888f, 0.08544620f, 0.01554795f, 
    0.01036837f, -0.10889953f, -0.38035154f, 0.03886899f, 0.24307355f, 0.10775661f, -0.05133439f, 0.08045511f, 
    0.05880992f, 0.16851616f, 0.04494831f, -0.07891066f, -0.06809412f, -0.04619109f, -0.00266597f, -0.07408538f, 
    -0.15961263f, 0.02053937f, -0.15804081f, -0.04363159f, 0.97498703f, 0.35659271f, -0.20652689f, -0.12543245f, 
    -0.21789895f, 0.23755954f, 0.12442546f, 0.07432359f, 0.12023143f, 0.03832768f, -0.17278518f, -0.16300511f, 
    0.02477429f, -0.01298154f, 0.05786940f, -0.14617492f, -0.05817165f, -0.21670440f, 0.10606521f, 0.06316838f, 
    0.29787451f, -0.10027822f, 0.08677310f, -0.27931941f, 0.37755328f, 0.00638291f, 0.09960776f, 0.12494791f, 
    0.11730073f, 0.05778655f, 0.01248852f, -0.02803099f, -0.02631747f, -0.01779301f, -0.02522785f, 0.07091495f, 
    -0.03461934f, 0.07411601f, 0.13244882f, 0.08386369f, -0.37542710f, 1.00563574f, 0.04610257f, -0.54672718f, 
    0.29825234f, 0.21637288f, 0.18806961f, -0.22345187f, -0.22240622f, -0.13972886f, -0.07311767f, 0.05668535f, 
    -0.18213482f, -0.08736741f, 0.06736578f, 0.10623682f, 0.16105627f, -0.02788777f, 0.01141973f, 0.10704825f, 
    -0.11627537f, -0.04298368f, -0.15558256f, 0.03889645f, 0.21750471f, 0.07669619f, -0.01603653f, 0.11243916f, 
    -0.13785474f, 0.00239664f, -0.09888008f, 0.05065041f, 0.16274989f, 0.01327909f, -0.07742298f, 0.00132700f, 
    0.03931492f, 0.01842720f, 0.07244717f, 0.02830870f, -0.42120531f, 0.54198372f, 0.02828500f, -0.11973324f, 
    0.25677785f, 0.29786056f, 0.06932317f, 0.00941250f, -0.09125494f, 0.04006084f, -0.16082512f, -0.02551557f, 
    0.08072230f, 0.01928898f, 0.10302933f, -0.07514529f, 0.07117129f, -0.00090930f, -0.02152961f, -0.00344885f, 
    -0.37826011f, -0.03062679f, 0.19759601f, 0.46751532f, 0.42564800f, -0.09766336f, 0.07295333f, 0.10633511f, 
    -0.04749181f, -0.05458464f, -0.01402214f, 0.02762910f, -0.11025779f, -0.06299376f, -0.12649526f, -0.02668293f, 
    0.00604883f, -0.00931190f, 0.07816239f, 0.03966905f, 0.10853968f, 0.07085703f, 0.11050675f, 0.32030985f, 
    0.28138342f, 0.07880586f, -0.17231433f, -0.17213552f, -0.02621525f, -0.31265742f, -0.11271555f, 0.01377165f, 
    0.06293646f, -0.07973925f, -0.08892451f, -0.11769068f, 0.00337100f, 0.16283591f, -0.05145222f, -0.08520459f, 
    0.00283264f, -0.17092498f, 0.47875327f, -0.13412394f, 0.39108461f, -0.10333281f, 0.04088053f, 0.04837537f, 
    0.07047438f, -0.03023295f, 0.15684442f, 0.11396752f, -0.06643291f, -0.06376738f, 0.19602394f, -0.05387959f, 
    -0.17364375f, -0.06557792f, -0.01676437f, -0.04383462f, -0.18993646f, -0.09271759f, -0.09438129f, -0.37242636f, 
    -0.42453453f, -0.13186602f, -0.24867830f, 0.23180196f, 0.02831819f, -0.19460936f, 0.02042097f, -0.06444992f, 
    0.01415876f, -0.01777001f, 0.04490266f, 0.06661581f, 0.15950800f, -0.12069536f, 0.09435657f, -0.14506501f, 
    0.33231694f, 0.04427191f, -0.07384804f, 0.20540728f, 0.19716796f, 0.02041687f, 0.02470282f, 0.03806924f, 
    0.02062166f, 0.08703753f, 0.07059276f, 0.05109691f, 0.03809725f, 0.03664914f, 0.02221332f, 0.02405612f, 
    -0.00233785f, -0.02867432f, -0.09034696f, 0.10597526f, 0.75393975f, -0.62711698f, -0.11369289f, -0.13395135f, 
    -0.38571233f, -0.07573001f, -0.53002721f, -0.02061387f, -0.14849107f, -0.14828862f, 0.05796253f, -0.04694639f, 
    0.08156606f, 0.05292302f, -0.05284679f, 0.14118360f, -0.02361370f, 0.02307834f, -0.18330003f, -0.08035701f, 
    -0.03988153f, -0.01296030f, -0.08123437f, 0.09767949f, 0.14529556f, 0.06548166f, 0.10169891f, 0.08164471f, 
    -0.01562734f, 0.03191081f, 0.12657759f, 0.07569218f, 0.00902714f, 0.03134929f, 0.11558713f, -0.04860770f, 
    -0.04720769f, -0.01079329f, 0.01903827f, 0.02243723f, -0.18495408f, -0.03681764f, 0.11324851f, 0.12893300f, 
    0.02983010f, -0.18082409f, 0.06409985f, 0.02644555f, 0.00639688f, -0.02408986f, -0.02250110f, 0.03066113f, 
    0.04573685f, 0.12014615f, 0.05557484f, -0.00003541f, 0.11202136f, -0.11458820f, -0.03387615f, 0.18133238f, 
    0.00318729f, 0.01703234f, 0.03347648f, -0.01735976f, 0.08130103f, 0.03553103f, 0.08034802f, 0.05681073f, 
    -0.06527176f, 0.05546574f, 0.08395784f, 0.08064332f, 0.15888087f, -0.07626189f, 0.02103741f, 0.07075830f, 
    -0.06384294f, -0.13644382f, -0.07052825f, -0.11847106f, -0.37551460f, -0.20319369f, 0.11732626f, -0.29529536f, 
    -0.11805002f, 0.05671366f, 0.13924780f, -0.10966294f, 0.01371494f, 0.02903314f, -0.09319320f, 0.05929719f, 
    -0.03888701f, 0.22809921f, 0.06958956f, -0.18863207f, 0.03615520f, -0.06320931f, -0.09916356f, -0.10785039f, 
    -0.01734213f, 0.21427493f, -0.00139498f, 0.22105205f, 0.00761457f, -0.09632028f, -0.07372503f, -0.06397559f, 
    -0.12576896f, -0.01781975f, 0.16960798f, -0.12692837f, -0.09080779f, 0.02950808f, 0.04770287f, -0.02639767f, 
    -0.08738302f, -0.02027506f, -0.06859573f, -0.08343967f, 0.03823752f, -0.53301537f, -0.16786313f, 0.33189088f, 
    -0.40613985f, 0.20033476f, -0.02902021f, 0.11102982f, -0.08896683f, 0.02700227f, 0.00874087f, 0.02557102f, 
    -0.06874330f, -0.05518004f, -0.00043910f, -0.03583652f, 0.20115656f, 0.02840948f, -0.28059539f, 0.14895099f, 
    -0.09971254f, -0.16622628f, 0.07316620f, 0.14486688f, -0.00181090f, -0.10671768f, -0.09639798f, -0.04661450f, 
    -0.06021747f, 0.01889344f, 0.02567237f, 0.00585122f, -0.05892146f, 0.08258212f, -0.00112149f, 0.00079118f, 
    0.02769418f, -0.02254910f, 0.05006436f, 0.05488271f, 0.12164679f, 0.34848443f, -0.73970205f, 0.19412135f, 
    0.25172850f, 0.02323171f, -0.02914920f, 0.05438656f, 0.10431873f, 0.10334290f, 0.10416947f, 0.01612081f, 
    -0.00610132f, -0.00376103f, -0.01963096f, 0.19652542f, 0.14425749f, 0.32951480f, -0.07926114f, 0.31237477f, 
    0.10352607f, -0.28211945f, 0.31865302f, 0.22070444f, -0.09258235f, -0.19767180f, -0.06093457f, 0.07157505f, 
    -0.12800846f, -0.19212787f, 0.01362407f, -0.03354551f, -0.03303750f, 0.02226067f, -0.02475000f, 0.01275073f, 
    -0.04537873f, -0.05185181f, -0.11416199f, -0.12407317f, 0.15255244f, 0.04814541f, 0.08605310f, 0.04491787f, 
    -0.00533293f, 0.06085072f, -0.01211073f, -0.02487275f, -0.08801936f, 0.10357333f, 0.15214022f, -0.01000178f, 
    0.06267356f, 0.03234378f, -0.00539206f, 0.10702508f, 0.01181036f, -0.03318110f, -0.09128943f, -0.04207434f, 
    0.02080327f, -0.15539026f, -0.08248147f, -0.01566393f, -0.25356337f, 0.07396396f, -0.09868596f, -0.02321689f, 
    -0.03253243f, 0.00884964f, 0.06030309f, -0.00585079f, -0.15078023f, -0.00567930f, -0.07307933f, 0.00365006f, 
    -0.19247791f, -0.00536129f, -0.22017729f, -0.10714561f, 0.29645872f, -0.17514569f, 0.34208772f, 0.13916069f, 
    0.10194816f, -0.30408841f, -0.02949518f, -0.04931177f, -0.05679811f, 0.02863476f, 0.02939260f, -0.01818499f, 
    -0.11316414f, 0.05791123f, 0.07911748f, 0.03646477f, 0.04479289f, 0.07686380f, 0.02869734f, -0.03568703f, 
    0.06845526f, -0.08434446f, 0.18794505f, -0.18066798f, 0.03027579f, -0.10980270f, 0.17673141f, -0.04623946f, 
    -0.08214935f, -0.17179832f, -0.02273285f, 0.01315982f, -0.01762274f, 0.02552746f, -0.09911276f, 0.03953613f, 
    0.12568626f, -0.09283749f, 0.01010084f, 0.21724936f, -0.19185676f, -0.12615725f, 0.00322938f, 0.04945228f, 
    -0.03556056f, -0.12684999f, -0.07668474f, -0.02616769f, -0.27223739f, -0.11660625f, -0.03576636f, 0.02713901f, 
    -0.12936339f, 0.05957619f, -0.09193040f, 0.07787883f, 0.13314077f, 0.01918123f, 0.03287846f, 0.18084438f, 
    -0.02466136f, -0.17645696f, -0.12748635f, -0.08424898f, -0.11864275f, -0.11949996f, -0.13359724f, -0.02202732f, 
    -0.07561705f, -0.04783954f, 0.01334481f, -0.10493179f, -0.04879839f, -0.09540157f, 0.06674196f, -0.11844224f, 
    -0.23033401f, 0.03323843f, -0.08727232f, -0.15885866f, 0.13106003f, -0.31466702f, -0.32795659f, -0.37926278f, 
    0.14326090f, 0.11790513f, -0.09264087f, 0.03960548f, 0.00914256f, -0.06880030f, 0.00105012f, 0.06283155f, 
    -0.02690159f, -0.12952249f, -0.01393679f, 0.06418517f, -0.11846803f, -0.21854034f, -0.20796223f, -0.18224888f, 
    0.07591971f, 0.06240545f, -0.05638846f, -0.09042931f, -0.12234050f, 0.09145734f, -0.00890002f, 0.00818837f, 
    0.03055518f, 0.09586117f, 0.13825068f, 0.02723568f, -0.04508579f, 0.00124324f, -0.09022769f, 0.05045090f, 
    -0.02379334f, 0.02261615f, -0.01846554f, 0.06559149f, -0.53480387f, -0.10866863f, -0.15684031f, -0.40779620f, 
    -0.36532933f, 0.01667868f, 0.00731497f, 0.03530902f, 0.05659676f, 0.02872700f, -0.01557457f, -0.03679193f, 
    -0.01789588f, -0.06806041f, -0.07219085f, -0.24842530f, 0.01680653f, -0.02683582f, 0.12756917f, 0.11668497f, 
    0.22495976f, 0.08893889f, 0.00119796f, 0.14987864f, 0.13910167f, 0.03835296f, 0.15367676f, 0.02001121f, 
    0.22670200f, 0.09761066f, -0.01731015f, -0.01021274f, 0.01114979f, 0.00582605f, -0.03235483f, 0.02732400f, 
    0.11713108f, -0.07473052f, 0.25436369f, 0.34261429f, 0.08013044f, 0.16107950f, 0.06742161f, 0.25514492f, 
    -0.01609314f, -0.01070988f, -0.07935890f, -0.16725844f, -0.12144820f, 0.05547900f, 0.00941945f, 0.08054247f, 
    -0.01446581f, 0.03478712f, 0.02995300f, 0.03499597f, -0.07584830f, -0.09278341f, -0.06875577f, -0.12533718f, 
    0.20656337f, 0.24447818f, 0.39442939f, 0.36876902f, 0.29087380f, -0.20369050f, 0.00506397f, -0.02689253f, 
    0.06305460f, 0.14730465f, -0.01098415f, -0.00940734f, -0.04546522f, 0.01209002f, 0.01573063f, -0.02834386f, 
    -0.05502656f, -0.16595092f, -0.03028647f, -0.30561447f, 0.00757135f, -0.50035816f, -0.01332941f, -0.35972103f, 
    -0.24013178f, 0.11155459f, 0.03257814f, 0.07150758f, 0.01424398f, 0.07114056f, -0.00111817f, 0.07424781f, 
    0.06474427f, -0.11375993f, -0.14543398f, -0.06982502f, -0.02587394f, 0.04704912f, -0.04120730f, 0.10794266f, 
    0.33808428f, 0.01262350f, -0.06166891f, 0.49937832f, 0.14455912f, 0.08551288f, -0.00028497f, 0.11729491f, 
    0.13396038f, 0.13928361f, 0.06397831f, -0.08429109f, 0.05073901f, 0.01189128f, 0.04030806f, 0.04594878f, 
    0.16101155f, -0.05689169f, -0.02235779f, 0.11696742f, 0.07448886f, -0.53731120f, -0.05704941f, 0.33286372f, 
    0.07140020f, -0.16516727f, -0.29474577f, 0.04240546f, -0.29255548f, -0.02848767f, -0.27728564f, 0.04821316f, 
    0.08380727f, 0.07057355f, -0.19210339f, -0.00644866f, -0.07480928f, -0.01119852f, -0.11422516f, 0.06286424f, 
    0.08673893f, 0.00412192f, 0.16517861f, 0.11630607f, -0.09064191f, -0.10603587f, 0.00568165f, -0.14209762f, 
    -0.10411783f, -0.06330853f, 0.04189733f, -0.09652091f, -0.06624792f, 0.01424543f, 0.00746280f, 0.03197059f, 
    -0.00320186f, -0.03677005f, -0.05762121f, -0.10593333f, -0.04771496f, -0.27495176f, 0.15092741f, 0.00999468f, 
    0.01910015f, -0.12966728f, 0.00065704f, -0.04151836f, -0.02673129f, 0.04565464f, 0.02733613f, -0.03843182f, 
    -0.17378025f, 0.00839205f, -0.02187637f, 0.02025330f, 0.03688689f, 0.07171653f, -0.03749340f, -0.04512741f, 
    0.15641385f, 0.13478026f, 0.28026044f, -0.31809768f, 0.09145499f, 0.21412218f, 0.07596900f, 0.01075935f, 
    -0.08080118f, 0.11273847f, 0.04771382f, -0.02087256f, 0.08344574f, 0.03031921f, -0.09937834f, 0.02107982f, 
    0.11497550f, -0.13878950f, -0.04499469f, 0.05305221f, -0.29170167f, -0.12359509f, -0.23187274f, -0.33599582f, 
    -0.09923871f, 0.00543485f, -0.10658488f, -0.04028403f, -0.06420257f, -0.09659082f, -0.04888999f, -0.06061793f, 
    0.08930811f, -0.25453806f, -0.01630551f, 0.00592734f, -0.19988737f, -0.03293508f, -0.16064765f, -0.06160064f, 
    -0.02374142f, 0.01049971f, -0.06456149f, 0.23823771f, 0.23844101f, -0.08449407f, 0.16367817f, 0.19435808f, 
    0.05676667f, 0.18019149f, 0.08652516f, -0.03612842f, 0.01317376f, -0.12466484f, -0.03028820f, -0.11076234f, 
    -0.00833935f, -0.14887221f, -0.05969495f, -0.23641041f, 0.00314070f, 0.02109351f, -0.10866205f, -0.01710062f, 
    0.05307558f, 0.15815558f, 0.13503069f, -0.01609278f, -0.03299523f, 0.07864592f, 0.11936528f, 0.03764318f, 
    -0.05124265f, -0.01908721f, 0.11747291f, 0.05831585f, -0.19704209f, -0.11647332f, -0.03322863f, -0.02655416f, 
    -0.07224127f, -0.17501794f, -0.22262318f, 0.05724087f, 0.05640807f, 0.08863187f, 0.01987816f, -0.05127751f, 
    -0.00657140f, 0.01215661f, 0.11777075f, -0.00740062f, -0.00105733f, 0.00530604f, -0.04429775f, -0.16570505f, 
    -0.03439441f, 0.13213034f, -0.06363993f, -0.12789519f, -0.68930405f, 0.03109081f, 0.08735657f, -0.27347675f, 
    -0.12938821f, -0.23202819f, 0.09012833f, -0.06997842f, 0.05280166f, -0.05382812f, 0.22734924f, -0.05599569f, 
    -0.13433924f, 0.09762479f, -0.01817228f, 0.03801348f, -0.03125164f, -0.12254670f, 0.17887536f, 0.30161884f, 
    -0.19057764f, -0.23705342f, -0.21925229f, 0.13890202f, 0.02921870f, 0.09768636f, -0.03605839f, 0.01445133f, 
    -0.01172078f, 0.04669081f, -0.01754898f, -0.05058755f, -0.01039369f, -0.00454530f, -0.02098740f, 0.11095556f, 
    -0.08639070f, 0.29451862f, -0.06306673f, 0.02466979f, -0.23216256f, -0.01586904f, 0.19950454f, 0.04493971f, 
    -0.18186784f, 0.19594702f, -0.10034411f, 0.07236687f, 0.11656309f, -0.15907009f, -0.00602145f, 0.00391572f, 
    -0.02907707f, 0.16039135f, 0.07678568f, 0.00758932f, 0.09334315f, -0.21530159f, -0.15727362f, -0.35803536f, 
    0.02840334f, -0.02180714f, -0.04045119f, -0.00294478f, 0.06436731f, 0.01271825f, -0.00867369f, 0.04761514f, 
    0.02055506f, -0.02374882f, -0.18509206f, -0.14373480f, 0.01500830f, -0.10150387f, -0.03270632f, 0.04064361f, 
    0.09886787f, 0.05019899f, 0.07009467f, 0.05582628f, -0.40240043f, 0.11788018f, -0.14639983f, -0.50121564f, 
    0.09797767f, -0.13244587f, -0.04142717f, 0.01396764f, -0.08100010f, 0.01687185f, 0.06309932f, 0.09975985f, 
    -0.02808919f, -0.20608576f, 0.10443753f, -0.02606521f, -0.17114545f, 0.23779838f, 0.01607356f, -0.07425404f, 
    0.08707322f, -0.00934074f, 0.08263422f, 0.04380789f, -0.40250045f, 0.04089946f, -0.05716690f, -0.13970706f, 
    0.20167650f, 0.14866349f, 0.13960093f, -0.05971229f, -0.01484459f, -0.02191018f, 0.02742415f, -0.01073114f, 
    0.06340361f, -0.02812102f, 0.05773865f, 0.16186093f, -1.26893330f, 0.82990140f, -0.08307786f, 0.07788594f, 
    0.14443265f, -0.05837448f, -0.21925955f, -0.02501347f, 0.08927298f, -0.20560475f, 0.05843628f, -0.11685223f, 
    0.00359315f, 0.07869329f, -0.06596272f, 0.01843720f, -0.22819717f, 0.06710517f, 0.15276501f, -0.04501033f, 
    0.03095156f, 0.09609453f, 0.18009263f, 0.19093633f, -0.22300173f, -0.12417430f, 0.10394003f, -0.00946970f, 
    -0.07982076f, 0.22358149f, 0.05137746f, 0.01143696f, 0.03248571f, 0.00990130f, 0.05029076f, -0.09883759f, 
    -0.02952978f, -0.06772952f, 0.03801578f, 0.05740498f, -0.03191315f, -0.24965763f, -0.18980175f, 0.04908426f, 
    0.02213757f, 0.11683466f, 0.03393365f, -0.06754319f, -0.00269645f, -0.04020125f, 0.04254693f, 0.02268100f, 
    0.05310955f, 0.00586701f, 0.01959066f, -0.31220362f, -0.17038260f, 0.03763175f, 0.11959052f, -0.19517225f, 
    -0.36323169f, -0.09343273f, 0.22870067f, -0.23347716f, -0.12829046f, 0.16345291f, -0.01151032f, -0.04019143f, 
    -0.26753503f, 0.12327069f, 0.04011232f, 0.03461549f, -0.01261713f, 0.04900317f, 0.06030958f, 0.14746360f, 
    -0.18058144f, -0.21104696f, 0.03218267f, 0.10486782f, 0.01419779f, -0.00127922f, 0.13660783f, -0.16793425f, 
    -0.02113993f, 0.01090396f, -0.00894137f, 0.05829766f, 0.03849993f, -0.05736433f, 0.23543690f, -0.05410514f, 
    -0.03505944f, -0.07841118f, -0.02847201f, 0.03759390f, 0.04993007f, 0.03488962f, 0.01636426f, 0.04921853f, 
    -0.18033135f, -0.28552276f, -0.06415814f, 0.23148569f, 0.00204161f, -0.04909008f, -0.09301458f, -0.06613600f, 
    0.13002378f, -0.12370754f, 0.12367814f, -0.00045564f, 0.06589371f, 0.05634912f, -0.03186515f, 0.21707794f, 
    0.02360846f, -0.06453543f, 0.13847651f, 0.21346812f, -0.58003724f, 0.03929868f, -0.40169343f, -0.34936577f, 
    -0.33175337f, -0.02351467f, -0.04053484f, -0.09295753f, -0.07905168f, 0.23747514f, 0.03612572f, -0.00676135f, 
    -0.03071766f, -0.05330923f, -0.16677056f, -0.06913973f, -0.04003449f, 0.02414573f, -0.03253873f, 0.07856686f, 
    0.27810779f, 0.09958193f, 0.27061829f, -0.03179726f, -0.14065568f, 0.01941741f, -0.02090236f, -0.03103130f, 
    -0.00209491f, 0.04364784f, 0.00514335f, 0.03487422f, -0.02314819f, -0.13062696f, 0.01259685f, 0.00141751f, 
    -0.03085238f, -0.07245959f, 0.11018863f, -0.13304086f, -0.06682827f, 0.06463789f, 0.00301623f, 0.20287010f, 
    -0.14296867f, -0.14140068f, 0.06849036f, 0.06308206f, -0.04843584f, -0.09410437f, 0.01011251f, -0.01399219f, 
    0.02406429f, -0.01957558f, 0.08347838f, -0.21845932f, -0.03960558f, 0.02864255f, -0.03442970f, -0.39292994f, 
    -0.09628343f, -0.24878126f, 0.02611876f, 0.14532463f, -0.18121924f, 0.11672077f, -0.12624970f, -0.24725695f, 
    0.26171067f, -0.01735472f, 0.00387963f, 0.13261892f, -0.08523546f, -0.03901680f, 0.02795370f, 0.08732469f, 
    -0.01052371f, 0.00091443f, 0.09824617f, 0.37640610f, -0.17608429f, -0.49490228f, -0.21347812f, 0.29263294f, 
    0.13990718f, 0.02149208f, 0.05488747f, -0.12311734f, -0.01398291f, 0.08365361f, 0.26830453f, -0.08313940f, 
    0.16067813f, 0.07009968f, 0.11804379f, 0.10878741f, -0.02251606f, 0.10547727f, -0.07731358f, 0.11525833f, 
    -0.07962078f, -0.24074736f, -0.17215401f, -0.04778585f, 0.09396121f, 0.03518115f, -0.05440523f, -0.09027555f, 
    -0.04790748f, 0.01182494f, -0.03214015f, 0.07527766f, 0.10984197f, 0.07048871f, 0.18847449f, -0.02904768f, 
    0.01945922f, 0.08685172f, 0.14858708f, 0.08556534f, 0.64556736f, -0.31496468f, -0.25832000f, -0.13672024f, 
    0.11773533f, 0.04856638f, -0.06447837f, -0.02701574f, -0.09068559f, -0.00737516f, -0.15383838f, 0.08867679f, 
    -0.19354808f, -0.00282300f, 0.32336619f, 0.02143357f, -0.15524185f, 0.01784657f, -0.06959472f, 0.02086841f, 
    0.14199582f, 0.04562403f, 0.24924129f, 0.26739401f, -0.24301675f, 0.11906093f, 0.03798273f, 0.04018207f, 
    -0.03583309f, 0.09846358f, 0.08244714f, 0.04733831f, 0.00790876f, -0.02082712f, -0.00516322f, 0.00047492f, 
    0.10236798f, 0.02020003f, -0.21594739f, -0.17762953f, 0.16160426f, 0.05458467f, 0.19518359f, -0.09598744f, 
    -0.21447422f, 0.04489903f, 0.03832953f, 0.09195266f, 0.11723892f, 0.00183189f, 0.11127745f, 0.01544437f, 
    -0.02969313f, -0.01443185f, 0.04203101f, -0.02054228f, 0.07303777f, -0.03939024f, 0.06663907f, 0.17851658f, 
    0.20789231f, -0.00553053f, 0.36118031f, -0.10641273f, -0.18523970f, 0.22357625f, 0.12066878f, -0.07806624f, 
    -0.02698481f, -0.08480571f, 0.02215405f, 0.03301517f, 0.02253384f, -0.02044036f, 0.04056631f, 0.05309328f, 
    0.07692441f, -0.06896479f, 0.05940765f, 0.24513260f, -0.30854800f, 0.48199844f, -0.38281599f, -0.08139884f, 
    0.11181460f, -0.06305646f, -0.04151436f, -0.02234552f, 0.00866843f, -0.05786591f, 0.04225860f, -0.05375954f, 
    -0.12493665f, 0.08490279f, 0.00648648f, -0.24554284f, -0.03635491f, 0.19355547f, -0.12683138f, -0.20341936f, 
    -0.01309607f, 0.13740461f, 0.43428144f, 0.19142628f, -0.25687167f, 0.01286160f, -0.24189578f, 0.11454172f, 
    -0.03259817f, 0.08397623f, 0.06936102f, 0.04824063f, 0.00869255f, -0.00397296f, -0.02179309f, 0.09421243f, 
    -0.15391591f, 0.02279536f, -0.22989807f, -0.08015218f, -0.41550979f, -0.13161999f, -0.10467538f, 0.08391528f, 
    -0.66473228f, 0.30388677f, -0.13453294f, 0.07496522f, 0.08871642f, -0.05605386f, -0.00809592f, -0.05990065f, 
    -0.21318673f, -0.08557700f, 0.37274122f, -0.02873280f, 0.05653904f, 0.11404101f, 0.10001490f, -0.01936873f, 
    -0.33576220f, 0.03774240f, 0.01741131f, -0.45980585f, -0.05706035f, 0.06102214f, 0.08317639f, 0.08379268f, 
    -0.29448798f, -0.17753576f, 0.04383779f, 0.02573281f, 0.07769375f, -0.11954995f, 0.02122224f, 0.02907565f, 
    -0.05165006f, 0.04018057f, -0.01889423f, -0.01335718f, -0.15870464f, -0.04446023f, -0.46982291f, -0.27049443f, 
    -0.01277079f, -0.01142704f, 0.05271665f, -0.03997914f, -0.04528033f, 0.02006533f, -0.07632563f, 0.12719017f, 
    -0.09963838f, 0.14063214f, -0.04537495f, -0.10991397f, -0.02434458f, 0.02654948f, -0.01023681f, -0.01428373f, 
    0.26469886f, -0.05860893f, -0.02635921f, -0.59820926f, 0.43112791f, -0.04012268f, 0.43326014f, -0.12832671f, 
    0.20122226f, -0.03320760f, 0.08186691f, 0.10177065f, 0.02279157f, -0.05929552f, 0.01070641f, -0.07910427f, 
    -0.04071372f, -0.26703683f, -0.01460279f, -0.12930745f, 0.73315412f, 0.01287389f, -0.39556375f, 0.01891905f, 
    0.17187458f, 0.02045299f, 0.09396568f, 0.05939770f, -0.15410624f, 0.14748268f, 0.10148495f, 0.00123926f, 
    0.15301105f, -0.11099453f, -0.13046139f, 0.26616317f, 0.20830438f, -0.08133221f, -0.08451577f, 0.07818847f, 
    -0.01216974f, 0.08182385f, -0.15038945f, 0.24134172f, -0.13771103f, -0.00468372f, -0.14820321f, 0.05950886f, 
    0.08574960f, 0.09559180f, -0.06375584f, 0.05079941f, -0.07235941f, -0.08899746f, -0.04812131f, 0.06449872f, 
    0.04696676f, 0.22303307f, -0.12747209f, -0.01580806f, -0.12920129f, -0.12662554f, -0.21943621f, 0.10157012f, 
    0.13536732f, 0.09210026f, -0.08969979f, 0.03752604f, -0.01416388f, -0.06972535f, 0.08703712f, -0.12705275f, 
    0.03106043f, 0.10279860f, -0.08158858f, 0.11552810f, 0.05109174f, 0.27034256f, -0.07774841f, 0.03692828f, 
    -0.04170353f, 0.00716776f, 0.00421099f, -0.20708174f, -0.04944332f, -0.02937771f, 0.05823742f, 0.04842047f, 
    -0.04746421f, -0.00868509f, -0.00626537f, -0.07840637f, -0.01052011f, -0.03188862f, -0.08387450f, 0.08194581f, 
    0.00884905f, -0.11147439f, -0.05597215f, 0.10879816f, -0.32403955f, -0.18499869f, 0.29089120f, -0.10555837f, 
    -0.05056947f, 0.01021514f, -0.21757250f, 0.00123336f, 0.05735264f, 0.08707316f, 0.25928587f, 0.15427782f, 
    -0.06732693f, 0.13678657f, -0.10184014f, 0.00375613f, 0.04865856f, 0.12876545f, -0.06296742f, 0.08455474f, 
    0.23646072f, -0.16695155f, -0.25175503f, -0.19621789f, 0.11118422f, -0.01790062f, 0.07616246f, 0.11195408f, 
    -0.03387655f, 0.01215487f, -0.06878405f, -0.03497396f, -0.07826915f, -0.13407917f, -0.00070238f, -0.15721774f, 
    -0.10977474f, -0.32063115f, 0.00623459f, 0.05115033f, -0.36064032f, -0.46676165f, -0.97274494f, -0.08185215f, 
    0.10209230f, -0.26754010f, -0.08740108f, -0.17699817f, -0.19166778f, -0.30724701f, -0.03494877f, -0.02154507f, 
    -0.05625432f, 0.03649984f, 0.06060749f, -0.05892008f, 0.03053419f, 0.01039361f, 0.20592289f, 0.08944346f, 
    0.14201646f, 0.03294094f, -0.02752113f, -0.05714670f, 0.01575486f, 0.00224466f, -0.02688593f, -0.04308026f, 
    -0.00717303f, -0.01833361f, -0.00106276f, -0.05515958f, -0.16730888f, -0.05310523f, 0.08885805f, -0.02362553f, 
    -0.05661573f, 0.04755610f, -0.08940232f, -0.14080794f, -0.22069997f, 0.12665047f, 0.15533145f, 0.10876769f, 
    0.20564625f, 0.04144943f, 0.04179511f, -0.01190014f, 0.04250000f, -0.07549003f, 0.12031605f, 0.10608596f, 
    0.21813251f, 0.20324853f, 0.11637557f, 0.09076957f, -0.01719685f, 0.03137527f, -0.00755971f, 0.07811061f, 
    -0.50425684f, 0.18969445f, 0.33713937f, -0.01560474f, -0.12626334f, -0.21141168f, -0.10449124f, -0.12674381f, 
    -0.24809130f, 0.20001036f, -0.19464250f, 0.09448623f, -0.08965956f, -0.01556806f, 0.06630977f, -0.00041893f, 
    -0.00133558f, -0.02865651f, 0.03422766f, -0.07316791f, -0.05058312f, -0.52462351f, 0.26980862f, 0.16610520f, 
    -0.12821808f, -0.06378723f, 0.06891775f, 0.12649804f, -0.00746238f, 0.02805948f, 0.06512401f, 0.01041924f, 
    0.01225968f, 0.10008004f, -0.02329838f, 0.18481196f, 0.14599842f, 0.09117352f, 0.12127687f, 0.03823718f, 
    -0.21059224f, -0.61062801f, -0.72018701f, 0.05577079f, 0.04501275f, -0.13681591f, -0.04509186f, -0.01953948f, 
    -0.09559649f, -0.00551785f, -0.04068623f, 0.00531504f, 0.05865079f, -0.09921568f, -0.05932919f, -0.01029363f, 
    -0.01253500f, -0.14037378f, 0.14318751f, -0.06254502f, -0.61761731f, -0.14813468f, -0.13244285f, -0.16392048f, 
    -0.14243846f, -0.02072014f, 0.05088343f, 0.06093375f, -0.00557461f, 0.00266587f, -0.01850545f, -0.00060071f, 
    0.01810188f, 0.01712950f, -0.02955802f, 0.13108280f, 0.08668194f, -0.00145039f, -0.06066725f, -0.00084594f, 
    -0.44023579f, -0.65173900f, -0.02343323f, 0.14183556f, -0.13896385f, 0.04584667f, -0.12059503f, -0.11061921f, 
    -0.07609355f, 0.10090353f, 0.01172315f, 0.09661981f, 0.04938942f, 0.06603564f, -0.07297254f, -0.01493112f, 
    0.09031238f, 0.11352738f, -0.11771084f, 0.06814273f, -0.14949892f, 0.11753232f, 0.29962453f, -0.03738637f, 
    -0.03956467f, -0.02589991f, -0.05492746f, -0.06905394f, -0.15804246f, -0.14809272f, -0.06125077f, -0.01173995f, 
    -0.05049321f, 0.00492227f, 0.01568765f, -0.01940794f, -0.06612746f, 0.01823997f, -0.11854956f, -0.08154261f, 
    -0.03376866f, -0.15048939f, 0.09576459f, 0.06066933f, 0.07268996f, -0.03327708f, 0.11550128f, -0.01789478f, 
    -0.07279732f, -0.03089844f, 0.13484770f, -0.05005143f, -0.16062503f, 0.03609550f, -0.06184025f, -0.00831090f, 
    0.01944929f, 0.01175911f, 0.07850070f, -0.04591824f, -0.76006955f, 0.67486238f, 0.59652323f, -0.12898961f, 
    0.35396007f, -0.20260644f, -0.09443186f, -0.05268191f, -0.10544147f, 0.22777079f, -0.05238726f, 0.14579628f, 
    0.09840082f, 0.16498764f, 0.02732103f, 0.03136442f, -0.03861140f, -0.03218184f, 0.05202208f, -0.03963139f, 
    -0.15496397f, -0.50147605f, -0.38475412f, 0.07091725f, -0.23000580f, 0.01481484f, 0.09311328f, -0.01748140f, 
    0.03712145f, -0.14648484f, 0.04237600f, -0.02632371f, 0.02900338f, 0.07528822f, 0.05440289f, 0.06249268f, 
    0.09271996f, 0.18032849f, 0.23026347f, 0.12786663f, -0.24763745f, -0.51724011f, -0.37395412f, -0.00945568f, 
    0.25225502f, -0.11402187f, -0.16745119f, -0.03676640f, -0.08986448f, -0.04159511f, 0.04157803f, -0.03648008f, 
    0.04688730f, -0.14358464f, -0.07154741f, 0.04918148f, 0.01561099f, -0.07607873f, 0.16570900f, -0.07075639f, 
    -0.13841531f, -0.06022699f, 0.16021773f, -0.08954800f, 0.07094041f, 0.06723627f, 0.16507696f, 0.02514643f, 
    -0.05367199f, 0.19866300f, -0.01679464f, 0.08480754f, -0.07063376f, 0.10394111f, -0.04324091f, -0.00894579f, 
    0.02471363f, -0.02697019f, 0.02840593f, 0.08742884f, -0.07997949f, 0.15286067f, -0.03330516f, -0.24199629f, 
    0.14759436f, -0.01811673f, -0.06141793f, 0.11662179f, 0.02711965f, -0.05108504f, -0.07892113f, -0.03039550f, 
    -0.07043227f, 0.06159280f, 0.00275705f, 0.14173362f, 0.06228776f, -0.01236813f, -0.23755448f, 0.13003930f, 
    -0.06539188f, 0.11115189f, -0.03045976f, -0.04725764f, 0.08383834f, -0.01353858f, -0.03758784f, -0.07510147f, 
    0.01045497f, 0.11127659f, -0.00596223f, -0.03407257f, 0.08986650f, -0.02761053f, 0.18883802f, 0.05527540f, 
    -0.01797121f, -0.15360899f, -0.05532280f, 0.00709053f, -0.13633297f, 0.09023444f, -0.19597596f, -0.15235096f, 
    0.08730592f, 0.01598356f, 0.01438374f, -0.09894745f, 0.02513455f, 0.07264335f, 0.00031905f, -0.02454885f, 
    0.00991017f, 0.02667158f, -0.19518720f, 0.06288755f, 0.18873568f, 0.00398022f, 0.18862790f, 0.07366790f, 
    -0.48926073f, -0.45039663f, -0.67757076f, -0.11896487f, 0.13735613f, -0.11963064f, 0.17781515f, 0.13253802f, 
    -0.11933291f, -0.31554598f, 0.01730475f, -0.02769278f, 0.01249770f, 0.07139171f, 0.07102164f, 0.02271921f, 
    0.02521996f, 0.08360398f, 0.22751124f, 0.09210625f, -0.84010404f, -0.23188350f, 0.37087819f, -0.06514900f, 
    -0.12204069f, -0.07580404f, -0.12603493f, -0.02202403f, -0.07607578f, -0.13524292f, 0.00593179f, 0.05321782f, 
    0.00679592f, 0.00719152f, 0.01291067f, 0.02510557f, -0.02055589f, 0.00326608f, 0.04785983f, -0.11998233f, 
    -0.91742206f, -0.87629133f, -0.54157013f, -0.30335063f, 0.25145209f, -0.15689178f, -0.03136228f, -0.32871145f, 
    -0.12422067f, -0.53355813f, 0.02848880f, -0.06156483f, -0.08513370f, -0.03289836f, 0.01561598f, 0.01677374f, 
    0.00774382f, 0.12780969f, 0.07713644f, 0.04620347f, -0.03219105f, 0.01542292f, 0.03353424f, 0.07024546f, 
    0.11756448f, -0.02617345f, -0.05548904f, -0.08687509f, 0.01563237f, 0.10313650f, -0.17094773f, 0.16738550f, 
    0.20641829f, 0.17502445f, 0.03264280f, 0.01437505f, 0.10843549f, -0.00969950f, 0.05516062f, 0.01041183f, 
    -0.53612059f, -0.32662144f, -0.77885741f, -0.30719268f, 0.25245997f, -0.32824272f, 0.15097246f, -0.13914280f, 
    0.10394251f, -0.12447045f, -0.01287246f, -0.03533202f, 0.00240101f, -0.03962155f, 0.11186641f, 0.01902116f, 
    -0.04926226f, 0.11375447f, 0.23252133f, 0.09322770f, -0.35286313f, -0.19199407f, 0.48383960f, 0.02889665f, 
    -0.05845695f, -0.21987401f, -0.03268105f, -0.13772340f, -0.17268869f, 0.27058911f, -0.14603452f, 0.05527386f, 
    0.14931689f, 0.00996955f, -0.04072102f, -0.02253243f, 0.06208776f, -0.10325463f, 0.11852429f, -0.08383871f, 
    -0.29575703f, 0.20880324f, 0.39663228f, 0.24329261f, 0.07606674f, 0.07877328f, 0.00617800f, 0.05379860f, 
    -0.14279544f, 0.00872956f, -0.11567090f, 0.13585454f, 0.08329142f, 0.13701260f, 0.03374171f, 0.04289478f, 
    -0.00128739f, 0.06402054f, -0.12662160f, -0.02824617f, -0.37991291f, 0.37906709f, 0.36768001f, 0.00318842f, 
    0.32829136f, -0.04061339f, -0.07741407f, -0.04049552f, -0.08190098f, 0.20278217f, -0.03704647f, 0.12487137f, 
    0.06114751f, 0.03623279f, -0.00065320f, 0.03819082f, -0.00633983f, -0.02947788f, 0.01654659f, 0.01712904f, 
    0.63250721f, -0.27914718f, -0.63037461f, -0.09628592f, -0.73465091f, 0.10016238f, 0.20197177f, 0.04339038f, 
    -0.17066962f, -0.76588637f, 0.03534352f, 0.03135866f, -0.02167373f, 0.02148313f, 0.13083731f, -0.02788323f, 
    -0.06671222f, 0.25538433f, 0.00608959f, 0.02247892f, 0.33190292f, 0.19839951f, -0.15838224f, -0.22683221f, 
    0.15508404f, -0.06849933f, -0.11425780f, 0.02471867f, 0.12537193f, -0.02069958f, 0.05494157f, -0.03058127f, 
    0.02201770f, -0.19961461f, -0.08227080f, -0.02869822f, 0.02531950f, -0.08809555f, -0.13021907f, 0.06534461f, 
    0.28392830f, -0.42454323f, -0.58894980f, -0.30259737f, 0.24807376f, -0.09087914f, 0.14082453f, 0.32966146f, 
    0.21029203f, -0.10717896f, 0.02744200f, -0.02968687f, -0.10761785f, -0.03601960f, 0.04871907f, 0.00645374f, 
    0.04182744f, 0.00742393f, 0.26847935f, 0.08414596f, 0.13799286f, -0.27555785f, -0.03082883f, 0.03700474f, 
    0.12016591f, -0.07666660f, 0.02362813f, 0.10007347f, -0.03300137f, -0.00242960f, -0.04903324f, -0.07849041f, 
    -0.13276316f, -0.07679833f, -0.02000572f, -0.17692219f, -0.06083333f, -0.01117322f, -0.08745896f, 0.00586676f, 
    0.00987648f, 0.11870250f, 0.06694589f, 0.05855143f, -0.12567136f, -0.00263096f, 0.01716131f, 0.01819406f, 
    -0.00526497f, -0.03503034f, 0.07427925f, 0.04576905f, 0.04434629f, 0.01340321f, -0.05361429f, -0.05283088f, 
    -0.19436201f, -0.19716850f, 0.07844450f, -0.03536827f, 0.54759681f, 0.15632853f, 0.34996372f, -0.45358771f, 
    0.04496195f, -0.25951040f, 0.27017900f, 0.05424757f, 0.06887676f, -0.16144934f, -0.01783674f, -0.08448747f, 
    0.18440285f, 0.01366845f, 0.06109977f, -0.12078121f, 0.04184472f, -0.03898283f, 0.01145492f, 0.03980036f, 
    -0.02101645f, 0.08763468f, 0.04827392f, -0.00848981f, -0.13214403f, -0.02106253f, -0.02779460f, -0.04418547f, 
    -0.03171236f, -0.06896508f, 0.04202374f, 0.05497797f, 0.03575178f, -0.00619771f, 0.03078447f, -0.07428335f, 
    -0.25248498f, 0.14837570f, 0.05688911f, 0.01833440f, -0.07734773f, -0.49247134f, -0.20495129f, -0.16581644f, 
    -0.05017349f, 0.01603700f, 0.01509010f, -0.03588880f, 0.22037852f, 0.20759955f, -0.05578431f, -0.00643998f, 
    -0.08886575f, -0.11430719f, -0.08700156f, 0.01129184f, 0.07829079f, -0.02961269f, 0.19261450f, -0.00197941f, 
    -0.10497111f, -0.05648265f, 0.03789539f, 0.02822120f, -0.00874240f, 0.01684199f, 0.01533599f, 0.05388631f, 
    0.01152393f, 0.00822149f, 0.05966363f, -0.00977865f, 0.04688238f, -0.02205843f, 0.00176283f, 0.01342376f, 
    0.04626381f, -0.04401515f, 0.08340254f, 0.04801555f, -0.16532063f, -0.10809673f, 0.23935676f, 0.16752359f, 
    0.10996076f, 0.09498335f, 0.05428445f, 0.18873209f, -0.01871342f, -0.04555845f, -0.08223888f, 0.02994697f, 
    0.01755325f, -0.01129845f, -0.02496384f, -0.09648687f, 0.08795334f, -0.01665894f, 0.04118456f, 0.14151084f, 
    0.60269570f, -0.49496508f, -0.32100469f, -0.04768164f, -0.07804957f, 0.14585556f, -0.05788032f, -0.12905060f, 
    -0.10398930f, -0.08681724f, 0.02741575f, 0.07554881f, 0.08108485f, 0.03390741f, -0.02018128f, 0.04235466f, 
    -0.04418777f, 0.05741683f, -0.01586133f, -0.07394830f, 0.27527022f, 0.08265974f, -0.02321543f, 0.13019922f, 
    -0.58527058f, -0.01048481f, 0.06658548f, -0.06377804f, -0.00396060f, 0.03342189f, -0.08056987f, -0.02721817f, 
    -0.03315260f, 0.04028289f, -0.04367763f, 0.00949246f, -0.06012575f, 0.02005415f, -0.22974765f, 0.07111018f, 
    0.30825216f, -0.34200627f, -0.31142554f, 0.26735911f, -0.11532399f, 0.07396556f, -0.01778595f, -0.19811489f, 
    0.11853330f, 0.04673249f, 0.01872652f, 0.02577215f, -0.09371734f, 0.00430918f, 0.00400288f, -0.08594136f, 
    0.00993432f, -0.00782608f, -0.07405490f, -0.10971981f, -0.02726148f, 0.30007836f, -0.06664885f, -0.04794777f, 
    -0.17128599f, 0.04197508f, 0.03949675f, 0.06729550f, -0.06337401f, -0.04159661f, 0.07415910f, 0.04353490f, 
    0.04901563f, 0.02446103f, 0.00993451f, 0.10036512f, -0.01342563f, -0.08813893f, -0.28192315f, -0.30220255f, 
    0.36172470f, -0.93218553f, 0.82873732f, -0.64541793f, -0.24021010f, -0.33161545f, 0.37125054f, -0.28653929f, 
    0.43069360f, -0.09335649f, -0.02227350f, -0.00021515f, -0.00145628f, -0.09006771f, 0.00164141f, -0.18065257f, 
    -0.00894632f, -0.12353065f, 0.01733324f, -0.06852885f, 0.05396213f, -0.05122314f, 0.03223241f, -0.08788001f, 
    0.02562322f, 0.09815232f, 0.06776785f, -0.02248297f, -0.01730042f, -0.02851273f, 0.03535321f, -0.08433796f, 
    0.06792755f, 0.02918590f, -0.00112833f, 0.02019927f, 0.04717121f, -0.06740008f, 0.00522567f, -0.03413502f, 
    0.05431935f, 0.16660528f, -0.09727185f, -0.07854100f, -0.13489915f, -0.02070463f, 0.04124112f, 0.00993570f, 
    -0.00143351f, -0.05359307f, -0.21837327f, 0.06048177f, 0.03204195f, -0.13202718f, -0.12134761f, -0.02495958f, 
    -0.08538494f, -0.01873410f, -0.06947000f, -0.02090759f, 0.67401844f, -0.74128598f, -0.68735301f, -0.17450559f, 
    -0.31965968f, -0.07693846f, -0.22828312f, -0.17522249f, 0.33207715f, -0.17483085f, 0.01654355f, 0.10215592f, 
    0.08062701f, 0.05595269f, 0.06654144f, -0.00030669f, -0.00071641f, 0.02434172f, 0.06576147f, 0.00444044f, 
    -0.37497199f, -0.67184246f, 0.38672271f, -0.21660410f, 0.49293280f, -0.16030324f, -0.10483746f, 0.06371588f, 
    0.02053995f, -0.02013897f, -0.01553542f, 0.02766530f, -0.06506012f, -0.07798468f, -0.01253856f, 0.06724217f, 
    0.10649874f, 0.06712790f, 0.06812815f, -0.14971760f, 0.32071567f, -0.49083346f, -0.34397793f, -0.27415180f, 
    -0.20110549f, -0.07015405f, -0.06207248f, -0.15070882f, 0.15395012f, 0.05941385f, 0.01156342f, -0.00335268f, 
    -0.14038485f, 0.01694327f, 0.01667407f, -0.10418183f, 0.04430515f, -0.04822240f, 0.01308419f, -0.03162888f, 
    0.45304626f, 0.02243600f, -0.26017067f, -0.16292690f, -0.18533184f, -0.14234106f, 0.11844136f, 0.00238605f, 
    -0.18524048f, -0.04144932f, -0.02164447f, -0.03861769f, 0.09998032f, -0.08100346f, -0.15745321f, -0.04170040f, 
    -0.03804577f, 0.02322799f, -0.11909556f, -0.05686132f, -0.03872987f, 0.05238527f, 0.14895332f, 0.09282508f, 
    -0.03549597f, -0.05901237f, -0.07911070f, 0.12592566f, -0.07948643f, -0.03514884f, 0.02375403f, 0.06199188f, 
    0.01268596f, 0.03978159f, -0.11601496f, -0.21660355f, -0.29019830f, 0.01623221f, -0.01695235f, 0.07221229f, 
    0.06469913f, 0.08563890f, -0.03704092f, -0.01418612f, -0.12022527f, 0.01695691f, 0.01784470f, -0.01896404f, 
    -0.04986559f, -0.01191860f, -0.04635173f, -0.14397901f, -0.20257862f, -0.13910736f, -0.27953503f, 0.05928303f, 
    0.01486639f, -0.01186684f, 0.02635386f, -0.03321661f, 0.00095762f, -0.07923436f, -0.10098434f, 0.16736251f, 
    -0.33134341f, 0.00887914f, 0.03801047f, 0.02432425f, -0.02207339f, -0.00344931f, -0.07281650f, -0.02162237f, 
    -0.00785953f, -0.00399322f, -0.05544829f, -0.01879757f, -0.06764795f, -0.09656394f, 0.01287945f, 0.04834268f, 
    -0.17113897f, -0.05965604f, 0.25296977f, 0.27362263f, -0.00294351f, 0.12420519f, 0.14517875f, -0.04790393f, 
    -0.06645103f, 0.17418762f, 0.04294576f, -0.05834450f, -0.00853383f, -0.00234733f, 0.00595300f, 0.03070632f, 
    0.13448246f, -0.04713364f, -0.04160441f, -0.07003360f, 0.34155667f, -0.79589003f, -0.27916068f, -0.07409552f, 
    -0.12861174f, -0.03914217f, 0.08179078f, -0.13589835f, -0.02938082f, 0.04094538f, -0.03740756f, 0.06697804f, 
    -0.03034598f, -0.01276812f, 0.02888702f, -0.04197710f, -0.00256431f, -0.04807415f, -0.06310166f, -0.02612902f, 
    -0.28247258f, -0.54075557f, 0.07154872f, 0.31948802f, 0.14197595f, -0.02641485f, 0.14205182f, 0.00800349f, 
    -0.01905329f, 0.11906517f, 0.05547161f, 0.02088308f, -0.01405445f, -0.01078289f, -0.04259457f, 0.00743804f, 
    0.01175816f, -0.03078004f, 0.20298810f, -0.01480723f, 0.09624348f, 0.15752490f, -0.06115207f, 0.04357224f, 
    -0.28364423f, -0.02325865f, 0.03593577f, -0.03719717f, -0.00717649f, -0.00769964f, -0.05688675f, -0.09048038f, 
    -0.04983147f, -0.01349520f, -0.17417644f, 0.01494262f, -0.04231279f, -0.08995733f, 0.01183286f, 0.09617732f, 
    -0.29817685f, -0.09109803f, -0.27424887f, 0.60888547f, -0.31660733f, 0.14623095f, 0.07655156f, 0.08097902f, 
    -0.13286680f, 0.18801910f, 0.02600519f, -0.02060472f, -0.05150873f, 0.01493983f, -0.00152972f, 0.00799671f, 
    0.09794606f, -0.05850178f, 0.06967565f, 0.03817980f, 0.34626016f, 0.22921138f, -0.23078699f, -0.23113218f, 
    -0.20137471f, 0.16714157f, -0.01758157f, -0.13964769f, 0.05766699f, 0.04205390f, 0.08610219f, 0.11235956f, 
    0.08410554f, -0.06321441f, 0.06263310f, 0.01514260f, 0.03959571f, -0.01552952f, 0.02862540f, -0.05052990f, 
    -0.11205421f, -0.25727451f, 0.05556919f, -0.19330510f, -0.04346686f, -0.15239652f, -0.04165977f, 0.02884758f, 
    0.15022248f, 0.05131920f, -0.03681301f, -0.07831669f, 0.06906648f, -0.06562059f, -0.02033567f, -0.06669246f, 
    0.00442839f, -0.08558591f, 0.07250994f, -0.02120905f, 0.17467348f, -0.16409367f, -0.36967918f, -0.17464449f, 
    -0.15576345f, 0.00195508f, -0.09977588f, 0.01898490f, 0.11827673f, -0.01372285f, -0.01301041f, 0.00228013f, 
    -0.00372694f, 0.05565311f, 0.08583049f, 0.03971857f, 0.03679804f, 0.01179460f, 0.07782783f, 0.09298636f, 
    -0.80777025f, -0.71797240f, 0.74355942f, -0.33483955f, 0.41182441f, 0.14210461f, -0.16689825f, 0.12436597f, 
    -0.01267317f, 0.10558277f, 0.06554424f, -0.06419016f, 0.08857941f, 0.02764666f, -0.07466112f, 0.20029269f, 
    -0.06658601f, 0.01092782f, -0.22409622f, -0.19682513f, -0.12451117f, 0.16795151f, -0.18323034f, 0.05884762f, 
    -0.07269305f, 0.00984201f, -0.03901609f, 0.05831742f, -0.03623702f, -0.01424455f, 0.09040815f, -0.00481188f, 
    0.04579681f, -0.00300360f, 0.09657384f, -0.02888568f, -0.13150866f, 0.08009341f, -0.14359899f, 0.06700508f, 
    -0.33167738f, -0.10297725f, -0.12358961f, 0.15271670f, -0.21557799f, 0.07873832f, -0.05651622f, -0.06680977f, 
    0.08841066f, 0.10371643f, 0.04089535f, 0.03732614f, 0.01774639f, 0.05497809f, -0.02527690f, 0.06944278f, 
    -0.02234429f, -0.12219705f, -0.08950957f, 0.06648215f, -0.02615981f, 0.13228062f, 0.02175036f, 0.04480794f, 
    -0.11866996f, -0.00614360f, -0.01228370f, 0.03548838f, -0.02929313f, -0.03448811f, 0.03411264f, -0.02278087f, 
    0.04992782f, 0.05830857f, -0.06137339f, -0.05890551f, -0.16952528f, 0.06140211f, 0.04380938f, 0.04756714f, 
    -0.69929624f, 0.16341862f, 0.24640590f, -0.00763667f, -0.30645341f, -0.07781547f, -0.10216488f, -0.09610166f, 
    0.00855496f, -0.07371605f, -0.11258040f, -0.07199419f, -0.05893323f, -0.04190836f, -0.07360363f, -0.00110165f, 
    -0.09404819f, -0.09047274f, -0.17320931f, 0.03708327f, 0.18321858f, -0.12119953f, -0.28206649f, -0.13343790f, 
    -0.19224861f, 0.09732244f, -0.24679092f, 0.26307571f, 0.15913095f, 0.22795036f, 0.13819441f, 0.05329105f, 
    -0.10136106f, -0.06779419f, 0.14711659f, 0.04572655f, 0.13531594f, 0.08826863f, -0.19462790f, 0.20338275f, 
    -0.28447074f, 0.25367180f, 0.15722609f, 0.08062977f, -0.17990635f, 0.00622735f, -0.03303828f, -0.06294797f, 
    0.01796493f, -0.08397364f, -0.10753236f, -0.02988816f, 0.02511675f, -0.04549440f, 0.00706490f, -0.00828564f, 
    0.04679106f, 0.01900610f, -0.00943732f, 0.00841294f, -0.04878766f, -0.27487665f, -0.63147777f, -0.44484928f, 
    -0.31526241f, -0.15892008f, -0.19111058f, -0.08086881f, -0.09223614f, -0.35314310f, 0.02114109f, -0.00367365f, 
    -0.04499932f, 0.03300874f, 0.10387184f, 0.07605305f, 0.00327865f, 0.11215688f, -0.15188098f, -0.30309644f, 
    0.13037339f, 0.04651529f, -0.02772680f, 0.06583815f, -0.03359274f, -0.05048126f, -0.05283033f, -0.11640258f, 
    -0.02704601f, -0.05035556f, 0.03614232f, 0.06829707f, 0.07643390f, -0.02547702f, 0.08036116f, -0.00649219f, 
    0.16436076f, 0.14015053f, 0.16196683f, 0.15546817f, -0.43567264f, -0.33337989f, 0.23508368f, 0.08954029f, 
    0.24882312f, -0.12122311f, 0.03514257f, -0.09145585f, -0.07838453f, -0.00318072f, -0.07648467f, 0.12700343f, 
    -0.00420700f, 0.12967226f, 0.02888505f, -0.01067866f, -0.11142927f, -0.05035560f, -0.02484789f, -0.02192733f, 
    0.19816463f, -0.28817302f, -0.43288329f, -0.26658991f, -0.05211411f, -0.05298204f, -0.13899435f, 0.03015404f, 
    -0.07470424f, 0.14736846f, 0.03183438f, -0.04258664f, -0.10531848f, -0.09904569f, -0.06345640f, -0.00021925f, 
    0.00478029f, 0.03886949f, 0.09318405f, 0.03640552f, 0.03881444f, 0.29368854f, 0.09207940f, 0.19993247f, 
    -0.38544708f, -0.22876450f, 0.05159358f, -0.08172020f, 0.09337709f, -0.05381354f, 0.09161539f, 0.08919527f, 
    -0.00381993f, 0.04556400f, 0.05758229f, -0.09936660f, -0.18222509f, -0.12726796f, -0.11128494f, -0.06322692f, 
    0.08130044f, -0.24993001f, -0.54472256f, -0.20640829f, 0.07130273f, 0.08245079f, 0.07330126f, 0.04943806f, 
    0.11200403f, 0.00365336f, 0.04535019f, -0.03780802f, 0.04100751f, 0.12305337f, 0.04125976f, 0.05597296f, 
    -0.11295693f, -0.05784638f, 0.01058668f, -0.10852198f, -0.83678472f, 0.16408649f, 0.37376794f, 0.09483359f, 
    -0.27552450f, -0.12360736f, -0.04687114f, -0.14223941f, -0.10490341f, -0.11696749f, -0.13890398f, -0.06886224f, 
    -0.02975987f, -0.12180489f, -0.04275497f, -0.20886660f, -0.22921184f, -0.11829505f, -0.06989831f, -0.16212597f, 
    0.12541981f, -0.21857692f, -0.96705151f, -0.25422159f, 0.12585960f, 0.22113217f, -0.17164776f, 0.31983563f, 
    0.11049648f, 0.11279058f, 0.05077739f, 0.05019733f, 0.02957769f, -0.04412819f, 0.03015656f, 0.04212059f, 
    0.03721967f, 0.02701069f, -0.08296067f, -0.04202098f, -0.10007109f, -0.18415602f, -0.15411937f, 0.03008636f, 
    -0.07099985f, -0.10707371f, -0.04474214f, 0.06603755f, 0.02374869f, 0.12322189f, 0.02239911f, -0.01060225f, 
    0.06825019f, -0.05137431f, 0.00239526f, -0.05856175f, 0.15160953f, 0.11927264f, 0.19887048f, 0.15831730f, 
    0.18864636f, 0.12626576f, 0.03289589f, 0.04596696f, -0.26470718f, -0.04368863f, 0.04261700f, 0.04202967f, 
    0.03744679f, -0.08291648f, 0.04959816f, 0.03398858f, -0.06294969f, 0.10087375f, 0.09770215f, 0.06282227f, 
    0.21583605f, 0.01664775f, 0.11328281f, 0.08490109f, -0.12336637f, -0.51081645f, -0.99869883f, -0.41884440f, 
    0.24277453f, -0.10264754f, 0.12988335f, 0.23977086f, 0.21689758f, 0.08614339f, 0.07804818f, -0.09780537f, 
    0.01800457f, -0.01070990f, -0.11953251f, -0.01350032f, -0.03671421f, -0.00720723f, -0.00012809f, -0.04079386f, 
    0.67926723f, -0.12110418f, -0.07041804f, -0.03459421f, -0.05949710f, 0.01073221f, -0.09424355f, 0.14806382f, 
    0.11532776f, 0.03744620f, 0.07897595f, 0.01041857f, 0.00595876f, 0.03968916f, 0.02037567f, 0.06903183f, 
    -0.09877172f, -0.11878145f, -0.25791311f, -0.47224683f, 0.04668988f, -0.15889408f, -0.68750638f, -0.45030421f, 
    -0.03914136f, 0.02921506f, 0.14227627f, 0.06977134f, 0.03577724f, 0.02316849f, 0.00804371f, 0.01546113f, 
    -0.05231913f, 0.15096803f, 0.08082292f, 0.09021303f, -0.07782236f, 0.08024573f, -0.06221452f, 0.03165971f, 
    0.31527865f, 0.15297666f, -0.19443648f, -0.04811019f, -0.15262440f, 0.03548738f, 0.12267542f, 0.16129290f, 
    0.18626532f, 0.00014694f, 0.17280728f, -0.04230905f, 0.01025250f, 0.00037721f, 0.02745858f, 0.07322519f, 
    0.11520149f, 0.01504139f, 0.13840424f, -0.03731153f, 0.00608991f, -0.03515596f, 0.15686497f, 0.03122201f, 
    0.02435302f, 0.09946156f, 0.09817552f, -0.01123684f, -0.08989237f, 0.18345630f, 0.04955632f, -0.02744338f, 
    0.01295529f, 0.10268603f, 0.00814929f, 0.01812121f, 0.13390493f, 0.01230612f, 0.10085826f, 0.02953652f, 
    -0.14404000f, 0.02506583f, 0.02648669f, -0.09999957f, -0.19330205f, -0.03947702f, -0.00272338f, -0.03157382f, 
    -0.00817140f, -0.01066514f, 0.03034405f, 0.00940303f, 0.02305267f, 0.13206172f, 0.13715945f, 0.01424464f, 
    0.01708994f, 0.03165519f, -0.03108569f, -0.00885796f, 0.29179642f, 0.18541957f, 0.16510397f, -0.06745572f, 
    -0.23618060f, -0.04946036f, -0.06356226f, -0.13363625f, -0.01463510f, -0.00809345f, 0.00042844f, -0.00492684f, 
    -0.00751733f, -0.09508499f, -0.05756730f, -0.19278969f, -0.04975385f, -0.00499538f, -0.25916767f, -0.37342694f, 
    0.30952084f, 0.04856275f, 0.31541458f, 0.02917769f, -0.28050557f, 0.16821893f, -0.19986102f, -0.13859384f, 
    -0.09304976f, -0.16820596f, -0.01235011f, -0.01376602f, 0.05127665f, -0.02635936f, 0.00007708f, 0.08331363f, 
    -0.08663149f, -0.09872954f, 0.03365248f, -0.47209507f, 0.12851138f, -0.21519366f, -0.50243658f, -0.22692405f, 
    0.12391257f, 0.07108194f, -0.15631586f, 0.07460141f, 0.11263458f, 0.22699797f, -0.08794059f, 0.00247673f, 
    -0.01868347f, -0.05846319f, 0.03320652f, 0.03310920f, 0.08428334f, 0.07749241f, 0.01079918f, 0.18237203f, 
    0.31114912f, -0.56813240f, -0.50003082f, -0.08739142f, -0.14116615f, 0.02373217f, -0.06566875f, 0.03624694f, 
    0.07989930f, -0.01920032f, -0.07863635f, 0.03220488f, -0.01153584f, 0.02075416f, 0.06830453f, 0.04166711f, 
    0.03975433f, 0.11591361f, 0.05899371f, 0.22449318f, 0.04488719f, 0.08375785f, 0.00892190f, -0.04866960f, 
    -0.16269059f, -0.14465646f, -0.02776449f, -0.08173284f, 0.05091817f, -0.07423554f, -0.00671259f, 0.08999143f, 
    0.02670787f, 0.02597675f, 0.00428443f, -0.01777739f, -0.06555826f, -0.08040283f, -0.04282949f, -0.08581613f, 
    0.39103070f, 0.00843997f, -0.06851905f, -0.25811923f, -0.22684960f, 0.00161975f, -0.06501876f, -0.21150836f, 
    -0.18324061f, -0.34011665f, 0.04107813f, -0.02719745f, 0.04547017f, -0.00107681f, 0.02812804f, 0.11751108f, 
    0.04861564f, -0.03905394f, -0.05248304f, -0.41571873f, -0.02904915f, -0.06650383f, -0.74410421f, -0.31647936f, 
    -0.23993357f, -0.08198402f, 0.03764829f, 0.01849093f, 0.16177326f, -0.04320529f, 0.15728290f, -0.05129044f, 
    0.18909478f, 0.01857921f, 0.18490689f, -0.05538473f, 0.01771643f, -0.00697592f, 0.04070061f, -0.00135895f, 
    -0.17909561f, -0.16270316f, -0.16551059f, 0.26500931f, 0.23029944f, -0.05977859f, 0.11900935f, 0.15705445f, 
    0.08715920f, 0.28752360f, 0.07350742f, -0.00825853f, 0.00453816f, -0.08144017f, -0.01660292f, -0.08107876f, 
    0.13909872f, 0.00985329f, 0.00616812f, -0.00548818f, -0.03421498f, -0.33134887f, -0.14452395f, -0.00200563f, 
    0.13856044f, -0.05202882f, 0.03368190f, 0.15173879f, 0.16214950f, 0.14825180f, 0.17664061f, -0.07850560f, 
    -0.03844997f, -0.05518128f, -0.08851722f, 0.04710427f, 0.00363375f, 0.02183457f, 0.03110741f, -0.06483134f, 
    -0.51069921f, -0.43551177f, 0.08548770f, 0.11947889f, 0.14613162f, 0.09689310f, 0.20122612f, -0.01223673f, 
    -0.04353754f, -0.01032454f, 0.01725848f, -0.01774679f, 0.13988487f, -0.00788005f, 0.07297412f, -0.05650258f, 
    -0.05218211f, 0.06164994f, -0.22372510f, 0.05579889f, -0.44428146f, 0.00075825f, 0.13986789f, 0.08416572f, 
    0.19662957f, 0.01561931f, 0.20271742f, -0.00677079f, 0.07513309f, 0.05797283f, -0.05902100f, 0.00416286f, 
    0.16407588f, 0.15417597f, 0.07486551f, 0.00393993f, 0.03053191f, -0.01226997f, 0.15803657f, 0.02169798f, 
    0.20172983f, 0.35837874f, 0.11623645f, 0.01879123f, -0.26635194f, -0.00281788f, -0.10916563f, -0.25150195f, 
    -0.05652401f, -0.22898704f, 0.03877373f, 0.01518495f, 0.07921774f, -0.04441039f, -0.03164835f, -0.05757221f, 
    0.07511487f, 0.21372496f, 0.11954288f, 0.08004460f, -0.20945640f, 0.14463545f, 0.03946432f, 0.05482347f, 
    -0.22298698f, -0.11863218f, -0.01013963f, -0.08575455f, -0.04559978f, -0.03319517f, -0.05248155f, 0.07825695f, 
    -0.04030991f, 0.05063963f, 0.07004723f, 0.07911663f, 0.19961272f, 0.04851788f, 0.08209231f, 0.10713809f, 
    -0.14059423f, -0.20591879f, -0.20032033f, -0.04435750f, 0.10130719f, -0.02131324f, 0.09841605f, 0.22065946f, 
    0.00560004f, 0.10209504f, -0.04831127f, 0.08544566f, -0.02848521f, 0.00081678f, -0.04646641f, 0.00482333f, 
    0.08639672f, 0.08256119f, -0.02280638f, 0.05209842f, -0.72773647f, -0.42377585f, -0.13390069f, -0.03173298f, 
    0.08843890f, -0.42340222f, 0.39270633f, -0.18631375f, -0.32813194f, 0.15659460f, 0.02322878f, -0.12793978f, 
    0.02103420f, -0.13851818f, -0.00138635f, 0.19350937f, -0.03297940f, -0.11499011f, -0.17853731f, -0.22719148f, 
    -0.18453681f, 0.10069928f, -0.57238036f, 0.10053322f, -0.00938200f, 0.01288735f, 0.15608780f, 0.29334909f, 
    0.02604744f, 0.06704471f, 0.07453752f, 0.00255978f, 0.01827114f, 0.05030697f, -0.02024382f, 0.08594264f, 
    0.09081621f, 0.02847960f, 0.04118831f, -0.00439106f, -0.20869349f, -0.32003924f, 0.09159383f, 0.19447337f, 
    -0.29585239f, 0.00480271f, -0.05572810f, -0.05774993f, 0.08276873f, 0.15644012f, 0.06254105f, 0.01782013f, 
    0.05520316f, 0.05676581f, -0.04462180f, -0.01550657f, 0.03103787f, 0.14244108f, 0.18456243f, 0.16276519f, 
    0.08825818f, 0.09031490f, 0.20933808f, 0.02109198f, -0.06651055f, 0.03737230f, 0.04673646f, 0.03655056f, 
    0.02738597f, 0.02264173f, 0.04116899f, -0.06946044f, -0.00094888f, -0.05564354f, -0.07354981f, 0.09085885f, 
    -0.05815327f, -0.16512705f, -0.02990360f, -0.08519984f, -0.03197443f, -0.49812576f, 0.03936627f, -0.52659357f, 
    -0.09722749f, -0.09595569f, -0.05619740f, -0.02870386f, 0.09746686f, -0.04667237f, -0.07094558f, 0.01959569f, 
    0.03145635f, 0.02269603f, -0.07756767f, 0.03520396f, 0.20713802f, 0.08025716f, -0.01025542f, 0.13130768f, 
    -0.22229931f, -0.08506446f, -0.09796016f, 0.29671115f, -0.23197916f, 0.05325931f, -0.11851366f, -0.26011440f, 
    -0.00427691f, -0.11353792f, 0.06527006f, -0.11839437f, 0.03201274f, -0.01943871f, -0.00069587f, 0.02587212f, 
    -0.08156005f, -0.02354545f, -0.07845423f, -0.11024819f, -0.65958732f, -0.42258871f, -0.17390956f, -0.50506729f, 
    0.16552165f, -0.02020548f, 0.05649710f, -0.14509165f, 0.09908219f, 0.14165635f, 0.04184186f, -0.07259212f, 
    -0.03412601f, -0.05911387f, -0.06490430f, 0.11139100f, 0.13640982f, -0.15445101f, -0.15384760f, -0.05822216f, 
    -0.34301889f, 0.01537444f, 0.27914837f, 0.35630211f, -0.48635736f, 0.13874157f, -0.29298830f, -0.02506358f, 
    -0.09055122f, 0.06185089f, 0.06835794f, 0.05533933f, 0.10486730f, 0.04132447f, 0.07110532f, -0.07909828f, 
    0.01136786f, 0.03400146f, 0.12701313f, 0.17615077f, -0.09387782f, -0.21612920f, -0.54966724f, -0.20266588f, 
    0.19617207f, 0.11403212f, 0.00111087f, 0.19118498f, 0.04896124f, 0.09687217f, -0.02816803f, -0.01253714f, 
    -0.03296870f, -0.00309824f, -0.02175392f, 0.12806016f, 0.15457520f, 0.02349754f, -0.00759733f, 0.01578849f, 
    0.09533019f, -0.42880446f, -0.24720368f, -0.43164894f, -0.36834276f, -0.39133644f, 0.06206016f, -0.14211255f, 
    0.05087634f, 0.08565335f, 0.07792480f, -0.05786986f, 0.01362745f, 0.03619415f, 0.03667279f, 0.06882693f, 
    0.00489422f, -0.02210211f, -0.04848862f, -0.12319566f, 0.12640718f, -0.03344757f, 0.25981757f, 0.06418499f, 
    0.06259540f, -0.02408269f, 0.02830017f, -0.17862584f, -0.12968354f, 0.05479996f, -0.06136420f, 0.07425517f, 
    0.19597274f, -0.01489976f, 0.00922511f, -0.02665373f, -0.11396787f, -0.12065417f, -0.09936299f, 0.05146978f, 
    -0.32896417f, 0.00682749f, 0.01598703f, -0.01068029f, 0.06585224f, -0.01941453f, 0.16366607f, -0.14618833f, 
    0.04109013f, -0.01343517f, -0.10250450f, -0.01186138f, -0.08940299f, -0.00728339f, -0.00935895f, 0.06244106f, 
    -0.10941605f, -0.02509084f, -0.07463979f, -0.14716865f, 0.10387917f, -0.06170340f, 0.12349880f, 0.49164268f, 
    -0.69202757f, 0.09450679f, -0.05419971f, -0.51954585f, -0.02885803f, -0.32427892f, 0.04520810f, -0.13781352f, 
    0.03984325f, 0.12265483f, 0.06588829f, 0.04872887f, 0.09600490f, 0.01313624f, 0.02781366f, -0.01299457f, 
    0.08280443f, -0.35214934f, -0.12847175f, 0.10113763f, -0.08607684f, -0.21362343f, -0.05556997f, -0.06749552f, 
    0.12094681f, 0.04942384f, 0.03056456f, -0.00632483f, 0.05791396f, 0.09846923f, 0.01951637f, -0.05394344f, 
    0.11650247f, -0.00612241f, 0.05118905f, 0.14340477f, -0.23312086f, 0.16488573f, 0.47496617f, 0.49503276f, 
    -0.55773723f, 0.15523373f, -0.15185277f, -0.09607694f, -0.03054510f, 0.10155446f, 0.04640890f, 0.00902547f, 
    0.09028015f, 0.02764074f, 0.06960416f, -0.06634952f, 0.06978960f, 0.06259380f, 0.07517431f, 0.06237283f, 
    -0.43841556f, 0.18460982f, -0.31330565f, 0.22596000f, 0.05991049f, -0.09896963f, 0.11625302f, -0.26233101f, 
    0.14242326f, -0.15267304f, 0.04375589f, -0.09681434f, -0.08114448f, 0.02335012f, 0.00168712f, 0.00957614f, 
    -0.03152639f, 0.02159452f, 0.00069355f, -0.10634460f, -0.23545927f, 0.02976711f, 0.00266211f, -0.46501401f, 
    -0.09030758f, 0.33408493f, -0.24695830f, 0.06357948f, -0.12526904f, -0.21076283f, 0.10675456f, -0.02682122f, 
    -0.09838847f, -0.04019367f, -0.03679978f, -0.01768723f, -0.27962932f, -0.13174514f, -0.07212266f, -0.04622126f, 
    -0.06843173f, -0.01835839f, 0.11152206f, -0.02978963f, 0.08779240f, -0.05802439f, 0.03761068f, 0.03578981f, 
    -0.04379208f, -0.24857724f, 0.12452342f, 0.17843556f, 0.05350215f, 0.10039359f, -0.21415356f, 0.11291687f, 
    0.07691733f, 0.01393024f, -0.08048362f, 0.08430655f, -0.08949278f, 0.09033111f, -0.05694958f, 0.20550868f, 
    0.13340767f, -0.01665541f, 0.08198505f, -0.15439616f, 0.12398627f, -0.16808531f, 0.08828116f, 0.00760932f, 
    0.10957142f, -0.18322635f, -0.06179244f, 0.05433126f, 0.09792872f, -0.11478895f, 0.01996556f, 0.28826752f, 
    0.27070171f, -0.22639257f, -0.72128969f, 0.22812313f, 0.02887028f, 0.15910120f, -0.01672815f, 0.20721585f, 
    -0.03194465f, 0.08285800f, 0.01621993f, 0.04868221f, -0.02117740f, 0.05870793f, -0.04618805f, -0.07030693f, 
    0.05033624f, 0.05559302f, 0.09012502f, 0.25549686f, -0.01142222f, -0.16539837f, 0.00942910f, 0.18129447f, 
    -0.31226826f, -0.06297919f, -0.09287326f, -0.01319068f, 0.05389331f, 0.12624112f, 0.04883071f, -0.08268579f, 
    0.03079034f, -0.01646078f, -0.03737795f, 0.08495039f, -0.05813396f, 0.00226265f, 0.00218494f, -0.13675684f, 
    0.02616011f, 0.01074308f, -0.01108640f, 0.18609525f, -0.42741624f, -0.12753184f, -0.09969831f, 0.22541858f, 
    0.11608934f, 0.23469767f, -0.03201836f, 0.04914876f, 0.00898704f, -0.08102926f, -0.04262031f, 0.05257694f, 
    -0.03051058f, 0.03970382f, 0.02035447f, -0.24222448f, -0.14747041f, 0.21467903f, 0.01066180f, 0.31341231f, 
    0.18498224f, -0.07778886f, 0.01013538f, -0.04124505f, 0.03211134f, -0.17145889f, 0.15663494f, -0.11019072f, 
    0.18001756f, -0.13303354f, -0.01508445f, 0.08357523f, 0.06682269f, -0.00099775f, 0.03040892f, 0.12162309f, 
    -0.61186093f, -0.10227451f, -0.90948987f, 0.07855546f, -0.05685303f, 0.14697264f, -0.20221010f, 0.19146833f, 
    -0.26391765f, 0.12649044f, 0.05356994f, 0.04239649f, 0.01659285f, 0.10052936f, -0.09404013f, -0.01303052f, 
    0.01102206f, 0.09226979f, 0.21605685f, 0.16698240f, -0.87591904f, 0.11138222f, 0.00695652f, 0.82087231f, 
    -0.02190760f, 0.01078235f, 0.19045860f, -0.44773933f, 0.00208727f, -0.34316415f, 0.07387671f, -0.14439595f, 
    0.07708383f, -0.12943554f, 0.10997071f, 0.14895132f, -0.00474123f, -0.11302209f, -0.08737659f, 0.03589607f, 
    0.18376161f, -0.02872286f, 0.26678908f, -0.25917813f, -0.14738460f, -0.00686588f, -0.12176886f, -0.29178515f, 
    0.14272590f, -0.07444290f, 0.02196513f, 0.13773401f, -0.02713281f, 0.08757518f, 0.02555480f, 0.03662812f, 
    0.03739235f, 0.05691610f, 0.00385705f, 0.11964354f, 0.26699460f, 0.06445934f, 0.29699859f, 0.40315875f, 
    -0.31243819f, 0.01382702f, -0.09497878f, -0.37444106f, -0.03090326f, -0.27671513f, 0.08175134f, -0.04418903f, 
    0.16769032f, 0.11380198f, 0.10759474f, 0.10687128f, 0.02703538f, -0.03651227f, 0.01698736f, 0.08320405f, 
    0.34500876f, -0.59274006f, -0.00919505f, -0.37106228f, 0.05382134f, -0.29124764f, -0.19376954f, 0.08948181f, 
    0.13584116f, 0.19353157f, -0.09568797f, 0.02235608f, 0.05050636f, -0.11272135f, -0.05458182f, 0.02082103f, 
    0.12714766f, 0.06570111f, -0.13776247f, -0.01273971f, -0.50390208f, 0.33714047f, 0.02490257f, -0.31811526f, 
    -0.10158620f, 0.03475600f, -0.28398785f, -0.00469079f, -0.01838133f, -0.04127212f, -0.00980313f, 0.06362448f, 
    -0.01278759f, -0.01936078f, 0.09323025f, 0.04547795f, 0.06734645f, -0.06452061f, 0.03640361f, 0.08075635f, 
    -0.09267403f, 0.48744148f, -0.64584327f, 0.05742647f, -0.14152794f, 0.17882289f, 0.16458410f, 0.27536723f, 
    0.00559301f, 0.07506060f, 0.09617241f, -0.08037002f, -0.06101324f, -0.08198769f, -0.13500570f, 0.09264392f, 
    -0.03346188f, -0.16483836f, 0.05890712f, -0.16293602f, -0.12297212f, -0.02061536f, -0.22474959f, -0.38351914f, 
    0.06730019f, 0.18114339f, 0.18646534f, 0.17683378f, 0.09576217f, -0.01588534f, 0.15279265f, 0.01258002f, 
    -0.08744034f, 0.04534638f, -0.01077965f, 0.13643344f, -0.09342214f, -0.03289818f, -0.09935977f, -0.00841748f, 
    0.17233491f, -0.38224238f, -0.09071610f, -0.00888477f, -0.20974697f, -0.17602776f, -0.18269670f, -0.06847430f, 
    -0.15844481f, -0.13780323f, -0.08953644f, 0.04610166f, -0.10044633f, 0.03183839f, 0.07372718f, 0.02804516f, 
    -0.12671204f, -0.11260778f, -0.09532852f, -0.06111391f, 0.62877488f, -0.13168821f, -0.01533072f, 0.22624998f, 
    0.12700482f, 0.08282705f, 0.03705445f, 0.33090657f, -0.06035746f, 0.18916060f, -0.04190500f, 0.11823248f, 
    0.05496430f, 0.04846834f, 0.01291299f, -0.12675516f, 0.03418372f, -0.16699180f, 0.24628747f, 0.02482786f, 
    -0.06220317f, -0.52714849f, -0.42869267f, -0.21522251f, -0.11016937f, -0.23736252f, -0.25566652f, 0.08169203f, 
    -0.05880620f, -0.03512782f, -0.09363271f, 0.12900618f, -0.08723478f, 0.02661077f, 0.03836607f, 0.08705171f, 
    -0.14019418f, 0.02198359f, -0.05577859f, -0.05360331f, -0.43826497f, -0.11509734f, -0.26987493f, -0.01644351f, 
    0.05443105f, 0.04633249f, -0.02774238f, -0.10774834f, -0.05233241f, -0.01387730f, 0.03018593f, 0.05141003f, 
    0.12663637f, -0.00931555f, -0.05209465f, 0.05435103f, -0.12625971f, -0.03558917f, -0.10263990f, -0.26509798f, 
    -0.38366684f, -0.17204623f, -0.10583837f, 0.00433154f, -0.04778954f, -0.07947843f, 0.01267355f, 0.08341122f, 
    0.13378561f, 0.05028230f, -0.02922145f, -0.08937907f, 0.03038357f, -0.04195952f, 0.03759338f, 0.08106811f, 
    0.05801284f, 0.12469633f, 0.21714792f, 0.27227452f, -0.29552090f, 0.37732956f, 0.20855372f, 0.02261744f, 
    0.15965042f, 0.10372915f, -0.08523501f, -0.02147603f, 0.09279358f, -0.05925622f, -0.08752521f, -0.07923003f, 
    -0.07729287f, 0.07774770f, -0.01603579f, -0.11875970f, 0.03604537f, 0.06316211f, 0.00674115f, -0.19263490f, 
    -0.12984689f, -0.11058122f, 0.32982600f, 0.01348458f, 0.23121727f, -0.10899185f, 0.12584551f, -0.00957232f, 
    0.05937427f, 0.04851891f, -0.03993635f, 0.09359262f, 0.02213240f, 0.11810599f, 0.11943714f, 0.12063703f, 
    0.10551471f, -0.03334372f, 0.10819621f, 0.21320225f, 0.51121485f, -0.52148056f, 0.70675290f, 0.19897462f, 
    -0.09426072f, 0.01797167f, 0.00260723f, 0.14329860f, 0.02819893f, -0.28696507f, -0.02502511f, -0.03837111f, 
    -0.08890580f, 0.06279462f, -0.02090862f, -0.17329252f, -0.04304885f, 0.22843981f, -0.27512911f, 0.08038452f, 
    -0.16790713f, 0.03021787f, 0.10524207f, -0.12649642f, 0.07874756f, -0.10902482f, 0.00875789f, -0.14404272f, 
    0.09582801f, 0.04855011f, -0.09394354f, -0.00704421f, -0.13300733f, 0.00702714f, -0.00694073f, 0.16166164f, 
    -0.13012829f, 0.03123770f, 0.01712850f, -0.04708114f, 0.09962681f, -0.12550148f, 0.25175548f, 0.16796902f, 
    0.19927132f, -0.14780858f, 0.03325835f, -0.06916164f, -0.27096313f, -0.26197484f, -0.02318544f, -0.04971173f, 
    -0.01630733f, 0.03544853f, -0.01131810f, -0.01488919f, -0.21335955f, -0.13445264f, -0.23870131f, -0.10775848f, 
    -0.08796924f, 0.18620840f, -0.76613992f, 0.21052159f, 0.32174274f, -0.11929382f, 0.03685653f, 0.13008296f, 
    -0.15130050f, 0.15482496f, -0.16519330f, 0.09738022f, 0.12229056f, -0.11022894f, -0.08860853f, 0.05040694f, 
    0.04561376f, -0.41845259f, 0.08376987f, 0.06776886f, -0.08622166f, 0.07865416f, 0.00618702f, 0.05992541f, 
    0.09730912f, -0.05083816f, 0.05279904f, -0.00832292f, -0.05345152f, 0.02124779f, -0.05140733f, -0.00708233f, 
    0.08288341f, 0.03638775f, -0.03429918f, 0.08064137f, 0.07231076f, 0.01122025f, 0.03234208f, 0.23600180f, 
    0.29624850f, -0.23337726f, 0.31704751f, -0.13227703f, 0.02053211f, -0.01815572f, -0.03652841f, 0.04220669f, 
    0.06303781f, -0.02216240f, 0.03302234f, 0.01125020f, 0.00597101f, 0.13347556f, 0.04298334f, -0.05177107f, 
    0.14694215f, 0.04115596f, 0.11342569f, 0.02496477f, -0.02671978f, 0.13742305f, -0.15113091f, -0.18571196f, 
    0.04874246f, 0.02598924f, -0.08695205f, -0.23578647f, 0.05566484f, 0.05396465f, -0.08732861f, 0.21105853f, 
    -0.02417541f, -0.16654044f, -0.15113635f, -0.04206283f, 0.00892712f, -0.05965101f, -0.04200899f, -0.03033214f, 
    -0.32244626f, 0.17226632f, -0.48130149f, 0.18763232f, 0.04179962f, 0.05390852f, 0.03492024f, 0.01427354f, 
    0.06470569f, -0.00440677f, -0.06591692f, 0.02944168f, -0.01269462f, -0.05670407f, 0.05398067f, -0.11287726f, 
    0.01180012f, -0.43822092f, -0.07581996f, -0.02311356f, -0.21869570f, 0.02922226f, -0.21064600f, -0.01874946f, 
    -0.00561427f, -0.08987893f, -0.09041788f, -0.09123687f, 0.05932424f, 0.11198454f, -0.02939353f, -0.01660397f, 
    -0.08356518f, -0.11445215f, -0.12205885f, 0.00785538f, -0.11525232f, 0.03068730f, -0.03387504f, -0.03671405f, 
    0.17757462f, -0.07569408f, 0.31213713f, -0.01705644f, 0.13711758f, -0.01248324f, 0.00353143f, -0.02690274f, 
    0.04639831f, 0.14739332f, -0.07472150f, 0.04913180f, -0.01623812f, 0.09257052f, -0.03691470f, -0.02018009f, 
    0.10718034f, -0.00625072f, 0.12853248f, -0.09919611f, -0.51557493f, 0.16164993f, 0.08177284f, 0.34629452f, 
    0.10674285f, -0.00046166f, 0.01756826f, -0.19537775f, 0.25324580f, 0.19708437f, -0.17720529f, -0.23093732f, 
    -0.01924160f, 0.03250607f, 0.18448296f, -0.00145506f, 0.22477901f, -0.19068031f, 0.27608082f, -0.01742518f, 
    -0.25245801f, -0.21546973f, 0.10057437f, 0.08249798f, -0.17072105f, -0.04357316f, -0.18904537f, -0.01917597f, 
    0.20468870f, -0.00184774f, 0.00971091f, -0.04978322f, 0.06200131f, 0.02279092f, -0.00689518f, 0.04541941f, 
    -0.01530195f, 0.06191611f, 0.21859448f, 0.07241952f, -0.12333644f, -0.06249109f, 0.20717135f, -0.08979674f, 
    -0.08338919f, 0.02404357f, -0.06679586f, 0.11847421f, 0.26191372f, -0.08590510f, 0.01505686f, 0.01475500f, 
    -0.08514702f, 0.00936338f, -0.07551226f, -0.11761606f, -0.16164725f, -0.00373248f, -0.10182634f, -0.22519572f, 
    -0.13843296f, -0.13653070f, -0.46255872f, -0.09790044f, 0.06000043f, -0.08608388f, -0.02960108f, -0.05436627f, 
    -0.22209837f, -0.17302045f, 0.06085397f, 0.09370832f, 0.00482421f, 0.02681539f, -0.00364790f, 0.16803437f, 
    -0.23691581f, -0.14403747f, -0.16298085f, -0.28359711f, -0.22798061f, 0.05883899f, 0.01989195f, 0.09831849f, 
    0.24486561f, -0.08907658f, -0.00807773f, 0.07918625f, -0.08558749f, 0.02423488f, -0.13322900f, 0.02353068f, 
    -0.02480084f, 0.07909426f, 0.06679439f, 0.09078991f, 0.01981233f, -0.05207429f, 0.07631696f, 0.16275828f, 
    -0.52607614f, -0.05223315f, -0.03472361f, 0.01626602f, 0.17058177f, 0.01374624f, -0.04345626f, -0.18444474f, 
    -0.06648738f, -0.03142377f, -0.07908238f, 0.03172526f, 0.06261621f, 0.14786118f, 0.00093814f, 0.10655696f, 
    0.04110903f, -0.19044414f, 0.14771387f, 0.07767717f, 0.40336713f, -0.17750314f, 0.21641736f, -0.11890749f, 
    -0.15689297f, 0.04788158f, -0.05551443f, 0.04892790f, -0.02476657f, -0.09329834f, -0.01564819f, 0.11676410f, 
    -0.15075503f, -0.04148263f, -0.12854005f, -0.03659625f, -0.06648733f, 0.05223985f, -0.06753682f, -0.16860537f, 
    -0.09396053f, -0.23044622f, 0.18759249f, -0.16066989f, 0.12828729f, -0.05519532f, 0.03621729f, 0.25113598f, 
    0.05229918f, -0.15577221f, -0.07981756f, 0.18747629f, 0.15642504f, 0.03580988f, -0.03472815f, 0.13606450f, 
    -0.08601549f, -0.01931391f, -0.14571667f, -0.42756447f, 0.31917840f, 0.26411763f, 0.18435442f, -0.28579855f, 
    -0.11127858f, -0.00647648f, -0.28429133f, 0.23855884f, 0.05092248f, 0.12507582f, -0.17138724f, 0.00726058f, 
    -0.06603093f, 0.08981644f, -0.10686161f, -0.03065836f, -0.15816224f, 0.03719828f, -0.00168797f, 0.05238558f, 
    0.01247558f, 0.19620317f, 0.08674531f, 0.13740644f, 0.07894423f, 0.13949817f, 0.11467067f, -0.10099567f, 
    -0.01262910f, 0.09335635f, -0.17289507f, 0.01803653f, 0.06480462f, 0.00190111f, -0.11498389f, -0.03179835f, 
    0.07087807f, -0.05987938f, 0.01032496f, -0.01697137f, -0.03324627f, 0.16069618f, -0.06350858f, 0.13405970f, 
    0.09947440f, 0.04355339f, -0.09928842f, -0.12315320f, 0.02365697f, 0.03286538f, -0.09257523f, 0.06908294f, 
    0.00728678f, -0.06436907f, -0.02546585f, -0.03309669f, -0.07931864f, -0.04652039f, -0.04350236f, -0.00539642f, 
    -0.31252110f, 0.15293786f, 0.10607382f, 0.17830898f, -0.17289419f, 0.10016252f, -0.39662915f, 0.07257299f, 
    0.17545775f, 0.10981496f, -0.03907171f, 0.02586861f, -0.07926179f, -0.00129099f, 0.01040590f, -0.08415051f, 
    -0.16117735f, -0.50736463f, -0.23848242f, 0.17222236f, 0.01919700f, -0.07450324f, -0.00537625f, 0.12369175f, 
    -0.04587258f, -0.03947736f, 0.07315075f, 0.21004345f, -0.04413795f, -0.05384378f, -0.01648013f, -0.11952011f, 
    0.02546030f, 0.09445868f, 0.08340374f, -0.02381627f, 0.03640740f, 0.05606227f, -0.00816355f, 0.06750716f, 
    -0.46227333f, -0.52160907f, -0.04818290f, -0.04439083f, 0.11199268f, -0.06944007f, -0.14442159f, 0.11545997f, 
    -0.07949383f, -0.03399259f, -0.13007145f, 0.06967938f, 0.00429152f, -0.02683050f, 0.01605860f, 0.07868589f, 
    -0.01670510f, 0.11503223f, 0.12948981f, 0.11232779f, -0.21290214f, -0.60281837f, 0.39537224f, 0.05933503f, 
    -0.17412378f, -0.02237576f, -0.08026589f, 0.02667032f, -0.00826589f, -0.08117508f, -0.13819753f, 0.01733365f, 
    -0.00429411f, -0.06054444f, -0.09371673f, -0.04213454f, 0.18918572f, 0.19680795f, 0.09268288f, 0.09405210f, 
    0.23868641f, -0.06242305f, 0.11925466f, -0.10130043f, -0.15220913f, -0.10301909f, 0.01117314f, -0.04055286f, 
    -0.03716584f, 0.04807546f, -0.07604786f, -0.01920258f, -0.03347235f, -0.04081509f, -0.03402561f, 0.05361017f, 
    0.07879649f, 0.08959262f, 0.05718399f, -0.07141244f, -0.71932954f, -0.24515894f, 0.17116900f, 0.47112671f, 
    -0.00382457f, 0.05688408f, 0.11596620f, 0.17394105f, -0.05571674f, 0.21178484f, -0.30844584f, -0.01537657f, 
    -0.14272428f, 0.05917697f, -0.07174410f, 0.06883239f, 0.00335548f, -0.17971237f, 0.13457964f, -0.16612846f, 
    0.32262173f, 0.10182086f, 0.35607895f, -0.13108104f, -0.28775832f, -0.06808858f, -0.01663483f, -0.13290510f, 
    0.10143905f, 0.01529562f, -0.07224607f, -0.01029047f, 0.08571218f, -0.11080687f, -0.10176721f, -0.03902058f, 
    0.13448599f, -0.05092285f, -0.08108693f, 0.12550297f, -0.06115238f, -0.44859543f, -0.59586430f, -0.19364823f, 
    -0.13854966f, -0.11104889f, -0.11590812f, 0.17941840f, -0.18404764f, -0.09332962f, 0.02504243f, 0.08128142f, 
    0.03601009f, -0.06631931f, -0.06943681f, 0.02068292f, -0.11733362f, 0.07950795f, 0.03115045f, -0.01812185f, 
    0.02508083f, 0.07957251f, 0.02751355f, 0.14450864f, -0.04304855f, -0.11836377f, 0.00504999f, 0.04278396f, 
    0.00011849f, -0.08260366f, -0.02124731f, 0.10454264f, -0.03608530f, -0.04140264f, 0.03893362f, -0.07367341f, 
    -0.09354869f, -0.02015095f, -0.16734011f, -0.14515457f, -0.63633484f, 0.18549551f, -0.53152746f, 0.29642364f, 
    0.14534546f, -0.01537332f, 0.12166277f, -0.00461725f, 0.09967527f, 0.02170188f, -0.18480089f, -0.06704447f, 
    0.00689247f, 0.10566283f, -0.04467935f, 0.11317491f, 0.03264510f, 0.04665634f, -0.13025750f, 0.11225088f, 
    -0.04901488f, -0.47168413f, -0.02058118f, 0.12949270f, 0.14811862f, 0.09933184f, -0.06804340f, -0.09895615f, 
    -0.13881761f, -0.04346238f, 0.07055373f, -0.04680257f, 0.01004009f, -0.09094155f, -0.18354034f, -0.05572341f, 
    -0.09251534f, -0.02414310f, -0.01454909f, -0.12158452f, -0.35189569f, 0.05282274f, -0.65958911f, 0.45627707f, 
    0.51105708f, 0.17754477f, 0.13809024f, 0.07364812f, -0.13941650f, 0.06236717f, 0.04266541f, 0.17909043f, 
    -0.02812948f, -0.12958528f, 0.01336166f, -0.02947140f, 0.15910895f, 0.21566163f, 0.23509164f, 0.01884423f, 
    0.24374475f, -0.34430134f, 0.40110311f, -0.34420845f, 0.17833495f, -0.05183412f, -0.11849628f, -0.04884516f, 
    0.10332248f, -0.03701123f, 0.00693689f, 0.01589923f, 0.09382623f, 0.09175812f, -0.02316695f, 0.09426362f, 
    0.07704194f, 0.02308413f, 0.16830389f, -0.09083764f, 0.42094582f, -0.32344246f, 0.02711016f, 0.10410354f, 
    -0.00685060f, -0.03133167f, 0.02315122f, -0.12702231f, -0.02471025f, 0.03058072f, -0.04907765f, 0.03202531f, 
    -0.01540184f, -0.02938761f, -0.05293264f, 0.04710185f, 0.05895833f, -0.00118419f, 0.01637975f, 0.00369021f, 
    -0.18484581f, -0.15428609f, -0.11226293f, 0.41979557f, -0.54961890f, 0.08701076f, -0.25381547f, 0.14639805f, 
    -0.06083655f, 0.13597959f, -0.04501557f, -0.09887829f, -0.12150484f, 0.07065197f, -0.02155737f, 0.13863941f, 
    0.03770822f, 0.14531529f, 0.16582724f, -0.08085428f, -0.26033744f, 0.03001073f, -0.37148681f, 0.25845435f, 
    0.08424836f, -0.13750368f, 0.02526451f, 0.05336358f, -0.05776490f, 0.05022576f, -0.01368100f, 0.02770494f, 
    -0.03779993f, -0.07089769f, -0.01977061f, 0.02452927f, -0.13249347f, -0.19236639f, -0.16324098f, -0.27070436f, 
    -0.16645844f, 0.01282703f, -0.09684052f, 0.07757249f, 0.07195163f, 0.04070761f, 0.14003059f, 0.06541356f, 
    -0.12757993f, 0.06207211f, -0.03622658f, 0.15336430f, -0.05605368f, 0.03415064f, 0.09616865f, -0.11353728f, 
    -0.03772649f, 0.04004346f, 0.01282518f, -0.05640953f, -0.52042097f, -0.23172365f, -0.42843965f, 0.24029157f, 
    -0.74314690f, -0.03407852f, 0.00259225f, -0.07587629f, -0.09055923f, 0.07072295f, -0.10951103f, -0.08439404f, 
    0.03366176f, 0.02020249f, -0.00566256f, -0.00768994f, -0.03164922f, 0.02335474f, -0.01245673f, 0.03858212f, 
    -0.14193320f, -0.17657556f, -0.16712405f, 0.26766029f, -0.22184384f, 0.09036616f, -0.03016873f, 0.11882006f, 
    -0.14932032f, -0.15615444f, 0.05323784f, -0.01680644f, 0.10937444f, 0.12899832f, 0.06271394f, 0.13253252f, 
    -0.06027025f, 0.27042833f, 0.07299979f, 0.04976518f, 0.15761293f, -0.22959067f, -0.08892179f, -0.23354779f, 
    -0.14604147f, 0.00765990f, -0.01037354f, -0.00492232f, -0.09741046f, -0.02378120f, 0.00541570f, 0.01840929f, 
    0.18877912f, 0.07484429f, -0.00446928f, 0.05066645f, 0.01618940f, 0.05827858f, 0.12750328f, 0.04945279f, 
    -0.07620569f, -0.11498937f, -0.04187438f, 0.10750428f, 0.24816933f, 0.11812764f, 0.13636765f, 0.12442268f, 
    -0.15105246f, 0.04127477f, -0.00391044f, -0.03347110f, 0.03508483f, -0.02469349f, 0.08152068f, -0.04921970f, 
    -0.08142692f, -0.02423922f, -0.03156121f, 0.03397426f, 0.28521541f, 0.08377612f, -0.02788903f, 0.36367607f, 
    -0.02388947f, -0.08961924f, 0.14376734f, -0.05263172f, 0.36372337f, -0.13015965f, -0.17622630f, 0.04238850f, 
    0.01651276f, -0.07196836f, 0.11740009f, 0.10584023f, -0.04076077f, 0.25119799f, 0.06852318f, -0.14754064f, 
    -0.27887508f, -0.13930131f, -0.07260504f, -0.00645928f, -0.18791911f, 0.01684397f, 0.05293805f, 0.12980118f, 
    0.10051191f, -0.09194973f, -0.05485645f, -0.01538855f, 0.07139885f, -0.07369507f, -0.04796531f, 0.10709932f, 
    -0.03328880f, -0.06859142f, -0.15246536f, -0.17057884f, -0.19297214f, -0.13828799f, -0.23116355f, 0.21743420f, 
    0.14893599f, 0.11897659f, 0.01177484f, 0.12094894f, -0.20155537f, -0.21046664f, 0.04442954f, -0.18780515f, 
    0.01262264f, 0.26871446f, 0.07560729f, 0.09135365f, -0.09304176f, 0.08053948f, -0.03878507f, -0.05261803f, 
    0.31864476f, -0.16144556f, 0.24135698f, -0.00239831f, 0.06931011f, -0.01682359f, -0.25242522f, -0.01414226f, 
    -0.03129476f, -0.17775249f, -0.00159926f, -0.00412672f, 0.00735416f, -0.04857904f, 0.03772564f, 0.03761388f, 
    -0.04850672f, -0.05315972f, 0.03697758f, 0.02448796f, -0.00966628f, -0.20338453f, -0.11800610f, 0.25329423f, 
    0.02819838f, -0.13999173f, -0.29058817f, -0.09850945f, -0.26641765f, -0.12835130f, 0.07826680f, 0.01827651f, 
    -0.06038801f, -0.09974068f, -0.13711515f, 0.07990080f, -0.06978574f, -0.01759894f, -0.05489263f, -0.16443516f, 
    0.02331563f, -0.32835871f, -0.12524484f, -0.11039329f, -0.09553347f, -0.01087236f, -0.43727541f, 0.08054182f, 
    -0.32983544f, -0.11015283f, -0.00372519f, 0.03439777f, -0.01812807f, -0.00656804f, -0.06457820f, -0.00621626f, 
    -0.07381682f, 0.02477640f, 0.01227732f, -0.14824773f, -0.17890531f, -0.17072064f, -0.17561652f, -0.19851457f, 
    0.06237698f, 0.01702741f, 0.10421809f, 0.09428877f, -0.07130396f, -0.01149524f, -0.03497038f, -0.06949499f, 
    0.06258766f, 0.05475813f, 0.12884912f, -0.00645688f, 0.04220783f, 0.05587956f, 0.01204458f, 0.12781718f, 
    0.19223306f, -0.46772003f, -0.08610581f, -0.32410204f, 0.36900428f, -0.14012915f, -0.27604505f, -0.13818803f, 
    0.05793291f, -0.23603000f, -0.04170688f, 0.04750198f, 0.00715070f, 0.03937649f, 0.01572206f, 0.06088018f, 
    0.03745490f, -0.14248900f, -0.07052860f, 0.00910028f, -0.44227839f, -0.13486461f, -0.37814677f, 0.06890050f, 
    0.07769500f, 0.27993754f, 0.26006776f, 0.31900159f, -0.24118675f, 0.14798564f, 0.07561882f, 0.09091094f, 
    0.05504478f, 0.15815675f, -0.03130220f, -0.01783801f, -0.06646350f, -0.00293893f, 0.01769347f, 0.03125462f, 
    -0.50421268f, 0.25968111f, -0.41611347f, 0.37715751f, 0.01904742f, -0.03973727f, 0.07330564f, -0.01040284f, 
    0.12190492f, 0.08825588f, -0.06451895f, -0.13161072f, -0.06730877f, 0.00954319f, 0.01906465f, -0.01595314f, 
    0.04795726f, 0.07310168f, -0.02829919f, -0.04055211f, -0.46948123f, 0.12254262f, -0.28301123f, 0.15844792f, 
    -0.46366134f, -0.03388556f, 0.10133291f, 0.05618740f, -0.00621295f, 0.04209675f, -0.11999637f, -0.06398100f, 
    0.12603220f, 0.08696256f, -0.05318566f, 0.00003556f, -0.02733936f, -0.04213469f, -0.03771131f, 0.10835357f, 
    -0.22389583f, -0.46207902f, -0.14048226f, 0.74576473f, 0.10512272f, -0.01874703f, -0.05285249f, 0.02286787f, 
    0.18926936f, -0.05083086f, -0.09322519f, 0.01462646f, 0.05342370f, 0.06346951f, 0.13168927f, -0.06872531f, 
    0.06681527f, 0.27317250f, 0.27990013f, -0.13285506f, 0.42311531f, -0.23825981f, 0.24037139f, 0.16796987f, 
    0.11611062f, -0.04576932f, 0.27816555f, -0.15003943f, 0.22267935f, -0.09645055f, -0.12415963f, 0.13121006f, 
    0.00408310f, 0.04453395f, 0.10558873f, -0.06937779f, 0.06679358f, 0.04076706f, 0.06496933f, -0.08523527f, 
    0.52511716f, 0.13681659f, 0.48004624f, 0.15475234f, -0.06809460f, 0.03028337f, 0.06728463f, -0.14349963f, 
    0.03524621f, -0.15038738f, -0.13013962f, 0.10628474f, 0.01677738f, 0.10183834f, 0.08698529f, -0.04739304f, 
    -0.13080771f, 0.00255264f, -0.05554912f, 0.15630674f, 0.29905891f, 0.30581403f, 0.06800166f, 0.08047954f, 
    -0.04050858f, -0.01542136f, 0.12014767f, 0.01961936f, 0.01552294f, 0.05179890f, -0.12873550f, 0.01688668f, 
    0.03138373f, -0.06634940f, -0.12474300f, 0.00699752f, -0.06497965f, 0.03281811f, -0.04838391f, 0.07866418f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.16951789f, 0.07619275f, 0.02647680f, -0.15000142f, -0.05882337f, 0.05823181f, 0.06625874f, -0.06591040f, 
    0.04692124f, 0.02980766f, 0.04987530f, 0.01342625f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
