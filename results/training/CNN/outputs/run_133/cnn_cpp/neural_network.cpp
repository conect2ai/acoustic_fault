#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.66933924f, 1.05582047f, 0.40088460f, -0.64323574f, -0.56179601f, -0.39124823f, 0.56029660f, -0.06434514f, 
    0.16593279f, 0.84963793f, -0.18102258f, 0.31364924f, -0.16666768f, -0.41986075f, 0.18940167f, -0.12912279f, 
    -0.19187860f, -0.12695275f, 0.09333810f, -0.54268563f, -0.22768171f, -0.30083624f, 0.31251580f, -0.13083848f, 
    0.11181774f, 0.86442596f, -0.35139224f, -0.47627383f, 0.74390090f, -0.18331563f, -0.71208471f, -0.76952034f, 
    0.24325912f, -0.45888665f, -0.62824768f, -0.77247155f, -0.38439822f, 0.19919339f, -0.40238437f, -0.60425085f, 
    -0.07637836f, -0.09048186f, 0.30916479f, 0.10266516f, 0.12838137f, -0.06944145f, -0.00177729f, -0.28284359f, 
    -0.18269731f, -0.27216938f, -0.84858847f, 0.48377889f, 1.20114040f, 0.71452624f, -0.69918811f, -0.12170133f, 
    0.23397726f, -0.33076251f, 0.43237567f, 0.10109414f, -0.20073332f, 0.14256692f, -0.23868233f, 0.02134156f, 
    -0.23043709f, 0.32408446f, 0.39633751f, 0.09217697f, -0.25040668f, -0.23447873f, 0.04687507f, 0.04338574f, 
    -0.57703489f, -0.16206977f, -0.42551097f, -0.15325266f, -1.00944698f, 0.52158314f, 0.98858297f, 0.37239796f, 
    0.86123210f, 0.76457721f, 0.79068655f, 0.45253471f, -0.44325361f, -0.82262653f, -0.30943343f, -0.40376627f, 
    0.43434229f, 0.08052912f, 0.11316326f, 0.12458381f, -0.29327101f, -0.00206941f, 0.29782614f, -0.09681102f, 
    -0.10234045f, -0.01732838f, -0.08575002f, -0.05133639f, 1.52600241f, 0.69119859f, -0.20480901f, 1.02573812f, 
    0.94121146f, 0.55542397f, 0.36323279f, 0.32647505f, 0.53873575f, 0.20635642f, -0.50037241f, 0.01702619f, 
    0.00209007f, -0.24472438f, -0.41201279f, -0.19023830f, -0.26807290f, -0.04811172f, -0.04104313f, 0.16452463f, 
    0.22531649f, 0.01858158f, 0.11828059f, -0.03559130f, 0.15011764f, 0.35465375f, 1.25883782f, 0.57625526f, 
    -0.13125214f, -0.38430792f, -1.09270608f, -0.77993226f, -0.35428718f, -0.92517698f, -0.22233099f, 0.48238033f, 
    0.33449984f, -0.21594971f, 0.09813874f, -0.21593431f, -0.08165131f, -0.37215585f, -0.05155979f, -0.22875684f, 
    -0.01913825f, 0.33981240f, 0.10742266f, -0.16686487f, 0.21834891f, -0.16215867f, 1.12331378f, 0.93901944f, 
    1.11519217f, 0.80098385f, 0.61572456f, 0.11197855f, 0.03856836f, -0.72721267f, -0.02356328f, -0.16547592f, 
    0.26706314f, 0.18814826f, 0.13436404f, 0.15470006f, 0.13346915f, 0.32281345f, 0.37605983f, 0.31987593f, 
    -0.18910770f, 0.13501385f, 0.04634239f, 0.25060886f, -0.14230055f, 0.20645787f, 0.50362188f, -0.71188402f, 
    -0.06006333f, -0.55407476f, -0.02570722f, 0.13725355f, -0.85782295f, -0.46449628f, -0.41703165f, -0.77547807f, 
    0.03355327f, 0.46324706f, 0.61138660f, 0.45962837f, 0.24985670f, 0.36969382f, 0.62314385f, 0.07160839f, 
    0.11428225f, 0.32321018f, 0.73947448f, -0.23936088f, -0.15781493f, 0.13941824f, -0.30378589f, 0.29537320f, 
    0.51635766f, -0.16818006f, 0.79147452f, 0.90678275f, 0.74921906f, -0.11638807f, -0.78199810f, -0.27605236f, 
    0.28845349f, 0.57525039f, 0.47743171f, 0.22210743f, -0.46975854f, 0.45109093f, -0.44059387f, -0.31321830f, 
    0.01298075f, -0.04182346f, 0.14799732f, -0.03368045f, 0.00491480f, -0.24917953f, 0.19928136f, -0.30150110f, 
    -0.04624387f, 0.96923882f, 0.53029299f, -1.37063873f, -0.95351785f, -0.57892817f, 0.31419110f, -0.48910058f, 
    0.06187821f, 0.34186909f, -0.75689530f, -0.12675409f, 0.06193873f, 0.40444860f, 0.08784287f, -0.10408904f, 
    0.11666906f, -0.14404134f, 0.04652799f, -0.20706424f, -0.10214341f, -0.26738295f, 0.24816318f, 0.26866031f, 
    -0.19787037f, 0.25120610f, -0.66665792f, -0.51856560f, -0.06371719f, 0.83559680f, 0.05127396f, -0.82394689f, 
    0.61739391f, 0.76390880f, -0.65651089f, 0.37890428f, 0.12132316f, 0.09934361f, 0.53972518f, -0.08224059f, 
    0.14723767f, 0.33331877f, 0.24282157f, 0.30666834f, 0.17928740f, 0.20476466f, 0.58105958f, 0.00381568f, 
    0.16990845f, 0.50774854f, 0.06260274f, -0.13780569f, -1.30732989f, -0.60753018f, -0.36801895f, -0.81955320f, 
    -0.17268886f, -0.58187401f, -0.59859973f, 0.06444266f, 0.37058330f, 0.00919684f, 0.38042620f, -0.08667980f, 
    0.14045312f, -0.42068157f, -0.19846562f, 0.14752001f, 0.31360584f, 0.39891201f, 0.14422299f, 0.26048931f, 
    0.05548332f, -0.19083600f, 0.02354227f, -0.06071278f, -0.31927404f, -1.51659107f, -1.04816639f, -0.24838755f, 
    -0.01954719f, -0.52388883f, 0.51775271f, 0.42888042f, 0.23060705f, 0.59925884f, 0.38142473f, 0.42221853f, 
    0.14802445f, -0.30441579f, -0.38222501f, -0.18267764f, 0.09007454f, -0.03760523f, 0.15688987f, -0.41437885f, 
    -0.35815626f, -0.20681143f, 0.08742857f, -0.00372440f, 0.19274063f, -0.67217565f, -1.13072884f, -1.03736579f, 
    -0.50272870f, -0.38081771f, 0.76012951f, 0.92761344f, -0.06547363f, 0.46746334f, 0.53495109f, -0.14571539f, 
    -0.09693398f, -0.08092915f, 0.28808528f, 0.70352453f, -0.19593905f, -0.04550800f, -0.15163942f, -0.04886132f, 
    0.03498777f, 0.11467404f, -0.25552878f, -0.32959095f, 0.07795252f, -0.11158196f, 0.96458131f, 0.15101007f, 
    0.51642179f, 0.50226462f, 0.10850188f, -0.70307380f, -0.59992647f, -0.52916467f, 0.20977053f, -0.24496068f, 
    -0.50698477f, -0.22445592f, -0.55489266f, -0.30483797f, -0.27872807f, 0.22251101f, -0.37834576f, -0.33443132f, 
    -0.10216896f, -0.17398298f, -0.20332825f, 0.23671065f, 0.31941408f, -0.37204421f, -0.48581263f, -1.33076715f, 
    -0.31607810f, 0.23649451f, -0.32805684f, -0.62153667f, 0.71120095f, 0.89901853f, 0.01336961f, -0.27781224f, 
    0.48853695f, 0.02855195f, -0.28582162f, -0.34707803f, -0.57763726f, 0.07297942f, 0.08845866f, 0.21278885f, 
    -0.00088040f, -0.13890393f, -0.14320539f, -0.21917181f, -0.04522981f, 0.23878813f, -0.17735638f, 0.17284662f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02922969f, 0.08531760f, 0.17129725f, 0.09161209f, 0.08161519f, 0.30163643f, 0.29974315f, 0.34371525f, 
    0.25684234f, 0.26670939f, 0.31496266f, 0.25668618f, 0.22457695f, 0.22122037f, -0.05502458f, -0.10516705f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03946606f, -0.03027748f, -0.04762534f, 0.05566675f, -0.05658722f, -0.07453042f, -0.02531610f, -0.05404890f, 
    -0.04471263f, 0.04953001f, 0.01821579f, -0.00749319f, 0.01558422f, -0.06553936f, -0.01923715f, -0.07659911f, 
    -0.00640033f, 0.01218957f, 0.03808415f, -0.04391595f, 0.01207350f, -0.01311009f, -0.04603263f, -0.05924486f, 
    -0.03783714f, 0.06098748f, -0.04399091f, -0.05442864f, -0.04246821f, -0.02998661f, 0.02740648f, -0.03440410f, 
    0.02129478f, -0.05301050f, 0.01813285f, -0.01952973f, -0.05569819f, -0.06603388f, -0.07297663f, 0.01477486f, 
    0.01104955f, -0.02073429f, 0.06538931f, -0.04848922f, -0.00681131f, -0.06771585f, -0.04929073f, -0.02937759f, 
    0.00383862f, 0.01857899f, -0.07449927f, 0.06162164f, -0.04461666f, -0.00631336f, -0.04692373f, -0.00221753f, 
    0.01122364f, 0.01926105f, -0.01817593f, 0.06554028f, -0.04000960f, -0.02512125f, 0.04259700f, 0.04239992f, 
    0.00910231f, 0.05961622f, -0.00256992f, -0.07088088f, -0.02949900f, -0.07683201f, -0.07231011f, -0.00512101f, 
    0.05964512f, 0.04006430f, -0.04779858f, -0.04359302f, 0.03229543f, 0.05885080f, 0.02990858f, 0.03108330f, 
    0.02901165f, -0.00870016f, -0.01593204f, -0.04499684f, -0.00120569f, -0.03245521f, 0.02045211f, -0.06685114f, 
    0.04365820f, 0.00040758f, -0.06242208f, 0.01579026f, 0.03446723f, 0.02876141f, -0.00374083f, 0.06008992f, 
    0.04014470f, 0.06375704f, 0.00762847f, -0.07387111f, -0.03379630f, -0.05352060f, 0.05476130f, -0.04259543f, 
    -0.04472425f, 0.00100903f, -0.07188947f, 0.01244849f, -0.05925822f, -0.02619046f, -0.01410585f, -0.03004509f, 
    -0.06797288f, -0.06801651f, -0.01437469f, 0.05475421f, -0.02647229f, 0.02758427f, -0.00409916f, -0.04649223f, 
    -0.00854729f, 0.03432166f, 0.06313261f, 0.04487161f, -0.04772534f, 0.03948088f, -0.03643955f, 0.00979688f, 
    0.02207285f, -0.03827493f, -0.03822268f, -0.04254837f, 0.05998739f, 0.04707487f, 0.05686115f, 0.04709394f, 
    0.06272404f, -0.03289913f, -0.04325050f, 0.06457913f, 0.05768665f, 0.01424620f, -0.01939976f, -0.02644383f, 
    0.02052625f, -0.07633494f, 0.00155866f, 0.00096048f, 0.06081503f, 0.06158346f, -0.06997125f, -0.01493029f, 
    -0.00326979f, -0.06672706f, 0.01344916f, -0.02118267f, -0.07308960f, 0.05704078f, 0.01452616f, -0.02315591f, 
    -0.05407484f, -0.05480821f, -0.04358480f, 0.04791676f, -0.03344444f, -0.00201345f, 0.00730000f, -0.04271124f, 
    0.03221676f, 0.06004254f, 0.00854289f, 0.04455053f, -0.00819202f, -0.03349259f, -0.06557583f, -0.04873153f, 
    0.04617021f, -0.07560349f, -0.04001864f, 0.02100955f, -0.06519499f, -0.01779751f, -0.05863658f, 0.03725390f, 
    -0.02495000f, 0.04810315f, 0.03712673f, 0.04919484f, -0.06259924f, 0.04718342f, -0.00846826f, -0.00173202f, 
    -0.01703655f, 0.25260007f, -0.20896615f, -0.21660930f, 0.07172480f, -0.05286722f, 0.20939264f, -0.08350064f, 
    -0.15234140f, 0.01406178f, -0.01466144f, -0.04573139f, -0.20243940f, -0.09476481f, -0.03529850f, -0.16921721f, 
    -0.16221733f, 0.12779030f, -0.10455690f, 0.08080597f, 0.05046663f, 0.10444947f, 0.09333689f, 0.02540047f, 
    0.13580270f, 0.10699008f, 0.13037926f, 0.01203520f, -0.16899092f, 0.00262287f, -0.24367218f, -0.17213842f, 
    0.20007907f, 0.16943993f, 0.22048670f, -0.09748635f, -0.59880418f, 0.19775189f, 0.40898952f, -0.02498199f, 
    0.00628056f, -0.01060960f, -0.08808497f, -0.04358961f, 0.03159949f, 0.12978590f, -0.10909889f, -0.10098808f, 
    0.10634702f, -0.27749491f, 0.20365793f, -0.28546873f, -0.07683916f, 0.00542628f, -0.09482592f, 0.05844395f, 
    0.15800840f, -0.04764001f, 0.03948899f, -0.00681380f, 0.20937678f, 0.54201853f, -0.13361481f, 0.05644546f, 
    0.08693042f, 0.02366417f, 0.09146632f, 0.22207423f, 0.03624895f, -0.01974251f, 0.00559944f, 0.23568708f, 
    0.57622403f, 0.04076033f, 0.19717142f, 0.21528514f, 0.06568496f, -0.04516260f, 0.11775513f, -0.06654555f, 
    0.10634769f, -0.04384732f, 0.16997582f, 0.23977235f, 0.10013527f, 0.18779466f, -0.05821090f, -0.10436732f, 
    0.21790037f, 0.08106931f, 0.05297177f, 0.10959574f, -0.14045651f, 0.07647844f, 0.15638240f, 0.22579691f, 
    0.39131299f, -0.08056063f, -0.05906712f, 0.29095662f, 0.13724938f, -0.10734966f, -0.06529092f, 0.23994325f, 
    0.15508871f, 0.02079213f, 0.13526401f, 0.22418201f, -0.10190060f, -0.03303111f, -0.03370195f, -0.04258521f, 
    0.10257962f, 0.02052467f, 0.13845490f, -0.07328344f, 0.00154351f, -0.04782442f, 0.04948232f, 0.20140395f, 
    -0.32181618f, 0.21528344f, -0.18287565f, 0.13174914f, 0.04124911f, 0.03177980f, -0.00018566f, 0.15547107f, 
    0.02348134f, -0.09381857f, 0.28386000f, 0.16341142f, -0.23235457f, -0.24073419f, -0.21816628f, -0.02951315f, 
    -0.05003399f, -0.20964731f, -0.07498701f, -0.08890294f, 0.16371800f, 0.07031866f, 0.10841373f, 0.05283046f, 
    -0.15394734f, 0.07211246f, -0.19245979f, -0.22627586f, -0.08966677f, 0.09841426f, -0.01112101f, 0.01606560f, 
    0.15810603f, -0.00440825f, 0.07572103f, 0.14910845f, 0.29910550f, -0.12886490f, 0.06235074f, -0.21880671f, 
    -0.00520563f, 0.07763945f, 0.01757649f, -0.08628336f, 0.07457587f, 0.13432443f, 0.08788335f, -0.13018414f, 
    -0.04271657f, 0.22181293f, 0.04427049f, -0.02068777f, 0.20974258f, -0.09188773f, 0.13099186f, 0.18731977f, 
    -0.12440257f, 0.21080279f, -0.04731516f, -0.01998399f, 0.04102058f, -0.15219173f, -0.05928849f, -0.07475384f, 
    -0.16725111f, 0.06128046f, -0.06054821f, -0.16824371f, 0.10058543f, -0.18946069f, -0.11282264f, -0.06117516f, 
    0.33146116f, 0.28090519f, 0.17710088f, -0.16192336f, 0.21674971f, 0.05980771f, -0.10653255f, 0.12816708f, 
    0.13452086f, 0.10411242f, 0.07362809f, 0.00008131f, 0.08664843f, 0.16204156f, -0.01626698f, 0.13340786f, 
    0.16218109f, 0.14501056f, 0.13272031f, -0.04279190f, -0.05373628f, 0.03953711f, 0.05787407f, 0.01103799f, 
    0.14545062f, 0.35366178f, 0.10823346f, 0.06169369f, 0.01776574f, 0.30193833f, 0.26437575f, 0.02739345f, 
    -0.10446835f, 0.13027197f, 0.24409674f, -0.00291904f, -0.12022424f, -0.34546140f, 0.20086262f, -0.16440518f, 
    0.21551219f, 0.18574855f, -0.01507141f, -0.03176698f, 0.04795547f, -0.09997550f, 0.09390391f, 0.02374819f, 
    -0.23492950f, 0.27287626f, 0.07547497f, -0.15436293f, 0.06472018f, 0.15081330f, -0.04157587f, 0.05465018f, 
    0.16890734f, 0.05132059f, -0.04545358f, 0.11487326f, 0.47124907f, -0.04554347f, -0.31178477f, 0.46425319f, 
    0.03850984f, 0.11053789f, -0.01758251f, 0.18278784f, 0.12510942f, 0.12510328f, 0.05014576f, 0.00382098f, 
    0.75172883f, 0.16298401f, 0.01307673f, 0.27161500f, -0.09553313f, -0.12606455f, 0.15758839f, 0.03115531f, 
    -0.02111152f, -0.07486857f, -0.25209579f, -0.18221688f, -0.39414129f, 0.12499689f, 0.09520522f, 0.14560638f, 
    0.06183362f, 0.03905493f, -0.11037484f, -0.03273345f, -0.10527139f, -0.22015946f, -0.08338402f, -0.38720113f, 
    0.61989987f, 0.13420163f, -0.09742913f, -0.03834569f, -0.13157116f, 0.10747861f, 0.00440693f, 0.07197214f, 
    0.13746357f, -0.02607311f, 0.08609477f, 0.08389787f, 0.46079132f, -0.13593104f, 0.02379688f, 0.22049282f, 
    0.01244664f, -0.11368952f, -0.01093329f, 0.03186841f, -0.03550566f, 0.08082532f, -0.02483160f, 0.06886942f, 
    -0.61158115f, 0.38955668f, -0.11393207f, -0.01182479f, -0.01999816f, 0.00202500f, -0.12611957f, -0.08799611f, 
    -0.03874552f, -0.12967458f, -0.15916911f, -0.21712667f, 0.19959266f, 0.08849666f, -0.34217080f, -0.18026738f, 
    -0.09479658f, -0.20401452f, 0.08305565f, -0.03960505f, -0.14473438f, 0.18808074f, -0.14074090f, 0.02843281f, 
    0.11851589f, -0.06405190f, -0.13783808f, -0.13104247f, -0.01717823f, -0.10152343f, -0.00393433f, 0.04189078f, 
    0.05900059f, 0.11926163f, 0.06796173f, 0.03985076f, 0.13871515f, 0.00088909f, -0.11007268f, -0.22645639f, 
    0.01200590f, 0.10984057f, -0.09768741f, -0.05623392f, -0.12211262f, -0.07629763f, -0.16080941f, 0.04529740f, 
    0.52067852f, 0.34266376f, -0.60865080f, 0.04068073f, -0.00794264f, 0.25845549f, -0.01564595f, 0.08889732f, 
    0.13383459f, -0.34472892f, 0.16272080f, -0.00909248f, -0.17937601f, -0.09080585f, 0.00902469f, -0.03564943f, 
    -0.15633872f, 0.08381255f, -0.12833491f, 0.06449141f, -0.05098383f, 0.14848092f, 0.27274102f, -0.34734875f, 
    -0.76814640f, -0.67447054f, 0.30109993f, -0.06157050f, 0.18499050f, 0.10279956f, 0.06208356f, -0.18730676f, 
    0.07156835f, -0.05316490f, 0.00636688f, 0.17807448f, 0.51806229f, -0.03201677f, -0.13016264f, 0.18951774f, 
    -0.02020103f, 0.07675705f, 0.07823317f, 0.03540230f, -0.05619330f, -0.00585962f, -0.07073668f, 0.23529990f, 
    -0.43939942f, 0.29567859f, -0.12116545f, 0.09122451f, 0.17536180f, 0.10424549f, -0.06189999f, 0.03616352f, 
    -0.01392097f, -0.00709006f, -0.08233116f, 0.21377173f, -0.00837107f, 0.49932605f, -0.56240588f, 0.23088761f, 
    0.06425837f, 0.06075348f, 0.14795248f, 0.08523510f, 0.03449098f, 0.11257514f, 0.12281769f, 0.03967730f, 
    0.10485888f, 0.00433511f, 0.04469317f, 0.18716402f, -0.01300316f, -0.00152156f, 0.04553529f, 0.07690087f, 
    0.18554051f, -0.08696820f, -0.14440699f, 0.01858730f, -0.46321839f, -0.42833579f, 0.44199151f, 0.18780585f, 
    -0.13275772f, -0.04738925f, 0.03956359f, -0.10112005f, -0.10073697f, -0.01026256f, -0.01163527f, 0.05731862f, 
    -0.39611512f, 0.01136469f, 0.14987332f, -0.09778005f, -0.16701211f, -0.04685672f, -0.07631471f, 0.16911508f, 
    0.19560589f, -0.01776963f, 0.10441203f, 0.08430208f, 0.07340197f, -0.21548514f, 0.22443211f, 0.28835964f, 
    0.03124188f, 0.03703447f, 0.30157998f, 0.06794825f, 0.24448957f, 0.21208699f, 0.06175253f, 0.11321577f, 
    -0.15172905f, -0.02142095f, 0.09340627f, 0.07863902f, 0.07770868f, 0.13029456f, 0.08336793f, -0.07145159f, 
    0.12204062f, 0.04345377f, -0.02626022f, -0.07821722f, 0.26868629f, -0.22056462f, 0.10333585f, 0.07373759f, 
    -0.24739446f, 0.17366172f, 0.14557746f, 0.09459542f, -0.22568499f, 0.15807413f, 0.07727394f, 0.03394702f, 
    -0.23396760f, -0.05481201f, -0.18525325f, -0.01581945f, 0.06211082f, -0.05707232f, -0.20022635f, 0.18261443f, 
    0.04649590f, 0.02673905f, -0.08624119f, 0.02090276f, 0.47238001f, 0.33311167f, -0.05692264f, 0.48625517f, 
    0.12942329f, 0.26637915f, 0.17919081f, 0.14770220f, 0.10354789f, 0.21022946f, 0.12860134f, 0.10395708f, 
    -0.13355322f, 0.24797288f, -0.24355735f, 0.17220400f, 0.08506671f, 0.06486734f, 0.04808978f, 0.11819325f, 
    -0.14090607f, -0.01423721f, 0.00821321f, -0.17494023f, -0.27863413f, 0.13105395f, -0.31357545f, 0.17743419f, 
    0.22149232f, -0.08731809f, 0.11549827f, 0.04153183f, 0.14587028f, 0.01777899f, 0.05694724f, 0.15779349f, 
    0.06649806f, -0.04497081f, 0.35966393f, 0.46683013f, 0.06725067f, 0.14624393f, 0.11073016f, -0.03581930f, 
    0.09840371f, -0.05284810f, -0.01925279f, 0.23917148f, -0.32136646f, 0.52904654f, -0.10678031f, 0.12635179f, 
    0.12734891f, 0.01725346f, -0.05117048f, -0.04888910f, -0.02199656f, 0.01418404f, -0.02602163f, 0.14041181f, 
    0.45853737f, 0.04252646f, 0.16021678f, -0.01204857f, 0.01000315f, 0.07672343f, -0.13618089f, 0.05070501f, 
    0.27329630f, -0.04477466f, 0.10647446f, -0.13685736f, -0.33059317f, -0.06373950f, -0.22257966f, -0.06272561f, 
    0.04499346f, -0.00036441f, -0.03666656f, 0.12972003f, 0.08879767f, 0.02239386f, -0.02312914f, 0.00432785f, 
    0.32327169f, -0.23363200f, 0.01802147f, 0.11426987f, 0.21775435f, -0.16164699f, 0.01506434f, -0.12301197f, 
    0.09600966f, -0.21914889f, -0.10973930f, -0.12501176f, 0.67589921f, -0.12830038f, 0.06727397f, 0.16719261f, 
    0.03335880f, 0.20053996f, 0.06848017f, 0.04906682f, 0.03867751f, 0.05539257f, -0.12804395f, -0.08414018f, 
    0.00640222f, 0.37236530f, 0.05869055f, 0.41280565f, 0.02583028f, 0.10040096f, 0.05834053f, 0.06556275f, 
    -0.04068341f, 0.03870930f, 0.13260427f, -0.06720875f, -0.27646032f, 0.03715791f, 0.03668047f, -0.89927375f, 
    0.18154448f, 0.14753777f, -0.03705905f, -0.09261363f, -0.06553576f, 0.00957598f, -0.07103249f, 0.08681119f, 
    -0.02871081f, 0.31741023f, 0.08557993f, -0.25444618f, 0.09436962f, 0.18652807f, -0.07029370f, 0.02474820f, 
    -0.06860178f, 0.00579382f, 0.05399715f, -0.12488048f, 0.17612998f, 0.08719728f, 0.01416229f, -0.17663023f, 
    -0.02204808f, -0.01831381f, -0.18194115f, 0.10894430f, -0.00755353f, 0.09564139f, -0.00545213f, -0.19021788f, 
    0.01733411f, 0.18014087f, 0.32161805f, -0.23127590f, -0.25604135f, -0.08812129f, 0.05912954f, 0.09958183f, 
    0.01555892f, 0.04514504f, -0.04700639f, -0.18211456f, -0.17243840f, -0.15053622f, 0.29066008f, -0.14975044f, 
    0.17070866f, -0.06646424f, -0.03074145f, 0.09797630f, -0.00630692f, 0.03581924f, 0.02464823f, -0.05782320f, 
    0.59324580f, -0.25700429f, -0.11672285f, 0.08605137f, -0.07623790f, 0.12205400f, -0.10674042f, -0.01661734f, 
    -0.00336985f, 0.03112434f, 0.09569798f, 0.11440559f, -0.15480115f, -0.17100514f, 0.24941948f, -0.25494748f, 
    0.14663503f, 0.05431831f, 0.09171151f, 0.07339348f, -0.11793728f, 0.03732660f, -0.12642935f, -0.06676722f, 
    0.48273671f, -0.39060855f, 0.25245237f, 0.15503535f, -0.12886719f, -0.10444377f, -0.04684704f, 0.04577971f, 
    -0.01301581f, -0.02971824f, 0.09720296f, 0.05507121f, 0.31980544f, 0.10630307f, 0.30607873f, -0.07955301f, 
    0.03946117f, -0.00221792f, -0.08874746f, 0.11060842f, -0.06466118f, 0.14070189f, -0.02114134f, 0.14111072f, 
    -0.17844485f, -0.08065803f, -0.02476481f, -0.40833521f, -0.01806779f, 0.11823882f, -0.07707134f, 0.08868198f, 
    -0.17450754f, 0.03334567f, -0.12966962f, 0.05236023f, 0.47871417f, -0.15314621f, 0.03762510f, 0.03992205f, 
    0.12170784f, 0.08162857f, 0.07137069f, -0.00688165f, 0.09157842f, 0.26765940f, 0.01521408f, 0.16316095f, 
    -0.43887472f, 0.05200234f, 0.13838811f, 0.15690975f, 0.10229965f, 0.06240543f, -0.07824783f, -0.04017006f, 
    0.18555792f, 0.08928060f, 0.07002309f, 0.13052540f, 0.47035500f, 0.24545541f, 0.26184782f, 0.25383630f, 
    0.21395130f, 0.18515256f, 0.05298805f, -0.06606640f, 0.05393392f, 0.00104946f, 0.01612563f, 0.16554394f, 
    -0.01375516f, 0.33868894f, 0.21410875f, 0.38120386f, -0.13171503f, 0.17958659f, 0.39234227f, 0.33525905f, 
    -0.04646669f, 0.28426754f, -0.05737514f, 0.05319190f, -0.12628978f, -0.25854677f, -0.00078762f, 0.13379160f, 
    0.08111032f, 0.05690268f, 0.10658769f, 0.07930316f, -0.00677694f, -0.22238255f, 0.19582826f, 0.04853061f, 
    -0.31084579f, 0.14639540f, -0.28096059f, -0.13670132f, -0.00528697f, 0.00593324f, 0.07661860f, 0.06841238f, 
    0.02173727f, 0.13228561f, 0.07412139f, 0.02794208f, 0.04925510f, 0.08300269f, 0.25588292f, 0.13998453f, 
    0.11593305f, 0.06876979f, 0.03921154f, -0.01921402f, -0.04003449f, 0.00468920f, -0.07871942f, -0.07961019f, 
    -0.36733490f, -0.01570237f, -0.36643714f, -0.11234353f, -0.08185397f, -0.04521599f, -0.01858202f, -0.01142680f, 
    0.15127005f, -0.01815947f, -0.15059969f, -0.17203039f, 0.04282511f, 0.13062562f, 0.12058202f, 0.10758192f, 
    0.04331987f, 0.19228537f, 0.17410880f, 0.10988580f, 0.31915951f, -0.11857812f, 0.00906580f, -0.15876979f, 
    0.02946876f, -0.08955246f, -0.20329048f, 0.05290653f, -0.11200387f, 0.03785558f, 0.07999396f, -0.03088169f, 
    0.09236524f, 0.19975995f, -0.09726220f, -0.05999885f, 0.17656523f, 0.09252487f, 0.23864478f, 0.02474128f, 
    -0.09652053f, 0.12118278f, -0.08340430f, -0.09111368f, 0.12927850f, 0.05307258f, -0.01988907f, 0.00656342f, 
    -0.26497605f, 0.08472263f, 0.34716144f, 0.10741461f, 0.25030196f, 0.04268795f, 0.06360037f, -0.00697333f, 
    0.00648789f, 0.01594613f, -0.18674256f, -0.02839357f, 0.14291532f, 0.12566514f, 0.12954424f, -0.14095137f, 
    -0.15589695f, -0.07274567f, 0.08285812f, -0.15361917f, -0.26379618f, -0.00027811f, -0.21871205f, -0.01698921f, 
    -0.01132860f, 0.29726681f, 0.01799331f, -0.10292979f, 0.10577088f, 0.03993066f, 0.09355563f, -0.00259354f, 
    0.03873582f, 0.19598177f, -0.01655170f, 0.07837502f, 0.12317131f, 0.12432421f, 0.16881466f, -0.14227349f, 
    -0.03789420f, 0.02708907f, 0.04995021f, 0.02776547f, 0.08330952f, -0.32209280f, 0.07662664f, 0.28581858f, 
    0.12767467f, 0.11983465f, -0.13145065f, 0.06499767f, -0.06184859f, 0.05826025f, -0.14865874f, 0.20514287f, 
    0.09846189f, -0.11802189f, 0.07116070f, 0.01436564f, 0.56558806f, 0.17870045f, 0.37370226f, -0.10954732f, 
    0.07014153f, 0.12366343f, -0.03723671f, 0.24221309f, -0.24149458f, 0.07138304f, 0.03910001f, 0.08996026f, 
    -0.02473427f, -0.06582003f, -0.05037900f, -0.01514349f, 0.02138576f, -0.02839126f, -0.06372497f, 0.05391774f, 
    -0.05197655f, 0.03252162f, -0.04020946f, 0.04355080f, -0.04028812f, 0.03970588f, 0.06226722f, -0.02999173f, 
    -0.06225894f, -0.04444135f, -0.02412512f, 0.05377064f, -0.01746210f, -0.05649156f, -0.06706169f, -0.03184439f, 
    -0.02352535f, -0.01635652f, -0.02090270f, 0.00227910f, -0.07490244f, -0.03556157f, -0.06432970f, -0.07122286f, 
    0.06387357f, 0.03968553f, 0.03021343f, 0.03358701f, 0.05748405f, -0.04087962f, 0.00149941f, -0.03097516f, 
    -0.02908595f, -0.01046662f, -0.03562884f, -0.01776605f, -0.04374561f, -0.01285840f, -0.02596848f, 0.01164497f, 
    -0.02561590f, 0.04189149f, -0.02009131f, -0.07107444f, -0.07896692f, -0.03590863f, 0.03370365f, 0.04369045f, 
    0.04877538f, -0.05636493f, 0.06278813f, -0.00356274f, 0.02265155f, -0.04116719f, 0.00348422f, -0.00652376f, 
    0.02342420f, -0.04090809f, 0.02294437f, -0.07337710f, -0.06698670f, 0.01208702f, -0.07020515f, -0.03119499f, 
    -0.02550432f, -0.01523162f, -0.06551314f, 0.00279712f, 0.00723887f, 0.04594987f, -0.02925995f, 0.02241631f, 
    -0.07550009f, -0.00515643f, -0.02453602f, 0.01550328f, -0.00934085f, -0.00046889f, -0.02010059f, -0.00049311f, 
    -0.05150988f, -0.03139886f, 0.02707711f, 0.04506264f, -0.00021900f, -0.00191534f, 0.01850202f, -0.06127986f, 
    -0.04763897f, -0.04163193f, -0.01542851f, -0.04902643f, 0.00419838f, -0.04425159f, 0.01733789f, -0.03634774f, 
    0.05783814f, -0.05436678f, -0.06562910f, -0.02779034f, 0.04075772f, -0.06257832f, -0.02418762f, 0.03534119f, 
    -0.03351980f, -0.02374389f, 0.03265061f, 0.00308717f, 0.00199413f, -0.01097588f, 0.01366015f, -0.07923833f, 
    0.01406846f, 0.04462972f, 0.01203397f, 0.02582897f, -0.05743529f, 0.05871570f, 0.01394896f, -0.05239635f, 
    -0.02723855f, 0.00463356f, -0.06134770f, 0.00054913f, -0.00161534f, -0.06701586f, 0.00604547f, -0.04834072f, 
    -0.04708593f, 0.00071876f, 0.04157963f, 0.04381435f, -0.02853354f, 0.02210548f, -0.03062189f, 0.00259291f, 
    0.01618858f, -0.01505510f, 0.02044802f, 0.04573281f, -0.01997617f, -0.02140439f, 0.00519776f, -0.00698084f, 
    0.05009665f, 0.03985988f, -0.06231694f, -0.03978793f, -0.02802034f, 0.04726917f, 0.02277049f, -0.01456723f, 
    0.05030587f, 0.05738989f, -0.00157558f, -0.06245831f, -0.01279986f, 0.04555624f, 0.02092202f, -0.03759151f, 
    -0.01914460f, -0.04345287f, -0.00785777f, 0.06219603f, -0.05922849f, -0.05293817f, -0.05366007f, -0.06953035f, 
    -0.02228771f, 0.00334207f, -0.05068288f, -0.02329628f, -0.01242271f, 0.01983460f, -0.05400423f, 0.00706765f, 
    -0.01611787f, -0.03274013f, -0.00917196f, 0.03376974f, -0.02948357f, 0.06089556f, -0.00187986f, 0.00894162f, 
    0.08744655f, -0.08260754f, -0.03934082f, 0.02992504f, 0.01809856f, -0.12481561f, 0.02506411f, 0.01491390f, 
    0.18043451f, 0.01880312f, 0.10181639f, -0.02139829f, -0.19526820f, -0.15897018f, 0.27322114f, 0.25751424f, 
    -0.07849707f, 0.07234817f, 0.05321022f, 0.04793258f, -0.05786312f, -0.13115868f, 0.03590576f, 0.21447656f, 
    -0.25012603f, -0.13003181f, -0.03492232f, 0.04666748f, -0.06855971f, -0.08221433f, -0.09894122f, -0.12288105f, 
    -0.22758625f, -0.15076134f, 0.05321025f, -0.02766722f, 0.18765870f, -0.51688451f, -0.04813987f, 0.05212535f, 
    -0.09018694f, 0.08869465f, 0.13212208f, 0.09553166f, 0.03010033f, 0.24761350f, 0.15253624f, 0.08855804f, 
    -0.22263120f, -0.31976801f, -0.26893154f, -0.22795990f, 0.02167311f, -0.06030384f, -0.17533892f, -0.04096115f, 
    0.03850000f, -0.06733578f, 0.16945980f, -0.02675966f, -0.01274918f, 0.05456812f, -0.15848061f, -0.15098488f, 
    0.18162914f, 0.09308899f, -0.17028755f, 0.15192714f, -0.06634782f, -0.01675178f, 0.12344857f, 0.17311901f, 
    -0.27201605f, -0.29288432f, -0.15033944f, -0.45381081f, 0.12129260f, 0.04167099f, 0.03125029f, -0.10962188f, 
    -0.01546621f, 0.01122461f, 0.09114273f, 0.12443679f, 0.09562501f, 0.03482743f, -0.03049243f, -0.00581468f, 
    0.14142942f, -0.13668913f, -0.05638491f, -0.03031779f, -0.21767601f, -0.02190470f, -0.04995859f, 0.04173901f, 
    -0.05059159f, -0.22559464f, -0.13635175f, -0.00971710f, 0.18375020f, 0.00310794f, -0.08343438f, 0.00603975f, 
    0.03533489f, 0.00953410f, 0.20784004f, -0.02338228f, 0.19773735f, 0.26437619f, 0.21672486f, 0.07065972f, 
    0.05513427f, -0.04464133f, -0.06055931f, 0.00226991f, 0.10560457f, 0.08411235f, -0.07083369f, -0.02566697f, 
    0.20600988f, -0.07785039f, -0.04835118f, -0.00744428f, -0.05433999f, 0.11381462f, -0.11623563f, -0.00206041f, 
    -0.01228358f, -0.05427740f, 0.07582782f, 0.11658902f, 0.30412090f, 0.49897021f, 0.13409722f, -0.08618698f, 
    -0.11864850f, 0.10774990f, 0.11120935f, -0.11966942f, -0.02576473f, -0.12302100f, 0.13917172f, -0.08436847f, 
    0.63144201f, 0.06450550f, 0.28419670f, -0.00093310f, -0.16740948f, -0.16604374f, -0.02623213f, 0.00433160f, 
    -0.03996755f, -0.18017845f, 0.10886277f, 0.01682360f, 0.45609811f, 0.40458834f, 0.13177721f, 0.14757574f, 
    0.02886735f, -0.02938589f, 0.11787722f, -0.15533443f, -0.08352816f, 0.08093483f, 0.03371239f, 0.08640308f, 
    -0.31578451f, -0.26235440f, 0.04315783f, 0.18920664f, 0.03511425f, -0.21483584f, 0.13326903f, -0.15410487f, 
    -0.15879796f, 0.02464608f, 0.01042589f, 0.18348269f, -0.05092835f, 0.37622613f, 0.02590317f, 0.17167495f, 
    0.13284980f, 0.11099599f, -0.02915479f, 0.12512015f, 0.13782404f, 0.03756113f, 0.02366542f, -0.18608296f, 
    0.19144565f, -0.17452350f, 0.33138660f, -0.11320642f, -0.02523776f, 0.02229091f, 0.09453504f, 0.09403475f, 
    -0.06554485f, 0.12328710f, 0.16824320f, 0.01954856f, 0.14632672f, 0.07736017f, -0.02489361f, 0.13295506f, 
    -0.03106684f, -0.01545963f, 0.00990278f, 0.03929798f, -0.10464645f, 0.11750036f, 0.03779216f, 0.08573751f, 
    0.02631373f, -0.02503129f, -0.21213183f, 0.24741004f, -0.05933850f, 0.14372273f, 0.07779845f, 0.19835186f, 
    -0.13668168f, -0.08226997f, -0.24151921f, 0.12535103f, 0.09432518f, 0.46322140f, -0.29825801f, 0.16640311f, 
    0.09433179f, -0.10752938f, 0.01429745f, -0.02037269f, -0.06502787f, -0.09189257f, 0.17628725f, 0.05591545f, 
    0.17044033f, 0.00167252f, -0.35152102f, 0.31289774f, 0.21740189f, -0.14837492f, 0.21292111f, -0.09278799f, 
    -0.02808280f, 0.14928366f, 0.15245771f, -0.03442544f, -0.19656558f, -0.12569587f, 0.40688801f, -0.16468135f, 
    -0.12744834f, 0.12488659f, 0.00988524f, -0.17753555f, -0.01580239f, -0.00141460f, -0.01100686f, -0.07395826f, 
    0.10971745f, -0.08679385f, -0.23312904f, 0.02371999f, 0.20937480f, 0.14463744f, -0.13911141f, -0.10522176f, 
    -0.25130439f, -0.01278142f, -0.11642944f, -0.02206415f, -0.19704704f, -0.26440421f, 0.13134056f, -0.15862130f, 
    0.15451051f, -0.02564811f, 0.08985574f, 0.05905974f, 0.16467647f, 0.02222246f, -0.06011534f, -0.03279006f, 
    -0.27416644f, -0.23548675f, -0.07956192f, 0.18081062f, 0.13504803f, 0.14710860f, -0.10772736f, -0.02922077f, 
    -0.06394465f, 0.19562252f, 0.01361621f, -0.09035669f, -0.44976458f, -0.03245939f, 0.25263068f, -0.18760313f, 
    -0.17913316f, -0.05425531f, 0.12749176f, 0.04565728f, 0.01773921f, 0.02727724f, -0.02821951f, -0.07031855f, 
    0.26536301f, 0.07448746f, 0.14029738f, 0.06802966f, 0.03016265f, -0.12339372f, -0.04344516f, -0.14674811f, 
    -0.12194521f, -0.03633847f, -0.08516079f, -0.04900207f, -0.07040866f, -0.44434690f, 0.30732355f, -0.03070538f, 
    -0.00503419f, 0.18545599f, -0.06407537f, 0.13701817f, 0.04575989f, 0.08344860f, -0.03522181f, 0.21078625f, 
    -0.06413455f, 0.03476467f, 0.07735334f, 0.46492639f, -0.04568413f, 0.05160569f, 0.09380068f, 0.26923364f, 
    -0.10038547f, 0.31257924f, -0.04181616f, -0.14905825f, 0.01621437f, 0.19840650f, 0.17342113f, 0.12158274f, 
    -0.15597473f, -0.16889846f, 0.11765458f, 0.08805553f, 0.21647817f, -0.15123869f, -0.02442182f, 0.06082592f, 
    0.01592085f, -0.26923394f, 0.08009416f, 0.22577535f, -0.11921535f, 0.32728574f, -0.18072669f, -0.02643326f, 
    0.20932475f, -0.06521711f, 0.09847000f, -0.04314282f, 0.11569984f, 0.15793997f, 0.35666108f, -0.41364247f, 
    0.04147231f, -0.27333495f, 0.08960964f, -0.00370172f, 0.00696675f, 0.05650338f, 0.11690863f, 0.10972043f, 
    0.04691908f, 0.00903152f, 0.03377297f, 0.04601158f, -0.07646865f, 0.04155682f, 0.00362968f, -0.00697975f, 
    0.04484614f, -0.06016478f, -0.01955184f, -0.06081271f, -0.07637081f, -0.06854535f, -0.01939947f, -0.02488820f, 
    -0.04201570f, 0.00433353f, 0.01760214f, -0.02315659f, -0.00863394f, 0.03770057f, -0.00471378f, 0.03325746f, 
    -0.00599848f, 0.00667579f, 0.00446085f, -0.07107270f, -0.05676464f, 0.03949963f, -0.02334244f, -0.00952259f, 
    0.01592048f, -0.01134728f, -0.05885400f, 0.00315295f, 0.03244787f, 0.02128124f, -0.01963918f, 0.00876713f, 
    -0.03887677f, -0.02096811f, -0.00056607f, 0.06611379f, -0.01385359f, -0.03189271f, 0.03538505f, 0.01939395f, 
    -0.02870702f, 0.01134622f, 0.05869030f, -0.03652840f, -0.03751710f, 0.05578185f, -0.02372483f, 0.02814536f, 
    -0.02999509f, -0.02058350f, -0.03898343f, 0.05503281f, -0.02577383f, 0.01353699f, 0.03360079f, -0.01036043f, 
    -0.05577256f, -0.05856108f, 0.03457768f, -0.01049540f, -0.00413908f, -0.02488339f, 0.02201494f, -0.01364642f, 
    -0.00649169f, 0.04690192f, -0.04494774f, -0.02460158f, 0.00350466f, -0.02338804f, -0.05508550f, -0.01163765f, 
    -0.01677143f, -0.00874283f, 0.04511046f, 0.03369087f, 0.02600566f, 0.00402935f, -0.03611771f, 0.01431702f, 
    -0.00542010f, 0.05402406f, -0.00856021f, -0.05679054f, -0.07222302f, -0.03198216f, 0.03111624f, -0.00149027f, 
    -0.04532653f, -0.06206268f, -0.00687616f, -0.05831592f, -0.05618448f, 0.02808426f, 0.01827172f, 0.01136301f, 
    -0.07947091f, 0.03913264f, 0.05780991f, 0.00366924f, -0.04387627f, 0.05835765f, 0.03058073f, -0.04194825f, 
    -0.04533317f, -0.05506811f, -0.06073202f, 0.04502971f, -0.07395676f, 0.00862587f, 0.00778840f, 0.02323288f, 
    0.04364347f, -0.00209639f, -0.06019451f, -0.02765358f, -0.07372276f, -0.01223184f, 0.01701229f, -0.06121477f, 
    0.02914123f, 0.00899288f, -0.06795403f, -0.05300659f, 0.02774938f, -0.07187410f, -0.06465842f, -0.07560835f, 
    0.05466572f, 0.01395750f, -0.04369500f, 0.03997599f, 0.02898590f, -0.00150202f, 0.04746987f, 0.02782572f, 
    -0.04489105f, -0.05305180f, -0.04381533f, 0.02429965f, 0.03921559f, 0.01849180f, -0.01543165f, -0.00363307f, 
    -0.00031638f, -0.07415372f, 0.03172577f, -0.01627452f, 0.00317307f, 0.04679421f, -0.07228214f, 0.02238309f, 
    0.03632985f, 0.00458906f, -0.04393636f, 0.03854168f, -0.07017224f, 0.00488044f, -0.06197769f, 0.04770848f, 
    0.02178421f, 0.01637089f, 0.00423406f, -0.05840562f, 0.00187512f, -0.04026091f, -0.06426907f, -0.05568853f, 
    0.00265161f, 0.04839265f, -0.02527747f, -0.04191486f, -0.02445967f, -0.03898527f, 0.02090889f, -0.03891471f, 
    0.05819383f, 0.00992392f, -0.00144390f, 0.05672383f, -0.00855281f, -0.01037801f, -0.05232151f, 0.01839638f, 
    -0.03875944f, -0.02468480f, 0.03248736f, 0.00286387f, -0.06375365f, -0.00741447f, 0.04219864f, -0.00073760f, 
    -0.07191110f, 0.02176210f, -0.00951180f, -0.01015754f, -0.06486759f, -0.00790634f, 0.01473890f, 0.03518390f, 
    -0.06386291f, -0.07814565f, -0.02024493f, -0.00578971f, 0.02640499f, 0.04142140f, -0.04825757f, 0.05972996f, 
    0.01390357f, -0.03487727f, -0.08037125f, -0.01056893f, 0.03009539f, -0.06618450f, -0.02566991f, -0.00906676f, 
    0.05350952f, 0.02651708f, -0.06007002f, 0.03834643f, -0.02009055f, -0.01157831f, -0.06625742f, 0.02311520f, 
    -0.03444912f, 0.04965326f, 0.00800227f, 0.03049853f, 0.03742871f, 0.01142286f, 0.03393170f, -0.04093081f, 
    -0.06793912f, -0.01540269f, -0.03531334f, -0.04405589f, -0.02653107f, 0.04274286f, -0.05928433f, -0.06565229f, 
    -0.04893826f, -0.03783841f, 0.02066472f, 0.00691743f, 0.04709380f, -0.03337954f, 0.00610647f, -0.02077099f, 
    -0.06645922f, -0.02106635f, -0.00994291f, -0.07151134f, -0.04910097f, 0.01881987f, -0.04125980f, -0.02256660f, 
    -0.04261113f, 0.01595207f, -0.03933415f, 0.02487938f, 0.03009005f, 0.03032019f, 0.04738455f, 0.05142222f, 
    -0.02184831f, 0.03926355f, 0.04134081f, 0.01290309f, -0.06400160f, -0.01120394f, -0.00888715f, -0.02720145f, 
    -0.05350207f, -0.00168628f, 0.01620333f, -0.01815769f, -0.02294489f, 0.05512518f, 0.00031006f, -0.07935429f, 
    0.05558152f, -0.07238787f, -0.01433310f, 0.02696042f, 0.05199246f, -0.03819319f, 0.00646326f, 0.01117889f, 
    -0.07972230f, -0.01272478f, -0.05958432f, 0.01616956f, -0.02385545f, 0.04845041f, 0.01229674f, -0.07022236f, 
    0.04670141f, -0.01923536f, 0.01054651f, 0.03161686f, 0.02966608f, 0.02602024f, -0.01451266f, 0.06145969f, 
    0.01564415f, 0.02223121f, -0.04459487f, -0.08252064f, -0.03714925f, -0.03309070f, -0.03129629f, -0.04872816f, 
    -0.05832018f, -0.01420417f, -0.07507272f, -0.00239006f, -0.03730986f, 0.00237739f, -0.02004398f, 0.05732821f, 
    0.05483061f, -0.02254774f, -0.04797164f, 0.00179401f, -0.01659589f, -0.04722181f, -0.05999512f, 0.05053215f, 
    0.03654975f, 0.02435345f, 0.00553533f, 0.04967108f, -0.00171064f, 0.03626737f, -0.03651255f, -0.02558886f, 
    0.00426646f, -0.03155479f, 0.05170447f, 0.05197760f, -0.07191101f, -0.03560818f, -0.00391667f, -0.06594298f, 
    0.05338212f, 0.04708021f, 0.05936290f, 0.02349689f, -0.00232099f, -0.00439649f, -0.02561553f, 0.03969973f, 
    0.01816889f, -0.03468738f, 0.04752199f, 0.01206084f, 0.04674511f, -0.05854506f, -0.06425904f, -0.06809589f, 
    0.04541236f, -0.01366960f, -0.08691593f, -0.07392346f, -0.03906486f, 0.03746740f, -0.01709792f, -0.05753696f, 
    -0.00874002f, 0.03393644f, -0.07102818f, 0.01297412f, -0.04165924f, -0.02837536f, -0.05226487f, -0.01510365f, 
    -0.00079425f, 0.08311941f, 0.04351417f, -0.08442298f, -0.08399318f, 0.20650226f, -0.00896672f, 0.08357896f, 
    0.00197626f, -0.03368286f, 0.07992633f, -0.14834611f, -0.33663028f, -0.11272936f, -0.00036454f, 0.24980962f, 
    -0.27927640f, 0.07690538f, -0.07453924f, -0.07417317f, -0.04192671f, 0.02135779f, -0.04067885f, 0.18771535f, 
    0.39531946f, -0.02503465f, 0.15043448f, 0.28600082f, 0.13046120f, 0.06983508f, -0.18177582f, -0.16048494f, 
    -0.01410984f, 0.04061026f, 0.24824150f, -0.06881685f, 0.73502088f, 0.11403152f, -0.27925783f, 0.23113257f, 
    0.06127432f, 0.16565630f, -0.00509514f, -0.14961137f, 0.13742469f, -0.06128131f, 0.00796528f, 0.09286543f, 
    -0.07889575f, 0.37287953f, 0.17374901f, 0.14902973f, -0.13281797f, -0.02774006f, -0.11301144f, -0.25125557f, 
    -0.00758492f, 0.01510903f, 0.07102305f, 0.05821509f, -0.31123820f, 0.24975483f, 0.20626481f, -0.01839256f, 
    -0.07911051f, -0.29196513f, -0.01340595f, -0.12084473f, -0.13327765f, 0.00307868f, 0.15135852f, 0.09079038f, 
    0.06169071f, 0.40741265f, 0.54939395f, 0.11870169f, -0.24790791f, -0.08891093f, 0.05325677f, -0.14870258f, 
    0.03122655f, 0.02028655f, 0.18822870f, -0.01335558f, -0.05612076f, -0.10230953f, 0.01556945f, -0.06769931f, 
    0.06732167f, 0.07915032f, 0.00139299f, -0.07532004f, 0.03039755f, 0.16130255f, 0.16628729f, 0.00080633f, 
    0.25856003f, 0.35425195f, 0.56527078f, 0.20031914f, -0.18864559f, -0.12228776f, 0.02153952f, 0.05105086f, 
    0.02389991f, 0.06192621f, 0.20415986f, -0.16060597f, -0.30988380f, -0.14005457f, 0.27201629f, -0.23066364f, 
    -0.10474670f, -0.14305851f, 0.07828809f, 0.09715053f, 0.11245572f, -0.22460602f, -0.00084922f, 0.01534630f, 
    0.19744782f, -0.05200166f, -0.33296916f, 0.34145981f, -0.14672643f, 0.11671974f, 0.03193500f, 0.20050621f, 
    0.13996992f, 0.05251494f, 0.09914730f, 0.17273591f, -0.51881742f, -0.26391873f, -0.22677593f, -0.29178029f, 
    0.14441836f, 0.14877640f, 0.14650725f, 0.03822923f, 0.05059084f, 0.05769477f, -0.13170855f, -0.14658689f, 
    0.06510129f, -0.51709133f, -0.14610447f, -0.21941277f, 0.04799661f, 0.07004164f, 0.25957575f, 0.05925402f, 
    0.12998736f, -0.03565913f, -0.02196804f, 0.02478146f, -0.08296363f, -0.34698719f, -0.04144778f, -0.34803364f, 
    0.37542856f, 0.05466617f, 0.14930129f, 0.03408541f, -0.04201040f, 0.14159702f, 0.09259985f, -0.15756334f, 
    -0.22753662f, 0.11782216f, 0.15220493f, -0.01066334f, -0.06169750f, -0.04891280f, -0.13463011f, 0.00627463f, 
    -0.11022756f, -0.11740100f, -0.01443619f, -0.10871162f, 0.16530263f, -0.12744033f, -0.04814032f, 0.06507251f, 
    -0.02641886f, -0.01227639f, 0.07683981f, 0.07289486f, -0.09626551f, 0.03387091f, 0.04854992f, 0.07268172f, 
    0.01780463f, 0.30725306f, 0.26816863f, 0.24907354f, -0.03026285f, 0.17046888f, 0.01361166f, 0.29846361f, 
    0.18164369f, 0.21791270f, 0.12818225f, 0.04393691f, 0.00522180f, -0.06450830f, 0.12485425f, -0.27307507f, 
    0.14421187f, 0.09737764f, 0.03607841f, 0.08013575f, 0.02510984f, 0.13505870f, -0.16144416f, 0.18334067f, 
    0.24031489f, 0.22758429f, 0.27388376f, -0.08534522f, -0.01231617f, 0.20826299f, 0.18881036f, 0.26132396f, 
    -0.07257842f, 0.15509716f, 0.21510784f, -0.10276841f, 0.18892956f, -0.40836805f, -0.14567745f, -0.02291697f, 
    0.22628060f, -0.04116490f, -0.08466369f, 0.09909675f, 0.00398213f, -0.15416253f, 0.15078430f, 0.16186251f, 
    -0.60013223f, 0.04248141f, -0.27164784f, -0.25472331f, 0.11890480f, -0.04087642f, 0.16223530f, 0.15480673f, 
    0.07806914f, 0.16612892f, 0.31473497f, 0.22801782f, 0.06671816f, 0.07892606f, 0.04322922f, -0.11910624f, 
    0.15776770f, 0.30079052f, 0.04892403f, 0.04119203f, 0.05964383f, 0.11383144f, 0.00622084f, 0.00401635f, 
    -0.09123608f, 0.15641911f, 0.03548392f, -0.14413583f, 0.19307372f, 0.20005921f, -0.11206727f, -0.05385717f, 
    -0.04324804f, -0.01315145f, -0.00237128f, -0.30186495f, 0.02232633f, 0.39101443f, 0.02192253f, 0.03078239f, 
    -0.05496867f, 0.21736914f, 0.02284650f, 0.12881687f, -0.01412157f, -0.23357718f, 0.00702235f, -0.31780258f, 
    -0.03938014f, 0.24431331f, 0.29017550f, 0.09272408f, -0.00925490f, 0.08456139f, 0.15399422f, -0.06306206f, 
    0.09199852f, 0.09471976f, 0.11184209f, 0.06067257f, -0.04680896f, -0.35853204f, 0.27126551f, 0.16501182f, 
    0.17955838f, -0.00648873f, -0.11019523f, 0.04205299f, 0.15437716f, 0.08483389f, -0.12125175f, 0.17535360f, 
    0.09768900f, 0.16326837f, 0.24541017f, 0.25997362f, 0.15197982f, 0.01279107f, 0.06729439f, -0.14607218f, 
    -0.17065988f, -0.04089252f, -0.21476685f, -0.14062162f, -0.16086280f, 0.00256019f, -0.02569073f, -0.55971164f, 
    -0.05137787f, -0.04754670f, -0.05897195f, 0.09455975f, -0.16295165f, 0.08552381f, -0.01492689f, 0.08193568f, 
    0.26991111f, -0.30899128f, 0.12899476f, 0.12710878f, -0.06270782f, -0.08213618f, 0.05268603f, 0.20031895f, 
    0.07712254f, -0.03192951f, 0.03827541f, -0.03629974f, 0.36025873f, -0.25590312f, 0.14781694f, -0.01805099f, 
    -0.12536159f, -0.11489218f, -0.00876488f, -0.01989114f, -0.06739154f, -0.19642188f, 0.14276247f, 0.02304950f, 
    -0.37889856f, 0.20093493f, 0.09608142f, -0.39525920f, 0.13303490f, 0.26339754f, 0.04522552f, 0.15879285f, 
    0.25434494f, -0.04482372f, 0.05960655f, 0.06182832f, 0.14032315f, -0.68981367f, -0.27268931f, -0.23791990f, 
    -0.24592461f, -0.20951448f, -0.02115052f, 0.19127953f, -0.04321189f, -0.00833358f, 0.06547487f, -0.01723325f, 
    -0.00071847f, 0.02208126f, 0.06312925f, -0.06184297f, -0.06802939f, -0.04181838f, 0.06634365f, -0.02823993f, 
    -0.01334793f, 0.02280555f, -0.00296896f, 0.04596798f, 0.03582027f, 0.01272671f, -0.03829512f, -0.02256937f, 
    -0.05557847f, -0.03541710f, 0.01230188f, 0.04216880f, 0.02432160f, -0.04535693f, -0.01137525f, 0.04458203f, 
    -0.02479395f, 0.02760276f, -0.04914237f, 0.01583618f, -0.03543030f, 0.01456495f, -0.01314746f, -0.05013904f, 
    0.04751035f, 0.06394342f, -0.02152220f, -0.05873962f, -0.02622786f, -0.02433333f, -0.02717471f, -0.02673064f, 
    0.02997221f, 0.02562106f, -0.01557418f, -0.01824375f, -0.07295541f, -0.00952654f, -0.07575835f, -0.02806662f, 
    0.03819456f, -0.01961349f, 0.02825216f, -0.00029029f, -0.05321323f, 0.00785699f, -0.05949910f, -0.03099866f, 
    0.04380921f, 0.00015555f, 0.00118251f, 0.02209627f, -0.07388327f, 0.00794966f, 0.00039355f, 0.02829692f, 
    -0.06003290f, -0.02485555f, -0.00173185f, 0.04915961f, -0.07512918f, -0.02552801f, 0.03353421f, 0.04266380f, 
    -0.04336742f, -0.02702837f, -0.00729777f, -0.00208460f, 0.00090196f, -0.02904171f, -0.04918811f, 0.06163824f, 
    -0.06250853f, 0.00904381f, -0.03735613f, 0.03548679f, 0.04180996f, -0.05060218f, -0.02784989f, 0.06239685f, 
    0.05021919f, 0.00987430f, -0.03399452f, -0.07568161f, -0.07060163f, 0.02141647f, -0.04898614f, 0.01806435f, 
    0.06512480f, 0.04772807f, 0.05943450f, -0.06544598f, 0.03154236f, -0.07083779f, 0.02241133f, -0.00853203f, 
    -0.07773326f, -0.02877382f, -0.01981853f, -0.01718703f, -0.05870106f, -0.00940651f, -0.07183600f, -0.06949258f, 
    -0.00107701f, -0.04560587f, -0.04980240f, -0.04760684f, 0.06022481f, -0.00646076f, -0.05473067f, -0.00055999f, 
    0.03406077f, -0.06099916f, 0.01729411f, 0.00100611f, 0.00626620f, -0.06368110f, -0.07558693f, 0.03312773f, 
    -0.01986879f, 0.06034900f, -0.04065762f, 0.00408901f, 0.00267995f, -0.05866129f, 0.03063166f, -0.03569543f, 
    -0.02292221f, 0.05816193f, -0.04247237f, 0.01511295f, 0.04905268f, -0.02184627f, 0.03815900f, -0.01432005f, 
    -0.03613719f, 0.03989896f, 0.00082826f, -0.02810604f, -0.07644404f, -0.06309757f, 0.04214451f, -0.06058868f, 
    -0.00645428f, 0.01971312f, -0.04389685f, -0.03393549f, -0.07060788f, -0.04497746f, -0.00537832f, -0.06174132f, 
    0.04172583f, 0.01741011f, 0.01216063f, 0.02790287f, -0.05596318f, -0.01758711f, -0.05246561f, -0.05091184f, 
    0.05475311f, -0.04002522f, 0.00548581f, 0.02641816f, -0.00180894f, -0.00216732f, 0.05145060f, 0.01596776f, 
    -0.03376894f, 0.04771711f, -0.00255981f, -0.06395251f, -0.01641464f, 0.04070446f, 0.01792271f, -0.04505841f, 
    -0.03030161f, -0.05266787f, -0.04497469f, -0.06273880f, -0.01375851f, -0.02646986f, -0.00506553f, -0.03146233f, 
    -0.15091430f, -0.11319840f, -0.01222381f, -0.50465596f, 0.02397959f, -0.10689589f, 0.13041240f, -0.06709163f, 
    -0.22183815f, -0.03725615f, 0.12675431f, -0.15493891f, -0.19719708f, 0.04274495f, -0.41715738f, 0.24886397f, 
    -0.09033389f, 0.10798956f, -0.28956017f, -0.22501031f, 0.09401247f, 0.12965606f, 0.10016900f, 0.00624039f, 
    0.12615608f, 0.20794350f, -0.26983228f, 0.26533884f, -0.11900676f, 0.16032539f, -0.00627654f, -0.13750610f, 
    -0.02826101f, 0.09141888f, -0.06849708f, 0.04074138f, -0.49903563f, 0.43347642f, 0.08255859f, 0.20586342f, 
    0.12875777f, 0.15832201f, 0.07964288f, -0.00569079f, 0.14145613f, 0.12299449f, 0.09688514f, -0.01729611f, 
    0.69296587f, -0.18675245f, 0.03007752f, 0.19954541f, 0.09761883f, 0.03069247f, 0.04341318f, 0.10815097f, 
    0.06237105f, 0.14540274f, -0.15793295f, -0.22434112f, -0.08528551f, 0.26723483f, 0.17941819f, 0.19152275f, 
    -0.11082841f, -0.02148486f, 0.05668459f, -0.11727215f, 0.14198780f, -0.02821880f, 0.09004189f, 0.03206766f, 
    0.77431947f, -0.05463101f, 0.11352240f, 0.24627066f, -0.05216496f, -0.17217176f, 0.26490641f, -0.04348112f, 
    0.05372257f, 0.00755332f, -0.03420218f, 0.19207083f, 0.02514997f, -0.20288396f, 0.22802384f, 0.05180492f, 
    0.18814398f, -0.06384626f, 0.09225567f, 0.09181456f, -0.05734117f, 0.01226122f, 0.01506075f, 0.00690525f, 
    0.28214258f, -0.21170403f, -0.14543729f, 0.38632497f, 0.02546725f, 0.00395746f, -0.03327986f, 0.14675391f, 
    0.09222058f, 0.05488816f, -0.04255817f, 0.14979550f, -0.17928320f, -0.04279181f, -0.11895923f, -0.34469390f, 
    -0.14631236f, -0.12165033f, 0.32367066f, -0.13849197f, -0.23551650f, 0.01046464f, 0.04619805f, -0.12779121f, 
    -0.18681270f, 0.22368133f, -0.58259171f, 0.38261309f, -0.09318182f, 0.05538765f, -0.32588762f, 0.15271404f, 
    0.12255913f, -0.20458223f, 0.09686214f, -0.07297795f, -0.43428966f, -0.47578791f, 0.04500038f, 0.08884356f, 
    -0.01836844f, -0.06763529f, 0.23441283f, 0.03182083f, 0.08646633f, 0.03188530f, -0.01825802f, -0.03100200f, 
    -0.29539597f, 0.14751641f, -0.31924269f, 0.18861645f, 0.07978564f, 0.05625564f, 0.04231358f, 0.01118610f, 
    0.05316584f, 0.05612155f, -0.14391816f, 0.11887123f, -0.04009135f, -0.05161207f, -0.05379501f, -0.13210090f, 
    0.20787665f, -0.04065023f, 0.02581410f, 0.15061966f, 0.07849763f, 0.06880935f, -0.04620051f, -0.04056866f, 
    0.26730371f, 0.04417919f, -0.10556418f, 0.10935742f, 0.03497313f, -0.11877365f, 0.03236009f, 0.07280727f, 
    0.03254128f, -0.02012056f, 0.09140518f, 0.05461362f, 0.23114222f, 0.10122185f, 0.34043229f, -0.13444787f, 
    0.10327348f, 0.02683359f, -0.01401410f, 0.11048346f, 0.08925442f, 0.00693073f, -0.09641802f, -0.08300703f, 
    0.05641568f, 0.19709921f, -0.13928504f, 0.12031911f, -0.03331695f, -0.17308971f, 0.18194771f, -0.10894890f, 
    -0.18747008f, -0.05962443f, 0.00817237f, 0.04378759f, -0.41658869f, 0.02880424f, 0.16250962f, 0.04488971f, 
    -0.09194628f, -0.06672640f, 0.03525378f, -0.00799832f, -0.04685494f, -0.00050159f, 0.19721660f, -0.07650714f, 
    0.23972185f, -0.20333667f, 0.22586587f, -0.00840468f, -0.05094174f, -0.08506592f, -0.19396654f, 0.12775452f, 
    0.31461960f, 0.22536980f, -0.05582450f, 0.04699224f, -0.29836240f, 0.11059876f, 0.14261176f, 0.10546807f, 
    -0.03481737f, -0.04787380f, 0.11569688f, -0.18676913f, -0.02309276f, -0.18957132f, 0.01843922f, -0.25279522f, 
    -0.01452211f, -0.02374222f, -0.06278523f, -0.05708699f, 0.15831886f, 0.02022171f, 0.06597832f, 0.02793567f, 
    -0.05256989f, 0.16594973f, -0.15460543f, -0.11295263f, 0.13148177f, -0.24990074f, -0.26565564f, 0.23969381f, 
    -0.14896612f, 0.00750115f, 0.10538732f, 0.07183721f, 0.15260825f, -0.04791960f, 0.03661657f, 0.10395168f, 
    0.11630709f, -0.06455598f, -0.15219724f, 0.22052903f, 0.13376510f, 0.01984002f, 0.13889833f, 0.12680337f, 
    0.08670991f, 0.06883565f, -0.06673267f, 0.24245830f, 0.01292589f, -0.07218265f, -0.19058675f, 0.08986589f, 
    0.05018743f, 0.24456194f, 0.00525863f, -0.09918899f, -0.19400963f, -0.01369863f, 0.15016718f, 0.22611757f, 
    0.01475975f, -0.14776033f, 0.03849643f, 0.09711648f, 0.26613623f, 0.01645298f, 0.02222522f, 0.04860747f, 
    0.00863430f, 0.02005117f, -0.25726622f, 0.11018629f, -0.04459050f, 0.45379218f, -0.10821658f, -0.10967866f, 
    0.05688289f, -0.00109680f, 0.12307758f, -0.03355534f, 0.21912387f, -0.16901998f, 0.15385257f, -0.10363722f, 
    -0.08317053f, 0.22298437f, 0.04069617f, 0.04974163f, 0.05443287f, 0.03047780f, 0.31152114f, 0.10848586f, 
    0.00890402f, -0.03818445f, 0.17190562f, 0.12133931f, -0.08833868f, 0.02887923f, -0.28547248f, 0.26694295f, 
    -0.21795350f, -0.28087819f, -0.02232154f, -0.00987601f, -0.06000429f, -0.14822823f, -0.11927710f, -0.12933488f, 
    -0.51957172f, 0.05175123f, 0.10994952f, -0.09804729f, -0.21395399f, 0.01464594f, 0.06255767f, -0.34314728f, 
    0.01981625f, 0.16766168f, -0.03824885f, 0.06521777f, -0.38800654f, -0.00235927f, 0.29019150f, 0.13556381f, 
    -0.34188250f, 0.16318062f, -0.13631274f, -0.10968988f, 0.08857466f, 0.07730664f, 0.09353780f, -0.04185684f, 
    -0.25718433f, -0.12562056f, -0.01874253f, -0.08645792f, 0.00491422f, -0.00403422f, -0.03315285f, 0.06813095f, 
    0.05502399f, 0.20086767f, 0.07364392f, 0.11318967f, -0.18706384f, 0.27428895f, 0.32150969f, 0.20655026f, 
    -0.08273919f, 0.10934373f, -0.00937271f, -0.13784517f, 0.12726001f, -0.27721494f, -0.14466065f, 0.05390892f, 
    0.02069772f, 0.03467361f, -0.02772446f, 0.04783556f, -0.04508687f, -0.01580028f, 0.04454923f, -0.04523595f, 
    -0.02040330f, 0.01983241f, -0.01983411f, 0.00734915f, -0.00885138f, 0.04481136f, -0.06107381f, -0.03524055f, 
    0.02207459f, -0.05082262f, 0.02742368f, 0.03174824f, -0.03967302f, 0.02697179f, -0.05289531f, -0.03877991f, 
    -0.04127102f, -0.01845324f, 0.02291139f, -0.03477465f, 0.00987472f, 0.07401347f, -0.00346381f, 0.00819509f, 
    0.01038652f, -0.03823392f, 0.02987148f, -0.06809342f, -0.06262319f, -0.04723529f, -0.01221562f, 0.04957061f, 
    -0.03263830f, -0.06169523f, 0.02818518f, -0.05347120f, -0.05248718f, -0.02874181f, 0.00860436f, -0.00927778f, 
    -0.02609096f, -0.02133222f, -0.06502085f, -0.02151850f, 0.00967996f, -0.03247864f, 0.02141041f, -0.05174814f, 
    -0.04178477f, -0.02607612f, 0.05097783f, 0.02056932f, -0.06598388f, -0.00920007f, 0.07076425f, 0.00572517f, 
    -0.01057435f, -0.04956704f, 0.00775672f, -0.07052084f, -0.03587110f, -0.01987093f, -0.01693189f, -0.05258915f, 
    -0.03268246f, -0.08017989f, -0.05794549f, -0.00523331f, 0.03568900f, 0.03566189f, 0.00800631f, 0.01997887f, 
    -0.00455156f, -0.06333339f, 0.02257878f, 0.02103129f, -0.05346855f, -0.05219604f, -0.02206783f, 0.01815744f, 
    0.03385632f, -0.00880333f, -0.01558100f, -0.05168346f, 0.00265686f, 0.02567759f, -0.05840392f, -0.03789435f, 
    0.00250499f, 0.00609269f, 0.02559059f, -0.05878390f, 0.00491355f, -0.04196287f, -0.05077615f, -0.05399648f, 
    -0.02514700f, 0.02781167f, -0.07124109f, -0.06713318f, -0.01998439f, 0.02758114f, -0.01793598f, -0.05559713f, 
    0.05137396f, 0.03279146f, -0.02541441f, -0.03818405f, -0.02728359f, -0.05181078f, -0.00103936f, -0.05979816f, 
    -0.01316006f, 0.04538316f, -0.01883385f, 0.05138256f, 0.07554481f, 0.02681693f, -0.05571430f, -0.07312994f, 
    -0.03927141f, 0.03895067f, -0.06622443f, 0.06875281f, 0.01474649f, -0.02336060f, -0.07088705f, -0.06343380f, 
    0.06857048f, -0.00618258f, 0.04243492f, -0.05471838f, 0.05161443f, -0.04874671f, 0.06494116f, -0.00384355f, 
    0.00855711f, -0.04992701f, -0.00507576f, 0.05091734f, -0.02960338f, -0.02521179f, -0.06067972f, -0.06163148f, 
    0.06342473f, 0.01909493f, -0.04088392f, 0.05265268f, -0.06952190f, 0.04163523f, -0.05892803f, -0.07760886f, 
    -0.02539360f, -0.05976202f, 0.00197310f, 0.04625164f, 0.03018309f, 0.00234146f, -0.07492954f, 0.03645667f, 
    -0.00706067f, 0.05373852f, -0.04611336f, -0.00432145f, 0.06904601f, -0.03138571f, -0.05224315f, -0.04567600f, 
    0.03453771f, 0.05992918f, -0.04096651f, -0.05501682f, 0.06804822f, 0.04635280f, -0.03565551f, -0.01185675f, 
    0.01611862f, 0.04863661f, -0.08074746f, 0.02258991f, 0.04709109f, 0.05548546f, -0.02721677f, -0.02099310f, 
    -0.00610952f, 0.00658681f, -0.04112473f, -0.07949462f, -0.00469474f, -0.06851631f, -0.04857032f, -0.03593758f, 
    -0.03097144f, 0.00928000f, 0.04242033f, 0.05005906f, 0.02726995f, 0.00554179f, -0.06902538f, 0.02146825f, 
    0.03657351f, 0.04797981f, 0.00612056f, -0.00294858f, -0.00500492f, 0.03313843f, -0.06822462f, 0.05314805f, 
    0.05992379f, -0.01417398f, 0.00084880f, -0.05899978f, -0.02014881f, -0.00693772f, -0.03489828f, -0.06984288f, 
    -0.00613225f, 0.05380524f, -0.02783307f, -0.04909486f, 0.02170642f, -0.02394479f, -0.05872479f, -0.00247655f, 
    0.02376263f, -0.06348183f, 0.01978954f, -0.01181110f, -0.03853599f, -0.07370856f, -0.07281768f, -0.00685713f, 
    -0.04280216f, 0.06363414f, 0.02106743f, -0.02791206f, -0.04000884f, 0.00458963f, 0.05986199f, 0.00554776f, 
    -0.06078883f, 0.02561955f, 0.02496172f, -0.07263883f, 0.01652371f, -0.03531036f, 0.03676941f, -0.05196087f, 
    0.03841372f, -0.03543458f, -0.04773898f, -0.02331165f, -0.04627411f, 0.02788509f, -0.05568614f, -0.04004567f, 
    -0.04479701f, -0.00216989f, 0.05113932f, 0.06102330f, -0.01073581f, -0.06272508f, -0.03674047f, -0.05487569f, 
    0.05483514f, -0.05563084f, -0.04200399f, 0.01212387f, -0.04017032f, 0.01642618f, 0.05678949f, -0.06397151f, 
    -0.04549104f, -0.07557071f, -0.04611409f, -0.03930177f, 0.02667530f, 0.04935037f, 0.02458046f, -0.07967360f, 
    -0.07650439f, 0.05391998f, -0.03914965f, -0.07003256f, 0.05901336f, 0.00504470f, 0.06022276f, 0.03518791f, 
    0.01594371f, 0.06207867f, 0.02585319f, -0.04290414f, -0.02494278f, -0.05548539f, -0.06447701f, -0.00270995f, 
    -0.00631116f, 0.03283520f, -0.01384777f, -0.00165319f, -0.07093690f, -0.03532371f, -0.07048334f, 0.04120833f, 
    -0.01745077f, -0.05025478f, 0.05643658f, -0.02125680f, 0.00740554f, 0.00092000f, -0.06001877f, -0.06911026f, 
    -0.05615495f, -0.04239929f, -0.07527881f, -0.02149019f, -0.03475842f, 0.03409648f, -0.02181801f, 0.03962378f, 
    -0.03202603f, -0.01997018f, 0.01459729f, -0.06351762f, -0.04713004f, 0.04741720f, 0.01993381f, -0.03729220f, 
    0.05276943f, -0.07331789f, 0.02189081f, 0.01494382f, -0.00990368f, -0.04498114f, -0.05116256f, -0.01702240f, 
    0.00411684f, 0.06552555f, 0.04140708f, -0.08022808f, -0.04787555f, -0.04190806f, 0.02113101f, 0.04051282f, 
    -0.04985687f, -0.02519300f, 0.06041244f, -0.05841681f, 0.05808045f, 0.02457630f, 0.00621788f, 0.02804806f, 
    0.06188750f, -0.05554351f, -0.01936034f, 0.00351388f, -0.00814821f, 0.00807381f, -0.06248994f, -0.00518162f, 
    -0.02477125f, -0.02379303f, 0.05897298f, -0.05571789f, 0.03722822f, -0.01154236f, 0.01638690f, 0.01646533f, 
    0.02115035f, -0.06776648f, -0.04564745f, 0.05818456f, -0.01975845f, -0.02022723f, -0.05720817f, 0.02317085f, 
    -0.04047780f, -0.03066931f, -0.05660256f, 0.00382491f, 0.00298919f, 0.00862488f, -0.03390761f, -0.03278466f, 
    -0.01922585f, 0.00237025f, -0.03715214f, -0.04025878f, 0.04710794f, 0.01621329f, 0.01641153f, -0.06333553f, 
    0.03917257f, 0.00553557f, 0.01651031f, 0.03980858f, -0.02873812f, -0.07188335f, 0.01295409f, -0.00213369f, 
    0.05115902f, -0.07505918f, -0.01400265f, -0.03672404f, 0.01765292f, -0.07311421f, -0.04471582f, -0.00482637f, 
    -0.05219117f, 0.03636885f, -0.05288605f, -0.06211496f, -0.02125542f, 0.00521965f, -0.05939882f, 0.04286351f, 
    0.04725598f, -0.06464442f, -0.01753640f, 0.03111035f, -0.06580467f, -0.04118717f, -0.00137864f, -0.05482491f, 
    0.06056372f, 0.00409342f, -0.03442583f, -0.05579224f, 0.00463626f, 0.02505895f, -0.05886505f, 0.03182127f, 
    -0.01494886f, -0.08681691f, 0.01467574f, 0.05797669f, -0.03520176f, 0.03578949f, 0.01549835f, 0.02005146f, 
    0.00383527f, 0.05274750f, 0.02352539f, -0.03811688f, -0.01494806f, -0.00277767f, 0.03868431f, 0.06034292f, 
    0.00324069f, 0.05704227f, 0.02005205f, -0.03013948f, 0.03585725f, -0.05444007f, 0.02531592f, -0.00326231f, 
    -0.00309863f, -0.04203234f, -0.04332663f, -0.03593304f, 0.01309258f, 0.04906892f, 0.05396807f, -0.01965847f, 
    0.03132976f, 0.05736454f, 0.00142870f, 0.00335390f, -0.06045839f, 0.04189334f, -0.01841224f, 0.02720395f, 
    0.03038552f, -0.01636213f, -0.02438272f, -0.05611409f, -0.06720859f, -0.07240430f, -0.03387728f, 0.02945041f, 
    0.06109561f, -0.02174506f, 0.03938468f, 0.00670300f, -0.04194279f, -0.07745001f, -0.00133668f, -0.02434336f, 
    0.02282964f, -0.05488307f, -0.07858732f, -0.01603233f, 0.01435263f, 0.05372364f, -0.04470964f, -0.03362716f, 
    0.02009615f, -0.02773834f, -0.06306658f, -0.05183468f, -0.07357875f, -0.06511246f, -0.01319526f, -0.03223998f, 
    -0.00333788f, -0.06866588f, -0.01854758f, -0.00227140f, 0.03917681f, -0.07007478f, 0.01608210f, 0.01402644f, 
    0.03615893f, -0.07790105f, 0.05219588f, -0.05544554f, -0.04163456f, 0.00055828f, 0.02986219f, -0.01826439f, 
    -0.06227433f, 0.02642990f, -0.04975475f, -0.08712033f, 0.04949691f, 0.01618716f, -0.07255274f, -0.00144709f, 
    -0.05916635f, -0.06375063f, -0.06237340f, -0.02567429f, -0.08450530f, 0.02740002f, 0.02811385f, 0.02250487f, 
    -0.01771028f, 0.03617598f, 0.02735380f, 0.05364756f, -0.00346939f, -0.05900032f, -0.02308073f, -0.04422510f, 
    -0.01497659f, -0.03437762f, 0.01801293f, -0.01493992f, 0.05045270f, 0.00828618f, 0.02231236f, -0.03613570f, 
    -0.02084862f, -0.02046717f, -0.05108588f, 0.02839955f, -0.04588046f, 0.07039887f, 0.02364678f, -0.01124697f, 
    0.00338183f, -0.04416438f, 0.03777092f, 0.02642841f, 0.03888235f, -0.00320140f, 0.01490502f, 0.06269448f, 
    -0.26409760f, -0.07784216f, -0.17916583f, 0.16983616f, 0.00719787f, -0.07689847f, 0.09211284f, -0.04492780f, 
    0.16918468f, 0.05338817f, 0.03342985f, 0.17570756f, 0.06364376f, 0.38312456f, 0.02767806f, 0.17994262f, 
    0.28639710f, -0.09218520f, -0.03315661f, 0.01278973f, 0.05175950f, -0.04991247f, 0.05178315f, 0.17381361f, 
    0.44743606f, -0.11536103f, 0.12352254f, 0.11827278f, 0.03474786f, 0.09670100f, 0.23686105f, 0.23207353f, 
    0.00311750f, 0.26789764f, -0.11929424f, -0.03827401f, -0.07458813f, -0.17497748f, -0.00215609f, -0.15266241f, 
    0.09904233f, -0.15894900f, 0.09272047f, 0.17239203f, 0.14474344f, -0.17507786f, 0.08759909f, 0.26250982f, 
    0.30150968f, 0.22213171f, -0.03610231f, -0.07474934f, 0.09699854f, 0.06005746f, -0.09494045f, -0.08897366f, 
    -0.19640537f, 0.03777154f, 0.14141634f, -0.02314877f, -0.18790467f, -0.12999074f, 0.03793582f, -0.08707377f, 
    -0.01180566f, -0.08857300f, 0.02429546f, -0.21911334f, 0.00927157f, -0.01194396f, -0.05934425f, 0.05637464f, 
    -0.03691994f, 0.30436689f, -0.19952656f, 0.15448989f, 0.25663534f, -0.08778326f, -0.16729018f, -0.01142134f, 
    0.03958911f, 0.01836521f, -0.19877540f, -0.16408995f, 0.04615461f, 0.03715745f, -0.29875988f, -0.09079915f, 
    -0.03157669f, 0.03745562f, 0.22545704f, 0.19677106f, 0.31459412f, -0.19361582f, -0.03817249f, -0.44165507f, 
    0.23315655f, -0.12161410f, -0.15066755f, 0.02757011f, 0.04321677f, -0.15320864f, -0.21515973f, -0.16236225f, 
    0.03026513f, 0.01830695f, -0.19697614f, -0.03789343f, -0.04415448f, 0.36355582f, -0.46564749f, 0.03129917f, 
    -0.15608555f, 0.04170297f, -0.14544465f, -0.12737468f, 0.16533326f, 0.18853723f, 0.07681307f, 0.10610565f, 
    0.03409996f, -0.11037152f, 0.23032974f, 0.03129090f, 0.09058223f, -0.10024068f, 0.18540438f, -0.31134570f, 
    -0.13163868f, 0.05676518f, -0.24111371f, -0.22941014f, -0.12158117f, -0.04463479f, 0.28600061f, 0.01942488f, 
    -0.11479051f, -0.12271959f, -0.18015625f, -0.09877840f, -0.29499534f, -0.03561233f, -0.15637191f, -0.15297917f, 
    -0.30887842f, 0.47161910f, 0.13405557f, -0.09835739f, 0.12942778f, -0.02757920f, -0.00106679f, 0.10324907f, 
    -0.06488427f, 0.15890262f, 0.18138817f, 0.07922210f, -0.01184686f, 0.02136655f, 0.27258766f, 0.04561279f, 
    -0.05898305f, 0.15374203f, 0.11008735f, 0.19946900f, 0.08806641f, -0.23747818f, 0.07507703f, 0.18233790f, 
    -0.01598453f, 0.11049994f, -0.06121283f, 0.10894459f, 0.10438380f, 0.12756272f, -0.28767139f, -0.02996658f, 
    -0.04988305f, 0.04592413f, 0.19054542f, 0.08660528f, 0.70646816f, 0.05098240f, 0.11192881f, -0.07023856f, 
    0.12135781f, 0.16636637f, -0.00063729f, 0.19413587f, -0.26254851f, -0.07126629f, 0.07471939f, 0.35077623f, 
    -0.20301694f, 0.29199654f, 0.01843369f, 0.07809367f, -0.05080795f, -0.09888107f, 0.03081043f, -0.08929361f, 
    0.02753602f, 0.00479628f, 0.04540699f, 0.08489719f, -0.60960567f, -0.00777907f, -0.07590058f, -0.02108668f, 
    0.17124322f, 0.01938260f, 0.05260166f, 0.11096536f, 0.16211477f, -0.06705476f, -0.12903191f, 0.07345940f, 
    -0.00679426f, -0.16451856f, -0.31471896f, -0.35483927f, -0.17790025f, 0.11953551f, 0.02590610f, -0.27269286f, 
    0.03899307f, -0.05010204f, 0.03449627f, -0.13626271f, 0.02637700f, -0.38484100f, 0.02898789f, -0.16272585f, 
    -0.09069823f, 0.09423083f, -0.18757565f, 0.22657117f, -0.05542599f, 0.20691231f, -0.01557163f, 0.06719947f, 
    0.57988405f, -0.46118805f, 0.12195527f, 0.39641556f, 0.05514798f, 0.02441701f, 0.03329653f, 0.04668721f, 
    0.07960425f, 0.04455150f, 0.02729662f, 0.02276723f, 0.07738635f, 0.14938848f, -0.16448919f, -0.28718224f, 
    0.05480350f, -0.07909508f, 0.08031549f, -0.10315602f, 0.23302063f, 0.01841186f, 0.05978746f, 0.10623144f, 
    0.23095749f, -0.13110854f, 0.15913272f, 0.28396058f, -0.04274532f, -0.04400031f, 0.06843388f, -0.05038987f, 
    0.28499326f, 0.11381831f, 0.23894951f, -0.01032225f, 0.18282549f, 0.28815687f, -0.30721667f, -0.05473201f, 
    0.01431075f, -0.01507482f, 0.16155101f, 0.03719681f, -0.11943995f, 0.29557046f, 0.02175343f, -0.05008691f, 
    0.07089366f, 0.00338191f, 0.17564398f, 0.12792425f, 0.02259157f, -0.06793500f, -0.12008663f, 0.23742355f, 
    -0.00573505f, -0.10574332f, -0.08182386f, -0.15272580f, 0.16125710f, -0.28728840f, -0.40146425f, -0.03867334f, 
    0.20497106f, -0.06333364f, 0.09501342f, -0.03271457f, -0.09178123f, 0.05300177f, 0.21495526f, 0.06608760f, 
    -0.10829617f, 0.00267155f, -0.29189560f, 0.44340914f, -0.23367935f, 0.07360987f, 0.01330244f, -0.07330339f, 
    -0.11937847f, 0.06250948f, 0.14115922f, 0.00366163f, 0.07786408f, 0.08011929f, 0.15089764f, -0.04231709f, 
    -0.09220962f, 0.02059545f, 0.09574349f, 0.10318924f, 0.12684453f, 0.00908239f, 0.18532115f, 0.02654335f, 
    0.21994708f, 0.14481743f, 0.10551549f, 0.12470592f, 0.07369345f, -0.14947087f, -0.00723843f, -0.00675094f, 
    -0.03497040f, -0.04601706f, -0.00328666f, -0.07748219f, 0.33609262f, 0.00879000f, 0.13960852f, 0.34470963f, 
    -0.05846341f, 0.00588362f, 0.02765192f, 0.14904973f, -0.06454694f, 0.09869223f, -0.05342418f, 0.16538304f, 
    -0.12114780f, 0.20511982f, 0.21670151f, -0.06059244f, -0.00021719f, -0.14050157f, 0.20373216f, 0.02195472f, 
    -0.02066987f, 0.02811510f, -0.00365812f, -0.08258579f, -0.28122920f, -0.31578994f, -0.33661547f, 0.00278714f, 
    -0.18007806f, 0.03549533f, -0.03648169f, 0.03506738f, -0.00428836f, 0.31900045f, -0.04359631f, 0.09052758f, 
    0.21799763f, -0.11761939f, 0.26525176f, 0.40231898f, -0.06401280f, 0.05631636f, 0.17341948f, 0.21870716f, 
    0.13912442f, 0.12354323f, -0.06484411f, 0.02267889f, -0.27911991f, 0.41234466f, 0.10942794f, -0.13747540f, 
    0.20022818f, -0.00833386f, 0.13795236f, 0.09876834f, -0.06991055f, 0.15279955f, -0.07542232f, -0.00362061f, 
    0.33225861f, -0.21355091f, 0.28271678f, -0.31418747f, 0.07266266f, 0.08099534f, -0.09483329f, 0.16631275f, 
    -0.03067529f, 0.05343474f, 0.02870670f, 0.09975798f, -0.10727735f, 0.09843605f, 0.06438601f, -0.36889413f, 
    0.08623050f, -0.05246671f, 0.08429738f, 0.01985398f, -0.07206916f, 0.04082636f, -0.05423557f, 0.10807469f, 
    -0.30725616f, 0.32535696f, 0.05007378f, -0.55611819f, 0.18145657f, 0.11185670f, 0.10157496f, -0.13120866f, 
    -0.03378351f, -0.03350161f, 0.02536955f, 0.07233232f, 0.25114122f, -0.21958648f, 0.17198411f, 0.40098384f, 
    0.00560999f, -0.03053698f, -0.11047875f, 0.02008248f, 0.07697648f, -0.17868355f, -0.05660636f, -0.07794853f, 
    -0.23998937f, 0.29502785f, 0.03937365f, -0.15866353f, 0.18214101f, 0.15112437f, -0.00244719f, -0.01816181f, 
    0.03665678f, 0.04598592f, 0.09086095f, 0.17334884f, 0.28071970f, -0.05018946f, -0.10855327f, 0.05160164f, 
    0.02574357f, 0.02442532f, 0.01331702f, 0.00310233f, 0.01925404f, -0.10108498f, 0.03812687f, 0.05802706f, 
    -0.12532249f, 0.04623063f, -0.31764749f, -0.54089183f, 0.30833989f, 0.13465036f, 0.08162240f, -0.00547215f, 
    -0.00173119f, 0.02819216f, -0.06205560f, 0.21805745f, -0.10086343f, 0.51024699f, -0.33535385f, 0.46222019f, 
    0.19816265f, 0.12965910f, 0.04718045f, -0.06398575f, 0.17633593f, -0.03814299f, 0.01563733f, 0.12090192f, 
    0.37248826f, -0.14173186f, 0.16243567f, -0.18388852f, 0.07555772f, 0.05903301f, 0.29186115f, 0.09893622f, 
    -0.13080060f, 0.12170880f, -0.00784219f, -0.20278406f, 0.06314339f, 0.16313264f, -0.13714612f, 0.31811020f, 
    0.16702467f, 0.00495725f, -0.14454563f, -0.13977355f, 0.06566575f, 0.14202529f, 0.05748386f, -0.06223011f, 
    -0.26076531f, 0.15938382f, 0.25596032f, 0.03672706f, 0.04420168f, 0.10086545f, 0.04166707f, 0.04186361f, 
    0.03239809f, 0.18653297f, -0.04410073f, -0.20574296f, -0.27360725f, 0.03532464f, -0.07126763f, 0.40685642f, 
    -0.14324448f, 0.14679487f, 0.14822435f, 0.15467790f, 0.02083634f, 0.01107417f, -0.03233295f, -0.13503848f, 
    -0.20787039f, 0.29756504f, 0.26971006f, 0.04426898f, 0.04263260f, 0.09586382f, 0.05722183f, -0.14393649f, 
    0.01620805f, 0.19763626f, 0.08238550f, 0.27372220f, -0.36372882f, -0.04832572f, -0.13021471f, 0.48540279f, 
    0.05425474f, 0.04852907f, 0.06490280f, 0.07667220f, -0.09912096f, 0.06732193f, 0.04908136f, -0.05990618f, 
    0.01730613f, 0.04762110f, 0.03972245f, 0.05224351f, -0.05163542f, 0.01094555f, 0.04050251f, 0.01299111f, 
    -0.05400870f, -0.06307095f, -0.00685977f, 0.03476933f, 0.05061107f, -0.02303723f, 0.05672314f, 0.02853931f, 
    0.02537578f, -0.02470943f, -0.06365235f, -0.02563769f, -0.05548292f, 0.00526307f, -0.02792643f, -0.01181636f, 
    0.05670296f, 0.01280980f, 0.00038480f, 0.05827068f, 0.05053962f, -0.03096925f, 0.00854840f, -0.01420366f, 
    -0.06730357f, 0.04522331f, -0.07085235f, -0.04409605f, -0.02736337f, 0.06604657f, -0.05698127f, 0.06562429f, 
    0.01539770f, -0.03380848f, 0.04078593f, -0.06027769f, 0.00364067f, -0.06731827f, 0.00446787f, 0.03108392f, 
    -0.05967793f, 0.06195960f, 0.03417484f, -0.05489640f, -0.02521780f, -0.00450029f, -0.04265020f, 0.06632899f, 
    -0.00429102f, 0.00595315f, -0.06334656f, 0.03220529f, 0.03871194f, -0.02743458f, -0.02482755f, -0.03562987f, 
    -0.03539384f, -0.04755600f, 0.05028965f, 0.02490089f, 0.05938442f, -0.04382673f, -0.06003960f, 0.02032827f, 
    -0.06765128f, -0.05706766f, -0.01518880f, -0.01050626f, 0.05967089f, -0.01342545f, -0.02135455f, 0.01959213f, 
    0.02129107f, -0.05822016f, -0.05665128f, -0.03518418f, 0.03105052f, -0.07843155f, -0.01579768f, 0.02839346f, 
    -0.05034394f, -0.07036359f, -0.04996479f, 0.00233541f, 0.01863417f, -0.01670147f, -0.03973570f, -0.03104242f, 
    0.02352517f, 0.06085071f, 0.02471859f, -0.05747152f, 0.03205570f, -0.06803577f, 0.00306710f, 0.00768697f, 
    0.06117253f, 0.04401310f, -0.04644398f, -0.02679202f, 0.02664687f, 0.04393074f, -0.07085632f, -0.05833887f, 
    -0.06737170f, 0.02393484f, 0.00087117f, 0.06290925f, 0.02477441f, 0.01031109f, -0.07696524f, 0.04943722f, 
    -0.02507537f, 0.04202481f, -0.05157639f, 0.05483074f, -0.07476127f, 0.02521632f, -0.06094581f, -0.07303448f, 
    -0.00100748f, 0.00775991f, 0.01481811f, -0.06270315f, -0.04459542f, 0.01980402f, -0.00966810f, 0.01514474f, 
    -0.06253476f, -0.04029615f, 0.02307771f, -0.05997103f, -0.00968496f, -0.05990424f, 0.01096336f, -0.01651296f, 
    0.03288693f, -0.02603871f, -0.06054689f, 0.05556047f, -0.02809711f, -0.01993984f, -0.05178593f, 0.01887261f, 
    0.03182966f, -0.01560965f, 0.05217868f, 0.03378909f, -0.00107586f, 0.02821352f, 0.00394238f, -0.06618759f, 
    0.04892356f, -0.06204101f, 0.02528061f, -0.05337086f, -0.06110005f, -0.03483158f, -0.02912446f, 0.01872226f, 
    -0.04619156f, -0.02594947f, 0.01040130f, -0.02141427f, -0.05630598f, -0.03565018f, 0.03620005f, 0.06388131f, 
    0.04411732f, -0.03058122f, 0.03896411f, -0.04927437f, 0.02327916f, -0.03764163f, -0.02664720f, 0.02282996f, 
    -0.05329089f, 0.01756738f, -0.04491566f, -0.07174922f, -0.02474104f, 0.00009305f, -0.07370587f, -0.06432817f, 
    0.49019048f, -0.21824330f, 0.15017089f, 0.25091016f, 0.03472138f, -0.06463006f, 0.04201477f, -0.00983375f, 
    0.02772690f, 0.10185985f, -0.06111362f, 0.06089621f, -0.54772395f, -0.00265670f, -0.04711186f, -0.25315008f, 
    0.09177490f, -0.20246093f, 0.12049425f, 0.11336608f, -0.07768285f, 0.04336621f, 0.06097394f, 0.08630988f, 
    0.01409073f, -0.10848501f, 0.20559369f, -0.23958038f, 0.16825034f, -0.09639145f, -0.21220176f, 0.03424587f, 
    0.18989658f, 0.01686058f, 0.09020746f, 0.04228256f, 0.23117819f, 0.30977312f, -0.08232412f, -0.09897020f, 
    0.18378800f, -0.01734511f, -0.01503736f, 0.08937810f, -0.13045944f, 0.16218296f, -0.02415075f, 0.19535875f, 
    -0.19844908f, 0.14867309f, 0.11472186f, 0.01358808f, 0.17617828f, 0.06966799f, -0.01506465f, -0.07704219f, 
    0.14177541f, -0.12552135f, 0.01647318f, 0.01566445f, 0.20038521f, -0.25200650f, -0.10643144f, -0.15448256f, 
    0.06549706f, -0.09422497f, -0.15465406f, 0.10756605f, 0.09953912f, -0.02499086f, 0.16686352f, 0.16182320f, 
    0.28607938f, 0.24622281f, 0.23812176f, 0.05703015f, 0.18426909f, 0.16572277f, -0.20581126f, -0.05041301f, 
    -0.01176615f, 0.09457149f, 0.06242686f, 0.04207100f, -0.22632584f, -0.09580098f, -0.19078575f, -0.05459559f, 
    -0.09374524f, -0.02406108f, -0.02613436f, -0.11174842f, -0.05361152f, 0.05068970f, -0.02185684f, 0.20890635f, 
    -0.05879182f, 0.10957258f, 0.27090994f, -0.39722863f, 0.40966979f, -0.00810128f, 0.07593197f, 0.10003588f, 
    0.20528825f, -0.15460142f, -0.02692835f, 0.16720720f, -0.18853885f, 0.21344729f, 0.05231354f, 0.04720359f, 
    0.13070562f, 0.14995360f, -0.07192057f, 0.06324230f, 0.08575229f, -0.11776458f, 0.15123008f, 0.15021773f, 
    -0.21286537f, 0.01461257f, 0.04943789f, 0.00491698f, 0.10565134f, -0.09009247f, 0.18919380f, 0.01128641f, 
    -0.09756279f, 0.04727641f, -0.04193171f, -0.16222368f, 0.17094690f, 0.19243538f, -0.14634466f, -0.06803220f, 
    0.13477932f, 0.22584106f, -0.16376601f, 0.05984284f, 0.07080645f, 0.09413892f, 0.09929923f, 0.15875359f, 
    -0.57359946f, -0.16320598f, -0.03267651f, 0.16909625f, 0.23847534f, 0.03132148f, 0.15552333f, 0.10544325f, 
    0.03196597f, -0.08886688f, 0.11112665f, 0.03196033f, -0.47606635f, -0.11458998f, -0.13498877f, 0.16301537f, 
    0.04329391f, 0.06924507f, 0.14027064f, 0.02302798f, -0.09335651f, 0.17711069f, 0.01068601f, -0.07460821f, 
    -0.12053586f, 0.08320089f, 0.46941113f, -0.09634132f, 0.06935676f, -0.00333291f, 0.07051833f, -0.20653394f, 
    0.10915958f, 0.12663515f, -0.05566348f, 0.04810827f, -0.88313800f, -0.27557269f, -0.45954242f, 0.16513392f, 
    -0.16724260f, 0.11523759f, 0.17634781f, -0.09658245f, -0.01461219f, 0.05859138f, -0.02174129f, 0.17258573f, 
    -0.15871333f, 0.24094652f, -0.43179691f, -0.09981205f, 0.01172606f, 0.18112873f, 0.17551166f, -0.05613770f, 
    -0.18242738f, -0.00806247f, -0.08353493f, 0.06060453f, 0.43599728f, -0.37066895f, 0.11783699f, -0.18209915f, 
    -0.18141945f, 0.15225165f, 0.15221083f, 0.13741758f, -0.03081694f, -0.03854533f, 0.09124328f, 0.01554295f, 
    -0.00393580f, 0.08628347f, -0.06963582f, 0.09153926f, 0.15812050f, -0.07473490f, -0.19477147f, -0.01170813f, 
    0.07435720f, -0.00359767f, 0.23131655f, -0.07540771f, -0.24703968f, 0.25346163f, 0.24157488f, 0.17634624f, 
    -0.15291421f, 0.04933774f, -0.14766759f, -0.16966371f, -0.00425040f, 0.14068782f, -0.12442273f, -0.21475726f, 
    0.54285592f, -0.24635454f, 0.42787212f, 0.06981484f, -0.15210341f, -0.21744995f, -0.02913835f, 0.00727164f, 
    -0.04120531f, -0.02974160f, 0.04583874f, 0.00793509f, -0.38987428f, 0.31839719f, -0.24351452f, 0.14897937f, 
    0.00139230f, 0.04251376f, 0.11798650f, 0.13305308f, -0.06116429f, 0.05162716f, 0.00580526f, 0.18593659f, 
    0.24663229f, -0.15703656f, 0.23235229f, 0.36719969f, -0.09775774f, 0.07100803f, 0.10797672f, -0.05450567f, 
    0.08018174f, -0.17393267f, 0.23347013f, 0.21329373f, 0.07088370f, 0.03115200f, 0.06356956f, -0.07324263f, 
    0.07102570f, 0.01727719f, -0.24598093f, -0.03526780f, -0.08039151f, 0.26681802f, 0.10741990f, 0.28020495f, 
    0.05436485f, 0.17257862f, 0.26942068f, 0.58701801f, -0.09019016f, -0.04479528f, -0.09602189f, -0.04147539f, 
    0.08428363f, -0.05669670f, 0.16037251f, 0.10848891f, 0.02745966f, -0.24047726f, -0.11122078f, 0.04873308f, 
    0.05087646f, -0.00502982f, 0.11205545f, 0.06501781f, 0.10991849f, 0.05077003f, -0.10439613f, 0.09913601f, 
    -0.07023216f, -0.08889571f, 0.10084725f, -0.05390897f, 0.03482680f, 0.01898809f, 0.07762565f, 0.29783273f, 
    0.10681253f, -0.11340561f, 0.19536233f, 0.21743275f, -0.38980082f, 0.06057302f, -0.04190953f, -0.16509233f, 
    0.05238521f, 0.04728676f, -0.05727972f, 0.14059989f, 0.23188713f, -0.09508459f, 0.15644936f, 0.16960000f, 
    0.25025263f, -0.12189613f, -0.01755247f, -0.23183537f, -0.12045763f, 0.10832134f, -0.15825419f, -0.09149161f, 
    0.13501991f, -0.21072462f, 0.08318143f, 0.28150317f, 0.17176829f, -0.11496455f, -0.11476800f, -0.31356573f, 
    0.06580420f, 0.01524428f, 0.01782717f, -0.11973003f, 0.07911449f, 0.16173807f, 0.05958725f, -0.14857730f, 
    -0.15037985f, 0.06755476f, 0.01463616f, 0.10291202f, 0.23611794f, -0.07913352f, 0.16672899f, 0.12734193f, 
    -0.10015796f, 0.27059245f, -0.10557775f, -0.02185761f, 0.26767725f, -0.19051319f, 0.05576317f, -0.24922675f, 
    0.06272035f, -0.08667102f, -0.03326939f, -0.08371987f, 0.24177583f, -0.25234759f, -0.12351893f, -0.04769010f, 
    0.03751076f, 0.34633780f, 0.13207346f, 0.03380707f, -0.16734707f, -0.05056299f, -0.01253013f, 0.11167727f, 
    -0.04164063f, 0.00692384f, 0.15677336f, 0.06781837f, -0.32927880f, 0.11154107f, -0.04116739f, 0.33396038f, 
    0.11303308f, 0.01443280f, -0.06387305f, -0.09717059f, 0.19959837f, 0.10406686f, 0.07741943f, -0.04314081f, 
    -0.28422853f, 0.07652225f, -0.33296847f, 0.08363078f, -0.17492537f, 0.01780531f, 0.06765395f, -0.12059948f, 
    -0.08231806f, -0.07279577f, -0.05536867f, 0.15337016f, 0.19797315f, -0.28106499f, 0.04015393f, -0.11352696f, 
    -0.02756167f, 0.13215400f, -0.04625768f, 0.14241023f, 0.04280902f, 0.10064624f, 0.12733608f, -0.05097793f, 
    0.27273667f, -0.30397847f, -0.14563116f, 0.37670496f, 0.24997385f, 0.05186477f, -0.03612016f, -0.00533147f, 
    0.07761165f, 0.21195368f, 0.07920928f, -0.04938374f, 0.26819494f, 0.21981673f, 0.03450665f, -0.03914831f, 
    0.11150897f, 0.14154203f, 0.06718137f, -0.06966252f, 0.23196663f, 0.13998453f, 0.11819970f, -0.04259145f, 
    -0.04348313f, -0.58443987f, -0.17212828f, 0.14753789f, 0.19184180f, -0.01640917f, 0.00055262f, -0.04960711f, 
    0.00966919f, 0.13258395f, -0.01533527f, 0.14733669f, 0.33888832f, 0.10111511f, -0.29177997f, -0.22899184f, 
    0.29100183f, -0.06777868f, 0.10704714f, 0.08858682f, -0.09719277f, 0.17490657f, -0.03284314f, -0.14299037f, 
    -0.18114811f, -0.21590364f, 0.07750680f, 0.31003577f, -0.02211787f, 0.08985092f, -0.12832968f, 0.07115138f, 
    -0.10726179f, 0.01465588f, 0.17611492f, -0.13012236f, -0.17329766f, -0.32040343f, 0.03533301f, -0.35396120f, 
    0.07692810f, -0.06051728f, -0.02835568f, 0.00115910f, -0.02233049f, 0.15242378f, 0.07643931f, -0.22617933f, 
    0.42378071f, 0.25939679f, -0.20047773f, 0.28962085f, -0.11184918f, 0.11141276f, -0.21380113f, -0.05547754f, 
    -0.05676119f, 0.09547617f, 0.21395706f, 0.18391792f, 0.22520542f, -0.21721952f, 0.24310520f, -0.19101541f, 
    -0.15804401f, -0.10377450f, 0.17895909f, 0.18329528f, 0.11575503f, -0.21349156f, -0.02587461f, -0.04496193f, 
    0.57995754f, 0.09704336f, 0.07716361f, 0.37572074f, -0.08525123f, -0.07907607f, 0.16934201f, 0.11229728f, 
    -0.22406413f, -0.01024546f, 0.05060529f, -0.08036175f, 0.63660097f, 0.20613296f, 0.24520926f, 0.27168366f, 
    -0.05011200f, -0.14653771f, 0.10698695f, 0.24282408f, -0.10185058f, -0.01311524f, -0.14767742f, -0.05425671f, 
    0.11688728f, -0.20410660f, 0.12611689f, 0.03076411f, -0.07367080f, -0.15672153f, -0.17006266f, -0.01227647f, 
    0.13321348f, -0.10245533f, 0.03775777f, -0.13164860f, 0.18041287f, 0.02071217f, 0.20714359f, -0.22288516f, 
    -0.03772062f, -0.13983785f, 0.03176177f, 0.16027100f, -0.03461244f, 0.13801506f, 0.00914713f, -0.14278467f, 
    -0.07602421f, 0.02112719f, -0.03512568f, 0.02915221f, -0.05926137f, -0.02461931f, -0.07278122f, -0.02625904f, 
    0.03053571f, -0.01272612f, -0.02761158f, -0.04962553f, -0.00455984f, -0.00894472f, -0.06873295f, -0.05001244f, 
    -0.07164825f, 0.02030303f, -0.02466128f, -0.03519126f, -0.06413092f, 0.03902122f, -0.01581703f, -0.03259104f, 
    -0.07746983f, -0.04445647f, -0.07446514f, -0.05520583f, -0.05550132f, 0.01905518f, -0.02806501f, -0.04194491f, 
    0.02326167f, -0.02230203f, -0.01579257f, 0.05623240f, 0.01724977f, 0.00207119f, 0.02017977f, -0.03368242f, 
    -0.05814071f, 0.00514243f, 0.05039879f, -0.05778171f, 0.05556059f, 0.03231425f, 0.02066232f, 0.06027818f, 
    -0.05524615f, -0.03886029f, 0.01524472f, -0.04010917f, -0.03835638f, 0.05765368f, 0.06140989f, 0.02933147f, 
    0.05926474f, -0.02105514f, 0.06099369f, 0.00354696f, -0.00409913f, -0.02853732f, 0.02627908f, -0.00061447f, 
    -0.04413588f, 0.05841235f, -0.05060755f, -0.02051404f, 0.01003427f, -0.03323897f, -0.02624673f, -0.03389389f, 
    -0.03503698f, 0.00253604f, -0.00306812f, 0.00448525f, -0.00857222f, -0.02856800f, 0.02875243f, 0.00620766f, 
    0.06480426f, -0.05869774f, -0.06921650f, -0.00217635f, 0.00303174f, -0.07107485f, -0.07314820f, -0.06606220f, 
    -0.00808556f, 0.04791845f, -0.06699706f, 0.06195460f, 0.02594762f, 0.02486655f, 0.01148121f, 0.02399763f, 
    -0.02148254f, -0.05921052f, -0.07178919f, -0.07713900f, 0.01627698f, -0.06688815f, -0.07511808f, -0.03899254f, 
    -0.04512916f, 0.04376347f, 0.04388771f, 0.02486612f, 0.03394128f, -0.02982952f, -0.01844091f, 0.04163666f, 
    -0.01366192f, -0.01523904f, 0.00978097f, 0.04482663f, -0.03723948f, -0.02124587f, 0.00910407f, -0.05499345f, 
    -0.03742938f, 0.05973491f, -0.06781148f, 0.04961589f, -0.05848607f, 0.01526823f, 0.01435710f, 0.02954530f, 
    -0.01942991f, -0.04580116f, 0.00554639f, -0.05307917f, -0.04556071f, -0.07124079f, -0.01328396f, 0.03962601f, 
    0.00225308f, 0.01700455f, -0.04023932f, -0.01932244f, -0.04290899f, -0.03721693f, 0.01861762f, 0.02577180f, 
    0.04803366f, 0.01128581f, -0.00635107f, -0.02712096f, 0.06180479f, 0.04623933f, -0.07842511f, -0.03363593f, 
    -0.02182208f, 0.02859664f, -0.07965111f, -0.03488333f, 0.01442352f, 0.01343493f, -0.03932611f, -0.00767105f, 
    -0.00418122f, 0.03544851f, -0.01614695f, 0.03375527f, 0.00481680f, -0.03964826f, -0.02307515f, -0.06695020f, 
    -0.01735293f, -0.06092133f, -0.04101163f, 0.01787444f, 0.01124292f, 0.04982659f, -0.01587713f, 0.02822720f, 
    -0.07305545f, -0.06540684f, 0.03517240f, -0.06219487f, -0.07802616f, 0.00372878f, 0.01140108f, 0.02933848f, 
    -0.05682485f, -0.02144929f, 0.01894708f, 0.02243438f, 0.00479624f, 0.03426119f, 0.05138558f, -0.03693706f, 
    0.99778444f, -0.09111580f, 0.09708972f, -0.22101897f, 0.09987174f, -0.13409261f, 0.03948415f, -0.01744425f, 
    -0.02919355f, 0.12817818f, 0.08358168f, -0.09524281f, -0.16030514f, 0.02643845f, -0.24905665f, -0.02261798f, 
    -0.08329786f, -0.19012900f, 0.04347998f, 0.01518644f, -0.15160190f, -0.01117083f, 0.14351183f, -0.13216168f, 
    0.11926690f, -0.11100637f, 0.22936563f, 0.13184208f, 0.07509594f, -0.15440239f, -0.08684289f, -0.01786650f, 
    0.14466347f, 0.06913885f, -0.01656449f, 0.01640456f, 0.17530161f, 0.28878477f, 0.23483367f, 0.17500423f, 
    0.21602403f, 0.00489741f, 0.09937873f, -0.07518407f, -0.01329743f, 0.05651709f, 0.04432141f, 0.09543879f, 
    -0.37212786f, 0.33961278f, 0.02611966f, 0.18588579f, 0.22653216f, 0.07836213f, -0.02057492f, -0.06766099f, 
    0.15431440f, -0.02628340f, -0.08583888f, -0.03942997f, 0.45766208f, -0.03102448f, -0.00204866f, -0.22122817f, 
    -0.14219111f, -0.06323415f, -0.00037587f, 0.18159673f, -0.02144354f, -0.05463639f, 0.07885714f, 0.07406861f, 
    0.64207208f, 0.34309036f, 0.13864157f, -0.08601238f, 0.07239836f, 0.06866375f, 0.08780436f, 0.07781526f, 
    -0.24620038f, 0.04651570f, -0.13091244f, 0.02306640f, -0.38513267f, -0.28125969f, 0.17266759f, -0.00094017f, 
    -0.10584813f, -0.02483563f, -0.12216552f, -0.05277025f, 0.04379509f, -0.13659675f, -0.11695068f, 0.06081054f, 
    0.15202019f, -0.08021907f, 0.06866314f, -0.29303962f, 0.10735302f, -0.00186048f, 0.07168218f, 0.08484040f, 
    0.10955559f, -0.03350395f, 0.15099058f, 0.14416239f, 0.01434669f, 0.29673898f, 0.44825229f, -0.01317284f, 
    -0.06654419f, 0.07725567f, 0.05719567f, 0.31376371f, -0.14121683f, -0.14079159f, 0.00097766f, 0.04524862f, 
    -0.16048047f, 0.15342540f, -0.04252609f, -0.09699579f, -0.04999376f, -0.24872291f, -0.07646354f, 0.05682739f, 
    0.10086738f, -0.04304146f, -0.09819431f, 0.00974576f, -0.02471826f, 0.01340707f, -0.20102422f, 0.08965327f, 
    0.19727662f, 0.14921971f, -0.06293907f, 0.13536994f, 0.08813856f, 0.03960189f, 0.02517964f, 0.04240601f, 
    -0.48780683f, -0.36062315f, -0.12311117f, 0.16887644f, 0.03760747f, -0.04244774f, 0.13779475f, 0.15796441f, 
    0.09619934f, 0.16077386f, 0.07315298f, 0.05117803f, -0.41207984f, 0.04294184f, -0.05729783f, -0.26864257f, 
    0.22584864f, 0.25199953f, -0.05380674f, -0.23353687f, 0.02166375f, 0.20548455f, -0.03767752f, -0.08392552f, 
    0.35475424f, -0.03584290f, -0.06178696f, -0.12741794f, -0.07315622f, 0.10657572f, -0.09496219f, -0.04860066f, 
    0.07420930f, -0.04441251f, -0.10585342f, 0.06845847f, -0.40114278f, -0.02553291f, -0.05530990f, -0.01767646f, 
    0.14068586f, 0.17250873f, 0.15495108f, -0.25064161f, 0.16634898f, 0.01563296f, 0.10880501f, -0.07021406f, 
    0.40576664f, -0.01801279f, -0.38267046f, -0.09864390f, 0.10256630f, -0.04359823f, 0.14928934f, 0.01729221f, 
    -0.02399436f, -0.13591072f, -0.03414781f, 0.13587852f, 0.03356313f, -0.08941591f, 0.10727157f, 0.20426640f, 
    -0.21392255f, -0.19797264f, 0.07591929f, 0.04884991f, 0.06417531f, 0.12134142f, 0.18549058f, -0.06555445f, 
    -0.50531673f, -0.03909601f, 0.03064243f, 0.33658519f, 0.02026618f, -0.28461987f, -0.28283939f, -0.04705729f, 
    0.02193974f, 0.04685402f, -0.11011305f, 0.19717796f, 0.14317811f, 0.17019047f, 0.26837751f, 0.11623390f, 
    -0.19613788f, -0.14722221f, 0.03324322f, -0.28004146f, 0.02380835f, 0.23016961f, 0.14232004f, -0.06702437f, 
    -0.03037685f, -0.12094063f, 0.04137320f, 0.17565468f, 0.17148398f, 0.14327441f, -0.25215745f, -0.25722578f, 
    0.00113710f, -0.11157960f, -0.00384278f, -0.19474033f, 0.59757864f, 0.16867387f, -0.10363866f, 0.22205177f, 
    0.09272167f, -0.20235042f, -0.19461867f, 0.19340253f, 0.10963225f, 0.02743779f, 0.18101987f, 0.07787593f, 
    0.15780409f, -0.46283650f, -0.10624116f, 0.10902611f, 0.06335771f, -0.00029656f, 0.05810304f, -0.16642693f, 
    -0.11239339f, 0.00808030f, 0.13200819f, 0.30551463f, 0.04260316f, -0.21266334f, -0.14221480f, -0.29262108f, 
    0.05107689f, -0.10249281f, -0.22159198f, -0.17421669f, -0.00673786f, 0.36373693f, -0.00676504f, 0.33569649f, 
    -0.10280396f, -0.20213734f, -0.06550889f, 0.26654100f, 0.26247633f, -0.09566710f, -0.02399201f, 0.02075281f, 
    -0.03260018f, 0.00234347f, 0.25765365f, 0.00319631f, -0.06430111f, 0.29168859f, 0.38659230f, -0.22794352f, 
    0.00388648f, 0.15644258f, -0.14919600f, 0.15175781f, 0.19161145f, -0.03440112f, 0.06833541f, -0.08626010f, 
    -0.24664453f, 0.15662451f, 0.01566572f, -0.21789981f, 0.07609750f, -0.07359806f, -0.00788452f, 0.09417842f, 
    0.06994486f, 0.17040163f, 0.26524055f, 0.29153794f, 0.28962308f, 0.06310596f, -0.16243581f, 0.15979736f, 
    0.13424486f, 0.14909476f, -0.03240498f, 0.08647698f, 0.28232056f, -0.16972241f, 0.11167973f, 0.03957762f, 
    -0.04991024f, 0.07591342f, -0.19547637f, -0.15636460f, -0.03378867f, 0.12117942f, 0.17019044f, 0.10932182f, 
    -0.04866998f, -0.03033778f, 0.01035875f, 0.05473668f, -0.11145904f, 0.22870341f, -0.07433327f, -0.10251472f, 
    0.14075764f, 0.09687197f, 0.09915520f, -0.15947370f, 0.01211740f, 0.05321230f, -0.02932157f, -0.09491923f, 
    0.16862501f, -0.38905782f, 0.10797588f, 0.18487872f, 0.09523764f, -0.18659043f, -0.04580058f, -0.08798183f, 
    0.09437422f, 0.00298375f, -0.16431022f, -0.03761120f, -0.27466154f, 0.51077592f, 0.28144246f, -0.05502608f, 
    0.22609352f, 0.14112628f, 0.10414717f, -0.26167753f, 0.12345313f, -0.13041769f, -0.04552837f, -0.11233787f, 
    0.10238376f, 0.04955156f, -0.09503102f, -0.03637571f, 0.07095835f, 0.01143106f, -0.01711622f, -0.05779483f, 
    -0.18497190f, 0.01694082f, 0.19721374f, 0.17982566f, 0.38663149f, -0.11265538f, -0.20026706f, 0.01155064f, 
    -0.06952445f, -0.05903606f, 0.14692864f, -0.00518723f, 0.01327999f, -0.05738508f, 0.02665236f, 0.03347145f, 
    0.18279374f, -0.18116988f, -0.27564365f, -0.45800751f, 0.20920335f, 0.04228068f, 0.14169234f, 0.11506554f, 
    0.06735709f, -0.13304326f, 0.06744058f, 0.05810912f, 0.16172713f, 0.12393850f, -0.15854006f, 0.08244218f, 
    -0.10965754f, -0.05028497f, 0.08176897f, -0.06614178f, 0.10149740f, 0.15740402f, 0.09535617f, 0.00912102f, 
    1.00450933f, -0.00387901f, 0.23013742f, 0.56447726f, -0.02647997f, -0.17674424f, 0.11781299f, 0.08752747f, 
    -0.05744676f, 0.10992031f, 0.04560106f, 0.01425565f, -0.53180999f, -0.52606618f, -0.35867313f, -0.11621124f, 
    -0.17556784f, -0.04407230f, 0.00111724f, -0.08975133f, 0.02900031f, 0.03934329f, -0.05869450f, -0.06388985f, 
    0.33537945f, 0.05185086f, 0.12062347f, 0.47094488f, -0.04636898f, 0.16351189f, 0.04516699f, 0.12909216f, 
    0.10419799f, -0.15119478f, 0.06015280f, -0.25281802f, -0.21161863f, -0.14432541f, 0.26955065f, 0.08344650f, 
    -0.27480984f, 0.02396271f, 0.06540677f, -0.04446335f, 0.04173846f, 0.04391393f, -0.00993112f, -0.10441624f, 
    -0.36901391f, 0.07423828f, 0.22252855f, 0.42672345f, -0.12711006f, 0.13299116f, -0.02886532f, -0.08652691f, 
    0.04519267f, -0.19066148f, -0.16623962f, -0.16015619f, 0.48843822f, 0.20560560f, -0.59715360f, 0.18268664f, 
    -0.23055229f, 0.03956732f, -0.03204178f, 0.16975646f, -0.01614012f, 0.12322944f, 0.09645665f, 0.02761540f, 
    0.06980448f, -0.32353190f, 0.25149503f, -0.04342304f, -0.05446437f, -0.25528571f, 0.10062284f, -0.12830722f, 
    -0.18541116f, -0.01778602f, -0.16066535f, -0.14599413f, 0.02286308f, 0.29632232f, 0.43019539f, 0.15755026f, 
    -0.13422437f, 0.24089240f, 0.04676860f, 0.24944955f, 0.13184758f, -0.05576204f, 0.14324318f, 0.05992944f, 
    0.05368648f, 0.17573957f, 0.12600721f, 0.23214941f, -0.03879166f, 0.08607958f, -0.05415040f, -0.09893199f, 
    -0.03656643f, 0.04252196f, 0.02738196f, 0.03829136f, -0.33440444f, 0.18818402f, 0.07450754f, 0.20461120f, 
    0.10911079f, 0.00509002f, -0.14532673f, 0.01665566f, -0.12270420f, 0.22281472f, -0.01207785f, -0.00869404f, 
    0.22704640f, -0.18962368f, -0.26762831f, 0.35428128f, -0.07109018f, 0.10025582f, 0.09399000f, 0.08274119f, 
    0.09876933f, 0.20531936f, 0.08416218f, -0.04538140f, -0.20886818f, 0.06470936f, 0.01788040f, 0.00986669f, 
    0.17428315f, -0.06066175f, 0.12486852f, 0.09245425f, 0.05419054f, 0.00195373f, 0.09415082f, 0.14672218f, 
    0.06686350f, 0.00639849f, 0.02306404f, 0.00716187f, -0.00576955f, -0.00766056f, -0.00103499f, 0.01695845f, 
    0.01662472f, -0.07524879f, -0.01099537f, -0.06179702f, 0.01524891f, 0.03702870f, -0.03363406f, 0.01334238f, 
    0.00926200f, -0.04045722f, 0.01889609f, 0.00610735f, 0.02293735f, -0.05536200f, -0.00018042f, -0.05469536f, 
    -0.04711933f, 0.03952944f, 0.00313600f, -0.05285416f, 0.02573283f, -0.04060060f, 0.04124976f, 0.03886503f, 
    -0.01464721f, -0.03532138f, -0.02248951f, 0.05475983f, 0.03427130f, -0.03233337f, 0.05979939f, 0.02218963f, 
    0.01341480f, -0.02239200f, -0.05938207f, -0.00819705f, -0.02394110f, 0.00437896f, -0.04704714f, 0.00471616f, 
    0.06927342f, -0.02081284f, 0.02663100f, -0.03646710f, -0.04988225f, -0.04112551f, 0.02453711f, 0.00116398f, 
    -0.01954999f, -0.07507928f, 0.04960212f, 0.05266327f, -0.02045074f, 0.03451659f, -0.01275892f, 0.01448427f, 
    0.03117729f, 0.03451536f, 0.00106447f, -0.01878279f, -0.02537343f, 0.03621356f, 0.04710120f, -0.04410220f, 
    0.05343981f, -0.07349092f, 0.04951750f, -0.05716063f, -0.00067117f, -0.05915927f, -0.01843297f, -0.02832020f, 
    0.04261362f, -0.05937961f, 0.04054759f, -0.03066236f, -0.01697704f, 0.04701350f, -0.06755368f, -0.01558597f, 
    0.01217946f, 0.02222134f, -0.05823339f, 0.00563652f, 0.02268777f, 0.03462224f, -0.07120889f, 0.06220390f, 
    0.06725593f, -0.03514562f, 0.06664762f, -0.07182923f, -0.07014535f, -0.04268973f, 0.00391883f, -0.01556092f, 
    -0.05297225f, 0.04120829f, -0.05872183f, 0.02466906f, -0.03451733f, 0.02949875f, 0.05704932f, 0.06270551f, 
    -0.01734380f, -0.01063187f, -0.04564598f, -0.06457032f, -0.01968074f, -0.01667711f, -0.03833224f, -0.04941120f, 
    0.00495973f, 0.00519005f, 0.02367205f, -0.03534281f, 0.05288680f, -0.05248795f, -0.05398452f, -0.03726242f, 
    0.06537636f, -0.02522765f, -0.04655718f, -0.00449773f, 0.04051429f, -0.02889053f, -0.02671224f, -0.06473391f, 
    0.03289927f, -0.03420293f, 0.04759528f, -0.06533235f, 0.00925814f, 0.00754975f, 0.04805028f, 0.00619579f, 
    -0.03771203f, 0.06101628f, 0.06872057f, -0.05750175f, -0.06977313f, -0.04486457f, 0.02834813f, -0.05499035f, 
    0.01298738f, -0.05012968f, -0.07943583f, -0.05444285f, -0.05504566f, 0.06068766f, -0.02984986f, 0.02872059f, 
    0.03035837f, -0.02016296f, -0.04125168f, -0.06278427f, 0.05126779f, -0.04398252f, 0.02413977f, -0.00482913f, 
    -0.05978700f, 0.03361031f, -0.06301346f, -0.03053850f, 0.07601529f, -0.06079888f, -0.02388072f, 0.00482201f, 
    -0.03254125f, -0.03889691f, 0.06037608f, -0.04572728f, 0.03392333f, -0.06644815f, -0.02228571f, -0.06183164f, 
    0.05220374f, 0.00061354f, -0.03942319f, -0.01046926f, -0.01751048f, -0.08262042f, -0.03172051f, -0.06052826f, 
    0.01082549f, -0.05010477f, -0.00043535f, -0.06349562f, 0.05093871f, -0.06020531f, 0.06223629f, -0.02767986f, 
    0.02432482f, 0.04788964f, -0.00968638f, 0.03393525f, -0.00146063f, 0.01542898f, -0.00071255f, 0.02507070f, 
    -0.02361105f, -0.02176606f, -0.02639092f, 0.05313592f, -0.05018016f, -0.07222886f, -0.00795283f, 0.04322824f, 
    -0.04543373f, 0.01763456f, -0.02477879f, 0.05387862f, 0.02581022f, -0.02043022f, -0.07475545f, -0.05375826f, 
    0.01730748f, -0.00954347f, 0.00797147f, -0.02468053f, 0.04083493f, 0.04327564f, -0.01850360f, 0.00078880f, 
    -0.07393795f, -0.06428041f, 0.02646661f, -0.00910352f, 0.02552969f, 0.05129035f, 0.01220331f, -0.02876380f, 
    0.03292426f, -0.01309911f, -0.03163832f, -0.00250780f, 0.00695921f, -0.06485629f, -0.04193438f, 0.01025244f, 
    0.04956533f, 0.04562285f, 0.05402836f, -0.06973511f, -0.00861988f, -0.06163217f, 0.00395063f, 0.03706028f, 
    0.05420071f, -0.07501808f, -0.03483443f, -0.07315006f, 0.00809377f, -0.01097722f, -0.01562335f, -0.06683057f, 
    -0.06684358f, -0.04157244f, 0.00233847f, 0.00838818f, 0.03288349f, -0.01754359f, -0.07000276f, 0.02318973f, 
    0.06247821f, -0.01087411f, -0.04114436f, 0.02549805f, -0.03232820f, 0.02406192f, 0.05881307f, 0.03874541f, 
    0.03226047f, 0.02606248f, -0.06037335f, 0.05185471f, 0.03386896f, 0.03226933f, -0.00647594f, -0.04539355f, 
    0.02797632f, 0.00995542f, 0.00716981f, -0.00943711f, 0.06440578f, -0.05653328f, -0.02530400f, -0.00122235f, 
    -0.03879195f, 0.05155932f, -0.02115042f, 0.03028779f, 0.05840836f, -0.01703415f, 0.04008239f, -0.02623310f, 
    -0.05208644f, -0.04921941f, -0.03818714f, -0.03786927f, -0.06400740f, -0.00220965f, -0.02181904f, -0.07349977f, 
    -0.03610465f, -0.07031823f, -0.04714110f, -0.03210621f, -0.07207491f, -0.03632639f, 0.01079994f, -0.04789541f, 
    -0.03937320f, 0.01688526f, -0.04294667f, -0.00529287f, 0.06675636f, 0.02854806f, -0.04044903f, 0.02400684f, 
    -0.02680458f, -0.04559918f, -0.04449507f, 0.04165880f, -0.03092216f, -0.02794845f, -0.02655078f, -0.02586243f, 
    -0.01585541f, 0.00356884f, -0.04105475f, 0.03794393f, 0.05297712f, -0.04937273f, -0.02193212f, -0.06990772f, 
    -0.04924237f, -0.05317411f, 0.02175532f, -0.02887944f, 0.03216079f, -0.04299916f, -0.01868466f, 0.05600278f, 
    -0.02928453f, -0.00763681f, 0.03388896f, -0.07232880f, 0.01908567f, -0.04315669f, -0.01941436f, 0.05676873f, 
    0.01018153f, -0.00549799f, 0.01458803f, -0.05636889f, 0.06473752f, -0.03612630f, -0.01423654f, -0.00843111f, 
    -0.04206063f, 0.02686133f, 0.03932359f, 0.05692939f, -0.03117251f, -0.04188666f, 0.00130184f, -0.05896404f, 
    -0.03034020f, -0.02002861f, -0.03045263f, -0.06108190f, -0.00900547f, -0.03153982f, 0.00162359f, 0.02461353f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06439567f, 0.16628049f, 0.07389364f, 0.06186756f, 0.02694802f, 0.02519478f, -0.02894198f, 0.10007194f, 
    -0.11419590f, 0.02887741f, -0.06516863f, -0.01474332f, 0.17490187f, 0.04951907f, -0.04013712f, -0.01766245f, 
    0.05009550f, -0.03619242f, 0.05650620f, -0.05521760f, 0.20985585f, 0.11350969f, -0.06083297f, 0.12917103f, 
    0.07616080f, 0.03048354f, -0.03774776f, -0.11624600f, -0.05964702f, -0.18823612f, 0.01891293f, -0.07591437f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.14315762f, 0.17450215f, 0.02503092f, 0.09947123f, 0.01536164f, 0.32083058f, 0.15105565f, -0.61609298f, 
    0.15530498f, -0.01766626f, -0.15487403f, 0.15389284f, -0.36864567f, -0.18208219f, 0.55827051f, 0.28201091f, 
    0.08235843f, -0.03569577f, 0.10475735f, 0.36960804f, -0.28715095f, -0.77471060f, 0.01096858f, -0.69766003f, 
    0.04720647f, 0.00321613f, 0.14164835f, -0.01286555f, 0.04311177f, -0.20106776f, -0.06744234f, 0.04407351f, 
    0.02333435f, 0.01725374f, 0.11236824f, 0.13324881f, 0.26983574f, -0.45484507f, 0.07439315f, 0.33395904f, 
    -0.40703103f, 0.08735629f, 0.11162169f, 0.31038752f, -0.21139222f, -0.05123109f, 0.25434947f, -0.61569464f, 
    0.11951790f, 0.14961870f, -0.12163208f, -0.98202521f, 0.47110486f, -0.57839406f, -0.02830002f, 0.04225876f, 
    0.22362755f, 0.09309604f, -0.08708713f, 0.06166774f, -0.00215648f, 0.36327055f, -0.10206454f, 0.04484568f, 
    -0.06801976f, 0.07586714f, -0.33396164f, -0.54164356f, 0.47460508f, -0.25481385f, 0.13406867f, -0.20008677f, 
    0.55516052f, 0.13233507f, 0.08163429f, -0.06497280f, 0.28321141f, -0.13796058f, 0.32516482f, -0.51070976f, 
    0.16239898f, -0.04051865f, -0.10598627f, 0.06135676f, 0.13190113f, 0.11709122f, 0.04433567f, -0.64897710f, 
    0.08999407f, 0.49842328f, -0.00700421f, -0.48470795f, -0.70081538f, -0.05635403f, -0.17231828f, 0.05682172f, 
    -0.09778457f, -0.11929660f, 0.18761441f, 0.11356688f, -0.96004373f, 0.35667673f, 0.01787218f, -0.07382168f, 
    0.41100439f, 0.12954016f, -0.02332100f, -1.21709585f, 0.40444872f, -0.14799270f, -0.49670818f, -0.06505863f, 
    -0.11131954f, -0.05592728f, 0.10533061f, -0.05617758f, -0.51938206f, -0.17834149f, -0.15002581f, -0.70708287f, 
    0.29466742f, 0.15208566f, -0.01488156f, -0.49664524f, 0.16592239f, 0.08011511f, 0.08427713f, 0.06900810f, 
    -0.11599497f, -0.10408525f, -0.24714798f, 0.45789322f, -0.46637124f, -0.00483578f, -0.16916445f, -0.95142025f, 
    0.25094083f, -0.10906279f, -0.07626111f, -0.33237472f, -0.23148714f, 0.10639412f, 0.15261571f, 0.02982724f, 
    -0.00269505f, -0.05336479f, 0.13436386f, 0.39086944f, 0.18098737f, 0.26633778f, -0.08442049f, 0.24795805f, 
    -0.27002880f, -0.29532966f, -0.09489439f, -0.20175232f, -0.40969467f, 0.38945529f, 0.14457266f, 0.13224766f, 
    -0.02001821f, 0.42061487f, 0.04424102f, 0.09779117f, -0.48872408f, -0.34700462f, 0.17566891f, -0.00874796f, 
    -0.36591038f, -0.13952649f, -0.10559024f, -0.02224386f, -0.39527169f, -0.15093240f, 0.24080230f, 0.52783555f, 
    0.03163351f, -0.08121553f, 0.12148657f, -0.45727986f, -0.50605303f, 0.26364797f, -0.10062180f, 0.28575841f, 
    0.34831962f, -0.63136828f, 0.04287874f, 0.35856864f, 0.27284038f, -0.16428472f, 0.07643472f, -0.09399447f, 
    0.01268043f, 0.15724398f, 0.16952956f, -0.18285507f, 0.22403166f, 0.16540313f, 0.15243916f, 0.05524059f, 
    -1.24972868f, 0.12580696f, -0.03287655f, 0.29978210f, 0.45818311f, 0.12474457f, -0.39040852f, -0.35530886f, 
    0.10210387f, 0.02870708f, 0.12797640f, 0.37857541f, -0.04254092f, 0.17737590f, -0.11860425f, -0.00201536f, 
    0.14673091f, -0.75629133f, 0.10118064f, -0.15965346f, -0.92035627f, -0.05787495f, -0.05217369f, -0.00800146f, 
    -0.08643372f, -0.67462856f, -0.01313953f, 0.14795624f, 0.22542374f, 0.17843123f, -0.14550442f, 0.18434857f, 
    -0.14651865f, -0.08908812f, 0.11038225f, -0.33145770f, -0.81316483f, -0.06959620f, -0.63459140f, 0.00843549f, 
    0.03332561f, -0.11050098f, -0.06481957f, 0.41896430f, -0.46062762f, 0.42191732f, -0.12419023f, -0.48077190f, 
    -0.55907404f, -0.02362671f, -0.02776607f, -0.11442744f, 0.21975517f, 0.22635400f, -0.06087513f, 0.01057074f, 
    0.10014259f, 0.15524694f, -0.80994314f, -0.64013475f, 0.24687709f, -0.41129398f, 0.08017021f, 0.01760021f, 
    0.06397174f, -0.18302378f, 0.09203525f, -0.26580951f, -0.34268123f, -0.17158073f, -0.33182436f, 0.48543373f, 
    -0.04422078f, 0.05005816f, 0.12830622f, 0.33526036f, 0.34152263f, -0.12658662f, -0.07043347f, 0.33849120f, 
    0.29327986f, 0.09909818f, -0.00500755f, 0.01567758f, 0.43858629f, 0.37865150f, 0.13922429f, 0.09495796f, 
    0.02953755f, -0.30417514f, -0.11708579f, 0.06373519f, 0.50357813f, -0.01601167f, -0.18014407f, -0.06869969f, 
    0.51174885f, -0.13485198f, 0.02487830f, 0.08510586f, 0.28463525f, 0.01101275f, -0.44815156f, -0.55676526f, 
    -0.04415840f, 0.13828556f, 0.04204482f, -0.14415652f, -0.63939482f, 0.16068445f, -0.01190717f, 0.43532452f, 
    -0.61060905f, -0.30303517f, 0.03773140f, 0.46169102f, -0.05560426f, -0.27970663f, 0.12449760f, -0.03039383f, 
    -0.01779827f, 0.17933589f, -0.58563381f, 0.24981050f, 0.19289318f, 0.02695597f, -0.12485605f, 0.53550887f, 
    -0.39956212f, -0.12230630f, -0.00894669f, -0.26230288f, 0.06907488f, 0.12996492f, -0.56017494f, -0.11024392f, 
    -0.04453647f, -0.02651169f, -0.00582611f, -0.59138930f, 0.32121408f, 0.23662785f, -0.11827597f, 0.09862380f, 
    -0.02395475f, 0.33855471f, -0.06856150f, -0.88594711f, 0.22182091f, -1.09077275f, -0.07531471f, 0.11323881f, 
    0.12868799f, 0.25242254f, 0.58825886f, -0.43058234f, -0.68477654f, 0.03213459f, -0.09580722f, -0.11130393f, 
    -0.40643856f, 0.01366406f, -0.13486004f, -0.90970165f, 0.11451954f, -0.05194160f, 0.05900448f, 0.26820469f, 
    0.01623859f, 0.14731938f, -0.04855365f, 0.05116788f, 0.42800856f, 0.29267895f, 0.02025897f, 0.25913063f, 
    -0.66607410f, 0.21629748f, -0.01141422f, 0.15508759f, 0.05083236f, -0.59155798f, 0.02447468f, -0.12999663f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.19558609f, -0.10465945f, -0.16119710f, 0.12541409f, -0.03340454f, 0.03075810f, 0.16740704f, -0.13398623f, 
    -0.23316151f, -0.18365462f, 0.30210921f, -0.01495821f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
