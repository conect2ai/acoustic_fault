#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.06966472f, 0.51582950f, -0.43482003f, -0.11826625f, -0.11522175f, -0.53039438f, 1.13627076f, -0.89138740f, 
    -0.53261149f, -1.10225320f, 0.08497080f, 0.16712077f, -0.13656846f, -0.24984802f, -0.03327981f, 0.18498795f, 
    -0.03556946f, -0.12122519f, 0.40645477f, -0.16781950f, -0.22103435f, 0.11573680f, 0.26905736f, -0.17565542f, 
    0.01037567f, 0.21659951f, -0.06148320f, -0.08007979f, 0.57165229f, -0.61635637f, 0.51335436f, -0.01731871f, 
    -0.44661281f, -0.42595524f, 0.10735881f, 0.30054399f, 0.03619374f, 0.19046970f, -0.46235621f, 0.24445269f, 
    -0.01127707f, 0.26566979f, -0.09003887f, -0.31015551f, -0.09164228f, 0.37760267f, 0.11012437f, -0.13113719f, 
    -0.10850325f, -0.00464626f, 0.14161548f, -0.05117159f, -0.38724893f, -0.33497995f, -0.05476474f, 0.19516949f, 
    0.07689814f, -0.16777821f, 0.19691257f, 0.31646720f, -0.06873220f, -0.34228995f, 0.22967385f, 0.04736561f, 
    0.13297807f, -0.07511774f, -0.14985828f, 0.16351138f, -0.31810862f, -0.56479841f, 0.13218550f, 0.24257116f, 
    0.35860932f, 0.36174053f, 0.39831349f, -1.35880697f, 0.03446869f, 0.20269728f, 0.47982252f, 0.18682306f, 
    0.68326944f, -0.03852583f, -0.27216810f, 0.04692465f, 0.02458897f, -0.29196543f, 0.11481373f, -0.51045930f, 
    0.36442900f, -0.14843237f, 0.35913777f, 0.12763301f, 0.16563202f, -0.32225356f, -0.04661129f, 0.04401193f, 
    -0.23480159f, 0.11881610f, -0.02240716f, 0.06112949f, -1.24150825f, 0.09135611f, -0.70440722f, -1.10561144f, 
    -0.48441657f, 0.11878662f, 0.23108421f, -0.15631522f, -0.32854271f, -0.10982894f, -0.04554525f, -0.20192106f, 
    -0.33798036f, -0.45808583f, 0.18689026f, 0.07642277f, -0.07854125f, -0.23944719f, 0.00823818f, -0.14323564f, 
    0.17870177f, -0.25073421f, -0.23375227f, -0.31861380f, -0.58035308f, -0.92187881f, -0.78661638f, -0.71712393f, 
    -0.50266010f, -0.19856323f, 0.64954424f, -0.00698010f, 0.32797176f, 0.26729184f, 0.71860009f, 0.33960047f, 
    -0.09998868f, 0.07865186f, -0.16914707f, 0.19112085f, 0.04053476f, 0.09407144f, 0.02168300f, -0.09072776f, 
    -0.14406379f, 0.01236129f, 0.17269880f, -0.01627820f, -0.01301261f, 0.11641590f, -1.63198900f, 0.19308467f, 
    0.73423231f, 0.23105517f, 0.30654559f, -0.98058844f, -0.63571590f, 0.45569819f, 0.09946953f, -0.03873855f, 
    -0.04897665f, 0.36083221f, -0.31429887f, 0.47558245f, -0.01887957f, 0.05440682f, -0.04377087f, 0.16069019f, 
    -0.31398377f, -0.35925967f, 0.19527148f, 0.00248942f, 0.26649356f, -0.04979039f, -0.28393239f, -0.90598297f, 
    -0.63681525f, -0.36140576f, -1.07260692f, -1.08343041f, 1.06843412f, 0.25488400f, -0.29599229f, 0.06508563f, 
    0.21832485f, -0.28615853f, -0.12119202f, 0.14220627f, -0.15351786f, -0.33431134f, 0.17448017f, 0.04843336f, 
    0.18350458f, 0.08142246f, 0.00076258f, 0.05218691f, 0.30578953f, 0.28497913f, 0.12004160f, -0.18037345f, 
    0.11099791f, -0.44784081f, -0.17344378f, 0.27244824f, 0.76945418f, -0.96958506f, -0.72920275f, 0.15146655f, 
    -0.67575604f, -0.41065976f, 0.05352394f, -0.16363941f, 0.49333367f, 0.33713409f, 0.08168534f, 0.14676392f, 
    0.05589376f, -0.44939226f, 0.09043344f, -0.15874028f, 0.00254279f, -0.19169147f, -0.10256041f, 0.32497439f, 
    -0.24797803f, 0.20966958f, -0.27877876f, -0.49723366f, -0.48838985f, -0.59803551f, -0.05396149f, -0.11653986f, 
    -0.06418924f, -0.30456901f, -0.15559846f, 0.27040043f, 0.68905932f, 0.33893669f, 0.28957230f, 0.21904643f, 
    -0.13557932f, -0.32981968f, 0.18948066f, 0.00188607f, 0.09952754f, -0.05635919f, -0.38069394f, 0.04016485f, 
    0.04268637f, -0.28983027f, -1.18032646f, -0.38868594f, -0.46911317f, -0.35296789f, -0.56447482f, 0.36606273f, 
    0.56544256f, 0.12079005f, 0.27831423f, 0.82102692f, 0.09635767f, 0.25336897f, -0.17618309f, -0.05960255f, 
    -0.35205695f, -0.38275656f, 0.26078242f, -0.26621300f, -0.07875021f, -0.21875018f, -0.16141656f, -0.19988325f, 
    -0.05734031f, -0.13109973f, 0.08900627f, -0.29193452f, 0.10394591f, 0.12751584f, 0.33101085f, 0.00694018f, 
    0.20459001f, 0.12185922f, -0.04585026f, -0.12600692f, -0.16572702f, 0.02523709f, 0.48508760f, -0.04501943f, 
    -0.13814826f, -0.11612506f, 0.05978339f, -0.04348990f, 0.27625948f, -0.33167553f, 0.24884588f, -0.12912264f, 
    0.29554546f, 0.36630955f, 0.17732497f, 0.03628675f, 0.73254335f, 0.53402877f, 0.37091854f, 0.31902891f, 
    -0.12847529f, -0.10642473f, 0.28112561f, -0.26453832f, -0.51885027f, -0.55020219f, 0.15074325f, -0.22420819f, 
    -0.02701387f, -0.35046417f, 0.04067992f, 0.14970160f, 0.20401719f, -0.12577884f, 0.06941737f, -0.25416687f, 
    0.05291986f, -0.16443196f, -0.21991448f, 0.03915884f, -0.05085854f, -0.19550754f, 0.04690238f, -0.08015388f, 
    0.44056332f, 0.11231656f, 0.09593212f, -0.50173694f, -0.61229378f, -0.09451085f, 0.62818074f, -0.58774120f, 
    0.23626919f, 0.12839252f, 0.15659781f, -0.19058177f, 0.18157892f, -0.20526871f, 0.52324700f, 0.66703105f, 
    -0.22545497f, 0.18415356f, 0.15741110f, -0.34075159f, -0.27378377f, -0.64987898f, -0.04432845f, -1.16960990f, 
    0.23088589f, 0.61402124f, 0.29968059f, 0.07267433f, -0.04163124f, -0.23250607f, 0.16218957f, -0.20695367f, 
    0.24912319f, -0.19292654f, -0.39317149f, 0.00511110f, 0.28740078f, -0.50236315f, -0.27325827f, -0.35625812f, 
    -0.08643592f, -0.13130410f, -0.34123632f, -0.40724188f, -0.58478874f, -0.30438641f, -0.47744161f, -0.64278424f, 
    0.26178068f, -0.07912236f, -0.08965901f, 0.52222782f, -0.65968335f, -0.28411582f, 0.34650362f, 0.82094008f, 
    0.58672738f, -0.38217896f, -0.40009215f, 0.00940893f, -0.32802203f, 0.29799542f, -0.07117325f, 0.32650936f, 
    0.14388871f, -0.10271060f, -0.19744363f, -0.45185730f, -0.01746639f, 0.07799050f, 0.20896772f, -0.11872424f, 
    -0.52553982f, -1.01956308f, -0.42464539f, 0.25209531f, -0.28656062f, 0.49612918f, 0.44245991f, -0.03794112f, 
    -0.10012856f, 0.74393219f, 0.18220541f, 0.27190581f, 0.11737919f, 0.12672205f, 0.19206162f, -0.14365146f, 
    -0.18738177f, -0.12622003f, -0.07700415f, 0.05907617f, -0.07963155f, -0.04166540f, 0.02026219f, 0.53981990f, 
    -0.37932432f, 0.73203731f, 0.58284914f, -0.41469568f, -0.62592703f, 0.03740824f, -0.08751406f, -0.00368899f, 
    0.06001778f, -0.22940746f, 0.08791353f, -0.30528519f, 0.22415520f, 0.38583234f, -0.59048545f, -0.27158239f, 
    0.00005606f, 0.21934929f, -0.00716050f, -0.01080891f, 0.02573668f, -0.12894122f, 0.01763240f, 0.10436614f, 
    0.16923891f, -0.01714507f, 1.48212171f, -0.04345750f, -0.21024935f, -0.36414498f, -1.26878285f, 0.83648711f, 
    0.39627537f, 0.07710420f, -0.31114173f, 0.06116660f, -0.03314986f, 0.00902187f, -0.45076498f, 0.12221184f, 
    0.15015619f, 0.04019565f, -0.08515814f, 0.12837884f, -0.12546425f, -0.12619516f, -0.22560252f, -0.28185174f, 
    -0.03314854f, 0.29620004f, 0.09247769f, -0.69884610f, -0.24804477f, 0.24878113f, 0.57158077f, 0.39452630f, 
    -0.30792886f, 0.50826061f, 0.27553377f, 0.04782707f, -0.08242179f, -0.09981234f, 0.13547319f, -0.29147252f, 
    0.09603908f, -0.03550225f, 0.04022690f, -0.23551118f, -0.19291793f, -0.00496454f, -0.03734957f, -0.01337975f, 
    -0.40112111f, 0.07866178f, 0.01917021f, 0.19171973f, 0.57155395f, 0.97401696f, 0.85990089f, -0.56432289f, 
    -0.93429250f, -0.85556161f, -0.44587860f, -0.29633600f, -0.17592472f, -0.24101481f, 0.00828118f, -0.02623623f, 
    0.51093262f, 0.14641955f, 0.35704353f, -0.09584784f, -0.06790741f, 0.33577541f, -0.05084962f, -0.00444245f, 
    -0.06316703f, 0.30510408f, -0.04121185f, 0.07066160f, -0.06019282f, -0.00991131f, -1.02832711f, -0.93843538f, 
    -0.67655963f, 0.55502546f, -0.82488418f, -0.68080080f, 0.45781192f, 0.16353503f, -0.30714056f, 0.31034914f, 
    0.08136815f, -0.06046218f, -0.24616191f, 0.07819432f, 0.04939329f, -0.20929487f, -0.42429510f, -0.27875203f, 
    -0.60294235f, -0.17490278f, 0.14594343f, 0.10009490f, -0.18083310f, 0.13200414f, -0.82896310f, 0.00470478f, 
    0.20776442f, 0.11854275f, -0.23983289f, -0.18780230f, -0.04707766f, -0.15285850f, 0.46315899f, 0.41595870f, 
    0.05819515f, -0.01856180f, -0.28292078f, -0.15372741f, -0.05381161f, 0.20533264f, -0.13589565f, -0.29280367f, 
    0.13167658f, -0.17357898f, -0.17440975f, -0.27626261f, -0.21739073f, -0.47075823f, -0.44753808f, 0.15663962f, 
    0.96625906f, 0.44104508f, -0.31873107f, -0.09724261f, -0.99468672f, -0.41235080f, -0.45530373f, -0.06542624f, 
    0.35070264f, -0.19023822f, -0.45912465f, -0.26521814f, 0.03003358f, -0.05786336f, 0.24096866f, 0.33537707f, 
    -0.00786631f, 0.05210225f, -0.13608627f, 0.08381265f, 0.12996840f, 0.11342378f, 0.12184849f, 0.09887151f, 
    -0.26887101f, -0.64896840f, -0.13474135f, -0.43759954f, -0.42147392f, -0.94179660f, -0.73573655f, -0.74839884f, 
    -0.75509453f, -0.79574317f, 0.82802528f, -0.42694119f, 0.45024458f, 0.35153249f, 0.24567354f, -0.14435121f, 
    -0.26667249f, -0.02136925f, 0.01420800f, -0.22594401f, -0.11616573f, 0.25459859f, 0.14749971f, 0.03566762f, 
    0.33331373f, -0.44184324f, -1.06477261f, -0.54592812f, -0.08559541f, -0.41746023f, -0.86615956f, -0.53781855f, 
    -0.29630315f, -0.58152640f, -0.97072583f, -0.05483652f, -0.51699984f, -0.31157643f, 0.20985256f, -0.29093060f, 
    -0.18601407f, -0.13850248f, 0.14149137f, -0.21923316f, 0.28814116f, 0.02441638f, -0.19934162f, -0.36741972f, 
    0.06690890f, 0.08525842f, -0.13863714f, 0.14914262f, 0.24533281f, 0.02952511f, -0.10948821f, -0.49149874f, 
    0.16107324f, -0.01634761f, 0.06336799f, -0.03399284f, 0.24557738f, 0.31160608f, 0.14258112f, -0.53710049f, 
    -0.00707832f, 0.26446968f, -0.27304882f, 0.14353813f, -0.03741965f, -0.37002590f, -0.39502698f, 0.51304030f, 
    0.40137526f, -0.19591084f, 0.20398948f, 0.83633798f, -0.72503209f, -0.26563954f, 0.27201089f, 0.22328888f, 
    0.54167587f, 0.09052912f, 0.62900853f, -0.75626320f, -0.60633332f, -0.40510035f, -0.05287419f, -0.03525731f, 
    -0.09957928f, -0.19808942f, 0.17359459f, -0.15837364f, 0.33770573f, 0.18801914f, -0.18919095f, 0.13464417f, 
    -0.00232956f, -0.18970425f, -0.01787652f, -0.06177916f, 0.46439022f, 0.23053084f, 0.48531479f, 0.17295890f, 
    -0.32034516f, -0.47249702f, 0.21297479f, 0.52575767f, 0.03719877f, -0.27752483f, 0.25590292f, -0.06083754f, 
    -0.09353191f, 0.18252867f, -0.07531957f, -0.37872893f, -0.28774655f, 0.10404217f, -0.06692650f, -0.22121564f, 
    0.21616599f, 0.08821391f, 0.10715696f, -0.23801526f, -0.20836112f, 0.19693430f, 0.23849228f, 0.42971358f, 
    0.45513946f, 0.14124458f, -0.25881132f, -0.39413288f, -0.14452006f, -0.40599331f, -0.05616146f, -0.09536728f, 
    -0.36729193f, -0.17522955f, 0.16898595f, 0.43813094f, 0.49747360f, 0.31417277f, 0.09317930f, 0.10045045f, 
    -0.49782121f, 0.06730371f, -0.25020477f, -0.22402582f, -0.22272593f, -0.50213355f, -0.02673173f, 0.38748729f, 
    -0.24254049f, 0.33775806f, 0.06512003f, 0.21530707f, 0.03856972f, 0.06337908f, 0.12020634f, 0.01916009f, 
    0.53246301f, -0.38370353f, 0.10439206f, 0.12611926f, 0.15711215f, 0.08615381f, -0.07110190f, -0.00560223f, 
    -0.05646804f, -0.08584230f, 0.14450471f, 0.04184918f, 0.13090046f, 0.17925787f, -0.05599754f, -0.17705253f, 
    -0.62487382f, 0.20395555f, 0.12683369f, 0.30856669f, -0.53727430f, -0.06444219f, 0.36460990f, -0.21145140f, 
    0.55482727f, -0.21634984f, 0.11471953f, -0.01413294f, 0.26991260f, -0.21685986f, -0.00993041f, -0.22598994f, 
    -0.35446468f, 0.00062329f, 0.64304340f, -0.26767081f, -0.14570278f, 0.06450167f, -0.12099384f, 0.41867155f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.44582316f, 0.34474781f, -0.13386618f, 0.33766341f, -0.08240933f, 0.34626082f, 0.28998715f, -0.18792228f, 
    0.18666515f, 0.14778931f, 0.24063265f, 0.05272556f, 0.21633410f, 0.10073347f, 0.10959604f, 0.37746948f, 
    0.21578296f, 0.45118201f, 0.33997014f, 0.61492187f, 0.23474030f, 0.38397861f, 0.03172626f, 0.31066298f, 
    0.12336711f, -0.46708325f, 0.21148491f, -0.01186868f, 0.42664331f, 0.05131511f, 0.05969868f, 0.40562642f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.25064778f, -0.20773804f, -0.44327745f, 0.05420857f, 0.09561660f, -0.14275751f, 0.05480511f, 0.00277568f, 
    -0.04162058f, 0.09796135f, -0.04442346f, -0.00134334f, -0.05600474f, -0.17509575f, -0.39415887f, -0.07493768f, 
    -0.31022716f, 0.02000453f, -0.04092480f, -0.16272657f, -0.15986609f, -0.11130808f, -0.06708048f, -0.18738604f, 
    0.00275040f, 0.01685752f, 0.00412908f, 0.08837834f, 0.02213294f, 0.01120521f, -0.03654082f, -0.04538636f, 
    -0.14031035f, -0.25825408f, -0.04171782f, -0.08951974f, 0.38987523f, 0.01189997f, -0.08354318f, -0.45817319f, 
    -0.36066261f, -0.16198891f, 0.05311720f, 0.03778505f, -0.13011402f, 0.00599696f, -0.13624668f, -0.12725100f, 
    0.26697415f, 0.21891980f, -0.08975247f, -0.04418545f, 0.05324492f, 0.37280273f, 0.01996277f, 0.06358909f, 
    -0.15609199f, -0.05709819f, 0.04888561f, 0.03990427f, 0.25339445f, 0.03345554f, 0.10151238f, -0.04303429f, 
    0.13945882f, 0.19957893f, 0.06415351f, -0.26786357f, 0.00626425f, -0.01425894f, -0.06240183f, 0.02374276f, 
    -0.04520852f, 0.28923953f, 0.55737001f, -0.39080876f, -0.26363680f, 0.00343503f, -0.09905598f, 0.10524406f, 
    -0.01264872f, -0.08629104f, -0.37194562f, -0.00228785f, 0.38219494f, -0.05784617f, -0.29224825f, -0.10678206f, 
    0.01743375f, 0.31079179f, -0.03833824f, 0.06017432f, 0.03368628f, 0.05848296f, -0.01192368f, 0.06979067f, 
    0.27439147f, 0.27298003f, 0.16741431f, -0.16508041f, 0.05346099f, -0.02031215f, -0.11468185f, 0.01934725f, 
    -0.01990923f, 0.06191077f, -0.04642847f, -0.05706950f, 0.34993157f, 0.03808977f, -0.10055614f, 0.05491475f, 
    0.03146796f, 0.02372376f, -0.17461240f, -0.00740373f, 0.10919037f, -0.00427299f, 0.01407823f, 0.08358983f, 
    0.08070295f, 0.00905460f, -0.03064892f, 0.00593000f, 0.15598926f, 0.15007259f, 0.06362382f, -0.02580374f, 
    -0.09072024f, 0.07782255f, -0.00250218f, -0.16724333f, 0.00685773f, -0.03187513f, -0.00662143f, 0.08947325f, 
    -0.27108687f, -0.26752821f, 0.01738009f, 0.05704191f, -0.07766463f, -0.06280980f, -0.01454226f, -0.03923374f, 
    -0.68246293f, -0.58154333f, -0.17734726f, 0.08919874f, 0.00016411f, -0.02485370f, -0.12535143f, 0.06547286f, 
    -0.03255859f, 0.04195424f, 0.01835974f, 0.12027629f, -0.02542600f, 0.25677422f, -0.00287928f, 0.01086231f, 
    0.00519457f, -0.17531270f, 0.05069789f, -0.18060349f, 0.05354594f, 0.00011620f, -0.00534212f, -0.08333788f, 
    0.13677841f, -0.05387743f, 0.01845878f, -0.22305597f, -0.01714901f, -0.08340980f, 0.06602098f, -0.01380271f, 
    0.02402388f, -0.09983603f, 0.10893333f, 0.22096917f, -1.15124273f, 0.40767330f, 0.34015238f, -0.17856263f, 
    -0.04142940f, 0.04934690f, 0.03909450f, 0.03473827f, -0.12995908f, -0.21747200f, -0.02735983f, -0.05757814f, 
    0.18063119f, 0.13242097f, 0.01558862f, 0.07697248f, 0.06938309f, 0.01816967f, 0.00376990f, 0.00543602f, 
    -0.03390568f, -0.13171043f, -0.09189091f, 0.02297169f, -0.40487784f, 0.04675257f, -0.71167982f, 0.29345125f, 
    -0.08300304f, -0.01928310f, -0.06947713f, -0.06854711f, -0.07986840f, -0.12803493f, -0.04355194f, 0.06661858f, 
    -0.02714711f, -0.52218169f, -0.35666138f, 0.06868277f, -0.04199936f, 0.01558150f, -0.09122436f, -0.19508144f, 
    -0.16549318f, -0.17097479f, -0.15739711f, 0.11622698f, 0.32569811f, -0.35787764f, -0.01028544f, -0.19355959f, 
    -0.08983608f, -0.00886776f, 0.14696874f, -0.02546183f, -0.10344453f, -0.11631470f, 0.00054382f, 0.02719860f, 
    0.20956111f, -0.10582177f, 0.08733183f, 0.00819517f, -0.11671156f, 0.03901317f, -0.02081671f, -0.14937471f, 
    0.10867658f, 0.05468248f, -0.03706303f, -0.05484745f, 0.38343129f, 0.28074563f, -0.01890895f, -0.17048357f, 
    0.02721976f, 0.13320774f, -0.08003465f, -0.24599436f, -0.23129828f, -0.17773600f, -0.25556144f, -0.08638290f, 
    -0.08661427f, 0.02182025f, 0.15588811f, -0.01324558f, 0.04708752f, 0.06751183f, 0.04741931f, 0.08200428f, 
    0.04404374f, 0.25789803f, 0.20881884f, 0.07875028f, -0.02319091f, 0.34143034f, 0.14258781f, -0.30726653f, 
    -0.07172909f, 0.03721162f, -0.15409358f, -0.18052854f, 0.00677285f, 0.00163405f, -0.05699661f, 0.00170008f, 
    0.29800433f, 0.35011911f, -0.19146803f, -0.48437771f, 0.06780831f, -0.07791469f, 0.08484001f, -0.02140351f, 
    -0.03126862f, -0.00083786f, -0.06300467f, -0.02837953f, 0.47043428f, 0.12420210f, 0.04654231f, -0.29736105f, 
    0.22528690f, 0.10527421f, 0.22052762f, 0.04333448f, -0.02112859f, -0.04378165f, -0.04352534f, -0.09389831f, 
    -0.11664128f, -0.05009760f, 0.07096114f, 0.00646576f, -0.02297692f, -0.01561941f, -0.08454599f, 0.03431954f, 
    -0.15999842f, -0.16056389f, -0.18805794f, -0.04814099f, 0.20467085f, -1.06047297f, -0.24941429f, 0.03564524f, 
    -0.19582364f, -0.07446038f, 0.20629936f, -0.14512059f, -0.14839047f, 0.09718234f, -0.05594919f, -0.00624896f, 
    -0.45834172f, -0.88483465f, 0.06439437f, 0.08513617f, 0.04298641f, 0.13909929f, -0.00308327f, -0.00593698f, 
    -0.00619785f, -0.03416100f, 0.05777748f, 0.05018011f, -0.14589480f, 0.00229157f, 0.22757795f, -0.02215749f, 
    -0.03923077f, -0.13987644f, -0.09016435f, -0.04075125f, -0.00825230f, -0.09982446f, 0.04332915f, 0.02535223f, 
    -0.00038265f, -0.06289213f, 0.03610634f, -0.02983175f, 0.01074228f, 0.00687066f, -0.01340062f, -0.02385825f, 
    -0.08444446f, -0.02945223f, -0.20290263f, -0.05491894f, -0.05482431f, 0.12754515f, 0.12928085f, -0.25504059f, 
    -0.13982870f, -0.06970300f, 0.10901309f, -0.09629384f, -0.09032485f, -0.20394571f, -0.02284412f, -0.19108886f, 
    0.16154230f, -0.44164130f, -0.26022163f, -0.41240799f, -0.31663451f, 0.01204792f, -0.25039119f, 0.08103926f, 
    -0.06764881f, 0.03538645f, 0.06862013f, 0.10575502f, 0.07549941f, 0.00855182f, -0.04660348f, -0.15113433f, 
    0.14214921f, -0.16999437f, 0.06993429f, 0.15555660f, 0.06496431f, -0.22460990f, 0.09097861f, 0.09871053f, 
    0.00285409f, 0.03777610f, 0.14777547f, 0.02236945f, -0.05958289f, -0.09803408f, 0.12645894f, 0.03136037f, 
    -0.01005733f, 0.02117744f, 0.07375772f, -0.27190724f, -0.06270784f, -0.04425863f, 0.03964617f, 0.01278415f, 
    0.18745148f, -0.05026327f, 0.02781154f, 0.06954221f, 0.29974496f, -0.10021640f, -0.09303810f, 0.06712155f, 
    0.27045530f, -0.02447470f, 0.29999417f, 0.17092618f, 0.12112036f, 0.09315378f, -0.28124151f, -0.20823038f, 
    -0.00766432f, -0.00922909f, -0.02939605f, 0.04606247f, -0.06062283f, -0.10225371f, -0.41322526f, -0.12822495f, 
    -0.04629295f, 0.04356989f, -0.01976593f, -0.12816466f, -0.15751268f, -0.01796632f, 0.01091788f, -0.13351279f, 
    -1.11273360f, -0.51088911f, -0.35347638f, -0.50797981f, -0.03629120f, -0.05208130f, 0.08498857f, 0.34016082f, 
    0.01740660f, -0.02090478f, 0.05078147f, -0.15024628f, 0.38768157f, 0.59417737f, 0.09923244f, -0.09113577f, 
    -0.02682991f, -0.01759465f, -0.00512994f, 0.14869802f, -0.12861860f, -0.03525499f, -0.06946032f, -0.08021765f, 
    -0.22718242f, 0.07719830f, -0.36229303f, 0.06710307f, -0.32129690f, -0.10778249f, 0.18235101f, -0.10691348f, 
    -0.08094130f, 0.00037170f, 0.09229906f, 0.11171924f, -0.12583953f, -0.14262466f, -0.01485325f, -0.05865639f, 
    0.11927880f, 0.16146578f, -0.05770127f, -0.05600940f, 0.21162419f, 0.11609018f, 0.06475419f, 0.04372099f, 
    0.32075161f, -0.17033289f, -0.40162382f, -0.20808460f, -0.07319551f, 0.08160499f, -0.06058109f, -0.20078480f, 
    0.04699636f, -0.08645009f, -0.18097220f, -0.13587004f, 0.02429395f, -0.03645961f, 0.01222126f, 0.07464634f, 
    0.18135080f, 0.15066190f, -0.02488169f, -0.00004592f, -0.13136840f, 0.02060506f, -0.06501094f, 0.06171912f, 
    0.34683573f, 0.13923067f, 0.23450644f, 0.04135941f, -0.10252010f, -0.09437680f, -0.03211443f, -0.08354795f, 
    -0.02478988f, -0.04498789f, 0.01775323f, 0.13308248f, -0.14769007f, 0.19939241f, -0.00294206f, -0.04227891f, 
    -0.01349889f, -0.09390617f, -0.01941951f, 0.20383310f, -0.08462817f, -0.38453326f, 0.29195043f, -0.01307263f, 
    0.10856656f, 0.08970796f, -0.20640968f, -0.17755459f, -0.02210432f, 0.05319090f, -0.01560321f, -0.08986890f, 
    -0.10459891f, -0.31379661f, -0.11109205f, -0.57316077f, -0.51173341f, 0.36697757f, 0.28356239f, 0.04598456f, 
    0.11556675f, -0.02409448f, -0.00521958f, -0.15197961f, 0.04057546f, 0.13253084f, -0.33937651f, 0.04373651f, 
    0.28006011f, -0.06941601f, -0.29011905f, -0.17235462f, -0.02616346f, -0.03084753f, 0.06426746f, -0.03319668f, 
    0.00356599f, 0.03576782f, 0.22723933f, -0.07998274f, 0.39674816f, -0.14162616f, 0.02746350f, 0.01516283f, 
    0.02053729f, -0.09403856f, 0.16422758f, -0.00443199f, -0.10964263f, 0.01284097f, 0.05511808f, 0.03525821f, 
    1.11456740f, -0.26259539f, 0.14241078f, -0.09042498f, -0.05220604f, -0.15573496f, 0.03974532f, 0.01660124f, 
    0.07287165f, 0.03441106f, -0.16249925f, -0.21441963f, 0.21323231f, -0.10817449f, 0.20970093f, 0.20259058f, 
    -0.04606552f, 0.10316008f, -0.03957744f, -0.08741689f, 0.12159585f, 0.12895642f, 0.10383494f, 0.10393345f, 
    0.09879495f, -0.16739275f, -0.06277929f, -0.07351618f, -0.08496372f, -0.11578613f, -0.21129924f, -0.05806065f, 
    -0.06582034f, 0.00486130f, 0.03085907f, 0.12067954f, -0.38201842f, 0.33802548f, -0.24675694f, 0.11234856f, 
    0.07178777f, 0.13030499f, 0.13925658f, 0.05054431f, 0.06232734f, 0.01731776f, -0.06626648f, -0.02720069f, 
    -0.02523742f, 0.11482488f, -0.02765562f, -0.02366284f, 0.01551999f, 0.02560618f, -0.08817533f, 0.01772723f, 
    -0.53587657f, -0.18730275f, -0.15495577f, -0.22357611f, 0.10817457f, -0.06810033f, 0.09454092f, -0.39699677f, 
    0.02604645f, 0.05805333f, -0.13205802f, 0.02693464f, -0.04940623f, -0.04813898f, 0.00276590f, -0.00928642f, 
    -0.18490461f, 0.13060285f, 0.08576663f, -0.07309999f, -0.10042743f, 0.10398982f, 0.08392114f, 0.15250514f, 
    -0.06965335f, 0.04048820f, 0.01798423f, 0.03200461f, -0.02649931f, 0.21102047f, 0.38691819f, 0.05850453f, 
    -0.02247330f, -0.06789218f, 0.06860298f, -0.35766494f, 0.02346264f, -0.04081495f, 0.06078459f, 0.00626842f, 
    0.05643389f, -0.06163913f, 0.19615568f, -0.04583848f, 0.00211792f, 0.25895542f, -0.03760666f, 0.05432338f, 
    -0.15564691f, 0.22680801f, -0.14859486f, -0.03575497f, 0.98762101f, -0.06993786f, 0.02741447f, 0.17804669f, 
    -0.16270353f, 0.00806261f, -0.15208524f, -0.26529378f, 0.07976844f, -0.12145736f, -0.06539023f, 0.03159326f, 
    0.40637115f, 0.39472887f, 0.43521059f, -0.08890381f, -0.04496856f, -0.05139310f, -0.06375799f, 0.02800885f, 
    0.07070076f, -0.02992368f, 0.13690697f, -0.04209723f, -0.04583796f, 0.08718839f, -0.00399874f, 0.04651195f, 
    0.11723039f, -0.06572290f, -0.12250540f, 0.06593297f, 0.00484800f, 0.14115827f, -0.09269369f, -0.04326536f, 
    0.01356565f, 0.12648158f, 0.09032193f, 0.11223029f, -0.08965231f, 0.00656388f, 0.01415947f, 0.01316747f, 
    -0.02376348f, 0.05881881f, 0.08759086f, -0.03774629f, -0.05713359f, 0.29541117f, -0.12282544f, -0.03105094f, 
    0.05569167f, 0.15774344f, 0.12180129f, -0.32607090f, 0.08311610f, 0.12727663f, 0.03045287f, 0.22556669f, 
    -0.10358308f, -0.15585366f, -0.06324347f, -0.36624929f, 0.04121042f, 0.04453947f, 0.07715826f, -0.11123090f, 
    -0.01139204f, -0.11605925f, 0.02764873f, -0.03352685f, -0.10299143f, -0.02378410f, 0.00080510f, -0.12861064f, 
    0.09524415f, -0.20978282f, -0.26975885f, 0.09647876f, -0.02383445f, 0.10467079f, -0.07802676f, 0.04180446f, 
    -0.09538587f, -0.12148444f, 0.07207809f, 0.01079156f, 0.12122120f, 0.12014066f, 0.04052328f, -0.09666506f, 
    -0.11053754f, -0.20458323f, -0.00532829f, 0.05171723f, 0.04977022f, -0.21628320f, 0.10029852f, 0.26038083f, 
    0.16368641f, 0.12952732f, -0.03337614f, 0.09520160f, 0.07026652f, -0.05683646f, 0.05186289f, 0.17402831f, 
    -0.00217811f, 0.06734879f, 0.46386036f, 0.38703933f, 0.04638599f, -0.38453832f, 0.11919076f, 0.00494964f, 
    0.00587577f, 0.02562600f, -0.12085892f, -0.02890077f, -0.14696389f, 0.28499946f, 0.26021624f, 0.33085623f, 
    0.05090306f, 0.07225381f, 0.02575991f, 0.06983767f, 0.12182160f, 0.10085827f, 0.02445851f, 0.18895131f, 
    0.60176462f, -0.01565237f, -0.50791228f, 0.14979438f, -0.11380967f, 0.00847118f, -0.05151035f, -0.22289346f, 
    0.01063351f, -0.04657612f, -0.12378391f, 0.06478357f, -0.06099591f, 0.30454761f, 0.66181517f, 0.64903951f, 
    -0.22429901f, -0.13954745f, 0.11027319f, 0.17432080f, 0.08598941f, -0.02645843f, -0.01470355f, -0.06057168f, 
    -0.30247352f, 0.11260165f, -0.39445943f, 0.20634964f, -0.18471573f, -0.25989768f, 0.18756945f, -0.10651211f, 
    -0.03454381f, 0.00150071f, 0.05187938f, -0.06223287f, -0.06851979f, 0.02011055f, 0.08608727f, -0.02871245f, 
    -0.13769776f, -0.14574902f, 0.03181905f, -0.29136556f, 0.00643346f, 0.17234589f, 0.04223879f, 0.00586607f, 
    0.25926813f, 0.33080509f, 0.37822488f, 0.27260455f, -0.04491764f, 0.10960319f, 0.05546571f, 0.00991404f, 
    -0.01214618f, -0.16161965f, -0.13763373f, 0.12312032f, -0.00989577f, 0.08206687f, -0.02275304f, -0.13252395f, 
    -0.04510611f, -0.14795780f, 0.02676296f, 0.14272282f, -0.04337208f, -0.00289488f, 0.00557867f, -0.05703887f, 
    -0.38822022f, 0.09281786f, 0.05964796f, -0.43217465f, 0.05648405f, -0.09460980f, 0.02121951f, 0.06855933f, 
    0.00507842f, 0.00299709f, 0.03008812f, -0.01003662f, 0.02726426f, 0.01090434f, -0.08158433f, 0.02498079f, 
    0.01013957f, -0.02904773f, -0.22217831f, 0.16970539f, 0.05588327f, -0.15457569f, 0.21597143f, -0.12842123f, 
    -0.06214118f, 0.08801934f, -0.16835801f, -0.06243147f, -0.02332596f, -0.07538676f, -0.02321081f, 0.03024730f, 
    0.11206163f, 0.23831418f, 0.00028833f, 0.01193395f, -0.24392702f, -0.22437078f, -0.09273530f, 0.13689460f, 
    0.02787570f, 0.02401946f, 0.02229148f, -0.08171084f, 0.02648760f, 0.08291625f, -0.04785138f, 0.11222095f, 
    0.01943283f, -0.04633688f, 0.30316550f, 0.11120965f, 0.02676090f, -0.10792173f, 0.08043526f, 0.01624408f, 
    -0.16575399f, -0.07522250f, 0.10226378f, -0.04550967f, 0.10569605f, -0.07507011f, 0.32366243f, -0.21219151f, 
    -0.00812766f, -0.12432478f, 0.06010626f, 0.04410306f, 0.01490268f, 0.05469246f, 0.02407530f, -0.01026691f, 
    -0.75043142f, 0.63858861f, 0.29494733f, -0.67311478f, 0.00456105f, -0.00565891f, -0.02393971f, -0.15180990f, 
    -0.05836613f, 0.13009551f, -0.07229594f, 0.15823072f, 0.02068858f, -0.08115925f, -0.28952906f, 0.05809988f, 
    0.01137581f, 0.02885466f, -0.01479521f, 0.11015408f, -0.17735222f, 0.01892947f, 0.06020665f, 0.05941481f, 
    -0.35642707f, -0.22706687f, 0.13816696f, -0.09282423f, 0.05008741f, -0.05220156f, -0.28788388f, -0.23989363f, 
    0.14383699f, -0.03600577f, -0.01050842f, -0.04229490f, -0.05483454f, 0.45441467f, -0.03995496f, 0.18170570f, 
    0.00739892f, -0.03857284f, 0.12359853f, -0.05477826f, -0.05945788f, 0.00439548f, -0.02474996f, 0.04446635f, 
    0.23088728f, 0.00309771f, -0.02496010f, 0.15179949f, -0.00604814f, 0.01151794f, 0.03344131f, -0.07508448f, 
    0.07384267f, 0.09722637f, 0.20291793f, 0.21202652f, 0.00871242f, -0.47624066f, 0.50112289f, -0.15047260f, 
    0.03989886f, -0.17274779f, -0.09410705f, 0.17670938f, -0.00600644f, -0.04992710f, -0.06221226f, 0.00844763f, 
    -1.08286250f, -0.42021441f, -0.25865111f, -0.53103364f, 0.14102484f, 0.15871100f, -0.18485878f, -0.09416191f, 
    -0.00382794f, -0.07792688f, 0.01618631f, -0.08659448f, -0.88403016f, -0.45090553f, -0.39300269f, -0.26291361f, 
    -0.00778004f, -0.05209789f, 0.06406105f, 0.09567551f, -0.00672809f, 0.03888104f, -0.05050376f, -0.07311316f, 
    0.02883659f, -0.18038222f, -0.13275385f, -0.00132197f, 0.01650832f, 0.19949445f, 0.02261886f, 0.02436198f, 
    0.10794705f, 0.02711578f, 0.05702943f, 0.04333924f, -0.35182294f, -0.07803815f, -0.19364418f, -0.21853484f, 
    -0.09910281f, -0.15003227f, -0.00930289f, -0.17284782f, 0.19765380f, -0.06924362f, 0.13769920f, -0.04605946f, 
    -0.07309972f, -0.03914844f, -0.15824804f, -0.01930286f, 0.03896261f, -0.06751475f, -0.00351634f, 0.00323042f, 
    0.08156202f, 0.03088546f, -0.06457321f, 0.06350748f, -0.04909130f, -0.01243345f, -0.05045797f, -0.00374833f, 
    0.05075578f, 0.01657788f, -0.31197768f, -0.05692797f, 0.06295748f, -0.09634846f, 0.08387139f, 0.03190104f, 
    -0.13799497f, -0.03578687f, -0.15728916f, 0.03365643f, -0.02708853f, 0.00609535f, 0.04217111f, 0.08198918f, 
    -0.11002279f, 0.08779778f, -0.00401326f, 0.08261131f, 0.26349139f, 0.10269564f, -0.33172286f, 0.08273973f, 
    -0.17734034f, 0.17851683f, -0.12985729f, 0.01026914f, -0.05573256f, 0.17722976f, 0.03694862f, -0.19497167f, 
    -0.15608791f, -0.15818509f, -0.13525355f, 0.24135108f, -0.02526293f, 0.00552567f, -0.31958273f, 0.04703302f, 
    -0.14041302f, -0.37913728f, -0.12645535f, -0.02787533f, -0.09914151f, -0.31149340f, -0.08186071f, 0.19914012f, 
    0.10679754f, -0.11551711f, 0.03285815f, 0.02982039f, -0.16299780f, 0.25121468f, -0.25414839f, 0.12507109f, 
    -0.03036658f, 0.07810408f, -0.06625697f, 0.27797943f, 0.08100460f, 0.00705387f, -0.17783283f, -0.05955693f, 
    0.03449185f, 0.08089516f, 0.08467609f, 0.10527371f, -0.15175124f, 1.11056769f, -0.29179943f, -0.39983109f, 
    -0.03033386f, 0.12699348f, 0.01698044f, -0.10879418f, -0.67557693f, 0.13518104f, -0.04301815f, -0.09209164f, 
    0.34130484f, -0.28973201f, 0.02404942f, 0.27608550f, 0.08531373f, -0.20380594f, 0.09206142f, -0.19669412f, 
    0.08277123f, 0.09842848f, 0.12636137f, 0.20803180f, 0.16766776f, -0.20375700f, 0.00716839f, -0.01061949f, 
    0.23565494f, -0.01983729f, 0.09857127f, -0.03922090f, 0.02155207f, -0.01229078f, -0.02314649f, 0.07395668f, 
    0.35597861f, 0.61858428f, -0.28386042f, -0.61142474f, -0.05789391f, -0.13705669f, -0.06330433f, -0.03102771f, 
    -0.01691540f, 0.05377493f, 0.01572888f, 0.02438999f, 0.25008044f, -0.10135999f, 0.09148614f, 0.27063352f, 
    0.06607367f, 0.01984676f, -0.11117085f, -0.00936138f, -0.03706553f, -0.02380011f, -0.05207781f, 0.17496306f, 
    0.02197703f, -0.14452381f, -0.22201353f, 0.26215902f, 0.07834452f, 0.01679613f, 0.10383508f, 0.12550621f, 
    0.09344997f, 0.06231583f, 0.15115462f, 0.17975360f, -0.38122424f, -0.26671419f, -0.17829023f, 0.34486687f, 
    0.17470089f, 0.01874833f, 0.24167940f, -0.08782139f, 0.07118248f, -0.20315365f, 0.22346319f, -0.14520177f, 
    0.20551507f, -0.25959581f, 0.07658371f, 0.23766752f, 0.18152559f, 0.10872417f, 0.02339623f, -0.11767270f, 
    -0.10319600f, 0.04771610f, -0.04469065f, 0.03149176f, -0.02362108f, -0.04337220f, 0.03924105f, -0.25754145f, 
    0.00907911f, -0.12724246f, -0.29139674f, -0.11704884f, -0.04167825f, 0.19520505f, -0.02472184f, -0.12998509f, 
    -0.34582224f, -0.04424823f, 0.02869576f, 0.38236722f, -0.25049788f, -0.21824008f, 0.03934738f, 0.15874913f, 
    0.02975764f, 0.24734378f, -0.03728285f, -0.00121488f, -0.20878127f, 0.13038003f, -0.13149397f, 0.07450965f, 
    -0.01484641f, 0.03921240f, -0.11316270f, -0.03894159f, -0.12186567f, -0.15271585f, 0.10556658f, 0.21167056f, 
    -0.43805858f, 0.37214184f, -0.17576917f, 0.03603464f, -0.06119894f, 0.03774051f, -0.05726083f, -0.03632266f, 
    -0.11822228f, 0.10281417f, 0.07131711f, 0.09757707f, 0.97879845f, -0.30534372f, -0.16007850f, -0.51266903f, 
    -0.10873150f, -0.13359059f, -0.12373817f, 0.10574255f, -0.17925704f, 0.14557147f, -0.13485380f, -0.04724678f, 
    -0.76206470f, -0.29836881f, 0.12995777f, -0.05335927f, 0.23871997f, 0.08597397f, -0.01256673f, -0.14701626f, 
    -0.00821407f, -0.18740694f, 0.00361801f, -0.06237445f, -0.18236470f, 0.43199503f, 0.10815942f, 0.00335268f, 
    -0.14211211f, -0.23191878f, -0.28783962f, -0.16407831f, -0.06078643f, -0.00561206f, -0.22795570f, 0.09250171f, 
    -0.98478514f, -0.09292418f, -0.04716598f, 0.35896164f, -0.00886095f, -0.13380696f, 0.27479261f, -0.18714039f, 
    -0.07226555f, 0.06070184f, 0.18563099f, -0.05684063f, -0.61981070f, 0.56567836f, -0.53218883f, -0.77595973f, 
    0.10987461f, -0.02232131f, -0.06701623f, -0.14745989f, -0.16025063f, -0.10593453f, 0.00705728f, 0.09785499f, 
    0.07474321f, -0.02873333f, 0.25450480f, 0.02061450f, 0.04213306f, 0.00924081f, -0.13422160f, 0.03851642f, 
    -0.07696277f, -0.12857975f, -0.11988482f, -0.01013691f, -0.04149594f, 0.04381210f, -0.12721930f, 0.08944899f, 
    0.00885559f, -0.05352965f, 0.03760453f, -0.03095872f, -0.00544052f, 0.19454570f, -0.00172725f, -0.03332940f, 
    0.39731669f, 0.11192806f, 0.14489692f, -0.01884119f, 0.11266222f, 0.21259287f, 0.01153864f, -0.21697815f, 
    -0.01174583f, -0.03297893f, 0.00945480f, -0.04501927f, 0.16864513f, -0.19148631f, 0.23350668f, -0.09071866f, 
    -0.33465672f, 0.02679718f, -0.07219586f, 0.02372186f, -0.00495895f, 0.04213390f, -0.11798050f, -0.09748863f, 
    0.02638732f, -0.11635251f, 0.01507926f, 0.09384172f, 0.08626467f, 0.23409320f, -0.05571466f, 0.11428247f, 
    0.06225020f, -0.14028542f, 0.22166048f, -0.24455726f, -0.22158340f, -0.06318367f, -0.07031260f, 0.13592690f, 
    -0.00257958f, 0.06900998f, -0.03275007f, 0.17753361f, -0.10735779f, 0.00956824f, -0.06523596f, -0.06411201f, 
    0.15301795f, -0.15957925f, 0.07389663f, -0.12109719f, 0.12206558f, 0.11292997f, -0.18595156f, -0.11654024f, 
    -0.19537354f, 0.07687826f, 0.25659856f, -0.17644653f, -0.11789579f, 1.22161949f, -0.08790307f, 0.73041803f, 
    0.38326040f, 0.12259561f, 0.08032309f, -0.04237857f, 0.22649442f, 0.07204067f, 0.24759211f, 0.04051658f, 
    -0.18901972f, -0.23061670f, 0.00001089f, -0.16665997f, -0.18951978f, 0.12923685f, -0.30902228f, 0.10460180f, 
    -0.15907140f, 0.08062729f, -0.02250591f, -0.03152397f, 0.16222036f, 0.01154457f, 0.22082543f, 0.33323312f, 
    -0.26221541f, 0.02293077f, 0.05282643f, 0.16133912f, 0.11534062f, 0.21901846f, 0.06588495f, 0.18198530f, 
    -0.37947235f, -0.38750529f, 0.08175813f, -0.23723488f, -0.33647737f, -0.06051750f, -0.18660364f, 0.07686055f, 
    -0.14861113f, -0.16422595f, 0.23257205f, -0.15699141f, -0.55220801f, -0.05473352f, -0.45773786f, -0.45778513f, 
    0.08494434f, 0.03212288f, -0.17378442f, -0.03325780f, 0.05363738f, -0.18108417f, -0.16514321f, -0.20080841f, 
    0.10437138f, 0.35673609f, 0.17308681f, 0.07145186f, 0.09311233f, -0.06038492f, 0.11437470f, -0.07009701f, 
    0.05853571f, -0.08676674f, -0.05356639f, -0.21710974f, 0.20210010f, 0.10049161f, -0.01549485f, -0.10754450f, 
    0.12444036f, -0.07433896f, -0.11664291f, -0.26448184f, 0.06061682f, -0.04107183f, 0.01450658f, -0.21813692f, 
    0.08785824f, 0.06331290f, -0.00117759f, 0.08972143f, -0.00888272f, 0.08683357f, 0.03699576f, 0.11092019f, 
    -0.10760610f, -0.08982985f, -0.06450149f, -0.09340524f, 0.10976741f, -0.87223053f, 0.03360064f, -0.01000049f, 
    -0.04171887f, -0.03558396f, 0.07916819f, -0.21514460f, -0.09937944f, 0.15647782f, -0.18701743f, -0.15005319f, 
    -0.12401427f, -0.16698448f, 0.03002149f, 0.20036751f, 0.11541539f, -0.06784599f, -0.10777143f, 0.02608356f, 
    0.03687485f, 0.02592023f, 0.06283689f, 0.24828927f, 0.08350613f, 0.16305117f, -0.03001541f, 0.04670898f, 
    -0.15062363f, -0.00256426f, -0.04072561f, -0.00730891f, 0.07070721f, -0.02046680f, -0.08399258f, 0.04239058f, 
    -0.14154787f, -0.32903099f, -0.04866971f, 0.37687483f, -0.08240539f, -0.03686474f, -0.13299178f, -0.31201953f, 
    0.07188579f, -0.28599346f, 0.16692823f, 0.08904603f, -0.16556488f, 0.01511294f, 0.07508071f, 0.22441366f, 
    -0.08754150f, -0.33582544f, -0.06106005f, -0.27610189f, 0.05809430f, -0.01045729f, 0.05713363f, -0.04149855f, 
    0.08229835f, 0.01546060f, 0.44721827f, 0.05637719f, -0.24909100f, 0.10711863f, -0.14088063f, 0.32185030f, 
    -0.06060030f, -0.11945995f, -0.04510041f, -0.03615260f, 0.07242758f, 0.15957406f, 0.16387364f, 0.09361989f, 
    0.04935514f, -0.15542977f, -0.02696282f, -0.00175729f, 0.10796749f, 0.11139277f, 0.00013167f, 0.04198015f, 
    0.12233593f, 0.25064009f, 0.11908616f, 0.13001981f, -0.11295046f, -0.14625196f, -0.01073825f, 0.06689724f, 
    0.08169128f, -0.17543980f, 0.00191251f, 0.08708204f, 0.16647318f, 0.05329916f, 0.02767696f, 0.14623609f, 
    0.10014587f, -0.01495731f, 0.02953156f, -0.00866299f, -0.02068538f, 0.00821422f, -0.00790542f, -0.05455263f, 
    0.30362743f, 0.47696403f, -0.10124764f, 0.18535255f, 0.10234784f, 0.07675430f, 0.06273182f, 0.14157256f, 
    0.11820357f, -0.01825194f, -0.00876870f, -0.02662161f, 0.08874719f, -0.15968353f, 0.19349244f, 0.22071670f, 
    -0.16735806f, -0.04485444f, 0.15751208f, -0.36140731f, 0.02385767f, 0.02451936f, -0.17109916f, 0.12407173f, 
    0.02769905f, -0.07845469f, 0.01917122f, -0.03401846f, -0.02479533f, -0.09541065f, -0.08562031f, 0.01154344f, 
    0.15799621f, 0.18944626f, 0.00178892f, 0.34915012f, -0.74266064f, -0.32787523f, -0.35845092f, -0.27368477f, 
    0.11868384f, 0.04000535f, 0.01147695f, 0.12416474f, -0.11158108f, -0.17073308f, 0.05763632f, -0.07846009f, 
    0.15554854f, 0.25762433f, -0.08577643f, 0.03589585f, 0.01684029f, -0.01021692f, -0.02658561f, -0.00333056f, 
    -0.19241606f, -0.10950793f, -0.12692632f, -0.05462497f, -0.06247805f, -0.19235301f, -0.29831436f, -0.35803661f, 
    -0.03589759f, 0.00194761f, -0.05760983f, -0.10112824f, 0.15337320f, -0.01519511f, -0.00409723f, -0.23918852f, 
    -0.26323590f, 0.23745434f, -0.29138264f, 0.02241980f, 0.12672889f, -0.05730735f, -0.09914331f, -0.01699119f, 
    -0.13929538f, 0.11348595f, -0.00643147f, 0.20392613f, -0.15802386f, -0.51282692f, 0.03427674f, -0.23845090f, 
    0.02217350f, 0.05120347f, -0.02161858f, -0.06068460f, -0.08598393f, -0.09113260f, -0.18562333f, -0.09240323f, 
    -0.12394369f, 0.24183501f, -0.07207433f, 0.16983831f, -0.14709415f, 0.19663499f, 0.00757837f, 0.02816978f, 
    0.09556402f, 0.00703909f, -0.07980373f, -0.13073456f, 0.03974759f, -0.06930281f, 0.22248282f, 0.07615802f, 
    -0.01457542f, -0.01438414f, -0.20027864f, -0.01613807f, 0.05742922f, -0.13021637f, 0.15635981f, 0.03076958f, 
    -0.03086252f, -0.08537795f, -0.17195788f, -0.04773538f, -0.08081780f, -0.03945461f, 0.03551805f, 0.00333144f, 
    0.12845540f, 0.31552860f, 0.15169184f, 0.39325458f, 0.04056605f, -0.02755068f, -0.22003040f, 0.41603288f, 
    0.08491763f, 0.13317223f, 0.00339229f, 0.00008504f, 0.11769999f, -0.03565597f, 0.00888842f, -0.08155639f, 
    0.11448942f, 0.24848053f, 0.30867529f, 0.32571059f, -0.20271637f, -0.01948115f, 0.04465594f, 0.14384907f, 
    0.03197715f, -0.04895762f, -0.00315503f, -0.05166302f, -0.08117024f, -0.00010880f, 0.10647978f, 0.08178024f, 
    -0.14054431f, 0.14954628f, 0.01295187f, 0.14826563f, -0.00109345f, 0.02512284f, -0.04238066f, 0.00309241f, 
    -0.08040278f, 0.02500520f, 0.00845291f, -0.05410352f, -0.09667514f, -0.31288716f, 0.04105850f, -0.06057499f, 
    0.11330494f, -0.13019045f, -0.10643228f, -0.16164328f, -0.21038476f, -0.21251112f, 0.15586860f, -0.44726008f, 
    0.03135488f, 0.25064471f, -0.09566990f, -0.07604764f, -0.00673849f, -0.14022087f, -0.05371177f, -0.02204886f, 
    -0.68906564f, -0.57458520f, -0.16797389f, 0.00152482f, 0.10582823f, -0.08751691f, 0.08168630f, -0.05473020f, 
    0.01756729f, 0.00713696f, -0.02835930f, -0.00344790f, 0.20019484f, 0.13134357f, -0.08989462f, 0.32913718f, 
    -0.07090808f, -0.17371833f, -0.04858668f, -0.12673928f, 0.14072478f, -0.14993070f, -0.18151517f, 0.12906115f, 
    0.12484390f, 0.08074550f, 0.07313803f, 0.07866451f, 0.17030986f, 0.05328944f, 0.02991201f, 0.06238693f, 
    0.11746804f, -0.08427144f, -0.14236544f, -0.21110134f, -0.09773506f, -0.32048479f, 0.06633278f, -0.41285461f, 
    -0.14460762f, -0.17067610f, -0.12455146f, 0.07775263f, -0.33927417f, -0.23382626f, -0.15528667f, -0.06255956f, 
    0.15070206f, 0.53208786f, -0.18641491f, -0.12089101f, 0.19719221f, 0.07034239f, 0.38365957f, 0.07678604f, 
    0.07384170f, 0.06092742f, 0.00205569f, 0.09378566f, 0.27440402f, -0.07906657f, -0.14107056f, -0.08590364f, 
    -0.03715359f, 0.17548308f, -0.10617603f, 0.31151092f, 0.08484161f, 0.06715202f, 0.11589501f, -0.00688586f, 
    -0.12639922f, -0.12202083f, -0.08892006f, -0.13871224f, -0.12843965f, 0.00853264f, -0.20181738f, -0.05659186f, 
    0.24405657f, 0.04415864f, -0.09931132f, 0.31714001f, -0.27454644f, 0.02547356f, 0.15845661f, 0.01865624f, 
    0.06837024f, -0.15746078f, -0.23061445f, -0.03249423f, 0.04852888f, -0.22717342f, 0.05049660f, 0.10998633f, 
    -0.28565931f, 0.47243378f, -0.08987004f, -0.29618317f, -0.14418443f, -0.12880094f, 0.09943073f, 0.10068320f, 
    0.05269982f, -0.19871816f, -0.11391840f, -0.29334936f, -0.46724731f, -0.19999434f, -0.08836763f, -0.27271739f, 
    -0.02293027f, -0.06481311f, -0.02902001f, 0.02791101f, 0.02284420f, -0.07761844f, -0.07566258f, 0.09770161f, 
    0.21594298f, -0.11928993f, 0.51480120f, 0.29172242f, 0.13745192f, -0.02691234f, 0.12036300f, 0.07906724f, 
    0.12986946f, 0.13235344f, -0.03702601f, 0.01392932f, -0.34849241f, -0.27743545f, -0.30210930f, -0.52978587f, 
    0.10723241f, -0.10114210f, 0.01005895f, -0.11521897f, 0.04738159f, -0.02375078f, 0.01381185f, -0.09079868f, 
    0.01176090f, -0.04759441f, 0.22769958f, -0.21664156f, 0.30269960f, -0.07387900f, -0.03574070f, -0.04650488f, 
    0.03390922f, -0.03563481f, -0.14968401f, 0.06140166f, 0.16896921f, 0.08749267f, -0.14220975f, -0.11577409f, 
    0.06333753f, 0.02746139f, -0.05599746f, -0.08015648f, -0.11010064f, -0.12882903f, 0.05114086f, -0.13889454f, 
    -0.73120517f, -0.18352902f, -0.21606487f, -0.22318397f, -0.07806943f, -0.03782550f, 0.03233794f, 0.19467935f, 
    -0.00280701f, -0.06810487f, 0.16756122f, 0.05961812f, -0.05087475f, -0.11471181f, -0.09803657f, 0.01011782f, 
    -0.10849010f, -0.03320450f, -0.06169100f, -0.10432295f, 0.21643525f, -0.06171417f, 0.06330344f, -0.02364847f, 
    -0.06590558f, -0.42873490f, -0.54680103f, 0.00386843f, 0.11067624f, 0.08593654f, -0.09335054f, -0.05230511f, 
    -0.00438151f, -0.11797116f, -0.03100801f, -0.08381370f, -0.00688388f, -0.16080551f, 0.09175911f, -0.09274199f, 
    -0.24486405f, -0.25192949f, -0.10514748f, 0.24740686f, -0.10252862f, 0.29463094f, 0.07352287f, -0.32299632f, 
    0.19741812f, -0.17795600f, 0.22932349f, 0.17788419f, 0.10564446f, 0.03163822f, 0.04987518f, 0.07407766f, 
    -0.19707432f, -0.07930163f, -0.38393912f, -0.21964873f, 0.13713844f, -0.31923831f, 0.14064121f, 0.32038969f, 
    -0.08993970f, 0.03316637f, 0.04131538f, 0.13225320f, -0.00321463f, -0.14165172f, 0.15393405f, 0.01340152f, 
    -0.23987223f, -0.32885551f, 0.14541066f, -0.02823825f, 0.03074955f, 0.05047616f, -0.10761280f, 0.08043630f, 
    0.19273664f, 0.28557092f, -0.06579891f, -0.16763487f, 0.28400791f, 0.06253622f, -0.27382892f, -0.06313670f, 
    0.06491970f, 0.31450596f, -0.09823340f, -0.04438185f, 0.11401153f, -0.10886332f, 0.05894101f, 0.03303696f, 
    0.06402781f, -0.10750855f, -0.73514992f, -0.60774463f, -0.05272428f, 0.12507780f, -0.09746075f, 0.05746680f, 
    0.30711943f, -0.13351859f, -0.10454021f, -0.14692983f, -0.15017049f, 0.00848632f, 0.28496093f, 0.27346501f, 
    0.01653446f, -0.15144953f, -0.03583329f, 0.12115610f, 0.02136177f, 0.00235829f, 0.01377691f, 0.00617185f, 
    -0.22505656f, 0.03745852f, -0.34995681f, 0.07467875f, 0.13288966f, 0.03758649f, 0.14379510f, 0.05835512f, 
    -0.09295347f, 0.02413813f, 0.01077471f, -0.05055728f, 0.24787147f, -0.06082000f, 0.17354685f, -0.06664881f, 
    -0.04163460f, 0.05462429f, 0.04820662f, 0.00061841f, 0.12319198f, -0.09259631f, -0.05553091f, -0.03689086f, 
    -0.27203560f, -0.29873753f, 0.02306154f, -0.00156842f, 0.01275356f, 0.02534279f, 0.03376816f, 0.11474696f, 
    -0.03645654f, -0.33606154f, -0.36370611f, -0.23626083f, -0.01107515f, 0.34729469f, -0.00949503f, 0.15169430f, 
    0.23534927f, 0.02587049f, -0.07696780f, 0.04615728f, 0.06533790f, 0.07537002f, 0.09657914f, 0.00888670f, 
    0.18873540f, 0.11222342f, 0.03388899f, 0.03828609f, 0.26746035f, 0.08166462f, 0.14036687f, -0.32569888f, 
    0.06407586f, 0.06969035f, -0.04820821f, 0.07880106f, 0.30536142f, 0.07424664f, 0.08484400f, 0.21357305f, 
    0.26573190f, 0.06510131f, -0.08996934f, 0.02959907f, -0.01354397f, 0.05095429f, -0.00189704f, 0.15619729f, 
    -0.12435685f, 0.12063359f, -0.34679833f, 0.13317308f, -0.03226593f, -0.17642081f, 0.11902847f, 0.05173089f, 
    0.21124099f, -0.11725742f, 0.14166778f, 0.28794923f, -0.41758347f, 0.25542864f, -0.19708118f, -0.19181754f, 
    -0.11584617f, -0.12877248f, -0.07449348f, 0.06601407f, -0.22718838f, 0.08893831f, -0.05103994f, -0.30919108f, 
    -0.10939195f, -0.37291685f, -0.42163688f, 0.35958692f, 0.09551422f, 0.02526020f, -0.00752165f, -0.03249983f, 
    -0.05497798f, 0.09091546f, -0.10820451f, -0.00941729f, -0.07658645f, -0.18337944f, 0.15390438f, -0.07349616f, 
    -0.10153697f, 0.06489803f, -0.09316135f, 0.05156382f, -0.16552155f, -0.14610043f, 0.21494523f, -0.21569179f, 
    -0.01721820f, -0.11862355f, -0.05315800f, -0.01325709f, 0.04882447f, -0.00122745f, -0.01272251f, -0.06617524f, 
    0.10818009f, 0.12330833f, 0.00987593f, 0.23600069f, -0.10278990f, -0.41820994f, 0.26596770f, 0.51697350f, 
    0.01164043f, -0.08431420f, -0.06525310f, 0.34597641f, 0.00229521f, 0.18872096f, -0.07077575f, 0.10248010f, 
    -0.79975301f, -0.85562164f, 0.35212675f, 0.46230125f, -0.01494175f, -0.07461934f, 0.07534435f, -0.10294442f, 
    0.06501523f, -0.01802334f, -0.00915695f, -0.00658736f, 0.24288709f, -0.22216886f, 0.13589263f, 0.15614021f, 
    0.00992688f, 0.03415310f, 0.27369487f, -0.19249736f, 0.04521637f, 0.08857882f, -0.10186674f, -0.03914622f, 
    -0.02622046f, 0.07599153f, -0.03848621f, 0.01399534f, 0.02107631f, -0.21339953f, 0.03088395f, 0.07637026f, 
    0.01732879f, 0.08499368f, 0.02538169f, -0.06563757f, -0.07528441f, -0.21515794f, 0.13027181f, 0.08500038f, 
    -0.22552221f, -0.00190876f, -0.01643310f, 0.07902934f, -0.06741007f, 0.15155715f, 0.07399676f, -0.15898323f, 
    -0.78835279f, -0.64439768f, 0.06497260f, -0.01565048f, -0.23097087f, 0.13164574f, 0.13038027f, -0.10869502f, 
    0.06587431f, 0.04786269f, 0.00675145f, -0.03729306f, -0.39762658f, 0.43085155f, 0.41249406f, 0.17407505f, 
    -0.08755315f, -0.07187361f, -0.04006615f, 0.27078277f, 0.00720694f, 0.09649968f, 0.13031103f, -0.02523977f, 
    -0.20191313f, -0.11913973f, -0.50853014f, -0.18614994f, -0.17864533f, 0.20959796f, -0.11001469f, -0.11924153f, 
    -0.11141873f, -0.00630670f, 0.20913894f, -0.04416789f, -0.58402729f, 0.04645275f, 0.30975264f, -0.17624778f, 
    0.20001657f, 0.05623669f, 0.03638479f, -0.27544358f, -0.05608717f, 0.07903624f, -0.03873211f, 0.04068451f, 
    -0.49014398f, -0.16398200f, -0.42946389f, -0.00887486f, 0.08318158f, 0.07362269f, -0.00795935f, -0.01882794f, 
    -0.01985374f, -0.07570338f, -0.04877467f, 0.05440645f, 0.08118871f, 0.26320726f, 0.05886879f, -0.19806990f, 
    -0.24969265f, -0.11558580f, -0.21620600f, -0.07281066f, -0.00823222f, -0.10119360f, -0.04767331f, 0.03785609f, 
    -0.53436935f, 0.20623940f, 0.59634006f, 0.39728552f, -0.13047093f, -0.05466792f, 0.01890976f, 0.03786908f, 
    0.01250530f, 0.22674605f, 0.09535045f, 0.13152039f, -0.10041900f, -0.16937333f, -0.07471562f, 0.05592670f, 
    -0.25945252f, 0.02916900f, -0.07017496f, -0.01049339f, 0.02544695f, -0.07584848f, -0.02892274f, -0.03897777f, 
    0.18715200f, -0.21577953f, -0.21808541f, -0.17659849f, 0.10369957f, 0.13916589f, 0.18596226f, -0.21164042f, 
    0.04228534f, 0.06271763f, -0.03762502f, -0.02805683f, 0.15154229f, -0.15441528f, -0.21901171f, 0.05034495f, 
    -0.01014651f, 0.35438529f, 0.23743936f, 0.13002662f, 0.23626663f, 0.31483603f, -0.17150328f, 0.15677844f, 
    -0.37681696f, 0.03065803f, -0.23960875f, -0.13364862f, 0.01995480f, 0.07571331f, 0.01675513f, 0.07117359f, 
    0.14703210f, -0.00352073f, 0.26728147f, 0.01509314f, 0.24494685f, -0.02862862f, -0.32053494f, 0.17088871f, 
    -0.09157928f, 0.12183314f, -0.12210935f, 0.26865709f, -0.06327347f, 0.00527824f, 0.29628119f, 0.08302151f, 
    -0.42160702f, 0.31397218f, 0.25906166f, 0.14801353f, -0.06544561f, -0.06075829f, -0.06940062f, 0.06739727f, 
    -0.11449197f, -0.03457563f, 0.18389057f, 0.10395803f, -0.01935094f, -0.07308888f, -0.03518134f, -0.18264633f, 
    0.01527143f, 0.04979774f, 0.03606972f, 0.03708468f, -0.02408109f, 0.10859444f, -0.03458190f, 0.01855472f, 
    0.45625997f, 0.34110183f, 0.22286391f, 0.00418857f, 0.08820851f, -0.18269914f, 0.15457636f, -0.05051417f, 
    0.01982382f, 0.00502709f, 0.35971501f, 0.03626198f, 0.06619059f, 0.04444619f, -0.06194937f, -0.07181964f, 
    0.09117078f, -0.00723291f, 0.05287914f, 0.01821255f, -0.06132502f, -0.02267853f, 0.09799767f, -0.15298246f, 
    0.65455192f, -0.53367168f, -0.34633714f, -0.23232509f, 0.05170255f, -0.01770638f, 0.26451990f, -0.03627848f, 
    0.10533298f, -0.06283173f, -0.13705924f, -0.01417584f, -0.65235329f, 0.38698003f, -0.23385231f, -0.39573488f, 
    -0.04881928f, -0.05771410f, -0.17505294f, 0.16313770f, -0.02873427f, 0.03955279f, 0.08106223f, -0.14846590f, 
    -0.05643091f, -0.00456377f, 0.02122372f, 0.07629906f, -0.00986079f, 0.02844827f, 0.03078536f, 0.10328504f, 
    0.19848551f, 0.06472491f, 0.09379992f, -0.07284151f, -0.15453035f, -0.45810983f, -0.80008352f, -0.44843632f, 
    -0.39809680f, 0.18786575f, 0.11549290f, 0.02644159f, -0.06049563f, 0.02152157f, 0.00903689f, -0.07450862f, 
    -0.93807989f, -1.03030479f, -0.16102578f, -0.35569835f, -0.15390675f, -0.36598733f, -0.34511346f, -0.49686384f, 
    -0.12620151f, -0.02102862f, -0.08145063f, -0.01444247f, -0.46536115f, -0.82946587f, -0.60350209f, -0.17675452f, 
    -0.22446570f, -0.13818647f, -0.05188394f, -0.47846845f, 0.02190889f, 0.00499012f, -0.02854312f, -0.00265266f, 
    0.12657863f, -0.07294888f, 0.07503185f, -0.03699605f, -0.08149686f, -0.19899558f, -0.07155262f, 0.14698590f, 
    -0.10250232f, 0.18038622f, -0.13761602f, -0.12942468f, -0.53781945f, -0.17471868f, 0.33323005f, 0.03215418f, 
    0.25975600f, 0.11313975f, 0.02377214f, -0.15842965f, -0.01115510f, 0.15671614f, 0.11562177f, 0.00513532f, 
    0.25863665f, 0.12671456f, -0.18473318f, -0.24758439f, 0.05487340f, 0.06919888f, 0.09152091f, 0.07091209f, 
    0.00352234f, -0.03473895f, 0.02924889f, 0.11181051f, 0.07644568f, -0.23250055f, -0.29946849f, 0.08207566f, 
    -0.01060016f, 0.27411690f, 0.20280246f, -0.02734018f, -0.07900827f, -0.17570671f, 0.03577526f, 0.00304295f, 
    0.01631001f, -0.05603947f, -0.05014503f, -0.03501813f, 0.00111946f, 0.00040069f, 0.00012095f, 0.00957817f, 
    -0.05123334f, -0.15168512f, -0.04287793f, -0.36217922f, 0.04619501f, 0.05715724f, 0.07062569f, 0.11306853f, 
    -0.03078356f, -0.14684319f, 0.03790214f, 0.27866206f, -0.00036883f, -0.18811932f, 0.18227871f, 0.06626170f, 
    -1.16826999f, 0.60363734f, 0.21656336f, -0.00901833f, 0.02537452f, -0.37977451f, -0.02770719f, 0.00844563f, 
    -0.06284839f, 0.04999269f, 0.03929738f, -0.02268928f, -0.07845885f, 0.16973622f, 0.32098940f, -0.22539981f, 
    -0.22656137f, -0.06646124f, -0.06817576f, 0.03189261f, -0.08689073f, -0.01604983f, -0.15352626f, -0.00240598f, 
    0.14868943f, -0.06456092f, 0.05114604f, -0.05160138f, -0.10212522f, 0.07204427f, 0.06288910f, 0.04973607f, 
    -0.03378826f, -0.00719348f, 0.07537814f, 0.00689118f, 0.40633565f, 0.05913553f, 0.16500427f, -0.41076747f, 
    -0.02886066f, -0.00394144f, -0.10806040f, -0.10447129f, -0.26814628f, 0.07360998f, 0.02345190f, -0.26847416f, 
    -0.24660580f, -0.24994911f, -0.48925319f, -0.32107165f, 0.05462516f, 0.03565728f, 0.15797049f, 0.13457574f, 
    -0.02325060f, -0.08692072f, -0.11257380f, 0.15188567f, 0.79029107f, -0.75212568f, -0.33390677f, -0.30752850f, 
    -0.17002128f, -0.13349369f, -0.11823957f, 0.02363200f, 0.05016547f, 0.08624084f, 0.05117116f, -0.03308606f, 
    0.52617347f, 0.14883664f, -0.27594188f, 0.73271781f, 0.08082362f, 0.06818800f, 0.20659463f, -0.16795918f, 
    -0.22750746f, 0.14753342f, 0.06921016f, -0.04427747f, -0.32740971f, -0.41947281f, -0.56832051f, -0.59138119f, 
    -0.00528139f, 0.24439520f, -0.22440477f, 0.20765400f, 0.11605218f, -0.01819944f, 0.06630939f, -0.02852913f, 
    -0.50947189f, -0.10258265f, 0.06844599f, 0.00962311f, 0.14009829f, 0.01717575f, 0.06761526f, -0.02518668f, 
    -0.01893492f, 0.03974365f, -0.05852060f, -0.00605106f, -0.41246834f, -0.02768098f, -0.27619201f, -0.17905787f, 
    0.02420078f, 0.06024038f, 0.10334923f, 0.23201266f, -0.04023108f, 0.01328593f, 0.11915413f, 0.04840306f, 
    0.74112165f, -0.72399586f, -0.63734579f, -0.58558643f, -0.00157475f, -0.06645162f, -0.13611344f, 0.04850211f, 
    0.15587172f, -0.00267107f, -0.03501536f, -0.16421612f, 0.05328394f, 0.13678798f, 0.02194351f, 0.00721495f, 
    -0.15882276f, -0.24258335f, 0.02591426f, 0.08505485f, -0.00607783f, 0.06212358f, 0.05736393f, -0.08085494f, 
    0.01072066f, 0.14433402f, -0.01440352f, -0.17706504f, -0.07791711f, -0.00690670f, -0.07850094f, -0.01868431f, 
    0.05574520f, 0.03333008f, 0.00128638f, 0.03370593f, 0.18197528f, -0.02888311f, 0.07540952f, -0.22200061f, 
    -0.06093484f, 0.12897789f, -0.12586410f, -0.05233705f, -0.10791332f, -0.01212628f, 0.00913608f, 0.13818268f, 
    0.22507134f, -0.39853060f, 0.17708778f, -0.24322584f, 0.01988112f, -0.01839772f, -0.04503745f, 0.02745547f, 
    0.02849271f, 0.13871868f, 0.14683214f, -0.00311954f, 0.08099372f, -0.36807629f, 0.01893070f, -0.15352514f, 
    0.04953051f, 0.04457016f, 0.00615999f, -0.03673885f, -0.06867611f, -0.11896864f, -0.12074830f, -0.18229318f, 
    0.33008853f, -0.33199930f, -0.10595003f, -0.30600989f, 0.02683482f, 0.03300244f, -0.05457269f, -0.00178086f, 
    -0.09425302f, 0.00115841f, 0.10303021f, 0.05802282f, -0.52212960f, 0.08633018f, 0.04449284f, 0.13075238f, 
    0.01558356f, -0.03255585f, 0.12424769f, -0.02776629f, 0.02259064f, 0.02865018f, 0.08055523f, -0.00412739f, 
    -0.05597714f, 0.33251831f, 0.25863898f, 0.20426933f, -0.04584184f, 0.19928277f, 0.08996674f, 0.00463555f, 
    -0.14890994f, 0.16030945f, -0.02226378f, -0.01431809f, 0.11184493f, 0.05864384f, -0.18338889f, -0.11957842f, 
    -0.02457860f, 0.02330641f, 0.00103911f, -0.02689375f, -0.05635030f, 0.10456536f, -0.26883855f, -0.27949470f, 
    -0.38094819f, 0.18537401f, -0.14459787f, 0.21644209f, -0.29369119f, -0.08753701f, -0.16385648f, 0.06857502f, 
    0.03493082f, 0.05165374f, 0.08682571f, 0.02940299f, -0.15534075f, -0.51066762f, -0.56864321f, 0.40554816f, 
    -0.08536164f, -0.04937136f, 0.03533536f, -0.05494234f, -0.01228898f, 0.00255904f, 0.06629699f, -0.03622781f, 
    0.35353607f, -0.13865893f, 0.11461928f, -0.05963312f, 0.03598519f, 0.04025323f, -0.04339306f, -0.02935236f, 
    0.19142659f, -0.13961874f, 0.00106635f, 0.10938563f, -0.69917464f, -0.23605315f, -0.15228145f, 0.16241316f, 
    0.07787110f, 0.10683961f, 0.12342262f, 0.01387028f, 0.06184209f, -0.03805197f, 0.04962041f, 0.06529270f, 
    -0.68125391f, -0.55887824f, 0.14424801f, 0.64731526f, 0.05715704f, 0.04678822f, 0.00514865f, 0.02211689f, 
    -0.06425487f, -0.03177532f, -0.00210672f, 0.03474448f, -0.32901624f, -0.42394844f, -0.24811853f, 0.02296519f, 
    0.21043102f, -0.10940535f, 0.16873512f, 0.29644352f, -0.04586111f, -0.05500408f, -0.11585322f, -0.06600730f, 
    -0.02902544f, 0.03062296f, -0.02530778f, 0.04843487f, -0.01620002f, -0.08544038f, 0.07508768f, -0.01547458f, 
    0.01426534f, -0.11380395f, -0.05674034f, -0.04752414f, 0.02941396f, 0.19962099f, -0.25354072f, -0.09725668f, 
    0.00728230f, -0.36269408f, 0.20906392f, 0.06074081f, -0.01550410f, 0.13080083f, 0.04921846f, 0.06973826f, 
    -0.08074791f, 0.09703432f, -0.08885564f, 0.00284270f, -0.02958541f, 0.06240543f, -0.06256333f, -0.03118156f, 
    0.08597649f, 0.02148797f, -0.04744208f, -0.17485356f, 0.02759904f, -0.05606851f, 0.03494184f, -0.05627247f, 
    -0.07242731f, 0.01039382f, -0.03869749f, -0.16019389f, 0.00290113f, -0.03593729f, -0.07782469f, 0.08558554f, 
    0.07646797f, 0.06100875f, 0.05339317f, -0.08949014f, -0.02686522f, -0.00099404f, -0.00157022f, -0.02760881f, 
    0.04024350f, -0.13323957f, -0.05872320f, -0.13086535f, 0.20242471f, -0.10696074f, -0.48745355f, -0.11741850f, 
    -0.00796226f, 0.01479026f, 0.00008492f, -0.15995501f, -0.19110684f, 0.07583058f, -0.17252982f, -0.15079290f, 
    -0.01472912f, -0.11896510f, 0.12121717f, 0.06440374f, 0.17177078f, 0.37078762f, -0.05497803f, -0.10128732f, 
    -0.06233050f, 0.13610934f, 0.04684568f, 0.13508667f, -0.15393622f, -0.18109228f, 0.03991253f, 0.18147002f, 
    -0.06771087f, 0.01101128f, -0.03799003f, 0.03448831f, -0.02751516f, 0.05266614f, 0.02468979f, 0.02602789f, 
    -0.32477638f, -0.19500209f, -0.11255599f, -0.00257295f, 0.08625867f, 0.02994475f, -0.02923792f, 0.00283883f, 
    0.15768307f, 0.22542061f, 0.08334377f, 0.24220681f, 0.26481920f, -0.02266452f, -0.20461972f, -0.20995110f, 
    -0.10905661f, -0.17251575f, 0.17229454f, 0.05665085f, 0.12342506f, 0.00522752f, -0.16837642f, 0.08816390f, 
    0.09736218f, -0.33226690f, -0.56969613f, -0.37990203f, -0.04128668f, 0.02942005f, 0.06856796f, -0.10364332f, 
    -0.16514997f, -0.02649087f, -0.13027252f, -0.18616605f, -0.26518148f, -0.57003808f, -0.69454867f, -0.06383168f, 
    0.09120404f, 0.12380382f, 0.16479947f, 0.15834290f, 0.01474510f, -0.01145488f, -0.17085998f, -0.02371064f, 
    0.94138747f, 0.08104279f, -0.37998331f, -0.09528206f, 0.26744971f, 0.04591214f, 0.23075934f, 0.12835744f, 
    0.07883544f, 0.09434187f, 0.11605467f, 0.23212552f, -0.12679161f, -0.71851158f, -0.44157144f, 0.44215876f, 
    -0.02258981f, -0.02696932f, 0.18454672f, 0.05654009f, -0.12199693f, -0.02206950f, -0.01376519f, 0.08973106f, 
    0.61444962f, 0.17366378f, -0.20731407f, 0.17147471f, -0.04206799f, -0.08082017f, 0.11318169f, -0.21832092f, 
    0.15609524f, 0.00581187f, 0.01157275f, 0.04825303f, -0.17769065f, -0.28519988f, -0.08033472f, 0.02047466f, 
    -0.12260061f, 0.02751819f, 0.02976957f, 0.13049720f, -0.30059665f, -0.24929465f, -0.18986946f, -0.15248008f, 
    -0.49784711f, -0.35646775f, -0.27928591f, 0.33448726f, -0.06016237f, 0.13533017f, 0.13104083f, 0.00354604f, 
    0.05373895f, 0.03103390f, -0.11887530f, -0.15518390f, -0.04673288f, -0.05828753f, -0.02451809f, -0.05552096f, 
    0.04717327f, 0.04129910f, -0.00403612f, -0.07576342f, 0.14100528f, 0.10971902f, 0.05477157f, 0.15775427f, 
    -0.55610681f, -0.00083493f, 0.13004948f, 0.10727257f, -0.08526045f, -0.05960063f, -0.17733194f, -0.15039992f, 
    -0.14449595f, 0.00753358f, -0.08540961f, -0.05086017f, 0.00161601f, -0.09655516f, -0.01652658f, -0.07682054f, 
    0.19573162f, -0.01353586f, 0.00708516f, -0.06846955f, -0.19406492f, 0.03387956f, -0.24010693f, 0.00607617f, 
    0.34659600f, 0.09518551f, 0.09059305f, -0.17201696f, 0.07035664f, -0.06492095f, 0.09784754f, -0.01955955f, 
    0.09013584f, -0.18022829f, -0.13780004f, -0.44216195f, 0.35645378f, 0.01909563f, -0.27758113f, -0.29948968f, 
    0.04703346f, -0.09512492f, -0.07253910f, -0.07380456f, 0.07868874f, -0.00944813f, 0.19783597f, 0.26078838f, 
    -0.16246746f, -0.40342808f, -0.29359826f, -0.13495432f, -0.07088476f, 0.02303468f, 0.06423438f, -0.00116872f, 
    0.25332320f, -0.12064512f, 0.15212631f, -0.03101452f, -0.59356964f, -0.15002179f, 0.01009292f, 0.18489915f, 
    -0.04054277f, 0.04538770f, 0.06027362f, 0.02002574f, 0.04621267f, 0.03977538f, 0.05876275f, 0.03576568f, 
    -0.77741504f, -0.47499526f, 0.43801317f, 0.32844979f, 0.03461955f, -0.02557589f, -0.09212584f, -0.04575225f, 
    0.19060941f, 0.02334863f, 0.07573142f, 0.07584342f, 0.26924121f, -0.10325821f, -0.23361047f, -0.26956752f, 
    -0.16613048f, -0.04306959f, 0.03780246f, 0.02687334f, 0.00432702f, -0.00884935f, 0.05949675f, 0.05462749f, 
    -0.35387930f, -0.15752545f, 0.07261036f, 0.16152331f, 0.14805441f, -0.14069702f, -0.31219244f, 0.14027949f, 
    -0.06844498f, 0.08199952f, 0.10706826f, 0.05067470f, 0.19292636f, -0.93479055f, -0.82692200f, -0.34327042f, 
    0.16006595f, 0.07200032f, 0.15768293f, 0.08668014f, 0.06715309f, 0.12971602f, 0.03317789f, 0.19355430f, 
    -0.19220464f, -0.16193390f, -0.00163644f, -0.03141424f, 0.06854345f, -0.04893465f, 0.03953102f, 0.02212730f, 
    -0.22295630f, -0.00010230f, -0.12651151f, -0.44670779f, -0.11837826f, 0.15543050f, 0.32827803f, 0.19673374f, 
    -0.04359180f, -0.17957249f, 0.00980180f, -0.08742051f, -0.04234512f, 0.04341108f, 0.07094263f, -0.01513431f, 
    0.09617206f, -0.59656626f, -0.46433574f, -0.21755368f, -0.04094934f, -0.05661480f, 0.01542777f, 0.21255119f, 
    0.02359511f, 0.18220961f, 0.01397012f, 0.10456228f, 0.09602466f, 0.03782055f, -0.28575000f, -0.32518137f, 
    -0.19241144f, -0.17958260f, -0.02088434f, -0.25411600f, 0.03852703f, -0.06987353f, 0.02133886f, 0.10951394f, 
    0.01008323f, -0.05685944f, -0.00403309f, 0.07986113f, 0.07654525f, 0.01257256f, -0.14565612f, 0.08953296f, 
    0.08679118f, 0.21427126f, 0.10843915f, 0.14247741f, 0.06919716f, -0.00454979f, -0.14744890f, -0.13550211f, 
    0.02867733f, -0.00749691f, 0.09074352f, -0.25595611f, -0.01521828f, -0.16293868f, -0.14294857f, 0.09587698f, 
    -0.17982529f, 0.21768636f, -0.10788569f, -0.04732348f, 0.04293526f, 0.00027489f, -0.00303099f, 0.06956318f, 
    -0.04906372f, -0.01414206f, 0.06642278f, 0.07415573f, -0.29948914f, -0.08259597f, 0.00716693f, -0.02719272f, 
    0.07556032f, -0.05816280f, 0.07172915f, -0.15671174f, -0.14898138f, -0.07070512f, -0.13582481f, -0.29113168f, 
    -0.02321349f, -0.12309132f, -0.07945950f, -0.22753049f, -0.01306401f, 0.00271112f, -0.00266251f, -0.07930798f, 
    -0.00990768f, 0.13236323f, 0.15028241f, 0.07599340f, 0.59829342f, -0.02748045f, -0.19372138f, 0.10725468f, 
    0.03499557f, 0.02919571f, -0.05627046f, -0.12161652f, 0.42976156f, -0.09809085f, 0.24200614f, -0.20254903f, 
    -0.05557242f, -0.17574999f, 0.12048405f, -0.99896526f, -0.04684740f, -0.15948872f, 0.02307571f, 0.07995443f, 
    0.06185198f, 0.09357453f, -0.10720902f, -0.14129399f, 0.17767708f, -0.25030893f, -0.04218753f, -0.06959869f, 
    0.04017287f, 0.28198269f, -0.19141677f, 0.05579020f, -0.01650010f, -0.09536827f, -0.15403174f, -0.03227988f, 
    0.19630447f, 0.13316195f, 0.02607212f, -0.18457763f, -0.04036193f, -0.12510186f, 0.07221380f, -0.08370326f, 
    -0.01254028f, -0.04071559f, -0.15807493f, -0.12531890f, -0.12429294f, 0.03553765f, -0.45244646f, 0.37992531f, 
    0.03655892f, 0.25470841f, -0.11679627f, -0.24272564f, 0.12671731f, -0.04712189f, -0.13596669f, -0.09513300f, 
    -0.35711241f, 0.05489502f, 0.13788122f, -0.41247529f, -0.04496402f, 0.04862874f, -0.16092032f, -0.08055837f, 
    0.21433641f, 0.07194874f, 0.20117848f, 0.10327408f, 0.40735775f, -0.00281351f, 0.40807849f, 0.18050289f, 
    0.05015699f, -0.16563852f, -0.15847081f, -0.16568978f, 0.07154059f, -0.00105033f, -0.02302292f, 0.00020370f, 
    -0.71326154f, -0.06794348f, -0.92307997f, 0.35267410f, 0.13075820f, -0.03863168f, -0.07463846f, -0.18188475f, 
    0.05466579f, -0.01073741f, -0.10137318f, -0.10892649f, -0.16817601f, -0.11266247f, -0.15125857f, -0.86501461f, 
    -0.34118250f, 0.25933048f, -0.15126120f, 0.25132778f, 0.18324564f, -0.07296547f, -0.03311345f, 0.01393354f, 
    0.03024491f, -0.34302294f, -0.30415711f, 0.00693916f, 0.22265074f, -0.19875157f, 0.12989955f, -0.08469816f, 
    -0.00299847f, 0.01119030f, -0.07947112f, -0.24652368f, 0.00782031f, 0.26838717f, 0.34259346f, -0.34694117f, 
    -0.06848356f, -0.17848831f, 0.11136466f, 0.11898962f, -0.01435160f, 0.14335649f, -0.00618152f, 0.08390788f, 
    0.09727678f, 0.09467056f, 0.31305355f, 0.03003319f, 0.03030762f, -0.19256914f, -0.15531841f, -0.11832860f, 
    -0.09810057f, -0.00920424f, 0.01990354f, -0.07075391f, -0.16591720f, -0.19188870f, 0.03600617f, 0.03801697f, 
    0.28247690f, 0.20772924f, 0.03012346f, 0.13293582f, 0.06246687f, -0.19547307f, -0.00933069f, -0.09442018f, 
    -0.09438574f, -0.40928990f, 0.09473639f, -0.08237191f, 0.10744070f, 0.24822240f, 0.14723727f, 0.18287168f, 
    -0.00375792f, -0.04235595f, -0.15015541f, 0.02765744f, -0.04214347f, -0.18704213f, 0.15260687f, -0.14126515f, 
    0.02145321f, 0.35597262f, -0.13544156f, -0.28653392f, 0.10779794f, -0.08690978f, -0.09092077f, 0.11273389f, 
    -0.09302801f, -0.39488953f, 0.31604823f, 0.30057794f, -0.04211067f, 0.04886880f, -0.03638580f, -0.09938821f, 
    -0.15860519f, 0.15703444f, 0.18760788f, 0.05017835f, 0.07649504f, 0.30432138f, 0.11258252f, 0.20926479f, 
    0.02871156f, -0.23378256f, 0.05666472f, -0.29697949f, 0.18693210f, -0.05973781f, 0.03826963f, 0.07441527f, 
    0.34156752f, -0.01604418f, 0.42049688f, 0.23243596f, -0.15309913f, 0.00379529f, -0.33307272f, -0.16332509f, 
    -0.06913705f, -0.19483966f, -0.04417588f, 0.13509046f, -0.18340310f, 0.12139156f, -0.00294248f, -0.31998882f, 
    0.20561509f, -0.17295748f, 0.18521084f, -0.06085610f, -0.10695551f, 0.01992059f, 0.00959083f, 0.06002327f, 
    -0.04064603f, -0.42771149f, 0.03281887f, -0.63239723f, -0.14207441f, 0.13180338f, 0.09860997f, 0.13400252f, 
    -0.04791588f, 0.03674261f, 0.04148311f, 0.12209437f, -0.32008034f, 0.10099512f, 0.16905937f, 0.33206332f, 
    0.13231577f, 0.09218741f, -0.19107047f, -0.04652049f, -0.04709294f, -0.01321521f, 0.05068982f, -0.02725266f, 
    0.00716786f, 0.97378230f, -0.65517294f, -0.03659112f, -0.07023327f, 0.01364217f, 0.17362331f, 0.00382128f, 
    0.06731975f, -0.06786854f, -0.06896943f, 0.08110648f, -0.31772757f, -0.25993881f, 0.52335155f, 0.18008921f, 
    0.05175998f, -0.43214372f, 0.01372219f, -0.08275691f, -0.08574583f, -0.03413737f, -0.02413096f, -0.02967086f, 
    -0.10214510f, 0.06245776f, 0.20982048f, 0.28777269f, -0.12925841f, 0.08379065f, -0.06132984f, -0.11341849f, 
    0.11776086f, -0.05291869f, 0.13787961f, -0.01830391f, -0.28011706f, 0.08389468f, -0.86260700f, 0.23535578f, 
    0.07195687f, -0.02788011f, 0.24646159f, -0.05172636f, -0.02803055f, -0.06123599f, 0.00430384f, 0.06225326f, 
    0.20591788f, 0.07403018f, 0.01059207f, -0.24263227f, 0.00471730f, -0.25551528f, 0.16036221f, 0.24362005f, 
    -0.04671928f, 0.01719798f, 0.01681301f, -0.06005617f, -0.34596047f, 0.15569595f, 0.19753863f, 0.37956741f, 
    -0.10117798f, -0.16201437f, 0.07052384f, 0.13799416f, 0.02094103f, 0.11504589f, 0.06223409f, -0.01508935f, 
    -0.21639249f, -0.16608858f, -0.22336271f, 0.16758575f, 0.13149908f, -0.00380645f, -0.04327103f, 0.07512800f, 
    0.11274432f, -0.26747623f, -0.32128385f, -0.19537303f, -0.49062130f, -0.33266759f, -0.11404179f, -0.40671432f, 
    0.21198322f, -0.01578824f, 0.04521427f, 0.34199569f, -0.07906663f, 0.02660086f, -0.15511258f, 0.17935035f, 
    -0.16850871f, 0.14205819f, -0.16153245f, 0.19721849f, -0.02763082f, 0.13484187f, 0.05702341f, -0.07100011f, 
    0.13710387f, 0.03611731f, -0.01527232f, -0.04139242f, 0.10621321f, -0.00139442f, -0.32870197f, -0.11987416f, 
    0.02979793f, 0.16546622f, 0.30137655f, 0.16235629f, 0.08618897f, 0.15891336f, 0.03800802f, -0.05397879f, 
    -0.01093305f, 0.06598490f, 0.01984740f, 0.04488977f, 0.19145131f, 0.14916578f, -0.16561411f, -0.25757027f, 
    0.14834489f, -0.20549271f, -0.18853939f, -0.21582356f, -0.50230843f, -0.14550088f, -0.07881656f, 0.13401420f, 
    0.23656352f, -0.06559081f, 0.01389266f, -0.19239691f, -0.07646333f, -0.14031139f, 0.20098838f, 0.08357409f, 
    0.02795002f, 0.06232016f, 0.68558657f, 0.53228664f, -0.08813296f, 0.13895270f, -0.03216814f, 0.03076034f, 
    -0.04800526f, 0.05436322f, 0.16139109f, 0.00847910f, -0.08835749f, 0.08164993f, 0.40869948f, 0.25744843f, 
    -0.01723127f, 0.41621518f, -0.02239220f, -0.09235716f, -0.26501185f, -0.14245778f, 0.24373938f, 0.08199923f, 
    0.06423280f, 0.18695775f, -0.14879245f, 0.01663704f, 0.07903463f, 0.06328613f, 0.04749212f, -0.03057831f, 
    0.11540348f, 0.25828588f, 0.23507625f, 0.32860073f, 0.03684176f, 0.50849676f, -0.07963973f, 0.25750417f, 
    -0.00579893f, 0.07976552f, 0.21974567f, 0.21246423f, -0.16139843f, 0.15481894f, 0.26603204f, 0.20148093f, 
    0.21803300f, -0.50762689f, 0.00065354f, -0.07142351f, -0.01110644f, -0.04162652f, -0.02776718f, 0.14105111f, 
    -0.08609794f, 0.13744962f, -0.15099390f, -0.36115476f, -0.00296225f, 0.16337496f, 0.21318235f, 0.14923234f, 
    -0.06501489f, -0.25678694f, -0.04544416f, 0.09433265f, -0.12746082f, 0.12999998f, 0.12330650f, -0.12365194f, 
    -0.02531155f, 0.43478626f, 0.38951302f, 0.05270084f, -0.16250300f, -0.04381336f, 0.02236057f, 0.22399698f, 
    -0.17572987f, 0.04410199f, -0.12421184f, 0.11581728f, 0.27879179f, -0.24544303f, 0.12591545f, 0.30978590f, 
    0.15971294f, -0.29970697f, 0.10060140f, -0.00452404f, -0.14114894f, 0.13974757f, -0.08842293f, -0.00082901f, 
    -0.78161824f, -0.31505471f, -0.06718189f, 0.06972795f, -0.01146645f, 0.38324180f, -0.17649531f, 0.12420923f, 
    0.02989909f, 0.10906997f, 0.01859113f, -0.12493573f, -0.18745881f, -0.09694362f, 0.13238113f, 0.03789359f, 
    0.07499223f, 0.25785342f, -0.03750211f, 0.04219553f, -0.11243749f, 0.00323865f, 0.00776855f, -0.17915641f, 
    0.19537501f, 0.13501893f, 0.07460655f, -0.20389418f, 0.09675515f, -0.11137937f, -0.05973607f, 0.03769230f, 
    -0.00818636f, -0.11964004f, -0.10677598f, -0.28122684f, -0.08508581f, -0.16267860f, 0.05684354f, -0.11535714f, 
    -0.25158635f, -0.00247549f, 0.04558359f, -0.09755347f, 0.03983074f, -0.00636895f, 0.18629381f, 0.10233235f, 
    0.02243968f, -0.30223155f, 0.08947229f, -0.01064974f, -0.33346730f, -0.01233518f, -0.11510314f, -0.13350861f, 
    -0.02820613f, -0.12573320f, -0.02994229f, -0.06960106f, -0.36517823f, 0.23863383f, -0.29199505f, -0.09995238f, 
    -0.01374555f, -0.04828873f, -0.04410756f, -0.01605833f, 0.06039451f, -0.11680180f, -0.16191274f, 0.03896774f, 
    -0.33120450f, 0.41608557f, -0.01273101f, -0.05453402f, -0.03593427f, 0.07829107f, 0.00511539f, -0.00900707f, 
    0.05878422f, -0.25526515f, -0.36835617f, -0.62612689f, -0.35003647f, 0.13142690f, -0.22290659f, -0.10313246f, 
    -0.22773327f, 0.03098049f, -0.04467501f, -0.09109061f, 0.03069828f, -0.02380388f, -0.07906947f, -0.14769930f, 
    -0.56557482f, 0.39308023f, 0.02764621f, -0.25256109f, 0.06115328f, 0.22421041f, -0.23564704f, -0.07389775f, 
    -0.10416231f, 0.08880989f, 0.03574549f, -0.09129404f, 0.04618765f, 0.27762958f, 0.07719519f, 0.07520215f, 
    -0.14471434f, -0.13199820f, -0.09147371f, 0.00811979f, -0.11457780f, -0.02368631f, 0.17444475f, 0.00043363f, 
    0.07463007f, 0.01487322f, -0.00010767f, 0.39337042f, 0.14056484f, 0.07248510f, -0.41171813f, 0.02270098f, 
    0.02761490f, -0.06793187f, -0.21261477f, -0.22384936f, -0.10065798f, -0.08987077f, 0.28246036f, -0.15827401f, 
    -0.12299984f, -0.04842715f, -0.10791084f, 0.03474041f, 0.15055354f, -0.14179853f, -0.03838063f, 0.10288320f, 
    -0.10976786f, -0.55868959f, 0.22726464f, -0.02383548f, -0.00527840f, 0.03323640f, 0.21102816f, -0.02763083f, 
    -0.10629301f, 0.12657307f, 0.01770978f, 0.07736538f, -0.33692017f, -0.20182154f, 0.08328117f, 0.14121930f, 
    0.01397992f, 0.11855984f, 0.05579876f, -0.00664637f, 0.05303123f, 0.00334605f, 0.05687447f, 0.07426182f, 
    -0.03231404f, 0.05029948f, 0.00250674f, -0.39675444f, -0.00222118f, -0.00235547f, -0.08462770f, 0.02895600f, 
    -0.19655067f, -0.12958220f, -0.32598600f, -0.21908405f, 0.12002400f, 0.00816788f, -0.23808093f, 0.06161121f, 
    -0.21123989f, 0.04526054f, 0.23377885f, -0.14500839f, 0.03098146f, 0.10244606f, -0.10789407f, 0.05718267f, 
    -0.27195045f, -0.21059616f, 0.05981329f, 0.35869405f, -0.16344418f, -0.02484440f, 0.02722171f, -0.02066879f, 
    0.08501179f, 0.21335047f, 0.04169900f, 0.21890905f, -0.43660200f, -0.22060062f, -0.73827899f, 0.01740331f, 
    -0.05741860f, 0.16767909f, -0.46169379f, -0.08838370f, 0.02363694f, 0.13368131f, 0.02864166f, -0.01765620f, 
    0.10950913f, -0.20658354f, 0.15834656f, -0.24295776f, -0.16239753f, 0.04372293f, 0.05751791f, -0.04310489f, 
    -0.16685894f, -0.16904865f, 0.08494224f, 0.31317252f, -0.58014536f, -0.07472656f, 0.15454324f, 0.48388517f, 
    -0.16364220f, -0.01101403f, -0.35977432f, 0.27534929f, -0.09683302f, -0.17129494f, -0.01844978f, 0.09111015f, 
    -0.11159872f, -0.46561006f, -0.09766308f, -0.12093101f, -0.20799375f, -0.15485306f, 0.00148969f, -0.01646941f, 
    -0.04310563f, -0.11242039f, -0.01374424f, 0.01249346f, -0.24734470f, -0.22633982f, -0.17113873f, -0.32072133f, 
    -0.03280286f, -0.10547565f, -0.01953804f, -0.02708215f, -0.49405047f, -0.26512763f, -0.28873649f, 0.01645554f, 
    -0.14721023f, -0.28475797f, -0.30018014f, 0.23702009f, -0.24153854f, -0.06181357f, 0.26104933f, -0.14373051f, 
    0.03264267f, 0.01853614f, -0.23152231f, 0.36480826f, -0.53009409f, 0.23372246f, 0.52469522f, 0.00387173f, 
    -0.06874257f, -0.09170660f, 0.07508653f, 0.25590366f, 0.00867637f, 0.00748598f, -0.07018971f, 0.10309564f, 
    -0.25622305f, 0.16364533f, -0.32967150f, 0.41352010f, -0.37041304f, 0.21014212f, -0.38578850f, -0.16952118f, 
    0.03004197f, -0.07803451f, 0.07661337f, -0.07685688f, -0.79763609f, 0.45259389f, -0.12577957f, 0.20111319f, 
    -0.18499571f, -0.11996029f, 0.54780310f, -0.14852956f, -0.08252645f, 0.10876122f, -0.05452371f, -0.20994318f, 
    -0.01096072f, -0.00509415f, -0.12669127f, -0.09459806f, 0.04048818f, -0.00975343f, -0.11202364f, 0.05257037f, 
    -0.18862125f, -0.03010794f, -0.26314896f, -0.18783103f, -0.65674603f, -0.18158679f, -0.05399683f, 0.17481560f, 
    0.07681418f, -0.01230000f, 0.12136550f, -0.12185805f, -0.19444092f, -0.07389136f, 0.23232371f, 0.11333826f, 
    -0.13243371f, 0.01156515f, -0.01125223f, -0.22532311f, -0.13240671f, 0.01027727f, 0.18775779f, 0.12308047f, 
    0.10475864f, 0.11473075f, 0.12473728f, -0.11285262f, -0.36076802f, 0.31558275f, -0.04630993f, 0.04219307f, 
    -0.05555231f, -0.10157195f, 0.04989391f, 0.04203438f, -0.20578662f, -0.12192460f, 0.11507750f, -0.19208685f, 
    -0.30456015f, -0.48313430f, 0.25883338f, -0.37436625f, 0.10530485f, 0.11479352f, 0.06209847f, 0.03292227f, 
    -0.08821844f, -0.06129377f, 0.15530547f, 0.07934670f, -0.08523264f, 0.25387371f, 0.13415910f, -0.07141531f, 
    0.05830049f, 0.06946426f, 0.15007095f, -0.17672987f, 0.05912625f, 0.03762131f, -0.09042965f, -0.14296657f, 
    0.56916058f, -0.10698327f, 0.52510506f, -0.31505999f, -0.03378322f, 0.09996112f, -0.17278804f, -0.07063958f, 
    0.03066491f, -0.06054796f, 0.09161997f, 0.00847300f, -0.22202751f, -0.45568731f, -0.01827690f, 0.12319318f, 
    -0.23872299f, -0.19089624f, 0.00690466f, 0.00488158f, -0.07556937f, -0.01464925f, -0.09708091f, -0.08310524f, 
    -0.53663880f, 0.32936230f, -0.71146703f, -0.42187625f, 0.11477865f, -0.14148475f, -0.05861442f, -0.10872378f, 
    -0.06660239f, 0.12836646f, 0.09000499f, 0.09748648f, -0.13754448f, 0.26598141f, -0.13999453f, -0.13241202f, 
    -0.01297996f, 0.01961494f, -0.00235262f, -0.11158882f, -0.15751259f, -0.00068172f, -0.09469846f, -0.25210041f, 
    0.17665365f, 0.38233471f, 0.14749771f, -0.18074557f, 0.01198575f, -0.08680920f, -0.03900483f, 0.11088574f, 
    -0.08637227f, 0.07018041f, 0.10526042f, -0.20218913f, -0.08632012f, -0.03651616f, -0.16790321f, 0.14887145f, 
    0.18939807f, -0.03458288f, 0.16301729f, -0.01026170f, 0.16155966f, 0.07121923f, -0.09181517f, -0.05376563f, 
    -0.30909249f, -0.07620594f, -0.08231574f, 0.27894083f, 0.00933072f, -0.02993829f, 0.01613401f, 0.09832813f, 
    0.26084390f, 0.02559505f, 0.17069502f, 0.27832526f, 0.34417251f, -0.09329626f, 0.02781947f, -0.17626992f, 
    -0.09420891f, -0.02912640f, -0.05862324f, 0.18510847f, 0.05640385f, 0.15027367f, 0.07230877f, -0.08263596f, 
    -0.57538420f, 0.29804918f, -0.57598656f, 0.32986307f, 0.09463098f, -0.21381435f, 0.19844253f, 0.00067913f, 
    0.02134137f, 0.04743538f, -0.28467503f, 0.11895848f, 0.18762350f, -0.12573183f, 0.72799683f, 0.12037318f, 
    0.01178636f, 0.08461556f, -0.29930034f, 0.34832802f, -0.21802050f, 0.15529281f, -0.06189929f, 0.02230999f, 
    -0.65200281f, 0.13065158f, 0.04353235f, 0.34366480f, -0.04167862f, 0.09474783f, 0.13779673f, 0.23966581f, 
    -0.29479033f, -0.02880322f, 0.09827297f, 0.22871277f, -0.29248518f, -0.07968108f, -0.30867210f, -0.04394801f, 
    0.08709172f, 0.03275362f, 0.06721310f, -0.10602515f, 0.22341771f, 0.10623106f, 0.02390790f, 0.06197501f, 
    0.30294091f, -0.02984078f, 0.59015894f, -0.19902338f, 0.19450390f, 0.02772367f, -0.00004904f, 0.04817388f, 
    -0.10134894f, -0.04021608f, -0.03394685f, 0.09935050f, -0.44113454f, -0.65553522f, 0.39603472f, -0.18039009f, 
    0.00044228f, -0.17040837f, -0.32211411f, -0.01218453f, -0.02844267f, 0.13951214f, 0.21357948f, -0.10220303f, 
    -0.07087154f, 0.01254496f, -0.19181438f, -0.06260094f, 0.02018274f, -0.05163733f, 0.07913342f, -0.11961398f, 
    0.19988783f, 0.11155444f, 0.11294514f, 0.24912855f, 0.45551819f, -0.18971652f, 0.56560367f, -0.08899748f, 
    0.06947538f, -0.27518040f, -0.12151721f, -0.06165396f, -0.11145240f, -0.06959593f, -0.02056161f, -0.10294087f, 
    -0.17573902f, -0.44253686f, -0.12636006f, 0.11143717f, -0.21239783f, -0.24813025f, -0.08852216f, -0.20072088f, 
    0.15427725f, -0.19147137f, -0.02130620f, -0.03043113f, 0.08431334f, -0.25681865f, -0.02740503f, -0.01579520f, 
    -0.21044920f, -0.09684891f, -0.25209162f, 0.12066718f, -0.04661213f, 0.02346304f, 0.05893582f, -0.13048938f, 
    0.02016507f, 0.16163002f, -0.09486358f, -0.04842305f, 0.10903654f, 0.26538977f, 0.07959346f, -0.14490758f, 
    -0.19478406f, -0.19442023f, 0.20629391f, -0.29124975f, -0.25227261f, 0.18689804f, 0.24979116f, -0.21219666f, 
    -0.14376254f, 0.04020043f, -0.02271088f, 0.32569468f, -0.07793502f, 0.03343825f, -0.13210812f, -0.04300241f, 
    0.27671859f, -0.02625674f, 0.36563110f, 0.08703309f, 0.01483831f, 0.05538770f, 0.06671964f, 0.02634495f, 
    -0.05838678f, -0.16529076f, -0.02671491f, -0.01411749f, 0.29504713f, 0.32111084f, 0.13028754f, -0.26983398f, 
    0.09653519f, -0.14573243f, 0.07004502f, 0.11107422f, 0.22592005f, 0.05475314f, 0.18372223f, -0.08176221f, 
    0.02800703f, 0.07563508f, -0.08352105f, 0.09904431f, 0.06074498f, -0.03549884f, 0.10834952f, 0.23310351f, 
    -0.00752818f, 0.02171644f, -0.11205836f, 0.00726585f, 0.13927136f, 0.10561766f, 0.19402811f, -0.10898718f, 
    0.19535655f, 0.08601891f, 0.03199021f, -0.12618853f, -0.03559666f, 0.08060511f, -0.05986384f, -0.02262390f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.20569544f, 0.08538497f, 0.09962356f, -0.11751132f, -0.06880943f, 0.10244030f, 0.02584762f, -0.15618844f, 
    0.12278610f, 0.05401885f, 0.01773736f, -0.06338023f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
