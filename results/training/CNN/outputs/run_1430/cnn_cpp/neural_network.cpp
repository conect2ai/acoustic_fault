#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.94202185f, -0.40372428f, -0.98755997f, -0.94526875f, -0.95029217f, 0.53311092f, 0.28494307f, 0.62895417f, 
    -0.02722016f, -0.04896438f, 0.06036915f, -0.27437708f, -0.23087625f, -0.36462513f, 0.19506702f, 0.24245490f, 
    0.12721264f, -0.02568231f, 0.13183145f, -0.06751778f, -0.11939669f, -0.00117914f, 0.05726642f, -0.02520161f, 
    0.36895788f, 0.79909968f, -0.02420496f, 0.05599390f, 0.53205043f, 0.65137857f, 0.16182442f, 0.26587147f, 
    0.09007419f, 0.28266260f, 0.29969805f, -0.03056708f, 0.39308682f, -0.11485123f, 0.10121918f, 0.18906845f, 
    -0.12207199f, -0.06183109f, 0.04377920f, -0.04990336f, -0.21763833f, -0.29364461f, 0.10986441f, 0.12840904f, 
    -0.24674383f, -0.25714710f, 0.11058576f, -0.41519532f, -0.92530036f, -0.16546358f, -0.58685142f, 0.31966376f, 
    0.61764461f, 0.39001986f, -0.38756886f, -0.68106782f, -0.02634653f, 0.08294393f, 0.15180916f, -0.28740293f, 
    -0.30076364f, -0.03446864f, -0.26925203f, -0.26008138f, -0.59810716f, -0.32226887f, 0.33075938f, 0.50870705f, 
    0.02293760f, 0.44523364f, -0.23239821f, -1.22430909f, -0.82133204f, -0.12603241f, 0.58911598f, 0.91446304f, 
    -0.53090954f, 0.15180136f, -0.01267585f, 0.59299093f, 0.47563562f, 0.01351920f, 0.40592113f, -0.04339733f, 
    0.58353728f, -0.09166068f, -0.34188572f, 0.12846099f, 0.17570128f, -0.37533253f, -0.25594252f, 0.08251030f, 
    0.00757072f, 0.01187954f, 0.11343094f, 0.03847969f, -0.51651341f, 0.28085205f, 0.27825516f, 0.05866075f, 
    -0.07548740f, 0.15306249f, 0.09993612f, 0.04603261f, -0.12827264f, 0.57485330f, -0.38173515f, 0.92903423f, 
    -0.49675938f, -0.48479438f, 0.38387579f, -0.17325357f, 0.00821923f, -0.38105720f, -0.17440842f, 0.10883752f, 
    -0.14772078f, 0.24086381f, 0.13422079f, 0.12981007f, -0.13979608f, -0.60243446f, -0.67804021f, -0.09818844f, 
    -0.31278956f, 0.19851352f, -0.87726843f, -0.87980652f, -0.56712580f, -0.05737996f, 0.02680409f, -0.09810015f, 
    -0.33520508f, -0.36675733f, 0.51544821f, -0.20057523f, 0.24403532f, -0.66542816f, -0.19024903f, -0.09701305f, 
    -0.28589639f, -0.11916870f, -0.26204702f, -0.40096369f, -0.42792866f, -0.03672496f, 0.11615843f, -1.04714203f, 
    -1.00440729f, -0.85675412f, -0.35717472f, 0.12793265f, 0.21449740f, 0.82114393f, 0.60682476f, 0.16523415f, 
    0.35833329f, 0.65246916f, -0.15141459f, -0.26447606f, -0.10502274f, -0.17692095f, -0.04838789f, 0.11942879f, 
    -0.20784631f, -0.03373970f, -0.27483034f, 0.02745721f, 0.00041146f, 0.00429117f, -0.15466744f, 0.89102238f, 
    0.89053845f, -0.23345520f, -0.89783609f, 0.42604649f, 0.11055629f, 0.39811879f, 0.05829892f, -0.40203300f, 
    -0.65857482f, -0.03776520f, 0.28010449f, -0.20463522f, -0.27340609f, 0.02812362f, 0.07194082f, -0.11188278f, 
    0.20965080f, -0.17140287f, -0.02840264f, -0.03422121f, -0.15639636f, -0.37167683f, -0.30658638f, -0.46552792f, 
    0.54313278f, -0.11300141f, 0.17754315f, 0.44834834f, 0.56030762f, 0.04650502f, 0.24393936f, 0.30909020f, 
    -0.42521968f, -0.06059524f, -0.14704810f, -0.00003781f, 0.09703928f, 0.21749865f, 0.37801427f, -0.17723422f, 
    -0.08641674f, -0.17983539f, -0.16710697f, -0.21441737f, 0.20530887f, -0.28741905f, -0.14648372f, 0.55028754f, 
    -0.19000845f, 0.55230254f, 0.92296475f, 0.57001632f, 0.17680393f, -0.12670381f, -0.57370603f, -0.67720044f, 
    -0.40692171f, -0.39211369f, -0.52101284f, -0.06122957f, -0.32922363f, -0.33417600f, 0.01336461f, -0.30108589f, 
    -0.08697724f, 0.10951617f, 0.33510587f, 0.30882269f, -0.21741700f, -0.08799013f, -0.10234190f, -0.13577203f, 
    -0.04948012f, -0.04988163f, 0.50525326f, -1.10672033f, -0.17696276f, -0.38242477f, 0.75034457f, -0.62664998f, 
    -0.55406880f, 0.28571570f, -0.97513056f, -0.74820310f, -0.24514319f, -0.29313824f, 0.67002624f, -0.27916226f, 
    -0.16358088f, -0.13276812f, 0.01430871f, -0.07326674f, 0.24013752f, 0.01756665f, -0.04890149f, 0.05828192f, 
    0.12900168f, 0.10640611f, 0.25988549f, -0.08299968f, 0.01312660f, 0.36834797f, 0.23894544f, -0.04647752f, 
    -0.49349570f, -0.26955643f, -0.30931595f, -0.17807540f, 0.88568264f, -0.12557329f, -0.16321334f, -0.11306444f, 
    0.18720464f, 0.50679290f, 0.44924009f, 0.08774450f, 0.27170205f, 0.15495038f, -0.66144800f, 0.25804660f, 
    0.10661203f, 0.15856515f, -0.29613385f, -0.21135072f, 0.62878662f, 0.60643035f, -0.26080391f, 0.28522959f, 
    -0.43954262f, 0.15338802f, -0.27503136f, -0.24772163f, 0.39753661f, 0.33514288f, -0.02628100f, -0.23840761f, 
    0.31934312f, 0.27426156f, -0.35167092f, -0.12326419f, -0.20629813f, -0.07528028f, 0.23218682f, -0.02454144f, 
    -0.16531651f, -0.26699042f, -0.12244444f, -0.20641825f, -0.35900876f, 0.31042004f, -0.22676444f, 0.23666017f, 
    0.09672535f, 0.45173585f, -0.35983184f, -0.04850483f, 0.25138193f, 0.19147111f, 0.28484797f, -0.32634035f, 
    -0.09471913f, 0.54668409f, -0.54222327f, -0.07809836f, 0.19625273f, -0.20834616f, -0.45917422f, 0.12707411f, 
    -0.20323989f, -0.05258298f, 0.11695907f, 0.15218228f, 0.28630409f, 0.56428891f, -0.50327593f, 0.23760459f, 
    0.39321572f, 0.68412286f, 0.41706568f, -0.09677169f, -0.74192923f, -0.51507300f, 0.31874099f, 0.29778084f, 
    -0.11677583f, -0.01621930f, -0.05674446f, -0.19349800f, -0.32690462f, -0.14575438f, 0.03487990f, 0.02161393f, 
    -0.01841537f, -0.30041927f, 0.21224445f, 0.29379231f, -0.09419782f, 0.30386406f, 0.21704714f, -0.02627398f, 
    0.71271485f, 0.52903599f, 0.09642269f, -0.33469227f, -0.23325257f, 0.10448702f, 0.21345095f, 0.15834481f, 
    0.18916534f, 0.30930009f, -0.22196147f, -0.17873867f, -0.29047292f, -0.38709700f, 0.03712266f, 0.14909750f, 
    -0.31181335f, -0.28579262f, -0.21622637f, -0.08843115f, 0.01083775f, -0.51043779f, -0.55168146f, -0.61223400f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20792563f, 0.07558782f, 0.42621887f, 0.45783186f, 0.41775951f, 0.48912841f, 0.33646750f, 0.28993118f, 
    0.48990476f, 0.02046297f, 0.27008212f, 0.39936721f, 0.32971084f, 0.44099846f, 0.35802919f, 0.16671091f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01828731f, 0.00852945f, 0.02174602f, 0.06440686f, 0.00220093f, 0.05989725f, 0.02097583f, -0.05540612f, 
    0.00424582f, 0.02472689f, -0.06127078f, 0.02583549f, -0.03011002f, -0.02013069f, -0.07892988f, -0.06019552f, 
    -0.03807199f, 0.05432834f, -0.05175899f, -0.05467656f, -0.10041821f, -0.07606049f, -0.05894125f, -0.01197733f, 
    0.03736626f, -0.07866877f, 0.00664963f, -0.04314011f, 0.02067575f, 0.00233220f, -0.07185326f, 0.05053884f, 
    0.02045541f, -0.08627644f, -0.03225449f, -0.00015674f, -0.09340198f, -0.07082258f, 0.02990073f, -0.01847951f, 
    0.00046354f, 0.03244389f, 0.04088706f, -0.10863429f, -0.03170219f, -0.02665094f, 0.04876676f, 0.03202913f, 
    -0.03607820f, 0.03164288f, -0.03277680f, -0.08014927f, 0.01384652f, -0.05372973f, -0.06249515f, 0.03232658f, 
    -0.04672321f, -0.02326309f, -0.07034302f, 0.03433480f, 0.01859512f, -0.08420141f, 0.04673751f, -0.00759893f, 
    0.02546386f, -0.01692702f, 0.04934219f, -0.04033843f, -0.00191699f, -0.10932567f, -0.00123977f, -0.00830707f, 
    0.02444792f, -0.02755045f, 0.00041128f, 0.01081550f, -0.07319221f, -0.04292117f, -0.03269790f, -0.07522921f, 
    0.06552793f, -0.00740929f, -0.05710494f, -0.10150062f, -0.08947080f, -0.08098660f, 0.00943245f, -0.01830709f, 
    -0.09177789f, -0.01167019f, 0.01088268f, 0.01605895f, -0.03807302f, -0.01823375f, -0.11844458f, -0.01404534f, 
    -0.02767212f, 0.03157471f, -0.07951046f, 0.00506590f, -0.07433144f, -0.00968440f, 0.02955608f, 0.04812128f, 
    -0.01042505f, -0.08927260f, 0.02984904f, -0.03331618f, 0.06412092f, 0.08076032f, 0.00241394f, -0.08047538f, 
    -0.03639606f, -0.02598055f, 0.06282187f, 0.01576880f, -0.02822553f, -0.04919551f, -0.01664652f, 0.02554756f, 
    0.05864177f, 0.05063470f, -0.01780132f, -0.01961447f, -0.03271782f, -0.06894036f, -0.04212143f, 0.00398325f, 
    -0.09824685f, -0.02902893f, -0.08426978f, -0.07518382f, 0.01039102f, -0.04349039f, -0.00837931f, -0.07063871f, 
    0.00104841f, -0.06691451f, 0.00608036f, -0.00764942f, -0.04374165f, -0.01221626f, -0.08807553f, 0.01094637f, 
    -0.05344271f, 0.01513969f, -0.06325009f, -0.00629053f, -0.08336402f, 0.03454664f, -0.01910473f, -0.09697736f, 
    -0.00721617f, 0.02008831f, 0.01146474f, 0.03604946f, -0.07286771f, -0.09219643f, -0.07623960f, -0.07212368f, 
    0.00384993f, -0.08895920f, -0.03361158f, -0.03251649f, -0.09087917f, -0.08452925f, 0.00077595f, 0.00398131f, 
    0.02550420f, 0.01730106f, -0.08270366f, -0.02095877f, -0.11230661f, -0.04913498f, 0.00739724f, -0.01839432f, 
    -0.06850123f, -0.06460901f, -0.02526969f, -0.02646052f, -0.04562880f, 0.02181875f, -0.01245111f, -0.04363421f, 
    0.03795413f, 0.04058409f, -0.08971540f, 0.00013793f, 0.00188244f, -0.10476881f, -0.06026359f, 0.02961596f, 
    0.03211851f, 0.03358572f, 0.01191985f, 0.00485214f, 0.03245883f, -0.06227681f, -0.05845962f, -0.09076486f, 
    -0.00193057f, -0.00172744f, -0.06452893f, 0.03249775f, -0.03149600f, 0.01757981f, -0.07020564f, -0.01058135f, 
    -0.00603985f, -0.06696329f, 0.05114201f, 0.00798706f, 0.04199549f, -0.01040776f, -0.04937450f, -0.06808697f, 
    0.00175942f, -0.03912196f, -0.02006515f, 0.01375943f, -0.05105234f, 0.04113639f, 0.04681281f, -0.02415093f, 
    -0.05913124f, 0.05474177f, -0.01371015f, -0.02284625f, -0.05205463f, 0.03659874f, 0.01309325f, 0.01851905f, 
    0.02974056f, -0.00556809f, -0.02166851f, -0.05444664f, 0.01051330f, 0.02875504f, -0.03503759f, -0.05960371f, 
    -0.06059762f, -0.06248464f, 0.04606092f, 0.01126829f, 0.02796847f, -0.01299511f, 0.01804490f, -0.05048417f, 
    -0.00304392f, -0.07819426f, -0.01518143f, 0.01869134f, -0.05436314f, 0.02979468f, -0.05806598f, 0.01910256f, 
    -0.05129687f, -0.08214878f, -0.00786177f, 0.04115640f, 0.03958340f, -0.04657314f, 0.00929052f, 0.00522365f, 
    -0.01343905f, 0.02684086f, 0.02342566f, -0.03720174f, 0.03320040f, -0.02165145f, 0.00623297f, -0.01188530f, 
    -0.07702330f, -0.04283478f, -0.07312713f, 0.00381256f, -0.04335364f, 0.02148669f, -0.03604347f, -0.07341401f, 
    0.02782029f, -0.04121437f, -0.00871939f, 0.03315968f, -0.00514889f, -0.05596898f, -0.04662627f, -0.00343306f, 
    -0.02761921f, 0.01651044f, -0.02150899f, 0.02010932f, -0.01474498f, 0.02101118f, -0.03558616f, 0.01704573f, 
    -0.07751296f, -0.01787480f, 0.01378735f, -0.08686090f, -0.04054920f, -0.06531624f, -0.00992378f, 0.03157299f, 
    0.03625886f, -0.06121040f, 0.06441669f, -0.06976911f, -0.04524206f, 0.04153028f, -0.08337272f, 0.01456617f, 
    -0.08430742f, 0.03156612f, 0.02481935f, 0.00522803f, -0.06830441f, 0.03293991f, -0.04754058f, -0.01811983f, 
    0.04445256f, 0.02422752f, 0.02695311f, -0.00693930f, 0.00605482f, 0.00200139f, -0.06916718f, 0.03012340f, 
    0.02070778f, 0.01905672f, -0.05586587f, 0.06241589f, 0.06395606f, -0.05952349f, 0.04581506f, 0.01834223f, 
    -0.02464378f, -0.08336317f, -0.07498799f, 0.00301961f, -0.06209738f, 0.01683331f, -0.01211683f, 0.04334864f, 
    0.01845637f, -0.05824647f, -0.02932653f, -0.02601079f, -0.00115260f, 0.01518093f, 0.01120502f, -0.03812751f, 
    0.01422707f, -0.03006544f, 0.04673043f, -0.05409797f, 0.01113435f, 0.05035955f, -0.04245404f, -0.00974839f, 
    0.06900369f, -0.03174986f, 0.05548443f, -0.06999800f, -0.03270571f, -0.07260731f, 0.02862409f, -0.01844910f, 
    -0.06267391f, -0.04958908f, -0.07794932f, -0.02543212f, 0.00298945f, 0.06275752f, -0.04854321f, -0.07422096f, 
    0.01213547f, 0.04785012f, 0.04702547f, 0.00132413f, -0.03215392f, 0.02424117f, 0.00903531f, -0.06374612f, 
    0.05144357f, 0.03536076f, -0.00083776f, -0.03482777f, -0.06494004f, 0.02386521f, 0.02750222f, -0.04542665f, 
    -0.06293171f, -0.07213872f, 0.05863951f, -0.06302969f, 0.01991978f, -0.05981241f, 0.01402880f, 0.02290153f, 
    -0.05284540f, -0.07588161f, -0.05165515f, -0.04116479f, -0.00127465f, 0.04538112f, -0.06013321f, 0.03943979f, 
    -0.00912632f, 0.00303211f, -0.03780424f, -0.05863464f, 0.01367674f, -0.00686658f, 0.05751653f, -0.04988707f, 
    -0.01217654f, 0.04529639f, -0.04296891f, 0.00955751f, 0.02970539f, -0.02458150f, 0.04481837f, -0.00559583f, 
    0.01479344f, -0.01077925f, 0.02387501f, -0.05875188f, -0.01529853f, -0.07978147f, 0.00234120f, -0.04306406f, 
    0.06402532f, -0.02275795f, -0.01203266f, 0.01626078f, 0.02708733f, 0.05337438f, -0.06268952f, -0.00604381f, 
    -0.01853726f, 0.03485880f, 0.02976212f, 0.03291656f, 0.04868458f, 0.01687348f, -0.07792114f, -0.00691639f, 
    -0.04459712f, -0.06280179f, 0.03406014f, 0.00323337f, -0.07212618f, 0.01089561f, -0.02541663f, 0.04634420f, 
    0.00823324f, 0.00548737f, 0.00514021f, 0.04747657f, -0.00701066f, -0.05926574f, -0.00784872f, -0.08003317f, 
    0.04527999f, -0.07538204f, 0.01093215f, 0.00005257f, -0.01389800f, -0.01202631f, 0.04952196f, -0.00663951f, 
    -0.07175282f, -0.05122645f, -0.06893001f, 0.02420388f, -0.01615988f, 0.02318982f, -0.03189974f, 0.01188268f, 
    0.02650590f, -0.07184956f, -0.03886153f, -0.06270761f, -0.05557398f, -0.07817467f, 0.01801710f, 0.06128164f, 
    0.04288441f, -0.07806028f, -0.06568619f, 0.04963506f, -0.00122507f, -0.00915769f, -0.01203529f, -0.05362504f, 
    0.05049042f, 0.02494241f, 0.03673708f, -0.03149196f, -0.05751900f, 0.02903249f, 0.02009859f, 0.03513262f, 
    0.01076132f, 0.01048812f, -0.05398336f, 0.00629874f, 0.05029033f, -0.05447096f, 0.03514501f, 0.02980798f, 
    -0.04939688f, 0.06220971f, 0.03672758f, 0.06041283f, -0.07863225f, 0.01345379f, -0.05976893f, -0.01326788f, 
    -0.02124296f, 0.04277349f, 0.05625565f, 0.01343077f, -0.07547882f, 0.02599985f, -0.06189112f, -0.05447214f, 
    0.02826508f, 0.04567171f, 0.00032060f, -0.00442594f, -0.04385934f, -0.05452451f, 0.00829471f, -0.03679138f, 
    -0.04749843f, -0.07747743f, -0.06036424f, 0.05906859f, -0.07270004f, -0.01772092f, -0.04422284f, 0.05199449f, 
    -0.07364126f, 0.00776929f, -0.04603038f, -0.02128545f, -0.04975758f, -0.06695864f, 0.01032650f, 0.03804336f, 
    0.03953960f, 0.05620332f, -0.07804297f, 0.00428010f, -0.02948223f, 0.06030345f, 0.03525900f, -0.03614537f, 
    -0.02193494f, -0.00402590f, -0.06479210f, 0.00266429f, 0.03794812f, -0.05483806f, -0.07411204f, 0.05111703f, 
    -0.06038639f, 0.04368120f, -0.04841162f, -0.03100491f, -0.05133200f, 0.03027900f, 0.01539940f, -0.04458081f, 
    -0.21530415f, -0.13313130f, -0.11104065f, 0.06931648f, 0.14155902f, -0.06461237f, 0.03490170f, 0.16259527f, 
    -0.00991249f, 0.07373220f, 0.02954808f, 0.17008822f, 0.12871781f, 0.08554506f, -0.04983447f, -0.01123341f, 
    -0.12371104f, -0.13399503f, -0.03541510f, -0.16323608f, -0.00811723f, -0.03178955f, -0.04919357f, -0.08655895f, 
    -0.18067303f, 0.29534435f, 0.04157707f, 0.07193036f, 0.14250982f, 0.01918991f, 0.35629934f, 0.10094333f, 
    0.03830639f, 0.13143753f, 0.17379928f, 0.09365816f, 0.20131844f, -0.25436455f, -0.25942859f, -0.48093441f, 
    0.07248242f, 0.03964552f, -0.03458948f, 0.10135480f, 0.09723379f, 0.15220656f, 0.22736084f, -0.03691506f, 
    0.27312395f, -0.05162795f, 0.25790742f, 0.14017196f, -0.00972179f, -0.09911899f, 0.03068429f, 0.00731811f, 
    0.12784259f, 0.19208091f, 0.29805234f, 0.30971524f, -0.15630208f, -0.19175830f, -0.03432005f, 0.23491743f, 
    0.05735397f, 0.04726290f, 0.11467145f, 0.14696263f, 0.11893924f, -0.07777049f, -0.09129584f, 0.04480103f, 
    -0.19454856f, -0.10178247f, -0.27685773f, -0.06141419f, -0.16947800f, -0.05417161f, 0.03606175f, 0.12039794f, 
    -0.01239001f, 0.11253221f, 0.23271880f, -0.10671252f, 0.03797562f, 0.01042248f, 0.46252865f, 0.04361510f, 
    -0.12986219f, 0.00708391f, 0.03101199f, 0.08846624f, 0.11766065f, -0.05515868f, 0.03482689f, 0.04651012f, 
    0.07966820f, 0.13499312f, -0.09898364f, -0.06224432f, -0.06303056f, -0.05940886f, 0.05349455f, 0.02099478f, 
    -0.02367780f, 0.00493145f, -0.00910985f, 0.00599948f, -0.05713780f, -0.14111145f, 0.32185602f, -0.04088847f, 
    -0.11493472f, 0.01414553f, -0.00924101f, 0.13447443f, -0.01205578f, 0.00501022f, -0.00683457f, 0.01864380f, 
    -0.05202772f, 0.38068688f, 0.13646975f, 0.47914812f, 0.12863468f, 0.28763035f, -0.09929917f, 0.02336927f, 
    -0.07687421f, 0.05761956f, 0.01124419f, 0.12599710f, 0.17348951f, -0.22239141f, 0.10046107f, -0.04934191f, 
    0.04561902f, -0.10989002f, 0.00550446f, 0.19644919f, -0.10417172f, -0.06834743f, -0.00143752f, 0.04214465f, 
    0.19412713f, 0.08761137f, 0.06286906f, -0.00342327f, -0.15135412f, 0.03395639f, 0.02439004f, 0.10328062f, 
    0.19225664f, -0.01582339f, 0.04429599f, -0.27661800f, 0.13847449f, 0.10524621f, -0.05919333f, -0.06259957f, 
    -0.08217975f, -0.05445884f, -0.11476411f, -0.03223040f, 0.03972876f, 0.05569502f, 0.06532232f, 0.06111883f, 
    0.06579564f, 0.01101078f, 0.19273522f, -0.20712827f, -0.18904579f, -0.12366881f, -0.02921312f, -0.01823137f, 
    -0.06684779f, 0.03969734f, 0.08944694f, 0.04861787f, 0.22778608f, 0.07920580f, 0.11289914f, 0.09708457f, 
    0.01817930f, -0.11031076f, -0.11075691f, -0.06699362f, 0.01971462f, 0.00633944f, -0.11491408f, -0.06992662f, 
    0.39454803f, 0.16439839f, 0.08150017f, 0.01144565f, 0.03469785f, 0.00572648f, 0.06700850f, -0.00995333f, 
    -0.10037588f, -0.00910644f, 0.08467284f, -0.00103521f, -0.07021523f, 0.02704231f, 0.05665322f, 0.03450572f, 
    -0.04999364f, 0.04975745f, -0.06229725f, -0.08067660f, -0.14392106f, 0.16458307f, 0.03729080f, -0.07792334f, 
    0.21541589f, -0.16108638f, -0.04435956f, -0.00674112f, -0.03288365f, 0.09907123f, 0.00709780f, 0.20343748f, 
    -0.10944361f, -0.18937163f, -0.14512049f, 0.16429725f, -0.17573738f, 0.64335954f, 0.26304644f, -0.08993901f, 
    -0.13437635f, 0.09248065f, 0.03065828f, 0.04742820f, -0.02198731f, -0.05279968f, -0.03905826f, -0.00273837f, 
    -0.06226127f, 0.11378323f, 0.26535875f, 0.09365624f, -0.08275590f, -0.00797413f, 0.01111354f, 0.08816587f, 
    -0.01039854f, 0.03627840f, 0.07754530f, -0.04143108f, 0.05393561f, 0.18112388f, -0.21061519f, -0.24857908f, 
    0.14139764f, 0.16545314f, 0.23757197f, 0.06394868f, 0.02902752f, 0.10247575f, -0.02046775f, -0.25517756f, 
    0.15498517f, 0.17254327f, 0.21121328f, -0.01762060f, 0.05586169f, 0.08333199f, 0.01998181f, -0.04510612f, 
    0.09543977f, 0.14801644f, -0.04208397f, 0.21097137f, -0.05823829f, -0.26761961f, 0.15600719f, 0.00491433f, 
    0.00083092f, -0.11181551f, -0.08411433f, 0.09437092f, -0.20598634f, 0.03669414f, -0.23402701f, 0.07735096f, 
    -0.09817491f, 0.04863103f, 0.09222731f, 0.13122669f, -0.01854511f, -0.08694831f, -0.09089937f, -0.12293396f, 
    0.02995994f, -0.07246071f, -0.00593293f, 0.01895840f, -0.37458083f, -0.04713466f, -0.17980140f, -0.18849041f, 
    -0.05054675f, -0.00047657f, 0.02571105f, -0.16620840f, -0.10650168f, 0.02533004f, 0.00656486f, 0.11181562f, 
    -0.01443610f, -0.21241657f, -0.46249965f, -0.08083726f, -0.01338934f, -0.14936300f, 0.11709719f, 0.03126150f, 
    0.02035974f, 0.10791557f, -0.01655701f, 0.09018621f, -0.08936471f, 0.10102468f, 0.02575272f, 0.00943277f, 
    0.11739915f, 0.20869496f, 0.00523943f, -0.09159420f, -0.04840572f, 0.09709902f, 0.03017057f, -0.05280324f, 
    -0.23100206f, 0.10756222f, -0.04970087f, -0.01521923f, 0.05410171f, -0.00953989f, -0.06934112f, 0.02842955f, 
    -0.04999097f, 0.13380624f, -0.06548582f, 0.31905299f, -0.04241319f, 0.05720365f, 0.05606623f, 0.02238459f, 
    -0.14784947f, 0.04125370f, 0.05942867f, 0.08257746f, -0.01111279f, -0.01617625f, 0.15425554f, 0.10235711f, 
    -0.28601408f, 0.10379718f, -0.28735045f, 0.09402472f, 0.03384207f, 0.06796703f, 0.04320402f, 0.02237394f, 
    -0.00783920f, 0.04815958f, 0.08213598f, 0.03649142f, -0.01187189f, 0.12888131f, 0.16848846f, -0.01497238f, 
    0.01113128f, -0.03636017f, -0.02500902f, 0.01135149f, -0.12513205f, 0.04170233f, -0.03722672f, -0.05334324f, 
    -0.00209778f, 0.04494710f, -0.01815054f, -0.04569052f, 0.02062572f, 0.04885779f, -0.04390385f, -0.08649947f, 
    -0.04310410f, -0.03729060f, -0.01993877f, -0.06791046f, -0.04621117f, 0.04269648f, -0.06083431f, -0.05145962f, 
    0.03450494f, -0.10678557f, -0.08415896f, 0.01909737f, 0.04809803f, 0.05809937f, -0.06131177f, -0.05701721f, 
    -0.06856221f, 0.02716256f, -0.06396974f, 0.00616584f, 0.06272661f, -0.07126475f, 0.03178576f, 0.04168678f, 
    -0.02839997f, -0.03947326f, -0.05217159f, -0.04994232f, 0.04337848f, -0.00709504f, 0.07106467f, -0.05701242f, 
    0.00448692f, -0.01255371f, 0.01946046f, 0.03606537f, 0.02224619f, 0.03944657f, -0.00630847f, -0.03088826f, 
    -0.06903934f, 0.05125630f, 0.01296675f, 0.05375871f, -0.04875494f, -0.10065196f, 0.03114962f, -0.05132054f, 
    -0.06590267f, -0.10066663f, -0.00689663f, -0.08166623f, -0.08410259f, -0.02282444f, -0.03496497f, -0.09716354f, 
    -0.00447086f, 0.04485938f, 0.05670246f, -0.04253633f, -0.02767478f, 0.02983797f, -0.04735465f, 0.05642005f, 
    0.02447424f, 0.06738489f, -0.01985755f, -0.01425584f, 0.05495709f, -0.02316185f, 0.02959659f, -0.02688923f, 
    -0.07336289f, -0.06981952f, -0.05288726f, 0.05744939f, 0.05229295f, -0.00456145f, -0.09942283f, 0.03659859f, 
    -0.04912639f, -0.05033448f, -0.08064023f, 0.01592487f, 0.07465187f, -0.00437778f, -0.00646950f, -0.05042143f, 
    0.05555706f, -0.03565295f, 0.00557830f, -0.02715246f, 0.00366052f, -0.05326540f, 0.05459927f, -0.05233774f, 
    0.00376525f, -0.02213545f, 0.04328267f, 0.03656945f, -0.02771895f, 0.02910859f, -0.08074520f, -0.02295768f, 
    0.02161198f, 0.01008050f, -0.03127090f, -0.01582276f, 0.02074465f, -0.01253403f, 0.04596730f, -0.01569472f, 
    -0.00476455f, -0.03642410f, -0.08534194f, 0.02333874f, 0.06062733f, 0.05750237f, 0.05401085f, 0.00135842f, 
    -0.06975456f, 0.00281247f, -0.08240285f, 0.01333407f, -0.03260769f, -0.01602537f, -0.01306674f, 0.00749877f, 
    -0.01661966f, 0.01384994f, -0.02739785f, -0.04120250f, 0.01804879f, -0.02723103f, -0.08386254f, 0.00021226f, 
    0.03536743f, 0.02855323f, -0.06812839f, -0.09020431f, -0.03610626f, -0.00385145f, -0.04265102f, -0.00584549f, 
    -0.02283181f, 0.03001840f, -0.01689132f, -0.05914356f, 0.03502518f, 0.05693138f, -0.03437318f, -0.00006114f, 
    -0.06954361f, -0.08793867f, -0.02719323f, -0.02928901f, 0.05452825f, -0.02489806f, -0.00454030f, -0.06890663f, 
    0.06291271f, -0.02478275f, 0.01825844f, -0.04768291f, 0.06890474f, -0.02790255f, 0.03402366f, -0.00420915f, 
    -0.09061322f, -0.02061487f, -0.04653287f, -0.00642780f, 0.03357276f, 0.01167972f, 0.02331905f, -0.11221252f, 
    -0.08398448f, 0.03621716f, -0.07286235f, 0.04298323f, 0.06019609f, 0.02543942f, 0.03950187f, -0.06332374f, 
    -0.05140777f, -0.00763654f, 0.27916422f, 0.12556890f, -0.17627665f, -0.04808934f, 0.02570352f, 0.21915564f, 
    -0.04010994f, 0.07830361f, -0.02967763f, 0.10365628f, 0.10314238f, 0.05217208f, -0.11381643f, -0.11012290f, 
    -0.08267682f, 0.06818818f, -0.03619634f, -0.06394640f, 0.06375478f, 0.04438778f, 0.09037867f, 0.20493881f, 
    -0.01819691f, -0.01177620f, 0.40230083f, -0.04341312f, -0.12537698f, -0.01032180f, -0.06157440f, 0.15429784f, 
    0.01491817f, -0.05299031f, 0.14737239f, -0.01380245f, 0.01531459f, -0.03680051f, -0.13064857f, 0.45064524f, 
    0.12848520f, -0.04340897f, -0.09261546f, -0.18306772f, 0.13322040f, -0.06458553f, 0.05788701f, 0.19118440f, 
    0.09573399f, 0.36078501f, -0.08780758f, -0.01580751f, -0.03431832f, 0.10612968f, 0.13025503f, -0.22853774f, 
    0.04854009f, 0.01592818f, -0.17964864f, 0.12308058f, -0.09492568f, -0.00086732f, 0.07711771f, 0.17267640f, 
    -0.11537184f, -0.20331904f, -0.09403224f, -0.01661407f, -0.03696297f, 0.12406155f, -0.02267796f, 0.20445064f, 
    -0.03810148f, 0.22154267f, 0.29705805f, 0.03183556f, 0.01157842f, -0.11028029f, -0.00588162f, 0.10519052f, 
    -0.01285946f, -0.08479907f, 0.14448600f, 0.07000528f, 0.02540659f, 0.17896283f, 0.13728961f, -0.12626103f, 
    0.11651945f, -0.00680898f, 0.19447850f, -0.01901232f, 0.03533705f, 0.07717656f, 0.11806139f, -0.05887605f, 
    0.11565936f, 0.07508960f, 0.00533623f, -0.13104492f, 0.11563141f, 0.08654547f, -0.01790559f, 0.00729217f, 
    0.11136887f, -0.01205934f, 0.00156761f, -0.04856081f, 0.34985971f, 0.04610335f, -0.01814925f, 0.12045174f, 
    -0.01802378f, -0.07726929f, 0.31037885f, 0.12121477f, 0.03420632f, -0.02229724f, -0.16344880f, -0.14502552f, 
    -0.21255448f, -0.29300821f, 0.40867835f, 0.00143406f, -0.14568369f, 0.11314522f, 0.03378232f, 0.33192021f, 
    0.06152112f, -0.12782580f, 0.09905040f, -0.01681619f, 0.03265801f, 0.12474984f, -0.17993239f, 0.08194177f, 
    0.07739986f, 0.02382646f, 0.15299852f, -0.13664953f, 0.31416193f, 0.03629169f, -0.05000772f, 0.05953778f, 
    0.19055863f, 0.09178637f, -0.03487224f, 0.02501032f, -0.01919799f, -0.10556288f, 0.11368594f, 0.00294898f, 
    0.04855954f, 0.11891927f, -0.12223858f, -0.02010213f, 0.04336829f, -0.03120367f, 0.09144240f, -0.03729153f, 
    0.04813005f, 0.01836341f, 0.00347681f, 0.02761657f, 0.08082394f, -0.10052411f, 0.12835942f, -0.12265584f, 
    0.16243789f, -0.18622504f, -0.13580281f, 0.24933112f, 0.02073954f, 0.13510191f, 0.15192595f, -0.09877647f, 
    0.08045743f, -0.15082654f, 0.03763882f, -0.05004466f, 0.18784457f, 0.14549065f, -0.01059522f, 0.05620985f, 
    0.01095702f, -0.09585617f, 0.16192096f, -0.07694627f, 0.04030819f, -0.09014631f, 0.11364924f, 0.07512027f, 
    0.03279101f, -0.08206227f, -0.02229861f, 0.01436019f, -0.05147983f, 0.02893732f, -0.08953290f, -0.01766418f, 
    -0.08403154f, -0.00384350f, -0.07070477f, -0.05065575f, 0.02011577f, -0.00823746f, 0.03083204f, 0.01204877f, 
    0.01873047f, 0.03279354f, 0.00824144f, -0.02132282f, -0.05790606f, 0.03414011f, 0.04305908f, 0.01815504f, 
    -0.01909392f, -0.07812425f, 0.02977441f, 0.05444397f, 0.05514017f, 0.01475913f, -0.05992442f, -0.06252906f, 
    0.01942326f, 0.02672383f, 0.00348337f, 0.03391694f, -0.01989766f, -0.01333209f, 0.05502203f, -0.02339025f, 
    -0.03456914f, -0.07077748f, 0.02301941f, 0.04658388f, -0.01261898f, -0.05831874f, 0.01211635f, 0.02667327f, 
    -0.05384178f, 0.00010371f, -0.00957128f, -0.08387138f, -0.07072448f, -0.05322213f, 0.02578444f, 0.02286879f, 
    -0.00969123f, 0.04413656f, -0.05361936f, -0.04866290f, 0.03757221f, 0.03904671f, 0.03376202f, -0.05134648f, 
    -0.04270104f, -0.06158089f, -0.06451906f, -0.02980859f, 0.00800425f, 0.00139891f, 0.01262354f, -0.00105088f, 
    -0.08256239f, 0.05553036f, -0.04407625f, 0.05853454f, -0.01138994f, -0.00442011f, -0.00364772f, -0.05716520f, 
    0.00897239f, 0.06528875f, 0.01323242f, 0.05414980f, -0.06782997f, -0.04654849f, 0.00474021f, -0.08485776f, 
    -0.08772746f, -0.07110789f, -0.04505247f, 0.04923084f, 0.04555310f, -0.05078261f, 0.00651439f, 0.05299702f, 
    -0.00128836f, 0.03718403f, 0.00847408f, 0.02783494f, -0.01955129f, -0.03189716f, -0.02872416f, -0.00055201f, 
    0.04448194f, -0.01334176f, -0.01691332f, -0.00078712f, -0.05359608f, -0.01328265f, -0.06501161f, -0.06316064f, 
    -0.00474577f, 0.01319134f, -0.06098077f, -0.06768848f, 0.02207673f, -0.01515365f, -0.04721577f, -0.05837708f, 
    -0.04452806f, -0.04373536f, -0.05206294f, 0.04297357f, -0.03536721f, 0.04040832f, 0.02394051f, -0.02107737f, 
    -0.02387006f, -0.06874005f, 0.04495995f, -0.03881202f, -0.03925367f, 0.03580501f, -0.04962105f, -0.01348519f, 
    0.03349550f, -0.01211670f, -0.05095254f, -0.07588264f, 0.05271362f, -0.02846981f, -0.04756463f, 0.04302661f, 
    -0.07325537f, 0.03628174f, -0.03684150f, 0.03698066f, -0.01961536f, 0.03761051f, 0.02933284f, -0.06913527f, 
    0.07489405f, -0.00557341f, -0.07823605f, -0.05365685f, -0.02441091f, 0.00659511f, -0.01371520f, 0.00812020f, 
    -0.04994113f, 0.01789093f, 0.04631143f, -0.08075409f, 0.05001254f, -0.06271698f, 0.03620737f, -0.05217243f, 
    0.03574941f, 0.03083241f, -0.06269884f, -0.03108048f, -0.01890681f, -0.03835302f, 0.01820547f, -0.09481377f, 
    -0.03135497f, 0.04632079f, 0.01192611f, -0.06702340f, 0.03926268f, -0.05784001f, 0.00909531f, 0.04826608f, 
    0.03111722f, -0.03450519f, -0.04356685f, 0.00416022f, -0.06500749f, 0.05217485f, 0.05288454f, 0.01969583f, 
    -0.34028384f, 0.22633684f, 0.15269108f, -0.01076410f, -0.18059988f, -0.17592719f, 0.17107409f, 0.24684615f, 
    -0.00618879f, -0.02445863f, 0.07354483f, -0.00344898f, 0.19903141f, 0.02284924f, 0.04820850f, 0.04457027f, 
    0.03128395f, -0.03597051f, -0.00351459f, -0.05884254f, 0.09590328f, -0.13561323f, 0.08987423f, 0.01279304f, 
    -0.13158847f, 0.09016382f, 0.36746362f, -0.10152977f, -0.07709857f, -0.08250814f, 0.10557660f, 0.21486934f, 
    0.01757051f, 0.12235456f, 0.10212655f, 0.06998610f, 0.16327493f, -0.23172063f, 0.03289441f, 0.38080385f, 
    -0.01938559f, -0.02082284f, -0.10207918f, -0.01810322f, 0.11007738f, 0.03467616f, 0.21131614f, 0.17167784f, 
    0.25630099f, 0.06757987f, 0.19774041f, 0.28078258f, 0.04405046f, 0.06574867f, -0.04614009f, -0.00661951f, 
    0.09999459f, -0.07731621f, 0.24222811f, 0.16077662f, -0.19513108f, -0.18458261f, -0.01997476f, 0.30800369f, 
    -0.17228350f, -0.08705399f, -0.01668301f, 0.07797695f, 0.03281699f, 0.13168348f, -0.08866375f, 0.13442340f, 
    -0.27221447f, 0.24168810f, 0.21970677f, -0.12443051f, -0.14991832f, -0.08035719f, -0.05540707f, 0.00509741f, 
    0.00318349f, -0.04252923f, 0.21281090f, 0.04581271f, 0.15954706f, 0.17502339f, 0.07575377f, -0.24176021f, 
    0.13168877f, -0.03695854f, 0.36359513f, -0.00491083f, 0.28521621f, -0.02576766f, 0.26447010f, -0.00339174f, 
    0.25939757f, 0.09611423f, 0.23759139f, 0.06640496f, 0.08555500f, 0.03384407f, -0.01407811f, 0.09563204f, 
    0.04514442f, 0.05880196f, -0.03396646f, -0.08266456f, 0.26080924f, -0.07168681f, -0.26227385f, 0.04100586f, 
    0.13708776f, 0.18071586f, 0.20792392f, 0.17779559f, 0.02565456f, -0.01357503f, -0.04694315f, -0.06073789f, 
    -0.26117811f, -0.15287451f, 0.31617674f, -0.08276005f, 0.06186886f, 0.04138947f, 0.10677721f, 0.21898302f, 
    0.02705218f, -0.07143741f, -0.02838759f, 0.08774713f, 0.18259509f, -0.15902653f, -0.07883500f, 0.06148979f, 
    -0.02641005f, -0.09370971f, -0.08631293f, 0.09554935f, 0.19579116f, -0.08373749f, -0.00057633f, 0.05209566f, 
    0.33612806f, 0.17898376f, 0.04482030f, 0.00954758f, -0.03969011f, 0.02663673f, 0.15398355f, -0.03423148f, 
    0.29426357f, 0.12210588f, -0.03177235f, -0.07383594f, 0.09494202f, -0.01443211f, 0.04729917f, -0.01801629f, 
    0.04316766f, -0.07922736f, 0.03019986f, -0.06218214f, -0.01151871f, 0.03214618f, -0.01530481f, -0.09163564f, 
    -0.04802797f, -0.36454517f, 0.02745287f, 0.20122179f, 0.01323520f, 0.17527579f, 0.06047172f, -0.05808266f, 
    0.01234257f, 0.01894552f, 0.03755162f, -0.04771888f, 0.43781441f, 0.22212987f, -0.10519724f, 0.17631963f, 
    -0.01384455f, -0.01972207f, 0.03484137f, -0.08375927f, 0.12779258f, -0.00277749f, 0.09130744f, 0.13850449f, 
    -0.49513525f, 0.13097036f, 0.11359131f, -0.07857195f, -0.16971961f, 0.05482881f, 0.15726970f, 0.14864972f, 
    -0.01657917f, -0.03380966f, -0.11611852f, -0.08609786f, -0.08065122f, 0.10964070f, -0.22122166f, 0.10966562f, 
    -0.04698190f, 0.00881301f, -0.10379582f, -0.11601624f, 0.06217857f, -0.15124135f, -0.01832165f, -0.06429135f, 
    0.03661304f, -0.05710508f, 0.20337342f, -0.20438522f, -0.02045962f, 0.05011304f, 0.02047679f, 0.15991165f, 
    0.11661957f, 0.13540545f, -0.05951490f, 0.03945715f, -0.30672789f, -0.24236383f, 0.18966573f, 0.70009398f, 
    -0.08299647f, -0.06571619f, -0.10108680f, 0.08353575f, 0.11241510f, -0.09179292f, 0.35283989f, 0.18900238f, 
    -0.17216751f, 0.23498674f, -0.01650820f, 0.29018992f, -0.09787509f, 0.12281505f, -0.08675478f, 0.04769991f, 
    0.23467955f, 0.10965577f, 0.23299758f, 0.26494700f, -0.09567441f, -0.02740278f, 0.17470667f, 0.17654058f, 
    0.00023221f, -0.11926813f, 0.05774569f, 0.23737448f, 0.14501108f, 0.11081025f, 0.06521632f, 0.20007971f, 
    -0.13049848f, 0.22800787f, 0.16150196f, -0.15214723f, -0.02239184f, -0.03207022f, -0.13228740f, -0.08248951f, 
    0.07259231f, 0.01416386f, 0.19452451f, 0.01120790f, -0.15534399f, -0.18214589f, -0.08158647f, -0.27444559f, 
    0.04298494f, 0.17854348f, 0.02313446f, 0.03863327f, 0.08808717f, 0.07641069f, -0.04638349f, -0.08465949f, 
    -0.03535876f, 0.04944947f, 0.08236699f, -0.13886735f, 0.06223104f, 0.16167416f, -0.06368030f, 0.14234398f, 
    0.01716038f, 0.03332133f, 0.16576749f, -0.11338090f, 0.16431202f, 0.15102386f, 0.06237925f, -0.02768362f, 
    0.18219940f, 0.01015638f, -0.13424890f, -0.13605732f, -0.17234842f, 0.00023709f, -0.06709161f, -0.17673646f, 
    0.17301640f, -0.41591021f, 0.21694137f, -0.16967563f, -0.06395369f, 0.18880646f, 0.04107454f, 0.16671082f, 
    0.06566413f, 0.09457996f, 0.04011590f, 0.14836210f, 0.04180345f, 0.06017804f, -0.01979651f, 0.00548309f, 
    0.18473728f, 0.08661372f, -0.03207980f, 0.31055743f, -0.03017486f, 0.04800333f, 0.01041703f, -0.04638299f, 
    0.25491393f, -0.09698755f, 0.09658030f, 0.14162675f, -0.08926506f, -0.06525560f, 0.03353557f, -0.12603121f, 
    0.06061028f, 0.02742017f, -0.00434407f, -0.12333333f, 0.00167703f, -0.00165450f, 0.13633147f, 0.07198532f, 
    -0.11511107f, -0.07637168f, -0.05694948f, -0.00295091f, 0.06429118f, 0.02539067f, 0.11253694f, 0.08151969f, 
    -0.17228410f, 0.18096341f, -0.05496513f, 0.17952304f, -0.14679052f, 0.07049633f, 0.04891158f, -0.03586390f, 
    -0.01983342f, -0.06062495f, -0.05963087f, -0.02291953f, -0.11884522f, 0.08917445f, -0.14317448f, -0.05019546f, 
    0.10959844f, -0.10344411f, 0.04701856f, 0.00133090f, 0.10245363f, -0.01635786f, 0.03822635f, -0.03266719f, 
    0.01803652f, -0.04235822f, 0.02666652f, 0.02830975f, 0.04274306f, -0.02781821f, -0.02679446f, -0.01284422f, 
    -0.05500434f, -0.04038836f, -0.00549932f, -0.07873913f, 0.04449413f, -0.02496481f, -0.06882840f, -0.07023965f, 
    0.06124681f, -0.06198135f, -0.01243811f, 0.05118577f, 0.03148218f, 0.05518636f, -0.01599762f, -0.07526259f, 
    -0.02377450f, 0.02909942f, 0.00052626f, 0.03820150f, 0.05403024f, 0.01645040f, 0.06388545f, 0.04381914f, 
    -0.03005285f, 0.04508316f, -0.01287025f, 0.00820223f, 0.00187700f, -0.03137939f, 0.02639884f, -0.02989060f, 
    0.02973004f, 0.00585838f, -0.05768832f, -0.03443625f, 0.05237184f, 0.03872656f, 0.01073101f, -0.06281806f, 
    0.05486291f, 0.06582078f, 0.05027739f, 0.06215995f, 0.00456097f, 0.00811357f, -0.02989013f, -0.06799468f, 
    0.05103195f, -0.06176847f, -0.04824248f, -0.07573502f, -0.06904669f, 0.05931244f, -0.04442425f, -0.06151587f, 
    -0.01706954f, 0.01762864f, 0.05511696f, -0.07186779f, 0.00486527f, 0.05774548f, -0.07895742f, 0.02064797f, 
    0.02885032f, -0.01133902f, 0.05460127f, 0.00124198f, -0.00122499f, 0.05495940f, -0.05329404f, -0.01588545f, 
    -0.06063865f, -0.04184864f, -0.04109401f, -0.07744687f, 0.01156925f, -0.04106513f, 0.00607950f, 0.00783871f, 
    -0.03300306f, -0.03329137f, -0.02121491f, 0.01344347f, -0.02800516f, -0.02775785f, -0.04783392f, -0.02180609f, 
    -0.06169789f, -0.07023201f, 0.00995194f, 0.02498613f, -0.00269068f, -0.04177290f, -0.01714015f, -0.02034049f, 
    0.06526113f, -0.05700627f, 0.00345987f, 0.01305721f, -0.02032109f, 0.02999924f, -0.05352553f, 0.02653570f, 
    0.00070796f, -0.05701688f, -0.02756758f, -0.01495783f, 0.00165822f, -0.05789795f, -0.04773499f, 0.05097713f, 
    0.01665296f, 0.04971419f, 0.03240822f, 0.00851451f, 0.01696940f, -0.01882561f, 0.04063632f, -0.04399301f, 
    -0.01267519f, -0.01553618f, -0.06684452f, -0.02183071f, -0.01282653f, 0.03914116f, 0.05820017f, 0.00835356f, 
    0.04443415f, -0.06680207f, 0.02099325f, -0.05032043f, 0.00995021f, -0.03371150f, 0.03172177f, -0.07471219f, 
    0.02653988f, -0.03724877f, 0.06002378f, -0.00842120f, -0.05328728f, 0.01492870f, -0.01235756f, 0.03040951f, 
    -0.00544730f, -0.05686129f, -0.02035773f, 0.03661749f, -0.04737097f, 0.00575232f, -0.01864953f, -0.00509675f, 
    0.00602808f, -0.03624457f, 0.05894933f, 0.02157697f, -0.03464101f, -0.06190030f, -0.05336467f, 0.06240067f, 
    -0.00667316f, 0.00389798f, 0.06113690f, -0.00071188f, -0.04438734f, -0.01884155f, -0.03092760f, 0.05890858f, 
    -0.06547920f, 0.05779586f, -0.07375275f, -0.03188464f, -0.06527876f, -0.00591977f, 0.05102581f, -0.01998665f, 
    -0.06007827f, 0.04207607f, -0.03305241f, -0.03567110f, 0.00753562f, -0.06528597f, 0.01891296f, -0.06638110f, 
    -0.21327825f, -0.01024494f, 0.01257729f, -0.01644571f, -0.06212232f, 0.16506858f, 0.18876523f, 0.17162128f, 
    0.05824718f, 0.08279911f, -0.11471605f, -0.01033203f, -0.06913400f, -0.00809583f, 0.19400673f, 0.00843342f, 
    0.05004784f, -0.05137042f, 0.10319660f, -0.01295674f, 0.10961542f, -0.13529573f, 0.18771356f, 0.00983979f, 
    0.09604639f, -0.22226797f, -0.08341790f, 0.05602044f, 0.01568197f, 0.14601472f, 0.16374446f, -0.17129643f, 
    -0.03785080f, -0.03937222f, -0.20197044f, 0.05759100f, 0.38646463f, 0.11172115f, 0.08633021f, -0.10092724f, 
    -0.02222113f, 0.14460270f, 0.13199326f, 0.08235178f, -0.02659905f, -0.01545624f, 0.22744183f, -0.23291394f, 
    -0.06394548f, -0.18433382f, 0.34712631f, -0.00686288f, -0.04888152f, 0.04108741f, -0.04527276f, 0.14446564f, 
    -0.07236449f, -0.06446569f, 0.21269490f, -0.21316749f, 0.10109320f, 0.16586120f, 0.13542366f, 0.00045334f, 
    0.16874333f, 0.16967070f, -0.10424905f, 0.04662987f, -0.17161989f, -0.24457772f, -0.31239575f, 0.04046803f, 
    0.06505819f, -0.13152726f, -0.18483643f, 0.02125043f, 0.06428225f, 0.08898636f, 0.13898820f, 0.02009648f, 
    0.09592932f, -0.06985287f, -0.02475371f, 0.02973302f, -0.26541597f, 0.02230758f, -0.39115375f, 0.07186701f, 
    -0.05329278f, -0.07771989f, 0.00610056f, -0.12773640f, 0.14552504f, 0.02515503f, 0.17007296f, -0.13538493f, 
    -0.06711932f, -0.09972304f, 0.14479473f, -0.00496840f, 0.01949534f, 0.14014421f, -0.14778152f, 0.05061689f, 
    0.03291136f, 0.06993892f, 0.08899470f, -0.00474587f, -0.17835641f, 0.34177020f, -0.02235136f, 0.00218978f, 
    -0.00822447f, 0.09751651f, 0.00174126f, -0.15812483f, -0.00418508f, -0.02473211f, 0.05187831f, -0.03240458f, 
    0.27581546f, -0.01640181f, -0.00796447f, -0.07214082f, 0.11768666f, 0.06170321f, 0.14876300f, 0.10815020f, 
    0.01095037f, 0.04094468f, -0.01717352f, 0.04367699f, -0.19482076f, -0.17451775f, 0.20912068f, 0.01162297f, 
    -0.00722159f, -0.10842205f, -0.04323865f, -0.07194766f, -0.10362370f, -0.17425792f, -0.06262938f, 0.06655896f, 
    0.02618272f, 0.12290367f, -0.08590452f, 0.04613785f, -0.03794377f, -0.07980105f, 0.00003353f, -0.09587823f, 
    0.08371577f, 0.05086068f, 0.13842249f, -0.09217389f, 0.02899097f, -0.13085917f, 0.01460398f, 0.03039360f, 
    0.07212516f, 0.05044175f, 0.09183027f, 0.00870347f, 0.11260743f, -0.02107386f, 0.02953301f, 0.18506777f, 
    0.09818806f, 0.15945293f, 0.22630088f, 0.02162581f, 0.13868967f, -0.03190402f, 0.02942453f, 0.07259431f, 
    0.02142122f, 0.01326898f, 0.20273311f, 0.04537292f, -0.16573139f, -0.08687550f, -0.14461493f, 0.06907299f, 
    0.06590062f, -0.01456668f, -0.02897052f, 0.00938441f, -0.00581598f, -0.14294767f, 0.01472949f, 0.14722045f, 
    0.03645093f, 0.28482279f, 0.19146587f, -0.03218247f, 0.08660093f, 0.20227757f, 0.03615492f, 0.01461238f, 
    0.17574455f, -0.17257537f, 0.00541678f, 0.08693424f, -0.08685482f, -0.40864021f, 0.11232167f, 0.32927558f, 
    0.03419396f, -0.15755421f, -0.09624483f, -0.38634396f, -0.05213252f, -0.04316042f, 0.18659447f, 0.12961414f, 
    0.35700452f, 0.05263585f, -0.06515979f, 0.02363660f, 0.15225263f, 0.02030826f, 0.24349120f, -0.00012216f, 
    0.18193980f, -0.09137014f, -0.07665281f, -0.21164098f, 0.13577546f, 0.05250144f, 0.30150783f, 0.35248613f, 
    -0.07057246f, -0.15488409f, -0.14899819f, 0.01289360f, -0.04278558f, 0.11367522f, -0.08302435f, -0.01859633f, 
    0.03027697f, -0.31317672f, -0.11517653f, -0.16680165f, 0.01501904f, -0.13799423f, -0.04552382f, 0.15384360f, 
    0.04450958f, 0.08571880f, 0.03229445f, -0.02519716f, 0.25474936f, 0.33016822f, 0.31545120f, 0.07502324f, 
    0.30738908f, 0.20491426f, -0.02848836f, 0.18081327f, 0.04177250f, -0.03939195f, 0.00405154f, 0.22886610f, 
    0.44712263f, -0.01526807f, 0.01186599f, -0.02669685f, 0.06286401f, -0.16074656f, -0.09622084f, -0.02961599f, 
    0.07591526f, 0.06982257f, 0.06601879f, 0.10621119f, -0.39511350f, -0.19314960f, -0.48391104f, 0.01740129f, 
    0.03143906f, 0.00097223f, -0.20862041f, -0.04562763f, 0.13976531f, 0.09487376f, 0.02446102f, -0.05199547f, 
    -0.04242669f, -0.19165835f, -0.31457904f, 0.11051206f, 0.01676096f, -0.09800028f, -0.16280694f, -0.02419832f, 
    -0.09585235f, 0.10762449f, 0.23755099f, -0.15503478f, -0.20600946f, 0.25450015f, 0.25590196f, 0.10365959f, 
    0.14653856f, 0.16127485f, -0.14862543f, 0.11861351f, 0.07179981f, -0.05172359f, 0.13947134f, -0.03607100f, 
    0.49016517f, 0.21764264f, -0.00368199f, -0.12462723f, 0.17415835f, 0.18984191f, 0.10722452f, 0.17084818f, 
    -0.05162888f, 0.15618922f, 0.05620242f, -0.11470375f, -0.46483913f, 0.09311561f, 0.15113425f, -0.18482324f, 
    0.12838019f, 0.06432287f, -0.13499305f, -0.04037427f, 0.23355938f, -0.16358607f, 0.12446281f, 0.24910147f, 
    -0.33156350f, -0.28514016f, 0.05927594f, -0.05922865f, 0.03896581f, -0.25058547f, -0.09661507f, -0.12946655f, 
    -0.05128445f, 0.01476431f, 0.16266637f, 0.10253788f, -0.33853740f, -0.31375942f, -0.19667199f, 0.13187286f, 
    0.01869296f, 0.14190608f, -0.10271625f, -0.12628144f, -0.09120283f, -0.25368819f, -0.08896632f, 0.16809511f, 
    -0.51064771f, 0.02365526f, 0.49623153f, 0.07201155f, -0.03598134f, 0.10704296f, 0.03025741f, 0.31125897f, 
    -0.06646307f, -0.31082252f, 0.04152974f, -0.12957856f, -0.31552178f, -0.28396481f, -0.10767700f, 0.48153365f, 
    -0.04997788f, 0.06117484f, -0.00250645f, -0.09977850f, 0.09399100f, -0.24359724f, -0.04037958f, 0.25004041f, 
    0.29228681f, 0.27453977f, 0.17742608f, 0.44041601f, 0.04746093f, 0.12584741f, 0.15347576f, -0.11317597f, 
    0.04952030f, 0.22526243f, -0.00811521f, 0.02053702f, -0.13782291f, -0.05766752f, -0.08031102f, -0.24319164f, 
    -0.08956800f, -0.07402160f, -0.04010142f, -0.06686879f, -0.11235554f, -0.06218331f, -0.02128060f, -0.00188807f, 
    0.25788501f, -0.14330350f, 0.30471984f, 0.11633608f, -0.01454744f, 0.24724445f, 0.10580794f, 0.26956627f, 
    -0.02788239f, 0.09552663f, 0.06796120f, 0.20615354f, -0.19586062f, 0.32551447f, -0.09231538f, -0.03830760f, 
    -0.13347404f, -0.01235576f, -0.02656882f, 0.00207318f, 0.05223146f, 0.04214485f, -0.17658809f, -0.20520966f, 
    -0.07245798f, 0.01831811f, -0.07371134f, 0.11674590f, -0.03250478f, -0.03175518f, 0.10244380f, 0.05601980f, 
    -0.12484381f, -0.04863300f, -0.02185710f, -0.09085565f, 0.04577587f, 0.23768499f, -0.15930603f, 0.06130670f, 
    0.01104766f, 0.03914888f, 0.09330681f, 0.07618251f, -0.05879193f, 0.03261308f, -0.01299399f, 0.04950202f, 
    -0.01396824f, 0.45415869f, 0.16077358f, 0.12387457f, 0.00695789f, 0.09791306f, -0.02757058f, 0.02735945f, 
    0.10201173f, 0.15386298f, -0.20330113f, 0.06447014f, 0.04131681f, 0.01798633f, 0.00171071f, -0.06388766f, 
    0.14044388f, -0.01697145f, 0.07983755f, 0.00027778f, -0.20474571f, -0.08192015f, 0.13884033f, 0.10852990f, 
    -0.18676710f, -0.22258814f, -0.00476505f, -0.11441837f, 0.02116011f, -0.05594963f, -0.19771294f, 0.00264907f, 
    0.02951830f, -0.06825805f, -0.05063121f, 0.07842203f, 0.04108818f, 0.13930455f, -0.27874711f, -0.04416814f, 
    0.10829721f, 0.11253166f, 0.08826096f, -0.24087118f, -0.08453350f, -0.03211815f, 0.02589330f, 0.03625455f, 
    -0.02855326f, -0.15681057f, 0.09057017f, 0.12924343f, -0.02525390f, -0.04420669f, 0.09864011f, 0.01790943f, 
    0.04384368f, 0.04027405f, 0.02362073f, 0.07450507f, -0.13222216f, -0.07583255f, -0.18406934f, 0.00943107f, 
    -0.13948871f, 0.01922813f, 0.06597769f, -0.05425207f, -0.01450973f, 0.08544582f, -0.01662224f, -0.09320983f, 
    -0.13639368f, -0.03643290f, -0.01543986f, 0.07753041f, 0.08194587f, 0.07037428f, -0.04964390f, -0.02903048f, 
    -0.20746271f, 0.03477835f, -0.14480542f, 0.19932823f, -0.10863855f, -0.07325874f, 0.05917012f, 0.00902864f, 
    -0.12768018f, -0.00793071f, 0.02949105f, 0.06691307f, 0.05409577f, 0.08251681f, 0.09292976f, -0.01377214f, 
    -0.01657603f, -0.10584484f, -0.33825222f, 0.04634291f, 0.11441395f, 0.00490219f, 0.04660652f, -0.00109413f, 
    0.00302750f, 0.06480774f, 0.07116804f, 0.02917678f, 0.10432169f, 0.08478957f, -0.02750047f, -0.15432930f, 
    -0.03396596f, 0.02595909f, 0.02664591f, 0.06595040f, -0.05874648f, -0.02690426f, 0.22506274f, -0.03872507f, 
    -0.07620460f, 0.28037563f, 0.00538253f, 0.30452442f, 0.16019392f, -0.05462383f, 0.09075160f, -0.00515781f, 
    0.08219922f, -0.08639451f, -0.12017343f, 0.20521070f, -0.15258095f, -0.32756040f, 0.15359612f, -0.03516879f, 
    -0.26179945f, -0.32082945f, -0.13490553f, -0.07764643f, 0.07125023f, 0.08416492f, 0.17876075f, 0.11999423f, 
    0.10817591f, 0.14476909f, 0.21776573f, -0.01514399f, 0.18048953f, -0.05473925f, 0.23508924f, 0.04663751f, 
    0.13150084f, -0.04401654f, 0.05578781f, 0.12406737f, 0.12243879f, -0.04263482f, 0.41747844f, 0.15485962f, 
    -0.23270756f, -0.11734318f, 0.07099222f, 0.08967373f, -0.00984397f, 0.00939996f, -0.10773616f, 0.08204436f, 
    0.19451000f, -0.10407384f, -0.00218812f, -0.07895262f, 0.07409306f, -0.18312888f, -0.11462492f, 0.12142279f, 
    0.12936835f, -0.05809952f, 0.05220007f, 0.11103089f, -0.28575972f, -0.07026280f, -0.02355779f, 0.16153273f, 
    0.07161693f, 0.15817326f, -0.00514419f, 0.02577072f, 0.01554737f, 0.06882653f, 0.13548495f, 0.11655508f, 
    -0.00299596f, 0.35927251f, 0.18928513f, 0.06666329f, 0.05492555f, -0.04462493f, 0.11020438f, -0.20824800f, 
    0.07164834f, 0.04129192f, -0.09476157f, 0.11964185f, 0.07123964f, -0.01815388f, 0.36588296f, -0.07520757f, 
    -0.01379190f, -0.26721436f, -0.03036004f, -0.03711088f, 0.04172709f, -0.03647845f, 0.07347519f, 0.14550515f, 
    -0.18931460f, -0.07641044f, 0.16173869f, 0.27909982f, -0.24916245f, -0.21807593f, -0.12874369f, 0.12870818f, 
    -0.12154993f, -0.18082480f, -0.07285146f, 0.00448307f, -0.17443897f, -0.23985125f, 0.07697872f, -0.00735397f, 
    -0.06318457f, 0.07673047f, 0.11416136f, 0.11454420f, 0.24118826f, 0.01309461f, 0.10668293f, -0.04570345f, 
    -0.31415516f, 0.09952320f, -0.27586129f, 0.26195547f, 0.32951090f, 0.12355027f, 0.12853914f, 0.15610343f, 
    0.05824405f, -0.02002806f, 0.10141975f, 0.07797061f, -0.18456605f, -0.36124155f, -0.01629402f, 0.17984265f, 
    -0.15939304f, -0.03047958f, -0.25857481f, 0.01285331f, 0.11762695f, -0.10722528f, -0.09272895f, 0.12945127f, 
    -0.15565410f, 0.17661905f, -0.04083898f, 0.00154587f, -0.14584391f, -0.06169900f, -0.07930517f, -0.07637142f, 
    0.21248509f, -0.03790682f, 0.04035466f, -0.02891018f, -0.04668252f, -0.06918325f, -0.09798589f, 0.08069869f, 
    -0.10292219f, 0.05189180f, 0.03292821f, -0.08656842f, -0.09430297f, -0.23219013f, -0.32657400f, -0.23219536f, 
    -0.22556621f, -0.11689857f, -0.02399343f, -0.05552871f, -0.03294030f, 0.16414063f, 0.28860578f, 0.03651575f, 
    0.04656361f, -0.04713969f, -0.05344152f, 0.10503859f, 0.23823561f, 0.17133710f, 0.12837735f, 0.16383950f, 
    0.03370226f, -0.13839392f, 0.07302851f, 0.09104996f, 0.16883545f, -0.02502006f, -0.03027682f, 0.09130730f, 
    -0.37438107f, -0.34538010f, -0.22564644f, -0.40918857f, -0.11765617f, -0.04182801f, -0.19148549f, -0.09485449f, 
    -0.24464765f, -0.21078463f, -0.04021825f, -0.20412683f, 0.14644776f, 0.21441340f, 0.02137515f, 0.12465144f, 
    -0.05831536f, 0.00264827f, -0.02834523f, -0.01592760f, 0.02243245f, 0.14744048f, -0.02768311f, 0.02581895f, 
    -0.17002629f, -0.27273813f, -0.18900886f, -0.15057552f, -0.06265161f, -0.24071023f, -0.09284525f, 0.16802411f, 
    -0.05987269f, 0.05344244f, 0.11813985f, -0.06722821f, -0.40353465f, 0.06490336f, 0.12105517f, 0.25829697f, 
    -0.10880695f, -0.01842047f, -0.02474088f, -0.10549089f, -0.01205405f, -0.07161850f, 0.09974422f, 0.12111849f, 
    -0.12590882f, 0.30919451f, -0.05186429f, 0.05982896f, -0.00616634f, 0.06089693f, 0.03522454f, 0.00199984f, 
    0.06678642f, -0.04785260f, 0.08044280f, 0.05055697f, -0.05679395f, -0.16686495f, -0.10097180f, -0.21614584f, 
    -0.01424271f, -0.26053575f, 0.12500422f, 0.12833136f, 0.11663681f, 0.18166706f, 0.24082673f, 0.20354761f, 
    0.07479289f, -0.26252037f, 0.05575472f, -0.10134825f, 0.00204809f, -0.00759450f, -0.03551259f, 0.09123271f, 
    0.12683755f, 0.19598065f, 0.11254933f, -0.12704894f, 0.14327092f, 0.03796653f, 0.13155279f, 0.15381525f, 
    -0.01620727f, 0.19196869f, -0.03170450f, 0.14961749f, 0.16475265f, 0.07360051f, -0.00853362f, 0.21162999f, 
    0.35619211f, 0.13381538f, -0.00999669f, 0.08994944f, 0.07471465f, -0.02826544f, 0.02113790f, -0.08928281f, 
    -0.08516833f, 0.07030620f, 0.02016746f, 0.05871378f, 0.76863861f, -0.04003182f, 0.21115224f, 0.13941009f, 
    0.07056024f, 0.08751212f, 0.10254314f, 0.03841670f, -0.15036653f, -0.04945604f, -0.08386464f, 0.02536612f, 
    -0.04620042f, -0.39354420f, 0.35200360f, -0.50505823f, -0.20761314f, -0.03990656f, -0.25875762f, 0.09595909f, 
    -0.00076973f, -0.02162525f, -0.07218137f, -0.04057288f, 0.12702742f, 0.36476433f, -0.07836713f, 0.00281760f, 
    0.20706850f, 0.27129257f, 0.21678881f, 0.17706174f, -0.04624211f, 0.00026919f, 0.09998683f, -0.10683572f, 
    0.13638599f, -0.18113586f, 0.06954068f, 0.03062300f, 0.03178930f, 0.09380409f, 0.14705449f, 0.12746479f, 
    0.12406944f, 0.07897919f, -0.04135067f, 0.07453884f, 0.11254661f, 0.11942323f, 0.15567987f, 0.05776197f, 
    0.04851115f, -0.02288768f, -0.08229099f, -0.09805946f, -0.06920203f, -0.09399112f, -0.03368851f, -0.17936175f, 
    -0.13011867f, 0.12382717f, 0.02260221f, 0.18829741f, -0.00343379f, 0.18999694f, -0.10708033f, -0.14366068f, 
    -0.17451273f, -0.07662705f, -0.09032913f, -0.08102777f, 0.37196478f, 0.11658604f, 0.11069519f, 0.04258082f, 
    -0.03771117f, -0.01926327f, 0.08900108f, 0.06433579f, 0.10654074f, 0.01889983f, 0.20010440f, 0.04364793f, 
    -0.02345274f, 0.27784568f, 0.15642500f, -0.04261365f, -0.11747343f, -0.05406381f, -0.03194663f, -0.03384927f, 
    -0.06971526f, -0.04619099f, -0.00231699f, -0.13995633f, 0.15285213f, 0.24472761f, -0.01735189f, 0.09468780f, 
    -0.02733105f, -0.01344054f, -0.01644950f, -0.07245562f, -0.07549789f, 0.00179836f, -0.09064764f, -0.03366259f, 
    -0.17083387f, -0.04840888f, 0.25193286f, -0.01635457f, -0.17112929f, -0.06559286f, 0.12741041f, 0.49262989f, 
    -0.02061955f, -0.19416140f, 0.07808390f, -0.08483250f, -0.08798727f, -0.06640079f, -0.32017884f, -0.02077723f, 
    -0.05954678f, 0.16554876f, -0.05815388f, -0.04169367f, 0.10645658f, 0.14653032f, 0.15672044f, -0.02520329f, 
    0.19752024f, 0.29550028f, -0.28014782f, 0.16557270f, 0.03299183f, 0.04530652f, 0.00099463f, 0.04805474f, 
    0.14078575f, 0.21315482f, 0.01428479f, 0.15090461f, -0.10805487f, -0.33537480f, -0.16603191f, 0.13981105f, 
    0.14607605f, -0.14348289f, 0.10349526f, -0.00188369f, 0.16786651f, 0.01604940f, 0.06092631f, -0.04803801f, 
    0.02993811f, 0.13469836f, 0.11943362f, 0.07880456f, -0.08291551f, 0.05404770f, -0.08707387f, 0.09076465f, 
    0.09524323f, 0.23597060f, -0.02834127f, 0.06471667f, 0.16356756f, 0.05577885f, 0.11851263f, -0.11552428f, 
    -0.00225590f, -0.07010581f, -0.12457922f, 0.17969358f, 0.04108024f, 0.20268542f, -0.10089554f, 0.22449805f, 
    0.36326617f, 0.18511772f, -0.08279507f, 0.06190838f, 0.01598403f, -0.10495413f, 0.11426825f, -0.01024345f, 
    0.00090026f, 0.15643562f, -0.07142910f, -0.00277344f, 0.22690880f, -0.04244633f, 0.13573302f, -0.37435862f, 
    -0.03296826f, -0.11559556f, -0.04977319f, 0.19219138f, -0.04806842f, -0.03561913f, 0.04265739f, -0.02455697f, 
    -0.22558272f, 0.06604477f, 0.14912362f, 0.02243154f, -0.18980676f, 0.07280408f, 0.04913659f, -0.11654455f, 
    -0.00070045f, -0.04017387f, -0.06445444f, -0.01603517f, 0.15842806f, 0.07130788f, 0.05299218f, 0.04290053f, 
    0.41876918f, 0.27295300f, 0.03189170f, 0.07982135f, 0.06211149f, 0.14286217f, 0.21581367f, -0.10748195f, 
    0.14722516f, 0.06182378f, 0.14675592f, -0.05380962f, 0.00043143f, 0.03840386f, -0.02406920f, 0.01280491f, 
    0.12482295f, 0.27978781f, 0.30297208f, 0.03364251f, 0.11487589f, 0.02403777f, 0.00025145f, 0.01681812f, 
    -0.02294715f, 0.00977984f, 0.03391971f, 0.00312680f, -0.05651662f, 0.04469453f, 0.03929963f, -0.06684358f, 
    -0.04463895f, 0.07872207f, -0.10331595f, -0.00120187f, 0.07474820f, 0.02793454f, -0.06889484f, 0.13224275f, 
    0.01527565f, -0.02147021f, -0.10076985f, 0.00362668f, 0.16213915f, 0.04659633f, 0.16199940f, -0.10991193f, 
    -0.09700917f, 0.02202145f, -0.15019259f, 0.05881659f, 0.00172904f, -0.14890477f, 0.12990108f, -0.00521285f, 
    -0.07028947f, 0.33263183f, 0.12131814f, -0.19478546f, -0.03895702f, -0.07563534f, 0.11649653f, 0.12652032f, 
    0.03577964f, -0.05074063f, 0.08609633f, 0.04153147f, 0.08142807f, -0.26342103f, -0.30186749f, -0.01376018f, 
    0.13882123f, 0.00319572f, -0.10599561f, 0.03304496f, 0.19504431f, 0.04920633f, 0.01164960f, 0.02016512f, 
    0.12687862f, 0.12239935f, 0.28918380f, -0.05497468f, -0.10858453f, -0.03377621f, 0.22806102f, 0.16150494f, 
    0.07779024f, -0.08874482f, 0.14504518f, -0.04638630f, -0.39017320f, -0.39338887f, -0.03627971f, 0.33006138f, 
    -0.07820796f, 0.08367086f, -0.02391863f, -0.13878310f, 0.07284925f, 0.05471707f, 0.18387185f, 0.01633177f, 
    -0.17492092f, -0.01095875f, -0.37555712f, -0.09049694f, 0.03874554f, 0.07099071f, 0.00242835f, 0.09464280f, 
    -0.04848781f, -0.03062845f, -0.05446439f, -0.06981944f, -0.02320941f, 0.06256290f, 0.28173885f, 0.26935229f, 
    0.02539197f, -0.24173075f, -0.12589370f, 0.01341487f, 0.07219504f, 0.08953238f, -0.03740730f, 0.23428088f, 
    0.10163104f, -0.04676676f, 0.07559648f, -0.15495962f, 0.01568463f, 0.00724617f, -0.01852646f, -0.04809154f, 
    0.11131534f, -0.00319170f, 0.06563201f, 0.18985109f, 0.12988217f, -0.06485648f, -0.46414021f, -0.16851395f, 
    0.00234806f, 0.08331497f, 0.16402014f, 0.07178804f, -0.00743777f, -0.01068682f, 0.24672505f, 0.04142667f, 
    0.00529422f, -0.23429698f, -0.25718930f, -0.18226525f, 0.03814367f, 0.17458488f, 0.05939104f, -0.02400031f, 
    0.09508709f, 0.20959209f, 0.12348954f, 0.00484684f, 0.59158987f, 0.28077793f, -0.08271862f, 0.07938622f, 
    -0.05620768f, -0.15380175f, -0.05753326f, 0.04866389f, -0.03715729f, -0.01931756f, 0.06577046f, -0.02393822f, 
    0.22292383f, 0.01196159f, 0.40776485f, -0.18498918f, -0.18618315f, -0.09252193f, -0.00060699f, -0.02774631f, 
    -0.06577390f, -0.12870193f, -0.11903740f, 0.05609835f, -0.04196079f, 0.06344071f, 0.03013936f, -0.11466766f, 
    0.17403191f, 0.22560382f, -0.13194330f, -0.08598940f, 0.09698931f, 0.17581446f, 0.15670583f, -0.02126302f, 
    0.29248711f, -0.18510059f, 0.05495365f, -0.01908227f, 0.00462417f, -0.04528703f, 0.02159500f, -0.04596034f, 
    -0.15928951f, 0.04127647f, 0.03707029f, 0.04629548f, -0.11286608f, -0.17742454f, 0.00946223f, 0.01741453f, 
    0.13759634f, 0.05858144f, -0.02236456f, -0.00248313f, -0.00333625f, -0.01953273f, -0.08018330f, -0.06079534f, 
    -0.10896380f, -0.15222251f, 0.19232565f, 0.25831378f, -0.10111307f, -0.05700247f, -0.08390996f, -0.08112370f, 
    0.04199545f, -0.06351407f, -0.05196317f, 0.02377488f, -0.11848609f, -0.32693192f, -0.21357675f, 0.13455316f, 
    0.07636458f, -0.00161890f, -0.02754100f, -0.05574968f, 0.00315260f, -0.16109550f, -0.01109888f, -0.01311229f, 
    0.04203922f, -0.02181050f, -0.05843844f, -0.01517358f, 0.00482237f, 0.04339904f, -0.00785583f, 0.01418477f, 
    -0.01672196f, -0.06445672f, -0.02190483f, 0.05767507f, -0.00079924f, 0.03947319f, -0.02779611f, 0.00534053f, 
    0.03737370f, -0.00696748f, -0.01108698f, 0.06255692f, -0.04186628f, 0.01650946f, 0.01892314f, 0.01098814f, 
    0.03597680f, 0.01101917f, -0.07086202f, 0.06485408f, -0.07066712f, -0.02569218f, -0.05822182f, -0.02311447f, 
    -0.02228242f, 0.05477529f, -0.05468295f, 0.04826441f, 0.00262557f, -0.05444204f, -0.04589571f, 0.05374575f, 
    -0.01775644f, -0.07149067f, -0.07038174f, -0.01373448f, -0.04724091f, 0.05129494f, -0.02599963f, 0.03287758f, 
    -0.05115145f, -0.05496264f, 0.01591525f, 0.02284665f, -0.05105432f, -0.03256408f, 0.05231259f, -0.00408911f, 
    0.00738038f, -0.00140106f, -0.05578300f, 0.02965223f, -0.04979797f, -0.04898944f, 0.02854291f, 0.01097589f, 
    -0.02337301f, 0.06727945f, 0.00719267f, -0.00026596f, 0.04222167f, 0.02078236f, 0.04387603f, 0.02335612f, 
    0.04111917f, 0.04586454f, -0.00344626f, -0.00164495f, 0.06082938f, 0.00363926f, -0.02007068f, 0.00150677f, 
    -0.00504603f, 0.05947955f, 0.06077859f, -0.01242569f, -0.00170393f, 0.05075050f, -0.04041705f, 0.03084582f, 
    0.01543600f, 0.00145341f, 0.02504986f, 0.04986821f, 0.06364277f, -0.06135695f, 0.01638425f, 0.03417064f, 
    0.06203697f, 0.00749881f, -0.03083131f, -0.05612858f, 0.03195503f, 0.01991528f, 0.05517421f, -0.03401081f, 
    -0.04002407f, -0.02749455f, -0.03746513f, -0.05778760f, -0.05124484f, -0.04629559f, -0.06450196f, 0.03610731f, 
    -0.02718943f, -0.00380751f, -0.04234964f, -0.04845229f, -0.05507294f, -0.03954920f, -0.05194172f, -0.04515491f, 
    -0.04896073f, -0.06457560f, -0.03067091f, 0.01143359f, -0.04757558f, -0.06158242f, -0.03469300f, -0.06250853f, 
    -0.03052532f, -0.01922969f, 0.03300726f, -0.02541243f, -0.00687970f, -0.00436470f, -0.02987565f, 0.02114843f, 
    0.01467557f, -0.06336585f, 0.04315702f, -0.05178057f, -0.02962180f, -0.04431050f, -0.00537753f, 0.05072938f, 
    0.02788679f, -0.05365434f, 0.04911951f, -0.01618249f, -0.03032250f, 0.06355178f, -0.06750270f, -0.05383258f, 
    -0.00609564f, -0.00738722f, -0.01539142f, 0.00365677f, -0.06893085f, 0.02784230f, -0.03705636f, -0.06513870f, 
    -0.07030618f, 0.03209908f, 0.03415847f, -0.00635226f, 0.06509936f, -0.03528121f, -0.04942838f, -0.04753065f, 
    -0.02367611f, -0.01611358f, -0.01981659f, 0.04981583f, 0.04425470f, 0.05865920f, -0.05504907f, 0.07204393f, 
    -0.03386963f, 0.02394101f, -0.00274344f, -0.03890299f, -0.02459416f, -0.02169925f, 0.02325345f, -0.04275169f, 
    0.00867242f, -0.06119231f, -0.05541083f, 0.04074496f, 0.01265741f, -0.04956247f, -0.02588134f, -0.05365327f, 
    0.05373837f, 0.10315316f, -0.06383008f, -0.04546037f, 0.28398281f, 0.29337913f, 0.06251197f, 0.04674722f, 
    -0.05904309f, -0.06851891f, 0.06223037f, 0.08789418f, 0.11243203f, 0.25516275f, 0.09644847f, 0.18610451f, 
    -0.18200806f, -0.09087357f, -0.19640839f, -0.26483738f, -0.26252806f, -0.01854135f, -0.21195683f, -0.23018780f, 
    -0.02052904f, 0.08125389f, -0.12223686f, 0.13250476f, 0.10285807f, 0.13428569f, 0.17958228f, 0.18426265f, 
    0.03018856f, 0.07238496f, 0.11847997f, -0.10827235f, 0.05235285f, -0.22715299f, -0.13496931f, -0.39540491f, 
    -0.04955663f, -0.01124252f, -0.08476973f, 0.11138363f, 0.09816271f, 0.17523302f, -0.00754775f, 0.10913190f, 
    0.25247985f, 0.08153150f, 0.08422727f, 0.34474531f, 0.02711375f, -0.02573602f, -0.09635489f, 0.24157296f, 
    0.20252177f, 0.28978246f, 0.07597998f, 0.28609073f, 0.08003610f, -0.17527798f, -0.08145133f, -0.02106544f, 
    0.30242282f, 0.06374156f, 0.09875991f, 0.07436056f, 0.07138787f, -0.05447996f, 0.06583206f, -0.14047061f, 
    -0.06337496f, 0.02722394f, -0.27800548f, 0.12318061f, -0.08411489f, 0.21455999f, 0.12033456f, 0.15925819f, 
    0.14097840f, 0.16209765f, 0.14259465f, -0.02682249f, 0.14591500f, -0.25676525f, 0.47696173f, 0.12467688f, 
    -0.10307895f, 0.10002391f, -0.18682933f, 0.14674290f, -0.13201600f, 0.05036344f, -0.24326578f, 0.01836416f, 
    0.14229620f, 0.22191198f, 0.06744411f, 0.29198560f, -0.19530228f, -0.21550249f, 0.02039501f, -0.13077781f, 
    -0.07721156f, -0.01931825f, 0.02308929f, -0.16656804f, -0.28120530f, -0.09178412f, 0.38514873f, -0.25246060f, 
    -0.11135835f, -0.06791291f, -0.07570656f, 0.02949859f, -0.15561511f, -0.23564744f, 0.02990159f, 0.21478483f, 
    0.20089802f, 0.29104000f, -0.18941821f, 0.22348846f, -0.03443651f, 0.07403441f, 0.02448478f, -0.23872180f, 
    -0.01674047f, 0.11579767f, 0.05515979f, -0.01913126f, 0.27552837f, -0.01764317f, 0.11672984f, -0.06546348f, 
    0.16027036f, -0.01517619f, 0.22664843f, 0.20435485f, -0.10111069f, 0.12574342f, 0.09919979f, 0.06769274f, 
    -0.09573589f, -0.04104596f, 0.23543185f, -0.20320702f, -0.13640089f, -0.07192555f, 0.00036717f, 0.04725664f, 
    -0.02271979f, -0.11426625f, 0.24701010f, -0.16968729f, 0.28045774f, 0.20029633f, -0.07978984f, 0.10056759f, 
    -0.21389864f, -0.15397154f, 0.00850319f, -0.17090213f, 0.12769447f, 0.21138784f, 0.01019885f, 0.14628670f, 
    0.04110932f, 0.43362251f, 0.16134925f, -0.02873276f, -0.13850470f, -0.21655685f, -0.06278965f, 0.10104739f, 
    -0.01248067f, 0.06424805f, 0.04496260f, -0.06746564f, -0.07888519f, 0.20704623f, 0.37848932f, 0.07352745f, 
    -0.04652970f, -0.09762170f, -0.26385015f, -0.07269780f, -0.18237233f, -0.04241199f, -0.11910829f, -0.17960887f, 
    -0.02317657f, 0.03163769f, -0.05153269f, 0.04406502f, -0.00223094f, 0.06203321f, -0.07898901f, -0.03387089f, 
    -0.00945973f, -0.04042850f, -0.00930507f, 0.05263188f, -0.06222105f, 0.05431039f, 0.00353241f, 0.03752519f, 
    -0.00070900f, 0.05019379f, -0.06633200f, -0.06897894f, -0.03833659f, -0.00661966f, 0.02144833f, 0.03844341f, 
    -0.05667249f, 0.04934838f, -0.02062560f, 0.00672229f, -0.05579854f, 0.02055211f, 0.04681023f, 0.06085967f, 
    -0.02434131f, -0.04862921f, 0.05346658f, -0.04968434f, -0.08227612f, 0.03126740f, 0.05314079f, -0.02327168f, 
    -0.00166597f, 0.01334528f, -0.05351051f, -0.03441480f, 0.03442200f, -0.03422540f, -0.05491806f, -0.06122337f, 
    -0.06729349f, 0.01143016f, -0.05572985f, -0.00420379f, 0.03089441f, 0.05551232f, -0.01775214f, 0.02870090f, 
    -0.01048882f, -0.06049207f, -0.04611902f, -0.03496218f, 0.00530619f, 0.04468989f, -0.03896773f, 0.04382033f, 
    -0.02669873f, 0.01096695f, 0.03392531f, 0.05385002f, 0.00559324f, -0.02957274f, 0.03003477f, -0.02155688f, 
    0.02285593f, -0.02172439f, -0.01553531f, 0.01563140f, 0.00821925f, 0.01435408f, 0.01536936f, -0.02226854f, 
    0.03541950f, 0.00253773f, 0.01997658f, -0.04807007f, 0.02546991f, 0.01386928f, -0.00121555f, -0.05450955f, 
    -0.04636167f, -0.01754426f, 0.01287937f, 0.02297910f, 0.03327168f, -0.02486665f, -0.08332179f, -0.04832642f, 
    0.02967991f, 0.00328466f, 0.03580774f, -0.00631371f, -0.04873234f, -0.04908137f, -0.03301392f, -0.03844675f, 
    0.02946532f, -0.06276650f, 0.05623052f, 0.06151849f, -0.06569046f, -0.07297798f, -0.01503680f, -0.06806606f, 
    -0.00034075f, -0.03949201f, -0.02837567f, -0.06249180f, -0.06204055f, 0.03433755f, -0.05851430f, 0.02143442f, 
    0.01166373f, 0.05009422f, -0.01711353f, -0.03357356f, -0.00418642f, 0.05301329f, -0.06982974f, 0.01408223f, 
    -0.06753203f, 0.01404510f, 0.06813700f, -0.04103874f, -0.05333093f, -0.02365362f, -0.03967855f, -0.06144618f, 
    0.01133173f, 0.06074090f, -0.03102281f, 0.01484600f, 0.01808410f, 0.05589632f, 0.04585116f, -0.05609081f, 
    0.03965006f, -0.04980385f, -0.07363634f, -0.00653360f, 0.06599046f, -0.00898019f, -0.05274140f, -0.01222648f, 
    -0.05142574f, 0.02481681f, 0.00404272f, -0.04090504f, -0.06827319f, -0.04426793f, -0.00918385f, -0.01113367f, 
    -0.03875268f, -0.03792742f, -0.06141235f, -0.04421606f, 0.02313806f, -0.02239874f, -0.04539932f, -0.03970277f, 
    -0.07854374f, 0.00985862f, -0.07369366f, 0.05866414f, 0.04527226f, -0.05583338f, 0.00511109f, 0.01111459f, 
    0.04376330f, 0.04775039f, 0.05109100f, -0.00394324f, -0.04890446f, 0.03068286f, -0.06043852f, -0.02404830f, 
    -0.05981814f, -0.03831268f, 0.06480409f, -0.07220512f, 0.04012110f, 0.03925539f, -0.03294356f, 0.03541807f, 
    0.04745882f, -0.04857535f, -0.00021455f, 0.03520657f, 0.03310378f, -0.05978350f, -0.00302054f, 0.05458970f, 
    -0.02523072f, -0.06847228f, -0.01361017f, 0.02544875f, -0.03014053f, 0.04114819f, -0.03842459f, 0.00427925f, 
    0.04057800f, 0.04503062f, 0.04835555f, 0.01623332f, -0.07583728f, -0.03842722f, 0.00933296f, -0.06094673f, 
    -0.07917283f, 0.06442767f, -0.04007048f, -0.07501902f, -0.00331201f, 0.00428998f, 0.05672445f, -0.07796711f, 
    -0.01872409f, -0.05019795f, -0.03001233f, 0.03561884f, 0.07844236f, -0.01729073f, -0.01502322f, -0.02904492f, 
    0.00105946f, 0.04609593f, -0.01740201f, 0.03635500f, -0.05715941f, -0.00597661f, -0.02258171f, 0.02739863f, 
    -0.06956063f, -0.01794129f, 0.05831008f, -0.05229706f, -0.03122008f, -0.04317493f, 0.02059477f, -0.04980823f, 
    0.01409769f, 0.01560765f, -0.05268474f, -0.00980240f, -0.06587180f, 0.02397075f, 0.05697440f, 0.03811975f, 
    0.00746869f, -0.01011695f, -0.01979019f, 0.06077110f, -0.06953406f, -0.02327961f, -0.01910786f, 0.08046471f, 
    0.03683799f, 0.04243572f, 0.00277230f, -0.00315322f, -0.00253054f, 0.01458172f, 0.00253227f, 0.02968466f, 
    -0.01422634f, -0.05891773f, -0.02328113f, 0.03501505f, 0.05883503f, 0.05589014f, -0.00535650f, -0.00129916f, 
    -0.00655131f, -0.00328462f, -0.04236932f, -0.07138918f, -0.06504871f, -0.04628175f, -0.01971460f, -0.01257170f, 
    -0.06024374f, 0.05311892f, -0.04208178f, -0.02578956f, -0.02592108f, -0.03251609f, -0.03077326f, -0.00148491f, 
    0.06199856f, -0.07825356f, 0.00656330f, 0.02424400f, -0.07362131f, 0.00412653f, -0.00111689f, 0.00258935f, 
    -0.03330587f, -0.03599917f, 0.00759417f, 0.05035215f, -0.06742937f, -0.06548132f, -0.05501452f, 0.02349295f, 
    -0.02336991f, 0.02906968f, -0.06979475f, -0.00808803f, 0.02668807f, 0.04491025f, -0.00140467f, 0.03507643f, 
    -0.05979963f, -0.01579300f, -0.02044151f, -0.02351253f, -0.06443199f, 0.00064605f, 0.00055489f, -0.03429841f, 
    0.01871789f, 0.01534937f, 0.03355906f, 0.04184116f, -0.04353876f, -0.07870058f, -0.01879466f, -0.01404882f, 
    0.05276632f, 0.00997707f, -0.03875175f, -0.05239378f, -0.06529993f, 0.03908376f, -0.05142000f, 0.04939315f, 
    -0.05118447f, 0.04619966f, 0.00050127f, -0.02342464f, -0.00687840f, 0.01538320f, 0.04577591f, 0.00956587f, 
    0.04729404f, 0.01780665f, -0.04210903f, -0.07737035f, 0.06470542f, -0.03641964f, -0.00274633f, 0.00337865f, 
    0.02813972f, -0.00555651f, -0.04040005f, 0.02144675f, -0.00878201f, 0.01870103f, -0.06469882f, 0.04603646f, 
    0.06211218f, 0.02851521f, -0.02532632f, 0.04709505f, 0.03902247f, -0.04816979f, -0.04242899f, -0.01619122f, 
    0.00565433f, -0.03901659f, -0.06287035f, -0.02099490f, -0.04239729f, -0.01220550f, -0.03712018f, -0.00593493f, 
    0.02537055f, -0.05453846f, -0.02972438f, -0.03441801f, -0.04158636f, 0.01494254f, 0.04814995f, 0.02415919f, 
    -0.00203043f, -0.04904338f, 0.03306742f, -0.09005710f, -0.02385931f, 0.01065497f, -0.08580065f, -0.05705328f, 
    0.04141438f, 0.01365854f, 0.03610180f, 0.03544066f, -0.01149829f, -0.01227506f, -0.06307737f, -0.08687528f, 
    0.04200941f, -0.06754210f, -0.08283506f, 0.01198888f, 0.03057684f, -0.01176165f, -0.05409248f, -0.07629170f, 
    0.01156736f, 0.01510887f, 0.01548545f, -0.00452068f, -0.00157602f, 0.05189600f, 0.05333298f, -0.05072457f, 
    -0.00664677f, -0.06837359f, -0.01332326f, 0.05080392f, 0.02415399f, 0.00652668f, -0.00399942f, 0.03931029f, 
    -0.03104323f, -0.08512474f, 0.05270116f, 0.00128933f, -0.03107560f, 0.03963156f, 0.02117111f, -0.02792076f, 
    -0.07380723f, -0.03865183f, 0.02656821f, -0.01489312f, -0.03173866f, -0.07135946f, -0.06681817f, 0.01745540f, 
    0.03343587f, -0.01381096f, -0.07523855f, -0.03162398f, 0.04537466f, 0.01296778f, 0.03285003f, -0.00180412f, 
    -0.03568348f, 0.03829049f, -0.01742287f, -0.06553686f, 0.04690577f, -0.02931220f, -0.02919987f, -0.05614780f, 
    -0.04368720f, 0.00995239f, -0.02917330f, -0.06081643f, 0.01303911f, 0.02005624f, -0.03872065f, -0.07519362f, 
    -0.02744352f, -0.06494062f, 0.01151235f, -0.01934004f, -0.05369876f, 0.01477950f, -0.03905347f, 0.02629557f, 
    0.05124581f, -0.05489676f, -0.04261690f, 0.00770075f, 0.01601322f, -0.03152734f, 0.01951398f, 0.03853634f, 
    0.05448895f, 0.05417795f, 0.03833479f, -0.04373508f, 0.05791332f, 0.04070829f, -0.04576855f, 0.00048725f, 
    0.00991240f, -0.00597442f, 0.05414002f, -0.03932144f, 0.03527568f, -0.08264530f, -0.04840699f, 0.02515342f, 
    -0.01054210f, -0.02013798f, 0.02777598f, -0.03383072f, -0.08294194f, 0.04775901f, 0.01095536f, -0.06133480f, 
    -0.03147702f, 0.04369769f, -0.02119033f, 0.02449712f, 0.00228504f, -0.07690905f, -0.07732416f, -0.07636171f, 
    0.01310326f, 0.01381683f, 0.04587332f, -0.02447035f, -0.07788595f, -0.05096122f, 0.03309217f, -0.03820140f, 
    -0.03033492f, 0.00216171f, 0.04790910f, 0.04559961f, -0.05764228f, -0.02384392f, -0.09199667f, -0.05303815f, 
    0.04843320f, 0.00517792f, 0.02673260f, 0.02455562f, -0.04346922f, -0.01103442f, -0.07788701f, -0.01472289f, 
    0.03939780f, -0.04514879f, 0.02860502f, -0.03070006f, -0.00165084f, 0.01888236f, -0.05175902f, -0.06851573f, 
    -0.07651008f, -0.08491442f, -0.02092836f, 0.04456417f, -0.01774989f, 0.01869833f, -0.08314744f, 0.04126862f, 
    -0.03710850f, -0.00190701f, 0.03173003f, 0.02127285f, -0.04980133f, -0.02785888f, -0.03133287f, 0.01712743f, 
    0.00390104f, -0.09801827f, 0.00579246f, 0.00209290f, 0.02359745f, -0.08061641f, 0.02157817f, 0.01153637f, 
    0.24395707f, -0.00030737f, 0.11674147f, 0.20856330f, -0.03377397f, -0.19343600f, 0.13610069f, 0.03246460f, 
    -0.08142275f, 0.03806346f, -0.00734034f, 0.04641003f, -0.04982577f, -0.30239126f, 0.16483073f, -0.20555918f, 
    -0.23160255f, -0.13039136f, -0.06453773f, -0.09693056f, -0.20957552f, 0.02960210f, 0.20838195f, 0.15119758f, 
    -0.26923963f, -0.06666265f, 0.24330629f, -0.01537609f, -0.00187021f, 0.00304352f, -0.00389429f, 0.08518109f, 
    0.01145909f, 0.06783490f, -0.00767227f, 0.18113811f, 0.40873954f, 0.49395010f, 0.15219039f, 0.04071468f, 
    -0.08286159f, 0.01094339f, -0.25082940f, 0.09629993f, -0.16512227f, -0.07087169f, 0.03851822f, 0.00831823f, 
    0.12797442f, 0.04110800f, 0.22314002f, -0.02325995f, -0.00606836f, 0.00191405f, -0.02871505f, -0.18758188f, 
    0.07471512f, -0.02411731f, 0.05912558f, 0.13828184f, -0.30705881f, -0.00766069f, -0.28905424f, 0.13962762f, 
    0.01828567f, 0.12380778f, 0.10764015f, 0.08862527f, -0.06475285f, 0.21612802f, 0.02642369f, -0.06708394f, 
    -0.01227601f, 0.29767960f, 0.29174480f, 0.11720356f, -0.07292029f, -0.26279378f, 0.14475515f, -0.01925415f, 
    0.12943742f, 0.11098818f, -0.15103456f, -0.01654894f, 0.13254608f, 0.23065637f, 0.57171631f, -0.12232193f, 
    0.07021680f, -0.16634558f, 0.19932288f, 0.05870928f, 0.10509903f, -0.06141245f, 0.04524202f, 0.18865852f, 
    -0.04796427f, -0.00019174f, 0.13094556f, 0.17392947f, -0.10258181f, -0.06465340f, -0.06489046f, -0.16375968f, 
    -0.06456666f, -0.15128452f, 0.04957617f, 0.24906842f, -0.19896027f, -0.22697647f, -0.20439506f, 0.00505688f, 
    -0.16799931f, -0.08338311f, 0.28260243f, 0.12040200f, 0.12625054f, 0.07680992f, -0.15209134f, 0.09063563f, 
    -0.62903631f, -0.08375327f, -0.33934897f, 0.20709251f, 0.04470781f, -0.17458078f, 0.27078319f, 0.34880435f, 
    -0.03561152f, -0.03843245f, -0.05377564f, 0.07442903f, -0.07796202f, -0.38666296f, -0.17817007f, 0.24025425f, 
    0.02651422f, -0.07080539f, -0.27597231f, -0.26890877f, 0.09201834f, -0.23276179f, -0.04106966f, -0.05894689f, 
    -0.31382728f, 0.15455136f, -0.20268904f, -0.09442205f, 0.02930269f, 0.12103586f, -0.06013821f, 0.06877309f, 
    0.05273676f, 0.17563437f, -0.02377653f, 0.14476246f, -0.10739344f, 0.10735318f, -0.12053998f, 0.11058674f, 
    0.01982394f, -0.05612141f, -0.11948379f, -0.11402793f, 0.02400382f, 0.03130405f, 0.10419236f, -0.19039978f, 
    -0.08654765f, -0.15515956f, -0.16897076f, -0.06836450f, 0.03036905f, 0.17288877f, -0.01144189f, -0.12717173f, 
    0.15359540f, 0.07854819f, 0.06318059f, -0.04081232f, 0.23919386f, 0.17243713f, 0.18523394f, -0.02011059f, 
    -0.26208231f, 0.04527606f, 0.17971815f, 0.04848141f, -0.01028903f, 0.22027604f, 0.11064196f, 0.22449559f, 
    0.00160748f, -0.05448229f, 0.00404862f, -0.11146262f, -0.06714258f, 0.20257458f, 0.21719266f, 0.08932389f, 
    -0.03075410f, 0.07338182f, 0.02157913f, -0.07398484f, -0.09883542f, 0.22775649f, -0.05332780f, -0.14981829f, 
    -0.07233039f, -0.03617618f, -0.06717683f, -0.10871486f, -0.07350246f, -0.09212255f, -0.00237000f, -0.14960347f, 
    0.14661300f, -0.11969548f, 0.01787887f, -0.11277757f, -0.05658920f, 0.26808408f, 0.01029474f, 0.11705945f, 
    -0.00658203f, 0.13771273f, -0.04092604f, 0.10897215f, -0.17743397f, 0.35792696f, 0.19982117f, 0.24635468f, 
    0.03960476f, 0.06259404f, 0.04971388f, -0.15471514f, 0.07865895f, -0.08626079f, 0.23708095f, 0.07032928f, 
    -0.25394660f, 0.02885737f, 0.36464161f, 0.05049608f, -0.20205805f, 0.05258005f, 0.07107837f, 0.09182988f, 
    0.01361925f, 0.04576012f, 0.10440020f, -0.01640465f, 0.20206535f, 0.24239667f, 0.02795901f, 0.02753232f, 
    0.09740635f, 0.02451878f, 0.10977353f, 0.16429810f, 0.09569836f, 0.02433092f, -0.16080534f, -0.04110803f, 
    0.03787410f, -0.12891451f, 0.15238632f, -0.10164199f, 0.11253398f, -0.00951013f, -0.05208374f, 0.06379100f, 
    0.00372468f, -0.10369185f, 0.04928635f, 0.14315988f, -0.18692970f, -0.27426419f, -0.14078298f, 0.01178424f, 
    0.02492570f, 0.09205754f, 0.07829402f, -0.00587637f, 0.06805956f, -0.11367735f, -0.12709475f, -0.18110505f, 
    -0.11914568f, 0.07223380f, 0.39546046f, -0.20326783f, -0.08920534f, 0.21042848f, -0.29161650f, -0.08301951f, 
    0.20289373f, -0.15584767f, 0.03057539f, -0.03594761f, -0.01527135f, 0.27136847f, -0.23634905f, -0.00800821f, 
    0.12329504f, 0.01869749f, -0.10953451f, -0.23630622f, -0.08046229f, -0.02441354f, -0.10017278f, -0.08553610f, 
    0.34254837f, -0.23447865f, -0.02526402f, -0.07281768f, 0.06324667f, -0.03432402f, 0.06691029f, 0.11844681f, 
    0.03810097f, 0.21023861f, 0.05542389f, 0.21930034f, -0.23240760f, 0.20958993f, -0.08588203f, -0.18676959f, 
    0.18519337f, 0.07231742f, 0.07415211f, 0.00977725f, -0.07270401f, 0.04215928f, -0.03707003f, -0.10692433f, 
    0.08882906f, 0.11600643f, 0.10490187f, 0.04977351f, -0.05517683f, -0.13362759f, 0.08576038f, -0.24139500f, 
    -0.10742969f, 0.05009549f, -0.10518959f, 0.06046989f, -0.00832402f, -0.05901167f, 0.11284053f, -0.00873572f, 
    -0.15703852f, -0.02905005f, 0.10351735f, -0.05690247f, 0.09045241f, -0.00229195f, 0.15692618f, 0.26354566f, 
    -0.02112243f, 0.10021575f, -0.14497623f, 0.19641252f, -0.07321628f, 0.15671103f, 0.05043808f, -0.11487643f, 
    0.12938175f, -0.01645858f, -0.01654842f, -0.05375858f, -0.07085608f, 0.21279886f, -0.04185813f, 0.11134145f, 
    -0.00526103f, -0.07806089f, -0.01077441f, -0.04744467f, -0.17032091f, -0.03838629f, -0.08983679f, -0.18560152f, 
    -0.05707585f, -0.05722545f, -0.04205211f, -0.01804881f, -0.03754927f, -0.04949323f, -0.06423340f, -0.05095137f, 
    0.05169296f, -0.06202232f, -0.01509938f, 0.04683805f, 0.06274488f, 0.05831742f, -0.04264856f, -0.06485152f, 
    0.04643433f, -0.01588928f, -0.05952244f, -0.07148141f, -0.07631826f, 0.03096456f, 0.00857858f, -0.03038139f, 
    -0.05618243f, -0.10739598f, -0.08905066f, 0.08665334f, 0.06381139f, -0.05482462f, -0.04380121f, 0.00604789f, 
    -0.04373505f, 0.06230758f, 0.03982850f, -0.05518680f, 0.04467305f, 0.01946426f, 0.01395852f, -0.08804524f, 
    -0.07217478f, -0.04333317f, -0.06576429f, -0.06933764f, -0.07299948f, -0.04685547f, 0.00327636f, -0.06114658f, 
    0.00381930f, -0.06018155f, 0.00264726f, -0.03789124f, -0.06835338f, 0.06374478f, -0.05616505f, 0.00762075f, 
    0.04761058f, -0.06657561f, -0.05148816f, 0.00645191f, 0.01936654f, -0.07733820f, 0.00387981f, -0.06171049f, 
    -0.02422024f, 0.02486148f, -0.00877285f, 0.01595224f, -0.00811471f, 0.06049860f, -0.02381237f, -0.03600004f, 
    -0.07573904f, 0.01308501f, 0.05952808f, 0.06237061f, -0.04497057f, -0.02902782f, 0.02174168f, -0.00408499f, 
    -0.05774591f, 0.01852641f, 0.03060988f, -0.02655129f, 0.02129934f, 0.01099174f, -0.05299437f, -0.00110629f, 
    -0.01784370f, 0.06616034f, 0.06261894f, -0.03602597f, 0.05751515f, -0.02693125f, 0.00973491f, -0.02723993f, 
    -0.06969877f, 0.04681152f, 0.02301294f, 0.04424694f, -0.05790130f, -0.05373780f, 0.01423179f, 0.01669238f, 
    0.01823219f, -0.08079545f, 0.05549286f, 0.05091870f, 0.09311932f, -0.06203191f, 0.08729724f, 0.00083413f, 
    0.00353508f, -0.03194105f, 0.06089732f, -0.04442405f, -0.03050845f, 0.02650734f, 0.00223395f, -0.00965223f, 
    0.04966045f, -0.12101183f, -0.05160360f, 0.00567000f, 0.03326859f, -0.02494716f, 0.07395664f, -0.01340103f, 
    -0.04612598f, 0.03515711f, 0.00675650f, -0.01661994f, -0.05086707f, 0.01676019f, 0.00331945f, 0.05051954f, 
    -0.00360462f, 0.04887694f, -0.03659953f, -0.02509595f, -0.00298898f, -0.07807823f, 0.05886850f, 0.04660296f, 
    0.00012157f, -0.03372554f, -0.02945672f, -0.04155368f, -0.00281836f, -0.01665638f, -0.06819368f, -0.07197456f, 
    -0.00097295f, -0.05741006f, -0.07376503f, 0.02245712f, 0.06052592f, -0.03051770f, -0.04558446f, -0.00088178f, 
    -0.06890751f, -0.05170538f, -0.05022360f, 0.00900807f, 0.03154967f, 0.02071237f, -0.02100769f, -0.06783407f, 
    -0.05808304f, -0.02893262f, 0.03703760f, -0.06747936f, 0.04208892f, -0.00037267f, -0.00469483f, -0.01468767f, 
    -0.06112238f, -0.07579955f, -0.04111062f, -0.06955310f, 0.00366651f, 0.02411693f, 0.02459515f, 0.01884546f, 
    0.03381336f, 0.00145753f, 0.06624565f, 0.04566057f, -0.07557739f, 0.02771264f, -0.05920118f, -0.03439708f, 
    -0.01332825f, 0.03041502f, 0.04411114f, -0.07388434f, -0.02652522f, -0.02229670f, -0.05870772f, 0.05027585f, 
    0.04667767f, -0.01882362f, -0.05635427f, -0.02113495f, -0.07271371f, 0.02649068f, 0.04774795f, -0.02302395f, 
    -0.04029242f, -0.05512892f, -0.01592384f, -0.04433556f, -0.06502066f, -0.01112572f, -0.01153392f, 0.02214253f, 
    -0.01721283f, -0.02077857f, 0.03213573f, -0.05173187f, -0.07930838f, 0.04115326f, -0.03499548f, 0.00375250f, 
    0.02383181f, 0.01019781f, 0.04765641f, 0.02562623f, -0.01450020f, 0.04082775f, -0.04484729f, 0.04502369f, 
    -0.01738005f, -0.02685412f, -0.04726016f, 0.04071353f, -0.00506125f, 0.00692606f, -0.08100026f, 0.03289843f, 
    -0.04349245f, 0.02569612f, -0.01067855f, -0.04377228f, -0.07257392f, 0.01784836f, -0.07589407f, 0.02365723f, 
    -0.04062631f, 0.01988836f, 0.00104852f, -0.05601636f, -0.06919008f, 0.02826731f, 0.02788390f, 0.05407562f, 
    -0.05153376f, -0.07064623f, -0.03284557f, -0.00155151f, 0.00535398f, -0.05991294f, -0.02857900f, -0.04739666f, 
    0.03306758f, -0.03833155f, -0.04295428f, -0.00417083f, -0.03227742f, -0.02480218f, -0.00089525f, 0.00865513f, 
    -0.00006978f, 0.01056122f, 0.01015362f, -0.04101523f, 0.05414293f, 0.00048132f, -0.03443737f, 0.00829409f, 
    0.02546772f, -0.07720298f, 0.01625179f, 0.01252860f, -0.03552802f, 0.02077113f, -0.04404678f, -0.06957341f, 
    0.01122864f, -0.01132968f, 0.02584768f, 0.01213927f, -0.00123580f, -0.04164803f, 0.05358506f, -0.08300870f, 
    -0.03579000f, -0.06928775f, -0.04668747f, -0.00191954f, -0.07299591f, 0.01922114f, -0.03486788f, -0.07736793f, 
    0.03215053f, -0.04156984f, -0.07880762f, 0.04538931f, 0.00219465f, 0.03206804f, 0.04106519f, -0.04873831f, 
    -0.02060929f, 0.00203742f, -0.05484770f, -0.02477404f, -0.01241936f, 0.02529365f, 0.02486965f, -0.09441559f, 
    -0.05399332f, -0.02969250f, -0.03234477f, 0.04444027f, -0.03393226f, -0.08000831f, -0.07674066f, -0.08332418f, 
    -0.01719886f, -0.08461200f, -0.06176778f, -0.05006973f, -0.01569090f, -0.01588759f, 0.00607207f, -0.07195931f, 
    0.04417364f, -0.02979949f, 0.03936567f, -0.03141337f, 0.05409491f, -0.00590633f, 0.05966056f, 0.05112940f, 
    -0.03616707f, -0.07141194f, 0.03772715f, -0.02580489f, 0.01563524f, 0.05183803f, 0.05503872f, 0.01565462f, 
    -0.01375928f, 0.00403277f, 0.04235026f, -0.05588453f, -0.01211037f, -0.04348628f, 0.03298434f, -0.07175620f, 
    0.02914558f, -0.03712412f, -0.04690061f, 0.01227133f, -0.04831131f, 0.00435065f, -0.00026203f, 0.02679717f, 
    0.02708880f, 0.00071668f, -0.06361083f, -0.00901802f, -0.01672772f, -0.00282522f, 0.05726140f, -0.05279324f, 
    0.00145681f, -0.03274316f, -0.03437850f, -0.02146818f, 0.04359499f, 0.05039582f, -0.05872307f, -0.00975233f, 
    -0.45783177f, 0.33779684f, 0.13215142f, -0.08450410f, -0.18396340f, -0.05002433f, 0.19228047f, 0.28272200f, 
    0.13102531f, 0.02582346f, -0.08842358f, -0.08580429f, -0.02373545f, 0.04274094f, -0.07095118f, -0.20750293f, 
    -0.10753670f, -0.17858706f, -0.03170985f, -0.06185755f, 0.22220878f, -0.10287925f, 0.10475264f, -0.09171372f, 
    0.06779245f, 0.14858435f, 0.24119726f, -0.12565611f, -0.04131302f, -0.05711154f, 0.28703329f, -0.03447051f, 
    -0.01127339f, 0.02473089f, 0.08514514f, 0.11480038f, -0.23862630f, -0.28038058f, 0.24303719f, 0.25514248f, 
    -0.07453712f, 0.13852277f, -0.02150151f, 0.03475966f, 0.20513947f, 0.06715675f, 0.22705771f, -0.01540921f, 
    0.18116511f, -0.14457856f, 0.23674822f, 0.08223383f, -0.03144917f, 0.10822446f, -0.01520985f, 0.03676092f, 
    0.03776906f, 0.08132976f, 0.49067414f, -0.07933710f, -0.06971479f, 0.01999670f, 0.04127142f, 0.25123546f, 
    0.01222664f, 0.03937256f, -0.02653725f, 0.15874147f, -0.00691334f, 0.04606697f, -0.21296512f, 0.19574340f, 
    -0.02839743f, 0.14152811f, 0.13359807f, -0.28090960f, -0.22891381f, -0.04727088f, -0.19742255f, 0.20738497f, 
    0.16170685f, -0.08182203f, 0.05275140f, -0.01793339f, -0.01148488f, 0.08087046f, -0.63665807f, -0.26794365f, 
    0.15412581f, -0.03300832f, 0.12965263f, 0.02934741f, 0.00688047f, -0.06569704f, 0.06840310f, -0.11743791f, 
    -0.03712165f, 0.05015028f, 0.24585743f, -0.13818629f, -0.06935632f, 0.20509638f, -0.20477591f, 0.14604478f, 
    -0.01490193f, 0.13169637f, 0.12068390f, -0.05815583f, 0.10184044f, 0.10087682f, -0.47940439f, -0.17110553f, 
    0.18024141f, 0.12389619f, -0.05615432f, -0.07775368f, -0.09531292f, -0.07165647f, -0.02501140f, -0.07084850f, 
    0.05816784f, -0.13703412f, 0.22498900f, -0.14539823f, 0.00888095f, 0.20522259f, 0.04895234f, 0.05106227f, 
    -0.01080664f, -0.00589631f, 0.01811422f, 0.28769317f, -0.24306530f, -0.28508025f, -0.12540188f, -0.11332131f, 
    0.07112492f, 0.11301208f, -0.07053477f, 0.15021612f, 0.01134436f, 0.00696351f, -0.15339933f, 0.01540170f, 
    0.62555254f, 0.22946583f, -0.34882388f, -0.02034609f, -0.13629843f, -0.14720967f, 0.16104004f, -0.02835083f, 
    0.04124184f, -0.03303813f, -0.08816961f, 0.00800648f, 0.06877667f, -0.23491223f, 0.04524418f, -0.08846679f, 
    -0.08036419f, -0.05524035f, 0.09998725f, 0.04513401f, 0.06161187f, -0.10167725f, 0.10488755f, 0.18570194f, 
    -0.16732490f, -0.12533560f, -0.21147156f, 0.09770363f, -0.32705879f, 0.15600780f, 0.09071425f, 0.13999970f, 
    0.16025914f, 0.00826664f, 0.07322787f, 0.12144664f, 0.36309558f, -0.05729233f, -0.38804206f, -0.27658734f, 
    0.05042500f, -0.21535619f, 0.06672923f, -0.00372913f, 0.06687622f, -0.09610423f, 0.00834244f, -0.08387864f, 
    0.01815182f, 0.02190299f, 0.01364739f, 0.06328416f, -0.00217581f, 0.03350636f, 0.05663030f, 0.04858650f, 
    -0.07148227f, -0.04205248f, -0.04712610f, -0.07701377f, -0.05249143f, 0.01718464f, -0.03815363f, 0.01147506f, 
    -0.00298822f, -0.03885303f, -0.05187706f, 0.00001596f, -0.01995902f, 0.00930895f, -0.00801094f, -0.01457579f, 
    -0.05757960f, -0.06308347f, 0.03345163f, 0.00739525f, -0.07730342f, -0.02625118f, 0.03493328f, -0.07279412f, 
    -0.02804682f, -0.00961785f, 0.04175047f, -0.06073526f, -0.03588938f, 0.05520871f, 0.02812681f, -0.01281004f, 
    0.02943016f, 0.01583966f, -0.03925073f, -0.07103495f, 0.05069728f, -0.06999400f, 0.03600011f, 0.00253206f, 
    -0.03742932f, 0.03730970f, -0.04774698f, 0.02529180f, 0.02206368f, -0.07038186f, -0.02174348f, -0.06748781f, 
    0.00735523f, -0.01127900f, -0.06181874f, -0.03726222f, -0.06927372f, -0.02533491f, -0.01996716f, 0.04691720f, 
    -0.00790539f, 0.00777922f, -0.05571378f, 0.00174091f, 0.01904870f, 0.05209180f, -0.07756653f, 0.04152449f, 
    0.00686664f, -0.00062822f, -0.00037219f, 0.01161307f, -0.04653127f, -0.03339915f, 0.02665529f, -0.07967092f, 
    -0.02158904f, 0.01149104f, -0.07945149f, 0.04021747f, 0.02820620f, 0.01192000f, -0.03572831f, -0.07360377f, 
    -0.03521703f, -0.02038506f, -0.03056853f, 0.00348552f, 0.02561903f, -0.04211151f, 0.00127446f, -0.06939915f, 
    -0.07275120f, -0.04195536f, 0.05498094f, -0.01842549f, 0.04490823f, -0.04463485f, 0.02240409f, 0.03553327f, 
    -0.01318819f, 0.00179666f, -0.00512856f, 0.00467822f, 0.04787748f, 0.03682484f, -0.01347695f, -0.06165503f, 
    0.00321078f, -0.04527179f, -0.02394464f, -0.03488650f, 0.04780851f, 0.02112836f, -0.05515242f, -0.00607702f, 
    0.04403852f, -0.04017138f, -0.02842814f, -0.04403027f, -0.03513803f, 0.06202798f, -0.05378780f, -0.05625046f, 
    0.01690746f, -0.04468416f, 0.02822863f, -0.07072192f, 0.05673323f, -0.04646241f, 0.00365919f, -0.00470881f, 
    -0.01938068f, -0.06707381f, 0.04354246f, -0.02359819f, -0.02719202f, 0.02430263f, -0.07712033f, 0.00508298f, 
    -0.07137883f, -0.00274970f, 0.03931908f, 0.01897051f, -0.00387797f, -0.06570458f, 0.01649122f, -0.01543550f, 
    -0.03918598f, -0.07677314f, -0.05059123f, 0.04695467f, 0.05589754f, -0.05505492f, 0.05076625f, -0.07252944f, 
    -0.02240832f, -0.03079821f, 0.04706411f, -0.06112562f, 0.00626610f, -0.07486948f, -0.06609206f, -0.00395612f, 
    -0.07419459f, -0.04866828f, -0.07808339f, -0.02229723f, -0.02508692f, -0.05211581f, 0.01451361f, -0.00965123f, 
    -0.06812432f, -0.03874405f, -0.06764629f, -0.00370528f, -0.06988548f, 0.03503972f, 0.05929559f, -0.01669701f, 
    0.04546019f, 0.01050009f, 0.04104621f, -0.03161640f, 0.02488388f, 0.01283900f, 0.05791402f, 0.04143957f, 
    0.33034620f, 0.33531532f, 0.16036259f, 0.10594789f, 0.08137333f, 0.18140715f, -0.01793769f, -0.08541843f, 
    -0.11602847f, 0.04596841f, 0.02729805f, -0.05805606f, 0.13367979f, 0.21593235f, -0.00772218f, 0.36672965f, 
    -0.20493199f, 0.02631446f, -0.02146075f, -0.02123856f, -0.19342577f, 0.05285449f, -0.15522610f, -0.15245791f, 
    0.23337291f, 0.03110712f, -0.12025976f, 0.13283835f, -0.02238359f, -0.06096898f, 0.22008452f, 0.16589727f, 
    -0.18692809f, -0.05927828f, -0.13265060f, -0.11984336f, -0.33321485f, 0.33257997f, -0.06660669f, -0.33257481f, 
    -0.05926493f, -0.01752237f, -0.04483204f, -0.15165600f, -0.07666532f, 0.04127976f, -0.13951631f, 0.11063065f, 
    0.08109272f, 0.30590227f, 0.08968715f, 0.23917638f, 0.11911365f, 0.00210775f, 0.02293213f, 0.10795527f, 
    -0.02516287f, 0.15155038f, -0.12749395f, 0.03825086f, 0.06211061f, 0.02320698f, -0.11652350f, -0.17036618f, 
    0.19529630f, 0.01294057f, 0.02813949f, 0.07292964f, -0.01608211f, -0.05381495f, 0.13849682f, -0.07506098f, 
    0.16609959f, 0.14345786f, -0.29786927f, -0.06751481f, -0.05793141f, 0.08867364f, -0.03800967f, 0.12618296f, 
    0.13399659f, 0.09561069f, -0.08562249f, 0.16265169f, 0.39010555f, -0.11609012f, 0.07804261f, 0.14456666f, 
    -0.05699610f, 0.02120055f, -0.13717574f, 0.01435407f, -0.13237692f, 0.09115797f, 0.02022933f, 0.05075814f, 
    0.08387364f, 0.33927342f, -0.02304897f, 0.05827950f, 0.06418237f, -0.00159985f, -0.13997671f, -0.12125930f, 
    -0.06574474f, 0.07454957f, 0.02555082f, -0.08357670f, 0.19010733f, -0.18429279f, 0.20097090f, -0.42234954f, 
    -0.03606437f, -0.13458201f, -0.03938004f, 0.17098086f, -0.00923652f, -0.06349298f, -0.15283960f, 0.00957400f, 
    0.13849925f, 0.13911550f, 0.15745568f, 0.21475591f, -0.14227214f, 0.23673156f, -0.15552706f, 0.13847202f, 
    -0.01807623f, 0.06466091f, -0.02397566f, -0.12011127f, -0.04444539f, 0.21323439f, -0.07767958f, -0.07190256f, 
    0.12650657f, 0.01198434f, 0.11837300f, 0.01883932f, -0.05103111f, -0.02106821f, 0.14602026f, 0.04766412f, 
    -0.16504800f, 0.00829589f, 0.23370288f, 0.00796996f, -0.00416702f, -0.00192941f, -0.03424815f, 0.08827087f, 
    0.10938451f, 0.09220765f, 0.19867752f, 0.01531786f, 0.14313407f, 0.03284557f, 0.18588701f, -0.05212339f, 
    -0.22881541f, -0.02008924f, 0.08408552f, 0.08616144f, -0.11627959f, -0.15750314f, 0.01902587f, -0.14831686f, 
    -0.34569329f, 0.30611014f, -0.04452456f, 0.04461350f, 0.25529203f, -0.06538033f, -0.13259493f, 0.13450879f, 
    0.00420964f, 0.00070029f, -0.15121974f, -0.09214176f, 0.24581313f, -0.03773802f, 0.20292485f, 0.00769682f, 
    0.05681539f, 0.03492584f, -0.21850318f, 0.01737770f, -0.06743509f, -0.14120613f, -0.04072769f, -0.01111566f, 
    -0.12911327f, -0.15635169f, -0.27135372f, -0.12427814f, 0.20210637f, 0.02526835f, 0.03678333f, 0.06645483f, 
    0.15598084f, -0.03339688f, -0.03167279f, 0.22249821f, -0.03265411f, -0.22623882f, 0.06420573f, -0.04348048f, 
    -0.01349408f, 0.00968412f, 0.06121828f, -0.06701463f, 0.05628454f, -0.10227854f, 0.08092181f, -0.13240099f, 
    -0.08067456f, 0.28240037f, -0.20271468f, -0.08317224f, 0.21966311f, -0.09381747f, 0.04831819f, -0.20373349f, 
    0.00403582f, 0.12119031f, 0.05710607f, 0.04616293f, 0.26908603f, 0.01788262f, 0.42615834f, 0.00094518f, 
    -0.02968531f, -0.06821531f, 0.06342484f, 0.12651624f, -0.01481786f, 0.00336051f, 0.09809343f, 0.07795869f, 
    -0.04357045f, -0.37017071f, 0.42369696f, -0.17159531f, 0.03464261f, -0.18663315f, -0.07830773f, 0.12227360f, 
    0.06125950f, -0.02239923f, 0.24617778f, 0.04678618f, 0.05561526f, 0.11353187f, 0.12140334f, 0.07303300f, 
    0.00262970f, 0.11679774f, 0.07176537f, 0.05475952f, -0.13971001f, -0.18995562f, -0.22766662f, -0.10710503f, 
    -0.00561827f, -0.10234690f, -0.14471610f, 0.00639596f, 0.11208437f, -0.07936288f, 0.04112925f, 0.01494250f, 
    0.01738801f, -0.01879275f, 0.14922367f, 0.09240125f, -0.08412166f, 0.10168687f, 0.04527321f, 0.04233069f, 
    -0.04842826f, -0.00517163f, 0.01836839f, -0.10219555f, 0.25495693f, -0.09760793f, 0.00227801f, 0.06026329f, 
    -0.07901450f, -0.20815526f, 0.04505197f, 0.06189699f, 0.00632213f, 0.08568931f, -0.00097745f, 0.02895787f, 
    -0.13179408f, -0.05519377f, -0.06765656f, -0.07178237f, -0.25820842f, -0.02008859f, -0.10729346f, 0.07046532f, 
    0.06746399f, 0.24343579f, -0.00734875f, 0.09484857f, 0.05697287f, 0.06726401f, -0.01266417f, 0.01936314f, 
    0.15503109f, 0.23803996f, -0.19964300f, 0.10648093f, 0.24165381f, 0.16798536f, 0.05012088f, 0.02464403f, 
    0.02339955f, 0.10161354f, 0.04497145f, 0.00401869f, -0.03159211f, -0.15091243f, 0.17599827f, 0.03972517f, 
    -0.05922132f, -0.26394826f, -0.08337118f, 0.18987831f, -0.11706758f, -0.05558101f, -0.01318211f, 0.13759878f, 
    0.04628923f, 0.00373819f, 0.00120245f, -0.00367336f, -0.02588916f, 0.00115776f, -0.01132075f, -0.00119070f, 
    0.14353199f, -0.17219840f, -0.00511252f, -0.03779550f, -0.22126462f, -0.06076536f, -0.11004423f, 0.05510535f, 
    0.05267938f, 0.01678597f, -0.07766131f, -0.12322967f, 0.08112277f, -0.04956177f, 0.00031393f, 0.06083930f, 
    -0.07062566f, -0.13059622f, 0.17208792f, -0.11374740f, 0.03276009f, 0.01313290f, 0.02281539f, 0.07583372f, 
    0.11482319f, 0.08137228f, 0.07620104f, 0.06463802f, -0.21736579f, -0.16518405f, -0.03045611f, 0.12720886f, 
    0.06002015f, 0.09972940f, 0.05840514f, 0.04136910f, 0.02157830f, 0.07553381f, -0.14186218f, 0.11986051f, 
    -0.03571855f, -0.05610188f, 0.00685221f, -0.00868298f, -0.07070041f, 0.02065712f, 0.04335801f, -0.03823991f, 
    0.04564571f, 0.01198204f, 0.06602028f, 0.03184105f, 0.02535279f, -0.05453488f, -0.03617414f, 0.03054751f, 
    -0.04639228f, -0.02158726f, 0.05559877f, 0.03895859f, 0.00112749f, 0.06457939f, 0.06343735f, 0.00418040f, 
    -0.05345608f, 0.01087804f, -0.02249611f, -0.05330212f, -0.03661610f, 0.00586393f, 0.03210379f, 0.00454860f, 
    0.00350224f, 0.03069538f, 0.03803767f, -0.07403941f, 0.01057873f, -0.06314673f, -0.00668836f, -0.05696633f, 
    -0.05231664f, 0.05324302f, 0.03702177f, 0.03569703f, 0.02328887f, -0.07062633f, -0.03402131f, -0.06809597f, 
    0.02878443f, 0.04751704f, 0.01255958f, 0.00200335f, -0.02026608f, -0.00188274f, 0.00506126f, -0.06928371f, 
    0.04909013f, -0.04425159f, -0.07789207f, -0.04490030f, -0.00602585f, -0.07771178f, -0.01660107f, -0.03248050f, 
    0.05923061f, -0.00206710f, -0.01241856f, -0.02662852f, 0.04061780f, 0.00598104f, 0.05889164f, -0.05879764f, 
    -0.01689041f, -0.06419393f, -0.05685056f, 0.01968670f, -0.04755453f, -0.02653819f, -0.06080103f, -0.04888669f, 
    0.03513082f, -0.00126124f, -0.05757992f, -0.02816782f, 0.03630302f, -0.07790828f, 0.02138847f, -0.06478035f, 
    -0.02507003f, 0.05777794f, 0.05076914f, -0.00080675f, 0.02871849f, 0.04864642f, -0.06070322f, -0.05325856f, 
    -0.02085171f, -0.06352527f, -0.01924213f, -0.04242738f, -0.01471647f, 0.06536781f, -0.02123191f, -0.03826216f, 
    0.05677813f, 0.03038521f, 0.02365583f, -0.01399022f, 0.03529124f, 0.00627570f, 0.02152395f, -0.06679899f, 
    -0.04802494f, -0.04493386f, 0.04285849f, -0.07338647f, -0.07716949f, -0.06304486f, -0.01363838f, -0.05142013f, 
    0.06332866f, 0.02142753f, 0.03263057f, -0.06043491f, 0.03621117f, 0.03726019f, -0.06300885f, 0.02803961f, 
    -0.02255491f, 0.00700096f, -0.04662090f, -0.06383842f, 0.05197848f, 0.06195100f, 0.02943047f, -0.05405186f, 
    0.00748425f, -0.01357840f, -0.06929661f, -0.01195380f, -0.03081318f, -0.02171714f, -0.01160053f, 0.02347550f, 
    0.00179609f, -0.03192080f, -0.06864505f, 0.02068438f, -0.02045171f, 0.00749815f, -0.05591220f, -0.00415467f, 
    -0.04954578f, -0.02310777f, 0.03224873f, 0.03534879f, -0.06935292f, -0.06087481f, -0.01000435f, 0.05415220f, 
    -0.04268230f, -0.04489581f, -0.05320105f, 0.04264268f, 0.01450547f, -0.06430889f, -0.00897423f, 0.02649188f, 
    -0.04523120f, -0.03340139f, -0.07164454f, 0.04101956f, -0.05572915f, 0.00936433f, 0.04976126f, 0.00454064f, 
    0.00336913f, -0.01312373f, 0.04015541f, 0.01515186f, 0.05617681f, -0.04477794f, -0.05370065f, 0.03744313f, 
    -0.02788580f, 0.04672582f, -0.06211206f, -0.06936459f, -0.03517771f, -0.01519155f, -0.01440939f, 0.05618867f, 
    0.05044227f, 0.42816791f, 0.29997927f, 0.19558825f, 0.00923012f, 0.17479867f, 0.20818862f, -0.13092247f, 
    -0.01227199f, 0.24041022f, -0.04358735f, 0.02329103f, -0.19835207f, -0.24548030f, -0.00244269f, -0.07942203f, 
    -0.59789377f, -0.21856073f, -0.22129251f, -0.06444938f, -0.17374055f, -0.03797615f, -0.06801529f, 0.11834365f, 
    0.31017312f, -0.10624845f, 0.35733905f, 0.14546739f, -0.01994361f, 0.07266257f, 0.22468680f, 0.05792089f, 
    0.11961102f, -0.33179754f, -0.02760494f, 0.10422388f, -0.21904628f, -0.03260287f, -0.30118352f, 0.10688743f, 
    -0.20521355f, 0.11293135f, 0.07790575f, -0.39261791f, -0.10996489f, -0.03093942f, 0.03394830f, 0.02914804f, 
    0.01275081f, 0.15854511f, -0.09202161f, -0.08830587f, 0.31528941f, 0.06335711f, 0.11723953f, 0.05700454f, 
    -0.13377661f, -0.07131703f, -0.10443334f, -0.14032139f, 0.01387990f, 0.04923459f, 0.09667171f, 0.21873923f, 
    0.04993336f, -0.11672676f, -0.04220073f, -0.02300916f, 0.04769713f, 0.19009317f, -0.06148398f, 0.01771237f, 
    0.09297677f, 0.38838553f, 0.11614162f, 0.09134085f, -0.07107787f, -0.04425982f, 0.04057090f, -0.07589588f, 
    0.09562634f, 0.07845414f, -0.14857928f, 0.15229614f, 0.25252420f, 0.08207059f, -0.07963946f, -0.14133731f, 
    0.05900654f, -0.20204554f, -0.05334233f, 0.13297670f, -0.07661862f, 0.06257234f, 0.11402697f, 0.00056556f, 
    -0.00460818f, -0.01050134f, -0.16077650f, 0.08134533f, -0.35680658f, -0.04309514f, -0.23966663f, -0.12154143f, 
    0.08938804f, -0.08318075f, 0.02714961f, -0.10596556f, 0.22760113f, 0.19076736f, 0.06710047f, -0.14604753f, 
    0.03487409f, -0.12800902f, -0.05999351f, 0.00157366f, 0.10017211f, -0.18140627f, 0.15368609f, -0.05199573f, 
    -0.06814928f, 0.03794397f, 0.14464179f, 0.15950777f, -0.16563120f, 0.06932008f, 0.14178672f, 0.09103915f, 
    0.07758382f, 0.01962914f, 0.16399978f, -0.04043990f, -0.60375178f, -0.18851326f, -0.00843904f, -0.00699077f, 
    0.22325647f, 0.08409774f, -0.13451405f, -0.20177789f, 0.08846975f, -0.14072011f, 0.21314742f, 0.13665967f, 
    -0.25885367f, 0.21527548f, 0.13194694f, -0.11691441f, 0.13372807f, 0.01201446f, -0.35953751f, 0.06574252f, 
    -0.09905832f, 0.26078099f, 0.21267188f, 0.04552099f, 0.13766704f, -0.17569457f, -0.02494258f, 0.07938867f, 
    -0.16142605f, 0.06980415f, 0.14105816f, -0.04985585f, -0.25311014f, 0.02012610f, -0.12514564f, -0.19381267f, 
    -0.20758063f, 0.15039085f, -0.09897473f, 0.08746430f, 0.30215460f, -0.10606422f, -0.04020498f, -0.03445056f, 
    -0.00944604f, -0.09383497f, 0.08380707f, 0.14477631f, 0.32715237f, 0.02729174f, -0.02577131f, -0.11558418f, 
    0.16771211f, -0.09040642f, -0.11067426f, 0.12453035f, 0.20954441f, -0.09187626f, -0.11113935f, 0.06362281f, 
    0.20664074f, -0.33428839f, -0.16860981f, 0.20919788f, 0.08004662f, 0.00040961f, -0.03311224f, -0.08613500f, 
    -0.09948317f, -0.03770390f, 0.15895185f, 0.08433147f, -0.02482683f, -0.17931044f, -0.10890847f, -0.15066873f, 
    -0.08173999f, -0.09676951f, -0.31569999f, 0.00663835f, -0.10435787f, -0.17277189f, -0.14732185f, 0.29357189f, 
    -0.11890687f, -0.05366039f, -0.19388144f, 0.20575048f, 0.04250136f, 0.15050575f, -0.03645571f, -0.27668142f, 
    -0.12762018f, 0.13042682f, 0.03980574f, 0.10007480f, 0.16315369f, 0.31126931f, -0.20543236f, -0.45855665f, 
    0.10265577f, 0.06863648f, -0.11059634f, -0.29469031f, -0.06385228f, -0.01610200f, -0.12723053f, 0.13447817f, 
    0.11774424f, 0.08598466f, -0.03716974f, 0.01777476f, 0.02572243f, -0.07353599f, -0.14261195f, -0.25615880f, 
    -0.24497804f, -0.28627264f, -0.08512978f, -0.16393343f, 0.32617137f, 0.17290621f, 0.21132390f, 0.16775092f, 
    -0.25858343f, 0.11512436f, 0.01975792f, 0.08715771f, 0.07960942f, 0.05237212f, 0.23576836f, 0.25740114f, 
    -0.03893133f, -0.11821343f, -0.10428359f, 0.32082295f, 0.04484855f, 0.01024608f, 0.09943923f, -0.22667141f, 
    0.03792225f, 0.18095869f, 0.05933639f, 0.20500554f, -0.03581606f, 0.25478452f, -0.20688458f, 0.38459909f, 
    0.13069016f, -0.08974283f, 0.21366280f, -0.02555973f, 0.05024096f, 0.17958431f, 0.42083323f, 0.35528719f, 
    0.05559043f, -0.00219705f, -0.42029083f, -0.12593727f, 0.01984135f, -0.32064977f, -0.06979437f, -0.33146724f, 
    -0.21528454f, 0.02284768f, -0.23765293f, 0.20299891f, 0.34934863f, 0.23693651f, 0.30619842f, 0.41164413f, 
    0.11083844f, 0.08203415f, 0.46626621f, 0.21842077f, 0.13784379f, 0.08051927f, -0.08547727f, 0.07086110f, 
    0.00302309f, 0.11875173f, 0.23872717f, 0.08006658f, 0.15718332f, 0.00965879f, 0.13166253f, 0.11120640f, 
    0.03320659f, -0.12719329f, -0.05569064f, -0.07379390f, -0.03100200f, -0.06771030f, -0.19372116f, -0.02599842f, 
    -0.26630670f, 0.03347722f, -0.03351090f, -0.20730533f, -0.07254169f, 0.05627487f, -0.08721670f, 0.01575582f, 
    -0.30999619f, -0.28103796f, -0.05280396f, 0.06812804f, -0.01870137f, 0.13197382f, 0.04583509f, 0.09874738f, 
    -0.01116794f, 0.13340144f, 0.13767402f, 0.26427662f, -0.28462860f, 0.04816594f, -0.12671153f, -0.21300207f, 
    0.30203179f, -0.13698828f, -0.47715962f, -0.05961571f, -0.52136016f, -0.31708708f, -0.22823258f, -0.33500031f, 
    0.16289851f, 0.04592784f, 0.05074137f, -0.23920976f, 0.36491397f, 0.07689227f, -0.19151008f, -0.29695031f, 
    -0.40531066f, -0.13426214f, -0.15231590f, -0.14539431f, 0.16933998f, 0.06892594f, 0.25091901f, 0.06843170f, 
    -0.27117720f, -0.02218643f, -0.15472712f, -0.11529952f, -0.04807908f, 0.31001711f, 0.16806465f, 0.27590203f, 
    0.42847928f, 0.44761685f, 0.33075988f, 0.20571400f, 0.23835130f, 0.15630195f, -0.01990167f, -0.06450780f, 
    -0.03157952f, 0.01086027f, 0.11423618f, -0.01455726f, 0.00141556f, -0.11080185f, -0.01997088f, 0.14746013f, 
    -0.05293916f, 0.02514337f, -0.07314064f, 0.11452015f, 0.02887723f, 0.17567554f, 0.00765089f, -0.01889022f, 
    0.27837470f, 0.28099036f, 0.07312936f, 0.02849191f, 0.02791611f, 0.00539877f, -0.30084175f, 0.17756808f, 
    -0.00100851f, 0.04274612f, 0.02804497f, -0.11984379f, -0.57257271f, 0.08877571f, 0.39619726f, 0.28094810f, 
    -0.14250815f, -0.15347558f, -0.00332092f, -0.00914137f, -0.03137920f, 0.01906302f, -0.28667367f, 0.10859284f, 
    0.03894325f, 0.10874113f, -0.15323757f, 0.12097612f, -0.04369931f, -0.07899050f, 0.08537666f, -0.03379706f, 
    0.03679135f, -0.09028525f, -0.01703164f, 0.15545832f, -0.25043449f, 0.09840696f, -0.15935013f, 0.05992986f, 
    -0.17584875f, -0.10423210f, 0.09656481f, -0.02655701f, -0.20583647f, 0.05045391f, 0.19033079f, 0.02552419f, 
    -0.02685788f, 0.51627988f, 0.02889333f, -0.12417839f, 0.11281204f, 0.00471517f, -0.02503094f, -0.14646515f, 
    0.01878916f, 0.14949708f, -0.00361132f, -0.05678228f, 0.22126746f, -0.11074674f, 0.09256607f, -0.01111734f, 
    0.17316130f, -0.01830188f, 0.07090323f, -0.05380403f, -0.10298932f, 0.09096883f, 0.01012638f, -0.00901511f, 
    0.07643160f, -0.01120402f, 0.13850491f, 0.13998951f, 0.07962719f, -0.02355710f, -0.06851508f, 0.02077736f, 
    0.01647817f, 0.04541345f, 0.07318017f, 0.04556245f, 0.29473659f, -0.40391302f, -0.22135258f, 0.16309053f, 
    -0.04942792f, 0.07302692f, 0.11970644f, -0.06677615f, 0.11533009f, 0.02463094f, 0.02827499f, 0.04786086f, 
    -0.32994619f, -0.05073897f, -0.17549659f, 0.10690270f, -0.00532623f, -0.03157115f, -0.04933795f, 0.02331816f, 
    -0.03337625f, -0.00600727f, -0.02562988f, 0.01114667f, 0.11186943f, 0.07498915f, -0.32525599f, 0.08135928f, 
    -0.01939227f, 0.08776067f, -0.08656237f, 0.00010425f, 0.17181283f, -0.09060776f, 0.00226401f, -0.03175684f, 
    -0.04600578f, -0.06650457f, -0.04094455f, 0.02611164f, 0.00066347f, 0.06572382f, 0.02610810f, 0.01963061f, 
    0.03311041f, 0.14449085f, -0.16239311f, 0.29084051f, 0.05282777f, -0.02573154f, 0.05814812f, 0.10594577f, 
    -0.01155821f, 0.02832420f, 0.08693313f, 0.05413972f, 0.00567310f, -0.03923974f, -0.07901289f, -0.09453057f, 
    -0.28588733f, -0.02351238f, -0.13402234f, 0.21510209f, -0.08525999f, 0.12888518f, 0.05523834f, -0.06179292f, 
    -0.01692885f, -0.04372481f, -0.10109826f, 0.02114905f, 0.38472104f, 0.07824668f, 0.00035535f, -0.04746713f, 
    -0.07474577f, 0.00623131f, 0.10351580f, 0.03994235f, 0.04213488f, 0.00562755f, 0.10184114f, 0.04107402f, 
    -0.45808998f, 0.16864583f, -0.17918560f, -0.08781935f, 0.10667250f, 0.15180732f, 0.10007662f, 0.16231889f, 
    0.03379150f, -0.21657044f, -0.09569084f, -0.04493362f, -0.17212258f, 0.17385687f, -0.10987665f, -0.09247078f, 
    0.12955354f, -0.17162360f, -0.13710178f, -0.22518972f, 0.04225364f, -0.23255944f, -0.01142859f, -0.24213769f, 
    -0.08400019f, 0.19185135f, -0.21768321f, -0.11679629f, 0.10005699f, 0.02640223f, 0.00240672f, 0.11585156f, 
    0.08120215f, 0.19885415f, 0.12569736f, -0.04370954f, -0.20032147f, -0.06771045f, 0.64399111f, 0.16583943f, 
    -0.04547370f, -0.17521191f, -0.02055353f, 0.17670283f, 0.24394821f, 0.07825074f, 0.21345210f, 0.11660377f, 
    -0.11695699f, -0.04309801f, 0.00870963f, 0.44862750f, -0.23009065f, -0.08053871f, -0.10457166f, 0.06950876f, 
    0.29691106f, 0.27455458f, 0.43280289f, 0.19485787f, -0.04669288f, -0.07528552f, 0.10733034f, 0.07091412f, 
    0.07133257f, 0.09938071f, 0.14680788f, 0.19782321f, -0.00267667f, -0.16727449f, -0.02041162f, 0.03480656f, 
    -0.02131509f, 0.06009261f, -0.05062109f, 0.01975816f, -0.01321179f, 0.12718788f, -0.22659898f, 0.12556532f, 
    -0.01847151f, -0.00876214f, 0.18639643f, -0.00569827f, -0.19996126f, -0.29727003f, -0.18128021f, 0.01264274f, 
    0.11214133f, 0.19930595f, -0.01294810f, 0.10109479f, 0.16392498f, -0.04897047f, -0.07730134f, 0.02242949f, 
    -0.10087617f, 0.00378212f, 0.08270993f, -0.19939902f, 0.03962968f, 0.15692057f, -0.10507511f, 0.06468731f, 
    -0.07909763f, 0.03256421f, -0.00488601f, -0.03836308f, -0.02171081f, -0.18817437f, -0.22141720f, 0.03674491f, 
    0.04690311f, 0.25671512f, -0.03203689f, -0.06992172f, -0.12590712f, -0.04077154f, 0.01508957f, -0.06542753f, 
    0.24274470f, -0.06925025f, 0.04659481f, -0.05466331f, 0.20999901f, 0.14114943f, 0.00672126f, -0.00910979f, 
    0.01124927f, 0.07475477f, -0.07654789f, 0.27190730f, 0.20644322f, -0.08805173f, -0.09703162f, -0.26456341f, 
    0.04746837f, 0.08622518f, 0.21008301f, 0.40186957f, -0.10403515f, 0.23627023f, 0.00315938f, -0.11783583f, 
    0.39270091f, -0.06449969f, -0.19310112f, -0.01729363f, -0.21096775f, -0.14146739f, 0.17809357f, -0.03274900f, 
    -0.06502135f, 0.01370054f, 0.06288555f, -0.06959546f, -0.07027623f, -0.09244744f, 0.05517166f, -0.02357651f, 
    -0.16406494f, -0.05774282f, -0.01243279f, 0.09633380f, 0.23902725f, 0.07756881f, 0.04162684f, 0.18763803f, 
    -0.11867681f, -0.02475723f, 0.01031637f, 0.09634317f, -0.30051681f, 0.26837677f, 0.04217372f, -0.04743243f, 
    0.02020697f, 0.01978435f, 0.09443682f, -0.01358080f, -0.16033122f, -0.10145190f, -0.23850282f, -0.07509150f, 
    -0.01519614f, -0.06513084f, 0.05359416f, -0.08557843f, -0.18394466f, 0.08430251f, 0.06589043f, -0.13322929f, 
    0.03063189f, -0.00058258f, -0.06107280f, -0.05480296f, 0.05262156f, 0.02550940f, -0.03566768f, 0.06444440f, 
    -0.03616221f, -0.03813435f, 0.03624832f, -0.05006524f, 0.04089866f, 0.01879619f, -0.06615362f, 0.03292818f, 
    -0.01658466f, 0.06954886f, 0.00744549f, 0.01898208f, 0.03373994f, -0.00613230f, 0.01740459f, -0.00830373f, 
    -0.06774157f, 0.03708789f, 0.03815826f, 0.03570268f, 0.00190253f, -0.06419405f, -0.03247945f, -0.03532271f, 
    -0.00826087f, 0.04660863f, 0.05563011f, -0.06591605f, 0.02084285f, 0.06540168f, 0.03080511f, -0.05851308f, 
    -0.00776905f, -0.02084483f, 0.00624827f, -0.02159493f, -0.03730550f, 0.06222564f, 0.05916790f, 0.03264318f, 
    0.02718303f, -0.06087392f, -0.05873738f, 0.05806572f, -0.04904388f, -0.05173106f, -0.03172005f, 0.06024558f, 
    -0.05758918f, -0.00350581f, -0.06622327f, -0.07083359f, -0.02469833f, 0.05331629f, 0.01644950f, -0.06450358f, 
    -0.03053045f, -0.04421877f, -0.02649319f, -0.00887953f, 0.03340384f, -0.03154818f, -0.03684433f, 0.00109162f, 
    -0.01120687f, 0.03827609f, 0.02835542f, -0.02446437f, -0.02510175f, -0.02548206f, -0.02402800f, -0.06031214f, 
    -0.02270456f, 0.00962199f, -0.01673278f, -0.05781307f, 0.04921983f, -0.06559255f, -0.04391724f, -0.06092970f, 
    -0.03382540f, -0.06366073f, -0.02246075f, -0.06108467f, 0.05140465f, -0.02709833f, 0.06552292f, 0.05842558f, 
    -0.05116280f, -0.00029740f, -0.03177575f, 0.01355398f, 0.05764640f, -0.02853009f, -0.00500792f, -0.06964646f, 
    0.00957762f, -0.02811240f, 0.03082858f, -0.02151673f, -0.04306540f, -0.03467370f, -0.04213073f, -0.05805982f, 
    -0.00587235f, 0.04746583f, -0.03010245f, 0.01295134f, -0.02676560f, -0.03252519f, -0.00154214f, -0.04301984f, 
    -0.00285712f, -0.04786863f, -0.05607941f, 0.00147963f, -0.06412312f, 0.02287303f, 0.01314109f, -0.05501363f, 
    0.00182672f, 0.00430861f, 0.05444621f, 0.07032186f, -0.05547201f, -0.03240962f, 0.02426298f, -0.02579437f, 
    0.04366361f, -0.04858845f, -0.01687582f, -0.00187209f, 0.04693251f, -0.05571248f, 0.06901980f, 0.02407665f, 
    -0.02808486f, -0.04857360f, -0.03175547f, -0.03527930f, 0.06336366f, 0.01389627f, 0.00286244f, 0.01135924f, 
    -0.06496250f, -0.05715987f, -0.05965322f, -0.02717946f, -0.03890364f, -0.03345019f, 0.05465370f, 0.02312776f, 
    -0.05894285f, -0.02164272f, 0.04288386f, -0.05135490f, 0.03576184f, -0.03674518f, -0.00009180f, 0.04926560f, 
    0.01174001f, -0.03161141f, -0.03493489f, 0.05468484f, -0.02350271f, 0.03307386f, -0.01277165f, 0.04901557f, 
    -0.04793977f, -0.04555612f, -0.01767185f, 0.00732725f, -0.03494683f, -0.01471391f, -0.02063062f, 0.05839060f, 
    -0.02339076f, 0.06945594f, -0.02826587f, 0.02973914f, -0.06149618f, -0.00036213f, -0.03125541f, -0.04961846f, 
    0.35652861f, 0.21556836f, 0.10522243f, 0.09870274f, 0.29179159f, 0.08800294f, 0.12548417f, 0.04619488f, 
    0.03920453f, 0.11275975f, 0.06441574f, 0.15629528f, 0.00772017f, -0.42553291f, 0.03134035f, -0.04739510f, 
    -0.34306386f, -0.14709671f, -0.02409548f, -0.10072102f, 0.04107135f, 0.26305723f, 0.18334685f, -0.05144978f, 
    0.30725271f, 0.34484994f, 0.13622643f, 0.19261925f, 0.06646169f, -0.01970020f, 0.18827400f, 0.27625710f, 
    0.02315440f, 0.01868378f, -0.01186397f, -0.02499495f, -0.19386128f, 0.16150153f, -0.04558915f, -0.14286871f, 
    -0.02807085f, -0.07828320f, -0.07269792f, 0.00804848f, -0.08807597f, -0.00771166f, -0.06882425f, 0.13780050f, 
    -0.03080261f, -0.05412048f, 0.27440849f, -0.13239343f, 0.05817980f, -0.05107982f, -0.02283101f, 0.13952395f, 
    0.06504826f, 0.20600367f, -0.00880166f, 0.27635786f, -0.11863765f, 0.14286505f, -0.05925934f, 0.12146079f, 
    0.13605227f, -0.03082712f, 0.00062795f, 0.05371552f, -0.17550142f, 0.01983369f, -0.11122143f, -0.24702679f, 
    0.11871540f, -0.00456087f, -0.05610448f, -0.05557825f, 0.07356142f, -0.10179788f, 0.08133303f, -0.05152581f, 
    -0.06056095f, 0.09520107f, -0.08190608f, -0.11105724f, 0.31634566f, -0.13714956f, 0.46056929f, -0.20742071f, 
    -0.29537955f, -0.20871419f, -0.11277600f, 0.27513862f, -0.22490151f, -0.00565043f, -0.13962372f, -0.08677366f, 
    -0.13546951f, 0.13536797f, 0.13335671f, 0.19238017f, -0.15415092f, -0.03633593f, -0.08278942f, -0.24716790f, 
    0.07602847f, -0.02265273f, 0.15008943f, -0.06373227f, -0.26875287f, -0.28051776f, -0.02999420f, -0.12377568f, 
    -0.34617841f, -0.06650128f, 0.02644457f, 0.13004191f, 0.11372600f, 0.03297744f, -0.06692774f, 0.02915625f, 
    -0.17293648f, 0.35373047f, -0.28934991f, 0.38287160f, 0.03118967f, 0.19069791f, -0.10039251f, 0.03868573f, 
    -0.01768710f, 0.01942571f, 0.11248269f, -0.10314970f, 0.04444607f, 0.11913557f, 0.10359003f, 0.11126667f, 
    0.01518239f, -0.11940005f, 0.08540106f, 0.11513992f, -0.01548191f, -0.00101982f, 0.23402540f, 0.21243614f, 
    -0.37252951f, 0.14379092f, 0.06016158f, -0.14131398f, -0.26833424f, -0.06841557f, -0.15271421f, 0.07121564f, 
    0.10258096f, -0.01041050f, 0.02814410f, -0.17330408f, 0.04693611f, 0.04629052f, 0.09453847f, 0.04197849f, 
    -0.27816010f, 0.02369759f, -0.02307431f, -0.17151497f, 0.26309654f, 0.17819175f, 0.14212386f, 0.11558586f, 
    -0.49363595f, 0.04034730f, 0.11765976f, -0.07629222f, -0.16434781f, -0.01652650f, 0.09581974f, 0.03182006f, 
    0.23733859f, 0.09067988f, -0.05442277f, 0.23155057f, -0.16433945f, -0.22044593f, -0.05074919f, 0.06330813f, 
    -0.07015724f, 0.00132843f, 0.04079560f, 0.12133157f, -0.05130381f, -0.18108353f, -0.24218272f, -0.15704648f, 
    0.07764159f, -0.02313758f, -0.05290315f, 0.17431787f, 0.18864058f, 0.03610451f, -0.06106735f, -0.15622729f, 
    -0.00626591f, 0.02363903f, 0.00498445f, -0.00825835f, -0.05654432f, 0.21506177f, 0.14980498f, -0.10518660f, 
    -0.10133468f, 0.03032191f, -0.03711950f, -0.04218066f, -0.11320741f, 0.12271062f, -0.03978753f, -0.00378893f, 
    -0.17557800f, -0.06213167f, -0.12842953f, 0.12583718f, -0.01853609f, 0.05804383f, 0.02934153f, 0.15316610f, 
    0.07686890f, 0.10433475f, 0.10216690f, 0.02828039f, 0.23941481f, 0.18406032f, -0.14181733f, -0.54774511f, 
    -0.04760259f, 0.04735254f, -0.00027694f, 0.04281928f, 0.10549575f, 0.22037809f, -0.15670680f, 0.01463535f, 
    0.25447983f, 0.06607420f, 0.04947413f, 0.13739927f, 0.03855916f, 0.07339312f, -0.06576947f, 0.04515211f, 
    -0.08207615f, 0.16421708f, 0.13028127f, 0.10152230f, -0.00770499f, -0.29392642f, -0.21262939f, -0.06231721f, 
    0.06890903f, 0.19391829f, 0.14804450f, -0.04537107f, 0.03634502f, -0.00462840f, 0.26141682f, -0.04029793f, 
    -0.15566227f, 0.29077455f, 0.02904601f, 0.25956312f, -0.03457666f, 0.15949924f, 0.18942766f, 0.15836516f, 
    0.09700181f, 0.21475542f, -0.12510166f, 0.00642490f, 0.08124804f, -0.14068401f, 0.50799865f, 0.13848855f, 
    -0.08674773f, -0.10941945f, 0.01230466f, 0.09361093f, -0.07107597f, 0.22527105f, -0.12828034f, 0.13438545f, 
    0.06319444f, 0.13307492f, 0.05142187f, 0.11027614f, -0.04660497f, -0.17642638f, 0.02484403f, -0.12456067f, 
    -0.01140521f, -0.03502424f, -0.11278242f, 0.19451271f, -0.35188502f, -0.20916730f, 0.22194639f, -0.13996893f, 
    -0.24298064f, 0.04321698f, 0.07179985f, -0.06737695f, 0.01941461f, -0.11443887f, 0.00016754f, 0.05489320f, 
    -0.20585477f, 0.10338511f, -0.39117092f, 0.25870314f, -0.04483392f, -0.04695217f, -0.01369784f, -0.20774323f, 
    0.08457486f, -0.03162120f, -0.08256775f, 0.02116857f, 0.12635960f, -0.13960525f, 0.01089450f, 0.12711501f, 
    -0.03743615f, 0.20221464f, 0.09606249f, -0.00015004f, -0.06381594f, -0.04280921f, -0.00419332f, -0.05114764f, 
    -0.28376961f, 0.06297767f, 0.04680758f, -0.13455461f, -0.04173588f, 0.04283280f, 0.00891716f, 0.02573765f, 
    0.04104925f, 0.13493821f, 0.08820280f, 0.03509218f, 0.18615593f, 0.24270205f, -0.12713581f, 0.12205032f, 
    -0.04823885f, -0.05304924f, -0.01504151f, -0.05579548f, -0.03838933f, 0.27437764f, 0.10395405f, -0.06791963f, 
    0.22008352f, 0.22795796f, -0.06074156f, -0.14854597f, 0.19318675f, -0.23112813f, -0.17862430f, -0.05922876f, 
    -0.06061001f, 0.14302658f, -0.03952422f, -0.08027630f, 0.08218075f, 0.20066056f, 0.20423116f, -0.18949232f, 
    -0.20688286f, -0.02537259f, -0.05229524f, -0.05908942f, -0.02541717f, 0.12802064f, 0.09568070f, -0.09097325f, 
    0.51913655f, 0.17407006f, -0.11803878f, 0.05947105f, 0.21743055f, 0.11872116f, 0.04543963f, -0.07227960f, 
    0.07635387f, 0.13990964f, 0.09305839f, 0.07632805f, -0.12249736f, -0.13662770f, -0.13548474f, -0.01076408f, 
    0.01342031f, -0.02261317f, -0.06831410f, -0.14224932f, -0.10382555f, 0.15975401f, 0.02322358f, -0.13995804f, 
    0.15791605f, 0.35306841f, -0.14623985f, 0.32388061f, 0.05095802f, 0.09742811f, 0.02389391f, 0.03631764f, 
    -0.09310748f, 0.08505487f, 0.03256795f, -0.02306477f, -0.41639084f, 0.41703448f, 0.09352575f, -0.50818497f, 
    -0.04642577f, -0.07169927f, 0.07581604f, -0.14654194f, 0.24598044f, 0.17177995f, -0.15206413f, 0.08904073f, 
    -0.03462913f, -0.16594762f, 0.20740400f, -0.08353789f, -0.03544127f, -0.28246102f, 0.02746691f, 0.12775408f, 
    -0.01604432f, 0.09453612f, 0.03576506f, 0.05781427f, 0.19166659f, 0.29138339f, 0.16543357f, -0.11766427f, 
    0.17870830f, 0.10075603f, 0.02358632f, 0.09489972f, -0.17062974f, -0.09643573f, -0.06790410f, -0.22508395f, 
    0.31158531f, -0.18582283f, -0.27056706f, 0.00957952f, 0.08262111f, 0.15525706f, -0.00003064f, 0.11497723f, 
    0.04218997f, 0.04214500f, 0.03389683f, -0.08241148f, 0.00309922f, -0.31530648f, 0.08242886f, 0.28657493f, 
    -0.02454424f, -0.09608274f, 0.13610524f, 0.02304420f, -0.17376387f, -0.11524021f, -0.07784732f, -0.01607453f, 
    -0.31191641f, 0.13179208f, -0.16565485f, -0.31002125f, -0.03787283f, 0.03550862f, -0.09466699f, -0.14520374f, 
    0.02425406f, 0.09648752f, 0.10496650f, 0.02647318f, -0.04379527f, -0.12266673f, 0.14720850f, -0.16820034f, 
    -0.04303743f, 0.13352203f, 0.07679170f, 0.13919400f, 0.07426474f, 0.04393091f, -0.05067345f, 0.13211344f, 
    0.24733505f, 0.53953612f, -0.00052779f, 0.35534468f, 0.05750340f, 0.01205369f, -0.11232203f, -0.09304692f, 
    -0.11126825f, 0.04755833f, 0.03100375f, 0.02631752f, -0.12309831f, 0.14878015f, 0.04081985f, -0.26883706f, 
    -0.04369637f, -0.04953733f, 0.05442844f, 0.00301210f, -0.12819651f, 0.04136823f, 0.24360739f, 0.02646478f, 
    -0.42899036f, -0.25261751f, -0.05514003f, -0.14442816f, -0.18313748f, -0.04947749f, 0.02413394f, -0.07515286f, 
    -0.08725367f, -0.12191992f, -0.11826140f, -0.10705505f, -0.07093617f, 0.04731439f, -0.02039952f, 0.01833339f, 
    -0.13471308f, 0.00096552f, -0.08378552f, -0.05869253f, 0.18397935f, 0.12706423f, 0.07297215f, 0.26759824f, 
    -0.26774305f, 0.11761081f, 0.19855957f, -0.16977346f, 0.01994147f, 0.00551129f, 0.03539925f, -0.07979888f, 
    0.20476413f, 0.14309061f, 0.00784658f, 0.14616753f, -0.17152777f, -0.43748605f, 0.22379793f, 0.09271569f, 
    -0.09578288f, -0.01522229f, -0.10529903f, 0.03784286f, -0.16778471f, 0.03203242f, -0.00265731f, -0.24814041f, 
    -0.00064134f, -0.26161355f, -0.13733357f, -0.21871078f, -0.00053890f, 0.09499520f, 0.19198324f, 0.08578377f, 
    0.10171065f, -0.01049020f, 0.01174141f, 0.10296777f, -0.00546421f, -0.11799764f, 0.23461787f, -0.04814978f, 
    0.16392164f, -0.10132054f, -0.00043017f, -0.13896449f, 0.15698962f, 0.05775015f, 0.18235204f, 0.00332623f, 
    0.18128008f, 0.05326471f, -0.08464400f, -0.12823121f, 0.14948443f, 0.24687907f, -0.13767135f, 0.12703708f, 
    -0.03766038f, 0.11675645f, 0.04419891f, -0.04157573f, 0.29308081f, 0.21782333f, 0.35486054f, 0.48847896f, 
    0.09744480f, -0.19764128f, -0.03360039f, 0.05730880f, 0.09283955f, -0.09559567f, 0.09903657f, -0.00605846f, 
    -0.16538174f, -0.07600361f, 0.20155355f, -0.22507627f, -0.12630762f, -0.05954054f, -0.23591472f, 0.01255144f, 
    0.14890403f, -0.07598802f, 0.06871983f, -0.04562677f, 0.25364199f, 0.42361736f, 0.21282369f, 0.02014207f, 
    0.13427603f, 0.03142352f, 0.10316761f, 0.04948883f, -0.00622411f, -0.00119827f, -0.15385321f, -0.07748765f, 
    0.36808226f, -0.35114807f, 0.22654755f, -0.08981434f, 0.08766750f, -0.20808077f, -0.08150784f, -0.07270322f, 
    -0.08962485f, -0.04779743f, 0.13566542f, 0.05747464f, -0.58497345f, -0.10111641f, -0.13818219f, -0.06358836f, 
    -0.03932114f, 0.00051673f, -0.01509096f, -0.07242230f, 0.08548541f, 0.04765963f, -0.13260368f, -0.05669040f, 
    -0.07362617f, -0.25042871f, 0.34486893f, 0.02604898f, -0.01927195f, 0.03729007f, -0.01435597f, 0.01419679f, 
    0.09767280f, -0.05995663f, 0.10436000f, 0.03202933f, -0.28150240f, 0.39280075f, -0.18198748f, 0.37340266f, 
    0.10987320f, 0.21186371f, 0.15908191f, 0.01973255f, -0.14400418f, 0.08667073f, -0.00367365f, -0.25372404f, 
    0.40004334f, -0.01428946f, -0.37664089f, -0.33390546f, 0.28448185f, -0.03986987f, 0.18492830f, -0.01273784f, 
    -0.01936109f, 0.12559415f, 0.00532436f, 0.01420514f, -0.12991957f, -0.11143833f, 0.02036678f, -0.11913014f, 
    0.04434247f, 0.08129165f, -0.00212649f, 0.15151615f, 0.13882571f, 0.04807197f, -0.09357364f, -0.02503023f, 
    -0.04306069f, -0.07920678f, -0.02191390f, 0.03291248f, 0.01511513f, -0.10925131f, -0.04173284f, -0.24892114f, 
    -0.23251852f, -0.20738144f, -0.04297598f, 0.03754734f, -0.23600547f, -0.02444010f, 0.04772817f, 0.11275966f, 
    0.12895271f, -0.05043788f, -0.07089515f, -0.00579914f, 0.31279770f, -0.08418622f, 0.09137703f, 0.34933493f, 
    -0.04513463f, -0.15585378f, 0.16183467f, 0.21424115f, -0.14449067f, 0.01774606f, 0.02405815f, 0.01236369f, 
    0.08810200f, -0.09156591f, 0.03902069f, -0.02110921f, -0.51927447f, -0.07201205f, -0.09898150f, 0.35862800f, 
    -0.18554068f, 0.07533526f, 0.17103100f, -0.00943494f, -0.01617740f, 0.07182212f, 0.06789115f, -0.03624694f, 
    0.08630673f, -0.23876907f, -0.11705784f, -0.08884406f, 0.07253699f, -0.22948836f, -0.06398547f, 0.29523793f, 
    0.08986299f, -0.19128442f, -0.01962549f, 0.05623014f, 0.07723203f, -0.24683583f, -0.16849637f, -0.10986455f, 
    0.27423990f, -0.13774565f, 0.06109986f, -0.02942815f, 0.22323550f, 0.00968517f, 0.22842400f, 0.10984884f, 
    -0.04012714f, 0.26833421f, -0.19505513f, 0.01570370f, 0.18352591f, -0.07434009f, -0.17255403f, -0.06605632f, 
    -0.07105634f, -0.01560168f, 0.03618285f, -0.07308064f, 0.24307762f, 0.27151030f, 0.38409889f, 0.04613959f, 
    0.21231014f, 0.05172958f, -0.06235193f, -0.03064605f, 0.00960254f, 0.11150648f, -0.08957846f, -0.12301153f, 
    0.08914180f, 0.01399479f, 0.07091632f, -0.30539104f, -0.31278270f, -0.17820455f, -0.22128962f, -0.31458330f, 
    0.09002035f, 0.03413434f, 0.16024211f, -0.22366777f, 0.32898158f, 0.21602860f, 0.27292523f, 0.05649455f, 
    0.03358802f, 0.08369639f, 0.02478808f, 0.03184474f, 0.12178127f, -0.05086533f, -0.01572394f, 0.23259342f, 
    0.23475452f, -0.26725480f, 0.30516002f, 0.12147596f, 0.13179481f, -0.11024902f, 0.01507969f, 0.11719485f, 
    -0.00274067f, -0.00997537f, 0.15261629f, -0.13480589f, -0.26691145f, 0.13855889f, -0.37251604f, 0.34973207f, 
    0.19748209f, 0.03247152f, 0.08466147f, -0.18525882f, 0.39259893f, 0.11657590f, 0.33129984f, 0.14482118f, 
    0.06658866f, -0.15277788f, -0.16110569f, -0.43614402f, 0.21955653f, 0.01019944f, 0.02263794f, -0.14682047f, 
    -0.25612065f, 0.09393036f, -0.21062712f, -0.02006542f, 0.25101665f, 0.20178249f, 0.05813323f, 0.79375488f, 
    0.16578749f, 0.33084840f, 0.21972357f, 0.05217796f, -0.01276436f, 0.14694907f, -0.18280685f, -0.05623735f, 
    0.15340917f, 0.16731106f, 0.37933359f, -0.00962652f, 0.22262256f, -0.08004646f, 0.02463742f, 0.24691467f, 
    -0.04745150f, -0.03805334f, -0.09547759f, 0.04091001f, 0.02852164f, -0.08047163f, -0.26540536f, -0.24102691f, 
    -0.05951715f, 0.01208974f, 0.09113130f, -0.15732433f, 0.05220795f, -0.00307675f, -0.29416493f, -0.00892446f, 
    0.15753533f, -0.19343908f, -0.19823115f, 0.06175275f, 0.07356881f, 0.04482093f, 0.19744392f, 0.02859944f, 
    0.00440031f, -0.02159675f, -0.05930876f, 0.18864666f, -0.33218697f, -0.08104378f, -0.09817384f, -0.12515391f, 
    0.26951489f, -0.16660230f, -0.37330806f, -0.02570211f, -0.30388668f, -0.41257662f, -0.12795629f, -0.13349427f, 
    0.24452792f, -0.33519340f, 0.19190243f, 0.05721113f, -0.06421994f, 0.22453588f, -0.14955114f, -0.31142232f, 
    -0.12058521f, -0.12945659f, -0.17536002f, -0.26029822f, -0.05394436f, -0.08637075f, -0.06013623f, 0.26637465f, 
    -0.04388285f, 0.14370203f, 0.27200395f, 0.00926492f, 0.21915007f, 0.20211186f, 0.13574301f, 0.26386109f, 
    0.10679079f, -0.17740491f, -0.17451729f, 0.28821969f, 0.23926577f, 0.24411377f, -0.04831596f, 0.09979337f, 
    -0.05950185f, 0.04622606f, 0.04550894f, 0.05931373f, -0.17072083f, 0.18892147f, -0.06350050f, -0.07423390f, 
    -0.05624400f, -0.10007887f, -0.07932609f, 0.01018638f, -0.19939168f, 0.06399139f, 0.00250049f, 0.10843277f, 
    0.05398890f, 0.10484765f, -0.13818680f, 0.45272964f, 0.07479008f, 0.19761886f, 0.13039233f, 0.06486130f, 
    0.08025666f, 0.24492462f, 0.09973684f, 0.18316725f, -0.11756517f, 0.00365142f, -0.35961738f, -0.45445594f, 
    -0.00152196f, 0.01875277f, 0.11408391f, 0.06926496f, 0.14319435f, 0.00488060f, -0.10006350f, -0.05497295f, 
    0.07743481f, 0.00094689f, 0.08910094f, 0.00804379f, 0.03897537f, -0.01597457f, 0.00085202f, -0.03031208f, 
    0.17490460f, 0.04651313f, 0.07437117f, 0.25113744f, 0.10427053f, -0.03054375f, 0.01474370f, -0.11292004f, 
    0.16907893f, 0.09427262f, -0.07662265f, 0.12567665f, 0.03580769f, -0.05066423f, 0.03990715f, 0.08922130f, 
    -0.21997778f, -0.09705168f, -0.46742472f, 0.25906047f, 0.11069274f, 0.24024719f, 0.29075831f, 0.05020845f, 
    0.11588059f, 0.05848228f, -0.00925368f, -0.09621482f, -0.11117704f, -0.05030390f, 0.20212941f, 0.18913418f, 
    -0.07833490f, 0.05980507f, -0.07988733f, 0.03364993f, -0.10372254f, -0.17247917f, -0.10352731f, -0.12163249f, 
    -0.25218347f, 0.07795174f, -0.05190135f, -0.14187942f, -0.06176561f, -0.07119152f, 0.00077705f, 0.07653940f, 
    -0.10190731f, 0.08002520f, 0.14493252f, 0.08852469f, -0.16057591f, -0.09741241f, 0.57125372f, 0.15485707f, 
    0.04198101f, 0.05254992f, -0.10292947f, 0.00900236f, -0.01070743f, -0.05343486f, -0.11897620f, -0.06250608f, 
    0.17985886f, 0.24638480f, 0.14031246f, 0.49576908f, 0.22989216f, 0.36215410f, -0.10306150f, 0.07324184f, 
    0.14147207f, 0.15237597f, 0.00092890f, 0.03533725f, -0.07633376f, 0.10230641f, 0.21260206f, -0.01002884f, 
    -0.05044634f, -0.04301200f, 0.17559929f, 0.13277796f, -0.24973610f, -0.05860710f, 0.15632142f, 0.05170695f, 
    -0.28536934f, -0.12275301f, -0.07001976f, 0.11244018f, -0.10815647f, 0.02204964f, 0.00805315f, 0.00422340f, 
    -0.00137037f, -0.15679869f, -0.05748734f, -0.08690979f, 0.11873770f, 0.13395825f, 0.05289992f, -0.19407430f, 
    -0.05865741f, -0.00723512f, -0.13860103f, -0.04239064f, 0.12695003f, 0.06655010f, 0.16890119f, 0.17869513f, 
    0.15402730f, 0.38679108f, 0.31873038f, -0.28081408f, 0.11426998f, -0.14386851f, -0.04429736f, 0.01209287f, 
    -0.07000774f, 0.14854120f, 0.13229480f, 0.07275712f, 0.05295201f, -0.02726922f, 0.16250877f, 0.11403136f, 
    -0.07269136f, 0.00819453f, -0.07543190f, 0.02857540f, -0.13246152f, -0.07182316f, -0.05132112f, -0.21159299f, 
    0.09348464f, 0.23168632f, 0.19769488f, 0.35208696f, 0.04682799f, 0.03395272f, -0.03422544f, -0.08792160f, 
    -0.23742643f, 0.01806649f, 0.09513521f, -0.11635840f, 0.01645115f, 0.18750632f, -0.09007099f, -0.00217664f, 
    -0.22320575f, -0.02451085f, -0.13163507f, -0.04143984f, -0.04693048f, 0.16736849f, -0.03273442f, 0.13139832f, 
    -0.01716380f, -0.11578166f, 0.27119085f, 0.20180307f, -0.16425458f, 0.21621361f, 0.06465269f, 0.33686602f, 
    0.06112333f, 0.08073889f, 0.13362233f, 0.15878400f, -0.48370972f, 0.23418342f, -0.21375632f, -0.09831604f, 
    -0.08988956f, 0.00350140f, 0.04811472f, -0.07966608f, 0.04638345f, 0.05539419f, -0.04829913f, 0.21641628f, 
    -0.00104243f, 0.28795597f, -0.02117984f, 0.26967800f, 0.04418445f, 0.07661298f, -0.03589911f, -0.06270314f, 
    0.11302360f, 0.05335459f, -0.06620916f, 0.41151449f, -0.18675432f, -0.13859548f, -0.21577545f, 0.00431806f, 
    0.05816328f, -0.00518714f, 0.08450693f, 0.13542031f, 0.06542697f, 0.18651618f, 0.14462984f, -0.08592212f, 
    -0.25821671f, 0.35089442f, 0.09260055f, 0.22166121f, -0.05380990f, 0.07893170f, 0.09603405f, 0.04245589f, 
    0.02849817f, 0.21849115f, -0.09253116f, -0.02242680f, 0.32764444f, -0.18429679f, 0.47027436f, -0.04908015f, 
    -0.09537199f, -0.10663801f, -0.09154965f, 0.05967526f, -0.01235744f, 0.15747115f, -0.10164195f, 0.11642288f, 
    0.18547432f, 0.22968179f, 0.07316896f, 0.08565060f, -0.04323613f, -0.12316658f, 0.04260483f, -0.03470854f, 
    0.19565053f, -0.00379506f, 0.03225711f, 0.21419969f, 0.13108440f, -0.29997507f, 0.10111995f, -0.21678513f, 
    -0.14292529f, -0.20339088f, -0.00300192f, -0.02390571f, -0.07224824f, -0.11588184f, -0.11627853f, 0.04987170f, 
    -0.17223389f, -0.21690698f, -0.10158215f, 0.32236356f, -0.24635787f, 0.03442746f, -0.08398524f, 0.11732811f, 
    0.05026738f, -0.15578675f, -0.04253447f, -0.00079120f, 0.15272312f, 0.10423247f, -0.08940823f, 0.17159539f, 
    0.17703351f, 0.24473232f, 0.15057072f, 0.00097981f, 0.00836093f, -0.12764680f, 0.05635009f, -0.00804892f, 
    -0.12661082f, 0.11865300f, -0.04525373f, -0.07818073f, -0.06232104f, 0.07376865f, -0.00536193f, 0.01290355f, 
    0.20385508f, 0.29495230f, 0.01153419f, -0.05706556f, 0.20854639f, 0.18848959f, 0.11583718f, 0.02312089f, 
    -0.10239765f, -0.10721905f, 0.05560071f, 0.00242002f, -0.08077623f, 0.07678076f, 0.14850384f, -0.00403483f, 
    -0.08537053f, 0.30262443f, -0.33764911f, 0.14652386f, 0.05541073f, -0.07714988f, 0.03569572f, -0.10369466f, 
    -0.09270353f, -0.01881537f, -0.12217968f, 0.02426285f, 0.25752142f, 0.30729011f, 0.10127144f, -0.16576791f, 
    -0.02467987f, -0.07736521f, -0.01822934f, -0.03909606f, -0.05839413f, 0.04753406f, -0.01889379f, -0.26580617f, 
    -0.19013317f, -0.05638504f, -0.40390319f, -0.31666240f, 0.05752176f, 0.10811125f, 0.08221249f, -0.03582053f, 
    0.01573331f, 0.04403878f, -0.01138091f, 0.01018297f, 0.20371947f, -0.03554007f, 0.27582929f, 0.06188824f, 
    0.02643308f, -0.01278026f, -0.13650081f, -0.16405194f, 0.20899585f, -0.05630012f, 0.11958506f, -0.02237453f, 
    -0.00906258f, 0.04711444f, 0.14899868f, 0.07455833f, 0.23283368f, 0.24905823f, 0.30482969f, 0.22833323f, 
    0.13327318f, 0.04513078f, 0.05551517f, 0.05552778f, 0.38057917f, -0.46841285f, 0.00798574f, 0.02533833f, 
    -0.14608045f, -0.12758170f, 0.01688939f, -0.11894331f, 0.18193917f, 0.06294310f, 0.09445941f, 0.13071379f, 
    -0.08094980f, -0.10541852f, 0.11732358f, -0.24283868f, -0.07514355f, 0.04528078f, -0.09137093f, 0.09587894f, 
    0.15123954f, -0.13367599f, -0.01756519f, -0.00423447f, 0.16946992f, 0.22360882f, 0.39775112f, 0.18684891f, 
    0.19816718f, -0.00117444f, 0.09178507f, 0.14846292f, 0.13446875f, -0.04308308f, -0.19155514f, -0.11008800f, 
    0.21661106f, -0.62485671f, -0.07200100f, -0.26745859f, -0.01995541f, -0.05230427f, -0.00341987f, -0.14083563f, 
    0.06388124f, -0.09076792f, 0.02703486f, -0.03415062f, -0.13247627f, 0.08427557f, -0.12633771f, -0.12968206f, 
    -0.11107145f, 0.07893980f, -0.04175981f, 0.04960997f, 0.07104004f, 0.03553498f, -0.11593954f, -0.15788013f, 
    0.00620599f, -0.15740329f, 0.32041311f, 0.05663653f, -0.15432566f, -0.00918338f, 0.04212314f, -0.16477068f, 
    -0.00575952f, -0.02743603f, -0.01380005f, -0.13639326f, 0.08798227f, 0.51413029f, -0.05226655f, 0.19018950f, 
    0.05926293f, -0.03893568f, -0.09619510f, 0.06497233f, -0.12620121f, -0.03045897f, 0.00957642f, -0.05601787f, 
    0.48579073f, 0.29771149f, -0.13842307f, -0.09597021f, 0.12818541f, 0.03907729f, 0.21240917f, -0.34896508f, 
    0.01847891f, 0.12408370f, 0.08949881f, 0.13997062f, -0.16740331f, -0.11183513f, 0.27247959f, -0.08939974f, 
    0.18441495f, 0.25311899f, 0.01162703f, 0.15023793f, -0.01018116f, 0.05860844f, 0.07649302f, 0.04284728f, 
    0.22813962f, -0.01334228f, 0.12348270f, -0.04272618f, -0.00301380f, -0.14847177f, -0.18841045f, -0.08112982f, 
    -0.05521039f, -0.19924210f, 0.07939259f, -0.21968614f, 0.02498011f, -0.02468888f, -0.07690877f, 0.15714845f, 
    0.27170539f, 0.01078625f, -0.10094637f, -0.18686636f, 0.08062448f, 0.08222406f, -0.04163260f, 0.10610189f, 
    0.23663734f, -0.05527334f, 0.24346782f, 0.30013669f, -0.11934152f, -0.03153159f, -0.02592430f, -0.03263430f, 
    -0.10676553f, -0.02490652f, 0.00330956f, 0.06992868f, -0.25122520f, 0.13558422f, 0.18945664f, 0.45167881f, 
    0.05600124f, -0.04570823f, 0.04659235f, 0.08624743f, 0.08540174f, -0.00075297f, -0.01340225f, -0.09875396f, 
    -0.28180462f, -0.40886587f, -0.64287925f, -0.31851882f, -0.04308050f, -0.10400862f, -0.01923870f, -0.13260710f, 
    -0.10738676f, -0.04480472f, -0.05158311f, 0.02515567f, 0.12228116f, 0.01228044f, 0.14686345f, 0.11169086f, 
    0.01546140f, 0.03608388f, 0.00210563f, -0.09148190f, 0.14071557f, 0.13126875f, 0.08295768f, 0.11300286f, 
    0.06520050f, -0.46927762f, -0.12768735f, -0.05413447f, 0.09280991f, -0.02546069f, 0.31755084f, 0.00530850f, 
    0.05103314f, -0.02012551f, -0.04290767f, -0.02773483f, -0.08496390f, 0.13104157f, 0.30290666f, -0.12164079f, 
    -0.18220022f, 0.08530767f, -0.02218865f, -0.04847966f, -0.02971554f, -0.11864648f, 0.07809512f, -0.04213734f, 
    -0.01522621f, 0.15510188f, 0.16755095f, -0.05962196f, -0.03598252f, 0.07015801f, 0.01378429f, -0.01087470f, 
    0.09362455f, -0.03247264f, 0.06224315f, -0.06182421f, -0.12494038f, -0.06532374f, -0.31709480f, -0.21156143f, 
    0.08371709f, -0.00088313f, 0.00692334f, 0.06406006f, -0.10298952f, -0.09965366f, -0.16959505f, -0.03401182f, 
    0.24562654f, -0.51566011f, -0.07698898f, -0.31440267f, -0.06842410f, 0.01394217f, -0.03469552f, -0.12134874f, 
    0.26052096f, 0.08865713f, 0.04378037f, -0.05396321f, 0.14706902f, -0.05046123f, 0.08925879f, 0.04070793f, 
    -0.03316815f, -0.09523927f, -0.06462916f, 0.06696453f, 0.15065442f, 0.05781131f, 0.03597603f, 0.02313156f, 
    0.24109423f, -0.08305153f, 0.13075224f, 0.22089571f, -0.13056909f, -0.07781395f, -0.09171206f, -0.02716764f, 
    -0.05214988f, 0.08674083f, 0.00290450f, -0.04597064f, 0.37605938f, 0.25667271f, 0.01416266f, 0.30001381f, 
    -0.21904716f, -0.09768017f, 0.21575212f, -0.17529629f, 0.01159447f, 0.02167512f, 0.00700913f, 0.04806203f, 
    -0.16388538f, -0.18828103f, -0.74703455f, -0.25337139f, 0.26913583f, -0.06238214f, 0.05976558f, -0.10143387f, 
    -0.09118296f, -0.01666688f, -0.09146757f, -0.02757673f, -0.15030268f, 0.10674178f, -0.07685661f, 0.03971915f, 
    0.26561499f, 0.14485447f, -0.08890310f, 0.05979057f, 0.00768616f, -0.05061719f, -0.05036243f, -0.04835784f, 
    -0.03687258f, 0.07019398f, 0.05057684f, 0.00750619f, 0.04787050f, 0.05472765f, -0.03812781f, -0.00995539f, 
    0.29068881f, -0.01810612f, 0.17810185f, 0.09824606f, 0.10628328f, 0.15659676f, 0.07135808f, 0.21573977f, 
    0.00731365f, -0.01027744f, -0.01961487f, -0.03378091f, -0.06496429f, -0.05986094f, -0.00890135f, 0.05381755f, 
    0.00485834f, 0.15007049f, 0.00093046f, 0.34536898f, -0.12324853f, 0.03106060f, 0.01244309f, -0.01327089f, 
    -0.10741600f, -0.03912818f, 0.02485523f, 0.10062008f, 0.28362471f, 0.06667866f, 0.02030993f, 0.13805604f, 
    0.01074640f, -0.03777383f, 0.05606475f, 0.07451736f, 0.17503947f, 0.04789473f, 0.02711155f, 0.23368481f, 
    -0.13936248f, 0.00474195f, 0.23501942f, 0.38089201f, -0.11663440f, -0.19016302f, -0.01300755f, 0.10760522f, 
    -0.03989613f, -0.14723451f, -0.05397322f, -0.00363979f, -0.26050600f, -0.10780931f, -0.07228882f, -0.21608587f, 
    0.00228012f, -0.02601731f, 0.04315520f, -0.02709394f, 0.03843673f, -0.09464130f, 0.09181717f, 0.22476286f, 
    0.02336070f, -0.00702994f, -0.10943875f, -0.00613624f, 0.04018121f, -0.05091268f, -0.01214469f, -0.30714554f, 
    0.07432472f, 0.05607309f, 0.07611820f, 0.16259158f, 0.43887052f, 0.34637329f, 0.21015762f, -0.22664185f, 
    -0.11041627f, 0.13428441f, -0.01975476f, 0.03672504f, 0.11530319f, 0.20111860f, 0.00242835f, -0.09298286f, 
    0.41495186f, -0.09187281f, 0.10342762f, 0.09269868f, -0.12146072f, -0.04967741f, -0.06745016f, 0.05572879f, 
    -0.15675929f, 0.06207917f, 0.26107359f, -0.09003702f, 0.05131955f, -0.09038448f, -0.01811179f, -0.05754557f, 
    -0.16858824f, 0.11992569f, -0.18006434f, -0.03313962f, 0.20116660f, -0.02808262f, 0.04364711f, 0.33788934f, 
    -0.06273862f, 0.47438586f, 0.17513376f, 0.17032433f, -0.07794806f, 0.00802078f, 0.08684380f, 0.16704360f, 
    0.09653948f, -0.00601056f, 0.00413619f, 0.00260233f, -0.29464334f, 0.05627868f, -0.30423787f, 0.17276470f, 
    0.11450743f, -0.16280864f, 0.14704601f, -0.17321597f, 0.15780109f, 0.16684383f, 0.28753123f, 0.12882790f, 
    -0.15332493f, -0.04686668f, -0.14387763f, 0.02424498f, 0.07164220f, -0.01459642f, -0.00318710f, 0.21145116f, 
    -0.27381486f, 0.01899233f, -0.05807463f, 0.18810108f, -0.08783294f, 0.04765880f, 0.09939735f, 0.19350718f, 
    0.27298045f, 0.06175310f, 0.23905905f, -0.01751342f, 0.24657300f, 0.10233361f, -0.07643317f, -0.14911285f, 
    -0.11601605f, -0.12618034f, 0.19625778f, -0.00722972f, 0.19485337f, 0.02118570f, -0.00190339f, 0.18844500f, 
    0.06750987f, -0.07598440f, -0.01515410f, 0.04707865f, -0.20435697f, -0.20247716f, -0.02020421f, 0.15372296f, 
    -0.20060880f, -0.03004144f, -0.06790214f, -0.02262898f, 0.07453616f, -0.10132732f, -0.20508653f, 0.17094067f, 
    -0.19279177f, -0.10140270f, -0.24086532f, -0.01468338f, 0.01622032f, -0.00058514f, 0.07926106f, -0.09778427f, 
    0.16946670f, 0.09104239f, -0.03849491f, 0.37880394f, -0.19836777f, -0.11620821f, -0.09967262f, -0.10239869f, 
    0.19953293f, 0.03147823f, -0.10450479f, 0.27746636f, -0.17260163f, -0.28036910f, 0.03370547f, -0.09321731f, 
    0.22180577f, -0.06843235f, 0.12311023f, -0.23660530f, 0.07805004f, 0.02673738f, -0.10087306f, -0.01776599f, 
    -0.02370033f, -0.01376234f, -0.02699436f, -0.08998809f, 0.09755749f, 0.05777193f, 0.00632337f, -0.12721540f, 
    -0.16584517f, -0.16963439f, -0.02616955f, -0.03564533f, 0.15061624f, 0.13773642f, 0.17952004f, 0.38862509f, 
    0.51517773f, -0.21415919f, 0.01202884f, 0.24363494f, 0.11681259f, -0.01457926f, 0.01190290f, 0.03660798f, 
    -0.04426548f, 0.11892942f, 0.07398982f, 0.08843318f, -0.42530304f, -0.18714580f, -0.39607036f, -0.36169928f, 
    -0.07715953f, 0.02972439f, 0.07544690f, -0.03165165f, -0.05060906f, 0.12288528f, 0.02204528f, 0.20312965f, 
    0.10087492f, 0.05962975f, 0.12889414f, 0.31727558f, -0.00658490f, 0.13213222f, -0.11279742f, 0.22045359f, 
    -0.00166957f, 0.16508690f, 0.11104726f, 0.30711889f, -0.17975391f, 0.32657149f, -0.33009505f, -0.04524853f, 
    0.09483098f, 0.13428999f, 0.01069803f, -0.00785084f, 0.00105908f, -0.08789763f, -0.08553004f, 0.02326037f, 
    -0.07371973f, 0.13274039f, -0.07157420f, -0.10576762f, -0.10462058f, 0.02126839f, 0.09518566f, -0.07729544f, 
    -0.08009532f, 0.06661612f, -0.10588921f, 0.03733741f, -0.02083052f, 0.19637203f, 0.12052799f, 0.02687705f, 
    0.02241402f, 0.00913038f, -0.05289557f, -0.04028526f, -0.02227237f, 0.15906574f, -0.05368363f, 0.05596548f, 
    -0.12638295f, -0.13659364f, -0.06376365f, 0.03747390f, 0.09087441f, 0.05559102f, 0.03216766f, 0.23090497f, 
    0.02958754f, 0.03286431f, -0.17836744f, 0.07694182f, 0.12147384f, 0.06508227f, 0.22052823f, 0.03110157f, 
    0.02232321f, 0.07718447f, 0.04240152f, 0.02306390f, 0.02179522f, 0.00060296f, -0.01736488f, 0.13256043f, 
    -0.14875403f, -0.13148382f, -0.19705735f, -0.33671182f, 0.00963145f, 0.01688982f, 0.03784444f, 0.04936275f, 
    0.08727501f, 0.03065653f, -0.02543519f, 0.16555355f, 0.46150562f, -0.12555549f, 0.03230890f, 0.20552517f, 
    -0.12816262f, -0.06629893f, 0.19133915f, 0.11680754f, 0.04604968f, 0.03924330f, -0.09702738f, -0.15682457f, 
    -0.05276021f, 0.07627505f, 0.25364533f, 0.29016152f, -0.07996811f, -0.03893201f, -0.18836774f, 0.02404184f, 
    0.04647515f, -0.05342643f, 0.02262064f, 0.09598056f, -0.05990312f, 0.29579177f, -0.01810107f, 0.07948207f, 
    0.01527528f, -0.13092802f, 0.17741437f, -0.10924347f, 0.01542780f, 0.05972733f, 0.15720691f, 0.11590085f, 
    -0.32087150f, -0.13014582f, -0.19863249f, 0.04095732f, -0.01240341f, 0.13348658f, 0.02547171f, -0.02936711f, 
    0.19984163f, -0.03843048f, -0.22831856f, -0.12472714f, -0.15175325f, 0.00871729f, 0.15929081f, -0.12768219f, 
    -0.06144332f, -0.02995047f, -0.04571389f, 0.00485730f, 0.05906347f, 0.02081844f, 0.13886899f, -0.15456009f, 
    0.04342221f, -0.15253739f, -0.10963937f, -0.13989067f, 0.06215958f, 0.01664308f, 0.00242520f, -0.16545001f, 
    -0.03902959f, 0.04813395f, 0.05189132f, 0.03393884f, -0.06341331f, -0.09564795f, -0.06583866f, -0.17733960f, 
    -0.08514464f, -0.08021434f, 0.06549869f, 0.01184758f, 0.01709482f, -0.06146593f, -0.08334354f, -0.07758236f, 
    0.33628350f, 0.22194164f, 0.01221059f, -0.14595538f, 0.09166703f, 0.12853345f, 0.19456272f, -0.02724940f, 
    0.08949017f, 0.11908456f, 0.10249492f, -0.13677607f, 0.04555064f, -0.17605014f, 0.29123676f, 0.08768503f, 
    0.00790247f, 0.19464506f, 0.05371393f, -0.12893763f, -0.05263973f, 0.08631996f, 0.11831017f, -0.18410975f, 
    0.12939391f, 0.06631029f, 0.01420650f, -0.13421409f, -0.04782634f, -0.01368048f, -0.03574580f, 0.05212365f, 
    -0.16997579f, -0.01525697f, -0.07575745f, 0.03922286f, 0.00595900f, 0.21278538f, 0.14168121f, 0.32260424f, 
    0.02178880f, -0.11607952f, -0.11847185f, -0.01250022f, 0.03081006f, 0.06837849f, 0.02004323f, 0.02986617f, 
    -0.40759096f, -0.13714424f, 0.15273437f, -0.08807255f, 0.05339411f, 0.09543777f, -0.03038320f, 0.20097862f, 
    0.01531577f, -0.05825129f, -0.08839021f, -0.23198083f, 0.17143853f, 0.23283988f, 0.06970617f, -0.01351625f, 
    0.07143202f, -0.06498541f, 0.19571361f, 0.07225932f, 0.14246731f, 0.06372143f, -0.08100067f, -0.24881200f, 
    0.26060972f, -0.08572949f, 0.13058750f, 0.00394902f, 0.10153361f, 0.04322390f, 0.00758171f, 0.02613985f, 
    -0.01397129f, 0.14913099f, 0.00964795f, 0.29446337f, 0.12853028f, -0.27424052f, -0.24363919f, 0.09116332f, 
    -0.12224300f, -0.08965199f, 0.15385744f, 0.21427096f, -0.00479948f, 0.26157606f, 0.00230212f, 0.16015583f, 
    -0.18439831f, -0.21608791f, 0.21037237f, -0.02590559f, -0.06968984f, 0.11400311f, -0.34095824f, -0.53659725f, 
    0.08831706f, -0.04369722f, 0.09254734f, -0.04353962f, -0.25309393f, 0.04200542f, -0.33945143f, -0.28942966f, 
    0.01352437f, 0.08590337f, -0.00076129f, 0.07737321f, -0.03485947f, -0.00371954f, 0.06710439f, 0.20041254f, 
    0.21041149f, 0.03803399f, -0.28763536f, -0.15514024f, 0.01984242f, -0.17295092f, 0.13327171f, -0.04610061f, 
    -0.17117298f, 0.05522417f, -0.07665591f, -0.11865866f, 0.04649286f, 0.10492585f, 0.10181452f, -0.21687122f, 
    -0.01083604f, 0.06352095f, 0.04523792f, -0.02491594f, 0.02556119f, -0.03854266f, -0.13471903f, -0.26448131f, 
    -0.29248118f, 0.02550915f, 0.41426504f, -0.15155186f, 0.10022607f, -0.31802818f, 0.02713009f, -0.10262173f, 
    -0.20551495f, 0.14311191f, 0.13600299f, 0.08560883f, -0.26959717f, -0.13641846f, -0.25987449f, 0.07899910f, 
    -0.05173396f, -0.10529355f, 0.33744970f, -0.19394524f, -0.16459571f, 0.03256561f, 0.00559015f, 0.09467618f, 
    -0.48823756f, 0.00188145f, -0.02555044f, 0.27328265f, 0.13995124f, 0.04259877f, -0.03164742f, 0.17312209f, 
    0.29504341f, -0.09570938f, -0.08733982f, -0.24295704f, -0.70494485f, 0.02236256f, 0.04342132f, 0.26874951f, 
    -0.09300325f, 0.07451291f, -0.00401028f, 0.01644731f, -0.19245909f, 0.02955084f, 0.08831608f, 0.05143919f, 
    0.15268955f, -0.29145423f, -0.36555356f, 0.06061368f, 0.20992224f, 0.15643638f, -0.15451302f, -0.08032999f, 
    0.04072626f, 0.03353141f, -0.02082918f, 0.08809346f, -0.02522676f, 0.09546812f, -0.04739821f, 0.01303582f, 
    0.03278008f, 0.01051752f, 0.01305327f, 0.03008263f, 0.03830785f, 0.13545480f, -0.02299836f, 0.14538400f, 
    0.04105577f, 0.03877476f, -0.41919893f, 0.42799014f, 0.26315647f, 0.14801078f, 0.20925619f, -0.17004855f, 
    -0.04102477f, 0.07272469f, 0.14214136f, -0.03414003f, 0.36030668f, -0.07870295f, -0.32273668f, -0.51681584f, 
    0.10115816f, 0.01059159f, 0.11018509f, 0.02376607f, 0.04945038f, 0.11093046f, -0.01608303f, -0.12409321f, 
    -0.00831984f, 0.00766808f, -0.09165154f, -0.15176930f, 0.12174268f, -0.00906756f, 0.01947688f, -0.02918640f, 
    -0.10297783f, 0.02957829f, -0.11813013f, -0.03050336f, 0.32923859f, 0.06705729f, 0.08050210f, -0.22596662f, 
    0.11563712f, 0.10931876f, -0.18746008f, -0.03778680f, 0.10899060f, 0.00637548f, 0.09246729f, 0.19097017f, 
    0.02892544f, -0.44422162f, -0.41034469f, 0.14246608f, 0.09301237f, 0.12194326f, 0.18460718f, 0.02631326f, 
    0.04161891f, 0.04385645f, 0.02622851f, -0.05531034f, -0.19742273f, -0.01117458f, -0.13377108f, 0.31484771f, 
    -0.09935360f, 0.14093561f, -0.12243260f, -0.04763073f, 0.00355396f, 0.14190063f, 0.21585411f, 0.05745311f, 
    -0.06770932f, 0.04470273f, -0.13026440f, -0.12096580f, 0.10298558f, -0.00664094f, 0.07320360f, -0.00183836f, 
    -0.02180742f, 0.07799338f, 0.01325107f, 0.10738927f, 0.11146354f, 0.13436189f, 0.61643511f, 0.12560670f, 
    -0.07516485f, -0.12318470f, -0.15851985f, 0.28761214f, 0.02069508f, -0.02863996f, -0.00176947f, -0.01850449f, 
    0.41555759f, 0.28646684f, 0.29461107f, 0.14960535f, 0.21415284f, 0.30092087f, -0.10000370f, -0.05540549f, 
    0.04392125f, -0.00122323f, -0.02352609f, -0.06531313f, 0.02942326f, 0.17867084f, 0.15506679f, 0.01299237f, 
    -0.23205370f, -0.07261164f, 0.14108369f, -0.04611600f, -0.12987655f, 0.05997237f, -0.07471791f, 0.08558022f, 
    -0.16523974f, -0.23308994f, 0.02699277f, 0.02585642f, -0.01807725f, 0.03922914f, -0.12014089f, -0.01772257f, 
    -0.01890472f, -0.14741690f, 0.07543579f, -0.03304734f, 0.10179608f, 0.02711615f, 0.09989084f, -0.13898462f, 
    0.08071982f, -0.01097170f, -0.06122472f, -0.04874057f, 0.01744560f, -0.02676874f, -0.01798698f, 0.00947834f, 
    0.31461450f, 0.37108412f, 0.47155046f, -0.18285356f, 0.24125393f, -0.16047148f, -0.08874817f, 0.09960803f, 
    -0.05695491f, 0.11956322f, 0.06156242f, -0.02222483f, -0.26007017f, -0.02394991f, 0.20686977f, 0.07388236f, 
    -0.00779810f, -0.03352737f, 0.02449138f, -0.04987063f, 0.10238641f, 0.00364244f, -0.03430809f, 0.01028083f, 
    0.00804059f, 0.02728053f, -0.05946156f, 0.07411647f, 0.00500784f, 0.01680124f, 0.06036741f, 0.05023030f, 
    0.02044367f, -0.06933922f, -0.00618579f, 0.05386185f, 0.05868357f, -0.02415126f, 0.04720652f, 0.00046090f, 
    0.05729499f, -0.06309612f, 0.05511199f, -0.08286830f, -0.03658970f, -0.04880821f, 0.01412616f, -0.00477590f, 
    -0.01384166f, -0.04224424f, -0.02022434f, -0.01012780f, 0.04934827f, 0.02540373f, 0.02471110f, 0.05794426f, 
    0.00917874f, -0.05581324f, 0.00798715f, 0.01457707f, 0.03975422f, 0.02780674f, 0.03235045f, -0.04734522f, 
    0.01365422f, 0.03022751f, 0.04174242f, -0.06217746f, 0.02598234f, -0.06817650f, 0.02306712f, 0.02238197f, 
    0.05778987f, 0.01559414f, -0.03081652f, -0.01700084f, -0.07631698f, -0.00334176f, 0.03545491f, 0.01790776f, 
    -0.01455319f, 0.00007123f, -0.07617264f, 0.02461393f, -0.04578403f, -0.04997453f, -0.07206318f, -0.02675118f, 
    0.00049064f, 0.05488791f, -0.02800223f, -0.02717395f, -0.02326878f, -0.01900517f, -0.02159270f, 0.00436928f, 
    -0.07614734f, 0.05522967f, -0.00254763f, -0.01646154f, 0.01978214f, -0.02546812f, -0.04714239f, -0.07583135f, 
    -0.00122915f, -0.02275520f, -0.03195417f, -0.01486117f, 0.02143112f, 0.02624087f, -0.03544264f, -0.05462664f, 
    0.04007962f, 0.03996900f, 0.00550533f, 0.05405687f, -0.02731551f, -0.03201665f, 0.03599332f, -0.01669987f, 
    0.02476162f, 0.02240928f, 0.01608225f, 0.01197993f, -0.07500874f, -0.04353046f, -0.01913326f, 0.02005991f, 
    -0.06732957f, 0.05683805f, 0.01412469f, 0.05217051f, -0.06919200f, -0.04522971f, 0.00743794f, -0.04751958f, 
    0.04721434f, -0.04825990f, -0.07063649f, -0.03994181f, -0.05310000f, -0.03174767f, -0.00452312f, -0.03774345f, 
    -0.06617770f, -0.04755247f, -0.07167020f, -0.01696389f, -0.04354420f, -0.02749949f, -0.03540261f, -0.04522029f, 
    -0.01780632f, -0.06460884f, -0.00397908f, 0.05761789f, 0.00605737f, 0.00342374f, -0.02579489f, 0.03870875f, 
    -0.07416200f, -0.03228518f, -0.06644724f, 0.04433879f, -0.01195461f, -0.05638842f, 0.02192954f, -0.06883311f, 
    0.03863251f, 0.01603359f, 0.03759088f, -0.07137989f, -0.06127080f, -0.05687420f, -0.06906831f, 0.00427876f, 
    -0.03638702f, -0.03259432f, 0.02213039f, 0.03484522f, -0.05877335f, -0.02267542f, -0.02558268f, 0.01750463f, 
    0.04642366f, -0.01927382f, -0.05651763f, -0.05288507f, 0.03469269f, 0.02853971f, 0.02359814f, -0.05080567f, 
    0.05104259f, 0.00676490f, 0.02497040f, -0.05712519f, -0.02766454f, -0.02804637f, -0.00774304f, -0.05376882f, 
    -0.04074192f, 0.04504262f, 0.03586847f, -0.06630740f, -0.00194332f, -0.03422917f, 0.02314252f, -0.07520190f, 
    0.02811909f, -0.00966409f, -0.05349806f, -0.06146923f, 0.00418394f, 0.00638219f, 0.03978493f, 0.05187150f, 
    0.26193300f, 0.40507978f, -0.07064160f, -0.03082632f, 0.11113230f, 0.17231075f, 0.20905283f, 0.01150619f, 
    -0.00304483f, 0.05907634f, 0.01867120f, -0.01833555f, -0.12796851f, -0.27176097f, -0.10917922f, -0.11866277f, 
    0.09238190f, -0.03684141f, -0.01310387f, 0.01318081f, 0.07440979f, 0.06477753f, -0.04891371f, -0.22807854f, 
    0.34962744f, -0.02970397f, 0.17771870f, 0.10848746f, 0.03733576f, 0.13809636f, 0.18919539f, 0.11042550f, 
    -0.04414254f, -0.01387639f, -0.02240944f, -0.10601520f, -0.32588592f, -0.38133198f, 0.02430755f, 0.04479768f, 
    -0.16358906f, 0.01257531f, 0.14878266f, 0.13270238f, 0.15780263f, 0.10937834f, 0.10297130f, -0.26289320f, 
    -0.03016971f, -0.16423152f, -0.27263188f, -0.08575327f, -0.02594428f, 0.02857640f, -0.01226877f, 0.15497951f, 
    0.04804727f, -0.02360326f, 0.07985398f, -0.32379684f, 0.25529650f, 0.27438894f, 0.21846227f, 0.09461195f, 
    0.03544727f, 0.02814422f, 0.01193451f, 0.09006002f, 0.19705632f, -0.04044149f, -0.07053384f, -0.02629443f, 
    0.36842892f, -0.11340147f, -0.13540715f, -0.15342882f, -0.00261840f, 0.10580227f, 0.08756125f, 0.11455058f, 
    0.25282452f, 0.12163357f, -0.09939838f, -0.15943269f, -0.00196377f, -0.09758981f, -0.59767759f, -0.07858336f, 
    0.12990180f, -0.05118047f, 0.02429824f, 0.03805520f, -0.14639212f, 0.07591031f, -0.09683140f, -0.11814028f, 
    -0.16775396f, -0.49351138f, -0.15140763f, -0.10271693f, -0.02260683f, -0.04701151f, -0.09027711f, 0.01683153f, 
    0.09236681f, 0.05899015f, 0.19604138f, -0.05392942f, 0.03198560f, 0.34790787f, -0.24036551f, -0.21250404f, 
    0.16506070f, -0.20974773f, -0.28386909f, -0.11017907f, -0.08197141f, 0.03740764f, 0.06831404f, 0.05095397f, 
    0.36584783f, 0.09715208f, 0.15541765f, -0.18103886f, -0.02563262f, -0.00147393f, 0.13540190f, -0.24318172f, 
    0.08349749f, 0.04243500f, 0.11472471f, 0.14735505f, -0.23240736f, -0.12614925f, -0.00242152f, -0.09998257f, 
    0.09892916f, 0.22580001f, -0.12610035f, 0.08247997f, -0.02822475f, -0.00601457f, 0.07678563f, 0.00478462f, 
    -0.10573769f, -0.26996809f, -0.08333199f, -0.18014920f, 0.09156188f, 0.00561021f, -0.01542651f, 0.02994050f, 
    -0.41488606f, -0.04143793f, -0.05937476f, -0.09956574f, -0.14260191f, -0.17955568f, -0.06073239f, 0.03199602f, 
    -0.00699820f, 0.00782996f, 0.05430886f, 0.03202551f, 0.14723225f, 0.17430072f, 0.01246952f, 0.24399059f, 
    -0.13769662f, 0.05582723f, 0.03212317f, 0.22215168f, -0.04155660f, -0.13184249f, -0.07522798f, 0.14906730f, 
    0.09236722f, 0.05637562f, 0.15123397f, 0.10475446f, -0.29477221f, -0.20304374f, -0.25417668f, -0.30853388f, 
    0.19272611f, 0.05043358f, -0.02726721f, 0.09007448f, 0.06846192f, 0.05114329f, 0.07009690f, -0.19576646f, 
    -0.48832393f, -0.08234357f, -0.48044586f, -0.14303660f, -0.07784578f, -0.22833204f, -0.13643353f, -0.09319000f, 
    -0.08371928f, -0.02875896f, 0.01238451f, -0.04805790f, 0.24933095f, 0.07794939f, 0.19344836f, 0.12535602f, 
    -0.03784526f, 0.05746633f, -0.03528471f, -0.02725178f, 0.11386304f, 0.02621668f, -0.07496866f, -0.02490575f, 
    -0.03539129f, -0.11698582f, -0.42815498f, -0.03425599f, 0.08452223f, 0.09444682f, 0.15603121f, 0.17216815f, 
    -0.02213165f, 0.14684132f, 0.02113772f, 0.11869960f, 0.00489582f, -0.04228174f, 0.17438231f, -0.33854830f, 
    -0.17786425f, -0.07730436f, -0.03962215f, 0.02970067f, 0.06352873f, -0.02108460f, 0.02408221f, -0.24189025f, 
    0.34204409f, 0.06030137f, 0.27410725f, 0.22376338f, -0.03774479f, -0.02880964f, -0.03298859f, 0.03380796f, 
    0.04836150f, 0.09852266f, 0.24054669f, -0.16316754f, -0.34318686f, -0.04952293f, -0.19326583f, -0.24476622f, 
    -0.03752399f, 0.12957613f, -0.05605484f, 0.00809049f, -0.00779836f, -0.14464803f, -0.07733389f, 0.04861532f, 
    -0.00555215f, -0.11783006f, -0.24844931f, -0.49304798f, -0.16068935f, -0.04609023f, -0.03212567f, -0.08669896f, 
    0.33160439f, 0.10030988f, -0.03285573f, -0.06361533f, 0.18448254f, -0.00841552f, 0.04823465f, 0.15951388f, 
    0.07609682f, -0.04307215f, 0.04824836f, 0.05914148f, 0.07677156f, 0.07087920f, 0.00547256f, 0.03635359f, 
    0.27807915f, 0.15084745f, 0.36887455f, 0.30219123f, -0.00918989f, -0.04369340f, -0.08421652f, -0.10254265f, 
    -0.02113626f, 0.00196843f, -0.02145764f, -0.00506466f, 0.36295494f, -0.02937157f, -0.18711795f, 0.10539239f, 
    -0.11696238f, 0.05944471f, 0.11969285f, -0.14600031f, -0.02378048f, 0.09379293f, 0.03080938f, 0.10069329f, 
    -0.51550305f, -0.12682046f, -0.74320090f, -0.07073973f, 0.15245605f, -0.06517957f, 0.05014729f, -0.41128796f, 
    -0.01981955f, -0.05605819f, -0.00057670f, 0.03365179f, 0.05590313f, -0.06857405f, -0.05814410f, 0.05879530f, 
    0.02812599f, 0.01814216f, -0.04704009f, 0.15716879f, -0.01823669f, 0.05161666f, 0.09148687f, -0.12457924f, 
    0.16059320f, 0.11033820f, -0.00962885f, 0.07328898f, -0.00184250f, 0.00305987f, 0.09307170f, 0.06881716f, 
    0.22702891f, -0.04164837f, 0.13079180f, 0.08773281f, 0.09647046f, 0.13443518f, 0.10988915f, 0.30670869f, 
    -0.05540372f, 0.01493605f, -0.00897753f, 0.04218658f, -0.07830925f, -0.05681542f, -0.08891226f, 0.05320485f, 
    0.02298276f, 0.11533011f, 0.20288220f, 0.32873026f, -0.22594219f, 0.07818380f, -0.04727413f, -0.02306494f, 
    0.04795005f, -0.05534890f, 0.04951199f, 0.11238159f, 0.37644094f, -0.02227866f, 0.22243193f, 0.26072362f, 
    -0.09103324f, 0.01677255f, 0.04670764f, 0.03298868f, 0.10799063f, 0.01690474f, 0.00121532f, 0.07443685f, 
    -0.33238140f, -0.21484180f, -0.13579138f, 0.02095614f, -0.01423509f, -0.10968065f, 0.12958196f, 0.11695502f, 
    0.10132580f, 0.07816852f, 0.09636844f, 0.16913271f, -0.00592304f, 0.03605168f, 0.06955516f, -0.09723340f, 
    0.00163182f, -0.07836780f, 0.05013971f, -0.15729925f, -0.04692424f, -0.09192518f, -0.02174144f, 0.07748067f, 
    -0.31148979f, 0.13929039f, 0.19829287f, -0.01511125f, 0.05673709f, -0.00897370f, 0.25081825f, 0.17206705f, 
    0.15360998f, 0.17270306f, 0.18435706f, 0.18510075f, 0.41288033f, -0.19782652f, -0.10144108f, 0.20669213f, 
    0.12985596f, -0.11042513f, -0.10056823f, 0.00835466f, 0.15306738f, -0.00591712f, 0.29710943f, 0.24635164f, 
    0.12172487f, -0.05233463f, 0.11681681f, 0.08864414f, 0.09360877f, 0.02374506f, -0.16348958f, 0.02128593f, 
    0.23494801f, 0.06477857f, 0.08981535f, 0.30614504f, -0.23238260f, -0.19607596f, -0.04883856f, 0.19441220f, 
    0.07729617f, -0.08833568f, 0.01548446f, 0.14632905f, 0.05582877f, -0.00715296f, -0.00089380f, -0.00107085f, 
    -0.28642616f, 0.03556614f, 0.18326665f, 0.11784828f, -0.12276291f, -0.00561601f, 0.01972308f, -0.03145761f, 
    -0.01316235f, 0.01435769f, 0.24206442f, -0.04991445f, -0.08509275f, 0.14419782f, 0.34738487f, -0.12407557f, 
    -0.03393741f, -0.10743397f, 0.17180359f, 0.02570009f, 0.12085715f, -0.10257968f, -0.04522645f, 0.13765396f, 
    0.03240281f, 0.12323206f, -0.03914195f, 0.00122459f, -0.03730372f, -0.08991519f, 0.09917364f, -0.00096208f, 
    -0.07961525f, 0.01824034f, -0.11684451f, -0.00631670f, -0.06920092f, 0.01263434f, 0.14404179f, 0.12534381f, 
    0.15125938f, 0.31812352f, 0.26837003f, 0.06322654f, -0.02908944f, -0.08029897f, -0.05818636f, -0.10690741f, 
    -0.15672013f, -0.04317775f, 0.00169605f, 0.13908057f, 0.15714628f, 0.14969271f, 0.06323137f, -0.02553168f, 
    0.12042362f, 0.05533085f, 0.08602042f, 0.07762678f, 0.19867033f, -0.23586841f, 0.05484955f, 0.12767048f, 
    0.15733008f, -0.08497932f, -0.08594189f, 0.18520673f, 0.07288475f, 0.10735532f, 0.05843174f, 0.13133895f, 
    0.20550694f, 0.16337027f, -0.02986970f, -0.05720991f, -0.00915178f, -0.07263260f, -0.07067113f, -0.05450527f, 
    0.18099324f, 0.01365364f, -0.00296290f, -0.18879886f, 0.10730794f, 0.01415878f, -0.16252278f, 0.03247444f, 
    0.14860739f, -0.05006620f, 0.02470578f, -0.01979134f, 0.08055983f, 0.19274843f, 0.03302811f, -0.02637126f, 
    0.14308755f, -0.22329268f, 0.07039761f, -0.15909830f, 0.15795991f, 0.04204958f, 0.02348244f, -0.08408118f, 
    -0.04996955f, 0.11282477f, 0.10159077f, 0.04664155f, -0.02156500f, 0.28659788f, 0.11364169f, 0.19655444f, 
    -0.01236183f, -0.01089711f, -0.03159558f, -0.00047567f, 0.01852512f, -0.05824015f, -0.18613820f, -0.04808577f, 
    0.23400231f, 0.20010585f, 0.07970042f, 0.03385619f, 0.24334347f, 0.07157089f, 0.01996835f, 0.02271855f, 
    0.17992225f, -0.03147142f, 0.01510854f, 0.15049662f, -0.20718518f, -0.43551391f, -0.11310397f, 0.02207155f, 
    0.17905889f, -0.02478238f, -0.06828623f, -0.02210934f, 0.24483092f, 0.14234678f, 0.14251198f, 0.22434191f, 
    0.23107512f, 0.35110703f, 0.06728252f, 0.18490078f, 0.20990697f, -0.14309128f, 0.00517327f, -0.06632166f, 
    0.15106739f, -0.01397320f, 0.11898607f, 0.00991653f, 0.00792921f, -0.23994790f, 0.14943016f, 0.22739385f, 
    -0.06719196f, -0.10673689f, -0.00803989f, 0.06540506f, -0.05222435f, 0.09797547f, -0.09737184f, 0.20927468f, 
    -0.07664017f, -0.41712531f, -0.27568918f, -0.27143121f, 0.12606744f, -0.15989335f, -0.14287321f, -0.02158216f, 
    0.06031595f, -0.09991775f, -0.23586060f, 0.12164287f, 0.10615190f, 0.10937428f, 0.24051753f, 0.12599865f, 
    0.09283680f, 0.00915935f, -0.05174472f, -0.02619690f, 0.08890443f, -0.05363746f, 0.10953066f, 0.18255581f, 
    0.20553392f, 0.01652427f, -0.05782674f, 0.05212086f, 0.16781345f, 0.07272985f, 0.11642957f, -0.02216230f, 
    0.04521138f, 0.15810888f, 0.07904506f, 0.00477722f, -0.13222036f, 0.12840217f, -0.13968387f, -0.06563249f, 
    -0.02906060f, -0.04980350f, -0.11276992f, -0.10773251f, -0.03442522f, -0.05168164f, 0.13001715f, 0.01909790f, 
    -0.21647252f, -0.34199548f, -0.31495306f, 0.04386045f, 0.07467621f, -0.27775788f, 0.13885109f, -0.06328811f, 
    -0.12592657f, 0.04428529f, 0.05490543f, 0.02303342f, 0.01894994f, 0.11459779f, 0.25364503f, 0.29662293f, 
    -0.08600679f, 0.14344394f, 0.04119680f, 0.25360203f, 0.05719502f, 0.07470616f, 0.13703731f, -0.09365679f, 
    0.24096631f, 0.37702692f, -0.06295390f, 0.01976356f, 0.14676540f, 0.13495404f, -0.13080658f, -0.18555948f, 
    -0.08779237f, -0.00930357f, -0.11166661f, -0.03001978f, 0.02895329f, -0.09562822f, 0.12796934f, -0.01769422f, 
    -0.11501241f, -0.04081666f, -0.20515694f, 0.11199851f, 0.17326997f, 0.02172351f, 0.10278474f, 0.07250658f, 
    -0.14229506f, -0.21936120f, -0.14028698f, -0.03360114f, -0.03860165f, 0.06021218f, -0.26677564f, 0.03200332f, 
    -0.05431454f, 0.00070115f, 0.09497625f, -0.00610221f, -0.20463631f, -0.26727372f, -0.15324010f, 0.10418539f, 
    0.14974394f, 0.03272104f, -0.26157206f, -0.05410568f, -0.00644529f, -0.04326633f, -0.14733607f, -0.00884163f, 
    -0.17181686f, -0.26448366f, 0.59228724f, -0.02967271f, -0.09095241f, -0.08346228f, 0.02788489f, 0.16870774f, 
    0.08577402f, -0.11043087f, -0.04900484f, 0.03966684f, -0.22755545f, -0.35262787f, -0.16559027f, 0.22725271f, 
    0.09809338f, 0.09092589f, 0.03468869f, 0.01975822f, 0.14397615f, 0.02483910f, 0.06927379f, 0.24244732f, 
    0.48450795f, -0.38272685f, -0.22831729f, -0.09739440f, -0.10068572f, 0.08400076f, 0.14998318f, 0.15015531f, 
    0.01854343f, 0.05925713f, -0.12935159f, 0.01856810f, -0.11179259f, 0.13802139f, 0.06199709f, -0.09112645f, 
    0.02290628f, 0.09086358f, 0.03497982f, -0.08541315f, -0.02209865f, 0.14769067f, 0.17068072f, 0.22932844f, 
    0.34711513f, -0.30384642f, -0.08040248f, 0.18583106f, 0.01094454f, 0.26266417f, 0.21440020f, 0.16275942f, 
    -0.01993205f, -0.10838068f, -0.05084885f, 0.17756271f, 0.35903293f, 0.49321291f, -0.17932476f, -0.30413225f, 
    0.07335040f, 0.14568760f, 0.11898907f, -0.21563067f, 0.03959659f, 0.02247118f, 0.19685304f, -0.03240488f, 
    -0.10048744f, 0.09281272f, 0.44574258f, -0.19348618f, -0.12923016f, -0.02028384f, 0.14421308f, -0.06258958f, 
    -0.20001075f, 0.08264010f, -0.07621920f, -0.10909102f, 0.29951194f, 0.34211564f, 0.10913453f, -0.14924432f, 
    0.23627402f, 0.15653421f, 0.03892395f, 0.18033189f, 0.09630179f, 0.07496570f, -0.08985973f, -0.09995786f, 
    0.32980368f, -0.46457523f, -0.14003371f, -0.05331870f, 0.05942896f, 0.02310692f, 0.11905657f, 0.13976824f, 
    0.19924994f, -0.10290886f, -0.14106774f, -0.01660474f, -0.19806063f, -0.01785264f, -0.08122831f, 0.14447181f, 
    -0.03748955f, 0.09651565f, -0.07973200f, 0.01780794f, -0.01071093f, -0.20005669f, 0.00505703f, -0.18956171f, 
    -0.00291847f, 0.06403448f, 0.06867542f, -0.16805834f, -0.07472856f, 0.09454555f, -0.12667799f, -0.07092735f, 
    0.18069880f, 0.04022028f, 0.17100698f, -0.00363424f, -0.01027333f, 0.55405658f, 0.14198270f, 0.05266696f, 
    -0.01882752f, -0.13069062f, -0.04025552f, -0.03470588f, -0.08941968f, -0.00173405f, -0.01607662f, -0.13219346f, 
    0.26311567f, -0.02467900f, 0.02825923f, 0.09000909f, -0.04216172f, 0.13237159f, 0.05927851f, 0.24126065f, 
    0.05153364f, -0.00057910f, 0.04251295f, -0.00286145f, -0.28859985f, 0.21119308f, 0.17914407f, -0.18105899f, 
    0.22585912f, 0.04356498f, 0.10933866f, -0.14451091f, -0.21792915f, 0.09945952f, 0.06806530f, 0.13982125f, 
    -0.20418203f, 0.03012620f, -0.01902033f, 0.07539435f, 0.02186045f, -0.05438525f, -0.09930534f, 0.01095478f, 
    -0.02559265f, 0.00457861f, -0.00772178f, -0.03796317f, 0.07311402f, 0.02297324f, 0.13917695f, -0.14993091f, 
    0.03307142f, 0.13784757f, -0.03297444f, -0.10245071f, 0.07053405f, -0.04947799f, 0.18432716f, 0.18580215f, 
    0.09729804f, 0.12176864f, -0.00186745f, 0.12162691f, 0.04963308f, -0.06555467f, -0.00312627f, -0.05614880f, 
    0.01700800f, -0.00324719f, 0.04620387f, 0.11565882f, -0.10350601f, 0.08459872f, 0.23014586f, 0.07874899f, 
    0.01429064f, 0.01817256f, 0.01545921f, 0.06898384f, -0.00114998f, -0.10617162f, -0.13578422f, -0.16563889f, 
    0.02619289f, 0.05468992f, -0.05320126f, 0.06126260f, 0.05558239f, 0.00966389f, -0.05140037f, -0.04431260f, 
    -0.00266232f, 0.02497006f, 0.04865032f, -0.05732370f, -0.06372166f, -0.06481944f, 0.05708647f, 0.06032326f, 
    -0.01227480f, -0.07628239f, 0.00188055f, -0.06836816f, 0.00005848f, 0.06445414f, -0.02662328f, -0.07629552f, 
    -0.06147232f, -0.06615795f, -0.04029290f, 0.02044001f, -0.02754149f, -0.07864497f, -0.04448346f, 0.01850218f, 
    -0.02645257f, -0.01833138f, -0.07345631f, -0.07718655f, -0.07538147f, -0.04524016f, 0.01918963f, 0.04042027f, 
    0.01786645f, -0.04364773f, -0.01810598f, -0.00785728f, 0.04120387f, -0.07925266f, -0.04220491f, 0.05584874f, 
    0.01773722f, 0.00579433f, -0.03644444f, -0.03916311f, 0.02975005f, 0.00338691f, 0.04631012f, -0.04762163f, 
    0.01577602f, 0.06233790f, 0.05663050f, -0.06930527f, 0.04844491f, 0.06066002f, 0.03090706f, -0.04939933f, 
    0.05347396f, 0.03388638f, -0.06236137f, -0.02197085f, 0.01148481f, 0.02032009f, -0.04904504f, -0.05731777f, 
    -0.01338099f, -0.00837541f, 0.01952262f, 0.01625537f, 0.00885003f, 0.02469253f, -0.03331906f, 0.05283663f, 
    -0.06039972f, -0.03460227f, -0.04231408f, 0.03091888f, -0.01307191f, 0.04786422f, -0.02454030f, 0.03459206f, 
    -0.06171711f, -0.04899624f, 0.05994079f, -0.02429983f, -0.03787169f, 0.00923232f, -0.03104487f, 0.01442303f, 
    -0.02635208f, 0.04191457f, 0.02982052f, -0.06789824f, -0.03914900f, -0.06613166f, -0.03106010f, -0.06478126f, 
    -0.06522766f, -0.04254796f, 0.02702548f, 0.00255832f, 0.03621068f, -0.00291331f, -0.04772680f, -0.05783640f, 
    -0.04355327f, -0.06540842f, -0.03829855f, 0.02621645f, 0.05725449f, -0.01004001f, -0.05227716f, -0.06992710f, 
    0.01668097f, -0.05123995f, 0.04821521f, 0.05812554f, -0.05139461f, -0.06456184f, -0.01078772f, 0.01301466f, 
    -0.01227279f, -0.07405739f, -0.03593956f, -0.02926548f, 0.05714276f, -0.02757878f, -0.00872796f, -0.07194717f, 
    0.03861535f, 0.03112129f, 0.04778810f, -0.03506022f, 0.02870471f, 0.03718674f, 0.03325997f, -0.07905263f, 
    0.02177031f, 0.06187707f, 0.05449077f, -0.03700214f, 0.00921467f, -0.04906313f, -0.07385793f, -0.02825784f, 
    -0.02646041f, -0.02591455f, -0.04381686f, -0.03818091f, 0.05325552f, -0.04951493f, -0.05736868f, 0.03873451f, 
    0.02231512f, -0.06320814f, -0.03094801f, -0.01344915f, -0.05088390f, -0.05342732f, -0.07870196f, 0.04366412f, 
    -0.07672557f, 0.05580560f, 0.02687297f, 0.00453507f, -0.01621301f, 0.05317998f, -0.03151641f, 0.01561149f, 
    -0.06510226f, 0.00761796f, -0.07161475f, -0.06912892f, 0.04828253f, 0.01664349f, 0.05942937f, -0.04314239f, 
    0.01093789f, -0.06360456f, -0.03349084f, -0.06218709f, -0.06148637f, 0.06217059f, 0.00651904f, -0.01933247f, 
    0.06441536f, 0.01073114f, 0.05823724f, 0.03712996f, 0.00716456f, 0.05796251f, -0.07573666f, 0.02530784f, 
    -0.06535938f, 0.03108875f, -0.06717002f, -0.03370823f, -0.01591969f, 0.06146607f, -0.00335896f, -0.02449488f, 
    0.02236934f, 0.03692201f, -0.01645832f, -0.00980302f, -0.05813073f, -0.06799288f, 0.03696376f, 0.03683021f, 
    -0.01971774f, 0.00344056f, 0.01753044f, -0.05794845f, 0.04948352f, -0.06804024f, 0.02886801f, 0.05762581f, 
    0.03520478f, -0.07627662f, -0.02603562f, 0.03538715f, -0.03571588f, -0.01691921f, -0.06605998f, 0.06023768f, 
    -0.01469956f, 0.05929340f, -0.02459157f, -0.05069032f, 0.03299224f, -0.06039794f, -0.06074119f, -0.02903733f, 
    -0.07156116f, 0.01783723f, 0.02803479f, 0.00144074f, -0.07672407f, -0.06582303f, -0.05459069f, -0.01064732f, 
    0.01167232f, -0.03040226f, -0.05682709f, -0.04377541f, -0.02767516f, 0.01630978f, -0.02525217f, -0.03633080f, 
    -0.07103579f, -0.00558440f, 0.02581856f, 0.02609351f, -0.06517316f, -0.07394416f, -0.00173855f, -0.06693429f, 
    -0.01682634f, 0.04022279f, -0.00798043f, 0.02223251f, -0.08485306f, 0.00615455f, -0.02093391f, 0.07121274f, 
    0.02726521f, -0.02458624f, 0.05269063f, 0.02507977f, -0.03778266f, -0.01233402f, -0.00669623f, 0.00963004f, 
    -0.00172132f, 0.04979945f, -0.07269599f, 0.05737349f, -0.06814869f, -0.06295015f, -0.01068702f, 0.00628058f, 
    0.04453526f, 0.04928785f, -0.03723096f, -0.02815091f, -0.03651853f, 0.05641839f, 0.02536191f, 0.06968049f, 
    0.01544865f, 0.02405004f, -0.04185917f, 0.02772296f, -0.08878337f, -0.02136420f, 0.05253964f, -0.06079294f, 
    0.01548422f, -0.00853394f, -0.02078438f, -0.02975031f, 0.02711959f, -0.01196969f, -0.01378554f, -0.05956260f, 
    0.03484022f, -0.06112273f, -0.02881898f, 0.02826508f, 0.00118476f, -0.02499920f, 0.06790072f, -0.06333327f, 
    -0.02653652f, -0.03987842f, 0.00826404f, -0.05363560f, 0.00331386f, -0.05623667f, -0.01909642f, -0.07440249f, 
    0.02524133f, -0.06563105f, 0.06514452f, 0.03045693f, -0.07519183f, -0.03713322f, -0.04364708f, 0.06811903f, 
    -0.01312657f, -0.03161714f, 0.03387986f, 0.05357559f, -0.00583247f, 0.00268828f, 0.00520290f, -0.06860854f, 
    -0.04717099f, 0.03668042f, 0.06395859f, -0.02914642f, 0.01791405f, 0.01026496f, -0.04856876f, -0.06836688f, 
    0.05492898f, 0.01976024f, -0.00666699f, 0.07066715f, -0.07334544f, 0.05635123f, -0.02867279f, 0.04331141f, 
    -0.01701243f, 0.06521355f, 0.00772983f, -0.05777831f, 0.04040731f, -0.04916528f, -0.00438014f, -0.05810099f, 
    -0.06579483f, -0.05459125f, -0.06559012f, -0.05537978f, 0.01389045f, -0.06715734f, -0.03185296f, -0.04472933f, 
    0.05520008f, -0.02796555f, 0.00946482f, -0.05298069f, -0.02970741f, 0.00223227f, 0.01255218f, -0.04737002f, 
    -0.14679070f, -0.36297038f, -0.17604792f, -0.23444019f, 0.01996543f, -0.01629118f, -0.05766594f, 0.16411586f, 
    -0.06163990f, -0.05671448f, 0.00822663f, 0.01509774f, -0.03873673f, -0.02088377f, -0.16668186f, -0.10591506f, 
    0.11170012f, 0.03248456f, -0.00546152f, 0.05230008f, 0.14579134f, -0.07458749f, 0.04652404f, 0.11635835f, 
    -0.29252145f, 0.18871287f, -0.10496914f, -0.09996723f, 0.07327896f, 0.01528171f, -0.16304687f, -0.07504380f, 
    -0.04202139f, 0.16288431f, 0.09306680f, 0.02584842f, 0.07224438f, -0.06168982f, 0.19908518f, 0.33946437f, 
    0.25544572f, -0.12620290f, -0.15019378f, -0.01876316f, 0.08609357f, 0.02292593f, 0.12110671f, 0.18366876f, 
    -0.15170979f, 0.05150817f, -0.19957411f, 0.07132670f, -0.13162635f, -0.05429625f, -0.07210653f, -0.07061157f, 
    0.18221205f, -0.00128063f, 0.22530214f, 0.14723459f, 0.09539204f, 0.10030587f, 0.26130474f, 0.02638750f, 
    0.01534484f, 0.07803264f, 0.04827914f, -0.00066833f, 0.20579904f, 0.05072895f, 0.10702103f, 0.24058288f, 
    -0.07864571f, -0.26006278f, 0.11047314f, -0.00222192f, 0.02411455f, -0.06544984f, -0.05775204f, 0.14366722f, 
    0.01493812f, -0.03933365f, 0.33259425f, -0.02637977f, -0.27627048f, 0.04091379f, -0.19365016f, 0.00038669f, 
    0.09180997f, 0.27114430f, 0.08705322f, 0.01072904f, 0.05985909f, -0.04475796f, 0.08295880f, -0.07066122f, 
    -0.08239474f, -0.08606597f, -0.07087556f, -0.28980461f, 0.17649843f, 0.07660103f, 0.05650868f, 0.08278060f, 
    -0.10263912f, 0.08725138f, -0.06936683f, 0.11824216f, 0.38626021f, 0.10786077f, -0.07392827f, 0.42114356f, 
    0.19944401f, 0.33762956f, 0.19461827f, 0.27207941f, -0.10384806f, 0.10253476f, -0.09554591f, -0.10877864f, 
    0.16843973f, 0.01085268f, 0.43958637f, -0.21408302f, 0.12353876f, -0.07252304f, -0.09736208f, 0.14019084f, 
    0.02885175f, 0.02917754f, -0.04584986f, 0.00447639f, 0.22920153f, 0.16483274f, -0.10456540f, -0.18599877f, 
    -0.00109232f, 0.08586263f, 0.15019527f, 0.13943070f, 0.06858771f, 0.22080424f, 0.03197515f, -0.01412444f, 
    0.31680489f, -0.28198987f, -0.06161233f, 0.01485704f, 0.02538151f, 0.00684643f, 0.05810849f, 0.01330377f, 
    -0.13239071f, -0.08169688f, -0.17760624f, -0.00235650f, -0.12027267f, -0.08077324f, -0.05010862f, -0.13902332f, 
    0.25334096f, 0.00673921f, -0.25749084f, -0.00434936f, 0.05469370f, -0.08248338f, -0.06184529f, 0.11310561f, 
    0.08457511f, -0.24997190f, 0.07855834f, 0.06113741f, -0.10867886f, 0.11092985f, 0.06756542f, -0.13850212f, 
    -0.05265715f, -0.08301394f, -0.02209265f, -0.06762510f, -0.18024588f, -0.02866620f, 0.02725749f, 0.12627554f, 
    0.03096389f, -0.00548620f, 0.11963333f, -0.12852776f, 0.03457992f, 0.21129665f, 0.10641475f, 0.12497534f, 
    -0.00268629f, 0.31390020f, 0.44474724f, -0.10255689f, -0.17415379f, 0.10147407f, -0.07777845f, -0.16176741f, 
    -0.02044971f, -0.04995554f, 0.05302453f, -0.00636936f, 0.00472939f, 0.06521781f, -0.21022458f, 0.11467279f, 
    0.11038239f, 0.11383273f, 0.10297543f, 0.05467397f, -0.14113864f, 0.01245686f, 0.03604978f, -0.04913352f, 
    0.04202459f, -0.19135521f, -0.04371459f, -0.14896010f, -0.07764097f, -0.05706896f, -0.19927143f, -0.27664706f, 
    -0.01019414f, -0.05821651f, 0.01829670f, -0.20722282f, -0.28053162f, 0.01562781f, 0.03363992f, 0.37209579f, 
    0.04977857f, -0.00187847f, 0.00189615f, -0.00627172f, 0.05742764f, 0.12322635f, -0.20504326f, 0.02572293f, 
    -0.02786765f, 0.18139212f, -0.43438643f, 0.16823010f, 0.10222135f, 0.02966536f, 0.04957443f, -0.02614910f, 
    -0.06693783f, 0.05214448f, -0.24200375f, -0.00450400f, 0.12618214f, -0.05659178f, 0.07494891f, -0.08415942f, 
    -0.02884541f, -0.02829527f, 0.05650368f, -0.10024601f, 0.01048906f, 0.08350365f, 0.24029286f, 0.20631985f, 
    0.08283684f, 0.43170527f, 0.33098236f, 0.10711221f, -0.02214156f, 0.08064622f, -0.05661802f, 0.04970055f, 
    0.07426880f, 0.13403538f, 0.05336180f, 0.23197058f, 0.01738751f, -0.15898472f, -0.27605727f, 0.10993555f, 
    0.11562953f, 0.02220504f, -0.00500403f, -0.04401748f, -0.13882926f, 0.37143552f, 0.16110864f, 0.05316084f, 
    0.20041342f, 0.12385987f, -0.18508115f, 0.02021503f, 0.14913711f, -0.06162257f, 0.12640239f, 0.10024838f, 
    -0.07142016f, 0.14747968f, 0.07197849f, -0.02405186f, 0.12224989f, 0.04367371f, 0.14683768f, -0.05481325f, 
    -0.05270774f, -0.05821594f, 0.11390248f, 0.19321783f, -0.05178603f, -0.07210216f, 0.09408340f, 0.03920239f, 
    0.12870605f, -0.23536749f, 0.12425284f, -0.47704706f, -0.20045720f, -0.15002584f, 0.05991536f, 0.13303532f, 
    0.02342710f, -0.04368101f, -0.04633876f, -0.11477385f, 0.17655055f, 0.13547283f, -0.18036586f, 0.08524358f, 
    0.08532973f, 0.16611327f, 0.20332819f, -0.16198774f, 0.18618128f, 0.10407465f, -0.11365133f, -0.07350590f, 
    -0.00563631f, -0.12613016f, -0.00032812f, 0.14370641f, 0.15629709f, -0.08822479f, 0.09039479f, 0.12794015f, 
    -0.09202632f, 0.17506719f, 0.17999391f, 0.40146732f, 0.09532563f, -0.10591181f, 0.02111341f, -0.09408851f, 
    0.05906241f, 0.07826439f, -0.06795836f, 0.13135903f, -0.14677991f, -0.12014411f, -0.05277322f, -0.15969673f, 
    -0.02894023f, 0.13657175f, -0.03065783f, 0.08700783f, -0.00861748f, 0.12213336f, 0.07363214f, 0.12749387f, 
    0.02791835f, -0.20907855f, -0.14886071f, -0.21453343f, -0.13588785f, 0.08604600f, -0.04366773f, -0.17885806f, 
    -0.00921228f, 0.03420191f, -0.00327192f, -0.09172059f, -0.03765942f, -0.08697727f, 0.29723442f, 0.27127057f, 
    0.35747162f, 0.29531094f, 0.37874436f, -0.07618552f, -0.01811069f, -0.03829560f, 0.06086811f, 0.02525616f, 
    -0.05304813f, -0.04322091f, 0.00240925f, 0.08807259f, 0.32090676f, -0.10431018f, 0.02286208f, 0.27601439f, 
    -0.18070212f, 0.04903951f, -0.02281804f, 0.01452487f, 0.00002768f, 0.16633476f, -0.07037704f, 0.03324373f, 
    0.19228242f, -0.00639136f, 0.15401877f, 0.00532404f, -0.03175511f, -0.11380621f, -0.01818681f, 0.14056076f, 
    -0.08543392f, -0.18879849f, -0.02901808f, -0.11083978f, 0.07168195f, -0.38387448f, -0.39952135f, 0.00740742f, 
    0.09050693f, 0.03006039f, -0.10242005f, -0.00954264f, -0.18988743f, -0.00053391f, -0.04261464f, 0.04116888f, 
    0.03145455f, 0.02992069f, -0.31907547f, -0.35164049f, 0.20416188f, 0.07150791f, -0.21287952f, -0.01814769f, 
    -0.02543165f, -0.11546651f, -0.32844487f, -0.18409443f, 0.10206508f, 0.02591102f, 0.10057172f, 0.14589199f, 
    0.11110259f, -0.12933969f, -0.11235297f, -0.04105477f, 0.12440906f, 0.16148601f, 0.15024072f, 0.04234460f, 
    0.29497954f, 0.17613143f, 0.14861010f, 0.10708369f, -0.12619059f, 0.03964047f, 0.18213145f, 0.02054271f, 
    0.03241089f, 0.15547091f, -0.09413760f, 0.04322674f, 0.17918606f, 0.18430072f, -0.08960959f, -0.01005890f, 
    -0.07227653f, -0.04058020f, -0.08127584f, 0.03387060f, -0.00976463f, 0.22702131f, 0.05887409f, 0.22501829f, 
    0.35828605f, -0.05478233f, -0.24003270f, 0.14457436f, -0.10108905f, -0.25551069f, 0.05095845f, -0.29108024f, 
    -0.03151437f, 0.04504064f, -0.00250463f, 0.08224637f, 0.40807638f, 0.27589554f, 0.21881978f, 0.01363471f, 
    -0.12964568f, -0.07687385f, -0.03559668f, 0.16645594f, 0.00980974f, -0.02739359f, 0.08612420f, 0.20019577f, 
    0.17943752f, 0.38754383f, 0.05153788f, -0.00569976f, -0.10101743f, 0.01306190f, 0.06816844f, -0.06480425f, 
    -0.07647642f, -0.08143302f, -0.09656467f, -0.24983977f, -0.10577548f, 0.12561356f, -0.05834353f, -0.02058446f, 
    0.05981696f, 0.26763499f, -0.13563173f, -0.30421457f, 0.10396581f, -0.03820426f, 0.07226653f, -0.06679590f, 
    -0.09404805f, -0.11854213f, 0.13660847f, -0.00345346f, 0.26140502f, -0.08579933f, -0.23097035f, 0.22728665f, 
    0.09846555f, 0.06881090f, 0.29194650f, 0.05348903f, -0.02739171f, -0.06293845f, -0.08885499f, 0.00501011f, 
    0.06673195f, 0.11169039f, -0.13962638f, -0.12707818f, -0.07101209f, 0.08540669f, -0.18317066f, -0.31959876f, 
    -0.15886407f, 0.07152301f, 0.20132260f, 0.16227637f, 0.35045516f, -0.04324598f, -0.11373768f, 0.10491958f, 
    -0.04308978f, -0.14611475f, -0.25581396f, -0.15723328f, -0.04691206f, -0.07465779f, 0.25462660f, 0.26510403f, 
    -0.04040964f, 0.13392252f, -0.01309554f, 0.08976286f, 0.27451670f, 0.02925899f, 0.07311185f, 0.20278607f, 
    0.35156447f, -0.28797618f, -0.09409764f, -0.16574976f, 0.09078269f, 0.00968737f, 0.06771395f, 0.07206987f, 
    0.21287151f, -0.09600324f, 0.15085576f, 0.07599428f, 0.12794065f, -0.25502342f, 0.18084256f, 0.06972636f, 
    0.17221905f, 0.10683892f, -0.00771086f, -0.08638249f, 0.06239967f, 0.05286519f, 0.19378598f, 0.12688763f, 
    0.00011483f, 0.25582695f, -0.05488717f, -0.05216004f, 0.17070381f, -0.04543654f, -0.01253904f, 0.22182481f, 
    -0.11600947f, -0.08401569f, -0.07500564f, -0.21575417f, 0.35427853f, 0.15059611f, 0.14648007f, 0.21365274f, 
    0.20499840f, -0.05388873f, -0.06144648f, 0.06313977f, 0.03795018f, -0.01005406f, -0.06492491f, -0.06152230f, 
    0.04481318f, -0.08564050f, 0.18505195f, -0.52957171f, -0.09631865f, -0.07894254f, -0.31248805f, -0.18462695f, 
    0.14683859f, -0.02512316f, -0.13147487f, -0.09106287f, 0.26163778f, 0.27515852f, 0.15774605f, 0.02479754f, 
    0.09947169f, 0.08464970f, 0.19552740f, -0.04006963f, -0.00474479f, 0.15132916f, -0.05400011f, 0.05771240f, 
    0.25653875f, -0.30499661f, 0.25522220f, 0.01224541f, 0.12920018f, -0.15582427f, 0.00917778f, -0.14120901f, 
    -0.12799573f, 0.13628691f, 0.09365825f, -0.01389798f, -0.20040029f, 0.25549656f, 0.06263635f, 0.08333427f, 
    -0.04815532f, -0.00191628f, 0.01752448f, -0.03269003f, 0.18110563f, 0.07747018f, 0.10032358f, -0.00453135f, 
    0.11446856f, -0.11603379f, -0.09489574f, -0.14174047f, -0.04249786f, -0.05049495f, -0.02487789f, -0.36849922f, 
    -0.14205062f, 0.11489180f, -0.15295726f, -0.01873109f, -0.04042500f, 0.32040116f, -0.00307834f, 0.30020103f, 
    -0.06103776f, 0.17694671f, 0.14619681f, 0.22032325f, -0.02308711f, 0.09787616f, -0.08386390f, -0.01805806f, 
    0.21452042f, 0.36039409f, -0.10308325f, 0.03301380f, 0.04946354f, -0.07597869f, 0.14695260f, 0.05663070f, 
    -0.02487224f, 0.01289807f, -0.01119402f, -0.23893070f, -0.01096854f, 0.18032244f, -0.09881292f, -0.18259035f, 
    0.11666931f, -0.14437591f, 0.03527837f, -0.14335789f, 0.09754565f, -0.04752788f, -0.30794361f, -0.09636694f, 
    -0.01879416f, -0.07650399f, 0.00242525f, -0.01082553f, 0.09055424f, -0.06296674f, 0.03095711f, 0.13676885f, 
    -0.00720695f, -0.03555850f, -0.01271084f, 0.10463038f, -0.36317167f, 0.03571412f, -0.28219292f, -0.07282986f, 
    0.19508822f, -0.13622190f, -0.35642231f, -0.32896394f, -0.14347999f, -0.18351352f, -0.19600232f, -0.18408982f, 
    -0.02561510f, -0.26727945f, 0.27093181f, 0.16027726f, -0.07603093f, 0.14259616f, -0.21064992f, -0.15576871f, 
    0.04893189f, -0.09071538f, -0.10349047f, -0.28755096f, -0.12676562f, 0.00191094f, 0.18798491f, 0.28414220f, 
    -0.10990295f, 0.19392522f, 0.19713761f, 0.06667183f, 0.02723208f, 0.09610110f, 0.02676970f, 0.27094823f, 
    -0.00340423f, -0.03506589f, 0.21597469f, 0.27049369f, 0.05779345f, -0.06746300f, 0.06427334f, -0.06521045f, 
    -0.11328049f, -0.14753520f, 0.09891068f, 0.06393403f, -0.15887332f, -0.08079407f, -0.07490682f, -0.17175998f, 
    -0.15491992f, -0.10346299f, -0.05499911f, 0.05288824f, -0.01194522f, 0.02445005f, -0.08151011f, 0.16637114f, 
    -0.25407067f, -0.07666191f, 0.06974050f, 0.04251084f, 0.02900963f, 0.00810477f, -0.05219770f, -0.05240899f, 
    0.10961476f, 0.04197375f, 0.21604429f, 0.14803110f, 0.50641757f, -0.09964094f, -0.36968988f, -0.10890765f, 
    0.00537510f, 0.04384553f, -0.13752046f, 0.02163725f, 0.16918002f, 0.13588522f, -0.03399150f, 0.11317468f, 
    0.42800453f, 0.14704719f, -0.27335730f, 0.03319759f, 0.11938067f, 0.14087096f, -0.00068678f, -0.15853536f, 
    0.08523866f, -0.02333296f, 0.04417049f, 0.03539952f, -0.14106058f, -0.33751246f, -0.22335458f, 0.06819382f, 
    -0.06355283f, -0.04161628f, 0.02221098f, -0.14743391f, 0.10428072f, 0.05983323f, 0.14052083f, 0.03713399f, 
    -0.19021760f, 0.36789450f, 0.25124776f, 0.43876374f, -0.12708795f, 0.00786340f, 0.19327702f, 0.00673883f, 
    0.13423477f, 0.14863688f, 0.06040029f, -0.07787745f, -0.07626244f, 0.05662224f, 0.38097367f, -0.02993441f, 
    0.12807682f, -0.05755865f, 0.07492625f, 0.00430369f, -0.00690032f, 0.40821066f, 0.18741399f, 0.32089949f, 
    0.11331366f, 0.02477600f, -0.08977722f, 0.13143054f, -0.00943684f, -0.38707602f, 0.16697390f, 0.08997597f, 
    -0.16094984f, -0.07228789f, -0.03195871f, 0.15840816f, -0.01013562f, -0.03434654f, 0.33916914f, 0.14148065f, 
    -0.02485877f, -0.05760276f, 0.20305112f, 0.15609848f, -0.04639368f, -0.13126449f, -0.08245831f, 0.00708705f, 
    -0.38606676f, 0.14132555f, -0.10030992f, 0.15873064f, 0.03627908f, -0.10771587f, 0.20795868f, -0.12104035f, 
    0.07030003f, -0.11950304f, -0.03073921f, -0.19993398f, 0.31764156f, -0.33372432f, 0.08058807f, 0.28543678f, 
    0.10254610f, 0.15622853f, -0.02174512f, -0.06090596f, 0.12188293f, 0.03107788f, -0.06225750f, 0.03610884f, 
    -0.36873192f, -0.05047053f, -0.13476469f, -0.08271402f, 0.10786103f, 0.27248251f, -0.03037599f, 0.22880439f, 
    0.14779803f, 0.18268068f, 0.20341156f, 0.19508180f, 0.07139061f, 0.06923787f, -0.18874893f, -0.01359159f, 
    0.12267008f, -0.05061002f, -0.19249766f, -0.01421149f, -0.05067397f, 0.17979465f, -0.14908782f, -0.32554007f, 
    0.44228294f, 0.06015456f, -0.02941952f, -0.06463746f, 0.23979886f, -0.21537845f, -0.02677116f, -0.08361043f, 
    -0.21729025f, 0.01709817f, -0.09528038f, 0.00291357f, 0.04985281f, 0.21461411f, 0.12069417f, -0.17188458f, 
    -0.22371146f, -0.11435933f, -0.12772721f, -0.03843623f, 0.28095481f, 0.29966506f, 0.17991845f, 0.10116381f, 
    -0.03303501f, 0.02184098f, -0.07390075f, -0.02748790f, -0.02525797f, -0.02288102f, 0.02854388f, -0.05191059f, 
    -0.01587336f, 0.01958278f, -0.00712001f, 0.02308349f, 0.01764703f, -0.00256597f, -0.05222700f, 0.01104330f, 
    -0.06457157f, -0.03774082f, 0.02693156f, -0.09445234f, -0.02245509f, -0.05754233f, -0.01211408f, -0.07037412f, 
    0.03476822f, -0.01510548f, -0.06269400f, 0.06051695f, -0.07735921f, -0.01553223f, -0.00946785f, -0.00569213f, 
    0.02311819f, -0.06339373f, -0.07803002f, 0.03606026f, -0.01557294f, -0.07699475f, 0.00054014f, -0.06248458f, 
    -0.09104592f, -0.10774750f, -0.10261891f, 0.02019526f, -0.06186165f, 0.02492449f, -0.02223429f, -0.00035306f, 
    -0.02021901f, -0.01132126f, -0.04706544f, -0.09856267f, -0.06664731f, -0.02243530f, -0.05629398f, -0.04374540f, 
    -0.10104606f, 0.03326601f, -0.07694869f, -0.07449891f, -0.03526195f, -0.00637270f, 0.01759054f, 0.02215054f, 
    -0.03195283f, 0.02907300f, 0.00744657f, 0.02441568f, -0.07764273f, 0.00304069f, 0.00779538f, -0.08925979f, 
    -0.10562287f, 0.01110532f, 0.03172325f, -0.09251001f, -0.10361255f, -0.03759492f, -0.05285289f, -0.01098216f, 
    -0.00246185f, -0.04163843f, 0.03055106f, 0.02040476f, -0.06442913f, -0.09965639f, 0.03001178f, -0.03058084f, 
    -0.02514171f, -0.02378897f, 0.03943634f, -0.08530462f, -0.05036402f, -0.09237856f, -0.00393814f, -0.06492110f, 
    -0.03998910f, -0.07460599f, 0.02437763f, -0.06768824f, -0.02615981f, -0.03640572f, 0.03250513f, 0.02319547f, 
    -0.06617805f, 0.00246344f, -0.07514703f, 0.01840965f, -0.02021179f, 0.01401291f, -0.04236008f, 0.03721698f, 
    -0.01188416f, -0.07485697f, -0.09979679f, -0.09396704f, -0.00008059f, -0.10838664f, 0.01237761f, -0.06625535f, 
    0.05483481f, -0.03042437f, -0.06128980f, 0.02123213f, -0.05114926f, 0.04584897f, 0.01385636f, -0.03490815f, 
    -0.04811594f, -0.01789470f, -0.03796397f, -0.10666835f, 0.00945784f, 0.02836423f, -0.02735429f, 0.01605403f, 
    -0.02651268f, -0.07734711f, -0.06645311f, 0.02694121f, 0.01123953f, 0.02337250f, -0.01091063f, -0.04153905f, 
    -0.05575207f, -0.02403004f, -0.08448517f, -0.04634825f, -0.06561337f, -0.07240812f, -0.01549280f, -0.00234316f, 
    -0.06930280f, 0.03356649f, 0.05058707f, -0.06163047f, -0.09133616f, -0.09147665f, -0.09563036f, -0.10180905f, 
    -0.09442479f, -0.06874005f, -0.00527668f, -0.08736476f, 0.02265743f, -0.00198566f, -0.01921008f, -0.06278739f, 
    -0.07902382f, -0.01485584f, -0.04044227f, 0.06305911f, 0.03175411f, -0.08180843f, 0.02431206f, 0.02320934f, 
    -0.03436304f, -0.00526340f, 0.00854527f, 0.02299069f, -0.01924129f, -0.06371929f, -0.01590218f, -0.01509236f, 
    -0.00962602f, -0.09026728f, -0.07746175f, -0.01998068f, -0.10485723f, -0.07614373f, 0.00144512f, 0.00940980f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00748333f, -0.07881700f, -0.04826758f, 0.15236777f, 0.04484208f, -0.04312104f, 0.15702936f, -0.01193006f, 
    0.19813560f, 0.29224882f, -0.03589591f, -0.06801885f, 0.10556073f, 0.04518747f, 0.15589462f, 0.23388655f, 
    0.13024944f, 0.13267241f, -0.00663626f, 0.09952815f, -0.02709377f, -0.01169146f, -0.07238624f, 0.08700214f, 
    0.08786295f, 0.07034365f, -0.06871017f, 0.19872765f, -0.02809040f, 0.06001226f, -0.06096277f, -0.00322698f, 
    0.08230814f, -0.12736927f, 0.05054841f, 0.17708941f, -0.01294615f, 0.08340606f, 0.03013089f, -0.02764544f, 
    0.08592676f, -0.01805532f, 0.07033293f, 0.18434680f, 0.04062853f, 0.10016906f, 0.04294556f, 0.00697589f, 
    0.02979826f, -0.15432534f, 0.03492296f, 0.02228474f, 0.09331428f, 0.24751018f, 0.04239463f, -0.06471796f, 
    0.04170615f, -0.03277301f, 0.05641379f, -0.06307440f, -0.04989844f, -0.10937198f, 0.07245290f, -0.03674696f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.10752574f, -0.10131899f, -0.02317873f, -0.49496976f, 0.25398540f, 0.09281304f, -0.33267745f, -0.11200815f, 
    -0.45950460f, -0.15326013f, -0.03119862f, 0.16639337f, 0.31467107f, 0.02969003f, -0.18432409f, -0.30017051f, 
    -0.37238154f, -0.14194137f, -0.08856282f, -0.02782318f, -0.03490262f, -0.12430209f, -0.04030013f, -0.45387909f, 
    0.19324541f, -0.00548774f, 0.08896313f, -0.33979759f, 0.08162461f, 0.17107542f, 0.14646743f, 0.11893263f, 
    -0.11397699f, 0.21912642f, -0.07186680f, -0.03236473f, -0.01972184f, -0.04263273f, -0.07498088f, 0.19267772f, 
    0.28826362f, 0.24068868f, 0.02558088f, -0.39904219f, -0.03674349f, 0.04261164f, 0.10672765f, -0.10120621f, 
    0.52798164f, 0.19355813f, -0.04763360f, 0.19482116f, -0.21296981f, -0.41954246f, 0.07141554f, 0.11185108f, 
    -0.06820209f, 0.08503334f, -0.04489869f, 0.13278612f, 0.05237831f, 0.31178460f, -0.37955761f, -0.02442483f, 
    0.02849806f, -0.11044422f, 0.07639980f, -0.03068446f, 0.13547826f, -0.11104635f, -0.14135122f, -0.09862186f, 
    -0.06897343f, 0.01728086f, -0.10140651f, 0.01089903f, -0.08309007f, 0.10109483f, 0.03929739f, 0.36186627f, 
    0.06907514f, 0.10445869f, -0.01235658f, 0.25568491f, 0.05154162f, -0.02311451f, 0.01048500f, -0.01646792f, 
    0.06878138f, 0.02956176f, -0.05758793f, 0.03309109f, -0.12524024f, 0.31041449f, -0.04485719f, 0.07199482f, 
    0.44277990f, -0.73128086f, 0.05301019f, -0.11699019f, 0.07447629f, 0.25485674f, 0.10048600f, 0.13721113f, 
    -0.17944875f, -0.97191560f, -0.05018244f, 0.20424144f, 0.25453699f, 0.24183948f, -0.70338231f, -0.08787581f, 
    0.47402072f, -0.10488815f, -0.09700893f, 0.38831419f, 0.23527838f, -0.13493010f, -0.03001958f, -0.02153500f, 
    -0.09344139f, 0.07782374f, -0.52539164f, -0.05785758f, 0.18751927f, -0.37974408f, -0.20464036f, -0.05451354f, 
    0.05296298f, -0.06880313f, -0.11790147f, -0.00456960f, 0.10691116f, -0.04415672f, 0.07056344f, -0.08009653f, 
    0.09061509f, 0.11620939f, 0.04770422f, 0.09939160f, 0.25552672f, 0.07085401f, 0.35834256f, -0.58288151f, 
    0.05380869f, -0.27925771f, 0.11842638f, 0.22435533f, 0.08817224f, 0.05318841f, 0.09518885f, 0.17252067f, 
    -0.25123620f, -0.04945574f, -0.09226173f, 0.04910133f, 0.05810756f, 0.09605788f, 0.09356054f, -0.07987015f, 
    0.44373706f, -0.80464417f, 0.06220951f, -0.33025923f, -0.02636765f, 0.10928930f, 0.11126565f, -0.93505865f, 
    -0.28609490f, -0.48169535f, -0.04056011f, 0.09167238f, -0.25183019f, -0.21192798f, 0.25323847f, -0.34558147f, 
    -0.54885131f, -0.20173897f, 0.08923639f, -0.27666697f, -0.62118161f, 0.14259650f, -0.04615363f, -0.22315061f, 
    -0.12807591f, -0.04277083f, -0.49456790f, 0.20684054f, 0.33888569f, -0.15908101f, 0.32989585f, -0.02453253f, 
    0.06100866f, 0.00808265f, 0.04061492f, 0.13642985f, -0.00499576f, -0.13018480f, -0.13677903f, 0.00171309f, 
    -0.22135513f, -0.32471436f, 0.11442627f, -0.35285169f, -0.07750062f, 0.04216878f, 0.22044735f, -0.34473580f, 
    -0.15871766f, -0.27187753f, -0.04857075f, 0.08232984f, 0.04654858f, 0.10618135f, 0.08133370f, 0.28838146f, 
    -0.44479895f, -0.05232101f, -0.11666043f, -0.87888032f, -0.03238773f, 0.10834723f, 0.17704904f, 0.09542564f, 
    -0.04390191f, 0.18498507f, 0.19791627f, -0.32156041f, -0.06259242f, 0.24674982f, 0.38489726f, 0.19919948f, 
    -0.23476581f, 0.02418096f, 0.27023804f, 0.10992558f, -0.20166844f, -0.17174621f, -0.02940134f, 0.23900302f, 
    -0.35641733f, 0.22773181f, 0.00117279f, -0.24931820f, -0.35094830f, -0.00880606f, 0.18869281f, -0.11302897f, 
    0.05783436f, -0.01012470f, -0.09471609f, -0.23925656f, 0.08554490f, 0.09480828f, 0.20814414f, -0.04068601f, 
    -0.06051470f, -0.05870695f, -0.01353012f, -0.40902597f, -0.36018708f, -0.11077029f, 0.19145489f, -0.10582563f, 
    0.09383191f, 0.04387212f, -0.06040693f, 0.02245290f, 0.05929238f, 0.11379670f, 0.01265823f, -0.66630435f, 
    -0.11525039f, 0.23488173f, -0.03615014f, -0.72154152f, -0.07016703f, 0.01268220f, -0.08944310f, -0.13648330f, 
    -0.12717749f, -0.10045288f, -0.06938339f, 0.14210212f, -0.08068947f, -0.12961867f, -0.09103015f, -0.11456787f, 
    0.30442849f, 0.31085598f, 0.05596274f, -0.22161254f, -0.10796425f, -0.25099489f, -0.43740952f, -0.16438022f, 
    0.00565660f, 0.21986838f, -0.08953737f, -0.17251405f, -0.03934436f, 0.06693989f, 0.27258107f, 0.12150753f, 
    -0.33503836f, 0.08774292f, -0.05998044f, 0.07401562f, 0.24345903f, -0.12982516f, 0.13062200f, -0.04304041f, 
    -0.08158638f, 0.05779354f, 0.16746376f, 0.08054816f, 0.13392997f, -0.03324629f, 0.02669257f, 0.04252987f, 
    0.10955794f, 0.05390172f, 0.02673707f, 0.17223549f, -0.34596190f, 0.10066032f, -0.13127252f, -0.14077610f, 
    0.07031408f, 0.22289601f, -0.12938763f, 0.08555290f, 0.13986976f, -0.11958032f, 0.04510937f, -0.07975610f, 
    -0.19293049f, 0.15004677f, 0.07790218f, 0.01836765f, 0.11628415f, -0.02375603f, 0.06765655f, -0.63230079f, 
    0.07759104f, -0.02238872f, 0.09458135f, 0.40474889f, 0.09723420f, -0.21768695f, 0.24944898f, -0.02041973f, 
    -0.26373574f, -0.76265949f, -0.08066471f, 0.46890166f, 0.10938422f, 0.06844072f, -0.49929002f, 0.07031899f, 
    0.31262472f, 0.14863704f, 0.05383550f, -0.31313413f, 0.35775706f, -0.07917676f, -0.27909812f, -0.14076820f, 
    -0.17148875f, 0.01704045f, -0.01173561f, 0.13858773f, 0.04453300f, 0.06577518f, 0.15960747f, -0.15591593f, 
    -0.06800739f, 0.10554286f, 0.31669053f, -0.25168243f, -0.14913155f, 0.06545000f, -0.40792766f, -0.03771726f, 
    -0.01786455f, -0.12727749f, 0.12047106f, -0.01208969f, 0.10987427f, 0.09560156f, -0.00160679f, 0.07866961f, 
    0.22510205f, 0.16037601f, -0.09375369f, -0.08290531f, -1.09758663f, 0.14320049f, 0.15026833f, -0.10212131f, 
    0.14106755f, -0.26672357f, 0.06556495f, 0.03534008f, -0.02410911f, 0.06009628f, -0.01510383f, 0.20571814f, 
    -0.11028146f, -0.02712178f, -0.02391827f, 0.41739175f, 0.11541488f, -0.03505059f, -0.00963129f, 0.00805453f, 
    -0.49024341f, 0.08936525f, 0.21499112f, 0.57558441f, 0.08139069f, -0.85371464f, 0.28953603f, -0.51245797f, 
    -0.57296377f, 0.01411702f, -0.25509331f, 0.24833708f, -0.62928426f, -0.21237364f, 0.38591120f, -0.32493737f, 
    -0.58538717f, -0.55114776f, 0.06911910f, -0.31459081f, 0.07299157f, 0.07752229f, -0.68661922f, -0.82607037f, 
    -0.10395689f, -0.06747572f, 0.06202509f, 0.11994354f, -0.50637770f, -0.58388180f, 0.23675431f, -0.01324452f, 
    -0.05829643f, -0.12449978f, -0.05243194f, 0.21928082f, -0.19749807f, -0.01377050f, -0.03241175f, -0.10237449f, 
    0.11399081f, -0.27895287f, -0.04819266f, 0.17430970f, -0.28840429f, -0.53942603f, -0.24452534f, -0.37777174f, 
    0.10406273f, -0.15218566f, 0.04228015f, 0.01691880f, 0.10898506f, -0.07445190f, -0.04155790f, 0.16029142f, 
    -0.22289926f, -0.10332412f, -0.01133467f, 0.46044093f, -0.07589210f, -0.23118658f, 0.16897799f, 0.00298046f, 
    -0.59146971f, 0.44479591f, -0.39082715f, -0.43910828f, 0.04222909f, -0.41514671f, -0.00801823f, -0.56220734f, 
    -0.21319434f, 0.34307206f, -0.20682180f, -0.36840722f, 0.25165910f, 0.05016780f, 0.18616854f, -0.35953704f, 
    -0.25825277f, 0.05263931f, -0.06076861f, -0.48215419f, 0.04875084f, 0.13247578f, -0.47836950f, 0.13468139f, 
    -0.12237965f, 0.02001190f, -0.09817258f, -0.23252955f, 0.19274777f, 0.46740901f, 0.13489805f, -0.03806914f, 
    0.06168373f, 0.02352004f, 0.03905394f, 0.10974117f, 0.15909532f, -0.11681128f, -0.06338091f, -0.05045224f, 
    -0.14362009f, 0.09860373f, 0.11580610f, 0.03524391f, -0.74963385f, 0.22072701f, -0.45766261f, -0.27060026f, 
    -0.06556107f, -0.82884961f, 0.04052003f, 0.26556978f, -0.04928720f, 0.08039545f, -0.10635611f, -0.25060993f, 
    0.33852950f, 0.08136315f, -0.12122376f, -0.46148574f, -0.02296587f, -0.52161396f, -0.11261706f, -0.12579714f, 
    -0.68530881f, -0.19361030f, -0.57563931f, -0.02268695f, 0.09212314f, -0.42861760f, 0.33459315f, -0.13305297f, 
    0.22375429f, -0.65288371f, 0.35232106f, 0.12892388f, 0.37471703f, -0.16738299f, -0.01780340f, 0.16339739f, 
    -0.23268832f, 0.23614812f, 0.05053155f, 0.00248167f, -0.23167141f, 0.25467706f, -0.43804434f, 0.25207299f, 
    0.01417754f, 0.00128457f, 0.03226206f, -0.32489282f, -0.80001074f, -0.58528316f, 0.28796288f, -0.04254292f, 
    0.01268101f, 0.09889410f, -0.04516416f, -0.39447486f, 0.20739344f, -0.01844746f, 0.26963371f, 0.01522047f, 
    0.15251799f, 0.13454790f, 0.05309552f, -0.39491186f, -0.16307077f, 0.07070984f, 0.00510903f, 0.05945143f, 
    -0.04587713f, 0.11769635f, 0.09225184f, -0.44769609f, -0.01559715f, 0.03520045f, -0.07410753f, 0.35804513f, 
    0.19955559f, -0.05946783f, 0.01588937f, -0.20041470f, 0.01760218f, -0.77726495f, 0.07284148f, 0.00335803f, 
    -0.17863609f, -0.08322888f, 0.16053699f, -0.17794719f, -0.03479873f, 0.02742047f, -0.16593805f, -0.78408444f, 
    0.50151706f, 0.37239832f, -0.72280347f, -0.01740764f, 0.15633066f, 0.07707419f, -0.17502148f, 0.15764165f, 
    0.48959312f, -0.84217709f, 0.02338359f, -0.24287786f, -0.08750874f, 0.12585647f, 0.04615901f, -0.24186026f, 
    0.03486197f, 0.07355499f, 0.25534242f, 0.08187125f, 0.12923114f, 0.59426397f, 0.09930208f, 0.02128020f, 
    0.04039465f, -0.06221642f, 0.05808162f, 0.05414445f, 0.34870225f, -0.11858739f, 0.25907585f, -0.05133845f, 
    0.11886014f, 0.22708549f, 0.05623357f, 0.09072014f, -0.42613870f, 0.21817453f, 0.03377798f, -0.31544679f, 
    -0.20851602f, -0.37819681f, -0.07216795f, -0.28859395f, -0.01315671f, 0.01931564f, -0.10476010f, 0.32967830f, 
    0.47702008f, -0.01608987f, -0.09574490f, 0.32673848f, 0.04884301f, 0.35723513f, -0.11901826f, -0.09018950f, 
    0.12695011f, -0.21546797f, 0.07809841f, -0.00266139f, -0.01327212f, 0.30055404f, -0.20822805f, 0.20793159f, 
    -0.08698349f, -0.22840767f, 0.19554159f, 0.33835566f, -0.55940217f, -0.53535718f, 0.01908117f, 0.36973578f, 
    -0.25840059f, -0.25661188f, 0.11713260f, -0.31077918f, -0.28008404f, -0.05240600f, -0.47813410f, 0.33348826f, 
    0.11393316f, 0.10449078f, -0.17284100f, -0.51551145f, -1.03301847f, -0.47456419f, -0.48639357f, 0.00323360f, 
    0.12336483f, -0.03578580f, -0.00627543f, 0.10421902f, -0.44904274f, -0.04886382f, 0.20133288f, -0.05606398f, 
    0.01303529f, 0.23396026f, -0.03842641f, -0.44720533f, -0.32857907f, -0.24289557f, -0.78668177f, 0.41137373f, 
    0.30242237f, 0.48148248f, -0.08191793f, 0.19658877f, -0.09514932f, 0.09800615f, -0.06119457f, -0.55406398f, 
    -0.05858942f, 0.09759573f, 0.03963481f, -0.25865540f, -0.11027163f, 0.53972101f, -0.37657410f, 0.10033352f, 
    -0.05180605f, 0.22765778f, -0.12927172f, -0.05682041f, -0.07022138f, -0.29527417f, -0.04968663f, -0.04787448f, 
    -0.64800727f, -0.00027176f, 0.07573256f, 0.22592553f, -0.19633152f, -0.26880082f, -0.35731810f, 0.09529528f, 
    -0.35122582f, 0.12477484f, -0.05681886f, -0.38781425f, -0.29263413f, -0.00788733f, -0.17029701f, -0.07524909f, 
    0.09563937f, -0.06071746f, 0.23659177f, 0.33976531f, 0.30895171f, -0.16494866f, 0.03744089f, 0.00332641f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.11094329f, -0.00729293f, 0.03572626f, -0.13775221f, -0.01589414f, 0.10428505f, 0.06782223f, -0.20130128f, 
    0.00282171f, 0.04493317f, 0.15174660f, 0.11822502f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
