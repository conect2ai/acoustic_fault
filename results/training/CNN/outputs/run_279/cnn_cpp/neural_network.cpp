#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.34861523f, -0.25811616f, 0.59837353f, 0.22614387f, 0.71253622f, -0.25405666f, -0.14423315f, -0.43077844f, 
    -0.48750678f, -0.14839742f, 0.62799656f, 0.35426581f, -0.02162837f, 0.20521978f, 0.21496971f, -0.47318891f, 
    0.07733381f, 0.06300956f, 0.16077703f, 0.09345551f, -0.19532712f, 0.11436474f, 0.17626959f, -0.16582561f, 
    0.04583009f, 0.45042166f, -1.00247824f, 0.04926442f, 0.80407655f, 0.54107726f, -0.94567758f, 0.17081460f, 
    0.11148164f, -0.10418919f, 0.39427570f, 0.23883502f, 0.18990040f, -0.20371522f, -0.27273434f, -0.05995503f, 
    -0.01480140f, 0.35537317f, 0.11604716f, 0.14248008f, 0.12291694f, -0.00020128f, -0.04197749f, -0.13979189f, 
    0.08306272f, -0.16994303f, 0.05367983f, -0.84929681f, -0.52000672f, -0.56665945f, 0.43995553f, -0.27652174f, 
    0.81416947f, 0.66471338f, 0.27495170f, 0.42702404f, 0.17786749f, -0.08276249f, -0.26799566f, -0.04978792f, 
    0.00535127f, -0.08591780f, -0.37445071f, -0.16919184f, -0.23283671f, -0.18463147f, -0.03130386f, 0.03169274f, 
    0.31076968f, -0.14590077f, 0.17465396f, 0.35027069f, -0.42044041f, -0.16363983f, 0.79364526f, 0.73524547f, 
    0.80693185f, 0.45772615f, 0.09078709f, 0.38108921f, 0.34421268f, -0.44029471f, 0.15693849f, -0.29842618f, 
    0.30080381f, 0.13559191f, -0.05582784f, -0.16421475f, -0.11258882f, -0.01463404f, 0.04176215f, 0.00985114f, 
    -0.13096660f, -0.10036854f, -0.12993911f, -0.09532975f, -0.46211758f, -0.49684602f, -0.40641907f, 0.11432230f, 
    -0.45232931f, -0.31974763f, -0.15125924f, 0.17568029f, -0.37727335f, -0.23219953f, 0.07741644f, 0.39470294f, 
    0.25187823f, -0.03230755f, -0.21468745f, -0.68883055f, -0.00028704f, 0.15020609f, -0.20401067f, -0.30155829f, 
    0.31645960f, -0.04120598f, 0.18046975f, 0.16779737f, 0.27459028f, 0.48228830f, 0.64762825f, 0.42917556f, 
    -0.08849777f, 0.43433136f, 0.05524162f, 0.22859496f, 0.02699739f, 0.24317692f, 0.55448544f, -0.01594018f, 
    0.17829441f, -0.22670746f, -0.35931510f, -0.11221963f, 0.29037821f, -0.22777453f, -0.33128449f, -0.03492075f, 
    -0.04668191f, -0.11294389f, -0.06546146f, 0.24982817f, -0.20041452f, 0.15367809f, -0.01547190f, -0.39231333f, 
    0.52463186f, 0.41469210f, 0.10074091f, -0.40771174f, 0.58841252f, -0.08597070f, 0.43008313f, 0.01058250f, 
    0.00680374f, -0.23818336f, -0.19064020f, -0.07891999f, -0.51074386f, -0.50225073f, -0.48365891f, -0.41802248f, 
    -0.01858702f, -0.38904467f, 0.01781916f, -0.02175520f, -0.10119741f, -0.21377082f, 0.01014499f, -0.66070676f, 
    -0.00719461f, -0.32173884f, -0.69342494f, 0.20391719f, -0.13330114f, -0.22133356f, 0.04059497f, 0.42684835f, 
    -0.37883011f, 0.00751578f, 0.19163953f, -0.07974773f, -0.00673108f, -0.06322671f, 0.53598511f, -0.06571317f, 
    -0.29010358f, 0.08984929f, 0.10964034f, -0.25296563f, -0.14457920f, 0.17200500f, -0.11018306f, -0.28041059f, 
    0.46148419f, 0.86364877f, 0.56898665f, -0.75812417f, -0.07603736f, -0.76331198f, 0.25895631f, -0.24517226f, 
    -0.39008740f, -0.33315772f, 0.19920284f, 0.17911726f, 0.04801726f, -0.07854886f, 0.09524091f, -0.11760344f, 
    0.07540093f, 0.08256362f, 0.03517677f, -0.15166636f, -0.29113317f, -0.05858242f, -0.02448459f, 0.00577622f, 
    0.21522009f, 0.83971137f, 0.42586979f, -0.32506594f, 0.70723987f, -0.50317776f, -0.24714182f, 0.19803934f, 
    0.22531381f, 0.18775991f, 0.25059050f, 0.09795786f, -0.09100321f, -0.04011528f, 0.29973257f, -0.23787020f, 
    0.32101780f, -0.05248597f, -0.10621904f, -0.33303347f, 0.20133717f, -0.10218134f, -0.07583891f, 0.08022798f, 
    0.04323651f, -0.20777480f, 0.77640504f, 0.50206429f, 0.10461777f, -0.25420320f, -0.56398708f, 0.64838147f, 
    0.36989233f, -0.51391536f, -0.41675478f, -0.23382473f, 0.21133107f, 0.39191663f, -0.28001392f, 0.25251123f, 
    0.26737881f, 0.26329675f, -0.21264185f, -0.07232571f, 0.15206000f, -0.02241014f, -0.19231504f, 0.35322013f, 
    0.04791557f, -0.06073182f, 0.25398326f, -1.12930036f, 0.03933952f, 0.49293905f, 0.05105086f, -0.19571784f, 
    0.59960246f, 0.87867302f, -0.00621481f, 0.08792428f, 0.26489100f, 0.19286373f, -0.18522225f, 0.16440512f, 
    -0.27462354f, -0.07911454f, 0.09935911f, -0.17825495f, -0.12213780f, -0.09490654f, -0.15243988f, -0.07479504f, 
    0.04967738f, 0.01348114f, 0.04247262f, -0.06608313f, -0.34394786f, -0.11961745f, -0.38789165f, -0.54864079f, 
    -0.17259291f, 0.02891435f, -0.50058633f, -0.31927544f, 0.33602566f, -0.48056573f, -0.37392733f, -0.33532447f, 
    0.21025454f, -0.01464764f, -0.01150031f, 0.15531200f, 0.09281973f, 0.13894048f, 0.35220203f, 0.04165105f, 
    0.33992004f, 0.04689000f, 0.19394399f, 0.20774037f, 0.30202347f, 0.80326980f, 0.13383080f, 0.52307868f, 
    0.65398449f, 0.66674900f, 0.45465145f, 0.13513058f, -0.33410197f, 0.12648380f, 0.14894132f, -0.34468597f, 
    0.03192867f, 0.17524469f, -0.00635797f, 0.05516842f, -0.13324641f, 0.19374505f, 0.19810714f, 0.19427863f, 
    0.12146940f, 0.19276057f, -0.00820314f, 0.05714313f, -0.15597859f, -0.06120665f, 0.49948329f, 0.48770681f, 
    -0.25386292f, -0.32806137f, 0.08856666f, 0.49480146f, -0.53205192f, -0.50798070f, -0.43009359f, -0.37048873f, 
    0.32432926f, 0.56687832f, 0.37515154f, 0.33770448f, -0.13308971f, 0.27605751f, -0.31167608f, 0.15892871f, 
    0.20405415f, 0.18993084f, 0.07367183f, -0.14954661f, 0.04704894f, 0.01585574f, 0.05681602f, -0.32826242f, 
    -0.40778035f, -0.18137252f, 0.08937804f, 0.33495995f, -0.75418329f, -0.31614128f, -0.14122017f, -0.49033540f, 
    0.08850332f, 0.31458506f, -0.15127271f, -0.03915545f, 0.37519696f, -0.21423088f, 0.14785437f, 0.02064521f, 
    0.05059642f, 0.00779287f, -0.15814041f, -0.01880469f, -0.45037043f, 0.22287914f, -0.12355042f, 0.08344448f, 
    0.46034810f, -0.34844255f, 0.01014158f, -0.10831155f, -0.49812311f, -0.47088817f, -0.27150235f, -0.20078276f, 
    0.04866624f, -0.46425855f, -0.24075398f, 0.43876660f, -0.11846342f, -0.30742437f, -0.55252087f, 0.20941657f, 
    0.21498410f, -0.40489030f, -0.31547225f, -0.46909994f, -0.00725353f, 0.23571943f, 0.00132258f, 0.25352705f, 
    -0.23248838f, -0.62834519f, 0.18001518f, 0.19681871f, -0.17464584f, 0.30554673f, -0.88472837f, 0.31664172f, 
    0.02000617f, -0.57018828f, 0.13655511f, 0.21077055f, 0.30724797f, 0.30206114f, -0.10604139f, 0.22982675f, 
    -0.00297763f, 0.17441659f, 0.30855900f, 0.03982759f, -0.26028076f, 0.36914468f, -0.20020846f, -0.27340725f, 
    -0.01895069f, -0.00143685f, -0.09896050f, 0.67308581f, 0.74284893f, 0.53088212f, -0.05135595f, -0.75094104f, 
    0.70720369f, -0.20599620f, -0.28991851f, 0.06683655f, 0.09423023f, 0.16438028f, -0.07935195f, 0.10185259f, 
    0.13607830f, -0.06170703f, -0.08933019f, -0.03671887f, -0.05773920f, -0.00002792f, -0.02312570f, 0.33930388f, 
    0.38935336f, 0.14298329f, 0.06462133f, 0.83448464f, 0.21664973f, -0.84535956f, -0.90589732f, -0.34100279f, 
    0.03811977f, 0.24715993f, -0.22730879f, -0.11699494f, 0.33864948f, 0.10579991f, 0.12720335f, 0.22299820f, 
    -0.14863627f, -0.17394328f, 0.06177203f, 0.06619235f, 0.13470954f, 0.16996948f, 0.06013712f, -0.04456341f, 
    0.03306291f, 0.29984343f, -0.10748565f, 0.30349731f, 0.42290226f, -0.06824655f, -0.49812728f, -0.13395324f, 
    0.01512246f, -0.45657507f, 0.08695143f, -0.21510795f, 0.28806105f, -0.59092671f, -0.47169340f, -0.05332603f, 
    0.29739228f, -0.14261690f, 0.22850280f, -0.40071428f, -0.21407431f, -0.40553319f, 0.14720488f, 0.24691224f, 
    0.04795087f, -0.26461068f, -0.00412624f, -0.26321661f, 0.11543787f, 0.71620017f, 0.44972083f, 0.59842330f, 
    0.16470122f, -0.26616883f, -0.76246494f, -0.46918169f, -0.37937704f, 0.39606875f, -0.46635067f, -0.03845772f, 
    -0.10397530f, -0.08553063f, 0.11262079f, -0.09111270f, 0.17627275f, -0.33324233f, 0.03158165f, 0.12871663f, 
    0.05568671f, 0.16953655f, 0.31918806f, 0.28546312f, 0.18422066f, 0.03963893f, 0.92315996f, 0.42077520f, 
    -0.59628087f, 0.53344280f, -0.27764049f, -0.18654929f, -0.32829651f, 0.35789496f, 0.07710604f, -0.07913808f, 
    -0.01837566f, -0.14468442f, 0.35286763f, -0.02155919f, 0.15969743f, -0.15685399f, -0.26591939f, -0.20810184f, 
    -0.23471364f, 0.16689515f, -0.06989764f, -0.00214744f, -0.20710842f, -0.34574112f, -0.28001568f, 0.63381571f, 
    0.52553022f, -0.08054748f, 0.37879711f, 0.59553617f, -0.02336760f, 0.07561872f, -0.00338793f, 0.53085536f, 
    -0.01332963f, 0.21502681f, 0.18604925f, 0.16799316f, -0.03224311f, -0.09172609f, -0.31276676f, -0.24106218f, 
    0.33476186f, -0.17045926f, -0.02248841f, 0.15433091f, 0.32063925f, 0.30168465f, 0.17965981f, 0.24322803f, 
    0.49069315f, 0.56250536f, 0.47647983f, 0.26609200f, 0.03639516f, 0.26477715f, 0.10152747f, -0.42759356f, 
    -0.66198182f, -0.05850160f, -0.15288043f, -0.18976839f, -0.31586215f, 0.00548714f, -0.20886917f, -0.12774979f, 
    0.15541250f, 0.22901596f, -0.06957890f, -0.09899413f, 0.07748247f, 0.09246145f, -0.13276078f, -0.05010236f, 
    0.16564107f, -0.06694236f, -0.62841731f, -0.76812959f, -0.54354006f, -0.14500593f, 0.48112154f, 0.11627950f, 
    0.44329718f, 0.25453648f, 0.31629479f, -0.48472965f, -0.14843597f, -0.43632382f, -0.32660308f, -0.18239973f, 
    -0.28391320f, 0.05786680f, -0.05715583f, 0.09856953f, 0.04961923f, -0.17562504f, 0.16761176f, -0.26832417f, 
    0.04520877f, -0.04581125f, -0.46204740f, -0.13222846f, -0.65059608f, -0.23364922f, -0.29715043f, 0.12927192f, 
    0.03777329f, 0.10595093f, 0.14814338f, -0.56849915f, -0.33310083f, 0.02408253f, 0.03316914f, 0.52490932f, 
    0.10672201f, 0.13389149f, -0.12117390f, 0.07330345f, -0.34120581f, -0.31079647f, -0.10323744f, 0.08275139f, 
    0.15837401f, -0.04464305f, 0.05966809f, 0.45482159f, -0.08302259f, 0.20071228f, 0.85708100f, 0.57874501f, 
    0.31065187f, 0.40809384f, 0.09112889f, 0.43187690f, -0.22772966f, -0.08519322f, 0.18467790f, -0.24136132f, 
    -0.26946199f, -0.24908707f, 0.18463221f, -0.08460326f, -0.02292578f, -0.10706042f, -0.19261052f, 0.12633903f, 
    0.29883596f, -0.18485126f, -0.11797738f, 0.13996543f, -0.25736919f, -0.73461592f, -0.47149447f, -0.27731431f, 
    -0.56926847f, 0.00213480f, 0.59433633f, -0.43443489f, 0.01793763f, 0.40420851f, 0.04958062f, 0.34600765f, 
    -0.27266839f, 0.07988288f, 0.29774749f, 0.07232278f, -0.17829198f, 0.16698384f, 0.06446187f, 0.22270663f, 
    -0.05387910f, 0.12845284f, 0.09483541f, 0.22569360f, -0.20410818f, -0.45698988f, -0.15800163f, -0.43337262f, 
    -0.39667541f, -0.52926821f, 0.54647708f, 0.62772900f, -0.08604911f, 0.29430440f, 0.55052918f, 0.01325478f, 
    -0.22690250f, 0.21992278f, -0.13876693f, -0.21428069f, -0.14212349f, 0.28560188f, 0.12475500f, 0.41115892f, 
    -0.23258902f, -0.23078217f, -0.22632770f, -0.23714399f, -0.06213855f, 0.35815775f, 0.45459533f, 0.50036377f, 
    0.43084070f, 0.49567202f, 0.46986914f, 0.09590586f, 0.26071522f, 0.26388162f, -0.02782129f, 0.28782994f, 
    -0.15839244f, 0.10893112f, 0.06910726f, 0.41407311f, -0.14832790f, 0.07414243f, -0.08720719f, 0.05166944f, 
    0.22582923f, -0.08684836f, -0.34125176f, 0.05493589f, -0.19634658f, 0.32862413f, -0.12178157f, -0.87394100f, 
    0.67347455f, 0.66278356f, -0.03185201f, 0.61115301f, 0.61180860f, 0.18655665f, -0.27244493f, -0.26360884f, 
    -0.33798620f, -0.26545733f, -0.34139779f, 0.32268149f, 0.31909001f, -0.10712008f, -0.30651069f, -0.13394439f, 
    -0.09152418f, -0.24636844f, -0.10433422f, -0.12537299f, -0.06469628f, -0.23761384f, -0.16066971f, -0.14707519f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05955459f, 0.16397946f, -0.00511715f, 0.11669626f, 0.34370366f, 0.16799831f, 0.08683169f, 0.19647773f, 
    0.13089949f, 0.03569548f, 0.06336536f, -0.13496852f, 0.19016676f, 0.23643547f, 0.07639961f, 0.26154298f, 
    0.04315325f, 0.10681296f, 0.27745527f, 0.39622468f, -0.07359482f, 0.03717528f, 0.09129225f, 0.06375694f, 
    0.27131492f, -0.12933241f, 0.09329264f, 0.15667005f, 0.15158357f, 0.05923744f, 0.04972203f, 0.06735460f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05173418f, -0.11339669f, 0.06718814f, 0.23953824f, 0.07637632f, -0.02000826f, -0.02828024f, -0.01517484f, 
    0.09509869f, 0.09879313f, -0.09211349f, -0.05068513f, -0.18403168f, 0.17324017f, 0.00433511f, 0.14452329f, 
    0.13243307f, 0.07696047f, 0.06750080f, -0.01386771f, -0.03424558f, 0.13277037f, -0.04006918f, 0.00404284f, 
    -0.37120190f, 0.18912727f, -0.08564851f, 0.03933706f, 0.10604140f, -0.07975424f, 0.07781985f, 0.13219987f, 
    -0.08638468f, 0.08470996f, 0.09915562f, -0.02027872f, -0.19429778f, -0.07652514f, -0.11560345f, 0.06186292f, 
    0.08416799f, 0.01023535f, 0.06567605f, -0.01895617f, 0.03472202f, 0.06550160f, 0.04424558f, 0.01131903f, 
    -0.04417337f, -0.00574400f, 0.03022443f, -0.08842500f, 0.05748184f, -0.05812742f, 0.01033532f, -0.03337010f, 
    0.01043487f, 0.18972494f, -0.11472661f, 0.10782457f, -0.08671341f, 0.00468558f, -0.11802384f, -0.06716558f, 
    0.03897768f, 0.05813872f, 0.06442126f, 0.07810914f, 0.02084021f, -0.03681081f, 0.11995812f, -0.07067722f, 
    -0.14683627f, 0.23516898f, -0.06165784f, -0.06223809f, 0.07223374f, 0.01224957f, 0.08495809f, -0.00081296f, 
    -0.02982249f, 0.21323772f, 0.20779948f, 0.18556909f, 0.06003878f, 0.03247936f, -0.00546795f, 0.16285631f, 
    -0.11364084f, -0.01955929f, -0.07138134f, 0.10790813f, 0.05845839f, -0.00070220f, 0.00420642f, -0.07832256f, 
    -0.02979823f, 0.08495070f, 0.03935317f, 0.07852576f, -0.14604542f, 0.10646842f, 0.15676916f, -0.03723479f, 
    0.07898166f, 0.06228330f, 0.02100557f, -0.07895937f, 0.09304171f, -0.17267212f, -0.13213542f, -0.10782395f, 
    0.03948422f, 0.15327135f, -0.03662962f, 0.05013764f, -0.06282892f, 0.20693254f, 0.07538253f, -0.02459369f, 
    0.07393756f, -0.05139480f, 0.09679110f, 0.05149359f, 0.04792452f, -0.02439077f, -0.10599216f, 0.01576735f, 
    0.04233146f, -0.04752156f, 0.08211415f, -0.02450456f, -0.04579282f, 0.13811873f, 0.04360266f, -0.06534278f, 
    0.00750543f, 0.01102535f, -0.04058303f, 0.25497308f, 0.03403434f, 0.05065117f, 0.03993915f, 0.02631469f, 
    0.18800114f, 0.04371196f, -0.08093370f, 0.10479786f, -0.06264901f, -0.03202555f, -0.05037135f, 0.03704748f, 
    -0.13208063f, -0.06001642f, -0.07884993f, 0.01692488f, 0.05112341f, -0.07643705f, -0.09444881f, 0.10930856f, 
    0.06334999f, 0.05735039f, 0.02592757f, 0.03859590f, 0.00283768f, -0.06838960f, -0.12151124f, 0.13416730f, 
    0.13558936f, -0.07844434f, 0.03539131f, 0.15427785f, -0.04412302f, -0.03979470f, 0.02027061f, 0.07280526f, 
    -0.02299003f, -0.08282754f, 0.00149256f, -0.05131824f, -0.08671500f, 0.10936876f, 0.10601212f, 0.10379784f, 
    0.06509859f, -0.01034616f, 0.08883903f, 0.04101692f, -0.02454594f, 0.07372121f, -0.02855060f, -0.12774770f, 
    0.02048841f, 0.13901412f, 0.16268049f, 0.07819615f, -0.16631667f, 0.01806597f, -0.00482115f, 0.04354763f, 
    -0.03928172f, 0.24694908f, 0.18216126f, -0.03242380f, -0.19194385f, 0.09512496f, 0.16146141f, 0.15701115f, 
    -0.02360324f, 0.03166127f, 0.02302623f, 0.00950993f, 0.04221062f, 0.05894357f, -0.13000920f, 0.00890656f, 
    -0.12951106f, 0.11805636f, 0.14980561f, 0.08891686f, 0.04671560f, 0.00836695f, -0.10450552f, 0.02391996f, 
    -0.06734440f, -0.03264435f, 0.00545258f, -0.00653317f, -0.04824247f, 0.03224032f, -0.05310221f, 0.14930871f, 
    -0.01349664f, 0.01206950f, 0.14277621f, -0.03413410f, 0.01443309f, 0.09295327f, -0.17001872f, -0.01410285f, 
    -0.03966121f, 0.21959883f, 0.09141529f, 0.00016108f, 0.08075752f, -0.00410283f, 0.03952675f, -0.02089047f, 
    0.09209047f, 0.00781608f, -0.00022148f, 0.02412215f, 0.13743214f, 0.12922174f, -0.06668660f, 0.06513323f, 
    -0.00813334f, 0.07518722f, -0.09295306f, -0.08086914f, 0.17157352f, -0.01395205f, 0.10019418f, -0.03776042f, 
    0.31011567f, 0.12127037f, -0.15543459f, 0.07781519f, 0.12882000f, 0.07144026f, 0.12117507f, 0.02968424f, 
    0.07213823f, 0.06124323f, 0.12947567f, 0.01421682f, 0.20058507f, -0.10754928f, -0.04352748f, -0.00022281f, 
    0.13204214f, 0.09573689f, -0.05594580f, -0.09502032f, -0.10787444f, 0.02995298f, -0.06874160f, 0.02520669f, 
    0.15049066f, 0.00437898f, -0.00718741f, 0.13102536f, 0.00503715f, 0.12289971f, -0.03201195f, 0.00849258f, 
    0.06893636f, 0.08655592f, 0.00126716f, 0.03698152f, -0.23502225f, -0.10060081f, -0.09011941f, 0.12409072f, 
    -0.06496840f, -0.01783801f, 0.08975336f, 0.05383142f, -0.03202394f, 0.02294941f, 0.13144860f, 0.08354352f, 
    0.17351477f, 0.05271270f, -0.04938085f, -0.05789120f, 0.07117344f, -0.05339039f, 0.06238667f, -0.01751631f, 
    0.01038359f, -0.02454572f, 0.07420793f, -0.01714007f, 0.08368742f, -0.07707395f, 0.11109035f, -0.05523920f, 
    -0.02089353f, -0.05897908f, 0.01522691f, 0.08726465f, 0.01943195f, 0.07681626f, 0.02225810f, -0.00628472f, 
    0.02525140f, 0.03370866f, 0.07999952f, 0.01972762f, 0.01845903f, 0.09102839f, -0.12063473f, 0.10293470f, 
    -0.08929340f, -0.08699767f, 0.03204624f, 0.00464723f, -0.03906669f, -0.08309196f, 0.12404662f, 0.09403916f, 
    -0.11079314f, -0.01099137f, 0.05277389f, 0.07212679f, 0.01366412f, 0.02869490f, 0.03714560f, 0.04829571f, 
    -0.20398051f, -0.07197088f, -0.19319738f, 0.03488020f, -0.08554596f, 0.02512049f, -0.02037090f, 0.06349628f, 
    -0.07769644f, -0.01940614f, -0.04625019f, -0.03050867f, 0.14121184f, 0.12842943f, 0.06563687f, 0.09139418f, 
    0.03253403f, 0.05775797f, -0.00140146f, 0.08377441f, 0.09885719f, -0.00275066f, 0.03171876f, 0.16971162f, 
    -0.11277872f, 0.20009214f, 0.07975622f, -0.28654599f, 0.09816979f, -0.02227333f, -0.15820687f, -0.02499607f, 
    -0.00281264f, -0.09199291f, 0.13526276f, 0.02493254f, -0.12482098f, -0.11281355f, 0.12517340f, -0.11461063f, 
    0.02476744f, -0.04881304f, 0.04378676f, -0.04987823f, 0.15307727f, -0.01642111f, 0.05197470f, -0.06919376f, 
    0.00127932f, -0.29829162f, -0.01133907f, 0.14158523f, 0.09535861f, 0.01065994f, 0.00699342f, 0.13362360f, 
    -0.00153209f, -0.17046809f, -0.01681799f, 0.16019645f, 0.21171625f, 0.33799717f, -0.12991509f, -0.06919715f, 
    0.00638213f, 0.09358016f, 0.07124914f, 0.07993329f, -0.05754186f, 0.02516414f, 0.07179605f, 0.07021453f, 
    -0.12663601f, -0.05878766f, -0.10837995f, -0.04871758f, 0.08515761f, -0.02509372f, -0.02467051f, 0.08135878f, 
    -0.01417755f, -0.07574347f, 0.05177762f, 0.07416221f, 0.12310827f, 0.05447101f, 0.13651325f, 0.00185956f, 
    0.09841189f, -0.03308177f, -0.04858207f, -0.01756691f, -0.01913597f, 0.09294415f, 0.02578456f, 0.00227869f, 
    0.00255863f, -0.10931395f, 0.04945480f, 0.02428124f, 0.03291363f, 0.01068881f, 0.09084690f, 0.01409602f, 
    0.06544306f, 0.02204715f, 0.02240504f, -0.00279272f, -0.13069682f, -0.16755514f, -0.08140597f, 0.06943122f, 
    0.06812352f, 0.06643883f, 0.04730701f, 0.09343674f, -0.04171693f, 0.06684675f, 0.05301477f, 0.12517680f, 
    0.07549954f, -0.12953724f, 0.07523939f, -0.08316009f, 0.04395926f, 0.06987090f, -0.11837980f, -0.00074792f, 
    0.06518624f, 0.02331239f, 0.16607092f, 0.09795013f, -0.18578194f, 0.21492648f, 0.20221460f, 0.09935525f, 
    0.06795426f, -0.09241489f, 0.17343068f, -0.11112759f, 0.10328875f, -0.08888870f, -0.03753814f, 0.12183423f, 
    -0.19091435f, 0.24115713f, 0.22460042f, -0.15198660f, 0.15459333f, -0.01822483f, 0.00184362f, -0.02590947f, 
    0.00396121f, -0.03229814f, 0.01687527f, 0.07940423f, -0.13195786f, -0.05012059f, -0.27909252f, -0.06703790f, 
    0.01812465f, -0.03089834f, 0.05122359f, -0.01810192f, 0.06898917f, -0.10204430f, -0.08754081f, -0.02866399f, 
    -0.25979617f, -0.17652395f, 0.07190258f, -0.04451527f, 0.10421163f, -0.03123629f, -0.07607611f, -0.08646232f, 
    0.09524251f, -0.02528441f, -0.03203632f, 0.09998772f, 0.02838991f, 0.34127972f, 0.18543355f, -0.10194782f, 
    0.05393052f, -0.01670181f, -0.03235190f, -0.01578751f, -0.00564676f, -0.00443961f, 0.05233052f, -0.08099946f, 
    -0.19826055f, 0.22879934f, 0.10082757f, -0.26651037f, -0.01304328f, 0.02995739f, -0.06440748f, -0.14026166f, 
    0.06312048f, 0.08796966f, 0.06927383f, -0.06269048f, -0.04523060f, -0.07884908f, -0.10896133f, -0.00885362f, 
    0.07432816f, 0.08627075f, 0.01047680f, 0.01101815f, -0.01355680f, 0.10923766f, 0.16132630f, 0.04918245f, 
    -0.07351365f, -0.06320941f, -0.01363839f, -0.06696666f, 0.14255491f, 0.12842926f, 0.05015900f, 0.01620517f, 
    0.03888634f, -0.06625996f, 0.02623146f, 0.18274088f, 0.32012963f, -0.15579185f, -0.00854927f, -0.06695478f, 
    0.10796992f, 0.10477653f, 0.01840540f, 0.02076630f, 0.00357390f, 0.00192903f, 0.08645318f, -0.04016140f, 
    -0.02045769f, -0.03661649f, 0.18396960f, -0.03923296f, -0.01312050f, 0.06531534f, 0.07081606f, 0.00205235f, 
    0.10850210f, -0.08005139f, -0.00624751f, 0.04517092f, -0.11111063f, -0.03077151f, 0.17172554f, -0.00389516f, 
    -0.09150908f, 0.06260832f, 0.08262396f, 0.18807918f, 0.00815872f, -0.06068715f, 0.00959279f, 0.01087463f, 
    -0.04383667f, -0.09765391f, -0.14622775f, 0.12940407f, 0.03369348f, -0.08400954f, -0.08062419f, 0.04538095f, 
    -0.09609825f, -0.08037161f, -0.06438366f, 0.08493405f, -0.24559833f, -0.16763760f, 0.29555985f, 0.19310677f, 
    -0.06023698f, -0.00664857f, 0.08755723f, -0.13706556f, -0.13320303f, 0.15165728f, 0.03388860f, 0.10783838f, 
    -0.23374565f, -0.08370911f, 0.12534334f, 0.05635433f, -0.02981610f, -0.02851561f, 0.07291642f, -0.10660782f, 
    -0.00785881f, -0.04437336f, -0.07854453f, 0.07444990f, -0.09860404f, 0.04218246f, 0.11085407f, 0.06955159f, 
    -0.09308339f, -0.03621969f, 0.04615207f, -0.06062058f, 0.01511975f, -0.12432297f, 0.04321479f, 0.02161154f, 
    -0.11142199f, 0.17606246f, 0.19448559f, -0.06581277f, 0.11416028f, 0.09238333f, -0.05004975f, 0.04352778f, 
    -0.01066104f, 0.05081908f, 0.01365858f, -0.01809680f, -0.20616077f, -0.02813022f, 0.05543984f, 0.17485265f, 
    0.05711650f, 0.07292874f, -0.05011652f, 0.14013684f, 0.00509456f, 0.00149800f, -0.05375235f, -0.00547644f, 
    -0.23553941f, -0.17429350f, -0.06877777f, 0.18830271f, -0.00128174f, 0.09536961f, 0.03747081f, 0.08119027f, 
    0.03722623f, -0.02771555f, -0.02383916f, -0.00340290f, 0.00788418f, 0.31538460f, -0.06506314f, 0.08094604f, 
    0.09911509f, -0.02192072f, 0.08369276f, 0.00254885f, 0.07296088f, 0.08080819f, 0.07379927f, 0.17633033f, 
    -0.28973201f, -0.08712558f, 0.01769866f, -0.06037871f, 0.04432539f, -0.01507679f, -0.03337018f, -0.04597173f, 
    -0.00855753f, 0.00222096f, -0.01374101f, 0.03107880f, -0.26490355f, -0.18076606f, 0.06489284f, 0.05852593f, 
    0.09755926f, -0.00483608f, 0.06648581f, 0.06814722f, -0.04563893f, 0.05589505f, 0.10795834f, -0.01379949f, 
    0.08821180f, 0.12251612f, 0.10384037f, 0.04150467f, 0.19206299f, 0.00398363f, 0.04082268f, 0.02046814f, 
    0.00098089f, 0.12156916f, -0.03042050f, 0.03317012f, 0.19265172f, 0.10394299f, -0.31102294f, -0.23567444f, 
    -0.00409009f, 0.06079042f, -0.03868907f, 0.06138237f, -0.02977495f, 0.07772975f, -0.09273054f, -0.11408194f, 
    0.01124301f, -0.02377656f, -0.02396285f, -0.29018563f, -0.08665615f, -0.12449282f, -0.00592834f, 0.00462362f, 
    0.01505593f, -0.03037890f, -0.02764988f, 0.04193269f, 0.22960557f, -0.26478803f, 0.09828284f, 0.03559275f, 
    -0.20149332f, -0.03462164f, 0.03059197f, -0.03264740f, 0.06681260f, 0.02677359f, 0.05851510f, -0.02046856f, 
    0.07022521f, 0.00064918f, 0.11127830f, -0.06916527f, 0.13304728f, -0.00726634f, -0.06254227f, 0.03018209f, 
    0.03276238f, 0.04679021f, 0.02437938f, 0.08641706f, 0.09788813f, 0.06719226f, -0.10818364f, 0.17134602f, 
    0.01361805f, 0.12026222f, 0.01705032f, 0.04566065f, 0.04044361f, -0.00984762f, 0.03760960f, -0.01876290f, 
    -0.17298719f, -0.04497757f, -0.10018715f, -0.00178876f, 0.08637995f, 0.04632523f, 0.08973078f, 0.03881409f, 
    0.00574141f, -0.04026485f, -0.04301022f, -0.02278272f, -0.04613297f, 0.03033584f, 0.26403746f, 0.10408428f, 
    0.03900217f, -0.03703452f, 0.00488086f, 0.07550712f, 0.09895831f, -0.01153370f, 0.07070237f, -0.06154295f, 
    0.07698570f, -0.17267078f, 0.17858960f, 0.16079724f, -0.08624565f, 0.00679966f, 0.10908315f, -0.06602626f, 
    0.01905563f, 0.01655327f, -0.05681832f, 0.04828944f, -0.06394577f, -0.02589991f, 0.02769596f, -0.06047695f, 
    -0.05657781f, 0.13698739f, -0.00085955f, 0.08840115f, 0.05064123f, -0.08442354f, 0.07670545f, -0.00243207f, 
    0.06972458f, -0.09684844f, 0.13131399f, -0.06810927f, 0.05853692f, 0.03646741f, -0.14560860f, 0.00008314f, 
    -0.04169439f, 0.01829073f, 0.01378418f, -0.05176780f, -0.08443372f, 0.28337595f, 0.12967734f, 0.18829885f, 
    -0.07326805f, -0.07416773f, 0.00952084f, -0.03033943f, 0.08087767f, -0.01442502f, 0.02679504f, 0.02897382f, 
    -0.04870089f, 0.18906134f, 0.09108861f, -0.10204513f, -0.08523443f, 0.07586682f, 0.01922462f, -0.05828497f, 
    -0.02894115f, 0.01339358f, -0.04477021f, -0.00483153f, 0.26183313f, -0.09948230f, 0.09073897f, 0.07739007f, 
    0.01187096f, 0.12041628f, 0.08505262f, -0.08250198f, -0.03730645f, 0.08364933f, 0.05265779f, 0.08873645f, 
    -0.13624732f, -0.02609823f, 0.08944868f, -0.05543214f, -0.04763648f, -0.03309474f, 0.07109358f, 0.03800995f, 
    0.06123020f, -0.07174265f, 0.01482667f, 0.04191099f, 0.08165264f, 0.26107755f, -0.09367041f, -0.00713905f, 
    -0.18572614f, -0.02846794f, 0.07624748f, 0.06584846f, -0.09601709f, 0.04394951f, -0.06270731f, -0.03347481f, 
    -0.05001025f, 0.11965705f, 0.14194715f, -0.19340333f, -0.09856435f, 0.07097916f, -0.00854776f, -0.08417828f, 
    0.07363482f, 0.03096263f, -0.01977448f, -0.01995136f, -0.06686236f, -0.05819551f, -0.00426218f, -0.00550091f, 
    -0.07024989f, -0.05541460f, 0.10130006f, 0.06259249f, 0.09774921f, 0.02127178f, -0.02792583f, -0.01686993f, 
    0.18395659f, -0.11650284f, -0.03201358f, 0.05041596f, 0.04474670f, 0.05576866f, -0.01394160f, -0.00424074f, 
    -0.03995351f, 0.04022389f, 0.10914162f, -0.02577640f, -0.19460145f, -0.28720602f, -0.01790511f, 0.00661400f, 
    0.06084277f, -0.00654624f, -0.02889616f, -0.06593592f, 0.07653740f, -0.03407263f, 0.02936438f, -0.01043225f, 
    0.01288117f, -0.13755320f, 0.17862982f, -0.05522820f, -0.02037380f, 0.01103621f, 0.07640354f, -0.08070016f, 
    0.08258837f, 0.00355664f, -0.00850231f, 0.01845038f, 0.22707352f, -0.04860584f, 0.11492553f, -0.07836167f, 
    0.08944783f, -0.04015978f, 0.12525983f, 0.04158482f, -0.02810300f, 0.06134576f, -0.00353784f, -0.06194739f, 
    0.01708937f, -0.15897071f, -0.15895389f, 0.14551766f, -0.06502171f, -0.01465393f, 0.01102874f, -0.00789706f, 
    -0.03361019f, -0.13503110f, 0.05673484f, 0.04794677f, -0.04264133f, -0.18446594f, 0.14952555f, 0.01963030f, 
    -0.03770532f, -0.07065050f, -0.01300051f, -0.05856346f, -0.11023636f, -0.02147319f, -0.11166951f, 0.04507850f, 
    -0.15147020f, -0.10550785f, 0.14001654f, 0.01995198f, -0.00219875f, -0.04393025f, -0.06660383f, 0.06601292f, 
    0.01732170f, -0.01261078f, 0.00139745f, 0.08904764f, -0.11821987f, 0.08603396f, 0.16492118f, 0.10462891f, 
    -0.13604765f, -0.00957520f, -0.00721652f, -0.01422237f, 0.00457898f, 0.05958996f, -0.10873201f, -0.12068024f, 
    0.07810981f, 0.25394893f, 0.04918179f, -0.12459013f, -0.12398566f, -0.04001699f, 0.10189218f, 0.04529060f, 
    -0.01136691f, 0.00528300f, -0.04777675f, -0.00240661f, 0.03197933f, -0.02043953f, 0.03756811f, -0.21245746f, 
    0.17249426f, 0.04090624f, -0.00072032f, -0.06335943f, 0.02727205f, 0.04257023f, 0.07297817f, 0.20407568f, 
    -0.06067451f, 0.07807242f, 0.07483632f, 0.10325672f, -0.01156141f, 0.07605847f, -0.07053605f, 0.06390972f, 
    0.00173998f, -0.01116804f, -0.15838818f, 0.08344901f, 0.12193466f, 0.21194884f, -0.12062908f, 0.17492531f, 
    0.14060652f, 0.01803142f, 0.09692834f, 0.06077951f, 0.04832075f, 0.02290011f, 0.05585884f, 0.00634366f, 
    -0.15799500f, -0.02567263f, -0.00806920f, -0.07707069f, 0.08070490f, 0.09729086f, 0.02534636f, -0.10021848f, 
    0.01618983f, 0.09524179f, 0.05590323f, 0.03086728f, 0.05500478f, -0.04054331f, 0.03920466f, -0.07845888f, 
    0.31335688f, -0.02948401f, -0.03195301f, 0.04207063f, 0.11708161f, 0.24621139f, -0.04150169f, 0.12025560f, 
    0.17178135f, 0.21513203f, 0.08983638f, 0.05943541f, -0.03260598f, 0.04621564f, 0.05302729f, 0.10960214f, 
    0.01655641f, 0.18492156f, -0.01038392f, -0.01396954f, -0.03769418f, 0.02542188f, -0.20134364f, -0.18396422f, 
    -0.10366681f, 0.00029952f, 0.06200451f, 0.01081320f, -0.04955224f, -0.00190555f, -0.09859327f, 0.01010127f, 
    0.14478897f, 0.06239781f, -0.13363415f, 0.10213607f, 0.08554151f, 0.01228529f, -0.06571782f, 0.06765307f, 
    0.08657245f, 0.07554112f, 0.09233914f, 0.02915997f, 0.19031467f, -0.14766774f, -0.05548203f, 0.06840564f, 
    -0.00388455f, 0.05878511f, 0.06759653f, 0.08656394f, -0.00614230f, -0.06082373f, 0.01965433f, 0.10984994f, 
    0.43309554f, -0.17793745f, 0.07508666f, 0.07635380f, -0.00144220f, -0.01678743f, 0.03938257f, 0.09515679f, 
    0.01282698f, -0.02832457f, 0.02693470f, -0.06359988f, 0.39121893f, -0.29848891f, 0.08832188f, 0.03205071f, 
    -0.06490310f, 0.02410343f, -0.06377889f, 0.02559985f, -0.04257168f, 0.12231304f, -0.06717899f, 0.01186792f, 
    0.28972664f, 0.02615758f, -0.02915969f, 0.02945705f, -0.04626395f, -0.01316582f, -0.03696198f, -0.00173537f, 
    0.21511050f, -0.11029880f, -0.02424002f, -0.08420928f, 0.07144362f, -0.00278164f, -0.08145400f, 0.05723054f, 
    0.05274431f, 0.10415748f, 0.07023035f, -0.02395259f, -0.04912328f, -0.01690127f, 0.01657178f, 0.09075420f, 
    0.20443699f, -0.10618452f, -0.06755909f, -0.11805820f, 0.03074377f, 0.18732740f, 0.00148317f, 0.12056220f, 
    0.11086484f, -0.05149605f, 0.02040126f, -0.05621624f, -0.05458034f, 0.13405088f, 0.06310844f, -0.05010398f, 
    0.05634619f, 0.14258561f, 0.06001485f, 0.10287677f, 0.05431432f, 0.02910083f, -0.02331373f, 0.04043844f, 
    0.13513288f, 0.12044559f, -0.20878522f, -0.08328772f, 0.12443117f, 0.09173815f, 0.04948240f, 0.04523120f, 
    0.14718851f, 0.10310271f, 0.01268846f, 0.12013276f, 0.14230900f, -0.18360537f, 0.06136198f, 0.09415421f, 
    -0.04299763f, -0.07472199f, 0.03017268f, 0.01858781f, 0.01807719f, -0.11202192f, -0.02028451f, 0.09524164f, 
    0.19802605f, -0.24581163f, -0.12757961f, -0.12566017f, 0.06214229f, -0.05949211f, 0.04903154f, -0.06680195f, 
    -0.08642574f, -0.03056483f, -0.06962305f, -0.02834975f, -0.08037885f, -0.00921673f, -0.13951524f, 0.04784953f, 
    -0.08201212f, 0.02539686f, -0.04841375f, -0.02038127f, -0.06835695f, 0.06706650f, -0.00991972f, -0.00366127f, 
    -0.09421480f, 0.04783763f, 0.03672376f, -0.02305643f, -0.23414786f, -0.02556485f, 0.05952665f, -0.01211242f, 
    0.11306223f, 0.05490666f, 0.04509977f, 0.01444929f, 0.06752837f, -0.10528918f, 0.00392117f, 0.08722579f, 
    -0.03185884f, 0.02529624f, -0.00001152f, -0.08376410f, -0.02063248f, -0.12682714f, 0.08343170f, -0.13499174f, 
    0.04535775f, -0.17038774f, -0.07416978f, -0.01857284f, 0.10440706f, 0.03414574f, 0.10027134f, 0.06203758f, 
    0.01497496f, 0.14668635f, -0.10537896f, 0.04031524f, 0.17155351f, 0.01496600f, 0.00440490f, -0.05167225f, 
    0.02566824f, -0.02433872f, -0.02296446f, -0.00505513f, -0.06402693f, -0.04617088f, -0.04211196f, 0.03777490f, 
    0.03640678f, -0.07611541f, -0.01943388f, -0.14880653f, 0.10078841f, -0.03252029f, 0.06948071f, -0.07213979f, 
    0.03578684f, -0.19748354f, -0.02177313f, -0.02738050f, 0.15615958f, 0.16498898f, -0.05062366f, -0.05900590f, 
    0.01723839f, 0.07852373f, -0.08594644f, 0.07787540f, -0.06134399f, 0.02385935f, 0.03570795f, -0.03839397f, 
    0.22771505f, 0.04212116f, -0.13202511f, -0.03862281f, -0.06061207f, 0.05350282f, 0.03522405f, -0.09720269f, 
    -0.00831774f, 0.02254944f, 0.04009319f, 0.00122525f, 0.20033142f, 0.07522445f, 0.05943197f, -0.05967022f, 
    0.01270518f, -0.01053808f, -0.01608413f, -0.02677195f, -0.06382262f, -0.00012271f, 0.12398286f, 0.09497971f, 
    -0.14785838f, -0.17437707f, 0.02689768f, -0.04960656f, -0.08733805f, 0.03601082f, -0.01465532f, 0.00360785f, 
    -0.08230466f, 0.06699612f, -0.09206173f, -0.05528717f, 0.04662673f, 0.01359699f, -0.04545234f, -0.08756247f, 
    0.09954023f, 0.03398794f, 0.05100925f, 0.07884806f, -0.08830240f, 0.07490809f, -0.00153171f, 0.10518015f, 
    -0.09586595f, -0.14278561f, 0.06689151f, -0.02302882f, 0.01078815f, -0.06054939f, 0.04373283f, 0.09061147f, 
    0.17482948f, 0.00703802f, -0.08635663f, 0.02669699f, 0.08103251f, -0.09731104f, 0.07461801f, 0.16934726f, 
    0.06284660f, 0.13132285f, 0.03539809f, 0.01281189f, 0.01945016f, 0.04620481f, 0.06147320f, 0.01597118f, 
    -0.01196973f, -0.04821880f, -0.06043650f, -0.03280191f, 0.09847655f, -0.00053393f, 0.02334729f, -0.02163570f, 
    0.05315101f, -0.07033874f, 0.08031131f, -0.08743379f, 0.12611178f, -0.02490181f, 0.11345114f, -0.06607306f, 
    -0.14053585f, -0.00803211f, -0.04238339f, 0.01411253f, 0.12058202f, 0.04424746f, -0.06428365f, -0.00173597f, 
    0.09870586f, 0.02403386f, 0.00359225f, -0.09026483f, -0.13862848f, -0.00203903f, -0.01317524f, -0.12340967f, 
    -0.04860527f, -0.03745345f, 0.01561924f, -0.06805786f, 0.15606432f, -0.24030337f, 0.03137016f, 0.08609957f, 
    0.00342787f, 0.06022082f, -0.04620720f, -0.01070931f, -0.02215271f, -0.06279410f, 0.05856947f, -0.02093463f, 
    0.45007795f, 0.09445216f, -0.01395940f, 0.08687720f, -0.04713164f, -0.09005303f, -0.02130923f, -0.04963222f, 
    0.00437298f, 0.02622380f, -0.06677536f, 0.02571533f, 0.01536984f, -0.03337603f, 0.02097480f, -0.03424530f, 
    -0.12903000f, -0.09354205f, 0.10040601f, 0.15177870f, 0.01469609f, -0.09889326f, -0.04843946f, -0.11444856f, 
    0.06747720f, -0.04554572f, -0.01193276f, 0.09040403f, 0.06802227f, 0.02424214f, -0.03445462f, -0.10524290f, 
    0.11900582f, -0.01665914f, -0.07461185f, -0.01576916f, 0.08916395f, -0.07694897f, -0.13435429f, -0.06655634f, 
    0.01732804f, 0.01822696f, -0.07542914f, -0.06570673f, 0.01716226f, 0.05081205f, -0.02284122f, -0.01303233f, 
    0.02203591f, 0.05799291f, -0.04663535f, 0.04790791f, 0.12182842f, -0.02550668f, -0.05562282f, 0.10318232f, 
    0.07169192f, 0.13714705f, 0.01154399f, 0.10194917f, -0.07366905f, 0.03428984f, -0.09525899f, -0.05485915f, 
    0.08606241f, -0.04294653f, 0.01711628f, 0.03689034f, -0.05165742f, -0.01088301f, -0.03507962f, 0.06904813f, 
    0.09073816f, -0.04594271f, 0.10821773f, 0.07605765f, 0.06479319f, -0.09230735f, 0.05267320f, 0.01154641f, 
    0.02441228f, -0.03305278f, 0.12577035f, -0.02230261f, 0.32158160f, -0.22363447f, 0.03340346f, 0.02076814f, 
    -0.12447504f, -0.00536487f, 0.02199549f, 0.03676214f, -0.09016155f, 0.12040842f, -0.06837610f, 0.05104372f, 
    0.08785643f, 0.01288215f, 0.02786950f, -0.15838607f, 0.02587866f, 0.10871869f, -0.06671005f, 0.05974422f, 
    0.04251127f, -0.08185489f, 0.06739315f, 0.02305673f, 0.12252264f, 0.10872962f, -0.19364910f, 0.09228460f, 
    0.03951879f, 0.04064408f, 0.07512976f, 0.01361615f, -0.09739665f, 0.03092776f, 0.08283214f, 0.00555985f, 
    0.18146035f, 0.04113312f, -0.01500908f, -0.06580362f, 0.06619609f, 0.17946632f, 0.01610924f, 0.11154976f, 
    0.01793439f, -0.10998306f, 0.06873663f, -0.10656630f, 0.03826070f, 0.05533342f, -0.08427475f, -0.18561137f, 
    -0.02411529f, -0.07878774f, 0.01507061f, -0.01653954f, 0.10571930f, 0.09483123f, -0.02338042f, 0.09817221f, 
    0.06908737f, 0.01217731f, -0.09162989f, -0.06826502f, -0.01948051f, 0.10783094f, 0.06515058f, -0.08219543f, 
    0.04626067f, 0.05636834f, -0.02754285f, 0.07309686f, 0.07977100f, -0.28943714f, -0.02292163f, 0.06651779f, 
    0.17158772f, -0.06951860f, -0.00927001f, 0.06485970f, 0.04093291f, 0.10523465f, -0.03478932f, 0.05289908f, 
    0.16033676f, -0.21726321f, -0.10881494f, -0.17486018f, 0.10488956f, 0.01510975f, -0.01175989f, -0.12475950f, 
    0.11673895f, -0.14118984f, 0.00777880f, -0.00525035f, -0.09860650f, 0.03914416f, -0.19151287f, -0.04925844f, 
    -0.00988630f, 0.01856883f, -0.03204398f, 0.03634773f, -0.20649448f, 0.02033350f, -0.17457889f, -0.02595953f, 
    0.05054085f, -0.03134269f, -0.06246378f, -0.04987070f, -0.13198040f, 0.13726126f, -0.01181397f, 0.02010800f, 
    0.05899947f, 0.08708647f, 0.07874222f, -0.04068058f, 0.11224647f, -0.09295779f, 0.03430821f, 0.01990684f, 
    0.04005945f, -0.00005370f, -0.04876427f, -0.02712729f, 0.06184780f, -0.01431117f, 0.13636257f, -0.07495975f, 
    0.01027656f, -0.20013067f, -0.23070252f, 0.02071235f, 0.02754196f, -0.04523024f, -0.00911845f, -0.06971424f, 
    0.00265297f, -0.07503373f, 0.12170689f, 0.00732057f, 0.14293221f, 0.06343229f, -0.14168566f, -0.13605176f, 
    0.09176508f, 0.05643328f, 0.12112010f, 0.07305484f, -0.06377465f, 0.03871939f, 0.08742514f, 0.06645925f, 
    -0.07216250f, -0.11207516f, 0.00890288f, -0.18338172f, -0.01897748f, -0.02267423f, 0.07125318f, 0.03316878f, 
    0.02871173f, -0.08088547f, 0.04806744f, 0.05613046f, 0.12888932f, 0.12556981f, -0.11475567f, -0.08363987f, 
    -0.06354831f, 0.03652268f, -0.05410128f, 0.03613031f, -0.01502496f, 0.05838446f, 0.03198296f, -0.02583564f, 
    0.08634659f, 0.03871365f, -0.08748730f, 0.04454264f, -0.05499607f, 0.01369885f, 0.07032065f, -0.00793281f, 
    0.07906941f, 0.06613036f, 0.05697197f, 0.03276670f, 0.06115294f, 0.12051384f, -0.07575347f, 0.06627803f, 
    -0.00372641f, 0.00234298f, 0.13049522f, -0.11876561f, -0.02530636f, 0.02866208f, 0.04255389f, 0.07496373f, 
    -0.14598893f, -0.08851442f, -0.06852844f, -0.13427944f, 0.13690588f, -0.00846430f, -0.11842395f, 0.03508956f, 
    -0.11711120f, 0.02760441f, 0.01962832f, -0.11530872f, -0.09081142f, 0.03217927f, 0.16301696f, 0.09450889f, 
    0.03748420f, -0.04942894f, 0.06453913f, 0.00083955f, 0.01417701f, 0.12460411f, -0.03079269f, 0.06599663f, 
    -0.13395007f, -0.11259495f, -0.00376122f, 0.03706773f, 0.13452275f, -0.02471494f, -0.03262492f, -0.09746266f, 
    0.20097449f, 0.09671187f, -0.00397319f, 0.02798945f, 0.17909051f, -0.12928294f, 0.04887367f, 0.27001345f, 
    0.05288490f, 0.14713103f, 0.02885406f, -0.03421845f, 0.04341268f, 0.04304448f, 0.08819386f, 0.08686561f, 
    0.02300355f, 0.12257387f, 0.01080390f, -0.07085270f, 0.10643893f, 0.11726657f, 0.01895355f, -0.03977256f, 
    0.08896336f, -0.02557549f, -0.02699927f, -0.06424692f, -0.20989870f, -0.07551659f, 0.06285646f, 0.20342322f, 
    -0.07677668f, 0.00344277f, -0.00748116f, -0.01281964f, 0.07641999f, 0.12788860f, -0.07519984f, -0.01756199f, 
    0.11965173f, -0.12569682f, -0.02413354f, -0.27923065f, 0.01084372f, -0.04621737f, -0.00056841f, -0.03869921f, 
    -0.06931286f, -0.00773998f, 0.05675321f, -0.09205468f, 0.24553901f, -0.15398139f, 0.15829304f, -0.04628879f, 
    -0.07040945f, 0.05146937f, -0.00182357f, 0.08953542f, 0.06316338f, -0.03081233f, 0.01797905f, 0.04359414f, 
    0.23783968f, 0.16590780f, 0.10580681f, 0.13015993f, -0.00865415f, -0.07896941f, -0.01355552f, 0.01589221f, 
    -0.03121951f, 0.00670139f, -0.00504998f, 0.02997104f, -0.03057037f, -0.06083146f, 0.11107541f, 0.25830111f, 
    -0.21483077f, -0.06711558f, 0.10652924f, -0.00727714f, -0.12067688f, -0.09169035f, 0.05408146f, -0.07350246f, 
    0.04676326f, -0.03317053f, -0.15248814f, 0.13967668f, 0.12643513f, -0.02299813f, -0.07661451f, 0.00593324f, 
    -0.00285154f, -0.05790658f, 0.05780200f, -0.05149774f, -0.03973753f, 0.23209052f, -0.19879790f, -0.12411989f, 
    0.11450107f, 0.00566209f, -0.10385346f, -0.04945050f, -0.00992317f, 0.05493498f, 0.05226829f, -0.05711454f, 
    -0.15001607f, -0.18267342f, 0.27140746f, 0.04518156f, -0.08708181f, 0.00160088f, 0.00879347f, -0.06817024f, 
    -0.06573313f, -0.05464713f, 0.02897820f, -0.09980430f, 0.02988024f, -0.07487252f, 0.00352234f, -0.01532197f, 
    -0.14236897f, 0.03326416f, 0.02008679f, 0.00330827f, 0.08168329f, 0.12172774f, 0.07951667f, -0.03993404f, 
    -0.07157635f, -0.14647073f, 0.00339357f, -0.13873933f, 0.00737931f, 0.15737756f, -0.11385489f, -0.01970039f, 
    0.01385970f, -0.03628387f, -0.06453639f, 0.09515481f, 0.02786157f, 0.09801950f, -0.07253641f, -0.02898326f, 
    0.04485679f, 0.09918196f, 0.02306484f, -0.03179609f, 0.04498408f, 0.05786721f, 0.00761810f, 0.00967981f, 
    0.05390516f, -0.11913168f, -0.07616098f, 0.16768956f, -0.01798197f, -0.01019456f, -0.09826522f, 0.13298364f, 
    0.00636918f, -0.03723944f, -0.00812145f, 0.01860943f, 0.04288198f, -0.05144316f, 0.14555177f, -0.08668561f, 
    -0.02473989f, 0.03674013f, 0.02037389f, 0.05910467f, 0.04210864f, 0.02892943f, -0.04023933f, 0.01516606f, 
    -0.21908402f, 0.19119409f, 0.02959612f, 0.13222221f, -0.08517479f, 0.02377896f, 0.08587861f, -0.02425599f, 
    -0.05816836f, -0.04325397f, 0.02868395f, -0.13426550f, 0.15108883f, 0.19030616f, 0.08822422f, 0.03421129f, 
    -0.03673261f, 0.04182023f, 0.08979220f, -0.04296191f, -0.04630236f, 0.07600811f, 0.04427242f, -0.11465035f, 
    -0.13617875f, 0.05793135f, 0.08416003f, -0.02942373f, -0.01215321f, 0.02320381f, 0.08007021f, 0.02712000f, 
    0.06958431f, -0.10793117f, 0.04178402f, -0.02836432f, 0.21034464f, 0.06328465f, -0.08243635f, 0.04078227f, 
    -0.09472762f, -0.02694128f, -0.07754658f, 0.05442041f, 0.00323186f, -0.00946000f, 0.03265754f, -0.00495350f, 
    -0.22528911f, 0.02901757f, 0.08004612f, -0.10030785f, -0.07845199f, -0.04768166f, 0.07348111f, 0.02402520f, 
    -0.07646336f, 0.10330242f, -0.02331572f, -0.01865738f, -0.28793588f, 0.36801022f, 0.11425965f, -0.07869886f, 
    0.12829429f, -0.05879751f, 0.12246199f, -0.04447209f, 0.08817578f, -0.00401307f, -0.00245413f, -0.01092029f, 
    0.04954753f, -0.00093990f, 0.10062885f, 0.12378716f, 0.18803401f, 0.07526595f, 0.12958746f, 0.00753543f, 
    0.05290028f, 0.01854870f, 0.09289520f, 0.12732373f, 0.15962546f, 0.04436757f, 0.02119811f, 0.01664087f, 
    -0.01573480f, 0.01206516f, -0.00745806f, 0.05336962f, 0.08126852f, 0.01439084f, -0.05403674f, 0.12354092f, 
    -0.19314046f, -0.04252993f, 0.21710479f, 0.01726358f, -0.17034514f, -0.05128220f, 0.04240147f, 0.03852009f, 
    -0.03418807f, 0.04160601f, -0.00251186f, 0.06918499f, 0.09763299f, -0.18041055f, 0.14357139f, 0.21330683f, 
    0.02142107f, 0.04579085f, -0.05357315f, -0.00082523f, -0.03144887f, -0.01620090f, 0.00916769f, 0.01221102f, 
    0.12906630f, 0.03177305f, 0.02247371f, 0.18707447f, -0.06546021f, 0.09975026f, 0.05127954f, 0.06660486f, 
    -0.16591731f, 0.00212111f, -0.01851446f, -0.04692553f, -0.08480551f, -0.19717009f, 0.12344312f, 0.05319183f, 
    0.06968980f, -0.09732348f, -0.09543931f, 0.02302891f, 0.05409557f, -0.01652632f, -0.01243293f, 0.02756127f, 
    -0.19421421f, 0.01815364f, 0.07984135f, 0.02571410f, -0.05427867f, 0.00539532f, 0.00406481f, -0.05295071f, 
    0.10612803f, -0.06530914f, -0.05442097f, 0.03946879f, 0.13392520f, -0.28972107f, 0.14202923f, -0.19636510f, 
    -0.02102670f, -0.03437686f, 0.12021975f, 0.12162724f, -0.00739038f, -0.07026264f, -0.06500877f, -0.09215292f, 
    0.31745201f, -0.01203429f, 0.05939496f, 0.03616619f, -0.01758461f, -0.08693968f, -0.05727706f, 0.07097582f, 
    -0.16750924f, -0.04945489f, 0.01016596f, -0.00765368f, 0.05137968f, -0.03055426f, -0.12075213f, 0.34772480f, 
    0.01195115f, -0.17015365f, 0.04177172f, -0.04239355f, -0.04359554f, -0.02601469f, 0.01866003f, -0.05369747f, 
    0.41649929f, 0.02455581f, -0.03556495f, 0.04262386f, -0.17464148f, 0.01354132f, -0.06578208f, -0.07164862f, 
    -0.23482385f, 0.01246942f, -0.17351209f, -0.05074375f, 0.10972265f, 0.03620145f, 0.05078081f, 0.06028577f, 
    -0.08446120f, -0.04592009f, 0.04619073f, 0.00263928f, -0.05374390f, -0.06718421f, -0.08164722f, -0.07482664f, 
    0.05649133f, 0.12117440f, 0.15986086f, 0.10736364f, -0.13439544f, -0.02542861f, -0.01424497f, 0.04723988f, 
    -0.03608413f, 0.01583799f, 0.00579741f, 0.12577793f, 0.28652185f, 0.02517734f, 0.04505649f, 0.08069398f, 
    0.16432548f, 0.06741828f, -0.02968438f, -0.08042543f, 0.06055649f, -0.03284075f, 0.07376221f, 0.02580297f, 
    -0.12610333f, 0.16558573f, -0.05793961f, 0.01585369f, 0.08108582f, 0.02345380f, 0.03187220f, 0.09710044f, 
    0.08521341f, 0.02068583f, 0.05281375f, 0.14581794f, 0.05497772f, 0.11372745f, 0.03654268f, 0.11913722f, 
    -0.01113892f, 0.10202711f, -0.02887814f, -0.01711708f, 0.10404442f, 0.08059371f, -0.01204859f, -0.03866868f, 
    -0.14850849f, -0.03698613f, 0.03981977f, 0.11140254f, 0.08144856f, -0.02106131f, 0.03781757f, 0.12865041f, 
    -0.06289432f, -0.00370579f, -0.03701836f, 0.04529168f, -0.05309477f, 0.18329424f, -0.08388495f, -0.01062224f, 
    0.14953940f, -0.00952600f, -0.04327293f, -0.07716858f, -0.01188854f, 0.09016872f, 0.05446173f, -0.01961353f, 
    0.11968637f, 0.09780922f, 0.14802548f, 0.02648513f, -0.01132103f, -0.01465048f, 0.02222270f, 0.00442156f, 
    -0.10115061f, -0.05026414f, 0.02313750f, -0.00440506f, -0.09206868f, 0.15460275f, 0.11284047f, 0.07131080f, 
    0.00031503f, 0.11674547f, 0.15572290f, -0.07469795f, -0.18031873f, 0.06466962f, -0.04434374f, -0.11468404f, 
    -0.13834044f, 0.02101001f, 0.10726190f, -0.03902293f, -0.01471594f, -0.07173327f, -0.01222239f, -0.05410991f, 
    0.05030381f, -0.04890641f, 0.17937064f, -0.02287733f, -0.36020544f, -0.08842253f, -0.02359819f, 0.04982509f, 
    0.08811478f, -0.07585271f, -0.04685944f, -0.01640370f, 0.12257475f, 0.08172245f, 0.10405113f, 0.00591915f, 
    -0.37278530f, 0.09975713f, -0.19587329f, -0.14731652f, 0.10332472f, 0.04303917f, 0.04601638f, 0.01509594f, 
    -0.02091061f, 0.09146252f, -0.06825905f, 0.08620104f, 0.01914304f, 0.34708235f, -0.06890307f, 0.02496360f, 
    0.13372754f, 0.01062175f, 0.06067799f, -0.05090453f, 0.05337283f, 0.09640272f, 0.13729745f, 0.08837150f, 
    -0.30594900f, -0.16689204f, -0.15513125f, 0.12696528f, 0.08773924f, 0.06513298f, -0.03810919f, 0.02211916f, 
    -0.02032962f, -0.05159399f, -0.00180567f, 0.01825284f, 0.28003332f, -0.00133806f, 0.16232093f, -0.13419917f, 
    0.09139181f, -0.03816787f, -0.00342227f, -0.04790360f, 0.05735243f, 0.10859423f, 0.04001458f, -0.12216367f, 
    -0.27408057f, 0.14656347f, 0.00790265f, 0.16856651f, 0.01153134f, -0.02313482f, 0.12835290f, 0.02734028f, 
    0.05126140f, 0.03689988f, -0.06445756f, -0.03202094f, -0.01226625f, -0.18049791f, -0.05304791f, 0.09087201f, 
    -0.01462575f, -0.02138606f, -0.00444017f, 0.06423259f, -0.04178737f, -0.00428092f, -0.02074396f, -0.06483231f, 
    0.16849957f, 0.11078476f, 0.09081170f, -0.10138255f, -0.05767940f, 0.01368894f, 0.04683333f, -0.00744465f, 
    -0.03050181f, -0.05385509f, 0.13315406f, -0.00106400f, 0.28086296f, 0.21769340f, -0.02804188f, 0.12034885f, 
    -0.05677082f, -0.06623954f, -0.00510264f, -0.00183022f, 0.05062195f, -0.02795682f, -0.03050037f, 0.02064236f, 
    0.04833101f, 0.16956519f, 0.27031133f, -0.10604711f, -0.07387078f, 0.10960246f, -0.00138605f, -0.06421844f, 
    0.03128591f, 0.02384243f, 0.02026422f, 0.03813325f, -0.25307614f, 0.01879863f, 0.12171791f, -0.04241940f, 
    0.10227144f, 0.11074374f, 0.00549055f, -0.04278785f, 0.03013904f, 0.02510515f, 0.01054070f, 0.03353018f, 
    -0.13412248f, -0.21752514f, 0.11525986f, 0.05949746f, 0.14809015f, 0.07377001f, 0.05459932f, 0.03886823f, 
    0.06861151f, -0.03401850f, 0.10449875f, 0.13402970f, 0.23206350f, 0.17461376f, 0.03885490f, 0.14709644f, 
    0.07220637f, 0.00559858f, 0.06318674f, 0.01649930f, 0.01079255f, 0.06184787f, -0.03857139f, 0.08107108f, 
    -0.05753744f, 0.14020126f, 0.25012505f, -0.01814335f, -0.06346844f, -0.02836113f, 0.06434407f, -0.00967306f, 
    0.11365727f, 0.10126760f, 0.05651069f, 0.03240943f, -0.18083689f, -0.11627085f, -0.10211906f, 0.16175720f, 
    0.08910882f, -0.05050149f, -0.02394297f, -0.02486976f, 0.02479866f, 0.00923578f, 0.02383404f, -0.02159681f, 
    0.02328414f, 0.03125669f, -0.08456127f, -0.02532043f, -0.02193209f, 0.06655376f, 0.04308847f, 0.04134570f, 
    -0.07526141f, 0.03158770f, -0.02045078f, -0.01802292f, -0.07546052f, -0.16645384f, -0.18465230f, -0.04386140f, 
    -0.02167061f, 0.00264248f, -0.03803096f, -0.01335558f, 0.03168078f, -0.00897613f, 0.01156374f, -0.03619273f, 
    0.07205621f, 0.05197945f, 0.09356311f, 0.12765566f, -0.11401728f, -0.01009297f, -0.00092696f, -0.02954773f, 
    0.05219469f, -0.08786649f, 0.02094348f, 0.03424823f, 0.10251747f, -0.10610752f, 0.18719158f, -0.15868430f, 
    -0.05817848f, -0.05673717f, 0.02245640f, 0.12384817f, -0.08211622f, -0.09371661f, -0.06208667f, 0.01633435f, 
    -0.04783003f, 0.02574609f, -0.09608028f, 0.07089165f, 0.03121966f, 0.01381318f, -0.04241771f, 0.03392549f, 
    -0.02047896f, 0.01592427f, -0.00663638f, -0.01236255f, 0.25422588f, 0.08022024f, 0.10513941f, 0.11186899f, 
    -0.06299280f, -0.06744785f, -0.10697497f, 0.00979392f, 0.05286310f, -0.01456921f, 0.01155394f, -0.01491422f, 
    0.03115843f, 0.09015979f, 0.00810947f, 0.07765993f, -0.00373026f, -0.07864346f, 0.01736076f, -0.07180460f, 
    -0.07230904f, -0.01040788f, -0.01506337f, -0.01641880f, 0.08894709f, 0.07315791f, 0.07946460f, -0.02878293f, 
    -0.07016657f, -0.07853564f, 0.01118391f, 0.01343038f, 0.01498743f, -0.13775870f, -0.07963362f, -0.09839980f, 
    0.11526337f, 0.07867754f, 0.08228882f, 0.06071047f, -0.08249576f, 0.06497414f, -0.04345418f, 0.02824915f, 
    -0.02488316f, 0.05588327f, 0.00528911f, 0.00941236f, -0.04289800f, 0.05166483f, -0.04456395f, 0.06995630f, 
    0.22677097f, 0.01761295f, 0.01301652f, 0.02392753f, -0.00159769f, -0.01343082f, 0.04412201f, -0.02086382f, 
    -0.28714541f, 0.02111436f, 0.01501260f, 0.11777376f, 0.10323334f, 0.09410402f, 0.07643812f, 0.26189330f, 
    0.19262266f, -0.01630475f, 0.09361701f, 0.06762225f, -0.11304510f, 0.21521705f, 0.02214321f, 0.14096685f, 
    0.03268720f, -0.08361199f, 0.01089722f, 0.01726204f, 0.06657476f, 0.06778072f, -0.08721682f, 0.13365495f, 
    -0.39849952f, -0.33753172f, -0.03511301f, -0.01332352f, 0.20935628f, -0.01285608f, 0.05145165f, 0.10558496f, 
    0.05840054f, 0.02448543f, 0.03177558f, -0.02197553f, -0.01487197f, -0.16876200f, 0.01594199f, -0.11717069f, 
    0.17774497f, 0.03718122f, -0.04475580f, 0.03896930f, 0.03523565f, 0.05842991f, 0.08923452f, -0.00234748f, 
    0.15736514f, 0.17231999f, 0.01637963f, 0.08877179f, 0.09097174f, -0.01164081f, 0.01639630f, 0.14641427f, 
    -0.02977610f, -0.02664626f, 0.00527057f, -0.00222548f, -0.17787290f, 0.02658954f, 0.14096932f, -0.04133817f, 
    -0.04442605f, 0.10940108f, 0.04895385f, 0.00502828f, -0.03049984f, 0.01114545f, -0.00595699f, 0.05590785f, 
    0.04383864f, 0.00061945f, -0.00838328f, -0.03681694f, 0.01714094f, -0.00342495f, 0.00529797f, -0.03994415f, 
    0.03966976f, -0.03368294f, -0.01038612f, 0.02616525f, -0.01783949f, -0.01999530f, 0.00924096f, -0.01585103f, 
    -0.04835461f, 0.04048608f, 0.00355998f, -0.05202032f, 0.01535102f, -0.03854103f, -0.05625350f, -0.03973499f, 
    0.02781771f, 0.02965615f, -0.02533947f, -0.05653646f, 0.04922384f, 0.02869515f, -0.00776837f, -0.03577329f, 
    -0.04578939f, 0.01845920f, -0.04822080f, -0.05170303f, -0.00939362f, 0.01477946f, 0.02792066f, 0.00583898f, 
    0.00651877f, -0.02544691f, -0.03776717f, 0.00090101f, -0.04132592f, 0.03771714f, 0.01556114f, 0.01406405f, 
    -0.03957373f, -0.03684615f, 0.02805130f, 0.01489442f, -0.02502122f, -0.00788362f, -0.01845470f, -0.03915291f, 
    -0.00657860f, -0.04614993f, -0.05854343f, -0.04914364f, -0.00531894f, 0.01329561f, 0.04114051f, 0.01279355f, 
    -0.01994459f, -0.02584814f, -0.01514084f, 0.00785850f, -0.02846969f, 0.02861040f, -0.05629724f, -0.04594958f, 
    -0.03154455f, 0.04146791f, 0.03303641f, -0.02461811f, -0.02685322f, -0.01749773f, -0.00329087f, 0.01254230f, 
    0.00941292f, 0.00103793f, 0.04056646f, 0.00248740f, 0.02125087f, -0.04776158f, -0.00136171f, -0.01032385f, 
    -0.03582791f, 0.01998631f, 0.03258210f, -0.03615942f, 0.00936364f, -0.05361653f, -0.03006925f, 0.01428830f, 
    -0.03471675f, -0.04039372f, 0.03003537f, -0.01269504f, -0.04420103f, 0.00398120f, -0.00952501f, -0.05306250f, 
    0.01717112f, -0.01339816f, 0.03032974f, 0.03582961f, -0.03968489f, 0.00585313f, 0.00743011f, -0.04282773f, 
    -0.01840235f, -0.03789831f, 0.04245351f, -0.00961265f, 0.02266919f, -0.01745123f, 0.00820881f, 0.03081591f, 
    -0.03624062f, -0.01125517f, 0.03219598f, 0.03276769f, -0.01513924f, 0.01871362f, 0.03900823f, -0.00096878f, 
    -0.05387419f, -0.05920604f, -0.05812259f, -0.01933475f, 0.03225261f, 0.01276544f, -0.01206862f, -0.01320238f, 
    -0.05433504f, -0.01550974f, -0.01789397f, -0.02684546f, 0.01510988f, -0.01933001f, -0.03112787f, -0.04718924f, 
    0.02785163f, -0.05162047f, -0.05339653f, 0.01022208f, -0.01988244f, -0.00069239f, 0.02575931f, -0.00271063f, 
    -0.02691950f, -0.00367184f, -0.04690418f, 0.02691466f, -0.01167735f, 0.04221774f, 0.02300453f, -0.02195179f, 
    -0.04069347f, 0.03405509f, 0.01525129f, -0.01296978f, 0.00710128f, 0.04246825f, 0.01785448f, -0.03298200f, 
    -0.00000307f, -0.04283317f, -0.01377654f, 0.03429546f, -0.01164456f, 0.02567714f, -0.00606908f, -0.00445183f, 
    0.01934642f, 0.03376625f, 0.02681167f, -0.00894152f, -0.02644357f, 0.00693046f, -0.02234234f, 0.02852711f, 
    -0.02538083f, -0.05025297f, 0.02493810f, 0.01461932f, 0.04578979f, 0.03482792f, 0.01174999f, 0.01839643f, 
    0.01588548f, -0.04549558f, 0.02707551f, 0.01964042f, -0.03710128f, -0.04917997f, 0.00302233f, -0.00855178f, 
    -0.02137368f, -0.00576891f, 0.04025140f, 0.02571519f, 0.04678053f, -0.00671551f, 0.01690084f, 0.02340614f, 
    -0.03384069f, -0.01923937f, -0.00940898f, -0.02369012f, -0.02103420f, 0.04766057f, 0.00754563f, -0.03969221f, 
    -0.01179371f, -0.04219359f, -0.04779575f, 0.02596893f, 0.02413021f, -0.00226855f, -0.04624915f, -0.01451719f, 
    -0.05965369f, -0.01968974f, -0.03420603f, -0.00426621f, -0.03580663f, 0.01240559f, 0.03553281f, -0.01571889f, 
    0.01531736f, 0.03335521f, -0.01617864f, 0.00969879f, -0.01967385f, 0.02117554f, -0.02355686f, 0.03179491f, 
    -0.01202753f, -0.04743947f, 0.00211228f, -0.00863033f, -0.02812336f, -0.04788296f, -0.03743424f, 0.02718790f, 
    -0.01767198f, -0.02273878f, -0.00166594f, 0.00071060f, -0.05343126f, -0.03455455f, -0.01701351f, 0.02015249f, 
    0.00527505f, -0.03246845f, -0.03892747f, -0.01726050f, -0.04081716f, -0.02275161f, -0.05337429f, -0.02771175f, 
    -0.04213770f, -0.05942150f, -0.02039339f, 0.02384433f, 0.00369999f, 0.03987486f, -0.01269243f, -0.02330514f, 
    0.00158032f, -0.00484235f, -0.00179219f, 0.02029467f, -0.02085341f, 0.03610575f, 0.03490295f, 0.02913623f, 
    -0.02821402f, -0.02454593f, 0.02305817f, -0.01285410f, -0.04652659f, -0.02072907f, -0.00675558f, 0.02057510f, 
    -0.06012526f, 0.00896702f, -0.01083123f, 0.04130007f, 0.02594526f, -0.03706936f, 0.01644424f, -0.02706040f, 
    0.00876129f, 0.00914566f, 0.00589827f, -0.04186990f, -0.04763694f, -0.04048663f, -0.02892851f, -0.01342100f, 
    -0.00895881f, -0.05510749f, 0.02794053f, 0.01976039f, 0.02777873f, 0.00393890f, 0.02939468f, -0.04858558f, 
    -0.02974253f, 0.00346733f, 0.04171626f, 0.02965866f, 0.02345606f, 0.01086336f, -0.04531272f, -0.00591010f, 
    -0.02631680f, -0.01746394f, -0.05542162f, -0.00381159f, 0.03398049f, -0.05520678f, 0.02548825f, -0.02993826f, 
    0.03466545f, -0.00567317f, -0.02313412f, 0.01968422f, -0.01452140f, 0.01908623f, 0.02687042f, 0.02332187f, 
    0.01749421f, -0.03532106f, 0.00363755f, 0.00940484f, 0.02898457f, -0.03374404f, 0.03215355f, -0.00784200f, 
    0.00950708f, -0.03097172f, 0.03795744f, -0.00200246f, 0.01663089f, -0.00800848f, -0.01582735f, 0.01715621f, 
    -0.05298317f, -0.01840561f, 0.01429247f, 0.04198076f, -0.02165600f, -0.03262294f, -0.00059796f, 0.01232671f, 
    -0.03175987f, 0.01445922f, -0.05155381f, 0.01332582f, 0.02617847f, 0.04274503f, -0.00971224f, -0.02744719f, 
    -0.04600589f, 0.01364948f, -0.04247589f, 0.03459022f, 0.03843847f, 0.03220153f, -0.05924845f, -0.00416203f, 
    0.02634767f, -0.00054037f, -0.04062537f, -0.00000890f, -0.04958468f, 0.02017478f, -0.01452842f, -0.01115017f, 
    0.00728450f, 0.00926419f, 0.02188858f, 0.00877639f, 0.00634285f, 0.01090070f, -0.00412771f, -0.02590471f, 
    0.03761106f, -0.02913934f, 0.00634919f, -0.01029906f, -0.03697121f, -0.00271430f, -0.05395961f, -0.04675025f, 
    0.01563424f, -0.00542816f, 0.01462779f, -0.03295231f, -0.05181384f, -0.04852901f, -0.03918545f, -0.04960047f, 
    -0.03814146f, -0.02047620f, 0.03464931f, -0.05275281f, 0.00166156f, 0.03933895f, -0.03936558f, -0.02009440f, 
    0.03871515f, 0.01568931f, -0.04503690f, -0.02521681f, 0.00890578f, 0.00015290f, 0.00358711f, 0.01336082f, 
    -0.00154557f, -0.04608828f, 0.00481902f, -0.00420347f, -0.00082974f, -0.04199834f, -0.00511219f, 0.00158431f, 
    0.01454401f, 0.02920938f, -0.03180780f, -0.01395153f, -0.02350445f, -0.00376034f, 0.04354092f, -0.03642212f, 
    0.00923050f, -0.00815254f, 0.04228203f, -0.04861983f, 0.04325691f, -0.02340560f, 0.00311710f, -0.03231598f, 
    -0.03782657f, -0.03841029f, 0.03764937f, -0.03129303f, 0.03745453f, -0.04481018f, 0.02747693f, -0.03212279f, 
    -0.02821420f, -0.04903610f, -0.04129509f, 0.03052019f, -0.00954411f, 0.03349881f, 0.00155969f, -0.05651381f, 
    0.04108315f, -0.03002211f, -0.04635316f, -0.03640292f, 0.01925323f, 0.01091228f, 0.04266061f, -0.00720849f, 
    -0.04039642f, -0.00790559f, 0.03073872f, 0.01186884f, 0.01470782f, -0.02390203f, -0.00937437f, 0.04881259f, 
    -0.02757999f, 0.01662515f, -0.04598954f, 0.02233846f, -0.03089465f, 0.01272421f, -0.04691222f, 0.03611533f, 
    0.02558763f, 0.02331375f, 0.00043579f, -0.02755646f, -0.05089580f, -0.01356005f, -0.03967582f, 0.00294439f, 
    -0.01974441f, -0.04815586f, -0.02020433f, -0.01283365f, 0.04078866f, -0.05046358f, -0.03161997f, -0.00811262f, 
    -0.04367595f, 0.00623381f, -0.02658342f, 0.03841806f, 0.00249761f, 0.03008456f, -0.00949207f, 0.01793157f, 
    -0.01755111f, -0.05192746f, 0.01883191f, -0.00288156f, 0.02845124f, -0.01489631f, -0.03360686f, -0.04092237f, 
    -0.03502005f, 0.02064760f, -0.03612401f, -0.04531715f, -0.04169456f, -0.04203688f, 0.02775157f, 0.00321553f, 
    -0.04925203f, -0.04328696f, -0.02287150f, -0.04805160f, 0.02528999f, 0.02214185f, -0.02311835f, -0.04443670f, 
    -0.03973081f, 0.01209438f, -0.03551555f, 0.00843829f, -0.03785850f, -0.03890056f, 0.00327523f, -0.04483740f, 
    -0.00094701f, -0.01617358f, -0.00048709f, -0.03269905f, -0.00896107f, 0.02586096f, 0.00416786f, 0.03715212f, 
    0.03948488f, 0.00336611f, 0.02882806f, 0.01856249f, 0.02949198f, 0.03403433f, 0.02745971f, -0.01938822f, 
    -0.02017847f, -0.01286555f, -0.02846390f, 0.03638279f, -0.04717724f, 0.03267427f, 0.00009689f, -0.00639916f, 
    -0.02488699f, 0.01030612f, 0.01179472f, 0.01422560f, -0.04491981f, -0.03478541f, -0.03030584f, 0.00271235f, 
    0.02700723f, -0.03911452f, 0.00218319f, -0.03896124f, -0.03740770f, 0.02370144f, 0.00967654f, -0.04760591f, 
    -0.03219443f, 0.02552724f, 0.04490229f, 0.02042641f, -0.04661904f, -0.01278088f, 0.03217846f, 0.01796717f, 
    -0.01563986f, -0.02157385f, -0.01648267f, -0.00096715f, -0.02680063f, 0.02669883f, -0.02572240f, -0.00698760f, 
    -0.00924849f, -0.02888620f, -0.04538022f, -0.01624084f, -0.02465403f, -0.00939427f, -0.00544410f, -0.01626748f, 
    -0.03225666f, 0.03622029f, 0.00248686f, -0.05009331f, 0.00606301f, -0.01128845f, -0.05084151f, -0.00979649f, 
    0.04552181f, -0.01208893f, -0.03693923f, -0.01133094f, -0.05313077f, -0.01929757f, -0.00937846f, 0.03907780f, 
    -0.01756241f, -0.02598433f, -0.04697876f, -0.03079991f, 0.03707059f, 0.04507428f, 0.00936360f, 0.00095418f, 
    -0.01931630f, -0.02866690f, -0.01421047f, 0.01661927f, 0.02786628f, 0.02433911f, -0.02181871f, -0.00134918f, 
    -0.00768275f, -0.00216527f, -0.01947368f, 0.04372470f, -0.03555294f, -0.05056357f, -0.00822851f, 0.01161237f, 
    -0.02208793f, 0.02434024f, 0.03506949f, 0.01352826f, -0.02446622f, -0.03004164f, -0.02354114f, 0.00729553f, 
    -0.03381838f, -0.02125409f, -0.01672581f, -0.04686454f, 0.04245379f, -0.05613212f, -0.04199325f, -0.03283614f, 
    0.03791692f, -0.03354343f, 0.02227515f, 0.02816218f, -0.03112857f, 0.03210328f, 0.03602797f, 0.03720436f, 
    0.02205678f, -0.04128011f, -0.02103661f, -0.00606234f, -0.00838949f, 0.01896326f, -0.02914539f, -0.05278467f, 
    -0.05487974f, -0.01548447f, 0.02841032f, -0.03863951f, 0.02989516f, 0.02214488f, -0.02726110f, -0.00664486f, 
    0.00936618f, -0.05077022f, 0.03686792f, -0.03314706f, 0.01386057f, 0.03421998f, -0.00353147f, -0.00663951f, 
    0.03005361f, 0.02801027f, 0.02302795f, 0.01442233f, -0.03426842f, -0.03198451f, 0.02070608f, 0.04331023f, 
    -0.05444187f, -0.01310954f, 0.01710166f, 0.03084878f, -0.01657142f, 0.02605657f, -0.05154769f, 0.00918829f, 
    0.00254046f, -0.02080943f, -0.02924334f, 0.02575180f, 0.00072903f, -0.04191679f, -0.01797604f, -0.01582882f, 
    0.00541580f, -0.02261028f, 0.02390949f, -0.05558402f, -0.00703725f, -0.02981311f, -0.03184414f, -0.03521838f, 
    -0.05230140f, 0.03827375f, -0.00926232f, -0.04402911f, 0.02743985f, -0.00610439f, -0.05513538f, 0.00797950f, 
    0.00786340f, 0.01038648f, 0.03462685f, -0.04038482f, 0.00025727f, -0.04556841f, 0.02416751f, -0.01974268f, 
    0.02445007f, -0.00790238f, -0.03968653f, -0.01094218f, 0.02457858f, -0.01390831f, -0.03168359f, 0.03396694f, 
    -0.00722776f, -0.01636091f, 0.00179412f, 0.03441465f, 0.04340258f, -0.01083362f, -0.02449044f, -0.01170246f, 
    0.01380310f, -0.04216994f, 0.03862264f, -0.00826837f, -0.03746857f, 0.00298658f, -0.00858674f, 0.01294404f, 
    -0.13569631f, -0.10177597f, 0.22130340f, 0.12868951f, 0.04900284f, -0.04520356f, -0.05404326f, -0.06018125f, 
    0.04051419f, -0.00230882f, -0.08550504f, -0.12056291f, 0.02859265f, 0.07879914f, 0.10150649f, 0.24352938f, 
    -0.17129281f, 0.04800557f, 0.07444862f, -0.00867612f, -0.01231725f, 0.03227391f, -0.01690352f, -0.06232505f, 
    0.01072457f, -0.04180940f, -0.03090430f, -0.12070142f, 0.13372508f, 0.03496800f, -0.06131108f, 0.17052871f, 
    0.01453296f, -0.03467536f, 0.15300570f, 0.12564756f, 0.16778870f, -0.10189387f, -0.19906436f, 0.17073900f, 
    -0.00370111f, 0.06329919f, 0.09816027f, 0.01392773f, 0.01223886f, -0.06031279f, 0.07602996f, 0.08379558f, 
    -0.12430058f, -0.11898711f, -0.11635039f, -0.07655472f, 0.00490698f, 0.01959997f, -0.02815260f, 0.04965960f, 
    0.01665904f, 0.09421179f, -0.07627317f, 0.03459391f, -0.19198883f, 0.12098651f, 0.06289879f, 0.00320555f, 
    -0.03101733f, 0.04285737f, 0.06618155f, 0.11097676f, 0.06661735f, -0.08296440f, 0.05479436f, -0.11416974f, 
    0.11131541f, 0.10873312f, 0.06432230f, 0.09815448f, -0.01095402f, 0.05087170f, 0.06183164f, 0.04700191f, 
    -0.00210506f, 0.08276279f, 0.17256770f, 0.15263970f, 0.03825753f, 0.02351513f, -0.00515385f, 0.00264525f, 
    -0.08221215f, 0.08444019f, -0.00589483f, 0.09516706f, 0.04756217f, 0.03400534f, 0.08361432f, -0.00919714f, 
    -0.17675251f, 0.16745362f, 0.07830279f, 0.01272483f, -0.09563731f, 0.10715809f, 0.05245477f, -0.01105126f, 
    0.08976570f, 0.06214271f, -0.06181850f, -0.06995545f, 0.15961814f, -0.01074243f, -0.02128743f, 0.08876932f, 
    -0.01714422f, 0.02077818f, -0.01010698f, 0.11169303f, -0.03386553f, 0.07996606f, -0.02205050f, 0.00409913f, 
    0.03573387f, 0.06463532f, 0.11024761f, -0.00469988f, 0.04447531f, -0.12214953f, -0.10202891f, 0.09717999f, 
    -0.06209993f, -0.03513748f, -0.06040866f, -0.08197418f, -0.09335411f, -0.01521731f, -0.01797325f, -0.01565911f, 
    -0.05242654f, 0.06520126f, 0.01651878f, 0.06384911f, -0.04929880f, 0.11572722f, 0.09613995f, 0.06444719f, 
    -0.00091277f, -0.09469200f, 0.06145083f, -0.06341296f, -0.14340615f, -0.13405386f, 0.13749260f, -0.00251335f, 
    -0.01762598f, -0.03598752f, -0.09636619f, -0.00709903f, 0.16503665f, -0.07454681f, -0.02707670f, 0.04973146f, 
    -0.16430837f, 0.03992438f, 0.04892813f, 0.02884882f, 0.05792975f, -0.05842939f, -0.03360615f, -0.01356813f, 
    0.08033559f, -0.10379858f, 0.13507012f, 0.02362344f, -0.03335599f, 0.07176720f, 0.10757107f, 0.03927133f, 
    -0.01756664f, -0.03286095f, -0.10428229f, -0.07253559f, -0.05165250f, 0.15106277f, 0.01449135f, 0.02995342f, 
    -0.00191175f, -0.04775629f, 0.07472179f, 0.05997687f, 0.01808968f, -0.03003439f, -0.04989093f, -0.09297834f, 
    0.16233809f, -0.05605211f, 0.08314095f, 0.02126225f, -0.03819003f, 0.00462170f, -0.07497729f, 0.05078515f, 
    -0.07936085f, 0.12030046f, 0.14022408f, 0.00982610f, -0.37796277f, 0.04740964f, 0.07323285f, 0.07421225f, 
    -0.00900149f, 0.03198826f, 0.02451762f, -0.03027819f, 0.12714617f, 0.01142983f, -0.15570812f, 0.06453297f, 
    -0.29904753f, 0.06903918f, 0.21054111f, 0.00436059f, 0.02170719f, -0.07427675f, 0.06629048f, -0.03693444f, 
    0.00543538f, -0.07682326f, -0.07697981f, 0.00637593f, 0.25820294f, -0.24298133f, 0.03559542f, -0.14167719f, 
    0.04051281f, 0.04157296f, 0.18610215f, 0.05360305f, -0.07778237f, -0.02461672f, -0.04752100f, -0.10833932f, 
    0.02308033f, -0.09092457f, 0.06612147f, 0.03692073f, 0.05552087f, -0.07951540f, 0.05037534f, 0.00827768f, 
    -0.04294619f, 0.00075975f, -0.02730780f, 0.11944965f, 0.00818900f, 0.03401428f, -0.01821767f, 0.09397514f, 
    0.06038735f, -0.08015207f, 0.03146666f, -0.04818049f, 0.05847732f, -0.02748721f, -0.03436301f, -0.00095814f, 
    0.34333366f, -0.14120424f, 0.03383004f, 0.18265408f, -0.05546062f, 0.00592274f, -0.02931990f, 0.04549341f, 
    0.10802820f, 0.04983933f, 0.01785584f, 0.10284913f, 0.08338663f, 0.01970294f, 0.06601202f, 0.08351942f, 
    -0.05906923f, 0.03120421f, -0.08079920f, -0.09810206f, -0.11644376f, 0.09013662f, -0.10375585f, -0.01295553f, 
    0.13973054f, 0.10833273f, 0.15379196f, 0.11323681f, -0.02690410f, 0.04679117f, -0.00230954f, 0.08603393f, 
    -0.00489861f, -0.02891629f, -0.00360712f, 0.08671527f, -0.15518150f, -0.21183512f, -0.06301345f, -0.11223441f, 
    0.07546449f, -0.10629438f, 0.05853175f, -0.03956076f, 0.07632149f, 0.05541229f, 0.20893671f, 0.14641365f, 
    0.06764290f, 0.10152237f, -0.04663749f, -0.06793506f, -0.03293759f, -0.04521452f, -0.05245050f, -0.01494119f, 
    0.02004105f, -0.06217245f, -0.00487360f, 0.03506006f, 0.31249520f, 0.00375523f, 0.00151640f, 0.18944722f, 
    0.01217683f, 0.10068370f, 0.07990766f, 0.05763562f, 0.03119677f, 0.05653226f, 0.07722312f, -0.01124652f, 
    0.00150924f, -0.07126359f, -0.05848172f, 0.01527658f, -0.02679221f, 0.04320429f, -0.04346742f, -0.00494917f, 
    -0.14377365f, -0.01826463f, 0.04549270f, 0.01815010f, -0.09501289f, -0.15563509f, -0.03983869f, -0.11924285f, 
    0.03696202f, -0.03870047f, 0.00375346f, 0.00323571f, 0.09368117f, 0.14519969f, -0.04038720f, 0.02789375f, 
    0.00131502f, 0.09080338f, 0.02796829f, 0.04850888f, -0.03092681f, -0.02185807f, 0.09018674f, 0.13531728f, 
    0.02610356f, 0.13599229f, -0.09442161f, -0.03536876f, 0.21015361f, 0.07331891f, -0.04746537f, -0.05140219f, 
    -0.08558603f, 0.00060469f, 0.14201003f, 0.07010313f, 0.02943894f, 0.05149188f, -0.09090711f, 0.11695476f, 
    -0.10228926f, 0.03626896f, -0.30882925f, 0.00386146f, 0.13342227f, 0.03362032f, 0.00586490f, -0.12925707f, 
    0.04157683f, -0.09528106f, -0.03648918f, 0.01254774f, -0.03392031f, 0.02885316f, -0.10377581f, 0.01577943f, 
    0.15118703f, -0.02896370f, -0.00942685f, 0.02731563f, -0.00406913f, -0.00592408f, 0.04323304f, 0.00873969f, 
    -0.08407225f, 0.17298746f, 0.05009039f, 0.30387473f, -0.06325783f, -0.02767938f, -0.10113906f, -0.00456889f, 
    -0.08287941f, 0.03123095f, 0.03691001f, 0.04711590f, 0.00443235f, 0.08583561f, 0.09228201f, 0.01700351f, 
    0.05082121f, 0.00965303f, -0.00016711f, 0.03076725f, -0.10993208f, 0.06608082f, 0.05858430f, 0.00384929f, 
    0.00078793f, -0.04935971f, 0.10185266f, -0.11301757f, -0.11324880f, -0.14143644f, 0.00248007f, -0.02539188f, 
    -0.12125851f, -0.00975856f, -0.03665766f, 0.11964979f, 0.33424652f, 0.06403984f, -0.05696731f, 0.11817835f, 
    0.11363429f, -0.01459955f, 0.03474089f, 0.06305253f, -0.08535506f, 0.07062724f, 0.00660571f, -0.01791301f, 
    -0.22396955f, -0.07343368f, -0.01841045f, -0.06055696f, 0.00174618f, -0.00968683f, 0.04711134f, -0.04228531f, 
    -0.05151007f, 0.05237177f, 0.00030692f, 0.13236064f, -0.13075066f, -0.12418780f, -0.10573392f, 0.20280457f, 
    -0.07594941f, -0.05428404f, -0.01140105f, 0.08304242f, 0.02107098f, 0.02218161f, 0.03993814f, 0.04817653f, 
    0.19259936f, -0.21137837f, -0.15140906f, -0.23020625f, 0.13850215f, 0.06688442f, 0.06176931f, -0.12231751f, 
    -0.07602384f, -0.02567622f, 0.00831654f, -0.00617914f, 0.18730333f, 0.06546997f, -0.00560516f, -0.06867148f, 
    -0.04056221f, 0.06130511f, 0.11322560f, 0.03824840f, -0.07138554f, 0.12670930f, 0.03114170f, -0.08091892f, 
    0.27614927f, 0.02324129f, 0.09459385f, -0.27438310f, 0.10839164f, 0.05297177f, 0.07632661f, -0.08568176f, 
    0.04211114f, -0.08141243f, 0.02353395f, 0.01203067f, 0.35984164f, 0.08088216f, -0.01633546f, 0.02542535f, 
    -0.05389630f, -0.02463786f, -0.06314790f, 0.14560024f, -0.04196128f, 0.05272836f, 0.06754511f, -0.04619117f, 
    -0.39659527f, -0.00343114f, -0.15760353f, -0.07392038f, -0.06383272f, -0.01027536f, -0.09356532f, 0.12460506f, 
    0.00943188f, -0.05053726f, -0.01651305f, 0.05849256f, -0.02079518f, 0.15520526f, -0.00798330f, 0.09800161f, 
    0.12244686f, 0.10259426f, -0.00940190f, 0.00858953f, -0.00008610f, -0.04647921f, -0.02035469f, 0.05713717f, 
    -0.22605674f, 0.14665867f, -0.07071302f, -0.13503683f, 0.12286515f, -0.05296093f, 0.02214373f, 0.02474038f, 
    -0.08434529f, 0.11371095f, 0.03768060f, -0.15968524f, -0.24045493f, -0.18062721f, -0.23046842f, 0.11050195f, 
    -0.04877290f, 0.03548398f, -0.02290515f, -0.06857397f, -0.03935111f, 0.07088387f, 0.06912495f, 0.03521072f, 
    -0.18679936f, -0.02849889f, -0.03020186f, -0.23791102f, -0.02023483f, 0.05899283f, 0.02438826f, 0.07614522f, 
    -0.00304374f, 0.04877734f, -0.07114996f, 0.13292445f, 0.39051384f, -0.09110206f, -0.05826177f, 0.00607218f, 
    -0.08581393f, -0.03600002f, 0.03716989f, -0.02240783f, -0.08231881f, 0.08836716f, -0.07584115f, -0.01361093f, 
    0.30010444f, -0.00523464f, -0.11900791f, 0.00057215f, -0.12167584f, 0.08408619f, -0.03699956f, 0.02242809f, 
    0.02143345f, -0.04349008f, 0.05536987f, -0.01667135f, -0.05730863f, 0.27681768f, 0.20072688f, -0.03549472f, 
    -0.05010546f, -0.04240286f, 0.01914888f, -0.00364136f, -0.03845964f, 0.02587286f, -0.00745122f, 0.08983654f, 
    -0.13308403f, 0.11950827f, -0.11078632f, -0.23492855f, 0.15050849f, -0.00556626f, 0.05417093f, -0.08122502f, 
    0.12561464f, 0.11295365f, -0.06662372f, -0.09297089f, -0.26422617f, -0.08648430f, -0.19128928f, -0.10412522f, 
    -0.08166157f, 0.06415354f, 0.02236175f, -0.04141112f, 0.02229782f, -0.00559207f, 0.12843645f, -0.00450590f, 
    -0.03045292f, 0.08553035f, -0.10378996f, -0.14825092f, 0.08720355f, 0.00592266f, 0.10587047f, -0.00308591f, 
    0.00114630f, 0.13856257f, 0.07593339f, -0.05416932f, 0.20671250f, 0.04523234f, 0.04380281f, 0.04814903f, 
    0.07481305f, 0.04016931f, -0.00646260f, -0.05207273f, -0.09452898f, -0.02126393f, 0.02583965f, 0.12081932f, 
    -0.08436299f, -0.22593851f, -0.02094179f, -0.00690861f, 0.14222366f, 0.03691682f, -0.01890109f, -0.01962990f, 
    0.10826219f, 0.04020071f, -0.04788706f, 0.02288383f, -0.12599607f, 0.17132726f, 0.18389598f, 0.34478700f, 
    -0.18673642f, -0.05589599f, -0.01576033f, 0.14066675f, -0.03576537f, 0.00829708f, -0.10990737f, -0.05053082f, 
    -0.09059507f, 0.06566209f, -0.01289423f, -0.11556681f, -0.13811323f, -0.11502095f, 0.02778575f, 0.03297849f, 
    0.07212275f, -0.02282103f, -0.04259156f, -0.04208598f, -0.04222840f, 0.03568295f, 0.10918195f, 0.09113702f, 
    0.02507544f, -0.09245732f, -0.01365989f, -0.08795716f, -0.02210425f, -0.03366976f, 0.00743581f, 0.06987235f, 
    0.06540550f, 0.07755405f, 0.27141199f, -0.04698146f, -0.15418123f, -0.06094930f, -0.05060962f, 0.11417928f, 
    0.05646670f, -0.03810225f, 0.01764476f, 0.00128270f, 0.09185548f, 0.10483602f, 0.13703386f, 0.20534012f, 
    -0.13626309f, -0.14905617f, 0.12624595f, 0.14758880f, -0.17556047f, 0.04471070f, 0.13690250f, -0.10564748f, 
    0.16140981f, 0.03591387f, 0.02428820f, 0.12941067f, 0.10744829f, -0.02168757f, 0.04480733f, 0.00416312f, 
    -0.06434608f, -0.05142441f, 0.00672351f, 0.06043975f, 0.19816647f, 0.13044462f, -0.01699610f, -0.00699267f, 
    0.08063195f, -0.02901988f, -0.13762593f, -0.05631479f, 0.07743616f, 0.07155757f, 0.00173385f, 0.04409793f, 
    -0.00717812f, -0.03171231f, 0.04175363f, 0.02586411f, -0.03659866f, 0.00107556f, -0.04332476f, -0.03439960f, 
    -0.02964863f, -0.03740514f, 0.00442662f, -0.02613235f, 0.00867603f, 0.00675140f, 0.02177523f, 0.02321125f, 
    0.03411762f, 0.01691811f, -0.00820032f, -0.03136372f, -0.01999666f, -0.03780713f, -0.03339734f, -0.00525904f, 
    0.03936689f, 0.03704012f, 0.05068385f, 0.03610612f, 0.00779500f, 0.02283517f, -0.05055567f, -0.02508177f, 
    -0.03146545f, -0.00521000f, -0.00075147f, -0.05452103f, -0.00444237f, 0.00845281f, 0.02986926f, 0.03836295f, 
    -0.05388701f, 0.00775397f, -0.02539151f, 0.04138606f, -0.03287764f, -0.02864141f, -0.02141255f, 0.03452558f, 
    0.00403431f, -0.03546404f, -0.04127366f, 0.01590628f, -0.01327925f, -0.01847837f, -0.01863351f, -0.01343809f, 
    -0.05015802f, -0.05202965f, -0.00296708f, -0.00271619f, -0.04232960f, -0.03709081f, -0.05298769f, 0.04437692f, 
    -0.05336321f, 0.00725529f, -0.02317427f, 0.02739989f, 0.00176224f, -0.04708197f, 0.00689709f, -0.02822414f, 
    -0.01597830f, 0.01992894f, -0.05209894f, -0.04861804f, -0.03829467f, -0.02217928f, 0.01325563f, 0.02834604f, 
    0.01034456f, 0.04129428f, -0.00188327f, 0.02817336f, -0.00140512f, 0.03692383f, -0.03788601f, -0.02467406f, 
    -0.02516065f, -0.03856156f, 0.03130584f, -0.00438290f, 0.01817961f, 0.01347187f, 0.02751131f, -0.03231009f, 
    -0.03484767f, 0.01923830f, -0.01458302f, -0.03422663f, -0.00694927f, -0.00623880f, -0.04635797f, -0.02215540f, 
    -0.01549941f, 0.03869662f, 0.00742098f, 0.01091978f, 0.02566340f, 0.03365781f, -0.00254700f, 0.00255265f, 
    -0.00160520f, 0.03835358f, -0.01135974f, -0.00180080f, -0.01191321f, 0.02467871f, -0.02259651f, 0.02300575f, 
    -0.04754955f, -0.01885360f, -0.02150582f, -0.01750240f, -0.01354551f, 0.04183641f, 0.04074164f, -0.03545354f, 
    -0.04477093f, -0.04219833f, 0.04875932f, -0.05576152f, 0.01455654f, 0.02770977f, -0.01876816f, 0.04414215f, 
    -0.01516329f, -0.05166353f, 0.01009136f, 0.00710490f, -0.02747594f, 0.00889755f, -0.03364281f, 0.02662269f, 
    -0.04350598f, -0.02859026f, 0.01365438f, 0.03002148f, 0.01651386f, -0.03168479f, -0.04765379f, 0.03421035f, 
    -0.04024575f, -0.03451936f, 0.02666668f, 0.02798278f, -0.04745720f, 0.03557650f, 0.03187516f, -0.02945378f, 
    -0.03405381f, -0.00019911f, 0.01534414f, -0.02955615f, -0.00176452f, -0.02494180f, -0.01721540f, 0.01891416f, 
    -0.03240956f, 0.04225306f, 0.03324894f, 0.02980463f, -0.05040010f, 0.00200393f, -0.00777256f, -0.04308986f, 
    -0.02794951f, -0.04198948f, -0.01143367f, 0.00990009f, 0.00143642f, 0.01760275f, -0.02939995f, -0.00787085f, 
    0.03523015f, -0.04860281f, 0.01732653f, -0.04469290f, 0.01199212f, -0.04255426f, 0.03693628f, 0.00009942f, 
    0.02022524f, 0.02631529f, 0.02081248f, 0.02182806f, 0.01597358f, 0.01065435f, -0.02721882f, 0.01931202f, 
    0.02477485f, 0.02109276f, 0.03258905f, 0.01001056f, -0.02434549f, -0.04311288f, -0.02283158f, 0.02957554f, 
    -0.02738743f, -0.03875490f, 0.03034892f, 0.03788879f, 0.00748583f, -0.01909881f, 0.03546093f, 0.03920725f, 
    0.00348762f, -0.02165692f, 0.00551630f, -0.00397613f, -0.01346036f, 0.02875909f, 0.00390978f, 0.03521169f, 
    -0.05042185f, -0.03197428f, 0.00842236f, 0.03400972f, -0.02997883f, -0.02124402f, 0.01932964f, -0.03993639f, 
    0.02225516f, 0.01593462f, -0.03855407f, 0.03461489f, -0.00871129f, 0.00862994f, -0.03180066f, -0.00475489f, 
    0.02567567f, -0.04816880f, 0.03848320f, 0.02993870f, 0.04231348f, -0.00704804f, -0.01148035f, -0.04268084f, 
    -0.02300920f, -0.03531738f, 0.03187212f, -0.03986096f, 0.00064308f, -0.03641919f, -0.01139272f, -0.03587724f, 
    -0.05212981f, -0.03020358f, -0.03943565f, 0.05482528f, 0.00822745f, 0.04766228f, -0.00744061f, -0.00527774f, 
    0.02918805f, 0.01980099f, -0.05360101f, -0.00297820f, 0.04194777f, -0.03186782f, 0.00888667f, 0.02252918f, 
    -0.02678444f, -0.04509006f, 0.00724239f, -0.00082639f, -0.02635645f, 0.00232720f, 0.03775795f, -0.00209271f, 
    0.01414247f, 0.02225857f, 0.01031387f, -0.04270973f, 0.03981463f, -0.03106593f, -0.01409608f, -0.04705077f, 
    -0.01754183f, 0.04806204f, 0.02038288f, -0.03615131f, -0.01766409f, 0.01615045f, 0.02577680f, -0.02902078f, 
    0.03042123f, 0.01216544f, 0.00410258f, -0.05172007f, 0.00085662f, 0.03121797f, -0.05221685f, -0.00268168f, 
    0.02782843f, -0.02462029f, -0.03083911f, 0.00845541f, 0.00213090f, -0.05490223f, -0.01187332f, -0.04739321f, 
    -0.03602988f, -0.02307473f, 0.02245715f, 0.02017247f, 0.02080387f, -0.03401083f, 0.02862594f, 0.01942894f, 
    0.04033583f, 0.02618653f, -0.00947063f, -0.02475845f, -0.04839560f, -0.05197253f, -0.05330790f, -0.02807661f, 
    -0.01971735f, 0.03943023f, 0.03117250f, 0.00882599f, 0.03932418f, 0.01879087f, -0.00135231f, -0.02128324f, 
    0.01462296f, 0.00617446f, 0.01233582f, -0.02582315f, 0.01025725f, 0.00531380f, 0.00161816f, -0.01980305f, 
    -0.01203909f, 0.01125799f, -0.02975031f, 0.03630389f, -0.03391181f, -0.03016215f, -0.04621075f, -0.03236660f, 
    -0.05334732f, -0.03717238f, -0.01168074f, 0.00254959f, -0.04749030f, -0.01387872f, 0.01211621f, -0.05425088f, 
    0.03776529f, -0.04397439f, 0.01529084f, -0.03883231f, 0.01006246f, 0.00029774f, 0.01720667f, 0.04365248f, 
    -0.04607187f, 0.00915981f, 0.05140183f, -0.04909857f, -0.03233735f, 0.02020466f, 0.01875679f, -0.00827620f, 
    -0.00111785f, 0.02962407f, 0.03475579f, 0.03922272f, 0.01537435f, -0.02625206f, 0.00899775f, -0.00897474f, 
    0.01208249f, 0.08815059f, 0.18962869f, -0.02618672f, 0.02068011f, 0.02941188f, 0.03747933f, 0.00867586f, 
    -0.08400722f, -0.03713197f, 0.08245016f, 0.00641171f, -0.02231381f, -0.18219751f, -0.05846377f, 0.05658044f, 
    0.04811288f, 0.04422890f, -0.01966842f, 0.00471229f, 0.08987104f, -0.01750279f, 0.09879286f, 0.00219778f, 
    0.11227275f, -0.07038596f, -0.13727906f, -0.06671093f, -0.13832602f, 0.08053234f, -0.00236016f, 0.00113135f, 
    -0.00737439f, -0.00511465f, -0.07043030f, 0.04241277f, -0.07025769f, 0.20378543f, -0.02686012f, 0.01181683f, 
    0.17667340f, -0.09544051f, -0.03629294f, 0.09666618f, 0.09789847f, 0.06642787f, 0.14000346f, -0.00608978f, 
    0.02728369f, 0.04627240f, -0.07163347f, 0.05591572f, -0.02908131f, 0.03095584f, -0.03689649f, 0.15696728f, 
    0.00285820f, -0.05750088f, 0.02216674f, 0.00819328f, 0.12796652f, -0.14519639f, -0.05683866f, -0.14727260f, 
    -0.00702646f, 0.01048028f, -0.01317843f, -0.01548979f, 0.06141092f, 0.00764766f, -0.08513060f, 0.04271118f, 
    -0.14705327f, 0.11663764f, -0.06111795f, 0.09934214f, 0.05447011f, 0.11413947f, -0.02799493f, 0.02103890f, 
    -0.00668991f, 0.01507565f, -0.21021649f, -0.09675230f, 0.13557668f, -0.02532723f, 0.04033997f, -0.09160575f, 
    0.03689624f, -0.05881665f, -0.04722972f, -0.02394035f, -0.01127918f, -0.02906622f, -0.01953244f, 0.02722987f, 
    -0.31768075f, 0.08579613f, 0.02091354f, -0.22209749f, 0.01428389f, -0.01940330f, 0.02308468f, 0.02328393f, 
    -0.03577641f, -0.11798918f, 0.05324632f, 0.00051214f, -0.08799586f, -0.07324052f, -0.15549047f, -0.03453850f, 
    0.02502178f, 0.00955764f, -0.00080317f, -0.00877704f, -0.05019734f, 0.02604942f, -0.00858156f, 0.02443269f, 
    -0.26767901f, 0.01991212f, 0.15538387f, -0.22673149f, 0.02153901f, 0.03529714f, 0.10541258f, -0.03430765f, 
    0.09995724f, -0.01400268f, 0.01282179f, -0.00263793f, 0.21978720f, 0.18717752f, -0.05721619f, -0.06809200f, 
    0.04167707f, -0.06269184f, 0.00282644f, -0.08606399f, 0.06406030f, -0.01904052f, -0.12341774f, -0.08210594f, 
    -0.10214956f, -0.19919683f, -0.00472168f, -0.04179256f, 0.12657738f, 0.01958771f, 0.00139725f, 0.13481590f, 
    0.08209794f, 0.10753935f, 0.08884483f, 0.09774917f, -0.05208135f, -0.08704373f, 0.01225413f, -0.00413992f, 
    0.14048715f, -0.04221607f, 0.06638450f, 0.08964740f, -0.05557423f, 0.05090666f, -0.01700789f, 0.12315939f, 
    -0.09169762f, 0.00717667f, 0.17882374f, -0.20499158f, 0.00762819f, 0.08886830f, 0.09252299f, 0.01975470f, 
    0.00281683f, 0.04925287f, 0.09237833f, -0.01268033f, 0.33237255f, -0.09527574f, -0.12824771f, 0.10816415f, 
    0.01517860f, 0.07355762f, 0.00681032f, 0.05465016f, -0.00068214f, 0.03070714f, 0.03079976f, 0.05047976f, 
    -0.22649239f, 0.09164870f, 0.16806251f, 0.00351198f, -0.01516810f, 0.07004572f, 0.03203465f, -0.07557330f, 
    0.14345059f, -0.02787578f, -0.01031054f, -0.02773819f, 0.14386174f, 0.10440045f, -0.14048047f, -0.00228699f, 
    0.03488057f, 0.02801446f, 0.02757866f, 0.08255807f, -0.04386140f, -0.00973934f, 0.01904496f, 0.02286323f, 
    -0.23942047f, 0.12669122f, -0.05956202f, 0.12465349f, -0.00716889f, 0.16035056f, 0.02101182f, 0.03381216f, 
    0.06009814f, 0.00163760f, -0.04536973f, -0.01804665f, -0.21111125f, -0.17161940f, 0.28545898f, -0.10827296f, 
    0.06614711f, -0.06944691f, 0.17909856f, 0.12108878f, -0.00085750f, -0.01968242f, 0.06954768f, 0.02412005f, 
    0.01739044f, -0.04996555f, 0.03035615f, 0.04849330f, 0.09823768f, 0.09431869f, -0.02303944f, 0.15852992f, 
    -0.01366274f, -0.03475543f, -0.05381813f, 0.08205711f, -0.27940243f, 0.15148292f, 0.18410377f, 0.13793290f, 
    0.01178312f, -0.00974864f, -0.01676289f, 0.00896324f, 0.01754375f, 0.00999947f, -0.06097170f, 0.06546080f, 
    -0.00351846f, -0.13762255f, -0.04559142f, -0.00371921f, 0.00604417f, 0.09353201f, 0.08444604f, -0.01742626f, 
    -0.07443825f, -0.08015272f, -0.06459512f, 0.05435759f, 0.11726452f, -0.04768300f, -0.04689843f, -0.07132200f, 
    -0.03844647f, 0.02127002f, -0.01041704f, 0.06771883f, 0.01536149f, -0.01214265f, 0.06636665f, 0.07264502f, 
    -0.34768632f, 0.06504676f, 0.12675026f, -0.04376646f, 0.10463773f, 0.00653838f, -0.01818348f, 0.05133891f, 
    -0.02736018f, 0.01485186f, -0.04884871f, 0.01563148f, 0.15533009f, 0.00284568f, 0.03980597f, 0.17194912f, 
    -0.01118521f, 0.04940222f, -0.00132355f, 0.03127638f, -0.03797105f, -0.08122956f, -0.01331029f, -0.11428201f, 
    0.00566073f, 0.07055137f, -0.12685472f, 0.01757260f, -0.00922636f, 0.00790833f, 0.06270946f, 0.09057080f, 
    0.09741314f, 0.06859256f, -0.06693692f, -0.00174206f, -0.13934870f, 0.06088472f, -0.08023054f, 0.06518511f, 
    0.03399081f, -0.02036246f, 0.03256682f, 0.03637963f, 0.05931156f, 0.00692279f, -0.03160476f, 0.13968952f, 
    -0.10259657f, -0.15365234f, 0.02114359f, -0.02199540f, 0.02150432f, -0.11856636f, 0.06941644f, 0.13077331f, 
    0.05977330f, -0.00852737f, 0.05540302f, 0.00806728f, 0.18326506f, 0.10614130f, 0.02474641f, 0.00168951f, 
    0.10546293f, -0.00871788f, 0.03900949f, -0.01241715f, -0.02944073f, 0.00267504f, 0.05531136f, 0.02106764f, 
    -0.00402590f, -0.09790095f, -0.01392632f, -0.02369966f, 0.11328251f, 0.09793875f, -0.06014831f, -0.04301292f, 
    0.04729068f, -0.04157455f, 0.08469862f, 0.06968792f, -0.15543295f, 0.18336305f, 0.01364738f, -0.09725292f, 
    0.12887722f, 0.07353280f, 0.08661336f, -0.02310799f, -0.00455192f, -0.02229306f, 0.01067648f, 0.01364793f, 
    0.00105727f, 0.05983776f, -0.00037679f, -0.07890576f, 0.07595597f, 0.13238500f, 0.02349688f, 0.04048990f, 
    -0.03971723f, -0.10532445f, 0.19275713f, 0.08149930f, -0.13167000f, -0.08744191f, -0.01308261f, -0.12349454f, 
    0.07915521f, -0.02233656f, -0.03869250f, 0.01151412f, 0.06214205f, 0.02054655f, 0.11494766f, 0.06104338f, 
    0.07559070f, -0.10484292f, -0.02980684f, 0.06991415f, -0.13554710f, 0.03418493f, 0.02610571f, -0.14835420f, 
    0.00948044f, 0.02218883f, -0.11445868f, 0.02131965f, 0.06116415f, 0.14299642f, 0.08871565f, -0.15564789f, 
    0.01001121f, -0.01535720f, -0.08416807f, -0.05242360f, 0.02170332f, 0.09195606f, 0.11300074f, 0.03714510f, 
    0.04450450f, -0.01346397f, 0.03546397f, 0.19229834f, -0.12846260f, -0.07110622f, -0.05092259f, -0.01900274f, 
    -0.01070446f, -0.08762190f, 0.16842455f, 0.02068037f, 0.34714785f, 0.03664998f, -0.04510619f, -0.10524260f, 
    0.14426382f, 0.07641026f, -0.01877283f, -0.02809895f, 0.02290477f, 0.07357436f, -0.09389704f, 0.07923721f, 
    -0.18761106f, -0.01699906f, -0.10869353f, 0.00990114f, 0.01945196f, 0.01735078f, -0.00016986f, -0.07030083f, 
    0.02128682f, -0.00616334f, -0.11248852f, -0.05659779f, -0.04659676f, -0.15252638f, 0.03906175f, 0.13676809f, 
    0.04890965f, -0.06099096f, 0.00665838f, -0.07390451f, -0.09443787f, 0.08783127f, -0.00895524f, 0.03975980f, 
    0.18738694f, 0.01882662f, -0.15752736f, -0.19227685f, 0.19557364f, 0.02565025f, 0.04668399f, -0.00198898f, 
    -0.03066290f, -0.03494726f, 0.14499913f, 0.01275897f, 0.18813209f, 0.07135376f, 0.03416636f, -0.05246677f, 
    0.08629915f, -0.05182329f, 0.07930077f, 0.02005241f, -0.02435953f, -0.01416265f, -0.03513839f, 0.08095954f, 
    0.07782532f, 0.15871517f, 0.02837993f, -0.11086057f, 0.02549509f, 0.06601252f, 0.19942398f, 0.02879970f, 
    -0.03757755f, 0.00031304f, -0.00773267f, 0.00519723f, -0.13197149f, -0.00037631f, -0.02260475f, -0.01449787f, 
    0.07777193f, -0.10332755f, -0.02877528f, -0.12698138f, 0.10932384f, -0.05879138f, -0.03594265f, -0.09786781f, 
    -0.30316299f, -0.06966492f, 0.09092651f, -0.01373302f, 0.00454099f, 0.05506001f, -0.06257099f, 0.00819894f, 
    0.11592310f, 0.00834205f, 0.08431290f, 0.10100038f, 0.01600659f, 0.10875813f, 0.00865524f, 0.03205312f, 
    0.18076465f, 0.02614225f, 0.02530221f, -0.00319159f, 0.05667384f, -0.02840446f, 0.03853497f, 0.08587541f, 
    -0.19613469f, 0.22850817f, 0.02788083f, -0.05228159f, 0.11352629f, -0.03050293f, 0.04015034f, -0.03270445f, 
    0.02511982f, 0.13250390f, 0.06915545f, 0.03624380f, -0.06419683f, -0.25796381f, -0.02047469f, 0.02437663f, 
    -0.00109183f, 0.02157806f, -0.10700303f, -0.11725247f, -0.01515417f, -0.02534757f, 0.13342583f, 0.14538853f, 
    -0.11039118f, 0.04275962f, -0.13804069f, -0.14312397f, -0.02424059f, 0.04592935f, 0.03205119f, -0.02352086f, 
    0.17559652f, -0.15583809f, -0.27278280f, 0.08749571f, 0.44321680f, -0.06537290f, -0.05087653f, -0.12892337f, 
    0.06967957f, -0.02625370f, -0.00958435f, 0.02906176f, -0.02396492f, -0.01268220f, 0.04517226f, -0.04956917f, 
    0.29406574f, 0.00353979f, -0.12050742f, -0.01073232f, -0.02553078f, 0.08439609f, 0.03186633f, 0.05003116f, 
    0.05980316f, -0.00607066f, -0.02651365f, 0.10808168f, -0.07897794f, 0.10042332f, 0.19731495f, -0.17512108f, 
    0.02049449f, -0.07795949f, -0.13203391f, 0.16614315f, 0.02558703f, -0.06547926f, 0.07506070f, 0.10419868f, 
    0.01345241f, -0.08456818f, -0.05934948f, -0.04027290f, -0.07677311f, 0.02932047f, 0.05781831f, 0.03857071f, 
    -0.03946369f, 0.04164588f, 0.01580336f, -0.08114281f, -0.16033445f, -0.12072950f, -0.19561902f, -0.04386527f, 
    -0.02707675f, 0.03414842f, 0.04792046f, -0.00944335f, -0.07505450f, 0.06062990f, 0.07832698f, 0.06972811f, 
    0.00836619f, 0.07021178f, -0.02993376f, -0.11519956f, 0.01739372f, -0.00379083f, 0.07552283f, 0.03361898f, 
    -0.11095020f, 0.05924061f, -0.01745431f, -0.09538012f, 0.02331537f, 0.08246846f, 0.06981682f, -0.09203219f, 
    0.01430541f, -0.00747478f, 0.05260872f, 0.10296770f, 0.04037927f, -0.11249410f, 0.14920199f, -0.01457478f, 
    -0.07486665f, -0.11234739f, -0.03788769f, -0.00713282f, 0.08994158f, 0.02370368f, -0.03328446f, 0.03450148f, 
    -0.01623966f, 0.07066159f, 0.10203020f, 0.02647776f, 0.07092750f, 0.16340040f, 0.12967186f, 0.14611469f, 
    0.03173321f, 0.01154860f, -0.14574786f, 0.09034394f, -0.01059562f, -0.11615463f, -0.15903156f, -0.14723708f, 
    -0.31953114f, -0.07317317f, 0.04188358f, 0.12976828f, -0.05303130f, -0.02076995f, -0.00855545f, 0.07681007f, 
    0.01461411f, 0.06962125f, 0.08173496f, 0.02168611f, -0.15190023f, 0.01390110f, -0.04109710f, 0.05385904f, 
    0.12254753f, -0.02863346f, -0.00574411f, -0.08402029f, 0.04847959f, 0.04703091f, -0.07463356f, 0.07672802f, 
    -0.06661038f, -0.12255006f, 0.05918192f, 0.02516795f, 0.02486535f, -0.13165605f, 0.07192472f, 0.06201077f, 
    0.06089751f, -0.04040435f, -0.04271335f, -0.02158057f, -0.04250310f, 0.02102228f, -0.00556987f, -0.00379833f, 
    0.04499638f, 0.02680784f, -0.01838255f, -0.01018524f, -0.05183499f, -0.16727102f, -0.01721402f, -0.09285788f, 
    0.17524914f, 0.04811815f, 0.03795764f, 0.04547819f, 0.18415850f, 0.03816449f, 0.02305114f, -0.05927420f, 
    0.01751617f, -0.10978220f, 0.08269744f, 0.15948531f, 0.07939157f, -0.13196382f, 0.07779619f, -0.06600381f, 
    0.05130866f, 0.15456057f, -0.02146365f, -0.03460305f, 0.00672934f, 0.09039017f, 0.05272942f, -0.06779880f, 
    0.01308648f, -0.05272126f, -0.04007763f, -0.06405435f, 0.03107097f, -0.06316562f, -0.00501191f, 0.00902346f, 
    0.04438317f, -0.05547759f, -0.08636396f, -0.02524040f, -0.14665745f, 0.19371654f, 0.01055307f, -0.16953939f, 
    0.05911741f, -0.04233038f, -0.04384563f, -0.01363360f, 0.04566859f, 0.00849959f, -0.00552928f, -0.06540255f, 
    -0.46186388f, 0.08792774f, 0.00545249f, 0.00497844f, 0.13756570f, -0.14440349f, 0.08584019f, 0.05302701f, 
    0.05253003f, -0.11933228f, 0.17511368f, 0.10154349f, -0.23571096f, 0.03747768f, 0.02750862f, -0.16213067f, 
    0.07616407f, 0.01589567f, 0.03958336f, 0.02765896f, -0.07612086f, -0.10318165f, -0.14369529f, 0.06952991f, 
    -0.35750896f, -0.00804597f, 0.05218393f, -0.11724430f, 0.09957109f, 0.03730109f, 0.04329371f, 0.00846827f, 
    -0.07616565f, 0.04948186f, 0.03313196f, 0.05593405f, -0.07784717f, 0.19985172f, 0.01925614f, 0.03021036f, 
    0.00687255f, 0.04908029f, -0.02481355f, 0.08223394f, 0.01842153f, 0.09381275f, 0.05266358f, -0.13250415f, 
    -0.01919292f, 0.01850509f, 0.14228182f, -0.09072353f, 0.00256451f, -0.13988169f, 0.05394799f, -0.01282302f, 
    -0.02441879f, 0.01973670f, 0.16538832f, 0.18377997f, 0.08639482f, -0.09340571f, -0.09774378f, 0.05960463f, 
    -0.00190732f, -0.08583152f, -0.04866954f, -0.09527334f, 0.01245291f, 0.05194122f, 0.06869904f, 0.06704738f, 
    0.16842553f, -0.15205993f, 0.20608540f, 0.23170295f, -0.07881597f, 0.01997475f, -0.01518177f, -0.04429231f, 
    0.03081195f, 0.02936810f, 0.02148625f, -0.00146449f, -0.10054470f, 0.16289315f, 0.10279825f, -0.14834513f, 
    0.10883959f, -0.00962556f, -0.00516786f, -0.04914572f, 0.02502123f, 0.14451163f, 0.00572942f, 0.01118614f, 
    0.05344674f, 0.07151136f, 0.02054430f, 0.11151249f, 0.11212394f, 0.00733422f, -0.04432168f, -0.02785144f, 
    0.14735007f, 0.02279029f, 0.05455580f, 0.02344155f, -0.16633806f, -0.18405786f, -0.14292274f, 0.00972879f, 
    0.02814390f, 0.08831093f, 0.02009828f, 0.08156361f, 0.00100019f, 0.10338851f, -0.01747026f, 0.08476111f, 
    0.19760683f, -0.03066535f, -0.06802934f, 0.12568383f, 0.02410188f, -0.06191441f, -0.04372380f, -0.02265561f, 
    -0.12868004f, -0.04927332f, -0.06602403f, -0.02034764f, 0.16332337f, 0.26632047f, 0.03255187f, -0.19315012f, 
    -0.03762503f, 0.02735425f, 0.02941071f, 0.11553608f, 0.07876652f, 0.05007214f, 0.00422384f, 0.01198912f, 
    -0.02414349f, 0.08152700f, -0.11578069f, 0.20449045f, 0.01230152f, -0.05648213f, -0.06745382f, -0.00090636f, 
    -0.04014522f, -0.20680791f, 0.09994439f, -0.09324947f, -0.24689536f, 0.06700654f, -0.12471625f, -0.00498745f, 
    -0.01699102f, -0.05293797f, 0.07790980f, -0.00957044f, 0.07673024f, 0.02314158f, 0.11075400f, 0.02327519f, 
    0.09593629f, -0.06095790f, -0.05485578f, -0.02064653f, -0.03602240f, 0.04024792f, 0.03767690f, 0.09760782f, 
    -0.11098444f, 0.11341388f, 0.23653522f, 0.07108366f, -0.09074747f, -0.05555886f, 0.00017965f, 0.05324237f, 
    -0.11129933f, -0.05561882f, -0.00083220f, -0.00567922f, 0.09466879f, -0.07775779f, -0.02992798f, 0.05574152f, 
    0.11816840f, 0.00927555f, 0.25973150f, -0.03680423f, 0.04707076f, -0.02456160f, -0.02541181f, 0.03044201f, 
    0.02571261f, 0.03007232f, -0.01101123f, -0.00986388f, 0.04300083f, -0.01030686f, -0.21488103f, 0.25629312f, 
    -0.02102733f, 0.10968848f, 0.05693688f, 0.01556108f, -0.01897485f, 0.07706702f, -0.13266043f, -0.12510931f, 
    -0.01848625f, 0.19229214f, -0.07564555f, 0.14280427f, 0.11377673f, -0.05195265f, -0.14752807f, -0.09112696f, 
    -0.01308192f, -0.08047926f, 0.01434453f, 0.02441466f, 0.17301147f, 0.12411833f, 0.14151271f, 0.04733701f, 
    -0.02922573f, 0.03390599f, -0.05751457f, -0.10153230f, 0.05562174f, 0.03184235f, 0.01436074f, -0.10859337f, 
    -0.08286935f, 0.17532723f, 0.09041492f, 0.08254090f, 0.08497681f, 0.04986428f, 0.01343119f, -0.15940426f, 
    0.04782163f, 0.03637318f, 0.11415628f, 0.07812500f, -0.02306831f, 0.01099608f, 0.01487883f, -0.07925753f, 
    0.00745496f, -0.04477558f, 0.02834509f, -0.01241214f, -0.03009059f, 0.04839410f, -0.09662073f, -0.07237493f, 
    0.13243505f, 0.16171868f, 0.11285418f, 0.02748909f, -0.00695446f, 0.08862403f, 0.00559439f, 0.02334245f, 
    0.05895543f, 0.08777122f, -0.05384741f, 0.04906720f, -0.35491294f, -0.06036516f, -0.09451472f, 0.15252696f, 
    0.10877660f, -0.08690325f, -0.04386726f, -0.09146442f, -0.03011143f, -0.00485481f, 0.03313362f, 0.04982599f, 
    -0.06220800f, -0.06659170f, 0.05824843f, 0.01687633f, 0.13826770f, -0.00386741f, 0.09908734f, 0.14508519f, 
    0.02170582f, -0.00032986f, 0.10319275f, 0.06585116f, 0.09060210f, 0.06563083f, -0.00859105f, -0.19731550f, 
    0.05792181f, -0.03591569f, 0.05634239f, 0.12476568f, 0.04819854f, 0.05946366f, 0.00151889f, 0.09096275f, 
    -0.39690012f, 0.10268874f, 0.04627169f, 0.01843478f, 0.08077966f, 0.05920269f, -0.11352667f, 0.06868033f, 
    -0.05485362f, 0.07065403f, -0.04294571f, -0.01188983f, -0.25712124f, -0.17280865f, 0.03581963f, 0.08366730f, 
    -0.00071435f, -0.01476187f, 0.05791035f, -0.10883778f, -0.04618018f, 0.07631805f, 0.06770284f, 0.15132846f, 
    -0.01301661f, 0.17685583f, 0.04129581f, -0.13104598f, -0.00315588f, 0.01776071f, 0.00180641f, 0.09909987f, 
    0.01242892f, 0.08994265f, 0.01101426f, 0.02905432f, -0.12741524f, 0.07494958f, -0.09109356f, -0.07552219f, 
    -0.01326099f, 0.03340036f, 0.04166309f, 0.03799999f, 0.00115473f, 0.03924410f, 0.02980480f, 0.04715927f, 
    -0.00232075f, -0.00618315f, 0.02489302f, 0.02555948f, 0.02857127f, -0.04430290f, -0.05811928f, -0.03071600f, 
    0.00731726f, 0.00027794f, 0.03679194f, -0.04116770f, -0.01046753f, -0.02160008f, -0.00300522f, -0.02569550f, 
    0.02824789f, 0.04142272f, 0.01128256f, 0.00580908f, -0.00468024f, -0.01850292f, -0.00871935f, 0.03247399f, 
    0.02160764f, 0.01172166f, 0.01978817f, -0.03270790f, 0.03897814f, 0.00576651f, -0.01394015f, 0.03927978f, 
    -0.03894682f, -0.04931721f, 0.00722440f, 0.03449764f, 0.02040971f, 0.00084883f, -0.00689571f, -0.00474070f, 
    -0.03416545f, -0.02631414f, 0.04369916f, 0.03098382f, 0.03674836f, -0.05553334f, -0.01580848f, 0.03799208f, 
    0.03717263f, 0.02853891f, -0.01282314f, 0.00122787f, -0.00631159f, -0.05398640f, -0.03190671f, 0.00698056f, 
    -0.06078089f, -0.03928537f, -0.03162388f, 0.03438461f, -0.02015225f, 0.02901001f, -0.04917250f, -0.01715919f, 
    0.00029074f, -0.03749822f, -0.02878419f, 0.04254453f, 0.03960535f, 0.01665005f, 0.00898152f, -0.03308644f, 
    -0.00860229f, 0.00749929f, -0.02374301f, -0.04554861f, -0.05565031f, 0.00897796f, -0.01111542f, -0.01142151f, 
    -0.02394708f, -0.02776106f, -0.02605215f, -0.04696654f, 0.03327283f, 0.02526892f, -0.00761953f, -0.00742253f, 
    -0.04637408f, 0.01620964f, 0.01743460f, 0.02322853f, -0.02912346f, -0.05098579f, -0.04644784f, -0.02526554f, 
    -0.02841281f, -0.04571914f, -0.00688070f, -0.04162689f, -0.01770416f, -0.04164157f, 0.00583663f, 0.02559270f, 
    0.02697050f, -0.02258596f, -0.01024453f, -0.01749511f, -0.02269239f, 0.05180977f, 0.02156917f, 0.01795119f, 
    -0.03632519f, -0.05245035f, 0.01207129f, -0.02538851f, -0.03852817f, -0.04175815f, -0.01205632f, 0.01667662f, 
    -0.00854156f, -0.04277832f, -0.03622715f, -0.02944741f, -0.05083067f, -0.03221169f, 0.03897498f, -0.02238997f, 
    0.03319537f, -0.04345214f, -0.04643615f, -0.00636560f, -0.06110960f, -0.03736673f, -0.01860440f, 0.03280587f, 
    -0.03013685f, 0.03758535f, 0.03430814f, 0.00356539f, -0.04767106f, 0.02238553f, 0.03709579f, -0.04178936f, 
    -0.05044406f, -0.01007863f, -0.03669778f, 0.03198427f, -0.01586847f, -0.06154988f, -0.03447359f, -0.05846047f, 
    -0.04416917f, -0.01443688f, 0.03254617f, -0.05692939f, 0.03757612f, 0.02873659f, -0.00280949f, -0.02715760f, 
    -0.03814121f, -0.00057276f, -0.05638085f, -0.00438933f, -0.02900810f, -0.00481125f, -0.05296700f, -0.01434489f, 
    0.03398749f, -0.00858709f, -0.03701574f, 0.02202334f, -0.02831483f, 0.03224506f, 0.03603682f, 0.04032451f, 
    -0.02520688f, 0.02197899f, 0.03293937f, 0.03624991f, 0.01677165f, -0.02286821f, 0.03008424f, 0.01386613f, 
    0.00235207f, 0.03130085f, 0.00637799f, -0.04321153f, -0.04082042f, 0.03469563f, 0.02899872f, 0.02773814f, 
    0.00018098f, -0.00631304f, 0.03044169f, 0.02267797f, -0.05746254f, -0.00705638f, 0.01265716f, 0.02500174f, 
    -0.03563486f, 0.00877814f, -0.00041341f, 0.02215019f, -0.05862129f, 0.00173659f, 0.00981996f, 0.04468311f, 
    -0.02260796f, 0.04065265f, 0.00267773f, -0.03172440f, -0.00935293f, -0.01567153f, -0.03776197f, -0.00826987f, 
    -0.00727627f, 0.00626308f, -0.04997145f, -0.01408976f, -0.03200836f, -0.00000926f, 0.00333180f, -0.02247515f, 
    0.01388085f, -0.03506942f, 0.03086299f, -0.01030546f, -0.04318514f, 0.02311240f, -0.01359193f, 0.00037427f, 
    -0.00844546f, -0.04857150f, 0.00680764f, -0.03303890f, -0.00490110f, -0.03784930f, 0.01139647f, 0.01602183f, 
    0.03131441f, 0.04126859f, -0.05744674f, 0.00888674f, -0.04582692f, -0.00023968f, 0.03507351f, 0.01203993f, 
    -0.03068374f, -0.01610673f, 0.03244853f, -0.04585549f, -0.03091227f, -0.01309423f, 0.03882032f, 0.03445453f, 
    -0.03141873f, 0.04078955f, 0.00042274f, 0.03732138f, -0.02946489f, 0.03179127f, -0.02001272f, -0.04503273f, 
    0.02045120f, -0.05477373f, -0.04756278f, 0.02995181f, 0.00441937f, -0.04998703f, -0.00136722f, -0.03841538f, 
    0.04474853f, -0.00872607f, 0.03133325f, -0.03618009f, -0.05250287f, -0.00828987f, 0.03201789f, -0.04601914f, 
    -0.01559546f, -0.00601558f, -0.01703190f, 0.03072857f, -0.00214524f, 0.03889227f, -0.01236222f, 0.01390250f, 
    0.02770185f, 0.03665260f, -0.01689233f, -0.03174845f, 0.00790013f, -0.05396852f, 0.00938106f, 0.03295585f, 
    -0.05024748f, 0.02018416f, -0.03560854f, -0.04173434f, -0.00051937f, -0.01388016f, -0.01190847f, -0.01457398f, 
    0.03237969f, -0.01461860f, 0.01366848f, -0.03311410f, 0.03475505f, -0.02208588f, 0.00935008f, -0.04890196f, 
    -0.00078405f, 0.02348105f, -0.05121276f, -0.01047487f, 0.03015969f, -0.02646673f, -0.05570048f, 0.02355856f, 
    -0.00068138f, 0.03409995f, -0.00410686f, 0.01380004f, -0.01526430f, 0.00797255f, 0.02830730f, 0.00137181f, 
    -0.03776116f, 0.02234307f, -0.00359099f, 0.03209439f, -0.02886317f, -0.01145383f, 0.03666694f, -0.05588530f, 
    -0.05718734f, 0.03573140f, -0.02378449f, -0.06234730f, -0.03588185f, -0.01261409f, -0.01888856f, 0.03852762f, 
    -0.02653171f, -0.03957585f, -0.02533880f, -0.06259692f, -0.00986631f, 0.03186867f, -0.02778091f, -0.01846765f, 
    0.03350220f, -0.02235091f, 0.03206499f, 0.00903419f, -0.00930185f, -0.02119721f, -0.01378360f, 0.00924574f, 
    -0.01074177f, -0.03556424f, 0.04417924f, -0.04639745f, 0.01434187f, -0.05549497f, -0.05119207f, -0.01752965f, 
    -0.00792979f, -0.04432118f, -0.05726381f, -0.01074300f, 0.04457473f, 0.01395795f, 0.02875858f, -0.01915454f, 
    0.01576044f, 0.00576482f, 0.02227755f, -0.05786606f, -0.03075441f, -0.03676627f, -0.05408652f, -0.00478802f, 
    -0.04451372f, -0.02778465f, -0.00206439f, -0.02574992f, -0.01384167f, -0.01642345f, -0.03741588f, 0.03692424f, 
    -0.04904751f, -0.02959808f, -0.00591802f, 0.02727893f, 0.04552620f, 0.01860412f, -0.02346820f, 0.02198902f, 
    0.04118937f, -0.01170062f, -0.05094802f, -0.02426050f, 0.01261939f, -0.05224227f, -0.00234179f, -0.02245913f, 
    0.00213759f, 0.04306039f, -0.02857744f, 0.01161467f, 0.00804175f, -0.02314176f, -0.02706900f, 0.01913501f, 
    0.00563875f, -0.01427480f, -0.00401608f, -0.01419956f, 0.04491301f, -0.05208049f, -0.05022718f, 0.04495056f, 
    -0.02459274f, 0.03620761f, 0.02117185f, -0.03942391f, 0.02213768f, -0.02419292f, -0.04795369f, -0.01647607f, 
    -0.04988991f, 0.01937048f, -0.02810523f, -0.03251007f, 0.00659057f, -0.05057469f, -0.04827013f, -0.03156668f, 
    -0.01244574f, -0.03947853f, -0.04511305f, 0.03036718f, -0.02718904f, -0.04024810f, -0.03462640f, -0.03553464f, 
    -0.03648662f, -0.04246166f, -0.02254297f, 0.02355010f, -0.04167287f, -0.00146778f, 0.02971612f, 0.01499096f, 
    -0.00989823f, 0.00629095f, -0.01024445f, 0.01073300f, 0.00739740f, -0.04157376f, 0.03520821f, -0.01211459f, 
    -0.03328391f, -0.00405836f, 0.01433104f, 0.03839624f, -0.04476379f, 0.03345690f, 0.02408488f, -0.04078603f, 
    0.04509330f, -0.02698725f, 0.00059311f, -0.05002061f, 0.03139436f, -0.03615753f, -0.02978705f, -0.05585548f, 
    -0.00185894f, 0.00972091f, -0.00585113f, -0.03292144f, -0.00127885f, -0.02818307f, -0.02049270f, -0.00996789f, 
    -0.04615611f, 0.01620658f, -0.03364396f, -0.02104240f, 0.03729288f, -0.00717577f, 0.01850168f, -0.01137687f, 
    0.03225051f, -0.01744417f, 0.03795816f, -0.03230888f, -0.00486247f, -0.05335139f, -0.05506232f, 0.02573378f, 
    0.03705751f, -0.02823190f, 0.00858055f, -0.03994799f, -0.03524641f, -0.05582999f, -0.03028388f, 0.04719198f, 
    -0.00692705f, 0.00954312f, 0.02938569f, -0.03613246f, -0.02762846f, -0.01095788f, 0.03660206f, 0.03236348f, 
    -0.03390303f, 0.00798716f, -0.03900594f, -0.01487410f, 0.00685176f, 0.04143095f, -0.02883328f, 0.00316092f, 
    0.04604411f, 0.00264146f, 0.01209652f, -0.04719749f, 0.04271819f, 0.03297954f, -0.05586246f, -0.02655890f, 
    -0.02127652f, -0.04937086f, -0.00901868f, -0.02364162f, 0.01458932f, -0.01527586f, -0.03856691f, 0.04230754f, 
    -0.03092691f, 0.02560625f, 0.02299391f, 0.03521042f, 0.03769507f, -0.02700715f, -0.04631874f, 0.03427674f, 
    -0.01773193f, -0.01087799f, -0.02505208f, -0.04221508f, -0.02180254f, -0.00907248f, 0.01303369f, -0.03367689f, 
    0.01615784f, 0.00689974f, -0.05326535f, 0.02349997f, -0.00244382f, 0.01738708f, -0.00926091f, -0.01520496f, 
    0.02669971f, 0.02030055f, 0.01573974f, -0.00469646f, 0.04389147f, 0.04584115f, -0.04588961f, -0.01488644f, 
    0.02272552f, -0.03125648f, 0.04084308f, 0.03327852f, 0.00626131f, 0.03763995f, -0.00172452f, 0.00251332f, 
    0.01172394f, 0.00036067f, 0.02310407f, -0.04192258f, -0.01303816f, -0.00800169f, -0.03743535f, 0.01626395f, 
    0.02699612f, 0.00000996f, -0.00533003f, -0.04028914f, -0.04262870f, -0.02871131f, 0.03525361f, -0.04969871f, 
    0.02437923f, -0.04866187f, 0.03126105f, -0.03542491f, 0.03114032f, 0.02445615f, -0.03202248f, -0.04548505f, 
    -0.02387492f, -0.03942574f, -0.04822331f, 0.02648488f, 0.02280373f, -0.03891198f, -0.01425457f, 0.00863098f, 
    -0.00664897f, 0.01186336f, -0.00136092f, -0.03105849f, -0.00821840f, -0.00389868f, -0.03530917f, 0.01806961f, 
    0.04420048f, 0.04257661f, -0.00880166f, -0.01285198f, 0.04051020f, -0.05159020f, 0.04157502f, -0.00767932f, 
    0.00447583f, 0.01391284f, -0.04672149f, 0.01927409f, 0.00349301f, -0.01960348f, 0.01871790f, 0.01595675f, 
    -0.00815465f, 0.01339431f, -0.03895108f, -0.02826785f, -0.01537754f, 0.00256962f, 0.02352596f, -0.02459804f, 
    -0.03873808f, -0.02388127f, -0.02382283f, -0.00616522f, 0.01241494f, -0.00878164f, -0.05561292f, -0.03731840f, 
    -0.03888591f, -0.02661644f, -0.01931242f, 0.00153574f, 0.02593420f, -0.00040921f, 0.00958290f, -0.04829392f, 
    -0.04958476f, 0.03220281f, -0.05446161f, -0.02425305f, 0.02896546f, -0.02415447f, -0.04228703f, 0.04499807f, 
    -0.04969980f, 0.04573864f, -0.01467919f, -0.00716187f, -0.00666640f, -0.02325219f, -0.00218002f, 0.00152468f, 
    0.03525736f, -0.03786743f, -0.00063305f, -0.00529010f, 0.02799782f, 0.04345319f, -0.01351333f, -0.05497621f, 
    -0.02730568f, -0.00135609f, 0.03887485f, -0.03863460f, 0.03264172f, -0.05369329f, 0.03810669f, -0.01895002f, 
    0.00007513f, 0.03844338f, -0.04661737f, 0.00571841f, 0.01877589f, 0.00213256f, -0.02915603f, 0.02966031f, 
    -0.00304269f, 0.01869546f, -0.02373336f, -0.01990347f, -0.04575176f, 0.02734881f, 0.01435340f, -0.04730983f, 
    0.02227465f, -0.00276356f, -0.05051186f, -0.02967544f, -0.05184448f, 0.02474879f, 0.03236968f, -0.04083700f, 
    0.04356990f, -0.02849839f, 0.03438303f, -0.03063582f, -0.00065666f, -0.04917071f, -0.05390367f, 0.01487303f, 
    0.02848200f, 0.01218045f, -0.00877058f, -0.04274355f, -0.00121755f, -0.01611587f, 0.03011636f, 0.01761861f, 
    0.03771837f, 0.01702446f, 0.02536202f, 0.01461785f, -0.04779405f, 0.04242278f, -0.01957633f, -0.01497162f, 
    0.02363822f, 0.00268890f, -0.01334138f, -0.04471553f, 0.00905806f, -0.04466456f, -0.02084380f, -0.01644434f, 
    -0.04966656f, 0.04695010f, 0.01720639f, -0.03793263f, -0.01263634f, -0.05238819f, 0.03788638f, -0.02945758f, 
    -0.02102194f, -0.04553293f, 0.02868447f, -0.03850880f, 0.03668245f, -0.00529968f, -0.01063585f, -0.04110603f, 
    0.25464621f, -0.04891865f, -0.11319420f, 0.10901807f, -0.14179240f, 0.05149773f, 0.14949653f, 0.05633562f, 
    0.06648086f, 0.21539225f, 0.00210461f, 0.11439618f, 0.40708581f, -0.04701692f, -0.07664136f, 0.16181628f, 
    -0.08915570f, 0.06452598f, -0.03170028f, 0.01045673f, -0.02368689f, -0.03072109f, 0.01067907f, 0.15732017f, 
    0.13039495f, 0.23325342f, 0.06321037f, -0.08973878f, -0.08431922f, 0.08115526f, 0.04674714f, -0.09585970f, 
    0.08553794f, 0.11662164f, -0.04974764f, -0.07278219f, 0.05531285f, -0.17179988f, 0.20697767f, 0.19447222f, 
    -0.18400390f, -0.09859115f, -0.06621583f, -0.00489221f, 0.05259735f, -0.01410862f, -0.01934065f, -0.05897146f, 
    0.16655214f, 0.09505398f, 0.08750519f, -0.01195329f, -0.01859064f, 0.02887530f, 0.11812642f, 0.03116810f, 
    0.06384673f, 0.00088492f, -0.01279814f, -0.03735948f, -0.03385352f, -0.05077585f, 0.00854762f, 0.14273286f, 
    -0.03039432f, 0.03397713f, 0.05746962f, -0.05274582f, 0.02618013f, 0.01876611f, -0.04173522f, 0.10225261f, 
    0.13872489f, -0.12372352f, -0.11166251f, 0.04962840f, 0.06330749f, 0.01363671f, -0.08716942f, -0.13083299f, 
    -0.07710394f, 0.03117823f, -0.05012183f, -0.00799157f, -0.16353893f, 0.04713511f, 0.14860849f, -0.12106141f, 
    0.10393912f, 0.05454848f, -0.06827886f, -0.03883774f, -0.08998607f, -0.02741555f, -0.04964760f, 0.02502885f, 
    0.02079180f, 0.23100506f, -0.09985245f, 0.05290086f, 0.08387639f, -0.08918793f, -0.08399340f, 0.08958273f, 
    -0.07025055f, 0.01627023f, -0.10704030f, -0.07583195f, 0.04081366f, -0.14658712f, -0.08131076f, 0.14590549f, 
    -0.09134488f, 0.00832599f, -0.11360974f, 0.03298479f, -0.05518556f, -0.04615254f, 0.04145293f, -0.05203202f, 
    0.07706509f, 0.01835575f, -0.25350386f, 0.11046511f, -0.17600305f, 0.05286174f, 0.07045106f, 0.03849113f, 
    -0.06271251f, 0.08412024f, 0.04025960f, 0.02937214f, 0.45093071f, -0.07983553f, 0.24881734f, 0.03662133f, 
    -0.09961308f, 0.04755617f, -0.02063436f, -0.04172436f, -0.07967331f, -0.01049792f, 0.10271556f, -0.02762911f, 
    -0.09868944f, 0.20247523f, 0.09014276f, -0.02626808f, -0.00990915f, 0.05117620f, 0.03959142f, -0.00542146f, 
    0.07106969f, 0.03171820f, 0.09698669f, -0.08191142f, 0.10092111f, -0.22554567f, -0.01296152f, 0.21715862f, 
    -0.10276102f, -0.05764390f, -0.04038165f, -0.05298027f, -0.06994005f, 0.05366955f, 0.11551706f, 0.02052448f, 
    0.09890251f, 0.06044456f, -0.05818577f, -0.00575677f, -0.01715516f, 0.05869498f, -0.01424768f, 0.04594751f, 
    0.14509387f, 0.06846073f, 0.00208217f, 0.09631090f, 0.04862640f, 0.06628393f, 0.15239915f, -0.07773110f, 
    0.04716483f, 0.03112536f, -0.04910059f, -0.06964269f, 0.02050457f, 0.03109678f, -0.10440448f, 0.00107367f, 
    0.01502548f, -0.00866253f, 0.11311615f, 0.07248331f, 0.07924180f, -0.07810485f, -0.03006805f, -0.01231429f, 
    0.21464805f, -0.08853550f, -0.02771217f, -0.00038903f, -0.09933302f, 0.06392898f, -0.00342363f, 0.01806507f, 
    0.08757404f, -0.01247570f, 0.00966424f, -0.00192856f, -0.07011354f, 0.02031449f, 0.15588129f, 0.11671964f, 
    0.21375982f, -0.01579320f, -0.22313771f, 0.02014176f, 0.11741305f, -0.07642914f, -0.07605612f, -0.11379211f, 
    -0.05205457f, 0.08585273f, 0.06864338f, 0.04622206f, -0.18960002f, 0.25310025f, -0.09065051f, -0.09023239f, 
    0.12268043f, -0.02885731f, 0.01579906f, -0.06014334f, 0.14261155f, 0.04343596f, 0.11223146f, 0.05029496f, 
    -0.14196403f, -0.11236267f, 0.02302046f, -0.11696737f, -0.07700908f, 0.06024644f, 0.08242627f, -0.01450092f, 
    0.09790271f, 0.11597104f, 0.06073830f, -0.05847881f, -0.03166772f, -0.04078748f, -0.08887914f, -0.12507287f, 
    -0.01968851f, 0.04467230f, -0.05539110f, 0.08115116f, 0.03833269f, -0.01966478f, -0.00680523f, 0.09388998f, 
    -0.08126859f, -0.03343396f, -0.12646797f, -0.06202402f, 0.03027833f, -0.01107563f, -0.08740459f, 0.19978023f, 
    0.10046102f, 0.01089365f, 0.10123933f, -0.03295639f, 0.05836114f, 0.01490535f, -0.07013299f, 0.03896095f, 
    0.12549573f, 0.05208760f, 0.00621441f, 0.13010089f, 0.06016027f, 0.05695304f, 0.16295882f, 0.04760066f, 
    0.00907309f, 0.01898304f, 0.00623507f, 0.11783440f, -0.07358780f, -0.16641441f, 0.06937670f, -0.02762682f, 
    0.02414097f, -0.00878400f, 0.08615037f, 0.01797376f, 0.24663305f, 0.11748192f, 0.11851523f, -0.23431559f, 
    -0.04749400f, 0.00980984f, 0.07941391f, 0.02323364f, 0.00576014f, 0.04697849f, -0.04854627f, 0.03275082f, 
    0.08487399f, 0.01677856f, 0.06805101f, -0.22485395f, 0.08071674f, 0.08169772f, 0.02604466f, -0.21115586f, 
    -0.02669309f, 0.12703665f, -0.04327886f, -0.00367150f, -0.00608627f, -0.20501623f, 0.07010286f, 0.12715736f, 
    -0.07719061f, 0.01363570f, -0.08866260f, -0.04805014f, -0.01238335f, -0.04459923f, -0.01653465f, -0.17407385f, 
    0.26485544f, 0.11687250f, -0.03005560f, 0.01449315f, -0.04498222f, 0.06316771f, 0.14276239f, -0.03017163f, 
    -0.02074820f, -0.00713258f, -0.00040204f, 0.00943442f, 0.33047482f, 0.24747844f, 0.01094012f, 0.00121302f, 
    0.02199210f, 0.15579012f, -0.09614167f, -0.00377515f, 0.00218089f, -0.08162642f, -0.04779319f, 0.00695297f, 
    0.17415254f, -0.05003680f, -0.00862181f, 0.12808542f, -0.01475973f, -0.00069598f, -0.07034320f, -0.11859150f, 
    0.00389614f, -0.05965806f, 0.04084945f, -0.06743022f, -0.09279971f, -0.16057360f, 0.20037843f, 0.16995674f, 
    0.02492572f, -0.16137353f, -0.06228710f, -0.00791215f, 0.08196742f, -0.07221111f, 0.04063985f, -0.08253218f, 
    -0.00994300f, 0.00357568f, -0.03174861f, -0.01420762f, 0.03021910f, 0.03718602f, 0.02441680f, -0.02636600f, 
    -0.03337537f, -0.00588413f, 0.02645832f, 0.02993177f, -0.06134703f, 0.03791865f, 0.01137535f, 0.00420863f, 
    0.00403143f, 0.02231735f, -0.01226801f, -0.02955216f, 0.03553072f, -0.01529382f, -0.04253784f, 0.01229587f, 
    0.03438040f, 0.01959610f, 0.00716361f, -0.03726583f, -0.04158467f, -0.05220900f, -0.02987894f, -0.03293674f, 
    0.00219651f, 0.03783959f, 0.02442670f, 0.00086568f, -0.03855005f, 0.03630944f, -0.02327771f, 0.00314262f, 
    0.01114150f, 0.00050587f, 0.00144728f, 0.03666880f, -0.05836979f, -0.02390309f, 0.02288082f, -0.00227671f, 
    0.00920945f, -0.02277281f, -0.03034689f, 0.01995961f, -0.03663469f, -0.03219518f, -0.02766088f, -0.04893639f, 
    0.03583826f, -0.05921524f, -0.03686858f, 0.04010164f, -0.05631477f, 0.03000309f, -0.00600671f, 0.01448331f, 
    -0.05472708f, -0.00305242f, -0.01269629f, -0.01838320f, -0.03064826f, 0.03723849f, -0.02509001f, 0.02754078f, 
    0.01583325f, -0.02302793f, 0.03496835f, -0.01641505f, 0.02692217f, 0.04043541f, -0.01555487f, 0.03890055f, 
    0.01233870f, -0.02715827f, -0.02293278f, 0.01447446f, -0.03159258f, -0.03562439f, 0.00964829f, -0.03422862f, 
    -0.00694932f, -0.01451180f, -0.00933688f, 0.00586301f, -0.04407697f, 0.01636598f, 0.03186990f, -0.02746989f, 
    0.02992022f, -0.05118329f, 0.01041001f, 0.03969977f, -0.03599969f, -0.04701966f, -0.00528240f, -0.02688991f, 
    -0.03379035f, 0.00871146f, 0.02751218f, 0.03189005f, 0.04172938f, 0.00369430f, 0.02122706f, -0.01727302f, 
    0.03911191f, -0.05071393f, 0.02789985f, -0.02552582f, 0.03927342f, 0.00324733f, 0.01118820f, 0.01478979f, 
    0.03229271f, 0.00865283f, -0.02407218f, -0.00841774f, -0.05956679f, 0.03680976f, 0.00003138f, -0.00316657f, 
    -0.05453084f, -0.04780590f, 0.02540097f, -0.05230393f, -0.02293527f, -0.00297591f, 0.03466766f, -0.01653157f, 
    0.02761346f, -0.02436049f, -0.04319347f, 0.01433733f, -0.03398028f, 0.03344265f, -0.03834872f, 0.00629708f, 
    -0.00004470f, -0.05171743f, -0.03684760f, 0.00174373f, -0.00417291f, -0.01442328f, 0.00704673f, 0.04089424f, 
    0.02483375f, -0.04784280f, 0.00508089f, -0.03661612f, -0.03695766f, 0.01638591f, -0.05706780f, -0.00644936f, 
    -0.03748032f, 0.03205350f, -0.04785060f, 0.03290302f, 0.01109835f, -0.05553189f, -0.04095994f, -0.03436780f, 
    -0.03706998f, -0.00889884f, -0.04008991f, 0.01469840f, -0.03732830f, 0.00817092f, 0.02546348f, -0.01551925f, 
    -0.01762141f, -0.04847945f, -0.05199638f, -0.02666274f, 0.04006423f, -0.05182356f, 0.01579017f, -0.05073637f, 
    0.00416720f, -0.00854066f, 0.02304040f, 0.03801224f, -0.00806059f, 0.00840851f, 0.03699882f, -0.02277685f, 
    -0.00542377f, -0.02278657f, 0.02879393f, -0.01915739f, -0.00789567f, -0.05840083f, -0.05881006f, -0.02233028f, 
    0.00637268f, -0.05604903f, -0.04326656f, 0.03856730f, 0.01561634f, 0.04077867f, -0.04539086f, -0.03434846f, 
    -0.04239681f, 0.00628766f, -0.03128750f, 0.02424594f, -0.03014173f, -0.05802656f, -0.03655818f, 0.01522768f, 
    -0.02920025f, 0.00727592f, 0.03922643f, -0.04839537f, 0.03694578f, -0.02967888f, -0.03869244f, 0.00048778f, 
    0.03001147f, -0.01819324f, 0.02271645f, -0.03462795f, -0.02550760f, 0.02408192f, -0.03618152f, -0.02430051f, 
    0.03571641f, 0.00418439f, 0.01182325f, 0.03586250f, 0.00140307f, -0.04970426f, 0.01550000f, 0.03726431f, 
    -0.03488204f, -0.05052154f, -0.03876952f, 0.00428822f, -0.01512616f, -0.03062069f, 0.01498217f, -0.00549846f, 
    -0.03706719f, -0.02369418f, -0.03276923f, -0.01573787f, 0.00704231f, -0.04863915f, -0.02562622f, -0.00104183f, 
    -0.01444845f, -0.03817860f, -0.03147648f, 0.00961892f, -0.01345519f, 0.03863857f, 0.02977315f, 0.02897524f, 
    0.01818899f, 0.00109757f, 0.00186015f, -0.03451003f, 0.01829227f, -0.00939972f, -0.00972023f, -0.03435948f, 
    -0.05080938f, -0.04536708f, -0.05560026f, 0.00833926f, -0.01608431f, -0.01872537f, 0.03147170f, 0.01515837f, 
    0.01024345f, -0.02264627f, 0.00501992f, -0.05857061f, -0.04392149f, 0.01544806f, 0.04144633f, -0.06167173f, 
    -0.02285634f, 0.01709467f, -0.04591533f, -0.01366738f, 0.03487895f, -0.05884453f, 0.03945548f, 0.01302660f, 
    -0.03258710f, 0.02231796f, -0.03045655f, -0.05316583f, 0.04343094f, 0.00534984f, 0.01126300f, 0.00342502f, 
    -0.02568852f, 0.00353640f, 0.04115486f, 0.00938959f, -0.05510469f, 0.03177586f, 0.02537532f, -0.01123954f, 
    -0.03809996f, 0.01089335f, -0.04334399f, 0.01331449f, -0.04454032f, -0.05653382f, -0.02348982f, -0.03811111f, 
    0.02921360f, -0.03007381f, -0.02127758f, -0.02827832f, -0.00217711f, 0.01392017f, -0.04942863f, -0.01371719f, 
    0.01470121f, -0.04068714f, -0.05706137f, -0.03014447f, -0.02929032f, -0.00519061f, -0.01160644f, 0.00574881f, 
    0.02478554f, -0.02919230f, 0.01060432f, -0.04589038f, -0.02524908f, 0.02925585f, 0.04006145f, -0.04263996f, 
    0.01100886f, 0.01240329f, -0.04772640f, 0.03968280f, -0.00929952f, -0.03592865f, -0.05339748f, -0.04504063f, 
    0.02312143f, 0.00712230f, 0.02310403f, 0.01778490f, -0.06056757f, -0.01611078f, -0.01645291f, 0.00060215f, 
    0.03588488f, -0.03938790f, -0.02843825f, 0.01505481f, -0.00080906f, -0.03365003f, 0.02106330f, -0.02254947f, 
    -0.00972649f, -0.00687791f, -0.05091115f, 0.00959711f, 0.02281399f, -0.00241810f, -0.05739269f, -0.04578049f, 
    0.00255691f, 0.03065788f, 0.03068592f, 0.01662881f, 0.04201614f, 0.02288678f, 0.03096583f, -0.01178907f, 
    -0.00273625f, -0.05885572f, 0.00810982f, -0.00807976f, 0.00203320f, -0.02859818f, 0.00733828f, 0.02433010f, 
    -0.00456978f, -0.04955133f, 0.02912320f, -0.03913357f, -0.01174572f, -0.02395810f, 0.02792233f, -0.00446640f, 
    -0.01308304f, 0.03705651f, 0.02281857f, -0.02366994f, 0.00162517f, -0.05473676f, 0.00229427f, -0.04000349f, 
    -0.01037949f, -0.02539351f, -0.03258370f, 0.02242525f, -0.03573716f, -0.05473828f, 0.01417850f, 0.01774932f, 
    -0.01540938f, 0.02602665f, 0.03693552f, -0.01430394f, 0.02991980f, 0.01357078f, -0.00960845f, 0.00064563f, 
    -0.02300204f, 0.00449898f, -0.00202800f, -0.00926333f, 0.04305016f, -0.05665625f, -0.03950139f, -0.05209505f, 
    -0.04185204f, -0.00576934f, 0.01494117f, 0.00597724f, -0.01791518f, -0.05904698f, -0.03647357f, -0.00449249f, 
    -0.00578308f, -0.04341700f, -0.00594180f, 0.01101629f, 0.04165800f, -0.05885423f, -0.00112152f, -0.01556545f, 
    -0.04198678f, 0.00085458f, -0.00092557f, 0.00696802f, -0.04387259f, -0.01582010f, -0.01169788f, 0.04326073f, 
    -0.04021732f, -0.00795085f, 0.02835429f, 0.02555905f, -0.02093489f, 0.03350988f, -0.04986412f, 0.03155695f, 
    0.00574808f, -0.00566481f, 0.03342151f, 0.04006226f, -0.00384826f, -0.01321107f, 0.00492611f, 0.03779377f, 
    -0.02551419f, -0.00005503f, -0.04506346f, -0.00235091f, -0.03079343f, -0.02099610f, 0.00388950f, -0.04589651f, 
    -0.01190013f, 0.02895336f, -0.00167539f, 0.00041938f, 0.00420167f, -0.04236483f, -0.03527775f, 0.03212170f, 
    -0.04261084f, -0.04112999f, 0.03991162f, -0.04736138f, 0.02564440f, 0.00452254f, -0.02890354f, 0.00809662f, 
    0.02672855f, 0.03097728f, 0.04231872f, 0.00823753f, 0.02086000f, -0.02368002f, -0.00179233f, 0.04321524f, 
    -0.04982574f, -0.04035084f, 0.01356711f, 0.03231868f, 0.01631187f, -0.02865796f, 0.00173895f, -0.01082327f, 
    -0.00891761f, -0.04906199f, -0.03606150f, -0.00642188f, -0.01009783f, 0.03616825f, -0.03059610f, -0.03559161f, 
    0.03862755f, 0.03025540f, -0.03729093f, -0.01917226f, -0.02477511f, 0.00089967f, 0.02253567f, -0.01219386f, 
    -0.04694074f, 0.03759759f, -0.05481162f, 0.01966738f, 0.02301153f, 0.01386972f, -0.05212928f, 0.01047110f, 
    -0.03360306f, -0.04454341f, 0.03847998f, -0.00912048f, -0.03625676f, 0.03115629f, -0.05253803f, 0.00686173f, 
    -0.05272101f, -0.03888363f, -0.00673439f, -0.02086417f, -0.02045299f, 0.00297115f, -0.03754847f, -0.05775477f, 
    0.01029523f, 0.00188388f, 0.04035765f, -0.01035871f, 0.00462049f, -0.02704736f, 0.02593541f, 0.02863502f, 
    0.02194055f, 0.04331363f, 0.02094736f, 0.02112919f, 0.03178446f, -0.05220785f, 0.03174307f, -0.03433152f, 
    -0.02466659f, -0.01634823f, -0.01032361f, -0.02658808f, 0.00711178f, -0.01027455f, -0.03321989f, -0.01218472f, 
    -0.02005985f, 0.03206874f, -0.04799210f, -0.03547713f, 0.01593290f, 0.04161103f, 0.04333570f, 0.03007040f, 
    0.01720020f, -0.05128058f, -0.00030385f, -0.00110754f, 0.00378764f, -0.00905931f, -0.00363995f, 0.01788833f, 
    0.02674411f, 0.02591164f, -0.02324188f, 0.03830538f, -0.01374890f, -0.01172408f, 0.04366048f, -0.01023838f, 
    -0.05660712f, -0.02330049f, 0.00099607f, 0.04172340f, -0.02191633f, -0.02236742f, -0.02864152f, 0.01194996f, 
    -0.02965341f, -0.05813342f, 0.01356387f, 0.00304975f, -0.02442649f, 0.04195208f, 0.03884660f, 0.01262449f, 
    -0.04606295f, 0.00770482f, -0.05371646f, -0.04845611f, -0.05489010f, 0.00270256f, -0.02621966f, -0.01098999f, 
    0.02115460f, 0.03462265f, 0.03137789f, -0.03133260f, 0.00658371f, -0.00847940f, -0.03399875f, 0.03799902f, 
    -0.01976102f, -0.01543092f, -0.02086501f, -0.01783135f, -0.05130244f, -0.05294676f, 0.02660172f, 0.01523120f, 
    0.00637894f, 0.03385332f, 0.02517446f, -0.04264672f, 0.00796245f, 0.02434145f, -0.03942983f, 0.00331488f, 
    -0.03435985f, -0.01773752f, -0.04444224f, -0.01353712f, -0.03786446f, -0.00445246f, 0.00256894f, 0.04170144f, 
    0.03871996f, -0.02783357f, -0.05077965f, -0.02566849f, -0.02159791f, 0.02914882f, 0.00424235f, 0.03989631f, 
    -0.01204400f, -0.03279237f, 0.02555388f, -0.02558170f, -0.01657511f, 0.02729746f, 0.04258582f, -0.01168886f, 
    0.01125854f, -0.00446908f, -0.01184146f, -0.03056361f, -0.03281476f, -0.02001778f, -0.04353027f, 0.00919940f, 
    -0.01918649f, -0.02747475f, -0.05172195f, 0.01894356f, -0.01722818f, -0.03883605f, -0.00110440f, 0.01801790f, 
    -0.04271823f, -0.05310544f, -0.04282781f, -0.00936184f, -0.02148768f, 0.01090608f, -0.01404552f, -0.05646780f, 
    -0.00283982f, -0.00480443f, -0.05280152f, -0.02254476f, -0.01324632f, 0.02563946f, 0.03415453f, -0.00098378f, 
    -0.04913598f, -0.02936582f, -0.01664227f, 0.00979815f, 0.02162678f, -0.00741790f, -0.00679391f, -0.02679213f, 
    -0.04123344f, 0.01140102f, -0.04406023f, -0.00353154f, -0.00957773f, 0.00785567f, -0.00712162f, -0.00654960f, 
    -0.01087493f, -0.03931206f, 0.01009945f, 0.00386561f, -0.02974441f, 0.01831796f, 0.03860967f, 0.03190855f, 
    0.02707377f, 0.01697589f, 0.01294923f, -0.00509406f, -0.02120600f, -0.04269529f, 0.03564389f, -0.00003430f, 
    -0.00484852f, 0.00276581f, -0.00223581f, 0.02934046f, 0.03068489f, -0.02464949f, -0.00657320f, 0.03918111f, 
    0.04641561f, -0.03570609f, -0.01564247f, -0.00761312f, -0.01803996f, 0.00160039f, 0.01615559f, 0.00139680f, 
    0.03334301f, -0.04569191f, 0.03358421f, -0.01897450f, -0.03769966f, 0.00477394f, -0.03848316f, -0.04876354f, 
    0.01948734f, -0.01827107f, -0.04136212f, -0.05364047f, -0.04125493f, -0.05449892f, 0.01763247f, -0.05107400f, 
    -0.04951873f, -0.01433927f, 0.00953721f, 0.00180964f, 0.02733207f, 0.04311046f, 0.01479156f, 0.01131008f, 
    -0.03937440f, 0.01684625f, -0.04901450f, 0.03305924f, 0.03767474f, 0.01194186f, 0.02640726f, -0.00848169f, 
    -0.05365902f, 0.01279504f, -0.04870228f, 0.04035068f, 0.04444295f, -0.00307745f, -0.04793907f, 0.00834769f, 
    -0.03337556f, -0.03069928f, 0.02702299f, 0.03998363f, -0.01045520f, 0.02273566f, -0.05288871f, -0.03095726f, 
    -0.02123541f, 0.01825450f, -0.05641399f, 0.01769145f, 0.02662564f, 0.02096634f, -0.00815360f, -0.04367752f, 
    0.01602410f, 0.00240241f, -0.05689123f, 0.00131514f, 0.00859628f, -0.04192116f, 0.02459728f, -0.03122204f, 
    0.01168916f, -0.00590892f, -0.00748955f, 0.02223642f, 0.02857845f, 0.02769712f, 0.01595410f, -0.01738216f, 
    -0.02202652f, -0.04114887f, -0.03077242f, -0.04479349f, -0.03534710f, 0.03952700f, -0.01331108f, 0.01732434f, 
    -0.04930168f, -0.01232559f, -0.04682723f, 0.01283020f, -0.03446238f, -0.03879375f, 0.03686281f, 0.01493361f, 
    -0.01661655f, 0.03012476f, 0.00694293f, 0.00637334f, 0.04285349f, 0.02976859f, 0.01972291f, 0.00430130f, 
    -0.00340962f, 0.04122679f, -0.04042429f, -0.00046714f, -0.00262503f, -0.03431236f, -0.01872221f, 0.00768003f, 
    -0.01162023f, 0.01267877f, 0.00423911f, 0.01537114f, -0.02953879f, -0.04345041f, 0.03840337f, -0.03197633f, 
    -0.02377755f, 0.02519291f, -0.02632693f, -0.03900509f, 0.00383911f, -0.03021040f, -0.03430795f, -0.02186374f, 
    -0.01336658f, -0.05684414f, -0.05091698f, 0.01410700f, -0.04880755f, 0.03247400f, -0.04051178f, -0.00384927f, 
    0.03060357f, 0.01610386f, -0.01412621f, -0.02431382f, -0.04308136f, -0.05319399f, -0.00754862f, -0.01642704f, 
    0.03890967f, 0.02822935f, -0.02987141f, 0.02677672f, -0.05024344f, 0.00519976f, 0.01586982f, -0.02249634f, 
    -0.03727151f, -0.00944604f, 0.04712942f, -0.05168393f, 0.04080426f, 0.03676645f, -0.01214687f, 0.00604543f, 
    -0.03470582f, -0.05393900f, 0.04441482f, -0.00237485f, 0.00476292f, -0.00421495f, 0.02875679f, -0.05154241f, 
    -0.01669598f, -0.03616140f, -0.02910165f, -0.03428434f, -0.03002058f, 0.00936330f, -0.01348417f, -0.05655892f, 
    -0.00723446f, 0.00676820f, -0.03757418f, 0.01960611f, -0.02709352f, -0.00083727f, -0.02367200f, 0.00692863f, 
    -0.02147180f, -0.02766282f, 0.04441026f, -0.02031832f, -0.04561428f, -0.03133541f, 0.04265514f, -0.03705124f, 
    -0.03321762f, 0.01574241f, 0.03056097f, 0.04363868f, 0.03624435f, 0.02539358f, 0.00319082f, 0.02584421f, 
    0.03046553f, -0.02691201f, -0.02589107f, -0.04478777f, 0.01266061f, -0.04605313f, -0.00329329f, 0.04044088f, 
    -0.02384860f, 0.02073830f, 0.03342414f, 0.04296812f, -0.02886955f, 0.03929644f, -0.04227651f, 0.00630629f, 
    0.00005878f, 0.03658660f, 0.01827584f, -0.04453483f, 0.01507374f, -0.00864243f, -0.00010090f, -0.01914022f, 
    -0.04853263f, -0.05482485f, -0.03076351f, 0.00642599f, -0.00927445f, 0.02865313f, -0.03511011f, 0.04355944f, 
    0.02470384f, -0.05050952f, 0.00320249f, -0.01404567f, 0.01927496f, -0.03472009f, 0.01658425f, 0.01154617f, 
    -0.03157955f, -0.02214731f, -0.00300210f, -0.02245539f, -0.04628087f, 0.00159077f, -0.02728762f, -0.03373566f, 
    0.03443926f, -0.02404279f, -0.02124882f, -0.03093443f, -0.01788426f, -0.00676906f, -0.03320501f, -0.00624481f, 
    0.02486380f, 0.03061735f, -0.00861421f, -0.03547299f, -0.03755809f, -0.03230695f, -0.05528161f, 0.03653726f, 
    -0.01001388f, 0.01915543f, -0.04652428f, -0.01002316f, -0.03274678f, -0.02446666f, -0.04643648f, -0.04485124f, 
    -0.02770510f, -0.03479504f, -0.02591330f, -0.05468842f, 0.01015097f, -0.02214076f, -0.00129501f, -0.02638097f, 
    0.00573662f, -0.00545358f, -0.05653070f, -0.05109489f, 0.03339391f, 0.00216738f, 0.00843215f, -0.02209095f, 
    -0.03045182f, 0.01091117f, -0.01289352f, 0.04356772f, 0.00504085f, -0.03921858f, -0.03499608f, 0.00379183f, 
    -0.00335163f, -0.02168156f, 0.03641576f, -0.03973776f, 0.02883496f, 0.02549541f, -0.02786396f, 0.04443114f, 
    0.00756858f, -0.00310043f, -0.00324174f, -0.02228956f, -0.00100383f, 0.02253729f, 0.03459559f, 0.04212806f, 
    -0.00529504f, 0.01063181f, -0.04585859f, -0.05428765f, -0.05426187f, -0.00490605f, -0.05497343f, -0.04612298f, 
    -0.03735625f, -0.03756248f, -0.00401260f, 0.02789785f, 0.01590687f, -0.03378965f, -0.00294540f, -0.04716592f, 
    0.03720096f, 0.01092898f, 0.01400003f, -0.01852079f, -0.03300380f, -0.01513214f, -0.04216533f, 0.01001834f, 
    0.01144278f, 0.04286733f, -0.02792069f, -0.02279772f, -0.00962776f, 0.03034267f, 0.04032409f, -0.04702454f, 
    -0.01094379f, -0.02578229f, -0.03434018f, -0.03956629f, -0.00395578f, 0.03128036f, -0.01014958f, -0.03944974f, 
    -0.03161410f, -0.01418890f, 0.00194778f, 0.00727632f, 0.03420903f, -0.05216737f, 0.01996459f, 0.04226006f, 
    -0.00409752f, -0.00354029f, 0.00000230f, -0.03791677f, 0.02361470f, 0.04082445f, -0.01290048f, 0.00372750f, 
    0.03937479f, -0.00309390f, 0.00627363f, -0.01321483f, -0.05032348f, -0.04750609f, -0.02918159f, 0.00211022f, 
    0.03967533f, -0.03737782f, -0.01798401f, 0.00789786f, -0.05300055f, 0.02551078f, -0.03266873f, -0.01986313f, 
    -0.04099914f, -0.01581019f, -0.04910011f, -0.00478515f, -0.01131711f, 0.04271294f, 0.02313618f, 0.01645913f, 
    0.00079842f, -0.05363574f, -0.03882813f, 0.01466733f, 0.02900099f, -0.02830276f, -0.04221183f, -0.00237299f, 
    -0.05037240f, 0.00194076f, 0.01719833f, -0.02149310f, 0.02631580f, -0.03187901f, -0.03650965f, 0.03701114f, 
    0.06019764f, -0.04233812f, 0.21893892f, -0.03251693f, -0.14986078f, 0.10769635f, 0.12366119f, -0.00913194f, 
    -0.11215515f, 0.04130034f, 0.08544170f, 0.08279680f, -0.07333886f, -0.00993082f, 0.01216553f, -0.06249682f, 
    0.04738069f, 0.01075386f, -0.06766423f, 0.09220498f, 0.03618615f, 0.05932173f, 0.08483400f, -0.02434666f, 
    -0.00211732f, 0.04596373f, -0.01763120f, -0.18124916f, -0.15003248f, 0.10393371f, 0.05412601f, -0.14360587f, 
    0.13065633f, 0.05499219f, -0.14101046f, -0.05884912f, -0.20362458f, 0.10521962f, 0.11691469f, -0.09881475f, 
    0.05328704f, -0.07700314f, -0.04171017f, 0.00167109f, 0.14456786f, -0.02671023f, -0.01725784f, -0.04319776f, 
    0.17183688f, 0.08341704f, 0.08847242f, 0.12443753f, -0.07611946f, 0.03455990f, 0.09105177f, 0.12729807f, 
    -0.07441586f, 0.08617327f, 0.14040780f, 0.02861712f, -0.08411239f, -0.15585278f, 0.00704264f, -0.08937840f, 
    -0.06536298f, 0.01234768f, -0.02277627f, -0.06568909f, 0.05767393f, 0.00078425f, -0.15172562f, 0.11734499f, 
    -0.11251732f, 0.06329210f, -0.07517489f, 0.05844430f, -0.02988748f, -0.14258595f, -0.14673387f, -0.05693883f, 
    -0.04245664f, -0.12705636f, -0.12350582f, -0.13675751f, 0.07202809f, 0.11501745f, 0.11753217f, -0.02659282f, 
    0.08871907f, -0.12171883f, -0.00874272f, -0.16595317f, -0.16785473f, -0.08195429f, 0.05404367f, 0.04469906f, 
    -0.15511860f, -0.00232257f, 0.07131425f, 0.12617053f, 0.02001761f, -0.11765786f, 0.01485212f, 0.08608296f, 
    -0.01317872f, -0.13888960f, 0.00601563f, -0.01418244f, -0.13287923f, -0.07564232f, -0.15752935f, -0.10761986f, 
    -0.03890797f, 0.07934526f, -0.05071539f, -0.09308490f, 0.01486734f, -0.01832248f, 0.10306873f, 0.00538764f, 
    -0.26044104f, 0.02322356f, -0.06400912f, 0.19726536f, -0.11583807f, 0.07472363f, 0.08075526f, 0.08337811f, 
    0.01288659f, 0.10809130f, 0.12973318f, 0.06092440f, -0.06981363f, 0.24965444f, 0.13822451f, 0.00171909f, 
    0.11306980f, -0.06022239f, -0.01997328f, -0.11087536f, 0.06514546f, -0.11903436f, -0.02867326f, -0.05669144f, 
    0.18904972f, 0.08171985f, 0.11656756f, 0.03129353f, 0.21296200f, 0.10554820f, -0.02279334f, 0.00986532f, 
    0.00819590f, 0.12071011f, 0.13078205f, 0.02111225f, -0.17042936f, -0.05701040f, -0.00926319f, -0.03981718f, 
    0.05585991f, -0.04034894f, 0.02224410f, 0.02444440f, 0.07178275f, 0.13525333f, 0.04931906f, 0.08800040f, 
    -0.02225371f, 0.01073573f, 0.06165566f, 0.05835277f, -0.09826659f, 0.01040718f, -0.00276709f, -0.00395113f, 
    0.06038398f, -0.00283407f, 0.12215930f, 0.12777418f, 0.11946697f, -0.03898812f, 0.17456347f, 0.09657547f, 
    0.10148134f, 0.04356633f, -0.15027107f, 0.00980771f, 0.06615979f, 0.04618383f, 0.02653144f, 0.00604311f, 
    -0.09319042f, 0.05508580f, 0.12269824f, 0.27465451f, -0.01215104f, -0.00709237f, 0.03570232f, -0.02142794f, 
    0.07353504f, -0.02093859f, -0.09984876f, -0.01804709f, -0.12841363f, 0.06962787f, 0.11306905f, -0.01571021f, 
    0.08093801f, -0.03369942f, -0.02241097f, -0.01850398f, 0.02072262f, -0.01546805f, 0.08767173f, 0.11983971f, 
    -0.18957765f, 0.00686304f, -0.03092284f, 0.12434757f, 0.07624491f, -0.04494323f, -0.05965498f, 0.06879648f, 
    -0.01539988f, 0.10764164f, -0.04483572f, 0.12066723f, -0.19528359f, 0.00718137f, -0.09632658f, -0.03774302f, 
    0.06901801f, 0.03368064f, -0.07669361f, 0.06680863f, 0.15957320f, 0.02913221f, 0.03544528f, 0.05152961f, 
    0.15491900f, -0.00809438f, 0.10885595f, 0.09755338f, -0.00855873f, 0.08944912f, -0.00426324f, 0.03599393f, 
    0.00996892f, -0.01276015f, 0.08636117f, 0.00930308f, -0.04727409f, -0.03859864f, 0.04223909f, 0.14494446f, 
    -0.02966459f, -0.00802927f, -0.06593353f, -0.00450568f, -0.01273784f, 0.01588682f, 0.01214803f, 0.01137733f, 
    0.05877658f, 0.13200948f, -0.05140416f, -0.08224643f, -0.07499148f, 0.05991049f, -0.04434595f, -0.00614889f, 
    -0.09862074f, -0.10066155f, -0.07280634f, -0.01324357f, -0.14440303f, -0.01938081f, -0.04983487f, -0.11270671f, 
    0.05388114f, -0.03041370f, 0.02533461f, 0.15632090f, 0.11212489f, 0.09164823f, 0.19917631f, -0.00568477f, 
    -0.10664627f, -0.04770319f, -0.03094466f, 0.15255700f, -0.03886736f, -0.11566148f, 0.00316190f, 0.02117834f, 
    0.03481318f, 0.01432783f, 0.03812498f, 0.03813514f, 0.31628594f, 0.05961333f, -0.04470316f, -0.12953411f, 
    -0.04223306f, 0.04622030f, 0.03624586f, -0.03750400f, 0.00173409f, -0.06960846f, -0.09374239f, -0.10068239f, 
    0.06632247f, 0.05605429f, 0.09387781f, -0.04561488f, 0.10800673f, 0.13843118f, 0.02098037f, 0.05469904f, 
    0.06886619f, 0.14929081f, 0.09732807f, 0.06047195f, -0.08896190f, 0.01554087f, -0.03315426f, -0.05813589f, 
    -0.00337650f, -0.00087007f, -0.04849881f, -0.00533754f, -0.04347841f, 0.03600870f, 0.00248402f, -0.06532364f, 
    -0.11790588f, 0.09842487f, -0.00834432f, 0.01465132f, 0.08211655f, -0.07550421f, 0.11154777f, 0.09168243f, 
    0.06192150f, 0.09114883f, -0.00697904f, 0.04783064f, 0.17566317f, 0.39881325f, -0.17736083f, -0.09173889f, 
    0.03592606f, 0.14212945f, -0.09162619f, -0.12371302f, 0.02400463f, -0.06266839f, 0.01790218f, 0.00295031f, 
    -0.04299129f, -0.05143752f, 0.10208064f, -0.06629955f, -0.04739104f, -0.00676416f, -0.05143464f, -0.06468064f, 
    -0.00805749f, -0.04753029f, 0.15636528f, 0.07566935f, -0.20805743f, 0.02565421f, 0.31560394f, 0.15787043f, 
    0.05411531f, -0.04243647f, 0.02828886f, 0.01262338f, 0.02465519f, -0.06734475f, 0.00607758f, -0.07938904f, 
    0.04005814f, -0.01439507f, -0.03029770f, -0.03508598f, -0.01353691f, -0.00257663f, -0.01329269f, -0.02493371f, 
    -0.03374033f, 0.00774056f, -0.02864939f, -0.01039455f, -0.05160905f, -0.01615199f, 0.02746434f, 0.00399344f, 
    0.03540336f, -0.00728630f, -0.01372803f, 0.00887499f, 0.02644564f, 0.02206903f, -0.03330206f, -0.01738041f, 
    -0.04724050f, -0.02896015f, -0.05114762f, 0.03906795f, -0.05567971f, 0.01687214f, -0.04891150f, -0.05539911f, 
    0.01719864f, -0.00206566f, -0.03466665f, -0.03380915f, 0.03633187f, -0.05712150f, 0.04258552f, -0.03026832f, 
    -0.01581632f, 0.03265605f, 0.01696542f, -0.01607166f, 0.04303605f, -0.03192364f, 0.04630988f, -0.05547243f, 
    0.04005912f, -0.03836664f, -0.01275486f, 0.00767591f, 0.00995823f, -0.05202357f, -0.03478876f, -0.01109837f, 
    0.00619620f, -0.00017833f, -0.03841259f, -0.01776466f, -0.04298355f, -0.00850336f, 0.04196998f, -0.03932904f, 
    -0.01674329f, 0.01312376f, 0.00924998f, 0.04440873f, -0.03478241f, -0.04470068f, 0.02611221f, 0.01642558f, 
    0.02773632f, 0.03654089f, -0.00978514f, -0.02575500f, -0.03434091f, -0.00363024f, -0.04909918f, -0.03221456f, 
    -0.01765162f, 0.01757413f, 0.02808756f, -0.02918878f, 0.02177911f, 0.02980037f, -0.02310300f, -0.04831909f, 
    0.00269900f, -0.05251150f, 0.04127612f, -0.05211124f, -0.00527851f, 0.01132263f, -0.04973067f, -0.00236561f, 
    -0.00682796f, 0.02438564f, -0.02937826f, -0.01687100f, 0.01448988f, 0.02697317f, -0.00277348f, -0.00152322f, 
    0.02158541f, 0.01323902f, 0.01822021f, 0.02299009f, 0.01414093f, 0.02055291f, 0.01681162f, -0.01954136f, 
    -0.02735942f, -0.01118463f, 0.04024932f, -0.04863783f, 0.04847607f, -0.01875570f, -0.01350590f, -0.00993625f, 
    0.04305080f, 0.04223367f, -0.02679355f, -0.02063450f, 0.00008975f, 0.03673718f, -0.02452777f, 0.00267259f, 
    -0.04234500f, 0.02014370f, 0.01891629f, -0.01801110f, 0.03887477f, -0.05068118f, 0.04233912f, -0.03854134f, 
    -0.03286034f, -0.05469677f, 0.02607860f, -0.03601005f, -0.03829908f, 0.02397318f, -0.04564153f, -0.02529969f, 
    -0.01205635f, -0.02404027f, -0.01061991f, -0.00026578f, 0.04639978f, -0.00123047f, -0.05164824f, -0.01474347f, 
    0.01181157f, 0.01607977f, -0.02518099f, -0.03601935f, 0.03446903f, -0.01740045f, -0.00737535f, -0.03660343f, 
    -0.04066610f, 0.03264237f, 0.02316616f, 0.02599094f, -0.02239837f, 0.00238170f, 0.01834907f, -0.02437503f, 
    -0.00148228f, 0.04527261f, -0.04528313f, 0.02277014f, -0.01638512f, 0.01886091f, -0.03359724f, -0.03840281f, 
    0.03800229f, -0.04462588f, -0.03237749f, -0.02716159f, 0.04713601f, 0.02031433f, -0.05063353f, -0.01573791f, 
    -0.02224407f, -0.03911092f, -0.02247328f, -0.02147686f, -0.04585848f, -0.02646401f, -0.05381658f, -0.02374759f, 
    -0.04002197f, 0.02702045f, 0.01896761f, -0.03421415f, 0.00569234f, 0.01826740f, -0.00713781f, 0.03073694f, 
    0.02669621f, -0.06062344f, -0.05417914f, 0.03166413f, -0.03663675f, -0.02817193f, 0.00797897f, -0.04257648f, 
    0.04460991f, -0.02535842f, 0.03313361f, -0.01509600f, 0.02643042f, 0.01408333f, 0.02274378f, 0.01006417f, 
    -0.03062157f, -0.00535187f, 0.03944612f, 0.01659403f, 0.01558928f, 0.03998626f, 0.01802265f, -0.05314101f, 
    0.00724556f, 0.02000126f, -0.00402801f, -0.04258412f, 0.03618877f, 0.03216377f, -0.02877801f, 0.01827344f, 
    -0.02783354f, -0.03090639f, -0.01772273f, 0.01915988f, -0.04476834f, -0.01001893f, -0.02427184f, 0.04264921f, 
    -0.03645378f, -0.02340914f, -0.05585488f, 0.04596435f, -0.01437860f, -0.00314636f, 0.03151438f, -0.01349054f, 
    -0.05823256f, 0.01894270f, 0.03773169f, 0.01363377f, 0.03729139f, 0.03169095f, -0.05238117f, 0.01471782f, 
    -0.02514976f, -0.01436764f, -0.01022974f, -0.03302794f, -0.02849849f, -0.04309478f, 0.01452600f, -0.02489559f, 
    -0.04098186f, -0.02487059f, 0.03253480f, -0.00860541f, 0.03580266f, 0.03499507f, -0.02501658f, -0.00141739f, 
    0.01663805f, -0.04468575f, 0.01583461f, 0.00527617f, 0.04637918f, 0.02097184f, 0.01260381f, -0.05182763f, 
    -0.02520945f, 0.00839515f, 0.03228931f, -0.01651412f, -0.03039010f, 0.01688152f, -0.01004578f, -0.00388525f, 
    0.04212590f, 0.00682514f, -0.03995280f, -0.03992204f, -0.02857210f, -0.05076362f, -0.00810294f, 0.03261034f, 
    -0.01424322f, -0.03002323f, 0.03659975f, 0.01595899f, -0.02338441f, -0.01076210f, 0.03945116f, 0.02490319f, 
    0.01230042f, 0.01650806f, -0.00294868f, -0.00486327f, -0.03643101f, -0.01832682f, -0.04336910f, 0.02197177f, 
    -0.01025012f, 0.01027994f, -0.04491749f, -0.03626363f, -0.02446622f, 0.01406773f, 0.01409211f, -0.02450825f, 
    0.01397337f, 0.03476501f, -0.05952037f, -0.05232333f, -0.00040777f, 0.02641097f, 0.02101669f, -0.05244298f, 
    0.01213670f, 0.02770374f, -0.02576066f, 0.00389512f, -0.03945785f, 0.02555810f, -0.00297454f, -0.01810036f, 
    -0.04124398f, -0.04098288f, 0.03757674f, -0.05624580f, -0.00925229f, -0.05039685f, 0.01169835f, -0.01525504f, 
    0.02894945f, -0.05387823f, 0.00996290f, -0.00521080f, -0.05806206f, -0.00042582f, -0.00351201f, -0.05484388f, 
    -0.03775110f, -0.04147026f, -0.03579827f, -0.04898321f, -0.00373280f, -0.01459880f, -0.02725084f, -0.05613599f, 
    -0.05252088f, 0.01269416f, -0.02535776f, 0.03185032f, -0.02747549f, -0.05548611f, 0.00672026f, 0.00528115f, 
    -0.03623707f, -0.01455040f, 0.03615010f, -0.01945725f, -0.02658332f, 0.02672048f, 0.03601974f, -0.00770131f, 
    -0.05444289f, 0.03497636f, -0.03584716f, -0.03481903f, -0.01115570f, 0.02705950f, -0.04104949f, -0.05020850f, 
    0.09671658f, 0.10264681f, 0.14425343f, -0.11947227f, -0.09777741f, 0.03668447f, 0.04770560f, 0.01831031f, 
    -0.04624039f, -0.07228920f, -0.00482510f, 0.13345687f, -0.02760215f, 0.21488424f, 0.20611072f, -0.25601032f, 
    0.00873882f, -0.14012410f, -0.09611866f, 0.02206465f, 0.14465511f, -0.02549846f, 0.01116340f, 0.04264639f, 
    -0.32058799f, 0.00463791f, -0.01888735f, -0.07728442f, 0.05476656f, 0.01653245f, 0.02395753f, -0.10789551f, 
    0.07930138f, -0.06337523f, 0.02935220f, 0.05337994f, -0.29859707f, 0.03196141f, 0.18005066f, -0.14414710f, 
    -0.06903763f, -0.01151320f, -0.02146236f, 0.04993594f, 0.00999441f, -0.08931467f, -0.11284333f, -0.07913936f, 
    -0.18980964f, 0.07299300f, 0.16009052f, 0.03874234f, 0.05568377f, 0.00000100f, 0.04968799f, 0.09933231f, 
    -0.11069306f, 0.01149693f, 0.09867255f, 0.00278503f, 0.05489024f, 0.17133990f, 0.08686716f, 0.08842972f, 
    0.04194048f, 0.06924804f, -0.03174315f, -0.04944065f, -0.00947143f, 0.03840800f, -0.02536998f, 0.03605298f, 
    0.10345043f, -0.02044605f, 0.11721873f, 0.00799591f, 0.04923600f, -0.17452227f, -0.03395105f, -0.07716182f, 
    -0.05330104f, -0.15448204f, 0.07764113f, -0.06759527f, -0.04807512f, -0.05898697f, 0.09545111f, -0.05990410f, 
    0.16238074f, -0.09945285f, -0.03434099f, -0.19096857f, -0.03444474f, 0.01323574f, 0.02814670f, 0.11022741f, 
    0.11113013f, 0.01555412f, 0.05463579f, 0.25444883f, 0.06036331f, -0.05400266f, -0.02659366f, -0.04634871f, 
    -0.00443506f, -0.08385111f, -0.02027147f, 0.07139057f, -0.09152089f, 0.20397188f, 0.05882758f, 0.02421063f, 
    0.09964312f, -0.07473753f, 0.00567720f, -0.02100633f, -0.06696927f, 0.05132366f, 0.02170156f, 0.04381188f, 
    -0.04897954f, 0.30894029f, -0.18092750f, 0.21896204f, 0.03790906f, 0.06588050f, 0.04604476f, -0.02339824f, 
    0.00060913f, 0.03540039f, -0.00174372f, 0.00613555f, -0.04526013f, -0.33789429f, 0.07128581f, 0.11563028f, 
    0.07153630f, -0.00138482f, 0.06513076f, -0.11765745f, 0.06029116f, -0.05758283f, -0.00082765f, 0.03746836f, 
    -0.00854527f, 0.01737962f, 0.01027675f, -0.03464771f, 0.09832174f, 0.09283336f, -0.07079057f, -0.00931882f, 
    0.03645735f, 0.02084512f, 0.05608121f, -0.10012016f, 0.08330593f, 0.22177181f, 0.15278688f, -0.09288914f, 
    -0.05190753f, -0.03429071f, -0.03990354f, -0.02327811f, 0.03287257f, 0.05156705f, -0.00319963f, -0.04851364f, 
    -0.09305795f, 0.24977081f, -0.17136721f, 0.13842075f, -0.06503640f, 0.06629868f, -0.08972818f, -0.10887951f, 
    0.01538601f, -0.19933683f, 0.12300046f, 0.13644719f, -0.07923880f, -0.09363094f, 0.00301901f, -0.10131165f, 
    -0.02958638f, 0.01512069f, -0.07501093f, -0.03820671f, 0.10974106f, -0.04238613f, 0.18478271f, 0.15544905f, 
    0.08161502f, -0.05213015f, -0.17840762f, 0.17273739f, 0.01554252f, -0.00280109f, 0.04369177f, 0.06494948f, 
    0.07511356f, 0.00217512f, 0.00495652f, 0.07054710f, 0.04850122f, -0.13707443f, 0.03072634f, 0.02346452f, 
    0.03413768f, -0.06647303f, -0.05040029f, -0.03797543f, 0.01845625f, -0.00867764f, 0.10145488f, 0.09772884f, 
    0.17451157f, -0.17902908f, 0.05320722f, -0.00682905f, 0.07337322f, 0.01219288f, 0.03571203f, 0.03864887f, 
    0.02099375f, 0.03116869f, -0.00305246f, 0.01024003f, -0.17145671f, 0.10798369f, -0.30614901f, 0.14195423f, 
    -0.07009215f, 0.14676481f, -0.04151357f, 0.06890285f, 0.19012284f, -0.05503176f, 0.02550531f, -0.05034437f, 
    0.10022725f, 0.13503672f, -0.09230591f, 0.01361862f, -0.05522771f, -0.00426862f, -0.08226748f, -0.14029391f, 
    0.01389720f, -0.07528025f, 0.21710365f, -0.02268778f, -0.19885078f, -0.07321624f, 0.07154309f, 0.20698027f, 
    0.00203297f, 0.02882501f, 0.08849097f, 0.00698356f, -0.01954926f, -0.01395182f, 0.05442930f, -0.09163870f, 
    -0.13247032f, 0.26291558f, 0.07004043f, 0.03567626f, -0.04388059f, -0.07461511f, -0.08921410f, -0.05024626f, 
    -0.17275505f, 0.06530276f, 0.06790943f, -0.05055154f, -0.20894864f, -0.00195618f, 0.04583627f, -0.02747943f, 
    -0.03116335f, -0.10059560f, -0.02354801f, 0.12929282f, 0.04436735f, -0.02186210f, 0.01797670f, -0.01009311f, 
    0.07914580f, 0.06233995f, 0.09646858f, 0.12113009f, 0.02453560f, 0.01251928f, -0.00146144f, 0.07690851f, 
    0.02494525f, 0.05060933f, 0.02684826f, 0.06178477f, -0.11582427f, 0.08770527f, -0.06633678f, -0.07871522f, 
    0.14938532f, 0.04724972f, -0.00327839f, 0.03443035f, 0.00282640f, -0.03215288f, -0.08686843f, -0.08106215f, 
    -0.24125730f, -0.20110479f, 0.06878353f, -0.00926948f, 0.12728596f, 0.03171152f, 0.12038261f, 0.03723383f, 
    0.06255685f, 0.05589694f, 0.01720701f, 0.08112229f, -0.01055609f, 0.05179796f, 0.17039236f, -0.14717931f, 
    0.08283195f, -0.08984987f, 0.01075839f, 0.00948800f, 0.06223955f, 0.05656367f, 0.04465053f, -0.03799850f, 
    -0.36509609f, 0.19356199f, -0.08490022f, 0.01963273f, 0.10006347f, 0.01982937f, 0.04120339f, 0.01732760f, 
    -0.03674499f, 0.03161665f, 0.03118977f, -0.06515966f, -0.14387457f, -0.02715949f, -0.16280071f, 0.07518553f, 
    0.02611541f, 0.17987815f, -0.09224179f, -0.13207278f, 0.00121970f, -0.05117649f, 0.08082335f, 0.09676758f, 
    0.11720812f, 0.14370692f, 0.22825123f, 0.02368148f, -0.01234513f, 0.03552990f, -0.02958423f, -0.09619101f, 
    -0.08327264f, -0.04535008f, 0.08253849f, 0.03801162f, -0.05049059f, -0.14676031f, 0.13074844f, 0.09206904f, 
    0.03626389f, 0.06897001f, 0.03291820f, 0.06093572f, -0.00692899f, 0.07207545f, -0.04700105f, -0.10650545f, 
    0.15393804f, 0.14592396f, -0.24657810f, -0.18479370f, -0.01180077f, -0.06186678f, 0.08722275f, 0.12228980f, 
    0.03841231f, 0.01026121f, 0.11458805f, 0.13241337f, 0.04612774f, -0.18276806f, 0.05999136f, -0.02218967f, 
    0.02517223f, -0.06272595f, 0.00443053f, 0.07601387f, 0.00564636f, -0.12999366f, 0.04944096f, 0.09038567f, 
    0.24200875f, 0.00023237f, 0.11032629f, 0.04485967f, 0.00965963f, 0.00310933f, 0.03111909f, 0.03937131f, 
    0.10776749f, 0.02281461f, -0.01603948f, -0.08949009f, 0.26583546f, 0.00923167f, 0.16156758f, -0.01101179f, 
    -0.05122305f, 0.01500512f, -0.05456001f, -0.01538573f, -0.04751714f, 0.04255382f, -0.04825361f, 0.01999474f, 
    -0.02163410f, 0.05592245f, 0.04068780f, 0.19369765f, 0.05696064f, 0.03098681f, 0.05024066f, -0.04517025f, 
    0.14152192f, -0.16713379f, 0.05005265f, -0.11169067f, 0.12192271f, 0.03175633f, 0.14845990f, 0.15602107f, 
    0.05163645f, 0.04293528f, 0.01669851f, -0.02056705f, -0.00766521f, 0.01901011f, 0.01074149f, 0.07639708f, 
    0.15991987f, -0.15843004f, 0.03978865f, -0.01325825f, 0.08201247f, -0.02869766f, -0.02840300f, -0.01361002f, 
    0.05249604f, -0.12813269f, -0.07085226f, -0.04800825f, -0.15702637f, -0.03472411f, 0.08891533f, -0.06387666f, 
    0.11388515f, 0.05377558f, 0.00651420f, 0.00802823f, 0.01486679f, -0.03378011f, 0.05389823f, 0.08518388f, 
    0.27164111f, -0.06901689f, -0.03747603f, 0.02842587f, 0.05725314f, -0.01923849f, -0.15538186f, 0.00835084f, 
    -0.00751459f, -0.03133734f, 0.05015890f, 0.07564297f, 0.02475504f, 0.17486237f, 0.21549857f, 0.19169070f, 
    0.08963663f, -0.06348875f, 0.04434960f, -0.07461812f, 0.09976595f, -0.17034888f, 0.01755849f, 0.08568949f, 
    0.26163131f, 0.05750288f, -0.08297791f, 0.00420870f, -0.01684225f, 0.05757327f, 0.08075833f, -0.08643960f, 
    -0.06998092f, 0.02842384f, -0.03684383f, 0.01810124f, -0.08672589f, -0.32443812f, -0.01389376f, 0.14957708f, 
    -0.01988755f, 0.05585155f, -0.03523268f, -0.16179599f, -0.06849919f, 0.02631819f, 0.00407788f, 0.02917471f, 
    -0.10626537f, 0.02652628f, 0.05902860f, -0.07587652f, -0.02688360f, 0.08265271f, 0.06058185f, -0.01179799f, 
    0.12007523f, -0.00597871f, 0.01237078f, -0.02826653f, 0.07453497f, 0.06398135f, -0.02224489f, 0.01146835f, 
    -0.07631138f, -0.06674379f, -0.04978158f, -0.05415993f, -0.04278978f, -0.02455695f, 0.14880902f, -0.13433331f, 
    0.12214390f, 0.04214429f, -0.10115932f, -0.11714067f, 0.08153933f, -0.04661572f, -0.03339294f, -0.07815281f, 
    0.03951344f, 0.07887567f, -0.06390842f, 0.09765446f, -0.04900554f, -0.00762677f, -0.12293532f, -0.17212029f, 
    -0.00625011f, -0.03101699f, 0.01238538f, 0.02357920f, -0.00228218f, -0.08503119f, 0.07597444f, 0.11485343f, 
    0.04130659f, -0.14428820f, -0.13542579f, -0.19030866f, 0.21096988f, -0.10363015f, 0.04942941f, -0.04407235f, 
    0.10358984f, -0.23246555f, 0.00496390f, 0.03994793f, 0.03079255f, -0.00926666f, -0.09906489f, -0.11775390f, 
    0.04645527f, 0.08393078f, -0.07375492f, 0.08722940f, -0.00167179f, 0.04962409f, 0.21575771f, -0.03937024f, 
    0.42869538f, -0.11495283f, -0.10133067f, -0.06607613f, 0.00652180f, -0.06088420f, 0.06112342f, -0.07508636f, 
    0.06794420f, 0.06574620f, 0.07940713f, 0.01427363f, 0.15934549f, 0.16953957f, -0.03568356f, -0.02672956f, 
    0.09359454f, 0.02452396f, -0.08551040f, 0.08629082f, 0.05953389f, -0.03754860f, 0.17469661f, -0.00363605f, 
    -0.08877957f, -0.21433984f, -0.07604241f, 0.16844915f, -0.03330813f, 0.05026680f, -0.07193852f, -0.05915545f, 
    -0.07857621f, 0.05513311f, 0.04315973f, -0.01398526f, 0.10519471f, -0.09565514f, 0.13186479f, -0.13888170f, 
    0.02843956f, 0.00884447f, -0.01444740f, 0.12074328f, -0.14340794f, -0.04224025f, -0.01897465f, 0.09168635f, 
    -0.28368682f, -0.02200703f, 0.16448833f, -0.04548561f, 0.04807392f, -0.09945763f, -0.05395127f, 0.08733458f, 
    0.06020466f, 0.09103244f, -0.02842086f, 0.10256303f, -0.08953693f, 0.04798467f, 0.08644655f, 0.11313686f, 
    -0.00390515f, 0.04083667f, 0.02622007f, 0.10975913f, 0.11999647f, -0.03661081f, 0.03993626f, -0.02159772f, 
    0.09175522f, 0.00168378f, -0.11337007f, -0.14609940f, -0.08405029f, -0.04074059f, 0.04518529f, 0.01286775f, 
    0.07393815f, -0.05912010f, 0.05152418f, -0.05853583f, 0.14713955f, 0.04057134f, 0.02118829f, -0.16354114f, 
    0.02942259f, -0.01835236f, -0.06209573f, -0.00516166f, 0.09821595f, 0.07251488f, -0.03351255f, -0.01622842f, 
    -0.04267118f, -0.15359348f, 0.15392837f, 0.00011687f, -0.02238241f, 0.09569731f, 0.00725134f, -0.03604836f, 
    0.01150495f, 0.04584026f, -0.01742749f, -0.03594727f, -0.04458854f, 0.00202500f, 0.07171974f, 0.02491477f, 
    0.10664338f, 0.06150124f, 0.04538553f, -0.02393168f, 0.02746675f, -0.03544708f, 0.05903501f, 0.06904662f, 
    0.17295504f, 0.10173426f, -0.12728807f, -0.02438029f, -0.01025966f, -0.02354047f, 0.08648999f, -0.06285526f, 
    0.06183527f, 0.09211569f, -0.00762993f, -0.01041412f, 0.10775863f, -0.05784682f, -0.01662893f, -0.08889478f, 
    0.07354086f, 0.00079082f, 0.01166705f, 0.02024189f, 0.05637216f, -0.01923902f, -0.02202136f, -0.01360738f, 
    0.20602268f, 0.07089253f, 0.09020045f, 0.05731259f, 0.12823673f, -0.00608588f, -0.03573872f, -0.03844802f, 
    0.11232465f, -0.05864286f, 0.01100387f, -0.00143293f, -0.09262335f, -0.17215155f, -0.10737407f, -0.10612008f, 
    -0.01512200f, -0.04385399f, -0.03005658f, -0.01727441f, -0.04813187f, -0.00368599f, 0.07648916f, -0.02081619f, 
    0.15134265f, 0.16859321f, -0.25881773f, -0.12841122f, 0.07518117f, -0.09530313f, -0.04064428f, 0.06471434f, 
    0.02300663f, 0.04781551f, 0.02076919f, 0.07737103f, 0.11572808f, -0.14031832f, 0.01595136f, -0.08592102f, 
    0.00011638f, -0.02905388f, 0.02314131f, 0.01220040f, 0.02451934f, -0.11433265f, 0.01434018f, 0.04337271f, 
    0.36974481f, -0.10426971f, 0.18491367f, 0.12918834f, 0.03425731f, -0.03787925f, 0.00048271f, 0.11317757f, 
    0.00432221f, 0.01010536f, 0.09841342f, -0.02026802f, 0.36612436f, -0.17288563f, 0.10635616f, 0.04448868f, 
    -0.03766200f, 0.04980882f, -0.01096423f, 0.02578589f, -0.10084333f, 0.07634180f, 0.00389960f, 0.09838396f, 
    0.08964754f, 0.02247562f, 0.06289560f, -0.03273976f, -0.00498650f, 0.07242161f, 0.00953208f, -0.06717242f, 
    0.11870429f, -0.11047214f, -0.03449292f, -0.08087789f, 0.05422306f, 0.10476500f, -0.01084770f, 0.14796107f, 
    0.08569746f, 0.04842028f, 0.02685141f, 0.03192049f, -0.04797510f, -0.00997926f, 0.03485854f, 0.04493951f, 
    0.23885375f, -0.12305048f, 0.02723846f, -0.11099620f, 0.00154713f, 0.09926266f, 0.00572228f, 0.08237498f, 
    0.10742292f, -0.07749452f, 0.05384573f, -0.02096845f, -0.03777918f, -0.00186473f, -0.02260824f, -0.03480498f, 
    -0.00219895f, 0.08681709f, 0.03052450f, 0.06131326f, 0.04308039f, -0.00715079f, 0.03331054f, 0.07548260f, 
    0.20509756f, -0.06754044f, -0.15527631f, -0.12924723f, 0.02981236f, 0.01301047f, -0.00985158f, 0.02228211f, 
    0.09486695f, 0.10275912f, -0.01267565f, 0.06572295f, -0.04430363f, 0.06919885f, 0.19714403f, 0.06898521f, 
    0.07002411f, 0.00229746f, 0.07869375f, 0.07287509f, 0.07277592f, -0.06260531f, -0.04962397f, 0.13071193f, 
    0.15979405f, -0.19874658f, -0.02822719f, -0.08939477f, 0.05991648f, 0.03152993f, 0.04093647f, -0.09506371f, 
    0.01949105f, -0.05546792f, -0.06614790f, 0.04354144f, 0.01755391f, -0.19040607f, -0.11039556f, 0.13180318f, 
    -0.09393586f, 0.01206675f, -0.03183275f, -0.01451441f, -0.06764871f, 0.15187965f, -0.03618379f, 0.02216072f, 
    -0.06095004f, 0.01786427f, 0.02002870f, -0.06004484f, -0.19676492f, 0.02459783f, -0.00474108f, 0.01789316f, 
    0.12117825f, 0.00133807f, 0.00824565f, -0.04411173f, 0.01577879f, -0.00386507f, 0.01787134f, -0.04404858f, 
    0.02486427f, 0.01816652f, 0.01965860f, 0.02885401f, -0.08759674f, -0.08342892f, 0.10931694f, -0.11653475f, 
    0.04864901f, -0.09023607f, -0.17472859f, -0.13567071f, 0.14595696f, -0.03203957f, -0.04672770f, -0.04830772f, 
    -0.01105551f, 0.12222797f, -0.07053451f, -0.06276165f, 0.11768208f, 0.03616712f, -0.13944320f, -0.14565966f, 
    0.00274527f, -0.01044660f, 0.05027331f, 0.07725123f, -0.00755868f, -0.00215075f, -0.01351213f, 0.06985198f, 
    0.00180103f, -0.07452377f, -0.11909123f, -0.18640999f, 0.09655837f, -0.04600839f, 0.06140713f, 0.01535077f, 
    0.02766758f, -0.18112490f, -0.03046668f, 0.04584341f, 0.22429183f, 0.02637709f, -0.13059986f, -0.15574281f, 
    -0.02559489f, 0.10562944f, -0.01881263f, 0.08253455f, -0.06698953f, 0.02842805f, 0.12448790f, -0.09900755f, 
    0.29757842f, 0.01074892f, -0.07492084f, -0.11027934f, -0.05724056f, -0.00459003f, 0.05634698f, -0.04638310f, 
    0.03223026f, -0.03283583f, 0.06039394f, -0.00436320f, 0.17812410f, 0.09622801f, -0.00507517f, 0.05081168f, 
    0.01262994f, -0.04438030f, -0.00653373f, 0.00060368f, -0.04309330f, 0.02263357f, 0.12924173f, 0.04332989f, 
    -0.10831619f, -0.18121848f, -0.01935219f, 0.04533936f, 0.03276046f, -0.00497247f, 0.00541962f, 0.01009209f, 
    -0.05512501f, 0.06070609f, -0.04896421f, 0.03639685f, -0.06162855f, -0.04634411f, 0.12667453f, -0.10709972f, 
    0.04902725f, -0.02430074f, 0.03688842f, 0.00893950f, -0.14799991f, 0.05174968f, -0.02591481f, 0.13943271f, 
    -0.25667605f, -0.16985750f, 0.09613862f, -0.01633647f, 0.01774339f, -0.00783306f, -0.01606024f, 0.05314834f, 
    0.19069007f, 0.04820522f, -0.05368362f, 0.11332647f, -0.01120999f, -0.00179669f, 0.06235080f, 0.09692998f, 
    0.04797585f, 0.04000008f, 0.07349341f, -0.04616072f, 0.02454046f, 0.00054114f, 0.04426890f, -0.01216303f, 
    0.04184117f, 0.00234328f, -0.06693989f, -0.18408850f, 0.10994304f, -0.00731644f, 0.05124609f, -0.05299452f, 
    0.05253666f, -0.03259662f, -0.00863459f, -0.06121044f, 0.00994518f, -0.04249452f, 0.13644049f, 0.00372655f, 
    -0.02579110f, -0.07265981f, -0.05865366f, -0.03184305f, 0.15955086f, 0.14731593f, -0.09199972f, 0.04528067f, 
    0.05408344f, -0.04045574f, 0.09551184f, -0.05727899f, -0.13843440f, 0.00894731f, -0.01530387f, -0.05310937f, 
    -0.07827015f, -0.05985390f, -0.01246941f, -0.05611946f, 0.12359039f, -0.05564193f, 0.02663752f, -0.02201192f, 
    0.05591967f, 0.08821718f, 0.07594898f, -0.01193234f, -0.04318897f, -0.06913258f, 0.04070120f, 0.10763863f, 
    0.33430505f, 0.08565738f, -0.01269993f, -0.02056745f, -0.06388008f, 0.01601526f, -0.06117693f, -0.11407814f, 
    0.01279937f, 0.05974106f, 0.01657674f, 0.03005878f, -0.04353893f, -0.10609862f, 0.07720994f, 0.04456626f, 
    -0.05030822f, -0.10473176f, 0.06798649f, 0.10140184f, -0.00611814f, 0.04622964f, -0.06151366f, -0.06048149f, 
    0.04413680f, 0.09319991f, 0.01320657f, 0.06092274f, 0.11757562f, 0.05041881f, 0.05163105f, -0.06472670f, 
    0.08191111f, 0.03585307f, -0.04349798f, -0.03003257f, 0.08949479f, -0.00569986f, -0.22129908f, -0.11353108f, 
    0.04075444f, -0.06441454f, -0.03766811f, -0.07707347f, -0.01647826f, 0.07944123f, -0.03792171f, 0.00627285f, 
    0.18907608f, 0.16167107f, -0.14292747f, 0.15644553f, 0.02750864f, 0.03181464f, 0.04008874f, 0.01156319f, 
    0.09690377f, 0.04662929f, -0.01370595f, -0.01609080f, 0.26683450f, 0.01838780f, 0.00906223f, 0.23270534f, 
    0.00222271f, 0.06174193f, 0.12999637f, -0.02184146f, -0.03321106f, -0.09268366f, -0.04350227f, 0.01920480f, 
    -0.03643001f, 0.19753318f, -0.08410641f, 0.04021096f, 0.03677570f, -0.05947452f, -0.00096738f, 0.07110050f, 
    0.00867584f, 0.08562669f, 0.03759335f, -0.07734843f, -0.07796516f, -0.04633497f, 0.05444537f, 0.10415325f, 
    0.16027930f, -0.03111442f, 0.06616958f, 0.03435298f, 0.02480565f, 0.06461735f, 0.07465263f, -0.04698858f, 
    -0.12230489f, 0.00914874f, -0.13555238f, -0.02531468f, -0.06165516f, -0.01389721f, 0.00833264f, -0.16206701f, 
    0.05116590f, 0.07634919f, -0.07781537f, 0.03578112f, 0.11682778f, -0.08644234f, 0.08186156f, -0.09734177f, 
    -0.01703806f, -0.06014945f, 0.01507025f, 0.07515875f, -0.02308469f, -0.06393050f, 0.11986261f, -0.14571612f, 
    -0.07726029f, 0.05750145f, -0.06937917f, 0.01390250f, 0.06472608f, 0.03569611f, 0.05639928f, 0.08717631f, 
    0.08104897f, 0.21124420f, -0.03804432f, 0.14513308f, -0.08218303f, -0.15047607f, -0.08604536f, 0.08275349f, 
    -0.05815403f, 0.15023930f, -0.05563663f, 0.18659993f, 0.05017419f, -0.00192795f, -0.01709864f, -0.11826260f, 
    0.09897754f, 0.24305108f, -0.05171760f, -0.06621724f, -0.06773289f, 0.01481356f, -0.01985889f, 0.02455120f, 
    -0.04968166f, 0.06691802f, -0.03865825f, -0.11460683f, 0.02581622f, 0.08176147f, -0.04158096f, 0.03449294f, 
    -0.06287828f, 0.11061800f, 0.04323167f, 0.09683260f, -0.01945265f, 0.09452002f, -0.02924856f, -0.06557175f, 
    0.14861068f, -0.03321915f, 0.15060177f, -0.08572791f, -0.07539547f, -0.00713924f, 0.06991531f, 0.12439705f, 
    0.04274600f, -0.00564266f, 0.03590477f, -0.06610341f, 0.49679583f, -0.11720328f, 0.09634943f, -0.05348471f, 
    -0.05879704f, 0.07656986f, -0.01019826f, 0.13161622f, 0.08634748f, 0.11216290f, 0.11608043f, -0.02434148f, 
    -0.11641895f, -0.12878907f, -0.06915561f, -0.03577396f, -0.10719027f, -0.11564099f, -0.08474991f, 0.00486573f, 
    -0.01593891f, -0.05299891f, -0.10494673f, 0.01921883f, -0.04832906f, -0.03673141f, -0.01038514f, 0.11960243f, 
    0.08352257f, -0.00011909f, 0.10384081f, 0.02646173f, -0.00419180f, -0.08611309f, -0.14374834f, 0.08174378f, 
    0.04846345f, 0.06603996f, 0.16571495f, -0.02574386f, 0.10777242f, -0.00364031f, 0.12536578f, 0.05198807f, 
    0.06719045f, 0.02880195f, -0.12705652f, -0.05602676f, -0.00404128f, -0.00116028f, -0.04426203f, 0.08525668f, 
    -0.06923331f, 0.00804313f, 0.05542038f, -0.02504095f, -0.05895362f, 0.05788405f, -0.12769461f, -0.08981359f, 
    -0.17939840f, 0.19182046f, 0.00315849f, -0.09853617f, -0.02497031f, -0.05151198f, -0.12105075f, 0.04603307f, 
    0.08416201f, 0.08942297f, 0.02798472f, -0.11795655f, 0.02303261f, 0.06372667f, -0.08838471f, 0.09155739f, 
    -0.05698954f, -0.00552000f, 0.10026093f, -0.02557071f, -0.05774444f, -0.01430214f, -0.11935380f, 0.00462290f, 
    0.23038332f, 0.14284313f, -0.06034325f, 0.01693769f, -0.02739255f, -0.00173164f, -0.04838058f, -0.02050413f, 
    -0.13095103f, -0.00308179f, -0.00360023f, -0.05332364f, -0.12736939f, -0.00207247f, 0.18597589f, 0.00351435f, 
    0.06422926f, -0.10030504f, 0.02638159f, -0.04206962f, -0.06031237f, 0.00399143f, 0.00036489f, 0.07697168f, 
    -0.26672277f, 0.11075805f, 0.03180386f, -0.08634876f, -0.06784938f, -0.06063731f, 0.15313844f, -0.03030889f, 
    0.17593352f, 0.10125113f, 0.05425060f, 0.03500658f, 0.16260219f, 0.25621524f, -0.07414147f, -0.28249753f, 
    -0.04311780f, 0.12988605f, -0.12288891f, 0.08323495f, 0.00444906f, -0.12265679f, -0.00033493f, -0.03364608f, 
    -0.01561110f, 0.03304736f, -0.08870029f, -0.05876012f, 0.04889236f, 0.00197786f, 0.06609291f, 0.11342111f, 
    0.08684793f, -0.02238477f, 0.04550580f, 0.04129233f, 0.08707925f, 0.12459553f, -0.04282899f, -0.12271201f, 
    0.06084683f, -0.00605206f, -0.02557433f, -0.12277981f, -0.01050642f, -0.01001530f, -0.02114988f, 0.04736660f, 
    0.02833657f, -0.05063109f, 0.00066207f, -0.08531354f, 0.02965030f, 0.02755564f, 0.01233681f, -0.04437594f, 
    0.01480563f, 0.06034473f, 0.01704435f, -0.01602533f, 0.06801517f, 0.00918316f, -0.02549994f, -0.08538486f, 
    -0.00443499f, -0.02006367f, 0.08243607f, 0.13617219f, -0.12362095f, -0.08302058f, 0.02882472f, 0.14579514f, 
    0.07016203f, 0.11152331f, -0.08709102f, 0.13750742f, -0.04391334f, -0.06362136f, -0.03506125f, 0.03743995f, 
    0.00457374f, 0.10804172f, -0.08599587f, 0.01189981f, -0.14414385f, -0.02939076f, -0.10371595f, 0.02348590f, 
    0.01372229f, 0.04837364f, -0.03662173f, -0.02257879f, -0.09783266f, 0.03542135f, -0.05496169f, -0.06066798f, 
    0.07827935f, -0.28118390f, 0.06565489f, -0.06016713f, 0.00823079f, 0.05634721f, 0.05230441f, -0.02180497f, 
    0.01108648f, -0.03186471f, 0.11647656f, -0.08367301f, 0.23861913f, -0.08315841f, 0.15016927f, -0.05635681f, 
    0.02161048f, 0.01032191f, -0.02502711f, 0.18166137f, 0.02805983f, 0.02062126f, -0.08874881f, -0.04208819f, 
    -0.01185011f, -0.10768894f, -0.12856308f, -0.09834048f, 0.03080155f, 0.02556804f, 0.08648299f, 0.02406745f, 
    -0.00562398f, 0.02246262f, -0.05521404f, 0.01068828f, 0.11044344f, -0.09195156f, 0.19298704f, -0.01576407f, 
    -0.09321398f, -0.01137503f, 0.05752648f, -0.04373367f, 0.14209314f, -0.05243899f, 0.04495432f, 0.25687280f, 
    -0.07238650f, 0.06933700f, 0.18520093f, -0.09930690f, -0.04204969f, -0.03741228f, -0.02979667f, 0.02197412f, 
    -0.11547780f, -0.11833226f, 0.07478738f, 0.07197939f, -0.19396152f, 0.10455254f, -0.02996874f, -0.32033625f, 
    0.11013082f, -0.03010962f, -0.02174967f, 0.07315544f, 0.05805536f, -0.05001978f, 0.01225028f, -0.03206911f, 
    -0.15565640f, -0.19609739f, 0.00229845f, -0.18743816f, -0.03739626f, -0.02216193f, 0.09906778f, 0.02767470f, 
    0.09138003f, -0.09294718f, 0.01606320f, -0.01342361f, -0.04788414f, 0.00750687f, 0.13912863f, -0.28532770f, 
    0.00748331f, 0.01172482f, -0.01464336f, 0.04225482f, 0.00918041f, 0.02095868f, -0.11699770f, 0.08032882f, 
    -0.15337218f, 0.01345963f, 0.06665762f, 0.10278910f, 0.09023806f, 0.05344903f, -0.05806184f, 0.09040150f, 
    -0.02127926f, -0.08789238f, 0.15730980f, -0.03491250f, -0.02551332f, 0.12208638f, 0.04442418f, -0.00046038f, 
    0.04516768f, 0.04449976f, -0.04414373f, -0.04477970f, 0.09521144f, 0.08735517f, -0.02368207f, 0.07158252f, 
    0.00448257f, 0.07014076f, 0.12089287f, 0.01431646f, 0.00053968f, -0.08139113f, -0.06938303f, 0.08379626f, 
    0.04181686f, -0.12641193f, 0.03548198f, -0.06281321f, 0.26554400f, 0.04159814f, -0.02946666f, -0.01632470f, 
    0.04007011f, -0.11506296f, 0.10090798f, -0.19055440f, -0.00280860f, 0.10616232f, 0.05128966f, 0.07679775f, 
    0.07223849f, -0.07337096f, 0.15495262f, 0.16962682f, -0.03950769f, 0.00930175f, 0.00613623f, -0.05794997f, 
    0.03475833f, -0.03102518f, 0.04254268f, 0.12202445f, -0.09500955f, 0.16026573f, 0.17815071f, -0.11362876f, 
    0.11601603f, 0.00060071f, 0.01206868f, -0.02885834f, 0.06464936f, -0.00205551f, -0.07114403f, 0.17925681f, 
    -0.11789946f, -0.00597856f, -0.01705280f, 0.14101696f, 0.08325405f, 0.02358150f, -0.05623388f, -0.07794177f, 
    0.07327458f, 0.06295227f, -0.00224160f, -0.00657144f, -0.55933017f, -0.09851605f, -0.18979944f, 0.10339549f, 
    0.06088033f, -0.01686747f, -0.00369938f, -0.13076562f, -0.01779323f, 0.03371208f, -0.06030596f, 0.00848329f, 
    0.13222483f, -0.00020370f, 0.02293919f, 0.17649370f, 0.07316303f, 0.15317623f, -0.01193432f, -0.00680280f, 
    0.01437622f, 0.06720398f, 0.02129923f, -0.07292838f, 0.11320858f, 0.17954090f, 0.13398799f, -0.23172590f, 
    0.04114394f, -0.03260572f, -0.00695105f, 0.02872276f, 0.09860939f, 0.04539588f, 0.12031656f, -0.04728004f, 
    -0.04403033f, -0.14447027f, -0.07087346f, 0.20143773f, 0.04708306f, -0.09183105f, 0.01957323f, -0.08301407f, 
    -0.01662211f, -0.07451060f, 0.01795346f, 0.11080614f, 0.05934177f, -0.01458495f, -0.15454416f, -0.00434360f, 
    0.08829342f, -0.01624576f, -0.10287182f, 0.05471727f, 0.07201651f, -0.06179557f, 0.16636844f, 0.16252780f, 
    -0.01457002f, -0.12179656f, -0.14705670f, 0.12215940f, 0.05763454f, 0.05798573f, 0.07443850f, 0.00017749f, 
    -0.04311518f, -0.03088317f, 0.04715919f, 0.09105021f, -0.01648682f, -0.02959625f, -0.02600609f, 0.02201979f, 
    -0.03239970f, -0.09917219f, -0.05611157f, 0.10698705f, -0.02049611f, -0.08460025f, 0.02775055f, -0.03099823f, 
    0.06182116f, -0.04601377f, 0.14163475f, -0.04983360f, -0.02611609f, 0.00170165f, 0.12044681f, 0.13325195f, 
    0.03544148f, 0.03889499f, -0.03550449f, 0.07374314f, 0.23826872f, -0.28196251f, -0.09089424f, 0.16094869f, 
    -0.04913429f, 0.05721829f, 0.03192414f, 0.10573481f, 0.08239182f, -0.06932314f, -0.05709647f, -0.04389721f, 
    0.23654179f, 0.11722130f, -0.03372157f, 0.23165530f, 0.06435234f, 0.03728257f, -0.13756393f, -0.02404276f, 
    -0.09557503f, -0.06142515f, -0.03070820f, -0.03156082f, 0.03937606f, 0.15041423f, 0.15440165f, 0.16081968f, 
    -0.01816851f, -0.07641012f, 0.07872368f, 0.00912102f, -0.04025950f, 0.00253096f, 0.01399375f, 0.02507751f, 
    -0.08979210f, 0.25492084f, 0.21092282f, 0.08105949f, 0.02261950f, -0.07862422f, -0.04416348f, -0.11548048f, 
    -0.02798848f, -0.01369495f, -0.11821818f, 0.04307128f, -0.10995945f, 0.04294640f, 0.10173506f, 0.00235323f, 
    -0.08303531f, -0.01854445f, 0.10140282f, 0.04380836f, 0.09570626f, 0.00520787f, -0.00614520f, 0.01290061f, 
    0.17264399f, 0.06908205f, 0.06051799f, 0.03765872f, 0.05021921f, 0.03649240f, 0.02227038f, -0.03737033f, 
    0.06208403f, -0.00692107f, 0.04059685f, -0.04572946f, -0.09414160f, -0.04290865f, -0.16221963f, 0.08092048f, 
    0.06115678f, 0.02864827f, -0.09964816f, -0.10557728f, 0.06359128f, -0.01816495f, 0.00934073f, -0.10591918f, 
    -0.14163783f, -0.07098254f, 0.06154219f, 0.00965665f, 0.08366390f, 0.03702736f, 0.13193728f, 0.07185262f, 
    0.05954161f, -0.03532974f, 0.17343082f, 0.11354122f, 0.10501920f, 0.11931622f, 0.03591246f, -0.20973167f, 
    0.06692997f, 0.05221548f, -0.02942680f, -0.01112611f, 0.04259994f, 0.00510759f, 0.04027811f, 0.12914324f, 
    -0.21632569f, 0.12268389f, -0.14351076f, 0.12719838f, 0.12890096f, -0.01980539f, -0.02190617f, 0.04528380f, 
    0.02905854f, 0.12988774f, -0.09221244f, 0.01311934f, -0.21548736f, -0.01695667f, -0.16524647f, -0.03187647f, 
    -0.06129185f, -0.00414518f, 0.02496201f, -0.12558711f, 0.02423226f, -0.00190884f, 0.09259072f, -0.05147121f, 
    0.00993792f, 0.19299904f, 0.21229403f, -0.14037041f, 0.00179025f, 0.05207708f, 0.00225931f, 0.02759523f, 
    0.06314127f, -0.00105073f, 0.09527331f, 0.10225982f, -0.11153527f, 0.00387518f, 0.00305680f, -0.02022911f, 
    0.07803613f, 0.11015326f, 0.03960352f, 0.04541463f, -0.14408839f, 0.13535002f, -0.02048406f, -0.09148368f, 
    -0.10608749f, -0.05862136f, -0.08960858f, -0.01924171f, 0.10280094f, -0.07927539f, -0.00516388f, -0.14267212f, 
    0.11257055f, -0.00884311f, -0.01717071f, -0.02866504f, 0.03164846f, -0.04599881f, 0.11248345f, 0.15066630f, 
    -0.01666474f, 0.00141376f, 0.06374182f, -0.08506035f, -0.06970447f, 0.05175883f, -0.00793733f, 0.02916206f, 
    0.28115138f, 0.05057750f, 0.08336055f, 0.31296542f, 0.02738577f, 0.02479885f, -0.03840131f, -0.02197795f, 
    -0.12127491f, 0.08036572f, -0.00486272f, 0.04273422f, 0.03780698f, 0.15007527f, -0.18363905f, 0.16801457f, 
    -0.00247051f, 0.02527758f, 0.05885182f, -0.02308516f, 0.04070761f, 0.06650333f, 0.08232725f, -0.04028953f, 
    0.36888424f, -0.00835293f, 0.12129444f, -0.03230262f, -0.00602444f, -0.04141526f, -0.00610376f, -0.01901213f, 
    -0.05334362f, 0.09956994f, -0.06171862f, 0.07799076f, -0.12902319f, -0.07693227f, -0.06196548f, -0.02593553f, 
    0.00694783f, -0.05554303f, -0.01751133f, -0.02962667f, -0.02448418f, -0.01261136f, 0.09771788f, 0.04358760f, 
    -0.02870143f, -0.13235261f, 0.04980353f, -0.01126022f, 0.02398621f, 0.10981039f, 0.10829098f, -0.08408444f, 
    -0.04939332f, 0.13431555f, -0.00942024f, 0.16239320f, -0.08914748f, 0.08373353f, -0.06557713f, 0.17680533f, 
    0.04768008f, 0.13711999f, 0.10019717f, 0.16586125f, 0.11345622f, -0.05135887f, 0.09469917f, -0.04343225f, 
    -0.05544287f, -0.26054037f, -0.08415230f, -0.15569842f, 0.01562263f, 0.11304648f, -0.04014358f, 0.04283311f, 
    -0.00239070f, 0.09151975f, -0.01592609f, -0.04708408f, -0.10179980f, -0.15868895f, 0.03023725f, 0.01490395f, 
    -0.08452559f, -0.01850729f, 0.06683945f, 0.02532300f, 0.06474605f, -0.03611087f, 0.01421276f, -0.02953367f, 
    -0.04037096f, 0.01666812f, 0.05492187f, 0.04384309f, 0.04005516f, -0.02032263f, 0.01231560f, 0.00663753f, 
    -0.04224723f, 0.00807057f, -0.00684667f, 0.01139537f, 0.34863174f, 0.30134568f, 0.07746638f, 0.00467440f, 
    0.11719143f, -0.04653341f, 0.00272566f, 0.08791026f, 0.00185881f, -0.02812547f, 0.06487492f, 0.07208628f, 
    0.05404652f, 0.13177231f, 0.01157995f, -0.05117149f, -0.00597319f, -0.03707508f, 0.04393559f, 0.03859946f, 
    0.01202634f, -0.06969996f, -0.12715268f, 0.04306715f, -0.26033232f, 0.06248416f, -0.14456995f, 0.06513364f, 
    -0.05611251f, -0.00590223f, 0.00409468f, -0.08505197f, -0.06476517f, -0.05986313f, 0.00836967f, 0.00901679f, 
    -0.08953476f, 0.20615214f, -0.07341498f, -0.12756561f, -0.02451968f, 0.10864481f, -0.10754371f, 0.09421501f, 
    -0.11230457f, 0.13934553f, 0.05280340f, -0.11634541f, 0.04672922f, 0.07770087f, 0.20082401f, 0.06436405f, 
    -0.00115065f, -0.01281205f, 0.12290097f, -0.10025195f, -0.02210212f, 0.05431127f, -0.07704012f, -0.07606897f, 
    0.13503884f, 0.05975900f, 0.10727789f, 0.05230232f, -0.05770607f, 0.05709811f, 0.01153928f, 0.08589964f, 
    -0.00146567f, 0.12638816f, -0.02123569f, 0.07391598f, 0.24911889f, -0.01908719f, 0.21302243f, -0.00674340f, 
    0.02800811f, 0.04590252f, 0.00467091f, -0.11832485f, 0.05258650f, 0.08186892f, -0.10634040f, 0.01058095f, 
    -0.20611872f, -0.04197950f, 0.08528236f, -0.05945859f, 0.05246168f, 0.09759817f, 0.01948134f, -0.02287431f, 
    -0.00133209f, -0.12884358f, -0.01216518f, 0.03311792f, -0.08188251f, 0.30260134f, 0.08795229f, 0.03271085f, 
    -0.02968640f, 0.05068344f, -0.02920837f, 0.02461489f, -0.01129638f, 0.14045249f, 0.02354448f, 0.03975813f, 
    0.11253690f, -0.03524023f, 0.10392922f, -0.03289157f, -0.03511444f, -0.01243542f, 0.09077889f, 0.07126256f, 
    0.05615564f, 0.00112722f, 0.00704498f, 0.07615773f, -0.12926127f, -0.29159221f, -0.03067628f, -0.06166680f, 
    0.05131683f, -0.04532661f, -0.03642019f, -0.05986565f, -0.02859988f, 0.02439377f, -0.03730696f, -0.05158832f, 
    0.06915257f, -0.12666042f, -0.01827902f, -0.10179735f, 0.02678987f, 0.06853608f, 0.05330899f, 0.08147939f, 
    0.07413995f, 0.01781409f, 0.13191690f, -0.10313541f, -0.05813548f, -0.00161866f, -0.04797406f, -0.02094357f, 
    0.10541856f, 0.11770935f, 0.00039672f, -0.03303847f, -0.17595252f, 0.00109371f, 0.04162620f, 0.07501081f, 
    -0.17621206f, -0.04646476f, -0.08270212f, 0.04728341f, -0.00008987f, -0.03204108f, -0.00000947f, -0.01835830f, 
    -0.04365643f, -0.05372347f, 0.05618315f, -0.02909062f, 0.01665100f, 0.09160107f, 0.20063277f, 0.16645412f, 
    -0.19373661f, 0.07579166f, 0.07346556f, 0.14285342f, -0.12357569f, 0.01302066f, -0.00388256f, 0.04465035f, 
    0.17537041f, 0.10514340f, 0.07538135f, 0.14208047f, -0.07253333f, 0.05431782f, -0.01653130f, -0.03781981f, 
    -0.07338184f, -0.10315982f, -0.11213493f, -0.05680308f, -0.04151049f, 0.03230318f, -0.03010141f, 0.15606090f, 
    -0.00639397f, -0.02908047f, 0.05884617f, -0.06126309f, -0.08155487f, -0.05169549f, 0.01574648f, 0.00876583f, 
    0.23001771f, 0.09801139f, 0.18296930f, 0.02714466f, -0.07054076f, 0.01627227f, -0.05597710f, -0.06343546f, 
    0.02011249f, -0.02160265f, 0.00506436f, 0.15099375f, -0.03889458f, 0.08490317f, 0.21568742f, 0.05035354f, 
    0.06413370f, -0.05951966f, 0.00206569f, 0.08847611f, -0.01608100f, 0.04781072f, 0.09430858f, 0.00814976f, 
    -0.18629622f, -0.10748089f, -0.10734220f, 0.12766708f, 0.04911151f, -0.04416722f, -0.03788761f, 0.00019855f, 
    0.00129052f, -0.00720403f, -0.03701609f, 0.01955833f, 0.30640587f, 0.15925153f, -0.14841719f, 0.03762152f, 
    -0.01940022f, -0.14000835f, -0.12524930f, 0.00996602f, 0.05558347f, -0.03475546f, 0.02509789f, -0.01057437f, 
    0.01906761f, -0.01188334f, -0.05727653f, -0.05550558f, -0.04744018f, -0.03047422f, -0.03982804f, 0.01026268f, 
    0.03514577f, 0.02824346f, -0.01955167f, 0.01494171f, 0.00535985f, 0.04579911f, 0.00466325f, -0.03254549f, 
    0.02775427f, -0.00170444f, -0.05822844f, -0.04781293f, -0.01541933f, -0.01447809f, -0.00361399f, -0.01654240f, 
    -0.03258088f, -0.03040501f, -0.04608072f, 0.04214458f, 0.01915210f, -0.02344904f, -0.01882138f, -0.05492032f, 
    0.01352906f, -0.01645830f, 0.03999235f, 0.01958033f, -0.01901309f, -0.04253608f, -0.03929992f, -0.03288312f, 
    -0.02034196f, -0.04080778f, -0.00531857f, -0.02692590f, 0.00209337f, -0.02117599f, 0.02296045f, -0.01377306f, 
    0.02050021f, -0.04710582f, 0.00461034f, 0.01787910f, -0.05692241f, 0.02979920f, -0.01348720f, -0.04778319f, 
    0.02371879f, 0.03605241f, 0.01239034f, 0.01345054f, 0.00566778f, -0.01689647f, 0.02492183f, -0.05599515f, 
    -0.02424731f, -0.02294113f, -0.04514536f, 0.01578959f, -0.03014915f, -0.00149159f, -0.04989108f, -0.04457005f, 
    0.01778902f, 0.02025573f, 0.03643638f, -0.03953730f, -0.01590840f, 0.00056546f, -0.01659797f, 0.03650300f, 
    0.00231154f, -0.03670203f, -0.03425483f, 0.02382322f, -0.03591353f, -0.04685561f, 0.00865398f, -0.04944614f, 
    0.00778608f, -0.00151417f, -0.05804696f, -0.01867691f, -0.04753893f, -0.05669070f, -0.05279331f, -0.01034187f, 
    -0.05177923f, -0.04945534f, 0.01846360f, 0.00648023f, -0.04665290f, -0.01114011f, -0.04144287f, 0.00846164f, 
    -0.00600166f, 0.03464914f, 0.01195918f, 0.02959820f, -0.03800308f, 0.01816897f, -0.05162083f, 0.02119020f, 
    -0.00421544f, -0.05524949f, -0.03117899f, -0.04922806f, 0.03113556f, -0.00733122f, -0.01442805f, 0.04232844f, 
    0.01164435f, -0.01295942f, 0.03429459f, 0.04647873f, -0.01474465f, 0.01513147f, -0.05278654f, 0.03835974f, 
    -0.03745385f, -0.00180192f, -0.02433641f, -0.00730317f, -0.00564612f, 0.03218965f, -0.02606398f, -0.02243543f, 
    -0.03968981f, -0.03334230f, -0.00419083f, -0.01937176f, -0.02757947f, -0.01739591f, 0.00856714f, 0.03781451f, 
    -0.01737058f, 0.01963683f, 0.04116476f, -0.04890011f, 0.03147231f, -0.02249067f, -0.05742242f, 0.01101252f, 
    -0.02438711f, -0.01125977f, 0.01152583f, 0.00551180f, 0.02153332f, 0.04319111f, -0.00659554f, -0.03880824f, 
    -0.01863002f, -0.01507373f, -0.02444524f, -0.03061301f, -0.03570700f, -0.01432324f, -0.02385323f, 0.02289644f, 
    0.01295854f, -0.01630007f, -0.04714942f, 0.04203350f, 0.03321661f, -0.03282678f, -0.05608544f, -0.04696355f, 
    0.00573585f, -0.05256736f, -0.04959675f, -0.04413155f, 0.02445112f, -0.04211900f, -0.00730732f, 0.02855758f, 
    0.01758741f, -0.05152819f, -0.03029117f, -0.01358039f, -0.01919201f, -0.04826439f, -0.05579813f, -0.05680581f, 
    -0.02078838f, -0.01685931f, -0.04388843f, -0.00442713f, 0.01552152f, 0.00878803f, 0.04170489f, 0.04302134f, 
    0.03497263f, 0.01236605f, -0.02797393f, 0.02318191f, -0.00661437f, -0.04218425f, -0.00459854f, 0.00005480f, 
    -0.04383713f, -0.00722811f, -0.02065640f, -0.04347974f, -0.03780416f, 0.01366827f, -0.03390801f, -0.02895545f, 
    -0.04002561f, 0.00488366f, -0.03753287f, 0.01336544f, -0.01066659f, 0.00878679f, -0.04123050f, -0.03760036f, 
    -0.02274256f, 0.01537834f, 0.04515691f, 0.02185285f, 0.02489105f, 0.01265762f, -0.03578185f, -0.03048019f, 
    -0.00249224f, 0.02248254f, 0.00476843f, 0.04152878f, -0.01090625f, 0.03737498f, -0.02533637f, 0.01434222f, 
    -0.00211949f, 0.00623472f, 0.04295262f, -0.04280889f, 0.04305724f, -0.02215617f, 0.03313867f, -0.01196903f, 
    -0.04653674f, -0.03745334f, 0.03090708f, 0.02125284f, -0.04372076f, -0.02056837f, -0.04204884f, 0.04079850f, 
    -0.03524151f, -0.00356175f, 0.02550159f, -0.03204851f, -0.00239849f, -0.03886244f, 0.02043123f, -0.01032153f, 
    0.00092046f, -0.00775896f, 0.02493202f, -0.03431896f, 0.01195708f, -0.02932363f, -0.03074021f, -0.01337623f, 
    0.00194090f, -0.03472026f, -0.02998956f, -0.02637415f, -0.01407729f, -0.02742423f, -0.02097059f, 0.02738730f, 
    -0.00187376f, 0.02557614f, 0.04757610f, -0.00165106f, -0.05501657f, 0.03460338f, 0.03886092f, 0.01187999f, 
    0.02043630f, -0.01891244f, 0.02232577f, -0.00346142f, 0.03327155f, -0.05480867f, 0.02266238f, -0.02007967f, 
    0.04151550f, 0.02300785f, -0.02428871f, -0.00781771f, 0.03147737f, -0.03364089f, 0.02051037f, 0.03534622f, 
    -0.04327691f, -0.04803837f, -0.00758371f, 0.02438690f, 0.04806252f, -0.00808134f, 0.01224039f, 0.01879554f, 
    0.02943738f, 0.01437634f, -0.02768102f, 0.01435796f, 0.03451067f, 0.00483087f, -0.01752969f, -0.05083695f, 
    -0.02423599f, -0.05345922f, 0.02162243f, 0.02618957f, -0.02669099f, -0.01524937f, 0.00578373f, -0.04406916f, 
    0.01812086f, -0.00216364f, -0.02447256f, -0.02819678f, -0.03955474f, 0.01276533f, -0.01582361f, 0.02064020f, 
    -0.00054366f, -0.04134101f, -0.02649651f, -0.01460044f, 0.00511143f, 0.01670789f, -0.03074615f, 0.01960422f, 
    0.00416874f, -0.01065490f, 0.03950956f, 0.01658087f, 0.01432696f, -0.04392491f, -0.03778083f, 0.02858237f, 
    -0.03192990f, 0.00534525f, -0.01765411f, -0.05900498f, -0.05639272f, -0.03568343f, -0.04130213f, 0.02120593f, 
    -0.02161223f, 0.02187313f, -0.00906958f, -0.02315243f, -0.04585887f, -0.04557562f, 0.04591622f, -0.00856696f, 
    0.00442014f, -0.03284046f, -0.04363467f, -0.02368782f, -0.03591190f, -0.01084121f, 0.01387262f, -0.00795282f, 
    0.04116878f, -0.04709545f, -0.01109299f, -0.05543067f, 0.02123186f, 0.02671300f, 0.02262982f, -0.04120758f, 
    0.14415213f, 0.00287323f, -0.19880584f, -0.20544946f, -0.00081905f, -0.01886692f, -0.01025977f, -0.06605253f, 
    0.06906400f, -0.07474381f, -0.14124663f, -0.03268674f, 0.35131386f, 0.05301085f, 0.24036597f, 0.15005438f, 
    -0.04012301f, -0.12687276f, 0.00410935f, -0.06019326f, -0.01517226f, 0.07346791f, -0.06196867f, -0.03816525f, 
    -0.05255961f, 0.23784508f, -0.01725357f, 0.10119842f, 0.06218239f, 0.02395890f, -0.02535074f, 0.02325808f, 
    0.01769198f, 0.00283110f, 0.09298038f, -0.00580337f, -0.14035615f, 0.11713178f, 0.09187825f, 0.03024248f, 
    0.06357797f, -0.04116306f, 0.07894389f, -0.05832997f, 0.10490007f, -0.18333589f, 0.00005819f, -0.03647571f, 
    -0.13248529f, 0.08769213f, -0.01526451f, 0.08006264f, -0.00630427f, -0.02802584f, 0.09906384f, -0.06701800f, 
    -0.06231456f, 0.14426278f, -0.08341078f, 0.11435277f, -0.08527426f, -0.01276273f, 0.18571860f, 0.07705981f, 
    -0.01708032f, -0.04795606f, -0.09455705f, -0.02562142f, 0.12956943f, -0.00147428f, 0.15097143f, -0.05756552f, 
    0.13655865f, -0.18803224f, 0.00607209f, 0.12591502f, 0.00412846f, -0.10479737f, -0.03945222f, -0.06739783f, 
    -0.07942077f, 0.17559895f, 0.12974700f, 0.26431489f, -0.03560214f, -0.11751635f, -0.02262110f, 0.16888641f, 
    0.03317463f, 0.10053543f, 0.01246784f, 0.12931645f, 0.02313029f, -0.11844292f, 0.14224070f, -0.05383563f, 
    0.00589223f, -0.02363318f, 0.09743427f, 0.11318580f, 0.06762300f, -0.01728851f, -0.12811008f, 0.13302873f, 
    -0.03220391f, 0.02168721f, -0.10193826f, -0.07550845f, -0.11233344f, 0.23713250f, 0.13409176f, 0.08061834f, 
    0.04247576f, -0.00900286f, -0.01453575f, -0.06178822f, -0.05347863f, -0.05793771f, 0.03491329f, -0.16074668f, 
    -0.06438004f, 0.27020496f, 0.02213658f, 0.16891006f, -0.03029719f, -0.04481690f, 0.00576865f, 0.06916311f, 
    -0.03475359f, 0.03154223f, -0.00537034f, 0.04671849f, 0.47908252f, -0.15254948f, 0.17055978f, -0.00744259f, 
    0.05599167f, 0.13849258f, 0.02632567f, 0.12595563f, 0.01509372f, 0.03355379f, 0.13760489f, 0.10625684f, 
    0.07786194f, 0.04702538f, 0.01308805f, 0.01677852f, -0.05767441f, -0.18385202f, -0.03151943f, -0.13086569f, 
    0.02626534f, -0.11526120f, -0.06809442f, 0.00652029f, -0.01167873f, 0.10930859f, -0.03683811f, -0.01010502f, 
    -0.05933053f, -0.06240809f, 0.01680211f, -0.08172078f, -0.09405760f, -0.01018928f, -0.18850981f, -0.03769418f, 
    0.06731302f, 0.27206221f, 0.03301988f, -0.10762694f, 0.04588876f, 0.09681129f, -0.06612016f, -0.02690948f, 
    0.03571616f, -0.02456819f, -0.14632146f, -0.17459948f, -0.20751080f, 0.01559165f, 0.16610749f, -0.02796188f, 
    -0.16069901f, -0.04168067f, 0.13764946f, 0.00021302f, 0.09690703f, 0.01553382f, -0.00020367f, -0.15777895f, 
    0.26755458f, 0.09937492f, -0.00640535f, 0.07435051f, 0.04415147f, 0.04428648f, -0.16570331f, 0.08701730f, 
    0.07589663f, 0.16235346f, 0.10932836f, 0.04493535f, -0.20749001f, -0.16713645f, 0.15686768f, 0.01580505f, 
    0.09650370f, -0.06355785f, 0.12718247f, -0.14076944f, 0.00661357f, -0.13020895f, -0.16411886f, -0.02954137f, 
    0.13386846f, -0.17763543f, 0.11232900f, -0.02237853f, 0.08509598f, -0.04800372f, -0.12083239f, -0.01311405f, 
    -0.14340305f, -0.06125390f, -0.07514511f, -0.04845385f, -0.12190621f, 0.10394085f, -0.01970189f, 0.09235159f, 
    0.08348249f, 0.05355582f, -0.09769882f, -0.01120850f, 0.04733412f, 0.03904891f, -0.10572906f, -0.01861817f, 
    0.00318725f, 0.03500009f, -0.08778670f, 0.04981038f, -0.16195339f, -0.05985905f, 0.24552719f, -0.15323366f, 
    0.17335281f, -0.10090624f, 0.14721106f, 0.13027784f, 0.11656691f, -0.15662660f, -0.00947953f, -0.21279266f, 
    0.04180218f, 0.14274743f, -0.15969799f, -0.18165356f, -0.05391449f, -0.09579373f, -0.02501144f, 0.00477570f, 
    -0.01385242f, 0.17047644f, 0.00429568f, 0.02361761f, 0.01266548f, 0.10399062f, 0.01595318f, 0.10084344f, 
    0.01803523f, -0.07421877f, 0.03260138f, 0.06435625f, -0.16753852f, 0.13738702f, 0.05022187f, -0.17842425f, 
    0.01084775f, -0.04988178f, -0.12534440f, -0.01871115f, -0.04881051f, 0.00736812f, -0.10567637f, -0.10286664f, 
    0.15946011f, 0.09072444f, 0.01104146f, 0.00297620f, -0.04293418f, -0.13439542f, -0.00208746f, 0.02605082f, 
    -0.08621368f, 0.07465173f, 0.05056957f, 0.08544783f, 0.08469695f, 0.00459547f, -0.02879910f, -0.37114176f, 
    -0.04675036f, 0.08628412f, 0.17366336f, 0.13387977f, -0.09112274f, -0.03268615f, 0.14356565f, 0.20231424f, 
    0.10227572f, 0.09043407f, 0.09700876f, 0.22444385f, -0.02884328f, 0.12683760f, -0.05364807f, -0.03728539f, 
    0.00351270f, -0.00561540f, -0.11037972f, 0.03806772f, -0.05478105f, 0.17051437f, -0.10476724f, 0.10737041f, 
    0.17355055f, -0.14919204f, 0.02446617f, -0.00112416f, -0.06424362f, 0.08239175f, 0.07400619f, -0.04294102f, 
    -0.05170320f, -0.09397433f, -0.09922197f, -0.08782294f, -0.04746371f, 0.14129031f, 0.01977503f, -0.00735905f, 
    -0.01246359f, -0.06873271f, -0.02506648f, 0.00899181f, 0.13937920f, -0.02864105f, -0.05854027f, -0.25792077f, 
    0.11838149f, 0.07379882f, 0.00241477f, 0.02614875f, 0.18519399f, 0.10104978f, -0.10977753f, 0.18295299f, 
    0.03454363f, 0.01089641f, 0.01689648f, -0.01169799f, -0.04604575f, 0.05098227f, -0.02078271f, 0.07049122f, 
    0.06292725f, 0.06505401f, -0.04819673f, 0.06183675f, 0.18737555f, -0.12740143f, 0.07288062f, 0.04504288f, 
    -0.10664979f, -0.10214914f, -0.10011519f, 0.14099833f, 0.00646537f, -0.03213701f, -0.00355289f, 0.09625154f, 
    0.00847806f, -0.05219772f, -0.05078039f, 0.03809555f, 0.03726766f, -0.01817958f, -0.01633387f, -0.03094382f, 
    -0.04249850f, -0.01279198f, -0.02299563f, -0.04538403f, 0.02530671f, -0.00538830f, 0.03643889f, -0.02533600f, 
    0.01719104f, 0.02228082f, -0.00911837f, -0.03242432f, -0.05571375f, -0.03007380f, -0.00505147f, -0.02315184f, 
    -0.00680749f, -0.04474088f, 0.02205601f, 0.03654997f, -0.00303639f, -0.00484574f, -0.02668387f, -0.03158133f, 
    0.01540170f, 0.04097635f, 0.00740199f, 0.02180476f, -0.03811784f, -0.01666945f, 0.02786456f, -0.01652085f, 
    0.04600569f, 0.00920283f, -0.03732079f, 0.00199371f, -0.00488796f, -0.03413812f, -0.04550533f, -0.04799305f, 
    -0.03051070f, 0.01994231f, 0.02634754f, -0.03312780f, -0.04720603f, -0.00549139f, -0.03220819f, -0.02114500f, 
    -0.02550535f, 0.01745835f, -0.00295323f, 0.00101631f, -0.00153454f, -0.04826481f, 0.03242843f, -0.04540048f, 
    0.03572568f, 0.02645755f, 0.01764987f, 0.00339021f, -0.05552653f, 0.02782330f, -0.00791338f, 0.03256106f, 
    0.02885015f, -0.03381959f, 0.02496501f, -0.04572775f, 0.00310929f, 0.01570438f, -0.04837036f, -0.03464488f, 
    0.02138140f, -0.04146725f, -0.03275367f, -0.00676520f, 0.03151163f, -0.01880401f, 0.02495554f, -0.01467736f, 
    0.02785474f, 0.02245937f, -0.00536053f, -0.02179377f, -0.00910804f, -0.02882228f, -0.02317691f, -0.04569001f, 
    -0.04746181f, 0.04386936f, -0.04689788f, -0.01832455f, 0.02386272f, -0.04284528f, 0.01859447f, -0.02386449f, 
    -0.02820882f, -0.03210203f, 0.01491516f, -0.03426374f, -0.05510313f, 0.00527658f, 0.04289933f, 0.00838081f, 
    0.04676866f, 0.00872582f, 0.00284225f, -0.04361633f, -0.02870695f, -0.04263715f, 0.04342218f, -0.04144398f, 
    0.03887355f, 0.01907935f, 0.00556106f, -0.00360256f, -0.01613158f, -0.04159767f, -0.04946047f, 0.03966533f, 
    0.03355724f, -0.02667727f, -0.03504528f, 0.04091544f, 0.02291117f, -0.01193464f, -0.05397782f, -0.01471316f, 
    0.03250215f, -0.03382286f, 0.03683783f, -0.03934969f, 0.01809513f, 0.01118175f, -0.01281560f, -0.03728207f, 
    0.00336113f, -0.04830862f, -0.03449058f, -0.05411072f, 0.02926994f, -0.01376851f, -0.00831629f, -0.01664493f, 
    0.02026667f, 0.03022433f, -0.02849752f, -0.04626517f, 0.04113130f, 0.03861225f, -0.04771230f, 0.03711465f, 
    -0.01176219f, 0.01572232f, 0.04693919f, 0.00524025f, -0.04858438f, 0.01437435f, -0.02541792f, 0.02590544f, 
    -0.04403383f, -0.03583172f, -0.02499446f, 0.00015063f, -0.05578673f, -0.02298919f, 0.00487239f, 0.02321630f, 
    0.04683471f, 0.02830618f, 0.02371795f, -0.04491746f, 0.04344473f, -0.00904561f, -0.02217125f, -0.03978727f, 
    0.03848216f, 0.00228391f, -0.04398744f, 0.00709315f, -0.01704346f, -0.03936917f, -0.00497499f, -0.03440033f, 
    -0.03961670f, -0.04915071f, -0.01708101f, -0.00589641f, -0.04478572f, -0.02877079f, 0.00522295f, 0.04443399f, 
    -0.05900461f, 0.03814096f, 0.02335732f, 0.00942085f, 0.01715674f, 0.01760709f, 0.04740161f, -0.05327015f, 
    -0.03143627f, 0.01176683f, 0.01125843f, -0.03286080f, -0.05213821f, 0.03398040f, -0.01665306f, -0.04050419f, 
    -0.00931256f, 0.02563437f, 0.02904656f, 0.00512487f, -0.04116051f, 0.02745653f, -0.01288444f, 0.00152002f, 
    -0.02682521f, -0.03821424f, -0.04114188f, 0.00302744f, -0.00546182f, 0.04255491f, -0.00658220f, -0.04362011f, 
    0.02933942f, -0.04174853f, -0.03129064f, 0.04067284f, -0.04470579f, -0.00672446f, -0.05627020f, -0.03077220f, 
    0.04059504f, -0.04513562f, -0.02186273f, -0.02956470f, 0.00507118f, -0.02456909f, -0.01131908f, 0.00875149f, 
    -0.02267650f, -0.02952906f, 0.04348595f, -0.00571215f, -0.00675572f, -0.03025663f, 0.02146424f, 0.00849199f, 
    -0.03917135f, -0.02493075f, 0.03155329f, -0.03610170f, -0.04225138f, -0.04200340f, -0.03522873f, 0.00774004f, 
    0.02435196f, 0.00025065f, -0.01503337f, 0.03311509f, -0.00914671f, -0.00784881f, -0.04164879f, -0.04210440f, 
    -0.02333171f, -0.04901515f, -0.02729265f, 0.02294663f, -0.03059294f, 0.02855668f, 0.02052530f, -0.03746409f, 
    -0.00208317f, -0.00227107f, 0.03343432f, 0.02983371f, 0.03890549f, 0.03996138f, 0.02400840f, 0.04022361f, 
    -0.04931218f, -0.01697956f, -0.01993555f, -0.04413009f, 0.00940140f, -0.00972867f, -0.03669748f, -0.04574014f, 
    -0.02643453f, 0.01922609f, -0.02806598f, -0.04634834f, -0.01871145f, -0.00060294f, -0.01049529f, -0.04257880f, 
    0.03952209f, -0.03398258f, -0.04132469f, 0.03217249f, 0.00405378f, 0.02264442f, -0.02078301f, -0.01047779f, 
    0.00400885f, -0.05182498f, -0.03330093f, -0.00589658f, 0.03156986f, 0.03806620f, -0.02447777f, -0.02451093f, 
    0.04438509f, -0.03529781f, -0.01642369f, 0.00714520f, 0.02062703f, 0.00594360f, 0.00759098f, 0.04231717f, 
    -0.02060831f, -0.00600305f, -0.05088979f, -0.00166688f, -0.01314622f, -0.02428203f, -0.00324956f, 0.00247657f, 
    0.01614545f, 0.02278816f, -0.03436693f, 0.04689607f, -0.00345089f, -0.02105173f, -0.02220168f, -0.05525056f, 
    -0.01779226f, -0.00723725f, -0.03116050f, -0.02595857f, 0.03759367f, -0.03824895f, -0.02834670f, 0.01479707f, 
    0.02549739f, -0.03228220f, 0.03904867f, 0.00621211f, -0.02359352f, -0.01937043f, -0.01721722f, -0.00319005f, 
    -0.01178129f, 0.04508019f, 0.00609849f, 0.02219752f, 0.04756714f, 0.04252864f, -0.00818487f, 0.03339220f, 
    0.02808031f, 0.02233756f, 0.02754962f, -0.01964791f, -0.02944668f, -0.05019474f, 0.03243680f, 0.01570846f, 
    0.01387103f, -0.03687967f, 0.01114257f, 0.03676579f, 0.04364230f, 0.00178171f, 0.01411368f, -0.02922150f, 
    0.28341281f, 0.23748414f, 0.19011709f, -0.00167054f, -0.06273098f, 0.10185389f, -0.03971720f, 0.16622268f, 
    0.00901808f, 0.00799918f, 0.01600241f, -0.00298716f, 0.41487145f, 0.06549101f, 0.17834495f, -0.25897464f, 
    -0.13815956f, 0.03229341f, 0.02253515f, -0.00464719f, 0.03408466f, -0.05070300f, -0.01776410f, -0.01089527f, 
    0.26020086f, -0.23798694f, -0.05094238f, -0.13103381f, 0.01069575f, -0.14082526f, -0.03344172f, 0.03768064f, 
    0.00325313f, -0.05405328f, 0.08847327f, 0.06073324f, 0.18458870f, -0.08049186f, 0.16321401f, -0.41631630f, 
    0.03527943f, 0.00835615f, -0.11848626f, -0.02027890f, 0.07677910f, -0.03008837f, -0.09593966f, 0.00930624f, 
    -0.01920835f, -0.12957898f, -0.03705143f, 0.07624935f, 0.02602295f, 0.00552892f, 0.14915480f, -0.03342211f, 
    -0.00369066f, 0.06976738f, 0.03929544f, -0.09876331f, 0.12566890f, 0.20459095f, 0.18309876f, 0.03748788f, 
    -0.07784087f, 0.13669856f, -0.05731723f, 0.02702498f, -0.00726047f, -0.12831491f, -0.06818657f, 0.13414149f, 
    0.25615862f, -0.03959965f, 0.08508738f, -0.09823886f, 0.03582923f, -0.03638116f, -0.12478285f, 0.14132823f, 
    -0.01004424f, -0.06583167f, 0.07290600f, 0.02340289f, -0.20914789f, -0.19002444f, -0.11398838f, -0.01483682f, 
    0.08602496f, 0.16038027f, 0.07715074f, -0.06767140f, 0.05303251f, 0.00208277f, -0.00815819f, 0.10643191f, 
    0.02287480f, 0.14501341f, 0.03714759f, 0.22382723f, 0.04117186f, -0.02323958f, -0.02072966f, -0.00186630f, 
    0.00108358f, -0.03150587f, 0.04076398f, 0.02875160f, -0.09913790f, 0.24240059f, 0.22454076f, 0.02481741f, 
    -0.02605181f, 0.00604023f, 0.11909182f, -0.00461559f, 0.01102068f, -0.01549687f, 0.03578465f, 0.07631402f, 
    -0.10595934f, -0.14701355f, -0.06464350f, 0.20174658f, 0.10998090f, -0.01350312f, 0.05926413f, 0.08263216f, 
    -0.06523816f, -0.03622301f, -0.08691286f, -0.08539268f, 0.15915780f, -0.35653859f, -0.09256537f, -0.12038513f, 
    0.00877793f, -0.01873707f, -0.00439945f, -0.01435519f, -0.00043122f, -0.00462087f, 0.13908039f, -0.04208630f, 
    -0.30415118f, -0.12618761f, -0.25519648f, 0.08860544f, 0.02730198f, -0.02450419f, -0.06917008f, -0.09681249f, 
    0.07609235f, -0.01406881f, -0.03859801f, -0.04381938f, 0.04586647f, 0.24643852f, 0.20074859f, -0.13806656f, 
    0.03300395f, 0.06132762f, -0.03914975f, -0.02344473f, 0.06911036f, -0.05569666f, 0.06064926f, -0.06246669f, 
    -0.08983908f, -0.00656316f, -0.01975598f, 0.06041158f, 0.07447387f, 0.12831859f, 0.01707565f, -0.06400295f, 
    0.05342722f, 0.07146014f, -0.08418640f, 0.08337458f, 0.19757572f, -0.02883642f, -0.11409856f, -0.19526382f, 
    0.00102538f, 0.10717074f, -0.07398512f, -0.00516818f, -0.00379905f, 0.02900596f, 0.01692446f, 0.06676720f, 
    -0.16644795f, -0.03918486f, -0.13648604f, -0.04951229f, 0.07762472f, -0.05990937f, 0.00464103f, -0.11238699f, 
    0.13088731f, -0.17186829f, -0.13966537f, -0.02261284f, 0.28538260f, -0.09690765f, -0.05685951f, -0.03805245f, 
    0.03440508f, 0.05586118f, -0.00733141f, -0.03912459f, 0.02064566f, 0.03716891f, 0.05231084f, 0.02362054f, 
    0.28433210f, 0.14778197f, 0.04196793f, -0.06114444f, 0.04209001f, 0.06431633f, -0.04311159f, -0.03348532f, 
    0.00371147f, 0.04331174f, -0.00732654f, -0.05652102f, -0.28792828f, -0.20855346f, -0.00054047f, 0.14356314f, 
    -0.00289285f, 0.00482941f, -0.02801584f, 0.12676011f, 0.00472692f, -0.05012277f, 0.12816085f, 0.01350882f, 
    -0.19659150f, -0.02641480f, -0.04608824f, 0.02512839f, -0.01948388f, 0.05798834f, 0.04309594f, -0.07065761f, 
    -0.00125286f, 0.12877932f, -0.01308397f, 0.01338668f, -0.25936112f, 0.14774901f, 0.00229882f, 0.02926929f, 
    -0.03367761f, 0.04638220f, 0.12637076f, 0.10475059f, -0.14129186f, -0.05377823f, 0.09630693f, 0.01955648f, 
    -0.22595942f, -0.02261763f, 0.17098871f, -0.00087958f, -0.07170606f, -0.12849614f, -0.02987747f, 0.06242386f, 
    -0.00008437f, -0.00336251f, -0.02271306f, 0.01365799f, -0.08475054f, 0.24260560f, 0.15867665f, -0.05913581f, 
    -0.04537578f, -0.10559982f, 0.04069759f, 0.03680674f, -0.09293500f, -0.00318745f, -0.05324240f, -0.06187100f, 
    0.02486870f, 0.04283512f, 0.09092657f, 0.05990770f, 0.08137909f, -0.04886506f, 0.06961325f, 0.04019906f, 
    0.02766199f, -0.02244912f, -0.07726854f, -0.10565828f, -0.09389321f, -0.12953646f, -0.14340179f, -0.09115444f, 
    -0.01857617f, -0.05552310f, -0.10092717f, 0.00835613f, 0.13210860f, 0.02417585f, -0.07600807f, 0.00321043f, 
    -0.28003731f, -0.15366629f, -0.13615872f, 0.03364604f, -0.00868172f, 0.08369377f, -0.10410574f, -0.01568502f, 
    -0.02315306f, 0.08604970f, 0.01467142f, 0.01809135f, 0.06211121f, 0.10967265f, 0.04933135f, -0.21186286f, 
    0.08175607f, 0.06213112f, -0.05388450f, -0.08770881f, -0.02975275f, -0.02611957f, -0.01111111f, 0.02504306f, 
    -0.09187104f, -0.37882245f, -0.17995441f, -0.08971464f, -0.10970242f, 0.00029280f, 0.00549154f, -0.04647489f, 
    0.06303106f, 0.01091345f, 0.03944702f, -0.07895712f, -0.14265114f, -0.27005008f, -0.16768882f, -0.13292037f, 
    0.03193048f, 0.04777819f, -0.08571361f, -0.01466626f, -0.00004737f, 0.06750127f, 0.03192120f, -0.02305195f, 
    0.08329302f, 0.15643339f, 0.32014510f, -0.11069936f, 0.01660146f, 0.10359295f, 0.06139997f, -0.12165789f, 
    0.05071294f, 0.06803633f, 0.03033052f, 0.00942586f, 0.21726610f, -0.06742390f, 0.13103758f, 0.02025271f, 
    0.01724581f, 0.05457513f, 0.00270464f, -0.07613867f, -0.03847847f, 0.11599133f, 0.00339321f, -0.09611637f, 
    0.09775902f, 0.14824894f, -0.26765099f, -0.01825429f, 0.04283501f, 0.00505163f, 0.04514375f, 0.13671374f, 
    0.13747974f, 0.07028966f, 0.18582204f, 0.02777050f, -0.15345395f, -0.15496850f, -0.04461117f, 0.20440827f, 
    0.07607333f, 0.02338363f, 0.03210983f, 0.06680103f, -0.04638505f, -0.05369879f, 0.02962342f, 0.09550127f, 
    0.26471525f, 0.01317260f, 0.01459467f, 0.10622619f, 0.10405359f, -0.10134684f, 0.04685827f, 0.06905575f, 
    -0.02102453f, 0.09976101f, 0.05520688f, -0.13796271f, 0.29953459f, 0.00504570f, 0.00618301f, 0.11814257f, 
    0.02586361f, -0.01430043f, 0.05360968f, -0.01969196f, -0.09300956f, 0.03443208f, 0.10370526f, 0.08769875f, 
    -0.03948912f, 0.07081660f, -0.10812189f, 0.13524616f, 0.02975382f, 0.01654670f, 0.03987075f, -0.16385563f, 
    0.14930858f, -0.09809452f, 0.05406664f, -0.04417650f, 0.08215895f, 0.02328363f, 0.06688543f, 0.00693678f, 
    0.05704503f, 0.01596726f, 0.03078113f, -0.04969977f, 0.00708963f, 0.00031897f, 0.06293432f, -0.01802879f, 
    0.06549139f, -0.12500884f, -0.00386210f, 0.02843592f, 0.03802920f, 0.04486864f, 0.00255197f, 0.06006994f, 
    0.13827477f, -0.00479353f, -0.09763717f, 0.05727376f, -0.15311155f, -0.08426364f, 0.01161226f, 0.03535547f, 
    -0.06368422f, 0.10307766f, 0.01692552f, 0.16275713f, 0.03669582f, -0.03252470f, 0.01326329f, 0.03709428f, 
    0.25169152f, 0.10795955f, -0.16113274f, -0.09928779f, 0.04819165f, 0.06921685f, -0.05772825f, 0.01180600f, 
    0.09355691f, 0.10604183f, 0.03752776f, 0.16432814f, -0.03057718f, 0.07301210f, 0.17894144f, 0.11731064f, 
    0.05678521f, -0.07096688f, 0.02877453f, -0.03200680f, 0.08250263f, -0.17614320f, -0.01788860f, 0.11499231f, 
    0.36531892f, -0.04219548f, 0.05717446f, -0.02230178f, 0.07904126f, 0.06264746f, 0.01089705f, -0.03135214f, 
    -0.02463657f, -0.01389945f, 0.00531655f, 0.07012310f, -0.17882921f, -0.23170766f, -0.06493375f, 0.07528942f, 
    -0.09770024f, 0.10265766f, -0.03969942f, -0.10662444f, -0.05542694f, 0.03194280f, 0.08148358f, 0.13601075f, 
    -0.05462785f, -0.11724184f, 0.11113767f, -0.07228287f, -0.16190359f, 0.00297295f, 0.02487011f, 0.01077283f, 
    0.17140694f, 0.04123352f, -0.07324389f, -0.01249776f, -0.05461795f, -0.03071377f, -0.03847779f, 0.07834457f, 
    0.01549720f, 0.05614788f, -0.01884315f, -0.00729450f, 0.02172849f, -0.06266236f, 0.09063620f, -0.04975175f, 
    0.23837484f, -0.00466223f, 0.00349655f, -0.11819790f, 0.11442145f, 0.02097096f, -0.02211331f, 0.00253754f, 
    0.09926251f, 0.14990135f, -0.11483110f, -0.02249142f, -0.08341832f, 0.07340027f, -0.08730297f, -0.07741538f, 
    -0.01311943f, 0.00181512f, 0.07716016f, 0.07325247f, 0.06384338f, -0.00078758f, 0.02941412f, -0.01337786f, 
    0.07088588f, 0.04535249f, -0.07724746f, -0.25672501f, 0.12529269f, 0.01847609f, 0.02857719f, -0.08842973f, 
    0.02370821f, -0.09595889f, -0.08933305f, -0.03169287f, -0.01556265f, 0.11762297f, -0.14498532f, -0.14455993f, 
    -0.02254067f, 0.10424552f, 0.00057531f, 0.10923998f, 0.04160224f, 0.04040987f, 0.14411801f, -0.07559452f, 
    0.24992989f, 0.01812420f, -0.07835452f, -0.08955230f, -0.02647399f, -0.02742769f, 0.05305811f, 0.00492594f, 
    -0.03147619f, -0.02899385f, 0.03228331f, 0.07341710f, 0.23217274f, 0.19627486f, 0.03780249f, 0.00934187f, 
    0.07382520f, -0.03670279f, -0.11676180f, 0.04953922f, -0.08877753f, -0.01949799f, 0.12353383f, 0.04613617f, 
    -0.20338206f, -0.17989911f, -0.02401131f, 0.11253116f, -0.03034562f, 0.04042878f, -0.07377695f, -0.01015932f, 
    0.01529669f, 0.09340987f, -0.04643299f, 0.05641289f, 0.27285445f, -0.03734699f, -0.00391588f, -0.27764818f, 
    0.10444938f, 0.04585112f, -0.04005338f, 0.10793099f, -0.07456665f, -0.05125159f, -0.02501934f, 0.15320104f, 
    -0.21427961f, -0.12564050f, 0.11981782f, 0.02880624f, 0.14875847f, -0.07037207f, 0.03093426f, 0.11422329f, 
    0.24186438f, 0.02555064f, -0.00431748f, 0.09660880f, -0.05865729f, 0.03610049f, 0.03789332f, 0.08354878f, 
    0.02460035f, 0.08943375f, 0.05122442f, -0.04098721f, 0.05296957f, -0.05385759f, -0.03727499f, -0.05165250f, 
    0.04032243f, 0.02905003f, -0.12398722f, -0.13680077f, -0.03752954f, 0.01966409f, 0.03752733f, 0.00726667f, 
    0.03453459f, -0.09081206f, 0.02064168f, -0.14782052f, 0.01224692f, -0.07866330f, -0.02647284f, -0.20484191f, 
    -0.05110543f, -0.02762441f, -0.06953283f, -0.00703008f, 0.06848562f, 0.03519334f, -0.01286200f, 0.04783067f, 
    0.05674314f, -0.08281010f, 0.10844379f, 0.11475711f, -0.09820861f, 0.07212568f, -0.04063992f, -0.01668460f, 
    -0.02562150f, 0.00730909f, -0.01910903f, -0.01430805f, -0.07597518f, -0.08355381f, 0.00735944f, 0.08067250f, 
    0.10839482f, 0.04034707f, -0.03451579f, -0.00150514f, -0.02473475f, -0.04574224f, 0.03291323f, 0.10028312f, 
    0.18879522f, -0.10197130f, -0.19729219f, -0.00834051f, -0.00132277f, 0.00065601f, 0.02292338f, -0.13324359f, 
    0.04770100f, 0.01973226f, -0.02282181f, 0.02847572f, 0.03591658f, -0.22737797f, 0.03749075f, -0.10428541f, 
    0.01096048f, -0.00668377f, 0.06890521f, 0.16827615f, 0.04070106f, -0.02603322f, -0.06632715f, -0.02998015f, 
    0.03215382f, 0.00875381f, -0.06168307f, 0.03591710f, 0.09722898f, -0.00850566f, 0.04396727f, -0.00220981f, 
    0.05321684f, -0.00256165f, -0.07002516f, -0.07040218f, 0.01081959f, -0.24304779f, -0.13635895f, -0.13532098f, 
    -0.02492968f, -0.01236749f, -0.11342135f, -0.05528921f, 0.11611601f, -0.00269007f, 0.10009281f, 0.04291566f, 
    -0.20216240f, -0.14403045f, 0.16545536f, 0.01726825f, 0.12157562f, -0.03167567f, -0.03412240f, -0.12531941f, 
    0.08676845f, 0.03092766f, -0.05193846f, -0.01316026f, -0.11068403f, -0.02622909f, 0.00197458f, 0.14065541f, 
    -0.10872278f, -0.04306988f, 0.08295329f, -0.09514623f, 0.11675619f, 0.10663293f, -0.04117033f, -0.00432423f, 
    -0.21272321f, 0.07340734f, 0.00930853f, -0.00908168f, 0.22287539f, 0.07696836f, -0.08845495f, -0.02085290f, 
    -0.04025182f, -0.02091472f, -0.03386217f, 0.11883420f, 0.22094852f, 0.05698753f, -0.06538109f, 0.27637255f, 
    -0.07010613f, 0.01630782f, 0.02732447f, 0.03890418f, -0.00446493f, 0.00510063f, 0.04962078f, 0.05017066f, 
    -0.21516816f, -0.18225101f, -0.05171635f, -0.12532343f, 0.10696659f, 0.03334357f, 0.03565865f, 0.03534373f, 
    -0.03168753f, 0.01206045f, -0.05435030f, 0.08416998f, 0.17323275f, 0.07333200f, 0.10581382f, 0.12068482f, 
    -0.00615675f, -0.08166495f, 0.02321443f, 0.05151605f, -0.04279451f, -0.00133357f, 0.06823052f, -0.02339739f, 
    -0.00257404f, 0.12578937f, 0.04621614f, 0.20850749f, -0.00566764f, 0.08655030f, 0.14344949f, -0.06487498f, 
    -0.00569807f, 0.14090978f, 0.09162693f, 0.10618510f, -0.09332903f, -0.11509344f, -0.00359723f, -0.08802657f, 
    -0.06609624f, 0.01601900f, 0.03245465f, 0.08672339f, 0.08541902f, 0.09499780f, 0.06329586f, 0.02833363f, 
    0.09232634f, 0.25777987f, -0.02935282f, -0.16816364f, -0.06679052f, 0.03964872f, 0.05840017f, 0.00130573f, 
    0.04712238f, 0.05889980f, 0.11600798f, -0.01101349f, 0.34568036f, -0.03316874f, -0.00056295f, 0.25477314f, 
    -0.02116547f, -0.12202281f, 0.06109573f, 0.07941453f, 0.02614816f, 0.16399378f, 0.02376739f, 0.04905428f, 
    0.20982908f, 0.25992745f, 0.01707965f, -0.24383788f, 0.00158434f, -0.04164203f, -0.09122138f, -0.07695819f, 
    -0.03096152f, -0.02038888f, 0.00494956f, -0.07069314f, 0.01600140f, 0.01160141f, 0.00706211f, -0.02370237f, 
    -0.05455625f, 0.03509526f, 0.09592526f, 0.09453814f, 0.00192567f, 0.05332409f, -0.05783253f, 0.05994403f, 
    -0.20532343f, -0.18028659f, 0.04205232f, -0.12917225f, -0.01547962f, -0.00568140f, 0.03693275f, 0.04336553f, 
    -0.00151649f, -0.05665936f, 0.00905668f, 0.10918021f, 0.34021872f, 0.03630322f, 0.12100890f, 0.32241049f, 
    -0.15244076f, 0.03247870f, 0.03233804f, 0.03712715f, 0.09917811f, -0.00641658f, -0.02014644f, 0.05751174f, 
    0.03534227f, 0.15290612f, 0.03373571f, -0.09008285f, -0.11744873f, 0.09646238f, 0.09026455f, -0.07703441f, 
    0.07853267f, 0.02170611f, 0.10096168f, -0.03868065f, -0.22716753f, -0.08202583f, -0.08718087f, 0.01129414f, 
    0.04945670f, -0.02669614f, 0.08089545f, 0.03607677f, -0.03124302f, 0.09474418f, -0.00720487f, -0.07411221f, 
    0.03641503f, -0.01442880f, -0.03323565f, -0.09752199f, -0.01993020f, 0.00054950f, 0.04685144f, 0.17628904f, 
    -0.07719205f, 0.17126136f, 0.03424175f, 0.15863074f, -0.07080512f, -0.07629050f, 0.00962120f, -0.02824929f, 
    -0.07487221f, 0.03043717f, -0.02259480f, -0.04190689f, 0.04422025f, 0.05500841f, -0.02904249f, 0.08996556f, 
    -0.14594951f, 0.09452777f, 0.13598818f, 0.08783843f, -0.06511169f, -0.02579698f, 0.02412046f, -0.00791955f, 
    0.06563360f, -0.07694416f, -0.01137412f, 0.01677467f, 0.13970596f, 0.05496194f, 0.02622853f, -0.16568093f, 
    -0.07404413f, -0.01901429f, 0.09606730f, 0.00995275f, -0.06336745f, -0.01637203f, 0.02895232f, 0.01240682f, 
    -0.10113557f, -0.02436062f, -0.03565382f, -0.18691166f, 0.06997912f, -0.04879427f, 0.06829196f, 0.04521705f, 
    -0.08238774f, 0.01386461f, 0.09784944f, 0.02339898f, -0.03769689f, -0.10908499f, -0.02467721f, 0.15677825f, 
    0.03366718f, -0.07476633f, 0.11432565f, -0.00081057f, 0.16812213f, 0.04016909f, 0.04217859f, -0.01279040f, 
    0.30783328f, -0.08681752f, -0.04222718f, 0.11809727f, -0.03079645f, -0.05106428f, -0.04175974f, 0.02156120f, 
    0.03686763f, 0.03953329f, 0.03994492f, -0.03758135f, 0.31862316f, -0.07235464f, 0.08977039f, 0.24386613f, 
    -0.10596702f, 0.01359372f, -0.02017806f, -0.03003815f, -0.06863035f, -0.03848701f, -0.07213106f, -0.02109553f, 
    0.18632133f, 0.15646981f, 0.15751787f, 0.10060409f, -0.04618895f, 0.11101159f, -0.04257446f, 0.02797583f, 
    -0.02678336f, 0.02560632f, -0.02472742f, 0.00683704f, -0.27106166f, 0.00598839f, 0.04302326f, 0.12918322f, 
    0.16282459f, -0.05473160f, 0.06382883f, 0.05158259f, 0.00244535f, -0.03223769f, 0.15291658f, 0.09278999f, 
    -0.05031178f, 0.01886808f, -0.06654546f, -0.08746082f, 0.04582730f, 0.03247154f, 0.00844074f, 0.02107460f, 
    0.03579918f, 0.00861688f, -0.01341017f, -0.03124729f, 0.33416378f, 0.00945879f, 0.15815285f, 0.40172929f, 
    -0.10592384f, 0.02136646f, 0.03709664f, 0.03428584f, 0.09567921f, 0.03846836f, -0.02215996f, -0.06736491f, 
    -0.13536502f, -0.07992372f, 0.10391019f, -0.01958837f, -0.00126237f, 0.04751283f, -0.02030898f, 0.01721053f, 
    -0.07074288f, 0.01016924f, 0.03970952f, 0.06816067f, 0.04424929f, -0.06869838f, 0.07700393f, 0.06793767f, 
    0.02825801f, -0.01285295f, -0.01014944f, 0.02806136f, 0.01845755f, 0.01246928f, 0.10032294f, 0.02628771f, 
    0.33732468f, 0.15912436f, -0.00428236f, 0.21668260f, 0.05975391f, -0.06408164f, 0.00030123f, 0.08445773f, 
    -0.07933573f, 0.00975728f, -0.00639332f, -0.03477893f, 0.23339953f, 0.18364449f, -0.03645321f, 0.00739385f, 
    -0.09269533f, -0.00254341f, 0.01106713f, 0.02467485f, 0.02427189f, 0.00415586f, -0.01911579f, 0.02432474f, 
    0.30682364f, 0.19547118f, -0.26691166f, -0.05608649f, 0.01297363f, -0.04031126f, 0.03119469f, -0.00178507f, 
    0.01068478f, 0.06127768f, -0.02629604f, 0.00490451f, 0.32751873f, -0.02627219f, -0.01378809f, 0.00280137f, 
    0.16143321f, -0.04765429f, -0.04658651f, -0.03078330f, -0.10388039f, -0.03596985f, -0.00992041f, 0.04568950f, 
    0.02406053f, 0.18640870f, -0.12497059f, 0.15023103f, -0.02320197f, 0.04665735f, 0.09923796f, 0.01509346f, 
    -0.08763147f, 0.08317107f, 0.04312767f, -0.04784821f, -0.12745228f, 0.05234597f, 0.17629178f, -0.18754902f, 
    0.12639020f, -0.13207693f, 0.03921889f, 0.03453225f, 0.06235384f, -0.06635408f, 0.04518530f, -0.04621594f, 
    0.03365384f, 0.09796171f, 0.07055835f, 0.13062188f, -0.07417067f, 0.03823530f, 0.09053606f, -0.11276359f, 
    0.05719654f, 0.11748270f, 0.01689884f, -0.03839716f, 0.08457856f, -0.18862307f, 0.04253874f, -0.18300807f, 
    0.06416330f, -0.02837615f, -0.09659532f, -0.06312861f, 0.01322604f, -0.02522787f, 0.07331946f, -0.02071967f, 
    0.02545854f, -0.10956386f, -0.03868135f, -0.13673536f, 0.01240394f, -0.09737522f, -0.00939298f, 0.08470689f, 
    -0.08313368f, 0.06202136f, -0.16539155f, 0.08139114f, 0.10105049f, -0.09536092f, 0.02603424f, 0.14271517f, 
    0.12730597f, 0.09612309f, 0.00604202f, 0.04893570f, -0.00422012f, -0.05949745f, 0.01680015f, -0.06029648f, 
    0.06912309f, -0.06420673f, 0.03608784f, 0.08717186f, 0.05847767f, -0.05429420f, -0.04444471f, 0.00987553f, 
    -0.14681211f, -0.04129723f, -0.08776358f, -0.05751193f, -0.21660239f, 0.22674282f, 0.10184937f, -0.14235631f, 
    -0.00089701f, 0.02573534f, 0.01844784f, -0.10539284f, -0.06499889f, -0.01750933f, 0.05190379f, -0.06518167f, 
    -0.19064085f, -0.06321315f, 0.03130783f, 0.02803989f, 0.03821085f, 0.00004338f, 0.16729634f, 0.08185989f, 
    0.12961759f, -0.00867272f, -0.02135286f, 0.02241682f, 0.63458669f, -0.04487525f, 0.02685645f, 0.06030597f, 
    -0.00295911f, 0.06981228f, 0.05401340f, 0.09995143f, -0.07602809f, 0.06494163f, 0.07773785f, 0.00241814f, 
    0.00449261f, 0.00718028f, -0.04674302f, 0.07213704f, 0.10496615f, 0.03189847f, -0.08549014f, -0.07332049f, 
    0.07227480f, 0.00006335f, -0.00936902f, -0.03171371f, -0.12184366f, 0.06188039f, 0.01631789f, -0.15010250f, 
    0.03025937f, -0.02279494f, 0.08638529f, -0.13657144f, -0.14023377f, 0.03887867f, -0.04459490f, 0.00061734f, 
    -0.10651581f, 0.04377318f, 0.00738401f, -0.15842505f, 0.08482143f, -0.02899415f, -0.01112765f, -0.01974859f, 
    0.03112290f, 0.06899586f, -0.06862243f, -0.13557261f, 0.14855888f, -0.04410293f, -0.08535420f, 0.04017279f, 
    0.00319269f, 0.07004296f, -0.02991879f, 0.00902083f, 0.07627460f, 0.05366760f, 0.06486264f, 0.06690439f, 
    -0.05578735f, 0.19084923f, 0.03447363f, 0.11470955f, 0.08948780f, -0.04666946f, -0.07180736f, -0.02169104f, 
    0.07776351f, -0.02209884f, 0.04666223f, -0.02346366f, 0.28581235f, -0.09063730f, -0.17079239f, -0.01546600f, 
    -0.00047094f, 0.05659792f, 0.04532877f, 0.01893252f, -0.08661450f, 0.01344992f, -0.05287524f, -0.04474644f, 
    0.40705979f, -0.04068179f, -0.14098309f, -0.03538657f, 0.05104979f, -0.04323342f, -0.08269795f, -0.00079058f, 
    -0.12077310f, -0.00961510f, -0.01397509f, -0.01036353f, -0.24497318f, 0.09687135f, 0.13396086f, 0.24525741f, 
    0.10346149f, 0.01379571f, -0.04206092f, 0.02158938f, 0.03434312f, 0.06249295f, 0.01603450f, -0.00748372f, 
    -0.08832797f, 0.07299633f, -0.05601494f, 0.13803452f, -0.04253270f, 0.04193272f, 0.09403288f, 0.02052607f, 
    0.13522632f, 0.01864506f, 0.05041025f, 0.09212636f, 0.08392406f, 0.20862861f, 0.08611824f, -0.21859874f, 
    -0.05926723f, 0.12432162f, -0.20878386f, -0.00754008f, -0.07041480f, -0.12144389f, 0.06980255f, 0.10143344f, 
    -0.30724660f, 0.21746427f, 0.04523324f, -0.15833539f, 0.03319156f, 0.06859926f, 0.02609161f, 0.02990137f, 
    0.04526099f, -0.01947526f, -0.01534215f, 0.05425957f, -0.14568682f, 0.13631108f, -0.02034947f, -0.26507324f, 
    0.10983452f, -0.04479591f, -0.12410862f, 0.01755838f, 0.07556683f, 0.04165628f, 0.05734318f, -0.05527637f, 
    -0.02133853f, 0.04913410f, 0.00064193f, -0.08168936f, 0.04403712f, -0.08628740f, -0.01769160f, 0.01238262f, 
    -0.04047488f, 0.01035090f, 0.02624753f, 0.01688021f, 0.35930192f, 0.19131422f, 0.00635160f, -0.02020910f, 
    0.00553893f, 0.11171706f, 0.08091662f, 0.06147236f, -0.15615532f, -0.06268910f, -0.10680441f, 0.01570411f, 
    0.08247721f, -0.00383091f, 0.11221602f, 0.21614867f, -0.04184287f, 0.04285673f, -0.06219307f, 0.04344006f, 
    0.12829682f, 0.11105888f, -0.05319593f, 0.05552574f, -0.29461369f, 0.07355381f, -0.11625589f, -0.32443386f, 
    0.14009289f, -0.05584010f, 0.01149268f, -0.07795711f, -0.02569056f, 0.06080436f, 0.00974805f, 0.04792819f, 
    0.11778306f, -0.12705417f, 0.04997377f, -0.02653767f, 0.10713769f, 0.06947760f, 0.10860381f, -0.04447817f, 
    0.12423495f, -0.02092850f, 0.02583058f, -0.09434049f, 0.30709416f, 0.19009233f, 0.05326337f, -0.02147053f, 
    0.01534971f, 0.03613374f, -0.00607513f, 0.21935104f, 0.08787137f, 0.02565730f, -0.04088878f, -0.08121680f, 
    -0.02376656f, 0.00910489f, -0.03257394f, -0.17710415f, 0.02786222f, 0.07919328f, -0.03460591f, -0.08493388f, 
    -0.02485189f, -0.05745531f, 0.01857625f, -0.01021102f, -0.17031485f, -0.05158452f, 0.15662925f, -0.03731103f, 
    -0.09654190f, -0.03220120f, -0.08986081f, -0.02839329f, -0.01788041f, -0.08662993f, 0.11926604f, 0.18485205f, 
    0.23874827f, 0.16821983f, -0.21007718f, 0.02741555f, 0.03954036f, 0.02966247f, 0.01046328f, 0.06163327f, 
    0.05490150f, 0.02334481f, -0.02545976f, 0.02962301f, 0.24249834f, 0.18986829f, 0.11961582f, -0.17256176f, 
    0.17788859f, 0.05330798f, 0.04096021f, 0.02286144f, -0.08640081f, -0.06349435f, -0.08249021f, -0.06809678f, 
    0.09858732f, -0.00258820f, 0.04467051f, 0.16580649f, -0.01999519f, -0.13287412f, 0.11471221f, 0.06884272f, 
    0.05554203f, -0.09998284f, 0.19009554f, -0.07237349f, -0.28910774f, -0.15356632f, 0.16392693f, -0.17017686f, 
    0.04426067f, -0.05540368f, 0.01684246f, 0.05346645f, -0.04972304f, -0.08661134f, -0.10042237f, -0.02359023f, 
    0.09279506f, 0.09937301f, 0.07052404f, 0.01596075f, 0.00553387f, 0.03582655f, 0.10476486f, -0.09242553f, 
    -0.03583526f, 0.05345140f, 0.07793359f, -0.05453538f, -0.24896133f, 0.05184801f, 0.02211020f, -0.02538153f, 
    0.01725547f, 0.05098673f, 0.04462456f, 0.00102821f, 0.07052250f, -0.05786547f, 0.11514667f, -0.00882101f, 
    0.15282141f, -0.11332016f, 0.06533869f, -0.27764246f, 0.06609687f, -0.05435275f, -0.05284129f, 0.11122009f, 
    0.01054189f, -0.01740780f, 0.04491958f, 0.12847829f, 0.05210667f, -0.01289159f, 0.02047196f, 0.06456321f, 
    0.07151355f, 0.10216819f, -0.01964828f, 0.04313409f, 0.05573337f, -0.00195040f, -0.01807223f, 0.04268596f, 
    0.01914656f, -0.14250360f, 0.08808096f, 0.19286945f, 0.06070363f, 0.01264577f, -0.01193368f, 0.01281603f, 
    -0.09034216f, 0.05104897f, -0.14248252f, 0.02621531f, -0.36445335f, 0.20840570f, 0.16595736f, -0.20312127f, 
    0.07217404f, 0.22611372f, 0.06224309f, 0.03522271f, -0.02248497f, 0.05026740f, 0.07631419f, -0.01454469f, 
    -0.06634068f, -0.10023234f, -0.02051899f, 0.20979322f, 0.08620027f, 0.05262627f, 0.09703509f, 0.08491145f, 
    0.13731377f, 0.02746128f, 0.02193905f, 0.02073239f, 0.27185586f, -0.22310662f, 0.00608081f, 0.11962961f, 
    -0.03730192f, 0.01251364f, 0.01056379f, 0.04300330f, -0.02327980f, 0.03521904f, 0.09509477f, 0.07392343f, 
    0.09072023f, 0.10699439f, -0.11154611f, 0.09600424f, -0.09518811f, -0.04744958f, -0.03461050f, -0.05269458f, 
    -0.11591092f, 0.00078443f, -0.04556429f, -0.01135943f, -0.29722425f, 0.11921678f, -0.06408995f, -0.34289113f, 
    0.07906268f, 0.03529549f, 0.05940459f, 0.01373507f, -0.02170475f, -0.01975045f, -0.01470665f, -0.08807684f, 
    0.03365944f, -0.05223936f, -0.16261795f, 0.11331684f, 0.13530281f, 0.02491277f, -0.06872558f, 0.01368682f, 
    -0.02356886f, -0.07333242f, -0.05742744f, -0.09694673f, 0.12434471f, 0.16451971f, 0.01950473f, -0.11847334f, 
    -0.02323858f, 0.02394914f, 0.00978207f, -0.00556406f, 0.10799605f, 0.01846433f, -0.04221274f, 0.00827251f, 
    0.00593052f, 0.03820793f, 0.03006103f, 0.01943075f, 0.01988726f, 0.00542348f, -0.07886939f, -0.00024098f, 
    0.04003856f, -0.00175504f, 0.09616560f, -0.02407907f, 0.04859608f, 0.06374971f, -0.03880788f, 0.03525567f, 
    -0.01155604f, -0.02066341f, 0.12908052f, 0.09356217f, 0.01507120f, -0.08400719f, -0.03413250f, -0.03563857f, 
    0.26108336f, -0.06531169f, 0.08203311f, -0.13377148f, 0.07951026f, 0.04160330f, -0.03980803f, 0.00464959f, 
    -0.07977802f, 0.06941524f, 0.05702110f, -0.01330090f, -0.14527881f, 0.11576941f, -0.10370769f, 0.37076890f, 
    0.09957991f, 0.09746777f, -0.05454011f, -0.00180584f, 0.06270419f, 0.08687606f, -0.02813146f, -0.02475821f, 
    -0.03461392f, 0.15193999f, 0.04862873f, 0.16401367f, -0.03571183f, 0.03437071f, 0.06783888f, -0.05956022f, 
    0.20666008f, 0.02286847f, -0.02017575f, 0.07389193f, -0.02681971f, 0.14327475f, 0.09016301f, -0.25513455f, 
    -0.06469077f, 0.08541691f, -0.04152210f, -0.04354802f, -0.11531930f, 0.00171366f, -0.05745395f, 0.00164639f, 
    -0.34683168f, 0.18982184f, 0.08989518f, -0.03920158f, 0.09706508f, 0.04907020f, 0.10536350f, 0.05553320f, 
    0.08522032f, -0.01709200f, 0.04745645f, 0.10585736f, -0.25831813f, 0.09912234f, 0.01261580f, -0.19346906f, 
    0.13058814f, 0.05477330f, 0.05110175f, 0.03992878f, 0.07589290f, 0.11190362f, 0.00146447f, 0.07138298f, 
    -0.00299635f, -0.07959501f, -0.02419188f, -0.09160441f, 0.17240550f, 0.03433735f, 0.06613330f, 0.01050191f, 
    0.07716810f, 0.05748178f, -0.06837498f, -0.05754978f, 0.00676159f, -0.05021667f, -0.07796051f, -0.02002726f, 
    -0.05196245f, -0.01397401f, 0.04471762f, -0.04817069f, -0.04911812f, 0.01070751f, -0.04193201f, 0.09278459f, 
    0.12440211f, 0.00909857f, 0.12290426f, 0.19911526f, -0.03648459f, -0.04446452f, -0.03708247f, -0.03131262f, 
    -0.02174452f, 0.02125323f, -0.04990646f, -0.01398777f, -0.17885822f, -0.02876739f, -0.04728551f, -0.34136167f, 
    0.13988015f, 0.03635788f, -0.01186364f, -0.01516481f, -0.03635240f, -0.08901574f, 0.11674451f, 0.06803778f, 
    0.13403273f, 0.06750660f, -0.00617714f, -0.06281137f, -0.00278685f, 0.08118533f, -0.01278216f, -0.05832243f, 
    0.09142610f, 0.03936586f, 0.00599839f, 0.00374007f, -0.02359541f, -0.05795021f, 0.03798488f, 0.03365666f, 
    -0.03671966f, 0.01621753f, 0.08003405f, 0.03731596f, 0.03418258f, 0.08838512f, -0.03196728f, 0.04424701f, 
    -0.27358383f, -0.01998470f, 0.01828189f, -0.30858648f, -0.06562864f, 0.04229569f, 0.08869846f, -0.04831639f, 
    0.03891440f, 0.13675454f, 0.03388536f, 0.01845195f, 0.00650875f, -0.09839395f, -0.06243391f, -0.01697982f, 
    0.00772104f, -0.03673226f, -0.06255282f, 0.01162426f, 0.12506777f, 0.08926426f, 0.01216047f, 0.11173016f, 
    0.26044279f, 0.12252448f, 0.02182329f, 0.16766453f, -0.05416264f, 0.01553697f, 0.09185658f, 0.04534565f, 
    -0.05556765f, 0.00697855f, 0.10541070f, 0.05065302f, 0.20621936f, 0.03119584f, -0.18441595f, 0.00557974f, 
    0.07944376f, 0.02939138f, -0.07339140f, 0.05323296f, 0.09545923f, -0.10669827f, 0.05973810f, 0.11897052f, 
    -0.09713675f, 0.01578578f, -0.04713126f, -0.19396026f, 0.00712130f, 0.07688476f, 0.07476163f, 0.06039656f, 
    0.02194422f, -0.04489496f, 0.00736290f, 0.02070386f, 0.05045946f, -0.25606507f, 0.29879105f, -0.06506241f, 
    0.02016902f, -0.01074489f, -0.09012406f, 0.07111377f, -0.01506657f, 0.10498941f, -0.01577261f, 0.05084997f, 
    -0.28494367f, -0.07284568f, -0.07081027f, 0.10140365f, 0.08677832f, 0.05895460f, -0.07052846f, 0.07367137f, 
    -0.00775583f, -0.15755299f, 0.03540630f, -0.16056907f, 0.24379674f, 0.07339697f, 0.14120954f, 0.02656738f, 
    -0.01205311f, -0.02011798f, 0.07790654f, -0.01917771f, 0.06555089f, -0.01849746f, 0.05544727f, -0.00326422f, 
    -0.00763246f, 0.11192520f, -0.09874038f, -0.01786912f, -0.02702489f, -0.07937833f, 0.00080072f, 0.07902122f, 
    0.04429079f, -0.11072559f, -0.01764935f, -0.11779965f, -0.07253696f, -0.03678012f, -0.00790667f, -0.16542484f, 
    0.08360391f, 0.08538502f, -0.02929316f, -0.00301198f, -0.07616902f, 0.08070501f, -0.12008467f, -0.03955059f, 
    0.22267364f, 0.34063089f, -0.00150575f, 0.12511539f, -0.07307906f, -0.05653765f, 0.11878698f, -0.08245562f, 
    0.03024465f, -0.09097421f, 0.04562333f, 0.01733905f, 0.22941226f, 0.23497334f, -0.02015402f, 0.16387051f, 
    -0.05264634f, -0.01562724f, 0.01218644f, -0.00072945f, -0.04127032f, 0.04510574f, 0.01515684f, -0.02190610f, 
    0.17032807f, -0.17892225f, 0.00082573f, -0.10491403f, -0.03894816f, 0.10593652f, 0.16401498f, -0.02224400f, 
    -0.02032285f, 0.06117759f, -0.00798333f, -0.06094271f, 0.01181617f, -0.31552044f, 0.10441972f, -0.07568748f, 
    -0.11930537f, 0.10972603f, 0.04912226f, -0.04155764f, -0.00965646f, 0.13259853f, 0.05316053f, -0.13725670f, 
    -0.08339017f, -0.05679817f, -0.03134935f, 0.08993610f, 0.12619708f, 0.11011069f, -0.02240902f, 0.03641203f, 
    -0.01675879f, 0.02698722f, 0.17258945f, 0.02576551f, 0.34820744f, -0.05030276f, 0.19754919f, 0.04684529f, 
    0.04506803f, 0.01953889f, -0.01461698f, -0.01044054f, 0.02910707f, 0.07410055f, -0.00315316f, 0.09930137f, 
    -0.12929648f, -0.21173477f, 0.08239093f, 0.06223650f, 0.01347941f, -0.09474099f, 0.13384162f, -0.07128352f, 
    0.05490770f, -0.07335418f, 0.01344773f, 0.13464539f, 0.09339262f, -0.06118837f, -0.22135536f, -0.07143174f, 
    0.10871240f, 0.08422586f, -0.05404598f, 0.07837378f, -0.03262786f, -0.06605683f, -0.00320778f, 0.13478749f, 
    -0.18124968f, -0.05810345f, -0.06430598f, -0.01651030f, 0.03519280f, -0.15058155f, 0.05936324f, -0.09018862f, 
    -0.01233741f, -0.10674738f, -0.01138122f, -0.05907414f, 0.14214024f, -0.05323195f, -0.28979397f, -0.02327182f, 
    0.04174916f, -0.04500073f, 0.03448584f, 0.09747785f, -0.12405277f, 0.04357013f, 0.04959720f, 0.06616644f, 
    0.49555191f, 0.10825940f, -0.17991604f, 0.07436298f, -0.08186977f, -0.03126898f, -0.02557094f, -0.09645463f, 
    0.05433891f, 0.07571677f, 0.06530909f, 0.03587442f, 0.08458378f, -0.17423239f, 0.02601125f, -0.15232402f, 
    0.09263204f, -0.09784461f, 0.06917617f, 0.00928513f, -0.01371894f, -0.14500925f, 0.12126858f, 0.08629192f, 
    -0.15891761f, 0.06149895f, -0.16004960f, 0.04957229f, 0.05876852f, -0.04836392f, -0.15751700f, 0.02600952f, 
    -0.10332205f, 0.03347766f, -0.03192373f, -0.10035855f, 0.18738298f, 0.36822680f, -0.02066044f, 0.06060016f, 
    -0.04616859f, 0.05332205f, -0.04784763f, 0.10443752f, -0.00005603f, -0.15774196f, -0.03708300f, 0.03716588f, 
    -0.05323399f, 0.19184068f, -0.00245696f, 0.08355855f, -0.02959317f, -0.15073833f, -0.06509617f, -0.03271914f, 
    -0.08942052f, 0.14921524f, -0.11575152f, 0.02766297f, 0.18581977f, 0.15807419f, 0.06532107f, 0.00290517f, 
    -0.12587886f, -0.07815410f, 0.01061627f, -0.02191206f, 0.07997501f, 0.00097973f, 0.02701470f, -0.00998094f, 
    0.32200679f, 0.11323888f, 0.08441022f, 0.00306297f, -0.00142004f, -0.04724802f, 0.14013405f, -0.00518104f, 
    -0.06575333f, -0.00933924f, -0.02807656f, 0.01646742f, 0.16816320f, -0.04135491f, -0.08305460f, -0.08841300f, 
    0.21968023f, -0.03252357f, -0.01218857f, -0.00258894f, -0.07071504f, -0.04355433f, -0.00575487f, 0.05003246f, 
    -0.27931356f, 0.00106128f, -0.03174106f, -0.12515217f, 0.14085393f, -0.01407789f, 0.12347133f, 0.06264874f, 
    0.05184234f, 0.08988463f, 0.11031318f, 0.02001245f, 0.01164682f, -0.05976122f, 0.08460925f, -0.04752674f, 
    -0.02099854f, 0.11155127f, -0.07008852f, -0.04102874f, 0.11693080f, 0.09680641f, -0.06478188f, 0.04364859f, 
    -0.06763124f, -0.22167347f, -0.04956902f, 0.04885184f, 0.10498318f, 0.06754809f, 0.13181169f, 0.08500860f, 
    -0.01686303f, 0.08102103f, -0.02556413f, -0.09111878f, 0.15918325f, -0.03754494f, -0.03161736f, -0.04556989f, 
    0.01711593f, 0.13225262f, -0.01646381f, 0.03151522f, 0.00523563f, 0.01977088f, 0.02849261f, -0.11295982f, 
    0.26484275f, 0.18854696f, 0.21720184f, -0.05899717f, 0.03326442f, 0.01815310f, 0.09359432f, -0.06458902f, 
    0.04252447f, 0.04813303f, -0.00532969f, 0.01704462f, -0.29605472f, -0.07692933f, 0.20674565f, -0.03963353f, 
    -0.03096327f, 0.09962844f, 0.10283284f, -0.10513500f, -0.02568566f, 0.07453877f, 0.08855598f, 0.04103314f, 
    -0.17052898f, -0.07783340f, -0.20451087f, -0.16083854f, 0.01384842f, -0.04060498f, -0.08629575f, 0.00372973f, 
    0.09743375f, 0.02793010f, 0.01754731f, 0.07334824f, -0.13536067f, -0.08491915f, -0.00334306f, -0.01299476f, 
    -0.02353440f, -0.04515701f, -0.00483871f, -0.02103408f, 0.01800037f, 0.09090137f, 0.04999751f, -0.07138997f, 
    -0.02849290f, -0.04915477f, -0.05494931f, 0.17890954f, 0.02117045f, 0.03476613f, -0.05200893f, 0.14030457f, 
    0.00500297f, 0.05513190f, -0.05338774f, -0.01512975f, -0.28701022f, 0.26797709f, -0.41118997f, -0.02169476f, 
    0.03023946f, -0.00387875f, 0.00610329f, -0.01570881f, -0.01016148f, 0.04779115f, 0.09580821f, 0.00861099f, 
    0.15782480f, 0.10138534f, 0.07649419f, 0.09815592f, 0.08825953f, 0.02273068f, 0.03898751f, -0.07229663f, 
    -0.09810294f, -0.00990782f, -0.03857697f, 0.09132477f, -0.12515177f, -0.08457453f, -0.10790578f, -0.19458881f, 
    0.07225257f, -0.12715891f, -0.04988682f, 0.00586806f, 0.04196019f, 0.07088016f, 0.05721339f, -0.05631657f, 
    -0.08669679f, -0.11126010f, 0.09591344f, -0.10014275f, 0.01197746f, 0.04676715f, 0.10873375f, -0.05386010f, 
    0.07594150f, 0.15285419f, -0.10206854f, 0.10999537f, 0.10752706f, 0.13814963f, -0.02799329f, 0.23754159f, 
    -0.02987765f, -0.02522215f, 0.06092727f, 0.13518834f, 0.12914230f, -0.05333899f, 0.02503450f, 0.01404954f, 
    -0.02750468f, -0.36958393f, 0.05651702f, -0.05884385f, -0.04967579f, 0.07019753f, -0.17525454f, -0.01424356f, 
    -0.05866253f, 0.07587252f, 0.00012457f, -0.06550452f, -0.37338477f, -0.05619765f, 0.00643402f, -0.23454250f, 
    -0.07671424f, -0.03268424f, 0.08979969f, -0.03896796f, 0.16285606f, -0.08695743f, 0.02431875f, -0.04360462f, 
    -0.27609783f, 0.06390405f, 0.11274365f, -0.07690050f, 0.10382213f, 0.03632850f, -0.08751105f, 0.00856180f, 
    0.13831475f, -0.03173746f, 0.04316577f, 0.13739818f, 0.06425032f, 0.30964816f, -0.12042965f, -0.02268237f, 
    0.12727982f, 0.05667981f, -0.05710859f, 0.07011120f, -0.02893709f, 0.02864040f, -0.00218760f, 0.06594250f, 
    0.18927956f, 0.03881420f, 0.12970923f, 0.05746204f, 0.10284094f, -0.00800508f, 0.08483718f, 0.05188216f, 
    -0.02982868f, -0.05788245f, -0.07364956f, 0.03091251f, -0.30725753f, 0.17324756f, -0.20811783f, -0.20060775f, 
    0.06897163f, 0.01212854f, 0.02752191f, 0.05042325f, -0.01764510f, 0.00518854f, -0.12045225f, 0.01856891f, 
    -0.13364907f, 0.15882687f, -0.02485329f, -0.17483658f, -0.01944208f, -0.04346711f, -0.09531759f, -0.05047160f, 
    -0.02541723f, 0.13369866f, 0.08076169f, -0.10802469f, 0.05941121f, 0.05886351f, 0.13999146f, 0.10451947f, 
    0.01513847f, 0.03606469f, 0.15788545f, 0.08762988f, 0.05434551f, 0.10761300f, -0.02371331f, -0.04867664f, 
    0.17550790f, 0.13676845f, 0.10832350f, 0.06030250f, 0.04459817f, 0.07993226f, -0.02097712f, 0.01867512f, 
    -0.15294999f, 0.04452069f, 0.06928021f, -0.06584762f, 0.09293063f, -0.06684007f, 0.17570743f, -0.04011025f, 
    -0.02612523f, 0.13799343f, 0.01239353f, 0.03199602f, 0.05052781f, 0.01171557f, -0.04659345f, -0.16575193f, 
    -0.31683412f, -0.03508418f, 0.19694254f, -0.08808275f, 0.01102667f, 0.08091077f, -0.05042687f, -0.01536098f, 
    0.04040483f, -0.07325842f, 0.01869758f, 0.06177760f, -0.08512089f, 0.15185574f, 0.21374995f, 0.15064536f, 
    -0.01118292f, 0.10216828f, 0.07158262f, -0.02079235f, -0.02975473f, 0.11456800f, -0.08398242f, -0.01057848f, 
    0.14408749f, 0.05160432f, 0.14406382f, 0.10390638f, 0.06117270f, 0.02334302f, -0.08330915f, 0.02204717f, 
    0.13588858f, 0.01647412f, -0.09466206f, 0.12290791f, 0.00117775f, -0.17581408f, 0.30647686f, -0.01226570f, 
    -0.15292805f, -0.04126094f, -0.03639104f, -0.09372395f, 0.02607562f, 0.10346991f, -0.00651130f, -0.01822995f, 
    -0.19350611f, -0.03061093f, 0.00844552f, -0.00698471f, -0.06613585f, 0.05782359f, 0.05976841f, -0.12004197f, 
    0.12580892f, 0.00630275f, 0.00811570f, 0.00297151f, -0.31363854f, -0.01733969f, -0.02910072f, -0.11311090f, 
    0.01155969f, 0.04703540f, 0.01383635f, -0.07783448f, -0.01720534f, 0.02025629f, 0.03080689f, 0.03298437f, 
    -0.17067237f, 0.11396055f, -0.04381203f, -0.06047499f, 0.06524962f, -0.03305348f, -0.03045887f, 0.03593240f, 
    0.02635540f, 0.00446901f, -0.03672692f, 0.03124330f, -0.07441033f, -0.00128050f, 0.05994005f, 0.23365775f, 
    0.03451495f, 0.13987687f, 0.06002219f, 0.05327052f, 0.04561143f, 0.06333688f, 0.10378254f, 0.05323184f, 
    0.21010837f, 0.08665783f, 0.18348210f, 0.23719229f, -0.00496577f, 0.03157597f, -0.00135016f, 0.16911756f, 
    -0.03644274f, -0.07655583f, -0.08231886f, -0.00883850f, -0.15533005f, 0.25370479f, -0.11164848f, -0.06228964f, 
    -0.01160583f, -0.04763180f, -0.02618790f, 0.01523528f, -0.01144786f, 0.06192819f, 0.05602143f, 0.19398373f, 
    -0.04232288f, 0.05165433f, 0.14118654f, 0.11895042f, 0.16008811f, 0.09243251f, -0.03215755f, 0.03776495f, 
    0.05843224f, 0.03098362f, 0.03672729f, 0.10717549f, -0.21075380f, 0.02881376f, 0.22272502f, 0.13796516f, 
    0.14743912f, -0.07781743f, 0.14235568f, 0.08703694f, -0.07258424f, 0.09732927f, 0.04073266f, 0.09505314f, 
    -0.25502950f, -0.10205686f, -0.22070910f, -0.17039433f, 0.04393261f, -0.06958363f, -0.11517234f, 0.03703718f, 
    -0.00452070f, 0.05910747f, -0.01980541f, 0.04046843f, -0.11367302f, 0.17445405f, -0.31886393f, -0.12683138f, 
    -0.05040784f, -0.09788693f, -0.05675285f, -0.03405858f, -0.01789238f, 0.02866660f, -0.00671366f, -0.01833860f, 
    0.03882243f, 0.14686607f, 0.37419379f, -0.07204455f, 0.01070165f, 0.09475529f, 0.05567763f, 0.08886665f, 
    -0.10962132f, -0.06261426f, 0.02241320f, 0.00194084f, 0.02774655f, 0.03291832f, 0.14962681f, -0.16577874f, 
    -0.07083410f, 0.07530632f, 0.03491942f, 0.09458610f, 0.02782495f, 0.01395787f, 0.00583076f, 0.02984684f, 
    0.33268470f, -0.23233992f, 0.08817034f, -0.12092456f, -0.01915121f, 0.05463799f, 0.04717387f, -0.02361490f, 
    0.14980780f, -0.10005275f, -0.00013147f, -0.00399476f, 0.12249707f, -0.19489966f, 0.16149841f, -0.06530331f, 
    -0.06973454f, -0.00358711f, -0.14464572f, 0.02392513f, 0.11670329f, -0.02433882f, -0.02580313f, -0.00259263f, 
    0.16257089f, 0.08441169f, 0.02929048f, 0.02278560f, -0.00070428f, 0.01182367f, 0.02547132f, 0.12079872f, 
    -0.02346797f, -0.05929266f, 0.14875920f, 0.01181470f, -0.04574024f, 0.12378212f, -0.07654879f, 0.05956121f, 
    -0.03515162f, 0.06493164f, 0.03942642f, -0.01115903f, -0.01130258f, -0.03062790f, -0.11225411f, 0.15710542f, 
    0.16157590f, 0.09624103f, 0.02982305f, 0.12069908f, -0.03638726f, 0.04610684f, -0.06478509f, 0.00994229f, 
    -0.04391377f, -0.14326346f, 0.03521449f, -0.14142917f, 0.04590928f, 0.05034773f, 0.04711095f, -0.18064041f, 
    0.08418554f, -0.04118945f, 0.04974101f, -0.10291228f, -0.05160717f, 0.15386981f, -0.03313139f, 0.13413711f, 
    -0.09977172f, 0.14726415f, -0.04940856f, 0.01738174f, 0.13238673f, 0.02528765f, 0.08598556f, -0.01400140f, 
    0.04514686f, 0.03274597f, 0.03219640f, 0.12092108f, 0.05792514f, -0.14146310f, -0.02231865f, 0.06748906f, 
    0.15298706f, -0.07245900f, 0.01116399f, 0.05155714f, 0.04700257f, -0.01091387f, 0.01563442f, 0.12901145f, 
    -0.05501623f, -0.07686413f, -0.17371333f, 0.02949474f, 0.12850884f, -0.02733831f, -0.07373425f, -0.02655097f, 
    -0.05293095f, 0.05448002f, -0.03428311f, -0.02243630f, -0.29195786f, -0.14709282f, -0.14404291f, 0.03928950f, 
    -0.07237637f, -0.13074818f, -0.00200273f, -0.10705795f, -0.00945778f, -0.08022691f, -0.08811469f, -0.03812516f, 
    -0.06179512f, -0.00720098f, 0.00643376f, -0.08860552f, 0.01791456f, 0.08295917f, 0.02319592f, -0.05781660f, 
    0.05788275f, 0.12758423f, 0.17361666f, -0.00334124f, 0.07533182f, -0.17732799f, 0.18958324f, -0.01272436f, 
    0.03074350f, -0.06648745f, -0.07898331f, -0.05463089f, 0.11955597f, 0.00960150f, 0.21921389f, -0.00360726f, 
    0.14311466f, -0.14628129f, -0.15964513f, 0.05685008f, 0.03880472f, 0.09083124f, 0.03169225f, -0.05126316f, 
    -0.07142211f, -0.02002497f, -0.00091588f, 0.16744472f, 0.21128450f, 0.11999191f, 0.05199594f, -0.09568182f, 
    0.03573293f, 0.06585769f, -0.08598538f, -0.00948261f, -0.04582351f, -0.06033426f, 0.13379765f, 0.14642569f, 
    -0.09957606f, -0.02361310f, 0.00426861f, 0.07782196f, 0.06439546f, 0.05450415f, 0.08141739f, 0.05582422f, 
    0.09339476f, -0.10915885f, -0.16076472f, 0.06053516f, 0.05381640f, 0.16932938f, -0.01451446f, -0.04975934f, 
    0.03405850f, 0.05661320f, -0.00291760f, 0.07880077f, -0.03237249f, 0.00592303f, 0.08251288f, 0.08872703f, 
    -0.14546621f, 0.00600146f, -0.05404842f, -0.00124526f, 0.03972759f, 0.05919349f, 0.05725959f, 0.05383182f, 
    0.06982542f, 0.11063911f, 0.02271889f, 0.08665301f, 0.01490466f, -0.12491822f, -0.15236753f, -0.03343594f, 
    -0.01485788f, 0.01237880f, 0.00140136f, 0.05244044f, 0.10333412f, -0.05258623f, 0.05708705f, -0.00493988f, 
    0.07201578f, -0.04615682f, 0.10048676f, -0.03240586f, 0.03816985f, 0.05191189f, -0.01801178f, 0.03504115f, 
    -0.17375754f, -0.06224892f, 0.09655880f, -0.04549739f, -0.35171354f, 0.00271028f, 0.02113773f, 0.16307254f, 
    0.13336039f, 0.03429360f, 0.17996080f, 0.10738142f, -0.01815142f, 0.09592990f, 0.03617270f, 0.08404914f, 
    0.14539324f, -0.14115754f, 0.11567762f, 0.10277321f, 0.01987193f, -0.07393395f, 0.01887295f, -0.01062968f, 
    -0.06806609f, 0.00134668f, -0.13750069f, 0.03001719f, 0.04140997f, -0.09596083f, -0.01508697f, 0.12701988f, 
    -0.04370273f, -0.03727001f, 0.02807707f, 0.08396702f, 0.14405613f, 0.05622697f, 0.13235898f, 0.02425779f, 
    -0.08688549f, -0.03599127f, 0.02999668f, 0.09604067f, 0.02259285f, 0.01996452f, -0.04427126f, -0.01239566f, 
    0.03952534f, -0.01912436f, 0.09921087f, 0.00555813f, -0.04603785f, -0.10312495f, -0.08852931f, -0.05609166f, 
    -0.09027413f, 0.02216546f, -0.12463047f, -0.00540108f, 0.04815155f, 0.02074605f, -0.09089734f, -0.10774378f, 
    -0.08737662f, -0.09848081f, -0.03487840f, -0.12316998f, 0.02467590f, -0.02375020f, 0.01441477f, -0.06538494f, 
    0.00502122f, 0.04732202f, 0.04185350f, 0.03351027f, 0.14535415f, -0.12918171f, 0.08027950f, -0.04568976f, 
    -0.06448002f, 0.04092746f, -0.04421914f, 0.07461785f, 0.04128585f, 0.04147975f, 0.05391556f, -0.00314895f, 
    0.16339782f, 0.04835700f, -0.14649940f, 0.01108314f, -0.06748038f, -0.06440610f, 0.03485405f, -0.00921723f, 
    -0.00777008f, 0.01585553f, -0.02986746f, 0.04577534f, -0.10396090f, -0.02281932f, -0.20698288f, 0.00816835f, 
    -0.09269050f, 0.08347349f, -0.04909364f, -0.18421519f, -0.01488912f, -0.13798064f, 0.02664945f, -0.04985771f, 
    0.00613230f, -0.05931690f, 0.20568556f, 0.06169136f, 0.07880103f, 0.03242685f, 0.02541850f, -0.12157557f, 
    0.04857108f, 0.00051601f, 0.14090599f, 0.10589544f, 0.09628761f, -0.02117123f, 0.02965445f, 0.05658406f, 
    0.13936517f, 0.03941538f, -0.00667406f, -0.01356993f, -0.01032528f, 0.05960379f, 0.00551218f, -0.11411294f, 
    0.06690244f, -0.03670223f, -0.22366662f, 0.12947537f, 0.09343395f, -0.16405185f, -0.15924163f, -0.14862235f, 
    0.01572289f, 0.04324260f, -0.10156751f, 0.02019494f, 0.26095510f, 0.02376283f, -0.06659847f, -0.21161225f, 
    0.10051978f, -0.00814206f, 0.02734953f, -0.05754928f, -0.06392538f, -0.03908729f, -0.02300990f, -0.07617369f, 
    -0.17715284f, -0.00283622f, 0.12486900f, 0.25976536f, 0.07270107f, -0.05686511f, 0.05766232f, 0.08900597f, 
    -0.03490239f, -0.03454972f, 0.17794271f, 0.10028818f, -0.11058968f, -0.09877322f, -0.04784092f, -0.05474991f, 
    -0.00237207f, 0.03028953f, 0.12434312f, 0.11450642f, -0.08702113f, 0.01133706f, -0.12788251f, -0.07231321f, 
    0.05413090f, 0.03640872f, 0.05530796f, -0.16010116f, 0.05268707f, 0.00211489f, 0.03088915f, -0.05739666f, 
    -0.03205335f, 0.04108249f, -0.09485015f, -0.00048793f, 0.02176015f, 0.03373741f, -0.14976598f, 0.08410713f, 
    0.00819991f, 0.03451207f, -0.00672654f, 0.02732271f, -0.07907844f, -0.05773117f, 0.18350485f, -0.12252926f, 
    0.09736083f, -0.04482276f, 0.01440115f, -0.17504115f, 0.00361885f, 0.14485162f, 0.08045900f, 0.06653517f, 
    -0.03308567f, 0.05223043f, 0.06114331f, 0.04838739f, 0.06404220f, 0.16762112f, -0.06630173f, 0.03770489f, 
    0.02254521f, -0.01338066f, -0.01743660f, 0.03365768f, 0.16969161f, 0.06735373f, 0.04546408f, -0.03293150f, 
    -0.00944871f, -0.27770883f, 0.06073410f, 0.08441159f, -0.10532127f, 0.03874157f, -0.00535595f, -0.01768334f, 
    0.00625839f, -0.04493562f, -0.09254225f, -0.08834568f, -0.11647700f, -0.04014428f, 0.02871750f, -0.09998152f, 
    -0.05085900f, 0.13644809f, 0.07774719f, 0.09437549f, -0.04128247f, 0.14625229f, -0.01772050f, -0.21519487f, 
    -0.15741251f, -0.15050517f, 0.02895086f, -0.07771485f, 0.01201893f, -0.09819128f, 0.04216419f, -0.05712947f, 
    0.18411636f, -0.02224303f, 0.08356719f, -0.00093257f, 0.40001190f, 0.21462482f, -0.08107223f, -0.02727467f, 
    0.00896071f, 0.07340297f, 0.03353649f, 0.14235790f, -0.08426717f, 0.14053100f, -0.00707120f, -0.01103763f, 
    0.10118360f, 0.16538061f, -0.09280878f, 0.06634106f, -0.06044158f, -0.04022176f, 0.00291543f, 0.03415539f, 
    -0.16353305f, -0.03805651f, -0.04401820f, 0.06726408f, -0.08570977f, 0.20970379f, -0.00625799f, -0.10403841f, 
    0.05818890f, 0.08947064f, 0.05817749f, 0.00532151f, -0.03218060f, 0.00082795f, -0.14151333f, -0.08389898f, 
    -0.27309623f, -0.01334459f, -0.11332394f, -0.05006957f, -0.04573719f, -0.02753523f, 0.02080207f, -0.05944209f, 
    -0.08300994f, -0.10994051f, 0.02366580f, -0.16312277f, 0.13571192f, -0.05101403f, -0.09103598f, 0.03077932f, 
    0.02368373f, 0.00581658f, 0.08306114f, -0.00283465f, -0.06239420f, 0.01763394f, -0.08407955f, 0.00216192f, 
    0.04496874f, -0.01564395f, 0.07417680f, -0.02914067f, -0.06227282f, -0.04368713f, 0.06617498f, 0.09661866f, 
    -0.16277876f, 0.14845276f, 0.24746683f, 0.09492253f, 0.33216515f, -0.12252364f, 0.08699322f, 0.03731627f, 
    -0.09323195f, -0.03216908f, -0.02284396f, -0.03980745f, 0.00109322f, -0.01122554f, -0.15646404f, -0.03915794f, 
    0.15038420f, -0.02546922f, 0.09373799f, -0.01234861f, -0.07414436f, -0.00404962f, 0.01644594f, -0.03560420f, 
    -0.02028366f, 0.01908872f, 0.02824447f, -0.05524426f, -0.13911761f, 0.19104970f, -0.00947410f, 0.20875117f, 
    -0.00554100f, 0.00537121f, 0.15555219f, -0.11128688f, 0.00030068f, 0.07877295f, -0.10924949f, -0.06333890f, 
    0.09911826f, 0.18535578f, -0.10238303f, -0.05792161f, 0.13176689f, -0.03107159f, -0.07158706f, -0.02520944f, 
    0.11284738f, -0.09160012f, 0.00420499f, 0.04729727f, -0.02109796f, 0.11870544f, 0.14671201f, 0.05690198f, 
    -0.11251043f, -0.01071204f, 0.01095068f, -0.08659014f, -0.05855401f, 0.08609054f, -0.05867068f, 0.04598613f, 
    -0.19291429f, 0.00922342f, -0.05534834f, 0.03724797f, 0.01355283f, 0.08400732f, 0.02046604f, -0.03876345f, 
    0.05093764f, 0.01767774f, 0.09883240f, 0.04243235f, 0.04539832f, -0.03213017f, -0.00448262f, 0.04127381f, 
    0.01553023f, 0.06919130f, -0.00792625f, -0.08983742f, -0.13644835f, 0.14169717f, -0.00348320f, -0.02153906f, 
    -0.06725170f, 0.06266502f, 0.08112004f, -0.07018587f, 0.11521617f, 0.06350242f, 0.01256035f, -0.04667431f, 
    0.06166236f, 0.07219444f, -0.07624444f, -0.02317864f, -0.15275523f, 0.04870182f, 0.10365463f, 0.36439422f, 
    0.05410421f, 0.03374042f, 0.11664376f, 0.00512887f, -0.02755895f, 0.04259770f, 0.07909725f, 0.07899508f, 
    0.17896602f, 0.13878416f, -0.05858731f, -0.01334282f, 0.03714065f, -0.14958431f, 0.05160749f, -0.03876797f, 
    -0.05582547f, -0.05665166f, -0.10371485f, -0.05342982f, 0.09458222f, 0.00740336f, 0.00637026f, -0.12575565f, 
    -0.08698443f, 0.03529255f, 0.08090623f, -0.01306047f, -0.03615728f, 0.00637446f, 0.01318802f, 0.01214480f, 
    0.14347535f, 0.23318605f, 0.37218490f, 0.02402385f, 0.00539302f, 0.06811523f, -0.12473407f, -0.00901539f, 
    -0.00560789f, 0.05095422f, 0.08903911f, 0.00732047f, -0.10665327f, 0.05838380f, 0.15769053f, 0.28658152f, 
    -0.01311036f, -0.10681985f, 0.14161652f, 0.10680094f, -0.09576894f, 0.13882937f, 0.03195864f, -0.00188848f, 
    -0.13074432f, -0.01703566f, -0.11632669f, -0.04890691f, 0.01078425f, -0.02676328f, -0.01064235f, 0.05918647f, 
    -0.02732308f, 0.07317112f, -0.05542913f, -0.04425234f, -0.00338933f, 0.36694762f, -0.25114292f, -0.16399832f, 
    0.03179473f, -0.05197180f, 0.01228999f, -0.00896395f, -0.00335807f, 0.10597073f, -0.10044830f, 0.07898346f, 
    -0.00228785f, -0.01931500f, -0.03884845f, -0.00517246f, -0.00004377f, -0.05161997f, 0.03935630f, -0.01792093f, 
    -0.00334429f, -0.04132296f, -0.03263812f, 0.04411178f, 0.01546005f, -0.00736738f, 0.01561925f, -0.01311367f, 
    -0.02231225f, 0.03177800f, -0.04431774f, -0.01333578f, -0.03222248f, -0.00006909f, -0.04138663f, -0.03360853f, 
    -0.04734699f, 0.02005101f, -0.03252065f, -0.02406314f, -0.03409587f, -0.02664247f, -0.01950266f, -0.05631426f, 
    0.02374111f, 0.00002041f, -0.00993523f, 0.03508063f, 0.02712659f, -0.02825391f, 0.00152652f, -0.03567285f, 
    0.02868556f, 0.00295021f, -0.04002263f, -0.03075364f, 0.01767335f, 0.04167782f, -0.03626298f, -0.03307073f, 
    -0.00375486f, 0.01740511f, -0.01350355f, -0.03503960f, -0.00947670f, -0.01523819f, 0.00959429f, 0.00361836f, 
    0.02238318f, 0.00058764f, -0.02708935f, 0.03824984f, -0.01420672f, -0.04222447f, 0.03494135f, 0.01512295f, 
    0.02267019f, 0.02224795f, 0.03847092f, 0.03346684f, 0.01608079f, -0.05611751f, -0.03500020f, 0.01271506f, 
    0.02734409f, -0.00504907f, -0.01101999f, 0.03549065f, 0.00057852f, -0.04100403f, 0.03793697f, -0.05042076f, 
    -0.05256213f, -0.01066413f, -0.01460534f, -0.01932854f, 0.02377220f, 0.05130641f, -0.03933937f, 0.04087316f, 
    -0.04876361f, 0.03369600f, -0.01418615f, 0.01220467f, -0.00989419f, 0.04511987f, 0.03625036f, -0.03925294f, 
    0.01214592f, -0.02524300f, -0.00601809f, -0.04467792f, 0.01590934f, 0.00703485f, 0.00457234f, -0.02486379f, 
    -0.00613066f, 0.01703247f, 0.04486000f, 0.01249014f, 0.01533259f, -0.05184409f, -0.02129370f, 0.04500693f, 
    -0.01750178f, -0.04624104f, -0.00513138f, 0.00168454f, -0.00532285f, -0.00454968f, -0.01939675f, -0.02904022f, 
    -0.02421061f, -0.00203980f, 0.03061158f, -0.04953488f, 0.03748143f, 0.01264394f, 0.03182090f, 0.00560173f, 
    -0.00814315f, 0.02539518f, 0.00579350f, -0.04602084f, -0.02088391f, -0.03952925f, 0.02102188f, 0.00442559f, 
    -0.03199856f, 0.01347670f, 0.03536289f, -0.05305042f, -0.01710173f, 0.01617784f, 0.04220256f, -0.04540557f, 
    -0.02006599f, -0.03055342f, -0.01961076f, -0.03946857f, 0.01345706f, 0.04585072f, 0.00269654f, -0.03194877f, 
    -0.03967491f, -0.02742554f, -0.02924394f, -0.02455617f, -0.01425872f, 0.01381817f, 0.04220721f, -0.05003252f, 
    0.01617472f, -0.05001553f, 0.00663818f, -0.04899238f, -0.03615862f, -0.01234418f, -0.01444661f, -0.03998857f, 
    -0.02347293f, -0.03282594f, -0.00442264f, -0.02162980f, -0.01159416f, 0.03453161f, -0.02804944f, 0.01315797f, 
    -0.01733140f, 0.01918495f, 0.01090186f, 0.01356210f, 0.00614170f, 0.01251090f, 0.04910526f, -0.04151892f, 
    -0.00612289f, 0.04672944f, 0.03773498f, 0.04482594f, 0.03154621f, 0.04419881f, 0.01835397f, -0.02419669f, 
    -0.02912963f, 0.02322534f, 0.02408064f, 0.04801454f, -0.00138774f, -0.01637697f, -0.01292965f, -0.01581081f, 
    -0.00914349f, 0.04246444f, 0.02534667f, -0.01038460f, -0.02853523f, 0.01200483f, 0.00895257f, 0.00306932f, 
    0.04299390f, 0.01258725f, -0.01231753f, 0.01612025f, -0.02513332f, -0.00839335f, -0.05041217f, -0.02339623f, 
    -0.00922906f, -0.04008881f, 0.04542110f, -0.01455001f, -0.00561444f, 0.01223882f, -0.00471495f, -0.05855801f, 
    -0.00296115f, -0.01544234f, -0.02459381f, -0.03467114f, -0.01140020f, -0.04532154f, 0.04041346f, -0.02892135f, 
    -0.00990056f, 0.02858839f, -0.03131138f, 0.01349872f, -0.05176066f, 0.02784338f, 0.01253456f, -0.00485301f, 
    0.00633399f, 0.03503720f, -0.04639317f, 0.02981267f, 0.02246082f, -0.03967033f, -0.00641848f, -0.04537266f, 
    0.00930694f, 0.02150166f, -0.03384525f, 0.00192205f, 0.02239928f, 0.03139991f, -0.04606401f, 0.02024295f, 
    -0.01185883f, 0.03782056f, -0.00119400f, -0.04660527f, 0.03772957f, -0.05045370f, -0.01652125f, 0.02205252f, 
    0.00074097f, -0.05167747f, 0.03977441f, -0.01394560f, 0.03935891f, -0.00815784f, -0.03144159f, -0.04759521f, 
    0.00751709f, 0.01511358f, -0.01376007f, 0.03848593f, 0.02786615f, -0.02503333f, -0.03098750f, -0.04327324f, 
    0.00018283f, 0.03325139f, -0.00588151f, 0.00547071f, -0.05015491f, 0.01957667f, 0.01350453f, -0.04966477f, 
    0.04793158f, -0.02132186f, -0.00770237f, 0.03074614f, -0.00666050f, 0.04385250f, 0.01989246f, -0.02290037f, 
    0.00447290f, -0.02115211f, 0.01317169f, -0.01801213f, -0.04001715f, 0.01742242f, 0.02860542f, -0.00631689f, 
    -0.03357508f, 0.03514908f, -0.00433356f, 0.02572744f, 0.02878992f, 0.00967728f, -0.01382359f, 0.01546363f, 
    -0.03088939f, -0.05314320f, 0.00240510f, -0.03073041f, -0.00931978f, -0.01391770f, 0.03619262f, -0.04305054f, 
    0.03012187f, 0.01856242f, -0.03311760f, -0.04959401f, 0.04768974f, -0.00503300f, -0.01545209f, -0.05839352f, 
    -0.02327979f, -0.00441589f, -0.01431446f, -0.03341680f, -0.01193790f, -0.02780770f, -0.01728065f, -0.03704171f, 
    0.01847220f, 0.02696688f, -0.04244195f, 0.02702536f, -0.03201475f, 0.00139218f, -0.03024868f, -0.03745983f, 
    -0.00597160f, 0.02403273f, -0.02675052f, -0.00027802f, 0.00454980f, 0.02707375f, 0.03465048f, -0.02505432f, 
    -0.02537661f, -0.05759764f, 0.04241562f, -0.00669998f, 0.02537881f, 0.01573027f, -0.00267789f, 0.00413950f, 
    0.03147107f, 0.00419974f, 0.02956354f, -0.00812762f, 0.01214047f, -0.01581264f, -0.00736048f, 0.03425479f, 
    0.01593937f, 0.04229502f, 0.00644351f, 0.00735171f, -0.02260398f, 0.00129568f, 0.02858457f, 0.00959827f, 
    -0.04932768f, -0.04718921f, 0.02526521f, 0.04190167f, -0.03427674f, 0.04346411f, -0.04719766f, -0.02547959f, 
    0.01563764f, -0.02828620f, 0.00688760f, -0.04846116f, -0.04814102f, -0.01267435f, -0.01015251f, 0.00899457f, 
    -0.03492422f, -0.03546660f, 0.01824925f, 0.00547022f, 0.03682140f, -0.03713887f, -0.00062026f, 0.04061628f, 
    -0.04421631f, -0.04874727f, 0.03016028f, 0.02095602f, -0.04852720f, -0.03499451f, 0.03972027f, 0.01989353f, 
    -0.02911690f, 0.00363548f, -0.05819584f, 0.04035519f, -0.02317095f, -0.05837112f, -0.04514787f, 0.00015186f, 
    -0.01738268f, -0.03722756f, -0.04962955f, 0.01570423f, 0.02885632f, -0.03987116f, -0.05814828f, -0.05655657f, 
    -0.03826812f, -0.00040712f, 0.02625206f, 0.03938579f, 0.03778929f, 0.00879018f, 0.00731774f, -0.05124014f, 
    0.01670559f, 0.02523846f, 0.03008462f, -0.04908902f, 0.01827238f, -0.01873332f, -0.04283225f, -0.04783022f, 
    -0.03173288f, -0.01098146f, -0.02768686f, -0.05329641f, -0.01904029f, -0.01490730f, 0.03988808f, -0.02068289f, 
    0.03517269f, -0.02517203f, 0.00905791f, -0.00915416f, -0.00971480f, -0.00278682f, 0.02910858f, 0.00563171f, 
    0.01473516f, -0.05163993f, 0.00708276f, 0.02563003f, -0.03786489f, 0.03619925f, 0.00760399f, 0.01518781f, 
    -0.02826706f, -0.03181937f, -0.01232261f, 0.02902532f, -0.01594488f, 0.02222610f, -0.00451969f, -0.00924049f, 
    -0.04247567f, -0.03359833f, -0.03646113f, -0.00756462f, -0.02115486f, -0.02406070f, 0.02279415f, 0.00165864f, 
    -0.01199041f, -0.04853964f, 0.03072308f, -0.04701715f, 0.02616562f, -0.00049719f, -0.02168782f, 0.01333480f, 
    0.03272691f, 0.03692569f, -0.00388034f, -0.04782150f, 0.02247017f, -0.01876300f, 0.01969093f, 0.00283489f, 
    -0.04680483f, -0.04178267f, 0.03624231f, 0.02590305f, -0.01307926f, -0.01072423f, -0.02332358f, -0.00762988f, 
    0.03838525f, 0.01301211f, -0.00873263f, -0.00342241f, -0.02934672f, -0.03800580f, 0.02480550f, -0.03810287f, 
    -0.00753480f, 0.03051544f, -0.03766869f, -0.03741866f, 0.00636608f, -0.04567016f, -0.05183116f, 0.00423986f, 
    -0.03134282f, -0.05298904f, -0.03271335f, -0.03580720f, 0.04264782f, -0.05120748f, 0.00141424f, -0.02656055f, 
    -0.03555980f, -0.03146531f, 0.01959954f, -0.00623373f, 0.03435796f, -0.01386563f, -0.05391707f, 0.02917355f, 
    -0.05329248f, 0.02968314f, -0.01882987f, -0.05532948f, -0.05602135f, -0.02278155f, 0.03300182f, -0.00906452f, 
    -0.05143930f, -0.05329755f, -0.02346634f, 0.02066184f, -0.04228820f, -0.00914015f, -0.01870208f, -0.02127985f, 
    0.02186035f, -0.00231338f, 0.02074039f, 0.00754292f, -0.04897327f, -0.04454726f, -0.01806688f, -0.03785869f, 
    0.00437425f, 0.03186911f, -0.04049786f, -0.04415670f, 0.03424085f, -0.01481113f, -0.04543119f, 0.00085450f, 
    0.01446955f, 0.02882037f, 0.00645441f, -0.04387299f, -0.02681165f, -0.05414542f, -0.01585225f, -0.00183642f, 
    -0.03034403f, -0.02876119f, -0.05090423f, -0.05623207f, -0.03645790f, -0.02244552f, 0.03979569f, 0.00060850f, 
    -0.01026748f, 0.01284265f, 0.01050328f, -0.01348854f, -0.03478214f, -0.00756130f, -0.00685097f, -0.00727502f, 
    -0.03412767f, -0.00371430f, 0.02139661f, -0.05580999f, 0.01213269f, 0.00259051f, 0.00233675f, 0.02041598f, 
    -0.02951044f, -0.02214316f, 0.04010614f, -0.03874266f, -0.04353290f, 0.03383725f, -0.05356882f, -0.04005456f, 
    0.01807783f, -0.03196318f, -0.01956260f, -0.02528940f, 0.01846148f, 0.03602152f, 0.00345265f, -0.05008749f, 
    0.02203736f, -0.03992279f, -0.03153212f, 0.01713168f, -0.04878404f, 0.00662536f, -0.03541490f, 0.01805781f, 
    -0.02997106f, -0.04588778f, 0.03134338f, 0.00889619f, -0.02642042f, -0.04899708f, -0.04093729f, -0.01309972f, 
    -0.04340042f, 0.03886007f, 0.03997223f, 0.03793802f, 0.03447140f, 0.03383845f, 0.00170430f, -0.01589465f, 
    0.01564527f, 0.04658074f, -0.01050945f, 0.04200393f, -0.03855644f, -0.00393367f, 0.03287145f, -0.02129186f, 
    -0.00508926f, -0.05597164f, -0.02100907f, -0.01479074f, 0.03483469f, -0.01530579f, -0.04274789f, 0.01386724f, 
    -0.02510041f, 0.01501519f, 0.01716106f, -0.00562241f, -0.03410034f, -0.02449260f, 0.04860855f, -0.01646180f, 
    0.03818172f, -0.03736637f, -0.01392310f, -0.01545719f, 0.01741266f, -0.04655182f, -0.01969505f, 0.04202028f, 
    -0.04662160f, -0.05782437f, 0.03238446f, -0.05613428f, -0.04381373f, -0.01555858f, -0.05822890f, 0.02448672f, 
    -0.01147078f, 0.04103681f, -0.01872784f, -0.02433419f, -0.02364187f, 0.01728686f, -0.03353277f, 0.03599097f, 
    0.01305736f, 0.01563793f, -0.02580984f, -0.05024130f, -0.02916639f, 0.01733176f, -0.04159621f, 0.00558108f, 
    0.02815105f, -0.00333636f, -0.03978266f, 0.02265843f, 0.02080165f, -0.03547214f, -0.05460429f, -0.03097284f, 
    0.02375847f, 0.01910767f, -0.00428686f, 0.02830607f, 0.04163511f, -0.01138317f, -0.04634831f, 0.02379037f, 
    -0.04337580f, 0.02533555f, 0.03723525f, -0.03744111f, 0.02561231f, -0.01687609f, 0.01514716f, -0.03491429f, 
    0.02215831f, 0.01769559f, -0.01016817f, 0.02664017f, -0.01875675f, -0.01312164f, -0.01698400f, 0.00490956f, 
    -0.05192934f, -0.00203623f, 0.03921446f, -0.00829992f, 0.00129703f, 0.02497348f, -0.04867621f, 0.03054222f, 
    -0.03648353f, -0.03706950f, -0.04466183f, 0.00176663f, 0.02509203f, 0.02292979f, 0.01276983f, 0.02751861f, 
    -0.05850471f, -0.00395962f, 0.00230983f, 0.01128245f, -0.03075128f, -0.01234032f, -0.03692998f, 0.00148050f, 
    -0.04026175f, 0.00343165f, -0.03090240f, -0.04258481f, -0.02004835f, -0.03840716f, -0.05064141f, -0.05525495f, 
    0.03296809f, -0.05183576f, -0.03668186f, -0.05569730f, -0.00952560f, -0.02915523f, 0.00364558f, -0.03864951f, 
    -0.04012629f, 0.00654987f, -0.00721772f, -0.00985623f, -0.05619473f, 0.01252055f, 0.01693373f, -0.00646966f, 
    0.03451645f, 0.00353144f, -0.02557673f, 0.01866057f, -0.00457357f, 0.04120445f, -0.02779429f, 0.03027756f, 
    -0.04696241f, -0.02659732f, -0.04308482f, 0.03864456f, -0.01632648f, -0.01744265f, 0.00408012f, 0.03473115f, 
    0.04027423f, -0.01699355f, -0.00431615f, -0.01254280f, -0.00496916f, 0.01065076f, -0.01406081f, -0.00206610f, 
    -0.00929261f, -0.03020912f, 0.04922670f, 0.02673537f, -0.03852761f, -0.02268553f, 0.00208783f, -0.01761470f, 
    -0.04783461f, 0.00637567f, -0.04119074f, -0.00237996f, -0.03436241f, 0.04307150f, -0.01858377f, -0.00023567f, 
    0.03567445f, -0.00293131f, 0.03096348f, -0.04803491f, 0.02251187f, 0.03391113f, 0.02795156f, -0.02405793f, 
    -0.00915286f, -0.04574421f, 0.00839046f, 0.01316227f, -0.04024372f, 0.00312246f, -0.02083618f, 0.00010193f, 
    0.01652908f, -0.05528894f, 0.02148948f, 0.01714516f, -0.05712477f, -0.04641383f, 0.04278314f, -0.01162317f, 
    0.03160126f, -0.02823647f, -0.04733201f, -0.04516466f, -0.05074397f, 0.03009461f, -0.01377079f, -0.05285396f, 
    0.01884888f, -0.05583505f, 0.02072449f, 0.00862891f, -0.00451943f, -0.01908704f, -0.02487198f, -0.05941884f, 
    0.00005831f, 0.01523441f, -0.03688260f, 0.00895585f, -0.05525864f, -0.00456617f, 0.03686053f, -0.04854221f, 
    0.01306057f, 0.00744836f, -0.02085417f, -0.01470816f, -0.05164390f, 0.02551420f, 0.01904651f, -0.01501484f, 
    -0.04018756f, 0.00040804f, -0.00203644f, -0.01490860f, -0.01444027f, -0.03685784f, 0.02576031f, -0.03207306f, 
    -0.03032093f, -0.04734033f, -0.02022677f, 0.04301016f, 0.03073171f, -0.04482610f, -0.00595962f, -0.04165807f, 
    0.02421862f, 0.02632205f, -0.02697108f, 0.00464443f, -0.02914292f, 0.04178177f, 0.00299226f, 0.00154946f, 
    0.04192788f, -0.02643272f, -0.03189008f, 0.02096864f, 0.01258438f, 0.01004049f, -0.00632904f, -0.05507135f, 
    -0.02513802f, -0.03581284f, -0.04822799f, -0.01171920f, -0.04237365f, -0.05011785f, 0.01954252f, 0.00758338f, 
    -0.03803176f, 0.00413618f, -0.02201543f, -0.00276801f, -0.03513715f, -0.02914099f, -0.03416289f, -0.03341274f, 
    -0.01195551f, 0.03395652f, -0.02118554f, -0.05042716f, -0.01519048f, 0.01697982f, -0.02874888f, 0.00193131f, 
    0.03554392f, -0.01559165f, -0.02283438f, 0.00196642f, 0.03319401f, 0.00880579f, 0.01097069f, 0.01125075f, 
    0.02082493f, -0.04598060f, 0.01548191f, 0.01058531f, -0.03129449f, -0.03757183f, 0.00760513f, -0.03312419f, 
    -0.00217870f, -0.01478531f, 0.02391447f, -0.02198747f, -0.00611461f, 0.01496915f, -0.05538643f, -0.05792686f, 
    -0.01251268f, -0.02389075f, -0.00060623f, -0.05468762f, 0.04509287f, -0.02577840f, 0.03557670f, -0.03725382f, 
    -0.05160220f, 0.01907109f, 0.03448808f, -0.03996620f, 0.01971044f, -0.00882165f, 0.02325763f, -0.02188411f, 
    -0.04725882f, 0.03606576f, -0.02241200f, -0.03060652f, 0.01542325f, 0.03026949f, -0.00242270f, -0.02338909f, 
    0.00195267f, -0.01809351f, 0.04261299f, -0.00695303f, -0.03100285f, -0.05000003f, -0.01683865f, 0.02255649f, 
    0.00004916f, -0.01147493f, 0.00455843f, -0.01906170f, -0.01450603f, -0.04368289f, -0.01407192f, -0.04855287f, 
    0.03749065f, -0.03233429f, 0.04067849f, 0.03109143f, 0.00281552f, -0.02039154f, 0.04430596f, -0.00970365f, 
    -0.05070077f, -0.05044268f, -0.00551795f, 0.02969326f, -0.00398883f, -0.00381783f, -0.02156419f, -0.01546307f, 
    -0.05153271f, -0.04981261f, 0.02619019f, -0.05115474f, 0.02534704f, 0.02885515f, -0.01164244f, -0.03437456f, 
    -0.04178772f, 0.00237072f, 0.01222624f, 0.03930734f, -0.00117163f, 0.00202109f, -0.04122027f, -0.00032621f, 
    -0.03227767f, 0.01931589f, 0.01767775f, -0.04753408f, -0.05389559f, -0.03027350f, 0.03780754f, -0.01327761f, 
    -0.01949132f, 0.02419513f, -0.00310009f, 0.02881917f, -0.00218575f, -0.03527378f, -0.04925935f, 0.03497876f, 
    -0.01696264f, -0.04108559f, 0.01124024f, 0.03150298f, -0.03830260f, 0.03293319f, -0.02601356f, -0.00596286f, 
    -0.04533131f, 0.03875640f, 0.02688651f, -0.00002433f, -0.03492483f, -0.01686119f, -0.03135748f, -0.02021560f, 
    -0.00629421f, 0.02278466f, 0.04025770f, 0.00574598f, -0.00479911f, 0.04353662f, -0.01546653f, -0.03367968f, 
    0.02417371f, 0.02395707f, 0.02539726f, -0.02137184f, 0.02918152f, -0.01015893f, -0.02727756f, -0.04052508f, 
    -0.00808316f, -0.05732643f, -0.03120757f, 0.03591764f, 0.00568337f, 0.02608627f, 0.02924419f, 0.01754225f, 
    0.04048405f, 0.03643996f, 0.01129819f, 0.02596319f, 0.01933458f, 0.01396438f, 0.00007643f, 0.04357292f, 
    0.00131697f, -0.00160428f, 0.00956703f, 0.05005269f, -0.00478765f, -0.05463226f, 0.03508564f, -0.00649757f, 
    0.01346098f, -0.05571599f, 0.04179512f, -0.04136541f, 0.02496064f, -0.01108776f, -0.03512041f, 0.03832757f, 
    -0.00017257f, 0.01033202f, 0.04047111f, 0.04493973f, -0.01733194f, -0.02253637f, -0.04106655f, -0.05321320f, 
    0.00387800f, -0.04683828f, -0.04071314f, -0.04924336f, 0.01888971f, -0.00111253f, 0.03937133f, 0.04464146f, 
    -0.04106237f, 0.00880998f, 0.03196402f, 0.03382619f, -0.02197812f, -0.01517706f, 0.04509661f, 0.04496625f, 
    0.05424623f, 0.01686906f, 0.05034428f, -0.01257830f, 0.03366608f, 0.02267723f, 0.04127193f, 0.03191417f, 
    -0.04707104f, 0.01404332f, 0.00316291f, -0.01414525f, 0.02675124f, 0.03228894f, 0.03954842f, -0.01888530f, 
    0.03892485f, -0.01481468f, 0.01249393f, 0.00666336f, -0.04519238f, 0.00727055f, 0.03040768f, 0.01487067f, 
    -0.01776566f, -0.00503148f, 0.05166153f, -0.00965874f, 0.00264250f, -0.05078914f, 0.02803332f, -0.01350055f, 
    0.02648488f, -0.03310152f, -0.02606019f, 0.01529661f, 0.00008864f, -0.01358707f, -0.05146585f, -0.03094303f, 
    -0.04607107f, -0.04961077f, -0.01691267f, -0.00513128f, 0.00507080f, -0.01804487f, -0.04797920f, -0.03836045f, 
    -0.01379318f, -0.01647810f, -0.00352279f, 0.01705229f, 0.01023428f, -0.02252924f, -0.02663363f, 0.01094532f, 
    -0.01791828f, -0.03573110f, 0.00776734f, -0.01398476f, -0.03457653f, 0.03570150f, -0.02925704f, 0.00406468f, 
    -0.02772438f, 0.00351943f, -0.00936327f, 0.02334814f, 0.02246649f, -0.03475715f, -0.02797950f, 0.01812022f, 
    0.03821852f, 0.02439450f, -0.01839187f, 0.01421565f, 0.03518303f, 0.03402570f, 0.01232853f, 0.01465192f, 
    -0.04417370f, 0.02521473f, 0.01198924f, -0.04445292f, 0.01952464f, 0.03555080f, -0.03495821f, -0.05303285f, 
    0.04220446f, -0.01629270f, 0.00410655f, 0.01315518f, 0.01573110f, -0.04437032f, -0.00776115f, -0.04273576f, 
    -0.03409023f, -0.00581506f, -0.00782476f, 0.02450381f, -0.01140148f, -0.05864488f, -0.03989190f, -0.01866510f, 
    -0.03671598f, 0.02699818f, -0.03099891f, 0.02456608f, -0.03301810f, -0.04183034f, -0.03003707f, -0.05299246f, 
    -0.01238618f, 0.02204937f, -0.04239766f, -0.01874624f, -0.00335078f, -0.04314031f, -0.02356862f, -0.04184680f, 
    0.01188296f, 0.04163783f, 0.01568470f, 0.01593427f, 0.01585056f, 0.02896203f, 0.00077361f, -0.02623828f, 
    -0.04776539f, -0.02434594f, 0.00947890f, -0.01873014f, -0.00893460f, -0.01838694f, 0.04027945f, 0.03206220f, 
    0.03117073f, 0.02655624f, 0.00934124f, -0.04777430f, 0.00821198f, -0.05834277f, -0.02756274f, -0.01425940f, 
    -0.05129728f, -0.05112653f, -0.01091963f, -0.00799081f, -0.01129287f, -0.03219717f, -0.05507730f, -0.05161725f, 
    0.04143291f, 0.01432287f, -0.03140770f, -0.05561878f, 0.02059902f, -0.03195523f, 0.00486248f, -0.00546472f, 
    -0.00652570f, -0.02437700f, 0.04222127f, -0.00166355f, 0.03430352f, 0.02667468f, 0.00633547f, 0.01575117f, 
    -0.01564431f, 0.00632995f, 0.00526221f, -0.01343697f, -0.01533662f, -0.00118632f, -0.00335140f, -0.01947782f, 
    0.01369763f, -0.04490770f, -0.02698460f, 0.01592947f, 0.02526874f, -0.05196910f, 0.00174835f, -0.05406372f, 
    0.00642131f, 0.02727823f, -0.01976435f, -0.04402009f, 0.02534301f, 0.03003247f, 0.02828879f, 0.03400682f, 
    0.00619110f, -0.00744002f, 0.01895046f, 0.01759574f, -0.05565924f, 0.00773248f, 0.03208619f, 0.00465127f, 
    -0.04230415f, -0.01657667f, 0.01038866f, 0.00692016f, -0.05324832f, -0.02432064f, -0.01467496f, 0.02162710f, 
    0.02551339f, 0.01584303f, -0.02902424f, -0.01655804f, 0.02738352f, -0.05937294f, -0.04752593f, -0.03681910f, 
    0.03615728f, -0.05624582f, 0.01784248f, -0.04419364f, 0.04505903f, -0.02398905f, 0.03812420f, 0.03466961f, 
    -0.03171504f, -0.02703744f, 0.01217081f, -0.03453054f, -0.02249197f, -0.02277122f, -0.00340201f, -0.04219570f, 
    -0.03354462f, -0.02615665f, 0.00269169f, -0.01776965f, -0.04241323f, -0.03729742f, 0.01753361f, -0.00893034f, 
    0.03175182f, 0.01593702f, -0.01776535f, -0.02576397f, 0.01896324f, -0.02123366f, -0.02903849f, 0.03197745f, 
    -0.01665263f, -0.05827611f, -0.02156001f, 0.00508316f, 0.03011941f, -0.01418314f, -0.04190508f, 0.01825828f, 
    -0.01698797f, 0.01503853f, 0.04056775f, -0.05570929f, -0.04025865f, 0.01659077f, 0.01966098f, -0.03011622f, 
    0.01383768f, 0.05050856f, 0.00417404f, 0.02343539f, -0.03095104f, 0.04209515f, 0.04251968f, 0.00668093f, 
    0.00204018f, 0.00149621f, -0.04844315f, -0.02621447f, 0.01215831f, 0.04012106f, -0.02133948f, -0.01158518f, 
    -0.00052895f, 0.01495966f, 0.00482911f, -0.03466404f, -0.03280196f, -0.01981249f, 0.01716994f, -0.03459935f, 
    -0.00720661f, 0.02441779f, 0.02881232f, -0.04154117f, -0.03128863f, -0.00321976f, -0.01789341f, -0.03978106f, 
    -0.02585070f, -0.02871992f, 0.00103005f, -0.04796587f, -0.01845421f, 0.00502222f, -0.05096667f, -0.00662977f, 
    0.00623337f, 0.01232493f, -0.02314557f, -0.04055489f, -0.03623079f, 0.00749787f, 0.04062935f, -0.00272481f, 
    0.02613532f, 0.04588639f, 0.01959877f, -0.02944911f, -0.02977620f, 0.02015983f, -0.02936263f, -0.02229179f, 
    -0.00430050f, -0.01111717f, 0.03512751f, -0.04436404f, 0.04199396f, -0.04154080f, -0.04100068f, 0.00490711f, 
    -0.01771489f, 0.00473925f, -0.00518712f, 0.01795022f, -0.01863108f, 0.04710431f, 0.05180876f, -0.05379267f, 
    0.04379318f, -0.03772182f, 0.01403731f, 0.02707317f, 0.04140474f, -0.01176186f, -0.03051339f, -0.00963142f, 
    -0.04387602f, 0.02538430f, 0.03816419f, -0.04788850f, 0.02476582f, 0.02858548f, -0.04858748f, -0.03577529f, 
    0.01832766f, -0.05203887f, -0.04852992f, -0.03449589f, -0.03573628f, -0.02608509f, 0.01738545f, 0.01319965f, 
    0.01075908f, 0.04375782f, -0.01308834f, 0.01529250f, 0.05478185f, 0.00946406f, 0.00459797f, -0.04604334f, 
    -0.01134410f, -0.01203363f, -0.03322705f, 0.03479456f, -0.02145008f, 0.02263178f, 0.00121668f, -0.03312116f, 
    -0.03093378f, -0.04498637f, -0.05657416f, -0.01388095f, 0.00959431f, -0.02925005f, -0.04234765f, -0.00604753f, 
    0.03755236f, -0.05652779f, -0.03419398f, -0.03352985f, -0.00489984f, 0.03659534f, 0.02940697f, 0.03249921f, 
    -0.02410432f, -0.03565836f, -0.02147377f, 0.01465902f, 0.02492933f, -0.00727154f, -0.03703867f, 0.04338443f, 
    -0.04910293f, -0.02520607f, 0.01592324f, 0.03654314f, 0.03014097f, -0.04714844f, 0.03849020f, -0.04667544f, 
    -0.05189458f, 0.04704402f, -0.01936881f, -0.21522216f, 0.02320103f, 0.04948441f, 0.03325687f, -0.09110095f, 
    -0.02341408f, -0.03121809f, 0.06792839f, 0.16917551f, -0.07274690f, -0.15591775f, -0.00033196f, -0.00029297f, 
    0.00551490f, -0.06109657f, -0.06992545f, 0.03033639f, 0.14134778f, 0.05117550f, 0.06498004f, 0.07162659f, 
    -0.05971845f, 0.16382758f, 0.00126574f, -0.03899453f, -0.10176755f, 0.11606593f, 0.04992550f, -0.18800376f, 
    0.03551379f, 0.11826808f, -0.22428913f, 0.00581681f, -0.08338767f, 0.28050238f, 0.10871179f, 0.07920855f, 
    0.05524784f, -0.11350343f, 0.02941576f, 0.05833407f, 0.04083261f, 0.00576490f, 0.02448867f, 0.00237759f, 
    -0.03227768f, 0.01100587f, 0.02081733f, 0.05468072f, -0.02567999f, 0.01471636f, 0.08721687f, 0.07501233f, 
    -0.09881420f, -0.13930234f, 0.15892623f, 0.08273481f, 0.24225524f, -0.03906098f, 0.10643584f, 0.06912785f, 
    0.07816749f, -0.08020973f, -0.09213040f, 0.00242098f, 0.02826880f, 0.03936832f, -0.11418846f, 0.10189719f, 
    -0.16703963f, -0.02021698f, 0.05167441f, 0.17551558f, 0.03540443f, 0.01011600f, 0.00461802f, -0.06970507f, 
    0.00274992f, -0.02171286f, -0.18227495f, -0.06871062f, -0.13716687f, -0.11893674f, -0.02285129f, -0.06586412f, 
    0.13471346f, -0.06701127f, -0.06358884f, -0.01970629f, -0.10781741f, -0.08469760f, 0.00222742f, 0.06903489f, 
    0.06566487f, -0.00726367f, 0.00144184f, -0.14685483f, 0.07963631f, -0.01223656f, -0.03594554f, -0.05848234f, 
    -0.13844246f, -0.09091781f, 0.06191118f, -0.04650685f, 0.01562179f, -0.00990644f, 0.05060859f, 0.10802116f, 
    -0.02097817f, -0.02802388f, 0.04302935f, 0.01140586f, -0.00029204f, -0.03596129f, -0.01517680f, -0.06755163f, 
    -0.08298767f, 0.21984264f, -0.02369603f, -0.07300375f, -0.04722314f, 0.05978679f, 0.10838738f, -0.13407910f, 
    -0.00058297f, 0.04740137f, -0.02286629f, 0.08526090f, 0.34034196f, 0.02220445f, 0.15396190f, 0.00325832f, 
    0.03123061f, 0.01284328f, 0.05197443f, -0.16219582f, 0.09118882f, -0.15492432f, -0.04849508f, -0.03723779f, 
    -0.22723149f, -0.07057961f, -0.02009006f, -0.11134449f, 0.19370584f, 0.05294431f, -0.03633551f, 0.06287786f, 
    0.07840794f, 0.05836757f, 0.10751270f, 0.13291498f, -0.03131579f, 0.13474405f, 0.10003966f, 0.13981672f, 
    0.06581803f, -0.02854704f, -0.00171822f, 0.00886879f, 0.01447161f, 0.12709823f, 0.00422159f, -0.00615905f, 
    -0.04772919f, 0.22637871f, 0.09346686f, -0.24613325f, 0.02998705f, 0.04810853f, -0.00260435f, -0.14074312f, 
    0.06653532f, 0.07023279f, 0.09461541f, -0.00286786f, -0.02376406f, -0.18307778f, -0.03735932f, -0.02077809f, 
    -0.00479634f, 0.02705636f, -0.08784352f, -0.04140048f, -0.01492190f, 0.01930367f, 0.09535646f, 0.08314080f, 
    -0.09179924f, -0.03448431f, -0.05005116f, -0.05796632f, 0.07478115f, 0.09192372f, 0.03492213f, 0.04652634f, 
    0.11579410f, -0.06791158f, -0.07303882f, 0.10517788f, 0.29662228f, -0.14104970f, -0.10681807f, -0.10225276f, 
    0.03913607f, -0.00537047f, -0.03393909f, -0.04779221f, -0.03868405f, 0.00554602f, 0.10060513f, 0.06815567f, 
    0.09245969f, -0.11318894f, -0.04281976f, 0.14103580f, 0.02953131f, 0.05713147f, -0.04277288f, 0.02387946f, 
    0.09204160f, -0.03307702f, -0.05972065f, 0.04320158f, -0.16305999f, 0.09343623f, 0.10020530f, -0.15338844f, 
    -0.00357613f, -0.02667798f, 0.01929112f, 0.07256602f, 0.06021888f, -0.04165002f, 0.05221095f, 0.04617416f, 
    -0.01013781f, -0.13031515f, -0.07803724f, -0.05893371f, -0.03447815f, 0.01743340f, -0.03640716f, 0.07264470f, 
    -0.00433635f, -0.01732930f, 0.08125975f, 0.02790128f, -0.14091046f, -0.12682679f, 0.09523851f, 0.01178087f, 
    -0.00408919f, 0.03904751f, -0.02092662f, 0.02469965f, 0.00257698f, 0.04664975f, 0.01233566f, 0.02945687f, 
    -0.08350763f, -0.01336932f, -0.04218240f, -0.10795863f, -0.00990627f, -0.07248279f, -0.04123797f, -0.04060299f, 
    -0.10347781f, 0.09060938f, -0.04594522f, -0.13461760f, 0.05294334f, 0.09963514f, -0.00340892f, 0.03938782f, 
    0.01189855f, -0.05867162f, 0.04958336f, 0.11144321f, 0.04985102f, -0.06272809f, 0.13763553f, -0.03089728f, 
    -0.18522340f, 0.07463773f, 0.00537218f, 0.00136038f, -0.06308997f, -0.04077166f, -0.05805985f, 0.08342732f, 
    -0.00983270f, 0.08836502f, 0.01429602f, 0.09498350f, 0.24621530f, 0.27602321f, 0.17415880f, 0.03588704f, 
    0.12910406f, 0.11057792f, -0.06342880f, 0.10296677f, -0.02996264f, -0.03252200f, -0.03254372f, -0.09758371f, 
    -0.24223524f, -0.04281081f, 0.03472746f, -0.01147929f, 0.07740743f, 0.05637014f, 0.00740722f, 0.03523148f, 
    0.09192663f, 0.10061174f, -0.02434588f, -0.02753121f, -0.18165970f, 0.20882416f, 0.09606426f, 0.22217070f, 
    0.03635408f, -0.03995979f, -0.05212612f, -0.06499942f, 0.07530043f, 0.03088567f, -0.06744009f, -0.05030972f, 
    -0.12597881f, -0.03779751f, 0.04593423f, -0.06466772f, 0.05919418f, -0.04518106f, 0.11313823f, 0.08632499f, 
    0.07778346f, 0.06423306f, 0.07671189f, 0.01551825f, 0.24037550f, 0.18516217f, 0.08798353f, 0.10267527f, 
    0.12759170f, 0.05362538f, -0.02942648f, -0.07974014f, 0.04112191f, -0.03393383f, 0.06648596f, 0.09161627f, 
    0.20066586f, 0.00652682f, 0.11602755f, 0.13105826f, 0.09315252f, 0.03802983f, -0.05232790f, -0.03799190f, 
    -0.03736945f, -0.05006475f, 0.04270860f, 0.02839283f, -0.19576693f, 0.05435683f, 0.13939452f, 0.02705706f, 
    0.02494067f, 0.02477167f, -0.03617069f, 0.03338911f, 0.01554978f, -0.09038579f, -0.02830050f, -0.10028625f, 
    -0.15338698f, -0.02870391f, 0.15533490f, 0.08926785f, -0.03783986f, -0.08203445f, -0.01265763f, -0.00709425f, 
    -0.09342970f, -0.12102842f, 0.02341590f, -0.13638581f, -0.37806559f, 0.02571243f, 0.04264379f, -0.16342242f, 
    -0.01851352f, -0.01951648f, -0.01846596f, 0.14454956f, 0.00217338f, 0.09164293f, 0.01103441f, -0.15692466f, 
    0.11264656f, -0.08100885f, -0.01551359f, 0.01172359f, -0.04671338f, 0.12498565f, 0.03757522f, -0.01645837f, 
    -0.06703915f, 0.02981641f, -0.10902774f, -0.01963747f, -0.05198099f, 0.09148562f, -0.02418205f, -0.15498781f, 
    0.08112399f, -0.04741666f, -0.00086884f, -0.10576430f, -0.01291946f, 0.12864156f, -0.01694655f, -0.02008248f, 
    0.23888780f, 0.09366830f, 0.10106821f, 0.14226680f, 0.01855364f, 0.01023160f, -0.11816631f, 0.01146129f, 
    0.07613383f, 0.06295107f, -0.00023611f, 0.01318501f, 0.07595608f, -0.07234313f, -0.14050536f, -0.10339873f, 
    -0.00390211f, -0.04777222f, -0.05073467f, -0.05938078f, 0.00439298f, -0.03905938f, -0.05298487f, -0.08927307f, 
    -0.14541462f, 0.14824124f, 0.01901759f, 0.06527053f, -0.12648700f, 0.17853235f, -0.11015425f, 0.07530255f, 
    0.00650224f, -0.13755770f, 0.01326800f, -0.13989246f, 0.24073404f, 0.24977243f, 0.16202110f, 0.19894671f, 
    0.07266644f, -0.05541930f, 0.08757932f, 0.00452598f, -0.09691973f, 0.05557830f, -0.03060474f, -0.03284134f, 
    0.26482791f, -0.02323708f, 0.02459350f, 0.03298588f, -0.02353914f, -0.02279415f, 0.04197124f, -0.04362097f, 
    0.08471330f, -0.01710278f, 0.06999055f, 0.03375087f, 0.15365012f, -0.17198689f, -0.07431389f, -0.08942139f, 
    -0.09271646f, -0.17868495f, -0.05284023f, -0.05466327f, 0.01485358f, -0.11563161f, -0.04609125f, -0.02098508f, 
    0.22160661f, -0.25762835f, -0.11087795f, 0.13479324f, -0.06407385f, -0.03907291f, -0.05765071f, -0.13222311f, 
    -0.02409561f, 0.03341517f, -0.00073924f, -0.02070869f, -0.64841443f, 0.34738573f, 0.05936979f, 0.01077149f, 
    0.16645014f, -0.00568245f, -0.01426506f, 0.01785093f, 0.03898327f, 0.06350367f, 0.00781585f, -0.05673110f, 
    0.25599214f, 0.26157582f, 0.27541304f, 0.17012893f, 0.19833481f, 0.16240695f, 0.09318866f, -0.01808142f, 
    -0.02784465f, -0.06465426f, 0.03116650f, 0.12457472f, -0.07462677f, -0.07693192f, -0.05248241f, 0.00910184f, 
    0.09035548f, -0.10320465f, -0.05626831f, 0.01527060f, 0.06316744f, -0.08995929f, -0.02888675f, -0.05148499f, 
    0.08200324f, -0.00759689f, -0.10955168f, 0.19194348f, -0.04823177f, -0.14118285f, -0.02004928f, -0.03533532f, 
    0.02725780f, -0.03563657f, -0.02917860f, 0.04555045f, 0.14468853f, 0.07269986f, 0.17967877f, 0.16387430f, 
    0.00996832f, -0.02120837f, -0.06482551f, 0.00430241f, -0.02919285f, -0.00668369f, 0.01302635f, 0.03899363f, 
    0.09361324f, 0.13700978f, 0.12052508f, 0.16420422f, -0.05886571f, 0.05455978f, 0.07288016f, 0.10761393f, 
    -0.17701021f, 0.07141390f, -0.09541638f, -0.00034341f, 0.01513433f, 0.05935302f, 0.08327798f, -0.06542637f, 
    -0.08084079f, 0.01661082f, -0.01740924f, 0.06498015f, -0.02611753f, 0.01691144f, -0.03295548f, -0.05558467f, 
    -0.15609944f, -0.09756664f, -0.10538005f, 0.03290850f, -0.16386169f, -0.03312413f, -0.07775141f, 0.03626138f, 
    0.04109158f, -0.06858284f, 0.00788402f, -0.00575686f, 0.24385187f, 0.00262107f, -0.06812100f, -0.05328502f, 
    -0.06693096f, -0.00973711f, -0.07830863f, 0.04957504f, -0.07841698f, 0.05526802f, -0.08685097f, 0.01022461f, 
    0.36222890f, 0.11443323f, 0.13867001f, 0.16702902f, 0.14880870f, 0.04185946f, -0.10253386f, 0.00626726f, 
    -0.08946322f, -0.00261151f, -0.02934071f, 0.02513533f, 0.31577855f, 0.06117120f, -0.02133172f, 0.13949886f, 
    -0.01503128f, -0.11786766f, -0.10279413f, 0.04136414f, -0.05294443f, 0.02861252f, -0.02044949f, 0.02332772f, 
    0.32099274f, 0.16070357f, 0.03455774f, 0.04574579f, -0.04452186f, -0.01990041f, -0.05054244f, -0.12363675f, 
    -0.01794186f, -0.05527248f, -0.02729137f, -0.10908820f, -0.10415936f, -0.18500668f, -0.13520272f, 0.00348454f, 
    -0.00989230f, -0.08373346f, -0.01825985f, -0.05299992f, 0.01950207f, -0.13780969f, -0.08047710f, -0.00823701f, 
    0.12141243f, -0.11789220f, -0.03157547f, 0.18008357f, -0.04208814f, -0.04700447f, -0.03813682f, -0.02700044f, 
    0.03597451f, 0.03772699f, 0.00948158f, -0.04214085f, 0.31815633f, 0.23214212f, 0.03813643f, 0.29502839f, 
    0.19186646f, 0.18027587f, 0.05385752f, 0.01491314f, 0.15931068f, 0.02639798f, 0.03724306f, -0.14900665f, 
    0.08397371f, 0.11380765f, 0.09614321f, 0.10375744f, 0.07522875f, 0.05155571f, 0.04568305f, 0.15379539f, 
    -0.02422910f, 0.01735874f, 0.18548024f, 0.06907499f, -0.02636068f, 0.01780419f, 0.07788470f, -0.02727968f, 
    -0.14900894f, -0.03580652f, -0.09170762f, -0.04940891f, 0.09228525f, 0.04893136f, -0.02051408f, 0.01921559f, 
    0.13261086f, 0.24088188f, 0.01890969f, 0.23637830f, 0.17417108f, -0.00417822f, 0.08053484f, 0.07817796f, 
    0.07361046f, 0.03421779f, -0.05879654f, 0.05055811f, -0.08005314f, 0.13632269f, -0.05076177f, 0.02180654f, 
    0.12593696f, 0.01007629f, 0.07969350f, 0.04604020f, -0.10489200f, -0.01659309f, 0.05429841f, -0.06401943f, 
    -0.16356187f, -0.08293146f, -0.00167173f, 0.01229635f, 0.04874091f, -0.13390929f, -0.06076887f, 0.04737172f, 
    0.01886394f, -0.11233578f, 0.00511567f, -0.01884501f, -0.20260546f, 0.10808370f, 0.13138983f, 0.12774138f, 
    0.07927270f, 0.05130026f, 0.02916495f, -0.03364902f, -0.17555642f, 0.11965392f, 0.03579788f, -0.03326013f, 
    0.00545797f, 0.04271094f, -0.00183269f, -0.04032755f, -0.00744989f, 0.01639266f, 0.02542842f, -0.05369365f, 
    0.00021988f, 0.01180099f, -0.01824953f, 0.04210221f, 0.01487879f, -0.04117527f, -0.02776547f, -0.02634800f, 
    0.00576447f, -0.00323431f, 0.00640148f, 0.01982412f, 0.04227385f, 0.03746715f, 0.02701036f, -0.01329660f, 
    -0.03424641f, -0.03139687f, 0.04663886f, 0.01639098f, 0.03031552f, 0.02547280f, 0.03920885f, -0.04452053f, 
    0.02606227f, -0.01998729f, -0.02676577f, -0.01786946f, -0.01564194f, -0.01339329f, -0.05323129f, -0.03340058f, 
    0.04385381f, 0.00243868f, 0.03458558f, -0.05327995f, -0.03784361f, 0.02881684f, -0.05263270f, 0.00556253f, 
    0.03805917f, -0.01397090f, 0.00131560f, -0.03237912f, -0.00249108f, -0.01594599f, -0.05094209f, -0.02773927f, 
    -0.03233550f, -0.01572992f, 0.03151550f, -0.01470254f, -0.01114688f, 0.03925957f, 0.02667767f, 0.02914053f, 
    -0.05767591f, 0.00059115f, -0.04180542f, 0.03640919f, -0.05248218f, -0.03823565f, -0.04901720f, 0.03315553f, 
    0.04817957f, -0.03111383f, -0.02880852f, 0.03292064f, -0.02849469f, -0.04715173f, 0.00613713f, -0.00047311f, 
    -0.05849099f, -0.00049660f, 0.02867915f, 0.02867903f, -0.00615743f, -0.04759964f, 0.02628328f, -0.04837760f, 
    0.04460254f, -0.04179663f, -0.06079835f, 0.01975434f, -0.01518273f, 0.03602879f, 0.02188927f, -0.04373649f, 
    -0.01160540f, -0.02307986f, -0.02434073f, 0.00037384f, -0.01627812f, -0.00029361f, -0.05650154f, -0.01682489f, 
    -0.01164115f, 0.02314648f, -0.00945906f, -0.00020422f, 0.01760216f, 0.00688761f, -0.05791257f, -0.02579574f, 
    0.03680788f, -0.00771480f, 0.04264788f, -0.00959779f, -0.02560385f, -0.04740118f, -0.01557124f, -0.04476333f, 
    -0.01389717f, 0.00625963f, 0.03679715f, -0.00991901f, -0.03599729f, 0.03471689f, 0.00005311f, 0.02179235f, 
    -0.04772334f, 0.03086057f, 0.03815542f, 0.01645502f, -0.03451516f, -0.00144521f, 0.00245746f, -0.04040369f, 
    0.02455650f, 0.01404271f, -0.00277149f, -0.03350693f, -0.04570268f, -0.03623622f, -0.02147966f, 0.04380854f, 
    -0.05355741f, -0.02199942f, 0.00706401f, -0.06191593f, -0.05130945f, 0.01110446f, -0.02469281f, -0.04769009f, 
    0.02146933f, -0.02537603f, 0.04551507f, -0.05418671f, -0.00300362f, -0.04118053f, 0.03806674f, -0.01253596f, 
    0.01851279f, -0.00214960f, -0.00562018f, -0.01581669f, 0.01641280f, -0.00822317f, 0.00166254f, 0.00786445f, 
    -0.01912253f, 0.01882545f, 0.03968094f, 0.03756178f, 0.03592917f, 0.00318801f, -0.02568140f, -0.01660463f, 
    0.01056944f, 0.00505335f, 0.02929739f, -0.01510097f, -0.00679061f, 0.02080789f, -0.04668238f, -0.05867854f, 
    -0.01162563f, 0.00164275f, 0.03310855f, 0.00334347f, -0.01999278f, -0.05027156f, 0.00158992f, 0.00438536f, 
    -0.05224207f, -0.05432058f, 0.02332706f, -0.04152936f, -0.05139336f, -0.04313446f, -0.04829744f, -0.03857467f, 
    -0.02168206f, 0.00750245f, -0.05612273f, -0.01481437f, -0.01000170f, 0.01150944f, -0.04130174f, 0.01987638f, 
    0.04252253f, -0.03732152f, -0.05560730f, 0.00945410f, -0.03691384f, 0.04972192f, 0.02650087f, -0.05040758f, 
    0.01787386f, 0.03989414f, -0.02518533f, 0.03896261f, -0.01695052f, -0.01409343f, -0.00086988f, -0.05206263f, 
    0.03724456f, 0.03114252f, -0.00416294f, 0.00060862f, -0.02806061f, -0.03996179f, -0.02975044f, -0.01337649f, 
    -0.05581557f, 0.00241008f, 0.04324630f, -0.01230242f, 0.01190631f, 0.00726523f, -0.04360729f, -0.02233172f, 
    0.03710341f, 0.04329656f, 0.01116253f, -0.01001959f, -0.02302912f, 0.00878836f, -0.03078295f, 0.01778212f, 
    0.03461862f, -0.03238797f, 0.00825474f, -0.02556463f, -0.02845200f, 0.01549600f, -0.02426897f, -0.05325353f, 
    0.02005554f, 0.02093908f, -0.03999048f, 0.00890459f, 0.03574772f, -0.06274255f, 0.02275010f, 0.02456467f, 
    -0.04216741f, -0.05112727f, -0.00200098f, -0.04049771f, -0.04566820f, -0.02104498f, -0.02813251f, 0.00038495f, 
    0.04278579f, 0.03480734f, 0.00850887f, -0.03799066f, -0.01856322f, 0.02117233f, -0.00524322f, -0.02385584f, 
    -0.03183375f, 0.03488077f, -0.02149229f, 0.02299725f, -0.05069539f, 0.02038313f, -0.00862145f, 0.00952274f, 
    0.01358471f, -0.01552223f, 0.03746874f, -0.02102276f, -0.03694971f, -0.03605174f, -0.01563297f, -0.00546278f, 
    0.04582088f, 0.02282208f, 0.03858455f, 0.00380223f, 0.02023910f, 0.01699206f, -0.00368779f, 0.01880650f, 
    -0.03363521f, -0.01966164f, -0.00103055f, -0.01766620f, 0.00012175f, -0.05739533f, 0.02187934f, -0.01325294f, 
    -0.04379924f, -0.00909192f, -0.01428717f, -0.03736071f, -0.01467635f, -0.03792974f, -0.01183212f, -0.05469332f, 
    0.03771638f, -0.00970606f, 0.00554998f, -0.00984671f, 0.03021044f, -0.01200299f, -0.04325122f, 0.01963555f, 
    0.00105697f, -0.00342060f, -0.01340938f, -0.04347383f, -0.00007344f, -0.02033138f, -0.04389194f, -0.00774344f, 
    -0.03418866f, -0.03206056f, 0.04343190f, -0.02102510f, 0.02540120f, -0.02220282f, 0.04075317f, -0.02882897f, 
    -0.03643353f, -0.00311471f, -0.03749729f, 0.03773556f, 0.02934235f, 0.01756663f, 0.02731450f, 0.00290289f, 
    -0.02965515f, -0.00270100f, 0.02294716f, -0.04400444f, -0.02855818f, -0.04037279f, -0.03626584f, 0.00168022f, 
    -0.03530328f, 0.00370113f, -0.04490608f, 0.03968031f, -0.05492495f, -0.03182527f, 0.01343650f, 0.03472479f, 
    0.00714155f, -0.02866608f, -0.02183244f, -0.04434660f, -0.02049362f, 0.02117664f, 0.00559640f, 0.01102545f, 
    0.02387684f, 0.01311576f, -0.06313480f, -0.05151061f, 0.01486189f, -0.01115462f, -0.00044374f, -0.04294078f, 
    -0.24604131f, 0.00831259f, 0.34973827f, 0.07152337f, 0.09161983f, 0.04904598f, -0.01518940f, 0.00651889f, 
    0.00942399f, -0.07383481f, 0.15771931f, -0.05089518f, -0.46972442f, 0.01145962f, -0.04199910f, -0.03322262f, 
    0.09426389f, -0.00378031f, -0.02601024f, 0.01849369f, 0.07605556f, 0.05183877f, 0.08872045f, -0.02068149f, 
    0.08815543f, -0.18173702f, -0.17070469f, -0.09599231f, 0.00125593f, 0.02699494f, 0.00288944f, 0.11052754f, 
    -0.05246283f, -0.03114673f, -0.13009574f, 0.01899818f, 0.09723457f, 0.16228622f, -0.19129150f, -0.03466093f, 
    0.06792596f, 0.03772578f, -0.02864333f, 0.02493623f, -0.02960432f, 0.07965554f, 0.05028457f, 0.10381012f, 
    0.11763270f, -0.07910370f, -0.07937304f, 0.10340912f, 0.03393972f, 0.01037366f, -0.06122056f, 0.03967442f, 
    0.12381141f, -0.07707227f, 0.14409268f, 0.09858078f, 0.04127192f, -0.02348227f, -0.14486995f, -0.11796799f, 
    0.08289950f, 0.05358235f, 0.00668717f, -0.08152984f, 0.00411661f, -0.01373049f, -0.08449686f, 0.00148162f, 
    -0.13092680f, 0.20435193f, -0.00002901f, 0.07807440f, -0.01055319f, 0.08905516f, 0.01021926f, 0.01033988f, 
    0.01740032f, 0.00057290f, -0.05244023f, -0.14198075f, 0.16924572f, 0.15384422f, -0.03080129f, 0.00222125f, 
    0.01456006f, -0.04772861f, 0.08319107f, -0.01433025f, 0.04443554f, 0.07250166f, 0.00896824f, 0.04600947f, 
    -0.08858486f, -0.03311652f, 0.01412260f, -0.03111942f, 0.00113628f, 0.06818672f, 0.13882697f, -0.05318017f, 
    0.06079967f, 0.01079219f, 0.10950113f, 0.02730295f, 0.15441144f, -0.13061887f, -0.10777733f, -0.09012169f, 
    0.03024153f, -0.06436446f, 0.04786512f, -0.05301616f, 0.07246786f, -0.02054868f, -0.04252305f, 0.19344659f, 
    -0.12956773f, -0.17420696f, 0.13149677f, -0.08303621f, 0.09475623f, -0.06468382f, -0.05890597f, 0.01300358f, 
    0.02970842f, 0.03677701f, -0.02740225f, 0.04033637f, -0.63953650f, 0.35149717f, -0.15005761f, -0.12680295f, 
    0.02900830f, -0.03104764f, -0.04788212f, -0.03873315f, 0.01388393f, -0.00731686f, -0.12994352f, -0.07917542f, 
    0.13740364f, -0.07038506f, 0.06391662f, 0.02949725f, 0.04515846f, 0.06014565f, 0.05234592f, 0.09966426f, 
    0.03841734f, 0.12035183f, 0.09776156f, 0.03824714f, -0.06481934f, -0.10280795f, -0.05122774f, -0.02180973f, 
    0.06852430f, -0.05051776f, -0.07331329f, 0.00876647f, 0.08960274f, -0.01734344f, 0.03541376f, 0.11900359f, 
    0.10124020f, -0.16591890f, 0.12354507f, 0.09649316f, -0.00006478f, -0.05923458f, 0.02155277f, 0.02132553f, 
    -0.03913043f, 0.10696986f, 0.09621965f, 0.09979054f, 0.14390977f, -0.00469205f, 0.11443713f, 0.16282237f, 
    0.13443056f, 0.04198739f, 0.00862718f, 0.01776877f, 0.04727056f, 0.06287402f, 0.04195698f, 0.02837295f, 
    0.00568757f, 0.05240833f, 0.04108657f, 0.02943747f, -0.01254181f, 0.07811180f, 0.07637373f, 0.03162450f, 
    -0.03799917f, 0.02772284f, -0.05914250f, 0.07087287f, -0.06287717f, 0.24586552f, 0.01779873f, -0.04568835f, 
    0.00049484f, 0.06722561f, -0.05810129f, 0.08074439f, 0.06571665f, 0.01488486f, 0.03096223f, -0.00731458f, 
    -0.40197751f, 0.17268692f, 0.04091065f, 0.14054847f, -0.08995523f, 0.06706990f, 0.04283113f, 0.03664619f, 
    0.14336266f, -0.06200571f, -0.03027734f, 0.14046517f, 0.20832439f, -0.25447986f, 0.14298445f, -0.09466281f, 
    -0.03890179f, -0.01614720f, 0.00208805f, 0.12452663f, -0.03318455f, 0.00912715f, -0.01134857f, 0.08600821f, 
    0.19096641f, -0.00850387f, 0.10344435f, 0.14536814f, 0.16797355f, 0.02308573f, -0.09628837f, 0.15073581f, 
    -0.14019132f, 0.01828532f, -0.13620818f, -0.00720402f, 0.04253551f, -0.04967509f, -0.01267222f, 0.25121096f, 
    0.04739186f, -0.02077666f, 0.04953010f, 0.00100776f, 0.11410092f, 0.08320443f, 0.01156205f, 0.02929843f, 
    0.30175254f, -0.05478153f, -0.01767932f, 0.09450564f, -0.04462079f, 0.01925581f, 0.04935504f, -0.12770815f, 
    0.00117482f, -0.04356490f, -0.15647592f, -0.01533296f, 0.10713819f, -0.08879210f, -0.01862690f, 0.07227534f, 
    -0.03136104f, 0.00393516f, 0.07659256f, -0.03432928f, 0.00478448f, -0.10706283f, 0.04582356f, 0.02545996f, 
    -0.12986468f, -0.08039779f, 0.04440743f, 0.05285388f, 0.06853829f, 0.09747837f, -0.03880524f, -0.02475517f, 
    -0.02297496f, 0.02082006f, 0.05869219f, -0.00231221f, 0.06287568f, -0.10178772f, -0.07530531f, 0.15483792f, 
    0.02859820f, 0.02768760f, 0.01513945f, 0.02857339f, 0.11503379f, -0.02256682f, -0.01069912f, -0.17336044f, 
    -0.02323374f, -0.04578444f, -0.05718533f, -0.04329123f, -0.03879749f, -0.01062215f, 0.04237974f, 0.15662341f, 
    0.01004600f, -0.01024198f, 0.16536047f, 0.09750324f, 0.09700451f, 0.03497346f, 0.03655423f, 0.02609930f, 
    0.00642410f, -0.00554221f, -0.02685829f, -0.02441872f, 0.08592249f, 0.04790897f, -0.03957371f, 0.11245070f, 
    -0.01558180f, -0.12402616f, -0.07029273f, 0.04489635f, 0.05221817f, -0.08384470f, -0.01105281f, 0.06529001f, 
    0.04545583f, -0.02122303f, -0.02401049f, 0.07241508f, -0.15891723f, -0.03348379f, -0.03555711f, -0.06065960f, 
    0.01643280f, 0.00741197f, 0.08058972f, -0.01800675f, -0.04577303f, 0.00106651f, 0.09542983f, -0.05212705f, 
    -0.17125721f, -0.08769977f, -0.06575073f, 0.03538130f, 0.10181286f, 0.00632194f, -0.01778677f, 0.07676147f, 
    -0.01431274f, -0.11616151f, 0.00811212f, 0.01738374f, -0.04097158f, 0.14928548f, -0.00373511f, 0.02270468f, 
    0.06776861f, 0.14622791f, -0.01659551f, -0.00688357f, -0.03720789f, 0.03804814f, 0.02240861f, 0.00115558f, 
    0.20413445f, 0.15010545f, 0.07237863f, 0.01557603f, 0.00102463f, 0.01664112f, 0.01465263f, 0.04360222f, 
    -0.02368324f, 0.15232606f, -0.09528142f, 0.08130576f, 0.32378793f, -0.14319779f, -0.01206473f, 0.13255751f, 
    -0.05063777f, 0.01699000f, 0.00012834f, -0.02506814f, 0.04273596f, -0.01943270f, 0.03468501f, 0.00883657f, 
    0.14344367f, 0.04478897f, 0.10322098f, -0.13771711f, -0.06800570f, -0.01024915f, -0.01567619f, 0.02559410f, 
    0.07444394f, -0.03327145f, 0.11574666f, 0.07788547f, -0.00085405f, -0.21991728f, 0.00918953f, 0.14137940f, 
    0.04635476f, -0.06554789f, -0.00237017f, 0.09981206f, 0.06906042f, -0.03550810f, 0.05684201f, -0.00859230f, 
    -0.01908322f, 0.04684060f, -0.04555306f, -0.09832567f, 0.03419820f, 0.11762502f, 0.03421224f, 0.07540425f, 
    0.00834411f, -0.04605310f, -0.04722960f, -0.13633022f, -0.10518910f, -0.04819991f, 0.08164573f, 0.07639135f, 
    -0.12938167f, 0.02466395f, 0.00623056f, -0.01747754f, 0.06288695f, -0.03501583f, -0.01971242f, 0.09209388f, 
    0.23143192f, -0.03465817f, -0.00850121f, 0.02904579f, 0.02891811f, -0.02967784f, 0.01775541f, 0.03036260f, 
    0.03595673f, 0.01111928f, -0.01870780f, -0.08353591f, -0.00326654f, 0.04311177f, 0.05881565f, -0.23522530f, 
    -0.03135723f, 0.00417793f, -0.03351790f, 0.05945853f, -0.00092943f, -0.05398760f, -0.02922455f, 0.01134429f, 
    -0.27967429f, 0.15736610f, 0.06892481f, -0.01250611f, 0.00505778f, -0.02674242f, 0.01790567f, -0.02737973f, 
    -0.00047377f, -0.07911537f, -0.18591419f, 0.00392266f, -0.25417510f, -0.04242742f, -0.06400637f, 0.17826745f, 
    -0.05694602f, 0.04722032f, -0.07626069f, 0.02372369f, -0.05704669f, 0.08041005f, -0.01625076f, -0.02068347f, 
    -0.22320847f, -0.05392606f, 0.05156480f, -0.16863142f, 0.01331324f, -0.01178245f, 0.10293348f, 0.03380233f, 
    0.08742317f, 0.03628543f, 0.03046112f, -0.06660490f, 0.53614235f, -0.06865387f, 0.00002889f, -0.04696568f, 
    -0.12186055f, 0.05119234f, -0.01475866f, -0.03849846f, -0.03876688f, -0.00464303f, 0.05828748f, -0.01835197f, 
    -0.00826442f, -0.01221960f, -0.09575789f, -0.03777134f, 0.09593987f, -0.02726490f, -0.02650043f, 0.03341200f, 
    -0.00331560f, 0.07278442f, 0.08085893f, 0.01406502f, 0.00777575f, -0.09830888f, 0.06015724f, 0.04171434f, 
    -0.11754997f, -0.04563070f, 0.07214092f, 0.09032191f, -0.06851474f, 0.04177185f, 0.03993309f, 0.01731827f, 
    -0.02390543f, -0.07259310f, 0.06899431f, -0.21357681f, 0.00514288f, 0.10571910f, 0.03398980f, -0.05942726f, 
    0.04900632f, -0.00785307f, -0.04447519f, 0.05064208f, 0.21767060f, 0.13890728f, -0.06866548f, -0.00080093f, 
    0.04951134f, 0.07399111f, 0.03693033f, 0.03632569f, 0.04334714f, -0.00705172f, -0.06692559f, 0.00287694f, 
    -0.19813417f, -0.00206980f, 0.18989177f, 0.06556167f, 0.10407156f, -0.00057625f, 0.03641624f, -0.06078753f, 
    0.07676268f, -0.05866160f, 0.13454656f, -0.01931812f, -0.15559584f, 0.03542447f, -0.06089403f, 0.03342714f, 
    0.06345228f, 0.04352742f, -0.01050901f, -0.02199800f, 0.00602384f, 0.07121336f, 0.00741295f, 0.10546596f, 
    -0.16045256f, 0.12185481f, -0.00394082f, -0.02221852f, 0.05889180f, 0.00614183f, 0.07584541f, 0.01175140f, 
    -0.01088853f, 0.06072623f, 0.03422124f, -0.07094099f, -0.13060653f, -0.17233269f, 0.04229097f, -0.04802989f, 
    0.13487756f, 0.01151253f, 0.22594127f, -0.00577631f, 0.10722546f, 0.01259502f, 0.10520248f, -0.05083331f, 
    -0.19968341f, -0.11421160f, -0.01936498f, -0.10925247f, -0.03895531f, 0.00538836f, 0.01896831f, 0.01049384f, 
    0.06296176f, -0.10327386f, 0.07822054f, 0.06514525f, -0.25887397f, 0.19091597f, 0.23923366f, 0.01766378f, 
    0.05346769f, 0.00671174f, 0.01947467f, 0.03095360f, 0.08707635f, 0.05284785f, -0.16706677f, 0.05764507f, 
    -0.17524318f, -0.22107358f, 0.03047149f, 0.02278810f, 0.05696853f, 0.00135511f, -0.02645031f, -0.02895385f, 
    0.03764633f, -0.04479395f, -0.00691801f, 0.04831440f, 0.05380634f, -0.01348680f, -0.06343824f, 0.09799429f, 
    -0.01083771f, -0.01451934f, -0.01696704f, 0.01868960f, 0.09383199f, 0.16242440f, 0.12426885f, 0.07478592f, 
    -0.11587077f, 0.28873977f, 0.06623098f, -0.10135528f, -0.02166509f, -0.02650920f, 0.02894294f, 0.00386011f, 
    -0.02538777f, -0.04969685f, -0.02315227f, 0.07200032f, 0.06595048f, -0.01310397f, -0.04037445f, -0.07890597f, 
    0.00089870f, 0.04811978f, 0.03298900f, 0.01552321f, -0.04521042f, 0.01543321f, -0.02980867f, 0.06361646f, 
    0.09160351f, 0.02100194f, -0.03739148f, -0.09327366f, 0.04377574f, -0.01329552f, 0.01998863f, -0.04278084f, 
    0.06697030f, 0.11956101f, -0.10948072f, -0.00439823f, 0.10996272f, 0.01336015f, -0.12953366f, -0.01846493f, 
    0.02216993f, 0.02742001f, -0.01063339f, 0.08319286f, 0.03216136f, 0.05661960f, 0.05777064f, 0.02384877f, 
    0.03914741f, -0.07279962f, 0.01648619f, -0.03261688f, -0.02036742f, 0.02296129f, 0.01071691f, -0.02505776f, 
    0.00403065f, 0.03103952f, 0.06588750f, -0.04812898f, 0.25011033f, 0.11463821f, 0.00595150f, -0.02532070f, 
    0.01936804f, 0.08459151f, -0.07468510f, 0.04560196f, 0.05153291f, 0.05823833f, -0.00386030f, 0.02604919f, 
    0.04704196f, -0.01122267f, -0.06761286f, 0.03322410f, -0.06158353f, 0.06360151f, -0.02402823f, -0.00827185f, 
    0.02543190f, 0.07585306f, 0.02253228f, 0.01300175f, -0.10681800f, 0.15031922f, -0.12524304f, -0.13412212f, 
    -0.01669360f, -0.03143404f, 0.02013734f, -0.02609149f, 0.11357357f, -0.05938072f, -0.08332913f, -0.01517758f, 
    0.11728144f, 0.06991854f, 0.03427187f, 0.02479826f, -0.03082183f, -0.02555208f, -0.00578360f, -0.02156124f, 
    0.00308728f, -0.06219659f, -0.02192218f, -0.03649703f, 0.54036921f, 0.05401716f, 0.05837268f, -0.15902470f, 
    -0.15406522f, 0.04261209f, 0.07611271f, -0.05941485f, -0.06771642f, -0.09858195f, -0.07339317f, -0.10618713f, 
    0.13920748f, -0.19978245f, 0.10494845f, 0.11235561f, -0.07218099f, 0.04572041f, -0.06566351f, 0.06399083f, 
    0.00332136f, -0.10068098f, 0.15436783f, 0.03547142f, -0.00786333f, -0.27781472f, 0.06870181f, -0.26081502f, 
    0.02346450f, 0.09044132f, -0.00869408f, -0.04383142f, 0.06360167f, 0.04007101f, -0.08212177f, -0.08431392f, 
    0.06022801f, -0.07321593f, 0.03925433f, 0.11891751f, -0.09205470f, 0.02139818f, -0.00643080f, -0.00247897f, 
    0.06359685f, 0.05876132f, -0.04107004f, -0.11153141f, 0.02421802f, 0.11929484f, 0.16951357f, 0.05734004f, 
    -0.10622533f, 0.05610025f, 0.05421088f, 0.06207206f, 0.00149166f, -0.02507058f, 0.11438096f, -0.03472757f, 
    0.16434047f, 0.01371814f, 0.09741504f, -0.13370976f, -0.10464829f, 0.00604591f, -0.00487551f, 0.07223918f, 
    0.08199953f, -0.07730135f, 0.16507715f, 0.02850479f, 0.08350929f, 0.16321149f, -0.05440551f, 0.08476501f, 
    0.04620170f, 0.19576947f, 0.10353413f, -0.04279477f, -0.03242150f, 0.14473361f, -0.00019787f, 0.00925424f, 
    0.08313493f, -0.04736425f, -0.03390147f, 0.10654732f, 0.00164660f, -0.05275043f, 0.03110157f, 0.03396582f, 
    -0.03481360f, 0.05501927f, -0.06551854f, -0.04664064f, 0.12931967f, 0.29773727f, 0.06203845f, -0.09709267f, 
    -0.14674039f, 0.02522581f, 0.05260388f, 0.08297276f, -0.10130804f, 0.09580773f, 0.03318620f, -0.01222849f, 
    -0.04860341f, -0.14926399f, -0.02365897f, 0.01617168f, 0.01137295f, -0.02938738f, 0.12004595f, 0.08191938f, 
    -0.04822741f, 0.02277093f, -0.17039934f, -0.00616808f, 0.11693707f, -0.04357277f, 0.01983078f, -0.04740496f, 
    0.09337167f, -0.08848944f, 0.10950699f, 0.11569508f, 0.04633883f, 0.12161853f, 0.02174380f, 0.01649733f, 
    -0.07415410f, 0.17898470f, -0.07900187f, 0.16533232f, -0.09076184f, 0.00812628f, -0.00460793f, -0.06128946f, 
    -0.02550550f, 0.02119285f, -0.04818594f, -0.02191667f, 0.10057411f, 0.14897284f, 0.07494322f, -0.11118530f, 
    -0.03773196f, 0.08023150f, 0.05344369f, -0.05071288f, 0.05544199f, 0.00135620f, -0.04563078f, -0.07855757f, 
    -0.23070012f, -0.10505070f, -0.03414567f, 0.08949359f, 0.05750336f, -0.02745782f, 0.10887892f, 0.04187225f, 
    -0.01786451f, 0.03970203f, -0.15341401f, -0.08870561f, 0.16378614f, -0.16427302f, -0.04479992f, -0.05485945f, 
    -0.07393438f, 0.07401225f, -0.09731337f, 0.05120519f, -0.05001125f, -0.08696412f, 0.01447153f, -0.01757214f, 
    0.08551055f, -0.09044962f, -0.14091630f, 0.07417368f, -0.02328793f, -0.01810869f, 0.01876317f, 0.02722824f, 
    -0.07950738f, -0.02408631f, 0.00750670f, -0.06771283f, 0.33798882f, -0.18387549f, -0.01721523f, 0.06663349f, 
    0.06453584f, -0.05365521f, 0.00858602f, 0.09665658f, -0.04459647f, -0.03657034f, -0.09081655f, -0.06014913f, 
    0.34037519f, -0.07025086f, -0.00316674f, -0.15028648f, -0.04080883f, 0.08935744f, 0.00142778f, -0.06098271f, 
    0.00969674f, 0.00002516f, 0.03736998f, -0.06823107f, 0.19025706f, -0.11706693f, -0.01782939f, 0.05679077f, 
    -0.03367809f, -0.09031449f, 0.02896727f, 0.02840806f, -0.12397549f, -0.05550591f, -0.03318826f, -0.11924300f, 
    0.18528762f, 0.15367535f, -0.01985581f, -0.03085927f, -0.06030222f, -0.06003458f, 0.02895522f, -0.08744711f, 
    -0.12835556f, -0.02644358f, -0.06807251f, -0.04293671f, -0.10578764f, 0.11689793f, -0.14838502f, 0.04698684f, 
    -0.09147026f, -0.03226778f, 0.04356269f, 0.03189488f, -0.09650719f, -0.06856655f, -0.02202896f, -0.01833685f, 
    0.08354593f, 0.14744493f, 0.12944473f, 0.02583897f, -0.13978770f, -0.02905290f, 0.06168560f, 0.09888804f, 
    -0.09826189f, -0.02173187f, -0.00865965f, -0.02422676f, -0.02167249f, 0.18882936f, 0.12078699f, 0.04702154f, 
    -0.14396340f, -0.10916728f, 0.01913984f, -0.09743328f, -0.05807680f, 0.01058098f, 0.02156136f, -0.05116970f, 
    0.18018129f, -0.01994935f, 0.07320274f, -0.08201666f, 0.06958513f, -0.06421036f, 0.15859400f, 0.01812847f, 
    -0.00754332f, 0.05997390f, -0.02770777f, -0.03782351f, 0.16800255f, 0.04870509f, 0.05859850f, 0.10010923f, 
    0.04970212f, -0.02285885f, -0.00676714f, -0.00482060f, 0.04044024f, 0.00521137f, -0.03442165f, 0.13330920f, 
    -0.11743610f, 0.18212382f, -0.08111054f, 0.17906532f, -0.06912496f, -0.11836170f, 0.02549025f, -0.02344809f, 
    0.00654810f, 0.04189668f, -0.06922126f, 0.00415208f, 0.00760794f, -0.01149186f, -0.01345299f, -0.14005369f, 
    0.04103129f, 0.14942756f, 0.07813642f, -0.06472628f, 0.07880075f, 0.04491420f, 0.07240840f, -0.03274584f, 
    0.18252027f, 0.00688050f, 0.16525280f, 0.04595556f, -0.05533287f, 0.04961904f, -0.01894439f, 0.04705294f, 
    -0.07408878f, 0.06471426f, -0.07223395f, -0.10379504f, -0.01752224f, 0.01399178f, 0.01645859f, 0.02088225f, 
    0.09754975f, -0.01154979f, 0.00398088f, 0.07107735f, -0.06149277f, 0.14143848f, -0.03497753f, -0.08709502f, 
    0.09809570f, 0.18496647f, 0.13695481f, -0.12767309f, -0.01351558f, 0.10469977f, 0.06422196f, -0.06791355f, 
    -0.02302376f, 0.13274285f, 0.00442885f, 0.05108459f, 0.24518646f, -0.03531760f, -0.02387610f, -0.03963523f, 
    -0.09936298f, 0.10062906f, 0.15813810f, -0.11127549f, -0.04986311f, 0.16497149f, -0.06478062f, -0.00388448f, 
    0.02749590f, 0.03116448f, -0.03489331f, 0.03915700f, 0.01678013f, -0.02825922f, -0.02454810f, -0.04963249f, 
    0.02731593f, 0.01816263f, 0.00341003f, -0.04997549f, 0.02034139f, -0.04202789f, -0.00217885f, -0.03117585f, 
    -0.04776747f, -0.03054577f, 0.02111974f, -0.01690949f, -0.02754126f, 0.04562595f, -0.01128472f, -0.01807882f, 
    -0.02963251f, -0.00640218f, -0.00077112f, -0.00352576f, 0.00920758f, 0.04169487f, 0.01720187f, -0.02008023f, 
    -0.02758936f, -0.03850041f, 0.01463064f, -0.05203063f, -0.04632396f, -0.02518764f, 0.02920897f, 0.00789006f, 
    0.00073264f, -0.03809858f, 0.02987607f, -0.02387994f, -0.04961221f, -0.02655596f, -0.03924678f, -0.04817811f, 
    0.04248289f, -0.05370717f, 0.03668964f, -0.00723986f, 0.01913592f, 0.01454614f, 0.02745088f, 0.01029545f, 
    -0.04224886f, -0.01345300f, 0.00191995f, -0.01216943f, -0.04165526f, -0.03261020f, -0.04989778f, 0.03767964f, 
    0.03848825f, 0.04246973f, -0.00434133f, 0.00520189f, -0.02817440f, -0.04592811f, 0.03914816f, 0.03825109f, 
    -0.02258244f, 0.00627220f, -0.04287822f, -0.00008245f, -0.02631819f, -0.01281004f, 0.02043076f, 0.02245869f, 
    0.00835022f, 0.04180417f, -0.04815535f, 0.01103531f, -0.01768243f, -0.03717144f, -0.05006706f, -0.04734493f, 
    0.02799328f, -0.00036189f, -0.04556419f, -0.03243964f, -0.00364056f, -0.04404545f, 0.04112341f, -0.01352789f, 
    0.01627405f, -0.04140837f, 0.04509665f, -0.03239900f, -0.00300128f, 0.04216532f, -0.03231993f, 0.03174408f, 
    0.00731356f, -0.01191521f, -0.01595820f, -0.04686394f, -0.01129092f, 0.04355026f, -0.04740078f, -0.02176584f, 
    -0.02167598f, -0.03095053f, -0.02290064f, 0.01567425f, -0.02272563f, 0.04307432f, 0.01682502f, -0.01718576f, 
    -0.00761548f, 0.04534488f, 0.01874084f, -0.01591830f, 0.00826483f, 0.01824247f, 0.03735589f, -0.03113126f, 
    0.01803679f, -0.00237074f, 0.04046786f, -0.03641974f, -0.04645473f, -0.03889262f, 0.04897213f, 0.01024620f, 
    0.01747559f, 0.01663255f, -0.00776410f, -0.02743827f, -0.01178916f, 0.02533474f, -0.01479575f, 0.00954736f, 
    -0.03462235f, -0.03729498f, -0.04371409f, 0.03378074f, -0.03457704f, -0.03267619f, 0.04407349f, -0.03841108f, 
    -0.03934806f, -0.03091785f, -0.00455414f, -0.02534919f, 0.00275601f, 0.01171338f, 0.03201390f, -0.03343302f, 
    0.03451370f, -0.02464808f, -0.05265287f, 0.02923140f, -0.02054449f, -0.00453191f, -0.02559649f, -0.00825187f, 
    -0.01509572f, 0.01855254f, -0.01139614f, -0.02816893f, 0.00348156f, -0.03087935f, 0.03343568f, -0.04489577f, 
    0.03535721f, 0.04117549f, -0.00725088f, -0.04863932f, -0.02741520f, -0.04064249f, 0.03286400f, -0.05064268f, 
    -0.03084330f, -0.02766164f, -0.04024287f, -0.02617362f, -0.00768377f, -0.02744240f, -0.00527183f, 0.02518045f, 
    -0.00756350f, -0.03244236f, -0.04804422f, 0.03258116f, -0.01609766f, 0.01853278f, -0.00920532f, -0.05217571f, 
    -0.04994351f, -0.00948032f, 0.01412454f, 0.04025818f, -0.02181006f, -0.01320371f, 0.02168976f, -0.00755761f, 
    0.00588484f, 0.03407745f, 0.03661996f, -0.02811534f, 0.00385526f, -0.03543215f, -0.04079604f, -0.03463918f, 
    0.02263325f, -0.03608384f, -0.04674418f, -0.05294141f, -0.03418450f, -0.03489803f, 0.02117291f, -0.05254399f, 
    -0.02936769f, -0.01401769f, -0.03808999f, -0.05502861f, -0.00950077f, -0.03553266f, 0.00429900f, -0.03247126f, 
    -0.01313944f, -0.04028603f, -0.03806161f, 0.00080554f, -0.00686650f, -0.02898344f, 0.00500520f, 0.03104169f, 
    0.04243108f, 0.02492801f, -0.01854944f, -0.02145149f, 0.03577766f, 0.02140392f, 0.01704075f, -0.05585847f, 
    -0.00498342f, -0.04181299f, -0.04035527f, 0.04032571f, 0.01999649f, 0.00194623f, 0.01751130f, 0.00712091f, 
    -0.01877064f, -0.02487360f, -0.05487353f, 0.04052709f, -0.03619714f, -0.03715605f, -0.00920925f, 0.03704370f, 
    0.02823686f, -0.04121078f, -0.00757502f, 0.01100529f, -0.04358704f, 0.00418891f, 0.03489362f, 0.00008158f, 
    -0.02953142f, -0.03324144f, -0.02525275f, 0.04229766f, -0.05576422f, -0.02514759f, -0.00140798f, -0.04522515f, 
    -0.02015464f, 0.02770280f, 0.04117427f, 0.01662024f, -0.04808147f, -0.03437883f, -0.01541897f, 0.04552085f, 
    -0.03020804f, 0.01619707f, 0.01697640f, 0.00015916f, -0.00239764f, -0.03107654f, 0.02666955f, -0.05502293f, 
    0.00024630f, 0.02743950f, -0.04544183f, 0.00420801f, -0.05151567f, -0.00553206f, -0.04971038f, -0.04071593f, 
    0.02955819f, -0.01616471f, 0.02102639f, 0.00548718f, 0.04408198f, 0.01605433f, 0.02390861f, 0.02237184f, 
    -0.00495516f, -0.03483754f, -0.00401857f, 0.03765133f, 0.01354088f, -0.03661864f, 0.02698625f, -0.05007831f, 
    0.04289537f, 0.00937982f, -0.02410683f, 0.00134473f, 0.01555861f, 0.02638221f, 0.02077274f, 0.02146828f, 
    0.02926809f, -0.00722741f, -0.00994932f, -0.00202664f, 0.02703163f, 0.03702293f, 0.01842942f, -0.01086180f, 
    -0.02016538f, 0.02600803f, 0.03814506f, 0.00393493f, -0.00913694f, -0.00140832f, 0.00576954f, -0.02512524f, 
    0.01155464f, -0.03981120f, 0.00632441f, -0.03235476f, -0.03966391f, -0.04776296f, -0.00862166f, 0.00426384f, 
    -0.00224550f, 0.00274288f, 0.03949538f, -0.03470841f, 0.02040747f, 0.02530908f, 0.00222917f, 0.01930017f, 
    -0.00934550f, -0.01533260f, 0.00575578f, 0.01248446f, 0.03055835f, -0.04588563f, 0.02691261f, 0.00834916f, 
    -0.04918572f, 0.02315309f, 0.02463618f, -0.04218125f, -0.05211120f, 0.01683954f, -0.04108633f, -0.00694744f, 
    -0.04842752f, -0.02500067f, -0.03869989f, -0.04036219f, 0.01247767f, 0.02729878f, -0.03546645f, -0.03084699f, 
    0.09409824f, 0.11665573f, -0.19961582f, 0.04610386f, 0.02197101f, 0.08994382f, 0.11080124f, 0.00322774f, 
    0.03991910f, -0.05852565f, -0.00766238f, 0.06970590f, -0.05697444f, 0.22293356f, 0.08155153f, 0.00157209f, 
    0.21886259f, -0.03764916f, 0.06630608f, 0.03909249f, 0.00102159f, 0.01801824f, -0.04331017f, -0.02618084f, 
    -0.23066378f, 0.23886575f, -0.01704805f, 0.15968475f, -0.05875770f, -0.04050129f, 0.04385320f, 0.00016394f, 
    0.03897420f, 0.06313092f, -0.00827198f, 0.00295944f, -0.32808492f, 0.12312023f, 0.07872824f, -0.15103811f, 
    0.03845546f, -0.05755766f, 0.03897649f, -0.08460561f, 0.01619437f, -0.00674405f, 0.05473854f, -0.07631548f, 
    -0.02757422f, 0.09710553f, 0.06719535f, 0.10668322f, -0.03967827f, -0.06229326f, 0.03176764f, -0.15160380f, 
    -0.12903821f, 0.20770980f, -0.01121722f, 0.08915300f, 0.02669066f, -0.00873263f, -0.07313286f, -0.09345712f, 
    0.05403126f, -0.05966434f, 0.00058769f, 0.00282479f, -0.03671008f, 0.05448877f, 0.09765963f, 0.00076612f, 
    -0.09558574f, -0.03975604f, -0.02867982f, -0.15436547f, 0.07906703f, -0.15264258f, -0.00448066f, -0.04848593f, 
    0.07176012f, 0.13270769f, 0.05196115f, 0.19519687f, -0.09336533f, -0.12465748f, -0.08037490f, 0.19494498f, 
    0.08086826f, 0.00847771f, 0.01979980f, -0.00374924f, -0.00803333f, -0.06178066f, 0.04844425f, -0.03018239f, 
    0.20573936f, -0.10006191f, -0.01533847f, 0.20448640f, 0.01945878f, -0.02354291f, 0.00355264f, 0.01796711f, 
    -0.06036750f, -0.01520323f, 0.02760023f, -0.04062655f, -0.15766621f, 0.13261496f, 0.08948597f, -0.19830778f, 
    0.06909092f, 0.13570900f, 0.00977251f, -0.01027687f, -0.04318956f, 0.02876379f, 0.03878291f, -0.09339097f, 
    0.09642980f, 0.09715758f, -0.06252997f, 0.31587031f, -0.00620115f, 0.05367835f, 0.03206045f, 0.07391308f, 
    0.05765914f, 0.06664837f, 0.04292005f, -0.00961386f, 0.17809950f, -0.22699142f, 0.12834305f, 0.05454022f, 
    0.11439117f, -0.04578971f, 0.03658597f, 0.06799603f, 0.09344916f, 0.01117200f, 0.11894253f, -0.00577988f, 
    0.03620904f, 0.09738094f, 0.00799126f, 0.05877271f, 0.03241098f, -0.06881227f, -0.11739704f, -0.03379840f, 
    -0.13579825f, -0.13913828f, -0.10527267f, -0.03356181f, -0.15942872f, 0.04236797f, -0.07735956f, -0.06264471f, 
    0.19396907f, 0.03683247f, 0.06222397f, 0.00170828f, -0.02836482f, 0.02438249f, -0.02814239f, -0.02016713f, 
    0.02022796f, 0.22854792f, -0.11222154f, 0.11228020f, 0.11701941f, -0.05026342f, -0.02359158f, 0.04420503f, 
    -0.07560366f, -0.09348169f, -0.03072889f, -0.04678847f, -0.13006291f, 0.02044143f, 0.06213846f, -0.01918076f, 
    -0.13525973f, -0.01161078f, 0.08174053f, -0.03401068f, 0.10292397f, -0.03625598f, 0.00599669f, 0.01458547f, 
    0.00707530f, 0.21016967f, -0.02985819f, -0.01953486f, 0.04456619f, 0.07011160f, -0.05355914f, 0.08771474f, 
    0.07825063f, 0.13824652f, -0.07826795f, 0.00399100f, 0.19840877f, -0.03127189f, 0.03141787f, 0.08186709f, 
    -0.02310340f, 0.01103034f, 0.17274807f, -0.08140727f, -0.07193822f, -0.08171739f, -0.00524842f, 0.05920935f, 
    0.36561906f, -0.08633563f, -0.02602126f, 0.00572640f, 0.07771868f, 0.01874101f, -0.11336955f, 0.00825290f, 
    -0.17823797f, 0.02737168f, 0.05646968f, 0.00527228f, -0.14421365f, 0.27735677f, -0.00382401f, 0.30365461f, 
    0.05451444f, 0.00793176f, -0.11633295f, 0.01046076f, 0.06703332f, 0.06246719f, -0.08211233f, 0.11281223f, 
    0.02003756f, 0.33620477f, 0.05710853f, 0.10883014f, -0.05792801f, 0.02422153f, 0.11102939f, -0.04903435f, 
    0.17482966f, 0.12444960f, 0.11831997f, 0.00455104f, 0.11892537f, 0.06006098f, -0.07107360f, -0.28037441f, 
    -0.03225039f, 0.22260562f, -0.05029901f, -0.06015753f, 0.00782566f, -0.02305633f, 0.14415045f, -0.06075570f, 
    -0.06130954f, 0.33080482f, 0.00767503f, -0.11283411f, 0.03040200f, 0.06484304f, 0.06066959f, 0.07510351f, 
    0.06594838f, -0.01576320f, 0.10144201f, -0.02269058f, -0.19072790f, 0.07794885f, -0.02429316f, -0.27397189f, 
    0.20468007f, -0.00902640f, 0.06220936f, -0.00272396f, -0.03715573f, -0.06762672f, -0.01409738f, 0.01156504f, 
    0.07637107f, -0.21493910f, -0.16862997f, 0.06310222f, 0.06827114f, -0.08366853f, -0.04737182f, 0.02861876f, 
    0.02719686f, 0.04852046f, -0.04340477f, 0.00332291f, -0.02716293f, 0.08188426f, -0.06125702f, 0.05187536f, 
    -0.09698768f, 0.03439191f, -0.01287708f, 0.08124564f, -0.13021640f, -0.09352618f, 0.00650183f, -0.00757174f, 
    -0.00469384f, 0.02784418f, 0.11659610f, 0.19732097f, 0.03706444f, 0.01396898f, -0.06073630f, 0.02477918f, 
    0.00387195f, -0.00537450f, 0.07869611f, 0.03020199f, -0.35345212f, 0.08014944f, 0.01926546f, -0.20537384f, 
    0.07627268f, -0.10268102f, 0.02980924f, -0.03921061f, -0.00490747f, 0.02724612f, -0.03089072f, -0.02608083f, 
    -0.05177623f, -0.03485873f, 0.00859554f, -0.04558790f, 0.09270587f, 0.13331017f, -0.03478061f, 0.04174527f, 
    0.08871537f, -0.01480254f, 0.05039612f, -0.00891370f, -0.05540720f, -0.03885799f, 0.08527497f, -0.01571851f, 
    -0.09790026f, 0.07596834f, 0.04768431f, 0.07221411f, 0.02441661f, -0.02086564f, 0.06222273f, 0.06671478f, 
    -0.10172729f, -0.02687078f, 0.01980484f, -0.14968517f, 0.00195140f, 0.04514063f, -0.01487226f, -0.03880168f, 
    -0.02924824f, -0.00312916f, 0.02206063f, 0.05440158f, 0.13345106f, -0.20952718f, 0.22907901f, 0.11299927f, 
    0.02906337f, -0.00702138f, -0.07790719f, 0.06135921f, 0.07878314f, -0.03478458f, 0.12974790f, 0.12192051f, 
    -0.05517540f, -0.03298574f, 0.01931648f, -0.02830632f, -0.05658218f, -0.06247076f, -0.03303184f, 0.01734348f, 
    0.03617521f, 0.02141729f, 0.00395563f, -0.01804128f, 0.03705788f, 0.02581840f, 0.04041171f, -0.02851029f, 
    0.00161506f, -0.01036992f, -0.05513873f, -0.03394225f, -0.01989270f, -0.03332027f, -0.04404847f, -0.03501879f, 
    -0.05497392f, -0.03987759f, -0.04014577f, 0.04914578f, -0.03055152f, 0.04088075f, 0.00482184f, -0.01155234f, 
    -0.04393864f, 0.01095476f, 0.00772767f, -0.00559879f, -0.05541981f, -0.02580755f, -0.03220662f, -0.02456541f, 
    -0.02063716f, -0.00476816f, 0.03727415f, 0.00306917f, 0.00858061f, -0.04361208f, 0.02885894f, -0.03890048f, 
    -0.03788831f, 0.03499098f, 0.00131457f, 0.03741712f, 0.04996796f, -0.01208777f, 0.03924649f, -0.02948848f, 
    0.01241997f, 0.03812294f, 0.02107098f, -0.02149449f, -0.02804004f, 0.03630750f, -0.00196751f, 0.01668227f, 
    0.02597688f, -0.03834238f, -0.01490182f, 0.03228198f, -0.04813703f, -0.06554578f, 0.00181173f, 0.04052237f, 
    -0.03673903f, 0.01366203f, -0.01378431f, -0.01601661f, 0.04529477f, 0.04183271f, -0.00396999f, 0.01285456f, 
    0.01298194f, -0.02467018f, 0.05486199f, 0.03849253f, -0.02061895f, -0.03394510f, 0.00031851f, 0.02004919f, 
    0.05035392f, 0.01360671f, 0.02211706f, -0.03950022f, -0.01116329f, -0.04868120f, 0.01168690f, 0.03144382f, 
    -0.03903054f, -0.03677107f, -0.03486121f, 0.00099119f, 0.03446906f, -0.00983736f, -0.02324947f, -0.04437227f, 
    0.02790450f, 0.01031188f, -0.00503513f, -0.00177256f, -0.03913475f, 0.02031161f, 0.02717336f, -0.05455593f, 
    0.03173079f, 0.02358339f, 0.01562439f, -0.00362133f, 0.00910952f, 0.04012828f, 0.00887153f, -0.02474427f, 
    -0.04766598f, 0.03124395f, -0.04131007f, -0.03438888f, -0.02073619f, 0.01036724f, 0.02635597f, -0.04633377f, 
    0.02882647f, 0.00170412f, -0.03583613f, 0.01080301f, -0.04839418f, 0.03785370f, 0.01535327f, 0.02877508f, 
    -0.02210223f, 0.03440644f, 0.01667238f, 0.02267799f, -0.04838316f, -0.01782732f, 0.04020935f, 0.00178189f, 
    -0.04506345f, -0.00741326f, -0.00268417f, 0.03535444f, -0.01167094f, 0.04809668f, 0.01607320f, -0.01828487f, 
    -0.04875036f, 0.02771857f, 0.02291078f, -0.03287049f, 0.01772061f, -0.00893201f, -0.05796303f, -0.03532051f, 
    0.01989572f, -0.02764625f, 0.00908592f, 0.02767980f, -0.01670321f, -0.04020861f, -0.02483292f, 0.01844191f, 
    -0.05658621f, -0.00854984f, 0.02856248f, -0.01855244f, 0.02297834f, -0.02580491f, 0.03682180f, 0.03042301f, 
    -0.04041830f, -0.01321080f, 0.00738036f, -0.05789579f, -0.04925508f, 0.02634238f, 0.00171098f, -0.04351724f, 
    0.04368281f, -0.01258574f, 0.03435786f, -0.01872604f, -0.04671670f, 0.01515918f, 0.00099139f, -0.02490188f, 
    -0.03340925f, 0.04822338f, 0.05022090f, 0.04380831f, -0.02841555f, -0.01078646f, 0.01347838f, -0.04366849f, 
    0.00457803f, -0.00663754f, -0.04280708f, -0.04849997f, -0.05190574f, 0.02096872f, 0.00761541f, 0.01507638f, 
    -0.03614063f, 0.00310895f, 0.03241599f, 0.01127776f, -0.00810507f, 0.00937321f, -0.01009844f, 0.03657234f, 
    0.02543156f, -0.00084206f, 0.00973023f, -0.00992611f, 0.00610688f, -0.05339292f, -0.04154176f, -0.03396221f, 
    -0.03897415f, 0.01523607f, -0.04656129f, -0.05054950f, -0.01828383f, 0.00544170f, 0.03773029f, 0.01227946f, 
    -0.03734058f, 0.04404521f, 0.03700298f, -0.02427199f, -0.01210030f, 0.02720439f, -0.02567958f, -0.04696171f, 
    -0.01692896f, -0.01911188f, 0.03377219f, -0.02386011f, -0.03167023f, 0.01979841f, 0.02116617f, 0.03517343f, 
    0.01152025f, -0.02752084f, -0.02339472f, -0.02980573f, 0.03929723f, -0.02267665f, 0.03059893f, -0.03330836f, 
    0.00807377f, -0.01864873f, -0.02066663f, 0.02615260f, -0.02454246f, -0.00324116f, 0.03353435f, -0.04961855f, 
    -0.02976396f, 0.04478360f, -0.00604183f, -0.02351111f, 0.03665707f, 0.02547320f, -0.01628677f, 0.00653984f, 
    0.03328604f, -0.04383263f, -0.03586781f, 0.03689777f, 0.02064988f, 0.02441230f, -0.02050659f, -0.01385274f, 
    -0.02810264f, 0.03003945f, -0.02374014f, 0.03458779f, 0.01314344f, -0.03751751f, -0.01566707f, -0.04977205f, 
    -0.04092648f, 0.01694965f, 0.05069671f, -0.02839825f, 0.02842444f, -0.01574144f, -0.02630861f, 0.02190480f, 
    0.00810287f, -0.03522383f, 0.03541078f, 0.04274968f, 0.00209790f, -0.01699947f, -0.05043587f, -0.01145625f, 
    0.03743412f, 0.04354062f, -0.02520254f, -0.04396332f, -0.00069263f, 0.02866406f, -0.01674640f, -0.03875841f, 
    -0.03601160f, -0.00512037f, -0.03384215f, -0.06018014f, -0.00319888f, -0.03149249f, -0.02154771f, 0.00295020f, 
    0.02635882f, 0.02980790f, 0.04835301f, 0.02164385f, -0.03556424f, -0.04003025f, -0.02285830f, -0.02764668f, 
    -0.00679829f, -0.04673832f, -0.00674996f, -0.04734455f, -0.02034982f, 0.02100082f, -0.03077510f, 0.00411319f, 
    0.00454665f, -0.01416085f, -0.03888549f, -0.00640975f, 0.04551207f, -0.01096710f, -0.02035030f, 0.03276934f, 
    -0.04571911f, 0.01080051f, -0.01021716f, -0.05897181f, 0.01229578f, -0.00789871f, -0.00023270f, 0.03831176f, 
    0.01463370f, -0.02217568f, -0.04465647f, 0.03146724f, 0.00690568f, -0.00705389f, 0.01985970f, -0.02993543f, 
    -0.01055721f, 0.01294735f, -0.01986247f, -0.00811445f, -0.05126272f, -0.02250293f, -0.01534272f, 0.03577813f, 
    0.00664911f, 0.00125104f, 0.00109199f, -0.00987689f, 0.05624228f, -0.02801049f, 0.05351122f, 0.05011183f, 
    -0.01292749f, -0.01751729f, -0.05083770f, 0.00167262f, 0.02448289f, -0.05784822f, -0.00455083f, 0.01063714f, 
    0.02450243f, 0.01649507f, -0.03588961f, 0.00563571f, -0.03583362f, 0.01273730f, 0.03521863f, -0.04025181f, 
    0.04158805f, -0.04075196f, 0.01261745f, 0.02047191f, -0.04070811f, -0.03053488f, 0.04472674f, -0.00824371f, 
    -0.05544536f, 0.03358711f, -0.03027465f, -0.04525504f, 0.00779097f, 0.00830605f, -0.00539681f, 0.02000000f, 
    -0.02942329f, -0.03045698f, -0.05193051f, -0.02753533f, -0.04812269f, -0.00792220f, -0.04928918f, 0.02403714f, 
    -0.01914568f, -0.00644863f, 0.01424455f, -0.00295754f, 0.03631850f, -0.05570992f, 0.00895311f, 0.02452930f, 
    -0.03338740f, -0.05463768f, 0.00492437f, 0.01053649f, 0.04220772f, 0.02152643f, 0.03179567f, -0.00796156f, 
    -0.05663690f, 0.02693211f, 0.00245495f, -0.02110649f, 0.03977340f, -0.01772184f, 0.03976713f, -0.01580295f, 
    -0.01298193f, -0.00615050f, -0.03510293f, 0.04012626f, -0.04726208f, 0.01984501f, 0.00114855f, -0.02025065f, 
    0.01219385f, 0.03358116f, 0.01690951f, -0.03060786f, -0.00553113f, 0.03805403f, 0.00373974f, -0.02523674f, 
    -0.04859154f, 0.01787172f, -0.02608145f, 0.03846957f, 0.03997042f, 0.03577204f, 0.01362687f, -0.05688779f, 
    -0.03177711f, -0.01138911f, 0.00414770f, 0.02766453f, -0.01521534f, -0.02477386f, -0.03171025f, -0.01161436f, 
    -0.00996705f, 0.00894255f, 0.02441131f, -0.03356271f, -0.03483576f, -0.04984841f, -0.05306166f, 0.00003357f, 
    -0.00210640f, -0.02621880f, -0.02976415f, -0.01407130f, -0.02509189f, -0.03489951f, 0.02625125f, 0.02274080f, 
    -0.01507873f, 0.03996973f, -0.02028178f, 0.03067521f, 0.03572920f, 0.03997355f, -0.03689264f, -0.04678386f, 
    -0.02697057f, -0.03679175f, 0.02734580f, -0.04389296f, -0.02836351f, -0.03337714f, -0.02975155f, -0.02552636f, 
    -0.05499225f, -0.02709067f, -0.02756353f, -0.00604419f, 0.01402124f, -0.04194919f, -0.02342847f, 0.00652124f, 
    -0.02141654f, 0.01385650f, 0.03255768f, -0.01628694f, 0.02125294f, 0.03012305f, 0.01756303f, 0.02280971f, 
    -0.03348122f, -0.04702586f, -0.00051192f, 0.02991084f, -0.03613126f, 0.03777155f, -0.00326411f, 0.00452129f, 
    -0.03033803f, -0.03038371f, 0.00522798f, 0.03193222f, 0.01912156f, 0.03279017f, -0.02027594f, 0.00213932f, 
    -0.00210491f, -0.03008341f, 0.03955180f, -0.01576552f, 0.04152541f, -0.01967098f, -0.05034464f, -0.03874223f, 
    0.02441191f, -0.03926167f, 0.01408661f, -0.02429077f, -0.03662178f, 0.01756315f, 0.01093771f, 0.03939880f, 
    -0.04212556f, -0.01774721f, -0.05451274f, 0.02557244f, -0.03202188f, -0.00193335f, -0.05365221f, -0.02542196f, 
    -0.02764507f, -0.02709245f, -0.01557190f, -0.05686679f, 0.00540750f, 0.01179200f, 0.03406420f, -0.03340467f, 
    -0.05562600f, -0.04384881f, -0.04665605f, 0.03899765f, 0.03193493f, -0.04087590f, 0.01976039f, -0.01495554f, 
    -0.01265640f, -0.03386872f, -0.01154354f, -0.01014013f, 0.00405225f, -0.01955041f, 0.04339149f, -0.02458012f, 
    0.03346122f, 0.01866659f, -0.01231932f, -0.04606054f, 0.03762869f, 0.02287191f, 0.02076016f, -0.01092194f, 
    -0.01110470f, -0.02488950f, -0.02968066f, -0.00799640f, 0.01434867f, -0.04009681f, 0.00676881f, -0.03848795f, 
    -0.00342837f, -0.01549106f, -0.05616925f, -0.02430109f, -0.05213825f, 0.03003541f, 0.00446955f, 0.03498280f, 
    -0.02392006f, -0.05270701f, -0.04321275f, -0.01500617f, -0.03668401f, -0.04271019f, -0.01998757f, -0.00767961f, 
    -0.04165231f, -0.02877887f, 0.03168245f, -0.01250226f, 0.00880442f, 0.01559637f, 0.03852371f, 0.01465952f, 
    -0.02489614f, 0.00044961f, -0.03347107f, 0.00159568f, -0.02946118f, -0.00813084f, -0.03724501f, -0.02840108f, 
    0.03073703f, -0.03738087f, -0.04838110f, -0.00504751f, -0.02560854f, 0.05676702f, -0.01073299f, -0.02324946f, 
    -0.01908749f, -0.00756782f, -0.03848784f, -0.01727481f, 0.01413408f, -0.00472568f, -0.05232029f, 0.00544450f, 
    0.02570231f, 0.01342901f, 0.00189967f, 0.03945890f, 0.00879380f, -0.04634191f, 0.01472934f, 0.04123672f, 
    -0.02489728f, -0.04944913f, 0.01067969f, 0.01853936f, 0.00245940f, -0.04162789f, 0.00683680f, 0.01327662f, 
    0.00902891f, -0.04883894f, 0.03844066f, -0.00165204f, 0.04428204f, 0.03110434f, 0.00152288f, -0.02379374f, 
    -0.03345808f, -0.01165034f, -0.05120349f, -0.03801441f, -0.03515605f, 0.01872727f, 0.01262111f, 0.03460441f, 
    -0.00252444f, 0.02619337f, 0.03857788f, -0.04379591f, -0.03079996f, 0.03143733f, 0.01980089f, 0.00100969f, 
    0.01425061f, -0.04951661f, -0.02577147f, 0.01144710f, -0.00285129f, 0.04248214f, -0.05334774f, 0.01185645f, 
    0.02555476f, -0.05656188f, -0.00623070f, -0.02427673f, 0.01356625f, 0.00467440f, -0.04014357f, -0.00713025f, 
    0.03322546f, 0.00782789f, 0.00943213f, 0.02439299f, 0.01171287f, 0.03037153f, -0.03744812f, -0.01507558f, 
    0.03873145f, -0.02668928f, -0.04758289f, -0.04506069f, 0.01821968f, -0.01822508f, -0.04948962f, 0.00935812f, 
    -0.02933233f, -0.05587537f, -0.02090652f, -0.00450614f, 0.01208670f, -0.01644787f, -0.03634429f, 0.00926030f, 
    -0.05014974f, 0.00140405f, -0.02116488f, 0.02177675f, 0.02163843f, -0.02732719f, 0.03876810f, 0.04189515f, 
    -0.05275813f, 0.04231875f, 0.03434796f, 0.00947294f, 0.01350318f, -0.04417825f, 0.01742523f, 0.02253781f, 
    0.00487457f, -0.05234484f, -0.00359973f, -0.02390789f, -0.02187119f, -0.03163547f, -0.02552956f, 0.02873520f, 
    -0.05662941f, 0.04429443f, -0.00010685f, -0.03445666f, -0.03215912f, 0.01548837f, -0.00552322f, -0.05026048f, 
    -0.03090662f, 0.03176273f, -0.04109108f, 0.02519940f, -0.04642646f, -0.00075021f, 0.02767515f, -0.02742049f, 
    -0.05174127f, 0.06931398f, -0.01391034f, -0.17134382f, 0.08082525f, 0.07239135f, 0.06263711f, 0.02741800f, 
    0.04986500f, -0.00498750f, 0.12218302f, 0.02096481f, -0.54559946f, 0.14599210f, 0.10487990f, -0.07453068f, 
    0.23682261f, -0.08294959f, -0.07239788f, 0.02010133f, 0.00926678f, 0.11658503f, 0.08037182f, 0.00663602f, 
    -0.04283874f, 0.04032389f, -0.09573150f, 0.10875643f, -0.05251333f, 0.02670453f, 0.09626464f, -0.11796585f, 
    0.02246552f, 0.00008122f, -0.05604945f, -0.13179006f, -0.11301768f, 0.26790786f, 0.03017896f, -0.09996493f, 
    -0.06508836f, -0.04834624f, -0.07803492f, -0.08054027f, -0.00995410f, 0.04431497f, 0.01200986f, 0.01724816f, 
    0.02651923f, 0.07701942f, 0.19488141f, 0.03300829f, -0.01170439f, -0.09544189f, 0.06940036f, 0.04343451f, 
    -0.05496252f, 0.05598225f, 0.14631908f, 0.12277779f, -0.01032349f, 0.07622579f, -0.05040053f, -0.02901038f, 
    0.16601342f, 0.05652631f, -0.01413459f, -0.08315580f, 0.02680894f, 0.11179881f, -0.05615638f, 0.14512788f, 
    -0.07591821f, -0.05335339f, 0.07138416f, -0.00464095f, 0.02843722f, -0.12516667f, -0.09668931f, -0.03152879f, 
    -0.05998198f, -0.00482573f, -0.04194412f, 0.06763011f, -0.03890008f, -0.16753249f, -0.00738404f, 0.22996591f, 
    0.12298298f, -0.07225048f, 0.08381604f, -0.09414066f, -0.04390884f, -0.03964036f, 0.07368744f, 0.16719380f, 
    0.22265273f, -0.20605314f, -0.02220847f, 0.05979099f, 0.07352267f, 0.04059266f, 0.02494640f, 0.02656849f, 
    -0.00046771f, 0.03117754f, 0.19347289f, 0.11471041f, -0.02203600f, -0.00162793f, 0.07781269f, -0.10855235f, 
    0.23906419f, 0.00004073f, 0.07916497f, -0.14669023f, 0.02672680f, -0.13959140f, 0.06856879f, 0.10137436f, 
    0.09298498f, 0.21557358f, -0.05534981f, 0.33663300f, 0.13382429f, 0.05933107f, -0.04649130f, 0.02804952f, 
    -0.00015746f, -0.01779029f, 0.03893029f, 0.09483509f, -0.39513612f, -0.09883498f, -0.08124609f, 0.08291820f, 
    0.14147066f, -0.10931345f, -0.02191135f, -0.12096639f, 0.10293020f, -0.12804666f, -0.04684239f, -0.00128856f, 
    0.11026863f, -0.01240100f, 0.04426699f, -0.02387079f, 0.10301278f, 0.04385237f, -0.05247058f, -0.05425950f, 
    0.05269265f, -0.07516839f, -0.00368020f, 0.00860950f, -0.11226653f, 0.00465583f, 0.03235209f, -0.01888754f, 
    0.18122055f, -0.04820159f, -0.06967983f, -0.07366310f, 0.09009697f, 0.08947544f, 0.11697283f, 0.00229371f, 
    0.19801566f, 0.23304616f, -0.18057257f, 0.06982422f, 0.11994817f, -0.02143865f, -0.12082320f, 0.08614475f, 
    -0.07001542f, 0.00179306f, 0.10330949f, 0.11105176f, -0.26370063f, 0.08331882f, 0.21537951f, -0.05145983f, 
    -0.04547013f, -0.06064298f, -0.05817112f, -0.02427160f, 0.06269649f, -0.01753354f, 0.15944941f, 0.08570644f, 
    0.09384195f, 0.11571572f, -0.06798082f, -0.01840277f, 0.02938700f, 0.08099652f, 0.02256157f, 0.07576769f, 
    0.13290721f, -0.03914406f, -0.13231327f, 0.12483733f, 0.04390129f, 0.12145050f, 0.07231063f, -0.03731096f, 
    -0.05104832f, -0.03139326f, 0.12255138f, -0.06324174f, 0.06464960f, 0.08608129f, 0.10607785f, 0.03735064f, 
    -0.02797982f, -0.06089333f, 0.05052015f, -0.01093137f, 0.05804412f, 0.03023751f, 0.03046465f, 0.09532154f, 
    0.05822907f, -0.04409639f, -0.00421907f, 0.16190377f, -0.12197595f, 0.26461652f, -0.13578463f, 0.16966294f, 
    -0.06607987f, 0.07393456f, -0.21772105f, 0.09057672f, 0.14593185f, 0.07058160f, -0.03219534f, 0.06000539f, 
    0.12690435f, 0.04547673f, 0.14824678f, 0.16202697f, 0.02055728f, 0.06856842f, -0.02092030f, -0.05036181f, 
    0.01741827f, -0.00759562f, 0.00602395f, -0.02180843f, -0.02328732f, -0.26153901f, 0.01806323f, -0.15909082f, 
    0.04426979f, 0.14055425f, 0.03426937f, -0.05868717f, 0.00819518f, 0.09718923f, 0.06469445f, 0.01875484f, 
    0.07415604f, 0.20028730f, 0.01604907f, 0.00136167f, 0.13991281f, 0.01190515f, 0.02760162f, -0.07560991f, 
    -0.00019691f, 0.01723814f, 0.04320985f, -0.04586886f, -0.12797406f, -0.02571456f, -0.00400364f, -0.09813613f, 
    0.20496622f, 0.06707011f, 0.00842081f, 0.07171608f, 0.03276427f, -0.08153377f, 0.07075702f, 0.00214035f, 
    -0.07618906f, -0.16273297f, -0.13885252f, 0.09069832f, 0.03908300f, 0.05594238f, -0.12159031f, -0.07157405f, 
    -0.00010804f, -0.00732408f, 0.15643416f, -0.00262693f, -0.12133200f, 0.05151275f, -0.04375456f, -0.03389760f, 
    -0.04186536f, -0.01170969f, -0.08742660f, 0.01220141f, 0.03978969f, -0.04913861f, -0.06336831f, -0.16766880f, 
    -0.04188636f, -0.22387134f, 0.10724498f, 0.15416053f, -0.00171189f, 0.13881882f, 0.04929244f, -0.00841204f, 
    0.00787276f, -0.00129658f, 0.14372566f, 0.00549543f, -0.15203735f, 0.04336066f, 0.11785469f, -0.09249294f, 
    0.04265766f, -0.09335744f, -0.03884213f, -0.00577181f, 0.03850384f, -0.00349110f, 0.03267415f, 0.06537770f, 
    -0.14400734f, 0.11417474f, -0.20581652f, -0.03156283f, 0.07394458f, 0.00153107f, 0.00669533f, -0.05713683f, 
    0.14256199f, -0.05070074f, -0.02474830f, 0.09178244f, -0.21968417f, -0.02043265f, -0.00456554f, -0.03456250f, 
    -0.13630295f, -0.01422728f, 0.01881466f, -0.14140962f, 0.05912948f, -0.11890764f, 0.09262381f, 0.01211360f, 
    -0.04675039f, -0.04096028f, 0.00751095f, -0.07539181f, 0.06940605f, -0.03163023f, -0.04109486f, -0.05577602f, 
    0.03524457f, -0.13794591f, 0.12073423f, 0.11468767f, 0.11468801f, -0.11070327f, 0.06852425f, 0.20139639f, 
    0.11766362f, 0.04519570f, -0.14391336f, 0.12836993f, 0.06075275f, 0.08219345f, 0.07488342f, -0.12661478f, 
    0.10875412f, 0.13321082f, 0.07591304f, -0.11008789f, -0.03042631f, 0.07900859f, 0.05796982f, 0.08339188f, 
    0.01491956f, -0.02640040f, 0.01247581f, -0.01381035f, -0.05271124f, 0.21609519f, 0.14932710f, 0.00141210f, 
    0.13533272f, 0.04516523f, -0.01734980f, -0.01727814f, -0.00938098f, -0.03564504f, 0.04450792f, -0.11587478f, 
    0.01979510f, -0.04720240f, -0.06206571f, 0.04920741f, -0.06709249f, -0.05676487f, 0.06920891f, 0.07011387f, 
    0.14041406f, -0.00269890f, 0.04563511f, -0.04622559f, -0.42771262f, 0.13724819f, -0.02289641f, -0.16328888f, 
    0.18193217f, -0.08746698f, 0.05874329f, 0.08253364f, 0.10164498f, -0.09564337f, 0.04412192f, -0.03350436f, 
    0.03094530f, 0.14146511f, 0.06649730f, 0.03175781f, -0.05609279f, -0.01247167f, 0.10921128f, 0.05102222f, 
    -0.03379828f, 0.11116416f, 0.12834704f, 0.07480047f, -0.23481844f, -0.16153890f, 0.05653474f, -0.19743009f, 
    0.00113017f, 0.02500347f, -0.01843467f, 0.02726655f, 0.12953463f, 0.01145738f, -0.00792548f, -0.01414656f, 
    -0.00098582f, 0.11152651f, 0.07996612f, -0.05734403f, 0.01154937f, -0.10806131f, -0.04177336f, 0.02576863f, 
    -0.03069701f, 0.10893857f, -0.00716309f, 0.12032071f, 0.24593136f, 0.01477777f, 0.00398623f, 0.14562102f, 
    0.03595155f, 0.03411422f, -0.00740501f, -0.00048816f, -0.04146911f, -0.02047438f, 0.10139519f, 0.04220773f, 
    -0.24730904f, -0.16644733f, 0.29481173f, 0.18151355f, 0.01607042f, -0.06018359f, -0.07985356f, 0.11932191f, 
    -0.09390183f, -0.07143749f, -0.00218146f, -0.03790472f, -0.37117910f, 0.09508996f, 0.09432704f, -0.15617681f, 
    0.02449386f, 0.20756455f, 0.02366571f, -0.04281992f, 0.05008458f, -0.00245006f, 0.02111640f, -0.01824414f, 
    -0.40635774f, 0.02412197f, 0.18817416f, 0.26144403f, 0.06528667f, 0.05356267f, 0.04828111f, 0.16071351f, 
    0.16162294f, 0.09871329f, 0.12825884f, 0.02268309f, 0.22474371f, -0.12018168f, -0.04916866f, -0.04755645f, 
    0.07108872f, -0.06016732f, 0.05556766f, -0.05240952f, 0.11537985f, 0.00376628f, 0.07360892f, 0.07885555f, 
    0.23116170f, -0.05339564f, 0.00548579f, 0.16476516f, 0.16320466f, -0.05589655f, 0.01403500f, -0.03148415f, 
    -0.09713118f, -0.01448301f, -0.06251626f, 0.04074582f, -0.36689472f, 0.07585590f, -0.05241762f, -0.31126967f, 
    0.07622129f, -0.01219436f, 0.05613619f, 0.08849778f, -0.07602947f, 0.11997022f, -0.02050245f, 0.03362926f, 
    0.02859668f, 0.01449660f, 0.09394842f, 0.03330129f, 0.11497410f, 0.05770042f, -0.02261943f, 0.01134713f, 
    -0.01539832f, -0.05392800f, 0.01483129f, -0.01409262f, 0.07728311f, 0.15613100f, 0.06071147f, 0.03204290f, 
    -0.03642849f, 0.00941722f, 0.03832969f, 0.00316919f, 0.13927449f, 0.06062685f, 0.02278692f, -0.04705293f, 
    -0.11488853f, 0.25226608f, 0.16027905f, 0.25866950f, 0.00240539f, 0.11015910f, -0.02480678f, 0.01319839f, 
    0.09208603f, 0.08307115f, 0.05931916f, -0.06281873f, -0.13930136f, 0.05978149f, -0.01294686f, 0.08052929f, 
    0.06082235f, 0.07044020f, 0.06440371f, 0.04613795f, 0.00012562f, -0.03153794f, 0.00923765f, 0.02894702f, 
    -0.17860796f, 0.06504691f, 0.14473096f, -0.03136938f, 0.18710597f, 0.02819114f, -0.04545025f, 0.10451812f, 
    -0.06400643f, 0.08346875f, -0.03719978f, -0.00583494f, -0.27655384f, -0.13288975f, -0.02262236f, 0.23481537f, 
    0.10373238f, 0.09336282f, -0.01552366f, 0.01463552f, 0.09576564f, 0.11995743f, -0.03127937f, 0.03364480f, 
    0.03390744f, 0.18392439f, 0.14327177f, 0.27654949f, -0.05376018f, 0.09219664f, 0.09051894f, 0.02472461f, 
    0.15822099f, -0.02459748f, 0.05445988f, 0.20015159f, -0.07703261f, 0.09389513f, 0.29087135f, -0.16887107f, 
    -0.06718518f, 0.07555176f, -0.06436938f, -0.07132027f, 0.02409720f, 0.00041930f, -0.06483549f, -0.01045952f, 
    -0.14906564f, -0.01612595f, 0.09954214f, 0.01225891f, 0.02330955f, 0.18967912f, 0.11323912f, 0.03651346f, 
    -0.00625862f, -0.06339785f, -0.01394079f, 0.06498270f, -0.29638639f, 0.06962974f, -0.08747504f, -0.27418387f, 
    0.05752772f, -0.03146031f, 0.02885623f, 0.05041238f, 0.00589572f, 0.09830455f, 0.05156444f, -0.01389073f, 
    -0.28325018f, -0.00658535f, 0.04865317f, -0.08349320f, 0.04604862f, 0.02559382f, -0.01103836f, 0.05630378f, 
    0.06182155f, 0.02882881f, -0.00795120f, -0.02059837f, 0.04315985f, -0.07383612f, -0.25011852f, -0.17451616f, 
    -0.04158939f, 0.05881036f, 0.08241194f, -0.01511631f, -0.01273452f, -0.01988344f, 0.06695631f, 0.10802370f, 
    0.17966664f, 0.03810188f, 0.10258798f, 0.23777843f, 0.05125460f, 0.03922967f, -0.00758945f, 0.09048361f, 
    0.03054159f, 0.06988931f, -0.09439292f, 0.10705227f, -0.28533876f, 0.23597749f, -0.23969671f, -0.29819483f, 
    0.16228779f, -0.05796012f, 0.06495246f, 0.11267054f, -0.01200580f, 0.04288908f, 0.04343817f, 0.09178012f, 
    -0.23682153f, -0.10791265f, -0.13146955f, -0.10549220f, 0.02695297f, -0.03932840f, -0.02579647f, 0.03899061f, 
    0.12732372f, 0.05836165f, 0.07457973f, -0.03343180f, -0.02851501f, -0.00432390f, -0.02421422f, -0.06758301f, 
    0.03610311f, 0.06609104f, -0.02576715f, -0.02846410f, 0.06321096f, 0.08147608f, -0.00451117f, 0.13956696f, 
    -0.32762346f, -0.03143557f, 0.01923897f, -0.22958463f, 0.02315838f, 0.05577654f, 0.02668900f, 0.04763813f, 
    0.04481310f, 0.08886766f, 0.07150119f, 0.11418519f, -0.00700907f, -0.01101220f, 0.00769682f, 0.06329590f, 
    0.06194312f, 0.03181262f, 0.09130976f, 0.16922015f, 0.09856724f, -0.03863650f, -0.00530806f, 0.05880965f, 
    -0.03689478f, -0.02566759f, -0.03076634f, 0.02738051f, 0.01984208f, -0.06084473f, 0.01470567f, -0.01797536f, 
    -0.01519769f, -0.04092691f, -0.02046198f, -0.03129758f, 0.00838017f, 0.00297732f, 0.01281582f, -0.02270729f, 
    -0.04660139f, -0.02803591f, -0.02662285f, 0.01192223f, 0.01357052f, -0.02517090f, -0.01444456f, -0.06202711f, 
    0.00773118f, -0.05746298f, 0.00213190f, -0.01056287f, 0.02697224f, 0.03526095f, -0.05247904f, -0.00542937f, 
    0.00753450f, -0.04449474f, 0.02278101f, -0.00963538f, -0.01483397f, -0.02782565f, 0.02355703f, 0.04164329f, 
    0.01685668f, 0.01401272f, -0.00851440f, 0.04064722f, -0.01223572f, -0.05313116f, -0.01159024f, 0.02436156f, 
    -0.02625319f, 0.02639266f, 0.03699434f, 0.00154882f, -0.00409055f, -0.03845451f, 0.02139748f, -0.00609177f, 
    -0.03379847f, 0.03831141f, 0.03639602f, -0.04700839f, -0.00505528f, 0.00531657f, 0.04748182f, 0.02998523f, 
    0.04617382f, -0.02574063f, 0.01981516f, 0.02801189f, -0.00086200f, 0.03168359f, 0.03099713f, -0.05060196f, 
    0.02587603f, 0.02847794f, 0.04236823f, 0.03834163f, -0.00581003f, -0.01556482f, -0.02259692f, -0.03087577f, 
    0.01237408f, -0.00639392f, -0.01086118f, -0.02045942f, -0.01183497f, -0.05742499f, 0.00787459f, -0.03319525f, 
    -0.01335333f, 0.01588684f, -0.04031174f, 0.00938458f, 0.01966875f, 0.03982294f, 0.02785951f, -0.04351719f, 
    0.00810004f, 0.02868841f, -0.02889936f, -0.02264215f, -0.00967215f, -0.01282431f, -0.05163436f, -0.02518152f, 
    -0.05293486f, -0.05494431f, -0.05726585f, 0.00554883f, -0.04986618f, 0.01192694f, 0.00308110f, -0.03604493f, 
    -0.04985937f, 0.03799729f, -0.01515852f, -0.02876800f, -0.00035502f, -0.03944709f, -0.01224249f, -0.00475579f, 
    -0.04063357f, -0.05196692f, 0.00256390f, 0.02438416f, -0.00383957f, -0.01263705f, -0.03277103f, -0.02972139f, 
    -0.04301783f, -0.02067063f, -0.05474676f, -0.04671529f, 0.02780364f, 0.03816522f, -0.00572185f, -0.02667319f, 
    0.00220761f, 0.00457588f, 0.00322748f, 0.01738746f, -0.01241531f, 0.01552126f, -0.01923894f, -0.04163641f, 
    0.04085232f, -0.01459685f, -0.03996659f, 0.03722348f, -0.05630852f, -0.02554769f, -0.03836438f, 0.03112199f, 
    0.01956832f, -0.03671838f, 0.02397784f, -0.02784728f, 0.02907918f, 0.03557448f, 0.00654674f, -0.04416346f, 
    -0.00541360f, 0.00051680f, 0.02543657f, -0.00240254f, -0.00133219f, 0.02058160f, 0.00359029f, -0.04833469f, 
    -0.00421297f, 0.02989560f, 0.04547795f, -0.04765543f, -0.01402523f, 0.02049972f, 0.01395531f, -0.01830268f, 
    0.02600183f, -0.03050409f, 0.03368445f, 0.02636021f, -0.03313101f, -0.03531275f, 0.03737744f, -0.02075499f, 
    0.00821807f, 0.02088055f, 0.02870266f, -0.04800127f, 0.02197760f, -0.01962868f, 0.02940645f, -0.02782509f, 
    0.02092763f, -0.04621348f, 0.01155550f, 0.01641384f, 0.03318396f, -0.06050012f, 0.01396220f, -0.03325815f, 
    -0.05353468f, 0.03362729f, -0.01903008f, -0.03380971f, -0.00083842f, 0.03427467f, -0.02914248f, -0.03075261f, 
    0.01371840f, 0.00933683f, 0.01833763f, -0.04125958f, -0.04852925f, 0.00360533f, -0.02492362f, 0.02787718f, 
    -0.02357169f, -0.01004467f, 0.04113783f, -0.04257157f, -0.03532115f, 0.04052816f, -0.02654159f, 0.03332316f, 
    0.00164017f, -0.01706403f, -0.02284569f, 0.03847762f, 0.00641172f, -0.01270122f, -0.03063921f, 0.00730075f, 
    0.02929312f, -0.04754952f, 0.00992420f, -0.01913672f, -0.04348042f, 0.02340832f, -0.02699641f, 0.04131708f, 
    -0.00719710f, -0.01485188f, 0.02491239f, -0.05502492f, 0.03091156f, -0.05976072f, -0.00081308f, 0.02469571f, 
    -0.00409739f, 0.01861748f, -0.00016638f, 0.02331853f, -0.01731973f, -0.04129372f, -0.01581560f, -0.04214172f, 
    -0.04111791f, 0.02100827f, 0.02934074f, -0.03701268f, -0.00432933f, -0.01308266f, -0.04880605f, 0.05366660f, 
    0.01966769f, 0.03159460f, 0.02982666f, -0.02762065f, -0.02869044f, -0.03781806f, -0.03788852f, 0.03083615f, 
    -0.03907114f, -0.00525041f, 0.01643283f, -0.05759352f, -0.01892573f, -0.02214052f, -0.02388835f, 0.02821919f, 
    -0.01973417f, -0.04671166f, 0.01195321f, 0.00094496f, -0.02204741f, 0.04067039f, 0.00408975f, 0.02131904f, 
    -0.01168596f, -0.02501035f, 0.00974228f, -0.00857092f, 0.04498870f, 0.02032588f, 0.01894055f, 0.00808517f, 
    -0.01190929f, -0.02973573f, -0.03171362f, -0.05379265f, -0.04681584f, 0.03786498f, 0.00668365f, 0.03611397f, 
    -0.01661065f, -0.04648089f, 0.00403624f, 0.03246747f, -0.03652949f, 0.02501065f, -0.02152514f, -0.02216283f, 
    -0.03523827f, -0.04848142f, 0.03332061f, 0.00555142f, 0.01932409f, 0.01488510f, -0.03532058f, -0.05188872f, 
    -0.04497931f, -0.00099239f, 0.03701500f, -0.05307686f, -0.06309858f, 0.01307014f, -0.00780706f, 0.03951911f, 
    -0.00615179f, -0.04575826f, 0.00831753f, -0.06218980f, 0.02659134f, -0.02438879f, -0.04401842f, -0.05915984f, 
    -0.00359232f, 0.00499114f, -0.00984905f, -0.05341075f, -0.05929825f, -0.04407134f, 0.03950216f, -0.04154263f, 
    0.02173040f, 0.01333244f, -0.04044009f, -0.05543683f, 0.01262624f, -0.03549768f, -0.04992307f, -0.01108205f, 
    0.00101036f, 0.04378380f, -0.01175789f, -0.06046059f, 0.02195632f, -0.04656100f, 0.01823982f, 0.03029997f, 
    0.00286082f, 0.03605757f, 0.01493761f, -0.02709107f, -0.03673623f, -0.01736648f, -0.00093869f, -0.01227534f, 
    0.01934073f, -0.03575194f, 0.03083259f, -0.02999352f, -0.00686285f, 0.03146996f, 0.00480746f, -0.04085357f, 
    -0.04349499f, -0.06098251f, -0.04504289f, -0.02806425f, 0.03309467f, -0.02958226f, -0.01054232f, -0.01895590f, 
    0.05167791f, -0.12105127f, 0.08990914f, 0.20209946f, -0.05409675f, 0.04593306f, 0.04440236f, 0.05516184f, 
    0.00003332f, -0.01106634f, 0.05689232f, 0.02890216f, -0.03575384f, 0.03685410f, -0.12161367f, 0.05172599f, 
    0.00102497f, -0.03935715f, 0.03047264f, -0.00140232f, 0.03978755f, -0.04291987f, 0.02860171f, 0.06954736f, 
    -0.12508993f, -0.03595283f, -0.01503717f, -0.26342744f, 0.02278030f, 0.10989967f, 0.03850662f, 0.06374219f, 
    0.00839449f, 0.05414944f, -0.01224147f, -0.07161830f, 0.16416554f, -0.14641161f, 0.08090477f, -0.05776163f, 
    -0.04934302f, 0.07499421f, -0.04804182f, -0.11465833f, 0.03166220f, 0.03629186f, -0.08403724f, 0.03624431f, 
    -0.13743111f, -0.04364263f, -0.07834940f, 0.20238999f, 0.01276753f, -0.02044192f, -0.06990455f, -0.08969924f, 
    0.14569125f, 0.01540989f, 0.07325868f, -0.11571668f, 0.19214343f, 0.07124893f, 0.07715739f, -0.02816450f, 
    0.02778105f, 0.02928294f, 0.01132050f, -0.00391911f, 0.05754566f, -0.02641070f, -0.02394769f, -0.01006673f, 
    -0.01815333f, 0.13188097f, -0.11573299f, 0.02802979f, -0.05751251f, 0.01420261f, 0.01960369f, -0.00141782f, 
    0.08088564f, -0.04435079f, 0.12151197f, -0.08717640f, 0.00238008f, 0.08320596f, 0.07563899f, 0.00265065f, 
    0.02189833f, 0.01508222f, 0.04592553f, -0.07902042f, -0.09355194f, 0.08397244f, -0.03156551f, -0.04663865f, 
    0.15941525f, 0.26254284f, 0.00843181f, 0.10019080f, -0.01236248f, -0.01529044f, 0.07975060f, 0.01115283f, 
    0.18380490f, 0.03833658f, 0.09222796f, 0.09416735f, 0.39024347f, 0.08471096f, -0.03176650f, -0.04574539f, 
    -0.05328794f, -0.08863086f, -0.07065361f, -0.06063558f, -0.02406332f, 0.03209768f, 0.01744589f, 0.10675149f, 
    0.37298632f, -0.18424886f, -0.03375894f, 0.13035649f, -0.14766748f, 0.02312248f, -0.03922620f, -0.01541598f, 
    -0.04871723f, 0.07743198f, -0.06391896f, 0.02231354f, -0.51187605f, -0.06639985f, 0.14571506f, 0.02957945f, 
    -0.06650665f, 0.05442690f, 0.03836480f, -0.07359875f, 0.04026575f, 0.10794967f, 0.05616933f, 0.02613584f, 
    0.02290209f, 0.06652319f, 0.08764666f, 0.16670482f, 0.00724601f, 0.10726268f, 0.04443165f, 0.03212545f, 
    0.06642988f, 0.05948555f, 0.03672926f, -0.06040950f, 0.35214826f, -0.19224256f, 0.01429085f, 0.13308617f, 
    -0.07415558f, -0.04056617f, -0.01931631f, -0.07864694f, 0.10571051f, -0.02407331f, 0.03601737f, 0.10308693f, 
    0.07847998f, -0.24559882f, 0.06111351f, 0.24068943f, -0.02342573f, -0.13206211f, 0.01847955f, -0.00170092f, 
    0.08640448f, 0.02514033f, -0.02071268f, 0.20909342f, -0.10859699f, 0.01405795f, -0.01396914f, 0.00898429f, 
    0.07872056f, -0.09932947f, -0.02026904f, -0.00878213f, -0.04657726f, -0.07749288f, -0.03068111f, 0.01706466f, 
    0.12502584f, 0.04132256f, -0.14309409f, -0.00186893f, 0.00373775f, -0.12348409f, 0.02532004f, -0.02892684f, 
    -0.06278042f, -0.05806295f, -0.04340113f, -0.07189976f, -0.25176254f, 0.11173863f, -0.05894255f, 0.05958639f, 
    0.02368242f, -0.06455121f, -0.11648328f, 0.05664302f, 0.01780111f, -0.07517119f, 0.03654800f, 0.03834013f, 
    0.24371733f, 0.01908823f, -0.05275308f, 0.01808108f, -0.04705008f, -0.02412070f, -0.05704904f, 0.01485678f, 
    -0.01192613f, 0.01008209f, 0.02152636f, 0.04786112f, 0.29780203f, -0.10014503f, -0.08324187f, -0.18870120f, 
    0.07528950f, -0.04823279f, -0.04102563f, 0.05769257f, 0.01069587f, -0.03016194f, 0.03710805f, -0.00231993f, 
    0.02579430f, -0.01179992f, 0.02826481f, 0.07853983f, 0.03041474f, -0.01096278f, -0.06076583f, -0.01752070f, 
    -0.11467864f, 0.05253256f, -0.05399532f, -0.12110945f, 0.35077152f, 0.12457102f, -0.28140622f, 0.08507477f, 
    0.06695310f, 0.02602318f, -0.03044859f, 0.13480714f, -0.00175215f, -0.15527226f, 0.01773467f, 0.00835651f, 
    0.16596963f, 0.20919463f, -0.04104444f, 0.03057131f, -0.06905413f, -0.06998661f, -0.09326425f, 0.09957349f, 
    -0.01033865f, 0.02125243f, 0.02750921f, 0.03772659f, 0.15216352f, 0.05287572f, 0.02090480f, 0.09139268f, 
    -0.03352675f, 0.03535766f, -0.01974867f, 0.07548942f, 0.06414822f, -0.00647587f, -0.08439250f, -0.11683309f, 
    0.38959575f, -0.07928743f, 0.00131552f, 0.18547225f, -0.12342212f, -0.00622128f, -0.01030497f, -0.04971112f, 
    -0.03702191f, -0.02400112f, 0.02700231f, 0.02191225f, 0.17251769f, -0.06590334f, -0.00656891f, -0.19613521f, 
    0.14602599f, -0.06101866f, -0.05380776f, -0.13177367f, 0.05596184f, -0.00109273f, 0.00666074f, -0.06323694f, 
    -0.20503700f, 0.05436224f, 0.00092532f, -0.02036922f, 0.08559198f, 0.09622953f, 0.00203969f, -0.00977829f, 
    0.02795780f, 0.04790888f, 0.18643850f, 0.03859368f, 0.06993654f, -0.08067669f, 0.09945605f, -0.02750024f, 
    -0.04346082f, 0.09204324f, -0.04094585f, -0.04625369f, 0.02417365f, 0.02419189f, -0.03038976f, 0.00174322f, 
    0.04819229f, -0.01941869f, -0.09088865f, 0.13702539f, 0.09623707f, -0.04925854f, 0.11086458f, 0.03836051f, 
    0.01300284f, 0.06166296f, -0.08838490f, -0.01595668f, 0.07396889f, 0.01374494f, -0.21348481f, -0.20681977f, 
    0.02587379f, 0.09765487f, -0.06054227f, 0.03783190f, 0.06278856f, -0.12570806f, -0.10427750f, -0.06402956f, 
    0.18596584f, 0.08080073f, 0.09408764f, 0.01588892f, -0.02535620f, 0.01076773f, 0.08914128f, -0.02383855f, 
    0.04553142f, -0.13128440f, -0.00039411f, 0.02732360f, -0.12196784f, -0.25546786f, 0.24686332f, 0.14850311f, 
    -0.03151231f, 0.12101595f, 0.08479765f, -0.03797148f, -0.06740849f, 0.05150146f, 0.05219433f, 0.04445578f, 
    -0.07130400f, -0.09369235f, 0.34791589f, 0.16013741f, -0.03595062f, 0.08831064f, -0.04605713f, 0.03315209f, 
    -0.01011390f, 0.02883472f, -0.04974458f, -0.08996721f, 0.22889222f, -0.03646608f, 0.06226479f, 0.28193107f, 
    -0.18501027f, 0.12163106f, -0.00529897f, 0.03495710f, 0.01298028f, 0.08308689f, -0.00465061f, 0.08312922f, 
    0.31627819f, -0.09878447f, 0.03462014f, -0.20687389f, 0.03226432f, 0.07623458f, -0.05065493f, 0.06093077f, 
    0.04020091f, 0.05434350f, -0.02102422f, 0.05849705f, 0.28757271f, -0.18271022f, -0.12775993f, 0.19389892f, 
    -0.05769947f, 0.00323501f, 0.00670718f, -0.02501543f, 0.11299455f, 0.01716103f, 0.09706835f, -0.01656307f, 
    0.18152918f, -0.02527389f, -0.02033956f, -0.04161659f, -0.05098769f, 0.05184846f, 0.02205021f, 0.06526281f, 
    0.09812807f, 0.07199870f, -0.02692492f, -0.00967138f, -0.11577886f, -0.00195737f, -0.01769202f, 0.05348627f, 
    -0.11897955f, 0.04576020f, 0.05334345f, 0.01147520f, 0.02623582f, -0.05203614f, -0.05819102f, 0.07603642f, 
    0.11398743f, 0.08906572f, -0.03362551f, 0.17721152f, -0.03500518f, 0.13866879f, -0.00525431f, 0.00359983f, 
    -0.00219886f, 0.01973303f, 0.08013713f, -0.09081963f, 0.03015089f, 0.14831223f, 0.11193585f, -0.19221258f, 
    -0.00175891f, 0.04194542f, 0.10245509f, 0.05810897f, 0.03178319f, 0.01158503f, 0.02780200f, -0.00852174f, 
    -0.29682672f, 0.26362747f, 0.03319624f, -0.10033726f, 0.00632690f, 0.02185664f, 0.08463506f, 0.08331187f, 
    0.07654766f, 0.03016290f, -0.01026485f, -0.03916526f, 0.16805245f, -0.23661445f, -0.12948669f, 0.19360749f, 
    -0.09826052f, -0.01363312f, -0.06563351f, 0.08809890f, 0.03426958f, 0.03578263f, 0.00251803f, 0.05334494f, 
    -0.07571166f, -0.08884993f, 0.01942961f, -0.08449801f, -0.06959963f, -0.03680693f, -0.04775730f, 0.08639172f, 
    -0.09138405f, -0.01554269f, -0.05225332f, -0.06806591f, 0.00258044f, 0.20219859f, 0.01831102f, -0.07022355f, 
    -0.06814135f, 0.01987579f, 0.03966524f, 0.01362525f, -0.00594673f, -0.04775643f, 0.01638005f, -0.02098377f, 
    0.00061729f, -0.00958043f, 0.07506310f, -0.04154009f, -0.02255712f, 0.00526389f, 0.08647148f, 0.06838454f, 
    0.01714569f, 0.18469210f, 0.08155596f, 0.01941250f, 0.11064175f, -0.24124505f, 0.00505695f, 0.17499694f, 
    -0.17961392f, -0.00549315f, 0.01319486f, -0.03740150f, 0.06060106f, 0.03162543f, 0.08227535f, 0.11401182f, 
    0.14871307f, -0.24177344f, 0.16111560f, -0.05744223f, -0.05055182f, 0.11652640f, 0.10361697f, 0.00430219f, 
    0.06435866f, 0.05547874f, -0.09083771f, 0.09178453f, 0.12201463f, 0.15687990f, 0.13080171f, 0.05298187f, 
    0.10462385f, 0.01903789f, 0.01733621f, 0.02586973f, -0.02987384f, -0.01745244f, -0.05540445f, 0.03038690f, 
    0.03346161f, -0.03609847f, 0.14968197f, 0.10248464f, 0.01218690f, 0.01899141f, 0.00459542f, -0.01004520f, 
    -0.01432838f, -0.03470025f, 0.05461679f, -0.04602856f, -0.35018623f, 0.14336060f, 0.08420150f, 0.04505483f, 
    0.04917523f, -0.00020041f, -0.00647382f, 0.01788528f, 0.03198879f, 0.10586879f, -0.03830552f, 0.08916997f, 
    -0.38058183f, 0.19327614f, -0.04187381f, 0.07903150f, 0.00184541f, 0.06285952f, 0.01124570f, -0.03934421f, 
    0.08385250f, -0.01724527f, -0.03789850f, 0.05225695f, 0.18469998f, -0.25518608f, 0.09382839f, -0.23188661f, 
    0.05997869f, -0.03301889f, 0.17487144f, 0.05259907f, 0.02323959f, -0.04377471f, 0.03810260f, 0.00978893f, 
    0.04858617f, -0.24567488f, 0.06097097f, -0.14598769f, -0.01478995f, 0.04346916f, 0.06168833f, 0.13953705f, 
    -0.10868864f, 0.00932407f, -0.03361380f, 0.07432467f, -0.17561494f, 0.03253908f, -0.10443866f, 0.19613807f, 
    0.12187768f, -0.03926777f, 0.11531635f, 0.04279170f, 0.03946319f, 0.05707549f, -0.09046364f, 0.03548060f, 
    0.41675746f, -0.26451784f, -0.06185039f, 0.12200667f, -0.04208658f, 0.02407811f, -0.03092659f, 0.10315496f, 
    0.00433983f, -0.01117358f, -0.10189380f, -0.01635201f, 0.20992899f, -0.09357537f, -0.00172023f, 0.19206685f, 
    -0.04149603f, 0.07417652f, -0.05097633f, 0.01331351f, 0.04705648f, 0.08550530f, 0.05882364f, -0.00937030f, 
    0.02484317f, 0.14886795f, 0.15819888f, 0.13219038f, -0.09467626f, 0.01360149f, 0.00557727f, 0.00113104f, 
    -0.07570708f, -0.02700473f, 0.04978471f, 0.09517188f, 0.11225610f, -0.12175648f, -0.01980158f, -0.20277360f, 
    -0.06529292f, -0.05048515f, 0.12588930f, -0.05941617f, 0.04496952f, 0.03124455f, 0.08576567f, 0.10701862f, 
    0.06393838f, 0.12547576f, -0.06521669f, -0.19153665f, -0.01999151f, -0.02960633f, -0.03068548f, -0.07435393f, 
    0.00059493f, -0.00295881f, -0.02143723f, 0.06033736f, 0.24153182f, -0.15922482f, -0.03205344f, 0.30471823f, 
    -0.13510311f, 0.05847701f, 0.05386880f, 0.04525951f, -0.00408216f, -0.00448795f, 0.03034445f, -0.11495326f, 
    0.11737508f, -0.04326096f, -0.03540796f, -0.01323863f, -0.03715565f, -0.06253613f, 0.08250751f, 0.02010719f, 
    -0.07110799f, 0.04403117f, 0.05918879f, 0.06480935f, 0.19274297f, 0.10477243f, -0.05641706f, -0.21541281f, 
    0.03341545f, 0.02059447f, -0.03754244f, 0.01457737f, 0.07472377f, -0.03684089f, -0.02747135f, -0.04070399f, 
    0.02066340f, -0.03458218f, 0.05273770f, 0.16736053f, -0.08536122f, -0.00618337f, -0.00519815f, 0.02041811f, 
    0.03876514f, 0.01142864f, -0.02158730f, -0.00980417f, 0.08588537f, 0.12233010f, -0.02510626f, 0.04279738f, 
    0.05714503f, -0.01758309f, 0.05673786f, 0.02867527f, -0.00971505f, -0.02544577f, -0.01443255f, -0.09932557f, 
    0.04289992f, -0.15663324f, 0.04411238f, 0.24778770f, -0.03623321f, -0.02263732f, 0.02329903f, 0.01208902f, 
    0.01128359f, 0.13341559f, -0.04705163f, 0.05203823f, -0.11446074f, 0.02714615f, -0.20334318f, 0.03759405f, 
    0.14710386f, -0.07923602f, -0.05590924f, 0.05327303f, -0.01997361f, 0.01064883f, 0.11494579f, -0.00853717f, 
    -0.35027248f, 0.18627495f, -0.02829378f, -0.18082936f, -0.08286609f, 0.06278415f, 0.18070464f, 0.04751753f, 
    -0.06385942f, 0.08212792f, -0.05152384f, -0.02012153f, -0.03716726f, -0.09305754f, -0.01415541f, 0.14539188f, 
    0.02109355f, -0.09245256f, 0.02976280f, 0.12023432f, 0.00458366f, 0.01158096f, -0.02978771f, 0.07892404f, 
    -0.01633753f, 0.05969512f, 0.09225287f, -0.09910225f, 0.01396406f, 0.06424026f, -0.02678856f, 0.07494704f, 
    -0.06745107f, 0.03427361f, 0.05299056f, -0.10677508f, 0.01421136f, 0.02718890f, -0.10751497f, -0.02883208f, 
    -0.02535513f, 0.05298201f, 0.05439002f, 0.04331889f, 0.01635687f, 0.00754190f, 0.00341747f, 0.02156561f, 
    -0.11024611f, 0.17538331f, -0.07016989f, -0.02170595f, 0.04114364f, 0.02402129f, -0.03242064f, -0.02910636f, 
    -0.05181355f, -0.02546197f, 0.01108471f, -0.15023719f, 0.20040222f, 0.11620981f, 0.08934528f, -0.02900621f, 
    -0.08561306f, -0.18303978f, 0.00259906f, -0.01858663f, -0.05639412f, -0.07824891f, -0.08775845f, -0.02526494f, 
    -0.13761003f, 0.04722502f, 0.09227180f, 0.16693100f, -0.14985384f, -0.07807001f, 0.05208237f, -0.05454523f, 
    0.09603165f, -0.04670479f, -0.06622455f, -0.05516442f, 0.03610228f, -0.25308561f, -0.16996545f, -0.15654247f, 
    0.01042638f, 0.02748008f, -0.13395351f, 0.00136259f, -0.00840811f, 0.08425107f, 0.05302894f, -0.02704048f, 
    -0.10000670f, -0.13253649f, -0.03950874f, -0.00592834f, -0.00928323f, -0.05222351f, -0.04058043f, -0.07678517f, 
    0.15100674f, 0.02860779f, 0.13558847f, 0.05049005f, -0.04457308f, 0.24985741f, -0.00581593f, -0.11021563f, 
    0.01585598f, 0.00257373f, 0.01744825f, 0.11208885f, -0.08855577f, 0.04137991f, -0.09147651f, -0.04628909f, 
    0.25209481f, 0.12721133f, 0.00873650f, 0.09052375f, 0.10230973f, 0.12136680f, 0.04042243f, 0.02015075f, 
    -0.03085796f, 0.05926043f, 0.09910870f, -0.03809303f, 0.11074254f, -0.16085650f, -0.02626574f, 0.10089949f, 
    0.04491818f, 0.01788696f, 0.04129296f, 0.06321765f, -0.03319410f, 0.10207931f, 0.01492406f, 0.16709426f, 
    -0.01045971f, -0.14947958f, -0.00563588f, 0.11692155f, -0.11430566f, -0.13483892f, 0.02238180f, -0.02782762f, 
    0.13496332f, -0.07554082f, 0.19149034f, 0.07466266f, 0.05543797f, 0.01244190f, -0.04142316f, 0.15479639f, 
    0.12443016f, -0.07994247f, 0.00402483f, 0.11444454f, 0.01836666f, 0.09848902f, 0.03122236f, 0.06380566f, 
    -0.12082577f, 0.01978439f, 0.19422476f, 0.12260551f, -0.00147226f, -0.00174590f, 0.05886938f, -0.04384933f, 
    -0.05439655f, 0.10800580f, 0.15010767f, -0.02415837f, -0.22717591f, 0.13291563f, -0.03364331f, 0.00696440f, 
    -0.11220156f, -0.04692017f, -0.04662854f, 0.09177580f, -0.02463937f, 0.07037156f, 0.07346775f, 0.06855603f, 
    -0.18452021f, 0.14308874f, -0.05268307f, 0.17251725f, 0.06168012f, -0.06421935f, -0.05466030f, 0.06647644f, 
    0.09725416f, 0.10516168f, 0.04038938f, 0.01820325f, -0.08696890f, 0.04023131f, -0.12193428f, 0.04573409f, 
    -0.04246830f, -0.00713201f, 0.21797998f, -0.12369479f, 0.10251486f, 0.04573544f, -0.03694874f, 0.03983698f, 
    -0.01816912f, 0.01073735f, 0.05681246f, -0.06867801f, 0.09744127f, 0.07852861f, -0.17586865f, 0.06989305f, 
    0.09611098f, -0.00253104f, -0.03328053f, -0.02536098f, 0.16165280f, 0.25901183f, 0.16022547f, 0.18352839f, 
    -0.02784470f, -0.05739734f, -0.08850695f, 0.02746774f, 0.19817497f, 0.05079470f, -0.02142368f, 0.01188676f, 
    -0.06295849f, 0.01934597f, -0.21981321f, -0.02225503f, 0.03454026f, 0.10613775f, -0.07071458f, -0.10521524f, 
    0.02047555f, 0.03183028f, 0.02727511f, 0.02686645f, 0.14397961f, -0.07418616f, -0.06543045f, 0.01427291f, 
    -0.00285904f, 0.12869346f, -0.05028398f, 0.04704509f, 0.06393246f, 0.10037526f, 0.08331589f, 0.02024376f, 
    0.04408360f, 0.08074024f, 0.10524478f, 0.06609040f, 0.03142644f, 0.08016614f, -0.01321454f, -0.03022524f, 
    0.08762000f, -0.01263340f, -0.01889924f, 0.04949080f, 0.02355872f, -0.01118841f, 0.01304346f, 0.12201684f, 
    0.02810837f, 0.03660390f, 0.10581747f, -0.09695113f, -0.05464029f, 0.00222683f, 0.00124664f, -0.12774225f, 
    0.08298769f, 0.01285467f, -0.01735531f, -0.28759259f, 0.13762726f, -0.07204546f, 0.05986067f, 0.01139408f, 
    0.06250511f, 0.07075147f, 0.14590815f, 0.01041290f, 0.19958806f, -0.03045508f, 0.10324518f, -0.10592785f, 
    -0.08701634f, -0.04709074f, -0.11249223f, 0.01997492f, 0.06660207f, 0.04583641f, -0.06551474f, 0.05760021f, 
    0.02262738f, 0.14669861f, 0.16654484f, 0.11940398f, 0.00124724f, 0.02426090f, -0.00662111f, 0.13587321f, 
    -0.05999110f, 0.04418853f, 0.06574669f, -0.00876344f, 0.14692537f, 0.24219365f, -0.00659174f, 0.18368295f, 
    -0.13059671f, -0.00306928f, 0.04222193f, -0.03970332f, -0.06627217f, -0.01061865f, 0.02236910f, 0.01090469f, 
    -0.08810021f, -0.03191566f, -0.13526167f, 0.01255195f, -0.08866611f, -0.05528596f, -0.08421092f, 0.01333488f, 
    -0.02151716f, -0.09881996f, 0.07193673f, -0.06341721f, -0.41715014f, 0.23721451f, 0.03001476f, 0.05436467f, 
    0.06765629f, 0.00100502f, 0.03482570f, -0.01046629f, 0.06464460f, -0.02091299f, 0.03610918f, 0.03157053f, 
    -0.00352816f, -0.04012977f, -0.02041684f, 0.11202213f, 0.07077996f, -0.03751027f, -0.04501490f, -0.09522501f, 
    0.03141962f, -0.01648832f, -0.14745149f, -0.06851304f, 0.05727688f, 0.22666810f, 0.14421187f, -0.04833246f, 
    -0.00311966f, 0.07295388f, 0.05717093f, 0.03998069f, -0.08946816f, 0.04779409f, -0.08471683f, -0.08047250f, 
    -0.13816468f, 0.09057745f, 0.03719164f, 0.28245595f, 0.07133073f, -0.02783245f, 0.00446453f, 0.08783530f, 
    -0.05382764f, -0.09675271f, 0.16921449f, 0.02962080f, -0.21420652f, -0.14967474f, -0.06654317f, -0.03331663f, 
    0.04119791f, 0.06462383f, 0.08880802f, -0.01660170f, 0.03285389f, -0.06752028f, -0.05089551f, 0.00263336f, 
    0.06543998f, 0.03966357f, 0.14747471f, -0.13677374f, 0.08535650f, -0.06723578f, 0.06576867f, -0.09398827f, 
    -0.11044663f, 0.21699281f, -0.07817388f, 0.11464892f, -0.24614492f, 0.11911888f, -0.11702562f, 0.05965099f, 
    -0.00196994f, -0.02545054f, 0.00115605f, 0.03178329f, 0.02705141f, 0.01874465f, 0.14119120f, -0.01960786f, 
    0.10304021f, -0.00660553f, 0.13029553f, -0.15346701f, -0.01411351f, -0.01439667f, 0.02566969f, 0.04046512f, 
    -0.03738875f, 0.07825791f, 0.32148051f, 0.27028942f, 0.01441695f, 0.11121067f, -0.03905770f, 0.21847896f, 
    0.00586712f, 0.03563030f, 0.01202661f, 0.05433119f, 0.08861514f, 0.02412872f, 0.05985104f, 0.05179685f, 
    0.02029010f, -0.17058708f, 0.05631772f, 0.14029691f, -0.01614833f, 0.10143566f, 0.06374403f, 0.06026521f, 
    -0.00347256f, 0.12536910f, -0.06301326f, -0.02809411f, -0.08500850f, 0.02718916f, 0.12429111f, -0.14108720f, 
    0.00529798f, 0.09499673f, 0.03707907f, 0.04181406f, -0.05184422f, 0.12194337f, 0.02985935f, -0.10982586f, 
    0.09078570f, 0.12099336f, -0.04312463f, 0.24025014f, 0.06966400f, -0.01855161f, -0.12261733f, 0.08287647f, 
    0.03074821f, -0.10237378f, 0.00829697f, -0.03374061f, 0.09632849f, -0.04465925f, -0.09104887f, -0.00750127f, 
    0.03347077f, 0.03552691f, 0.05525012f, 0.22392933f, 0.05233623f, 0.12504514f, 0.04662272f, 0.08466089f, 
    0.17713955f, 0.17704262f, -0.09926755f, 0.00466515f, -0.14915438f, -0.08239242f, -0.06673383f, -0.04215365f, 
    -0.15594536f, -0.12942155f, -0.13299455f, -0.09736372f, -0.03773800f, 0.11990442f, -0.09229886f, -0.16626297f, 
    -0.09429436f, 0.11151207f, 0.06527448f, -0.00976280f, -0.02055934f, -0.07144179f, -0.00207592f, -0.01920461f, 
    0.00620370f, 0.08568960f, -0.21697359f, 0.14384720f, -0.01372669f, -0.01806058f, -0.06213759f, 0.10217049f, 
    -0.11967828f, -0.11294477f, -0.03006638f, -0.13954200f, -0.12810972f, 0.12068550f, 0.14608286f, -0.07082649f, 
    -0.08581582f, -0.02357332f, 0.09736671f, -0.03990431f, 0.02179491f, 0.03074997f, -0.01800602f, -0.13154243f, 
    0.19761711f, 0.05730272f, 0.02862154f, 0.02302716f, -0.12069541f, 0.07032275f, -0.07799710f, 0.17017747f, 
    -0.14222953f, 0.22394730f, 0.09854501f, 0.05957752f, -0.02099499f, -0.06826223f, 0.31096074f, 0.16376138f, 
    -0.04406066f, -0.04155514f, 0.07091409f, -0.10187105f, 0.12065822f, 0.04160664f, -0.19118029f, -0.01852923f, 
    -0.05887490f, -0.03531475f, 0.17294873f, -0.05965316f, 0.10924836f, -0.07128593f, -0.05295822f, 0.03685987f, 
    -0.04796102f, 0.02156218f, 0.07547433f, -0.09176471f, -0.02737560f, 0.20368825f, -0.17728230f, 0.33209634f, 
    -0.05900605f, 0.09877089f, 0.03095183f, -0.04519795f, -0.06424043f, 0.08241868f, -0.08529866f, -0.08441387f, 
    0.11516830f, 0.17808904f, -0.00990369f, 0.00212878f, 0.04079147f, -0.02975722f, 0.10475107f, -0.08027044f, 
    0.05286711f, -0.05939843f, 0.04477929f, 0.11028201f, -0.02791407f, -0.09199666f, -0.05851962f, -0.10406943f, 
    0.01972496f, 0.07392801f, 0.03965750f, -0.12509359f, 0.03753035f, 0.05206443f, 0.10281330f, -0.05336098f, 
    0.10578970f, 0.15142603f, -0.00190276f, 0.05270290f, 0.05988985f, 0.09281396f, 0.08499498f, 0.05728108f, 
    0.09438626f, -0.01485036f, 0.13983530f, 0.03582171f, -0.06809688f, -0.02360547f, 0.02320604f, -0.00874598f, 
    0.02799666f, 0.04978918f, -0.05844605f, -0.07056189f, -0.08311153f, 0.07958452f, -0.02331576f, 0.01033196f, 
    0.11629636f, -0.03830616f, -0.06220181f, 0.04881814f, 0.07339437f, 0.09636091f, -0.04026876f, 0.02752171f, 
    0.03745684f, 0.05026577f, -0.02651581f, 0.07414164f, -0.33934847f, -0.00620916f, -0.01500792f, 0.17243591f, 
    -0.09341078f, 0.03667678f, 0.11711749f, 0.02859228f, -0.02212158f, 0.09363372f, 0.13344553f, 0.09636055f, 
    0.23327170f, 0.06340971f, 0.05897238f, 0.07126888f, 0.01097644f, -0.09402677f, 0.00087128f, -0.00800863f, 
    -0.13867109f, -0.07299659f, -0.07295100f, 0.00138476f, 0.12654875f, 0.00526500f, 0.00220814f, -0.11873715f, 
    0.02897485f, -0.05528540f, 0.09119435f, 0.02200258f, 0.02428502f, 0.00862698f, 0.05018777f, -0.04698773f, 
    0.00559872f, 0.28195527f, 0.10353418f, -0.02857322f, -0.10094074f, 0.13846068f, -0.09315474f, 0.01055483f, 
    -0.10362060f, -0.01329547f, 0.01757107f, 0.06171868f, -0.28994846f, -0.15158376f, 0.06735517f, 0.12022360f, 
    -0.07753596f, -0.01891169f, 0.06016397f, 0.01979780f, -0.05710526f, 0.12649818f, 0.04121047f, 0.12135140f, 
    -0.20507519f, 0.02714702f, -0.03474102f, -0.02005667f, -0.05623411f, -0.03026312f, 0.01513971f, 0.10180081f, 
    -0.06442001f, 0.06175788f, -0.00653218f, 0.03985000f, 0.31487104f, 0.11457681f, -0.14479533f, -0.02140017f, 
    0.06121974f, 0.00089269f, -0.04249178f, 0.12020323f, 0.05967967f, 0.06191601f, 0.03707692f, 0.12310071f, 
    0.03850339f, -0.03725671f, 0.03012557f, 0.00978343f, 0.03285470f, 0.02684261f, -0.00589016f, 0.04372783f, 
    -0.03790482f, -0.02025879f, 0.00813828f, -0.03788099f, -0.02982018f, -0.04592638f, -0.02893111f, -0.03351377f, 
    -0.02902931f, -0.00273748f, 0.01914152f, -0.05400294f, -0.05341908f, -0.04115663f, 0.01940249f, -0.00543529f, 
    0.01422630f, -0.02429660f, -0.04176114f, -0.04691152f, -0.04070345f, 0.02431236f, 0.01698050f, -0.01169930f, 
    0.00672933f, -0.03829311f, 0.01411265f, 0.00591900f, -0.02876008f, 0.02267974f, -0.04549900f, 0.01997311f, 
    -0.01379540f, -0.03573055f, -0.04483474f, 0.02194096f, -0.00148529f, -0.03491264f, 0.01588177f, -0.00221506f, 
    0.01217657f, 0.02616631f, -0.03827620f, 0.04030517f, 0.03002223f, -0.04776009f, -0.02151352f, 0.01308114f, 
    0.03987430f, -0.01412817f, 0.04174111f, 0.01943563f, -0.02501533f, -0.03002590f, -0.05378020f, -0.03105551f, 
    0.00104806f, -0.03406427f, 0.03229782f, -0.01455193f, 0.04224753f, -0.01952831f, -0.03969767f, -0.02805371f, 
    -0.00555337f, -0.01785393f, -0.05444168f, 0.03731649f, -0.01576872f, 0.00526346f, -0.01558691f, -0.01295379f, 
    0.01117804f, -0.04110561f, 0.03269359f, -0.03470217f, 0.04287644f, -0.01350133f, 0.01715958f, 0.01374222f, 
    0.04269022f, -0.02923166f, 0.01890117f, 0.02221840f, 0.03089522f, -0.02176914f, -0.03069818f, -0.04977445f, 
    -0.01628864f, -0.05562915f, 0.03028510f, 0.04278149f, -0.03742488f, -0.05108786f, -0.05100362f, -0.03516572f, 
    -0.04432646f, -0.03003032f, -0.01376830f, 0.03946800f, 0.03451840f, 0.01931616f, 0.03534909f, 0.03144198f, 
    0.02677891f, -0.05086816f, 0.01402135f, 0.01972700f, -0.03614164f, -0.00483542f, 0.04553626f, 0.00611537f, 
    -0.00366890f, 0.01856793f, 0.00987319f, 0.01810740f, 0.01122915f, -0.00457448f, 0.01856678f, 0.00997530f, 
    -0.02441090f, 0.02392969f, 0.00055770f, 0.04451750f, -0.05029374f, -0.01352613f, -0.01399623f, 0.00721261f, 
    -0.05160047f, 0.01300681f, -0.04662513f, -0.03055768f, 0.04346259f, -0.01929802f, -0.00090736f, 0.00431146f, 
    -0.04930891f, -0.01226322f, -0.01232362f, 0.01190147f, -0.04637177f, 0.02094680f, 0.02364459f, -0.02180731f, 
    0.01805917f, 0.01678561f, -0.04555202f, 0.00675380f, -0.00057402f, -0.00294799f, 0.01008448f, -0.00966723f, 
    -0.01281788f, 0.01478150f, -0.01744475f, -0.03414306f, -0.03495841f, 0.03805123f, -0.00160101f, -0.00001948f, 
    -0.04741518f, 0.00140931f, 0.03427079f, -0.02166494f, -0.05577145f, 0.00177133f, -0.04869074f, 0.04015129f, 
    -0.03144752f, 0.01388486f, 0.00715969f, -0.01664254f, -0.02430759f, -0.02750351f, 0.03696537f, 0.04247145f, 
    0.03244692f, -0.00042264f, -0.01959156f, -0.02330898f, -0.03124999f, 0.04395350f, 0.00721726f, 0.00206036f, 
    -0.03734602f, -0.02259062f, -0.03764559f, -0.05291631f, 0.00074553f, -0.01327469f, -0.01873607f, -0.04769641f, 
    0.01753139f, 0.00217013f, 0.01846779f, -0.04339445f, -0.01625828f, 0.02556613f, 0.02687987f, 0.00677079f, 
    -0.03972455f, -0.04277322f, -0.03610240f, -0.01865003f, 0.01508551f, 0.04431784f, -0.00916302f, -0.04014996f, 
    -0.05615017f, 0.03981744f, -0.04073013f, 0.01682364f, 0.01958606f, -0.04583094f, 0.02687700f, -0.05083643f, 
    0.02039353f, -0.03245049f, 0.04260540f, -0.00283275f, 0.02460546f, -0.01907810f, 0.02169625f, 0.00270697f, 
    0.00958259f, -0.02673411f, 0.03745223f, -0.05532616f, 0.03701399f, -0.01503820f, 0.02555229f, -0.02686564f, 
    0.01697255f, -0.01352097f, 0.04447015f, -0.01504227f, 0.01926372f, 0.02285819f, 0.03055312f, -0.00393505f, 
    -0.02013554f, -0.03742417f, 0.00227517f, 0.03425583f, 0.00265104f, 0.03222318f, 0.03593875f, -0.03159701f, 
    -0.05459197f, 0.03594586f, -0.03836000f, -0.05215736f, 0.02806092f, 0.02381911f, -0.04352055f, 0.04331334f, 
    -0.04113007f, -0.03977514f, -0.02836284f, 0.00809907f, -0.03049066f, 0.01228259f, -0.03432241f, 0.02357000f, 
    -0.03654556f, 0.00682980f, 0.00695229f, -0.03586089f, 0.02186224f, -0.04926677f, 0.03936915f, -0.03925894f, 
    0.03533096f, 0.02829483f, -0.01537773f, -0.01984262f, -0.05423282f, -0.00051824f, -0.00863129f, -0.00183351f, 
    -0.05093840f, -0.03410613f, 0.03122870f, -0.03065771f, 0.00433506f, 0.00112117f, 0.04477234f, -0.04865916f, 
    -0.02957882f, 0.01829031f, -0.03742780f, -0.01619709f, 0.00927043f, -0.04234736f, 0.04298464f, 0.00930308f, 
    -0.03077026f, -0.04280853f, -0.03446474f, -0.03419360f, -0.02676065f, -0.01533793f, -0.03710771f, 0.00731829f, 
    -0.02126456f, -0.03125951f, -0.03886226f, -0.01701270f, 0.01074829f, -0.04740597f, 0.03916628f, -0.00377421f, 
    0.02012148f, -0.00202856f, -0.04502320f, 0.00750541f, -0.04880711f, 0.02702524f, -0.02214586f, -0.03345126f, 
    -0.01259883f, 0.01050295f, 0.03886010f, 0.00407919f, 0.01306627f, -0.00082910f, -0.02753695f, 0.02598276f, 
    0.01634772f, 0.03679705f, 0.02963910f, -0.03333212f, 0.03447442f, 0.00414807f, -0.04826647f, 0.01244046f, 
    -0.04374144f, -0.04354209f, -0.04210458f, -0.04932178f, 0.00902406f, -0.01635042f, 0.01360719f, -0.01987928f, 
    -0.02159879f, -0.05646966f, -0.02490845f, -0.02984199f, 0.03072269f, 0.00778294f, 0.02457498f, -0.03869842f, 
    0.00833173f, -0.02858857f, -0.04034431f, -0.01246199f, -0.00153146f, -0.04859303f, -0.00199183f, 0.03064145f, 
    -0.03363990f, -0.03416396f, -0.01855598f, -0.02841188f, -0.00820767f, -0.00963466f, 0.04318210f, 0.04526382f, 
    -0.01414132f, 0.01203210f, -0.04911777f, 0.02047958f, -0.00786921f, 0.03446773f, -0.03709370f, 0.00776887f, 
    0.15641785f, 0.13726997f, 0.24294931f, 0.22880121f, 0.00627208f, 0.09537867f, 0.05676510f, 0.11174972f, 
    -0.04010849f, 0.10341415f, -0.07189316f, -0.08571742f, 0.16161752f, 0.17649053f, 0.09262481f, -0.01833316f, 
    0.03503396f, 0.04800401f, -0.00939173f, 0.07842936f, -0.03539251f, -0.02991507f, -0.02238054f, -0.00144076f, 
    0.21988109f, -0.15711191f, 0.01689110f, -0.09719922f, 0.00647941f, -0.02469557f, 0.03122800f, 0.12133487f, 
    0.09522027f, -0.09177957f, 0.13503352f, -0.05220681f, -0.02562349f, -0.37113205f, 0.07880686f, -0.16338313f, 
    -0.03875405f, -0.04005736f, -0.01082689f, 0.02417573f, 0.08189366f, -0.06212840f, -0.13059920f, 0.00725665f, 
    0.01540776f, 0.09723515f, -0.02701922f, -0.04835971f, -0.04296187f, 0.06269292f, 0.06227040f, 0.10046801f, 
    0.10733270f, 0.05310400f, 0.03616910f, -0.02609152f, -0.19411391f, 0.07862774f, -0.07338986f, 0.02476055f, 
    -0.04240576f, 0.09998307f, 0.09627431f, 0.00633722f, 0.09647335f, -0.01681836f, 0.01206875f, 0.11738060f, 
    0.16762587f, 0.08969145f, 0.04064199f, -0.09674171f, 0.02716136f, 0.05003512f, -0.08939463f, 0.09973953f, 
    0.06022050f, -0.09304027f, 0.12930390f, -0.01222856f, 0.08991450f, 0.05755861f, 0.06881431f, -0.16307731f, 
    0.01663908f, 0.01953178f, 0.01909625f, -0.05074518f, -0.04188623f, 0.12390743f, -0.01220877f, 0.10953274f, 
    -0.22234790f, 0.20460944f, 0.10623863f, 0.24444501f, -0.00518265f, -0.02120716f, 0.11242890f, 0.06735587f, 
    0.06026936f, 0.07519964f, -0.12423865f, 0.10943089f, -0.13021171f, -0.09168524f, 0.02021541f, -0.06675425f, 
    0.13915847f, 0.09183838f, -0.01034809f, 0.04797387f, 0.05124334f, 0.09598777f, -0.04120940f, 0.05412631f, 
    0.04962394f, -0.28680667f, -0.14678872f, 0.11858000f, 0.04635123f, 0.00958459f, -0.06777540f, 0.05302219f, 
    0.00417041f, -0.01564855f, 0.04980505f, -0.03895707f, -0.23016961f, -0.17361718f, -0.11559703f, -0.01122049f, 
    -0.11177834f, 0.00889296f, -0.00273699f, -0.01894420f, -0.01662931f, 0.04116085f, -0.00329049f, -0.03016839f, 
    0.08369571f, 0.03046996f, -0.04830474f, 0.03464236f, -0.14416820f, 0.02944879f, -0.02590713f, -0.05329010f, 
    -0.09166173f, 0.10450739f, 0.01607437f, -0.14164248f, 0.07023413f, -0.21465702f, 0.00547458f, -0.17375496f, 
    -0.00828976f, -0.03757796f, -0.00471298f, 0.01049184f, 0.03772770f, 0.04260682f, 0.15449333f, 0.03890755f, 
    0.16001709f, -0.30877855f, -0.10050781f, 0.26248103f, 0.09537823f, 0.07670385f, 0.04070101f, 0.01849020f, 
    0.03914096f, -0.15265685f, -0.04041551f, 0.09064557f, 0.14805965f, 0.28023380f, 0.01927843f, 0.00783443f, 
    0.00623027f, -0.02735582f, -0.01141143f, 0.09354702f, -0.07454228f, 0.01297525f, 0.02370614f, 0.07482611f, 
    -0.08798116f, -0.00400643f, 0.07273094f, 0.07130271f, 0.01002443f, -0.01499897f, -0.00583026f, -0.08018089f, 
    0.02805320f, -0.00599829f, 0.08966842f, -0.03786333f, -0.19898251f, 0.25615358f, -0.07634916f, 0.05369052f, 
    0.07365368f, 0.05887138f, -0.02967162f, 0.05835767f, -0.07436956f, 0.01759935f, 0.04059860f, 0.08889978f, 
    -0.08909984f, 0.16127911f, -0.04054559f, -0.01696358f, 0.10027396f, -0.01043847f, 0.04323922f, 0.08980066f, 
    0.04571467f, 0.08746652f, 0.10407156f, 0.00376770f, 0.09548414f, -0.20580529f, -0.20820688f, 0.16198204f, 
    0.00781940f, 0.00969301f, 0.13036601f, -0.07821479f, 0.03200699f, 0.01064659f, 0.02439938f, -0.03614856f, 
    -0.09311677f, -0.01773089f, 0.10377639f, 0.01068110f, -0.01119929f, 0.00897506f, 0.01468403f, 0.07223556f, 
    -0.06524841f, -0.02765072f, -0.00626403f, -0.00072910f, -0.16290018f, 0.22799933f, 0.06306998f, 0.02339049f, 
    0.07019192f, 0.06529737f, 0.15692103f, 0.13327855f, 0.01885709f, -0.00468133f, -0.02012120f, 0.09194116f, 
    0.07071412f, -0.04263309f, 0.03547628f, 0.09228138f, 0.08823720f, 0.04044684f, 0.01627748f, 0.02190755f, 
    0.05692638f, 0.01012644f, -0.01568678f, 0.15787333f, 0.00236760f, -0.10218676f, -0.09783698f, 0.00805745f, 
    0.00916654f, 0.03530801f, 0.05256650f, -0.00189700f, 0.12384015f, 0.13056406f, 0.00415587f, 0.08644252f, 
    0.09319257f, -0.03712289f, 0.08669921f, -0.04002497f, 0.08595096f, 0.13255021f, 0.05186718f, -0.01388145f, 
    0.08687679f, -0.03349632f, 0.07143375f, -0.00544789f, -0.11054543f, -0.18909311f, -0.16534817f, -0.15376867f, 
    -0.13344455f, -0.05628441f, -0.03861206f, -0.06678605f, 0.09089724f, 0.01995903f, -0.01045108f, -0.01081569f, 
    0.12032260f, 0.00046439f, -0.02965641f, -0.12474902f, 0.04660299f, -0.06349638f, 0.05166005f, -0.03618483f, 
    -0.08537879f, 0.03908300f, 0.06044785f, -0.00668568f, 0.13542064f, -0.22555624f, -0.05721674f, -0.28780669f, 
    0.04599324f, 0.07646515f, -0.02819267f, 0.06901156f, -0.00368175f, -0.01509714f, 0.06024406f, -0.02754514f, 
    0.18625270f, 0.08162857f, -0.16142759f, 0.00320825f, -0.07926424f, -0.01342108f, -0.02267141f, 0.02684530f, 
    -0.06546095f, 0.00675321f, 0.04377105f, 0.02994226f, -0.03030363f, -0.06878854f, -0.14971140f, -0.06917011f, 
    -0.12544918f, 0.00436734f, 0.03124550f, -0.09365726f, -0.02825925f, -0.02344755f, -0.11110386f, 0.03614020f, 
    -0.19191191f, -0.03670422f, 0.02720814f, -0.21669307f, 0.00661778f, 0.01503045f, -0.01004881f, -0.04794124f, 
    0.03714342f, 0.09675099f, 0.06790237f, 0.00495675f, 0.06363403f, -0.07580440f, 0.01529577f, -0.01935047f, 
    0.11582313f, 0.09288623f, -0.00781517f, 0.04624045f, 0.06725791f, 0.08262605f, -0.03969253f, 0.03123190f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01745343f, 0.03819262f, -0.04344258f, 0.07307195f, 0.06607153f, 0.01411417f, 0.01008744f, -0.03775747f, 
    0.02179543f, -0.02081300f, -0.05498838f, 0.01095935f, 0.09421860f, -0.02120239f, 0.02781100f, 0.01978138f, 
    -0.03170878f, -0.05109255f, -0.05454276f, -0.02347308f, -0.01185438f, 0.01963371f, -0.01798091f, -0.05714117f, 
    0.07989597f, -0.01455755f, 0.03945805f, 0.08191214f, 0.01330769f, 0.00745542f, -0.00363492f, -0.04303309f, 
    -0.01442053f, 0.06428888f, -0.02224607f, 0.03486725f, 0.02732069f, 0.04829638f, -0.01823557f, 0.05464194f, 
    0.00528484f, 0.00301093f, -0.05618111f, -0.01826664f, 0.03603891f, -0.00132696f, 0.00714857f, -0.02177896f, 
    0.10235031f, 0.04829850f, -0.06040046f, -0.05534347f, 0.01471914f, 0.00930475f, 0.00660176f, 0.00612586f, 
    0.08351529f, -0.04482940f, 0.01975503f, 0.02017820f, 0.08043327f, -0.03939848f, 0.00416628f, 0.03164281f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.01836501f, -0.25888920f, 0.24563286f, -0.18852742f, -0.27953571f, 0.13913783f, 0.18272349f, 0.01678260f, 
    0.09846060f, 0.16400824f, -0.26175210f, 0.00585839f, 0.08390481f, -0.23624614f, -0.21805522f, -0.00317590f, 
    -0.04158318f, 0.35409558f, 0.07532056f, -0.08550940f, 0.07624238f, 0.11612705f, -0.07925110f, -0.17368700f, 
    -0.05058416f, -0.28457519f, 0.23125263f, -0.39408767f, -0.11079185f, 0.03364005f, 0.32833001f, -0.05015768f, 
    -0.38678145f, -0.04799290f, 0.13386333f, 0.22984868f, -0.34929386f, 0.14628145f, -0.14089090f, -0.25524259f, 
    -0.19715677f, -0.10615887f, -0.12381594f, -0.07734720f, 0.07060356f, 0.18821780f, -0.45473203f, -0.09277600f, 
    -0.20232275f, 0.27634516f, -0.20261875f, 0.06885181f, -0.18802506f, 0.01253275f, -0.01676940f, -0.42599943f, 
    0.00177371f, -0.01944431f, 0.09019501f, 0.24908014f, 0.17814624f, -0.38441887f, -0.04101810f, -0.19262233f, 
    -0.27167913f, 0.18253152f, 0.15738933f, 0.30369613f, 0.10627797f, 0.20245737f, 0.10463262f, -0.00315978f, 
    0.06492309f, 0.18952614f, -0.21854495f, 0.01526564f, -0.06612209f, 0.10569680f, -0.24103867f, -0.00291740f, 
    -0.07266798f, -0.08660080f, -0.06754902f, 0.04026956f, 0.06743675f, -0.24716650f, -0.02961546f, -0.19204976f, 
    0.17807278f, 0.22534540f, -0.14020091f, 0.00956523f, -0.08967490f, 0.03787605f, -0.39113706f, -0.09498721f, 
    0.19185397f, 0.18224385f, 0.10143626f, -0.64149499f, -0.46497121f, 0.10907983f, -0.10001541f, 0.16889732f, 
    -0.26057252f, -0.10704230f, 0.10045320f, 0.04648072f, 0.07181281f, -0.03659756f, 0.23065355f, -0.05242709f, 
    0.18699841f, -0.08797688f, 0.09544393f, 0.11734891f, -0.49107823f, -0.13418479f, -0.06079535f, -0.17132585f, 
    -0.33107966f, 0.08129185f, 0.23562489f, 0.22733819f, -0.17840254f, -0.30642533f, -0.08910680f, -0.00246405f, 
    -0.05942144f, -0.02243434f, -0.20492049f, 0.16695268f, 0.12440613f, -0.04048346f, -0.14575931f, 0.08275902f, 
    0.11750004f, -0.20624836f, 0.36303690f, 0.02625001f, 0.19544312f, 0.23198363f, -0.38464034f, 0.05613063f, 
    -0.12602778f, 0.07877179f, -0.07121792f, -0.10444906f, -0.02084218f, -0.27450639f, -0.02052200f, -0.35300013f, 
    -0.17732194f, 0.11448390f, 0.27645683f, -0.39623937f, 0.07419571f, 0.10472070f, -0.24865657f, -0.01912861f, 
    0.16228338f, -0.16182342f, -0.00729372f, 0.35181433f, 0.02143937f, 0.17532496f, -0.22548704f, 0.02165067f, 
    0.35928941f, -0.08592490f, -0.13216372f, 0.04665754f, -0.02462127f, 0.15059301f, -0.42941660f, 0.10165198f, 
    -0.18799254f, 0.13801476f, 0.34828871f, -0.06371906f, 0.04474897f, 0.05680392f, -0.06991670f, -0.46241117f, 
    -0.08707904f, 0.02726571f, -0.32151783f, -0.06113697f, -0.09084025f, -0.13663003f, 0.10401737f, -0.05983758f, 
    0.30000985f, -0.51428652f, -0.47776672f, -0.06659003f, -0.20806074f, 0.10295074f, -0.20677190f, 0.07703695f, 
    0.00490842f, 0.26481947f, -0.36056790f, 0.04194154f, -0.04460062f, 0.00813744f, -0.28561690f, 0.08423573f, 
    -0.04855698f, -0.01749224f, 0.04615816f, -0.03595518f, -0.06320934f, 0.12033585f, -0.02477802f, -0.42383802f, 
    -0.62101936f, -0.45106941f, 0.06484171f, -0.26259515f, 0.17240235f, 0.06991231f, 0.05397731f, -0.01095701f, 
    -0.13060826f, -0.15402181f, 0.01178296f, -0.43899250f, -0.14351343f, -0.66411221f, -0.01086676f, 0.12444618f, 
    -0.25749469f, -0.10704011f, -0.12880901f, 0.05091559f, -0.01353755f, -0.28037679f, 0.14914133f, 0.08114451f, 
    0.26847625f, -0.23775063f, -0.22704911f, 0.10396261f, 0.12879182f, 0.09930172f, 0.08098338f, 0.21898808f, 
    0.14323001f, -0.03862698f, -0.02167779f, 0.29224962f, -0.00721823f, 0.17577778f, 0.10054543f, 0.14877778f, 
    0.22078559f, 0.17905633f, 0.06038328f, -0.38683850f, 0.18456414f, 0.16443846f, 0.18344951f, -0.02761571f, 
    0.08675751f, 0.21455739f, 0.02335924f, -0.11543439f, 0.02495583f, -0.30416054f, 0.35986048f, -0.08537110f, 
    0.07003466f, -0.44888797f, 0.10918060f, -0.03680464f, -0.00331695f, -0.20099634f, 0.03981054f, 0.02149463f, 
    -0.36073765f, -0.21694458f, -0.15738212f, 0.10710915f, -0.05968942f, -0.00853123f, -0.16856469f, -0.00267154f, 
    -0.67612916f, -0.29658538f, 0.20346875f, -0.39118049f, -0.22231881f, -0.12691043f, 0.20816262f, -0.11460274f, 
    0.30725971f, 0.11579666f, -0.02003324f, 0.10247990f, 0.06669177f, -0.03131656f, 0.05437462f, -0.04956888f, 
    0.16977762f, -0.02704474f, -0.10185684f, 0.07331122f, -0.18962744f, 0.09955817f, -0.06062152f, -0.07364885f, 
    0.00730723f, -0.10133057f, -0.19527064f, -0.05578990f, 0.23691761f, 0.15920000f, -0.00468481f, -0.08605939f, 
    -0.21131568f, 0.00827375f, -0.08460747f, -0.31133273f, -0.24305780f, 0.17412235f, 0.19573939f, 0.00857055f, 
    0.00623933f, -0.17011261f, -0.07667556f, -0.06947370f, 0.03420889f, 0.31690446f, 0.10659461f, -0.06753154f, 
    -0.10189518f, -0.09817047f, -0.02149286f, -0.11474565f, 0.08579269f, 0.27110252f, 0.02543311f, 0.36534837f, 
    0.00829812f, -0.28298086f, -0.13966134f, 0.24792102f, -0.42372629f, -0.05838653f, -0.08879975f, 0.02177156f, 
    0.19192000f, -0.18474309f, -0.09255730f, 0.01293807f, -0.12525119f, 0.18018997f, -0.49107867f, 0.17339930f, 
    -0.44913512f, 0.10755736f, 0.04775016f, 0.03250975f, -0.09176625f, 0.15811177f, 0.26500785f, 0.00863044f, 
    0.08906887f, -0.13725536f, -0.00037428f, -0.12596127f, 0.07486323f, 0.06951761f, 0.00639149f, 0.18818793f, 
    0.12486271f, 0.11107093f, 0.19024158f, -0.17441365f, 0.00205182f, -0.31458962f, 0.01150232f, 0.02215656f, 
    -0.12104284f, -0.01327734f, 0.17894542f, 0.00353162f, -0.03553662f, -0.21412258f, -0.31205541f, 0.02100221f, 
    0.01418022f, 0.17534159f, -0.49229586f, -0.08470480f, -0.31382072f, -0.46063855f, 0.19202690f, 0.08972320f, 
    -0.04277851f, 0.06215952f, -0.07940358f, 0.04672637f, 0.02886476f, -0.22187056f, -0.05065297f, 0.25233039f, 
    0.10096993f, 0.14261794f, -0.03122335f, 0.04109884f, -0.12623797f, 0.08538762f, 0.29470685f, 0.12094608f, 
    0.37128225f, -0.01359398f, -0.06544630f, -0.01015855f, 0.27833542f, -0.01329212f, -0.36792350f, 0.14945048f, 
    0.04547776f, 0.03641456f, 0.01557873f, 0.07645756f, -0.07188772f, -0.23672234f, -0.76823419f, -0.12589248f, 
    -0.38257784f, 0.13425006f, 0.23694737f, 0.10382707f, 0.02112121f, -0.07644656f, -0.07391233f, -0.08518375f, 
    0.13814116f, 0.12850806f, -0.10312194f, -0.02985294f, -0.23562944f, 0.25963899f, 0.03194042f, 0.29994711f, 
    -0.10061788f, -0.26392269f, 0.00222396f, -0.02646784f, -0.19537786f, 0.18028527f, -0.32031670f, -0.04371248f, 
    0.11907373f, -0.25704750f, 0.16996144f, 0.05156415f, -0.26595205f, 0.03892458f, -0.09470250f, -0.06322815f, 
    -0.03842688f, 0.11962806f, -0.02923084f, 0.10689146f, -0.06113304f, 0.19368108f, 0.09022281f, 0.09452325f, 
    -0.01829723f, -0.01353977f, -0.21131143f, -0.03998520f, 0.18868713f, -0.03698125f, 0.18250787f, 0.02033092f, 
    -0.26001048f, -0.28283337f, -0.30913314f, 0.22110339f, 0.11194334f, -0.23945306f, 0.20859788f, -0.30325881f, 
    0.27816203f, 0.06823526f, 0.06237117f, -0.11168971f, -0.09294859f, 0.06315436f, 0.19550230f, 0.04898643f, 
    -0.14726077f, -0.29384264f, 0.24197738f, -0.00018945f, 0.12836979f, -0.04216786f, -0.01546535f, 0.00170876f, 
    -0.00794191f, -0.05130045f, -0.03826259f, -0.21519965f, 0.05218754f, 0.14318667f, -0.11537709f, -0.33781412f, 
    -0.17239134f, 0.09367557f, -0.15019928f, 0.15226787f, 0.30708990f, -0.36893815f, -0.09249186f, 0.01754739f, 
    0.01636301f, -0.32303280f, 0.24415950f, -0.03530947f, -0.23171782f, 0.27175340f, -0.08589183f, -0.11595985f, 
    0.08798746f, 0.32783663f, -0.06103064f, -0.09830254f, -0.07569813f, -0.11429665f, -0.07989437f, 0.29664922f, 
    0.28858185f, 0.17303818f, -0.16631377f, -0.23736958f, 0.08898032f, -0.11322211f, -0.05747124f, -0.01432650f, 
    -0.40508094f, 0.17376858f, 0.19090582f, -0.26277798f, -0.33515716f, -0.10903011f, -0.15573898f, 0.14552759f, 
    -0.12751015f, -0.01405825f, 0.00380089f, 0.02551397f, 0.00226719f, 0.28965515f, -0.11077318f, 0.09360085f, 
    -0.19551709f, -0.16069496f, -0.50189728f, 0.04330888f, 0.07481887f, -0.05424393f, -0.08243699f, 0.34018052f, 
    -0.45505208f, 0.01177600f, -0.11053433f, -0.19920975f, -0.02095239f, -0.06094520f, 0.07782365f, -0.26270810f, 
    -0.14546196f, 0.29134697f, 0.23864211f, -0.17994745f, -0.32019341f, -0.13586359f, 0.22485481f, 0.05062724f, 
    -0.04228329f, -0.06748299f, 0.12260518f, 0.08119487f, -0.01336670f, 0.16547519f, 0.07588240f, 0.04236503f, 
    -0.06386396f, -0.33148441f, 0.04682713f, -0.06714469f, -0.01781770f, -0.26245016f, 0.04695528f, -0.04818939f, 
    0.12607586f, 0.07206957f, 0.11901563f, -0.10086156f, 0.11481170f, 0.01178529f, 0.32951146f, -0.06813512f, 
    -0.07546146f, 0.23956402f, -0.03325456f, 0.23495841f, 0.09709227f, -0.18736164f, 0.34759071f, -0.37611678f, 
    -0.04409459f, -0.01684291f, -0.09674145f, 0.07010524f, -0.04891117f, 0.13215347f, -0.16314289f, -0.08326811f, 
    -0.08327056f, -0.17616847f, -0.08937693f, -0.09305473f, 0.25071031f, 0.01114757f, 0.05017971f, 0.16562971f, 
    0.21082370f, 0.09592000f, -0.33683228f, -0.44471624f, -0.40878195f, 0.00238671f, -0.07752710f, -0.40098730f, 
    -0.18434267f, 0.00717104f, -0.20096776f, 0.17661452f, 0.25193945f, -0.18700887f, -0.41643423f, 0.07980207f, 
    -0.02871278f, -0.24252380f, -0.27579498f, 0.01752980f, 0.27001891f, -0.16970490f, -0.27564684f, -0.07491232f, 
    -0.07000235f, 0.06801518f, 0.00817176f, 0.02955488f, 0.11300650f, 0.19865301f, -0.11371433f, -0.28514346f, 
    0.08127844f, 0.19868267f, -0.14189607f, 0.03093096f, 0.00610666f, -0.01914513f, -0.56449872f, -0.05681737f, 
    -0.23200116f, 0.08290465f, -0.38143092f, 0.18669601f, 0.15738681f, -0.21590756f, 0.21274434f, 0.21767592f, 
    0.05396054f, -0.09219903f, -0.04296166f, -0.01820978f, -0.11712025f, 0.03768187f, 0.00937614f, -0.08541607f, 
    0.16564490f, 0.30766642f, -0.42318562f, -0.04280221f, -0.20634718f, -0.11663506f, -0.05375010f, 0.03894466f, 
    0.27456355f, -0.03170238f, -0.43090826f, 0.06787729f, 0.22247192f, -0.25791135f, 0.00011915f, 0.25106022f, 
    0.24296658f, -0.58901948f, -0.38320243f, 0.16609789f, 0.18972531f, -0.32141000f, 0.01253361f, -0.01800002f, 
    -0.02956674f, -0.04311690f, -0.08930641f, -0.05031094f, -0.34500161f, -0.25545961f, 0.21599437f, 0.03355215f, 
    0.10814155f, -0.00650339f, -0.00917592f, -0.09093963f, -0.01300891f, -0.27442062f, -0.00413012f, -0.23842520f, 
    0.08260785f, 0.13884930f, 0.23260027f, 0.03562894f, -0.28108063f, 0.05302365f, -0.16806129f, 0.07539973f, 
    -0.40202916f, 0.28231847f, -0.14474675f, 0.14399993f, 0.18161374f, 0.27269068f, -0.27657703f, -0.24256501f, 
    0.05182571f, 0.01075540f, -0.06462581f, -0.02717003f, -0.04762883f, -0.40129548f, 0.05484537f, -0.11395808f, 
    -0.05330256f, -0.24873817f, -0.06126513f, 0.09634204f, 0.23318166f, -0.05921862f, -0.01385439f, 0.01145970f, 
    -0.04169299f, -0.01420241f, 0.37468189f, -0.31939167f, 0.19787019f, 0.04841458f, 0.11401568f, 0.17163469f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.09284615f, 0.09775439f, -0.06222598f, 0.01795661f, 0.05779925f, 0.00548124f, -0.10557794f, -0.18627474f, 
    0.05601428f, -0.03067616f, 0.00442541f, -0.07380848f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
