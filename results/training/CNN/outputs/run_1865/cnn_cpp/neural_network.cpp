#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.87362444f, -0.80583483f, -0.62134892f, 0.30781025f, 0.08767707f, 0.25301191f, 0.24191715f, 0.38009402f, 
    -0.02038061f, 0.00370998f, -0.22644746f, -0.25639069f, -0.06432496f, 0.16160248f, -0.06744670f, 0.07989328f, 
    -0.13307692f, -0.49226767f, -0.08378182f, -0.22780846f, 0.02495305f, -0.09316377f, 0.08811346f, 0.11022742f, 
    -0.15691389f, -0.80602002f, -0.24816225f, 0.14319842f, 0.29125562f, 0.45261043f, -0.09243803f, -0.31118658f, 
    -0.15634842f, 0.42538515f, 0.17369866f, -0.40924904f, 0.00387920f, -0.06021598f, -0.09581613f, -0.16430454f, 
    0.01191216f, 0.17052558f, 0.05660036f, -0.08029093f, 0.23702496f, -0.02357684f, 0.15801774f, 0.02005487f, 
    -0.29202929f, -0.06535211f, 0.18633378f, -0.25530618f, 0.07898512f, 0.23570929f, 0.21073663f, -0.10422516f, 
    -0.02350942f, -0.03442952f, -0.09686270f, 0.12747058f, -0.10291199f, -0.26897380f, 0.32025427f, -0.43267035f, 
    0.54089403f, 0.17483471f, -0.09107372f, -0.12888500f, 0.09905773f, 0.01048305f, -0.10789128f, 0.05308362f, 
    -0.12703542f, 0.27218333f, 0.45967400f, 0.00217180f, 0.01010765f, -0.38529909f, -0.30220878f, -0.22648148f, 
    0.38740122f, 0.49603558f, 0.02397984f, -0.14837375f, -0.29895175f, 0.09251466f, 0.62359428f, -0.27608424f, 
    -0.12298148f, -0.17735295f, -0.27377424f, -0.26269197f, -0.17773469f, -0.18807392f, -0.09289797f, 0.31175521f, 
    -0.00369244f, 0.25380421f, 0.28762478f, 0.43788096f, -0.76101327f, -0.40031877f, 0.13694982f, -0.28106335f, 
    -0.20080025f, -0.38547051f, -0.19806379f, -0.56145531f, -0.33589202f, -0.03455116f, 0.26507607f, -0.28908440f, 
    0.20277429f, -0.48397207f, -0.06736910f, 0.16260365f, 0.19425255f, 0.11599667f, 0.20042093f, 0.23684222f, 
    0.20274678f, 0.12597677f, 0.08730037f, -0.09215891f, -0.06510586f, -0.23303235f, -0.42235848f, -0.62753832f, 
    -0.69313073f, -0.62802196f, 0.32619241f, -0.11223064f, 0.15083642f, 0.17174187f, 0.14877172f, 0.05810953f, 
    0.17306346f, 0.51059026f, -0.06425428f, -0.01231848f, -0.18087886f, -0.20093185f, 0.09377360f, 0.14813638f, 
    0.06259293f, -0.21553203f, -0.16442627f, -0.00478891f, -0.13209924f, -0.30522078f, -0.35757512f, 0.38946038f, 
    0.79549640f, -0.28382435f, -0.44539359f, -0.32147864f, -0.01756782f, 0.35832053f, 0.39127505f, -0.15899101f, 
    -0.18064426f, -0.27903718f, 0.12067970f, 0.06535628f, -0.05589202f, -0.06981841f, 0.16529651f, 0.11867399f, 
    -0.28949288f, -0.00863919f, -0.15453826f, -0.19756530f, -0.36087146f, -0.11815984f, -0.19643323f, 0.63224763f, 
    0.67166859f, 0.40205988f, 0.46339354f, -0.60818493f, -0.38072461f, -0.34050369f, -0.31081751f, -0.28634977f, 
    -0.26929235f, 0.14152373f, -0.07727948f, -0.12428192f, 0.13483073f, 0.00815849f, -0.12398398f, 0.04024266f, 
    0.03250645f, 0.26806191f, -0.38442421f, -0.06318056f, 0.05891025f, -0.16900918f, 0.13347536f, -0.21610723f, 
    0.28877124f, -0.36702654f, 0.12262513f, 0.28439426f, 0.43165883f, 0.34759018f, 0.16244429f, -0.01536803f, 
    -0.39432335f, 0.05090425f, -0.06356344f, -0.25790942f, -0.20387861f, -0.28672701f, 0.61849391f, -0.05557883f, 
    0.09486443f, 0.00978928f, -0.01403098f, -0.11443122f, 0.16636325f, -0.17088522f, 0.04758920f, -0.14644423f, 
    -0.31597194f, -1.14742398f, -0.42823422f, 0.08196444f, 0.67712182f, 0.63299507f, -0.03855869f, 0.62041193f, 
    0.07290109f, 0.22787742f, 0.10621402f, -0.08496233f, -0.02170170f, 0.19911723f, 0.09333432f, -0.13825083f, 
    0.10986691f, -0.32906914f, 0.06458382f, -0.21994057f, -0.05082848f, -0.03666960f, -0.06553992f, 0.17474110f, 
    0.04761225f, 0.06647900f, -0.52576995f, -0.52037090f, -0.14230527f, -0.00250986f, 0.33704686f, -0.51403826f, 
    -0.47257218f, -0.74002320f, -0.02620776f, -0.43106559f, 0.18349890f, 0.00642179f, 0.21889268f, 0.84295321f, 
    -0.22075751f, -0.06904685f, -0.10821225f, -0.35872516f, -0.36201438f, -0.02706729f, -0.00246634f, 0.20297049f, 
    -0.13146509f, -0.06891792f, 0.10931505f, 0.16489752f, -0.63618755f, 0.04748571f, -0.19531034f, -0.77770716f, 
    -0.11577310f, -0.16995166f, -0.26912525f, 0.01267249f, 0.11253519f, -0.01188312f, 0.05096572f, -0.49988657f, 
    -0.23157327f, -0.36090553f, -0.03144267f, 0.14603907f, 0.24484122f, 0.02276335f, 0.10390677f, -0.31016332f, 
    -0.43859071f, -0.32714760f, -0.11592994f, -0.35382473f, 0.06066417f, -0.20766716f, -0.04486805f, 0.07229941f, 
    0.17339264f, 0.33593902f, -0.38727492f, -0.42904663f, -0.21366283f, 0.32642138f, 0.26222241f, -0.17237042f, 
    -0.31972408f, 0.34156567f, -0.09112743f, 0.15951900f, 0.00585843f, -0.02993861f, 0.05234392f, -0.22823998f, 
    -0.40958005f, 0.05583024f, 0.36479107f, -0.01341768f, 0.35761744f, 0.31766215f, 0.20773593f, -0.54748333f, 
    -0.63652241f, 0.08622820f, 0.27411139f, 0.41349351f, 0.33045816f, -0.40926787f, -0.35210866f, -0.39615270f, 
    -0.47378758f, -0.23895580f, 0.25991902f, 0.08319819f, -0.38295564f, 0.08892604f, 0.13657987f, 0.00018163f, 
    0.05856898f, -0.12042434f, -0.38899678f, -0.16314860f, 0.32282838f, 0.21168169f, 0.64942437f, 0.80941629f, 
    0.55135894f, -0.42628416f, -0.38066992f, -0.23674239f, 0.03675268f, -0.04808926f, -0.16529080f, -0.00593809f, 
    0.42427066f, -0.12904666f, -0.19905782f, 0.04823917f, -0.29671696f, 0.02234468f, -0.12557019f, -0.08287726f, 
    0.07578515f, 0.01587463f, 0.07469140f, 0.13863443f, -0.13657519f, -0.13952921f, 0.11708657f, 0.52263612f, 
    -0.85092688f, -0.84569895f, -0.39752281f, -0.12138370f, 0.21693301f, 0.11588400f, 0.21458814f, 0.39418823f, 
    0.25306401f, 0.02774426f, 0.25815615f, 0.02103723f, -0.02151348f, -0.02401661f, -0.19153345f, -0.36849409f, 
    0.15015893f, 0.09710083f, -0.15550536f, 0.18729398f, -0.14804573f, -0.31472629f, 0.13466346f, 0.34947735f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08121452f, 0.14080958f, 0.35344663f, 0.16519326f, -0.09028862f, 0.09901965f, 0.13199332f, 0.12851365f, 
    0.10900301f, 0.13932322f, 0.02743829f, 0.15494272f, 0.26383701f, 0.08918794f, 0.29302052f, 0.28711292f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01024054f, 0.04883687f, -0.00996343f, -0.02802372f, -0.06236002f, -0.06368286f, 0.03062603f, -0.03199362f, 
    -0.05715244f, 0.05885241f, -0.08385520f, 0.00750883f, -0.01793190f, 0.05114430f, -0.03244528f, -0.00781743f, 
    -0.01320686f, -0.07675800f, 0.02017378f, 0.01272853f, -0.08547843f, 0.00885363f, -0.01878002f, -0.03219828f, 
    -0.01189559f, 0.03679400f, 0.02851111f, -0.06821490f, -0.03541944f, -0.02429064f, -0.05983636f, 0.04350812f, 
    0.05243084f, -0.01191418f, 0.00268859f, -0.04203825f, 0.04574138f, 0.05439540f, 0.04302233f, 0.01082424f, 
    0.03027793f, -0.01845193f, 0.02797369f, 0.04677355f, 0.02154323f, 0.02233437f, 0.03552291f, 0.00835096f, 
    0.03009402f, -0.07444198f, -0.00673705f, 0.00498316f, -0.02536529f, -0.06240165f, 0.04472435f, 0.00945023f, 
    0.04964718f, -0.01457218f, 0.05292642f, 0.05269240f, -0.04987761f, -0.05417717f, 0.05709270f, 0.03501086f, 
    0.04274449f, -0.03053317f, 0.05286669f, -0.05495271f, -0.02624512f, -0.02642578f, -0.02333560f, 0.01318046f, 
    0.02033588f, -0.06668691f, -0.08486923f, -0.08292711f, 0.05017735f, -0.04858818f, -0.01946390f, -0.05272041f, 
    0.01247838f, 0.03710500f, -0.00411684f, -0.06241468f, -0.08270657f, 0.00773459f, -0.07981670f, -0.04032670f, 
    0.02697297f, 0.00342880f, 0.01468838f, 0.05049255f, 0.04726782f, -0.01058261f, 0.04280240f, 0.00435705f, 
    0.02388319f, 0.05045593f, 0.02875996f, -0.01322304f, 0.01630018f, 0.00348469f, 0.03407768f, -0.01842954f, 
    -0.01411479f, -0.08670041f, 0.03100112f, 0.04516816f, -0.05350581f, 0.02776463f, -0.00339847f, -0.01887502f, 
    -0.03600854f, -0.04622709f, -0.05055461f, -0.08092381f, 0.05597281f, -0.08235839f, 0.00164247f, 0.01364205f, 
    0.03269179f, 0.03912583f, -0.04053301f, 0.02520252f, 0.03675361f, -0.07023985f, 0.05166727f, -0.00643689f, 
    0.05165233f, 0.04722847f, 0.03551231f, -0.07378156f, -0.04961020f, -0.07065781f, 0.01116720f, -0.04144734f, 
    -0.06465355f, -0.00632971f, -0.03377162f, 0.01394126f, 0.00682495f, -0.01607955f, -0.07561602f, -0.07193647f, 
    0.05373007f, 0.01746235f, -0.04501152f, -0.03457759f, -0.03260422f, 0.02688185f, 0.05089489f, 0.02165571f, 
    0.04946143f, -0.04892343f, -0.00827102f, -0.01817742f, -0.00688785f, -0.08136213f, -0.06456854f, -0.05884508f, 
    -0.03724730f, -0.08403563f, 0.05315057f, -0.00842259f, -0.07125027f, 0.04871765f, -0.08561786f, -0.05598595f, 
    -0.03349608f, -0.00817741f, -0.07385124f, 0.02733679f, -0.05697020f, -0.05775724f, -0.01989093f, -0.06570178f, 
    -0.06621056f, -0.05153150f, -0.00223462f, 0.02326338f, -0.01058206f, -0.05580890f, -0.04621889f, 0.00483525f, 
    -0.07735740f, -0.06078170f, -0.03930751f, 0.00901860f, 0.05552805f, -0.00887189f, -0.02248719f, 0.02153248f, 
    -0.20806205f, 0.23498389f, 0.00274416f, 0.01887296f, 0.20823754f, 0.10222577f, 0.13273484f, -0.09741994f, 
    0.05858529f, 0.04626717f, -0.03212621f, -0.13575384f, -0.13141409f, 0.29681009f, -0.03395645f, 0.01504050f, 
    -0.01842379f, 0.00447376f, 0.01094670f, 0.02170369f, 0.08854958f, -0.00877340f, -0.06736086f, -0.06896620f, 
    -0.10363731f, 0.02290443f, 0.01046700f, 0.06873575f, 0.06068479f, -0.09175430f, 0.02817312f, -0.16014221f, 
    0.08743823f, 0.00862450f, 0.15366827f, 0.01774199f, 0.00143664f, -0.19125240f, 0.23513561f, -0.22408190f, 
    -0.10920271f, -0.09017017f, -0.04202642f, -0.06256616f, 0.13296182f, 0.04889911f, 0.06193348f, 0.11816859f, 
    0.11012561f, 0.01414141f, -0.06392937f, -0.30913192f, -0.07385673f, 0.03535519f, -0.08056466f, 0.02425944f, 
    -0.02100370f, -0.08133977f, -0.01959429f, 0.05817185f, 0.06072790f, -0.04555881f, -0.07413038f, -0.21512645f, 
    0.10887015f, 0.09560932f, -0.01352463f, -0.06688286f, -0.04200057f, 0.01317706f, -0.00399207f, -0.01531873f, 
    -0.05463609f, 0.06418214f, 0.00076328f, 0.14939556f, -0.04744907f, 0.07378214f, -0.05715437f, 0.06488362f, 
    0.01729384f, -0.10213590f, -0.04658154f, -0.00005620f, -0.00791545f, -0.20815144f, -0.21062297f, -0.15434204f, 
    -0.00898399f, 0.22689094f, 0.03051626f, -0.04172118f, -0.02061663f, -0.06445879f, -0.09012575f, -0.07400125f, 
    0.16397019f, -0.03497865f, 0.41392469f, 0.18928103f, -0.06418568f, 0.04380200f, -0.09085521f, -0.15812761f, 
    -0.14908241f, -0.11895862f, 0.07246447f, -0.09041817f, 0.01822928f, 0.15991648f, 0.35704923f, 0.18836921f, 
    -0.08136581f, -0.14412998f, -0.03129217f, -0.06534316f, 0.07122448f, 0.02672458f, -0.01203744f, 0.11859652f, 
    -0.04503199f, 0.15583189f, -0.24081500f, -0.14604396f, -0.00005283f, -0.06815712f, 0.10924569f, 0.02314938f, 
    0.05705614f, -0.01042419f, 0.09612665f, -0.05028369f, 0.16640902f, 0.05511243f, 0.03315937f, -0.08570034f, 
    0.15903419f, 0.07915447f, -0.10945266f, -0.02153906f, 0.11585877f, 0.00046063f, 0.04323586f, -0.05554291f, 
    0.11071413f, -0.05336851f, -0.14362733f, -0.08161722f, 0.03936533f, -0.07004160f, -0.06551543f, -0.05393792f, 
    0.06360895f, 0.14805302f, 0.01732178f, 0.11367384f, 0.50730264f, -0.34695387f, 0.09443959f, 0.19465093f, 
    0.10729900f, -0.20646846f, 0.14040308f, -0.10490421f, 0.27922750f, -0.06826497f, 0.06781239f, 0.14861433f, 
    0.04125319f, -0.02903147f, -0.05584218f, 0.13809180f, -0.12234906f, 0.00231956f, 0.00331383f, 0.08512289f, 
    -0.12866963f, -0.08477952f, -0.04708563f, -0.05071950f, 0.35630426f, 0.21800177f, -0.00264206f, -0.19741347f, 
    0.14989977f, -0.03050392f, 0.16557226f, 0.04192271f, 0.04181995f, -0.04787672f, 0.12426045f, 0.02230131f, 
    -0.22714508f, -0.06137804f, 0.18703605f, -0.13838209f, -0.02800058f, -0.06400029f, 0.01538490f, 0.25660834f, 
    0.09006425f, 0.15889829f, 0.00004075f, 0.15792701f, -0.16021597f, -0.16222771f, -0.04807418f, 0.03768205f, 
    -0.06393000f, 0.08846860f, -0.03315165f, 0.05613008f, -0.12903608f, -0.03445622f, 0.11555760f, 0.00289006f, 
    0.09711114f, 0.03566854f, 0.12590101f, 0.07142615f, -0.06648950f, -0.05302820f, -0.04626108f, -0.13672723f, 
    0.10178424f, 0.12720491f, 0.16257368f, 0.01128294f, -0.15510826f, -0.05973160f, 0.17790416f, 0.06218982f, 
    -0.14669256f, -0.14276153f, -0.01861707f, 0.03504566f, 0.07295228f, 0.02074454f, 0.08544799f, 0.04033652f, 
    -0.35352996f, -0.16534008f, 0.02774979f, 0.02866777f, 0.02618993f, -0.06936667f, 0.26812446f, -0.05233312f, 
    -0.01985319f, -0.06213363f, 0.00240949f, -0.00544126f, -0.15175296f, 0.07893176f, -0.05647580f, -0.01608722f, 
    -0.10724377f, 0.07058997f, -0.03018215f, 0.11678588f, 0.04682389f, 0.12572727f, -0.06649327f, -0.14655565f, 
    0.27932566f, -0.09117347f, 0.04298824f, -0.05634551f, 0.02175242f, 0.09897134f, 0.08302855f, 0.02386613f, 
    -0.12615135f, 0.08294776f, -0.03057140f, -0.02998176f, 0.32743359f, -0.30908489f, 0.03713796f, -0.21319187f, 
    0.00436099f, 0.07237921f, 0.16927913f, 0.00175588f, 0.03670564f, -0.01019256f, 0.02737052f, -0.09887036f, 
    0.04149466f, 0.23030217f, 0.07690926f, 0.09282833f, 0.00959265f, -0.06848279f, 0.03570621f, 0.03306421f, 
    0.08971170f, -0.02797115f, -0.03014433f, -0.17372733f, -0.16760194f, -0.05829011f, -0.03014358f, -0.10551807f, 
    -0.04790322f, -0.01262341f, -0.08976264f, -0.13273515f, 0.13557510f, 0.06751979f, 0.11474268f, 0.06221043f, 
    -0.18066901f, -0.12955528f, 0.06133458f, 0.16113907f, -0.09110879f, 0.00340545f, 0.00210610f, -0.16861308f, 
    0.04110812f, 0.01072683f, -0.00359929f, 0.02125167f, 0.05202154f, 0.11446088f, -0.03431201f, 0.23480049f, 
    -0.03893456f, 0.09298097f, -0.01473973f, 0.04668595f, -0.07974517f, -0.03202124f, 0.03383385f, -0.01789360f, 
    -0.00235325f, 0.13854155f, -0.05908627f, 0.01320640f, -0.01488664f, 0.06593178f, 0.02375585f, 0.04960851f, 
    0.04831478f, 0.12691200f, 0.12234622f, 0.07980244f, -0.10835002f, 0.24257688f, 0.17752142f, 0.07931041f, 
    0.04101069f, 0.14002301f, -0.00082561f, -0.01752526f, 0.09963924f, 0.14083262f, 0.05075808f, 0.19260137f, 
    0.55370754f, -0.00425520f, 0.22766955f, 0.02560792f, -0.14034401f, -0.08946206f, -0.04513494f, -0.08324414f, 
    -0.09604824f, -0.11292405f, 0.07080311f, 0.00199617f, -0.07589281f, 0.06148132f, -0.09201086f, 0.08880176f, 
    -0.04337816f, 0.06777772f, 0.03018208f, 0.11832540f, 0.20610689f, 0.05343749f, -0.05830044f, -0.06367304f, 
    0.26345232f, 0.00823771f, -0.05291761f, -0.15818480f, 0.12163789f, 0.17689851f, 0.15079938f, -0.09863932f, 
    -0.12894101f, 0.02886700f, -0.06687553f, 0.09317023f, 0.30695063f, 0.16095875f, -0.17338373f, -0.17719164f, 
    0.02792223f, 0.09695587f, -0.03498524f, -0.13037913f, -0.01480892f, 0.01578439f, -0.00736880f, 0.02514543f, 
    0.03127674f, 0.16235635f, 0.02306550f, -0.09599362f, -0.01415427f, 0.00938390f, 0.03251509f, -0.01763710f, 
    0.12954563f, 0.13539113f, 0.05914535f, -0.01977896f, -0.14494187f, 0.07102501f, -0.15009715f, 0.10197505f, 
    -0.07190739f, -0.09434329f, 0.16495936f, 0.10727812f, 0.02580927f, 0.10367788f, -0.05480989f, 0.14588678f, 
    0.21714520f, -0.02192013f, -0.21361221f, -0.19882248f, 0.13450022f, 0.06185251f, 0.00228030f, -0.05133538f, 
    -0.12156928f, -0.07322163f, -0.15839882f, -0.04072317f, 0.08986665f, -0.09118145f, -0.10331046f, 0.26270384f, 
    0.13526833f, 0.12490496f, 0.04416319f, 0.05582482f, 0.10497525f, -0.02859060f, -0.07938217f, 0.09672739f, 
    0.08624951f, -0.15107629f, 0.22741327f, -0.09960031f, -0.04021576f, 0.02414944f, -0.02289038f, 0.09096631f, 
    -0.06435568f, 0.13412841f, 0.02753165f, -0.01684569f, -0.28647155f, -0.23744927f, 0.31500107f, -0.03660274f, 
    -0.09678797f, -0.07553955f, -0.04356989f, 0.00694974f, -0.06534233f, -0.03461101f, 0.03709325f, 0.09930158f, 
    -0.08886198f, 0.17960492f, -0.11264614f, 0.05349682f, 0.02607490f, -0.11980602f, 0.03900052f, -0.03138907f, 
    0.10307784f, -0.02236036f, -0.07268048f, -0.03232214f, 0.13615020f, 0.06555568f, -0.37495461f, -0.44889030f, 
    -0.04252193f, 0.16310692f, 0.16461903f, -0.04974002f, -0.02430770f, -0.05584829f, 0.09871923f, -0.07235029f, 
    0.00773526f, -0.05909108f, -0.11617699f, -0.17992166f, 0.22172554f, -0.02844580f, 0.11246251f, 0.11042423f, 
    0.02798243f, -0.02967853f, 0.05767174f, -0.04892771f, -0.03360124f, -0.03592866f, -0.07421784f, 0.20307764f, 
    0.17665482f, 0.09874976f, -0.03646901f, -0.02127177f, 0.03246245f, 0.00494651f, -0.02328623f, 0.01204240f, 
    -0.03707008f, 0.10746869f, 0.00883042f, -0.00106459f, -0.02367395f, -0.04546999f, 0.05064229f, -0.05755710f, 
    -0.02510327f, 0.16593216f, 0.16827235f, -0.01903270f, 0.31542060f, 0.08373547f, 0.24835302f, 0.32984480f, 
    0.09381698f, -0.00389564f, 0.20200510f, -0.18647830f, 0.02647121f, -0.00213541f, 0.05606528f, 0.14235410f, 
    -0.06856418f, -0.03420397f, 0.35454646f, -0.07553066f, -0.15274739f, 0.02358925f, -0.09769122f, 0.05464013f, 
    -0.12388173f, -0.05860977f, 0.06124471f, -0.01199979f, -0.14011219f, 0.12585658f, -0.39096132f, 0.12797926f, 
    0.13572153f, 0.07659916f, 0.08414015f, 0.05165816f, 0.15353589f, 0.11829496f, -0.01489547f, -0.02745939f, 
    -0.09762830f, 0.03593574f, 0.19305193f, 0.17930549f, -0.19508082f, 0.04792930f, -0.10028626f, 0.12110740f, 
    0.02260675f, 0.02789241f, 0.02622822f, -0.01175972f, -0.12514134f, -0.23847292f, -0.27070028f, 0.18382782f, 
    0.05075900f, 0.06744643f, -0.06592638f, 0.00732059f, -0.00280180f, 0.02976884f, 0.06645000f, -0.04579519f, 
    -0.08696561f, -0.06980789f, -0.03349282f, 0.08630468f, 0.11037477f, 0.13900895f, 0.10604285f, -0.01910349f, 
    -0.03894928f, -0.01085125f, 0.09586667f, -0.05767026f, 0.09987786f, -0.19109368f, 0.41488153f, -0.24788670f, 
    0.13850136f, -0.08663017f, -0.07640187f, 0.04201709f, 0.04233729f, 0.11226509f, 0.03193445f, 0.03247467f, 
    -0.26976421f, -0.27342659f, -0.01065996f, 0.14094749f, -0.10247748f, -0.09554294f, -0.00774673f, 0.08039018f, 
    -0.01604195f, -0.01435489f, -0.00959120f, 0.07076621f, -0.04382316f, 0.30754992f, 0.33453578f, -0.08253036f, 
    -0.17686023f, -0.24225874f, -0.17122808f, -0.03089174f, 0.03893105f, 0.07167494f, 0.13815615f, 0.01440389f, 
    -0.04872802f, 0.37621292f, -0.18887016f, 0.08072957f, -0.03249114f, -0.06961725f, 0.04089187f, 0.01184186f, 
    0.03407339f, 0.03450331f, -0.04626700f, 0.08004893f, -0.03573863f, -0.04148174f, -0.52376306f, -0.35867599f, 
    -0.05745451f, 0.26717550f, 0.29496211f, 0.02034573f, -0.00196646f, -0.01048580f, -0.00603659f, 0.01552027f, 
    0.24836044f, -0.34181380f, 0.20745264f, -0.04696522f, 0.08553808f, 0.13199773f, -0.00506866f, 0.05057533f, 
    -0.10831880f, -0.09169682f, -0.04346903f, 0.05131851f, 0.06823542f, -0.02408292f, 0.30258065f, 0.32013363f, 
    -0.07330325f, -0.02861001f, 0.00521598f, -0.08276208f, 0.13896960f, 0.10835473f, 0.04369364f, -0.03041661f, 
    -0.32880676f, 0.15753786f, -0.15667634f, 0.10631799f, -0.04259692f, -0.03985099f, -0.05023789f, -0.09705011f, 
    -0.04850362f, 0.01963557f, 0.01034726f, -0.05679210f, -0.02184722f, 0.00452650f, 0.03763287f, -0.02349007f, 
    0.05675319f, 0.06938402f, -0.03160284f, 0.13939647f, 0.11471419f, 0.09345394f, -0.06177533f, -0.08685893f, 
    0.14774768f, -0.06667495f, -0.12587067f, -0.03407758f, -0.12365371f, 0.11632720f, 0.13511540f, 0.00377412f, 
    0.07369204f, 0.08597054f, -0.21918432f, 0.04126308f, -0.05332502f, -0.01432540f, 0.21236950f, -0.12847912f, 
    0.07296548f, 0.01362538f, 0.04724807f, -0.04220875f, -0.00023645f, 0.10447440f, 0.14683565f, -0.02138022f, 
    0.15052134f, 0.03936214f, -0.19869944f, -0.34572080f, 0.03587349f, 0.03116026f, 0.19816761f, -0.01619984f, 
    0.09791873f, -0.00143544f, -0.02985964f, -0.04013622f, 0.23582487f, 0.35247344f, 0.36836120f, -0.08262777f, 
    -0.01998360f, -0.00231667f, -0.15536000f, -0.00723091f, -0.02053375f, 0.00330378f, -0.11058249f, 0.09658141f, 
    -0.01265643f, 0.20080803f, -0.11757336f, -0.04538963f, 0.21911266f, 0.01583088f, -0.00860688f, -0.06083966f, 
    -0.19797544f, 0.05668700f, 0.01022180f, 0.09253110f, 0.10136473f, 0.15241790f, 0.00839028f, 0.03028960f, 
    -0.06501175f, -0.01341580f, 0.01748855f, 0.10733610f, -0.12389314f, -0.03369896f, 0.02088502f, -0.10343247f, 
    0.02871422f, -0.00551939f, 0.09343863f, -0.05803841f, -0.09439468f, 0.00591057f, 0.05736998f, -0.00905077f, 
    0.01135026f, 0.08697616f, 0.22197425f, 0.15023306f, 0.08622257f, 0.22344926f, 0.28913492f, -0.08709983f, 
    -0.03061287f, -0.10022011f, -0.02934783f, 0.13147616f, 0.04542700f, -0.00208505f, 0.21355367f, 0.04633224f, 
    0.11248611f, -0.16761066f, 0.11628452f, 0.04589205f, 0.15147604f, 0.01535064f, -0.02925950f, -0.00338707f, 
    -0.09802682f, 0.06523951f, 0.12364610f, 0.11424085f, -0.01004359f, -0.13724141f, 0.04309054f, -0.02397599f, 
    0.02817356f, 0.07102455f, -0.07213702f, 0.10783570f, -0.08164819f, 0.00529283f, -0.04740937f, -0.10096626f, 
    0.16249682f, 0.06670986f, -0.06144603f, -0.03642682f, -0.20096436f, 0.05424903f, -0.10086215f, -0.02212548f, 
    -0.02200130f, -0.01176334f, -0.13245378f, -0.13349159f, -0.22387370f, -0.42715034f, 0.07084353f, 0.00583004f, 
    -0.30373016f, 0.06092571f, 0.02575482f, 0.04920044f, 0.07416534f, -0.04306698f, 0.00552828f, -0.00400348f, 
    -0.04369264f, 0.23788849f, 0.09386443f, -0.04920598f, -0.07151762f, -0.11419562f, -0.10291035f, -0.07067485f, 
    -0.06846827f, -0.01096965f, 0.06521239f, -0.11730780f, 0.11759286f, 0.38797429f, 0.01783512f, -0.23996599f, 
    0.00109133f, -0.02407896f, 0.02493197f, -0.15280215f, -0.03854625f, -0.11950145f, -0.00515289f, 0.08895208f, 
    0.06815318f, 0.12621157f, -0.00650440f, 0.08545634f, 0.08103394f, 0.11899666f, -0.00219361f, 0.02337616f, 
    -0.05322609f, 0.12469538f, -0.04723258f, -0.06429097f, -0.08791573f, -0.08538860f, 0.05480028f, 0.12708603f, 
    0.09278035f, 0.13677424f, -0.02414990f, -0.10764826f, 0.00080330f, -0.04575800f, -0.06011857f, -0.14237973f, 
    -0.01150744f, -0.00874103f, 0.01986882f, -0.20722502f, -0.13163882f, 0.09286963f, 0.04563971f, -0.09647594f, 
    0.03356320f, 0.17363620f, 0.11674482f, 0.06163514f, 0.07380213f, -0.01319247f, -0.06193733f, 0.22800116f, 
    -0.12979132f, 0.00389258f, 0.13525604f, -0.10845610f, 0.11042509f, 0.06074567f, -0.13643894f, 0.18977252f, 
    -0.20217714f, 0.03419276f, -0.12227184f, -0.17957395f, -0.22779660f, -0.19766203f, -0.01306115f, -0.03727278f, 
    -0.00797111f, 0.02157149f, 0.01596644f, 0.02323874f, -0.10283787f, -0.03229649f, 0.09517962f, 0.06501383f, 
    -0.03779488f, -0.17196596f, 0.13570145f, 0.12363855f, 0.10088152f, -0.02307873f, 0.15771346f, 0.06151488f, 
    -0.33641711f, 0.15147410f, 0.13175920f, 0.14083318f, 0.00976381f, -0.06647658f, 0.05167415f, 0.17540759f, 
    0.06387898f, -0.09457758f, 0.10914329f, -0.02817055f, -0.02010285f, 0.14517710f, -0.29953685f, 0.08789378f, 
    0.20933431f, 0.24264833f, 0.09283462f, 0.03578270f, 0.01919234f, 0.03564410f, 0.00401661f, 0.12301000f, 
    -0.07737785f, -0.04765859f, -0.09169722f, -0.00133429f, 0.22520278f, 0.06798847f, 0.11527690f, 0.08277037f, 
    0.08085939f, -0.04316618f, -0.01900610f, -0.02362897f, -0.20476235f, 0.05897647f, 0.06860656f, -0.23974109f, 
    0.16034327f, -0.07380253f, -0.03006656f, 0.02394032f, 0.17461109f, 0.26565254f, -0.15262321f, 0.01147407f, 
    -0.18454897f, -0.46579534f, -0.25227225f, -0.48633900f, -0.09782779f, 0.08722188f, -0.02705149f, -0.22610773f, 
    -0.05135135f, -0.08775456f, -0.00822039f, 0.00372681f, -0.04412285f, 0.19773072f, 0.06205353f, -0.05392146f, 
    -0.17083572f, -0.06195816f, 0.00425897f, -0.00036484f, -0.04752019f, 0.19120607f, 0.02841837f, 0.11063141f, 
    0.10106390f, 0.17688408f, -0.05122012f, 0.05602073f, 0.03381946f, -0.11881794f, 0.08007766f, 0.08723555f, 
    0.19257413f, 0.29671863f, 0.13875714f, 0.14145249f, 0.08164811f, -0.15595713f, 0.08368091f, -0.15782505f, 
    0.17778327f, 0.46390656f, 0.27259260f, 0.12095904f, 0.03738556f, -0.07073688f, -0.01638747f, -0.02248525f, 
    0.03825832f, 0.06772086f, -0.05575473f, 0.02565338f, 0.03353512f, 0.15580435f, 0.10607192f, 0.05075056f, 
    -0.07132719f, -0.03121085f, -0.14862394f, 0.10312461f, -0.22841948f, 0.18334505f, -0.03573750f, 0.31854677f, 
    0.05625534f, -0.01634221f, -0.06612693f, -0.04140881f, 0.16536929f, 0.18168043f, 0.17014979f, 0.01848211f, 
    -0.45075688f, -0.60583085f, -0.48094961f, -0.38568071f, -0.02376202f, -0.10892666f, -0.06255423f, -0.14837353f, 
    0.02926124f, -0.11930723f, 0.06230297f, 0.03376712f, -0.23919263f, -0.07708213f, -0.04650693f, -0.05749469f, 
    0.11180635f, 0.00960062f, 0.24756652f, 0.05040071f, 0.06761149f, 0.14463180f, 0.09389796f, 0.01055901f, 
    0.02652249f, -0.05257040f, 0.17112860f, -0.02946450f, 0.25811502f, 0.32606858f, 0.10660094f, 0.27494654f, 
    0.08246941f, 0.00964849f, 0.06618317f, -0.10585783f, 0.07693963f, -0.36817667f, 0.18557790f, -0.03961864f, 
    0.27883762f, -0.05287610f, 0.05461205f, 0.04887080f, 0.12810072f, -0.00594474f, 0.21639593f, 0.30418652f, 
    -0.09222200f, 0.01909705f, 0.12051945f, -0.16670512f, -0.01884188f, 0.04964631f, 0.09823585f, 0.11671153f, 
    -0.06420728f, -0.10545002f, -0.03572136f, -0.06330667f, 0.13497022f, 0.33735135f, 0.40582111f, -0.03662762f, 
    0.13294627f, -0.03018468f, -0.07494143f, 0.16242649f, -0.02116220f, 0.38457066f, 0.00081498f, 0.09035622f, 
    0.02095600f, 0.01035350f, -0.00622662f, -0.02977047f, 0.03398284f, 0.02832023f, 0.04856310f, -0.04380000f, 
    -0.00975229f, 0.00652080f, -0.08173964f, 0.00476456f, -0.05775607f, 0.01181881f, -0.06861399f, -0.01543706f, 
    -0.01611703f, -0.05424638f, 0.00336641f, -0.03215142f, -0.06351618f, -0.03321211f, -0.00804999f, -0.04667845f, 
    -0.05086550f, -0.03991863f, -0.05106240f, 0.03040364f, 0.05474682f, -0.00601033f, -0.02057252f, 0.03112218f, 
    -0.08195557f, -0.07377820f, 0.02595636f, 0.03113491f, -0.00178110f, 0.00945861f, -0.01948444f, -0.04976092f, 
    0.02168743f, -0.03243994f, -0.03394328f, -0.03771916f, -0.02174232f, 0.01776219f, -0.01826772f, 0.00101970f, 
    0.03786052f, -0.04264354f, 0.01348189f, -0.02590976f, -0.00363965f, 0.05868200f, 0.00962665f, 0.02681583f, 
    0.06489386f, 0.04570807f, -0.02762781f, -0.04537217f, 0.03711592f, -0.02865085f, 0.05315978f, 0.00969141f, 
    -0.05273121f, 0.04328451f, 0.02493725f, -0.02225633f, -0.06766152f, 0.01695445f, 0.05684703f, -0.01021984f, 
    -0.02066486f, 0.06737216f, 0.02778152f, -0.06645098f, 0.04108056f, 0.03069250f, -0.00268925f, -0.01459897f, 
    0.03242300f, 0.03418973f, -0.07399346f, -0.05248328f, 0.02956525f, 0.05212659f, -0.00923440f, 0.01687505f, 
    0.00280098f, 0.00652686f, 0.01709127f, -0.03823864f, -0.00984538f, -0.02626490f, 0.00187022f, 0.00313787f, 
    0.06259878f, -0.05439247f, 0.01649397f, 0.04592455f, -0.01919919f, 0.03966837f, 0.05841691f, -0.02873096f, 
    0.02898278f, -0.05504327f, -0.02301177f, -0.06084349f, -0.04397749f, -0.00769315f, -0.01590954f, -0.04978293f, 
    0.00835691f, 0.01057220f, -0.03049579f, -0.04567352f, -0.05122669f, -0.07532488f, -0.06044934f, 0.03312343f, 
    -0.06336706f, -0.00574213f, 0.00198992f, 0.01423256f, 0.00972922f, -0.03155334f, -0.05539391f, -0.05887721f, 
    -0.06517318f, 0.02028662f, -0.02980927f, -0.04100882f, 0.03259129f, 0.02362868f, -0.01406540f, -0.03187793f, 
    0.03980006f, -0.01685334f, -0.07283961f, 0.01699413f, -0.05286474f, -0.03526087f, -0.03956817f, -0.02123443f, 
    -0.01240439f, 0.03548294f, -0.05558475f, 0.05707395f, -0.06269260f, 0.02653559f, 0.02615375f, -0.05003880f, 
    -0.06972685f, 0.01884208f, -0.00711199f, 0.06473906f, -0.03257987f, -0.06830519f, -0.04267246f, 0.04209003f, 
    -0.03808679f, -0.07340330f, -0.01878227f, -0.05889087f, -0.05140205f, 0.04566900f, 0.04947650f, -0.06038180f, 
    0.03783321f, -0.04987119f, -0.00707391f, 0.00014020f, -0.03016099f, 0.05828212f, 0.06953853f, 0.04695202f, 
    0.06872120f, -0.01855625f, -0.06000285f, -0.05010489f, 0.00695942f, -0.05141525f, -0.05173712f, -0.00225774f, 
    -0.03351343f, -0.03250706f, -0.02230428f, 0.06149157f, 0.05292316f, 0.06354073f, 0.01323022f, 0.04236378f, 
    0.04329262f, -0.02372530f, -0.07057551f, -0.02023828f, 0.02353332f, 0.04613791f, -0.07837989f, 0.01568526f, 
    0.04223765f, 0.02418465f, 0.05927873f, 0.04077612f, -0.00949890f, 0.02310231f, -0.01897236f, 0.05895903f, 
    -0.03201278f, -0.02462076f, -0.03359473f, -0.04908885f, 0.06027574f, -0.00638529f, 0.02275360f, 0.02085191f, 
    -0.01299558f, 0.03857075f, 0.04845186f, -0.04048246f, 0.01735493f, -0.00909994f, -0.06510768f, -0.01663054f, 
    -0.04091097f, -0.04629732f, -0.01711309f, -0.03024697f, -0.01436967f, -0.05635469f, 0.02742797f, 0.04466837f, 
    -0.02853791f, 0.03831053f, -0.04388582f, -0.05848023f, 0.01462796f, 0.03000366f, -0.01569655f, 0.03688016f, 
    -0.01964290f, -0.07470787f, 0.00467158f, -0.03788058f, 0.06169432f, -0.02010130f, 0.04285985f, -0.00177673f, 
    0.02713803f, 0.02897040f, -0.03481409f, -0.02078281f, -0.00280983f, -0.02443282f, -0.05641596f, -0.07295671f, 
    -0.01561030f, 0.06505659f, -0.02714588f, -0.01550257f, -0.03653309f, -0.01783505f, -0.00414711f, -0.02277187f, 
    0.06001372f, -0.02449150f, 0.06038281f, -0.01569797f, 0.01182631f, -0.06999600f, 0.03359584f, 0.05868129f, 
    -0.05124069f, -0.03977773f, -0.00871623f, -0.02615173f, 0.03233065f, -0.07019190f, 0.02384151f, 0.00809699f, 
    -0.04799662f, 0.02587498f, -0.03245246f, -0.02911962f, -0.03716451f, 0.02089548f, 0.02068599f, 0.02899074f, 
    -0.06977213f, -0.06798199f, -0.03141970f, -0.01288994f, 0.05566540f, -0.04358884f, 0.03181490f, 0.00956312f, 
    0.01181818f, 0.00706319f, 0.03331524f, -0.03092045f, -0.07416335f, -0.01963110f, -0.04432991f, -0.03499625f, 
    -0.03695085f, 0.02772841f, -0.00303401f, 0.03355747f, -0.04379654f, -0.02793088f, -0.01807925f, -0.06855512f, 
    -0.01087943f, -0.00739699f, -0.01873360f, 0.03658320f, -0.06033355f, -0.03729590f, -0.06806246f, -0.01869044f, 
    -0.05651842f, -0.03976933f, -0.02182751f, -0.05297004f, 0.01977912f, -0.07475189f, 0.03969171f, -0.06296492f, 
    0.03578709f, 0.02097555f, -0.04000182f, -0.04757085f, -0.07417805f, -0.03375398f, -0.02498988f, 0.00986867f, 
    0.00646831f, -0.03236189f, -0.07216464f, 0.04746176f, -0.05900080f, -0.02266088f, 0.06067801f, 0.01838296f, 
    0.04329095f, 0.02410743f, -0.04247141f, 0.00116847f, -0.03512648f, -0.02814916f, 0.05592623f, 0.05978681f, 
    0.04502540f, 0.01962760f, 0.06343542f, -0.06494635f, -0.07048161f, -0.03150048f, 0.03490803f, -0.00611020f, 
    0.05009007f, -0.06243774f, -0.04411979f, -0.00774905f, 0.03762125f, -0.06674410f, -0.03033356f, -0.03698391f, 
    0.02854617f, 0.00636193f, 0.06416003f, -0.03956753f, 0.03280465f, 0.01495067f, 0.01753913f, 0.02546504f, 
    0.00044396f, -0.05410342f, 0.05871166f, 0.04051127f, 0.05275346f, -0.01877916f, -0.01590362f, 0.05897056f, 
    -0.30697674f, -0.52588916f, -0.25119066f, -0.00608891f, 0.00831256f, -0.10260160f, -0.02004408f, -0.09269572f, 
    0.04316432f, -0.07256657f, -0.06000181f, -0.06776966f, -0.19455662f, -0.10806028f, 0.08654435f, -0.10228480f, 
    0.13008735f, 0.15606456f, 0.09329145f, 0.04862629f, -0.06705051f, 0.00213903f, -0.05026609f, -0.05130845f, 
    0.05120824f, 0.06364247f, 0.13485700f, 0.07089198f, -0.14413533f, -0.03277054f, -0.07513823f, 0.00540391f, 
    -0.11575422f, -0.03714588f, -0.10425194f, 0.05761642f, 0.11347319f, 0.00850187f, -0.12568395f, 0.00663429f, 
    0.06549016f, -0.09244721f, -0.03836652f, -0.00981304f, -0.03974438f, -0.06351130f, -0.07792143f, 0.03011646f, 
    0.10782773f, 0.15198985f, 0.07679206f, -0.02071913f, -0.00562776f, -0.04976520f, 0.02186238f, 0.19693589f, 
    -0.00508245f, 0.04683476f, -0.00743085f, 0.04168068f, 0.04127617f, -0.43907019f, -0.13306481f, -0.18556394f, 
    0.04913554f, -0.03970445f, 0.03768867f, -0.20518143f, 0.20007274f, 0.10037236f, 0.09081890f, -0.17721227f, 
    0.05048838f, -0.07610002f, 0.11004516f, -0.01400418f, 0.00683010f, 0.07649554f, 0.12004411f, -0.03781829f, 
    0.10042997f, -0.03997198f, 0.07499409f, -0.11906117f, 0.29875562f, 0.20353484f, 0.23924623f, 0.14013341f, 
    -0.00105221f, -0.03032818f, -0.00477856f, -0.13052039f, 0.00675740f, 0.01501647f, 0.01201112f, 0.06665140f, 
    0.06681425f, 0.17172731f, -0.05985137f, 0.06721606f, 0.04556971f, -0.01829700f, 0.03205861f, 0.06602237f, 
    -0.00405084f, 0.14722236f, 0.04273297f, -0.02458703f, -0.13476412f, -0.02991186f, 0.13546382f, 0.23658812f, 
    -0.01661936f, 0.05770019f, -0.00159448f, 0.08404224f, -0.08873112f, -0.03890872f, -0.00255119f, 0.10656162f, 
    -0.21735941f, 0.08168933f, -0.28933328f, -0.16103359f, 0.24925694f, -0.23215207f, 0.18837599f, 0.21737693f, 
    0.06318417f, 0.00477659f, 0.01650622f, -0.07791986f, -0.13853711f, -0.25396818f, -0.11944464f, -0.43935522f, 
    -0.03646845f, 0.01337803f, -0.14314160f, -0.00455537f, 0.16366981f, 0.09769789f, 0.14337425f, 0.16399913f, 
    0.01276562f, 0.10432766f, -0.10469699f, 0.13900186f, 0.05631967f, 0.05022291f, 0.03832583f, -0.04964836f, 
    -0.11048938f, -0.06847432f, 0.06394641f, -0.00807555f, 0.12983197f, -0.04454113f, -0.21681505f, -0.02893519f, 
    -0.13499461f, -0.01667384f, 0.01085070f, -0.15726545f, -0.03727286f, 0.12724486f, 0.05263265f, 0.04036148f, 
    0.35397360f, 0.01493801f, 0.24693960f, 0.14054385f, -0.03695302f, -0.07487473f, -0.08830939f, 0.04627563f, 
    0.06337708f, -0.01116329f, 0.01275892f, 0.04996011f, 0.09036201f, -0.29009515f, -0.20725878f, -0.11896230f, 
    -0.02341017f, 0.04320903f, -0.08448576f, -0.12973078f, 0.05540475f, -0.11071108f, 0.04310971f, -0.07684790f, 
    -0.00399853f, 0.13492358f, 0.06192858f, 0.12267371f, -0.06613087f, 0.03757539f, -0.13806371f, 0.05221269f, 
    -0.04036523f, 0.10035433f, 0.04118282f, 0.10399660f, 0.16115279f, 0.02010775f, -0.23123497f, -0.09985583f, 
    -0.09945188f, 0.05585235f, 0.10556074f, 0.03011012f, 0.05538802f, 0.04367645f, -0.03248886f, 0.21665010f, 
    -0.16991147f, -0.09684267f, 0.01229019f, 0.07744589f, 0.11040197f, -0.00464262f, 0.10096133f, 0.14583039f, 
    -0.16788538f, -0.09527501f, -0.14056823f, -0.30089831f, 0.13713767f, 0.13858502f, 0.19433340f, 0.19836332f, 
    0.20411164f, -0.07463957f, -0.02007259f, -0.13965277f, -0.00891920f, -0.08486653f, 0.18026631f, -0.05203031f, 
    -0.09200315f, -0.11041722f, -0.07503175f, 0.06106810f, -0.02072597f, -0.13260944f, -0.10667685f, -0.19940785f, 
    -0.12555683f, -0.01503297f, -0.19653420f, -0.14205933f, -0.03438513f, 0.16975668f, 0.23495410f, 0.35217023f, 
    -0.01442110f, -0.13520853f, 0.17007905f, 0.09732589f, -0.12323976f, -0.06115825f, -0.07799628f, 0.12243468f, 
    0.09981360f, 0.16829778f, -0.30796885f, -0.04587680f, -0.14382081f, -0.15498668f, -0.11111683f, -0.07164400f, 
    0.05149982f, 0.10800556f, 0.23251967f, 0.19578102f, -0.08938791f, 0.08891416f, -0.02450883f, 0.50581896f, 
    0.27909455f, 0.15108177f, 0.11678320f, -0.19918324f, 0.01943879f, 0.08034834f, 0.03372715f, -0.00547715f, 
    -0.12235095f, -0.11091257f, -0.05982899f, -0.01350122f, 0.10426338f, 0.13402626f, 0.00792521f, -0.09556386f, 
    -0.01718464f, 0.16890213f, -0.02514467f, 0.19649191f, 0.01344542f, 0.27366018f, 0.15914847f, -0.21148483f, 
    -0.05345651f, 0.11508533f, -0.14121543f, -0.04452450f, -0.02532641f, 0.06221964f, -0.06707805f, -0.03545311f, 
    0.06648242f, -0.04585455f, -0.17911175f, 0.07610876f, 0.03942965f, 0.03441976f, -0.07908776f, 0.06131237f, 
    -0.00178178f, 0.11089917f, 0.05147386f, -0.01826700f, -0.33448231f, -0.21011029f, -0.04475170f, 0.13348699f, 
    0.05565583f, 0.02483057f, 0.14543520f, -0.02064037f, 0.04749193f, 0.21110417f, 0.15994020f, 0.12531824f, 
    0.13970052f, -0.23544356f, 0.16925992f, -0.02984096f, 0.17843091f, -0.03574594f, -0.16379884f, 0.18680170f, 
    0.00225703f, -0.03967382f, -0.22922243f, -0.18281859f, -0.16438331f, -0.21865526f, 0.11159206f, 0.04713250f, 
    0.06430607f, -0.13877207f, -0.10435022f, 0.01207984f, -0.12486933f, -0.17378902f, 0.08819360f, -0.07716347f, 
    -0.45407686f, 0.27011067f, -0.17740564f, -0.17712027f, 0.14877708f, 0.20021385f, -0.00344853f, -0.09592825f, 
    0.02126143f, -0.02284998f, 0.09201300f, -0.10399848f, 0.14362289f, 0.37609991f, 0.34756267f, 0.38083792f, 
    0.10047746f, -0.11668703f, 0.12966192f, -0.05762905f, -0.03671509f, 0.19902861f, 0.06439169f, -0.08364965f, 
    -0.02253938f, 0.17864919f, -0.30008769f, -0.10574684f, -0.03913887f, 0.14938594f, -0.05999485f, -0.11665773f, 
    0.03694479f, 0.09801935f, -0.09294154f, 0.03767063f, -0.13691978f, 0.08392758f, 0.15642096f, -0.30853117f, 
    -0.09707852f, 0.16842286f, -0.07397410f, 0.07429462f, -0.06879894f, -0.04785619f, -0.16144297f, 0.07674711f, 
    0.05035128f, 0.07625141f, 0.00098691f, 0.05307765f, 0.05677703f, -0.03984499f, 0.06634378f, -0.12074337f, 
    -0.09343682f, 0.12865281f, 0.07383110f, 0.00280457f, 0.24031411f, 0.13499172f, 0.24497956f, 0.12283716f, 
    -0.00720838f, -0.10693549f, 0.13352047f, -0.11616039f, 0.14371037f, 0.05250342f, 0.13872617f, -0.03176627f, 
    -0.06477678f, -0.17617799f, -0.47393653f, -0.32974729f, 0.07592338f, -0.01734934f, -0.13190177f, 0.17559154f, 
    -0.05963426f, 0.03812150f, -0.06330432f, 0.04469147f, -0.10012338f, -0.22631703f, -0.08840825f, -0.58186346f, 
    -0.13622095f, -0.05828550f, 0.01626655f, 0.11276668f, 0.13208531f, 0.00487247f, 0.11288640f, -0.00204803f, 
    -0.03876586f, 0.15867856f, -0.08067194f, 0.16604061f, -0.14629951f, 0.09691383f, -0.02572148f, -0.07862078f, 
    -0.00628288f, -0.11747234f, -0.12258231f, 0.00864838f, 0.09870391f, 0.17553820f, -0.16606109f, 0.17112111f, 
    -0.10573549f, -0.01267372f, -0.08895198f, 0.05811661f, 0.10338246f, 0.03298105f, 0.04457861f, 0.01430005f, 
    0.23819336f, -0.17087093f, 0.23760152f, 0.08598980f, -0.03793145f, 0.04931980f, -0.11534521f, -0.09813575f, 
    -0.04764498f, 0.06575916f, -0.11168766f, -0.11545771f, 0.20158748f, 0.19188257f, 0.30670962f, 0.04747267f, 
    -0.20044339f, 0.13682599f, 0.00807896f, -0.05804244f, 0.00570528f, -0.04906687f, 0.05673816f, 0.11994398f, 
    0.06987572f, 0.03221837f, -0.11510036f, -0.15460828f, 0.04827463f, 0.22667608f, 0.10379448f, 0.18543936f, 
    -0.15824346f, -0.05223152f, 0.07257831f, 0.03211191f, 0.13411291f, -0.05807638f, 0.02542537f, -0.06795565f, 
    -0.04796278f, -0.01454599f, 0.04876301f, 0.09890722f, -0.06856650f, -0.20616633f, 0.08263189f, -0.09803490f, 
    0.07233338f, -0.06251618f, 0.04569002f, -0.18448611f, 0.05823170f, 0.20980027f, -0.07527620f, 0.07607038f, 
    -0.01108266f, 0.05098840f, 0.00762132f, -0.04591073f, 0.22954021f, -0.11002654f, -0.32292217f, 0.05466620f, 
    -0.01315904f, -0.10297291f, 0.14739713f, 0.02795040f, 0.02422988f, 0.05009472f, -0.02900125f, -0.20458721f, 
    0.16599463f, 0.18596761f, -0.17209886f, 0.16824472f, 0.11098196f, -0.02017999f, 0.05912219f, 0.00456439f, 
    0.06911637f, 0.06144063f, 0.00478647f, -0.05804703f, 0.20675227f, -0.00731282f, -0.09550720f, -0.47305548f, 
    -0.03336604f, -0.07652156f, 0.15129061f, -0.22599530f, 0.04969720f, 0.29037803f, -0.00289898f, -0.04787200f, 
    0.28399783f, -0.09111661f, 0.01994496f, 0.20936976f, -0.04207043f, -0.07692865f, -0.05043834f, 0.06330962f, 
    0.14400986f, -0.07623219f, 0.05273947f, 0.13690066f, -0.03187783f, -0.02280969f, -0.04646271f, 0.08354580f, 
    -0.00108659f, 0.07385237f, 0.02732391f, -0.07598255f, 0.06622958f, -0.06628689f, 0.12748706f, -0.02903030f, 
    -0.02765243f, -0.15451276f, -0.06019365f, -0.09987387f, 0.03553441f, 0.00816357f, 0.02073782f, 0.15840410f, 
    -0.19044010f, -0.24573168f, -0.29066953f, -0.28229979f, 0.16966937f, 0.02488615f, -0.09330616f, -0.00464395f, 
    0.07937489f, -0.08789875f, -0.13363007f, 0.02381595f, -0.20111285f, -0.15966353f, -0.22624590f, -0.20097131f, 
    0.10988377f, 0.26441705f, -0.11445317f, -0.01047482f, -0.11337583f, 0.00398542f, -0.10329672f, 0.04051351f, 
    -0.03643469f, -0.03477677f, 0.00180653f, -0.09137259f, 0.19616927f, 0.17411011f, 0.17788364f, -0.14930852f, 
    -0.01956905f, -0.17658558f, 0.01881576f, -0.05637839f, 0.15279377f, 0.12268128f, 0.21994625f, 0.19904631f, 
    -0.39396125f, 0.05026817f, -0.09944237f, 0.04952819f, -0.13440736f, -0.23885708f, 0.08381978f, -0.05036664f, 
    0.18147935f, -0.04317756f, 0.10842389f, 0.19591752f, 0.03847588f, 0.44756380f, -0.18346332f, 0.09148564f, 
    0.07141931f, 0.17613350f, 0.04631995f, -0.12462153f, -0.10064667f, 0.01380512f, 0.04332520f, 0.06110394f, 
    0.02735440f, -0.39562017f, -0.02820130f, -0.18676268f, -0.16842964f, 0.10381558f, 0.02461906f, -0.07870723f, 
    0.11060505f, -0.06085825f, -0.01363821f, 0.11134057f, 0.02650457f, -0.15669627f, 0.12929972f, 0.24239546f, 
    -0.04707959f, -0.06745161f, -0.04103998f, -0.08897583f, 0.00061313f, -0.06576430f, 0.04336343f, -0.06121036f, 
    0.17167392f, 0.28995508f, 0.10106125f, -0.10070547f, -0.12652822f, 0.08569012f, 0.07548025f, 0.06345455f, 
    0.09899364f, -0.08496603f, -0.02067412f, 0.02135013f, 0.13773023f, 0.17470852f, 0.10399964f, -0.15817147f, 
    0.13604355f, -0.08589845f, -0.01876200f, 0.07319847f, 0.08966859f, 0.09282190f, 0.10018674f, 0.11140455f, 
    -0.07977734f, 0.00098500f, -0.14588685f, 0.11817542f, 0.03114142f, -0.11570456f, -0.00364242f, 0.03630454f, 
    0.03971195f, -0.00811188f, -0.34582293f, -0.28537521f, -0.03081631f, -0.17269184f, 0.04466334f, -0.06725605f, 
    -0.05583227f, 0.00011358f, -0.03442686f, 0.26576325f, -0.02071706f, 0.09625214f, 0.08668194f, -0.04527617f, 
    -0.10306398f, -0.28600276f, -0.15893069f, 0.26328811f, 0.04859509f, 0.16824594f, 0.13533661f, 0.01290505f, 
    -0.03474363f, -0.01814004f, -0.04583077f, 0.05345728f, 0.22416203f, 0.02622818f, 0.20488867f, -0.11939635f, 
    -0.13142498f, -0.02723105f, -0.11143442f, -0.06639492f, -0.03965442f, 0.03912351f, -0.01489014f, -0.14636490f, 
    0.38370988f, -0.10349445f, 0.23128600f, 0.25261471f, -0.06318340f, -0.04536990f, 0.06324679f, 0.12566142f, 
    0.27437189f, -0.01511227f, 0.06510063f, 0.12782633f, 0.19796872f, -0.03838343f, -0.04598794f, 0.16353817f, 
    0.10182608f, 0.09205481f, -0.03644982f, -0.04282286f, -0.04629268f, -0.03768037f, 0.03765696f, 0.05192982f, 
    -0.21843804f, -0.14602101f, -0.08861756f, -0.06139721f, 0.03306924f, 0.09295307f, 0.02138617f, 0.15457578f, 
    -0.45390713f, -0.09442177f, -0.33494619f, -0.42916569f, 0.16846520f, 0.07738560f, -0.15432152f, -0.09983084f, 
    0.16743535f, -0.10234449f, -0.09784070f, -0.12874095f, -0.17410477f, -0.32113901f, -0.17361604f, -0.28628567f, 
    -0.04984668f, -0.05960969f, -0.14725035f, -0.04050333f, 0.08938520f, 0.05442758f, -0.06298186f, 0.10643207f, 
    -0.15632784f, -0.06270714f, -0.18496515f, -0.21595423f, 0.20552729f, 0.34187791f, 0.18029043f, 0.22822814f, 
    -0.22569463f, -0.04494832f, 0.12706567f, 0.01352222f, 0.22500874f, 0.10898969f, 0.03176667f, 0.25521678f, 
    -0.07864359f, 0.00559451f, -0.15901317f, 0.00169054f, -0.05313383f, -0.21298429f, -0.06247823f, -0.10256200f, 
    0.17863289f, 0.18281864f, 0.30315906f, 0.26556581f, -0.16368620f, 0.28469694f, 0.14340515f, 0.20658030f, 
    0.16055298f, 0.10077975f, 0.03675381f, -0.13198705f, -0.05440661f, -0.14006101f, -0.01086182f, 0.06579980f, 
    0.16120018f, -0.19149469f, -0.10096631f, 0.06287473f, -0.00092246f, -0.02456979f, 0.02527561f, -0.07727237f, 
    0.09050138f, 0.22822258f, 0.00457157f, 0.31430030f, 0.26204830f, 0.07616088f, 0.03831074f, 0.00742211f, 
    -0.09530210f, -0.12126508f, -0.05173154f, 0.11149841f, -0.06887492f, 0.02343642f, -0.00312022f, -0.12812264f, 
    0.07241648f, -0.03659286f, -0.04919367f, -0.07387581f, 0.09869096f, -0.02768474f, -0.15351062f, 0.02149920f, 
    -0.01101052f, 0.00207021f, -0.04440075f, -0.04791624f, -0.13600515f, 0.00401450f, 0.00284997f, -0.00968289f, 
    0.04431782f, 0.13852218f, 0.26149833f, 0.20450722f, 0.06342626f, 0.24790183f, 0.26872006f, 0.21126656f, 
    -0.10062753f, -0.03607952f, 0.11893301f, -0.08425871f, 0.10565177f, -0.05710794f, -0.09709744f, 0.06044936f, 
    0.02349274f, -0.08961927f, -0.06502443f, -0.22886594f, -0.14027862f, 0.02331788f, 0.02981728f, -0.07422972f, 
    0.01885481f, 0.00935549f, -0.16541107f, 0.18280792f, -0.08941178f, 0.00647041f, 0.09572826f, 0.00836674f, 
    -0.26404059f, 0.01163154f, 0.01227668f, -0.00646254f, 0.14947166f, 0.14146651f, -0.12537612f, -0.11786816f, 
    -0.01196919f, -0.17334932f, -0.08228587f, -0.07171497f, 0.05464439f, 0.38882369f, 0.36315438f, 0.07601693f, 
    -0.15962510f, -0.08410631f, 0.00146357f, -0.00629769f, -0.09245703f, 0.20669913f, 0.02240759f, 0.00512278f, 
    -0.12184671f, 0.20132279f, -0.05010158f, 0.06905738f, 0.09242464f, 0.14940087f, 0.07314291f, 0.09317707f, 
    0.09436379f, 0.08442365f, -0.02690191f, -0.03126982f, -0.11617296f, 0.23645514f, 0.19641618f, 0.14093252f, 
    0.07845176f, -0.03497293f, 0.07232738f, 0.10387401f, -0.02833232f, 0.07955822f, -0.05087464f, -0.02506554f, 
    -0.07813460f, -0.00914124f, -0.11257459f, 0.06136661f, -0.03391079f, -0.03057526f, -0.04227535f, -0.11025912f, 
    0.08165025f, 0.06320332f, 0.06827301f, 0.18848471f, -0.11810198f, -0.08316619f, 0.05211115f, -0.16707523f, 
    -0.05418433f, -0.04045538f, 0.05673319f, -0.13739391f, 0.29251033f, 0.14348829f, 0.06819540f, 0.11009295f, 
    -0.02286017f, -0.07015082f, 0.04226549f, -0.10424639f, 0.17666969f, 0.05791042f, 0.02604651f, 0.25886345f, 
    -0.03180193f, 0.00071990f, 0.00171355f, 0.05860442f, 0.03359666f, -0.07592206f, -0.19610770f, -0.19169970f, 
    0.06138149f, 0.21392964f, 0.00991944f, 0.11510218f, -0.03831857f, -0.03090831f, -0.00105809f, -0.20289099f, 
    -0.24671985f, -0.10299806f, 0.01172591f, 0.03669481f, 0.07767927f, 0.08755790f, -0.06190759f, 0.07434478f, 
    -0.06995419f, -0.16717477f, -0.08388292f, -0.21500926f, -0.16057047f, -0.04585440f, -0.08916730f, -0.21194801f, 
    -0.02381579f, -0.04916409f, -0.09368245f, 0.01073316f, -0.15026177f, -0.08146657f, 0.04383231f, -0.06756172f, 
    -0.03934389f, -0.13560612f, 0.30766937f, -0.06760416f, -0.09360601f, -0.05847854f, -0.08644337f, -0.09260757f, 
    -0.08869115f, 0.00518069f, -0.11912067f, -0.15888679f, 0.05951347f, -0.08539917f, 0.08032233f, 0.16954018f, 
    -0.15464216f, -0.20026223f, 0.01233329f, -0.06512389f, 0.18577759f, 0.02042740f, 0.12606040f, 0.09071842f, 
    0.03172454f, -0.06135276f, -0.00630116f, -0.09225982f, 0.04220138f, 0.04761633f, 0.17041014f, 0.01538609f, 
    -0.03936490f, 0.03884732f, 0.04841663f, 0.05403852f, 0.22544944f, 0.06827188f, 0.04946788f, 0.06026905f, 
    0.02416422f, 0.10009997f, -0.02567696f, 0.01381417f, -0.09982215f, -0.13194124f, 0.00066728f, -0.01419940f, 
    0.08087336f, -0.06282740f, -0.01888774f, -0.12867168f, -0.00729564f, 0.06309783f, 0.10310416f, -0.01845975f, 
    0.08796537f, -0.05675342f, 0.07587279f, 0.17808871f, 0.07805209f, 0.02527337f, 0.00193507f, 0.07589068f, 
    0.08015717f, -0.02458264f, -0.03300474f, 0.02022822f, 0.19450022f, -0.05854776f, -0.03438884f, 0.00790897f, 
    -0.04693072f, 0.11095563f, -0.23209740f, 0.00976146f, 0.05323490f, -0.18267594f, -0.11071924f, -0.01765212f, 
    -0.03930919f, -0.01635222f, -0.05604954f, -0.00232866f, 0.14730123f, -0.09449409f, 0.13751426f, -0.18565595f, 
    0.03261136f, 0.09235542f, 0.10024714f, -0.02372985f, 0.17890121f, -0.03480648f, 0.13832591f, 0.05522688f, 
    0.30845839f, 0.05174355f, 0.36360678f, 0.21221255f, -0.06399749f, -0.02996781f, -0.06360321f, -0.07452627f, 
    0.04338529f, -0.06094022f, 0.12643555f, 0.13419080f, -0.05799099f, -0.15441357f, -0.27851468f, -0.09646350f, 
    0.06898716f, 0.04245289f, -0.02793511f, 0.07188856f, -0.05205704f, -0.05457387f, 0.00059654f, 0.02987120f, 
    -0.04060211f, 0.01774000f, 0.07628869f, 0.09645297f, -0.01964326f, -0.04268634f, 0.13544677f, -0.00203165f, 
    -0.04258276f, -0.09004329f, -0.13730827f, -0.15981615f, 0.28944409f, 0.07008651f, 0.09323165f, 0.08902208f, 
    0.25289011f, -0.03434331f, -0.10730183f, 0.03813115f, -0.28538370f, -0.06523442f, -0.03081082f, -0.06789204f, 
    0.08844139f, 0.03078383f, -0.02492667f, 0.21166016f, -0.20971556f, -0.11343899f, -0.11015197f, -0.22262311f, 
    -0.06947628f, -0.10822675f, -0.03161196f, -0.14052856f, 0.05615749f, 0.20204580f, 0.18747269f, 0.18172401f, 
    -0.04491296f, -0.08746828f, -0.00593664f, -0.04233752f, 0.15526730f, 0.12941222f, 0.06248921f, 0.13195108f, 
    0.21010339f, 0.04771583f, 0.03839485f, -0.21167922f, -0.06137960f, -0.08728041f, 0.01270063f, 0.03375820f, 
    0.20006169f, 0.10349266f, 0.04861125f, 0.14026697f, -0.02599317f, 0.11172391f, 0.04777247f, 0.08690244f, 
    -0.07227460f, 0.01408955f, 0.09898639f, 0.00847292f, 0.13445231f, 0.11916407f, 0.10747409f, 0.14106531f, 
    0.08350317f, 0.28639776f, -0.24429269f, 0.08754548f, 0.06686286f, 0.08842561f, 0.06438401f, 0.02173891f, 
    -0.00162433f, 0.08004960f, 0.18556598f, 0.21102320f, -0.13088755f, 0.18986475f, 0.01583549f, 0.06278773f, 
    0.17666729f, 0.11877783f, 0.10251485f, 0.04846045f, -0.18027152f, 0.14978439f, -0.02358573f, -0.02395250f, 
    -0.08813936f, 0.10639906f, -0.07391661f, 0.20225397f, -0.01882429f, -0.09170376f, -0.05473275f, 0.05684468f, 
    -0.10277357f, -0.01652994f, -0.09221318f, -0.17182258f, -0.16725926f, 0.13153261f, 0.00147287f, -0.11030490f, 
    0.05128724f, -0.02074827f, 0.06634507f, 0.13828987f, -0.01933447f, 0.07876954f, 0.08898276f, 0.16827060f, 
    -0.01018370f, 0.16508660f, -0.13686301f, 0.25809479f, 0.07772730f, -0.11646351f, -0.02661983f, -0.16460471f, 
    -0.11305169f, 0.02114221f, -0.04354517f, -0.18455642f, 0.16804662f, -0.00833300f, 0.14265335f, -0.00051532f, 
    0.01583886f, -0.07129733f, 0.06861940f, -0.05445854f, -0.22301175f, -0.02634434f, -0.03099973f, -0.20217153f, 
    0.14226635f, -0.25719208f, 0.34659460f, -0.13223411f, -0.10435785f, 0.05967202f, 0.00095465f, 0.08810668f, 
    -0.02661173f, 0.03217078f, 0.00194531f, 0.02005284f, 0.14360464f, 0.40582678f, 0.07198539f, 0.17680939f, 
    -0.04591034f, -0.01498104f, -0.09605341f, 0.04410137f, -0.13016511f, -0.06916980f, -0.05193666f, -0.10918487f, 
    0.28622895f, -0.06913053f, 0.02563426f, -0.16733895f, -0.02333221f, -0.03831749f, 0.09464789f, 0.12689942f, 
    0.01487189f, 0.01350307f, -0.03745382f, 0.09078386f, -0.04731325f, -0.22518562f, 0.31833202f, 0.15251139f, 
    -0.14113529f, 0.04517232f, -0.13315432f, 0.09642757f, -0.03623571f, -0.05225659f, 0.08573230f, -0.04280163f, 
    -0.06954126f, -0.23494527f, -0.05723550f, -0.08447562f, 0.10681898f, 0.02707463f, -0.14581503f, 0.10294713f, 
    -0.09249381f, -0.02826782f, -0.22697346f, 0.00855159f, 0.02613894f, 0.12596628f, -0.24999523f, 0.03352255f, 
    0.15629508f, -0.03331338f, 0.20939106f, -0.16629057f, 0.05796362f, -0.07019337f, -0.10010156f, -0.18728648f, 
    -0.07735919f, 0.19637586f, 0.09053870f, 0.25091588f, 0.10940082f, -0.05221776f, 0.01227881f, 0.12382329f, 
    0.03465667f, -0.04256689f, -0.00053684f, -0.03157542f, 0.04172562f, 0.29159054f, -0.02298383f, 0.09084583f, 
    -0.11026093f, 0.08385759f, 0.08459872f, 0.20506018f, 0.09991281f, -0.09819458f, -0.02940079f, -0.00606308f, 
    -0.15286343f, 0.02210564f, -0.13429011f, 0.04169879f, -0.10262973f, 0.10718704f, -0.01372383f, -0.18863338f, 
    0.04639446f, 0.08793976f, 0.04821677f, 0.09225845f, -0.06558451f, 0.00229949f, -0.05662097f, 0.29061988f, 
    0.00336727f, 0.06594080f, -0.09592540f, -0.04503188f, 0.06419332f, -0.17731190f, -0.00823311f, 0.01942332f, 
    0.14638834f, -0.34783712f, -0.02451341f, 0.08256990f, 0.05224708f, -0.02442482f, 0.00233591f, 0.09276756f, 
    -0.01300004f, 0.10656968f, -0.05367022f, 0.01301664f, 0.24573296f, 0.03846657f, -0.11836769f, -0.22973883f, 
    -0.05642707f, -0.13132511f, -0.03405504f, 0.27775323f, -0.04679410f, 0.06338612f, 0.06189927f, 0.04379582f, 
    0.29047427f, -0.14183225f, 0.44194597f, 0.26384836f, 0.17983702f, 0.11037870f, -0.06134207f, 0.06634084f, 
    -0.08374827f, -0.05512409f, 0.00491267f, -0.02521259f, 0.11949530f, -0.03532839f, 0.01185185f, 0.05190138f, 
    -0.08279344f, 0.16807424f, 0.25715679f, 0.19085748f, -0.03048523f, 0.05513687f, 0.03203994f, 0.11586774f, 
    -0.09939095f, -0.20835336f, 0.24099129f, -0.16054763f, 0.02125617f, 0.17097244f, 0.04282907f, 0.12713872f, 
    0.10589331f, -0.20908035f, 0.07816725f, -0.06216475f, -0.27362680f, 0.38849959f, -0.16507897f, -0.13790376f, 
    -0.07390965f, -0.02843881f, 0.04080708f, -0.01459148f, -0.10511366f, -0.00767754f, -0.01708453f, -0.03837713f, 
    -0.03610627f, 0.03670254f, -0.18610582f, -0.07090568f, 0.18967511f, -0.11519273f, -0.05878654f, -0.08783407f, 
    0.18828201f, -0.06519545f, -0.05780602f, -0.02400702f, -0.01715731f, -0.06226749f, -0.01780125f, 0.05035888f, 
    -0.10521810f, 0.08029879f, 0.11347996f, 0.11914653f, -0.00508461f, 0.15587401f, -0.08278222f, 0.10290539f, 
    -0.06346022f, 0.02658022f, -0.00246722f, 0.01025812f, -0.03773016f, -0.02629095f, -0.06607947f, -0.03548039f, 
    -0.00728185f, -0.01880680f, -0.03613282f, -0.06307830f, 0.03700165f, -0.07524682f, 0.00158026f, -0.01697437f, 
    0.04638457f, -0.07805081f, -0.02948243f, -0.03424162f, 0.04457405f, 0.03578183f, -0.02058957f, -0.00650256f, 
    0.00232751f, -0.00236147f, 0.05679765f, -0.07310379f, -0.01434990f, -0.07681935f, 0.04045285f, 0.05249991f, 
    0.05095033f, 0.04797898f, -0.07416420f, 0.04273815f, 0.01538795f, -0.02875386f, 0.04579997f, -0.00913786f, 
    -0.06164623f, 0.03934848f, 0.01415445f, 0.03319035f, -0.00706441f, -0.05207965f, -0.02668069f, -0.07539111f, 
    0.02908639f, 0.01399528f, 0.01908464f, -0.00111164f, -0.06449377f, -0.06203597f, 0.05068114f, -0.02079340f, 
    0.03995474f, 0.03031432f, 0.04800825f, -0.04661665f, -0.06513523f, 0.02540683f, 0.02635916f, 0.01531558f, 
    0.03750196f, -0.06214530f, -0.06571318f, -0.07176197f, -0.02928186f, 0.02070510f, 0.00915393f, -0.07112034f, 
    0.05603839f, 0.04445278f, 0.03664606f, -0.01528525f, -0.06552839f, -0.02838582f, -0.07536177f, -0.07573442f, 
    0.00530826f, -0.04466458f, -0.06529637f, 0.04509049f, -0.04171601f, -0.05853880f, -0.07730766f, -0.06564892f, 
    0.05041196f, -0.02054694f, -0.04573608f, -0.05901488f, -0.07085744f, 0.02825007f, -0.03754400f, -0.02337448f, 
    0.01234232f, -0.05771051f, 0.05566029f, -0.05333923f, -0.04845091f, -0.04121438f, -0.03312521f, -0.02153322f, 
    0.03581959f, -0.07357956f, -0.01763473f, -0.07200641f, -0.04595488f, -0.00051917f, 0.03619511f, 0.02813830f, 
    -0.02585917f, 0.05968307f, 0.04956774f, 0.00154491f, 0.02763280f, 0.04360551f, 0.00214115f, -0.06953146f, 
    0.05821115f, -0.04647117f, 0.05643300f, -0.07529710f, 0.05525674f, -0.02094740f, 0.03925210f, 0.03161297f, 
    -0.01580883f, -0.04594266f, -0.06565855f, 0.02799203f, -0.00073575f, -0.04415336f, -0.06796733f, -0.06625173f, 
    0.06613649f, -0.01131937f, -0.05448439f, -0.04663453f, -0.02722006f, -0.03065749f, -0.07783355f, -0.04175360f, 
    -0.00677076f, 0.01617094f, 0.01247318f, 0.04325313f, 0.00890668f, -0.02502743f, 0.04547909f, -0.04147189f, 
    -0.02989723f, -0.06917325f, -0.04490919f, -0.00359005f, 0.00117305f, -0.04237905f, -0.05641417f, 0.01699518f, 
    -0.00166975f, 0.00947073f, -0.00084576f, -0.05750469f, -0.01890624f, 0.01863779f, 0.04473531f, 0.02995915f, 
    -0.07445426f, -0.06722537f, -0.01171206f, -0.02701398f, -0.07699865f, -0.00855891f, 0.04108679f, -0.01208709f, 
    -0.07740624f, -0.01600020f, 0.00841679f, -0.00628142f, -0.00564544f, 0.00516416f, -0.03883327f, -0.03333879f, 
    -0.00040493f, -0.00566356f, 0.01018210f, -0.00136862f, -0.00165696f, -0.00601691f, 0.02857701f, 0.04210785f, 
    -0.11430394f, -0.31379271f, 0.06623844f, 0.05962178f, 0.03531022f, 0.04399407f, 0.18052059f, 0.02312103f, 
    -0.01047486f, -0.09619130f, 0.06214400f, -0.09725255f, -0.13210809f, 0.04707328f, 0.24898347f, 0.01759497f, 
    0.19994190f, 0.03626778f, 0.21059784f, 0.04340787f, -0.06560707f, 0.00435039f, 0.01356202f, -0.13001437f, 
    0.08154464f, -0.05623426f, -0.10761154f, -0.00107689f, 0.00995672f, -0.01137819f, -0.00671373f, -0.08898605f, 
    0.24015190f, 0.06528669f, -0.02306085f, 0.08236162f, -0.11099201f, -0.17618769f, -0.28074878f, 0.01073839f, 
    0.00108318f, 0.31702697f, 0.01597052f, 0.16439502f, 0.04179889f, 0.04925635f, -0.12479623f, 0.17391782f, 
    0.14669351f, 0.35653475f, -0.02949930f, -0.05822622f, -0.07706328f, 0.01524971f, 0.09263828f, 0.09015685f, 
    0.02724345f, 0.00317321f, -0.04144945f, -0.09229133f, 0.04355254f, -0.07720099f, -0.19824088f, -0.14858191f, 
    0.01242855f, -0.00547038f, 0.08494734f, -0.03953781f, -0.04445466f, 0.08483427f, 0.08672611f, 0.01393284f, 
    -0.22858711f, -0.21481438f, 0.00966595f, -0.10984231f, 0.11322682f, -0.11317166f, -0.04476140f, -0.08272366f, 
    0.00082981f, -0.06332906f, 0.13556896f, -0.09470393f, 0.26185298f, 0.38826725f, 0.22213650f, -0.19867027f, 
    -0.00321670f, -0.25149754f, 0.00927136f, 0.05878538f, -0.11603359f, -0.00484942f, 0.10232928f, -0.08623272f, 
    -0.13937686f, 0.06983144f, -0.08597935f, 0.00748307f, -0.06472757f, -0.10087327f, -0.06523515f, 0.02740432f, 
    0.18967232f, -0.05912082f, -0.01314565f, -0.09186280f, -0.14579028f, -0.40689963f, -0.15409014f, 0.30055791f, 
    -0.06056456f, -0.11564775f, -0.06062923f, -0.14149593f, 0.00615189f, 0.09200635f, 0.13263938f, 0.10290124f, 
    0.17687848f, -0.19749776f, 0.23537558f, -0.08171600f, 0.03757840f, -0.11770010f, 0.30712882f, 0.01468781f, 
    0.02201171f, -0.15362772f, 0.01375784f, 0.09820677f, 0.42310008f, 0.30431193f, 0.10039279f, -0.04745524f, 
    -0.01807489f, 0.03402715f, -0.07798991f, 0.01792461f, -0.03650032f, -0.17407900f, -0.02240849f, 0.03802489f, 
    -0.05605074f, 0.14805245f, -0.01316342f, 0.14218147f, 0.19218318f, 0.01237774f, 0.12704311f, 0.11804637f, 
    0.09152118f, 0.01340743f, 0.05253441f, 0.06483089f, -0.00201366f, 0.05015234f, 0.03143948f, 0.07755350f, 
    -0.00254452f, 0.11954721f, -0.08858693f, 0.12680836f, 0.08747811f, -0.03014702f, 0.11510772f, 0.01531498f, 
    0.36433056f, 0.11502974f, 0.27960056f, 0.14401798f, -0.08581166f, 0.01582288f, -0.14697705f, -0.07570235f, 
    -0.08083257f, -0.14663105f, -0.06135112f, 0.06384839f, 0.23699784f, -0.36969596f, -0.14804143f, -0.03946127f, 
    0.05486274f, 0.08891582f, -0.08892927f, 0.08905642f, 0.06964273f, 0.01482115f, 0.13895331f, 0.06079338f, 
    0.19249749f, -0.05333739f, 0.13653272f, -0.08565431f, -0.10374735f, 0.11717464f, 0.20317604f, 0.06220251f, 
    0.07738853f, -0.06451940f, -0.08048558f, 0.03510097f, 0.07556104f, -0.00856845f, 0.13052700f, 0.13862184f, 
    -0.16076583f, -0.09887507f, -0.09521681f, -0.01912751f, 0.00831457f, 0.06055770f, -0.00479693f, -0.12475866f, 
    -0.01288701f, 0.08925208f, 0.13314824f, 0.20120138f, -0.02278782f, -0.06113206f, -0.00634479f, -0.00000618f, 
    -0.04582401f, 0.08083349f, 0.10362957f, 0.07040599f, -0.01344308f, -0.07666195f, -0.00726802f, 0.00508478f, 
    -0.07628213f, -0.05207234f, -0.02065171f, -0.07529558f, 0.01712670f, -0.10313533f, -0.05691861f, -0.08511636f, 
    0.10725100f, 0.09305810f, -0.07076091f, 0.03504380f, -0.01421332f, -0.04148098f, 0.10212909f, 0.16518852f, 
    -0.02361091f, 0.05897336f, 0.08009750f, 0.06415363f, 0.08088037f, 0.10694405f, -0.15369424f, 0.29802087f, 
    0.02794050f, 0.06943820f, 0.14998052f, 0.09913750f, 0.08096363f, 0.06338223f, -0.03762677f, 0.01622894f, 
    -0.15678297f, -0.19802590f, 0.11601958f, 0.04111635f, -0.03309934f, 0.08258326f, -0.07381564f, 0.05109824f, 
    -0.03875560f, -0.21107368f, -0.02337136f, -0.11368935f, -0.23679766f, 0.06799794f, 0.24277826f, -0.11869506f, 
    0.09732456f, -0.14799194f, -0.15901478f, -0.23872174f, -0.04474198f, 0.08086991f, -0.02117652f, 0.00503771f, 
    0.08807718f, 0.02229636f, 0.12683207f, 0.10411623f, 0.05536168f, -0.02732508f, 0.01525196f, 0.10095590f, 
    0.09670429f, 0.00911571f, -0.06086462f, -0.03848883f, 0.26648122f, -0.28732234f, 0.11363956f, -0.22794843f, 
    -0.15560092f, 0.00296071f, 0.10867492f, 0.15404855f, 0.04292297f, -0.03121417f, 0.09903131f, 0.02614870f, 
    0.18942578f, 0.07511897f, 0.10139339f, -0.02918217f, -0.03876258f, 0.02100676f, 0.01645022f, 0.00692402f, 
    0.00077353f, -0.01851199f, -0.10402013f, -0.05537887f, -0.00860802f, 0.17362490f, -0.00027035f, 0.04839070f, 
    0.00050725f, 0.12320128f, -0.05380835f, 0.01491710f, -0.01091973f, -0.13867357f, -0.05054280f, 0.05797968f, 
    -0.06542689f, 0.22845900f, -0.08751554f, 0.04797712f, -0.05143424f, -0.15697034f, 0.01592289f, -0.02724631f, 
    0.07173065f, 0.12613310f, 0.12609707f, 0.12135217f, -0.13577351f, 0.05550162f, 0.14565162f, 0.09792282f, 
    -0.02964933f, -0.11586206f, -0.02044392f, -0.02715891f, 0.13741560f, -0.04330999f, 0.03101968f, -0.09975390f, 
    0.23430291f, -0.02797534f, 0.12806517f, 0.07848918f, 0.08792175f, -0.06230664f, -0.12199530f, 0.07113311f, 
    -0.01815050f, -0.03594027f, -0.07574234f, 0.12870941f, -0.10618587f, 0.13604882f, -0.30974722f, -0.07884100f, 
    -0.10356042f, 0.31491956f, 0.07378308f, 0.06689931f, 0.20099469f, -0.05475371f, -0.15174708f, 0.03239205f, 
    -0.06537981f, 0.33523232f, 0.29504508f, 0.35419056f, -0.02794163f, -0.04644373f, -0.08414933f, 0.08315087f, 
    0.07535658f, 0.00240417f, -0.00134241f, 0.02982895f, -0.23386531f, -0.12522347f, 0.08886079f, 0.28562877f, 
    -0.03641943f, 0.01183321f, 0.00656850f, 0.11073968f, 0.05573372f, 0.03652962f, -0.13510630f, 0.04255098f, 
    -0.23666801f, -0.22058600f, -0.15063201f, -0.11793964f, 0.05817173f, 0.11091606f, -0.00660490f, 0.01075608f, 
    0.06000762f, 0.05079029f, 0.00783562f, -0.00161967f, 0.28492510f, 0.15937155f, 0.11738349f, -0.00743300f, 
    0.16269484f, 0.05750722f, 0.10463516f, 0.06729591f, 0.02455140f, 0.00178181f, 0.08590477f, 0.07033449f, 
    -0.14859620f, -0.10504270f, 0.22722936f, 0.36080143f, -0.09474291f, -0.02271105f, -0.07561696f, 0.06517383f, 
    0.00990536f, 0.13162358f, 0.07737368f, 0.02137468f, 0.00875339f, 0.06727387f, 0.28702879f, 0.24922737f, 
    -0.00581807f, -0.08423115f, 0.01558458f, 0.10478611f, 0.00647195f, -0.05599420f, 0.12888809f, -0.01605901f, 
    -0.01407258f, -0.00241327f, -0.36794478f, -0.12933296f, -0.00848952f, -0.04624831f, -0.06938897f, -0.17605338f, 
    0.13357277f, -0.08866762f, 0.12868910f, -0.08081497f, -0.53775907f, -0.10145067f, -0.07748226f, 0.17876312f, 
    0.09705647f, 0.09934641f, -0.07577738f, 0.11801717f, 0.04309039f, -0.07937694f, 0.01528023f, -0.05475123f, 
    -0.11467258f, -0.22217137f, -0.21662608f, -0.33232841f, -0.00759424f, 0.03179223f, -0.03970823f, 0.07785731f, 
    0.08753397f, 0.05873289f, -0.09817593f, 0.02471696f, -0.39827806f, -0.06039071f, -0.01824348f, 0.06674848f, 
    0.11426404f, 0.10324311f, -0.13763049f, 0.06945851f, -0.13373017f, 0.07799654f, 0.04462194f, 0.10559434f, 
    -0.03662088f, 0.16350004f, 0.08973205f, 0.37188908f, -0.07649453f, -0.01270805f, -0.02938026f, 0.23726331f, 
    -0.06871539f, 0.05746507f, -0.12411831f, -0.01790127f, 0.08981996f, 0.17968650f, 0.11097970f, 0.03533638f, 
    -0.04636753f, -0.08315720f, -0.09624545f, 0.04545749f, 0.07083809f, 0.04301851f, -0.07186074f, 0.02874264f, 
    0.03571855f, -0.12524216f, -0.01584994f, -0.07000141f, 0.14217602f, 0.14842717f, 0.13624050f, 0.22629143f, 
    0.09082919f, 0.04987157f, 0.05235362f, -0.00186320f, 0.11874695f, 0.13601434f, -0.27068815f, -0.12819189f, 
    -0.04918257f, 0.01901444f, 0.11856546f, -0.04904013f, -0.05516046f, -0.05689906f, -0.14303169f, -0.29396433f, 
    -0.28810307f, -0.36063319f, -0.18304345f, -0.05597445f, 0.02972743f, -0.13966982f, -0.09518960f, 0.03942637f, 
    0.16906133f, 0.01842150f, -0.07448158f, 0.10909384f, 0.15748213f, 0.22463174f, 0.20508915f, 0.12512226f, 
    0.01203252f, 0.12492157f, -0.15900195f, 0.01157956f, -0.09051770f, 0.09701502f, 0.09533034f, 0.01431729f, 
    0.02536613f, -0.05791423f, 0.01933335f, 0.02824412f, 0.05859518f, -0.02619041f, -0.08310048f, 0.00700560f, 
    0.04803222f, -0.03188851f, -0.03133135f, -0.03923498f, -0.05516516f, -0.02331718f, -0.04614569f, -0.02171108f, 
    -0.01985009f, -0.03167267f, -0.03971475f, -0.07377347f, 0.04778729f, 0.04686201f, -0.01040830f, -0.01580080f, 
    0.04920663f, -0.07276411f, -0.04112076f, -0.00278229f, -0.03489413f, 0.00116114f, 0.04121041f, -0.04746914f, 
    0.02947440f, 0.01375031f, -0.06342357f, 0.05911509f, 0.04366975f, -0.05790245f, -0.00636655f, -0.01846936f, 
    -0.00574271f, 0.03024446f, -0.03442986f, -0.08156993f, -0.06937030f, -0.04230158f, -0.06919194f, 0.03787648f, 
    -0.04369152f, -0.06036331f, -0.01322619f, -0.05877803f, 0.00523472f, 0.04666520f, -0.06396028f, -0.04702486f, 
    -0.01070570f, -0.06395466f, -0.04860207f, -0.05856031f, 0.01347746f, 0.03653641f, -0.07619290f, 0.01878725f, 
    -0.07683294f, -0.00183825f, 0.05988143f, 0.03726866f, 0.02204567f, 0.05327507f, -0.06746993f, 0.02298224f, 
    -0.02917079f, -0.06160503f, 0.06110959f, -0.06845311f, -0.07983103f, -0.05480864f, -0.07320634f, -0.07240800f, 
    0.02973076f, -0.00772695f, -0.04069254f, -0.06314064f, 0.06384522f, -0.07171869f, -0.00498753f, -0.00918008f, 
    -0.01064277f, 0.05682505f, 0.03639529f, 0.00522847f, -0.06502917f, 0.03202699f, -0.01597838f, -0.03363691f, 
    -0.03305203f, 0.01430127f, -0.03675437f, 0.05548965f, 0.00533264f, -0.01980715f, -0.06974038f, 0.02870880f, 
    -0.02449614f, -0.07054906f, -0.01186097f, 0.01052109f, 0.00452718f, 0.03071571f, 0.02884256f, -0.03444327f, 
    -0.01120171f, -0.04144699f, -0.03227106f, 0.02814187f, -0.06250102f, -0.00090399f, 0.05875494f, -0.01031465f, 
    -0.07487206f, -0.03434347f, -0.03523387f, -0.00814733f, 0.02177129f, 0.05861107f, -0.04791887f, 0.02521301f, 
    -0.01117595f, 0.01585023f, 0.05895303f, -0.03457017f, 0.03142321f, 0.02153764f, 0.03845574f, -0.07796419f, 
    0.04497585f, -0.00791740f, -0.04391528f, -0.00210978f, -0.04234002f, -0.00880302f, -0.05063270f, -0.02486204f, 
    -0.06088773f, -0.06254795f, 0.00456582f, 0.04966647f, -0.04844789f, -0.02478114f, -0.00996781f, 0.01391975f, 
    0.05969212f, -0.04180504f, -0.05807595f, -0.00217865f, 0.04484386f, -0.07383451f, -0.00562001f, 0.05283337f, 
    0.04034926f, 0.00388018f, -0.02816235f, -0.04004138f, 0.01032162f, 0.05537251f, -0.02301567f, -0.00278116f, 
    0.00523290f, 0.03940704f, 0.02472882f, -0.02974368f, 0.05724898f, -0.01276735f, -0.02861174f, -0.06736762f, 
    -0.03594925f, 0.04247925f, -0.05472287f, -0.04894248f, 0.02178559f, -0.00894816f, 0.01718098f, -0.05019436f, 
    0.05871216f, 0.04961701f, -0.01427308f, 0.04955768f, 0.04303270f, 0.04131803f, 0.04412809f, -0.02015954f, 
    0.00978556f, 0.38192260f, 0.01105814f, 0.09743644f, 0.17495476f, 0.02591203f, -0.09329434f, -0.11833675f, 
    -0.14879946f, 0.15292241f, 0.19803189f, 0.10176791f, 0.13094901f, 0.17903987f, 0.23052318f, 0.02525487f, 
    0.00781593f, -0.04298933f, 0.09331663f, 0.08219412f, -0.03737814f, -0.01753336f, -0.05812977f, -0.05971249f, 
    0.06555188f, -0.17531782f, -0.10852111f, -0.15588067f, 0.03734184f, -0.22614132f, -0.04283972f, -0.13141678f, 
    0.10396338f, 0.00122691f, -0.00736511f, -0.01709319f, -0.03434224f, 0.17949554f, 0.00165096f, 0.15621459f, 
    0.16121389f, -0.09961262f, 0.00869203f, 0.00425392f, 0.07212771f, 0.04242306f, 0.12368678f, 0.02534991f, 
    0.28193653f, 0.21509358f, 0.26850811f, 0.07294928f, 0.09440511f, 0.17009027f, 0.00257773f, -0.10005687f, 
    0.06106258f, -0.01494560f, -0.01107312f, -0.05091901f, 0.12535486f, -0.09306651f, 0.00576036f, -0.05429876f, 
    0.09125876f, 0.07321114f, -0.11096220f, 0.07852241f, -0.04890257f, -0.04245045f, -0.07067016f, 0.05907694f, 
    -0.22885485f, -0.22567615f, -0.04951629f, -0.14859089f, 0.01400488f, 0.04298150f, 0.03351490f, -0.03057262f, 
    -0.02757303f, 0.04068775f, 0.03857575f, 0.11556408f, 0.39119142f, 0.01399950f, -0.19725768f, -0.03752517f, 
    -0.33280700f, -0.08360425f, -0.02574660f, 0.15557580f, 0.08384091f, -0.05128422f, 0.05571058f, 0.09689060f, 
    -0.24037440f, -0.27605617f, -0.18730894f, -0.17216817f, -0.12992600f, 0.00992453f, -0.08707008f, 0.05536271f, 
    -0.03901561f, -0.02983353f, 0.12869434f, -0.01590218f, -0.59309989f, 0.13670515f, -0.17212746f, -0.12367766f, 
    0.08689085f, -0.00266888f, -0.08652607f, -0.07882937f, -0.11358072f, -0.02301013f, 0.00894022f, 0.06205349f, 
    0.32564402f, 0.16197154f, 0.27693307f, 0.15456288f, 0.14407329f, 0.03889556f, 0.11414183f, 0.17175527f, 
    -0.02348035f, -0.09074860f, 0.06843881f, -0.10405683f, 0.32167587f, 0.08452384f, 0.27628592f, 0.24550225f, 
    -0.00793273f, -0.04611765f, 0.06502532f, 0.09318776f, 0.03042972f, -0.03761302f, 0.07907809f, 0.04166032f, 
    0.09909898f, -0.13930981f, 0.06158650f, -0.13007337f, 0.01145856f, -0.03212873f, -0.09189886f, -0.08875081f, 
    -0.05843720f, -0.03064255f, -0.04446628f, -0.16205028f, 0.29133657f, 0.16274336f, -0.02972956f, 0.10847805f, 
    -0.04128657f, -0.13388589f, 0.05179816f, 0.05773523f, 0.06680283f, -0.28188121f, -0.05266920f, 0.12302639f, 
    -0.25300160f, -0.18368399f, -0.37532616f, -0.08249852f, -0.03437125f, -0.01862537f, -0.03371222f, -0.08339582f, 
    0.02694043f, 0.09926116f, 0.10537528f, -0.06986115f, 0.25607643f, -0.19889547f, 0.08969658f, 0.01052734f, 
    0.17134909f, -0.07164780f, 0.05233141f, -0.07457474f, -0.02795440f, 0.09769706f, 0.06989122f, 0.00911947f, 
    0.02245336f, 0.02049857f, -0.39508459f, -0.03061023f, 0.06139988f, -0.03352073f, -0.15149212f, 0.09511299f, 
    -0.02212740f, 0.14684501f, -0.13102530f, -0.02179959f, 0.19358692f, -0.04422399f, 0.26790959f, 0.07262687f, 
    -0.03212772f, -0.07059000f, 0.02447780f, 0.06838589f, -0.09834844f, -0.03676172f, -0.02680356f, 0.04129801f, 
    0.06898898f, -0.02940788f, 0.07857446f, -0.11526796f, 0.11219592f, 0.09660521f, -0.14302249f, -0.04298932f, 
    0.06869909f, 0.06876233f, -0.04138060f, 0.05228776f, 0.04229792f, 0.04514061f, 0.16515391f, -0.07128605f, 
    0.11949327f, 0.23539545f, -0.12659556f, -0.02646650f, -0.00443661f, -0.05988258f, 0.27406994f, 0.05012235f, 
    -0.03603189f, -0.08324462f, 0.23516501f, 0.18229969f, 0.10627347f, -0.05989474f, 0.05672614f, 0.25657570f, 
    0.00454613f, 0.09955171f, 0.09809492f, 0.04558815f, 0.13062204f, -0.32628146f, 0.11132281f, -0.03206492f, 
    -0.01707180f, -0.10286856f, -0.07530327f, 0.09910569f, -0.02599405f, -0.15524690f, 0.12819014f, -0.02296159f, 
    -0.04928303f, 0.13883847f, -0.07883463f, 0.07234769f, -0.03398709f, -0.04196076f, 0.03048599f, 0.06176888f, 
    0.05111452f, -0.08336069f, -0.12976855f, 0.00132202f, -0.19771083f, 0.20772366f, 0.05602590f, 0.46555877f, 
    -0.03678182f, 0.17596045f, 0.08162563f, 0.14866783f, 0.03877819f, 0.15779419f, -0.05268792f, -0.03522336f, 
    -0.00554299f, -0.00733757f, 0.17393392f, -0.17288083f, -0.02790549f, -0.04451733f, -0.00041328f, 0.04871382f, 
    0.06532611f, -0.01405672f, 0.10618418f, 0.08120402f, 0.17435142f, 0.25228333f, -0.01203772f, -0.01368937f, 
    0.02888859f, -0.10806482f, -0.06861871f, 0.05127031f, 0.00160161f, -0.16765429f, 0.05036473f, -0.03984278f, 
    0.24184194f, 0.35178477f, 0.21169353f, 0.09654325f, 0.03240300f, 0.33704850f, 0.02376347f, 0.11314087f, 
    -0.04362623f, 0.19855371f, -0.14378515f, -0.03631454f, -0.03707719f, -0.12124724f, 0.09046740f, 0.01198303f, 
    0.06458540f, -0.11725251f, 0.12357647f, 0.08798079f, -0.05725146f, -0.11005623f, 0.00417346f, -0.11985417f, 
    -0.00273454f, 0.11551607f, -0.00197040f, -0.11521145f, -0.13800715f, -0.01042399f, -0.05947424f, -0.11767847f, 
    0.06388780f, 0.01938700f, -0.11127696f, 0.08656321f, -0.23224576f, 0.13538618f, -0.32144964f, -0.09216210f, 
    -0.21105959f, 0.12982127f, -0.06833977f, 0.12620899f, -0.11006547f, -0.00905217f, -0.07966267f, -0.02130207f, 
    -0.31942162f, 0.12520826f, -0.24666774f, 0.31197864f, 0.13682103f, -0.01769002f, 0.10035150f, 0.06227684f, 
    0.11709186f, 0.10945822f, 0.03992335f, 0.02891797f, -0.15070224f, -0.30415097f, 0.17804879f, 0.02831272f, 
    -0.01000796f, -0.10571714f, -0.04114858f, 0.11203551f, -0.05236504f, -0.20088580f, 0.12525204f, 0.22786234f, 
    0.22957918f, -0.00176900f, -0.07476540f, -0.06764734f, 0.09105448f, -0.04498539f, 0.02234851f, 0.17500724f, 
    0.11498182f, -0.13845047f, 0.00218910f, 0.05239409f, 0.36040798f, -0.15713978f, 0.25309294f, -0.04981663f, 
    0.09900469f, 0.18414381f, 0.06133601f, -0.00654085f, 0.06849530f, -0.07400895f, 0.08391402f, 0.03219149f, 
    -0.11899683f, 0.01942063f, -0.04878925f, -0.15328246f, 0.09433825f, -0.05586677f, -0.15092963f, 0.15970181f, 
    -0.27855697f, -0.09108234f, -0.28276941f, -0.33107179f, -0.06846798f, 0.17870589f, -0.38629797f, 0.12086960f, 
    0.01624412f, -0.08453174f, -0.06770206f, -0.20382307f, -0.22352391f, -0.02366732f, -0.11629768f, -0.24321422f, 
    0.09377866f, 0.02275663f, 0.03507432f, -0.01066380f, 0.23396665f, -0.05582680f, 0.04149115f, 0.08693343f, 
    -0.01994862f, -0.08598660f, -0.09646504f, -0.19457875f, 0.06729498f, -0.08492175f, 0.03060807f, 0.27378055f, 
    0.03200116f, -0.02305517f, 0.22387287f, 0.10327827f, 0.17344491f, 0.15446198f, 0.08401000f, 0.17324555f, 
    0.17723180f, -0.13922794f, -0.01848644f, 0.04469730f, 0.01679005f, -0.04531549f, -0.11315304f, 0.02204643f, 
    0.25379872f, 0.26044813f, 0.18359652f, 0.06974852f, -0.01228999f, 0.39380327f, 0.53467685f, 0.37426654f, 
    0.12782760f, 0.05255467f, -0.07766394f, 0.04035353f, 0.06693824f, 0.08039450f, 0.00703141f, 0.16922808f, 
    -0.04299456f, 0.31772330f, -0.37025875f, -0.16423057f, 0.14727585f, -0.05856667f, 0.30203810f, 0.03981547f, 
    0.09408439f, 0.25057521f, 0.01538170f, 0.20279804f, 0.03439627f, 0.22173005f, -0.31121209f, -0.25540659f, 
    0.28986096f, 0.04131157f, -0.06613182f, 0.08505891f, -0.00266238f, 0.10096667f, -0.01161466f, -0.18307967f, 
    0.21665831f, -0.08168358f, 0.15890278f, 0.05077137f, 0.16073576f, 0.11559086f, -0.11560356f, 0.05058169f, 
    0.12882221f, -0.05978163f, -0.05017661f, -0.06840010f, -0.11520178f, -0.10547613f, 0.05190781f, 0.13043861f, 
    0.02230199f, -0.00154962f, 0.26413649f, 0.03910784f, -0.18038464f, 0.29726210f, 0.22059536f, 0.20317264f, 
    -0.20586205f, -0.02428327f, 0.20763674f, -0.05676055f, 0.13246012f, 0.00619990f, -0.18774977f, -0.06414781f, 
    -0.18560976f, -0.29390475f, 0.15198456f, -0.20748261f, -0.19658564f, 0.37698683f, -0.08641089f, 0.01734441f, 
    0.11675591f, -0.02559597f, -0.10327625f, 0.00723726f, -0.12979649f, -0.00816867f, 0.03501913f, 0.10173361f, 
    -0.15681458f, 0.10194424f, 0.31940362f, 0.05961759f, -0.01114369f, 0.04609990f, -0.23182930f, -0.21688999f, 
    -0.01795266f, -0.00149762f, 0.01361400f, -0.00986439f, -0.38137025f, 0.05564885f, 0.01592895f, 0.20663489f, 
    -0.00283908f, -0.00205070f, -0.00949664f, 0.15123934f, -0.04872969f, 0.12193227f, 0.04377911f, -0.09874135f, 
    -0.11981160f, -0.18138056f, -0.17103177f, -0.33107540f, 0.01773999f, -0.00479785f, 0.00946759f, 0.17374095f, 
    0.16398834f, -0.03562263f, -0.06154862f, 0.21124081f, 0.22025380f, -0.01520789f, 0.16853170f, 0.08026061f, 
    0.13748163f, 0.09398355f, 0.05929868f, -0.10843765f, -0.03781416f, 0.01601407f, 0.17918447f, 0.06490505f, 
    -0.01990691f, -0.05115517f, 0.00604517f, -0.08902852f, 0.10635769f, 0.01644029f, -0.04486566f, -0.01389180f, 
    -0.01871623f, -0.02586708f, 0.06468041f, -0.04265658f, -0.19171104f, -0.05263506f, -0.13044620f, -0.02905785f, 
    -0.12002265f, 0.08997969f, -0.05575982f, -0.05209597f, 0.05709706f, -0.01192917f, 0.15998581f, -0.04651780f, 
    -0.18782058f, -0.17640026f, 0.00441526f, -0.20108905f, 0.13162874f, -0.02829268f, 0.17711091f, -0.04021660f, 
    0.02973163f, -0.07568005f, -0.00102981f, -0.03774247f, -0.12660211f, 0.04955636f, -0.05118425f, -0.01015013f, 
    -0.04606182f, 0.03102613f, -0.03927306f, 0.16138904f, 0.00348829f, 0.08933523f, -0.05981771f, 0.00719601f, 
    0.11987546f, -0.03701681f, 0.10115086f, 0.00247775f, 0.03989216f, 0.04906286f, 0.05597610f, 0.06704085f, 
    0.03213425f, 0.11469078f, -0.07743581f, -0.04017701f, 0.23499683f, 0.05287378f, 0.11646118f, -0.10902569f, 
    0.03927683f, 0.08062856f, 0.26491526f, 0.23334789f, -0.03016017f, 0.03193609f, -0.04576103f, -0.05200660f, 
    -0.03440075f, 0.12848772f, -0.01578283f, 0.00487632f, 0.00448818f, -0.02549117f, 0.13851795f, -0.00656678f, 
    0.06865539f, -0.12547956f, -0.09965177f, -0.02596374f, 0.08018333f, -0.06372336f, -0.18564634f, -0.17033587f, 
    0.10428710f, -0.03707990f, -0.01056011f, 0.05204796f, 0.24086100f, 0.09303824f, 0.18199226f, 0.12697098f, 
    -0.01933661f, -0.18053232f, 0.11305641f, -0.16548546f, 0.04033817f, 0.20041011f, 0.01852790f, -0.18627357f, 
    0.11591780f, 0.05829408f, -0.12499329f, 0.09751876f, -0.04579245f, -0.16224176f, -0.07753937f, 0.14913090f, 
    -0.02814299f, 0.15095773f, 0.22389303f, 0.05009335f, -0.00288639f, 0.00407786f, -0.03074614f, 0.05099972f, 
    -0.02234163f, 0.07173204f, 0.12927985f, 0.04119553f, 0.04569527f, 0.09713546f, 0.05217642f, -0.02215018f, 
    0.15768841f, -0.04042999f, 0.10203085f, -0.00075279f, -0.36061054f, 0.24678800f, 0.10466811f, -0.03867237f, 
    -0.03403745f, 0.03560837f, -0.12925586f, 0.22980213f, 0.11967713f, 0.00736844f, 0.01328975f, 0.22173922f, 
    0.02375668f, -0.07928631f, 0.10469828f, 0.04291569f, 0.02352720f, -0.01974207f, -0.04171529f, -0.09807713f, 
    0.01633454f, 0.00018782f, 0.04459244f, -0.05819356f, -0.31653732f, -0.00337873f, -0.06492467f, 0.07962226f, 
    -0.01437456f, 0.01280319f, -0.00166418f, 0.23229134f, 0.05949302f, -0.03958285f, 0.06628033f, -0.02480739f, 
    0.17222631f, -0.18720806f, -0.02678613f, 0.22899732f, 0.02622140f, -0.08744235f, -0.04446042f, 0.12716405f, 
    0.07764857f, -0.10622084f, 0.11002916f, 0.09776829f, 0.16968185f, -0.20980671f, 0.18972003f, 0.01469060f, 
    0.26350737f, 0.08118328f, 0.05496042f, 0.03524127f, 0.01417644f, -0.00532251f, 0.03012042f, 0.04375212f, 
    0.05327188f, -0.00259252f, -0.11047006f, -0.22318758f, 0.12946013f, 0.08549573f, -0.04442626f, 0.06233891f, 
    -0.05395296f, 0.01237804f, -0.27970326f, -0.13845873f, 0.01482038f, 0.04808492f, -0.31714898f, 0.00739095f, 
    0.11448432f, 0.31918311f, 0.05797235f, -0.01094697f, -0.13565628f, -0.09390666f, -0.05219673f, 0.03639188f, 
    0.07554103f, 0.19223449f, 0.15532462f, 0.26767331f, -0.02737356f, -0.07678615f, -0.04425462f, -0.06049578f, 
    0.06297664f, 0.00398207f, -0.06064073f, -0.12884012f, 0.01500970f, -0.15667935f, 0.09178080f, -0.07931841f, 
    -0.04392676f, -0.13385101f, 0.02134231f, -0.01383775f, 0.16389853f, 0.03352538f, 0.06932227f, -0.02534045f, 
    -0.07781582f, -0.00084969f, -0.12800567f, -0.02489318f, 0.03732019f, 0.02437930f, 0.09747463f, -0.08977298f, 
    0.04852560f, 0.12266488f, 0.13436413f, 0.02257866f, -0.00458419f, 0.45398986f, 0.13988359f, 0.26404190f, 
    0.01410876f, -0.09095527f, 0.08591426f, 0.28484511f, 0.03960982f, 0.05089912f, -0.03971814f, -0.06913844f, 
    0.00847364f, -0.13127093f, -0.25775409f, -0.27438664f, -0.04521065f, 0.03598487f, 0.11200870f, -0.06200633f, 
    0.02840211f, 0.09519266f, -0.06544265f, 0.15415460f, -0.01338449f, -0.07165314f, -0.41927472f, 0.04667765f, 
    0.11066187f, 0.04516434f, -0.00078167f, -0.08651115f, -0.05010343f, 0.12996651f, 0.03431652f, -0.15221779f, 
    0.18388502f, -0.09906775f, 0.27519768f, 0.32413280f, 0.06782582f, -0.03787303f, 0.00280635f, 0.10126215f, 
    0.10088415f, -0.03680236f, -0.03176774f, -0.06009394f, 0.02922064f, -0.07603313f, 0.13361765f, -0.03266035f, 
    -0.09314975f, -0.08747296f, 0.12633839f, 0.03964432f, 0.02086936f, 0.00667245f, 0.17737050f, 0.18515867f, 
    -0.04615165f, -0.19011398f, 0.20854989f, 0.02026932f, 0.01613876f, 0.05030899f, -0.13135774f, -0.02268999f, 
    -0.02068114f, -0.19298430f, -0.00673005f, -0.10840037f, -0.06998594f, 0.28724843f, -0.04364534f, -0.09547459f, 
    -0.09413943f, 0.05745660f, 0.08497052f, 0.19493008f, -0.26395112f, 0.02022576f, -0.00668305f, -0.01043916f, 
    -0.17850147f, 0.06908354f, 0.06287548f, 0.08980376f, -0.09822975f, 0.12397309f, -0.01065483f, 0.04195283f, 
    0.04115966f, -0.03540300f, 0.08141298f, -0.08405972f, 0.00102626f, -0.34012574f, 0.22310144f, 0.00877229f, 
    -0.02534482f, 0.01998728f, -0.00987538f, -0.01233070f, -0.19261198f, 0.06059960f, 0.07231226f, 0.11977856f, 
    0.08636147f, -0.15906015f, 0.01619517f, 0.05415266f, 0.14616919f, -0.01343541f, 0.07591996f, -0.04586710f, 
    -0.00029942f, -0.04597078f, 0.09351160f, -0.01078169f, 0.18760683f, 0.07981274f, -0.14957987f, -0.10726448f, 
    0.27752331f, 0.06355428f, 0.11271431f, -0.03387054f, 0.04579760f, 0.04298663f, -0.14017938f, 0.14959967f, 
    0.00631574f, 0.06646661f, -0.10492372f, -0.09235901f, 0.04637738f, -0.04682609f, -0.04973749f, -0.04764415f, 
    0.12664482f, 0.01568356f, 0.05746563f, -0.13138562f, -0.05450988f, 0.02913662f, -0.17159832f, 0.16643308f, 
    -0.02255548f, 0.08009976f, 0.06432869f, 0.13279630f, -0.02090666f, 0.05087491f, -0.03444603f, 0.04892844f, 
    0.17450450f, -0.07749786f, -0.04509476f, 0.01632045f, -0.06728794f, 0.01244109f, 0.00723009f, -0.26289579f, 
    -0.06534712f, -0.03499034f, -0.15605292f, -0.06739309f, 0.04663489f, -0.23371728f, 0.01365995f, 0.08666755f, 
    0.01943448f, -0.02334576f, 0.20596373f, 0.07183403f, -0.07155477f, -0.06257914f, -0.00841051f, -0.00657278f, 
    0.11754971f, 0.09700365f, 0.03998040f, -0.07008828f, 0.01898805f, -0.01634177f, 0.10006002f, 0.02987783f, 
    0.16480540f, 0.19943978f, 0.20317665f, 0.11833739f, -0.07634979f, 0.27103332f, 0.30226704f, 0.23307359f, 
    0.03070158f, -0.06878414f, 0.03734662f, 0.04501225f, -0.01869131f, -0.01264233f, -0.02539410f, 0.02015555f, 
    -0.06879959f, 0.20091769f, -0.20712574f, -0.19954607f, -0.07793009f, 0.09736436f, -0.00632648f, -0.05331615f, 
    0.13492212f, -0.10028005f, 0.08338063f, 0.06392992f, -0.13174640f, 0.08298035f, -0.45860034f, -0.13769571f, 
    0.12799218f, 0.13464077f, -0.10598348f, -0.05202119f, 0.03875539f, 0.10041012f, 0.05247517f, -0.05089278f, 
    -0.02838450f, -0.31913206f, -0.08208364f, 0.00639510f, 0.03551763f, -0.07147475f, -0.00688595f, 0.11257947f, 
    0.05908319f, 0.10013139f, 0.02559596f, -0.05270407f, -0.11828343f, -0.07259779f, -0.03286704f, 0.12204985f, 
    0.01852629f, -0.08438473f, 0.04628032f, -0.07024567f, 0.12782146f, 0.06566716f, 0.03575270f, -0.01187276f, 
    0.02805840f, -0.13647777f, 0.09875415f, 0.09049272f, 0.02545762f, -0.12714848f, -0.12630191f, 0.09243925f, 
    -0.00972473f, 0.02954972f, 0.01070633f, -0.06579308f, 0.11463644f, 0.02451106f, 0.27419925f, 0.16180332f, 
    0.06393112f, -0.09157239f, 0.02458106f, 0.07847270f, -0.05176802f, -0.05961717f, 0.11216561f, 0.18907720f, 
    -0.23560213f, 0.11734202f, 0.35227820f, -0.03106916f, -0.13135935f, 0.07009677f, -0.10310697f, 0.03622319f, 
    -0.17642221f, -0.07034254f, 0.07880808f, -0.03952200f, 0.11160381f, -0.15800519f, 0.04551714f, 0.14209954f, 
    0.17513101f, -0.00038427f, 0.10332564f, 0.11574927f, -0.00979499f, 0.06527029f, 0.06709532f, 0.01603529f, 
    -0.07083917f, -0.04321446f, 0.01300415f, -0.00397630f, 0.04012435f, -0.06075558f, 0.05493975f, -0.07538836f, 
    -0.04045679f, 0.04079355f, 0.01157209f, -0.06182752f, -0.03852416f, 0.06250106f, -0.03198861f, 0.02971535f, 
    -0.05143948f, 0.01314440f, 0.00371995f, 0.00883386f, 0.00145295f, -0.05247020f, -0.03157167f, -0.05039817f, 
    -0.06550447f, 0.02447345f, -0.02759430f, 0.00820245f, 0.03199071f, 0.05160674f, -0.00690249f, 0.04404506f, 
    0.05553662f, -0.02429898f, -0.03737694f, -0.07829434f, 0.00440690f, -0.02514620f, 0.01606287f, -0.02956420f, 
    -0.08330426f, -0.03977629f, -0.02274220f, -0.00521080f, -0.07664476f, 0.01020016f, 0.01705425f, 0.04491771f, 
    0.01697131f, 0.03751749f, -0.04526940f, -0.01481734f, -0.03244606f, -0.05298194f, -0.06245046f, 0.01773828f, 
    0.03153859f, -0.00650111f, -0.02154120f, -0.07171334f, -0.01998458f, -0.00552150f, -0.01254452f, -0.00879853f, 
    0.05986555f, -0.07403833f, 0.04250270f, 0.06093159f, 0.03581694f, -0.01652161f, 0.05911534f, -0.08420567f, 
    -0.04489047f, 0.03360557f, -0.02414118f, -0.06431626f, 0.00188271f, -0.02041477f, 0.01758709f, -0.00489927f, 
    -0.05342778f, -0.07323121f, 0.04077959f, -0.07347377f, 0.04393077f, -0.03227648f, -0.01569922f, -0.07259976f, 
    -0.05499193f, 0.01177303f, -0.05705016f, 0.01714241f, 0.02045767f, -0.00386440f, -0.03034054f, 0.04848152f, 
    -0.02916870f, 0.00817049f, 0.06894275f, -0.04737717f, 0.01405943f, -0.01195942f, 0.01779073f, 0.01633579f, 
    -0.07813375f, -0.06567299f, 0.00514063f, -0.05600250f, -0.01745623f, 0.02700684f, 0.03269036f, -0.07690029f, 
    0.04662894f, -0.01600452f, -0.04947029f, 0.04872521f, 0.04637351f, -0.02735486f, 0.02577173f, 0.04076497f, 
    0.05878972f, 0.03817483f, -0.04038808f, 0.00041563f, -0.01912612f, 0.00238514f, -0.07210093f, -0.00650839f, 
    -0.05431150f, -0.02091683f, 0.00239622f, 0.04883952f, 0.01970393f, 0.06899220f, 0.04292354f, 0.01621182f, 
    0.01698708f, 0.02176119f, 0.02509564f, -0.05909523f, 0.00747611f, -0.04861629f, 0.00025967f, 0.04532437f, 
    -0.02217050f, 0.01395367f, -0.06329235f, 0.04854704f, 0.04594490f, -0.07905215f, 0.02541071f, -0.06715643f, 
    -0.05598930f, 0.05621272f, -0.06279714f, 0.00405387f, -0.00229349f, -0.00175744f, 0.01802739f, 0.05411803f, 
    -0.03442748f, -0.04365999f, -0.02971301f, 0.03443576f, -0.00346078f, 0.03131330f, -0.00726286f, 0.04893277f, 
    -0.02917430f, -0.02139237f, 0.02457461f, -0.00228063f, -0.05735910f, 0.07098429f, 0.04694110f, -0.01731471f, 
    0.00895883f, -0.02689162f, -0.00779020f, -0.06460650f, -0.01445992f, -0.03793513f, -0.07501417f, 0.04777530f, 
    -0.00802194f, -0.01797185f, 0.03407602f, 0.00961484f, -0.04452638f, 0.03805872f, 0.03989376f, -0.01473051f, 
    -0.17224059f, -0.02860204f, -0.08379871f, -0.02073216f, 0.17167050f, -0.03826034f, -0.06253897f, 0.09556743f, 
    0.03247771f, 0.16117170f, 0.13334988f, 0.09606311f, -0.00641384f, 0.00401419f, 0.04968513f, -0.02732670f, 
    0.03609755f, 0.04013409f, 0.06750561f, 0.10713944f, 0.05101909f, 0.15444696f, -0.02943516f, 0.08545472f, 
    -0.01114697f, 0.03906708f, -0.00160132f, -0.13757969f, 0.07680181f, -0.09738915f, -0.13893186f, -0.09731863f, 
    0.04219585f, 0.12180461f, 0.04607586f, 0.11807375f, -0.25316423f, 0.11095156f, 0.05891677f, 0.00609573f, 
    -0.15214159f, -0.07387253f, -0.03080721f, -0.02704364f, 0.13426286f, 0.18399785f, 0.20675452f, 0.05925518f, 
    -0.12970987f, -0.21197586f, -0.00685158f, 0.01414362f, 0.11551731f, 0.00788936f, 0.09322374f, 0.06082949f, 
    -0.01693345f, 0.04258140f, 0.00506614f, -0.04253367f, -0.16192596f, -0.10139109f, -0.00277496f, 0.11349549f, 
    -0.01696971f, 0.01040712f, -0.02550616f, 0.23901522f, -0.07509889f, 0.01335973f, -0.07255359f, -0.11070160f, 
    0.27037403f, 0.06203756f, 0.00843160f, 0.02554958f, -0.04796871f, 0.07882466f, -0.05247766f, 0.05379467f, 
    -0.14204189f, 0.09803569f, 0.07906821f, -0.02127428f, -0.04219121f, -0.19812278f, 0.16726968f, 0.12826385f, 
    -0.04691613f, 0.08778067f, 0.07547891f, 0.08450855f, 0.03549509f, -0.08400504f, -0.03131637f, -0.09427597f, 
    -0.08226608f, 0.13854322f, -0.07984063f, -0.05903258f, -0.03554479f, 0.05120371f, -0.07380639f, -0.07297078f, 
    -0.12549378f, 0.03577693f, -0.05090157f, -0.15714438f, -0.06080135f, 0.19854294f, -0.22762467f, -0.27261955f, 
    -0.01470890f, -0.06153359f, -0.09490731f, -0.12680981f, 0.03273606f, 0.01047713f, 0.04468670f, -0.03948785f, 
    -0.01435876f, -0.31447491f, -0.07125101f, 0.08263379f, 0.10493710f, -0.01533798f, 0.07074220f, 0.02327342f, 
    -0.03585478f, 0.05916733f, 0.04725873f, -0.02859097f, -0.10498855f, -0.18116146f, 0.05288953f, 0.25498766f, 
    0.02693542f, 0.11154240f, 0.11647218f, 0.08149067f, 0.01090749f, -0.00634871f, -0.02595640f, -0.06119126f, 
    -0.07478283f, -0.16490304f, 0.13052957f, -0.07867674f, -0.00295840f, 0.21642981f, 0.06635594f, -0.07813867f, 
    0.10548475f, -0.06564598f, 0.22082445f, 0.03186421f, 0.06661884f, 0.28605309f, 0.05452501f, 0.02596764f, 
    -0.02858819f, -0.01254686f, 0.10852441f, -0.01966818f, 0.11695834f, -0.06584797f, 0.02814777f, 0.20337203f, 
    -0.13452673f, 0.23167013f, -0.00403553f, -0.21622385f, -0.01913834f, -0.09216584f, -0.03761927f, -0.03133566f, 
    -0.04560616f, 0.03584779f, 0.03100650f, 0.04734464f, -0.20656748f, -0.05177497f, 0.07502919f, 0.06564198f, 
    0.00028964f, 0.02910576f, 0.10880437f, 0.05806092f, 0.06521867f, 0.11875314f, 0.06620628f, 0.03822346f, 
    -0.01257823f, 0.03350906f, 0.01770939f, -0.07740429f, -0.09154771f, -0.06258157f, -0.03881426f, -0.08873229f, 
    -0.00445270f, -0.03131148f, -0.06359034f, 0.04178347f, 0.03062811f, -0.10721000f, -0.10235358f, -0.02044188f, 
    -0.06751908f, -0.02348399f, -0.06472782f, 0.03352116f, -0.08947081f, 0.02468329f, 0.00667263f, 0.03322139f, 
    -0.03200395f, 0.05700152f, -0.07296803f, -0.01078199f, -0.07876433f, -0.04251303f, 0.00234468f, -0.00427190f, 
    -0.02653483f, -0.00743022f, 0.03058467f, -0.07275572f, -0.02335604f, -0.04175847f, 0.01618202f, -0.04935181f, 
    0.02446506f, -0.06622827f, -0.07417855f, -0.04026791f, -0.04962532f, -0.03775003f, 0.02772261f, -0.08883760f, 
    -0.05549547f, 0.00032356f, -0.04521505f, -0.08537090f, -0.10263013f, -0.05530967f, -0.06362631f, -0.01424667f, 
    -0.07648117f, 0.03131750f, -0.02409944f, -0.09371310f, -0.04995462f, 0.02766962f, -0.05269200f, -0.09403412f, 
    -0.00778580f, -0.00629073f, -0.01072005f, 0.00766410f, -0.05410875f, -0.05852346f, 0.02907502f, -0.08199397f, 
    -0.01900266f, -0.08751054f, 0.00113225f, -0.07705951f, -0.00653317f, -0.04928564f, -0.01195149f, -0.05611987f, 
    0.01428724f, 0.01168645f, -0.10187881f, -0.03642221f, 0.02127029f, 0.02008974f, 0.05138623f, -0.05734604f, 
    -0.06196533f, -0.03042861f, -0.04827966f, -0.08572981f, -0.06641665f, 0.04008283f, 0.03736585f, -0.00645165f, 
    0.02673240f, 0.02311054f, 0.01806770f, -0.06242860f, -0.02358553f, 0.00770844f, -0.01953010f, -0.01738468f, 
    0.03626551f, 0.02328367f, 0.01844449f, 0.00341613f, -0.05989498f, 0.05583192f, -0.02146143f, -0.03900558f, 
    -0.06554230f, -0.00297030f, -0.01923203f, -0.08115207f, -0.05047365f, 0.05576098f, -0.07131540f, 0.00921638f, 
    -0.01044271f, -0.07030378f, -0.07936444f, -0.05876980f, -0.09568966f, -0.10133278f, -0.01715082f, -0.06576101f, 
    -0.01729934f, -0.07882659f, 0.03190080f, -0.03842633f, 0.02988331f, 0.03793450f, -0.01207640f, -0.00128320f, 
    0.01782308f, -0.03233293f, 0.02929799f, -0.07780819f, -0.06606866f, -0.03319772f, 0.05914283f, -0.05670916f, 
    -0.01248401f, -0.07351837f, -0.06585706f, -0.04361252f, -0.05098283f, -0.07826648f, 0.00008293f, -0.03208143f, 
    -0.04829449f, -0.03887666f, 0.01373947f, -0.08992095f, -0.02132715f, -0.08456515f, -0.09071018f, -0.04128346f, 
    0.01233365f, -0.09845184f, -0.09711898f, -0.07988063f, -0.07992931f, -0.09201872f, -0.02968545f, -0.04974288f, 
    -0.03537811f, 0.05650500f, 0.00007363f, -0.01935559f, 0.03428574f, -0.08858150f, -0.08778269f, 0.04499438f, 
    0.03996953f, -0.07472772f, -0.07431241f, 0.02209549f, 0.01233022f, -0.06990772f, -0.09489390f, -0.01171956f, 
    -0.01695980f, -0.00615653f, -0.00738817f, -0.02322184f, 0.00243984f, -0.07111511f, -0.07391975f, -0.04797500f, 
    -0.26540998f, 0.13156174f, 0.11474561f, 0.09566082f, -0.07758047f, -0.03919425f, -0.14170037f, 0.18949348f, 
    -0.03694493f, 0.09023319f, 0.12467710f, 0.08548857f, -0.16963683f, -0.19471253f, -0.14418268f, 0.24603234f, 
    -0.04555930f, 0.09229103f, -0.04975326f, 0.14425236f, -0.07830203f, -0.07979334f, 0.04487611f, 0.07161415f, 
    -0.02439217f, -0.11439405f, 0.10005380f, -0.05584502f, -0.02508530f, 0.06380006f, 0.01890239f, -0.05285580f, 
    -0.10934446f, -0.00771995f, 0.01994362f, -0.01366866f, -0.01481589f, 0.14829160f, 0.28794593f, -0.09748136f, 
    0.02457331f, -0.01312453f, -0.02519578f, 0.02140751f, -0.00095050f, 0.12694348f, 0.12240201f, -0.04792955f, 
    -0.35598394f, -0.27811560f, 0.13505054f, 0.18060289f, 0.01688362f, -0.13749300f, 0.14085375f, -0.01069873f, 
    -0.05570948f, -0.02364376f, -0.04399931f, 0.01898446f, -0.09343625f, 0.09900764f, 0.15384541f, 0.18194132f, 
    -0.11517360f, -0.10813171f, 0.01048224f, 0.09224482f, -0.02297633f, 0.08226099f, 0.04370303f, 0.05370368f, 
    0.33854356f, 0.15396474f, -0.20604396f, -0.06612790f, -0.05990792f, -0.06902500f, -0.08531685f, -0.06914505f, 
    0.13989614f, 0.29224950f, 0.02746157f, 0.11612356f, 0.23637031f, -0.38126206f, -0.10131980f, 0.21753991f, 
    -0.03955391f, 0.17437905f, 0.07488624f, 0.09138601f, 0.05068576f, -0.00604398f, -0.05441882f, -0.09341271f, 
    -0.04599019f, 0.13116345f, 0.00029200f, 0.08879682f, 0.09274237f, 0.06223316f, -0.05939301f, 0.08085823f, 
    -0.00835954f, 0.06661440f, -0.12589113f, -0.01461118f, -0.38079685f, 0.23155852f, 0.05884755f, 0.00590042f, 
    0.01971879f, -0.04108454f, -0.06175241f, -0.02619471f, -0.09043460f, 0.14110635f, -0.04124969f, 0.01955515f, 
    -0.18786651f, -0.16410576f, -0.03358388f, 0.36673638f, 0.07584862f, 0.06937441f, -0.10820498f, 0.02076904f, 
    -0.01353454f, 0.06525687f, 0.02807852f, 0.00932668f, -0.21649027f, 0.00859535f, 0.01899325f, 0.17654981f, 
    -0.14226779f, 0.07087703f, 0.07188246f, 0.00578838f, -0.02086687f, 0.15676332f, -0.01383798f, 0.02364540f, 
    -0.02234243f, -0.11451171f, 0.09388704f, -0.00048131f, 0.02338482f, 0.18398005f, 0.05654906f, 0.13679811f, 
    0.00910174f, -0.11400504f, -0.01212964f, 0.08529693f, -0.10351529f, 0.15040402f, 0.03117907f, -0.02460017f, 
    0.02514910f, 0.04564567f, 0.11165281f, -0.02966821f, -0.01971190f, -0.03722415f, 0.02245171f, 0.06279148f, 
    0.15916227f, 0.05318118f, -0.03374264f, -0.37047148f, -0.00960129f, -0.02824428f, -0.05005357f, -0.08486000f, 
    0.07600781f, 0.09020641f, -0.03866686f, -0.11662487f, -0.02383393f, 0.23826450f, 0.26973712f, 0.22319451f, 
    0.00076176f, 0.03232649f, -0.06293222f, 0.10032897f, -0.02144549f, 0.07998394f, 0.01672265f, 0.04876630f, 
    0.01956275f, 0.03627826f, -0.56817597f, -0.12840071f, 0.03179802f, -0.10370138f, -0.09399114f, 0.02180672f, 
    -0.00785991f, 0.07094828f, -0.03605880f, 0.01643624f, 0.18388422f, 0.09648959f, 0.18386649f, -0.10228167f, 
    0.01756837f, 0.02979613f, 0.00210549f, 0.08633066f, 0.02856549f, 0.02228276f, 0.01046155f, -0.05920433f, 
    0.05111545f, 0.04533149f, 0.05241555f, -0.15812817f, 0.18273014f, 0.02171676f, -0.00813808f, -0.04874798f, 
    0.06712362f, 0.01811154f, -0.01265243f, -0.01706723f, 0.05236678f, 0.15292908f, 0.21337572f, 0.18233418f, 
    0.02895136f, 0.18954064f, 0.02934042f, 0.00233525f, 0.03133362f, -0.00371466f, 0.26808119f, 0.12887309f, 
    -0.07849620f, -0.05604358f, -0.08634434f, -0.00852549f, 0.02451994f, 0.01622854f, 0.00021682f, -0.01900414f, 
    -0.05887210f, 0.00585834f, -0.00594506f, 0.01770269f, 0.00771510f, -0.38594624f, -0.06785996f, -0.28428364f, 
    -0.04506410f, 0.01042106f, -0.08284062f, 0.19176093f, 0.03240264f, -0.09238276f, -0.02481174f, -0.01102833f, 
    -0.04972275f, 0.16886568f, -0.04043237f, 0.04246226f, -0.04705643f, -0.06114450f, -0.07332695f, -0.06985751f, 
    0.03376365f, 0.03838037f, 0.08350242f, 0.13520995f, 0.04065471f, 0.09381574f, -0.32154927f, 0.15235209f, 
    -0.04266720f, -0.03010971f, 0.03806610f, 0.27710795f, -0.03513899f, 0.04444350f, -0.11641971f, -0.08570293f, 
    0.05083776f, -0.19714576f, 0.22521600f, -0.21204379f, -0.02873325f, -0.04705814f, -0.05160929f, -0.09830222f, 
    -0.07879189f, 0.01500189f, 0.02297049f, 0.05973055f, 0.30439112f, 0.28528625f, -0.05968900f, -0.16375962f, 
    -0.08673551f, -0.01033065f, -0.02657936f, -0.05853669f, 0.24422868f, 0.00477798f, 0.04792200f, 0.12504509f, 
    0.02930037f, 0.11626765f, 0.07472186f, 0.02960631f, -0.01319811f, 0.19968021f, 0.14741677f, 0.17814374f, 
    0.03047935f, 0.06847172f, -0.09116095f, 0.02124649f, -0.08311911f, -0.34641480f, 0.01442972f, 0.14522283f, 
    -0.06710391f, 0.02748439f, -0.02879783f, 0.09459009f, -0.06304926f, -0.06292624f, 0.05799140f, -0.20549744f, 
    0.08034757f, -0.09082595f, 0.06246463f, -0.08769437f, 0.03061176f, 0.13418019f, -0.00034693f, -0.01965143f, 
    -0.00686667f, 0.00572269f, -0.04850968f, -0.04104587f, 0.00112302f, 0.01774933f, 0.11284722f, 0.12994316f, 
    0.03744498f, -0.04153969f, 0.04880549f, -0.01470009f, -0.03510797f, -0.01720503f, -0.11216123f, 0.03294833f, 
    -0.20820835f, 0.29290247f, -0.29998875f, 0.24151163f, 0.02183741f, 0.08508544f, 0.02922615f, -0.03266719f, 
    -0.01450789f, 0.02252500f, 0.13230951f, -0.06068260f, 0.23270418f, -0.38763943f, -0.03981521f, -0.07396547f, 
    0.04728987f, -0.14446279f, 0.16135266f, 0.09128220f, 0.09097596f, 0.12687962f, 0.24954319f, 0.00434231f, 
    0.24281842f, 0.20324366f, 0.41100425f, 0.16898546f, 0.14090528f, 0.07651031f, 0.20914781f, -0.10453277f, 
    0.01613584f, 0.10370269f, 0.11006030f, 0.00847863f, -0.03924898f, 0.21795842f, -0.07406752f, -0.00150536f, 
    0.09921048f, -0.05024263f, -0.02192820f, 0.06606634f, 0.02146382f, -0.02627331f, -0.16032185f, -0.06586966f, 
    -0.23676282f, 0.00885905f, -0.49316198f, 0.05042188f, -0.01415574f, -0.07562799f, -0.11494448f, -0.17432831f, 
    -0.03821192f, -0.00807423f, 0.03553962f, -0.16832967f, 0.14617650f, 0.00440790f, -0.14431839f, -0.13040872f, 
    0.05809433f, 0.02213535f, 0.24115384f, 0.21118419f, -0.09163594f, -0.04490405f, -0.09269167f, 0.01514373f, 
    0.23494962f, 0.11820131f, -0.07387127f, -0.00849712f, -0.02962766f, 0.13564426f, -0.07529806f, 0.01573812f, 
    0.00355009f, -0.07386326f, -0.12028023f, -0.09572712f, 0.16346431f, 0.18705869f, -0.08097508f, 0.28198832f, 
    0.02704913f, 0.19664811f, 0.17168370f, -0.07099904f, 0.08958337f, -0.02442470f, -0.04075227f, 0.12991954f, 
    0.09241830f, -0.23335031f, 0.09234489f, -0.13654952f, -0.10762773f, 0.06282637f, -0.04694901f, -0.06102357f, 
    0.06855810f, 0.16563420f, 0.17619441f, 0.10423736f, -0.74796486f, -0.31842771f, 0.13257731f, -0.64467883f, 
    -0.06140758f, -0.15899058f, -0.27325788f, 0.02295548f, -0.09879222f, -0.20545985f, 0.10210624f, 0.18934897f, 
    -0.16271618f, -0.15224174f, -0.24546300f, 0.05804795f, -0.00142258f, -0.27246928f, -0.08474856f, -0.23344444f, 
    0.08634874f, -0.03118964f, 0.11151981f, -0.07677541f, -0.09200133f, 0.00964818f, -0.18513641f, -0.32035032f, 
    -0.09267739f, -0.11245519f, 0.19384909f, 0.02197314f, -0.09813960f, 0.25271666f, 0.03019013f, -0.15876490f, 
    0.14210847f, 0.01698845f, 0.01682377f, 0.04564999f, 0.10322799f, -0.01375950f, 0.15454808f, 0.20270801f, 
    0.05987341f, -0.04619325f, 0.00372428f, -0.01649659f, 0.12769409f, 0.26567954f, 0.09632818f, -0.13038135f, 
    0.22467971f, 0.09143252f, -0.01983027f, 0.12044313f, 0.05426474f, -0.01020423f, 0.10904993f, 0.24128988f, 
    -0.09261994f, 0.00435662f, -0.14338163f, -0.07235959f, 0.11714893f, -0.10470743f, -0.01360816f, -0.13919432f, 
    0.00887763f, 0.10028933f, 0.03007441f, -0.01275769f, 0.44052204f, -0.04567925f, 0.22860508f, 0.18738995f, 
    0.11674821f, 0.07173844f, 0.16503625f, -0.21234870f, 0.06467798f, -0.20804977f, 0.01792659f, -0.21433631f, 
    -0.31586012f, -0.67370343f, 0.43894297f, -0.58318526f, -0.02030721f, 0.12733291f, -0.20388502f, 0.25939849f, 
    -0.27505356f, -0.13215502f, 0.03326130f, 0.10554042f, 0.06853458f, 0.35377783f, -0.01075561f, 0.08188369f, 
    0.01220080f, 0.13763581f, 0.11009282f, -0.00611669f, -0.00889518f, -0.05886457f, 0.03910319f, 0.06745876f, 
    0.01555554f, 0.31913841f, -0.17360951f, 0.14141653f, 0.11701373f, 0.16018455f, -0.13388287f, 0.01577404f, 
    -0.04047229f, -0.08162460f, 0.11845203f, -0.00915640f, 0.03321139f, -0.04700200f, 0.39560533f, 0.10432055f, 
    0.04483175f, 0.10016894f, 0.13937971f, 0.11371832f, 0.06580991f, -0.01343946f, 0.11731666f, -0.11476308f, 
    -0.03756655f, -0.19789271f, -0.04377671f, -0.21594889f, 0.11864396f, 0.02244581f, 0.03752428f, -0.08732598f, 
    0.02663692f, -0.03810151f, -0.06197270f, 0.23647767f, -0.14463486f, -0.02016736f, -0.06531334f, 0.00360915f, 
    0.03742108f, 0.07599346f, -0.06995481f, -0.05793775f, 0.12017675f, -0.01006653f, 0.13020781f, -0.09402966f, 
    0.14688656f, 0.27156818f, 0.26190448f, -0.04786231f, 0.12155183f, 0.08287469f, 0.10447977f, 0.23027545f, 
    0.11394948f, -0.05312807f, 0.04531195f, 0.08773292f, 0.07932021f, -0.20085000f, 0.02520993f, -0.35961452f, 
    0.14321913f, 0.03123791f, -0.15956554f, 0.10110997f, -0.01788398f, 0.03827000f, 0.04935758f, 0.05416062f, 
    -0.37453395f, -0.10687153f, -0.15282588f, 0.08370543f, -0.09832677f, -0.06827322f, -0.04870411f, -0.02851004f, 
    0.01531214f, -0.08510303f, -0.13845050f, -0.01771112f, 0.34618592f, 0.03229019f, -0.39031217f, -0.03970841f, 
    -0.13965988f, 0.18362789f, -0.03070619f, 0.09704448f, -0.13691238f, 0.03119433f, -0.10413172f, -0.16039760f, 
    -0.11414088f, -0.19165520f, 0.09044432f, -0.38737106f, -0.10499591f, -0.04312238f, 0.02936838f, 0.07751218f, 
    -0.27589521f, 0.00979680f, 0.06010824f, 0.01203204f, -0.23708981f, 0.02866658f, 0.17678303f, 0.18401352f, 
    -0.06555477f, -0.07144346f, -0.09798682f, -0.01146055f, 0.20695297f, -0.15678713f, 0.06012617f, 0.17911384f, 
    0.28261590f, 0.48350906f, 0.27927095f, -0.11483862f, 0.04563601f, 0.16462615f, 0.11693814f, 0.14039393f, 
    -0.07095752f, -0.05058281f, -0.06196408f, 0.02033716f, 0.38603005f, 0.03637351f, 0.15350996f, 0.14740327f, 
    0.19740346f, 0.21259087f, 0.09010320f, 0.15177523f, 0.06536077f, 0.03666922f, 0.10045701f, -0.00889106f, 
    -0.03371307f, 0.05659026f, 0.01461561f, -0.04354068f, 0.08781993f, 0.26658890f, 0.07406074f, -0.06250063f, 
    -0.03407668f, -0.04982521f, -0.07401485f, 0.03090798f, 0.05144276f, 0.06565981f, -0.35714519f, -0.00797717f, 
    0.09645768f, -0.06466354f, -0.06321062f, 0.04054683f, 0.02683945f, 0.14077777f, -0.03311110f, 0.22555426f, 
    -0.25222790f, -0.03366438f, -0.60125017f, 0.35900608f, -0.14770642f, -0.01068029f, 0.08054858f, -0.17037238f, 
    -0.11734516f, 0.01411273f, -0.07580341f, 0.02301567f, 0.09093980f, -0.33872133f, 0.12028550f, -0.13193211f, 
    0.11143695f, -0.06282320f, -0.03673891f, -0.00681610f, -0.01928857f, 0.07714425f, 0.11715470f, 0.07602645f, 
    -0.02155749f, 0.02754584f, 0.38104379f, 0.14119901f, -0.08418620f, -0.06447944f, -0.04281958f, -0.10269883f, 
    -0.19757727f, -0.11393070f, 0.15316409f, 0.02589917f, -0.18132675f, -0.15527254f, -0.15900274f, -0.08529090f, 
    -0.03077256f, 0.01410085f, 0.00969489f, 0.05182556f, 0.05506962f, -0.07965493f, -0.04671369f, -0.05823842f, 
    0.05696482f, -0.01204371f, 0.02909639f, 0.04843992f, -0.06525996f, -0.11189549f, 0.06383435f, 0.04283861f, 
    -0.07272924f, -0.13278514f, -0.22953950f, -0.15890513f, 0.08327608f, 0.00625111f, -0.15889612f, -0.03302872f, 
    0.16381896f, 0.03913990f, -0.03504651f, -0.01004619f, -0.24049892f, 0.05464448f, -0.13264403f, -0.00271476f, 
    0.02658769f, 0.08212439f, -0.00833687f, 0.13190444f, -0.28335217f, -0.02923599f, -0.09617496f, -0.38763580f, 
    -0.04260502f, -0.00445851f, -0.15576746f, -0.13870795f, -0.13968420f, 0.26021567f, 0.08493297f, 0.07919490f, 
    -0.10736907f, -0.10029820f, 0.02819262f, -0.15524745f, 0.03719690f, 0.23872314f, -0.06031999f, 0.11437763f, 
    0.09088723f, -0.08290061f, 0.00158469f, -0.19049139f, 0.02047499f, -0.12431696f, 0.05673413f, -0.04581419f, 
    0.15189672f, 0.24765733f, 0.14455980f, 0.15313835f, 0.32827744f, 0.02631325f, 0.15360814f, 0.10753966f, 
    -0.11124177f, -0.03853894f, 0.12592292f, -0.14057651f, 0.08651886f, -0.03668926f, 0.05988283f, 0.14584078f, 
    -0.08845398f, 0.15572783f, -0.24196370f, 0.12888412f, 0.08810369f, 0.00336667f, 0.08711159f, 0.00223500f, 
    0.02203836f, -0.00092639f, -0.03593079f, 0.03372606f, -0.31666672f, -0.02333348f, 0.00531159f, 0.20657204f, 
    0.12977396f, 0.02224946f, -0.07414268f, 0.08113953f, -0.11713123f, 0.09019263f, -0.06190991f, -0.11485083f, 
    -0.19034207f, -0.17414038f, 0.00524846f, 0.01959923f, 0.07080410f, -0.14360435f, -0.06320594f, -0.03282747f, 
    0.00995909f, -0.16839488f, -0.06493438f, -0.03151963f, -0.18514813f, 0.05377148f, 0.05133148f, 0.01806882f, 
    0.01615854f, -0.08643028f, 0.02496625f, -0.09052280f, 0.04555598f, 0.16780439f, 0.17529671f, 0.12031057f, 
    0.02192000f, 0.00453743f, -0.11563175f, 0.21339352f, 0.16835956f, -0.03156786f, -0.07325108f, -0.05281982f, 
    -0.13024275f, -0.11772633f, -0.10052288f, -0.06788549f, 0.05529098f, 0.05020745f, 0.07428560f, -0.07775698f, 
    0.05252307f, 0.00181881f, -0.10595692f, 0.01158848f, -0.13102092f, -0.05410589f, 0.02131352f, 0.07790985f, 
    0.24380355f, -0.14772472f, 0.19620508f, -0.15827303f, -0.13594919f, 0.04589505f, -0.06689125f, 0.04404247f, 
    0.01069416f, -0.03040776f, 0.00057672f, -0.06339298f, -0.01076171f, 0.28009009f, 0.14827174f, 0.21478355f, 
    -0.05434574f, -0.01530906f, -0.08860003f, 0.10932455f, -0.13900059f, 0.05646797f, -0.10495120f, -0.06418660f, 
    -0.03993692f, -0.06365175f, 0.20656525f, 0.12422547f, -0.07787423f, -0.05727185f, -0.01111584f, 0.05736715f, 
    -0.10222611f, 0.05378732f, 0.14404158f, 0.05934897f, -0.14317438f, -0.06655460f, -0.14210363f, -0.08260117f, 
    0.12493256f, 0.06208292f, -0.03535175f, 0.08989494f, -0.00622387f, -0.01193775f, -0.02618555f, 0.02631958f, 
    0.05285283f, -0.00290741f, -0.10986120f, -0.07772505f, 0.11974525f, -0.00754828f, 0.08781933f, -0.07843173f, 
    0.00899611f, 0.03249297f, -0.05285363f, -0.11311467f, 0.06707425f, -0.00775812f, 0.07848696f, 0.08523048f, 
    0.07315924f, -0.03957276f, 0.03378493f, 0.12702686f, -0.00094661f, 0.09645343f, 0.01996264f, 0.02228388f, 
    -0.15600531f, -0.22316033f, -0.06860945f, 0.18378489f, -0.08989643f, -0.07577239f, 0.02323165f, -0.18678096f, 
    -0.06760581f, -0.11986413f, -0.10745858f, -0.03664928f, -0.10987514f, 0.15490218f, 0.04821033f, 0.05601229f, 
    -0.04747813f, 0.01068096f, 0.08827881f, 0.06203672f, 0.04039992f, 0.00942692f, 0.00900331f, 0.00012508f, 
    0.31307101f, 0.13907379f, -0.12912478f, -0.15784742f, -0.08151831f, -0.04046525f, 0.03791644f, -0.07829493f, 
    0.15327121f, 0.30296218f, 0.11531608f, 0.13089933f, 0.09304189f, 0.10697862f, 0.16961391f, 0.20045757f, 
    -0.04332558f, 0.03924179f, 0.08349591f, 0.14319697f, 0.00847028f, -0.05560483f, -0.01508076f, 0.00994376f, 
    0.07162382f, 0.05108568f, -0.23826844f, 0.11990745f, 0.11710882f, 0.06075549f, -0.00491891f, 0.03050031f, 
    0.13833787f, 0.03699527f, -0.01892720f, -0.05017097f, -0.17082606f, 0.14027570f, -0.19978002f, 0.05495235f, 
    0.03875452f, 0.00409372f, -0.11481833f, 0.01286517f, -0.06365277f, 0.19255055f, 0.00239505f, -0.06571278f, 
    -0.11777084f, -0.40262109f, -0.00660239f, 0.21545008f, 0.11844966f, -0.06842393f, -0.03582708f, 0.08761068f, 
    -0.11348717f, -0.13997994f, -0.01919295f, -0.05182363f, -0.10183692f, -0.05325143f, 0.01899072f, 0.11201288f, 
    -0.09224924f, 0.09335817f, 0.01810247f, -0.05462097f, 0.08797467f, 0.00857525f, 0.15198724f, 0.13415244f, 
    0.07002189f, -0.09178213f, 0.07599756f, -0.04304805f, 0.11899416f, 0.10246786f, -0.07305792f, 0.11452655f, 
    -0.11642504f, 0.00666772f, -0.08428678f, -0.10321922f, 0.13972540f, 0.03383433f, 0.26020345f, 0.02858785f, 
    0.11268605f, -0.09454387f, 0.19963782f, -0.04851373f, -0.05650677f, -0.07991514f, 0.01217553f, 0.06443584f, 
    0.13996474f, 0.13865329f, 0.35900787f, -0.38711935f, 0.00382887f, -0.06570563f, -0.08270751f, 0.02134883f, 
    0.04041097f, -0.01374365f, 0.03777799f, -0.15512551f, 0.13133904f, 0.24567686f, 0.17865896f, 0.07177723f, 
    0.02029644f, -0.03639130f, 0.12159899f, 0.05314045f, 0.02461460f, 0.11844353f, 0.05206677f, -0.05073151f, 
    0.02253121f, 0.05010902f, 0.05041317f, 0.05816612f, 0.02494474f, 0.03672480f, -0.01414817f, -0.06123812f, 
    -0.01885162f, -0.05206808f, -0.07629579f, 0.01573895f, 0.00272822f, -0.07154631f, 0.01916974f, -0.02369785f, 
    0.06283827f, -0.03615239f, -0.04853202f, 0.01234514f, -0.03991788f, -0.02050701f, -0.04268382f, 0.04085932f, 
    0.00294910f, -0.02478120f, 0.01202437f, -0.02303034f, -0.00955595f, 0.02222587f, 0.00634605f, -0.07633679f, 
    0.05744459f, -0.05594965f, 0.03364007f, -0.04108187f, -0.00579161f, -0.03917361f, -0.07917907f, -0.01562321f, 
    0.02520916f, 0.03067223f, -0.02058907f, -0.06808400f, 0.02557379f, 0.02029089f, 0.04825070f, -0.00123327f, 
    -0.04772595f, 0.02301022f, 0.00465472f, -0.07787661f, 0.05078653f, 0.04474847f, -0.07800025f, -0.07671530f, 
    -0.02936818f, -0.07069129f, 0.05802648f, -0.06345387f, 0.00369940f, -0.07597857f, -0.04647019f, -0.04391523f, 
    -0.02596858f, -0.07615474f, -0.05730799f, 0.05449997f, 0.05836047f, -0.07653393f, -0.01887450f, -0.06076787f, 
    0.03768825f, 0.00622398f, -0.06374697f, -0.07662980f, -0.06173576f, -0.02532426f, 0.01688106f, 0.01394876f, 
    0.05023256f, -0.02256516f, -0.04371811f, 0.01471620f, 0.02634135f, -0.07826383f, -0.07289108f, 0.05247903f, 
    0.03961964f, 0.02019198f, 0.03438037f, -0.06193318f, 0.06208009f, -0.00964297f, 0.05920786f, -0.00765457f, 
    -0.07344069f, -0.00459172f, 0.01673332f, -0.01287829f, -0.01999458f, -0.02597929f, -0.05321113f, -0.00243511f, 
    -0.00607316f, 0.01599333f, -0.05694029f, 0.03878065f, 0.00581145f, 0.02135655f, 0.06412432f, -0.03668074f, 
    -0.05488986f, -0.02228029f, 0.01928457f, 0.00064244f, -0.02421699f, 0.00803261f, 0.01846164f, -0.03502756f, 
    -0.02414026f, -0.06825031f, -0.00913227f, -0.04639072f, -0.06821775f, 0.05987798f, 0.04872988f, -0.02663832f, 
    -0.04200327f, 0.05237581f, -0.00891726f, -0.05190498f, -0.01031001f, -0.03764426f, -0.04911300f, 0.04160281f, 
    -0.02951214f, -0.00208437f, -0.04414462f, -0.03133629f, 0.02219464f, 0.03474247f, -0.04440429f, 0.02377116f, 
    -0.03357511f, 0.01074663f, -0.03385983f, -0.04897619f, -0.03133573f, -0.07504248f, 0.03442052f, 0.03702774f, 
    -0.03178743f, -0.02466883f, 0.05081743f, -0.06725530f, -0.03352078f, 0.02388516f, -0.06576745f, 0.02990702f, 
    0.00624138f, -0.04928183f, -0.05142234f, 0.00694668f, -0.00791109f, -0.00938562f, 0.05139486f, 0.05059925f, 
    0.01123311f, -0.07127382f, 0.01403329f, -0.04392048f, 0.04191917f, -0.00321309f, -0.02442267f, -0.05550043f, 
    -0.07071666f, 0.02555570f, 0.03928387f, 0.04358166f, 0.00892011f, -0.02439718f, 0.04905738f, -0.04283229f, 
    -0.07797505f, -0.05912510f, 0.05689324f, -0.01060044f, -0.06033820f, 0.03207994f, 0.05815491f, -0.01336109f, 
    -0.00878100f, 0.04450379f, 0.05551641f, -0.03972276f, 0.04662967f, 0.02188983f, -0.05336453f, 0.01601770f, 
    -0.05877952f, -0.04595396f, 0.01370932f, 0.00800617f, -0.03388043f, -0.01004516f, 0.01089716f, -0.05040544f, 
    -0.06422181f, -0.07051691f, -0.07326869f, -0.02784833f, -0.06635673f, -0.04901779f, -0.02783967f, -0.05275212f, 
    0.02155531f, 0.04972902f, -0.06256658f, -0.05498458f, 0.00404187f, -0.05689597f, -0.03759158f, -0.05587725f, 
    0.05632100f, -0.01587270f, -0.04350292f, -0.02265820f, 0.01681193f, 0.01255171f, 0.01015093f, 0.03986781f, 
    0.04179933f, 0.05994596f, -0.00554062f, -0.03078228f, -0.05828907f, -0.03873407f, -0.05786169f, -0.01142612f, 
    0.02993597f, 0.06147575f, -0.04342604f, -0.03616665f, 0.00566846f, -0.02138641f, -0.01823952f, -0.01112556f, 
    0.04009501f, -0.05062022f, 0.03624521f, 0.02496887f, 0.04557721f, -0.07524569f, -0.03241912f, 0.01821444f, 
    -0.01385260f, 0.02978646f, -0.03724320f, 0.01278500f, 0.00259612f, 0.04852767f, 0.03600925f, -0.02100948f, 
    -0.06014765f, -0.02158143f, 0.03774355f, -0.02338026f, -0.03049309f, 0.01420164f, 0.02493985f, -0.05213741f, 
    -0.06306493f, -0.01003886f, -0.05747762f, -0.02586736f, -0.03589161f, 0.05122280f, -0.04495340f, -0.07042355f, 
    -0.06437194f, -0.07760356f, -0.00197472f, 0.06313291f, -0.02852053f, -0.01636803f, -0.04290256f, -0.07795963f, 
    0.03741280f, 0.00399478f, 0.04246749f, 0.00642239f, 0.05530159f, 0.03723339f, -0.07627802f, -0.01124706f, 
    0.02504604f, -0.05012782f, 0.02920776f, -0.02643282f, -0.01140077f, 0.00111828f, 0.01398718f, 0.04729082f, 
    -0.02185060f, -0.00670724f, -0.07595792f, 0.03765660f, -0.05651216f, 0.06130822f, -0.04523452f, -0.05819973f, 
    0.02955002f, 0.06610011f, 0.03008774f, -0.01334785f, -0.01893902f, -0.05967233f, 0.01744215f, 0.05237309f, 
    0.01538312f, -0.04305244f, -0.06123777f, 0.06010264f, -0.05020887f, -0.04853604f, 0.04689714f, -0.01354424f, 
    -0.00650854f, 0.03523285f, -0.03307330f, -0.01336606f, -0.03278665f, 0.01311010f, 0.04486915f, -0.07300316f, 
    -0.00298832f, 0.03386204f, 0.00526901f, -0.04089874f, -0.00627015f, -0.06821514f, -0.01036990f, 0.01673351f, 
    0.00868378f, -0.07494657f, 0.03092017f, 0.01048443f, -0.06659760f, -0.03159883f, 0.05461389f, -0.04635422f, 
    0.03640173f, 0.03987291f, 0.05126763f, -0.02646647f, -0.06704757f, 0.03599823f, 0.01907495f, -0.02887838f, 
    -0.04739203f, 0.01288770f, -0.05189270f, 0.03467991f, -0.07459313f, -0.07011365f, 0.02869632f, 0.03203303f, 
    0.00161729f, 0.04774017f, -0.05796743f, -0.07347960f, -0.07116757f, 0.00480598f, -0.02979775f, -0.01892268f, 
    0.00243709f, -0.02874034f, -0.05704978f, -0.07167076f, 0.00886156f, 0.02830070f, -0.04048994f, 0.02901261f, 
    0.18327148f, 0.13408394f, 0.07362267f, 0.28148627f, -0.16013765f, -0.03351374f, -0.03898678f, -0.13649493f, 
    -0.05764931f, -0.05809188f, 0.04795545f, 0.01451110f, 0.03046533f, 0.03279448f, 0.03627717f, -0.11240581f, 
    -0.11286850f, -0.12986757f, 0.11194468f, -0.01163961f, 0.15676239f, -0.02250743f, -0.12579337f, 0.14533190f, 
    -0.13987167f, -0.04166170f, -0.10351277f, -0.09820601f, -0.11843937f, -0.00798119f, -0.03659457f, -0.06205739f, 
    0.05441332f, 0.04449130f, 0.10454839f, -0.03296324f, 0.03743190f, -0.01727257f, 0.07671507f, 0.27147615f, 
    0.08973490f, 0.04177596f, 0.14677167f, 0.10960993f, 0.00224049f, 0.05085871f, 0.08230548f, 0.07260106f, 
    0.31009671f, 0.21772830f, 0.09158589f, 0.11226843f, -0.00841459f, 0.00868075f, -0.06785756f, -0.14679249f, 
    -0.01748828f, 0.08640056f, -0.04577234f, 0.07937483f, 0.22499938f, -0.01576581f, 0.04439535f, -0.00165435f, 
    0.17175974f, 0.06336314f, 0.11755554f, -0.03096304f, 0.04998957f, -0.17310190f, 0.10183940f, -0.07420751f, 
    -0.25014678f, -0.18800680f, -0.02980281f, -0.08562617f, 0.03969286f, -0.06430454f, 0.02941168f, -0.01985501f, 
    0.15144087f, 0.00351083f, 0.07576981f, 0.02338800f, -0.17111205f, -0.07459946f, -0.28178683f, -0.05866260f, 
    0.05047883f, -0.23408537f, -0.11217388f, -0.10926505f, 0.04398181f, -0.02777930f, -0.03389439f, -0.02414050f, 
    -0.20979504f, -0.20598377f, -0.19125178f, -0.13045061f, -0.12348171f, -0.01417646f, -0.07492955f, -0.01677277f, 
    -0.10147954f, 0.03896781f, -0.03017029f, 0.10119905f, -0.22286287f, -0.09527127f, -0.11932167f, -0.18022721f, 
    -0.05990717f, -0.02520993f, 0.02504842f, -0.12916727f, 0.04352426f, 0.06692128f, 0.00840136f, 0.12724575f, 
    0.06973521f, 0.21829039f, -0.00097454f, 0.22771505f, -0.16605748f, 0.00140761f, 0.08895431f, 0.25056961f, 
    -0.06110218f, 0.05914617f, 0.06348272f, 0.09616902f, 0.08910538f, -0.08217931f, 0.15426745f, 0.08784129f, 
    -0.05501691f, -0.06138553f, -0.13076611f, -0.05027176f, 0.15188080f, 0.00160135f, 0.16729970f, 0.00031477f, 
    0.17255197f, 0.06843565f, -0.00565884f, 0.06106120f, -0.03512405f, 0.02832028f, 0.10823169f, -0.05005085f, 
    -0.07893324f, 0.08425098f, 0.05731714f, 0.00545914f, 0.28870478f, -0.17672460f, 0.11214148f, 0.22104195f, 
    0.07436942f, 0.00599374f, 0.04554243f, -0.12547988f, 0.06284373f, -0.05518461f, 0.08911244f, -0.05307179f, 
    -0.41312093f, -0.20602694f, -0.31652829f, -0.17280611f, -0.10847411f, 0.01523098f, -0.04653843f, 0.06525223f, 
    0.01088278f, 0.01808938f, 0.03614447f, -0.05413743f, 0.30142516f, -0.08268588f, 0.00237992f, 0.15573435f, 
    0.09463470f, 0.03186611f, -0.00450591f, -0.15211454f, -0.12491425f, 0.03435803f, 0.18584426f, -0.03468767f, 
    -0.05555815f, -0.05640854f, -0.03875491f, -0.07713228f, 0.03995078f, 0.01307926f, -0.05492438f, -0.06555854f, 
    -0.07175915f, -0.02192013f, 0.04325845f, 0.04566646f, -0.06474968f, -0.02078107f, -0.01089017f, 0.04757658f, 
    -0.01394346f, -0.00272580f, 0.00987963f, -0.02831239f, 0.02084714f, -0.00532271f, -0.00466874f, 0.05162337f, 
    -0.00316517f, -0.01421261f, -0.06667966f, -0.05194412f, 0.03447735f, -0.06378792f, 0.06136803f, -0.05581293f, 
    -0.07309051f, 0.00309830f, -0.01774905f, -0.06187588f, -0.00960369f, -0.06705248f, -0.04997598f, 0.01661702f, 
    -0.01232746f, -0.04669960f, 0.01301091f, 0.01682445f, 0.02282315f, -0.04162804f, -0.06150659f, -0.07621094f, 
    0.05776862f, 0.00154118f, -0.07465494f, 0.04924322f, -0.06098189f, -0.03651917f, -0.04038541f, 0.03054856f, 
    -0.00910727f, -0.06053760f, -0.03028307f, -0.07854795f, 0.05005223f, -0.04241111f, 0.01848875f, 0.01927983f, 
    -0.00015572f, -0.02478750f, -0.01775333f, -0.06580810f, 0.01405336f, 0.00306187f, -0.07715549f, 0.01180995f, 
    0.06161650f, -0.06879750f, -0.01434460f, -0.03313949f, 0.02945784f, -0.00689799f, 0.02120651f, 0.01903987f, 
    -0.03410705f, -0.07661923f, 0.03990493f, 0.02409933f, 0.00342860f, -0.00341562f, -0.05761458f, 0.03678625f, 
    0.04027835f, 0.02473089f, -0.06454004f, 0.00278822f, -0.01805505f, -0.02318165f, 0.00601956f, -0.06386212f, 
    0.01337539f, 0.01763649f, -0.02767328f, 0.03944420f, 0.04483026f, -0.00430861f, 0.04480913f, 0.02044307f, 
    0.05578396f, 0.03110040f, -0.02845635f, -0.05602754f, -0.04775530f, 0.03482325f, -0.06719244f, 0.03486101f, 
    0.03377204f, 0.04577243f, -0.01102660f, 0.02650533f, 0.02009771f, 0.02329464f, -0.04605675f, -0.06015155f, 
    0.02586793f, -0.01123710f, -0.00778961f, 0.01826547f, -0.07363645f, -0.04174101f, 0.06536231f, 0.06381255f, 
    -0.02397830f, -0.06846861f, -0.02130822f, 0.01734193f, 0.04801994f, -0.05784009f, -0.06480106f, -0.01323361f, 
    0.05324614f, -0.04140217f, 0.06144538f, -0.01738064f, -0.00407206f, -0.06366231f, -0.00003411f, -0.04253472f, 
    0.04810374f, 0.06341454f, -0.02558530f, 0.03246961f, 0.02694361f, -0.06033446f, 0.06155520f, -0.07098129f, 
    0.00630959f, -0.00233891f, 0.00124638f, 0.04097084f, 0.01041669f, -0.03033847f, 0.05540781f, -0.07058623f, 
    0.01285884f, -0.06849290f, -0.02083220f, 0.06289750f, -0.02331183f, 0.00621505f, 0.03000790f, -0.02646295f, 
    -0.00916464f, -0.02986205f, -0.02370573f, 0.04588875f, -0.05950250f, -0.02269759f, -0.06839311f, 0.05168042f, 
    -0.02227763f, -0.05046122f, -0.05217767f, 0.06154060f, -0.06315847f, -0.01033079f, -0.00972887f, -0.00233232f, 
    0.02166652f, -0.05725491f, -0.03923983f, -0.04539897f, 0.06296790f, 0.04589126f, -0.03454668f, 0.02150277f, 
    -0.22701727f, -0.33438051f, -0.30984005f, 0.02220241f, -0.04610018f, -0.14469665f, -0.24891093f, -0.03338923f, 
    0.02515443f, -0.21160972f, -0.12079164f, -0.13249266f, -0.20742778f, -0.09290009f, 0.09019462f, 0.06639502f, 
    0.13827950f, 0.06933942f, -0.02264121f, 0.12177318f, -0.01824748f, 0.03281579f, -0.05756853f, 0.01320285f, 
    -0.00213879f, 0.05973885f, 0.04853288f, 0.06729263f, -0.03267973f, -0.00286310f, -0.06396788f, 0.06476669f, 
    0.01510245f, -0.05885046f, -0.12584482f, -0.03036448f, 0.11813406f, 0.05343090f, -0.09875972f, 0.06396642f, 
    0.06556300f, 0.05696889f, -0.07923577f, 0.03489509f, -0.01695611f, 0.05251702f, 0.00986152f, -0.02826302f, 
    0.09036251f, 0.06276384f, 0.11716356f, 0.03710261f, -0.07530653f, -0.20929039f, -0.15241516f, 0.02213949f, 
    -0.05765466f, -0.02915643f, -0.08721905f, 0.00019813f, -0.04565812f, -0.42181158f, -0.08120156f, -0.31289110f, 
    -0.07371515f, -0.12356980f, -0.10774462f, -0.23747271f, 0.18060538f, 0.09495116f, 0.11095913f, -0.15020908f, 
    -0.06632886f, -0.04516696f, 0.01905866f, 0.03013179f, 0.10757937f, -0.04523308f, 0.06404847f, 0.03074504f, 
    0.07527667f, -0.04862019f, -0.03357556f, -0.05165855f, 0.22143152f, 0.25317851f, 0.15094920f, 0.22046690f, 
    -0.12312638f, -0.12041381f, 0.12689237f, -0.04056021f, -0.02456576f, -0.08101683f, 0.01978602f, 0.01563482f, 
    0.16293561f, 0.11937806f, -0.05667535f, -0.02709168f, -0.01850121f, -0.00452813f, -0.01896383f, -0.02374696f, 
    -0.00624273f, -0.01202796f, 0.03212483f, -0.02149846f, 0.04680061f, 0.08500199f, 0.12406798f, 0.19486678f, 
    0.06757308f, -0.05303105f, -0.01768022f, 0.03043961f, -0.10339177f, -0.08218014f, -0.02984841f, 0.00342583f, 
    -0.23302393f, 0.01061309f, -0.15133110f, 0.01586487f, 0.25420603f, -0.16216332f, 0.08287982f, 0.13068561f, 
    -0.00430389f, -0.02727204f, 0.02316250f, -0.05822956f, -0.19057803f, -0.29595605f, -0.09245451f, -0.45358810f, 
    0.13612999f, -0.11854224f, -0.22241239f, -0.17560041f, 0.10886911f, 0.01886483f, 0.09768084f, 0.12060995f, 
    0.05979556f, 0.03735598f, -0.05133746f, 0.15907449f, 0.05223875f, 0.09141506f, -0.00698413f, 0.01832613f, 
    -0.10695223f, -0.09690273f, -0.08677702f, -0.00827239f, 0.05763962f, 0.08136380f, -0.23554212f, -0.11314261f, 
    -0.12779924f, 0.06007314f, -0.04234632f, -0.09458634f, -0.08830571f, 0.04512272f, -0.06007462f, -0.00555896f, 
    0.19787243f, 0.23929366f, 0.28918475f, 0.12323568f, -0.00676678f, -0.09234959f, 0.02876087f, -0.01875672f, 
    -0.04339863f, -0.04598817f, -0.09190676f, -0.01693053f, 0.14914310f, -0.16497041f, -0.09680647f, -0.14808738f, 
    -0.07188579f, 0.02954597f, -0.07326774f, -0.00679499f, -0.10742409f, -0.08838141f, 0.10881906f, -0.01155827f, 
    -0.27774185f, 0.33584371f, -0.02430746f, -0.10679349f, 0.07929713f, 0.02306535f, -0.12046918f, 0.09965840f, 
    -0.07205366f, 0.00811327f, 0.04213201f, -0.00430994f, -0.04519835f, -0.08939185f, 0.10705580f, 0.18708029f, 
    0.02476448f, 0.16687255f, 0.18619765f, 0.09818701f, -0.01851895f, 0.03712991f, 0.15923150f, -0.02223152f, 
    -0.06568541f, -0.11394174f, 0.00992162f, 0.05903991f, -0.06166439f, -0.09471150f, -0.04719473f, 0.00212681f, 
    -0.06918945f, -0.01703575f, 0.01595709f, 0.06733885f, -0.25049207f, -0.07394904f, 0.02669770f, -0.07411535f, 
    -0.11234593f, 0.00225501f, -0.07518744f, -0.14828196f, 0.07340828f, 0.03771758f, 0.04568337f, -0.03957761f, 
    -0.09726174f, -0.14335202f, 0.15811868f, -0.12056036f, 0.19169086f, -0.05030317f, 0.19978541f, 0.07051440f, 
    -0.09467964f, 0.01102011f, -0.01266933f, 0.01100567f, -0.08714245f, 0.05878590f, 0.00117506f, 0.01061394f, 
    -0.10925607f, 0.01318448f, -0.04435480f, 0.17590435f, 0.03595653f, 0.04388144f, -0.01226145f, -0.03921473f, 
    0.12878621f, -0.08210845f, -0.03298400f, 0.05614118f, -0.00688554f, 0.00043669f, -0.09933071f, 0.11034937f, 
    -0.04884598f, 0.06614573f, 0.04792904f, -0.11881398f, 0.27272165f, -0.31799948f, 0.26264155f, -0.05079231f, 
    0.06214300f, 0.21961108f, 0.15298435f, 0.09106461f, -0.00397245f, -0.00617949f, -0.00947630f, -0.06604351f, 
    -0.24627388f, 0.15614334f, -0.10876277f, 0.10181093f, 0.06734505f, -0.06818520f, 0.10250527f, 0.12818533f, 
    -0.09432221f, 0.15229388f, -0.07628511f, -0.01490434f, -0.28917196f, 0.07730310f, 0.16306987f, 0.10983201f, 
    0.09206159f, -0.06881174f, -0.09771492f, -0.01262413f, -0.07609235f, 0.00611922f, 0.06880885f, -0.05772325f, 
    -0.06117442f, -0.07685899f, 0.15612994f, -0.10671593f, 0.09186994f, 0.14673303f, -0.08863112f, -0.06002361f, 
    -0.09946393f, -0.01525095f, 0.03158537f, 0.04552447f, 0.06219948f, -0.00393411f, 0.07048375f, 0.11848844f, 
    -0.03573785f, 0.14738649f, 0.18078776f, -0.04988715f, -0.06839082f, 0.04582450f, 0.16405746f, 0.23363851f, 
    -0.07116339f, 0.08603273f, 0.02557834f, -0.05044280f, 0.03202273f, 0.23610662f, 0.14061150f, -0.01040747f, 
    0.05253324f, -0.10776620f, 0.04077883f, 0.03517510f, -0.15187337f, 0.15449837f, -0.26991910f, -0.10236430f, 
    -0.02998297f, -0.00535430f, -0.08328751f, -0.09382911f, -0.00410031f, 0.06786714f, -0.08722841f, 0.20433705f, 
    0.09960528f, -0.01040591f, 0.04506852f, -0.02224747f, -0.00020145f, -0.05480335f, -0.04120867f, -0.18215796f, 
    0.02387286f, -0.01038271f, -0.12342111f, -0.00759372f, -0.29946238f, 0.20020543f, 0.06724548f, 0.16261609f, 
    -0.02661970f, -0.02485903f, -0.06054113f, 0.11464547f, 0.02104941f, 0.09896991f, 0.15286565f, 0.08873975f, 
    0.42343071f, 0.00648618f, 0.00103227f, -0.06891447f, -0.03703539f, 0.03979779f, 0.13470609f, 0.01673343f, 
    0.19959795f, 0.00374936f, -0.13127935f, 0.08578975f, 0.04526086f, -0.11079396f, 0.22375540f, 0.22908120f, 
    -0.06328949f, 0.14916977f, -0.06071603f, -0.05065667f, -0.05644122f, -0.12139058f, 0.12386578f, -0.09995664f, 
    -0.30895749f, -0.07286127f, -0.16879846f, -0.02740531f, 0.15367596f, -0.03123670f, -0.02487955f, 0.02380324f, 
    -0.41626331f, 0.00304328f, -0.22748154f, -0.09214313f, 0.24170369f, -0.00905369f, -0.12396032f, -0.13274440f, 
    0.17934932f, -0.09981090f, 0.01976308f, -0.18618433f, -0.07340523f, -0.24108839f, -0.22186294f, -0.25609899f, 
    -0.04131112f, 0.02802387f, -0.01512656f, 0.03305357f, 0.08904026f, -0.01362034f, -0.00405247f, 0.21956760f, 
    0.00786608f, -0.07369332f, -0.06586142f, 0.08383135f, 0.08625949f, 0.23536851f, -0.03096002f, -0.03458413f, 
    -0.17220512f, 0.00048082f, 0.05685214f, 0.05956458f, 0.14476092f, 0.03193170f, 0.04400208f, 0.21492080f, 
    -0.18458065f, 0.03076304f, -0.00424863f, 0.10255396f, -0.27099642f, 0.01395172f, -0.11238421f, -0.15549606f, 
    0.03557142f, 0.06867041f, 0.05483780f, 0.13784637f, -0.10124670f, 0.15800755f, -0.00191208f, 0.10415179f, 
    0.14478515f, 0.11313769f, -0.17591009f, -0.04643811f, 0.05039651f, -0.15918107f, -0.12118880f, 0.09867410f, 
    0.24089752f, -0.20688163f, 0.15222931f, 0.04041541f, -0.02831834f, -0.10614569f, 0.04025453f, -0.00710172f, 
    -0.06310820f, 0.11253273f, -0.07247377f, 0.07041179f, 0.44725841f, 0.00837205f, 0.12864108f, -0.23565224f, 
    -0.32507828f, -0.12163108f, 0.08263819f, 0.00439675f, 0.06745380f, 0.12674944f, 0.05910035f, -0.05599757f, 
    0.05965274f, 0.07809778f, 0.08892320f, 0.06951954f, 0.12938118f, 0.13989407f, 0.01676042f, 0.01482022f, 
    0.06799272f, -0.12705113f, 0.00706866f, -0.01212354f, 0.00860069f, 0.08837427f, -0.06731451f, -0.13151388f, 
    0.00905438f, 0.16373757f, 0.20160389f, 0.26155517f, 0.04280034f, 0.11542151f, 0.10704128f, 0.25501817f, 
    -0.20997187f, -0.03276306f, 0.03610808f, -0.08329844f, -0.02777041f, 0.11061712f, -0.00274477f, -0.00898639f, 
    0.04463787f, -0.23027332f, 0.05540287f, -0.24720390f, -0.03579739f, 0.23479639f, -0.09219874f, -0.15008360f, 
    0.12360463f, -0.09707098f, -0.11264975f, 0.15430723f, 0.02088674f, 0.13702670f, 0.00626371f, -0.08324859f, 
    -0.04540268f, -0.06320383f, 0.00462168f, 0.02183052f, 0.14874484f, -0.05204621f, 0.03098436f, 0.01965807f, 
    -0.01311474f, -0.10108204f, -0.08314399f, 0.00348323f, -0.03353047f, 0.20399180f, -0.04607160f, -0.23609634f, 
    -0.15836880f, 0.01227286f, 0.11776159f, 0.03742009f, -0.03985012f, 0.14725143f, -0.15259185f, 0.10633104f, 
    -0.09332991f, -0.01647252f, 0.11131929f, 0.01481674f, -0.01738320f, 0.05733260f, -0.02934271f, 0.26289058f, 
    0.18946329f, 0.15256442f, -0.06186026f, 0.09230120f, -0.23906270f, -0.26307309f, -0.00529787f, 0.18787785f, 
    -0.03182482f, -0.04637725f, -0.13724723f, -0.08192493f, 0.06393383f, 0.04705397f, 0.18598153f, 0.17386883f, 
    -0.02766365f, -0.12448029f, 0.03766534f, -0.04650457f, -0.12075065f, 0.02908523f, -0.05375969f, 0.07373137f, 
    -0.04927419f, 0.01304454f, -0.10360491f, -0.14639099f, -0.07184016f, -0.17422312f, 0.04258040f, -0.08825982f, 
    -0.06513902f, -0.18468882f, 0.07916866f, 0.03029481f, -0.07551796f, -0.02125064f, 0.21876080f, -0.06950448f, 
    -0.22078255f, -0.02720181f, 0.09871236f, 0.11118276f, 0.01439255f, -0.14031820f, 0.08269141f, 0.13418968f, 
    0.09681334f, 0.05862813f, 0.06355205f, 0.07406869f, 0.07105315f, 0.16561115f, 0.18528688f, 0.14853053f, 
    0.01527457f, -0.03543494f, 0.08060911f, 0.13663456f, 0.08036865f, -0.09788144f, -0.02777083f, 0.06309991f, 
    -0.03070405f, 0.04391881f, -0.09378520f, -0.04099223f, 0.08249383f, -0.13429449f, 0.06270448f, -0.10946843f, 
    -0.04567369f, -0.01686510f, 0.10974888f, -0.03198736f, 0.14240865f, 0.33869475f, -0.24398780f, 0.15617602f, 
    -0.14743017f, -0.31301752f, 0.01272077f, -0.14008506f, -0.10967463f, 0.00526862f, -0.05407771f, -0.01957561f, 
    0.11182059f, -0.18316808f, 0.06821605f, -0.16411541f, 0.00237661f, 0.01742416f, -0.13298157f, 0.13401091f, 
    0.08316600f, -0.23591971f, -0.10910072f, -0.11171190f, -0.22871222f, -0.65033060f, 0.14505233f, -0.01838437f, 
    -0.02207983f, 0.06033608f, -0.11589415f, 0.01070300f, -0.12565322f, 0.01525369f, -0.13963184f, -0.03593490f, 
    -0.01790652f, 0.00332930f, 0.18499552f, 0.13537702f, -0.03612185f, 0.03433097f, 0.04074154f, -0.10809068f, 
    0.18059589f, 0.19276899f, 0.15172061f, 0.21062826f, 0.08483972f, -0.00145732f, 0.11218982f, 0.11385608f, 
    0.07053039f, -0.03087750f, 0.06598240f, 0.19883370f, 0.13548437f, 0.03753991f, 0.17390713f, -0.01781359f, 
    0.05907865f, -0.12984833f, -0.00505394f, 0.03587719f, -0.24347509f, -0.04995143f, -0.01811874f, 0.20340361f, 
    -0.04662753f, 0.14040938f, -0.38714752f, -0.07894788f, -0.17310639f, 0.14080288f, -0.16698104f, -0.09194521f, 
    0.03523138f, 0.07753585f, -0.06649084f, 0.14565927f, 0.04628229f, 0.13756987f, 0.04339578f, -0.05070575f, 
    0.41410679f, 0.34814653f, -0.51094371f, 0.16577883f, 0.04405403f, -0.07778417f, 0.06811719f, -0.07397723f, 
    0.06662594f, -0.11739070f, -0.01630335f, -0.06129869f, 0.17371672f, -0.03951635f, 0.00441803f, -0.04144273f, 
    -0.17430744f, -0.01672482f, 0.00534307f, -0.04990664f, -0.01276437f, -0.01117356f, -0.17168492f, 0.05913181f, 
    0.09917363f, -0.04202709f, 0.19151467f, 0.05274712f, -0.05001508f, 0.04472538f, -0.00674060f, -0.08045548f, 
    0.09658084f, 0.01975060f, 0.06145457f, 0.02541464f, -0.06721260f, -0.05697604f, 0.16044043f, 0.16616793f, 
    -0.01750444f, -0.09935334f, 0.12513556f, 0.01983407f, 0.07806464f, -0.03965421f, -0.01395403f, -0.02277981f, 
    0.02911971f, -0.05719651f, -0.07662495f, 0.09148584f, 0.01722747f, 0.04653508f, 0.05734177f, 0.00125885f, 
    -0.05768203f, 0.04890549f, -0.11652819f, 0.12133104f, 0.06799871f, 0.03238934f, -0.20047703f, -0.05967512f, 
    0.16326512f, 0.04282369f, 0.10537782f, -0.06342649f, 0.07306143f, -0.03131620f, -0.16144659f, -0.05996718f, 
    0.07661619f, 0.35502756f, 0.02163823f, -0.09687626f, 0.04785440f, 0.16018748f, 0.06779780f, 0.03173594f, 
    -0.00313918f, 0.00965442f, -0.01577076f, 0.05276665f, 0.09295262f, 0.27701503f, -0.00849213f, -0.12165044f, 
    0.04619518f, 0.25345233f, 0.05064533f, -0.04650144f, 0.00075011f, 0.10003903f, 0.06506120f, 0.04826996f, 
    -0.40448713f, -0.11671035f, -0.08257788f, 0.01779341f, 0.11380588f, 0.03088457f, 0.00500188f, -0.04168185f, 
    -0.03263260f, -0.01361428f, -0.01208028f, 0.13580446f, 0.20444001f, 0.08648559f, -0.34614870f, -0.30019957f, 
    0.00033142f, -0.23592600f, -0.23397353f, 0.05478706f, -0.07430664f, -0.03457865f, 0.13376786f, 0.03585913f, 
    -0.01232839f, -0.46159437f, -0.10905898f, 0.09045345f, -0.00266069f, -0.08703288f, -0.05569296f, 0.02607318f, 
    0.10869987f, 0.00241741f, 0.10322665f, -0.04923656f, -0.18826689f, -0.40695241f, 0.15353502f, 0.32661355f, 
    0.06730866f, -0.16790742f, 0.05117278f, 0.10554375f, 0.15681237f, 0.13973176f, 0.01636994f, -0.05921076f, 
    -0.00623539f, 0.09228558f, 0.24681006f, -0.14113575f, 0.04044777f, -0.16598956f, -0.03202282f, -0.09707719f, 
    0.12977032f, -0.02298279f, 0.06924046f, 0.03122928f, 0.28272593f, 0.13885608f, 0.01174297f, -0.21793859f, 
    -0.05403572f, 0.11122531f, 0.07635222f, 0.11565334f, -0.07518833f, -0.04623107f, 0.09480756f, 0.09470817f, 
    0.15701692f, 0.01442399f, 0.06147591f, -0.02707747f, 0.06867959f, 0.00338822f, 0.12493769f, 0.19909565f, 
    0.07802002f, -0.05035016f, -0.09873096f, -0.13622914f, 0.17136768f, -0.04905631f, -0.04684746f, -0.18771352f, 
    0.13620234f, 0.15090388f, -0.07444150f, 0.10739642f, -0.03483446f, 0.06678907f, -0.11240974f, -0.03440441f, 
    0.14318533f, -0.12655637f, -0.21116814f, -0.07693253f, 0.09839316f, 0.10938039f, -0.07702257f, -0.04396391f, 
    0.04695827f, -0.05507019f, -0.01953387f, -0.01751605f, 0.06286588f, 0.06010816f, 0.04336304f, -0.15602878f, 
    -0.03568556f, -0.02171278f, -0.00434302f, -0.15560611f, 0.01682709f, 0.04157835f, -0.03854060f, -0.10229395f, 
    0.13220571f, 0.18018341f, 0.21764827f, -0.00516200f, -0.11254481f, -0.01553980f, 0.01561998f, -0.14805813f, 
    -0.12062371f, -0.07223143f, 0.03168835f, -0.00605759f, -0.22955279f, -0.12147154f, -0.04354331f, 0.09145971f, 
    -0.03610608f, 0.09000517f, 0.03020956f, -0.06525273f, -0.04289027f, -0.04815616f, 0.05351274f, -0.07465935f, 
    -0.05157191f, -0.05023937f, -0.02476526f, 0.15604034f, -0.02711995f, 0.00608032f, 0.13214004f, 0.05236944f, 
    -0.01746682f, -0.13188478f, -0.13677192f, -0.03248085f, 0.12621360f, -0.04209856f, -0.10998059f, -0.04311581f, 
    0.19208916f, -0.01010264f, -0.15802819f, -0.04981447f, -0.15746713f, 0.03777196f, -0.14754307f, -0.13805418f, 
    0.12552966f, 0.19562852f, 0.04772592f, 0.12024846f, -0.07264418f, 0.08032805f, -0.03435164f, -0.02529239f, 
    -0.00651496f, 0.01456067f, -0.00030453f, -0.07078621f, -0.01860446f, 0.06812692f, 0.00548940f, 0.06657864f, 
    0.13643694f, -0.07363237f, -0.05300086f, -0.08734377f, 0.10268503f, 0.19976808f, -0.06537148f, 0.11446018f, 
    -0.05217659f, -0.22017851f, 0.07413770f, -0.14982881f, 0.02472216f, -0.06684884f, 0.05179010f, 0.08935823f, 
    0.08729896f, -0.02282527f, 0.14202194f, 0.22503778f, 0.18811823f, 0.00142975f, 0.06631501f, 0.03092233f, 
    0.04927985f, -0.01949523f, 0.10221659f, -0.19606796f, 0.01739681f, 0.05303345f, 0.09252849f, 0.06117943f, 
    -0.09751578f, 0.20312177f, -0.22090478f, 0.04444236f, 0.05615642f, 0.08912497f, 0.13757628f, 0.13159277f, 
    -0.02757210f, 0.08592110f, 0.09953192f, 0.01649203f, -0.27071738f, -0.03532795f, 0.43397626f, 0.14754352f, 
    0.02885981f, 0.08933299f, 0.09731901f, 0.03108169f, -0.12585217f, 0.15299881f, -0.00210855f, 0.02427621f, 
    0.02462816f, 0.34778559f, 0.02341462f, -0.10148201f, 0.03851565f, -0.06283206f, 0.00472617f, 0.02063506f, 
    -0.00221647f, -0.11994134f, -0.02518468f, -0.08537925f, 0.01702478f, 0.19494560f, -0.03901270f, -0.13158914f, 
    0.00209222f, -0.09330053f, 0.02613241f, 0.06293216f, 0.07143551f, 0.07357042f, 0.08812518f, 0.21842325f, 
    -0.00388202f, 0.10811883f, -0.17312178f, 0.24097535f, 0.19296400f, -0.13877860f, 0.07508351f, -0.03746518f, 
    -0.09758609f, 0.05711796f, -0.14197876f, -0.03501500f, 0.12175493f, -0.11200688f, -0.06323083f, -0.04748503f, 
    -0.08897973f, 0.00518258f, -0.17423643f, -0.10109608f, -0.00746256f, 0.00807360f, 0.08710221f, -0.02193548f, 
    0.36423755f, -0.12542722f, 0.13780212f, -0.01703968f, 0.00155973f, 0.10873283f, 0.07969949f, 0.00158499f, 
    0.06050063f, 0.01325139f, 0.01403558f, 0.01663804f, 0.08912577f, 0.32421884f, 0.07309438f, 0.10166173f, 
    -0.04848556f, 0.05198586f, -0.16299222f, -0.06625818f, -0.06122224f, -0.00065140f, -0.04001719f, -0.02237351f, 
    0.15810511f, 0.07101176f, 0.13893256f, 0.28125808f, 0.17086184f, 0.15708166f, -0.02369828f, 0.03268075f, 
    0.10920715f, -0.12880599f, 0.11003948f, 0.00866022f, 0.03485592f, -0.05133560f, 0.00443522f, -0.05469199f, 
    0.15668175f, 0.20496120f, 0.08688699f, -0.00080224f, 0.04628641f, -0.01943175f, -0.04708274f, 0.03389132f, 
    -0.14008062f, -0.14045133f, -0.18980479f, -0.08401088f, 0.08607690f, -0.12067176f, -0.15780874f, 0.08167360f, 
    -0.25544813f, -0.33377138f, -0.54232061f, -0.34773764f, 0.04443266f, 0.01884379f, -0.25561169f, -0.12783399f, 
    0.07860309f, 0.03211350f, -0.12605156f, 0.04940069f, -0.02543875f, -0.24543020f, -0.12827240f, -0.52293074f, 
    0.06936309f, 0.07908889f, -0.02709946f, -0.04928305f, 0.15363163f, 0.08483667f, -0.01116665f, 0.12302393f, 
    0.00847842f, 0.01808225f, -0.02047011f, -0.12105171f, 0.11439087f, 0.02958808f, 0.14005271f, 0.05017428f, 
    0.16331641f, -0.09514186f, 0.08132248f, 0.04991277f, 0.18241523f, 0.08413091f, 0.16146637f, 0.24231616f, 
    0.00295410f, 0.02461749f, -0.16438609f, 0.04765239f, -0.05606437f, -0.13270707f, -0.11319337f, -0.01661162f, 
    0.20059066f, 0.19659142f, -0.05814713f, 0.16100633f, -0.03821368f, 0.61557394f, 0.13147856f, 0.35059130f, 
    -0.01368851f, 0.15573639f, 0.00316400f, 0.11184298f, -0.06842915f, -0.00352194f, 0.02386639f, -0.13275012f, 
    -0.02406000f, -0.03195675f, -0.11448455f, -0.20899804f, -0.15818019f, -0.07383115f, 0.01016856f, -0.04902287f, 
    0.03181804f, 0.06644177f, -0.02787799f, 0.16461577f, -0.08496325f, 0.15240622f, -0.03490109f, 0.38435093f, 
    -0.12038263f, -0.15911616f, -0.33724484f, -0.21412207f, -0.15544118f, -0.08683305f, -0.13368379f, -0.09380803f, 
    0.18153472f, 0.14235759f, 0.09855825f, -0.05298354f, 0.17810464f, 0.09709582f, 0.17126623f, 0.16953866f, 
    -0.05475070f, 0.11117446f, 0.01296902f, -0.01603776f, 0.13931879f, 0.04230174f, 0.18173549f, -0.02443292f, 
    0.15905176f, 0.05579736f, 0.16237393f, 0.15832646f, 0.03759712f, 0.20424685f, 0.13585444f, 0.16220902f, 
    -0.11983630f, -0.24038754f, -0.15402436f, -0.03220389f, 0.08370533f, 0.08557329f, -0.07338608f, -0.09219051f, 
    0.10709205f, -0.17281219f, -0.07519887f, -0.32625669f, 0.17429624f, -0.06434028f, -0.11897106f, 0.03326014f, 
    0.04422611f, -0.10089294f, -0.08696114f, 0.13621795f, -0.01775038f, 0.06140552f, -0.00204717f, -0.10289840f, 
    -0.20018902f, -0.03242562f, -0.13421316f, 0.13991597f, -0.08822937f, 0.12910533f, 0.06049586f, -0.12210917f, 
    0.02595394f, -0.04806138f, -0.16114895f, -0.14286968f, 0.06630716f, 0.03153529f, 0.30923960f, -0.02705458f, 
    -0.00346575f, 0.01478158f, -0.18653691f, -0.03441691f, -0.09471917f, 0.12925893f, 0.07732831f, 0.00469413f, 
    -0.19829829f, 0.08893139f, -0.06006293f, 0.02769389f, 0.03672345f, 0.10023020f, -0.05794232f, 0.06207273f, 
    0.10374273f, -0.09880245f, -0.05725915f, -0.06227246f, -0.09307054f, 0.12689063f, 0.13483477f, 0.22457270f, 
    0.07562928f, 0.12492050f, 0.16676074f, 0.02862702f, 0.05825321f, -0.01533498f, 0.06621817f, -0.07838798f, 
    -0.08004833f, 0.03499213f, -0.00727995f, 0.02152396f, 0.05784336f, 0.20199193f, 0.09036753f, -0.06468318f, 
    0.17131422f, -0.01268376f, 0.26222298f, 0.29972753f, -0.18078117f, -0.05293289f, 0.33542365f, -0.21118116f, 
    -0.09527262f, 0.04615806f, -0.25167608f, 0.00619343f, 0.20008375f, 0.07422467f, 0.06263548f, 0.05437387f, 
    -0.06138016f, -0.16566619f, 0.02976790f, -0.14473115f, 0.16627681f, 0.05905935f, 0.07616016f, 0.20318425f, 
    -0.14683272f, -0.00285084f, 0.15816478f, 0.08595525f, 0.02968522f, 0.06109723f, 0.01762246f, -0.17666346f, 
    -0.00744840f, 0.02528047f, -0.13029771f, 0.08537292f, -0.07651941f, -0.00571914f, -0.02030319f, -0.06525263f, 
    -0.27167466f, 0.10172989f, -0.06080323f, 0.12470180f, -0.03470504f, -0.10778077f, 0.00140542f, 0.18255764f, 
    -0.02556694f, -0.12882085f, -0.06360301f, 0.00945016f, 0.12586434f, -0.31125700f, -0.35928842f, -0.36686933f, 
    -0.05051834f, 0.22283511f, 0.14710332f, -0.04195594f, -0.14534417f, -0.10825658f, -0.12955327f, -0.31585744f, 
    -0.08439903f, -0.08120998f, 0.32520899f, -0.05050304f, -0.13341863f, -0.06652005f, 0.05312878f, 0.08862400f, 
    -0.12359300f, -0.03285178f, -0.09754995f, -0.04757319f, -0.00962060f, -0.16310449f, 0.28877217f, 0.34725189f, 
    -0.16587096f, -0.23277156f, -0.05487752f, -0.10747812f, 0.19375642f, -0.12951376f, 0.13386084f, 0.24228540f, 
    -0.04307521f, 0.20290717f, -0.01507276f, -0.23521814f, 0.03965206f, 0.15256441f, 0.06383222f, -0.20514289f, 
    -0.07561184f, 0.02598589f, -0.10330712f, 0.03722344f, 0.07663763f, 0.04222154f, 0.00685099f, -0.01938324f, 
    0.17122842f, 0.10476707f, 0.01501240f, 0.03748386f, -0.01202017f, 0.00614404f, -0.01822388f, -0.07554994f, 
    -0.04902494f, 0.07586440f, -0.00902543f, 0.03403248f, -0.06625895f, 0.17250909f, 0.17799491f, 0.03440769f, 
    0.20024337f, 0.11651053f, 0.02106088f, 0.19451304f, 0.03023374f, -0.02772778f, -0.04417287f, 0.03671872f, 
    0.01875504f, 0.03044629f, -0.12767641f, 0.06537870f, 0.16433352f, 0.14372914f, 0.03872409f, 0.22226204f, 
    0.06028581f, 0.04424302f, -0.37554270f, 0.09143956f, -0.13084659f, -0.29523021f, 0.21470411f, -0.10396300f, 
    -0.07115898f, -0.01031373f, -0.17664020f, 0.07934817f, -0.00569500f, 0.00076468f, 0.15028512f, -0.16022196f, 
    0.04511211f, 0.00152129f, 0.01712185f, 0.09775798f, 0.14760345f, 0.06856318f, 0.12616709f, 0.06323087f, 
    0.21990992f, -0.63973129f, -0.80916101f, -0.39143217f, -0.10985689f, 0.08416487f, 0.01858419f, 0.05155960f, 
    0.06705205f, 0.00426745f, -0.21905956f, 0.03886051f, 0.17965424f, 0.13481559f, 0.16458564f, -0.12088771f, 
    -0.01308795f, 0.10440791f, -0.21287799f, -0.03060626f, -0.07840987f, -0.00248090f, -0.01239665f, 0.02682479f, 
    0.08322190f, 0.04517987f, 0.02694299f, 0.01679085f, 0.04081522f, 0.09629909f, 0.04573981f, -0.04863398f, 
    -0.00364110f, 0.06406068f, 0.00183417f, 0.09867959f, 0.19524661f, 0.09879730f, -0.04180297f, 0.07163873f, 
    -0.05212672f, 0.08331063f, 0.14953431f, -0.02582697f, 0.18599854f, 0.01854530f, 0.15017413f, 0.15294991f, 
    -0.05011359f, -0.12354621f, -0.40414268f, -0.23461221f, 0.17898212f, -0.02084070f, -0.29256198f, 0.25284821f, 
    -0.10381730f, -0.11367821f, 0.06078539f, -0.04314489f, -0.56398767f, -0.60852343f, -0.37810594f, -0.44335955f, 
    0.01117519f, 0.00642083f, -0.09775337f, 0.10911062f, 0.21250314f, -0.05005463f, 0.04420676f, -0.13218133f, 
    0.01674214f, 0.20810822f, 0.00810543f, 0.00595897f, -0.01788062f, 0.11267046f, 0.00692580f, 0.01191160f, 
    -0.00639976f, -0.13570046f, -0.14972937f, -0.05457244f, 0.18284944f, 0.20437904f, 0.00683665f, 0.25460112f, 
    -0.29683945f, -0.16258158f, -0.09515193f, 0.08850921f, 0.01510969f, 0.05061181f, 0.01558936f, 0.05073988f, 
    0.39199531f, -0.03759667f, 0.20734581f, 0.07734585f, 0.08235678f, 0.03566575f, -0.03406542f, 0.03155395f, 
    0.03704088f, 0.16714424f, -0.04056806f, -0.02099767f, 0.45374614f, 0.15507466f, 0.19127642f, -0.02802192f, 
    -0.07346597f, 0.02873052f, 0.04631686f, -0.08670118f, 0.04655954f, 0.00052506f, -0.02145485f, 0.05883260f, 
    -0.00638324f, -0.07121038f, -0.19678150f, 0.33127382f, 0.19011945f, 0.08328067f, 0.07539431f, 0.14394379f, 
    -0.16288723f, 0.03255256f, 0.03157067f, 0.01055868f, -0.10730054f, -0.18706486f, 0.01123764f, -0.12237619f, 
    0.00043190f, 0.11180840f, 0.04975748f, 0.06535468f, -0.05278167f, -0.17244396f, -0.03288521f, 0.03682221f, 
    0.02658681f, -0.06384892f, 0.03893701f, -0.19169980f, -0.11338032f, 0.15029225f, 0.15887450f, 0.06697646f, 
    -0.08622257f, 0.05755934f, 0.08432595f, 0.05258282f, 0.00750303f, 0.06791291f, -0.14082134f, 0.09358343f, 
    -0.16498166f, -0.01941363f, 0.20850568f, -0.15821767f, -0.00501199f, 0.03617787f, 0.05685903f, -0.14358509f, 
    0.37937316f, 0.30889535f, 0.06980960f, 0.19384001f, 0.03449116f, -0.05119577f, 0.02233504f, -0.04934809f, 
    0.10351837f, 0.07902998f, 0.11367410f, 0.03653853f, 0.06314419f, -0.37585187f, -0.55692220f, -0.51422489f, 
    -0.10563523f, 0.00247424f, 0.12119972f, -0.11787759f, 0.09057199f, 0.09993899f, -0.09597413f, -0.01016738f, 
    -0.22928466f, -0.12228885f, 0.03802689f, 0.03126520f, 0.11390906f, -0.05726378f, -0.01460708f, 0.17129593f, 
    -0.00115490f, 0.12311047f, 0.08252227f, 0.03729832f, -0.11137844f, 0.05634046f, 0.08915146f, 0.14554092f, 
    0.06994861f, 0.11503580f, 0.18199168f, 0.06526531f, -0.01959306f, 0.04144167f, 0.07039957f, 0.06014846f, 
    0.00642397f, -0.01352482f, 0.07128765f, -0.09161322f, 0.04290440f, -0.08571536f, -0.13776432f, -0.01826203f, 
    -0.02493685f, 0.12346622f, 0.05191508f, -0.02037491f, -0.37044859f, -0.03704074f, -0.07016720f, 0.17372850f, 
    -0.17935666f, 0.13433763f, -0.04173823f, -0.13365223f, 0.18952554f, 0.09463901f, 0.02958778f, 0.07461593f, 
    -0.15157019f, -0.11190949f, 0.01682858f, 0.10064791f, 0.03344882f, -0.05071515f, 0.21916138f, -0.00396258f, 
    -0.04262443f, 0.03712146f, 0.05003759f, -0.02609160f, -0.08867790f, -0.15031393f, -0.07593562f, 0.07042143f, 
    -0.00923717f, -0.06001795f, 0.12491045f, 0.15440480f, -0.07378200f, -0.05695649f, -0.00047992f, -0.08321755f, 
    0.23681340f, -0.06656724f, -0.11108996f, -0.08171364f, 0.16530603f, 0.06331466f, -0.00230212f, 0.00164841f, 
    -0.02750686f, 0.05286776f, 0.08316733f, -0.00482825f, 0.01632214f, 0.15322940f, 0.39950022f, 0.23099776f, 
    0.02394576f, 0.00294355f, 0.03784273f, 0.14467223f, -0.01598359f, -0.02957316f, -0.06210262f, -0.01021666f, 
    -0.21842057f, 0.29828900f, -0.10666826f, -0.17229386f, -0.05825857f, 0.02617735f, -0.07455339f, -0.09548581f, 
    0.09251976f, 0.09077059f, -0.19949652f, -0.05716105f, -0.36399058f, -0.09710082f, -0.43825048f, 0.08667029f, 
    0.01388646f, -0.03408428f, -0.19196981f, -0.00221606f, -0.01730327f, -0.01783188f, 0.08815964f, 0.04663242f, 
    0.00486533f, -0.30609059f, 0.06869589f, 0.11388566f, -0.01917088f, -0.06533208f, 0.00697496f, 0.10725867f, 
    -0.02123384f, 0.02773779f, 0.03604199f, 0.10193345f, -0.02407641f, -0.07514951f, 0.09490175f, 0.17400919f, 
    0.02669165f, -0.07382363f, -0.01247682f, -0.06456199f, -0.00340542f, 0.00742626f, 0.09611670f, -0.01698316f, 
    -0.09109249f, 0.01793505f, 0.05263721f, 0.01109755f, 0.12864697f, 0.23660244f, 0.07411249f, 0.01727176f, 
    0.08367559f, -0.11793590f, 0.09322325f, 0.09278325f, -0.10402773f, 0.23390886f, -0.00536526f, -0.06451603f, 
    -0.07122931f, 0.05700210f, -0.01590337f, 0.05262437f, 0.10481749f, 0.06840453f, -0.00829740f, 0.21065615f, 
    -0.07891104f, 0.13537766f, 0.13023689f, 0.11237535f, -0.01086081f, -0.12958571f, -0.17883047f, -0.10325094f, 
    -0.08887149f, -0.04689925f, -0.05967780f, 0.04667492f, -0.13555470f, -0.16510689f, 0.22778377f, 0.12341948f, 
    -0.03066964f, 0.07366367f, 0.01933502f, 0.14934433f, 0.08136945f, 0.03161706f, 0.24584167f, 0.09807862f, 
    0.01528211f, 0.04819131f, 0.05176236f, 0.01769325f, -0.04886662f, -0.01343593f, -0.07322795f, -0.01299968f, 
    -0.07547905f, -0.04768398f, -0.05173743f, -0.07473432f, 0.05341647f, 0.02649208f, -0.08347965f, 0.03918749f, 
    0.04799369f, -0.05361350f, 0.01763009f, 0.04383574f, -0.05607474f, -0.06816554f, 0.03906612f, -0.01571824f, 
    -0.02914965f, 0.04416875f, -0.02814188f, -0.05774280f, -0.06674109f, -0.01326136f, 0.02949641f, 0.01947960f, 
    -0.02013820f, -0.00740294f, 0.04704336f, 0.00527325f, 0.00537362f, 0.02924359f, 0.04472238f, -0.01031535f, 
    0.01729066f, 0.01472387f, 0.01918121f, -0.01194917f, 0.06038749f, -0.08220915f, 0.03989920f, 0.00357023f, 
    -0.02453209f, -0.01521198f, 0.02521248f, 0.01463547f, -0.07244995f, -0.04484228f, -0.05033704f, -0.06589660f, 
    -0.06555264f, 0.01070550f, 0.01404562f, -0.03092534f, 0.03107072f, -0.04533829f, -0.00333529f, -0.06741037f, 
    -0.02954507f, 0.04726345f, -0.03194233f, 0.02682634f, 0.03270239f, -0.04942621f, -0.06518293f, 0.02602493f, 
    0.00707608f, -0.01431548f, -0.04861547f, 0.02570884f, 0.04387134f, -0.07717901f, -0.05032938f, -0.01850307f, 
    0.02106949f, 0.05224115f, 0.00905928f, 0.02283391f, -0.04788924f, -0.05869949f, -0.01251306f, 0.03421426f, 
    -0.03450417f, -0.07784263f, 0.04545694f, 0.06156527f, 0.01821346f, 0.01970659f, -0.04781239f, -0.07478533f, 
    -0.04241012f, -0.05829900f, -0.05582951f, -0.05704782f, 0.04092514f, -0.03323182f, 0.01002740f, 0.02905988f, 
    -0.03002447f, -0.07772257f, 0.02146538f, -0.04929744f, 0.03472519f, -0.04203688f, 0.01180476f, 0.04553141f, 
    -0.06410140f, -0.06341363f, 0.01619384f, -0.07104059f, -0.06140668f, -0.01453228f, 0.05655790f, -0.04842119f, 
    -0.04828361f, 0.01609704f, -0.03310032f, 0.00175719f, 0.05120026f, -0.00093903f, 0.03935769f, -0.06424888f, 
    0.02259648f, -0.00485074f, -0.08183848f, -0.07711323f, -0.07854463f, 0.04721238f, -0.06126750f, -0.00073508f, 
    -0.04692390f, -0.01624331f, 0.05788226f, -0.08210581f, -0.02882479f, 0.04388584f, -0.01316613f, -0.06703528f, 
    0.04405838f, 0.01817198f, -0.07182562f, 0.01335760f, 0.05493262f, 0.02490424f, -0.06320537f, -0.02448038f, 
    0.05917183f, -0.00135348f, -0.06836236f, 0.01641224f, 0.02135964f, -0.05985709f, 0.04644878f, -0.05228722f, 
    0.01311051f, -0.00950726f, 0.04740617f, -0.06707070f, 0.01112533f, 0.00641197f, 0.01489167f, 0.04191878f, 
    0.01306608f, -0.00016288f, 0.05394391f, -0.06569257f, -0.02221140f, 0.03065610f, 0.06124974f, 0.04517604f, 
    -0.00278811f, 0.06568882f, -0.07083186f, -0.02686070f, -0.02695509f, 0.04811759f, 0.03730204f, -0.00911550f, 
    0.01919869f, 0.05577772f, -0.06738947f, -0.03205941f, -0.08296138f, 0.00692533f, -0.07015213f, -0.04760554f, 
    0.13819928f, 0.05248808f, 0.28943929f, 0.35599649f, -0.09026974f, -0.01371895f, 0.13069881f, 0.13265656f, 
    -0.01464755f, -0.03248093f, -0.04264551f, 0.02817934f, -0.36864603f, -0.05802675f, -0.35283467f, 0.03004971f, 
    -0.00345597f, -0.02558679f, -0.20280164f, 0.06510501f, -0.09984214f, -0.04631398f, -0.13886835f, 0.02925250f, 
    -0.00724358f, 0.06627379f, -0.01421711f, -0.03185904f, -0.03779022f, -0.05393078f, 0.02532648f, -0.17722699f, 
    -0.11679411f, -0.03684047f, -0.05239889f, -0.02802720f, 0.32018387f, -0.08178580f, 0.23598872f, -0.15342160f, 
    -0.01985290f, -0.02122544f, 0.06215834f, 0.13247140f, 0.00513782f, 0.05105327f, 0.00643860f, 0.07622699f, 
    -0.16394258f, -0.04669133f, -0.05587203f, 0.05050716f, -0.14808963f, -0.00311311f, -0.10520155f, 0.05483504f, 
    -0.12103867f, -0.10770030f, 0.00962081f, -0.00988736f, -0.03607322f, 0.11346773f, 0.07336589f, -0.11572893f, 
    -0.05674111f, 0.00808955f, 0.10911785f, -0.09003267f, 0.07974081f, 0.02917637f, 0.14168203f, -0.09151275f, 
    0.00936317f, 0.27903593f, 0.05513064f, -0.06033269f, 0.05301426f, -0.06141391f, 0.01078815f, -0.11409929f, 
    0.20488749f, 0.03366415f, -0.01620957f, 0.08472586f, -0.31117320f, 0.21513580f, 0.05274981f, -0.24522953f, 
    -0.21758881f, -0.05193989f, -0.14189753f, 0.13345648f, 0.10784455f, -0.11135004f, -0.01725447f, 0.01025104f, 
    0.29526919f, -0.04882941f, 0.08275928f, -0.00338722f, -0.17876467f, -0.06185384f, -0.03593485f, -0.09564035f, 
    0.10751990f, -0.02614883f, 0.09414235f, -0.06584059f, -0.02608448f, 0.09484930f, 0.09447607f, 0.22684695f, 
    0.01525514f, 0.00354947f, 0.02819601f, -0.08188904f, -0.06369546f, -0.02380590f, 0.04078778f, -0.02887611f, 
    -0.34824121f, 0.11169377f, -0.15010615f, 0.29421949f, -0.07212602f, -0.09569880f, 0.09948857f, 0.18297373f, 
    -0.04280419f, 0.05859187f, -0.02733689f, 0.08213467f, -0.03785281f, 0.23823248f, 0.14302568f, -0.24302740f, 
    0.07886963f, 0.01598398f, -0.10952204f, 0.01230397f, 0.08320573f, -0.13161051f, -0.07059828f, 0.05775019f, 
    0.03107204f, 0.08037449f, -0.20946151f, -0.00273046f, -0.03649032f, 0.09132420f, 0.04271139f, 0.01974223f, 
    -0.01121249f, 0.15723161f, 0.01895711f, 0.09787534f, 0.33070973f, -0.04860503f, 0.21496342f, 0.04985467f, 
    0.01901905f, 0.02479071f, 0.23796047f, -0.01683889f, 0.02726453f, 0.02083125f, 0.07229207f, -0.23593709f, 
    0.33880463f, -0.02859228f, 0.32704458f, -0.13812639f, -0.17368406f, -0.04744147f, -0.02971156f, 0.14921734f, 
    0.12997720f, -0.02462233f, -0.01690595f, -0.06914227f, 0.15938038f, 0.14218986f, 0.06454714f, -0.31948337f, 
    -0.19137321f, -0.09260686f, -0.15945041f, 0.07355066f, -0.00760935f, 0.04953526f, -0.01510841f, 0.05061112f, 
    -0.05966943f, 0.15313163f, -0.12681374f, 0.01974862f, 0.14456320f, 0.08475979f, 0.05297897f, 0.09496837f, 
    0.00355088f, 0.25183886f, -0.00580556f, 0.06476967f, 0.18213327f, 0.14401972f, 0.04696282f, -0.08509029f, 
    -0.02292078f, -0.06849732f, 0.03411867f, 0.05517117f, -0.10324042f, 0.14291146f, -0.09533727f, 0.00001508f, 
    -0.12884048f, -0.08159065f, 0.04845925f, -0.13919504f, 0.03780065f, -0.09972095f, -0.12096503f, -0.09341623f, 
    -0.01606533f, 0.12110810f, 0.21922278f, 0.07593641f, 0.10464537f, 0.18737525f, 0.21285880f, 0.09630629f, 
    -0.06928068f, -0.00811716f, 0.13749580f, 0.02169793f, 0.19759530f, 0.01268844f, 0.22803077f, 0.02763349f, 
    -0.07076760f, -0.14471723f, 0.09203912f, 0.02511557f, 0.21985108f, -0.02646141f, 0.08744176f, 0.16724823f, 
    -0.12896699f, 0.02673648f, 0.04580812f, 0.11371894f, 0.01111718f, -0.18471709f, -0.06381686f, 0.19283338f, 
    0.16325018f, 0.01955667f, -0.00613354f, 0.18067139f, 0.01564828f, -0.16500366f, -0.06529927f, -0.14775169f, 
    0.26775947f, 0.08457277f, -0.04479314f, 0.01698287f, -0.17687353f, 0.05888773f, -0.06315452f, -0.03150654f, 
    -0.02335853f, -0.07567569f, -0.13662083f, -0.11781481f, -0.42335317f, -0.18400547f, 0.11337102f, 0.26652497f, 
    -0.06474381f, -0.02558877f, -0.23294452f, 0.03947464f, 0.06325891f, -0.05961518f, -0.05891063f, -0.11964477f, 
    -0.06432977f, 0.16198692f, 0.15673465f, -0.06201030f, -0.16276915f, -0.03559082f, -0.17210922f, -0.11901601f, 
    -0.00421080f, 0.06885528f, -0.00264301f, -0.13073632f, 0.25999677f, 0.18986005f, -0.16438140f, -0.36542973f, 
    -0.09577966f, 0.02726652f, 0.03174547f, -0.10960326f, -0.01888959f, -0.11444527f, 0.05651366f, 0.08814551f, 
    0.14714915f, 0.01254972f, -0.12040024f, 0.21451779f, 0.17518243f, 0.14425056f, 0.09013496f, 0.27917388f, 
    -0.11844131f, 0.21811965f, -0.02529177f, -0.00181561f, -0.09786481f, -0.13101842f, 0.01767296f, 0.29603261f, 
    0.02379576f, 0.01579087f, 0.01394982f, 0.04781309f, 0.00868368f, -0.13112855f, -0.06672148f, -0.09281375f, 
    0.05398752f, -0.06848543f, 0.08332095f, -0.21179725f, -0.05480680f, 0.05526685f, 0.01703216f, -0.03130353f, 
    0.06042777f, 0.09113406f, 0.18293351f, 0.11562933f, 0.06516593f, 0.02973879f, 0.00684629f, 0.26124340f, 
    0.03288527f, -0.13229774f, 0.09741110f, -0.13430250f, 0.14441505f, -0.04073279f, -0.04018041f, -0.05944088f, 
    -0.28523099f, 0.19526115f, -0.11173264f, -0.09242450f, 0.04291673f, -0.13446905f, -0.10613231f, 0.03484291f, 
    0.01763611f, 0.03826847f, -0.10501961f, 0.04903458f, 0.00600514f, 0.04252589f, -0.12500612f, 0.12372618f, 
    0.07430444f, 0.03512226f, 0.22583278f, -0.02635834f, 0.25362167f, 0.04680387f, 0.14348282f, 0.02854938f, 
    -0.05748215f, -0.01419245f, -0.06449432f, -0.07989171f, -0.06398717f, 0.03460918f, -0.04289921f, 0.00592926f, 
    0.00420611f, -0.02432209f, -0.02102377f, -0.07218836f, -0.00287381f, 0.00652176f, -0.06898713f, -0.02509700f, 
    0.04068356f, -0.06483728f, -0.06037929f, -0.01968533f, 0.00721170f, 0.01534904f, -0.02234672f, 0.02316841f, 
    -0.05143610f, -0.06501304f, 0.03492052f, 0.04045931f, 0.04731904f, -0.06139675f, 0.04703173f, -0.02389652f, 
    -0.06565230f, 0.05300483f, -0.04394960f, 0.05271135f, 0.05519189f, -0.02052729f, -0.06019385f, 0.05659199f, 
    -0.01253199f, -0.01039401f, 0.02998057f, -0.06349740f, 0.00388997f, -0.04930412f, -0.00815302f, 0.00673687f, 
    0.04164172f, 0.05705106f, -0.02528903f, 0.05470889f, -0.05498550f, 0.01544318f, -0.03928263f, -0.04073958f, 
    0.05276757f, 0.04893067f, -0.07995171f, -0.01229429f, -0.05470381f, 0.03944455f, 0.01536922f, 0.03751438f, 
    -0.01179582f, -0.03565204f, 0.00246937f, -0.03723190f, 0.01438962f, -0.07821493f, -0.07090794f, 0.04713518f, 
    -0.00167787f, -0.04987414f, 0.00740125f, 0.01115204f, -0.00568955f, 0.05739912f, 0.04094850f, 0.02295675f, 
    0.05163129f, 0.02972218f, -0.05773153f, -0.04397947f, 0.01044691f, 0.03401199f, -0.06827416f, -0.05375044f, 
    -0.02102054f, 0.01004945f, 0.01872107f, -0.06410459f, -0.00978350f, -0.05737019f, -0.07269967f, -0.07706774f, 
    -0.01458041f, 0.01857115f, 0.03333629f, -0.03641911f, -0.06789654f, -0.05648946f, -0.06578878f, -0.07079898f, 
    -0.01732937f, 0.00954009f, -0.04273470f, -0.06068676f, 0.00885639f, -0.02013058f, -0.04136960f, -0.01735503f, 
    -0.08542591f, 0.01694085f, -0.04829958f, -0.02892290f, -0.04848481f, -0.03314545f, -0.02900542f, -0.00167521f, 
    -0.07662201f, 0.01091270f, 0.05660937f, 0.00862565f, 0.01543762f, -0.01642898f, -0.03769211f, 0.01529307f, 
    -0.05924765f, -0.07114109f, -0.03809889f, 0.03701554f, 0.00408222f, -0.01106758f, 0.05167519f, 0.03796985f, 
    -0.05308795f, -0.03072528f, 0.00974792f, 0.01819608f, 0.04445581f, -0.02523566f, -0.07957878f, -0.08123832f, 
    0.00008428f, -0.01521072f, 0.00289919f, 0.01512072f, 0.05403264f, 0.05783889f, -0.06791258f, -0.07857630f, 
    -0.03131238f, 0.05273808f, -0.03139214f, 0.03429866f, -0.05363360f, 0.03176453f, 0.02763824f, -0.00106551f, 
    -0.05476905f, 0.02193643f, 0.05729311f, -0.00063055f, -0.07871393f, -0.01948856f, 0.04056500f, -0.00034246f, 
    0.01133228f, -0.00600767f, -0.07359198f, 0.02406855f, 0.02652674f, 0.03937024f, -0.02264306f, 0.04193925f, 
    -0.02648155f, 0.00832852f, -0.07413609f, 0.01309491f, -0.02893669f, -0.02528648f, -0.06133328f, 0.04979242f, 
    -0.06926240f, 0.02489583f, -0.06245765f, 0.04867929f, 0.02990662f, 0.00485401f, -0.03472273f, 0.02540592f, 
    0.16583648f, -0.03517526f, 0.03882546f, 0.04960647f, 0.12307671f, -0.08599839f, 0.05971642f, -0.03060713f, 
    0.02986849f, 0.12514909f, 0.08807784f, 0.26468462f, 0.31450117f, 0.05745807f, -0.27830362f, -0.24018615f, 
    0.04218553f, 0.12175969f, 0.01031100f, 0.09527172f, 0.03892071f, -0.06910525f, 0.02659640f, -0.11372658f, 
    -0.15901452f, -0.01022903f, -0.20846052f, -0.17773348f, -0.03396806f, -0.30311331f, 0.04681394f, -0.00618362f, 
    -0.20515105f, -0.45735067f, -0.33031356f, -0.50006348f, -0.07263635f, 0.02592682f, 0.04643984f, 0.17963657f, 
    0.03562843f, -0.19779992f, -0.03440609f, -0.13933347f, -0.21630736f, -0.20125066f, 0.01716804f, -0.08691346f, 
    0.16512103f, -0.05962005f, -0.19408725f, -0.14818417f, 0.00240291f, 0.05423893f, -0.04736053f, 0.01244150f, 
    -0.06169070f, -0.10679506f, -0.19165893f, -0.27290118f, 0.05411817f, -0.00918889f, 0.08335844f, 0.03813187f, 
    0.03747739f, 0.08552249f, 0.10374679f, 0.10738949f, 0.08641089f, 0.13409756f, -0.03778753f, 0.29935977f, 
    0.21195419f, 0.11506256f, 0.20863016f, -0.16905692f, -0.28033552f, -0.13021921f, 0.06152793f, -0.01486406f, 
    0.09686351f, 0.33969837f, 0.25420007f, 0.40082702f, 0.41320470f, -0.00447117f, -0.02987541f, 0.36471313f, 
    0.03834788f, 0.17356357f, 0.30777282f, -0.00512278f, -0.14759099f, 0.05886164f, -0.15242228f, 0.14536065f, 
    0.01562144f, 0.12317929f, -0.15822992f, 0.06172555f, 0.02186168f, 0.11486758f, 0.01806304f, -0.19935949f, 
    -0.02706035f, -0.01955578f, 0.10186318f, 0.19168177f, -0.09229468f, 0.37554106f, -0.07393012f, -0.24869588f, 
    -0.02755657f, -0.00408860f, -0.10767651f, -0.24416934f, -0.05708494f, 0.04140330f, 0.02687551f, -0.03586996f, 
    0.06648411f, 0.07312826f, -0.11349580f, 0.03977231f, -0.06949764f, 0.09900146f, -0.06321115f, 0.21094739f, 
    0.06198022f, 0.12694508f, 0.07110065f, -0.07462485f, -0.15960106f, -0.19668122f, 0.01449419f, 0.17677590f, 
    0.01931260f, 0.11521208f, 0.25349486f, 0.26730323f, -0.03082171f, 0.14024128f, 0.21950525f, 0.15226029f, 
    0.08493239f, -0.08920732f, -0.07155115f, -0.09957639f, 0.08823834f, -0.23786801f, -0.16169548f, -0.03142207f, 
    -0.18850319f, -0.00075523f, -0.19125916f, -0.34750557f, 0.22888036f, -0.06145054f, 0.16952589f, 0.07573038f, 
    -0.08318616f, 0.00435559f, 0.08134574f, 0.08789138f, -0.00276832f, -0.11490003f, 0.03117961f, 0.25281054f, 
    -0.13377349f, 0.10021134f, -0.04342453f, -0.03473015f, -0.05892385f, 0.21346271f, 0.14436869f, -0.01435350f, 
    -0.32140213f, 0.00864407f, 0.03334541f, -0.13722935f, 0.01696902f, 0.07446569f, 0.10131925f, 0.21559262f, 
    0.00521787f, -0.16811568f, 0.13613336f, -0.21745664f, -0.01635947f, 0.25420821f, 0.14299552f, -0.03250754f, 
    -0.31154981f, 0.05827716f, -0.21476102f, -0.00756179f, 0.07345124f, 0.01796341f, -0.17869465f, 0.14078778f, 
    -0.08010886f, 0.03072063f, 0.04952567f, 0.10007497f, 0.17587456f, -0.18093197f, 0.38617116f, 0.20968992f, 
    0.03831742f, 0.17775576f, 0.07198109f, 0.06367258f, -0.05711418f, -0.07630709f, 0.08462349f, -0.01599757f, 
    -0.02547246f, -0.17846316f, 0.12526888f, -0.17347805f, 0.15578504f, 0.00270253f, -0.07528304f, 0.15881027f, 
    -0.13053179f, -0.06181160f, -0.07910173f, 0.17565571f, -0.10732363f, 0.34641033f, -0.06259554f, 0.02031461f, 
    -0.01746466f, 0.05347143f, -0.05658661f, -0.23933637f, 0.05981708f, 0.02358793f, 0.04361171f, -0.07197881f, 
    -0.06452172f, -0.05981678f, 0.27562743f, 0.19675408f, 0.09082663f, 0.00590618f, 0.10849109f, 0.16936778f, 
    0.07568868f, 0.05048469f, -0.04348524f, -0.08148093f, 0.02739774f, -0.08082841f, 0.10097467f, -0.12243199f, 
    -0.02199413f, -0.05786355f, -0.06734342f, 0.12329150f, 0.01122318f, -0.03378060f, 0.04148225f, -0.02977639f, 
    -0.11490873f, -0.25283334f, -0.23903885f, 0.00297876f, -0.00959940f, 0.01253732f, -0.08376545f, 0.05411821f, 
    -0.03080522f, 0.07180778f, 0.01264264f, 0.02523543f, 0.55818003f, 0.05696456f, -0.09277537f, 0.49317470f, 
    0.20121205f, 0.30887839f, 0.32790545f, 0.11792803f, -0.09030828f, -0.00885719f, -0.02864311f, -0.12940080f, 
    -0.10839852f, -0.18731296f, -0.13199612f, -0.36573842f, 0.08298662f, 0.04078737f, 0.07933478f, 0.18916483f, 
    -0.10215198f, 0.19803943f, -0.11915854f, 0.09844024f, -0.31467223f, -0.07740606f, -0.19176312f, 0.14153655f, 
    0.13096893f, -0.05940811f, -0.19187731f, 0.14771460f, 0.13170728f, -0.02272005f, 0.11370067f, 0.06599703f, 
    0.14167458f, 0.04790435f, 0.21353218f, 0.06460592f, 0.03016008f, 0.10430492f, -0.06189468f, -0.05088443f, 
    0.03966491f, 0.04597170f, -0.09328633f, -0.02523750f, -0.01208126f, -0.11835488f, 0.01641776f, 0.19334215f, 
    -0.18833144f, 0.01106474f, 0.23761667f, 0.15456556f, -0.05919147f, 0.15971352f, 0.14025101f, 0.05627234f, 
    -0.02380263f, -0.07307762f, 0.23127666f, -0.04739668f, 0.13622694f, 0.20058763f, -0.02955799f, -0.00853721f, 
    -0.01852504f, -0.25534073f, -0.07899165f, -0.08695289f, -0.29344481f, 0.21531466f, -0.30595279f, -0.24525227f, 
    -0.13232814f, -0.03538620f, -0.16095778f, 0.11391432f, -0.11017431f, -0.03756499f, -0.04522191f, 0.26212114f, 
    -0.13974606f, -0.00888555f, -0.41432530f, 0.28030849f, 0.13975804f, -0.09321821f, 0.15404391f, -0.30281177f, 
    0.06419075f, 0.02245020f, 0.06343471f, -0.03631783f, -0.20405674f, -0.20836340f, 0.30093825f, 0.09092268f, 
    0.05697966f, -0.00095567f, 0.00298448f, 0.05824303f, 0.00175213f, 0.07619745f, 0.00221710f, 0.04551359f, 
    -0.33537427f, 0.14110051f, -0.16328485f, -0.04065629f, 0.14201364f, 0.03728941f, -0.02880758f, 0.10127600f, 
    0.02437789f, 0.16809486f, 0.09436479f, 0.04075074f, -0.12406676f, 0.11715154f, 0.01477424f, 0.07445713f, 
    0.06117743f, -0.00801664f, 0.18022950f, 0.16370258f, 0.00901686f, -0.01240678f, 0.04493279f, 0.02786866f, 
    -0.03464503f, -0.09452319f, 0.00100094f, 0.03888627f, 0.18800901f, 0.04157842f, 0.09115501f, -0.02387805f, 
    -0.02438067f, 0.04076507f, -0.03427011f, 0.05232866f, -0.15474778f, 0.01878781f, 0.06041018f, -0.04033510f, 
    -0.06139449f, -0.09018007f, 0.08277390f, -0.06804736f, 0.10176130f, 0.19612838f, 0.02450617f, 0.11769342f, 
    -0.17534648f, -0.09960937f, -0.11546438f, -0.24079837f, 0.12031190f, 0.10991760f, 0.16464980f, 0.10851563f, 
    0.01653504f, 0.02496635f, -0.06851628f, 0.03404203f, -0.00710234f, 0.03357087f, -0.05876038f, -0.25096667f, 
    -0.06490577f, 0.10151692f, 0.07777938f, 0.16185625f, -0.00860691f, 0.00913539f, -0.03430440f, -0.02985422f, 
    0.01905293f, 0.10420676f, -0.14920810f, 0.07130158f, -0.03942504f, 0.09134288f, 0.01595144f, -0.06100447f, 
    0.01051166f, 0.10561828f, -0.06629760f, -0.00816416f, 0.18882635f, -0.24005045f, -0.24866943f, -0.08077770f, 
    0.16104454f, 0.22401990f, 0.11839321f, 0.11230545f, 0.02862022f, -0.05344844f, 0.04711674f, -0.02566199f, 
    0.04380046f, -0.33896327f, 0.27933535f, 0.02865656f, 0.01012543f, 0.10562729f, 0.00561913f, -0.06796140f, 
    0.01858843f, -0.09851396f, -0.00351509f, -0.03515045f, -0.05999180f, 0.16293627f, 0.02268646f, 0.17651741f, 
    -0.02900520f, -0.09902384f, -0.02641510f, 0.00395963f, 0.13160470f, 0.13874200f, 0.05890744f, 0.09597353f, 
    -0.18026310f, -0.30715838f, -0.06624303f, -0.19665556f, 0.02450904f, -0.07784858f, -0.03527683f, -0.07305265f, 
    0.14984013f, -0.05732471f, 0.16349924f, -0.02599669f, 0.06604973f, -0.14014819f, -0.03005283f, 0.04595960f, 
    -0.10071653f, 0.12338138f, 0.04382659f, -0.00810693f, -0.05532504f, -0.02082714f, 0.03916290f, -0.07197536f, 
    0.03156049f, -0.22204974f, 0.24181898f, -0.14228763f, 0.07303062f, 0.27674976f, 0.00129599f, 0.27811360f, 
    0.14348577f, -0.11603342f, 0.06635682f, -0.06786393f, -0.03022508f, -0.04159102f, -0.00330950f, 0.00074481f, 
    0.17128938f, -0.00284456f, 0.07017356f, 0.19627936f, 0.20356186f, -0.09007315f, -0.02888601f, 0.18406573f, 
    -0.11903371f, 0.25215077f, -0.32791874f, -0.13932028f, -0.02465209f, 0.07976429f, -0.02869824f, -0.05513005f, 
    -0.07727002f, -0.08143500f, 0.07760745f, -0.03794770f, 0.09130596f, -0.01419420f, 0.26486769f, -0.06888583f, 
    0.00142933f, -0.12820645f, 0.20052625f, -0.00671060f, 0.12620574f, 0.20135038f, 0.12693086f, 0.04204010f, 
    -0.30031824f, 0.21457338f, 0.12062989f, 0.34889016f, 0.03476354f, -0.06903875f, -0.14416085f, 0.17384729f, 
    -0.03877010f, -0.02451920f, -0.07070586f, 0.00344441f, -0.29040319f, -0.17527133f, -0.00492956f, 0.14537498f, 
    -0.01194856f, 0.12158875f, -0.01654895f, 0.12123165f, -0.09459605f, -0.02167565f, -0.03016245f, -0.00239553f, 
    0.07056919f, -0.07894107f, 0.16306274f, -0.08592875f, 0.00614933f, 0.01294001f, -0.05954610f, 0.03746004f, 
    0.03976491f, -0.01393312f, -0.04007676f, -0.00777350f, 0.17461371f, 0.13031162f, 0.19161512f, -0.02459196f, 
    0.04827818f, 0.09682390f, 0.02765182f, 0.11735038f, 0.03150457f, -0.09379192f, 0.10384633f, 0.05745257f, 
    -0.16370569f, -0.17168672f, 0.22792198f, 0.21851861f, -0.06616919f, -0.21882977f, 0.11794751f, 0.12363058f, 
    -0.13418548f, -0.04368759f, 0.05694326f, 0.03691593f, 0.01180769f, -0.24998398f, 0.25103000f, -0.01928369f, 
    -0.09367746f, -0.17964748f, -0.04072322f, 0.02147308f, 0.13953985f, 0.07048798f, 0.07627069f, -0.00709062f, 
    0.11290292f, -0.03401190f, -0.20468569f, -0.03237312f, 0.01276001f, -0.10690128f, 0.07938743f, -0.09718088f, 
    0.12823460f, 0.05490214f, 0.04571185f, -0.04331370f, -0.00699238f, 0.17404725f, 0.07674292f, 0.20750497f, 
    0.00500880f, 0.07264884f, 0.01357748f, 0.07477736f, -0.01701974f, 0.06979569f, -0.05407853f, -0.19097921f, 
    -0.15073226f, 0.24609292f, -0.02239921f, -0.17689914f, -0.15014598f, -0.01995131f, 0.02572367f, 0.12231789f, 
    0.14786908f, 0.03966873f, 0.02447472f, 0.01678039f, -0.33845028f, -0.03788102f, 0.10056976f, 0.34368095f, 
    0.22294952f, 0.10646872f, -0.11482131f, -0.12212943f, -0.01959057f, -0.04035275f, 0.04798236f, 0.01549984f, 
    -0.16376041f, 0.17657739f, 0.05074989f, 0.23383883f, -0.00801180f, 0.10483003f, 0.07585210f, 0.09343733f, 
    -0.10038161f, 0.04847717f, -0.06287184f, 0.05502693f, -0.02330566f, 0.00447976f, 0.04667359f, -0.09354611f, 
    -0.03232216f, -0.11010447f, -0.05544341f, -0.02768509f, 0.16548279f, -0.02571204f, -0.00608634f, 0.03005756f, 
    -0.06227378f, 0.14950392f, -0.15169942f, 0.11408975f, 0.13002197f, 0.18550615f, 0.18128590f, 0.11450021f, 
    0.03320013f, -0.05335124f, -0.07100173f, 0.16419558f, -0.03092164f, 0.13570710f, -0.17455585f, -0.11075684f, 
    -0.02999377f, 0.10618453f, 0.06442208f, 0.05563752f, 0.06405649f, 0.14478715f, 0.00216812f, -0.07204592f, 
    0.26070336f, -0.16016001f, 0.09835263f, 0.13941766f, -0.21511132f, -0.19003822f, -0.02145291f, -0.03050020f, 
    0.09826045f, 0.01234967f, -0.08551206f, -0.03579300f, 0.17973971f, -0.10276946f, 0.17844203f, 0.08792637f, 
    -0.09392501f, 0.02388913f, -0.19829327f, 0.06925622f, -0.07208171f, -0.08605498f, -0.04815391f, 0.01407929f, 
    -0.00212502f, -0.17502292f, 0.14135280f, 0.18654601f, -0.03815084f, 0.05940026f, 0.14227387f, 0.04356735f, 
    -0.00258414f, 0.01053467f, 0.13237135f, 0.00518076f, -0.22986330f, 0.02451466f, -0.17811848f, 0.02104353f, 
    0.15760127f, -0.03005625f, -0.00438487f, -0.03943712f, 0.04878320f, 0.01774109f, -0.15807201f, 0.03600027f, 
    0.01255340f, 0.04968914f, -0.05610614f, -0.02720452f, 0.01107209f, -0.06185200f, 0.01281465f, -0.15186462f, 
    0.00725495f, 0.03954577f, 0.09481491f, 0.04017908f, 0.13220258f, -0.08029146f, 0.12931874f, -0.06100937f, 
    -0.00362595f, -0.05158900f, 0.05485078f, 0.05534057f, 0.00357369f, 0.11538687f, -0.04207144f, 0.14676175f, 
    -0.09126528f, 0.04017135f, -0.06516128f, 0.03056040f, 0.03336180f, 0.02306932f, -0.02098039f, -0.02398117f, 
    0.01279402f, -0.13460641f, -0.06342593f, -0.06075571f, -0.15849239f, 0.03911516f, -0.04325553f, -0.20427839f, 
    0.04614884f, 0.08024798f, 0.11274848f, -0.03439108f, 0.00729584f, 0.08097701f, -0.01169450f, -0.06872453f, 
    -0.04198972f, 0.22303560f, -0.00395992f, -0.07981638f, -0.08329263f, 0.03120349f, 0.05339306f, 0.00660009f, 
    0.03960248f, 0.10943640f, 0.03058942f, -0.08283750f, -0.00403669f, 0.29729608f, -0.30656224f, -0.27542686f, 
    -0.05231399f, -0.08876648f, -0.08604202f, 0.11580533f, 0.03092785f, -0.11249230f, -0.02626763f, 0.03840200f, 
    0.10217442f, -0.23368335f, 0.17867117f, -0.07298311f, -0.05223458f, 0.02933452f, -0.15625331f, -0.12967551f, 
    -0.02181435f, -0.13459589f, 0.04500584f, -0.16553855f, 0.09969095f, -0.22888726f, -0.10930943f, 0.08770987f, 
    -0.14927955f, -0.09812249f, -0.05953998f, -0.06069692f, 0.11456013f, 0.13371132f, 0.08275593f, 0.08558124f, 
    -0.17536674f, -0.15577206f, -0.02827329f, 0.23393831f, -0.04685831f, -0.15175895f, 0.16405021f, 0.04540842f, 
    -0.09483994f, 0.02354161f, -0.01149850f, -0.01175205f, 0.10794892f, 0.16187875f, 0.12505428f, -0.09167885f, 
    0.04911530f, -0.00393802f, -0.13675809f, -0.02209149f, 0.05577802f, -0.13486089f, -0.12629296f, -0.09384974f, 
    0.08744587f, -0.09180050f, -0.07920441f, 0.00794084f, -0.06173566f, 0.05825098f, -0.08315226f, 0.12530585f, 
    -0.06998751f, 0.13620834f, -0.09800328f, -0.00800352f, 0.24845609f, -0.14760886f, 0.32563347f, 0.15753184f, 
    0.07286616f, -0.06518864f, 0.12783910f, -0.02816167f, -0.00320804f, -0.00315196f, 0.02447420f, -0.06926812f, 
    0.13384251f, 0.21476272f, 0.24602075f, -0.11914019f, -0.11826101f, 0.00262100f, 0.03385453f, 0.11230868f, 
    -0.01124821f, 0.01234341f, 0.03136411f, -0.05799728f, 0.32006770f, -0.06186808f, 0.02956785f, -0.21444678f, 
    0.03080027f, -0.02979281f, 0.00155503f, 0.00735840f, 0.05976429f, 0.13217242f, 0.04663707f, 0.08696971f, 
    -0.07699810f, -0.26718324f, -0.37603250f, -0.25123528f, 0.04949753f, -0.17819805f, -0.15950176f, 0.10810972f, 
    0.04490355f, 0.05759390f, -0.06801525f, 0.13520810f, -0.11110304f, -0.39096472f, 0.07837701f, -0.08857222f, 
    0.11052333f, 0.19093806f, -0.01370074f, 0.02304396f, 0.05565567f, 0.04415732f, 0.06336883f, 0.00149492f, 
    0.06948810f, 0.05428614f, -0.01905889f, -0.07517476f, 0.11885383f, -0.02532772f, -0.07093666f, -0.05754661f, 
    -0.13559368f, -0.01657807f, -0.03506745f, -0.08152314f, 0.00080905f, 0.17501688f, -0.03777223f, 0.12265644f, 
    -0.00067592f, 0.00410981f, -0.00932734f, 0.01007631f, 0.01266562f, 0.07840347f, 0.07230093f, -0.00770850f, 
    -0.20591748f, -0.10743929f, -0.30482107f, -0.32411587f, -0.02276512f, 0.07644393f, 0.07207771f, -0.01486232f, 
    0.03363524f, -0.05573425f, -0.06037939f, -0.06369598f, -0.12769097f, -0.13624083f, -0.02232059f, -0.48499388f, 
    -0.04530320f, 0.04302533f, -0.05023763f, -0.02167414f, 0.21530274f, 0.13366483f, 0.06014059f, -0.05526149f, 
    0.16769163f, 0.13774703f, 0.10519597f, -0.00063889f, -0.06769045f, 0.06540725f, 0.11925849f, -0.04089371f, 
    0.09655359f, 0.09592062f, -0.09604116f, 0.05245229f, 0.57728809f, -0.07542191f, -0.15810698f, 0.05522811f, 
    0.09491235f, 0.24466264f, 0.30325735f, 0.30593264f, -0.00999360f, -0.00553135f, 0.04715308f, 0.06754237f, 
    0.21394478f, -0.05133137f, 0.03095552f, 0.21136659f, 0.08431619f, 0.00997898f, 0.03326374f, 0.02118252f, 
    -0.10718416f, 0.01036675f, 0.03982817f, -0.01309862f, 0.03583870f, 0.13629477f, 0.07773917f, 0.18299513f, 
    0.04893035f, -0.03596035f, 0.00463516f, -0.12568372f, 0.02655597f, 0.04729470f, 0.05809410f, -0.06329572f, 
    -0.19871575f, 0.09459495f, -0.03065940f, -0.03391344f, 0.09705581f, -0.26098394f, 0.03695188f, -0.00138327f, 
    0.14890014f, 0.00581634f, 0.07970099f, 0.04700394f, -0.18666121f, -0.37778744f, -0.18986659f, -0.29421818f, 
    -0.13893294f, 0.00229204f, 0.05654281f, 0.11651041f, 0.15795305f, 0.00441396f, 0.20711647f, 0.23920849f, 
    -0.04178742f, -0.03929003f, -0.00280080f, -0.03634514f, 0.04067495f, 0.11874975f, -0.08656010f, -0.15126520f, 
    -0.02786176f, -0.13828503f, -0.13644612f, -0.12184078f, -0.09781113f, -0.08630826f, -0.11362688f, -0.24405582f, 
    0.01108334f, 0.16499643f, 0.19641718f, 0.04005683f, 0.07042249f, 0.12245773f, -0.08954031f, 0.22661939f, 
    0.46345204f, -0.04720749f, 0.13302280f, 0.10231489f, 0.04657489f, 0.10101397f, 0.08426490f, -0.06888327f, 
    -0.07701054f, -0.03964633f, -0.00125944f, 0.00707722f, -0.12719588f, -0.16139449f, -0.16468641f, -0.10157568f, 
    -0.09611236f, -0.15721324f, -0.01333372f, 0.03209173f, 0.05295593f, 0.12392209f, 0.01702248f, -0.06281919f, 
    -0.09614683f, 0.34184530f, -0.01627492f, 0.14614268f, 0.01651579f, -0.05265982f, -0.11497637f, 0.03089650f, 
    -0.07610017f, -0.06728677f, -0.12482373f, 0.04170178f, -0.03110770f, -0.17309144f, 0.19351991f, 0.10962746f, 
    0.08285298f, 0.01335364f, 0.10733358f, 0.03888755f, 0.00240973f, -0.04813354f, 0.05336416f, -0.05905003f, 
    -0.08563417f, -0.14832492f, -0.02110592f, -0.13792224f, -0.00586390f, 0.00019800f, 0.09739702f, 0.08380768f, 
    0.02151378f, -0.10250020f, -0.08249211f, -0.06192356f, 0.08059890f, 0.13991745f, -0.04520548f, -0.09733465f, 
    0.08455347f, 0.18194346f, -0.08711826f, -0.00551826f, 0.02786088f, -0.12118936f, -0.06913603f, -0.07844312f, 
    0.05120277f, 0.20221895f, 0.18772633f, 0.07930349f, 0.00357313f, 0.02240470f, 0.08116899f, 0.15425649f, 
    -0.00435474f, -0.00829387f, 0.07006248f, -0.00819593f, 0.09935508f, -0.08018006f, 0.18301609f, -0.22547106f, 
    0.10007060f, -0.09917300f, -0.08466998f, -0.03562861f, 0.04005594f, -0.06414678f, 0.02284175f, 0.01109988f, 
    -0.29619664f, -0.24999824f, -0.15178184f, -0.00854398f, -0.05501609f, -0.14909878f, -0.02406312f, -0.03169507f, 
    -0.00601917f, -0.02375938f, 0.00292071f, 0.13258637f, 0.20632693f, -0.06089278f, -0.07576755f, 0.10027328f, 
    0.08946869f, 0.16359700f, 0.13266200f, 0.13544597f, -0.08551639f, 0.01913097f, 0.02414119f, -0.08550248f, 
    -0.19122304f, -0.17323217f, -0.05095605f, -0.21502864f, -0.06185751f, 0.02816160f, 0.01297714f, 0.06616495f, 
    0.02045975f, 0.07660484f, 0.01327601f, 0.00418277f, -0.30012459f, -0.01276374f, 0.16598541f, 0.28533798f, 
    0.12873664f, -0.05634458f, -0.10234515f, -0.03986141f, -0.01288630f, -0.03496551f, -0.04805775f, 0.01444660f, 
    0.13408355f, 0.47650743f, 0.20224877f, -0.12821552f, 0.07505772f, 0.10854520f, 0.03919400f, -0.01316587f, 
    0.03422477f, 0.00070297f, -0.06872985f, 0.02636416f, 0.12678397f, 0.07238729f, 0.12557267f, -0.07890490f, 
    -0.02315904f, -0.00643913f, 0.14002469f, 0.04148538f, -0.07460397f, -0.01098232f, 0.15733276f, 0.09765060f, 
    -0.07414085f, 0.14010790f, -0.02756623f, 0.06827021f, 0.13293079f, 0.11098559f, 0.11752301f, 0.07357400f, 
    0.05349325f, -0.18861318f, -0.15514231f, -0.12442636f, -0.16045846f, -0.02921810f, -0.29092899f, -0.27644125f, 
    -0.14772139f, 0.07286052f, -0.24100089f, 0.07280087f, -0.09011644f, 0.00368671f, -0.13413033f, -0.12376286f, 
    0.01755619f, -0.17426901f, -0.31787202f, 0.15387563f, -0.07963552f, -0.05476163f, 0.11679883f, -0.05061900f, 
    -0.01194983f, -0.01212220f, -0.12217212f, 0.02141384f, 0.03562070f, -0.08202454f, 0.25137845f, 0.09739659f, 
    -0.01670195f, -0.02173979f, -0.18828642f, -0.04721521f, -0.08725423f, -0.11666979f, 0.01106409f, -0.09447939f, 
    -0.08389708f, -0.01889508f, 0.00222221f, 0.05659080f, -0.01518545f, -0.06922731f, -0.04846748f, -0.04430543f, 
    0.00346771f, -0.10422560f, -0.00931738f, -0.06923819f, -0.07606097f, -0.01463563f, -0.07138871f, 0.04965457f, 
    0.03693195f, 0.03913438f, -0.12301368f, -0.05263613f, -0.03060041f, -0.05276414f, -0.00526601f, -0.00884939f, 
    0.04421679f, 0.05393667f, 0.04754317f, -0.00253555f, 0.00866582f, -0.05255213f, -0.07459660f, -0.00257767f, 
    -0.06729107f, -0.01135983f, 0.01318734f, 0.00126206f, 0.01526518f, -0.05242914f, -0.04766468f, -0.07543753f, 
    0.01964709f, -0.07725184f, -0.07153723f, -0.09553887f, 0.04837270f, 0.05338697f, 0.00442857f, -0.00153305f, 
    0.04912871f, -0.01549641f, 0.02321904f, -0.04233735f, -0.01087483f, 0.02231365f, 0.03267638f, 0.02396276f, 
    -0.06756182f, 0.05159264f, 0.01510559f, -0.00851722f, 0.02786033f, 0.02771469f, -0.00876532f, 0.03828062f, 
    0.01986614f, -0.03878230f, 0.03522734f, 0.02547207f, -0.03185041f, 0.00823712f, -0.09668458f, -0.03180474f, 
    -0.05417840f, -0.00691672f, 0.04233298f, 0.03653766f, -0.00176362f, -0.03756370f, -0.05781846f, 0.00107874f, 
    -0.01585348f, -0.04042305f, -0.06915800f, 0.01778143f, 0.02679601f, -0.10195024f, 0.00888656f, -0.04460282f, 
    -0.00244006f, -0.00400479f, 0.00713187f, -0.10385188f, -0.06242965f, 0.04020837f, 0.05578751f, 0.00834603f, 
    -0.01333445f, -0.02941047f, -0.00790683f, -0.01188606f, -0.06740101f, -0.04540434f, 0.04187024f, -0.00145843f, 
    -0.03642146f, 0.04835290f, -0.06041982f, -0.06942357f, 0.03706630f, 0.05011940f, 0.03234926f, 0.00073701f, 
    0.01890776f, -0.01267502f, -0.01099221f, 0.08513586f, 0.01097746f, 0.06481296f, -0.08285801f, -0.00527955f, 
    -0.04548945f, 0.03573182f, -0.03401258f, -0.02287800f, -0.01105605f, -0.00011472f, -0.01384067f, -0.02765125f, 
    0.04787845f, -0.00164134f, -0.06833854f, -0.02319445f, 0.01789716f, 0.01742133f, 0.03874841f, -0.07022934f, 
    0.07164267f, 0.00784546f, 0.05823109f, 0.03418599f, -0.06914604f, 0.04095070f, -0.04535315f, 0.00720509f, 
    0.01089892f, -0.03938299f, 0.05092617f, 0.02731342f, -0.03532062f, -0.03871793f, -0.02665758f, -0.03134935f, 
    0.04860571f, -0.06076493f, 0.03689027f, 0.02787265f, 0.02580274f, -0.01724510f, -0.01739217f, -0.06570861f, 
    0.05953078f, -0.01024523f, -0.00122558f, -0.01952640f, 0.04662042f, 0.03000095f, 0.02684388f, -0.06166532f, 
    0.05210992f, -0.07836433f, -0.06330340f, 0.05678103f, -0.05497808f, -0.05801418f, 0.05828562f, -0.07585973f, 
    -0.05794691f, 0.00068498f, -0.03859457f, -0.01157361f, 0.04434806f, -0.04062153f, 0.02656287f, 0.02212506f, 
    -0.06395730f, -0.05799730f, -0.00094021f, -0.08755359f, 0.00377822f, 0.02585860f, -0.03294933f, -0.07719158f, 
    -0.11066230f, -0.20110250f, 0.16433130f, 0.24484795f, -0.05898902f, -0.01880822f, 0.04520974f, 0.13499025f, 
    0.05709761f, -0.19986635f, -0.01317965f, -0.05511243f, -0.16593941f, 0.07180870f, -0.08173319f, 0.08035237f, 
    0.14649175f, 0.05400864f, 0.08374274f, -0.00648507f, -0.00647397f, -0.00147477f, -0.04270267f, 0.06045371f, 
    0.05278926f, 0.14745587f, 0.01243020f, 0.11028838f, 0.05992382f, 0.04068726f, 0.15725677f, -0.03536229f, 
    0.11176923f, 0.00014348f, 0.10903009f, 0.05379014f, -0.01766707f, -0.18041067f, 0.11084081f, -0.02920059f, 
    -0.07932030f, 0.07566970f, -0.08272032f, 0.14850311f, -0.04263049f, -0.03544213f, -0.06659637f, 0.03443821f, 
    -0.11759332f, -0.02007249f, 0.05017881f, 0.00372971f, -0.15745278f, -0.04579804f, 0.04945602f, -0.03405999f, 
    -0.19007936f, -0.01580613f, -0.02558207f, -0.04609475f, 0.04909810f, -0.09042504f, -0.02336695f, -0.05001644f, 
    -0.04012608f, -0.11550391f, 0.02705992f, -0.07349665f, 0.07256629f, 0.08351083f, 0.07265010f, -0.09689318f, 
    -0.13265623f, -0.06235583f, 0.03885209f, -0.09639096f, 0.00370169f, -0.09860630f, 0.10572872f, 0.02023409f, 
    0.08315157f, -0.13328297f, 0.01423110f, 0.00047749f, -0.06519443f, 0.23438573f, 0.09075630f, -0.17018373f, 
    0.03124359f, 0.00048255f, -0.02789011f, -0.14661857f, -0.16367257f, -0.10925218f, -0.02182723f, -0.01809457f, 
    -0.06875866f, 0.21025699f, 0.01666860f, 0.03556440f, -0.11235924f, 0.04782223f, -0.04284729f, 0.04788188f, 
    0.01558036f, -0.03158509f, 0.08002958f, 0.06755021f, -0.05727795f, -0.16460904f, 0.06001654f, 0.26929930f, 
    -0.05824637f, -0.00127549f, 0.05146253f, -0.01446926f, 0.18508431f, 0.08043084f, 0.19202001f, 0.13849410f, 
    -0.19472337f, 0.19516625f, -0.09376175f, 0.05461175f, -0.18485554f, -0.04624360f, 0.17369148f, -0.06898588f, 
    0.02745391f, -0.02008416f, -0.01742239f, -0.00968856f, 0.09725671f, 0.28061137f, 0.08930232f, -0.12261747f, 
    0.07240762f, -0.12481002f, -0.20967172f, -0.03583780f, 0.08039436f, -0.11933246f, -0.04917184f, -0.06150456f, 
    -0.02581480f, 0.15858461f, -0.07855024f, 0.23253334f, 0.08599548f, 0.01945137f, 0.12371486f, 0.18116339f, 
    -0.05991039f, 0.07632868f, 0.04649958f, 0.04009230f, 0.05347801f, -0.03317416f, 0.29375330f, 0.08607323f, 
    0.01538661f, -0.02560019f, -0.11791144f, 0.03437684f, 0.07054906f, 0.13830073f, 0.13125302f, 0.02455357f, 
    0.25311604f, 0.01649111f, 0.19328937f, 0.20815811f, -0.09024998f, -0.06586939f, 0.05642341f, 0.13016263f, 
    -0.03078049f, -0.10753004f, 0.01025884f, 0.04073120f, 0.20151721f, 0.05147987f, 0.01114734f, -0.04319238f, 
    -0.04562761f, 0.03220068f, -0.18658213f, 0.09919645f, 0.11245325f, -0.07173005f, -0.05706709f, 0.00366667f, 
    0.00090889f, -0.02065586f, 0.03787453f, 0.05527530f, 0.04828236f, 0.00174205f, 0.00362591f, -0.03802501f, 
    -0.03428316f, -0.05994634f, -0.02277828f, 0.03094674f, -0.00819962f, 0.03283190f, 0.00730426f, -0.02343892f, 
    -0.03741493f, 0.00973722f, -0.02393656f, 0.06009177f, 0.03534184f, -0.03647562f, -0.05967428f, -0.05703174f, 
    -0.00498729f, 0.06188609f, -0.07036974f, 0.03487796f, 0.04529817f, 0.04678505f, -0.03106214f, -0.00377646f, 
    -0.04935094f, -0.03486165f, -0.03521991f, -0.03028237f, -0.02086306f, -0.07927349f, 0.00398195f, -0.03579820f, 
    0.03106700f, 0.04292187f, -0.01796154f, 0.02292472f, -0.00282421f, 0.04574139f, -0.07282314f, -0.07522698f, 
    -0.07229868f, -0.06407110f, 0.03937211f, 0.04944722f, 0.03446412f, -0.04972405f, -0.07499150f, -0.06851648f, 
    0.01118698f, -0.06347667f, -0.02065085f, -0.03048376f, -0.03206354f, -0.06143415f, -0.00257671f, 0.04116343f, 
    -0.03508449f, -0.03101583f, 0.01725593f, -0.07016519f, 0.06016538f, 0.01088949f, -0.08043437f, -0.07683872f, 
    0.05864368f, 0.06199412f, -0.05474819f, -0.07850832f, -0.01380493f, 0.04161569f, 0.01105143f, 0.03751863f, 
    -0.03623462f, -0.00050613f, -0.07079686f, 0.02685514f, 0.01105220f, 0.04911127f, 0.03922816f, 0.06324565f, 
    -0.03661868f, -0.01327021f, -0.04402656f, -0.03850705f, 0.00736432f, -0.00881663f, 0.01308348f, -0.00301775f, 
    -0.06520832f, 0.03406139f, 0.01820716f, -0.06265055f, -0.01499708f, -0.04888328f, -0.07348503f, -0.00028791f, 
    -0.02396023f, 0.04705048f, -0.05014085f, -0.07365028f, -0.07394478f, -0.01073977f, 0.03656262f, 0.01317441f, 
    -0.05814241f, 0.01078028f, -0.03605495f, -0.06925137f, -0.04009582f, -0.02407531f, 0.05654533f, 0.03569014f, 
    -0.03880450f, 0.06150549f, 0.04919251f, -0.01836523f, 0.05039866f, 0.00844180f, 0.01564492f, 0.01964603f, 
    -0.02441069f, 0.05878788f, 0.03140056f, 0.05614949f, -0.04713654f, -0.05410621f, -0.03880907f, 0.05853200f, 
    0.00253382f, -0.04967332f, 0.05062576f, 0.05304979f, 0.00862666f, -0.00478973f, -0.05874804f, -0.01665812f, 
    0.06129227f, 0.01178296f, 0.00575198f, 0.02986682f, -0.01310513f, 0.02675410f, -0.07678410f, -0.06774683f, 
    -0.04705234f, 0.01174679f, 0.03543167f, -0.02873774f, 0.01816946f, 0.04649933f, -0.02427915f, -0.00862907f, 
    -0.04424769f, 0.01478024f, 0.05319801f, -0.00121867f, -0.02438486f, -0.01002106f, -0.01502074f, -0.06767366f, 
    -0.01118580f, -0.05967623f, 0.00941424f, -0.05342280f, -0.00472295f, -0.04277996f, -0.07571932f, 0.00694378f, 
    -0.01844406f, -0.01297658f, -0.04287392f, 0.03364598f, 0.04820552f, -0.02079680f, 0.05525587f, -0.01791808f, 
    -0.02712962f, -0.05779726f, 0.03433393f, -0.06299105f, -0.01107445f, -0.03444421f, 0.03227079f, -0.05375513f, 
    0.15330946f, -0.07121693f, -0.08509977f, -0.16739768f, 0.13984282f, 0.15762383f, 0.18040730f, -0.14385101f, 
    -0.01230663f, -0.03035041f, -0.08296278f, 0.01660081f, 0.16560759f, 0.31582257f, 0.22817835f, -0.12919742f, 
    0.18049105f, 0.02154835f, 0.08048607f, 0.02643759f, 0.00770848f, -0.02798195f, -0.01882929f, 0.03996620f, 
    0.11862070f, 0.06098368f, -0.01428378f, -0.12380692f, 0.02605611f, -0.04173181f, -0.01044716f, 0.01829834f, 
    0.09307674f, 0.13192075f, 0.09283068f, 0.03072133f, -0.21847259f, -0.05740149f, -0.34206784f, 0.19644202f, 
    -0.12161967f, 0.02347219f, 0.11465330f, -0.04569566f, -0.02374493f, 0.08219942f, -0.09765287f, 0.13576375f, 
    0.37336859f, 0.25331414f, -0.08013228f, -0.23469558f, 0.13176496f, 0.19132502f, 0.13607927f, 0.14082539f, 
    -0.01224316f, 0.00821418f, -0.04269841f, -0.06677271f, 0.23938321f, -0.17094359f, -0.16117027f, 0.13339745f, 
    0.14575253f, 0.15410307f, -0.00818851f, 0.15095347f, 0.00582623f, -0.06952278f, -0.00505530f, -0.02726449f, 
    -0.12514558f, -0.26151600f, 0.23416544f, -0.02803330f, 0.04250461f, 0.09658288f, -0.03391144f, 0.00828843f, 
    0.01108648f, -0.07659271f, -0.00623359f, -0.06019979f, -0.19040182f, 0.08836579f, 0.36950076f, 0.03578609f, 
    0.00191351f, -0.14267720f, -0.11373813f, -0.01825224f, -0.07136124f, -0.02723863f, 0.01159956f, 0.00788073f, 
    -0.20077360f, 0.35711262f, -0.01691865f, -0.10411432f, -0.04319830f, -0.14306839f, 0.01222298f, -0.07595403f, 
    0.01439274f, -0.02217888f, 0.02858384f, -0.05915073f, 0.18806750f, -0.00158128f, -0.38971832f, -0.24453217f, 
    -0.03679372f, 0.03116480f, 0.14903381f, -0.02911628f, 0.11032346f, -0.03250525f, 0.18154302f, 0.07741012f, 
    0.30938539f, 0.01156974f, 0.06670509f, -0.23618400f, 0.22300424f, 0.14927723f, 0.16344941f, 0.08724516f, 
    0.10433841f, -0.04422708f, -0.04153678f, -0.00553485f, 0.13678817f, 0.02041984f, 0.01267617f, 0.10077432f, 
    0.17408499f, 0.02629051f, 0.04819250f, 0.04712258f, -0.05226971f, -0.11812636f, -0.05158905f, 0.01574611f, 
    -0.07307913f, 0.14656638f, 0.09721895f, 0.04942388f, 0.06701607f, -0.04570220f, -0.00024120f, -0.04014030f, 
    -0.00089402f, 0.04220842f, 0.20593639f, 0.00973373f, 0.18148577f, 0.06568009f, 0.13705796f, 0.27865446f, 
    -0.04697631f, 0.03103740f, 0.03972445f, 0.09071635f, 0.02630582f, -0.07669602f, -0.09019164f, 0.14033358f, 
    -0.15786038f, 0.13700588f, 0.32198265f, 0.28493139f, -0.05093703f, -0.10700119f, -0.13615130f, -0.04834632f, 
    -0.15303214f, -0.04449725f, -0.00129306f, 0.07691133f, -0.02815488f, -0.18800624f, -0.30864504f, 0.11435235f, 
    0.12748370f, 0.07888246f, 0.17198759f, -0.00147553f, 0.14728953f, -0.02722121f, 0.15828554f, -0.07339250f, 
    -0.18401743f, 0.09424678f, 0.11948594f, 0.07791270f, -0.20212065f, 0.01325687f, -0.05320751f, 0.15623327f, 
    -0.02466624f, 0.06639675f, 0.02219699f, 0.03996664f, -0.20842576f, -0.18693998f, -0.17371996f, 0.04777030f, 
    -0.19332527f, 0.10241189f, -0.05349445f, 0.00017911f, -0.01078834f, -0.10666392f, 0.10423340f, 0.00108324f, 
    -0.00310687f, -0.00352149f, -0.00471991f, 0.09138267f, -0.07329204f, 0.02081789f, 0.03302576f, 0.05420085f, 
    -0.08373487f, -0.02185737f, -0.04635018f, -0.09566116f, 0.08464574f, -0.12140413f, 0.34141189f, -0.06266454f, 
    0.12146715f, -0.08593050f, -0.07195290f, 0.07727468f, 0.00127072f, 0.06496515f, 0.00905988f, -0.10551236f, 
    -0.31319773f, -0.14731617f, 0.12576120f, 0.14638564f, -0.05286562f, -0.16088927f, 0.01969031f, -0.03229394f, 
    -0.04133974f, 0.03280184f, 0.03467605f, -0.00217333f, -0.09188291f, 0.30151919f, 0.27239603f, 0.19726479f, 
    -0.01391455f, -0.08444993f, 0.04033801f, 0.01980530f, 0.00365939f, 0.10164639f, 0.04608829f, 0.05706205f, 
    0.03639368f, 0.18549773f, -0.08152759f, -0.06330363f, -0.12577659f, -0.11547807f, 0.02445078f, -0.10728860f, 
    0.02849951f, -0.01607827f, 0.11009987f, 0.12437157f, 0.08100150f, -0.07387530f, -0.27064002f, 0.00069867f, 
    0.11795144f, 0.20075396f, 0.20911446f, -0.08988068f, 0.02535916f, 0.02785844f, -0.02815562f, -0.06279940f, 
    0.06210839f, -0.08390899f, -0.01695715f, 0.10035476f, 0.04746106f, 0.03481363f, 0.02488199f, 0.02186411f, 
    -0.03110859f, -0.02456355f, -0.05606733f, 0.00040869f, -0.05979048f, -0.10409379f, 0.33218729f, -0.01159407f, 
    -0.04999026f, 0.07181806f, -0.05665619f, 0.07412742f, 0.04488068f, 0.06748891f, -0.04942478f, 0.15299922f, 
    -0.09293934f, 0.08420291f, -0.05079016f, 0.08771653f, -0.08669286f, -0.03798312f, -0.11184784f, -0.08400363f, 
    -0.00324551f, 0.04395955f, 0.07213646f, 0.12979874f, -0.09082535f, 0.05319520f, 0.00057884f, 0.00878662f, 
    -0.03588374f, 0.02955354f, 0.03147667f, 0.06579892f, 0.05212424f, 0.04335773f, -0.02284317f, -0.03632309f, 
    0.17311446f, -0.03049769f, -0.13176434f, 0.14773682f, 0.15136309f, 0.02852406f, 0.02899973f, 0.07827039f, 
    -0.09336410f, 0.02941610f, -0.19717018f, -0.05237588f, -0.09615640f, 0.02135613f, 0.05029066f, -0.00480437f, 
    0.06037012f, -0.03086153f, 0.00715490f, 0.05357611f, 0.04904161f, 0.10815365f, 0.09202907f, -0.17287774f, 
    0.34549883f, -0.04244183f, -0.00213473f, -0.02299826f, 0.05470409f, -0.05492251f, 0.05603426f, -0.05093045f, 
    0.03588532f, -0.05364433f, -0.10368085f, -0.00687754f, 0.22158740f, 0.33217323f, 0.20812431f, 0.12693889f, 
    -0.17405415f, 0.01237995f, -0.08158995f, 0.00198427f, 0.02233757f, 0.10869987f, -0.03269076f, 0.04490585f, 
    0.04047684f, -0.08478297f, -0.07957229f, 0.05713546f, 0.07983924f, 0.02688118f, 0.10210587f, 0.05382598f, 
    0.16336480f, -0.00733026f, -0.01536169f, -0.14537190f, 0.05159802f, 0.05058373f, 0.17247212f, 0.09334572f, 
    0.14085366f, 0.01581193f, 0.06890187f, 0.15183392f, 0.09606726f, 0.07967546f, 0.00902816f, -0.03866662f, 
    -0.08179797f, -0.07023711f, -0.08579033f, 0.06133944f, 0.18425627f, 0.06652590f, -0.00467632f, -0.03069378f, 
    -0.01915609f, 0.01436581f, -0.01069368f, 0.12675527f, -0.08283751f, 0.05721885f, -0.06492692f, -0.07996278f, 
    0.02513215f, 0.04050850f, -0.05112889f, -0.08263338f, 0.00666931f, 0.04148982f, -0.04048402f, 0.05448635f, 
    -0.00489351f, 0.05645778f, -0.11732573f, -0.19869766f, 0.07307758f, 0.15741585f, 0.00947436f, 0.25356704f, 
    0.04078393f, -0.06752338f, 0.03549996f, -0.01721618f, 0.00264924f, 0.04340016f, -0.03934368f, -0.15025623f, 
    -0.12912810f, 0.01757176f, 0.06361414f, 0.06480885f, -0.00900668f, 0.02572367f, -0.00049134f, -0.10700832f, 
    -0.19858648f, 0.11312320f, -0.18797143f, 0.20464346f, 0.01644181f, 0.08118357f, -0.06123444f, 0.02563706f, 
    0.05049340f, 0.07575461f, 0.08966517f, 0.03067094f, -0.20255861f, 0.03203612f, -0.04325743f, -0.17926563f, 
    0.02241731f, 0.11353944f, -0.06941930f, 0.06039429f, -0.04178415f, -0.12449633f, 0.07744497f, -0.07279288f, 
    0.16418773f, -0.40448326f, 0.21333760f, -0.11424366f, 0.05969095f, -0.11170044f, -0.04205961f, 0.02304338f, 
    -0.01989059f, -0.03412445f, -0.07014213f, -0.03130651f, 0.15306011f, -0.03743390f, -0.13710131f, 0.25343803f, 
    -0.01774581f, -0.00902695f, -0.00445098f, 0.09333543f, 0.11466914f, 0.06277969f, 0.13338721f, -0.07976515f, 
    -0.00436532f, -0.17758955f, 0.03782481f, -0.06900346f, 0.08310837f, -0.00133593f, -0.05825673f, 0.04290118f, 
    0.06310456f, -0.04831372f, -0.04355500f, -0.07346870f, 0.09679191f, -0.04939401f, 0.03692491f, -0.24637026f, 
    -0.06638619f, 0.10026700f, 0.17746234f, 0.10641026f, -0.16914219f, -0.13342896f, -0.04024541f, 0.07072696f, 
    -0.02890158f, -0.16024263f, 0.23746461f, -0.14025293f, 0.09443234f, 0.09281593f, 0.01190430f, 0.21300101f, 
    0.08219831f, -0.12188932f, 0.10823425f, -0.03400801f, 0.04443575f, -0.10424834f, -0.06451083f, -0.04812479f, 
    -0.05574059f, -0.00927848f, -0.01221312f, -0.08576940f, 0.09019760f, -0.03624374f, -0.07526917f, 0.09602332f, 
    -0.29527491f, 0.06559243f, -0.20198143f, -0.07529682f, 0.12670018f, 0.03709447f, -0.02849455f, -0.05790826f, 
    -0.02962943f, -0.02842221f, -0.11476740f, 0.06106233f, 0.08273498f, -0.11035883f, 0.24113658f, -0.14347319f, 
    -0.05156600f, -0.01042110f, 0.08304753f, -0.07025967f, -0.00790666f, 0.14051640f, 0.16875404f, 0.10695044f, 
    -0.10818209f, -0.05729175f, -0.06121590f, -0.11282703f, 0.06131247f, 0.06053763f, 0.09033828f, 0.05907939f, 
    -0.04324004f, 0.07636688f, 0.18143411f, 0.05070289f, 0.11808810f, 0.13970374f, 0.07277589f, -0.03792590f, 
    0.17793976f, 0.08799870f, 0.11831427f, 0.16746600f, -0.00352809f, 0.16410188f, -0.04113605f, 0.05110890f, 
    -0.03117440f, -0.04039757f, -0.06639829f, -0.01007139f, 0.01017583f, -0.03447699f, -0.11432266f, -0.05113033f, 
    0.12822644f, 0.04572180f, 0.14126185f, 0.11608249f, -0.23430134f, 0.03970854f, -0.15196006f, 0.02660169f, 
    -0.24080737f, 0.10852105f, 0.05313557f, -0.01206938f, 0.14092739f, 0.19249751f, -0.02559760f, 0.20292617f, 
    -0.11684537f, -0.28435346f, -0.15474454f, -0.09442934f, 0.05998154f, 0.01461191f, 0.12597145f, 0.10519831f, 
    -0.05311597f, -0.00677642f, -0.10910995f, -0.05275829f, -0.06098238f, -0.14425696f, -0.15401396f, 0.14609066f, 
    -0.01895596f, 0.04795312f, 0.14209810f, 0.14764139f, -0.08580792f, 0.05457639f, -0.08142298f, -0.05611365f, 
    0.29477394f, -0.01357272f, 0.00706419f, 0.00386503f, 0.12899195f, 0.01519028f, -0.07516024f, 0.10371555f, 
    -0.01222023f, 0.11607233f, 0.11630648f, -0.05210881f, -0.11530071f, 0.01211162f, 0.34858292f, 0.00176828f, 
    0.01185562f, -0.11278003f, 0.05980237f, 0.04140992f, -0.06409749f, -0.10979061f, 0.09568888f, -0.02807275f, 
    -0.09065541f, 0.28733584f, -0.08519275f, -0.06966821f, -0.01903974f, -0.03759577f, 0.01911186f, -0.03342406f, 
    -0.00758153f, 0.05991417f, -0.10967373f, -0.14226559f, -0.16210738f, 0.09512158f, -0.36188394f, -0.12796703f, 
    -0.03559230f, -0.06240968f, -0.08398843f, -0.01781568f, -0.02351722f, -0.03006894f, 0.19296783f, 0.01534391f, 
    -0.08563038f, -0.31732681f, -0.02245868f, -0.09968676f, 0.20905569f, -0.02303787f, 0.03107888f, 0.09925845f, 
    0.11861666f, 0.00412563f, -0.03954696f, 0.06968945f, -0.03794516f, -0.04951524f, 0.06001063f, 0.17813425f, 
    0.03132489f, 0.03676820f, 0.13870376f, -0.06349853f, -0.10595423f, -0.01932676f, -0.04898232f, 0.03396657f, 
    -0.14222986f, -0.15601388f, 0.17256761f, -0.14625643f, -0.05666162f, 0.12282369f, 0.05667025f, -0.05316930f, 
    0.05510199f, -0.08872952f, 0.24488570f, 0.06303537f, 0.01035551f, 0.19196698f, 0.10651539f, 0.19743066f, 
    0.07166998f, 0.05592933f, 0.11238214f, -0.02028220f, 0.09084664f, -0.02591460f, 0.01843653f, 0.14370063f, 
    -0.15715167f, 0.17576288f, 0.22924179f, -0.08715052f, -0.08205677f, -0.18521859f, -0.20852986f, -0.06821909f, 
    -0.13500330f, -0.04731544f, -0.06047438f, 0.03924969f, -0.12266554f, 0.00243848f, 0.05651236f, 0.13241674f, 
    0.02968841f, 0.01015415f, 0.12797482f, 0.10913055f, 0.08594386f, 0.05414018f, 0.24536106f, 0.09711497f, 
    0.10904634f, 0.05382048f, -0.33205181f, -0.09038962f, 0.11507773f, -0.05796098f, -0.06967563f, 0.09585326f, 
    0.01123286f, 0.02047522f, 0.14872535f, 0.15806203f, 0.12100426f, 0.06155849f, -0.12231547f, -0.22532547f, 
    0.21239668f, 0.06777023f, -0.06743598f, 0.04970396f, -0.00968656f, -0.01187101f, -0.01688489f, 0.13225724f, 
    0.05048267f, 0.02360206f, -0.03663168f, -0.20169513f, 0.14934236f, -0.01074205f, 0.01142092f, -0.06460039f, 
    -0.01913847f, -0.03518602f, -0.08097266f, -0.05834788f, 0.00027277f, 0.06783094f, -0.03156251f, 0.02579790f, 
    -0.10622746f, 0.10907325f, 0.16779569f, 0.05820157f, -0.07187736f, 0.05137198f, -0.00329697f, 0.02158641f, 
    -0.11934120f, -0.22074279f, -0.21100387f, -0.40465325f, -0.09577823f, -0.11300676f, -0.03052255f, -0.20473209f, 
    0.03755003f, -0.08458262f, -0.08387432f, -0.10372636f, 0.15345336f, -0.09328562f, -0.01352587f, -0.41435769f, 
    -0.12487266f, -0.14496803f, -0.10887603f, 0.20567332f, 0.01340947f, 0.01151357f, 0.10115482f, 0.02269338f, 
    0.02607375f, 0.17218249f, 0.08970534f, 0.00215348f, 0.04235682f, 0.04139862f, 0.02914199f, -0.09587943f, 
    0.03527902f, 0.10687567f, -0.04832019f, 0.16523580f, 0.11029016f, 0.10651612f, -0.19921522f, 0.01887659f, 
    0.02157997f, 0.08760733f, 0.15247346f, 0.38055870f, -0.04727711f, 0.00083678f, -0.01248564f, 0.03630131f, 
    0.04545057f, -0.06763646f, -0.03750368f, -0.07078208f, -0.06423726f, 0.04572639f, -0.05614238f, -0.06902671f, 
    0.02960022f, -0.03646823f, 0.01487797f, -0.00694066f, 0.01561364f, 0.24874477f, -0.15722848f, -0.06101495f, 
    0.01299848f, 0.02752315f, -0.11484338f, -0.17876373f, -0.09901571f, 0.07768715f, -0.09485001f, -0.16436923f, 
    -0.15207067f, -0.33154762f, -0.25515878f, -0.16210222f, 0.03114120f, -0.03879534f, 0.05884422f, -0.02623064f, 
    0.01961083f, 0.07980896f, -0.01252490f, -0.02602389f, -0.05989942f, -0.16582751f, -0.06177912f, 0.01219435f, 
    -0.03089132f, 0.01540307f, 0.16948681f, 0.19175051f, 0.06623095f, -0.00586032f, 0.14724801f, 0.13256413f, 
    -0.02537184f, -0.03877578f, 0.19087836f, -0.08396467f, -0.06964751f, 0.14180790f, -0.09491192f, 0.03928718f, 
    -0.05801028f, 0.02763927f, -0.03333673f, -0.09401276f, 0.08598986f, -0.02235087f, 0.11278979f, -0.00740033f, 
    0.09883731f, 0.05806503f, 0.11713008f, 0.17928851f, -0.09921803f, 0.00654134f, -0.04062279f, 0.13626219f, 
    -0.19221272f, 0.02458969f, -0.05366239f, 0.01629420f, -0.10162386f, 0.09687311f, 0.11352975f, -0.10667359f, 
    -0.00487481f, 0.05113159f, -0.01409463f, -0.11916280f, 0.05812622f, -0.13598448f, 0.04145790f, -0.11857104f, 
    0.02813816f, -0.23730123f, 0.05828925f, 0.09049834f, 0.03790421f, 0.15930696f, 0.01971029f, 0.04466795f, 
    -0.16298287f, -0.11181203f, 0.04689836f, -0.04947776f, -0.19280425f, -0.03224646f, -0.09824581f, 0.20951678f, 
    0.10924336f, -0.05432809f, 0.02648764f, 0.04219183f, 0.03758755f, -0.09095889f, 0.02400050f, 0.26211980f, 
    0.01626822f, 0.09345467f, 0.07408202f, 0.06216829f, -0.00946090f, -0.06296254f, 0.16368459f, 0.14673142f, 
    0.01128527f, -0.13538371f, 0.05026606f, 0.03627158f, 0.14406914f, 0.07692903f, 0.14950143f, 0.17745931f, 
    -0.00549136f, -0.00611339f, 0.05596465f, 0.05942558f, -0.06971315f, -0.07376105f, 0.17336805f, 0.07616333f, 
    -0.08580023f, 0.13047947f, -0.07652657f, -0.19081134f, -0.01756761f, -0.08451855f, 0.04767459f, 0.05780199f, 
    -0.28563717f, -0.17627020f, 0.03948739f, 0.26298904f, -0.03426261f, -0.23752616f, 0.13718058f, -0.12536901f, 
    -0.13247131f, -0.03427098f, -0.08198711f, -0.08644526f, -0.03777529f, 0.17843302f, 0.24109283f, 0.14686537f, 
    -0.11642160f, -0.16890430f, 0.08667147f, 0.04186285f, -0.01671275f, 0.02235199f, -0.10001141f, -0.04009759f, 
    -0.02917024f, -0.03922952f, -0.14278764f, -0.17099446f, -0.05018926f, -0.18430437f, 0.04280173f, -0.16761002f, 
    -0.01492561f, -0.01620758f, 0.22905797f, 0.03765929f, 0.19381653f, 0.04370351f, 0.10255878f, 0.29336894f, 
    0.27138245f, 0.10893769f, 0.22389312f, 0.03306304f, -0.14163660f, 0.02801140f, -0.06605432f, -0.07088333f, 
    -0.21723358f, 0.02886681f, -0.04827908f, 0.05012671f, 0.12696812f, 0.05877610f, 0.09585935f, 0.15652920f, 
    0.04925570f, 0.00973626f, -0.07797086f, 0.10408737f, -0.00356730f, -0.29113626f, -0.11693438f, -0.05594267f, 
    -0.02208487f, 0.07472261f, -0.01866864f, 0.02852731f, 0.20609725f, 0.15396945f, 0.06116214f, 0.22281094f, 
    -0.09011376f, -0.13841943f, 0.02955591f, 0.08255575f, -0.16261785f, 0.01580824f, -0.14618172f, -0.14121620f, 
    0.03400899f, -0.04888828f, -0.03663594f, 0.07157909f, -0.08652805f, -0.05868444f, -0.09706531f, 0.15337975f, 
    0.01337191f, -0.02807288f, 0.16173010f, 0.03715327f, -0.07377319f, 0.01608959f, 0.01792209f, -0.02815219f, 
    0.00658358f, 0.19508532f, 0.02557547f, 0.22847573f, 0.11405144f, 0.02819275f, 0.23042585f, 0.23954490f, 
    0.07995987f, 0.04989575f, -0.01277027f, 0.09410506f, -0.53459501f, 0.14120661f, 0.10624300f, -0.05053257f, 
    -0.02139477f, 0.09151171f, -0.27196813f, 0.09094136f, -0.10812379f, 0.07946528f, 0.16228391f, 0.00052924f, 
    0.13416718f, 0.04115202f, 0.02384816f, 0.10137977f, 0.03985724f, -0.10529597f, -0.06965937f, -0.04808368f, 
    0.06784226f, -0.13051453f, 0.01335457f, -0.03676229f, -0.01788242f, 0.07691257f, 0.22667034f, 0.31996876f, 
    -0.09877998f, 0.04725867f, -0.13714235f, 0.23193760f, 0.00781064f, -0.09998488f, 0.00831791f, -0.01680684f, 
    0.06133213f, 0.14464183f, 0.17931513f, 0.06396982f, -0.05084012f, 0.03418868f, 0.01752355f, -0.08395343f, 
    -0.13641480f, 0.11262016f, -0.03215422f, -0.00268486f, 0.04100857f, 0.07703242f, 0.01619428f, -0.02826791f, 
    -0.14780571f, -0.01693600f, -0.01135053f, 0.02780997f, 0.03290154f, -0.07909326f, -0.05119871f, -0.04488322f, 
    -0.06442834f, -0.05722287f, -0.10717075f, 0.10550858f, -0.04736311f, -0.04960912f, -0.08326143f, 0.10527761f, 
    -0.13692947f, -0.05697186f, -0.13074623f, -0.17957312f, 0.03718537f, 0.01528903f, -0.10892918f, -0.05922972f, 
    0.16612335f, -0.16452588f, 0.04460849f, -0.15006623f, -0.11782089f, -0.04715918f, -0.06819101f, -0.17936558f, 
    -0.04450831f, -0.10902245f, -0.02758221f, 0.07521159f, -0.00914640f, -0.03824323f, -0.03960768f, -0.04535649f, 
    0.04252409f, 0.05466100f, 0.02276007f, 0.00440845f, 0.01561870f, 0.26518467f, 0.04726833f, 0.39332992f, 
    -0.00162713f, -0.09541753f, 0.17630787f, 0.01150146f, 0.06754573f, 0.06064602f, 0.04445459f, 0.17569172f, 
    0.17509519f, -0.14324236f, -0.05852260f, -0.09489399f, -0.09997267f, 0.02802584f, -0.13631366f, 0.04934339f, 
    0.06644568f, 0.04711559f, 0.15897058f, 0.10378759f, -0.24130163f, -0.15093781f, 0.28217500f, 0.20554556f, 
    0.05828518f, 0.07215723f, -0.11985746f, -0.05819727f, -0.02634711f, -0.01149904f, -0.03566431f, 0.06458255f, 
    -0.06307349f, 0.08942373f, -0.07824510f, 0.18302888f, 0.00223912f, 0.03431702f, -0.00997997f, -0.02683113f, 
    0.01410122f, 0.18705606f, -0.07223762f, 0.04135064f, -0.11718929f, 0.18385044f, 0.10928241f, -0.05595733f, 
    -0.06123923f, 0.06114447f, 0.05727347f, -0.00532248f, -0.12360767f, 0.01898737f, -0.01207526f, 0.08668201f, 
    0.09654197f, -0.15075333f, -0.04684185f, -0.07170379f, 0.21068572f, 0.13132091f, -0.04343679f, 0.11980010f, 
    -0.02272141f, -0.06673525f, -0.10078770f, -0.00959391f, -0.12919390f, 0.06768748f, -0.06201155f, 0.14405292f, 
    0.08804890f, 0.07456698f, 0.11272587f, 0.01911886f, -0.02060405f, 0.07983243f, 0.21017471f, 0.24727669f, 
    -0.10858359f, 0.03054863f, 0.03808869f, -0.03884524f, 0.13373236f, -0.01196888f, -0.05320307f, 0.03134758f, 
    -0.06368218f, 0.06574295f, 0.01425874f, -0.05920519f, 0.00182713f, 0.07263961f, -0.07052339f, 0.01703999f, 
    -0.00783318f, -0.01547052f, -0.05196468f, -0.14400057f, -0.07822711f, -0.02933461f, 0.01053710f, -0.05689977f, 
    -0.09459350f, -0.06334096f, 0.01704449f, -0.16186778f, 0.07565955f, 0.01904888f, -0.05555328f, -0.04195644f, 
    0.06666721f, -0.09320276f, -0.04374389f, 0.02061980f, 0.01935114f, 0.38418192f, 0.08796088f, 0.30578107f, 
    0.00290861f, 0.09669064f, -0.01692346f, -0.10073908f, 0.05619762f, -0.01243356f, 0.01230852f, 0.04717389f, 
    0.18932043f, -0.14709766f, -0.02764264f, -0.10210025f, 0.02945275f, -0.07955696f, -0.02465404f, 0.05191996f, 
    0.11502461f, 0.02191294f, -0.07396669f, 0.12149175f, 0.17289935f, 0.00314512f, 0.23733638f, 0.08062660f, 
    0.07853705f, -0.09345824f, -0.06008420f, 0.00544670f, -0.02666182f, -0.06828206f, 0.08002044f, -0.13386577f, 
    -0.01144127f, 0.01087962f, -0.01081848f, -0.07836075f, 0.08057114f, 0.04968515f, 0.06889245f, 0.07311645f, 
    -0.06102589f, -0.08388246f, -0.04508128f, -0.02728040f, -0.00782259f, 0.00809186f, -0.04253856f, -0.06149991f, 
    0.01987417f, 0.14833561f, 0.00402813f, 0.01186134f, -0.13008170f, -0.10597029f, -0.01278823f, -0.00928365f, 
    0.19533028f, 0.27317631f, 0.02350199f, -0.13189602f, 0.08641957f, 0.15724950f, 0.03024977f, 0.10632610f, 
    0.12617709f, 0.05052841f, 0.01432249f, -0.03309524f, 0.08186866f, 0.10603072f, 0.01099934f, -0.33343872f, 
    -0.11948436f, 0.10280450f, -0.08678216f, 0.00218386f, 0.01694378f, 0.03174352f, 0.00007333f, 0.09936968f, 
    -0.21033679f, 0.07726934f, 0.00728558f, 0.10506357f, 0.06147999f, -0.04153926f, 0.05636589f, -0.00534656f, 
    0.03619174f, 0.01014436f, -0.09741407f, 0.08786990f, 0.25839481f, 0.05396552f, -0.24398069f, -0.17688924f, 
    -0.04428907f, 0.02229155f, 0.06177234f, 0.14058472f, 0.05494328f, 0.06923486f, 0.03565110f, 0.05376869f, 
    0.07408249f, -0.18393333f, 0.09496906f, -0.03936216f, 0.07058198f, -0.05833660f, -0.00737341f, 0.02674386f, 
    0.13626853f, -0.12616128f, 0.13839133f, 0.01477039f, 0.23532808f, -0.05241981f, 0.09630758f, -0.00989450f, 
    -0.01884756f, -0.09287616f, 0.09749418f, 0.03587991f, 0.09285661f, -0.02810580f, 0.00697611f, -0.10262451f, 
    0.06586604f, 0.14424768f, 0.15173522f, -0.03813915f, 0.05952867f, 0.00883059f, -0.05466765f, -0.10257415f, 
    0.01073153f, 0.04890575f, -0.01077513f, 0.01572357f, 0.14148472f, -0.01866719f, -0.01845011f, -0.23335120f, 
    -0.02292310f, 0.19772175f, 0.14379095f, 0.13326697f, -0.07579122f, -0.16302976f, 0.07664615f, 0.09812219f, 
    -0.03346886f, 0.05825841f, 0.02422187f, -0.06202452f, -0.05753466f, -0.11737112f, 0.08066877f, -0.06880362f, 
    0.07200292f, -0.05362286f, -0.10996321f, 0.05057089f, -0.16492902f, 0.11438260f, -0.07125719f, -0.16817690f, 
    -0.03893450f, 0.25455815f, -0.13894141f, 0.13517258f, -0.10541021f, 0.01760537f, -0.10209479f, 0.00277794f, 
    0.01853657f, -0.09263617f, -0.14434350f, 0.09176032f, 0.03470122f, 0.15764160f, 0.02817675f, -0.06315940f, 
    0.01277823f, 0.02549683f, 0.07189011f, -0.00567307f, -0.13336478f, -0.15876260f, 0.09349661f, -0.14124440f, 
    -0.02367172f, -0.07828806f, -0.03362492f, 0.09480611f, -0.03392410f, -0.04677927f, -0.05408827f, 0.11799533f, 
    0.08318622f, -0.53352857f, -0.36831588f, -0.49044719f, -0.07475387f, 0.09622746f, 0.06922800f, 0.06637844f, 
    -0.05155804f, 0.04905933f, -0.08931696f, 0.14466621f, 0.24930747f, 0.20650545f, 0.03260493f, -0.19056422f, 
    0.08440244f, 0.10072848f, 0.12489258f, -0.11417001f, 0.07951199f, 0.00509950f, 0.02635639f, 0.00682373f, 
    0.09221172f, 0.06382178f, 0.04968751f, 0.09066512f, 0.09411258f, -0.06906457f, 0.05383561f, 0.05673035f, 
    0.00541026f, 0.02155890f, 0.03352040f, -0.06018872f, -0.13718714f, -0.14503078f, 0.10140353f, 0.19818935f, 
    -0.09371611f, -0.12363981f, 0.04698394f, -0.09615512f, 0.17999096f, 0.12568302f, 0.05779230f, 0.05411373f, 
    -0.01032460f, -0.13724394f, -0.39117825f, -0.20724997f, 0.17445995f, 0.02378730f, -0.06919927f, -0.23263657f, 
    -0.05666553f, -0.00485116f, -0.02939716f, -0.09835101f, -0.19736274f, 0.16350543f, -0.10976832f, -0.00561703f, 
    0.04172903f, 0.03700254f, -0.00833575f, 0.19833270f, -0.05292657f, 0.07243140f, -0.09963547f, 0.03403558f, 
    0.05235115f, 0.14898305f, 0.01749414f, -0.03905822f, 0.01034153f, 0.09263842f, -0.03815781f, -0.03610320f, 
    0.06497198f, 0.01616245f, 0.07410754f, 0.02362421f, 0.48556983f, -0.10532354f, -0.00962431f, 0.12150943f, 
    -0.09195353f, -0.04872719f, 0.30836952f, -0.08479594f, 0.01618859f, -0.07187907f, -0.10392245f, -0.08923904f, 
    0.06693130f, -0.05747090f, 0.15874566f, 0.21057354f, 0.08622295f, -0.01623870f, -0.06430996f, -0.09617203f, 
    -0.02667853f, -0.06442786f, -0.00147408f, -0.01659292f, 0.39950991f, 0.03495276f, -0.06406323f, -0.26715681f, 
    -0.16198464f, -0.03262705f, -0.04527893f, -0.10124491f, 0.13612162f, -0.04133227f, 0.04274784f, 0.10920182f, 
    -0.01115046f, -0.50114363f, -0.30835974f, -0.09872547f, 0.03936099f, -0.07512484f, -0.18327676f, -0.11158383f, 
    0.04170993f, -0.00546611f, 0.02149004f, 0.03989841f, -0.31065458f, -0.35592565f, -0.21181652f, 0.41758856f, 
    0.01849351f, 0.12453499f, 0.02320335f, 0.09904148f, -0.03933317f, -0.04206886f, -0.04480219f, -0.02556115f, 
    0.05742847f, -0.10154881f, 0.02115872f, -0.10014336f, -0.01250966f, 0.07085592f, 0.10691178f, 0.13405579f, 
    -0.03262287f, 0.06084141f, 0.04225850f, 0.03978973f, -0.25633696f, 0.00245114f, 0.17360571f, 0.10427610f, 
    0.02418428f, -0.06000203f, -0.02691984f, -0.04250631f, 0.03943141f, 0.02110341f, 0.03016379f, 0.25335237f, 
    0.37166241f, 0.24578680f, 0.03595039f, 0.03207810f, -0.04069224f, 0.01067987f, -0.03267982f, -0.11010715f, 
    -0.00167639f, -0.05672386f, 0.09969781f, -0.14550367f, 0.01209266f, 0.00670033f, -0.20579718f, 0.10310982f, 
    -0.10402726f, -0.11126459f, 0.09762575f, 0.08234651f, 0.15693878f, 0.15467948f, 0.00426766f, -0.05881145f, 
    -0.16721204f, 0.37555987f, 0.11899105f, -0.00669661f, 0.21362306f, 0.16037911f, 0.11754020f, 0.04687472f, 
    -0.11068654f, 0.22759257f, 0.07259584f, 0.05776519f, -0.20115915f, 0.37475905f, -0.07222994f, -0.03912159f, 
    -0.04628475f, -0.08901829f, 0.18623595f, 0.08965434f, 0.01385983f, 0.06478596f, -0.13893445f, -0.09287012f, 
    -0.08116853f, -0.01259396f, -0.08432113f, -0.00999486f, -0.14894715f, -0.13730089f, -0.02829681f, -0.21991214f, 
    0.19550985f, 0.03726826f, 0.25602734f, 0.09650336f, -0.03711598f, -0.21475160f, 0.27754399f, -0.14136069f, 
    0.05520000f, -0.03972441f, 0.06623905f, 0.07285384f, 0.22708198f, 0.17291230f, 0.13723777f, 0.15008031f, 
    0.06949725f, -0.01966073f, 0.01624796f, 0.01747602f, 0.20738064f, 0.10406461f, 0.03456696f, 0.08095493f, 
    -0.01135897f, 0.03702594f, -0.02655890f, 0.04361152f, -0.01195165f, -0.15786235f, -0.11204597f, 0.01611010f, 
    0.19308332f, 0.14767085f, -0.08861203f, -0.09203550f, 0.01253780f, -0.04455031f, -0.00284929f, -0.01957388f, 
    0.09523860f, -0.09099059f, -0.02554583f, 0.02252551f, -0.10012890f, 0.02037882f, -0.01165717f, -0.04547323f, 
    -0.08708109f, -0.06742672f, -0.05790509f, -0.18301141f, -0.23011637f, -0.38354060f, -0.08489387f, -0.22078852f, 
    -0.09128245f, 0.00282260f, -0.04403351f, -0.04134281f, -0.00690675f, -0.03599862f, -0.11938499f, -0.02576553f, 
    -0.17334408f, 0.13803837f, 0.25516248f, 0.15736336f, -0.22007303f, 0.00217183f, -0.12597457f, -0.11447955f, 
    -0.09264744f, 0.02348670f, 0.07748698f, -0.21871610f, -0.19565149f, 0.20141919f, 0.28708634f, -0.06891684f, 
    -0.17889217f, -0.12559785f, -0.03318549f, -0.18988661f, 0.04845673f, -0.03282835f, 0.12482968f, 0.26844886f, 
    0.05048171f, 0.11675391f, -0.07944924f, -0.01325207f, 0.13822678f, 0.00052115f, 0.19782548f, 0.32064137f, 
    -0.09204287f, -0.05977920f, -0.00150070f, 0.04836681f, 0.11509528f, 0.13646509f, 0.03595902f, 0.05305868f, 
    0.11802083f, 0.18985422f, -0.16518898f, -0.03226651f, 0.12786672f, -0.09244686f, -0.06132666f, -0.03854867f, 
    0.06715784f, 0.08649449f, -0.32581288f, -0.09587278f, 0.11532691f, 0.04343611f, 0.03261693f, -0.01563640f, 
    0.15594287f, 0.22588737f, 0.08501609f, 0.16541976f, 0.46350408f, -0.16976452f, -0.04701507f, 0.30562037f, 
    0.14497313f, 0.02101991f, 0.03690375f, -0.14109294f, 0.30030879f, -0.17357384f, -0.01550561f, 0.09704258f, 
    0.06925713f, -0.11133359f, -0.04793779f, 0.08357295f, -0.17048402f, -0.24189773f, -0.08427013f, -0.00400622f, 
    -0.15456110f, -0.12360314f, -0.16092995f, 0.04805357f, 0.35025606f, 0.16233446f, -0.15681058f, 0.11189113f, 
    0.10652752f, 0.09539127f, 0.00174887f, -0.08994649f, 0.17001012f, -0.09775065f, 0.15114288f, 0.17526239f, 
    -0.05014972f, 0.21513814f, -0.13067868f, 0.02449178f, -0.03218612f, 0.08590675f, 0.02717781f, 0.17002600f, 
    -0.01882915f, 0.06898942f, -0.01776882f, -0.05973416f, -0.03474909f, -0.06247465f, 0.26374900f, 0.06203924f, 
    -0.13935845f, 0.04256925f, 0.02029071f, 0.06085347f, 0.02463988f, 0.08917631f, 0.03922017f, -0.15469706f, 
    -0.19154826f, -0.19191787f, -0.04349145f, -0.12456883f, 0.02587521f, -0.04495955f, -0.10748385f, -0.02797386f, 
    -0.00777040f, 0.13002500f, 0.20125090f, 0.12750466f, 0.14818946f, 0.00432356f, 0.05517593f, 0.08612744f, 
    -0.12258807f, -0.02795126f, 0.14209704f, -0.00701815f, 0.05678571f, -0.04155508f, 0.24714287f, 0.09469592f, 
    0.04007794f, 0.14804387f, 0.26941481f, 0.33992672f, 0.05081735f, 0.02801908f, 0.23746443f, 0.27887687f, 
    -0.02163611f, 0.03219219f, 0.09911368f, -0.01052685f, 0.08106208f, -0.22656740f, -0.11292125f, 0.00049538f, 
    0.17791413f, 0.08825477f, -0.04900392f, 0.00976598f, -0.00986475f, -0.03152109f, -0.11212295f, -0.09062513f, 
    -0.19098768f, -0.19720466f, -0.13461268f, -0.13568881f, -0.02411531f, -0.02719862f, -0.12051943f, -0.03968717f, 
    -0.08723563f, -0.24229333f, -0.11336870f, -0.21455154f, -0.13327661f, -0.00265958f, -0.04917074f, 0.20549642f, 
    0.04324064f, -0.05053904f, -0.05765659f, -0.05052067f, -0.11602565f, 0.02382753f, -0.21802394f, -0.07680972f, 
    -0.17415138f, -0.04381289f, 0.03922243f, -0.26729828f, -0.12200751f, -0.09100605f, -0.10153691f, -0.08113978f, 
    -0.20437355f, -0.01213616f, -0.09746262f, -0.12052418f, -0.13610069f, -0.04768715f, 0.06706809f, -0.28616112f, 
    -0.12056104f, -0.01947231f, 0.02502861f, 0.01989001f, 0.14099914f, 0.04866287f, 0.03198692f, 0.23774837f, 
    0.38859260f, 0.44472918f, 0.40301478f, 0.32374948f, -0.07417768f, 0.11504925f, 0.14438820f, 0.21227254f, 
    0.02860686f, 0.11619855f, -0.08453391f, -0.08287950f, 0.22057733f, 0.17640440f, 0.09865049f, 0.15279183f, 
    0.16107316f, 0.07224493f, -0.03760538f, 0.15738003f, -0.00952868f, -0.07208421f, -0.06888087f, -0.09082642f, 
    0.03977566f, 0.22468996f, -0.05767369f, -0.00900962f, 0.13411634f, 0.01610849f, 0.01452951f, 0.03526242f, 
    -0.06017810f, 0.08969349f, 0.04502850f, 0.18994662f, 0.03443503f, 0.29604948f, -0.14713389f, 0.16920184f, 
    0.16056868f, 0.00447607f, -0.01795938f, 0.01392354f, 0.04380107f, -0.00298100f, 0.02624120f, -0.02532104f, 
    -0.10586270f, -0.18922049f, -0.31038275f, 0.35346475f, -0.09566060f, -0.06707651f, -0.07153051f, -0.19059820f, 
    -0.01486896f, 0.00319262f, -0.04680441f, 0.04210705f, 0.07638461f, -0.03462631f, -0.14383209f, 0.08100611f, 
    -0.09834000f, 0.15311509f, -0.01590683f, 0.08791059f, 0.18754256f, -0.01055610f, 0.17539673f, -0.02009328f, 
    0.04687065f, -0.00011157f, 0.14328875f, -0.02028345f, 0.01770675f, 0.09937954f, 0.12954578f, 0.00577288f, 
    -0.02821221f, 0.21384776f, 0.05509578f, 0.08416895f, 0.00367671f, 0.04934594f, -0.31730363f, -0.18621023f, 
    0.01095794f, 0.00786135f, -0.03842989f, -0.08212262f, -0.06615769f, -0.10998213f, 0.00115045f, 0.09486263f, 
    0.00701256f, 0.14667791f, 0.05095210f, 0.07443261f, -0.01352076f, -0.03445698f, 0.09759461f, -0.13097969f, 
    0.09521656f, 0.13081272f, 0.14317557f, -0.13493492f, 0.05371305f, 0.02366377f, 0.19137089f, 0.02406047f, 
    -0.10818671f, -0.11814053f, 0.01957602f, 0.10713577f, -0.01433464f, 0.07914872f, 0.15213308f, 0.16871382f, 
    -0.17896913f, -0.26469019f, -0.06141224f, -0.06978825f, 0.07009339f, -0.07568923f, 0.03489977f, -0.22902305f, 
    -0.16631918f, -0.06449763f, -0.16511728f, -0.06514136f, -0.11837107f, 0.05245369f, -0.09521809f, 0.11675472f, 
    -0.02604872f, -0.01901143f, 0.12392085f, 0.09452229f, 0.00854144f, 0.03466188f, -0.16649270f, -0.09182833f, 
    0.34666708f, 0.00819684f, 0.03989308f, -0.19721536f, -0.10396640f, 0.01998878f, 0.08257088f, 0.01579141f, 
    0.09436964f, 0.18786973f, 0.09285906f, 0.04430022f, -0.04521150f, -0.18340303f, 0.15640767f, -0.07805078f, 
    -0.07178607f, -0.15570891f, 0.01833337f, -0.00602769f, 0.04638085f, -0.00776053f, 0.02586733f, -0.00299032f, 
    -0.03977939f, 0.29406857f, 0.03903109f, 0.24279830f, -0.01288670f, 0.04336373f, -0.00478260f, -0.11513902f, 
    0.16878851f, -0.04586229f, 0.04685403f, -0.06628533f, 0.01057392f, 0.15355451f, -0.04395385f, -0.27779880f, 
    -0.08574151f, 0.11303621f, -0.05878787f, -0.04237983f, 0.01445413f, 0.12386826f, 0.11592500f, 0.08421706f, 
    -0.19568422f, -0.25463399f, -0.22317167f, 0.16974849f, 0.10894091f, -0.10082839f, -0.02765270f, 0.07496810f, 
    -0.04545606f, 0.01229070f, 0.00869323f, -0.03802268f, -0.10128382f, 0.07526061f, -0.01759654f, 0.16500334f, 
    0.11849635f, 0.07468031f, 0.03984328f, 0.01757023f, 0.05209200f, -0.07788183f, 0.01532996f, -0.05913744f, 
    -0.02164007f, 0.05318453f, -0.05780451f, 0.01390988f, 0.04328198f, -0.03746809f, 0.00088444f, -0.06557328f, 
    -0.07875480f, 0.20264445f, 0.14535551f, 0.15943523f, 0.28691578f, 0.01061769f, 0.43113795f, 0.37635520f, 
    0.15328245f, -0.00628612f, 0.23811203f, -0.03962414f, 0.00962157f, -0.05349164f, 0.05897716f, 0.01382004f, 
    0.34543484f, 0.16963404f, 0.46473047f, -0.32139280f, -0.13910574f, -0.10412845f, -0.10078689f, 0.00704569f, 
    -0.10536452f, 0.00229450f, 0.00518805f, -0.02647919f, 0.03831480f, 0.25829449f, -0.15371412f, 0.23756632f, 
    -0.01383002f, -0.03443834f, 0.08982702f, 0.24233316f, 0.19902804f, 0.05501038f, 0.01379373f, -0.03240587f, 
    -0.24379326f, 0.28684455f, 0.07971911f, 0.16391173f, 0.05582182f, -0.13945608f, -0.07015920f, 0.07098957f, 
    0.13563424f, 0.10732839f, 0.10888325f, 0.03341850f, -0.26164603f, -0.09758960f, -0.23334712f, 0.10347006f, 
    0.02728349f, -0.02905724f, 0.10478107f, 0.07465038f, -0.03177252f, -0.05593083f, 0.05195018f, 0.08178288f, 
    -0.02060016f, 0.05060188f, 0.05206253f, -0.02383040f, -0.17017069f, -0.06371503f, 0.05167888f, 0.00586545f, 
    -0.08220127f, -0.09297284f, 0.04255773f, -0.05829364f, 0.08635852f, -0.10849493f, 0.31515384f, -0.10500964f, 
    -0.05670748f, -0.13748527f, -0.09113780f, 0.08064526f, -0.01256570f, -0.00150537f, -0.06704930f, -0.02610102f, 
    -0.18831314f, -0.17221095f, 0.17874274f, 0.07624361f, -0.07855636f, 0.11223356f, 0.11890848f, -0.02507495f, 
    0.05544940f, -0.02662250f, -0.03399465f, -0.05317562f, -0.00703910f, -0.00707568f, 0.19140476f, -0.34160805f, 
    -0.00044740f, 0.09840536f, -0.04762541f, 0.00606459f, 0.14019749f, 0.02253388f, 0.09700579f, 0.05558732f, 
    0.06272124f, 0.14439994f, 0.00730903f, -0.01234006f, 0.08087082f, -0.07619072f, -0.00290537f, -0.10878686f, 
    0.05837849f, 0.12412050f, 0.02278336f, 0.05715373f, 0.41765493f, -0.06739232f, -0.31618077f, -0.11337639f, 
    0.05899764f, 0.08893217f, 0.19390266f, 0.01128093f, -0.03848149f, 0.03664453f, -0.05401910f, -0.02644415f, 
    0.10699195f, -0.02578798f, 0.00981195f, 0.11260925f, -0.11329632f, 0.07852139f, -0.05485391f, -0.00030818f, 
    -0.11836373f, -0.04933508f, 0.00095288f, -0.14807047f, -0.21502085f, 0.13811323f, 0.32712832f, 0.23737946f, 
    -0.06032396f, -0.02821477f, -0.10899269f, -0.14173359f, 0.10789009f, 0.09110276f, -0.09202372f, 0.00596091f, 
    -0.38585719f, 0.18361840f, -0.11685155f, 0.12100995f, 0.02140413f, 0.04414267f, 0.07896610f, 0.04721273f, 
    0.10926723f, 0.10016233f, 0.14685938f, 0.07170654f, -0.04989711f, -0.13239463f, 0.03515663f, -0.10593367f, 
    -0.06992928f, 0.10867687f, -0.09985431f, 0.09684463f, 0.21427616f, 0.05349194f, 0.02141418f, -0.00813096f, 
    -0.00159714f, 0.04130250f, -0.06571306f, 0.05971560f, 0.07762650f, 0.06539407f, 0.01776142f, 0.05203651f, 
    -0.10681643f, 0.05357691f, -0.12688841f, -0.02630079f, 0.22169954f, -0.17141578f, 0.10208221f, -0.00809011f, 
    0.16408367f, 0.10440606f, 0.06049473f, 0.05946752f, 0.01634512f, 0.10304382f, 0.00781037f, -0.00316158f, 
    0.35163647f, -0.01318279f, -0.08885778f, 0.04375444f, -0.06494405f, -0.02038412f, 0.11523023f, -0.09395985f, 
    0.02796547f, -0.06452803f, 0.02873908f, -0.11149555f, 0.27027974f, -0.02718276f, 0.18604614f, -0.15466507f, 
    -0.09115945f, -0.16283078f, -0.04006562f, -0.04968321f, -0.00402062f, -0.01319294f, 0.01581937f, 0.00274774f, 
    -0.08066794f, -0.19678082f, 0.02342462f, -0.10456755f, -0.15331621f, -0.01284956f, 0.09654824f, 0.16700459f, 
    0.04743076f, -0.02246381f, -0.05608695f, -0.02516674f, 0.01871852f, 0.01579521f, 0.16733022f, 0.12668897f, 
    -0.00356318f, -0.02035629f, 0.12285057f, 0.02591021f, 0.00638781f, -0.05123594f, 0.10059058f, 0.02528928f, 
    0.05057220f, -0.05263862f, 0.15607820f, 0.12138659f, 0.07038990f, 0.03977144f, -0.02592480f, 0.05308815f, 
    0.10045182f, 0.07679191f, 0.11559124f, 0.04468384f, -0.18728161f, -0.04669631f, 0.06973298f, -0.01022736f, 
    -0.21017954f, 0.05329303f, -0.00968911f, -0.15287185f, 0.10602112f, -0.11538118f, -0.03185843f, 0.03324297f, 
    -0.04819486f, -0.09381916f, 0.01613992f, 0.13885473f, -0.04180541f, -0.04723322f, 0.22113721f, 0.10698394f, 
    -0.12882613f, 0.03605559f, -0.05902373f, -0.08704531f, 0.06578372f, 0.12878010f, -0.06064834f, 0.14080139f, 
    0.04904120f, -0.12278306f, 0.06499732f, 0.09054261f, -0.06567531f, 0.03867690f, -0.08816803f, -0.05332952f, 
    -0.01282671f, -0.13916652f, 0.04247217f, -0.16577311f, 0.04571348f, -0.08921524f, -0.08382820f, 0.05876896f, 
    -0.04468038f, -0.07510519f, 0.03637744f, -0.00993015f, -0.00870536f, 0.04032214f, 0.28425100f, 0.04947342f, 
    0.19609486f, 0.01623588f, 0.03320974f, -0.09954294f, -0.19004686f, 0.05235247f, -0.16370940f, -0.12357691f, 
    -0.20710243f, 0.22309783f, 0.11513257f, 0.02058349f, -0.07002909f, -0.06255565f, 0.07849566f, 0.13177617f, 
    0.10437845f, 0.00283703f, -0.07973646f, 0.05267152f, 0.02409572f, -0.19648713f, 0.02513128f, -0.05402111f, 
    -0.10417871f, -0.11459210f, -0.01767441f, 0.04890205f, 0.19895877f, 0.02920668f, 0.08883315f, 0.15711984f, 
    0.02590453f, 0.10883921f, 0.10772371f, -0.07262400f, -0.13046154f, 0.09782340f, -0.00514192f, -0.14083102f, 
    0.08639224f, 0.07811641f, -0.07581349f, 0.08259699f, -0.01070567f, 0.12014079f, -0.06986516f, 0.00602977f, 
    0.07556837f, -0.00741541f, -0.01181471f, -0.05691094f, -0.05192358f, -0.10607684f, -0.01778072f, -0.03484570f, 
    0.01968377f, 0.23764548f, 0.00837119f, 0.07310447f, 0.16255634f, 0.01010139f, 0.16763701f, 0.07053113f, 
    0.07741849f, 0.04829519f, 0.05413160f, 0.15850259f, -0.40391815f, 0.13826554f, 0.13716629f, 0.02640940f, 
    0.01894955f, 0.02968496f, -0.24888299f, 0.08252725f, 0.01644237f, 0.15196826f, 0.14149217f, 0.08244922f, 
    0.12576109f, 0.04420425f, 0.06389625f, 0.21533325f, 0.06482138f, -0.12693380f, 0.00524812f, -0.07235182f, 
    -0.06453610f, -0.08890014f, -0.09894720f, 0.02661316f, -0.06515978f, -0.05887018f, -0.15508740f, 0.19422926f, 
    -0.03047859f, 0.12015092f, -0.06524810f, 0.22967277f, 0.18470119f, -0.03328270f, 0.09292288f, -0.01660317f, 
    -0.16942304f, -0.33586547f, -0.24786580f, -0.26625869f, -0.17472021f, 0.05423622f, -0.01926238f, 0.13813020f, 
    -0.11509821f, 0.03183967f, -0.11850803f, 0.19905165f, -0.00046163f, -0.05334221f, 0.12458974f, -0.08254511f, 
    0.18755640f, 0.17479467f, 0.00958329f, 0.06049938f, -0.04943819f, -0.05807155f, -0.01636662f, -0.18492918f, 
    0.08873935f, 0.12791075f, 0.15264077f, 0.05374604f, 0.00116319f, -0.18361698f, -0.00441930f, -0.01292527f, 
    -0.04875728f, -0.15844044f, -0.12490148f, -0.11189640f, 0.08443318f, -0.12385482f, 0.02107089f, 0.15770052f, 
    0.05896728f, -0.09595049f, -0.05452734f, -0.05209015f, -0.06524784f, 0.15313293f, -0.10826864f, 0.04847329f, 
    0.22976923f, 0.17730665f, -0.05530659f, -0.05773352f, 0.08770598f, 0.08709782f, 0.12636696f, -0.14237911f, 
    -0.11919504f, -0.13793302f, -0.11246969f, -0.22966141f, -0.31642279f, -0.14960584f, -0.08301020f, -0.40977603f, 
    0.08565826f, 0.09177199f, 0.07831907f, -0.04007916f, 0.19774731f, 0.14324830f, 0.08587603f, 0.07552840f, 
    0.15477207f, -0.00132418f, 0.16148296f, -0.15068850f, 0.05051589f, 0.01813370f, -0.00250160f, -0.02194900f, 
    -0.02316267f, 0.14078167f, 0.06110471f, 0.06539927f, 0.71731097f, 0.07495339f, 0.20477659f, 0.26807794f, 
    -0.12026448f, -0.04342919f, 0.43524355f, -0.09759276f, -0.06941416f, -0.04587843f, -0.11013024f, 0.07154597f, 
    0.17186150f, 0.24656872f, 0.02061178f, 0.17686291f, 0.09067740f, 0.10737158f, 0.04695661f, 0.01690267f, 
    0.10979445f, 0.14008105f, 0.14281523f, -0.01844583f, 0.04422663f, 0.09538572f, -0.07839704f, 0.09544066f, 
    0.02117508f, 0.01965625f, -0.07729221f, -0.10935868f, -0.07771134f, -0.04194091f, -0.03098561f, 0.03119536f, 
    -0.38438636f, 0.02039514f, 0.13238238f, -0.08412314f, 0.12596337f, -0.23425665f, -0.05804650f, -0.02785649f, 
    0.09491128f, -0.15930089f, 0.03859307f, -0.09971226f, -0.15284106f, -0.29813489f, -0.03248697f, 0.01823702f, 
    0.05889251f, 0.02023741f, -0.05951371f, 0.13556500f, 0.05944106f, 0.16292445f, 0.07572180f, 0.03595064f, 
    -0.01649561f, 0.12728737f, -0.14284785f, 0.12732153f, 0.08586949f, -0.04328396f, -0.07590543f, -0.06219074f, 
    -0.17146561f, -0.07820731f, -0.16705902f, 0.01360192f, -0.12060240f, 0.00991776f, -0.14010312f, 0.06238461f, 
    -0.14171737f, 0.03689296f, -0.00197178f, 0.02456322f, -0.11303180f, -0.03651397f, -0.02823775f, 0.33195764f, 
    0.73706079f, 0.18283896f, 0.40028322f, 0.15729573f, -0.15509897f, -0.00803913f, -0.00984623f, -0.08913558f, 
    -0.07307134f, 0.08189728f, 0.05160229f, 0.05312590f, -0.07493418f, -0.18965767f, -0.32293209f, 0.11442403f, 
    -0.09582052f, 0.03734593f, 0.04839317f, 0.04281767f, 0.14794175f, -0.05724578f, 0.04272148f, 0.07646031f, 
    -0.05971307f, -0.21780132f, -0.04233896f, -0.04941558f, 0.00017393f, -0.04867561f, 0.08463047f, 0.17480180f, 
    0.03963484f, 0.07434697f, 0.18953927f, 0.07472754f, 0.18320414f, -0.20467764f, -0.00141678f, 0.10881762f, 
    0.12176591f, 0.09960517f, 0.03247447f, 0.07226586f, -0.01187989f, -0.06745698f, 0.09854640f, -0.04802993f, 
    -0.03199355f, -0.09139748f, -0.07893640f, -0.09186305f, 0.04746662f, 0.04059621f, -0.03340125f, -0.03934770f, 
    -0.02609418f, 0.02316844f, -0.02945051f, -0.04270519f, -0.15080309f, -0.00011910f, -0.02555966f, 0.01107241f, 
    -0.03553848f, 0.08766563f, 0.04881935f, -0.06396255f, -0.04941678f, -0.00965018f, 0.01140973f, -0.04625246f, 
    -0.23008962f, -0.27182621f, -0.05907350f, 0.12134719f, 0.04725703f, -0.13646562f, 0.08469266f, 0.03069145f, 
    -0.05466006f, -0.01733924f, -0.06967692f, -0.07987926f, -0.15348513f, 0.06302399f, -0.03663369f, 0.06400234f, 
    -0.20672235f, -0.13393620f, 0.06384628f, 0.18892871f, -0.04567487f, 0.15259846f, 0.02246515f, 0.08027848f, 
    0.26207754f, 0.05767411f, -0.03698285f, 0.01680747f, 0.02490148f, -0.00146813f, 0.00982440f, 0.02579403f, 
    0.06056366f, 0.27968243f, 0.14476728f, -0.00477335f, 0.04574530f, 0.13899964f, 0.23638411f, 0.16443327f, 
    0.06890022f, 0.10876115f, 0.27291918f, 0.14270446f, 0.06119642f, 0.03672168f, -0.03096249f, 0.02545555f, 
    0.02576293f, 0.09140752f, -0.10546799f, -0.00144790f, -0.00190686f, -0.00659967f, 0.10063662f, -0.04366758f, 
    -0.02352182f, 0.01108403f, -0.03750077f, 0.05973239f, 0.03071107f, -0.00128624f, -0.24458745f, -0.04709198f, 
    0.03590871f, 0.00767200f, -0.07193726f, -0.08119325f, -0.03990581f, 0.14989518f, 0.10665965f, -0.07077004f, 
    -0.06830860f, -0.39331105f, 0.11187514f, 0.22564097f, 0.06687536f, 0.05903073f, -0.09082162f, 0.04728348f, 
    -0.05164003f, 0.01368202f, -0.02719095f, -0.03640583f, -0.11953954f, -0.06537741f, 0.00111434f, 0.26272818f, 
    0.00054927f, 0.03032887f, 0.23061337f, 0.15058340f, -0.13180076f, 0.09710809f, 0.00109638f, 0.06777677f, 
    -0.11140118f, -0.12271057f, 0.10101821f, -0.05975577f, 0.01263812f, 0.04394873f, -0.06286068f, 0.02981485f, 
    0.08269748f, -0.08593178f, 0.02151845f, 0.03696065f, -0.26312926f, 0.38185763f, 0.20129272f, 0.04496845f, 
    -0.02423059f, -0.03317042f, -0.07286131f, 0.05690908f, -0.10721809f, 0.00357734f, -0.06883303f, 0.14947008f, 
    -0.09362080f, 0.18488905f, 0.11856937f, -0.05529356f, -0.02735441f, 0.03630397f, -0.12586556f, -0.07251449f, 
    -0.06637557f, 0.00589097f, -0.01841240f, -0.02014484f, -0.19345583f, -0.07260624f, 0.14945066f, 0.14498627f, 
    -0.04682723f, 0.02321531f, -0.01556998f, 0.24909855f, -0.02358514f, 0.18391232f, 0.04747890f, 0.13686112f, 
    0.02775594f, 0.05569313f, -0.00215001f, -0.01597183f, -0.03463528f, -0.01269220f, 0.01259835f, -0.06176368f, 
    -0.02146121f, -0.02110415f, 0.04540800f, -0.05988141f, 0.03056941f, 0.02578659f, -0.02065139f, 0.02134943f, 
    0.05944105f, -0.03731933f, 0.00119862f, -0.06920759f, 0.06052484f, -0.04985717f, -0.04234363f, -0.04240574f, 
    0.01599628f, 0.00790982f, 0.02046556f, 0.01681129f, -0.02793233f, 0.03502313f, -0.00455625f, -0.05838300f, 
    0.04306126f, 0.00733588f, -0.08565335f, 0.04779361f, 0.02546562f, 0.01917738f, 0.02019136f, 0.05040682f, 
    -0.04787051f, -0.01264423f, -0.03554115f, 0.02163969f, -0.03570266f, -0.08612520f, -0.00413326f, -0.08860369f, 
    -0.04542481f, 0.03096624f, -0.05247607f, 0.03700387f, 0.03795455f, 0.06462770f, -0.07702680f, 0.02921166f, 
    0.04286733f, 0.00220849f, -0.05077520f, -0.05734447f, -0.03035507f, 0.03127789f, -0.04998567f, -0.03186088f, 
    -0.02737073f, -0.00956571f, 0.05828924f, -0.01705262f, -0.04908874f, -0.02420508f, -0.02673353f, -0.01199373f, 
    0.01439482f, 0.02033020f, -0.08018792f, -0.05066619f, -0.07242326f, -0.01403004f, -0.06279866f, 0.04114832f, 
    0.04532135f, -0.07251633f, -0.00503466f, -0.00603052f, -0.00015283f, -0.05886569f, -0.02509480f, -0.04699478f, 
    -0.00521674f, 0.05433177f, 0.02038757f, -0.05407413f, -0.03556405f, -0.04410336f, -0.07018874f, 0.00979134f, 
    0.00441421f, -0.08252043f, -0.04498493f, -0.03232069f, -0.03762662f, -0.04602901f, -0.00172816f, 0.03152310f, 
    -0.06067618f, 0.00744817f, -0.02864444f, 0.02860551f, 0.03874346f, -0.06544480f, -0.09633070f, -0.06328244f, 
    0.03970722f, 0.02194739f, -0.01075777f, -0.01037850f, -0.00903134f, -0.00796401f, -0.04339589f, -0.04539177f, 
    -0.06562917f, 0.05958211f, -0.01967740f, 0.01178049f, 0.02639329f, 0.05989102f, -0.04687005f, -0.00274015f, 
    -0.06514674f, 0.05438718f, 0.00131470f, 0.03661394f, -0.05459137f, 0.02546125f, -0.06401469f, 0.03187346f, 
    -0.04349008f, 0.01971578f, -0.01575170f, -0.00827183f, 0.00904973f, -0.03599941f, 0.04720774f, -0.03464332f, 
    -0.04160690f, -0.05785292f, 0.04750994f, -0.01112131f, -0.00102954f, 0.04319487f, -0.03471517f, 0.00488062f, 
    -0.00816773f, -0.04832155f, 0.04573879f, -0.05668757f, 0.03952485f, -0.04276915f, -0.08365427f, -0.07918651f, 
    -0.06234748f, -0.04387527f, 0.01132553f, 0.05887936f, -0.01935621f, -0.03792511f, -0.07142120f, -0.07487836f, 
    0.02479026f, -0.01518600f, -0.00210938f, -0.06532475f, -0.06830462f, 0.05363330f, 0.01259064f, -0.08186451f, 
    0.04484113f, 0.03038866f, -0.05367368f, -0.08417138f, 0.03910875f, -0.00020797f, 0.05045765f, 0.00638292f, 
    -0.05929005f, -0.06616899f, -0.04150946f, -0.01649989f, -0.04561808f, -0.04442665f, -0.02139337f, -0.01040317f, 
    -0.02442228f, -0.04565802f, 0.06486065f, 0.00053013f, -0.01703910f, -0.03854854f, -0.06499366f, -0.04723071f, 
    -0.06293890f, 0.01044142f, 0.01213230f, -0.01085636f, -0.01011034f, -0.00138178f, 0.00731373f, 0.04598334f, 
    0.04588349f, 0.01363099f, -0.02988969f, -0.01946627f, -0.05632368f, 0.04513599f, 0.03398361f, 0.02209863f, 
    -0.06191373f, 0.03458923f, 0.02509405f, -0.04180546f, -0.00590794f, 0.01365648f, -0.06933823f, 0.06012819f, 
    0.02932245f, 0.05911893f, -0.07649077f, -0.05494994f, -0.00499806f, -0.07331257f, -0.07029789f, 0.03959953f, 
    0.05347749f, 0.06176525f, -0.03457358f, -0.06388891f, -0.04013963f, -0.04146932f, -0.07237509f, 0.03879282f, 
    -0.02750303f, -0.02952640f, 0.05878346f, -0.05507759f, -0.06801394f, -0.03523715f, -0.03749514f, 0.05652874f, 
    -0.05596084f, -0.02252076f, -0.07275827f, 0.04159129f, -0.07767184f, -0.06924976f, 0.03931706f, -0.03845561f, 
    0.05982033f, 0.04699121f, -0.01828238f, -0.04694925f, 0.01516332f, -0.00571800f, -0.07711507f, -0.00048311f, 
    0.00667002f, 0.04568322f, 0.00413485f, 0.00671150f, -0.01951392f, -0.04406947f, -0.06681165f, 0.05146317f, 
    0.00183262f, -0.03428847f, 0.01558259f, 0.02480750f, -0.07605616f, -0.07422346f, 0.03896137f, 0.02993007f, 
    -0.02060761f, 0.04513164f, -0.01154967f, -0.04439881f, 0.04987988f, -0.03368460f, -0.00356564f, 0.03828242f, 
    -0.06694992f, 0.03140486f, -0.02875606f, -0.04835800f, -0.01813403f, -0.05277841f, -0.01628945f, -0.01046678f, 
    0.06183944f, -0.02398854f, 0.00054832f, -0.05722684f, 0.06385387f, -0.01862615f, 0.04760542f, -0.02839601f, 
    -0.04158656f, 0.04188386f, -0.01353938f, -0.03679330f, 0.04372250f, 0.06291395f, -0.07022072f, 0.04312585f, 
    -0.07788128f, 0.04961470f, -0.05326365f, 0.00377530f, 0.01543524f, -0.01372396f, -0.04602677f, -0.03866342f, 
    -0.00388001f, -0.03957101f, -0.06173589f, -0.00134356f, -0.02721263f, 0.02701985f, 0.01585783f, 0.05983350f, 
    -0.01758841f, -0.04736181f, 0.00879413f, 0.04831889f, 0.00592857f, 0.00864312f, 0.03803840f, 0.03694269f, 
    0.01733399f, -0.04323075f, -0.03927687f, -0.00261368f, -0.03134560f, 0.05404482f, 0.00358893f, 0.00498227f, 
    -0.05457596f, -0.04985147f, -0.03752460f, 0.00593834f, -0.00016305f, 0.01190706f, -0.07212574f, -0.04796537f, 
    -0.03101060f, 0.04317253f, 0.05698946f, 0.03706318f, -0.07355290f, 0.02614415f, -0.07227590f, -0.04027401f, 
    -0.06424785f, 0.01467125f, -0.06127755f, -0.05107582f, -0.03621287f, -0.03433268f, 0.03504943f, -0.03882672f, 
    0.00844079f, 0.01139132f, -0.03217649f, 0.02242487f, -0.04379973f, -0.01796836f, -0.03837756f, -0.02083275f, 
    -0.00527066f, 0.00240448f, -0.06823575f, -0.07604027f, 0.05020118f, 0.04794583f, 0.05946550f, 0.01292490f, 
    -0.18214576f, -0.19127266f, 0.04673467f, 0.07466178f, -0.03891255f, 0.03934944f, 0.12336875f, 0.10474747f, 
    0.07072058f, -0.02989499f, 0.14469115f, -0.06644016f, -0.07436757f, -0.02959653f, 0.02868630f, 0.05064338f, 
    0.09231550f, 0.07000291f, 0.06045258f, 0.02972631f, 0.11548229f, 0.05765877f, -0.09405889f, 0.09196867f, 
    0.08361728f, -0.03502396f, -0.05420774f, -0.06324937f, 0.05967288f, -0.05893250f, -0.12397483f, -0.04372625f, 
    0.08139773f, 0.10796668f, 0.00466401f, 0.00298296f, -0.15270421f, -0.07721996f, -0.08048411f, 0.18023108f, 
    -0.22344935f, 0.16647620f, 0.05895580f, 0.02501957f, 0.11496324f, 0.16603619f, -0.06492872f, 0.12912813f, 
    -0.00097675f, 0.00362948f, 0.00754513f, 0.07658866f, 0.00966934f, -0.04423710f, 0.17240876f, 0.03131985f, 
    -0.03120688f, 0.02572296f, 0.01390075f, 0.01937140f, -0.00564348f, -0.15523526f, -0.06405708f, 0.10024014f, 
    -0.03643700f, -0.03223891f, 0.20631433f, 0.07101336f, -0.04251758f, -0.04466109f, -0.01887350f, -0.10228782f, 
    -0.00092178f, -0.07724752f, -0.11324213f, 0.03484135f, 0.14258471f, -0.05362330f, 0.03128500f, -0.12054461f, 
    0.06017252f, 0.11789949f, 0.09761911f, 0.01045013f, -0.06775315f, 0.37051845f, 0.42871532f, 0.22187886f, 
    0.00429676f, -0.11134337f, -0.09110694f, 0.03942285f, -0.11601765f, -0.14487706f, 0.03645276f, -0.09487733f, 
    -0.04207363f, 0.15936501f, -0.10017372f, -0.07869421f, -0.04397491f, -0.05576532f, -0.02328739f, 0.00802459f, 
    0.07413001f, 0.01001696f, -0.11917239f, -0.08055060f, -0.10672006f, -0.15283829f, -0.47414851f, 0.10923713f, 
    -0.10199493f, -0.07724487f, -0.10255530f, -0.09315850f, 0.09339433f, 0.06472638f, 0.11716375f, 0.07963436f, 
    0.05477807f, -0.35201699f, 0.07085070f, 0.13964581f, -0.00557979f, -0.03407594f, 0.17797643f, 0.14532517f, 
    -0.05296795f, -0.05232473f, 0.06807486f, 0.09525983f, 0.08732133f, -0.00527026f, 0.01586364f, 0.03578935f, 
    -0.01579028f, -0.05169975f, -0.11377841f, -0.09395795f, 0.04488760f, -0.11039825f, -0.03899397f, -0.03819003f, 
    0.06594450f, -0.06224571f, 0.17728852f, -0.04210508f, 0.10234058f, 0.14201969f, -0.05136885f, 0.15603283f, 
    0.06359432f, -0.03752809f, 0.08956743f, 0.05533523f, 0.05070697f, 0.17956372f, 0.07216600f, 0.02835647f, 
    -0.00357737f, -0.02582292f, 0.07756874f, -0.03473189f, 0.09107365f, 0.00960200f, 0.13765770f, 0.01112738f, 
    -0.03016669f, 0.20188259f, 0.36687100f, 0.03019469f, -0.04200923f, -0.10594618f, -0.22377369f, 0.03328877f, 
    0.01086519f, -0.10604918f, -0.02949672f, 0.08294242f, 0.05821693f, -0.22523682f, 0.15655734f, 0.01691555f, 
    0.02543483f, -0.01861170f, -0.04937022f, 0.06085171f, -0.12429066f, -0.03361802f, 0.07800230f, 0.05701317f, 
    0.02660826f, 0.01529039f, 0.02682646f, -0.01081973f, -0.05871749f, 0.00242206f, -0.06352596f, -0.02628680f, 
    -0.01854362f, -0.03215425f, -0.01255792f, -0.02742794f, -0.06494468f, -0.06773975f, -0.03910319f, -0.03772835f, 
    0.04414158f, 0.00302554f, 0.06486092f, 0.03445787f, -0.03119257f, -0.03942910f, 0.05562821f, -0.05571366f, 
    0.02671320f, -0.02591175f, -0.06182099f, 0.00867827f, -0.05239147f, -0.04301895f, -0.00700540f, 0.00450989f, 
    -0.06386112f, -0.03237630f, 0.04359456f, -0.02494019f, 0.00105145f, -0.05357293f, -0.07689366f, 0.05586236f, 
    -0.04008513f, -0.03699522f, -0.04175394f, -0.00244354f, -0.04287460f, -0.00546006f, -0.04226048f, 0.02889466f, 
    -0.05824345f, -0.06373186f, -0.05230360f, -0.03987111f, -0.01644271f, 0.01705477f, -0.05561178f, 0.01797494f, 
    0.01143439f, -0.02178027f, 0.00853921f, 0.03590747f, 0.05884881f, 0.01177981f, 0.06402333f, 0.01100000f, 
    -0.04398667f, 0.01651560f, -0.02346844f, 0.05063238f, 0.05563103f, 0.02223673f, -0.04085652f, -0.02163669f, 
    -0.02395224f, -0.05641984f, -0.03213131f, 0.05715169f, 0.00009150f, -0.01409983f, -0.02647317f, -0.05356262f, 
    -0.03350820f, -0.04693831f, -0.02146036f, 0.01557512f, 0.01221853f, -0.00838173f, 0.02897406f, -0.00174561f, 
    -0.02583540f, -0.05468646f, -0.05429745f, -0.02487829f, -0.01552071f, 0.01530965f, -0.06288915f, -0.01857112f, 
    -0.04770358f, -0.02870993f, -0.01647311f, -0.02167923f, 0.00324078f, 0.04615938f, 0.03499671f, 0.04792264f, 
    -0.02131226f, -0.01980506f, -0.00594671f, -0.01735728f, 0.01584678f, -0.04747835f, 0.03878085f, -0.02129943f, 
    0.00630528f, -0.04361566f, -0.07735884f, 0.04442758f, 0.01287186f, 0.05395758f, -0.02777186f, 0.03193818f, 
    -0.00642346f, 0.05176848f, 0.01120826f, -0.04807843f, -0.02140632f, -0.06558252f, 0.05842895f, -0.03132778f, 
    0.05574040f, -0.01816711f, -0.04651532f, -0.05578807f, 0.06386144f, -0.02629849f, 0.02795607f, -0.02385124f, 
    -0.01520321f, -0.06487599f, -0.01475691f, -0.07727864f, -0.01364701f, -0.00847317f, 0.06435766f, -0.06127014f, 
    -0.05488507f, -0.00915846f, -0.02890064f, -0.05806146f, 0.06512656f, 0.01443882f, 0.04556967f, 0.03189546f, 
    -0.01783337f, 0.00206902f, 0.04172832f, -0.01924051f, 0.00205929f, -0.01578756f, 0.05651659f, 0.00769297f, 
    0.00553299f, -0.06906547f, 0.03353779f, -0.05286246f, 0.03221087f, 0.05327052f, -0.05250719f, -0.00134563f, 
    0.03167741f, 0.06422797f, 0.01410711f, 0.00067533f, 0.02468193f, 0.02164212f, 0.00937134f, -0.03028486f, 
    -0.04899441f, 0.01462587f, 0.00470728f, -0.03710889f, 0.04158602f, -0.05732416f, -0.05532340f, -0.07521638f, 
    0.03520359f, -0.01595615f, -0.05390554f, -0.00628617f, -0.01009483f, 0.02634721f, -0.00113044f, 0.01638392f, 
    0.05779229f, -0.01922712f, -0.04400403f, 0.00462811f, 0.01544532f, -0.05224166f, -0.01541701f, 0.03069447f, 
    -0.03846832f, 0.05080559f, -0.03758259f, 0.01069755f, -0.01027093f, 0.00070816f, -0.06559612f, -0.04439215f, 
    0.04598126f, -0.02196088f, 0.03799837f, -0.01060336f, 0.00239811f, 0.00917644f, 0.01377092f, -0.06718562f, 
    0.05866052f, -0.00696272f, -0.05529471f, -0.04064444f, 0.02544183f, -0.02365311f, 0.00661664f, -0.05190391f, 
    -0.00630375f, -0.01763761f, 0.02540174f, -0.04772082f, -0.01350834f, -0.03838367f, 0.02970408f, -0.00889380f, 
    -0.07583887f, -0.05078567f, 0.01886530f, 0.03225251f, -0.02138333f, 0.03027199f, -0.03258709f, 0.01229186f, 
    -0.05837099f, 0.04835044f, -0.05172877f, 0.06672502f, 0.02333547f, 0.04457186f, 0.03251970f, -0.08056643f, 
    0.01426730f, 0.01374117f, -0.01465937f, -0.07884035f, -0.04764396f, -0.01555531f, -0.03739163f, -0.06921404f, 
    -0.05473528f, 0.04374796f, 0.03262191f, 0.03555857f, -0.05224040f, 0.01938231f, -0.00339103f, -0.05674722f, 
    -0.02561032f, 0.05420660f, -0.03589656f, 0.05918561f, 0.01856828f, -0.07466615f, -0.03013841f, -0.04345707f, 
    -0.02510330f, -0.00540250f, 0.02549473f, -0.07531177f, 0.02574487f, 0.01072530f, -0.03495050f, -0.07950827f, 
    -0.06909508f, -0.02628112f, -0.06605889f, 0.00360518f, 0.05478277f, -0.04393050f, -0.06239688f, -0.00406209f, 
    0.03432600f, -0.03893039f, -0.07835072f, 0.04315586f, 0.01130011f, -0.00527814f, 0.01088979f, 0.01468149f, 
    0.05783145f, -0.02475378f, 0.03532302f, 0.00731266f, -0.06109074f, -0.00559198f, -0.02093710f, -0.04159741f, 
    -0.05259971f, -0.04404952f, -0.04601555f, -0.00231824f, -0.01026978f, 0.01851225f, -0.01923802f, 0.04018933f, 
    0.04506534f, 0.03935194f, 0.05568338f, -0.02271256f, -0.01029896f, -0.01382107f, -0.00610592f, -0.07863032f, 
    -0.06690037f, -0.04793699f, 0.04568189f, 0.02008403f, -0.04664699f, -0.03268913f, -0.04942484f, 0.01748260f, 
    0.01340590f, 0.01198737f, -0.06701639f, -0.04040352f, -0.01259814f, -0.03644482f, -0.04950722f, -0.05976357f, 
    -0.07782058f, -0.01101563f, -0.03077671f, -0.06185395f, 0.03389421f, 0.04697856f, 0.04879819f, -0.01093711f, 
    0.04647063f, 0.05463026f, -0.04311334f, -0.03613541f, 0.03265086f, -0.03259586f, -0.02466728f, 0.02512239f, 
    -0.03503516f, -0.07858846f, -0.02728764f, 0.05421910f, -0.07042400f, -0.06457613f, 0.01301183f, -0.01042051f, 
    -0.01616680f, -0.03225097f, 0.05174697f, -0.05550098f, -0.05644028f, -0.05530952f, 0.03305967f, 0.04690534f, 
    0.04059270f, -0.04231293f, 0.05760071f, -0.02341833f, 0.02594189f, 0.05159204f, -0.02291487f, 0.03159876f, 
    -0.04621142f, -0.04544968f, -0.07517427f, -0.08312237f, 0.03547695f, -0.01671554f, 0.03697097f, 0.06195993f, 
    0.06997523f, -0.00644691f, -0.04202421f, -0.01360806f, -0.02332044f, 0.05915438f, -0.06118267f, -0.04680767f, 
    0.03919691f, 0.01630231f, -0.07156675f, -0.04111534f, 0.04212679f, -0.04438873f, 0.01844992f, -0.05109266f, 
    0.05137965f, 0.04564853f, -0.01589146f, 0.06797215f, 0.01315933f, 0.06458376f, -0.05876207f, 0.05172618f, 
    -0.05998324f, -0.07227579f, 0.03179852f, -0.02606051f, 0.01482653f, 0.01927254f, -0.07925250f, 0.06048236f, 
    0.01381307f, 0.05734418f, 0.04238950f, 0.00890609f, 0.03026120f, -0.04789824f, 0.04817097f, 0.06621756f, 
    -0.06171225f, 0.04546493f, 0.00253769f, 0.04259969f, -0.06553554f, 0.03856802f, -0.07213104f, -0.05742158f, 
    -0.06293655f, -0.05114437f, 0.00679107f, -0.00749183f, -0.03086216f, 0.05166591f, 0.03316376f, -0.05591086f, 
    0.06448244f, -0.06546579f, -0.04742552f, -0.05430966f, -0.03341669f, -0.03291276f, 0.00018286f, -0.05696925f, 
    -0.05486931f, 0.03642522f, 0.05958933f, -0.04317211f, 0.01701262f, 0.01975267f, 0.06283055f, -0.01295861f, 
    0.00380512f, -0.04996355f, -0.07056774f, 0.01462247f, -0.00344922f, -0.06290508f, 0.03475404f, -0.04784372f, 
    -0.05035114f, 0.04914310f, 0.02384109f, 0.05822982f, 0.06474505f, -0.06484091f, -0.04784568f, -0.03063248f, 
    0.04672986f, -0.00438871f, 0.05597369f, -0.00666978f, -0.01109383f, -0.02075991f, -0.06032277f, -0.01652093f, 
    -0.06285430f, 0.05534354f, -0.00322248f, 0.01666118f, 0.01135117f, -0.04881905f, 0.03294192f, 0.06551246f, 
    0.02083244f, 0.02062776f, -0.00593295f, -0.06483416f, -0.04803406f, -0.03140810f, -0.04985499f, -0.01710742f, 
    -0.02586310f, 0.06505095f, 0.02701154f, -0.05643394f, 0.05477791f, -0.04083883f, 0.01352366f, -0.01247648f, 
    -0.03636852f, 0.02392427f, -0.04406523f, 0.01578371f, -0.00528114f, 0.02459108f, -0.03396209f, -0.03176931f, 
    -0.06228822f, 0.02761685f, 0.03742727f, -0.02874819f, 0.00625212f, 0.03456746f, -0.01535495f, -0.07355733f, 
    0.02664088f, -0.05273193f, -0.03263825f, -0.06786247f, 0.05991965f, 0.01936659f, -0.03016633f, -0.03801487f, 
    -0.06079187f, -0.02637185f, -0.00177386f, -0.04734454f, -0.00860672f, 0.04741311f, -0.02563070f, -0.07425027f, 
    0.04078478f, -0.07931817f, -0.01903216f, 0.03131284f, -0.03796010f, 0.05588695f, 0.01273158f, -0.06780018f, 
    -0.04651154f, 0.06214873f, -0.02342804f, -0.01920382f, -0.07381213f, -0.04894727f, -0.03740860f, -0.05021627f, 
    -0.04773336f, -0.06344664f, -0.08021443f, 0.06207071f, -0.06816707f, 0.01296199f, -0.00976008f, -0.05141184f, 
    -0.04187276f, 0.01855046f, -0.02777331f, -0.02873645f, -0.06068955f, 0.03704654f, -0.06505533f, -0.03536874f, 
    -0.05472060f, 0.02681546f, 0.05765821f, 0.03397999f, -0.08105599f, -0.05302583f, -0.00026992f, -0.06362800f, 
    -0.01401766f, 0.04531559f, -0.01610386f, -0.00440454f, -0.02066736f, -0.04454380f, -0.03436790f, 0.07922113f, 
    -0.06931843f, -0.01373636f, -0.02857281f, 0.01370896f, -0.07992893f, -0.04060710f, -0.04159366f, -0.06690817f, 
    -0.00400139f, -0.05482612f, 0.06015256f, 0.06402648f, -0.04970937f, -0.06453363f, -0.07018118f, -0.06376011f, 
    -0.06385767f, -0.02791908f, 0.05061847f, 0.02419018f, -0.00351775f, 0.02553457f, 0.01020784f, -0.08206847f, 
    -0.02342280f, 0.01109252f, -0.02448690f, -0.01006227f, -0.00867866f, 0.06075197f, -0.04583531f, -0.05430403f, 
    -0.00613634f, -0.00803550f, -0.02530101f, -0.05413955f, -0.05664040f, -0.04724528f, -0.00570811f, -0.05107452f, 
    -0.04294185f, -0.05750070f, -0.07248843f, 0.01184239f, -0.03548340f, 0.00870209f, -0.00367505f, 0.05683358f, 
    0.05014044f, 0.02104645f, -0.03877239f, -0.06489900f, -0.06681851f, 0.00628906f, 0.00569624f, -0.05145244f, 
    -0.05365107f, 0.07400683f, -0.04831383f, 0.01915305f, -0.04022057f, -0.06276172f, -0.00332682f, -0.03146458f, 
    -0.06211026f, -0.07461719f, 0.05498261f, 0.04021901f, -0.08092845f, -0.06775164f, -0.07490762f, 0.03593598f, 
    0.02863381f, -0.03475309f, 0.04172147f, 0.00084769f, 0.03967150f, -0.07861426f, 0.05504504f, 0.02211960f, 
    -0.00840154f, 0.04089843f, 0.02705231f, -0.00442243f, 0.01737335f, 0.04370436f, -0.04318445f, 0.01462183f, 
    0.00410250f, 0.01775307f, 0.04753974f, -0.02545124f, -0.03867609f, 0.00000880f, 0.01881684f, 0.01367228f, 
    -0.00471908f, 0.00224707f, 0.02579951f, 0.05968768f, -0.00262927f, 0.01079868f, -0.02558637f, 0.03450998f, 
    0.00428724f, -0.08041236f, 0.00544115f, 0.03749005f, -0.02798133f, 0.05533553f, -0.04658437f, -0.02007558f, 
    0.01035704f, -0.03951166f, -0.00192272f, -0.05664803f, 0.04324612f, -0.01075707f, -0.05756821f, -0.04158431f, 
    -0.04809868f, -0.00279496f, -0.06053180f, -0.01615215f, -0.04747899f, 0.06085004f, -0.00752287f, 0.03329409f, 
    -0.03340314f, 0.05787361f, -0.04299976f, 0.00316672f, -0.00814916f, -0.05497988f, -0.05287376f, 0.02494479f, 
    -0.07327875f, -0.07046605f, 0.05129423f, 0.01667743f, -0.00161482f, -0.03604640f, -0.02951649f, -0.00940638f, 
    -0.00465105f, -0.05164245f, 0.04502018f, 0.05963497f, 0.01468316f, 0.01015235f, 0.03752611f, -0.03501769f, 
    -0.00598973f, -0.05608953f, 0.01936133f, -0.04588041f, -0.06678142f, -0.06546216f, 0.06889372f, -0.03622522f, 
    0.00907071f, -0.01075515f, 0.00018456f, -0.04989994f, -0.00472069f, 0.00156016f, -0.01915552f, -0.04795443f, 
    -0.04090813f, -0.02534252f, 0.06216190f, -0.05494611f, -0.00301742f, -0.07795236f, -0.04920653f, -0.02851802f, 
    0.04103412f, -0.05172004f, 0.01885181f, 0.00771514f, -0.01684628f, 0.00870968f, -0.00811246f, 0.06920275f, 
    -0.01407664f, -0.04724065f, 0.26124108f, 0.32490736f, -0.06656186f, -0.03582219f, -0.00192764f, 0.05860746f, 
    0.00149447f, -0.03312808f, 0.03286649f, -0.00746774f, -0.19740936f, -0.05680948f, -0.15296541f, 0.21903813f, 
    0.06458509f, 0.04336869f, 0.01596940f, 0.16960582f, 0.03022771f, -0.05017636f, 0.08339918f, 0.00893673f, 
    -0.10838988f, -0.06446158f, -0.04627825f, 0.05300142f, 0.15523218f, 0.15700021f, 0.12940003f, 0.10181159f, 
    0.02032511f, -0.11213475f, -0.00216265f, 0.03185732f, 0.09059632f, -0.11311514f, 0.10017066f, -0.28831992f, 
    0.28809130f, -0.01121077f, -0.17846657f, -0.02377684f, 0.04065444f, 0.06305341f, -0.12965837f, -0.02826606f, 
    -0.22516683f, 0.04346349f, -0.05798021f, -0.00965757f, -0.11628612f, 0.00219072f, -0.09020308f, -0.08010086f, 
    0.05010244f, -0.05089942f, -0.03696008f, 0.01996185f, -0.02134367f, 0.33752194f, 0.19316280f, 0.05050027f, 
    -0.19040063f, -0.09305261f, -0.05708672f, -0.19176313f, -0.04987910f, 0.27296776f, 0.19242282f, 0.12705202f, 
    -0.10802796f, 0.12013892f, -0.23205200f, 0.03062787f, 0.04432813f, -0.00949057f, 0.01960543f, -0.00169441f, 
    0.12289967f, 0.09029572f, 0.14415023f, 0.15187727f, 0.00863273f, -0.01929904f, -0.16049483f, -0.16209912f, 
    0.10473077f, 0.21830730f, 0.22543932f, -0.04509576f, 0.06900036f, -0.12804186f, 0.02147469f, 0.07729286f, 
    0.19974993f, -0.30074617f, 0.00055569f, 0.05788537f, 0.12349165f, 0.02490656f, -0.01647174f, 0.08212367f, 
    -0.03178672f, -0.01663244f, -0.12992698f, 0.09399949f, -0.11252979f, -0.15662166f, 0.37011912f, 0.26933104f, 
    -0.02158883f, -0.04692300f, -0.06864466f, 0.08043623f, -0.05055974f, 0.19066128f, 0.16826731f, 0.05994499f, 
    -0.13630961f, -0.06444779f, -0.08343741f, -0.04438964f, 0.06311655f, -0.07918935f, -0.09408706f, -0.07025927f, 
    -0.13624434f, -0.08594249f, 0.00510419f, -0.07084236f, 0.01055620f, 0.11471403f, -0.03392310f, -0.24700934f, 
    0.05687357f, 0.15291759f, -0.01405023f, 0.03377628f, 0.09631308f, 0.14518267f, -0.04813266f, -0.00187000f, 
    0.05266105f, -0.13162610f, -0.11559658f, 0.04010012f, 0.03310727f, 0.11117938f, 0.07332886f, 0.17431667f, 
    0.05048881f, -0.07797452f, -0.18944517f, -0.05511299f, -0.00365474f, -0.14126500f, 0.15304410f, -0.07048861f, 
    0.10708835f, -0.08153202f, -0.04171252f, 0.00480439f, -0.05594037f, 0.13062218f, 0.06020463f, -0.07124057f, 
    0.11141566f, -0.12214492f, -0.12842299f, -0.19281323f, 0.04606097f, 0.07194924f, 0.04078051f, 0.09205214f, 
    0.11341243f, -0.06583273f, -0.10897211f, -0.06855427f, 0.21319434f, 0.41000909f, 0.38014019f, -0.10072763f, 
    -0.10584521f, 0.03684071f, -0.06916460f, 0.01696217f, -0.09999944f, 0.17899029f, 0.02893541f, 0.13276662f, 
    0.38004738f, 0.10600034f, 0.19836318f, 0.25068071f, 0.04004093f, 0.11223739f, 0.06104613f, 0.02378643f, 
    0.01245916f, 0.08499899f, 0.12713428f, -0.00518537f, 0.02997279f, 0.06477457f, -0.01866197f, -0.09132192f, 
    -0.05410442f, 0.01736335f, -0.02674808f, -0.14956088f, -0.09371068f, -0.08347613f, -0.06353713f, -0.06800916f, 
    -0.14551987f, 0.00062356f, -0.09404201f, -0.06814361f, -0.09297141f, -0.10528620f, 0.01533915f, -0.17374900f, 
    0.03284420f, -0.06604706f, 0.02963646f, -0.27212137f, 0.18999371f, -0.02802698f, 0.22064358f, 0.02153385f, 
    0.08841351f, -0.02841729f, 0.06137514f, 0.09702710f, -0.00324107f, -0.00973872f, 0.09301466f, -0.02378919f, 
    0.11543877f, 0.21623884f, 0.08178358f, 0.07097111f, -0.13011917f, 0.06407075f, 0.01617575f, -0.01081985f, 
    -0.01018278f, 0.00412915f, -0.11262657f, 0.03852318f, 0.06893240f, 0.09497713f, 0.00501545f, -0.01845836f, 
    -0.01431962f, 0.06300934f, 0.01479483f, -0.00856944f, 0.11171733f, 0.06944132f, -0.11376850f, 0.02308821f, 
    -0.17096864f, -0.07144740f, -0.03766055f, -0.19022366f, -0.08428226f, -0.07216554f, 0.01213065f, -0.00025318f, 
    0.00455684f, -0.02484983f, 0.04097521f, 0.15559249f, 0.01508047f, 0.01540159f, -0.62076277f, -0.34165666f, 
    0.02932499f, -0.08549248f, -0.10874417f, 0.05896647f, -0.05009990f, -0.05850646f, -0.02698995f, 0.15928073f, 
    -0.21593919f, -0.23215468f, -0.03894847f, -0.17410865f, -0.15154324f, 0.02845623f, -0.14648853f, -0.10077551f, 
    -0.08596632f, -0.15969682f, 0.12308238f, -0.07037618f, -0.01418221f, -0.16357423f, 0.02469468f, -0.20225050f, 
    -0.11868726f, 0.07142676f, 0.00787328f, -0.09974422f, -0.06752518f, 0.13275449f, 0.12194210f, -0.00559364f, 
    0.06790354f, 0.29642475f, 0.10650416f, 0.28677529f, -0.01624048f, -0.02124847f, 0.13745566f, 0.22799431f, 
    -0.04686753f, 0.15767795f, 0.00702991f, 0.06667497f, 0.17668620f, 0.19492291f, 0.16065797f, 0.04548338f, 
    0.11274835f, 0.01896913f, -0.03436514f, 0.23201624f, 0.04755897f, -0.11649147f, 0.08819392f, 0.07352601f, 
    0.07899215f, 0.06785882f, -0.20456196f, 0.13361739f, -0.04363107f, -0.14006168f, -0.04446635f, -0.07898536f, 
    -0.07319683f, 0.24060564f, -0.08370473f, -0.08095754f, 0.32509568f, -0.07126055f, 0.29981571f, 0.19084249f, 
    0.02723300f, 0.05081799f, 0.03537376f, 0.03920949f, 0.05294106f, 0.01161274f, 0.07641837f, -0.09503271f, 
    -0.08495259f, -0.73906159f, -0.30806935f, 0.04917152f, -0.13156527f, -0.00153454f, 0.03166005f, 0.06590982f, 
    -0.16961993f, -0.09859428f, 0.02506829f, -0.03478346f, 0.24871604f, 0.07472326f, -0.10571078f, -0.05019639f, 
    -0.00719131f, 0.04936324f, -0.04664698f, 0.04185913f, 0.09864714f, -0.08444367f, -0.08435167f, 0.00882785f, 
    -0.00271062f, -0.05955931f, 0.08691892f, 0.08480744f, -0.03810383f, 0.02779089f, 0.01318870f, -0.05597087f, 
    -0.01777865f, 0.27217066f, 0.12376390f, 0.17173016f, -0.02517963f, 0.02145933f, -0.27632838f, -0.22972232f, 
    0.05186061f, 0.01507770f, -0.07571499f, 0.17070356f, 0.01947695f, 0.05844292f, -0.10314498f, 0.03672175f, 
    0.07155045f, -0.08169857f, -0.08603563f, -0.12408782f, -0.14353810f, -0.18684335f, 0.04383827f, 0.09362593f, 
    -0.10811222f, -0.15070730f, -0.15822060f, -0.18101774f, -0.06827223f, -0.14592260f, 0.23292725f, 0.02257371f, 
    -0.07673920f, -0.18860959f, 0.21987608f, -0.15462793f, -0.02666368f, -0.07723965f, -0.12403513f, 0.01527804f, 
    -0.11889452f, -0.15937397f, -0.08572643f, 0.08265983f, -0.05189718f, 0.04547188f, -0.01838590f, 0.13324304f, 
    0.02948091f, -0.05711788f, -0.09270008f, -0.00871847f, -0.12560749f, 0.03599535f, 0.09043823f, 0.22085933f, 
    -0.03712850f, -0.06289855f, 0.12202892f, 0.08128538f, -0.00425839f, -0.15801273f, 0.10350265f, 0.27367914f, 
    0.48891857f, 0.16371445f, 0.10169381f, -0.07064618f, -0.08835202f, 0.09289791f, 0.03820836f, -0.19210286f, 
    -0.20221382f, 0.22776586f, 0.16438723f, 0.16876499f, 0.10266023f, -0.06113470f, 0.18016376f, 0.36570928f, 
    -0.03109453f, -0.00911597f, 0.01790759f, 0.02085287f, -0.03737691f, -0.13655196f, -0.10225672f, 0.03521981f, 
    0.09729128f, 0.25209597f, -0.04977197f, 0.32033563f, 0.16242683f, 0.06939346f, -0.08243817f, -0.24016812f, 
    0.02936640f, 0.05940377f, 0.12377144f, 0.04991137f, -0.08727160f, 0.21191348f, -0.01544330f, -0.28799057f, 
    -0.36084014f, 0.19248909f, -0.11334769f, -0.15391697f, -0.05941377f, 0.06278802f, -0.08393688f, -0.01285781f, 
    0.00405353f, -0.30255839f, -0.11347859f, 0.29218131f, -0.07421023f, -0.01800518f, -0.03374406f, 0.16776291f, 
    -0.02864359f, 0.03128648f, 0.11670862f, -0.00762765f, -0.14523657f, -0.07582387f, -0.04108464f, 0.22842215f, 
    0.13142501f, 0.13598329f, 0.07907985f, 0.07035479f, 0.07734601f, 0.07015805f, 0.10738969f, 0.08290389f, 
    0.03867849f, -0.12979823f, -0.02928719f, 0.02736211f, -0.01742893f, 0.04362338f, -0.00871132f, 0.05808711f, 
    -0.12797545f, -0.08753050f, -0.18354805f, -0.03799587f, 0.02643054f, 0.09847483f, 0.07363830f, 0.06333886f, 
    0.01356352f, 0.07615065f, 0.25468883f, 0.00996675f, 0.03046186f, -0.07054311f, 0.02127137f, 0.07804501f, 
    0.22334786f, 0.30372295f, 0.10995081f, -0.31382081f, 0.24753490f, -0.05158406f, -0.17888546f, -0.03558393f, 
    -0.06406915f, 0.01861967f, -0.07427690f, -0.18726611f, 0.02925376f, 0.10497696f, 0.15106465f, 0.15620287f, 
    -0.16462310f, -0.10181488f, 0.02128774f, -0.22419263f, 0.00075490f, -0.04635746f, -0.02063473f, 0.04493456f, 
    0.01138522f, -0.07710452f, -0.12807505f, -0.12370329f, 0.05974850f, 0.00161040f, 0.00779895f, 0.01494439f, 
    0.27220258f, 0.11268597f, 0.01023618f, 0.04398576f, -0.07378365f, -0.08135775f, 0.35228670f, 0.25852281f, 
    -0.01094876f, -0.03804312f, 0.13090745f, 0.06609187f, -0.05346077f, -0.06139918f, 0.03296721f, -0.07304925f, 
    -0.00807328f, -0.16365643f, 0.02451737f, 0.08436893f, 0.15845695f, 0.02585762f, -0.10227661f, -0.04156127f, 
    -0.06246271f, -0.01758876f, -0.13794053f, 0.12593414f, -0.00696162f, -0.06466565f, -0.15849179f, -0.08100677f, 
    -0.00453425f, -0.05569110f, -0.13601905f, -0.22193334f, -0.01575752f, -0.04370401f, 0.01482317f, -0.10301432f, 
    0.03856098f, 0.19411440f, 0.10995685f, -0.07657492f, 0.11658582f, 0.03756496f, 0.19672979f, 0.04967721f, 
    0.02969291f, 0.06115175f, -0.00349341f, -0.05364696f, 0.07578681f, 0.12600756f, -0.05135756f, -0.21832892f, 
    0.01304070f, 0.14720576f, 0.15180336f, 0.14229934f, 0.02696334f, 0.00817899f, -0.09949762f, -0.09695089f, 
    -0.27039871f, -0.09071551f, -0.10912161f, 0.14968887f, 0.03443596f, 0.09605692f, 0.01274174f, 0.08851244f, 
    -0.09957198f, -0.10699406f, 0.04497363f, -0.00314796f, 0.24830468f, 0.01330039f, -0.30885857f, -0.19551937f, 
    0.16589662f, 0.15185016f, 0.12551957f, -0.02146776f, -0.13914056f, 0.01848317f, 0.05106712f, -0.12907086f, 
    -0.06701837f, -0.41084230f, 0.25903672f, -0.04377823f, 0.02426457f, -0.02163530f, -0.02011246f, -0.03677127f, 
    0.00194286f, -0.09639756f, 0.00172221f, -0.00231986f, 0.17655225f, -0.44685429f, 0.08119328f, 0.17487133f, 
    -0.03091466f, -0.19384624f, -0.11721350f, 0.07594305f, 0.20863710f, 0.02181819f, 0.09920793f, 0.03018177f, 
    0.10684691f, 0.10411047f, 0.30554238f, -0.06332516f, 0.08796335f, 0.09009406f, -0.03530550f, -0.20477808f, 
    0.18857193f, -0.07099667f, 0.01139928f, 0.03792789f, 0.19607385f, 0.00635223f, 0.07435866f, -0.04614887f, 
    -0.01803234f, 0.22449087f, 0.22089010f, 0.10259666f, -0.05840704f, -0.09082190f, 0.10763544f, -0.00142629f, 
    -0.00709049f, -0.02462842f, 0.19107884f, -0.03027430f, 0.07798821f, -0.08869480f, -0.08029117f, 0.09073488f, 
    0.13182141f, -0.11323195f, -0.11705346f, -0.00396565f, -0.24345179f, 0.13308230f, -0.18936533f, -0.01110341f, 
    -0.00165808f, 0.02825452f, -0.19621998f, 0.14430375f, 0.04847555f, -0.01780784f, -0.14065333f, 0.14840767f, 
    0.07247365f, 0.09669321f, -0.54720026f, 0.15952347f, 0.18030931f, 0.04770427f, -0.00631288f, -0.14751568f, 
    0.00495899f, -0.07294240f, 0.03299385f, -0.02055962f, 0.00428784f, -0.11103574f, 0.13385738f, -0.02995800f, 
    -0.11099994f, 0.01232097f, 0.01283059f, -0.03041124f, 0.11535381f, 0.02944440f, 0.06392366f, 0.03878054f, 
    0.05441979f, 0.43836719f, 0.14921439f, 0.30381277f, 0.12463488f, 0.11020709f, -0.03926528f, -0.04320782f, 
    -0.03026393f, 0.00917530f, 0.10014121f, -0.01836615f, -0.17035918f, 0.19146614f, 0.24929501f, 0.15540662f, 
    0.01954458f, -0.00712267f, -0.00858746f, 0.13470273f, 0.08192065f, 0.03271101f, -0.07791882f, -0.03112490f, 
    -0.16714151f, -0.12270247f, -0.40405685f, -0.14479752f, 0.00741806f, 0.01056742f, 0.00113418f, -0.18776765f, 
    0.06027884f, 0.09436497f, -0.09568636f, 0.14715284f, -0.00084497f, 0.09560277f, -0.10072212f, -0.18305621f, 
    0.21881829f, 0.04561932f, 0.14713186f, 0.10681499f, 0.17263733f, 0.16715123f, -0.02168258f, 0.01355862f, 
    0.23866816f, 0.16951562f, 0.01090454f, -0.17102565f, 0.10600907f, 0.19891709f, -0.01959909f, 0.15668462f, 
    0.06389376f, -0.04364739f, 0.06455391f, 0.09723136f, 0.07117566f, 0.02453978f, 0.00262320f, -0.16876552f, 
    0.03699355f, 0.02646167f, -0.03863776f, -0.01136666f, -0.03081319f, 0.08514818f, 0.08999625f, 0.11975919f, 
    -0.43202567f, -0.17492650f, -0.17018270f, 0.16239327f, -0.04130960f, 0.08519236f, 0.00313771f, -0.01183351f, 
    0.09746480f, 0.07953531f, 0.04998602f, 0.11554996f, -0.32976508f, -0.22314142f, -0.02782016f, -0.27527970f, 
    -0.12785551f, -0.04611373f, -0.05959371f, 0.19098227f, 0.03374709f, -0.21842761f, 0.12259962f, 0.02100574f, 
    0.07201555f, -0.28565142f, -0.05429248f, -0.16626261f, -0.14732783f, -0.06114376f, -0.15485959f, 0.06443173f, 
    0.00586799f, 0.03969736f, 0.09134964f, -0.02442932f, -0.38754827f, 0.12716720f, -0.02718150f, 0.30516410f, 
    0.09402187f, -0.10291996f, -0.07975589f, -0.02979961f, -0.01286852f, -0.02303409f, 0.03182506f, 0.07024873f, 
    0.06275992f, 0.08105671f, 0.13024282f, -0.03577997f, 0.15563989f, 0.09340351f, 0.03644678f, 0.14576364f, 
    -0.12042999f, -0.16831604f, -0.12802996f, -0.16541833f, 0.25823110f, 0.22945721f, 0.18207061f, -0.00513005f, 
    0.00928354f, 0.17339846f, 0.01129029f, -0.00042572f, -0.06444889f, -0.04138087f, 0.02228520f, 0.12676148f, 
    -0.11409520f, -0.20167361f, 0.09997895f, -0.05157334f, 0.05343353f, 0.14900656f, -0.04211079f, 0.07396213f, 
    0.16820842f, -0.08461843f, 0.15014064f, 0.03750600f, 0.49091020f, 0.03958819f, -0.20054308f, 0.05098300f, 
    0.07239692f, -0.16286002f, 0.09910952f, -0.06361645f, 0.05362152f, -0.08492335f, -0.15708923f, -0.05233143f, 
    -0.45347139f, -0.36333123f, -0.25491047f, -0.07932428f, 0.02826222f, -0.15487786f, -0.03455539f, 0.07684067f, 
    -0.01110585f, -0.01213130f, -0.08387525f, 0.10521652f, 0.14741533f, 0.07940943f, 0.22163071f, -0.15316963f, 
    0.03106703f, 0.01338455f, 0.04328616f, 0.07743301f, -0.06979750f, 0.12280132f, 0.01857293f, 0.13071291f, 
    -0.08476827f, 0.05679480f, -0.07977622f, -0.02189132f, 0.09683280f, 0.12949644f, 0.18660331f, -0.01220702f, 
    0.16195703f, -0.01526679f, 0.03714164f, -0.18293288f, -0.03960701f, 0.32180580f, 0.12678142f, 0.11235590f, 
    0.13685213f, -0.04983572f, 0.02833639f, 0.13717937f, 0.13733259f, 0.20793910f, -0.07424872f, 0.06058097f, 
    -0.03320681f, 0.01969625f, -0.14784577f, -0.02252595f, 0.10262085f, 0.00492328f, -0.10035138f, -0.15974440f, 
    0.04192272f, 0.10577708f, 0.04898190f, 0.18669339f, -0.11808094f, -0.17252301f, -0.07267758f, -0.16249801f, 
    -0.14054333f, -0.02133458f, -0.00371778f, -0.03299216f, 0.19058481f, 0.04358007f, -0.00319577f, 0.13157795f, 
    0.09897263f, 0.08474680f, -0.11481998f, -0.14095719f, 0.21697089f, 0.06750496f, -0.04855774f, 0.26614228f, 
    0.02185206f, 0.00113325f, 0.01606817f, 0.14184773f, 0.03379827f, -0.13030933f, -0.16903670f, -0.07645344f, 
    0.05067702f, 0.06141528f, 0.05765777f, 0.02747569f, -0.00210190f, -0.06698409f, 0.06518219f, -0.15109675f, 
    -0.22675122f, 0.01690302f, -0.11052768f, 0.19776772f, 0.09279302f, -0.00456769f, 0.00605153f, 0.06557847f, 
    -0.01524756f, -0.10985376f, -0.10229639f, -0.06387180f, -0.28361782f, 0.12270907f, 0.16234741f, -0.23279889f, 
    0.16452137f, 0.01325591f, -0.24045788f, 0.02423297f, -0.03831124f, -0.14788340f, -0.04829845f, -0.07126509f, 
    0.03675609f, -0.06111396f, 0.36759290f, -0.07499041f, -0.08445945f, -0.04700703f, -0.17939408f, -0.06082803f, 
    -0.06859531f, 0.03150019f, -0.05070233f, -0.18338609f, 0.18807463f, -0.08168029f, -0.07260978f, 0.18337971f, 
    -0.15191388f, -0.14591806f, -0.04527232f, 0.03153393f, 0.19345713f, -0.12455640f, 0.11534926f, 0.07976503f, 
    0.16688649f, -0.18836977f, -0.00544078f, -0.14259572f, 0.05000884f, 0.09482629f, 0.19969839f, 0.07700446f, 
    0.10751634f, 0.05533459f, 0.07565875f, 0.02578741f, 0.19188657f, 0.10345515f, 0.00146688f, -0.03552411f, 
    0.05522280f, 0.15107507f, 0.01178135f, -0.09442721f, 0.08485577f, -0.04837944f, -0.04520243f, -0.06990823f, 
    0.03151913f, -0.13547534f, 0.07639393f, -0.20542681f, -0.00639528f, 0.14113222f, -0.01926146f, 0.04126605f, 
    0.21763761f, -0.06142616f, 0.22279778f, 0.06570775f, 0.09073668f, -0.18318479f, -0.17807244f, 0.16118394f, 
    0.01198700f, -0.07445165f, 0.07997512f, 0.12149937f, 0.23243335f, -0.03622584f, 0.06791072f, 0.00875105f, 
    -0.16833012f, 0.21870196f, -0.09579529f, 0.07553492f, 0.01960544f, -0.04531582f, -0.01475316f, 0.00980044f, 
    -0.04240333f, -0.13054791f, -0.05610066f, 0.10365476f, 0.10002175f, -0.16487837f, 0.00233912f, -0.14067745f, 
    0.06067528f, -0.01714893f, 0.11709689f, -0.00895190f, 0.07925297f, -0.06935361f, 0.10453048f, 0.08993447f, 
    0.03796981f, 0.05563299f, -0.05429415f, 0.01152706f, 0.03800503f, -0.00986032f, 0.01533239f, -0.06706723f, 
    -0.07944462f, -0.03914855f, -0.04662988f, 0.04792621f, 0.02618591f, 0.03664195f, 0.00911891f, -0.00404682f, 
    -0.02312521f, 0.03978404f, -0.05369763f, -0.02032454f, -0.05510188f, -0.07652017f, 0.00841125f, 0.02616107f, 
    -0.07527525f, -0.01848476f, -0.06087683f, 0.02731377f, -0.06135054f, -0.05285140f, 0.01635456f, -0.04437193f, 
    -0.06451307f, 0.00664527f, 0.01472086f, 0.04803653f, 0.04345939f, 0.02039113f, 0.04335430f, -0.07460775f, 
    -0.00535936f, -0.04706417f, -0.06308611f, -0.02770269f, -0.01777358f, 0.03231478f, -0.06979132f, -0.00909289f, 
    0.05422270f, 0.01343223f, -0.04921174f, -0.01622738f, -0.08002387f, 0.00629364f, 0.03137347f, -0.05227799f, 
    0.05023018f, -0.07922570f, -0.00928628f, -0.06342059f, 0.00078954f, -0.05974179f, 0.00696534f, -0.08379795f, 
    -0.02118214f, -0.03998005f, -0.04051198f, -0.04827299f, 0.00333247f, -0.00281199f, 0.01878974f, 0.02204386f, 
    0.02733530f, -0.05140257f, 0.04308143f, 0.05245250f, 0.05482218f, -0.05526796f, -0.04018828f, -0.02233884f, 
    0.05762000f, 0.00833838f, 0.05118434f, -0.07006468f, 0.02387356f, 0.03091769f, 0.02561022f, 0.02367375f, 
    -0.00499331f, -0.06285072f, -0.08312531f, 0.03878995f, -0.00451977f, -0.03513655f, 0.02875028f, -0.02164537f, 
    0.03005438f, 0.04049788f, -0.05790025f, -0.05636312f, -0.01747393f, 0.00384297f, 0.02378378f, 0.05017138f, 
    0.00444936f, 0.04979524f, 0.01274948f, -0.01916534f, -0.03722227f, -0.02352803f, -0.05411406f, -0.00289076f, 
    -0.01331637f, -0.02707737f, -0.02263407f, -0.05696917f, -0.02274963f, 0.04129089f, -0.03480836f, 0.01717839f, 
    0.05492095f, -0.00341723f, -0.00172847f, 0.01585922f, -0.00500571f, 0.01815161f, -0.06991716f, 0.04396361f, 
    0.00834982f, -0.06299671f, 0.04972988f, 0.00335508f, 0.01281174f, -0.00078885f, 0.01653260f, -0.00440753f, 
    0.02428538f, -0.07186781f, -0.01534895f, -0.00674741f, 0.02968601f, -0.01476777f, -0.02788464f, -0.05109821f, 
    -0.04573135f, 0.02322107f, -0.04476591f, -0.01926354f, 0.05098057f, -0.04029349f, 0.03422680f, -0.00173432f, 
    -0.05930291f, 0.01400709f, 0.04905956f, -0.02487041f, -0.06372875f, -0.02903789f, -0.05288265f, -0.03084669f, 
    0.03014708f, 0.02006910f, -0.01260264f, -0.01404066f, 0.03681242f, -0.03067865f, -0.02292190f, 0.06206865f, 
    -0.05952033f, 0.02691752f, -0.04567802f, 0.06093471f, 0.05435877f, -0.06496619f, 0.03461388f, 0.05560891f, 
    -0.05468591f, -0.03781472f, 0.00611164f, 0.05131193f, 0.02426891f, -0.00152112f, 0.02523775f, -0.05309163f, 
    -0.06516003f, -0.08072707f, 0.06314657f, -0.04553698f, 0.00960791f, -0.04958048f, 0.05398691f, 0.04147834f, 
    0.09756119f, 0.06731179f, 0.22665355f, 0.25267354f, 0.09267851f, 0.04808925f, 0.06893913f, 0.22519876f, 
    -0.04238735f, 0.09077709f, -0.00555392f, 0.02802469f, -0.28763542f, 0.09371357f, -0.26799786f, 0.05070127f, 
    0.12137586f, 0.03252246f, 0.00975781f, 0.11345825f, -0.00526262f, -0.07760300f, -0.11419697f, 0.10068076f, 
    0.00397750f, 0.11286791f, -0.11567516f, 0.02416019f, -0.03501339f, -0.06091044f, 0.02178928f, -0.21190278f, 
    0.07918123f, 0.11193938f, 0.10024621f, 0.04338683f, 0.09881467f, 0.00971350f, 0.18915197f, -0.14504682f, 
    -0.00175083f, 0.04778561f, 0.00610388f, 0.18099493f, 0.09009021f, 0.15759957f, 0.00138901f, 0.18662076f, 
    -0.13069981f, -0.19222002f, -0.05361586f, -0.02566847f, 0.07284238f, 0.11260673f, -0.05626759f, 0.15966821f, 
    -0.07078174f, -0.06905078f, -0.11235227f, -0.02166854f, -0.20367794f, -0.07054807f, 0.06999646f, -0.15728621f, 
    -0.04786401f, 0.12662086f, 0.08736876f, -0.00109237f, 0.03023712f, 0.02716276f, 0.07098540f, -0.17171861f, 
    -0.00713688f, 0.27821845f, 0.06000481f, 0.06639678f, -0.05518480f, -0.03376446f, 0.05355758f, -0.04135283f, 
    0.05290776f, 0.05938687f, -0.01228504f, -0.04597215f, -0.20872900f, 0.09953006f, 0.14881156f, -0.22641654f, 
    -0.22314395f, -0.02560638f, -0.07355937f, 0.11735766f, -0.01629372f, -0.04337292f, 0.02696567f, 0.04684951f, 
    0.19256614f, -0.03859719f, 0.11818368f, -0.04090001f, -0.06129498f, 0.03730806f, -0.10037061f, -0.05951405f, 
    -0.01296968f, -0.05916692f, 0.06719838f, -0.11956279f, -0.04878232f, 0.12484142f, -0.10408878f, 0.10195851f, 
    0.03652158f, 0.02860466f, -0.11496943f, -0.09577373f, -0.00053718f, 0.08936188f, -0.00488104f, -0.02491252f, 
    -0.28612238f, -0.16420554f, -0.15127552f, 0.20508936f, -0.00116463f, -0.12678900f, 0.11784081f, 0.25132108f, 
    -0.14010434f, -0.02722243f, 0.01238175f, -0.02045304f, 0.07992613f, 0.19160239f, 0.18979929f, -0.07264487f, 
    -0.01005175f, 0.02951951f, 0.04198442f, -0.00417484f, -0.01117402f, -0.16862407f, -0.13347253f, 0.00063259f, 
    -0.01998582f, -0.17905815f, -0.05022710f, -0.04628341f, -0.08968364f, 0.07138956f, -0.04729667f, 0.00173996f, 
    0.02183580f, 0.11117940f, 0.17176114f, 0.04120905f, 0.44054800f, -0.00796080f, 0.16184679f, 0.18628609f, 
    0.00390536f, -0.08646740f, 0.22914962f, 0.00634989f, 0.05582312f, 0.07592577f, 0.01683818f, -0.00839934f, 
    0.20774063f, 0.13411848f, 0.38476294f, -0.29234925f, -0.23429346f, -0.06337058f, -0.08498414f, 0.09809528f, 
    -0.00013880f, 0.00030294f, 0.08134829f, -0.04580505f, 0.26965562f, 0.03565651f, 0.08780244f, -0.14912166f, 
    -0.04416575f, -0.13866946f, 0.01223322f, 0.19849125f, -0.05269535f, 0.05418279f, 0.06652576f, 0.02583307f, 
    -0.11251292f, -0.00137597f, -0.03035726f, -0.04472873f, 0.09880553f, 0.13687371f, 0.08200037f, -0.13381082f, 
    0.03601366f, 0.01451944f, -0.07560216f, 0.05704679f, 0.00836060f, 0.25458449f, 0.07522721f, 0.02012565f, 
    0.09852781f, -0.01243225f, 0.12430863f, 0.03920499f, 0.12332444f, 0.11722129f, -0.01996084f, -0.02217674f, 
    -0.02187477f, -0.11111217f, -0.16754280f, 0.15792678f, 0.06239963f, -0.04461136f, 0.05198023f, 0.06668612f, 
    0.00814639f, 0.00029497f, -0.01189052f, 0.14392363f, -0.22899778f, -0.23149067f, -0.04967663f, -0.03891336f, 
    -0.01215972f, -0.04624961f, 0.04152421f, -0.15759782f, 0.20737751f, 0.10806403f, -0.04129655f, 0.09813026f, 
    0.13101247f, 0.18975390f, -0.20527802f, -0.26505533f, 0.14856553f, 0.16700456f, -0.04476412f, -0.10047996f, 
    0.02286065f, -0.05482272f, -0.06020083f, 0.03371369f, 0.08094804f, 0.32712486f, -0.00252882f, -0.17591827f, 
    -0.04160807f, 0.08751984f, 0.08466235f, 0.01941563f, -0.21875109f, -0.03083044f, -0.05863815f, 0.08971061f, 
    -0.34698632f, -0.10949436f, -0.10532655f, 0.10144522f, 0.00317813f, -0.00596323f, -0.05183390f, 0.05486044f, 
    -0.05194066f, 0.00753674f, 0.04415602f, 0.18178442f, 0.21122083f, -0.16771512f, -0.19352907f, -0.25706118f, 
    0.13425808f, 0.04099735f, 0.09265501f, -0.03122292f, -0.12410611f, -0.09704891f, 0.00427565f, -0.00030197f, 
    -0.06236639f, -0.39055541f, 0.14148158f, 0.11386909f, 0.04005894f, -0.02760190f, -0.05531485f, 0.02148746f, 
    -0.05577683f, -0.18471226f, 0.01687247f, -0.11588147f, -0.03757896f, -0.18762401f, 0.25607476f, 0.22167328f, 
    -0.02972627f, -0.04725276f, -0.07324071f, 0.01165070f, 0.26425633f, 0.13949481f, 0.18672161f, 0.05523621f, 
    0.04366390f, -0.19037443f, -0.08454322f, -0.40806919f, 0.08808395f, -0.18428048f, -0.01669948f, -0.12843667f, 
    0.11984151f, -0.12391889f, 0.07161648f, -0.03446687f, 0.09974906f, 0.08640497f, -0.04602431f, -0.00513245f, 
    0.07971619f, 0.20626476f, 0.18145387f, -0.05532399f, 0.02539977f, 0.10558770f, 0.06642791f, 0.12857376f, 
    0.14352204f, -0.22220051f, 0.09341606f, -0.10711794f, 0.17859191f, 0.07177918f, 0.07801227f, 0.18327966f, 
    0.07755972f, -0.10628030f, -0.05671002f, -0.08577141f, -0.02731560f, -0.27652544f, 0.00932807f, -0.00557130f, 
    0.09993511f, -0.07879778f, -0.10677995f, 0.13866507f, 0.05081323f, -0.08556656f, 0.17312032f, 0.21938087f, 
    -0.10711630f, 0.06692000f, -0.15812990f, -0.10639431f, 0.12692954f, 0.11064777f, 0.07340609f, -0.05974164f, 
    -0.15647028f, -0.06003465f, 0.02743666f, 0.00140579f, 0.10371033f, 0.09959710f, 0.22866169f, -0.10845036f, 
    0.09377234f, -0.00026489f, 0.10255831f, -0.07155517f, 0.01125081f, 0.18624550f, 0.10911898f, 0.06679942f, 
    -0.09219860f, -0.06957339f, 0.13279437f, 0.16153121f, -0.14498439f, -0.01567664f, 0.05742246f, 0.05134998f, 
    0.01479840f, 0.15025936f, 0.12908015f, 0.05788847f, -0.28123206f, -0.16960180f, -0.20977153f, 0.16130441f, 
    -0.06303713f, 0.04777091f, -0.11035163f, 0.12499510f, 0.02303557f, -0.12668826f, 0.09578894f, 0.21102877f, 
    0.03881122f, -0.16230865f, -0.11431770f, 0.10517863f, 0.06473450f, -0.00746962f, 0.18525663f, 0.04822603f, 
    -0.20241223f, -0.11515804f, -0.02665928f, -0.02938160f, 0.18834516f, 0.01552373f, 0.17204471f, 0.00593760f, 
    0.06036757f, -0.12216215f, -0.05123986f, -0.16764523f, -0.05563469f, 0.01585251f, -0.11101156f, -0.06364495f, 
    -0.22952612f, -0.05167842f, 0.00043510f, 0.12449213f, -0.02212089f, 0.00473157f, -0.09250921f, 0.02285086f, 
    -0.02245674f, -0.11202376f, -0.02959481f, 0.01249923f, -0.15301387f, 0.51310408f, 0.23921198f, -0.03525723f, 
    -0.13952115f, -0.01690587f, 0.05753814f, 0.08711582f, 0.01284508f, -0.01385529f, -0.00141937f, 0.09595677f, 
    -0.15879171f, 0.17361897f, -0.12580164f, 0.01260957f, -0.02461933f, 0.05981670f, 0.03673311f, -0.23174962f, 
    0.10348693f, 0.13583961f, 0.06920462f, 0.19275628f, 0.10264464f, -0.11464875f, -0.37536120f, -0.14166054f, 
    0.11355098f, 0.01323938f, 0.02749180f, 0.02922571f, 0.03730670f, 0.02960516f, -0.02667593f, 0.05839864f, 
    0.23733518f, -0.47161084f, 0.12314761f, 0.08064976f, 0.13650410f, 0.14736423f, -0.01164749f, 0.00031590f, 
    0.05642304f, -0.10420671f, 0.05466320f, 0.12193525f, -0.06725995f, -0.10749985f, 0.16961384f, -0.04571541f, 
    -0.14343566f, -0.06612027f, -0.04935213f, 0.03707415f, 0.06840979f, 0.14161950f, 0.01360411f, 0.03369399f, 
    -0.18997163f, -0.18367022f, -0.02222279f, 0.22017229f, -0.07544024f, -0.09060119f, -0.09086774f, -0.09080157f, 
    -0.09558758f, -0.10110274f, 0.03407744f, 0.07832065f, -0.08984518f, 0.07775637f, -0.01033574f, 0.02440028f, 
    -0.13426833f, 0.19379704f, 0.16213545f, 0.02361604f, -0.01730205f, 0.16288596f, 0.04531486f, -0.04317045f, 
    0.08981697f, -0.17270558f, 0.09873911f, 0.06970751f, -0.03474991f, 0.05224562f, 0.04104805f, 0.23076381f, 
    -0.08123221f, -0.02331688f, -0.02184252f, -0.08707770f, -0.16524841f, 0.09825727f, 0.23067696f, -0.09217349f, 
    -0.04183696f, -0.08681425f, 0.06787887f, 0.03990849f, -0.12011696f, 0.05294331f, 0.04136870f, -0.16105680f, 
    0.05885177f, 0.04480520f, -0.13193314f, -0.38006234f, 0.10031123f, 0.10901225f, 0.09272546f, 0.00447107f, 
    0.14127444f, 0.07483690f, -0.07216901f, -0.10561960f, 0.19298872f, 0.24828178f, 0.43815809f, -0.00567114f, 
    -0.13120267f, -0.20230795f, 0.16556084f, 0.02018087f, -0.14452790f, 0.22878921f, -0.00928396f, 0.10931283f, 
    -0.14562987f, 0.00660247f, 0.01235565f, 0.21277915f, -0.00634855f, -0.01829354f, -0.01821047f, 0.21951185f, 
    0.07692445f, 0.05915947f, 0.05399279f, 0.01650569f, -0.19569187f, -0.16873029f, -0.01256581f, 0.34367022f, 
    0.15361734f, 0.13697885f, 0.02821273f, 0.14181313f, 0.00959975f, -0.03918044f, 0.04097998f, 0.03144595f, 
    0.02331897f, -0.14556803f, -0.00016098f, -0.07175212f, 0.06337913f, 0.08457192f, -0.08754414f, -0.03036497f, 
    -0.01753886f, -0.00847560f, -0.05696152f, 0.04425715f, 0.03749607f, 0.14016052f, 0.23974791f, -0.22461581f, 
    -0.03508255f, 0.08713003f, -0.10194147f, -0.06181219f, 0.00159749f, 0.01118651f, 0.18768306f, -0.09511133f, 
    -0.38892463f, -0.26734185f, 0.10073738f, 0.06016058f, 0.00347922f, -0.06911502f, 0.11601406f, 0.23523898f, 
    -0.04745607f, -0.00148283f, 0.01641482f, 0.00773021f, -0.03914038f, 0.03189528f, 0.24665552f, -0.15606391f, 
    -0.14159985f, -0.08020386f, -0.03046589f, 0.05774884f, -0.07027763f, 0.06224288f, 0.07283654f, -0.03857779f, 
    0.01180188f, 0.18774925f, -0.23007439f, 0.13677466f, -0.07573525f, 0.00484458f, -0.03071018f, -0.09756310f, 
    0.09302709f, 0.10144655f, 0.07987364f, -0.08762962f, 0.01807855f, 0.05888421f, -0.17021373f, 0.03151494f, 
    0.01521324f, 0.19438000f, 0.14266613f, 0.18888856f, -0.00695882f, 0.01140536f, -0.02403820f, -0.08301891f, 
    0.06189276f, -0.14214571f, 0.15984996f, -0.12214098f, -0.00226731f, 0.06518687f, -0.01859521f, 0.05583059f, 
    -0.06160591f, -0.03433719f, 0.01798878f, -0.07090032f, 0.04253020f, -0.07803420f, -0.00793390f, 0.21255577f, 
    -0.00222817f, -0.08830495f, -0.09516662f, -0.05537353f, 0.14493589f, 0.07616781f, 0.07268243f, -0.02011222f, 
    -0.18516082f, -0.12028653f, 0.01872708f, 0.21691465f, 0.01057704f, 0.07779789f, -0.06447424f, -0.02628197f, 
    0.05715866f, 0.04078694f, -0.08769164f, 0.07373570f, -0.00082177f, -0.00430257f, -0.00273457f, -0.06638807f, 
    -0.06030111f, 0.08653196f, 0.16727918f, 0.15492406f, 0.06419984f, 0.00899253f, 0.03218860f, -0.14063133f, 
    0.00927100f, -0.10392661f, 0.16403292f, -0.07428604f, -0.01520575f, 0.19256629f, -0.02801646f, 0.09909672f, 
    0.07305055f, -0.03263265f, -0.00768216f, 0.06898626f, -0.19378152f, 0.13867444f, -0.01607451f, -0.21763736f, 
    0.00335190f, 0.01559452f, 0.06521390f, 0.08887217f, 0.04385623f, 0.09030023f, -0.06267818f, -0.00214157f, 
    -0.16631371f, 0.02818757f, -0.28790858f, -0.18308355f, -0.02632186f, -0.10620960f, -0.00999733f, -0.03891029f, 
    0.03150865f, -0.02308513f, -0.06864240f, -0.04627765f, -0.01702608f, 0.00308296f, 0.42801404f, 0.00245054f, 
    -0.10251617f, -0.05457347f, -0.09206536f, 0.14380752f, -0.11899689f, 0.00652456f, 0.04335875f, 0.12566687f, 
    0.04626624f, 0.15116571f, 0.18385176f, -0.00213581f, 0.09923623f, 0.12825212f, 0.19950293f, -0.07418702f, 
    0.08003789f, -0.03401173f, -0.07015846f, 0.06416436f, -0.09317753f, 0.10262173f, 0.30664259f, -0.00501817f, 
    0.05158078f, 0.02883774f, 0.06107837f, 0.11156996f, -0.06148791f, -0.04215463f, -0.07762215f, -0.09196247f, 
    -0.05369429f, 0.00453509f, -0.05434367f, 0.07216699f, 0.00052189f, -0.15854867f, -0.08713714f, -0.05980763f, 
    0.09860330f, 0.15693766f, 0.11669318f, 0.01420083f, 0.04762966f, 0.03817870f, -0.30928597f, 0.11061013f, 
    -0.04709417f, -0.01157562f, 0.01861386f, -0.08159482f, -0.04622523f, 0.14241715f, -0.03896447f, -0.07737473f, 
    0.32939368f, 0.36825591f, 0.07138830f, 0.00698892f, 0.09782511f, 0.05567266f, 0.14440408f, 0.28877839f, 
    -0.11701932f, -0.00106996f, 0.05325585f, 0.01503637f, 0.17883562f, -0.05329834f, -0.17788893f, 0.25622979f, 
    0.16403578f, 0.18873526f, 0.08609257f, 0.00161020f, 0.10174508f, 0.03784951f, 0.01440686f, -0.09607615f, 
    -0.01691321f, -0.43367481f, 0.06001724f, -0.05332621f, -0.07324609f, 0.08438606f, -0.00829893f, -0.08695932f, 
    0.02750975f, -0.05399905f, 0.02333029f, -0.08875704f, -0.09462421f, 0.03289275f, 0.53293294f, 0.18464111f, 
    -0.02103560f, -0.13890851f, -0.23233497f, -0.12047078f, -0.03963352f, 0.11135353f, -0.00043891f, 0.06913295f, 
    -0.22757761f, 0.30241087f, -0.10630172f, -0.05674919f, -0.14973751f, -0.11027033f, 0.01436735f, 0.04771055f, 
    0.03833841f, 0.25059775f, 0.15058592f, 0.01453675f, -0.21461910f, -0.20628893f, -0.10914949f, 0.00738562f, 
    -0.01901225f, 0.05141019f, 0.08826223f, 0.02175977f, -0.01941597f, -0.10510708f, 0.12574364f, 0.11447123f, 
    0.30422610f, 0.06753146f, 0.12109233f, -0.08834916f, 0.16153923f, 0.10451461f, 0.23349488f, 0.12290064f, 
    0.00610190f, -0.04409499f, -0.06897379f, -0.00967478f, 0.20983540f, 0.21010305f, 0.05460027f, -0.09050240f, 
    0.07257103f, 0.03868045f, -0.09877384f, -0.05280918f, -0.10422795f, -0.04985158f, 0.03031289f, 0.11444754f, 
    -0.05408513f, 0.31095248f, -0.12122428f, 0.17251556f, 0.22336170f, 0.01812296f, -0.06757231f, -0.07232831f, 
    0.03118930f, -0.03443835f, 0.25538394f, 0.05053223f, 0.17536311f, 0.10955761f, -0.14071786f, 0.08815368f, 
    -0.00345910f, -0.02732334f, 0.02000403f, 0.01036024f, 0.11241315f, -0.05749127f, 0.03745103f, -0.17595896f, 
    0.15559213f, -0.19275035f, 0.29873022f, 0.14899509f, -0.01432812f, -0.12772249f, -0.08865769f, 0.02343577f, 
    -0.04387239f, 0.02012668f, 0.03160201f, 0.14017965f, -0.12570475f, 0.04714309f, -0.24857746f, 0.18553644f, 
    0.17915770f, 0.21574959f, -0.00855299f, 0.08553459f, 0.14658301f, 0.00345397f, 0.04606254f, -0.09267604f, 
    0.01195443f, 0.05905750f, 0.00425929f, -0.03438200f, -0.00390691f, -0.05464951f, -0.02375311f, -0.00677365f, 
    0.01918329f, -0.07017183f, 0.07204489f, -0.00928434f, -0.03373223f, 0.01250324f, -0.02515811f, -0.07493691f, 
    -0.07164474f, -0.03752112f, -0.05065082f, -0.05489635f, -0.06636643f, 0.00412009f, -0.04243715f, -0.06109016f, 
    -0.06976593f, -0.04840041f, 0.02611207f, 0.05665534f, -0.05803475f, 0.00714768f, -0.04334586f, 0.02092771f, 
    0.01093312f, -0.06151480f, 0.06225730f, -0.04251345f, 0.00717082f, 0.02614797f, 0.04371182f, -0.01849503f, 
    -0.06768676f, 0.02771730f, 0.02285324f, -0.04205946f, -0.07168274f, 0.02569360f, -0.00879077f, 0.05523484f, 
    -0.02201005f, -0.06679463f, 0.02478534f, -0.03359771f, 0.07116026f, 0.01309646f, -0.03005013f, 0.06511646f, 
    -0.01198626f, -0.05044007f, 0.05856485f, -0.01460378f, 0.02915069f, -0.00818901f, 0.03515949f, -0.03682820f, 
    -0.06416840f, -0.01274610f, -0.02729260f, 0.02716023f, -0.03845491f, 0.00757530f, -0.04327865f, -0.01505102f, 
    0.03197331f, 0.06545318f, 0.05698099f, 0.02942377f, 0.02213454f, 0.06004510f, -0.01576510f, -0.04141038f, 
    0.06422862f, 0.05372625f, 0.06159029f, -0.05124973f, 0.01205228f, 0.03933392f, -0.01131781f, -0.03956503f, 
    0.04282615f, 0.05934770f, -0.04988928f, -0.01130891f, -0.06234102f, -0.05026672f, -0.01259540f, 0.01356435f, 
    -0.06307635f, 0.04981659f, -0.02468335f, -0.06348643f, -0.04373408f, 0.06147956f, -0.02663325f, -0.07755977f, 
    -0.00350068f, -0.03906107f, 0.04862200f, 0.00254271f, -0.05408818f, 0.02009673f, 0.01282926f, -0.03159739f, 
    0.06215606f, -0.06240461f, 0.04506243f, -0.03814189f, -0.00335649f, -0.02246943f, -0.02273644f, 0.01200687f, 
    -0.01562806f, 0.03475070f, 0.02459996f, -0.04096670f, 0.02613819f, 0.03008234f, 0.00782261f, 0.00160624f, 
    0.05253291f, -0.04089010f, -0.03521356f, -0.06123340f, 0.06941409f, -0.01529971f, -0.02216554f, 0.03871545f, 
    0.03286192f, 0.04408301f, -0.03743836f, 0.05805195f, -0.05969437f, 0.01077689f, 0.01606287f, -0.03873028f, 
    0.03427679f, 0.00690094f, -0.03065096f, -0.07253561f, -0.04894476f, -0.01353949f, -0.04788850f, -0.07469923f, 
    -0.00434273f, 0.00395310f, -0.05512067f, 0.05798670f, -0.05437982f, -0.05630646f, 0.00408019f, 0.03612285f, 
    -0.07316203f, 0.00892209f, -0.05863924f, 0.04950397f, -0.01413477f, -0.00282762f, 0.02361646f, 0.06212940f, 
    -0.01257742f, 0.04062163f, -0.05722855f, -0.00819494f, -0.03425142f, -0.01185704f, -0.00450287f, -0.05215365f, 
    0.05581087f, 0.01601996f, -0.06799208f, -0.03725709f, -0.03065795f, 0.06166947f, -0.02798804f, -0.03011961f, 
    0.02887454f, 0.02594622f, 0.01151658f, -0.03836756f, -0.07593835f, -0.01011759f, 0.06140159f, 0.01523168f, 
    -0.08951543f, 0.15080337f, -0.04603008f, 0.06146194f, 0.19103289f, 0.04126744f, 0.02044324f, -0.02466700f, 
    -0.01774675f, 0.02715774f, -0.02989677f, 0.02697478f, -0.00438176f, 0.21048033f, -0.12868865f, -0.20536712f, 
    0.01065596f, 0.03350019f, 0.10591178f, 0.02337064f, -0.03851658f, -0.02746379f, -0.03409452f, 0.00997694f, 
    0.00716968f, 0.15127468f, 0.04847098f, -0.04830106f, -0.11788964f, -0.03812979f, -0.07889241f, -0.18041545f, 
    0.05310111f, -0.00431878f, 0.12641701f, 0.03142793f, -0.01827828f, 0.00901023f, 0.00104253f, 0.11758579f, 
    -0.08768597f, -0.05030144f, -0.12517807f, 0.10823156f, -0.03729566f, 0.05638345f, 0.04759341f, 0.15691112f, 
    0.23289858f, -0.10884854f, -0.07372618f, -0.06233177f, 0.08319473f, 0.01377080f, 0.06069063f, -0.03001254f, 
    -0.15852714f, 0.03924345f, -0.00447274f, 0.02460654f, 0.12057342f, -0.24861221f, -0.05827685f, 0.08913974f, 
    0.19999175f, 0.02149323f, 0.07841957f, -0.00304954f, -0.00527705f, 0.05638428f, -0.11504404f, -0.11702459f, 
    0.14980038f, -0.16027531f, 0.15418701f, -0.15099436f, -0.07346147f, 0.03936994f, 0.07695357f, 0.04111123f, 
    -0.02971832f, -0.02892626f, 0.01986894f, -0.10318246f, -0.27593607f, -0.08666817f, 0.37083504f, 0.08139839f, 
    -0.02700826f, -0.04408746f, -0.07932365f, -0.06561146f, -0.07799643f, -0.05623374f, 0.01607209f, -0.05548513f, 
    -0.22185588f, 0.41903675f, -0.13273117f, 0.01243949f, -0.07067522f, -0.04539040f, -0.03924253f, -0.11989834f, 
    -0.08620287f, 0.11233093f, 0.03027668f, -0.01440273f, -0.26938385f, 0.29987302f, -0.07107674f, -0.11027483f, 
    0.02286654f, 0.07792376f, -0.01764615f, -0.13408498f, -0.05450483f, -0.06609538f, 0.09777242f, 0.06480099f, 
    -0.04250830f, 0.11850987f, -0.09380064f, -0.04057014f, 0.09650122f, 0.10788729f, 0.11356816f, 0.10386967f, 
    -0.01277820f, -0.01416254f, -0.07501160f, -0.00137001f, 0.03626703f, -0.00148745f, 0.03360069f, 0.15035012f, 
    0.06126919f, -0.10693382f, -0.08123098f, -0.14623672f, -0.02497429f, -0.05019530f, -0.05447597f, 0.04876425f, 
    -0.08200017f, 0.14998095f, -0.03426214f, 0.03665978f, 0.12053094f, 0.09560339f, -0.02157244f, -0.09363776f, 
    -0.02056225f, 0.09094250f, 0.21376529f, 0.03960263f, 0.26073819f, -0.09439985f, 0.12404890f, 0.29916134f, 
    0.00062400f, -0.07691181f, 0.05781511f, -0.19256191f, 0.12532060f, 0.03914388f, 0.04793942f, 0.09762748f, 
    -0.03570991f, -0.06048632f, 0.24253662f, 0.11161267f, -0.17170869f, -0.13988774f, -0.05613271f, 0.06404255f, 
    -0.14841127f, -0.06334862f, 0.03508614f, 0.00735879f, -0.01398305f, 0.05632509f, -0.09927014f, 0.07817915f, 
    0.17377387f, -0.03371927f, 0.01113507f, 0.15330051f, 0.04612557f, -0.01240538f, 0.14331742f, -0.08680390f, 
    0.11042875f, 0.14342204f, -0.24205180f, -0.12157109f, 0.05724875f, 0.03420691f, -0.14801526f, 0.11555921f, 
    -0.01257460f, -0.04794621f, 0.06127439f, 0.17423061f, 0.32964930f, -0.19294555f, 0.16748540f, -0.03807306f, 
    0.08084001f, 0.22282408f, -0.01382732f, -0.05421726f, -0.10182659f, 0.04203764f, 0.09050994f, -0.04536698f, 
    -0.18088041f, -0.10948718f, 0.08924256f, -0.20790659f, 0.04345793f, -0.10314169f, -0.00116531f, 0.14129883f, 
    -0.17147177f, -0.09686081f, -0.10739670f, -0.20584574f, 0.02920969f, 0.28340265f, 0.06665170f, 0.18293954f, 
    0.03083342f, -0.14188516f, -0.17005220f, -0.16568196f, 0.00252345f, -0.04920894f, 0.24104518f, -0.17660871f, 
    0.04092117f, 0.01978993f, 0.19175497f, 0.30492607f, -0.06697078f, -0.10058840f, 0.00997081f, -0.13599612f, 
    0.06076899f, 0.03678900f, 0.03058988f, 0.08202239f, 0.03505724f, -0.12469613f, 0.25465983f, -0.00750173f, 
    0.19557491f, -0.15583029f, -0.01126109f, 0.11941164f, 0.19379729f, 0.10214666f, -0.01807285f, 0.09115954f, 
    -0.01496421f, -0.07913025f, 0.02360815f, -0.15843137f, -0.16254282f, -0.15987991f, -0.02089820f, -0.08568234f, 
    -0.04313770f, -0.04285619f, 0.06378299f, 0.05103152f, 0.46902183f, 0.04233096f, -0.09792669f, 0.52134424f, 
    0.08871936f, 0.41349590f, 0.24404845f, 0.06048815f, 0.00901125f, 0.23995270f, -0.07871898f, -0.02529034f, 
    -0.18014164f, 0.04784834f, -0.17884217f, -0.25140148f, 0.06890665f, 0.08075749f, 0.17938535f, 0.08246587f, 
    -0.09547974f, 0.06592944f, 0.06174809f, 0.18322912f, -0.12373388f, 0.33688432f, 0.15964514f, -0.17644538f, 
    0.16286457f, 0.00772314f, -0.18620057f, -0.15369125f, -0.14173131f, -0.00669010f, 0.05743004f, 0.02137212f, 
    0.14739102f, 0.46951336f, 0.10869914f, 0.12657672f, 0.02523525f, 0.13360143f, -0.14031391f, 0.09468903f, 
    0.02692732f, 0.19369026f, 0.01785922f, -0.04899710f, -0.02095456f, -0.08008296f, 0.06256533f, 0.23788676f, 
    0.07869186f, -0.00306598f, 0.07963982f, 0.10198648f, -0.10281218f, 0.15946315f, 0.23849350f, 0.00284274f, 
    -0.10522186f, 0.09237412f, -0.00695495f, 0.06405505f, 0.05339994f, -0.03098426f, -0.01846061f, -0.01967950f, 
    -0.14406869f, -0.00451162f, -0.20193262f, -0.30284822f, -0.34767261f, 0.16861299f, -0.25463617f, -0.16967602f, 
    -0.11967133f, -0.05218048f, -0.21276622f, 0.17951235f, -0.08197202f, 0.09696002f, 0.00466908f, 0.11679915f, 
    -0.16889760f, -0.11515899f, -0.38056871f, 0.35769618f, -0.11116239f, 0.14862864f, 0.25078386f, -0.33214042f, 
    0.02609568f, 0.02051171f, 0.01356544f, -0.02297479f, -0.16000116f, -0.07764891f, 0.12673604f, 0.15838681f, 
    0.05813269f, -0.09152848f, 0.02251677f, 0.15401441f, -0.07460058f, 0.03489337f, -0.00590112f, -0.16921347f, 
    -0.35644782f, 0.07974703f, 0.06752571f, 0.07505935f, -0.04030066f, -0.04031155f, -0.03251459f, 0.08750869f, 
    0.01454513f, -0.10281501f, -0.08694427f, -0.02057342f, -0.22847329f, -0.19685754f, 0.22414291f, 0.24314420f, 
    0.04042026f, 0.03675519f, 0.04105099f, 0.03299916f, -0.10318594f, -0.06072129f, 0.10835994f, -0.05432546f, 
    0.02873485f, -0.07873423f, 0.12080134f, -0.01402004f, -0.03099665f, 0.10205536f, -0.01022840f, 0.02733826f, 
    0.04586549f, -0.01565683f, 0.01632160f, 0.07976043f, -0.12908734f, -0.06793725f, 0.04949024f, -0.00110834f, 
    -0.01351941f, 0.08691514f, 0.00009031f, -0.11952596f, 0.01263024f, 0.01400992f, -0.00615096f, 0.08234856f, 
    -0.19238748f, 0.09985083f, 0.18142463f, 0.15150791f, -0.07345797f, -0.05166386f, 0.28081834f, 0.18073119f, 
    -0.03293055f, -0.06370178f, 0.03180141f, -0.05902022f, 0.12216476f, -0.00029254f, 0.12828924f, -0.18593733f, 
    -0.00950513f, 0.02426556f, -0.20516427f, 0.06973981f, -0.02359868f, -0.05992098f, -0.01753790f, -0.08184394f, 
    -0.05233854f, -0.21009888f, -0.01858158f, -0.12237392f, 0.04673408f, 0.00545559f, 0.06383621f, -0.00023389f, 
    -0.02382068f, -0.07046703f, -0.08363785f, -0.05628563f, 0.47390124f, -0.05757660f, 0.04040451f, 0.00575443f, 
    0.08967891f, 0.12701491f, 0.22676319f, -0.03260617f, -0.15036671f, -0.14835005f, 0.00822204f, -0.10135479f, 
    -0.06500316f, 0.10805403f, -0.01626562f, 0.03922672f, -0.01906188f, -0.10982874f, 0.04361977f, 0.07559904f, 
    0.12314525f, 0.06803582f, -0.05926025f, -0.13402823f, -0.21983938f, -0.12209671f, 0.19238003f, 0.26775119f, 
    -0.02827448f, -0.06337737f, 0.02832560f, -0.06076123f, 0.08423597f, 0.02049020f, 0.02579189f, 0.10990799f, 
    -0.00663699f, 0.22825819f, 0.26135954f, 0.06014352f, 0.00212452f, 0.03024352f, 0.13906687f, -0.11975055f, 
    -0.06495725f, -0.11171503f, 0.02742904f, 0.07291839f, 0.27144390f, 0.05616980f, 0.03110854f, -0.05068857f, 
    -0.10222014f, -0.02290869f, -0.05395325f, 0.04768028f, 0.03501161f, -0.07363832f, -0.03197350f, -0.00103941f, 
    -0.08678871f, 0.24987121f, -0.08682788f, 0.13640633f, 0.14516413f, 0.12595281f, 0.25364485f, 0.00098882f, 
    0.10996160f, -0.14888990f, 0.02210430f, 0.14554405f, -0.18890618f, 0.15761155f, -0.16299348f, -0.05361641f, 
    0.05000317f, 0.21956216f, -0.22096987f, 0.02030378f, 0.07854605f, 0.09078918f, 0.12199718f, 0.16358168f, 
    0.47985595f, -0.06421002f, 0.07348485f, 0.22316706f, -0.06143774f, -0.16993630f, -0.04764079f, -0.11513237f, 
    0.01974241f, -0.10477030f, -0.09768707f, 0.00050898f, -0.04556800f, -0.06906977f, -0.01881449f, 0.06082847f, 
    -0.14442255f, 0.12979323f, -0.16029938f, 0.12057231f, 0.12652665f, -0.13920027f, 0.05714874f, 0.11883423f, 
    0.03377480f, -0.23660342f, 0.07734621f, 0.07787456f, -0.14224055f, -0.06393585f, 0.09291022f, 0.22916587f, 
    0.24540968f, -0.02992107f, -0.09730330f, -0.02340871f, -0.15095267f, -0.11182512f, 0.15390037f, 0.32671303f, 
    0.10434318f, 0.00057189f, -0.00549786f, -0.00834810f, -0.03275520f, -0.03902575f, -0.01602064f, 0.00820057f, 
    -0.05217659f, -0.01860020f, -0.00477058f, 0.00688552f, -0.00281592f, 0.09816135f, 0.03434870f, 0.04298103f, 
    0.00484636f, 0.15497987f, 0.10163145f, 0.09555533f, 0.05215495f, -0.06144322f, 0.06741154f, 0.02695836f, 
    -0.16985941f, 0.22928762f, 0.01354819f, -0.13016342f, 0.03382546f, -0.06309537f, -0.00723688f, 0.02333234f, 
    -0.11830629f, 0.03133718f, 0.02285270f, 0.15475653f, 0.01856916f, -0.08450752f, 0.09093064f, 0.27113941f, 
    -0.13530284f, -0.00301199f, -0.02536273f, 0.01762004f, -0.02044917f, 0.00549967f, -0.00488188f, 0.15549742f, 
    -0.07359260f, -0.16066718f, 0.00362906f, 0.04893132f, -0.04356796f, -0.02470865f, 0.03985888f, -0.09851178f, 
    -0.15752578f, -0.07770197f, 0.00326287f, 0.06465996f, 0.00142325f, 0.03383775f, 0.04010076f, -0.06336448f, 
    0.07247439f, -0.14959851f, 0.02529235f, -0.02524322f, -0.22661097f, 0.29608437f, 0.22237417f, 0.05892886f, 
    0.19972323f, -0.13562898f, -0.14029150f, -0.09764318f, -0.11416357f, -0.12192831f, -0.14759411f, -0.17195171f, 
    0.05984985f, 0.05534475f, 0.24343696f, -0.03507674f, -0.06854014f, -0.08219749f, -0.05326490f, 0.10056511f, 
    0.08238028f, 0.09923875f, -0.14969498f, -0.10935470f, 0.26523682f, -0.42588019f, -0.05522390f, -0.01287528f, 
    -0.23054579f, -0.09231324f, -0.14443529f, -0.03702535f, 0.21394108f, -0.04271151f, 0.18072824f, 0.17524108f, 
    0.01157315f, -0.02253514f, 0.17936350f, 0.19732013f, 0.00329448f, 0.06574516f, 0.10808060f, 0.00350892f, 
    0.05141151f, 0.07555939f, -0.02686178f, 0.06958137f, 0.10611260f, 0.18456112f, 0.03979244f, -0.07017976f, 
    0.06084865f, 0.08570866f, -0.08144445f, 0.00888028f, 0.00329616f, -0.18731269f, -0.17680328f, 0.00582314f, 
    -0.03171351f, 0.20567474f, -0.01866439f, 0.07019687f, 0.06184145f, 0.20136024f, 0.12877615f, 0.16986963f, 
    0.13437879f, 0.05741661f, 0.15093203f, 0.18471019f, -0.27290246f, 0.27037153f, 0.07597390f, -0.00811528f, 
    0.04712212f, 0.09353150f, 0.01469595f, 0.04618020f, 0.03763420f, 0.18930601f, 0.19461444f, -0.10845125f, 
    0.28555614f, 0.16311805f, 0.30737540f, 0.27756360f, 0.02887802f, -0.11964807f, -0.18215656f, -0.02812655f, 
    0.11481403f, -0.24457432f, -0.08024949f, 0.11663551f, 0.05318605f, -0.11697795f, -0.07107487f, 0.01472285f, 
    -0.11928199f, 0.05239971f, -0.10405011f, 0.09648546f, 0.17273243f, -0.11777497f, 0.05761062f, 0.05902046f, 
    0.05842518f, 0.16341825f, 0.04108761f, 0.32789540f, 0.12036299f, 0.06544966f, -0.02959958f, -0.00829430f, 
    0.11097272f, -0.10852900f, -0.03952302f, -0.11103559f, -0.14786269f, -0.12599917f, 0.18700616f, 0.18335521f, 
    0.08799195f, 0.15522934f, 0.10054372f, 0.03209401f, 0.03458757f, 0.05239302f, -0.00979561f, 0.01891748f, 
    -0.19174096f, -0.20148401f, -0.14957540f, -0.19532047f, 0.08434396f, 0.03580598f, -0.14972752f, 0.04350489f, 
    -0.13786069f, -0.09308980f, -0.22222781f, 0.09776931f, 0.10221418f, 0.11359768f, -0.15080078f, -0.13276815f, 
    0.11825219f, -0.01776974f, -0.01057334f, -0.07003285f, 0.04377547f, -0.08496957f, -0.11533785f, -0.27536565f, 
    -0.03904625f, 0.05980747f, 0.05110264f, 0.00692473f, 0.09727793f, 0.09758458f, -0.03463128f, 0.28132907f, 
    0.14975098f, 0.04376566f, 0.07354212f, -0.02057621f, 0.11973290f, -0.08084999f, 0.13955517f, -0.10225997f, 
    0.01166662f, -0.11174980f, 0.04117372f, -0.03555919f, 0.05255623f, 0.09476542f, 0.21284255f, 0.19684145f, 
    -0.35202259f, 0.05308502f, -0.41938794f, 0.24886140f, 0.02124900f, -0.04546512f, -0.04520015f, -0.05116281f, 
    0.12377215f, 0.05129591f, 0.06619344f, 0.13195169f, -0.17627613f, 0.51838958f, 0.11156242f, 0.26434308f, 
    0.01695092f, 0.10285254f, -0.15637408f, 0.07264411f, -0.00028698f, -0.06098499f, 0.10439432f, -0.07773559f, 
    0.11741927f, -0.34514216f, -0.02867587f, -0.25901684f, -0.16304924f, 0.08925738f, 0.00396146f, 0.07743893f, 
    0.02296297f, 0.16500585f, -0.05259008f, 0.11206760f, -0.08499920f, 0.04812434f, 0.11906768f, 0.40896299f, 
    0.07002589f, -0.08494679f, -0.27936250f, 0.04828039f, -0.03343995f, -0.09097619f, 0.00847960f, -0.03835815f, 
    0.23333408f, 0.11327215f, 0.14323767f, 0.02900917f, 0.11769005f, 0.19294494f, 0.18904084f, 0.17039366f, 
    -0.03080100f, -0.02870741f, -0.07135661f, -0.09011268f, 0.09369560f, 0.05672909f, 0.16562724f, -0.15835546f, 
    0.05088527f, 0.04327351f, 0.12044826f, 0.01006607f, -0.03184944f, 0.15327808f, 0.08428392f, 0.16801661f, 
    -0.10021461f, -0.22258142f, 0.00954898f, -0.06820601f, 0.10875095f, 0.11373311f, 0.04952446f, 0.18091458f, 
    0.04198560f, -0.21494426f, -0.15627834f, -0.15888792f, -0.05472767f, 0.11811703f, -0.35959053f, -0.16420688f, 
    -0.10050183f, -0.09255663f, -0.08816900f, 0.15646842f, -0.10764141f, 0.06934366f, 0.01730225f, -0.02247809f, 
    -0.34872252f, -0.06797726f, -0.15901299f, 0.23315673f, 0.09363081f, -0.06745846f, 0.12509005f, -0.05917222f, 
    0.14776710f, -0.05386325f, -0.16794516f, 0.14032884f, 0.15091693f, -0.12694348f, 0.36657044f, -0.21694086f, 
    -0.02473634f, -0.03277246f, -0.05471320f, -0.11438146f, -0.08941161f, 0.01157416f, 0.07426002f, 0.08718568f, 
    -0.04736642f, -0.01417860f, 0.15956756f, -0.00211685f, -0.05205777f, 0.08227916f, 0.10506908f, -0.02583201f, 
    0.11653305f, -0.07566898f, -0.08186934f, -0.01777493f, -0.11726095f, 0.08708187f, 0.03172733f, 0.14203970f, 
    0.13599107f, 0.12241592f, 0.09053155f, 0.00645955f, -0.05852528f, 0.00945539f, 0.01399347f, -0.07927491f, 
    -0.04228259f, 0.10337937f, 0.10644965f, 0.03042340f, -0.01261694f, 0.05796592f, 0.05674554f, -0.03161819f, 
    0.06357105f, -0.02707291f, 0.02863824f, 0.12404022f, -0.04697920f, -0.13329175f, -0.00402427f, -0.04438832f, 
    -0.06407546f, -0.07086262f, -0.05646170f, 0.05584235f, 0.11073530f, 0.08090130f, -0.19827545f, 0.03732810f, 
    0.12772493f, 0.01265357f, -0.01234953f, -0.17608583f, 0.00908627f, 0.08054707f, 0.12974532f, 0.17844784f, 
    -0.11732586f, -0.03697333f, 0.03798344f, -0.04948240f, 0.10209699f, -0.01792555f, -0.15389238f, -0.08252709f, 
    0.03933931f, 0.05262491f, 0.04796072f, -0.04781055f, 0.00572226f, 0.13942622f, -0.00959185f, -0.18872833f, 
    -0.11853354f, -0.12866080f, 0.18074854f, 0.02382261f, 0.09155532f, -0.07086571f, 0.08187243f, 0.08386601f, 
    0.06809893f, -0.06648588f, -0.04022749f, -0.06962232f, -0.01371878f, -0.10939751f, 0.21722999f, -0.42938086f, 
    0.13160692f, 0.04662009f, -0.08807663f, -0.13281913f, -0.07599727f, -0.11193619f, 0.05939473f, -0.04372137f, 
    -0.02696857f, 0.23189293f, -0.03186623f, 0.05259252f, -0.01108991f, -0.02812038f, -0.06518673f, 0.09953413f, 
    0.03145218f, 0.00007113f, -0.05106568f, -0.06716101f, -0.12248603f, -0.10668869f, 0.06549369f, 0.29732829f, 
    -0.06923674f, 0.02038876f, 0.12706105f, 0.01911578f, 0.10854048f, -0.04342481f, 0.10310915f, 0.19697835f, 
    -0.11238018f, 0.06048000f, -0.09711570f, -0.20680952f, 0.10174277f, -0.05166202f, 0.08811625f, -0.16653340f, 
    0.09499319f, -0.00769679f, 0.05412912f, -0.02517192f, 0.15033802f, 0.17473231f, 0.03965839f, -0.07461692f, 
    0.09097049f, 0.08148189f, -0.08995628f, -0.10055544f, -0.02392110f, 0.04776864f, -0.03665339f, 0.11248884f, 
    -0.01627273f, 0.18062483f, 0.00815086f, 0.10551900f, 0.04524507f, -0.03562086f, 0.05760910f, 0.08138985f, 
    0.05570383f, 0.13962193f, 0.09371455f, 0.13627960f, 0.18358293f, -0.14036325f, 0.08862668f, 0.09635331f, 
    0.11843787f, -0.08960194f, -0.08240910f, -0.04940895f, 0.15786116f, 0.16271503f, 0.09456810f, 0.18771936f, 
    0.22666503f, -0.20715094f, 0.35886601f, 0.09113552f, -0.11711758f, -0.01315767f, -0.09942967f, 0.00557283f, 
    -0.06085908f, -0.07666176f, -0.08353777f, 0.10250072f, -0.02849632f, -0.01055194f, -0.14137477f, -0.13127318f, 
    0.01487581f, 0.05601712f, -0.02412867f, 0.09008987f, 0.10083793f, -0.06281932f, -0.05769162f, -0.05122370f, 
    -0.26871955f, 0.16760775f, 0.21185124f, 0.15890907f, -0.06346374f, 0.07474245f, -0.02444786f, -0.04189592f, 
    -0.15549527f, 0.03954627f, 0.21058963f, 0.00006617f, -0.16124257f, 0.01456039f, -0.27183828f, -0.06345023f, 
    -0.04488517f, 0.08757956f, 0.04269392f, 0.04090685f, 0.15145810f, 0.10265062f, 0.03603760f, 0.05432204f, 
    0.01938083f, 0.02766635f, -0.10080066f, 0.10052527f, -0.02734180f, -0.05176840f, 0.07648138f, 0.07591164f, 
    -0.00018809f, 0.01416298f, 0.01109605f, -0.10856424f, -0.12628728f, -0.06074398f, 0.18243708f, 0.08755467f, 
    0.13373084f, -0.13417807f, 0.04590587f, 0.08572967f, 0.11565881f, 0.20706987f, -0.00775545f, 0.02527958f, 
    -0.08515036f, -0.19632630f, -0.10358229f, 0.04163602f, -0.00866387f, 0.12415431f, -0.11385208f, -0.37738147f, 
    -0.06106517f, -0.05185595f, -0.05230093f, -0.05323824f, -0.26497272f, 0.19591548f, 0.06524504f, 0.19175115f, 
    -0.04049659f, -0.03321745f, 0.02360312f, -0.13593279f, -0.05044492f, 0.12339999f, 0.01371485f, 0.11988382f, 
    0.32489055f, -0.02682705f, -0.02749181f, -0.06770678f, 0.00064836f, 0.03827999f, 0.04572780f, 0.04601474f, 
    0.07795360f, 0.30133641f, 0.10537283f, 0.15546174f, 0.23031373f, -0.38917199f, 0.00240567f, 0.02113912f, 
    -0.04009278f, 0.03710824f, 0.16265218f, -0.03949453f, 0.02190448f, -0.10096075f, 0.03580767f, 0.04258567f, 
    0.05505790f, 0.14944232f, -0.08212130f, 0.23974441f, 0.07488316f, 0.10428407f, 0.05271695f, -0.01411064f, 
    0.00081708f, -0.04538265f, -0.04475723f, 0.02070590f, -0.26152775f, 0.11009154f, 0.05958559f, 0.12894037f, 
    0.01827166f, 0.00268474f, -0.11853307f, -0.03534180f, -0.04073304f, 0.12145706f, -0.09092866f, 0.01110277f, 
    -0.10713574f, -0.36030298f, -0.16541861f, 0.04778385f, 0.05326906f, -0.19788197f, -0.07236541f, 0.04572533f, 
    -0.03089941f, -0.16262609f, 0.12507436f, -0.04977581f, -0.09505306f, -0.14521852f, 0.03666666f, 0.11336983f, 
    -0.00275553f, -0.01857142f, -0.07866087f, -0.14877185f, 0.10107219f, 0.25478387f, 0.11919370f, 0.01160549f, 
    -0.01059373f, -0.19532746f, 0.00230644f, 0.06062761f, 0.23259214f, 0.07318272f, 0.06955288f, 0.18821084f, 
    -0.14807162f, 0.03413030f, 0.07128190f, -0.10599289f, 0.22389892f, -0.12400016f, 0.27320838f, 0.03108202f, 
    0.20379552f, -0.19218600f, 0.10002685f, -0.17808174f, 0.14280556f, -0.05477560f, 0.18669105f, 0.08839962f, 
    0.31720656f, 0.04073844f, 0.14390388f, -0.17932697f, -0.01782471f, -0.05775625f, 0.03790829f, 0.04494980f, 
    -0.07567944f, 0.02934413f, 0.03527706f, -0.13857301f, 0.19324622f, 0.45609266f, 0.23335016f, 0.14015052f, 
    0.02730704f, -0.05875583f, -0.02783001f, -0.03729147f, -0.07935227f, 0.13311544f, 0.02517657f, 0.02036841f, 
    0.20026000f, 0.22894962f, -0.18175267f, -0.24601366f, 0.15551575f, 0.09538876f, 0.16473795f, -0.01791736f, 
    0.03627405f, 0.13697542f, -0.08655497f, 0.03323993f, 0.30258316f, 0.29828149f, 0.28713369f, -0.14343777f, 
    0.00260133f, 0.05858024f, 0.00783082f, 0.07837038f, -0.03197095f, 0.00844909f, -0.00549061f, -0.08723720f, 
    -0.10661613f, -0.06883866f, -0.10710141f, -0.05340313f, 0.03669799f, -0.12752275f, -0.08874900f, -0.15286441f, 
    -0.10293762f, -0.06824803f, 0.05561139f, 0.00978167f, -0.05988832f, 0.08907516f, -0.06669975f, 0.10196915f, 
    0.10888119f, -0.12251730f, 0.11589175f, -0.15074319f, 0.09084605f, 0.17116874f, 0.18941090f, 0.10900696f, 
    0.18098558f, 0.12045243f, 0.06337626f, -0.15519823f, 0.18182044f, 0.08880087f, -0.07174421f, 0.05656180f, 
    -0.06486736f, 0.07923781f, 0.05821985f, 0.16304126f, 0.03842827f, -0.14296111f, -0.18846394f, -0.06769318f, 
    0.12060241f, 0.05113333f, -0.03403425f, 0.16995582f, 0.06622984f, -0.03626054f, -0.05077706f, 0.08354563f, 
    -0.06936152f, -0.04938996f, 0.13904132f, 0.06376667f, -0.10435615f, 0.14379400f, -0.10026467f, 0.13698834f, 
    -0.00307875f, -0.08428597f, -0.12113590f, -0.07694329f, -0.10126937f, -0.10515720f, 0.00655662f, 0.14438039f, 
    0.00905801f, 0.07847312f, 0.03841326f, 0.13454716f, -0.06409466f, 0.02666578f, -0.03376441f, 0.04245933f, 
    -0.02945830f, 0.02392098f, 0.19077022f, 0.01265774f, -0.15439695f, -0.11547247f, -0.06238534f, -0.12040042f, 
    -0.15678304f, -0.07420439f, 0.00916444f, -0.08431280f, 0.30588496f, 0.29544771f, 0.01273847f, -0.53356797f, 
    -0.10866036f, -0.00044362f, 0.14709289f, 0.02695562f, 0.14607583f, -0.08897797f, -0.01160672f, 0.03628241f, 
    0.25718170f, 0.15347897f, 0.04954406f, -0.11647733f, 0.20012277f, 0.16281700f, 0.12063392f, 0.18913344f, 
    -0.03173674f, -0.02574395f, -0.09390295f, -0.08491968f, 0.07068756f, 0.00322855f, -0.02563139f, 0.10336854f, 
    0.17608856f, 0.03980898f, 0.02217108f, 0.04489086f, -0.01141188f, -0.03225220f, 0.08000628f, 0.02688116f, 
    0.05148993f, -0.00012046f, -0.00644802f, -0.29572463f, -0.01494994f, -0.07218044f, -0.07251716f, -0.25080916f, 
    0.06769714f, -0.02159606f, 0.14684033f, -0.05465313f, 0.09735098f, 0.10294931f, -0.11393756f, 0.16067258f, 
    0.12860037f, -0.14797144f, 0.04066854f, 0.00110854f, 0.04502136f, -0.14434248f, -0.12273462f, 0.15704930f, 
    -0.30932373f, -0.02569476f, -0.23088314f, 0.15163881f, 0.06338687f, -0.11131570f, 0.02758321f, -0.03650612f, 
    -0.18564889f, 0.00242861f, -0.03936394f, 0.00320414f, -0.11873204f, 0.01245810f, -0.19032514f, -0.02711380f, 
    0.05182031f, 0.00109108f, 0.13504888f, -0.12037365f, 0.20968457f, 0.02795843f, 0.00839270f, -0.02157274f, 
    0.04926384f, -0.19855469f, -0.17493767f, 0.12736180f, -0.05269923f, 0.04689052f, -0.10901009f, 0.09783562f, 
    0.23416108f, 0.00316716f, 0.01253715f, -0.11848003f, 0.06128724f, 0.00886991f, 0.05420431f, 0.13801694f, 
    0.08335584f, -0.00913393f, -0.04563409f, 0.00012449f, 0.05289491f, 0.06981519f, -0.06105537f, 0.04549391f, 
    0.01598164f, -0.03034282f, -0.00596761f, -0.03161213f, 0.15208341f, 0.13828057f, -0.00665690f, -0.02800926f, 
    0.01420024f, 0.09341760f, 0.05024895f, 0.06705188f, 0.16295893f, -0.01175324f, 0.34286523f, 0.01289536f, 
    -0.04293657f, 0.26374272f, -0.08445031f, -0.07776089f, 0.01983347f, -0.04747185f, 0.19399126f, -0.05194714f, 
    -0.16799469f, -0.05658350f, 0.10292745f, 0.20035958f, -0.12367033f, -0.12322885f, 0.00613558f, 0.16011038f, 
    0.02737449f, 0.02839716f, 0.08823553f, 0.09577236f, -0.00378628f, -0.05582309f, 0.16705857f, -0.04119328f, 
    -0.04081279f, -0.18298556f, -0.00175595f, -0.00532802f, 0.00119551f, -0.15423575f, 0.17394997f, -0.02177097f, 
    -0.26113677f, 0.33182144f, -0.19936791f, 0.09216557f, -0.04639244f, -0.16642289f, 0.04225319f, -0.09457499f, 
    -0.02407256f, -0.19536938f, 0.05639098f, 0.04473941f, -0.21530397f, 0.28263456f, -0.22555134f, 0.25721353f, 
    0.02909372f, -0.01591058f, 0.06944925f, 0.08579084f, -0.03467239f, 0.02393118f, -0.17437246f, -0.11976999f, 
    0.13881481f, -0.13091218f, 0.33802730f, -0.15683745f, -0.06132140f, -0.00395048f, -0.07343545f, 0.00905275f, 
    -0.14197351f, -0.10179347f, 0.00187453f, 0.10246567f, 0.34619299f, 0.00796073f, 0.10325049f, 0.05298630f, 
    -0.13078666f, -0.06651899f, -0.04964516f, -0.05011046f, 0.16727774f, 0.08992407f, 0.05321518f, 0.02425860f, 
    -0.00887876f, 0.18130334f, 0.13621181f, 0.18308170f, -0.16075297f, 0.09141000f, 0.01359114f, -0.02149274f, 
    -0.00973978f, 0.20694570f, -0.01252176f, 0.10521205f, -0.00750476f, 0.00339717f, -0.01360415f, 0.02631211f, 
    0.00935533f, -0.04830346f, -0.00030820f, -0.02353692f, 0.04617074f, -0.11674763f, -0.12618212f, -0.17376496f, 
    0.14172763f, -0.06428926f, 0.02926140f, -0.09455790f, -0.10776297f, 0.13857947f, 0.07344972f, 0.13189445f, 
    0.10164650f, 0.07315417f, -0.14296210f, 0.14379552f, -0.13693352f, 0.04792985f, -0.07875012f, -0.06939682f, 
    -0.06987110f, 0.02382710f, -0.02793351f, 0.12726150f, -0.04187983f, 0.05996550f, 0.11979481f, -0.20917812f, 
    -0.15309282f, 0.28028125f, -0.15858398f, 0.23254751f, -0.02363298f, 0.01444558f, 0.11783208f, 0.03175615f, 
    0.17977007f, 0.05816483f, -0.04453810f, 0.04053970f, 0.24444447f, -0.12156362f, 0.09743625f, -0.04734967f, 
    -0.13477711f, -0.09997454f, -0.01564371f, 0.04706825f, -0.04363028f, -0.13068967f, 0.07282361f, 0.07712340f, 
    0.01662447f, -0.04029201f, -0.05267624f, -0.07950410f, -0.04097837f, 0.01838997f, -0.00233305f, -0.06106467f, 
    -0.07649249f, -0.00470605f, -0.13624518f, -0.06695619f, -0.07962823f, -0.04400006f, -0.04382150f, -0.01092855f, 
    -0.00845362f, -0.07964394f, -0.06436048f, -0.04279593f, -0.08665591f, -0.04597729f, -0.08646426f, 0.00773367f, 
    -0.00404508f, -0.08213934f, 0.04907865f, 0.01624946f, -0.01339624f, -0.03466598f, -0.04647908f, 0.01749371f, 
    -0.03053040f, -0.05187351f, -0.06130692f, 0.01537208f, -0.05241048f, -0.09439310f, -0.05164688f, -0.00661667f, 
    0.02137367f, -0.02077004f, -0.01385996f, -0.07102273f, -0.04925029f, -0.02116370f, -0.04014255f, 0.01084061f, 
    -0.06047883f, -0.04966540f, -0.07136815f, -0.08556343f, -0.02871804f, -0.08023840f, 0.01288800f, -0.02745668f, 
    0.00989654f, -0.08234657f, -0.03325079f, -0.05302238f, 0.02809227f, -0.01025657f, -0.08039960f, -0.04417072f, 
    -0.09578557f, -0.09626658f, -0.02382355f, -0.00345551f, 0.02507009f, 0.00042812f, -0.11154266f, -0.05645007f, 
    -0.06403399f, -0.08961295f, -0.10430329f, -0.04009891f, -0.07660981f, 0.00560184f, 0.01052989f, -0.03057132f, 
    -0.06963412f, 0.04430079f, -0.08599143f, -0.06907868f, -0.00438618f, 0.01883479f, 0.04011435f, 0.01905121f, 
    -0.04686725f, -0.07297643f, -0.09572195f, 0.01138389f, -0.07471942f, 0.02867429f, -0.01865799f, -0.02838866f, 
    -0.01748203f, 0.02524473f, 0.03208368f, -0.07310454f, 0.04105808f, 0.03899742f, 0.02896643f, -0.07932075f, 
    -0.06205158f, -0.06542721f, -0.03510863f, -0.08922814f, -0.02344371f, -0.02496050f, 0.02220747f, 0.06910592f, 
    0.01575119f, -0.00607263f, -0.03319998f, 0.04845109f, -0.00756665f, -0.00717898f, -0.11242752f, -0.07081231f, 
    -0.02273759f, 0.06727711f, 0.05702468f, 0.03478159f, 0.03469448f, -0.09303965f, 0.03887359f, 0.02174088f, 
    -0.10549439f, -0.03635550f, -0.09586176f, 0.02642922f, -0.03227125f, 0.03299789f, 0.00881158f, -0.01470975f, 
    -0.07968622f, -0.07325400f, -0.01048348f, -0.01469617f, -0.11651810f, 0.01703683f, -0.01792512f, -0.08511280f, 
    -0.00573925f, -0.02928608f, -0.09796263f, -0.08581423f, -0.03798043f, -0.08814933f, -0.08371922f, 0.02010276f, 
    -0.05069724f, 0.01856762f, 0.01087740f, 0.00904288f, -0.06982965f, 0.00614853f, -0.03664140f, -0.07388508f, 
    0.03214658f, -0.12014216f, -0.09734625f, -0.08649676f, 0.00299252f, -0.09474254f, -0.03359007f, -0.05880659f, 
    -0.00228893f, 0.00852553f, 0.01120920f, -0.03769127f, -0.07587710f, 0.01685879f, 0.04030465f, -0.01341226f, 
    -0.02328997f, -0.02081649f, 0.03835461f, -0.01480275f, 0.00176856f, -0.06776465f, -0.05523332f, -0.01308380f, 
    -0.01688381f, -0.09122404f, -0.01576425f, -0.04354499f, 0.00719533f, 0.04160264f, -0.05152206f, -0.00921494f, 
    -0.27562180f, 0.10750861f, 0.13881508f, 0.14075147f, -0.00577264f, -0.00794980f, 0.05337907f, 0.25772628f, 
    0.03818225f, 0.07837207f, 0.09593633f, 0.04356340f, -0.39429328f, -0.09019247f, -0.13143933f, 0.23341598f, 
    -0.07611232f, -0.03754881f, -0.05317599f, 0.11594263f, 0.02069105f, -0.06814790f, -0.02188381f, 0.02160400f, 
    0.01651877f, -0.02885934f, 0.08857287f, 0.12609783f, 0.06447447f, 0.06798483f, -0.04349262f, -0.02804852f, 
    0.00445619f, 0.00316120f, 0.06517380f, 0.01262720f, 0.04680030f, -0.08338852f, 0.31704867f, -0.12168350f, 
    -0.03055523f, -0.08590953f, -0.05212167f, -0.06765023f, 0.07311250f, 0.07150321f, 0.09730545f, 0.03201293f, 
    -0.45469642f, -0.18342505f, 0.02732980f, 0.14331649f, -0.01432521f, -0.11240069f, 0.06734033f, 0.10248750f, 
    -0.10673045f, -0.10702296f, -0.10823543f, 0.02190408f, -0.17185292f, 0.36877808f, 0.17530982f, -0.03280012f, 
    -0.02252948f, -0.01780150f, 0.02939175f, 0.06164362f, 0.04131994f, 0.06954239f, 0.03014597f, -0.03986597f, 
    -0.02085572f, 0.12120233f, -0.20641707f, -0.09279349f, -0.02421488f, -0.04461105f, -0.04643746f, -0.12725471f, 
    0.07655152f, 0.06073097f, 0.00104477f, -0.00926780f, 0.18800603f, -0.43526059f, -0.36429024f, -0.31845123f, 
    0.00463167f, 0.12492797f, -0.03301525f, -0.06778412f, 0.02949228f, -0.06962743f, 0.06794057f, -0.06498549f, 
    0.10980320f, -0.13138445f, 0.23942494f, 0.18346354f, 0.04399572f, -0.01104083f, -0.05286548f, 0.12390637f, 
    -0.01919413f, 0.00495316f, 0.01128550f, -0.19589001f, -0.14580221f, -0.26007339f, 0.32171085f, 0.07115928f, 
    -0.19329554f, -0.02572867f, -0.14180158f, 0.04026748f, 0.16006917f, 0.09434129f, -0.01790549f, 0.08257046f, 
    -0.33921301f, -0.07299060f, 0.06986172f, 0.17276230f, 0.00885013f, -0.01631184f, 0.01030012f, -0.08499838f, 
    -0.01858096f, -0.01892992f, 0.06711956f, 0.00228946f, 0.01794546f, 0.14407787f, -0.00504334f, -0.03000596f, 
    0.02439478f, 0.17048502f, 0.02700914f, 0.11370768f, 0.12889190f, 0.01210322f, -0.07578707f, -0.04338281f, 
    0.04172243f, 0.01751877f, -0.11388393f, 0.05829659f, 0.07306386f, 0.08149182f, 0.17619593f, 0.15159148f, 
    0.04428734f, 0.11270855f, -0.03182206f, 0.20524178f, -0.01089180f, 0.02911838f, 0.09782903f, 0.06482453f, 
    0.17254995f, -0.04956346f, 0.04468661f, -0.11795864f, 0.16759549f, -0.00521246f, -0.07000829f, -0.04487031f, 
    0.49639538f, -0.00457770f, -0.11748557f, -0.24902764f, -0.04996554f, -0.06355844f, -0.00360258f, -0.07422051f, 
    0.00357282f, -0.01942015f, -0.07501645f, -0.07117520f, 0.11687091f, 0.23925444f, 0.20206772f, -0.06987838f, 
    -0.18025826f, 0.06468649f, -0.08166154f, 0.06457311f, 0.06913032f, 0.07979596f, 0.00130981f, 0.09255348f, 
    -0.06924183f, 0.07012066f, -0.30292779f, -0.14106977f, 0.10913467f, 0.03511217f, 0.11285798f, 0.05428942f, 
    -0.00132698f, 0.19895345f, 0.00367886f, 0.05950823f, 0.19493239f, 0.24515064f, 0.22108111f, 0.00144582f, 
    -0.10507637f, -0.11843162f, -0.00123872f, 0.06411572f, -0.07446052f, 0.04467583f, -0.04847204f, 0.05715993f, 
    0.05559804f, -0.05197238f, -0.00850484f, -0.05147342f, 0.10503456f, -0.08535447f, -0.17597449f, -0.02300352f, 
    0.02616865f, 0.03544298f, -0.01290254f, -0.04941538f, -0.03132588f, 0.06598645f, 0.05710562f, 0.18176657f, 
    -0.01891956f, 0.12988034f, 0.14120860f, -0.20096916f, 0.15017422f, -0.09721088f, 0.14177971f, 0.04980869f, 
    -0.03012130f, -0.01898076f, -0.00360474f, 0.12280569f, 0.13557476f, -0.00221540f, -0.01715920f, 0.04322687f, 
    -0.01091647f, 0.07018282f, 0.09067190f, -0.01535909f, 0.03543471f, -0.09703786f, -0.09939896f, 0.23309694f, 
    0.16512819f, 0.02559117f, 0.13031186f, 0.21088931f, -0.10106587f, -0.22780526f, -0.12526818f, -0.01844451f, 
    0.17047703f, 0.06188281f, -0.02048266f, 0.13686869f, -0.02084721f, -0.01119487f, -0.14968902f, 0.02576878f, 
    -0.09698471f, -0.10684156f, -0.07400007f, -0.01281604f, -0.26769575f, 0.06550018f, 0.10748376f, 0.35853559f, 
    0.08644620f, -0.05561622f, -0.02981972f, 0.15304232f, 0.06793232f, 0.13495401f, -0.07025421f, -0.01453350f, 
    -0.13887870f, 0.02685778f, 0.27056378f, 0.00389589f, 0.01267335f, 0.02308461f, -0.02981708f, -0.05689153f, 
    -0.08981266f, 0.02755381f, -0.01750831f, -0.00917237f, 0.28069791f, 0.11721656f, -0.16117512f, -0.43838602f, 
    -0.08935457f, -0.01986408f, 0.01688441f, 0.07640432f, 0.00087247f, -0.16328195f, -0.00320923f, 0.06424078f, 
    0.28072828f, -0.21394952f, -0.00323552f, 0.05729739f, 0.10194496f, 0.22177109f, -0.01849215f, 0.15470093f, 
    -0.04910974f, -0.01479116f, 0.00267370f, 0.06667206f, -0.13653143f, -0.22314699f, -0.04729917f, 0.27435189f, 
    -0.11137514f, 0.01152443f, -0.00698798f, -0.06601893f, -0.16635814f, -0.17705084f, -0.01951856f, -0.07180399f, 
    0.16858934f, -0.05771746f, 0.12034325f, -0.23667876f, 0.01614171f, -0.03723538f, -0.05267040f, -0.05880741f, 
    0.09408955f, -0.01442860f, -0.04354233f, -0.03101285f, -0.08987643f, -0.03288379f, -0.08976416f, 0.13205913f, 
    0.03212821f, -0.10334721f, -0.12781939f, 0.09646691f, 0.02927469f, -0.30948687f, -0.06115564f, -0.09162437f, 
    -0.49196255f, 0.23899567f, -0.22016031f, 0.10378043f, 0.16401681f, -0.00605149f, -0.05952352f, -0.02651316f, 
    -0.02085884f, 0.05730294f, 0.00505945f, 0.02002771f, -0.02589158f, -0.10064491f, 0.06711393f, 0.27442440f, 
    -0.00377028f, 0.03068008f, 0.25971556f, 0.01804859f, 0.20592906f, 0.01064350f, 0.18779525f, 0.13267158f, 
    0.00099575f, 0.18374532f, -0.09858129f, -0.04040537f, 0.26382002f, 0.10670372f, 0.13539657f, -0.01415516f, 
    -0.08363681f, 0.10838485f, 0.03061501f, -0.04686195f, 0.19746354f, 0.23650923f, -0.00754631f, -0.08345933f, 
    0.19231430f, 0.06976629f, 0.14541236f, 0.12630738f, -0.03454724f, 0.09395569f, -0.05218705f, -0.00710394f, 
    -0.08799201f, 0.02879542f, -0.17599595f, -0.06845579f, 0.14412846f, 0.03973962f, -0.01735445f, -0.03142236f, 
    0.09137625f, 0.07117382f, -0.00619628f, 0.13660498f, -0.12575771f, 0.05710908f, -0.02768516f, -0.01450321f, 
    0.00314799f, -0.02514713f, 0.03973988f, -0.04878420f, 0.09899773f, 0.10263031f, -0.02226670f, 0.11051209f, 
    0.07808699f, -0.00181425f, -0.14930445f, -0.23724273f, 0.16719019f, 0.07097866f, -0.10641360f, 0.06276479f, 
    0.01232221f, 0.06354894f, -0.03039964f, -0.05089274f, -0.00102460f, -0.10940463f, -0.14118744f, 0.02769752f, 
    0.10742358f, 0.07900156f, 0.07302538f, 0.13911226f, -0.03970622f, -0.05767305f, -0.00007839f, -0.03673918f, 
    -0.03471600f, 0.08033434f, -0.11500911f, 0.12483243f, -0.03506855f, 0.06094655f, -0.00193885f, 0.11851894f, 
    0.01577044f, 0.12141725f, 0.03313423f, -0.08200151f, -0.48154113f, -0.03517572f, 0.29254380f, 0.06441072f, 
    0.02077226f, 0.12463970f, -0.05470636f, 0.07050565f, 0.01794757f, -0.15857579f, 0.03699000f, -0.02304439f, 
    -0.06349757f, -0.11095350f, 0.06162772f, -0.16282058f, -0.03708104f, -0.03228584f, -0.09058326f, -0.14135993f, 
    -0.07079799f, 0.09776105f, -0.10225977f, 0.07268611f, 0.03302142f, 0.26106048f, -0.16481338f, -0.06754076f, 
    -0.00135466f, -0.04576934f, 0.03396856f, -0.00234326f, -0.05840863f, -0.05371054f, -0.00987515f, 0.03351472f, 
    0.16380426f, -0.21816368f, -0.11855115f, -0.13719961f, 0.10215118f, 0.13256858f, 0.19492982f, 0.17900680f, 
    -0.06889398f, 0.02206637f, 0.07216118f, -0.07763205f, 0.06137987f, -0.08255601f, 0.06283067f, 0.14166096f, 
    -0.02423809f, 0.02263019f, -0.02467499f, 0.00092926f, -0.02555279f, 0.06905854f, -0.02036957f, -0.01811039f, 
    -0.00551926f, -0.25740832f, 0.17809132f, -0.19814533f, 0.05834955f, 0.06575797f, -0.08021355f, 0.01953010f, 
    -0.00609986f, -0.09056829f, 0.13854499f, -0.02771882f, 0.27199197f, -0.13950394f, -0.00801129f, 0.19599286f, 
    -0.02204688f, -0.12356951f, 0.15439880f, -0.13546665f, 0.09715146f, -0.14272706f, -0.00187671f, 0.11115769f, 
    -0.65906471f, 0.12921996f, -0.08840352f, -0.15829676f, 0.00347660f, 0.05380837f, -0.09910025f, 0.03404869f, 
    -0.05551567f, -0.08614599f, -0.04334207f, 0.04706464f, 0.00999955f, -0.13678227f, 0.06205368f, 0.04164910f, 
    0.08744188f, -0.03428503f, 0.18338655f, -0.04491561f, 0.07844727f, 0.15574850f, 0.13490425f, 0.03509663f, 
    0.26776478f, -0.06819814f, 0.12963712f, 0.08705320f, 0.00479545f, 0.11370251f, 0.07796308f, 0.10709699f, 
    0.15910555f, -0.02917792f, -0.05610073f, 0.04592934f, -0.06401850f, -0.17411788f, 0.08876636f, 0.12211525f, 
    -0.01910114f, 0.07397222f, 0.05252128f, -0.06353714f, -0.04004529f, -0.07844724f, 0.06730816f, -0.13413994f, 
    -0.17250788f, -0.14702246f, -0.17046981f, -0.17903104f, 0.06890474f, 0.07458793f, -0.04601638f, 0.12998694f, 
    -0.19229184f, -0.10055992f, -0.26041746f, -0.10891522f, 0.11526300f, -0.05676497f, -0.01114270f, -0.02576957f, 
    0.12155487f, 0.05407028f, -0.02149997f, -0.16912103f, -0.10086861f, -0.05955692f, -0.03602656f, -0.05805477f, 
    -0.03658646f, 0.19956405f, 0.13101497f, 0.17095540f, -0.03833787f, 0.04923319f, 0.02344854f, 0.02306872f, 
    0.05081386f, 0.07441139f, -0.03030407f, 0.01189281f, 0.16943233f, 0.17649148f, 0.02306702f, -0.05622417f, 
    0.00486637f, -0.08744016f, 0.03212435f, 0.05442600f, 0.15053180f, 0.19347231f, 0.02589696f, -0.01707779f, 
    -0.52943081f, -0.11429618f, -0.09693908f, -0.10159046f, -0.03382416f, -0.25077748f, 0.04774563f, -0.14397967f, 
    -0.06332640f, -0.19226679f, 0.06406690f, 0.06839787f, -0.01878672f, 0.20066139f, -0.30544862f, -0.19606167f, 
    0.12781508f, -0.02878251f, -0.06195696f, -0.19285840f, -0.17771298f, -0.14040582f, -0.01225781f, 0.00212172f, 
    0.04986320f, -0.46974236f, -0.05740670f, -0.23438177f, -0.06823467f, -0.01491636f, -0.03578478f, 0.04111303f, 
    0.01950805f, -0.15029876f, 0.02385671f, 0.09721643f, 0.39479223f, -0.73317939f, -0.01448428f, -0.11171862f, 
    -0.37029940f, -0.16774847f, 0.01403901f, 0.09073469f, 0.12047991f, 0.15592510f, 0.15896939f, 0.15378664f, 
    0.15441762f, 0.26520640f, 0.24612784f, 0.12936476f, -0.05442067f, 0.01894182f, 0.03034013f, -0.02888993f, 
    0.11051272f, -0.03886675f, -0.02226411f, -0.02195455f, 0.28686833f, 0.28440270f, 0.06241634f, -0.05159047f, 
    0.05998843f, 0.04823620f, -0.01106788f, 0.08050536f, 0.00959288f, 0.03083337f, -0.06424792f, -0.02175616f, 
    -0.15626737f, 0.08190244f, -0.01787265f, 0.18797325f, 0.04505041f, -0.01752440f, -0.09617400f, 0.14322911f, 
    0.10706417f, 0.04811441f, -0.12966610f, -0.03014830f, -0.16407692f, 0.13901687f, 0.05086009f, -0.02529080f, 
    0.10348425f, 0.02530077f, -0.22603187f, 0.13599449f, -0.09418382f, 0.03664457f, 0.10278556f, -0.07972636f, 
    0.21433623f, -0.27769184f, -0.32080296f, 0.30040020f, 0.15858305f, -0.02101984f, -0.03721989f, -0.16758703f, 
    -0.00053815f, -0.31360984f, -0.06818976f, 0.07821660f, 0.16402084f, 0.10560920f, -0.04716887f, -0.06226243f, 
    -0.17476769f, -0.00983442f, -0.16963267f, 0.07114325f, -0.07984729f, 0.07964700f, -0.16462345f, -0.00129387f, 
    0.25661457f, -0.27646160f, -0.14067902f, -0.06982873f, 0.08175743f, 0.07252770f, 0.13920678f, -0.01852714f, 
    0.09959290f, -0.14252712f, -0.03561345f, -0.02466541f, 0.14083163f, -0.03177335f, 0.19387695f, -0.06853892f, 
    0.03259731f, -0.15265295f, -0.04941358f, -0.09921993f, -0.01655790f, -0.05738160f, -0.01313383f, 0.03619580f, 
    0.07236594f, 0.11581201f, -0.04249413f, 0.00721284f, 0.14223218f, -0.00233163f, 0.03773206f, -0.02519121f, 
    0.05606214f, 0.08543394f, -0.04738791f, 0.00339483f, -0.01647865f, 0.06073528f, -0.24989949f, 0.02953532f, 
    -0.13967691f, 0.15487757f, 0.07933974f, 0.02398832f, -0.09696511f, -0.22935219f, -0.09823188f, -0.00631639f, 
    0.17259990f, 0.36151928f, -0.07316366f, -0.13033447f, 0.09782691f, 0.11037444f, 0.02843347f, 0.15936668f, 
    0.06858506f, -0.02445223f, -0.06922950f, -0.03715511f, 0.19645374f, -0.03175008f, -0.17188030f, -0.26828301f, 
    0.05084927f, 0.21154729f, -0.07989483f, -0.00735009f, -0.00406011f, -0.01729869f, 0.03788066f, -0.02762797f, 
    -0.31498134f, -0.02783131f, 0.10833454f, 0.13197076f, 0.09745964f, 0.09901574f, 0.00431678f, -0.00424683f, 
    -0.03504674f, -0.11303408f, -0.04547649f, -0.09971040f, -0.06495923f, 0.17457859f, -0.06625994f, -0.18875869f, 
    0.04043026f, -0.22697687f, -0.15573102f, 0.01846495f, -0.01921560f, -0.08733653f, 0.12379929f, 0.03620461f, 
    0.13324778f, -0.21623422f, 0.03637360f, 0.01273185f, -0.05039002f, -0.05092582f, -0.07683393f, -0.08521889f, 
    0.13518110f, 0.06328993f, 0.03314776f, -0.08016274f, 0.41595426f, -0.10969472f, -0.11161276f, 0.04490355f, 
    -0.07248081f, 0.01058677f, 0.06243468f, -0.02014248f, 0.09058650f, 0.01999563f, 0.03904191f, -0.08469626f, 
    0.11364309f, 0.10096227f, 0.21128599f, -0.06720935f, 0.07615823f, -0.03850897f, 0.14599560f, -0.06326461f, 
    0.06018682f, -0.05795972f, -0.04415868f, -0.06675076f, 0.19809166f, 0.07302371f, 0.04754782f, -0.24587657f, 
    0.06905843f, 0.08837070f, 0.08565352f, 0.16134562f, 0.02075099f, -0.12454067f, -0.06123817f, 0.06946622f, 
    0.05231056f, 0.13443527f, 0.07853661f, 0.02543012f, -0.05120169f, -0.13810979f, 0.00505631f, 0.03202396f, 
    0.07379428f, -0.04696776f, 0.08652990f, -0.04449387f, 0.10240974f, 0.07177328f, -0.04403676f, -0.03920381f, 
    -0.05419914f, 0.08154367f, 0.07969060f, -0.03532568f, -0.04790166f, 0.02202195f, -0.00121910f, -0.07032806f, 
    -0.01788148f, -0.02341871f, 0.15276255f, 0.19573520f, 0.09911954f, 0.17091800f, -0.04811827f, -0.03060298f, 
    0.04306324f, -0.08193233f, 0.03694323f, 0.04298643f, 0.00840534f, -0.24709465f, -0.35952243f, -0.18578511f, 
    -0.01426516f, 0.01598551f, 0.13453136f, -0.01490809f, 0.02289688f, 0.03088674f, -0.03288091f, 0.05230608f, 
    0.00924812f, -0.03977733f, -0.00562384f, 0.06483895f, 0.04522081f, 0.05477014f, -0.00484596f, 0.02407788f, 
    -0.05149242f, 0.03450072f, 0.04430200f, -0.03823100f, -0.01595651f, 0.00430355f, 0.00551629f, 0.05845637f, 
    -0.03594166f, 0.00470817f, -0.04906726f, 0.03744370f, -0.04478591f, 0.02550839f, 0.01775028f, 0.04751183f, 
    -0.06495252f, -0.02740335f, 0.05884194f, -0.05431290f, 0.04982234f, -0.04933640f, -0.05863373f, 0.02494666f, 
    -0.01757682f, 0.03805610f, -0.07605054f, -0.02310222f, 0.01598469f, -0.01306995f, -0.01229889f, -0.04272367f, 
    -0.06318700f, -0.05994419f, 0.02525227f, 0.00514684f, 0.02660696f, -0.00364732f, 0.04172937f, 0.04521932f, 
    -0.00544136f, 0.05730147f, -0.04080103f, 0.05233312f, -0.06269265f, -0.03495161f, 0.00856026f, 0.00856218f, 
    0.03025845f, -0.02591308f, -0.04409001f, 0.01319010f, -0.02632807f, -0.00038089f, -0.07625973f, 0.02454972f, 
    0.05360193f, -0.05980583f, -0.01928602f, 0.01674229f, -0.02761495f, -0.04000618f, -0.00985010f, -0.03373824f, 
    0.01680791f, -0.06212544f, -0.04364951f, 0.00066743f, -0.04784307f, -0.05719190f, 0.04249911f, -0.04930218f, 
    -0.02641974f, 0.04084985f, 0.04364177f, 0.04918995f, -0.03881336f, -0.07318658f, 0.03727478f, -0.06310760f, 
    0.05573795f, -0.00933397f, -0.03187054f, -0.06764968f, 0.02035698f, -0.00819760f, 0.00424485f, 0.03186576f, 
    0.04520507f, -0.01258004f, 0.05123624f, -0.04667075f, -0.02811668f, -0.05305214f, -0.05128816f, -0.04735853f, 
    0.04197217f, 0.05936350f, -0.03009683f, -0.04698876f, -0.00828209f, 0.04744919f, -0.00191825f, 0.07580456f, 
    -0.01159323f, -0.02517306f, -0.04311264f, -0.02205823f, 0.00948166f, -0.06339107f, -0.07766937f, -0.05649582f, 
    0.01977717f, 0.00961817f, 0.02966466f, 0.01012933f, 0.03781011f, 0.01044832f, -0.03799774f, -0.03429168f, 
    -0.03383821f, -0.06376763f, 0.00351963f, 0.02029485f, -0.05950944f, 0.04533685f, -0.05905762f, 0.00589339f, 
    -0.00970588f, 0.05052331f, -0.02564985f, -0.07992186f, -0.00275771f, -0.06435858f, 0.03983113f, -0.04979559f, 
    0.04473323f, 0.02237347f, -0.00807886f, -0.07983925f, -0.07681119f, 0.01352389f, 0.02986381f, 0.02446419f, 
    0.05238660f, 0.02517268f, -0.03744364f, 0.02449948f, 0.01116435f, -0.03531862f, -0.03328252f, 0.01949122f, 
    0.00273847f, -0.05149306f, -0.07549377f, -0.08235253f, 0.05285154f, -0.01967372f, 0.02633642f, -0.02969390f, 
    0.02821261f, 0.00495677f, -0.00806990f, 0.01270038f, -0.01894236f, -0.00925494f, -0.00215662f, -0.00333051f, 
    -0.01712948f, 0.04763049f, -0.02032076f, -0.02889254f, -0.04958431f, -0.02485489f, -0.05625383f, 0.03183064f, 
    0.02544121f, 0.04673495f, -0.07265950f, 0.00213837f, -0.01748798f, 0.04304204f, 0.03823486f, -0.03390827f, 
    0.01466502f, -0.54629523f, -0.40312093f, 0.05827418f, -0.10946102f, 0.14898504f, 0.01453096f, 0.07705165f, 
    -0.04110863f, -0.16093938f, 0.03839244f, -0.02133128f, 0.05257296f, -0.05395301f, 0.02258636f, -0.19202545f, 
    0.29480457f, 0.20358403f, 0.22772747f, -0.07515550f, 0.03861613f, -0.06490360f, 0.02981292f, -0.01755765f, 
    0.14799790f, 0.13229509f, 0.05601243f, -0.00410590f, 0.15357031f, -0.06070393f, -0.07888552f, 0.04885253f, 
    -0.01163718f, -0.03862293f, -0.03535230f, -0.03655556f, 0.01555348f, -0.08475526f, -0.16358155f, 0.15025380f, 
    -0.07318021f, -0.04980483f, -0.17006487f, -0.04703085f, -0.04829634f, 0.06576729f, -0.08872980f, 0.03729029f, 
    0.22410758f, 0.19216317f, -0.31419569f, -0.37937501f, -0.12254516f, -0.00185165f, -0.09479276f, -0.20520952f, 
    -0.15680753f, -0.04230226f, -0.05875033f, -0.23412476f, 0.00818530f, -0.25825512f, -0.03608599f, -0.39507243f, 
    -0.17848694f, -0.12842011f, 0.16453819f, -0.10026901f, 0.10752705f, 0.14135158f, 0.05306483f, -0.00830848f, 
    0.05690267f, 0.11558971f, 0.00743183f, 0.02400559f, 0.12871924f, -0.05830429f, 0.11016129f, -0.01284786f, 
    0.16142046f, -0.06691910f, 0.19137862f, -0.06564231f, 0.45179188f, 0.44852450f, 0.28960156f, 0.21135040f, 
    0.07398542f, 0.11430307f, 0.21965958f, 0.01307331f, -0.06948292f, 0.02997501f, 0.08520069f, 0.06655188f, 
    0.04465564f, 0.22490960f, 0.03431174f, 0.07876921f, -0.07757302f, 0.08101942f, 0.04309696f, -0.06466145f, 
    0.12022056f, 0.03520622f, 0.07612567f, 0.09177960f, -0.02582579f, 0.07295810f, -0.09670936f, 0.27487549f, 
    -0.00398554f, 0.04005474f, -0.12318142f, -0.10678241f, 0.02684627f, -0.08243879f, 0.01091493f, 0.00691973f, 
    0.12523311f, -0.05308725f, -0.16291738f, -0.25305930f, 0.03930451f, -0.19110210f, -0.01697249f, -0.08338103f, 
    0.05944411f, -0.07348523f, 0.06766091f, 0.03680787f, -0.06700322f, -0.03676743f, 0.05747747f, -0.03481547f, 
    0.15568525f, -0.02474962f, -0.07190811f, -0.04124906f, 0.10379877f, 0.20595120f, 0.10334039f, 0.09351423f, 
    -0.05315711f, 0.00686651f, -0.03736006f, 0.06604989f, 0.02948078f, -0.07982692f, -0.19581775f, 0.04277344f, 
    -0.26032522f, 0.06952295f, -0.20631686f, -0.05159410f, -0.07681745f, 0.00846125f, 0.08643174f, -0.02356827f, 
    -0.14869426f, -0.09744047f, 0.00060036f, 0.16132168f, -0.06619712f, 0.06346530f, 0.09485061f, 0.40090820f, 
    0.31624180f, 0.28154761f, 0.38536835f, 0.27935067f, -0.05237396f, 0.10643519f, -0.09110259f, -0.08579965f, 
    -0.02284639f, -0.02136468f, 0.07820616f, -0.01204105f, 0.19665736f, -0.33884466f, 0.01966408f, -0.09524536f, 
    0.03370066f, -0.18033054f, -0.01278632f, 0.05007335f, 0.06631952f, 0.15205996f, 0.02834886f, -0.02518958f, 
    0.33425194f, 0.06088538f, 0.34348074f, 0.19984457f, 0.05622328f, 0.12825628f, 0.12501365f, -0.11929028f, 
    0.02292736f, 0.12202533f, 0.01238040f, 0.08097500f, -0.09439973f, 0.03374251f, -0.12569235f, -0.00236190f, 
    0.03746230f, 0.02287721f, -0.10002517f, -0.03116435f, 0.04655992f, 0.00068297f, -0.04418941f, 0.00306827f, 
    -0.32796416f, -0.11022943f, -0.17691079f, -0.03934982f, -0.14913967f, -0.06719400f, 0.00698734f, 0.01890147f, 
    -0.20329113f, -0.07535804f, -0.20602109f, -0.28185737f, 0.14637391f, 0.01574276f, -0.08368092f, -0.02359181f, 
    0.12256283f, -0.01901936f, 0.13995439f, 0.12032264f, -0.25177544f, -0.14818229f, -0.16939580f, -0.15519865f, 
    0.16653781f, 0.15145256f, -0.05894270f, 0.19091612f, -0.13616280f, 0.04693029f, -0.12587003f, -0.08040076f, 
    0.03197285f, 0.08533155f, -0.18146212f, -0.12286736f, 0.13327856f, 0.21286695f, 0.11340088f, 0.35651579f, 
    0.04707392f, 0.07131170f, 0.16612962f, -0.01543719f, 0.10193586f, 0.03839247f, -0.03420293f, 0.17273794f, 
    -0.08779211f, -0.13756952f, -0.10151439f, -0.20618452f, -0.08733689f, -0.11801155f, -0.02602766f, -0.06706832f, 
    0.07830360f, 0.06181176f, 0.14988048f, 0.24779959f, -0.55799329f, 0.11725207f, -0.06170675f, -0.00959564f, 
    0.10915420f, 0.03099010f, -0.25085446f, -0.07699959f, -0.10901165f, 0.07568977f, 0.04769599f, 0.27821809f, 
    -0.21600199f, -0.20045958f, -0.28021884f, -0.03922011f, -0.02496168f, -0.10679604f, -0.06004473f, -0.07302850f, 
    0.05688256f, 0.05407194f, 0.07512656f, 0.10207976f, -0.05668778f, -0.04943549f, -0.15348242f, -0.35478127f, 
    -0.07290838f, 0.10269609f, 0.13736209f, -0.02154039f, -0.09044940f, 0.19510502f, 0.07870273f, -0.05496003f, 
    0.19712700f, 0.18306915f, 0.04626748f, 0.05818776f, -0.02437340f, 0.03975189f, 0.01365187f, 0.10861236f, 
    0.10371790f, -0.05905531f, -0.01792291f, -0.05252854f, 0.08897126f, 0.19840199f, 0.11535335f, -0.02232810f, 
    0.12824889f, 0.01882198f, 0.07689578f, 0.14025527f, 0.01878186f, 0.09939932f, 0.10995626f, 0.23881130f, 
    -0.12083340f, 0.09477758f, -0.04748702f, 0.21803471f, 0.06985150f, -0.11581703f, -0.04026491f, -0.01157489f, 
    0.11500739f, 0.11295859f, -0.06782594f, -0.17169681f, 0.20598705f, -0.03870131f, 0.16940892f, 0.10245838f, 
    0.10808582f, -0.03195231f, -0.04622009f, 0.04356410f, -0.05010370f, -0.10977419f, 0.14969252f, -0.34331611f, 
    -0.21863717f, -0.48100477f, 0.09017139f, -0.20559362f, 0.04601586f, 0.14293320f, -0.17348202f, 0.20034061f, 
    -0.06007427f, -0.04496843f, 0.05865291f, 0.11215039f, 0.17977779f, 0.32496145f, -0.02233849f, 0.06959189f, 
    -0.06818953f, 0.11662661f, -0.04672922f, 0.02349106f, 0.06128563f, -0.00997947f, -0.15998521f, -0.04274810f, 
    0.30721202f, -0.16244172f, 0.13328986f, -0.08206791f, -0.04066015f, -0.05361792f, 0.06855358f, -0.02638208f, 
    -0.06181818f, -0.01981623f, 0.05150643f, 0.08894431f, 0.00664518f, 0.00023168f, -0.03968693f, -0.09864232f, 
    0.00489092f, 0.03482726f, -0.01771367f, -0.13087553f, -0.11150225f, -0.04672917f, 0.14794208f, -0.08777507f, 
    0.10233247f, 0.17996599f, 0.12566972f, 0.06520627f, -0.08076903f, -0.06571832f, 0.07540458f, 0.06142461f, 
    -0.01207236f, -0.12083411f, 0.03742974f, -0.08213022f, -0.06671467f, 0.00490067f, -0.04003060f, 0.16283853f, 
    -0.00471839f, 0.01515489f, -0.09325811f, 0.10387918f, -0.18403448f, -0.02166326f, -0.09446628f, 0.01676975f, 
    0.21902789f, 0.17037947f, -0.00191901f, -0.04452371f, -0.05675719f, -0.09329244f, 0.06615698f, -0.13864322f, 
    -0.04474480f, -0.02931499f, -0.12800270f, -0.12939239f, 0.09869313f, 0.19297223f, -0.05429325f, 0.17501445f, 
    0.04183572f, -0.06495485f, 0.09094070f, 0.06507584f, 0.08601414f, 0.18883650f, -0.11055133f, 0.12529650f, 
    0.01872560f, -0.16708302f, 0.26594374f, -0.20179489f, -0.02599538f, -0.05126343f, 0.09867333f, -0.04231205f, 
    0.11047158f, 0.01642541f, 0.19820182f, 0.04597666f, 0.25649193f, -0.06642020f, 0.19413207f, -0.14584276f, 
    -0.05402489f, -0.03488610f, 0.12689649f, -0.13395478f, -0.01371347f, 0.07662044f, 0.05672828f, 0.04684339f, 
    -0.15459733f, 0.41379690f, -0.29732156f, 0.12701073f, 0.03663764f, 0.00550121f, 0.15112169f, -0.06517186f, 
    0.07664948f, -0.02633282f, 0.16663921f, 0.03449652f, -0.21776623f, -0.13638607f, -0.06859392f, -0.21921028f, 
    0.03027820f, 0.06093859f, 0.10429913f, -0.06672874f, -0.02280744f, 0.05346235f, 0.00453270f, 0.00703074f, 
    -0.15563616f, 0.18295550f, 0.00530500f, -0.06730946f, 0.06193085f, -0.02945166f, -0.07143568f, -0.16398121f, 
    0.13452536f, -0.06599047f, -0.04611697f, -0.06590633f, 0.01458895f, 0.18215588f, 0.01043617f, 0.11508178f, 
    0.14588264f, 0.01966074f, -0.08394412f, 0.10800049f, 0.08051977f, 0.03687008f, 0.06124386f, 0.11168072f, 
    -0.02845937f, 0.37052602f, -0.17623296f, 0.22791401f, 0.06607519f, -0.24154924f, 0.03107976f, -0.11870919f, 
    -0.13702700f, 0.05204418f, 0.04490986f, -0.02027012f, 0.10530744f, 0.08981713f, 0.36670125f, 0.18002298f, 
    -0.01372387f, 0.14141506f, -0.07312106f, 0.06206176f, -0.03844400f, 0.08258297f, 0.02666547f, 0.15614390f, 
    0.33009458f, -0.25481009f, 0.39894861f, 0.14418170f, -0.10578478f, 0.01932121f, -0.03837099f, -0.07735706f, 
    -0.13843897f, -0.02717902f, 0.09524751f, -0.08615295f, -0.05204232f, 0.27353883f, -0.38051042f, 0.22692733f, 
    0.06727345f, 0.05910191f, -0.12320418f, 0.22982022f, 0.12682417f, -0.01833599f, -0.10702801f, -0.13824600f, 
    0.07476125f, 0.15179479f, -0.13672081f, -0.12340409f, 0.09771721f, 0.04972538f, 0.04510847f, 0.04122349f, 
    0.21517143f, 0.02076801f, -0.09470139f, -0.08133638f, 0.12438377f, -0.06247203f, 0.35132933f, 0.02340049f, 
    -0.00205995f, 0.21832599f, 0.02737449f, 0.11304974f, -0.01954639f, 0.04271161f, 0.14876214f, -0.21210201f, 
    -0.21753962f, -0.04569966f, -0.03481364f, -0.16806100f, 0.14972733f, 0.15858305f, -0.10820939f, -0.00311054f, 
    -0.19436415f, 0.05870149f, -0.07560286f, 0.17798989f, -0.12435360f, 0.06860419f, -0.18964683f, -0.07921268f, 
    0.02747889f, -0.00205974f, -0.05034754f, -0.10712922f, 0.03709774f, -0.08325641f, -0.06391845f, -0.06485686f, 
    0.20538586f, 0.04698214f, 0.03245295f, -0.22845571f, 0.17520370f, 0.18948750f, 0.17645444f, 0.30922565f, 
    -0.08862303f, 0.00101556f, 0.08223899f, -0.02930961f, 0.14462307f, 0.04115015f, -0.16644379f, -0.05229585f, 
    0.00366097f, -0.02496351f, -0.15706760f, 0.15852840f, 0.03154869f, 0.12234218f, 0.05099366f, 0.02200902f, 
    -0.10947972f, -0.14564943f, 0.23575848f, 0.11407014f, -0.23288326f, 0.08226730f, -0.06084285f, -0.00444328f, 
    -0.02527175f, -0.03669740f, 0.08161014f, -0.04087156f, 0.03206129f, -0.23636812f, -0.07158621f, 0.07068589f, 
    -0.03574482f, 0.11778878f, -0.00919675f, -0.10079643f, -0.12483172f, -0.25917509f, -0.08502237f, -0.18477471f, 
    0.04714679f, -0.04407744f, 0.02455736f, -0.13861869f, -0.08899774f, -0.10972487f, 0.11117562f, -0.02241415f, 
    -0.08425090f, 0.14227629f, 0.01868017f, 0.03446255f, 0.23193231f, 0.13838752f, 0.36535403f, -0.16480719f, 
    -0.16987288f, -0.31103396f, -0.02640175f, -0.04031929f, 0.27235740f, -0.05671852f, 0.14792259f, 0.08943851f, 
    0.16954692f, 0.14823842f, 0.02905112f, -0.11899786f, 0.17042506f, 0.15280260f, -0.01607405f, 0.08827779f, 
    0.09232198f, -0.06223166f, -0.08846751f, -0.06172342f, 0.18902867f, -0.00451532f, -0.03583827f, -0.00064294f, 
    0.06783236f, 0.22388217f, 0.12817775f, 0.08021845f, -0.08693501f, 0.11805588f, 0.08395109f, 0.15819477f, 
    -0.11209563f, 0.11622088f, 0.18894717f, -0.19820423f, -0.05554532f, 0.19072433f, 0.15876256f, -0.14617467f, 
    -0.00141565f, -0.19305681f, 0.13332522f, 0.03470998f, -0.00659247f, 0.17600389f, -0.30082214f, -0.00248534f, 
    0.11611488f, 0.09409811f, -0.11558927f, -0.14031617f, -0.03700586f, 0.11086390f, -0.06364664f, 0.20283207f, 
    -0.06440052f, -0.00751939f, -0.29147983f, 0.31940097f, 0.15908130f, -0.25139013f, -0.01633158f, -0.33867010f, 
    -0.05352623f, -0.03461803f, -0.10655541f, 0.04794285f, -0.28173867f, -0.04651735f, 0.00535382f, -0.06425054f, 
    -0.09372011f, 0.08390412f, 0.08155693f, -0.02563116f, 0.11960709f, 0.10160825f, -0.05309078f, 0.04437872f, 
    -0.03948276f, 0.03288444f, 0.26106158f, 0.09688341f, -0.16527189f, -0.10453030f, 0.00457853f, 0.00944314f, 
    -0.15167254f, -0.05692509f, 0.09771275f, 0.03949634f, -0.16143152f, -0.06973633f, -0.06839789f, 0.10828626f, 
    -0.22730935f, -0.06231613f, -0.07976702f, 0.11560403f, -0.00053705f, -0.09527476f, -0.04691916f, -0.04277248f, 
    0.04476145f, -0.08197487f, -0.05432010f, 0.15214282f, -0.01820315f, -0.11231488f, -0.00024445f, 0.06169016f, 
    -0.00333333f, 0.06931287f, -0.04598156f, -0.09544545f, 0.10596339f, -0.00006780f, 0.01420840f, 0.02831799f, 
    0.22652407f, -0.03154349f, 0.03180124f, 0.01859171f, 0.00877282f, 0.02007302f, -0.01324275f, 0.05298474f, 
    -0.06867711f, -0.06840911f, 0.06533408f, 0.27911720f, -0.07947484f, 0.00963076f, -0.08734465f, -0.26764339f, 
    -0.03912431f, 0.00915378f, -0.10142072f, -0.04130945f, -0.21587086f, 0.29675972f, -0.02781042f, 0.16424733f, 
    -0.09239361f, 0.05258898f, 0.07686877f, -0.01287453f, -0.07698145f, 0.13435273f, 0.00011282f, 0.00047118f, 
    0.15925689f, -0.01062027f, 0.00142323f, -0.12323118f, -0.10628952f, 0.07730312f, -0.03188893f, -0.02610457f, 
    0.16268481f, 0.14646195f, 0.17341711f, -0.00573263f, 0.15407866f, -0.22348619f, 0.00319581f, 0.09464812f, 
    -0.04129386f, -0.13667311f, -0.07470647f, -0.15540455f, 0.12426005f, -0.10284074f, -0.06470794f, 0.09939346f, 
    0.16536659f, 0.05860436f, -0.10274175f, 0.20086180f, 0.08155649f, 0.04068913f, -0.03960839f, 0.09249030f, 
    0.04543262f, 0.03467193f, -0.12851332f, -0.01993558f, 0.01051642f, -0.02146901f, 0.22084852f, 0.01593646f, 
    0.06681878f, 0.05561306f, 0.01245837f, 0.06073399f, -0.08554748f, 0.08640292f, -0.07066369f, 0.15585989f, 
    -0.08617622f, -0.24969056f, 0.13344955f, 0.20881820f, 0.06100763f, -0.18706879f, 0.01604079f, 0.05538213f, 
    -0.06851013f, -0.10633732f, 0.06147738f, 0.01568294f, -0.15173526f, 0.04213964f, 0.02373278f, 0.00241946f, 
    -0.17606765f, 0.05188799f, -0.11025257f, -0.04262167f, -0.02292546f, -0.02671487f, 0.09543535f, 0.08748315f, 
    0.12224498f, -0.09699982f, -0.03339644f, 0.12276480f, 0.15964910f, -0.06659977f, -0.07845205f, 0.02723937f, 
    -0.09808669f, -0.04269886f, 0.03866961f, -0.08144615f, 0.20042622f, 0.04118571f, 0.18991600f, 0.12361483f, 
    0.06179996f, -0.09516818f, 0.09115632f, -0.17036419f, -0.00391117f, -0.05179445f, 0.00398401f, -0.11204860f, 
    0.45534983f, 0.10213003f, 0.21237932f, -0.21185805f, 0.07040688f, -0.08523637f, -0.01132823f, 0.04710950f, 
    0.02847384f, -0.05683899f, -0.07560850f, -0.00057331f, 0.11831366f, 0.42982650f, -0.00036764f, 0.11088619f, 
    -0.10375547f, 0.09740553f, 0.08888245f, -0.02777682f, -0.04933392f, 0.17167619f, -0.07919593f, -0.02812582f, 
    0.00877130f, 0.00177808f, 0.00828698f, 0.04350149f, 0.06948931f, 0.05729740f, 0.01693738f, -0.03603059f, 
    -0.03268862f, -0.00180538f, -0.00800604f, -0.05390624f, 0.03173288f, -0.06264159f, 0.01999985f, 0.00755913f, 
    -0.06238229f, 0.05303301f, 0.00125724f, 0.01837920f, -0.06129522f, -0.02289149f, 0.03554831f, 0.06868278f, 
    -0.00421495f, -0.02700377f, -0.00621893f, -0.00725966f, 0.00126880f, -0.05483199f, 0.02352029f, 0.01457201f, 
    -0.03057051f, -0.06257903f, -0.00086265f, -0.06399730f, 0.05290741f, 0.03997454f, -0.07670782f, 0.05540522f, 
    0.03635801f, -0.07928301f, 0.02322945f, -0.05050628f, 0.01297796f, -0.01349747f, 0.05637405f, 0.05193305f, 
    0.00063955f, -0.02967479f, 0.00459111f, 0.02261614f, -0.01756861f, -0.02828805f, -0.05800084f, -0.07316742f, 
    -0.05016279f, -0.03722664f, -0.04690399f, -0.01401052f, 0.03096214f, -0.03075758f, 0.02041504f, 0.01677534f, 
    0.02414942f, -0.05023992f, -0.06891118f, -0.00593505f, -0.05707888f, -0.05729776f, -0.04223833f, -0.04084333f, 
    -0.05374122f, -0.07373295f, -0.02008794f, 0.04138120f, -0.04003262f, 0.02820805f, -0.04389682f, -0.06914538f, 
    -0.02463962f, 0.01551575f, -0.04682149f, -0.05076235f, 0.06215719f, -0.01588364f, -0.05184916f, -0.06733476f, 
    -0.03819177f, 0.03998931f, 0.01819823f, 0.03368076f, 0.01287419f, -0.04123702f, -0.00180378f, 0.05225587f, 
    0.03978021f, 0.00775691f, 0.05547122f, 0.01902089f, -0.06073729f, -0.06190969f, 0.01179830f, -0.02479061f, 
    -0.04483940f, -0.00469450f, -0.01662206f, 0.04702939f, 0.04930218f, -0.07390907f, -0.05087712f, -0.02598729f, 
    0.04289455f, 0.02018402f, -0.02436168f, -0.02567584f, -0.00923578f, -0.07140090f, -0.04423875f, -0.01100530f, 
    -0.07417790f, 0.04297878f, -0.00934482f, -0.03321624f, -0.04045504f, -0.04147992f, 0.00807238f, 0.04332212f, 
    -0.03186361f, 0.02363633f, -0.05652180f, 0.04442499f, 0.03278642f, 0.00730647f, 0.05244066f, -0.01748379f, 
    -0.00657835f, 0.05563293f, -0.03115387f, 0.02643784f, -0.00005108f, -0.01851506f, -0.04566255f, -0.06549186f, 
    0.03437626f, -0.07756547f, -0.00359691f, 0.03092741f, -0.04025153f, -0.03909151f, 0.05118588f, -0.00267258f, 
    0.03036906f, 0.03633994f, 0.02301198f, 0.03527326f, -0.05999298f, 0.06112621f, -0.05874890f, 0.03327329f, 
    0.06009500f, 0.05316744f, 0.02882187f, 0.04140025f, 0.00846896f, 0.03299927f, 0.02687853f, 0.01495626f, 
    -0.01132173f, 0.01557033f, 0.01118296f, -0.00429728f, -0.03651951f, 0.01119929f, -0.01778005f, 0.03722345f, 
    -0.02369814f, 0.05453487f, -0.06642258f, -0.06869563f, -0.05380943f, 0.05717412f, 0.02804468f, -0.03980717f, 
    -0.04342249f, -0.02222404f, -0.01153883f, 0.01931065f, -0.05694354f, -0.07351808f, 0.03673681f, -0.00081663f, 
    -0.50947535f, -0.09602306f, -0.28115347f, 0.14171055f, 0.06909867f, 0.12879305f, -0.03410897f, 0.01174169f, 
    -0.02294526f, 0.05374989f, -0.04596962f, -0.10549524f, -0.15325813f, 0.03057709f, 0.14483511f, -0.07264411f, 
    0.12134055f, 0.16842455f, 0.15911280f, -0.14585790f, -0.08451343f, 0.06123559f, 0.01517553f, -0.13318032f, 
    0.04750957f, 0.04882716f, -0.00286506f, 0.05934364f, -0.00449639f, -0.01765672f, -0.16689903f, -0.17509839f, 
    -0.07549813f, -0.09959790f, -0.14618729f, -0.04686347f, -0.04834898f, -0.01688512f, -0.03779789f, 0.10920657f, 
    -0.02994580f, 0.17009737f, -0.04928979f, -0.08417909f, -0.03953097f, -0.06987144f, -0.10537917f, -0.01534956f, 
    -0.06225691f, 0.06628650f, -0.27140164f, -0.34712908f, 0.06841640f, 0.05853075f, 0.14202483f, 0.20985803f, 
    -0.06152749f, -0.06448367f, -0.03467307f, 0.05213413f, -0.23284811f, -0.49856368f, -0.15390816f, -0.30074108f, 
    0.12666911f, -0.01574299f, -0.05057223f, 0.04090602f, 0.25665036f, 0.08236670f, 0.22864150f, -0.04916049f, 
    0.03612557f, -0.01717702f, 0.11005601f, 0.09471520f, 0.03753779f, -0.02135117f, 0.08083077f, -0.04614723f, 
    0.08532603f, -0.17311096f, 0.06050608f, 0.03477344f, 0.07476076f, 0.36469752f, 0.20650934f, 0.39716601f, 
    0.26553926f, 0.20790863f, 0.18754713f, 0.17441188f, -0.02492642f, -0.08447932f, 0.02575522f, -0.01620749f, 
    0.04380353f, 0.12475124f, 0.19536966f, 0.06887071f, 0.03271629f, 0.07853914f, -0.10525604f, -0.02269514f, 
    -0.15944825f, 0.09885041f, -0.07664757f, -0.12401561f, 0.08362541f, 0.12284043f, 0.16371615f, 0.30328429f, 
    -0.04480023f, -0.03919451f, -0.01727869f, -0.18922600f, -0.08595649f, -0.09069180f, 0.04877566f, 0.13439287f, 
    0.36248174f, 0.27454731f, -0.15047175f, -0.61383528f, -0.01205394f, 0.11463883f, 0.34779823f, 0.31291029f, 
    0.01136758f, -0.03016486f, 0.06406984f, -0.01781049f, 0.17850463f, -0.09722957f, -0.23733179f, -0.39653316f, 
    0.10381103f, -0.09429001f, -0.16689703f, 0.03721660f, 0.13882892f, 0.06602181f, 0.13223872f, 0.24014883f, 
    0.07774828f, 0.07390440f, -0.13098645f, 0.01032122f, 0.17880754f, 0.30550253f, -0.04606219f, -0.08583473f, 
    0.03343965f, -0.14132340f, -0.20468354f, -0.02189537f, 0.11901357f, -0.16288398f, -0.35167462f, -0.07524906f, 
    0.05137552f, 0.07377991f, -0.03309387f, 0.04405662f, 0.12516440f, -0.03886626f, -0.00613457f, -0.14782177f, 
    0.27437985f, 0.19072203f, 0.17144124f, 0.39496762f, 0.04355876f, -0.01334986f, -0.00240282f, -0.03717607f, 
    -0.01343742f, -0.09223767f, -0.07602043f, 0.12404056f, 0.26831961f, -0.31408873f, -0.02546278f, -0.29299831f, 
    -0.13293459f, 0.11982642f, -0.05550650f, 0.07384099f, 0.10399047f, 0.02055575f, 0.03346240f, -0.13605143f, 
    -0.06019760f, -0.01948496f, -0.06465427f, -0.06324635f, -0.07601159f, -0.06852414f, 0.02530720f, -0.00845533f, 
    0.06177865f, -0.02312760f, -0.07353218f, -0.07660628f, 0.00511852f, 0.03443205f, -0.03506591f, -0.06193247f, 
    -0.00374029f, 0.02701940f, 0.04189785f, -0.07533601f, -0.00467527f, -0.04735415f, 0.05449137f, -0.00596313f, 
    -0.02990203f, -0.07151248f, 0.04713715f, 0.01583206f, -0.06540929f, -0.06598414f, -0.06324399f, 0.02526345f, 
    -0.05679186f, 0.02368759f, 0.00964545f, 0.01311985f, -0.01628267f, -0.01103882f, -0.04060797f, -0.06238934f, 
    -0.00657794f, 0.03655129f, 0.04546706f, -0.04379445f, -0.00801446f, -0.06203607f, 0.01764817f, 0.03912280f, 
    -0.01262654f, -0.08179843f, 0.02048803f, -0.03133646f, -0.04637814f, 0.04022883f, -0.02510232f, -0.03070058f, 
    -0.06146784f, 0.05409691f, -0.06325455f, 0.05870332f, 0.05620427f, -0.04645549f, -0.05059216f, 0.02430095f, 
    0.03433545f, -0.04249548f, -0.03490717f, 0.01887849f, 0.04813733f, -0.00721150f, -0.05798312f, -0.00249723f, 
    0.06015385f, -0.03777021f, -0.07194601f, 0.06495148f, -0.05872374f, -0.03986922f, -0.05634477f, -0.02841212f, 
    -0.00103539f, 0.03578850f, 0.00065131f, 0.03472955f, 0.04032458f, 0.02625800f, -0.00856570f, 0.02350924f, 
    -0.00805910f, 0.03699937f, 0.03224154f, -0.07891112f, -0.02339299f, -0.00999061f, -0.04633540f, -0.03705467f, 
    -0.06856550f, -0.05858362f, -0.00794239f, -0.07255471f, 0.05826705f, 0.05489546f, -0.01625608f, -0.00846411f, 
    0.00915294f, 0.00197137f, 0.01777706f, -0.07213156f, 0.03969155f, -0.01131550f, -0.00677894f, 0.02713403f, 
    0.03547857f, -0.08052145f, 0.05290105f, -0.02122421f, -0.07088070f, 0.00770837f, 0.04970135f, 0.02630822f, 
    -0.01997308f, -0.02771205f, -0.02881619f, -0.06158852f, -0.04340774f, 0.05956697f, 0.00993013f, -0.04322996f, 
    -0.00809046f, -0.05719104f, 0.03523542f, -0.08080848f, -0.07115063f, -0.05584148f, -0.05753932f, -0.00050538f, 
    0.02884328f, -0.06962680f, -0.02265657f, -0.01110093f, -0.04475995f, -0.07212989f, -0.00302175f, -0.01564931f, 
    0.01829155f, 0.01746256f, -0.02185462f, -0.00527073f, 0.05490218f, 0.01282130f, -0.02673825f, 0.04682330f, 
    -0.04146640f, -0.04617045f, 0.02788269f, -0.07038541f, 0.00114494f, 0.03621432f, 0.00103839f, -0.05420236f, 
    -0.05635787f, 0.02191409f, 0.00111153f, -0.03593310f, 0.00317391f, 0.03509967f, -0.07467055f, 0.05712708f, 
    -0.06609238f, -0.01495201f, -0.04765178f, 0.03048353f, -0.03065649f, -0.02907906f, -0.07342132f, 0.06237086f, 
    -0.01190378f, 0.02556999f, 0.05167931f, -0.03052939f, -0.02362110f, -0.05102931f, 0.00692916f, -0.01537727f, 
    0.04823408f, 0.03988219f, 0.05820746f, 0.02225427f, -0.02581562f, 0.01579976f, 0.05074120f, -0.01026675f, 
    -0.19078019f, -0.13551271f, 0.09417331f, 0.08989023f, -0.07101218f, -0.09060083f, 0.01856926f, 0.03389639f, 
    0.23929499f, -0.02966671f, 0.15608913f, 0.02552742f, -0.36580831f, -0.10858624f, 0.08142721f, 0.29587081f, 
    0.14128439f, 0.09364510f, 0.15180579f, -0.00678999f, 0.06689707f, -0.01245521f, 0.04370056f, -0.06109526f, 
    0.11262612f, -0.06143721f, 0.06252773f, 0.13788161f, 0.09302218f, -0.01076658f, 0.06149893f, 0.06184763f, 
    -0.05446775f, -0.08415940f, 0.02305490f, 0.07490903f, -0.15891808f, -0.01580608f, -0.01927694f, -0.13513856f, 
    0.05121922f, -0.04380178f, -0.08894861f, -0.11525572f, -0.03636106f, 0.12535959f, -0.19078097f, 0.02366313f, 
    -0.21564703f, 0.14165500f, 0.07330139f, 0.10418128f, 0.04996210f, -0.06037170f, 0.18218228f, 0.02487510f, 
    -0.05481912f, 0.03146242f, 0.08125270f, 0.05429558f, 0.02259986f, 0.09548436f, 0.10662758f, -0.26884750f, 
    -0.13553394f, 0.04773004f, 0.21152309f, -0.01429916f, 0.09119395f, 0.12324245f, -0.00642347f, -0.16519275f, 
    -0.09337818f, -0.04816964f, -0.21448565f, 0.00400706f, 0.04876089f, 0.05320803f, -0.03374812f, -0.00605863f, 
    0.09766194f, -0.00760982f, 0.01793712f, -0.03249428f, 0.28981826f, 0.14498419f, -0.11658919f, -0.32038665f, 
    0.09709102f, 0.08717737f, 0.11408246f, -0.18379772f, -0.10966014f, -0.07466415f, 0.04610471f, 0.04380516f, 
    0.10058563f, -0.05685782f, 0.05188332f, -0.09904406f, -0.03768408f, 0.04195828f, 0.04823269f, 0.09102686f, 
    0.04145035f, 0.02718740f, 0.00567265f, -0.03676047f, -0.24213396f, -0.45303187f, -0.00270308f, 0.58027774f, 
    0.02691462f, -0.19583459f, -0.10137580f, 0.16464791f, 0.24101822f, 0.16736269f, 0.15391803f, 0.11262349f, 
    -0.03316692f, -0.01464013f, 0.19699092f, -0.04342251f, -0.09128677f, -0.07783274f, 0.02089164f, -0.18327448f, 
    0.14126687f, 0.04968276f, 0.07748143f, 0.01309274f, 0.12854189f, 0.18078113f, 0.02502039f, -0.19284090f, 
    -0.01272103f, -0.00257009f, -0.02389475f, -0.02065922f, 0.09073903f, 0.05846447f, 0.01894987f, -0.03586491f, 
    0.00873107f, -0.02951520f, 0.14645375f, 0.10969002f, 0.12517631f, 0.08805276f, 0.07541170f, 0.18449907f, 
    0.09250447f, 0.00704029f, -0.06389909f, 0.09675735f, -0.21336845f, -0.00125816f, 0.07626225f, -0.05677767f, 
    0.16660501f, -0.03708915f, -0.14833651f, 0.17091689f, 0.14909643f, 0.05983924f, 0.06805493f, 0.19665842f, 
    0.23110628f, -0.01149947f, 0.06557571f, 0.03929417f, 0.01792266f, -0.06414280f, 0.02960547f, 0.00831099f, 
    0.04270696f, -0.06575660f, 0.03884931f, 0.04084526f, 0.01876271f, -0.13336988f, 0.19818231f, -0.20400415f, 
    0.01308105f, 0.07449207f, -0.00977906f, 0.03209949f, 0.04558354f, 0.08581561f, 0.02872923f, -0.06207678f, 
    -0.25723809f, 0.30351946f, -0.01596650f, 0.03354444f, 0.00314576f, 0.04364838f, -0.06504831f, 0.14822353f, 
    -0.05367103f, -0.00061369f, -0.10383771f, 0.00473749f, -0.03329442f, -0.07129913f, 0.15982060f, 0.30606574f, 
    -0.05056569f, -0.00393839f, 0.06405325f, 0.13343167f, -0.06027911f, -0.03563548f, 0.05732271f, 0.01600899f, 
    -0.16620417f, -0.10817112f, 0.12015303f, -0.02352675f, -0.11446664f, -0.02806474f, -0.07516094f, 0.04296419f, 
    -0.11683021f, 0.05598467f, -0.01113527f, 0.09831352f, 0.02089410f, 0.14362584f, 0.17098752f, -0.21214321f, 
    -0.04051397f, -0.07086977f, -0.10890090f, -0.13279265f, 0.10209204f, -0.00662958f, 0.13739920f, -0.12222713f, 
    -0.16255140f, -0.26954618f, 0.20942004f, -0.00763402f, 0.19011931f, -0.12212420f, 0.13339145f, 0.19413327f, 
    -0.10303187f, 0.08413881f, 0.01444972f, 0.11581739f, -0.04214207f, -0.01968916f, 0.05776969f, 0.15095051f, 
    -0.06958906f, -0.12655303f, -0.11495387f, 0.16092081f, -0.04085062f, -0.07453310f, 0.06919763f, -0.09283701f, 
    0.12300429f, -0.07106310f, -0.15542185f, 0.03184976f, -0.11695287f, -0.07433693f, 0.00636922f, -0.03338156f, 
    -0.05628578f, -0.01517724f, 0.03061409f, -0.11853564f, -0.19317554f, -0.41104242f, 0.18103871f, 0.16142721f, 
    0.05144826f, 0.25269225f, 0.08771564f, 0.05368951f, -0.01536686f, 0.03603694f, -0.04732975f, -0.06785968f, 
    -0.03726886f, 0.17046836f, 0.09082966f, 0.03488015f, -0.04713484f, -0.07718354f, 0.07659003f, 0.07018787f, 
    -0.02754886f, 0.18905242f, 0.03183412f, -0.04682888f, -0.16409339f, 0.20093393f, 0.34844628f, -0.00955987f, 
    -0.00194788f, -0.04247803f, -0.07368079f, 0.02167937f, -0.09842712f, -0.06311533f, -0.02442286f, 0.04350838f, 
    -0.07303181f, 0.21638265f, -0.01626423f, 0.07703774f, 0.14136733f, 0.18954168f, 0.03568254f, 0.06339838f, 
    -0.12614541f, 0.14352989f, -0.00863568f, 0.01589389f, -0.13952443f, -0.01040721f, 0.02775721f, 0.10891346f, 
    0.01499901f, 0.07575506f, 0.13937029f, -0.01916188f, -0.08703917f, 0.08082799f, 0.05523771f, -0.05518926f, 
    -0.03839322f, 0.04517535f, -0.03449024f, 0.00901324f, -0.06125339f, 0.20369628f, 0.10988922f, -0.05243219f, 
    0.06507394f, -0.06876433f, 0.11770073f, 0.11150359f, -0.14216006f, 0.16094737f, -0.31149429f, 0.00834426f, 
    -0.03209617f, 0.03628664f, -0.10829815f, -0.02811597f, 0.11049563f, 0.05976137f, -0.15040548f, 0.03566171f, 
    0.10069709f, -0.09692427f, -0.29161656f, 0.03489901f, -0.04194064f, -0.12486156f, -0.07221583f, -0.07715886f, 
    0.09788153f, 0.07777461f, -0.12027238f, 0.03208197f, -0.05287562f, 0.15416697f, 0.14100550f, 0.10162852f, 
    -0.00266124f, -0.01134589f, 0.02436047f, 0.09087946f, 0.05603179f, -0.01339535f, 0.04499895f, 0.08911146f, 
    -0.17968696f, -0.23798732f, -0.26340315f, -0.34783506f, 0.04411210f, -0.16475077f, -0.11456808f, 0.03867891f, 
    0.04205614f, 0.08442286f, -0.01234150f, 0.13502078f, -0.17099655f, -0.22551708f, 0.13913961f, 0.05599056f, 
    -0.15000471f, -0.08824690f, -0.03123126f, 0.10779625f, -0.10539748f, 0.01766776f, 0.12498793f, -0.05348916f, 
    0.05951607f, 0.10742518f, 0.10817400f, 0.13235168f, -0.08025647f, -0.08337320f, -0.03804962f, -0.02119134f, 
    -0.15220426f, -0.04485298f, -0.09431405f, -0.05526390f, 0.15745468f, 0.18452027f, 0.10508195f, 0.06816216f, 
    0.07870831f, -0.11777180f, -0.00538737f, 0.00972002f, -0.00493364f, -0.05417331f, -0.02075312f, 0.04967656f, 
    -0.16199860f, -0.01411010f, -0.03847133f, -0.04064980f, 0.10042774f, 0.10850254f, 0.12329847f, 0.07631525f, 
    -0.04773309f, 0.08494160f, 0.01025136f, 0.09609859f, -0.27570680f, -0.11921109f, -0.07429586f, -0.22303519f, 
    -0.05717785f, 0.07554338f, 0.00438646f, -0.08908478f, 0.17816313f, 0.12688185f, -0.06756623f, 0.02641122f, 
    0.15358691f, 0.01172807f, 0.20987736f, 0.05557157f, -0.01368638f, 0.10952427f, -0.02184049f, 0.06124656f, 
    0.02900388f, 0.06967665f, -0.13337836f, -0.00209664f, 0.47925279f, -0.17727993f, 0.06275370f, -0.02936715f, 
    0.08244999f, 0.06270389f, 0.06484445f, 0.01594870f, 0.03890301f, 0.06058923f, 0.03833196f, 0.04773058f, 
    0.19775082f, 0.02577636f, 0.14776856f, 0.29523775f, 0.04740716f, -0.01789856f, 0.02961426f, -0.00265511f, 
    0.13984223f, 0.02136824f, 0.08794907f, -0.03593205f, 0.04158551f, 0.08112755f, 0.17819829f, 0.01715120f, 
    0.07945284f, -0.06790993f, -0.08788858f, -0.04299800f, -0.13770045f, -0.06832266f, -0.06684904f, -0.09286387f, 
    -0.25841859f, 0.17083052f, 0.05570209f, -0.00699328f, 0.17355147f, -0.05345260f, -0.08866547f, -0.01586753f, 
    0.12694852f, 0.01732931f, 0.04600786f, 0.01074197f, -0.31293052f, -0.24501455f, -0.08088174f, -0.31813058f, 
    -0.17263505f, 0.18487431f, 0.05723915f, 0.19494599f, 0.01069546f, -0.03634341f, 0.15694243f, 0.11542228f, 
    0.03362177f, 0.06762578f, 0.04505672f, -0.04312987f, 0.03116773f, 0.00976105f, -0.06392361f, -0.07395829f, 
    -0.07783815f, -0.03633693f, -0.07768292f, -0.08334067f, -0.05054403f, -0.04070027f, -0.21452960f, 0.02524018f, 
    0.07263365f, 0.15486753f, -0.00155302f, 0.08804827f, 0.08151977f, 0.02306300f, -0.00915524f, 0.01779252f, 
    0.48811328f, -0.05884740f, 0.20367624f, 0.05887699f, 0.12250444f, -0.01471183f, 0.04578567f, -0.14833167f, 
    -0.03376440f, 0.01985642f, 0.09861445f, 0.05693101f, -0.21691592f, -0.02741678f, -0.30130422f, -0.16833225f, 
    -0.13834156f, -0.11122891f, 0.05240757f, -0.08435237f, 0.15924554f, 0.04271901f, 0.01732627f, -0.08674065f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00482672f, 0.16582111f, 0.15606514f, 0.04348290f, 0.02662690f, 0.00513377f, 0.20287141f, -0.00051916f, 
    -0.06599356f, 0.03658910f, -0.04245613f, 0.08333514f, -0.06877873f, 0.03316236f, 0.13705236f, -0.00493086f, 
    0.06817495f, -0.07494335f, 0.08500544f, 0.05358318f, 0.06001006f, -0.08020800f, -0.04794076f, -0.13232438f, 
    -0.06121490f, 0.04118494f, -0.07926686f, -0.03660009f, 0.02700583f, 0.05066525f, -0.06008889f, 0.21838504f, 
    -0.05706913f, -0.08245103f, -0.02982557f, -0.03813771f, 0.09762105f, 0.00312207f, -0.00010008f, -0.05403723f, 
    -0.05077444f, 0.03108861f, 0.06765191f, -0.03755698f, 0.05055182f, 0.01671484f, -0.00950240f, -0.07428233f, 
    0.22200459f, 0.12581348f, 0.09520761f, -0.06965011f, 0.11245818f, 0.14281192f, 0.01507850f, -0.09375091f, 
    0.10454813f, 0.18578349f, 0.12652332f, 0.12503645f, -0.01256752f, -0.03908458f, -0.08994285f, 0.05984940f, 
    -0.05564990f, 0.06902406f, 0.03580558f, 0.13085206f, 0.15206064f, 0.06125610f, 0.10179194f, 0.07935067f, 
    -0.05573477f, 0.13479599f, 0.14046301f, 0.08539922f, 0.10190822f, 0.02369026f, 0.09458242f, 0.08020695f, 
    0.02889138f, -0.05965792f, 0.01910093f, 0.07161742f, -0.06449637f, -0.02439420f, 0.02666822f, 0.02455292f, 
    0.03785600f, -0.15488285f, -0.01147449f, 0.02293440f, 0.03021787f, 0.20101169f, -0.04812414f, 0.03929506f, 
    0.13148227f, 0.02321796f, 0.17769116f, 0.00114759f, -0.06007973f, 0.04210509f, -0.08589516f, 0.06899432f, 
    0.18923517f, 0.09183570f, 0.06930022f, 0.10944784f, -0.11072958f, 0.07557013f, 0.01041974f, 0.21652792f, 
    -0.04396710f, 0.04366748f, 0.00600185f, -0.09375953f, 0.01714634f, 0.17014942f, -0.00017230f, -0.01422312f, 
    -0.05729694f, 0.04937664f, 0.02775850f, 0.05792413f, 0.05712961f, 0.19737250f, 0.08560225f, -0.07906511f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.06947853f, 0.21326655f, -0.26534471f, 0.18600734f, -0.15485521f, -0.02397294f, -0.21625733f, -0.02608008f, 
    0.01110660f, 0.13466056f, -0.14139932f, -0.31489784f, 0.24185468f, 0.18516476f, -0.05915041f, 0.04761484f, 
    0.02237588f, -0.06735601f, 0.03246345f, 0.14712502f, -0.12725979f, 0.06476811f, 0.03607290f, 0.00773702f, 
    0.11151780f, -0.14827403f, -0.06407980f, -0.15632114f, -0.00577494f, -0.37903047f, 0.04214508f, -0.45358458f, 
    -0.17220730f, 0.20416239f, 0.13720948f, 0.01173690f, -0.44899940f, -0.01142196f, 0.02318919f, 0.05332010f, 
    0.04593701f, 0.06840928f, -0.03982998f, 0.22967963f, -0.61143100f, 0.15724999f, 0.17697003f, 0.17669000f, 
    0.06045872f, -0.29915252f, -0.41197950f, -0.06275339f, -0.19188125f, -0.07921451f, -0.06216474f, 0.18841887f, 
    -0.20791586f, -0.22599992f, -0.29506543f, -0.24901757f, -0.09558640f, 0.07897135f, 0.05502386f, -0.08467437f, 
    -0.06040023f, 0.16199730f, -0.21181783f, 0.11068443f, -0.23588106f, -0.21171081f, -0.40499154f, 0.05120597f, 
    0.12590340f, -0.07487401f, -0.00460909f, 0.02215239f, -0.27153161f, -0.29320747f, -0.05892975f, 0.04350110f, 
    -0.22195393f, -0.07204900f, -0.04152146f, -0.31243116f, -0.09003158f, 0.03977036f, 0.03002859f, 0.07754076f, 
    -0.01228455f, 0.09812073f, -0.41793826f, 0.11178847f, 0.15164769f, 0.03954280f, 0.00119075f, -0.28251454f, 
    0.12300883f, -0.43520084f, -0.40978718f, 0.16198915f, -0.02742301f, 0.04829592f, 0.09332587f, -0.12843357f, 
    -0.20846546f, 0.07103154f, 0.08605316f, -0.26588663f, 0.27017671f, -0.27049038f, -0.14322853f, -0.44416425f, 
    -0.03660126f, 0.07769140f, 0.16584660f, 0.15942071f, -0.07954295f, 0.10506605f, 0.15461123f, 0.12664250f, 
    0.32706216f, -0.02533608f, -0.02889440f, -0.89143801f, -0.03626265f, -0.17637627f, -0.09017859f, -0.00861298f, 
    -0.05791000f, 0.25123149f, 0.05091622f, 0.07142621f, -0.05459246f, -0.01733771f, -0.07536346f, -0.01080058f, 
    0.02237666f, 0.11493518f, -0.50437343f, 0.17621467f, -0.16585270f, -0.50753576f, 0.02627006f, -0.00570317f, 
    -0.04609502f, -0.07775795f, 0.25832960f, 0.07410706f, 0.14160115f, 0.04921670f, 0.12352426f, -0.25145179f, 
    -0.63207990f, -0.21894996f, -0.09446417f, -0.08446185f, -0.04462637f, -0.13166361f, 0.01719430f, -0.09066567f, 
    -0.14030999f, 0.40263644f, -0.04853390f, 0.01009162f, 0.06019184f, -0.02100099f, -0.03268208f, 0.13293891f, 
    -0.04830894f, 0.03843801f, -0.24354085f, -0.17280985f, -0.03616374f, 0.13633628f, 0.02071163f, -0.34615463f, 
    -0.07209491f, 0.20842358f, -0.09723484f, -0.03279694f, 0.28187725f, -0.00760677f, -0.07219332f, -0.23094296f, 
    -0.66164106f, -0.01357074f, -0.01905768f, 0.23483752f, 0.20519327f, -0.12599421f, 0.07424948f, 0.11185286f, 
    -0.05865927f, -0.00489271f, -0.01022383f, 0.03700433f, -0.05815918f, -0.12419277f, -0.22216365f, -0.05265971f, 
    -0.08517544f, 0.15075777f, 0.25012761f, 0.05511237f, 0.12826490f, 0.04313686f, -0.07206687f, 0.43854582f, 
    -0.15726779f, -0.02275112f, -0.01324028f, 0.07792542f, 0.04662487f, 0.03920699f, 0.05836137f, -0.04030880f, 
    0.05589141f, 0.28660181f, 0.22678928f, -0.08213085f, 0.20354646f, 0.10301591f, 0.05297910f, 0.21715242f, 
    0.05942493f, 0.00701464f, -0.11250483f, 0.10506164f, -0.04092110f, -0.00392084f, -0.54847723f, 0.04510556f, 
    0.04207767f, -0.19857380f, 0.11522906f, 0.02660139f, -0.10991149f, -0.13810460f, 0.02627118f, 0.19741459f, 
    -0.20925161f, -0.01889577f, 0.14570361f, 0.07049374f, 0.07378899f, 0.28327480f, 0.18660174f, -0.01223103f, 
    -0.38092077f, 0.10878664f, 0.03865489f, 0.32023638f, 0.05912574f, 0.10568347f, -0.17129654f, 0.09563087f, 
    0.04803826f, -0.06550146f, -0.05186658f, 0.00955253f, 0.15253140f, -0.12993625f, 0.18009105f, -0.05970476f, 
    0.06752182f, 0.05396086f, 0.11698495f, -0.19308341f, -0.14947174f, 0.35062397f, 0.03239847f, 0.20499808f, 
    0.11367902f, 0.03141864f, -0.07765896f, 0.10192550f, 0.16010973f, -0.01211750f, -0.62924349f, -0.12291087f, 
    0.17673174f, -0.07501547f, -0.03122720f, -0.00291496f, -0.05177842f, 0.00394695f, 0.05364675f, 0.11776553f, 
    -0.52079904f, 0.20434429f, -0.66364497f, 0.06831221f, 0.14522748f, -0.00821588f, 0.00340011f, -0.10647292f, 
    0.07167248f, -0.03662369f, 0.04630599f, 0.22103222f, -0.06783567f, 0.02021562f, 0.07510498f, -0.04708251f, 
    -0.07097572f, -0.19831260f, 0.05887475f, 0.00957846f, 0.29302689f, -0.01249696f, -0.03545457f, -0.28527153f, 
    -0.41035733f, -0.01065670f, 0.03748136f, -0.02748290f, -0.41143370f, -0.10471442f, -0.01745288f, 0.05564312f, 
    0.06201494f, -0.21605292f, 0.06927629f, 0.09222575f, 0.14942481f, -0.18379579f, 0.10731859f, 0.17457156f, 
    -0.10282078f, -0.31997550f, -0.11308048f, -0.30956453f, 0.11810892f, -0.08098904f, 0.04597667f, -0.67279172f, 
    0.04706584f, -0.02729719f, 0.06296594f, 0.13686614f, 0.05468118f, -0.07061121f, 0.06157360f, -0.00731739f, 
    0.18386927f, -0.54007548f, 0.21243577f, -0.20825650f, 0.07779998f, 0.10769624f, 0.06050659f, 0.14095280f, 
    0.07133640f, 0.13762577f, 0.04488505f, 0.00786044f, 0.00574475f, -0.03741933f, -0.42249915f, -0.15987241f, 
    0.22204414f, 0.10770215f, 0.12794083f, 0.10371850f, -0.25814262f, -0.04197688f, -0.00594378f, 0.13836052f, 
    -0.15355390f, 0.08028656f, -0.15070751f, -0.11784475f, 0.04410204f, -0.17324264f, 0.11786000f, -0.09923515f, 
    -0.14711425f, 0.12240700f, 0.06969152f, -0.52980876f, -0.08310774f, 0.08110981f, 0.11909909f, -0.10224826f, 
    -0.06495792f, -0.00751188f, -0.11784543f, 0.16070184f, -0.56697452f, 0.20924991f, 0.02176739f, -0.05959943f, 
    0.01337953f, -0.10562475f, 0.21260436f, 0.30486241f, -0.25465190f, -0.05888282f, -0.15517534f, 0.09725569f, 
    0.03850039f, 0.04616638f, -0.16878909f, -0.07997149f, 0.10891394f, 0.06492904f, 0.17047465f, 0.07477177f, 
    0.17398833f, -0.16792382f, 0.05501190f, 0.11999177f, -0.06254040f, 0.21754910f, -0.04270310f, 0.11054238f, 
    0.10540375f, 0.05279420f, -0.00912491f, 0.07202521f, 0.13474011f, -0.07887314f, 0.05724138f, 0.12493864f, 
    0.01278939f, 0.00108123f, 0.07521568f, -0.15147513f, -0.18799493f, -0.19163375f, 0.04296322f, 0.08455294f, 
    -0.37601471f, -0.23134461f, 0.14172046f, 0.06929328f, -0.22644176f, 0.25289416f, 0.01000906f, 0.22979923f, 
    0.07186040f, -0.01803653f, -0.01574297f, -0.28147134f, -0.23779805f, 0.00985513f, -0.09070142f, -0.28318545f, 
    -0.07022300f, 0.04378033f, -0.09556263f, -0.17175224f, 0.12864438f, 0.15851457f, -0.18141071f, 0.15739425f, 
    -0.33770716f, -0.33569092f, 0.06462843f, 0.03958053f, 0.08577045f, -0.13686521f, -0.15508777f, -0.22536984f, 
    0.05089991f, -0.02589388f, -0.04426800f, -0.01583721f, 0.07995305f, -0.09691735f, 0.08887104f, -0.09169482f, 
    -0.24569659f, -0.08479690f, 0.47368920f, -0.51639503f, 0.08867262f, -0.17706206f, -0.05920973f, -0.13283312f, 
    -0.19916242f, -0.35984263f, -0.19873071f, 0.11377028f, -0.01708916f, 0.14623828f, 0.10358272f, -0.16931133f, 
    -0.33570880f, 0.00850955f, -0.22656561f, 0.18815823f, 0.14952268f, -0.28847325f, 0.02715416f, -0.40075886f, 
    0.30941439f, 0.23187138f, -0.35223696f, -0.33249336f, -0.05185515f, -0.08820903f, 0.03138674f, -0.09073327f, 
    -0.05170762f, 0.24623574f, 0.06366042f, -0.07460893f, -0.09337717f, -0.47571170f, 0.10350810f, -0.36342666f, 
    -0.02783307f, -0.41892976f, -0.10638501f, -0.20077182f, 0.08377690f, -0.22943671f, -0.55916035f, 0.07578796f, 
    -0.05987571f, 0.08607209f, 0.18845566f, 0.04747171f, 0.26936689f, 0.15101422f, -0.28793851f, 0.09264752f, 
    0.19130312f, -0.07972649f, 0.01992102f, 0.10588370f, 0.15708059f, 0.05652444f, -0.03614365f, 0.15826756f, 
    0.08458733f, -0.03449489f, 0.16811730f, -0.08843572f, 0.02752348f, -0.27624229f, -0.03279970f, 0.00182908f, 
    0.04741261f, -0.15355574f, 0.00351406f, 0.06156214f, -0.06002117f, -0.08272196f, -0.02178863f, 0.05553311f, 
    0.01085846f, 0.13004075f, -0.12609453f, 0.12609512f, 0.35733473f, 0.05644717f, 0.10561895f, 0.09265033f, 
    -0.29451585f, 0.16706418f, -0.02830996f, -0.03415421f, -0.07598303f, -0.06369582f, -0.04893997f, 0.03390555f, 
    0.17995183f, -0.31288013f, 0.09903934f, -0.14415957f, -0.08623876f, 0.11530067f, 0.03508420f, -0.04764557f, 
    -0.06693219f, -0.17882878f, 0.17785126f, -0.05911255f, -0.31241935f, -0.24949211f, 0.25186872f, 0.05416161f, 
    0.04881448f, -0.07486468f, -0.24534100f, 0.09776206f, -0.27555421f, 0.00765998f, 0.10408725f, 0.12215735f, 
    -0.02270959f, 0.00700525f, 0.05467247f, -0.00851296f, -0.01391123f, 0.07123077f, 0.00527919f, -0.01614027f, 
    0.00376193f, 0.06428549f, 0.03391781f, 0.06978714f, -0.14604679f, -0.23412757f, 0.03140381f, -0.37732592f, 
    -0.16448894f, 0.01834178f, -0.03879797f, 0.03796357f, -0.04980008f, -0.16794387f, 0.21177198f, 0.06267078f, 
    0.13548861f, 0.11705682f, -0.17714900f, -0.21966554f, -0.12412512f, 0.18847203f, -0.05904222f, -0.06719631f, 
    0.04295726f, -0.32266721f, 0.26618356f, -0.00395921f, 0.07717449f, -0.26420557f, 0.14571631f, -0.00674760f, 
    -0.09743699f, 0.10225530f, 0.00369673f, -0.24542533f, 0.00717721f, 0.01344605f, -0.01904625f, 0.11112894f, 
    -0.01442243f, 0.03336444f, -0.00109570f, -0.15641148f, -0.07734873f, 0.02070217f, -0.09578736f, 0.05233804f, 
    -0.01898308f, -0.01321605f, -0.40457460f, -0.02443905f, -0.22302340f, -0.31785220f, 0.17809595f, -0.37696630f, 
    0.16221054f, -0.05171061f, 0.16057113f, 0.08279395f, 0.08467091f, 0.01694433f, 0.08089827f, 0.12662123f, 
    -0.11825147f, 0.04272096f, 0.01110267f, -0.30555376f, -0.04647980f, 0.08281898f, -0.01775270f, -0.00229935f, 
    -0.00593367f, -0.27797130f, 0.27509084f, -0.23748888f, -0.16347173f, 0.05544116f, 0.01578546f, -0.07901238f, 
    0.05436141f, -0.11874834f, 0.20432508f, -0.01139366f, 0.07248665f, 0.10722618f, -0.07819761f, -0.06553289f, 
    0.23516296f, -0.09032816f, 0.12101579f, 0.02054045f, -0.20997570f, 0.07320760f, 0.01795486f, -0.71288812f, 
    0.38466552f, 0.11985100f, 0.08979339f, -0.12152532f, 0.08897685f, 0.12658711f, 0.06163681f, -0.05791169f, 
    0.05252924f, 0.01378787f, -0.07031230f, 0.14332063f, 0.03028787f, -0.06897110f, -0.01336825f, -0.13891067f, 
    0.03964167f, -0.25947562f, 0.03693639f, 0.13225438f, -0.30428123f, -0.03617543f, 0.06854981f, -0.44927272f, 
    -0.02029591f, 0.02693354f, 0.05068224f, 0.09332371f, 0.04863060f, -0.07463638f, 0.04536449f, 0.04289508f, 
    -0.07083023f, -0.16014372f, -0.69160753f, 0.28847528f, 0.22042632f, 0.21319374f, 0.06118634f, -0.14216261f, 
    0.08452301f, -0.11286324f, 0.10918894f, 0.09170076f, 0.02653060f, -0.03324999f, 0.00057861f, 0.23786309f, 
    0.12073221f, 0.19104953f, 0.04594662f, -0.31364548f, 0.04762329f, 0.05971974f, 0.00881273f, 0.12539390f, 
    0.10117334f, 0.05475936f, 0.12510484f, -0.00229362f, 0.04146053f, -0.37510970f, -0.27105290f, -0.28174958f, 
    0.32329649f, -0.09583686f, 0.07539153f, 0.33576041f, 0.00665715f, 0.16121991f, 0.15004268f, 0.12239785f, 
    -0.00838124f, 0.04308990f, 0.15686488f, -0.00234483f, 0.20230453f, -0.09419125f, 0.20998852f, 0.05247387f, 
    -0.01421120f, -0.25447229f, 0.24518149f, -0.07271837f, -0.30623189f, 0.08029625f, -0.04365192f, 0.01822626f, 
    0.02229102f, 0.01515595f, -0.57026559f, -0.08686125f, -0.37203825f, 0.07277326f, -0.47354597f, -0.28417200f, 
    -0.19112660f, 0.12901247f, -0.28449258f, -0.16339800f, -0.01828181f, 0.07416941f, 0.03843015f, 0.22806641f, 
    -0.10749419f, -0.43781525f, -0.53931439f, 0.11869818f, 0.15735625f, 0.07817143f, 0.07618517f, -0.38123694f, 
    -0.07792032f, -0.24221884f, 0.20292568f, -0.04364179f, 0.04451972f, 0.14445931f, 0.04382798f, -0.46057734f, 
    0.09029282f, -0.32439825f, -0.07394181f, 0.03651693f, -0.21209699f, -0.13386863f, -0.07142347f, 0.19550164f, 
    0.07216132f, 0.20062353f, -0.24669613f, -0.06859524f, 0.08228222f, -0.10801324f, 0.00385563f, -0.11910424f, 
    0.02158819f, -0.40993154f, 0.23221742f, 0.02112314f, -0.03683629f, 0.03500386f, 0.23021518f, 0.03933463f, 
    0.07616103f, 0.27034944f, -0.05347254f, -0.57898808f, 0.14631686f, 0.15445332f, 0.05514836f, 0.04704579f, 
    0.07540207f, 0.03659739f, 0.02816829f, -0.27531210f, -0.05993912f, 0.05437654f, -0.09694245f, -0.09246921f, 
    0.16368419f, -0.39368784f, 0.14499001f, 0.12388901f, -0.73613948f, -0.32706118f, 0.03053355f, -0.12655652f, 
    0.28930220f, 0.28367200f, 0.07600836f, -0.35573053f, 0.07089633f, -0.17152612f, 0.04969925f, 0.05814575f, 
    -0.33150142f, -0.61356086f, -0.04735472f, 0.29119378f, -0.10069464f, -0.20129827f, -0.07008262f, 0.32509398f, 
    -0.12296386f, -0.16366160f, -0.12333313f, -0.21130712f, 0.02766670f, -0.09521279f, -0.28033715f, 0.09230170f, 
    0.01323949f, 0.18019043f, 0.01667529f, -0.44731075f, 0.01565264f, 0.07371530f, 0.01752027f, 0.10191445f, 
    0.04723263f, -0.22771412f, 0.01303588f, 0.12011625f, 0.01439415f, 0.15751261f, -0.18208034f, 0.05571879f, 
    0.03360560f, -0.06350052f, -0.21166767f, 0.18856604f, -0.21785797f, 0.15960285f, -0.09539465f, -0.03892595f, 
    0.47156250f, -0.06891383f, -0.45353532f, 0.00057212f, -0.48453450f, -0.07793961f, -0.27604303f, 0.13280818f, 
    0.20039602f, 0.08349536f, 0.33820304f, 0.03208726f, 0.02065029f, 0.16440023f, 0.02368795f, 0.00331094f, 
    0.21863271f, -0.18257165f, -0.17483079f, -0.23697555f, 0.09302413f, 0.06603862f, 0.05592142f, -0.28603196f, 
    0.01848027f, -0.02732964f, -0.17374328f, 0.33266947f, -0.10552568f, -0.05998721f, -0.21755454f, -0.04851146f, 
    -0.23411153f, 0.25377452f, -0.10046079f, -0.08452722f, 0.16415118f, 0.14899929f, 0.03533548f, 0.24644800f, 
    0.10927974f, -0.01254418f, -0.17533438f, 0.12144434f, 0.18571344f, -0.35307106f, 0.04017118f, -0.22257525f, 
    0.06993555f, -0.00331809f, -0.18966594f, 0.12527369f, 0.07111854f, 0.17086346f, -0.29379734f, -0.29919994f, 
    0.18873021f, 0.07721833f, -0.48677710f, -0.10637507f, 0.06848671f, -0.10336902f, -0.24881370f, -0.05385070f, 
    0.14077899f, 0.05747891f, -0.02110488f, 0.02110173f, 0.01603073f, -0.07714274f, 0.00402295f, 0.08910960f, 
    -0.25830340f, -0.03662296f, 0.17649178f, 0.04190495f, -0.23939908f, -0.07903793f, 0.04513632f, 0.16921873f, 
    -0.21383579f, 0.11590180f, 0.07631078f, -0.21985395f, -0.08178728f, -0.11165482f, -0.08605769f, -0.32123762f, 
    -0.02670110f, -0.05432561f, -0.17490326f, -0.39198634f, 0.16201960f, 0.11591683f, -0.06768742f, -0.07931953f, 
    0.06843749f, 0.05745091f, -0.21117797f, 0.20281012f, -0.01873875f, -0.09183433f, -0.20971464f, -0.16360039f, 
    0.25049943f, -0.02833719f, -0.05447635f, -0.25113872f, 0.07505824f, -0.24556057f, -0.06207263f, 0.09714152f, 
    0.00137132f, 0.15617803f, -0.05643260f, 0.24180016f, -0.13338234f, 0.05325918f, 0.07255282f, 0.03655107f, 
    -0.04259888f, -0.27756500f, 0.21771449f, 0.02006536f, -0.07548752f, -0.15270022f, 0.11563858f, -0.36564237f, 
    -0.20197903f, -0.08048464f, 0.10773914f, 0.05528262f, -0.44214606f, -0.08344681f, -0.42158407f, 0.01393292f, 
    -0.13954125f, 0.06446420f, 0.03026000f, 0.25739777f, -0.03426934f, 0.15211298f, -0.01086625f, -0.19063672f, 
    0.22461252f, -0.31079710f, -0.12974311f, -0.34443396f, -0.03438541f, -0.06026415f, -0.00099548f, 0.08816212f, 
    -0.07268565f, -0.19816358f, -0.17667829f, -0.45390469f, 0.06028416f, -0.24360050f, -0.32692024f, -0.46184489f, 
    0.11841554f, -0.03779984f, 0.17751825f, -0.01970167f, -0.31498066f, 0.20500383f, -0.01579287f, -0.17077997f, 
    -0.19043298f, 0.08150528f, -0.34233233f, 0.12662892f, -0.37088460f, -0.40036580f, -0.00713204f, 0.10096037f, 
    -0.01126213f, 0.27626809f, -0.24297503f, 0.07920249f, 0.19677480f, 0.01662675f, 0.10173686f, -0.05957394f, 
    -0.18937522f, 0.22682913f, 0.01618774f, 0.04209842f, 0.10601067f, -0.29942328f, 0.20288329f, -0.17418037f, 
    0.06525128f, -0.06875532f, -0.01460820f, 0.22017407f, -0.00517971f, -0.05413117f, -0.04799167f, -0.02079963f, 
    -0.24150546f, -0.50110924f, -0.17653199f, 0.14780505f, -0.33760920f, 0.23414646f, -0.07490555f, -0.02136761f, 
    0.18803495f, -0.19403969f, -0.05410803f, 0.01309914f, 0.01413426f, 0.08489334f, -0.30152988f, -0.28989226f, 
    0.17251107f, -0.33611691f, 0.03876542f, -0.08926085f, 0.13348347f, 0.14104585f, -0.03921282f, -0.31284940f, 
    0.24591656f, 0.31929168f, -0.09703591f, 0.00770273f, -0.03107098f, 0.18312727f, -0.46117428f, -0.11653401f, 
    -0.27778551f, -0.25648525f, 0.02224338f, 0.00292260f, -0.07415409f, -0.05894133f, -0.22325224f, -0.35680547f, 
    0.07294648f, 0.19479749f, -0.23146015f, -0.39113206f, 0.30027246f, -0.06449996f, 0.17340706f, 0.08591198f, 
    0.07056766f, -0.04983277f, 0.22151999f, 0.16021341f, 0.36377719f, 0.17364405f, -0.02836571f, 0.06711469f, 
    -0.18318303f, -0.01752730f, -0.18837996f, -0.39796847f, 0.13834715f, 0.02324222f, 0.16747275f, 0.09992813f, 
    -0.17502165f, -0.18491831f, 0.19609264f, 0.02952369f, -0.07899129f, -0.18530385f, -0.05733783f, 0.06825619f, 
    0.09852845f, -0.40743956f, 0.16569349f, 0.00228761f, 0.06111608f, -0.01928150f, 0.03512264f, 0.18125807f, 
    0.05958889f, 0.10495277f, -0.18959847f, -0.06714398f, 0.15993111f, 0.13752301f, -0.00703959f, 0.35362205f, 
    0.13374802f, -0.19096810f, -0.17975719f, 0.03934109f, 0.22181320f, -0.23799159f, 0.07107072f, 0.15778056f, 
    0.14705095f, 0.10887890f, 0.19950107f, 0.13364731f, 0.08112374f, 0.16721120f, 0.09548004f, 0.06689206f, 
    -0.05933587f, -0.57702088f, 0.07631930f, 0.14603299f, -0.24013248f, 0.09633157f, -0.07204945f, -0.17905879f, 
    0.06652707f, -0.31686696f, -0.28595316f, -0.28370950f, -0.25812915f, 0.29930738f, -0.28860989f, -0.24030025f, 
    -0.11701723f, 0.02315999f, -0.00142535f, -0.05777975f, -0.06625605f, 0.01380079f, 0.06985931f, -0.09357776f, 
    0.25127524f, 0.15440142f, -0.12489384f, -0.10218468f, 0.15830001f, 0.02249652f, -0.03338411f, 0.18177405f, 
    0.13645221f, 0.16376689f, 0.20228346f, -0.47163290f, -0.04656895f, -0.22557940f, 0.09617954f, -0.12138933f, 
    -0.31557223f, 0.36620566f, -0.08558827f, 0.01258943f, -0.39823246f, 0.25569010f, 0.05442058f, 0.02460167f, 
    -0.30616546f, 0.00592181f, -0.14244407f, -0.21250023f, -0.08418073f, 0.12731951f, -0.12759930f, -0.49098793f, 
    -0.30921438f, -0.16180161f, 0.07062529f, 0.20433828f, 0.04199504f, 0.10741935f, -0.02955962f, -0.15525997f, 
    0.05942914f, 0.26655650f, 0.19213535f, 0.13999444f, 0.20921679f, 0.39073354f, 0.00163018f, -0.03835730f, 
    0.07318894f, -0.30820209f, -0.20421511f, -0.23999658f, -0.18577598f, -0.54530901f, 0.01950269f, 0.09770238f, 
    -0.64185596f, -0.01815801f, -0.28010839f, 0.11381622f, 0.06984549f, -0.03856485f, -0.27933928f, 0.16018938f, 
    -0.44217888f, 0.03384230f, -0.65724593f, -0.17957628f, 0.02860219f, 0.07728750f, -0.07166401f, 0.21697697f, 
    0.04197435f, -0.25490928f, -0.01209062f, -0.18765406f, -0.11573043f, 0.06740853f, 0.00479936f, 0.02866822f, 
    0.03162772f, -0.27251786f, 0.07541593f, -0.40144849f, 0.03090718f, -0.53494710f, 0.05604504f, -0.41792262f, 
    0.26762217f, -0.37658033f, -0.02040638f, -0.06757594f, 0.29689053f, 0.28046834f, -0.01118661f, 0.02366716f, 
    -0.27240652f, -0.17133646f, 0.34100813f, -0.02493487f, -0.33754697f, 0.02482722f, -0.01755133f, 0.23824953f, 
    -0.01294951f, -0.07018735f, 0.21222255f, -0.32038656f, -0.05197673f, -0.10425857f, 0.10062779f, -0.12462348f, 
    -0.27982894f, -0.18129039f, 0.29468545f, 0.15690918f, 0.24173255f, 0.32847163f, 0.17517477f, -0.06507318f, 
    -0.13525102f, -0.08731315f, -0.03621519f, -0.17338882f, -0.05873363f, 0.07484879f, -0.06986506f, 0.07302760f, 
    -0.21156523f, 0.12940224f, -0.02128468f, -0.47866234f, -0.24083783f, -0.06829067f, -0.00335206f, 0.12354412f, 
    -0.51791900f, -0.35609385f, 0.08285510f, 0.07026525f, -0.05446836f, 0.29443988f, 0.15469113f, 0.11314941f, 
    0.11394751f, -0.51390362f, 0.18536296f, -0.10064716f, 0.01367514f, 0.14403823f, -0.09411789f, 0.24296920f, 
    -0.12013096f, -0.19617377f, -0.14915873f, -0.46879408f, -0.01742479f, -0.44165879f, -0.19431895f, 0.22432451f, 
    0.00598255f, -0.21203637f, 0.07716876f, -0.29980651f, -0.09829347f, -0.12357533f, 0.32662237f, 0.01945310f, 
    -0.00401219f, -0.45941868f, 0.09175626f, 0.10132922f, -0.24014257f, -0.30350053f, 0.07695314f, -0.07232346f, 
    -0.07157551f, 0.05192361f, -0.30061677f, -0.49832630f, 0.14531465f, -0.12763053f, -0.28876910f, 0.16069879f, 
    -0.27983761f, -0.05972515f, 0.39214027f, -0.14878510f, -0.33067295f, 0.04230854f, 0.08019361f, -0.14217354f, 
    0.26544386f, 0.18740299f, 0.32618874f, 0.27512512f, 0.06640013f, 0.04740246f, -0.06957530f, 0.02259246f, 
    -0.17066176f, -0.48544872f, -0.19919319f, 0.27296522f, 0.14005780f, 0.02602348f, -0.09141216f, -0.20461124f, 
    -0.07728723f, 0.02802058f, 0.12798923f, -0.37801969f, -0.13842361f, 0.04158113f, 0.09574460f, 0.02654657f, 
    -0.14098486f, -0.29879630f, 0.26009819f, -0.06602062f, -0.02561105f, -0.30241138f, -0.06674819f, 0.01400868f, 
    0.11956315f, -0.06880122f, 0.13723077f, -0.07380076f, 0.11636133f, 0.04908100f, -0.06047378f, 0.16064975f, 
    -0.01915155f, 0.12353432f, -0.18365678f, -0.07479867f, 0.16462427f, 0.07345725f, 0.14755809f, -0.19274677f, 
    0.04145178f, -0.05820641f, -0.57248712f, -0.38188028f, 0.05308867f, 0.00774753f, 0.13211732f, 0.25545004f, 
    0.17741399f, -0.01734543f, -0.08405533f, 0.17148580f, 0.00141637f, 0.06659953f, -0.07991219f, -0.05638264f, 
    -0.16450299f, -0.28187186f, -0.19841558f, -0.12340365f, -0.21371572f, -0.31893888f, 0.05554467f, -0.00332971f, 
    -0.09836703f, -0.18440856f, -0.02024275f, 0.08211098f, 0.05179871f, 0.14102034f, 0.02649271f, 0.21699776f, 
    0.00406949f, -0.17127186f, 0.16985650f, 0.01207756f, -0.41634265f, -0.32188350f, -0.04001679f, -0.21105544f, 
    -0.31626430f, -0.18827654f, -0.24874724f, -0.07547804f, 0.07041942f, 0.30222365f, -0.39134392f, 0.39053538f, 
    -0.29825160f, -0.10762378f, -0.08295079f, -0.04725480f, 0.06078444f, 0.19921187f, -0.22468328f, 0.01262514f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.07501553f, -0.05467651f, 0.05799219f, -0.09834954f, -0.03387630f, 0.08392546f, 0.08285596f, -0.14608307f, 
    0.12382711f, -0.00652052f, 0.00961336f, 0.04861427f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
