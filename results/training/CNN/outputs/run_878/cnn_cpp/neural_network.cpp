#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.12795718f, -0.66557336f, -0.14379981f, 0.35098895f, 0.30423194f, 0.61815816f, -0.24419723f, -0.33938500f, 
    -0.00810114f, -0.75501233f, -0.63515311f, -0.29066509f, 0.01430021f, -0.45493647f, 0.24123472f, -0.02927803f, 
    0.01298820f, 0.18823010f, -0.39803973f, 0.00819844f, -0.01650049f, 0.69599235f, 0.67236161f, 0.19310158f, 
    0.00199002f, 0.31879240f, -0.01487255f, 0.64645511f, -0.43452421f, 0.34838727f, 0.46793795f, 0.12584466f, 
    0.16695641f, -0.02549357f, -0.04076103f, -0.32532877f, 0.79002231f, 0.41846108f, 0.61312538f, -0.51492369f, 
    -0.03859048f, 0.01998909f, -0.14156803f, -0.05515839f, -0.09051152f, -0.69464815f, 0.56187713f, 0.06645091f, 
    0.09729743f, 0.01459122f, -0.28247342f, 0.17311254f, 0.18563133f, -0.44118482f, -0.12199253f, -0.32768735f, 
    -0.46521139f, -0.28310889f, 0.43919009f, 0.72225302f, 0.06145386f, -0.10470828f, 0.24056929f, -0.98273158f, 
    -0.21676999f, -0.21061723f, 0.07796235f, 0.62359828f, 0.42472312f, 0.03153627f, -0.32296792f, 0.09606795f, 
    -0.59741169f, -0.65811676f, -0.59218806f, -0.34308842f, -0.07093697f, -0.31277660f, 0.06328772f, -0.00637819f, 
    -0.21072507f, -0.56200039f, 0.16839267f, -0.22929902f, 0.66306370f, -0.42624852f, -0.17406286f, -0.11914170f, 
    -0.04501586f, 0.09509604f, 0.23881476f, 0.04362923f, 0.15118931f, -0.71035236f, -0.48709914f, -0.66084546f, 
    0.04519471f, -0.04200438f, 0.11405217f, -0.55381483f, 0.16501781f, 0.03766506f, -0.43680784f, -0.27335751f, 
    -0.61544514f, 0.20779930f, -0.17813843f, 0.26738060f, 0.51828998f, 0.34009674f, 0.56291068f, 0.07440614f, 
    -0.54635686f, -0.07870526f, 0.46104822f, 0.13240670f, 0.01637244f, 0.13447750f, 0.07017818f, -0.51453429f, 
    0.74094909f, 0.15638253f, -0.13615137f, -0.47225222f, -0.08971280f, -0.39634109f, -0.01253139f, 0.55175430f, 
    -0.14968286f, 0.49657488f, -0.38999310f, -0.57809985f, -0.23974156f, -0.09154997f, 0.00182045f, 0.45136264f, 
    0.47378334f, 0.49180752f, 0.20218740f, -0.52923024f, 0.37757912f, -0.12550841f, 0.38039783f, 0.12211335f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03280846f, 0.32743886f, 0.14682081f, -0.58828837f, 0.19385050f, -0.31937087f, -0.17541787f, 0.18584332f, 
    0.37215462f, -0.10648628f, -0.03488277f, -0.21370009f, 0.11046936f, -0.25411621f, 0.06843898f, 0.26538423f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.11801993f, -0.05528636f, -0.00734720f, 0.02542378f, -0.05466682f, -0.07696298f, 0.05392441f, -0.05645540f, 
    0.08632337f, 0.21880062f, -0.05777308f, 0.15590666f, -0.13855088f, -0.03625928f, -0.01457075f, -0.09311476f, 
    0.06690346f, -0.13860638f, 0.13368151f, 0.08296353f, 0.00478896f, -0.02004675f, 0.07818663f, -0.02282485f, 
    0.02483675f, 0.17032591f, 0.11385079f, 0.01188668f, 0.17896603f, 0.07177599f, 0.02704669f, 0.03340339f, 
    0.09350955f, -0.14276150f, -0.04218207f, -0.07673196f, -0.56167233f, 0.20697735f, 0.02504701f, 0.02040529f, 
    0.17538869f, -0.01787021f, 0.03551334f, -0.08655645f, -0.15317360f, 0.09043341f, -0.15632281f, -0.22392210f, 
    -0.07912125f, 0.05079041f, 0.04836270f, 0.05503072f, 0.09208405f, -0.08235183f, 0.08198956f, -0.10507673f, 
    -0.03586803f, -0.02475709f, -0.16799971f, -0.06279030f, 0.02780689f, -0.16184057f, 0.11115920f, 0.26454875f, 
    0.11004863f, -0.24322455f, -0.07924750f, 0.01983900f, 0.05258500f, 0.10336494f, 0.05402667f, -0.00748083f, 
    0.03779583f, -0.13440736f, 0.25867102f, 0.18168207f, 0.09522986f, 0.06046074f, -0.00285985f, 0.06775108f, 
    0.16033727f, 0.19541509f, -0.03898229f, -0.10552379f, -0.16691780f, -0.05077652f, 0.03243859f, 0.02647944f, 
    -0.10650536f, 0.05421910f, 0.14573409f, 0.14391790f, 0.22069809f, 0.07134918f, 0.05137149f, -0.18447907f, 
    -0.07977797f, 0.02784947f, 0.14674035f, 0.30488834f, 0.27056012f, -0.19384481f, 0.06266858f, -0.07325638f, 
    -0.11958807f, -0.12206947f, -0.00549068f, -0.02540552f, -0.39274499f, -0.10917401f, -0.07191262f, 0.03696309f, 
    0.05035928f, -0.08704872f, -0.04548800f, -0.05161901f, 0.02360613f, -0.10470080f, -0.17185374f, 0.29568833f, 
    0.17373745f, 0.07299566f, 0.11289919f, 0.00995668f, -0.11371893f, -0.02801287f, 0.16098256f, 0.00812225f, 
    -0.32020986f, -0.01203707f, 0.13630289f, 0.14511351f, -0.05738123f, 0.05483322f, -0.03711799f, -0.38360739f, 
    -0.22942601f, -0.12437870f, 0.09209079f, -0.00264664f, 0.07831202f, -0.09542756f, 0.22153524f, -0.03734266f, 
    0.21318567f, 0.02571263f, -0.38581553f, 0.19276829f, 0.25372803f, -0.14247206f, 0.13101889f, 0.18801847f, 
    0.06077168f, 0.14791881f, 0.24287169f, -0.19137090f, -0.01891400f, 0.05644312f, 0.10919090f, -0.06981744f, 
    0.19931503f, 0.13195822f, -0.24605486f, -0.03878074f, 0.15463607f, -0.04547023f, 0.00158673f, -0.04115432f, 
    0.04375253f, 0.07159288f, 0.00278063f, -0.30124906f, -0.30325931f, -0.12856810f, -0.01250582f, 0.04157272f, 
    -0.14583436f, 0.03798863f, 0.09083833f, -0.02438542f, -0.00653989f, -0.36660725f, 0.17095298f, 0.00122700f, 
    0.02691129f, 0.13544495f, 0.03580993f, -0.08395498f, 0.01196639f, 0.32453355f, 0.20392749f, 0.08424976f, 
    0.02553203f, -0.20231360f, -0.21971042f, -0.07169662f, -0.12985343f, 0.03344902f, 0.03089767f, 0.02701827f, 
    -0.21026783f, -0.01413455f, -0.19223079f, -0.11148777f, -0.03014816f, 0.07921016f, 0.00713850f, 0.05578547f, 
    0.28255841f, 0.12335257f, -0.05582905f, 0.04767506f, 0.00689917f, 0.04139375f, 0.07154485f, 0.03711830f, 
    -0.11893836f, 0.42505121f, -0.02500162f, -0.02808721f, 0.06343208f, -0.08658519f, 0.00446683f, 0.01282605f, 
    -0.03379731f, 0.09715578f, -0.04406284f, -0.05313520f, -0.17212293f, -0.04473303f, 0.14320196f, 0.07643835f, 
    -0.07900163f, 0.07867739f, 0.14991112f, -0.12660675f, -0.05657234f, -0.07042976f, -0.05848417f, -0.03668113f, 
    0.08868334f, -0.09355704f, 0.09391435f, -0.23470129f, -0.10650033f, 0.14443019f, 0.14853053f, -0.01297756f, 
    0.07266528f, -0.03039268f, -0.17248164f, -0.03862679f, 0.05869279f, -0.46747226f, 0.05182727f, 0.14900170f, 
    0.04898581f, 0.28206608f, -0.11020173f, 0.07279513f, 0.02088518f, 0.06845607f, -0.01684567f, -0.09693760f, 
    -0.14793077f, 0.05212334f, -0.15237875f, -0.17841214f, -0.07149176f, -0.01550062f, 0.20090875f, -0.25571641f, 
    -0.01283718f, 0.09064941f, -0.02544345f, -0.02138938f, -0.04054727f, 0.06672809f, 0.06341355f, -0.17356253f, 
    -0.36271068f, -0.01674005f, 0.13959660f, -0.06296653f, -0.07698668f, 0.16592681f, -0.09879626f, 0.10947112f, 
    0.03370105f, 0.14685336f, -0.09336879f, 0.10278497f, 0.12494411f, -0.11624093f, 0.04861511f, -0.00050453f, 
    0.01269981f, 0.09571993f, 0.09292292f, 0.33566171f, 0.07015115f, 0.04213939f, 0.11794846f, 0.01593499f, 
    0.00226098f, 0.10926183f, 0.04159126f, 0.19338447f, 0.16862454f, 0.13431251f, -0.01875353f, 0.06146328f, 
    0.04204280f, 0.13465692f, 0.05964112f, -0.08554651f, -0.03787653f, 0.05935586f, -0.04553865f, 0.10284123f, 
    -0.13995624f, 0.12848815f, -0.05179247f, 0.07614313f, -0.20490786f, -0.29575628f, 0.26027563f, -0.17289455f, 
    -0.01159520f, 0.14976653f, 0.00207587f, 0.06171260f, -0.05142890f, 0.33399484f, 0.00589491f, -0.15504117f, 
    0.03499225f, 0.05612589f, -0.03886996f, -0.00668282f, 0.15301476f, -0.00402026f, -0.01832574f, 0.05615697f, 
    -0.13125065f, 0.24342622f, -0.08900696f, -0.07557173f, 0.01530575f, 0.04653878f, 0.10855713f, 0.10616865f, 
    0.02612175f, 0.15756413f, 0.06263366f, -0.05647676f, 0.20028409f, 0.11720521f, 0.04119172f, -0.02611766f, 
    0.20601703f, 0.13379638f, 0.22585817f, 0.18412037f, -0.01444530f, 0.13964149f, -0.05583282f, 0.07440732f, 
    -0.19959563f, 0.25498518f, 0.10969782f, 0.11771312f, 0.23555246f, -0.04282691f, 0.11158771f, -0.11068016f, 
    0.08598480f, -0.09864243f, 0.10074979f, -0.21977200f, -0.03084819f, -0.11353766f, -0.22591972f, -0.03484957f, 
    -0.17904951f, 0.09457203f, -0.09313902f, 0.07082116f, -0.15149583f, -0.01760589f, -0.07175350f, 0.02877648f, 
    -0.04051726f, 0.04173652f, -0.00353657f, -0.12590183f, -0.15936923f, -0.13431168f, -0.21044816f, -0.00860859f, 
    -0.02553899f, -0.00631473f, -0.05653672f, 0.01774641f, 0.06818406f, 0.25874704f, 0.43955737f, 0.03057831f, 
    -0.04976915f, -0.05860737f, 0.10570306f, 0.05482793f, -0.04340149f, 0.03159450f, 0.10090716f, -0.02213710f, 
    0.06558553f, -0.06678794f, 0.12572613f, 0.09223548f, -0.05852489f, -0.00289832f, -0.16384685f, 0.27001339f, 
    -0.17683248f, -0.13852142f, -0.16143502f, -0.13662477f, 0.09720926f, -0.07529881f, 0.05781021f, 0.00482272f, 
    -0.07673916f, -0.03126480f, -0.00911844f, -0.01447698f, 0.01764284f, 0.06187481f, -0.07479025f, -0.05938528f, 
    -0.04965267f, -0.02710314f, -0.02175582f, -0.04909996f, 0.06749123f, -0.08414047f, -0.05711669f, 0.03460405f, 
    -0.04385240f, 0.07214989f, -0.01744586f, 0.04975120f, 0.01645418f, -0.02606372f, 0.02955092f, -0.07991782f, 
    -0.05472830f, -0.02362784f, -0.07008406f, -0.07406721f, -0.04165754f, -0.06350291f, -0.07841084f, -0.02306072f, 
    -0.07618330f, 0.07931125f, 0.00767475f, -0.07442304f, -0.02714252f, 0.06193236f, -0.04430859f, -0.01475989f, 
    -0.04327653f, 0.04243544f, 0.07635588f, -0.08686929f, 0.02921779f, -0.02541351f, 0.02556025f, -0.01843340f, 
    -0.03844725f, -0.05510616f, 0.07785371f, 0.04394008f, 0.06182607f, 0.00142017f, 0.06739873f, 0.03539796f, 
    -0.05122965f, 0.06641737f, 0.06985105f, -0.01840820f, 0.01180091f, -0.06868673f, 0.04647864f, -0.01936249f, 
    -0.03066297f, 0.07383205f, -0.00680911f, -0.02632846f, -0.05487992f, -0.04088275f, -0.08192176f, -0.00265901f, 
    0.04314950f, 0.02519312f, 0.06370120f, -0.08219600f, -0.02111206f, 0.00563772f, -0.02122358f, -0.05765827f, 
    -0.07685940f, -0.01002965f, -0.04099252f, -0.05072914f, -0.08617670f, -0.06225936f, -0.06433824f, -0.02428508f, 
    -0.00961430f, -0.00428615f, -0.07352005f, 0.00213180f, -0.07277318f, -0.01537114f, -0.00401688f, 0.03171539f, 
    -0.06826390f, -0.02287483f, 0.00301055f, -0.06006112f, -0.02626932f, 0.07070003f, -0.01078798f, 0.08206779f, 
    -0.02559295f, 0.01218356f, 0.05034572f, 0.00350026f, 0.05649551f, 0.03089006f, 0.03418993f, -0.07182010f, 
    -0.00571085f, -0.08865640f, 0.01225526f, -0.00322094f, 0.00932647f, -0.06867988f, -0.08084078f, 0.04007106f, 
    -0.03244586f, -0.00933156f, -0.04415388f, -0.05403906f, -0.04034597f, -0.01972997f, -0.03982859f, 0.06567225f, 
    0.03222772f, 0.07120087f, -0.01918276f, -0.02711547f, 0.03472478f, -0.05230369f, 0.03426394f, 0.05520970f, 
    -0.05504056f, -0.04503202f, -0.00053129f, -0.02431340f, 0.06186062f, -0.03469760f, 0.06496599f, -0.06855973f, 
    0.01878798f, 0.00044767f, -0.02650502f, -0.04006894f, -0.05871506f, 0.07470823f, -0.04403372f, -0.04380463f, 
    0.05405330f, -0.05725097f, -0.05140720f, -0.04787307f, -0.08376070f, -0.02537537f, 0.01246886f, 0.06025216f, 
    -0.00714851f, -0.02890824f, 0.04018748f, -0.07315445f, -0.04234763f, 0.02384792f, -0.01788852f, -0.07744686f, 
    -0.07968162f, -0.08159833f, 0.03766953f, 0.00007128f, -0.06761074f, 0.01081974f, 0.03529298f, -0.05602962f, 
    0.07712461f, -0.08467284f, 0.04511028f, -0.04421685f, 0.03469439f, -0.04224746f, -0.03690769f, -0.03571979f, 
    -0.04866458f, -0.01624443f, 0.01566595f, 0.02885825f, 0.04829196f, 0.04726224f, 0.03771692f, -0.03958172f, 
    0.01339328f, -0.01834004f, -0.08625011f, -0.00254600f, -0.02059003f, 0.03261205f, 0.06095934f, -0.06076005f, 
    0.03483153f, -0.01553719f, -0.05937795f, -0.04781671f, -0.01480440f, 0.02412132f, -0.06637771f, -0.07786775f, 
    -0.03070842f, 0.05849022f, 0.03618371f, 0.06587169f, 0.01031941f, 0.02138911f, -0.00442869f, -0.01114928f, 
    0.06120041f, 0.02054059f, -0.07678063f, 0.02194807f, -0.06253868f, -0.07519311f, 0.03974236f, -0.07808244f, 
    0.03143308f, 0.03689481f, -0.01034539f, -0.09050740f, -0.00359074f, -0.01846121f, 0.05625506f, 0.02804010f, 
    0.01459711f, -0.00811245f, 0.05946823f, -0.04029752f, -0.03469801f, -0.08171017f, -0.05738078f, -0.08968002f, 
    0.00324760f, 0.07231805f, -0.06475991f, 0.06800911f, 0.07442442f, -0.06589787f, -0.01188498f, -0.08760577f, 
    0.00726416f, 0.01776125f, -0.01899837f, 0.06144474f, 0.02482396f, -0.00617911f, 0.03874703f, -0.04846622f, 
    -0.01790974f, 0.05113255f, -0.05020086f, 0.05483865f, 0.00717559f, -0.07022656f, -0.05352819f, -0.06766450f, 
    -0.08277472f, -0.04449165f, 0.06888802f, -0.04895919f, 0.00117334f, 0.00088413f, -0.05265113f, -0.06591412f, 
    -0.08383823f, 0.05188781f, 0.05393605f, -0.03343445f, 0.01418556f, 0.04179731f, -0.05612123f, -0.09128144f, 
    -0.05617907f, -0.03540878f, -0.00643523f, 0.06281160f, -0.04828408f, 0.02958391f, -0.03583488f, 0.06354254f, 
    -0.04901219f, 0.05602121f, -0.05240170f, -0.03217594f, 0.01198543f, -0.07887927f, -0.07509992f, 0.04165215f, 
    -0.07860777f, 0.05032968f, -0.07302355f, -0.06515341f, -0.05802028f, 0.01414828f, 0.03496972f, -0.00956898f, 
    -0.00054722f, -0.06495870f, -0.08475567f, -0.00397051f, -0.00693783f, -0.06054696f, -0.08588503f, -0.00367043f, 
    0.05161475f, -0.05948430f, -0.03966299f, -0.07752463f, 0.05645875f, -0.00812655f, -0.00117007f, 0.01951498f, 
    0.06612018f, 0.05075841f, 0.06375181f, 0.05734572f, -0.04107334f, -0.04711617f, -0.00543201f, 0.05344908f, 
    -0.08289142f, 0.03235725f, -0.04474264f, -0.04789020f, -0.06512436f, -0.01792369f, 0.02083219f, 0.02914384f, 
    0.01435972f, 0.07327247f, -0.07075764f, -0.06753276f, 0.04976320f, -0.04518390f, 0.03196051f, -0.08350042f, 
    -0.04288397f, -0.00907493f, 0.05637424f, 0.07784160f, -0.05316171f, -0.05815590f, 0.00984069f, 0.07596005f, 
    0.02806943f, -0.06082488f, 0.04532379f, -0.06571008f, -0.01081164f, -0.01469716f, 0.03358574f, 0.01473068f, 
    0.02376388f, -0.04943994f, -0.01925273f, -0.04825722f, 0.08548882f, -0.02898646f, -0.02938310f, -0.00116596f, 
    -0.08968988f, 0.03553901f, -0.06803246f, -0.00198783f, 0.02138950f, -0.04554127f, -0.07952095f, -0.04270273f, 
    -0.00404795f, 0.01462817f, -0.02750325f, -0.04575684f, 0.02039140f, -0.03438930f, -0.03378862f, 0.03951704f, 
    0.01802412f, -0.04307563f, -0.05140460f, -0.00645549f, -0.01431907f, -0.01898824f, 0.00377384f, -0.06669690f, 
    -0.02560290f, 0.03281909f, -0.00909313f, -0.03875543f, -0.02957131f, 0.07149768f, -0.06834505f, 0.06081241f, 
    0.06115796f, 0.07582053f, 0.06532853f, 0.01363575f, 0.06203657f, 0.02638086f, -0.03112242f, 0.05113972f, 
    0.01106062f, -0.07105023f, -0.06816482f, 0.05947113f, -0.00341971f, -0.02074815f, -0.03930011f, 0.07616309f, 
    0.04702400f, 0.04289655f, -0.06951257f, -0.01309732f, 0.04335541f, -0.08105408f, -0.02516171f, -0.07575115f, 
    0.07345121f, -0.02504212f, -0.03032392f, -0.08628666f, -0.07322420f, 0.06473757f, -0.04563074f, 0.05376938f, 
    -0.14834200f, 0.14457585f, -0.13988358f, -0.17788605f, -0.00986284f, -0.07374243f, -0.14428015f, -0.07114618f, 
    0.02587385f, -0.51221645f, -0.10449816f, -0.22643921f, 0.04393927f, 0.03164700f, -0.06899047f, 0.17543551f, 
    -0.13465931f, 0.01833638f, -0.38544023f, -0.19186912f, 0.00371574f, 0.08326709f, 0.04440322f, -0.07561608f, 
    0.04739354f, -0.04115157f, -0.06937163f, -0.16633919f, -0.25915486f, -0.00449671f, -0.19431402f, 0.17266275f, 
    0.19500308f, -0.00910856f, -0.06868192f, -0.10111985f, 0.41480562f, 0.21307905f, 0.37633213f, -0.03777128f, 
    -0.02374209f, -0.17682339f, 0.12398932f, -0.05643419f, -0.00830935f, -0.26443431f, 0.00342172f, -0.03610912f, 
    -0.04130025f, 0.08815199f, -0.17083578f, 0.04803862f, 0.00783785f, 0.15170866f, 0.07070127f, -0.26395026f, 
    0.04825419f, 0.11189760f, 0.05239946f, 0.04879179f, -0.06282703f, -0.02503941f, -0.01277833f, -0.60797077f, 
    -0.25945154f, -0.26544234f, -0.07620225f, 0.01725809f, -0.00667947f, -0.06141252f, -0.00265052f, 0.08843113f, 
    -0.02523206f, 0.02900115f, -0.20676422f, 0.09136151f, 0.05593327f, 0.03255111f, 0.04739871f, 0.08802233f, 
    -0.07572295f, -0.28090805f, 0.07345268f, -0.10135705f, -0.20651768f, 0.04352460f, 0.01189925f, 0.22011524f, 
    -0.04419153f, 0.08351973f, 0.21259810f, -0.01206244f, -0.13383070f, -0.12161297f, 0.21848983f, 0.17223081f, 
    0.01812911f, 0.05868120f, 0.09537943f, 0.07561117f, 0.13352354f, 0.02535094f, 0.00995804f, 0.04856506f, 
    -0.17361589f, -0.03533752f, 0.02145673f, 0.12027363f, 0.20931001f, 0.14098705f, 0.22551467f, 0.20834459f, 
    -0.03263817f, 0.09745314f, 0.18213376f, 0.06606234f, -0.06119381f, -0.13927443f, -0.14504583f, 0.01689761f, 
    0.09439550f, -0.02237955f, -0.14329658f, -0.01732543f, -0.15256421f, -0.07257205f, 0.06910648f, 0.09012771f, 
    -0.03790504f, 0.11546746f, 0.04823470f, -0.08033455f, -0.10943356f, 0.11897907f, 0.16820939f, 0.32374939f, 
    0.03705925f, 0.27761355f, 0.07217113f, 0.07461403f, 0.15558164f, 0.11289863f, 0.13478313f, 0.06989804f, 
    0.25691321f, 0.26807702f, 0.12183384f, -0.14385906f, -0.04102570f, -0.06086451f, -0.01276642f, 0.09358546f, 
    0.02335128f, -0.04320887f, 0.01020595f, 0.04697802f, -0.18209048f, -0.01459940f, -0.00793629f, -0.00700294f, 
    0.10910757f, 0.12120458f, 0.23784673f, 0.05817920f, -0.01078731f, 0.06524545f, -0.31655350f, 0.06100340f, 
    0.01760328f, 0.02801113f, 0.03208533f, -0.12708853f, 0.30591071f, -0.27918884f, 0.04586799f, 0.02817971f, 
    0.04678319f, 0.14367667f, -0.13818403f, 0.21924737f, -0.23986694f, -0.08054976f, -0.11429238f, 0.26824468f, 
    0.09665625f, 0.14715512f, -0.02818849f, -0.10504224f, -0.11761460f, -0.11232349f, -0.12357130f, -0.24562915f, 
    -0.14164728f, 0.08119150f, -0.05900869f, -0.09863203f, 0.05955212f, -0.04334429f, 0.30271563f, 0.04294456f, 
    0.21261589f, -0.08602427f, 0.13848047f, -0.01696973f, -0.13572372f, 0.23314813f, -0.04812980f, 0.14072420f, 
    -0.11921266f, 0.16625811f, -0.26287973f, 0.05375623f, -0.05291227f, 0.14487614f, -0.01584960f, 0.07222264f, 
    -0.38276833f, -0.06813628f, 0.13365695f, -0.20296672f, -0.09918540f, 0.00170658f, 0.00187782f, -0.12503172f, 
    -0.05182069f, 0.03649622f, -0.18121932f, -0.13342932f, 0.03182563f, -0.04681542f, -0.09265241f, -0.03610420f, 
    0.04946199f, -0.08917457f, 0.35860649f, 0.18920536f, 0.07282510f, -0.02273369f, -0.00011738f, -0.18548149f, 
    0.10947008f, -0.01138154f, -0.03637181f, 0.04094964f, 0.11686715f, -0.14476621f, 0.07822046f, -0.08665410f, 
    -0.03228532f, 0.11062059f, -0.03233062f, 0.02545789f, 0.06024012f, -0.08210483f, 0.09196322f, 0.25263062f, 
    -0.01576136f, 0.01760942f, 0.02275217f, -0.11213321f, 0.05474991f, 0.04299087f, -0.11237065f, -0.08739289f, 
    -0.19097759f, -0.02308744f, -0.05059605f, -0.05635389f, 0.10412800f, -0.17921765f, 0.27803779f, -0.13443331f, 
    -0.04606440f, 0.03941682f, 0.05438652f, -0.00091559f, 0.06627974f, -0.02982537f, 0.01853183f, -0.40588874f, 
    -0.33664283f, -0.03025256f, 0.25261956f, 0.09588416f, 0.14831340f, 0.04914734f, -0.00735104f, 0.05025566f, 
    -0.08564559f, 0.05884402f, -0.06502165f, -0.07710231f, -0.03196678f, 0.06501085f, -0.05427244f, -0.08579908f, 
    -0.04718686f, -0.02812223f, 0.02274255f, -0.00356165f, -0.01686587f, 0.07197449f, -0.03831431f, 0.06720933f, 
    -0.07603268f, 0.02312556f, -0.06788185f, -0.04197722f, -0.05321264f, 0.00847337f, -0.04648827f, 0.03074921f, 
    0.03289472f, -0.06318145f, -0.02660955f, 0.02100159f, -0.07175089f, -0.03485502f, -0.00651546f, 0.01539306f, 
    0.00208355f, 0.03616405f, 0.02399409f, -0.03012264f, 0.04796514f, -0.05321517f, 0.03586242f, -0.06696528f, 
    -0.01831219f, 0.00725674f, 0.00113062f, -0.06820498f, 0.07080930f, -0.04997263f, -0.02088384f, 0.03955993f, 
    -0.08369400f, -0.04878490f, 0.00668180f, 0.05207259f, -0.04956482f, 0.01059354f, -0.06621753f, -0.02487990f, 
    0.03170744f, 0.01849383f, 0.05196306f, -0.02680406f, 0.03758987f, -0.03881524f, -0.02871713f, -0.06085414f, 
    -0.00688843f, -0.02233930f, -0.08369328f, 0.06893141f, 0.02211255f, 0.06269318f, 0.02564571f, -0.05617911f, 
    0.03740896f, -0.04795932f, -0.05741252f, -0.02087558f, -0.04404130f, -0.03658578f, -0.03549309f, 0.02411970f, 
    -0.07991982f, -0.05361502f, 0.02420303f, 0.02279078f, 0.05018145f, 0.00727488f, 0.04513682f, -0.07088454f, 
    -0.04545855f, 0.04853308f, 0.02297354f, 0.00013528f, 0.02516222f, -0.01928221f, 0.01850824f, 0.07717150f, 
    -0.05921108f, 0.02337818f, 0.04491834f, -0.07312928f, 0.06529005f, -0.03980725f, -0.04697897f, -0.06033761f, 
    -0.02494488f, -0.02016290f, 0.04752797f, 0.03016522f, 0.06560218f, 0.03783483f, -0.05186298f, -0.06179173f, 
    -0.03128500f, 0.00516239f, -0.03486118f, 0.06286611f, 0.01273075f, 0.00876997f, -0.06234286f, 0.01362239f, 
    -0.06047559f, 0.01649267f, -0.00012681f, -0.06706043f, -0.02716468f, -0.04827764f, -0.00500937f, -0.07096516f, 
    0.05688882f, 0.04230063f, 0.04183685f, 0.00997665f, 0.06051718f, 0.02956583f, -0.07072034f, 0.03034142f, 
    -0.04085010f, 0.04920428f, -0.03025226f, -0.06135444f, -0.06867273f, -0.07495839f, 0.01490790f, -0.05143693f, 
    -0.16653778f, -0.09015819f, 0.05976574f, 0.12282462f, -0.01507374f, 0.13537480f, 0.11098605f, -0.01392039f, 
    0.09609859f, 0.24118134f, 0.23354565f, -0.04481419f, 0.11927472f, 0.10244879f, 0.09781385f, 0.04623933f, 
    0.02257064f, -0.01956798f, 0.12933101f, -0.08611234f, -0.08529837f, 0.24694580f, 0.09075092f, 0.15328524f, 
    -0.06801667f, -0.05367320f, -0.08578119f, -0.16748430f, -0.13174267f, -0.05976409f, 0.14799745f, -0.00037938f, 
    0.13622904f, 0.01152373f, -0.05190594f, -0.13843219f, 0.38136798f, 0.34018603f, -0.04964607f, -0.11283924f, 
    -0.08927621f, -0.10894144f, 0.05725157f, -0.14650132f, -0.02944543f, 0.03343420f, 0.22731678f, -0.04072447f, 
    -0.21199763f, 0.09883679f, 0.05963364f, 0.11305817f, 0.10485295f, 0.20282872f, -0.57318753f, -0.08287984f, 
    0.18449585f, 0.15097815f, 0.05182176f, -0.03110788f, -0.09021929f, -0.23539960f, -0.15432870f, -0.25526348f, 
    -0.05197575f, 0.15931474f, -0.16574833f, -0.08543261f, 0.15621656f, 0.00274288f, 0.18502615f, 0.23081914f, 
    -0.06316660f, 0.09652944f, 0.25022444f, -0.12196271f, -0.04573505f, -0.12999289f, -0.16474074f, 0.14377515f, 
    0.22536655f, -0.13004209f, -0.07583752f, 0.01197074f, 0.01579055f, 0.07707121f, 0.15513749f, 0.07496236f, 
    -0.04982734f, -0.06624874f, 0.18887448f, 0.16340779f, -0.46110448f, 0.28844222f, -0.26633716f, -0.22889107f, 
    0.14910898f, 0.21319763f, 0.12064387f, -0.03677221f, -0.00968082f, -0.15471752f, -0.08380313f, -0.08635876f, 
    0.05627410f, -0.05036498f, -0.12215246f, -0.18578707f, 0.33701444f, -0.08385419f, -0.16184734f, -0.06281454f, 
    0.16582286f, -0.06526665f, -0.02569933f, 0.03180694f, -0.16812365f, 0.09830803f, -0.14695740f, 0.32685292f, 
    0.03813055f, -0.01092314f, -0.07641040f, -0.20891777f, -0.10116018f, 0.03555544f, 0.19832785f, 0.09834822f, 
    -0.13341314f, 0.12753497f, -0.08738663f, -0.07116336f, 0.13070041f, -0.10213374f, 0.07744441f, 0.18520741f, 
    -0.06762664f, -0.08868222f, 0.12559952f, 0.12806953f, 0.10246152f, 0.08430523f, 0.12141172f, -0.04321813f, 
    0.26851630f, -0.03912072f, -0.33439729f, 0.11686516f, 0.16810244f, -0.10717580f, 0.10775264f, 0.00410700f, 
    -0.01839871f, -0.04290000f, 0.03617079f, -0.24606197f, 0.12421259f, 0.17004637f, 0.01524752f, -0.01986722f, 
    -0.04465784f, 0.03637160f, 0.10610146f, 0.00839343f, -0.11063071f, 0.30114388f, 0.13058029f, 0.01253533f, 
    -0.03328908f, -0.06016542f, 0.03234062f, 0.40497217f, -0.23579045f, -0.37105656f, -0.05003425f, -0.12974678f, 
    0.06084519f, -0.04528801f, -0.03698675f, 0.21059760f, 0.08256955f, 0.02281502f, 0.19167727f, -0.03258071f, 
    0.03863965f, 0.08959832f, -0.08089931f, 0.04624888f, -0.04330336f, -0.01629533f, -0.20210692f, -0.00624876f, 
    -0.27039811f, -0.06172494f, -0.10350516f, -0.13531792f, 0.04412264f, 0.04000931f, -0.24788193f, -0.01817733f, 
    -0.42742580f, 0.16691138f, -0.00355027f, -0.06780805f, -0.11136460f, -0.01106107f, -0.07838919f, 0.43408284f, 
    -0.00003808f, -0.06619567f, 0.07406129f, -0.02636623f, 0.00312317f, 0.02899069f, 0.05717167f, -0.18518464f, 
    -0.31723738f, -0.01743392f, -0.06928679f, -0.01540499f, 0.07013288f, 0.05182673f, 0.07821585f, -0.05408094f, 
    -0.09929559f, -0.25567240f, -0.28663689f, -0.19360255f, 0.08527557f, 0.00866384f, -0.13281386f, -0.04414328f, 
    0.00397003f, -0.10293017f, -0.08842224f, 0.06999334f, 0.08820584f, -0.06743214f, 0.11908044f, 0.24196339f, 
    -0.13023642f, 0.13429277f, 0.17148368f, -0.02632039f, -0.04467293f, -0.21547200f, 0.16391030f, -0.07122197f, 
    0.05809338f, 0.03333817f, 0.04660775f, -0.01194269f, 0.03391395f, 0.16866010f, 0.08391073f, -0.20600894f, 
    -0.01135330f, 0.02425626f, 0.00122688f, -0.13588710f, 0.12473949f, -0.24839096f, 0.04664249f, 0.15440227f, 
    -0.03349558f, -0.17875309f, -0.03043247f, 0.21673855f, 0.14760281f, -0.20503774f, -0.14007638f, -0.03533661f, 
    0.12909201f, -0.10951369f, 0.04743141f, -0.05484705f, 0.08893535f, 0.16657253f, 0.05310910f, 0.02333943f, 
    0.19107077f, 0.07473034f, -0.21389653f, -0.06712052f, -0.04059236f, 0.02068151f, 0.18505307f, -0.07331190f, 
    -0.17722897f, 0.00822573f, -0.04795598f, 0.01502232f, 0.01813092f, -0.06511719f, 0.17613244f, 0.03871283f, 
    0.02743313f, -0.23369870f, 0.16942082f, 0.11564162f, -0.15255100f, 0.05819206f, 0.02152812f, -0.08582320f, 
    0.02912823f, 0.12788732f, 0.28373364f, -0.12711468f, 0.09756199f, -0.04800206f, -0.06860158f, -0.01012895f, 
    0.07534119f, 0.06170212f, 0.12101161f, -0.09780173f, -0.09088217f, 0.06434400f, 0.15678024f, -0.14210343f, 
    -0.06271592f, -0.06723064f, 0.17010435f, 0.00825754f, 0.20060511f, 0.16753711f, -0.28036454f, 0.06440845f, 
    -0.12698798f, 0.07580669f, -0.06947405f, 0.01710496f, -0.12564218f, -0.03133962f, -0.27760017f, -0.40721223f, 
    -0.04358099f, 0.04338143f, 0.09418963f, 0.00107360f, 0.04525154f, 0.02488082f, 0.46710616f, 0.22851805f, 
    -0.18361746f, 0.03962284f, -0.05467097f, -0.09280295f, 0.02792921f, -0.01638595f, 0.10703906f, 0.14576831f, 
    0.29206836f, -0.24915740f, 0.14493746f, 0.16431816f, 0.01689614f, 0.02216017f, -0.03978375f, -0.11379133f, 
    0.33771414f, -0.23542799f, -0.07106838f, 0.06395121f, 0.01313928f, 0.04443401f, 0.08745947f, -0.05468720f, 
    -0.06659576f, -0.32851020f, 0.15637676f, -0.21897863f, 0.02087024f, 0.06345680f, -0.13725378f, 0.15785858f, 
    0.00925049f, -0.01892409f, 0.00246950f, 0.02562186f, -0.00420226f, -0.06983905f, 0.02773322f, 0.10417791f, 
    -0.07516012f, 0.18170048f, 0.05393427f, -0.26168886f, -0.24032426f, -0.50946552f, 0.21327107f, -0.07691528f, 
    0.14638309f, 0.02830141f, -0.05302341f, -0.14763094f, -0.27943054f, 0.11054547f, 0.11434253f, 0.10432528f, 
    0.05229604f, -0.15145883f, -0.09190711f, 0.06938237f, 0.12023189f, 0.09830141f, -0.39811426f, -0.02298922f, 
    0.10506681f, 0.00793309f, -0.21142857f, -0.08425224f, -0.01434436f, -0.17265141f, -0.11767910f, -0.53348798f, 
    0.23450556f, -0.12137018f, 0.11524736f, 0.06010802f, -0.04382779f, 0.07348198f, 0.08702458f, 0.01142335f, 
    0.17324689f, -0.03172207f, 0.02660442f, -0.05387251f, 0.13470131f, -0.08404176f, -0.03947962f, 0.14005448f, 
    0.12133271f, 0.05272694f, -0.02420448f, 0.03730730f, 0.10334436f, 0.11598301f, 0.10989039f, 0.08102103f, 
    -0.11929822f, 0.05481869f, -0.00055350f, 0.37004820f, 0.01290328f, -0.05158659f, 0.01976031f, 0.05039336f, 
    0.03047085f, 0.12348988f, -0.00620960f, 0.06438421f, -0.18397932f, 0.05378201f, 0.06645564f, -0.07857461f, 
    0.01013003f, 0.04929207f, 0.09318390f, 0.07884436f, 0.05044578f, 0.20021951f, -0.00188151f, 0.05050801f, 
    -0.07348513f, 0.25477555f, -0.07147019f, -0.08840334f, -0.28164756f, 0.00525032f, -0.06409489f, 0.16990452f, 
    0.05476745f, -0.06338546f, -0.11669548f, -0.02139177f, 0.08945981f, -0.29585636f, -0.33259809f, -0.28830522f, 
    -0.03115449f, 0.05805447f, 0.13933615f, 0.01322993f, -0.22338144f, -0.05909672f, 0.02970980f, 0.02075273f, 
    -0.00338261f, -0.14285283f, -0.04332890f, 0.02944240f, 0.02934545f, -0.03938358f, 0.23183149f, 0.11126222f, 
    -0.19652331f, 0.20707254f, -0.13785855f, -0.00404944f, 0.06526502f, -0.04520786f, -0.03587860f, 0.03569372f, 
    0.29506132f, 0.11915433f, 0.47496873f, 0.04469857f, -0.06305736f, 0.06120757f, 0.02104846f, 0.04314744f, 
    -0.05367998f, -0.34695879f, -0.19114876f, -0.13315776f, 0.01143811f, 0.11042967f, -0.01776375f, -0.12164698f, 
    -0.02787722f, 0.08266295f, -0.51315141f, -0.04657197f, -0.57158703f, -0.01829839f, 0.01079966f, -0.00659339f, 
    -0.04617893f, -0.01096718f, -0.06042117f, -0.16546531f, -0.15509598f, -0.26580927f, 0.20299615f, -0.07529069f, 
    0.16787863f, -0.00598257f, -0.06665425f, -0.01784944f, 0.15282664f, 0.05923183f, -0.05891754f, -0.04208745f, 
    -0.02805219f, -0.01757014f, -0.10179795f, -0.05804322f, -0.05282423f, 0.28393194f, -0.07628612f, 0.01403682f, 
    0.05321873f, -0.28738612f, -0.15487413f, 0.18291751f, 0.01961548f, -0.13532391f, -0.34048629f, -0.09646664f, 
    -0.20638484f, -0.03398196f, -0.04101029f, -0.03563663f, 0.07394578f, -0.05099991f, 0.18669371f, 0.04763861f, 
    0.10334836f, 0.01771910f, 0.16408822f, 0.14603668f, 0.01611261f, 0.11897001f, 0.10819486f, -0.05260807f, 
    -0.06205187f, -0.04887806f, 0.04482928f, 0.04624904f, -0.01016446f, -0.08737168f, 0.01516611f, -0.05248192f, 
    -0.01274909f, 0.05335626f, -0.07395384f, -0.02865120f, 0.05819748f, 0.05598859f, 0.07285219f, -0.06576952f, 
    -0.09096426f, -0.10214564f, 0.04077235f, -0.00359485f, 0.02731619f, 0.01897849f, -0.09273891f, -0.01380647f, 
    -0.03615595f, -0.09495880f, -0.08107514f, -0.08499997f, -0.03716582f, -0.06162414f, -0.05604971f, -0.07832369f, 
    0.00988744f, 0.05202067f, -0.03042107f, -0.03107760f, -0.00044348f, -0.02988793f, -0.00831629f, 0.00914740f, 
    0.02358435f, -0.08893833f, 0.04176529f, 0.03219799f, -0.02525719f, 0.03078023f, -0.07104990f, -0.01660955f, 
    -0.01797427f, 0.04026587f, -0.04047501f, -0.08246757f, -0.08453529f, -0.00849793f, 0.03904568f, -0.03409839f, 
    -0.08507884f, -0.07507278f, -0.09049506f, 0.02673143f, -0.07191941f, 0.00117892f, -0.02804454f, -0.04303478f, 
    -0.07387587f, 0.02190584f, -0.02477375f, -0.08932848f, -0.01050378f, -0.07224359f, 0.06788703f, -0.05858645f, 
    -0.08129051f, 0.03856671f, 0.02662158f, -0.07239284f, -0.06929952f, 0.03718616f, -0.03858562f, -0.01897502f, 
    0.01886499f, 0.00334859f, 0.04602983f, 0.03770474f, -0.02314356f, -0.01422085f, 0.00003307f, 0.01850622f, 
    0.06146308f, 0.03772732f, -0.10152851f, 0.01801794f, 0.06233760f, -0.01540627f, -0.00231696f, 0.02401737f, 
    -0.06749573f, 0.00483582f, 0.08101874f, -0.09321252f, 0.04645088f, 0.00998373f, 0.00242173f, -0.04321992f, 
    -0.00588941f, 0.03026458f, 0.07278629f, 0.06251977f, -0.01892464f, -0.06801364f, -0.06568652f, -0.00702835f, 
    -0.05533763f, 0.05973072f, -0.02296929f, -0.07707909f, -0.03757807f, -0.02497395f, 0.06754615f, -0.01723383f, 
    0.02700434f, 0.05210961f, 0.06066538f, 0.03710493f, -0.05002015f, 0.05351790f, -0.06338845f, 0.03731540f, 
    -0.03562350f, 0.03466165f, -0.00647145f, -0.03517623f, -0.02057691f, -0.01923008f, 0.06891192f, -0.05733899f, 
    -0.03943799f, 0.05777134f, -0.01423352f, 0.04470701f, 0.02313184f, 0.01590361f, -0.03242227f, -0.07530992f, 
    -0.08295224f, -0.01046245f, -0.00842468f, -0.05344715f, 0.05795480f, 0.05053683f, -0.03244153f, -0.07271156f, 
    -0.01123332f, -0.02871038f, -0.04671411f, -0.00116256f, -0.00568234f, 0.03794905f, -0.01407371f, -0.03293119f, 
    0.04003796f, -0.05569597f, -0.07655363f, -0.06539622f, -0.04292003f, -0.07968713f, -0.00016107f, -0.00179088f, 
    -0.09523123f, 0.05047214f, -0.02253922f, -0.04576774f, 0.02603622f, 0.06549278f, -0.05269847f, 0.04972842f, 
    -0.02725693f, -0.02029302f, 0.02426318f, -0.08910885f, -0.04652594f, 0.04354097f, -0.00962540f, -0.08847632f, 
    0.00895322f, -0.06698269f, -0.08381872f, 0.04596112f, 0.04665117f, 0.00194418f, -0.03256782f, 0.06028019f, 
    -0.04098061f, -0.10067020f, -0.02606349f, -0.02139033f, 0.06824399f, -0.05407862f, -0.00450195f, 0.03478042f, 
    0.01237052f, -0.05715359f, -0.04547545f, -0.05858796f, 0.01988237f, -0.03317318f, -0.02019478f, 0.04228602f, 
    0.03922176f, -0.07978582f, -0.00658995f, -0.07979638f, 0.01777001f, -0.07168481f, -0.07919478f, -0.07787721f, 
    -0.00734041f, -0.03788004f, 0.04418466f, -0.04626632f, 0.00737175f, 0.01724624f, -0.03683517f, 0.06071597f, 
    -0.03380139f, 0.05515526f, -0.07502963f, 0.01773437f, -0.07743343f, -0.03298316f, 0.00457972f, -0.01521723f, 
    0.00247222f, -0.04071521f, -0.01832378f, 0.01999482f, 0.05279770f, -0.03512035f, 0.02482511f, 0.03165882f, 
    0.04132519f, 0.03976755f, -0.02600951f, -0.04278093f, 0.03109203f, 0.00604351f, 0.03631705f, 0.04891939f, 
    -0.01460768f, -0.01768544f, -0.08817835f, 0.06643947f, -0.02342767f, 0.05435689f, 0.05249091f, 0.04041260f, 
    0.03662430f, -0.00094151f, -0.08841117f, 0.03977696f, 0.03433518f, -0.02384867f, -0.08315428f, -0.03920628f, 
    -0.00209237f, -0.04055050f, -0.05817163f, -0.00051996f, -0.06527989f, 0.04105662f, -0.07453175f, -0.07177078f, 
    0.07482643f, -0.08793540f, 0.03859724f, -0.00093909f, -0.05930046f, 0.02917461f, -0.05288308f, -0.03235510f, 
    -0.07295795f, -0.01165261f, -0.01059662f, 0.03094378f, -0.07707018f, 0.01752858f, 0.00776069f, -0.03068618f, 
    -0.08291158f, -0.08969256f, 0.00991834f, 0.01384113f, -0.03863496f, -0.05841763f, -0.06716282f, -0.01680210f, 
    -0.07664907f, -0.02355875f, -0.01729081f, 0.06517158f, -0.02044764f, 0.03303025f, 0.03059440f, -0.06224548f, 
    -0.02706395f, -0.09477504f, -0.07296691f, -0.06266540f, 0.07115816f, -0.07970282f, -0.06588458f, 0.05127195f, 
    0.03321214f, -0.07253806f, -0.04947920f, -0.01264535f, -0.05405976f, -0.04479433f, -0.05454786f, -0.05824768f, 
    -0.01506287f, -0.07564660f, 0.06348296f, -0.00425866f, -0.06085667f, 0.00421273f, 0.01063023f, 0.04277653f, 
    -0.04490124f, -0.03532484f, -0.05182472f, -0.00103954f, -0.02874102f, 0.07500560f, -0.02357095f, 0.00088490f, 
    -0.01276709f, -0.07149519f, -0.02913348f, 0.06092317f, 0.04608337f, -0.01535651f, 0.06532446f, -0.03065725f, 
    0.04733258f, 0.02313859f, 0.03641505f, -0.06530569f, -0.02105612f, 0.04205194f, 0.00631704f, -0.06930052f, 
    -0.03270828f, -0.00701231f, -0.00473227f, 0.00550435f, -0.07723488f, 0.02910775f, 0.01473933f, -0.02385430f, 
    0.02627109f, 0.02406626f, -0.04970748f, 0.04710482f, 0.02605596f, 0.01938675f, -0.07825364f, -0.00210933f, 
    0.01727091f, 0.02384009f, -0.01803375f, -0.02330090f, -0.03570943f, 0.01625697f, 0.04600741f, 0.03806265f, 
    -0.00599659f, -0.07102272f, -0.09131357f, 0.01375257f, -0.05865369f, -0.01347932f, 0.05454225f, -0.10183624f, 
    -0.04425809f, 0.01084678f, 0.04655983f, 0.02232531f, -0.07804936f, -0.03048062f, -0.04749533f, -0.04075401f, 
    0.02020366f, -0.01468173f, -0.00064709f, 0.00470234f, -0.04540629f, -0.02335501f, 0.01071275f, 0.03476017f, 
    0.00322576f, -0.02597551f, 0.05907822f, -0.04939495f, -0.01066602f, -0.03474930f, 0.02526773f, -0.04337620f, 
    -0.08730803f, -0.00200474f, 0.04450404f, 0.02015315f, -0.03203396f, -0.06312891f, 0.02294381f, -0.04438546f, 
    -0.01118942f, -0.08731423f, 0.03359741f, -0.05943736f, -0.02292866f, -0.06672546f, -0.00523348f, -0.01162002f, 
    -0.04115846f, 0.01289478f, 0.07681055f, 0.05868027f, -0.07106396f, -0.09318321f, -0.06346586f, -0.05493159f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.09297789f, -0.02838731f, -0.14104646f, 0.06740171f, 0.00369826f, 0.00213218f, 0.08609579f, 0.02151432f, 
    -0.02959378f, 0.02206483f, 0.17074463f, 0.17404428f, 0.06528168f, -0.08395815f, 0.05120060f, -0.03809480f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.11585900f, -0.06760663f, -0.11506626f, -0.07516930f, 0.18858057f, 0.01105422f, -0.24263293f, 0.14112675f, 
    -0.21987313f, -0.07289565f, -0.23100150f, 0.10031998f, 0.02107030f, -0.01459384f, 0.15368980f, 0.21430501f, 
    -0.08042216f, -0.15638107f, -0.17564610f, 0.09629562f, -0.12522814f, 0.16786474f, -0.05036232f, -0.07080793f, 
    -0.22627643f, -0.06521794f, 0.19308156f, -0.13118079f, -0.03572756f, -0.17749500f, 0.13650706f, -0.10287848f, 
    0.28265989f, -0.40660840f, -0.10767009f, -0.20770597f, -0.09701046f, -0.21515848f, 0.22817291f, 0.33121115f, 
    0.10080853f, 0.15723281f, -0.40357587f, 0.24466012f, 0.15637310f, -0.25287569f, -0.15113094f, 0.16607866f, 
    -0.03213701f, 0.25806442f, 0.07785713f, -0.17597340f, 0.10841341f, -0.11240056f, 0.33202717f, -0.14002500f, 
    -0.10234918f, 0.23273227f, 0.26715156f, -0.17327668f, -0.51241052f, 0.09969199f, -0.11334351f, -0.16613558f, 
    -0.03984098f, 0.29523394f, 0.33227256f, -0.15862313f, -0.24195449f, 0.23623933f, -0.10340560f, -0.19886786f, 
    -0.05115271f, 0.01754298f, -0.11932062f, 0.31237537f, -0.24228364f, -0.03872342f, 0.06526337f, 0.06749950f, 
    -0.00234350f, -0.30378371f, 0.17718264f, -0.14387792f, 0.22314608f, -0.08679690f, 0.01498285f, 0.04101476f, 
    -0.06193522f, -0.05632418f, 0.24842270f, -0.00055507f, 0.51098406f, -0.02168540f, 0.03944280f, 0.07941767f, 
    -0.34001634f, 0.26589885f, -0.01401928f, -0.17007233f, 0.01080336f, -0.13764429f, 0.25600466f, -0.06255706f, 
    0.01735860f, -0.08657036f, 0.06060240f, 0.48583016f, -0.30705366f, -0.19950588f, 0.03212682f, -0.21220447f, 
    -0.07971124f, 0.41566405f, 0.26769745f, 0.15093249f, -0.09461040f, 0.18716745f, 0.02332052f, -0.13418485f, 
    0.19578506f, -0.11528326f, -0.19600490f, 0.18691751f, 0.12999335f, 0.08083238f, 0.07197360f, -0.23067161f, 
    -0.33906361f, 0.07716376f, -0.01218168f, -0.13068677f, 0.21821956f, 0.04922592f, 0.30954409f, 0.21281399f, 
    0.09921737f, 0.07288677f, 0.51340353f, -0.50434649f, -0.02421265f, -0.01469795f, -0.19521846f, 0.21310875f, 
    -0.01324180f, 0.45155522f, 0.11922808f, -0.20571467f, -0.00202012f, -0.18569547f, -0.07615091f, -0.26390296f, 
    0.14213659f, -0.30520752f, 0.44409066f, 0.15088202f, -0.12701330f, -0.12569185f, 0.13345803f, -0.09559231f, 
    0.16581939f, -0.30096278f, 0.21056765f, -0.10096551f, -0.05116108f, 0.12243237f, 0.26762646f, -0.38095635f, 
    -0.23925327f, -0.15670215f, 0.36485749f, -0.00000056f, 0.21728076f, 0.23677796f, -0.00401571f, 0.25160676f, 
    -0.22493176f, 0.17210752f, -0.19845161f, -0.11092141f, 0.15046658f, -0.13982636f, -0.01504836f, 0.00515632f, 
    -0.18653160f, 0.46166283f, 0.26248738f, -0.34482747f, 0.16935723f, 0.21045107f, 0.23582418f, -0.22706363f, 
    -0.40374699f, 0.26383296f, -0.12800996f, 0.23261718f, 0.07392465f, -0.18711588f, 0.47733656f, -0.01879224f, 
    -0.15428990f, -0.03547398f, 0.41970491f, 0.05557347f, 0.37794256f, -0.09284304f, -0.15974490f, -0.21954302f, 
    0.03790986f, -0.06780227f, -0.05558122f, -0.13227251f, 0.19788179f, -0.14427128f, -0.28418213f, 0.24990116f, 
    0.04750991f, 0.20823568f, -0.09417709f, 0.35327321f, 0.16231224f, 0.07044977f, -0.18522829f, 0.13779637f, 
    0.06303395f, 0.18366928f, -0.26856118f, -0.24506861f, -0.22175078f, -0.23874101f, -0.06350749f, 0.07209485f, 
    0.16466074f, -0.19160393f, 0.01291471f, -0.05867543f, -0.27093101f, -0.13215622f, -0.03580205f, -0.07058372f, 
    -0.31076640f, -0.07498746f, 0.16895695f, 0.24607518f, -0.17884830f, -0.00807604f, 0.23317723f, -0.55249304f, 
    0.13529506f, 0.14717644f, -0.32811898f, -0.15192384f, -0.09222222f, -0.16664353f, -0.11687326f, -0.07190880f, 
    -0.23051213f, 0.32662103f, -0.02049549f, 0.01772648f, 0.11260687f, 0.09022082f, -0.05597614f, 0.29944852f, 
    -0.06567994f, 0.31445691f, -0.51750439f, -0.03716301f, 0.03211022f, 0.15874228f, -0.00181341f, 0.07549498f, 
    0.10384531f, -0.00787267f, 0.17379072f, -0.22453371f, 0.03743032f, 0.23673850f, -0.30981097f, -0.12354578f, 
    0.16063491f, 0.00841552f, 0.56442553f, -0.42623025f, -0.30687425f, 0.05052793f, 0.04293505f, 0.04611311f, 
    0.24287876f, 0.32354558f, -0.12638980f, 0.24179742f, -0.16701920f, -0.18315998f, -0.31576613f, 0.16471361f, 
    0.22201592f, -0.24116810f, 0.46831104f, 0.27519742f, -0.10831887f, 0.12468210f, 0.09781862f, 0.14256495f, 
    -0.13656278f, -0.11466420f, 0.23456228f, 0.16066918f, -0.22965780f, 0.13310778f, -0.49776191f, -0.18655877f, 
    0.16848356f, 0.03168384f, 0.08224641f, 0.34416336f, -0.09921803f, -0.22241944f, -0.02981246f, -0.27844277f, 
    -0.21131110f, 0.35569534f, 0.13047092f, 0.17867491f, 0.17526585f, -0.07871732f, -0.04301633f, 0.41221502f, 
    0.01880190f, -0.13654736f, -0.14409083f, 0.01517666f, 0.18006843f, 0.19414327f, -0.18251145f, -0.22607099f, 
    -0.06940735f, 0.03616115f, -0.07989854f, -0.15211508f, -0.21153578f, 0.20397681f, 0.26536742f, -0.47546563f, 
    0.10747663f, 0.25080472f, -0.21355581f, 0.13074301f, 0.41805547f, 0.15839329f, 0.03967620f, 0.02549489f, 
    0.34379750f, -0.02326900f, -0.07664303f, 0.19465339f, 0.17595313f, -0.10702723f, 0.12322486f, 0.21354918f, 
    -0.13407928f, 0.27560905f, -0.35854006f, 0.28269455f, -0.51809168f, -0.18025570f, -0.05012368f, 0.19404900f, 
    0.06236286f, 0.35726532f, 0.43184453f, -0.09433808f, 0.13132004f, -0.14960410f, 0.25630876f, -0.47258654f, 
    -0.13026722f, -0.17996046f, -0.09002233f, -0.20251122f, -0.43520516f, 0.07015559f, -0.21971893f, -0.18358406f, 
    -0.20685041f, -0.24571133f, -0.01867008f, -0.13387749f, 0.18540126f, -0.16476801f, -0.12968671f, 0.07623389f, 
    -0.17407438f, 0.01618272f, -0.24128178f, -0.22425291f, -0.09566590f, 0.11915281f, -0.15386796f, 0.01199988f, 
    0.19828135f, 0.28774163f, -0.23386234f, 0.19410464f, -0.17959833f, -0.00310526f, 0.19875844f, -0.11735945f, 
    -0.12266889f, 0.12803662f, -0.01980867f, 0.20713638f, -0.30871609f, 0.04319145f, -0.12135723f, -0.19330721f, 
    0.40524027f, 0.09301858f, 0.39853671f, -0.17929935f, 0.12103134f, 0.01519794f, 0.04292132f, -0.04807591f, 
    0.22898620f, -0.04753586f, -0.36239740f, -0.33757043f, -0.04119586f, -0.14611517f, -0.19131644f, 0.15004478f, 
    0.03068648f, -0.19803129f, -0.01024194f, -0.00322309f, 0.03811768f, 0.03169843f, 0.27070394f, -0.42596921f, 
    -0.19727471f, 0.40311721f, 0.32411450f, 0.13022782f, -0.49754634f, 0.20075856f, -0.07996846f, -0.08055724f, 
    -0.31250682f, 0.18181691f, 0.15714583f, -0.14738996f, -0.12653619f, 0.11434882f, 0.19608389f, -0.17964450f, 
    -0.20026661f, 0.09950898f, 0.27906516f, -0.41193891f, 0.25937563f, -0.13845178f, 0.03306112f, -0.20445271f, 
    0.40235806f, 0.04291191f, -0.00827147f, 0.06031458f, 0.20279983f, -0.16461280f, -0.15226206f, -0.08857624f, 
    0.03600437f, 0.11961100f, -0.40525553f, 0.30862921f, -0.11451360f, -0.19050810f, 0.21730205f, -0.08729836f, 
    -0.30448365f, 0.10162690f, 0.04522295f, -0.00606596f, 0.10105230f, 0.17187363f, -0.31078985f, -0.15620708f, 
    0.12551624f, 0.33359692f, -0.15754548f, 0.07976819f, 0.38050312f, 0.10935117f, -0.09590188f, -0.00920783f, 
    0.22014222f, 0.33981669f, 0.06220186f, -0.08847190f, 0.09174696f, -0.02833004f, 0.34981710f, -0.02492384f, 
    -0.12629195f, -0.48217079f, 0.09862234f, 0.23385942f, -0.02342913f, 0.21484935f, -0.22294405f, 0.03211861f, 
    0.34725749f, -0.19526106f, 0.02405099f, -0.01536587f, -0.12705521f, -0.08018766f, 0.24078168f, 0.11569540f, 
    0.19079725f, 0.18916908f, -0.27926457f, -0.22123468f, -0.22739553f, -0.00623178f, 0.19737032f, -0.15959612f, 
    -0.53445601f, -0.00390025f, -0.02874766f, -0.21013704f, 0.01411064f, 0.09744405f, -0.17884065f, 0.14081557f, 
    -0.14299059f, 0.30353507f, 0.13612176f, 0.07213413f, 0.09006911f, 0.11150429f, -0.21258216f, 0.12852803f, 
    -0.00649838f, 0.15070759f, -0.15727715f, 0.13911256f, 0.21687116f, 0.16343433f, 0.08752639f, -0.08443025f, 
    -0.16974600f, -0.14842810f, -0.36134917f, 0.11832037f, 0.64269257f, 0.15641288f, 0.02170780f, 0.21636203f, 
    0.05270443f, -0.24216750f, -0.06555021f, 0.00336796f, -0.00375810f, 0.01207936f, -0.19477251f, -0.11382574f, 
    0.05844721f, -0.16589092f, 0.10981615f, -0.01940205f, -0.01978674f, 0.15820235f, 0.24969259f, -0.10489520f, 
    -0.19214897f, -0.17154877f, 0.16136177f, 0.00660073f, 0.01297748f, 0.24379912f, 0.31682649f, -0.39943177f, 
    -0.22576429f, 0.06281959f, 0.29127908f, 0.14997867f, 0.13694967f, -0.20715287f, 0.24713248f, -0.12596869f, 
    -0.31841660f, -0.16165307f, 0.20231338f, 0.06099766f, 0.05252112f, 0.03246265f, -0.23689330f, 0.13751328f, 
    0.09315399f, 0.04031885f, 0.26539761f, 0.24995469f, 0.49414504f, 0.24404405f, -0.05719730f, -0.04775422f, 
    0.24543035f, 0.00448440f, -0.03598809f, 0.06783383f, -0.11220747f, -0.12176023f, -0.33817351f, -0.10952318f, 
    0.20538418f, 0.38196409f, -0.01423901f, 0.21252404f, -0.14131847f, -0.10564665f, -0.04364426f, 0.17401664f, 
    0.27590066f, -0.22708505f, 0.01525791f, 0.12454806f, -0.02356170f, -0.09922941f, 0.31207958f, -0.26602507f, 
    -0.16566576f, -0.13094397f, 0.02353998f, 0.46028557f, -0.08319800f, 0.09233671f, 0.04841439f, 0.14528379f, 
    -0.23810975f, -0.17328635f, 0.01964149f, -0.21481110f, 0.12791876f, -0.05185647f, 0.24145830f, 0.09807289f, 
    -0.12056147f, 0.09360790f, 0.32044783f, 0.15581338f, 0.08446608f, -0.11235755f, -0.20154941f, -0.01664873f, 
    0.13379614f, -0.04089949f, -0.25217393f, -0.08924709f, 0.20358355f, 0.11207721f, 0.72354037f, 0.39229140f, 
    -0.23492171f, -0.19970442f, -0.20432490f, 0.06717601f, -0.12489385f, 0.19825888f, 0.20594782f, 0.02743156f, 
    -0.03656855f, -0.01476648f, -0.03543204f, -0.02596381f, -0.05821043f, -0.07387453f, -0.17072874f, 0.00315762f, 
    0.01811790f, -0.11561897f, -0.16900891f, 0.03981286f, -0.13713014f, 0.07014498f, 0.07477987f, -0.13514075f, 
    0.06317049f, -0.02009937f, -0.22680631f, 0.18533057f, 0.18047774f, 0.24962226f, 0.17505059f, -0.20940852f, 
    -0.15320227f, -0.11937389f, -0.20923987f, -0.05695742f, -0.04997739f, 0.22921759f, -0.01985601f, -0.03209370f, 
    -0.19346483f, -0.26101083f, 0.06605238f, -0.19414330f, -0.06735493f, -0.24002214f, 0.34949833f, -0.16409206f, 
    -0.17465255f, 0.14894803f, 0.21854535f, 0.05314350f, -0.07620163f, 0.16690484f, 0.07694501f, -0.22820631f, 
    0.12107667f, -0.45264059f, 0.19643098f, 0.12069539f, -0.00626209f, 0.02987303f, -0.13927166f, 0.35623485f, 
    -0.07396013f, -0.13189887f, 0.12221991f, 0.17159937f, -0.00030953f, 0.20889030f, 0.15998423f, -0.21410558f, 
    -0.23107567f, -0.17729002f, -0.24188843f, -0.17313579f, -0.17975104f, 0.21757171f, -0.22277838f, 0.09814447f, 
    0.19722599f, -0.03678662f, 0.03621623f, 0.18294567f, -0.21130818f, -0.21330673f, 0.19133151f, -0.00065038f, 
    0.18999775f, 0.23957430f, 0.28198710f, 0.01989341f, 0.06966353f, 0.08684260f, -0.17348275f, -0.01286362f, 
    -0.18661520f, -0.24698009f, -0.08095969f, -0.06843926f, 0.39577368f, -0.00959441f, -0.05959696f, -0.15792695f, 
    -0.07472876f, 0.05622303f, 0.31134135f, 0.17132021f, 0.04199748f, 0.09664334f, -0.28362846f, -0.10983174f, 
    -0.23332824f, -0.08451571f, 0.33061147f, -0.17695877f, 0.29779106f, -0.17083429f, -0.05813162f, -0.06893901f, 
    -0.22464044f, 0.35424566f, -0.20686972f, 0.21320474f, -0.06670583f, 0.18774159f, 0.29164818f, 0.41777551f, 
    0.23342507f, 0.26480258f, -0.21849740f, -0.07551175f, 0.37191904f, 0.11846693f, 0.23856220f, 0.10954826f, 
    0.33384481f, 0.09672126f, -0.07723778f, 0.13437879f, 0.20324600f, 0.12311916f, 0.06942761f, -0.30421039f, 
    0.12511152f, 0.30961609f, 0.49238133f, -0.30418614f, -0.15600081f, 0.18249714f, 0.22607371f, -0.08320722f, 
    0.17727058f, -0.02592938f, 0.27222890f, 0.24655682f, -0.03769594f, -0.03724076f, -0.40830010f, -0.12825783f, 
    0.17411739f, -0.03380924f, -0.16146727f, -0.21366239f, 0.31178787f, 0.08270882f, 0.06947941f, -0.03157432f, 
    -0.28063491f, -0.05860868f, -0.10622660f, 0.06729408f, 0.21303508f, -0.00696578f, 0.01733025f, -0.04068415f, 
    -0.17529042f, 0.21447290f, 0.48582804f, -0.05848885f, 0.07065614f, -0.22266412f, 0.23623413f, 0.04984052f, 
    -0.25744009f, 0.54460639f, -0.07692155f, 0.12535289f, 0.08216226f, -0.01020908f, -0.43621978f, 0.03238053f, 
    0.15173441f, 0.42531586f, -0.22076723f, 0.08516700f, -0.18381655f, 0.03380309f, -0.19506305f, -0.12287106f, 
    0.19065039f, -0.13505612f, -0.08020767f, 0.16099390f, 0.19266132f, -0.19850403f, -0.13410668f, 0.00237073f, 
    -0.02909470f, -0.27933869f, -0.01227051f, 0.03377231f, -0.24898235f, -0.08212253f, 0.02202398f, -0.10006821f, 
    0.26032379f, -0.28396472f, 0.19105585f, 0.20863691f, -0.11763957f, 0.12501642f, -0.55778694f, 0.42561191f, 
    0.12282071f, 0.02152751f, -0.43405399f, -0.12490971f, 0.27270594f, 0.20827168f, 0.13351965f, 0.09984636f, 
    0.44487488f, 0.02245024f, -0.15643638f, 0.07480150f, 0.19137487f, 0.11276689f, 0.18915486f, 0.35311410f, 
    -0.04354473f, 0.04102766f, -0.13860129f, 0.10013800f, -0.21248160f, 0.16734268f, -0.19081591f, 0.23771618f, 
    0.48174158f, -0.11424973f, -0.03310498f, -0.19035062f, -0.15059039f, -0.19009656f, 0.24717817f, -0.00748330f, 
    -0.14983857f, -0.19470130f, -0.21832038f, -0.35912335f, 0.43797413f, 0.00328422f, -0.09958762f, 0.12109235f, 
    -0.07187179f, -0.11768643f, 0.41715637f, -0.23970117f, 0.19296187f, 0.12209135f, 0.03345553f, -0.21559995f, 
    -0.04259188f, -0.21031459f, -0.36722153f, 0.00914480f, 0.44804183f, 0.06737524f, 0.07266545f, 0.07425617f, 
    -0.02482082f, -0.08176769f, -0.05464539f, -0.04834169f, -0.23900971f, -0.15977702f, -0.62255687f, -0.12088371f, 
    0.08477938f, 0.33740714f, 0.37025127f, -0.30440632f, 0.27050951f, -0.21914747f, 0.07013041f, -0.18929017f, 
    -0.06466225f, -0.20690389f, 0.01582534f, -0.17735650f, -0.05603699f, 0.12300618f, -0.34320056f, 0.43238991f, 
    0.19811314f, 0.24239999f, -0.08951724f, 0.39965671f, 0.24689314f, -0.27563801f, -0.10585593f, -0.20634106f, 
    0.27145883f, 0.31677884f, -0.15158403f, -0.01749128f, 0.18663454f, 0.11193100f, -0.36202708f, 0.32654878f, 
    -0.09562621f, -0.02138147f, -0.04890601f, 0.14981540f, -0.09778752f, -0.23172112f, -0.24288696f, -0.11934128f, 
    -0.01503397f, 0.65839416f, 0.13175029f, 0.01105994f, 0.01209612f, -0.22702873f, 0.09762295f, 0.19117570f, 
    0.08831675f, -0.02546086f, -0.16663463f, -0.22723785f, 0.13853353f, 0.08212419f, -0.18254870f, 0.18106498f, 
    -0.19932619f, 0.17387566f, -0.19946642f, 0.22938362f, -0.00867338f, -0.11633626f, -0.21414918f, -0.07996763f, 
    -0.23550135f, 0.08332014f, 0.14064957f, -0.19530337f, 0.01037784f, -0.06231300f, -0.16305882f, 0.24473777f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17447108f, 0.01460338f, -0.10972319f, -0.12263392f, -0.14897811f, 0.22427152f, -0.12273654f, -0.16111472f, 
    -0.02723786f, -0.12388883f, 0.13744690f, 0.06316817f, 0.02371859f, 0.06080166f, -0.10515106f, 0.09682889f, 
    0.28589439f, 0.04094459f, 0.17300545f, 0.14924438f, -0.39309278f, -0.28876948f, -0.01939226f, 0.01138285f, 
    -0.17200708f, -0.19894321f, 0.20090428f, -0.11518436f, 0.03768399f, 0.43269843f, 0.53939813f, -0.24603085f, 
    0.29842773f, 0.18383566f, -0.19323258f, -0.06026644f, -0.04276560f, 0.13248518f, 0.35448974f, 0.50159407f, 
    0.41264185f, -0.11218281f, -0.17011613f, -0.00809875f, 0.42557085f, 0.41997033f, -0.17055398f, -0.19905192f, 
    -0.18227121f, 0.19016325f, 0.16635339f, 0.37494192f, 0.36043912f, -0.19593368f, -0.27088323f, -0.38164392f, 
    0.00606438f, -0.30001906f, -0.60474229f, 0.34655720f, -0.08162770f, 0.16186351f, -0.04289369f, -0.07844514f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.00897393f, 0.10862467f, 0.07088195f, -0.12899153f, 0.06798637f, -0.14879088f, 0.08639332f, -0.01245450f, 
    -0.06532674f, -0.09872482f, 0.04424449f, 0.04124375f, -0.08046090f, -0.11050960f, -0.09456432f, 0.06176983f, 
    -0.09893089f, 0.01738532f, -0.09002573f, -0.08793567f, 0.11901731f, -0.01108176f, -0.06287706f, -0.01749597f, 
    0.10295326f, 0.03484568f, -0.05082549f, 0.02616646f, -0.13315614f, -0.12574010f, 0.09419577f, 0.02387451f, 
    -0.09284410f, -0.07634827f, 0.00439860f, -0.06099409f, 0.07729918f, -0.06615441f, -0.13940763f, 0.05105112f, 
    -0.00289494f, 0.01351942f, 0.08927274f, -0.06393637f, 0.00062122f, -0.03063395f, -0.04391068f, -0.11005301f, 
    0.09000605f, -0.04248144f, 0.07519010f, -0.06650468f, -0.07048557f, 0.01771680f, 0.04141371f, -0.07111007f, 
    0.05629196f, -0.06022819f, -0.01403968f, -0.05300024f, 0.05415618f, 0.04144004f, 0.05853590f, 0.09957834f, 
    -0.12302776f, 0.08951472f, -0.04459503f, 0.01680913f, -0.08105664f, -0.01337695f, 0.10408300f, 0.09194567f, 
    -0.04448994f, -0.11397248f, -0.04902254f, 0.04071588f, -0.11208848f, 0.04382406f, -0.12236384f, 0.00215220f, 
    0.08670092f, 0.06717362f, 0.02326503f, 0.06883632f, 0.03130798f, 0.02138032f, 0.00796461f, 0.08824302f, 
    -0.06498256f, -0.04822336f, -0.09209346f, -0.01850526f, -0.04670588f, -0.11228303f, -0.04487094f, -0.12275778f, 
    -0.02063930f, -0.02964630f, 0.01198511f, 0.03357258f, 0.01008638f, -0.14197274f, 0.04793233f, 0.01173379f, 
    -0.02030263f, -0.07583474f, 0.01993059f, 0.00198402f, -0.03159093f, 0.05489400f, 0.01839061f, 0.05425377f, 
    0.10540858f, -0.01148051f, -0.03889754f, -0.09410629f, 0.01436181f, -0.03461350f, 0.05611135f, 0.10619429f, 
    -0.03255435f, -0.05969889f, -0.00896054f, 0.02036583f, -0.00701208f, 0.10081461f, -0.06639691f, 0.08118127f, 
    0.02390946f, -0.00919306f, 0.20355852f, -0.04887393f, -0.16753595f, 0.14204434f, -0.17182463f, 0.03063655f, 
    0.02450554f, 0.05725304f, 0.12796463f, 0.12371339f, -0.19242714f, 0.04980393f, 0.09615839f, 0.19477586f, 
    0.13800843f, -0.05041760f, 0.00654242f, -0.43476257f, -0.00660165f, 0.20597854f, 0.02650942f, 0.05803476f, 
    0.03089544f, -0.00150990f, 0.03790782f, -0.19933885f, 0.10795559f, 0.18529668f, 0.16205356f, -0.01967847f, 
    0.04323199f, 0.02265677f, 0.27305916f, 0.06200147f, -0.03658918f, 0.21985680f, 0.03645384f, 0.26069477f, 
    -0.05660984f, -0.56678057f, 0.03870302f, -0.00149070f, -0.03580811f, -0.01435206f, 0.02866121f, 0.08667330f, 
    0.01604444f, 0.33019343f, -0.07925935f, 0.08676015f, -0.07635812f, -0.52765495f, 0.04974094f, -0.38158405f, 
    0.06194691f, 0.37245953f, 0.01892271f, -0.33506277f, 0.17946197f, -0.02583343f, -0.01042801f, -0.13741493f, 
    -0.09496610f, 0.00005244f, 0.10437551f, 0.20774071f, 0.09615980f, -0.03944147f, 0.07398450f, -0.06026062f, 
    0.17167129f, -0.37176156f, 0.01881640f, 0.17272739f, -0.04998747f, 0.04519688f, -0.04726218f, 0.12307774f, 
    -0.04409174f, -0.68884706f, 0.03381125f, -0.28124934f, -0.17085508f, -0.15181492f, 0.29104003f, -0.06465039f, 
    -0.05922978f, 0.19738334f, 0.05598212f, 0.33339018f, -0.09994990f, 0.38522416f, -0.08344845f, -0.09159313f, 
    0.37406412f, -0.10316494f, -0.22078358f, 0.01802122f, 0.10146071f, -0.19441202f, 0.16542590f, 0.14955606f, 
    0.05597408f, -0.19893168f, -0.01726595f, -0.04658617f, 0.15805885f, 0.20707141f, -0.11130063f, -0.15411972f, 
    -0.26076201f, 0.04848901f, 0.37596542f, -0.14047430f, 0.14079905f, -0.04495491f, -0.04356019f, -0.24100681f, 
    0.24908626f, -0.24546999f, -0.52583307f, 0.06747876f, -0.01145038f, 0.21239023f, -0.04219488f, 0.03295823f, 
    0.05073555f, -0.11019696f, -0.13571744f, 0.06202110f, -0.12907770f, -0.05034627f, -0.03561919f, -0.08619218f, 
    -0.11629016f, 0.04655357f, -0.03062536f, 0.07509336f, -0.08494283f, 0.03305558f, -0.06988230f, -0.10526840f, 
    -0.09211063f, -0.00518802f, 0.08852463f, -0.01022536f, 0.01043950f, 0.11167761f, -0.04612540f, -0.08012903f, 
    -0.09540901f, -0.09081771f, 0.07925320f, -0.11583304f, -0.08656134f, 0.02638877f, -0.00007692f, -0.01789243f, 
    -0.11282323f, 0.04880923f, 0.09737206f, -0.08985247f, -0.09115374f, 0.05976231f, -0.03934210f, 0.02799805f, 
    -0.08209153f, 0.05619148f, 0.04659624f, -0.03997892f, 0.03494755f, -0.12417785f, -0.00448027f, -0.07631350f, 
    0.07567656f, -0.05850629f, -0.07956938f, -0.03711345f, 0.00007450f, -0.01971297f, -0.01115648f, -0.01677597f, 
    0.10288332f, -0.05687559f, 0.07937232f, -0.08721086f, 0.02546167f, -0.01778905f, 0.06311666f, -0.10382423f, 
    -0.01692517f, -0.12182054f, 0.19293329f, 0.21067038f, -0.05703675f, -0.19986024f, -0.10108497f, 0.00975434f, 
    0.20301212f, -0.58085215f, -0.07724972f, 0.10243311f, -0.10884447f, -0.01269585f, -0.06207340f, 0.14906631f, 
    0.10556158f, -0.60296106f, 0.12957552f, 0.06890828f, -0.24664654f, -0.00087875f, 0.32119960f, 0.00128135f, 
    -0.03345059f, 0.17132291f, 0.29150870f, 0.21546368f, -0.05478337f, 0.38845861f, -0.06816225f, 0.06835742f, 
    0.42612267f, -0.13210590f, -0.32659897f, 0.11831274f, 0.04257882f, -0.18012328f, 0.20063713f, 0.05003941f, 
    0.03592652f, 0.30907375f, 0.03697807f, -0.02738807f, 0.07973279f, 0.13927516f, 0.04476094f, -0.20568426f, 
    -0.34981611f, 0.06812271f, 0.20892289f, -0.01005474f, -0.03118663f, -0.12087134f, -0.00511638f, -0.47375908f, 
    0.36699957f, -0.12515789f, -0.58114171f, 0.18795906f, -0.07137541f, 0.21559729f, 0.05026416f, -0.03203415f, 
    0.07482237f, -0.11868666f, -0.17706506f, 0.06495030f, -0.03795845f, -0.14696461f, -0.08347998f, -0.09581290f, 
    -0.06429069f, -0.12819353f, -0.05770199f, -0.12229003f, -0.09667931f, -0.05221564f, -0.00481389f, -0.14081523f, 
    -0.16042899f, -0.10848390f, -0.02240692f, 0.06391481f, -0.06501135f, 0.04020602f, -0.12572114f, -0.00851771f, 
    0.01199464f, -0.12283368f, 0.03464545f, 0.05613637f, -0.15183702f, -0.06806447f, 0.03878058f, -0.02835612f, 
    -0.13501030f, -0.06951021f, 0.01918127f, -0.05863959f, -0.02638189f, -0.05326289f, 0.06485256f, -0.15505482f, 
    0.01811519f, 0.03492913f, -0.03656305f, -0.05557071f, 0.03313028f, -0.13977011f, 0.12027787f, -0.05214191f, 
    -0.10050502f, -0.13542743f, -0.06279743f, -0.10419895f, 0.03978754f, 0.05171519f, 0.10748109f, 0.07286662f, 
    -0.16947992f, -0.12007865f, 0.01490832f, -0.01620841f, 0.03832981f, -0.02095319f, 0.05902873f, -0.11573830f, 
    -0.10779446f, -0.04458928f, 0.27182007f, 0.18911375f, 0.06413580f, -0.11617216f, 0.45610768f, -0.12053740f, 
    0.01021495f, 0.02448646f, -0.04983563f, 0.18936959f, -0.11497234f, 0.16315177f, 0.02495529f, -0.13426864f, 
    -0.20399797f, 0.05638719f, -0.28685424f, 0.20740412f, -0.45316905f, 0.22580260f, 0.24499565f, -0.32347858f, 
    -0.06693181f, 0.01981611f, -0.29358062f, 0.53406465f, -0.11959586f, -0.07360589f, 0.06646895f, -0.28408870f, 
    0.05676479f, 0.34118760f, -0.22861035f, -0.11089259f, 0.23517235f, 0.11572505f, 0.17961866f, 0.02237912f, 
    0.16945079f, -0.21117574f, -0.11972860f, -0.06732289f, 0.23794748f, 0.25871515f, -0.07101347f, -0.27967721f, 
    -0.08518836f, -0.20993979f, 0.20869777f, -0.33395076f, 0.22677068f, 0.36905307f, -0.08095571f, 0.81481677f, 
    -0.04925538f, 0.03082006f, -0.06836478f, 0.01943438f, 0.34207207f, -0.01392060f, -0.30529231f, -0.08376598f, 
    0.08575211f, 0.01320033f, -0.05122362f, 0.05713720f, 0.10784283f, 0.24902306f, 0.05785973f, 0.15308596f, 
    0.20434985f, 0.55813444f, 0.09560112f, -0.04665061f, 0.07659025f, 0.05483191f, -0.02605182f, -0.15647765f, 
    0.12434612f, 0.68905479f, -0.01747151f, 0.02841741f, 0.45036092f, -0.00313901f, -0.26310101f, 0.12034145f, 
    -0.03554568f, -0.24883507f, -0.10032104f, -0.14984477f, 0.23396328f, -0.31682655f, 0.16825433f, 0.16937634f, 
    -0.26147589f, 0.30007115f, 0.14435126f, -0.10513340f, 0.25862569f, 0.40758887f, -0.03235683f, -0.07053944f, 
    0.19987306f, -0.15911220f, 0.12345649f, 0.11774857f, 0.02846226f, 0.07392275f, 0.07038224f, 0.12331585f, 
    0.34515715f, -0.01660291f, 0.02231698f, -0.02965498f, 0.20989087f, -0.02251152f, 0.02490934f, 0.12688290f, 
    -0.19828981f, -0.16657443f, 0.50839186f, -0.18566681f, 0.14377284f, -0.20339486f, 0.03196020f, 0.05672469f, 
    0.12304997f, -0.08764042f, -0.11849514f, 0.05947426f, 0.09020027f, -0.08348128f, -0.08648548f, 0.09977812f, 
    -0.04237279f, 0.07278762f, -0.05797148f, 0.05745037f, 0.03669719f, -0.13152593f, -0.07032046f, 0.01907444f, 
    -0.07316057f, -0.07986870f, 0.05417059f, -0.08770010f, -0.02345501f, 0.05817498f, -0.14546227f, -0.15154773f, 
    0.08028868f, -0.03931377f, 0.01631247f, -0.09261385f, -0.10938246f, -0.09900445f, 0.01124049f, 0.04667982f, 
    0.07294456f, 0.06183372f, -0.09563436f, -0.04252043f, -0.11768239f, -0.00892765f, -0.04141584f, -0.05152386f, 
    0.04029022f, -0.15567800f, 0.08146656f, 0.08520943f, -0.04618543f, 0.02839601f, -0.07429428f, 0.08148035f, 
    -0.06261756f, -0.08217023f, 0.06198821f, -0.10501304f, 0.02480475f, -0.11291050f, -0.10448247f, 0.09465253f, 
    0.05723291f, -0.14175187f, -0.11051362f, -0.10847424f, 0.06787358f, -0.01654956f, 0.01051972f, 0.06388305f, 
    -0.08777955f, 0.04698591f, -0.26133001f, 0.03077103f, 0.10061397f, 0.03528960f, -0.40407029f, 0.10255665f, 
    0.00617262f, -0.03465373f, -0.01467417f, 0.49306026f, -0.67380893f, 0.14233895f, -0.02970778f, 0.18816090f, 
    0.32899323f, 0.18728997f, 0.38504654f, -0.10585642f, 0.01669661f, -0.27328017f, 0.10877985f, 0.10861679f, 
    -0.09253295f, -0.05869607f, 0.18517655f, -0.08105007f, 0.02885959f, 0.19384436f, 0.30138984f, -0.17037207f, 
    0.13569812f, -0.18362539f, 0.16824821f, 0.04895909f, -0.08986513f, -0.09872163f, 0.14381239f, 0.07825672f, 
    -0.18949553f, -0.56777316f, -0.02671273f, 0.11884463f, -0.18697043f, 0.13879164f, 0.04507144f, 0.05926672f, 
    0.05593197f, -0.02082627f, 0.22985388f, 0.22985195f, -0.01676655f, 0.27724788f, 0.05111332f, -0.46953481f, 
    0.06461272f, 0.25216228f, -0.55483341f, 0.28917110f, 0.13882989f, 0.47174120f, 0.23391481f, -0.05652845f, 
    -0.05149546f, -0.06945907f, -0.12093728f, 0.14132057f, 0.22698809f, -0.03925543f, 0.03566932f, 0.35990462f, 
    -0.00538629f, 0.31588212f, -0.16889347f, -0.24526890f, -0.01846992f, 0.08668646f, 0.14617281f, 0.06960995f, 
    -0.13361001f, 0.22050238f, 0.49264061f, 0.10349680f, 0.32940832f, -0.30307421f, -0.11305699f, 0.11973952f, 
    -0.08143681f, 0.00671927f, 0.23110810f, -0.44692734f, -0.03113323f, -0.03803515f, -0.05765039f, 0.28533420f, 
    -0.12761575f, -0.52331716f, -0.01095457f, 0.07133070f, -0.19138658f, 0.00267483f, 0.05023059f, -0.17795222f, 
    -0.17178039f, 0.44590002f, -0.08012637f, -0.04608727f, -0.31545076f, 0.11090823f, -0.09692232f, 0.42123196f, 
    0.25912303f, -0.02206140f, 0.11274297f, 0.09919593f, -0.09449910f, -0.06431492f, -0.01689513f, 0.49779916f, 
    0.03624343f, -0.70121378f, 0.26073694f, -0.40396890f, 0.13535707f, 0.34947154f, 0.29227147f, -0.06979109f, 
    -0.09260230f, 0.11759093f, 0.00753099f, -0.15215379f, 0.05008848f, 0.27809417f, -0.07785399f, 0.03322157f, 
    -0.44456416f, 0.25549275f, 0.23920351f, -0.46996307f, -0.11997332f, 0.06793742f, 0.04085209f, -0.12095700f, 
    -0.23157555f, 0.33860147f, 0.23351420f, 0.58234781f, -0.39847821f, -0.00179799f, -0.05090299f, -0.33558169f, 
    -0.11743210f, -0.03346663f, -0.11725831f, -0.08926296f, -0.13349798f, 0.18370202f, 0.16221946f, 0.19910663f, 
    0.00536042f, 0.00444017f, 0.76577276f, 0.12777810f, 0.10819114f, 0.35055128f, 0.10399238f, 0.38579917f, 
    0.10994122f, 0.14607081f, -0.12289573f, 0.10761239f, -0.06060282f, 0.19944121f, -0.11939472f, 0.17046691f, 
    0.16032895f, -0.23768592f, -0.09081221f, 0.47109967f, -0.04279716f, -0.23596349f, -0.07223257f, -0.48499620f, 
    0.08904787f, 0.88493907f, 0.13998766f, 0.57138562f, 0.17961693f, 0.15459174f, -0.26033738f, 0.06086127f, 
    0.04386772f, 0.07085057f, 0.44317383f, 0.09564263f, -0.09727360f, 0.01853728f, 0.15347855f, 0.09022633f, 
    0.05312556f, -0.77704960f, -0.06002147f, -0.11964458f, -0.23382671f, -0.06365965f, 0.17809330f, -0.11687609f, 
    0.32261375f, -0.13263777f, -0.49854690f, 0.17283931f, -0.09689374f, -0.11868576f, 0.28615072f, 0.01222765f, 
    -0.09996806f, 0.11033437f, 0.33802095f, 0.08451370f, -0.04552591f, 0.40497482f, 0.05672728f, 0.00680722f, 
    0.50418144f, -0.58312809f, -0.92986923f, 0.02634040f, -0.14506866f, -0.42979249f, 0.01287656f, 0.01656641f, 
    0.00901413f, 0.53634548f, -0.07365312f, 0.00628558f, -0.06531229f, 0.10390934f, -0.05155897f, 0.04483036f, 
    -0.29609790f, 0.02861170f, -0.05893329f, 0.24788432f, -0.30155918f, -0.09472167f, -0.09433046f, 0.02698024f, 
    0.30214897f, -0.30854040f, -0.28522733f, -0.07579762f, -0.04940808f, 0.08911412f, 0.08417434f, 0.11661734f, 
    -0.05827954f, -0.09804419f, -0.03749722f, 0.01766898f, 0.02049500f, -0.11628883f, 0.10772929f, -0.04402979f, 
    0.00630241f, -0.09822766f, -0.10926671f, -0.10220335f, -0.08288646f, 0.07180667f, 0.05415662f, -0.03796722f, 
    0.00148265f, 0.09939519f, 0.10670616f, 0.02985996f, -0.07965874f, -0.11428767f, 0.06525913f, 0.10719935f, 
    -0.06695785f, 0.07650499f, 0.08876062f, -0.01287825f, -0.00806009f, -0.00618385f, -0.11610608f, -0.04740638f, 
    -0.02244731f, 0.04163092f, -0.07041633f, 0.03155066f, -0.04415558f, 0.09035201f, -0.09989675f, -0.11868137f, 
    -0.01500104f, 0.05357337f, -0.09909588f, 0.01525635f, -0.03202601f, -0.11563402f, -0.10698071f, -0.09155655f, 
    -0.05767760f, -0.12233946f, -0.04474918f, 0.06862017f, -0.05264103f, 0.01705267f, 0.02786797f, -0.04247138f, 
    -0.00764493f, 0.05795130f, 0.08759493f, -0.10903719f, 0.01434631f, -0.10602199f, -0.01422821f, 0.08861241f, 
    -0.00226033f, -0.04535249f, 0.28858188f, -0.07373179f, -0.02504361f, 0.11367862f, 0.05433250f, 0.05419345f, 
    -0.06067427f, 0.02512062f, -0.18510088f, -0.21071407f, 0.07079756f, 0.41076484f, 0.02897546f, 0.74733651f, 
    0.35410234f, -0.61987251f, 0.01015564f, -0.31594607f, 0.08491321f, 0.21024662f, 0.13890107f, -0.05630234f, 
    0.00756733f, 0.05098948f, -0.10838091f, -0.07957372f, -0.10753717f, 0.19489236f, 0.15947257f, 0.00615130f, 
    -0.00195988f, 0.09210686f, -0.06074475f, 0.08771954f, 0.12109007f, -0.08611218f, 0.18986180f, 0.14358382f, 
    -0.04759764f, -0.33458281f, 0.04929779f, 0.02966914f, 0.16722789f, 0.06613606f, -0.04677519f, -0.19113483f, 
    -0.20717585f, 0.22260749f, -0.10355679f, -0.11263396f, 0.13062026f, 0.09956004f, -0.10866367f, -0.15224105f, 
    0.23545390f, 0.19251789f, -0.09960482f, -0.44027737f, 0.28033736f, 0.19037546f, 0.04276796f, -0.02021998f, 
    -0.00243083f, -0.02776489f, 0.01985000f, -0.17857310f, -0.07862775f, 0.01401796f, -0.02167192f, 0.03953557f, 
    -0.02132211f, -0.09747661f, 0.06367165f, 0.09311824f, 0.16021492f, 0.05805470f, -0.02645190f, -0.08615446f, 
    -0.00159840f, -0.03825557f, 0.00771886f, -0.03445135f, 0.04325635f, 0.05622860f, -0.09750374f, -0.06371404f, 
    -0.12006383f, 0.05055409f, -0.04762607f, -0.09586258f, -0.11955893f, -0.10000214f, -0.08832695f, 0.05531780f, 
    0.03506311f, 0.06780060f, 0.12479293f, 0.04880416f, -0.05984505f, -0.11972963f, 0.03784860f, -0.09546076f, 
    -0.11256959f, -0.10114671f, -0.11855696f, -0.00396864f, -0.06123015f, -0.02221558f, -0.09663434f, 0.07886032f, 
    0.04683993f, -0.03886166f, -0.10963123f, -0.12204407f, 0.06549030f, -0.10995921f, 0.11404194f, 0.08628776f, 
    -0.15661508f, 0.10008780f, -0.06219309f, 0.05625218f, 0.01088263f, -0.14545286f, -0.04936438f, 0.02960715f, 
    0.08883701f, 0.00647298f, 0.23156784f, 0.17841379f, -0.25002980f, 0.18753269f, -0.51397359f, -0.31400591f, 
    0.30771965f, -0.36185992f, 0.24074158f, 0.07506533f, 0.03200793f, -0.12812530f, 0.03510884f, -0.23480645f, 
    -0.31649095f, 0.59150934f, -0.32845837f, -0.29136491f, -0.53119588f, 0.01767343f, 0.11250924f, 0.09671255f, 
    -0.05682799f, -0.25435391f, 0.36528149f, 0.27456433f, 0.24940838f, -0.08577139f, -0.09719133f, -0.31926510f, 
    0.40755779f, 0.15585500f, -0.57662952f, -0.03094665f, 0.03818937f, 0.08246003f, 0.03893363f, -0.06819774f, 
    0.17178790f, -0.21311978f, -0.02879409f, -0.12086965f, 0.30220652f, 0.19268738f, -0.01238143f, -0.04909013f, 
    0.26618147f, -0.16392781f, 0.23092568f, 0.19089958f, 0.28172052f, -0.92142540f, 0.09099182f, 0.02666262f, 
    0.02460929f, 0.11134277f, 0.36475649f, 0.12841703f, -0.00374806f, -0.38111892f, -0.16583003f, 0.07789536f, 
    -0.06431554f, 0.08698224f, -0.01804741f, -0.05723702f, -0.12795204f, 0.07644432f, -0.02751735f, 0.04193804f, 
    -0.11907350f, -0.04507897f, -0.11951119f, -0.00104359f, -0.05474056f, -0.09484538f, -0.03576989f, 0.07976730f, 
    -0.07177079f, -0.04279019f, -0.01881117f, -0.02764251f, 0.04011296f, 0.03321368f, -0.03433911f, 0.04662140f, 
    0.02497043f, -0.01525516f, -0.03977558f, 0.07711960f, 0.04938749f, -0.10614128f, -0.14102750f, -0.01514270f, 
    -0.04580505f, 0.00073224f, 0.09057868f, -0.01250623f, 0.03254130f, 0.04781282f, 0.00810415f, -0.09098974f, 
    -0.10017346f, -0.12396460f, 0.02911085f, -0.10339917f, 0.01236642f, -0.09338405f, -0.04644729f, -0.04439897f, 
    -0.10816042f, -0.00812006f, -0.07152850f, -0.02098216f, 0.03652151f, -0.12658423f, -0.03401940f, -0.06019003f, 
    0.03164489f, -0.01394121f, -0.11050656f, -0.09702940f, 0.02299861f, 0.09996402f, -0.08325322f, 0.06384021f, 
    0.10802642f, 0.07123084f, 0.08908733f, -0.00356560f, 0.02852166f, 0.04310490f, -0.02319913f, 0.02732294f, 
    -0.08429927f, -0.04955210f, -0.06707332f, 0.10653155f, 0.02140366f, -0.11161577f, 0.02366312f, 0.01265760f, 
    0.02295410f, 0.08786783f, 0.06576672f, 0.01975374f, 0.08830127f, 0.08822570f, -0.13482328f, -0.11529341f, 
    0.04577912f, -0.09257695f, -0.05228211f, 0.05876581f, -0.00456934f, 0.03609337f, -0.08543172f, -0.02928227f, 
    -0.08626739f, 0.04135690f, -0.02583714f, -0.06098266f, -0.15217036f, 0.10729271f, -0.06651342f, -0.01401180f, 
    -0.13641758f, 0.05641390f, 0.03857628f, 0.08740471f, -0.10862197f, -0.03808891f, -0.01020819f, -0.09583753f, 
    0.01928801f, -0.04669219f, -0.09252500f, 0.13198827f, -0.02956912f, -0.01565991f, -0.01429895f, -0.00016743f, 
    -0.12772872f, 0.07851938f, -0.10021499f, 0.08071800f, -0.00585063f, -0.01105938f, -0.13807864f, 0.10414748f, 
    -0.07223865f, 0.04065624f, 0.15291069f, 0.06204130f, 0.19347151f, -0.04978223f, 0.35316119f, 0.17777561f, 
    -0.17235160f, -0.16514966f, -0.35287297f, -0.08975271f, -0.11363305f, 0.57011855f, 0.10046802f, 0.18952557f, 
    0.55525684f, -0.09766954f, -0.09902715f, 0.30543956f, 0.30534148f, -0.04175304f, 0.25782239f, -0.31038716f, 
    0.06686933f, -0.10229576f, -0.14529747f, 0.03150982f, -0.01134998f, 0.22091155f, 0.23308864f, -0.22990815f, 
    -0.05222080f, 0.34561726f, -0.15892455f, 0.01203707f, 0.00754689f, 0.28505638f, 0.23875079f, -0.02495692f, 
    0.07350130f, -0.32502779f, -0.04576355f, -0.01187991f, -0.00456252f, 0.07441315f, 0.11230071f, -0.23013802f, 
    -0.16836795f, 0.18833832f, -0.29144484f, -0.14317486f, 0.09441344f, 0.63520652f, 0.00447083f, 0.25405973f, 
    -0.14795543f, -0.27321443f, -0.76701373f, -0.10745785f, 0.40988448f, 0.38647905f, -0.05968273f, 0.04914954f, 
    0.03211580f, -0.04570600f, 0.00202422f, -0.10572802f, -0.40382791f, 0.21039547f, -0.01616097f, -0.54332328f, 
    0.26822659f, 0.14610803f, -0.00820231f, 0.34615687f, 0.12215784f, 0.19025452f, 0.06571146f, 0.37584209f, 
    -0.42915744f, 1.00049460f, 0.08757763f, -0.05950679f, -0.13128223f, 0.17393075f, -0.35276878f, -0.32578385f, 
    0.00226614f, -0.10694925f, -0.18645395f, -0.01678772f, -0.01640606f, -0.50534421f, -0.01695037f, -0.65760750f, 
    -0.27400163f, 0.22642878f, 0.24702044f, 0.12230799f, 0.17792696f, 0.11224451f, -0.15176497f, -0.08974897f, 
    0.22495143f, -0.15946469f, -0.03754252f, -0.00780308f, 0.08291920f, -0.11319490f, 0.10049236f, -0.07206366f, 
    0.03870228f, 0.10582992f, 0.13215792f, -0.14044584f, 0.34074262f, -0.29389283f, 0.11285329f, -1.06580579f, 
    -0.30644286f, -0.06420571f, 0.21767223f, 0.37766257f, 0.03911873f, 0.07596536f, -0.59934145f, 0.11465354f, 
    -0.05582397f, 0.11232589f, 0.04202108f, -0.07316623f, 0.06624573f, 0.34315139f, -0.15101670f, 0.02338372f, 
    -0.13344035f, -0.24522036f, 0.32096043f, -0.32276970f, -0.37026665f, 0.10449275f, 0.06087624f, 0.22948104f, 
    -0.24964777f, 0.08890089f, -0.04008803f, -0.15589884f, -0.14499824f, 0.06725227f, 0.12918468f, -0.02756283f, 
    0.03443465f, -0.04669748f, 0.18959312f, 0.08792765f, 0.00193437f, 0.04269212f, 0.03214049f, 0.17818739f, 
    0.26238957f, -0.22483338f, 0.46802655f, -0.07408293f, 0.25368840f, -0.03847051f, 0.04027397f, 0.47091433f, 
    0.15536556f, -0.54138505f, 0.04882754f, -0.02711557f, 0.11918895f, 0.28322375f, 0.11596890f, 0.06851723f, 
    0.01782525f, -0.10339451f, 0.04484139f, 0.08843018f, 0.09131438f, -0.55473602f, -0.04720199f, -0.36359087f, 
    0.22680432f, 0.48591843f, 0.16828734f, -0.27087602f, -0.09094480f, -0.07492290f, 0.07538070f, -0.01386108f, 
    -0.02872382f, -0.06315526f, 0.10347512f, -0.16261952f, 0.23555185f, 0.06373852f, 0.44191277f, 0.18377878f, 
    -0.40670651f, 0.17034240f, -0.02123238f, -0.19836193f, 0.17742094f, 0.25527844f, -0.02558203f, 0.05302408f, 
    0.21381156f, 0.20125210f, -0.14321461f, 0.67544103f, -0.07932508f, 0.15252918f, 0.06219234f, -0.10744461f, 
    0.08712529f, -0.07127331f, -0.16455390f, 0.07433217f, 0.00548939f, 0.10690191f, 0.20869771f, 0.02542928f, 
    -0.21834426f, 0.23354569f, 0.19299704f, -0.07030253f, -0.05396190f, 0.36851645f, 0.03362515f, 0.09131043f, 
    0.08445828f, 0.15180182f, 0.04127428f, -0.09673461f, -0.07971286f, 0.06922050f, -0.11782345f, 0.04765014f, 
    0.15456603f, -0.12336884f, -0.29631975f, 0.13045706f, -0.11408600f, 0.44842753f, 0.05888408f, 0.69432306f, 
    -0.08197584f, 0.64454168f, 0.12918688f, 0.10255555f, 0.10223725f, 0.05953473f, -0.20169064f, 0.02914703f, 
    -0.04182336f, -0.01464567f, 0.07118818f, 0.25212124f, -0.07150151f, 0.32188275f, -0.03841869f, 0.01614037f, 
    0.14091994f, 0.04863199f, 0.24780320f, 0.31418362f, -0.02032069f, 0.08140283f, -0.04697846f, 0.22835959f, 
    -0.08215175f, 0.25669068f, -0.28573611f, -0.67874855f, 0.00704405f, 0.46419823f, 0.05987299f, 0.06334607f, 
    -0.00900611f, 0.01429577f, 0.00224508f, 0.39084691f, 0.08530931f, 0.03378807f, 0.02897844f, -0.15018733f, 
    0.00711448f, 0.53575033f, 0.22058855f, -0.04831364f, 0.23097822f, 0.19471005f, 0.05623969f, 0.16372703f, 
    0.18364951f, -0.81195313f, 0.02838407f, 0.10661165f, 0.14981236f, 0.03098487f, -0.06698273f, 0.01542782f, 
    0.11145273f, 0.07201784f, 0.28008533f, -0.07766079f, 0.35910872f, -0.28568518f, -0.08961812f, -0.02458242f, 
    0.02056704f, 0.32112843f, 0.03241822f, -0.41539598f, 0.05495617f, -0.23423047f, -0.07615627f, 0.08928449f, 
    0.07679629f, -0.11753817f, 0.02565564f, -0.09412107f, 0.06199176f, -0.00789425f, 0.05084855f, 0.03018791f, 
    0.04082807f, 0.02629210f, 0.06267895f, -0.22010586f, 0.01858076f, -0.20667385f, -0.04808772f, 0.08380219f, 
    0.03893999f, -0.10703311f, 0.01223603f, -0.03444064f, -0.04015269f, -0.01846725f, -0.23038454f, -0.03510722f, 
    0.05842935f, -0.07587924f, 0.10928569f, 0.05722476f, -0.13374132f, -0.15897270f, -0.13354678f, 0.02066865f, 
    -0.11999467f, -0.08083145f, -0.07583430f, -0.06167850f, -0.10453290f, -0.00061308f, -0.10572962f, 0.00354062f, 
    0.00875213f, -0.11863843f, -0.04822497f, 0.00960505f, -0.12207079f, -0.07747207f, 0.07601425f, 0.01636684f, 
    0.00713285f, -0.02279619f, -0.08648838f, 0.03618866f, 0.06645459f, -0.01257827f, 0.00838380f, -0.09620997f, 
    -0.09970360f, -0.03557177f, -0.02674703f, -0.04751686f, -0.17739834f, -0.02025243f, 0.03932230f, 0.07642892f, 
    0.10739970f, 0.00849338f, 0.17771196f, -0.27808741f, -0.04171899f, 0.19610795f, 0.22253814f, -0.01652159f, 
    0.18962008f, -0.09621045f, -0.11844160f, -0.05241144f, 0.24219434f, 0.29616815f, -0.09123106f, -0.10040877f, 
    0.43151692f, -0.57435203f, -0.65695632f, 0.14240715f, 0.39441493f, 0.05895329f, -0.02941253f, -0.66803646f, 
    0.11444400f, -0.37078899f, -0.35977879f, -0.20993271f, -0.15520003f, -0.28170061f, 0.24928437f, -0.28528973f, 
    -0.09038017f, 0.57006019f, 0.16174643f, -0.03527100f, 0.01262800f, 0.47152111f, -0.13253541f, -0.23872322f, 
    0.16577157f, -0.11344280f, 0.03724416f, -0.02336092f, 0.17224467f, 0.13700305f, -0.01304780f, -0.16202936f, 
    -0.11123366f, 0.28848729f, -0.38671362f, -0.18038023f, 0.15257281f, 0.14486724f, -0.04981896f, 0.46161896f, 
    -0.12417163f, 0.21560153f, -0.34027186f, 0.16589290f, 0.41507235f, -0.07082405f, -0.02496801f, 0.02287401f, 
    0.03077890f, -0.02189417f, 0.08761758f, 0.07714926f, -0.17898563f, 0.02471569f, 0.02463333f, -0.03398825f, 
    0.14649740f, 0.16790052f, -0.19243227f, 0.61168927f, 0.20169257f, 0.06405250f, 0.00834015f, 0.11371501f, 
    0.27267876f, -0.12911402f, 0.14911552f, -0.70808268f, 0.16386332f, 0.44437021f, 0.17549317f, -0.22616845f, 
    0.02566218f, 0.30858952f, -0.14053474f, 0.18898267f, 0.17124186f, -0.09960852f, 0.15085065f, 0.03921113f, 
    0.02704764f, 0.28981921f, 0.24835779f, -0.03011984f, 0.12920302f, -0.04166186f, 0.13131383f, -0.17660870f, 
    0.12736936f, -0.40089935f, -0.04438643f, 0.05297928f, 0.02656427f, -0.10816626f, -0.04975592f, -0.07028237f, 
    -0.04851888f, 0.37985012f, 0.11975837f, -0.34132454f, 0.22323634f, 0.28537759f, -0.10106942f, 0.45829549f, 
    0.20700285f, -0.18850353f, 0.05823452f, -0.18740936f, 0.23977157f, 0.01302351f, 0.23315422f, 0.06645421f, 
    0.02599050f, 0.04561184f, 0.12568578f, -0.02791085f, -0.06503768f, 0.14104176f, 0.20577447f, -0.15401892f, 
    -0.09224183f, -0.24095747f, 0.00278930f, -0.05958494f, -0.16333801f, 0.18753822f, 0.10967990f, 0.05925693f, 
    0.06218984f, 0.76252717f, -0.17763481f, 0.05840664f, -0.13419051f, -0.34448281f, 0.03147598f, -0.14814495f, 
    -0.07777160f, -0.27491874f, 0.05013729f, -0.06357073f, 0.05312880f, 0.17928909f, 0.04665674f, -0.14854887f, 
    0.19387902f, 0.20254964f, -0.32467273f, 0.04844484f, -0.09193625f, 0.22776152f, 0.02318202f, 0.21397811f, 
    0.10458224f, 0.04676450f, 0.06341563f, -0.12091815f, 0.11916278f, 0.36436629f, -0.02723521f, -0.06719891f, 
    -0.04341596f, -0.02570125f, -0.13422324f, 0.22872788f, -0.07202933f, -0.24190059f, 0.13822584f, -0.18936804f, 
    -0.05247007f, -0.10758220f, -0.08810707f, 0.41292173f, 0.19840707f, -0.02301557f, -0.15895770f, -0.03072718f, 
    0.10813783f, -0.09669237f, 0.07751039f, -0.08901069f, -0.06799573f, -0.08617968f, 0.08598607f, -0.06832186f, 
    -0.11990609f, -0.09112800f, -0.07762619f, 0.10145386f, -0.02300662f, -0.03667882f, 0.03620109f, 0.11755382f, 
    0.02257421f, -0.10840492f, -0.03849050f, 0.02478470f, 0.02750349f, -0.07320668f, 0.06647585f, 0.02312267f, 
    -0.04862982f, -0.12469118f, -0.05452171f, -0.12105712f, -0.00916129f, -0.06321403f, 0.03028019f, -0.07497124f, 
    -0.10457110f, 0.05305419f, -0.09687457f, 0.00089842f, -0.11891321f, 0.03815640f, -0.04043942f, 0.03218165f, 
    0.00289781f, -0.08638580f, 0.08060226f, -0.02130654f, 0.07917020f, -0.10728735f, 0.08589193f, -0.06587502f, 
    -0.00841713f, -0.07186685f, 0.08161148f, 0.13210437f, -0.06266783f, -0.05272602f, 0.07026714f, 0.00998795f, 
    -0.01511072f, 0.02387005f, 0.03844896f, 0.04765764f, 0.04911501f, 0.03958969f, -0.07817000f, -0.09449422f, 
    0.08928104f, 0.07145619f, 0.24124207f, 0.15489285f, -0.11955686f, 0.08061021f, -0.07025392f, -0.05065911f, 
    -0.16739173f, 0.19491898f, -0.00869070f, -0.14542349f, 0.12522036f, 0.11504712f, 0.01398506f, -0.03326433f, 
    -0.27548477f, -0.77079499f, 0.13596970f, -0.03499097f, -0.15684186f, 0.12635665f, 0.10636044f, -0.32568640f, 
    -0.10241625f, 0.31801206f, -0.20580709f, 0.39005226f, -0.02189550f, 0.06929357f, -0.17437474f, 0.25331509f, 
    -0.04727791f, 0.06153160f, 0.47904557f, 0.09598303f, -0.02227210f, -0.07770202f, 0.13562216f, 0.32311714f, 
    0.12564300f, -0.07069284f, 0.10995641f, 0.03482513f, 0.11989560f, -0.15387055f, -0.09241675f, -0.05129456f, 
    -0.24384770f, 0.19291401f, -0.00062922f, -0.45925725f, 0.01757723f, -0.41181839f, -0.10508541f, 0.02316497f, 
    0.23264600f, 0.22341228f, 0.26011840f, -0.64723003f, -0.02067043f, 0.27305180f, -0.04439501f, -0.03335450f, 
    0.05440857f, -0.11413588f, -0.13695002f, 0.07521898f, -0.11982542f, 0.33744735f, -0.14788088f, 0.05740686f, 
    0.06692491f, 0.18097305f, 0.32318532f, -0.00057076f, 0.23587605f, -0.12962922f, 0.00026458f, 0.25930980f, 
    -0.05615840f, 0.58908176f, -0.06934703f, -0.10844353f, 0.24923810f, 0.08264133f, -0.30320150f, 0.42734569f, 
    -0.07000510f, -0.13044831f, 0.01431246f, -0.28984123f, 0.14525348f, -0.15743361f, 0.15676507f, 0.02939164f, 
    0.05359711f, 0.14169824f, 0.06403412f, 0.04293590f, 0.27502021f, 0.28383610f, -0.00309559f, 0.08071718f, 
    0.23379838f, -0.20545126f, 0.00696295f, 0.09288210f, 0.25601885f, 0.17026331f, 0.04140943f, 0.18525253f, 
    0.35213879f, 0.07143451f, -0.02294835f, 0.28248715f, 0.22881198f, -0.18309024f, -0.07696555f, -0.18551657f, 
    -0.31581929f, -0.29060698f, 0.53924936f, 0.05258744f, -0.15649451f, -0.36152637f, 0.03762718f, -0.03004823f, 
    0.03997222f, -0.06642519f, 0.25755858f, -0.15370546f, 0.12706402f, 0.11006898f, -0.06972855f, 0.06318767f, 
    -0.09307368f, -0.34603089f, -0.13582645f, -0.00536649f, -0.13106380f, 0.04903923f, -0.12616397f, -0.04112742f, 
    0.45513365f, 0.04024838f, -0.09375671f, 0.12163260f, 0.17465806f, -0.05336238f, 0.17459425f, 0.05131105f, 
    0.06481037f, -0.13843995f, 0.29177815f, -0.22285403f, 0.09129850f, 0.30677712f, 0.14951712f, -0.12409386f, 
    0.18271551f, -0.30229366f, -0.44969112f, -0.04332757f, -0.23857747f, -0.02360514f, 0.12809379f, -0.02049932f, 
    0.00009210f, 0.35193026f, -0.03535470f, -0.12152906f, -0.04303138f, 0.07324664f, -0.09532754f, 0.28380457f, 
    -0.00182912f, 0.17225465f, -0.18699270f, 0.58130419f, -0.10107104f, -0.53518391f, -0.06195848f, -0.87652451f, 
    0.13819586f, -0.18556739f, 0.18290965f, 0.39382473f, 0.02103030f, -0.07773378f, 0.08558735f, -0.04892293f, 
    0.11135699f, -0.08797362f, -0.04356087f, -0.06751551f, 0.08729308f, 0.09804827f, -0.70503700f, 0.23392355f, 
    -0.26442203f, -0.42436942f, -0.01821880f, 0.30872357f, -0.15934418f, 0.28089815f, 0.06792813f, 0.30303428f, 
    0.28367880f, -0.66376823f, -0.45288256f, 0.09565156f, 0.19306758f, 0.24090408f, -0.10864089f, 0.22728246f, 
    -0.10516685f, -0.27721283f, 0.24528246f, -0.25167853f, 0.18693043f, 0.19374253f, 0.29216182f, -0.21693398f, 
    0.13284922f, -0.06739461f, 0.49194342f, 0.00870275f, -0.11242753f, 0.13021976f, 0.09185863f, -0.32700837f, 
    -0.11588729f, 0.04942712f, 0.08670866f, 0.00209934f, -0.11981402f, -0.08792923f, 0.04243425f, 0.27261123f, 
    0.16858216f, 0.05065214f, -0.07241924f, 0.34759754f, -0.08226368f, 0.45442015f, -0.00600712f, 0.23256901f, 
    -0.14125009f, 0.73935765f, 0.63619697f, 0.54803586f, 0.04810856f, -0.14474244f, 0.21042545f, -0.12359415f, 
    -0.11435418f, -0.09350151f, -0.14827403f, 0.00207098f, 0.06738584f, -0.12863584f, -0.01164954f, -0.06460443f, 
    0.03581260f, -0.07678626f, 0.05141330f, -0.01456388f, -0.11674897f, 0.03280579f, 0.11704497f, 0.08944368f, 
    -0.06711709f, 0.09922686f, -0.10124170f, 0.02404748f, -0.07439505f, -0.11765088f, -0.15292057f, 0.07623620f, 
    0.03755268f, 0.05111342f, -0.04947484f, 0.03525871f, -0.08478459f, -0.08658360f, -0.09094770f, 0.07540610f, 
    -0.02545272f, 0.03890811f, -0.00589930f, 0.12147355f, 0.04316955f, -0.10523822f, -0.00384678f, 0.08851288f, 
    -0.06044943f, -0.03396975f, 0.09976557f, 0.07905819f, -0.03218495f, -0.07469944f, -0.05249783f, -0.11127114f, 
    -0.04385372f, 0.01044744f, 0.02312509f, -0.04372451f, 0.00902425f, -0.10142767f, 0.04666367f, 0.11890529f, 
    -0.07305772f, 0.01244259f, -0.04720481f, -0.00567175f, -0.04450643f, -0.08117417f, -0.01120069f, -0.08895175f, 
    0.12191328f, 0.02330148f, 0.18100414f, 0.09551453f, -0.09863958f, 0.19556066f, -0.05674631f, -0.07727236f, 
    0.12756748f, -0.33108509f, 0.11583710f, -0.00332432f, -0.27378178f, -0.04001673f, -0.10565500f, 0.62094891f, 
    0.19524997f, -0.06309081f, -0.02992300f, -0.58630121f, 0.08939463f, -0.01580369f, -0.07017731f, 0.26221141f, 
    -0.05275415f, -0.10455599f, 0.12307315f, -0.08946903f, 0.10307568f, 0.08598310f, 0.06053933f, -0.09529173f, 
    0.10339010f, -0.29177925f, 0.04826058f, 0.11471929f, -0.10336418f, -0.07440557f, 0.05050366f, 0.18990719f, 
    0.07550497f, -0.52625895f, -0.06841967f, 0.03513876f, 0.06035869f, 0.07486963f, 0.05703644f, 0.06485616f, 
    0.00099745f, 0.21523938f, 0.00030259f, 0.12179492f, -0.12131401f, -0.28346273f, 0.05619041f, -0.47723448f, 
    0.09107491f, 0.13065660f, -0.25115705f, -0.46039715f, 0.08959957f, -0.05983755f, 0.06161775f, -0.12905444f, 
    0.07463798f, -0.06841725f, 0.09579193f, -0.07731506f, 0.39537397f, -0.23985793f, -0.38604671f, 0.39606920f, 
    -0.44769207f, -0.07720718f, -0.54919565f, -0.43292123f, -0.57124376f, 0.13636865f, 0.01682008f, 0.31019431f, 
    0.36121505f, -0.27670312f, 0.24729432f, 0.38773251f, 0.43842614f, -0.47749099f, 0.15456986f, 0.20144133f, 
    0.07637770f, -0.24565111f, 0.29832083f, -0.75126326f, -0.09724989f, 0.34369719f, 0.07864642f, 0.01995939f, 
    -0.08253541f, -0.76565832f, 0.05702208f, 0.06668232f, -0.54692388f, -0.19431612f, 0.03028803f, -0.31780717f, 
    -0.34001544f, 0.36799115f, -0.03592438f, -0.00927900f, -0.50005126f, -0.12338488f, 0.03484863f, 0.39619324f, 
    0.17438740f, 0.07567411f, -0.33170384f, 0.43338490f, -0.93544143f, 0.26272884f, -0.11018077f, 0.56166387f, 
    0.04871000f, -0.39223179f, 0.33553290f, -0.26239994f, 0.13836163f, 0.35496792f, 0.20640674f, 0.08980776f, 
    -0.06623651f, -0.03252839f, 0.02568312f, -0.10673327f, 0.14338398f, 0.05061406f, 0.07536687f, -0.07775610f, 
    -0.10860693f, 0.13081989f, 0.07940383f, -0.04304294f, -0.06476576f, 0.00145464f, -0.00101507f, -0.07267846f, 
    -0.02746992f, 0.02015986f, -0.00975541f, 0.05824658f, 0.03096313f, -0.07615629f, 0.06471409f, -0.03740584f, 
    -0.07280327f, -0.03024783f, -0.11856717f, -0.01539387f, 0.06558317f, -0.10708002f, -0.10205972f, -0.03913305f, 
    0.04871427f, 0.05334717f, 0.04235853f, 0.03636509f, -0.05473480f, 0.02696234f, -0.12107928f, -0.07646648f, 
    -0.06638059f, 0.02940808f, 0.04666157f, 0.06208466f, -0.13890421f, -0.10183706f, -0.00577047f, 0.03805535f, 
    -0.01704910f, -0.02083408f, -0.01374545f, -0.02687149f, -0.02076675f, 0.04043184f, 0.06897305f, -0.03783699f, 
    0.04929200f, 0.09711360f, -0.11692145f, 0.00308649f, -0.10896345f, 0.11155336f, -0.12086235f, -0.00207251f, 
    -0.01260187f, 0.12444907f, 0.20238742f, 0.11195382f, -0.00253011f, -0.12416708f, 0.01366670f, 0.09378471f, 
    0.14529108f, -0.17747238f, -0.14655028f, 0.46330315f, -0.06439842f, 0.07703338f, -0.07599835f, -0.00262515f, 
    0.39809179f, 0.07172748f, 0.00181345f, 0.18285537f, 0.22087620f, -0.00662490f, 0.24403636f, -0.09961973f, 
    0.02121949f, 0.03686753f, 0.22062764f, 0.01149088f, 0.02130435f, 0.28263628f, -0.03102871f, -0.19863197f, 
    0.25625762f, 0.01330673f, -0.44287422f, 0.03342647f, -0.18431415f, 0.04081004f, 0.13604836f, -0.19339472f, 
    -0.01358004f, 0.44540849f, -0.08016177f, -0.12438695f, -0.08780821f, -0.09901192f, 0.02597624f, -0.12134563f, 
    -0.08294326f, 0.26488182f, 0.08106221f, 0.18410619f, 0.02637962f, 0.51654816f, -0.03030705f, -0.22388706f, 
    0.25016701f, -0.27975082f, -0.31325626f, 0.63067979f, 0.14804606f, 0.29246309f, 0.24854037f, 0.00602204f, 
    0.11184299f, 0.09661746f, 0.03542258f, 0.09631252f, -0.10292652f, -0.02842720f, 0.06986383f, -0.05674855f, 
    0.02390137f, 0.08919594f, -0.07494956f, -0.09100883f, -0.11170181f, -0.10111804f, -0.02578452f, 0.08904831f, 
    -0.02481739f, 0.08626191f, -0.04849963f, -0.05254789f, -0.02922077f, 0.00684266f, -0.10998108f, -0.07173964f, 
    0.04966161f, 0.08944338f, -0.12390651f, 0.00046345f, -0.08006206f, 0.03781079f, -0.01601330f, -0.01208313f, 
    -0.05926833f, 0.04181733f, 0.07614881f, 0.07539484f, 0.06307091f, 0.01254235f, -0.07100029f, 0.07646757f, 
    0.00965034f, 0.00302968f, -0.07529061f, -0.03159571f, -0.03511985f, -0.10127828f, 0.02562413f, 0.04080297f, 
    -0.02548551f, -0.02525435f, -0.12537719f, -0.09339790f, 0.05397984f, 0.06091408f, -0.02340770f, -0.02917111f, 
    -0.12188078f, 0.06857736f, 0.12348983f, 0.02639481f, -0.09704868f, -0.04832929f, -0.10034195f, -0.02744077f, 
    -0.09264192f, -0.11595361f, -0.08834655f, -0.08739648f, 0.08063444f, 0.09675366f, 0.08766510f, -0.09933084f, 
    -0.12801096f, -0.09777803f, -0.06808956f, -0.07821486f, -0.11973377f, -0.01650285f, 0.07962544f, -0.01857668f, 
    -0.10601013f, -0.10681532f, 0.03692988f, 0.10519634f, -0.02780720f, -0.06509146f, 0.09671120f, -0.05538828f, 
    0.08221178f, -0.13153365f, -0.02529019f, 0.01527633f, 0.01470962f, -0.00444476f, -0.02549382f, -0.07438853f, 
    -0.08291668f, 0.03110845f, 0.05474181f, 0.03297691f, 0.01704303f, -0.09114143f, -0.02292613f, -0.04235613f, 
    -0.00170531f, 0.04475220f, -0.05915014f, 0.08565679f, 0.00957880f, -0.09527265f, 0.12030986f, -0.08659218f, 
    -0.11838132f, 0.09444133f, -0.04302703f, -0.03985709f, 0.10021230f, 0.00783749f, -0.11722790f, -0.07978955f, 
    0.10955945f, 0.07830068f, -0.05912201f, -0.09313925f, -0.03262196f, -0.05512555f, -0.03877514f, -0.11461013f, 
    -0.07167247f, -0.08134605f, 0.07205905f, 0.11673223f, -0.21046168f, 0.07685961f, 0.23349820f, 0.12338988f, 
    0.24653533f, 0.24680217f, 0.20673062f, -0.45498836f, 0.34134272f, 0.00422580f, 0.06216438f, 0.64177042f, 
    -0.08449171f, -0.20444876f, 0.11379406f, -0.14166771f, 0.19163214f, -0.19903259f, 0.08296462f, 0.05495412f, 
    0.01298223f, 0.00801411f, -0.08302224f, -0.24059677f, 0.02239575f, -0.28638053f, -0.12611403f, 0.39741617f, 
    0.03451259f, 0.02299529f, -0.19632079f, 0.02681315f, 0.03329930f, 0.23433864f, -0.04472476f, 0.26914567f, 
    0.18468672f, 0.26924890f, -0.07613021f, -0.06836700f, 0.20752700f, 0.16449887f, 0.01426001f, -0.12895387f, 
    -0.03712146f, 0.16858256f, -0.23824514f, -0.31388080f, 0.04549435f, -0.18972446f, 0.02208195f, -0.34914228f, 
    -0.05019341f, -0.06419001f, -0.32382673f, -0.46752143f, 0.05951164f, -0.02397815f, 0.11716437f, -0.08980050f, 
    -0.07446775f, 0.09870344f, 0.13238826f, 0.24756347f, -0.01164307f, -0.22144602f, -0.04841382f, -0.11058990f, 
    0.24258669f, -0.08290050f, -0.05324327f, 0.12225877f, -0.13287719f, -0.08183513f, 0.09260979f, 0.17057355f, 
    0.02984406f, 0.10565586f, -0.33377862f, -0.65029132f, -0.02017964f, 0.18745212f, 0.17838082f, 0.25601918f, 
    0.09091957f, 0.28631148f, 0.17676340f, 0.34508812f, 0.16803697f, 0.05472152f, -0.02151623f, -0.02328859f, 
    0.32543716f, 0.19627205f, -0.44664404f, 0.06176643f, 0.09276796f, -0.22190052f, 0.11076861f, -0.03390518f, 
    -0.09042019f, -0.55933887f, -0.03018823f, -0.01409616f, 0.19682446f, 0.00585615f, 0.10806049f, -0.17594962f, 
    -0.16363582f, 0.12152186f, 0.19123727f, -0.35124880f, 0.03270269f, 0.53747296f, -0.09894146f, -0.03055469f, 
    0.16776629f, 0.00142181f, -0.28646260f, -0.38539928f, -0.13125402f, -0.09626313f, 0.12274557f, -0.11380696f, 
    -0.09224062f, -0.04324014f, 0.04680774f, 0.13592264f, 0.24783067f, 0.01467047f, 0.49280027f, 0.09390739f, 
    -0.31520799f, 0.30100194f, 0.20341143f, -0.29907522f, -0.10442648f, 0.19125140f, 0.05305415f, 0.12267519f, 
    -0.21578549f, 0.01710090f, 0.09568232f, 0.71481854f, -0.13572675f, -0.21942417f, 0.13992739f, -0.08573614f, 
    0.08110857f, 0.27652508f, -0.28610745f, 0.55557597f, -0.16903950f, 0.26997143f, -0.11339398f, 0.15178208f, 
    0.00334130f, 0.06025348f, 0.39365715f, -0.05388243f, -0.00976672f, 0.03700170f, 0.11868905f, 0.35306430f, 
    0.10077417f, 0.08419491f, 0.01644531f, -0.07858044f, 0.16944514f, 0.12448042f, 0.12013976f, -0.20309219f, 
    -0.05350552f, -0.29400975f, -0.02426324f, -0.15237471f, 0.01122404f, 0.77328646f, 0.03627588f, 0.76611525f, 
    0.16899785f, 0.41257396f, -0.27918109f, -0.17811669f, 0.03653322f, 0.27209693f, -0.29092398f, 0.11809009f, 
    0.03175698f, -0.08118601f, -0.42373514f, 0.20724244f, 0.39633250f, -0.30669776f, 0.32550630f, 0.16074580f, 
    -0.06884691f, 0.49437299f, -0.01273371f, -0.04725624f, 0.23851450f, -0.13998632f, -0.01000567f, 0.29183534f, 
    0.03327532f, -0.35591775f, -0.05011693f, -0.04767587f, 0.30522004f, 0.14395325f, 0.08424900f, 0.37979740f, 
    0.09771135f, 0.30898574f, -0.21101487f, 0.43351269f, -0.11670198f, -0.09782759f, 0.07831108f, 0.26424569f, 
    -0.14051065f, 0.10358293f, 0.56708050f, 0.01784967f, 0.16643882f, -0.20151965f, 0.10805361f, 0.01371189f, 
    0.01029560f, -0.35996971f, -0.10293190f, -0.07958871f, 0.06338888f, -0.28233099f, 0.02562077f, -0.08265563f, 
    -0.03314053f, -0.14351442f, 0.18937510f, -0.23089534f, 0.16890319f, 0.70453370f, -0.07958114f, 0.66185319f, 
    -0.21935941f, -0.00204325f, -0.14372198f, -0.50721276f, -0.28545448f, -0.02994085f, 0.04991520f, 0.04888336f, 
    -0.03111024f, -0.02690654f, -0.15159555f, 0.00346816f, -0.00187484f, 0.01842794f, 0.17741862f, 0.32444984f, 
    -0.06297645f, 0.25036156f, -0.17529766f, -0.06964590f, 0.29896834f, -0.00495549f, -0.01143089f, 0.47050396f, 
    0.19452365f, -0.11679409f, 0.52831692f, -0.48449653f, 0.38113496f, -0.18291704f, -0.15043350f, -0.06411935f, 
    0.08479914f, -0.14881682f, -0.19329138f, -0.43077964f, 0.04958914f, -0.03986317f, 0.05990762f, 0.48930165f, 
    -0.18618380f, 0.05458684f, 0.64747626f, -0.03662283f, -0.05592970f, 0.21199135f, 0.00378596f, -0.05566100f, 
    0.12675625f, 0.17758451f, 0.10565600f, -0.09255941f, -0.16722722f, 0.07972258f, 0.04853006f, 0.31748220f, 
    0.08446638f, 0.26446214f, -0.17190890f, 0.18576808f, 0.06445092f, 0.09482070f, 0.03773375f, 0.28386232f, 
    -0.04283774f, 0.32517946f, -0.36178616f, -0.18908669f, -0.01128125f, 0.19544123f, 0.23138164f, 0.09031188f, 
    -0.11494568f, -0.01579934f, 0.46853819f, 0.04355190f, -0.29262665f, 0.26352000f, 0.00347751f, -0.23930508f, 
    -0.26479796f, -0.23046014f, 0.19337934f, -0.06583075f, 0.02016512f, 0.14633135f, 0.06234032f, -0.12533762f, 
    -0.14870173f, 0.33197072f, 0.04424531f, -0.02673025f, -0.23922265f, 0.10946673f, -0.00271720f, -0.33855808f, 
    0.11555016f, 0.15754846f, 0.07419351f, -0.21201296f, -0.13627303f, 0.23374651f, 0.06818659f, -0.03619903f, 
    0.26995081f, -0.01956126f, 0.02363302f, 0.03744164f, 0.09929604f, 0.09434938f, 0.17906862f, 0.26409814f, 
    0.00881760f, 0.19850065f, -0.02628812f, 0.06119278f, -0.06214014f, 0.14307089f, -0.08660735f, 0.03617137f, 
    -0.19281903f, 0.01741132f, 0.14341179f, 0.26216015f, 0.06133392f, -0.69864643f, 0.05892848f, -0.19154614f, 
    0.11675336f, 0.48132202f, 0.15222009f, 0.46431112f, 0.02601307f, 0.12732542f, -0.12108047f, -0.00784986f, 
    -0.02057587f, 0.07171549f, 0.26799417f, -0.23762250f, -0.08969790f, 0.11890118f, 0.18873107f, -0.21700898f, 
    -0.20330392f, -0.33309102f, 0.10440338f, -0.32496428f, -0.07200095f, 0.22228809f, 0.07168705f, 0.01788540f, 
    -0.16444230f, -0.66213143f, -0.34596109f, 0.54319590f, -0.74005204f, 0.30836132f, 0.11949001f, -0.50422925f, 
    0.05588533f, -0.12398278f, -0.02520099f, 0.20510519f, -0.15624298f, 0.17213498f, 0.10715728f, -0.40300703f, 
    -0.09581281f, 0.23699211f, -0.56355941f, 0.03234898f, 0.17490332f, 0.29297331f, 0.06191149f, 0.32449988f, 
    0.06351914f, -0.01696075f, -0.06847729f, 0.02752039f, 0.26280591f, 0.31098109f, -0.05880651f, -0.35173863f, 
    -0.06650329f, -0.20328400f, -0.05591556f, 0.08864414f, 0.18749224f, -0.36595890f, 0.02361709f, 0.19846745f, 
    -0.09262803f, -0.08911213f, -0.06343776f, 0.32650262f, 0.30597889f, -0.22616600f, -0.64294153f, 0.12427533f, 
    0.12147900f, 0.03516531f, -0.24372450f, -0.08842068f, -0.04440882f, 0.19681318f, -0.36559227f, -0.13727218f, 
    0.12319449f, 0.10877534f, 0.03188264f, 0.31554040f, -0.32662439f, 0.25569791f, 0.09671052f, -0.25495350f, 
    -0.09029210f, 0.65414757f, 0.38002276f, -0.10356067f, -0.28587729f, -0.02522179f, -0.09404191f, -0.30413842f, 
    -0.01601540f, -0.00242583f, -0.17034943f, -0.08792550f, -0.09529347f, -0.06657597f, 0.23020925f, -0.20128827f, 
    -0.17994942f, 0.13611530f, 0.27456528f, 0.09273791f, -0.14745930f, 0.22389463f, 0.20638210f, 0.06616525f, 
    -0.07893190f, -0.83968341f, -0.09507962f, 0.12136334f, -0.12741725f, 0.21683536f, -0.00861488f, -0.01976551f, 
    0.10771006f, -0.03212262f, 0.20427389f, 0.11037140f, 0.21205291f, -0.39409414f, -0.05392624f, -0.12756324f, 
    -0.12649354f, -0.00310825f, -0.22930852f, 0.74461895f, 0.23700468f, 0.35290337f, -0.03878133f, -0.00163098f, 
    -0.01480120f, -0.11277646f, -0.19451384f, 0.20513016f, 0.05689129f, 0.14305298f, 0.14330468f, 0.10955731f, 
    -0.14193888f, 0.12615457f, 0.35160562f, -0.00888379f, -0.00393747f, -0.12440207f, 0.06280901f, -0.21905003f, 
    -0.45390612f, -0.09867974f, 0.05710610f, -0.34319821f, -0.42591360f, 0.38086987f, 0.00729974f, 0.18100791f, 
    0.05563213f, 0.14537211f, 0.11570072f, 0.43793789f, 0.18501842f, 0.11402696f, -0.08368514f, 0.16645016f, 
    -0.02480545f, -0.07472218f, 0.76846284f, 0.09009223f, 0.22920710f, -0.12811245f, 0.17717996f, 0.12681817f, 
    -0.10718786f, -0.47337475f, -0.04107925f, -0.07039873f, 0.19165395f, -0.02592260f, -0.09368010f, 0.04469006f, 
    -0.02349276f, -0.09858511f, 0.40422314f, -0.07067221f, 0.06476841f, -0.66614234f, -0.00942782f, -0.55037683f, 
    -0.07762521f, 0.55253732f, 0.67510372f, -0.25423217f, -0.26585019f, -0.28995943f, 0.09493516f, 0.01878882f, 
    0.05732994f, -0.05895048f, -0.12183122f, -0.05350540f, 0.05943191f, 0.06717593f, -0.06651667f, -0.07665331f, 
    -0.06130369f, 0.07883740f, -0.07768821f, 0.04501550f, -0.10775664f, -0.12046146f, -0.00333802f, -0.05375944f, 
    0.08396468f, -0.02985186f, -0.04496207f, 0.04655424f, -0.12176190f, -0.00726386f, -0.04327232f, 0.03644952f, 
    -0.08870521f, 0.04889674f, -0.03766353f, -0.10125469f, -0.07307975f, 0.01690399f, -0.09509014f, -0.02611312f, 
    -0.05850939f, -0.07387237f, -0.06414784f, 0.05125143f, 0.06166434f, 0.11033979f, 0.02774264f, -0.10615186f, 
    0.07992758f, 0.10622809f, -0.08720616f, 0.00289610f, -0.01685471f, -0.03726550f, 0.12479256f, 0.08117929f, 
    -0.12740587f, -0.03168247f, -0.11104983f, -0.03485808f, 0.05173463f, -0.03913032f, -0.06345983f, 0.06953213f, 
    0.07178391f, 0.03266291f, 0.09304003f, -0.02098663f, -0.04958261f, -0.01351619f, -0.08525033f, 0.10638507f, 
    0.00771831f, -0.10857908f, -0.31114569f, 0.25054836f, -0.08175171f, -0.00552990f, -0.38006100f, -0.25198007f, 
    0.54140705f, -0.23898564f, 0.09654661f, 0.59721535f, 0.05560301f, -0.20486152f, -0.03317532f, 0.40905458f, 
    -0.00568235f, 0.51000494f, -0.16876009f, -0.31273028f, -0.07567371f, 0.24489468f, -0.13196124f, 0.44022831f, 
    0.09621125f, -0.10920687f, 0.16301218f, 0.27683684f, 0.35990170f, -0.07325075f, 0.13813992f, -0.36093333f, 
    0.08594920f, 0.27883160f, -0.48590565f, -0.00107189f, 0.16574381f, -0.04343346f, 0.05654109f, -0.05407571f, 
    0.16063277f, -0.44247875f, 0.00818567f, -0.10197602f, 0.26634672f, -0.04756818f, 0.08598892f, -0.34774134f, 
    0.18267548f, 0.14598994f, 0.42186823f, -0.08508503f, 0.29312366f, 0.01099114f, 0.05975161f, -0.54266989f, 
    -0.24338117f, -0.61546040f, -0.44279677f, 0.28752613f, -0.27236730f, -0.20890906f, 0.09032521f, 0.07493509f, 
    0.07084581f, 0.11072926f, -0.21589811f, 0.00887811f, 0.29461950f, 0.29121780f, 0.06859604f, 0.06000480f, 
    0.19058543f, 0.34559372f, 0.15724964f, -0.03809652f, 0.07042213f, -0.06184948f, -0.03711214f, -0.26370332f, 
    -0.29938126f, 0.61407173f, 0.19854453f, 0.18893661f, 0.13357124f, -0.01062433f, -0.18644637f, 0.20873982f, 
    -0.04261149f, -0.07931776f, 0.13968265f, -0.02893929f, 0.10140618f, -0.11702532f, 0.09545948f, 0.20276800f, 
    -0.05102544f, 0.01492191f, 0.28893936f, 0.00278269f, 0.14011371f, 0.35666573f, 0.09260077f, -0.08370887f, 
    0.05123251f, -0.18666981f, -0.12343867f, 0.01348539f, 0.12331346f, 0.04900530f, 0.01723984f, 0.34986919f, 
    0.45260504f, -0.31762519f, 0.09452993f, 0.15421790f, 0.11477956f, -0.14453393f, 0.03568932f, -0.26421663f, 
    -0.12646398f, 0.09486920f, 0.40064514f, 0.20956425f, -0.13978326f, -0.23606832f, -0.00072803f, -0.03246624f, 
    0.06151012f, -0.05960256f, -0.28176042f, 0.17769319f, 0.20969471f, -0.02909321f, -0.25222865f, 0.23634653f, 
    0.20911604f, 0.04766624f, -0.06674873f, 0.31038398f, -0.03891724f, -0.01158221f, -0.02484500f, 0.09801636f, 
    0.23287344f, 0.46706176f, 0.09211713f, -0.03932242f, 0.41302073f, -0.01357694f, 0.00549409f, 0.31251571f, 
    -0.00531156f, -0.21434335f, 0.24507974f, -0.14951400f, 0.25227126f, -0.03351573f, 0.08744236f, 0.03624991f, 
    0.14744179f, -0.02130759f, -0.12636124f, -0.10879718f, 0.06456424f, 0.13610397f, -0.04703226f, -0.17818889f, 
    -0.03175672f, 0.17903259f, 0.07279594f, -0.02053131f, -0.04173968f, 0.02753537f, -0.00965686f, 0.08035307f, 
    0.16792537f, 0.00881700f, 0.04893701f, 0.04530077f, -0.07697721f, 0.21669790f, -0.01454709f, -0.31680086f, 
    -0.10954972f, -0.43684271f, -0.04923959f, 0.27772546f, -0.10139861f, -0.00775934f, 0.23188470f, 0.02995363f, 
    0.10345696f, 0.08024734f, -0.01679854f, -0.06913014f, -0.16297457f, 0.01924496f, -0.06784572f, -0.08470473f, 
    -0.10539433f, -0.04671666f, -0.02064835f, -0.05708346f, -0.01840394f, -0.03957558f, -0.01428929f, 0.00294559f, 
    -0.05992218f, 0.08173110f, 0.01863813f, 0.02661486f, 0.06703217f, 0.03514585f, -0.13717549f, -0.02741128f, 
    0.11643647f, 0.02334079f, -0.09928077f, 0.04999121f, -0.08023690f, 0.06688372f, -0.02794916f, 0.04516927f, 
    -0.02294471f, -0.13631983f, -0.09062916f, 0.00065398f, -0.04792064f, -0.09490521f, -0.04053922f, 0.03217953f, 
    -0.16012564f, -0.03477206f, -0.09438157f, 0.08172254f, -0.03595828f, 0.03523634f, 0.04260732f, 0.02148931f, 
    -0.03968050f, -0.02220988f, -0.09179638f, 0.00183475f, -0.14009732f, 0.08645347f, 0.12359180f, 0.03151499f, 
    -0.09070920f, -0.10564213f, 0.08144745f, -0.10941584f, -0.04119607f, -0.12909402f, -0.00805573f, -0.02803023f, 
    0.05034399f, 0.04544225f, 0.34009194f, -0.09776244f, -0.01176217f, 0.12328427f, 0.16576363f, -0.07449738f, 
    0.07929013f, -0.21875110f, -0.03953021f, -0.03416272f, -0.33693185f, 0.38570210f, -0.06743152f, 0.11215554f, 
    0.31091189f, 0.59715354f, -0.05102544f, 0.08395306f, 0.18825372f, -0.26525509f, 0.05496643f, -0.26769024f, 
    0.10665695f, -0.04802199f, 0.25552309f, -0.09652773f, -0.20400453f, 0.08616457f, -0.08157734f, -0.14391132f, 
    0.22402996f, 0.03288364f, -0.76171738f, -0.03521801f, -0.01986040f, 0.19911395f, 0.16458908f, -0.09815310f, 
    -0.12530692f, -0.06966088f, 0.03232859f, -0.01711665f, -0.09759649f, 0.11549427f, 0.07001832f, -0.17439130f, 
    0.03531074f, 0.23520610f, -0.00463882f, 0.01606965f, -0.03828144f, -0.03342169f, -0.11270569f, -0.14767694f, 
    0.16516784f, 0.02213459f, -0.51764035f, 0.30939251f, 0.37047946f, 0.25108033f, 0.10425074f, 0.02940066f, 
    0.11156698f, 0.00635502f, 0.10263215f, 0.12066550f, 0.01764487f, 0.04143598f, 0.16668114f, -0.21907024f, 
    -0.14683281f, -0.12403684f, -0.06748847f, 0.19387639f, -0.26360941f, 0.17978685f, 0.09803802f, 0.23251882f, 
    0.02538132f, -0.06634686f, 0.26148728f, 0.26309058f, -0.30713525f, 0.04900535f, 0.19178283f, -0.39033613f, 
    0.11127494f, 0.12487861f, -0.01972885f, 0.32960352f, -0.10137486f, 0.36651912f, 0.17093912f, -0.08900890f, 
    0.11217032f, 0.03481945f, -0.46717486f, 0.04615699f, 0.02509033f, -0.10606332f, 0.23378505f, 0.26974067f, 
    -0.01420079f, 0.19222938f, -0.02162467f, -0.04557796f, 0.21316527f, 0.30753851f, 0.03834380f, -0.39853075f, 
    -0.15281406f, 0.12881705f, 0.27981052f, -0.17025979f, -0.00523985f, 0.45576981f, 0.00705714f, -0.24058858f, 
    0.17990203f, -0.17341323f, -0.92514306f, 0.21272261f, 0.25037244f, 0.42523044f, -0.04589743f, -0.07807659f, 
    0.09925789f, -0.11125301f, 0.06902388f, -0.13601553f, 0.07982069f, -0.04148136f, 0.04872050f, -0.10231056f, 
    -0.03573230f, -0.07408462f, 0.02120008f, -0.09460200f, 0.00203695f, -0.14983226f, 0.02347727f, 0.09651646f, 
    -0.02751053f, 0.04684456f, 0.06050012f, -0.06286001f, -0.05347428f, -0.09754902f, -0.06812740f, -0.07247800f, 
    -0.01437633f, 0.07297455f, -0.08259944f, 0.04157687f, -0.15825012f, -0.03882330f, -0.09957680f, -0.05613284f, 
    -0.10559662f, 0.09122926f, 0.01831402f, -0.01340428f, -0.14895818f, -0.14189069f, 0.05612380f, -0.06025513f, 
    -0.15276349f, -0.01037410f, -0.06854790f, 0.01118319f, 0.09292721f, -0.07465424f, -0.03491096f, -0.05020791f, 
    0.05260367f, -0.11555604f, -0.14403160f, 0.09619818f, -0.13375467f, -0.06644151f, -0.05615339f, -0.06714782f, 
    -0.03408778f, 0.01233935f, -0.09718190f, -0.07654925f, -0.04039088f, 0.02103525f, 0.05554926f, 0.06722961f, 
    0.03245722f, 0.09778140f, -0.09368717f, 0.00178185f, 0.05183471f, 0.23202229f, -0.18983440f, 0.23465160f, 
    0.15233813f, 0.14973961f, 0.32564592f, 0.19667245f, 0.38086388f, -0.10279922f, 0.02128187f, -0.37950119f, 
    -0.06020202f, 0.00347190f, -0.10964411f, 0.25991929f, 0.11114440f, 0.37921804f, -0.12903088f, 0.15771939f, 
    -0.06966695f, -0.07342030f, 0.01457475f, 0.08029010f, 0.22700593f, -0.15426153f, 0.05822774f, -0.05887087f, 
    -0.15064007f, 0.34616408f, 0.45437607f, 0.04516052f, 0.26931107f, 0.26838845f, 0.10746682f, -0.13144954f, 
    0.15894085f, -0.04057911f, -0.00924115f, -0.06737813f, 0.19826134f, -0.01027433f, 0.10299601f, 0.29745874f, 
    0.33576202f, 0.08024912f, 0.01349304f, 0.15211457f, 0.24970733f, -0.24912779f, 0.05616686f, -0.04389463f, 
    -0.16198696f, 0.32288069f, 0.82500619f, -0.01071433f, 0.04015571f, -0.31414366f, -0.07540570f, -0.10806741f, 
    -0.01135863f, 0.01825507f, -0.34289736f, 0.06819273f, 0.21992303f, -0.07001202f, -0.35909092f, 0.19520240f, 
    0.33496174f, 0.16800322f, 0.06415045f, 0.58695346f, 0.10724297f, -0.10761172f, 0.06742637f, -0.54526407f, 
    0.16487965f, 0.36270812f, -0.14104481f, -0.09709479f, 0.10297500f, 0.18087772f, -0.13860072f, 0.20919536f, 
    0.09962519f, 0.22411311f, -0.10790518f, 0.12224348f, 0.30229196f, -0.05056190f, 0.12558293f, -0.24724126f, 
    -0.15977903f, 0.18194233f, 0.30894294f, -0.02314712f, 0.09915870f, -0.15983526f, 0.10066290f, -0.26709846f, 
    -0.14863084f, 0.32896554f, 0.10410273f, -0.02796146f, 0.05569003f, -0.31574073f, 0.05545673f, 0.19520877f, 
    0.18551531f, 0.00466013f, 0.27954996f, 0.03689318f, 0.18021324f, 0.18968172f, -0.10448026f, 0.17229383f, 
    -0.11821511f, -0.48444054f, 0.33284420f, 0.37085462f, -0.05443748f, -0.09421945f, 0.01573072f, -0.03045811f, 
    -0.02127159f, 0.09244104f, -0.25508177f, 0.05350285f, 0.11512721f, 0.10005801f, -0.15983407f, 0.08962242f, 
    0.26008543f, 0.40704450f, 0.19827200f, 0.07961956f, 0.19559689f, -0.08263914f, -0.04494829f, 0.18343204f, 
    -0.09772215f, 0.41424644f, 0.30624706f, -0.23380254f, 0.06150073f, -0.35081249f, -0.10229377f, 0.48065045f, 
    0.10574096f, -0.14044967f, 0.11352658f, -0.22656135f, 0.20938416f, -0.03987484f, 0.03675891f, 0.25338608f, 
    -0.18416160f, -0.09886935f, 0.23727106f, -0.00249032f, -0.05716605f, 0.03839458f, -0.11226388f, 0.04187756f, 
    0.02753990f, 0.23230398f, 0.05793141f, 0.07069728f, 0.11248137f, 0.16097969f, 0.00769354f, 0.50438297f, 
    0.17589191f, -0.05291327f, 0.09623805f, 0.15354112f, -0.04290153f, -0.37373403f, 0.00462570f, 0.30925995f, 
    0.02274883f, -1.03870869f, 0.16924453f, -0.00840576f, -0.07743694f, 0.08242794f, 0.21614765f, -0.03307941f, 
    -0.05544418f, -0.00160471f, -0.28268698f, 0.10947189f, 0.22949368f, -0.06674062f, 0.25478828f, 0.30779418f, 
    0.01676584f, 0.20226194f, 0.07334225f, -0.36018103f, 0.16628318f, -0.29182228f, -0.03819311f, 0.45419273f, 
    -0.14601840f, -0.60548300f, 0.08914744f, 0.20718028f, 0.35820583f, -0.03152899f, 0.17073803f, 0.35495368f, 
    -0.01593062f, -0.00500181f, 0.08570813f, 0.12058736f, 0.13390058f, 0.06973371f, -0.11768815f, 0.37376723f, 
    0.02027760f, 0.00952973f, 0.49550542f, -0.08487857f, 0.17734405f, -0.15196206f, -0.08096749f, 0.28295785f, 
    0.09398707f, 0.11400232f, -0.02050802f, 0.04450558f, 0.10658216f, 0.01040795f, -0.08814314f, 0.24811110f, 
    -0.03337826f, -0.14093600f, 0.08534187f, -0.04621984f, 0.02511343f, 0.15184018f, -0.04126154f, 0.27122456f, 
    -0.09375501f, -0.11649568f, 0.26214620f, -0.58435297f, -0.21552613f, 0.06659448f, 0.07984907f, 0.05587979f, 
    0.03469236f, -0.03271405f, -0.08754893f, 0.20238388f, 0.28213394f, -0.02592923f, -0.03397009f, 0.13374220f, 
    0.25270605f, -0.09945180f, 0.13207188f, -0.08722813f, 0.11308952f, -0.30214402f, -0.01345055f, 0.27123472f, 
    0.15179408f, -0.31190741f, -0.01977230f, -0.19768304f, 0.20191608f, -0.29203758f, 0.09073547f, 0.51222509f, 
    -0.08996210f, 0.07355458f, 0.27281240f, 0.04758282f, 0.14076124f, -0.00538147f, -0.11030063f, 0.04327339f, 
    0.18981342f, -0.32923704f, -0.01157162f, 0.08511560f, -0.03631883f, -0.23966897f, 0.07045080f, 0.06849603f, 
    -0.10000239f, 0.06589107f, -0.12219982f, -0.03501435f, -0.00986363f, 0.06462098f, -0.08570330f, 0.05651211f, 
    0.05979631f, 0.04721663f, 0.07146344f, 0.02563734f, -0.11360043f, -0.17573225f, -0.04374373f, -0.21996029f, 
    -0.03679635f, -0.31084010f, 0.06781060f, -0.24736899f, -0.23402721f, -0.05894811f, 0.13936314f, 0.07548056f, 
    0.04885839f, -0.07823727f, 0.04289127f, 0.02094548f, 0.16430143f, 0.12248368f, 0.10511678f, 0.00505026f, 
    -0.31006062f, -0.10854644f, 0.04675477f, -0.28040484f, -0.12031294f, 0.05485641f, 0.12565298f, -0.25341910f, 
    -0.04349856f, -0.44943836f, 0.10334760f, 0.64927173f, -0.27398452f, -0.10406437f, 0.14918278f, -0.04151530f, 
    0.06784724f, -0.11392574f, 0.11872677f, 0.22931433f, -0.16231902f, 0.17017142f, 0.08841848f, 0.06888571f, 
    0.10715235f, -0.04590571f, 0.45086515f, -0.07713524f, -0.04754242f, -0.12175967f, -0.03186205f, 0.07008793f, 
    -0.00424279f, 0.11206913f, -0.07353203f, -0.10960461f, 0.00739607f, 0.10689520f, -0.02068812f, 0.11849321f, 
    0.09598631f, -0.00027241f, 0.01255344f, 0.45791259f, 0.07657019f, -0.02959357f, 0.11323069f, -0.38037995f, 
    0.01432886f, 0.40334150f, 0.11789671f, 0.33084536f, -0.10119863f, 0.16041197f, 0.03702858f, 0.00095989f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.14242780f, -0.12685004f, 0.32044989f, 0.27049750f, -0.03378980f, 0.26165935f, -0.14890170f, -0.10075141f, 
    -0.10838666f, -0.16007173f, 0.49625945f, -0.06208700f, 0.31987494f, -0.00292035f, -0.10419152f, 0.15718254f, 
    -0.13779676f, 0.08858785f, -0.09107511f, -0.13306871f, 0.15130955f, -0.03724520f, 0.36839876f, -0.10345663f, 
    0.19241925f, -0.14019321f, 0.05930877f, -0.08018309f, 0.44709823f, 0.01407457f, 0.07326476f, 0.28743196f, 
    0.08994879f, -0.11538764f, -0.10435899f, 0.37604609f, -0.24174285f, -0.11820485f, -0.05438729f, 0.02458942f, 
    0.10494994f, 0.06205792f, -0.19529784f, -0.02775246f, -0.11775792f, 0.30859178f, 0.16314100f, 0.15591289f, 
    0.41573429f, 0.04970745f, 0.03842402f, 0.12063371f, 0.07527472f, 0.19183901f, 0.09543978f, 0.10681917f, 
    0.41619882f, -0.01244774f, -0.22605012f, -0.03951200f, 0.29682425f, 0.03692349f, 0.08543198f, 0.23212826f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.10230472f, -0.10908529f, -0.15746777f, -0.16523662f, -0.01978919f, -0.14022852f, -0.08916062f, -0.00680529f, 
    0.16698539f, 0.03009000f, 0.17119731f, -0.07687656f, 0.35542789f, 0.07706400f, -0.06890754f, -0.28652427f, 
    -0.18190946f, -0.16797253f, -0.03213595f, 0.05353913f, -0.19605698f, 0.39897832f, 0.14908382f, 0.23747987f, 
    -0.01731345f, -0.05548459f, 0.07474831f, -0.33575997f, 0.28145927f, -0.10299476f, -0.18746142f, 0.10899547f, 
    -0.01883250f, -0.36278337f, 0.00244585f, 0.03057535f, -1.28846645f, -0.13618048f, -0.06041548f, -0.00447618f, 
    0.08127511f, -0.29754731f, -0.16972782f, 0.29440159f, 0.01208024f, 0.09039403f, 0.07200543f, -0.41075888f, 
    0.23779279f, -0.13631411f, 0.08921730f, 0.09843738f, 0.25395191f, 0.13188155f, 0.00364911f, -0.03917216f, 
    0.05964946f, 0.06811935f, 0.01383446f, 0.11615974f, 0.11939714f, 0.12154729f, -0.04267438f, 0.06565349f, 
    -0.03835702f, 0.05360022f, 0.07397385f, -0.03523180f, 0.00962555f, -0.14481434f, 0.02052706f, 0.18576944f, 
    -0.03575283f, -0.02424860f, -0.07960432f, 0.08732562f, 0.22883797f, -0.78213984f, 0.11075086f, 0.04011384f, 
    -0.05253528f, -0.28715995f, 0.00632597f, -0.00790240f, -0.04834943f, -0.68860376f, 0.16484785f, 0.15979113f, 
    0.11469207f, 0.08717553f, 0.07599140f, 0.06845734f, -0.16028991f, -0.00534111f, 0.23795646f, -0.06966664f, 
    -0.39302167f, 0.26435801f, -0.04757175f, -0.17161019f, -0.01313938f, 0.06158482f, -0.32689559f, -0.06306432f, 
    -0.11780968f, -0.05039994f, 0.02133854f, 0.38450068f, 0.26711088f, 0.17699963f, 0.03425952f, 0.30311930f, 
    -0.05923788f, 0.27435121f, -0.03064671f, -0.32869729f, 0.01502411f, -0.27745304f, -0.07090053f, -0.44565189f, 
    0.09029998f, -0.09854569f, 0.09902657f, 0.05235210f, 0.01034616f, 0.27355412f, -0.19401816f, 0.06047171f, 
    -0.04155032f, 0.03396023f, 0.04368666f, 0.10634004f, -0.07577293f, 0.14079957f, -0.02338941f, 0.25135159f, 
    -0.28056416f, -0.01518067f, -0.22952989f, -1.06410658f, 0.23712820f, 0.47233155f, 0.08573921f, 0.18922728f, 
    -0.09163162f, 0.13949335f, -0.11466252f, 0.05970828f, 0.09409758f, 0.67118740f, 0.16369922f, 0.18284787f, 
    0.05245149f, -0.15238348f, 0.09179543f, -0.19465269f, 0.16190469f, 0.05288339f, 0.13891806f, -0.25986281f, 
    -0.00189978f, -0.79630512f, 0.03438623f, 0.01075153f, -0.29633406f, 0.07138053f, -0.01790432f, -0.02292079f, 
    -0.01094476f, 0.11071198f, 0.12832281f, 0.27807802f, -0.71118420f, -0.49086651f, 0.35458550f, 0.43093261f, 
    0.14464542f, -0.35226175f, 0.01709341f, -0.99984336f, -0.28491834f, -0.76147133f, -0.07489139f, 0.13481949f, 
    0.25486797f, 0.11347433f, -0.18353765f, -0.80964583f, -0.81493324f, -0.58506632f, -0.15147913f, -0.02146165f, 
    -0.03122311f, -0.02416827f, -0.28955424f, 0.14989719f, 0.00233112f, 0.30415419f, -0.04466634f, -0.68860197f, 
    -0.41278774f, 0.02516012f, 0.22033402f, 0.12019201f, -0.11340930f, 0.14874144f, -0.12118805f, -0.03843015f, 
    -0.11007583f, -0.86736012f, -0.12212384f, -0.00875309f, 0.01312313f, 0.02025013f, -0.51994842f, -0.29310822f, 
    -0.69159770f, -0.06416012f, -0.09210180f, -0.10744233f, -0.55225760f, 0.02213962f, -0.49580821f, -0.34785035f, 
    0.16749766f, 0.02251332f, 0.04841048f, -0.10476333f, 0.34440780f, -0.12659487f, 0.17292655f, -0.07771198f, 
    0.01037390f, 0.25275844f, 0.15700501f, 0.04239241f, 0.00108705f, 0.12052891f, -0.51995713f, -0.48263061f, 
    0.05606403f, -0.57496464f, -0.08480139f, 0.32739750f, -0.20865153f, 0.16785349f, 0.01751092f, -0.01604587f, 
    -0.00960283f, -0.06354318f, -0.53550512f, 0.10296512f, 0.11430427f, 0.18795386f, 0.22770444f, 0.03272839f, 
    -0.10599093f, -0.04573577f, 0.26044306f, 0.09469406f, -0.11244346f, 0.14787735f, 0.07329846f, -0.15437910f, 
    -0.10873221f, -0.10547825f, 0.25746650f, -0.33987221f, 0.00650248f, -0.08321216f, -0.01135568f, 0.08132778f, 
    -0.07602807f, 0.07358826f, -0.04656584f, 0.03371742f, -0.08688372f, -0.63179171f, 0.23485717f, -0.23816819f, 
    0.09598264f, -0.07739388f, -0.03664429f, -0.14766440f, 0.02320086f, 0.01364686f, -0.39390048f, 0.02667334f, 
    0.28787690f, 0.05943231f, -0.10956419f, 0.24333858f, -0.21312970f, -0.03816342f, 0.00024103f, 0.07174383f, 
    0.00249304f, -0.11394011f, -0.10081424f, -0.30880749f, -0.30405587f, -0.06405583f, 0.11041003f, 0.11341611f, 
    0.10189031f, 0.18299063f, 0.05319813f, 0.12964042f, 0.04887456f, 0.11375207f, 0.08270141f, -0.00491786f, 
    -0.06520496f, -0.04454575f, 0.04067809f, -0.01643616f, -0.14790209f, -0.00930456f, 0.13116071f, 0.06582976f, 
    -0.03750919f, -0.12400007f, 0.06291065f, 0.01184878f, 0.04430263f, -0.16015376f, 0.05884347f, -0.01712724f, 
    0.16975108f, -0.03791191f, -0.30969912f, 0.30496815f, -0.16773081f, -0.34536988f, -0.10618298f, 0.04541154f, 
    -0.03757067f, 0.26329827f, -0.12629707f, -0.14896041f, 0.35233939f, -0.21980311f, 0.25510311f, -0.11363102f, 
    0.20359325f, 0.05955564f, 0.03207333f, -0.11445028f, 0.02089285f, -0.00157915f, -0.04827379f, 0.12479867f, 
    -0.37203750f, -0.15168932f, -0.10577743f, 0.16847891f, 0.39488846f, -0.02651010f, -0.47128823f, 0.08967919f, 
    -0.06148203f, 0.06972314f, 0.09821031f, 0.03376602f, 0.18533318f, -0.11282307f, -0.29021972f, 0.29552335f, 
    -0.41779861f, 0.11847026f, -0.10326228f, 0.23448953f, 0.22342770f, 0.03612360f, 0.06144942f, 0.08039399f, 
    -0.27140027f, -0.00981427f, -0.00325734f, -0.02319713f, 0.18732889f, 0.22417854f, 0.12265595f, -0.15575287f, 
    0.05843827f, -0.09806749f, 0.04111680f, 0.20780183f, 0.07504962f, 0.21983176f, 0.02899867f, 0.11069971f, 
    -0.16495343f, -0.04899104f, -0.32885674f, -0.22069660f, -0.31819677f, -0.22269069f, 0.06533131f, 0.08082124f, 
    -0.04968198f, 0.15308474f, -0.09783355f, -0.08540171f, -0.42899129f, -0.50209516f, 0.13077320f, -0.39458773f, 
    0.22966869f, 0.00982121f, -1.28862715f, 0.17451882f, -0.31010032f, 0.09871782f, 0.19227527f, 0.07778706f, 
    -0.21260993f, -0.39113784f, -0.04383253f, 0.20389792f, -0.73061478f, 0.06862781f, -0.03949330f, 0.00442278f, 
    0.11909305f, 0.01002567f, 0.22346503f, -0.05801506f, -0.04235161f, -0.13056095f, -0.00023717f, 0.02821420f, 
    0.02762397f, 0.05077549f, 0.07940994f, 0.36436385f, -0.19330332f, -0.00763240f, -0.11678402f, -0.24648599f, 
    0.07230583f, 0.00054233f, 0.01089060f, 0.02553109f, 0.06324018f, 0.08040106f, 0.10272171f, -0.13800679f, 
    0.06285528f, -0.08790626f, -0.39312091f, -0.28942591f, -0.04904013f, -0.15825683f, -0.05318419f, -0.17534214f, 
    0.13821518f, 0.10474221f, -0.26255390f, 0.22169961f, -0.14737707f, -0.08846887f, -0.04607000f, -0.39445564f, 
    0.10091493f, 0.23282021f, 0.02622427f, -0.02158525f, -0.25824085f, -0.51431638f, -0.34762311f, 0.15601629f, 
    -0.18208626f, -0.13200969f, 0.11463809f, -0.36556366f, -0.29049668f, 0.08036587f, -0.25679830f, 0.09886946f, 
    0.08665714f, 0.25644264f, -0.01816402f, -0.42687145f, 0.24442858f, -0.00324299f, -0.05271668f, -0.11737748f, 
    0.04486851f, 0.25728473f, -0.70005006f, 0.07531314f, 0.21901788f, -0.10545428f, -0.18959399f, -0.65113473f, 
    -0.88057208f, -0.15262371f, -0.01021841f, -0.22305296f, 0.25785756f, 0.17392601f, 0.00912937f, -0.48798579f, 
    -0.79199320f, -0.10636914f, 0.35492474f, 0.28570274f, 0.11332079f, 0.22615728f, 0.15550941f, 0.05193699f, 
    -0.00011824f, 0.08847909f, 0.24286999f, -0.77976918f, -0.04149729f, -0.67582792f, 0.11531647f, -0.15341462f, 
    0.35289371f, -0.07768870f, -0.43115923f, -0.16357732f, -0.16304058f, 0.03158019f, -0.13554762f, 0.27685425f, 
    0.15518902f, -0.28435817f, 0.00605428f, 0.06505768f, 0.24823789f, 0.00287752f, -0.17635442f, 0.18494508f, 
    0.07102266f, -0.05371943f, 0.37486807f, 0.19740348f, -0.04826594f, -0.07621504f, 0.00804011f, 0.20834026f, 
    0.04547317f, -0.15677541f, -0.13839917f, 0.02648831f, -0.55975366f, 0.07007637f, -0.09407607f, -0.01408635f, 
    0.01157418f, 0.31976452f, 0.02881651f, -0.95798588f, 0.18153839f, 0.25239137f, -0.01000934f, -0.49920619f, 
    -0.09336423f, -0.14858338f, -0.04108678f, -0.16527234f, 0.14050134f, 0.02058723f, -0.03997961f, -0.12418156f, 
    -0.64066702f, 0.01289564f, 0.17888607f, 0.04895640f, 0.09289755f, -0.25344086f, -0.32248706f, -0.54560399f, 
    0.00423478f, 0.00352175f, 0.04508167f, -0.09023764f, 0.02988199f, -0.13374147f, 0.07796267f, 0.03832018f, 
    0.09869687f, 0.02300900f, -0.07977232f, 0.23353527f, -0.06237869f, -0.21691085f, -0.01554632f, -0.20575833f, 
    -0.07514533f, 0.26432070f, 0.03049921f, -0.07357236f, -0.59608942f, 0.19167092f, -0.04189262f, -0.07486666f, 
    0.15584725f, -0.11614621f, 0.15794469f, 0.14873004f, 0.05651912f, 0.08081533f, -0.09486030f, 0.07253218f, 
    0.13259183f, -0.19176432f, -0.00447862f, -0.10311935f, -0.15355907f, -0.13293397f, -0.00939691f, 0.09501833f, 
    0.00712661f, -0.57875949f, 0.02700463f, -0.44708979f, -0.24246117f, -0.45206666f, 0.16205072f, 0.11767921f, 
    0.24633704f, 0.21778253f, 0.08097102f, 0.31906086f, 0.15606028f, 0.08016172f, -0.12419714f, -0.05994681f, 
    -0.23002492f, -0.06955893f, 0.17519768f, 0.23621091f, 0.16064665f, -0.35528243f, -0.12072950f, -0.10265480f, 
    0.10246919f, 0.07835563f, 0.08038758f, 0.04076486f, 0.02443280f, 0.22130755f, -0.03684540f, -0.08011588f, 
    -0.45820856f, -0.05971357f, 0.24854168f, 0.04765905f, -0.06108179f, 0.30467799f, -0.10634308f, 0.04456770f, 
    0.05822765f, -0.95872432f, 0.07076017f, -0.10689848f, 0.16479158f, -0.14973164f, -0.07683745f, 0.00466322f, 
    -0.32798862f, -0.06517268f, -0.76260811f, -0.09560246f, 0.21435726f, -0.05338822f, 0.23592335f, -0.17535411f, 
    0.23178011f, 0.08448172f, -0.12524240f, 0.11375067f, 0.21746063f, -0.09051594f, 0.06357606f, -0.03414679f, 
    -0.08086615f, 0.19541773f, -0.30768707f, -0.18663295f, -0.65301305f, 0.09943397f, 0.23081735f, -0.47671387f, 
    -0.03425580f, -1.10303271f, 0.03629278f, -0.57022160f, -0.38620210f, -0.01932636f, -0.10930242f, 0.15217288f, 
    0.14558454f, -0.10148907f, -0.43546826f, -0.03813878f, 0.03165942f, -0.20371459f, -0.00975029f, 0.10528737f, 
    -0.10335741f, -0.05020562f, -0.15344095f, 0.06919561f, -0.10648686f, 0.07154772f, -0.04602524f, 0.41988456f, 
    -0.10203134f, 0.07340049f, 0.10622478f, -0.41077647f, -0.81335133f, -0.00531811f, 0.06625374f, 0.10997600f, 
    -0.06909385f, -0.20788449f, 0.05922891f, -0.10606652f, 0.35203138f, -1.24188483f, -0.38977513f, 0.19937496f, 
    0.02043935f, -0.14573239f, -0.01432657f, 0.31142119f, -0.20349652f, -0.10126717f, 0.03447706f, -0.53674090f, 
    -0.07077213f, -0.04415978f, -0.09808308f, -0.09466156f, -0.07263352f, 0.05809708f, 0.23815076f, -0.04156997f, 
    -0.05147975f, -0.24327762f, 0.23243447f, 0.31086335f, 0.35621774f, -0.03327097f, -0.49539027f, -0.97678572f, 
    -0.16426758f, -0.22534426f, 0.10878967f, 0.15938638f, -0.34168637f, 0.05064335f, -0.05584810f, 0.12362207f, 
    0.18711820f, 0.03283967f, -0.27259862f, 0.08746640f, -0.57569605f, -0.06211838f, -0.23179080f, -0.13562503f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.06172973f, 0.01072956f, -0.14244664f, -0.26862898f, 0.20241150f, -0.08020224f, -0.12506174f, -0.41271889f, 
    -0.20727649f, -0.12548159f, 0.28079632f, -0.18380146f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
