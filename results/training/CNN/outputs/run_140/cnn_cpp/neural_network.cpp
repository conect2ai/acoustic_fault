#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.30257586f, 0.27856383f, -0.29756632f, 0.22826126f, 0.66755164f, 0.23139466f, 0.38763297f, 0.56757677f, 
    0.32895538f, 0.35712111f, -0.18524849f, -0.09241726f, 0.04742084f, -0.18560344f, 0.05070114f, -0.09703530f, 
    0.00843590f, -0.01552880f, 0.00383289f, -0.16706564f, 0.27457052f, -0.15275933f, -0.14433733f, -0.21485354f, 
    -0.14539103f, -0.21272297f, -0.40575761f, -0.09135861f, 0.45191419f, 0.29247534f, -0.64068484f, -0.33323655f, 
    -0.06835356f, -0.19535223f, -0.00391651f, -0.25075909f, 0.21643779f, -0.12897560f, -0.18144576f, -0.00061131f, 
    -0.01612759f, -0.02054004f, 0.30200893f, -0.25535384f, 0.07076230f, 0.14600937f, 0.05735345f, 0.25162733f, 
    -0.09034749f, -0.25588381f, 0.40849522f, 0.63730156f, 0.53565413f, 0.87128854f, 0.42361277f, -0.16141689f, 
    0.04544295f, -0.37275332f, 0.23503745f, 0.00418168f, 0.07900818f, -0.08734240f, 0.16739026f, 0.03000573f, 
    -0.26932421f, -0.01116800f, 0.15484284f, 0.15941177f, -0.25359574f, 0.01492056f, -0.22024283f, -0.02442986f, 
    -0.14911166f, -0.02753242f, -0.11435508f, -0.16205631f, -0.70816427f, -0.36889172f, -0.33214641f, -0.28501129f, 
    -0.30634248f, -0.79088432f, -0.25740439f, 0.22260413f, -0.24720722f, 0.11545770f, -0.01758356f, 0.15289746f, 
    0.12807898f, -0.14991298f, 0.13495398f, 0.05495627f, 0.08273772f, 0.00052477f, 0.12700501f, -0.14114815f, 
    -0.20515199f, 0.20900950f, -0.11432315f, 0.08706829f, 0.87697667f, -0.23593609f, -0.44870386f, 0.33782259f, 
    0.24464773f, -0.24605678f, -0.08660281f, -0.21905561f, -0.10873997f, -0.01074245f, -0.50265646f, -0.03083668f, 
    -0.01231422f, 0.14667211f, -0.01077881f, -0.31866404f, -0.14876340f, -0.29876649f, -0.12971243f, -0.19254588f, 
    -0.20355414f, 0.17038114f, 0.13611168f, -0.17142339f, -0.21195880f, -0.50694168f, 0.23249255f, -0.07395053f, 
    -0.06271479f, -0.13114616f, -0.13304375f, -0.12606499f, 0.25868309f, -0.05144848f, 0.07522399f, -0.29866922f, 
    0.39761111f, -0.03601776f, 0.02872911f, -0.36202672f, 0.07343552f, 0.20547526f, -0.28534085f, -0.47360811f, 
    -0.55137229f, -0.12456711f, -0.07708811f, 0.12443725f, 0.00197091f, -0.16945231f, -0.05817082f, 0.41670734f, 
    -0.34121743f, 0.09841383f, 0.39585537f, 0.76168442f, 0.00239952f, -0.79000384f, -0.04478472f, -0.15832917f, 
    -0.03424257f, 0.28895420f, 0.02773589f, 0.15319730f, -0.10090301f, -0.09725924f, 0.00651755f, 0.07798626f, 
    -0.01491935f, 0.00789550f, 0.18460256f, -0.14557274f, -0.18576361f, -0.24186005f, -0.09922543f, 0.53723228f, 
    0.53368789f, -0.32108760f, -0.44152758f, -0.70261204f, -0.18180327f, -0.41652548f, -0.34279835f, -0.30980924f, 
    0.13753712f, 0.51789832f, 0.10032985f, -0.02122132f, -0.04322261f, -0.10056859f, -0.02508260f, 0.05823797f, 
    -0.00495497f, -0.04228976f, 0.06972571f, -0.00280498f, 0.17976759f, 0.11779867f, 0.07367535f, -0.23031068f, 
    -0.20235023f, 0.74799782f, 0.57162988f, 0.37818116f, -0.02929554f, -0.64008367f, 0.42238602f, 0.01497728f, 
    -0.26970962f, -0.09731179f, -0.11008824f, 0.07205458f, 0.06808057f, 0.13249405f, 0.18582034f, -0.06642850f, 
    0.00097410f, 0.23821208f, 0.05328797f, -0.09857833f, 0.02369968f, 0.08508056f, 0.11265868f, 0.26664472f, 
    -0.09592167f, 0.11416361f, -0.30894539f, -0.24051920f, 0.25938299f, 0.61499256f, -0.40211320f, -0.32937667f, 
    -0.43329391f, -0.59076953f, 0.27460563f, 0.28385627f, 0.42880619f, 0.00981444f, -0.00256798f, -0.10607108f, 
    0.04036917f, 0.04917822f, 0.20185688f, 0.20326065f, -0.01503354f, 0.14181811f, -0.02147013f, -0.29817957f, 
    -0.05261033f, 0.03921644f, -0.56458718f, -0.43427858f, -0.12444644f, -0.51392686f, -0.52335036f, -0.40053698f, 
    -0.23598237f, 0.06329817f, 0.00287845f, 0.12057062f, -0.07647189f, 0.02660987f, -0.08596116f, 0.03488454f, 
    -0.03493668f, 0.21086055f, 0.13510606f, 0.05156949f, 0.10967024f, -0.14117955f, 0.27824312f, 0.16011576f, 
    0.12681375f, 0.11064391f, 0.29029942f, -0.23862265f, 0.57256496f, -0.09825198f, -0.38885599f, 0.73883837f, 
    -0.04227372f, -0.45768151f, -0.16103460f, -0.68802142f, -0.25451201f, -0.03127297f, 0.24981110f, 0.23435102f, 
    0.16712965f, 0.12202344f, 0.25815827f, 0.05217740f, 0.01298095f, 0.04261248f, 0.09672114f, -0.10531108f, 
    -0.03744115f, 0.03499481f, 0.27689466f, 0.10503136f, -0.84045058f, -0.48071760f, -0.27540889f, -0.10014376f, 
    -0.30991197f, 0.40582263f, 0.91135681f, 0.19388519f, -0.00322238f, 0.23251256f, -0.22936857f, -0.12575924f, 
    0.10564701f, -0.19286858f, 0.18415661f, -0.08376391f, -0.06172263f, -0.02008267f, 0.02829912f, -0.13731436f, 
    -0.04200410f, -0.06842926f, -0.02558088f, 0.00816277f, -0.01931741f, 0.33572659f, -0.83909351f, -0.41301939f, 
    0.44925943f, -0.27605906f, -0.56272739f, 0.49230105f, 0.17148934f, -0.29337907f, -0.11718150f, 0.16859883f, 
    0.25499028f, -0.12226181f, -0.06965454f, 0.09473238f, 0.03950135f, -0.00062848f, -0.32908583f, -0.09621966f, 
    -0.09359205f, 0.10433258f, -0.01866721f, 0.00795951f, 0.24500175f, 0.10297032f, 0.36994031f, 0.12206014f, 
    0.46655154f, 0.54800344f, 0.64896959f, 0.26612335f, 0.05864248f, -0.01779195f, 0.01710808f, -0.45456010f, 
    0.01584177f, -0.16172145f, -0.28635949f, 0.01625487f, 0.06721833f, 0.10473111f, -0.16465634f, -0.00812647f, 
    -0.17312445f, 0.24446777f, 0.15292192f, 0.19366235f, 0.13195834f, 0.09808274f, 0.17246141f, -0.11380986f, 
    0.23409489f, -0.88087231f, -0.64063424f, -0.59630966f, 0.51874280f, 0.23320924f, -0.04891990f, 0.30075851f, 
    0.52273017f, 0.22436281f, -0.17583163f, 0.04688328f, -0.03190095f, -0.18813834f, 0.06889468f, 0.14405763f, 
    0.07491813f, 0.26195890f, -0.17080712f, -0.19562097f, -0.08167052f, -0.09507471f, -0.19639741f, 0.15974168f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00990908f, 0.18431838f, -0.07906047f, 0.17403457f, -0.02404569f, 0.15841825f, 0.13702220f, 0.19041638f, 
    -0.05641609f, 0.35426787f, 0.08447232f, 0.04587808f, 0.06126047f, 0.22227906f, 0.23761223f, 0.05762539f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03531611f, 0.07213470f, 0.09050546f, -0.04593805f, 0.12459540f, 0.03920489f, -0.06876495f, 0.04859088f, 
    0.08052652f, 0.08408728f, -0.00191428f, 0.05158358f, -0.19919971f, 0.14585350f, 0.09522168f, 0.00826712f, 
    -0.06156097f, -0.01925146f, 0.11484426f, 0.03245892f, -0.05312028f, 0.02830703f, -0.01595996f, 0.18610369f, 
    0.39389837f, 0.10172271f, 0.22290513f, 0.18752556f, 0.04693289f, 0.06117583f, 0.04285410f, 0.06197364f, 
    0.05041127f, -0.05018433f, 0.00699088f, -0.06129017f, -0.09367376f, -0.13975826f, -0.02113190f, -0.00378424f, 
    0.09521731f, 0.05093557f, 0.00495630f, 0.05074702f, 0.01684177f, 0.10573972f, 0.09973387f, 0.13140897f, 
    0.05635196f, -0.11017470f, 0.13009840f, 0.05908749f, -0.01041449f, 0.04805829f, -0.03087595f, 0.00048379f, 
    0.07258639f, -0.01820986f, 0.12206475f, 0.16838647f, -0.01594233f, 0.12499903f, -0.03743935f, -0.00291880f, 
    0.03686166f, 0.07349903f, -0.12447155f, 0.03568961f, 0.06765888f, -0.02246332f, 0.08966621f, 0.01365014f, 
    0.12099762f, 0.02181320f, 0.03785589f, 0.05508664f, 0.16872627f, 0.03608662f, -0.11910269f, 0.01725861f, 
    -0.06492583f, -0.00195725f, -0.02877041f, 0.07970620f, 0.22438957f, -0.10289142f, -0.04768258f, 0.06848846f, 
    0.06179348f, 0.16757888f, 0.10186887f, 0.22644994f, 0.01179619f, 0.11255520f, 0.07958445f, 0.07388034f, 
    -0.12064151f, 0.06612331f, 0.10631109f, 0.07529844f, 0.10980547f, 0.09908076f, 0.02551974f, 0.09003260f, 
    0.07443740f, 0.01087018f, 0.00062925f, 0.06106914f, -0.01639591f, 0.02721234f, 0.09255241f, 0.04639753f, 
    0.08237438f, 0.07392702f, -0.07994714f, 0.09518696f, 0.23118682f, 0.09982777f, 0.01731298f, 0.03405919f, 
    -0.13141650f, -0.15093219f, -0.17066211f, -0.20837708f, 0.08022619f, -0.06536309f, -0.12477987f, 0.09473077f, 
    0.05130504f, 0.02290677f, -0.00251155f, 0.13961549f, 0.07916139f, 0.09100100f, 0.16991340f, -0.12977356f, 
    -0.04607011f, -0.00344890f, 0.17585987f, 0.05799419f, -0.00505106f, 0.03463294f, -0.01658422f, 0.08073240f, 
    -0.14092347f, -0.14376493f, -0.26117036f, -0.18131314f, 0.08423365f, -0.01423918f, 0.03781196f, -0.01133940f, 
    0.10571156f, 0.01138981f, 0.05193112f, 0.09531113f, -0.15624505f, -0.03442362f, -0.12515989f, 0.10597649f, 
    -0.06178878f, 0.01378738f, -0.00988761f, 0.15198690f, 0.01324890f, -0.01159584f, 0.09731542f, -0.00575226f, 
    0.17772029f, 0.18719338f, 0.13013411f, 0.14638479f, 0.03358538f, 0.07529890f, 0.04543395f, 0.13996507f, 
    0.03474573f, 0.08892879f, 0.06728518f, 0.10574564f, 0.01976666f, -0.15790763f, 0.05269171f, -0.28472117f, 
    0.01635785f, 0.06788980f, -0.05516869f, -0.00126301f, 0.08619736f, -0.05434317f, 0.03004975f, 0.00646562f, 
    0.06993510f, 0.02960519f, -0.02197769f, -0.01710987f, -0.00041798f, -0.03076455f, -0.02597430f, -0.05208002f, 
    0.00626377f, -0.02161184f, -0.04804851f, 0.04905554f, 0.02706497f, 0.05315400f, 0.03410206f, -0.04877676f, 
    -0.02772485f, 0.00441756f, 0.03309230f, -0.06416303f, -0.03828324f, -0.08180669f, 0.00193330f, 0.00675298f, 
    -0.06919027f, -0.05074894f, -0.00810287f, -0.06824096f, -0.04023821f, 0.00163580f, -0.00778273f, -0.03643955f, 
    -0.03393363f, 0.05479264f, 0.01990569f, -0.04511767f, 0.01860248f, -0.05087028f, 0.03146143f, -0.06045459f, 
    0.02397383f, -0.02632705f, -0.02104200f, -0.00460996f, -0.05423883f, 0.03684535f, -0.00144927f, -0.05440907f, 
    -0.04766878f, -0.05966130f, 0.00089921f, -0.03587848f, -0.01511399f, 0.04909592f, -0.02920906f, -0.07187725f, 
    0.01871651f, -0.03795200f, -0.09111985f, 0.00305482f, -0.01614705f, -0.04349086f, 0.01834344f, 0.03465107f, 
    -0.01149505f, -0.01858088f, -0.06751272f, -0.08571228f, -0.04131019f, -0.01057751f, -0.03636573f, -0.02073674f, 
    -0.04563918f, -0.07278327f, 0.06620410f, -0.01843060f, -0.03364499f, 0.01594229f, 0.06300451f, -0.00083352f, 
    -0.04975951f, -0.04109293f, -0.07245801f, 0.02727262f, -0.03860261f, 0.00676100f, -0.04362015f, 0.03277243f, 
    -0.03060194f, 0.00132639f, -0.07244301f, -0.04618832f, 0.06981853f, -0.01451980f, -0.05735404f, -0.04979242f, 
    -0.03526843f, 0.00885657f, -0.00434225f, 0.01188738f, 0.01891275f, -0.02454437f, 0.07756519f, -0.02228931f, 
    0.02840874f, 0.02277770f, -0.00445162f, 0.01742303f, 0.05317252f, -0.03244301f, 0.05569610f, 0.04250222f, 
    -0.00421774f, -0.09231806f, -0.07961223f, -0.00845812f, 0.03127506f, -0.07089955f, -0.03710295f, -0.05565775f, 
    -0.04584626f, 0.01950336f, 0.01103722f, -0.04291116f, -0.00500801f, -0.05469006f, -0.03043807f, -0.03537286f, 
    -0.05796248f, 0.05321178f, 0.01426454f, -0.00016538f, 0.01759372f, -0.03136647f, -0.07374544f, -0.04049861f, 
    -0.07338706f, 0.05655052f, -0.03639951f, -0.00193656f, 0.00644018f, 0.00094183f, 0.06309342f, -0.01056101f, 
    0.05944527f, 0.03631197f, -0.03460586f, -0.03454871f, -0.06338314f, 0.00941486f, 0.04575467f, 0.04748956f, 
    -0.02517258f, -0.07415319f, -0.03744129f, -0.04002043f, -0.02586283f, 0.05188658f, -0.04284010f, 0.05107166f, 
    0.01742280f, 0.03125625f, 0.02525412f, -0.04380730f, -0.01803589f, -0.00737451f, -0.03391772f, 0.05544885f, 
    -0.06726409f, 0.01479292f, 0.05373681f, 0.03393638f, -0.00456002f, 0.01774566f, 0.07517331f, -0.01540916f, 
    -0.04789370f, 0.01445604f, 0.05725364f, -0.01771579f, -0.07664815f, 0.02847790f, -0.01546780f, -0.08335188f, 
    -0.04788490f, -0.01553479f, -0.02375425f, -0.06552283f, 0.04693501f, -0.07172655f, 0.02431005f, 0.00733459f, 
    -0.27296829f, -0.22794166f, -0.14354149f, -0.16164736f, 0.03186265f, 0.04810067f, 0.03008856f, 0.08281895f, 
    -0.01140374f, 0.13262124f, 0.17159683f, 0.14286709f, 0.08070467f, 0.12343266f, 0.32040608f, 0.22597656f, 
    0.03231056f, 0.10565656f, -0.05485572f, 0.11337636f, -0.05245146f, 0.02087100f, -0.01016844f, 0.08072689f, 
    0.01770626f, 0.10212005f, -0.16170576f, -0.19308707f, -0.04844504f, -0.08912198f, 0.01730887f, 0.05507183f, 
    0.12429652f, 0.16209905f, -0.10425379f, 0.00546706f, 0.15270539f, 0.02008172f, 0.02146949f, -0.02178164f, 
    0.05265727f, 0.00818429f, 0.18065411f, 0.10687947f, 0.09636135f, 0.06654140f, -0.14247623f, -0.04403513f, 
    0.03982498f, -0.09283452f, 0.07452630f, 0.04917339f, 0.03900729f, 0.04628780f, 0.00041996f, 0.05767452f, 
    0.06032421f, 0.05254802f, 0.07590867f, 0.12390526f, -0.05907853f, 0.08134763f, 0.03966552f, 0.10279863f, 
    0.02710085f, 0.04689700f, -0.02070068f, 0.04241033f, -0.03182914f, 0.24099617f, 0.15480600f, 0.06829919f, 
    0.31139544f, 0.06013212f, -0.09656249f, 0.25931415f, 0.01015600f, 0.08990967f, 0.03727502f, 0.13728486f, 
    0.05100483f, -0.02104602f, -0.08995908f, 0.06356774f, -0.05617817f, -0.04581631f, -0.02913851f, 0.17187184f, 
    -0.00314238f, 0.21187960f, -0.02467571f, 0.03615912f, 0.01573854f, 0.08608437f, 0.01641125f, -0.08527501f, 
    -0.24415965f, 0.01341364f, 0.15964036f, -0.04975598f, 0.00379215f, -0.18739752f, -0.02787736f, -0.05143408f, 
    -0.01322853f, -0.10708380f, -0.01738762f, 0.04086585f, 0.00918568f, 0.11867917f, 0.10722478f, 0.02841060f, 
    0.10561466f, 0.18343425f, -0.05042472f, -0.12391055f, -0.10035285f, 0.02190091f, -0.07220720f, -0.03791803f, 
    0.10579485f, -0.01070881f, 0.05708676f, -0.18976720f, -0.12128948f, -0.13967058f, -0.10477781f, -0.05781936f, 
    -0.13183214f, -0.01007280f, 0.02094097f, -0.01124390f, 0.16283488f, -0.05839248f, 0.04228570f, -0.07038493f, 
    0.11779775f, 0.15018439f, 0.00027044f, 0.03812376f, 0.08491182f, 0.04133437f, -0.09379856f, -0.00871132f, 
    0.23762658f, -0.06949039f, 0.01478335f, -0.02611971f, -0.00055218f, 0.06824734f, 0.03724102f, 0.05085882f, 
    -0.04307608f, -0.07895231f, 0.06989211f, 0.06398836f, -0.03116350f, 0.03017154f, 0.16748273f, 0.14810386f, 
    0.05411554f, -0.09230846f, -0.00848391f, -0.08759546f, -0.04316582f, 0.12797852f, 0.21688050f, -0.02229126f, 
    -0.05772646f, -0.11064214f, -0.01941385f, -0.17133084f, 0.10312091f, -0.22002596f, -0.04793753f, -0.01864699f, 
    -0.07171419f, -0.06258295f, 0.18736109f, -0.19860242f, -0.02547891f, 0.01464628f, -0.03591232f, -0.03374218f, 
    -0.05004643f, 0.00344223f, 0.04026646f, 0.03930134f, 0.06766655f, 0.10754623f, -0.03944716f, 0.02257366f, 
    0.23258215f, -0.01072532f, 0.16932079f, -0.00042222f, -0.05726821f, -0.00122157f, -0.17165846f, 0.06303981f, 
    0.11715160f, 0.08490687f, 0.02010695f, -0.05127962f, -0.08484995f, -0.07215395f, -0.16796510f, -0.01746673f, 
    0.02151569f, -0.11654493f, 0.06856366f, -0.00702732f, 0.10208943f, -0.00611238f, -0.00296430f, 0.07317488f, 
    0.26035875f, 0.04779662f, 0.07052796f, 0.36060351f, 0.02595284f, 0.08667206f, 0.13038801f, 0.06434850f, 
    -0.00005562f, -0.01136885f, 0.10236645f, -0.00921289f, -0.21264432f, -0.00078900f, 0.15433377f, -0.07154297f, 
    0.00527925f, -0.04456160f, 0.03132713f, -0.00609723f, 0.00167811f, 0.04593540f, 0.03197321f, 0.14002407f, 
    0.16618313f, -0.12778929f, 0.04422075f, 0.09792674f, -0.14102079f, -0.00972324f, 0.01849098f, 0.03770031f, 
    -0.01031661f, 0.09528641f, 0.01891733f, 0.04595404f, 0.03201972f, -0.00930946f, -0.13802993f, -0.00808282f, 
    0.10813395f, 0.00664021f, 0.02840422f, 0.01982844f, 0.14156938f, -0.12886553f, -0.12159616f, 0.02491882f, 
    -0.12018978f, -0.14975494f, 0.06836627f, -0.15792266f, -0.04360317f, 0.00801499f, -0.00619389f, 0.01549270f, 
    -0.06102414f, 0.07372431f, 0.07599501f, -0.01348917f, -0.06634643f, -0.04909960f, -0.13986458f, 0.00263690f, 
    0.01456537f, 0.02279581f, 0.19641951f, 0.15995897f, 0.01616709f, 0.00680874f, -0.00225348f, 0.02380399f, 
    -0.10900318f, 0.17236871f, -0.05301641f, 0.11877106f, 0.07053883f, 0.01482076f, 0.00273462f, 0.04923014f, 
    0.14681783f, 0.14272445f, 0.11175451f, -0.02210778f, 0.12985808f, -0.03286672f, 0.16427232f, -0.07544412f, 
    -0.09695789f, 0.04597863f, 0.00315631f, 0.10493117f, 0.08159050f, 0.01372129f, 0.01674064f, 0.10700694f, 
    -0.11549050f, -0.07198026f, -0.00392090f, 0.02113504f, 0.14614014f, 0.00528719f, 0.01751460f, 0.22053736f, 
    0.04492780f, 0.00133418f, -0.07310732f, 0.03229158f, -0.15211350f, 0.21789443f, 0.25905091f, -0.09296337f, 
    0.01430674f, 0.06406118f, 0.13558955f, -0.02626691f, 0.00409487f, 0.09811985f, 0.07929331f, 0.14102504f, 
    -0.02722945f, 0.05291054f, -0.15734278f, -0.13053323f, 0.01929597f, -0.00730049f, -0.02228845f, -0.08300871f, 
    0.05703815f, 0.07475759f, -0.06000821f, 0.02974151f, -0.04371933f, -0.07506453f, -0.05519414f, 0.02039184f, 
    0.00323376f, 0.09542917f, -0.01337923f, 0.11865872f, -0.01391498f, -0.02146006f, 0.00208752f, 0.03148701f, 
    0.03571406f, 0.21722667f, 0.19361421f, 0.24860789f, -0.12324708f, 0.04369399f, 0.12679432f, 0.03566688f, 
    0.00896064f, 0.11289314f, -0.05330549f, 0.14515477f, 0.07650284f, -0.00151661f, -0.07379086f, -0.15776782f, 
    0.13608921f, 0.07975365f, -0.04841350f, -0.07781144f, -0.00635700f, 0.00815411f, 0.14793432f, 0.09860561f, 
    0.08097030f, 0.11298693f, -0.06208248f, 0.11241520f, -0.01201221f, -0.09191256f, -0.18826535f, 0.01471542f, 
    -0.06808646f, 0.09492740f, 0.06639697f, -0.12666713f, -0.09647229f, 0.16601236f, 0.00754612f, -0.05100743f, 
    0.07187457f, -0.01587896f, 0.01096907f, 0.14169112f, 0.08823064f, 0.16023335f, -0.10090100f, -0.15837285f, 
    -0.11418822f, -0.36581081f, -0.08421970f, 0.17872509f, 0.09268669f, -0.10102303f, -0.04073381f, -0.10863698f, 
    -0.01857655f, 0.17147121f, 0.27675921f, -0.10357592f, -0.10935659f, 0.17517631f, 0.16328448f, -0.23368700f, 
    0.02218188f, -0.00244659f, -0.06166783f, -0.03663925f, -0.11735175f, 0.06739013f, -0.04289423f, 0.00291889f, 
    -0.15112670f, 0.01494315f, 0.03565365f, 0.06112673f, -0.08695900f, -0.02962195f, -0.06591237f, 0.01924967f, 
    0.02681123f, -0.02702716f, 0.17174144f, -0.11900556f, -0.14597681f, 0.11185492f, -0.03010192f, 0.03668237f, 
    0.02945144f, -0.13019942f, 0.10691831f, -0.03544078f, 0.06486190f, -0.16428107f, -0.16750038f, 0.09763137f, 
    0.10085989f, -0.02395939f, -0.08028518f, -0.00956754f, -0.11287434f, -0.04253949f, -0.02755404f, 0.03401627f, 
    0.08070312f, -0.03202323f, 0.17526254f, -0.06726216f, -0.00080679f, 0.29700786f, -0.13355044f, -0.19772303f, 
    0.13774714f, -0.02283053f, -0.07111644f, -0.00081684f, -0.02837290f, 0.02787878f, -0.02035859f, 0.09983443f, 
    -0.13751999f, -0.12729794f, -0.17436682f, 0.00692685f, 0.08434634f, -0.09174652f, 0.08941947f, -0.07674508f, 
    0.08471403f, 0.05633901f, 0.28984451f, 0.06171038f, -0.12542555f, 0.13202740f, -0.08297084f, -0.10901839f, 
    -0.00583037f, -0.06398179f, -0.07411849f, 0.03355060f, 0.03519593f, -0.02059108f, 0.13954192f, 0.04848850f, 
    -0.07646341f, 0.01561410f, 0.31226644f, 0.15067087f, 0.04407215f, 0.11623141f, 0.00307804f, 0.01638518f, 
    0.06486670f, -0.03877631f, -0.04010390f, 0.02356970f, -0.04126760f, 0.19686039f, -0.14178272f, -0.04574685f, 
    0.05148664f, 0.02036088f, -0.03881273f, 0.03499198f, 0.20252085f, 0.07740717f, 0.03995145f, 0.10903118f, 
    0.26503554f, -0.01698636f, 0.18966356f, 0.02146104f, -0.13459222f, -0.15640467f, 0.13615271f, -0.04777078f, 
    -0.05153587f, 0.07219149f, -0.06226829f, -0.21763010f, 0.26377133f, 0.05601219f, 0.05978336f, -0.16764034f, 
    0.08745747f, 0.10863812f, 0.05236358f, -0.01370134f, 0.05192830f, -0.00836719f, 0.05771874f, 0.06208238f, 
    -0.26016140f, -0.06037688f, 0.00561393f, 0.20380852f, 0.01826649f, -0.03960433f, -0.01487586f, -0.02780661f, 
    0.00795113f, 0.21083687f, -0.03277576f, 0.08355311f, -0.13089758f, 0.42716685f, 0.01600506f, 0.21396069f, 
    -0.05318161f, 0.09425387f, -0.05977004f, 0.04339092f, -0.02548172f, -0.17631252f, -0.05403514f, 0.11491011f, 
    0.03400038f, 0.03663269f, -0.06462230f, 0.08154557f, 0.03194112f, -0.07728487f, 0.07499264f, -0.06267945f, 
    -0.00153802f, 0.07939146f, 0.06207196f, 0.12503231f, 0.31726319f, 0.05794660f, 0.21273969f, 0.18142617f, 
    0.03665081f, 0.02399754f, -0.05661086f, -0.03487102f, -0.03042167f, -0.07316454f, -0.02118296f, -0.09735936f, 
    -0.35174289f, 0.00707636f, -0.06270156f, -0.16993359f, 0.09422118f, 0.05855094f, -0.19617076f, -0.04040405f, 
    -0.06756146f, 0.02414712f, -0.08702976f, 0.01039366f, 0.15157975f, -0.01319523f, -0.08501263f, -0.10547272f, 
    -0.03851389f, -0.04765770f, -0.06539077f, -0.06440340f, -0.07789285f, 0.01214675f, -0.00510832f, -0.05142780f, 
    -0.31141010f, 0.04672532f, -0.01704596f, -0.00187976f, 0.15464082f, 0.08369551f, 0.02872780f, -0.04341964f, 
    -0.06808550f, -0.01754240f, 0.03711072f, -0.02470414f, 0.05307605f, -0.01912952f, 0.00588168f, 0.05966728f, 
    -0.05380759f, 0.11996196f, 0.07215796f, 0.15477628f, -0.04162155f, 0.07735939f, 0.12019577f, 0.01481192f, 
    -0.12499853f, 0.22987215f, -0.05034334f, 0.14685786f, 0.17288829f, 0.04117193f, 0.04531808f, 0.04628609f, 
    0.12001344f, -0.00278577f, 0.09338459f, 0.06064276f, -0.27286527f, 0.06360797f, 0.21596858f, 0.03100025f, 
    -0.01735807f, 0.01135504f, 0.06980581f, -0.20929641f, -0.06081367f, -0.01507585f, 0.04593683f, -0.04685501f, 
    0.16085374f, 0.06189683f, -0.00728395f, 0.05334818f, 0.06450339f, 0.03126549f, -0.10921419f, -0.02378439f, 
    0.04000874f, -0.11691599f, 0.04145783f, -0.08889081f, 0.17403591f, 0.13214163f, -0.01158146f, 0.02461520f, 
    0.14788269f, -0.01358763f, 0.18048976f, 0.04898595f, -0.12817824f, 0.07235436f, 0.07601905f, -0.00706872f, 
    0.14866683f, -0.12389560f, -0.00271826f, -0.07599961f, -0.12641172f, 0.02072315f, -0.05383123f, -0.21735671f, 
    -0.04964032f, -0.00795160f, 0.09840215f, -0.07244214f, 0.20165773f, -0.01579059f, -0.23959510f, -0.06918654f, 
    0.16844141f, 0.04797904f, -0.12114044f, -0.02817371f, 0.07126775f, -0.01521007f, 0.02652516f, -0.01129525f, 
    0.21062325f, 0.01974551f, 0.04649854f, 0.01040876f, -0.10029624f, -0.10108859f, 0.04250105f, 0.13630745f, 
    0.01352870f, -0.06619207f, -0.00255716f, -0.05376305f, 0.07154024f, 0.03415123f, 0.10100735f, -0.13114181f, 
    0.08899187f, -0.09296080f, 0.01968262f, -0.17855528f, 0.02611531f, 0.00035271f, 0.04370958f, 0.14292990f, 
    -0.20457074f, 0.13878080f, -0.18628821f, -0.12807010f, 0.25128746f, -0.02580173f, -0.04887985f, -0.01790470f, 
    -0.03975478f, -0.04936755f, 0.05970575f, -0.01884103f, -0.15340997f, -0.00345974f, 0.26244199f, 0.22965381f, 
    -0.07305717f, -0.05016680f, 0.12685083f, 0.06333841f, -0.08202615f, 0.01951202f, 0.07371713f, 0.05059254f, 
    0.00370359f, 0.02470816f, -0.07527944f, -0.03093275f, 0.01263029f, 0.04042887f, 0.04475916f, -0.05242316f, 
    0.02947128f, -0.06072429f, 0.01653807f, -0.00989361f, -0.00237184f, -0.02678910f, -0.05662895f, -0.03516299f, 
    -0.00670507f, 0.03819603f, 0.03112572f, 0.01110658f, -0.07656213f, 0.02413540f, -0.05943716f, 0.02131880f, 
    0.00889727f, 0.04700143f, -0.07095620f, -0.02548643f, -0.07649880f, 0.00144238f, -0.05246683f, -0.01391202f, 
    -0.01015236f, -0.04217029f, 0.05862647f, -0.00434709f, 0.01145132f, -0.04005303f, -0.07278710f, 0.03192951f, 
    -0.07962618f, -0.03963851f, 0.04984919f, -0.04727256f, -0.07429884f, -0.04678399f, -0.03106091f, -0.03681151f, 
    -0.01287983f, -0.04547146f, 0.03219791f, -0.06329042f, -0.01016995f, -0.07839466f, -0.03741644f, -0.03291772f, 
    -0.06038580f, -0.05850040f, -0.05848396f, 0.01388088f, 0.05059637f, 0.00941691f, 0.05978408f, -0.07273727f, 
    -0.02941836f, -0.03177461f, 0.04684551f, 0.03615084f, -0.04102170f, -0.01304671f, -0.05770951f, 0.01839164f, 
    0.01642846f, 0.03824506f, -0.04541913f, 0.05933957f, -0.04279363f, 0.04502746f, 0.00889670f, -0.03247188f, 
    -0.07261870f, 0.04434019f, -0.03204332f, 0.05214539f, 0.03244673f, -0.02053578f, 0.05573415f, -0.04922249f, 
    0.05506948f, -0.02129113f, 0.03215046f, -0.08208823f, -0.07616653f, -0.07459201f, -0.08118943f, -0.03047313f, 
    -0.05356513f, 0.00719050f, 0.03043338f, 0.03120271f, 0.05189889f, 0.00929188f, -0.04818627f, -0.02945586f, 
    -0.02957304f, -0.06481538f, 0.00952932f, 0.04314164f, -0.02291769f, 0.04112142f, -0.04150669f, 0.01000907f, 
    0.03405941f, 0.02810024f, -0.01384036f, 0.01039646f, 0.04024783f, -0.01916008f, -0.06410984f, -0.07060066f, 
    -0.02778667f, -0.01193766f, -0.01792566f, 0.00270011f, -0.01692268f, -0.05686875f, -0.00078803f, -0.05773493f, 
    -0.06103167f, 0.05293357f, 0.04584674f, 0.00344133f, 0.06553304f, -0.05725176f, 0.01385202f, 0.00877691f, 
    0.05717765f, 0.02180029f, -0.00471035f, 0.05864046f, -0.04997088f, -0.03537992f, -0.02757764f, 0.04756724f, 
    -0.03148782f, 0.00841045f, -0.02446671f, 0.03024657f, 0.05110788f, -0.00863061f, -0.03952288f, -0.06856456f, 
    0.01797099f, -0.02521833f, 0.02127839f, -0.04359176f, 0.00964633f, -0.07387570f, -0.04354475f, 0.04553670f, 
    -0.06689370f, -0.04874875f, -0.06274182f, 0.04016029f, -0.02864519f, 0.05656118f, -0.00864746f, -0.07396401f, 
    -0.06090164f, -0.04318272f, -0.06760280f, 0.02826646f, 0.04971093f, -0.00326749f, 0.01136297f, 0.04198060f, 
    -0.00808793f, 0.01809991f, 0.05241394f, 0.02901707f, -0.05584094f, -0.01297040f, -0.06973041f, 0.02214014f, 
    -0.05189759f, 0.05635154f, 0.01567879f, -0.00830807f, -0.00299809f, 0.00652692f, -0.01305961f, 0.03355882f, 
    0.04739569f, -0.08484463f, 0.04671862f, -0.00037334f, 0.05120296f, -0.03927588f, 0.03733267f, 0.02485733f, 
    -0.01432707f, -0.03033467f, 0.00538731f, -0.06471442f, 0.10231425f, -0.02446308f, -0.03940631f, -0.04144133f, 
    0.11874124f, -0.08105169f, -0.08777893f, -0.04911312f, 0.01205118f, -0.07242800f, -0.08914683f, 0.01516571f, 
    0.00086342f, 0.06603961f, 0.05028801f, -0.11629847f, -0.05426035f, -0.03384054f, -0.09522580f, -0.04399867f, 
    0.02353567f, 0.05960853f, -0.01107175f, 0.05722324f, -0.04641162f, 0.05362457f, -0.07260475f, 0.00714963f, 
    0.04331736f, -0.07732013f, 0.05475418f, 0.10794554f, -0.01371616f, -0.01804587f, -0.13204998f, 0.02245343f, 
    0.13949127f, -0.05545356f, 0.01433421f, -0.00484029f, 0.01464787f, -0.10315017f, -0.07718925f, 0.10673615f, 
    -0.01858493f, -0.06337438f, 0.09585031f, 0.06443080f, -0.07270881f, -0.04301288f, -0.01518704f, -0.04392041f, 
    0.06114507f, -0.01739606f, 0.00547136f, 0.02435791f, 0.02747887f, -0.04718391f, 0.03829621f, -0.00810664f, 
    -0.04993997f, 0.02257669f, -0.04305489f, -0.08146941f, -0.08465755f, -0.05297633f, 0.01028383f, 0.14902805f, 
    0.08061247f, -0.01487470f, 0.01466560f, -0.00688891f, -0.00224909f, 0.00447314f, 0.09239168f, 0.08080985f, 
    -0.10756204f, 0.06438804f, 0.04055024f, 0.01700688f, -0.00367168f, 0.03379710f, 0.05111250f, -0.07735635f, 
    -0.10463525f, 0.02305019f, -0.00730565f, -0.03536142f, 0.07666732f, 0.03108526f, -0.04749531f, -0.00185701f, 
    0.00011877f, 0.08143054f, -0.01724081f, -0.10862007f, 0.06594107f, 0.02454041f, -0.03886207f, -0.05923953f, 
    0.04850706f, 0.01944787f, -0.10038394f, -0.01241148f, 0.04556883f, 0.07420217f, -0.00956639f, -0.02804198f, 
    -0.02923880f, -0.00036937f, 0.05245284f, -0.03499401f, 0.10785304f, 0.01453221f, 0.02979665f, -0.08090978f, 
    -0.10284108f, -0.02613930f, 0.03310841f, -0.05832946f, 0.03451675f, 0.09371884f, 0.00841746f, 0.02158205f, 
    -0.03740583f, -0.04702016f, -0.13586369f, 0.05633292f, 0.03131876f, -0.02802349f, -0.11522668f, -0.00548151f, 
    0.00988262f, -0.03061763f, -0.04503460f, -0.12306803f, 0.06585719f, -0.00704032f, -0.00013801f, 0.05399400f, 
    0.02843077f, 0.04465600f, -0.12712947f, -0.00720886f, 0.08461633f, 0.09381610f, 0.07593354f, -0.07987048f, 
    -0.01952894f, 0.00970074f, -0.05186130f, 0.03771410f, -0.04240840f, 0.01932571f, -0.00345639f, -0.05055019f, 
    0.09180229f, 0.07773171f, 0.04265989f, -0.13064970f, -0.07133062f, 0.01409794f, -0.11290426f, -0.03524424f, 
    0.08698520f, 0.05645696f, 0.00922289f, 0.02426278f, -0.00043399f, -0.04637158f, 0.04873552f, 0.08341432f, 
    -0.05532832f, 0.01532732f, -0.01136316f, 0.02252046f, -0.05229367f, -0.04409711f, 0.03817345f, -0.04158529f, 
    -0.16045836f, 0.00620536f, -0.03952729f, -0.08563533f, -0.05997844f, -0.09645281f, 0.03083842f, -0.05872096f, 
    -0.07657210f, -0.10734880f, 0.03050270f, 0.03857071f, 0.03519464f, 0.12642609f, 0.28338131f, 0.06095747f, 
    -0.02586739f, 0.16066934f, 0.00124606f, 0.06677508f, -0.11843896f, 0.04154097f, -0.03462496f, -0.04665636f, 
    -0.23698646f, 0.10516963f, 0.06324069f, -0.02515915f, 0.09774027f, 0.12278323f, 0.03333809f, 0.03860518f, 
    -0.02253623f, 0.05753488f, -0.04824028f, -0.13708372f, 0.16154315f, 0.08928385f, -0.14819270f, 0.00763598f, 
    -0.06592573f, -0.01095405f, 0.03968355f, 0.01805306f, 0.13333189f, 0.10921546f, -0.03873001f, 0.09438755f, 
    0.03351840f, 0.16257109f, 0.15022109f, -0.07859315f, 0.11058102f, 0.15939248f, 0.09275953f, -0.08275978f, 
    0.05949435f, -0.03466989f, 0.10663650f, 0.15229189f, 0.13080890f, -0.05333709f, 0.09957273f, 0.09655667f, 
    -0.00169891f, 0.08322146f, 0.05176228f, 0.03933077f, 0.03515950f, 0.11633717f, 0.10158338f, 0.20344254f, 
    0.33749110f, 0.32065228f, -0.06910177f, 0.11664308f, 0.08565922f, 0.07409906f, -0.06465210f, 0.10807365f, 
    0.01735395f, 0.05935030f, -0.13717827f, 0.02903635f, -0.00191288f, 0.03553833f, -0.03770783f, 0.12554701f, 
    -0.05527200f, 0.04446006f, -0.07273482f, -0.00351368f, 0.09450632f, 0.02655567f, -0.12481821f, 0.02331800f, 
    -0.01613830f, -0.12488668f, 0.22066335f, -0.01525723f, 0.15338729f, -0.05002671f, 0.00407445f, 0.09973004f, 
    -0.04485467f, -0.03250752f, -0.02491745f, 0.00343116f, -0.13239898f, 0.18022703f, -0.06072833f, 0.00856857f, 
    0.14387675f, 0.05193507f, -0.06863497f, -0.18985668f, 0.06029955f, 0.02829232f, -0.09061735f, -0.07012524f, 
    0.18704940f, -0.02839140f, -0.08517819f, -0.00046892f, -0.03295935f, 0.00283209f, -0.01363825f, -0.05531379f, 
    -0.16887531f, -0.03220013f, 0.05957141f, 0.02024553f, 0.15268709f, -0.10149126f, -0.11287054f, 0.10821329f, 
    -0.02003819f, 0.04933067f, -0.06678684f, 0.00535256f, 0.09536684f, 0.02034302f, -0.10839358f, -0.00823082f, 
    0.14527017f, -0.13577688f, -0.11704388f, 0.13507950f, 0.02083678f, -0.04171151f, 0.04514240f, 0.01028899f, 
    -0.01833302f, 0.06449064f, 0.03859963f, 0.09096216f, 0.21028595f, 0.19958569f, 0.06111400f, -0.02545124f, 
    -0.10530337f, 0.02471372f, -0.00643095f, -0.00991394f, -0.04297326f, 0.09593597f, 0.05848330f, 0.01722531f, 
    -0.11146358f, -0.10294729f, 0.02170874f, -0.04275831f, 0.17556949f, -0.04377966f, -0.02854090f, 0.01760678f, 
    -0.00147885f, -0.13163523f, 0.06718291f, -0.16017526f, -0.31321695f, 0.15265179f, 0.06008984f, 0.17198889f, 
    -0.16280474f, -0.04414791f, -0.04873436f, 0.17160025f, 0.04334172f, 0.07024521f, -0.00273685f, 0.04235247f, 
    -0.05902551f, -0.02642736f, 0.01210867f, 0.02019007f, -0.00259553f, -0.07286484f, 0.06227817f, -0.01121605f, 
    0.03558635f, 0.03017074f, 0.02911753f, 0.02321780f, -0.02362390f, -0.06782892f, 0.06034054f, -0.05652297f, 
    0.07000582f, 0.01255242f, 0.04585657f, 0.00144992f, -0.03627988f, -0.06034866f, -0.06125856f, 0.03878972f, 
    -0.00770851f, -0.00419884f, -0.06801654f, -0.06645446f, 0.04214383f, -0.02759116f, -0.06538529f, 0.05963677f, 
    -0.01873341f, -0.01267098f, -0.03793635f, -0.00005987f, -0.07269637f, -0.02160111f, -0.06027624f, -0.02536054f, 
    -0.01487456f, 0.04716453f, 0.04770353f, -0.02259824f, -0.07028431f, 0.02952630f, -0.00611647f, -0.01885001f, 
    0.07293697f, 0.03606559f, -0.07270315f, 0.00311199f, -0.07055584f, 0.00723497f, -0.02694696f, -0.02319541f, 
    0.05209824f, -0.03236589f, -0.04806731f, 0.00017985f, 0.01035536f, 0.02565196f, 0.00635254f, -0.03043281f, 
    0.00946879f, -0.00068735f, -0.07809066f, -0.04256528f, -0.02847720f, 0.02739908f, 0.04225777f, -0.05100533f, 
    0.02449899f, -0.07129638f, -0.03133406f, 0.02208056f, 0.00543373f, 0.03643033f, 0.06579155f, 0.02172009f, 
    -0.04834206f, 0.02735459f, -0.00239619f, 0.05665161f, 0.06987940f, -0.01432308f, 0.01449564f, -0.04032668f, 
    -0.01243809f, -0.06879214f, -0.00465381f, -0.02730993f, -0.05481325f, 0.00386295f, 0.05373015f, 0.05198810f, 
    -0.01439940f, -0.02558268f, 0.05050589f, 0.05418690f, 0.00690563f, -0.05022557f, -0.01231644f, -0.08178347f, 
    -0.00184376f, 0.03465645f, 0.04272730f, 0.02299589f, -0.05411094f, 0.01854863f, 0.05247364f, 0.01115210f, 
    -0.03803496f, -0.07590625f, 0.06095710f, 0.00976964f, 0.04167639f, -0.01241194f, -0.04689684f, -0.05174618f, 
    -0.03543241f, 0.06926788f, -0.04740290f, -0.00362260f, -0.04272209f, -0.00644456f, -0.06724098f, -0.00922817f, 
    -0.05513707f, -0.03360378f, 0.05909095f, 0.04475061f, -0.01319332f, 0.05585342f, -0.04958360f, -0.00357417f, 
    -0.01524864f, 0.04507151f, -0.07582147f, -0.06996196f, 0.01701054f, -0.08397223f, 0.04276406f, 0.05948047f, 
    -0.03806671f, 0.06811473f, 0.02932782f, 0.06142564f, 0.02138274f, 0.00544718f, -0.06832920f, 0.03491236f, 
    -0.02291986f, -0.03952189f, -0.07504594f, -0.03184339f, 0.03336826f, 0.03123593f, -0.03801077f, 0.04629391f, 
    0.00354107f, 0.06625731f, -0.05225345f, 0.03986733f, 0.02261294f, -0.07119438f, -0.07496846f, -0.05285579f, 
    0.00243666f, -0.07688816f, -0.03338143f, 0.04417900f, -0.02510180f, 0.03437763f, -0.04476127f, 0.01815573f, 
    -0.00876961f, -0.00184242f, 0.03000303f, -0.03825164f, -0.01523597f, -0.07051281f, -0.04497535f, -0.05237224f, 
    -0.03313886f, 0.04619749f, 0.01047138f, -0.02730218f, -0.06583941f, -0.04746699f, 0.06795993f, -0.04252876f, 
    -0.05731469f, 0.04461383f, -0.07426094f, -0.07621779f, -0.04773195f, 0.06199101f, 0.06237585f, 0.01002371f, 
    -0.05004279f, 0.05793371f, -0.06472044f, -0.07928579f, 0.00199298f, -0.05572766f, 0.04339199f, -0.01193827f, 
    -0.02646491f, -0.03626772f, -0.01193742f, -0.08201668f, 0.03149782f, 0.02712952f, -0.02629311f, 0.02803219f, 
    -0.01004710f, 0.00112526f, 0.03059644f, -0.04800183f, 0.03973669f, -0.02531947f, -0.04878437f, -0.07410089f, 
    -0.04303366f, -0.08582634f, -0.01350996f, -0.02774821f, 0.03794273f, -0.05667674f, 0.05787005f, 0.01318969f, 
    -0.00325797f, 0.00592831f, -0.03324411f, 0.03816608f, -0.02544793f, -0.02786984f, -0.05629210f, 0.01998948f, 
    0.06337785f, 0.03432271f, 0.00483826f, 0.03581397f, -0.03695418f, 0.06625748f, 0.01797850f, -0.01872038f, 
    -0.02103533f, 0.00246316f, 0.00748909f, -0.01489915f, -0.06845074f, 0.01466483f, -0.06377951f, -0.01821673f, 
    -0.04092771f, -0.05248011f, -0.03845307f, 0.02711168f, -0.06388839f, -0.06281926f, -0.05959377f, 0.03604239f, 
    0.01730686f, 0.05772883f, 0.05727096f, -0.03742841f, -0.04250254f, 0.01664647f, -0.07697218f, -0.04569358f, 
    0.03553676f, -0.02006444f, -0.06589872f, -0.01698493f, -0.04386165f, -0.01993396f, -0.02303028f, -0.01417475f, 
    0.03217212f, -0.04356862f, 0.04541619f, 0.04121253f, -0.02532056f, 0.00362300f, -0.05754350f, -0.05695474f, 
    0.00325148f, 0.04722631f, -0.05725968f, -0.06647927f, -0.02961618f, 0.02436681f, -0.02419402f, 0.01869459f, 
    -0.03369633f, 0.03975330f, -0.04078138f, 0.05306336f, -0.03293320f, 0.06092770f, -0.00597428f, -0.02001251f, 
    -0.07135533f, -0.01632220f, -0.05936968f, 0.04259534f, 0.04049613f, 0.02298269f, 0.03504806f, -0.03297940f, 
    -0.06482693f, -0.06654555f, 0.02891437f, 0.00156877f, -0.03859835f, 0.05517392f, -0.08322056f, 0.01873948f, 
    0.00170542f, 0.02132333f, -0.04925060f, 0.06448972f, -0.02713608f, -0.00932199f, 0.02496742f, 0.05191789f, 
    -0.01234641f, 0.03587200f, -0.04114310f, 0.04476117f, 0.03414011f, -0.06275005f, -0.02874777f, -0.04295246f, 
    -0.03978857f, -0.00474454f, 0.06453127f, -0.06404669f, 0.06143722f, -0.07170703f, 0.04270386f, 0.03540207f, 
    0.04962397f, -0.06142558f, 0.00579648f, -0.05308991f, 0.03327041f, 0.05436316f, -0.06740646f, -0.02406731f, 
    0.00656244f, -0.01602429f, 0.01350728f, -0.08033887f, 0.05399566f, 0.01732613f, 0.03437489f, -0.00027737f, 
    -0.02947217f, 0.01592587f, 0.06051868f, 0.04233434f, -0.06442077f, -0.04485466f, -0.07752687f, -0.06659002f, 
    -0.03560158f, 0.05841255f, -0.06268211f, 0.01062447f, 0.05068433f, 0.03753134f, 0.00731272f, 0.04464834f, 
    0.01861317f, -0.01111158f, -0.07150082f, -0.06843083f, 0.05695884f, 0.05736933f, 0.02172862f, -0.06550389f, 
    -0.03501206f, 0.01643103f, -0.00615772f, 0.09176395f, 0.01977938f, 0.11092274f, -0.04786117f, 0.06944283f, 
    0.14311348f, 0.11248740f, 0.08652997f, -0.06532974f, -0.24932650f, -0.02010352f, -0.08620191f, 0.09053121f, 
    -0.07377782f, -0.02117754f, -0.04525838f, 0.08911496f, 0.04460154f, -0.11400006f, 0.06546433f, 0.08966604f, 
    0.39545164f, -0.07961740f, -0.27038905f, 0.42750686f, 0.02408782f, -0.02734669f, 0.06757468f, 0.02623577f, 
    0.02465358f, 0.03389033f, -0.00091184f, -0.09714139f, 0.02113954f, 0.01826268f, 0.20617962f, -0.13481784f, 
    0.06471834f, 0.07512774f, 0.05740988f, 0.12391467f, -0.08737655f, 0.01737072f, 0.04009643f, 0.01156183f, 
    0.25815722f, -0.07822829f, 0.10058494f, 0.18065360f, 0.00889462f, -0.10664670f, -0.02193743f, 0.05421733f, 
    0.02113839f, 0.03059744f, -0.05770170f, 0.05305812f, -0.24861038f, 0.21791157f, -0.05797055f, -0.21647950f, 
    0.06172181f, -0.02063772f, 0.00277904f, -0.02796128f, 0.00163356f, 0.07905209f, 0.04879671f, -0.09012493f, 
    0.12563516f, -0.16432327f, 0.00854105f, 0.06793125f, -0.00572339f, -0.07735192f, -0.05336311f, -0.12213951f, 
    0.00725848f, 0.05567763f, 0.05468769f, 0.02786388f, 0.23001830f, 0.06784085f, -0.17476979f, -0.25367746f, 
    0.01626377f, 0.01547044f, 0.09190886f, 0.04722631f, -0.01844971f, 0.15772542f, 0.06002684f, -0.00592420f, 
    -0.18631664f, 0.11586812f, -0.19867179f, 0.01244890f, -0.05380224f, -0.05297150f, 0.05981112f, -0.09494560f, 
    0.12819950f, -0.09047350f, -0.00853840f, -0.04149413f, -0.07462625f, -0.07994282f, 0.00317559f, 0.07560673f, 
    -0.06540839f, 0.03120347f, 0.01440267f, 0.08952106f, -0.03987178f, -0.03165731f, 0.03160652f, 0.01798388f, 
    -0.11634106f, 0.11283633f, 0.28606111f, -0.07804035f, -0.13843958f, 0.00962537f, 0.02063731f, 0.16234599f, 
    0.02620705f, 0.05282461f, -0.03265372f, 0.00868136f, 0.11061919f, 0.07634100f, 0.14979111f, -0.06626695f, 
    0.06922519f, 0.14467874f, 0.03250916f, 0.01510984f, 0.06503530f, 0.02514432f, -0.00169097f, 0.04966050f, 
    0.16491443f, 0.07974089f, 0.14094734f, -0.04937135f, -0.00253449f, -0.00941199f, -0.06875210f, 0.13256076f, 
    0.00772446f, 0.02510927f, -0.11853829f, -0.03120640f, -0.01839976f, -0.24956085f, -0.11710231f, 0.18087481f, 
    0.05415892f, -0.05092458f, 0.07576380f, -0.03519443f, 0.00358520f, -0.00204779f, -0.10731290f, 0.04371357f, 
    0.16880408f, -0.01541953f, 0.16492538f, 0.30506071f, -0.19084251f, -0.04105517f, -0.03038813f, 0.05913070f, 
    -0.01653029f, 0.01602492f, -0.05727359f, 0.04494529f, 0.36326042f, 0.05165069f, -0.01113354f, -0.27979818f, 
    0.14085905f, 0.04057413f, 0.03262455f, -0.13386238f, 0.03270310f, -0.06227674f, -0.00843685f, -0.10148383f, 
    0.02710743f, 0.23029397f, 0.07822489f, 0.15231149f, 0.04542371f, 0.08826884f, 0.00530536f, -0.05913281f, 
    -0.09114501f, 0.10917532f, 0.12898365f, 0.04372535f, -0.19642852f, -0.02314712f, 0.25711927f, -0.00495438f, 
    -0.07802890f, 0.12704289f, 0.11724471f, -0.06318793f, 0.03168252f, 0.01451508f, -0.07757322f, -0.06846305f, 
    -0.06666151f, 0.15929686f, 0.03042025f, -0.07188936f, 0.02679658f, -0.11358438f, -0.15257159f, 0.09148412f, 
    0.11552733f, 0.13069631f, -0.04546212f, 0.06660389f, -0.12506655f, 0.02863678f, 0.01603089f, -0.05331200f, 
    -0.10344138f, 0.02669093f, 0.00942013f, 0.05500982f, -0.05742950f, -0.01959322f, -0.02449161f, -0.12543690f, 
    -0.22790326f, 0.40654624f, 0.01070482f, -0.05627798f, -0.02315841f, 0.01990160f, -0.05642369f, -0.16571833f, 
    -0.28588995f, 0.02175943f, 0.12480269f, 0.11117265f, -0.01130842f, -0.10300142f, 0.22048996f, 0.12581930f, 
    -0.09001222f, 0.05113244f, 0.00588810f, 0.07029776f, 0.09820807f, 0.25356671f, 0.15708126f, 0.07848607f, 
    -0.07191064f, 0.35827500f, 0.05186369f, 0.13901837f, -0.02371447f, 0.07078139f, -0.06693412f, -0.09050591f, 
    0.04410255f, 0.10110639f, -0.06603035f, -0.03835626f, 0.03866668f, 0.37327999f, 0.12447477f, -0.15835944f, 
    -0.04750566f, 0.13748462f, -0.05704578f, -0.14638045f, -0.19785742f, -0.07588418f, 0.01975673f, -0.13006508f, 
    0.41849384f, -0.26086158f, 0.14048934f, 0.11042861f, 0.23448853f, -0.07844771f, 0.00195039f, 0.09378631f, 
    -0.07352726f, -0.04527587f, -0.02490803f, -0.12359643f, -0.29777384f, 0.28982154f, -0.04973011f, -0.15215531f, 
    -0.05848162f, -0.03037996f, 0.07379204f, -0.12931904f, -0.03458730f, -0.12392566f, 0.04994221f, -0.01724275f, 
    -0.17378931f, -0.09862059f, 0.08381062f, -0.07141022f, -0.00075335f, 0.02293246f, 0.06461187f, -0.05013286f, 
    -0.09925875f, -0.01461632f, 0.01005622f, -0.08855756f, 0.07891922f, 0.07184035f, -0.10161005f, -0.19986221f, 
    0.04934330f, -0.00721069f, -0.02680635f, 0.03544065f, 0.07217561f, -0.12717040f, -0.07013606f, -0.08247396f, 
    0.17520647f, -0.14909142f, 0.27965689f, -0.08698522f, 0.08325145f, 0.12985317f, 0.07216435f, -0.10207027f, 
    -0.00308629f, -0.08193845f, 0.08711991f, 0.07653644f, -0.07640202f, 0.17438307f, -0.01604672f, -0.05828504f, 
    0.04758546f, -0.00252399f, -0.02339393f, -0.01066128f, -0.02618654f, 0.06050075f, 0.17468178f, 0.01069953f, 
    0.15004379f, 0.09230071f, -0.07354660f, 0.15488356f, 0.24807370f, -0.03453214f, -0.08488414f, -0.07950436f, 
    0.03749667f, -0.09402329f, -0.09602467f, -0.04787372f, -0.09438845f, 0.09680545f, 0.23894282f, 0.01794398f, 
    -0.05304556f, 0.09553161f, -0.04750016f, 0.12057244f, -0.00821041f, 0.02835079f, 0.02529096f, -0.00986497f, 
    0.05127282f, -0.02984496f, 0.00588499f, -0.02636795f, -0.06413038f, 0.01494116f, -0.03123906f, -0.00098009f, 
    -0.05359539f, 0.03857609f, -0.03993780f, 0.07047843f, -0.02799334f, -0.06418173f, -0.03107737f, -0.06791577f, 
    0.03457229f, -0.03718777f, 0.01354226f, 0.05207431f, -0.00342133f, 0.06690853f, -0.02213166f, -0.05325083f, 
    0.06638399f, 0.01783394f, 0.06239342f, -0.07166328f, -0.01726385f, -0.03450724f, -0.00956748f, 0.01200620f, 
    -0.05986405f, 0.01588537f, 0.00958738f, -0.04115348f, -0.02158160f, 0.04964313f, -0.06488911f, 0.06565676f, 
    -0.02169180f, 0.05887496f, -0.01700812f, 0.00461124f, 0.03667784f, 0.00754500f, 0.01640073f, 0.03530187f, 
    0.00995192f, 0.04790865f, 0.05620026f, 0.05635253f, -0.00040597f, -0.05466430f, -0.01450260f, 0.02488938f, 
    0.06227601f, 0.06568506f, -0.01113346f, 0.01035036f, -0.04839256f, -0.01747404f, 0.04227249f, -0.06016267f, 
    0.06240275f, 0.01226211f, -0.04368260f, -0.00193549f, 0.05432039f, -0.00858087f, -0.02063698f, 0.02471248f, 
    0.01553492f, 0.02493216f, 0.02795563f, -0.07083219f, 0.04786145f, -0.06379778f, -0.07891851f, -0.05193887f, 
    0.00259974f, 0.05776573f, 0.04898687f, 0.01034524f, -0.00156101f, -0.03359765f, -0.06291037f, -0.05884050f, 
    0.01009258f, -0.05710685f, -0.05862975f, 0.02108377f, -0.04897898f, 0.04862766f, 0.01422177f, -0.00201948f, 
    0.01046470f, -0.05726535f, 0.01409985f, 0.01690728f, -0.02950106f, -0.02872940f, -0.00575095f, -0.01500874f, 
    -0.06958075f, 0.05626771f, -0.05309771f, -0.03300320f, 0.00689816f, 0.05127997f, 0.03093319f, 0.03807653f, 
    -0.06945319f, -0.04191644f, -0.00380866f, 0.04227275f, -0.05836857f, 0.00992829f, -0.01811599f, -0.06797324f, 
    -0.03824836f, -0.07706329f, -0.06146076f, 0.03999405f, -0.05648518f, -0.07845546f, 0.03768765f, -0.02537193f, 
    0.02449326f, 0.03526930f, 0.00906434f, -0.05217466f, 0.06118945f, -0.03609284f, -0.00167522f, -0.06374022f, 
    -0.02601686f, 0.00400439f, -0.04776401f, 0.03188338f, -0.00240580f, 0.00500798f, -0.02883484f, -0.04454551f, 
    0.03713020f, -0.00600458f, -0.06966251f, 0.00302652f, 0.04553960f, -0.02473132f, 0.01599544f, -0.04444762f, 
    -0.06296691f, 0.04971279f, -0.00827119f, -0.07108543f, -0.07227422f, -0.00789174f, 0.00570731f, 0.01341666f, 
    0.01451157f, -0.04785237f, -0.00652582f, -0.02313778f, -0.06799877f, -0.03233969f, -0.05832780f, -0.00786811f, 
    -0.04997075f, -0.01868198f, -0.07339480f, -0.01474251f, -0.05653265f, -0.05171700f, 0.02692636f, 0.01447176f, 
    -0.00719473f, 0.06507185f, -0.00202048f, -0.02256491f, -0.05724325f, 0.00161607f, 0.05471246f, 0.05525572f, 
    -0.01526730f, 0.01428866f, -0.02595718f, -0.04731477f, 0.05544009f, -0.05555587f, -0.02059032f, -0.07037641f, 
    0.35228509f, 0.11417440f, 0.05019623f, 0.07558347f, 0.05728728f, -0.09707524f, 0.01373324f, -0.08680516f, 
    0.06648496f, -0.02719319f, -0.07729581f, 0.03330356f, 0.07480081f, -0.12450270f, -0.24717149f, 0.05112967f, 
    -0.02398085f, -0.00496485f, -0.09013913f, -0.03190202f, 0.08958420f, -0.06239656f, 0.05559909f, -0.09396967f, 
    -0.10496922f, -0.21065365f, -0.12604567f, 0.26962179f, 0.11265128f, 0.14074907f, -0.08069657f, -0.09870920f, 
    -0.14230148f, -0.06092242f, -0.01399810f, 0.01418146f, 0.09679316f, 0.05595190f, 0.08655186f, 0.08486367f, 
    -0.00545889f, 0.08888595f, 0.01308063f, 0.00823033f, -0.05105735f, 0.00415272f, 0.08765006f, -0.10195753f, 
    0.08312695f, -0.00988983f, -0.05750458f, 0.16998225f, -0.05913016f, -0.01081296f, -0.03620514f, 0.12384711f, 
    -0.02667904f, 0.06804024f, 0.02705267f, -0.00341484f, 0.11902395f, 0.01514740f, -0.05471814f, -0.04103303f, 
    0.08148130f, 0.13984819f, 0.17430536f, 0.03060662f, -0.07116359f, 0.01978400f, -0.12160392f, -0.05536485f, 
    -0.19147436f, -0.07155313f, 0.09434370f, -0.23946495f, 0.01889375f, -0.01996619f, 0.04679226f, 0.00470878f, 
    -0.09179105f, 0.06752231f, 0.09286480f, -0.06431114f, -0.02502494f, -0.02034009f, 0.09659337f, -0.13280135f, 
    -0.01327176f, -0.16093303f, 0.04407421f, -0.10849860f, 0.15015936f, -0.08640183f, -0.06230395f, -0.09668518f, 
    0.02131154f, -0.02576549f, -0.21608624f, 0.02544438f, -0.02936017f, 0.11881421f, -0.05350795f, -0.05770042f, 
    0.13025537f, -0.00922315f, 0.01686099f, -0.04443416f, 0.07258196f, -0.19204508f, -0.06848276f, 0.12325226f, 
    -0.03984678f, -0.08549281f, 0.08701912f, 0.07029002f, 0.01088964f, 0.04770252f, 0.06499413f, 0.01313933f, 
    0.20325308f, 0.01356514f, 0.20317505f, 0.26068169f, 0.15894529f, 0.12969777f, 0.04200553f, 0.11821043f, 
    0.10611834f, -0.00065934f, -0.04185186f, 0.01471749f, -0.11568220f, -0.07772226f, 0.06976295f, 0.26712281f, 
    0.01041247f, -0.07210666f, 0.07232442f, -0.04473610f, -0.08897517f, 0.02456342f, 0.05236119f, -0.00489567f, 
    -0.11213285f, 0.38844106f, 0.23208152f, 0.14007278f, 0.01544151f, -0.05264217f, 0.03044450f, 0.17004405f, 
    0.09927593f, -0.03189055f, 0.05853501f, -0.01298568f, 0.11096328f, 0.00822312f, 0.00143559f, -0.24886967f, 
    0.02543489f, 0.06688161f, -0.07781377f, 0.10728428f, 0.04451703f, 0.00840730f, -0.17111884f, 0.05936099f, 
    0.03134366f, -0.10273002f, 0.03248981f, 0.22257532f, -0.03427515f, 0.07221323f, 0.05544154f, -0.12210339f, 
    0.03244284f, 0.09243058f, -0.08808278f, 0.10567287f, 0.27881062f, 0.17219076f, 0.04245371f, 0.13071784f, 
    0.19442321f, 0.00082104f, 0.12432112f, 0.00528485f, 0.00754147f, 0.00972340f, 0.01415410f, -0.05185021f, 
    -0.16248278f, -0.24051823f, -0.00620870f, 0.14025939f, 0.04820457f, 0.06649728f, 0.21346807f, -0.13170157f, 
    0.06884617f, 0.11646757f, 0.02971192f, -0.03102625f, -0.12961432f, -0.11999267f, 0.15234315f, 0.23436517f, 
    -0.02185619f, 0.13797368f, -0.16397084f, 0.03977804f, -0.04816740f, -0.08987867f, 0.07379934f, 0.01757224f, 
    0.18105203f, 0.12245084f, -0.21707998f, 0.28906104f, -0.08394632f, 0.08260250f, -0.02246626f, 0.08756784f, 
    0.01372973f, 0.02985539f, -0.10630448f, -0.14867832f, 0.07737161f, 0.01195773f, 0.06377909f, 0.15872243f, 
    -0.11632896f, 0.02924703f, 0.13688681f, 0.04506176f, 0.12727629f, 0.05071682f, -0.00110170f, 0.02395232f, 
    0.27437258f, -0.04085696f, 0.02986770f, 0.16966285f, 0.09523237f, 0.03744256f, 0.01028567f, 0.14684106f, 
    -0.00079560f, 0.06878904f, 0.03121799f, 0.13680746f, 0.10220017f, 0.09017548f, 0.23786794f, -0.03555989f, 
    -0.02318382f, 0.08292883f, 0.02159503f, 0.08452904f, -0.05267433f, 0.31415513f, 0.14758237f, 0.01885955f, 
    0.38299471f, 0.08264916f, -0.09470575f, 0.14550965f, -0.00060259f, -0.01408137f, 0.06440584f, -0.03102072f, 
    0.15274398f, 0.03369364f, 0.04418616f, 0.02688245f, 0.00946585f, -0.23575659f, -0.13173233f, -0.06279895f, 
    -0.17818682f, 0.13876206f, 0.00289655f, -0.12294257f, 0.08420498f, 0.04764220f, 0.09247593f, -0.05390277f, 
    -0.29931659f, 0.04229854f, 0.13953367f, -0.02923283f, 0.01619873f, 0.05702697f, 0.05691619f, -0.10892028f, 
    -0.04748422f, -0.15820903f, -0.15586963f, 0.04176578f, -0.19854861f, -0.10635088f, 0.13638677f, 0.26588324f, 
    0.05131174f, 0.09682861f, 0.00928259f, -0.09970380f, 0.04150951f, 0.06847803f, -0.02913903f, -0.10525552f, 
    0.17366672f, -0.02316805f, 0.14545739f, -0.21042904f, -0.13317676f, -0.19173624f, -0.13095903f, 0.03107516f, 
    -0.14652354f, 0.04017108f, -0.04886927f, 0.11568329f, 0.02002589f, -0.04802526f, -0.06458026f, -0.01362435f, 
    0.11223919f, 0.05880595f, -0.15638912f, 0.01010224f, 0.02577169f, -0.09308843f, -0.08926199f, -0.21300155f, 
    0.18414061f, -0.00753406f, 0.27911997f, -0.06624087f, -0.01643863f, -0.09824707f, -0.06974026f, 0.15074988f, 
    -0.08514909f, -0.01887970f, -0.01368343f, 0.22647613f, 0.01934126f, 0.04120869f, 0.06250061f, -0.05449275f, 
    -0.05427564f, -0.15577570f, -0.05111277f, -0.19963056f, -0.01833335f, 0.10429775f, 0.07214300f, -0.03653035f, 
    0.09872941f, -0.20873663f, -0.00196705f, 0.08748889f, -0.04198454f, -0.09581371f, -0.00069076f, -0.04112204f, 
    -0.00520307f, -0.20667143f, 0.16639395f, -0.19852418f, 0.18757319f, 0.08028783f, 0.16574852f, -0.10482895f, 
    -0.10919002f, 0.02456489f, 0.14273311f, 0.04222601f, 0.02493152f, 0.16451897f, 0.02490248f, 0.03160921f, 
    0.09117503f, 0.24526463f, -0.03862690f, 0.08157270f, 0.12643035f, 0.07760520f, -0.08504921f, -0.01826534f, 
    0.04353300f, 0.19148540f, -0.01980418f, -0.01881806f, -0.05076668f, -0.13257971f, -0.22261672f, 0.24341704f, 
    0.04707747f, -0.00119871f, 0.06149051f, -0.04914789f, -0.00585714f, 0.07596710f, 0.12255146f, 0.04934037f, 
    0.02979525f, -0.11215615f, -0.13840327f, -0.04066539f, -0.12491603f, -0.13725424f, -0.03258018f, 0.05215880f, 
    -0.04450439f, -0.03598309f, -0.01944047f, -0.02630419f, -0.02671561f, -0.27977446f, 0.10007363f, -0.10829367f, 
    -0.03104899f, 0.11138759f, -0.05594536f, 0.05566072f, -0.08218566f, -0.00488153f, 0.12806052f, -0.09337845f, 
    -0.30945036f, -0.08161054f, -0.03153964f, 0.05527962f, -0.07463859f, 0.06301969f, 0.04459202f, 0.04924932f, 
    -0.06970977f, -0.00711130f, -0.04654871f, -0.08934087f, -0.17984842f, -0.13127096f, -0.11098453f, 0.10893486f, 
    0.02559778f, 0.00560013f, -0.03921523f, 0.07884193f, 0.05527895f, -0.07370286f, 0.02807067f, -0.12439544f, 
    -0.20701253f, 0.28875011f, 0.12833874f, -0.02646395f, 0.03991578f, -0.12253894f, 0.01402718f, -0.07480848f, 
    0.05169158f, 0.00495953f, 0.15745604f, -0.01143961f, -0.07784277f, -0.01241019f, 0.34175983f, 0.02295621f, 
    -0.01229840f, -0.06501237f, 0.03856352f, 0.04602614f, 0.00384099f, -0.03135417f, 0.11493102f, 0.08545291f, 
    0.04677550f, 0.09896253f, -0.12242099f, -0.06180751f, -0.04146552f, 0.14586814f, -0.07769946f, 0.02686543f, 
    0.00391952f, -0.15083183f, 0.14771043f, 0.07522196f, -0.02072191f, -0.10850975f, 0.00485495f, 0.08055133f, 
    -0.05774243f, -0.03053607f, 0.08911632f, 0.10901438f, 0.11239130f, 0.12735429f, 0.03884642f, -0.01624231f, 
    0.04513649f, -0.01561246f, -0.13998878f, -0.03334411f, 0.08401728f, 0.08120701f, -0.05606981f, -0.00114539f, 
    0.07531998f, 0.05773470f, -0.08587032f, 0.10499632f, 0.22120380f, -0.03161942f, 0.17129073f, -0.33914319f, 
    0.08639927f, 0.08526794f, 0.04829580f, 0.06813192f, 0.06875762f, 0.08166353f, 0.07788628f, 0.17938149f, 
    0.50543547f, 0.34629700f, 0.13038656f, 0.01133075f, 0.04598802f, 0.00566271f, -0.09166060f, 0.06903606f, 
    0.00252712f, -0.00501295f, -0.00788260f, -0.07111949f, -0.07540117f, -0.28924602f, -0.17474328f, 0.31465879f, 
    0.01190035f, 0.08676187f, -0.11400840f, -0.01348392f, 0.02225265f, 0.09131531f, -0.05459342f, 0.16712022f, 
    -0.06255365f, 0.04480166f, -0.24062639f, -0.09439687f, 0.03008334f, 0.00921456f, -0.00828838f, -0.03626037f, 
    0.08098850f, 0.06922549f, -0.08963466f, 0.18554142f, 0.09537483f, -0.12821496f, 0.18216287f, -0.49584791f, 
    0.01769135f, -0.06156171f, 0.01281886f, 0.04198731f, 0.06089222f, -0.01852271f, -0.02230560f, -0.08842403f, 
    -0.21503118f, -0.09035771f, 0.00693940f, -0.09012991f, -0.03925084f, 0.00514226f, -0.07620712f, -0.02401060f, 
    -0.03499008f, 0.09764020f, 0.02448072f, 0.06463619f, 0.08502383f, -0.09315815f, 0.10650959f, 0.37498090f, 
    0.05127517f, 0.03259142f, -0.10124733f, -0.01610060f, 0.10181166f, -0.01558790f, 0.07116732f, -0.05324047f, 
    -0.24517494f, -0.03595325f, -0.18205093f, 0.12352104f, -0.16191269f, 0.04379240f, 0.03358941f, 0.10672383f, 
    -0.00358262f, -0.00119707f, -0.02508969f, 0.08099350f, 0.17106546f, 0.02327020f, 0.06991212f, 0.15150847f, 
    -0.06883308f, 0.01947498f, 0.10973187f, -0.03416999f, 0.11134246f, -0.02940003f, -0.12550576f, -0.11563690f, 
    0.11272774f, -0.00985695f, 0.11269971f, 0.26219222f, 0.03893374f, 0.01731976f, 0.00803346f, 0.15239842f, 
    -0.03096304f, -0.02942873f, 0.20251836f, 0.03460693f, -0.04332994f, 0.03693416f, 0.09785087f, 0.14067344f, 
    0.00352155f, 0.16729978f, -0.01410196f, 0.12597202f, -0.00647502f, 0.16298665f, -0.02773418f, -0.02343331f, 
    0.08702769f, 0.15423153f, -0.04340829f, -0.01161131f, 0.00639937f, 0.04807393f, -0.01249871f, -0.02611144f, 
    -0.00987028f, 0.06794342f, 0.01683199f, -0.00728278f, -0.18908733f, -0.02956141f, 0.00149203f, 0.07355104f, 
    -0.18841325f, 0.16946150f, 0.11678772f, -0.06229325f, 0.09702276f, -0.11910582f, 0.01907162f, -0.11264993f, 
    -0.41504896f, 0.03599630f, 0.09982784f, 0.06831146f, -0.00554038f, -0.02037604f, -0.05899141f, 0.01939196f, 
    -0.04629278f, -0.01519945f, 0.07480515f, -0.00430603f, -0.01049669f, 0.01129519f, 0.15815584f, 0.22599719f, 
    0.00724299f, 0.08956202f, 0.04441524f, -0.02857975f, 0.08634079f, 0.09142732f, -0.01810890f, 0.00056183f, 
    0.17994985f, -0.19984980f, 0.09181851f, -0.16467969f, -0.01946754f, 0.00072480f, 0.00564527f, 0.09372316f, 
    -0.06044666f, -0.01020343f, -0.08430868f, 0.03823375f, 0.20882964f, -0.07048252f, 0.09291500f, -0.08188729f, 
    -0.01540339f, 0.05699267f, -0.05891681f, 0.02840435f, 0.09955114f, -0.01557284f, 0.03733459f, 0.03689476f, 
    0.18255563f, 0.17772001f, 0.07943772f, -0.05896789f, 0.05041048f, -0.04848105f, 0.06842109f, 0.02180573f, 
    -0.07781027f, -0.14911023f, -0.05150841f, -0.02121688f, -0.16889785f, 0.00713813f, 0.10429011f, 0.11598790f, 
    -0.09858800f, -0.08989689f, -0.12600975f, -0.06382955f, -0.05694848f, 0.06306141f, 0.11371246f, 0.12008351f, 
    -0.23024581f, 0.02626945f, -0.11151225f, -0.06504333f, -0.11891775f, -0.11821821f, 0.00408019f, -0.02090230f, 
    0.14270140f, -0.05248596f, 0.06659203f, -0.14120993f, 0.10301366f, 0.00748315f, 0.06743769f, -0.17284364f, 
    0.00689233f, 0.17436567f, 0.07919809f, -0.02419373f, 0.07362512f, -0.08049774f, 0.01271680f, 0.11388116f, 
    0.05654875f, -0.00783012f, -0.07879993f, -0.07844280f, -0.01023599f, -0.08149394f, -0.05138133f, 0.04680017f, 
    0.02334846f, -0.01361892f, 0.04022979f, -0.02343933f, -0.04159460f, -0.07455873f, -0.01405296f, 0.01027209f, 
    0.02380815f, -0.01767813f, 0.00557844f, 0.00863027f, -0.04542826f, -0.03792835f, 0.03839174f, -0.04615047f, 
    -0.03932345f, -0.03518981f, -0.03542048f, 0.03260622f, 0.05559739f, 0.02757399f, -0.04934571f, 0.01201325f, 
    0.04165908f, 0.03785237f, -0.02256486f, -0.03528076f, -0.01457979f, 0.03069429f, -0.06148172f, 0.00504956f, 
    0.03292047f, -0.05309281f, 0.01301235f, -0.03950594f, 0.04903995f, 0.01355986f, -0.03969666f, 0.02781635f, 
    -0.07309195f, -0.03207477f, 0.03822323f, -0.06796759f, -0.00620672f, -0.04327438f, -0.03997880f, -0.04823599f, 
    -0.04164441f, 0.00035314f, 0.01661698f, -0.02593753f, 0.02000112f, 0.00102891f, -0.01931695f, 0.02712341f, 
    -0.03118793f, 0.01577113f, 0.03132830f, 0.05286094f, 0.03232579f, -0.01245204f, 0.00763611f, -0.00353619f, 
    0.04979279f, -0.06168881f, -0.05294777f, 0.05675070f, -0.06048380f, 0.02928459f, 0.02033072f, -0.05741527f, 
    -0.05465032f, -0.00528663f, -0.01045985f, 0.05388821f, 0.01245118f, -0.05145484f, 0.01292982f, -0.00816581f, 
    -0.04588991f, 0.03825159f, 0.00057004f, 0.01892281f, 0.02259213f, -0.06583388f, -0.01808095f, -0.01759073f, 
    -0.03244879f, 0.03542078f, -0.04338814f, -0.01040748f, -0.06408928f, -0.03341599f, -0.03113123f, -0.01127429f, 
    -0.02705751f, -0.04898356f, -0.06404760f, 0.05501347f, 0.04247394f, -0.05158639f, 0.00544772f, -0.03109703f, 
    -0.03445880f, -0.00587275f, -0.01036499f, -0.07263723f, 0.00288893f, -0.01983242f, -0.04221788f, 0.06243292f, 
    -0.07537196f, -0.04572429f, -0.07493655f, -0.06806616f, -0.06681202f, 0.04409888f, 0.05630995f, -0.06431384f, 
    -0.03527606f, -0.03567791f, -0.04756242f, 0.03624669f, -0.02232000f, -0.00234810f, 0.00472469f, -0.07050705f, 
    -0.00876120f, 0.05287314f, 0.04866986f, 0.06097382f, 0.03076868f, 0.05061123f, 0.06011582f, -0.06734861f, 
    -0.03514427f, -0.03371015f, -0.03672684f, -0.00995516f, -0.05536286f, -0.00754780f, -0.03643392f, 0.02740183f, 
    -0.04430631f, 0.00067687f, 0.04922846f, 0.05766913f, 0.01147442f, 0.04971564f, 0.00565452f, -0.08129278f, 
    -0.05117679f, -0.05803746f, -0.02325412f, -0.01497652f, -0.02131136f, 0.04971470f, 0.00883973f, 0.04387531f, 
    0.03900091f, 0.00216902f, -0.02148721f, 0.04151724f, -0.00206315f, -0.03695839f, -0.00854281f, -0.04688388f, 
    -0.07326237f, -0.05451995f, 0.06216139f, 0.04993725f, 0.04402950f, 0.02821798f, -0.02298765f, 0.00242875f, 
    -0.06728322f, 0.01232299f, 0.04949929f, -0.02302860f, -0.06988166f, -0.04968420f, -0.03686750f, -0.07836903f, 
    0.19625339f, 0.20151612f, -0.22163269f, 0.17719196f, 0.13613382f, -0.02044421f, -0.00475858f, -0.06594937f, 
    -0.01004816f, 0.01812499f, 0.15609440f, -0.00192585f, 0.02633415f, 0.08307680f, -0.03325611f, 0.00434106f, 
    -0.08539972f, 0.05057503f, 0.18168649f, 0.03778860f, 0.05850403f, 0.14084919f, 0.04606103f, -0.03808732f, 
    -0.30986422f, -0.12615325f, 0.11105465f, -0.26417872f, 0.10983844f, -0.01024521f, -0.24269885f, 0.01784080f, 
    -0.05081802f, -0.05520323f, 0.00834476f, -0.04493431f, 0.20976521f, 0.10381140f, 0.07060836f, -0.01426428f, 
    -0.00973357f, 0.18105675f, 0.05916156f, 0.05998587f, -0.05160223f, -0.01903130f, -0.00016462f, -0.17703983f, 
    -0.50746244f, 0.05650930f, -0.15073767f, 0.11222972f, -0.03074989f, -0.10295558f, 0.04149375f, -0.17196164f, 
    -0.00760850f, 0.00974636f, 0.03578926f, 0.02163531f, 0.02890987f, -0.13815071f, 0.00635634f, -0.04232176f, 
    0.06419533f, 0.04553829f, 0.14591739f, -0.01673417f, -0.02628290f, -0.06078593f, -0.04638055f, -0.00204850f, 
    -0.36241832f, 0.21683060f, -0.13810293f, -0.03856916f, 0.09182727f, -0.12939867f, 0.04832261f, -0.01777431f, 
    0.07529909f, -0.05879863f, 0.06430598f, -0.10902630f, -0.10677135f, 0.07305572f, 0.30671620f, -0.22554865f, 
    0.07496815f, -0.05527326f, -0.13141771f, -0.14810233f, 0.07692111f, -0.08227167f, 0.09791646f, 0.06020024f, 
    0.33685103f, -0.06349545f, -0.05609875f, -0.05141366f, -0.00341383f, -0.01512290f, -0.06875776f, 0.05651176f, 
    -0.12655894f, -0.03280844f, 0.07116665f, -0.06467259f, -0.07188203f, 0.03673697f, -0.16147363f, -0.07153224f, 
    0.00249837f, -0.12294772f, 0.12406825f, 0.03535361f, -0.03575416f, 0.01546830f, 0.05066884f, -0.05182600f, 
    -0.00269345f, 0.17853327f, 0.03980510f, 0.22181451f, 0.08002588f, 0.15740368f, 0.11718665f, -0.07903412f, 
    -0.06629114f, -0.04531233f, -0.04331607f, -0.07295410f, 0.12839583f, 0.01973595f, -0.22724104f, 0.03556412f, 
    -0.03407514f, -0.04480240f, -0.07841028f, 0.01287500f, 0.11483751f, 0.03876561f, 0.03029495f, 0.00326975f, 
    0.12138709f, 0.17075826f, 0.29227015f, 0.30770087f, 0.03923267f, 0.03211361f, 0.01585841f, 0.03326814f, 
    0.02268704f, 0.09846537f, -0.02976926f, -0.06983043f, 0.04975842f, 0.15180245f, -0.15606293f, -0.02798602f, 
    0.12499060f, -0.00613931f, -0.05030818f, 0.04536311f, -0.03533893f, 0.11015467f, -0.08409055f, 0.19252256f, 
    -0.14408144f, 0.08111674f, -0.24174970f, -0.13456079f, 0.07455603f, 0.01646376f, -0.02238267f, 0.01663123f, 
    0.04865672f, -0.00791799f, -0.04108402f, 0.19045748f, -0.03745889f, 0.16471797f, 0.30098307f, 0.16748641f, 
    0.01080957f, -0.04864184f, 0.08399079f, 0.13029212f, -0.05053756f, -0.09697884f, 0.05416904f, -0.03660961f, 
    0.04416742f, -0.18728638f, -0.20080590f, 0.00760576f, -0.03917723f, -0.03009906f, 0.11831187f, -0.01499840f, 
    0.12142235f, -0.03366415f, 0.04021293f, 0.01025387f, -0.10020533f, 0.15758684f, -0.01196993f, -0.03543746f, 
    0.00125934f, -0.03577464f, -0.12643239f, 0.07552809f, 0.02957682f, 0.15558903f, 0.04292919f, -0.04274457f, 
    0.06118600f, -0.14286418f, -0.00150746f, -0.14289838f, 0.23106487f, 0.01673408f, -0.11535381f, -0.00717644f, 
    -0.01434626f, 0.06471279f, 0.03885576f, 0.14362860f, 0.10457510f, 0.02138643f, -0.02687465f, 0.01718960f, 
    -0.15541852f, -0.12107368f, -0.02530299f, -0.13059542f, -0.04376043f, -0.06298386f, -0.00225558f, 0.06653707f, 
    0.03299329f, 0.00069432f, -0.04110606f, 0.11261742f, 0.10298195f, -0.05642653f, -0.04447028f, -0.02316004f, 
    0.27962181f, -0.07089125f, -0.01780510f, 0.05648277f, 0.05465978f, 0.11274073f, 0.08474671f, -0.14052190f, 
    -0.06107226f, 0.05985812f, 0.12094614f, -0.06128307f, -0.06226525f, 0.06814806f, -0.07846204f, 0.12689395f, 
    0.18118399f, -0.15674518f, -0.01335321f, 0.01794139f, -0.06714290f, -0.02838624f, 0.05797819f, 0.07222801f, 
    0.07197601f, -0.06444851f, 0.10752082f, 0.10638512f, 0.23425955f, -0.00369904f, -0.07813127f, -0.18762475f, 
    0.13761294f, -0.05349034f, 0.07196985f, 0.02381233f, 0.15752538f, 0.20284052f, 0.05884282f, 0.08836151f, 
    -0.13666864f, -0.01522091f, 0.09503522f, 0.09392919f, -0.05459647f, -0.12080111f, -0.03161246f, 0.08326241f, 
    0.07069537f, 0.18558587f, 0.01019949f, 0.00247925f, 0.04835462f, 0.05056142f, -0.06212452f, 0.03763879f, 
    0.17795101f, -0.10191279f, 0.00590438f, -0.04671568f, 0.05069356f, -0.03096435f, 0.05511579f, 0.13860968f, 
    0.08081225f, 0.01404862f, -0.01926519f, -0.04688541f, -0.09267961f, -0.09784123f, 0.01368161f, 0.04360530f, 
    -0.02183751f, 0.03189981f, 0.09490813f, -0.06788701f, -0.14343396f, 0.04745115f, -0.19614574f, 0.38550502f, 
    -0.01273281f, -0.09806027f, 0.11523332f, 0.09039815f, -0.10017985f, 0.07472969f, 0.08835416f, 0.00527508f, 
    -0.42257109f, -0.09006434f, -0.14473763f, -0.00893167f, -0.12492731f, 0.01133782f, -0.04242539f, -0.05056336f, 
    0.06170255f, 0.03364258f, 0.05915743f, 0.00706764f, -0.36011726f, 0.22447659f, 0.05590158f, -0.13985085f, 
    0.20221907f, -0.04966753f, 0.02805824f, 0.09703384f, -0.03126903f, -0.05578262f, -0.06492086f, 0.04268188f, 
    0.17791629f, -0.12853974f, 0.17078914f, 0.00047742f, 0.03479645f, -0.00834898f, -0.07141398f, -0.00944481f, 
    0.06454231f, 0.09297305f, 0.09344588f, 0.06328916f, 0.12980646f, -0.05234959f, -0.16706395f, 0.20171069f, 
    0.03236404f, -0.03766045f, -0.08718906f, -0.09771188f, 0.06097333f, 0.04481095f, -0.04315307f, 0.02922810f, 
    0.09947570f, 0.06001264f, -0.24190907f, -0.00078102f, 0.08443420f, -0.05485107f, -0.10307360f, -0.01774624f, 
    0.11613039f, -0.00733282f, 0.07921480f, -0.10910243f, -0.18458652f, 0.18677229f, -0.03271152f, 0.02092513f, 
    0.03006118f, -0.08169907f, 0.10116701f, 0.11998252f, 0.00746725f, 0.05736563f, -0.09898801f, -0.06747799f, 
    0.28682733f, -0.28737354f, 0.06573823f, 0.08076677f, 0.07071032f, -0.06592555f, -0.08168370f, -0.06699812f, 
    0.03061564f, -0.06987749f, 0.12469561f, -0.02427895f, 0.20351693f, -0.08504631f, 0.03527811f, -0.14983457f, 
    0.05482338f, 0.10233591f, -0.07070065f, -0.08996525f, 0.06091402f, -0.01466116f, 0.05185453f, 0.14174917f, 
    -0.16927887f, -0.05906633f, 0.05754985f, 0.17440341f, 0.06739485f, -0.05602935f, 0.02893628f, -0.16410419f, 
    0.23738103f, 0.00088129f, 0.12092282f, 0.13937819f, -0.23885766f, 0.12245606f, 0.03172221f, -0.19547954f, 
    0.00388808f, 0.03732512f, 0.08360533f, 0.00767835f, -0.07056368f, 0.08153374f, -0.01294886f, 0.16237225f, 
    0.29022107f, 0.08781035f, -0.07411111f, 0.18301414f, -0.08534199f, 0.06859934f, -0.03109812f, -0.03081479f, 
    0.04825307f, 0.00711442f, 0.12726785f, -0.08080143f, 0.48348624f, 0.05310567f, -0.15986343f, -0.15118003f, 
    0.09972323f, -0.01968269f, -0.17702271f, -0.02581946f, 0.14011692f, 0.11750075f, 0.03253141f, 0.11330672f, 
    0.01558944f, 0.01416678f, -0.00981937f, 0.17993751f, -0.15365531f, -0.04807378f, -0.09976500f, -0.00295801f, 
    0.03926226f, 0.02145910f, 0.00333061f, 0.11608895f, -0.14793819f, 0.07422672f, -0.04381286f, -0.00249630f, 
    0.18183880f, -0.01784135f, -0.00034010f, 0.11158288f, 0.06154726f, 0.07024534f, 0.08930708f, 0.01054416f, 
    0.02365310f, 0.18066157f, 0.06859310f, -0.11110142f, 0.04640316f, 0.02064579f, -0.01672683f, 0.03432272f, 
    0.01154066f, 0.02348921f, 0.06137871f, -0.03466058f, 0.15590231f, -0.00864277f, -0.05638560f, 0.30658388f, 
    0.05857734f, 0.08062486f, 0.09329228f, 0.03718581f, 0.00399024f, 0.17311633f, 0.01030468f, 0.04027399f, 
    -0.35602272f, -0.04786421f, -0.17045316f, 0.10019652f, -0.06749192f, 0.01899054f, 0.00690144f, 0.05140381f, 
    -0.09286895f, 0.07862313f, 0.03673360f, -0.06001343f, -0.37058690f, 0.05052111f, -0.00986976f, 0.13589872f, 
    0.11862909f, -0.03038595f, 0.11500731f, 0.13547719f, -0.10219723f, -0.06940959f, -0.12047809f, 0.14966764f, 
    0.19194137f, -0.14026251f, 0.18887566f, 0.04052307f, -0.08665919f, 0.13315450f, 0.06842571f, -0.08507839f, 
    -0.00775681f, 0.08513794f, 0.04720291f, 0.05215863f, 0.09610081f, -0.02101449f, 0.03179807f, -0.10469002f, 
    -0.05891547f, -0.00401661f, 0.04106710f, -0.00694886f, 0.08317019f, -0.01139473f, -0.03628232f, -0.01794933f, 
    -0.00079437f, 0.01208632f, -0.02493421f, -0.04607940f, -0.06710285f, -0.02662721f, -0.02891942f, -0.05719283f, 
    -0.01766935f, -0.06342187f, -0.00161731f, 0.02547553f, -0.03533812f, -0.04174766f, 0.02389756f, -0.00095426f, 
    0.05241622f, 0.00411076f, -0.05843808f, 0.05754647f, 0.01631115f, 0.02827616f, -0.03804189f, -0.07482459f, 
    -0.00267415f, -0.04148293f, -0.02809853f, -0.00230360f, -0.04561463f, 0.04873228f, 0.03462280f, 0.01296933f, 
    0.01523038f, -0.04868024f, -0.04105621f, -0.04811360f, -0.01913140f, -0.05167251f, -0.09947145f, 0.01643980f, 
    -0.00115023f, 0.04382775f, 0.05743802f, -0.03970568f, 0.02354568f, -0.08742622f, -0.02677400f, -0.10151372f, 
    -0.01377128f, -0.00468130f, -0.08529720f, 0.02763144f, 0.02502026f, 0.05873310f, 0.02773927f, 0.04929270f, 
    -0.09042299f, -0.01964650f, 0.02480334f, -0.08849870f, -0.02878600f, -0.04679761f, -0.08109553f, -0.03435799f, 
    -0.08038909f, -0.02341798f, 0.01292785f, 0.04420909f, 0.03313560f, -0.04537158f, -0.03931032f, 0.00285637f, 
    0.04068456f, 0.03852960f, 0.03154779f, -0.08527782f, 0.00989529f, 0.02220253f, 0.01429906f, 0.02747248f, 
    -0.00306967f, 0.01142481f, -0.03742319f, 0.05269565f, -0.06267349f, 0.03667760f, 0.05033533f, 0.01755187f, 
    -0.02017712f, 0.00602529f, 0.00740359f, -0.04964861f, -0.07439975f, 0.01748656f, -0.00774204f, 0.01232937f, 
    0.02510553f, -0.02143262f, -0.02704050f, -0.02338842f, -0.00557392f, 0.06832572f, -0.06709499f, 0.01290200f, 
    -0.00523441f, -0.04623977f, 0.07769915f, -0.01313182f, 0.08780149f, 0.01609297f, 0.04328035f, 0.03845942f, 
    -0.08072035f, -0.03615674f, -0.02299094f, -0.02366599f, 0.01338096f, 0.03680190f, -0.01710647f, -0.01032295f, 
    -0.06868792f, -0.05914434f, 0.00187292f, 0.03191909f, 0.03187709f, -0.03170424f, -0.00350860f, -0.02811319f, 
    -0.02882433f, 0.05745417f, 0.01457873f, -0.01864446f, -0.04496672f, 0.05100502f, 0.01925677f, 0.00114298f, 
    -0.04454380f, -0.07183791f, -0.04006522f, -0.06026887f, 0.00504408f, -0.02963076f, -0.06019382f, -0.00520425f, 
    0.02075825f, 0.10225483f, 0.05104408f, -0.03769150f, 0.03069603f, 0.00887663f, 0.02228473f, -0.07131344f, 
    -0.00344723f, 0.03536392f, -0.06726367f, -0.01234643f, 0.00999111f, -0.04371508f, -0.07804949f, -0.04178928f, 
    -0.04867518f, -0.00102544f, -0.03796386f, -0.00893992f, -0.01490228f, 0.05226532f, 0.05228363f, -0.08049742f, 
    -0.02257430f, 0.02599432f, -0.07181837f, 0.08138639f, -0.01789611f, -0.09106996f, -0.02245720f, -0.06115522f, 
    0.02025259f, 0.00905326f, 0.02087900f, -0.02281643f, 0.07368430f, -0.00037645f, -0.04817081f, -0.02008100f, 
    -0.03032008f, -0.10103119f, 0.02949798f, -0.02941011f, -0.00981694f, 0.05238615f, 0.04254734f, -0.07574735f, 
    -0.01539311f, 0.05349063f, 0.15043758f, 0.10424348f, -0.04903578f, 0.02349219f, 0.03080232f, 0.15691057f, 
    0.12183271f, -0.07479099f, 0.05661291f, 0.01796971f, -0.07465843f, 0.08569818f, 0.07635015f, -0.10972930f, 
    -0.08857288f, -0.07098798f, 0.08763599f, -0.01743036f, -0.05594572f, 0.03948602f, -0.08655491f, 0.07811804f, 
    0.24162132f, 0.17751883f, 0.30589184f, -0.10965399f, -0.03311771f, -0.10804535f, 0.14914091f, 0.15979333f, 
    0.02832014f, -0.06111973f, -0.03006012f, -0.13376683f, -0.08057292f, 0.02184269f, -0.00624151f, -0.06385788f, 
    0.14555205f, 0.05582543f, -0.00827821f, 0.11376460f, 0.04280485f, 0.00080126f, 0.06107435f, 0.08239222f, 
    0.07899533f, 0.09023905f, 0.02147842f, -0.06127618f, -0.04487701f, 0.00294321f, -0.06937614f, -0.08438499f, 
    -0.02402080f, 0.03128586f, -0.06096966f, 0.16356406f, 0.08669747f, -0.05126854f, -0.02705090f, 0.03118277f, 
    -0.05261027f, -0.10964798f, -0.09092040f, 0.01526577f, 0.10292961f, -0.02575541f, 0.12059034f, 0.08139404f, 
    -0.12636380f, 0.00189051f, -0.08679213f, 0.01070482f, 0.04661858f, 0.05243585f, -0.13065520f, 0.15479773f, 
    -0.00541958f, -0.00601575f, -0.03649580f, 0.03478956f, 0.24148236f, 0.01143132f, -0.13348748f, -0.05306264f, 
    -0.02801782f, 0.02718171f, 0.04960027f, 0.02368279f, -0.05383343f, 0.05395260f, -0.01065314f, -0.03117824f, 
    0.12809689f, 0.00035233f, 0.11998899f, 0.01017672f, 0.08533397f, 0.01266916f, 0.05494469f, 0.01530307f, 
    -0.04525059f, 0.03657637f, -0.07737596f, 0.05511927f, -0.08155724f, 0.15165773f, -0.01882497f, -0.12454729f, 
    0.08404307f, -0.00398892f, -0.02422999f, 0.03469777f, 0.05835427f, -0.04147025f, -0.08306137f, -0.04414359f, 
    -0.18238638f, 0.08780659f, -0.06534985f, 0.02002154f, 0.06066102f, 0.00733057f, 0.04284157f, -0.04683721f, 
    -0.05339493f, 0.06977449f, 0.06601851f, -0.09967542f, -0.08681418f, 0.17611329f, 0.03153678f, -0.20396802f, 
    -0.09565876f, 0.08036559f, 0.03626626f, 0.08901115f, 0.13911171f, 0.04698840f, -0.09199213f, 0.07548715f, 
    -0.11518672f, -0.13179599f, -0.17074256f, 0.01416174f, 0.15813880f, 0.18594335f, -0.01476491f, -0.14328335f, 
    0.12670764f, 0.10985781f, 0.02509007f, 0.19707227f, 0.13847259f, -0.02562016f, -0.10172666f, 0.10378111f, 
    -0.02455465f, 0.03650712f, -0.00183218f, 0.10969716f, 0.01674898f, -0.00604295f, -0.02536786f, 0.00156038f, 
    0.23232935f, 0.18714939f, 0.13908227f, 0.02055431f, -0.00680701f, 0.11052783f, 0.15434708f, 0.09065781f, 
    -0.10171083f, 0.00098873f, 0.02056250f, -0.03275529f, -0.08232167f, -0.17887621f, -0.05771685f, 0.01229881f, 
    -0.00432917f, 0.07217007f, -0.04494386f, 0.08758795f, -0.00578189f, 0.10237360f, 0.01978760f, -0.02728583f, 
    -0.01989022f, 0.06134712f, -0.06300763f, -0.00171585f, 0.02008564f, -0.02567500f, 0.04169498f, 0.03273199f, 
    -0.01274062f, -0.01131047f, 0.00863681f, 0.00759438f, -0.03328491f, 0.03094472f, -0.03624948f, 0.00582864f, 
    -0.03478427f, 0.03226987f, 0.03721339f, 0.01448070f, -0.05032701f, 0.00753385f, 0.00436063f, -0.03890284f, 
    -0.04239859f, -0.07430568f, -0.04050626f, 0.04879281f, 0.05471546f, -0.03330335f, -0.08015501f, 0.03604374f, 
    0.05592978f, -0.01042352f, 0.00876077f, -0.03540709f, 0.00827343f, -0.01604076f, -0.01374026f, -0.04875796f, 
    -0.07099376f, 0.03332715f, -0.01243175f, 0.03237633f, -0.00349879f, 0.01774802f, 0.03491381f, 0.01954746f, 
    -0.04198028f, 0.05955194f, -0.04737558f, -0.04400894f, 0.04756793f, -0.03110042f, -0.07656766f, -0.05488183f, 
    -0.06591956f, -0.02655600f, 0.04828330f, -0.05973891f, 0.04953091f, -0.06193981f, 0.03123732f, -0.07261782f, 
    0.01185666f, 0.04196526f, -0.02530063f, 0.01626029f, -0.03762731f, 0.04200903f, -0.03849491f, 0.03768801f, 
    -0.03910089f, 0.02708388f, 0.03988208f, -0.05389258f, -0.05886214f, 0.00411307f, 0.00464776f, 0.04002057f, 
    -0.06674657f, -0.06924420f, -0.02342799f, 0.02872472f, 0.05872459f, 0.01782158f, -0.01067614f, 0.00483539f, 
    -0.03221136f, -0.05706732f, 0.02887419f, 0.05284292f, -0.04540893f, -0.00309845f, -0.00206806f, 0.05860681f, 
    -0.01717593f, -0.06807682f, 0.04815359f, -0.06863004f, -0.07599839f, 0.05012536f, -0.01649419f, 0.05580444f, 
    -0.02491719f, -0.04616444f, -0.01197091f, 0.03806386f, 0.05096819f, 0.00203124f, -0.05444910f, -0.06794467f, 
    -0.00408030f, 0.01764211f, -0.07452329f, -0.03035957f, -0.02544183f, -0.05977736f, 0.06420904f, 0.06193880f, 
    0.04680842f, -0.04030000f, 0.05165194f, -0.02916870f, 0.00772830f, -0.04154567f, 0.02706889f, -0.07344522f, 
    -0.03289920f, -0.01758058f, 0.02377147f, -0.02558663f, 0.00523423f, -0.01767721f, 0.05470001f, -0.08178531f, 
    -0.04003719f, -0.01266288f, -0.03211267f, 0.00390515f, -0.06215486f, -0.05804041f, 0.01224865f, -0.03288629f, 
    -0.03623005f, 0.04005003f, 0.02405766f, -0.00948208f, 0.00453199f, 0.00784357f, 0.01384666f, -0.04207698f, 
    0.02960517f, 0.03638833f, -0.02533580f, 0.05835098f, -0.00515469f, -0.04298380f, 0.02796957f, 0.01804286f, 
    -0.04928863f, 0.01605085f, 0.03596181f, -0.00801866f, 0.03087831f, -0.02838873f, 0.00040368f, -0.04954805f, 
    -0.04739111f, 0.00913349f, -0.02612954f, -0.04818716f, 0.00162595f, -0.00648400f, -0.06745455f, -0.01011696f, 
    0.04404653f, -0.06292509f, -0.01356434f, -0.04946490f, 0.03166678f, -0.01232455f, 0.02020385f, 0.00793903f, 
    -0.03757289f, 0.00916445f, 0.03177642f, 0.02298326f, 0.01821508f, 0.00768682f, -0.01368688f, -0.07749501f, 
    -0.16444620f, 0.02413432f, -0.20333837f, 0.05712431f, 0.10725247f, 0.04160840f, 0.01331316f, 0.06408064f, 
    0.06688324f, 0.09351049f, 0.14472237f, -0.05336079f, -0.25624645f, 0.16025719f, 0.04390862f, 0.05851397f, 
    -0.05694040f, 0.06989382f, 0.05083915f, -0.03987320f, -0.08087379f, -0.00149688f, 0.02601259f, 0.01413592f, 
    0.04887856f, 0.06254434f, 0.00800787f, -0.33435050f, 0.13754711f, 0.05473062f, -0.13493425f, 0.01580709f, 
    0.10810194f, 0.04327248f, -0.16185156f, -0.04560861f, 0.13740987f, -0.09217268f, -0.03742361f, -0.08027210f, 
    -0.04212427f, -0.02524410f, -0.12459605f, 0.12194644f, -0.00096015f, -0.00295152f, 0.06074492f, 0.01740019f, 
    -0.39349982f, 0.05965747f, -0.15260671f, -0.17975922f, 0.18402664f, 0.07834713f, 0.04458399f, -0.13384736f, 
    0.17526324f, -0.10052113f, 0.00291917f, 0.14119607f, -0.14293987f, -0.09076732f, 0.12580961f, 0.06054622f, 
    -0.03669694f, -0.02044064f, 0.02116544f, 0.08831456f, 0.00879747f, 0.07932259f, 0.13202113f, -0.01124904f, 
    0.00528746f, 0.27180022f, 0.13789552f, 0.34954834f, 0.02118870f, -0.00584777f, 0.05365095f, -0.03462562f, 
    0.14194570f, 0.09722471f, -0.06803642f, -0.01247675f, 0.38888621f, 0.20438483f, 0.18169056f, -0.07016259f, 
    0.08247195f, -0.00060452f, -0.11981944f, -0.04002725f, -0.07201716f, 0.03244337f, 0.09002434f, 0.07226942f, 
    0.52316034f, -0.12829186f, -0.19121999f, -0.01690404f, -0.04271422f, 0.06609298f, -0.11864270f, -0.05424600f, 
    -0.15649553f, -0.07826971f, 0.03888222f, 0.05294456f, -0.14518097f, 0.10067888f, -0.04231700f, 0.00215419f, 
    0.15260729f, 0.07160025f, 0.03606280f, 0.04311077f, -0.09813518f, 0.05208721f, -0.03175694f, -0.12106665f, 
    -0.18455610f, 0.20701276f, -0.15659755f, -0.06229075f, -0.13303305f, -0.06953296f, -0.00530760f, -0.11111053f, 
    -0.06673132f, -0.06121591f, 0.00373218f, 0.00799909f, 0.07597334f, -0.11078008f, -0.21541683f, -0.04231394f, 
    0.21838962f, 0.06634215f, 0.05941850f, 0.13877062f, 0.03586671f, -0.01251304f, 0.02857454f, 0.05345581f, 
    -0.01975625f, -0.17370872f, -0.05232948f, 0.15782887f, 0.01322898f, 0.03962862f, -0.02754676f, 0.02740162f, 
    0.04176754f, 0.09395891f, 0.01350813f, 0.00607014f, -0.02890844f, 0.06264821f, 0.01029164f, 0.16919976f, 
    0.11455639f, 0.00661581f, 0.11665156f, -0.02846549f, -0.00337573f, 0.07472912f, 0.15193337f, 0.00893354f, 
    0.13460538f, -0.10063057f, -0.23560746f, -0.20890495f, 0.19484836f, 0.08775941f, -0.12079631f, -0.04938997f, 
    -0.10816050f, -0.09383033f, 0.12257384f, -0.04405865f, 0.00129386f, -0.28214726f, 0.10503706f, -0.19188930f, 
    -0.09914083f, -0.08014492f, -0.01253404f, 0.03844510f, 0.03250014f, 0.05166276f, -0.09575096f, -0.05083780f, 
    -0.01059349f, -0.19031709f, -0.00940689f, 0.04636864f, -0.07692397f, -0.09342664f, 0.21447143f, 0.08952962f, 
    0.01672261f, -0.05900266f, 0.01445424f, 0.13193487f, 0.22669719f, -0.00374342f, 0.19373581f, -0.06709278f, 
    -0.00045260f, 0.09919102f, -0.04237406f, 0.02597335f, -0.03413714f, -0.05502874f, 0.03471488f, 0.03195731f, 
    -0.17819430f, 0.18009396f, 0.07758438f, -0.14594817f, 0.05583894f, 0.04244698f, -0.05783161f, 0.07739124f, 
    0.07877166f, 0.05002247f, -0.05007310f, -0.04386413f, -0.03517772f, 0.12742643f, -0.18251570f, -0.03665148f, 
    0.11054207f, 0.02768238f, -0.03321427f, 0.05353074f, -0.02438038f, 0.02673852f, -0.15729281f, -0.08722182f, 
    -0.18769732f, 0.03876362f, -0.08811219f, -0.14844143f, 0.10366945f, 0.06531717f, 0.04386785f, 0.06078027f, 
    -0.00147526f, 0.08759616f, -0.13321497f, 0.01843955f, 0.18426475f, -0.13322766f, 0.02496144f, -0.12130238f, 
    -0.06846993f, -0.02983278f, 0.02629364f, 0.06353240f, -0.05241639f, 0.03894251f, 0.23032306f, -0.05764620f, 
    -0.06610356f, -0.01563373f, 0.01644227f, 0.00661478f, 0.01172447f, -0.05972867f, 0.07779020f, 0.10821524f, 
    0.00952870f, -0.04962600f, -0.01808195f, 0.08168392f, -0.21548907f, -0.00746144f, 0.05093515f, 0.05239274f, 
    0.02644542f, -0.00828096f, 0.02479953f, -0.11944181f, -0.04337521f, 0.04835492f, -0.05575470f, -0.03056738f, 
    0.13608569f, 0.05184037f, 0.03112396f, -0.04984604f, 0.12166893f, 0.02426885f, 0.09904174f, 0.03743189f, 
    -0.08257829f, 0.12015322f, -0.16463704f, -0.04080603f, 0.14172661f, -0.00182127f, -0.06894672f, -0.05379289f, 
    0.10913841f, -0.00005193f, 0.00490380f, -0.02182041f, -0.04568726f, 0.01290869f, 0.01013481f, -0.03725077f, 
    0.05345803f, 0.12656003f, -0.00212490f, 0.08274659f, -0.04745314f, 0.00421435f, 0.00479058f, -0.09942287f, 
    -0.11522830f, -0.10375071f, 0.13944308f, -0.06690039f, -0.08080107f, 0.04194375f, -0.26421627f, 0.04508241f, 
    0.06337336f, -0.06001586f, 0.02577505f, 0.02861641f, -0.05388350f, -0.04617387f, 0.02827750f, -0.05923413f, 
    0.19392638f, -0.01265495f, 0.08014134f, 0.14571223f, -0.10519721f, -0.02162970f, 0.02085676f, 0.06363846f, 
    -0.02513110f, -0.02601161f, 0.06067745f, 0.09794896f, 0.45612386f, 0.12571840f, 0.12884125f, -0.22576232f, 
    -0.03063371f, 0.11124335f, 0.09840552f, -0.06566975f, -0.01173690f, 0.01582706f, 0.15934795f, 0.02150499f, 
    0.06052837f, 0.01036508f, -0.03722756f, -0.06801927f, 0.07387295f, -0.09288012f, -0.00488516f, -0.04410753f, 
    0.04453061f, -0.05982533f, 0.16031154f, -0.08964901f, -0.28984886f, 0.15929991f, 0.09273752f, 0.42050990f, 
    -0.04842414f, -0.09369800f, 0.04015005f, 0.10593984f, -0.07933121f, 0.14311460f, 0.10288202f, 0.05211730f, 
    -0.23084652f, -0.15008406f, -0.07194406f, -0.04402401f, -0.10610091f, -0.02163101f, -0.06927067f, 0.03951011f, 
    -0.07606272f, -0.01800057f, 0.02140819f, 0.04387106f, 0.20085274f, 0.16199306f, 0.02950037f, -0.03369412f, 
    0.13965642f, -0.12397853f, -0.02056966f, 0.00348525f, -0.14372669f, 0.05104288f, -0.04667898f, -0.14388490f, 
    -0.39858478f, -0.26462901f, -0.06507555f, -0.33905149f, 0.06846102f, -0.07355282f, -0.05922770f, -0.00345180f, 
    -0.02654006f, -0.17040925f, -0.12790532f, -0.11295167f, 0.30651981f, 0.27261251f, 0.22715011f, 0.02648007f, 
    0.15304789f, -0.10606135f, 0.03771507f, 0.09681027f, -0.04254945f, -0.01504057f, 0.11096108f, -0.07513960f, 
    0.06754210f, -0.15168697f, 0.16204309f, 0.03410879f, -0.07966157f, -0.04378778f, -0.03138847f, 0.03457350f, 
    -0.06232589f, -0.16147029f, -0.00617400f, -0.10794441f, 0.11244667f, 0.04437841f, -0.01336774f, 0.01270344f, 
    0.15762745f, 0.09310458f, 0.08716986f, -0.20004323f, -0.19859388f, -0.15741549f, -0.10389000f, -0.04037765f, 
    -0.28842214f, 0.08696192f, -0.20558976f, -0.05628859f, -0.02359069f, -0.19399884f, 0.17720008f, -0.03450497f, 
    -0.13721742f, -0.09776852f, 0.03953985f, 0.01947856f, 0.03786287f, 0.09444977f, 0.13428470f, 0.08153835f, 
    -0.06310325f, 0.00442438f, 0.05033176f, 0.00781413f, -0.07471380f, 0.09657992f, 0.00926115f, -0.01006926f, 
    -0.43867603f, -0.28949398f, 0.11002274f, -0.24824996f, -0.07363328f, -0.06536681f, -0.11237716f, -0.07370123f, 
    0.03805646f, -0.01200470f, -0.07315902f, 0.03613498f, 0.24446487f, 0.19914226f, -0.18123801f, -0.06690325f, 
    0.02053541f, -0.05022400f, -0.00953715f, 0.10058792f, -0.10205782f, 0.03005485f, 0.04780083f, -0.07212775f, 
    0.33221576f, 0.26179513f, 0.16952994f, 0.06823298f, 0.15892114f, 0.19440752f, 0.05972512f, 0.04989653f, 
    0.04357575f, 0.13207947f, 0.18677653f, -0.07081950f, 0.16321652f, -0.15315495f, -0.02507578f, -0.04015417f, 
    0.01191738f, -0.08827867f, 0.01140451f, 0.01419131f, 0.03325956f, 0.08134719f, 0.03652573f, -0.08619721f, 
    0.39374161f, 0.25034481f, -0.09184132f, 0.03018396f, -0.06474538f, 0.16108049f, 0.08956037f, -0.06817469f, 
    0.09964163f, -0.01937381f, 0.02469703f, 0.03649062f, 0.25012353f, 0.02184563f, 0.12002876f, 0.09801217f, 
    -0.05884394f, 0.08141408f, 0.14736761f, 0.12733775f, -0.06330316f, -0.01059338f, -0.00897799f, 0.14520246f, 
    -0.32603848f, -0.02613661f, -0.16807918f, -0.19049077f, -0.00054053f, -0.10048160f, -0.10497023f, 0.02637570f, 
    -0.02845789f, 0.01620512f, 0.08735602f, -0.03379176f, 0.03209784f, 0.19678952f, -0.04302407f, -0.02172684f, 
    0.19714727f, 0.07526567f, 0.10532383f, -0.05896114f, 0.04686684f, -0.06377552f, 0.05223841f, -0.06151499f, 
    0.14387828f, 0.19250485f, 0.03360983f, 0.31232971f, 0.19242457f, 0.06959612f, 0.02054725f, 0.19962165f, 
    0.02358702f, 0.11069879f, 0.10759227f, 0.11639933f, -0.02187147f, -0.04832071f, -0.08379661f, 0.11105050f, 
    -0.01345003f, -0.05955166f, 0.05649982f, -0.01367036f, 0.05750415f, -0.04467656f, -0.01404938f, 0.02857274f, 
    0.13379623f, 0.14740378f, 0.06413766f, 0.16374014f, -0.01165878f, -0.00659817f, -0.03916995f, 0.06648771f, 
    0.08385307f, -0.02130019f, -0.10609839f, -0.10073159f, -0.26917401f, -0.23979224f, 0.08305535f, -0.26795039f, 
    0.05286489f, 0.06156730f, 0.00557669f, 0.12111972f, 0.02994743f, -0.01863999f, 0.00308844f, -0.06575906f, 
    -0.26042381f, 0.09226100f, -0.15877046f, 0.03726529f, 0.13257055f, -0.09494319f, -0.04355446f, 0.00704879f, 
    -0.03010425f, 0.06086154f, -0.05315957f, 0.05510249f, 0.01129136f, -0.01006654f, -0.09185093f, 0.03136356f, 
    0.08012861f, 0.06837650f, 0.04453515f, 0.03623471f, 0.03898044f, 0.06155981f, 0.06875128f, -0.08562855f, 
    -0.27849880f, 0.00789176f, 0.20569701f, -0.05223039f, 0.00376175f, 0.01213793f, 0.08000787f, -0.01193494f, 
    0.06958670f, 0.06570862f, 0.08833385f, 0.04725801f, -0.17943592f, 0.08481530f, 0.30494136f, -0.24542271f, 
    -0.03096460f, -0.00795205f, 0.06308311f, -0.02050903f, -0.08309898f, 0.00040197f, 0.11257016f, -0.02450114f, 
    0.37942183f, 0.16826552f, -0.20034002f, 0.12273989f, 0.05209903f, 0.21214268f, -0.07341669f, -0.07480972f, 
    -0.01104348f, -0.06290152f, 0.04275427f, -0.04303955f, 0.04919601f, -0.08886550f, 0.03905141f, -0.04573167f, 
    -0.07150980f, 0.02423025f, 0.06215314f, 0.10192868f, 0.02369696f, 0.08546954f, 0.15046266f, -0.05885989f, 
    -0.31991899f, -0.03331601f, -0.07579532f, -0.07890413f, -0.11705638f, 0.03259042f, -0.04491561f, 0.05998764f, 
    0.13458973f, 0.08762388f, -0.14474431f, -0.01614714f, -0.02019443f, 0.15247639f, -0.02123032f, -0.41506439f, 
    0.08837434f, 0.04152217f, 0.09329544f, -0.02639954f, 0.12885171f, -0.06841244f, 0.06493959f, 0.01198901f, 
    0.30151552f, 0.01478686f, 0.15681568f, -0.00508346f, 0.11608281f, 0.04152619f, -0.09879586f, 0.02575321f, 
    0.06992240f, 0.02260925f, 0.00435593f, -0.03505339f, -0.05033815f, -0.08014131f, -0.16771884f, -0.01402420f, 
    0.05813109f, 0.02863608f, 0.04342358f, -0.00700699f, -0.01183574f, 0.07757231f, 0.06527367f, -0.02671921f, 
    0.07596783f, 0.19274464f, -0.05654071f, 0.20439291f, 0.17742868f, -0.02604664f, 0.01626901f, -0.05894224f, 
    0.01558663f, 0.07460248f, -0.03219477f, 0.09745975f, 0.06098483f, -0.13841991f, 0.20109734f, -0.11837549f, 
    0.09497271f, -0.00599952f, 0.07060413f, -0.00511042f, -0.03747435f, 0.01500037f, 0.05275287f, 0.00055104f, 
    -0.10672974f, 0.01100700f, 0.13862650f, -0.16166265f, -0.03179533f, -0.03251080f, -0.08705208f, -0.00960517f, 
    0.02972188f, -0.00150362f, -0.05799803f, -0.09484740f, -0.09098797f, 0.14047733f, 0.02970340f, -0.06042054f, 
    0.02064855f, -0.10827640f, -0.09973314f, -0.01648739f, 0.04108361f, 0.08830815f, -0.04414748f, -0.02860985f, 
    0.27562079f, 0.11033782f, 0.10885033f, 0.05705073f, 0.02385064f, 0.01787141f, 0.07482585f, -0.03903288f, 
    0.06443442f, 0.03423484f, 0.04380086f, 0.12652804f, -0.17004381f, -0.01462014f, -0.00133314f, 0.01808313f, 
    0.00678640f, -0.05031949f, 0.00085718f, -0.01344390f, 0.02000553f, -0.03633332f, 0.06976768f, 0.09391762f, 
    0.10343453f, 0.08334219f, 0.05731567f, 0.12367596f, -0.09965687f, -0.04262821f, -0.02137378f, 0.03091121f, 
    0.09373541f, -0.03446205f, 0.05384334f, -0.03579199f, -0.15452212f, 0.06549862f, 0.01157865f, 0.01139822f, 
    0.03633017f, 0.00065931f, -0.01092373f, 0.19178262f, 0.10446454f, 0.11053074f, -0.00992859f, -0.00322578f, 
    0.29560092f, -0.11652206f, 0.20155923f, 0.12233102f, 0.03537438f, 0.12118484f, 0.06114168f, -0.01753451f, 
    -0.00755301f, 0.08911308f, 0.00186555f, 0.13655588f, 0.17816004f, 0.15115260f, -0.18134110f, 0.19454470f, 
    0.13832460f, -0.02358898f, 0.03313414f, 0.29319486f, 0.09807022f, -0.07644590f, -0.02924526f, 0.06719685f, 
    0.21735658f, 0.06311069f, -0.02142591f, 0.09257443f, 0.02290765f, -0.02742413f, 0.08823570f, 0.12915200f, 
    0.04521287f, 0.05593766f, 0.11697851f, 0.06949170f, 0.11383007f, 0.20498048f, 0.11165003f, 0.04241557f, 
    -0.02640252f, 0.00637851f, -0.00904889f, 0.09766778f, -0.00215559f, 0.08553462f, 0.04510910f, 0.08397701f, 
    -0.19947773f, -0.09338368f, -0.06694113f, -0.18507296f, -0.05779050f, -0.06755866f, -0.04857630f, -0.06350858f, 
    0.05656023f, 0.10344570f, 0.06643403f, -0.02090421f, -0.14842427f, 0.15852940f, 0.21023147f, 0.22917043f, 
    -0.02226633f, 0.01712202f, 0.06487825f, -0.00069697f, -0.12543477f, -0.05037919f, 0.06615618f, 0.13043417f, 
    -0.30536646f, -0.15956959f, -0.08617077f, -0.22197066f, -0.04967545f, 0.11786014f, 0.04714908f, 0.03769653f, 
    0.10082223f, -0.07366616f, 0.08833530f, 0.05559519f, -0.30542079f, 0.05315349f, 0.02501842f, 0.04823403f, 
    0.01242313f, -0.13595295f, 0.04233994f, 0.08538339f, 0.11669856f, 0.00831650f, 0.06901862f, -0.01326931f, 
    0.14570251f, -0.09101126f, 0.11584535f, 0.09265416f, 0.07311774f, 0.07821421f, 0.03505678f, 0.03648055f, 
    0.11588413f, 0.14625791f, 0.02294629f, 0.00552150f, 0.21495010f, -0.06387819f, -0.25336707f, -0.07289281f, 
    0.05567180f, 0.13781749f, -0.11188433f, -0.09022105f, 0.04504089f, -0.05703028f, -0.10730524f, 0.03721946f, 
    0.24338333f, 0.03751354f, 0.03392332f, -0.06870916f, 0.04489420f, 0.01046497f, -0.22460724f, 0.01383987f, 
    0.04063845f, 0.02992468f, -0.00403492f, -0.05039961f, 0.05216765f, 0.08218840f, -0.24946663f, -0.09839793f, 
    0.04545586f, -0.02925872f, 0.10693543f, -0.03232990f, -0.01007443f, 0.07489817f, 0.04248619f, 0.13056722f, 
    -0.01102965f, -0.08004117f, 0.15596390f, 0.20121998f, 0.15542495f, -0.05237060f, 0.07405992f, -0.06819620f, 
    -0.02911504f, -0.08678960f, 0.02166138f, -0.02583757f, -0.09301306f, -0.06030647f, -0.02486518f, -0.17558168f, 
    0.14593336f, 0.04888535f, 0.02798183f, 0.04734043f, -0.08416914f, 0.11082046f, 0.08798786f, 0.12859456f, 
    -0.04789330f, -0.20986632f, 0.06723458f, -0.01098556f, -0.06904452f, -0.06890121f, 0.08068307f, 0.01407727f, 
    0.09367742f, 0.04506464f, -0.08897065f, -0.08165923f, -0.10049344f, 0.11622794f, -0.09878076f, -0.04000321f, 
    -0.11019170f, 0.02176577f, 0.01610620f, -0.14583832f, 0.01791455f, -0.28158063f, -0.02918749f, 0.02130471f, 
    -0.02278158f, -0.04353746f, 0.01054350f, -0.16965234f, 0.13793223f, -0.02891912f, -0.12170579f, 0.06020125f, 
    0.06654125f, -0.11043376f, 0.12745200f, -0.01375708f, 0.16334191f, -0.08727707f, -0.11212277f, -0.02081887f, 
    0.02436465f, 0.03129386f, 0.07034715f, 0.18630183f, -0.02300793f, 0.08850675f, 0.03838135f, -0.06314344f, 
    -0.33048338f, 0.07504036f, -0.06623257f, 0.01581928f, 0.04974197f, 0.13888448f, 0.01225797f, 0.02006770f, 
    0.03032248f, -0.00421361f, 0.08626204f, 0.13492404f, 0.19199799f, -0.05924796f, 0.01874767f, -0.07321770f, 
    -0.00451052f, 0.01225968f, -0.08710054f, 0.17374633f, 0.06635745f, -0.02585892f, 0.13069734f, 0.04757504f, 
    -0.02091102f, 0.02815957f, -0.03365460f, -0.05672932f, 0.00910480f, -0.00688219f, -0.06741978f, -0.01680597f, 
    -0.01205107f, 0.13248137f, -0.00261719f, 0.08472381f, 0.21893072f, 0.01260085f, 0.11028581f, -0.24103716f, 
    0.02519117f, 0.13080451f, 0.08753777f, 0.01343101f, 0.04066437f, 0.21095815f, 0.07236926f, 0.10514104f, 
    0.20693639f, 0.11775839f, -0.16856167f, -0.00214046f, -0.07300116f, -0.14166217f, -0.02561680f, -0.02435070f, 
    0.08575572f, 0.13022870f, -0.01742567f, -0.12068334f, 0.13327728f, -0.35632136f, -0.14176518f, 0.03480095f, 
    -0.01883223f, 0.17935894f, -0.04312249f, 0.10638569f, 0.01040670f, -0.14092165f, -0.00452717f, 0.14597978f, 
    -0.16186707f, 0.17272142f, 0.07852875f, 0.12611669f, 0.01921220f, 0.11701386f, 0.04456625f, 0.04733018f, 
    0.07222839f, 0.11288255f, -0.07362540f, 0.19825159f, -0.10599767f, -0.03410701f, -0.05619678f, -0.12859207f, 
    0.06087526f, -0.10003838f, -0.00373476f, 0.02301008f, -0.03619951f, -0.12563935f, 0.02030496f, -0.02551930f, 
    -0.14783844f, -0.16196625f, 0.02846343f, -0.04372452f, 0.05350807f, 0.03687761f, 0.18743539f, -0.00115523f, 
    0.02260718f, -0.09165894f, 0.06969035f, 0.09221409f, 0.07803250f, 0.08134944f, 0.26367885f, 0.14923152f, 
    0.03498120f, 0.09538020f, -0.02787670f, -0.02392742f, -0.09446277f, -0.08289825f, -0.02155087f, -0.02060201f, 
    -0.03516139f, 0.14799130f, 0.09674769f, -0.22357941f, -0.08967102f, 0.03293357f, -0.10465124f, 0.01399192f, 
    0.12437204f, 0.07361184f, -0.14076896f, -0.00479904f, 0.24955976f, 0.14288613f, -0.12472939f, 0.18810043f, 
    0.02636743f, 0.01085154f, -0.02031850f, 0.00622558f, 0.11330602f, 0.01097267f, -0.08446834f, -0.01015714f, 
    0.12561391f, 0.17437533f, 0.02815605f, 0.13837913f, 0.07652693f, 0.05920758f, -0.02241035f, 0.07426034f, 
    -0.16831328f, 0.02210993f, 0.03936481f, 0.20906946f, 0.19563243f, -0.01065969f, 0.19634779f, 0.13500005f, 
    0.03123937f, 0.11388409f, 0.09013060f, 0.12590517f, -0.06905539f, 0.22030076f, 0.09001672f, 0.07787686f, 
    0.00473196f, 0.14886725f, -0.05080202f, 0.10826382f, -0.05027591f, 0.12664197f, 0.12650830f, 0.05865511f, 
    0.02451827f, -0.04184163f, -0.06541620f, 0.15382169f, -0.14285088f, -0.01938569f, 0.03196028f, 0.21104318f, 
    0.03817625f, 0.09156106f, -0.01802132f, -0.14321555f, 0.01857633f, -0.00665505f, -0.07873689f, -0.03434024f, 
    0.00474835f, -0.09232567f, 0.25961950f, -0.01937783f, 0.13745201f, -0.09918767f, -0.03503442f, 0.02574858f, 
    -0.03646006f, -0.03298144f, -0.13893832f, -0.08312538f, -0.10329598f, -0.01368998f, 0.02419502f, 0.09228723f, 
    0.21579042f, -0.11710273f, 0.05794157f, -0.07696629f, -0.00450095f, 0.08031668f, 0.02326432f, -0.01369245f, 
    0.16373318f, -0.01986410f, -0.05213145f, -0.03812120f, -0.00166924f, -0.03940939f, -0.00789782f, -0.10219820f, 
    -0.15106870f, 0.06421246f, 0.00291684f, -0.12683292f, -0.23202361f, -0.08867436f, -0.09310201f, 0.13908228f, 
    -0.19739999f, -0.11411254f, -0.08747023f, 0.00279034f, 0.04866332f, -0.18619850f, -0.10945141f, -0.14869775f, 
    -0.22574253f, -0.12367485f, 0.00145822f, -0.12094403f, 0.16268498f, 0.11668037f, 0.15011904f, -0.07257816f, 
    0.02961073f, -0.15733108f, 0.05777592f, 0.20537311f, -0.23114432f, 0.26256353f, 0.04979284f, -0.05797031f, 
    -0.02694003f, -0.04590525f, 0.07517069f, -0.08611187f, 0.03705126f, 0.04519980f, 0.06467410f, 0.02061402f, 
    0.17814159f, 0.03702062f, -0.03362742f, -0.25782308f, 0.02520402f, -0.14516391f, -0.04706634f, -0.04381607f, 
    0.00293307f, -0.10632981f, 0.15700397f, -0.16585104f, 0.02913397f, -0.10744612f, 0.03995658f, 0.11052857f, 
    -0.05512138f, 0.10057687f, 0.12074848f, 0.06170980f, 0.12155306f, 0.17510557f, -0.05924797f, 0.05003864f, 
    0.16508105f, 0.07384960f, -0.09713712f, -0.05980641f, 0.04083060f, -0.04888090f, -0.02759941f, -0.12616999f, 
    0.09494583f, -0.00793489f, 0.06439976f, -0.16949119f, -0.06033856f, 0.09494535f, -0.05503373f, -0.02532604f, 
    0.04404566f, -0.01499222f, -0.04013779f, 0.00676852f, 0.05730862f, 0.07371238f, -0.01260491f, -0.05808511f, 
    -0.12546800f, -0.18091004f, 0.07657781f, -0.02182237f, 0.13583562f, -0.00880529f, 0.03851652f, 0.04426817f, 
    0.06900614f, -0.02788390f, 0.05155779f, 0.02560819f, 0.37821338f, 0.25875250f, -0.01334362f, 0.22743708f, 
    0.04111103f, 0.00186234f, 0.04730184f, -0.06297142f, 0.08902651f, 0.05661351f, 0.03198789f, -0.01077331f, 
    0.09307386f, 0.15196723f, -0.00774147f, 0.13257279f, 0.02463201f, 0.07881111f, 0.00637579f, -0.12346618f, 
    0.05568788f, -0.08698460f, 0.12844628f, -0.01240973f, 0.17600776f, 0.06002828f, 0.12468636f, 0.08536962f, 
    0.00692676f, 0.06621078f, 0.13706465f, -0.02987036f, -0.05611170f, 0.00058649f, -0.12809221f, 0.12058815f, 
    -0.00971315f, 0.28184235f, -0.16860107f, -0.02713588f, -0.07064719f, -0.01914693f, -0.03236156f, 0.03819495f, 
    -0.09798723f, 0.01034114f, 0.09153400f, -0.04117265f, 0.28598136f, -0.02686700f, -0.16512181f, 0.06317446f, 
    -0.03022503f, -0.08809114f, -0.07973350f, -0.11237156f, 0.07625815f, 0.04601899f, -0.01119686f, 0.06382462f, 
    -0.03874186f, -0.13628091f, 0.27243963f, 0.01480647f, -0.11503267f, -0.05358916f, -0.00842847f, 0.08083721f, 
    0.01153027f, -0.00216029f, 0.07609487f, 0.06441027f, -0.21135382f, -0.01341545f, -0.11941800f, 0.12504603f, 
    0.17404255f, -0.15322003f, -0.03706825f, 0.01138411f, 0.02629854f, 0.00233723f, -0.04869917f, 0.04921036f, 
    0.44025883f, 0.10860180f, 0.06957534f, 0.15882072f, 0.18890834f, 0.05460443f, 0.09706145f, 0.11750280f, 
    -0.06585363f, 0.07968976f, 0.02328600f, 0.06224972f, -0.12577184f, -0.13020307f, -0.08390965f, 0.47313309f, 
    -0.18218528f, -0.10747062f, -0.09859151f, 0.03443252f, -0.02737987f, -0.02543191f, 0.00612766f, -0.03042529f, 
    -0.47342098f, 0.14905095f, -0.04603897f, 0.07468597f, 0.06221225f, 0.04276698f, 0.05019002f, -0.04536153f, 
    0.02969702f, -0.02539778f, -0.04993103f, -0.01350916f, -0.24785683f, 0.31664598f, 0.08315372f, -0.10049365f, 
    0.02520587f, -0.08643648f, 0.08417385f, 0.14790285f, -0.04766689f, -0.09348585f, -0.09601150f, 0.09538110f, 
    0.06113043f, -0.06346829f, 0.04972327f, -0.11735319f, -0.05064249f, 0.06104966f, 0.10677414f, 0.04837055f, 
    0.03683629f, -0.00644622f, 0.07970704f, 0.04488158f, 0.00314937f, 0.16027768f, -0.02035118f, 0.15889743f, 
    0.01514185f, -0.09327187f, -0.04427225f, 0.00098445f, 0.01279255f, -0.03820565f, 0.08302592f, 0.04537070f, 
    0.01462727f, -0.01406382f, 0.02733509f, 0.00530489f, 0.06015556f, -0.01294058f, -0.01440990f, 0.03187517f, 
    -0.00679997f, -0.05220575f, 0.04253491f, 0.02109321f, -0.00747594f, 0.04153365f, -0.02679440f, 0.05181303f, 
    -0.07252572f, -0.06292912f, -0.05603086f, -0.03270826f, 0.02055017f, 0.00497741f, 0.04549268f, -0.06158603f, 
    -0.00555225f, -0.00397032f, -0.06392776f, 0.00251903f, -0.03350614f, 0.05175972f, -0.03549254f, -0.05957069f, 
    0.02251837f, -0.03061612f, -0.04561707f, 0.03289878f, -0.02815264f, -0.00617003f, 0.00057486f, -0.02675348f, 
    -0.05569080f, -0.00773238f, -0.01490136f, 0.01762419f, 0.05614864f, -0.06684975f, -0.03507206f, 0.02643979f, 
    0.03980678f, -0.03094221f, -0.07543602f, 0.06459758f, 0.05583946f, -0.07262090f, -0.06920095f, 0.04148423f, 
    -0.01075072f, -0.04260376f, 0.01206836f, 0.01695041f, -0.07388154f, 0.00427943f, -0.05240338f, -0.00375892f, 
    0.05747770f, 0.02986391f, -0.02486999f, -0.06001968f, -0.06001649f, 0.05271117f, -0.06389344f, -0.01692878f, 
    -0.00081400f, -0.06116093f, 0.02461616f, 0.05700495f, -0.01567548f, 0.04483132f, -0.03914758f, -0.02512854f, 
    -0.03451358f, -0.05406434f, 0.04566418f, 0.05748048f, 0.00644068f, 0.01456087f, -0.04387670f, -0.04240393f, 
    -0.03587631f, 0.05678769f, -0.02124964f, -0.05169197f, 0.05460969f, -0.03816304f, 0.06630407f, -0.00276068f, 
    -0.05920387f, 0.05522252f, -0.02576418f, -0.03312558f, 0.00213174f, 0.05877411f, 0.00388549f, -0.03891188f, 
    0.04470746f, -0.07275748f, 0.00802814f, -0.00834023f, -0.07044622f, -0.08153373f, -0.05225359f, 0.02601689f, 
    0.02976481f, -0.06870836f, -0.05625614f, -0.02777964f, -0.05141542f, -0.06035154f, 0.00486551f, -0.04957379f, 
    0.01897763f, -0.06839800f, 0.01128796f, 0.04058411f, 0.02730428f, 0.04509241f, 0.05890418f, -0.06008996f, 
    -0.03073408f, -0.02017690f, 0.01508198f, -0.06947132f, 0.02610967f, -0.03183472f, 0.00561444f, 0.04402621f, 
    -0.05717490f, -0.07694506f, -0.00716045f, 0.06714682f, -0.06319554f, 0.00625393f, -0.01545946f, -0.05505738f, 
    -0.05564645f, 0.06074099f, -0.02659355f, -0.03972735f, 0.03551161f, 0.00589662f, -0.00259945f, -0.04921155f, 
    -0.00435594f, -0.01076815f, 0.04408532f, 0.00170800f, 0.02543145f, -0.01909824f, -0.00631482f, 0.01414615f, 
    0.03883268f, -0.01634002f, 0.00299472f, 0.03547105f, 0.03055121f, -0.02081354f, -0.05918381f, -0.05841650f, 
    -0.02466115f, -0.03999131f, -0.06906162f, -0.03771549f, -0.00523933f, 0.02595196f, -0.01240484f, -0.04010406f, 
    -0.04537214f, 0.05573536f, 0.06181624f, 0.04210464f, 0.05317637f, 0.03672536f, 0.01187962f, 0.03781545f, 
    -0.04213373f, -0.01346012f, -0.05257978f, -0.03183940f, 0.03854201f, 0.04052808f, -0.07500453f, -0.05624423f, 
    -0.31897220f, -0.15712267f, -0.26456934f, -0.08580805f, 0.05554214f, -0.05528570f, 0.08571313f, -0.05392198f, 
    0.03751510f, 0.08503180f, 0.04494420f, 0.11447809f, 0.17660317f, 0.12101994f, 0.27099183f, 0.25708166f, 
    -0.03358645f, 0.05363268f, -0.03794650f, -0.04516440f, -0.05208182f, -0.03126401f, -0.04581400f, -0.01345872f, 
    -0.17906226f, -0.05083815f, -0.04358283f, -0.23670436f, 0.12576221f, -0.00238964f, 0.00912157f, 0.04922010f, 
    0.07922176f, 0.14350556f, 0.00038702f, 0.10710996f, 0.28817764f, 0.02361782f, -0.16191755f, 0.14740485f, 
    0.01925749f, 0.06107897f, -0.00589135f, 0.00597307f, 0.10421883f, 0.05296206f, -0.03187208f, -0.05320523f, 
    -0.15658239f, -0.01813657f, 0.05445187f, -0.00718433f, 0.11197848f, -0.01851840f, 0.00757978f, 0.06079777f, 
    0.13718735f, -0.04182742f, 0.11815406f, 0.16260536f, 0.11069046f, 0.03697612f, 0.10380263f, 0.15329808f, 
    -0.08010256f, 0.10201169f, 0.06794422f, 0.10786352f, -0.06529640f, 0.16060726f, 0.05762593f, 0.16523646f, 
    0.32884324f, 0.21197462f, -0.10660450f, 0.16709420f, 0.05861441f, 0.02505806f, 0.08038330f, -0.01016287f, 
    -0.03066569f, -0.03768598f, 0.00861343f, 0.09030110f, 0.04876678f, -0.00141518f, 0.12954924f, 0.14408617f, 
    0.05089578f, 0.05606771f, 0.00548050f, -0.06369006f, 0.07854629f, -0.05248120f, -0.02924407f, 0.01256579f, 
    -0.07478491f, -0.05554602f, 0.05224501f, 0.10012514f, 0.05623033f, -0.00911681f, -0.08627965f, 0.06719198f, 
    -0.10327792f, -0.05254592f, 0.02994296f, 0.07428909f, -0.06369378f, 0.10351962f, 0.00301007f, 0.08796034f, 
    0.17811638f, -0.04415590f, 0.05711000f, -0.18707135f, -0.11752578f, 0.10050467f, 0.01370435f, 0.02729934f, 
    0.22577819f, -0.04155266f, -0.02413851f, -0.11828729f, -0.06494901f, -0.09252612f, -0.10933182f, -0.09850492f, 
    -0.10356671f, 0.01438065f, -0.01356544f, 0.01780953f, 0.20032132f, -0.18573852f, -0.14316709f, 0.10239876f, 
    0.02030642f, -0.03091877f, 0.01397328f, 0.05586477f, 0.06866743f, -0.06603353f, 0.01648512f, -0.05201491f, 
    0.01137799f, -0.05231865f, -0.01696821f, 0.07992658f, -0.03357220f, -0.02562700f, 0.08057348f, 0.12136669f, 
    -0.04340454f, -0.10805054f, 0.02925037f, 0.05670939f, -0.06013699f, -0.03251928f, 0.13421692f, 0.00510876f, 
    0.05528022f, -0.07264476f, 0.02564382f, -0.06511532f, 0.02192268f, 0.08868801f, 0.05753155f, 0.10056210f, 
    -0.08164886f, -0.15913358f, -0.16025253f, -0.15380038f, 0.14101768f, -0.00592188f, -0.12153655f, -0.10394391f, 
    -0.03950413f, -0.04757484f, 0.06342880f, -0.03886572f, -0.05560958f, -0.14596157f, 0.17285006f, -0.03616389f, 
    -0.14618994f, -0.06864798f, 0.11736573f, 0.02888110f, 0.00571244f, 0.12138521f, -0.09782051f, -0.01025656f, 
    0.34588581f, -0.22208527f, -0.14913982f, 0.26672590f, -0.05762304f, -0.06131491f, 0.13385008f, -0.02347933f, 
    -0.00780342f, 0.00523826f, 0.02738609f, 0.04742137f, -0.10077321f, -0.04135218f, 0.14627685f, 0.25027278f, 
    -0.02933585f, 0.09665459f, 0.06516789f, 0.21591163f, 0.23512459f, 0.05187457f, -0.05124100f, 0.05931764f, 
    -0.22788620f, -0.14456877f, 0.01725427f, 0.31779858f, 0.14326522f, 0.07562583f, -0.07530108f, 0.03816774f, 
    0.17232496f, 0.05894025f, 0.03687240f, -0.08699261f, -0.15770176f, -0.06049568f, 0.12600644f, -0.03085110f, 
    -0.07571310f, 0.03297596f, 0.06902488f, 0.11030551f, 0.01535674f, 0.17585541f, 0.04337206f, -0.08422796f, 
    -0.04566049f, -0.00863916f, 0.08511274f, 0.09000671f, 0.06835642f, 0.01277126f, -0.08064894f, 0.01710854f, 
    0.08080328f, 0.03896879f, 0.01197091f, 0.20692156f, 0.25963795f, 0.07450409f, 0.04483830f, -0.18443412f, 
    0.05826573f, 0.16054285f, 0.04185556f, -0.11549509f, -0.10644783f, 0.02214208f, -0.00027809f, 0.10833665f, 
    0.23861243f, -0.17991655f, -0.02344652f, -0.05578948f, -0.00830100f, 0.00234601f, 0.09784629f, 0.23195638f, 
    0.05629690f, -0.02916309f, -0.01182296f, 0.03246270f, -0.34524804f, 0.01603004f, 0.12180018f, -0.36661234f, 
    -0.00410480f, 0.16010900f, 0.26065508f, -0.16586646f, 0.05272042f, 0.07700135f, -0.03959981f, 0.12598401f, 
    -0.53749162f, 0.10546185f, 0.14286216f, 0.19929978f, 0.15653339f, 0.02933692f, 0.06751414f, -0.01837326f, 
    0.07590303f, 0.11546716f, 0.01626078f, -0.13023232f, -0.09901056f, -0.09611209f, -0.03450996f, -0.00914012f, 
    0.08730181f, 0.01693792f, 0.00290332f, -0.08833109f, 0.06200772f, 0.04317365f, 0.11488415f, 0.10984926f, 
    -0.02691059f, -0.21441300f, 0.16155028f, -0.19941835f, -0.18689477f, -0.04332265f, 0.04523465f, 0.00980884f, 
    0.05793037f, 0.02295153f, 0.10507345f, -0.06259155f, -0.01062375f, 0.11980015f, -0.19023789f, -0.09802736f, 
    -0.02936090f, 0.02105486f, 0.01853174f, -0.08039684f, 0.00323636f, 0.00099295f, 0.04340007f, -0.08763624f, 
    -0.09723492f, -0.21142204f, -0.00527983f, -0.08883081f, -0.12731269f, -0.16249971f, 0.01987534f, -0.07305965f, 
    0.02180269f, -0.04675464f, 0.04199988f, 0.08325285f, -0.00110832f, 0.25878879f, -0.01752941f, -0.15395159f, 
    0.07620966f, -0.01936066f, 0.13680118f, -0.04295112f, -0.07024549f, -0.04590060f, 0.15370041f, -0.01246660f, 
    0.05090110f, 0.22771698f, -0.05745484f, 0.15528795f, 0.18404151f, -0.05583207f, -0.01846539f, 0.04939688f, 
    0.08542142f, -0.03701383f, 0.10511579f, 0.02025098f, -0.15442067f, 0.05198106f, 0.17698379f, 0.31951830f, 
    -0.07915904f, -0.06896403f, -0.02486349f, 0.01436508f, -0.07179435f, 0.07625441f, 0.16866983f, 0.00811254f, 
    -0.04759239f, -0.04465181f, -0.06437209f, 0.04029166f, -0.01528849f, -0.04587715f, -0.03299445f, -0.00884280f, 
    0.05973557f, 0.00232769f, -0.04186162f, 0.02694650f, 0.05069159f, -0.02194420f, -0.04457136f, 0.04307709f, 
    -0.00492980f, -0.00422189f, 0.05456095f, -0.04951733f, 0.05548234f, 0.01141046f, -0.05728642f, 0.01268746f, 
    -0.05866372f, -0.02235773f, 0.06282472f, -0.04758275f, -0.03031154f, -0.00788902f, -0.04085717f, -0.00150814f, 
    0.00555596f, -0.04101634f, 0.05276537f, -0.04612675f, -0.03795336f, 0.05845806f, -0.00529810f, 0.00656300f, 
    -0.00943966f, -0.00148246f, -0.00708509f, 0.05824224f, 0.01219159f, 0.02450227f, -0.06419361f, -0.06205720f, 
    -0.00575823f, -0.06891473f, -0.06556021f, 0.00465736f, -0.00211296f, 0.01648755f, 0.01422893f, -0.06728946f, 
    -0.05313573f, 0.00711041f, 0.00170077f, -0.07185877f, 0.05234257f, -0.03112495f, -0.05430867f, -0.08234452f, 
    0.00447610f, -0.00297027f, -0.04971376f, -0.03472899f, 0.03576800f, -0.07948197f, 0.04645684f, -0.03310476f, 
    -0.04145085f, 0.00693197f, -0.02933786f, -0.04904740f, 0.01141320f, -0.00662315f, -0.03191251f, 0.06043134f, 
    0.02282085f, 0.03514010f, 0.02724015f, -0.05602168f, -0.04851740f, -0.01246176f, 0.04248560f, -0.03222449f, 
    0.00377195f, -0.07283206f, -0.00302732f, 0.00278993f, 0.06642056f, 0.05386979f, 0.06426096f, -0.05943809f, 
    -0.07571233f, -0.04528646f, -0.03055681f, -0.06707228f, -0.02878268f, -0.00752082f, -0.02654195f, -0.07422650f, 
    0.01775319f, -0.00712650f, -0.05714216f, 0.01593572f, 0.01044125f, -0.06025613f, -0.05511669f, -0.01452368f, 
    -0.03864550f, -0.07548569f, 0.00905513f, -0.06620403f, -0.03440113f, -0.03039123f, -0.03488323f, -0.07003301f, 
    0.01179876f, -0.00653041f, 0.02070787f, -0.03950775f, 0.04660339f, 0.03091874f, 0.06253866f, 0.05055569f, 
    -0.00901510f, 0.06384861f, 0.00430654f, 0.01316005f, -0.01918964f, -0.02897653f, 0.06157808f, -0.01701512f, 
    0.01072000f, -0.03305606f, -0.02972393f, 0.05094700f, -0.05976378f, 0.00032532f, 0.04047144f, 0.04535640f, 
    0.01646704f, 0.00526325f, 0.06841736f, 0.00999426f, -0.00522580f, -0.01847799f, 0.00548276f, -0.03966672f, 
    0.00836253f, -0.04775077f, 0.02122713f, 0.05086080f, 0.03212972f, -0.05047247f, -0.00076632f, 0.04338326f, 
    0.04532796f, -0.05014566f, 0.00817993f, 0.04341594f, -0.07429778f, 0.04797680f, 0.02891947f, -0.05127995f, 
    0.04679234f, 0.04877444f, 0.04461404f, 0.06747885f, 0.00211726f, -0.01476820f, 0.01850797f, 0.05860839f, 
    -0.00202982f, 0.00308094f, 0.03076624f, -0.00015371f, 0.00653924f, 0.01332653f, -0.04208780f, -0.01356548f, 
    -0.01926250f, -0.00504207f, 0.01165210f, -0.04087706f, 0.01030835f, -0.00972574f, 0.03750274f, -0.04293883f, 
    0.02733659f, 0.05129289f, -0.02418638f, -0.07703923f, -0.02438182f, 0.03088465f, -0.02336417f, -0.03599167f, 
    -0.05772377f, 0.04734530f, -0.02879215f, 0.06549818f, 0.04700226f, 0.01614119f, 0.05136952f, -0.07430882f, 
    -0.07783908f, -0.06376208f, 0.04677089f, -0.03606485f, 0.00217841f, -0.04613816f, 0.04807911f, -0.01808348f, 
    0.04966969f, -0.04613048f, 0.05051651f, -0.03563727f, 0.02100008f, 0.04090096f, -0.02809622f, -0.06183809f, 
    0.03409511f, 0.02536232f, 0.03553748f, -0.00556238f, -0.00008410f, 0.00734417f, 0.00849089f, -0.05724514f, 
    -0.01658891f, -0.06347902f, -0.03441264f, -0.05260966f, 0.04819733f, 0.00700932f, 0.01797452f, -0.01679177f, 
    -0.00268493f, -0.06633887f, -0.04114100f, -0.00990647f, -0.01634949f, -0.03312159f, -0.00770901f, -0.06642982f, 
    0.05670359f, -0.07476058f, 0.06172520f, -0.02650860f, -0.07521449f, 0.03705091f, 0.03706929f, -0.02982598f, 
    -0.05123878f, 0.00449981f, 0.05257996f, -0.06152269f, 0.06255598f, 0.05161896f, 0.02693558f, 0.05747271f, 
    0.05271426f, 0.05355419f, 0.02963725f, -0.04222858f, 0.01964857f, -0.04865978f, -0.05176581f, 0.02679609f, 
    -0.03484946f, -0.03103181f, 0.01467407f, 0.03203765f, -0.02766822f, 0.01635744f, -0.06448381f, -0.07685760f, 
    0.03603156f, -0.00981410f, 0.01616071f, 0.04587785f, -0.02040629f, 0.01381232f, 0.03018669f, 0.05992189f, 
    0.01647115f, -0.06209010f, -0.02824306f, 0.02421721f, -0.07109676f, -0.02214798f, -0.03843091f, -0.02869043f, 
    0.02746750f, 0.01294157f, -0.04394315f, -0.01532503f, -0.03474506f, 0.03055423f, -0.03315247f, -0.06597535f, 
    0.00742140f, 0.00576199f, -0.03197026f, 0.05437152f, -0.01413307f, -0.02023472f, -0.01848857f, -0.00718810f, 
    -0.01945383f, 0.02056525f, -0.02844546f, 0.02320263f, 0.05715704f, -0.01729528f, -0.06579172f, -0.06502257f, 
    -0.01730585f, -0.04127766f, -0.04014899f, -0.04885689f, 0.01111182f, -0.06730638f, -0.04745899f, -0.04457643f, 
    0.03780209f, -0.03278506f, -0.06852061f, 0.04054210f, 0.01889089f, -0.01768099f, -0.05741883f, -0.05124254f, 
    -0.00976307f, -0.01220345f, -0.06299572f, -0.05291710f, -0.02806855f, -0.06955721f, -0.04191221f, -0.00208656f, 
    0.05459087f, -0.04441931f, -0.07284159f, -0.04729958f, -0.00221672f, 0.06208451f, 0.00756165f, -0.03515463f, 
    -0.05923742f, -0.02211308f, -0.02994947f, -0.06595605f, 0.06363734f, 0.06078335f, -0.07268140f, 0.03512879f, 
    0.03966817f, -0.01416966f, -0.00783191f, -0.00565993f, 0.01046834f, 0.02641476f, 0.04841460f, -0.06454194f, 
    0.00311651f, 0.01836398f, -0.05643234f, -0.00443206f, -0.02182599f, -0.03926860f, 0.03372472f, 0.04682565f, 
    0.03726329f, -0.03309489f, 0.03870342f, 0.00204717f, -0.06156001f, 0.00510563f, 0.01996278f, 0.00893035f, 
    -0.06750966f, -0.03971966f, -0.06596820f, 0.02473292f, 0.03937493f, 0.04697215f, -0.05110866f, -0.01811511f, 
    0.02262296f, -0.05454271f, -0.08004238f, 0.03119217f, -0.01012048f, 0.05049790f, 0.04250445f, -0.07751856f, 
    0.02323772f, -0.06518266f, -0.01941528f, -0.06741827f, 0.04855973f, 0.00643813f, -0.07567772f, 0.03849666f, 
    0.01405994f, 0.03249695f, -0.05860241f, -0.03104680f, 0.02135763f, 0.05647835f, 0.04204826f, -0.03265576f, 
    -0.04186074f, -0.04818960f, 0.02693842f, -0.01450682f, -0.05127510f, -0.02879023f, 0.00655731f, 0.01707027f, 
    0.00992752f, 0.04460588f, -0.07156975f, -0.07860526f, 0.03463059f, -0.02070009f, -0.05400461f, -0.00865029f, 
    -0.02335376f, -0.07415828f, 0.04532824f, -0.06016927f, 0.03909593f, 0.04596147f, -0.02519215f, 0.04775580f, 
    -0.04455689f, 0.00556692f, -0.03820461f, 0.05538519f, -0.01668004f, 0.05777293f, -0.00302795f, -0.04914583f, 
    -0.06934178f, -0.04613876f, -0.03458161f, -0.00864949f, 0.01034232f, -0.00523380f, -0.06793743f, -0.02059404f, 
    -0.04411031f, 0.00472378f, 0.00210533f, -0.01937574f, 0.00966669f, -0.02099541f, 0.01127178f, 0.03011078f, 
    0.03409346f, 0.05448110f, 0.02990532f, -0.01275279f, -0.03871664f, -0.01001448f, -0.06349883f, 0.01439702f, 
    0.02567195f, -0.00780204f, -0.05551301f, -0.00928874f, -0.01450538f, 0.05785540f, 0.03657023f, 0.00224724f, 
    0.01005225f, 0.04975822f, -0.00874369f, -0.01944152f, -0.02693768f, 0.01721740f, 0.01281198f, -0.01408924f, 
    -0.04366018f, 0.03604252f, -0.05858766f, -0.01317053f, -0.01549981f, 0.05045852f, -0.03025023f, -0.05739498f, 
    0.00586400f, -0.04806385f, -0.03533352f, 0.02325492f, 0.01364098f, 0.02527658f, 0.01058268f, -0.02928401f, 
    -0.01603397f, 0.03529261f, 0.06457102f, -0.00254360f, -0.07559800f, -0.04162409f, 0.05118099f, 0.01289678f, 
    0.03057145f, 0.00960123f, 0.04933384f, 0.01879261f, 0.06172522f, -0.06280659f, -0.00616763f, 0.00301830f, 
    -0.00732033f, -0.03443705f, -0.03288326f, -0.00025855f, 0.02214491f, 0.04665378f, 0.00224014f, -0.03219321f, 
    -0.07251676f, -0.06397165f, -0.05185510f, 0.01171395f, 0.05105786f, 0.00165170f, -0.04795979f, 0.01431704f, 
    -0.07287183f, -0.02731903f, -0.01725747f, -0.00157970f, 0.05773598f, 0.05708924f, -0.07509486f, -0.07629001f, 
    -0.00557946f, -0.07808382f, -0.06643783f, 0.04983208f, -0.03292417f, -0.07176067f, -0.05880857f, 0.06062932f, 
    -0.07039380f, 0.04974270f, 0.01628734f, 0.02167471f, -0.07023042f, 0.00066985f, -0.06415549f, 0.00058568f, 
    -0.03633447f, -0.06476017f, 0.04704419f, -0.00474182f, 0.03578930f, 0.05237054f, -0.02195616f, 0.00384012f, 
    -0.03836470f, -0.02092976f, 0.02293527f, -0.02901242f, 0.01117382f, -0.02336556f, -0.07018819f, 0.04893013f, 
    0.00774371f, -0.00847653f, -0.28976122f, -0.06052826f, 0.07657079f, 0.04741618f, -0.00966413f, -0.00771977f, 
    -0.06470078f, 0.14175946f, 0.16756669f, 0.06974410f, -0.01273646f, 0.06174835f, 0.19678888f, 0.17216206f, 
    0.00209828f, 0.07633231f, 0.02725410f, -0.07877940f, 0.11217210f, -0.00606543f, 0.00545643f, -0.10295215f, 
    -0.09351183f, -0.18185484f, -0.11564232f, -0.04529800f, 0.04292855f, -0.04030507f, -0.05974942f, 0.02270367f, 
    -0.02208186f, 0.01365753f, 0.03322787f, 0.00237921f, 0.30240667f, -0.02669540f, 0.03109395f, -0.07133430f, 
    0.11864169f, 0.07885307f, 0.19325121f, 0.03158788f, -0.06713811f, 0.06785312f, -0.08924214f, -0.13272750f, 
    0.02225385f, -0.09010857f, 0.06327982f, 0.03025944f, 0.16135882f, 0.11366848f, -0.02791627f, -0.09154847f, 
    0.09052841f, 0.04470025f, 0.06083658f, 0.06210722f, -0.02634365f, -0.01238186f, 0.04207573f, 0.00451971f, 
    -0.01065604f, 0.05865463f, -0.01228475f, -0.04320651f, 0.13259730f, 0.07516812f, 0.15645589f, 0.07917766f, 
    0.09488992f, 0.22827619f, -0.12588100f, 0.21208434f, -0.00028771f, -0.07772008f, -0.09515189f, 0.03114089f, 
    0.05969632f, 0.01263677f, 0.07826892f, -0.06776266f, 0.12838353f, -0.17515607f, -0.09970436f, 0.01303882f, 
    0.03831812f, 0.16702780f, -0.08271074f, -0.08647155f, 0.01200348f, 0.07248725f, -0.01597295f, -0.04511827f, 
    -0.38717744f, -0.07546840f, 0.16113351f, 0.05161471f, -0.04381735f, 0.07912125f, -0.00723199f, 0.06270809f, 
    0.01201174f, -0.07705811f, 0.04095116f, 0.16080461f, -0.22809751f, 0.00112932f, -0.02164260f, 0.14011993f, 
    0.09329387f, 0.06326643f, -0.02298705f, -0.00121722f, -0.06749716f, 0.06057746f, 0.02007061f, -0.17326507f, 
    0.21122715f, 0.07110394f, 0.12560171f, -0.10431314f, -0.00524310f, -0.04393500f, 0.09740945f, -0.12116149f, 
    -0.09736452f, 0.06720411f, 0.03882524f, -0.01422786f, 0.39753789f, -0.18420762f, -0.17668141f, -0.05192135f, 
    0.18676671f, 0.20577209f, -0.12279636f, -0.04227731f, 0.08428977f, 0.06839239f, -0.06984653f, 0.02945566f, 
    0.25543931f, 0.01273655f, 0.00303474f, 0.06944013f, 0.03073917f, -0.11452041f, 0.06560803f, 0.05276622f, 
    -0.10359833f, -0.05368166f, -0.02300182f, -0.02576688f, 0.01533774f, -0.10834458f, 0.04077137f, 0.15721712f, 
    0.09816254f, -0.03528840f, -0.04981939f, -0.07718658f, 0.00941948f, 0.04008441f, 0.03102697f, 0.20118013f, 
    -0.30380800f, -0.03970863f, -0.09948367f, -0.08549969f, -0.09102650f, -0.08172462f, -0.03249773f, -0.08391718f, 
    -0.13259049f, 0.03878603f, 0.18570462f, 0.08296707f, -0.16741268f, -0.06627093f, 0.24001566f, -0.22870706f, 
    -0.08068390f, 0.08381248f, 0.02333271f, 0.10130563f, -0.05701019f, 0.03411555f, 0.00126770f, 0.07871740f, 
    -0.03559126f, 0.01327683f, 0.03966369f, -0.04343445f, 0.05077832f, -0.05923218f, -0.00144590f, 0.01953338f, 
    -0.06874333f, 0.06278849f, -0.04816971f, 0.02768146f, 0.02175737f, 0.01834813f, -0.00035822f, -0.02910297f, 
    -0.03345527f, 0.00989925f, -0.01183654f, 0.01045050f, 0.06046969f, 0.04243898f, -0.04936092f, 0.01047213f, 
    0.05252227f, 0.05817030f, 0.04120742f, 0.03345598f, -0.01582556f, -0.07928440f, 0.06043724f, 0.06206468f, 
    -0.02362353f, -0.04744675f, 0.02549803f, -0.00048260f, 0.00726632f, 0.05771534f, -0.07461842f, 0.05237506f, 
    -0.02467726f, 0.01308158f, 0.04160913f, -0.00387434f, 0.02113182f, -0.01939460f, 0.01934606f, -0.03673898f, 
    -0.02491631f, -0.01767734f, 0.05380447f, -0.07270252f, 0.01356028f, 0.02729023f, -0.03380372f, -0.05189703f, 
    -0.07376904f, 0.02710255f, -0.04955446f, 0.00238478f, -0.05351577f, 0.05444951f, 0.03070796f, -0.04790836f, 
    -0.06116337f, -0.01161016f, 0.02407939f, -0.00510944f, -0.05430983f, -0.04988690f, -0.05830827f, -0.02512834f, 
    0.00493000f, 0.03134255f, -0.02731001f, -0.04044989f, 0.00175156f, -0.00978706f, -0.03836554f, 0.06015986f, 
    -0.03965214f, 0.02719298f, -0.01764100f, -0.03046251f, 0.04062324f, -0.06009551f, -0.06249809f, 0.00987797f, 
    -0.07138170f, -0.01236855f, -0.03206689f, 0.02067154f, -0.03379272f, 0.01322572f, 0.06741197f, -0.00798089f, 
    0.04742801f, -0.04275672f, -0.01211624f, -0.04174942f, -0.05129724f, -0.05688541f, -0.05157736f, 0.00960628f, 
    0.05659717f, -0.04771898f, 0.05127245f, 0.01021994f, 0.00139013f, -0.01197051f, -0.05577523f, 0.00823639f, 
    -0.01601253f, 0.03744707f, 0.05675600f, 0.03618131f, 0.06422442f, -0.02016087f, 0.02788189f, 0.00156367f, 
    0.04900630f, -0.01276439f, -0.04761565f, -0.05686923f, 0.02654390f, 0.03742939f, -0.00764598f, 0.03558316f, 
    -0.03100130f, 0.06766701f, 0.03241286f, 0.05863393f, -0.00254270f, -0.04233168f, 0.02190721f, 0.04112127f, 
    -0.00168159f, 0.01739156f, 0.01812289f, -0.00734576f, 0.01098181f, 0.02953801f, 0.03486873f, -0.03523110f, 
    -0.08351861f, -0.08650630f, -0.03081027f, -0.04327580f, -0.01225331f, -0.03952004f, -0.07463051f, -0.01880915f, 
    -0.04203334f, -0.08485457f, -0.01527132f, 0.05529862f, -0.07939256f, -0.05769296f, -0.03311736f, 0.03575932f, 
    0.01097512f, -0.05007859f, -0.05647526f, -0.04300018f, 0.00650695f, -0.06598520f, -0.03079400f, 0.02911789f, 
    -0.06736466f, 0.04042698f, -0.06786556f, 0.00504358f, -0.05151089f, 0.01224026f, -0.06568702f, -0.03603761f, 
    -0.06568433f, -0.02398741f, -0.04764863f, -0.07711697f, 0.01501054f, -0.03417794f, 0.04912372f, -0.06660710f, 
    0.06033648f, 0.00478779f, -0.00083285f, -0.04520253f, -0.03390184f, 0.00874684f, -0.01650879f, 0.01591638f, 
    0.40472606f, 0.16094652f, -0.05029940f, -0.00818050f, 0.14763278f, 0.05126700f, -0.02306715f, -0.19234832f, 
    0.09150936f, 0.10223233f, -0.06993798f, 0.04645306f, 0.00837165f, -0.13493507f, -0.09486143f, 0.25219235f, 
    0.02567935f, -0.05869024f, -0.18232930f, -0.03960878f, 0.18921135f, -0.00662062f, 0.14310458f, -0.12315471f, 
    -0.02514564f, -0.23701149f, -0.18020780f, 0.32982764f, 0.01501686f, 0.12126200f, -0.06543759f, -0.15425639f, 
    0.01697540f, -0.05549447f, 0.07539140f, 0.12082373f, 0.01430440f, -0.10299375f, 0.17232153f, 0.18066277f, 
    -0.07024447f, 0.10573981f, -0.04006946f, -0.08437821f, 0.05354133f, -0.01184938f, 0.01647598f, -0.07490140f, 
    -0.02397654f, 0.01836555f, -0.09302422f, 0.36078504f, 0.06104310f, -0.11123328f, -0.04902894f, 0.11051366f, 
    0.03917549f, 0.00562910f, 0.00261809f, -0.03222904f, -0.00832783f, 0.11569141f, 0.00706668f, 0.02190800f, 
    0.14802909f, 0.11291546f, 0.12282450f, 0.06590098f, -0.04019175f, 0.06005071f, -0.17898342f, 0.00188350f, 
    -0.14948252f, 0.11473985f, 0.09347036f, -0.21164736f, 0.02493112f, -0.01994937f, 0.12735544f, -0.07027762f, 
    0.04591569f, 0.11096155f, 0.17895906f, -0.05521875f, -0.19565047f, -0.09234388f, 0.16708569f, -0.19393088f, 
    0.02255474f, -0.06323175f, 0.18682738f, -0.14104894f, 0.16843541f, 0.01788693f, -0.00334862f, -0.06114662f, 
    -0.09791883f, 0.06013330f, -0.11754896f, 0.19883679f, -0.07350885f, 0.14471646f, -0.16466983f, -0.06477811f, 
    0.13395551f, -0.07212703f, 0.10674661f, -0.14688776f, 0.01638485f, -0.23200709f, 0.11907805f, 0.24288762f, 
    -0.07644727f, -0.04505611f, 0.08287460f, 0.05547174f, 0.12099333f, -0.01435979f, -0.01180250f, 0.00775097f, 
    0.11651785f, -0.03457152f, 0.09363071f, 0.08486342f, 0.14296751f, 0.09264835f, 0.13845032f, 0.21763191f, 
    0.16758122f, 0.06108962f, -0.14820945f, 0.10197194f, -0.00234595f, 0.03671695f, 0.04845633f, 0.15568145f, 
    -0.03095380f, -0.13183628f, -0.03360622f, -0.05198839f, -0.01882773f, -0.06992727f, 0.02503262f, 0.07993781f, 
    -0.08570076f, 0.42680967f, 0.23166907f, 0.01871687f, 0.05871885f, -0.04078568f, -0.00040188f, 0.09672806f, 
    0.07742851f, 0.00406082f, 0.05686095f, -0.14929366f, -0.35205361f, 0.05007853f, -0.13395828f, -0.11399544f, 
    0.02545798f, 0.08855060f, -0.02669074f, 0.04879373f, 0.04288061f, 0.08679935f, -0.17972031f, 0.10975847f, 
    0.03604499f, 0.00356159f, 0.01548248f, 0.19092432f, -0.10401303f, 0.10844390f, 0.02445661f, -0.07703647f, 
    0.14895341f, 0.04147836f, -0.10515331f, 0.02763909f, 0.45317718f, 0.15633442f, 0.06850328f, -0.10902964f, 
    0.20815308f, -0.00964373f, 0.15291353f, -0.02181916f, -0.04536327f, -0.16332540f, 0.02316904f, 0.01200007f, 
    -0.09672037f, 0.02876960f, -0.08853007f, 0.04248192f, 0.06675624f, -0.01912175f, -0.06239714f, 0.09870017f, 
    0.01549077f, -0.11753925f, 0.00749167f, -0.04227381f, 0.01442568f, 0.13986458f, -0.03804005f, -0.10161098f, 
    0.11255972f, -0.14078160f, 0.00914564f, 0.13315685f, -0.08357336f, 0.04815866f, 0.06046833f, 0.05346241f, 
    0.22286956f, -0.07875842f, -0.15234838f, 0.07477142f, 0.05473006f, -0.16831043f, -0.06575793f, -0.06727298f, 
    -0.00788834f, -0.01401658f, -0.00143688f, -0.08339096f, -0.05090728f, 0.05839421f, 0.08933869f, -0.33222255f, 
    -0.05221948f, 0.03516496f, 0.02080869f, -0.03108220f, -0.06729496f, -0.01635904f, 0.05593202f, 0.02953871f, 
    0.08030712f, -0.19668518f, 0.02309752f, 0.02896473f, 0.05054066f, -0.06596605f, -0.02377302f, -0.01983611f, 
    0.14001776f, 0.02251552f, -0.04324063f, -0.11294938f, -0.26860487f, 0.11006492f, -0.01446899f, -0.21983768f, 
    0.01202779f, -0.15301438f, 0.03003973f, -0.15763602f, -0.01231258f, -0.01003810f, -0.00255865f, -0.09749205f, 
    0.12472365f, -0.26580977f, 0.04737119f, 0.21272047f, -0.08350734f, 0.02150764f, 0.01570330f, 0.02531347f, 
    0.15677889f, -0.05516294f, 0.03784549f, 0.05759485f, 0.25327745f, 0.16891652f, -0.21256797f, -0.00895311f, 
    0.07892188f, 0.00827052f, -0.07017482f, 0.13358136f, 0.05875347f, 0.09818595f, -0.01204023f, 0.10495630f, 
    -0.02058667f, 0.12642384f, -0.24655223f, -0.06402481f, -0.14208838f, -0.10354621f, 0.02752643f, -0.11057778f, 
    0.09907478f, 0.10461341f, 0.07620979f, 0.05497207f, 0.13254073f, 0.15637256f, -0.12589422f, -0.06113570f, 
    0.08828644f, -0.00712212f, 0.01795119f, 0.05256899f, -0.11585301f, -0.05856139f, 0.02322868f, -0.01783755f, 
    -0.22460142f, 0.28453723f, 0.08526772f, -0.05890580f, -0.24722405f, 0.04019381f, 0.05631706f, -0.00801168f, 
    0.10535286f, 0.05713975f, -0.02055952f, -0.05562298f, 0.04457746f, 0.01856333f, 0.00104121f, 0.17519020f, 
    0.26145956f, 0.14418451f, 0.12152439f, -0.04049915f, -0.03890024f, 0.08010128f, 0.06731674f, 0.04715405f, 
    0.16133881f, -0.01201492f, 0.05911201f, 0.03486330f, -0.11511225f, 0.01740554f, -0.02241705f, 0.09777451f, 
    0.03899943f, 0.05625185f, -0.01905612f, -0.07359765f, 0.12327177f, -0.16595599f, 0.06350487f, -0.01215072f, 
    0.13139619f, -0.04892987f, 0.01818155f, -0.02828041f, 0.09839424f, -0.05066359f, -0.00164225f, -0.05092230f, 
    0.10645886f, -0.25330624f, 0.23843552f, 0.08999841f, -0.04535493f, 0.01374953f, 0.04248868f, 0.07725414f, 
    -0.03798613f, 0.16793258f, -0.01331185f, 0.15182754f, 0.20862521f, 0.17301309f, -0.15311678f, 0.12025450f, 
    -0.04505219f, 0.03668764f, 0.08019075f, -0.13889647f, -0.06528153f, 0.02520834f, -0.01260323f, -0.07855566f, 
    -0.25280306f, -0.05910993f, -0.00593094f, -0.23246638f, 0.09825629f, -0.01830964f, -0.02467068f, 0.11043434f, 
    0.09377933f, -0.10738934f, 0.12405454f, -0.00900498f, 0.09319241f, 0.22790514f, -0.03306852f, -0.13633844f, 
    0.05201545f, -0.10557880f, 0.15394117f, 0.04890571f, -0.10620855f, 0.11154158f, -0.06170167f, 0.09567250f, 
    0.13374469f, 0.02521268f, 0.22073507f, -0.48569435f, -0.03706806f, -0.09890863f, -0.12551145f, 0.00438362f, 
    0.01688381f, -0.01773136f, 0.07421534f, 0.18514170f, 0.10383779f, 0.06326590f, -0.14885770f, -0.07627779f, 
    0.08002090f, -0.05251582f, -0.09837946f, -0.07610282f, 0.05136123f, -0.11924184f, 0.01266762f, 0.00756764f, 
    -0.12852824f, -0.12762304f, 0.00700704f, -0.08437470f, 0.07403079f, -0.11796514f, 0.06941923f, -0.10846540f, 
    0.12209115f, -0.09627248f, 0.02272734f, 0.09827428f, -0.11400859f, 0.08244848f, -0.01474539f, -0.13520326f, 
    -0.05685563f, -0.08411407f, 0.04325335f, -0.00650371f, -0.03597701f, -0.05935713f, 0.10066183f, -0.10266323f, 
    -0.05500460f, -0.12368152f, 0.07718669f, 0.07694597f, 0.11524257f, 0.04528720f, 0.13498388f, 0.09412145f, 
    0.08034892f, -0.07690532f, 0.01187864f, 0.02831199f, 0.25106978f, -0.01674913f, -0.05221800f, 0.20264149f, 
    0.18480337f, -0.02629765f, -0.06295774f, 0.17007770f, 0.00494222f, 0.00111398f, 0.09228645f, 0.01613055f, 
    0.23763889f, 0.10816043f, -0.02132048f, 0.00600038f, -0.13291261f, -0.05244555f, 0.02575161f, 0.11899579f, 
    0.08946048f, 0.11972491f, -0.05417058f, 0.07337727f, 0.28462595f, 0.03326818f, -0.02893293f, -0.09964287f, 
    0.19830173f, 0.03279049f, 0.01918171f, 0.11770499f, -0.07474250f, 0.04656037f, -0.00842239f, 0.10748328f, 
    -0.19558756f, 0.20350006f, -0.18724380f, -0.10212656f, 0.03878591f, 0.08162275f, 0.02870221f, -0.10976011f, 
    -0.06572989f, -0.04484909f, 0.04476350f, -0.12545775f, 0.04238406f, -0.01383800f, 0.03707505f, 0.21058440f, 
    0.12886801f, -0.00131436f, 0.15674026f, 0.08766983f, -0.10032059f, 0.00496760f, 0.17339146f, 0.08241357f, 
    -0.28569037f, 0.02416310f, -0.28150725f, -0.00529092f, -0.01139995f, 0.13276923f, -0.03661935f, -0.00794446f, 
    0.05341300f, 0.03299363f, 0.03338679f, -0.07133476f, -0.14234909f, -0.00586035f, 0.03694352f, 0.11150695f, 
    0.12711526f, 0.11974302f, 0.09352371f, 0.04121164f, 0.10969112f, -0.01260535f, 0.06656861f, -0.00620044f, 
    0.15040542f, -0.02015883f, 0.11343995f, -0.19729531f, 0.01412769f, 0.10386503f, -0.05777295f, 0.01838336f, 
    0.01760350f, 0.05322615f, 0.13605313f, 0.15093806f, 0.17186800f, -0.26101139f, -0.25973898f, 0.08531047f, 
    0.01105222f, -0.00268020f, 0.11076690f, -0.04195162f, 0.01563380f, 0.01950051f, -0.00031167f, -0.05955235f, 
    -0.17586137f, -0.25293803f, 0.00205105f, 0.08334531f, 0.09204780f, 0.08345892f, 0.21750480f, 0.17998603f, 
    0.19063966f, -0.01592883f, 0.17316431f, 0.10615812f, -0.04984366f, 0.00522959f, 0.15739045f, -0.11976919f, 
    -0.10886231f, 0.12357859f, 0.03655347f, 0.03925031f, 0.00135283f, -0.07695623f, 0.04738341f, 0.10337758f, 
    0.34722677f, 0.20706530f, -0.02798032f, 0.02436673f, -0.05489975f, 0.03777924f, 0.00447676f, 0.02372646f, 
    0.08444574f, 0.00474290f, -0.06685007f, -0.11761288f, -0.12622821f, 0.08236785f, -0.10843136f, -0.19304834f, 
    0.03950319f, -0.08376469f, -0.00987957f, 0.18750334f, -0.12645613f, 0.06706893f, -0.06248465f, 0.04386908f, 
    0.10264079f, 0.01196443f, -0.03215680f, -0.19918215f, 0.13351218f, -0.00966331f, -0.07893575f, 0.05144231f, 
    0.03176443f, 0.08486301f, -0.10562717f, 0.14652872f, -0.03790757f, -0.02814764f, 0.09344481f, -0.08248462f, 
    -0.08766434f, -0.05096627f, -0.03260070f, 0.06991043f, -0.05721215f, 0.16323872f, 0.29622516f, 0.03470772f, 
    0.15268198f, -0.24427761f, 0.02176947f, 0.09484913f, -0.00760051f, 0.01763811f, 0.06860616f, 0.07513636f, 
    0.12193799f, -0.08574544f, -0.08808808f, 0.08952818f, -0.03773937f, 0.01137763f, -0.11929232f, -0.16163236f, 
    -0.00767252f, 0.09528005f, -0.02203025f, -0.07866161f, -0.03349831f, 0.12994343f, 0.05465076f, -0.02580244f, 
    0.17987405f, 0.08929366f, 0.11140304f, -0.08096993f, 0.06894275f, 0.08150949f, 0.02769182f, -0.08968797f, 
    -0.06403966f, 0.03936353f, -0.16491155f, 0.06945255f, 0.00885953f, -0.02293471f, -0.03550630f, -0.00557801f, 
    0.03467713f, 0.04480753f, -0.05940441f, 0.00048630f, -0.18963963f, -0.08649421f, -0.05129699f, -0.09014598f, 
    -0.18951783f, 0.25779194f, 0.10214540f, 0.02607793f, -0.32412180f, -0.11999748f, -0.10231645f, -0.14446412f, 
    -0.13203613f, -0.06111491f, 0.03579693f, -0.08991725f, -0.12375854f, 0.19002536f, -0.17348982f, -0.07698980f, 
    0.13569140f, 0.01145501f, -0.00485609f, 0.08700688f, 0.07673469f, 0.00969937f, -0.10687348f, -0.18316907f, 
    0.31244263f, -0.26727879f, 0.07258742f, 0.14033568f, -0.04620685f, 0.10173869f, -0.07149860f, 0.02506366f, 
    0.03914351f, -0.01564680f, 0.06339517f, 0.10237490f, 0.47108665f, 0.08987526f, -0.08199465f, -0.07558423f, 
    0.01663899f, -0.01046276f, 0.03655727f, -0.09693238f, -0.01713166f, 0.03164543f, 0.18573876f, -0.12535483f, 
    0.29818904f, 0.02193346f, 0.15942998f, 0.06079670f, -0.00916873f, 0.02162064f, -0.11193635f, -0.07478250f, 
    0.00618613f, -0.05368472f, 0.21221502f, -0.07743856f, -0.07123301f, -0.04287804f, 0.18115467f, 0.31805634f, 
    0.00800619f, -0.04429784f, 0.05215649f, 0.03404845f, -0.00932220f, 0.16831462f, -0.00601183f, -0.08741964f, 
    -0.23325302f, -0.01624357f, -0.17651339f, -0.10801526f, 0.12511608f, -0.03581142f, 0.06971144f, -0.01284850f, 
    -0.05112282f, -0.02499525f, 0.12048315f, 0.16039549f, 0.16298994f, 0.18002474f, 0.06309519f, -0.00422183f, 
    0.09813685f, 0.05389214f, 0.01205839f, 0.05674187f, 0.06685167f, -0.02529172f, -0.02921603f, 0.00069184f, 
    0.15056564f, 0.01704982f, -0.28963345f, -0.17071956f, 0.20756410f, -0.04140472f, -0.09157638f, -0.07185299f, 
    0.04922008f, 0.00929709f, 0.05500009f, -0.00155468f, -0.05224394f, -0.05743292f, -0.03516960f, -0.26471943f, 
    -0.09727433f, 0.00172784f, -0.05362156f, 0.13291310f, -0.07211620f, 0.03279737f, -0.03379768f, -0.02254135f, 
    -0.32514751f, -0.16026197f, 0.01996328f, -0.11565668f, 0.18847455f, 0.03466628f, 0.06602026f, -0.05252483f, 
    0.14214797f, -0.05426427f, -0.10572749f, -0.01187869f, -0.11021478f, 0.15138978f, -0.10856669f, -0.07305803f, 
    -0.00895121f, -0.02222209f, 0.04232879f, 0.00863673f, 0.04726729f, 0.02293127f, 0.10347741f, -0.05677312f, 
    0.18596478f, -0.00655372f, 0.06099061f, 0.25221562f, 0.10692975f, 0.01916600f, 0.09422661f, 0.03303064f, 
    0.09424695f, 0.01502637f, 0.07806534f, 0.08250616f, 0.19618936f, 0.16964929f, 0.14518553f, -0.05230459f, 
    0.06203942f, 0.13177113f, -0.20564631f, 0.06658056f, 0.00247645f, -0.00264333f, 0.15169045f, 0.01788257f, 
    0.17931721f, 0.10482872f, -0.31581515f, -0.11607651f, -0.01514336f, 0.05689833f, 0.00689371f, 0.01232733f, 
    -0.00040974f, -0.06355296f, 0.01493675f, 0.05835645f, 0.25211471f, 0.11413080f, -0.06283784f, 0.06239308f, 
    0.17162780f, 0.03394467f, 0.14932252f, -0.02241161f, -0.19557109f, -0.01720127f, -0.01353112f, -0.09419491f, 
    -0.18679591f, 0.12280068f, -0.01082766f, -0.08784498f, -0.30831638f, 0.08229974f, -0.05023506f, -0.20829676f, 
    0.07673106f, -0.02754608f, 0.04358021f, 0.00682656f, 0.22019587f, 0.01148679f, -0.14534850f, 0.04230903f, 
    0.23450361f, 0.20036212f, 0.01194927f, 0.06583627f, -0.01411590f, 0.05798713f, -0.01827681f, -0.02557163f, 
    0.47515830f, -0.06174642f, 0.10981034f, 0.00730845f, -0.13383754f, -0.05061553f, -0.01192776f, 0.18693534f, 
    -0.04735650f, -0.01316312f, 0.06725802f, -0.16548362f, 0.23171782f, -0.07192412f, 0.09564992f, -0.02674331f, 
    0.11612292f, 0.02923151f, 0.06935615f, -0.07899524f, 0.15123633f, 0.12394737f, 0.10424091f, 0.04061470f, 
    -0.05902913f, -0.19723709f, -0.05183524f, -0.12013222f, 0.06504671f, 0.04387701f, -0.08161423f, 0.04399830f, 
    -0.08931419f, 0.02189643f, 0.18989499f, 0.03009501f, 0.13651270f, -0.04998516f, -0.02221650f, 0.05901431f, 
    -0.14289287f, -0.12271430f, 0.11666040f, 0.04012146f, -0.03418040f, 0.07347716f, -0.07069954f, -0.04426270f, 
    0.14649601f, -0.16777721f, 0.08259584f, 0.04684849f, 0.13291210f, 0.03963807f, 0.15524068f, 0.06623379f, 
    0.14803551f, 0.13461536f, 0.04699262f, 0.21630101f, -0.09020893f, -0.17602408f, 0.09167381f, 0.19111221f, 
    -0.08947355f, 0.10962396f, 0.00718169f, -0.02552242f, 0.10714130f, -0.11280131f, 0.09651816f, 0.04349380f, 
    0.25007215f, 0.19256185f, -0.02861359f, 0.28619239f, -0.07158649f, 0.06407902f, -0.00331198f, -0.05335299f, 
    0.04546167f, -0.04345883f, 0.03749743f, -0.12552911f, -0.38975048f, -0.11535295f, 0.03334755f, -0.00300975f, 
    0.13108219f, 0.04524136f, 0.10106421f, 0.09479735f, -0.03081070f, 0.09604095f, -0.14366329f, 0.00202593f, 
    0.15124927f, -0.14103794f, -0.11052327f, -0.10034484f, -0.00060848f, 0.04835664f, 0.05985567f, 0.00651899f, 
    0.04233151f, 0.17456682f, -0.09146728f, 0.04334281f, 0.10237995f, -0.03904638f, -0.01223950f, 0.04359995f, 
    0.06039099f, 0.10374216f, -0.04201708f, 0.02393471f, -0.03659941f, 0.06240066f, 0.14260489f, 0.02908067f, 
    0.09236208f, -0.17988923f, 0.09627650f, -0.11882000f, 0.06078271f, 0.01164516f, 0.00601964f, 0.07602839f, 
    -0.06889582f, -0.04482066f, -0.13764666f, -0.02762418f, -0.23291373f, -0.13625859f, 0.01001905f, -0.14885220f, 
    -0.08186901f, 0.04253084f, 0.04457658f, -0.05699169f, -0.00408681f, -0.02431351f, 0.02988756f, 0.01419654f, 
    -0.01608840f, 0.15454030f, -0.06637236f, -0.03029230f, 0.06146054f, 0.07762917f, 0.05522362f, -0.13211343f, 
    0.04800617f, -0.12030385f, -0.07280573f, 0.04948962f, -0.04982854f, -0.00540510f, 0.25477201f, 0.08739296f, 
    -0.02078987f, -0.03581352f, -0.04871809f, -0.07107993f, -0.07117958f, -0.02498914f, -0.09116179f, -0.02304432f, 
    -0.17900012f, -0.14121073f, 0.04230086f, 0.01149926f, -0.12520303f, -0.16485880f, -0.07361099f, -0.01962436f, 
    0.00510074f, -0.05681043f, -0.07063424f, 0.04360535f, -0.11884649f, 0.31270716f, 0.04372081f, -0.34157571f, 
    0.01317565f, -0.03561777f, 0.03503145f, -0.02799455f, -0.03141692f, -0.05820481f, -0.00655666f, -0.13033558f, 
    0.20586857f, -0.01870511f, -0.00415492f, -0.10204110f, 0.05807912f, -0.04742861f, 0.05217183f, 0.13547446f, 
    -0.00846018f, -0.00589547f, 0.07660662f, 0.12380326f, 0.46587279f, 0.03545236f, -0.10430734f, -0.16468909f, 
    -0.10048375f, 0.02823806f, 0.06367064f, -0.10440671f, 0.05621444f, 0.05641850f, 0.08691693f, -0.17274027f, 
    0.10483449f, 0.18632381f, -0.00101866f, 0.23855382f, 0.10826682f, -0.07277301f, -0.06345484f, -0.01785703f, 
    0.09810816f, -0.09271000f, 0.19810466f, 0.00399513f, -0.14988616f, -0.11602952f, 0.25435561f, 0.10279771f, 
    0.05079546f, -0.00381629f, 0.13065602f, 0.10852243f, -0.11015042f, 0.07186194f, 0.00197989f, 0.02411635f, 
    -0.07260993f, -0.21928844f, 0.16171569f, -0.06709811f, -0.09313101f, 0.14592806f, 0.18967308f, -0.02796907f, 
    -0.00145816f, 0.03065152f, 0.01847157f, 0.13917851f, 0.12646212f, -0.09032280f, 0.14886504f, 0.18803993f, 
    0.08462362f, 0.02402697f, -0.04394151f, 0.04060676f, 0.00564931f, -0.07363253f, 0.07397264f, 0.02859383f, 
    0.06694274f, 0.18087725f, 0.14785804f, -0.13102283f, -0.18593022f, 0.09587649f, 0.09276067f, 0.00472948f, 
    0.16098133f, -0.01849165f, 0.01497448f, 0.17613803f, -0.02694567f, 0.00039252f, -0.04517614f, 0.29362538f, 
    0.10462463f, 0.00553956f, 0.15302190f, 0.03729260f, 0.04129951f, -0.01156401f, -0.14977789f, 0.02647173f, 
    0.32019645f, -0.01159759f, 0.01851327f, 0.24922639f, 0.03248552f, 0.03566943f, 0.03058491f, 0.16655676f, 
    -0.08212022f, 0.11022872f, 0.06898408f, 0.07181774f, 0.14243074f, -0.06729367f, 0.16588242f, 0.06819399f, 
    0.01964816f, 0.02447578f, -0.05665179f, 0.10544054f, 0.01745957f, 0.15690421f, 0.09789523f, -0.02203388f, 
    -0.08494876f, -0.04362623f, 0.04788579f, -0.15665184f, 0.01885298f, 0.12555797f, 0.04610657f, 0.07059163f, 
    0.01385817f, 0.13670087f, -0.03036571f, 0.10664064f, -0.19051827f, -0.13542689f, 0.16934679f, 0.16488138f, 
    -0.06945091f, 0.09276956f, 0.21414264f, -0.01064368f, 0.02805421f, -0.12402213f, -0.12016524f, 0.03312317f, 
    -0.17031841f, -0.01293060f, 0.26456216f, 0.00139123f, -0.05297029f, -0.04917904f, -0.01595279f, 0.02781967f, 
    0.07409513f, 0.11614648f, -0.07404248f, -0.11537272f, 0.12271115f, -0.01967522f, 0.16593733f, 0.13527319f, 
    0.02253092f, -0.01597584f, 0.09671674f, 0.00587575f, 0.14764924f, 0.08781759f, -0.10829639f, 0.08863789f, 
    0.02179604f, -0.18767269f, -0.11724240f, -0.04431002f, 0.12455186f, 0.03750408f, -0.02875652f, 0.02756996f, 
    -0.07936295f, -0.01375409f, 0.02484835f, -0.03013414f, -0.17728537f, 0.10674004f, 0.16807653f, -0.03466299f, 
    -0.19734715f, -0.03162628f, 0.08474284f, -0.00417277f, -0.04248743f, -0.05999719f, 0.03523365f, 0.01265697f, 
    -0.33633432f, -0.08642730f, -0.16975036f, -0.11274279f, 0.04806468f, 0.07422994f, -0.00657284f, -0.01902497f, 
    0.12502111f, 0.00279603f, -0.00392967f, 0.12494987f, -0.36440611f, 0.07780459f, 0.10726155f, 0.05319494f, 
    -0.09714759f, -0.06353944f, -0.00083262f, 0.10552184f, 0.01796137f, -0.00429383f, -0.00177328f, -0.05907819f, 
    0.26197088f, 0.20292501f, -0.03907901f, -0.07707479f, 0.03972254f, 0.01469618f, 0.02471150f, 0.08876661f, 
    0.07393599f, -0.10227580f, 0.07535642f, -0.03485601f, 0.14456952f, -0.25550458f, -0.08733049f, 0.02993209f, 
    0.14942482f, 0.04063854f, 0.11471748f, 0.04491428f, -0.01258726f, 0.13416943f, 0.03789697f, 0.00743195f, 
    -0.03123659f, -0.01821061f, 0.04926888f, -0.02311985f, 0.03228295f, -0.05831288f, -0.00032827f, -0.05375639f, 
    -0.03497859f, -0.00213488f, -0.03102991f, 0.03327004f, 0.05976022f, 0.02655077f, 0.02578342f, -0.05267921f, 
    0.05402144f, 0.05827003f, -0.06740647f, -0.06749644f, 0.00004162f, 0.02335471f, 0.03912167f, 0.02821069f, 
    0.05035309f, 0.05398918f, -0.00909037f, -0.05181012f, 0.06011220f, 0.00697719f, 0.01912933f, -0.01359704f, 
    -0.00739709f, -0.02077497f, 0.05529423f, -0.04686176f, -0.00719075f, -0.07760955f, -0.02529671f, 0.02014709f, 
    -0.00092420f, -0.00071396f, -0.04851918f, -0.07270202f, -0.06758780f, 0.03746048f, 0.01362183f, 0.01589497f, 
    0.00670771f, -0.00956998f, 0.06439947f, -0.03407039f, -0.00070115f, -0.06888453f, -0.07863808f, 0.01369762f, 
    -0.00798755f, 0.00153181f, -0.06541935f, 0.05357265f, -0.00254736f, -0.00592481f, -0.04054159f, -0.04549068f, 
    -0.02713222f, 0.05948513f, -0.03232519f, -0.02070798f, 0.02117076f, 0.05220102f, 0.02147377f, 0.02135009f, 
    0.03311970f, -0.06485306f, -0.03592116f, -0.07546294f, -0.04341906f, 0.03130703f, 0.04183909f, -0.04649035f, 
    0.00594055f, -0.00470498f, -0.03813659f, -0.06702507f, -0.07756881f, 0.01232345f, 0.04574392f, -0.06677815f, 
    0.02429206f, -0.06903098f, 0.05319059f, -0.01732587f, -0.05811691f, -0.05542768f, -0.05785621f, -0.07629108f, 
    -0.07198075f, 0.01410704f, -0.02604670f, -0.06095626f, -0.04685508f, 0.03518419f, -0.01865900f, -0.04653600f, 
    -0.00963350f, -0.01675140f, -0.05586129f, -0.05501105f, -0.00753110f, 0.05982270f, 0.02620211f, 0.02731008f, 
    0.00744871f, 0.05915846f, 0.02669046f, 0.04567176f, -0.02636361f, 0.03079360f, -0.07584812f, -0.03697702f, 
    0.05642033f, 0.04678004f, 0.06427689f, -0.02968308f, -0.04335202f, 0.00775917f, -0.03294087f, 0.01242448f, 
    -0.07309824f, 0.04323978f, 0.04831806f, 0.02057517f, 0.04097531f, -0.00577856f, -0.04609979f, 0.05901729f, 
    0.04312324f, 0.02729932f, 0.03518181f, 0.02168023f, 0.01131272f, 0.05533574f, 0.01749971f, -0.03271865f, 
    -0.02864994f, -0.04064687f, 0.02232566f, -0.00292179f, -0.00940843f, -0.02178365f, 0.04172348f, -0.01537481f, 
    -0.06977349f, 0.04480616f, -0.05657028f, -0.06932172f, -0.02639800f, -0.05866940f, -0.07184821f, -0.00653102f, 
    0.02158966f, 0.03302008f, -0.02873720f, -0.05209171f, 0.06080131f, 0.04928962f, -0.04189402f, -0.04565896f, 
    -0.07921374f, -0.04569743f, 0.04336915f, -0.06938117f, -0.07732922f, -0.02336610f, 0.05215910f, -0.06276958f, 
    0.03691409f, 0.05517163f, 0.02522264f, 0.02677735f, -0.01510625f, -0.01484548f, -0.03543126f, 0.04096754f, 
    0.00077531f, -0.06458271f, -0.06486985f, -0.05477584f, -0.02711016f, -0.03983878f, 0.01136238f, -0.00444564f, 
    0.31764171f, 0.07489455f, 0.20060007f, 0.02173454f, -0.09973468f, -0.03512174f, 0.03070673f, -0.05412026f, 
    -0.00284972f, -0.05999257f, -0.00945143f, -0.05563919f, 0.02706221f, -0.17962503f, 0.08170693f, 0.05564059f, 
    -0.01390565f, 0.12526871f, -0.02927129f, -0.03266165f, -0.03828244f, 0.01749045f, -0.01096778f, 0.07845911f, 
    -0.25444469f, 0.13103443f, 0.28148675f, -0.02675483f, -0.13681297f, 0.15471506f, -0.01378821f, 0.07830952f, 
    0.08241655f, -0.09664107f, -0.08398619f, -0.09244488f, 0.11405367f, 0.09065801f, 0.06690195f, 0.28216901f, 
    0.18668477f, 0.08059303f, 0.07855573f, -0.05313870f, 0.01916219f, 0.03995347f, 0.00615992f, 0.03256838f, 
    0.05896670f, 0.05077889f, -0.05579201f, 0.23358813f, -0.04066534f, 0.05979726f, -0.00871424f, 0.09168044f, 
    -0.10755685f, -0.01417872f, 0.01614136f, 0.17349364f, 0.29353213f, -0.22145137f, 0.12606682f, 0.17810388f, 
    0.01705436f, 0.04486120f, 0.03359081f, -0.00848734f, -0.08392491f, 0.06417711f, 0.07065625f, 0.08416520f, 
    -0.32876024f, 0.21684502f, -0.05577960f, -0.22664045f, -0.00753998f, -0.04094664f, 0.05849210f, 0.15337127f, 
    -0.08943672f, 0.03931950f, 0.01068578f, -0.05844427f, -0.20381351f, -0.10277833f, 0.16183007f, 0.00749320f, 
    -0.05583973f, -0.06178014f, 0.27281725f, -0.16679509f, -0.02649773f, -0.09771731f, -0.05996189f, 0.00713143f, 
    0.03472224f, -0.06066509f, 0.22612853f, 0.03527411f, 0.09229719f, 0.01292300f, -0.00945516f, 0.00341360f, 
    -0.02046662f, 0.07739119f, -0.10857489f, -0.04490407f, -0.09843363f, -0.11550861f, 0.16827829f, 0.07350276f, 
    0.10345430f, -0.02538957f, -0.02330237f, -0.00279315f, 0.18569653f, 0.04659844f, -0.05720571f, 0.02228548f, 
    0.15086053f, -0.13469356f, -0.01636424f, 0.24757816f, 0.23301814f, 0.09381470f, 0.05157506f, 0.11894914f, 
    -0.13418061f, -0.06967823f, -0.05889476f, 0.05221242f, -0.19942488f, -0.00042380f, 0.04397766f, 0.04618740f, 
    -0.19289450f, -0.15429014f, -0.10436098f, -0.12053303f, 0.10626037f, -0.05703377f, 0.05313276f, -0.05784912f, 
    -0.30597368f, 0.11877251f, 0.11835298f, 0.12309666f, 0.12046485f, 0.04230804f, 0.05685347f, -0.05852276f, 
    0.12744978f, 0.03212107f, 0.03234754f, 0.11801769f, -0.05547939f, 0.24319130f, 0.06489988f, -0.06354190f, 
    -0.06441150f, 0.02002326f, -0.06259742f, 0.10854644f, -0.01999221f, -0.00557905f, -0.01547940f, 0.00204446f, 
    0.11221050f, 0.33399072f, 0.01193083f, -0.14898258f, -0.00769002f, -0.06742670f, 0.07008268f, -0.03287137f, 
    0.02495072f, -0.01788119f, -0.00063892f, 0.03847691f, -0.16190235f, 0.05821902f, 0.13923240f, 0.17852452f, 
    0.13605368f, 0.06776018f, 0.10645651f, 0.13582189f, -0.01540676f, 0.03220773f, 0.16640058f, 0.06028659f, 
    0.18828833f, -0.04372844f, -0.02987385f, -0.05478858f, 0.17549244f, -0.01665344f, 0.02738098f, 0.07446451f, 
    0.11319592f, 0.07141711f, -0.01188250f, 0.06439228f, -0.08293360f, 0.01319141f, -0.22690150f, -0.12001529f, 
    0.02990228f, 0.00598227f, 0.12182526f, -0.01042029f, -0.05033648f, -0.00544850f, 0.07812903f, 0.11783757f, 
    0.28843224f, 0.06548969f, 0.05918022f, 0.15599599f, 0.08732285f, 0.08552116f, 0.04033067f, -0.02603158f, 
    -0.12192558f, -0.17237908f, 0.01810303f, -0.01198855f, -0.21789876f, -0.11928521f, 0.02458441f, -0.08579081f, 
    0.15866584f, 0.10725910f, -0.07925051f, 0.15740645f, -0.01836817f, 0.09630726f, 0.07847808f, 0.15398586f, 
    0.13848116f, -0.19951823f, -0.05650027f, -0.09060685f, -0.06256191f, 0.02744468f, 0.09141517f, -0.02553221f, 
    -0.00446003f, 0.07115301f, -0.10049619f, 0.12159094f, -0.01792908f, 0.04384154f, -0.18973258f, -0.11959177f, 
    -0.02427711f, -0.00185068f, 0.04258837f, -0.10507658f, -0.05215491f, -0.15611555f, -0.08834007f, -0.00456278f, 
    -0.11928149f, -0.19530952f, 0.09780570f, -0.14771315f, 0.16450998f, -0.08144486f, -0.07167030f, -0.04923782f, 
    -0.03183083f, -0.08902580f, 0.03133592f, -0.09734789f, 0.20051381f, -0.16499737f, 0.07482892f, -0.19894662f, 
    0.04679450f, -0.11160360f, 0.02056667f, 0.11140211f, -0.02243843f, 0.12135724f, 0.06141139f, -0.04807652f, 
    -0.02253696f, 0.19732256f, -0.19136065f, -0.03145399f, -0.05986401f, 0.21354344f, -0.04977407f, -0.08942548f, 
    -0.01687441f, -0.11767807f, -0.02567700f, 0.05461598f, 0.22214001f, -0.17006914f, 0.09609561f, -0.03906927f, 
    -0.02034439f, 0.01038266f, -0.12735008f, 0.04051816f, 0.07811408f, 0.01081969f, 0.08571610f, -0.05654613f, 
    -0.01847456f, 0.10356338f, -0.07882905f, 0.04869208f, 0.07872467f, -0.01802773f, -0.05837240f, 0.14206126f, 
    0.10355513f, 0.10689220f, -0.01085049f, 0.17922254f, 0.07525642f, 0.04197024f, 0.06532145f, -0.20184062f, 
    0.02734515f, 0.05274822f, 0.12076951f, -0.07841479f, -0.00648164f, 0.08585330f, -0.02054960f, 0.02700617f, 
    0.07124845f, 0.16119987f, -0.13227506f, 0.10089272f, -0.04265213f, -0.09473694f, -0.10299950f, 0.10373414f, 
    0.02076927f, 0.07568823f, 0.04233382f, -0.03856022f, 0.28937635f, -0.34075856f, -0.19916986f, 0.01854419f, 
    -0.02901798f, 0.06442922f, 0.05352103f, 0.10176679f, -0.05352051f, 0.01759892f, -0.10742538f, 0.07544567f, 
    0.03548060f, 0.16902027f, 0.11453653f, 0.17307629f, 0.03453716f, 0.06887534f, 0.12423293f, 0.05395652f, 
    0.02562865f, 0.09199462f, 0.09046038f, 0.06315896f, 0.06367730f, -0.12243760f, 0.05649907f, -0.06463092f, 
    -0.00642598f, -0.13349587f, 0.07996677f, 0.10474262f, 0.01232761f, -0.04158482f, 0.05794531f, -0.07761468f, 
    0.03773455f, -0.03134375f, -0.05355362f, 0.05233845f, -0.04096007f, -0.06918107f, -0.06571194f, 0.02708582f, 
    -0.06213848f, 0.04173114f, -0.07070472f, 0.05947785f, -0.01880618f, -0.04351112f, -0.01573347f, -0.02671046f, 
    -0.03224438f, 0.02177209f, 0.02507196f, 0.06314075f, 0.05650493f, 0.00198857f, 0.00619895f, -0.01573894f, 
    -0.08686788f, -0.04773737f, 0.05610585f, -0.05907416f, 0.02595520f, 0.02216722f, 0.05473817f, -0.04452491f, 
    0.02711533f, 0.00801278f, -0.03771662f, -0.05031231f, -0.01523483f, -0.04925996f, 0.02071181f, 0.00125311f, 
    -0.05273940f, 0.02520115f, -0.06529514f, -0.01060861f, -0.03612639f, 0.05075708f, 0.02135924f, -0.05841807f, 
    -0.08589406f, -0.02478226f, -0.04283744f, 0.00843838f, -0.08406267f, 0.03570291f, -0.01449586f, 0.04867792f, 
    0.05625713f, 0.03643858f, -0.05953276f, 0.06409635f, -0.02239850f, 0.02222459f, -0.07337225f, -0.02169017f, 
    -0.02695572f, -0.05817718f, -0.02325875f, -0.06094471f, -0.06889245f, -0.02423417f, 0.04878226f, -0.05931168f, 
    -0.06027191f, -0.04010499f, -0.06332228f, 0.05537388f, 0.00393785f, 0.00828411f, -0.04351055f, -0.06055931f, 
    -0.00334105f, -0.06005519f, -0.02824741f, 0.05057408f, 0.03992295f, 0.04516546f, 0.04543047f, -0.07853949f, 
    0.06200615f, 0.01631850f, -0.02930046f, 0.04396308f, 0.03211379f, 0.03062220f, -0.01511952f, -0.02854370f, 
    -0.03019051f, -0.05883732f, 0.01805792f, -0.02217453f, -0.07710858f, -0.06317505f, -0.03205673f, -0.03617804f, 
    0.02074922f, 0.03133738f, 0.01190826f, 0.03457998f, -0.01333940f, 0.02104188f, -0.00742599f, 0.01684230f, 
    -0.06395344f, 0.02410393f, -0.05284441f, 0.01190070f, -0.04175832f, 0.03931123f, -0.07575585f, -0.01527195f, 
    -0.06908685f, 0.05560144f, -0.01209651f, -0.02642392f, -0.02879179f, 0.00449803f, -0.01020593f, -0.05389388f, 
    0.00012670f, -0.06054511f, -0.00599438f, 0.01415086f, -0.02480065f, 0.00686855f, 0.04362804f, -0.02480955f, 
    -0.05006776f, 0.03374342f, 0.05010578f, -0.05880403f, -0.01888234f, 0.03913798f, -0.03005543f, -0.07424217f, 
    -0.01459486f, 0.05249882f, 0.05589639f, -0.02726884f, -0.02294996f, -0.03133712f, 0.05569291f, -0.04186597f, 
    0.05121766f, -0.06317767f, -0.04280169f, 0.05159548f, 0.01849488f, -0.00374041f, -0.02445797f, -0.04299339f, 
    -0.04246021f, 0.03585947f, -0.05226752f, 0.05415937f, -0.04294694f, 0.02735014f, -0.02462872f, 0.05306993f, 
    0.04584913f, 0.04252325f, -0.06383527f, -0.02383945f, -0.05156844f, -0.07680599f, -0.00585383f, -0.07207315f, 
    -0.03282515f, 0.03888328f, -0.02447548f, -0.00006920f, 0.03602780f, -0.02140215f, 0.02210404f, 0.03932982f, 
    0.04640869f, 0.00791430f, 0.03269823f, 0.03448739f, 0.03167882f, 0.01470803f, -0.03376647f, -0.00200106f, 
    0.38767874f, 0.17437378f, -0.06229775f, 0.04889014f, 0.09388500f, -0.10461428f, -0.01961914f, -0.09461772f, 
    0.05538442f, -0.07895383f, -0.00866051f, -0.06842522f, -0.19401976f, -0.01236039f, -0.17660731f, -0.03657949f, 
    -0.01653886f, -0.01775849f, 0.11427396f, -0.00357055f, 0.10785601f, 0.10986033f, -0.06347708f, 0.00377859f, 
    0.07861867f, -0.08625669f, 0.17068571f, 0.06470310f, 0.12849984f, -0.00579219f, -0.09323596f, -0.19755258f, 
    -0.04770304f, -0.00444346f, 0.10872905f, 0.05905307f, -0.21523266f, -0.16413423f, -0.04707812f, 0.04788566f, 
    -0.03638557f, 0.01710325f, -0.14161818f, 0.03848254f, 0.09528908f, -0.00405640f, 0.17514814f, 0.12105338f, 
    -0.29915974f, 0.20458098f, -0.11496428f, 0.02528510f, -0.04292358f, 0.00422213f, 0.09447986f, -0.03274866f, 
    0.08413123f, -0.06934324f, 0.11384942f, 0.03656212f, 0.05186973f, 0.04973826f, 0.00230234f, -0.07675584f, 
    0.10191678f, 0.04938493f, 0.09129423f, 0.02876086f, 0.05283768f, -0.04573766f, -0.02515425f, 0.16644809f, 
    -0.03288866f, -0.04581533f, 0.09051479f, -0.10314892f, 0.10001494f, 0.06801085f, -0.04143322f, -0.01944915f, 
    0.03039494f, -0.01959723f, -0.01068884f, 0.03226299f, 0.11794550f, 0.15758194f, 0.08221822f, -0.26484099f, 
    0.17372268f, -0.14883532f, 0.02759785f, 0.00873157f, -0.00514123f, -0.06731170f, 0.01705175f, 0.06601565f, 
    0.36298785f, -0.02722592f, -0.01612103f, 0.18020187f, 0.02304353f, 0.06164629f, -0.02805821f, 0.05745034f, 
    0.03610283f, 0.11811947f, 0.08195322f, 0.00136256f, -0.06517160f, -0.02607394f, -0.09463707f, 0.02887117f, 
    0.07611025f, -0.10377363f, 0.02880328f, -0.06340386f, 0.00787406f, 0.05620174f, 0.08109602f, -0.00215010f, 
    -0.13669701f, -0.09556503f, -0.08803948f, 0.11690172f, 0.09628778f, -0.01104012f, -0.05024787f, 0.01727971f, 
    0.08521114f, 0.03923073f, 0.06636528f, 0.00484913f, 0.02622552f, 0.02319535f, -0.11432925f, 0.23690744f, 
    0.03774661f, 0.04139003f, 0.08008421f, 0.00332387f, -0.01673435f, -0.05343980f, 0.09975135f, 0.06362913f, 
    -0.41263211f, -0.14801544f, -0.00499545f, -0.01253183f, -0.03274629f, -0.04466321f, -0.02474432f, 0.05624496f, 
    0.12210945f, -0.00251509f, -0.07796459f, -0.16639769f, -0.11553958f, 0.16200230f, -0.08907184f, -0.20830257f, 
    0.10387611f, 0.07009001f, 0.00517574f, 0.14253905f, -0.00913090f, -0.10608201f, -0.03781264f, 0.03249452f, 
    0.10219995f, 0.12789533f, 0.01584839f, 0.15190041f, 0.16600926f, 0.10650332f, 0.03542582f, 0.02126662f, 
    0.07251336f, 0.14110868f, -0.01161741f, 0.10346867f, -0.04732282f, -0.05469816f, 0.17037238f, 0.08168641f, 
    -0.02175127f, -0.01838569f, -0.06159737f, 0.02293175f, -0.08165677f, -0.11078485f, 0.04011991f, -0.11331619f, 
    -0.06299638f, 0.05789574f, -0.05895428f, -0.00415334f, 0.05335186f, -0.01063572f, -0.07280879f, -0.04720460f, 
    -0.01100294f, -0.01073604f, 0.02550616f, 0.04968516f, 0.04789467f, -0.01203038f, -0.00305778f, 0.02109551f, 
    0.06615709f, -0.05384216f, -0.03851556f, 0.00022811f, -0.01486734f, -0.01461260f, -0.05818813f, 0.07082168f, 
    0.01798216f, 0.00854562f, -0.05679558f, 0.01277419f, -0.04523378f, 0.03103413f, -0.04049386f, -0.06099983f, 
    0.05564103f, -0.05244536f, -0.00106798f, -0.06055365f, 0.01228588f, -0.04336938f, 0.02574212f, 0.04945676f, 
    0.02259635f, 0.05088208f, -0.00605209f, 0.06295959f, -0.06295325f, -0.04631948f, 0.05438494f, 0.01436276f, 
    -0.07497327f, 0.00230315f, 0.05353518f, -0.02493575f, -0.06388125f, 0.00405567f, -0.02184040f, 0.00699116f, 
    -0.01905150f, -0.02797020f, 0.05923502f, -0.03060561f, -0.02123807f, 0.00801365f, 0.02101418f, -0.03302942f, 
    0.03185662f, -0.07808002f, -0.01952542f, -0.01134779f, 0.01535901f, 0.02713405f, 0.01099595f, -0.03743295f, 
    -0.05296978f, 0.03241028f, -0.07741903f, -0.06913900f, -0.01989791f, 0.04525986f, -0.05775685f, -0.06397668f, 
    -0.07675081f, 0.02364653f, -0.04113473f, 0.05554181f, 0.05052323f, -0.03721429f, -0.01167190f, -0.05345564f, 
    -0.05434364f, 0.04374664f, 0.04113731f, -0.03013216f, -0.03732186f, 0.05484842f, -0.07333767f, -0.06930238f, 
    -0.02285784f, -0.04224597f, 0.05544644f, 0.02351441f, -0.00250563f, -0.04394360f, 0.01255060f, 0.01204395f, 
    -0.06451712f, -0.03079157f, -0.00222797f, 0.03948921f, 0.01671484f, 0.03383531f, -0.06767981f, 0.05487746f, 
    0.03779566f, 0.03827944f, -0.00690001f, 0.04796812f, 0.02605497f, 0.04604430f, 0.06958611f, -0.04656990f, 
    -0.02498085f, 0.01781102f, 0.03863037f, 0.03735087f, -0.02189825f, -0.03338787f, -0.07640151f, -0.07433940f, 
    0.05208936f, 0.00343629f, -0.00303206f, 0.01410069f, -0.03310428f, 0.06160475f, 0.01870510f, -0.08247452f, 
    -0.01540657f, 0.00864215f, -0.01301700f, 0.05763832f, 0.04513665f, 0.03913480f, -0.03875546f, -0.01312993f, 
    0.00219271f, -0.05239715f, -0.03995247f, -0.05142134f, -0.07608698f, 0.01829899f, -0.03067073f, 0.02946791f, 
    -0.04788481f, 0.00674234f, -0.01571476f, 0.01798896f, -0.08102069f, 0.04091846f, -0.04376394f, -0.03087361f, 
    -0.02678127f, -0.05705818f, -0.06881889f, 0.05861087f, 0.04954709f, -0.03990887f, -0.01529015f, -0.05611575f, 
    -0.08082242f, -0.07421104f, -0.05397141f, -0.07216132f, -0.02397944f, 0.04435934f, -0.01590794f, -0.06354969f, 
    -0.01514335f, -0.08020730f, 0.04649333f, -0.01951587f, 0.03524351f, -0.05292066f, 0.01535891f, 0.05122571f, 
    -0.01170175f, 0.02876621f, -0.04838702f, -0.06652266f, 0.02101463f, 0.06337974f, -0.05247242f, 0.02155074f, 
    -0.21455437f, -0.10143185f, 0.00711891f, 0.05400486f, -0.00966963f, 0.04447678f, 0.22737931f, -0.02403004f, 
    0.07455662f, 0.09918594f, -0.00359595f, 0.28579161f, 0.31926259f, -0.06193573f, 0.14187711f, 0.20744039f, 
    0.09739801f, 0.13336942f, -0.02120988f, -0.07291374f, -0.04763933f, -0.07157771f, 0.08700775f, 0.07237790f, 
    -0.21488340f, 0.23798791f, 0.03783927f, -0.35949239f, -0.13574429f, 0.00007275f, -0.03923225f, -0.02179546f, 
    0.16252309f, 0.11799089f, -0.13705599f, 0.12928765f, 0.19230618f, -0.05760033f, -0.12087574f, 0.08292492f, 
    0.06812172f, -0.02034243f, 0.04990861f, 0.10024966f, 0.09376037f, -0.06620479f, -0.20443711f, -0.13562518f, 
    -0.20330741f, 0.05744950f, -0.08737293f, 0.20589113f, 0.16714846f, -0.03907001f, 0.01398168f, 0.12949240f, 
    -0.07594240f, -0.02279045f, 0.03206615f, 0.03104809f, 0.18979837f, -0.11220660f, 0.11691067f, 0.03653627f, 
    -0.00851658f, 0.07849644f, 0.07968462f, 0.08235276f, -0.04052173f, 0.17961362f, 0.14186354f, -0.16991027f, 
    -0.29153308f, -0.05145308f, 0.14002204f, 0.03722581f, 0.04982024f, 0.08844125f, 0.23167472f, 0.02580999f, 
    -0.01686926f, 0.07141431f, -0.02878183f, 0.12172268f, -0.32826710f, -0.13476174f, 0.42113999f, 0.18182978f, 
    -0.03714775f, 0.14501424f, 0.21790040f, -0.16301389f, 0.03224969f, -0.09354308f, -0.00552042f, 0.04450053f, 
    0.15717596f, 0.09955300f, 0.04925728f, -0.05448828f, -0.03577802f, -0.00237873f, -0.13330391f, -0.01759148f, 
    -0.06113074f, 0.01876537f, -0.00477958f, -0.03751394f, 0.36870390f, -0.10056980f, 0.09347626f, 0.06357644f, 
    0.16325472f, -0.03451460f, 0.22869176f, 0.02583813f, 0.05380452f, 0.09458780f, 0.08811849f, 0.12233090f, 
    0.04618295f, -0.00134948f, -0.28112218f, -0.02063869f, 0.01646514f, 0.10703035f, 0.04264073f, -0.10910483f, 
    0.02311642f, 0.01826696f, -0.01121045f, -0.16227715f, 0.06278507f, 0.00345472f, 0.08002084f, -0.00251730f, 
    0.06022771f, -0.03166695f, 0.09009615f, 0.02386247f, 0.04909750f, -0.12423421f, 0.00674472f, -0.06761634f, 
    -0.01093563f, 0.05427146f, 0.10898186f, 0.10553824f, 0.07622800f, 0.11220019f, 0.05781655f, 0.08901592f, 
    0.04699252f, -0.01120606f, -0.01319943f, 0.05765023f, -0.18355004f, 0.07707656f, -0.02170337f, 0.06733125f, 
    -0.00873456f, 0.04798715f, -0.00748035f, -0.01704828f, 0.05195473f, 0.12294695f, 0.19110298f, 0.02442374f, 
    0.07121659f, 0.20762989f, -0.18544172f, -0.26994032f, 0.04355957f, -0.05113754f, -0.09631776f, -0.02437326f, 
    0.15110691f, -0.00069941f, 0.09752762f, 0.09080005f, 0.06186706f, -0.27980584f, 0.08394019f, 0.04498929f, 
    0.05263389f, 0.08728655f, 0.20834918f, 0.05657321f, -0.02238796f, 0.06843950f, 0.10742277f, -0.01409018f, 
    -0.13589133f, 0.01452368f, 0.10603574f, -0.24050273f, -0.07045566f, -0.09599189f, 0.10112732f, -0.14260481f, 
    -0.01048842f, -0.18156497f, -0.02063127f, -0.02510522f, 0.17972584f, 0.13084504f, -0.03137013f, -0.22648489f, 
    0.06051209f, 0.11679551f, -0.06359430f, 0.07323750f, -0.13842075f, 0.00267791f, -0.01769997f, 0.00642612f, 
    -0.03764941f, 0.09609933f, 0.05556130f, -0.02483054f, 0.07352529f, 0.15959166f, 0.01826862f, -0.03758308f, 
    -0.08733538f, 0.01481011f, 0.18518646f, 0.07709075f, 0.02162525f, 0.18222089f, -0.11155041f, 0.16021085f, 
    0.05422220f, -0.06345309f, -0.11113933f, -0.08013793f, 0.12281004f, 0.09371788f, 0.06859778f, 0.07950138f, 
    0.20707570f, 0.06275152f, -0.05554933f, -0.23526272f, -0.02918977f, 0.09184184f, 0.02321774f, -0.02547370f, 
    0.08751783f, -0.02320139f, 0.08921479f, -0.03289187f, 0.15928511f, 0.07016752f, 0.08089019f, 0.11810983f, 
    -0.02207787f, -0.05472488f, -0.01418344f, 0.10706376f, -0.04622751f, 0.05417870f, 0.01391109f, 0.07364400f, 
    0.21028352f, 0.00839456f, 0.01779081f, 0.04432084f, 0.08888111f, 0.15810455f, 0.09347814f, 0.00673980f, 
    -0.14049599f, -0.01730122f, -0.01419564f, -0.02401431f, 0.21001783f, 0.06938842f, -0.21913615f, 0.17757393f, 
    0.05277422f, -0.16481894f, -0.11923451f, 0.13032037f, -0.00370770f, -0.00239729f, -0.18641673f, -0.06589615f, 
    0.20849103f, -0.14321493f, 0.05619496f, -0.14422141f, -0.00806130f, -0.06039229f, -0.02533134f, 0.03155842f, 
    -0.02875587f, 0.06749389f, -0.01892686f, 0.06766921f, 0.14684807f, 0.08709878f, -0.05878888f, 0.03182423f, 
    0.13692778f, -0.06203404f, 0.03644539f, -0.00477990f, -0.04847521f, -0.08742158f, -0.16487217f, -0.07470015f, 
    0.24696834f, 0.04973509f, 0.04596721f, 0.27445027f, 0.09354018f, -0.05461800f, -0.02014291f, -0.17538933f, 
    -0.08645041f, -0.07251152f, 0.04799341f, 0.02165687f, -0.15705222f, -0.00377125f, 0.01373398f, 0.44308126f, 
    0.05073278f, -0.15544315f, 0.05257262f, 0.02474800f, -0.11160236f, 0.03108732f, 0.00749487f, -0.02850035f, 
    -0.05164550f, 0.09635454f, -0.05848632f, 0.08535992f, -0.02048211f, -0.04725644f, 0.14039710f, 0.06311290f, 
    0.06397134f, 0.03375578f, 0.10132002f, -0.02055925f, 0.52146912f, 0.18971436f, 0.24701405f, -0.20303339f, 
    -0.10871112f, -0.08577902f, 0.00396910f, 0.01249184f, 0.00119076f, -0.05796117f, 0.00801486f, -0.09655204f, 
    -0.01246146f, -0.27158594f, 0.23866479f, -0.01714641f, -0.01868133f, 0.00922955f, 0.02477845f, -0.02165441f, 
    -0.05826491f, 0.07352197f, 0.06183802f, -0.07056449f, -0.09232035f, 0.28708825f, -0.25482562f, 0.45942369f, 
    -0.12521544f, -0.02327359f, -0.04378532f, 0.03800371f, 0.02938827f, -0.01867501f, -0.08262698f, 0.00645976f, 
    -0.06703454f, 0.01239565f, -0.07713462f, -0.12310572f, -0.01288591f, 0.06190787f, -0.00486947f, -0.04578583f, 
    0.01769444f, 0.21345189f, -0.18504322f, -0.05623002f, 0.22060719f, 0.02255518f, -0.04761833f, 0.18348366f, 
    0.12579800f, -0.01981008f, -0.14584345f, -0.01702658f, -0.03271366f, -0.13480793f, 0.10874555f, 0.03355260f, 
    -0.08576301f, -0.19984287f, -0.24165924f, -0.01934504f, -0.19270623f, 0.03235494f, -0.00350567f, 0.07620215f, 
    0.03309198f, 0.00722095f, -0.13036233f, 0.14252593f, 0.21782948f, 0.05492700f, 0.04465269f, 0.22027227f, 
    0.10572600f, 0.07537989f, 0.15253267f, 0.01001033f, 0.08437067f, 0.00156538f, 0.11872342f, -0.03533776f, 
    0.30105141f, -0.09224308f, 0.07617763f, 0.28756505f, -0.00712498f, -0.09720573f, 0.02817482f, 0.27566844f, 
    -0.05594162f, -0.08952822f, -0.07389583f, -0.12404011f, -0.12069534f, 0.14821114f, 0.05367852f, 0.00209334f, 
    0.08127191f, 0.06941583f, 0.11896105f, -0.01807567f, -0.04017688f, 0.10357875f, -0.01952239f, -0.09188207f, 
    0.05186914f, -0.00740235f, -0.01186965f, 0.01792078f, -0.00442938f, 0.00667762f, 0.13866340f, -0.12577949f, 
    -0.06697442f, 0.14323369f, 0.09707243f, 0.11796970f, -0.06721628f, 0.05324738f, 0.02443710f, 0.03433337f, 
    -0.11898427f, 0.07469302f, 0.01961289f, -0.02590339f, 0.17887980f, 0.04388845f, 0.04330821f, -0.03785612f, 
    -0.20677286f, 0.02848011f, -0.10320126f, 0.06915954f, -0.23033749f, 0.04684380f, -0.11364939f, -0.01491475f, 
    0.09937721f, 0.00625662f, 0.00252777f, -0.10433832f, 0.22091393f, -0.06930993f, 0.04632774f, 0.18167391f, 
    -0.00271789f, 0.11053015f, -0.01249357f, -0.04044795f, -0.11048439f, -0.04058305f, -0.07197137f, 0.05912680f, 
    0.22355248f, 0.03161176f, 0.07892146f, 0.03470877f, 0.05818156f, 0.11473148f, 0.06295399f, 0.06319423f, 
    0.12883574f, -0.01909027f, 0.10116248f, -0.02565729f, 0.04772124f, -0.13357595f, 0.11838265f, 0.10623694f, 
    -0.03454066f, -0.01209435f, 0.03244301f, -0.07483691f, -0.11369433f, 0.02353583f, 0.08256729f, 0.03479278f, 
    0.00592615f, 0.23267445f, 0.18447679f, -0.10977241f, 0.00308832f, -0.03648724f, -0.04876046f, 0.04767261f, 
    0.02751042f, 0.00220722f, 0.11419136f, 0.00134353f, -0.26427838f, -0.04115798f, 0.07150353f, 0.14490557f, 
    -0.06387249f, 0.00410248f, -0.09624989f, -0.00230746f, 0.09609553f, 0.09063943f, -0.00387433f, 0.09292849f, 
    -0.08576867f, -0.24786115f, -0.09185785f, -0.06610192f, -0.14745924f, -0.00593623f, 0.04995472f, -0.07841098f, 
    0.07750826f, 0.02954209f, -0.10312176f, -0.07821099f, 0.23769912f, -0.03739155f, -0.21305194f, -0.05538724f, 
    0.14522393f, -0.03956663f, -0.01802163f, -0.16108908f, 0.03548805f, 0.04460562f, 0.03728010f, -0.07866126f, 
    -0.00861471f, 0.04287131f, -0.02205519f, -0.01337138f, 0.05861101f, 0.05975463f, -0.01220491f, 0.02390248f, 
    0.02002239f, -0.02660827f, 0.04963162f, -0.01126164f, -0.03900819f, -0.00892520f, -0.06609658f, -0.06059372f, 
    0.01946397f, -0.06525132f, -0.01218661f, -0.04079483f, 0.06549709f, 0.02355016f, 0.02861310f, 0.03529106f, 
    -0.02406513f, 0.03864174f, -0.06217077f, -0.04504322f, -0.04367586f, 0.04639122f, -0.05852810f, 0.03565371f, 
    0.02083192f, -0.06491137f, 0.03328241f, 0.01421156f, -0.00807237f, -0.04852322f, -0.05715257f, -0.02635341f, 
    -0.06317189f, 0.02347868f, -0.06515317f, 0.03699315f, 0.05013479f, -0.04174971f, -0.06805598f, -0.04849126f, 
    0.04104933f, 0.04567400f, 0.04870285f, -0.01190413f, 0.06056050f, 0.00912421f, -0.00679987f, -0.04612942f, 
    -0.07516954f, -0.01045950f, 0.04896162f, -0.02159412f, 0.01191439f, -0.03461143f, 0.01553309f, -0.03553484f, 
    -0.01799883f, -0.07348835f, -0.05594991f, 0.00092599f, 0.02711537f, -0.04572323f, -0.01956781f, 0.04634345f, 
    -0.00923089f, 0.00102392f, 0.00437942f, -0.03447201f, -0.06466366f, -0.00808377f, -0.06004006f, -0.02293226f, 
    -0.03674280f, -0.04372009f, -0.02121021f, -0.07442745f, 0.05560611f, -0.01456308f, -0.02141801f, 0.01614239f, 
    -0.06550302f, -0.05161115f, -0.07240099f, -0.03210294f, -0.04405610f, -0.01172785f, 0.02215840f, 0.01127252f, 
    -0.00464188f, 0.02322071f, -0.04062310f, 0.05263657f, 0.00264670f, 0.03606956f, -0.07367918f, -0.02188829f, 
    -0.01022795f, -0.01257506f, 0.04082032f, -0.04617573f, 0.01818387f, -0.02619318f, -0.01062051f, -0.02475662f, 
    0.02773692f, -0.00614158f, 0.05576749f, -0.05066523f, -0.00335041f, -0.00585247f, -0.06225696f, 0.01890448f, 
    -0.05550059f, -0.00122855f, 0.02229581f, -0.04961214f, 0.04411651f, -0.02013745f, -0.04574540f, -0.05865243f, 
    0.04953676f, 0.06835081f, 0.05381854f, -0.01687732f, -0.06190661f, 0.03670128f, 0.00175454f, -0.05821333f, 
    0.00696475f, 0.02491190f, 0.05889348f, 0.01363987f, 0.00385187f, -0.06457166f, -0.00370087f, -0.03571976f, 
    -0.07308324f, 0.06437702f, -0.07558603f, 0.02846782f, -0.02946616f, 0.01959026f, 0.03019337f, 0.04776705f, 
    -0.03336128f, -0.07371017f, -0.03483287f, -0.03437087f, -0.01895977f, -0.02535901f, -0.01905338f, -0.05855782f, 
    0.03218482f, 0.06116478f, 0.06326903f, 0.02253433f, -0.02413139f, -0.07679392f, 0.03066667f, -0.04067190f, 
    0.01033219f, -0.05869397f, 0.02588083f, -0.00418387f, -0.02413777f, -0.06164294f, 0.00427426f, 0.01236193f, 
    0.05684416f, -0.03041320f, -0.06243062f, -0.01204877f, -0.06035623f, -0.04585290f, -0.05447742f, -0.07043968f, 
    -0.06975161f, 0.00821754f, -0.04012014f, 0.04144132f, -0.00022876f, 0.01807695f, -0.04006724f, -0.00644592f, 
    -0.00645367f, 0.36679992f, 0.02099496f, -0.36931342f, 0.01625910f, 0.03312677f, -0.31940892f, -0.02352258f, 
    -0.07700334f, -0.11667778f, -0.12423161f, -0.13376217f, 0.06201918f, 0.05835734f, -0.09050844f, -0.12463477f, 
    -0.06429674f, 0.00485193f, 0.21536049f, -0.07579200f, -0.13260959f, 0.06671149f, -0.09615855f, 0.09591281f, 
    -0.06123160f, 0.24303629f, 0.38239738f, -0.17741214f, 0.06990683f, -0.01958388f, 0.09868868f, -0.20267357f, 
    0.02099675f, 0.04018233f, 0.10313760f, 0.11399197f, -0.33172274f, -0.15158200f, -0.18504506f, 0.02401642f, 
    0.07585312f, -0.04120730f, 0.01583809f, 0.05125833f, 0.12669529f, -0.11820228f, 0.02586821f, 0.16509582f, 
    -0.34416881f, 0.14264707f, 0.05374150f, -0.05892542f, -0.01328253f, 0.03453614f, -0.02224807f, -0.05400339f, 
    0.07645383f, -0.01289258f, 0.04869848f, 0.07169554f, 0.02665315f, -0.02582695f, -0.05734030f, 0.16286397f, 
    -0.09177792f, -0.06422467f, -0.02942281f, 0.08225893f, 0.08597509f, 0.05003143f, 0.00774725f, 0.18839461f, 
    -0.03443400f, 0.14179395f, 0.13394567f, 0.05980523f, 0.09580529f, 0.05604351f, -0.14895967f, 0.05139610f, 
    0.00005096f, 0.10162345f, 0.00867517f, -0.12346180f, -0.06990428f, -0.03927359f, 0.01802800f, 0.27270862f, 
    0.07821076f, -0.13732037f, 0.05038231f, 0.16589874f, -0.03627038f, -0.03143554f, -0.03316691f, 0.01471821f, 
    0.26667821f, 0.03775823f, 0.15137759f, -0.03884000f, 0.08936115f, 0.09398492f, -0.01005228f, 0.04411841f, 
    -0.07778360f, 0.13345830f, -0.12284113f, -0.05459144f, -0.05047802f, 0.15142626f, -0.11608542f, -0.10084768f, 
    -0.01119937f, 0.15218282f, 0.05489868f, 0.02660641f, 0.15977363f, 0.08244042f, 0.04031679f, 0.06946429f, 
    -0.42230812f, -0.27260724f, -0.41056809f, -0.03595419f, 0.17901325f, -0.03646239f, 0.05107854f, -0.02058923f, 
    -0.02296119f, 0.05443269f, 0.12089775f, 0.01252054f, 0.22016482f, -0.16180705f, 0.00624076f, -0.06002792f, 
    -0.04678374f, -0.00301384f, 0.04503011f, 0.06090875f, -0.03112876f, -0.03407980f, 0.01909948f, 0.05320907f, 
    -0.36533636f, -0.21336456f, -0.32404390f, -0.05669740f, 0.10192515f, 0.02744397f, 0.03560971f, -0.04299891f, 
    0.05517213f, -0.00088493f, -0.01423093f, 0.06544600f, -0.26740140f, 0.05042594f, 0.06404350f, -0.02111210f, 
    -0.04603109f, 0.17161410f, -0.01234418f, 0.19119509f, 0.18657967f, 0.05154784f, 0.06503330f, 0.13381895f, 
    0.04650195f, 0.20519210f, 0.13368315f, -0.10349444f, 0.11947520f, 0.06462730f, 0.02198298f, 0.03043931f, 
    0.02341492f, 0.07102374f, -0.19521484f, 0.07337230f, -0.40569511f, -0.20855789f, -0.05169314f, -0.06613987f, 
    -0.04574745f, -0.09666484f, -0.13443397f, 0.09379411f, 0.16725406f, -0.01710409f, 0.06971523f, -0.02422028f, 
    -0.01456908f, 0.13151860f, -0.04851267f, -0.20277938f, -0.02850835f, -0.13321909f, 0.02498875f, -0.22977528f, 
    -0.12493251f, -0.10559376f, -0.04943517f, -0.15651616f, 0.12493054f, 0.06507151f, 0.01246672f, 0.06273126f, 
    0.04032210f, 0.03294500f, -0.05675371f, 0.00389682f, -0.10137078f, 0.06756365f, -0.04685011f, -0.11385880f, 
    -0.31565359f, -0.17692824f, 0.07332384f, 0.02049524f, 0.20448321f, 0.07614173f, 0.02989257f, -0.07532392f, 
    -0.04611026f, 0.14637497f, 0.16064622f, 0.07074761f, 0.17614605f, 0.05098956f, -0.08067299f, 0.18846110f, 
    -0.02311093f, -0.03720440f, -0.06581703f, -0.15003221f, 0.13619535f, 0.06274119f, 0.03968650f, 0.06849456f, 
    -0.00207397f, 0.07594530f, 0.10299923f, -0.05222809f, 0.02634844f, 0.07475934f, 0.10137483f, -0.00245835f, 
    0.07808051f, -0.08453276f, 0.12630287f, -0.04864284f, 0.12788345f, 0.14528726f, 0.05407123f, 0.12085274f, 
    0.02597141f, 0.03565481f, 0.14428569f, 0.18885280f, -0.02260267f, 0.07029267f, -0.04250055f, 0.20462345f, 
    0.23522808f, 0.18459918f, 0.03926908f, 0.12640993f, 0.06443089f, 0.10727277f, -0.00016651f, 0.07479708f, 
    -0.02763282f, 0.02941928f, 0.04516517f, -0.00265329f, 0.16167825f, 0.10059705f, 0.08737602f, 0.19801144f, 
    0.01283187f, -0.09280472f, -0.09381641f, 0.08055220f, 0.14558671f, -0.04882042f, -0.07935270f, 0.03270625f, 
    -0.02581042f, -0.08385133f, -0.09618833f, 0.03109705f, -0.00914988f, -0.01451241f, -0.13400640f, 0.23984733f, 
    -0.05925091f, 0.01646667f, 0.03408644f, 0.04914703f, 0.03315998f, 0.09136274f, -0.04387657f, 0.02066496f, 
    0.10903080f, 0.00954252f, 0.11809889f, -0.14447591f, -0.10379987f, 0.03637024f, 0.08954625f, -0.01612947f, 
    0.33724663f, -0.02103291f, -0.00046398f, 0.14873315f, 0.07109839f, 0.01850710f, 0.04756472f, -0.09593660f, 
    0.02633937f, 0.00210991f, 0.10259098f, 0.08350383f, 0.09774578f, -0.11422334f, -0.10727873f, 0.39772752f, 
    -0.00137955f, -0.07246745f, -0.03468402f, 0.05071086f, -0.16051912f, -0.06617406f, 0.01067612f, 0.00401941f, 
    -0.08243434f, 0.15238973f, 0.08636075f, 0.10044876f, -0.07194828f, -0.07729180f, 0.04199393f, 0.05502252f, 
    -0.07397268f, -0.03193700f, 0.10865697f, -0.02384556f, 0.07350858f, 0.22354022f, 0.15243764f, -0.05803508f, 
    0.02053470f, -0.03736300f, -0.01954217f, 0.02458451f, 0.00365787f, -0.01428903f, -0.06677570f, 0.12655962f, 
    -0.13308457f, -0.24827619f, 0.03091653f, -0.14625996f, 0.10983036f, -0.01436422f, -0.10416918f, -0.06686018f, 
    0.08638716f, 0.06356353f, -0.03999442f, -0.00408419f, -0.04637477f, 0.23361726f, -0.03486313f, 0.26479113f, 
    -0.00722857f, 0.01821241f, -0.05241418f, 0.03287988f, 0.03517809f, -0.13579920f, 0.02921360f, 0.01120650f, 
    -0.03417560f, -0.05640830f, -0.05574607f, -0.06944692f, -0.04826715f, 0.03767666f, -0.06354926f, -0.01933409f, 
    0.06783766f, -0.01094973f, 0.03677225f, 0.04649071f, -0.04242675f, -0.03918768f, 0.06218488f, 0.06796630f, 
    -0.01068320f, -0.03590021f, 0.05524676f, -0.06860708f, -0.04445073f, 0.01148629f, 0.05428286f, 0.06547271f, 
    -0.05814979f, -0.05187987f, -0.05245409f, -0.07001083f, -0.06296894f, 0.01368888f, -0.04048280f, -0.02657018f, 
    0.02964504f, -0.05503359f, -0.06269886f, -0.01746672f, 0.02298745f, 0.03583153f, -0.02704457f, 0.06043119f, 
    -0.03198635f, -0.02299460f, -0.01952792f, 0.03195795f, -0.06057807f, -0.04663847f, -0.04757935f, -0.02411846f, 
    0.03795059f, -0.02591935f, -0.04347976f, -0.00147003f, 0.03080621f, -0.06753546f, 0.05182081f, 0.01772300f, 
    -0.07081379f, -0.02239962f, 0.05306399f, -0.01951416f, -0.00146905f, 0.04959891f, -0.05194504f, 0.05838890f, 
    -0.00109316f, -0.00338454f, 0.03377551f, 0.01153445f, -0.00980211f, 0.01040177f, 0.06106540f, 0.01176148f, 
    -0.00663364f, 0.05686307f, 0.01353887f, -0.05864913f, -0.02344170f, -0.05644168f, -0.06708267f, 0.00541517f, 
    -0.00800567f, -0.05358622f, 0.05636228f, -0.03479181f, 0.06592453f, 0.06531022f, -0.06777515f, 0.05575274f, 
    -0.01625358f, 0.00016744f, -0.01325077f, -0.00540535f, 0.06079181f, -0.01122043f, -0.00924068f, 0.00111447f, 
    -0.04030682f, -0.05302548f, 0.00717248f, 0.04970308f, -0.03782344f, 0.02018930f, 0.04277158f, 0.03306292f, 
    -0.03641766f, 0.05212623f, 0.04186840f, 0.03495755f, -0.03984600f, -0.00381162f, 0.05848916f, -0.00343750f, 
    -0.00864476f, 0.06345174f, -0.06783300f, 0.04215346f, -0.00607827f, -0.04798391f, -0.03738323f, -0.02928164f, 
    0.02710393f, 0.00244741f, -0.05714997f, -0.07015019f, -0.03978249f, 0.00633634f, 0.01622571f, -0.02089134f, 
    -0.04586358f, -0.03712094f, -0.04537454f, 0.06951606f, -0.01389034f, -0.02528912f, -0.01373977f, -0.00470832f, 
    0.01733002f, 0.01926235f, 0.02233824f, 0.03368346f, -0.02829732f, -0.00812343f, 0.04492442f, 0.07069708f, 
    -0.00467310f, 0.01471021f, -0.05484781f, -0.00454143f, -0.06277555f, -0.03742400f, 0.02231676f, -0.02584250f, 
    -0.06529433f, 0.04662634f, -0.02961552f, 0.07036014f, -0.05550002f, -0.06910394f, -0.04699875f, -0.06823635f, 
    -0.01484211f, 0.02226242f, -0.06367368f, 0.02675465f, 0.04455801f, 0.05777314f, -0.05588815f, 0.00375095f, 
    -0.04841642f, -0.03473678f, -0.06567294f, 0.01883760f, -0.00894838f, -0.02345130f, -0.05699462f, -0.06013623f, 
    0.00178213f, -0.00506804f, -0.05046000f, -0.01900984f, -0.06803748f, -0.05367685f, -0.04197251f, -0.02218756f, 
    0.01884566f, -0.02174370f, -0.07191960f, 0.00369374f, -0.03904640f, -0.03895926f, 0.01961999f, -0.05061152f, 
    -0.19528122f, 0.00374229f, 0.22702967f, -0.13978867f, -0.13876809f, -0.04433640f, -0.13429686f, -0.07453748f, 
    0.03603690f, 0.08352564f, -0.10890728f, 0.09147523f, 0.20740882f, 0.15712069f, -0.00474994f, 0.01316007f, 
    0.01692961f, -0.00986810f, 0.01288559f, -0.01424446f, -0.20955873f, -0.01996730f, 0.05895259f, 0.20012319f, 
    0.03777131f, 0.11380574f, -0.03384188f, 0.04776527f, -0.12454773f, -0.19998913f, -0.02115169f, 0.04956303f, 
    -0.01064346f, 0.08200505f, -0.11916298f, -0.07146949f, -0.13662595f, 0.14421546f, -0.02332687f, -0.07101204f, 
    0.14959820f, 0.05701651f, -0.04029038f, -0.01583428f, -0.00167702f, -0.07607806f, -0.14560437f, -0.05281046f, 
    0.32090750f, -0.05217524f, 0.16590555f, 0.10601147f, -0.08896293f, 0.01754304f, 0.01638919f, 0.08369017f, 
    -0.08106057f, -0.09900136f, 0.02605063f, -0.02219291f, -0.15021706f, 0.00948782f, -0.10363862f, 0.25958285f, 
    0.09540267f, 0.09685347f, -0.03357675f, 0.08231486f, 0.02262552f, 0.18444952f, 0.10703110f, -0.11075979f, 
    0.03406981f, -0.15081103f, 0.13494700f, 0.11933540f, -0.10667794f, -0.03774140f, 0.05763453f, 0.03536215f, 
    0.03681186f, -0.01868203f, -0.05800751f, 0.02278468f, -0.30548644f, 0.15666938f, 0.01622047f, 0.34708688f, 
    -0.00635015f, 0.04022520f, -0.06241861f, 0.12451862f, -0.09136374f, -0.03183505f, -0.07353487f, -0.16618717f, 
    0.08556599f, 0.07442007f, -0.10778417f, -0.03740671f, 0.03605090f, -0.07762352f, 0.10606733f, -0.11168796f, 
    -0.06754591f, -0.02249636f, -0.11212908f, -0.01963454f, 0.34854692f, 0.01870828f, 0.02676820f, -0.02630687f, 
    -0.08224349f, 0.10335893f, 0.04494210f, 0.00575826f, -0.01253319f, -0.02701476f, -0.00464172f, -0.03773298f, 
    -0.04214648f, 0.07790818f, 0.09002889f, 0.04681606f, -0.05086385f, 0.12306015f, -0.05995741f, -0.10165387f, 
    0.13360262f, 0.14721188f, -0.09225883f, -0.04153345f, -0.20179097f, 0.10627580f, 0.13770133f, -0.13077630f, 
    0.08317587f, -0.03342346f, -0.13133517f, -0.02171236f, 0.02505747f, -0.17826724f, -0.03040364f, -0.04472462f, 
    0.59636736f, 0.10477588f, 0.04051209f, -0.36872283f, 0.06028726f, 0.15247278f, 0.01843058f, 0.03767882f, 
    0.05037352f, 0.00079312f, 0.11630882f, 0.16883697f, 0.33435968f, 0.00451649f, 0.18471384f, 0.09700871f, 
    -0.08401159f, -0.07496022f, 0.02858430f, -0.20708375f, 0.04162996f, 0.13111536f, 0.16848655f, -0.03278282f, 
    -0.01839440f, 0.02804777f, 0.00773891f, 0.05300315f, -0.12081832f, -0.21514764f, -0.11695518f, 0.01193778f, 
    0.01264111f, 0.02499391f, 0.06052399f, -0.14247051f, 0.14078486f, 0.28714687f, -0.38664365f, -0.17691410f, 
    0.14633282f, 0.13257328f, 0.02351880f, -0.06450951f, 0.08246268f, 0.03687431f, -0.11358272f, -0.03602914f, 
    0.05960633f, 0.03725379f, 0.03966178f, 0.01362548f, -0.04047176f, -0.03651075f, -0.11703221f, 0.14190638f, 
    -0.14732416f, -0.03787431f, -0.02907963f, 0.10750322f, 0.20329906f, 0.16386685f, -0.09354107f, -0.15362185f, 
    0.13121152f, -0.03547930f, 0.18796863f, 0.14547046f, -0.01883803f, 0.16344482f, -0.07788522f, 0.10108479f, 
    -0.22029814f, -0.12576309f, 0.10510048f, -0.04934855f, 0.25421330f, -0.03525954f, 0.00009899f, -0.00652133f, 
    -0.07106946f, -0.01338383f, 0.02894711f, 0.01255142f, -0.20780942f, 0.01696026f, 0.08708598f, -0.30928999f, 
    0.09707857f, 0.00260324f, -0.09037290f, -0.03313340f, -0.06953072f, 0.00912310f, 0.00339641f, 0.02172822f, 
    -0.35526934f, -0.07834344f, -0.00485272f, -0.19758743f, -0.08781848f, 0.07243351f, -0.01311804f, -0.05770488f, 
    0.05749109f, -0.04796818f, -0.03189553f, -0.17736964f, 0.04497176f, 0.08015966f, -0.21146291f, -0.05354483f, 
    -0.03557132f, -0.03351130f, 0.00928174f, -0.17932308f, 0.19186255f, -0.18671173f, -0.05726750f, -0.06432360f, 
    -0.10578125f, -0.15724325f, 0.04818342f, 0.05249647f, 0.09802622f, -0.06170340f, -0.01989998f, 0.06704347f, 
    0.17507735f, -0.07108788f, 0.12714295f, -0.07180837f, -0.12952566f, 0.12622216f, 0.00858086f, -0.08384342f, 
    0.16401361f, 0.00420668f, 0.02406361f, 0.10869598f, 0.02625760f, 0.05624561f, 0.10085993f, 0.05240285f, 
    0.03564574f, 0.08113379f, -0.26348186f, -0.10509271f, 0.11459544f, 0.02138530f, 0.01286103f, 0.04657343f, 
    0.02450562f, 0.07153273f, 0.12946513f, 0.13674097f, 0.38346994f, 0.18714559f, -0.06171022f, -0.14007705f, 
    -0.06011434f, 0.07320816f, 0.01965731f, 0.06174147f, -0.03356879f, 0.00751516f, 0.14691995f, 0.05961776f, 
    -0.19695365f, -0.04812939f, 0.10373668f, -0.02889448f, -0.00728345f, 0.10951450f, 0.05551613f, -0.14932252f, 
    0.12301294f, 0.07368604f, 0.08703996f, 0.04988613f, 0.15127914f, 0.14910544f, -0.03454617f, -0.17859145f, 
    0.21475291f, 0.21499677f, 0.04772484f, 0.01729924f, 0.01124050f, 0.06912389f, 0.17225082f, 0.14205360f, 
    0.38935700f, -0.04445454f, -0.16820419f, 0.05291110f, -0.20963427f, -0.09488847f, -0.05066254f, -0.03047281f, 
    0.02211789f, 0.13988711f, 0.00740845f, -0.12744927f, 0.34139705f, -0.13338166f, 0.02492963f, -0.09890107f, 
    0.05172246f, 0.16877861f, -0.01032500f, 0.00924041f, 0.18516244f, 0.03337836f, 0.07026965f, 0.04578634f, 
    -0.28084907f, 0.15174608f, 0.02469452f, -0.01760479f, 0.10046259f, 0.06177252f, -0.04148445f, 0.04801283f, 
    0.00845369f, 0.15626004f, -0.10792925f, 0.09990980f, -0.22919515f, 0.06599856f, 0.00541323f, 0.11347455f, 
    -0.12077855f, -0.04402376f, -0.00333071f, 0.01498862f, -0.00861116f, -0.02051079f, 0.08007917f, -0.01082509f, 
    0.12723123f, 0.19010074f, 0.09584936f, -0.04357833f, 0.04751813f, -0.03476672f, -0.12247735f, -0.03049421f, 
    0.01992275f, -0.04379025f, 0.07757981f, -0.16897583f, -0.14158973f, 0.02513873f, -0.04795538f, -0.07805165f, 
    -0.05175167f, -0.02284791f, 0.07713716f, -0.00566206f, 0.01798687f, 0.20345853f, -0.02821556f, -0.12325472f, 
    -0.04788058f, 0.05920125f, 0.19659141f, -0.21520238f, 0.02416929f, 0.04112251f, 0.03005870f, -0.06807034f, 
    0.01805265f, -0.03049337f, 0.13574521f, 0.08460928f, 0.04227686f, 0.09254981f, -0.03029650f, 0.28412178f, 
    -0.02592738f, -0.01833137f, -0.11441543f, -0.05531176f, 0.14035174f, -0.07558279f, -0.01626126f, 0.00909440f, 
    -0.16093411f, 0.28485256f, -0.03656596f, -0.01363096f, -0.01316092f, 0.00440531f, 0.05152832f, -0.05696408f, 
    -0.08218066f, -0.11169783f, 0.05079183f, 0.00617182f, -0.00796356f, -0.18623658f, 0.05621827f, 0.18883817f, 
    0.09670915f, -0.02504919f, 0.00011628f, 0.15354826f, 0.08146795f, 0.03542988f, 0.00807556f, 0.19250928f, 
    -0.15499657f, 0.21826082f, -0.04730013f, -0.04150844f, 0.04959606f, 0.12340450f, 0.00699816f, 0.02500110f, 
    -0.06161213f, 0.04204117f, 0.02693092f, -0.06544030f, 0.15204065f, 0.23022825f, 0.14090109f, 0.05355359f, 
    0.13053465f, -0.14005581f, 0.00192918f, 0.01798190f, 0.02859720f, -0.08282420f, -0.05006030f, 0.10419875f, 
    0.49389768f, -0.16783834f, 0.13981694f, -0.01744688f, 0.01966704f, -0.09512336f, 0.05480408f, 0.09061995f, 
    -0.00785944f, 0.03291432f, 0.11420998f, -0.06349577f, -0.24862124f, 0.04611922f, 0.05349769f, -0.11388830f, 
    0.07405919f, -0.00628514f, 0.03092047f, -0.01345003f, 0.10875750f, 0.05822685f, 0.01740374f, 0.03165819f, 
    0.00707694f, -0.11439314f, -0.06259615f, 0.27218986f, 0.17844784f, 0.06351659f, 0.12612399f, 0.04952928f, 
    0.01102958f, -0.05605202f, 0.01243304f, 0.00469427f, -0.11095730f, -0.05987693f, 0.00676783f, 0.16445290f, 
    -0.11925270f, -0.11861128f, -0.06681295f, -0.01698893f, -0.03947232f, -0.12234829f, -0.00997979f, 0.04045583f, 
    -0.34559804f, -0.03290824f, 0.02131868f, 0.05876311f, 0.07714391f, 0.14779642f, 0.10830718f, -0.00097201f, 
    0.09380860f, -0.05474932f, 0.01394141f, -0.06542179f, -0.10056198f, 0.22640614f, 0.03734599f, -0.07468440f, 
    0.09068177f, -0.01784903f, -0.01263290f, 0.12144409f, 0.00671014f, -0.01935225f, -0.02082432f, 0.03226725f, 
    0.08197523f, 0.02134205f, -0.02957151f, -0.11346526f, 0.12293606f, 0.06531795f, -0.01713401f, -0.04169333f, 
    0.05021174f, 0.08346326f, -0.02959374f, 0.00292076f, -0.09738020f, -0.00972510f, 0.03098626f, 0.05651147f, 
    -0.01419748f, 0.11514502f, -0.10684483f, 0.10033175f, 0.08427750f, -0.07035165f, -0.03308563f, 0.09674796f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07813039f, 0.05038736f, 0.09354451f, 0.03208157f, 0.03932159f, 0.01027661f, -0.02780991f, 0.05270727f, 
    -0.01510921f, -0.01093196f, -0.00235245f, -0.04779170f, 0.00689975f, -0.04059203f, 0.00389929f, -0.02764929f, 
    -0.03476693f, 0.04652813f, 0.00725411f, 0.06887988f, 0.09613816f, 0.16159044f, 0.01294800f, 0.11222458f, 
    -0.06364235f, 0.05908268f, -0.03256764f, 0.00593168f, -0.06458668f, 0.03116311f, 0.04116333f, -0.04663781f, 
    0.04374008f, -0.01042020f, 0.02608986f, 0.10646142f, -0.08144119f, -0.05868214f, -0.02223176f, 0.12836331f, 
    -0.00462318f, -0.03288817f, 0.07496957f, 0.09618927f, 0.02031345f, 0.15066168f, -0.01567583f, -0.02137552f, 
    -0.00616238f, -0.04681138f, 0.12156575f, -0.05707655f, 0.07652675f, -0.00727526f, 0.05614705f, 0.06630652f, 
    -0.06774711f, 0.00468224f, 0.07168992f, -0.04082845f, -0.01014559f, -0.01376258f, 0.06630040f, -0.00728048f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.00461434f, 0.09284776f, -0.07315574f, 0.04190665f, -0.13553251f, -0.10831648f, -0.02980094f, 0.00845760f, 
    -0.03033874f, 0.12703052f, -0.11908074f, 0.24583265f, 0.46215999f, 0.00133599f, 0.19550987f, 0.22022699f, 
    0.10778135f, -0.01550396f, -0.00864397f, 0.16049896f, 0.25539169f, 0.16990092f, -0.07894719f, 0.12293383f, 
    -0.00372697f, 0.22766463f, -0.11934122f, -0.22540829f, 0.19672081f, 0.12280298f, -0.30718783f, 0.25510004f, 
    0.29179427f, 0.01049152f, -0.10119968f, 0.13254446f, -0.00620483f, -0.11347087f, 0.01935424f, 0.00206181f, 
    0.10318393f, 0.26437876f, -0.09292188f, -0.09731326f, 0.07770150f, -0.27352673f, -0.05520767f, 0.07579513f, 
    0.00422334f, 0.13495678f, -0.16338253f, -0.04947110f, 0.23515436f, 0.07468236f, -0.12549523f, -0.25530449f, 
    0.06778905f, -0.03114788f, -0.23429784f, -0.07986128f, -0.10732245f, -0.21781677f, -0.33726099f, 0.18212202f, 
    -0.11210541f, 0.06249508f, -0.08679985f, 0.00290243f, -0.34233576f, 0.45273736f, 0.00469886f, 0.03651174f, 
    -0.13084030f, 0.07338730f, 0.05452143f, -0.19391054f, 0.02071414f, 0.12027282f, 0.13165630f, 0.02518387f, 
    0.10434181f, 0.16422307f, 0.09577919f, -0.01123673f, 0.05569671f, -0.14117487f, 0.00871199f, -0.11006340f, 
    0.00151356f, 0.11693934f, 0.14767776f, -0.38197976f, 0.14713597f, 0.05153456f, -0.03529355f, 0.13572395f, 
    -0.14719285f, 0.10271386f, 0.29721120f, -0.02693281f, -0.09252568f, -0.03749503f, -0.02090912f, -0.15625745f, 
    0.10613913f, 0.18542650f, -0.07887983f, 0.04138941f, 0.05874679f, 0.22750677f, 0.12951481f, 0.08635060f, 
    -0.06255623f, -0.03524787f, 0.07340321f, 0.04486974f, 0.11686362f, 0.12480070f, 0.30973592f, 0.14374998f, 
    0.21478084f, -0.11752108f, -0.17649284f, 0.13813722f, 0.04782543f, 0.19726658f, 0.07571238f, 0.05599995f, 
    0.01817367f, 0.07992062f, 0.05738221f, -0.06465092f, 0.03954198f, -0.11999524f, -0.06606653f, -0.00298466f, 
    0.07343011f, -0.04344772f, -0.09967863f, 0.02294126f, -0.14008723f, 0.06794148f, -0.12542044f, 0.02474558f, 
    0.02573509f, -0.10289049f, 0.06098029f, -0.02486796f, -0.04453278f, -0.01402291f, 0.01983394f, -0.13871188f, 
    0.06117648f, -0.09974770f, 0.00768587f, -0.09530038f, 0.04474649f, 0.08862127f, -0.04302318f, -0.07792316f, 
    -0.12086520f, -0.11807583f, -0.06957715f, 0.02734723f, 0.10723495f, -0.01620356f, 0.07014864f, -0.10009718f, 
    0.01122673f, -0.08048415f, 0.08152210f, -0.12912239f, -0.10801298f, 0.03237746f, 0.01369745f, 0.05112522f, 
    -0.07035312f, 0.06826720f, -0.00736902f, 0.07037752f, -0.09214043f, -0.06486804f, 0.09559787f, 0.05727751f, 
    0.01035213f, -0.04410037f, 0.05860303f, 0.05147709f, -0.12499590f, -0.03104684f, -0.03786852f, -0.05740054f, 
    -0.01157831f, 0.05394850f, 0.29653719f, -0.19633935f, -0.26853305f, 0.33453700f, 0.02666461f, 0.12393204f, 
    0.11049732f, 0.08465336f, -0.00855433f, -0.10915647f, 0.21187550f, -0.05055476f, -0.10124871f, 0.21095888f, 
    0.36840254f, 0.12301020f, 0.05551807f, 0.26980489f, -0.02014693f, 0.04754229f, -0.06460636f, -0.10442284f, 
    -0.05345273f, 0.43729040f, 0.03521386f, -0.27925286f, 0.18239918f, 0.04047988f, -0.24135002f, 0.24709553f, 
    -0.10360537f, -0.10677535f, 0.28813371f, -0.09828488f, 0.05538334f, -0.09396938f, -0.07026730f, 0.29560581f, 
    0.00335636f, 0.10293593f, -0.12713067f, 0.10152832f, 0.15900566f, 0.35472429f, -0.01878143f, -0.00260293f, 
    -0.03822942f, -0.05071092f, -0.00911466f, 0.09047067f, -0.12173606f, -0.02777861f, 0.28920305f, -0.07969458f, 
    0.05799325f, 0.09627710f, -0.20531313f, -0.04275622f, -0.05365255f, 0.11207031f, -0.15273266f, -0.06402813f, 
    -0.03645706f, -0.09118311f, -0.11730436f, -0.13359758f, -0.11126673f, -0.11130446f, 0.07853930f, 0.06589256f, 
    -0.09662880f, -0.04920979f, 0.10295345f, 0.03727425f, -0.09539792f, 0.08505534f, -0.09372973f, 0.08680529f, 
    -0.01721794f, -0.04573392f, 0.11898673f, 0.08281021f, -0.05018733f, -0.05848062f, -0.10448363f, 0.03894478f, 
    -0.09746796f, -0.02911583f, -0.08302817f, 0.06094317f, 0.00783937f, -0.01979529f, -0.09080298f, -0.03526566f, 
    -0.12222590f, -0.07453938f, 0.09421790f, -0.07622540f, 0.01641184f, -0.08759834f, -0.00222276f, -0.05120244f, 
    0.06059939f, -0.02905066f, -0.13059257f, -0.04624993f, -0.04877675f, -0.00366752f, -0.07244395f, 0.06900279f, 
    -0.05680582f, -0.10885894f, 0.07290335f, -0.08651093f, -0.11060554f, -0.07930873f, -0.10975710f, 0.09853607f, 
    0.00687391f, -0.04259652f, 0.05316895f, 0.00230937f, 0.04075369f, -0.00099849f, -0.09490947f, 0.01684418f, 
    0.04273459f, -0.09961182f, -0.12971278f, 0.05949687f, -0.02061968f, -0.12008218f, -0.02547006f, 0.10905863f, 
    0.09445130f, 0.04324298f, -0.10273724f, 0.07663798f, -0.07943794f, -0.03548001f, 0.26112083f, 0.06123746f, 
    -0.19016412f, 0.18419103f, -0.06954484f, 0.07006165f, 0.06234151f, 0.04900390f, 0.05126796f, 0.08992769f, 
    0.07635947f, -0.36959261f, 0.06317550f, 0.37530899f, -0.18185931f, 0.01454846f, -0.15534881f, 0.15315351f, 
    0.29697269f, 0.00648912f, 0.07696575f, -0.11308600f, -0.09829879f, 0.03715587f, 0.02183619f, -0.00448802f, 
    -0.09264059f, 0.17956202f, -0.15757561f, -0.11802211f, -0.19455150f, -0.23091052f, -0.12490190f, 0.08491539f, 
    -0.06059356f, 0.24614534f, -0.02883576f, 0.06302693f, -0.05460469f, 0.00843609f, -0.06748416f, 0.14783499f, 
    0.10951801f, -0.05103998f, -0.11948638f, 0.20083381f, -0.01765604f, -0.13363247f, -0.34068769f, 0.11862813f, 
    0.09517170f, -0.05158301f, -0.09412666f, 0.27168140f, 0.13587935f, -0.31062758f, -0.05359852f, 0.12804174f, 
    -0.27703625f, -0.01101336f, 0.11741845f, 0.17272778f, -0.25428072f, 0.09132832f, 0.28932685f, 0.02794613f, 
    -0.16616210f, -0.02189866f, -0.03158645f, -0.00176482f, 0.13160980f, -0.04213353f, 0.01316045f, 0.13140531f, 
    0.08550067f, -0.47709370f, -0.06139841f, 0.38923159f, 0.13840634f, 0.02563884f, 0.23074389f, -0.14785467f, 
    -0.01827064f, 0.02268610f, -0.30821946f, 0.15239835f, -0.07556424f, -0.09447265f, -0.10521685f, -0.11927946f, 
    0.08951075f, 0.26717332f, 0.09655807f, -0.01861065f, -0.06572750f, -0.14675720f, 0.22836898f, 0.05775303f, 
    0.00645503f, 0.04556734f, 0.16643521f, 0.12042899f, 0.12385609f, -0.12751415f, 0.08758897f, 0.07602603f, 
    0.20108500f, 0.10329130f, -0.04468675f, -0.13664031f, 0.01704457f, 0.15413478f, 0.06977827f, -0.08051065f, 
    0.18630688f, 0.09548943f, -0.08450545f, 0.16903500f, 0.15461525f, -0.07365236f, -0.09155554f, 0.00687249f, 
    0.15128900f, 0.01489018f, 0.06958281f, -0.17136680f, 0.31546155f, 0.02916610f, 0.02402852f, -0.23165490f, 
    0.04947502f, -0.13243060f, 0.07702349f, 0.15458626f, -0.21801320f, -0.05913098f, -0.11847971f, 0.18434581f, 
    -0.05408965f, 0.07082106f, 0.06122072f, 0.39836863f, 0.17235608f, 0.11474066f, 0.26463988f, -0.15265720f, 
    0.10050159f, -0.12027106f, -0.15333568f, -0.14809771f, 0.11482643f, -0.12404062f, -0.11152579f, -0.15452805f, 
    -0.10895260f, -0.15777245f, -0.18713777f, -0.02540496f, -0.02297992f, -0.17757276f, 0.02715663f, 0.01829396f, 
    0.00900969f, 0.21246292f, 0.21452898f, 0.09183974f, 0.14991808f, 0.02611931f, -0.13785033f, 0.16345528f, 
    -0.26551098f, 0.04253376f, 0.84309000f, 0.10307498f, 0.09582864f, -0.04722511f, 0.13886639f, 0.21168049f, 
    -0.01359937f, -0.07051405f, -0.03321508f, 0.20011429f, 0.23670210f, -0.10473868f, -0.05422472f, 0.07748190f, 
    -0.20730984f, -0.01722355f, -0.06585036f, 0.26623020f, -0.04441271f, -0.02558852f, 0.21795790f, 0.03492573f, 
    0.07908760f, -0.00185542f, 0.09651463f, 0.04937437f, -0.06662473f, -0.09319523f, -0.09602068f, -0.01602820f, 
    -0.07193738f, -0.24777800f, -0.22975431f, 0.15844131f, 0.21217974f, 0.14904000f, 0.14055641f, -0.12296963f, 
    -0.12522516f, 0.09705316f, -0.25281948f, 0.04490076f, 0.01190830f, 0.05282643f, -0.07124455f, -0.17407925f, 
    0.07476927f, 0.13794866f, -0.05247670f, -0.25418332f, -0.04447178f, -0.00452928f, 0.30046797f, 0.07200775f, 
    -0.01240233f, 0.05697241f, 0.18171294f, 0.05976078f, 0.23375647f, 0.01111014f, -0.04879192f, 0.00242559f, 
    0.16249174f, -0.09221679f, 0.08836464f, 0.10475550f, -0.11163405f, -0.02900022f, -0.01509647f, -0.08153521f, 
    0.02175554f, 0.07413501f, -0.05400132f, -0.07867463f, 0.32604462f, -0.02493276f, -0.09848615f, -0.00299989f, 
    0.10507090f, -0.05713648f, -0.07614660f, 0.10062266f, 0.25654969f, -0.11285768f, 0.01228885f, 0.11780146f, 
    -0.31990483f, -0.30892253f, 0.02450755f, -0.01136039f, 0.16072510f, 0.01382637f, 0.09794547f, 0.10800794f, 
    -0.06563914f, 0.37258852f, 0.18850894f, -0.44564050f, 0.00580407f, 0.21851960f, -0.15503785f, 0.16007127f, 
    0.05264269f, -0.08401878f, -0.00901498f, 0.00227616f, 0.11912170f, 0.09700086f, 0.07638996f, -0.22564608f, 
    0.07002775f, -0.15914905f, 0.31221941f, 0.12047066f, 0.39179811f, 0.30159107f, 0.01589952f, -0.20095989f, 
    -0.04132834f, -0.11444771f, -0.03774237f, 0.01400326f, 0.16006286f, 0.03985375f, -0.12931523f, 0.23381740f, 
    -0.07692362f, 0.00330141f, 0.24454671f, 0.11497149f, 0.11194350f, 0.14910981f, 0.12257423f, 0.28455898f, 
    0.13507342f, -0.13143659f, 0.20350248f, 0.20709267f, -0.21781680f, -0.00156967f, -0.10515815f, 0.03929940f, 
    -0.18789002f, -0.02652301f, 0.05061609f, 0.35124210f, -0.09610012f, -0.12566543f, 0.06385235f, 0.27046666f, 
    -0.04900404f, 0.07091644f, 0.08839409f, -0.39948913f, 0.04421240f, 0.00688822f, -0.01818360f, -0.04183776f, 
    0.11074732f, -0.17212760f, -0.26795816f, -0.29841563f, 0.13256764f, 0.30688134f, -0.21956070f, 0.01544763f, 
    -0.03515975f, -0.00404968f, 0.15023418f, 0.16328435f, 0.01158535f, -0.10506399f, 0.06004163f, -0.12735371f, 
    0.06467031f, 0.17263395f, 0.03844447f, 0.18130556f, 0.03711044f, -0.00727570f, 0.23634513f, 0.26290175f, 
    0.04551230f, -0.14445446f, -0.02610891f, -0.11641265f, 0.02158339f, -0.10969867f, 0.07113264f, -0.06156661f, 
    0.27385283f, -0.01212389f, -0.30280843f, 0.02026879f, 0.07951227f, 0.21337709f, -0.22383969f, -0.15363461f, 
    0.06591210f, -0.02863270f, -0.14643078f, 0.17712083f, -0.03530183f, -0.37041041f, -0.06092225f, -0.03090281f, 
    0.10800393f, -0.05575741f, -0.08158500f, 0.32284200f, -0.08946096f, -0.06078776f, 0.01265758f, 0.17674387f, 
    0.30037680f, -0.14848122f, 0.10349671f, -0.02469378f, -0.18439676f, 0.16141090f, 0.07058353f, 0.14001752f, 
    -0.11622797f, 0.01861837f, -0.02703132f, 0.05086762f, 0.13538590f, 0.06021497f, 0.17771690f, -0.36011615f, 
    -0.12688607f, 0.10607598f, -0.37033927f, 0.15119761f, 0.00154353f, -0.09203050f, -0.02821290f, 0.03782721f, 
    0.06150388f, -0.02910473f, 0.15776150f, -0.05692888f, -0.01583806f, -0.09398852f, 0.03630626f, -0.14401369f, 
    -0.00187794f, -0.01496735f, 0.31494927f, 0.11247427f, -0.11210004f, -0.04861119f, -0.22729069f, -0.14195913f, 
    0.17109630f, -0.02185769f, -0.31861186f, -0.19122012f, 0.03642917f, -0.12900899f, 0.22198430f, -0.16393046f, 
    0.19150050f, 0.04496465f, 0.21247390f, 0.04955341f, 0.00803437f, 0.16725093f, 0.11674691f, 0.15185972f, 
    0.00388014f, 0.12089404f, -0.04241604f, 0.10142053f, 0.20376574f, 0.01375640f, -0.13971525f, 0.04424611f, 
    -0.20733020f, 0.21178064f, 0.08870490f, -0.04101944f, 0.34126344f, 0.10346697f, 0.00538869f, 0.13732272f, 
    0.11645211f, 0.02054629f, -0.24176322f, -0.46658003f, 0.04814348f, 0.20625685f, -0.19316177f, 0.32722369f, 
    0.06585363f, 0.00914319f, 0.19169652f, 0.39122200f, 0.07816112f, 0.08086197f, 0.02040440f, -0.09464040f, 
    -0.10562541f, -0.04930203f, 0.01087159f, -0.13859443f, -0.20403276f, -0.00599112f, -0.10357521f, 0.15457085f, 
    0.11501686f, 0.07817058f, -0.19971415f, 0.10456611f, 0.03787998f, 0.12129627f, 0.04976318f, -0.21056138f, 
    0.01166491f, -0.10371850f, -0.01061860f, 0.09302548f, -0.06246057f, -0.06548219f, -0.11127981f, 0.07445532f, 
    0.09853271f, -0.00503434f, -0.08754193f, 0.09945983f, 0.02800680f, -0.10758623f, 0.01208077f, 0.00570913f, 
    0.02644699f, 0.01696720f, -0.05321433f, 0.02104611f, -0.10918304f, -0.08181702f, 0.02481977f, -0.22948150f, 
    -0.19257674f, -0.24822789f, 0.07983608f, 0.13952854f, 0.17725448f, 0.33767477f, 0.00408130f, 0.16214724f, 
    0.06015906f, 0.29359716f, -0.04334503f, -0.00014965f, 0.07862844f, 0.15962504f, 0.11758393f, -0.25534940f, 
    0.04279593f, -0.05282741f, -0.10254256f, -0.16068459f, 0.01692903f, -0.04258095f, 0.03507632f, -0.16929056f, 
    -0.03862306f, -0.04798444f, 0.20762867f, 0.30156741f, 0.17213874f, 0.11871123f, 0.01488120f, -0.16460136f, 
    -0.12029830f, -0.09816142f, 0.19691736f, 0.05467606f, 0.35443565f, 0.12446962f, -0.20614521f, 0.11288740f, 
    -0.07120343f, 0.07358745f, 0.52885461f, -0.01665335f, 0.10827267f, -0.30803147f, 0.01307355f, 0.18578820f, 
    0.21557269f, 0.01080503f, 0.12353808f, 0.02131040f, -0.31762064f, -0.06836054f, 0.01258695f, -0.08418427f, 
    0.19023849f, -0.02248986f, -0.06555139f, 0.20445678f, -0.20846294f, -0.03695881f, 0.15744889f, 0.35559145f, 
    -0.23473145f, 0.19894393f, -0.04286531f, -0.26056099f, 0.17916086f, 0.16338959f, -0.03595757f, 0.00935071f, 
    -0.02291707f, -0.11697013f, -0.14909245f, -0.01055704f, -0.02152134f, -0.04407063f, -0.02200171f, 0.18926157f, 
    0.19801463f, 0.00418220f, 0.04980266f, 0.19391571f, -0.09239957f, 0.00547931f, -0.02072906f, 0.02918060f, 
    0.09550368f, 0.00089189f, -0.23572376f, -0.21510774f, -0.03369457f, -0.25715414f, 0.24764328f, 0.17021778f, 
    -0.04608336f, 0.09266551f, 0.18124847f, 0.05033275f, -0.02141716f, -0.07199134f, 0.03172239f, 0.00762113f, 
    0.18517974f, -0.09054321f, -0.17256288f, -0.10338157f, 0.06733824f, -0.27697095f, -0.42774537f, 0.00485103f, 
    0.03415597f, -0.01558676f, 0.14468925f, 0.18939508f, -0.23009960f, -0.17558348f, 0.04738791f, 0.14525506f, 
    0.18220183f, -0.03026192f, -0.01426731f, -0.13626710f, -0.25627440f, 0.10161604f, -0.06966694f, 0.15441173f, 
    -0.50506079f, 0.06637993f, 0.00385217f, -0.39089310f, 0.12006368f, -0.15306179f, -0.07046191f, 0.18321724f, 
    0.10701364f, -0.34821609f, 0.25412166f, 0.01675976f, -0.04921724f, 0.18908030f, -0.09025851f, 0.25127587f, 
    0.10492295f, 0.05404621f, 0.01046233f, 0.04214513f, 0.09972084f, -0.06139714f, 0.05109830f, -0.10050613f, 
    0.08885898f, 0.07371704f, -0.08139870f, 0.06146619f, 0.14481401f, -0.28454900f, 0.23124327f, 0.28588390f, 
    0.05800039f, 0.21603028f, -0.01128524f, -0.12156075f, -0.16387142f, 0.01731530f, 0.10443871f, 0.27207881f, 
    -0.03654214f, 0.08144198f, -0.03702229f, 0.08791509f, -0.06423424f, 0.25182822f, -0.13512193f, -0.08534562f, 
    0.24213254f, 0.08295967f, -0.08220109f, 0.20630285f, 0.01706802f, -0.20735918f, -0.00499143f, -0.14407296f, 
    -0.20332277f, 0.05336438f, -0.01928909f, 0.10826650f, 0.16953769f, -0.09911239f, 0.04057996f, -0.07101743f, 
    0.37235349f, -0.08344015f, 0.00744693f, 0.22053620f, -0.10354117f, 0.23346201f, -0.05695394f, 0.09607804f, 
    -0.02348338f, 0.09567368f, -0.34439322f, 0.18534499f, 0.07736830f, 0.05910246f, 0.21312051f, -0.14891163f, 
    -0.04425552f, -0.01839075f, -0.09211214f, -0.00210877f, 0.02872900f, 0.10040921f, 0.07182285f, -0.04598845f, 
    0.08156059f, 0.19156264f, -0.18000793f, -0.06825060f, -0.34201196f, -0.16919491f, 0.00892054f, 0.10372625f, 
    -0.02414427f, 0.18005244f, 0.14460593f, 0.03509188f, 0.19931661f, -0.00889920f, 0.01129900f, -0.30010062f, 
    -0.20169871f, -0.10832348f, 0.53093809f, -0.09798068f, 0.09062120f, -0.23555742f, 0.00099985f, 0.12566853f, 
    0.12588568f, -0.03126654f, -0.11068527f, -0.06849598f, -0.35423574f, -0.03777868f, -0.06526858f, 0.04580902f, 
    0.01870436f, 0.05455881f, -0.10930628f, -0.30857176f, -0.24790776f, 0.06763027f, 0.13697304f, 0.12939227f, 
    -0.18330602f, -0.06454597f, -0.02604909f, -0.05705690f, 0.19932616f, -0.08992513f, -0.05598308f, -0.15569560f, 
    0.07673542f, -0.18541104f, 0.10185554f, -0.19018830f, -0.03405386f, 0.13834600f, -0.07314600f, 0.14692818f, 
    0.11286225f, 0.04895188f, 0.11898935f, 0.30745229f, -0.06101182f, 0.07027426f, -0.02385636f, -0.37409940f, 
    -0.11082314f, 0.22308946f, -0.28154644f, -0.03092205f, -0.15083039f, -0.04784744f, 0.13343543f, 0.12084028f, 
    -0.04381413f, 0.17786357f, 0.13736841f, 0.02812538f, 0.22930805f, 0.08389148f, 0.08556172f, 0.02090771f, 
    0.12468863f, 0.09474245f, 0.07827834f, 0.19494633f, -0.01522768f, -0.23036379f, -0.05919307f, 0.11097160f, 
    0.00475964f, -0.03930688f, -0.10911503f, 0.07224613f, -0.07151072f, -0.02586914f, 0.02639878f, -0.11468901f, 
    0.09913164f, 0.08621682f, -0.00674773f, -0.12155965f, -0.03564302f, 0.06424183f, 0.02145093f, -0.07644586f, 
    -0.07239413f, -0.09310976f, -0.06970682f, -0.04327155f, -0.06734554f, -0.06807078f, 0.04454065f, -0.02105574f, 
    0.06761876f, 0.04622850f, -0.01810034f, -0.10124625f, 0.00057086f, -0.14226146f, -0.07341384f, 0.06849624f, 
    0.04077791f, 0.01075332f, 0.03016852f, 0.06446432f, 0.08570279f, 0.08154723f, -0.05341491f, 0.03918936f, 
    -0.08371749f, -0.02195496f, -0.03246780f, -0.01379196f, -0.04887716f, 0.07022616f, 0.09054694f, -0.02795041f, 
    -0.10758922f, -0.12899983f, -0.04324983f, -0.11358517f, -0.08363206f, 0.07340465f, 0.04459705f, -0.06622577f, 
    -0.01265151f, 0.09547721f, 0.06767734f, 0.05404308f, 0.02150124f, 0.05053561f, -0.01671487f, -0.05788982f, 
    -0.06711150f, 0.00669837f, -0.02274078f, 0.03150507f, 0.21589611f, 0.10761485f, -0.00219468f, -0.11698988f, 
    -0.14640036f, 0.03900362f, -0.03854902f, 0.15103357f, -0.34560555f, -0.11963344f, 0.25091997f, -0.12417568f, 
    -0.10799524f, -0.15974785f, -0.01406172f, 0.17601791f, 0.37298524f, 0.17121032f, 0.09567709f, -0.17949615f, 
    -0.10053165f, 0.02284374f, 0.16241176f, 0.28930262f, -0.01985557f, 0.00538983f, 0.03719992f, -0.27028036f, 
    0.11117192f, 0.09308623f, 0.04354692f, 0.17943954f, 0.08203935f, -0.06210133f, -0.05635796f, 0.01392399f, 
    -0.01413934f, 0.24223597f, 0.32721540f, 0.19507180f, 0.16065635f, 0.29222238f, -0.00074120f, -0.11682278f, 
    0.00809668f, -0.08369645f, 0.27586704f, 0.12960622f, 0.28269300f, -0.08703445f, -0.01613092f, 0.17993525f, 
    0.13686419f, 0.05897327f, -0.35194740f, 0.17594604f, -0.10490900f, -0.34334999f, 0.11796882f, -0.16238660f, 
    0.11462167f, -0.06429242f, 0.12815069f, 0.09703933f, 0.12134933f, -0.05540882f, -0.08824455f, 0.03964881f, 
    0.23182368f, 0.10025825f, 0.02298804f, -0.17024443f, 0.22051981f, -0.04507142f, -0.16898102f, 0.27212158f, 
    -0.45902476f, 0.05995065f, -0.07050090f, -0.34296748f, 0.18037608f, 0.16579054f, 0.01744926f, -0.06310889f, 
    -0.03746221f, -0.02279727f, -0.03199902f, -0.35543892f, -0.17141949f, 0.21767320f, -0.01396730f, 0.20701662f, 
    -0.00587001f, 0.00393065f, 0.06239014f, 0.18984120f, 0.12263421f, 0.12384639f, -0.07016718f, 0.12251996f, 
    0.00864241f, -0.05945515f, -0.06226933f, 0.01022744f, -0.01483024f, -0.07326236f, -0.04313001f, 0.18944107f, 
    0.02593684f, 0.11781474f, -0.25264004f, -0.07210547f, 0.00851971f, 0.03933998f, -0.08204266f, 0.21674912f, 
    0.05583154f, 0.01217809f, 0.22507057f, 0.15756555f, 0.09741527f, -0.00392256f, -0.16227023f, 0.04037670f, 
    0.03824006f, 0.10490751f, -0.01550101f, -0.14630361f, -0.00660269f, -0.00047077f, -0.07373726f, 0.03659784f, 
    -0.00583135f, 0.06188792f, 0.05169446f, -0.14580870f, 0.06869432f, -0.10499460f, -0.10094343f, -0.20752813f, 
    0.08388251f, 0.02206225f, -0.06416936f, 0.04337019f, 0.08626736f, 0.04571232f, 0.06381412f, -0.13185680f, 
    -0.05286941f, 0.03500942f, -0.15287799f, 0.02676859f, -0.15349247f, 0.08521256f, -0.12085297f, -0.08403952f, 
    -0.01349025f, -0.04550086f, 0.08528441f, -0.10067485f, -0.07354245f, 0.06535930f, -0.01502635f, -0.06972338f, 
    0.10894895f, -0.02347620f, -0.13983488f, 0.01917041f, -0.03255202f, 0.04551980f, -0.02656359f, 0.07387933f, 
    -0.00074376f, -0.11906479f, -0.03466240f, -0.10355124f, -0.16203232f, -0.08373878f, -0.04995029f, -0.10485207f, 
    -0.03153870f, -0.09347075f, 0.04331607f, -0.08137420f, 0.07675123f, -0.07767245f, 0.00722822f, 0.02207532f, 
    -0.04279708f, -0.02525245f, -0.16500038f, 0.20588996f, 0.13364843f, -0.00591475f, -0.01749192f, 0.03456921f, 
    -0.20321023f, 0.11883933f, 0.09311865f, 0.05742324f, -0.03465074f, 0.00046579f, 0.25512460f, -0.03155652f, 
    0.30301350f, 0.04506512f, -0.07545173f, 0.17621157f, -0.10085375f, 0.01077773f, 0.11701050f, -0.01398971f, 
    0.01984587f, -0.03027364f, 0.06120423f, 0.24135008f, 0.10804335f, 0.17884921f, 0.12360539f, -0.23874879f, 
    -0.24326554f, 0.01854861f, -0.23148765f, -0.12885804f, -0.08722139f, 0.11143757f, 0.08300579f, -0.33554685f, 
    0.04269210f, 0.16354740f, 0.23360682f, 0.12497347f, -0.08620636f, 0.18672746f, -0.11909164f, 0.06933044f, 
    -0.05837613f, -0.00675994f, 0.08347929f, 0.05508405f, 0.12153526f, -0.05249548f, 0.17955671f, 0.02253641f, 
    0.10186682f, -0.02008341f, 0.02209537f, 0.02181780f, 0.06146505f, 0.38780427f, 0.18653351f, 0.04235573f, 
    -0.12157521f, -0.01909611f, 0.17988046f, -0.04570348f, 0.04881664f, -0.03692449f, 0.09585997f, 0.04303921f, 
    0.25429481f, 0.09435942f, -0.08160987f, -0.04349337f, 0.05671948f, -0.03163920f, 0.00005975f, 0.39653012f, 
    -0.15348707f, 0.19229354f, 0.00290057f, 0.17128746f, 0.06693749f, 0.27839336f, -0.03932930f, -0.02710698f, 
    -0.00414624f, 0.01573983f, -0.04591585f, 0.12548831f, -0.24106605f, 0.03373493f, -0.00109821f, 0.09706968f, 
    0.41040793f, 0.01963451f, 0.26223159f, -0.07282856f, -0.07097261f, -0.11514794f, 0.09708476f, 0.24732290f, 
    -0.06061585f, 0.13198778f, -0.04936749f, -0.21781808f, 0.14902261f, -0.04802005f, 0.15052117f, 0.03446693f, 
    0.11933214f, 0.09619139f, -0.04663267f, 0.10739804f, 0.06888136f, -0.11944767f, -0.15754040f, 0.26122835f, 
    0.03866185f, 0.06318244f, -0.38858914f, 0.28805080f, 0.06489162f, -0.38729522f, -0.51835269f, 0.14851448f, 
    -0.10774617f, -0.02567410f, 0.02746010f, 0.00399971f, 0.08573572f, -0.01877296f, -0.06257530f, -0.12238404f, 
    -0.10869154f, -0.02489331f, -0.04832658f, -0.14772430f, -0.10638970f, -0.11141030f, 0.02821960f, 0.08807372f, 
    -0.08432180f, -0.06583287f, 0.09712814f, -0.08191873f, 0.05626024f, -0.03776895f, -0.12400869f, 0.10069472f, 
    -0.05014320f, 0.03781391f, -0.00397138f, 0.05206738f, -0.07649073f, 0.01691926f, 0.01068626f, -0.10998879f, 
    0.04466463f, 0.11578350f, 0.10219678f, -0.02436567f, 0.04624392f, -0.07999244f, -0.04407470f, 0.00119242f, 
    -0.11883795f, -0.12610637f, -0.04549450f, -0.04597594f, -0.06079503f, 0.00790357f, -0.02313295f, -0.13019587f, 
    -0.05407837f, -0.07271699f, -0.09276058f, 0.01508477f, 0.10831159f, 0.09911044f, 0.08404426f, 0.04986316f, 
    -0.01768246f, -0.08047175f, -0.04142047f, -0.04646951f, 0.05194679f, -0.07659536f, -0.08882111f, -0.01856491f, 
    0.07995478f, 0.09204691f, -0.09664385f, 0.04299242f, -0.01557416f, 0.03074733f, 0.09836678f, -0.02486672f, 
    -0.00771904f, -0.01946993f, -0.08496501f, -0.06368551f, 0.08922930f, -0.12227811f, -0.13666248f, 0.04843733f, 
    0.06986666f, -0.13218915f, 0.05470257f, -0.07753675f, -0.03590385f, -0.06883527f, -0.04017698f, -0.07830019f, 
    -0.02184644f, -0.08332906f, -0.06888159f, -0.07215369f, -0.11419695f, -0.12294178f, -0.02178867f, -0.03757481f, 
    -0.10349077f, 0.11824179f, 0.03768468f, -0.03194512f, 0.06871808f, -0.06652293f, 0.10829702f, 0.06505153f, 
    -0.04717516f, -0.06982962f, -0.02321150f, -0.09955619f, -0.05410680f, 0.06563611f, 0.07020541f, -0.10853098f, 
    0.07705075f, -0.05381610f, 0.04825462f, 0.04756675f, -0.13806283f, 0.04025199f, 0.02484951f, 0.02985285f, 
    -0.00306123f, -0.07883202f, -0.10955224f, -0.07096785f, -0.02710421f, -0.12797235f, 0.00282610f, -0.07310918f, 
    -0.08887477f, 0.08284671f, 0.15755026f, -0.04873327f, 0.01725397f, 0.22550240f, -0.08760686f, -0.08289950f, 
    0.04394161f, 0.00867768f, 0.08158812f, -0.17240244f, 0.09495312f, -0.01884628f, -0.07487265f, -0.03297756f, 
    -0.00641568f, -0.00031967f, 0.06914558f, 0.20897773f, 0.17694592f, 0.26006112f, 0.01479237f, 0.11647808f, 
    0.08308760f, 0.32709906f, 0.20081499f, -0.11076741f, 0.07878385f, -0.11199773f, -0.09180463f, 0.30962664f, 
    0.16112182f, -0.03114283f, 0.31819844f, -0.00069906f, -0.00512218f, 0.09412344f, -0.10189819f, 0.15080053f, 
    0.00614844f, -0.03316995f, -0.13483337f, 0.19117968f, -0.12178221f, 0.20115036f, -0.14620239f, 0.00273648f, 
    -0.08253212f, 0.07732971f, -0.19346890f, 0.09999899f, 0.09438235f, -0.11236451f, 0.19184281f, -0.10413068f, 
    -0.05093350f, 0.05339870f, 0.13420337f, 0.08747214f, -0.02363233f, -0.38990498f, 0.05590881f, 0.01211837f, 
    0.11565706f, -0.02215189f, -0.04147610f, 0.06655952f, -0.07635507f, 0.04944907f, 0.03623424f, -0.01643774f, 
    0.07700457f, -0.09590849f, -0.11362488f, -0.36621067f, 0.28799200f, 0.02260808f, -0.10175092f, -0.21200693f, 
    0.05187464f, -0.23675656f, -0.10156673f, 0.23969844f, 0.07114156f, -0.00714728f, -0.08318256f, 0.26462883f, 
    0.02801554f, 0.48247024f, 0.22799926f, -0.08655397f, 0.17526656f, 0.13989694f, -0.18755099f, 0.25821185f, 
    -0.14462288f, 0.08039837f, 0.10108853f, -0.09479248f, -0.03867814f, -0.07646747f, -0.08098136f, -0.30797762f, 
    0.05728436f, -0.02173722f, -0.18915810f, 0.27833804f, 0.14907748f, -0.03432206f, 0.13592787f, 0.01651544f, 
    0.04493207f, 0.17875300f, 0.10016254f, -0.06431678f, 0.18400487f, -0.04816836f, 0.25592548f, 0.03949465f, 
    -0.14983906f, -0.00366629f, 0.59860975f, -0.08767017f, -0.04492235f, 0.04355411f, 0.08165994f, 0.21104614f, 
    -0.01834312f, 0.09430582f, 0.06554285f, -0.12522568f, 0.02093350f, 0.10258684f, 0.05398683f, 0.04992505f, 
    0.03705240f, 0.07235374f, -0.06480575f, -0.14727430f, -0.04607827f, 0.07117242f, 0.06168215f, -0.06742112f, 
    -0.38704813f, -0.28150427f, 0.03511639f, 0.14794660f, 0.23949702f, 0.14767234f, 0.04150923f, 0.08161993f, 
    -0.01324672f, 0.33505493f, 0.31935075f, -0.05950201f, 0.06191753f, -0.03855572f, 0.03531006f, -0.05073009f, 
    -0.08377785f, -0.07421465f, 0.10306396f, 0.31393799f, 0.04193310f, 0.08640506f, -0.08999015f, 0.04407726f, 
    -0.00623110f, -0.24323797f, 0.20059498f, 0.21603571f, 0.28642502f, 0.27999943f, 0.25383654f, 0.09533149f, 
    0.00902043f, -0.01031314f, 0.09189188f, 0.10031392f, 0.21782254f, 0.01899660f, 0.07141918f, 0.11778685f, 
    -0.24944635f, 0.12348297f, -0.02729552f, 0.11924446f, -0.02948132f, -0.37263894f, 0.17396565f, -0.05911912f, 
    -0.03986550f, -0.04378960f, -0.14827140f, 0.16180313f, 0.15642866f, 0.30582821f, -0.04185615f, -0.01382751f, 
    0.08624941f, -0.06094423f, 0.01862833f, 0.12662001f, -0.37455043f, -0.01129060f, 0.15123907f, 0.17297827f, 
    0.10940175f, -0.02646709f, -0.00268554f, 0.11406602f, 0.00196946f, 0.00687893f, -0.04977140f, 0.00357781f, 
    0.09926096f, -0.32340449f, 0.21333240f, 0.42443758f, 0.16169098f, -0.27374363f, 0.38618466f, -0.17830409f, 
    -0.16155536f, 0.00523669f, -0.10764867f, 0.40817466f, 0.06088115f, 0.11781568f, 0.05226694f, 0.07731374f, 
    -0.06871671f, 0.05840921f, 0.14403521f, -0.21951263f, 0.10361335f, 0.14728732f, 0.07292133f, -0.15760474f, 
    -0.05511964f, 0.12731759f, 0.37091643f, -0.04651635f, 0.01977936f, -0.07297803f, -0.03026118f, -0.16397919f, 
    0.01761641f, -0.07101378f, -0.34740284f, -0.10134361f, 0.06976780f, -0.15682508f, 0.32244432f, -0.42383677f, 
    0.17879041f, 0.04049746f, 0.01590690f, 0.08619670f, -0.21053228f, -0.24247271f, 0.02605531f, 0.03715435f, 
    -0.11264040f, -0.11557385f, -0.10978763f, 0.32757938f, -0.20271991f, 0.08356845f, -0.05686002f, 0.06055760f, 
    -0.09001648f, -0.18592882f, -0.00022180f, -0.12754735f, 0.16886204f, 0.32954329f, -0.07926473f, 0.10651307f, 
    -0.09243511f, 0.10130585f, -0.13301559f, 0.11019403f, -0.06290954f, 0.27710053f, 0.17621960f, -0.03715533f, 
    0.02798186f, -0.08375704f, 0.08814799f, -0.31713480f, 0.06729273f, 0.03077505f, 0.05768346f, 0.04269441f, 
    -0.02762976f, -0.09983115f, 0.29874539f, 0.42981589f, 0.01797236f, 0.23492177f, -0.18471342f, 0.04133610f, 
    0.02492658f, -0.03894622f, 0.16264346f, -0.09313241f, -0.13439693f, -0.03413225f, -0.00367775f, 0.12012527f, 
    0.20845522f, -0.08458911f, 0.00745665f, -0.07906163f, 0.11733449f, 0.23527466f, -0.01061382f, -0.17296489f, 
    0.17115538f, -0.04756431f, 0.14680998f, -0.06254242f, -0.02887850f, 0.12773517f, 0.00772148f, 0.14483355f, 
    0.09798745f, 0.08227137f, 0.06752412f, -0.03976217f, -0.07132161f, 0.06003539f, -0.19228378f, -0.21196383f, 
    -0.43062854f, -0.13314945f, 0.11193216f, -0.08742542f, 0.32235804f, 0.28790617f, 0.07180496f, 0.16675264f, 
    0.07664117f, 0.24174234f, 0.17991313f, -0.04805455f, -0.16679811f, 0.21946450f, 0.03496056f, 0.13213496f, 
    0.17182888f, -0.07500755f, 0.19093068f, 0.18614720f, 0.01019660f, 0.01856011f, -0.03320639f, -0.15464988f, 
    -0.08398207f, -0.25217238f, 0.10312422f, 0.44336107f, 0.21288900f, 0.16585469f, -0.16149129f, 0.17796412f, 
    0.12137283f, 0.06516760f, -0.17799832f, -0.08597783f, 0.02489312f, -0.10838892f, 0.10898902f, 0.19333434f, 
    -0.21842533f, -0.12100464f, 0.19501145f, -0.01791978f, -0.08516026f, -0.10774516f, -0.00935098f, -0.04035052f, 
    -0.10584807f, 0.01267356f, 0.00018885f, 0.00900687f, 0.29083499f, -0.19130786f, 0.06919517f, -0.01838942f, 
    0.16780072f, 0.07372413f, -0.05970617f, 0.36005706f, 0.30694491f, -0.05439069f, 0.22612746f, 0.34390220f, 
    0.16450837f, 0.00444258f, -0.06665894f, -0.04713659f, -0.14952308f, 0.26324338f, 0.06934284f, -0.05477195f, 
    0.04221162f, 0.31181175f, -0.21429981f, 0.09576153f, 0.05009882f, 0.09229066f, -0.27304772f, 0.01318685f, 
    0.14904341f, -0.02126144f, 0.02947279f, -0.22613317f, -0.10077091f, -0.04288022f, -0.01780236f, 0.00664112f, 
    0.02899664f, 0.08255950f, 0.30437937f, -0.25610951f, -0.06110922f, 0.18454164f, -0.08763121f, -0.22829993f, 
    0.12183100f, -0.07664124f, -0.08289819f, -0.00294768f, -0.21457060f, 0.01634438f, -0.19115834f, 0.27701566f, 
    0.02814349f, 0.05540601f, -0.13906704f, 0.22056530f, 0.04445565f, 0.23973337f, -0.23917176f, 0.06487548f, 
    0.08210405f, 0.00666701f, 0.25940210f, 0.10515724f, 0.05526745f, 0.28725243f, -0.13140236f, 0.14391124f, 
    0.23102017f, -0.04861637f, 0.04681056f, -0.12802866f, 0.11988628f, -0.00891624f, 0.01034069f, 0.29855117f, 
    -0.20231274f, 0.21662182f, 0.04333657f, -0.23311034f, -0.11025997f, -0.12591599f, 0.05890525f, 0.06624751f, 
    -0.04301023f, -0.16618015f, 0.17768568f, -0.30805996f, -0.03847793f, 0.02873158f, -0.12288658f, 0.38722339f, 
    -0.15357792f, -0.05630050f, 0.27390200f, 0.34176952f, -0.00533495f, 0.09775734f, -0.02506838f, 0.08821226f, 
    -0.05702220f, -0.13042295f, -0.07880101f, -0.08677917f, 0.20396107f, 0.04511733f, 0.25872847f, 0.19746651f, 
    0.10829835f, 0.05593220f, -0.06914342f, 0.07230305f, -0.20555440f, -0.07889166f, 0.13360405f, -0.14635524f, 
    0.05259154f, -0.05945750f, -0.32749718f, -0.07432260f, -0.01507749f, 0.28035942f, -0.06386268f, -0.10775744f, 
    -0.04363704f, -0.00452857f, 0.10062837f, -0.08284052f, 0.29977119f, 0.22632241f, -0.08599678f, -0.09340146f, 
    0.14401539f, -0.05331401f, -0.02778750f, -0.03825269f, 0.26096439f, 0.06946030f, -0.14993125f, -0.00044922f, 
    0.46605748f, 0.21317863f, 0.00782290f, 0.14852253f, -0.03498941f, 0.18052517f, -0.01500195f, -0.20454001f, 
    0.08359335f, 0.40100959f, -0.16665913f, -0.09224903f, 0.12275361f, 0.13810460f, 0.11919827f, -0.12797622f, 
    -0.07406075f, -0.06483494f, 0.25948083f, -0.01093813f, 0.03026083f, 0.07542227f, 0.08587749f, 0.37119713f, 
    0.01000935f, 0.00839320f, 0.13396384f, -0.07181548f, -0.22163731f, 0.34609321f, -0.18656281f, -0.18680751f, 
    -0.11699375f, -0.17171268f, -0.09994470f, -0.02296547f, 0.19384582f, 0.11239081f, -0.03384573f, -0.25802207f, 
    0.06966949f, 0.01865647f, 0.16004375f, 0.11722336f, 0.05274951f, -0.18717949f, 0.29922029f, 0.14362514f, 
    0.19202293f, 0.11194650f, 0.23852573f, 0.07859546f, -0.20471154f, -0.14705825f, 0.06046465f, -0.07449691f, 
    0.02114188f, -0.02759253f, -0.09003915f, 0.05430336f, -0.42958111f, -0.06561816f, 0.03242970f, -0.11259218f, 
    0.22203906f, 0.21969409f, 0.08561017f, -0.16823265f, 0.10086711f, 0.07320009f, -0.00529927f, -0.06573794f, 
    -0.05645765f, -0.00385432f, -0.15241329f, 0.08492915f, 0.07337941f, 0.24444635f, 0.32552558f, -0.07283127f, 
    -0.23121791f, -0.00327709f, 0.11391603f, -0.25726801f, -0.11026897f, 0.05891131f, 0.02716781f, 0.00255189f, 
    -0.04075796f, -0.01796262f, 0.18578021f, 0.47842148f, -0.17909205f, 0.34997633f, -0.07995591f, 0.20696789f, 
    -0.02377523f, -0.15374239f, 0.21466532f, -0.01712519f, -0.20783265f, 0.07249243f, 0.20427428f, -0.16081284f, 
    0.16718222f, -0.11140864f, 0.02002583f, 0.02771033f, -0.00670020f, 0.33460456f, 0.21870854f, -0.12274704f, 
    -0.00891285f, -0.02959245f, -0.13870041f, -0.01334986f, -0.08484958f, -0.01258621f, -0.08964650f, -0.00914942f, 
    -0.11653637f, -0.11522888f, -0.00643352f, -0.09007106f, -0.10227609f, -0.10087775f, 0.00510982f, -0.04468611f, 
    -0.05316922f, -0.11209083f, -0.03887640f, -0.02619863f, -0.01514196f, -0.00040108f, -0.08778885f, -0.10492620f, 
    -0.10255881f, -0.03483406f, -0.05178415f, 0.08380878f, 0.00493761f, 0.03207443f, -0.01217853f, 0.03530322f, 
    0.08065523f, -0.01764300f, -0.08360503f, -0.07425986f, 0.10730422f, -0.05556057f, -0.00567932f, 0.02593147f, 
    0.05933654f, -0.11226918f, -0.07469020f, -0.01503287f, -0.01193541f, 0.04822285f, -0.06435496f, -0.08572522f, 
    0.02790430f, -0.06226958f, -0.04126166f, -0.04801624f, 0.02782738f, 0.07933402f, -0.07368804f, -0.08953624f, 
    -0.14784500f, -0.05493116f, -0.00096324f, 0.06974304f, -0.06399006f, -0.03165194f, -0.01468975f, -0.07112814f, 
    -0.15126067f, 0.06363826f, 0.19513828f, -0.04518009f, 0.27569455f, 0.31184888f, 0.07786963f, 0.05221285f, 
    0.04923077f, -0.08260927f, 0.01508026f, 0.05707897f, -0.11546407f, -0.10194290f, 0.01632630f, -0.04052573f, 
    0.06466148f, -0.02310998f, -0.09095915f, 0.22095118f, 0.08454178f, 0.23706785f, -0.10607034f, -0.11005658f, 
    0.03339194f, -0.03246730f, 0.12131882f, 0.11489544f, 0.03406141f, -0.01962959f, 0.11578245f, -0.08588234f, 
    0.01649814f, -0.01824570f, 0.12949188f, 0.03504050f, 0.07626587f, 0.10540062f, -0.06879678f, 0.23812817f, 
    -0.10167996f, 0.12516890f, 0.14480831f, 0.15092260f, 0.07779667f, 0.27333224f, -0.17285559f, -0.04538106f, 
    0.08103410f, -0.06860484f, -0.09652048f, 0.04446425f, -0.07785935f, -0.07804362f, 0.22950436f, 0.09033762f, 
    0.02146520f, -0.04089224f, -0.42577967f, 0.02138981f, -0.02084605f, 0.10881434f, 0.32986563f, -0.17705879f, 
    0.05636950f, -0.09238284f, 0.24261440f, -0.07185528f, 0.13947339f, 0.26560768f, -0.08911205f, -0.08701114f, 
    0.17825446f, 0.03905544f, -0.04431855f, 0.12445211f, 0.40126008f, 0.01849596f, 0.01774464f, 0.21033053f, 
    0.20542794f, 0.29907212f, 0.00825243f, -0.08916819f, -0.30505624f, -0.16092305f, 0.13855995f, 0.11196533f, 
    0.11867131f, 0.03049600f, 0.24107067f, -0.37815851f, 0.18813705f, 0.00561361f, -0.08944467f, 0.05914722f, 
    -0.29513472f, 0.03890295f, 0.22740386f, -0.02442699f, -0.08428326f, 0.09268774f, 0.02429575f, 0.16313778f, 
    -0.04147044f, 0.01252214f, -0.01873798f, -0.28194642f, 0.26991215f, 0.21133848f, 0.23553354f, -0.01581790f, 
    -0.01557166f, 0.10766275f, -0.12694561f, -0.10385901f, -0.24809009f, -0.06141699f, 0.15493320f, -0.06408243f, 
    0.10478539f, 0.09690368f, -0.24666135f, 0.07484006f, -0.10450067f, 0.35973045f, 0.01920082f, -0.06131085f, 
    -0.09590708f, 0.05843250f, -0.19664347f, -0.04682283f, 0.04768406f, 0.34095463f, 0.08281268f, -0.04635228f, 
    0.16813667f, -0.10263743f, 0.01591908f, -0.38406587f, 0.24777606f, -0.05148111f, 0.12745568f, -0.16506362f, 
    -0.05751758f, 0.14020805f, -0.08294365f, 0.31335202f, 0.04162950f, 0.13910112f, -0.03830181f, -0.08068419f, 
    0.01000686f, 0.23245418f, 0.05488798f, 0.14678130f, 0.01569865f, -0.01348040f, -0.00380081f, 0.16626638f, 
    0.10326003f, -0.05055968f, 0.02005701f, 0.26454490f, -0.07520486f, 0.03395475f, 0.08265784f, 0.01416263f, 
    -0.09931344f, 0.10689031f, -0.36562157f, -0.05569340f, -0.42067757f, -0.23831727f, -0.09280297f, 0.18745141f, 
    0.08807249f, 0.24991685f, -0.14368771f, -0.04310606f, 0.28414279f, 0.08392768f, 0.16895148f, -0.01542311f, 
    -0.00633290f, -0.10591062f, 0.22984672f, 0.03832870f, -0.08248626f, -0.38523620f, -0.11888959f, 0.31498173f, 
    -0.26581901f, -0.04316329f, 0.11221918f, -0.14258605f, 0.03206094f, 0.25029042f, -0.02209353f, 0.06790737f, 
    0.05848272f, 0.11657264f, -0.08148155f, -0.37046263f, -0.21214104f, -0.06800441f, 0.12348037f, -0.03225102f, 
    0.23052827f, -0.03925996f, 0.02739399f, 0.43993029f, -0.04536186f, -0.21103853f, 0.08532144f, -0.04397675f, 
    -0.07954712f, -0.27026236f, 0.17262805f, 0.59280926f, -0.22417678f, -0.21903025f, -0.02214646f, 0.27188638f, 
    0.35909295f, 0.00123952f, 0.20391843f, -0.34595335f, -0.10122824f, -0.09025352f, -0.02462338f, 0.17380571f, 
    -0.02664220f, -0.08157742f, -0.28540692f, 0.02248376f, -0.24101210f, -0.11398773f, -0.23152190f, 0.07479902f, 
    -0.04177227f, 0.28112459f, -0.03666634f, 0.03699807f, -0.25648832f, 0.02303203f, 0.15950227f, 0.25917965f, 
    0.24900444f, 0.02931708f, -0.00611598f, 0.25253999f, 0.01176624f, 0.09578764f, 0.13469031f, 0.20830694f, 
    -0.03445959f, 0.00710357f, 0.04444099f, 0.08383109f, -0.06543466f, -0.11456023f, 0.03445516f, -0.11389776f, 
    -0.04954344f, -0.03254966f, 0.03332437f, -0.01936886f, -0.04197704f, 0.04205321f, -0.14339954f, 0.06136966f, 
    0.00880555f, 0.02124727f, 0.05602498f, 0.00057681f, 0.08477709f, 0.03441313f, -0.04904069f, -0.15565322f, 
    0.05926564f, -0.05974526f, -0.00606389f, -0.14294693f, -0.14503424f, 0.00816719f, -0.06166419f, -0.09135582f, 
    0.08756553f, -0.11722594f, -0.09481032f, -0.09139709f, -0.10834040f, -0.12438980f, 0.01136693f, -0.15068105f, 
    -0.05528703f, 0.08466402f, 0.06308742f, 0.07144775f, -0.03990335f, -0.11683329f, 0.05448957f, 0.02493356f, 
    0.01923310f, -0.09381863f, 0.04253207f, -0.01511983f, -0.06183068f, 0.10748665f, -0.05860436f, -0.01722200f, 
    -0.15091932f, 0.03025693f, -0.07097530f, -0.12395784f, -0.07579461f, 0.01043281f, 0.04922106f, -0.08259781f, 
    0.16215746f, -0.09009507f, -0.21625508f, 0.07650392f, 0.17167644f, 0.16905190f, -0.10331785f, 0.00109078f, 
    -0.11372987f, 0.00349350f, 0.08095650f, 0.17750165f, 0.22190087f, -0.09650598f, -0.08177581f, 0.08434360f, 
    0.04082402f, -0.13801375f, 0.02051586f, 0.12115683f, 0.07114094f, 0.04179738f, 0.00820871f, 0.03618200f, 
    0.01081239f, -0.00671888f, -0.03096461f, -0.27658799f, 0.12135770f, 0.02755275f, -0.04360842f, -0.11742631f, 
    0.01336239f, -0.04805648f, -0.20080684f, 0.35958937f, 0.07549814f, 0.05595309f, 0.09097874f, 0.03750364f, 
    -0.11698809f, 0.02545145f, 0.01387702f, -0.25263637f, 0.24989396f, -0.01655336f, 0.06064485f, -0.18889949f, 
    -0.03484395f, -0.08352752f, -0.00236031f, 0.01645245f, 0.27168193f, 0.00382162f, -0.22152023f, -0.02600824f, 
    -0.31692383f, -0.05016361f, 0.07243624f, -0.05049665f, 0.02650005f, -0.34511244f, 0.10262500f, 0.03452091f, 
    0.03683687f, -0.00468382f, 0.09787006f, -0.13395327f, 0.00797195f, 0.16935314f, 0.03692457f, 0.16603626f, 
    0.25910202f, 0.09532304f, 0.06134132f, -0.22541504f, 0.05223626f, 0.08565010f, 0.08585384f, -0.09028961f, 
    -0.36986473f, -0.19531113f, 0.03745303f, -0.09743639f, 0.03776782f, -0.03018027f, -0.03115987f, 0.09114130f, 
    0.13003865f, 0.36126715f, 0.40518335f, -0.28896561f, -0.06263763f, -0.01039269f, -0.23473272f, 0.29040623f, 
    0.09790205f, -0.04049941f, 0.01838051f, -0.15353653f, 0.06156006f, -0.11636787f, 0.06685286f, -0.30412403f, 
    0.07288795f, -0.13840038f, 0.06371744f, 0.15315321f, 0.31096196f, 0.19291814f, 0.05823150f, 0.09103727f, 
    -0.03191693f, 0.08972806f, -0.02709865f, -0.00093506f, 0.15277728f, 0.12074991f, 0.12668268f, 0.40831906f, 
    -0.03081809f, -0.11555336f, 0.06853058f, 0.21716492f, 0.09242016f, 0.13502102f, -0.05018740f, 0.20943156f, 
    0.15251093f, 0.02944617f, -0.11519749f, 0.07249324f, -0.21901040f, -0.25984508f, 0.06593173f, -0.08184498f, 
    -0.18599357f, 0.04591972f, -0.03838350f, 0.17742319f, 0.16559500f, 0.02957475f, 0.04163842f, 0.19499935f, 
    0.01493927f, -0.27441922f, 0.02048062f, 0.11620063f, 0.08027391f, 0.26850560f, -0.04933387f, 0.18493032f, 
    -0.07318572f, 0.29964158f, -0.03703311f, -0.40409875f, 0.19939393f, 0.13507558f, -0.18968202f, 0.00354809f, 
    -0.11427654f, -0.04027195f, -0.04290649f, -0.16985501f, -0.12204055f, 0.03709809f, -0.10540156f, -0.15256207f, 
    -0.05541157f, 0.03036281f, 0.10096445f, 0.20216465f, 0.49206632f, 0.11122849f, 0.21463543f, 0.20842730f, 
    -0.05583153f, 0.14446336f, 0.19077677f, -0.13087842f, 0.12465551f, 0.02405403f, 0.06270383f, -0.05559740f, 
    -0.07791839f, -0.09374739f, -0.17055133f, -0.21804045f, -0.00679071f, -0.18218862f, -0.29334530f, 0.17601423f, 
    -0.03665252f, 0.05789596f, -0.11806596f, -0.08328501f, 0.10372282f, 0.04696493f, 0.00140814f, 0.12113433f, 
    0.00250711f, -0.07526062f, -0.04569781f, 0.08171020f, -0.08259790f, 0.10279522f, -0.12526289f, 0.09270851f, 
    -0.06245877f, 0.00544761f, -0.07624017f, 0.06811512f, -0.11841674f, 0.09166687f, -0.01106839f, -0.17400032f, 
    0.04937778f, 0.01512528f, 0.01030829f, 0.07769200f, 0.01294709f, 0.04149242f, -0.05398731f, -0.13474832f, 
    0.03525656f, 0.01599567f, -0.06126544f, 0.03883480f, -0.06161606f, -0.00406854f, -0.01405154f, -0.11274555f, 
    0.02089898f, -0.04538105f, -0.07498273f, 0.03492815f, -0.10691906f, 0.02172462f, 0.03685087f, -0.15668695f, 
    -0.09644020f, -0.08106111f, -0.00263419f, -0.10742115f, 0.04010998f, -0.06905650f, -0.02550157f, -0.07740644f, 
    -0.13579486f, 0.04275335f, 0.01912304f, 0.00069022f, -0.04148959f, -0.09750796f, 0.00732555f, -0.01100715f, 
    0.02169979f, 0.10653841f, -0.17789273f, 0.11345002f, -0.03334897f, 0.10199312f, 0.12290715f, -0.02698875f, 
    -0.13016813f, 0.08131481f, 0.04949187f, -0.20009562f, -0.03788993f, -0.09430320f, 0.13116547f, -0.32971027f, 
    0.33564681f, 0.08228884f, -0.09574212f, 0.33029538f, -0.02024749f, 0.01306181f, 0.06346629f, -0.05917034f, 
    0.01476768f, 0.02277754f, -0.11700465f, 0.28401297f, 0.02732316f, 0.15252411f, 0.02344748f, 0.20443593f, 
    0.16256981f, -0.04085833f, -0.09860489f, -0.07102523f, -0.06608378f, 0.11648994f, -0.01789368f, -0.22466283f, 
    0.06896676f, 0.26902810f, -0.02896360f, 0.16825598f, -0.46164703f, -0.26480448f, -0.30715200f, 0.12662625f, 
    -0.01891898f, 0.19166349f, -0.13703927f, 0.02190421f, 0.15521571f, -0.04169290f, 0.27321202f, -0.15314066f, 
    0.26119360f, -0.10964369f, 0.14473677f, 0.12436966f, 0.10629830f, 0.00748416f, -0.21612999f, 0.11989494f, 
    0.20779774f, 0.07977329f, 0.10858447f, 0.04754985f, 0.05032931f, -0.05746822f, -0.03908156f, -0.03046877f, 
    0.18041645f, 0.04206761f, -0.00949254f, -0.28657529f, -0.16269538f, 0.01636090f, -0.08599491f, -0.32402468f, 
    0.25133881f, 0.14264520f, -0.03678118f, 0.04820213f, 0.02331950f, 0.07383394f, -0.08160036f, 0.14128862f, 
    0.02024723f, 0.07375402f, -0.18868130f, 0.69977570f, -0.08911803f, 0.03564738f, 0.08596319f, -0.06326862f, 
    0.21166170f, 0.06189926f, 0.21601442f, -0.12523416f, 0.10704474f, -0.11727473f, -0.01972073f, 0.13009894f, 
    0.02081013f, -0.10315806f, -0.21621113f, 0.28492224f, -0.35416576f, 0.07139583f, -0.18403433f, 0.03002764f, 
    -0.08969814f, 0.13778538f, 0.03025480f, 0.01138822f, -0.01924557f, -0.00910941f, 0.06120595f, 0.08266506f, 
    0.07019467f, -0.07969125f, 0.48011091f, 0.15117033f, -0.03674929f, 0.04295875f, 0.17474680f, 0.22300529f, 
    -0.00171207f, 0.04367842f, 0.15225229f, -0.09134941f, -0.05325799f, 0.20972407f, -0.06238725f, 0.01410394f, 
    0.14623907f, 0.02304607f, 0.08720380f, 0.06837127f, -0.04015962f, -0.11764390f, 0.19891126f, 0.17758542f, 
    0.41628331f, 0.24774505f, -0.10347156f, 0.20237130f, -0.27811542f, -0.01413757f, 0.07294898f, -0.10252194f, 
    0.04081253f, 0.17286067f, 0.01705549f, 0.04844365f, 0.09492981f, -0.11994398f, 0.20750012f, -0.23436239f, 
    -0.15475267f, -0.10567929f, 0.20413668f, -0.18431115f, -0.09223387f, -0.07271830f, -0.04196714f, 0.19766101f, 
    -0.11368407f, 0.17092054f, -0.14189997f, -0.11850322f, -0.13674183f, 0.20639881f, 0.21140043f, -0.12476446f, 
    0.08573265f, 0.10508252f, 0.01394198f, 0.10311780f, 0.01028983f, 0.07834326f, -0.04776752f, 0.17121412f, 
    0.18329442f, -0.06884489f, -0.04499994f, 0.20043644f, 0.04411009f, 0.20191412f, 0.00199521f, -0.01859009f, 
    0.18841605f, 0.08392207f, -0.11888379f, 0.19356646f, 0.09763791f, 0.06929602f, 0.07272311f, 0.09416203f, 
    -0.12290288f, 0.12839939f, -0.07996050f, 0.22993454f, 0.32316297f, -0.01429513f, 0.02477090f, 0.16462426f, 
    0.04196411f, -0.04780359f, -0.07563303f, 0.08396357f, -0.07311478f, -0.01652533f, -0.04129027f, -0.02364932f, 
    0.04185970f, -0.14363500f, 0.13508242f, -0.29212984f, 0.22708659f, -0.08780780f, 0.16398355f, -0.23599182f, 
    -0.23384660f, -0.04016423f, -0.19414325f, 0.39602852f, 0.04496945f, 0.02208179f, -0.00791536f, 0.07431848f, 
    0.07036544f, 0.23460284f, -0.13703854f, -0.25656307f, 0.39955997f, -0.00960194f, 0.54788673f, -0.01949966f, 
    0.11588936f, 0.06484538f, 0.25529683f, -0.07563999f, 0.23078406f, -0.01739234f, 0.03023254f, -0.38548183f, 
    -0.34493378f, -0.01727641f, -0.26174381f, -0.36416411f, 0.08464190f, -0.33615181f, 0.03204233f, -0.10421882f, 
    0.16716574f, 0.06155117f, 0.03063986f, -0.05043282f, 0.27681053f, 0.01753815f, -0.04802450f, -0.10447738f, 
    0.21781626f, -0.11116159f, -0.02510843f, -0.00431783f, 0.15367195f, 0.08948520f, 0.00083195f, 0.06173776f, 
    0.23703332f, -0.07013449f, -0.05938716f, 0.33121273f, 0.06264640f, 0.32878879f, -0.09494053f, 0.13965027f, 
    -0.10219900f, 0.35783213f, -0.17842120f, 0.21341950f, 0.02756453f, -0.02223071f, 0.15764615f, -0.22442503f, 
    0.12084068f, -0.06427726f, 0.16539611f, 0.15931559f, 0.03397765f, -0.08940038f, 0.03758456f, 0.53178835f, 
    -0.04211849f, 0.08114367f, 0.00949600f, -0.10676719f, -0.17084761f, 0.13868213f, -0.15624754f, -0.20909515f, 
    -0.02536765f, -0.15578467f, 0.06485375f, 0.09486060f, 0.15243566f, 0.01334375f, -0.20903508f, -0.12333835f, 
    -0.23718755f, 0.04397319f, 0.09941221f, 0.13392121f, -0.07154660f, -0.50983357f, 0.17084368f, 0.01283226f, 
    0.22903077f, -0.07692859f, -0.02726507f, 0.18136112f, 0.40624428f, -0.18193883f, -0.09510723f, -0.08298759f, 
    0.01098910f, 0.11305834f, -0.07232187f, 0.08503418f, -0.15694681f, -0.07990149f, 0.02152994f, -0.14624226f, 
    -0.05863978f, -0.02164714f, 0.05816019f, -0.22686562f, 0.31511232f, 0.36346555f, -0.01930493f, 0.03467584f, 
    -0.09916849f, -0.25787914f, -0.29292968f, 0.39968008f, -0.09793213f, 0.28123620f, 0.26899159f, -0.21489123f, 
    0.14111611f, -0.04312896f, -0.09535268f, 0.13068978f, -0.06100986f, -0.02146278f, -0.06380083f, -0.20331959f, 
    0.07709746f, 0.20966941f, 0.07876100f, 0.05989835f, -0.41755849f, -0.17516600f, -0.23782851f, -0.07567869f, 
    -0.08158226f, -0.12945767f, 0.00691744f, 0.08488049f, 0.19688563f, 0.05024023f, -0.22856273f, 0.18738155f, 
    0.09477939f, -0.12153259f, 0.10793548f, 0.18274255f, 0.03191495f, 0.11373790f, 0.20919536f, 0.12771304f, 
    0.12897998f, -0.01157834f, 0.16418132f, 0.27196327f, 0.44700614f, -0.13499095f, 0.08795663f, 0.09005044f, 
    -0.08410526f, -0.05043160f, 0.01135291f, 0.24124368f, -0.08889379f, 0.00191691f, -0.06140973f, 0.16707386f, 
    -0.14393045f, 0.15928935f, -0.04840680f, -0.07059483f, 0.11185759f, -0.03267492f, -0.03993473f, -0.08369585f, 
    0.02592945f, -0.52236420f, 0.06965949f, 0.20567277f, 0.01769154f, 0.20736906f, 0.19514057f, -0.14164577f, 
    -0.02510830f, -0.04263016f, -0.22646292f, 0.19099447f, 0.11905577f, 0.01594407f, 0.04783490f, -0.09419554f, 
    -0.01981948f, 0.04867550f, 0.35782495f, -0.04518450f, 0.08024407f, 0.06219983f, -0.02569099f, 0.10854226f, 
    -0.08475753f, 0.11252915f, -0.10472143f, 0.02008536f, -0.09207898f, 0.08296674f, -0.09936599f, -0.04457659f, 
    0.07099617f, -0.07113029f, -0.10866033f, -0.08533119f, -0.10589541f, 0.46043497f, 0.14247727f, 0.02476574f, 
    0.22182927f, -0.08772866f, 0.03848086f, -0.04394710f, -0.43753481f, -0.20890217f, -0.07616064f, -0.01325705f, 
    -0.28915840f, 0.04957403f, -0.11911011f, 0.34532055f, 0.03307828f, -0.02757319f, 0.01710885f, 0.20426595f, 
    0.35309759f, 0.05606557f, -0.01537794f, 0.15191507f, 0.17371258f, 0.18259177f, 0.04170157f, 0.11342857f, 
    0.10521287f, 0.25727844f, -0.35328513f, -0.11479158f, 0.11012949f, -0.07800331f, -0.02327855f, 0.11872084f, 
    0.13151619f, -0.08167300f, -0.03357828f, -0.17700236f, 0.03233960f, -0.11810435f, -0.09085644f, 0.09462009f, 
    -0.06201330f, 0.22584718f, -0.04652634f, 0.20935112f, -0.06622819f, -0.06209572f, -0.17045933f, 0.23295934f, 
    0.07925869f, 0.13835455f, 0.08564387f, 0.10382517f, 0.01729113f, -0.02122788f, 0.28975996f, -0.39245847f, 
    0.18725760f, 0.01501741f, -0.11593007f, -0.25698876f, 0.08540416f, -0.17628884f, -0.35894960f, 0.07322214f, 
    -0.18355693f, 0.11658838f, -0.17556091f, 0.13580067f, 0.35981897f, 0.22359873f, 0.09434522f, -0.03777677f, 
    -0.13643171f, -0.04058038f, 0.02537128f, -0.04366633f, 0.25514069f, -0.03709174f, 0.27187860f, -0.24690673f, 
    0.10067301f, -0.07014722f, -0.01044387f, 0.32755437f, -0.00425721f, -0.23065309f, 0.09023634f, -0.02918446f, 
    -0.07728773f, -0.39844832f, 0.13854761f, 0.08424482f, 0.19021085f, -0.13702695f, -0.10464287f, -0.06671797f, 
    0.10341759f, 0.11790694f, -0.07577343f, 0.13578950f, 0.11031481f, 0.03590111f, 0.10653396f, -0.20125574f, 
    -0.11565941f, 0.28773320f, -0.10447461f, -0.16356879f, -0.20889522f, -0.06599835f, 0.13807552f, 0.13002776f, 
    0.08006822f, 0.27182117f, -0.10924818f, 0.11439267f, 0.16224468f, 0.00353126f, 0.17110400f, 0.09419872f, 
    0.07030337f, -0.03295041f, -0.09688990f, 0.03703592f, -0.06438240f, 0.31013536f, 0.25563923f, 0.13674372f, 
    0.08734464f, 0.10416314f, 0.06397326f, -0.06472579f, 0.01017484f, 0.06033999f, -0.07465813f, -0.04499531f, 
    -0.03481868f, -0.06713717f, 0.09566540f, -0.08735263f, -0.07975477f, 0.07135912f, -0.00057008f, -0.07587609f, 
    -0.07380863f, 0.02171373f, 0.03961706f, 0.03829702f, 0.06400721f, 0.00273144f, 0.05426845f, 0.04639585f, 
    0.08388519f, -0.02179108f, 0.00397248f, 0.04449033f, -0.13451828f, 0.03371375f, -0.02757876f, -0.14869505f, 
    -0.03400540f, -0.09014143f, -0.07928661f, 0.07783654f, 0.10992598f, 0.07594015f, -0.02310318f, -0.01236397f, 
    -0.01785911f, -0.09385346f, -0.02494091f, 0.08534346f, -0.06231642f, 0.08742014f, -0.01730752f, 0.05117074f, 
    -0.12799183f, -0.15362206f, -0.11934486f, 0.10631847f, -0.04758279f, -0.06577685f, -0.09952757f, 0.01675839f, 
    0.00069841f, -0.04803537f, -0.05478153f, -0.06091142f, -0.00797331f, 0.03447789f, -0.06766241f, 0.10438534f, 
    -0.14490077f, -0.02127524f, 0.19727132f, -0.20973980f, 0.05326711f, 0.26962844f, 0.11617130f, -0.06665151f, 
    0.10936718f, -0.00781587f, 0.11384097f, 0.06642661f, -0.05539794f, -0.05620953f, 0.14715530f, 0.17044757f, 
    -0.17214969f, 0.06687777f, -0.06675494f, 0.30895036f, 0.22692740f, 0.28589875f, -0.10524487f, -0.12746078f, 
    0.01979861f, 0.09842858f, 0.08889363f, 0.36620834f, -0.07975374f, -0.23145981f, -0.01896328f, 0.19932814f, 
    0.31017032f, -0.03642679f, 0.22587733f, 0.15537208f, -0.07057828f, -0.02832629f, -0.07498358f, 0.37576199f, 
    0.09127940f, 0.07325151f, 0.05403181f, 0.02997250f, 0.12023211f, -0.04624561f, -0.17922698f, -0.09860265f, 
    0.06707871f, 0.18577461f, -0.03834707f, -0.05100735f, -0.07659003f, -0.04382583f, 0.07912190f, 0.06938638f, 
    0.15144561f, -0.09557046f, -0.36906156f, 0.19594309f, 0.02404006f, -0.26134524f, -0.17598084f, 0.03507109f, 
    -0.13648932f, 0.01812721f, -0.11419503f, -0.06329674f, 0.02108892f, 0.00936328f, 0.06709115f, -0.01272417f, 
    0.08155376f, 0.08873446f, 0.03107814f, -0.11822226f, 0.02796866f, 0.06065795f, -0.11651318f, -0.00663990f, 
    -0.12109253f, -0.13052367f, -0.09140542f, -0.10475343f, -0.00523109f, 0.11763976f, -0.11404771f, -0.00104648f, 
    0.03737886f, 0.10864738f, -0.05174114f, -0.02170008f, -0.11015059f, -0.06805906f, -0.01269755f, 0.02578811f, 
    0.01124095f, 0.09433235f, -0.01098312f, -0.10904340f, -0.11905918f, 0.10371213f, 0.12176970f, 0.05072802f, 
    0.00312698f, -0.08202999f, 0.07012850f, 0.04477530f, 0.02602788f, 0.05399030f, -0.02224728f, -0.08446897f, 
    -0.09450312f, -0.02341963f, -0.09445422f, 0.06400530f, -0.08044096f, 0.10813875f, -0.04144106f, 0.02391616f, 
    -0.07450551f, -0.07186724f, 0.03305868f, -0.04488372f, 0.02934305f, -0.10707983f, 0.05359825f, -0.02077830f, 
    -0.00585850f, 0.02290288f, -0.06151580f, -0.10485540f, -0.10151003f, 0.01731212f, -0.13287190f, -0.01728093f, 
    -0.00833779f, 0.03723177f, 0.07262551f, 0.04640698f, 0.07648442f, 0.02895547f, 0.03127895f, -0.01673670f, 
    -0.01957059f, -0.05066949f, -0.02756014f, 0.09978162f, -0.12076268f, 0.08892901f, -0.12317295f, 0.02816411f, 
    0.10880283f, 0.03404591f, 0.11776073f, -0.11331180f, -0.13025905f, -0.01948879f, 0.03242346f, -0.09308665f, 
    0.01191633f, 0.00641837f, -0.09391019f, -0.09475218f, 0.02602161f, -0.04836058f, 0.09880523f, -0.11848781f, 
    -0.07509202f, 0.08172223f, 0.04783854f, -0.04247012f, 0.03148048f, -0.00363787f, -0.04592841f, -0.02849617f, 
    -0.10866942f, -0.13490114f, 0.05937746f, -0.06004662f, -0.05347439f, -0.01182922f, 0.04941218f, -0.09532335f, 
    0.04340371f, 0.05338965f, 0.04120975f, -0.04925987f, 0.03045107f, -0.11233058f, 0.00350048f, -0.13910238f, 
    0.15516619f, 0.07352625f, 0.09113161f, 0.06991705f, -0.10207720f, 0.25406522f, 0.05986197f, -0.00477116f, 
    0.12048711f, -0.03171857f, -0.00346492f, -0.13554303f, 0.14914367f, 0.08004999f, -0.19104338f, 0.01692571f, 
    0.10727959f, -0.12390749f, -0.08022160f, 0.29531318f, -0.26235655f, -0.23668903f, 0.12592277f, 0.21835244f, 
    0.00935226f, 0.22182541f, 0.32980463f, 0.08320238f, 0.16448212f, -0.10167501f, 0.18141259f, 0.10376447f, 
    -0.27340183f, 0.03491390f, -0.11039004f, 0.20027030f, 0.06536554f, -0.03277349f, -0.02564356f, 0.13891101f, 
    -0.09630861f, -0.24302152f, -0.13736536f, 0.01158005f, 0.42357311f, -0.00615485f, 0.35426983f, 0.12364214f, 
    0.02720642f, 0.15375410f, 0.14035296f, 0.04468181f, 0.05909889f, -0.10459624f, 0.23456840f, -0.03086919f, 
    -0.33249104f, -0.09029903f, 0.27657548f, -0.25474316f, 0.08715506f, -0.03854935f, 0.33680290f, 0.08182273f, 
    0.03564800f, -0.01532072f, 0.01977389f, -0.03098783f, 0.01503020f, -0.12636420f, -0.03522018f, -0.02224074f, 
    0.07133245f, -0.02183499f, -0.02126488f, 0.05163303f, 0.05372562f, 0.00405278f, -0.01700857f, -0.02986110f, 
    -0.07067336f, 0.04437019f, -0.01632678f, -0.16242054f, 0.03300160f, -0.02909689f, -0.03169083f, 0.04555409f, 
    0.10754737f, -0.13190112f, -0.02575855f, 0.02751742f, -0.00591038f, -0.00789060f, -0.03275754f, -0.13654913f, 
    -0.06812198f, -0.02701513f, -0.13259268f, -0.05033002f, -0.08374642f, 0.10029155f, -0.08196998f, 0.01479486f, 
    0.09839570f, -0.05925650f, -0.14625706f, -0.06981329f, -0.09449428f, -0.09864142f, -0.03716448f, -0.02822682f, 
    -0.08886601f, -0.07591571f, -0.16215831f, -0.06320873f, 0.03532826f, -0.08739441f, -0.16224818f, -0.08789296f, 
    0.06696113f, -0.08928365f, 0.06631402f, -0.04463669f, 0.10497814f, -0.06082262f, -0.01315665f, -0.09396074f, 
    0.24633679f, 0.07237741f, 0.25345573f, 0.17645390f, -0.17175665f, -0.05961657f, 0.02927638f, -0.12638986f, 
    -0.03515118f, -0.05282710f, 0.02447028f, 0.28919345f, -0.17207447f, 0.00983268f, -0.10948697f, 0.23937404f, 
    0.36845335f, 0.28656533f, -0.09762581f, -0.20493826f, -0.19438183f, -0.02519128f, 0.07404685f, 0.07065104f, 
    -0.09600987f, 0.10006597f, -0.16377366f, 0.19489354f, -0.02377578f, 0.03509932f, 0.30505359f, -0.32735327f, 
    -0.11610366f, 0.02172453f, 0.12191860f, -0.06155877f, -0.10647209f, -0.07821685f, -0.11463737f, 0.23350812f, 
    -0.05458947f, 0.02339719f, -0.05898773f, -0.09903190f, -0.04470780f, 0.06561220f, 0.14684972f, 0.09860539f, 
    0.07418571f, -0.10289869f, 0.31351370f, -0.11252803f, -0.18829378f, 0.05669795f, -0.05268103f, -0.04918240f, 
    0.05118646f, -0.00968182f, -0.02255099f, -0.01133758f, 0.06028301f, 0.15147048f, -0.05074004f, -0.29478005f, 
    0.05139694f, 0.05987509f, -0.07170027f, 0.25471562f, 0.13585232f, -0.51664394f, -0.09816049f, -0.03760014f, 
    -0.25628960f, 0.03876078f, -0.11062987f, 0.26341167f, -0.01811552f, 0.05073531f, -0.06018538f, 0.01710330f, 
    0.04412946f, -0.05393162f, 0.11370753f, 0.01699617f, 0.02637557f, 0.35535255f, -0.16968179f, 0.02680905f, 
    -0.09043080f, 0.09096038f, -0.24481477f, -0.15940398f, 0.07418094f, 0.07763765f, 0.19346724f, -0.22692756f, 
    -0.08623803f, -0.10938665f, -0.33620813f, -0.05062321f, -0.01661004f, -0.10414706f, 0.01954625f, 0.03393389f, 
    0.00257562f, 0.11616240f, -0.01550126f, 0.13089165f, -0.01209546f, -0.07700691f, 0.24450071f, 0.19144078f, 
    0.08497552f, 0.07561155f, 0.17290279f, 0.01429369f, 0.20930097f, 0.06842692f, -0.08888587f, -0.06827063f, 
    -0.17863266f, 0.08472142f, 0.27341726f, -0.23115070f, -0.09748378f, -0.10253373f, -0.14581828f, 0.12457764f, 
    0.05567067f, -0.01836613f, -0.11080667f, 0.08596526f, -0.05853687f, 0.08265432f, -0.12270990f, 0.09351142f, 
    -0.02322584f, 0.02376758f, -0.01870459f, -0.03423775f, -0.00930766f, -0.03029534f, -0.04591027f, 0.09561878f, 
    -0.07755516f, 0.00988443f, -0.03203578f, -0.02004868f, -0.05082893f, -0.01286985f, -0.12963009f, -0.13778219f, 
    -0.12927294f, 0.08431162f, 0.08634558f, 0.00099822f, -0.11902405f, -0.04860776f, -0.13643193f, -0.12929010f, 
    0.06032526f, -0.00295606f, -0.12918679f, -0.12816499f, 0.01916517f, -0.02152331f, -0.03620516f, 0.08902377f, 
    0.03554231f, -0.08971006f, -0.03425206f, -0.08094713f, 0.06043781f, 0.09722769f, 0.07115823f, -0.08953097f, 
    -0.09747423f, 0.02080861f, -0.00996486f, 0.05580008f, -0.13358669f, -0.06512019f, 0.07002399f, 0.03608480f, 
    -0.09085967f, -0.02701673f, -0.11801302f, 0.07452439f, 0.03177039f, -0.05549176f, -0.13474466f, -0.02850402f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.03773725f, 0.11450579f, -0.08682296f, 0.13918440f, -0.11608431f, -0.01279723f, 0.02609848f, 0.09183393f, 
    -0.09033440f, 0.10195886f, 0.10013240f, -0.11978071f, 0.07992497f, 0.05174012f, -0.03477183f, 0.00850376f, 
    -0.02910202f, 0.07799646f, -0.03554605f, -0.00529798f, 0.10485531f, -0.15099025f, 0.00863757f, -0.01267358f, 
    -0.06232291f, 0.03449855f, 0.15973319f, 0.00265061f, 0.13917655f, 0.01533969f, 0.07568056f, 0.18484525f, 
    -0.04407884f, -0.10983030f, 0.09133941f, 0.28130603f, -0.10484283f, 0.01841818f, -0.10806617f, -0.02572654f, 
    -0.06383228f, -0.08913530f, -0.06983547f, 0.03066829f, -0.04706775f, -0.00663387f, 0.08806851f, 0.16301495f, 
    0.05105770f, 0.11957385f, 0.04673493f, 0.03058461f, 0.04996804f, 0.09531758f, -0.09723165f, 0.07154064f, 
    0.09903927f, -0.02246702f, 0.06087738f, 0.13431771f, -0.15906328f, 0.11536377f, 0.08399776f, 0.07721830f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.17973164f, 0.10576843f, -0.05140995f, 0.16562755f, -0.11234909f, -0.07003792f, 0.17182569f, -0.25889224f, 
    0.16815463f, -0.31946361f, 0.21802297f, 0.06731737f, 0.09248759f, -0.43064606f, 0.03504135f, 0.01232152f, 
    0.03387826f, -0.18105385f, -0.09442270f, -0.18362017f, -0.16026781f, 0.00757391f, 0.23916788f, -0.37233049f, 
    -0.10449200f, 0.00587864f, -0.37199444f, -0.15334691f, -0.52231073f, -0.08765033f, 0.03600672f, -0.30488148f, 
    0.05629896f, 0.13330139f, -0.23490788f, 0.11128967f, 0.07797663f, -0.05710482f, 0.33886620f, -0.29700625f, 
    -0.39830300f, -0.08029020f, -0.34318024f, -0.29922411f, 0.05376499f, -0.04511014f, 0.18487857f, -0.28231880f, 
    0.01430063f, 0.11015424f, -0.49891007f, -0.13748260f, 0.25216278f, 0.26982519f, 0.16613831f, -0.10001392f, 
    -0.26108608f, 0.02273932f, 0.12031037f, -0.09430471f, -0.03104617f, 0.12904294f, -0.02419923f, 0.05464855f, 
    -0.03351914f, -0.26452029f, 0.02038508f, -0.36826625f, 0.04239915f, 0.16690861f, 0.18347318f, 0.19144516f, 
    0.11487168f, -0.17974274f, -0.03748533f, 0.21010919f, -0.24961399f, 0.22406346f, 0.09541205f, -0.03801860f, 
    0.22923647f, -0.19055507f, -0.07376103f, 0.07489831f, -0.31854984f, -0.02517029f, 0.02010437f, 0.23452067f, 
    0.00279791f, -0.10987078f, -0.31792843f, -0.07414435f, -0.00801456f, 0.18062371f, 0.13304141f, -0.13813750f, 
    0.20627002f, -0.29528034f, -0.25690481f, 0.00584973f, -0.04949344f, -0.17395075f, -0.22252639f, -0.44230813f, 
    0.28340581f, -0.02791242f, 0.01493478f, -0.30252507f, 0.19132832f, 0.06595746f, -0.14306822f, 0.01883872f, 
    -0.05057788f, 0.27708134f, 0.11766743f, 0.00024991f, -0.00764319f, 0.14489582f, -0.19119194f, 0.11824439f, 
    0.16916476f, -0.02011523f, -0.07311115f, 0.13131775f, 0.06019659f, 0.18756256f, 0.34399310f, 0.04497825f, 
    -0.37111279f, 0.31874183f, -0.10760409f, 0.03807908f, -0.06643605f, -0.46783322f, 0.04286436f, -0.04427768f, 
    0.24222499f, 0.02368172f, 0.04500260f, -0.15859216f, -0.20434320f, -0.07400873f, -0.18915510f, -0.11068608f, 
    -0.14065465f, 0.22228913f, -0.05068105f, 0.27445585f, -0.36979192f, -0.08791386f, 0.21228029f, -0.19855645f, 
    -0.00910305f, -0.11438338f, -0.31095597f, -0.00517502f, 0.21790427f, 0.27152517f, -0.42022628f, -0.29602313f, 
    -0.15149064f, 0.02773501f, -0.07861383f, -0.11816820f, -0.11794388f, 0.07857516f, 0.24801312f, -0.19371206f, 
    -0.46192747f, 0.00573679f, 0.07544222f, 0.15268600f, -0.03703998f, -0.08182597f, -0.37203303f, -0.48305228f, 
    0.26948038f, 0.34583980f, -0.19808508f, -0.32701701f, -0.07567313f, -0.41039404f, 0.27492228f, 0.10362302f, 
    -0.11072689f, 0.06524098f, -0.05483217f, 0.16082510f, 0.05045385f, 0.00750891f, -0.34053972f, 0.06104499f, 
    -0.19661157f, -0.06126433f, -0.00275967f, 0.06558379f, 0.05004481f, 0.07536782f, -0.23425798f, -0.44734660f, 
    -0.11940373f, -0.05064791f, 0.12483457f, 0.01436098f, 0.14865920f, -0.35788321f, 0.26944891f, 0.15739761f, 
    -0.22833592f, 0.03060569f, 0.03614969f, -0.07061614f, 0.37932590f, -0.01604574f, -0.34872615f, 0.27355635f, 
    0.03505109f, -0.08144616f, -0.04912012f, -0.54930562f, -0.12373015f, -0.13142759f, 0.01732117f, -0.03674626f, 
    0.22088313f, 0.13703068f, 0.15140709f, -0.00450581f, -0.00638772f, 0.04073231f, 0.22549057f, -0.12703513f, 
    -0.22801398f, -0.05803982f, -0.32387835f, -0.00323825f, -0.67462999f, -0.03574428f, -0.33675364f, 0.03695992f, 
    0.13701622f, -0.51140201f, 0.18247803f, 0.07651778f, 0.03373753f, -0.21994619f, -0.40946406f, -0.06745081f, 
    0.06659570f, -0.09187217f, -0.00663005f, -0.64507413f, 0.11255588f, 0.19296759f, -0.81921631f, -0.08887395f, 
    0.25173062f, 0.04336152f, 0.07738750f, -0.11013531f, 0.11270779f, 0.24602549f, 0.03658946f, -0.16087629f, 
    -0.05875948f, -0.22552246f, 0.10017917f, -0.01150795f, 0.22089946f, -0.21309571f, 0.36159351f, 0.25422522f, 
    -0.08576105f, 0.38204756f, -0.02839055f, -0.08371393f, 0.15763302f, -0.08066940f, -0.28970119f, 0.14797989f, 
    -0.08707035f, 0.08382930f, 0.07994600f, -0.00905842f, 0.08860957f, 0.08617532f, -0.20896499f, 0.06414931f, 
    -0.41438681f, 0.11172638f, -0.46997702f, -0.25307664f, -0.06337941f, -0.18366212f, -0.20357817f, 0.26166794f, 
    -0.02708735f, 0.05854198f, 0.07722726f, 0.01294573f, 0.00014989f, -0.10811429f, 0.13228656f, -0.06545499f, 
    -0.28133637f, 0.25555578f, -0.21822326f, -0.13530000f, -0.15234195f, 0.17089951f, -0.00148263f, 0.04557450f, 
    0.11854140f, -0.06574389f, -0.09820997f, -0.06681775f, 0.08035053f, -0.19704282f, -0.19138861f, -0.05743425f, 
    -0.06108495f, 0.06535958f, 0.01797012f, -0.36943391f, 0.12458162f, 0.10989279f, 0.12199162f, 0.27183896f, 
    0.07283309f, -0.00916407f, 0.03570937f, -0.80875319f, 0.02432604f, 0.13340527f, -0.10616149f, 0.06171564f, 
    0.18547624f, 0.24462841f, -0.07867101f, 0.01146929f, 0.03164441f, -0.11898267f, 0.21423583f, -0.24559650f, 
    -0.11588678f, 0.00464180f, -0.17328691f, 0.07624511f, -0.15499471f, -0.49440226f, 0.11522216f, -0.00160166f, 
    0.25441077f, -0.31584060f, -0.00616143f, 0.09205622f, 0.08281883f, -0.18367344f, -0.38127229f, 0.16284852f, 
    -0.54379284f, -0.04264906f, -0.21987455f, 0.06616750f, -0.10476401f, 0.10943063f, 0.38990739f, 0.29879877f, 
    -0.06147269f, -0.27972817f, -0.10129178f, 0.26849800f, -0.03545630f, -0.02894566f, 0.12487587f, 0.05935295f, 
    -0.36186713f, -0.04821178f, -0.03004158f, -0.19259137f, -0.04465777f, -0.07373944f, -0.00975483f, -0.06003279f, 
    -0.23858926f, -0.00964857f, -0.02760947f, 0.01435254f, 0.02625118f, -0.49001151f, -0.12001938f, 0.19008715f, 
    -0.27959830f, 0.28876778f, -0.00702660f, -0.20270973f, 0.07834744f, 0.03179409f, -0.22883868f, 0.26705837f, 
    -0.24490120f, -0.15213032f, 0.01037897f, -0.35685715f, 0.21981710f, 0.03279136f, -0.06854144f, -0.38419512f, 
    -0.07450227f, -0.10458072f, -0.02779453f, 0.18450466f, 0.24562216f, -0.21107610f, 0.04364390f, 0.24568884f, 
    -0.35480204f, 0.21835512f, -0.28899688f, 0.00944976f, -0.04595555f, -0.08087098f, 0.16589308f, -0.27141914f, 
    -0.70763481f, 0.06621286f, -0.37051836f, 0.33717626f, -0.00212541f, -0.02204647f, -0.36002803f, 0.00897764f, 
    -0.32785293f, -0.21987313f, -0.32077953f, -0.21943350f, 0.09142742f, -0.29624435f, -0.20363553f, -0.06583475f, 
    -0.30957758f, 0.10547724f, -0.08113362f, 0.34655380f, 0.09196410f, -0.12163064f, -0.20324707f, -0.02178298f, 
    -0.02531689f, -0.02893977f, 0.09864485f, 0.12973547f, -0.06426448f, 0.22116318f, -0.10854288f, 0.10195716f, 
    -0.17346187f, -0.02440520f, -0.34813029f, 0.09845958f, -0.52365083f, -0.23207261f, -0.11478928f, 0.15412384f, 
    -0.22516431f, -0.10776017f, -0.01491867f, -0.00072059f, -0.19005924f, -0.05305319f, 0.06200468f, 0.15169649f, 
    -0.00689217f, -0.02390675f, -0.00883560f, -0.17542182f, -0.22423752f, -0.01102070f, -0.42655203f, -0.27905694f, 
    0.16726658f, -0.09927614f, -0.14623956f, -0.50615627f, 0.02692781f, 0.09491442f, 0.15124661f, 0.13387977f, 
    0.24777026f, 0.03774051f, -0.01699264f, 0.24589090f, -0.17381717f, -0.00795854f, 0.15624265f, 0.04218375f, 
    0.19167419f, 0.21020323f, -0.14275038f, -0.24272300f, -0.08420970f, -0.43982187f, 0.30132020f, 0.06567062f, 
    0.21003625f, 0.00897822f, 0.02369546f, -0.11766457f, -0.13506615f, -0.41677979f, -0.08649693f, -0.07593975f, 
    0.26999670f, -0.45834890f, 0.02778708f, -0.58991796f, 0.10664718f, -0.20364769f, 0.13958152f, 0.16889381f, 
    0.24534146f, 0.33597094f, -0.16227639f, 0.02592910f, 0.12532553f, 0.21287501f, -0.40382805f, -0.41402161f, 
    0.12156396f, -0.31446990f, -0.01903841f, 0.18075751f, 0.01393025f, -0.05347923f, 0.02803433f, -0.11038775f, 
    -0.10562304f, 0.09535255f, -0.19336183f, -0.14224266f, 0.07387067f, 0.05584704f, -0.25578064f, -0.10839874f, 
    0.26866546f, -0.28837419f, 0.09900577f, -0.50945449f, 0.06222029f, -0.03560869f, -0.17260866f, 0.04004772f, 
    -0.00573431f, -0.02593545f, 0.49965715f, -0.11642751f, -0.11842220f, 0.05683002f, -0.16949260f, -0.30599013f, 
    -0.27926794f, 0.18397476f, 0.28092945f, 0.25685373f, 0.23568515f, -0.47332060f, 0.25624347f, 0.05131805f, 
    -0.05442061f, -0.10972933f, -0.06674862f, -0.22728842f, -0.03761412f, -0.38811091f, 0.10720397f, -0.10965791f, 
    0.12814699f, 0.08765431f, 0.07759082f, 0.27509195f, -0.04011878f, -0.13075955f, -0.55126071f, 0.17294316f, 
    -0.15932700f, -0.11013532f, -0.14128168f, 0.11936877f, 0.10642722f, -0.08702368f, -0.12591143f, -0.27937216f, 
    0.21204454f, -0.10063647f, -0.04322390f, -0.38042837f, -0.09990013f, 0.00516628f, -0.15336838f, -0.15789333f, 
    -0.04651006f, -0.07571048f, 0.24534117f, 0.15402690f, -0.02244964f, -0.31941852f, -0.37801892f, -0.08755001f, 
    -0.12469929f, -0.11995529f, 0.34799320f, -0.16413920f, 0.02897191f, -0.14240485f, 0.16896689f, 0.31172791f, 
    0.06601185f, -0.12216745f, 0.27896678f, -0.03283956f, -0.06072028f, 0.05675326f, 0.15939485f, 0.16637719f, 
    0.05950863f, 0.06466302f, 0.24187689f, -0.43242133f, -0.53407335f, 0.19195899f, -0.05901364f, -0.04362004f, 
    -0.10591988f, -0.05858584f, -0.09387238f, 0.23445314f, -0.09034149f, 0.00066340f, -0.21331295f, -0.06870213f, 
    -0.46410298f, 0.02755104f, 0.05380750f, -0.01569075f, 0.01262934f, -0.12047309f, 0.01789147f, -0.19418858f, 
    -0.14493732f, -0.35228032f, -0.11619204f, 0.10688305f, -0.07187722f, -0.01009854f, -0.29966339f, -0.14593761f, 
    -0.05142805f, -0.28204757f, 0.09770272f, 0.26336998f, -0.25087991f, -0.07834923f, 0.10115679f, -0.15826324f, 
    -0.01161056f, 0.09461588f, 0.14271583f, -0.27852669f, 0.15153244f, 0.37731946f, 0.04658674f, 0.07387324f, 
    -0.24735001f, -0.04905263f, 0.12979785f, 0.20655179f, 0.01154952f, 0.25444853f, -0.10547382f, 0.02634891f, 
    0.10840481f, -0.02597112f, 0.06310115f, -0.18369119f, -0.66193324f, -0.06554576f, 0.20531024f, 0.16068952f, 
    -0.00173677f, -0.09584115f, 0.16164708f, 0.05751137f, 0.08064018f, -0.15667783f, 0.00147872f, -0.10218529f, 
    0.22055045f, -0.10454751f, -0.08787715f, 0.05121320f, -0.02733606f, 0.00304408f, -0.89882284f, -0.04958063f, 
    0.13628331f, 0.13198107f, -0.09933943f, 0.19249141f, -0.01815392f, -0.10490572f, -0.30650657f, -0.50113344f, 
    -0.31187189f, 0.28288627f, 0.08379617f, 0.18521774f, 0.04677963f, 0.20975900f, -0.09643661f, -0.15681550f, 
    -0.37327033f, -0.10901447f, -0.03043518f, 0.27133584f, -0.05615247f, 0.03640362f, 0.00791515f, -0.02251220f, 
    -0.08678491f, -0.12981240f, 0.15884410f, -0.05686821f, 0.22315280f, -0.19968219f, 0.30546230f, 0.14219268f, 
    0.16745922f, -0.19834659f, -0.02971583f, 0.01394455f, -0.02785828f, 0.14480250f, -0.12621093f, -0.15120716f, 
    -0.54714608f, 0.02027323f, -0.10036840f, 0.23910511f, 0.26618540f, -0.10001995f, -0.03028667f, -0.17124569f, 
    -0.15432429f, -0.72054434f, 0.02453795f, -0.16430335f, -0.26736766f, 0.20761783f, -0.37215716f, 0.03523873f, 
    0.13908340f, -0.07085065f, -0.09443536f, -0.40975124f, 0.06950010f, -0.20755421f, -0.42922416f, 0.05186287f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.00464913f, -0.05019935f, -0.03500267f, 0.05762867f, 0.03816146f, -0.10465894f, 0.13704579f, -0.06828001f, 
    -0.00621702f, -0.09507851f, 0.11683872f, -0.03068552f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
