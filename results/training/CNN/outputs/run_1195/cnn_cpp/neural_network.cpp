#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.13032889f, -0.12270048f, 0.05773860f, 0.41391149f, 0.40164036f, -0.01078938f, -0.10985141f, 0.61239958f, 
    0.03041883f, -1.28156459f, -0.97063714f, -0.56963032f, 0.59826815f, 0.69568408f, 0.37590575f, -0.21086431f, 
    0.27058986f, -0.32988667f, -0.46439537f, -0.08237767f, 0.24538927f, -0.02111096f, -0.88337660f, -1.15839994f, 
    -0.44977322f, -0.42427364f, -0.29623231f, 0.45620823f, 1.27131224f, -0.74415892f, 0.05632676f, -0.29819250f, 
    -0.37434280f, -0.12995145f, 0.24531306f, 0.08461205f, 0.71861207f, 1.01767147f, 0.11281724f, -0.31447437f, 
    -0.58975565f, -0.06269761f, -0.38464668f, 0.55794084f, -0.19512393f, 0.21712017f, 1.03698003f, -0.20488265f, 
    0.21968548f, 0.44552919f, 0.39228889f, 0.01806023f, -0.40506840f, -0.44324049f, 0.58100909f, 0.40989602f, 
    0.77739316f, -0.10099950f, 0.38363317f, 0.32367435f, 0.41049001f, -0.42967582f, 0.27815697f, 0.29978415f, 
    -0.48621824f, -0.73894024f, -0.45513597f, -0.44698423f, -0.60719848f, 0.10722083f, 0.77705407f, 0.88788086f, 
    -0.88307315f, 0.21375832f, 1.07504821f, 0.11617468f, -0.14336975f, -0.00638184f, -0.67835957f, 0.71058768f, 
    -0.59129041f, -0.50120300f, -0.65215927f, -0.27986285f, 0.27157193f, 0.78036088f, -0.51946861f, 0.29587150f, 
    -0.59018052f, -0.71047753f, -0.59378135f, -0.32465407f, -0.90935153f, -0.44489983f, 0.31647161f, -1.04453230f, 
    0.12886445f, -0.33331361f, -0.28259203f, 0.24284747f, 0.08428157f, 0.42883211f, 0.34668881f, 0.86261624f, 
    0.25877392f, 1.09602416f, -0.60649967f, 0.19237712f, -0.47928727f, 0.25130141f, -0.06541561f, -0.14743152f, 
    -0.87855959f, -1.08057439f, 0.65133518f, 0.43365917f, -0.14501198f, 0.43450254f, -0.38616401f, 0.04072042f, 
    -0.83910519f, -0.66092587f, -0.90597302f, 0.44871321f, -0.83762968f, -0.20734024f, 0.62133437f, -0.68312687f, 
    0.70815980f, -0.30472642f, 0.07401426f, 0.02462692f, 0.19376406f, 0.43626070f, 0.64575273f, -0.20911174f, 
    0.25326663f, 0.48225170f, -0.89398134f, -0.68568414f, 0.59418571f, 0.12737204f, 0.39257866f, 0.54382110f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.79446131f, -0.30919230f, -0.46083710f, 0.38454384f, -0.18221553f, 0.70393038f, 0.53228414f, -0.22362496f, 
    0.33706510f, 0.66134459f, -0.25875428f, -0.34744874f, 0.20635970f, 0.38115305f, 0.01773796f, 0.00452141f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.12408165f, -0.35397679f, 0.18888211f, -0.00981686f, -0.00277244f, 0.33328220f, -0.03431907f, 0.18499595f, 
    0.07315509f, -0.37762266f, 0.05913927f, -0.08271649f, -0.31944755f, -0.27127364f, -0.31472766f, -0.15193337f, 
    -0.04105901f, -0.20101829f, 0.06403006f, 0.02499295f, 0.55528194f, -0.25709230f, -0.01584517f, -0.09804081f, 
    -0.10227402f, 0.13559461f, -0.19029911f, -0.22029193f, 0.25437361f, 0.09489711f, 0.18600827f, 0.14903551f, 
    0.40406767f, -0.02959237f, 0.01957175f, -0.08824952f, -0.12002458f, 0.31771827f, 0.42505884f, -0.06309570f, 
    -0.15119758f, -0.09134041f, -0.02780119f, -0.04336289f, -0.17398971f, -0.47663659f, 0.13554066f, 0.24425197f, 
    0.00817239f, 0.09594239f, -0.19866769f, -0.07578275f, 0.07819838f, 0.15764619f, -0.18071838f, 0.33523795f, 
    0.21276943f, 0.03952495f, 0.01733297f, -0.04386876f, -0.07929595f, 0.22263554f, -0.06247727f, -0.13175440f, 
    0.02124190f, 0.59269375f, -0.17812972f, 0.01756991f, -0.02141208f, 0.16253234f, 0.02527983f, -0.01805749f, 
    -0.55273110f, 0.35451525f, -0.06502167f, -0.25946510f, 0.41016582f, 0.02622312f, -0.03802830f, 0.11763011f, 
    0.11390688f, 0.22617021f, 0.29203412f, 0.28154960f, 0.07006179f, 0.06948832f, -0.37292913f, -0.01716533f, 
    0.21786427f, 0.22386645f, 0.21117933f, 0.09840957f, 0.62702858f, -0.04874233f, -0.16860785f, -0.18972805f, 
    0.10208358f, 0.04917229f, -0.10955101f, -0.27094871f, 0.07810278f, 0.24831434f, 0.08395747f, -0.08601262f, 
    -0.31906793f, -0.03244248f, 0.50880760f, -0.08129264f, -0.11878175f, 0.00221100f, 0.25627160f, -0.13504517f, 
    0.00120609f, -0.02724450f, 0.07418154f, 0.08273512f, 0.08909450f, 0.03308490f, 0.00163559f, 0.46585813f, 
    -0.47309843f, 0.04899570f, 0.01683696f, 0.01654403f, 0.04261231f, 0.07508998f, -0.11480200f, -0.04915847f, 
    -0.24756144f, -0.02198279f, 0.22941208f, -0.05725142f, 0.21802008f, -0.05108783f, 0.14962462f, -0.22139907f, 
    0.26827142f, -0.59929657f, 0.19055690f, -0.21878938f, -0.30740237f, 0.10898693f, 0.07992230f, 0.16427483f, 
    -0.08221338f, -0.22047780f, 0.26857153f, 0.01443025f, 0.03152899f, -0.29129171f, 0.21837933f, -0.05296145f, 
    0.14356534f, 0.42680454f, -0.42935565f, 0.14522950f, 0.14789632f, 0.02455967f, -0.46247956f, -0.05394863f, 
    0.06346288f, 0.07118861f, 0.33859947f, 0.28941742f, -0.07001885f, 0.18014191f, 0.14645013f, -0.04238451f, 
    -0.14366083f, 0.12758362f, -0.04212914f, -0.01876966f, 0.57779425f, -0.17276046f, -0.18240361f, 0.10559391f, 
    0.03282298f, 0.02618994f, 0.15076877f, 0.18086670f, -0.01462084f, 0.14126596f, -0.13943870f, -0.05314570f, 
    0.20974344f, 0.11903235f, 0.18765171f, -0.22621420f, -0.03072676f, -0.03609622f, 0.22729127f, 0.09754409f, 
    -0.17122060f, -0.07619561f, -0.07193197f, -0.17917566f, -0.09173169f, -0.37605059f, 0.04409745f, 0.11583993f, 
    0.21954925f, -0.14498390f, -0.01278643f, -0.12023216f, -0.15918437f, -0.02031080f, 0.20980504f, 0.44251537f, 
    -0.09597137f, -0.03365520f, -0.22784595f, 0.16389889f, -0.00022439f, 0.15846710f, -0.20139804f, 0.41450483f, 
    0.04875928f, 0.46291748f, -0.32173470f, 0.17209464f, 0.16957854f, -0.06452453f, -0.10276956f, 0.18099669f, 
    -0.16402921f, -0.27383891f, -0.37785232f, -0.14518069f, -0.03267482f, -0.19278924f, -0.16210039f, -0.11761371f, 
    0.01221238f, -0.29359818f, 0.18940553f, -0.01440891f, -0.01696278f, 0.04931606f, -0.04307384f, 0.15238039f, 
    0.08263557f, -0.09672623f, -0.07219203f, 0.14232612f, 0.22400317f, -0.02053764f, 0.03855654f, 0.06838283f, 
    0.15953630f, -0.13820632f, 0.18735246f, -0.12649718f, -0.05353805f, 0.11821602f, -0.01216536f, -0.03412610f, 
    0.20311318f, 0.00211937f, 0.09339813f, 0.00421399f, 0.01832094f, -0.04441164f, 0.16358174f, 0.03307047f, 
    -0.01361837f, -0.06521278f, -0.06843293f, -0.10027497f, -0.02129094f, -0.16448899f, -0.14529423f, 0.12913612f, 
    0.41648486f, 0.09427072f, -0.00100835f, 0.12203977f, 0.07543307f, 0.27235600f, 0.28976962f, -0.17812169f, 
    0.45216382f, 0.03305351f, 0.08066007f, -0.34859648f, 0.01373811f, 0.12037577f, 0.06361389f, 0.12121203f, 
    -0.07652838f, -0.08436005f, -0.29571843f, 0.03607346f, 0.18340202f, 0.08718374f, 0.32842529f, 0.01108160f, 
    0.29051518f, -0.43331712f, 0.21559142f, -0.11593135f, 0.06053721f, -0.19411695f, 0.19932832f, 0.06721201f, 
    0.17670734f, -0.15969677f, -0.25204596f, -0.31283632f, -0.09670468f, 0.07885307f, 0.08679349f, 0.03541117f, 
    0.10003043f, 0.10506275f, -0.13660797f, 0.29513857f, -0.17010808f, 0.18026327f, 0.13688174f, 0.27369761f, 
    0.07198543f, 0.08638323f, 0.07575691f, 0.15110603f, -0.05443855f, -0.56852573f, -0.18034962f, -0.01862412f, 
    0.24480249f, -0.13302279f, 0.02545734f, 0.01271168f, 0.09266776f, 0.23598254f, -0.29225692f, -0.30024305f, 
    -0.00650344f, 0.17030203f, 0.16289809f, -0.05385370f, -0.05151252f, -0.00564319f, -0.17658316f, -0.42398283f, 
    -0.20523255f, -0.03626990f, 0.01198030f, 0.05788902f, 0.00313770f, 0.13427238f, -0.09292942f, -0.25086176f, 
    -0.05289478f, 0.02877988f, -0.00583334f, -0.09531674f, -0.08652827f, -0.08790809f, 0.20693631f, 0.12088846f, 
    0.20002981f, -0.15788083f, 0.05529507f, 0.39668739f, -0.02279716f, 0.02403799f, 0.02375240f, -0.20647615f, 
    -0.15569907f, 0.07689621f, 0.24882297f, 0.40031523f, -0.19480394f, 0.09034943f, 0.19420108f, -0.14680761f, 
    0.01457248f, -0.07586322f, -0.61279774f, -0.11119628f, 0.35866240f, 0.08630261f, 0.00467491f, 0.17802086f, 
    -0.01098035f, 0.28926700f, 0.13119154f, -0.05643920f, -0.13946357f, -0.27822691f, -0.08149228f, 0.08896802f, 
    -0.07643156f, 0.29575813f, 0.18543880f, 0.04165290f, -0.24695371f, 0.11285416f, 0.08335494f, 0.06928412f, 
    -0.02373617f, 0.05253759f, 0.08270094f, 0.16070202f, 0.09627058f, -0.11980397f, 0.15732676f, -0.21836384f, 
    0.22200984f, 0.10429975f, 0.15925656f, 0.08035109f, 0.29521656f, -0.22297819f, -0.00776969f, -0.17173102f, 
    -0.37219062f, -0.03862631f, 0.03531851f, 0.07564519f, 0.10722618f, 0.24630125f, 0.08191910f, -0.00651674f, 
    -0.08967284f, -0.05185688f, 0.03803809f, -0.10089884f, 0.24357688f, 0.19243072f, 0.19004510f, 0.08037102f, 
    0.11667714f, 0.09090380f, -0.00105115f, -0.06623030f, 0.08149920f, 0.07505241f, 0.02673274f, 0.06114862f, 
    0.02091952f, 0.61163735f, -0.19908074f, -0.25448856f, 0.01364771f, -0.09789651f, 0.19144017f, -0.08018271f, 
    0.10912370f, 0.07679322f, 0.08076562f, 0.34333631f, -0.09114813f, -0.27621505f, -0.02630995f, -0.24630797f, 
    -0.04628864f, 0.08428123f, 0.31541762f, -0.41840550f, -0.34070894f, -0.50231743f, -0.12481598f, 0.19985475f, 
    -0.08211730f, -0.10280877f, -0.00405534f, -0.03919413f, -0.22935565f, 0.28453115f, -0.13873430f, -0.09453364f, 
    0.00563316f, -0.03563759f, 0.06016949f, -0.09399936f, 0.10459143f, 0.06275311f, -0.08029723f, 0.17873549f, 
    0.03564246f, 0.00483888f, -0.30212265f, 0.15093157f, 0.04115730f, -0.18642403f, 0.05283301f, -0.16032651f, 
    0.03651089f, 0.10881599f, -0.14688705f, -0.06875189f, 0.22758977f, -0.01018171f, -0.04282843f, 0.14895128f, 
    0.07459557f, -0.25541660f, -0.06510037f, -0.03914139f, 0.07951880f, -0.14324580f, 0.14067762f, 0.07655468f, 
    -0.23666312f, 0.25660226f, 0.12359169f, -0.31215075f, 0.04977044f, 0.20717423f, 0.17633975f, 0.11524195f, 
    0.05661909f, 0.09063093f, 0.08397688f, -0.01721725f, 0.11699490f, 0.05597772f, 0.18705125f, 0.20872369f, 
    -0.02574545f, -0.16953543f, 0.40042031f, 0.32881609f, 0.09629598f, -0.00735232f, 0.10195919f, 0.27439553f, 
    -0.00441327f, -0.26376221f, -0.02723122f, 0.00664295f, 0.30077648f, 0.40343291f, -0.29993072f, -0.50790983f, 
    -0.37284404f, 0.01049178f, 0.05235009f, 0.19128908f, 0.15594870f, 0.19116452f, -0.11381374f, -0.23848096f, 
    -0.09148289f, 0.06152148f, 0.01333162f, -0.02458050f, 0.28414714f, -0.29637030f, 0.11087941f, 0.14675860f, 
    -0.02162197f, 0.05168232f, -0.25759503f, 0.08573535f, 0.13276879f, 0.10869857f, -0.53439975f, -0.13047849f, 
    -0.03133608f, 0.00407533f, 0.36750311f, -0.03170386f, 0.06057408f, 0.06702569f, 0.08671734f, -0.71033108f, 
    -0.06926455f, 0.36174175f, -0.14694634f, -0.07154793f, -0.36645937f, 0.10433912f, 0.09941109f, -0.11292879f, 
    0.06281108f, -0.15937814f, -0.08809280f, -0.05243414f, -0.19848564f, -0.09466102f, 0.17778255f, 0.19795389f, 
    0.13734147f, 0.08421884f, -0.27430430f, 0.38833475f, -0.00501811f, 0.09199955f, 0.03888911f, 0.22350819f, 
    -0.01621238f, -0.04856807f, 0.26531741f, 0.02598433f, 0.37923163f, 0.02302819f, 0.08422676f, 0.05639238f, 
    0.30176863f, -0.03323606f, -0.17162848f, -0.26014629f, -0.05318283f, 0.31794730f, -0.06124242f, -0.06907240f, 
    -0.02549778f, 0.13831834f, 0.04820957f, -0.07373006f, -0.59990543f, -0.15175502f, -0.21949136f, 0.07406438f, 
    -0.09051863f, 0.19539984f, 0.07243730f, -0.18138649f, 0.00194745f, -0.27890244f, 0.03563292f, 0.09244398f, 
    0.16397405f, -0.01673517f, 0.13114512f, -0.11615314f, -0.13435696f, 0.15033916f, -0.12868403f, -0.19520865f, 
    -0.09576781f, 0.25268823f, 0.18637744f, -0.02057739f, 0.02918473f, 0.27657339f, 0.10684339f, 0.34429455f, 
    -0.02152640f, 0.73997563f, 0.02531548f, 0.01308517f, 0.06653731f, 0.02554861f, -0.04497000f, -0.28973764f, 
    0.47847533f, 0.17659388f, -0.22524570f, -0.09254595f, 0.14527367f, -0.24613103f, 0.16101238f, 0.22190198f, 
    0.22604193f, 0.28845784f, 0.10352803f, 0.45152834f, 0.11468595f, 0.07305772f, 0.30677018f, 0.39350730f, 
    0.18748981f, 0.15790562f, 0.23355195f, -0.24398349f, 0.27851948f, 0.17704231f, -0.20098884f, -0.13836451f, 
    0.25934118f, -0.10263805f, -0.11991831f, -0.00207190f, -0.11233855f, 0.03712753f, -0.26284364f, -0.23252761f, 
    -0.25599262f, 0.35904852f, 0.22385356f, 0.13125375f, 0.43562171f, 0.06287369f, 0.31815559f, -0.04427094f, 
    -0.09470258f, 0.09067542f, 0.06549521f, -0.36965913f, 0.20689596f, -0.19660880f, 0.07121699f, 0.21164015f, 
    0.05194310f, 0.04549985f, -0.03744281f, -0.00927917f, -0.14786343f, -0.11877383f, -0.13379107f, 0.08647648f, 
    -0.11591760f, -0.10650347f, -0.14784151f, 0.01087493f, 0.07925073f, 0.19645286f, -0.02784988f, 0.14774604f, 
    0.38344109f, -0.51387459f, -0.01540705f, -0.12406216f, -0.12301441f, 0.30643889f, -0.04530886f, -0.23815367f, 
    -0.00211117f, 0.19328117f, 0.00830771f, -0.03246750f, 0.12533683f, 0.07570745f, 0.07966635f, 0.26969919f, 
    0.02650070f, -0.33516234f, 0.36838743f, 1.11943066f, -0.12631303f, -0.11170609f, -0.23952749f, -0.03840819f, 
    0.09353618f, 0.07632200f, -0.42763072f, -0.48186439f, -0.13166672f, -0.19181089f, -0.04754483f, -0.12716293f, 
    0.01218875f, -0.06374535f, 0.25381607f, 0.52590966f, -0.33078706f, -0.22895728f, 0.08067697f, 0.09273346f, 
    0.12275181f, 0.15919657f, 0.09007639f, -0.03831873f, 0.01586228f, -0.15656948f, -0.13115649f, 0.02211696f, 
    0.15275747f, 0.08177667f, 0.00442054f, -0.19798175f, -0.14120059f, -0.03391104f, -0.05501448f, 0.07659961f, 
    -0.01001559f, 0.12129553f, 0.10781074f, 0.24061820f, 0.21084189f, 0.08785728f, 0.11136896f, -0.06391922f, 
    0.13243432f, -0.02748214f, 0.17662589f, 0.10852890f, 0.04424781f, 0.14063939f, 0.21037881f, -0.18227719f, 
    0.13478798f, -0.79017806f, -0.08032943f, -0.09979129f, 0.01111450f, -0.01506881f, -0.05842412f, -0.19439939f, 
    0.07729602f, -0.02883171f, 0.03897117f, 0.05212965f, -0.18263263f, -0.09642795f, 0.07892695f, 0.29097468f, 
    0.10274545f, -0.28914583f, -0.03089232f, 0.36224052f, 0.11297387f, 0.01458031f, 0.08938286f, 0.15074667f, 
    0.28785080f, 0.44921958f, -0.95739657f, 0.19421925f, -0.08938631f, -0.00247637f, -0.14868033f, -0.13148007f, 
    -0.17622957f, -0.16320446f, -0.25058463f, 0.11509675f, -0.13190851f, 0.12107389f, -0.29520091f, -0.21597578f, 
    -0.05937188f, 0.07665819f, -0.10165542f, 0.20400538f, 0.13155466f, -0.93679690f, -0.11196812f, -0.02752602f, 
    0.10205443f, -0.32271352f, 0.00145565f, -0.01153476f, -0.10516784f, -0.35383922f, -0.27106681f, -0.24428758f, 
    0.22294891f, 0.16441545f, -0.02445653f, 0.06047474f, -0.02096926f, 0.11660402f, 0.32708880f, -0.11894495f, 
    -0.43849906f, -0.10776257f, -0.09084693f, 0.13444005f, 0.07749021f, -0.05092773f, -0.12246542f, -0.25008458f, 
    -0.32596207f, -0.37807310f, -0.21754289f, 0.02332065f, 0.04972033f, -0.00167736f, -0.08679329f, 0.10258478f, 
    0.01505750f, 0.03070177f, 0.08806536f, 0.10085748f, 0.00006132f, 0.34142008f, -0.18146275f, -0.18366955f, 
    -0.36899194f, -0.25642145f, -0.27507532f, -0.46095175f, 0.17147419f, -0.06585850f, 0.08600090f, 0.35033473f, 
    -0.09402452f, 0.11222240f, -0.06701944f, -0.09417827f, 0.33451521f, 0.14942670f, -0.03765822f, 0.14570107f, 
    -0.00467290f, -0.09109948f, 0.18949048f, 0.40806177f, 0.28796417f, 0.13161875f, -0.07712746f, 0.06747321f, 
    -0.12299308f, -0.12409077f, 0.06149687f, -0.15105087f, 0.43092456f, 0.30371907f, 0.25311902f, -0.20096949f, 
    -0.20431471f, -0.00649987f, 0.14311093f, 0.01555425f, 0.01830479f, -0.13782115f, 0.20042229f, 0.18425921f, 
    -0.05981962f, 0.02849368f, -0.17813188f, 0.06949675f, 0.26340565f, 0.06308793f, 0.23043336f, 0.23185736f, 
    0.01669641f, 0.24225174f, -0.17927001f, 0.07769838f, 0.13067001f, -0.05533133f, -0.02459660f, -0.02584523f, 
    -0.22504690f, 0.24647661f, 0.14903527f, 0.05013342f, 0.02552802f, -0.11543702f, 0.07320791f, -0.34863719f, 
    -0.08525401f, -0.05445710f, 0.01638790f, 0.27728748f, -0.09466629f, -0.01046729f, 0.03400286f, 0.05958929f, 
    -0.02894134f, -0.21594599f, -0.02680968f, 0.01070542f, -0.01909935f, 0.16043982f, -0.09548642f, 0.05539716f, 
    -0.07043689f, 0.08805556f, 0.00262184f, -0.29902670f, -0.03237591f, 0.03030887f, -0.02689834f, 0.04083833f, 
    -0.00661890f, -0.03536348f, 0.04027079f, 0.02837173f, -0.12617737f, -0.12697922f, 0.28987482f, 0.08576227f, 
    0.19683774f, -0.26024655f, -0.23649392f, -0.02310832f, 0.07678349f, -0.15708157f, -0.20897181f, 0.05130878f, 
    -0.09202130f, 0.24043112f, 0.00142135f, -0.06329288f, 0.03772879f, 0.03865277f, 0.17349151f, 0.17579679f, 
    0.25896683f, -0.00898567f, -0.03424538f, 0.20020384f, 0.00890470f, 0.17384617f, 0.01539122f, -0.04275179f, 
    -0.05102240f, -0.09416221f, 0.13633648f, -0.20346782f, -0.14826547f, 0.02950759f, -0.34853849f, -0.21244198f, 
    0.11462761f, 0.04615107f, -0.02531969f, 0.00334051f, -0.07058199f, -0.06855740f, -0.07109556f, -0.24371852f, 
    0.00350186f, -0.08554826f, -0.01129080f, -0.04309140f, 0.02288790f, -0.05672102f, 0.00961590f, 0.00610920f, 
    0.04804464f, 0.08532409f, -0.02587624f, -0.05607092f, -0.07286726f, -0.00680133f, -0.03991367f, -0.06439419f, 
    -0.06219326f, -0.06675971f, -0.05413707f, -0.04592529f, 0.04020994f, -0.03618911f, -0.02586447f, -0.09217621f, 
    0.01806794f, 0.01457820f, -0.04159584f, -0.03983662f, 0.06934663f, -0.05398643f, 0.03840613f, 0.02127142f, 
    -0.01814382f, -0.04769809f, 0.02837507f, -0.01368185f, -0.06116227f, -0.07436617f, -0.02332037f, 0.02940926f, 
    -0.05404647f, 0.04736631f, 0.05034269f, -0.00753999f, 0.06256169f, -0.04765307f, -0.05258257f, 0.03541328f, 
    0.04941422f, -0.09264190f, -0.05605016f, -0.04796766f, 0.04074533f, -0.05245752f, 0.03333093f, -0.08248789f, 
    -0.00802062f, 0.04320420f, -0.00439213f, -0.04293516f, -0.08350990f, 0.04097492f, -0.04438785f, 0.04845372f, 
    0.00633142f, -0.06628063f, -0.06767361f, -0.05880456f, -0.09572612f, -0.08274900f, -0.10046516f, -0.00891146f, 
    0.05346771f, 0.02827346f, 0.06443483f, 0.03472785f, 0.00550373f, -0.09349050f, 0.06791354f, -0.06451698f, 
    -0.02645803f, -0.00596323f, 0.04974247f, 0.05763621f, -0.08434057f, -0.08241057f, 0.03422579f, -0.05491845f, 
    0.01191225f, 0.00676131f, -0.03686471f, 0.05227656f, -0.00534052f, -0.03335191f, 0.02340449f, -0.00903539f, 
    -0.10953939f, -0.03598147f, -0.00802118f, -0.07959975f, -0.10244691f, -0.09922168f, -0.05098375f, -0.03541534f, 
    -0.01268496f, -0.04768596f, -0.02808085f, -0.04867804f, -0.06419383f, 0.02149033f, 0.03718998f, -0.02433034f, 
    0.02832677f, -0.08100329f, -0.03245540f, 0.01443074f, -0.04279086f, 0.00291416f, 0.03136956f, -0.04483595f, 
    -0.08527105f, -0.05920258f, 0.03099125f, 0.03997914f, -0.04630917f, 0.03074912f, 0.02256994f, -0.01973313f, 
    0.03636285f, -0.02872736f, 0.06233788f, 0.01767906f, -0.05227519f, -0.05676893f, 0.04944288f, -0.01949593f, 
    -0.00234202f, -0.03707468f, -0.02646591f, -0.03496382f, -0.08481804f, -0.03473978f, -0.04664357f, -0.06339080f, 
    -0.01301328f, 0.09492356f, -0.00216978f, -0.03357283f, -0.07412454f, 0.13636087f, -0.11022067f, -0.19988021f, 
    0.00718501f, 0.01112388f, -0.11940389f, 0.41169083f, -0.03511709f, 0.24401093f, 0.12543058f, -0.02421023f, 
    0.05239120f, 0.27757031f, 0.19186461f, 0.27228311f, 0.38162452f, 0.04258457f, 0.05187732f, -0.06938640f, 
    -0.06402467f, 0.21882679f, 0.09301709f, 0.20839418f, 0.03236158f, -0.05104267f, -0.11706126f, 0.08390786f, 
    -0.25678971f, 0.08773100f, -0.15084621f, -0.03334143f, 0.12431955f, 0.17508821f, -0.33519751f, 0.00493586f, 
    -0.25493297f, 0.01324186f, 0.16156788f, -0.05579248f, 0.11767200f, -0.32288465f, -0.07863323f, -0.06988612f, 
    0.10542100f, 0.18769965f, 0.04674494f, 0.05953711f, -0.03554859f, -0.14390461f, 0.33592254f, 0.01332003f, 
    -0.17843369f, 0.16360097f, 0.05754922f, 0.10231782f, 0.07435594f, 0.02087726f, -0.06061504f, -0.10196784f, 
    -0.24648993f, 0.06390310f, 0.06214646f, 0.21559219f, -0.01146482f, -0.11961430f, -0.04590821f, -0.23359591f, 
    0.52941597f, -0.07942285f, -0.36746410f, -0.01055146f, 0.15602562f, 0.01657268f, -0.04236721f, 0.10738192f, 
    -0.07081148f, -0.14077953f, -0.08380366f, 0.02626697f, -0.19376053f, 0.05427139f, 0.01083116f, 0.16216931f, 
    0.18443739f, 0.31286183f, 0.11125638f, 0.00663818f, -0.10847234f, -0.12880969f, -0.05699480f, -0.03878359f, 
    -0.00903542f, 0.07782395f, 0.20085613f, 0.03436494f, -0.22492188f, 0.20769453f, 0.25610000f, 0.26945624f, 
    0.14701696f, -0.30562162f, -0.15151241f, -0.04992561f, 0.17430581f, -0.05550034f, -0.22116557f, 0.32567596f, 
    0.14544347f, 0.21450745f, -0.37678680f, -0.27490053f, -0.00605704f, -0.07007473f, 0.35136151f, 0.01517328f, 
    0.32294399f, -0.05259447f, 0.07816401f, -0.02808239f, 0.13967067f, 0.01079153f, -0.01756835f, -0.08333214f, 
    -0.02853622f, 0.11568476f, 0.12556866f, -0.04490412f, -0.19444516f, -0.11901658f, -0.23024221f, -0.16364913f, 
    0.22385919f, -0.25919020f, -0.02509968f, -0.09506404f, 0.29868993f, -0.39507377f, -0.26026472f, -0.04479612f, 
    0.39838940f, 0.10315838f, 0.05923164f, -0.11125292f, -0.05405239f, 0.07625806f, 0.07597414f, 0.18678665f, 
    -0.09977010f, -0.37042359f, -0.35070348f, -0.18958867f, -0.43641135f, -0.28304055f, 0.21879500f, -0.15923198f, 
    -0.12786272f, -0.10020038f, -0.57517302f, -0.19469370f, 0.00442673f, -0.19832161f, -0.03549057f, -0.07552791f, 
    0.08229834f, -0.07825328f, 0.18152338f, 0.16782224f, -0.28936899f, 0.18529136f, 0.05882215f, -0.19240218f, 
    0.35245588f, 0.20626377f, -0.14388463f, 0.14310321f, 0.38344836f, -0.21075745f, 0.02613663f, -0.28407708f, 
    -0.03974298f, -0.01812672f, -0.14747556f, 0.20371541f, 0.11476234f, 0.03694135f, -0.01369244f, -0.05598742f, 
    0.03248176f, -0.06707398f, 0.10986223f, 0.12167937f, 0.17284866f, 0.23384485f, 0.34234115f, 0.13353109f, 
    0.05349177f, -0.32349065f, -0.16330040f, -0.08018529f, -0.06543696f, -0.03369659f, 0.12169073f, -0.35023010f, 
    0.06924947f, -0.79011214f, 0.20821668f, 0.12899528f, -0.18773000f, -0.16313460f, -0.08286702f, 0.01846597f, 
    0.29363221f, 0.06878790f, 0.38226750f, -0.09473980f, 0.15829812f, 0.09635232f, 0.09773208f, -0.03338039f, 
    0.33605117f, 0.10570645f, -0.15317214f, -0.12860765f, 0.15234904f, 0.17277808f, -0.07248000f, 0.21295670f, 
    0.01556045f, 0.27058366f, -0.03855664f, -0.45309767f, 0.14173295f, -0.08601082f, -0.15831341f, -0.11116109f, 
    0.18405364f, 0.05256263f, 0.07897878f, -0.10095295f, -0.37948835f, 0.18000348f, -0.24460435f, -0.13384566f, 
    -0.18591522f, -0.03890979f, -0.10351529f, 0.09045636f, -0.64445055f, -0.15959904f, -0.04261650f, -0.13233507f, 
    0.04034542f, -0.17954287f, 0.09188014f, 0.06282691f, 0.05652844f, -0.09136534f, -0.37030143f, -0.30958393f, 
    -0.01795910f, 0.11090285f, 0.01127298f, -0.04482531f, -0.07171705f, -0.01202106f, 0.16257000f, -0.08092682f, 
    -0.31756818f, -0.11262986f, 0.04041968f, 0.21934180f, 0.11226135f, 0.07244153f, -0.15081115f, -0.19675072f, 
    -0.08751535f, -0.04739514f, -0.02233557f, -0.11257412f, -0.06990822f, -0.00960665f, -0.00100734f, 0.00651911f, 
    -0.45064840f, -0.33965096f, -0.25357631f, -0.03458024f, -0.07131801f, 0.11497057f, 0.05667871f, 0.28521857f, 
    0.17440145f, -0.07872056f, -0.23021737f, -0.01485400f, 0.01128003f, -0.13240367f, 0.05546622f, 0.10109225f, 
    0.02647907f, 0.11026578f, 0.31463325f, 0.05577492f, 0.15073849f, 0.08493744f, -0.09833511f, 0.04220136f, 
    0.20757577f, -0.10900036f, -0.13008802f, 0.37521216f, -0.43956089f, -0.96170300f, -0.34635413f, 0.16742420f, 
    -0.04345997f, 0.10928414f, 0.15377873f, 0.05679401f, 0.47637048f, -0.57396841f, -0.37589872f, -0.19824296f, 
    0.03810346f, -0.00554328f, 0.15488982f, -0.10578094f, 0.11849100f, 0.73603427f, 0.05154779f, -0.43768412f, 
    -0.09102620f, -0.23310849f, 0.05139421f, -0.00588293f, -0.12076505f, -0.00404614f, -0.03744151f, -0.47265843f, 
    0.04989026f, 0.06385469f, -0.21472345f, 0.00522442f, -0.00414696f, -0.13657792f, -0.01791140f, 0.38657537f, 
    0.29097322f, 0.59249878f, -0.16854858f, 0.02809860f, -0.12346422f, 0.07029108f, 0.04301098f, 0.13264276f, 
    -0.84877348f, -0.49699450f, 0.43961260f, 0.08257319f, 0.00776361f, -0.00087533f, 0.09163944f, 0.22413060f, 
    0.08889712f, -0.03980557f, -0.02984240f, 0.07503101f, 0.01581255f, -0.09204710f, 0.01029112f, 0.12643538f, 
    0.09757674f, -0.11262625f, 0.17075974f, 0.32433662f, 0.42031518f, -0.05779922f, 0.01750737f, 0.08209648f, 
    0.14639956f, 0.00774353f, -0.12962836f, -0.15663227f, -0.06741625f, -0.42213657f, 0.14844623f, -0.20831800f, 
    0.01448445f, 0.00609645f, -0.02532317f, 0.16828865f, 0.34344295f, 0.21328324f, 0.41755459f, -0.15102907f, 
    0.02948064f, -0.00507141f, 0.01545571f, 0.11355548f, 0.00627967f, 0.27532190f, 0.37856117f, 0.17303449f, 
    0.04202360f, 0.16160050f, -0.04431564f, -0.09391289f, -0.20657922f, -0.08200853f, 0.09666944f, 0.09108665f, 
    -0.31214765f, 0.07572455f, 0.13753700f, 0.07019226f, -0.01244914f, -0.12691352f, 0.09033314f, -0.08574463f, 
    -0.14762607f, 0.20008241f, 0.02754771f, -0.13361657f, -0.08523657f, 0.00853893f, -0.02045804f, -0.01299103f, 
    -0.07378965f, 0.25234485f, 0.19479874f, 0.16519299f, -0.11832796f, 0.02277782f, 0.09195739f, 0.12195642f, 
    0.11677273f, -0.19688547f, 0.32789665f, 0.01819450f, -0.03199838f, 0.02068762f, -0.21578498f, 0.18666238f, 
    -0.27788809f, -0.06208596f, 0.29935288f, -0.11312108f, -0.28066149f, 0.12184609f, 0.22659710f, 0.07372507f, 
    -0.08784298f, -0.02729636f, -0.42040977f, -0.58490133f, -0.38380978f, -0.15631044f, 0.05181330f, 0.02064540f, 
    0.25520441f, 0.13922463f, -0.01764020f, -0.07893562f, 0.01007690f, -0.02100330f, 0.10874823f, -0.13628665f, 
    -0.10970613f, 0.07199015f, -0.05259645f, -0.17547500f, 0.17905770f, -0.00078079f, 0.04330660f, 0.23910740f, 
    0.09900149f, -0.02907179f, 0.05051596f, -0.31468505f, -0.35060439f, -0.38455558f, 0.23203772f, 0.10668214f, 
    0.21529962f, -0.20529597f, 0.09988273f, 0.05911791f, 0.03184396f, -0.04674926f, 0.10659638f, 0.08219549f, 
    -0.26348251f, -0.28340226f, 0.23678994f, -0.12531064f, 0.27494246f, 0.02609798f, 0.05238473f, 0.25267613f, 
    0.24627215f, -0.22517176f, 0.51677996f, 0.32162198f, -0.14017285f, -0.12636462f, -0.00657293f, -0.10897537f, 
    -0.02479790f, 0.00453210f, 0.21413113f, -0.09489572f, -0.03402583f, -0.10805521f, -0.02841229f, -0.01828076f, 
    -0.20314284f, -0.23443437f, 0.28839538f, 0.41674402f, -0.43637750f, -0.08093142f, -0.12223154f, -0.23757024f, 
    -0.00650892f, 0.10506707f, -0.20103584f, -0.07318462f, -0.15208904f, 0.09361178f, -0.14600205f, 0.24063566f, 
    0.17235605f, -0.21872117f, 0.03177563f, -0.10910764f, -0.07225636f, -0.15298504f, -0.07684476f, -0.03488832f, 
    -0.14609918f, 0.25872019f, -0.00886293f, 0.11246507f, 0.33762035f, -0.00833314f, 0.49606368f, -0.18926366f, 
    0.00421842f, 0.00942871f, 0.03935990f, 0.00368297f, 0.26794407f, -0.08699331f, -0.04711906f, 0.01962393f, 
    -0.37014842f, 0.27706763f, 0.26775983f, 0.14834312f, 0.01698736f, 0.26113203f, 0.24875772f, -0.04430600f, 
    -0.01914642f, 0.03616054f, 0.38347414f, 0.18551253f, 0.31480488f, -0.09496853f, -0.02707131f, 0.11312018f, 
    0.65206540f, 0.22825234f, 0.17701539f, -0.02610081f, 0.00726981f, 0.17543727f, 0.05104173f, -0.09858626f, 
    -0.15556994f, -0.40029800f, -0.23275611f, -0.37294272f, 0.00837763f, 0.23123619f, -0.06004417f, 0.00258785f, 
    -0.13890618f, 0.05986063f, -0.00510070f, -0.07438488f, -0.03492656f, -0.09809942f, 0.01105294f, 0.16677903f, 
    -0.13906808f, 0.03621471f, 0.01382674f, 0.29784530f, -0.02996779f, 0.06796601f, -0.00808259f, -0.00555463f, 
    0.28185239f, 0.08776218f, 0.11620349f, 0.07416628f, 0.49181780f, -0.02807852f, 0.07955604f, 0.08750228f, 
    0.05438996f, 0.04245307f, 0.06921470f, 0.15850879f, 0.20048381f, 0.19874918f, 0.10438199f, 0.19034693f, 
    0.07284629f, -0.25620967f, 0.16818225f, -0.20462409f, -0.09302893f, 0.06683635f, 0.35776490f, 0.24547866f, 
    0.06854401f, 0.06462140f, -0.13117829f, -0.12534644f, -0.03239808f, -0.09187945f, 0.10413770f, -0.27750385f, 
    0.12702207f, 0.09974740f, -0.05342488f, -0.06387943f, 0.08589609f, 0.08063000f, -0.28374505f, 0.17925531f, 
    -0.23443322f, -0.07851123f, -0.37494633f, 0.08526424f, 0.06718953f, -0.27982992f, -0.13807739f, 0.06253033f, 
    -0.02690354f, -0.02967446f, -0.03128365f, -0.32246861f, -0.11386444f, 0.04830587f, 0.15008400f, 0.11575044f, 
    -0.13729587f, 0.14891972f, 0.56540340f, -0.08929358f, -0.30538335f, 0.05206877f, 0.23123229f, -0.03441433f, 
    0.13273479f, 0.14176640f, 0.07832564f, 0.23109362f, 0.16942446f, 0.22777303f, -0.16095793f, -0.27714053f, 
    -0.06927205f, 0.00354613f, -0.21939009f, 0.06447561f, -0.73042130f, -0.19110182f, -0.28473189f, 0.07298175f, 
    0.08326913f, 0.03542679f, -0.11208451f, -0.08817335f, -0.24789198f, -0.20152058f, -0.72415215f, -0.52238530f, 
    0.01745645f, 0.03743694f, -0.19826722f, 0.10132594f, 0.04872495f, 0.02283233f, 0.44573745f, 0.21266744f, 
    -0.11419909f, 0.12177089f, 0.16572508f, 0.30285773f, -0.06721772f, 0.17590398f, -0.17384236f, 0.40701512f, 
    -0.04548154f, -0.26920432f, 0.02325682f, -0.02674363f, 0.01210036f, 0.15352024f, -0.06231603f, -0.04199284f, 
    -0.12572277f, 0.17886209f, 0.21534452f, -0.15980291f, 0.07014055f, 0.02495690f, 0.13624720f, 0.01446748f, 
    -0.08676133f, 0.54684758f, -1.07704568f, -1.07825696f, -0.12566927f, -0.01194588f, 0.28210860f, -0.03523950f, 
    -0.13184273f, -0.09883456f, 0.25459331f, 0.58053535f, 0.08522561f, -0.14233825f, -0.21305789f, -0.14605507f, 
    0.08205064f, -0.09382445f, 0.09008056f, -0.42470044f, 0.14522985f, -0.10285133f, -0.01533113f, 0.24264295f, 
    0.11367578f, 0.08998639f, 0.21391194f, -0.09186778f, -0.13339481f, 0.30121273f, 0.20955212f, -0.09380257f, 
    0.04033499f, -0.13635969f, -0.06811610f, -0.00568566f, 0.05660305f, -0.18721227f, 0.22162239f, 0.21499881f, 
    0.06557113f, 0.18661091f, 0.05045165f, 0.01603962f, 0.21868269f, 0.07616242f, -0.03324156f, 0.36617216f, 
    0.07458175f, 0.05260803f, -0.05218268f, -0.07331281f, 0.19379276f, 0.07099766f, 0.12123020f, -0.13715249f, 
    -0.38967320f, 0.07842950f, -0.11578605f, -0.17422463f, 0.12483744f, -0.01079857f, -0.14909151f, 0.07272122f, 
    0.22868024f, 0.12290649f, -0.16281392f, 0.14160021f, 0.15352373f, -0.27796352f, 0.15101767f, 0.16980560f, 
    0.02405739f, -0.18211772f, -0.01325803f, -0.38944054f, 0.24200429f, -0.01948265f, 0.19189931f, 0.08298365f, 
    0.06181649f, 0.14475511f, 0.06336547f, -0.17850505f, -0.57432860f, -0.31647232f, -0.08003247f, 0.01156774f, 
    -0.21025938f, -0.33206967f, 0.18234251f, -0.11688711f, 0.16828582f, -0.25211594f, -0.04903528f, -0.08729691f, 
    -0.05699157f, 0.07632576f, -0.22761439f, -0.12796505f, -0.37295622f, 0.11318091f, -0.02469818f, -0.01070074f, 
    0.01780305f, -0.10976584f, -0.01827334f, 0.24092668f, 0.18731126f, 0.16535050f, -0.02999186f, 0.25068659f, 
    0.21146224f, 0.07439977f, 0.15375897f, -0.06906649f, 0.09089741f, -0.07573424f, 0.21781749f, -0.48547921f, 
    0.06155945f, -0.21829997f, -0.06438175f, -0.17203130f, 0.09230386f, -0.06162854f, 0.13915360f, 0.15572238f, 
    -0.58411431f, 0.20399104f, -0.11792594f, -0.09864353f, -0.21969092f, 0.03195349f, 0.14813858f, -0.03135113f, 
    -0.01336701f, 0.03846775f, 0.07598116f, -0.03878580f, 0.11618286f, 0.40434331f, -0.15434910f, -0.01386321f, 
    0.24684595f, -0.68740302f, -0.07497286f, 0.01809335f, 0.11586461f, 0.09721782f, 0.02693420f, -0.04044603f, 
    -0.14860216f, -0.08759221f, 0.00054160f, -0.16144973f, -0.23709610f, -0.05683969f, -0.03167974f, 0.29624692f, 
    0.08261964f, -0.23096813f, -0.13774477f, 0.17253761f, -0.18340796f, 0.08140319f, 0.27793750f, 0.17374152f, 
    0.26723382f, 0.12254210f, 0.21285981f, 0.13819019f, 0.27028462f, -0.15737373f, 0.04251816f, -0.05489253f, 
    0.17364414f, 0.03506637f, -0.17605734f, 0.21501301f, 0.09118722f, -0.13821855f, -0.02546202f, 0.00011583f, 
    0.17798422f, -0.06812560f, 0.02307601f, -0.05540436f, -0.10172853f, -0.11248460f, 0.03216401f, -0.05130491f, 
    0.09667569f, -0.01026221f, -0.13023101f, 0.14548290f, -0.11670794f, -0.12692790f, 0.05027087f, -0.31966016f, 
    -0.00769339f, -0.51304668f, -0.08454168f, -0.29073709f, 0.04529717f, 0.08216814f, -0.05620574f, 0.15947646f, 
    0.35948232f, -0.03139913f, 0.35137460f, 0.16009407f, 0.48679179f, 0.13444969f, -0.01880639f, -0.11051328f, 
    0.02650519f, -0.11344659f, 0.32449585f, 0.15545876f, 0.36294398f, -0.14977241f, 0.02016975f, -0.13511942f, 
    -0.23851168f, -0.15185136f, -0.23978099f, 0.24472304f, 0.21354769f, -0.04176962f, 0.02914170f, 0.05939735f, 
    -0.14474665f, 0.00618890f, 0.03996628f, -0.24562022f, -0.21607061f, 0.10836279f, 0.03097390f, -0.23746507f, 
    0.18123719f, -0.12226021f, -0.15168998f, 0.06707489f, -0.29447928f, -0.22401313f, -0.27763516f, -0.08711672f, 
    0.03641326f, -0.19381726f, 0.07987640f, 0.33544418f, 0.10372603f, -0.13271916f, 0.07725172f, -0.23229825f, 
    0.01957977f, 0.12300611f, 0.12568107f, -0.01788500f, 0.10016652f, 0.07144695f, 0.16190954f, 0.11114195f, 
    -0.04925871f, -0.13777559f, 0.09028175f, -0.00258563f, -0.02104416f, 0.00744676f, 0.30213416f, 0.10352845f, 
    0.08818232f, -0.24484044f, -0.11372960f, -0.02088545f, 0.12170180f, 0.12723382f, 0.24224725f, 0.11809555f, 
    -0.13133059f, 0.13346921f, 0.12700756f, -0.23908365f, -0.02944190f, -0.22669530f, -0.05280397f, 0.07263639f, 
    0.28103986f, -0.78354639f, -0.07234097f, -0.24261266f, 0.14561802f, 0.20147009f, 0.07535028f, -0.18488307f, 
    -0.03386227f, 0.09504815f, 0.04423438f, 0.03459372f, 0.66933769f, -0.05436368f, -0.24928501f, -0.20508577f, 
    0.13876264f, 0.17290996f, -0.20499156f, 0.67477608f, 0.16776676f, 0.19078316f, -0.19448906f, -0.10051629f, 
    -0.02924302f, 0.17370962f, -0.25169218f, -0.05459765f, 0.35081467f, 0.15278684f, 0.10886454f, -0.09349965f, 
    -0.11182716f, 0.04899962f, -0.03090933f, -0.00410987f, 0.25107470f, 0.15324336f, -0.15302217f, -0.22022153f, 
    0.04078074f, -0.15711115f, 0.02324220f, 0.07126196f, 0.12539198f, 0.10069046f, 0.10458950f, 0.18107478f, 
    -0.01199485f, -0.04370267f, -0.23125100f, 0.19635326f, 0.03363984f, 0.10867151f, -0.08908550f, -0.18942201f, 
    -0.10390061f, 0.38212091f, -0.07837604f, -0.05758337f, -0.11438341f, -0.03090657f, 0.09773079f, -0.10034529f, 
    0.50306994f, 0.14456649f, 0.14619347f, -0.08379337f, 0.04551813f, -0.15716453f, 0.27381104f, -0.08547474f, 
    0.05021428f, -0.26774421f, 0.23680755f, 0.08705229f, 0.19244266f, 0.26880324f, 0.24297671f, -0.00464678f, 
    0.22343461f, 0.25245002f, -0.09117322f, -0.05903023f, 0.29650852f, 0.01277165f, -0.08410970f, -0.01047340f, 
    -0.21481510f, 0.00195067f, 0.18718275f, 0.03700512f, 0.13928311f, 0.21389785f, 0.00578844f, -0.36741039f, 
    -0.18020731f, 0.01439589f, 0.04758738f, 0.16276745f, -0.00752363f, -0.32019633f, -0.10360897f, 0.25598654f, 
    -0.16789322f, -0.09277599f, 0.10183118f, -0.02983115f, -0.03123411f, 0.17480029f, -0.10123876f, 0.19579396f, 
    -0.09757380f, -0.01016225f, 0.08269365f, 0.03974322f, -0.07737668f, 0.01288635f, 0.02964612f, -0.13481167f, 
    0.02285057f, -0.07049295f, -0.01091768f, 0.07866501f, 0.04071328f, 0.10671641f, -0.09506080f, 0.30332676f, 
    -0.25887713f, -0.30697736f, -0.07030666f, -0.30498132f, -0.24537463f, 0.10953452f, 0.17935933f, -0.23026858f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.15709765f, -0.31352353f, 0.32639059f, -0.03079900f, 0.14385675f, 0.28197628f, -0.09392019f, 0.04584081f, 
    -0.26693296f, 0.38888326f, 0.09881619f, 0.20912388f, -0.07904824f, 0.10778533f, 0.33178675f, 0.16799913f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.35030293f, -0.05776441f, 0.33430237f, -0.50767750f, 0.53615773f, -0.37650004f, 0.13625880f, 0.22883539f, 
    -0.12274029f, -0.59389532f, -0.08453325f, 0.16807079f, -0.48057342f, -0.03586959f, 0.06544463f, -0.14908016f, 
    0.18376048f, 0.03678798f, -0.11002354f, 0.02816906f, -0.28915936f, 0.16288595f, -0.21680294f, 0.17809613f, 
    -0.20197982f, -0.10461812f, 0.17991015f, 0.06755517f, -0.13260235f, 0.16049944f, -0.22402394f, -0.08355990f, 
    0.39649934f, 0.10065493f, 0.16138746f, -0.28431508f, 0.30040950f, -0.46297511f, -0.10210928f, 0.17963703f, 
    -0.13269049f, 0.27989101f, -0.48851982f, 0.06735913f, -0.05722750f, -0.33862260f, 0.20075661f, 0.16887671f, 
    0.05514158f, -0.16935737f, -0.04036232f, -0.23137526f, -0.07800652f, 0.00903420f, 0.21514745f, 0.07527717f, 
    -0.09899203f, 0.76472241f, -0.00906259f, -0.26393771f, 0.20637082f, 0.87505680f, -0.33673266f, -0.00224379f, 
    0.12194363f, 0.02985939f, 0.54841423f, 0.21848385f, -0.03478941f, -0.55876690f, -0.46781683f, 0.20858182f, 
    -0.29263330f, -0.13320634f, 0.08784296f, 0.01225447f, -0.30095077f, 0.43740112f, 0.34593281f, -0.25370556f, 
    -0.23358515f, 0.25760153f, 0.02129317f, 0.73156911f, 0.11426214f, 0.38334611f, -0.17240432f, 0.09230449f, 
    0.14274657f, 0.43849120f, -0.32471195f, 0.13881372f, -0.50206894f, -0.39357620f, 0.34679061f, -0.01836191f, 
    -0.39846694f, 0.17642030f, 0.04804933f, 0.17464994f, -0.15696788f, 0.61290848f, 0.16780961f, -0.09949853f, 
    0.17166057f, 0.19639705f, 0.50246722f, -0.10142855f, -0.20579988f, 0.22675905f, 0.04902571f, 0.45620176f, 
    0.35135809f, -0.17109933f, 0.01377467f, -0.35376787f, 0.07454793f, -0.42423430f, -0.25458938f, 0.26456976f, 
    -0.07922143f, 0.23128588f, 0.13635460f, -0.16503915f, 0.28359157f, 0.15957643f, 0.26275748f, -0.16096218f, 
    0.43779179f, 0.40065289f, -0.47176075f, 0.68314481f, 0.53383750f, -0.64365613f, -0.47887138f, 0.23415191f, 
    0.26186550f, 0.57213295f, 0.18885113f, -0.10347886f, -0.06589673f, 0.08562241f, -0.33681378f, -0.11579358f, 
    0.32578170f, -0.03549344f, 0.45682997f, -0.24089509f, -0.08046261f, -0.59765953f, -0.40663305f, -0.21939707f, 
    -0.50339776f, -0.01295470f, 0.07496344f, 0.22722150f, -0.34265184f, 0.11240738f, 0.28595009f, 0.58186942f, 
    0.49953118f, -0.48097500f, -0.00751892f, 0.24162282f, -0.07432670f, 0.40282845f, -0.07529508f, 0.05479271f, 
    0.36413401f, 0.13134845f, -0.44739348f, -0.16671471f, 0.21403648f, -0.64376891f, 0.25437796f, 0.09609959f, 
    0.09748235f, -0.77103758f, 0.00352242f, 0.07932417f, 0.32775721f, -0.36927661f, 0.75052780f, -0.01888622f, 
    0.22446795f, -0.52083200f, 0.64181334f, -0.32057366f, -0.46814066f, -0.27178401f, -0.13633983f, 0.06001221f, 
    0.38743225f, 0.22368392f, -0.30075109f, 0.53685009f, 0.36920452f, 0.13523534f, -0.03649426f, 0.03212247f, 
    0.17666166f, 0.20039850f, -0.00360902f, -0.07151753f, -0.27811825f, -0.74376631f, 0.11204728f, 0.00664479f, 
    -0.03046706f, -0.27494845f, 0.21863423f, 0.25126195f, 0.19067955f, -0.42965463f, -0.58009118f, -0.13202217f, 
    -0.01282893f, 0.49119425f, -0.45402136f, 0.18371563f, -0.13686650f, 0.40321815f, 0.28179559f, 0.36577991f, 
    0.29887500f, -0.25086924f, 0.37892261f, -0.45499149f, -0.06899694f, -0.33687162f, 0.36348099f, -0.01195595f, 
    -0.18370502f, -0.08312128f, 0.29351997f, -0.14296716f, 0.24996886f, 0.37007987f, 0.23555113f, -0.22097886f, 
    0.13644695f, -0.21909747f, 0.37416551f, -0.37965813f, -0.13967702f, -0.30083963f, -0.50905508f, -0.16945639f, 
    -0.37698427f, 0.74776196f, 0.27502641f, 0.40451369f, -0.26155344f, 0.15513961f, 0.25200158f, 0.50076151f, 
    0.19096756f, 0.11568815f, -0.05022857f, -0.14139077f, 0.17297272f, 0.15909037f, 0.36097991f, 0.19361393f, 
    0.41069442f, -0.51925093f, -0.42776656f, 0.10018528f, -0.23391886f, 0.14334360f, -0.21631455f, 0.15938520f, 
    0.36697838f, 0.41344395f, -0.24913351f, 0.36153156f, 0.22026560f, -0.27942860f, 0.20508648f, -0.17937021f, 
    0.32976013f, -0.37243313f, 0.15126830f, -0.57080448f, -0.09567125f, 0.65578187f, -0.53597879f, 0.28454012f, 
    -0.22956482f, -0.16546352f, -0.27545965f, 0.26019633f, 0.05475206f, -0.25027329f, 0.22608593f, 0.01729378f, 
    0.20303302f, 0.27991414f, -0.00339156f, 0.05205756f, 0.21948177f, 0.24662915f, -0.20178568f, 0.23713927f, 
    -0.10891676f, -0.94159395f, 0.04402367f, -0.05533445f, 0.48251429f, 0.71356177f, 0.26866928f, 0.14008243f, 
    0.11286577f, -0.38111725f, 0.43728372f, 0.49384686f, -0.68292254f, -0.74700820f, -0.16517213f, -0.08599898f, 
    0.12089344f, 0.17818944f, 0.25471711f, -0.51260066f, 0.23052770f, 0.15917584f, -0.11121917f, -0.04914106f, 
    0.30948091f, -0.15339097f, -0.45393285f, -0.21821909f, 0.10554492f, 0.32329208f, -0.18499961f, 0.41764888f, 
    -0.19667612f, -0.18857771f, -0.04169615f, -0.00608758f, 0.05702650f, 0.25227651f, 0.17514211f, 0.12332921f, 
    0.11154035f, -0.25465438f, 0.80399048f, 0.44385540f, 0.37857017f, 0.40292671f, -0.06301557f, -0.38979292f, 
    0.26389191f, 0.05679939f, 0.27144933f, 0.12763670f, 0.00594792f, -0.03278728f, -0.08795746f, -0.08887731f, 
    -0.41672546f, 0.44157979f, 0.07496665f, -0.45427370f, 0.13149391f, -0.13445951f, 0.27853116f, -0.12227111f, 
    0.04431801f, 0.23260151f, -0.14747806f, 0.18084008f, 0.13977811f, -0.46753818f, -0.14866646f, 0.04880247f, 
    -0.40883115f, 0.35572436f, 0.39410385f, 0.26775423f, 0.20998500f, 0.19619717f, 0.20510793f, -0.14665091f, 
    -0.02881663f, 0.21194218f, -0.13035324f, 0.30091646f, -0.31334329f, -0.29976264f, 0.19071488f, -0.10876167f, 
    0.23750629f, -0.26315254f, 0.11626884f, -0.12666669f, 0.23423000f, 0.21559258f, 0.02715341f, -0.24012896f, 
    0.48502263f, -0.46607706f, 0.33402735f, -0.57109028f, -0.11902528f, 0.23317246f, 0.41070876f, -0.14151601f, 
    0.19555981f, -0.17799057f, 0.03413827f, -0.12454776f, 0.19271535f, 0.10662919f, 0.13999216f, 0.24353957f, 
    0.12294157f, 0.56279451f, 0.27347550f, 0.62676352f, 0.07299244f, 0.07638932f, -0.14827411f, 0.22784010f, 
    -0.62644124f, -0.09281064f, 0.35651043f, -0.22318813f, -0.29273835f, -0.60098767f, 0.01431079f, -0.10494628f, 
    -0.04170137f, -0.45369703f, 0.47268444f, -0.29711765f, -0.00846043f, 0.58783317f, -0.25958106f, 0.15289116f, 
    0.16318108f, -0.02758900f, -0.17098920f, -0.21405025f, -0.91656899f, 0.04146351f, 0.37103307f, 0.71504843f, 
    0.25428921f, -0.19903407f, -0.10998049f, 0.23574194f, 0.02535219f, 0.07768022f, 0.06207079f, -0.16204138f, 
    -0.36480880f, 0.54808050f, -0.00448134f, 0.23388228f, 0.32806093f, 0.15025395f, 0.27059221f, -0.21615669f, 
    0.08014132f, 0.14187102f, -0.08728556f, -0.01416153f, -0.54571760f, 0.03541700f, 0.12749299f, 0.13926066f, 
    -0.05822287f, 0.09102619f, 0.54933429f, 0.16303799f, 0.32302639f, 0.26481670f, -0.10422588f, -0.10444551f, 
    0.54214394f, -0.38240957f, -0.15825380f, -0.49395502f, 0.07917986f, -0.43183717f, 0.22007373f, -0.07931962f, 
    0.48897091f, 0.10025284f, -0.31344646f, -0.26009125f, -0.04065468f, -0.14922068f, -0.15263949f, 0.47900581f, 
    0.28920662f, -0.36843392f, 0.28143930f, -0.50436372f, -0.01610568f, 0.04241169f, -0.02985100f, -0.08389710f, 
    -0.11625446f, 0.27802250f, 0.15620136f, -0.23358932f, 0.28275067f, -0.62576562f, 0.16401543f, 0.58670992f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.24743904f, 0.09692649f, 0.49345928f, 0.24523622f, 0.47710723f, 0.29585317f, 0.07680138f, -0.08992911f, 
    0.03604626f, 0.30312991f, 0.12701267f, 0.15133454f, 0.41110274f, 0.37511909f, -0.14813076f, 0.47448680f, 
    0.08382915f, -0.05857605f, 0.04206621f, 0.55447835f, -0.05222335f, -0.03202574f, -0.09379721f, -0.11533117f, 
    -0.30614543f, -0.01696668f, -0.09189241f, 0.45513025f, 0.05087027f, 0.07900846f, 0.08772549f, 0.02695495f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.43344015f, -0.01287119f, -0.84290916f, -0.32506597f, -0.24740528f, 0.17006868f, 0.09344091f, -0.24514778f, 
    0.36350852f, -0.48033679f, 0.10634774f, 0.22916754f, 0.25795439f, 0.03566514f, -0.56168038f, -0.48875815f, 
    -0.26744947f, 0.22081359f, 0.13164254f, 0.19177327f, -0.62866968f, 0.24909592f, -0.26974943f, 0.29352140f, 
    0.16230239f, -0.57701075f, 0.10007179f, -0.52361846f, -0.04194922f, -0.08360223f, -1.07660067f, -0.63564330f, 
    0.16452321f, -0.00913031f, 0.15946111f, 0.67649013f, 0.22299495f, 0.12070327f, -0.30071053f, -0.02333614f, 
    0.11194875f, 0.11387583f, -0.18169035f, -0.18190317f, 0.21994859f, 0.22130823f, 0.03399526f, 0.34403211f, 
    -0.57182264f, -0.85729939f, 0.25119850f, 0.36278865f, -0.29427138f, 0.10871735f, 0.11498556f, 0.27283427f, 
    -0.06208740f, -0.20768194f, 0.07298339f, -0.40574351f, 0.22696985f, 0.11201265f, -0.43235537f, -0.16526805f, 
    -0.02322975f, -0.14546807f, 0.06837066f, -1.03316855f, -1.23056066f, 0.39079291f, 0.32928231f, -0.32249141f, 
    -0.86017323f, -0.36812752f, 0.03316028f, -0.13940644f, 0.05764483f, 0.22658132f, -0.63916689f, 0.19187187f, 
    0.10999021f, -0.66352570f, -0.20076595f, 0.82199240f, 0.12041572f, -0.29667258f, -0.11619557f, -0.41830286f, 
    0.20881021f, -0.03956999f, -0.60879755f, 0.72848177f, -0.08916412f, 0.23826815f, 0.07297863f, 0.00493782f, 
    0.14496963f, 0.01035151f, 0.37014636f, -0.57118398f, -0.22266035f, 0.11825952f, -0.17820337f, -0.36667612f, 
    0.37514129f, -0.10411099f, -0.79926497f, -0.07351778f, 0.27461940f, 0.13948640f, -0.68024778f, -0.28716457f, 
    0.58661681f, 0.36190581f, 0.32777375f, -0.08860058f, 0.37728831f, -0.40051812f, -0.48259681f, -0.03669732f, 
    -0.34857398f, -0.44603649f, -0.11156518f, -0.05092980f, -0.94356543f, 0.54344904f, 0.65847039f, -0.09319025f, 
    0.07519525f, 0.02537461f, -0.41159880f, -1.22750986f, -0.20676102f, -0.58222288f, -0.02567655f, 0.04505789f, 
    0.14794610f, -0.11468767f, -0.20807573f, 0.40238264f, 0.00320389f, -1.50173056f, 0.38032502f, -0.09340438f, 
    -0.04294237f, 0.14858189f, -0.31800100f, 0.01433658f, -0.17874740f, 0.31388175f, 0.01953683f, 0.08141619f, 
    -0.01218333f, 0.28426862f, -0.08964135f, -0.41237676f, -0.17563877f, -0.12358348f, 0.08133089f, -0.03972748f, 
    -0.28563702f, -0.08279283f, -0.16097945f, -0.54558408f, 0.14511195f, 0.00248825f, 0.26857540f, -0.09946071f, 
    -0.26225865f, 0.47047257f, -0.52832627f, 0.07743448f, -0.08469460f, -0.16646081f, 0.28404570f, 0.31871954f, 
    -0.30782408f, -0.06181000f, 0.15114431f, -0.04443597f, -0.00420603f, 0.05382223f, 0.21703552f, 0.03767481f, 
    -0.03768267f, 0.01786199f, 0.36789924f, 0.06395303f, -0.12010363f, 0.10585270f, -0.49843499f, 0.31108066f, 
    -1.71920180f, -0.07807904f, -0.15394510f, -0.10332899f, -0.23829144f, 0.47262037f, 0.29535156f, -0.01873294f, 
    -0.49445543f, -1.14949501f, 0.67531753f, -1.36169136f, -0.02199930f, 0.00504830f, -0.12557809f, -0.30340827f, 
    -0.03801161f, -0.54174340f, -0.27110445f, -0.03547604f, 0.05562011f, -0.18493798f, 0.20903771f, -0.61051387f, 
    0.25999522f, 0.20596363f, -1.12563419f, 0.64224315f, 0.07947045f, -0.38327718f, 0.05185293f, 0.16500238f, 
    -0.79390252f, 0.13678104f, -0.15930496f, 0.10855152f, -0.30596024f, -0.10924510f, 0.18092033f, 0.22289062f, 
    0.47320956f, -0.73658693f, -0.55370367f, 0.03487296f, -0.76727301f, 0.21037650f, 0.03815187f, -0.60996938f, 
    -0.20710400f, 0.73093581f, -0.07936533f, -1.72396100f, 0.28453138f, 0.21187621f, 0.17576402f, 0.07786377f, 
    -0.16095869f, -0.11442737f, -0.99395841f, -0.36682397f, 0.17786780f, -0.27016369f, -0.20040193f, -1.17886019f, 
    0.40339103f, 0.03922816f, -0.02313188f, 0.05967478f, 0.91385418f, -0.10572963f, -0.12325728f, -0.00199594f, 
    -0.28438029f, 0.63326913f, -0.40034717f, -0.41354764f, -1.18447280f, 0.41970369f, 0.22813423f, 0.54100943f, 
    -0.18465728f, -0.49267465f, -0.36668932f, -1.47240078f, 0.11451405f, 0.14522135f, -0.08137770f, 0.16316013f, 
    -0.34117115f, 0.09905484f, -0.64470458f, 0.17642651f, 0.12914354f, -0.01717562f, -0.36043194f, -0.10234632f, 
    0.25919849f, -0.14447615f, 0.12194660f, 0.11104523f, 0.23046355f, 0.02678173f, -0.04020389f, -0.55916321f, 
    -0.83153296f, -0.64911270f, 0.07920528f, 0.25760832f, -0.09984741f, -0.26602817f, 0.03890323f, -1.17320538f, 
    0.57840067f, 0.15919349f, -0.09290145f, 0.16853680f, 0.17836906f, 0.14718622f, -0.02471755f, -0.53297073f, 
    -0.77472037f, 0.23762028f, -0.38545606f, 0.08568963f, -0.06565469f, -0.59522974f, 0.05882386f, -0.15291196f, 
    0.20472312f, 0.13608922f, 0.37800044f, -0.38255852f, 0.33618218f, 0.41364199f, -0.50457776f, -0.04750044f, 
    0.39536738f, 0.07499868f, 0.19315033f, -1.02752125f, 0.39731172f, 0.15755388f, 0.01209753f, -0.12902363f, 
    -0.04251316f, 0.32447362f, -1.06392860f, -1.25261617f, -0.01136942f, -1.02568460f, 0.56111312f, 0.24258061f, 
    -0.20338254f, -0.18720733f, 0.37520081f, 0.03521096f, 0.03394188f, -0.81801242f, -0.15301798f, -0.13473323f, 
    0.03940183f, 0.12082592f, 0.41355690f, -0.03730781f, -0.23125903f, -0.62627208f, -0.66754049f, 0.51912451f, 
    -0.25483131f, 0.24645351f, 0.55895203f, 0.09864917f, -0.12294590f, 0.28483957f, 0.31078517f, 0.00804801f, 
    -0.18886408f, -0.32116538f, -0.16959262f, -0.30573735f, 0.10100167f, -0.56532508f, 0.17359045f, -0.01648983f, 
    -0.36757603f, 0.25355437f, -0.90291572f, 0.06100575f, 0.05291354f, -0.09028696f, 0.58888364f, 0.33601585f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.29831198f, 0.03410281f, 0.16130732f, 0.02307980f, 0.00835930f, -0.10034765f, 0.11964295f, -0.41807532f, 
    -0.07050013f, 0.44663900f, 0.00690693f, -0.34071526f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
