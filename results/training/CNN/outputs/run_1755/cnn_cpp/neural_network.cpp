#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.20472829f, -0.19410081f, -0.54217553f, -0.75528502f, -0.44043916f, -0.11997839f, 0.02343466f, 0.26077700f, 
    0.15166390f, -0.47122881f, -0.08594818f, 0.30863732f, 0.22988135f, -0.38192651f, -0.08879816f, -0.47182795f, 
    -0.24356957f, 0.04764760f, -0.33436266f, -0.20349324f, 0.26310760f, 0.43888471f, -0.33679482f, 0.26185015f, 
    0.34230980f, 0.16360308f, 0.34530088f, 0.59337962f, 0.41828302f, 0.11227067f, 0.44545144f, -0.20221967f, 
    0.10874621f, -0.25912204f, -0.02069888f, -0.04237651f, 0.28850493f, 0.23078780f, -0.33911598f, -0.24767585f, 
    -0.40190306f, 0.06871724f, -0.11146616f, 0.24039246f, -0.14052548f, -0.07482603f, 0.06258834f, -0.22828351f, 
    -0.10562652f, 0.16359101f, 0.89241379f, -0.42151684f, -0.17498595f, 0.01341968f, 0.29032555f, 0.42181641f, 
    0.41456163f, -0.13966252f, 0.13360691f, -0.37382296f, 0.15812588f, 0.16695268f, -0.15011393f, -0.22819634f, 
    0.00211429f, 0.12772462f, -0.14752130f, 0.28606191f, -0.35944575f, 0.06889866f, -0.03857336f, -0.05235736f, 
    -0.18424208f, -0.14251339f, 0.03566768f, -1.16199708f, -0.30899408f, -0.50215048f, -0.82180482f, -0.21097313f, 
    0.11162860f, -0.39019865f, -0.34847495f, -0.01515453f, 0.45303267f, -0.25813532f, -0.57912654f, -0.17075080f, 
    -0.56051356f, -0.16763102f, 0.26760122f, 0.04860779f, -0.16777404f, 0.06882746f, -0.09553021f, 0.06743326f, 
    0.07405870f, -0.16679655f, -0.23976333f, -0.34141359f, 0.47820538f, -0.09515885f, -0.04638452f, -0.08351405f, 
    -0.87822843f, -0.01535593f, 0.18374626f, -0.09585519f, -0.54297763f, -0.70136642f, -0.30956528f, -0.51418722f, 
    -0.15062714f, 0.27616918f, 0.15289676f, 0.22020766f, -0.25176221f, -0.37872797f, -0.01381295f, -0.54657191f, 
    -0.61274034f, -0.43126938f, -0.03625030f, -0.61854333f, -0.32426697f, -0.81940299f, -0.40904394f, -0.40777856f, 
    -0.28119242f, -0.02873969f, -0.36257142f, -0.40079704f, -0.06352344f, -0.53867537f, -0.57377470f, 0.51087207f, 
    0.61712855f, 0.14271134f, 0.08967163f, 0.31998911f, -0.02574971f, 0.19524466f, -0.37110570f, -0.05734647f, 
    -0.05380912f, 0.07836508f, 0.11299099f, -0.23802173f, -0.02470289f, 0.08129855f, -0.38903585f, -0.00971817f, 
    0.04411647f, 0.57481921f, 0.00939080f, -0.24086630f, 0.40846831f, 0.39925644f, -0.26783252f, -0.45523289f, 
    -0.11955325f, -0.17789258f, 0.09931253f, -0.03202501f, -0.07792099f, 0.21445142f, 0.26851648f, -0.02058253f, 
    -0.49792594f, 0.14271010f, -0.45228979f, -0.33886379f, 0.43875542f, 0.35577741f, 0.04321772f, 0.39913490f, 
    -1.14936590f, -0.46261719f, 0.95685369f, -0.14370611f, 0.29330796f, 1.02254677f, -0.36363128f, -0.55471897f, 
    -0.16006219f, 0.31773391f, -0.02558639f, 0.11585335f, -0.38394362f, 0.12985699f, 0.11455911f, -0.10220767f, 
    -0.11257078f, 0.30185315f, -0.02995829f, -0.02975544f, -0.09096948f, -0.03614496f, 0.08806947f, -0.06608235f, 
    0.33501661f, -0.56079847f, -0.12196123f, -0.01603910f, 0.70170122f, -0.62597710f, -0.45215717f, -0.22691314f, 
    -0.22303136f, 0.31494379f, -0.33972785f, -0.05388009f, 0.61508030f, -0.41852152f, -0.13812746f, 0.07963081f, 
    -0.01735181f, -0.15712805f, 0.32554975f, -0.27235287f, 0.09041234f, -0.20256709f, -0.00511965f, 0.21427998f, 
    0.43897900f, 0.21498105f, -0.09851569f, 0.07027135f, 0.22933900f, 0.23799436f, 0.37031350f, 0.04625586f, 
    -0.30536130f, 0.00514983f, 0.11212915f, -0.17779173f, 0.41499963f, -0.18053769f, -0.41089395f, 0.04529756f, 
    -0.34964645f, 0.32161760f, 0.03656863f, 0.15860291f, -0.02603067f, -0.04621014f, 0.50079674f, 0.20487046f, 
    0.11490835f, 0.43342555f, -1.21552312f, -0.13306110f, 0.65609819f, 0.56322479f, 0.21613756f, -0.81873101f, 
    -0.77224988f, -0.31845084f, 0.41038066f, 0.36340818f, 0.12243222f, 0.00819423f, -0.16669348f, 0.45202759f, 
    -0.29175863f, -0.18251815f, 0.06449304f, -0.07787251f, -0.44730487f, -0.39714238f, 0.09043394f, 0.05423919f, 
    0.17541824f, 0.12158503f, -0.07301018f, -0.16824159f, 0.86218029f, 0.01250422f, -0.38602617f, 0.19602168f, 
    -0.15681808f, 0.09753484f, 0.43686947f, -0.21716127f, -0.28487843f, -0.04845558f, 0.06481095f, 0.01634501f, 
    0.47004560f, -0.38058773f, 0.54207373f, -0.40201074f, -0.37217888f, 0.00261076f, -0.24087319f, -0.18682094f, 
    0.36687648f, 0.34254685f, -0.05111486f, 0.15117425f, -0.79363859f, -0.73632962f, -0.72242910f, -0.46473154f, 
    -0.91310042f, 0.79461092f, 0.30769143f, 0.42753538f, 0.13855223f, 0.19067678f, 0.02331415f, 0.03610003f, 
    -0.02643308f, 0.28397033f, -0.13838314f, -0.14118785f, 0.11801251f, -0.24001640f, -0.32068831f, -0.04302783f, 
    -0.26910910f, -0.17737798f, 0.24517088f, 0.08247927f, 0.02464821f, -0.80134040f, -0.15251049f, -0.41920477f, 
    0.10362011f, 0.60093230f, 0.39639008f, 0.26315588f, 0.25734764f, 0.61688030f, 0.33298615f, 0.28984228f, 
    0.25739101f, -0.01519638f, -0.02942116f, -0.16823727f, -0.28530458f, -0.26901200f, -0.19909050f, -0.00535750f, 
    -0.19312924f, 0.26310670f, 0.30176204f, 0.05844759f, 0.14981598f, -0.10952678f, -0.55786693f, -0.21429881f, 
    0.53736925f, 0.93285006f, 0.83056414f, -0.12233176f, -0.50095105f, -0.54715413f, -0.19136579f, -0.15829454f, 
    -0.07289949f, -0.46842656f, -0.14795868f, 0.32122844f, 0.25730556f, -0.16873592f, -0.24420802f, 0.26226211f, 
    0.17945014f, 0.41140908f, 0.09328403f, -0.18026885f, -0.07674833f, -0.14499311f, -0.06315096f, -0.23920944f, 
    0.08524197f, 0.43260756f, 0.44236046f, 0.04931275f, -0.06570800f, 0.21480054f, 0.08551558f, 0.21241394f, 
    0.20059715f, 0.15415944f, -0.39868599f, 0.15841937f, 0.41100702f, -0.26577684f, -0.05290638f, 0.02091547f, 
    -0.09566402f, -0.20145836f, -0.16988440f, -0.04425733f, -0.22723681f, -0.36585623f, -0.24896750f, 0.01374195f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08147192f, 0.15905325f, 0.30954239f, -0.26320750f, 0.19705221f, 0.17417592f, 0.23293293f, 0.08445572f, 
    0.40922138f, 0.33898631f, 0.11169700f, 0.15708038f, 0.28545937f, 0.26317060f, 0.25605959f, -0.03275951f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00908999f, 0.00210119f, 0.09992589f, -0.17484051f, -0.03218753f, 0.13653474f, 0.12848090f, -0.06285638f, 
    0.00791342f, -0.15859930f, 0.04648351f, 0.13760424f, -0.23113075f, -0.43967840f, -0.08311521f, 0.32564580f, 
    -0.04632755f, 0.04948623f, 0.04062982f, -0.08268040f, 0.02537760f, -0.16343299f, 0.05007681f, -0.00370679f, 
    0.11875515f, -0.08494837f, 0.08072741f, -0.00096303f, 0.09750303f, -0.11738230f, 0.01452864f, -0.06001295f, 
    0.09843893f, -0.09641015f, 0.06086352f, 0.07026543f, -0.02748634f, 0.32317901f, 0.18428022f, -0.13448480f, 
    -0.03701578f, -0.00791409f, -0.19271772f, -0.01484937f, -0.07971589f, -0.00410036f, -0.05498927f, -0.04414153f, 
    0.08682675f, 0.02476541f, -0.17759138f, -0.29612467f, 0.16600895f, 0.14042196f, 0.11103507f, 0.07994599f, 
    0.13742360f, 0.06857916f, -0.05167101f, 0.14499719f, -0.09481169f, 0.16481279f, -0.02364360f, -0.15932989f, 
    0.03670429f, 0.07588473f, 0.08387694f, 0.11547834f, -0.01260088f, -0.00960457f, 0.06447703f, 0.00897632f, 
    0.01197738f, -0.10156397f, 0.16502012f, 0.09800724f, 0.12900122f, 0.11511418f, -0.04848472f, 0.06813587f, 
    -0.01666522f, -0.13208297f, 0.00453474f, 0.07504295f, 0.69273907f, -0.38465649f, 0.33408606f, -0.26754463f, 
    0.22207971f, 0.14717694f, -0.33435658f, 0.01838545f, 0.05941216f, -0.05703792f, 0.03225777f, 0.17777041f, 
    -0.09903236f, -0.08121685f, -0.07757446f, 0.04953709f, 0.09861498f, 0.17855851f, 0.18063807f, 0.11465765f, 
    0.09596633f, -0.00163592f, 0.10182866f, 0.20293508f, -0.01450326f, -0.25460154f, 0.05004771f, -0.03527073f, 
    -0.07322942f, 0.08509648f, -0.01635927f, -0.07230017f, 0.10407235f, 0.03997236f, 0.15764618f, 0.16499254f, 
    -0.34797856f, 0.13044858f, 0.24938317f, -0.09456625f, -0.04420752f, 0.17247282f, -0.02621649f, 0.15060812f, 
    0.01252009f, -0.06066036f, -0.08480251f, 0.05339291f, -0.35572451f, 0.11818878f, -0.20035522f, 0.12075999f, 
    0.07719666f, -0.15472111f, 0.24312988f, -0.08891812f, -0.02338543f, 0.19397146f, -0.10844101f, 0.13227652f, 
    0.16756144f, 0.20963524f, -0.08159196f, -0.01896151f, -0.05979022f, -0.01444521f, -0.06889924f, 0.16107069f, 
    0.07266854f, 0.13512588f, 0.15580557f, -0.10757722f, -0.17806849f, 0.05087813f, 0.45275599f, 0.29284060f, 
    -0.01848873f, -0.05067710f, -0.03290099f, -0.23830542f, -0.00810457f, 0.04058283f, 0.04476121f, -0.05623638f, 
    -0.02956949f, -0.37089330f, -0.06612388f, -0.07754795f, 0.04255233f, 0.15188017f, 0.11855060f, 0.07071412f, 
    -0.01152588f, 0.00220511f, -0.06080764f, -0.22665158f, -0.00996474f, 0.02929111f, -0.00900074f, 0.17310891f, 
    -0.09863951f, -0.05705306f, -0.09265174f, -0.09241455f, -0.02272270f, -0.09761915f, -0.13721363f, -0.04486973f, 
    0.09406569f, 0.18103918f, -0.01462140f, -0.01780454f, -0.03826484f, 0.13327083f, 0.10689911f, -0.11299356f, 
    -0.08580442f, -0.13829172f, -0.02892383f, -0.17227764f, -0.10156646f, -0.09093829f, -0.02822608f, 0.09766611f, 
    0.13042943f, -0.28205147f, 0.06434551f, -0.25888193f, -0.12756839f, -0.01588485f, 0.05416383f, -0.00281694f, 
    0.43257171f, -0.17009751f, 0.02568846f, -0.03979399f, -0.29835480f, -0.28694782f, -0.05719430f, 0.01853792f, 
    0.03894038f, 0.10026752f, -0.02687786f, 0.13851278f, -0.05643133f, 0.13360530f, 0.01245245f, 0.18417135f, 
    0.00671994f, 0.20539109f, -0.11635195f, 0.00672194f, -0.02110795f, 0.04551510f, -0.05496967f, -0.10316829f, 
    0.11690395f, 0.07676326f, 0.06866457f, -0.04161587f, 0.06898694f, 0.08177226f, 0.00103749f, -0.03217662f, 
    0.10537251f, -0.03429269f, 0.00221053f, 0.20233780f, 0.23337315f, 0.13612981f, 0.00016433f, 0.05284646f, 
    -0.07893800f, -0.00250363f, 0.00437274f, 0.12751861f, 0.07096940f, 0.29583657f, 0.15507638f, -0.10842112f, 
    -0.06022840f, -0.14701724f, 0.14864859f, 0.02022004f, 0.10284071f, -0.00480112f, 0.12113896f, 0.05848803f, 
    -0.05348076f, 0.00816703f, 0.03960458f, -0.21184042f, 0.78602433f, -0.71753514f, 0.28006423f, -0.08794370f, 
    -0.16837874f, -0.00279555f, -0.11910608f, -0.01582151f, 0.00897176f, -0.01053158f, 0.00716651f, 0.24926606f, 
    -0.04472754f, -0.06034096f, 0.06490399f, -0.12219986f, -0.08765480f, 0.24196725f, 0.00964668f, -0.00829026f, 
    -0.02964147f, -0.03539580f, 0.05852271f, -0.16594723f, -0.06490306f, -0.02931517f, 0.10334151f, 0.11536033f, 
    0.20509057f, -0.14418513f, -0.02612526f, 0.11702169f, -0.03265689f, -0.07286226f, -0.26840892f, -0.47013116f, 
    -0.11787277f, 0.34468716f, 0.02294621f, 0.11419615f, 0.16293871f, 0.13642494f, 0.08790372f, -0.03024273f, 
    -0.09265088f, -0.00092087f, 0.00923536f, 0.28391033f, -0.09754482f, -0.30547082f, -0.05296462f, 0.26557508f, 
    0.15917493f, 0.14422336f, 0.00017743f, -0.11539910f, -0.05949494f, -0.24321039f, -0.32618535f, 0.06995269f, 
    0.45225129f, 0.30199009f, 0.24585155f, 0.17095113f, -0.10181302f, 0.00823333f, 0.18604706f, -0.03872395f, 
    0.12830348f, 0.12681806f, 0.04065603f, 0.14796643f, 0.10043152f, 0.06738063f, -0.19365434f, 0.30620256f, 
    -0.12683162f, -0.14640737f, 0.07594239f, -0.08772134f, -0.02194433f, -0.20027614f, -0.15346618f, 0.02986030f, 
    0.26248190f, 0.09290144f, 0.00475023f, -0.30786231f, -0.01061388f, -0.00029012f, -0.08563142f, 0.09149309f, 
    0.01102217f, 0.07101537f, -0.22396396f, 0.00501933f, 0.12089772f, 0.05093234f, -0.17310765f, 0.32363588f, 
    -0.05778628f, -0.12389328f, -0.04751012f, -0.16493316f, 0.07744110f, 0.04219305f, -0.19908991f, 0.13711368f, 
    -0.05456782f, 0.17774659f, 0.01719710f, 0.12846024f, 0.04374154f, -0.08854694f, 0.11473205f, 0.14545242f, 
    -0.11980326f, 0.09903564f, -0.13104925f, 0.00575397f, 0.06378395f, 0.30430630f, 0.13523151f, -0.19172467f, 
    -0.04831352f, -0.13403995f, -0.04238650f, 0.06181071f, -0.05037324f, 0.02275027f, -0.12311629f, 0.14291607f, 
    0.25188789f, 0.07400281f, 0.06611641f, -0.02852982f, -0.12781990f, 0.02322418f, -0.03420153f, 0.01742468f, 
    0.05462398f, 0.27701047f, 0.04289008f, -0.02576351f, 0.17529024f, -0.09790651f, -0.10920547f, 0.33691177f, 
    -0.06957527f, 0.11047225f, -0.10843494f, 0.13524386f, -0.03180418f, 0.01274664f, -0.04281395f, 0.00066724f, 
    -0.10633422f, -0.17295432f, 0.11381821f, 0.19078077f, -0.08638080f, -0.02750024f, 0.14219306f, -0.01428439f, 
    -0.09391909f, 0.09293375f, 0.18395580f, 0.04935296f, -0.27642518f, -0.22586711f, -0.00635272f, 0.10513312f, 
    0.02703338f, 0.06353077f, 0.22114103f, 0.24304217f, -0.11148643f, 0.03369585f, -0.07919648f, 0.06699012f, 
    -0.02295885f, 0.37477311f, -0.20869884f, 0.07805763f, 0.00246069f, -0.19801658f, 0.18553147f, -0.22489482f, 
    -0.07539004f, 0.20060162f, -0.08821543f, -0.08314418f, 0.01452587f, 0.17954859f, 0.00250563f, 0.01344887f, 
    -0.05731300f, -0.21768124f, 0.11694869f, 0.06242373f, 0.11924481f, 0.06361148f, 0.10382918f, 0.01105681f, 
    -0.18526605f, -0.09098086f, -0.28609243f, 0.25713184f, -0.03811642f, -0.13052303f, 0.10932393f, -0.25519848f, 
    -0.01559712f, -0.02691079f, 0.02382156f, -0.24075164f, 0.07630596f, 0.00650665f, 0.03188301f, -0.06712025f, 
    0.15738410f, -0.00374861f, -0.00329259f, 0.07024417f, -0.23026453f, -0.08441787f, -0.15512677f, -0.14664991f, 
    -0.02365709f, 0.06836808f, -0.36729917f, 0.16408390f, -0.03872650f, -0.03740747f, -0.08108284f, 0.02914580f, 
    -0.12518173f, -0.06947806f, -0.02254119f, 0.05970180f, 0.26664028f, -0.19312330f, 0.05185846f, 0.09220879f, 
    -0.13756640f, 0.02344180f, -0.09451173f, -0.01393377f, -0.03270631f, -0.27262968f, 0.08359125f, -0.00643426f, 
    0.23657121f, 0.18241730f, 0.45265734f, 0.08642989f, -0.08842178f, 0.01783032f, 0.15194666f, -0.14729838f, 
    -0.02006106f, 0.11313466f, 0.07546571f, 0.09610464f, 0.26687282f, 0.07213327f, -0.09791798f, 0.21174188f, 
    0.07608180f, 0.05414845f, 0.05085431f, 0.07897118f, -0.09147344f, -0.11244178f, -0.17197938f, 0.01259553f, 
    -0.09484053f, 0.40235248f, -0.30371907f, -0.15609655f, -0.09328083f, 0.11991502f, 0.01789532f, 0.17759706f, 
    0.04228147f, 0.04501099f, 0.20972747f, 0.05831433f, 0.01877277f, 0.11334515f, -0.04546773f, -0.03382722f, 
    -0.02623233f, -0.00865214f, -0.01806875f, -0.07396165f, 0.19349641f, -0.06940682f, 0.14020050f, -0.05303467f, 
    -0.01860753f, 0.16014999f, 0.15130456f, 0.00238743f, -0.04239893f, -0.05850890f, -0.04180480f, 0.02210201f, 
    -0.02992844f, -0.05754561f, -0.07605782f, -0.04588565f, 0.30831301f, 0.11663583f, 0.07805540f, 0.01157144f, 
    -0.06816388f, 0.01337629f, -0.07727901f, -0.06164841f, 0.02686436f, 0.13821636f, 0.06680161f, 0.04538155f, 
    0.23328555f, -0.00158724f, 0.16019997f, 0.09609802f, 0.01527500f, 0.08298910f, -0.03477396f, 0.11336696f, 
    0.09509733f, -0.04068138f, 0.07854684f, 0.00343731f, -0.07200417f, 0.10470825f, 0.07019167f, 0.00762295f, 
    -0.00033045f, 0.07737423f, -0.16639724f, -0.05377768f, -0.01187943f, 0.03140134f, -0.02758849f, -0.16992976f, 
    0.07270689f, 0.03565689f, 0.12504229f, -0.10841340f, 0.00722019f, -0.14515983f, 0.05168306f, -0.00754846f, 
    0.00503558f, -0.03327103f, 0.00497517f, 0.22472659f, -0.00590830f, -0.00177484f, 0.17454159f, 0.07773597f, 
    -0.15894352f, 0.00623422f, -0.10594699f, -0.05602354f, -0.03295882f, -0.01199334f, 0.08826679f, -0.06401747f, 
    0.08422466f, -0.06139109f, 0.25621924f, -0.02939534f, 0.04112126f, 0.07616150f, 0.20181850f, 0.06542303f, 
    -0.06441472f, 0.20765767f, -0.15667336f, -0.08359087f, 0.25995696f, -0.56978124f, 0.19317578f, 0.19572979f, 
    -0.18603019f, 0.18113358f, 0.03872147f, 0.15127572f, -0.02590814f, -0.05618704f, 0.14119212f, 0.11876094f, 
    -0.06167893f, -0.03104639f, 0.09988302f, -0.07031927f, -0.08461149f, 0.13091917f, 0.06357976f, 0.22811832f, 
    -0.07742998f, -0.08424552f, -0.03335664f, -0.03075463f, 0.04657236f, 0.11680431f, 0.00702510f, 0.10496011f, 
    0.05507439f, 0.13471955f, 0.02683427f, 0.13708265f, -0.09835021f, 0.00096019f, -0.08606391f, -0.15629689f, 
    -0.37482241f, -0.01550354f, -0.18217969f, 0.21053053f, -0.06900403f, 0.13436410f, -0.06354321f, -0.02663078f, 
    0.05138548f, -0.01632887f, -0.10225088f, -0.07165785f, 0.17568500f, -0.04873301f, 0.19239032f, 0.00345307f, 
    0.02183715f, -0.09692515f, 0.16035797f, 0.14228076f, -0.05895115f, -0.09985142f, -0.03189487f, -0.00031110f, 
    0.41275740f, 0.27410531f, 0.27645025f, -0.01959411f, -0.19496128f, -0.10477165f, 0.04721051f, 0.05753453f, 
    -0.02485336f, 0.03427815f, 0.01598562f, -0.07562145f, 0.11029578f, 0.18313593f, -0.17364381f, 0.03856481f, 
    -0.06220956f, 0.03858435f, 0.02428826f, 0.11937106f, -0.03653525f, -0.03780084f, -0.06456736f, -0.09190708f, 
    -0.10328487f, -0.25460202f, -0.24019793f, -0.07862302f, 0.05138851f, -0.02327235f, -0.12209897f, 0.09500186f, 
    -0.00470012f, -0.05395167f, 0.08062433f, 0.06222902f, 0.03171242f, 0.10706975f, 0.01287737f, 0.02007123f, 
    -0.05209598f, -0.00263654f, 0.02715807f, 0.00943437f, 0.11898755f, 0.04199689f, -0.23521049f, 0.17879756f, 
    0.05128143f, -0.07726189f, -0.05276494f, 0.00912507f, -0.00158558f, 0.00044019f, -0.07413758f, -0.00119957f, 
    0.02490261f, -0.01016830f, -0.01790180f, 0.05535769f, 0.02421147f, 0.02799559f, 0.04290646f, 0.01927839f, 
    -0.05885363f, 0.02228989f, 0.06110638f, -0.00833440f, 0.04435183f, 0.04595659f, -0.06377674f, -0.03054362f, 
    0.00170760f, -0.03492954f, 0.00677651f, 0.04667694f, -0.06060037f, -0.06965263f, 0.04224459f, 0.05485103f, 
    0.00062588f, -0.07544891f, -0.03389979f, 0.04868557f, -0.02142814f, 0.02318481f, -0.07462792f, 0.03167932f, 
    -0.03788436f, -0.05681634f, -0.06882061f, 0.05532912f, 0.06458265f, -0.05725130f, 0.04234140f, -0.00881094f, 
    -0.03178374f, 0.05257948f, -0.07915045f, 0.00192293f, -0.03467129f, -0.03171169f, 0.04537249f, -0.01423599f, 
    0.04209333f, -0.04363044f, -0.02387728f, -0.06492009f, 0.00279085f, -0.00656958f, 0.03610757f, 0.04804176f, 
    -0.01141836f, -0.04138186f, -0.00992840f, -0.03275210f, 0.05941914f, -0.04296726f, 0.02785780f, 0.02139091f, 
    -0.04579836f, -0.01251456f, -0.08414261f, 0.01796483f, 0.01062291f, -0.02050057f, -0.00195482f, 0.03206945f, 
    -0.04946649f, -0.07739349f, -0.07863601f, -0.05056693f, 0.02626820f, 0.02308779f, 0.04393752f, -0.06296705f, 
    -0.05833746f, 0.04679416f, -0.03153080f, -0.08143279f, -0.05186232f, 0.02077367f, 0.01832298f, -0.01431751f, 
    -0.04713098f, -0.07041671f, 0.00354312f, 0.04114152f, 0.03955286f, -0.04611715f, -0.04824421f, -0.01437683f, 
    -0.03446952f, -0.04767497f, 0.05497153f, -0.00037377f, -0.04538172f, -0.03700985f, -0.04452422f, 0.05062914f, 
    0.04401060f, -0.00866605f, 0.05537948f, -0.02085594f, -0.03319712f, -0.01893374f, -0.04323945f, 0.01386183f, 
    0.05286744f, -0.05270573f, -0.01915690f, -0.02746773f, -0.03728956f, -0.05980341f, -0.00918570f, 0.00350784f, 
    0.05556395f, -0.06676947f, 0.03715472f, 0.01501894f, 0.02330821f, 0.01454780f, -0.07144594f, 0.04406513f, 
    0.01466827f, -0.05100400f, -0.05245927f, 0.02127028f, -0.02588121f, -0.03031072f, -0.00165996f, -0.03761808f, 
    -0.01038832f, 0.04904191f, -0.04442188f, 0.02071331f, -0.01429789f, -0.03955329f, 0.00760053f, -0.07029194f, 
    -0.07125340f, 0.05569762f, 0.00804831f, -0.07953622f, -0.02295411f, -0.05947204f, -0.07070110f, 0.06789585f, 
    -0.01011333f, -0.00082199f, 0.00640485f, -0.02084028f, 0.00871376f, -0.00592631f, -0.04832966f, -0.04144328f, 
    0.04927434f, 0.03497390f, -0.07823821f, 0.02232092f, 0.02842893f, -0.05502133f, -0.06429274f, 0.02596286f, 
    0.03321481f, -0.05059087f, 0.05611046f, -0.06963278f, -0.01123057f, -0.06275743f, 0.02787723f, -0.06061205f, 
    -0.06436090f, -0.04570902f, -0.04576101f, 0.01224922f, 0.05318576f, 0.04053001f, -0.06016717f, 0.03595933f, 
    0.27305508f, 0.08685004f, 0.03398452f, 0.29286298f, 0.07049713f, 0.23070326f, 0.03803432f, 0.29933739f, 
    -0.05195174f, 0.06188255f, 0.03152809f, -0.01959593f, -0.14398018f, -0.14225550f, -0.07190015f, 0.00077009f, 
    -0.07164892f, -0.09937489f, 0.00276496f, -0.11368022f, -0.01523946f, 0.06145457f, -0.01257157f, -0.00046329f, 
    0.03017904f, 0.01371405f, -0.16572161f, -0.03402137f, -0.10800055f, -0.12148979f, -0.08189341f, 0.00768838f, 
    -0.15086868f, 0.22451505f, 0.18283559f, 0.01874194f, 0.30865428f, 0.10095942f, -0.22623196f, 0.09734233f, 
    0.19683422f, -0.10202654f, -0.07813750f, -0.07559220f, -0.12217785f, -0.02448943f, -0.16724445f, -0.03075928f, 
    -0.01244095f, -0.12530935f, 0.13315056f, 0.24059242f, 0.07151260f, 0.00736346f, -0.10981391f, 0.12102480f, 
    -0.01361357f, -0.09651469f, -0.00710749f, -0.15996064f, 0.09248366f, -0.10615534f, 0.00973556f, 0.21345678f, 
    0.11491261f, 0.11971238f, 0.04925836f, 0.29398558f, -0.16152312f, 0.00465682f, 0.05488443f, 0.07883427f, 
    0.07941899f, 0.02812034f, 0.10686325f, 0.00079273f, -0.11134693f, 0.02976832f, 0.03790798f, -0.18921670f, 
    -0.07194419f, 0.00931530f, -0.12568143f, 0.04560458f, -0.04982617f, 0.45960543f, 0.06603961f, 0.24770284f, 
    -0.04039437f, 0.24176249f, 0.05007526f, -0.02948196f, 0.01921385f, 0.06392431f, 0.16922894f, 0.11451562f, 
    -0.02089449f, 0.35817710f, 0.13942213f, 0.15710966f, -0.10045371f, 0.17921372f, 0.01321831f, -0.12595916f, 
    0.01272504f, -0.10054767f, 0.03867899f, -0.00535528f, -0.11070102f, 0.03408325f, -0.04776307f, -0.02846424f, 
    -0.00879056f, -0.03321292f, -0.11332992f, -0.07118364f, 0.01917889f, 0.13959718f, 0.07757705f, 0.04589680f, 
    -0.07796980f, 0.52077901f, -0.07598784f, -0.15495524f, 0.17441139f, -0.09905121f, 0.15379418f, 0.05796806f, 
    -0.11390895f, -0.00038011f, -0.08775324f, 0.10244662f, 0.11613249f, -0.08220778f, 0.02602208f, -0.03270014f, 
    -0.16487588f, 0.04029583f, 0.00281890f, -0.00659503f, 0.05818710f, 0.05830541f, 0.12817979f, 0.24963757f, 
    0.26459286f, 0.07484739f, 0.00119603f, 0.22600451f, 0.09788164f, 0.14321800f, 0.17520902f, 0.04445795f, 
    0.10422696f, 0.09849701f, -0.09301149f, -0.09387586f, -0.22812252f, 0.00473460f, -0.28772169f, -0.14315024f, 
    -0.08185033f, -0.00890323f, -0.05804860f, -0.00958858f, -0.02066243f, 0.09526545f, 0.07173616f, 0.07612007f, 
    -0.04499689f, 0.41827485f, -0.23759864f, -0.26692981f, -0.11167713f, -0.08057655f, -0.17544384f, 0.01208622f, 
    0.10340021f, 0.00184441f, -0.04708073f, -0.08412380f, -0.19369724f, -0.23032224f, -0.07256150f, -0.07396460f, 
    -0.04684273f, 0.04467932f, -0.01406672f, -0.01109365f, 0.07536950f, -0.12101363f, -0.02921123f, -0.30035201f, 
    0.19864444f, 0.18308000f, 0.05144693f, 0.12932406f, -0.15568627f, 0.11167882f, -0.02936901f, 0.03477847f, 
    -0.04571328f, 0.03286652f, -0.04882560f, -0.15215990f, -0.05906596f, -0.04769613f, -0.13235343f, -0.03438659f, 
    -0.13584606f, -0.20347296f, -0.07953855f, 0.10355327f, -0.01601834f, -0.10343140f, -0.02424197f, -0.11938816f, 
    0.14326374f, 0.02865453f, -0.10755869f, 0.04291087f, -0.18992889f, -0.08876906f, -0.20026831f, 0.18712224f, 
    0.15934350f, 0.13888296f, 0.11389941f, 0.09084121f, -0.33695042f, -0.07129464f, -0.13564417f, 0.34045693f, 
    0.02463698f, -0.15031077f, -0.06754714f, -0.03169519f, -0.02506324f, 0.12622383f, 0.03170636f, -0.00979464f, 
    -0.11568944f, 0.09341643f, 0.10070620f, -0.03146301f, 0.19090359f, 0.01898224f, -0.04079364f, -0.00370583f, 
    0.10293794f, -0.16027546f, 0.04208862f, 0.03462964f, 0.07691846f, -0.17274635f, 0.14952280f, 0.06264694f, 
    -0.10409533f, -0.01408120f, 0.08025267f, 0.11826626f, 0.03895040f, 0.20182931f, 0.05590997f, 0.11736816f, 
    -0.06993991f, 0.04608716f, 0.05100863f, 0.07944084f, 0.04955216f, -0.01941434f, 0.26706272f, -0.14850661f, 
    -0.01673346f, 0.04046790f, 0.06995878f, -0.08772414f, 0.03154418f, -0.08186866f, 0.27866611f, 0.05191858f, 
    -0.04970834f, 0.11017885f, -0.04525146f, 0.10671426f, -0.03192990f, -0.06475432f, 0.04055768f, 0.06464171f, 
    0.15018085f, -0.16753626f, 0.16635774f, 0.12203649f, -0.17416735f, 0.44050390f, 0.14179027f, 0.08389768f, 
    0.05342255f, 0.12626775f, 0.13384418f, -0.09794984f, -0.13616632f, 0.05659596f, -0.12794322f, 0.04860713f, 
    0.01148574f, -0.06717391f, 0.06801651f, 0.10504944f, -0.01909472f, -0.04564852f, -0.12276076f, -0.14591748f, 
    -0.23167036f, 0.30579567f, -0.34513336f, 0.00171259f, 0.06319933f, -0.04304422f, 0.16293578f, 0.08428007f, 
    -0.02297723f, -0.06373265f, -0.04549781f, 0.13790745f, 0.38191003f, -0.35160434f, -0.00115162f, -0.02825134f, 
    -0.03532135f, 0.11816376f, 0.00387900f, -0.00501566f, 0.08107838f, -0.11656068f, 0.07768741f, 0.04740119f, 
    0.07889989f, 0.47551900f, 0.55409366f, 0.44371209f, -0.00600339f, 0.16067681f, 0.26860294f, -0.13112441f, 
    0.01687408f, 0.05202411f, 0.06763421f, 0.17070755f, -0.09869967f, 0.03300979f, -0.30755812f, 0.11438373f, 
    -0.08055293f, -0.24917614f, -0.02597876f, 0.03179657f, -0.00626217f, -0.16586779f, -0.17839417f, 0.02018340f, 
    -0.10976464f, 0.40473390f, -0.22013374f, 0.06811776f, -0.02725251f, -0.07708099f, -0.12424222f, 0.11747299f, 
    -0.01218561f, 0.02707203f, -0.13712913f, 0.02615883f, -0.12696387f, -0.13033549f, -0.14995018f, 0.15501325f, 
    -0.01910234f, -0.08407980f, -0.08870284f, -0.07392870f, 0.12509055f, -0.03759110f, -0.03118131f, -0.05636048f, 
    0.27508265f, 0.38355207f, 0.29830694f, -0.10773789f, 0.09666296f, 0.05386915f, -0.04299638f, 0.02889912f, 
    0.02904331f, 0.10157721f, -0.17992902f, -0.11965475f, 0.02136739f, 0.00378353f, 0.01063892f, 0.05425892f, 
    0.08064571f, -0.05975538f, -0.10008893f, 0.03671884f, 0.06085372f, -0.06970381f, 0.05183657f, 0.08135272f, 
    0.07226688f, 0.08511981f, -0.15549815f, 0.10083560f, 0.05368338f, 0.05575172f, -0.12720184f, 0.15277731f, 
    0.20015351f, 0.17864785f, 0.06739995f, 0.04561235f, -0.29165217f, 0.17659257f, 0.29080069f, 0.17138489f, 
    0.12138565f, -0.07571237f, 0.09596045f, -0.02511415f, -0.03773564f, 0.02129124f, 0.11292628f, 0.11788439f, 
    0.19856349f, 0.10405529f, 0.17984119f, -0.20440355f, -0.04406529f, -0.03655088f, -0.06212076f, -0.14970115f, 
    0.07123217f, -0.00168707f, 0.13052946f, 0.09698182f, -0.14040029f, 0.00188321f, 0.52853638f, -0.17977247f, 
    0.11988566f, -0.04070134f, -0.08526383f, -0.08574978f, 0.09927240f, -0.04181430f, -0.02186517f, 0.04960938f, 
    0.08164785f, -0.18868735f, 0.11126279f, 0.10221522f, 0.12917419f, -0.07085547f, 0.05814620f, 0.10345304f, 
    -0.12379651f, 0.07212782f, 0.02898713f, -0.01266480f, -0.17042081f, 0.30790433f, -0.33105153f, 0.07352637f, 
    0.16771120f, -0.12071888f, 0.20575815f, 0.08534526f, 0.05571736f, 0.23699889f, -0.04019975f, -0.07823568f, 
    -0.12223648f, 0.18217902f, 0.12919021f, -0.08394524f, -0.13450195f, 0.26817429f, -0.09470492f, 0.20723070f, 
    -0.11651979f, 0.07699393f, 0.04623716f, 0.00285073f, -0.09338441f, -0.05697590f, -0.05713784f, 0.16684133f, 
    0.07109176f, 0.22723003f, -0.04437941f, 0.04990211f, -0.01303984f, -0.15517287f, -0.14915824f, -0.15860796f, 
    -0.72624886f, -0.15615295f, 0.12750722f, 0.16558966f, -0.07820467f, -0.10377040f, 0.02074009f, -0.04904952f, 
    -0.04695221f, -0.09029220f, 0.01277527f, -0.08172396f, 0.38644660f, -0.19822195f, 0.06471305f, -0.10087001f, 
    0.07758237f, 0.19555917f, -0.11704584f, 0.07982691f, 0.09237032f, -0.14975055f, 0.13248341f, -0.01929111f, 
    -0.12263227f, 0.63986862f, 0.35942149f, 0.05110780f, 0.04171709f, -0.12218264f, -0.02072503f, -0.18367119f, 
    0.01520889f, 0.00752795f, -0.09450062f, -0.11037589f, -0.29459316f, -0.01521518f, -0.01410848f, 0.33089450f, 
    0.01786591f, -0.01553039f, -0.10110661f, 0.06921184f, 0.08108326f, -0.00633218f, 0.07074896f, -0.05745345f, 
    -0.35218602f, 0.18313047f, 0.03007263f, 0.45597279f, 0.14871843f, 0.00925353f, -0.02485392f, 0.27275732f, 
    0.14427261f, 0.05156235f, 0.06870365f, 0.15975307f, -0.01517826f, -0.07654578f, 0.01704811f, 0.06251188f, 
    0.01841442f, -0.03641094f, -0.07177509f, 0.00623588f, 0.10697982f, 0.12175934f, 0.05334364f, 0.17849086f, 
    -0.36814970f, -0.45279744f, -0.35322735f, -0.21650447f, 0.14956175f, -0.06917109f, -0.00089209f, -0.03392715f, 
    -0.08759369f, -0.10470072f, -0.00243518f, 0.05029883f, 0.11034565f, 0.10037132f, 0.01323145f, 0.13958934f, 
    -0.06998296f, 0.06930493f, 0.01311458f, 0.05535790f, 0.16076978f, 0.04468413f, 0.06710823f, 0.09464191f, 
    0.17250530f, -0.03127909f, 0.14121144f, 0.09273948f, 0.07045682f, 0.04878898f, 0.04484964f, 0.04523329f, 
    0.28374121f, 0.19880380f, 0.13579187f, -0.05948231f, 0.05320783f, -0.29604062f, -0.38498518f, -0.24131519f, 
    0.12350148f, -0.00482590f, -0.26384830f, 0.03020366f, 0.01717671f, -0.06026454f, -0.06492355f, 0.00412554f, 
    0.13405813f, 0.09871085f, -0.04191690f, 0.00281374f, -0.12481857f, -0.22714265f, 0.08732203f, 0.05488227f, 
    -0.24627401f, 0.12320546f, 0.04650183f, -0.07070909f, 0.09204860f, 0.20049578f, -0.32686532f, 0.28535315f, 
    0.43331593f, 0.01023008f, 0.02993788f, 0.25709808f, -0.14035936f, -0.05808111f, -0.05235206f, -0.01137986f, 
    0.13779049f, 0.24484786f, -0.12427092f, 0.20087272f, -0.15548167f, 0.04240609f, 0.09209818f, -0.21393171f, 
    -0.08990781f, 0.03062205f, -0.12199934f, -0.05974183f, 0.56295425f, -0.35016546f, 0.08801486f, -0.10566998f, 
    0.04159943f, 0.33682540f, -0.36358732f, -0.00606129f, -0.01129223f, -0.16949992f, -0.02126603f, 0.11497602f, 
    -0.23120965f, 0.11124849f, 0.12086021f, 0.00547095f, 0.13468719f, 0.16451685f, -0.00721728f, -0.23714747f, 
    -0.03400226f, -0.09444347f, 0.04109267f, 0.02024888f, 0.15635492f, 0.04529183f, 0.10638052f, 0.04219406f, 
    -0.04416090f, 0.06275593f, 0.11062375f, 0.09346636f, 0.02898559f, -0.00805831f, 0.04473205f, 0.02422293f, 
    0.04102126f, 0.05516473f, -0.13292894f, 0.25282416f, -0.18258339f, 0.11316543f, -0.10240833f, -0.17630567f, 
    0.06588460f, -0.10863926f, -0.14809258f, -0.01957100f, -0.09586620f, 0.20576929f, 0.00360544f, 0.12740724f, 
    0.00770636f, 0.00409047f, 0.20007768f, -0.12584780f, 0.05135543f, 0.13908014f, -0.06122487f, 0.03875744f, 
    0.34090787f, -0.49742237f, -0.34889254f, -0.14409758f, -0.04070212f, -0.03238222f, -0.14417052f, 0.13937640f, 
    0.19565931f, -0.00653862f, 0.08911200f, -0.13614398f, 0.31386748f, 0.08509552f, 0.07564618f, 0.10972848f, 
    0.08374398f, 0.02129210f, 0.01478027f, 0.05290295f, -0.05564093f, -0.05752398f, -0.07120148f, -0.04272979f, 
    0.22285150f, -0.01572175f, -0.00066908f, -0.20121810f, -0.22548987f, -0.07867577f, -0.08019194f, -0.05519180f, 
    -0.08278228f, 0.07181309f, 0.07829584f, 0.01812409f, 0.04666077f, 0.03064730f, 0.01115220f, 0.15316395f, 
    0.10210294f, -0.00566956f, 0.01811531f, -0.00670070f, 0.27714014f, -0.09438340f, -0.17670542f, 0.04431854f, 
    -0.08196379f, -0.02573291f, -0.13725923f, -0.11599709f, 0.07957762f, 0.34149122f, 0.08052233f, 0.10717159f, 
    -0.13413690f, -0.05276604f, 0.07783973f, 0.10107898f, -0.10906373f, 0.00121578f, 0.07232615f, 0.15252621f, 
    -0.05272420f, -0.06893579f, -0.07207708f, -0.11574971f, -0.06970046f, -0.02202137f, 0.12685710f, 0.11479545f, 
    0.24917950f, -0.09332549f, 0.00994383f, 0.07117333f, -0.02217709f, -0.07277580f, -0.06145668f, -0.15290308f, 
    0.01388958f, 0.06709678f, 0.03513710f, 0.10267275f, -0.16739960f, 0.30605927f, 0.21360092f, 0.29232866f, 
    -0.11432282f, -0.19788642f, -0.06430377f, -0.00043781f, -0.04885444f, -0.04447236f, -0.18161960f, -0.05160766f, 
    0.07615417f, -0.06857681f, 0.01681164f, -0.12088479f, 0.30639103f, 0.25012642f, 0.07799428f, -0.14768851f, 
    -0.00071346f, -0.11186380f, -0.11701558f, -0.17311820f, -0.21087655f, 0.04308253f, -0.20287749f, -0.12776941f, 
    0.15989625f, 0.00121656f, 0.02239456f, 0.03387703f, -0.21271090f, -0.12256414f, -0.10514989f, 0.18181196f, 
    0.04226173f, 0.07679362f, -0.09610856f, 0.32570890f, 0.20805183f, -0.03369568f, 0.01165575f, -0.11653797f, 
    0.35605654f, 0.00347137f, 0.14257878f, 0.06909270f, 0.64167690f, -0.44990647f, 0.10498796f, -0.39008045f, 
    0.00582398f, -0.05982506f, 0.02670041f, 0.16369668f, 0.19957343f, -0.06223689f, 0.04518711f, 0.01102538f, 
    0.29270938f, -0.20094913f, -0.16880456f, 0.17703165f, 0.09397520f, 0.19381009f, 0.21064222f, -0.06098826f, 
    0.17269699f, 0.11411335f, 0.11687607f, 0.20626640f, 0.01479234f, -0.10538229f, -0.09485301f, -0.07057902f, 
    -0.17808761f, -0.05956540f, -0.00264240f, -0.00907099f, 0.10683460f, 0.16123362f, 0.02118781f, 0.14962156f, 
    0.03186857f, -0.42793998f, -0.07965427f, 0.19558321f, 0.08615839f, -0.14887540f, -0.02264988f, 0.31922787f, 
    0.21549262f, -0.06532849f, 0.06694733f, 0.04915195f, -0.28922653f, -0.19655775f, -0.16957764f, 0.01337578f, 
    -0.01190002f, -0.08819453f, 0.22304294f, -0.10572907f, 0.09100932f, 0.25084457f, 0.02930190f, 0.28565085f, 
    -0.03406351f, 0.19700001f, 0.02654785f, -0.10106680f, -0.09057523f, 0.03056973f, 0.08668785f, -0.14350015f, 
    0.07840026f, -0.13965166f, 0.03706692f, 0.03367399f, -0.20647287f, -0.14458907f, 0.06922762f, 0.29898331f, 
    -0.12606949f, -0.20087467f, -0.04349347f, -0.08730753f, 0.06395253f, 0.17271049f, 0.11230256f, 0.12584692f, 
    -0.02345022f, 0.08095593f, 0.13709088f, -0.15677354f, 0.13596609f, -0.09548763f, -0.06384618f, 0.25125924f, 
    -0.11657215f, 0.08338606f, -0.05616953f, -0.15317836f, -0.02120261f, 0.12622812f, -0.09587885f, 0.20467456f, 
    0.05683563f, 0.04920573f, -0.10220595f, -0.08722465f, -0.07233241f, -0.14753222f, 0.04930827f, -0.14527617f, 
    -0.11041594f, -0.13623203f, -0.08098083f, -0.03274174f, 0.04636942f, -0.10109751f, 0.09073523f, 0.18330674f, 
    0.02541375f, 0.15588632f, -0.01264647f, -0.00628459f, 0.08612581f, 0.26418298f, 0.05450569f, -0.11294329f, 
    -0.03726104f, 0.07458632f, -0.03951557f, 0.12289726f, -0.09858034f, 0.08300456f, 0.00909145f, -0.07395194f, 
    -0.16764571f, 0.15476003f, 0.04271358f, -0.09511255f, 0.01143961f, 0.03652109f, -0.01521393f, 0.02256969f, 
    0.03803465f, -0.00034761f, 0.10997541f, 0.04532446f, -0.00036193f, -0.13926113f, -0.03467803f, -0.11299738f, 
    -0.01612186f, -0.22498642f, 0.20204976f, 0.01565749f, -0.00818312f, -0.14044403f, 0.10935490f, 0.10830794f, 
    -0.12352612f, -0.09636504f, 0.06618565f, 0.18677123f, -0.15896842f, 0.03928121f, -0.02135141f, 0.09671783f, 
    0.10777055f, 0.10298111f, 0.23631461f, -0.08220074f, -0.24363425f, -0.09886534f, -0.15703145f, -0.06075875f, 
    0.12494595f, 0.04202208f, -0.03169282f, 0.01817740f, 0.00408308f, -0.10636035f, -0.12390472f, -0.00395888f, 
    -0.08879856f, 0.41442949f, -0.25984889f, 0.01147760f, 0.08827713f, 0.09766819f, -0.08361990f, -0.09990336f, 
    0.18690139f, 0.02788013f, 0.10456195f, 0.04787347f, -0.61524767f, 0.37530059f, -0.15034088f, 0.00902320f, 
    0.18687277f, -0.13847940f, 0.28370896f, 0.29043880f, -0.05235923f, 0.12245971f, 0.12749159f, -0.12165207f, 
    0.16344105f, -0.00059991f, 0.16401573f, 0.15985875f, 0.28316942f, -0.04239037f, -0.00816017f, -0.01440786f, 
    0.16841504f, 0.11114425f, -0.04755024f, -0.11304888f, -0.12129464f, -0.03301920f, 0.03601637f, -0.10548250f, 
    0.10375997f, 0.16370270f, 0.06153838f, -0.00666874f, 0.02808243f, -0.00479350f, 0.06947016f, -0.02369783f, 
    0.54558933f, -0.21220124f, 0.11868259f, 0.32123891f, 0.14944674f, -0.14765619f, 0.08316075f, -0.04349685f, 
    -0.01022043f, 0.05177801f, 0.21960472f, -0.02567222f, -0.04092915f, 0.12017827f, -0.03057413f, -0.17177933f, 
    -0.05920107f, 0.10736742f, -0.03773250f, -0.10171444f, 0.02314863f, 0.04461145f, 0.17891563f, 0.05442847f, 
    -0.38082367f, -0.29013273f, -0.18987058f, -0.06159120f, -0.00521535f, -0.01842970f, -0.00190904f, 0.12633878f, 
    0.07030693f, 0.00254349f, 0.06748169f, 0.11842758f, 0.08563517f, -0.03437836f, 0.14921011f, -0.01136695f, 
    0.09887203f, -0.05545830f, -0.09339795f, -0.04041890f, 0.07557860f, 0.11291515f, 0.23927620f, 0.17417480f, 
    0.18414098f, 0.12086646f, 0.16033834f, 0.03714716f, 0.17948136f, 0.21976435f, 0.31035566f, 0.02150998f, 
    0.10643557f, -0.00066702f, -0.01203357f, -0.00065607f, 0.15495759f, 0.09251206f, 0.03451779f, -0.02128159f, 
    0.04465314f, -0.00640319f, -0.12756369f, -0.15038233f, 0.02539282f, 0.03555820f, 0.28757188f, -0.02815646f, 
    -0.13708229f, 0.11975572f, 0.11347358f, -0.03260925f, -0.10529643f, 0.02970274f, 0.19159296f, 0.15137661f, 
    -0.10376421f, -0.00342820f, -0.09164582f, 0.01457908f, 0.19517310f, 0.09612827f, 0.11135287f, -0.03603015f, 
    -0.08991104f, 0.02304528f, -0.08153353f, -0.02709202f, 0.01296322f, 0.04399822f, 0.01468645f, -0.08734099f, 
    0.25428805f, -0.11887056f, 0.07115554f, -0.00803059f, -0.15972216f, -0.04000360f, -0.06012375f, 0.01007974f, 
    0.01885317f, 0.05471567f, -0.09787688f, 0.19349588f, -0.09760261f, 0.05219859f, -0.14959376f, 0.13838385f, 
    -0.10548849f, -0.11632405f, -0.09550454f, 0.00215517f, 0.04643339f, 0.05006631f, -0.06364549f, -0.11452791f, 
    0.07867189f, -0.05265291f, 0.15244432f, 0.08181719f, 0.25823075f, -0.00988285f, 0.17688860f, 0.11414193f, 
    -0.02375693f, 0.07355591f, -0.09077522f, 0.04977596f, -0.30645087f, -0.14850956f, 0.07421221f, 0.10875339f, 
    0.01551255f, 0.03833740f, 0.04824549f, 0.14233607f, -0.09909702f, 0.13090624f, -0.03801063f, -0.01639617f, 
    -0.01795968f, 0.40126351f, 0.05023561f, 0.04939937f, 0.04947788f, 0.08997154f, 0.17761065f, -0.09184762f, 
    0.13084987f, 0.13646828f, 0.02015459f, 0.01184384f, 0.20990214f, -0.44844848f, 0.14313671f, 0.18976405f, 
    -0.14253534f, 0.16648577f, 0.15332823f, 0.35675043f, 0.13186400f, -0.08476405f, 0.18096057f, 0.23110524f, 
    0.00829009f, -0.13102953f, 0.03361862f, 0.05659002f, -0.04281497f, 0.18906860f, 0.18934326f, 0.05913464f, 
    0.11666025f, -0.11102575f, 0.10747864f, -0.07682013f, -0.02873397f, 0.00843540f, -0.03447596f, -0.12383810f, 
    0.06399298f, 0.05298458f, 0.00796219f, 0.08808593f, -0.05925213f, -0.00123863f, -0.11969009f, -0.08242546f, 
    -0.37106857f, -0.03864280f, -0.60075372f, 0.41216889f, 0.15188259f, -0.08364192f, 0.00990964f, 0.05562659f, 
    0.06442508f, -0.03895179f, 0.08680394f, 0.04243482f, 0.02769990f, -0.03395016f, 0.12486543f, -0.05268367f, 
    -0.08951125f, -0.11597665f, 0.18535306f, -0.01549658f, -0.00936158f, -0.02064057f, 0.04052868f, 0.22596070f, 
    0.33107910f, 0.23245496f, 0.12844022f, -0.04602409f, -0.16719489f, -0.08354974f, 0.18340448f, 0.05735956f, 
    0.01898659f, 0.04622141f, 0.05389961f, 0.02581996f, 0.04865032f, -0.01493746f, -0.11532734f, 0.09019601f, 
    -0.05100562f, -0.10133632f, 0.04985912f, -0.05304713f, -0.00713579f, -0.06785974f, -0.12133131f, -0.01693073f, 
    -0.04394527f, -0.01227441f, -0.34975478f, -0.45717791f, -0.07732104f, 0.11962613f, -0.04105192f, 0.22641250f, 
    -0.10813305f, 0.06413396f, -0.00506061f, -0.13421038f, -0.08544725f, 0.13898134f, -0.03764195f, 0.05722317f, 
    -0.10669211f, -0.05969606f, -0.07627343f, -0.03930953f, 0.10168334f, -0.01642906f, -0.16183114f, -0.15089433f, 
    0.14125790f, -0.07545459f, 0.04884614f, 0.02170409f, 0.06338564f, 0.28148675f, 0.07760729f, 0.02417358f, 
    0.05764028f, -0.03061953f, 0.11962045f, -0.05434007f, 0.32368150f, 0.25113931f, 0.19633333f, 0.08722479f, 
    -0.00497207f, -0.08064418f, -0.05482217f, -0.01896408f, -0.03669951f, 0.08631665f, 0.14048696f, 0.11222445f, 
    0.12119780f, -0.02872147f, -0.16197400f, 0.17209984f, -0.07780950f, 0.06010985f, -0.02025676f, -0.06195106f, 
    0.02503264f, -0.08972614f, 0.02297394f, 0.10304756f, -0.15989336f, 0.32830244f, 0.24112964f, -0.00680743f, 
    0.01800386f, -0.00868942f, 0.14049506f, 0.00571411f, -0.02013361f, 0.00234125f, 0.05306736f, 0.09032117f, 
    0.05017521f, 0.08542094f, -0.01063416f, 0.03136470f, 0.07917087f, 0.04967579f, -0.19463514f, -0.08674272f, 
    0.25910997f, -0.11657728f, 0.07602994f, -0.03625058f, 0.24911843f, 0.15045209f, -0.00390109f, 0.01779533f, 
    -0.05127046f, 0.07090433f, -0.02551095f, -0.03472585f, 0.12452967f, -0.03905824f, -0.04287795f, 0.09591839f, 
    0.11117662f, -0.23581825f, 0.09615109f, 0.14462733f, 0.04158787f, -0.03462123f, 0.02293657f, -0.00490624f, 
    0.08104295f, 0.08381022f, 0.02593857f, 0.11085805f, 0.05872285f, 0.05791392f, -0.58995354f, -0.03432417f, 
    -0.01751469f, -0.16792078f, 0.36328748f, 0.05618627f, 0.10774617f, 0.01469615f, -0.00141899f, -0.09180517f, 
    0.48666477f, 0.17641306f, 0.35629582f, -0.04715868f, 0.02620171f, 0.09826475f, -0.37559539f, -0.07719193f, 
    -0.00239847f, -0.01683468f, -0.10235208f, 0.17529431f, -0.01612194f, 0.11762957f, -0.09923609f, 0.13364899f, 
    -0.10320892f, -0.14948751f, -0.00277645f, -0.15108219f, 0.04604084f, 0.04147321f, -0.06426957f, -0.04442213f, 
    -0.12567759f, -0.30723906f, 0.45822623f, -0.07599929f, -0.05633094f, -0.24319121f, 0.19425854f, 0.03327566f, 
    0.08343715f, 0.11464457f, 0.01059304f, 0.11740714f, 0.01802204f, -0.02880411f, 0.09798210f, 0.00504059f, 
    0.00761343f, -0.01122619f, -0.10532314f, -0.09316828f, 0.04484806f, 0.02814179f, 0.00871076f, 0.06260367f, 
    -0.26544723f, -0.21518531f, -0.36432314f, -0.06577762f, -0.03363473f, 0.17596671f, 0.09147525f, -0.09423980f, 
    0.05123847f, -0.21257757f, -0.20970744f, 0.01653412f, -0.23528688f, -0.06401016f, -0.21755023f, -0.06500422f, 
    -0.13711704f, -0.02012582f, -0.05773460f, 0.01405946f, 0.11406228f, 0.11255036f, 0.12088633f, 0.05166605f, 
    0.11462776f, 0.16379818f, 0.50912935f, 0.02044044f, 0.13247019f, -0.30211428f, -0.09994572f, 0.13226974f, 
    0.01681570f, 0.03392431f, -0.10194569f, -0.00027169f, 0.09167743f, -0.16460398f, 0.02742577f, -0.02412451f, 
    0.00615706f, -0.02169155f, 0.03185626f, -0.00293519f, -0.05207863f, 0.01028511f, -0.01865035f, -0.04760741f, 
    -0.10105037f, 0.13064535f, 0.19633126f, -0.16597927f, 0.09098183f, 0.02428935f, 0.01085935f, 0.06147235f, 
    0.11041502f, -0.05483566f, 0.11077321f, 0.04906682f, -0.07929359f, -0.16256031f, 0.01675513f, 0.33267993f, 
    -0.16225922f, 0.05573446f, -0.17148197f, -0.17087753f, -0.02477052f, -0.06068874f, 0.10137801f, 0.21623985f, 
    0.15605929f, -0.01638904f, 0.11283008f, 0.00060063f, 0.03020215f, -0.08485168f, -0.10673156f, -0.14532372f, 
    0.22194192f, -0.14458321f, 0.04743463f, 0.02382593f, -0.18599404f, 0.06224693f, 0.19833316f, -0.04180580f, 
    0.03374018f, -0.02991387f, -0.15440677f, -0.03808904f, -0.11959148f, 0.02987257f, -0.02333714f, -0.00293534f, 
    0.43214566f, -0.07271999f, -0.06382765f, -0.17245978f, 0.10674735f, 0.10067723f, 0.17070128f, 0.07498884f, 
    0.09393096f, -0.00507715f, 0.02769927f, 0.19088407f, -0.46628508f, 0.11169654f, 0.16756928f, -0.06169232f, 
    0.07235397f, 0.13116001f, 0.03997568f, -0.16351491f, -0.16062711f, -0.08224571f, 0.03920536f, 0.07345232f, 
    -0.08068676f, -0.14475428f, 0.16218172f, 0.09616055f, 0.06837609f, 0.19152308f, 0.00581738f, 0.02809381f, 
    0.10381290f, 0.12290438f, 0.00839751f, 0.08942576f, 0.10743140f, -0.04225038f, 0.15292513f, -0.07823938f, 
    0.24464385f, 0.17803393f, -0.24971169f, -0.00452409f, 0.08995513f, -0.01680502f, 0.09823405f, -0.02775354f, 
    -0.02849049f, -0.08331973f, -0.20048004f, 0.07438079f, 0.02516219f, 0.13962801f, 0.06497099f, 0.22162238f, 
    0.12836884f, 0.00142592f, -0.05373771f, 0.30703828f, -0.03727049f, -0.22791108f, -0.14324340f, 0.01512560f, 
    -0.05094040f, 0.04275862f, -0.11942768f, -0.15275919f, 0.06947064f, 0.04851466f, 0.01492683f, 0.04063492f, 
    -0.66180378f, -0.18105754f, -0.01097180f, -0.12405918f, -0.23386253f, 0.14370002f, 0.04242352f, 0.08504110f, 
    0.07563835f, 0.12263617f, -0.02335714f, -0.00669275f, -0.12851676f, 0.07388506f, -0.07758556f, -0.06140193f, 
    -0.04654173f, -0.23509189f, 0.18589064f, 0.07259179f, 0.03196563f, 0.20376201f, -0.02677569f, 0.08439769f, 
    -0.06786481f, 0.39829573f, 0.03659525f, -0.19325836f, 0.11124232f, -0.14911827f, -0.10706775f, 0.13281868f, 
    -0.11083593f, 0.03804239f, 0.10980318f, -0.14878823f, -0.21818778f, 0.01323186f, 0.35889107f, 0.08714156f, 
    -0.07732140f, -0.06207665f, -0.16056466f, -0.02018900f, 0.02721898f, 0.14678143f, 0.14960776f, 0.10948439f, 
    -0.40822637f, -0.41517311f, -0.11289737f, 0.40989122f, 0.27968785f, 0.15836599f, 0.09763093f, -0.02772056f, 
    0.01098800f, -0.18228914f, 0.08430178f, -0.07982787f, 0.10644262f, -0.00005018f, -0.02532388f, -0.00819132f, 
    -0.08309520f, 0.07021064f, 0.00463757f, -0.02206785f, -0.06843515f, -0.03992569f, -0.04944436f, -0.11506940f, 
    -0.11710770f, 0.04611376f, -0.13134384f, 0.23084743f, 0.05441304f, 0.13793266f, 0.09201804f, 0.23663521f, 
    -0.09728574f, 0.12944682f, 0.02235712f, 0.10198359f, 0.23991923f, 0.60612512f, 0.12210800f, -0.34704924f, 
    -0.16059040f, -0.16148536f, -0.21845651f, -0.07006613f, -0.16276424f, -0.09001708f, -0.13096137f, 0.02250418f, 
    0.10037243f, 0.15002771f, -0.02538700f, 0.04586782f, -0.20760530f, 0.00142860f, -0.11136860f, -0.00844916f, 
    -0.13022763f, 0.08717594f, 0.15622723f, 0.02902636f, 0.07444561f, -0.14325257f, -0.07848667f, 0.19120798f, 
    -0.04391738f, -0.07646015f, -0.06953568f, 0.00285804f, 0.05803597f, -0.08245421f, -0.08969335f, 0.10433497f, 
    -0.15839580f, -0.14388967f, 0.12989056f, 0.12720241f, 0.11061109f, 0.17230837f, 0.12265520f, -0.02094298f, 
    -0.04405916f, -0.02054623f, 0.06593952f, -0.23018458f, -0.18159904f, -0.22790578f, -0.23869552f, 0.02946613f, 
    0.12137397f, 0.12344605f, 0.02773928f, 0.13273330f, -0.03673866f, -0.01835905f, -0.07588594f, 0.17853522f, 
    0.03607282f, 0.28129810f, -0.29575759f, 0.24070673f, -0.05421766f, -0.01338364f, 0.13380419f, -0.24222843f, 
    0.19570728f, 0.08476803f, 0.06679486f, 0.10129599f, -0.14115010f, 0.46207488f, -0.19869122f, -0.04136203f, 
    -0.04716855f, -0.13097852f, 0.25855684f, 0.05471767f, 0.24172795f, 0.01087356f, 0.32949054f, -0.00120909f, 
    0.17685030f, 0.04770256f, -0.16891930f, 0.22925743f, 0.01225883f, 0.11809155f, 0.10832840f, -0.15933335f, 
    0.15156806f, 0.01021153f, 0.02258799f, -0.07673633f, -0.05539740f, 0.05291964f, -0.14278401f, -0.21761440f, 
    -0.03459589f, -0.11771232f, -0.00304415f, 0.02563072f, 0.02971758f, 0.06138225f, -0.08598388f, 0.06937114f, 
    0.31492385f, -0.09683274f, -0.30760816f, 0.01171394f, 0.00628378f, -0.11169890f, 0.03122485f, 0.15225281f, 
    0.03725516f, -0.00787507f, 0.07950272f, -0.00279199f, 0.21674120f, -0.31779179f, -0.08560404f, -0.13458687f, 
    -0.26505026f, -0.05482174f, -0.01814945f, -0.09068175f, -0.10635922f, -0.03076141f, 0.21237087f, 0.22310308f, 
    -0.01882748f, 0.02059396f, 0.22338274f, 0.06635571f, -0.08941829f, 0.09885298f, 0.22378981f, -0.08592359f, 
    0.10666416f, 0.11410177f, 0.09219678f, 0.05452491f, -0.07582646f, -0.17221913f, -0.36420920f, -0.10140618f, 
    0.01562219f, -0.11470158f, 0.05788252f, 0.03818026f, -0.04645705f, 0.05042556f, 0.09322986f, 0.07045001f, 
    -0.03629574f, 0.52144617f, -0.21734279f, -0.09633876f, -0.05991352f, -0.02406005f, 0.03232597f, 0.06637888f, 
    0.01391050f, -0.02280868f, 0.11217537f, -0.00978593f, 0.00280016f, 0.18530568f, 0.07870958f, -0.04538137f, 
    -0.13534284f, -0.07521984f, -0.06201437f, -0.13767272f, -0.04333283f, -0.11825068f, 0.23402981f, -0.17246735f, 
    -0.05202095f, 0.08495627f, 0.21879235f, -0.10184196f, -0.05199461f, -0.12539054f, 0.12474578f, 0.04942840f, 
    0.11177208f, 0.09535221f, 0.03525880f, 0.07627285f, -0.05426404f, -0.23485972f, 0.06182987f, 0.07055084f, 
    -0.01019629f, 0.04915759f, 0.04659192f, -0.05355787f, 0.11537020f, -0.00097979f, -0.06630228f, -0.01723417f, 
    0.02240236f, -0.05993894f, 0.26328760f, -0.17859498f, 0.07561360f, -0.08613200f, 0.03636715f, -0.12359008f, 
    0.17999645f, -0.02559060f, 0.08581299f, 0.02553407f, -0.24925089f, -0.24677356f, 0.01833117f, 0.03029619f, 
    -0.04466908f, -0.03605220f, -0.07143804f, -0.05897561f, 0.08713944f, -0.03786474f, -0.00391186f, 0.00106403f, 
    0.11528508f, 0.14474724f, 0.06421389f, 0.09062934f, 0.12689121f, 0.05498327f, 0.21865414f, 0.05463995f, 
    0.02619663f, 0.09611179f, 0.02663366f, 0.11945361f, -0.29550254f, -0.05746418f, 0.24605834f, 0.16340816f, 
    -0.02179183f, 0.03332683f, 0.07200391f, 0.01092653f, -0.04362705f, 0.09395365f, 0.10522251f, 0.08510883f, 
    -0.04918488f, 0.22269641f, 0.05451369f, -0.03182665f, 0.08297058f, 0.18552412f, -0.11787629f, 0.09505983f, 
    -0.06787490f, -0.07151204f, 0.05262841f, -0.13376708f, 0.08129162f, -0.28796342f, 0.58823019f, -0.00508587f, 
    -0.00308771f, 0.21250401f, -0.21770081f, 0.03310606f, -0.01246768f, 0.12518989f, -0.12168071f, -0.13211206f, 
    -0.36206588f, -0.20428385f, -0.10000972f, 0.09620222f, 0.04262071f, 0.03654070f, 0.22465925f, 0.15524834f, 
    0.06796577f, 0.04114867f, 0.03403984f, 0.04509468f, 0.10350592f, -0.22150075f, 0.09736932f, -0.18135192f, 
    0.10923354f, -0.01091710f, 0.08801550f, 0.03597896f, 0.04581852f, -0.03212805f, 0.02313898f, -0.02241128f, 
    -0.26543230f, -0.07388856f, -0.39975223f, 0.29553166f, -0.24892706f, 0.15200864f, -0.21043602f, 0.01428088f, 
    -0.05750287f, 0.06457869f, 0.10746686f, 0.05148450f, -0.16769244f, 0.22946730f, 0.00723656f, 0.08148900f, 
    0.06363111f, -0.07246733f, 0.08341117f, -0.01364276f, 0.01492695f, -0.00444717f, 0.01328863f, -0.11511459f, 
    0.12371822f, 0.31616831f, 0.23432122f, -0.06544448f, 0.03712174f, -0.07914533f, -0.09703873f, 0.13355148f, 
    0.09592088f, 0.13668595f, 0.13482592f, 0.03518446f, 0.19971649f, 0.18400295f, 0.30521390f, 0.00001336f, 
    0.00739075f, 0.00942729f, -0.04555468f, -0.10281241f, 0.08250250f, 0.01166047f, -0.13182995f, 0.09375852f, 
    -0.34556958f, -0.42235410f, -0.22059558f, 0.25750169f, 0.03758537f, 0.22771217f, 0.19111544f, 0.06412506f, 
    -0.05106429f, -0.07387681f, 0.08552273f, 0.06517621f, 0.16372547f, 0.12127858f, -0.04253195f, 0.05202151f, 
    -0.09782869f, 0.03957197f, 0.00365772f, -0.01958323f, -0.00878681f, 0.00757028f, -0.14561199f, 0.07712160f, 
    -0.03862108f, 0.04842876f, -0.04789658f, -0.06539870f, -0.04211371f, -0.02889065f, 0.02993719f, 0.03094391f, 
    -0.02619064f, -0.06096709f, 0.04071905f, 0.02319565f, -0.05168244f, -0.07123160f, 0.00056447f, 0.02463339f, 
    -0.03870340f, 0.01473857f, -0.00142140f, -0.06387699f, -0.04814174f, -0.03150896f, -0.00970098f, -0.06164266f, 
    0.05802311f, 0.05368217f, -0.03253009f, -0.07780932f, -0.07428778f, 0.04036782f, -0.02622837f, 0.00537180f, 
    0.02167854f, 0.01535888f, 0.02274299f, -0.07064892f, -0.04893176f, -0.05331971f, -0.03547774f, 0.00478071f, 
    -0.03770046f, -0.02032234f, 0.05293153f, -0.00907051f, -0.06027678f, 0.03905525f, 0.02349328f, 0.05114411f, 
    0.06260740f, 0.03471831f, 0.03260161f, -0.02950470f, -0.07179700f, 0.01265020f, 0.01818676f, -0.07194140f, 
    -0.02938423f, -0.05781087f, -0.03270150f, -0.03504870f, -0.01445797f, -0.05734178f, -0.07071723f, 0.00247088f, 
    0.06232068f, -0.02848185f, 0.05977702f, -0.01581120f, 0.02829170f, -0.07261270f, -0.01778097f, -0.02480933f, 
    -0.00713622f, 0.00406587f, 0.02188331f, -0.05918562f, -0.05727166f, -0.06960938f, -0.03360315f, -0.05420500f, 
    -0.04733403f, -0.00765585f, 0.00750304f, -0.04838239f, -0.03440855f, -0.03311877f, 0.03140492f, -0.03267736f, 
    -0.04805154f, -0.05427610f, -0.04782969f, 0.01257124f, 0.01812897f, -0.05259244f, -0.06511699f, -0.07859589f, 
    0.01407396f, 0.06281191f, 0.00812262f, -0.03144662f, -0.04536957f, 0.05845525f, -0.06808621f, 0.05160979f, 
    0.00240733f, -0.01421077f, 0.04507472f, -0.07392555f, -0.07999847f, -0.06435125f, 0.01549660f, -0.04953018f, 
    -0.06529591f, 0.01350296f, 0.01031835f, 0.02408483f, 0.01346815f, 0.01945404f, 0.01192988f, -0.00282629f, 
    -0.06468331f, -0.01505289f, 0.03964897f, -0.05369179f, 0.01257074f, -0.05317179f, -0.00735398f, -0.07140734f, 
    -0.07912420f, -0.06153925f, -0.02906553f, 0.04961037f, -0.04127353f, 0.02006070f, -0.03385410f, -0.00519435f, 
    0.03207792f, -0.02842886f, 0.01658431f, 0.05242615f, 0.02443506f, 0.06318068f, 0.03794627f, -0.00152387f, 
    0.00206704f, 0.02566916f, -0.07950578f, 0.00260377f, -0.05211280f, 0.01760257f, -0.03508181f, 0.02608301f, 
    -0.00032381f, 0.05689049f, 0.06351170f, 0.03478728f, 0.04302806f, 0.01044785f, 0.03736595f, 0.03154714f, 
    0.03310395f, -0.05662340f, 0.00623106f, 0.04514730f, -0.03143728f, -0.06586168f, 0.03219216f, 0.05792016f, 
    0.00988864f, -0.03041580f, 0.02035388f, 0.03669057f, -0.06903908f, 0.02195093f, -0.04968650f, 0.02775107f, 
    -0.04590016f, -0.01149187f, -0.07341380f, -0.06430227f, 0.04296887f, -0.03132637f, 0.03552686f, -0.07223237f, 
    0.01715092f, -0.04663876f, 0.03224741f, -0.01501647f, -0.07448248f, -0.03474322f, -0.03747596f, -0.00827222f, 
    -0.00119276f, 0.00467872f, 0.06160363f, 0.01960745f, -0.07294687f, 0.16092424f, 0.03617475f, -0.01147103f, 
    -0.03808606f, -0.09052350f, 0.14060615f, -0.07976752f, 0.19900844f, 0.27318671f, 0.03397367f, 0.20531206f, 
    -0.23092981f, -0.26205301f, -0.11883841f, 0.00238831f, -0.00650853f, -0.01352181f, 0.24331568f, 0.02816088f, 
    -0.03666044f, -0.11353385f, -0.16712289f, 0.19957824f, -0.03650022f, -0.01626555f, -0.12065678f, -0.00860889f, 
    0.13803399f, -0.09752318f, -0.03540265f, 0.00141374f, -0.24336298f, 0.08927149f, 0.07431427f, -0.13158175f, 
    0.00719750f, 0.00805063f, -0.00715567f, 0.13737984f, -0.10233858f, -0.04933466f, -0.13757950f, -0.10830404f, 
    0.14354211f, 0.13307345f, 0.00482247f, -0.05698451f, 0.13593946f, -0.04924554f, -0.06410900f, -0.00781913f, 
    0.14371780f, -0.14596012f, -0.12712876f, 0.00978642f, 0.29086715f, 0.09604231f, 0.14668073f, -0.04030289f, 
    -0.19398016f, 0.04895223f, -0.01217832f, -0.13591209f, 0.02489551f, 0.00106146f, 0.02665331f, -0.11652865f, 
    0.25715798f, -0.36122084f, 0.25009391f, -0.02416113f, -0.07237429f, 0.09955361f, 0.17583700f, 0.13850899f, 
    0.06736926f, 0.19071138f, -0.02758397f, 0.20531511f, 0.07441862f, -0.10421864f, 0.07423848f, 0.24067758f, 
    -0.07676648f, 0.05485972f, 0.26935506f, 0.04125349f, 0.10121185f, 0.00686796f, -0.04190869f, 0.08605798f, 
    0.53128374f, -0.00716481f, 0.24822427f, -0.01099136f, -0.05241189f, 0.25706196f, -0.14227234f, 0.33288023f, 
    -0.07307401f, 0.10476275f, -0.06874407f, 0.23876528f, -0.10790545f, 0.03922475f, -0.04149265f, 0.18745559f, 
    -0.08269125f, -0.06178221f, 0.08923765f, -0.27507046f, 0.00802512f, -0.00550497f, 0.09231281f, 0.01061261f, 
    0.06234720f, -0.09642205f, 0.16000120f, -0.17704092f, -0.04268736f, 0.00884516f, 0.10267766f, -0.05371550f, 
    0.07120112f, 0.12245448f, 0.03494968f, 0.12130275f, 0.00855838f, -0.07166220f, 0.05847561f, -0.16118415f, 
    0.24624969f, 0.17848432f, 0.08464533f, 0.14211392f, -0.01645184f, 0.06249915f, -0.07630867f, 0.17055923f, 
    -0.07826126f, 0.00473247f, -0.02134088f, -0.05708762f, -0.07347564f, -0.04125608f, 0.04153601f, 0.03512322f, 
    0.09798645f, -0.06226076f, -0.06518452f, 0.02162492f, -0.10264016f, -0.09499486f, -0.22119483f, -0.17005622f, 
    -0.37358728f, -0.22697039f, -0.03102613f, -0.02769547f, 0.04793910f, 0.05967276f, 0.11639974f, -0.00826608f, 
    0.08786842f, 0.00990798f, 0.20344542f, 0.17791562f, 0.06975296f, -0.08872931f, -0.08489683f, 0.05350945f, 
    -0.02532200f, -0.05680414f, -0.08549605f, 0.04669195f, 0.03815089f, -0.05353111f, 0.07808238f, -0.24628824f, 
    0.03545663f, -0.05218767f, 0.02075958f, 0.00041654f, 0.05316475f, -0.00977109f, -0.06183808f, 0.12733048f, 
    0.06399492f, -0.00936545f, -0.02225390f, -0.00920245f, 0.06053289f, 0.03914995f, -0.00520070f, -0.05359258f, 
    0.04184651f, -0.05256473f, -0.06440014f, -0.00354977f, 0.00667002f, 0.06442260f, 0.03555439f, -0.03394710f, 
    0.01242532f, -0.04042565f, 0.05701067f, -0.03249867f, -0.02452029f, -0.03233335f, 0.07192869f, 0.04850750f, 
    -0.04834598f, -0.06884008f, 0.05605915f, -0.03197338f, 0.04039491f, -0.02140564f, -0.05787033f, -0.05308356f, 
    0.02222645f, -0.06555525f, -0.02343934f, -0.04361462f, -0.02427730f, -0.08200086f, -0.06673068f, -0.05948759f, 
    -0.00286466f, 0.03247454f, -0.06684512f, 0.00392576f, 0.05749417f, 0.03386163f, -0.06038901f, -0.04766018f, 
    0.04238373f, 0.01526785f, 0.03744238f, 0.01085210f, -0.06632972f, 0.01959173f, -0.06843637f, -0.06417553f, 
    -0.00218680f, -0.02829543f, 0.04827545f, 0.03909824f, -0.03781368f, -0.06560031f, -0.00373279f, -0.03095817f, 
    0.00525050f, -0.04943950f, -0.04078696f, 0.03534617f, -0.05204592f, -0.00910663f, 0.00946929f, 0.01636215f, 
    -0.02527319f, 0.02704886f, -0.02628255f, -0.06949123f, 0.01516519f, -0.00596771f, -0.01715815f, -0.03947263f, 
    -0.05486355f, -0.01752825f, 0.00551577f, -0.06900752f, 0.02420939f, -0.04520141f, 0.05004244f, 0.00374871f, 
    -0.02421433f, 0.05236204f, 0.03379617f, -0.04077562f, 0.06265815f, -0.01266210f, -0.05314950f, 0.00855198f, 
    0.05328670f, -0.01385079f, 0.01652441f, 0.02347190f, 0.03410932f, -0.04451590f, -0.02216012f, -0.00804007f, 
    0.01009594f, -0.06111383f, 0.02266791f, -0.04925202f, -0.07082532f, -0.05558498f, 0.01659169f, 0.02941249f, 
    0.06833104f, -0.03731726f, -0.06385636f, 0.00975607f, -0.06658464f, 0.01605294f, -0.00736578f, 0.04112104f, 
    0.04483792f, -0.03444028f, 0.01661673f, -0.03514601f, 0.07478260f, 0.00512683f, -0.00396951f, 0.04499347f, 
    -0.01155731f, -0.02295992f, 0.04728404f, -0.01187841f, -0.06471194f, 0.04089170f, 0.07288080f, -0.03376279f, 
    -0.07432225f, -0.06689484f, 0.06332509f, -0.02902270f, -0.07551347f, -0.03838716f, 0.04309276f, 0.03696471f, 
    0.02074088f, -0.03326585f, 0.01460953f, -0.04696782f, 0.03030408f, 0.05272726f, 0.02512608f, 0.03506991f, 
    -0.05437544f, -0.02869760f, -0.07745264f, -0.00408217f, -0.04750304f, 0.02278400f, -0.04859992f, 0.00454060f, 
    -0.02916146f, -0.01827864f, 0.02500251f, -0.03954476f, -0.00112695f, -0.02673000f, -0.02045198f, -0.06726567f, 
    0.00877140f, 0.00520910f, 0.02933915f, -0.05178520f, 0.00366900f, -0.02257725f, -0.00932474f, 0.04757698f, 
    -0.05549598f, 0.00149020f, 0.03591326f, 0.03451836f, 0.06262271f, -0.00507786f, -0.02883227f, -0.01578452f, 
    -0.02216039f, 0.02097933f, -0.01991747f, -0.05454711f, -0.01120492f, -0.02310827f, 0.05420109f, -0.01188099f, 
    -0.05473711f, -0.10574534f, -0.11438151f, -0.10386549f, -0.01913657f, 0.05257701f, 0.08241867f, 0.00756731f, 
    0.04319778f, -0.10097454f, 0.08240518f, 0.12960595f, -0.04074580f, -0.06719995f, 0.03132597f, 0.07776907f, 
    -0.08065318f, -0.03677157f, -0.01963675f, -0.08196655f, 0.03773709f, 0.03182500f, 0.05140994f, 0.04066356f, 
    -0.23724300f, -0.03003775f, 0.04214878f, -0.17519431f, 0.09911598f, -0.06125299f, -0.01231095f, -0.04405546f, 
    0.09819253f, -0.18259043f, 0.11104555f, 0.13981822f, -0.06688247f, -0.15854505f, 0.00647329f, -0.14722218f, 
    0.00430265f, 0.01674807f, 0.01504746f, 0.02504702f, -0.03244336f, -0.04239123f, -0.00877179f, 0.00463145f, 
    0.00219364f, -0.00198438f, -0.14827846f, -0.14009103f, 0.05593513f, 0.22075421f, 0.18418592f, 0.08526298f, 
    0.06426413f, -0.06887380f, -0.03213741f, -0.06058874f, -0.23444177f, -0.03632485f, -0.26012257f, -0.17204595f, 
    0.04293159f, 0.04588789f, -0.00275941f, -0.12913890f, -0.01624117f, -0.04416813f, 0.00041837f, -0.02559500f, 
    -0.01121517f, -0.03849423f, -0.15243639f, -0.10131416f, -0.11836283f, 0.19132361f, -0.14304008f, 0.04728141f, 
    0.09769108f, -0.01031222f, 0.10965167f, 0.21503407f, -0.13882074f, 0.19494189f, 0.43034199f, -0.13700229f, 
    0.09452791f, 0.07882870f, -0.16014044f, 0.03911073f, 0.00080246f, 0.05138563f, 0.03435493f, -0.07663521f, 
    0.20077629f, -0.11389759f, -0.15684026f, 0.11900362f, 0.06983703f, -0.01491960f, 0.09331821f, 0.19598438f, 
    0.12369649f, 0.08814050f, 0.06095639f, 0.15509908f, -0.00618051f, -0.14588284f, 0.04523702f, -0.12827614f, 
    0.02376446f, 0.01665936f, 0.03451029f, -0.00830324f, 0.03924515f, 0.09343438f, 0.15620145f, 0.23604734f, 
    0.64464396f, -0.01786239f, 0.22378428f, -0.25789604f, 0.01690328f, 0.10842841f, 0.03435807f, 0.08270320f, 
    0.00250160f, 0.00466294f, 0.17414586f, 0.07521331f, -0.20482424f, 0.10235681f, -0.09366310f, -0.02771505f, 
    0.09514226f, 0.00626490f, 0.08617027f, 0.05791761f, -0.06155607f, 0.15277772f, -0.03575071f, 0.05770169f, 
    -0.18139815f, -0.06052688f, 0.04215825f, -0.00367259f, -0.01962165f, -0.02860280f, -0.11417185f, 0.19553933f, 
    0.01651154f, 0.08101732f, 0.08355105f, -0.02695161f, 0.00666876f, 0.06067114f, 0.21860333f, -0.11382530f, 
    -0.10562324f, -0.12344619f, 0.00316621f, -0.07955871f, 0.02918631f, 0.28281271f, 0.20574549f, 0.09991871f, 
    0.03397743f, -0.12422526f, -0.00285495f, 0.17206264f, 0.06623558f, 0.17309389f, 0.17713597f, -0.02060795f, 
    -0.09450940f, -0.11946080f, -0.04816399f, 0.02949633f, 0.06428245f, 0.10550493f, 0.02351527f, -0.14363115f, 
    -0.12540941f, -0.00120138f, 0.01687940f, 0.03104357f, -0.03694591f, 0.10152728f, 0.22870834f, -0.02400922f, 
    0.05484643f, 0.01096854f, 0.06139791f, -0.02318614f, 0.07631028f, 0.26169157f, 0.13623239f, 0.09944328f, 
    -0.04468637f, -0.04016904f, 0.05057281f, 0.03181978f, 0.09627501f, -0.04868375f, 0.08647135f, 0.08083483f, 
    -0.09841379f, 0.06452031f, -0.12261879f, -0.21583925f, 0.04333435f, -0.00866535f, -0.04563853f, 0.02212156f, 
    0.23518530f, -0.25020909f, 0.03097385f, 0.12974270f, -0.07682915f, 0.07631668f, -0.14612234f, -0.08641907f, 
    0.05459924f, -0.16637063f, -0.07171788f, 0.04048790f, -0.07217187f, 0.40013662f, 0.18005052f, 0.03707664f, 
    0.01951783f, 0.03132742f, -0.08604424f, 0.04544700f, -0.05791176f, -0.07997192f, -0.17144494f, -0.06805695f, 
    0.30261409f, 0.15758786f, 0.01094209f, -0.07784206f, 0.03387273f, -0.06154640f, 0.01581412f, 0.12309708f, 
    -0.01550925f, -0.03919946f, -0.12951446f, -0.08189248f, 0.04376385f, 0.14152539f, 0.22133665f, 0.02123589f, 
    0.03934948f, 0.07291221f, 0.02840773f, -0.04768538f, -0.14797871f, 0.00952860f, -0.00783306f, 0.14578512f, 
    0.02662490f, -0.12351532f, 0.16420151f, 0.08215265f, 0.20174237f, 0.16163702f, 0.09973422f, -0.06550103f, 
    0.20359917f, 0.04433179f, -0.04447113f, -0.01531565f, 0.33275595f, -0.45989245f, -0.40199819f, 0.02482422f, 
    -0.05608106f, 0.00621614f, 0.17488796f, 0.08162299f, 0.24979289f, 0.01788718f, 0.09824605f, 0.04407002f, 
    0.28054428f, 0.10023189f, 0.10736543f, 0.07255094f, -0.01675517f, 0.13779871f, -0.03835806f, 0.10242198f, 
    0.10188441f, -0.07109571f, -0.04031586f, 0.27922937f, 0.02700642f, 0.00195050f, -0.18494740f, 0.06908371f, 
    -0.08895056f, 0.06743193f, 0.05951845f, -0.01426377f, 0.23468138f, -0.00617219f, -0.04753799f, -0.04735586f, 
    -0.44605505f, -0.19123489f, 0.11766671f, 0.05329986f, 0.06431054f, 0.00078264f, 0.06567325f, 0.03722076f, 
    -0.04984298f, -0.02258356f, 0.04978122f, 0.06572668f, -0.14611889f, -0.06393135f, 0.05288912f, -0.08421133f, 
    -0.06409608f, -0.04348889f, 0.07227337f, -0.11456326f, 0.20146506f, 0.04178018f, -0.04840711f, 0.17651232f, 
    0.14809448f, 0.08950141f, -0.28273374f, -0.22973160f, 0.00411010f, -0.06587968f, 0.01312958f, -0.01548375f, 
    0.02501575f, -0.13197029f, -0.00807096f, -0.10771947f, -0.31504688f, -0.11366824f, 0.08243143f, 0.15574326f, 
    -0.14586358f, -0.03790574f, -0.12675332f, 0.01199411f, -0.00970200f, -0.05291611f, 0.11114807f, 0.10491806f, 
    0.17778289f, -0.30734012f, 0.13510765f, -0.25303692f, 0.10637435f, -0.01478007f, 0.02133960f, 0.10500127f, 
    -0.06980054f, -0.01176658f, -0.13661487f, -0.15928482f, 0.01843149f, 0.06413224f, -0.10778689f, 0.18327937f, 
    0.10152934f, 0.00941472f, -0.13819398f, -0.08942573f, 0.03131849f, -0.09387022f, -0.16922565f, -0.05162870f, 
    -0.22880100f, 0.02838465f, -0.11919815f, -0.04040997f, 0.01986330f, 0.00941907f, 0.06505040f, 0.11466080f, 
    -0.04862370f, 0.05599223f, -0.11839022f, 0.01070540f, 0.12180041f, 0.11462201f, 0.12139339f, -0.00541563f, 
    -0.05666776f, -0.02615647f, -0.13394019f, -0.00329638f, 0.01729997f, -0.08104596f, -0.04528873f, 0.05011022f, 
    0.10471971f, -0.05991262f, 0.10570271f, -0.04627482f, -0.00732123f, -0.07777984f, -0.03791019f, 0.01971113f, 
    0.05752115f, 0.30230778f, -0.05260789f, 0.20788080f, -0.07260493f, -0.05308817f, -0.04638889f, 0.27108115f, 
    -0.13496104f, -0.11626901f, -0.11509561f, -0.17486335f, 0.06478619f, 0.03152797f, -0.07114500f, 0.00585248f, 
    -0.16190004f, -0.27296960f, 0.09923597f, 0.02805992f, 0.25891456f, 0.21934864f, 0.07152566f, -0.02165619f, 
    -0.10299025f, 0.09670526f, 0.26063344f, 0.08749303f, -0.30689228f, -0.18209577f, -0.11448180f, -0.02476199f, 
    -0.06152230f, 0.03087474f, 0.02521675f, 0.07862177f, -0.04403432f, 0.00192470f, -0.03382633f, 0.01790984f, 
    -0.05971032f, 0.19837961f, 0.01708813f, 0.07029077f, 0.27883330f, 0.00853324f, 0.03951786f, -0.09356115f, 
    -0.00234125f, 0.08890191f, 0.08466846f, 0.20027728f, 0.07107043f, -0.13143790f, -0.10555405f, 0.07843145f, 
    -0.11080098f, -0.18061654f, 0.28945234f, 0.08415423f, 0.35098565f, -0.05438815f, 0.34287807f, -0.03840913f, 
    0.09427471f, -0.19432954f, -0.44567913f, 0.31135282f, 0.06063319f, 0.02251344f, 0.37811518f, 0.01179989f, 
    0.08837309f, 0.07010540f, 0.09317476f, -0.03732532f, -0.11621987f, 0.00375590f, -0.13499929f, -0.02958397f, 
    0.15173602f, 0.01104934f, 0.00131269f, 0.08381388f, 0.00220133f, -0.00680043f, -0.04469666f, 0.07427336f, 
    -0.09638949f, -0.24168667f, -0.56933796f, 0.08955535f, 0.09995569f, -0.10044810f, -0.08305489f, 0.10272333f, 
    -0.02521035f, 0.03777871f, 0.16007137f, -0.02571171f, 0.03624867f, -0.36508676f, 0.01745152f, -0.11847658f, 
    -0.01226441f, -0.07721586f, -0.01998173f, 0.06350798f, -0.08810330f, 0.00595635f, 0.12249268f, 0.03626382f, 
    -0.03240147f, 0.22727405f, 0.26143441f, 0.08289754f, -0.08028102f, 0.02970641f, 0.18586956f, -0.08151270f, 
    0.11086550f, 0.10858802f, 0.18299450f, 0.06237315f, -0.14810221f, -0.04398712f, 0.02342247f, 0.32820019f, 
    -0.02025806f, -0.01648386f, 0.02180355f, 0.00640968f, -0.00678238f, 0.13293596f, 0.11663933f, 0.16687022f, 
    -0.14867614f, 0.35939184f, -0.26999551f, 0.03764829f, 0.14255835f, 0.44889328f, 0.06457024f, 0.29927146f, 
    0.04103098f, 0.09286953f, 0.08015805f, -0.09830205f, 0.03704344f, 0.10251978f, 0.03653618f, 0.03139596f, 
    -0.00830204f, -0.02887674f, -0.03429165f, -0.07210751f, 0.17473182f, 0.01877336f, 0.20621052f, -0.09580600f, 
    0.01415264f, -0.01307598f, -0.06537394f, -0.03581250f, -0.05813632f, 0.02247796f, -0.06407133f, -0.02060352f, 
    0.04618768f, 0.01521292f, -0.03449636f, -0.00008053f, -0.02264553f, -0.01298217f, -0.06216584f, -0.05032449f, 
    -0.00001827f, 0.00277838f, 0.02043804f, 0.02721459f, -0.05112247f, 0.02690419f, -0.07918146f, -0.06311399f, 
    0.00554198f, -0.04905070f, -0.04206779f, 0.02261206f, 0.02129847f, -0.02524472f, -0.06983793f, 0.01146030f, 
    0.02298810f, 0.06410132f, 0.02509787f, 0.04613738f, 0.00817679f, -0.00575266f, -0.04714970f, -0.01574940f, 
    -0.05602785f, -0.06692273f, -0.03474839f, -0.00896853f, 0.05042072f, -0.01278425f, 0.03835288f, -0.05105387f, 
    -0.00878736f, -0.05905577f, 0.00285267f, 0.00323407f, 0.04285349f, 0.03035907f, -0.07207002f, -0.01675986f, 
    0.02717268f, -0.00704527f, -0.00890032f, 0.02424026f, 0.05461231f, -0.01807976f, 0.06838653f, -0.06245743f, 
    -0.06032857f, -0.00336629f, -0.02507596f, -0.06626000f, -0.01773353f, 0.05455072f, -0.02519730f, -0.02953583f, 
    -0.07161320f, -0.06332604f, -0.04094262f, -0.07078649f, 0.03062380f, -0.06376556f, 0.00032632f, -0.01968947f, 
    -0.01314550f, -0.06406260f, -0.04875596f, -0.05842873f, -0.05225452f, 0.00477371f, -0.01504660f, 0.02541753f, 
    0.01451619f, 0.00215225f, -0.06631058f, 0.01605088f, 0.01382658f, -0.00561609f, -0.01174626f, -0.05080975f, 
    0.01272738f, -0.00186854f, -0.03017790f, 0.04076406f, -0.04665714f, -0.06305113f, 0.05034170f, -0.04399307f, 
    0.03895319f, 0.00083107f, 0.03030328f, -0.03242844f, -0.02971299f, 0.02136551f, 0.05288560f, 0.03489194f, 
    0.02590644f, 0.00261912f, 0.01239748f, -0.06599844f, -0.00780943f, -0.06376759f, 0.06311207f, -0.07521785f, 
    0.02310185f, -0.03898585f, -0.05273513f, 0.05691973f, -0.03758028f, 0.00719501f, -0.00613130f, 0.01620373f, 
    -0.07203283f, 0.02397233f, -0.04302951f, 0.04090449f, 0.05378973f, 0.06056675f, -0.04602499f, 0.03396201f, 
    0.00546857f, -0.00079826f, -0.04457591f, 0.04591139f, -0.03593244f, -0.06810274f, 0.03770883f, 0.04911418f, 
    -0.02006911f, -0.01371784f, 0.04766310f, -0.03580872f, -0.03842426f, 0.00747077f, -0.00605814f, 0.00663087f, 
    -0.05889179f, -0.03541410f, -0.02358572f, -0.00064450f, -0.02970790f, 0.04935187f, 0.02047617f, 0.00077612f, 
    -0.03516861f, 0.04096134f, -0.05993123f, 0.02651970f, 0.04286065f, 0.05260595f, 0.02790785f, -0.04585257f, 
    -0.07963880f, -0.04444626f, -0.04548739f, -0.07146948f, -0.02251698f, -0.00610154f, -0.03752073f, -0.03992254f, 
    0.01956140f, -0.03197169f, 0.04186077f, -0.07764114f, -0.00242273f, 0.03851490f, 0.05110652f, -0.00566470f, 
    0.03993557f, 0.04408648f, -0.04959057f, 0.04172658f, -0.04812968f, -0.05029919f, -0.05032000f, -0.04595899f, 
    0.18680450f, 0.06646276f, -0.03549769f, 0.27412659f, -0.00816949f, 0.23106959f, 0.07839535f, -0.01095276f, 
    0.02202341f, -0.01258613f, 0.08664259f, 0.07854539f, -0.14789450f, 0.05779996f, -0.17034012f, 0.04253383f, 
    -0.12247142f, -0.09473865f, -0.13901117f, 0.04758587f, 0.03802288f, -0.15336613f, -0.00368061f, -0.03749349f, 
    -0.09827067f, 0.12604149f, -0.19547194f, 0.04363865f, -0.08326276f, -0.14967348f, -0.04034291f, 0.08460755f, 
    0.20275004f, 0.05653017f, 0.12333207f, 0.02552960f, -0.00904487f, -0.13373643f, -0.00208013f, 0.27950850f, 
    0.05563055f, -0.14827815f, -0.00094062f, 0.12055483f, 0.01517779f, -0.01246741f, -0.07249732f, 0.16757847f, 
    -0.07709355f, 0.03855911f, -0.00699272f, 0.12983099f, 0.00427321f, 0.21714167f, 0.05112185f, -0.14438409f, 
    0.07224533f, -0.15692775f, 0.03783045f, -0.18223639f, 0.01240177f, -0.12472301f, -0.10286442f, -0.10539311f, 
    0.09018885f, 0.00849318f, 0.11978349f, 0.14469118f, 0.12821737f, 0.10819117f, 0.05207928f, 0.10712226f, 
    0.03674806f, -0.05167206f, -0.03743203f, 0.08233950f, -0.15909307f, -0.08746438f, 0.01358965f, -0.09579021f, 
    -0.08575974f, 0.03192588f, 0.03878449f, 0.12270457f, 0.04443360f, 0.45216775f, 0.35664937f, -0.23155485f, 
    0.07202949f, 0.00011409f, -0.07699067f, -0.17031451f, -0.00036315f, 0.06887807f, -0.08526652f, 0.01712876f, 
    -0.08371984f, 0.05169729f, -0.01067528f, 0.13364750f, -0.10758327f, 0.34106582f, -0.01325208f, 0.15097906f, 
    0.00877227f, 0.07722699f, 0.12047070f, -0.05483351f, -0.11540280f, -0.16006564f, -0.04437888f, -0.13791373f, 
    -0.03967575f, -0.12867640f, -0.00833292f, -0.00713656f, -0.01432561f, 0.06992079f, 0.13079619f, 0.08312684f, 
    0.06986072f, 0.29618457f, -0.02153623f, -0.27872548f, -0.11834309f, 0.00621989f, 0.04171643f, 0.14411870f, 
    -0.10625014f, -0.03255436f, 0.05709795f, 0.18196471f, 0.22110797f, -0.26536494f, -0.14813045f, 0.10918607f, 
    0.05170492f, 0.06213713f, 0.04917378f, -0.08223773f, 0.00821323f, 0.01113179f, 0.16916072f, 0.07783874f, 
    -0.03625108f, 0.08528918f, 0.28350210f, 0.31339926f, 0.04746872f, 0.19972670f, 0.18671238f, -0.14868338f, 
    0.15976979f, 0.03815479f, 0.04179922f, 0.10640623f, 0.04671540f, 0.02781507f, -0.23120423f, -0.25510055f, 
    -0.13706474f, -0.10046688f, 0.11215506f, -0.07307471f, -0.04290041f, 0.04181104f, 0.01980061f, 0.06193651f, 
    -0.18045686f, 0.52117795f, -0.22619034f, 0.17842357f, -0.12707317f, 0.05772178f, -0.08996082f, -0.01128973f, 
    -0.12088246f, -0.02047859f, -0.07791007f, -0.09366393f, 0.04354140f, -0.06675760f, -0.07046460f, -0.03849162f, 
    -0.06139024f, -0.00976709f, -0.04551806f, -0.03061957f, 0.02634031f, -0.08255520f, 0.06850005f, -0.01478472f, 
    -0.02219434f, 0.10513467f, 0.23970634f, -0.18086751f, -0.05786846f, -0.05416482f, 0.08042872f, 0.16900694f, 
    0.08895295f, 0.08059069f, -0.03745515f, -0.09775522f, 0.21095566f, 0.04935126f, 0.24440990f, 0.18446586f, 
    -0.03418893f, 0.07552548f, 0.01458381f, -0.16713211f, -0.09567811f, 0.13617885f, -0.02504382f, 0.15033595f, 
    0.23728122f, 0.03231597f, 0.06511667f, 0.14627956f, -0.10036664f, 0.00135236f, -0.14200628f, 0.07159877f, 
    -0.04906356f, 0.00904869f, 0.08954436f, -0.03723884f, 0.21102469f, 0.21863680f, -0.14188720f, -0.14064932f, 
    0.06169947f, 0.08588370f, -0.00444562f, -0.12829860f, -0.05161950f, 0.18154013f, 0.01876586f, -0.15053497f, 
    0.30783600f, -0.20233163f, 0.13014066f, -0.03564593f, -0.05650727f, -0.16000645f, 0.03507947f, 0.25015035f, 
    0.02218726f, 0.07457525f, -0.02683368f, 0.28665230f, -0.20960256f, 0.01339455f, 0.14303350f, -0.02886072f, 
    -0.00959185f, 0.04246765f, -0.09610067f, -0.00681872f, -0.15522449f, 0.04136686f, -0.05030788f, -0.00500697f, 
    -0.09261967f, 0.02067824f, 0.25065926f, -0.05960241f, 0.11503784f, -0.00624223f, 0.01355910f, 0.02073105f, 
    0.07197379f, 0.17836317f, -0.05928916f, -0.03909826f, -0.25824732f, -0.17458299f, -0.26627123f, 0.45744151f, 
    0.07298528f, 0.16456527f, 0.16947556f, 0.21215867f, 0.15511258f, -0.01429677f, 0.15487906f, 0.09001099f, 
    0.03230392f, 0.21293648f, 0.04360816f, -0.07574626f, -0.00994068f, -0.03632805f, 0.02076106f, 0.00162806f, 
    -0.03726019f, -0.07674425f, 0.00991196f, 0.05091030f, -0.06926654f, 0.04789936f, -0.09668560f, 0.11497863f, 
    0.01571150f, 0.11293778f, -0.01445595f, 0.03675926f, -0.14844075f, -0.05514814f, -0.26399982f, -0.09538575f, 
    -0.78062445f, 0.07165066f, -0.18609321f, 0.12422986f, 0.18874648f, -0.13521259f, 0.06701209f, -0.03631924f, 
    0.04903641f, 0.07192957f, -0.11982488f, -0.05876281f, 0.08125275f, -0.04566780f, 0.22866769f, -0.13398424f, 
    -0.20771204f, 0.03788899f, -0.11800026f, 0.00320786f, -0.04218236f, -0.07869606f, 0.04784136f, 0.17044799f, 
    0.19793265f, 0.14281678f, -0.17369817f, -0.25498551f, -0.03238670f, -0.06849518f, -0.00774773f, 0.09465545f, 
    -0.12455222f, 0.00302875f, 0.11905406f, -0.04842566f, -0.21519467f, 0.19519296f, 0.08189782f, 0.23452716f, 
    -0.01566332f, 0.02863920f, -0.09051923f, 0.06066376f, -0.03897648f, -0.03271313f, 0.06072704f, 0.07106266f, 
    0.08654065f, -0.08869381f, -0.08647951f, -0.18423550f, 0.14888735f, 0.13831899f, -0.00350338f, 0.03474783f, 
    0.08528315f, -0.05175767f, 0.05563048f, -0.02309421f, 0.06544709f, 0.10979918f, -0.00863837f, 0.04099036f, 
    0.00141446f, 0.02697261f, -0.02012799f, -0.11416297f, 0.05627794f, -0.02818684f, -0.11377172f, -0.05356577f, 
    0.17334861f, 0.33026025f, 0.18449286f, 0.21893233f, 0.09377164f, 0.05838398f, 0.03524051f, 0.01198732f, 
    -0.00441571f, 0.03324674f, -0.03991588f, 0.05868072f, -0.55805361f, -0.59637046f, -0.39439222f, -0.54756159f, 
    0.18158941f, 0.04117716f, 0.04360898f, -0.08168331f, -0.04704161f, 0.03114365f, -0.00366764f, 0.09997963f, 
    0.10218038f, -0.37697592f, -0.25544897f, -0.24205852f, -0.04797072f, -0.00267201f, 0.11077454f, -0.11969818f, 
    -0.13721870f, 0.06319266f, -0.01684815f, -0.04464145f, 0.47937438f, 0.18833594f, 0.19243640f, 0.26823846f, 
    0.12438931f, 0.29523432f, 0.05190941f, 0.05159179f, -0.00131030f, 0.04265267f, 0.05928274f, 0.13106386f, 
    0.28867787f, 0.09399325f, 0.27702194f, 0.31914160f, 0.06696041f, -0.08372887f, -0.01301177f, 0.12988260f, 
    -0.12893343f, 0.18804230f, -0.04805551f, 0.30795783f, 0.34206828f, 0.14367454f, 0.15075825f, 0.17320131f, 
    0.12261280f, 0.13308781f, 0.05629620f, -0.01553437f, 0.00468355f, 0.00598076f, 0.08415733f, 0.00807969f, 
    -0.18521962f, -0.01391048f, 0.02289828f, -0.09455869f, 0.11295450f, -0.16554844f, 0.00185658f, 0.01584556f, 
    0.12818344f, -0.15112191f, 0.02101151f, -0.11253369f, 0.11093413f, -0.22919044f, -0.44927785f, -0.15930590f, 
    -0.09067781f, -0.34155533f, 0.09444804f, -0.06016158f, 0.20060493f, -0.00835040f, 0.13603547f, 0.04022181f, 
    0.08955467f, 0.11564717f, -0.13360412f, -0.04407271f, -0.02399229f, -0.21556574f, 0.09949458f, -0.17010748f, 
    -0.06114293f, -0.09535980f, -0.23601399f, -0.15084219f, 0.11156691f, -0.10707138f, -0.09317878f, -0.23481262f, 
    0.16069514f, -0.04293074f, 0.08113854f, 0.05410569f, -0.00558456f, 0.02683708f, -0.17740485f, -0.11057086f, 
    -0.12651691f, 0.15794633f, 0.08336563f, 0.07037383f, 0.06123387f, 0.02450020f, 0.02554378f, -0.01756723f, 
    0.04523829f, -0.05149727f, -0.00737105f, -0.05515444f, -0.36301327f, -0.17819455f, -0.14288229f, 0.10898927f, 
    -0.03203531f, -0.12587599f, -0.17111968f, 0.11075601f, -0.07407104f, -0.14751522f, -0.10789506f, -0.08480673f, 
    0.47826073f, 0.03549392f, 0.06637241f, 0.11634680f, 0.29442635f, 0.10238245f, 0.13085628f, -0.05556059f, 
    -0.03896415f, 0.04089292f, 0.06161537f, 0.09625027f, -0.14194648f, -0.22183247f, -0.41157261f, -0.13854155f, 
    0.06127717f, -0.01061827f, -0.08379599f, -0.00810935f, 0.03741633f, 0.06819797f, -0.02090081f, -0.01537742f, 
    0.17998552f, -0.21145056f, -0.09889446f, -0.02771970f, -0.21009065f, -0.06552608f, -0.08208041f, -0.06779201f, 
    0.10447686f, -0.02668017f, 0.09760772f, -0.00387956f, -0.30658737f, -0.19098108f, -0.26884815f, -0.15290010f, 
    0.03382486f, 0.04648619f, 0.05442441f, -0.03863619f, -0.07156276f, -0.03044276f, 0.02810346f, 0.12919396f, 
    0.00136219f, 0.16624157f, 0.23966675f, 0.07341214f, -0.15160473f, -0.20256621f, 0.03955093f, -0.07896557f, 
    -0.04067170f, -0.00044837f, -0.00859518f, -0.08341388f, -0.10739809f, -0.39405304f, 0.00922248f, 0.01911114f, 
    0.08813422f, 0.02858431f, -0.04891169f, -0.03795809f, 0.02684903f, 0.03296332f, -0.11914580f, 0.01935835f, 
    -0.19780599f, 0.03301687f, 0.15810540f, -0.16474877f, 0.05038827f, 0.09459034f, -0.02571826f, 0.10847962f, 
    0.13374798f, -0.07068682f, 0.07636892f, 0.12450941f, -0.31022075f, -0.38079584f, -0.14795284f, -0.00518609f, 
    -0.10261568f, -0.05309947f, 0.00774672f, -0.11058029f, -0.01660514f, -0.07842897f, 0.01800557f, -0.06165534f, 
    -0.02870873f, 0.00125074f, -0.00416551f, 0.05236227f, 0.05822897f, -0.05922013f, 0.04383636f, 0.19749063f, 
    0.12058384f, 0.12345133f, 0.14865795f, 0.24953228f, -0.14166780f, 0.07853980f, 0.32712474f, 0.24565335f, 
    -0.11258854f, 0.04843133f, 0.08098548f, -0.01259090f, -0.03481829f, -0.00715269f, 0.12585783f, -0.12666164f, 
    -0.09626773f, 0.21284932f, 0.20792937f, -0.16572464f, 0.05133075f, 0.04113116f, 0.01762771f, 0.11040942f, 
    -0.07436540f, 0.11179963f, 0.07228418f, -0.04438405f, -0.64815772f, -0.03408206f, 0.33997390f, 0.58744657f, 
    0.09450500f, 0.31935462f, -0.33767885f, 0.16732284f, 0.04253387f, 0.12152494f, -0.12327233f, 0.10249710f, 
    -0.13963127f, -0.14040634f, 0.18819109f, -0.03488906f, -0.05977903f, 0.14026751f, 0.11810609f, 0.09904824f, 
    0.01232171f, -0.05293106f, -0.01478104f, -0.17490982f, 0.02694094f, -0.10359682f, -0.18550181f, 0.13941500f, 
    0.25403497f, 0.18088464f, -0.05816982f, -0.17351024f, -0.14241825f, -0.19162750f, -0.06384492f, -0.16724131f, 
    -0.42614725f, 0.23075587f, -0.39869836f, 0.23955934f, -0.08856687f, 0.06955436f, 0.01604812f, -0.38346198f, 
    -0.02765416f, 0.18749808f, -0.00024481f, 0.16564447f, 0.22008227f, 0.04004342f, 0.30729857f, -0.18923183f, 
    0.13961101f, 0.05369295f, -0.22610879f, 0.08221961f, 0.03332865f, -0.07691491f, 0.24409989f, -0.18649425f, 
    -0.03294137f, 0.32330909f, 0.37219295f, 0.23936856f, 0.06240080f, -0.14865574f, -0.02537123f, 0.22869563f, 
    -0.10469533f, 0.11223070f, 0.05855831f, 0.06869971f, -0.01677242f, 0.24264091f, 0.15434921f, 0.03089422f, 
    -0.02104605f, 0.04212412f, -0.09556464f, 0.04916443f, 0.02276970f, 0.05849528f, -0.05171065f, 0.06372361f, 
    -0.35161853f, -0.23265201f, -0.09858294f, 0.54700512f, 0.17734934f, 0.17190769f, 0.05584292f, 0.07280282f, 
    0.02649787f, -0.07901466f, 0.01930495f, 0.17044218f, -0.13071123f, -0.18879028f, -0.21291322f, -0.28957555f, 
    -0.06549621f, -0.16792804f, 0.04437802f, -0.20716767f, 0.14473714f, 0.22661474f, 0.04185829f, 0.18148038f, 
    -0.21732065f, -0.03237742f, 0.22126229f, -0.00666719f, 0.04845942f, 0.07259002f, 0.03999208f, 0.17615665f, 
    0.06602287f, 0.01493935f, 0.13451597f, 0.07577962f, 0.05431245f, 0.04103296f, -0.02414103f, -0.13575369f, 
    -0.07518129f, -0.05204422f, -0.12611191f, -0.09243643f, -0.03241146f, 0.00745290f, 0.08743045f, -0.04390223f, 
    -0.04004018f, -0.01248152f, 0.11512320f, -0.09002499f, 0.04794103f, -0.04573496f, -0.04982816f, 0.03896325f, 
    0.25488898f, -0.11835686f, 0.08408858f, 0.08774341f, -0.24263719f, -0.21060814f, 0.12336998f, 0.01602559f, 
    0.09258229f, -0.16407694f, 0.03028117f, 0.26186255f, -0.02648252f, -0.24030690f, -0.09233849f, -0.09445031f, 
    0.01395650f, 0.30820695f, 0.07126817f, 0.12748143f, -0.06131838f, 0.05581033f, 0.18444583f, 0.05697615f, 
    0.09579200f, -0.07495221f, -0.06386425f, 0.00662781f, -0.41020277f, 0.00010108f, 0.22438316f, 0.15831101f, 
    0.20310618f, 0.09039842f, 0.00048109f, -0.19980010f, -0.09536030f, 0.00951064f, -0.01059212f, -0.04556170f, 
    -0.04291990f, 0.29221287f, -0.12204696f, 0.00862379f, -0.04709622f, 0.17039491f, 0.08891629f, -0.13580701f, 
    0.18876573f, 0.19538556f, 0.04847347f, 0.03226546f, -0.44589987f, 0.10079534f, 0.38147414f, 0.25202137f, 
    0.12461182f, 0.25190523f, 0.05904430f, 0.28755790f, -0.12614818f, 0.09801030f, 0.11027489f, -0.05828202f, 
    0.03930612f, -0.21152605f, 0.24265325f, 0.20771989f, 0.13893917f, 0.08929368f, -0.01581146f, 0.39093685f, 
    0.06317377f, 0.12409610f, 0.10363488f, 0.09929569f, 0.00898438f, -0.05687540f, -0.00550168f, -0.04908137f, 
    -0.00180865f, 0.04709541f, 0.01479204f, -0.04914792f, 0.05434433f, -0.02879744f, 0.02883215f, 0.05770129f, 
    0.20974660f, -0.24459153f, -0.11302155f, 0.40209657f, -0.16736205f, 0.05168527f, 0.08861914f, -0.15372750f, 
    0.01791558f, 0.12608178f, 0.06307909f, -0.01263090f, 0.01226624f, 0.07127720f, 0.04652410f, -0.07114730f, 
    -0.15326294f, -0.07059389f, 0.07454421f, -0.05096634f, 0.11440605f, 0.13053952f, -0.07085351f, 0.06424514f, 
    -0.14591461f, 0.09375688f, 0.04495165f, -0.13216342f, -0.11531250f, -0.20415340f, -0.14354023f, 0.14614451f, 
    -0.05285431f, 0.20230927f, 0.07416007f, -0.02860609f, 0.15301612f, -0.04766981f, 0.09951026f, -0.13442264f, 
    0.01373044f, -0.01567209f, -0.07099875f, -0.08308496f, -0.06408071f, 0.10367094f, 0.05137332f, 0.00700404f, 
    -0.08106691f, -0.37173852f, -0.11853331f, 0.11296167f, 0.17832731f, 0.16229330f, 0.19657707f, -0.00104223f, 
    -0.04126190f, 0.10497620f, 0.00115043f, -0.07069106f, 0.12784085f, 0.07950231f, -0.00867261f, -0.10407583f, 
    -0.04023335f, -0.03468754f, -0.05365048f, -0.05961809f, 0.05303041f, 0.00216056f, -0.05182096f, -0.04230401f, 
    0.06875845f, -0.01051351f, 0.18420221f, 0.10930326f, 0.03379476f, 0.04348159f, 0.17503181f, 0.08646034f, 
    0.08447433f, 0.05195726f, 0.08898611f, 0.12036742f, 0.11701530f, -0.17639032f, 0.09768304f, 0.35126266f, 
    -0.01098169f, 0.06849198f, -0.02687361f, -0.09549744f, 0.15437382f, 0.00247246f, 0.03286887f, -0.00441340f, 
    0.16032530f, 0.06952634f, 0.03623635f, -0.12908046f, 0.04342255f, -0.06785280f, -0.07479893f, -0.12360396f, 
    0.11699242f, -0.00969913f, 0.03647843f, 0.08884611f, -0.26725650f, -0.26417598f, 0.03677617f, -0.03357246f, 
    -0.02631754f, -0.16504498f, -0.14208484f, 0.11185539f, -0.05440456f, -0.10973311f, -0.06179009f, 0.06449534f, 
    0.07461288f, 0.44785267f, 0.00635834f, 0.21242562f, -0.05885516f, 0.06366586f, 0.03192387f, 0.03490324f, 
    -0.04735998f, -0.00323697f, -0.19842479f, -0.18817519f, -0.08964106f, -0.01762312f, 0.21721704f, 0.23364790f, 
    0.20493576f, 0.12092271f, 0.13290916f, 0.20113793f, -0.01832268f, 0.03613599f, 0.09387216f, -0.07533677f, 
    0.07203440f, 0.08521727f, 0.10138369f, 0.12366696f, -0.09047087f, 0.08445027f, -0.08798422f, 0.00840878f, 
    0.07352620f, -0.05068115f, 0.04551472f, -0.14636286f, 0.20260248f, -0.03724810f, 0.34152475f, -0.20796448f, 
    0.07966336f, 0.09541881f, -0.38480452f, -0.00369692f, -0.14656565f, 0.05976195f, -0.29594776f, 0.04047412f, 
    -0.44817591f, -0.14130437f, 0.19658783f, -0.10842028f, 0.02229455f, 0.17519112f, -0.08649946f, -0.02366240f, 
    0.07494248f, -0.00815465f, 0.06141442f, 0.05426980f, 0.21002237f, 0.03011278f, 0.13451801f, -0.03320814f, 
    0.08096454f, 0.01600741f, 0.02767458f, 0.00130287f, 0.09769621f, 0.12276769f, 0.09372219f, -0.00229084f, 
    -0.21588558f, 0.26467091f, 0.02678680f, 0.29459208f, -0.24122314f, 0.16796553f, -0.05812859f, -0.14958419f, 
    -0.05737349f, -0.03205106f, -0.05223626f, 0.24901600f, 0.02033555f, 0.28057376f, 0.00474753f, 0.26121971f, 
    0.11878376f, -0.04915075f, 0.09923665f, -0.10530471f, 0.12271036f, 0.07785396f, -0.04742473f, -0.01611712f, 
    0.24158922f, -0.00056241f, -0.29602677f, -0.03653040f, -0.03467041f, -0.07843554f, -0.06101440f, 0.13803580f, 
    0.12821177f, -0.01469989f, -0.02827996f, -0.00547722f, 0.39872888f, 0.17397702f, 0.13296449f, -0.11320113f, 
    -0.06279621f, 0.00274211f, 0.01887186f, -0.06651051f, -0.02356426f, -0.03345925f, -0.13940154f, 0.04658246f, 
    -0.15770385f, -0.34040159f, 0.19663402f, -0.01019606f, -0.15222684f, -0.23767665f, -0.05609599f, -0.04920899f, 
    -0.00430559f, -0.03459993f, -0.05617768f, -0.04916954f, 0.09867938f, 0.04058031f, 0.04574658f, 0.03112287f, 
    0.00770748f, 0.01525311f, 0.02376386f, -0.07265107f, -0.11788997f, -0.07883216f, -0.20048392f, -0.05869770f, 
    -0.03721934f, 0.15335502f, 0.07814834f, 0.04725598f, 0.10084494f, 0.13860896f, 0.07348091f, -0.10721490f, 
    -0.13703185f, 0.08340854f, -0.29210225f, -0.11029898f, 0.06048793f, 0.05484115f, 0.12115120f, 0.14390336f, 
    -0.01682778f, 0.00206461f, -0.06683030f, 0.03208890f, 0.00882436f, 0.09508361f, -0.07803711f, 0.12536557f, 
    0.11843508f, -0.04015575f, -0.01414046f, 0.00617842f, 0.05987569f, 0.02381363f, -0.06616701f, -0.04150249f, 
    0.14177147f, 0.24752402f, 0.10480662f, 0.04176028f, 0.03856375f, 0.02350060f, 0.01453111f, 0.30211893f, 
    -0.07233398f, -0.03397482f, -0.25802791f, -0.13496421f, -0.24731840f, -0.29353178f, -0.39186332f, -0.42680272f, 
    -0.01184556f, -0.17469715f, 0.18269925f, -0.06250545f, -0.07736184f, -0.41578037f, 0.08172040f, -0.25622571f, 
    0.03361614f, -0.32199699f, -0.23144576f, -0.01260727f, 0.00078031f, 0.05820525f, 0.17192511f, 0.03112043f, 
    0.11735217f, -0.06673001f, -0.08041587f, -0.02010565f, -0.07210331f, 0.05057732f, -0.16440704f, -0.12308820f, 
    -0.22000538f, 0.20858002f, 0.12335436f, 0.07488929f, 0.07244926f, -0.16958654f, -0.08185299f, 0.02151544f, 
    0.12149433f, 0.13345180f, 0.17053604f, -0.10140210f, 0.12215012f, -0.23224872f, -0.08027708f, -0.02003191f, 
    -0.05053502f, 0.12530822f, 0.08984330f, -0.01993785f, 0.09811078f, 0.02874632f, 0.12714629f, 0.02144225f, 
    0.02798255f, 0.17533524f, 0.03180728f, 0.11843902f, -0.14112353f, -0.22557488f, 0.04053608f, 0.03646265f, 
    -0.08906994f, -0.10334842f, -0.01957475f, -0.12694636f, 0.05980400f, 0.05730063f, 0.02333961f, 0.00721746f, 
    0.13432837f, 0.02963129f, -0.10410610f, -0.02301705f, -0.13708493f, 0.05492567f, -0.20573759f, -0.03973017f, 
    -0.61794418f, -0.16789123f, -0.24431078f, 0.19427313f, 0.14304727f, -0.31611276f, -0.16948622f, 0.25964361f, 
    -0.08645819f, -0.11515179f, 0.00813196f, -0.01365164f, 0.08480840f, -0.00880390f, 0.14724565f, 0.04857956f, 
    -0.07341731f, 0.07918808f, 0.00184440f, -0.07168395f, 0.01065314f, -0.07508243f, 0.09840567f, 0.12037515f, 
    0.06225282f, 0.07541049f, 0.03295155f, -0.05288397f, 0.14236099f, 0.04469330f, 0.21025002f, -0.13981868f, 
    -0.29956692f, -0.12113862f, 0.11345504f, 0.04833588f, -0.01377592f, 0.09243385f, -0.05012090f, 0.16832058f, 
    0.10669550f, 0.16275923f, 0.01827027f, 0.01911474f, -0.07667547f, 0.06818142f, 0.14792383f, 0.06708649f, 
    0.02414697f, 0.15784130f, 0.21552908f, 0.13995942f, -0.02983148f, 0.04105153f, -0.17366795f, 0.04667173f, 
    -0.04833815f, 0.00540273f, -0.00583685f, 0.09867060f, -0.13892139f, -0.03877900f, -0.11334104f, 0.00811117f, 
    0.05171476f, 0.00167894f, -0.08920838f, 0.08049531f, 0.30474931f, 0.06779630f, 0.06165724f, -0.03864719f, 
    0.04236941f, 0.05460140f, -0.02033435f, 0.27226692f, -0.05825287f, 0.03416428f, 0.02177321f, -0.00190006f, 
    0.05667183f, 0.06538270f, 0.10352406f, -0.00817399f, -0.06346722f, -0.06514827f, -0.15665318f, -0.02893815f, 
    -0.13988049f, -0.15817149f, -0.09554767f, -0.02892246f, 0.03936316f, -0.08114336f, 0.00458164f, -0.03992129f, 
    -0.28134197f, -0.00382736f, -0.08612872f, -0.17305273f, 0.03736250f, -0.09928876f, -0.10507317f, -0.03302895f, 
    0.24503507f, 0.01155040f, 0.09371508f, 0.15354046f, -0.33881447f, -0.41528773f, -0.04547685f, 0.18100156f, 
    -0.09336300f, -0.11795376f, -0.01475839f, 0.02130851f, -0.11717115f, 0.01987061f, -0.11776781f, 0.00108815f, 
    -0.03529229f, 0.05745229f, 0.04150206f, 0.03469199f, 0.14416853f, 0.09981753f, 0.02832626f, -0.10062424f, 
    0.16787995f, -0.05259004f, 0.08438494f, -0.11894538f, 0.02437909f, -0.05871975f, 0.19653435f, 0.06300203f, 
    -0.03310330f, -0.07177501f, 0.08683719f, -0.06207018f, -0.01238292f, 0.05094336f, 0.05087797f, 0.03686650f, 
    0.05436828f, -0.03742466f, -0.07111511f, 0.07377519f, -0.12212955f, 0.09622350f, 0.02710653f, 0.04473820f, 
    0.09494509f, 0.09597394f, -0.01263899f, 0.22110456f, -0.11852808f, 0.29570848f, 0.38969630f, -0.01387279f, 
    0.06777851f, 0.15129046f, -0.11524173f, -0.12789580f, 0.06043385f, -0.01485202f, -0.16340473f, -0.10844694f, 
    0.21958570f, -0.10902037f, -0.03223067f, 0.07055146f, -0.03503937f, 0.19809167f, -0.00848693f, 0.20985147f, 
    0.13911189f, 0.17613955f, 0.05208435f, -0.03863149f, -0.08080819f, -0.17580253f, -0.02700562f, -0.03394777f, 
    0.08129873f, -0.12173983f, -0.07127611f, -0.15140587f, -0.02156017f, -0.06286340f, 0.10347795f, 0.06570360f, 
    0.23952320f, 0.03355530f, -0.09870491f, -0.21243079f, -0.22442093f, 0.11058883f, -0.02883074f, -0.08298621f, 
    -0.09133537f, 0.10274062f, 0.11713637f, 0.09820990f, 0.17974448f, -0.15036990f, -0.05905353f, -0.15558437f, 
    0.18369152f, -0.00992633f, 0.08022089f, 0.02879714f, 0.01663600f, 0.08570353f, 0.08186080f, 0.04872011f, 
    -0.32340464f, 0.19005553f, 0.39703071f, 0.27020812f, 0.00574899f, 0.08339734f, 0.13143481f, 0.00800386f, 
    0.10511165f, 0.09594305f, -0.01139006f, 0.03870802f, 0.01176349f, 0.08269645f, -0.04713557f, -0.26212123f, 
    -0.18090189f, -0.11977822f, -0.03882184f, 0.00191427f, 0.05407006f, 0.21258543f, -0.03172472f, 0.12530746f, 
    -0.30214038f, 0.18002108f, -0.03662072f, 0.56616360f, 0.02792409f, 0.07817174f, -0.01360466f, -0.04720862f, 
    -0.07819200f, -0.01768262f, -0.08390137f, 0.06677868f, -0.12586802f, -0.05163091f, -0.03497003f, -0.29713598f, 
    -0.05233013f, -0.08874402f, 0.02151717f, 0.04095928f, -0.04099912f, 0.08095813f, 0.09510493f, 0.05241000f, 
    0.06939352f, -0.13979924f, -0.13192981f, 0.21325324f, 0.16227773f, 0.15831390f, 0.07535653f, 0.19055201f, 
    0.05976917f, -0.00106512f, 0.09419707f, 0.00121547f, 0.01927276f, 0.30014956f, 0.10139454f, 0.14306468f, 
    -0.05426801f, -0.00538707f, -0.00667409f, -0.06924368f, -0.04534735f, 0.02080846f, -0.01335127f, 0.01518803f, 
    -0.16113755f, 0.13361079f, -0.03473658f, 0.04290194f, -0.08464027f, -0.01985028f, -0.02737824f, -0.06588142f, 
    -0.09752622f, 0.00780680f, 0.03813428f, -0.02436963f, 0.46058169f, 0.08861812f, -0.15309891f, -0.06181299f, 
    0.22675735f, 0.05250841f, 0.08123883f, 0.15724641f, -0.10987052f, 0.01126074f, -0.11906671f, -0.07527657f, 
    0.03280678f, -0.18001400f, 0.06144702f, 0.19661367f, -0.01203096f, 0.07322128f, -0.09178205f, 0.10925046f, 
    -0.03617809f, 0.03761905f, -0.03595722f, -0.17149289f, 0.21030745f, 0.06787265f, -0.35540345f, 0.03686445f, 
    0.20021491f, 0.21796344f, 0.11401859f, 0.08685390f, -0.06152274f, -0.10928944f, -0.01714045f, -0.00425001f, 
    0.13542381f, 0.12143698f, -0.09241121f, -0.09648955f, -0.14680178f, -0.00791511f, 0.07395209f, -0.07759957f, 
    -0.00072907f, 0.06148393f, 0.02957776f, 0.06032874f, -0.06821708f, 0.64747953f, -0.17578444f, 0.08304817f, 
    -0.01303700f, 0.05230465f, 0.16258375f, -0.03697878f, 0.03341102f, -0.00576709f, 0.19412562f, 0.08782765f, 
    0.13187174f, 0.43256217f, -0.02372785f, 0.19459589f, 0.17759533f, -0.09652944f, -0.11318279f, -0.19879332f, 
    0.08881177f, -0.09620589f, 0.01982584f, 0.06293964f, -0.04492213f, 0.10726705f, -0.02675248f, 0.00067385f, 
    -0.15626767f, -0.11064319f, 0.03044107f, -0.11600870f, -0.05310870f, 0.12010333f, 0.07448006f, 0.17265220f, 
    0.47352117f, 0.37319449f, 0.43694931f, -0.40708789f, 0.24567300f, 0.06829683f, 0.12995461f, 0.21071503f, 
    -0.05396063f, -0.04615160f, -0.10029946f, -0.03596364f, -0.03038619f, 0.08141939f, -0.09753093f, 0.02384027f, 
    -0.15031633f, 0.01220734f, 0.04441420f, -0.06441754f, -0.10863741f, 0.18529147f, 0.03660853f, 0.07742239f, 
    0.02301605f, -0.33729637f, -0.35972816f, 0.01736752f, 0.16869950f, 0.14028041f, 0.03977069f, 0.14291784f, 
    0.03448579f, 0.09624159f, -0.07521980f, -0.07343736f, 0.07491504f, 0.03677128f, -0.13815841f, -0.21994467f, 
    -0.01716463f, 0.02818661f, 0.09916358f, -0.00016274f, -0.03152572f, 0.12670779f, 0.14651507f, 0.01165677f, 
    0.26106957f, 0.30017054f, 0.08007561f, -0.23333499f, -0.03756150f, -0.06471737f, 0.04541221f, -0.07387309f, 
    0.04688089f, 0.05041133f, -0.08916868f, -0.17134053f, -0.03620221f, -0.01411634f, 0.08219355f, -0.15656804f, 
    -0.05264595f, 0.06597564f, 0.00927457f, -0.04737471f, 0.04793228f, -0.14492518f, 0.10580057f, -0.11939531f, 
    -0.01772940f, -0.05261862f, 0.05653139f, 0.03577292f, 0.03082995f, 0.01943573f, 0.03219793f, 0.06239745f, 
    -0.03348418f, 0.06067334f, -0.04843045f, -0.02470617f, 0.00306548f, -0.02042900f, -0.06527988f, 0.04106380f, 
    0.05934738f, -0.05569140f, 0.06272349f, -0.01308781f, -0.00965444f, -0.07184315f, -0.02239135f, 0.02389131f, 
    -0.05108950f, -0.07096655f, 0.04250739f, -0.03231199f, -0.00417660f, -0.00725892f, -0.00501851f, 0.00878701f, 
    -0.04656165f, -0.06698755f, 0.06561354f, -0.01292384f, -0.03402673f, -0.05187833f, 0.00110224f, -0.05526959f, 
    -0.05149335f, 0.05906177f, -0.03635020f, 0.05440242f, 0.04570745f, -0.07183650f, -0.00143593f, 0.03530074f, 
    -0.04548038f, -0.04634349f, -0.00744342f, 0.01999973f, 0.02324510f, -0.06854772f, -0.07612612f, -0.04800171f, 
    0.04923441f, -0.04079819f, -0.05950752f, 0.05903376f, -0.02401776f, 0.02362936f, 0.06411491f, 0.04983590f, 
    0.02091982f, -0.00491368f, -0.07705244f, 0.00311749f, 0.02707894f, -0.04847364f, 0.06243083f, -0.06513999f, 
    0.02556919f, -0.03758361f, -0.03080942f, -0.06598994f, -0.00023057f, 0.02939069f, -0.05936446f, -0.05331738f, 
    0.00930822f, -0.05585532f, 0.01908001f, 0.06588433f, -0.05550459f, 0.02613562f, -0.04433695f, -0.06877885f, 
    -0.06416883f, -0.04464258f, 0.05072118f, -0.00686866f, -0.02273193f, -0.03784036f, -0.02372982f, -0.06163159f, 
    -0.03830256f, 0.00913291f, -0.02323956f, -0.04382322f, -0.07304099f, -0.04692798f, 0.01268955f, 0.00483353f, 
    -0.04832759f, 0.03212938f, -0.05723559f, -0.04413424f, -0.02775331f, -0.01487166f, -0.01437985f, 0.00453064f, 
    0.02159643f, -0.04292025f, 0.03606201f, 0.06133815f, -0.03817022f, 0.06372654f, -0.06422227f, -0.06765278f, 
    -0.07048631f, -0.03254993f, 0.00481459f, -0.05234323f, 0.05887122f, -0.01101580f, -0.01099536f, -0.03773003f, 
    -0.05729095f, 0.02569741f, -0.04411622f, -0.06859940f, 0.01683417f, 0.06002551f, -0.00048296f, -0.04913438f, 
    -0.00163856f, 0.04791941f, 0.00963507f, -0.06741419f, -0.05320919f, 0.06531788f, -0.06572342f, -0.03906585f, 
    -0.00050109f, 0.02357284f, -0.05658478f, 0.05286071f, 0.03858899f, -0.04055396f, 0.06212901f, -0.07622737f, 
    0.05791377f, -0.01173710f, -0.03088028f, 0.03372556f, -0.06740765f, -0.02180457f, 0.06078260f, -0.02891892f, 
    0.05430158f, 0.03928592f, -0.06818303f, 0.01027783f, -0.04327104f, 0.04473977f, -0.04744987f, 0.00126899f, 
    -0.05130821f, 0.03875364f, 0.03615889f, 0.02500403f, -0.02719745f, -0.06125493f, -0.07157378f, 0.01631384f, 
    -0.05028854f, -0.05424931f, -0.07735565f, -0.06870376f, 0.04521785f, 0.02095893f, -0.03380218f, -0.00388424f, 
    -0.05947194f, -0.04154774f, -0.06513339f, -0.07285480f, -0.03765563f, -0.05350526f, 0.05442522f, -0.05418950f, 
    0.06366680f, 0.02984573f, -0.24752419f, 0.12899114f, 0.08575028f, 0.12180256f, 0.06814376f, 0.02966832f, 
    -0.09239092f, -0.19967289f, 0.00743206f, 0.07136340f, -0.02954854f, 0.08632325f, -0.06817042f, -0.00636743f, 
    -0.07795729f, -0.09200434f, -0.01915263f, -0.00260004f, -0.00779716f, -0.00282946f, 0.12100266f, 0.04286243f, 
    -0.13777980f, 0.01149877f, -0.13632825f, 0.10667343f, -0.07085361f, -0.06331026f, -0.07532522f, 0.00762640f, 
    -0.02608542f, 0.03728865f, -0.03233471f, 0.05025561f, 0.33079645f, 0.18409704f, -0.10543282f, 0.04853016f, 
    0.07459565f, 0.17473029f, -0.07093055f, -0.03569882f, -0.07009439f, 0.02488328f, -0.09329083f, -0.01034855f, 
    0.02357973f, -0.28715351f, 0.05135962f, -0.04358768f, 0.15196574f, 0.04699669f, 0.11798744f, 0.03121131f, 
    -0.06458656f, -0.06621272f, -0.00448441f, 0.06795604f, 0.21637629f, 0.06492060f, -0.39045724f, -0.28015321f, 
    -0.19412935f, -0.00469348f, -0.06460574f, -0.06320297f, -0.11772400f, 0.03717423f, -0.07733095f, -0.11260950f, 
    0.17107886f, -0.20930502f, -0.04538349f, -0.10024430f, -0.03227049f, 0.00237849f, 0.15739688f, 0.04552240f, 
    -0.04663836f, 0.15552442f, 0.04638363f, 0.17013876f, 0.32409281f, 0.14436962f, 0.16179426f, -0.08764905f, 
    -0.09142078f, 0.08406737f, 0.04315234f, -0.23330946f, 0.12381426f, 0.01908368f, 0.18010224f, -0.04274711f, 
    0.22701260f, 0.14221595f, -0.35870847f, 0.10945526f, -0.01563067f, 0.04463398f, 0.17273909f, 0.07908892f, 
    0.06201846f, -0.00385727f, 0.08687443f, 0.06766744f, -0.07275824f, 0.03464171f, -0.00835834f, 0.06770778f, 
    -0.00854743f, -0.09463394f, -0.02251944f, 0.02811988f, -0.04118666f, 0.05028026f, 0.05700328f, 0.10789619f, 
    0.32579115f, 0.27931595f, 0.12101963f, -0.50399792f, 0.21614960f, 0.04096084f, 0.13500825f, 0.15226020f, 
    -0.06235921f, 0.03025123f, -0.08019048f, 0.01499311f, 0.00218427f, -0.21934159f, -0.14448322f, 0.04636300f, 
    0.06202932f, -0.00842449f, 0.18528332f, 0.09971155f, -0.21132894f, 0.16407563f, 0.02578191f, 0.05059939f, 
    0.18887070f, -0.05414598f, 0.19117261f, 0.11650608f, 0.08171950f, 0.20799826f, 0.18437311f, 0.08425824f, 
    -0.06485763f, 0.08011337f, -0.00680843f, 0.10343855f, -0.08775048f, -0.07236961f, -0.20676488f, -0.07666387f, 
    0.01277248f, 0.06119904f, 0.14263538f, 0.06707013f, 0.08786330f, 0.12774530f, 0.08441965f, 0.02541569f, 
    0.14428398f, 0.42589417f, -0.29389310f, -0.02205680f, 0.00522002f, 0.10298398f, -0.02034170f, -0.02493137f, 
    -0.04713365f, 0.01090498f, -0.00565917f, -0.00706132f, -0.17013937f, 0.04678405f, 0.05084059f, -0.14915197f, 
    -0.10785528f, -0.05646406f, -0.02346098f, -0.03423403f, 0.03677912f, -0.04074046f, 0.14662699f, -0.07708684f, 
    -0.39040458f, -0.40393505f, -0.32719517f, 0.08880578f, 0.20170365f, -0.06442190f, 0.18464763f, -0.09693883f, 
    -0.08740092f, -0.05202601f, -0.12512101f, 0.00244080f, 0.34669751f, 0.33505324f, 0.33910879f, 0.31315172f, 
    -0.11290321f, -0.05958170f, -0.04395971f, 0.00265822f, -0.00556131f, 0.04821357f, -0.05686762f, 0.18153186f, 
    0.14455524f, -0.04079708f, 0.19202411f, 0.12732662f, 0.05204377f, 0.04155341f, -0.01220650f, -0.00456227f, 
    0.17904314f, 0.09345324f, 0.10700109f, -0.01549769f, 0.13391638f, -0.29722688f, -0.31100738f, -0.26106173f, 
    0.22503608f, 0.15917188f, 0.10689361f, -0.18520579f, -0.12991881f, -0.07684856f, -0.01480138f, -0.01786360f, 
    0.13654247f, -0.20234817f, -0.02329469f, 0.29176491f, 0.13546425f, -0.06741504f, 0.20277782f, 0.14883405f, 
    -0.07555849f, 0.07177577f, 0.12328384f, 0.15394360f, -0.58182752f, -0.22417171f, -0.03781264f, -0.07594168f, 
    0.12722158f, 0.04505492f, -0.04791534f, -0.06016396f, -0.08289885f, -0.06957798f, -0.00634839f, -0.17675187f, 
    0.17739703f, -0.03048030f, 0.21348463f, -0.06832036f, -0.23442261f, 0.10373730f, -0.00907996f, 0.12907726f, 
    -0.07561842f, 0.08674747f, -0.18677092f, 0.02386276f, 0.04480105f, 0.08589150f, -0.11193626f, -0.02296111f, 
    -0.03843753f, 0.40549204f, 0.12441619f, 0.24372062f, -0.01670271f, 0.07897486f, 0.14864500f, -0.02170997f, 
    0.35448983f, 0.30997267f, 0.10797119f, 0.19400164f, 0.03457059f, -0.01560066f, -0.06366670f, 0.06667330f, 
    -0.07266936f, 0.06115822f, -0.15927269f, 0.09614523f, 0.09419843f, 0.15304475f, 0.04489915f, 0.10847308f, 
    -0.06969687f, -0.12370323f, -0.09291012f, 0.02433543f, -0.04694922f, -0.00241081f, -0.00872537f, 0.03333488f, 
    0.33800721f, -0.13056156f, -0.05449542f, -0.26541233f, -0.08644967f, 0.13405788f, -0.23479898f, -0.12771618f, 
    -0.04836599f, -0.09657282f, 0.12447470f, -0.05583515f, 0.20740430f, 0.18332449f, 0.15516824f, -0.01847792f, 
    -0.08331500f, -0.16805112f, 0.11297745f, -0.01216534f, -0.14671895f, 0.11047293f, -0.00264382f, -0.13481447f, 
    -0.52082437f, -0.62024826f, -0.34933648f, -0.23462656f, -0.13954662f, -0.04549059f, 0.08141015f, 0.02797093f, 
    -0.03033656f, 0.04169792f, 0.09903448f, -0.04258358f, 0.10264800f, 0.13811807f, 0.06835033f, -0.17977390f, 
    -0.01580046f, 0.05503804f, 0.06034534f, -0.03709945f, 0.04727460f, 0.18827838f, 0.06774180f, 0.20704819f, 
    0.22594957f, 0.30567652f, 0.11288077f, 0.37664911f, -0.08231913f, 0.20269108f, 0.08735923f, -0.03587436f, 
    0.00706867f, -0.09805229f, 0.03308858f, 0.06055175f, 0.06923334f, 0.12126664f, 0.03866323f, -0.05373299f, 
    -0.07886643f, 0.02569897f, -0.02276637f, -0.05678385f, 0.30255952f, -0.17599988f, -0.06423702f, 0.16766077f, 
    -0.03423847f, 0.07093201f, -0.04468316f, 0.01258458f, -0.03948213f, 0.00796558f, -0.03711133f, 0.00666059f, 
    0.03771103f, -0.04153505f, -0.00479104f, -0.04388640f, -0.06556751f, -0.05290860f, -0.08116405f, 0.04111317f, 
    0.05612195f, -0.05661643f, -0.05411081f, 0.05368696f, 0.03502680f, 0.00661504f, 0.06564555f, -0.05341630f, 
    -0.00969933f, -0.03003223f, 0.01663206f, -0.02457543f, 0.07302869f, -0.07308358f, 0.00576521f, 0.03865185f, 
    -0.03900946f, -0.02768121f, 0.03068553f, -0.03816636f, -0.07108509f, -0.04000111f, -0.03285359f, -0.03766391f, 
    0.00442674f, 0.06202700f, -0.01275332f, 0.01269098f, -0.01936026f, -0.00501485f, 0.04192488f, -0.04140431f, 
    -0.04815980f, 0.08845137f, -0.01308382f, 0.07356148f, 0.05417641f, -0.00403591f, -0.04992779f, 0.00574444f, 
    0.06847297f, 0.04644632f, -0.03252161f, 0.04358922f, -0.02092190f, 0.04784181f, 0.05118054f, -0.01060309f, 
    -0.00920536f, 0.01901611f, -0.03862786f, 0.03540679f, -0.02091906f, -0.04503124f, -0.04096545f, 0.02217843f, 
    -0.04545587f, 0.00780187f, 0.04759254f, 0.03546969f, -0.03622451f, 0.01710452f, -0.08868958f, -0.04917029f, 
    -0.05077633f, -0.00048759f, -0.02545100f, -0.00702722f, -0.07110752f, -0.03071414f, 0.02893068f, -0.06999950f, 
    0.03786925f, -0.05949035f, 0.00365316f, 0.05385075f, -0.00169905f, -0.03280640f, -0.07688857f, 0.05870679f, 
    -0.00991608f, -0.07823493f, -0.05948247f, -0.01196766f, 0.00527896f, -0.05042362f, -0.07134902f, 0.05891173f, 
    -0.05255203f, -0.00733388f, 0.01045018f, -0.00718330f, -0.00727219f, -0.01520548f, -0.07406173f, -0.03576149f, 
    0.03361025f, -0.05100658f, -0.00866759f, -0.08151655f, -0.01353520f, -0.01152939f, 0.03867539f, 0.04105599f, 
    -0.04577807f, -0.08282755f, -0.03936993f, -0.06619810f, -0.08860811f, -0.06066189f, -0.02520472f, 0.01561152f, 
    -0.05260749f, 0.05058070f, -0.04401697f, 0.01911948f, -0.04267676f, -0.04551062f, -0.01259457f, 0.00706952f, 
    0.02883218f, 0.01939439f, -0.08116242f, -0.00007604f, 0.01283313f, 0.01669304f, -0.00469527f, -0.00035032f, 
    0.01057821f, -0.02554432f, -0.03970452f, 0.00993668f, 0.02512942f, 0.00071083f, 0.02335976f, -0.07218277f, 
    -0.07657628f, -0.06350248f, 0.02849800f, 0.01785609f, 0.00380283f, 0.03777044f, 0.05424810f, 0.00607125f, 
    -0.08093171f, -0.05421805f, -0.00257735f, -0.03034212f, 0.06323771f, 0.01447198f, -0.04519946f, 0.02142797f, 
    0.02294743f, 0.00602617f, -0.00981992f, -0.04969597f, 0.00704895f, -0.00389238f, 0.07809941f, 0.01839414f, 
    0.04624392f, -0.00040286f, 0.03092593f, -0.03830380f, -0.05243322f, -0.01902798f, -0.05513657f, -0.04440810f, 
    0.02930310f, -0.07796820f, 0.02294312f, -0.06913413f, -0.01791332f, 0.03714116f, -0.03616839f, -0.01113210f, 
    -0.48786294f, -0.30525354f, -0.31041628f, -0.12182336f, 0.03644967f, -0.12577721f, 0.20172018f, 0.04433917f, 
    -0.04304741f, 0.09582506f, -0.04656662f, 0.07079739f, 0.32021964f, 0.32130322f, 0.37966895f, 0.09878986f, 
    0.03886541f, -0.01277270f, -0.04998537f, -0.06588600f, -0.01241643f, 0.09750736f, -0.01639409f, 0.16201532f, 
    0.04755917f, 0.07787105f, 0.16013041f, 0.04485328f, 0.14101572f, 0.01596565f, -0.00499088f, -0.07933292f, 
    0.16209862f, 0.13280281f, -0.03818639f, 0.06935652f, -0.33063185f, -0.67648780f, -0.31418651f, -0.30758184f, 
    0.02707143f, 0.10584815f, 0.08908290f, -0.10961246f, -0.02293972f, -0.01699968f, -0.00470629f, 0.03721981f, 
    0.23760016f, -0.31525841f, -0.17214204f, 0.08299885f, 0.18043020f, 0.08669936f, 0.03156023f, 0.15325792f, 
    0.14104433f, 0.18912718f, 0.31582791f, 0.15064253f, -0.35665774f, -0.12219744f, -0.11950549f, -0.20677628f, 
    -0.15429284f, 0.13639913f, 0.01400583f, -0.16124250f, -0.08842340f, -0.07250945f, 0.03491466f, -0.03527363f, 
    0.16671182f, 0.04579448f, 0.01160024f, -0.00830331f, -0.06627823f, 0.11007858f, 0.05244914f, 0.03988127f, 
    -0.04979838f, -0.04569422f, -0.05619632f, 0.07762355f, 0.10357362f, -0.08100624f, -0.15623389f, 0.00291827f, 
    0.01923999f, 0.08602585f, 0.22395073f, -0.07758179f, -0.07254193f, -0.04349468f, 0.09491429f, -0.10767283f, 
    0.25441936f, 0.12719969f, -0.21941790f, 0.06067086f, 0.17930160f, -0.03861307f, 0.01594271f, -0.10454956f, 
    0.05025653f, 0.05845301f, -0.10350938f, 0.04191756f, -0.08295824f, 0.07226744f, 0.05676009f, 0.05555528f, 
    -0.08014324f, -0.13212530f, -0.02815033f, -0.05441766f, -0.00065766f, 0.05210024f, -0.01054973f, -0.02895829f, 
    0.40935591f, -0.20213073f, -0.06981223f, -0.39577958f, -0.02133624f, 0.08279008f, -0.10345488f, 0.06313404f, 
    0.03471516f, -0.00148260f, 0.14666367f, -0.03990106f, 0.04749024f, 0.21738587f, 0.12741902f, -0.00916184f, 
    0.05379378f, -0.15757629f, 0.02757180f, 0.03654405f, -0.09734242f, -0.04882466f, 0.01905514f, -0.13130189f, 
    -0.48583007f, -0.35641083f, -0.20192647f, -0.21816781f, -0.07656039f, 0.02555267f, -0.04985855f, 0.07383119f, 
    0.10529996f, 0.04189076f, -0.12325385f, 0.03490759f, 0.13976493f, 0.20531963f, 0.05006035f, -0.08673932f, 
    -0.10128056f, -0.09207764f, -0.04128246f, -0.11046549f, 0.08989801f, 0.18642324f, 0.05278092f, 0.09342597f, 
    0.17239654f, 0.06514735f, 0.14581841f, 0.13290183f, 0.15180005f, 0.02852951f, 0.22491102f, 0.04181432f, 
    -0.04734546f, 0.05766582f, 0.04554446f, 0.01301457f, 0.09108289f, 0.02537866f, 0.03980020f, -0.05200404f, 
    0.01769526f, -0.02318561f, 0.00849660f, -0.02211423f, 0.11320335f, 0.06918614f, 0.08403245f, -0.01012957f, 
    -0.01174616f, 0.08390600f, 0.07437740f, -0.16365810f, -0.00360075f, -0.03290233f, -0.12179610f, -0.20877264f, 
    0.01469091f, -0.07422195f, 0.00855858f, -0.11292908f, -0.14705393f, -0.13380671f, -0.11200535f, -0.01082504f, 
    -0.00428141f, 0.06858618f, 0.01241335f, 0.08998657f, -0.08910475f, -0.06850348f, 0.02200355f, -0.08656484f, 
    -0.05408118f, 0.06162423f, -0.01844409f, 0.07671547f, 0.13056387f, -0.02860467f, 0.07182104f, 0.07276598f, 
    0.15094388f, -0.13153972f, 0.08007824f, -0.10698028f, -0.45109060f, 0.00372150f, 0.21218337f, -0.06876185f, 
    -0.07773902f, 0.12586525f, 0.00554771f, 0.02320522f, -0.00861706f, 0.00721092f, 0.08235869f, 0.06306561f, 
    0.03405464f, 0.21606843f, -0.08787870f, -0.22459504f, -0.10295542f, 0.09669583f, 0.13409829f, -0.04530942f, 
    0.05107446f, -0.09511957f, 0.06386347f, 0.11512399f, 0.10823713f, 0.11916453f, 0.23893736f, -0.16016974f, 
    -0.20410782f, -0.04014533f, -0.11680654f, -0.12630029f, 0.06583687f, -0.01487871f, 0.00121888f, -0.08801365f, 
    0.17651981f, -0.43741426f, 0.17641370f, 0.04359840f, 0.16602750f, 0.02423750f, -0.06020408f, 0.25238836f, 
    0.03447292f, 0.01497423f, 0.13541852f, 0.04525519f, -0.08544059f, -0.18158297f, 0.28759384f, 0.09499761f, 
    0.02823390f, 0.00039953f, 0.07581196f, -0.02595993f, -0.05307370f, 0.33409199f, -0.12509482f, -0.14576611f, 
    0.23315232f, -0.28368065f, 0.02720975f, -0.12034231f, -0.06660018f, 0.09548701f, 0.01288802f, 0.38726956f, 
    0.04347464f, 0.20999448f, 0.04976887f, 0.07871228f, -0.10844679f, -0.00340487f, -0.10765185f, 0.03931054f, 
    0.18853016f, 0.11407898f, 0.04628075f, -0.03470509f, 0.11583537f, -0.09661242f, 0.08751781f, -0.09131363f, 
    0.02633478f, -0.19293903f, 0.13484117f, -0.13875096f, -0.11844092f, 0.10826800f, -0.08824538f, -0.07994665f, 
    -0.03646325f, -0.00505803f, 0.15167317f, 0.03882167f, 0.01817859f, -0.07540910f, -0.02624684f, -0.06837312f, 
    0.19316792f, 0.18326579f, 0.00796458f, 0.08411701f, 0.09184975f, 0.03432519f, 0.06608792f, -0.03149102f, 
    -0.29478619f, 0.32649660f, 0.31580967f, 0.13342166f, -0.07152491f, -0.02196667f, -0.09909879f, 0.02544023f, 
    -0.02514638f, 0.06559569f, -0.04786234f, 0.13737088f, -0.19751446f, -0.08215609f, 0.05007526f, 0.07280210f, 
    -0.01731963f, 0.07227339f, -0.01400625f, 0.03960940f, 0.18165597f, 0.13393208f, 0.08226817f, -0.03025922f, 
    -0.12069451f, -0.12285506f, -0.03204711f, 0.44665861f, 0.16535282f, 0.10630213f, 0.05726805f, 0.04272565f, 
    -0.07738394f, -0.14183953f, -0.07394609f, 0.16383994f, -0.06131703f, -0.03232049f, -0.02941104f, -0.06565744f, 
    0.01082264f, -0.02392073f, 0.08524456f, 0.11730755f, -0.10506311f, 0.10131188f, 0.08854378f, 0.18488334f, 
    0.30825678f, 0.06745873f, 0.20554447f, 0.16114040f, -0.03127518f, 0.03450074f, 0.05300856f, 0.15153313f, 
    0.08305716f, -0.00878895f, 0.05114565f, 0.07501768f, -0.47221261f, -0.55238497f, -0.17511962f, 0.07490946f, 
    -0.02381318f, -0.01379223f, 0.03937724f, -0.08157221f, 0.11833578f, -0.12628818f, -0.01504064f, 0.02327683f, 
    -0.18045422f, -0.38294917f, -0.12148517f, -0.34662619f, 0.03921912f, -0.06802423f, 0.00623269f, -0.14183743f, 
    0.19273138f, -0.06852479f, 0.13911808f, 0.10622486f, 0.15939301f, 0.08963908f, 0.23003951f, -0.16204835f, 
    0.06630944f, -0.01298559f, 0.11287457f, 0.04607293f, -0.07084283f, -0.06587008f, -0.01500441f, -0.07423643f, 
    0.24198566f, 0.31243965f, 0.01525592f, 0.22638777f, 0.03036894f, 0.10101206f, 0.10373150f, 0.11599816f, 
    -0.15252629f, -0.14079913f, -0.06960639f, -0.17398764f, 0.36491224f, 0.25554106f, 0.03095154f, 0.17602396f, 
    0.15816104f, 0.00757947f, 0.10756531f, 0.16551192f, 0.04939855f, -0.20048170f, -0.06928004f, -0.03067259f, 
    -0.00800772f, 0.04799471f, -0.08680425f, -0.06210784f, 0.13854246f, 0.11592764f, -0.05643556f, 0.15491040f, 
    -0.09582642f, -0.09454928f, -0.00942933f, -0.03454756f, 0.24477911f, 0.19085765f, -0.20777322f, -0.34371549f, 
    0.10420505f, 0.11958268f, -0.28019553f, -0.13068298f, -0.03374468f, 0.00847704f, -0.12072405f, 0.09696203f, 
    0.02580925f, 0.24874252f, 0.33033660f, -0.06318734f, 0.04046238f, 0.09037030f, -0.02680996f, 0.11971410f, 
    0.06708851f, -0.11483544f, -0.08001504f, 0.12099324f, -0.05691324f, -0.36015010f, -0.02745142f, -0.20502190f, 
    -0.05193641f, -0.00185807f, -0.09669094f, -0.04618344f, 0.16865157f, 0.26202425f, 0.25891665f, 0.17247434f, 
    0.28977990f, 0.30609936f, 0.68920124f, 0.03099709f, 0.03380687f, 0.24380468f, 0.13278504f, 0.01206025f, 
    -0.14417507f, 0.04216151f, -0.02355209f, 0.11792520f, -0.20478386f, 0.18621831f, -0.19686975f, 0.02073254f, 
    0.07219327f, 0.14115658f, 0.06244749f, -0.06949382f, 0.12504259f, 0.11480905f, 0.09837675f, -0.01677085f, 
    0.14659098f, -0.08640273f, -0.44749409f, 0.10829910f, 0.07976653f, 0.02214185f, 0.01749548f, 0.07731026f, 
    -0.05742360f, -0.12954806f, -0.07070225f, 0.01064509f, -0.06315196f, 0.02805388f, 0.10656175f, -0.01200037f, 
    -0.11972072f, -0.02200032f, -0.12434257f, -0.14631072f, 0.06775457f, 0.02413113f, 0.09034108f, 0.14333048f, 
    0.33325046f, -0.35847491f, 0.25213015f, 0.04027523f, 0.03853953f, 0.06017604f, 0.13081954f, 0.06308186f, 
    -0.01906282f, 0.10218526f, -0.03151910f, -0.08916856f, -0.08846940f, -0.23693025f, -0.07666681f, -0.05497950f, 
    -0.03996475f, 0.09287432f, -0.07569151f, -0.06225753f, 0.00083183f, 0.04076831f, -0.05972555f, -0.09210716f, 
    0.04274183f, 0.02612991f, 0.05873587f, 0.05009503f, 0.06186904f, -0.03269875f, -0.03416669f, -0.06649189f, 
    0.02687645f, 0.02864259f, -0.05964866f, -0.03048184f, -0.02267803f, 0.03677549f, -0.02770658f, -0.03870610f, 
    -0.07156008f, -0.05967464f, -0.04081254f, 0.02653030f, -0.08306163f, 0.01723140f, 0.00536495f, -0.08157147f, 
    0.00677432f, -0.02490846f, -0.05784574f, 0.03970651f, -0.02956491f, -0.02649383f, 0.03582023f, -0.05825134f, 
    -0.05401853f, -0.07743477f, -0.03183619f, -0.04917901f, 0.04611827f, -0.05852592f, 0.02484077f, -0.01328450f, 
    -0.06384519f, -0.07572831f, 0.00325846f, 0.00996234f, -0.00027296f, -0.01512645f, -0.04506411f, 0.02889329f, 
    -0.06380034f, -0.05601592f, 0.04786729f, -0.04211529f, -0.06509376f, -0.07959989f, 0.05140803f, -0.01139111f, 
    -0.01177924f, -0.07559133f, -0.02518520f, -0.00309319f, 0.03489166f, -0.01772057f, -0.06140195f, 0.06197395f, 
    0.02489034f, 0.03515844f, -0.03969130f, -0.04405038f, -0.04276687f, -0.05010958f, 0.00516837f, -0.06196335f, 
    0.00204089f, 0.03712299f, -0.01972080f, -0.00249707f, -0.01639893f, -0.03801312f, -0.06949631f, -0.00126706f, 
    0.00680845f, 0.03855594f, 0.02507367f, 0.06332497f, 0.07287189f, 0.06325151f, 0.05242353f, -0.08202671f, 
    0.05020849f, 0.01979410f, -0.05690869f, -0.08146898f, 0.02670965f, -0.00063419f, -0.02671371f, 0.05225813f, 
    0.07033218f, -0.01490535f, -0.01547545f, -0.04365908f, 0.00323225f, -0.08092475f, -0.06755568f, 0.04664822f, 
    -0.06704675f, -0.03954020f, -0.02210291f, 0.02811890f, 0.01538631f, 0.05446823f, -0.04549772f, -0.07050176f, 
    0.01549757f, 0.01044489f, 0.00721446f, 0.05440273f, -0.00310032f, 0.04758006f, 0.01833637f, 0.06375539f, 
    -0.02394731f, 0.01936261f, -0.01505405f, -0.03861382f, -0.03569721f, 0.03993103f, -0.01422706f, -0.04193917f, 
    -0.04292983f, 0.02289518f, -0.02356046f, -0.00371453f, 0.04500388f, 0.06060447f, 0.05046391f, 0.01891158f, 
    -0.08113444f, 0.04845393f, 0.02833096f, -0.02123929f, -0.05911887f, -0.03142938f, -0.05716490f, -0.00699450f, 
    -0.02832924f, -0.01877225f, 0.04440700f, -0.03371656f, 0.03467118f, -0.04826894f, 0.00505310f, -0.00978287f, 
    0.06036486f, -0.00242693f, -0.06424720f, 0.05620984f, -0.05707080f, 0.00392331f, -0.01910804f, -0.06798707f, 
    0.03852579f, -0.02826439f, 0.03712048f, -0.01289397f, -0.06634478f, 0.05791657f, 0.02702481f, -0.06424952f, 
    -0.03582222f, -0.07296799f, 0.02138839f, -0.06935859f, 0.03515432f, 0.01941042f, -0.00407068f, 0.00085345f, 
    -0.03432409f, -0.02291757f, -0.03777861f, -0.02963277f, 0.01568996f, 0.00582030f, 0.02233969f, 0.05315030f, 
    -0.05685040f, 0.03283897f, -0.00716358f, 0.00166838f, -0.00090586f, 0.02043417f, 0.05457612f, 0.05246394f, 
    -0.03682877f, 0.00026229f, -0.04896747f, -0.03307919f, -0.07502050f, -0.07529698f, -0.05988073f, -0.05084483f, 
    0.02193860f, 0.03430009f, -0.02107287f, 0.01025256f, 0.04797371f, -0.02803480f, 0.01787982f, -0.02059278f, 
    -0.04605414f, -0.02827747f, 0.05713147f, -0.00317017f, 0.03849972f, -0.00130865f, 0.00166586f, -0.00158473f, 
    -0.02632811f, -0.04138475f, -0.07664094f, -0.00195217f, 0.01642828f, 0.03629148f, -0.00657786f, -0.03662477f, 
    -0.04665927f, -0.02136564f, 0.01301702f, 0.03088287f, -0.01925254f, -0.00719201f, 0.02168322f, 0.05805055f, 
    0.02346824f, 0.03544437f, 0.03891860f, 0.02393087f, -0.00557284f, 0.05118957f, -0.06876775f, -0.00833922f, 
    -0.05192938f, 0.01922635f, -0.00604430f, 0.01511693f, 0.04431144f, -0.02273455f, -0.07596489f, 0.01932550f, 
    0.04940738f, 0.04107698f, 0.00116363f, -0.01167695f, -0.01145753f, 0.00750147f, 0.01063433f, -0.02690053f, 
    -0.08113278f, -0.01633517f, -0.04465462f, -0.06522493f, -0.02045489f, -0.01503831f, 0.00069985f, -0.04219230f, 
    -0.00904380f, 0.06474190f, -0.06189362f, -0.07748685f, 0.05284264f, -0.05079896f, -0.06930055f, -0.06792378f, 
    0.02806265f, -0.06111026f, -0.05736328f, -0.03678463f, 0.00752702f, 0.04079603f, -0.06990984f, -0.00840604f, 
    -0.00721218f, -0.00182815f, 0.02174211f, 0.01957543f, 0.03803277f, 0.04947147f, -0.00927142f, 0.02438392f, 
    -0.01036942f, 0.05528420f, -0.05026957f, 0.05262688f, 0.01367609f, 0.01217915f, 0.00587296f, -0.03350237f, 
    -0.06018388f, 0.04895736f, 0.05220338f, 0.03581689f, 0.02426332f, -0.01434909f, 0.02954743f, -0.04535331f, 
    0.03955450f, -0.03860109f, 0.03391530f, -0.06045702f, -0.00781073f, -0.03833960f, 0.01682081f, 0.04277596f, 
    0.01414734f, -0.00268631f, 0.04229066f, -0.01548450f, -0.06665929f, -0.04745413f, -0.06615816f, 0.02848385f, 
    -0.02397209f, 0.02755920f, -0.04818922f, 0.05945925f, -0.02695795f, -0.01018523f, -0.01417035f, 0.01696099f, 
    0.02692475f, -0.05243127f, -0.03738659f, -0.05986799f, -0.00082913f, -0.03051216f, 0.03544616f, -0.04415597f, 
    0.00629847f, 0.04318193f, -0.04215240f, 0.02937257f, -0.04618035f, -0.04100812f, -0.00579267f, -0.07928269f, 
    -0.01616468f, 0.04873978f, 0.00304948f, -0.02804388f, -0.06767400f, -0.06659137f, -0.07181791f, -0.02579515f, 
    -0.03756797f, 0.05316028f, -0.07074951f, 0.03444135f, -0.00747529f, -0.06515641f, -0.00477836f, 0.06584498f, 
    0.05990531f, 0.02052273f, -0.07302689f, -0.08055642f, -0.01515086f, 0.03075270f, 0.01841851f, -0.01068386f, 
    0.06082790f, -0.08029943f, -0.05330982f, 0.01078652f, -0.03485454f, -0.00038619f, 0.02790765f, 0.01732295f, 
    -0.05687658f, 0.00898829f, -0.07418635f, -0.06369635f, 0.03902157f, 0.02952420f, 0.00162730f, 0.01479998f, 
    -0.05742029f, -0.04938108f, 0.24081431f, -0.01388648f, -0.11185698f, -0.17261750f, -0.11012983f, -0.06359784f, 
    0.03509961f, 0.00924797f, 0.03967172f, 0.00894617f, -0.10997325f, -0.23642342f, 0.01284934f, 0.07941919f, 
    -0.03945388f, 0.04105217f, 0.06500366f, -0.01367969f, 0.01631971f, -0.06382383f, -0.08412015f, -0.12705523f, 
    -0.23448706f, -0.01904666f, 0.03231924f, -0.09074193f, 0.09650314f, 0.03139847f, -0.09106223f, 0.11282927f, 
    0.13865300f, -0.13166660f, 0.04807383f, 0.14789526f, -0.37653747f, -0.36244434f, -0.07537018f, -0.20789453f, 
    -0.10994983f, -0.09341985f, 0.14231619f, 0.03179136f, -0.01018688f, 0.03198327f, 0.08176611f, -0.00636207f, 
    -0.11071397f, 0.23505586f, -0.09813644f, 0.06574786f, 0.00951377f, 0.19111645f, 0.12023807f, 0.09848107f, 
    0.29314691f, 0.08930125f, 0.06325346f, -0.04419101f, 0.02284984f, 0.02623124f, 0.41152459f, 0.07613043f, 
    -0.00932824f, 0.02321513f, 0.01280539f, -0.05651717f, 0.04030275f, 0.01035489f, 0.09400773f, -0.05752183f, 
    -0.06189576f, 0.05868853f, 0.17879823f, -0.12137964f, 0.08629163f, 0.10790084f, -0.14964503f, 0.24157867f, 
    0.00823158f, -0.05885149f, 0.16694713f, 0.12464301f, -0.63632792f, 0.09539645f, 0.14343733f, 0.30406478f, 
    0.14047234f, 0.17229614f, -0.05708529f, 0.09005566f, -0.06779230f, 0.14875464f, -0.13094822f, 0.02886431f, 
    0.17198624f, -0.24210680f, 0.35806471f, 0.00236556f, -0.08712853f, 0.16081107f, -0.01514198f, 0.33111596f, 
    -0.02577008f, 0.17718616f, 0.15850501f, -0.00596844f, -0.10896053f, 0.01146320f, -0.11978225f, -0.02073644f, 
    -0.02291061f, 0.05299121f, -0.00733158f, -0.08440466f, 0.01710103f, -0.05329383f, 0.05284095f, -0.01938292f, 
    0.08387447f, -0.07908646f, -0.07500689f, 0.15778747f, -0.00628750f, 0.04687596f, 0.12454556f, -0.13930513f, 
    -0.00238343f, 0.03924973f, 0.18527496f, 0.07720249f, 0.13325556f, 0.01526763f, 0.05857606f, -0.27071512f, 
    0.07144903f, 0.12847389f, -0.11388896f, 0.07342934f, 0.06557349f, 0.03497310f, 0.03795407f, -0.06955042f, 
    -0.33627197f, 0.09506309f, 0.19047673f, 0.22282694f, 0.04357358f, -0.11513664f, 0.04266952f, 0.20055865f, 
    -0.04916570f, -0.00052151f, -0.03317441f, 0.09354527f, -0.09280149f, 0.03079384f, 0.09165977f, -0.09037989f, 
    -0.04223242f, 0.03482509f, -0.09372316f, -0.07721365f, 0.05741080f, 0.08225575f, 0.05566449f, 0.13214409f, 
    -0.08786546f, -0.20832165f, 0.12112326f, 0.49792108f, 0.16448186f, 0.17490062f, 0.07929685f, -0.01305435f, 
    -0.08176230f, -0.05135918f, -0.13015062f, 0.03455341f, -0.10455776f, -0.05698889f, -0.04141541f, -0.08841738f, 
    0.04198382f, -0.04445731f, 0.03699765f, -0.07149522f, 0.06891111f, 0.29181674f, 0.14762466f, 0.09498324f, 
    0.34598812f, 0.09634768f, 0.16330267f, 0.18188840f, 0.04190968f, -0.15503983f, -0.06815098f, 0.10694055f, 
    -0.01396812f, 0.04203495f, -0.12696619f, -0.10974164f, -0.17317830f, -0.20722598f, -0.01694506f, -0.05528769f, 
    0.15359333f, 0.08581199f, 0.18745245f, -0.00279276f, 0.11070864f, 0.09588743f, -0.08325154f, -0.01118183f, 
    -0.14301580f, -0.30017102f, -0.12311482f, -0.21129389f, -0.07437859f, 0.10355544f, 0.08384322f, -0.04060684f, 
    -0.04306335f, 0.13531831f, 0.01730882f, 0.10747571f, 0.21058765f, 0.16285971f, 0.12303184f, 0.00750236f, 
    -0.11003906f, 0.06044718f, 0.26804423f, 0.14637655f, 0.21390735f, 0.10198066f, 0.23265658f, 0.18943547f, 
    0.06002805f, 0.31374660f, 0.03294674f, 0.18717986f, -0.06701813f, -0.10817120f, 0.08386128f, 0.28952074f, 
    0.00957438f, 0.27322835f, 0.18703230f, 0.18441507f, 0.52592230f, 0.21901983f, 0.19278504f, 0.27556640f, 
    0.06822599f, -0.01252167f, -0.05828409f, 0.14292996f, 0.12467308f, -0.02009987f, -0.07291960f, 0.03227367f, 
    -0.01957094f, 0.03667061f, 0.10013620f, 0.02619063f, 0.37544546f, -0.11121544f, -0.16505003f, 0.21597159f, 
    -0.06250465f, -0.11116683f, 0.01327386f, -0.03857024f, 0.04364686f, -0.49268141f, -0.46742120f, -0.21802047f, 
    -0.08794965f, -0.25675333f, -0.15858814f, 0.11298923f, -0.16565800f, -0.01308257f, -0.05880183f, -0.00283343f, 
    0.01498558f, 0.10805517f, 0.33664379f, -0.01080597f, 0.03528569f, -0.26195499f, -0.03229843f, -0.23915301f, 
    -0.08520754f, -0.00911759f, -0.25853321f, -0.07086242f, 0.01992507f, -0.02899144f, -0.06501812f, -0.01299795f, 
    0.07769116f, 0.10220825f, -0.00908460f, -0.00259588f, -0.10882275f, -0.10137076f, -0.18995474f, -0.29955450f, 
    0.00891440f, 0.00380312f, 0.37203538f, 0.26737517f, 0.08721881f, 0.10452860f, 0.08088014f, -0.27208063f, 
    0.05678171f, -0.19510378f, -0.01379777f, -0.14675458f, -0.10864902f, 0.03367275f, 0.00856777f, 0.17922635f, 
    0.16083996f, 0.09499952f, -0.18514137f, -0.03187364f, 0.04958363f, -0.17892520f, -0.12932706f, -0.16580369f, 
    0.22069333f, -0.22127065f, -0.19602153f, 0.09058341f, -0.03239004f, -0.04546028f, 0.04244276f, 0.09478754f, 
    -0.06871223f, -0.14400575f, 0.05941501f, 0.16946782f, 0.07296337f, -0.10054595f, -0.04243683f, 0.12994428f, 
    0.05119826f, 0.12604810f, -0.10100655f, -0.09398548f, 0.05285396f, -0.04684190f, 0.13125987f, 0.20795456f, 
    0.47530121f, -0.23157349f, 0.56351167f, -0.06971952f, -0.01981794f, -0.06926996f, -0.03823892f, -0.13652253f, 
    0.05927319f, 0.12664117f, -0.02569843f, -0.04175157f, -0.27286002f, -0.32029483f, -0.23963074f, 0.09587990f, 
    0.09658159f, 0.07821232f, 0.05135890f, -0.07721325f, 0.13570318f, 0.21906641f, 0.11686505f, 0.20710167f, 
    -0.12039356f, -0.14164665f, 0.04966691f, -0.09287270f, 0.06073401f, 0.00016158f, 0.11546539f, 0.08015493f, 
    0.04278781f, -0.03210470f, 0.12020606f, 0.06400579f, -0.05856621f, -0.32559270f, 0.12755050f, 0.30894712f, 
    -0.01149043f, 0.14121482f, -0.01754748f, -0.14848579f, 0.02853764f, 0.03120509f, -0.01186879f, 0.01198693f, 
    -0.03056751f, -0.01996880f, 0.13790645f, -0.22134046f, 0.06381829f, 0.01870848f, -0.06600741f, -0.13901822f, 
    -0.03128567f, 0.13226172f, 0.00976641f, 0.04199167f, -0.13396914f, -0.12988444f, -0.10800385f, -0.40128544f, 
    -0.15469059f, -0.01517036f, 0.08941571f, -0.07464813f, 0.01942499f, 0.02649015f, 0.05017168f, 0.07073028f, 
    0.07530771f, -0.06094317f, -0.03293800f, -0.01978628f, -0.01330475f, 0.08251425f, 0.03094867f, 0.27718964f, 
    0.05049684f, 0.12018664f, -0.00630981f, 0.04827046f, -0.18005089f, -0.03899562f, -0.14845841f, -0.02404265f, 
    -0.04954731f, 0.16165152f, 0.21147816f, 0.16852197f, 0.04939226f, 0.01706500f, 0.03136728f, 0.03812347f, 
    -0.10609186f, 0.24326918f, -0.02692108f, -0.03710039f, 0.27204338f, 0.00993433f, -0.21513203f, -0.03893361f, 
    0.18918005f, -0.32062784f, -0.04156933f, -0.06849929f, 0.01900615f, -0.30337510f, -0.18888529f, -0.14950763f, 
    -0.02515899f, -0.00483816f, -0.32837197f, -0.10214270f, 0.11394551f, 0.04743266f, 0.00306395f, 0.08998356f, 
    -0.16757455f, -0.12664300f, -0.02841851f, -0.07589686f, 0.25356489f, -0.07547090f, 0.23073038f, -0.19625728f, 
    0.03210348f, -0.02868466f, -0.02696916f, 0.07484903f, 0.06077908f, -0.05399789f, -0.01289728f, -0.02601284f, 
    0.02938430f, 0.03829123f, 0.02900470f, -0.14899462f, 0.02504588f, 0.11051973f, 0.11218917f, 0.19638033f, 
    0.00145958f, 0.08528616f, 0.01860410f, 0.18653324f, 0.22866498f, 0.06739146f, 0.09287806f, -0.00317425f, 
    0.02710851f, 0.08402516f, 0.09195837f, 0.24260223f, -0.47377700f, 0.35024115f, 0.03223803f, 0.12769113f, 
    0.19374505f, -0.00775308f, -0.07696497f, -0.11470181f, 0.01479502f, 0.13475573f, 0.08622686f, 0.12210703f, 
    -0.05658029f, -0.20283277f, -0.40097117f, -0.16065088f, -0.09910957f, -0.04580739f, -0.07662428f, 0.20119943f, 
    0.12636538f, 0.04881178f, 0.16678362f, 0.07331402f, 0.05572953f, 0.23424721f, 0.46258152f, 0.10753550f, 
    -0.04336377f, 0.02173089f, -0.04629564f, -0.16209380f, 0.10684580f, 0.17908539f, 0.07399634f, 0.21746548f, 
    0.11973269f, -0.43251401f, 0.27974865f, -0.22168751f, 0.12628542f, 0.09516371f, 0.06563905f, -0.10289651f, 
    0.02543687f, -0.10319424f, -0.01656901f, 0.00295516f, -0.09807182f, -0.01422333f, 0.10021964f, 0.18161465f, 
    -0.08594699f, -0.07484303f, -0.07311968f, -0.14155145f, -0.03091187f, 0.06965323f, 0.13421923f, -0.09269428f, 
    0.00830650f, -0.43041629f, -0.10012414f, -0.12794869f, 0.18074453f, 0.15225752f, 0.03899049f, 0.20762987f, 
    0.01893315f, 0.03686131f, 0.01609900f, -0.02795531f, 0.40688980f, 0.36942282f, 0.26632306f, 0.12288347f, 
    -0.08093338f, -0.01798385f, -0.01330157f, 0.05997787f, -0.05519970f, -0.03832538f, 0.04410424f, -0.02139223f, 
    0.14110139f, 0.11347476f, 0.04730711f, 0.12774739f, -0.01774860f, 0.08916699f, -0.12394364f, -0.00007396f, 
    0.05357556f, 0.10388770f, 0.10709856f, -0.00133854f, 0.05030768f, 0.23252738f, -0.19020571f, -0.35079658f, 
    0.14892876f, -0.08397830f, 0.21885826f, 0.01513975f, -0.01697181f, -0.00141118f, 0.05079524f, 0.07983653f, 
    -0.02978270f, 0.17058678f, 0.11849350f, 0.04922530f, -0.04120507f, -0.01646590f, 0.02497936f, 0.00918622f, 
    0.25723535f, 0.16060884f, 0.04719335f, 0.01247178f, -0.03615356f, -0.17291267f, -0.16845676f, 0.12597774f, 
    0.29938382f, -0.04263544f, 0.01977367f, 0.13793214f, 0.02526907f, 0.12928875f, -0.07702518f, -0.04958384f, 
    0.08425424f, 0.07916328f, 0.05190539f, 0.13321295f, 0.04014459f, -0.07331746f, 0.02552392f, -0.14869830f, 
    -0.15904994f, 0.07389835f, 0.09900959f, -0.08008337f, -0.04779813f, 0.35960487f, -0.49584356f, 0.08508199f, 
    0.03687468f, -0.10078429f, 0.17115608f, 0.36960378f, -0.00388955f, -0.00993667f, -0.00065169f, 0.13065672f, 
    -0.18033379f, 0.19681413f, 0.47292614f, -0.14912146f, -0.01702535f, 0.14340515f, -0.23137474f, -0.14164175f, 
    -0.13085406f, -0.01731088f, -0.01210592f, -0.09524712f, 0.02726049f, 0.05371461f, -0.04277563f, 0.12581630f, 
    -0.20710076f, -0.00906450f, -0.08265643f, -0.05814333f, -0.10116727f, -0.09993432f, -0.07611433f, -0.18461032f, 
    -0.48796186f, 0.24959788f, 0.03771828f, 0.18061869f, 0.03627229f, -0.19561800f, 0.27332801f, -0.02826736f, 
    -0.01458105f, -0.04165345f, -0.00739750f, 0.19777377f, 0.11719406f, 0.04593268f, 0.06732283f, 0.04903589f, 
    -0.09814441f, 0.05306518f, -0.05457094f, -0.05731649f, -0.06313550f, -0.07990411f, -0.09275409f, -0.02992239f, 
    -0.24119119f, -0.64159799f, -1.02852893f, -0.34031630f, -0.01181400f, -0.01295014f, 0.08050658f, 0.01993269f, 
    0.11805483f, -0.09981473f, 0.00522330f, -0.04947551f, 0.08887888f, 0.07194639f, -0.12895468f, 0.09564269f, 
    -0.15469523f, -0.08513456f, -0.12440425f, 0.05966942f, -0.04261936f, -0.19489531f, 0.07981791f, 0.02780801f, 
    -0.02057608f, 0.31059933f, 0.33547392f, -0.18684946f, -0.04247992f, 0.03277880f, 0.11762062f, 0.18429998f, 
    0.03974134f, 0.01697119f, 0.03234173f, -0.04574631f, 0.26915395f, 0.01751576f, 0.17193200f, 0.21258138f, 
    0.09110428f, 0.03037004f, -0.01100259f, 0.05223561f, -0.00842420f, 0.01515603f, -0.07101052f, 0.05951168f, 
    -0.12755556f, -0.01354640f, 0.06928864f, -0.17815866f, 0.02035459f, -0.02867549f, -0.03485832f, -0.00795984f, 
    0.01031600f, 0.09641060f, 0.08397742f, -0.01550455f, -0.04428015f, 0.01033591f, -0.03871017f, -0.25397068f, 
    0.03928313f, 0.06206353f, -0.17614794f, 0.04741609f, -0.03671315f, -0.03994705f, 0.10681618f, -0.00880233f, 
    -0.08763038f, -0.18184204f, -0.02179188f, -0.13880624f, 0.03075767f, 0.15506841f, 0.10597407f, 0.00731245f, 
    0.25685778f, 0.11163217f, 0.05253165f, 0.18708096f, -0.49888647f, -0.06883297f, 0.25397822f, 0.00264184f, 
    -0.19446133f, -0.10170209f, 0.12717839f, 0.08888997f, 0.11297940f, -0.20265974f, 0.01686023f, 0.05806053f, 
    -0.09675266f, 0.20315516f, -0.02406098f, -0.15922119f, 0.00684993f, 0.09364012f, 0.11149961f, 0.02775317f, 
    0.19273147f, 0.00851650f, 0.16925479f, 0.09116600f, -0.09887067f, 0.15856583f, 0.31283146f, 0.08598030f, 
    0.12381847f, 0.01516605f, 0.04207237f, -0.05081034f, 0.03394660f, -0.15754609f, -0.18461317f, -0.05794310f, 
    0.07668635f, 0.02638179f, -0.14423348f, 0.06385170f, 0.23743074f, -0.00017751f, 0.01916210f, 0.04599859f, 
    0.23221233f, 0.06208811f, 0.14779776f, -0.07100576f, -0.13425572f, -0.37077451f, -0.13344400f, -0.23130566f, 
    0.05946825f, -0.24966694f, -0.04683250f, 0.28569600f, 0.06760233f, 0.14487538f, -0.02865499f, -0.30691755f, 
    0.30334058f, -0.27031124f, 0.23369420f, -0.10153384f, 0.09722505f, 0.14649758f, -0.04244791f, 0.22228754f, 
    -0.00700455f, 0.12140216f, -0.08334084f, 0.07346696f, 0.01521185f, -0.16030557f, -0.08383782f, -0.13193704f, 
    0.01567319f, 0.17612231f, -0.10393484f, -0.07824534f, 0.02978752f, -0.19675939f, 0.00184626f, -0.16015907f, 
    0.06839081f, -0.57346493f, 0.05711728f, 0.57099032f, 0.10017484f, 0.09316906f, -0.02479378f, -0.09420834f, 
    0.10088670f, 0.06026361f, 0.21266641f, -0.01290673f, -0.14700636f, 0.04383665f, 0.05384507f, -0.31941551f, 
    0.31191954f, 0.15607679f, -0.04752867f, -0.09676819f, 0.19770281f, -0.08773305f, -0.05928595f, -0.08686461f, 
    -0.28763556f, 0.14319721f, 0.06153305f, 0.01335809f, -0.05561255f, -0.18231080f, -0.09095199f, 0.18068115f, 
    0.09820046f, -0.12342568f, 0.08429774f, -0.01277424f, -0.04689588f, -0.16915722f, 0.21334247f, 0.08993801f, 
    -0.10319181f, -0.15966377f, -0.08107919f, -0.06108833f, 0.07955240f, 0.16448463f, 0.12466317f, 0.17894994f, 
    -0.12358828f, -0.51322168f, 0.28695309f, 0.25483850f, 0.21166421f, 0.00124874f, 0.23753625f, 0.10935792f, 
    -0.06633686f, 0.01363479f, -0.11648878f, 0.04790210f, 0.05754404f, -0.20146067f, -0.10206409f, 0.00434984f, 
    0.07867675f, -0.00925147f, -0.13188767f, -0.12708311f, 0.08635232f, 0.18167827f, 0.10297235f, 0.23715924f, 
    0.21783087f, 0.24357426f, 0.07457994f, -0.10728177f, 0.10583332f, -0.13930616f, 0.00771101f, -0.02784833f, 
    -0.06226629f, -0.17525913f, -0.19007152f, -0.01240845f, -0.08972013f, -0.35645428f, -0.02353781f, 0.20023899f, 
    0.24728872f, 0.14095975f, 0.23568538f, -0.13405481f, 0.12295868f, -0.04301047f, -0.13620773f, 0.06592686f, 
    0.31255081f, -0.20124742f, 0.19238764f, -0.09540362f, -0.09109476f, -0.12411166f, -0.01612887f, -0.17197554f, 
    0.14358950f, 0.09787685f, 0.03316520f, 0.10172421f, 0.16589992f, 0.24631467f, 0.03240432f, 0.03507285f, 
    -0.02104141f, 0.30614930f, 0.03473191f, -0.08456606f, 0.11133028f, 0.02146350f, 0.07338406f, 0.12454294f, 
    0.14606498f, 0.01201476f, -0.02873977f, -0.01129127f, 0.07666112f, -0.02858440f, -0.04444970f, 0.14611137f, 
    -0.02662736f, 0.10808743f, 0.03606092f, 0.27060395f, 0.18071185f, 0.18176299f, 0.02349070f, -0.06128323f, 
    0.09136856f, -0.02184550f, 0.09955014f, 0.18810257f, 0.04986746f, -0.01841352f, 0.00951004f, -0.07766917f, 
    -0.05574138f, -0.06370264f, 0.13880412f, -0.11916346f, 0.27275038f, -0.06432371f, -0.11680616f, 0.14462361f, 
    0.00264890f, -0.29445988f, 0.13282081f, -0.20873654f, 0.67306596f, -0.80143249f, -0.01255653f, -0.44068408f, 
    -0.09546668f, -0.07924172f, -0.38519290f, 0.10120339f, 0.07847626f, 0.00305104f, -0.01192401f, 0.10971550f, 
    -0.21251181f, -0.01704288f, -0.15546091f, -0.21820761f, 0.06729557f, 0.09018710f, 0.07015340f, -0.06883691f, 
    -0.00032006f, -0.05696879f, -0.04645133f, -0.10724116f, 0.00163360f, -0.03759845f, -0.04939295f, 0.10814520f, 
    0.19546704f, 0.16229871f, 0.02749288f, 0.12569442f, 0.06380979f, 0.06079805f, -0.30439886f, -0.20882316f, 
    -0.30267230f, 0.10234561f, 0.21066250f, 0.11107706f, 0.22861037f, 0.18071826f, -0.10462686f, -0.05984450f, 
    0.01459413f, -0.16587692f, -0.10039343f, -0.11041141f, -0.32666832f, -0.01572598f, 0.01250826f, 0.15879348f, 
    0.13255164f, 0.04695264f, -0.02614602f, -0.13779254f, -0.04291106f, -0.13363600f, -0.06312487f, -0.16323808f, 
    0.34176743f, 0.23823692f, 0.03882182f, 0.15706116f, 0.03612825f, -0.07766859f, -0.10668810f, 0.02694531f, 
    -0.06975171f, -0.08741369f, 0.16656120f, 0.04641956f, -0.00803546f, 0.16651517f, 0.35625988f, 0.55770832f, 
    0.12306913f, -0.01250023f, -0.10593425f, -0.09571915f, -0.03580264f, -0.10968702f, -0.06136794f, -0.02598128f, 
    0.36314690f, -0.25290677f, 0.19747640f, 0.03170460f, 0.04363399f, 0.03709187f, 0.17441969f, 0.22188333f, 
    0.01904800f, 0.02918066f, -0.10405876f, -0.04548200f, 0.00645261f, -0.10851552f, -0.11457307f, 0.39405638f, 
    0.05505854f, -0.02624819f, -0.15871997f, -0.11778451f, 0.04447757f, 0.20104177f, -0.06952510f, 0.21303865f, 
    0.13146889f, 0.06431135f, -0.06997486f, 0.02149214f, 0.09634894f, -0.01835383f, -0.03055257f, 0.21237068f, 
    -0.19291216f, -0.18694536f, -0.11310560f, -0.16128977f, -0.15781339f, 0.14580370f, 0.11750275f, -0.08628161f, 
    -0.01168326f, -0.10177146f, 0.00055211f, 0.04466985f, -0.02188612f, -0.12362134f, 0.17430313f, -0.06490052f, 
    -0.29661044f, -0.05542509f, 0.02454448f, -0.12033830f, -0.01108413f, -0.25690711f, 0.21039820f, -0.12984255f, 
    0.03589942f, 0.18393564f, 0.08928172f, 0.11307709f, 0.21882802f, 0.02687832f, 0.03090115f, -0.00021050f, 
    0.11481544f, 0.03497101f, 0.13552000f, 0.16163222f, 0.24980436f, -0.00113226f, 0.06957945f, 0.27124742f, 
    -0.05977249f, 0.08676252f, -0.10047431f, 0.09733324f, -0.07785719f, 0.15826753f, 0.11006633f, 0.06049371f, 
    0.22105719f, 0.26804310f, 0.28591883f, 0.22626996f, 0.29165965f, 0.07282982f, -0.16999802f, -0.16395229f, 
    0.11232029f, -0.04713010f, -0.03818174f, 0.18722859f, 0.19044216f, -0.12153068f, -0.11306545f, -0.06873845f, 
    0.03920562f, 0.02045215f, -0.26619005f, 0.09578858f, 0.20160426f, -0.12540653f, 0.06788941f, -0.04064413f, 
    -0.20318501f, -0.06130039f, 0.18255319f, -0.27794465f, 0.35648027f, 0.36432472f, 0.38987756f, -0.53902292f, 
    -0.13089435f, -0.12685494f, -0.15720005f, 0.00172404f, 0.10036998f, -0.01490781f, 0.10918744f, -0.18153286f, 
    -0.24960819f, 0.15335138f, 0.01846681f, -0.11170498f, 0.22462589f, -0.10210667f, -0.04459872f, -0.01348151f, 
    -0.15424751f, -0.13862151f, -0.17712614f, -0.26901442f, -0.09780531f, -0.24315025f, 0.14371528f, -0.32362813f, 
    0.05252487f, 0.06527835f, -0.15792789f, -0.07011439f, -0.29903075f, -0.42559290f, -0.15864523f, -0.59206414f, 
    0.59082288f, 0.15331282f, 0.52633542f, 0.15784052f, 0.21602841f, 0.19610916f, -0.12195107f, -0.14107385f, 
    0.06139302f, -0.08471522f, -0.07854436f, -0.01737479f, -0.34704682f, 0.20962843f, -0.19974396f, 0.09879505f, 
    0.25568047f, 0.00719521f, -0.05742147f, -0.16897036f, -0.29679099f, -0.32118976f, -0.20448621f, -0.54077631f, 
    0.28113648f, 0.00516990f, 0.26390010f, 0.27971020f, -0.10753936f, -0.07448687f, -0.06938104f, 0.26649180f, 
    0.26786777f, -0.10039591f, 0.04328287f, 0.22735174f, 0.54947948f, 0.21731165f, 0.17049155f, -0.09065842f, 
    -0.00824710f, -0.16625637f, -0.11232734f, -0.18728811f, 0.21434388f, -0.01255186f, 0.05314412f, -0.09103444f, 
    0.09898976f, 0.11848565f, 0.18650034f, 0.04861308f, 0.08468228f, 0.20016184f, 0.06232779f, 0.05143790f, 
    0.06405323f, 0.12650682f, -0.23694408f, -0.06983465f, 0.15624350f, 0.07247300f, 0.16692019f, 0.10111661f, 
    -0.24100894f, -0.14783150f, -0.21703549f, 0.00000057f, 0.19539809f, 0.16103403f, 0.24598655f, 0.37635618f, 
    -0.10842637f, -0.04704203f, -0.13437320f, 0.04566523f, 0.15494841f, 0.12959540f, -0.07351254f, -0.03660479f, 
    -0.02784192f, 0.04933092f, -0.10571531f, -0.01906261f, -0.05557807f, 0.31516448f, 0.00915158f, -0.16184904f, 
    0.04268129f, -0.04556679f, -0.03205045f, 0.04851742f, -0.14322996f, -0.03114926f, 0.06240929f, -0.00578687f, 
    -0.10260497f, -0.01821147f, 0.00734078f, 0.04820070f, 0.01842240f, 0.09199251f, -0.02494201f, -0.12878804f, 
    0.01679626f, -0.04708105f, 0.01280915f, -0.02357354f, 0.12358922f, 0.20173322f, 0.15008764f, 0.02861054f, 
    0.04519099f, 0.09334170f, 0.09627303f, 0.02569004f, -0.01348180f, -0.07326045f, -0.10795279f, 0.19211654f, 
    -0.02112417f, -0.06261789f, 0.04718117f, -0.04778389f, -0.10772479f, 0.06687868f, -0.05671102f, -0.14504047f, 
    0.00489546f, -0.02635912f, 0.11251553f, 0.07772296f, 0.04377930f, -0.01733058f, -0.13379228f, -0.29642466f, 
    0.06663948f, -0.06316233f, -0.01253506f, -0.16772860f, 0.07444651f, 0.00476374f, -0.05518263f, 0.02248582f, 
    0.08672494f, -0.11511819f, -0.26307443f, -0.02123240f, 0.04151955f, 0.03225334f, 0.05210400f, -0.02672205f, 
    0.07028981f, 0.12420337f, 0.02118831f, 0.05305060f, -0.11710807f, 0.39406589f, -0.04662379f, -0.21468584f, 
    0.12569086f, -0.12738426f, 0.41420856f, 0.06205265f, 0.15310685f, 0.09985328f, 0.17785014f, -0.18064439f, 
    0.39071614f, 0.18206097f, -0.24312298f, 0.05190161f, 0.03612825f, -0.11463089f, -0.09275856f, 0.04704851f, 
    0.02965287f, 0.06783867f, -0.10817984f, 0.07876750f, -0.08939216f, 0.03200853f, -0.04192910f, -0.03254440f, 
    0.09927934f, 0.07410711f, 0.07587337f, 0.01817352f, 0.03952762f, -0.14324817f, -0.00178297f, -0.14486042f, 
    0.52024788f, -0.44084513f, 0.38901490f, -0.07726171f, 0.00036437f, -0.00294095f, -0.05056487f, 0.22864909f, 
    0.03460755f, 0.04530726f, 0.04462732f, -0.11702593f, -0.01363237f, -0.04594079f, -0.09508303f, -0.07328501f, 
    0.03773797f, 0.13371272f, -0.04294060f, 0.00765348f, -0.09104636f, -0.06508136f, 0.10251456f, -0.10829408f, 
    -0.22640015f, -0.04949803f, 0.12494599f, -0.10955136f, 0.06391000f, 0.04233313f, -0.06124566f, -0.05563445f, 
    -0.04418366f, 0.07887590f, 0.00892384f, 0.16928595f, -0.07181235f, -0.17966139f, -0.05571776f, -0.06587522f, 
    0.02169712f, -0.04347309f, 0.02853332f, 0.10044977f, 0.10609900f, 0.21912013f, 0.17526910f, -0.00999176f, 
    0.11200116f, 0.15238650f, -0.04563124f, 0.34527901f, 0.27934757f, 0.12242001f, 0.25109616f, 0.17226237f, 
    -0.00877638f, 0.09261974f, 0.09922158f, 0.06436674f, 0.13795507f, 0.07294329f, 0.02003572f, -0.06364348f, 
    -0.01396384f, -0.02681378f, -0.04196049f, -0.02576015f, 0.07758620f, -0.05836622f, 0.33899388f, 0.13759755f, 
    -0.07283781f, 0.04265673f, 0.00673201f, -0.16329898f, -0.05962066f, 0.24403833f, -0.00866674f, 0.06113405f, 
    0.11970018f, -0.12634180f, 0.15373413f, -0.09330305f, 0.28565702f, 0.36554885f, 0.19733012f, 0.18377540f, 
    -0.17663656f, -0.13677804f, -0.08666981f, -0.03281746f, -0.07582065f, 0.04231260f, 0.16568285f, 0.01996454f, 
    0.18447743f, 0.07785743f, -0.06799405f, 0.33207086f, -0.19815974f, -0.04558380f, -0.23860724f, 0.05817180f, 
    -0.05541912f, -0.09426627f, 0.04106474f, -0.08678832f, 0.02848484f, 0.37590817f, 0.05465981f, -0.15954533f, 
    0.11274952f, 0.12709485f, 0.08243820f, 0.17662764f, -0.07232548f, -0.07163112f, 0.00321571f, -0.13247290f, 
    0.28376478f, -0.02862930f, -0.01219595f, -0.01065150f, 0.03428366f, -0.06000013f, -0.11098748f, 0.00746950f, 
    0.01844664f, -0.23423845f, -0.25724864f, 0.02486442f, 0.09892022f, 0.14954661f, 0.15557869f, -0.05548887f, 
    0.02404996f, 0.00957000f, -0.04563855f, -0.01416241f, -0.00538164f, 0.08806183f, -0.00276559f, 0.03889787f, 
    0.28970638f, -0.30143008f, 0.25792694f, -0.11032784f, -0.01665316f, 0.15410922f, 0.10262077f, 0.06554198f, 
    0.07216898f, 0.29748365f, -0.02648015f, 0.04832731f, 0.02538545f, -0.02543928f, -0.06925543f, 0.36178389f, 
    0.01493790f, 0.10187577f, 0.29602998f, 0.12225998f, 0.06225196f, -0.05494134f, 0.19257875f, 0.13277934f, 
    0.20093098f, 0.17819826f, 0.39913306f, 0.02547416f, -0.01045474f, 0.24944337f, -0.12509970f, 0.28679967f, 
    -0.04918267f, 0.02181081f, 0.10816465f, 0.25515819f, -0.11476649f, 0.09179649f, -0.17233777f, 0.11034852f, 
    -0.16642828f, 0.01783132f, 0.01539167f, -0.14430597f, 0.09629221f, -0.02557498f, 0.05509059f, -0.01896422f, 
    -0.24623062f, 0.04549656f, 0.25781515f, -0.09896085f, 0.00553070f, 0.06376351f, 0.27226487f, 0.06520408f, 
    0.03873473f, 0.04950993f, -0.12753776f, -0.01665360f, 0.04727764f, -0.07232278f, 0.06673719f, -0.09565609f, 
    -0.14739823f, 0.03501431f, 0.12376215f, 0.12706971f, -0.02079154f, 0.10375457f, -0.06548748f, 0.27522236f, 
    0.13098371f, -0.03724540f, -0.28382713f, -0.19518812f, -0.08614355f, 0.01251150f, 0.03757766f, -0.01711987f, 
    0.02681190f, -0.01425367f, -0.07455948f, -0.12781172f, -0.31200698f, -0.08388856f, -0.17496970f, -0.03924594f, 
    -0.18223490f, -0.08639704f, -0.12370688f, 0.00300332f, -0.10352948f, 0.01937589f, 0.09703306f, 0.02445377f, 
    0.03324139f, 0.05560775f, -0.05475312f, -0.26394448f, 0.11473411f, 0.02998284f, -0.00716942f, 0.02632301f, 
    0.01440438f, -0.06416766f, -0.10103285f, -0.10146506f, 0.19741558f, 0.09320061f, 0.11038238f, -0.00290491f, 
    0.02762262f, -0.03246612f, -0.04547719f, 0.00400663f, -0.02052317f, -0.14552037f, -0.15120085f, -0.02967452f, 
    0.13983883f, -0.13295451f, 0.00044487f, 0.18199514f, 0.04698959f, -0.15574650f, 0.05059745f, 0.17015488f, 
    0.01602229f, 0.08195068f, -0.07984981f, 0.02587482f, 0.14856748f, 0.05397318f, 0.20379175f, 0.23581405f, 
    -0.17165916f, -0.02618965f, 0.06319454f, -0.07390998f, 0.03798616f, -0.00106200f, -0.13334793f, 0.00145196f, 
    -0.01800369f, 0.15512732f, 0.10855344f, 0.08973780f, -0.11028444f, 0.02661790f, -0.12636861f, 0.11972820f, 
    -0.17038460f, 0.17032388f, 0.14881141f, 0.06320825f, 0.27134326f, -0.25186244f, -0.24948636f, -0.04021838f, 
    0.09813889f, -0.16745427f, 0.06577994f, -0.13927472f, -0.02001007f, 0.24578439f, 0.13199051f, -0.05202925f, 
    -0.07812103f, -0.17774437f, 0.12652335f, 0.27292916f, 0.14034867f, 0.06656048f, -0.04728593f, 0.18084563f, 
    -0.03347840f, 0.05925994f, 0.02993683f, -0.09111959f, -0.24755783f, -0.15007252f, 0.07582503f, 0.09119076f, 
    -0.05617414f, 0.17745225f, -0.00278169f, 0.16074759f, -0.09145224f, 0.05453812f, -0.05227857f, -0.09319120f, 
    -0.09868934f, 0.17868081f, 0.13573550f, -0.16672376f, -0.02367627f, 0.04864681f, -0.01829706f, -0.02617311f, 
    -0.05887946f, -0.02804143f, 0.00252346f, 0.21935977f, -0.62506521f, 0.62791461f, -0.08800773f, 0.51891112f, 
    0.05055030f, 0.19851868f, 0.09798919f, 0.02929304f, 0.03218050f, -0.10078482f, 0.23199214f, 0.08730333f, 
    -0.01536869f, 0.22859368f, 0.03548436f, 0.13021706f, 0.01992248f, 0.04788671f, 0.14614959f, -0.08018515f, 
    0.09038144f, -0.02130482f, 0.09786717f, -0.11505216f, -0.15617920f, 0.07332582f, -0.03977196f, 0.16993147f, 
    0.01095813f, -0.00910603f, -0.06340070f, -0.08597841f, -0.20588906f, 0.11770575f, -0.05935628f, 0.15022297f, 
    -0.10563310f, 0.54611158f, -0.28578448f, -0.27763984f, 0.14217244f, -0.08678936f, 0.17178056f, 0.00506834f, 
    -0.13308284f, 0.10097182f, -0.03829033f, 0.04343692f, 0.31308514f, 0.02618996f, 0.23142944f, -0.10188856f, 
    -0.27438939f, -0.02849500f, 0.00789768f, 0.05163114f, -0.15955816f, 0.10387540f, 0.20507543f, 0.16411746f, 
    -0.10336526f, -0.00243481f, -0.02291453f, 0.07130481f, 0.08052565f, 0.05079557f, 0.10771039f, 0.06705839f, 
    -0.07479981f, 0.01670681f, -0.07373207f, -0.04626172f, -0.17641629f, 0.08362763f, 0.06881004f, -0.00262073f, 
    -0.00132698f, 0.04500508f, 0.01245994f, 0.05735854f, 0.01822871f, 0.12813447f, 0.05875070f, 0.10791119f, 
    -0.02873264f, 0.48424950f, -0.23395386f, -0.10108262f, -0.04999089f, 0.21012686f, 0.02926932f, -0.12793900f, 
    0.07472028f, -0.12451282f, -0.03979046f, 0.04118230f, -0.05089875f, 0.02853954f, 0.01798082f, -0.10280222f, 
    -0.01920346f, -0.06314202f, 0.00997147f, -0.07571581f, 0.08860010f, -0.04861576f, -0.00743943f, -0.18433675f, 
    -0.07471091f, -0.02816946f, 0.01921541f, 0.05177054f, -0.02723044f, 0.05073600f, -0.07021550f, -0.06466647f, 
    -0.02416856f, 0.00268524f, -0.02639055f, -0.05516814f, -0.02118015f, -0.07293310f, 0.01116333f, -0.06507656f, 
    -0.01641989f, -0.06309987f, 0.04024133f, -0.07438334f, 0.05423303f, 0.03800659f, -0.05037884f, 0.02226866f, 
    0.02411275f, 0.02706802f, -0.01305389f, 0.04702022f, -0.03662042f, 0.00724270f, 0.05032897f, 0.03324998f, 
    0.00996046f, 0.02395052f, -0.07453991f, -0.07658641f, -0.07633786f, 0.04739634f, 0.04917337f, -0.00015129f, 
    0.03416422f, 0.01531872f, 0.01583833f, 0.02471690f, -0.06392612f, -0.03065938f, 0.03534840f, -0.06228764f, 
    -0.00154654f, 0.00229843f, 0.01364267f, -0.05335864f, -0.00990766f, -0.06856667f, 0.01901995f, 0.02004890f, 
    0.02873692f, -0.00688506f, 0.02050506f, -0.05437087f, 0.03532648f, 0.00723339f, 0.00080393f, -0.01323378f, 
    0.02225967f, -0.05664471f, -0.01321756f, -0.04903625f, 0.01708161f, 0.03426729f, -0.00327863f, -0.08097751f, 
    -0.06688231f, 0.03373332f, -0.07426096f, -0.06437303f, -0.03859961f, 0.00159786f, 0.05669265f, 0.00460910f, 
    -0.05371849f, 0.04987748f, -0.06801385f, 0.04693402f, -0.03655721f, -0.05816903f, 0.03142940f, -0.04103182f, 
    -0.03599177f, 0.05422291f, 0.05860071f, 0.03724097f, -0.07723053f, -0.05307475f, -0.06613577f, -0.02339085f, 
    0.02285388f, -0.06127947f, 0.01924044f, -0.01295880f, 0.04508186f, -0.01945581f, 0.01148171f, -0.02672952f, 
    -0.03177005f, 0.04481043f, -0.02092982f, -0.05371524f, 0.02997683f, -0.03676945f, -0.02255200f, 0.05656869f, 
    0.05812822f, -0.07754382f, 0.06459931f, -0.05255547f, 0.00490820f, -0.02414554f, -0.01221746f, -0.04647376f, 
    -0.02439405f, -0.02143729f, -0.04013170f, 0.01766885f, 0.00166244f, -0.04469667f, 0.00693244f, 0.00927371f, 
    0.05866255f, 0.03373778f, -0.00391075f, -0.03528874f, 0.01848257f, -0.07342540f, 0.01306318f, 0.04664959f, 
    0.03061172f, -0.06965445f, 0.02670484f, -0.05884296f, 0.03063685f, -0.06863824f, 0.01354478f, -0.00677901f, 
    0.03249814f, -0.00082650f, 0.01592218f, 0.05120778f, 0.00429413f, -0.04297284f, -0.05915365f, 0.01318328f, 
    0.00597140f, -0.06871370f, -0.06776866f, -0.01187730f, -0.02605414f, -0.01044447f, -0.01295259f, 0.01528536f, 
    0.06140230f, 0.04421615f, -0.03071534f, -0.06022454f, -0.04780724f, -0.05913422f, -0.06713007f, -0.05136891f, 
    0.01037876f, 0.02779548f, 0.05886863f, -0.02133713f, 0.00628182f, -0.05685653f, -0.06529021f, -0.00219861f, 
    0.04730605f, -0.00584814f, 0.06050307f, 0.02752434f, 0.01569701f, 0.00754928f, -0.05285662f, 0.00595227f, 
    -0.05489420f, 0.06370784f, -0.01792898f, -0.03852367f, -0.03883805f, -0.05362855f, 0.03825129f, 0.06142591f, 
    0.21730530f, 0.32282206f, 0.19016983f, 0.29481667f, 0.13774219f, 0.28148445f, 0.20578602f, -0.05200876f, 
    0.02515132f, 0.09354240f, 0.10195846f, -0.01884764f, -0.23221612f, -0.42491242f, -0.24463660f, -0.37606061f, 
    -0.02968879f, 0.05210719f, -0.03688462f, -0.04908211f, 0.00522874f, 0.09587713f, 0.08516268f, 0.11109160f, 
    -0.06702130f, -0.16361301f, -0.17512700f, -0.04066988f, -0.06702401f, -0.16759777f, -0.06552620f, -0.02791718f, 
    -0.25449055f, 0.10550670f, 0.07247034f, -0.07493471f, 0.33113304f, 0.25142884f, 0.09162739f, 0.22975244f, 
    0.15902889f, 0.17518784f, -0.11908076f, 0.07446748f, 0.05474420f, 0.05176811f, -0.13874391f, -0.21229455f, 
    0.08781442f, -0.14653739f, 0.21595113f, 0.15967816f, 0.14993612f, -0.05217259f, -0.31128907f, -0.31741703f, 
    -0.11591491f, -0.05266213f, -0.14038131f, -0.14612029f, 0.09941918f, 0.09289373f, -0.10730375f, 0.26721469f, 
    0.02759719f, 0.15827645f, 0.10689542f, 0.16211967f, -0.08580898f, -0.03048218f, -0.01074630f, 0.06791304f, 
    -0.18787330f, 0.05451553f, -0.13855699f, -0.15514196f, -0.12721321f, -0.02477384f, 0.13586655f, -0.10291150f, 
    0.04339381f, 0.23560198f, -0.07765633f, -0.00830913f, -0.10345373f, 0.33024588f, 0.04611134f, -0.02508743f, 
    0.03477705f, 0.10222685f, -0.12412971f, -0.15473974f, 0.09987304f, -0.30345559f, -0.07224295f, -0.01024438f, 
    -0.10873707f, 0.33252218f, -0.10190699f, 0.15518700f, 0.03324004f, -0.01701180f, -0.16122898f, -0.13074289f, 
    0.02610182f, -0.05270704f, -0.02654308f, 0.03972539f, 0.03315292f, -0.05933477f, -0.07018682f, -0.05769103f, 
    -0.01774743f, -0.03013875f, 0.03370054f, 0.07839213f, 0.09524355f, 0.17178838f, 0.12209587f, 0.21403134f, 
    -0.31399852f, 0.29572794f, -0.07847216f, 0.04655369f, 0.02964899f, -0.08666780f, -0.06428117f, 0.25584239f, 
    0.05977524f, 0.01327562f, -0.14673264f, -0.09363344f, -0.10674471f, -0.08302288f, -0.12988868f, 0.02528775f, 
    -0.10979599f, -0.12240551f, 0.06140347f, 0.00585364f, 0.02221086f, 0.12954162f, -0.03674958f, 0.28095117f, 
    0.50942087f, 0.19793913f, 0.15820351f, 0.17073216f, 0.17162758f, 0.13663627f, 0.20750353f, -0.07619489f, 
    -0.01119598f, 0.04724632f, -0.06145392f, -0.21113001f, -0.09586091f, 0.04129529f, -0.15162016f, -0.05868079f, 
    -0.08998185f, -0.09427213f, 0.06276780f, 0.11911363f, -0.06240991f, 0.20559935f, 0.08241901f, -0.05274275f, 
    -0.14119573f, 0.03846899f, -0.15671702f, -0.19195220f, -0.12306418f, -0.14238994f, -0.19206622f, 0.03131906f, 
    0.12742193f, 0.13582093f, 0.05757983f, -0.00732624f, -0.24049354f, -0.26542258f, -0.22310664f, -0.18704142f, 
    0.08621445f, 0.05334122f, -0.10454971f, 0.02728944f, -0.14416729f, -0.22466902f, -0.13798733f, -0.16960342f, 
    -0.10376593f, -0.13488176f, -0.00670992f, 0.16434205f, -0.01804145f, -0.16255984f, -0.00394002f, 0.16279924f, 
    -0.09672755f, 0.15266180f, -0.16088650f, 0.04900984f, 0.17757645f, 0.24318953f, 0.17058596f, -0.23353122f, 
    -0.09523160f, -0.08190005f, 0.13856298f, 0.06681295f, -0.17741008f, 0.06589885f, -0.25911444f, -0.04455568f, 
    -0.22155498f, 0.27499065f, 0.13494070f, -0.08509739f, -0.01884091f, -0.04138092f, -0.05062908f, 0.18643689f, 
    -0.05048108f, 0.16303560f, 0.05414006f, -0.00144481f, 0.15143847f, -0.25888819f, -0.26527068f, -0.03711069f, 
    0.01331478f, -0.06459289f, 0.10475717f, -0.00419714f, -0.00166846f, 0.11883822f, 0.12700538f, 0.07527263f, 
    -0.33332908f, -0.06925172f, 0.04020810f, 0.27200213f, -0.08049160f, 0.05225734f, 0.08827394f, 0.15499911f, 
    0.10990202f, 0.22786485f, 0.23647374f, 0.16927628f, -0.28546599f, -0.18623014f, -0.03875025f, -0.01331708f, 
    -0.12291660f, 0.05161805f, 0.12745011f, 0.14252132f, 0.01827966f, 0.06284754f, -0.03242498f, -0.16291377f, 
    -0.04894661f, 0.40554944f, -0.07853632f, -0.04929197f, 0.05761503f, -0.03947787f, -0.08631338f, 0.18093438f, 
    0.05025746f, 0.10955731f, 0.02880741f, 0.12148055f, -0.80970782f, 0.50265777f, 0.15573369f, 0.40482870f, 
    -0.05957136f, 0.23116678f, 0.13395301f, 0.18475896f, -0.02313450f, 0.07806176f, 0.20271589f, 0.01663167f, 
    -0.04264273f, 0.01045489f, 0.10918676f, 0.28734711f, 0.20507492f, -0.21910720f, 0.06843891f, 0.01425733f, 
    -0.15464056f, -0.01139037f, 0.03823600f, -0.29527771f, -0.07945585f, 0.13753939f, -0.05416214f, -0.07638796f, 
    0.07540532f, -0.07278780f, -0.07728803f, -0.04538817f, -0.46795723f, -0.14666349f, -0.17898001f, -0.15660366f, 
    0.52396065f, 0.24098013f, -0.36060247f, 0.21980344f, 0.26753071f, 0.05685494f, 0.00677760f, -0.00921087f, 
    -0.04668703f, 0.08933085f, 0.24778926f, 0.05311715f, 0.18271063f, 0.09669055f, 0.28288430f, -0.04951891f, 
    -0.09269761f, 0.08190838f, -0.21688604f, 0.00926187f, -0.17978068f, -0.10518928f, 0.13317752f, -0.00425483f, 
    -0.15952988f, -0.04647902f, 0.26195422f, 0.20422733f, -0.06956755f, -0.09080826f, -0.00083641f, 0.13682327f, 
    -0.10379969f, 0.13330686f, -0.03011156f, 0.15477918f, 0.23408429f, 0.18746379f, -0.04812988f, -0.15139827f, 
    0.16449389f, 0.02398847f, -0.08357028f, -0.11857340f, -0.02362194f, 0.06064449f, 0.01512393f, 0.04843032f, 
    0.03623233f, 0.31259516f, -0.18365970f, 0.11859226f, 0.05026062f, 0.21293646f, 0.11141872f, -0.02626803f, 
    0.08423074f, 0.01196048f, 0.11395872f, 0.12679815f, -0.15787266f, 0.01017860f, 0.04870231f, -0.19056749f, 
    -0.22119246f, -0.04798254f, -0.11352992f, -0.03928819f, 0.02952403f, 0.18046005f, 0.32200965f, 0.13532113f, 
    -0.09492774f, 0.11157627f, 0.05515533f, -0.17839061f, -0.05455177f, 0.11908989f, 0.06221113f, 0.08988415f, 
    -0.01709224f, -0.11128652f, 0.00661238f, -0.05969757f, 0.13451447f, 0.15446642f, 0.08850457f, -0.05501009f, 
    -0.08443733f, 0.01240074f, -0.01514416f, -0.10292736f, 0.10825277f, 0.07674695f, 0.05210645f, -0.02386118f, 
    0.43935606f, -0.07368008f, 0.06694620f, 0.04804484f, -0.09267750f, -0.00656920f, 0.00915664f, 0.00965819f, 
    0.01548529f, 0.04283861f, -0.08968021f, 0.01699213f, -0.05211936f, 0.18061586f, -0.00792286f, 0.09976041f, 
    -0.06197628f, 0.09475530f, -0.16876003f, 0.04497210f, 0.02682958f, 0.01885725f, -0.18686700f, -0.12385790f, 
    0.11629824f, 0.17597285f, 0.10629033f, -0.12123986f, 0.07223668f, -0.05412301f, 0.12930483f, 0.07589278f, 
    0.09147804f, -0.07095779f, -0.09451837f, 0.04772139f, -0.00296106f, 0.10013424f, 0.08095045f, 0.08100203f, 
    0.07998863f, 0.04747520f, -0.02396594f, 0.12131888f, -0.07779948f, 0.12863101f, -0.00192748f, -0.00866453f, 
    0.07540547f, 0.11220415f, 0.03354967f, 0.01546784f, -0.00288819f, 0.13896410f, 0.20799206f, -0.14692084f, 
    0.02080702f, 0.20828749f, 0.00731574f, -0.08553619f, 0.51405329f, -0.73053789f, 0.19722643f, 0.04053486f, 
    -0.08352035f, 0.19541967f, 0.05285313f, 0.24090600f, 0.15228964f, -0.12796433f, 0.07147371f, 0.12608372f, 
    -0.04948169f, -0.04275268f, 0.18934396f, -0.01490614f, -0.00964843f, 0.17497766f, 0.00293359f, 0.10647943f, 
    0.08866020f, -0.07528061f, 0.03334614f, 0.10396460f, 0.12312534f, 0.04389955f, 0.08877667f, -0.01249719f, 
    -0.05163378f, -0.00458025f, 0.06131724f, -0.00022096f, 0.01007365f, -0.01597940f, -0.10786749f, -0.06990135f, 
    -0.28621885f, -0.05595937f, -0.13114983f, 0.39293772f, 0.02105659f, 0.00269940f, 0.01250095f, -0.01872900f, 
    0.07366093f, 0.04536691f, -0.02257579f, 0.02211255f, -0.01739744f, -0.07885410f, 0.00024422f, 0.08947853f, 
    -0.03246069f, -0.08855766f, 0.24570045f, -0.00420701f, -0.02780069f, -0.04898119f, -0.17493133f, 0.17621304f, 
    0.42925799f, 0.16315518f, -0.06084194f, -0.17837930f, -0.11211655f, -0.16306899f, 0.09938140f, 0.05353289f, 
    0.09319334f, 0.00547972f, 0.11281765f, -0.09436540f, 0.13008919f, -0.04399010f, -0.02381295f, 0.04909118f, 
    -0.06811062f, -0.02668189f, -0.01752725f, 0.06003103f, -0.03208722f, -0.18540823f, -0.03612784f, -0.02990217f, 
    0.06544916f, -0.29926899f, -0.12344220f, -0.44304910f, -0.05627301f, -0.03821629f, 0.02411986f, 0.10622108f, 
    -0.04211929f, 0.01903369f, -0.00133403f, -0.10946833f, 0.07271788f, 0.09246321f, -0.03683492f, 0.13985100f, 
    -0.01327615f, -0.07705778f, -0.03042741f, -0.12120707f, 0.13460727f, -0.02237142f, -0.29817757f, 0.05621649f, 
    -0.00501954f, -0.12690413f, -0.06982214f, -0.26519576f, -0.01558612f, 0.07088563f, 0.01401975f, 0.02851573f, 
    0.06889252f, -0.03408787f, 0.00685982f, 0.02119958f, 0.01112030f, 0.03099908f, 0.03400426f, -0.02798165f, 
    -0.12419466f, 0.08181804f, -0.00669026f, -0.03312148f, -0.07351834f, 0.07133832f, -0.02633023f, 0.07213643f, 
    -0.04872721f, -0.18000886f, 0.11166659f, 0.03271605f, -0.03290521f, -0.06177370f, 0.01513817f, -0.02546526f, 
    -0.03284753f, 0.08285268f, -0.00387576f, -0.05012743f, 0.23650087f, 0.35889959f, 0.08791820f, -0.18150006f, 
    0.05733648f, 0.10918770f, 0.03935633f, -0.00333848f, -0.03030063f, 0.01099469f, 0.07824292f, -0.21333140f, 
    0.10171171f, -0.10911594f, -0.02029414f, -0.24949650f, -0.03916219f, -0.02282433f, -0.01535112f, 0.16521434f, 
    0.06062825f, 0.00816205f, -0.05522842f, -0.05252223f, -0.03583292f, 0.23784003f, -0.05894059f, -0.12627412f, 
    0.07302625f, 0.11032631f, -0.09795582f, 0.01397891f, -0.18578731f, -0.02538738f, -0.06745476f, -0.10482340f, 
    0.08942394f, -0.05099083f, 0.17329101f, -0.02879713f, 0.23804764f, 0.12775965f, -0.07796335f, 0.12479358f, 
    0.18925221f, 0.02935890f, 0.01228099f, 0.08531797f, 0.12945348f, -0.35156122f, -0.25487864f, 0.04161850f, 
    0.12540033f, 0.01381991f, 0.26732549f, 0.14402106f, 0.13570662f, 0.03299648f, 0.19442526f, 0.03689762f, 
    0.22506125f, 0.07445920f, 0.02222419f, 0.16472767f, 0.19000487f, -0.02948725f, 0.09730542f, 0.03802855f, 
    -0.04383421f, -0.05066486f, 0.09726782f, 0.14828776f, -0.10065600f, -0.06130460f, -0.13394117f, -0.02687931f, 
    -0.22525373f, 0.10074794f, -0.06828788f, -0.04243923f, 0.11147314f, 0.04147200f, -0.02747764f, 0.14530185f, 
    -0.03572739f, -0.02707107f, 0.23626621f, 0.04584833f, 0.32295236f, 0.00554274f, 0.08220319f, 0.11043016f, 
    0.06007323f, -0.10449135f, 0.03806743f, -0.00586742f, -0.23528920f, 0.17923687f, -0.10445447f, -0.10338337f, 
    -0.05564563f, -0.06126124f, 0.10636400f, -0.07330336f, 0.06012500f, 0.24867834f, -0.06865426f, 0.23199506f, 
    0.01018421f, -0.01673117f, -0.26751435f, -0.23093590f, -0.05744155f, 0.02915998f, -0.10392606f, 0.05792341f, 
    -0.03254905f, 0.04963685f, 0.02602266f, -0.17768015f, -0.38662875f, -0.05843194f, 0.21642710f, 0.25653464f, 
    -0.01295392f, -0.00813196f, -0.03938970f, -0.12990038f, -0.03249107f, 0.06277475f, 0.22047196f, 0.04085013f, 
    0.31384850f, -0.03861343f, 0.03652183f, -0.28717694f, 0.02635149f, 0.02670167f, 0.26528805f, 0.03253352f, 
    0.03571249f, -0.07426425f, 0.01529097f, -0.15654929f, -0.04539595f, 0.10703932f, -0.00376464f, 0.17096418f, 
    -0.02541110f, 0.06471483f, -0.00684467f, -0.02115784f, -0.01392183f, -0.04361447f, -0.07001013f, -0.03191913f, 
    -0.07961360f, -0.13693798f, -0.02349080f, 0.17286678f, 0.03482030f, 0.19485402f, 0.05444271f, 0.06730150f, 
    0.13637640f, -0.00261935f, 0.00658399f, 0.02958344f, -0.03073542f, 0.06421133f, 0.05285737f, -0.04626954f, 
    -0.28839943f, -0.12536511f, -0.10647045f, -0.05580666f, 0.11216648f, 0.01499795f, 0.08851245f, 0.03720453f, 
    -0.04440600f, 0.14833426f, -0.05771246f, -0.20524682f, -0.02227677f, -0.28209370f, 0.00354690f, -0.13837232f, 
    0.04566452f, 0.01381607f, 0.10468644f, 0.08545578f, -0.05859078f, -0.24039701f, -0.03188532f, 0.15574808f, 
    0.07286139f, -0.10487706f, -0.00614985f, 0.20273577f, 0.01746805f, -0.12560166f, -0.14039676f, -0.05560135f, 
    0.04803722f, 0.29629269f, 0.04142448f, 0.17112748f, -0.02597140f, 0.04987977f, 0.11951659f, 0.00231838f, 
    -0.01055017f, -0.15238358f, -0.13461579f, -0.21386428f, -0.15011697f, -0.17883936f, -0.14133270f, 0.30405211f, 
    0.42542750f, 0.13106118f, 0.08501814f, 0.06935535f, 0.05130145f, -0.00661778f, -0.08795386f, 0.07523177f, 
    0.02314128f, 0.24378836f, -0.28965211f, 0.08132527f, -0.19162181f, 0.16804616f, 0.10054622f, -0.05051665f, 
    0.00163386f, 0.07188346f, -0.06043750f, 0.04745721f, -0.10168439f, 0.56387419f, 0.41827136f, -0.28442222f, 
    0.15099394f, 0.04318260f, 0.03061532f, 0.08586896f, -0.04943014f, 0.08969325f, -0.02389321f, -0.17480791f, 
    -0.38869554f, 0.13390137f, 0.29058367f, 0.16509023f, 0.16838941f, 0.01069354f, -0.01898998f, 0.02012231f, 
    0.07736738f, 0.00593716f, 0.08437501f, 0.01227955f, 0.04100031f, -0.18313171f, 0.08314820f, -0.28897920f, 
    -0.08171885f, -0.11471224f, -0.03579730f, 0.01236352f, -0.00770040f, 0.07125592f, 0.39656311f, 0.09321995f, 
    0.33075407f, 0.15583318f, 0.12934768f, 0.29727775f, -0.05958798f, 0.17464207f, -0.01446836f, 0.04487335f, 
    -0.12005691f, 0.13479850f, -0.10300601f, -0.08648931f, 0.06091003f, 0.13609080f, -0.09902726f, 0.10496444f, 
    -0.25131848f, -0.05164491f, 0.24079390f, -0.15670326f, 0.10140037f, 0.18013188f, 0.09340952f, -0.03549652f, 
    0.13449866f, -0.24577807f, -0.28313187f, -0.23408420f, 0.02837710f, -0.01820393f, -0.03131455f, 0.17496987f, 
    0.17417128f, 0.12950809f, -0.03670567f, -0.09433822f, 0.33623797f, 0.02156097f, -0.10162489f, -0.39250416f, 
    -0.05696979f, -0.09335740f, 0.03723152f, -0.12521553f, 0.03478295f, 0.07689856f, 0.00513797f, 0.03768362f, 
    -0.15315032f, 0.01225462f, -0.02886710f, -0.07585068f, -0.11644287f, 0.20775169f, -0.03627894f, 0.03491840f, 
    0.03703371f, -0.02828449f, 0.01120212f, -0.04779600f, 0.17191280f, 0.10327049f, -0.01257165f, -0.20070456f, 
    -0.19638197f, -0.03739896f, -0.10981313f, -0.06811110f, 0.01522822f, -0.08832361f, -0.01432279f, -0.07334387f, 
    0.34281021f, 0.00697462f, 0.08810449f, 0.12989467f, 0.02541760f, 0.13174084f, 0.07974197f, 0.06222982f, 
    0.04311292f, -0.11990766f, 0.05782258f, 0.05535938f, -0.48607394f, -0.40206662f, -0.10051489f, 0.14411779f, 
    0.05460534f, 0.06736165f, -0.04036566f, -0.14800008f, 0.09067389f, -0.07316343f, 0.02377691f, 0.08445503f, 
    -0.05039137f, -0.09922448f, -0.24869880f, -0.14164503f, 0.00429403f, -0.19006854f, -0.08223975f, -0.12695009f, 
    0.08461811f, 0.08523992f, 0.09675410f, 0.21229173f, 0.06044508f, 0.15542704f, 0.19065040f, 0.07378770f, 
    0.11724128f, -0.09821527f, 0.06486589f, 0.32403067f, 0.11408918f, -0.00690018f, 0.10232129f, 0.01476044f, 
    0.14681543f, 0.40285105f, -0.05337283f, 0.10623220f, -0.05185565f, 0.14430486f, 0.16182308f, 0.12148393f, 
    0.01259281f, -0.06051362f, -0.09358915f, -0.15214451f, 0.31620252f, 0.19277361f, -0.02256902f, 0.22410189f, 
    0.41605017f, 0.00396446f, 0.01281184f, 0.23761679f, 0.01348727f, -0.01871450f, 0.07168850f, 0.22742011f, 
    0.06624436f, -0.07255986f, -0.13908169f, 0.07226314f, 0.07395601f, 0.11062723f, -0.13180107f, -0.03911505f, 
    -0.09290273f, -0.14627463f, 0.06142883f, 0.00605388f, 0.13686904f, 0.40752363f, 0.13765119f, -0.59429717f, 
    0.23292784f, -0.03547978f, -0.19984944f, 0.07719023f, -0.13880716f, 0.11229961f, 0.01152211f, 0.04167224f, 
    -0.34824425f, 0.18907407f, 0.37329635f, 0.03578453f, 0.09018853f, 0.10380737f, -0.04479732f, 0.11192515f, 
    0.01185589f, 0.13069382f, -0.02457593f, -0.00549310f, -0.23264951f, -0.36639011f, 0.03234491f, -0.28428432f, 
    -0.07019900f, 0.06452905f, 0.03902000f, 0.00878655f, 0.09506482f, 0.04674276f, 0.17056577f, -0.00101031f, 
    -0.14055891f, 0.22308064f, 0.65475398f, 0.35804406f, 0.03103647f, 0.17445065f, -0.09009706f, 0.19905835f, 
    -0.03041024f, -0.14895304f, -0.13037992f, -0.11951097f, -0.24066605f, 0.07098072f, -0.26698098f, 0.08562726f, 
    0.07101921f, 0.01159399f, 0.21355787f, -0.18711202f, 0.28152937f, 0.14033616f, -0.20134553f, 0.00630699f, 
    0.08186686f, -0.05581664f, -0.29332456f, 0.15964572f, -0.00427882f, -0.03579162f, -0.08692057f, 0.00650626f, 
    -0.01096329f, 0.07322456f, 0.09084710f, 0.05755974f, -0.03927014f, -0.17017436f, -0.11201692f, 0.04820755f, 
    -0.04864019f, -0.29686517f, -0.36604404f, -0.26660526f, 0.11454894f, 0.03073576f, 0.16306299f, 0.14548630f, 
    -0.04978152f, -0.10308259f, 0.26600510f, -0.20726189f, -0.02801425f, -0.01435187f, 0.12363675f, 0.03238510f, 
    0.01304814f, -0.02528151f, -0.11692167f, -0.31329060f, -0.10712186f, -0.18365480f, -0.09054291f, 0.19400303f, 
    -0.11940944f, -0.04052537f, -0.27668190f, -0.10468812f, 0.02422521f, 0.03943078f, -0.00851470f, 0.03459132f, 
    -0.02338380f, -0.19552086f, 0.04992357f, -0.06329838f, 0.02460195f, 0.13466430f, 0.09351038f, 0.04819501f, 
    0.10875170f, -0.04659893f, 0.02797960f, 0.03462735f, -0.09112038f, 0.06185964f, -0.02588306f, 0.11326372f, 
    0.00271700f, -0.00966443f, 0.08983027f, -0.02732459f, -0.00877591f, -0.00178752f, 0.12306783f, -0.03341648f, 
    -0.02662334f, 0.04615472f, -0.02270680f, -0.02902381f, -0.02173945f, 0.04582356f, 0.01932810f, -0.02130165f, 
    0.00938868f, -0.14379936f, -0.02578124f, 0.06479574f, -0.25719681f, 0.06037017f, 0.24599816f, -0.12067554f, 
    0.01538959f, -0.01829438f, 0.12896855f, 0.25635719f, -0.00463934f, -0.12932386f, 0.04084444f, 0.05904194f, 
    0.03813791f, 0.24445014f, -0.12194508f, -0.01777126f, -0.04381074f, 0.01894072f, -0.01605977f, -0.02167825f, 
    0.23751765f, -0.07224878f, -0.13150977f, -0.22333023f, 0.32930210f, 0.18934691f, 0.10042957f, -0.01901966f, 
    0.16992453f, -0.05230891f, -0.01498642f, 0.10572286f, 0.03544243f, -0.06899163f, -0.06285363f, 0.01311111f, 
    0.13141817f, 0.04620440f, -0.03248494f, 0.06068136f, -0.06521802f, 0.10517775f, -0.14963056f, -0.06518687f, 
    0.18009931f, -0.19342639f, 0.12355006f, -0.07556014f, 0.13133253f, -0.19053984f, 0.01677467f, -0.36408225f, 
    0.00905034f, 0.05015379f, -0.01760076f, 0.23128474f, -0.03320364f, 0.13335793f, -0.16065921f, 0.08321578f, 
    0.24093655f, -0.14601757f, 0.31913409f, -0.08727971f, 0.06738914f, 0.10266912f, -0.30373663f, -0.04853582f, 
    0.05815411f, -0.00296960f, -0.02666453f, 0.07950297f, 0.05743846f, 0.02468153f, 0.11376107f, -0.04884084f, 
    0.10841814f, -0.06999471f, -0.00108013f, -0.14154176f, 0.13199380f, 0.01453019f, 0.16957824f, 0.11073479f, 
    0.48998377f, -0.16918705f, 0.35363436f, 0.20077322f, 0.01814564f, -0.00695882f, 0.01985385f, -0.07214108f, 
    -0.01794525f, 0.10602396f, 0.11122410f, 0.18170422f, -0.13542670f, 0.14336489f, -0.15364516f, 0.01673918f, 
    0.15764274f, 0.07901684f, 0.06574269f, -0.10724399f, 0.11697278f, 0.10048165f, -0.04100842f, 0.13885824f, 
    -0.18698700f, -0.29402307f, -0.44566515f, -0.08888496f, -0.08383216f, 0.10107837f, -0.09225439f, 0.09747382f, 
    0.12678386f, -0.05476951f, -0.17651835f, 0.01930083f, 0.18655463f, -0.01496508f, 0.14137335f, -0.06952681f, 
    -0.05910027f, -0.02648365f, 0.04226868f, -0.08224638f, 0.08365349f, 0.04792462f, 0.05712083f, 0.01378150f, 
    0.23516092f, -0.27518141f, 0.44144198f, -0.05192403f, -0.02395949f, -0.23468751f, 0.09899003f, 0.04396448f, 
    0.03092568f, 0.03777474f, -0.19219135f, -0.01436930f, 0.01416129f, -0.07121331f, -0.06109776f, -0.02454449f, 
    0.04931295f, 0.04034331f, 0.01645044f, -0.00451687f, -0.16777420f, -0.02144195f, -0.00002110f, -0.06874432f, 
    0.23709589f, -0.11754450f, 0.04172871f, 0.26189744f, -0.06113604f, -0.06570066f, 0.00931408f, -0.01062648f, 
    0.03199702f, 0.01209810f, -0.01966609f, -0.08912718f, -0.02366112f, 0.04438834f, 0.13415347f, -0.04363828f, 
    -0.09305833f, -0.17674200f, 0.07187913f, 0.04497842f, 0.08560837f, -0.12648237f, -0.22456715f, -0.19622986f, 
    -0.22631113f, 0.00637318f, -0.14445451f, -0.15614448f, -0.01433511f, 0.17728513f, -0.05558662f, 0.16125898f, 
    0.06941057f, 0.02256288f, 0.08975726f, 0.14476854f, -0.05871380f, -0.23858032f, -0.12410386f, 0.01327442f, 
    -0.01612156f, -0.30038744f, 0.05388015f, -0.02557252f, 0.07263628f, 0.00056663f, -0.00896527f, 0.04710385f, 
    -0.13845344f, 0.15251970f, 0.05834534f, 0.30399731f, 0.07258977f, 0.14337428f, -0.08933994f, 0.01829464f, 
    0.04399584f, -0.14849576f, 0.04191319f, -0.13434276f, 0.36677271f, -0.06276918f, 0.19682397f, 0.23175284f, 
    -0.02654445f, 0.02041825f, -0.01577010f, 0.16151585f, 0.14013447f, -0.00243681f, -0.04504972f, -0.07757667f, 
    0.12363932f, 0.15928678f, 0.00143746f, -0.07651658f, 0.02686835f, 0.08283072f, 0.00750367f, 0.10023198f, 
    -0.17237058f, -0.07239382f, 0.02001821f, 0.04391140f, -0.45359221f, 0.27521777f, -0.24494702f, 0.27181092f, 
    -0.04414983f, 0.08191583f, 0.00712577f, 0.07064340f, -0.16127506f, 0.16251802f, -0.04298650f, 0.09710353f, 
    0.25852484f, 0.06056255f, 0.46702600f, 0.02840581f, -0.05247484f, 0.11197497f, 0.04867401f, -0.08565793f, 
    0.14563411f, -0.00410955f, 0.05247589f, -0.24329843f, -0.12570967f, 0.07994239f, -0.00265017f, 0.04991637f, 
    0.12642792f, -0.07259916f, 0.02888712f, -0.05913130f, 0.07133304f, 0.09247660f, 0.01147810f, 0.08387129f, 
    0.27928478f, 0.33614972f, -0.00693709f, 0.05105403f, -0.02643280f, 0.08093786f, 0.19613774f, -0.17234229f, 
    -0.16319260f, -0.04360703f, 0.05810202f, -0.00426080f, 0.35270447f, -0.11736754f, 0.19844344f, -0.08859386f, 
    0.11164196f, 0.22259606f, -0.13701388f, 0.06605229f, 0.13539402f, -0.05141612f, 0.07774837f, 0.09373412f, 
    -0.17650074f, -0.14977743f, 0.12193315f, 0.40348643f, 0.02878871f, 0.05211150f, 0.14655380f, 0.00844428f, 
    0.07792237f, -0.18579644f, -0.15188955f, 0.05264943f, -0.06767013f, -0.00595320f, -0.26106483f, -0.17542775f, 
    -0.06443120f, -0.01351416f, 0.12271573f, 0.07556520f, 0.12273893f, -0.04005384f, 0.00170714f, 0.10430057f, 
    0.16143177f, 0.33329892f, 0.26945949f, -0.00055513f, -0.08213256f, -0.11790030f, -0.04400495f, 0.00571177f, 
    0.03526539f, 0.06901167f, -0.20485017f, -0.09121924f, -0.28661576f, -0.22816095f, -0.10268734f, -0.04315894f, 
    0.02745973f, 0.01328909f, -0.06644049f, -0.12335562f, -0.02646579f, 0.03155123f, 0.17935377f, -0.11373104f, 
    -0.02893019f, -0.01287140f, 0.00756472f, -0.06958307f, 0.13356587f, -0.20519124f, -0.06391636f, 0.19947134f, 
    -0.14473739f, -0.04244689f, -0.03739506f, -0.12510924f, -0.03170725f, 0.07490098f, 0.02670233f, -0.10106096f, 
    -0.03688151f, 0.07528368f, -0.05106700f, 0.10835705f, -0.02808280f, 0.02521825f, 0.06695270f, -0.17590074f, 
    -0.47641873f, 0.01264944f, -0.04790854f, -0.10557624f, -0.06109669f, 0.10122780f, 0.11808797f, 0.02206733f, 
    0.13323541f, 0.09629717f, 0.11632262f, 0.04365753f, -0.00813025f, -0.25824511f, 0.13039699f, 0.01195646f, 
    0.05416366f, -0.03371064f, 0.30235270f, 0.13863818f, 0.17622612f, -0.21846126f, 0.02352538f, 0.30518219f, 
    -0.13480355f, 0.09212064f, -0.01065969f, 0.07655755f, -0.00512409f, 0.01800143f, 0.08752505f, 0.12601262f, 
    0.11553665f, 0.31491643f, 0.30205780f, 0.22454830f, 0.00422274f, 0.05304416f, 0.18174623f, 0.04672454f, 
    0.01225837f, -0.03102008f, -0.03695685f, 0.11099326f, 0.26520824f, -0.20636648f, -0.04719191f, -0.11317939f, 
    0.08805235f, 0.05328768f, -0.11453079f, 0.01082812f, 0.13928598f, -0.04828468f, -0.13431449f, 0.10387538f, 
    0.03804696f, 0.09729595f, 0.19123915f, -0.11242177f, -0.47994027f, 0.13138123f, -0.07681709f, 0.00071081f, 
    -0.00047037f, -0.15289156f, 0.10437131f, 0.13849367f, -0.03920166f, 0.02327582f, -0.02777663f, -0.27201042f, 
    0.11761311f, -0.04728605f, 0.12227128f, -0.02904198f, 0.17091434f, -0.06625979f, -0.05471116f, 0.22741938f, 
    -0.10308139f, 0.01035299f, -0.21760397f, -0.28435895f, -0.16366662f, -0.11256190f, -0.16609170f, -0.12909286f, 
    0.04036321f, 0.28572059f, -0.04548451f, -0.19084504f, -0.33961570f, -0.42365491f, -0.20631634f, -0.41997239f, 
    0.68647695f, -0.29291162f, 0.12583981f, 0.34034100f, 0.34586737f, 0.08874658f, -0.06405483f, -0.24223861f, 
    0.14861621f, -0.00866079f, 0.06268001f, -0.02507669f, 0.01235777f, 0.21437915f, 0.09227154f, -0.28542489f, 
    0.25138548f, 0.21467869f, -0.34098750f, -0.09888902f, -0.18031988f, -0.13407251f, 0.09743333f, -0.38688284f, 
    -0.14423908f, -0.01132918f, 0.22070174f, 0.20797917f, -0.09899903f, -0.22649135f, -0.15240970f, 0.18931535f, 
    0.07576372f, -0.11403345f, 0.03828572f, 0.08294895f, 0.06586009f, 0.00866583f, 0.13826171f, -0.11567330f, 
    0.09276389f, 0.03663363f, -0.18180524f, -0.08881720f, 0.21828161f, 0.18046232f, 0.15971749f, 0.03945703f, 
    0.13323049f, -0.13748460f, 0.35662556f, 0.52217227f, 0.33860612f, 0.02486408f, 0.21996978f, 0.03796981f, 
    0.11882231f, 0.08811136f, -0.07311853f, 0.09251718f, -0.09106865f, -0.13051628f, 0.05464729f, -0.08847792f, 
    -0.04873096f, -0.20907480f, -0.14857177f, -0.05254146f, 0.15924071f, 0.42738244f, 0.36427620f, 0.29022503f, 
    -0.10085982f, -0.17231555f, -0.12182030f, -0.03598096f, 0.21448348f, 0.21986577f, 0.11838491f, 0.16452439f, 
    0.09491638f, 0.02319956f, 0.14611900f, 0.08894433f, -0.01760983f, 0.06226176f, -0.01870673f, 0.11859882f, 
    -0.18158206f, 0.11106212f, -0.03829944f, -0.04139064f, -0.04649410f, -0.00356041f, 0.02693178f, 0.19739130f, 
    -0.09342032f, -0.09629213f, -0.11350874f, 0.00353843f, 0.01534235f, -0.06165692f, -0.00311536f, -0.28258118f, 
    -0.06983650f, -0.03123044f, 0.10986713f, -0.12470209f, 0.23380482f, 0.16817188f, 0.09159072f, -0.09972122f, 
    0.17926288f, 0.10416399f, 0.00313828f, 0.03906204f, -0.13607220f, -0.08170788f, -0.13775142f, -0.00189603f, 
    0.23297676f, -0.06606162f, -0.01678615f, 0.05362577f, 0.01575971f, 0.14034325f, 0.05840903f, -0.02458969f, 
    -0.02169582f, -0.01038481f, -0.11346815f, -0.11200129f, -0.02965245f, 0.11542205f, -0.27798131f, -0.08443154f, 
    0.16012299f, 0.12077449f, 0.07381208f, 0.06258970f, -0.09609905f, -0.21949388f, -0.07785584f, 0.04115091f, 
    0.16501728f, -0.16167171f, -0.00304755f, 0.12742364f, -0.08036228f, 0.07419220f, -0.11502898f, -0.02124430f, 
    0.19785216f, -0.06336699f, 0.02800844f, 0.20493399f, 0.26102346f, 0.35282898f, -0.19581087f, -0.19481705f, 
    0.01020611f, 0.01272420f, 0.20713378f, -0.13334063f, 0.13971117f, -0.03855958f, 0.17518725f, -0.11303767f, 
    0.14252250f, 0.12764929f, -0.07973984f, 0.32339573f, 0.22599915f, -0.08861706f, 0.07311157f, -0.01774087f, 
    0.12488201f, 0.02129488f, 0.01962622f, 0.33498189f, -0.12937081f, -0.19696899f, -0.05796585f, -0.11816645f, 
    -0.21009357f, 0.03593891f, -0.11018965f, -0.12243517f, 0.09502580f, 0.08342094f, 0.18706548f, 0.25725105f, 
    0.37246475f, 0.00722120f, 0.41296694f, -0.17866255f, 0.05145412f, 0.09788714f, 0.05858370f, 0.30042949f, 
    0.07369063f, -0.06451819f, 0.04142127f, -0.14700620f, -0.43829530f, 0.16322072f, -0.20945114f, 0.09562178f, 
    -0.16750871f, -0.16356491f, 0.22086996f, -0.09787776f, -0.09596176f, 0.26546136f, -0.11573970f, 0.20987257f, 
    -0.01007179f, -0.31054124f, -0.40780619f, -0.18278873f, 0.02064074f, 0.12406728f, 0.00955863f, 0.21723138f, 
    0.05338051f, 0.07883974f, 0.01421689f, -0.13168563f, 0.02972943f, -0.15600376f, 0.13789938f, -0.17900930f, 
    -0.17219469f, -0.04296441f, -0.03415578f, -0.17091888f, 0.01807941f, 0.15434779f, 0.20430146f, 0.16852632f, 
    0.16725551f, 0.09127440f, -0.04522763f, -0.11499796f, 0.05709627f, 0.11146965f, 0.09395599f, 0.01081805f, 
    0.02283590f, -0.07483620f, 0.12656808f, -0.10953413f, 0.02069280f, 0.10364547f, 0.13423181f, -0.13372082f, 
    -0.06849632f, 0.04930543f, -0.03648574f, -0.08225816f, -0.14712110f, -0.12258887f, 0.14857866f, -0.20538512f, 
    -0.33926049f, 0.12437323f, -0.09553544f, -0.15496747f, 0.13752946f, 0.06295151f, -0.05701557f, 0.00208292f, 
    0.05724877f, 0.07907553f, 0.02193248f, -0.06677322f, 0.28515956f, 0.33784199f, 0.23992711f, 0.16822469f, 
    0.03548638f, -0.08654656f, -0.02147236f, 0.00787510f, -0.05658761f, -0.00058803f, -0.03445610f, 0.15411016f, 
    0.16411969f, 0.16786720f, -0.04096382f, 0.17305881f, -0.03099478f, -0.07158788f, -0.10884480f, -0.12800071f, 
    0.12810063f, 0.03879996f, -0.12487208f, 0.04718881f, -0.76410329f, -0.39999956f, -0.05771353f, -0.21341754f, 
    0.04626244f, -0.10316736f, -0.13423680f, 0.07297083f, -0.04420909f, -0.03036780f, 0.08851837f, 0.23659039f, 
    0.11333381f, -0.37275341f, -0.11652751f, -0.06068777f, 0.01230970f, 0.00509695f, -0.19630919f, -0.23052180f, 
    0.18925072f, 0.09261991f, 0.04446301f, 0.19805354f, -0.21796601f, 0.11256305f, -0.05038267f, -0.20697103f, 
    -0.09563754f, 0.17115417f, -0.09794816f, -0.14630431f, 0.00848642f, -0.01291338f, 0.03697754f, -0.03491038f, 
    0.11580545f, -0.06229719f, 0.00486580f, 0.20768605f, 0.01897031f, 0.00581409f, -0.01895713f, 0.07088511f, 
    0.04115843f, 0.18207170f, 0.17566738f, -0.01127223f, 0.17379393f, 0.22259898f, -0.07928041f, 0.01803490f, 
    0.11987767f, 0.12695378f, -0.00308068f, -0.16180116f, 0.11789590f, 0.15754883f, -0.12676805f, -0.07569544f, 
    0.10472590f, 0.32812330f, -0.13377880f, -0.13863170f, 0.17940108f, 0.05911113f, -0.09635241f, -0.09020538f, 
    -0.00700664f, 0.08110425f, 0.04897239f, 0.08733496f, -0.04141445f, 0.05726499f, 0.07964780f, 0.14143932f, 
    -0.09507722f, -0.06260201f, -0.01036822f, -0.01251371f, -0.17798655f, -0.05056180f, -0.10656384f, -0.10507146f, 
    -0.28491330f, -0.11802416f, -0.04328429f, 0.02877864f, -0.03690334f, 0.05840402f, 0.02312539f, 0.23357108f, 
    0.10889758f, 0.00225076f, 0.09519792f, -0.16552871f, 0.06038765f, 0.20841725f, 0.21670538f, 0.09945606f, 
    0.00312906f, 0.03043082f, -0.04433642f, -0.07029422f, -0.15171976f, -0.18694404f, -0.05451237f, -0.03154257f, 
    -0.20754249f, -0.10353866f, 0.06706649f, -0.25100401f, 0.02687842f, -0.11142696f, -0.15029402f, -0.19660288f, 
    0.09245690f, 0.09332126f, -0.03608489f, 0.01091392f, -0.03165469f, 0.17439371f, 0.10677883f, 0.03508295f, 
    -0.03224877f, -0.04287601f, -0.05490823f, 0.00114997f, -0.02005066f, -0.02113978f, 0.01631209f, -0.02297826f, 
    -0.26054102f, 0.05280868f, 0.14871843f, 0.37400186f, 0.26178572f, -0.22557513f, 0.17459440f, 0.10676320f, 
    0.11624641f, 0.03224831f, 0.12714411f, 0.09665942f, 0.23981507f, 0.03604490f, 0.18241873f, 0.05989329f, 
    0.02628190f, -0.03307296f, 0.05934626f, 0.07315125f, 0.05274370f, 0.10267211f, 0.18236475f, 0.06956783f, 
    -0.00390854f, -0.05588451f, 0.02125488f, -0.03107575f, 0.04351685f, 0.05923886f, 0.05364077f, -0.00091104f, 
    0.00392458f, 0.03837800f, -0.07920124f, 0.06189070f, 0.04041892f, 0.06168942f, 0.04527981f, -0.05163236f, 
    -0.04183413f, 0.04227022f, -0.07478326f, -0.00461429f, -0.05691602f, -0.01636591f, 0.00428311f, -0.03315146f, 
    0.01289546f, 0.07347378f, -0.03544057f, -0.01683634f, -0.03919753f, -0.01126086f, -0.03895167f, 0.05486239f, 
    -0.04111801f, -0.03322693f, -0.06425171f, -0.06385883f, -0.06391416f, -0.00989509f, 0.00010635f, 0.05392864f, 
    -0.04184490f, -0.02471940f, 0.00086974f, -0.00672126f, -0.06620562f, -0.02395435f, -0.03549711f, -0.06824349f, 
    0.06101299f, 0.05169427f, -0.07094861f, 0.00229422f, 0.04271232f, -0.05619615f, -0.00181546f, 0.04528407f, 
    -0.05835389f, 0.05571895f, 0.03821402f, -0.05320621f, -0.04797752f, -0.05440120f, 0.00495873f, 0.00069288f, 
    -0.00138458f, -0.00455562f, -0.02643396f, -0.07034321f, 0.01595304f, 0.05436657f, -0.02862885f, -0.06600857f, 
    -0.05595635f, 0.03142436f, -0.07533394f, 0.03949684f, -0.02695626f, -0.02111613f, 0.03397649f, 0.03428119f, 
    0.04193464f, 0.03708943f, -0.02998220f, -0.05356917f, 0.06750753f, 0.03680645f, -0.06032221f, -0.02701131f, 
    0.01470434f, 0.02703529f, 0.01059358f, 0.04373351f, 0.05196414f, -0.05048337f, -0.04064056f, 0.02310664f, 
    -0.03077228f, 0.04360998f, -0.05848235f, 0.02007763f, 0.02849449f, -0.07578614f, -0.00733452f, -0.01708096f, 
    -0.03795304f, 0.02317129f, -0.04257481f, -0.02922880f, -0.02528029f, 0.03667430f, 0.05286109f, -0.03541677f, 
    0.06221885f, -0.02006747f, -0.05753889f, 0.04181403f, -0.02182460f, 0.06410779f, -0.05739891f, -0.03420004f, 
    -0.03426286f, 0.04220188f, -0.02268202f, -0.05293934f, 0.06001713f, -0.07111705f, -0.01485287f, 0.04350541f, 
    0.02671743f, -0.02580696f, -0.03019186f, 0.04201065f, -0.02498629f, 0.00073763f, -0.07021675f, 0.01200957f, 
    -0.00071704f, 0.00409908f, -0.05787088f, 0.01270856f, 0.04409260f, -0.02415911f, 0.06079063f, -0.04721558f, 
    -0.07421888f, -0.04398890f, -0.05390999f, 0.05632275f, 0.01449383f, -0.03732304f, 0.05996809f, 0.00344804f, 
    -0.01140935f, -0.05510378f, -0.03077191f, 0.05678193f, -0.04470592f, -0.03332481f, -0.02344791f, -0.03533374f, 
    -0.00176557f, -0.05758315f, -0.06521396f, 0.03359269f, -0.00938012f, 0.06273109f, -0.00962448f, -0.01506384f, 
    0.04710901f, -0.02316957f, -0.04357310f, -0.00428446f, 0.04185381f, -0.03267758f, -0.03265945f, -0.07349008f, 
    -0.02511997f, 0.00174030f, 0.05335465f, 0.06217243f, 0.04874904f, -0.01306381f, 0.02069987f, -0.05335048f, 
    -0.00925586f, 0.05336804f, -0.03135689f, -0.04529527f, -0.00692664f, -0.08189312f, -0.04929939f, -0.06492595f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.18908542f, 0.10615589f, -0.02146082f, 0.04952783f, 0.05317242f, 0.06845648f, 0.10921548f, 0.24896973f, 
    0.08922891f, 0.30732140f, 0.03451245f, 0.09935514f, 0.09451554f, 0.25971615f, 0.12590255f, 0.08182666f, 
    -0.03405426f, 0.07001915f, 0.00808636f, 0.04144561f, 0.15225111f, 0.28398260f, -0.01240807f, 0.02917591f, 
    0.06804852f, -0.10610338f, 0.12493002f, 0.19490361f, -0.01338997f, 0.18662138f, 0.10957346f, -0.16848123f, 
    0.05531092f, 0.07863296f, 0.12406660f, -0.04281603f, 0.14615616f, 0.12873605f, 0.02543915f, -0.06475820f, 
    0.01874432f, 0.16229558f, -0.13536204f, -0.03661187f, -0.08767240f, 0.13558750f, 0.02939373f, -0.02444272f, 
    0.07060900f, 0.13869841f, -0.06308223f, 0.03634074f, -0.08678449f, 0.07101950f, 0.02537307f, 0.13194208f, 
    0.05313390f, -0.02649277f, -0.02587721f, -0.04107624f, 0.07876025f, 0.04661491f, 0.00653223f, -0.00180970f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.16840330f, 0.25692013f, -0.29580504f, 0.03420566f, 0.03808568f, 0.07236098f, -0.10879870f, 0.03617906f, 
    0.21466631f, -0.28323570f, -0.44029149f, -0.45627883f, 0.06524823f, -0.12803908f, -0.49951360f, -0.43955052f, 
    0.00932640f, 0.04742816f, -0.10140880f, -0.02014950f, -0.03013416f, -0.40024546f, -0.08198595f, -0.06975911f, 
    -0.04373851f, 0.21544179f, -0.57534242f, -0.64925593f, -0.16388743f, -0.37196738f, -0.32142678f, 0.26587352f, 
    -0.09337536f, 0.27388602f, -0.13773276f, -0.11006029f, -0.25450763f, 0.05455385f, 0.20171934f, 0.04215636f, 
    -0.07430405f, -0.32375488f, 0.18310596f, -0.11442947f, -0.10765406f, -0.50733012f, 0.26520219f, 0.33662096f, 
    0.09116253f, 0.14327781f, -0.26086819f, 0.00986187f, 0.20838384f, -0.31131816f, -0.13806620f, 0.27323636f, 
    -0.41570365f, 0.07785272f, 0.01877264f, -0.15310362f, -0.01236873f, 0.18509781f, -0.04882358f, -0.01039668f, 
    0.07595208f, 0.15951851f, 0.31527600f, 0.15179232f, 0.06167820f, 0.13645829f, 0.08168964f, 0.12383264f, 
    0.02487598f, 0.27131706f, -0.21190885f, 0.18407205f, 0.09692983f, 0.22188313f, 0.20605201f, -0.09401751f, 
    -0.01971474f, 0.00533557f, -0.02064231f, -0.26517972f, 0.29614785f, 0.12816420f, -0.08130951f, -0.00847032f, 
    0.32721856f, 0.24606238f, -0.23205049f, -0.11210963f, -0.07122589f, 0.48081759f, -0.12141289f, -0.01604439f, 
    0.09394312f, 0.03782647f, 0.30575910f, -0.10016580f, 0.17131306f, -0.14418246f, -0.06007378f, -0.11645955f, 
    -0.08605505f, -0.28398314f, -0.20463243f, -0.14109908f, 0.16648947f, -0.29926139f, 0.02169268f, -0.67152375f, 
    0.01872195f, 0.11968841f, -0.04962729f, -0.05423912f, 0.28094888f, -0.44971350f, 0.22062989f, 0.05680948f, 
    -0.09195608f, -0.12717377f, -0.20575166f, -0.24035569f, -0.78054547f, 0.03936404f, 0.01261775f, 0.06999820f, 
    -0.06541508f, 0.23852868f, 0.36504111f, 0.08060226f, 0.12544040f, -0.01540439f, 0.47078395f, 0.23875098f, 
    0.02071395f, 0.42182809f, -0.03896824f, 0.19081093f, -0.12010875f, -0.17645168f, 0.35160923f, -0.06438894f, 
    -0.04429345f, -0.01263843f, 0.07007571f, -0.06174145f, -0.36020368f, 0.27285710f, 0.07665481f, 0.24352093f, 
    -0.42533278f, -0.82222426f, -0.04217242f, -0.03227869f, -0.14575163f, -0.02465492f, 0.24683526f, -0.29959342f, 
    0.04238382f, 0.12847756f, -0.47909319f, -0.01531367f, -0.37301081f, 0.17486255f, -0.43140468f, -0.02333572f, 
    -0.02392394f, -0.04086559f, -0.36155730f, -0.65405107f, -0.20178868f, 0.20785528f, -0.13751550f, 0.17321609f, 
    0.06242394f, -0.20344128f, -0.19395731f, 0.06678471f, -0.05129594f, 0.12735471f, 0.08919562f, -0.13764703f, 
    -0.09210525f, -0.12908252f, -0.12565686f, 0.00409251f, 0.15392850f, -0.48955184f, -0.17196465f, -0.03841108f, 
    -0.25896549f, -0.18618694f, 0.35662171f, -0.50693631f, -0.02915118f, 0.21623865f, 0.01200991f, 0.07081091f, 
    -0.03861903f, -0.46403319f, 0.11778952f, -0.27470958f, -0.15182307f, -0.26475736f, 0.25125688f, -0.11870292f, 
    -0.12904927f, -0.40625504f, 0.06764077f, -0.11958479f, -0.40008816f, -0.01670291f, -0.06480074f, 0.15526429f, 
    -0.19706771f, 0.12613833f, -0.03419602f, -0.24024598f, 0.07217583f, -0.10223983f, 0.09271330f, 0.26729736f, 
    -0.11802442f, 0.00898469f, -0.01077424f, 0.04503380f, -0.23985757f, -0.21613519f, 0.12748156f, -0.05704423f, 
    0.01060629f, -0.03381917f, 0.02948978f, 0.17405118f, 0.16966361f, -0.42758873f, -0.06850547f, 0.13643047f, 
    0.03265113f, -0.38777009f, 0.41111228f, 0.01848108f, 0.16142608f, 0.31561613f, -0.60923988f, -0.29845756f, 
    0.14466962f, 0.03759582f, -0.30796668f, 0.20456320f, 0.11001845f, -0.04566882f, -0.56680757f, -0.08327574f, 
    -0.17972851f, 0.29439014f, -0.05199673f, 0.19257082f, -0.10546366f, -0.05259400f, 0.15112908f, 0.12049104f, 
    0.08794715f, -0.39315724f, -0.33949351f, -0.07429986f, 0.03946130f, -0.19135827f, -0.39027286f, 0.02453622f, 
    -0.04596152f, 0.16006213f, -0.00448193f, -0.39259252f, -0.00977825f, -0.28382933f, 0.02394575f, -0.00615787f, 
    -0.19229569f, 0.18628658f, 0.28306741f, -0.17211464f, 0.25045857f, 0.13106287f, 0.16611235f, -0.29884052f, 
    0.05463114f, -0.24933171f, 0.18041012f, -0.01615317f, 0.06399319f, 0.09830577f, 0.14792056f, -0.03682536f, 
    -0.04584219f, 0.23132569f, 0.26615250f, -0.40638629f, -0.01923256f, 0.17646556f, 0.15625805f, 0.08537065f, 
    -0.09727588f, -0.16232784f, -0.27909786f, -0.03257328f, -0.02645635f, -0.14279550f, 0.00595331f, -0.55333871f, 
    -0.24357004f, -0.02899033f, 0.06991500f, 0.20513105f, 0.18067622f, -0.60147619f, 0.01437979f, -0.08753710f, 
    0.15035829f, -0.21405755f, -0.66643566f, -0.28513241f, 0.06869859f, -0.06892495f, -0.12295426f, 0.12753430f, 
    -0.16512521f, 0.21208209f, 0.04145890f, -0.25111273f, 0.26239327f, 0.28783333f, -0.17226771f, -0.09448177f, 
    -0.05371273f, 0.16041617f, -0.11218692f, 0.10923462f, 0.23258194f, -0.17814654f, -0.07970198f, 0.01333775f, 
    -0.24192712f, -0.07020307f, -0.32798663f, 0.05686285f, 0.10679665f, -0.18892375f, 0.05210834f, -0.00823387f, 
    -0.08660067f, -0.17053856f, -0.57784367f, 0.05307454f, 0.04339294f, 0.07227170f, 0.28662610f, 0.06148088f, 
    -0.08242493f, 0.07681274f, -0.03231538f, 0.22975367f, 0.15112643f, 0.37312734f, -0.10347931f, -0.13518280f, 
    0.09731764f, 0.09614889f, -0.28349873f, -0.05556249f, 0.03807875f, -0.69079328f, -0.10446087f, 0.12864561f, 
    0.17859009f, 0.20964833f, 0.34439144f, -0.01346787f, -0.01019140f, 0.24601197f, 0.15274420f, 0.00498195f, 
    0.00463385f, -0.53593296f, -0.07615440f, 0.15602370f, 0.09414233f, -0.70142895f, -0.09284256f, 0.20047234f, 
    -0.24488568f, -0.21819788f, -0.03310354f, -0.07331181f, -0.34024358f, 0.47780821f, -0.11898173f, 0.23106244f, 
    -0.00927070f, 0.12136479f, -0.09286393f, 0.27443349f, -0.36239597f, 0.15466870f, -0.03774423f, -0.08155493f, 
    0.05631539f, -0.53981370f, 0.45145097f, 0.15414897f, -0.19592533f, -0.26529327f, 0.40846536f, -0.36921230f, 
    0.08135913f, -0.01225331f, 0.05459206f, 0.02036560f, 0.15546018f, 0.26479989f, -0.81552148f, -0.06913254f, 
    -0.07175810f, 0.27084848f, -0.76767820f, -0.12675482f, -0.52521443f, 0.17318882f, -0.26045805f, -0.06137952f, 
    0.18123183f, -0.14721180f, -0.06749762f, 0.04692686f, -0.33008173f, 0.19371733f, -0.25437987f, -0.13738881f, 
    -0.24335754f, -1.05344296f, -0.40824622f, -0.75403643f, 0.34637740f, -0.08483966f, 0.08563098f, 0.05030920f, 
    -0.32226390f, -0.24708416f, 0.17136206f, 0.15147005f, -0.05687585f, -0.29682827f, -0.67180812f, -0.52701354f, 
    0.19869108f, -0.23090540f, 0.07356563f, 0.17705503f, -0.30235752f, -0.34586895f, 0.06599403f, 0.11821026f, 
    -0.01976318f, -0.12358873f, -0.00128202f, 0.05201993f, -0.18185289f, -0.10656643f, -0.12075536f, -0.25939259f, 
    -0.26359701f, -0.19596176f, -0.37286389f, 0.24468720f, 0.19008167f, -0.24783824f, -0.24578494f, 0.09597361f, 
    0.11689200f, -0.06253706f, 0.08378931f, -0.14592373f, 0.10267720f, -0.15867092f, -0.47787201f, -0.06811678f, 
    -0.02007305f, -0.16356795f, -0.01297876f, -0.11584674f, -0.02854769f, 0.05348235f, -0.42290527f, 0.44014317f, 
    0.07588854f, -0.02587277f, -0.39582500f, 0.06723830f, -0.29393816f, 0.18018936f, 0.27011821f, -0.07534886f, 
    0.57910091f, 0.05672272f, 0.14326584f, -0.44956934f, 0.17160302f, 0.15192264f, -0.05936199f, 0.09821496f, 
    -0.07846899f, -0.18467940f, -0.11928623f, -0.32128257f, 0.00081308f, 0.03734503f, -0.17254212f, -0.71990162f, 
    -0.16245604f, 0.32771066f, 0.11588983f, 0.06500960f, 0.08680441f, -0.42999887f, 0.25716972f, -0.12578402f, 
    -0.05077917f, 0.22738041f, -0.10793640f, 0.27912536f, -0.19305566f, 0.19321240f, 0.00631753f, 0.04461988f, 
    -0.47470674f, -0.06065261f, -0.65423656f, -0.10976566f, -0.20910382f, -0.16581963f, 0.22777873f, 0.25388175f, 
    -0.04127262f, 0.30751416f, 0.21442571f, -0.08347653f, 0.27318382f, 0.00981919f, -0.02869273f, -0.06420936f, 
    0.11378552f, 0.07093925f, -0.25167578f, 0.20345317f, -0.21008594f, -0.11087589f, -0.48742375f, -0.40549088f, 
    0.05187288f, -0.08601199f, 0.09443161f, 0.07448068f, -0.16174075f, 0.14579976f, -0.19139062f, 0.15850121f, 
    -0.20167524f, -0.71656799f, 0.21886483f, 0.15740651f, -0.14358793f, 0.26574364f, -0.26654842f, -0.09222279f, 
    0.30781794f, 0.01075410f, 0.02007550f, 0.07676424f, -0.06959563f, -0.37999815f, -0.22346434f, -0.05955214f, 
    0.13125895f, 0.14989528f, -0.03246697f, 0.21563056f, -0.55081189f, 0.19571175f, -0.43439060f, 0.30132574f, 
    0.06312398f, -0.71077913f, 0.09327814f, -0.03478585f, 0.14441694f, 0.10426860f, -0.11381087f, -0.52454269f, 
    0.21975964f, 0.13937561f, 0.22320144f, -0.02047505f, 0.16004272f, 0.12383027f, -0.48414123f, -0.71187687f, 
    -0.02825492f, -0.53606230f, -0.33292431f, 0.04950203f, -0.10255320f, -0.07663241f, 0.16838819f, -0.10854653f, 
    -0.12000302f, 0.05597178f, 0.24802718f, 0.51319718f, -0.32181376f, 0.25249746f, 0.46119535f, 0.09600576f, 
    -0.29397428f, -0.56455618f, -0.22073647f, 0.08390209f, -0.19684760f, 0.02698747f, 0.17160036f, 0.30741388f, 
    -0.32936531f, 0.04318413f, -0.04877789f, -0.34040251f, 0.17939939f, -0.24816833f, -0.25717029f, 0.03000739f, 
    0.20341396f, 0.03692906f, -0.21488874f, 0.15197021f, -0.05067892f, 0.30406734f, 0.14990197f, -0.07025064f, 
    -0.32795313f, -0.38225943f, -0.30648559f, 0.13901195f, -0.29787391f, 0.21527399f, -0.28808320f, 0.18332715f, 
    -0.04745898f, 0.12776782f, 0.04739520f, 0.18813948f, -0.19798614f, -0.15341642f, 0.04233459f, 0.15229216f, 
    0.09346417f, -0.65621513f, 0.28404912f, 0.11868753f, 0.34808463f, -0.23043399f, 0.19738300f, 0.14046744f, 
    0.03085132f, 0.09402922f, -0.31818527f, -0.04769462f, -0.42133433f, 0.00464925f, 0.05991242f, -0.05822668f, 
    0.09769884f, 0.29459974f, -0.71349519f, -0.01893069f, -0.21176533f, -0.50169927f, -0.36839858f, -0.52795368f, 
    -0.51632488f, 0.27263168f, 0.50919998f, 0.08985639f, 0.15748507f, 0.10061680f, 0.04885457f, 0.00286550f, 
    0.38412920f, -0.01667875f, -0.09695729f, 0.11360345f, -0.65324646f, -0.10235854f, -0.69306862f, 0.01886332f, 
    -0.59942067f, -0.49699330f, -0.02600443f, 0.09976757f, -0.05600608f, -0.00315230f, -0.12393630f, 0.20956939f, 
    -0.32994786f, -0.38294321f, 0.28293431f, 0.08877631f, 0.17601551f, -0.26208889f, 0.07349916f, -0.30632257f, 
    0.03546063f, 0.17016892f, 0.08540005f, -0.25050148f, 0.18923818f, 0.06112416f, -0.04512770f, -0.48009992f, 
    0.45476145f, -0.20391199f, 0.03227516f, 0.05646668f, -0.49199373f, -0.00258915f, -0.30615875f, 0.03902597f, 
    -0.08925698f, -0.25094852f, 0.02489487f, 0.08920404f, 0.02684489f, 0.00897527f, -0.30979282f, -0.07353713f, 
    -0.13357338f, 0.24296421f, 0.27483150f, -0.18655735f, 0.26849180f, 0.18003704f, -0.36935177f, -0.40626130f, 
    0.12303325f, 0.38606685f, 0.30819902f, -0.02038625f, -0.54045796f, 0.30124617f, -0.03220073f, 0.23920661f, 
    -0.39318982f, -0.43300056f, -0.16722056f, 0.21287167f, 0.24867530f, -0.23747918f, -0.05877500f, -0.09489813f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.02218885f, -0.06667554f, 0.23645075f, 0.02608944f, -0.18269667f, 0.04904057f, 0.01786571f, 0.05165659f, 
    0.01305775f, 0.06233795f, 0.01379955f, 0.12294178f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
