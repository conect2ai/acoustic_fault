#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.31889412f, -0.54361492f, 0.57132936f, 0.26635721f, -0.04267244f, -0.13764089f, -0.24020459f, -0.03951450f, 
    0.34635472f, -0.21106303f, -0.54388410f, -0.66854805f, 0.05937907f, 0.19434331f, 0.78638220f, 0.09069349f, 
    -0.07273876f, -0.18203934f, -0.20611127f, 0.02445165f, 0.01804776f, -0.11259071f, -0.51969612f, -0.64109057f, 
    0.32650715f, 0.25665170f, 0.35849169f, 0.46116927f, 0.58454239f, -0.44967270f, -0.03066599f, -0.27785283f, 
    -0.20200229f, -0.06312873f, 0.23655279f, 0.17589101f, -0.18853770f, 0.21002956f, -0.10407709f, -0.20825084f, 
    0.49741632f, -0.30761063f, 0.36005318f, -0.34058684f, 0.04536449f, 0.34144410f, 0.60172307f, -0.10839987f, 
    -0.16014107f, 0.05769036f, -0.31683823f, 0.04218520f, 0.21850942f, -0.22124971f, -0.71076179f, 0.20668907f, 
    0.30417755f, 0.30628812f, 0.62086540f, -0.38542235f, 0.23756458f, 0.13677980f, 0.00789391f, 0.27213755f, 
    0.26007235f, 0.10373787f, 0.19570336f, 0.35644260f, 0.35750705f, -0.09938589f, -0.17784342f, -0.04955085f, 
    0.03061341f, -0.12873858f, 0.10890875f, -0.44259822f, 0.40738168f, -0.73203331f, 0.50047427f, 0.36786747f, 
    -0.14506555f, -0.56230342f, -0.25840980f, 0.60062706f, -0.41855448f, -0.18013220f, -0.08020714f, 0.24128152f, 
    0.23813806f, 0.39189917f, 0.08649223f, 0.19961594f, 0.01373905f, -0.10461671f, 0.15959567f, 0.17292300f, 
    0.05162210f, -0.35275611f, -0.09117025f, -0.18112321f, 0.12839180f, -0.33024621f, -0.07902061f, -0.31194845f, 
    -0.40540931f, 0.29884121f, -0.04150347f, -0.21861351f, -0.24439614f, 0.54833937f, 0.16756032f, -0.59634769f, 
    -0.36815622f, -0.40350214f, -0.25270835f, -0.35501733f, -0.20367050f, -0.08629385f, 0.25501257f, -0.24873792f, 
    -0.49566165f, -0.14855307f, -0.40541190f, -0.21261604f, 0.49993747f, -0.39486524f, -0.05523846f, 0.25475258f, 
    -0.41429481f, -0.70723504f, -0.27715835f, -0.22880274f, 0.04819454f, -0.25196773f, 0.64863944f, 0.48991042f, 
    0.13132076f, 0.22575603f, 0.09389412f, 0.45946595f, -0.18179005f, -0.05301580f, 0.06829074f, 0.06438547f, 
    0.56595850f, -0.15016292f, -0.12830088f, -0.00931089f, 0.40115267f, 0.51829559f, 0.48381567f, -0.40489811f, 
    0.24570361f, -0.74884516f, -0.23306525f, 0.29865292f, 0.06667748f, 0.07228271f, 0.84712029f, 0.23614898f, 
    -0.31814322f, 0.12132069f, 0.36031502f, -0.16966072f, -0.31761169f, -0.09886741f, 0.35073313f, 0.36435530f, 
    -0.55066574f, -0.34309247f, -0.54950488f, 0.91808408f, -0.42072120f, -0.60271704f, 0.64683634f, 0.01378418f, 
    0.19119260f, -0.12265994f, 0.36348426f, -0.05471915f, -0.00625837f, 0.22304511f, 0.22417861f, -0.06871893f, 
    -0.45948645f, 0.32665560f, 0.16612457f, -0.21870463f, 0.00930636f, -0.75101942f, 0.94337767f, -0.52269220f, 
    -0.15862992f, 0.10061175f, 0.25013155f, -0.06444486f, 0.22103807f, 0.18418196f, 0.50450915f, 0.27573135f, 
    0.54831433f, -0.59175241f, -0.05521501f, 0.34494722f, -0.19122569f, 0.33844361f, -0.31109861f, -0.44949219f, 
    0.10811186f, 0.49490958f, 0.40839767f, 0.02683638f, -0.31427431f, 0.14525682f, -0.53280753f, -0.17257042f, 
    0.59574938f, -0.72273129f, 0.26021817f, -0.10519195f, -0.09565096f, 0.04353013f, 0.17779857f, 0.39729974f, 
    0.19402780f, -0.45309693f, 0.10456045f, 0.71407086f, -0.68279082f, 0.58187920f, -0.24983026f, -0.13373400f, 
    0.09217618f, -0.11630625f, 0.53046077f, -0.80279583f, 0.11973390f, -0.25707886f, 0.04320914f, -0.36640763f, 
    -0.07277922f, -0.15876310f, -0.30212054f, -0.02079023f, -0.54639518f, -0.48789096f, -0.17427376f, 0.88053942f, 
    -0.06597870f, -0.33953258f, 0.04670826f, -0.12084775f, 0.05235379f, 0.64490008f, 0.21057457f, -0.78966695f, 
    -0.24096330f, 0.07576923f, 0.18627007f, 0.26871723f, 0.38773066f, -0.04789421f, 0.49136561f, -0.54166210f, 
    0.31662875f, -0.29228291f, -0.28201205f, 0.02216111f, 0.27393013f, -0.39234307f, -0.37526357f, -0.25853163f, 
    0.14056621f, -0.26054803f, -0.43103245f, 0.09648920f, -0.01083889f, -0.20990443f, -0.14496115f, -0.60828125f, 
    -0.10361214f, -0.25279000f, 0.00063434f, 0.40887374f, -0.44572553f, 0.07616230f, 0.29657760f, 0.10679196f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07309786f, 0.15125376f, -0.02277930f, 0.12265819f, 0.00637053f, 0.17660689f, -0.23321378f, -0.02265321f, 
    -0.21778792f, -0.18187301f, 0.16836841f, -0.32596123f, -0.41457537f, -0.30866936f, -0.06403174f, -0.01575783f, 
    -0.13034798f, 0.01179925f, -0.15488544f, -0.06181243f, 0.24565063f, 0.01934262f, -0.35831216f, -0.11898443f, 
    -0.00118600f, -0.14056875f, -0.25821635f, -0.39914706f, -0.20888107f, 0.02855288f, -0.17373164f, 0.05592109f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.06046715f, 0.03284296f, 0.05691251f, -0.06970606f, -0.04390028f, -0.04961668f, -0.02387385f, 0.15645251f, 
    0.07907669f, 0.21688315f, -0.10833701f, -0.05033203f, 0.05473102f, 0.02440972f, 0.12736095f, -0.06497575f, 
    -0.01728613f, -0.06156631f, -0.03098308f, 0.16454995f, 0.25200877f, 0.08250001f, -0.08694159f, -0.02838086f, 
    -0.04077461f, -0.08355206f, 0.07643018f, 0.07914213f, -0.09671377f, -0.28479740f, -0.08096205f, -0.01273307f, 
    0.00663012f, 0.11460879f, 0.13612528f, 0.06965932f, 0.00625785f, 0.03900762f, -0.05301952f, -0.02727025f, 
    -0.09305769f, 0.10310528f, 0.06261239f, 0.03619691f, -0.17565455f, 0.12517142f, -0.22556125f, -0.14468828f, 
    0.11949658f, 0.00731738f, 0.05632262f, 0.18332760f, 0.09496467f, -0.03439624f, -0.23269971f, 0.00823465f, 
    -0.03049617f, 0.06194426f, -0.09822407f, 0.15179551f, 0.05855897f, 0.07491888f, 0.01082661f, 0.03434005f, 
    -0.08979997f, -0.28643864f, 0.09834097f, -0.14575414f, -0.20822780f, -0.03315557f, 0.00243148f, 0.02414504f, 
    -0.00714619f, 0.05361907f, 0.20441768f, 0.07785296f, 0.01385571f, 0.02432968f, 0.05426739f, -0.02577099f, 
    -0.10119839f, -0.17563689f, 0.21079481f, 0.26639435f, 0.09856969f, -0.06937833f, -0.00169233f, 0.00061987f, 
    0.00613825f, -0.00266114f, 0.09306500f, 0.05923945f, 0.02791399f, 0.08786822f, -0.05401540f, 0.04961058f, 
    -0.19205736f, -0.06288403f, -0.11903686f, 0.02590301f, 0.16032061f, -0.02466144f, 0.10793190f, 0.02170933f, 
    0.03603588f, -0.00458193f, -0.12823485f, -0.02453510f, -0.12665167f, 0.02990231f, 0.02092300f, 0.08041755f, 
    0.07325874f, 0.04064560f, -0.04908164f, 0.03209482f, -0.26876470f, -0.12888727f, 0.12717679f, 0.03812963f, 
    -0.01073657f, 0.04764628f, -0.01391210f, -0.03961063f, -0.08017716f, -0.19072518f, 0.06362976f, 0.14931788f, 
    0.16910589f, -0.05196011f, 0.08235403f, 0.07234156f, -0.10173350f, 0.02724747f, -0.04265786f, -0.22493133f, 
    -0.17534506f, -0.07090731f, 0.11878316f, 0.04324466f, 0.03030422f, 0.12751874f, -0.01563001f, 0.05440473f, 
    -0.17227909f, -0.16996114f, -0.09928772f, -0.04602150f, -0.03873271f, -0.03580761f, -0.05925632f, 0.08204961f, 
    0.13997944f, -0.27385607f, -0.15731496f, 0.05516127f, 0.03382106f, -0.11863384f, 0.09541675f, 0.03821944f, 
    0.09451108f, 0.04495342f, 0.15393543f, 0.01240681f, 0.08115386f, -0.08110164f, -0.14947411f, 0.02943828f, 
    -0.17255113f, -0.09454571f, -0.12513040f, -0.03666007f, -0.27087048f, -0.16270570f, 0.03762026f, -0.06938250f, 
    -0.01648928f, 0.10846956f, -0.06183097f, 0.08882539f, -0.14403433f, 0.05050699f, 0.05603905f, -0.07554011f, 
    0.02684730f, 0.02970219f, -0.08499838f, 0.02809691f, 0.01575301f, -0.16874529f, 0.08693463f, -0.08783915f, 
    -0.02040000f, 0.06780827f, 0.12057462f, -0.02323480f, 0.17218266f, -0.08532574f, 0.01492731f, -0.22077698f, 
    0.08875829f, -0.12369330f, -0.02408661f, 0.18079385f, 0.02300143f, 0.01305398f, -0.09181462f, -0.41293305f, 
    -0.21398990f, -0.21394707f, 0.12445941f, -0.14086863f, 0.04412838f, -0.07816356f, -0.10224942f, -0.37845755f, 
    -0.16040638f, 0.13681957f, 0.09971628f, 0.07394904f, -0.00355261f, 0.11890875f, -0.03280235f, 0.06200791f, 
    0.11957548f, -0.80176723f, -0.11503906f, 0.17878097f, 0.00253218f, 0.03157421f, 0.12597147f, -0.05585217f, 
    0.12113622f, -0.10927328f, 0.33341590f, 0.01556158f, 0.01939428f, 0.06745566f, 0.06308451f, 0.09731585f, 
    -0.10372904f, -0.15572858f, -0.18899502f, 0.11182640f, -0.10885242f, -0.13746385f, -0.00414883f, -0.01348871f, 
    -0.02413577f, -0.06931528f, 0.13195866f, 0.05236162f, -0.02311149f, 0.06697202f, -0.07156405f, -0.06535646f, 
    -0.06572777f, -0.06085582f, 0.02359203f, 0.08823632f, 0.11677845f, 0.03374987f, 0.06228689f, -0.03152012f, 
    0.06795601f, 0.07337365f, 0.04134264f, -0.07065640f, 0.09087523f, 0.03816210f, -0.05085497f, 0.12994897f, 
    0.00072424f, 0.01770040f, -0.04987219f, -0.00698159f, -0.01729223f, -0.03820073f, -0.13994555f, 0.03701735f, 
    0.18684192f, 0.15320027f, -0.06274096f, 0.11253686f, 0.04503664f, -0.01713115f, -0.10462862f, 0.08947195f, 
    0.23058559f, 0.16486266f, -0.14535604f, 0.19849031f, 0.06374069f, 0.05155955f, 0.00234220f, 0.20402829f, 
    -0.01398593f, 0.19995220f, -0.17111146f, -0.12283588f, 0.10897202f, 0.01847283f, 0.00404196f, -0.06986885f, 
    0.09039777f, -0.03896588f, 0.06097741f, 0.08523146f, 0.17823200f, -0.10479948f, 0.10885403f, -0.10249478f, 
    0.05051588f, -0.05001334f, 0.00503674f, 0.17824839f, -0.17223391f, -0.44387633f, -0.07048814f, 0.05507785f, 
    -0.07402368f, 0.09921490f, -0.00666261f, -0.02019597f, -0.16348965f, 0.03298601f, 0.03770206f, 0.03080464f, 
    -0.03922492f, 0.02250628f, 0.09260934f, -0.03569883f, -0.01005155f, -0.02443779f, -0.10414709f, -0.25584471f, 
    0.03405494f, -0.05547798f, -0.01244967f, 0.07194390f, -0.02363248f, 0.02685302f, -0.10771367f, 0.06610098f, 
    0.14293332f, -0.05034028f, -0.10572907f, 0.01784218f, 0.07926945f, 0.02663988f, 0.09797382f, 0.15260969f, 
    -0.11477470f, -0.35126656f, -0.00028230f, -0.08100984f, -0.09099764f, 0.11492534f, -0.09640580f, -0.04639614f, 
    0.03327251f, 0.09536290f, 0.24660024f, -0.06066284f, -0.07984670f, -0.03950769f, -0.03334654f, -0.08000088f, 
    0.01431672f, 0.13447577f, 0.12720750f, 0.13333830f, 0.05083471f, 0.06196794f, -0.10765648f, 0.06644926f, 
    -0.00036101f, -0.05901810f, -0.02491263f, -0.10943569f, 0.00021449f, 0.09326711f, -0.05490342f, 0.00872448f, 
    -0.00443814f, -0.10093260f, -0.11868612f, 0.30482170f, 0.12097319f, -0.05732441f, -0.00837569f, 0.04662958f, 
    0.07141703f, 0.06967440f, 0.07116374f, -0.03824567f, -0.00036033f, 0.14945629f, 0.17739472f, -0.04206060f, 
    0.09263343f, 0.03388957f, 0.00373541f, 0.01274828f, -0.12004848f, -0.01303440f, 0.05940108f, 0.01273424f, 
    0.04213548f, 0.00456401f, 0.10166480f, 0.04791205f, 0.00101487f, -0.01692020f, 0.14016493f, 0.09887838f, 
    0.08487107f, -0.09917581f, -0.03322598f, 0.08166624f, 0.12536390f, -0.05715244f, -0.14387535f, -0.05895820f, 
    0.05031153f, -0.44170436f, 0.10305373f, -0.11635201f, -0.11924032f, 0.08997390f, -0.07079481f, -0.00656125f, 
    -0.14176245f, 0.24068899f, -0.76085138f, -0.15045036f, -0.15021048f, 0.07063050f, -0.02593625f, 0.20149086f, 
    0.07630821f, -0.17397366f, -0.26061475f, 0.11255306f, 0.10836341f, -0.01067519f, 0.02067705f, 0.05821251f, 
    -0.03758003f, 0.07414058f, 0.09388882f, -0.19404170f, 0.12055768f, -0.09114429f, 0.05868506f, 0.05552986f, 
    0.02285212f, 0.11835986f, 0.00890173f, -0.31974941f, 0.04481243f, -0.35074213f, -0.04694227f, -0.01713548f, 
    0.01184304f, 0.02799530f, -0.02970699f, -0.13236539f, -0.21293351f, 0.00827435f, 0.05051343f, -0.03220293f, 
    0.09339188f, -0.04626442f, 0.01196238f, 0.00589074f, -0.11563604f, -0.29941350f, 0.11412227f, -0.42293221f, 
    -0.00111351f, -0.13398823f, 0.14125685f, 0.10694828f, 0.03581889f, -0.10262850f, -0.00772977f, -0.29207575f, 
    -0.34892479f, 0.13695781f, 0.01696726f, -0.23466493f, -0.11764558f, -0.02693617f, 0.04778029f, -0.04379763f, 
    -0.10525954f, -0.04018544f, 0.03100540f, 0.00447012f, -0.01959800f, 0.00095672f, 0.09353343f, -0.03911695f, 
    0.08216533f, 0.08877726f, -0.07477999f, -0.05969367f, 0.14385405f, -0.05155817f, 0.02047875f, 0.04029547f, 
    0.10728890f, -0.26193714f, -0.17199212f, 0.29813224f, -0.02385474f, 0.02135866f, -0.01403156f, -0.02249380f, 
    0.05958052f, 0.06452129f, 0.26724204f, 0.05398957f, 0.14317355f, 0.05536422f, 0.09761311f, 0.01333063f, 
    0.05741681f, -0.07228563f, 0.11859033f, 0.15424223f, -0.23983555f, -0.07964524f, 0.19754496f, -0.00163438f, 
    0.12631191f, 0.05720561f, 0.11026455f, 0.14908321f, 0.16149248f, -0.32318780f, -0.34221917f, -0.17995781f, 
    -0.05379263f, -0.04588726f, -0.05724784f, 0.00549642f, 0.01511890f, -0.08443712f, 0.14770129f, -0.26084030f, 
    0.03548923f, -0.02519006f, 0.06999391f, 0.14586432f, 0.08146791f, 0.10832470f, 0.24229841f, 0.17650001f, 
    0.13057867f, 0.00825744f, 0.11363503f, -0.05530392f, 0.07178283f, -0.06985375f, -0.04230692f, 0.06608754f, 
    0.08880769f, 0.12225641f, 0.00125256f, 0.06100708f, 0.09959678f, 0.08964535f, -0.05510473f, -0.00651146f, 
    -0.05840418f, -0.04740692f, -0.05287908f, -0.04613982f, -0.05234255f, -0.02053192f, 0.04042901f, 0.03336558f, 
    0.03106728f, -0.04255928f, 0.00502025f, 0.00859849f, 0.00446825f, 0.03205836f, 0.04233166f, 0.04823469f, 
    0.02176780f, -0.01842148f, -0.01919841f, 0.04558272f, -0.03709315f, -0.00711618f, -0.05367035f, -0.05791903f, 
    -0.02167768f, 0.02712691f, 0.02712617f, -0.01723495f, -0.05252982f, -0.01411474f, -0.01342115f, -0.04229074f, 
    0.02461155f, -0.02503127f, 0.02389513f, -0.02639109f, -0.02894976f, -0.05002012f, -0.02555941f, 0.05542405f, 
    -0.05788513f, -0.03500954f, -0.02542900f, -0.00668177f, 0.01586418f, 0.04870228f, -0.06203834f, -0.05064149f, 
    0.00996815f, -0.00616544f, 0.03387399f, 0.04177845f, 0.02681949f, -0.01359838f, -0.05686107f, -0.03693002f, 
    0.01750729f, 0.01759493f, -0.07228211f, 0.05043106f, -0.00947421f, 0.02689974f, 0.01870228f, -0.01935321f, 
    0.03172023f, 0.03692022f, 0.02793434f, 0.01529106f, 0.02415715f, -0.00270472f, -0.04161908f, -0.04946081f, 
    0.02657926f, -0.00387933f, -0.06059165f, 0.01945669f, -0.02204744f, -0.01000752f, 0.01161373f, -0.02569632f, 
    -0.04074148f, 0.03373327f, -0.06931293f, -0.01153929f, -0.02559380f, 0.02078925f, -0.02549341f, -0.04552202f, 
    -0.01123684f, -0.04042298f, 0.01274707f, -0.03841829f, 0.03273395f, 0.02143262f, -0.03948867f, -0.03700826f, 
    -0.04954999f, -0.00252471f, -0.04465345f, 0.00042066f, 0.00659744f, 0.03402391f, -0.02725728f, 0.02187123f, 
    0.03003989f, -0.00325527f, -0.01187520f, 0.02296479f, -0.03806040f, -0.03980529f, -0.03210692f, -0.05495842f, 
    0.01719907f, -0.03749324f, -0.03199689f, -0.05246608f, 0.01549311f, -0.00398776f, 0.01633320f, 0.00270760f, 
    0.00856945f, -0.03236950f, 0.03244462f, -0.01182851f, 0.02890258f, -0.03306612f, 0.00857463f, -0.04622563f, 
    -0.02392890f, -0.05637063f, -0.02676340f, 0.05443951f, 0.00454675f, -0.04752169f, -0.02061668f, -0.03710084f, 
    0.02542879f, 0.00020778f, 0.00420022f, 0.01417780f, 0.02569903f, 0.01326429f, -0.00372831f, 0.00730117f, 
    -0.05410017f, 0.04168689f, -0.03590044f, -0.06514372f, -0.00797114f, 0.04089051f, 0.04129407f, 0.05148910f, 
    0.03422870f, 0.03852553f, -0.03651369f, 0.02129053f, 0.03400740f, -0.05935246f, -0.04289127f, 0.05066405f, 
    -0.06137177f, 0.04293463f, -0.05843448f, -0.03255606f, 0.01611761f, -0.04978978f, -0.03260669f, 0.04723030f, 
    0.03106928f, -0.01694031f, 0.02192078f, -0.01418683f, -0.02649928f, -0.02689125f, -0.01746731f, 0.03339441f, 
    0.01891702f, 0.05159589f, -0.00414797f, 0.02432259f, 0.03895578f, -0.02408980f, 0.01207097f, -0.03577384f, 
    -0.04419429f, 0.01947197f, -0.01764639f, 0.02032314f, 0.03385533f, 0.04687425f, -0.02284618f, -0.02928224f, 
    0.03198965f, -0.03624305f, 0.00658669f, -0.04833307f, -0.00487703f, -0.01478583f, -0.00730280f, 0.04855543f, 
    0.02311215f, -0.04919669f, -0.02992636f, -0.01920688f, 0.01208913f, -0.04695970f, -0.02159729f, -0.06196447f, 
    -0.04422902f, -0.05434208f, 0.03569256f, -0.02988587f, 0.04745845f, 0.00186100f, -0.02894532f, 0.03292389f, 
    -0.06535852f, 0.02014463f, 0.02862834f, -0.05533157f, -0.02852218f, -0.02786652f, 0.02459865f, -0.00097290f, 
    0.02591680f, 0.03630720f, -0.05450245f, 0.02696977f, 0.01288968f, -0.04941900f, -0.06152970f, 0.01986531f, 
    -0.02425722f, 0.04771690f, -0.06694990f, -0.02357883f, -0.04726990f, 0.04874245f, -0.02594032f, 0.04036400f, 
    0.00893945f, -0.03611902f, -0.01386319f, 0.00574623f, -0.03847617f, 0.02228906f, -0.05335558f, -0.03025554f, 
    0.00856177f, 0.01230709f, 0.01703377f, -0.05910256f, -0.01653035f, 0.04508667f, -0.07148525f, -0.04877076f, 
    -0.00787898f, -0.03780732f, -0.03177601f, 0.01084089f, 0.00336480f, 0.02950283f, -0.02733841f, -0.04832448f, 
    -0.02228708f, 0.04830246f, -0.01782145f, -0.04843465f, 0.04001860f, -0.05717286f, 0.04331828f, -0.01058795f, 
    0.03502722f, 0.01602522f, -0.02117059f, -0.02926967f, -0.02144738f, 0.00833858f, -0.03574188f, -0.06339710f, 
    0.02046217f, -0.02041677f, -0.02750828f, -0.02980588f, -0.04648967f, -0.05018027f, -0.00966482f, -0.05518066f, 
    -0.16678701f, 0.22929282f, 0.07331693f, -0.01328456f, 0.04152196f, 0.12573878f, 0.03385161f, 0.04666464f, 
    0.02939907f, -0.20140705f, 0.24388883f, 0.19249532f, 0.13113430f, 0.16331041f, 0.07275546f, 0.15347277f, 
    0.12382306f, -0.19750702f, -0.01944126f, -0.06242637f, 0.22210498f, -0.01967250f, 0.04729727f, 0.04743914f, 
    0.02456769f, -0.07351767f, -0.05189686f, -0.27943209f, 0.25249574f, 0.20540504f, 0.03377772f, 0.14495219f, 
    0.09949183f, -0.00513369f, -0.03752172f, 0.00758371f, 0.13311723f, -0.05758657f, 0.07382270f, 0.03530375f, 
    0.08070613f, 0.17094193f, 0.10726347f, 0.10433023f, 0.15223199f, -0.21971557f, 0.06087048f, 0.22222956f, 
    -0.06033867f, -0.06844743f, -0.00042565f, -0.08798320f, 0.01830601f, 0.23995119f, -0.15692705f, -0.56730282f, 
    -0.28005579f, -0.20599301f, 0.02908189f, 0.03453292f, -0.16875328f, -0.06678302f, 0.07378414f, -0.06424061f, 
    -0.22591573f, -0.14150190f, -0.11889623f, -0.12497227f, -0.31069800f, 0.07816217f, -0.05567398f, -0.06060540f, 
    -0.07505476f, -0.04949611f, 0.17572053f, 0.01180211f, 0.09917213f, 0.00800417f, -0.23130535f, -0.03665407f, 
    -0.01826203f, 0.23808423f, -0.05365604f, -0.03158624f, -0.03311281f, 0.01842937f, -0.05808752f, -0.06999676f, 
    0.02886400f, -0.25366452f, 0.17114998f, 0.13887569f, -0.00665996f, 0.03891528f, -0.12675068f, -0.04753948f, 
    0.14298286f, -0.00218523f, 0.08669508f, -0.07747328f, -0.16729647f, 0.27399939f, -0.13592868f, -0.01767239f, 
    0.09206314f, 0.01791181f, 0.02058366f, -0.23632288f, -0.01687220f, -0.09021770f, 0.08294372f, -0.11355467f, 
    0.01628908f, -0.08834560f, 0.04775345f, -0.05171394f, -0.25168857f, 0.10012788f, -0.01467896f, 0.17519432f, 
    -0.05859659f, -0.05630438f, 0.18356188f, -0.07517602f, -0.08408579f, 0.04624074f, 0.03183147f, 0.05276698f, 
    0.20294775f, 0.09126853f, 0.04409773f, 0.05154920f, 0.09396996f, -0.07068562f, -0.14422679f, -0.13439585f, 
    -0.29377356f, -0.08732411f, -0.01853248f, 0.08459125f, -0.08514339f, 0.07081254f, 0.05087563f, 0.09369674f, 
    -0.09167462f, -0.11244212f, -0.08488877f, -0.03717906f, -0.08321158f, -0.12047715f, -0.07243500f, 0.12443224f, 
    0.18773834f, -0.19049399f, -0.27699262f, -0.26618451f, 0.03496781f, -0.13510223f, 0.01656444f, 0.00132734f, 
    0.17286044f, -0.05169217f, 0.31300494f, 0.32220918f, 0.12430964f, 0.08866435f, 0.04821219f, -0.14099179f, 
    0.10924062f, -0.04565551f, -0.15382756f, 0.29616460f, 0.08891535f, -0.36723918f, -0.04396374f, -0.04664907f, 
    -0.14230540f, -0.01203911f, 0.10930583f, 0.15550259f, 0.04229001f, 0.17045929f, -0.02469148f, -0.13935921f, 
    0.00951314f, 0.13886099f, 0.15210336f, 0.15266007f, 0.09311708f, 0.16885607f, -0.03397273f, 0.00504894f, 
    -0.10070251f, 0.03211968f, -0.01725027f, -0.03437025f, -0.18596798f, 0.24403267f, -0.29889023f, -0.45035413f, 
    -0.18803610f, -0.10736069f, -0.12336037f, 0.30262834f, -0.18834549f, 0.06687170f, 0.10857277f, 0.00200574f, 
    0.19654506f, 0.17117898f, -0.04069321f, 0.06584200f, -0.17019886f, 0.12271672f, 0.03677527f, -0.09561016f, 
    0.02534110f, -0.28727803f, -0.28315988f, 0.15931338f, 0.05274482f, 0.15020260f, 0.00147411f, 0.10694136f, 
    0.00331692f, 0.47338492f, 0.01790132f, -0.22107930f, -0.30645636f, -0.06743360f, -0.00154973f, -0.07925737f, 
    0.06471752f, -0.06416231f, -0.06662524f, 0.05867389f, 0.15757672f, -0.03621243f, 0.04385966f, 0.02482817f, 
    0.12748010f, -0.04060553f, -0.20057632f, -0.04778047f, 0.44429794f, 0.52299118f, -0.10850704f, -0.06563862f, 
    -0.21511197f, 0.12112920f, -0.22316535f, 0.06064771f, -0.14726168f, -0.03838401f, -0.03267243f, -0.18021429f, 
    0.02452241f, -0.03367183f, -0.11708324f, -0.08945566f, 0.06874382f, 0.18626495f, 0.17623499f, 0.34705740f, 
    -0.04533705f, -0.00769224f, 0.07822072f, 0.01827360f, 0.05203663f, 0.08512194f, -0.10291510f, -0.10154358f, 
    0.01439045f, 0.11715509f, 0.13204198f, 0.03546136f, -0.01122575f, 0.03332227f, -0.54738331f, -0.00779974f, 
    0.06122339f, 0.28186771f, 0.09932435f, 0.10404996f, 0.07071600f, 0.04995466f, -0.02944467f, 0.07288729f, 
    -0.33704600f, 0.07650443f, -0.41422039f, -0.10074204f, -0.00515421f, 0.05157583f, 0.12628613f, 0.14510669f, 
    -0.07792322f, -0.26015466f, -0.69916826f, -0.36143112f, -0.02106424f, -0.01589131f, -0.12921178f, 0.01805024f, 
    -0.14107692f, 0.00301111f, -0.23614851f, 0.41368490f, -0.03387478f, -0.02798930f, -0.10277039f, -0.02527264f, 
    0.10746716f, 0.00117798f, 0.01235953f, 0.00751611f, 0.22689000f, -0.17265858f, -0.13109787f, 0.17327599f, 
    0.07402941f, 0.05707965f, -0.01285932f, 0.12688617f, 0.21176264f, 0.23979020f, 0.03760375f, 0.13765226f, 
    0.19654882f, -0.06212144f, -0.02360221f, -0.14053322f, 0.10525134f, 0.08541155f, 0.14819923f, 0.07007150f, 
    -0.01157068f, 0.03948498f, -0.00441678f, 0.00451731f, 0.10787454f, 0.09065962f, 0.33965755f, -0.01052945f, 
    0.00825873f, -0.09453806f, 0.08571058f, -0.08680466f, 0.03189861f, -0.10447297f, -0.02797542f, 0.22516151f, 
    0.12097067f, 0.22360604f, -0.13322054f, -0.04101937f, -0.16547000f, 0.01625143f, -0.17518969f, -0.04744079f, 
    -0.02238972f, 0.18618602f, 0.06812897f, -0.08927798f, 0.02251054f, 0.04557488f, 0.12055625f, -0.01752883f, 
    0.17510362f, -0.07409495f, 0.07429091f, 0.24423589f, -0.12866625f, 0.05767307f, -0.04961419f, 0.12416255f, 
    0.10878843f, -0.13779214f, 0.10401626f, 0.15318787f, 0.16417035f, 0.02198113f, 0.12381476f, 0.07878648f, 
    0.07731342f, -0.04905091f, 0.01538010f, -0.45696786f, -0.23750414f, 0.09654021f, 0.05163534f, -0.12261536f, 
    -0.11459394f, -0.03229534f, 0.00615377f, 0.05224488f, -0.39099988f, -0.15336354f, 0.40963769f, 0.06279452f, 
    -0.04337015f, -0.16870333f, 0.09140643f, -0.02939715f, 0.10296135f, -0.34032455f, -0.02721331f, 0.33113968f, 
    -0.07598872f, -0.14425209f, -0.16627304f, 0.07425118f, -0.02913853f, 0.16188787f, -0.19571379f, -0.18336102f, 
    0.21981534f, -0.08568086f, 0.04576729f, -0.13355188f, -0.05989388f, 0.01045840f, 0.04048067f, 0.27054349f, 
    0.04268063f, 0.15093130f, -0.02258109f, 0.05906459f, -0.16408513f, 0.07479376f, -0.02929369f, 0.01908241f, 
    0.01655813f, -0.02946954f, 0.00852009f, -0.16586731f, 0.07326613f, -0.45881590f, -0.12804388f, -0.08135150f, 
    0.17821294f, 0.21860735f, -0.26509824f, -0.11663164f, -0.07832718f, -0.08383570f, -0.20689693f, 0.06693402f, 
    -0.15788186f, -0.00871555f, -0.03357213f, -0.08728205f, 0.00306900f, -0.06909196f, 0.09265314f, -0.02946295f, 
    0.10271816f, -0.03355737f, -0.06602899f, 0.04262392f, 0.15939713f, -0.20824817f, -0.21838999f, 0.06910276f, 
    -0.21288437f, 0.11789539f, 0.15508351f, 0.13076875f, 0.04345271f, 0.10925975f, 0.20126174f, 0.10226704f, 
    -0.02895830f, 0.06901406f, -0.05770501f, 0.18777116f, -0.01043939f, -0.11969142f, -0.43643293f, -0.04652790f, 
    -0.10587284f, 0.15346904f, -0.15727682f, -0.04087896f, 0.10529560f, 0.02176360f, 0.07074154f, 0.04338403f, 
    0.07617293f, 0.03524461f, 0.04365188f, -0.09632486f, 0.02550588f, 0.03208265f, -0.02533588f, 0.03389039f, 
    0.05259554f, -0.18691920f, 0.26312098f, 0.03030585f, 0.06620609f, 0.08161905f, -0.20404564f, -0.08639124f, 
    -0.07020094f, 0.04760239f, -0.00925978f, -0.01973039f, 0.05362324f, -0.05394095f, 0.20810422f, 0.22823228f, 
    0.04170172f, -0.28882426f, -0.50693500f, 0.13353677f, 0.08414187f, -0.01897039f, 0.04982080f, 0.03698850f, 
    -0.02459838f, -0.09408043f, -0.39004922f, -0.12011658f, -0.18699469f, -0.00629270f, 0.07861271f, -0.01456045f, 
    -0.07650273f, 0.09308017f, 0.10663043f, -0.13157685f, -0.52413392f, -0.45827952f, -0.18316309f, -0.02335858f, 
    -0.16769530f, 0.01523577f, -0.07050992f, -0.02768822f, -0.13623403f, 0.02335432f, 0.34989130f, -0.12400945f, 
    -0.13416092f, 0.04095881f, 0.07254661f, 0.14306207f, 0.04287346f, -0.08648022f, 0.24047025f, -0.08269633f, 
    0.01163740f, 0.29621652f, -0.04919094f, -0.05675577f, 0.04710729f, 0.06103216f, -0.33100346f, -0.07964204f, 
    0.12842180f, -0.15739176f, -0.18170527f, -0.00083084f, 0.05242978f, 0.06885083f, -0.13941738f, -0.10295668f, 
    -0.25583702f, -0.23129652f, -0.03830443f, -0.06458701f, -0.01560330f, 0.07077455f, 0.01778081f, 0.12848371f, 
    0.80335677f, 0.14055192f, 0.03117379f, -0.10950246f, 0.02180429f, 0.05048286f, 0.02305305f, 0.01215015f, 
    0.05731874f, 0.19023474f, 0.18665338f, -0.01550289f, 0.06221593f, -0.02496595f, 0.04489066f, 0.11174714f, 
    -0.00528724f, -0.01505907f, -0.32969823f, -0.67054039f, 0.20037298f, 0.02999814f, -0.01291596f, -0.20579769f, 
    -0.00564909f, -0.10686299f, 0.04576034f, -0.21013118f, -0.07790057f, 0.05166175f, 0.12290569f, 0.02739491f, 
    -0.04399355f, -0.01833219f, 0.09310355f, 0.03017727f, -0.01846169f, 0.00019251f, -0.06824282f, 0.06808050f, 
    0.04613373f, 0.02650194f, 0.02452465f, -0.02267373f, -0.02689048f, -0.07703175f, -0.07141583f, 0.09607659f, 
    0.01540617f, -0.08923001f, 0.06522376f, -0.04499698f, 0.04707648f, 0.06995830f, 0.28594744f, 0.12534152f, 
    -0.00901576f, -0.09540250f, -0.06179516f, 0.18638596f, -0.02032103f, -0.04606701f, -0.12217849f, 0.05783238f, 
    0.05577967f, -0.07847845f, 0.01050152f, -0.01702913f, 0.01367636f, 0.11915600f, -0.10185363f, -0.03596662f, 
    -0.66475493f, -0.30515629f, 0.17792480f, 0.05237149f, 0.00717062f, -0.07517853f, -0.02246338f, -0.09688971f, 
    0.07381922f, 0.33402357f, -0.26470399f, -0.43530509f, 0.15209731f, 0.01254642f, -0.07733417f, -0.05369408f, 
    -0.01742049f, 0.17922060f, -0.03920862f, -0.04973914f, 0.05260444f, 0.12843879f, 0.08598997f, 0.13100913f, 
    0.07009089f, 0.16276380f, 0.06825619f, -0.02658581f, -0.54278260f, -0.21227819f, -0.02244018f, 0.10301342f, 
    0.03699337f, 0.04853058f, -0.02900314f, -0.18362813f, -0.12315813f, 0.04556117f, -0.09672526f, -0.09301254f, 
    -0.04260201f, -0.11195812f, 0.09226901f, -0.03342396f, 0.02991197f, 0.05520162f, -0.67473245f, -0.04629415f, 
    0.04130103f, 0.02758428f, -0.03372453f, -0.08044836f, -0.03699561f, -0.00924528f, -0.33273190f, -0.59587020f, 
    -0.26978666f, 0.10565307f, 0.06102954f, -0.14064558f, -0.09416599f, -0.10275760f, 0.10565662f, -0.08478348f, 
    0.10354579f, 0.10734977f, -0.07734131f, -0.06616002f, 0.02108359f, 0.12922335f, -0.11090016f, 0.10885466f, 
    -0.04494227f, 0.03881089f, -0.05783539f, 0.02623000f, -0.10010107f, 0.08768092f, -0.05875477f, -0.13131867f, 
    0.00973413f, 0.26506725f, 0.11689749f, -0.19401549f, -0.03309922f, -0.13151343f, -0.06763816f, 0.01784575f, 
    -0.00346839f, 0.06974065f, -0.21464413f, -0.05099548f, 0.05248370f, 0.13430166f, 0.00101598f, 0.11593149f, 
    -0.01641111f, 0.11763956f, 0.06523272f, 0.03431211f, 0.04019181f, -0.04626903f, 0.03434189f, -0.04456922f, 
    0.10987861f, 0.01517085f, -0.02502117f, 0.13039596f, -0.08175179f, 0.04111120f, 0.20511347f, 0.02042570f, 
    0.02455650f, -0.00671164f, 0.04605309f, 0.09518117f, 0.13752750f, 0.67044353f, -0.11891071f, -0.37973377f, 
    0.07975177f, -0.03195265f, 0.21871202f, -0.03571809f, -0.14704101f, 0.00229106f, -0.14140856f, -0.07394207f, 
    -0.15740235f, -0.12694207f, 0.03206863f, 0.08669120f, -0.04438920f, 0.08250184f, 0.10237464f, 0.12451921f, 
    -0.04204530f, -0.09336125f, -0.10602795f, -0.01157867f, -0.21450467f, 0.11774233f, 0.06047800f, 0.11801495f, 
    0.02298944f, -0.23966780f, -0.31969810f, 0.06193479f, 0.14457174f, 0.13555002f, -0.06493770f, -0.05189592f, 
    0.11215463f, -0.04228587f, 0.07270879f, -0.23676360f, -0.04353597f, -0.14456281f, 0.10302289f, -0.02336801f, 
    0.03811100f, 0.03406985f, 0.02256743f, -0.35193840f, -0.22349820f, 0.07962946f, 0.07050422f, -0.01448708f, 
    0.26171368f, -0.05372808f, 0.01954336f, -0.26570779f, 0.20846434f, 0.50162357f, -0.03958010f, -0.11213242f, 
    0.10650489f, -0.12185298f, 0.04644870f, -0.04162078f, -0.30250478f, -0.36592701f, -0.25944880f, 0.03090597f, 
    -0.10048861f, 0.06240144f, 0.01728074f, 0.00349267f, 0.05463940f, 0.38565543f, -0.27572340f, 0.07664710f, 
    0.04197447f, 0.01106771f, 0.03748279f, -0.02495239f, 0.11367959f, -0.07638661f, 0.09307299f, -0.10137535f, 
    -0.59211206f, 0.03302316f, 0.00851034f, -0.07043988f, -0.02270227f, -0.05944282f, -0.07761241f, 0.54030889f, 
    0.05211641f, 0.25452775f, -0.02975375f, 0.07867356f, -0.12495102f, 0.00014985f, 0.00958000f, 0.02415092f, 
    0.28150117f, 0.17770971f, -0.04724861f, -0.00938387f, -0.03604990f, 0.12248629f, -0.03890907f, 0.02872289f, 
    -0.13406864f, -0.40357322f, -0.08261093f, -0.19436562f, -0.11598783f, 0.08635835f, -0.16804269f, -0.02494673f, 
    -0.16349114f, 0.08900306f, -0.35826495f, -0.46773553f, -0.19209494f, 0.10315918f, 0.02451200f, -0.04107828f, 
    -0.03757832f, -0.00604458f, -0.07353120f, 0.07595193f, -0.13378623f, -0.01365586f, 0.07809524f, 0.04276588f, 
    0.13991626f, -0.01104163f, -0.02729029f, 0.13905628f, 0.13276277f, -0.19903374f, 0.11569937f, 0.24602570f, 
    0.07189432f, 0.03281843f, 0.10451886f, 0.07064415f, 0.05913919f, 0.08316654f, -0.11364921f, -0.03305811f, 
    0.01622024f, 0.09772734f, 0.15209971f, 0.03383799f, -0.03735548f, 0.07955634f, 0.08464631f, -0.07291826f, 
    0.31778806f, -0.18005665f, -0.22357997f, 0.23297107f, 0.10325167f, -0.09323595f, 0.00336120f, 0.03092205f, 
    0.26029065f, 0.21566778f, -0.01234529f, -0.09361511f, 0.02597415f, -0.09658575f, -0.09262697f, 0.02559895f, 
    -0.19694579f, -0.12968947f, 0.30244413f, 0.14869387f, -0.01491443f, 0.08113496f, 0.04295139f, -0.17526311f, 
    0.05151686f, -0.16518815f, 0.31962237f, 0.10315401f, 0.02383432f, -0.04897635f, 0.05864201f, -0.05447425f, 
    -0.06657159f, 0.05048221f, -0.03462864f, 0.20007332f, 0.11267743f, 0.14168499f, -0.11065999f, -0.03106081f, 
    -0.04553240f, 0.07336887f, 0.20156960f, 0.00715604f, -0.09218795f, -0.26254520f, 0.05663257f, 0.09047558f, 
    -0.14786707f, 0.00063195f, -0.00765052f, 0.12655230f, -0.19537060f, -0.02350493f, -0.22391091f, -0.20034467f, 
    0.04837149f, -0.14326619f, -0.02187728f, -0.08427315f, -0.01597591f, 0.04573202f, -0.11178897f, 0.02626264f, 
    0.02032360f, -0.01106247f, -0.09282120f, 0.13870987f, 0.01487434f, -0.05450508f, -0.01261536f, -0.39517331f, 
    -0.30082947f, -0.13253614f, 0.09849784f, -0.10609085f, -0.04511692f, -0.04917310f, -0.00669259f, 0.10123077f, 
    0.03863724f, 0.22092912f, -0.11913842f, -0.09956321f, 0.08878999f, -0.13099036f, -0.03792381f, 0.02695877f, 
    0.02151013f, 0.17903484f, 0.13743432f, 0.04998191f, -0.26954857f, -0.24199159f, 0.01715310f, 0.03720944f, 
    0.01148540f, -0.07516816f, 0.05342551f, -0.01524002f, -0.05676664f, -0.05644995f, -0.10754918f, -0.13806032f, 
    -0.14226250f, 0.09225507f, -0.34170806f, 0.00017544f, 0.06848119f, 0.00448462f, -0.07793801f, -0.04500449f, 
    0.01403988f, 0.02584006f, 0.14729820f, 0.16586679f, 0.26050586f, -0.06725468f, -0.05081687f, -0.15560709f, 
    -0.18092617f, -0.01140709f, 0.04009085f, 0.04718433f, 0.11840432f, 0.05190367f, 0.09302704f, -0.02896694f, 
    0.09107059f, 0.02714339f, 0.01302633f, 0.15909149f, 0.05506841f, -0.13267040f, 0.05105845f, 0.08135241f, 
    -0.09987718f, -0.02996643f, -0.04365524f, 0.18623576f, 0.03614181f, 0.05098493f, 0.28047603f, 0.01984337f, 
    -0.30510023f, -0.15301150f, 0.10952310f, 0.11183888f, -0.07206108f, 0.04318471f, 0.01553884f, 0.10448396f, 
    0.04163555f, -0.12208594f, -0.00638516f, -0.05891477f, -0.09648538f, -0.01760216f, -0.05772868f, 0.11357336f, 
    0.11314394f, 0.24894908f, -0.31747776f, 0.03599452f, -0.15876378f, -0.04458084f, 0.03078532f, 0.06458160f, 
    -0.06498989f, -0.11090252f, 0.18006855f, -0.21601641f, -0.16541900f, -0.03118065f, -0.07654124f, 0.27382824f, 
    -0.00059973f, 0.00410818f, -0.10675007f, -0.13727072f, -0.23863994f, -0.11494271f, -0.00069158f, 0.01526425f, 
    0.15648118f, 0.00433812f, 0.14252801f, -0.28795385f, -0.26380277f, 0.27192518f, -0.26850832f, -0.12615447f, 
    -0.06719989f, 0.04986579f, -0.10682216f, -0.21327893f, 0.09882420f, -0.31118810f, -0.21028699f, -0.13843249f, 
    -0.04301365f, 0.08383621f, -0.04355643f, -0.08071319f, 0.09135387f, 0.12262964f, -0.10806099f, 0.00194576f, 
    0.14101566f, 0.00112205f, 0.05452881f, 0.04853447f, 0.12474389f, 0.07364477f, 0.01277671f, -0.08711272f, 
    -0.44237223f, -0.14320460f, -0.01029707f, -0.06006304f, 0.04798826f, -0.02615158f, 0.07861982f, -0.09540811f, 
    -0.07990851f, 0.09285235f, 0.12734626f, -0.07600730f, -0.08977108f, 0.10178098f, 0.01929572f, -0.07208971f, 
    0.27114424f, 0.16527081f, -0.08533709f, 0.13328633f, 0.02045345f, 0.18767150f, -0.10194764f, 0.10794239f, 
    0.03051664f, 0.33845255f, -0.00864226f, -0.09299586f, -0.01505748f, 0.08473731f, 0.02817185f, 0.09178604f, 
    0.05791983f, -0.01848015f, 0.14497638f, 0.23429300f, -0.03473456f, -0.03137689f, -0.09204640f, -0.14853314f, 
    -0.04561051f, 0.02502400f, 0.08343223f, -0.19087949f, -0.15753980f, -0.33115044f, -0.05601454f, -0.06497109f, 
    0.01653854f, 0.11786692f, 0.04157808f, -0.06899831f, -0.04776933f, -0.18097901f, 0.00727130f, -0.05844664f, 
    0.07992945f, -0.05560210f, 0.00592351f, -0.03741191f, 0.16870964f, -0.26480415f, -0.22429024f, 0.03496608f, 
    0.04813966f, -0.10783057f, -0.04360247f, -0.02720589f, -0.02412949f, 0.02769485f, -0.15006861f, -0.14403841f, 
    -0.14878292f, -0.05028186f, -0.11884815f, 0.06882983f, -0.02991862f, 0.03321347f, 0.08580445f, 0.06723861f, 
    -0.01735579f, -0.19870858f, 0.18983321f, -0.16913429f, -0.05165892f, 0.04034691f, -0.03086069f, 0.03232111f, 
    0.13915080f, 0.07232473f, 0.07528926f, -0.12230772f, 0.03029193f, 0.00204067f, -0.00397646f, -0.13188484f, 
    -0.03536092f, 0.07508398f, 0.26606259f, -0.02491041f, -0.01002977f, -0.08915183f, 0.01858410f, -0.01728137f, 
    0.06830279f, 0.05130062f, -0.18809490f, -0.12723632f, 0.28411540f, -0.02983220f, -0.09107033f, -0.05960477f, 
    0.11840031f, -0.04266069f, 0.04874757f, 0.09601019f, 0.23700303f, -0.11392406f, -0.04373788f, -0.08593147f, 
    0.06333499f, 0.02265093f, 0.10519328f, 0.13045377f, -0.21227561f, 0.11817612f, -0.03760155f, -0.05249072f, 
    -0.09224324f, -0.06953929f, -0.02599699f, 0.12880632f, 0.04936517f, -0.04308904f, 0.05698757f, -0.17799446f, 
    0.08786817f, -0.00385345f, -0.11547785f, -0.05435554f, -0.13278775f, 0.10685716f, 0.08483364f, 0.08032390f, 
    0.06755151f, -0.04593731f, -0.21206626f, 0.08668137f, 0.04604364f, -0.03053695f, -0.07874328f, 0.09327900f, 
    -0.00436561f, -0.37061635f, 0.10805251f, 0.04659937f, 0.14526314f, 0.03787860f, 0.06973413f, 0.01882230f, 
    0.00625399f, 0.03814385f, -0.25269723f, -0.01830519f, -0.03345444f, -0.00454951f, 0.11276949f, 0.02438220f, 
    0.24783885f, -0.00462108f, -0.23511566f, 0.24824472f, -0.03287730f, 0.13001494f, 0.13673750f, 0.00925864f, 
    0.07721538f, 0.06112100f, 0.27069443f, -0.02940744f, 0.24988759f, -0.09684072f, -0.03399971f, 0.00727961f, 
    0.03131704f, 0.13997367f, -0.11632483f, 0.54263556f, 0.04614493f, -0.36573970f, 0.06422198f, -0.09148623f, 
    0.13033324f, 0.00890252f, 0.12748785f, 0.06145087f, -0.30780372f, -0.01695878f, 0.26030630f, 0.01693997f, 
    -0.01253138f, -0.00687658f, -0.05602276f, 0.00583727f, -0.06251564f, -0.41198641f, -0.22434221f, -0.16053370f, 
    -0.04999645f, -0.12890247f, 0.07857843f, 0.12441986f, 0.03370389f, -0.01258083f, -0.15033866f, -0.35258046f, 
    -0.20875758f, 0.18189733f, -0.26363087f, -0.12973891f, 0.00113949f, -0.00098713f, 0.05911180f, -0.19352004f, 
    0.28510273f, -0.16518047f, -0.15213156f, 0.10040536f, -0.07527255f, -0.02870925f, -0.11963471f, -0.00379286f, 
    -0.11858895f, -0.13326308f, -0.16770342f, 0.03220608f, 0.14458045f, -0.02594401f, 0.00801363f, 0.14346114f, 
    0.07135938f, -0.09644555f, -0.41164398f, -0.06360711f, -0.08414378f, -0.17824398f, -0.05199809f, 0.00841839f, 
    -0.06687985f, 0.05261018f, 0.15116991f, -0.01072369f, -0.07326689f, 0.03525425f, -0.08067172f, -0.02079030f, 
    0.09269580f, 0.01386213f, 0.02381976f, 0.52026063f, -0.23007320f, -0.25302148f, -0.04195911f, -0.01109311f, 
    0.10777976f, 0.14441654f, 0.04903884f, -0.08779760f, 0.05290291f, -0.13870090f, -0.15839392f, -0.10393847f, 
    -0.08502057f, -0.19988251f, 0.00710117f, -0.00201442f, 0.06476853f, -0.05688796f, -0.08614207f, -0.23941934f, 
    0.00772055f, 0.01071857f, 0.10483064f, -0.01190203f, 0.04728656f, 0.10185701f, 0.33423361f, 0.25520581f, 
    0.11366147f, 0.02878820f, -0.12494890f, -0.06142469f, -0.02368087f, -0.04359275f, -0.03663912f, 0.12906070f, 
    0.03605464f, -0.07328111f, 0.03275966f, -0.02566309f, 0.12684476f, 0.03345144f, -0.09029874f, -0.03807753f, 
    0.08113285f, -0.27632210f, -0.19948736f, -0.09695682f, 0.18136050f, -0.20241080f, -0.04375757f, 0.07350804f, 
    0.08932947f, -0.19946994f, -0.23165381f, -0.14569640f, 0.12655559f, 0.04878091f, 0.04487791f, -0.02195837f, 
    -0.01886962f, -0.13619412f, -0.27211165f, -0.05990917f, 0.12690045f, 0.17246604f, 0.20720865f, -0.26723170f, 
    -0.00871084f, -0.11312565f, -0.11990713f, 0.05942219f, 0.21926698f, 0.15456474f, -0.04858952f, -0.04338406f, 
    -0.01389643f, -0.03159166f, 0.10259355f, -0.02190845f, 0.04375980f, -0.10498825f, 0.08764552f, -0.03237194f, 
    -0.15161429f, -0.02089114f, 0.02247564f, 0.10655579f, 0.03743890f, 0.16532077f, 0.09112015f, -0.06637397f, 
    -0.04913867f, 0.09898572f, -0.01730836f, -0.09512578f, 0.05223361f, 0.13756658f, 0.11361314f, -0.11590368f, 
    -0.06425985f, -0.00234343f, 0.02870467f, 0.09103522f, -0.24742989f, 0.02139344f, -0.10365837f, 0.15852372f, 
    0.26376912f, 0.05524663f, -0.02189530f, -0.01360889f, -0.05124178f, -0.07802074f, 0.04971623f, 0.01851301f, 
    -0.60749602f, -0.23588634f, 0.36963740f, 0.09271277f, -0.00834377f, -0.10176500f, -0.18129487f, -0.00847826f, 
    0.06522964f, 0.12902738f, -0.38767487f, -0.02891883f, 0.04479953f, -0.03224021f, -0.25955540f, -0.12839556f, 
    -0.12022246f, -0.11296047f, 0.22125679f, 0.11796772f, 0.04586788f, 0.00675696f, -0.01609043f, -0.04367923f, 
    0.04842802f, 0.12678587f, 0.05966523f, -0.04117091f, -0.06423751f, -0.09776308f, 0.02281301f, 0.22387031f, 
    -0.09304676f, -0.04424224f, 0.04819518f, 0.07604346f, 0.17958039f, 0.19262561f, 0.34280244f, -0.15614526f, 
    -0.15658280f, -0.09353279f, 0.06299461f, 0.02403472f, 0.06368046f, -0.07202021f, -0.06368308f, 0.01950201f, 
    0.05307268f, 0.13969445f, -0.00407965f, 0.03992035f, -0.01808807f, 0.23812863f, -0.16707668f, -0.03674000f, 
    -0.00345775f, 0.08164734f, -0.03244432f, -0.02200760f, 0.14994311f, -0.17712435f, -0.03985631f, 0.13953362f, 
    0.27345300f, 0.09173857f, -0.08465696f, -0.05424504f, -0.01023570f, -0.01628158f, -0.00246943f, -0.00952777f, 
    0.09313454f, 0.27092755f, 0.00410110f, 0.06813145f, 0.10693713f, 0.03313947f, -0.04433841f, -0.06528355f, 
    -0.03578297f, 0.15594257f, -0.06778104f, -0.34173691f, 0.11032432f, 0.03538393f, 0.14514886f, -0.00201139f, 
    0.08386397f, -0.08040291f, -0.10870272f, 0.01097690f, 0.02041568f, -0.03220575f, 0.16511263f, 0.02278967f, 
    0.16961177f, -0.01809524f, 0.24605481f, -0.39832780f, 0.28558502f, 0.12351233f, -0.20588364f, 0.00156366f, 
    0.12281976f, -0.01285992f, -0.01385328f, 0.17355418f, 0.20210472f, 0.14373139f, 0.04305907f, -0.03680872f, 
    0.00362439f, 0.02949918f, -0.06662024f, -0.04355438f, 0.24302289f, 0.06801414f, -0.05858089f, -0.34637243f, 
    -0.06305221f, 0.13784117f, -0.03786316f, -0.07337013f, -0.14057343f, 0.01687898f, 0.25025627f, 0.08939181f, 
    0.07324446f, -0.05930549f, 0.13747659f, -0.02371179f, -0.06423712f, 0.09210073f, -0.08853734f, -0.02472068f, 
    0.08580197f, -0.14292341f, -0.01932183f, -0.01066698f, 0.08712617f, -0.05465846f, 0.03251921f, 0.10201006f, 
    -0.03698343f, -0.05919785f, 0.02017095f, -0.04405651f, -0.02984443f, -0.00357370f, -0.02563147f, -0.06894458f, 
    -0.08963878f, 0.10465626f, -0.01673732f, -0.02885208f, 0.01837426f, -0.10128041f, -0.02210740f, 0.02823432f, 
    0.10087071f, -0.22255944f, 0.13078320f, 0.06159499f, -0.08444055f, -0.03264458f, 0.01434863f, -0.10739619f, 
    0.04350121f, -0.00197163f, 0.12442642f, -0.57916707f, -0.03701049f, 0.07328814f, 0.11607085f, 0.12914053f, 
    0.26577458f, -0.10602865f, -0.00355961f, 0.02773535f, 0.03037125f, 0.00563682f, 0.05428647f, -0.09870894f, 
    0.10883753f, 0.08361065f, -0.16806915f, 0.03872066f, -0.10402290f, 0.13059454f, 0.02314223f, -0.07504376f, 
    -0.08521743f, 0.06212893f, -0.07881970f, 0.04388487f, -0.09916492f, 0.05771543f, 0.12172162f, 0.18835488f, 
    0.09079690f, 0.04512224f, -0.01655866f, 0.16779727f, 0.06994132f, -0.08130884f, 0.14887071f, -0.26811492f, 
    -0.31131241f, -0.07435475f, 0.09786242f, 0.13314192f, -0.10426004f, -0.28249842f, 0.04164710f, -0.05946171f, 
    0.11419144f, 0.11611879f, 0.25751501f, 0.06277896f, -0.09822183f, 0.02673175f, 0.21023972f, -0.06768448f, 
    -0.00370432f, -0.00821453f, 0.12563519f, 0.03123235f, 0.05669221f, -0.11182791f, 0.13672060f, -0.00840001f, 
    -0.06633861f, -0.09929878f, -0.12261152f, 0.05393054f, -0.14179981f, 0.17135176f, -0.02776922f, -0.12249146f, 
    0.04776134f, 0.04246206f, 0.16289252f, 0.00265772f, -0.14661989f, 0.06755479f, 0.02597548f, -0.17998597f, 
    -0.01745648f, -0.00180400f, -0.00758983f, 0.09742025f, 0.16973808f, 0.02661178f, -0.00196480f, -0.00175195f, 
    -0.00983082f, -0.03829369f, -0.02381931f, -0.06833556f, -0.02294126f, -0.06164687f, -0.06363819f, -0.04854023f, 
    0.04462454f, 0.01646212f, 0.07291074f, -0.00194970f, 0.03357366f, 0.06851003f, -0.07593953f, -0.15413994f, 
    0.13271451f, 0.07317118f, 0.04482077f, 0.03747151f, 0.00250032f, 0.06537591f, 0.15024036f, -0.19496791f, 
    -0.09629946f, -0.00845284f, -0.05548409f, 0.02895499f, 0.16875327f, -0.08009396f, -0.05971271f, -0.09529287f, 
    0.13559072f, 0.01953778f, -0.14592475f, -0.00635395f, -0.04298576f, -0.25755882f, -0.08088836f, 0.01179617f, 
    0.18106413f, -0.12962615f, -0.04079892f, -0.00014425f, -0.01636633f, 0.15437503f, -0.01276439f, 0.13065724f, 
    -0.02098427f, 0.23793609f, -0.09053674f, -0.03733027f, -0.06969389f, -0.05436055f, 0.04327641f, 0.11352278f, 
    0.04310768f, -0.09884846f, -0.12217627f, -0.15388863f, -0.00751647f, -0.14686704f, -0.00252727f, -0.03285114f, 
    -0.17491773f, 0.17851569f, 0.11547183f, 0.00787075f, -0.28315642f, -0.50449783f, -0.29700455f, -0.12053201f, 
    -0.00964827f, 0.06190170f, 0.05293428f, 0.03515639f, -0.05868614f, 0.07298461f, -0.14607176f, -0.31135046f, 
    -0.00199974f, 0.07058768f, 0.08706864f, 0.01977909f, 0.09484265f, 0.06601098f, -0.06068426f, -0.09089846f, 
    0.01635771f, 0.08729873f, 0.06579750f, 0.01641882f, 0.21257935f, 0.17885591f, 0.12676024f, -0.14451534f, 
    -0.07352401f, 0.10944402f, -0.03270576f, 0.00245856f, 0.07026996f, 0.01250507f, 0.06447776f, -0.02044493f, 
    0.04127619f, 0.01328335f, 0.10363030f, 0.04269335f, -0.09438921f, 0.02604845f, 0.02545450f, 0.06558033f, 
    -0.03878394f, 0.00844390f, -0.08675253f, 0.09406924f, 0.14899227f, 0.08947387f, 0.17681341f, 0.02248550f, 
    -0.13729252f, 0.01246505f, -0.13781640f, -0.14498535f, 0.00326041f, -0.02538544f, -0.03696256f, -0.03519424f, 
    -0.08787638f, -0.20400856f, -0.16459206f, 0.12490173f, 0.05308553f, 0.04903465f, 0.07620588f, 0.03421606f, 
    -0.03553308f, 0.06088573f, 0.06472827f, -0.05017201f, -0.06223608f, -0.04591160f, -0.03189625f, 0.09880804f, 
    -0.03936383f, 0.12215997f, -0.00200130f, 0.10988013f, 0.09070855f, -0.08763534f, 0.08930950f, 0.09330719f, 
    0.01328244f, -0.13972108f, 0.05238122f, -0.02627257f, -0.13529474f, 0.07045379f, -0.02453182f, -0.11508101f, 
    -0.09234197f, 0.00295727f, 0.02228514f, -0.02986513f, -0.07487231f, -0.11391203f, 0.05692067f, 0.18447395f, 
    -0.30427697f, -0.08502796f, 0.16411263f, -0.08843754f, -0.04088708f, -0.22150257f, 0.03997154f, -0.27185437f, 
    0.21081887f, -0.03099604f, -0.15038683f, 0.01703958f, -0.13737932f, -0.28791019f, 0.10008339f, 0.00522310f, 
    0.20769179f, -0.03602842f, -0.26857409f, 0.01034582f, 0.02633965f, 0.05220611f, -0.15517847f, -0.01719663f, 
    -0.28258848f, 0.00640248f, -0.23698243f, -0.34795350f, -0.05160750f, 0.08191755f, 0.13244399f, -0.02176804f, 
    0.04479435f, -0.11021914f, 0.03080143f, 0.04209334f, 0.16148084f, -0.09933539f, 0.01282831f, -0.13739561f, 
    -0.01443232f, -0.14693989f, -0.18930873f, -0.09875322f, 0.06359237f, -0.17308068f, 0.05429339f, -0.23133045f, 
    -0.11421552f, -0.03576925f, 0.03345951f, -0.05050886f, 0.16885242f, 0.09953334f, 0.11072358f, -0.04112867f, 
    0.02299648f, 0.03188389f, 0.02902687f, 0.01322387f, 0.02753530f, -0.12012509f, 0.00775315f, -0.06981570f, 
    -0.05914139f, -0.15815882f, -0.06009996f, -0.00693788f, 0.19609019f, -0.03649676f, 0.15755655f, 0.00572070f, 
    0.07541928f, 0.09605701f, 0.05053194f, 0.05978814f, -0.04087508f, 0.02876514f, -0.03765649f, 0.05153931f, 
    -0.03054475f, 0.05236291f, 0.02025410f, -0.04160387f, 0.04515934f, -0.01578826f, 0.03790208f, 0.00896136f, 
    0.00621879f, -0.02093389f, 0.04790108f, -0.05838726f, 0.05162401f, 0.00810743f, -0.06071471f, 0.00934200f, 
    -0.04828264f, -0.06096819f, -0.02496229f, 0.00342533f, 0.01482008f, 0.02523267f, 0.02443314f, -0.05217526f, 
    0.00317367f, 0.00571120f, 0.01181879f, -0.02883359f, 0.00906985f, -0.03756089f, -0.04308388f, -0.04535927f, 
    -0.02232719f, 0.04791283f, -0.04802135f, -0.05878105f, 0.00609873f, 0.05245705f, -0.02908009f, 0.00126394f, 
    -0.06273721f, -0.02072059f, -0.03575759f, 0.01144932f, -0.00958732f, 0.00398335f, 0.03685169f, -0.02996976f, 
    -0.01797822f, 0.03751044f, 0.03380150f, 0.05327151f, -0.00662288f, 0.00659957f, -0.06076591f, 0.02317066f, 
    -0.04021290f, -0.01867213f, -0.03851707f, -0.02557149f, -0.05759534f, 0.02854007f, 0.05417787f, 0.03269130f, 
    -0.01362905f, 0.01121372f, 0.03374573f, 0.02999715f, -0.02358543f, -0.01096952f, -0.05345981f, 0.01373134f, 
    0.02215960f, -0.00450298f, -0.04989953f, -0.00967314f, -0.01960999f, -0.04840855f, -0.05812005f, -0.00678910f, 
    -0.02863433f, -0.04660955f, 0.02238231f, 0.01560603f, -0.06069926f, -0.01477380f, 0.03056998f, -0.05265162f, 
    0.02508607f, 0.04330552f, -0.01305949f, -0.04836475f, -0.02049613f, -0.02131120f, -0.01384881f, -0.00593780f, 
    -0.04900049f, 0.00780186f, 0.00961760f, 0.05615461f, -0.03729568f, -0.01898243f, -0.04798771f, -0.04685778f, 
    0.04902244f, -0.02859942f, 0.03669851f, 0.00771018f, -0.00792964f, 0.05139594f, 0.01168882f, 0.00249543f, 
    0.02340078f, -0.01739352f, -0.01927455f, -0.02298599f, 0.04922918f, -0.02819807f, -0.05561028f, -0.06069642f, 
    0.00460516f, -0.02892620f, -0.01328099f, 0.01164663f, -0.02180158f, 0.01550195f, -0.06324401f, -0.00135471f, 
    -0.02584232f, -0.02745439f, -0.06009842f, 0.04252786f, -0.03413711f, -0.00663042f, -0.03382299f, -0.02919227f, 
    -0.00468086f, -0.01103172f, -0.02381305f, 0.01294451f, 0.01312918f, -0.02292102f, 0.05273180f, 0.04191213f, 
    0.00876757f, 0.05009405f, -0.05650349f, 0.01600498f, 0.00838562f, -0.04435229f, -0.04263811f, -0.00524551f, 
    -0.02526837f, -0.05782973f, -0.02141927f, 0.05072261f, -0.05568435f, 0.00744635f, -0.01888648f, -0.00730105f, 
    -0.02141351f, 0.02560943f, 0.02119183f, 0.02253264f, -0.03609078f, -0.00282057f, -0.00250435f, 0.00447828f, 
    -0.05227927f, 0.01602885f, 0.03623468f, 0.02484966f, 0.04400266f, -0.04129547f, 0.00761039f, -0.01201831f, 
    0.03299662f, -0.01352063f, 0.01993169f, -0.04304653f, -0.00344661f, -0.05699529f, -0.06212119f, -0.01686315f, 
    -0.04686065f, -0.02831378f, -0.05124443f, -0.01272947f, 0.03470639f, -0.03719176f, -0.05212249f, -0.00847304f, 
    0.04177709f, -0.05372064f, 0.00763751f, 0.02759597f, 0.02713655f, -0.02262836f, -0.01500485f, -0.01794199f, 
    -0.01119554f, -0.00825376f, -0.04486787f, -0.05460865f, -0.06265081f, -0.03166481f, -0.02480002f, -0.04605524f, 
    -0.02824679f, 0.00669123f, 0.03526023f, 0.03786812f, -0.02118049f, 0.01458522f, 0.00416130f, 0.04434230f, 
    0.02246881f, 0.02096055f, -0.00871489f, -0.05526413f, 0.02343424f, -0.05515981f, -0.04451647f, -0.04260843f, 
    -0.04461743f, 0.05345663f, 0.05737402f, -0.06151585f, -0.03173727f, 0.03359843f, 0.01444255f, 0.01275781f, 
    -0.05924335f, 0.04991555f, -0.00963470f, -0.00083969f, -0.03425764f, -0.06106473f, 0.04174292f, -0.01946756f, 
    0.01084464f, 0.03852290f, -0.00415098f, -0.03802624f, -0.05138471f, -0.01207545f, -0.03902745f, -0.02311750f, 
    0.00646268f, -0.03048988f, -0.00417909f, 0.02951880f, 0.04217641f, 0.04218076f, 0.02169736f, -0.01439628f, 
    -0.04878091f, 0.03654985f, -0.00284367f, -0.03854167f, -0.02738823f, 0.01774691f, -0.02576973f, -0.04547895f, 
    -0.03747855f, 0.02711486f, -0.04150931f, -0.05073748f, -0.02355441f, 0.02740666f, 0.03149993f, 0.01001631f, 
    0.00289657f, -0.05873813f, 0.02103935f, -0.04192581f, -0.02535185f, 0.01549223f, 0.03923088f, 0.02257042f, 
    0.01322474f, -0.04240670f, 0.04996380f, -0.04756331f, -0.03470892f, 0.04821668f, 0.04095431f, -0.06069957f, 
    -0.01953463f, 0.00034760f, 0.04094380f, -0.03771303f, -0.00426457f, -0.04809782f, -0.04183161f, -0.01478634f, 
    -0.03023681f, -0.04975170f, -0.00509913f, -0.03117415f, 0.02145895f, -0.03697313f, -0.06189910f, -0.01853099f, 
    -0.04943194f, 0.01778169f, -0.06231961f, 0.04049713f, 0.01091113f, 0.00343129f, -0.02690969f, 0.04957111f, 
    -0.04113281f, -0.02584652f, 0.04724466f, -0.02946374f, 0.03242928f, -0.02350849f, -0.04479074f, -0.03429047f, 
    0.00390524f, 0.00116464f, -0.04246374f, -0.01692130f, -0.06132668f, -0.04209329f, 0.04523841f, 0.00897987f, 
    -0.00305503f, -0.03630603f, 0.03074189f, -0.04082291f, -0.04635260f, -0.04424463f, 0.00508508f, -0.04369247f, 
    0.01323223f, -0.05393807f, -0.01212768f, 0.01800732f, -0.02061073f, 0.00395726f, -0.01569085f, -0.05376216f, 
    -0.05456337f, 0.02171984f, 0.03654510f, -0.05509160f, -0.00280913f, 0.01780364f, -0.06057713f, -0.02184581f, 
    -0.04728063f, -0.04213998f, -0.00434279f, 0.00599306f, -0.02074966f, -0.02598483f, 0.00727392f, -0.03195247f, 
    -0.05106495f, 0.01181866f, -0.02147034f, -0.02844712f, -0.05499261f, 0.00387045f, -0.03509707f, -0.01736195f, 
    0.00526875f, -0.05483516f, -0.00978910f, -0.02037448f, 0.04456884f, 0.02230404f, -0.01562527f, -0.01287352f, 
    0.00924067f, 0.01809651f, -0.05899839f, -0.02460769f, 0.01855340f, 0.04228744f, 0.04949962f, -0.02923726f, 
    -0.00601656f, 0.04402994f, -0.02342611f, 0.04557643f, -0.02737467f, 0.01839824f, -0.04525344f, -0.00594846f, 
    -0.03605268f, -0.03350445f, 0.01174660f, -0.01938826f, 0.04819857f, -0.03381599f, -0.05160867f, -0.04150559f, 
    0.03230018f, 0.01148390f, -0.05855712f, 0.04836759f, 0.01821830f, 0.01250107f, 0.01728849f, -0.05316968f, 
    -0.02847341f, -0.02413702f, -0.01424145f, -0.05545807f, -0.00861221f, 0.03628441f, -0.04514550f, -0.04118435f, 
    -0.01195734f, -0.05017804f, -0.06470378f, 0.03197828f, -0.02140082f, -0.03282191f, -0.00349534f, -0.02910442f, 
    0.04068979f, 0.04884528f, 0.05110190f, 0.03096480f, 0.04720206f, -0.04335096f, -0.03155153f, -0.04393485f, 
    -0.06124445f, -0.01022832f, 0.01404335f, -0.02231804f, -0.04425155f, -0.04950028f, -0.03810689f, -0.03384715f, 
    0.01429719f, -0.01190486f, -0.02073828f, -0.04191061f, -0.04297176f, 0.03869329f, -0.03913894f, -0.02884945f, 
    0.00034176f, -0.04163532f, -0.06197754f, -0.03411959f, 0.01471437f, 0.00364893f, -0.04106781f, -0.02918492f, 
    0.02249093f, 0.04236428f, 0.00736674f, 0.02301232f, -0.04573476f, 0.01822631f, 0.00968895f, 0.01533015f, 
    -0.03236662f, 0.01254458f, 0.03884291f, 0.01098680f, -0.04541100f, -0.03002758f, -0.04844404f, 0.04907665f, 
    0.04326178f, 0.04227354f, -0.03200275f, 0.04409530f, 0.00051965f, -0.03463837f, -0.04908217f, 0.04743429f, 
    -0.05681356f, 0.00589163f, 0.01321485f, -0.01979911f, 0.00706003f, -0.04883207f, -0.03009379f, 0.02337291f, 
    -0.01394838f, 0.03832182f, -0.04615336f, 0.00945207f, -0.06241933f, -0.02571551f, -0.06275436f, -0.02221205f, 
    -0.04955898f, 0.03422337f, 0.03299545f, 0.01049532f, -0.03860087f, -0.03432303f, 0.01725815f, 0.00389648f, 
    0.01159515f, -0.05429074f, 0.00822864f, -0.01222663f, -0.03072503f, -0.03785371f, 0.02824920f, -0.01027899f, 
    -0.01683078f, -0.04355215f, 0.02171558f, 0.00565061f, 0.03796994f, -0.05501202f, -0.02057234f, 0.04303315f, 
    0.02574410f, -0.01646270f, 0.00416141f, 0.03695629f, -0.03253695f, -0.04997657f, 0.01296564f, -0.04616810f, 
    -0.00680641f, 0.03894751f, -0.00176099f, 0.04868293f, -0.00110580f, 0.03682444f, 0.02137208f, 0.04692925f, 
    0.04952212f, -0.04617852f, -0.05514870f, -0.01853829f, -0.04951577f, 0.01595272f, 0.05043906f, -0.04696363f, 
    0.00359761f, 0.02326434f, 0.04917659f, 0.00614874f, 0.03198130f, 0.00350880f, 0.02989258f, -0.06263145f, 
    -0.02419051f, -0.00688173f, -0.00948982f, -0.00361147f, 0.04300894f, 0.02698269f, -0.00063489f, -0.03779792f, 
    0.03226350f, 0.03799823f, 0.04011093f, 0.03113030f, -0.00982073f, -0.03546471f, 0.00362442f, -0.04942080f, 
    -0.01819099f, 0.03857570f, -0.03627511f, 0.03512323f, -0.02304589f, 0.04132894f, 0.03430016f, 0.02262975f, 
    -0.05661238f, -0.14048576f, 0.06350356f, -0.23459129f, 0.04394777f, 0.06227249f, 0.00759419f, 0.07393403f, 
    0.14106856f, -0.17804609f, 0.30426717f, -0.14716947f, 0.01613398f, -0.10170038f, 0.02298056f, 0.02283814f, 
    -0.01752633f, -0.08853514f, 0.00474266f, 0.02221317f, 0.18793586f, -0.09903190f, -0.12847027f, -0.07163370f, 
    0.03170936f, 0.09243549f, 0.06882794f, -0.19524209f, -0.25319278f, -0.17977048f, 0.03351077f, -0.01369045f, 
    0.13685177f, -0.04040216f, 0.13874307f, 0.06826556f, -0.00152829f, 0.13010243f, 0.31845319f, -0.05358380f, 
    -0.03018585f, -0.15905491f, 0.01235682f, -0.18184882f, 0.12556747f, 0.04078668f, -0.10364281f, -0.01806815f, 
    0.07169035f, 0.06510147f, -0.05260010f, -0.01039616f, 0.10162067f, -0.01912038f, 0.16131164f, 0.13033915f, 
    -0.30615240f, -0.10778946f, 0.07129470f, -0.03634924f, 0.07408251f, -0.11223101f, 0.07424682f, -0.02201947f, 
    0.03635600f, -0.13888624f, -0.08203887f, -0.08526519f, -0.05789343f, 0.09448595f, -0.12067822f, 0.09248324f, 
    -0.26334679f, 0.01896987f, 0.08716530f, -0.13876550f, -0.08413185f, -0.01262785f, 0.14218023f, 0.15893328f, 
    -0.03460547f, 0.07154348f, 0.06363887f, 0.07429259f, 0.11394514f, 0.10089817f, -0.13835193f, -0.09570251f, 
    0.06858900f, 0.11154671f, 0.03500572f, -0.17169216f, 0.08865371f, 0.06567855f, -0.13353685f, -0.03807489f, 
    -0.01072450f, -0.04439403f, 0.08309057f, 0.00310426f, 0.02473973f, 0.12901753f, -0.16630644f, 0.05190565f, 
    -0.09927353f, 0.10196170f, 0.00934755f, 0.06572974f, 0.09121954f, -0.19185448f, 0.25993654f, 0.10505224f, 
    0.02462880f, -0.20493150f, 0.12374609f, -0.07332766f, 0.00350076f, -0.03822825f, 0.15599260f, 0.29926434f, 
    -0.12431221f, 0.17578122f, -0.14053439f, -0.05252228f, 0.14610371f, -0.15979469f, -0.14659819f, 0.28844121f, 
    0.26808161f, 0.04975061f, -0.03689058f, -0.03235107f, 0.14176390f, 0.07224111f, -0.12688452f, 0.04850516f, 
    0.15181893f, -0.07508258f, -0.14546739f, -0.17762907f, -0.00230775f, 0.10797049f, -0.10474982f, -0.04166327f, 
    0.06409816f, 0.01583545f, 0.34542134f, 0.07488395f, 0.08835806f, -0.08054272f, -0.06909606f, -0.08682761f, 
    0.06488650f, -0.23937154f, 0.32543591f, -0.06404979f, -0.12730338f, -0.11331345f, -0.05940666f, 0.04939128f, 
    -0.00275589f, 0.06500558f, -0.11290379f, -0.05330845f, -0.24229686f, 0.13991313f, 0.00210713f, -0.09963008f, 
    -0.01599657f, -0.04840429f, 0.03441298f, -0.10050885f, -0.16655213f, 0.07955728f, 0.10864357f, -0.10267661f, 
    0.04929847f, 0.08420166f, 0.04214968f, 0.09638060f, -0.10464549f, -0.09155268f, 0.13413756f, 0.11135868f, 
    -0.12694634f, -0.07411481f, -0.07155166f, 0.03079568f, 0.09686226f, -0.13101287f, 0.05728190f, -0.43575698f, 
    0.04256199f, 0.15809816f, 0.22993119f, 0.04027351f, 0.02940783f, -0.15706792f, 0.09001861f, 0.23365857f, 
    -0.02120393f, -0.15082315f, 0.04786165f, 0.05505484f, 0.10270627f, 0.17830372f, -0.08059195f, -0.47669327f, 
    -0.51189673f, 0.05179666f, -0.00057121f, -0.05476313f, -0.20822239f, -0.00745977f, -0.06035272f, 0.11581512f, 
    -0.08634206f, -0.12305182f, 0.06159932f, 0.09833609f, 0.03803942f, 0.15858147f, 0.04266354f, -0.05833776f, 
    0.05077342f, -0.67225534f, 0.13334966f, 0.02538351f, -0.12554081f, 0.02885244f, -0.18307519f, -0.27974391f, 
    -0.13468337f, -0.07132592f, 0.15452005f, -0.00995562f, -0.15498243f, 0.16861100f, -0.11686277f, 0.14571184f, 
    0.15252519f, -0.09736893f, 0.03658164f, -0.60411537f, 0.18889159f, 0.16714187f, 0.14560585f, -0.16804840f, 
    0.05261170f, 0.00392421f, 0.01926190f, 0.18533301f, -0.39667276f, -0.03792046f, 0.18769945f, 0.10122637f, 
    -0.01728306f, 0.04809866f, -0.02424691f, -0.09373158f, -0.09780166f, 0.03481327f, 0.09531947f, 0.04249503f, 
    0.03902548f, 0.17799611f, 0.07823333f, -0.07641555f, 0.02790806f, -0.02684247f, -0.04069847f, -0.10442696f, 
    0.17889091f, -0.14075564f, 0.01903276f, -0.04552365f, 0.15176520f, -0.06370205f, 0.11265092f, 0.15760647f, 
    0.06854817f, 0.23509507f, -0.10322706f, -0.10628301f, -0.01674378f, 0.00145340f, 0.11991081f, 0.05335195f, 
    -0.43720174f, -0.25641721f, -0.18456009f, -0.22074962f, 0.02235401f, 0.04104426f, -0.02887782f, -0.10146693f, 
    0.09468201f, 0.14194959f, 0.14085640f, 0.19034153f, 0.07287912f, -0.14029056f, -0.05656112f, -0.05406444f, 
    0.16528638f, 0.08460265f, 0.19117428f, 0.07294918f, -0.06367365f, -0.05886695f, 0.05776865f, -0.11446335f, 
    -0.03337946f, -0.12247645f, -0.03107015f, 0.08019407f, 0.24546002f, -0.07387584f, 0.05490526f, -0.02542310f, 
    0.09824903f, -0.02638921f, 0.02812447f, -0.10173192f, -0.08743270f, -0.15944090f, -0.07322878f, -0.02260364f, 
    0.04819027f, -0.01939520f, 0.15303780f, 0.00389378f, -0.06129912f, 0.05998885f, -0.06495760f, -0.22089931f, 
    -0.00956833f, 0.13088328f, 0.04673496f, 0.17578599f, 0.02544050f, 0.00869933f, -0.22459178f, -0.03153508f, 
    0.14873782f, -0.07518685f, 0.15520814f, -0.11734245f, 0.05576605f, 0.00340996f, 0.03441072f, 0.12255608f, 
    0.15528907f, 0.23036627f, 0.08213334f, 0.03246777f, 0.09044006f, 0.03979832f, 0.06049262f, -0.04287656f, 
    0.05815160f, -0.21330573f, -0.03803838f, -0.05241276f, 0.12393967f, -0.21984625f, -0.05600330f, -0.10976030f, 
    -0.16626982f, -0.06547772f, 0.09507822f, -0.04537974f, 0.01499176f, -0.21588871f, 0.11315031f, -0.14163126f, 
    -0.08760704f, -0.14245050f, 0.14046390f, 0.00373915f, -0.07799318f, 0.02734663f, -0.02000481f, 0.04394609f, 
    0.13098086f, -0.00218101f, -0.00621765f, -0.05705609f, -0.33952424f, -0.25178775f, -0.01696412f, 0.09454510f, 
    -0.07285035f, 0.17827292f, -0.02334044f, 0.05935170f, -0.16191322f, -0.23594059f, -0.28611028f, 0.11546594f, 
    -0.14668773f, 0.04091304f, 0.08987014f, 0.19582014f, 0.14052790f, -0.21122858f, -0.36194327f, -0.15635195f, 
    -0.08866550f, -0.07783666f, -0.11881549f, 0.06945319f, -0.01636445f, 0.08774790f, -0.22034496f, 0.07771563f, 
    -0.08722157f, 0.09560440f, -0.20873094f, 0.01849723f, -0.09684863f, -0.06290662f, -0.04780549f, 0.11439838f, 
    -0.12297873f, 0.12124697f, 0.16662343f, 0.06430785f, 0.05596963f, 0.13374278f, -0.01459288f, -0.05976989f, 
    0.26016313f, 0.02705660f, 0.06025823f, 0.02675928f, -0.06922137f, -0.08902779f, -0.05111311f, 0.05164434f, 
    -0.03701983f, -0.11977939f, 0.31143534f, 0.19891763f, 0.00864090f, -0.07503124f, 0.02913414f, -0.12670293f, 
    -0.07794808f, -0.11033032f, 0.31511471f, 0.22060697f, -0.05969884f, 0.09158756f, -0.00787742f, 0.01623717f, 
    0.08608003f, 0.10654137f, 0.12278306f, 0.20437050f, -0.01157256f, 0.19554566f, 0.20856632f, -0.07912700f, 
    -0.05682411f, 0.02113259f, -0.01203622f, -0.04811782f, -0.13462946f, -0.14149818f, -0.37523070f, 0.02954122f, 
    0.04536839f, 0.09887440f, 0.08235188f, 0.02121445f, -0.00815928f, -0.42544681f, 0.10004493f, -0.11445281f, 
    0.13609928f, -0.06031478f, -0.00441641f, -0.01269146f, -0.12096056f, -0.11275019f, -0.18275413f, -0.10174156f, 
    -0.36894691f, 0.23077337f, 0.19444230f, 0.18598324f, 0.13398553f, -0.01879336f, 0.10205016f, -0.19362520f, 
    -0.37372264f, 0.14413622f, -0.04203027f, 0.06677907f, -0.01322639f, 0.09458670f, -0.06296731f, 0.17719330f, 
    0.14862819f, 0.02651265f, 0.26493230f, 0.20100008f, 0.00679654f, 0.16066416f, 0.02053328f, 0.00846464f, 
    -0.25591764f, -0.61962134f, -0.30969119f, -0.49725914f, -0.07092120f, -0.04348221f, 0.12952459f, 0.05863314f, 
    -0.02297211f, 0.12398002f, -0.18399265f, -0.38312861f, -0.26459607f, 0.21296401f, -0.16147117f, -0.25008747f, 
    0.07139210f, 0.05572594f, -0.04752084f, 0.20178787f, -0.11502299f, -0.16014661f, -0.25089827f, -0.20318517f, 
    -0.15334821f, 0.01062280f, 0.07643393f, 0.26787159f, -0.06628523f, 0.37744632f, -0.14669701f, 0.12905735f, 
    0.08852915f, 0.16049396f, 0.14690179f, -0.08173096f, -0.19168861f, -0.11349758f, -0.42841104f, -0.09662845f, 
    -0.29841816f, -0.04750447f, -0.10206617f, 0.10531696f, -0.05610725f, 0.00667020f, -0.25389826f, -0.04407841f, 
    -0.05763811f, 0.12122358f, -0.09327004f, 0.19380811f, -0.01903743f, 0.06904075f, 0.10570711f, -0.29546136f, 
    -0.12368606f, 0.01563836f, -0.07337674f, 0.12540682f, -0.04714147f, 0.12676239f, -0.02708003f, 0.05214575f, 
    0.22765055f, 0.05208753f, -0.17287213f, -0.11919561f, -0.00186413f, -0.11618790f, 0.04987425f, -0.05537952f, 
    0.06570695f, 0.09388550f, 0.31350642f, 0.38511032f, -0.08582023f, 0.05062249f, 0.09423207f, 0.07729942f, 
    0.01661442f, 0.01540821f, 0.00139328f, -0.32918009f, 0.00501726f, 0.09650372f, 0.03223620f, -0.08575766f, 
    -0.00976198f, 0.02032684f, -0.01051607f, 0.29505944f, 0.07777251f, -0.07988910f, 0.07454066f, 0.14352567f, 
    -0.03636914f, 0.11643453f, -0.02972337f, -0.02654918f, -0.05441329f, -0.00023822f, -0.02280076f, 0.14085098f, 
    -0.06342996f, 0.01068826f, 0.06041741f, 0.13039970f, -0.00451893f, 0.25604972f, -0.10694538f, 0.05204898f, 
    0.11855690f, 0.11946104f, 0.11169211f, -0.07130942f, -0.01469341f, 0.12552999f, -0.19735973f, -0.17424285f, 
    0.19164923f, -0.00734835f, -0.22900200f, -0.23616768f, -0.03156529f, -0.07384046f, 0.07730079f, -0.06143668f, 
    -0.15553725f, -0.07805409f, 0.01536064f, 0.11609706f, 0.03907062f, 0.02764367f, 0.06994031f, 0.01371674f, 
    -0.29487804f, -0.19055928f, 0.13201705f, 0.05673286f, 0.02620402f, -0.09677519f, -0.00092593f, -0.05249031f, 
    -0.12351961f, -0.03361952f, -0.41748139f, -0.39879763f, -0.14422005f, 0.00553158f, -0.04440558f, -0.10801698f, 
    0.02388514f, 0.04734510f, -0.06290281f, -0.04490755f, 0.05975324f, 0.07181605f, 0.22165976f, 0.07518746f, 
    0.13116769f, 0.17508475f, 0.09102749f, -0.29399472f, -0.28814551f, -0.35138115f, -0.18482690f, -0.06297024f, 
    -0.14670299f, 0.02856425f, 0.03282754f, 0.04066751f, -0.45892030f, -0.23142493f, 0.18738577f, -0.09819084f, 
    -0.14847505f, -0.21440111f, 0.10203170f, -0.08126903f, 0.04103132f, -0.04524104f, -0.35128260f, -0.01406589f, 
    -0.11442948f, -0.04700289f, -0.10438561f, -0.09934479f, 0.11307541f, 0.20289436f, -0.07716069f, -0.17146251f, 
    -0.32257405f, 0.01105375f, 0.00657292f, -0.10898342f, 0.06588265f, -0.09094846f, 0.07812196f, -0.12853470f, 
    -0.09528129f, 0.01378253f, -0.02052654f, 0.03315602f, -0.13093673f, -0.10517701f, 0.06166527f, 0.11472328f, 
    0.13394555f, 0.29143310f, -0.09319469f, -0.06877255f, -0.18762262f, -0.22143865f, 0.13476540f, 0.00766177f, 
    0.11106370f, 0.08659610f, 0.12249777f, 0.22378157f, -0.07456973f, -0.07613565f, -0.08631382f, 0.01383210f, 
    0.08932745f, 0.08849704f, -0.15200648f, -0.23293239f, 0.11557782f, -0.01513207f, -0.06421720f, -0.02513289f, 
    0.11504988f, -0.03571079f, 0.16826972f, -0.04558153f, 0.54690367f, -0.27928558f, -0.17677414f, -0.01696285f, 
    -0.01410856f, -0.05958953f, -0.01453046f, 0.03171443f, -0.09649295f, -0.02536608f, 0.02145953f, 0.16006204f, 
    0.20657972f, 0.03469318f, 0.03614292f, 0.20419946f, 0.16119851f, 0.16262439f, 0.13693660f, -0.03225955f, 
    -0.10079157f, 0.05903777f, 0.10681231f, 0.12811890f, 0.00435404f, 0.02189763f, -0.46994525f, -0.40035078f, 
    -0.35159248f, -0.05239121f, -0.04965683f, 0.04060719f, -0.07801991f, 0.05556230f, 0.06071330f, -0.00059619f, 
    0.05409184f, 0.10949507f, 0.17629406f, -0.14957352f, -0.16738430f, 0.01939275f, -0.00933441f, 0.14145117f, 
    0.18676348f, 0.15693547f, -0.31582111f, -0.03176402f, 0.18280372f, -0.11018956f, 0.08496795f, 0.08742569f, 
    -0.06128083f, -0.17004366f, -0.47957879f, -0.04219608f, 0.07827103f, -0.13469124f, -0.04533094f, 0.01323230f, 
    -0.07484107f, -0.09777928f, -0.19729289f, -0.21256089f, -0.11348286f, -0.10356597f, -0.03431645f, -0.10221965f, 
    0.17173661f, -0.07395888f, -0.04861431f, -0.21546875f, -0.32094672f, 0.12996802f, -0.50419706f, -0.07000825f, 
    -0.08482732f, -0.00032268f, -0.02243357f, 0.09059127f, -0.18786931f, -0.45222738f, -0.40065894f, -0.21862662f, 
    -0.04635879f, -0.03469380f, 0.06506503f, -0.04769043f, -0.15113832f, 0.35647464f, -0.09924599f, -0.15730551f, 
    0.04369129f, 0.02805888f, 0.12447163f, 0.14822668f, 0.03860678f, 0.01737911f, -0.14083233f, -0.07529444f, 
    -0.15110837f, -0.12822078f, 0.03282488f, -0.13897608f, 0.12587528f, 0.00902926f, 0.10336686f, -0.29738703f, 
    0.02033494f, 0.18546060f, 0.04489566f, 0.08867899f, 0.03980539f, 0.03857655f, -0.03320290f, 0.13406876f, 
    -0.06421847f, 0.01911761f, -0.00849502f, 0.00429177f, -0.04437774f, 0.05530243f, -0.06215915f, 0.02026290f, 
    -0.06614956f, 0.00674437f, -0.06463062f, -0.03459402f, -0.01210557f, 0.00461130f, -0.03481044f, -0.03156055f, 
    -0.00251088f, 0.03948527f, 0.01981452f, -0.01817870f, -0.01801033f, 0.04841634f, -0.05441977f, -0.04364576f, 
    -0.04074491f, -0.00468064f, 0.00571891f, -0.04921606f, -0.05169739f, 0.01717358f, -0.01144866f, -0.03341151f, 
    -0.00076946f, 0.03867538f, -0.01773733f, 0.01461222f, 0.03858352f, -0.04257267f, -0.04364917f, 0.00438345f, 
    -0.03410877f, -0.02216334f, -0.06228743f, 0.02964486f, -0.02349674f, 0.03787106f, -0.06478891f, 0.04517215f, 
    0.04398151f, 0.01368122f, -0.02895722f, -0.03473241f, -0.02045870f, -0.01483828f, 0.04732726f, 0.01470764f, 
    0.02366526f, -0.03329710f, 0.02308015f, -0.03903775f, -0.05936409f, -0.00391654f, -0.04332386f, -0.05323211f, 
    -0.01638939f, 0.02137301f, -0.04569503f, -0.04660705f, -0.06367444f, -0.00174557f, 0.04112946f, -0.03271757f, 
    -0.03657705f, 0.00616782f, -0.06799451f, -0.01649810f, -0.03933040f, 0.01903645f, 0.01169389f, 0.05348533f, 
    -0.03864058f, -0.01214806f, -0.01442230f, 0.03197480f, 0.02782880f, 0.00334953f, -0.03178399f, 0.01306768f, 
    -0.04584120f, 0.00093054f, 0.05106357f, -0.01132666f, 0.04457523f, 0.00557579f, -0.00616368f, 0.01411198f, 
    0.05459607f, -0.03735739f, 0.02563970f, -0.04602013f, -0.05230872f, -0.05533399f, -0.05509883f, 0.00695276f, 
    -0.02520944f, 0.02291976f, -0.02888176f, -0.00617608f, -0.03588910f, -0.04328872f, -0.06137259f, 0.01637265f, 
    -0.00439181f, 0.02533804f, -0.05916226f, -0.03748408f, -0.01435415f, 0.00682723f, -0.05493221f, 0.04145020f, 
    0.00422421f, -0.04102974f, -0.02810879f, -0.04554353f, -0.01576134f, 0.03428052f, -0.02489604f, -0.05815047f, 
    0.03388098f, 0.03592081f, 0.02335365f, 0.02667980f, 0.05220791f, 0.01000002f, 0.03609727f, -0.01202407f, 
    0.05120111f, -0.04773782f, -0.00992146f, -0.03839220f, -0.02142124f, 0.03770163f, -0.00375415f, 0.00589183f, 
    -0.01022529f, 0.03367557f, 0.02247498f, 0.01125967f, -0.06063145f, 0.03464208f, 0.02073105f, 0.03909294f, 
    0.05057845f, 0.00205826f, -0.01156875f, 0.03579373f, -0.04041728f, 0.00540945f, 0.04768713f, -0.02722972f, 
    -0.02429417f, -0.06103383f, -0.04401575f, -0.05081983f, -0.03570291f, 0.02223041f, 0.05398835f, -0.04353440f, 
    -0.02338709f, -0.02712866f, -0.00252217f, -0.01944138f, -0.01514706f, 0.01626848f, -0.02106060f, 0.00764249f, 
    0.00697539f, 0.00426847f, 0.00839132f, 0.00111292f, -0.05521892f, 0.03134823f, 0.03884169f, -0.03380377f, 
    0.04898889f, 0.00203685f, -0.05187790f, 0.02999959f, -0.02628456f, -0.03808415f, 0.02999816f, 0.02453444f, 
    -0.02128051f, -0.02578478f, 0.01584833f, 0.01083034f, 0.04688975f, -0.01332704f, 0.05704060f, -0.02602216f, 
    -0.03664256f, 0.05502932f, 0.00669960f, -0.02543278f, -0.01726500f, -0.03760619f, -0.04157100f, 0.05059682f, 
    -0.00780199f, -0.03558521f, -0.02594459f, -0.01491901f, 0.01536691f, -0.05212812f, -0.03995866f, 0.03380356f, 
    0.01460274f, -0.04811521f, -0.00704367f, -0.05401915f, 0.03863895f, 0.02560198f, 0.03752811f, -0.03587070f, 
    -0.05174910f, 0.04450781f, -0.01422983f, -0.05775722f, -0.00816724f, -0.00079358f, -0.04823921f, -0.03290696f, 
    -0.06071950f, -0.03086444f, 0.02807890f, -0.04821366f, 0.06614960f, 0.02101908f, -0.01311483f, 0.01121332f, 
    0.02471194f, 0.05993284f, -0.00095541f, -0.00740997f, 0.00659066f, 0.01477636f, -0.05733797f, -0.01567640f, 
    0.01619647f, 0.00782655f, -0.02372977f, 0.00688337f, -0.05791351f, -0.04533448f, -0.00735915f, 0.03198816f, 
    0.01507905f, -0.01365779f, -0.01847260f, -0.04437916f, 0.03782313f, 0.04893467f, 0.00698924f, -0.01744209f, 
    -0.05010764f, 0.03177671f, 0.01913419f, 0.03185750f, -0.02105340f, 0.00479103f, 0.00975623f, 0.03051571f, 
    0.04479866f, -0.04906559f, 0.02234227f, -0.04054196f, 0.05325555f, 0.04259184f, 0.01967057f, -0.05644764f, 
    -0.01044839f, 0.00278343f, 0.01613539f, -0.03631021f, -0.02338279f, -0.04444739f, -0.03496801f, 0.02946310f, 
    0.06351639f, -0.08808264f, -0.09834902f, -0.16955765f, -0.06794016f, -0.12430593f, 0.02814932f, 0.05775705f, 
    -0.23670195f, 0.06504699f, 0.05227725f, 0.21717690f, 0.05077028f, 0.13067991f, -0.25005707f, 0.06224218f, 
    0.02596464f, 0.01485583f, 0.28081155f, 0.10574406f, 0.04091498f, -0.04938322f, 0.01846984f, -0.18989885f, 
    0.12155975f, -0.02264960f, -0.18330598f, 0.03442550f, 0.08282436f, -0.13385838f, 0.04283643f, 0.03429416f, 
    0.04123132f, -0.01814087f, 0.02020366f, -0.15113404f, -0.08842000f, 0.03390045f, 0.10914832f, -0.05099723f, 
    0.11531755f, 0.06298789f, 0.01647799f, 0.02876786f, 0.02364157f, 0.20460521f, -0.14043684f, 0.04054670f, 
    -0.07459041f, -0.03212320f, 0.28839019f, 0.12945147f, 0.01891254f, -0.01057766f, 0.35783774f, -0.16097137f, 
    0.02991605f, -0.16073224f, 0.07461809f, -0.14050616f, 0.06267466f, 0.00076858f, -0.15093336f, 0.12593184f, 
    -0.03010623f, -0.01470152f, 0.04493419f, -0.07712890f, -0.08347740f, 0.03899389f, 0.23038834f, 0.11726990f, 
    -0.08250588f, -0.06135967f, 0.21591352f, -0.22141051f, 0.08186343f, 0.04095655f, 0.07749476f, 0.09407970f, 
    -0.20718391f, 0.10285590f, 0.20968769f, 0.02143724f, -0.17250575f, 0.00327456f, -0.18065985f, 0.02676154f, 
    0.03242363f, -0.23379783f, 0.00918558f, 0.00768400f, -0.17587106f, 0.19295698f, -0.10382897f, -0.02773683f, 
    0.05870016f, 0.13922700f, 0.10732601f, 0.10880174f, 0.08878323f, 0.10057558f, -0.07017906f, 0.09869508f, 
    -0.12110870f, 0.03540796f, -0.05970450f, 0.05514216f, 0.25672579f, 0.24639800f, 0.13876686f, 0.02525713f, 
    -0.06438352f, -0.02640849f, 0.10117079f, -0.06544324f, 0.07660601f, 0.06245189f, 0.13043138f, 0.09690032f, 
    -0.11843286f, -0.11546752f, 0.03505193f, -0.05037230f, -0.00576938f, 0.03722143f, -0.04019119f, 0.23560417f, 
    0.02973565f, 0.11400538f, 0.05469303f, -0.18722714f, -0.08133423f, -0.16318026f, -0.06603529f, 0.10438941f, 
    -0.10537262f, 0.06696792f, -0.00324255f, -0.07786278f, 0.02842604f, 0.03308325f, 0.06849008f, 0.05243017f, 
    0.20420364f, -0.01957759f, -0.03513376f, -0.19983776f, -0.09833962f, -0.22783512f, 0.06519207f, 0.06036093f, 
    0.08531021f, -0.00283237f, 0.15694302f, 0.11373302f, -0.20163730f, 0.06535188f, -0.02940278f, 0.11397776f, 
    0.13975589f, 0.04866553f, -0.05932226f, 0.02584109f, -0.35171261f, 0.03116283f, -0.20257697f, -0.04153103f, 
    -0.01134209f, 0.09411485f, 0.18404382f, -0.01772955f, -0.02777454f, 0.06949129f, -0.04234723f, -0.17376707f, 
    -0.07734700f, 0.04352898f, 0.09014243f, 0.09469095f, -0.02384418f, -0.03291615f, -0.16105561f, 0.10544872f, 
    0.00495729f, -0.03825182f, -0.06672402f, 0.05460247f, 0.03101725f, -0.09410840f, 0.03254091f, -0.12808874f, 
    -0.12968406f, 0.07865677f, -0.03276835f, 0.07671771f, -0.07353461f, -0.00663959f, -0.29117492f, -0.06276195f, 
    -0.17532487f, -0.01167706f, 0.07707582f, 0.06118784f, 0.16423719f, -0.04796939f, 0.01707220f, -0.12319905f, 
    -0.25144479f, 0.10896704f, 0.01822403f, 0.03549222f, -0.12155192f, 0.01604784f, -0.00598998f, 0.17700695f, 
    -0.22559844f, 0.08712750f, 0.21814314f, -0.03884256f, 0.01166409f, 0.14215243f, 0.14038692f, -0.10745350f, 
    -0.16428332f, -0.27006805f, -0.10390038f, 0.14036240f, -0.08881336f, 0.10132630f, 0.05421589f, -0.02132550f, 
    -0.15455170f, 0.20146935f, -0.05689356f, 0.01142835f, -0.01790854f, 0.01169562f, 0.05244600f, 0.03571847f, 
    0.02282494f, 0.02032115f, 0.11908773f, -0.07040671f, -0.15299311f, 0.12394406f, -0.00842403f, 0.01011466f, 
    -0.04738796f, -0.08123267f, 0.00537409f, 0.15039997f, -0.13089345f, 0.18583022f, -0.13559413f, -0.07764892f, 
    -0.05316988f, 0.14979617f, 0.03109249f, -0.06558333f, -0.30608183f, -0.05709511f, -0.16478622f, -0.03138841f, 
    -0.10428443f, 0.13428949f, 0.05329375f, -0.03902844f, 0.15498762f, 0.06995311f, 0.02037568f, -0.00701940f, 
    0.11919745f, -0.13745442f, -0.00135358f, -0.12413567f, 0.05716042f, -0.05563369f, 0.23806982f, 0.14248729f, 
    0.01107867f, 0.20262259f, -0.09435546f, 0.04640804f, -0.13604748f, 0.01185909f, 0.05491774f, 0.06138688f, 
    -0.45108756f, -0.27516741f, 0.26082861f, -0.10677161f, 0.07198036f, -0.23152849f, 0.03137822f, 0.01370463f, 
    0.04186145f, -0.18023436f, -0.07537854f, -0.27438846f, 0.05643623f, 0.03590273f, 0.13488282f, -0.11594358f, 
    0.09934029f, 0.06529026f, -0.23575833f, 0.02298675f, 0.08683687f, -0.01808878f, -0.04703708f, -0.16031033f, 
    0.10315117f, 0.03191908f, 0.02518133f, 0.35965526f, 0.01808835f, 0.05372991f, 0.09829000f, 0.08966868f, 
    0.04557887f, 0.00353849f, 0.01955285f, 0.04286013f, -0.06479231f, -0.18965028f, 0.29305753f, 0.06754281f, 
    -0.06504756f, 0.09655266f, 0.05283526f, 0.04803863f, 0.00433722f, 0.17807624f, 0.05210508f, 0.09902631f, 
    0.07115061f, 0.01079659f, -0.08022237f, 0.07415030f, 0.14190756f, 0.13412084f, -0.34582120f, -0.18312019f, 
    0.00158592f, 0.01843136f, -0.07514390f, -0.12041507f, 0.15882306f, 0.01268755f, 0.01130961f, -0.12344274f, 
    0.16838083f, 0.01749438f, 0.01856309f, -0.00257732f, -0.22601360f, -0.08364952f, 0.03967554f, -0.05447964f, 
    -0.25752914f, -0.09893167f, 0.05364928f, 0.11650064f, 0.11400640f, -0.10347401f, -0.01868241f, 0.06364429f, 
    -0.13462834f, -0.32505313f, -0.15438388f, -0.03493966f, 0.08617274f, -0.05233366f, -0.03808526f, 0.03147708f, 
    0.03144219f, 0.02772810f, 0.14126647f, 0.03772653f, 0.14499362f, 0.11738859f, -0.08111140f, -0.03545844f, 
    0.02633910f, 0.18153340f, 0.03300811f, -0.31226763f, 0.12888609f, -0.28962579f, -0.06073740f, -0.08780324f, 
    -0.10997457f, 0.02914770f, 0.05142063f, 0.07403187f, -0.12590630f, 0.08727278f, -0.14590439f, -0.17667064f, 
    -0.07582086f, 0.14692448f, 0.07689297f, -0.01051747f, -0.03039525f, -0.05850806f, -0.02343704f, 0.16668057f, 
    -0.15700184f, 0.03290359f, 0.04412377f, 0.07241675f, 0.00935179f, -0.04618492f, 0.01432941f, 0.25118923f, 
    -0.23218316f, 0.00082909f, 0.06134509f, 0.12122424f, 0.05144177f, -0.00034013f, -0.04657998f, 0.17194214f, 
    0.06758034f, 0.03859731f, 0.01508556f, 0.01274772f, 0.03073398f, 0.03422135f, -0.02786047f, -0.10630950f, 
    -0.07049436f, 0.21475400f, 0.21164063f, -0.08345655f, -0.14383657f, 0.02276775f, 0.04573284f, 0.07702173f, 
    0.01809184f, -0.32047483f, 0.12759243f, -0.02480380f, 0.11777440f, -0.11003058f, -0.09288319f, -0.06885522f, 
    0.05221578f, -0.05485297f, -0.04561422f, -0.07689177f, 0.03057309f, 0.06653428f, -0.01232697f, 0.01316695f, 
    0.01397494f, -0.06445099f, 0.12702167f, -0.15756352f, -0.41836295f, 0.07860328f, -0.13630348f, 0.10808934f, 
    0.23855074f, -0.03686082f, -0.04483393f, 0.05580618f, -0.01039028f, 0.12368886f, 0.07766410f, -0.00773003f, 
    -0.04242352f, 0.06459307f, 0.03281874f, 0.05379917f, 0.00123777f, -0.37001744f, 0.01007647f, -0.23642150f, 
    0.13366586f, -0.18354636f, 0.31167141f, 0.10726442f, 0.06793878f, -0.18529651f, -0.00578476f, 0.07046935f, 
    0.27575245f, 0.02246443f, -0.05505650f, -0.06906971f, -0.14163889f, 0.07333957f, -0.01379084f, -0.47799441f, 
    0.04343228f, 0.08673941f, -0.13365839f, 0.03453598f, -0.05510110f, 0.06060158f, 0.13604738f, 0.13670392f, 
    0.28959754f, -0.17721194f, 0.04427219f, -0.09171519f, -0.02401378f, 0.11815508f, 0.10262001f, 0.09841024f, 
    -0.09730567f, -0.61027730f, -0.32323897f, 0.19087510f, 0.24059553f, 0.04456257f, -0.29434779f, -0.03788379f, 
    -0.15034010f, -0.07196891f, 0.32507288f, -0.16027230f, 0.03923860f, -0.13758323f, 0.14072637f, 0.17529374f, 
    -0.04330729f, -0.02620716f, -0.06236693f, -0.38585058f, -0.24655198f, 0.12557498f, -0.06790846f, -0.17114173f, 
    0.00803603f, -0.08089027f, -0.08672506f, 0.14960437f, 0.01031402f, 0.11449452f, -0.27032149f, -0.06239156f, 
    -0.09936138f, -0.12958503f, 0.05805425f, 0.04323314f, 0.00218626f, -0.00582616f, 0.02917992f, 0.10997957f, 
    0.08711702f, 0.04596015f, 0.03018022f, 0.03966571f, -0.03762391f, 0.19772081f, -0.20892055f, 0.00511407f, 
    0.24465437f, -0.19784136f, -0.00575217f, 0.03823390f, 0.06713904f, 0.09503189f, 0.15467392f, -0.07310610f, 
    0.09881631f, 0.31367400f, 0.05691211f, 0.12375163f, 0.01713371f, 0.01889217f, 0.08750697f, 0.03333151f, 
    0.23797032f, 0.02988968f, -0.15163283f, -0.13071114f, 0.02771096f, -0.08968154f, 0.07360303f, 0.22491103f, 
    -0.10748146f, 0.15932696f, -0.00430180f, 0.08978717f, -0.15146630f, -0.23318529f, -0.17973067f, -0.02859890f, 
    -0.00779806f, -0.00053089f, 0.08712393f, 0.13338700f, 0.09442461f, 0.00117106f, 0.10132312f, 0.14770925f, 
    0.09698936f, -0.08053766f, 0.08308671f, -0.24352841f, -0.13676988f, -0.17340174f, -0.22383671f, -0.09020191f, 
    0.03362796f, 0.00760728f, -0.05968803f, -0.03057275f, 0.03872219f, 0.04467411f, 0.16417801f, -0.12936518f, 
    -0.00516408f, -0.09490292f, -0.02356700f, -0.04075184f, -0.04720627f, -0.16631073f, -0.24805772f, -0.02027717f, 
    0.04781741f, -0.05859483f, -0.00142341f, -0.07688399f, -0.05135546f, 0.00352871f, 0.07043760f, 0.02385980f, 
    0.08362061f, 0.06526256f, 0.00652971f, -0.01434669f, -0.04724552f, -0.05866362f, 0.00434371f, 0.07994977f, 
    -0.02574915f, 0.01699028f, 0.06961226f, 0.09784863f, 0.00983289f, -0.10994298f, -0.14413553f, 0.15509801f, 
    0.09184761f, 0.11750781f, -0.09173234f, -0.15399507f, -0.02585315f, 0.16934368f, 0.06638886f, 0.07751545f, 
    0.13298084f, 0.25469637f, 0.39206615f, 0.07768709f, 0.10213207f, 0.05351845f, -0.10873943f, 0.11711270f, 
    0.14518446f, -0.05508920f, -0.14800136f, -0.07050797f, 0.11151318f, 0.05200423f, 0.11310180f, 0.12909751f, 
    -0.02005352f, -0.16657507f, -0.06620071f, 0.19731233f, 0.13343008f, -0.05207296f, -0.01071319f, 0.05004219f, 
    0.10575262f, 0.04155368f, 0.06852114f, 0.02230700f, 0.08146455f, -0.04265602f, -0.10911306f, 0.14213206f, 
    0.03234682f, 0.05978641f, -0.01486452f, -0.17337258f, -0.13665451f, 0.10486510f, -0.08778271f, -0.03833181f, 
    0.10394796f, 0.07455996f, 0.15614058f, 0.18492320f, -0.06458269f, -0.11201873f, 0.05006348f, 0.16305554f, 
    0.11103218f, -0.00605794f, 0.06700204f, 0.11311956f, 0.00638315f, 0.00273248f, 0.02174713f, 0.01069672f, 
    -0.09736854f, -0.01360394f, 0.09965489f, -0.10852431f, 0.01720725f, 0.02163909f, 0.00963927f, 0.14592420f, 
    -0.08040498f, -0.11236955f, 0.09484004f, -0.17216840f, -0.11140042f, -0.19133630f, -0.11751101f, 0.00412904f, 
    0.07234920f, 0.01212379f, 0.04084611f, 0.10641559f, -0.08800060f, -0.02977869f, -0.14771412f, -0.03162447f, 
    -0.00492573f, 0.05487918f, 0.00301456f, -0.01852344f, 0.10455862f, 0.03991056f, 0.00538201f, 0.10708137f, 
    -0.02806141f, -0.04496635f, -0.03259134f, 0.05411487f, -0.06198932f, 0.12794830f, -0.04783846f, -0.23111367f, 
    0.05759865f, 0.07341531f, -0.14124855f, -0.00090373f, -0.19958593f, 0.01277710f, 0.00638572f, -0.01293882f, 
    0.04455151f, -0.00994363f, -0.01872023f, 0.01914707f, -0.05546733f, 0.04301338f, 0.04165761f, 0.14477614f, 
    -0.08991559f, 0.06230035f, -0.12964562f, -0.08120607f, 0.07501982f, -0.06976600f, -0.18791977f, -0.19005218f, 
    0.05225223f, 0.12894788f, -0.02397043f, -0.05799347f, -0.07904261f, 0.04528955f, -0.09922645f, -0.26585877f, 
    -0.43200853f, -0.00281834f, 0.06031269f, 0.02810973f, 0.04716636f, -0.01471669f, -0.27043417f, -0.18077128f, 
    -0.00423002f, -0.00949412f, -0.04524520f, -0.17586569f, -0.04124966f, 0.08720944f, 0.11695043f, 0.16761947f, 
    0.09597416f, -0.64088899f, -0.01910664f, 0.04292935f, 0.13374598f, 0.02699991f, 0.03547581f, 0.00342712f, 
    -0.06559880f, -0.11561102f, -0.01106598f, 0.08294249f, -0.34419519f, 0.11121977f, 0.04091842f, 0.09452359f, 
    -0.12569427f, 0.23348424f, -0.22153249f, 0.21939959f, -0.07209091f, 0.09860001f, -0.00170656f, -0.14021356f, 
    -0.25012392f, -0.02630626f, 0.04903301f, 0.01364765f, -0.02911953f, 0.10234027f, 0.13374068f, -0.02901469f, 
    -0.01733184f, 0.05471941f, -0.01276289f, 0.01725329f, -0.02329536f, 0.03009848f, -0.13876934f, -0.02815048f, 
    -0.11160497f, 0.03706295f, 0.07778857f, 0.04470068f, 0.03440598f, -0.09279388f, 0.12530343f, 0.06782228f, 
    -0.11506593f, -0.01667874f, -0.00454510f, -0.12244383f, 0.06753803f, 0.10147399f, -0.12617223f, 0.32158902f, 
    0.02088362f, 0.06789625f, -0.06500883f, -0.09085360f, -0.03033416f, 0.08193921f, -0.03001576f, 0.12440339f, 
    -0.04594615f, -0.05245792f, 0.04220612f, 0.02199276f, -0.01902969f, -0.04935719f, -0.00270931f, -0.01600659f, 
    -0.00878690f, -0.05704469f, -0.04067068f, -0.05589342f, -0.01750457f, -0.04856687f, -0.03097648f, -0.05566756f, 
    -0.00386033f, -0.04256302f, 0.03817695f, 0.01575284f, -0.00320514f, 0.04843775f, -0.01927971f, 0.00050066f, 
    0.01552663f, -0.02550202f, -0.02347809f, -0.02029434f, -0.00193711f, 0.05044716f, -0.05162198f, -0.06414958f, 
    0.03915620f, 0.02475576f, -0.00882321f, -0.00211384f, -0.02476075f, 0.03337852f, 0.01998633f, 0.04526734f, 
    -0.01188914f, 0.04690654f, -0.03920513f, -0.01215292f, -0.05714709f, 0.01768241f, 0.03836297f, -0.04716337f, 
    -0.01377057f, -0.06320591f, 0.05118363f, -0.03451521f, 0.01450127f, -0.05326945f, -0.04626074f, -0.05694569f, 
    -0.01322504f, -0.02053411f, 0.02262362f, -0.04224746f, -0.02302371f, 0.02756845f, 0.02227554f, 0.04644429f, 
    0.04365552f, 0.04008152f, 0.02306102f, -0.01700840f, -0.05271448f, 0.05285116f, -0.01973297f, -0.05924975f, 
    -0.00113236f, 0.00392132f, 0.00809666f, -0.01523873f, -0.02353083f, 0.00546775f, 0.01023607f, -0.03194850f, 
    -0.01877378f, 0.02912427f, 0.02972700f, -0.04538272f, -0.02609166f, 0.02335396f, 0.05072130f, -0.01975360f, 
    -0.05357344f, -0.02780459f, -0.02806375f, 0.04183112f, -0.03066893f, -0.04668321f, -0.04984673f, -0.00483251f, 
    0.04426150f, -0.02589733f, -0.04465685f, 0.00946588f, 0.00540956f, -0.01789146f, -0.04140555f, 0.05150975f, 
    0.02623595f, -0.02523851f, -0.00038032f, 0.00388880f, -0.02173305f, 0.03375413f, -0.04797222f, -0.06200339f, 
    -0.02247981f, -0.05510995f, -0.01516362f, 0.03087537f, -0.05197960f, -0.03648712f, -0.05778162f, 0.00323195f, 
    0.02863298f, -0.02961007f, -0.05777379f, 0.04980087f, 0.04666404f, -0.02454074f, -0.04704028f, -0.00349907f, 
    -0.04899239f, -0.04382649f, -0.03873757f, -0.00183505f, -0.02462784f, -0.03361822f, -0.05601845f, 0.04590795f, 
    -0.02277636f, -0.05157522f, 0.00681503f, 0.00770254f, 0.02692771f, 0.04957245f, -0.01886703f, 0.01571991f, 
    -0.03563136f, 0.03309279f, -0.04292738f, -0.02166218f, 0.03332024f, 0.02976349f, 0.03647757f, 0.00722962f, 
    0.01366783f, 0.04280061f, 0.02761122f, 0.02846661f, -0.00422037f, -0.03934762f, -0.00453908f, -0.03691301f, 
    -0.01016605f, 0.05027764f, -0.03215926f, 0.01395773f, 0.05229155f, 0.01288296f, -0.04611599f, -0.05193505f, 
    -0.02444013f, 0.02493446f, -0.06139186f, -0.05518190f, 0.04346018f, -0.02622577f, -0.02175464f, -0.06139459f, 
    -0.04780708f, -0.05262505f, -0.00589310f, -0.05806493f, -0.05481267f, 0.00893637f, 0.02768379f, 0.02951035f, 
    -0.06027729f, -0.03918524f, 0.03805414f, 0.01785728f, -0.00940524f, -0.02374847f, -0.03554986f, 0.04613595f, 
    0.04911021f, -0.03555348f, 0.02049445f, 0.02782598f, 0.02349170f, -0.04913923f, -0.01748609f, -0.06181148f, 
    0.02080360f, 0.02441534f, 0.04648503f, 0.01524496f, 0.01852317f, 0.05197844f, -0.00794458f, -0.01159901f, 
    -0.03363898f, -0.00229966f, -0.02178193f, -0.01805781f, -0.03901267f, 0.03332832f, -0.05473208f, -0.05555357f, 
    -0.06481549f, -0.04944748f, 0.03272449f, -0.03363746f, 0.04562477f, 0.02260405f, 0.04136669f, 0.01508583f, 
    -0.02473383f, -0.03065925f, -0.00305114f, -0.02160622f, 0.01730806f, 0.00292240f, -0.03448968f, -0.00481143f, 
    0.01314818f, -0.04878864f, 0.00860889f, -0.02540189f, -0.01473078f, 0.03907309f, -0.00083208f, 0.01265272f, 
    -0.01178773f, -0.03279862f, 0.05302971f, -0.02402974f, -0.01704772f, -0.01994459f, 0.01930112f, 0.03000218f, 
    -0.06054453f, -0.01641980f, 0.02731962f, 0.04619499f, -0.00416341f, 0.00573379f, -0.00608389f, -0.00955636f, 
    0.04646317f, 0.00520372f, -0.05106754f, -0.03552305f, 0.04313163f, -0.06168546f, -0.05328910f, -0.05418645f, 
    0.01078607f, -0.01723635f, 0.01438306f, 0.03098232f, -0.00970440f, -0.01011886f, 0.00189916f, -0.05819775f, 
    -0.05052556f, -0.03632256f, 0.05013124f, 0.02353647f, -0.04668262f, -0.05012419f, -0.03740466f, -0.04792404f, 
    0.04968446f, -0.02151699f, -0.03536866f, 0.03814582f, -0.01230467f, -0.06279749f, 0.02020350f, 0.03654660f, 
    0.31816757f, 0.04979477f, 0.12157199f, -0.10858524f, 0.05104452f, 0.18652023f, 0.11495999f, 0.07853364f, 
    0.08164493f, 0.23433700f, -0.05674458f, -0.04043891f, 0.12115087f, 0.02901477f, 0.12748863f, 0.05475086f, 
    -0.01232527f, -0.05424247f, 0.04921857f, 0.26832098f, 0.05126727f, -0.22188132f, -0.01741269f, -0.11195611f, 
    -0.07830738f, 0.00534543f, 0.10957119f, -0.04507309f, -0.23422657f, -0.33825779f, -0.08739181f, -0.03023325f, 
    0.05700343f, 0.00762285f, 0.07219712f, 0.03786013f, -0.11773608f, -0.09983112f, 0.15157655f, -0.02095069f, 
    -0.01176387f, -0.03426399f, -0.00453614f, 0.05787067f, 0.14579053f, -0.02731676f, -0.28615576f, -0.28245011f, 
    -0.00847794f, -0.02955664f, -0.10936228f, -0.06913891f, 0.11997822f, -0.02509489f, -0.29334173f, -0.42408615f, 
    -0.22435683f, -0.19522840f, -0.01708011f, 0.11395601f, -0.10236038f, 0.19331317f, 0.01371513f, 0.04022598f, 
    -0.38237843f, -0.28521451f, -0.04842649f, -0.12035624f, -0.26368764f, 0.07592702f, -0.01591851f, 0.08201151f, 
    -0.09937788f, 0.16747309f, 0.05148996f, -0.15615541f, -0.02681441f, -0.09831721f, -0.11623952f, 0.04871700f, 
    -0.02564045f, -0.09420622f, 0.09995861f, -0.01258430f, -0.05675846f, 0.08793536f, 0.11228276f, -0.06958904f, 
    0.12245800f, 0.05684971f, -0.10471575f, 0.13006128f, 0.19171882f, 0.07053231f, -0.13008402f, 0.01830061f, 
    0.14033400f, -0.05387487f, -0.05604153f, 0.06620216f, 0.20111804f, -0.04647051f, -0.26851061f, 0.01233604f, 
    -0.06115681f, -0.00776946f, 0.10230634f, -0.08092833f, -0.34156865f, 0.01138633f, -0.07531425f, 0.03350752f, 
    0.03777367f, -0.06287776f, 0.02576506f, 0.03590059f, 0.06880020f, -0.06253249f, 0.07617725f, -0.13744801f, 
    -0.06545053f, 0.11514271f, -0.14084159f, -0.07224973f, 0.10702028f, 0.05412523f, -0.04557555f, 0.15382518f, 
    0.10701491f, -0.02988843f, -0.16952114f, -0.04718025f, 0.07819919f, -0.03139759f, 0.05736536f, -0.13341442f, 
    -0.13588172f, -0.31997699f, -0.03570999f, 0.06728752f, 0.03495273f, 0.02206015f, -0.00557210f, 0.10997608f, 
    -0.25456151f, -0.19767927f, -0.28082383f, -0.24009427f, -0.10678197f, -0.01848714f, 0.09159406f, 0.01938402f, 
    0.02366452f, -0.58908439f, -0.48207486f, 0.14476673f, 0.07856061f, 0.05223216f, -0.00046214f, 0.02558197f, 
    0.04579778f, 0.03506508f, 0.29722908f, 0.12111957f, 0.15396762f, 0.09035268f, -0.00698472f, -0.11682910f, 
    0.18038337f, 0.10062932f, -0.05715118f, 0.68956012f, -0.13735814f, -0.26360279f, -0.02997709f, 0.02356590f, 
    -0.02883571f, -0.01223772f, -0.06861416f, 0.04420967f, -0.06057806f, 0.12091194f, 0.18650335f, 0.00466162f, 
    -0.05340829f, 0.00456598f, 0.11498339f, 0.03639837f, 0.00902484f, -0.58887583f, -0.22181094f, -0.18060973f, 
    -0.05383086f, 0.05642409f, 0.20655319f, 0.00219368f, 0.13932315f, -0.03203076f, -0.12284305f, -0.22826444f, 
    -0.06080749f, -0.11874430f, 0.00196839f, -0.05769771f, -0.06821249f, 0.06686368f, -0.07319009f, -0.24154899f, 
    -0.21131139f, -0.19284877f, 0.01693440f, -0.13331608f, -0.12091690f, 0.04505797f, -0.07476203f, -0.14673491f, 
    -0.01320869f, -0.04928569f, -0.12417750f, -0.07276668f, 0.17983894f, 0.09885360f, -0.01056816f, -0.01287858f, 
    0.13941777f, -0.47876617f, -0.48349014f, 0.08913487f, -0.06414941f, 0.00191254f, 0.03918377f, -0.09289486f, 
    0.16753003f, -0.12653364f, 0.28741398f, -0.04440065f, 0.03215532f, -0.01798557f, -0.03511514f, -0.06158904f, 
    -0.02162939f, -0.05667236f, 0.04947373f, 0.17882401f, -0.17189023f, 0.00598326f, 0.14936908f, -0.06879510f, 
    0.04463523f, 0.14062284f, 0.17066881f, 0.04845549f, 0.09071567f, -0.17663644f, -0.10550144f, -0.17788984f, 
    0.02571354f, -0.12966083f, -0.08487839f, -0.05950145f, 0.05393500f, 0.13935553f, 0.18919691f, -0.23194453f, 
    -0.03489008f, 0.05633110f, 0.05643319f, 0.02010083f, 0.14792196f, -0.07187421f, 0.05058772f, 0.12991919f, 
    0.04881497f, -0.04373236f, -0.03971119f, 0.08587256f, 0.05298212f, -0.02497449f, -0.02678130f, 0.09060755f, 
    0.05999610f, 0.02667735f, -0.18559143f, -0.00151703f, 0.21010342f, -0.00073478f, -0.03883248f, 0.06662084f, 
    -0.06085214f, 0.03470099f, 0.00403935f, 0.00022295f, 0.00557039f, 0.02945504f, -0.03950375f, -0.03711385f, 
    -0.05205871f, -0.03094483f, 0.00513644f, -0.01883399f, 0.02096325f, -0.05931970f, 0.00955652f, 0.03327985f, 
    -0.02046258f, 0.01656203f, -0.06062455f, -0.03285235f, -0.03707150f, -0.04406843f, -0.02302952f, -0.04648220f, 
    0.02207708f, -0.02296888f, -0.01284137f, 0.04666089f, 0.04588915f, -0.01880031f, -0.01261340f, 0.03483999f, 
    -0.03336596f, -0.03618866f, -0.04177936f, 0.04327608f, -0.06556835f, 0.00598253f, 0.00531784f, -0.00875041f, 
    -0.00144908f, -0.03086805f, -0.03503868f, 0.04170985f, -0.04836500f, 0.03650979f, -0.04653830f, 0.04033327f, 
    0.03164602f, -0.04506894f, 0.01818841f, -0.04574389f, -0.04207694f, 0.00091749f, 0.04721801f, -0.03123673f, 
    -0.03853526f, -0.03341540f, 0.03278869f, -0.00431455f, 0.01981177f, -0.04498629f, 0.04508321f, -0.01941107f, 
    -0.05740049f, -0.04636019f, -0.06343585f, 0.00917386f, -0.03444932f, 0.01891622f, 0.00945120f, 0.01165738f, 
    0.05113393f, 0.01761969f, -0.06448715f, 0.01059049f, -0.02198440f, -0.00905383f, -0.06333395f, -0.03033402f, 
    0.03674974f, 0.04211820f, -0.06044027f, -0.03003353f, 0.03009319f, -0.00683734f, -0.00701066f, 0.00528342f, 
    -0.03764751f, -0.03873416f, -0.05278346f, -0.02248088f, -0.04311884f, 0.02113703f, 0.03288004f, 0.01294487f, 
    0.04284104f, 0.00157247f, -0.00346671f, -0.02089369f, -0.05037112f, -0.01700669f, 0.01728807f, -0.03573109f, 
    0.03729981f, 0.00623738f, 0.02992839f, -0.00681457f, -0.06506401f, -0.01725551f, -0.02750100f, -0.02879117f, 
    -0.05848101f, -0.06588631f, 0.02711180f, -0.00885631f, -0.05071957f, -0.02715275f, 0.00990176f, 0.01702933f, 
    -0.04118105f, 0.01242428f, -0.06594886f, 0.01688110f, 0.04345028f, -0.00099019f, -0.01050495f, 0.03585919f, 
    -0.01209734f, -0.00912457f, -0.00014815f, 0.02861607f, -0.01640174f, 0.01126899f, -0.03854004f, -0.00889465f, 
    0.04059117f, -0.00841335f, -0.04750869f, 0.04045688f, -0.05314804f, -0.05583201f, 0.02639222f, 0.02085433f, 
    -0.01942652f, 0.02985680f, -0.06043096f, 0.00685156f, 0.03589680f, -0.03701912f, 0.02664488f, 0.02874487f, 
    0.00726893f, -0.05787916f, -0.05676217f, -0.05708067f, 0.00597445f, 0.00917956f, -0.03328548f, -0.02813061f, 
    -0.06400768f, -0.04156521f, 0.01880975f, -0.01976755f, 0.00739889f, -0.03499519f, 0.02972114f, 0.01449079f, 
    0.01154958f, -0.06683316f, -0.01667765f, -0.02848577f, -0.04809954f, 0.00252765f, 0.02027001f, 0.00629300f, 
    -0.01198270f, -0.05517478f, -0.01084806f, -0.06062865f, 0.02054218f, 0.03607859f, -0.06716137f, -0.05648550f, 
    -0.02265977f, -0.01738012f, -0.04108842f, 0.04586728f, -0.05284241f, -0.00720597f, -0.04778962f, 0.00262519f, 
    0.02465294f, 0.00107205f, -0.04810463f, -0.05805201f, -0.05212571f, -0.04151629f, -0.03955489f, -0.02028659f, 
    -0.04646247f, -0.01867610f, -0.02401234f, 0.01693694f, 0.04490311f, -0.05302768f, -0.02200623f, 0.02372167f, 
    -0.00038115f, -0.00137041f, 0.02648778f, 0.02804564f, -0.05373123f, -0.00351603f, -0.00929774f, -0.06590565f, 
    0.04301115f, -0.05383238f, -0.02409306f, 0.03631188f, 0.01604300f, -0.05279952f, -0.05050410f, -0.03262916f, 
    -0.04979693f, 0.03745201f, -0.03114862f, -0.05783627f, -0.02149685f, 0.03519816f, -0.01074246f, -0.01072006f, 
    -0.05047528f, -0.05615786f, -0.00664497f, -0.06056185f, -0.01382407f, 0.03204073f, -0.04716345f, 0.04657761f, 
    0.01750628f, -0.06568595f, 0.03559805f, -0.03503190f, -0.00142129f, -0.03534659f, -0.05322723f, 0.03058651f, 
    0.02838810f, -0.03091998f, -0.01396401f, 0.04392461f, 0.04625582f, -0.03492962f, 0.03342354f, -0.01408354f, 
    0.01629165f, 0.00067359f, 0.02647755f, -0.02464810f, 0.03682652f, -0.02080141f, 0.04167407f, 0.00707405f, 
    0.04467676f, -0.03352157f, 0.01880937f, 0.00693548f, -0.00251933f, 0.04258369f, -0.05564460f, -0.01653288f, 
    0.02627261f, 0.00286483f, -0.02204837f, -0.01037476f, -0.00846820f, -0.00329286f, 0.04390104f, -0.05635393f, 
    0.00242172f, 0.00962904f, -0.01226720f, 0.02241824f, 0.02201021f, 0.00203007f, -0.02447485f, 0.00788532f, 
    -0.03905980f, 0.22085364f, -0.00696929f, 0.03276291f, -0.14816464f, 0.03559120f, -0.06391823f, -0.11058054f, 
    -0.14008421f, 0.00521032f, 0.08342779f, 0.05132928f, -0.00353840f, 0.01792316f, -0.09928475f, -0.13577363f, 
    -0.02249893f, -0.03012554f, -0.00291097f, 0.15686189f, -0.03373498f, -0.14737844f, 0.05192678f, 0.05953565f, 
    0.11883633f, 0.02812023f, 0.03771751f, -0.06202613f, -0.02325516f, 0.22119568f, 0.06982326f, 0.06839044f, 
    0.04026156f, 0.21527514f, 0.04916935f, 0.07841855f, 0.11049043f, -0.02639186f, 0.06397745f, 0.00984441f, 
    0.07201345f, 0.04172086f, 0.08051800f, 0.05022283f, 0.07913578f, -0.13994737f, -0.07329457f, 0.05753483f, 
    0.07056943f, 0.01194851f, 0.05879698f, 0.04489375f, 0.06521743f, 0.00017854f, -0.09770498f, 0.06912756f, 
    -0.03674521f, 0.21794474f, -0.02600837f, 0.04034580f, 0.03303912f, 0.06754363f, 0.14501041f, -0.08946346f, 
    -0.26053935f, -0.08454758f, 0.05801962f, 0.16163379f, 0.03039638f, 0.01972253f, -0.07561129f, -0.20880215f, 
    0.06591713f, 0.02559693f, 0.04962384f, -0.09024761f, 0.11733115f, -0.10498566f, -0.01702628f, 0.15778902f, 
    0.12126756f, 0.08169461f, 0.19421910f, 0.04761260f, 0.04212329f, 0.06843230f, -0.02931125f, 0.00724535f, 
    0.05599166f, 0.15520675f, -0.00806464f, -0.17329319f, 0.03471021f, -0.09657340f, 0.00782101f, 0.01460327f, 
    -0.15036525f, -0.09273889f, -0.18312936f, -0.20644724f, 0.16574402f, -0.13469826f, 0.02680021f, -0.14521834f, 
    0.16549408f, 0.04876997f, 0.13085826f, -0.13889869f, 0.03804467f, -0.22306643f, 0.10623620f, -0.03993292f, 
    -0.05869740f, -0.02165302f, -0.19156723f, -0.23740670f, -0.31370175f, 0.15030293f, 0.21997428f, -0.00943651f, 
    -0.00708424f, 0.08995805f, -0.02295307f, 0.13304737f, 0.00814930f, -0.14285724f, 0.02623990f, 0.01212756f, 
    0.14796263f, -0.08547656f, 0.12306160f, -0.02168506f, 0.09509697f, 0.00311592f, 0.03662720f, -0.05280217f, 
    -0.06167871f, -0.12201078f, 0.10851301f, 0.17027672f, 0.06816867f, -0.02222452f, -0.01835617f, -0.01810153f, 
    0.11399361f, -0.07006116f, -0.07952621f, 0.12374234f, 0.15156031f, 0.05500469f, -0.06870212f, -0.00769885f, 
    -0.01666932f, -0.03832257f, -0.08387431f, 0.11330929f, 0.13726909f, 0.06012034f, 0.04510971f, 0.03406150f, 
    -0.01546672f, -0.00748001f, -0.00692207f, -0.13058220f, -0.10749592f, -0.12736876f, -0.03922137f, 0.09137551f, 
    -0.25514969f, -0.19004607f, -0.16429122f, -0.08113521f, 0.14513275f, 0.03250600f, 0.03238913f, 0.11617259f, 
    -0.16302420f, 0.00414707f, -0.03963098f, 0.26779357f, 0.02112500f, -0.02949895f, 0.17551893f, 0.02245298f, 
    0.08918399f, -0.03061020f, -0.02806976f, 0.06461795f, -0.07012710f, 0.15276812f, 0.09178777f, 0.29144755f, 
    0.09173645f, -0.22576609f, -0.09286641f, 0.14617620f, 0.07543234f, -0.08978018f, -0.20320141f, -0.35805246f, 
    -0.05075247f, 0.02634351f, 0.03997298f, -0.00936416f, -0.09402026f, -0.06102457f, -0.03960919f, -0.06977369f, 
    -0.12083145f, 0.13215055f, 0.06734326f, -0.04578944f, 0.00519358f, -0.14011474f, -0.07578310f, -0.21087210f, 
    0.06293686f, -0.07918727f, 0.02557640f, 0.00017205f, 0.07300262f, -0.17297573f, 0.10422042f, 0.14812915f, 
    0.20565489f, 0.29688707f, -0.16871980f, 0.35651430f, 0.15208650f, 0.08286382f, -0.15245818f, -0.03845679f, 
    0.03492590f, 0.01225332f, -0.18137544f, 0.10197429f, -0.06712893f, 0.13558401f, -0.08074857f, 0.02422400f, 
    -0.18864207f, 0.00023899f, -0.18162218f, 0.20718884f, -0.23619184f, 0.04810170f, 0.07409406f, 0.03944143f, 
    -0.01532828f, -0.07108989f, -0.32120231f, -0.09212895f, 0.03673249f, -0.08792778f, 0.10192958f, 0.13509792f, 
    0.00300849f, 0.13224714f, -0.02465486f, 0.03464982f, 0.13403711f, 0.11405794f, 0.17422417f, 0.03691863f, 
    -0.01670474f, 0.06010622f, 0.03007545f, 0.02084412f, 0.13925013f, -0.13928169f, -0.04945274f, -0.01980142f, 
    -0.04594892f, -0.02245043f, 0.00303303f, -0.01845453f, -0.01283438f, 0.05282188f, -0.09571341f, 0.16007754f, 
    0.10466245f, 0.11592609f, -0.05645244f, 0.05792101f, -0.07612123f, 0.15142243f, -0.00148480f, 0.06937443f, 
    -0.16329695f, -0.10011637f, -0.07706220f, 0.04824322f, -0.01862977f, 0.02546810f, 0.08029975f, -0.04496769f, 
    0.07580175f, -0.12808356f, -0.07607652f, 0.04157837f, 0.02275948f, 0.10228743f, -0.11231604f, -0.12100719f, 
    -0.06928274f, 0.06891365f, -0.34513062f, -0.14742708f, -0.12403237f, -0.16036771f, 0.02157166f, -0.36731192f, 
    0.08949925f, 0.03628051f, -0.01666477f, 0.45368895f, 0.13558191f, 0.17451684f, -0.01734797f, -0.09383313f, 
    0.01307329f, 0.10018612f, 0.08813081f, 0.00222257f, -0.02436145f, -0.00381125f, 0.06962837f, -0.05440798f, 
    -0.04421218f, 0.02917879f, 0.01939732f, 0.05220956f, 0.14769104f, 0.38769701f, 0.11986323f, 0.07487687f, 
    -0.05056396f, -0.04396450f, 0.01875187f, 0.00394968f, 0.11752573f, 0.15590514f, -0.15801248f, -0.04270502f, 
    -0.12077158f, -0.05660022f, -0.01125668f, 0.11276480f, 0.05853262f, 0.16707876f, 0.08646362f, 0.07364976f, 
    0.05807215f, -0.03062465f, -0.13979957f, 0.06099967f, -0.09638468f, -0.04480888f, 0.07146784f, 0.05158856f, 
    -0.37959808f, -0.26194903f, 0.12594265f, -0.24018027f, 0.06664426f, -0.18965955f, 0.06847855f, 0.03055263f, 
    0.10693590f, -0.14733742f, -0.15838771f, -0.05419831f, -0.08714133f, -0.05163746f, -0.03578098f, -0.05663989f, 
    0.10420654f, 0.04432485f, 0.15200993f, 0.16956566f, 0.02042835f, 0.04996033f, -0.00982170f, -0.04655896f, 
    -0.07902454f, 0.08098412f, 0.16265847f, 0.00255801f, -0.23422278f, -0.41147485f, -0.24344735f, -0.02165217f, 
    -0.18731099f, 0.05445177f, -0.04017986f, -0.01982435f, 0.07782831f, 0.24586433f, -0.15182117f, -0.16070127f, 
    -0.12716642f, -0.03134253f, 0.12147463f, 0.03275461f, -0.02768914f, -0.27267775f, 0.01387823f, -0.11510219f, 
    -0.14690280f, -0.08177999f, -0.13784014f, -0.00920411f, -0.11662547f, 0.07120187f, -0.04341520f, -0.02753529f, 
    -0.08735853f, 0.06375254f, 0.01629655f, -0.06818069f, 0.06593514f, 0.01843919f, 0.04773281f, 0.22556889f, 
    0.10627191f, 0.07769999f, -0.24364038f, 0.10757785f, 0.16492066f, -0.03834056f, 0.02023076f, -0.05211672f, 
    -0.02341186f, 0.08473175f, 0.07002843f, -0.03731089f, -0.01342847f, -0.00105774f, -0.02702726f, 0.13830888f, 
    0.13435850f, -0.14638768f, -0.02303776f, -0.00870118f, -0.01369308f, 0.01681477f, 0.07731110f, -0.07629950f, 
    -0.06973782f, 0.15576501f, -0.13820553f, -0.06324992f, -0.03892883f, 0.00758053f, 0.08270754f, -0.13109234f, 
    0.05815670f, -0.04095221f, 0.11951952f, -0.10603082f, -0.01896217f, -0.11984401f, -0.08615711f, 0.08115920f, 
    0.03967357f, 0.01529717f, -0.01157219f, 0.01548145f, 0.19307542f, 0.12563676f, 0.02774908f, 0.02675816f, 
    -0.10431527f, 0.03175455f, 0.11727987f, -0.03435694f, 0.06051951f, -0.17390352f, 0.04096315f, 0.00183037f, 
    0.01721464f, 0.12993863f, 0.06439504f, 0.09686919f, -0.05958411f, -0.07724422f, 0.41400447f, 0.13819213f, 
    0.14349107f, -0.02335358f, 0.07632686f, 0.07624301f, -0.19200237f, 0.06168733f, 0.08065093f, 0.00084851f, 
    0.25837484f, -0.34847745f, -0.08548501f, -0.02271476f, -0.05064775f, -0.05888515f, 0.06370601f, 0.19204336f, 
    0.18301348f, 0.11556755f, -0.13487914f, -0.04403283f, 0.09248003f, 0.06243129f, 0.02318534f, 0.01644486f, 
    -0.05248797f, 0.04326637f, -0.20454890f, 0.08528327f, -0.07393770f, 0.05792205f, -0.03233571f, 0.08549894f, 
    -0.10208093f, 0.00735141f, -0.01277827f, -0.15307473f, -0.13051853f, -0.05123302f, -0.02093528f, -0.11903597f, 
    0.02003210f, -0.15214118f, 0.01453198f, -0.15673195f, 0.01603713f, 0.19120228f, -0.33671939f, 0.10753959f, 
    -0.21681505f, 0.08897831f, -0.17050253f, -0.08177798f, 0.47761536f, 0.01397467f, -0.06951489f, 0.06794446f, 
    -0.06296302f, -0.02605730f, 0.03053998f, 0.18482856f, 0.03720401f, 0.00818714f, 0.01211767f, -0.15378112f, 
    -0.07366657f, -0.18508081f, -0.13000914f, -0.01437169f, -0.06379533f, 0.14714038f, -0.05054383f, 0.07908113f, 
    -0.01982629f, -0.09667522f, -0.16534846f, -0.05491686f, 0.01508144f, 0.01627447f, 0.04699842f, -0.21944085f, 
    0.18190220f, 0.07500096f, -0.01891707f, 0.13032384f, -0.00151999f, 0.08121912f, -0.01143949f, -0.08639523f, 
    -0.14126764f, -0.12322681f, 0.01222601f, -0.00832768f, 0.19661754f, -0.03715657f, 0.04778952f, 0.00686441f, 
    0.03799640f, -0.24857841f, -0.13391697f, -0.33452410f, -0.06888412f, 0.07401938f, 0.02795688f, -0.01318008f, 
    -0.01026991f, -0.07447392f, -0.31086698f, -0.15184768f, -0.29110119f, -0.06806387f, -0.01533782f, -0.32503706f, 
    -0.07360483f, -0.02995126f, -0.00148755f, 0.12694624f, -0.10422271f, -0.01878613f, 0.05915316f, -0.04677283f, 
    0.13030966f, 0.00089429f, -0.10524263f, -0.10350344f, -0.04036961f, -0.15249504f, 0.19617172f, -0.02166913f, 
    0.10536407f, -0.01730823f, 0.06937768f, 0.14494856f, 0.15884911f, 0.08396121f, -0.16984108f, 0.05747969f, 
    0.06895734f, -0.00849459f, -0.01267073f, -0.02570371f, 0.08485230f, 0.07973968f, -0.23240903f, -0.10103136f, 
    0.18466033f, -0.25580996f, -0.04055412f, 0.19473353f, -0.02766204f, -0.10356106f, -0.01431068f, -0.01766174f, 
    0.21533422f, 0.04175130f, -0.00195099f, -0.08274686f, 0.05480758f, -0.04261965f, 0.03659318f, 0.06919350f, 
    -0.11983920f, 0.00333325f, 0.24108189f, 0.08546653f, 0.05501086f, -0.03561940f, -0.19774915f, -0.02163545f, 
    -0.09599125f, -0.34461758f, -0.06279212f, -0.19246379f, -0.12096759f, -0.04208470f, 0.13337380f, 0.07487540f, 
    -0.03906389f, -0.03408954f, -0.01398192f, 0.19300671f, 0.00283431f, 0.06510706f, -0.00806616f, 0.01815596f, 
    0.07318119f, 0.14478365f, 0.26623231f, 0.04444335f, -0.18025619f, -0.40407944f, 0.02324987f, 0.18337490f, 
    -0.34088475f, -0.03639122f, -0.03778979f, 0.15370806f, -0.36914268f, -0.17762449f, -0.44070211f, -0.07352489f, 
    0.09577649f, 0.18122208f, 0.02221745f, -0.05301912f, 0.06796587f, -0.18087357f, -0.24863058f, -0.21918826f, 
    0.01551790f, -0.03053783f, -0.08618158f, -0.05983073f, 0.06633090f, 0.03241625f, -0.15650253f, -0.29886925f, 
    -0.61864346f, -0.03123660f, 0.00389762f, -0.04763081f, 0.03297355f, -0.11156092f, -0.03517015f, 0.14540334f, 
    0.08911660f, 0.11328828f, -0.01125817f, -0.06673023f, 0.06101765f, -0.02146221f, 0.09348467f, -0.08846200f, 
    0.06269278f, 0.15335879f, 0.18747808f, -0.11692895f, -0.09524656f, 0.02167873f, -0.04677564f, 0.08013023f, 
    -0.05545045f, -0.11356676f, 0.15487485f, 0.05668788f, -0.02030356f, -0.04177359f, 0.24724650f, -0.00127904f, 
    -0.17254299f, -0.01893844f, -0.14094059f, 0.04309123f, -0.27631402f, 0.06699345f, -0.04314067f, 0.07218164f, 
    0.10637077f, 0.12095245f, 0.13517858f, 0.13850635f, 0.08483557f, -0.06822366f, 0.03034256f, -0.04679082f, 
    0.09324542f, -0.08524664f, 0.01516009f, -0.11317805f, 0.19009429f, 0.10426614f, 0.16600221f, -0.06228883f, 
    -0.05212562f, -0.01287499f, 0.06796122f, 0.10175134f, -0.00756204f, -0.51649833f, -0.24511041f, -0.11297569f, 
    0.03206325f, 0.07374063f, 0.08814143f, 0.15827809f, -0.11110631f, 0.02918699f, 0.36488941f, -0.16355185f, 
    -0.09605683f, -0.10662325f, 0.03530622f, -0.02520019f, -0.04958842f, 0.08707250f, 0.02413600f, 0.15429075f, 
    0.02800913f, 0.00375531f, -0.00684552f, 0.10618117f, -0.13777366f, -0.04904006f, 0.29683530f, 0.22199689f, 
    0.27317029f, 0.07539485f, -0.17798838f, -0.01783649f, 0.04515148f, 0.04858195f, -0.07209380f, -0.07148980f, 
    -0.19899555f, -0.31699088f, -0.24270460f, 0.19148780f, -0.19816917f, 0.00984351f, -0.04009530f, 0.03631527f, 
    0.00137647f, -0.07191551f, -0.22604057f, -0.43409002f, -0.28238881f, 0.10501675f, 0.06932551f, -0.03646038f, 
    0.00199555f, -0.02310788f, 0.19560778f, -0.31523368f, -0.24614380f, 0.32427338f, 0.09195695f, -0.22181855f, 
    -0.00384420f, -0.16687191f, 0.15618476f, -0.09402719f, 0.13352682f, -0.29283738f, -0.07855356f, 0.00514326f, 
    -0.06159486f, 0.06884473f, -0.05233581f, 0.02522703f, -0.07792535f, -0.13927965f, -0.22099344f, -0.12984698f, 
    0.05475791f, 0.00894819f, -0.00171254f, 0.10321911f, -0.05133724f, 0.14863576f, 0.30081153f, -0.14896595f, 
    -0.18172453f, -0.23930444f, 0.00684389f, -0.10169270f, 0.06682460f, -0.05229696f, 0.10953860f, -0.28052330f, 
    0.16032168f, 0.13819626f, -0.00405696f, 0.17894648f, -0.21008657f, 0.03885134f, 0.08632968f, -0.09723825f, 
    0.21701890f, -0.08879713f, -0.03609559f, 0.04769468f, -0.11877043f, -0.02450994f, 0.01502228f, -0.05126277f, 
    -0.13227768f, -0.08986364f, -0.10092633f, 0.03922334f, 0.09638228f, 0.01099430f, -0.10766767f, -0.08195943f, 
    0.14372900f, 0.09232251f, 0.29619789f, -0.11641564f, -0.02175761f, 0.22604346f, 0.05885708f, -0.02137112f, 
    0.05824075f, -0.05388795f, -0.23083869f, 0.04411522f, 0.21341982f, 0.12469124f, -0.08409263f, -0.01516749f, 
    -0.18876101f, 0.03438091f, 0.04235576f, -0.16468653f, -0.07259087f, 0.03225594f, 0.01901232f, 0.04592289f, 
    0.03519748f, -0.04911387f, -0.05974704f, -0.10182790f, -0.11666691f, -0.07958484f, 0.07732353f, 0.02525727f, 
    -0.05910607f, -0.02706058f, -0.06743954f, 0.07588238f, 0.05489040f, 0.08333350f, -0.12150826f, -0.00276180f, 
    -0.12162463f, 0.03149592f, 0.09500640f, -0.04707702f, -0.11029039f, -0.12644339f, -0.09080487f, -0.13307504f, 
    0.07127237f, -0.02704943f, 0.12665662f, 0.14997989f, 0.00197496f, -0.02004438f, 0.03456662f, -0.01136126f, 
    0.02433899f, 0.08340309f, 0.03505213f, 0.24395886f, 0.29491153f, -0.03888199f, -0.07205348f, 0.00521332f, 
    -0.07138435f, 0.09794745f, -0.03831899f, -0.00806597f, 0.15285443f, 0.01678261f, -0.06265020f, -0.07726290f, 
    -0.26597434f, -0.20105664f, -0.03876612f, -0.00062072f, -0.16663979f, 0.00725981f, 0.14798625f, -0.02926318f, 
    0.14290684f, -0.00611058f, -0.06563431f, 0.15604208f, 0.13217193f, 0.11194479f, 0.16165712f, 0.16934060f, 
    -0.04317130f, -0.05829512f, -0.04957328f, 0.01278483f, 0.31990331f, 0.19966532f, 0.39292148f, 0.04433193f, 
    -0.05782587f, 0.00976204f, 0.10716806f, 0.02004216f, -0.04730952f, 0.16120920f, 0.21218389f, 0.19818263f, 
    0.08236139f, -0.00860735f, -0.06505715f, -0.01397460f, 0.03027157f, 0.12102273f, 0.01721273f, 0.17892018f, 
    0.01869140f, 0.09764288f, -0.05939734f, -0.06615539f, -0.00464253f, -0.17589252f, -0.10980350f, -0.02687656f, 
    -0.01693340f, -0.03782010f, -0.04119175f, -0.06593376f, 0.00036962f, 0.08771404f, 0.05864691f, -0.07579586f, 
    0.03105850f, -0.01798749f, -0.01376558f, 0.06525832f, 0.01632859f, -0.05660725f, -0.07824656f, -0.11627864f, 
    -0.18241219f, 0.13677199f, 0.03537714f, -0.02638515f, 0.03461675f, 0.15549524f, 0.04583924f, 0.04556841f, 
    -0.04944910f, 0.02611399f, 0.02768631f, 0.06612488f, -0.10446120f, -0.12778178f, 0.10818148f, 0.21572195f, 
    -0.03892247f, 0.03939876f, -0.00977194f, -0.22502963f, -0.01292694f, -0.00929264f, 0.00750035f, 0.02542760f, 
    0.12023114f, 0.00125637f, -0.01900321f, -0.09226797f, -0.06502221f, -0.01942030f, -0.04364337f, -0.07904232f, 
    -0.05013308f, -0.12883386f, 0.01717063f, 0.12330200f, -0.11259784f, -0.04474242f, 0.23803988f, -0.15489440f, 
    0.12169262f, 0.00448947f, -0.12138283f, -0.13614899f, 0.02032281f, 0.02287016f, -0.03444262f, 0.12784813f, 
    -0.14514245f, 0.00677182f, -0.01524690f, -0.08069268f, 0.13134222f, -0.07005352f, 0.18318148f, 0.18833566f, 
    0.22518001f, 0.01861289f, -0.01377857f, 0.06218459f, -0.02776699f, 0.08289147f, 0.03015792f, -0.24206367f, 
    -0.09104548f, 0.09602973f, -0.02064350f, 0.04282506f, 0.03439533f, -0.02367393f, -0.11831602f, -0.06314150f, 
    -0.20177831f, 0.29599148f, 0.16260599f, -0.09571227f, 0.03139097f, -0.10008290f, 0.04157281f, -0.08748565f, 
    0.16832969f, 0.23621780f, -0.07710069f, 0.29711828f, 0.11020110f, 0.09799961f, -0.04158178f, 0.03690387f, 
    -0.00605314f, -0.00611489f, 0.08423609f, -0.16519235f, 0.15832877f, 0.30741477f, 0.02159886f, 0.07991048f, 
    0.17377990f, -0.07774720f, 0.18647732f, 0.01364436f, -0.03961669f, 0.08586135f, -0.01576687f, 0.01045774f, 
    -0.04076676f, 0.01320876f, -0.02352235f, 0.10728160f, -0.03317981f, -0.00078272f, -0.00427469f, -0.05620426f, 
    -0.04068587f, 0.05295014f, -0.11233890f, 0.02840107f, -0.05151993f, 0.05642520f, 0.20106541f, 0.05680966f, 
    0.10902324f, 0.07230628f, 0.01208767f, -0.04718653f, -0.06450914f, -0.17290585f, 0.02926663f, 0.02427515f, 
    -0.11696491f, -0.02250561f, 0.11748614f, 0.00394210f, -0.11238217f, 0.04785609f, -0.09365050f, 0.01125127f, 
    0.17547353f, -0.09573866f, -0.01634716f, 0.00155802f, -0.13115822f, -0.11268899f, 0.02712693f, -0.03411732f, 
    -0.04090822f, 0.02165534f, -0.06895099f, -0.11334026f, 0.05983762f, 0.08866609f, 0.21404111f, 0.10687924f, 
    -0.03244081f, 0.09029366f, -0.13176984f, -0.20392725f, 0.00816297f, 0.09130408f, -0.02082276f, -0.00437300f, 
    0.06881470f, 0.10943084f, 0.15702021f, -0.18356997f, -0.17894252f, 0.06404551f, -0.00935751f, 0.02329990f, 
    -0.02334603f, 0.09369231f, 0.07325687f, 0.03501394f, -0.01225798f, -0.05319867f, -0.17207628f, 0.02462287f, 
    0.03000572f, -0.01285889f, 0.02939771f, 0.09351081f, 0.05048795f, -0.16290598f, 0.11344925f, 0.12016549f, 
    0.02805671f, 0.01216794f, -0.11607082f, 0.02746240f, 0.00664680f, 0.23335160f, -0.14826256f, -0.12607476f, 
    -0.23154829f, -0.15952006f, -0.11505500f, 0.00645398f, 0.09626544f, 0.08633488f, 0.18474828f, -0.39745188f, 
    0.08969320f, 0.11113415f, -0.01872172f, 0.00295503f, -0.20326979f, -0.00530996f, 0.00247854f, -0.00928150f, 
    -0.08583475f, -0.14209099f, 0.11615671f, -0.10073144f, -0.03653081f, -0.05363974f, 0.06044924f, 0.01822496f, 
    0.06725963f, 0.26661602f, -0.49197537f, -0.32786193f, 0.01308079f, -0.10874309f, 0.01401431f, 0.02861659f, 
    0.12542680f, 0.15437901f, 0.03921282f, 0.08543740f, 0.04815694f, 0.01577694f, 0.09867010f, 0.03531916f, 
    0.10397045f, 0.03104030f, 0.02367976f, -0.16448991f, -0.18835776f, -0.10585537f, 0.04428161f, -0.08263380f, 
    0.00996519f, 0.00431412f, 0.04309336f, 0.18435688f, -0.27904412f, -0.25266156f, 0.12021874f, -0.04930263f, 
    -0.03355996f, -0.04585421f, -0.07675960f, 0.05942990f, 0.00989131f, -0.02298068f, -0.17160021f, 0.01645279f, 
    0.02405154f, -0.05135720f, 0.00957108f, 0.05817648f, 0.16383608f, 0.21121229f, 0.04441814f, -0.30364987f, 
    -0.02104104f, 0.10287429f, -0.01806329f, 0.15947530f, 0.04235524f, 0.07608639f, 0.15750536f, -0.34620488f, 
    0.14391652f, 0.09027451f, -0.13969599f, 0.03573580f, -0.09762146f, 0.13650325f, 0.11280658f, 0.02918128f, 
    -0.17211749f, 0.12195667f, 0.17275147f, 0.04673386f, -0.00169754f, -0.19672492f, 0.24754101f, -0.10195366f, 
    0.10957245f, 0.02624594f, -0.27179918f, -0.39155164f, 0.08568605f, 0.19807349f, 0.08828171f, 0.02321099f, 
    -0.10701481f, 0.03165903f, 0.06650072f, 0.00986304f, 0.14623976f, 0.11239135f, 0.01257758f, -0.10497107f, 
    -0.06523184f, -0.21687682f, 0.00800162f, 0.03034211f, -0.10247575f, 0.04183744f, 0.02874434f, 0.15633665f, 
    -0.06914205f, 0.09750423f, 0.04142399f, -0.02713209f, 0.09079057f, 0.12982740f, 0.00223624f, 0.19070877f, 
    0.02619381f, 0.09316886f, 0.04363281f, 0.17228717f, 0.09004606f, 0.20967659f, 0.01948725f, -0.26385516f, 
    0.00614728f, 0.05377331f, 0.04860719f, -0.06368642f, 0.13692173f, 0.00750345f, -0.32728896f, 0.13624319f, 
    0.07280027f, -0.08372117f, 0.04355536f, -0.21267140f, -0.01892968f, 0.06553188f, 0.07718590f, 0.01412186f, 
    0.00369404f, -0.28549469f, -0.09169457f, -0.04817663f, 0.01679928f, -0.03360542f, -0.05446750f, 0.04306539f, 
    0.47807553f, -0.14780006f, -0.32807764f, 0.06531437f, -0.07796762f, -0.09629823f, 0.06550732f, 0.06572590f, 
    0.01195810f, 0.04136163f, -0.23327503f, 0.07152144f, -0.08480200f, -0.09843469f, -0.21124779f, -0.17205735f, 
    0.12965496f, 0.00789354f, 0.29246369f, -0.10843500f, -0.19135065f, 0.08837085f, -0.00906898f, -0.21673751f, 
    -0.05687932f, 0.08590612f, 0.04906241f, -0.06100373f, -0.03987113f, -0.04417991f, 0.10700224f, 0.01003881f, 
    -0.12857519f, -0.02420042f, -0.10486776f, -0.12929694f, -0.14585179f, -0.23408327f, -0.36885232f, -0.18446541f, 
    -0.18779276f, -0.08674812f, -0.01480801f, 0.05618656f, -0.02137785f, 0.17744970f, -0.02830823f, 0.04733622f, 
    0.10961790f, -0.11211195f, 0.01562955f, 0.10862856f, 0.08971960f, 0.11565945f, 0.03683090f, -0.12137342f, 
    -0.04825225f, 0.04762323f, 0.09032969f, 0.06807268f, -0.07323550f, 0.17076081f, -0.01320650f, 0.02090194f, 
    0.02274640f, 0.07419780f, -0.01251509f, 0.11524495f, 0.11442042f, -0.00688201f, 0.08941315f, -0.02873457f, 
    0.01245377f, 0.09852331f, 0.02701318f, -0.17158161f, 0.10611194f, 0.03258047f, 0.15094689f, 0.07176840f, 
    -0.20202285f, 0.06413760f, -0.28389949f, -0.23355182f, -0.11922686f, -0.12334392f, -0.04061813f, 0.04736776f, 
    0.04173803f, -0.18566845f, -0.17506902f, -0.14224030f, 0.05852401f, 0.01907743f, 0.00786002f, 0.05164410f, 
    -0.06176195f, -0.05699946f, 0.12806368f, -0.19248988f, -0.04334733f, -0.10030441f, 0.04434881f, 0.06220040f, 
    0.09997401f, 0.10535452f, -0.01764066f, 0.05250945f, 0.13060513f, 0.00402333f, -0.01921224f, 0.06898136f, 
    0.13185669f, -0.05209397f, -0.14256994f, -0.13318495f, 0.03291557f, 0.06365333f, -0.04971043f, 0.14652598f, 
    0.11045430f, 0.00199066f, 0.04389808f, 0.11481050f, -0.00857700f, -0.00199755f, 0.45984167f, 0.14867361f, 
    0.20921499f, -0.06036182f, -0.11147486f, 0.00073354f, 0.10733587f, -0.01734141f, -0.05336200f, 0.14427346f, 
    0.10969167f, 0.19934905f, -0.10224049f, -0.11000362f, 0.02339532f, 0.01894384f, -0.18826652f, 0.08717557f, 
    0.02094382f, -0.06758489f, -0.15925197f, 0.02218574f, -0.03267037f, 0.00900837f, 0.08183079f, 0.01877134f, 
    0.03670594f, 0.16964135f, 0.26606581f, 0.20600133f, 0.07821438f, 0.01961106f, 0.16262840f, -0.05150986f, 
    0.09339673f, -0.01061602f, 0.08552269f, 0.02926866f, 0.19084847f, -0.09874915f, 0.04709171f, 0.04379437f, 
    -0.02418227f, -0.08969001f, 0.14880747f, 0.02171184f, -0.28741843f, 0.06091224f, 0.12248402f, -0.03174429f, 
    0.11907387f, 0.00243060f, 0.04852634f, 0.05896873f, -0.21435051f, -0.06849501f, 0.01225734f, 0.12868333f, 
    -0.00433912f, 0.08410357f, -0.13117874f, -0.07420354f, 0.10502658f, 0.11279829f, -0.26123461f, 0.01820228f, 
    0.04930124f, -0.15303728f, 0.02715850f, -0.01629877f, -0.03400653f, -0.14157853f, -0.09861948f, -0.41855133f, 
    -0.32145140f, 0.00687790f, 0.05949853f, 0.00637130f, -0.09822296f, -0.01024123f, -0.03479984f, 0.19011657f, 
    -0.07624754f, 0.17635161f, -0.02715282f, -0.00977134f, 0.01370317f, 0.18430838f, -0.00125064f, 0.09166054f, 
    0.06931265f, -0.00037846f, 0.17910589f, -0.05202286f, 0.01114573f, -0.24362493f, -0.07225532f, -0.01134085f, 
    -0.00630101f, 0.10025206f, 0.01642986f, 0.10352039f, -0.27449286f, -0.13244213f, -0.15354380f, 0.07292118f, 
    0.02592899f, -0.06043269f, 0.02014852f, -0.05593267f, 0.18377237f, -0.02840090f, -0.05452083f, -0.13733993f, 
    -0.13120452f, -0.03919283f, 0.00264223f, 0.42529094f, 0.07084619f, 0.07976307f, -0.05995949f, -0.25138816f, 
    -0.10980312f, 0.16068695f, 0.01047827f, 0.05488561f, -0.13679707f, -0.02693085f, 0.18220079f, -0.04902765f, 
    0.05044540f, -0.01082022f, -0.02706081f, 0.11262817f, 0.08720643f, -0.09445418f, 0.04499247f, -0.27367851f, 
    0.04431265f, 0.16926773f, -0.10892247f, -0.03716673f, -0.15368621f, -0.13688198f, 0.08342040f, -0.05919461f, 
    0.18563995f, 0.03742032f, 0.00888223f, -0.05403303f, 0.16209725f, 0.02833290f, 0.06872687f, -0.15694070f, 
    -0.00032249f, 0.29146659f, 0.11295558f, 0.01224764f, 0.12216672f, -0.02036504f, -0.21556947f, 0.21790797f, 
    0.09007560f, -0.04106172f, 0.02106579f, 0.14960155f, 0.00995516f, 0.10973392f, 0.09129398f, 0.08993641f, 
    0.17298076f, -0.08812302f, -0.28501448f, 0.18594408f, 0.09388221f, -0.01795206f, -0.00661203f, 0.04586321f, 
    0.03749210f, 0.05355462f, -0.16679974f, -0.27051249f, 0.03330530f, 0.03984470f, -0.05079527f, -0.05295495f, 
    -0.08422191f, -0.01094926f, -0.12615502f, 0.01813103f, 0.00977591f, -0.13451047f, -0.14566642f, -0.15831605f, 
    -0.12354992f, -0.09155285f, -0.13000913f, -0.03705447f, -0.31812093f, -0.03222180f, 0.26271859f, 0.20439151f, 
    0.08023929f, 0.18766464f, -0.03399159f, 0.01854271f, 0.05032174f, -0.17196622f, -0.12612174f, -0.18382560f, 
    0.03251879f, -0.07178812f, 0.03368474f, -0.12925304f, 0.14537428f, -0.01646952f, -0.33092323f, -0.17222849f, 
    -0.09844607f, -0.02602860f, 0.07431049f, 0.00399210f, 0.09872557f, 0.14307058f, -0.16007826f, 0.14644523f, 
    -0.07670012f, -0.38345897f, -0.13394007f, -0.10910523f, -0.02328482f, 0.11767011f, 0.03175415f, -0.06222250f, 
    -0.04187267f, 0.17592269f, -0.02314221f, 0.10091948f, -0.03990418f, 0.03565000f, 0.09206058f, -0.17701797f, 
    0.03007521f, -0.02127342f, 0.06142393f, -0.10384191f, -0.02176689f, -0.08910517f, -0.14448249f, -0.07369625f, 
    -0.09319612f, -0.11055822f, -0.10700696f, -0.20877488f, -0.09118482f, -0.06264339f, 0.10108860f, -0.05496465f, 
    0.05301780f, 0.09003836f, 0.01001242f, 0.00353343f, -0.03603751f, 0.06355953f, 0.05570839f, 0.04543323f, 
    0.15702224f, 0.16748606f, 0.10309627f, 0.07500923f, -0.07004737f, 0.14257300f, 0.11216196f, 0.00148995f, 
    0.11131045f, 0.15030131f, 0.05284344f, 0.18453233f, 0.17518066f, -0.15720604f, 0.06663546f, 0.04152047f, 
    0.00939103f, 0.05412547f, 0.09304408f, -0.05746605f, 0.02954228f, -0.04083846f, -0.02616035f, 0.12192260f, 
    0.05023311f, 0.10116524f, 0.01544535f, 0.05466467f, -0.25486955f, 0.12471034f, 0.05715666f, -0.10690836f, 
    0.00237697f, -0.04816313f, -0.12010691f, 0.05568593f, 0.07244745f, -0.00387998f, -0.19013466f, -0.08295727f, 
    -0.13665538f, -0.09563395f, 0.13010202f, -0.01823414f, 0.09736532f, -0.04926382f, -0.05859708f, 0.12348695f, 
    0.05584000f, 0.11540306f, -0.04528987f, -0.13272962f, 0.07463328f, 0.01841759f, -0.03292633f, -0.10658199f, 
    0.08528262f, 0.08610396f, -0.08182054f, 0.04885949f, 0.05713976f, -0.02927193f, 0.00028147f, 0.12399788f, 
    0.04037844f, -0.08085818f, -0.12218826f, -0.37622765f, -0.08677155f, -0.05437047f, -0.03231659f, -0.11884331f, 
    0.08949858f, -0.04217195f, 0.18083109f, -0.09873779f, -0.05396631f, -0.23449844f, -0.07824966f, 0.10367792f, 
    0.06964134f, 0.08172721f, -0.02993525f, 0.00022622f, -0.33151758f, -0.02556130f, -0.01794006f, -0.12789077f, 
    0.09572805f, 0.11633027f, 0.02324038f, 0.06574903f, 0.06569283f, -0.02275123f, -0.00425617f, 0.02750486f, 
    -0.01992678f, 0.02039849f, 0.06709189f, 0.05153939f, 0.18536182f, 0.04279321f, -0.11167451f, -0.18681951f, 
    0.20914297f, 0.16270339f, -0.03959096f, -0.08504108f, 0.11276710f, -0.12469475f, 0.04190975f, -0.00297178f, 
    -0.13628028f, 0.07209045f, 0.03828812f, -0.05510164f, 0.06436020f, 0.07375146f, -0.12567443f, 0.02028210f, 
    -0.08287843f, 0.03026711f, -0.03007553f, -0.22315687f, 0.16539533f, -0.02409857f, 0.02931445f, -0.00989491f, 
    -0.03991194f, -0.11016743f, 0.05907271f, -0.04830557f, -0.12630771f, -0.04249217f, -0.03452462f, 0.02032998f, 
    -0.19005366f, -0.22209744f, -0.10563793f, -0.14289805f, -0.01042544f, 0.14427915f, -0.12446420f, 0.06147847f, 
    0.04949043f, -0.19896233f, -0.08883303f, 0.04679669f, -0.02061104f, 0.10236108f, 0.08102199f, 0.01487386f, 
    -0.04046652f, 0.14262530f, 0.02793276f, 0.05007619f, 0.09003345f, 0.10857184f, 0.13834734f, 0.07159113f, 
    0.08131284f, -0.12084827f, -0.03939008f, -0.07650819f, 0.02355097f, 0.09258999f, -0.02654030f, 0.08620045f, 
    0.03391996f, -0.00260366f, -0.00149250f, -0.04067391f, -0.14608355f, 0.07380194f, -0.00322078f, -0.03368645f, 
    -0.00063051f, 0.06018353f, -0.07142682f, 0.22107616f, 0.00679837f, 0.08977042f, -0.02826481f, -0.09668484f, 
    -0.04983729f, -0.00534787f, 0.03875200f, 0.03253138f, -0.07697880f, 0.01633028f, -0.11955025f, -0.03755873f, 
    0.23568514f, 0.13197032f, 0.23209602f, 0.36399391f, -0.00021190f, 0.15424190f, -0.08642917f, -0.04752630f, 
    0.02625839f, -0.03748291f, -0.03916122f, -0.11644617f, -0.01269501f, -0.05838195f, 0.15783757f, -0.05179256f, 
    -0.09329620f, 0.19313812f, -0.14405864f, 0.10882246f, -0.05246247f, 0.04549164f, 0.03685282f, -0.07567462f, 
    -0.05140892f, -0.10975722f, -0.17799786f, -0.13900961f, 0.14034265f, 0.11447627f, -0.17706458f, 0.15269493f, 
    0.00399879f, -0.00118897f, -0.08160527f, -0.05928368f, 0.05054936f, 0.06582364f, 0.18165916f, 0.15564832f, 
    0.12568164f, 0.13283236f, 0.13666725f, 0.00716154f, 0.11524037f, 0.06737138f, -0.01054549f, -0.01814484f, 
    -0.04845912f, 0.00751888f, 0.03588788f, 0.00950048f, 0.07860004f, 0.04411759f, 0.03032527f, -0.04141730f, 
    0.12234136f, 0.25070730f, -0.05200079f, 0.00079602f, 0.02089300f, 0.03336011f, 0.02025147f, 0.06039977f, 
    0.05823898f, -0.13915020f, 0.16304639f, -0.03560928f, -0.01401702f, -0.03232731f, 0.07179302f, 0.08938951f, 
    -0.05296881f, 0.08398306f, -0.08357726f, -0.04915985f, 0.03420845f, 0.06965162f, 0.14736734f, -0.10833133f, 
    -0.06043699f, 0.02734658f, -0.01498950f, -0.15721676f, -0.04435146f, 0.10616480f, 0.11783599f, 0.10868488f, 
    -0.06100982f, 0.00349374f, -0.11161858f, 0.24754137f, 0.12144677f, 0.02300024f, 0.02409662f, 0.00436346f, 
    -0.02738666f, -0.06139807f, -0.19322076f, -0.16120422f, 0.02785073f, 0.07277615f, 0.11864650f, 0.11143180f, 
    0.05438551f, -0.01090068f, 0.15040746f, -0.03644604f, 0.05922246f, 0.22752540f, 0.19813171f, 0.10050935f, 
    0.09945981f, 0.04437301f, -0.10756184f, -0.05792244f, -0.03821184f, 0.08805293f, 0.05834884f, 0.12402043f, 
    -0.27986908f, 0.02332120f, 0.06446667f, -0.10346123f, -0.16967449f, -0.12058436f, 0.00944527f, 0.12762693f, 
    -0.01961443f, -0.27866453f, 0.05320649f, 0.05332691f, 0.00093157f, -0.01994263f, -0.01806733f, -0.02094311f, 
    0.03936404f, -0.23148274f, -0.13789830f, 0.05428454f, 0.20504858f, 0.21264917f, -0.04333439f, -0.05382867f, 
    0.09051275f, -0.02245123f, -0.23028167f, -0.10067176f, 0.04558221f, -0.07543891f, 0.07690156f, 0.04376324f, 
    -0.05217540f, -0.03878998f, 0.09031015f, -0.08842301f, 0.00552935f, 0.07126411f, 0.05741407f, -0.00110441f, 
    0.17562337f, 0.11428870f, 0.10954943f, 0.02455853f, -0.00164487f, 0.01416770f, 0.11463609f, 0.14634152f, 
    0.17677936f, -0.02559495f, -0.07595332f, 0.15306708f, 0.08699968f, 0.06810735f, 0.08845674f, 0.07069184f, 
    0.04654557f, 0.06056434f, -0.04249579f, 0.02193994f, 0.06266887f, -0.06658804f, -0.06466111f, 0.05031479f, 
    0.10688597f, 0.15863925f, 0.02440863f, 0.01975205f, -0.10813711f, 0.16304238f, -0.23370871f, -0.03825317f, 
    -0.01499550f, 0.10116531f, 0.00620649f, 0.11549240f, -0.07969534f, 0.00811164f, -0.15099372f, 0.15384734f, 
    0.16619332f, -0.24387281f, 0.00264861f, -0.00695781f, -0.03086481f, -0.04429756f, -0.05098670f, -0.01714880f, 
    0.08274593f, -0.10820758f, -0.12131632f, 0.01622676f, -0.05992067f, 0.03776829f, -0.02111539f, 0.15027982f, 
    -0.12190926f, 0.21515705f, -0.01941440f, -0.04052171f, 0.22858526f, 0.11443786f, 0.16195473f, 0.07962323f, 
    -0.12078252f, -0.14661318f, -0.21796137f, -0.07248151f, -0.00873503f, -0.01223001f, 0.03880156f, 0.16178864f, 
    -0.00675282f, -0.00336262f, 0.18168373f, -0.14931786f, -0.00015841f, -0.00183817f, -0.00300940f, -0.01505315f, 
    0.20942089f, 0.06691949f, -0.03819813f, 0.01821009f, 0.07503939f, 0.14315133f, 0.03070373f, 0.08157420f, 
    -0.00064070f, -0.07096183f, -0.02803831f, 0.01670104f, 0.08444931f, 0.05060312f, -0.11024719f, -0.32814401f, 
    0.04257676f, 0.04729383f, 0.00402929f, -0.00042326f, -0.07407192f, -0.04678661f, 0.18215807f, 0.19191034f, 
    -0.15265544f, 0.05629608f, -0.06374343f, -0.15822122f, -0.00029030f, -0.03052238f, 0.04946491f, 0.11366037f, 
    0.11888769f, -0.06745860f, 0.06530105f, -0.18489952f, -0.03196167f, 0.15430853f, 0.06674048f, 0.06516667f, 
    0.00414651f, 0.00996217f, 0.01350695f, 0.03599663f, -0.01401143f, 0.03190111f, 0.08134776f, -0.26837197f, 
    -0.25793898f, 0.18765908f, 0.10506949f, -0.37878197f, 0.08651508f, -0.17446172f, 0.15388989f, 0.03896321f, 
    0.02116843f, 0.18222372f, 0.00818890f, -0.03315809f, 0.16118307f, 0.04192749f, 0.07643353f, -0.11432178f, 
    -0.08024855f, -0.03383695f, 0.15242372f, -0.06263836f, -0.18929785f, 0.11012761f, -0.07679091f, 0.01472106f, 
    0.07447235f, -0.01066132f, -0.06377060f, 0.20300823f, -0.05549273f, -0.09022427f, -0.29784620f, -0.07722872f, 
    -0.11047740f, 0.09433129f, -0.00539132f, -0.13900281f, -0.18453641f, 0.07567780f, -0.00284581f, 0.02715607f, 
    0.07974548f, 0.06017922f, 0.18246982f, 0.17721365f, -0.00040727f, 0.20286798f, -0.02180238f, 0.01286244f, 
    0.12660936f, -0.00350759f, -0.01277847f, 0.05121043f, -0.05692398f, 0.02054702f, 0.05071503f, -0.02275014f, 
    -0.11613559f, -0.00093884f, 0.05182072f, 0.06084581f, 0.00707738f, -0.07697171f, 0.06379134f, -0.06567208f, 
    0.04422387f, -0.02277095f, 0.01924211f, -0.01900551f, -0.04252365f, -0.05367476f, 0.04607266f, -0.05407652f, 
    0.02731989f, 0.03565149f, -0.02174962f, -0.04040967f, 0.04238012f, -0.03995904f, -0.04879620f, 0.03382746f, 
    0.03803099f, 0.00856056f, -0.04135711f, -0.02429123f, 0.04598513f, 0.04488506f, 0.04989057f, 0.00965243f, 
    0.00227628f, -0.00938991f, -0.03757959f, -0.00800459f, -0.02075825f, 0.02165164f, -0.02023957f, -0.00556194f, 
    0.01610136f, -0.05877182f, -0.04426313f, -0.01409528f, -0.06464955f, 0.02402945f, 0.04105200f, -0.05780718f, 
    0.02784897f, 0.02142159f, 0.02876926f, -0.04815755f, -0.05582134f, -0.03911041f, 0.03162028f, -0.06336277f, 
    -0.00847615f, -0.05173533f, -0.02885796f, -0.05478332f, -0.05824744f, -0.00525212f, 0.04546706f, -0.06189932f, 
    0.05805165f, 0.00061653f, -0.04839855f, -0.03801214f, -0.05118610f, 0.01465620f, -0.04170055f, -0.02466081f, 
    0.04447171f, -0.00342987f, 0.03786242f, 0.01836964f, -0.02333452f, 0.02290743f, 0.03538371f, 0.02834521f, 
    -0.04368806f, 0.02133248f, 0.03945661f, 0.04634601f, 0.03868139f, -0.04868139f, 0.02113347f, 0.03482810f, 
    -0.01641976f, 0.02089709f, 0.03215543f, -0.03282088f, -0.03493959f, 0.02011032f, -0.05738834f, -0.01764231f, 
    0.00815954f, -0.01326263f, -0.05466535f, 0.04205821f, 0.03219537f, -0.02037518f, -0.05073216f, 0.03009167f, 
    -0.01720187f, -0.00847766f, -0.04789971f, 0.03353788f, -0.01696177f, -0.02320688f, -0.03340595f, -0.03588795f, 
    -0.01623966f, 0.02713276f, -0.05100455f, 0.03423770f, -0.03566687f, 0.01485824f, -0.05319382f, -0.02005086f, 
    -0.05424329f, -0.00427299f, 0.04742580f, -0.02413452f, -0.01271821f, -0.05469731f, 0.01774842f, -0.00167494f, 
    0.00729099f, 0.01110251f, -0.01025165f, 0.01511472f, 0.00763218f, -0.05035035f, 0.03721378f, -0.04101459f, 
    -0.00427275f, 0.04005612f, -0.05120691f, 0.03883367f, 0.02063736f, 0.02268763f, 0.03230831f, -0.00116892f, 
    -0.00108570f, 0.02298755f, -0.05490244f, 0.04036062f, -0.05893454f, -0.05353555f, -0.00019551f, -0.04847344f, 
    0.03855656f, 0.00955622f, 0.00935497f, -0.00958002f, -0.02461077f, 0.01340699f, -0.05156211f, -0.00005949f, 
    0.03972801f, 0.00892878f, -0.06142152f, 0.00628730f, -0.02134459f, 0.02431152f, -0.00382889f, 0.02707017f, 
    -0.00530051f, -0.00280486f, -0.02070643f, 0.04301338f, -0.01152788f, 0.03997229f, -0.04089839f, -0.06453897f, 
    -0.03875402f, -0.00972870f, -0.02431937f, -0.01775167f, -0.05117832f, 0.04276697f, 0.01905698f, 0.03079677f, 
    -0.05166126f, 0.00539534f, -0.05769129f, -0.01945090f, 0.00198563f, -0.06537721f, -0.06459118f, 0.01579025f, 
    -0.00083561f, -0.00172032f, -0.05680373f, 0.00466288f, -0.01953593f, 0.00945500f, 0.02257284f, -0.04585537f, 
    -0.04214925f, 0.05091159f, 0.03126591f, 0.01553405f, -0.00731426f, 0.02737634f, 0.00675310f, -0.04660631f, 
    -0.01613568f, -0.01529741f, -0.02408190f, -0.00097982f, -0.01294929f, 0.00809619f, -0.05090436f, 0.00992654f, 
    -0.04170147f, -0.01249073f, -0.02176277f, -0.06005079f, 0.01135304f, 0.04149167f, -0.02961410f, 0.00725238f, 
    -0.01103281f, -0.05624208f, -0.05629671f, -0.05769724f, -0.01421380f, 0.04628624f, -0.03896609f, -0.00488760f, 
    0.03278270f, -0.04141684f, -0.04757873f, -0.00581318f, -0.00154974f, 0.03048088f, 0.03491960f, -0.03868750f, 
    0.03308058f, 0.02287989f, -0.06841406f, -0.01979968f, 0.04863074f, 0.02058424f, 0.04375888f, -0.03350027f, 
    0.00016740f, -0.05427588f, -0.04913703f, 0.01383400f, -0.04663193f, -0.04449455f, -0.05210622f, 0.03088074f, 
    0.04236064f, -0.03446555f, 0.00174230f, 0.02796263f, 0.04535180f, 0.03790198f, 0.02620663f, -0.04115507f, 
    0.03300644f, 0.05471951f, -0.04324232f, 0.00497492f, -0.03703510f, -0.03443688f, -0.04989105f, 0.02140818f, 
    0.04528352f, 0.01017094f, 0.02435605f, -0.04483524f, -0.04872458f, 0.03981424f, -0.03482095f, -0.03524639f, 
    -0.01832574f, 0.03662651f, -0.00198025f, 0.00571141f, 0.02962072f, -0.00858536f, -0.02453648f, -0.05965874f, 
    -0.05998593f, -0.04841794f, 0.04268598f, 0.03217652f, -0.03946926f, -0.03717707f, 0.01564938f, 0.02038678f, 
    0.01104864f, 0.05664786f, 0.07021123f, -0.03303526f, -0.11906224f, -0.00766585f, -0.07557739f, 0.07027698f, 
    0.00105920f, 0.01039443f, -0.05934415f, 0.08242942f, -0.07920325f, 0.08373775f, 0.04712212f, 0.02877387f, 
    0.05543918f, 0.10214459f, -0.12243784f, -0.01779855f, 0.12275591f, -0.12840164f, -0.05836012f, -0.00523682f, 
    -0.03181715f, -0.19591466f, -0.13913265f, 0.11556694f, 0.15902562f, 0.06448258f, 0.09744436f, 0.07194736f, 
    -0.06135254f, -0.04309629f, -0.03687045f, 0.00713794f, 0.18310350f, 0.07081340f, 0.19445331f, -0.02080525f, 
    0.11255660f, 0.18261243f, 0.09413087f, 0.16122399f, 0.13283363f, 0.10418592f, 0.28333104f, 0.19743821f, 
    -0.09016706f, -0.10057665f, 0.12707922f, -0.10189829f, 0.08115277f, 0.01909286f, 0.13009088f, -0.03301704f, 
    -0.04421822f, 0.03396827f, -0.03165010f, -0.06326852f, -0.00001103f, 0.05855040f, 0.22437514f, -0.03341024f, 
    -0.08031651f, -0.08723579f, 0.03107445f, 0.04491208f, 0.03229500f, 0.03735590f, 0.02236307f, -0.11018885f, 
    -0.08584267f, -0.19867487f, 0.04561156f, 0.10817692f, 0.01929009f, 0.10223640f, -0.02545447f, -0.00426304f, 
    0.04384051f, -0.30750355f, -0.20026956f, -0.05324718f, -0.10771398f, 0.05468734f, -0.09694561f, 0.00760117f, 
    -0.13952410f, -0.21334977f, -0.00079609f, 0.04059299f, -0.03461466f, 0.02366421f, 0.08362056f, 0.07350625f, 
    0.06186999f, 0.13367991f, 0.02114555f, -0.07843985f, -0.16979894f, 0.18843961f, -0.03054594f, -0.14505041f, 
    0.01760880f, -0.00929946f, 0.07293905f, 0.04423966f, 0.01138139f, -0.00577456f, 0.29776588f, -0.09763186f, 
    0.04829077f, -0.05079702f, -0.00902861f, 0.05832955f, -0.03815528f, -0.04512396f, 0.02592083f, 0.17181285f, 
    -0.09340174f, -0.06679025f, -0.03938008f, 0.01841884f, 0.15234348f, 0.18459764f, -0.11287372f, 0.04702415f, 
    0.07315665f, -0.04370191f, 0.06786904f, -0.13838367f, 0.00677987f, -0.01861332f, -0.07989139f, 0.04375399f, 
    -0.03343178f, 0.01238504f, 0.10340876f, 0.09562789f, 0.01559801f, 0.01601262f, -0.07844060f, -0.01939915f, 
    0.10922345f, -0.11740538f, 0.02643858f, -0.03649588f, 0.04977769f, 0.01110901f, 0.12515500f, 0.05617004f, 
    -0.19463892f, 0.07289170f, 0.01395002f, -0.00182721f, -0.01763058f, 0.11773808f, 0.07920823f, 0.07967292f, 
    0.13063075f, -0.06030440f, -0.24689204f, -0.21646632f, -0.16212019f, -0.00645616f, -0.04218647f, 0.06928030f, 
    0.09771995f, 0.00085598f, 0.19298050f, -0.15607674f, -0.00899480f, 0.01453077f, 0.00021982f, -0.01254924f, 
    0.26448628f, 0.02515893f, -0.13719782f, 0.06448006f, 0.13171315f, 0.24360169f, 0.06352770f, -0.04527550f, 
    0.00080777f, 0.06983833f, -0.01094331f, 0.13208164f, 0.06625992f, 0.01343399f, -0.08111588f, 0.08544721f, 
    -0.08642089f, 0.18165991f, 0.00211113f, -0.18954507f, 0.06615839f, -0.12636963f, -0.02648800f, 0.15226629f, 
    0.05592293f, -0.11342727f, -0.14325778f, 0.02247966f, -0.11318439f, -0.02089051f, -0.11198278f, 0.17099236f, 
    0.15099445f, 0.05582433f, -0.03741191f, 0.09784225f, 0.09043105f, 0.16719507f, 0.11254824f, 0.08546641f, 
    -0.14063513f, -0.10859612f, 0.04736159f, 0.02873518f, 0.04180283f, -0.05360832f, 0.06032231f, -0.20112218f, 
    -0.11128794f, 0.10908891f, 0.18554226f, -0.11407690f, -0.01366209f, 0.04128044f, -0.07034969f, -0.05425523f, 
    -0.04675478f, 0.04214464f, -0.02303475f, -0.12191515f, 0.21673013f, 0.12259603f, 0.01544625f, -0.03222040f, 
    -0.05604074f, 0.03429929f, 0.19363013f, -0.17237492f, -0.04288622f, 0.10052323f, -0.20332779f, -0.20338091f, 
    0.08133277f, -0.01162397f, -0.10451005f, 0.11185195f, -0.34792507f, 0.03341848f, -0.08687624f, -0.14056206f, 
    -0.03339476f, -0.04392501f, -0.25948220f, -0.23109631f, -0.32326782f, 0.19361840f, 0.07763311f, 0.21953420f, 
    0.02038412f, -0.12974086f, 0.01770050f, 0.18057711f, 0.05515983f, 0.29414237f, -0.06655389f, -0.09288713f, 
    0.10462370f, 0.06494889f, -0.10903033f, 0.09277298f, 0.08968785f, -0.01481527f, 0.14922386f, 0.00691348f, 
    0.08916567f, 0.17344329f, -0.06663693f, -0.03939382f, -0.03265700f, -0.01331065f, 0.10727461f, 0.05633321f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.08970753f, 0.04256600f, -0.00557946f, 0.18019670f, 0.15350299f, 0.11451507f, 0.12269872f, -0.03851766f, 
    -0.01269205f, 0.04648324f, 0.03232548f, -0.00670992f, 0.02061573f, 0.01563663f, 0.16671453f, -0.06608076f, 
    -0.02169758f, 0.10188312f, -0.04148493f, -0.04837334f, 0.01672067f, 0.02852875f, 0.09003641f, 0.02324325f, 
    0.09279867f, -0.08972535f, 0.18438502f, -0.04687034f, 0.15854080f, 0.07995471f, -0.00554959f, 0.14575569f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.22489387f, 0.07204091f, -0.02112735f, 0.16338421f, 0.29046753f, 0.69394183f, 0.14084350f, 0.32287404f, 
    0.22855733f, -0.02295160f, 0.09612516f, -0.00701749f, -0.33422491f, -0.25128660f, -0.23011898f, 0.12657276f, 
    -0.08224270f, -0.35502151f, 0.17550679f, 0.07435587f, -0.13638675f, 0.17372441f, 0.00327770f, 0.09186468f, 
    0.04272676f, 0.03369695f, 0.03409524f, -0.13056119f, 0.13029571f, 0.05064373f, 0.00608419f, 0.14795882f, 
    0.08000565f, -0.02037159f, 0.08917262f, 0.19768320f, -0.06963917f, -0.24442513f, -0.19652230f, -0.23065065f, 
    -0.02241983f, -0.12360649f, -0.14375830f, 0.00067241f, 0.23251186f, -0.18269528f, -0.51935482f, 0.17408557f, 
    -0.27596897f, 0.50520527f, -0.19741996f, 0.10366219f, 0.02272191f, 0.16777141f, 0.14788251f, 0.25730488f, 
    -0.20471635f, -0.26573199f, -0.05266438f, 0.03864795f, 0.23987775f, 0.09440798f, 0.05186007f, 0.18625000f, 
    -0.08236813f, -0.10048868f, -0.07671892f, 0.30569538f, -0.07151081f, 0.14495549f, 0.12688021f, 0.16624019f, 
    -0.58186054f, -0.05382316f, 0.13357998f, 0.08440834f, -0.28816456f, -0.12871392f, -0.73005968f, -0.09780519f, 
    -0.06654897f, -0.43006721f, 0.11080961f, -0.04730916f, 0.02292836f, 0.16283548f, 0.20091829f, -0.26300752f, 
    -0.03776204f, -0.01342431f, -0.15246046f, 0.23982766f, 0.20426388f, 0.22924350f, 0.11945274f, 0.07849657f, 
    0.00849940f, 0.29825044f, -0.09500991f, 0.12667334f, -0.42842796f, -0.23376645f, -0.50182205f, 0.04829977f, 
    0.05958849f, -0.19268146f, 0.15782923f, 0.00563771f, -0.09034879f, 0.13498458f, 0.12435428f, 0.11088898f, 
    0.38228562f, -0.14107549f, 0.17591052f, 0.10255441f, 0.03329320f, -0.14163367f, -0.12778221f, -0.15339160f, 
    -0.32976604f, 0.20972613f, -0.01733330f, -0.35856667f, -0.16651186f, 0.27386990f, -0.11331441f, 0.07694632f, 
    0.25575867f, -0.11638555f, -0.11546973f, 0.10318790f, -0.16461976f, -0.10678713f, 0.08995400f, -0.26395941f, 
    0.01541505f, 0.21347098f, -0.11279126f, -0.07300653f, 0.16309156f, 0.01334121f, 0.36036026f, -0.05026409f, 
    0.07618783f, 0.39752039f, -0.28477448f, 0.13784443f, 0.24964371f, 0.17386036f, 0.18639775f, -0.04645905f, 
    0.08653776f, -0.25793937f, -0.02364587f, -0.18366568f, 0.13192314f, -0.15554170f, -0.11261086f, 0.09874669f, 
    0.06780633f, -0.02030369f, 0.02464586f, -0.03687368f, 0.24253023f, 0.27263948f, 0.21713537f, -0.36220193f, 
    0.46448216f, 0.04300093f, -0.09571408f, 0.05084177f, -0.07934552f, -0.23744017f, 0.12687881f, -0.16054668f, 
    -0.06799833f, -0.04769939f, -0.19688025f, 0.15799399f, -0.01703219f, 0.16389704f, 0.13184415f, 0.25350252f, 
    0.03398654f, 0.17516077f, 0.34615567f, -0.09709314f, 0.00014067f, 0.16515446f, -0.16486296f, 0.06190936f, 
    0.24339446f, -0.02041813f, 0.02983184f, 0.19834059f, 0.09064464f, 0.16392112f, -0.15558311f, -0.34595913f, 
    -0.32637843f, -0.18261096f, -0.15859823f, -0.00322189f, 0.52504629f, -0.09107918f, -0.35101652f, -0.15547055f, 
    0.02170520f, 0.26514345f, -0.21803561f, 0.04533695f, 0.02277554f, -0.08507993f, 0.06055558f, 0.22203791f, 
    -0.01347779f, -0.14034684f, -0.04750732f, 0.05568664f, 0.16212742f, -0.09054136f, 0.12504879f, 0.07283366f, 
    0.04332532f, 0.00574922f, -0.07247583f, -0.04731510f, 0.28445569f, 0.03982182f, 0.05353817f, 0.03058431f, 
    0.21047227f, -0.12028011f, 0.07080258f, 0.05929929f, 0.53631270f, 0.13459904f, -0.00376859f, 0.02514444f, 
    0.05767458f, -0.04048049f, -0.06816664f, 0.13610354f, 0.28549439f, 0.05694550f, -0.15429622f, 0.21776812f, 
    0.24829131f, 0.04146126f, -0.21276946f, 0.16179919f, -0.13356918f, -0.03839651f, 0.08721332f, -0.03174931f, 
    -0.27631864f, 0.00317249f, 0.03012260f, 0.23105486f, -0.07283914f, 0.11815562f, 0.09208015f, 0.04316499f, 
    0.26717341f, -0.04663985f, -0.13837039f, -0.14433873f, 0.01076217f, -0.09598257f, 0.16432647f, 0.17062204f, 
    0.29894382f, -0.20084792f, -0.23993802f, -0.07595225f, -0.17237431f, -0.10181492f, -0.22261013f, -0.04796448f, 
    0.10176341f, 0.10642164f, -0.11606149f, -0.16786815f, -0.24752963f, 0.27491835f, -0.03386236f, 0.24004106f, 
    -0.14465457f, -0.07459893f, 0.06772752f, 0.13889937f, -0.48372141f, 0.28611645f, 0.06585097f, -0.09924595f, 
    -0.12743729f, -0.12506282f, 0.00865827f, 0.11033908f, -0.34468669f, -0.19183673f, 0.42415985f, 0.11665383f, 
    0.19576073f, 0.03464283f, -0.11031145f, -0.18039896f, -0.29279804f, -0.07617503f, -0.11395780f, 0.11386672f, 
    0.18404140f, 0.26299968f, -0.14993337f, -0.34317425f, -0.10433009f, 0.00140986f, 0.06888084f, 0.22799611f, 
    -0.02234752f, 0.12195472f, 0.09726813f, -0.08851496f, -0.09418070f, 0.03615882f, -0.25895041f, 0.02520820f, 
    0.01343539f, -0.00547422f, 0.12139218f, -0.13399325f, -0.27749991f, 0.03315968f, 0.23536898f, 0.00571338f, 
    0.14216657f, 0.01790477f, 0.02878866f, 0.17978746f, 0.09127384f, -0.05382018f, -0.20828341f, -0.19520468f, 
    -0.10612168f, -0.06406893f, -0.09620384f, 0.01327147f, 0.06893205f, 0.00629039f, -0.07696021f, -0.15379104f, 
    -0.07819602f, -0.19267282f, -0.15394713f, 0.05413691f, 0.16711545f, -0.11502728f, 0.19964887f, 0.21164136f, 
    -0.08636136f, 0.01630582f, -0.04577227f, 0.09232405f, 0.06594621f, -0.13259423f, -0.19111410f, -0.04671269f, 
    0.07002240f, -0.01019661f, 0.24645296f, -0.03458719f, 0.19504321f, 0.14269376f, 0.25911316f, -0.13909613f, 
    0.16500784f, 0.00462223f, 0.26089954f, 0.02846987f, 0.16757795f, -0.25255808f, -0.08294415f, -0.13695963f, 
    0.10790453f, 0.09029589f, 0.05318431f, -0.16255666f, -0.10016917f, 0.06142507f, -0.14643602f, -0.06009390f, 
    -0.02288022f, -0.17045599f, -0.03173542f, -0.14543641f, 0.00662100f, -0.17184901f, 0.12035850f, -0.00977828f, 
    -0.07965099f, 0.05860597f, 0.00695429f, -0.07330521f, -0.02802479f, -0.01749258f, 0.00447201f, 0.02903003f, 
    -0.11668409f, -0.17276362f, -0.16455299f, -0.06489784f, -0.14411278f, -0.11823055f, -0.17281041f, 0.09068661f, 
    0.02432577f, 0.21935675f, -0.08454162f, 0.11208797f, 0.11267844f, 0.24233662f, -0.01585240f, -0.04214380f, 
    0.10545538f, -0.01245732f, 0.16175292f, 0.05010401f, 0.16337319f, -0.10919951f, 0.20613697f, 0.17318006f, 
    0.21061425f, 0.17049159f, 0.12939419f, -0.15807109f, 0.41561478f, 0.17134173f, -0.27832317f, 0.08379990f, 
    0.19221303f, -0.07809953f, -0.22344697f, 0.08679366f, -0.03160170f, 0.10549016f, 0.03772549f, 0.00192947f, 
    0.09653456f, 0.15375265f, -0.02570560f, 0.26874787f, -0.46466416f, -0.02075015f, -0.29281229f, 0.15611745f, 
    -0.15745047f, 0.00824928f, -0.11767214f, -0.13786735f, 0.12987535f, 0.15698345f, 0.40581816f, -0.00293472f, 
    0.12010749f, -0.26093265f, 0.22003154f, 0.05875651f, 0.21734139f, 0.09239158f, -0.14163806f, -0.38640440f, 
    -0.35087237f, 0.06950133f, -0.03476926f, -0.15414506f, 0.06775823f, 0.08824481f, 0.14859429f, 0.18185900f, 
    0.23404460f, 0.01440042f, -0.05594659f, 0.25955740f, 0.19530156f, 0.05831911f, 0.06406838f, -0.15483293f, 
    -0.18793856f, -0.05869741f, -0.15099585f, -0.09121852f, 0.23896620f, -0.38205296f, -0.19748880f, 0.06576471f, 
    -0.10005350f, 0.00816921f, 0.08679069f, 0.06135742f, 0.36979681f, 0.13822444f, 0.26419330f, -0.18530858f, 
    -0.12240843f, -0.12813897f, 0.30046681f, -0.07912603f, 0.24540566f, 0.00818308f, -0.10034769f, -0.10774192f, 
    0.05654853f, 0.08605161f, 0.00439457f, -0.21802334f, -0.29948893f, -0.18079539f, 0.09914938f, 0.01315527f, 
    -0.07443008f, 0.09926098f, -0.11876933f, 0.00035602f, -0.30891478f, 0.20999913f, 0.59011257f, -0.08833210f, 
    0.18943962f, -0.07276616f, -0.16417469f, 0.04514186f, -0.19801988f, -0.09668837f, 0.21417955f, 0.02885932f, 
    0.08252949f, 0.25416875f, -0.05461238f, -0.22346841f, -0.08705795f, 0.22578505f, 0.07769323f, 0.11896656f, 
    -0.01998252f, 0.04626910f, -0.10737354f, 0.24676730f, 0.01645976f, -0.23617949f, -0.25764084f, -0.11793081f, 
    -0.17153567f, -0.11898368f, -0.08153429f, 0.07663515f, -0.17402375f, 0.13756333f, -0.41624883f, 0.10767481f, 
    0.05685134f, -0.00009163f, -0.07653362f, 0.10238826f, -0.16777362f, 0.00360577f, 0.00643915f, -0.26723361f, 
    -0.17191590f, 0.22132671f, 0.24924231f, -0.03529253f, -0.14675918f, -0.05440780f, 0.09975246f, -0.02917053f, 
    -0.03603607f, -0.32345378f, -0.13822402f, 0.28156343f, -0.33197588f, 0.13692352f, 0.02387493f, -0.17651395f, 
    0.16324764f, 0.17899927f, 0.03398181f, 0.01453818f, -0.01100848f, -0.27646631f, 0.01846350f, 0.03196310f, 
    -0.09808498f, -0.13675819f, -0.10791681f, 0.06150778f, -0.19852149f, -0.04692649f, 0.27908728f, 0.01284207f, 
    0.12143158f, 0.19298522f, 0.32538217f, -0.15927683f, 0.01010226f, -0.02542438f, -0.06538974f, 0.10934336f, 
    0.27937064f, 0.12790728f, -0.06644175f, -0.09598508f, 0.24476190f, 0.49451777f, -0.25428700f, -0.12326986f, 
    -0.01823282f, -0.16710734f, 0.08135738f, -0.07113556f, 0.44964686f, -0.31459469f, -0.07425777f, -0.13071989f, 
    0.31871474f, 0.21254580f, -0.10982558f, -0.05508030f, 0.06046483f, -0.16396616f, 0.01016916f, 0.21232443f, 
    -0.01477909f, 0.20941094f, -0.32065096f, -0.26549485f, 0.02529611f, 0.08532342f, -0.12054125f, -0.11923858f, 
    -0.01294169f, -0.03914934f, 0.09383333f, 0.16336420f, -0.23372594f, -0.43080294f, 0.02341742f, -0.11154775f, 
    -0.20971441f, 0.03485372f, 0.10456272f, 0.17174302f, -0.01902403f, 0.21015954f, 0.44165635f, -0.08646440f, 
    0.22363751f, 0.21645975f, -0.19061826f, 0.01235134f, -0.07510489f, -0.03994585f, -0.08612015f, 0.13777220f, 
    0.29140201f, -0.13947962f, 0.08099409f, -0.05509398f, -0.09592830f, 0.21371518f, 0.03121759f, 0.26431778f, 
    0.10807697f, 0.41303840f, 0.09581722f, 0.05639155f, -0.32715401f, -0.22339675f, -0.38807699f, 0.13292614f, 
    0.07913203f, -0.11127730f, -0.07457551f, 0.11436956f, -0.43016306f, 0.01728427f, 0.04973071f, -0.12491799f, 
    0.25032452f, 0.12337518f, 0.10833057f, 0.11695586f, 0.02539815f, 0.14642206f, 0.05389191f, -0.18866435f, 
    -0.37215665f, 0.02865723f, 0.03606622f, 0.01273472f, 0.05219161f, 0.07877124f, -0.13908763f, 0.19607510f, 
    0.15796970f, 0.05664289f, -0.12353804f, 0.19491389f, 0.15149666f, 0.17714159f, 0.19499466f, 0.23641726f, 
    0.05422198f, -0.16902672f, 0.13622569f, 0.11017782f, 0.07334576f, -0.14403962f, -0.31978112f, -0.12576662f, 
    -0.22512493f, -0.05598052f, 0.17265667f, 0.03794630f, 0.40379533f, -0.07948166f, 0.14917503f, 0.18359330f, 
    0.20978208f, -0.19053112f, 0.02056153f, -0.03847229f, 0.12960798f, -0.20361310f, 0.11749555f, 0.04933714f, 
    0.07014276f, 0.17452215f, 0.08765905f, -0.03747757f, -0.08140182f, -0.26647234f, -0.13948143f, 0.00356048f, 
    0.12026819f, -0.14270797f, -0.11531024f, 0.02948861f, 0.03484074f, -0.07176179f, 0.23394452f, -0.00229052f, 
    0.41351065f, 0.30086657f, -0.05065296f, 0.13484715f, -0.24068533f, -0.03484603f, -0.11164156f, 0.05001144f, 
    -0.00709042f, 0.22738758f, -0.32729501f, -0.23792839f, -0.08872095f, 0.26190755f, 0.04412085f, 0.16230376f, 
    0.05640154f, -0.20106645f, -0.13896222f, -0.12547445f, 0.19018887f, 0.59702611f, 0.19342992f, 0.00275572f, 
    0.12010255f, -0.21819040f, 0.17129654f, -0.02010957f, 0.26141754f, -0.11251859f, 0.01045552f, 0.05788261f, 
    0.28532469f, -0.18789145f, -0.05569332f, -0.14304960f, -0.10897858f, 0.13041386f, 0.01029794f, -0.06852336f, 
    0.31857663f, 0.26136336f, -0.13325121f, 0.05685538f, 0.00197895f, -0.06183926f, -0.13966243f, 0.00304962f, 
    0.19163731f, -0.11359771f, -0.09603410f, -0.07207061f, -0.14243118f, 0.29640797f, 0.08469959f, -0.16673473f, 
    0.35612780f, -0.16015564f, -0.07828211f, -0.07323388f, 0.21765354f, -0.09692857f, -0.36822030f, -0.07164935f, 
    0.00273565f, 0.19918843f, -0.07194731f, -0.03435197f, -0.16728519f, -0.10253262f, -0.14585164f, 0.21899064f, 
    0.21813394f, -0.05421508f, -0.16392276f, 0.12406373f, 0.22131422f, 0.06375983f, 0.08960218f, 0.06550620f, 
    -0.06694691f, -0.01319487f, 0.04409544f, 0.19278371f, -0.35811171f, 0.24792562f, -0.14928964f, -0.03108915f, 
    -0.18289538f, 0.26151279f, -0.09466746f, -0.11922210f, -0.17933810f, -0.33782202f, 0.45055521f, -0.08412547f, 
    -0.07014083f, -0.03888828f, 0.07398131f, 0.10645828f, 0.24772760f, 0.17081186f, 0.13585803f, -0.11630695f, 
    -0.28275958f, -0.29568717f, 0.50064290f, -0.44220680f, 0.17753486f, -0.12239942f, -0.11402121f, 0.05899232f, 
    -0.20598304f, -0.07745921f, -0.16683722f, 0.26631930f, -0.39247358f, 0.58927834f, 0.27944526f, 0.09705932f, 
    0.24563108f, 0.16372640f, 0.06451542f, 0.12914363f, -0.01727747f, -0.32097816f, 0.40337133f, 0.07084344f, 
    -0.17050441f, -0.16257963f, -0.16763791f, 0.04779257f, -0.28135034f, 0.11483871f, -0.01329661f, -0.00731675f, 
    0.00659454f, 0.21006118f, 0.36242431f, -0.07647937f, -0.07233983f, -0.04337410f, 0.02197390f, -0.08208110f, 
    -0.21759160f, -0.05955874f, 0.03342013f, 0.13935785f, -0.25061652f, 0.00819158f, -0.11726059f, -0.14912437f, 
    0.17876206f, -0.39926162f, -0.08642206f, -0.00497280f, 0.32615608f, -0.17748675f, -0.26970977f, 0.03296685f, 
    0.22088626f, 0.23908022f, -0.21748917f, -0.06711259f, -0.34293160f, 0.08000064f, -0.09457236f, 0.25176230f, 
    -0.07209000f, 0.26639670f, 0.11710592f, -0.40585792f, -0.05394446f, 0.28219008f, -0.05700330f, 0.23796397f, 
    -0.12063283f, 0.26839367f, 0.11429747f, 0.08711708f, 0.14112955f, -0.12965998f, 0.34262878f, 0.44327828f, 
    -0.13904679f, 0.03327573f, 0.15869208f, -0.00606352f, -0.24902166f, -0.21928684f, -0.04078512f, 0.01391899f, 
    -0.18101394f, -0.07421534f, -0.05932020f, 0.07591587f, 0.22635087f, 0.05560935f, 0.15430640f, -0.21258087f, 
    0.23171277f, -0.07622620f, -0.15263942f, 0.23408888f, 0.07347371f, 0.07855793f, -0.04740100f, -0.01413618f, 
    0.04825782f, -0.18654512f, -0.13148977f, 0.14634602f, 0.22397363f, -0.22798221f, 0.15299153f, -0.18587315f, 
    0.06666865f, 0.14730202f, -0.03945762f, -0.12444553f, 0.28815016f, -0.27853101f, 0.14126664f, 0.02114994f, 
    -0.23773481f, 0.25567189f, 0.07109693f, -0.11463674f, 0.27677974f, 0.13880430f, 0.12601171f, 0.11742474f, 
    0.11315995f, -0.32442790f, 0.33312708f, -0.05241573f, 0.18406074f, -0.12755877f, 0.03634094f, 0.02314748f, 
    -0.08485037f, -0.00025383f, 0.09928042f, -0.01547333f, -0.16722459f, -0.12973727f, -0.04412884f, -0.07736113f, 
    -0.02166520f, -0.04907440f, 0.02697984f, -0.00555232f, -0.08685809f, -0.01891806f, 0.01247014f, 0.00334812f, 
    -0.12056490f, 0.11069494f, -0.09814898f, -0.01649965f, -0.10951020f, 0.05233589f, -0.17826147f, -0.04564684f, 
    -0.14080939f, -0.20362100f, 0.03531398f, 0.04845026f, 0.02877826f, -0.00568350f, 0.12008025f, -0.22911929f, 
    0.11389825f, -0.12521228f, 0.10541555f, 0.18679558f, -0.09175760f, -0.57251745f, 0.00491953f, 0.13518952f, 
    -0.01593662f, 0.20962536f, 0.13838108f, 0.11334969f, -0.19570892f, 0.10398413f, -0.13211451f, -0.02460464f, 
    -0.15842967f, 0.34679365f, -0.09616165f, -0.12294467f, -0.09555116f, -0.07202636f, 0.08921794f, 0.20386791f, 
    0.21212849f, -0.17452438f, 0.43276748f, -0.14034830f, 0.12158617f, 0.07628057f, 0.06438774f, 0.18883561f, 
    -0.05567895f, -0.14522240f, -0.12772594f, -0.08470969f, 0.08713251f, -0.18675739f, 0.12817921f, -0.06836789f, 
    0.05792936f, -0.20808665f, 0.03412565f, 0.00162316f, 0.11094554f, -0.04718817f, -0.11154594f, 0.15498480f, 
    -0.11312880f, -0.00109294f, 0.06468102f, 0.01931629f, 0.14851506f, 0.16407801f, -0.12500316f, -0.14084458f, 
    -0.00151924f, -0.11005275f, -0.17724922f, 0.01085258f, -0.09061019f, 0.07164427f, 0.05342413f, -0.07452977f, 
    0.08124891f, 0.11693288f, -0.11087400f, -0.06261729f, 0.19000076f, 0.44718978f, -0.19661474f, -0.14627683f, 
    0.11539370f, 0.02493941f, -0.00587952f, -0.14480358f, 0.39499196f, -0.27139211f, -0.36390445f, 0.10439444f, 
    -0.12774791f, 0.27794600f, 0.14947632f, -0.10302840f, 0.09772024f, 0.14056799f, 0.23860230f, 0.02947764f, 
    -0.23458016f, 0.13807492f, 0.07343192f, -0.18787697f, 0.14592616f, -0.05421879f, 0.07136719f, -0.05937018f, 
    0.18725149f, 0.29044670f, -0.01492334f, 0.20053740f, 0.19436558f, -0.02729638f, -0.09231097f, 0.01700720f, 
    -0.18548892f, 0.13316001f, 0.00708254f, -0.03530908f, 0.10130934f, -0.35330880f, 0.04998576f, -0.05335940f, 
    0.18004964f, -0.07930290f, 0.15244353f, 0.11212990f, -0.04578862f, -0.01076244f, 0.26569223f, 0.02371079f, 
    -0.38530508f, 0.02634437f, 0.06469332f, -0.00206275f, 0.07828324f, -0.16442907f, 0.07782951f, 0.02492071f, 
    0.08401621f, 0.21300656f, 0.04678617f, -0.19462880f, 0.13915353f, -0.13001664f, 0.18997779f, 0.14198180f, 
    0.03891208f, 0.18954939f, -0.09727278f, 0.15462568f, 0.25051126f, 0.17747705f, 0.08456174f, -0.04944384f, 
    -0.05626263f, -0.07809263f, 0.04195654f, 0.17168136f, 0.24190016f, 0.05626804f, -0.15912899f, 0.14946873f, 
    0.13411157f, 0.15896286f, -0.32909131f, 0.18018655f, -0.11729438f, 0.14064208f, 0.03391058f, -0.03843012f, 
    0.15341289f, -0.04510222f, -0.10176096f, -0.16324702f, 0.08731276f, 0.19981717f, 0.34424108f, 0.07218099f, 
    -0.13470726f, -0.14492686f, 0.12863146f, -0.06115134f, 0.35832533f, -0.00194742f, 0.38636938f, 0.04477827f, 
    0.30351612f, 0.06345640f, -0.21059796f, -0.15936182f, 0.16078040f, 0.17496297f, -0.23077060f, -0.05705399f, 
    0.28313634f, -0.11915568f, 0.03824663f, 0.08464497f, -0.06046667f, 0.12044574f, -0.09890670f, 0.16045545f, 
    0.18604828f, 0.20696779f, -0.12579446f, 0.28772223f, 0.16771054f, -0.00611779f, -0.29947019f, -0.05707187f, 
    -0.18051663f, -0.09333229f, -0.02978287f, 0.14277089f, 0.38641128f, 0.06774122f, 0.00346349f, -0.15338348f, 
    0.36805621f, -0.11219681f, -0.00092558f, 0.11224953f, -0.06547210f, -0.05050561f, -0.05128611f, -0.10248563f, 
    -0.28764430f, -0.01207257f, -0.31913340f, 0.17717893f, 0.05437078f, 0.17087623f, 0.01103920f, 0.13756005f, 
    0.02021461f, -0.18932214f, -0.13318598f, 0.15522490f, -0.14376527f, 0.23329368f, -0.12202091f, -0.20634799f, 
    0.03938100f, -0.10391757f, -0.09072655f, 0.00002556f, 0.55407089f, -0.03709311f, -0.08570218f, -0.10037268f, 
    -0.04047458f, -0.29000264f, 0.45637280f, -0.15272598f, -0.28526908f, 0.06130442f, 0.12958428f, -0.13763735f, 
    -0.32285708f, -0.11739905f, 0.41755009f, -0.11337067f, -0.03912057f, 0.02475725f, -0.05765554f, 0.20066833f, 
    0.02854352f, 0.10076977f, 0.11202392f, 0.30364481f, 0.14779234f, 0.43844122f, 0.09196790f, 0.07736246f, 
    -0.28563756f, 0.17904112f, -0.11818421f, 0.05223441f, -0.19981246f, -0.36391705f, 0.26557457f, -0.02207668f, 
    0.05534201f, -0.05157492f, -0.12169977f, -0.13251145f, 0.27465916f, -0.04395431f, 0.01947406f, -0.17738208f, 
    -0.16374345f, -0.25836837f, 0.00539028f, 0.04695132f, 0.23126066f, -0.06785871f, -0.01218084f, -0.01456616f, 
    -0.10991880f, -0.01554990f, -0.06719159f, -0.16269284f, 0.01132954f, -0.05034179f, -0.20624532f, -0.02124131f, 
    0.12604380f, 0.14321741f, -0.01450446f, -0.08024831f, -0.11928887f, -0.04720712f, 0.11310999f, -0.07946891f, 
    -0.08891346f, 0.14607589f, -0.11770495f, 0.05780340f, 0.09293365f, -0.02899608f, -0.09284084f, 0.02963396f, 
    0.12535125f, -0.05980911f, -0.22084874f, -0.10718817f, -0.08767792f, -0.12724672f, 0.07043640f, -0.21849008f, 
    -0.19387329f, 0.02437751f, -0.03341672f, -0.02197653f, -0.15328507f, -0.14446625f, 0.15527754f, 0.04083788f, 
    -0.15826112f, -0.10882106f, -0.16381457f, -0.10337528f, -0.06324654f, -0.10879142f, 0.09697162f, 0.06624112f, 
    0.06923950f, -0.12208866f, 0.03964775f, 0.01843594f, 0.10226906f, 0.09825061f, 0.11126483f, -0.02117866f, 
    0.01477620f, -0.07341358f, 0.05159500f, -0.09740144f, -0.10725848f, -0.20544341f, 0.11167827f, -0.19270486f, 
    -0.02211617f, -0.18354882f, 0.12684709f, 0.20960841f, -0.19516356f, -0.13981384f, 0.24870251f, -0.11730767f, 
    -0.03876326f, 0.03029980f, 0.07656212f, -0.14193018f, -0.10151169f, -0.18055062f, -0.10421152f, -0.04733713f, 
    -0.11910672f, 0.19204190f, -0.14510575f, -0.01252708f, 0.04653513f, -0.11069326f, 0.26944679f, 0.31286281f, 
    0.44871390f, -0.18704720f, 0.09315865f, -0.14287247f, 0.09436255f, -0.06627890f, -0.06475835f, 0.09672315f, 
    0.09568802f, 0.16324715f, 0.00786704f, -0.21426147f, 0.07270605f, -0.05047464f, -0.08481602f, 0.11577771f, 
    0.40485281f, 0.16353622f, -0.03294372f, -0.08731119f, -0.37767324f, -0.23303145f, -0.39273670f, -0.00121407f, 
    0.00649436f, 0.45298755f, 0.13890049f, -0.02231881f, -0.28568840f, -0.03793070f, 0.13962094f, -0.00173941f, 
    -0.18647127f, 0.25290307f, 0.05653633f, -0.04658248f, 0.27895883f, 0.23425239f, -0.06882845f, -0.01871516f, 
    -0.05303612f, 0.06785534f, -0.03179320f, 0.15162273f, -0.18250383f, -0.33540696f, -0.09372188f, 0.16695829f, 
    -0.12619853f, 0.11332125f, 0.13102344f, -0.01356380f, -0.38761386f, 0.03136979f, -0.16487496f, -0.09377860f, 
    -0.21010605f, 0.24055669f, -0.13790564f, -0.09647822f, 0.29480907f, 0.17256030f, 0.00677075f, 0.20155549f, 
    0.23243943f, -0.24092619f, 0.41942278f, 0.08525855f, 0.15713565f, -0.02966238f, 0.14920871f, 0.07124485f, 
    0.28510776f, -0.01511001f, 0.15855281f, -0.13749193f, -0.14783601f, -0.12755235f, -0.29181239f, -0.09489865f, 
    0.08236593f, 0.11634223f, 0.12011886f, -0.11700478f, 0.28846061f, -0.02981227f, 0.15366909f, -0.03511664f, 
    0.21386619f, 0.07181475f, 0.29523140f, 0.11100933f, -0.07151971f, 0.14965919f, 0.13772005f, 0.10549658f, 
    -0.37914279f, -0.15206946f, -0.15419510f, -0.18900567f, 0.09148671f, -0.03685522f, 0.07884336f, 0.18894717f, 
    -0.00533653f, 0.03499942f, -0.11073328f, 0.32134226f, -0.20485234f, 0.62717116f, 0.34349608f, -0.31919914f, 
    -0.01774556f, 0.03861999f, -0.12126224f, -0.16731742f, 0.08076519f, -0.36284220f, 0.51060450f, 0.13340880f, 
    0.14562175f, -0.26856908f, -0.18651916f, -0.08188684f, -0.04417375f, -0.00767142f, -0.15495662f, 0.08733373f, 
    -0.08789034f, 0.01156553f, 0.27254289f, 0.02321508f, -0.08056200f, -0.14739166f, -0.09938371f, 0.14021870f, 
    0.14331307f, -0.10323405f, -0.03772004f, -0.04885256f, -0.39283291f, -0.33200368f, -0.23423034f, -0.27523628f, 
    0.10861269f, 0.03991733f, -0.06133563f, -0.15031841f, 0.37590304f, 0.16514280f, 0.37703729f, 0.09233290f, 
    0.13315910f, 0.37737519f, 0.03320364f, -0.17593032f, -0.29749349f, -0.16550070f, -0.09357773f, 0.20422836f, 
    0.11536579f, 0.01227271f, -0.14750934f, -0.33991835f, 0.14112093f, 0.09822094f, -0.04916153f, 0.29265675f, 
    0.04533146f, -0.19898498f, -0.06240965f, 0.11300083f, -0.16319537f, -0.24140529f, 0.27609792f, 0.13820679f, 
    -0.11936399f, 0.16291890f, -0.14148383f, -0.10524835f, 0.47967300f, 0.12696721f, -0.37129799f, 0.17793377f, 
    -0.16621232f, 0.23616973f, 0.22368604f, 0.09321208f, 0.19643591f, -0.05686956f, -0.02643272f, 0.11042665f, 
    0.08213509f, -0.15336435f, -0.05909496f, 0.14560880f, 0.12865311f, -0.02137836f, -0.05069063f, 0.01438592f, 
    -0.02015596f, -0.00564299f, 0.02177456f, 0.21481974f, 0.21870492f, 0.19123359f, -0.13625751f, 0.15128636f, 
    0.35508612f, 0.02808901f, -0.16473088f, 0.01542447f, -0.49511656f, -0.22713296f, -0.02945183f, -0.08587381f, 
    -0.20677727f, 0.15532048f, -0.18643685f, -0.01394982f, -0.13433780f, -0.12573189f, 0.05652802f, 0.00642949f, 
    0.17919381f, 0.06148658f, 0.24562967f, -0.14094345f, 0.21561721f, 0.18565139f, -0.04388189f, -0.03493805f, 
    -0.01069485f, 0.21503560f, 0.08166442f, -0.16180785f, -0.15574937f, -0.19349110f, -0.16195185f, -0.25566915f, 
    0.17492917f, 0.01840122f, -0.03983218f, 0.14116344f, -0.13091189f, 0.02858360f, 0.00648460f, 0.03713503f, 
    0.21798818f, 0.17163922f, -0.15753321f, 0.08237487f, -0.23679619f, -0.12642281f, 0.22319423f, 0.16723934f, 
    -0.40185449f, -0.02830316f, 0.19973180f, -0.11277060f, 0.08562894f, 0.08877039f, 0.11517143f, 0.01343016f, 
    0.09711677f, 0.16104458f, -0.11729824f, 0.00800627f, 0.28120118f, -0.04847198f, -0.45690948f, -0.30862489f, 
    0.12700368f, -0.02010018f, -0.06658988f, -0.14661013f, -0.13342671f, -0.09385562f, 0.12581575f, -0.11494026f, 
    0.10828381f, 0.03735492f, -0.03974440f, 0.01363172f, -0.21465655f, -0.08998311f, 0.09340844f, 0.08024602f, 
    -0.12635678f, 0.25200498f, 0.13711296f, -0.28418890f, -0.14900091f, 0.09663717f, 0.15396394f, 0.06169001f, 
    -0.10637384f, -0.17071918f, 0.07599974f, 0.12095697f, -0.53601867f, 0.16837269f, 0.15055938f, -0.16747852f, 
    0.11938800f, 0.15658785f, 0.11816271f, 0.06865760f, 0.07261363f, -0.08937553f, 0.65541923f, 0.12047654f, 
    0.08978773f, 0.01409422f, -0.30835766f, 0.03722808f, -0.06402595f, -0.01897481f, 0.22230437f, 0.04819511f, 
    -0.05776741f, 0.13810161f, 0.18983518f, -0.53530419f, -0.15173057f, 0.18267031f, 0.06736427f, -0.07251520f, 
    0.20383883f, 0.27399611f, 0.11504353f, 0.13464175f, -0.00790717f, -0.11225536f, -0.28521916f, 0.46585467f, 
    -0.32564077f, 0.02779861f, 0.07472868f, -0.04280208f, -0.23123796f, 0.19030996f, -0.01879843f, -0.05080198f, 
    0.20293579f, 0.08939819f, 0.26742378f, -0.15021995f, 0.11692170f, 0.05435942f, -0.07943581f, 0.01598440f, 
    -0.22572264f, 0.20110744f, -0.30624962f, 0.20282212f, -0.08338198f, 0.13225058f, -0.18138032f, -0.07313945f, 
    0.08636471f, 0.28884098f, 0.02944132f, -0.17423466f, 0.08815819f, 0.24644828f, -0.18728371f, -0.13772242f, 
    0.05855241f, -0.27308905f, -0.10521165f, -0.07805897f, 0.27573320f, 0.13692454f, 0.47499228f, 0.06481019f, 
    0.27208605f, -0.01963527f, -0.12513743f, -0.15340057f, 0.02353827f, -0.13278368f, -0.09518126f, 0.12029744f, 
    -0.27414235f, -0.06577741f, -0.09388902f, -0.15594970f, 0.15932827f, 0.22046243f, 0.08956548f, 0.11988121f, 
    -0.10514758f, -0.05047205f, 0.17585450f, -0.10582002f, -0.03828921f, -0.13823223f, -0.03651405f, 0.06433505f, 
    -0.08785049f, 0.07141857f, 0.15946184f, 0.15785627f, 0.14452818f, -0.18702279f, 0.14002118f, -0.16413449f, 
    0.06234168f, 0.04926465f, -0.05438906f, -0.13893968f, 0.20277572f, 0.08452161f, -0.09071746f, -0.14343362f, 
    -0.02614651f, -0.13130546f, 0.17132407f, 0.17197548f, 0.13147709f, -0.20299944f, 0.01656447f, 0.07983700f, 
    0.05591448f, 0.19346771f, 0.12461761f, -0.00337608f, 0.10969472f, 0.01526100f, -0.05415512f, 0.23199376f, 
    0.29110181f, -0.27251711f, 0.17404653f, 0.02906839f, -0.02123442f, -0.08645178f, -0.02024702f, -0.13208975f, 
    0.30312046f, -0.16680975f, 0.06039187f, 0.09197184f, 0.16404377f, -0.15315785f, -0.28443995f, -0.27864745f, 
    -0.13025212f, 0.19214906f, -0.27420583f, -0.14385583f, -0.05813615f, 0.26988184f, -0.10073566f, 0.11909220f, 
    0.26242295f, 0.42181581f, -0.17137580f, -0.09691995f, 0.10936496f, -0.31526974f, -0.28910530f, 0.45407671f, 
    -0.14045186f, 0.06512117f, -0.11792126f, 0.11800475f, -0.41520369f, -0.11283149f, -0.00702837f, 0.00018181f, 
    0.07896031f, 0.10753180f, -0.00026018f, -0.02784089f, 0.30647373f, 0.10927755f, 0.24701911f, 0.05709712f, 
    -0.10784455f, 0.02814283f, 0.13340928f, -0.05402362f, -0.09145194f, 0.09540776f, -0.15128386f, -0.06131431f, 
    -0.08280125f, 0.10626389f, 0.15624219f, 0.02393476f, -0.26837546f, -0.04153416f, -0.19657354f, -0.14998743f, 
    0.29057381f, -0.09765811f, 0.14728351f, -0.13337615f, 0.22215462f, -0.11926764f, -0.10738710f, 0.04513500f, 
    0.11935665f, 0.36726832f, -0.30672213f, 0.01193019f, -0.33518466f, -0.14192070f, -0.03497737f, 0.26404434f, 
    0.26882872f, -0.00240710f, 0.22089113f, -0.46346661f, 0.20450233f, 0.04472433f, -0.15561169f, 0.16727209f, 
    0.23697200f, 0.47763619f, -0.01577361f, 0.15713426f, 0.41446823f, 0.32532725f, -0.09449209f, 0.16284911f, 
    -0.17514439f, -0.15079294f, 0.08795112f, -0.16228442f, -0.00732370f, -0.20898540f, 0.33244771f, -0.04080466f, 
    0.25658593f, -0.19813310f, 0.03266877f, -0.02137513f, 0.53426027f, 0.01735323f, -0.03525615f, 0.06912384f, 
    -0.25945404f, -0.07179137f, -0.12172147f, 0.03776463f, 0.11889077f, -0.10266143f, -0.06053588f, 0.02906317f, 
    0.13498642f, 0.21977141f, -0.09805956f, -0.14739674f, 0.29745933f, 0.13636546f, 0.07657267f, 0.17572023f, 
    0.37681374f, 0.00135701f, 0.03105244f, -0.11672662f, -0.15011433f, -0.19203247f, -0.13981582f, -0.10651558f, 
    -0.06521789f, 0.30875164f, -0.04400507f, 0.15456787f, 0.13671188f, 0.15080126f, 0.06913892f, -0.00757530f, 
    0.11142199f, -0.12967336f, -0.13446997f, -0.05409131f, -0.09970485f, 0.23742956f, 0.13693568f, 0.10340008f, 
    0.04390132f, 0.00659004f, 0.04275060f, -0.06032535f, 0.08318613f, -0.11034378f, -0.06369485f, -0.05710672f, 
    0.16473192f, 0.23824435f, -0.02714348f, 0.03268466f, -0.21809520f, 0.25227734f, 0.56450927f, 0.10115036f, 
    -0.00212811f, -0.40075329f, -0.15794913f, 0.08277973f, -0.14591807f, 0.01644465f, 0.06032841f, -0.11483630f, 
    -0.19333267f, 0.26469129f, 0.09464838f, 0.07624760f, -0.10611375f, 0.13002509f, 0.12666239f, 0.03265333f, 
    -0.18918124f, -0.18860173f, 0.07867888f, 0.19781107f, -0.21496306f, -0.04390962f, 0.21016353f, -0.19754760f, 
    -0.02475423f, -0.37001565f, -0.00776692f, 0.09687577f, -0.01814929f, 0.07658081f, 0.33553013f, 0.13389036f, 
    0.09104498f, 0.08925764f, -0.31865677f, -0.17320350f, -0.12648326f, -0.00137792f, -0.17981952f, 0.15730980f, 
    0.18715876f, 0.17872013f, -0.18772545f, -0.07661892f, 0.02825506f, 0.29514554f, -0.12518108f, 0.29270506f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12693170f, 0.00446112f, 0.09374658f, 0.09815645f, 0.38194001f, 0.21350190f, 0.20144551f, -0.14092480f, 
    -0.06330478f, 0.20615508f, -0.10760521f, 0.04687324f, -0.01852038f, 0.12727281f, 0.24057475f, 0.05662451f, 
    0.26258102f, -0.09757154f, 0.04755010f, -0.19957824f, 0.04160253f, 0.12126263f, 0.04036053f, -0.08365570f, 
    0.19490291f, 0.09211772f, 0.24042299f, 0.17057192f, 0.05883443f, -0.08526783f, 0.09139862f, -0.02955453f, 
    0.15861621f, 0.00485283f, 0.19433908f, 0.00685803f, -0.11717468f, 0.25569695f, -0.00949834f, 0.17444159f, 
    0.18773875f, -0.08754171f, -0.13674025f, 0.29557708f, 0.15331446f, 0.20854074f, 0.25480717f, -0.03301711f, 
    0.25476333f, -0.08901201f, 0.17356052f, -0.06795604f, 0.08704270f, 0.18741161f, -0.01809162f, 0.00219437f, 
    -0.15478529f, -0.19046317f, 0.15273422f, 0.08327004f, 0.27894154f, 0.02308763f, -0.17037851f, 0.10305949f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.49182695f, -0.15575159f, -0.43943769f, 0.11884469f, 0.23380065f, 0.12644891f, -0.09155616f, 0.07133611f, 
    -0.17029944f, 0.02497907f, 0.00553771f, -0.06231340f, -0.10599668f, 0.12716348f, 0.01846527f, -0.11424989f, 
    0.23535195f, -0.06747507f, -0.14382735f, 0.03991101f, 0.45459470f, 0.09477070f, -0.01505752f, 0.01636425f, 
    -0.11246353f, -0.11432914f, 0.22351515f, 0.08798452f, -0.17318074f, 0.02619791f, 0.06398679f, 0.13704163f, 
    0.25493586f, -0.13831495f, -0.26962417f, -0.00074615f, 0.12300972f, 0.14178339f, -0.01015037f, -0.25438535f, 
    0.10925947f, 0.04780421f, -0.12549314f, 0.00639349f, -0.03266530f, 0.11055470f, 0.13479610f, 0.42045817f, 
    0.36831698f, 0.05112981f, 0.03575651f, 0.02111489f, 0.08045892f, 0.34197772f, -0.06698835f, 0.33450949f, 
    0.15242904f, 0.00325127f, -0.05245153f, -0.14418000f, 0.11630797f, 0.02329578f, 0.18760356f, 0.11190805f, 
    0.10534777f, 0.32362330f, -0.19613093f, -0.25716501f, 0.30820996f, 0.13331370f, 0.32948360f, 0.03218919f, 
    -0.42776358f, -0.29782629f, 0.13340236f, -0.00105422f, -0.04824705f, 0.16520648f, -0.11292481f, 0.16359946f, 
    -0.04521176f, -0.18795899f, 0.10003677f, 0.22310680f, -0.13483424f, 0.01879153f, 0.24281816f, -0.19168365f, 
    -0.10095750f, 0.11870531f, 0.25354216f, 0.03828872f, -0.17286555f, -0.01245383f, 0.34394985f, 0.01522963f, 
    -0.06133137f, 0.21460438f, 0.32586369f, 0.07306441f, -0.11743595f, -0.03103645f, -0.13985899f, 0.10195478f, 
    0.22311737f, 0.04779906f, 0.05172136f, 0.36999434f, 0.16280375f, -0.01687536f, 0.17009166f, 0.01805334f, 
    -0.06323317f, 0.03997349f, -0.00239508f, 0.12833215f, -0.08191336f, -0.11023208f, -0.15471911f, -0.27721837f, 
    0.07778055f, -0.02858640f, -0.11502663f, -0.00417482f, 0.09090339f, 0.23918054f, -0.14157440f, -0.18261370f, 
    0.39356235f, -0.16280833f, 0.35714850f, -0.12035608f, -0.07091455f, 0.29057661f, -0.14659694f, -0.26119331f, 
    0.12186375f, 0.29507858f, -0.11331762f, 0.30830035f, 0.08453842f, -0.13748655f, 0.05225071f, 0.22054686f, 
    -0.00564238f, 0.05146801f, 0.49703324f, 0.00045979f, -0.16361716f, 0.06126214f, 0.15150483f, -0.16304579f, 
    0.19648007f, -0.01127363f, 0.11475793f, 0.56840104f, 0.15225761f, -0.00998446f, 0.25924727f, 0.09587035f, 
    -0.07109359f, 0.04704499f, 0.21901037f, 0.18856108f, -0.37409648f, -0.19729626f, -0.12066282f, 0.40696168f, 
    0.24495792f, 0.08462969f, -0.01448119f, 0.10751800f, 0.15943766f, -0.08535344f, -0.01184641f, 0.59834832f, 
    -0.15628815f, -0.06468186f, 0.26076519f, -0.00358522f, 0.16233338f, 0.27688074f, -0.15727885f, -0.14472950f, 
    0.00449536f, -0.18526548f, -0.16585943f, -0.02128901f, -0.05755431f, -0.14297575f, 0.14484732f, -0.06203093f, 
    -0.02482811f, 0.24361716f, 0.15823106f, -0.10202868f, 0.03878813f, -0.00164634f, 0.14334074f, 0.01629519f, 
    -0.09930467f, 0.04813210f, 0.10818118f, 0.13002902f, -0.12121589f, -0.04760245f, 0.11822668f, -0.00937029f, 
    0.06246445f, -0.06889033f, 0.17568877f, -0.14971463f, 0.04030090f, -0.09321847f, -0.12046777f, -0.10931748f, 
    0.06741867f, -0.01294393f, -0.11429639f, -0.20021628f, 0.09552643f, -0.21874551f, 0.08528626f, 0.04900615f, 
    0.06518485f, -0.00956030f, -0.03732767f, -0.09935536f, -0.15432386f, 0.17436410f, 0.04398296f, 0.21085098f, 
    -0.05606252f, 0.02183119f, -0.04705532f, 0.21083996f, -0.18457012f, 0.03441505f, 0.09106470f, -0.38049078f, 
    -0.09599134f, 0.07233439f, -0.00298126f, 0.01033741f, -0.05261797f, -0.00521608f, -0.04625136f, 0.00298924f, 
    -0.01526140f, -0.19043593f, -0.04367755f, -0.00763578f, -0.23383875f, -0.16611809f, -0.01220522f, 0.00192228f, 
    -0.12374734f, 0.44820803f, -0.24239884f, 0.08516286f, 0.19737585f, 0.08686320f, 0.27090406f, -0.12722835f, 
    -0.24534662f, -0.06501636f, -0.09538098f, -0.04885516f, 0.11937432f, -0.02513598f, 0.05250551f, -0.02588718f, 
    -0.12729405f, -0.02434028f, 0.24686356f, 0.05800050f, 0.24107049f, 0.02579801f, 0.15287140f, -0.06052274f, 
    -0.24802575f, 0.06168128f, 0.24104229f, -0.08342998f, -0.01853922f, -0.11590052f, 0.05937499f, -0.09698066f, 
    0.18763617f, 0.06895234f, -0.02563514f, -0.01724514f, -0.16263384f, -0.08249201f, -0.07829824f, -0.02942712f, 
    0.07755674f, 0.15749642f, 0.09433484f, 0.22846261f, 0.16364279f, 0.23508947f, 0.00813943f, -0.13183318f, 
    0.16824929f, -0.03357082f, 0.11361662f, 0.21562184f, 0.00586053f, 0.18668684f, -0.03122842f, -0.03101469f, 
    0.05801074f, -0.16091016f, -0.14543647f, 0.15165502f, -0.00689541f, -0.00680391f, -0.16500695f, 0.01531535f, 
    0.07656977f, -0.03178721f, 0.09907403f, 0.10552853f, 0.07044882f, -0.09638528f, 0.08740361f, -0.10546646f, 
    -0.02352830f, -0.11888240f, -0.04989097f, -0.03527977f, -0.07937670f, -0.15067816f, -0.07759707f, -0.12836048f, 
    0.04058426f, 0.03654946f, -0.08374740f, 0.04997550f, -0.10901805f, -0.02681808f, 0.04538624f, -0.09687787f, 
    -0.11359337f, -0.11689717f, -0.13895112f, -0.03215077f, 0.09541294f, 0.03947785f, -0.10418701f, 0.12260567f, 
    0.00368382f, 0.09703705f, 0.00658568f, -0.02160306f, 0.03931694f, -0.02526090f, 0.03521985f, -0.11575351f, 
    -0.03886732f, -0.12487663f, 0.02297463f, 0.00808463f, -0.16050367f, -0.08600437f, 0.04768033f, -0.01549083f, 
    -0.14040937f, -0.06739018f, -0.03009385f, 0.05446790f, 0.00641157f, -0.04987460f, -0.06331513f, 0.09125571f, 
    -0.05491357f, -0.07398369f, -0.12959944f, -0.08237686f, -0.02960697f, 0.05522231f, 0.09892336f, -0.09690684f, 
    -0.11406217f, -0.21424052f, -0.46806091f, -0.04312393f, 0.25300527f, 0.25314587f, -0.11834215f, 0.02513079f, 
    0.10115362f, 0.00529573f, -0.01929737f, 0.08338404f, 0.10304369f, 0.11982392f, 0.00562983f, 0.05683861f, 
    0.21045999f, -0.09533240f, 0.02753394f, 0.01957558f, 0.30519435f, -0.13905489f, -0.00848600f, 0.04886698f, 
    0.22858733f, 0.06127894f, 0.17677553f, 0.07437757f, -0.18501611f, -0.15649003f, 0.17877287f, 0.13043150f, 
    0.23596860f, -0.04841068f, -0.19581707f, -0.06184944f, 0.04442657f, 0.21858749f, 0.07081118f, 0.02807618f, 
    0.06973737f, -0.10594703f, 0.02688144f, 0.04346254f, -0.14407058f, 0.10160112f, 0.04929877f, 0.32984266f, 
    0.14031105f, -0.07298408f, 0.08500738f, 0.08191732f, 0.18849008f, 0.25856301f, -0.17975289f, 0.14223494f, 
    -0.00870607f, 0.12282521f, -0.01854097f, -0.09353136f, 0.03996739f, -0.14259112f, 0.24671349f, 0.02920900f, 
    -0.14576474f, 0.15955673f, 0.12203253f, -0.20109037f, 0.23963308f, 0.16243939f, 0.24259791f, 0.00779930f, 
    -0.11652427f, 0.04539013f, 0.13906690f, 0.07125803f, -0.08133009f, 0.15211383f, 0.05819626f, 0.25150663f, 
    -0.15279540f, -0.08101108f, 0.02824198f, 0.06679789f, 0.00725917f, 0.00203905f, 0.15652733f, -0.21962272f, 
    -0.09629941f, -0.02777467f, 0.16711183f, 0.12790251f, -0.07249727f, 0.06217489f, 0.20655851f, -0.11310785f, 
    -0.04478627f, 0.00605959f, 0.16974595f, 0.08851981f, -0.17728244f, -0.01360100f, 0.04351220f, 0.13186745f, 
    0.16106261f, -0.03059434f, 0.11255743f, 0.18013410f, -0.19358157f, 0.13229826f, 0.07699890f, 0.59380376f, 
    0.04605488f, 0.05723054f, -0.01246817f, -0.07852507f, 0.00746860f, -0.03646026f, -0.25631851f, 0.03369777f, 
    0.13600922f, -0.18012407f, -0.02664891f, -0.08599349f, 0.14222544f, 0.04038988f, -0.26646635f, 0.10808066f, 
    0.15122077f, 0.03691204f, -0.49537605f, 0.07957890f, -0.12221617f, -0.01931985f, 0.07108378f, -0.09105021f, 
    0.02588042f, -0.35619470f, -0.06855546f, -0.13973491f, 0.08426867f, 0.08606234f, 0.10210788f, -0.04676716f, 
    0.07677721f, -0.03502501f, -0.18477173f, 0.11100046f, -0.11310732f, 0.13633284f, -0.06355813f, 0.22781405f, 
    0.13173376f, 0.10399626f, -0.07066371f, -0.32947934f, -0.06002493f, 0.17597757f, -0.05618913f, -0.06871907f, 
    -0.16221026f, 0.07162699f, 0.23331539f, 0.06721741f, 0.02299142f, -0.03625570f, 0.06640473f, 0.00197127f, 
    -0.17890389f, -0.04802081f, -0.09886305f, -0.28466126f, 0.25834537f, -0.14256687f, 0.21551205f, -0.53299367f, 
    0.10040829f, -0.14985734f, 0.20211229f, 0.01801360f, 0.19044213f, -0.04762631f, 0.10459551f, 0.12844655f, 
    -0.12146395f, 0.09379113f, 0.19557658f, 0.09773236f, 0.04035797f, 0.31877258f, -0.03406900f, 0.09013084f, 
    0.00989307f, -0.09827358f, 0.08379231f, 0.04912814f, 0.01126367f, 0.09752158f, -0.13901088f, -0.09802380f, 
    -0.02759802f, 0.14220607f, -0.05738638f, 0.06533366f, -0.05529951f, -0.12404773f, 0.01389357f, -0.02186981f, 
    0.03366600f, 0.00985118f, 0.09592874f, -0.08126757f, 0.01447137f, 0.04499459f, -0.05360425f, -0.26029110f, 
    -0.34108764f, -0.25033563f, 0.27054709f, 0.37756070f, -0.24866438f, 0.15203612f, 0.21744183f, -0.05296538f, 
    0.17653225f, 0.02934885f, -0.13441820f, -0.03887292f, 0.12587619f, -0.31049466f, 0.02787933f, -0.23371735f, 
    0.09785355f, -0.03252621f, -0.12231868f, 0.14444385f, 0.06535888f, 0.31052056f, -0.08720280f, 0.28013682f, 
    -0.38108674f, 0.08911939f, 0.25513721f, 0.16940387f, 0.17652224f, 0.10670328f, 0.13345741f, -0.12186737f, 
    0.05445146f, -0.14046313f, 0.28854603f, -0.23885642f, 0.14946061f, -0.02921195f, 0.00513096f, -0.07572196f, 
    -0.24627092f, 0.42388228f, -0.25554392f, -0.18421432f, 0.26025873f, 0.08739730f, 0.56194466f, 0.18556930f, 
    -0.24646114f, -0.34001634f, 0.02740429f, -0.09492565f, -0.06871358f, 0.27658650f, -0.17389992f, 0.13347308f, 
    0.03206758f, -0.05600585f, 0.18663125f, 0.19810605f, 0.05429029f, -0.03886044f, 0.03366156f, 0.05815920f, 
    0.12585849f, 0.27439255f, -0.13752180f, -0.37928778f, 0.07842378f, -0.14275026f, 0.09376130f, -0.09239859f, 
    0.04487840f, -0.05470278f, 0.25021258f, 0.17766657f, 0.09104668f, 0.07163352f, 0.18829602f, -0.09712195f, 
    -0.11975154f, 0.01930702f, 0.06415809f, 0.21067800f, 0.10565688f, -0.05154602f, -0.00446337f, -0.29816344f, 
    0.22684722f, -0.01526380f, 0.13535921f, -0.12540624f, 0.06863357f, 0.09464026f, -0.02644724f, 0.05034465f, 
    -0.01736425f, -0.20349787f, 0.02139039f, 0.34180278f, 0.02832351f, 0.07037790f, -0.26494628f, -0.05342242f, 
    -0.08735231f, 0.24904245f, -0.05487719f, -0.22562420f, 0.28669623f, -0.00344723f, 0.49509344f, -0.02268477f, 
    -0.21512562f, 0.04355932f, 0.05838846f, -0.08014736f, 0.06235537f, 0.14673668f, -0.14448534f, 0.13098264f, 
    -0.09019881f, -0.05785614f, 0.31283605f, 0.27075809f, -0.00061585f, -0.18149067f, 0.07082586f, 0.02693104f, 
    -0.07279086f, 0.02787988f, 0.10492153f, -0.04713363f, 0.15483993f, -0.16788764f, 0.18894610f, 0.02227369f, 
    0.07567014f, 0.08808051f, 0.27031666f, 0.04233289f, -0.11394018f, -0.00103040f, -0.06541040f, 0.04995571f, 
    0.17357911f, 0.09117742f, 0.13301201f, 0.13896118f, 0.06622255f, -0.02523064f, 0.19817105f, 0.15104234f, 
    0.36472315f, 0.06698757f, -0.10678720f, 0.07879259f, 0.04225526f, 0.09054220f, -0.29136643f, 0.03465215f, 
    0.11624997f, -0.04756838f, -0.20572114f, 0.28083009f, 0.08775076f, -0.05138470f, -0.17042433f, -0.12741965f, 
    0.21994603f, 0.18140082f, 0.00697589f, 0.14936772f, 0.00316885f, 0.10220273f, 0.02743805f, -0.11000691f, 
    0.16319078f, 0.26301318f, -0.06952634f, -0.47033966f, -0.10311154f, 0.06884515f, 0.01849457f, -0.07162262f, 
    -0.16646646f, -0.15135686f, 0.01558271f, 0.12590076f, 0.05654169f, 0.03613640f, -0.00811928f, 0.15014137f, 
    -0.21985264f, 0.03253451f, 0.08305955f, 0.11577670f, 0.09910963f, -0.14320514f, -0.08458178f, 0.09207128f, 
    -0.02969649f, 0.07963821f, -0.29604244f, -0.21957983f, -0.31614870f, -0.00536486f, 0.10001786f, -0.15142328f, 
    0.15871620f, 0.01160625f, 0.02063757f, 0.02446881f, -0.14139920f, -0.16944726f, 0.06630754f, 0.15063293f, 
    0.02144630f, -0.15770277f, 0.04387748f, 0.03080366f, -0.10862839f, -0.02381573f, -0.09309860f, 0.09038157f, 
    -0.10939848f, 0.00738282f, -0.15833691f, 0.03534722f, 0.04016932f, 0.05196749f, -0.14759798f, 0.21408354f, 
    -0.03119304f, -0.17932175f, -0.58710837f, 0.11429208f, 0.09887754f, 0.02419670f, -0.32477406f, 0.01928490f, 
    0.18181084f, 0.31456134f, 0.01200857f, -0.12343597f, 0.07891457f, 0.11238716f, 0.23492505f, -0.03961410f, 
    0.30399916f, -0.13834554f, -0.14668667f, -0.02637063f, 0.06398521f, 0.17648868f, -0.09004223f, 0.25355136f, 
    0.01093303f, -0.05635993f, 0.29598418f, 0.08337896f, -0.16423514f, 0.12717722f, -0.14711927f, -0.11737089f, 
    -0.15646331f, -0.06063429f, -0.12243465f, 0.04570737f, 0.07949254f, 0.21091916f, -0.02112757f, -0.31748906f, 
    0.18445489f, -0.10594452f, -0.00877773f, -0.13404070f, 0.12570937f, -0.01408892f, 0.11478269f, 0.19517517f, 
    0.17777084f, -0.42522436f, 0.07164150f, 0.08747173f, -0.00102604f, 0.21909764f, 0.13140717f, 0.44821519f, 
    -0.00729613f, 0.23419257f, 0.15228954f, -0.04541119f, 0.21690543f, 0.17509972f, 0.07598563f, -0.00420419f, 
    0.18793292f, -0.04143415f, -0.01177966f, 0.31478509f, -0.14003009f, 0.17109716f, -0.02185987f, 0.07770442f, 
    0.22035959f, -0.22149783f, 0.05675668f, 0.04607464f, -0.09485611f, 0.01438609f, 0.03561870f, -0.09515072f, 
    0.16476594f, 0.31996500f, -0.07166923f, 0.24684843f, -0.18898958f, 0.22962062f, -0.02245043f, 0.25524944f, 
    0.18118176f, 0.00331134f, -0.17635211f, -0.06861705f, 0.38860551f, -0.19019595f, -0.17133677f, 0.04776886f, 
    -0.22789072f, -0.08432955f, 0.20703949f, 0.15746674f, -0.08908068f, 0.01159147f, 0.17170282f, 0.18569130f, 
    -0.25166199f, 0.01795408f, -0.11960982f, -0.33692572f, 0.13880225f, -0.33969724f, 0.24921197f, -0.25336042f, 
    0.10364033f, -0.20106938f, 0.09402075f, 0.26032495f, 0.33495668f, -0.18695143f, 0.03813971f, 0.39373130f, 
    -0.06485303f, 0.30287004f, 0.09191016f, 0.07945215f, 0.10587417f, 0.04040543f, 0.15360364f, -0.16511327f, 
    0.08208568f, -0.09052525f, -0.12468718f, 0.18359546f, -0.10461922f, 0.15312643f, 0.06213772f, 0.08238332f, 
    0.16358262f, -0.27232993f, -0.06801867f, -0.04860194f, -0.08893563f, 0.04982262f, 0.29609752f, 0.11473529f, 
    -0.05591521f, 0.08449784f, -0.17785864f, 0.20972583f, 0.02703531f, 0.08107094f, 0.29115289f, -0.07515112f, 
    0.30223888f, 0.02063521f, 0.14372212f, 0.07738431f, -0.00827677f, 0.08149783f, 0.07499636f, 0.07894509f, 
    -0.24406363f, -0.05094624f, 0.11166073f, 0.23432723f, 0.04768457f, 0.11920872f, 0.25032407f, 0.30383506f, 
    0.09552812f, 0.02828192f, -0.09132060f, -0.12451681f, -0.09345595f, -0.09387473f, 0.00921354f, 0.32357499f, 
    -0.18064512f, 0.08028279f, -0.18187584f, -0.13286230f, -0.09642784f, -0.18540241f, -0.10858419f, 0.19211558f, 
    0.12064493f, 0.16572751f, -0.09541778f, -0.32174447f, 0.32287037f, 0.11748005f, -0.01957381f, 0.07428304f, 
    0.19951373f, -0.11676468f, 0.08459714f, -0.39104122f, 0.08549771f, 0.22303553f, -0.01004829f, 0.09487135f, 
    -0.06007645f, 0.08689210f, 0.08353525f, 0.07743803f, -0.10288577f, 0.03226354f, -0.36862990f, 0.21802633f, 
    0.09421852f, 0.21298900f, 0.12622471f, -0.28552559f, 0.10588446f, -0.40557617f, 0.02458921f, -0.22571364f, 
    0.19265983f, 0.10604724f, -0.30720434f, 0.35221681f, -0.18775435f, 0.16764952f, 0.07607447f, -0.11201233f, 
    0.10320843f, -0.09362841f, -0.00795114f, 0.00228623f, -0.00374201f, 0.13578114f, -0.48093092f, 0.14716685f, 
    0.06936277f, -0.06485878f, 0.02906752f, 0.28288198f, 0.12571403f, -0.12702881f, 0.03684647f, 0.43223795f, 
    0.04357723f, -0.10712648f, 0.03180547f, 0.09235784f, 0.16726638f, -0.07452564f, -0.37245554f, -0.21809615f, 
    -0.09727703f, -0.15483443f, -0.13745043f, 0.05013490f, -0.14579807f, 0.13337100f, -0.11756964f, 0.06239595f, 
    0.09054014f, 0.07892510f, 0.05999337f, -0.08860380f, -0.02117820f, -0.04606693f, 0.09086543f, 0.00712866f, 
    -0.06585833f, -0.00975458f, -0.03270631f, -0.12753755f, 0.08764894f, -0.12006900f, -0.05493685f, -0.07949480f, 
    -0.08332695f, 0.06052777f, 0.00770394f, 0.08786307f, -0.06748164f, -0.08937611f, -0.05760525f, -0.09053989f, 
    0.07614817f, -0.14359057f, -0.05129877f, -0.07212612f, -0.05253362f, -0.02008191f, -0.12700808f, -0.05968814f, 
    -0.09642399f, -0.05814241f, -0.07443056f, 0.00730277f, 0.07647482f, 0.03154251f, -0.02854211f, 0.06759311f, 
    -0.02638124f, -0.03504129f, 0.00169922f, -0.05396846f, -0.14296517f, -0.07017916f, 0.00967233f, 0.06239019f, 
    0.08582721f, -0.08469236f, -0.03440596f, -0.10074657f, -0.00571240f, -0.00121488f, 0.02008915f, -0.00887595f, 
    0.01816739f, -0.00803096f, 0.00727494f, -0.08376874f, 0.00170130f, -0.02873036f, -0.02136733f, -0.02311459f, 
    -0.04116097f, 0.13481450f, -0.26530778f, 0.00451257f, 0.22954144f, 0.12804717f, -0.05977915f, 0.05698854f, 
    0.10517853f, 0.03526941f, -0.04378671f, -0.08440868f, -0.03229067f, 0.18742256f, -0.22543094f, -0.21109252f, 
    0.14308448f, 0.00276230f, -0.04388149f, -0.19596048f, 0.25485393f, -0.06710437f, -0.00118321f, 0.12153707f, 
    0.04308579f, 0.15343425f, -0.21376459f, -0.03721797f, -0.21148488f, -0.09368034f, 0.00135861f, 0.12227369f, 
    0.07827878f, 0.07886200f, -0.28860390f, -0.22475381f, 0.14814501f, 0.13521318f, -0.02838441f, -0.40937731f, 
    -0.16096140f, 0.14875846f, -0.00250351f, 0.31649491f, 0.14574495f, -0.01509700f, 0.05674540f, 0.05386586f, 
    0.31825995f, 0.12017468f, 0.18244469f, 0.02211582f, -0.01606379f, 0.05896484f, 0.08868112f, -0.11427017f, 
    -0.03608720f, 0.00084822f, 0.18268000f, 0.06205633f, -0.33708423f, 0.26927862f, -0.04690416f, 0.18336061f, 
    -0.00212526f, -0.09605470f, -0.41986534f, 0.16054657f, -0.01489435f, -0.10186438f, -0.00259841f, -0.02870439f, 
    -0.06061002f, -0.03275469f, 0.00049597f, -0.02304023f, 0.02782157f, 0.05182885f, 0.04847823f, 0.14667886f, 
    0.09465678f, 0.31284997f, -0.16753498f, 0.19592464f, -0.12225136f, 0.25794798f, 0.05677214f, 0.28180069f, 
    -0.00039264f, -0.15114549f, 0.03664222f, -0.12943360f, -0.10043102f, -0.05774917f, -0.22169228f, -0.11403440f, 
    -0.04386627f, -0.03163474f, 0.06363066f, 0.21813260f, -0.07048584f, 0.01849033f, 0.05572626f, 0.00713603f, 
    0.14109325f, -0.09065589f, -0.07936070f, -0.17950286f, 0.06230126f, -0.03705167f, 0.06069903f, 0.19692123f, 
    -0.13115865f, -0.14562619f, -0.05945079f, 0.14965184f, 0.19581227f, -0.15798433f, 0.09347833f, 0.11384360f, 
    -0.10874547f, 0.32864052f, 0.36963424f, -0.13843057f, 0.32395583f, 0.29452375f, 0.00440080f, -0.15384114f, 
    -0.06314120f, -0.00568796f, 0.02267852f, -0.07279551f, 0.07228800f, -0.02312403f, -0.04567662f, 0.03389985f, 
    -0.02869697f, 0.00051589f, 0.01191952f, -0.13248323f, -0.07357863f, -0.03129285f, 0.06304833f, -0.09339084f, 
    -0.00377885f, -0.11901547f, -0.11531658f, -0.12450210f, -0.07203938f, -0.08952839f, -0.09843587f, -0.13267052f, 
    -0.10477045f, -0.14300855f, 0.10049979f, -0.08496273f, -0.00115257f, 0.04847984f, 0.08900587f, -0.06630418f, 
    0.04414061f, -0.10211358f, -0.03991167f, -0.13308392f, 0.08451384f, -0.12371314f, -0.03430812f, 0.08270954f, 
    -0.07683183f, 0.10282746f, 0.01055641f, 0.04432783f, -0.01381352f, -0.11207946f, -0.06831913f, -0.09203349f, 
    0.08413621f, -0.13902271f, 0.07421785f, 0.08945169f, -0.10572210f, -0.05596311f, 0.03164245f, 0.01571459f, 
    0.05185197f, 0.06054855f, -0.07044682f, 0.00575384f, 0.05001914f, -0.13483097f, -0.09438171f, -0.01015171f, 
    -0.17204386f, -0.05726324f, 0.10493882f, 0.25660920f, 0.13572475f, -0.30080664f, 0.20793319f, -0.06807937f, 
    -0.13593216f, -0.22334129f, 0.06492143f, -0.07922857f, -0.10655628f, 0.26543289f, 0.24057674f, 0.20250656f, 
    0.05336224f, -0.05194439f, 0.02306998f, 0.09058916f, 0.12970096f, 0.09961596f, 0.01567275f, 0.03725701f, 
    -0.00314059f, -0.15581140f, 0.16343886f, -0.19358157f, -0.10030351f, -0.02179871f, 0.07485683f, -0.06310378f, 
    -0.05074164f, 0.02242083f, -0.02132683f, 0.11196540f, -0.08512600f, 0.19542800f, 0.04666907f, 0.07527052f, 
    0.04027380f, 0.10761890f, 0.16224381f, 0.01696464f, -0.03261466f, 0.04776169f, 0.09122481f, -0.22692364f, 
    -0.00743851f, 0.05733814f, -0.27972290f, -0.11648615f, 0.04235016f, -0.00065609f, 0.02689857f, 0.02773350f, 
    0.11800342f, 0.05592857f, 0.25452697f, -0.13235441f, 0.30079517f, -0.19618680f, -0.06086201f, -0.11585330f, 
    -0.03889767f, -0.00479258f, -0.00214893f, -0.04090077f, -0.11898141f, -0.12093246f, -0.08590260f, -0.01525024f, 
    -0.03725476f, -0.05150291f, -0.00925582f, 0.01749697f, -0.09594290f, 0.08572216f, -0.06198302f, -0.11442938f, 
    -0.04644437f, 0.00238997f, -0.12126239f, -0.15905994f, 0.12178991f, -0.00089415f, 0.04430924f, -0.04898540f, 
    0.01381808f, 0.02500508f, 0.01155086f, -0.05765108f, -0.16215502f, -0.05375320f, -0.08237188f, -0.11528873f, 
    -0.15201999f, -0.00560776f, -0.05796352f, -0.04140021f, -0.03033491f, 0.00542364f, -0.12736513f, 0.02002384f, 
    0.10173434f, 0.10264812f, -0.02371219f, -0.05259952f, -0.13481057f, -0.10738593f, -0.12759313f, 0.07665762f, 
    0.06276210f, -0.04822997f, 0.07509522f, 0.00672412f, 0.00282200f, -0.02592405f, -0.09844814f, 0.04024727f, 
    0.12129533f, -0.03620701f, -0.08323255f, -0.14203806f, 0.09037661f, -0.10858040f, -0.07537550f, 0.04170644f, 
    -0.27952924f, -0.23129879f, -0.65485513f, 0.28594825f, 0.18757220f, -0.19889659f, 0.02017388f, -0.31473741f, 
    0.00991008f, -0.00912112f, 0.04424667f, -0.18323730f, 0.06848718f, 0.18731128f, 0.20328504f, 0.07348963f, 
    0.01555522f, -0.04567413f, -0.08152109f, 0.10437638f, -0.00298498f, 0.06462249f, -0.04925123f, 0.19218509f, 
    -0.30476403f, -0.39875925f, 0.35441402f, 0.06882862f, -0.04328169f, -0.34578136f, 0.00961445f, 0.10771954f, 
    -0.20183463f, 0.03664090f, -0.05033280f, 0.15752751f, -0.41447014f, -0.03163589f, 0.11856160f, 0.18719366f, 
    0.29295844f, 0.05361341f, -0.08831117f, -0.06883605f, -0.16647488f, 0.06781972f, 0.09163069f, 0.32569531f, 
    0.19362080f, -0.40864509f, -0.20564926f, 0.14433627f, 0.11248108f, 0.10313480f, -0.03019412f, 0.28517193f, 
    -0.11906710f, 0.09810191f, 0.16767281f, 0.01888569f, 0.24062814f, -0.11256328f, -0.09447964f, -0.14014342f, 
    0.24583539f, 0.13372447f, -0.05399988f, -0.06113740f, -0.07619257f, 0.23971231f, 0.14191842f, 0.11490031f, 
    -0.09617499f, -0.07059012f, -0.13033257f, -0.13659261f, 0.04775505f, 0.25216824f, -0.29940882f, 0.10363851f, 
    -0.15878351f, -0.10091104f, -0.01466813f, 0.44645512f, -0.09353442f, 0.05281410f, 0.03634233f, 0.04599594f, 
    -0.01259160f, 0.18764074f, -0.18189694f, -0.19856456f, 0.03674430f, -0.12924908f, -0.05124149f, -0.01149345f, 
    0.07657591f, -0.12993440f, 0.34391189f, -0.04982822f, 0.02493890f, -0.15721774f, -0.01590536f, -0.31693390f, 
    -0.04763988f, 0.07341614f, -0.08351143f, 0.05057685f, 0.43545532f, -0.09347404f, 0.19192752f, -0.21615727f, 
    -0.02021023f, -0.05163576f, 0.22099860f, 0.10663052f, 0.20677158f, -0.11848448f, 0.00828066f, 0.11236495f, 
    -0.04940800f, 0.21125825f, 0.05159218f, 0.04689758f, 0.11680441f, 0.28967014f, 0.02170262f, -0.20231587f, 
    0.11104772f, -0.09740393f, 0.20881538f, 0.08146842f, 0.07294624f, 0.11842310f, -0.29642808f, -0.31095803f, 
    0.16178900f, 0.36222738f, 0.13973972f, -0.00537905f, -0.10629056f, -0.03822439f, 0.01848555f, -0.08970688f, 
    0.20137975f, 0.15086533f, 0.36977914f, -0.15623119f, 0.22695793f, 0.13704631f, -0.18750115f, 0.21796137f, 
    0.06562576f, -0.09767274f, 0.27254945f, 0.28917572f, 0.14858221f, 0.06558706f, -0.11478167f, -0.07337342f, 
    0.04581661f, 0.08786204f, -0.26153252f, -0.15207079f, -0.27008584f, 0.06808375f, -0.09823709f, 0.00461470f, 
    -0.06084780f, -0.10754516f, -0.03837812f, 0.25838333f, 0.08004567f, -0.02890661f, -0.08649760f, -0.08835305f, 
    0.27520335f, -0.22916993f, 0.22185142f, 0.07610542f, 0.10624346f, 0.27803901f, -0.21362089f, -0.05124501f, 
    -0.15137005f, 0.11439475f, -0.08284716f, 0.21995528f, -0.22583912f, -0.08043850f, 0.23471855f, 0.31564957f, 
    -0.01464143f, -0.03219523f, -0.28468588f, 0.14758044f, 0.01221342f, 0.07424615f, 0.16384654f, -0.24798432f, 
    -0.25181839f, -0.39692882f, 0.03484231f, 0.04928891f, 0.08145204f, -0.04737034f, 0.01542843f, 0.29425952f, 
    0.00570454f, -0.03245240f, 0.09311207f, 0.16838287f, -0.15277128f, -0.01409222f, 0.13553187f, -0.21143933f, 
    0.04774145f, -0.13418539f, 0.06771821f, -0.04967979f, -0.09422807f, -0.14714658f, 0.00404298f, 0.03242737f, 
    -0.00922437f, 0.04467919f, 0.26610404f, 0.14068677f, -0.05305283f, -0.09228286f, 0.17101333f, 0.18703502f, 
    0.07636008f, -0.12444028f, -0.01612752f, -0.01581863f, -0.01607236f, -0.09818461f, 0.26727980f, -0.14289434f, 
    -0.01354399f, -0.00735032f, 0.08083198f, -0.03221831f, 0.02883256f, -0.13873169f, -0.00000347f, 0.19048677f, 
    -0.02012559f, 0.15834226f, 0.17553721f, -0.14367901f, 0.14626138f, 0.10107670f, -0.08338448f, -0.31919226f, 
    0.28107712f, -0.00888048f, 0.26125425f, 0.02042658f, 0.06084110f, 0.08620565f, -0.24662367f, -0.40740114f, 
    -0.15729624f, 0.42813748f, 0.04253948f, 0.05943283f, 0.05668536f, 0.10833322f, -0.04491178f, 0.13643634f, 
    0.16161112f, 0.06880973f, -0.00643400f, -0.10907743f, -0.08988559f, 0.15326869f, 0.17117791f, -0.11997890f, 
    -0.18966329f, -0.23911446f, 0.18956442f, 0.43276078f, -0.35217011f, 0.29598695f, 0.10812319f, 0.11172895f, 
    0.15045530f, -0.00308077f, 0.08250455f, 0.21459574f, -0.23553531f, -0.15050080f, -0.21116309f, -0.11576150f, 
    0.32872352f, -0.04015784f, -0.02019860f, 0.04748638f, 0.01447618f, 0.20884128f, -0.14192116f, 0.37735587f, 
    -0.32978970f, -0.16436353f, 0.28170019f, 0.01700013f, -0.08706879f, 0.08517671f, 0.03404053f, -0.06606685f, 
    0.19297063f, -0.01067289f, 0.24006781f, -0.01827546f, 0.22769821f, 0.11150319f, 0.07018705f, -0.14637230f, 
    -0.16518538f, 0.19322318f, 0.39922547f, 0.25139865f, 0.02864801f, -0.11626615f, 0.16989657f, -0.23827446f, 
    0.14679210f, -0.01741877f, 0.12844169f, -0.03793349f, -0.00409670f, -0.02616059f, 0.13628413f, 0.11208775f, 
    0.25446799f, -0.00319636f, -0.04512334f, 0.06192219f, 0.15406993f, 0.06970008f, 0.08892339f, 0.06250813f, 
    0.04070541f, -0.23318732f, 0.02889842f, -0.34033787f, 0.28862154f, -0.17335406f, -0.26097167f, -0.10847385f, 
    -0.00563175f, -0.02773597f, 0.14856167f, 0.04261094f, -0.15403910f, -0.05604373f, 0.28837943f, 0.25816444f, 
    -0.02691348f, 0.08707654f, 0.06182325f, 0.04822179f, -0.13854834f, 0.00306939f, 0.23282951f, -0.19663070f, 
    0.13386771f, -0.01051555f, -0.14574371f, 0.17978109f, 0.02253455f, -0.17287877f, 0.25934494f, 0.04825808f, 
    -0.00610251f, 0.19563225f, 0.02675346f, -0.09124691f, 0.18471338f, -0.35916346f, -0.17174947f, -0.00541531f, 
    -0.19629236f, -0.09204518f, -0.10113879f, 0.02752980f, -0.05732565f, 0.11039931f, -0.16220985f, -0.11420819f, 
    0.31319264f, -0.06306203f, 0.00517357f, -0.29803243f, -0.08505525f, 0.00257287f, 0.09566570f, 0.00387945f, 
    0.27555904f, 0.20934340f, 0.03016315f, -0.23039836f, 0.42226797f, 0.18462947f, -0.15765071f, 0.15896121f, 
    -0.00348804f, -0.16980374f, 0.05691585f, -0.11481815f, 0.02384639f, -0.06894120f, -0.24474497f, 0.00535421f, 
    0.04534784f, 0.02563282f, -0.12052504f, 0.15130523f, 0.00964387f, 0.07353853f, 0.17261937f, 0.02487102f, 
    -0.07056543f, -0.08198917f, -0.00900957f, -0.20423064f, -0.06111194f, 0.07932851f, 0.05890022f, 0.23505674f, 
    0.15188640f, -0.24833828f, -0.03002911f, 0.03373529f, 0.23216534f, 0.01611283f, 0.11236037f, 0.19078827f, 
    -0.09845063f, 0.10503363f, 0.00747450f, 0.06321990f, 0.03963839f, -0.08154996f, 0.09708653f, 0.36402240f, 
    0.25030670f, 0.18021882f, 0.67570966f, 0.07299296f, 0.00373410f, -0.03314132f, 0.27258140f, -0.26759109f, 
    0.23948696f, 0.44161159f, -0.09879394f, -0.06693161f, 0.00653541f, 0.02148725f, -0.07810477f, -0.00186783f, 
    0.00665576f, -0.11449811f, 0.21063176f, 0.07207926f, 0.08984695f, -0.01921386f, 0.03945142f, 0.03156357f, 
    0.01969717f, 0.16476716f, -0.15107839f, 0.26955351f, 0.39062175f, -0.00532920f, -0.08511887f, 0.09662776f, 
    -0.05228898f, 0.15358074f, 0.10400587f, -0.01030313f, -0.36468312f, -0.10649741f, 0.04203405f, -0.00685720f, 
    0.12711452f, -0.05368173f, 0.10283426f, 0.27899334f, -0.12937078f, -0.00234443f, -0.25774223f, 0.47829324f, 
    0.23516686f, -0.02471567f, 0.03990934f, -0.16027862f, -0.03938146f, 0.08210976f, -0.23114190f, 0.05618604f, 
    0.09976356f, -0.00184540f, -0.30509809f, 0.15224236f, -0.04750407f, -0.15464842f, -0.19905919f, 0.24322590f, 
    -0.28679925f, 0.13227193f, -0.10293014f, 0.10228357f, 0.08048863f, -0.05435121f, 0.35416961f, -0.03532482f, 
    0.11750772f, 0.03037649f, 0.00758876f, -0.03204309f, -0.09723745f, -0.16093643f, 0.28042731f, 0.10254251f, 
    0.12004916f, 0.00649348f, -0.04561600f, 0.12771942f, 0.12222088f, 0.07158750f, -0.16613908f, 0.10921422f, 
    -0.25351334f, -0.16490935f, 0.14442556f, -0.12543041f, 0.16447803f, -0.47316870f, 0.05962036f, 0.08201142f, 
    -0.13733530f, -0.06992436f, -0.07038495f, 0.15949343f, -0.30564028f, -0.23331779f, 0.33924341f, 0.15776855f, 
    0.20785092f, 0.03946525f, -0.17653829f, -0.05594235f, -0.16287194f, -0.03295200f, 0.31499612f, 0.09726895f, 
    0.24849088f, -0.02554129f, -0.27493331f, 0.11593090f, 0.08707198f, 0.02068723f, 0.20032457f, 0.32007223f, 
    0.08071845f, -0.19157466f, -0.15538894f, 0.04261406f, 0.24710348f, -0.27091959f, 0.04782653f, -0.04612627f, 
    -0.19209102f, 0.26140925f, -0.15841855f, -0.09185468f, 0.24196117f, -0.14097260f, 0.16987887f, -0.10903832f, 
    -0.02502775f, 0.21558568f, -0.01971008f, 0.00838816f, -0.08576056f, -0.01967933f, -0.15461218f, -0.32632416f, 
    0.27030134f, -0.04771482f, -0.15285769f, -0.04857510f, 0.11184302f, 0.11666607f, -0.08605625f, 0.14995418f, 
    -0.03647890f, 0.07921612f, -0.50941801f, -0.20435761f, 0.05796399f, -0.02012752f, -0.04024549f, -0.00180099f, 
    0.21618012f, -0.10859127f, -0.22314374f, -0.03156108f, -0.13716805f, 0.21404809f, -0.08127403f, -0.58466870f, 
    -0.22210300f, 0.04146494f, 0.05170415f, 0.15227810f, 0.13627887f, 0.08325174f, 0.04453165f, -0.33233228f, 
    0.41317707f, 0.04013189f, 0.17544024f, 0.02317839f, -0.02101190f, 0.01806665f, 0.11998627f, -0.16019845f, 
    0.06525510f, 0.04313960f, 0.14455840f, 0.17598851f, -0.14795502f, 0.19933985f, -0.17491311f, 0.16820972f, 
    0.03492952f, 0.14681210f, -0.14296255f, 0.32493773f, -0.06928547f, 0.04685882f, -0.07730523f, -0.13360845f, 
    0.17470725f, 0.08611507f, 0.00605724f, -0.23432347f, 0.03723001f, 0.04239447f, 0.12049635f, -0.07582093f, 
    0.04904994f, 0.13211234f, -0.14282337f, 0.02104037f, 0.21049955f, 0.21607058f, -0.10706992f, 0.34458655f, 
    -0.05304193f, 0.02735013f, 0.10895311f, -0.23190774f, 0.21754611f, -0.00489184f, -0.14828280f, -0.00110239f, 
    0.07982433f, 0.07605051f, -0.07621874f, 0.06152648f, -0.09099612f, 0.11298589f, 0.02802839f, -0.12687205f, 
    -0.12272506f, 0.05792949f, -0.14000651f, 0.05881763f, 0.19020191f, 0.12375588f, -0.01597813f, -0.12914716f, 
    0.17634496f, -0.19567741f, 0.08049827f, 0.23214923f, -0.04369411f, 0.08943278f, -0.02174485f, 0.14723653f, 
    -0.02689991f, 0.09593252f, 0.14810133f, 0.19073939f, -0.01879033f, -0.00466496f, 0.02834215f, 0.17468889f, 
    0.35071862f, 0.12249292f, 0.25444525f, -0.07975011f, -0.09605116f, 0.06379341f, -0.00135968f, -0.31314808f, 
    -0.06873796f, 0.15396006f, -0.00928297f, 0.21550119f, 0.09403653f, -0.01316027f, -0.01451816f, 0.09295184f, 
    -0.01791662f, 0.22118948f, 0.29440314f, -0.22948611f, 0.01092003f, 0.09261031f, 0.10845667f, -0.04876192f, 
    0.09119187f, -0.07697215f, 0.17779268f, 0.14652640f, -0.17618287f, 0.23184802f, 0.17203921f, -0.09416445f, 
    0.16610710f, 0.11622458f, 0.14452429f, 0.14539719f, -0.22635414f, -0.19807693f, 0.05568541f, 0.01507158f, 
    0.07668973f, -0.08506764f, 0.00827825f, 0.19039154f, 0.25500765f, 0.25221086f, -0.14547257f, -0.05957313f, 
    -0.19281080f, -0.25258729f, 0.44009820f, 0.05152912f, 0.10694660f, 0.03349472f, -0.01236696f, -0.36658844f, 
    0.03746017f, -0.02314875f, 0.16619311f, -0.07813019f, 0.07445654f, 0.08793785f, -0.06738130f, -0.09802498f, 
    -0.25941664f, 0.12400362f, -0.01901997f, 0.01078081f, 0.29593596f, 0.19010039f, 0.31302303f, 0.01864089f, 
    -0.14630832f, -0.18427002f, -0.07697219f, 0.05805286f, -0.07442713f, -0.07460906f, 0.10928240f, 0.23744728f, 
    0.20689823f, 0.10242952f, 0.27183321f, 0.01595342f, 0.17857489f, -0.00998845f, 0.30521855f, -0.15188007f, 
    0.12631427f, 0.17124824f, 0.10584468f, 0.03496410f, 0.17655259f, -0.11962173f, 0.11435020f, 0.06582349f, 
    0.24792320f, 0.05600552f, 0.19213757f, 0.12608558f, -0.04582004f, -0.05893826f, -0.13871178f, 0.34405959f, 
    0.04531090f, 0.00257679f, -0.13674524f, 0.37858671f, -0.00605468f, 0.16608694f, 0.14350861f, -0.15953360f, 
    0.29909998f, 0.28337428f, -0.16615245f, 0.21856761f, 0.08220527f, 0.30905086f, -0.12379788f, -0.22230452f, 
    -0.04484141f, -0.21402381f, -0.12148275f, 0.27693963f, -0.18378691f, 0.12714432f, -0.02178141f, -0.13949214f, 
    -0.03169649f, 0.37113029f, -0.31236294f, -0.14786342f, 0.23375687f, 0.18588001f, 0.18799768f, -0.08127748f, 
    -0.53551817f, 0.00061916f, 0.07557842f, -0.11018061f, -0.01396419f, 0.09462147f, -0.06569335f, 0.24468742f, 
    -0.15419510f, -0.12856355f, 0.25829744f, -0.13996741f, 0.15318853f, 0.12620416f, 0.05696123f, -0.16363539f, 
    -0.21567203f, 0.16109656f, 0.16966827f, -0.14310749f, -0.16210680f, 0.20022091f, 0.34117705f, -0.03406131f, 
    0.24651933f, -0.04515498f, 0.14995754f, 0.06872007f, -0.17253821f, -0.04134050f, -0.17675544f, -0.18848702f, 
    0.16081898f, -0.05524709f, -0.08500078f, 0.34773421f, 0.05121436f, 0.33756673f, 0.04756410f, -0.24831405f, 
    0.06987023f, 0.02190676f, 0.34841985f, 0.10769060f, 0.11368545f, -0.00603858f, -0.15537465f, -0.24127281f, 
    0.02279830f, -0.25971508f, 0.21624747f, 0.01136507f, 0.16093276f, 0.22830790f, -0.20951752f, -0.01524479f, 
    0.13890854f, -0.12691697f, 0.47248039f, -0.53631264f, 0.06580918f, 0.23547085f, 0.17846045f, -0.08989819f, 
    0.24424298f, 0.01567639f, -0.00358313f, -0.01747891f, 0.08190684f, 0.02404767f, -0.65662533f, 0.05041555f, 
    0.12909319f, 0.04456368f, 0.17290099f, 0.08483899f, 0.11901048f, -0.61275262f, 0.11832051f, 0.18517657f, 
    0.30081671f, -0.01939746f, -0.49405327f, 0.28051090f, -0.06432050f, 0.05222965f, 0.15228470f, -0.01242465f, 
    -0.02104191f, -0.04003222f, -0.11245416f, -0.07756177f, -0.00299256f, 0.35149187f, -0.42989025f, -0.56418997f, 
    0.10367124f, 0.16105852f, -0.10542081f, 0.23220941f, 0.02636470f, -0.04825068f, -0.56479883f, 0.36418259f, 
    0.06738488f, -0.08997943f, 0.10991162f, -0.10485350f, 0.22752355f, 0.04866602f, -0.34865251f, -0.22346669f, 
    -0.07995988f, -0.03621550f, -0.13744022f, 0.05102722f, -0.00393456f, 0.21376236f, -0.22267981f, 0.14873347f, 
    -0.05035433f, -0.15767625f, -0.58023584f, 0.08188193f, 0.09634595f, 0.13771082f, -0.26253650f, -0.17828012f, 
    0.15339573f, 0.41443592f, 0.12401740f, -0.05890824f, 0.06860206f, 0.04555692f, -0.14041440f, -0.22622021f, 
    0.30721134f, -0.06766330f, 0.27963150f, 0.14427921f, 0.07364734f, -0.06742286f, -0.21796916f, 0.13262413f, 
    0.22040311f, -0.09343195f, 0.09726231f, 0.24991578f, 0.07208336f, -0.23585619f, 0.05793870f, -0.01702426f, 
    0.01589863f, -0.10141695f, -0.07610293f, -0.24204548f, -0.10134636f, 0.10662536f, -0.45034426f, -0.21831885f, 
    0.01730782f, 0.10936919f, -0.07435733f, 0.13508187f, 0.09233691f, 0.05038994f, 0.03817824f, -0.06879153f, 
    0.28897905f, -0.15706499f, 0.21199533f, 0.09071751f, 0.11486947f, 0.34038591f, -0.36938670f, 0.30395317f, 
    0.07717337f, -0.09849744f, -0.12583181f, 0.30056792f, -0.38045880f, -0.01684091f, 0.13572928f, 0.09322798f, 
    -0.10444342f, 0.15041952f, 0.04032229f, 0.03871939f, -0.05958648f, 0.14091766f, 0.01123363f, -0.11307454f, 
    0.02948497f, 0.24979390f, -0.06166102f, 0.09352074f, 0.03144784f, -0.20305586f, -0.01826348f, 0.09801477f, 
    0.21621762f, 0.13937701f, 0.38238597f, -0.09532644f, 0.11284879f, -0.06162393f, -0.11584724f, -0.05369231f, 
    -0.13370582f, 0.05209059f, 0.01546257f, 0.40602010f, 0.10324182f, -0.23226888f, -0.06679183f, -0.09232952f, 
    0.26755705f, -0.09846941f, -0.06888754f, 0.15499765f, -0.05547397f, -0.32663408f, -0.06072198f, 0.22163089f, 
    -0.07295290f, 0.06152378f, -0.00314578f, 0.23031181f, 0.31229058f, 0.13421735f, 0.18924762f, 0.08694780f, 
    0.21603420f, -0.03594469f, 0.02028061f, 0.20971635f, 0.29279038f, 0.27390751f, -0.04340810f, -0.22249173f, 
    0.13251112f, -0.16781996f, 0.08605196f, 0.35589501f, -0.06967574f, -0.16387179f, 0.26980007f, 0.15118606f, 
    -0.05610085f, 0.22341473f, 0.09078889f, 0.15783119f, 0.09546743f, -0.06455125f, 0.59646028f, -0.13814500f, 
    -0.08448876f, -0.27666029f, 0.11913514f, 0.04169539f, -0.05236305f, 0.15875788f, 0.12149671f, 0.25226372f, 
    -0.12379017f, 0.06434701f, 0.05981750f, 0.08004154f, 0.02251256f, 0.19997545f, 0.14143617f, -0.11977845f, 
    0.11932653f, 0.10998232f, -0.02173878f, -0.13939963f, 0.09949598f, 0.03995318f, 0.07053522f, 0.09583950f, 
    0.05294682f, -0.03833856f, 0.40143943f, 0.10179349f, -0.09492093f, 0.08488742f, 0.29203910f, 0.04700565f, 
    0.09925833f, 0.12100235f, 0.04729288f, 0.08191670f, 0.21517415f, 0.10526595f, 0.03807291f, 0.08937439f, 
    -0.03411160f, 0.04073787f, 0.19463070f, 0.11173818f, 0.23107289f, -0.27148429f, -0.03939706f, -0.07599664f, 
    -0.02899911f, -0.04957100f, -0.04553556f, -0.11111510f, 0.19084446f, 0.15981510f, -0.13822919f, 0.12889591f, 
    0.32704318f, 0.01735423f, 0.18652445f, 0.14579806f, -0.01444795f, 0.14079213f, 0.21882251f, -0.10984398f, 
    0.21226098f, 0.25686100f, 0.05224476f, -0.23058675f, -0.11567643f, 0.07388071f, 0.02657178f, 0.07267292f, 
    -0.01830407f, 0.17115839f, 0.26343110f, 0.29483181f, -0.25032517f, -0.03095627f, -0.07021543f, 0.07295317f, 
    0.21078192f, -0.05220441f, -0.01466594f, 0.36878046f, 0.18975477f, -0.20767865f, -0.15933259f, 0.00592795f, 
    -0.28086278f, 0.06937971f, 0.12071066f, -0.00054366f, -0.30160943f, 0.02246031f, -0.01101524f, 0.23997518f, 
    0.10871235f, 0.03141624f, 0.05129114f, -0.04171849f, -0.18644753f, -0.46606174f, 0.00464740f, 0.27296367f, 
    -0.10407056f, -0.37782380f, -0.00053022f, -0.11913788f, 0.22360426f, 0.17860711f, -0.37320474f, 0.24508859f, 
    0.00011482f, 0.03688363f, -0.24052753f, 0.07277012f, 0.01727678f, 0.01070824f, -0.15887497f, 0.02767459f, 
    0.23915263f, -0.08918000f, 0.26840213f, 0.29510683f, -0.14681141f, 0.06866153f, -0.20935926f, -0.00803578f, 
    0.23015288f, 0.11224815f, 0.04081392f, 0.06522767f, 0.08413067f, 0.09015140f, 0.28954053f, 0.11287003f, 
    0.18458664f, -0.12708698f, -0.11188394f, -0.22217867f, 0.11606362f, 0.14234331f, 0.14056116f, 0.15916297f, 
    0.19706504f, -0.13358006f, 0.12347549f, 0.01373588f, -0.11085867f, 0.43295524f, -0.00433019f, -0.09897330f, 
    -0.14080471f, -0.09942552f, -0.26034817f, 0.02066144f, 0.09554313f, 0.24603531f, 0.20399146f, -0.28157359f, 
    0.15968652f, -0.08062489f, 0.12243675f, -0.21837153f, -0.07787839f, -0.03338192f, -0.16186443f, 0.34666410f, 
    -0.37937570f, 0.02570007f, 0.17739491f, -0.12761705f, 0.01225092f, -0.12882987f, 0.22214676f, -0.01585448f, 
    0.11573865f, 0.15500377f, 0.42077976f, -0.21982551f, 0.19856471f, 0.11526256f, 0.17506808f, 0.25188327f, 
    0.22664467f, 0.26493591f, -0.12141978f, -0.16294283f, -0.04440594f, 0.23940013f, 0.02987391f, -0.20109306f, 
    -0.01590159f, 0.07855701f, 0.09397758f, -0.16557758f, -0.04050897f, -0.25592491f, -0.11128847f, 0.09972863f, 
    0.14576969f, 0.00270363f, 0.25831294f, -0.05266604f, -0.22384302f, 0.04696201f, -0.09542499f, -0.05238357f, 
    -0.12586035f, -0.07040883f, 0.12219697f, 0.13537176f, 0.38748640f, -0.23266210f, 0.04387699f, -0.11152217f, 
    0.05018734f, -0.05493176f, 0.12417522f, 0.02223886f, -0.30871573f, -0.21527545f, -0.15702902f, 0.27599901f, 
    -0.11498605f, -0.12225602f, -0.02090799f, 0.14080553f, 0.40171278f, -0.07513168f, 0.13624179f, -0.21303360f, 
    0.30484784f, -0.16972680f, 0.24939692f, 0.34645736f, 0.15724283f, 0.17767499f, -0.33820894f, 0.12347972f, 
    -0.03863044f, -0.03588917f, -0.00671077f, 0.31934065f, -0.21133155f, 0.05868373f, -0.18120156f, 0.10342698f, 
    0.07635948f, 0.12597455f, 0.06046121f, 0.20668481f, -0.06447164f, 0.18090184f, -0.18306291f, -0.25362694f, 
    0.27694654f, 0.26400125f, -0.12002078f, -0.03962969f, 0.05673012f, -0.05807547f, -0.00137111f, -0.04417541f, 
    -0.05688362f, 0.18298034f, 0.10850714f, 0.01538068f, -0.03340564f, 0.23922053f, -0.07664172f, 0.22238231f, 
    -0.12161107f, -0.11463919f, 0.00371819f, 0.02624835f, 0.31523326f, -0.12512885f, -0.19873706f, -0.03794849f, 
    -0.03923957f, 0.15899876f, 0.05276597f, 0.05845074f, -0.42010134f, -0.35434806f, 0.01916289f, 0.03205280f, 
    -0.06025883f, 0.02534934f, 0.04072706f, -0.05455186f, 0.21205561f, 0.12106457f, 0.12923241f, 0.01669451f, 
    -0.01363091f, -0.23077281f, 0.01806312f, 0.22189784f, 0.18784834f, -0.03169499f, 0.11136045f, -0.01453674f, 
    -0.14573435f, 0.11378526f, 0.13620597f, 0.28602421f, -0.01066231f, 0.02565591f, -0.04537321f, 0.02781161f, 
    0.20274258f, -0.10523949f, 0.16480093f, 0.23051664f, -0.12897076f, -0.35266396f, -0.10748485f, -0.24873810f, 
    0.00276010f, -0.01579839f, 0.01259867f, 0.12047683f, -0.10083891f, 0.14080355f, 0.19204725f, 0.07603633f, 
    -0.05528190f, 0.25737491f, -0.00223835f, 0.17099801f, -0.11226483f, 0.33345526f, 0.18435164f, 0.09650306f, 
    -0.18874721f, -0.29081333f, 0.12425043f, -0.02410675f, 0.13394466f, 0.13699228f, -0.20753574f, -0.05917865f, 
    -0.23990051f, -0.03334166f, -0.02479874f, 0.07935678f, 0.01307727f, -0.05003527f, 0.16686004f, -0.05440844f, 
    0.17906122f, -0.08238797f, -0.07159074f, -0.03532286f, 0.17472975f, -0.06915728f, 0.00107105f, -0.29128766f, 
    -0.09227125f, -0.00490033f, -0.04063611f, -0.11808588f, -0.03936866f, -0.23781064f, 0.12734929f, -0.15568522f, 
    0.11241568f, 0.19722547f, 0.29402819f, -0.09459849f, 0.16795227f, 0.04189970f, 0.07211854f, -0.16935077f, 
    0.37150016f, 0.07550205f, 0.37104088f, -0.00573911f, -0.04064875f, 0.10806835f, 0.01177322f, 0.07105109f, 
    -0.01077225f, -0.09649602f, -0.02171340f, 0.15503107f, -0.11823942f, 0.11748298f, 0.00135378f, 0.18844244f, 
    -0.17205490f, -0.02737619f, -0.11875407f, 0.21336867f, -0.19711535f, -0.00246499f, 0.28230876f, -0.05447850f, 
    0.32239088f, 0.04874229f, -0.20350960f, -0.15732689f, -0.02034882f, 0.04419453f, 0.07646764f, -0.03341152f, 
    -0.06641893f, 0.14226851f, 0.23113982f, 0.10754588f, 0.12011031f, 0.12805581f, 0.21174683f, 0.02345003f, 
    0.12052733f, 0.12125377f, 0.11520872f, -0.06731072f, 0.16952640f, -0.20406365f, -0.08501305f, -0.04096461f, 
    -0.23646885f, 0.02179941f, 0.19687809f, -0.11614458f, -0.12416854f, -0.38777548f, 0.06999853f, -0.02339282f, 
    0.01636812f, 0.06817468f, 0.15393224f, -0.25513247f, 0.31606984f, 0.16958292f, -0.18636832f, 0.05506009f, 
    0.01160789f, 0.26923642f, 0.24091443f, -0.20215878f, -0.00438969f, 0.22676878f, 0.05874321f, 0.06905673f, 
    -0.11112932f, 0.06399366f, 0.11823730f, -0.03805606f, -0.09273773f, 0.03127470f, -0.27150384f, 0.12975152f, 
    -0.09776630f, 0.03518694f, 0.05526898f, 0.07103688f, 0.17815650f, -0.15850702f, 0.07524206f, -0.02113877f, 
    -0.11296913f, 0.06934146f, -0.01401160f, 0.00344531f, -0.09265678f, -0.08744635f, 0.24861719f, 0.04440333f, 
    0.08308307f, -0.04596790f, 0.12269314f, 0.08184535f, -0.00510785f, -0.10489678f, -0.15252139f, -0.23189208f, 
    0.04863084f, -0.06408655f, 0.03601275f, 0.25075927f, 0.01923447f, 0.09159757f, -0.14006327f, -0.04286145f, 
    -0.04066084f, -0.07616946f, 0.19418962f, 0.09734219f, 0.23222731f, -0.07978868f, -0.14538009f, -0.26633456f, 
    0.11269604f, -0.18293168f, 0.07161301f, 0.02645699f, -0.01996851f, 0.13656840f, -0.12985516f, -0.00508459f, 
    -0.16571903f, 0.00495783f, -0.28200457f, 0.17050031f, 0.05554820f, 0.14975892f, 0.17837662f, -0.07311030f, 
    0.07433505f, 0.25003049f, 0.00098371f, -0.07551616f, -0.10096681f, -0.08979170f, -0.01685792f, 0.02490807f, 
    0.07235856f, 0.05776538f, 0.18748514f, 0.18353356f, 0.25465873f, 0.00616367f, -0.03236818f, 0.28823200f, 
    -0.01069518f, 0.12488880f, -0.06423757f, 0.24821575f, 0.46499386f, -0.40097567f, -0.06036527f, 0.01255293f, 
    -0.00218314f, 0.02887439f, 0.12557457f, -0.11215916f, -0.00700870f, -0.12584685f, 0.06864738f, 0.37669936f, 
    -0.06980278f, -0.04273114f, 0.03964186f, 0.00741637f, 0.05826122f, 0.09791928f, 0.06879975f, 0.22078750f, 
    0.59134930f, 0.11767987f, -0.18863878f, 0.22315583f, -0.06040262f, 0.53525531f, -0.06943052f, 0.19761403f, 
    0.03728400f, 0.11183258f, -0.09931446f, 0.48379415f, -0.15710695f, -0.31902242f, 0.03000230f, -0.01707616f, 
    0.29302248f, -0.06627411f, 0.28406775f, 0.16786179f, -0.30747935f, -0.04673576f, -0.09535465f, -0.17585216f, 
    0.53778172f, 0.57129961f, 0.02733846f, -0.43100914f, -0.05391496f, 0.11979759f, 0.08217102f, -0.14670046f, 
    0.11092453f, 0.06161459f, -0.01018097f, 0.06297324f, 0.10876745f, 0.02838243f, -0.16332130f, 0.16320232f, 
    -0.01479441f, 0.04413534f, 0.05086431f, 0.34392595f, 0.36274716f, -0.09133002f, -0.31834006f, -0.07602578f, 
    -0.14055569f, 0.03405389f, -0.20697224f, -0.07159350f, -0.41135672f, 0.10404778f, 0.02847179f, 0.17055687f, 
    0.01161485f, -0.04060251f, 0.02110984f, -0.12270828f, -0.04954581f, -0.15156245f, -0.05469514f, 0.39504460f, 
    -0.05245730f, -0.35962260f, 0.21631853f, -0.12408218f, 0.06237360f, 0.12912875f, -0.09973256f, -0.00724462f, 
    -0.27467179f, 0.32558995f, -0.12691909f, 0.22520235f, 0.03838693f, 0.07889867f, -0.14356413f, 0.27536893f, 
    -0.19574265f, -0.04677576f, -0.26711547f, 0.27587914f, 0.19305985f, -0.06647322f, -0.00195955f, -0.26494083f, 
    -0.13309564f, -0.22469890f, 0.03805975f, 0.02056564f, -0.00199293f, -0.11296617f, 0.13163653f, 0.29771546f, 
    0.16625296f, 0.11162210f, 0.08685075f, -0.13358295f, 0.07361913f, 0.15982124f, -0.01297551f, 0.00762423f, 
    -0.21539015f, -0.18605852f, 0.26229975f, -0.26446512f, 0.05518229f, -0.17338066f, -0.14063504f, 0.00837812f, 
    0.10565378f, 0.03813680f, 0.19262902f, 0.10792872f, -0.27773201f, -0.00965937f, 0.31653702f, 0.29180411f, 
    -0.03032669f, 0.06233726f, 0.02279755f, -0.09202705f, 0.06271125f, -0.06496952f, 0.28148726f, -0.18954322f, 
    0.00315647f, -0.25086445f, -0.03123925f, 0.14057441f, 0.13067611f, 0.04918272f, -0.04282240f, 0.21308334f, 
    -0.08387541f, -0.06113642f, 0.28015637f, 0.06434398f, 0.14239815f, 0.05852629f, 0.06204163f, -0.06545787f, 
    -0.27435091f, -0.03594443f, -0.21870029f, -0.05133666f, 0.13524516f, 0.03795171f, 0.15019688f, -0.05714364f, 
    0.13320419f, -0.26307321f, 0.00652524f, 0.14177363f, -0.04084611f, 0.05103855f, 0.11113133f, 0.06755928f, 
    0.09502005f, -0.00446032f, 0.14353469f, 0.10477103f, -0.01192521f, -0.01267101f, -0.04391165f, 0.11006315f, 
    0.19919829f, -0.22345178f, -0.00480078f, 0.09172279f, 0.15972577f, -0.37595615f, 0.05717215f, -0.05825166f, 
    -0.07856022f, -0.01064049f, 0.07651202f, -0.01491449f, 0.03312838f, 0.32574579f, 0.11983737f, 0.32856920f, 
    -0.04225109f, -0.09316098f, -0.05081791f, -0.18172446f, -0.20153186f, -0.28886807f, 0.12638497f, 0.50283355f, 
    0.33126992f, -0.10303875f, -0.31077904f, -0.07814763f, -0.06351452f, 0.15802048f, -0.07676294f, 0.46143886f, 
    0.07049614f, -0.04023126f, -0.18672360f, -0.09227218f, 0.12660269f, -0.09782747f, 0.13334818f, 0.00987096f, 
    -0.16443376f, 0.02018004f, 0.34799916f, 0.10684772f, 0.19285415f, -0.23431608f, 0.18385324f, -0.29123592f, 
    -0.28158772f, -0.15334611f, 0.07809608f, 0.26607737f, -0.06058535f, 0.01157122f, 0.29630011f, 0.31250432f, 
    0.15458567f, -0.07714210f, -0.00272806f, 0.10989933f, -0.05617928f, 0.05155565f, 0.06089557f, 0.00573007f, 
    -0.02249208f, -0.28857604f, 0.15357168f, -0.16023396f, -0.14082168f, 0.15493371f, -0.06767151f, -0.11733620f, 
    -0.09986968f, -0.08601390f, 0.05091647f, 0.17438020f, -0.02399186f, -0.18187699f, 0.10163226f, 0.02777597f, 
    0.27527431f, -0.04426333f, 0.15536483f, 0.18119895f, 0.07267851f, 0.09510585f, 0.22875506f, -0.24124375f, 
    -0.14992712f, -0.09224813f, -0.13188057f, -0.01999238f, -0.08323997f, -0.27071512f, 0.09503487f, -0.09491891f, 
    0.03800258f, 0.20475884f, 0.34240752f, -0.43480310f, 0.14114158f, -0.18839821f, -0.19587743f, -0.04881339f, 
    -0.07176162f, 0.26986054f, 0.40260223f, 0.23975611f, 0.20387825f, -0.17193760f, 0.34053373f, -0.27013066f, 
    0.06959570f, -0.01018408f, -0.05655049f, 0.15100083f, 0.05765750f, -0.08915138f, 0.21243797f, 0.04686876f, 
    -0.04191544f, -0.22728692f, -0.02156810f, 0.04353246f, -0.05442437f, 0.20895611f, 0.00547081f, 0.18244766f, 
    -0.12665994f, -0.08337080f, 0.22380102f, -0.31568298f, 0.03495195f, -0.12806691f, 0.03526330f, -0.00157871f, 
    0.13336645f, -0.08305749f, 0.07102057f, 0.19848800f, -0.06941311f, 0.12720788f, 0.35965142f, 0.34204951f, 
    0.12346306f, -0.10076452f, 0.05250483f, 0.04954525f, 0.12769595f, 0.10028425f, 0.12934931f, -0.31523910f, 
    0.02663115f, -0.02073912f, -0.02498280f, 0.07777652f, 0.10254546f, 0.05458775f, 0.07190217f, 0.29440057f, 
    0.12214641f, 0.19532692f, 0.12890831f, -0.01718865f, 0.15287241f, -0.13099390f, -0.01849749f, 0.01634561f, 
    0.00969650f, 0.06809745f, -0.13894551f, -0.09261554f, 0.06587870f, -0.09563293f, 0.01719185f, -0.07641065f, 
    0.04038065f, -0.00924526f, 0.14019527f, 0.09227346f, 0.10741866f, 0.02728704f, 0.02054957f, -0.09118143f, 
    -0.09883796f, -0.07849160f, 0.08814713f, -0.00315766f, -0.12579510f, 0.03306077f, -0.13596813f, -0.03700075f, 
    0.09427249f, 0.07338352f, 0.03584118f, -0.06794600f, -0.01847308f, -0.07849628f, -0.07044906f, -0.04344548f, 
    -0.08076280f, -0.05157998f, -0.04968321f, -0.11463201f, -0.08698136f, -0.14158216f, -0.01327708f, 0.07867281f, 
    -0.09896610f, 0.00715431f, -0.01058194f, 0.04698727f, 0.06392781f, -0.05275995f, 0.01884029f, 0.04816347f, 
    -0.13543375f, -0.07706531f, -0.04581238f, 0.03692766f, 0.04373277f, -0.10950533f, 0.00921791f, -0.09888347f, 
    0.01991749f, 0.02344325f, 0.08925398f, 0.08986872f, -0.10178170f, 0.06253446f, -0.12489181f, 0.03402554f, 
    -0.19961643f, 0.23748706f, -0.15055415f, -0.08291134f, 0.24163702f, 0.11036416f, 0.05133720f, -0.24536900f, 
    -0.00735705f, 0.50235969f, 0.05878384f, -0.17212021f, -0.04922900f, -0.01762133f, 0.01897075f, -0.10412201f, 
    0.09083799f, -0.09750813f, 0.22477342f, 0.10474014f, 0.22576019f, -0.03276771f, -0.08951472f, 0.22679456f, 
    -0.13796344f, 0.04709789f, 0.15462799f, 0.03440673f, 0.29005107f, -0.11291413f, 0.07655672f, -0.04475078f, 
    0.13322486f, -0.08442576f, -0.06513981f, -0.17063290f, -0.26592174f, -0.02371354f, -0.21665502f, -0.09924918f, 
    0.14655396f, -0.10965272f, 0.09676871f, 0.12394350f, 0.01634379f, 0.10430989f, -0.05879015f, -0.18211074f, 
    0.29140010f, -0.11113785f, 0.14590867f, 0.11732595f, 0.07109257f, 0.34183320f, -0.12225770f, 0.20401877f, 
    0.00680084f, -0.30378723f, 0.00375896f, 0.29381081f, -0.28525037f, -0.16009721f, -0.03084728f, 0.23552859f, 
    0.06930576f, -0.02931321f, -0.44401214f, 0.25008604f, -0.04798115f, -0.08193158f, 0.02886652f, 0.16618918f, 
    0.20673159f, -0.03706775f, -0.06261485f, -0.31550878f, 0.00049929f, 0.24093516f, 0.11054784f, -0.09741754f, 
    -0.09485783f, 0.08806723f, -0.04675208f, 0.26306224f, 0.04042238f, -0.01712683f, -0.07615526f, 0.20826983f, 
    -0.01974434f, 0.08451787f, -0.11254875f, -0.17922309f, 0.10658798f, -0.06934663f, -0.07244059f, -0.01204747f, 
    -0.10369828f, 0.00856289f, 0.03922613f, -0.07515243f, 0.07996315f, 0.06871185f, -0.04829678f, -0.23110177f, 
    0.03902153f, 0.06136471f, -0.17197977f, -0.23915915f, -0.01191581f, -0.00016895f, -0.08203695f, 0.18214460f, 
    -0.04344980f, -0.14937182f, -0.01443729f, 0.05415770f, 0.04890478f, -0.09464476f, 0.09669688f, 0.09463241f, 
    -0.02107797f, 0.25441241f, 0.14854279f, 0.08641656f, 0.22320566f, 0.18777362f, -0.08675119f, -0.02305040f, 
    -0.05580088f, 0.00596354f, 0.09184647f, 0.22417562f, 0.05920737f, -0.09989326f, 0.07671109f, -0.02249520f, 
    0.36768970f, 0.25653407f, -0.02878921f, -0.10413421f, -0.07308777f, -0.05569992f, 0.13484994f, -0.10848174f, 
    -0.06306360f, 0.13933861f, 0.22029783f, -0.06496238f, 0.12165075f, 0.10127173f, -0.10749110f, 0.07379475f, 
    -0.03736056f, -0.11632215f, 0.01633264f, 0.20258266f, 0.23857109f, -0.33833495f, -0.29991430f, -0.07191889f, 
    0.11479712f, -0.12540174f, -0.10928486f, -0.14133269f, -0.05326449f, -0.03104952f, 0.19308311f, 0.16120458f, 
    -0.06547618f, 0.09747054f, 0.07508567f, -0.04533249f, -0.13837799f, -0.10718597f, -0.00422115f, 0.24095139f, 
    0.40615812f, -0.05894331f, 0.01360425f, 0.13967870f, 0.11231542f, 0.21175009f, 0.00236251f, 0.19386335f, 
    0.11845823f, 0.13706647f, -0.16290365f, 0.15605120f, -0.07298662f, -0.13423358f, 0.02647549f, 0.29934394f, 
    -0.40758690f, 0.05947587f, -0.31361946f, 0.00205265f, 0.14802547f, -0.09444474f, 0.05071793f, -0.03325143f, 
    -0.08322217f, -0.31262612f, 0.03870500f, -0.30332682f, 0.11640227f, 0.14303818f, -0.05408772f, 0.00869989f, 
    0.11657833f, 0.01491473f, -0.10465052f, 0.25636750f, 0.27351475f, -0.09730053f, -0.20355976f, 0.33810174f, 
    -0.19388103f, -0.12165262f, 0.03442964f, -0.12270491f, -0.11024809f, -0.09211634f, 0.08834887f, 0.05570428f, 
    -0.00113341f, 0.11940186f, -0.01648536f, 0.16706571f, -0.00129902f, 0.22322981f, 0.19485871f, -0.14868009f, 
    0.05226551f, 0.11594228f, 0.00492334f, 0.06353804f, 0.03911653f, -0.05312584f, -0.02229330f, -0.06527492f, 
    0.37159815f, -0.17164320f, 0.03582309f, -0.01058466f, 0.29189688f, 0.10453521f, -0.02641632f, 0.37519294f, 
    0.06409742f, -0.00810038f, 0.09932969f, -0.04676105f, 0.20161869f, 0.18492213f, 0.04751137f, 0.23066576f, 
    0.06658892f, 0.02883581f, 0.24221829f, 0.31720474f, 0.19320783f, -0.05955829f, 0.00183024f, -0.08345624f, 
    0.41448545f, 0.18149471f, -0.01045928f, -0.06007949f, 0.07729587f, 0.18060215f, 0.09369150f, -0.27534002f, 
    0.18775988f, -0.10598634f, 0.05312479f, -0.24604122f, 0.19810523f, 0.10883132f, 0.06980297f, 0.29832238f, 
    0.02500711f, 0.19175360f, -0.25623283f, -0.13740921f, 0.27553296f, 0.08293925f, -0.11538292f, 0.00856141f, 
    0.09561371f, 0.06380535f, -0.46702304f, -0.21826494f, -0.13551021f, 0.28757262f, 0.03341061f, -0.36379153f, 
    -0.12310775f, 0.12361256f, -0.09012435f, 0.06531990f, 0.00930935f, -0.02277361f, 0.03485557f, -0.26398417f, 
    0.31030846f, -0.04136578f, -0.08331428f, 0.01312604f, -0.03019265f, 0.02664586f, -0.09562110f, -0.20082615f, 
    0.08063141f, 0.00339594f, 0.07731304f, 0.06774411f, -0.28022125f, 0.17219792f, -0.16652949f, 0.41827393f, 
    0.18113270f, -0.22711144f, 0.02779483f, 0.28637734f, -0.46800953f, 0.00502494f, 0.00383786f, 0.00070843f, 
    0.08134867f, 0.04114655f, 0.07101270f, -0.01966868f, -0.08319677f, -0.03776559f, 0.04893979f, -0.04944748f, 
    -0.04230880f, 0.28408265f, -0.17476758f, 0.30539277f, -0.11420809f, 0.16296946f, 0.02347399f, 0.21693218f, 
    0.07670691f, -0.00064086f, -0.13034676f, -0.02277681f, 0.24822132f, 0.20110720f, -0.45439866f, 0.02792470f, 
    -0.18111010f, -0.20418286f, 0.24673180f, 0.15282613f, 0.23200552f, -0.10819621f, 0.10989176f, -0.07819280f, 
    0.00975924f, 0.03025748f, 0.03657482f, -0.35358900f, 0.14046516f, 0.03244610f, 0.00182418f, -0.23360452f, 
    -0.02212172f, -0.05491442f, -0.16068074f, 0.10095704f, 0.07641809f, -0.28252441f, 0.11013131f, 0.16836913f, 
    0.01715639f, 0.33327535f, 0.21712428f, 0.09111127f, 0.09702512f, 0.22052754f, 0.07177606f, -0.28526416f, 
    0.05118366f, 0.03448165f, -0.05804569f, 0.03670730f, -0.06609876f, -0.00747061f, -0.09403528f, -0.01740198f, 
    -0.00723320f, 0.01984143f, -0.06557539f, 0.00715443f, -0.09860542f, -0.11798765f, -0.09018867f, -0.08704961f, 
    -0.05484533f, -0.09364858f, 0.05283042f, 0.03438469f, -0.05373318f, -0.04774065f, -0.00049599f, -0.01559137f, 
    -0.06776562f, 0.08879371f, -0.01712324f, -0.06519499f, -0.13990046f, -0.12382802f, 0.09903636f, 0.01230359f, 
    -0.10755899f, -0.00767893f, -0.01143748f, -0.07172059f, -0.03811303f, -0.08782895f, -0.10445399f, -0.00296545f, 
    0.04248073f, -0.05510800f, 0.07193889f, -0.08907539f, -0.11405408f, 0.00231325f, -0.01703930f, -0.01962447f, 
    0.05247122f, 0.06453142f, -0.07481466f, -0.10085462f, -0.09739333f, -0.02625387f, -0.06152290f, -0.08397114f, 
    -0.00837120f, -0.10770840f, -0.08585817f, 0.05671978f, 0.07301839f, 0.06110263f, -0.11872312f, -0.00105749f, 
    0.16228433f, 0.07323825f, 0.42833477f, 0.05556910f, -0.00651375f, -0.35095561f, 0.02295337f, -0.16866197f, 
    -0.04291078f, 0.32891271f, 0.05552923f, 0.09765745f, 0.10762271f, 0.07224376f, 0.08243572f, 0.18339600f, 
    -0.13957077f, -0.06112819f, -0.04609785f, -0.02162782f, -0.14288174f, 0.07060985f, 0.17631485f, -0.20029394f, 
    0.05941802f, -0.26740733f, -0.01604159f, -0.08128099f, -0.34811866f, 0.39134508f, 0.03653849f, -0.03761666f, 
    -0.06271549f, -0.06343043f, -0.06045452f, 0.09491105f, -0.21729299f, -0.26451978f, -0.08257235f, -0.12848347f, 
    0.24992174f, -0.05232681f, 0.01692791f, 0.01050041f, -0.00439334f, 0.27077433f, -0.10605045f, -0.11639404f, 
    -0.60255128f, -0.04822348f, 0.15167432f, -0.31685960f, -0.15968025f, -0.36837339f, 0.14514984f, -0.42014310f, 
    0.00329825f, 0.19824897f, 0.23315744f, -0.52729172f, 0.27925852f, 0.03178749f, -0.21275049f, -0.11165068f, 
    0.08831861f, -0.03871736f, 0.31794652f, 0.07827652f, -0.02228149f, -0.01993948f, -0.12097835f, -0.29262063f, 
    0.09748255f, 0.35245720f, -0.12980065f, 0.00658925f, 0.04475990f, -0.16750064f, 0.16133827f, 0.11546738f, 
    0.00206439f, 0.18142451f, 0.37363747f, -0.16380197f, 0.12811658f, 0.03490991f, 0.00505187f, -0.19953644f, 
    -0.09404431f, -0.12421320f, 0.26147139f, 0.43630123f, 0.04929068f, 0.03248846f, -0.05892015f, -0.07077721f, 
    0.11519885f, 0.05370113f, -0.00621383f, 0.07321607f, -0.17398702f, -0.00309096f, -0.09861496f, 0.24402931f, 
    0.13464855f, 0.07932907f, -0.02539577f, 0.15884888f, -0.11310508f, 0.16792823f, -0.00515925f, 0.57101268f, 
    -0.28820944f, -0.08356518f, 0.05841708f, 0.07142439f, 0.01523868f, 0.17437668f, -0.08606355f, -0.30571520f, 
    0.05884157f, -0.07966156f, 0.04682555f, 0.05482398f, 0.03446665f, -0.24755816f, -0.06270610f, 0.08328984f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.02450546f, 0.00901159f, 0.17149149f, 0.14014119f, 0.20016918f, -0.08076511f, 0.26795584f, 0.11235763f, 
    0.14735422f, 0.09227852f, 0.09654687f, 0.07361254f, -0.15954269f, 0.09255849f, 0.11359140f, 0.15877666f, 
    0.16614424f, 0.00715112f, 0.31949532f, 0.05598730f, -0.05032928f, 0.13252653f, 0.07294770f, 0.10221405f, 
    -0.07105485f, 0.20117348f, -0.00705916f, 0.07889570f, 0.14349888f, 0.22269784f, -0.10927650f, 0.20915060f, 
    0.15868215f, -0.03156310f, 0.12593493f, 0.04351729f, 0.18986876f, 0.18137425f, 0.13789873f, 0.07661020f, 
    0.24959704f, -0.11749465f, 0.14523506f, 0.15170075f, -0.00091895f, -0.03419622f, 0.17040275f, -0.13667198f, 
    0.05847447f, 0.09674681f, 0.07484126f, -0.02152544f, 0.11900851f, 0.29233450f, 0.07364367f, 0.02966310f, 
    -0.06351291f, 0.07190487f, -0.12178203f, 0.33325738f, -0.36334851f, 0.04507788f, 0.00317914f, -0.00953063f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.24389428f, -0.06748854f, -0.53309113f, -0.10802647f, -0.31345993f, 0.01938793f, -0.41417009f, -0.23564184f, 
    0.20236674f, -0.12277447f, -0.23092259f, -0.25663170f, -0.21518426f, 0.13420324f, 0.05012709f, 0.06544099f, 
    -0.13835868f, 0.07511202f, -0.16205543f, 0.19145775f, -0.02902287f, 0.13265435f, -0.09253955f, 0.05626469f, 
    0.00352999f, -0.16928737f, 0.11510824f, 0.01922191f, 0.02279160f, -0.10679477f, -0.30604827f, 0.03641680f, 
    -0.09224886f, -0.06181347f, -0.15393928f, -0.45994768f, -0.27630800f, -0.11705700f, -0.08315772f, -0.67761451f, 
    -0.01117228f, -0.17144856f, 0.07769143f, -0.19703175f, -0.02320417f, 0.28185177f, 0.15974052f, -0.16292934f, 
    -0.48425296f, -0.20512559f, 0.07778569f, -0.17096511f, 0.21323651f, 0.14044461f, -0.01616440f, 0.10397611f, 
    0.10412563f, -0.49184495f, 0.00248039f, -0.02014916f, 0.29407629f, -0.06416451f, 0.19247270f, -0.44855303f, 
    -0.04261195f, 0.14860480f, -0.01538706f, 0.00109052f, 0.09078669f, 0.03982588f, 0.02005569f, 0.20575292f, 
    -0.15506873f, 0.11948083f, 0.02283500f, -0.00524874f, -0.04570169f, -0.22589807f, -0.67930937f, -0.01735054f, 
    0.29781562f, -0.06640570f, 0.14247701f, -0.08068196f, -0.08965841f, 0.18958572f, 0.02377225f, -0.16926879f, 
    -0.02269579f, -0.41527840f, 0.02562553f, 0.29249203f, 0.03116887f, -0.18895192f, -0.08333644f, -0.07296237f, 
    0.11559968f, -0.34798223f, 0.24028187f, -0.01399240f, 0.16577187f, 0.38876715f, -0.17434540f, -0.17156801f, 
    0.10877828f, -0.43433860f, 0.08519857f, -0.72757214f, -0.32556888f, 0.09250162f, 0.13638368f, 0.18737713f, 
    -0.37456241f, -0.04198848f, 0.00278639f, -0.40497053f, 0.24714899f, 0.08224855f, 0.08460122f, -0.43692273f, 
    -0.04291534f, -0.44245329f, -0.13422315f, 0.11324268f, -0.31627628f, 0.08298224f, 0.37497273f, 0.12208548f, 
    0.15553556f, -0.17844079f, 0.30474979f, -0.05003838f, -0.01960758f, -0.01196065f, 0.10382068f, 0.08419409f, 
    -0.45591545f, 0.30629301f, -0.43330428f, -0.01337905f, 0.23754291f, 0.24497485f, -0.30664513f, 0.09690252f, 
    -0.34907645f, 0.07474869f, -0.34092632f, -0.09521240f, 0.09511850f, -0.29311076f, 0.04875375f, 0.24700664f, 
    -0.46205077f, 0.06003788f, -0.44441098f, 0.21258777f, -0.38772583f, -0.01966346f, 0.26965949f, 0.12040486f, 
    -0.41237772f, -0.06430693f, -0.25561848f, -0.02756842f, -0.23621555f, -0.53135252f, 0.02371237f, 0.00038564f, 
    -0.18490690f, 0.23023327f, 0.14747033f, 0.03350799f, -0.04520049f, -0.31453350f, -0.00875497f, -0.20886642f, 
    0.06669505f, 0.22743748f, -0.14709447f, 0.10677277f, -0.50060803f, -0.03946964f, -0.03419758f, 0.05106966f, 
    0.02612381f, 0.09685144f, -0.14339978f, -0.13072707f, -0.09062207f, 0.08406071f, -0.30067503f, 0.24676479f, 
    -0.28655192f, -0.48116216f, 0.19177562f, 0.14889616f, -0.09927209f, -0.10881112f, -0.21127908f, -0.27212912f, 
    -0.00668910f, -0.02148132f, -0.30954301f, -0.27945313f, 0.04228469f, -0.09275112f, 0.11695203f, -0.03127839f, 
    -0.19198352f, 0.00975406f, -0.72474480f, 0.02437451f, 0.09475103f, -0.03175965f, -0.07629088f, -0.07201663f, 
    -0.28114274f, 0.06187179f, -0.08598834f, 0.09312853f, 0.16042750f, 0.17337923f, 0.32537565f, 0.04105082f, 
    -0.32388151f, 0.08607381f, 0.16633326f, -0.15323804f, -0.26934531f, -0.55141842f, -0.50156605f, 0.16032298f, 
    0.02779484f, 0.11646838f, 0.07813035f, 0.26677197f, 0.25156236f, 0.09717476f, -0.05318643f, -0.04295675f, 
    -0.04980088f, 0.31368771f, 0.07216191f, -0.12399463f, 0.02850098f, 0.09061664f, 0.09260859f, -0.12318575f, 
    0.04089149f, 0.20136391f, -0.23398004f, 0.07659181f, 0.01365444f, -0.03945869f, 0.08181559f, 0.23122351f, 
    0.07819694f, -0.19289376f, -0.37935850f, -0.06706316f, 0.00776208f, -0.12205906f, 0.01475731f, -0.07550689f, 
    0.03623850f, -0.33685780f, 0.09133988f, -0.06543615f, -0.03781521f, -0.04835485f, 0.12353595f, 0.19078130f, 
    -0.05120855f, -0.04028080f, -0.04156109f, 0.12476125f, 0.08642947f, 0.15801711f, 0.02882138f, 0.10800757f, 
    -0.05357965f, -0.64125174f, 0.04514780f, -0.45969537f, 0.23545846f, 0.14695834f, -0.29211506f, 0.11349016f, 
    0.06485271f, 0.03167154f, -0.53592116f, 0.10823657f, -0.60205883f, -0.40131545f, -0.57979244f, -0.12928538f, 
    0.09477115f, 0.04517953f, -0.00697991f, -0.51874709f, 0.02237115f, 0.01751873f, -0.04391979f, -0.28194085f, 
    0.19237766f, -0.12507194f, 0.05740466f, 0.13429210f, -0.00005960f, 0.11090245f, 0.08794484f, -0.46618092f, 
    0.21379240f, 0.08157650f, 0.01347125f, -0.04035999f, 0.02078870f, 0.12005534f, -0.61958146f, -0.19929822f, 
    0.12431163f, 0.04227380f, 0.00814288f, -0.14864537f, 0.07224543f, 0.01005501f, 0.02936419f, 0.05538766f, 
    0.12315401f, 0.09354616f, 0.10971020f, 0.00738589f, -0.18825959f, 0.11692999f, 0.03140241f, -0.06964663f, 
    -0.52446812f, -0.08668222f, -0.03892564f, 0.16034493f, 0.05901649f, 0.02457483f, 0.03374045f, 0.17306709f, 
    0.19577403f, -0.24755780f, 0.08164420f, 0.19065487f, -0.12849849f, 0.10679783f, -0.33559173f, 0.05905322f, 
    0.01020926f, 0.01034195f, 0.08248021f, -0.10675237f, 0.16420981f, -0.40297645f, -0.55589175f, 0.03456033f, 
    0.13409656f, -0.29744929f, -0.06479384f, 0.06799793f, 0.05756710f, 0.00163507f, -0.10296354f, 0.12133123f, 
    -0.07604583f, -0.85839784f, 0.07633198f, -0.02096250f, 0.03918274f, 0.03823854f, 0.09582306f, -0.09066458f, 
    0.11841290f, -0.33953571f, 0.34087831f, -0.37352824f, -0.04066463f, 0.05382110f, -0.34686288f, 0.02832826f, 
    0.20303483f, -0.46636733f, 0.01874246f, -0.03869281f, -0.03823199f, 0.03742363f, 0.20988417f, -0.28279921f, 
    -0.43716505f, 0.00593772f, -0.09708379f, 0.01609077f, -0.06015535f, 0.18683806f, -0.14545108f, -0.43807447f, 
    0.09494775f, -0.04301843f, 0.10129227f, -0.33670142f, -0.01550188f, -0.03774303f, 0.07221369f, -0.64925838f, 
    -0.22517116f, 0.25428766f, -0.47805858f, -0.04468246f, -0.73656756f, 0.08125596f, 0.22134869f, -0.67198837f, 
    0.19699520f, -0.00496918f, -0.42197374f, 0.01478465f, -0.15964715f, 0.27451375f, 0.23698691f, 0.13555162f, 
    -0.65050560f, 0.04075479f, -0.07422817f, 0.02858308f, -0.37248242f, -0.24224208f, -0.59734017f, 0.05433146f, 
    0.23903759f, 0.10737770f, -0.81843829f, 0.07395659f, -0.28054744f, -0.77738708f, 0.09809267f, 0.17679399f, 
    -0.02994308f, 0.09976277f, 0.12002401f, 0.21481659f, -0.02241668f, 0.04087101f, -0.08443469f, 0.11041130f, 
    -0.24410637f, 0.15177022f, 0.43117371f, -0.09559266f, -0.32196701f, -0.05999419f, 0.06608768f, 0.03895063f, 
    0.17005911f, -0.24567764f, 0.02148169f, 0.11524605f, 0.06307456f, -0.09508149f, 0.36425003f, 0.09577014f, 
    0.04837915f, 0.11250058f, -0.19096452f, -0.13826460f, 0.04794910f, -0.55037248f, -0.00772860f, -0.41344607f, 
    0.31808621f, -0.29829499f, -0.01087220f, -0.29251382f, -0.33171439f, -0.46221444f, -0.06525574f, -0.52742833f, 
    -0.26293898f, -0.21302976f, -0.02800798f, -0.18303311f, -0.18432227f, 0.17111830f, 0.11698315f, -0.37775341f, 
    0.01558412f, 0.51270777f, 0.09641009f, 0.18972200f, 0.15577485f, -0.14616902f, 0.20305634f, 0.13571954f, 
    0.01152545f, 0.22504416f, -0.32062456f, -0.06642765f, -0.49514973f, -0.46259382f, -0.07938963f, -0.09322481f, 
    0.16236496f, -0.18887092f, -0.28202903f, -0.27166858f, 0.10841840f, -0.03818481f, -0.04868857f, -0.26999247f, 
    -0.08423068f, 0.22574505f, 0.27026379f, 0.12044966f, 0.21821187f, -0.05891010f, 0.05280152f, -0.01119412f, 
    0.14717864f, 0.12522207f, -0.03416609f, 0.07435030f, -0.33123699f, -0.20145522f, 0.01959640f, -0.31832212f, 
    0.17426306f, 0.09245045f, -0.09472065f, -0.34910604f, -0.12075496f, -0.55126417f, -0.14787690f, -0.55760509f, 
    0.02797365f, 0.08207563f, 0.11071092f, 0.23763914f, -0.70589745f, -0.31278539f, -0.28864595f, -0.42837346f, 
    -0.15570506f, -0.24270105f, 0.30091602f, 0.26567465f, 0.20521370f, -0.12322859f, 0.11317844f, 0.27090681f, 
    -0.04128654f, -0.16552061f, -0.53977412f, 0.22565964f, -0.22946353f, -0.49736166f, -0.14215171f, 0.08305875f, 
    0.05102013f, -0.22799067f, 0.08564081f, -0.13005428f, -0.49093705f, -0.06816537f, -0.10912189f, -0.06190743f, 
    -0.32109159f, -0.30262712f, -0.41734645f, -0.27533117f, -0.80205745f, 0.02238858f, 0.05370769f, 0.17529111f, 
    0.19132441f, -0.20093004f, -0.47150731f, 0.15034096f, -0.03428324f, -0.04879979f, 0.25479633f, -0.41255161f, 
    0.26494998f, 0.03104070f, -0.18587844f, -0.18593550f, 0.01686777f, 0.29812118f, 0.18889591f, 0.02108230f, 
    -0.19236414f, -0.06235015f, 0.00815438f, -0.14030419f, -0.03048593f, 0.11841683f, 0.13464008f, 0.04026381f, 
    -0.22847690f, 0.19029041f, -0.33700547f, -0.34403387f, -0.00542437f, 0.20408559f, -0.46206203f, 0.01810403f, 
    0.04330789f, 0.20943259f, -0.31027994f, -0.13179755f, -0.27639133f, -0.05083111f, -0.00052824f, -0.12235642f, 
    -0.20975755f, -0.21648127f, 0.19129199f, -0.03161966f, -0.05104928f, -0.41407037f, -0.22003454f, -0.20537829f, 
    0.01042116f, 0.04137009f, 0.08980039f, 0.02260970f, -0.14600419f, 0.05168540f, 0.12403983f, 0.05421835f, 
    -0.00794527f, 0.17521751f, 0.11035579f, 0.31703424f, -0.77279478f, 0.10612716f, -0.19058150f, -0.07831763f, 
    -0.10349891f, 0.17676741f, 0.19279782f, 0.13173610f, 0.02050249f, -0.10870948f, 0.05100266f, 0.22127688f, 
    -0.06851655f, -0.37039268f, 0.20196997f, 0.22790155f, -0.07557607f, -0.65132391f, -0.11089684f, 0.11847122f, 
    -0.08517986f, -0.04294535f, -0.91091120f, -0.30788001f, -0.09281578f, -0.00614854f, -0.02456503f, -0.23230037f, 
    -0.39207634f, -0.13402571f, 0.07150810f, -0.32419115f, -0.00094044f, -0.13164675f, 0.37684378f, 0.21579912f, 
    -0.53553581f, -0.52527088f, -0.17320898f, 0.17488095f, -0.11805481f, -0.33095279f, -0.18751463f, 0.03085320f, 
    0.14212218f, 0.15144235f, -0.50675732f, 0.08411685f, -0.50491482f, -0.47669482f, 0.07176597f, 0.04462274f, 
    0.17146927f, -0.20672724f, 0.10525058f, 0.50023669f, 0.03124445f, 0.19328532f, 0.05669016f, 0.00293208f, 
    -0.33984840f, 0.04661132f, -0.01172976f, -0.40168658f, -0.47924638f, 0.00735136f, -0.31173477f, -0.07492895f, 
    -0.16920489f, -0.02526632f, -0.29130110f, 0.10148203f, 0.24702494f, -0.02550513f, -0.11329798f, -0.05382828f, 
    0.10770600f, -0.39839360f, 0.25417075f, 0.25244775f, 0.12873763f, -0.30132711f, -0.12895383f, -0.46395141f, 
    -0.19354080f, -0.08857872f, -0.08767167f, -0.64127916f, -0.07860401f, -0.28822809f, -0.08456168f, -0.31155613f, 
    0.12836312f, -0.00406486f, -0.51708883f, -0.44933194f, 0.03218990f, -0.26233864f, 0.26152113f, 0.05318848f, 
    0.29116434f, 0.11006062f, -0.09230655f, 0.10629779f, 0.17775090f, 0.03742430f, 0.07685392f, -0.01921365f, 
    0.05054785f, -0.17297933f, -0.49774954f, 0.19379309f, 0.12736383f, -0.40228510f, -0.21737683f, 0.13418674f, 
    0.15574095f, 0.04272861f, -0.09729562f, -0.40000111f, -0.32308397f, 0.06393756f, 0.08780731f, 0.26506492f, 
    0.01233307f, -0.09379357f, -0.00111602f, 0.20475818f, -0.62452000f, -0.03505065f, -0.43515784f, -0.12535179f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.22799906f, 0.20483181f, 0.06749837f, 0.06566580f, -0.06603919f, -0.04146286f, -0.04740529f, -0.15705767f, 
    0.05612474f, 0.15236245f, 0.12636559f, -0.02253528f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
