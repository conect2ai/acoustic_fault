#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.10560074f, -1.45875847f, 0.23193967f, 1.30981266f, 0.37072057f, 0.91200370f, -0.01206042f, -0.79855210f, 
    -0.34390596f, 1.07151377f, -1.13584781f, -0.11075839f, -0.78811431f, 0.06808996f, -0.60381007f, -0.65816879f, 
    0.56921232f, 0.19979239f, -1.19230664f, -1.16458380f, -0.79784244f, 0.30880287f, -0.15978281f, -0.34740025f, 
    0.46125326f, -0.15058073f, -0.13939342f, -0.71090692f, -0.58288234f, -0.60554230f, -0.19286048f, 0.79419923f, 
    1.47671890f, 0.32653564f, 0.16411467f, 0.47590697f, -0.94388843f, -0.74921966f, -1.18037200f, -0.29722759f, 
    -1.23661840f, 0.63581622f, -0.39828426f, 0.11107115f, 0.21284735f, -0.85915804f, 1.05838788f, -0.61058766f, 
    0.78619653f, -0.41609347f, -1.23201001f, -0.23659399f, 0.15248697f, -0.07472928f, -1.25666738f, -0.35059792f, 
    0.77419859f, -0.71179050f, 0.14933550f, -0.57041335f, 0.30411029f, 0.49321434f, -0.43459567f, 1.15661669f, 
    1.03488266f, 0.71952879f, 0.63032252f, 0.92836559f, -0.62442619f, 0.05486942f, 0.37139109f, 0.14159845f, 
    -1.44141257f, -0.07323966f, 1.34044361f, 0.26258630f, -0.32216564f, 0.64734554f, 0.08033643f, -0.22533545f, 
    0.56944489f, -1.62425685f, 0.87947142f, -0.90461755f, -0.48811409f, 1.04563689f, 0.22871405f, -0.02899403f, 
    -0.14923562f, 0.46854123f, 0.91260666f, 0.93638492f, 0.67385614f, 0.15098086f, -0.23544618f, 0.96518505f, 
    0.68776333f, -0.25713262f, 0.08504064f, -1.43235052f, -0.56397134f, -0.56682831f, 1.17237628f, 0.73556161f, 
    0.41864458f, -0.44044557f, 0.23042491f, -0.29654220f, 1.24012399f, 0.92168576f, 1.12059355f, -0.03450796f, 
    -0.69914889f, 0.18288724f, -0.22901642f, 0.22396652f, -0.25357297f, 1.14173508f, 0.43285897f, 0.02179465f, 
    -0.93530822f, 0.52135724f, -0.56956506f, 0.04952861f, 0.62035376f, 0.62392324f, 0.46627155f, 0.45513830f, 
    1.05744660f, -1.33082819f, -0.64259267f, -1.33139324f, -0.19464724f, -0.63588440f, -0.27613652f, 0.70453346f, 
    0.66426921f, 0.00440507f, -0.51412982f, -1.10243881f, -0.36163330f, 0.95357943f, 0.30694771f, 0.27186033f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04551982f, 0.37576139f, -0.10737122f, 0.03620347f, 0.29138938f, 0.24151301f, 0.29708958f, 0.54054803f, 
    -0.25940040f, 0.54021740f, 0.34973285f, 0.24811399f, 0.45969504f, -0.52911866f, 0.58549303f, -0.05700313f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.74280989f, -0.06333531f, -0.22643822f, -0.08252838f, 0.13821378f, 0.17447479f, -0.44652134f, 0.09811728f, 
    -0.22536707f, -0.31112707f, -0.23731983f, -0.40060762f, 0.04429875f, -0.15036072f, -0.20596419f, -0.03235742f, 
    -0.01452878f, -0.01457237f, 0.46741337f, -0.16094080f, -0.13276549f, -0.22589524f, -0.14264032f, 0.14592348f, 
    0.08839203f, 0.24675336f, -0.06225702f, -0.76227421f, 0.32919604f, -0.06539348f, 0.24178676f, 0.01284946f, 
    0.11886651f, 0.10229023f, -0.05099171f, -0.07492660f, 0.02596251f, 0.00249533f, -0.36622128f, 0.26167902f, 
    0.10451395f, 0.00530062f, 0.14483462f, 0.13992453f, -0.12564194f, -0.41360465f, -0.14007588f, 0.06029487f, 
    0.07085404f, -0.17633736f, -0.15010026f, 0.08841217f, -0.08686826f, 0.18980412f, 0.27936336f, -0.21170811f, 
    -0.17931584f, 0.08924176f, -0.12062564f, 0.24840847f, -0.00737293f, 0.05794647f, 0.01632182f, 0.59263033f, 
    -0.05322631f, 0.09991734f, -0.05219382f, 0.24291238f, 0.19720884f, -0.04085595f, 0.00399089f, 0.07874541f, 
    -1.55110633f, -0.23294514f, -0.06459304f, 0.07889149f, -0.01503244f, 0.05732603f, 0.08546629f, -0.02419751f, 
    0.22035377f, -0.19291331f, 0.17185305f, 0.33751065f, -0.19737148f, 0.08446268f, -0.17325395f, 0.00989936f, 
    0.03114882f, -0.12396066f, 0.50263679f, -0.12328114f, 0.15438361f, 0.13070118f, -0.02810261f, 0.11525501f, 
    0.16098061f, 0.10154083f, -0.17208154f, -0.09081658f, -0.01797997f, -0.24017462f, 0.07775867f, 0.03272059f, 
    -0.09798206f, 0.01315499f, -0.16662933f, -0.02697320f, 0.70447361f, 0.15376081f, 0.27394158f, 0.13699801f, 
    -0.28945619f, 0.13443992f, 0.13383518f, 0.07037649f, 0.07277101f, 0.25075173f, 0.27097031f, 0.01652244f, 
    0.05000683f, 0.16745931f, -0.06813324f, -0.01402056f, 0.06688917f, 0.21344778f, 0.71720272f, 0.29868302f, 
    -0.14976902f, -0.03695416f, 0.13375999f, -0.06246316f, 0.04965414f, 0.01872372f, 0.06421895f, 0.63753676f, 
    0.18969466f, -0.28866023f, 0.21306078f, -0.19310448f, -0.01960271f, 0.34740767f, 0.04892678f, -0.12975323f, 
    -0.35306677f, -0.22667839f, -0.33540151f, 0.09815340f, -0.13337876f, -0.11379962f, 0.39078721f, -0.15104289f, 
    0.04655561f, 0.27144173f, 0.20127718f, -0.37037489f, -0.05286013f, -0.10451221f, -0.08620827f, -0.04650699f, 
    0.14778070f, 0.13070740f, -0.48118231f, 0.58680183f, 0.12897669f, 0.30281627f, 0.18148008f, -0.31232977f, 
    0.19185525f, 0.19627681f, 0.10964637f, -0.23664354f, -0.18976498f, -0.01395156f, 0.25391647f, 0.11293621f, 
    0.17044607f, -0.37367201f, -0.23100160f, 0.20804328f, -0.35868901f, -0.22156532f, -0.36617047f, 0.08526095f, 
    0.45825222f, -0.13757373f, -0.03724229f, 0.12878136f, 0.06186778f, -0.06242554f, -0.05787656f, 0.22741053f, 
    0.03425074f, 0.25027952f, -0.14330490f, 0.02487713f, -0.02630169f, 0.11784329f, -0.20164074f, 0.01088958f, 
    -0.47900429f, 0.21160677f, -0.03343483f, -0.02774693f, 0.05608886f, 0.02189447f, -0.01034988f, -0.39339092f, 
    0.20422176f, 0.42400905f, 0.09756125f, -0.05236444f, -0.08891606f, 0.08713143f, -0.00870358f, 0.03707645f, 
    0.47190526f, -0.48810998f, -0.40079159f, -0.19020927f, -0.17961024f, -0.01885950f, -0.14761010f, -0.26026383f, 
    -0.16461371f, -0.52622283f, -0.00914205f, -0.38700691f, 0.05838443f, 0.15679328f, 0.12980698f, 0.12831149f, 
    0.00634431f, 0.20623225f, -0.20454811f, 0.26146582f, 0.39160180f, 0.18974869f, 0.07293699f, -0.26444271f, 
    -0.03822985f, 0.02572678f, -0.13649273f, -0.06409134f, -0.13617891f, -0.32135701f, 0.06513701f, 0.09743469f, 
    0.09538720f, 0.18089128f, 0.05525534f, -0.06135452f, -0.03182580f, 0.13294986f, 0.64749897f, 0.00861737f, 
    0.41014835f, 0.07176820f, 0.23378156f, 0.27433443f, -0.03896349f, 0.05064514f, 0.35854593f, -0.03627105f, 
    -0.30551371f, -0.01174569f, 0.05539430f, -0.09572707f, -0.11863615f, -0.07818938f, 0.01058044f, 0.12076992f, 
    0.42183977f, -0.04538254f, 0.16348681f, -0.15462302f, 0.10316946f, -0.00077068f, 0.02220462f, -0.38267723f, 
    -0.11164876f, -0.20008703f, -0.41240954f, 0.10499197f, -0.09394401f, -0.14445814f, 0.06529585f, 0.27509332f, 
    0.75829691f, 0.17988400f, -0.11337310f, -0.34489647f, 0.00416255f, -0.14553846f, 0.29556990f, -0.02946516f, 
    -0.01024081f, -0.48409098f, -0.28063333f, 0.12259922f, -0.11440723f, 0.16803527f, 0.28441763f, -0.03525620f, 
    0.07938974f, 0.05949252f, -0.58036846f, 0.11702850f, -0.13958347f, -0.17110553f, -0.02863404f, -0.09613377f, 
    -0.07239038f, 0.26380703f, -0.03250124f, -0.13033649f, -0.21013105f, -0.40972209f, -0.07413913f, -0.00479558f, 
    -0.01391452f, -0.03078558f, -0.10012741f, -0.37060758f, -0.88933355f, 0.13662606f, -0.01993907f, 0.22990619f, 
    0.18516789f, -0.01631072f, -0.04100458f, -0.08119312f, -0.12692580f, -0.31953695f, -0.44106242f, -0.11570496f, 
    0.28207198f, 0.17348848f, 0.05620223f, 0.15334547f, 0.13702746f, 0.21798253f, -0.28241268f, -0.76769644f, 
    -0.06950068f, -0.04909905f, 0.30684668f, 0.04358362f, 0.05164132f, -0.05000787f, -0.13399988f, -0.15901528f, 
    0.48313996f, 0.14252675f, 0.15839173f, 0.13050185f, 0.04679061f, 0.12663920f, 0.24409863f, 0.25828800f, 
    -0.38393271f, -0.60869741f, -0.34046230f, 0.13208242f, -0.12094481f, -0.00587514f, 0.15065926f, -0.04134391f, 
    0.40862903f, -0.18220270f, -0.31887084f, 0.18806617f, 0.15251611f, 0.00235074f, 0.17386766f, -0.06425792f, 
    -0.02805021f, 0.21036299f, -0.09163487f, 0.34677231f, 0.15023257f, -0.34322309f, -0.08240033f, 0.21254036f, 
    -0.04101735f, 0.25694349f, 0.03767711f, -0.48312211f, 0.01857949f, -0.21240613f, 0.18765470f, -0.04901813f, 
    -0.25424135f, -0.11064171f, -0.20499440f, -0.11132250f, 0.07342558f, 0.20842300f, 0.18344398f, 0.02233530f, 
    0.04929026f, 0.01779063f, 0.03962972f, 0.11226813f, 0.00698644f, -0.00567373f, -0.03022600f, -0.24475229f, 
    0.05952311f, -0.31200397f, 0.03382621f, -0.01743216f, 0.05501143f, -0.09088653f, -0.14233807f, 0.07311755f, 
    -0.11877619f, 0.07288319f, 0.05554936f, 0.22876118f, 0.11853220f, -0.03279434f, 0.24757457f, 0.10055800f, 
    0.37557563f, -0.22653832f, -0.05954998f, -0.11248154f, 0.17594039f, -0.04673432f, 0.17363106f, 0.02324621f, 
    0.68040061f, -0.11046497f, -0.59578192f, 0.23115756f, 0.14133266f, 0.31419405f, -0.03725437f, 0.11744500f, 
    -0.01391325f, -0.00623883f, -0.21881744f, -0.06685149f, -0.08249204f, 0.54092836f, 0.01297892f, -0.26462266f, 
    0.03161538f, -0.07440831f, -0.01789989f, -0.49227911f, 0.08885540f, 0.11048736f, 0.12565486f, -0.05828713f, 
    -0.01665836f, 0.00828849f, -0.16087805f, 0.08561785f, -0.17052715f, -0.24759321f, 0.10592750f, 0.22269483f, 
    0.10113826f, -0.02252570f, -0.11249990f, -0.22955348f, -0.00112922f, 0.15323895f, -0.60533959f, -0.03709072f, 
    0.15871975f, 0.22901629f, -0.01829633f, -0.03220421f, 0.21945274f, -0.05211095f, -0.21275605f, -0.00587916f, 
    -0.22318122f, -0.21082829f, -0.11727576f, 0.28764236f, 0.15676616f, 0.09256483f, -0.73879659f, -0.02560358f, 
    0.15475206f, -0.08238319f, 0.25453988f, -0.05851132f, -0.02903420f, -0.02711553f, -0.03215494f, -0.09460671f, 
    0.27438551f, 0.34261546f, 0.01392647f, -0.17991203f, 0.16422141f, 0.22394811f, 0.38983837f, 0.00323024f, 
    -0.15144704f, -0.12540954f, 0.45372033f, -0.10139398f, -0.04538605f, 0.09791458f, -0.06063945f, -0.04913941f, 
    -0.25786984f, 1.13170469f, -0.05222610f, -0.23456675f, -0.17048094f, 0.10522540f, 0.22584593f, -0.04271265f, 
    -0.15540923f, -0.01063258f, -0.20309536f, -0.03015854f, 0.28266963f, -0.24597317f, 0.33545712f, 0.12350388f, 
    0.00889523f, -0.03629059f, -0.14767320f, 0.04348243f, -0.37816036f, -0.16298369f, 0.33887956f, 0.14972821f, 
    0.18648407f, 0.09142368f, -0.27055499f, 0.32779527f, 0.36263525f, 0.38950524f, 0.25367472f, -0.37117645f, 
    -0.39595914f, -0.24492040f, -0.03605363f, -0.01439553f, -0.04538176f, -0.37806821f, 0.12669156f, -0.17860740f, 
    -0.09401919f, -0.00661312f, -0.24904247f, -0.36783403f, 0.08744063f, -0.13392073f, -0.00178035f, 0.23965159f, 
    0.23308101f, -0.18372719f, -0.28123263f, -0.22204250f, 0.22121878f, 0.23040527f, 0.45599708f, -0.00895987f, 
    0.09622467f, 0.23298593f, -0.46963209f, 0.01774751f, -0.08986868f, -0.24104032f, -0.07123201f, -0.17240013f, 
    -0.05256660f, 0.55818295f, -0.16104284f, -0.04244970f, 0.02674584f, -0.08568854f, 0.40747392f, -0.11575358f, 
    0.14765061f, 0.03144268f, -0.00453078f, -0.02430511f, -0.27161384f, -0.09723539f, 0.27944586f, -0.12285794f, 
    -0.14788100f, -0.09251156f, 0.01412696f, 0.46223617f, 0.38232133f, 0.14379987f, 0.17328887f, 0.17195369f, 
    -0.04126135f, 0.30548927f, 0.04440254f, 0.17886336f, -0.02400992f, -0.18260053f, 0.28970757f, 0.17655729f, 
    -0.05144763f, 0.02482481f, 0.02292147f, -0.06795536f, 0.32761550f, 0.03831054f, 0.58488530f, 0.16740373f, 
    0.05361259f, -0.05094843f, 0.17757177f, 0.00945302f, -0.04278835f, -0.14814055f, 0.14338155f, -0.01867192f, 
    0.22860774f, -0.14478090f, -0.09594548f, -0.29245156f, -0.03442519f, -0.23917159f, 0.15079489f, -0.16133061f, 
    0.15710175f, 0.11188310f, 0.00431561f, 0.03767146f, 0.11703379f, 0.08532979f, -0.11844905f, -0.32714671f, 
    0.17844385f, -0.30922198f, 0.18519150f, -0.16159038f, 0.14629591f, 0.14150523f, 0.16651268f, 0.11588718f, 
    -0.01201157f, -0.12137421f, -0.37002975f, 0.04720305f, -0.18656819f, -0.17089917f, -0.12481553f, 0.09589226f, 
    0.14632000f, -0.28849620f, -0.39451733f, 0.32656261f, 0.14519161f, 0.07267926f, 0.00177991f, -0.08434952f, 
    -0.15281138f, -0.04522707f, -0.39159551f, 0.00687185f, -0.42929119f, -0.10159861f, -0.19641046f, -0.16739833f, 
    0.06088408f, 0.00058736f, 0.21651091f, 0.31241348f, 0.33415243f, 0.45520738f, 0.29685223f, 0.08447507f, 
    0.24050994f, -0.20787641f, 0.20364565f, 0.12176839f, 0.00035386f, 0.24441764f, 0.00260992f, -0.00408568f, 
    -0.06582998f, -0.23200850f, -0.01611404f, -0.06573995f, -0.05473842f, -0.28010881f, 0.01157768f, 0.33286709f, 
    -0.26580217f, -0.01817761f, -0.13785832f, -0.31693539f, -0.14830464f, -0.07295191f, -0.01840223f, -0.48335186f, 
    -0.16534415f, -0.31935480f, -0.27190176f, 0.17797439f, -0.03780981f, -0.10115402f, -0.12386539f, -0.59095842f, 
    0.01265620f, -0.19933935f, -0.14648989f, -0.25267640f, -0.14143880f, -0.05297615f, -0.06320482f, 0.06076176f, 
    0.14192069f, 0.22842775f, -0.00266791f, 0.31252226f, 0.02659383f, 0.23466223f, -0.20268694f, 0.38660014f, 
    -0.09127201f, -0.20341006f, 0.08367764f, 0.15012987f, 0.00168773f, 0.26781556f, 0.00947739f, 0.40495491f, 
    0.04270213f, 0.10331009f, -0.07159962f, 0.04844157f, -0.18120046f, -0.50124842f, -0.07069446f, 0.03513281f, 
    -0.19582666f, 0.03700189f, 0.25675443f, 0.34638610f, 0.01585023f, 0.14641489f, 0.09531906f, 0.00939614f, 
    -0.15208063f, 0.00021754f, 0.28621882f, 0.05879838f, 0.10580640f, -0.14739288f, 0.21126108f, 0.02323110f, 
    -0.01335612f, -0.23116741f, 0.11133204f, 0.17727703f, 0.17429191f, 0.32372463f, -0.51553166f, -0.02060311f, 
    -0.01718346f, -0.25207779f, 0.03898967f, 0.05081961f, 0.10837322f, -0.07580702f, 0.40373972f, 0.24168943f, 
    0.12530825f, 0.07076786f, -0.28247920f, -0.03390837f, -0.06316226f, -0.01262096f, 0.10003364f, -0.70513636f, 
    -0.47460568f, -0.37519482f, -0.02070568f, 0.23760639f, 0.23163299f, 0.11496738f, -0.13712031f, 0.34840760f, 
    -0.09191489f, -0.15164655f, -0.13030329f, -0.08258835f, -0.04635171f, 0.03962211f, 0.19640496f, -0.08114851f, 
    0.12967391f, -0.20214027f, 0.14162180f, -0.00535735f, 0.07197953f, -0.18295398f, -0.03339768f, 0.28178740f, 
    0.14109050f, -0.03444236f, -0.55031002f, -0.61751437f, -0.10884029f, 0.37129760f, 0.03442101f, 0.18499884f, 
    0.01615195f, -0.04013972f, -0.71705180f, 0.20163901f, 0.36233532f, -0.14800040f, -0.44276834f, -0.03741497f, 
    0.14969596f, 0.07519194f, 0.13623306f, -0.12582047f, -1.05752456f, -0.58171129f, -0.20326746f, 0.16938013f, 
    0.10469227f, 0.12710077f, 0.11980604f, 0.00493546f, -0.16839908f, -0.35396916f, -0.64404982f, 0.22776902f, 
    -0.03788039f, 0.17296819f, -0.37095305f, 0.02903914f, 0.23912488f, 0.26434374f, 0.46075764f, 0.31422231f, 
    0.54959410f, 0.25729117f, 0.00794120f, 0.12133617f, 0.03316332f, -0.07031073f, -0.06969223f, 0.25974244f, 
    -0.03895976f, 0.10362988f, 0.02487539f, 0.05840497f, -0.32788908f, -0.20186035f, -0.04929632f, 0.09271678f, 
    0.23698416f, -0.10920943f, 0.15529013f, -0.13029689f, 0.26781771f, -0.16866434f, 0.17028521f, -0.10657077f, 
    -0.19363719f, 0.16588394f, -0.26643234f, -0.29040158f, 0.25570932f, -0.01168194f, -0.01427685f, -0.10076578f, 
    -0.14706279f, -0.01845068f, 0.04827317f, 0.97157407f, -0.05036679f, 0.10854334f, 0.12753803f, -0.10661443f, 
    0.13342322f, 0.05309138f, -0.02400714f, -0.31527987f, 0.49157244f, -0.01595716f, 0.10576744f, 0.00792716f, 
    -0.04288688f, 0.07144378f, -0.13992740f, -0.10710162f, -0.00403623f, 0.47584039f, 0.07889957f, 0.12595761f, 
    -0.01904846f, 0.25987726f, 0.18277270f, 0.11302269f, -0.13988924f, -0.62491250f, -0.44181889f, -0.17734469f, 
    0.14789963f, 0.07401845f, -0.08188207f, -0.15183356f, -0.07331582f, -0.12466904f, -0.19638713f, 0.43583643f, 
    -0.25484028f, 0.16142499f, -0.17396277f, -0.19860478f, 0.06503967f, 0.02014041f, 0.20721039f, 0.04324511f, 
    -0.49987423f, 0.15651484f, 0.09241967f, 0.18243179f, -0.25426716f, 0.01459376f, -0.02505453f, 0.30763742f, 
    -0.09582760f, 0.43829587f, 0.11461229f, -0.20163564f, -0.03491786f, -0.27295417f, -0.03579182f, -0.11436645f, 
    -0.03236917f, 0.05357940f, 0.22095469f, -0.07714911f, -0.16611534f, 0.00335793f, -0.05070154f, -0.11630522f, 
    0.20187508f, -0.00988704f, 0.45882252f, -0.24968991f, 0.11249456f, 0.25337145f, -0.07121332f, -0.17339943f, 
    0.12843202f, 0.12203341f, 0.07274476f, -0.04972400f, 0.00529325f, -0.21636330f, 0.05908222f, 0.27206174f, 
    -0.24584098f, -0.09215998f, -0.01984098f, 0.16776825f, -0.12624840f, 0.11296301f, 0.04233035f, 0.14157863f, 
    -0.17590442f, -0.06609473f, -0.04809873f, -0.10015862f, 0.23441468f, -0.44623661f, -0.20035449f, 0.00798960f, 
    0.21347755f, -0.07010472f, 0.05882136f, -0.01537853f, 0.03826004f, 0.09096049f, -0.55218911f, -0.55828899f, 
    0.12517394f, 0.01021358f, 0.06680380f, 0.22618164f, -0.21389331f, -0.08369516f, -0.16003552f, 0.32910508f, 
    -0.26676419f, -0.04329058f, 0.04437042f, -0.17982693f, 0.05655082f, 0.13237825f, 0.05764151f, 0.09688995f, 
    -0.02346784f, 0.00296475f, 0.02987018f, -0.08471269f, 0.00035803f, 0.04894919f, -0.09296517f, -0.02043415f, 
    -0.03740354f, -0.03057793f, -0.01482130f, 0.02312677f, -0.03958181f, -0.03153500f, -0.06171346f, 0.02447263f, 
    -0.00464489f, 0.02108996f, 0.02558691f, -0.03679810f, 0.04724104f, -0.07046320f, -0.04612023f, -0.04838514f, 
    0.05055121f, -0.07781783f, -0.08993878f, -0.07829552f, -0.09816886f, -0.00401247f, 0.01653041f, 0.02354706f, 
    0.00789076f, 0.03490529f, -0.06563374f, 0.05378355f, 0.05987145f, -0.02041861f, -0.04199029f, 0.05628197f, 
    -0.02851658f, 0.01991771f, 0.01191886f, 0.00771360f, 0.01049744f, -0.01659672f, -0.01052323f, -0.05770170f, 
    0.00344780f, -0.05818371f, -0.04684514f, 0.00803460f, -0.07913345f, -0.07513974f, 0.00144120f, -0.05520766f, 
    -0.05334479f, -0.08965460f, -0.00069656f, 0.02177740f, 0.04375088f, -0.05593991f, -0.09017430f, -0.06847572f, 
    -0.08747435f, -0.08607025f, 0.06464981f, -0.03427711f, -0.09201752f, -0.02721271f, 0.01416604f, -0.00283465f, 
    -0.08484242f, 0.05685721f, -0.08516717f, 0.02252312f, 0.02201638f, 0.03144572f, 0.05401269f, 0.01119536f, 
    -0.03764803f, 0.06724927f, -0.04791117f, 0.04892740f, -0.01164615f, 0.00120342f, -0.04697140f, 0.03820172f, 
    -0.07560168f, -0.06215321f, 0.01225318f, 0.00812678f, -0.02776039f, -0.02931019f, 0.05391587f, 0.05731435f, 
    -0.02077826f, -0.06348865f, -0.06338290f, -0.00425018f, -0.00265571f, 0.02062576f, -0.06847657f, 0.02254427f, 
    -0.04774192f, -0.08497225f, 0.02969434f, -0.06284043f, 0.01686667f, 0.00637771f, 0.04547362f, 0.05105989f, 
    0.05449301f, 0.01718122f, -0.00111514f, -0.02080377f, 0.01377297f, 0.05773496f, -0.03021939f, -0.08590949f, 
    -0.07105099f, -0.03616937f, 0.02372370f, 0.00673164f, -0.01673413f, -0.09093574f, -0.06438443f, 0.05281879f, 
    -0.04512281f, 0.01344624f, 0.06005388f, -0.01201622f, -0.02518465f, -0.09226705f, 0.02637731f, -0.05055415f, 
    0.06066097f, 0.03225023f, 0.03805327f, -0.00432148f, 0.02428188f, -0.04896494f, -0.00659202f, -0.04609272f, 
    0.21227126f, 0.01788753f, -0.10926586f, 0.22665331f, 0.15892622f, -0.56063843f, 0.20233804f, 0.27340370f, 
    0.01819748f, 0.25830945f, 0.40657213f, 0.18901756f, -0.04682880f, -0.01275933f, -0.06419335f, -0.08200713f, 
    -0.20685497f, -0.30362871f, 0.06344264f, 0.20801342f, 0.02275305f, -0.18740077f, -0.12047239f, 0.20217748f, 
    -0.01363514f, 0.40149629f, -0.00274716f, 0.46053696f, 0.07450712f, 0.09085841f, -0.02880370f, 0.19013411f, 
    -0.19088972f, 0.01947225f, 0.05881318f, 0.21621516f, -0.20285712f, 0.19401896f, 0.02435107f, -0.07221207f, 
    -0.09452631f, 0.13113132f, -0.24378175f, 0.14879668f, 0.11283433f, 0.53146005f, -0.17738244f, -0.08466077f, 
    0.08769146f, -0.03626730f, 0.04388228f, -0.10024288f, 0.06255662f, -0.29692549f, -0.05946165f, 0.17069586f, 
    0.15926886f, -0.01228779f, -0.14614831f, 0.04012829f, 0.00040138f, -0.05574592f, -0.04087674f, -0.35828859f, 
    -0.15393086f, -0.35822597f, -0.46262664f, 0.01464028f, -0.14805235f, 0.00650339f, 0.05757245f, 0.16534422f, 
    -0.54247189f, -0.08847819f, 0.05220157f, -0.07123285f, 0.04350395f, 0.08038612f, -0.32602367f, 0.02586916f, 
    0.21181415f, -0.08554102f, -0.02681137f, 0.07002934f, 0.02088969f, 0.05629751f, 0.02096412f, 0.11940269f, 
    0.06070018f, -0.08362242f, -0.20231466f, -0.04776929f, 0.01686181f, 0.26075318f, 0.00440299f, 0.05931989f, 
    0.04377531f, 0.23407523f, 0.48765260f, 0.18506765f, 0.36131379f, -0.07008214f, 0.01085305f, 0.22547418f, 
    -0.02145098f, 0.09984304f, 0.04303298f, -0.05863268f, -0.77482384f, -0.65748918f, 0.12499686f, 0.01514576f, 
    -0.01315117f, 0.23534110f, -0.12142018f, -0.14386252f, 0.11324607f, 0.09146260f, -0.30569044f, 0.09233082f, 
    -0.23372713f, 0.02577559f, -0.09640558f, 0.21569003f, -0.16673608f, 0.02530709f, 0.08417101f, 0.15383105f, 
    0.22932081f, 0.11175614f, -0.02107872f, 0.34051761f, -0.34636509f, -0.09445824f, -0.20197164f, 0.44005033f, 
    -0.23681666f, -0.16132104f, -0.19342740f, -0.18426794f, 0.36511207f, -0.27451411f, 0.03410943f, -0.17578611f, 
    -0.14374086f, 0.32799152f, -0.05084960f, 0.00966519f, 0.14681576f, -0.29503742f, 0.10626930f, 0.14896457f, 
    -0.15676153f, 0.27828005f, -1.01008189f, 0.28646305f, 0.07580126f, 0.10108813f, 0.20181656f, 0.18790311f, 
    0.19385268f, -0.08861286f, 0.13132000f, 0.35314021f, -0.07216270f, 0.24880771f, 0.08149500f, 0.12223637f, 
    -0.03719660f, 0.00524318f, -0.33485562f, 0.19867051f, 0.48509270f, -0.19173428f, -0.02102788f, -0.17040469f, 
    0.07787047f, 0.05384793f, 0.08917490f, 0.11709233f, -0.06714979f, 0.19175468f, 0.04929870f, 0.13845539f, 
    0.06998625f, 0.33609423f, 0.09266258f, -0.05405344f, 0.16339429f, -0.16769157f, -0.74511492f, -0.31981605f, 
    -0.16081639f, 0.09363667f, -0.08501291f, 0.11685709f, -0.05572855f, -0.09118547f, -0.51461768f, -0.48155877f, 
    -0.30757439f, -0.18075103f, 0.05129606f, 0.10259283f, -0.00189687f, -0.10290113f, -0.22854288f, 0.13421243f, 
    0.19694950f, 0.23026411f, -0.34149292f, -0.14160016f, -0.22678110f, -0.06553155f, 0.05183888f, -0.07834596f, 
    -0.88878876f, -0.02048219f, -0.14555517f, 0.05445543f, 0.02068611f, 0.02591531f, 0.05690684f, -0.01233372f, 
    -0.01855820f, 0.55078530f, 0.25647083f, -0.35449013f, 0.02975824f, 0.13565955f, -0.14402819f, 0.10934079f, 
    -0.06835581f, -0.14267820f, -0.03300238f, 0.17947701f, 0.05380186f, -0.15858318f, -0.17796852f, 0.10695372f, 
    0.04330677f, 0.16625698f, -0.00353535f, 0.33477825f, 0.02634848f, -0.36126769f, -0.09269164f, 0.23589368f, 
    -0.22089732f, 0.16094467f, 0.05122062f, 0.07157151f, 0.07661806f, 0.26696450f, -0.06059546f, 0.04243745f, 
    -0.29916105f, -0.03245864f, -0.03186090f, -0.01290000f, 0.06125474f, 0.75793964f, -0.06071291f, -0.13434644f, 
    0.05005990f, -0.29674837f, 0.09789962f, -0.06823079f, -0.05054317f, 0.26096559f, 0.12910078f, -0.29765949f, 
    -0.26352143f, 0.07352994f, 0.01752696f, 0.13861334f, 0.04070069f, 0.15156524f, -0.03666508f, 0.05550878f, 
    -0.37837374f, 0.21166000f, 0.06677791f, 0.05915383f, 0.12167384f, -0.04680558f, -0.02685405f, 0.16892788f, 
    -0.07803895f, 0.06703763f, -0.05001840f, -0.06278609f, -0.05561062f, -0.08760748f, 0.01753390f, 0.05796397f, 
    0.06286380f, 0.00016455f, -0.03879858f, -0.05146594f, -0.08122461f, -0.06291056f, -0.01844142f, -0.02306122f, 
    -0.02115926f, -0.06726358f, -0.02382975f, 0.06559876f, 0.05588350f, 0.01236658f, -0.03604313f, 0.05351769f, 
    -0.05813857f, -0.04302653f, -0.07097736f, 0.08832912f, 0.04275643f, -0.06988478f, -0.05868347f, -0.07820307f, 
    -0.04634636f, -0.01162530f, -0.02981900f, -0.08932522f, -0.01751895f, -0.06831298f, -0.08410060f, -0.01216842f, 
    -0.02246746f, -0.03360052f, 0.03129460f, -0.06780641f, 0.00478285f, -0.06249756f, -0.09015126f, -0.08344059f, 
    -0.05725902f, 0.03005446f, -0.05154186f, -0.04296892f, -0.04508788f, 0.03957189f, -0.02898563f, 0.00992998f, 
    0.02213105f, -0.03984494f, -0.06453089f, -0.08602344f, -0.04195453f, -0.08386606f, 0.00192088f, -0.00123652f, 
    -0.01544693f, -0.03482327f, -0.00603298f, 0.02551635f, 0.04186922f, -0.05743051f, 0.05316728f, -0.04790445f, 
    0.07845505f, -0.03059207f, -0.02202645f, 0.01610246f, -0.06330948f, 0.05326822f, 0.00531743f, -0.08157066f, 
    -0.01783049f, -0.06369974f, 0.00948256f, -0.01367647f, 0.02536612f, -0.04175514f, -0.00249249f, -0.06985434f, 
    -0.07583621f, -0.00239139f, -0.00637555f, -0.06135967f, 0.01470829f, 0.01613814f, -0.06053403f, -0.02302015f, 
    0.03743209f, -0.00177933f, 0.06550710f, 0.01986633f, -0.00837847f, -0.06945152f, -0.04082575f, -0.00984570f, 
    -0.05708894f, 0.04161284f, -0.00851449f, -0.05175214f, -0.03186135f, -0.03041867f, -0.06811714f, 0.08266065f, 
    0.03849605f, 0.01157984f, 0.03894111f, 0.00354772f, -0.03687090f, 0.00548160f, 0.07557003f, -0.03676037f, 
    0.01019038f, -0.03136104f, 0.00675346f, 0.05627607f, -0.05023469f, 0.00608700f, 0.01944628f, -0.01093434f, 
    -0.03880459f, -0.03142930f, -0.02691559f, -0.03137257f, 0.07278186f, 0.06784183f, 0.04121266f, 0.04209560f, 
    -0.05781416f, 0.03381273f, -0.05084293f, -0.08292373f, -0.02778457f, -0.09867308f, 0.05246855f, -0.06008545f, 
    0.05011304f, 0.00826634f, -0.00684815f, -0.08932164f, -0.07812247f, 0.01410532f, -0.07427724f, 0.02975848f, 
    0.03267113f, -0.09785812f, -0.00967824f, -0.09914564f, -0.06770676f, -0.04240645f, -0.04973821f, -0.01131551f, 
    -0.02007512f, 0.04366999f, -0.07092610f, -0.07289025f, -0.01277164f, -0.00944833f, -0.01810829f, 0.05791811f, 
    0.02205327f, 0.00608381f, -0.07194214f, -0.01336099f, -0.02680852f, -0.01989262f, 0.05519663f, -0.04641230f, 
    0.04651799f, -0.03216016f, 0.04456035f, 0.00858222f, -0.04416037f, 0.03548319f, -0.00198167f, -0.00250416f, 
    0.00176372f, 0.04114996f, 0.01326371f, 0.00468199f, -0.00463417f, -0.03091064f, 0.05891985f, -0.02971520f, 
    -0.03066609f, 0.03852789f, 0.04592170f, 0.03458543f, -0.08003692f, -0.01684201f, 0.03578282f, 0.01776141f, 
    -0.08547074f, 0.01038261f, 0.07064734f, -0.02657446f, -0.02247588f, -0.09989028f, 0.00786223f, 0.00931301f, 
    0.06889233f, -0.05609027f, -0.05641867f, -0.06166387f, 0.06460296f, 0.00464243f, -0.04446978f, 0.06273889f, 
    -0.02969341f, -0.02360626f, 0.06315017f, 0.05493688f, 0.00129972f, -0.07917473f, 0.06864895f, -0.08930374f, 
    0.02350692f, -0.05151813f, -0.05788993f, 0.04746877f, 0.01858040f, 0.02238008f, -0.06554572f, 0.01441096f, 
    -0.04914369f, -0.08414546f, 0.03643367f, -0.03888248f, -0.06733083f, -0.08601059f, 0.02448878f, -0.01881636f, 
    0.04972121f, -0.09464672f, -0.04301571f, 0.04202814f, 0.05324000f, -0.07012910f, -0.07514308f, -0.08520126f, 
    -0.03706488f, 0.00721196f, 0.04113979f, -0.01916052f, -0.01675725f, -0.02917261f, 0.02276845f, 0.04074504f, 
    0.05766899f, 0.00170665f, 0.03579189f, 0.02419113f, -0.06980892f, -0.03898941f, 0.06502982f, 0.02982839f, 
    0.00765917f, 0.04007549f, -0.01809531f, 0.04762474f, 0.00531112f, 0.01022118f, 0.03744293f, -0.05413056f, 
    -0.01229247f, 0.06281823f, 0.03974550f, -0.04521645f, 0.00104951f, 0.03902675f, -0.08906209f, 0.01610490f, 
    -0.00951190f, -0.03259718f, -0.01269731f, -0.09357879f, -0.08156896f, -0.02135029f, -0.01700506f, -0.03309200f, 
    0.25395489f, -0.18602557f, -0.13877842f, -0.09272952f, 0.05406123f, 0.05402616f, 0.15328576f, 0.14744779f, 
    0.06644045f, 0.43362269f, 0.08540039f, 0.01511135f, 0.06136508f, -0.08783352f, 0.03281994f, -0.13097672f, 
    0.06054284f, -0.09538057f, -0.11873735f, 0.13404849f, 0.78133148f, 0.34842345f, 0.01927056f, 0.14389288f, 
    -0.13894169f, 0.02447689f, 0.02009981f, 0.13523921f, -0.25754246f, 0.39703074f, -0.25362363f, 0.05628582f, 
    -0.01831664f, -0.19366828f, 0.14304291f, 0.04673602f, -0.13813031f, 0.00825908f, 0.41689283f, 0.12224193f, 
    -0.05197576f, 0.15546331f, 0.14926676f, -0.03793873f, 0.03042039f, -0.31255311f, -0.14256561f, -0.59542155f, 
    -0.01029461f, -0.29465532f, -0.13922037f, 0.01412865f, -0.08089042f, 0.20986927f, -0.09910136f, 0.32492810f, 
    -0.21351904f, 0.04200380f, 0.09889902f, -0.08797500f, 0.03044203f, 0.00734642f, -0.14957695f, 0.41898558f, 
    -0.01604179f, -0.45006645f, 0.05289844f, -0.10068686f, -0.08876593f, -0.08811131f, 0.13965158f, 0.09618846f, 
    0.45932734f, 0.07427047f, -0.22197568f, -0.12699369f, -0.18625052f, -0.10492533f, -0.00325138f, 0.15185778f, 
    0.13904525f, -0.62671435f, -0.02225520f, 0.06873769f, 0.01688433f, 0.00521716f, 0.00328196f, 0.03039368f, 
    -0.06156536f, 0.06944970f, -0.10983414f, 0.31417760f, 0.15454274f, 0.03050085f, 0.01589984f, -0.07615261f, 
    0.07816586f, -0.07379201f, -0.06540155f, -0.38353419f, -0.32036448f, 0.50419468f, 0.12719722f, -0.11975544f, 
    0.15176934f, -0.16205502f, -0.06308659f, -0.00565661f, 0.05834986f, 0.34707513f, -0.07375630f, 0.03092851f, 
    -0.02979774f, 0.03307955f, -0.13651177f, -0.01026824f, -0.25156865f, 0.46050373f, 0.05880570f, -0.27856377f, 
    0.22346011f, 0.01728564f, -0.08307545f, -0.09505006f, -0.17089562f, -0.20463678f, -0.26356584f, 0.29507068f, 
    -0.58582121f, 0.17806208f, -0.02773502f, -0.09206300f, 0.16125019f, 0.03740996f, 0.16756593f, 0.09584363f, 
    0.15714160f, -0.46347553f, -0.11650985f, 0.13792893f, -0.25380546f, -0.03419808f, 0.15801680f, -0.23777805f, 
    -0.37896484f, 0.35536063f, 0.15929534f, -0.13039738f, -0.02566318f, -0.32478929f, -0.00514370f, 0.01325387f, 
    -0.03773357f, -0.17459106f, 0.04722008f, -0.20483546f, 0.30668077f, 0.03337731f, 0.35373607f, -0.07610123f, 
    -0.02771270f, -0.04941774f, -0.09891277f, -0.17373054f, 0.74167144f, 0.13330117f, -0.05841698f, -0.16122364f, 
    -0.00492321f, 0.00564774f, 0.00228508f, 0.81825256f, 0.22755855f, 0.24824122f, 0.25659803f, 0.08005606f, 
    0.22246967f, 0.08189307f, -0.22316997f, 0.20270978f, -0.15753001f, -0.24832514f, -0.16651484f, 0.26682183f, 
    0.06400845f, -0.19933055f, -0.04849682f, 0.15755613f, 0.15356091f, -0.20502177f, -0.51321989f, -0.48207521f, 
    0.03645527f, 0.09424838f, -0.09658499f, 0.02673649f, 0.00355202f, 0.20783897f, 0.31663617f, -0.37400091f, 
    -0.67734456f, -0.07794423f, 0.01909811f, 0.14005077f, 0.03362915f, -0.06018777f, -0.05364440f, 0.09098560f, 
    -0.39528188f, 0.09534597f, 0.12281136f, -0.02796354f, 0.06122501f, -0.07047401f, 0.16052717f, 0.16106352f, 
    0.53642476f, 0.21012294f, -0.50129706f, -0.29200718f, -0.20082460f, 0.11223038f, -0.16766456f, 0.00561833f, 
    0.05855645f, 0.18270069f, 0.32401618f, -0.46573529f, 0.09378051f, -0.04860679f, 0.00412673f, -0.02827641f, 
    -0.02852885f, 0.02956149f, 0.09099042f, 0.00574223f, -0.02061399f, 0.15224889f, -0.04698041f, -0.07993370f, 
    0.13642730f, -0.16311525f, 0.41000479f, 0.76352435f, 0.08890826f, 0.38215587f, -0.02347857f, -0.18236646f, 
    -0.07746455f, 0.26223531f, 0.11167000f, 0.02663183f, -0.47472724f, 0.07033732f, -0.08875868f, 0.14240055f, 
    0.13334632f, 0.13922702f, -0.17633462f, 0.17036274f, 0.07221382f, 0.04731585f, 0.28475007f, -0.00610377f, 
    0.15043262f, -0.06439316f, 0.04540905f, -0.39687771f, -0.25383425f, -0.15813714f, -0.57550406f, 0.21367340f, 
    -0.36089438f, 0.12061782f, 0.17021506f, 0.05475468f, -0.16907151f, 0.21827070f, -0.19558081f, -0.21978348f, 
    -0.03247042f, -0.24724175f, -0.15568626f, -0.10745762f, 0.25326601f, -0.01814473f, 0.12991415f, -0.07642936f, 
    -0.15409070f, -0.13328433f, -0.23087621f, 0.22517629f, 0.11014020f, 0.16644253f, -0.18169779f, -0.10370772f, 
    0.14517866f, -0.10243764f, 0.37529790f, -0.14981271f, -0.33514631f, -0.29541871f, 0.10255466f, 0.31135386f, 
    0.09549653f, 0.21335720f, -0.01646156f, 0.11814555f, 0.05786742f, -0.20880249f, -0.07362549f, -0.11454336f, 
    -0.26030952f, 0.08140308f, 0.07418925f, -0.21112236f, -0.03825156f, 0.29012814f, 0.20910180f, 0.09703923f, 
    -0.27230853f, 0.06698038f, -0.02788134f, 0.02818984f, 0.35501897f, -0.14230813f, 0.06008064f, 0.07741302f, 
    0.11829951f, 0.01626438f, -0.00809413f, -0.05774038f, -0.08394756f, 0.55182004f, 0.22026521f, 0.33976188f, 
    0.03457670f, -0.13926485f, -0.05229582f, -0.12274863f, -0.17121759f, -0.12614189f, -0.07777550f, 0.32368696f, 
    -0.23303896f, -0.02951556f, -0.29131645f, -0.00991076f, 0.03696149f, -0.09386681f, 0.18474095f, 0.34840104f, 
    -0.13802913f, 0.19211996f, 0.13511890f, -0.02388006f, 0.12537922f, -0.09047156f, 0.21803942f, -0.10163790f, 
    0.23286201f, -0.00218672f, -0.22746614f, -0.16744439f, -0.10693342f, -0.01243263f, -0.09825483f, -0.28346121f, 
    -0.37333450f, -0.25221398f, 0.10333823f, 0.32753024f, -0.13883922f, 0.05268783f, 0.12314819f, -0.09253459f, 
    -0.03746749f, 0.02057355f, 0.00091988f, -0.60333180f, -0.30459780f, 0.22329068f, 0.13127708f, 0.08658073f, 
    0.20313281f, -0.41723987f, 0.03310355f, -0.15948738f, 0.23395377f, 0.33478445f, 0.14754695f, -0.03092961f, 
    -0.10240267f, -0.26619017f, 0.13048524f, 0.44121379f, -0.00281464f, -0.61084402f, -0.10885080f, 0.14572379f, 
    0.18032362f, 0.15783459f, 0.11324187f, 0.15055403f, 0.12979412f, 0.08479959f, 0.08560387f, -0.13015333f, 
    -0.30257404f, 0.23064388f, -0.09459522f, 0.21810788f, -0.01887806f, -0.09698573f, 0.32765710f, 0.07263297f, 
    0.07414984f, 0.18214875f, 0.03112545f, -0.01296941f, 0.09605294f, 0.12211761f, 0.29190183f, 0.27283946f, 
    -0.10080305f, 0.04729287f, 0.07571626f, -0.14515761f, -0.25043193f, 0.01006286f, 0.13400134f, -0.27957880f, 
    0.00432166f, -0.01203586f, -0.04756229f, -0.08259254f, 0.06825173f, 0.01240463f, 0.06814513f, 0.02234717f, 
    -0.05176708f, -0.07361712f, -0.03969460f, 0.02614478f, -0.01453192f, -0.06104614f, 0.02169205f, 0.00264452f, 
    0.02859452f, -0.06919517f, -0.00375994f, 0.08027552f, -0.05964822f, -0.00007402f, -0.00267407f, -0.09020504f, 
    0.02588331f, 0.05920657f, -0.02295703f, -0.01518406f, 0.06731859f, 0.07314076f, 0.05262777f, 0.05430040f, 
    -0.02557064f, -0.02917254f, -0.05813162f, -0.00887770f, -0.04928922f, -0.02123936f, -0.03786981f, -0.04413928f, 
    0.00333745f, 0.06785119f, -0.08567115f, 0.03914868f, -0.02253145f, -0.01842742f, -0.04174775f, -0.00107323f, 
    0.06416442f, 0.00215236f, -0.03394075f, -0.06177535f, -0.08017430f, -0.03590840f, 0.04486680f, 0.01725571f, 
    -0.04482781f, -0.04774720f, 0.05676927f, 0.00094153f, 0.02472859f, -0.04053010f, -0.03869634f, 0.06204418f, 
    -0.02023708f, 0.05853686f, -0.00002438f, -0.01096671f, -0.01209846f, -0.04285831f, -0.00762481f, 0.03182060f, 
    -0.00452101f, -0.02865374f, 0.05730913f, 0.06409287f, -0.01912251f, -0.06351502f, -0.02335453f, -0.01795797f, 
    -0.04137997f, -0.02423158f, 0.06244812f, -0.08132943f, -0.07191307f, 0.02355441f, -0.08163520f, 0.03914534f, 
    0.03054136f, -0.05209024f, 0.02221996f, 0.01622182f, -0.08211245f, -0.04023921f, -0.00204700f, -0.08455852f, 
    -0.04920861f, -0.03099271f, -0.04417002f, -0.02818297f, -0.02281936f, -0.04288717f, -0.03347654f, -0.03046186f, 
    -0.04279981f, 0.00914439f, -0.02161872f, -0.03222949f, -0.08317925f, 0.02342031f, 0.04585762f, -0.06338143f, 
    -0.06854016f, 0.03234519f, -0.02058602f, -0.05941675f, 0.00267389f, 0.05560754f, -0.07749283f, -0.03680250f, 
    0.07315776f, -0.02362847f, 0.00950222f, -0.03017984f, 0.07904816f, 0.04746825f, -0.01995794f, 0.00365171f, 
    -0.08287250f, -0.00750352f, 0.07197207f, -0.08405546f, -0.03515191f, -0.08457466f, 0.03969717f, -0.00343357f, 
    0.00845646f, 0.05459900f, 0.04750236f, 0.02432779f, -0.09087048f, 0.01212512f, -0.07963437f, 0.06527349f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.13357107f, 0.22161421f, 0.47012126f, 0.17730577f, -0.04495631f, 0.08354008f, 0.01669179f, -0.08980782f, 
    -0.04482881f, -0.07032676f, 0.04162684f, -0.01290795f, -0.06054590f, 0.14310372f, -0.05191980f, 0.05518235f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05880950f, -0.57022339f, -0.19161375f, 0.73597777f, 0.54630679f, 0.03549277f, -0.40458027f, -0.07098376f, 
    -0.43702051f, 0.73792434f, 0.05791701f, -0.09500941f, -0.49377203f, -0.21011414f, -0.35362074f, 0.01857963f, 
    -0.31957421f, 0.01977286f, 0.53798282f, 0.29956311f, -0.03458244f, -0.55817187f, 0.14031745f, 0.06779268f, 
    0.21841754f, 0.89218980f, 0.15588839f, 0.15620407f, -0.28149152f, -0.04790979f, -0.50814581f, 0.09811548f, 
    0.20877810f, -0.38339597f, -0.21038765f, -0.12494395f, -0.45430934f, -0.14553536f, -1.59484017f, 0.06500359f, 
    -0.43409255f, -0.39921889f, 0.27345842f, 0.23406389f, 0.23499230f, 1.05319202f, -0.24081816f, -0.09456415f, 
    -0.23262189f, -0.29495725f, -0.64360130f, -0.31592128f, -0.91156447f, 0.48269200f, -0.39018118f, -0.22069226f, 
    0.70063454f, -0.28081343f, 0.11223170f, -0.09674077f, -0.05695094f, -0.41975948f, 0.46469185f, 0.15737337f, 
    -0.17659134f, 0.60190189f, -0.27478144f, 0.03367194f, 0.23488660f, -0.00909976f, -0.18189935f, -0.00818875f, 
    -0.59874773f, -0.66911852f, 0.16930524f, 0.04255465f, 0.05830435f, -0.07454462f, 0.47835732f, -0.02433815f, 
    0.16114347f, 0.48596591f, 0.66471446f, -0.18559152f, 0.61097980f, -0.51200908f, 0.13653739f, -0.17896560f, 
    0.25160173f, 0.01751110f, -0.22449996f, -0.04083157f, -1.19671035f, -0.20031588f, -0.12212570f, -0.21848163f, 
    0.64535564f, 0.46410257f, 0.00554687f, 0.25964788f, -0.29510453f, -0.12871592f, -0.45624560f, 0.15095864f, 
    -0.24274306f, -0.17507188f, 0.19754888f, -0.03411091f, -0.39757442f, -0.73583770f, -0.02838462f, -0.06564147f, 
    -0.72940379f, 0.23436505f, -0.47988179f, -0.38413361f, 0.71437299f, 0.02552279f, 0.22179261f, -0.02463177f, 
    -0.04355639f, -0.32665733f, -0.02698042f, 0.21311308f, 0.40629727f, 0.17388107f, 0.08325798f, 0.16596448f, 
    -0.01783639f, -0.20720993f, 0.43492812f, -0.36093494f, -0.95120066f, -0.46454403f, 1.26228142f, -0.08159708f, 
    -0.05244990f, 0.02070925f, 0.07984387f, -0.10125802f, 0.73103940f, -0.03480696f, -0.35313255f, 0.13317601f, 
    -0.19805773f, -0.01543585f, 0.43316907f, 0.62864101f, 0.21682712f, -0.34850845f, -0.31028080f, -0.09940697f, 
    -0.48824775f, -0.56395620f, -0.09166604f, 0.03637827f, 0.82070976f, -0.45777634f, 0.09585946f, -0.08214372f, 
    0.13635676f, -0.81760001f, 0.00677972f, -0.70549303f, -0.11155532f, 0.85825390f, 0.01625758f, 0.11957349f, 
    0.28485388f, -0.25642744f, 0.15044098f, 0.18488947f, -0.52653813f, 0.31233859f, -0.46406913f, -0.21732272f, 
    0.72073835f, -0.51391679f, -0.65570182f, -0.16293745f, -0.32934636f, 0.12613690f, -0.01047989f, -0.24356438f, 
    -0.39833695f, -0.04107794f, -0.22515428f, 0.09353231f, -0.23747708f, -0.33431423f, 0.51743978f, -0.18982649f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.26516929f, 0.07012627f, 0.08383720f, -0.07513778f, 0.50977367f, 0.05489043f, -0.30826887f, -1.00643575f, 
    -0.72267437f, 0.22104961f, 0.62124550f, -0.09811284f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
