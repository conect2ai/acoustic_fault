#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.85142696f, 0.66242236f, 0.62193388f, 1.35336554f, 1.00167346f, -0.59805870f, -0.54786283f, 0.20348468f, 
    0.00736299f, -1.00898516f, -0.79874331f, -0.51062417f, 0.87951869f, 0.54532230f, 0.85636729f, -0.49768409f, 
    -0.07809940f, -0.70962697f, -0.73903161f, 0.69647312f, 0.99980330f, 0.15272014f, -0.46048987f, -1.46200228f, 
    0.15237373f, 0.41155621f, 0.49619156f, 0.93032467f, -1.35044634f, 1.14075947f, -0.29638699f, -0.64503944f, 
    1.09530056f, -0.03447529f, -0.44250682f, -0.32274213f, 0.51519704f, 1.08896399f, 0.67596996f, -0.81830919f, 
    0.99774683f, -0.01575025f, 0.48959956f, -0.31863764f, -0.03935807f, 0.95217294f, -0.83733267f, -0.83680916f, 
    -0.72613138f, -0.05697083f, -0.37254673f, -0.77808434f, -0.17307805f, 0.90660697f, 0.45087248f, 0.84280968f, 
    0.39749262f, 0.40205851f, -1.58237374f, -0.07964355f, 0.61582536f, -0.07307262f, 0.49382669f, -0.40873179f, 
    -0.70731187f, -0.58650875f, -0.36732671f, 1.21163905f, 0.32477897f, -0.25722215f, -0.19958566f, -0.63500756f, 
    -0.19052884f, -1.46843719f, 0.41637674f, 0.14677440f, -0.43145481f, 0.17569993f, -0.09152079f, -0.06223422f, 
    -0.15210721f, 1.25222278f, 0.89535165f, 1.25514638f, 0.35548577f, -0.55258042f, -0.01943972f, 0.26127476f, 
    0.80095202f, 0.31313804f, 1.18381774f, 0.65190017f, 0.52857560f, -0.61603028f, 0.41882381f, 0.85231692f, 
    -0.83857149f, 0.30852416f, 0.59614789f, -0.69222313f, -1.26353300f, -0.70066142f, -1.10622323f, 0.04565240f, 
    0.45989582f, 0.00595746f, 0.44656688f, 0.29128382f, -1.17301559f, 1.04067075f, -0.65012312f, -0.86001599f, 
    -0.36394703f, -0.82578337f, -0.27260786f, 0.23453240f, -0.39495376f, 0.54970008f, -0.49130499f, -0.78341943f, 
    0.86436683f, 1.03652847f, 0.97151971f, -0.28521520f, -0.18132125f, 0.43745518f, 0.60459310f, 0.58133620f, 
    0.25581381f, 0.58860046f, 0.12054288f, 0.60371804f, 0.47149667f, -0.97073114f, -1.00179350f, 0.29249242f, 
    -0.54049015f, 0.59934449f, -1.13420534f, 0.58151883f, -0.88230550f, 0.80264896f, 0.37263867f, 0.39759973f, 
    -0.94333261f, -0.84252053f, -0.92807138f, -0.29457229f, -0.87195414f, 0.48181349f, 0.01192396f, 0.28024259f, 
    -0.52705771f, -1.21303976f, 1.14865863f, -0.96816283f, 0.61549675f, 0.80529290f, -0.81082588f, -0.20341673f, 
    -0.26337719f, 0.28376260f, -1.42993557f, 0.57152969f, 0.26082915f, -0.70024657f, -0.72399324f, 1.16363454f, 
    0.07448266f, 0.03365887f, -0.22478865f, -0.66732162f, -0.78935456f, -0.27281570f, 0.84935510f, -0.04811274f, 
    1.09250009f, 0.87647891f, -0.64538604f, 0.52709216f, -1.09382951f, 0.68391681f, -0.23194802f, 0.16394900f, 
    0.22711356f, 0.28779942f, 0.54617900f, 0.85838634f, -0.33872637f, 0.81007546f, 1.25615096f, 1.20400119f, 
    -0.61818659f, -0.28048319f, -0.63479257f, -0.77744448f, -0.14821687f, -0.02050998f, -0.02510981f, -0.04093257f, 
    0.32933450f, -0.75967145f, -0.94929290f, -0.91971189f, -0.66437674f, 0.81862289f, 0.37465927f, -0.91390961f, 
    -0.43064207f, -0.63407302f, 0.13191670f, 0.80729663f, -0.46406576f, -0.30761284f, -0.72820324f, -0.75669605f, 
    -1.01286471f, 0.14605990f, 0.40522701f, 0.69907165f, 1.38696623f, 0.68538952f, -0.00268402f, 0.24271441f, 
    0.73866445f, 1.08360696f, 1.32707131f, -0.83755004f, 0.62683105f, -0.42073864f, -0.27267313f, 0.07438165f, 
    -0.23567070f, -0.33159620f, 1.10382843f, -0.84651554f, -0.54590839f, -0.60161173f, -0.92434144f, -0.38679165f, 
    -0.15087150f, -0.10952123f, -0.05136020f, 1.15215456f, -0.58930290f, -0.14925750f, 1.23865950f, 0.28208822f, 
    0.26026270f, 0.68325233f, 0.01768443f, -0.20880795f, -0.35246438f, -0.63306940f, 1.08188617f, 1.01193976f, 
    1.02911603f, 0.27229831f, -0.29987511f, -0.66590816f, 0.15794526f, -0.31995207f, -0.77153844f, 0.18014964f, 
    -0.67920297f, 0.53369534f, -1.18048441f, -0.41443691f, -0.84044641f, 0.00012917f, -0.68384713f, 0.50778991f, 
    -1.22883880f, -0.06086208f, 0.86929977f, 0.53827566f, 1.15252483f, -0.46114379f, 0.16665459f, -0.74267834f, 
    -1.06588280f, -0.71859545f, 0.35266063f, 0.16652191f, -0.31580517f, -0.07357032f, 0.14743182f, 0.33909318f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18985884f, 0.12253233f, -0.01185483f, -0.31763077f, 0.25418076f, 0.21158440f, 0.03437372f, -0.19363576f, 
    0.35773152f, 0.07292940f, 0.22144447f, -0.32105589f, 0.72303236f, 0.15487988f, 0.00529707f, -0.25943223f, 
    -0.13783643f, -0.18053490f, -0.15406570f, 0.07580340f, -0.16040871f, 0.38543639f, 0.16035959f, 0.36026680f, 
    0.23244792f, 0.08098473f, -0.14409415f, 0.11121500f, 0.16364104f, 0.10576765f, 0.03130008f, 0.10228050f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.16700670f, -0.06352244f, 0.16877185f, -0.05906960f, -0.18744391f, -0.02819688f, -0.11586034f, 0.10961850f, 
    0.05747472f, 0.27088177f, 0.24861932f, -0.10631056f, 0.12114743f, 0.00954578f, -0.23963721f, 0.07623951f, 
    0.07699344f, 0.04181963f, -0.47125530f, -0.40025195f, -0.22935838f, -0.20087916f, 0.20710863f, -0.10642686f, 
    0.02386087f, 0.02597625f, 0.20690432f, -0.99615908f, 0.07983271f, -0.08399136f, -0.07758817f, 0.06709255f, 
    -0.05258490f, 0.09476178f, -0.04204835f, 0.02396903f, 0.00645474f, 0.05437110f, -0.03430634f, -0.01642033f, 
    -0.12733690f, 0.06059600f, -0.00762807f, 0.02523533f, -0.14551897f, 0.00274904f, -0.53226125f, -0.13293251f, 
    0.01708751f, 0.20821925f, 0.10932623f, -0.00247531f, -0.17952767f, 0.01171229f, 0.04255372f, 0.03497360f, 
    0.18691741f, -0.06899599f, -0.13003485f, 0.07239303f, -0.03998099f, -0.01472763f, 0.16757056f, 0.21835300f, 
    -0.26264304f, 0.00800410f, 0.17087956f, -0.09066933f, -0.09320588f, 0.15750802f, -0.06767542f, -0.27353889f, 
    0.29233998f, 0.15321542f, 0.52966249f, 0.00192520f, 0.09878925f, 0.19042575f, 0.10390382f, -0.00743193f, 
    0.03293963f, -0.15228683f, 0.00230498f, 0.19517115f, 0.19077602f, -0.06562162f, -0.18017045f, -0.07465681f, 
    -0.16290934f, 0.37296829f, 0.08149825f, 0.21443669f, -0.19444384f, -0.04142308f, -0.18233453f, -0.11868783f, 
    0.21616659f, -0.11739085f, 0.00092164f, -0.05478881f, 0.00071962f, 0.36304128f, 0.03012720f, 0.10652041f, 
    -0.14503044f, -0.01954755f, 0.21042699f, 0.26263177f, -0.14055347f, 0.03489881f, -0.86518037f, 0.12730415f, 
    0.03342377f, 0.36426634f, 0.08390508f, -0.01161162f, -0.02849617f, 0.16129704f, -0.22139247f, 0.11318990f, 
    -0.05700276f, 0.06246931f, -0.02123900f, 0.15867732f, 0.02901652f, -0.02236653f, 0.09019297f, 0.09364225f, 
    0.12561931f, 0.03295405f, -0.02065798f, -0.00654878f, -0.06210814f, 0.17657810f, -0.11260708f, -0.24550521f, 
    -0.25486678f, -0.14264470f, -0.10623845f, 0.05368317f, -0.08438519f, 0.12970115f, 0.05569360f, -0.04951078f, 
    -0.07710381f, 0.39018199f, 0.17491345f, 0.18746234f, -0.08724399f, 0.15854427f, 0.07557075f, 0.05263250f, 
    0.03171724f, -0.57760096f, -0.12725878f, -0.30375090f, -0.08412724f, 0.08781563f, -0.02623170f, -0.03338923f, 
    -0.11945674f, 0.03334599f, 0.00261536f, -0.04035970f, -0.40359125f, 0.31040835f, 0.07403154f, 0.02233056f, 
    0.21446858f, -0.06048575f, 0.02766233f, 0.06094782f, 0.55445623f, -0.13712384f, 0.02370119f, 0.04771861f, 
    0.13573430f, -0.01055037f, 0.11926013f, -0.19151437f, -0.22871970f, -0.12048138f, -0.31405294f, -0.01459236f, 
    -0.05986435f, 0.05609718f, 0.22391886f, 0.05424399f, 0.19519188f, -0.02112066f, -0.05915987f, -0.21129768f, 
    0.21829322f, 0.06780427f, -0.01330417f, -0.00524423f, -0.00592959f, -0.16105105f, -0.43565345f, -0.37514621f, 
    -0.32344547f, -0.04204356f, 0.15272726f, 0.19234063f, -0.07228113f, -0.09430591f, 0.16806868f, 0.04444611f, 
    -0.05754666f, -0.31782442f, 0.05647250f, 0.04159307f, 0.05820297f, 0.10215222f, 0.14697655f, -0.30724680f, 
    -0.24883693f, 0.21792383f, 0.10555864f, 0.06900980f, 0.36286029f, -0.08637939f, 0.07265833f, -0.04540439f, 
    0.05789007f, -0.12717919f, -0.65515143f, -0.00536463f, -0.09312740f, -0.13095738f, -0.03916785f, -0.06197902f, 
    -0.18364741f, 0.08198062f, -0.18777309f, -0.03844992f, 0.01896864f, 0.11139967f, 0.14871137f, 0.16539294f, 
    -0.07701928f, 0.02591737f, -0.28628758f, -0.00947099f, -0.40241006f, 0.22578199f, -0.14535882f, 0.04575008f, 
    -0.05852171f, 0.05211959f, 0.01256407f, 0.00256838f, 0.02566875f, 0.26727942f, 0.00364812f, 0.09944934f, 
    0.03209972f, -0.16254377f, -0.00191538f, 0.17725764f, 0.02878479f, -0.10994586f, -0.19921236f, -0.25868565f, 
    0.08080634f, -0.02249902f, 0.16089942f, 0.10834304f, -0.10570932f, -0.00228833f, 1.01997268f, 0.02769700f, 
    -0.28173935f, 0.26210493f, 0.13862422f, 0.09119023f, 0.10579012f, -0.01944011f, -0.09681024f, 0.32130575f, 
    0.51045889f, -0.08125661f, -0.00318414f, -0.10023920f, 0.07020867f, 0.01291250f, -0.02376780f, 0.04370482f, 
    -0.01363465f, -0.04424103f, 0.01777677f, -0.04716238f, 0.04390791f, 0.00503703f, -0.04658293f, 0.02093895f, 
    -0.05438569f, 0.03079056f, -0.01534675f, 0.03917768f, -0.07503181f, -0.02371721f, 0.01650680f, -0.03678661f, 
    0.00307251f, 0.01270238f, 0.04434325f, -0.03527205f, -0.01878243f, -0.02644406f, -0.01661120f, -0.02347343f, 
    -0.04030864f, -0.04245913f, -0.02282057f, -0.03310563f, -0.00607818f, -0.05764668f, -0.03338546f, -0.06272227f, 
    -0.05944803f, -0.05583547f, -0.05566454f, 0.03042474f, -0.03093547f, -0.07583619f, 0.01903750f, 0.01021519f, 
    -0.01315059f, -0.02849856f, -0.00548296f, 0.04586709f, 0.03388896f, -0.03215895f, -0.03303503f, 0.01044107f, 
    -0.04478514f, -0.05014713f, -0.06390449f, 0.00538399f, -0.07742338f, -0.00807391f, 0.04254496f, 0.00028607f, 
    -0.04474443f, 0.04269218f, 0.00967297f, -0.02443302f, 0.03195878f, -0.00495401f, 0.02093229f, 0.00654011f, 
    -0.00922273f, 0.01510033f, 0.02830795f, 0.04687207f, -0.01929512f, -0.00102421f, 0.02402952f, 0.05055710f, 
    0.01597920f, -0.01496377f, 0.03116590f, -0.06714185f, 0.04402914f, -0.00358718f, -0.07271684f, 0.03171860f, 
    -0.00061854f, -0.01038451f, 0.04319563f, 0.01100878f, 0.03766564f, -0.00697672f, -0.01290837f, 0.05121598f, 
    -0.04183192f, -0.06711946f, -0.01991699f, 0.04702238f, 0.00684633f, 0.01614634f, 0.01005523f, 0.02534358f, 
    0.00539140f, -0.05588077f, -0.02062073f, -0.05575379f, -0.04999716f, 0.02080810f, -0.04979648f, 0.01034568f, 
    0.04116109f, 0.01484754f, 0.00146036f, -0.03979908f, 0.04229813f, 0.00589439f, 0.00331360f, -0.04107769f, 
    -0.02010018f, 0.01866042f, -0.02042240f, -0.01231945f, -0.02272206f, -0.03397517f, -0.04134560f, -0.06051473f, 
    -0.02871137f, 0.04113718f, 0.02285677f, -0.04072121f, 0.01384488f, -0.05104065f, 0.01558363f, 0.04911661f, 
    -0.02413890f, -0.01827476f, -0.03891414f, -0.06688503f, -0.06736666f, -0.02361447f, -0.04321278f, -0.04630126f, 
    0.00844958f, 0.02179304f, -0.05090968f, -0.03323983f, -0.02596365f, -0.04598948f, -0.07345311f, -0.07048973f, 
    0.02474608f, 0.00132498f, -0.05891927f, 0.01801724f, -0.05923053f, 0.04606569f, -0.03862125f, -0.00955190f, 
    0.00835632f, 0.01598059f, -0.03147781f, -0.01101131f, 0.01169101f, 0.02644961f, -0.06455420f, 0.01962175f, 
    0.03745831f, -0.04439472f, -0.00192465f, -0.01605125f, -0.01129889f, -0.07023432f, -0.00360158f, 0.01537774f, 
    -0.03068155f, -0.03528721f, -0.03936923f, 0.03829603f, 0.01466725f, 0.04454824f, -0.00900479f, 0.00043038f, 
    -0.04700322f, -0.03472376f, -0.03844993f, -0.05103524f, 0.04879232f, -0.01015397f, -0.04059225f, 0.00005856f, 
    0.05768153f, 0.04505424f, -0.04768416f, -0.02219090f, -0.07139385f, 0.01044683f, -0.00903436f, -0.05269851f, 
    -0.03165510f, -0.03395696f, 0.01662479f, 0.01589405f, -0.05371271f, -0.02813398f, -0.02521276f, -0.03350575f, 
    -0.00844846f, -0.02714092f, -0.02208827f, -0.06670320f, 0.02815627f, -0.05368622f, 0.04592561f, 0.02088387f, 
    0.03860111f, 0.04334002f, -0.04851297f, -0.01628942f, -0.02240648f, -0.03377903f, 0.00804361f, -0.04308265f, 
    0.03485797f, 0.03783508f, -0.00264604f, 0.00628974f, 0.02105396f, -0.03212517f, 0.01106519f, -0.00694869f, 
    -0.09702459f, 0.03381085f, -0.03370992f, -0.04994525f, -0.03669993f, -0.00292270f, -0.04892378f, -0.04786317f, 
    -0.01170846f, 0.02481819f, -0.01885827f, -0.03302679f, 0.03106688f, -0.05818808f, 0.02703598f, -0.03687171f, 
    -0.03611584f, 0.02568209f, 0.02074876f, 0.03181819f, 0.03209035f, 0.00675678f, 0.05350420f, -0.05030419f, 
    0.03709254f, -0.01557157f, -0.02882058f, -0.06416616f, -0.04336082f, -0.01362290f, -0.07589911f, 0.00646037f, 
    -0.01158221f, -0.05628536f, 0.00755133f, -0.05127914f, -0.05534838f, -0.06299970f, -0.06209191f, -0.02745116f, 
    -0.02240934f, -0.05017596f, -0.06682694f, -0.01518379f, 0.01545407f, -0.05428614f, -0.04880162f, -0.06067469f, 
    -0.03718806f, 0.02527810f, -0.00764026f, 0.04281596f, -0.05107046f, 0.01892242f, 0.01155879f, 0.04935140f, 
    0.03849339f, 0.06062848f, -0.04140961f, 0.02952349f, -0.07554817f, 0.00440983f, 0.01846605f, -0.02145142f, 
    -0.04296101f, -0.17675234f, -0.40444562f, -0.22067973f, -0.09023537f, 0.19896774f, 0.06546430f, -0.04208954f, 
    0.09879805f, 0.31514600f, 0.21011080f, -0.10534813f, 0.15793337f, 0.19602369f, 0.00047208f, 0.09220107f, 
    0.09877062f, 0.21997739f, 0.19914016f, 0.00097321f, -0.01671216f, 0.14465477f, 0.00937034f, 0.26770034f, 
    -0.05749706f, -0.14468570f, -0.06146174f, 0.05378515f, -0.03686886f, 0.03333778f, -0.10639328f, 0.09307881f, 
    -0.17141220f, -0.09008830f, -0.02421580f, 0.34566143f, -0.61589068f, -0.43723589f, -0.03385554f, 0.11384702f, 
    -0.04508985f, -0.06988534f, -0.16221839f, 0.07963622f, -0.05671822f, 0.28526586f, 0.23742923f, -0.17760457f, 
    -0.07617147f, 0.09072477f, 0.00927129f, -0.20009908f, -0.16191915f, -0.00047840f, 0.19159545f, -0.37146083f, 
    -0.32903388f, 0.28323632f, 0.12520912f, 0.09705384f, -0.05410739f, 0.14188384f, -0.07251760f, 0.33186680f, 
    0.24911195f, 0.07391819f, 0.30930069f, 0.11719404f, -0.19081342f, 0.15559709f, -0.03547325f, -0.10601252f, 
    0.05981832f, 0.20877136f, -0.07609558f, -0.13047655f, -0.16413204f, 0.05074603f, 0.20620742f, 0.12632775f, 
    0.04622891f, -0.62977922f, -0.42845795f, -0.23817986f, 0.07981405f, -0.00664763f, 0.37483844f, -0.04778438f, 
    -0.08630455f, -0.12274787f, -0.12716769f, -0.54610664f, 0.04188740f, -0.20573162f, -0.17976826f, -0.11593028f, 
    -0.11041959f, -0.10523084f, 0.35323253f, -0.11655114f, 0.16835213f, 0.12736425f, -0.06292573f, -0.26919666f, 
    -0.22213764f, 0.19328603f, 0.23897423f, 0.03357127f, 0.15491362f, 0.04966119f, 0.09069292f, 0.10853519f, 
    -0.15401274f, 0.23443691f, -0.12062977f, -0.12556206f, -0.24405080f, 0.29681888f, 0.08520947f, -0.13987079f, 
    0.09417634f, 0.16193169f, -0.34767985f, 0.22446735f, 0.15717891f, 0.24023545f, -0.13990268f, -0.03294563f, 
    0.14233677f, 0.00585071f, -0.05674668f, -0.05863844f, -0.20147234f, 0.09951510f, 0.16012675f, -0.04021267f, 
    0.08258371f, 0.12920824f, 0.08338633f, -0.04369193f, 0.11319850f, -0.25468299f, -0.17300531f, -0.21262504f, 
    -0.01098557f, 0.24141470f, 0.02571213f, 0.05336565f, -0.21243961f, 0.06726229f, -0.13826627f, 0.16671468f, 
    0.06872753f, 0.53582168f, -0.06317971f, 0.14003839f, -0.03842487f, 0.01100895f, -0.03461664f, 0.08624013f, 
    0.02423874f, -0.26791185f, -0.39098057f, -0.00177825f, -0.08522782f, -0.12869909f, 0.24868654f, -0.16243045f, 
    -0.16369928f, 0.02532165f, 0.18715695f, 0.22653177f, 0.14249802f, -0.16090044f, 0.08718966f, -0.11381572f, 
    0.14845473f, -0.07275029f, -0.14191003f, -0.07822512f, -0.08923946f, 0.23588732f, -0.13164045f, 0.08312883f, 
    0.03598955f, -0.04636285f, 0.17487702f, 0.02808048f, 0.12276765f, -0.14218791f, -0.60776806f, 0.10153180f, 
    -0.04169089f, 0.15170076f, 0.15570424f, -0.22851093f, -0.18439038f, -0.06983607f, 0.22349863f, 0.17495835f, 
    0.28571805f, 0.10900023f, 0.06573381f, 0.04157322f, -0.20267512f, -0.07297685f, -0.23957486f, 0.10858860f, 
    0.13838977f, 0.02400672f, -0.00788668f, 0.15948324f, 0.05903542f, -0.12685460f, -0.09568653f, -0.02879128f, 
    -0.22270501f, 0.17218779f, 0.04906666f, -0.05202089f, -0.16348420f, -0.08983816f, 0.10860603f, 0.02958240f, 
    0.19492123f, 0.22079943f, -0.33448961f, -0.00709377f, -0.12999602f, -0.10961169f, -0.06104421f, -0.03512303f, 
    0.01538004f, -0.33240011f, 0.49932688f, 0.30110890f, -0.16883191f, -0.01100743f, -0.09728970f, 0.20336516f, 
    -0.16939355f, -0.20094843f, -0.12956320f, 0.21967211f, -0.13825522f, 0.03543144f, -0.02909353f, -0.10141685f, 
    -0.06264123f, 0.20874888f, -0.04844388f, 0.06039789f, -0.21726348f, -0.25383329f, 0.10650262f, 0.01024714f, 
    0.06369485f, -0.14348212f, 0.12456170f, -0.01198501f, 0.03737440f, -0.27467087f, 0.27411750f, 0.23363408f, 
    -0.06602852f, -0.08669366f, 0.29745111f, -0.33889449f, 0.04728395f, -0.26095340f, 0.10018224f, -0.05559361f, 
    -0.14164025f, -0.26751259f, 0.06441393f, -0.07652935f, 0.12656562f, 0.04276062f, -0.07356786f, 0.14641473f, 
    0.24571507f, 0.31428248f, -0.18515737f, -0.15023805f, 0.06093404f, 0.00896882f, 0.06397962f, 0.11361335f, 
    0.04968870f, -0.01641753f, 0.03746544f, -0.04366494f, 0.04114041f, -0.01124177f, 0.01823363f, -0.02240966f, 
    -0.05715518f, 0.02395918f, -0.03123046f, 0.00674580f, 0.04104804f, 0.03647116f, -0.03624025f, -0.00999484f, 
    0.01424044f, 0.01340746f, 0.04981638f, -0.01530340f, -0.00595119f, -0.03921529f, -0.04336455f, 0.02525565f, 
    -0.04139776f, -0.00606366f, 0.02741634f, -0.01263509f, 0.01092952f, -0.06348857f, -0.06860106f, 0.02389762f, 
    0.03416231f, 0.03959728f, -0.04698592f, -0.06358004f, -0.05651634f, -0.00834941f, -0.00406372f, -0.04464655f, 
    -0.06187594f, 0.01248222f, 0.01862964f, -0.06197974f, 0.03810919f, -0.00756868f, -0.04762512f, 0.03785427f, 
    0.03391679f, 0.01717540f, 0.04507866f, 0.04034979f, 0.01892653f, -0.05289467f, 0.02053743f, -0.00994129f, 
    0.01179577f, 0.01325532f, 0.04947706f, 0.03695605f, -0.02042292f, -0.06379579f, -0.02298119f, 0.00664249f, 
    -0.03925584f, -0.04651181f, -0.05537603f, 0.03586806f, 0.04786582f, -0.00848452f, -0.01987430f, -0.04607835f, 
    -0.03219277f, 0.01596987f, 0.03144888f, 0.04936521f, -0.05142820f, -0.04840031f, 0.00200874f, -0.02464424f, 
    0.03713502f, -0.04652394f, 0.03129404f, -0.01547491f, -0.00281223f, -0.01574779f, 0.03176736f, 0.02732057f, 
    -0.04242519f, -0.00954902f, -0.04997840f, 0.00204205f, -0.00654290f, 0.02543981f, -0.06224279f, -0.06745908f, 
    -0.05742379f, -0.05744778f, -0.04818359f, 0.03090622f, -0.06547732f, -0.02950691f, -0.02371212f, -0.05022304f, 
    -0.05501544f, -0.03141414f, -0.02971824f, 0.00298429f, 0.00970250f, -0.04262652f, -0.05946510f, -0.04488533f, 
    -0.00200944f, -0.00492840f, 0.00284749f, 0.02192037f, 0.00495626f, 0.00280039f, -0.01566496f, 0.03962687f, 
    0.01797586f, 0.03461224f, 0.03718878f, -0.03290225f, -0.02078724f, 0.01727089f, -0.06101518f, 0.02580814f, 
    -0.02218067f, -0.03508811f, -0.05942015f, 0.00403531f, 0.02694776f, -0.01415256f, 0.00899329f, 0.02042496f, 
    0.03568217f, -0.00704714f, -0.05661978f, -0.03162741f, 0.03925930f, 0.00592137f, -0.02176697f, 0.00538823f, 
    -0.03182453f, 0.03560029f, -0.02231084f, -0.05813280f, -0.02610506f, 0.01330649f, -0.03679148f, 0.01933703f, 
    0.03021874f, 0.00688143f, 0.04069275f, -0.03040670f, 0.04135937f, -0.03113238f, -0.05472263f, -0.03670998f, 
    -0.04898299f, -0.02722255f, 0.05611331f, 0.02857465f, 0.04818948f, 0.02872343f, -0.02322668f, -0.00422161f, 
    0.05318117f, -0.03131461f, -0.04149632f, 0.01519994f, 0.04661379f, -0.04622124f, 0.02151998f, -0.04577052f, 
    -0.02004720f, 0.05073087f, -0.02346740f, 0.02462728f, 0.00500850f, -0.05607837f, -0.02742443f, 0.02261198f, 
    -0.01652054f, 0.04895638f, -0.01268686f, 0.00395377f, -0.00512673f, -0.01648306f, 0.04039281f, 0.02772775f, 
    0.01541738f, 0.00090251f, -0.03097017f, -0.02809483f, -0.02787033f, 0.02926790f, -0.06602895f, -0.05084914f, 
    -0.02058138f, -0.04059326f, 0.03957311f, 0.01612893f, -0.06300373f, 0.01522190f, -0.02072013f, -0.06707597f, 
    0.03911083f, -0.00511607f, -0.04304125f, -0.06373762f, 0.02937490f, -0.04932715f, 0.02975736f, -0.05010065f, 
    0.02931045f, -0.02613252f, 0.01887794f, -0.06605509f, 0.04532981f, 0.01937058f, 0.02468528f, -0.02620161f, 
    0.01721673f, 0.03364493f, -0.00236239f, -0.01640345f, -0.04673943f, -0.02181849f, 0.03631162f, -0.03316977f, 
    0.00476909f, -0.05399720f, -0.05015760f, 0.02924248f, -0.05343210f, -0.00230395f, -0.04625346f, 0.01588702f, 
    -0.04947021f, -0.00413917f, -0.04062087f, -0.01095834f, -0.04864573f, 0.00072279f, -0.03167152f, 0.02446676f, 
    -0.03020943f, -0.04276388f, 0.00034035f, 0.03048492f, -0.01245632f, 0.03062200f, 0.04429693f, -0.00013993f, 
    -0.00762053f, 0.01052720f, 0.04769745f, 0.02432461f, 0.04097554f, 0.04607550f, -0.00551096f, 0.00283540f, 
    0.03407557f, -0.03121165f, -0.02505344f, -0.00465887f, 0.02605157f, -0.06139747f, 0.03860939f, -0.02838955f, 
    0.01179861f, -0.01810093f, 0.03345510f, 0.03252627f, 0.04573222f, -0.00545060f, -0.00289761f, 0.00757009f, 
    -0.00956634f, 0.00294329f, 0.05112969f, -0.01177193f, -0.03718578f, 0.02905370f, 0.03933419f, 0.00369357f, 
    -0.12567507f, -0.02542840f, 0.09539352f, -0.04825290f, 0.03704810f, 0.12927060f, -0.31022906f, 0.26973000f, 
    -0.15439674f, -0.19281416f, 0.25395295f, 0.08999053f, -0.21939938f, -0.01434580f, 0.25682068f, 0.20979916f, 
    -0.05870871f, -0.07646431f, -0.08477364f, -0.23743623f, 0.19165222f, 0.18129067f, 0.07813673f, -0.18122344f, 
    -0.07896471f, 0.04989928f, -0.01707900f, 0.02245249f, 0.02210785f, -0.27006164f, -0.01438628f, 0.11951350f, 
    -0.27724382f, -0.23561803f, 0.13195708f, -0.18320657f, -0.01776621f, -0.46443722f, 0.15527077f, -0.09238595f, 
    0.02041988f, -0.04237213f, 0.13954785f, -0.02230361f, -0.14340974f, 0.22848947f, 0.13300222f, -0.25143340f, 
    -0.11670907f, -0.10094940f, 0.09742709f, 0.24760287f, 0.19323437f, 0.03592861f, 0.63759112f, -0.34464639f, 
    0.05893927f, 0.14140421f, -0.00075690f, -0.00355057f, -0.01131191f, 0.07146282f, -0.02860424f, -0.24147385f, 
    0.12902223f, 0.29243124f, -0.14937899f, 0.10571836f, 0.16055416f, -0.01973023f, 0.11549614f, 0.18930458f, 
    -0.04034756f, 0.21971728f, -0.25729153f, -0.10013971f, -0.14513519f, -0.09207814f, -0.04958927f, -0.15763654f, 
    -0.23979905f, 0.10502948f, -0.44177148f, -0.05956483f, 0.25927848f, -0.03598851f, 0.01704063f, 0.00484673f, 
    -0.02072619f, -0.02944839f, -0.33195347f, -0.27152744f, 0.06994469f, 0.00896836f, -0.01817320f, 0.10747539f, 
    0.04623149f, 0.00275250f, -0.07550021f, -0.09215105f, 0.35045967f, -0.02572820f, 0.09532492f, -0.02350269f, 
    0.00152834f, 0.08093206f, 0.07846916f, 0.13180976f, 0.08663339f, -0.15697536f, -0.17569342f, -0.02628132f, 
    0.01221454f, 0.08393525f, 0.10875732f, -0.04224614f, 0.08105177f, 0.04036440f, -0.00997659f, 0.10130523f, 
    0.06166342f, 0.07376684f, -0.05578046f, -0.08791128f, -0.02689308f, -0.12951541f, 0.05572736f, -0.16803230f, 
    0.27632859f, -0.03344286f, 0.04964058f, 0.09608041f, 0.01796697f, -0.00969436f, 0.31362009f, 0.01286314f, 
    -0.42350042f, -0.12628894f, 0.17465825f, 0.05985386f, -0.15089381f, -0.10307010f, -0.03161718f, 0.08628646f, 
    -0.28594083f, 0.20865418f, -0.22422586f, 0.13922785f, 0.05720004f, -0.16966346f, -0.13127953f, -0.04511831f, 
    0.04448671f, 0.57113421f, -0.13712120f, -0.32322469f, -0.27824703f, -0.32127133f, -0.20619541f, -0.05404701f, 
    -0.04140736f, 0.05418317f, -0.61900598f, 0.22269577f, -0.19938532f, -0.03769064f, -0.09959746f, 0.06154460f, 
    0.01213351f, -0.14966673f, 0.03304740f, 0.01729197f, 0.30247933f, -0.01740661f, -0.06337905f, 0.23707549f, 
    0.06773356f, -0.11445949f, 0.13801223f, 0.06681383f, 0.20651403f, 0.27072048f, 0.19816808f, -0.02306318f, 
    -0.14484932f, 0.06222481f, -0.07311755f, -0.09260149f, 0.25852686f, 0.00593356f, -0.42663774f, 0.20571029f, 
    0.23531149f, -0.03378216f, 0.00562135f, 0.21691595f, 0.09230578f, -0.01798935f, -0.06036952f, 0.07138816f, 
    -0.02928897f, 0.15276313f, -0.00390884f, -0.28465572f, 0.33121026f, -0.07503884f, 0.05770877f, -0.17549376f, 
    0.08812251f, 0.01819035f, -0.11704804f, 0.18270598f, -0.02396472f, -0.07732224f, 0.00358021f, 0.21448161f, 
    -0.00773052f, 0.13922884f, 0.33988205f, -0.02137854f, 0.06241616f, -0.03036686f, -0.08577311f, 0.17266178f, 
    -0.04053494f, 0.50702667f, -0.22007889f, -0.06288807f, 0.07789119f, 0.03956193f, 0.13636489f, 0.06629510f, 
    0.04111884f, 0.14847304f, 0.54169673f, 0.40559879f, -0.42425936f, -0.00880020f, 0.09727182f, -0.17346433f, 
    0.18817097f, 0.00944126f, -0.08747903f, -0.11864824f, 0.35608146f, -0.13051988f, -0.06095231f, -0.10372184f, 
    -0.10402162f, -0.30251998f, -0.19434491f, -0.08739293f, -0.31326950f, -0.03668846f, 0.20473291f, -0.08407135f, 
    -0.04769686f, 0.01050745f, -0.04477207f, 0.12550026f, -0.02004397f, -0.43923929f, 0.08577973f, 0.06549692f, 
    0.23730686f, 0.13119151f, -0.00128436f, -0.14048852f, -0.10990292f, 0.09642334f, -0.01798067f, 0.05125064f, 
    -0.18235266f, -0.00414491f, -0.03245886f, 0.00640989f, -0.01803893f, -0.12235035f, 0.33011392f, 0.00578506f, 
    0.29623929f, -0.18925099f, -0.07474264f, 0.03301467f, 0.03987364f, 0.04626423f, 0.00975697f, -0.12137076f, 
    0.09927654f, -0.26262638f, 0.30937716f, -0.15562522f, -0.11560695f, -0.03354225f, -0.04360549f, 0.12467027f, 
    0.03110098f, 0.32587263f, -0.13714206f, 0.04402572f, -0.15326348f, -0.16362041f, 0.19905257f, 0.26451460f, 
    0.13281527f, 0.11265036f, -0.11823818f, -0.02768474f, -0.19590318f, -0.29214314f, -0.01292731f, 0.01563235f, 
    0.13959959f, 0.02522436f, -0.23849373f, -0.42969170f, 0.22707510f, -0.01767883f, -0.12826499f, 0.10677520f, 
    -0.05638888f, -0.03518970f, -0.12468114f, 0.11377265f, -0.09002452f, 0.52445149f, -0.22840288f, -0.23844646f, 
    0.06453880f, -0.01526840f, -0.14359619f, -0.04869313f, 0.06222624f, 0.08607828f, -0.29705337f, 0.11530277f, 
    0.01908551f, 0.19024584f, -0.03236122f, -0.07193350f, 0.03564251f, -0.31348196f, -0.33770964f, 0.17079629f, 
    0.29323861f, -0.05130457f, -0.05278832f, -0.11227940f, -0.01942399f, 0.06835721f, 0.03602589f, 0.06931595f, 
    0.37329876f, -0.15293953f, 0.08302014f, -0.03413591f, 0.23017667f, 0.08744170f, -0.04319538f, 0.09086522f, 
    -0.11890658f, -0.42922068f, 0.21757151f, -0.19810149f, -0.08192755f, -0.11987863f, -0.05353707f, -0.06032284f, 
    0.07400785f, -0.15085776f, 0.28712380f, 0.35144231f, -0.27151498f, 0.06042268f, 0.01806447f, 0.09330809f, 
    0.16606937f, -0.39151108f, -0.04529237f, 0.18795581f, -0.24665482f, -0.40992334f, -0.07051490f, 0.17487884f, 
    0.05418173f, -0.02353400f, 0.13334590f, 0.52321905f, -0.35458529f, 0.46479735f, -0.10443519f, 0.07019661f, 
    -0.02559610f, -0.01020857f, -0.06915883f, -0.01118551f, -0.16453604f, -0.23616628f, -0.43428907f, 0.06325359f, 
    0.17374542f, -0.13089083f, -0.04756039f, 0.20068057f, -0.04191714f, 0.08706733f, -0.15609922f, -0.05152509f, 
    -0.04812344f, -0.35612634f, 0.10773008f, 0.16341074f, -0.22936362f, 0.20637098f, -0.09186011f, 0.21968065f, 
    -0.00738290f, -0.08761158f, 0.07166927f, 0.13996939f, -0.02519639f, 0.20166406f, -0.04197488f, 0.23166528f, 
    -0.02993422f, -0.03426160f, -0.04113545f, 0.19671313f, -0.00985415f, -0.12039014f, -0.08821473f, -0.11314824f, 
    -0.11462045f, -0.35056889f, 0.12116993f, -0.23533660f, 0.00327657f, 0.12523162f, 0.11701422f, 0.00109570f, 
    0.27963632f, 0.94984430f, 0.01622653f, -0.21453343f, -0.20570759f, 0.10940865f, -0.17692170f, 0.12775747f, 
    -0.11490078f, -0.07176743f, 0.05900250f, 0.04312241f, -0.20345253f, 0.04824562f, -0.09593754f, -0.09009791f, 
    -0.14853682f, -0.03542113f, 0.06372328f, 0.00495165f, 0.21197876f, -0.02087864f, 0.29868665f, 0.24073277f, 
    -0.06304695f, 0.11153375f, 0.06015742f, -0.04139113f, 0.60504860f, -0.27848658f, -0.09481084f, -0.04078090f, 
    0.13386223f, 0.24346954f, -0.01974527f, 0.00729955f, 0.17128827f, 0.11800489f, 0.12532982f, 0.01529153f, 
    -0.36778235f, 0.28257000f, -0.08073486f, 0.22040202f, 0.04026810f, -0.01740233f, -0.05477429f, 0.19996136f, 
    -0.14530361f, 0.01361199f, -0.06855075f, 0.00751129f, -0.18499786f, 0.14722086f, -0.17753038f, 0.29521066f, 
    0.13002148f, -0.22349201f, 0.11533204f, -0.23589961f, 0.02378561f, 0.12651087f, 0.06949051f, -0.11464863f, 
    0.43517876f, 0.20887491f, 0.07584763f, 0.01840462f, -0.15083751f, -0.03728979f, 0.09574018f, -0.00087334f, 
    0.09528682f, 0.34307134f, -0.45895934f, 0.05357721f, -0.21111108f, -0.01609051f, 0.10838236f, 0.02345828f, 
    0.04743285f, 0.10444827f, -0.50219458f, -0.07207904f, 0.19294767f, -0.00537827f, 0.07148303f, 0.15164433f, 
    -0.08413447f, 0.23143205f, 0.06400610f, 0.27784640f, -0.34800258f, 0.00740304f, -0.09731462f, 0.00467539f, 
    0.11354700f, -0.15805295f, -0.11059218f, -0.07131546f, -0.26421925f, 0.19195998f, 0.14667250f, 0.06656715f, 
    0.03724951f, -0.08279293f, 0.19225217f, 0.15440993f, 0.03451696f, -0.14581785f, -0.30289862f, -0.10699090f, 
    -0.05405216f, 0.06747640f, 0.04947519f, 0.11689319f, -0.11210100f, -0.12684764f, 0.71470881f, -0.08544534f, 
    0.04275658f, -0.02526211f, 0.22750480f, -0.09913546f, -0.12290882f, -0.24269152f, 0.04358568f, 0.10126583f, 
    -0.35812721f, 0.16304399f, -0.04036667f, -0.10111457f, 0.06016694f, 0.28590128f, 0.14553140f, 0.16057198f, 
    0.33292738f, 0.16647211f, -0.29145354f, 0.00254370f, -0.14026965f, -0.13421474f, 0.28529006f, 0.26226556f, 
    0.13942657f, -0.09834182f, 0.05278835f, 0.18627863f, 0.21729344f, -0.10795432f, -0.09562471f, -0.04552281f, 
    -0.00435318f, 0.15988646f, 0.17860912f, -0.33761337f, -0.31999668f, 0.13458017f, -0.14596029f, 0.06145845f, 
    0.12041885f, 0.08970679f, -0.08043709f, 0.05267772f, 0.11526655f, -0.15876812f, -0.10674949f, -0.00670459f, 
    -0.19627936f, 0.00384582f, 0.09358272f, -0.09254161f, -0.18078940f, -0.11406370f, 0.15909940f, 0.16925366f, 
    0.03947092f, 0.07453179f, 0.02536952f, 0.05959610f, 0.00134258f, 0.14103611f, 0.12830175f, 0.05322364f, 
    -0.11652391f, -0.25730374f, 0.06887880f, 0.03651086f, 0.04680371f, -0.09922705f, -0.32797277f, 0.18281521f, 
    -0.00091346f, 0.01035246f, -0.14424238f, -0.03106794f, -0.02334129f, -0.16892265f, 0.08397563f, 0.24467386f, 
    0.21388817f, 0.49230018f, 0.09103816f, 0.19416068f, -0.11681151f, -0.11539091f, -0.07382019f, 0.16783181f, 
    -0.06468868f, 0.02568981f, 0.11702788f, 0.09344467f, -0.03846775f, 0.13388394f, 0.04899387f, -0.24808417f, 
    -0.07394920f, -0.07409168f, 0.45317081f, 0.02249131f, 0.05525180f, -0.11064459f, 0.15480550f, -0.16964220f, 
    0.05888402f, -0.06988031f, -0.15216371f, 0.15067868f, -0.17734054f, 0.02812246f, 0.18425208f, 0.09017555f, 
    -0.34130755f, -0.12707369f, 0.16120306f, 0.40042275f, 0.03764618f, 0.56306398f, 0.11113839f, 0.05636635f, 
    0.05789195f, -0.01561636f, 0.11863033f, 0.14863224f, -0.12925047f, -0.14977294f, 0.05934985f, 0.12084056f, 
    -0.09763318f, -0.33928734f, -0.09546488f, -0.02120336f, -0.22325450f, 0.02892451f, 0.04283371f, 0.17524409f, 
    -0.06296553f, 0.10717499f, -0.22898400f, -0.03230578f, 0.00716659f, -0.01171628f, 0.05933310f, -0.06298838f, 
    0.02044387f, -0.15084562f, 0.04980144f, -0.03500254f, 0.07152205f, 0.08240643f, -0.04462974f, 0.00273345f, 
    -0.00012177f, -0.06257074f, -0.15554969f, 0.13825171f, 0.09932151f, -0.27639988f, -0.14443138f, -0.24282973f, 
    0.16178942f, -0.01875887f, 0.51109093f, 0.20963219f, 0.05792687f, 0.14863966f, 0.06834104f, 0.06282973f, 
    -0.25357842f, -0.26879048f, 0.01845916f, 0.06866049f, 0.06683470f, 0.11531497f, 0.12339669f, -0.00487841f, 
    0.15642548f, -0.20663649f, 0.08621184f, -0.43222815f, -0.06733730f, -0.00511792f, -0.06523949f, -0.05992204f, 
    -0.05194038f, 0.11644322f, 0.07091901f, -0.13306606f, -0.05577822f, -0.02574787f, -0.02462408f, -0.04804659f, 
    -0.03342571f, 0.14219798f, -0.12944679f, -0.05340834f, 0.04040784f, -0.02788112f, -0.07672334f, 0.02546247f, 
    -0.04007012f, 0.10057867f, 0.14847113f, 0.12571447f, 0.07681750f, -0.37876537f, -0.11680927f, -0.00563074f, 
    -0.02123849f, 0.14842062f, -0.03413049f, -0.10100655f, -0.00968732f, 0.12732692f, -0.30458921f, -0.07279123f, 
    -0.10293649f, -0.00591282f, -0.18463796f, -0.16742174f, -0.19715823f, -0.14521891f, -0.13346910f, -0.07773249f, 
    0.06045218f, 0.36058486f, 0.16483268f, 0.07243998f, 0.02909544f, -0.08225274f, 0.01843341f, 0.00463525f, 
    0.02412712f, -0.17175001f, -0.03780618f, -0.04921613f, 0.15357190f, -0.07987340f, -0.03330953f, -0.03661663f, 
    0.13030910f, -0.05913699f, 0.19303946f, 0.36855605f, -0.07270724f, 0.06856180f, -0.14467593f, 0.00804219f, 
    -0.04530492f, -0.04553021f, 0.08701140f, 0.11038165f, -0.17191124f, -0.18992138f, -0.14104387f, -0.04200108f, 
    -0.06033433f, 0.20708476f, -0.09986521f, 0.22195654f, 0.12440398f, 0.03492352f, -0.01420523f, -0.03909099f, 
    -0.10915092f, 0.15024665f, 0.07348835f, 0.03180752f, 0.18332681f, -0.17881453f, -0.20142387f, -0.15377025f, 
    -0.25473499f, -0.11692147f, 0.19381747f, -0.02892247f, 0.20856982f, -0.15792839f, 0.17579132f, 0.27020830f, 
    -0.09112352f, 0.06004699f, 0.10404587f, 0.09489543f, 0.02989860f, -0.06321259f, -0.31671593f, -0.17842712f, 
    0.15491019f, -0.03316730f, 0.21232018f, 0.12257803f, 0.09121439f, 0.17803329f, -0.34220970f, -0.28465557f, 
    0.13233830f, 0.47545120f, 0.27254987f, 0.15751573f, 0.15338022f, -0.09176037f, 0.07554223f, -0.02748354f, 
    0.02425570f, -0.05040463f, 0.03810937f, 0.00962300f, -0.02015208f, -0.04710878f, 0.03180966f, 0.02627834f, 
    -0.03920642f, 0.01442336f, -0.02121912f, -0.06129554f, -0.02827388f, 0.00398567f, -0.05173311f, -0.03151467f, 
    -0.05432962f, 0.04477484f, 0.02070773f, -0.04351312f, 0.03162733f, -0.05850572f, -0.02025832f, 0.03248324f, 
    0.02568901f, 0.01525800f, -0.00478777f, 0.01348863f, -0.01577194f, -0.00762852f, -0.02698467f, -0.03410907f, 
    -0.02593974f, 0.00267003f, 0.00627597f, 0.04160458f, -0.04833843f, 0.02841615f, -0.03574110f, -0.04115525f, 
    -0.05198001f, 0.03089521f, -0.02287484f, -0.00001475f, 0.03551881f, 0.00696639f, 0.02218562f, -0.01571796f, 
    -0.06146975f, -0.02932781f, -0.02845284f, -0.05822057f, -0.02381903f, 0.03434381f, -0.01180433f, 0.04547137f, 
    -0.02333217f, -0.03344655f, -0.05270151f, -0.00389570f, -0.01093875f, 0.02202364f, -0.03469442f, -0.00327322f, 
    0.04563930f, 0.01566038f, -0.05702609f, -0.03292779f, 0.03630372f, 0.00105577f, 0.00448145f, 0.02068585f, 
    -0.06320414f, -0.04013959f, -0.05268996f, 0.02536470f, -0.04624354f, -0.03985589f, -0.05631755f, 0.00224575f, 
    -0.03732247f, 0.03629953f, -0.02534978f, 0.03578792f, 0.00992195f, -0.04324516f, -0.04166044f, 0.00169697f, 
    0.05183152f, -0.05986783f, 0.03735311f, 0.01963031f, 0.01066199f, -0.03715840f, 0.04722968f, 0.05024261f, 
    -0.00662271f, 0.03834993f, 0.04161882f, -0.02205956f, -0.02428384f, 0.02164284f, -0.00024979f, -0.01583225f, 
    -0.05641823f, -0.05801999f, 0.04840228f, -0.06017899f, -0.00228580f, 0.00908901f, -0.02952375f, -0.02532500f, 
    -0.02234698f, -0.02415292f, -0.01974306f, -0.02757692f, -0.05978146f, 0.03327472f, 0.04196380f, -0.03897306f, 
    0.00853322f, 0.02128799f, -0.00627481f, -0.03699348f, -0.01034262f, 0.04296396f, -0.00728267f, -0.00771374f, 
    0.01021226f, 0.00228871f, 0.04536135f, 0.01334180f, -0.03647121f, -0.00981700f, 0.02499536f, 0.03703243f, 
    -0.02883924f, -0.04147817f, -0.05344398f, 0.05117590f, 0.02067759f, 0.02064316f, -0.01110836f, 0.03808863f, 
    0.01552322f, -0.02454206f, 0.02251084f, 0.04680304f, 0.00287786f, 0.05128765f, -0.05417381f, -0.05395456f, 
    -0.00570059f, 0.02485728f, 0.01081490f, -0.04936948f, -0.00354864f, -0.05330755f, 0.03455935f, -0.05413466f, 
    0.04483222f, -0.04511256f, -0.00326046f, -0.05259496f, -0.00398734f, -0.01160971f, -0.00586481f, -0.00084245f, 
    0.01523802f, -0.00077268f, 0.02936569f, 0.04600708f, 0.03438859f, -0.01026135f, 0.03822875f, 0.03854601f, 
    -0.04377631f, 0.03903344f, -0.05477748f, -0.00414064f, 0.01422949f, 0.01490632f, -0.05072387f, 0.04093581f, 
    0.04410134f, 0.03112802f, -0.06492134f, -0.00135545f, -0.00036348f, -0.05187441f, -0.04300544f, 0.05937852f, 
    0.03262376f, 0.01617695f, -0.01452674f, 0.03678268f, 0.04666709f, -0.03060428f, -0.05322966f, -0.01037686f, 
    -0.02463230f, -0.05639864f, 0.04809957f, -0.01183632f, 0.02877301f, -0.06371431f, -0.03392910f, 0.02243839f, 
    0.05060341f, 0.01135900f, 0.02096530f, 0.00431476f, -0.05910022f, 0.04910289f, -0.05579603f, -0.02379975f, 
    -0.03494581f, 0.03896268f, -0.03154728f, -0.00232267f, -0.05087618f, 0.00313830f, -0.01172238f, 0.02604304f, 
    -0.04291606f, -0.06145329f, -0.00411982f, 0.02174252f, -0.03208226f, -0.03406019f, 0.04417641f, -0.01070974f, 
    0.02480557f, -0.03681661f, -0.02790412f, -0.03647203f, -0.00293750f, 0.03295126f, -0.03303222f, -0.03222223f, 
    0.01574058f, 0.00201185f, -0.06481113f, -0.03685338f, -0.05251163f, 0.02898358f, 0.01694618f, -0.05540509f, 
    0.00794063f, 0.01756793f, -0.00412707f, -0.00908975f, -0.00214951f, -0.03449364f, -0.03041832f, 0.04471675f, 
    -0.01771152f, 0.01766727f, 0.03115735f, -0.00505656f, -0.04931325f, 0.01243310f, 0.02383814f, -0.05579313f, 
    0.02529651f, -0.04033004f, -0.04212836f, -0.03396314f, -0.01168894f, -0.00459513f, 0.00377625f, 0.01719985f, 
    -0.03362146f, -0.05441450f, -0.00424485f, 0.01765911f, -0.06175534f, -0.05516001f, -0.02525026f, -0.03377150f, 
    0.05142241f, 0.03371527f, 0.01176804f, -0.03536314f, 0.03026466f, 0.01334957f, -0.05144839f, 0.00376178f, 
    0.29552832f, 0.09811482f, -0.23399593f, -0.17497063f, -0.12977462f, 0.25823402f, 0.00651542f, -0.12454224f, 
    0.00767176f, -0.10574593f, -0.13732056f, 0.39968851f, 0.12069785f, 0.24619405f, 0.01405350f, -0.12735268f, 
    0.10808679f, 0.08640800f, 0.09280809f, -0.10755417f, -0.39719746f, 0.08348107f, -0.12148050f, -0.10611436f, 
    0.06292735f, -0.02422767f, -0.01738472f, 0.06324942f, -0.06480917f, -0.23678389f, 0.02812572f, -0.11850362f, 
    0.22443262f, -0.04465753f, 0.04012451f, 0.07615408f, 0.20821387f, 0.03712912f, 0.01924672f, -0.05432400f, 
    -0.10845555f, 0.04188224f, -0.05880113f, 0.03490433f, -0.13365364f, 0.48792756f, -0.02528714f, 0.13993435f, 
    -0.08168610f, 0.02768049f, -0.06434971f, 0.15120839f, 0.08052428f, -0.02999583f, -0.01259334f, -0.04001974f, 
    -0.23253934f, 0.09412947f, -0.03544543f, -0.07096876f, -0.08748587f, 0.03886988f, -0.22501557f, 0.38991955f, 
    0.30810589f, 0.45657450f, 0.17411651f, 0.13763587f, -0.12018916f, -0.23398849f, 0.07847197f, 0.17686020f, 
    0.07560867f, -0.15812458f, -0.13300927f, -0.01365710f, -0.12313262f, -0.00161723f, -0.25631821f, -0.02921266f, 
    -0.06135090f, 0.06017331f, -0.01190690f, -0.37149185f, 0.04280610f, 0.03110768f, 0.03979950f, 0.10856254f, 
    -0.14114523f, -0.00859742f, -0.07212155f, 0.17611925f, -0.07817234f, -0.16575846f, 0.03581769f, 0.09808058f, 
    0.02541942f, -0.03505331f, 0.06049713f, 0.24124566f, -0.20983501f, 0.46296826f, -0.08739442f, 0.04203797f, 
    0.02221573f, -0.08205726f, -0.04444837f, -0.00395147f, -0.42127657f, 0.06496496f, -0.29249707f, 0.25297967f, 
    -0.08558077f, -0.01652567f, 0.02918465f, 0.11774383f, -0.04445331f, -0.01712927f, -0.04246119f, 0.37377974f, 
    -0.02931326f, 0.03235552f, 0.03668562f, -0.12494867f, 0.01170620f, -0.00281449f, 0.02081186f, -0.08128998f, 
    0.00963431f, -0.05281406f, 0.07332056f, 0.10289025f, 0.07189914f, -0.04002080f, -0.22693828f, 0.32088768f, 
    -0.08945387f, -0.03014366f, -0.05125250f, 0.15888494f, 0.15733109f, 0.01805889f, -0.05918581f, -0.10549122f, 
    -0.05553759f, -0.12348090f, 0.43750572f, 0.06659669f, 0.06510698f, 0.15165514f, -0.06178588f, 0.00569450f, 
    0.06546327f, -0.56975204f, -0.11372697f, -0.01183402f, 0.35734767f, 0.04363712f, 0.05917564f, -0.11639348f, 
    -0.04590794f, 0.17812110f, -0.14944032f, -0.32369313f, -0.06299708f, 0.07483583f, 0.15418440f, -0.01653255f, 
    0.07385366f, -0.13531303f, -0.06137330f, -0.05823275f, -0.05668095f, 0.07504449f, -0.07142878f, 0.24169412f, 
    0.12694065f, 0.09179322f, -0.03515952f, 0.00709515f, 0.27981892f, 0.04618909f, 0.01737755f, -0.21678297f, 
    -0.08128571f, 0.25174060f, 0.01771356f, 0.03047972f, -0.38946545f, 0.10118552f, -0.14897501f, -0.20070179f, 
    0.15206657f, -0.15760298f, -0.11825661f, -0.05219653f, 0.05174412f, 0.09728473f, -0.16152033f, -0.22416788f, 
    -0.44622192f, -0.10022733f, -0.09070659f, -0.09255945f, 0.36223936f, -0.10026351f, 0.01644132f, -0.21773516f, 
    -0.08510540f, 0.25962731f, 0.09243745f, 0.10062752f, 0.00111066f, -0.17692555f, 0.05865301f, 0.13849220f, 
    -0.05668215f, -0.00420812f, 0.26592407f, 0.05886056f, -0.01162120f, -0.20028777f, -0.00798103f, 0.01037955f, 
    0.13002035f, 0.43581450f, 0.39656070f, 0.20511690f, -0.18321711f, -0.07366524f, -0.23009098f, -0.05169547f, 
    -0.00000263f, -0.05273654f, 0.46057105f, 0.29696929f, -0.06769354f, -0.12465657f, -0.14192082f, -0.23114133f, 
    0.16389135f, 0.10666877f, 0.06508808f, -0.16536373f, -0.09628405f, 0.23084141f, -0.14029443f, -0.00632985f, 
    -0.22775871f, -0.11014601f, -0.14495799f, -0.11405045f, -0.17946877f, 0.22192618f, -0.16136631f, 0.07598440f, 
    -0.03685001f, -0.00753788f, 0.12872545f, 0.01258294f, 0.23353222f, 0.12041803f, -0.00806183f, 0.08436496f, 
    -0.00509370f, -0.00855735f, 0.14719826f, -0.10518558f, -0.19651841f, 0.07252008f, -0.20666876f, -0.23227744f, 
    0.12435655f, 0.16269714f, -0.00363891f, -0.03870482f, -0.05641280f, 0.06747753f, -0.06558397f, -0.25646496f, 
    -0.00156978f, 0.46401191f, 0.02358707f, -0.08404758f, -0.22746299f, 0.03424312f, 0.02112794f, 0.04687085f, 
    -0.04986822f, 0.00999809f, -0.02854062f, 0.30951449f, 0.17533575f, -0.00886265f, -0.23540692f, 0.17095865f, 
    0.08550145f, 0.04478505f, 0.31471545f, 0.24466921f, -0.32703182f, 0.02290959f, -0.13401164f, -0.16114782f, 
    -0.02371822f, -0.08455663f, 0.19153211f, -0.13176043f, -0.09959530f, -0.10964265f, 0.06430194f, -0.08137839f, 
    0.00610456f, 0.05852694f, -0.04707462f, -0.37970445f, 0.25046703f, -0.34333566f, 0.28575021f, -0.03058034f, 
    0.12786748f, 0.17758487f, 0.20501864f, 0.16069414f, 0.17517152f, -0.30812281f, -0.34996456f, -0.05212796f, 
    -0.09848218f, 0.06035039f, -0.24312700f, 0.21474272f, 0.10121027f, 0.01370288f, 0.24690863f, -0.09396237f, 
    -0.03377791f, 0.18736166f, 0.07705451f, -0.13786705f, -0.07291196f, -0.08277781f, 0.29086041f, 0.24790961f, 
    0.12003467f, 0.17655113f, 0.05529594f, -0.32308578f, 0.18996714f, 0.17177553f, -0.16848475f, -0.07503146f, 
    -0.08783099f, -0.00892538f, -0.00567557f, -0.17309824f, -0.08524059f, 0.02321464f, 0.03272814f, -0.09610937f, 
    -0.49780139f, 0.07009394f, -0.14333685f, 0.08537485f, 0.08544382f, -0.10884284f, -0.08364844f, 0.10864045f, 
    -0.14563206f, 0.21699885f, 0.00608047f, 0.24949081f, 0.20819074f, 0.11878777f, -0.07832059f, -0.06855296f, 
    -0.04766562f, 0.16752280f, -0.29021674f, 0.17063412f, -0.30722886f, 0.19663489f, -0.10443992f, 0.03251537f, 
    -0.10891264f, 0.00306435f, 0.14877757f, 0.51859146f, 0.24699354f, -0.41808257f, 0.13038079f, -0.00524989f, 
    0.08212318f, -0.01341681f, -0.24362844f, 0.05461321f, -0.15032347f, -0.29697895f, -0.13201085f, 0.01900632f, 
    0.01758247f, 0.00448857f, -0.28789273f, -0.05915570f, -0.22444566f, 0.15650110f, 0.19719388f, -0.09365049f, 
    -0.14427474f, -0.22189260f, 0.12365256f, -0.13386956f, 0.08406716f, 0.03453961f, 0.33475205f, -0.36964539f, 
    -0.08053481f, 0.11550699f, 0.13969791f, -0.19555558f, -0.14506496f, 0.22241990f, 0.21887748f, 0.45652509f, 
    -0.17666516f, -0.26172939f, 0.11144426f, 0.30746546f, 0.23988298f, -0.11680730f, 0.19871821f, 0.16320252f, 
    0.08026481f, 0.28704727f, -0.08654912f, 0.26212117f, 0.28932574f, -0.20286953f, 0.03050186f, -0.11701434f, 
    0.18470162f, 0.01509413f, -0.20389587f, -0.55104357f, -0.03193225f, 0.14535284f, -0.22467646f, -0.17024879f, 
    0.03355428f, -0.03532204f, -0.27394116f, 0.17627744f, -0.24083765f, 0.17056346f, -0.15964499f, 0.00594320f, 
    -0.05850603f, 0.21141315f, 0.25134286f, -0.04217747f, 0.32875755f, 0.33768374f, -0.03669452f, 0.02525138f, 
    0.00371991f, 0.13532867f, 0.06020789f, -0.01415092f, -0.04500661f, -0.00865270f, -0.05447759f, -0.04553480f, 
    -0.08346088f, 0.00697053f, -0.06150200f, 0.01813232f, 0.17646310f, 0.01379238f, 0.17378341f, -0.05425648f, 
    0.04026033f, 0.02507581f, 0.02390909f, -0.19498670f, -0.03395901f, 0.05443787f, 0.12085714f, -0.16556311f, 
    -0.25811550f, -0.18686464f, 0.17114630f, 0.03326627f, 0.09392473f, -0.00650901f, -0.00521206f, 0.12045947f, 
    -0.04107277f, -0.14938673f, -0.18283708f, -0.03459472f, -0.11906073f, -0.06827587f, 0.06829735f, -0.29223779f, 
    0.27065581f, 0.31651831f, 0.10522883f, -0.03891735f, -0.18820529f, 0.11737449f, 0.06008947f, -0.14039354f, 
    0.01614657f, 0.19868688f, -0.08982982f, -0.06319372f, 0.24220607f, -0.02486469f, -0.08315073f, 0.04381768f, 
    0.19230567f, 0.09483448f, 0.12711075f, 0.42675743f, 0.16176872f, 0.20617829f, 0.10954918f, 0.32565168f, 
    -0.06806338f, -0.07614069f, -0.06810182f, -0.09749153f, 0.09469252f, 0.06527615f, 0.08973412f, 0.03311473f, 
    -0.03437743f, 0.16736411f, 0.20369805f, 0.02960272f, 0.12914783f, 0.13324164f, 0.10366067f, -0.08028700f, 
    0.02553946f, -0.20978723f, 0.07595852f, 0.11603057f, 0.15606830f, -0.11727799f, -0.06642101f, -0.15838869f, 
    0.12918752f, 0.12661095f, 0.14935996f, 0.03772108f, -0.03753387f, -0.24578871f, -0.06901549f, 0.15116604f, 
    -0.09405108f, -0.02370546f, -0.06656365f, -0.06587040f, 0.15099904f, 0.10818483f, 0.33803371f, -0.13127869f, 
    0.24736607f, -0.29022926f, 0.02011891f, 0.13411117f, 0.03602882f, -0.29384854f, -0.05488203f, -0.42988521f, 
    -0.05022876f, -0.06712143f, -0.04149760f, -0.00904260f, 0.00743677f, 0.03751306f, 0.00220849f, 0.00126916f, 
    -0.01348532f, 0.03028752f, -0.01702286f, -0.03020885f, 0.00463297f, -0.01650471f, 0.00819274f, 0.04853007f, 
    0.03584555f, 0.01033207f, 0.04241310f, -0.03294962f, -0.00564050f, -0.01924429f, -0.02526355f, 0.05523946f, 
    -0.00511730f, 0.00572856f, 0.02702602f, 0.01870507f, -0.05969888f, -0.03292518f, -0.02164355f, -0.05072956f, 
    0.03865798f, -0.04128443f, -0.02203442f, -0.01024061f, 0.00235263f, -0.03335118f, 0.00259822f, -0.01909141f, 
    0.04193828f, 0.01266652f, 0.03527835f, -0.05292377f, -0.04439827f, 0.00075495f, 0.00160552f, 0.06109741f, 
    0.00329154f, 0.02618819f, -0.02823689f, 0.04844478f, 0.01362449f, -0.03889741f, -0.06303692f, -0.03220193f, 
    0.04492404f, -0.00615192f, -0.02160108f, -0.01363377f, 0.04612165f, 0.01457995f, 0.04497967f, -0.01866298f, 
    -0.02810270f, 0.01182075f, 0.07018124f, 0.03320334f, 0.02457868f, 0.00997972f, -0.03370672f, -0.04478710f, 
    0.04546775f, 0.01813866f, 0.03149827f, 0.00694440f, 0.00314105f, 0.03556261f, -0.00510023f, 0.00986991f, 
    -0.05380993f, -0.03432483f, -0.02844906f, 0.03953169f, -0.00678021f, -0.01479136f, -0.04931489f, -0.04232698f, 
    -0.05649072f, 0.01562525f, -0.04992959f, 0.05440104f, 0.03266158f, -0.03748010f, -0.03872832f, -0.02196485f, 
    -0.05487186f, -0.01967896f, -0.06394362f, 0.02160282f, -0.01301786f, -0.06427714f, 0.00681713f, 0.00368291f, 
    -0.04015816f, 0.02615537f, 0.04509315f, -0.04758937f, -0.03637877f, -0.03239673f, -0.01521784f, -0.04522044f, 
    -0.05760091f, -0.02281258f, 0.00951041f, -0.04483048f, -0.06810943f, -0.02938441f, -0.04695038f, 0.02456306f, 
    0.00029047f, 0.05870552f, 0.00803256f, -0.03882197f, 0.00477698f, -0.03167205f, -0.03778277f, -0.02555559f, 
    0.01270458f, -0.04776011f, -0.02684708f, 0.00980130f, 0.05680387f, 0.02088352f, 0.03804862f, 0.03217072f, 
    0.01395943f, -0.04689731f, 0.02260101f, 0.04213268f, 0.02821555f, -0.06540658f, -0.01770355f, 0.05408180f, 
    -0.04372941f, 0.02305110f, -0.00256805f, -0.00342963f, -0.03886206f, -0.05900621f, -0.00214814f, -0.05280841f, 
    -0.00090900f, -0.04976714f, -0.01833504f, -0.02098361f, -0.03566811f, 0.00080017f, 0.01251576f, -0.05177428f, 
    0.02011094f, -0.02194239f, -0.04343441f, -0.02401696f, 0.05386906f, -0.03636426f, -0.07230937f, -0.00396888f, 
    -0.02021188f, 0.01019944f, -0.00522205f, -0.04884582f, 0.01255583f, 0.04605122f, 0.04634561f, -0.04602271f, 
    -0.02003791f, 0.01191538f, 0.03871689f, 0.04749450f, -0.04758415f, -0.02389973f, -0.01201634f, 0.05154799f, 
    0.01839775f, 0.01643552f, -0.00060635f, -0.01832958f, -0.02586396f, -0.07774853f, -0.03900338f, -0.01973192f, 
    -0.06508847f, -0.00294974f, -0.05497284f, -0.00323221f, -0.00389898f, 0.02822232f, 0.07675178f, -0.01122468f, 
    0.00810805f, -0.04230652f, 0.03397515f, -0.04861700f, -0.05999645f, -0.01847013f, -0.05675054f, -0.01853660f, 
    -0.06556507f, 0.03143698f, 0.01850053f, -0.05170261f, 0.03580302f, -0.02233812f, 0.02228302f, -0.07712804f, 
    0.01537606f, -0.00826924f, 0.01355274f, -0.03843211f, 0.04188135f, 0.00452350f, 0.01656815f, 0.04259543f, 
    -0.03631745f, -0.00650424f, -0.07306059f, 0.04728212f, -0.01643165f, -0.01014375f, 0.04644553f, -0.03744997f, 
    -0.07147330f, 0.00114964f, -0.00772411f, 0.02210553f, 0.02938210f, -0.00315408f, 0.00599958f, 0.00524015f, 
    0.00093547f, 0.00579535f, 0.01939958f, -0.07805474f, -0.04019836f, -0.07229997f, -0.02560175f, -0.02830137f, 
    0.01979848f, 0.05941637f, -0.02863250f, 0.05447131f, -0.01623033f, 0.02266397f, -0.01189295f, -0.01385539f, 
    -0.03643933f, 0.02754481f, 0.05613554f, -0.00450596f, 0.01649114f, 0.03443550f, 0.04828338f, -0.03216420f, 
    0.00555571f, -0.05904742f, -0.03587351f, -0.02160515f, -0.00214688f, -0.02908197f, 0.01058073f, -0.03553069f, 
    -0.07000583f, 0.00212159f, -0.04521453f, 0.03805362f, -0.01474792f, -0.03835557f, 0.06238355f, -0.03071107f, 
    -0.09184872f, -0.05169177f, -0.03732221f, -0.00788415f, 0.00996228f, 0.03022944f, -0.01118096f, -0.02105436f, 
    -0.42232960f, -0.39215326f, -0.06321512f, 0.13410713f, 0.05645231f, 0.18434413f, 0.17587954f, 0.09840121f, 
    0.00838474f, 0.55018276f, 0.01724323f, 0.14269775f, -0.05872890f, 0.03865798f, -0.12434893f, 0.04249708f, 
    -0.05161670f, -0.04322440f, 0.47211793f, -0.04652534f, 0.04898838f, 0.03977729f, -0.16404378f, 0.06529856f, 
    -0.11928770f, -0.02913238f, 0.06081524f, -0.24665478f, 0.27922297f, -0.04967684f, -0.22898750f, -0.14106341f, 
    0.18618819f, -0.13884619f, 0.00484715f, -0.26693881f, -0.11813785f, 0.16632482f, -0.05399374f, 0.11369193f, 
    -0.05516721f, 0.11063456f, -0.10399739f, -0.06949466f, 0.00697024f, 0.40667298f, 0.00378746f, -0.09804217f, 
    0.19747327f, -0.01581750f, 0.25694853f, 0.16921751f, -0.10449397f, -0.17149396f, -0.05467755f, 0.23444803f, 
    -0.05812147f, 0.11786229f, 0.22234285f, 0.08227289f, -0.28690869f, 0.06016220f, 0.16049002f, 0.27988672f, 
    -0.04775968f, -0.05728086f, -0.17107479f, -0.01921538f, 0.06020380f, -0.02328071f, 0.07391154f, -0.17739958f, 
    -0.01264978f, 0.07174528f, 0.04244330f, 0.00440609f, -0.12504634f, -0.22861440f, -0.07018048f, -0.14459886f, 
    -0.03140888f, -0.70069307f, -0.08014844f, -0.19808422f, 0.09620220f, 0.20804687f, 0.08281523f, -0.04782801f, 
    0.26214692f, 0.02117761f, -0.68182707f, -0.11534657f, -0.12117061f, 0.24933755f, 0.20318691f, 0.38053283f, 
    0.10034006f, -0.06779941f, -0.00678303f, 0.49435046f, -0.03115230f, -0.29640394f, -0.35474974f, -0.07635611f, 
    0.25198799f, -0.12598182f, 0.05328817f, 0.11584925f, -0.06167509f, -0.25495490f, 0.08991810f, -0.15367518f, 
    0.05447713f, 0.02498634f, -0.14046986f, 0.05237785f, -0.14555396f, 0.30364656f, 0.01136974f, 0.22071105f, 
    -0.09401008f, -0.09198872f, -0.18074813f, -0.13820863f, 0.11391605f, -0.16959946f, -0.36987191f, 0.00054649f, 
    -0.23242125f, 0.04062994f, 0.02923401f, 0.08720168f, -0.02188524f, 0.03843246f, -0.03746614f, 0.44814894f, 
    0.30313444f, 0.31855240f, 0.01137422f, -0.15739587f, 0.06259539f, 0.19307438f, -0.19961561f, 0.03482623f, 
    0.02066624f, -0.14763181f, -0.04209214f, -0.25904700f, 0.08079302f, -0.08786963f, -0.07786940f, 0.02923296f, 
    -0.01837656f, 0.19395995f, 0.04668251f, 0.02732471f, -0.19141883f, -0.24474557f, -0.05386792f, 0.11759104f, 
    0.02571737f, 0.02754259f, -0.05645163f, 0.06480435f, -0.46043339f, -0.27613759f, 0.04632945f, 0.02440020f, 
    0.27929610f, -0.24792130f, -0.08454012f, 0.17391558f, 0.15608907f, 0.17671792f, 0.11089691f, -0.05383054f, 
    -0.22288258f, -0.05270608f, 0.10077163f, -0.04551156f, 0.16166531f, -0.11743417f, 0.15815976f, -0.52781790f, 
    0.00598362f, -0.09232067f, 0.31956723f, 0.11811528f, -0.12638792f, -0.06671084f, 0.26389614f, 0.08004105f, 
    0.19940822f, 0.28035557f, 0.12638561f, -0.13143121f, 0.02688077f, 0.07318251f, 0.36603278f, 0.19299929f, 
    0.16247028f, 0.10483605f, -0.06914996f, -0.17363766f, 0.06392397f, 0.06509022f, -0.04790081f, -0.00111057f, 
    -0.11777907f, -0.05239865f, -0.11022087f, 0.03397250f, -0.00578835f, 0.04972984f, 0.12029862f, 0.13993759f, 
    0.47844848f, 0.09652484f, -0.12833643f, -0.15039879f, -0.20726895f, 0.08749688f, 0.09827317f, 0.02150920f, 
    0.05630980f, 0.19735496f, -0.11470247f, 0.01047829f, 0.09028351f, -0.00085750f, 0.23837809f, -0.19617765f, 
    -0.12741923f, 0.05984185f, 0.32093853f, -0.21490070f, -0.11095468f, 0.04386350f, 0.08733252f, 0.12687634f, 
    0.12976608f, -0.04140818f, 0.04217063f, -0.28397867f, -0.07558381f, -0.10396169f, 0.14461176f, -0.14143202f, 
    0.06673168f, -0.09866513f, 0.01202193f, -0.13235584f, 0.15471667f, -0.17253031f, -0.01085442f, -0.04888836f, 
    0.11143049f, 0.31970957f, 0.00822813f, 0.06613133f, -0.22722331f, -0.29267636f, 0.01000040f, 0.02520111f, 
    -0.15445706f, -0.13346343f, -0.02589502f, 0.02376408f, 0.02064739f, -0.08449131f, -0.07998126f, 0.02716975f, 
    0.08360933f, -0.07540851f, 0.05907042f, -0.37155437f, 0.15346064f, 0.07720327f, -0.04577348f, 0.21898395f, 
    -0.03259379f, -0.08797088f, -0.31603476f, -0.17448527f, -0.26886383f, 0.11014865f, 0.07579912f, -0.11750375f, 
    -0.04079920f, -0.24687183f, -0.15539120f, 0.00997090f, 0.23454992f, -0.10262971f, 0.08781732f, -0.03931760f, 
    -0.06992909f, -0.17670909f, 0.03904352f, -0.03930782f, -0.13172346f, 0.02481273f, -0.08352537f, -0.05430792f, 
    -0.03704204f, 0.08603284f, 0.28301755f, 0.05994725f, -0.03504866f, 0.07428107f, -0.14009964f, 0.00056901f, 
    0.24741969f, -0.13982622f, -0.04784747f, -0.18996768f, 0.01384932f, 0.04453254f, 0.24792446f, -0.25667793f, 
    0.06823735f, 0.05777106f, -0.01589386f, 0.04259283f, 0.34262705f, 0.42565602f, 0.38584468f, -0.05312541f, 
    0.00983628f, 0.08840691f, 0.09337614f, -0.07329379f, 0.06931637f, -0.07710218f, 0.00237434f, -0.28678951f, 
    0.05860554f, 0.07005516f, 0.13518223f, 0.22788198f, 0.09998035f, 0.00114285f, 0.33313859f, -0.09555317f, 
    -0.03464969f, 0.25484207f, 0.19575775f, 0.11658207f, 0.16841070f, -0.15275082f, 0.06255462f, -0.60981768f, 
    -0.31288469f, -0.08016601f, -0.09267509f, -0.06736391f, -0.01221033f, -0.26492286f, 0.01199810f, -0.06229076f, 
    -0.10254752f, 0.00711632f, -0.18304150f, -0.11350917f, 0.02159483f, -0.02773966f, -0.02542983f, -0.08040743f, 
    0.18563771f, 0.35192975f, 0.14155111f, 0.31242174f, 0.02517669f, -0.11526393f, -0.01150947f, 0.37133017f, 
    0.07293809f, 0.05022866f, 0.30735043f, 0.15652439f, 0.25598618f, -0.02642837f, 0.04612124f, -0.01698176f, 
    0.04200023f, -0.08569694f, 0.16563345f, -0.05504597f, 0.21500039f, -0.38903910f, -0.15831117f, 0.11525713f, 
    0.00530993f, 0.11993030f, 0.07847021f, 0.05975120f, 0.01249289f, 0.26105043f, 0.06923436f, -0.17659751f, 
    0.16992033f, 0.03726023f, 0.07825425f, 0.01331196f, 0.09185299f, -0.27269402f, -0.11840890f, 0.27038077f, 
    0.03212988f, -0.00068881f, -0.07062350f, -0.13831303f, -0.16266839f, 0.03537495f, 0.04740093f, 0.11317257f, 
    0.18073408f, 0.18332799f, 0.16723435f, 0.32934576f, -0.00069815f, 0.08141243f, 0.08639823f, 0.14235270f, 
    0.10006700f, 0.22092637f, 0.00248202f, 0.03674604f, 0.11849220f, -0.06201191f, 0.20172624f, -0.21896510f, 
    0.08856852f, -0.00409359f, -0.24957691f, 0.08717201f, 0.10896602f, -0.01536555f, 0.16611823f, -0.09031101f, 
    -0.06002820f, -0.51966137f, 0.06019436f, 0.22175021f, -0.00333276f, 0.00941467f, -0.07744664f, -0.00940742f, 
    -0.09234624f, 0.04688470f, -0.20070891f, -0.43959957f, -0.40079802f, -0.42936736f, 0.33440015f, -0.08695848f, 
    0.03830116f, -0.28216133f, 0.01717790f, -0.35875922f, -0.06394804f, -0.02529064f, 0.05837688f, 0.08701642f, 
    -0.04769150f, 0.06588694f, -0.07088165f, -0.07307386f, -0.04481458f, 0.12815121f, -0.17052706f, -0.06879072f, 
    0.15248919f, 0.01712939f, 0.15914351f, -0.03612728f, -0.16287182f, 0.71832269f, 0.43550533f, 0.18802431f, 
    0.03019805f, -0.03540037f, -0.06232519f, 0.17984174f, -0.14564976f, 0.21019363f, -0.09617063f, 0.10009479f, 
    -0.24379086f, 0.17589602f, -0.09502219f, -0.01492353f, 0.14090692f, -0.01246568f, -0.05416449f, -0.18640758f, 
    -0.19495998f, -0.16977231f, 0.00117247f, -0.02885430f, -0.02139024f, -0.26413617f, 0.30235633f, -0.11508606f, 
    -0.64715064f, -0.26777434f, -0.11699744f, 0.13430233f, 0.20234926f, 0.15798958f, -0.07184911f, -0.19088008f, 
    0.01343989f, 0.46756265f, -0.06379398f, 0.08346424f, 0.22322446f, -0.01548607f, -0.08568510f, -0.04640058f, 
    -0.10718913f, 0.12683462f, 0.05826304f, -0.12842961f, -0.66168451f, 0.10578255f, -0.07366720f, -0.03616750f, 
    0.03476844f, 0.01561449f, 0.10379433f, -0.32114404f, 0.24917527f, -0.32106033f, -0.01704722f, 0.10638425f, 
    0.04346060f, 0.00712190f, 0.10954092f, 0.02624238f, -0.66719365f, -0.51617950f, -0.25063020f, 0.00221632f, 
    -0.02989075f, 0.20087498f, -0.17700700f, 0.03226581f, 0.15545920f, -0.12018878f, 0.18666469f, -0.26981542f, 
    -0.00454311f, 0.05307761f, 0.12292649f, -0.04929144f, 0.19570802f, -0.06452089f, -0.34755039f, -0.11231216f, 
    0.24793980f, -0.04438208f, 0.22106914f, -0.00347338f, 0.19946302f, 0.06335078f, -0.06300877f, 0.19634765f, 
    -0.08046310f, -0.22535123f, -0.10786141f, -0.10956744f, -0.10298809f, 0.17047806f, 0.03295430f, -0.11998966f, 
    0.03146760f, 0.01095904f, -0.05700602f, 0.00134953f, -0.03948771f, 0.01348319f, -0.05758512f, -0.03256884f, 
    0.00506068f, 0.04764768f, -0.03394454f, -0.01253391f, -0.04640435f, -0.01585543f, 0.03769886f, 0.01770856f, 
    0.01578925f, -0.01291745f, -0.02704834f, 0.01863154f, 0.02322457f, 0.04280506f, -0.01531067f, -0.01007663f, 
    0.00922507f, -0.05327040f, -0.05893699f, 0.02274696f, 0.01640877f, -0.00348207f, 0.02391489f, -0.00658999f, 
    0.01670395f, 0.01077261f, -0.01997118f, -0.05778118f, -0.06743643f, -0.05414635f, -0.03684683f, 0.01181436f, 
    0.02298132f, -0.03864179f, -0.00119397f, -0.02901938f, -0.02919921f, -0.03040794f, -0.04589693f, -0.05821100f, 
    -0.03143350f, -0.00881719f, -0.03117309f, 0.04389718f, -0.00430489f, -0.05104394f, 0.01888645f, -0.06409346f, 
    -0.04089083f, -0.05643218f, 0.01174662f, 0.02881910f, -0.05898403f, 0.01302561f, -0.03772940f, -0.01513774f, 
    -0.04195402f, -0.01157180f, 0.02978678f, 0.04527349f, 0.02166765f, -0.04643311f, -0.05057941f, 0.04618387f, 
    0.02474460f, 0.02354225f, 0.02976270f, 0.03306807f, 0.04716324f, 0.00629778f, -0.02024233f, -0.00489504f, 
    0.05207296f, 0.01504321f, -0.06357142f, -0.03521311f, 0.05120153f, -0.00969559f, -0.00789947f, -0.03228300f, 
    -0.04613056f, -0.00162857f, 0.00044660f, -0.01982658f, -0.00472455f, 0.03772459f, -0.04592774f, -0.00904780f, 
    0.04463381f, 0.04149291f, -0.00303403f, 0.02929796f, -0.05145831f, -0.01764154f, 0.01984826f, -0.02548572f, 
    -0.03700905f, -0.05970529f, -0.00303826f, -0.03455599f, 0.02429366f, -0.02942883f, 0.05122978f, -0.02601118f, 
    -0.00392278f, -0.01455969f, -0.01999968f, -0.04913548f, -0.02900521f, -0.05177667f, -0.01425920f, -0.05910897f, 
    -0.03897488f, -0.05421969f, 0.04471653f, -0.00875879f, 0.03363712f, 0.02104395f, -0.02701204f, -0.02559462f, 
    0.04451153f, -0.05849935f, -0.04327030f, -0.00844719f, 0.04042879f, -0.01553957f, 0.00288406f, -0.04990534f, 
    -0.03275169f, -0.04111139f, -0.02298612f, -0.02041529f, 0.01483745f, 0.03848930f, -0.03654370f, -0.05114564f, 
    -0.00899729f, -0.04038972f, -0.01802787f, -0.02457746f, 0.02105213f, 0.03108830f, 0.02439299f, 0.05241742f, 
    -0.04435203f, 0.02170883f, 0.04074757f, -0.01435223f, 0.03493509f, 0.00444140f, -0.06244245f, 0.01856286f, 
    -0.05946649f, -0.04923398f, -0.04271644f, 0.03187196f, -0.01728126f, 0.01503303f, -0.01997534f, -0.03486519f, 
    -0.00962958f, -0.01379721f, -0.00637223f, -0.03867990f, 0.00670844f, -0.06216270f, -0.03842609f, 0.03767214f, 
    0.04259283f, 0.00572652f, 0.03702160f, -0.00890040f, -0.02017135f, -0.03994679f, -0.02473415f, 0.00906272f, 
    -0.03849722f, -0.02245413f, 0.02369896f, 0.02173478f, -0.04082293f, 0.01631543f, 0.02277420f, 0.05298860f, 
    0.01138440f, 0.00159926f, -0.04900821f, -0.02119451f, 0.05172511f, -0.00114303f, -0.01915822f, -0.02689085f, 
    -0.05784221f, -0.03195250f, 0.03248006f, -0.06351054f, 0.03892053f, -0.04521010f, -0.05159913f, 0.03273510f, 
    0.01522431f, 0.04182601f, 0.00086154f, -0.02056326f, -0.05611128f, -0.03463588f, -0.00260204f, -0.04238083f, 
    -0.03517506f, -0.00380231f, -0.02383284f, 0.02368679f, -0.05058950f, 0.02774878f, 0.02234808f, -0.04310470f, 
    -0.05369061f, -0.04429292f, 0.02119788f, -0.02104918f, -0.00860796f, 0.04190733f, 0.00718083f, 0.02063303f, 
    0.04523809f, -0.06030788f, -0.02244933f, -0.03968238f, -0.02403321f, -0.02176027f, -0.01951376f, 0.04472836f, 
    0.04264595f, 0.01352168f, -0.01657698f, 0.00261752f, -0.03846584f, 0.04947944f, 0.01090870f, -0.03617372f, 
    -0.01988169f, 0.05201665f, -0.02078432f, 0.02324435f, 0.00466220f, 0.03433150f, 0.01486209f, -0.01718151f, 
    -0.02907904f, -0.01160854f, 0.02132219f, -0.05516205f, -0.05518344f, 0.03199818f, 0.05218836f, -0.03136008f, 
    -0.05150136f, 0.02129818f, 0.03354282f, 0.05258982f, 0.04338730f, 0.00050731f, -0.01633088f, -0.05825317f, 
    -0.02283898f, 0.01003162f, 0.05383525f, -0.02184269f, 0.04364278f, 0.04650176f, -0.06357085f, 0.00057758f, 
    -0.01520032f, -0.02056810f, 0.03036072f, -0.04973907f, -0.05246481f, 0.02872787f, 0.01814034f, -0.02863063f, 
    -0.20362434f, 0.28441513f, 0.22924222f, 0.15785913f, -0.09084464f, -0.06654076f, 0.00108078f, 0.10651465f, 
    0.00721331f, 0.09292148f, 0.10776536f, -0.61901504f, 0.14097703f, 0.02501019f, 0.03160581f, -0.01609143f, 
    -0.12115268f, -0.04553220f, 0.36529627f, 0.05349049f, -0.02132778f, -0.04902586f, -0.01438766f, 0.13414061f, 
    -0.03241884f, 0.24183531f, 0.18288602f, 0.47517446f, 0.04969950f, -0.23207250f, -0.22257850f, -0.16848111f, 
    0.06523891f, -0.11576097f, -0.20943496f, 0.03932843f, 0.16054145f, 0.05251272f, 0.12941365f, 0.04239007f, 
    0.01893213f, 0.07783079f, -0.04922628f, -0.00779512f, -0.06735375f, -0.21304429f, -0.06346364f, -0.02887134f, 
    0.13423353f, 0.11835468f, -0.07316766f, -0.09349185f, 0.04747768f, -0.01050611f, -0.08310463f, 0.11518332f, 
    -0.02735321f, -0.01837537f, 0.03395799f, 0.07225945f, 0.09433473f, 0.10040618f, -0.03605555f, 0.21534467f, 
    -0.30918831f, -0.71381170f, 0.08691843f, 0.16489322f, -0.01281726f, -0.29663277f, -0.12076434f, -0.04636741f, 
    0.35279810f, 0.27894154f, -0.11070357f, 0.01326016f, -0.08854038f, 0.19001243f, -0.14250259f, -0.01526789f, 
    0.12237903f, 0.21728304f, 0.39262477f, 0.22457160f, -0.24089222f, 0.28630027f, -0.03167249f, -0.09035483f, 
    -0.01195257f, -0.17304915f, -0.21976933f, 0.01809091f, 0.10462236f, 0.07106127f, 0.08778258f, -0.01812163f, 
    0.06191225f, -0.01192547f, -0.01635630f, -0.27435327f, -0.06575000f, -0.14170234f, 0.04226774f, 0.10979683f, 
    -0.02902836f, 0.13315441f, 0.14543468f, -0.14127800f, 0.15300611f, -0.21224728f, 0.34946609f, -0.15576300f, 
    -0.02107901f, 0.05251078f, -0.02086129f, -0.00698259f, 0.18018220f, -0.07406315f, -0.01235474f, 0.21853574f, 
    0.17476758f, 0.24880059f, 0.02025873f, -0.02456771f, -0.32785875f, -0.15763217f, 0.20825940f, -0.02435384f, 
    -0.25040311f, 0.03945759f, 0.11223143f, 0.40018299f, 0.38522938f, 0.02390208f, 0.09266078f, 0.35744172f, 
    0.28228474f, 0.11629804f, 0.01229964f, 0.10061515f, -0.13448501f, -0.01309742f, -0.13391478f, 0.20204681f, 
    -0.58973646f, 0.20224556f, -0.26477250f, 0.02851652f, 0.33619064f, -0.30436963f, 0.18832178f, 0.05936093f, 
    -0.01094652f, 0.11087065f, -0.61010635f, 0.30299479f, 0.02581237f, 0.07199974f, -0.08303096f, -0.04994063f, 
    0.05973951f, -0.04469202f, -0.29222721f, -0.44334340f, -0.13352147f, -0.00506346f, -0.08205710f, 0.10181103f, 
    -0.01824362f, -0.02253961f, 0.32089925f, -0.15369965f, -0.28288761f, -0.05092498f, 0.00412368f, 0.08456660f, 
    0.19624703f, -0.03834778f, -0.05424636f, -0.08580649f, -0.33484498f, -0.54044563f, -0.40406096f, -0.12703064f, 
    0.06698190f, -0.11380304f, -0.01669361f, 0.02541105f, -0.11039208f, 0.30353785f, 0.16639283f, 0.28071487f, 
    0.05536133f, 0.10625447f, -0.15589210f, -0.16055414f, -0.01332141f, -0.04362778f, 0.01867643f, -0.11827321f, 
    -0.15965578f, -0.16620190f, 0.27125421f, 0.08420926f, -0.12359641f, 0.27700156f, 0.16501011f, -0.17088427f, 
    -0.01174143f, -0.25724939f, 0.08548229f, 0.11083253f, -0.07393830f, 0.19804814f, -0.09273323f, -0.06134779f, 
    0.33653426f, -0.31582409f, -0.04273675f, 0.15485582f, 0.07906630f, 0.14802636f, -0.08129162f, -0.12187891f, 
    -0.19383417f, -0.30981815f, 0.13020451f, 0.39350185f, -0.08794680f, 0.26025248f, -0.03035516f, 0.04147191f, 
    -0.05861710f, 0.14006290f, -0.10202955f, 0.04736755f, -0.01306385f, -0.01822518f, 0.29726291f, -0.03126311f, 
    -0.09121341f, -0.06027565f, -0.03983467f, 0.02431963f, -0.04722770f, 0.16161618f, -0.08037785f, 0.14430894f, 
    0.04916049f, -0.03080446f, 0.03890050f, 0.05370247f, 0.38980517f, -0.20158142f, 0.07957844f, 0.00432395f, 
    -0.05012763f, -0.04428444f, 0.04619232f, 0.09522649f, -0.05582821f, -0.00238318f, 0.01207723f, -0.25172910f, 
    0.16130717f, 0.13895158f, 0.14872889f, 0.23674402f, 0.16418990f, 0.06786457f, -0.58146971f, 0.02350189f, 
    -0.09355611f, -0.07995932f, 0.04013650f, -0.02911919f, -0.04869643f, -0.00912834f, 0.06553200f, -0.68818617f, 
    -0.28437218f, -0.14649658f, 0.15780134f, 0.14668424f, 0.03045111f, 0.03299292f, 0.07923175f, -0.18418115f, 
    -0.20868739f, -0.11208737f, -0.25164828f, 0.25035065f, -0.05715645f, 0.18950307f, 0.07676727f, 0.26215076f, 
    -0.20187534f, -0.19547571f, 0.00821301f, 0.22992186f, 0.05287141f, -0.03003905f, 0.10276647f, -0.25335881f, 
    -0.17675766f, 0.33221912f, 0.06469508f, 0.21225011f, 0.12094874f, 0.01555074f, -0.05235063f, -0.28926310f, 
    0.24135523f, -0.13716774f, -0.24998084f, 0.18488279f, -0.02975826f, -0.19341053f, -0.06813401f, 0.23237759f, 
    0.04641029f, 0.19959603f, -0.09843099f, -0.20477360f, -0.10656977f, -0.05280364f, -0.09981340f, -0.02621472f, 
    -0.03609661f, 0.12617096f, 0.04518548f, 0.02350118f, -0.07671271f, 0.20690902f, 0.15747239f, 0.03772760f, 
    -0.03413638f, 0.20877638f, -0.05501849f, 0.05675177f, 0.19036029f, 0.08838217f, -0.01756176f, -0.02437151f, 
    -0.12477095f, -0.07233127f, -0.09050318f, 0.09644260f, 0.20607121f, -0.12485507f, -0.34124535f, -0.50111169f, 
    -0.01058161f, 0.24215662f, -0.16413163f, 0.05971082f, 0.08597280f, -0.21566895f, 0.23434103f, 0.43428347f, 
    0.25301942f, -0.01707260f, -0.00923174f, -0.12214518f, 0.00890007f, -0.19829421f, 0.06670566f, -0.25426668f, 
    0.05823922f, 0.07819262f, -0.26508576f, -0.32176977f, 0.09022463f, -0.03342681f, -0.17031246f, 0.07498606f, 
    0.11405525f, -0.15847127f, -0.13334677f, 0.07176507f, -0.16753559f, 0.05470848f, 0.28212184f, 0.03893895f, 
    0.11962456f, -0.19227955f, -0.38376075f, -0.14356366f, -0.09464723f, -0.10036805f, 0.11986091f, 0.01520961f, 
    -0.33170035f, -0.06710371f, 0.03164355f, 0.02248088f, 0.27873558f, 0.36959231f, -0.04844140f, -0.09624649f, 
    0.03741878f, 0.02136893f, 0.08435774f, 0.13342845f, 0.21759091f, -0.33857331f, -0.04982305f, 0.00831893f, 
    0.12261808f, 0.17004889f, 0.10115854f, 0.00507045f, -0.02826900f, -0.10604922f, -0.30877587f, -0.00133459f, 
    -0.30528292f, -0.10795732f, 0.26861650f, 0.16518590f, 0.01563200f, -0.01049638f, -0.26031244f, -0.07267401f, 
    0.16352260f, -0.01871042f, -0.02209573f, -0.20866390f, -0.27780092f, -0.18754417f, 0.09944497f, -0.09328612f, 
    -0.00975635f, -0.09195751f, -0.06195160f, 0.15844150f, -0.10260662f, -0.14186688f, 0.09603179f, -0.07804769f, 
    0.24831334f, 0.37242943f, 0.00814191f, 0.18422773f, -0.06696381f, 0.11540472f, -0.00648274f, -0.03367139f, 
    -0.04873421f, 0.10759038f, -0.18100028f, 0.31170833f, -0.08150721f, -0.18041269f, 0.15772115f, 0.11124681f, 
    0.16781767f, 0.16750447f, -0.04744388f, -0.17839795f, -0.00731460f, 0.10816573f, 0.19431107f, 0.17508787f, 
    -0.21507762f, 0.03355803f, 0.07508162f, -0.15425965f, 0.37103173f, 0.14802621f, -0.01644256f, -0.36699605f, 
    0.18119222f, 0.15324785f, -0.10149238f, 0.02813035f, 0.06648097f, 0.39503735f, -0.04652188f, -0.06932989f, 
    0.17121683f, -0.01057943f, -0.15725926f, 0.01027618f, -0.01396226f, 0.07446076f, -0.05535372f, -0.09361538f, 
    0.00393089f, 0.11735687f, 0.02437115f, -0.37193948f, 0.16141041f, -0.10230047f, -0.17854936f, -0.13474883f, 
    0.00245306f, 0.12260266f, -0.09724572f, -0.11891955f, -0.03419881f, -0.28435349f, 0.26861370f, 0.42451525f, 
    -0.36987358f, -0.14811565f, 0.02972497f, 0.22438298f, 0.18641509f, 0.14635834f, 0.10542485f, -0.02168976f, 
    -0.20687890f, 0.20549537f, 0.12612101f, -0.01178280f, 0.20125550f, -0.15969855f, 0.09701288f, -0.09633920f, 
    0.17825048f, -0.02354525f, 0.08751961f, 0.06528117f, 0.10844129f, -0.05126680f, -0.10683236f, 0.03393688f, 
    -0.03226729f, 0.19517280f, 0.09584392f, -0.42652395f, -0.00599303f, -0.02673274f, 0.11580219f, -0.02304192f, 
    0.14798987f, -0.09070460f, 0.01806130f, -0.21545771f, -0.07955542f, -0.10852166f, -0.25645170f, 0.07646909f, 
    0.12587340f, 0.34021860f, 0.11783638f, 0.10635448f, -0.31512210f, -0.09111985f, 0.05857406f, 0.09284332f, 
    0.37804535f, -0.11375555f, 0.12398968f, -0.16169982f, -0.05724282f, 0.12998937f, 0.00127483f, -0.11331886f, 
    0.02202372f, -0.00379417f, 0.21477346f, -0.18997498f, -0.12855013f, -0.21782394f, -0.09052294f, -0.13677607f, 
    -0.13962252f, 0.18489590f, -0.03678089f, 0.00275645f, -0.00964471f, -0.07358842f, -0.15695803f, 0.15094131f, 
    0.02947180f, 0.03043683f, -0.04676276f, 0.00912402f, 0.01958052f, -0.04288444f, -0.01821534f, -0.02759625f, 
    0.02117441f, -0.03714461f, -0.01982041f, -0.05852832f, 0.01583379f, -0.00278874f, 0.04051502f, 0.05112335f, 
    0.00446760f, -0.01598507f, 0.04001375f, -0.00919274f, 0.04128525f, -0.01865095f, 0.02924023f, -0.01306523f, 
    -0.02069270f, -0.02056376f, -0.05608494f, -0.00270868f, -0.02833852f, -0.02512803f, 0.04253234f, 0.00239625f, 
    0.05014832f, 0.04862166f, -0.01541551f, -0.00578926f, 0.02658792f, 0.04327816f, 0.00262652f, -0.04289466f, 
    -0.05821851f, 0.04128851f, -0.06409539f, -0.02421583f, -0.04980079f, -0.03254515f, -0.02420719f, -0.04018905f, 
    -0.01248434f, -0.06127831f, -0.05540527f, 0.02686550f, -0.05289307f, -0.03295071f, 0.00769142f, -0.01190624f, 
    -0.01568487f, 0.01983990f, -0.01663210f, -0.05922811f, -0.03742149f, 0.02055846f, 0.04694883f, 0.00841131f, 
    0.04478096f, 0.00440542f, -0.06453635f, 0.05250942f, -0.02169919f, 0.04574466f, 0.01055713f, 0.02936046f, 
    -0.04707392f, -0.04572006f, -0.02572069f, 0.01200799f, -0.00171669f, 0.04416525f, 0.05174365f, -0.03386552f, 
    0.00833815f, -0.04525653f, -0.02694520f, -0.06271491f, 0.04684483f, -0.00425998f, -0.00912646f, -0.02462576f, 
    0.03795312f, -0.06200178f, -0.00288461f, -0.01400409f, 0.04306216f, -0.02430388f, -0.02682790f, -0.02019673f, 
    0.04543069f, 0.04925076f, -0.01353817f, -0.01920845f, -0.04171923f, 0.04199964f, 0.02702570f, -0.03099179f, 
    0.01861977f, -0.01463807f, 0.05223302f, 0.03785090f, 0.06272276f, -0.01188480f, 0.04494911f, -0.05389096f, 
    0.04263905f, -0.00903190f, -0.00768038f, 0.00617756f, -0.01170487f, -0.05528474f, -0.01872109f, 0.00614331f, 
    0.02582757f, -0.05527702f, 0.00311758f, 0.01647927f, 0.01794677f, -0.06323761f, 0.02090992f, -0.00320980f, 
    -0.01485237f, -0.05824583f, -0.01207628f, 0.02638724f, -0.03222219f, -0.04170901f, -0.00925130f, -0.02331486f, 
    -0.02405139f, -0.01143258f, 0.02627091f, -0.03349838f, 0.00340312f, -0.00979374f, 0.04077358f, 0.00089242f, 
    -0.01540973f, 0.03291607f, -0.04302202f, -0.01943062f, -0.04684630f, 0.01549548f, -0.04187511f, -0.00673209f, 
    0.02971647f, -0.03160995f, -0.05589876f, -0.00541366f, -0.02033330f, 0.01866765f, -0.03110960f, 0.04011363f, 
    -0.01094600f, -0.04012565f, 0.04689804f, 0.02634107f, 0.03234200f, 0.00335091f, -0.04168108f, 0.01555090f, 
    -0.00638011f, 0.03314834f, -0.04553134f, 0.00743901f, -0.05470886f, 0.02251422f, 0.03072097f, -0.03033171f, 
    0.03891221f, 0.01790209f, -0.06359780f, -0.02585469f, 0.00149726f, -0.01298245f, -0.04957108f, 0.04105593f, 
    -0.04525986f, 0.00798132f, 0.03799206f, 0.03235206f, 0.01743390f, -0.05912118f, 0.02240898f, -0.04276651f, 
    -0.01993305f, -0.04542945f, -0.05194389f, -0.05722039f, 0.02805153f, 0.01089313f, 0.01570908f, -0.02967639f, 
    0.00856889f, -0.00885737f, -0.01794004f, 0.03776758f, 0.02475532f, -0.02498874f, 0.03169031f, 0.03833221f, 
    -0.06448972f, 0.04547906f, 0.01690346f, 0.03167338f, 0.03868412f, -0.00307112f, 0.03551992f, -0.06054171f, 
    -0.00806636f, 0.04112881f, -0.00173672f, -0.03627335f, -0.00154113f, 0.04852332f, 0.00518132f, -0.06033349f, 
    0.00134153f, -0.06322985f, 0.00659154f, -0.03918731f, -0.00808381f, -0.06097835f, 0.02142715f, -0.06121019f, 
    -0.01508571f, -0.01933397f, -0.05460903f, 0.03430336f, 0.06189373f, -0.03855240f, 0.01530268f, 0.00980802f, 
    -0.01908154f, -0.00514525f, 0.03666466f, -0.05380995f, -0.01267252f, 0.01200591f, 0.01719338f, -0.05310508f, 
    -0.03560202f, -0.04949077f, 0.02739464f, -0.02839423f, -0.03834346f, -0.02341208f, -0.03584444f, 0.02597043f, 
    -0.00773124f, 0.04811317f, -0.03512747f, -0.03948415f, 0.05280696f, 0.02032265f, -0.00942961f, -0.03930767f, 
    0.02058332f, -0.04999618f, -0.01982787f, -0.04578524f, 0.00685257f, -0.03009030f, 0.02175386f, 0.01245931f, 
    -0.00069277f, 0.02621647f, 0.02277202f, -0.01646555f, 0.05004425f, 0.01485127f, -0.05623449f, -0.04747609f, 
    0.03010275f, 0.05162952f, 0.02087434f, -0.05004330f, 0.00486788f, -0.00188564f, -0.05497066f, 0.00133838f, 
    0.04714803f, -0.00297752f, -0.06552015f, 0.00499027f, -0.04369121f, 0.01612311f, 0.03520129f, 0.03188708f, 
    -0.05761471f, 0.01579474f, -0.00784932f, -0.05633176f, 0.04821778f, -0.00934179f, -0.00784009f, 0.01723742f, 
    -0.03388602f, -0.02371288f, -0.03377644f, 0.03560419f, 0.02749797f, -0.00077085f, -0.02881476f, -0.01806311f, 
    0.03129145f, -0.02761935f, -0.04711592f, 0.03030888f, -0.04169036f, 0.01095170f, -0.02039333f, -0.04103421f, 
    -0.00212292f, -0.04769421f, -0.04937304f, 0.02244781f, -0.02218108f, 0.04246355f, -0.05771000f, -0.00341027f, 
    0.01844203f, 0.02457403f, 0.00177040f, -0.04408586f, 0.03548266f, -0.03195011f, -0.00060424f, 0.03299597f, 
    -0.01078657f, 0.05036783f, -0.03352918f, -0.00962325f, -0.04350407f, 0.03822434f, 0.03841400f, -0.06014211f, 
    0.02618141f, -0.04557438f, -0.00825371f, -0.02186290f, -0.06292227f, -0.04344966f, -0.04484473f, 0.00460229f, 
    -0.03922933f, 0.01171043f, 0.02369967f, -0.03995847f, 0.02593610f, 0.02756819f, 0.00640988f, -0.01339771f, 
    0.04535637f, 0.04659050f, 0.01149813f, -0.02992245f, -0.01806894f, 0.04509265f, -0.01657535f, -0.00695154f, 
    -0.04720382f, 0.02954415f, -0.00946899f, 0.02989788f, 0.01306601f, -0.03913439f, -0.03616978f, -0.02789554f, 
    0.02778702f, -0.05163974f, 0.00197947f, 0.02417908f, -0.01337349f, -0.00658835f, 0.03981360f, 0.02120477f, 
    0.01075938f, -0.05689272f, 0.02741118f, 0.02087432f, 0.00011081f, 0.00107383f, 0.02570781f, 0.03247221f, 
    0.03679793f, -0.05440382f, -0.00165784f, -0.02353010f, -0.00328615f, -0.03235271f, -0.01333734f, 0.03149372f, 
    0.02704471f, -0.06612519f, -0.05353799f, 0.02202366f, -0.01924577f, -0.05717482f, -0.05070631f, 0.04109113f, 
    -0.02398068f, -0.02528838f, 0.03808609f, 0.05032532f, 0.01462601f, -0.04995157f, 0.00043550f, 0.00153158f, 
    -0.02222704f, -0.04112676f, -0.06448050f, -0.00961988f, 0.03676495f, 0.02937356f, -0.06373572f, -0.00042841f, 
    -0.01101804f, 0.00832633f, 0.00899809f, 0.04025539f, -0.05573552f, 0.04896110f, -0.01759672f, -0.00155583f, 
    0.03546290f, -0.01203490f, -0.02764313f, -0.02974842f, 0.02656466f, 0.05026003f, 0.02502721f, -0.03762308f, 
    0.01138921f, -0.03627433f, -0.01737050f, -0.02589498f, 0.04615015f, -0.05952723f, -0.05121237f, 0.03353207f, 
    0.00082822f, -0.05650827f, 0.00711102f, 0.04704241f, 0.02621680f, 0.01366789f, 0.03015413f, -0.02218014f, 
    -0.04737683f, -0.00101159f, -0.04737340f, -0.02667738f, -0.02411620f, 0.04164957f, -0.01152250f, -0.06141747f, 
    0.03665494f, 0.03735443f, -0.02045373f, -0.01174913f, 0.00859013f, -0.02072672f, -0.03017419f, 0.05072587f, 
    -0.00686027f, 0.03241165f, -0.06542306f, 0.03952729f, -0.06374896f, 0.02358629f, -0.01385338f, -0.05140323f, 
    0.02648705f, -0.04243096f, -0.06576540f, -0.05699430f, -0.05117392f, -0.06502346f, -0.01542479f, 0.00265735f, 
    -0.00997131f, 0.02850707f, 0.02828944f, 0.00969423f, 0.01789443f, 0.02522869f, 0.00109826f, -0.03822646f, 
    -0.00008365f, -0.06244501f, -0.03449566f, -0.04117706f, 0.02738349f, 0.00903448f, -0.01350954f, -0.04691702f, 
    -0.03482847f, -0.00193033f, 0.00441913f, 0.04251093f, -0.05255997f, 0.01751577f, 0.01546822f, 0.01572991f, 
    0.04559582f, 0.03794398f, -0.02557532f, -0.06039279f, -0.05435370f, -0.00562746f, 0.04640993f, 0.02710717f, 
    -0.04757447f, -0.02949257f, 0.03516024f, -0.02043933f, -0.06320870f, -0.05014080f, 0.03067334f, -0.06336161f, 
    0.03378819f, -0.02605634f, -0.06463824f, -0.03095348f, -0.05649913f, -0.04529745f, 0.00298056f, -0.02478080f, 
    -0.01532507f, -0.05008244f, -0.03949539f, -0.03630557f, -0.03809396f, 0.03388680f, 0.00217072f, 0.00033331f, 
    -0.04959002f, -0.02324940f, -0.06506147f, 0.01190110f, -0.06193063f, 0.04763783f, 0.02822841f, -0.03186002f, 
    -0.01473860f, 0.01988168f, -0.05970011f, -0.01071042f, -0.04440589f, 0.01961785f, -0.04711538f, -0.04557182f, 
    0.04448286f, -0.02411114f, 0.02374463f, 0.04059046f, -0.00104891f, -0.03702056f, -0.00891432f, 0.03728184f, 
    0.00811563f, 0.00042488f, 0.04044466f, 0.00622198f, -0.03855628f, 0.04351530f, 0.04987457f, -0.06368165f, 
    0.20499645f, -0.04989475f, -0.34550908f, -0.09596146f, 0.01489790f, 0.01838947f, 0.05436742f, 0.05302548f, 
    0.02294473f, 0.04588243f, -0.22269499f, 0.12846929f, 0.14050294f, 0.00623551f, -0.21868710f, 0.04897987f, 
    -0.01951554f, -0.02003263f, -0.10387298f, -0.08178900f, 0.02984595f, 0.08628793f, 0.13360319f, -0.13768762f, 
    -0.12491158f, -0.15548116f, 0.16959453f, -0.09196011f, -0.10055029f, 0.08132091f, 0.30729568f, -0.17179970f, 
    -0.23168038f, -0.00489902f, 0.23539597f, 0.04621573f, -0.06582939f, -0.11666648f, -0.08159319f, 0.11473788f, 
    -0.16781490f, 0.01546476f, 0.03916752f, -0.05363129f, 0.07199578f, -0.18540744f, -0.08493451f, -0.23117216f, 
    -0.07342308f, 0.10646193f, -0.03370406f, -0.06671003f, -0.02580412f, 0.16932170f, 0.25680515f, 0.14162174f, 
    -0.01576239f, -0.05052574f, -0.02624509f, 0.03156036f, -0.03817282f, -0.01448079f, 0.19098534f, -0.47383100f, 
    -0.17290694f, 0.10908726f, -0.16078867f, -0.22443183f, -0.05013285f, -0.08221009f, -0.05912756f, -0.04773000f, 
    0.24148196f, 0.20905887f, 0.01066473f, 0.28219330f, -0.22527355f, -0.19654712f, -0.10259215f, 0.09827943f, 
    0.23065968f, -0.05294967f, 0.00744665f, 0.25651407f, 0.08729819f, 0.04862668f, -0.06870776f, 0.14544080f, 
    -0.01631250f, -0.04392253f, -0.05290626f, -0.12287227f, 0.09414886f, 0.23020321f, -0.17639250f, -0.00033313f, 
    -0.02206865f, 0.10101788f, -0.11432151f, -0.25718594f, -0.09149325f, 0.31790656f, -0.10361299f, -0.00023386f, 
    -0.13003446f, -0.11126713f, 0.12236264f, 0.23876002f, -0.08943388f, -0.28219548f, -0.36211032f, 0.15504920f, 
    0.05832307f, 0.10730363f, 0.07278047f, 0.10704608f, -0.26773474f, 0.08774716f, 0.09078337f, 0.39145681f, 
    -0.07064818f, 0.28030860f, 0.08315556f, 0.02065712f, 0.14210348f, 0.08805302f, 0.02581590f, 0.03486582f, 
    0.37523460f, 0.05643840f, -0.01997010f, 0.09267571f, 0.25860509f, -0.08237240f, 0.08088692f, -0.28675216f, 
    -0.06134625f, -0.12487946f, 0.32064748f, 0.10545671f, -0.16641729f, -0.08239970f, 0.07721929f, 0.09039328f, 
    -0.23923789f, -0.14867704f, 0.01753042f, 0.10287721f, -0.14380367f, -0.05975352f, -0.00322230f, 0.28148964f, 
    0.08195376f, -0.34531739f, -0.21542218f, -0.21368155f, 0.11082547f, -0.01560475f, 0.13779333f, -0.27579489f, 
    -0.06357452f, -0.02872133f, 0.01269098f, 0.06979754f, -0.05291918f, 0.06177121f, 0.15636587f, -0.25036904f, 
    -0.08275691f, 0.12734784f, 0.14919508f, 0.54731137f, 0.08888339f, 0.30658901f, 0.03369171f, 0.07367416f, 
    -0.15460660f, -0.05891613f, 0.02504382f, 0.22297083f, 0.16819194f, -0.35205501f, -0.04700714f, -0.02590610f, 
    0.05892424f, -0.02075920f, -0.18672684f, 0.04468793f, 0.05392101f, -0.38283706f, -0.20465870f, 0.18027098f, 
    0.12439314f, 0.16683124f, 0.07077714f, 0.16644756f, 0.03060199f, -0.00799953f, -0.20339862f, -0.08416383f, 
    -0.03096680f, 0.00730679f, 0.05148951f, 0.02728251f, -0.00097520f, -0.10778035f, -0.27139178f, -0.24571618f, 
    -0.15359506f, -0.10816284f, -0.04969381f, -0.06872769f, -0.03171084f, 0.08158316f, -0.08813652f, 0.07969414f, 
    0.27163085f, -0.08654086f, 0.08557903f, -0.20461747f, 0.24857432f, 0.24454166f, -0.11813921f, 0.10921980f, 
    0.01976022f, -0.15427803f, 0.14626202f, -0.15085059f, 0.09114946f, 0.04014111f, 0.00734797f, 0.00427309f, 
    -0.24514177f, 0.16080010f, 0.05047544f, -0.11384390f, -0.18474033f, 0.08950647f, 0.09442104f, 0.00374953f, 
    -0.15218149f, -0.14966083f, -0.04517967f, 0.46121073f, 0.15994856f, 0.31326693f, -0.07346855f, 0.01231988f, 
    -0.09321494f, 0.16272399f, -0.01902875f, 0.30752188f, 0.28990293f, -0.13519852f, -0.08799796f, -0.10176983f, 
    -0.09307566f, -0.05506597f, 0.14584529f, -0.02978644f, 0.05634262f, -0.23427340f, -0.08883561f, -0.30947545f, 
    -0.00763660f, 0.22621469f, 0.13226599f, -0.04824445f, 0.04445696f, 0.09102541f, 0.06771468f, 0.02031509f, 
    -0.18043989f, -0.00700133f, 0.09470350f, -0.01468139f, -0.30657533f, -0.17635304f, -0.00879137f, -0.18437108f, 
    -0.45974189f, 0.52652353f, -0.10743693f, -0.19250971f, -0.05247787f, -0.07121928f, -0.12455644f, 0.17694856f, 
    -0.05395873f, -0.06584398f, -0.04744288f, -0.02204145f, -0.06061740f, 0.02985932f, -0.04949300f, 0.03519176f, 
    -0.00575261f, -0.01228808f, -0.04999642f, -0.00982396f, -0.00137104f, -0.00112940f, 0.04412524f, 0.00918821f, 
    -0.01005517f, -0.06120513f, -0.06678262f, 0.01004195f, -0.04661621f, -0.01870890f, -0.02630662f, -0.06529613f, 
    0.04370866f, -0.04865646f, -0.03772779f, -0.01428464f, -0.05658668f, -0.02149883f, -0.03452999f, 0.02622168f, 
    0.04497271f, -0.02291972f, 0.00442493f, -0.05933524f, -0.02035266f, -0.04712465f, -0.02619106f, -0.06305394f, 
    -0.03669285f, 0.04464679f, -0.02190945f, 0.03951296f, 0.03955700f, -0.05048451f, -0.04968809f, 0.01248361f, 
    -0.03574847f, -0.03590051f, 0.04100142f, -0.04662009f, -0.02351666f, -0.01599197f, -0.02852957f, -0.03371797f, 
    -0.06383514f, 0.03551538f, -0.06093708f, 0.01737552f, 0.02881975f, -0.06434069f, 0.01236852f, -0.01333943f, 
    0.03290622f, 0.05440025f, -0.04240054f, 0.01783113f, 0.00239904f, -0.02636248f, -0.05248086f, 0.04428780f, 
    0.04474942f, -0.00116924f, 0.01203723f, 0.03942312f, -0.03990434f, 0.00701630f, -0.04644857f, 0.03456954f, 
    0.02353496f, -0.04066179f, 0.00530817f, -0.01827614f, 0.04819610f, 0.02750484f, -0.04565906f, 0.01753853f, 
    -0.01667266f, -0.03804892f, -0.00371166f, -0.03732184f, -0.03819754f, -0.03229724f, 0.03391515f, -0.00048180f, 
    -0.01017100f, 0.01826933f, 0.04496851f, -0.02639156f, 0.00141908f, 0.03810767f, 0.05152431f, -0.03374164f, 
    -0.01723489f, -0.03017190f, -0.00677065f, -0.03842491f, -0.02886217f, -0.03655350f, -0.06812499f, 0.03954104f, 
    -0.00699853f, -0.03086831f, -0.05423763f, -0.06286567f, -0.02432553f, -0.03756738f, 0.02096206f, 0.02697102f, 
    0.04802840f, 0.04659846f, 0.03777948f, -0.00922920f, -0.06723471f, -0.04862704f, -0.03487540f, 0.03497095f, 
    0.03439296f, 0.04418745f, -0.05220149f, -0.05049507f, -0.02869506f, -0.06173495f, 0.04727468f, 0.01164658f, 
    -0.03952232f, 0.00272674f, -0.01181848f, -0.01615456f, 0.00397445f, -0.01928094f, -0.02260812f, 0.01898144f, 
    0.05991425f, 0.04118227f, 0.03823572f, -0.01554947f, 0.03000839f, -0.05195288f, -0.06272697f, -0.02200017f, 
    0.00462723f, 0.01527049f, -0.05237157f, -0.01058797f, -0.02047916f, 0.00580554f, -0.02511857f, -0.05446776f, 
    -0.04510741f, -0.02922683f, -0.03002126f, -0.02924559f, -0.01927587f, -0.05081846f, -0.00590956f, -0.05672676f, 
    -0.05378333f, -0.06588569f, 0.04346803f, 0.00620100f, 0.04603561f, -0.02466110f, 0.03006396f, -0.00510342f, 
    -0.03814616f, -0.02942135f, -0.04003669f, -0.01203846f, 0.04996637f, -0.00996739f, -0.04715737f, 0.03514999f, 
    -0.04334031f, 0.04907180f, -0.00391688f, -0.01873503f, -0.03530727f, 0.02020078f, -0.03153397f, 0.02822682f, 
    0.04363465f, -0.01224046f, 0.00700708f, -0.04533816f, -0.03570259f, -0.02816769f, -0.00692614f, -0.06130751f, 
    -0.05787028f, -0.04238763f, 0.04034133f, 0.01632411f, 0.01745710f, 0.01010897f, 0.01176841f, -0.01550385f, 
    0.05570121f, 0.01422613f, 0.02541566f, -0.05474805f, 0.00917074f, -0.00929570f, -0.00349787f, -0.01632305f, 
    0.01627329f, 0.02318909f, 0.02352767f, -0.01131877f, 0.04358280f, -0.05733236f, -0.02416814f, -0.01732382f, 
    0.00569625f, -0.02963646f, -0.04073550f, -0.02014229f, -0.04983027f, -0.06006322f, -0.02349969f, -0.00157686f, 
    0.01761757f, -0.00416070f, 0.02308674f, 0.02846721f, -0.04713019f, -0.00845148f, 0.02711599f, -0.05770993f, 
    0.01320990f, -0.00266957f, -0.06239996f, 0.03490185f, -0.03903139f, -0.06797186f, 0.01724697f, -0.02363922f, 
    -0.06147723f, 0.01163743f, -0.01848114f, -0.01097019f, 0.01801868f, -0.01727130f, -0.01720988f, 0.03882675f, 
    -0.00031570f, -0.02206339f, 0.00981502f, 0.04665237f, 0.00480074f, -0.04621540f, 0.02306051f, -0.04066957f, 
    -0.06588890f, 0.04294521f, 0.04256757f, -0.02163345f, -0.02781099f, 0.04344932f, 0.03522252f, -0.02836963f, 
    -0.05952904f, -0.04011058f, 0.02832230f, 0.04267280f, -0.01525979f, -0.01854759f, -0.02200062f, 0.03420709f, 
    0.02120066f, 0.03430696f, -0.01197829f, 0.03050970f, -0.01960150f, -0.00350232f, -0.00466478f, 0.02272888f, 
    -0.91361147f, 0.07771086f, -0.21832851f, 0.11882298f, 0.01335166f, 0.18646006f, 0.23644252f, 0.01796121f, 
    0.27799618f, 0.34568074f, 0.05862174f, 0.08216406f, -0.03157517f, 0.14418361f, 0.11578435f, 0.07294319f, 
    0.12307781f, -0.26697358f, 0.18167318f, 0.13392682f, -0.24612370f, 0.15106313f, -0.25674504f, -0.22386150f, 
    0.09599876f, -0.09081817f, 0.01652160f, -0.05669431f, -0.38351750f, 0.44220525f, -0.05998359f, 0.13096090f, 
    -0.23195107f, -0.08552274f, 0.09248089f, -0.02718842f, -0.65912670f, 0.30430537f, 0.07231840f, 0.24073680f, 
    -0.01642590f, -0.10386808f, -0.15404364f, -0.06180198f, 0.18210983f, 0.05444714f, 0.06878560f, 0.12730695f, 
    0.13883200f, 0.00350398f, 0.03893289f, 0.09306785f, 0.11234903f, 0.05409558f, -0.21724005f, 0.07319764f, 
    -0.26198488f, -0.09718250f, 0.02778794f, -0.03336268f, -0.08344217f, 0.22839054f, 0.12158786f, 0.11263672f, 
    0.03810750f, -0.22341219f, -0.01665915f, -0.13911527f, 0.06851200f, 0.01080829f, 0.25064078f, -0.10515544f, 
    0.30000597f, -0.06033400f, 0.31068352f, -0.02471235f, 0.19342718f, -0.23813583f, -0.02457630f, 0.05075285f, 
    0.09440351f, -1.03440917f, -0.33459672f, -0.17861819f, 0.08654088f, -0.23186554f, 0.07611407f, -0.08335418f, 
    0.08451100f, 0.14656995f, -0.56275928f, -0.35651320f, 0.02879576f, 0.00480959f, 0.01917198f, -0.07219375f, 
    0.41112500f, 0.07022154f, -0.15714158f, -0.31902212f, 0.12486368f, 0.00257906f, 0.17680384f, -0.06457593f, 
    0.03167759f, -0.32872245f, 0.24013358f, -0.06557474f, 0.38199204f, 0.14832449f, -0.03974631f, 0.00054848f, 
    0.09581376f, 0.19618309f, 0.01317016f, -0.03673716f, -0.14851138f, 0.12996238f, 0.21263470f, -0.08849508f, 
    0.12088674f, 0.02479222f, 0.01799136f, 0.10065507f, 0.11888652f, -0.02200797f, -0.51304585f, -0.12360378f, 
    -0.03009400f, -0.06649767f, 0.05977937f, 0.07166322f, -0.14976314f, 0.02121089f, -0.07288051f, -0.25491971f, 
    0.14741926f, 0.24060002f, -0.10040307f, -0.03915523f, -0.09672558f, -0.35967264f, -0.08492488f, 0.12673149f, 
    0.02032988f, -0.14360145f, 0.13540524f, -0.07719494f, 0.00010398f, -0.16420904f, -0.03278492f, -0.21251629f, 
    0.34521300f, 0.02737667f, -0.02992145f, -0.15857852f, 0.04558860f, -0.03860171f, 0.05902531f, 0.25074968f, 
    0.11698016f, 0.11649467f, -0.12409841f, 0.00426522f, -0.27324519f, 0.01528264f, 0.01715226f, -0.02687116f, 
    0.03024440f, 0.04557327f, -0.06039635f, 0.13220955f, 0.15834928f, -0.10141753f, -0.03297821f, 0.03945655f, 
    0.09944899f, -0.06167240f, 0.06392886f, 0.10079354f, -0.36677587f, 0.07575624f, -0.17322554f, 0.08068658f, 
    0.08537116f, 0.06929798f, 0.16277598f, 0.00475743f, 0.03582808f, -1.06718314f, 0.17697497f, 0.47312272f, 
    0.14412092f, 0.11551557f, -0.05246057f, 0.06595022f, -0.20788297f, 0.02152661f, 0.42688733f, 0.23475504f, 
    0.05028637f, 0.13499340f, 0.04739483f, 0.00139614f, -0.31166291f, 0.08825279f, 0.19298092f, 0.10095792f, 
    -0.16496946f, -0.27340725f, -0.13790368f, 0.02084309f, 0.18660121f, 0.26367244f, 0.13197264f, -0.19572264f, 
    -0.19081858f, 0.05790216f, -0.06725330f, 0.08548775f, 0.02278881f, 0.00174633f, 0.10840584f, 0.13905868f, 
    0.05442717f, -0.59096110f, 0.11764245f, -0.05566809f, 0.22277157f, 0.05959221f, 0.13302672f, 0.03359929f, 
    -0.06314224f, -0.17561331f, -0.05647051f, 0.06973953f, 0.19794460f, -0.01169320f, 0.03601711f, 0.05105753f, 
    -0.27685085f, 0.04209109f, 0.12378974f, -0.11636252f, 0.26007059f, -0.33090785f, 0.21306717f, 0.00685842f, 
    0.08096293f, 0.11200919f, -0.04682284f, 0.11769307f, 0.08383127f, 0.06363358f, -0.18892938f, -0.13664848f, 
    0.11289141f, -0.03830877f, 0.25848573f, 0.00807037f, -0.10783435f, -0.09494535f, -0.05159840f, 0.11914972f, 
    0.01388494f, -0.00766140f, -0.00157414f, 0.15399173f, -0.06492583f, -0.11441005f, -0.09672011f, 0.03177234f, 
    0.25075793f, -0.03449856f, 0.03781808f, 0.15320276f, -0.05082010f, 0.04861927f, 0.35224694f, -0.00879461f, 
    0.11815340f, 0.18315692f, -0.16552520f, -0.04640972f, -0.07805005f, 0.01573847f, 0.08730346f, 0.12715897f, 
    -0.06614249f, -0.01716704f, -0.00055350f, 0.05466702f, 0.02390850f, 0.02939081f, 0.02895153f, -0.01763017f, 
    0.04386635f, -0.05443192f, -0.04360696f, 0.00845608f, -0.01627402f, -0.03459558f, -0.01013637f, 0.05317659f, 
    0.00000079f, -0.00464317f, -0.06458502f, -0.07379854f, 0.00479270f, -0.06737483f, -0.03003371f, -0.02318903f, 
    -0.03528950f, 0.00349377f, -0.01717695f, -0.04218478f, 0.04605922f, -0.03818575f, 0.01761080f, -0.05140880f, 
    0.01271034f, -0.04299614f, -0.05537688f, -0.00357793f, 0.00466943f, -0.02719623f, -0.01467577f, 0.00131451f, 
    -0.02455992f, 0.02641364f, -0.00557675f, 0.02739515f, -0.00047037f, -0.03666602f, 0.00655013f, -0.04536242f, 
    0.01937226f, -0.04861557f, 0.04782849f, -0.01554731f, -0.01270163f, 0.01004738f, -0.02034850f, -0.01519597f, 
    0.04443863f, 0.01331732f, 0.03708975f, -0.02551666f, -0.03706333f, 0.01163079f, -0.03810362f, -0.00043148f, 
    -0.04454869f, -0.04647522f, -0.02098286f, 0.01290217f, -0.02301979f, 0.05493936f, 0.04756354f, 0.01062607f, 
    0.01247022f, 0.03307879f, 0.01370013f, 0.03091160f, -0.03785293f, 0.05359141f, 0.00636738f, -0.05763699f, 
    0.02402256f, -0.07070410f, 0.01118523f, 0.05242719f, -0.01728735f, 0.02208325f, 0.04585229f, -0.04469412f, 
    0.04970272f, -0.02355754f, 0.03599320f, -0.04350091f, 0.05002799f, -0.03568843f, 0.03914012f, -0.00595657f, 
    -0.02549646f, -0.01173313f, -0.05487866f, -0.02511665f, -0.02493695f, 0.01699126f, -0.04929655f, 0.03633165f, 
    0.05869482f, -0.02321162f, 0.00988011f, -0.06835576f, 0.04720021f, -0.04964482f, -0.00655348f, -0.04764964f, 
    -0.04783781f, 0.03008824f, 0.04807051f, 0.03217866f, -0.02350841f, -0.02581520f, -0.00492575f, 0.02098465f, 
    -0.02441520f, 0.02366711f, 0.02471598f, -0.04911086f, 0.05190959f, 0.01768111f, -0.06493638f, -0.02387676f, 
    -0.03700401f, -0.05240367f, 0.03909109f, -0.06261286f, 0.04211220f, 0.01860229f, -0.04353233f, -0.02075754f, 
    0.00355207f, -0.03476047f, -0.04063869f, -0.02691661f, 0.02209735f, -0.01404211f, -0.05428242f, 0.00524755f, 
    -0.02569604f, 0.05747091f, 0.03699116f, -0.03154124f, -0.02630717f, 0.01646956f, -0.01895610f, 0.03719914f, 
    0.03070953f, -0.02563671f, -0.03938605f, -0.04581559f, 0.02907678f, -0.04348671f, 0.03355285f, -0.03694850f, 
    -0.04610398f, -0.06072328f, -0.02956752f, 0.05066236f, 0.06664664f, -0.01791528f, -0.04453408f, -0.05169973f, 
    -0.00354556f, 0.05178404f, -0.02728153f, -0.00884629f, 0.01169609f, -0.04379773f, 0.00318194f, -0.00574852f, 
    0.00824957f, -0.03242111f, 0.01946967f, -0.06759435f, 0.02108780f, -0.06148301f, -0.02016186f, -0.06223207f, 
    0.00227112f, 0.03173212f, -0.03296955f, 0.01645224f, -0.00047266f, 0.03080616f, -0.04887366f, 0.02991985f, 
    -0.00410134f, -0.05933797f, -0.00692553f, 0.04886124f, -0.00834203f, -0.02111634f, -0.06725849f, 0.04714092f, 
    0.00076474f, -0.06488059f, 0.05064939f, -0.03715535f, -0.00810122f, -0.04817093f, 0.02159236f, -0.02594294f, 
    0.00716443f, 0.00323246f, 0.01878945f, -0.01223962f, -0.06501997f, -0.00103472f, -0.05215961f, -0.00799892f, 
    0.00448126f, -0.04394172f, -0.02496523f, -0.03307201f, -0.02529419f, -0.05364139f, 0.05167476f, -0.06176689f, 
    0.05031788f, -0.03455599f, -0.06371459f, -0.02204762f, 0.04448684f, 0.02356728f, -0.01502093f, 0.00631930f, 
    -0.03474594f, -0.03498054f, 0.03125658f, -0.03140054f, -0.01334138f, -0.02399252f, 0.02244116f, 0.01059398f, 
    -0.03612600f, -0.00076507f, 0.02506282f, -0.02960563f, 0.00716165f, 0.03017702f, 0.00021481f, -0.05795809f, 
    -0.02113081f, -0.04012590f, -0.01160046f, 0.02104017f, 0.02329561f, -0.02230399f, -0.00318856f, -0.06625278f, 
    0.00469906f, 0.03114735f, 0.04841939f, 0.03972964f, 0.04628237f, 0.02186006f, -0.02639769f, -0.02953590f, 
    0.00980389f, 0.04295439f, 0.04351041f, -0.01934927f, -0.01269511f, 0.01813666f, 0.03271762f, -0.01307446f, 
    0.04587462f, -0.05437656f, -0.01259622f, 0.02468548f, -0.02191351f, 0.03091271f, -0.05083653f, 0.03344711f, 
    -0.01735759f, -0.00836277f, 0.02318913f, -0.03465654f, -0.05984274f, -0.01664628f, -0.06121784f, 0.00596396f, 
    -0.08843678f, 0.21799462f, 0.39583585f, -0.15005140f, -0.02984597f, -0.01017850f, 0.15624888f, 0.16433549f, 
    0.22570971f, 0.01571293f, 0.25313905f, -0.52571988f, 0.28093615f, 0.01516655f, 0.31049222f, -0.02201355f, 
    -0.10446364f, 0.16313423f, -0.09441253f, -0.14397313f, 0.28214356f, -0.14249243f, 0.04523620f, -0.18046968f, 
    -0.14140947f, 0.25734764f, 0.27968997f, -0.54566264f, -0.20630990f, -0.55478036f, 0.07806159f, 0.00762800f, 
    -0.05859033f, 0.02377411f, -0.01475565f, -0.02781668f, -0.29415548f, 0.25437877f, 0.22853561f, -0.04988985f, 
    0.12711565f, -0.20281491f, 0.02583196f, 0.06963936f, 0.11303378f, 0.00128150f, -0.42114520f, -0.07831682f, 
    -0.05664632f, -0.06399011f, -0.02116104f, 0.02156536f, -0.11794760f, 0.23463896f, -0.19253993f, -0.09221038f, 
    0.32411712f, -0.29712415f, 0.08113825f, -0.10413656f, -0.03165274f, -0.07160298f, -0.04827857f, -0.69241208f, 
    0.18435971f, -0.46289808f, 0.30737841f, 0.07475371f, 0.18739128f, 0.03917938f, -0.37795922f, -0.02260569f, 
    -0.36313099f, 0.06169778f, 0.12311001f, 0.03895212f, 0.03333582f, -0.42453802f, -0.05832050f, 0.11462607f, 
    0.08708583f, -0.06315822f, 0.11688160f, 0.40875179f, -0.16537350f, 0.07681260f, -0.10362627f, 0.07350357f, 
    -0.10180255f, -0.00802191f, 0.24705897f, 0.17612813f, -0.02489467f, -0.13188499f, -0.22618303f, -0.06063315f, 
    0.08602159f, 0.09004927f, 0.12144901f, -0.55075437f, 0.16814969f, -0.05963510f, 0.44442445f, 0.01870244f, 
    0.13808270f, 0.03452347f, -0.03435852f, 0.23493786f, 0.25936615f, 0.08063534f, 0.17921405f, 0.03034281f, 
    0.15075301f, 0.11402027f, -0.08181098f, 0.02712778f, -0.17189512f, 0.25018269f, -0.00531987f, -0.32391459f, 
    0.11540490f, 0.05222618f, 0.15386394f, 0.21643843f, 0.15867494f, -0.03504222f, -0.04761193f, 0.14894050f, 
    0.00902556f, 0.08617149f, -0.07183255f, 0.01050628f, 0.30133072f, 0.28972238f, 0.14336848f, -0.33939961f, 
    -0.08851898f, 0.09937184f, 0.01243017f, 0.02649077f, 0.19955969f, 0.14993438f, -0.12230542f, -0.03911064f, 
    -0.48589280f, -0.05044416f, -0.48809540f, 0.21695334f, 0.11862500f, 0.23691241f, 0.23255415f, -0.02162858f, 
    -0.02140195f, 0.28319675f, -0.07581852f, -0.37018675f, 0.13903306f, 0.03173731f, 0.01346472f, -0.01615454f, 
    -0.15170348f, -0.08834963f, -0.21757437f, -0.67982328f, -0.05680088f, -0.02749655f, 0.08871721f, -0.05698319f, 
    -0.18119784f, -0.09010943f, -0.10683843f, -0.04852977f, 0.19528386f, -0.44529107f, 0.20130983f, 0.07554060f, 
    0.11904626f, -0.03299015f, 0.05923040f, -0.34533510f, -0.09011640f, -0.17218792f, -0.16423376f, 0.04202507f, 
    0.25171593f, -0.01136540f, -0.18054220f, -0.11907289f, 0.01291095f, 0.16562232f, 0.20783511f, 0.46197319f, 
    -0.25202191f, -0.15253983f, 0.01214904f, 0.08173075f, 0.04954806f, 0.20710874f, 0.18642510f, -0.01617304f, 
    -0.08290865f, -0.19361660f, -0.08978043f, 0.03024782f, -0.04824373f, 0.09159916f, 0.25247094f, 0.26123089f, 
    0.19982411f, -0.24723968f, 0.05231811f, 0.13289037f, 0.16191247f, 0.23701800f, -0.11204337f, -0.00550835f, 
    0.08181717f, 0.25701064f, 0.25057274f, 0.03022300f, 0.18531927f, -0.11413401f, -0.04537719f, 0.01360795f, 
    0.04875745f, -0.14043148f, -0.07564535f, -0.03128642f, -0.16601734f, -0.12973480f, -0.06824079f, -0.17083251f, 
    -0.20401597f, -0.05448591f, 0.00195118f, -0.38296163f, -0.00886853f, -0.19100812f, -0.05507671f, 0.00173129f, 
    0.08782225f, 0.05261626f, 0.15305273f, -0.08448552f, -0.17378056f, -0.37042123f, 0.05790874f, 0.16230084f, 
    -0.05855740f, 0.02078142f, -0.22299756f, 0.04560871f, -0.28641549f, 0.43085155f, 0.30495062f, -0.06795088f, 
    -0.01330159f, -0.09082828f, -0.00136815f, 0.14315192f, -0.03417274f, -0.09996863f, -0.15428305f, -0.26808718f, 
    0.21080434f, -0.00502054f, 0.08670962f, -0.00407512f, 0.03487416f, 0.09742905f, 0.04738811f, 0.34340370f, 
    -0.32307136f, -0.01037756f, 0.04098660f, 0.14892766f, 0.18634883f, 0.02108497f, -0.05023802f, -0.52856195f, 
    0.10742363f, -0.28355706f, 0.04736193f, 0.07337986f, 0.15043710f, 0.10641909f, 0.18332145f, 0.11513547f, 
    -0.06231748f, -0.05468458f, -0.00902736f, -0.00836004f, -0.06214047f, -0.03937816f, 0.00699545f, 0.02743779f, 
    0.02976071f, -0.03097849f, -0.01650335f, 0.04798809f, -0.03104024f, -0.06521548f, -0.03065003f, 0.03090144f, 
    0.05014621f, -0.05760716f, 0.04958156f, 0.02328698f, -0.00728059f, -0.06336896f, -0.03240586f, -0.00756817f, 
    -0.06489500f, 0.02400466f, 0.04898939f, 0.04419003f, -0.00328089f, 0.04260035f, -0.04903067f, -0.02718385f, 
    0.01129262f, -0.05285819f, 0.03049197f, 0.01528642f, 0.00874515f, -0.03547270f, 0.04696516f, 0.00212632f, 
    0.03685274f, 0.03296992f, -0.01004279f, -0.04202712f, -0.01614055f, -0.06508173f, 0.03594255f, 0.04867484f, 
    -0.04793800f, 0.00702106f, -0.01111935f, -0.06055536f, -0.06123735f, 0.03928699f, 0.03931007f, -0.06596857f, 
    -0.01279773f, -0.00257566f, -0.04934497f, -0.05682493f, -0.05619593f, 0.03163666f, -0.05191713f, -0.02026534f, 
    -0.01039594f, -0.05044521f, -0.00665928f, -0.06419243f, -0.02214392f, -0.05961122f, 0.03285518f, 0.00918006f, 
    0.01673806f, 0.00960212f, 0.00723402f, -0.04620310f, -0.05172024f, 0.00431894f, -0.05261638f, -0.00083819f, 
    -0.02855685f, 0.03617450f, -0.04763372f, -0.02841091f, 0.02270966f, 0.04014888f, -0.02437575f, 0.02261980f, 
    0.03847736f, -0.05873658f, -0.06227315f, -0.04922826f, 0.01127863f, 0.01816346f, 0.05195013f, -0.03021179f, 
    0.01058817f, -0.00809126f, 0.01877803f, 0.02031733f, 0.03087259f, -0.04297844f, -0.01641170f, 0.00938963f, 
    -0.04436374f, 0.03865592f, -0.02416790f, -0.06153600f, -0.01197647f, 0.01982952f, -0.03571237f, -0.00685918f, 
    0.01925859f, 0.01096788f, 0.02340492f, 0.01105112f, -0.05542246f, -0.03004266f, -0.05959651f, -0.01118345f, 
    -0.03881044f, 0.03144815f, -0.02193210f, -0.01522671f, -0.05949247f, -0.02971521f, -0.04517162f, -0.03018305f, 
    -0.05701752f, -0.05860605f, 0.00360919f, 0.00075848f, 0.03264907f, 0.03065604f, -0.04243305f, -0.03588650f, 
    -0.06568352f, -0.00092209f, -0.04493049f, -0.00418250f, -0.02939752f, -0.03108133f, -0.00481238f, -0.02743851f, 
    0.03731599f, -0.02477542f, -0.02712705f, -0.05650377f, -0.05477716f, 0.01922261f, -0.01128593f, -0.06143975f, 
    0.03540733f, -0.05364757f, -0.02486139f, -0.04870859f, -0.00985738f, -0.03795908f, 0.00340947f, 0.02256683f, 
    0.02574692f, 0.03419911f, 0.04690003f, -0.01402975f, -0.04077229f, 0.01077245f, 0.01370271f, -0.01185966f, 
    -0.00092022f, 0.01651709f, 0.00514202f, -0.06242621f, 0.03448920f, -0.04095818f, 0.02851058f, -0.01668898f, 
    -0.03533858f, -0.02437869f, 0.02355838f, 0.00219943f, -0.01938793f, -0.03417085f, 0.01128891f, 0.00518219f, 
    0.02151699f, -0.04252179f, -0.04764849f, 0.04508092f, -0.03002464f, 0.03153116f, 0.01706276f, 0.03435310f, 
    0.01776922f, -0.00484626f, 0.02874519f, 0.02142058f, 0.01102352f, -0.05029037f, -0.01010710f, -0.00904310f, 
    0.02765697f, -0.04820076f, 0.03436133f, 0.00053980f, 0.01081698f, -0.05098995f, 0.03421896f, 0.05033609f, 
    0.00555988f, 0.05148791f, 0.03323915f, -0.01340827f, -0.01179867f, -0.00690188f, -0.06037639f, 0.01479313f, 
    -0.00662395f, 0.04680445f, 0.04171589f, -0.05016283f, 0.00673729f, 0.01445640f, 0.04127449f, -0.04024898f, 
    0.03694304f, 0.00740162f, -0.05377769f, 0.03763843f, 0.00185897f, -0.04486204f, -0.05399365f, 0.04896415f, 
    -0.05374805f, -0.04535761f, 0.02845636f, 0.00161266f, 0.03226927f, -0.01956023f, 0.04597719f, 0.03953873f, 
    0.01962929f, -0.04108950f, -0.00000784f, -0.00730035f, 0.03967392f, -0.00824641f, -0.02879442f, 0.00118054f, 
    0.04876088f, -0.02235739f, -0.05883380f, 0.04209539f, 0.04922710f, -0.00539857f, 0.05290598f, 0.00943228f, 
    -0.01242564f, 0.03337105f, -0.03940565f, -0.03440345f, -0.04444240f, 0.01423730f, 0.01052416f, 0.01509905f, 
    -0.05747108f, -0.03309890f, -0.01818760f, 0.04247747f, 0.03793480f, -0.05351140f, 0.00450771f, 0.03927038f, 
    -0.00666519f, 0.01302654f, -0.02345440f, 0.01632372f, -0.05072597f, -0.00389418f, -0.00031408f, -0.02768113f, 
    -0.01109839f, 0.01078786f, 0.00051456f, -0.01337988f, -0.00984217f, 0.01113921f, -0.05044127f, 0.00021924f, 
    -0.40165362f, 0.02909460f, -0.55905825f, 0.11248152f, -0.04768548f, 0.15521270f, 0.27013248f, -0.03501062f, 
    0.20251583f, 0.36868608f, 0.14541067f, 0.09720290f, -0.10098981f, -0.18241604f, 0.15958957f, -0.15237340f, 
    -0.09505855f, 0.25789288f, 0.07438298f, 0.18004194f, -0.29424298f, -0.10401944f, -0.17509100f, -0.11037966f, 
    0.03846940f, 0.08067244f, 0.12927848f, -0.05155047f, -0.51395738f, 0.14279728f, -0.06459890f, 0.17607370f, 
    -0.04619764f, 0.12453347f, 0.07411525f, -0.12145343f, -0.16031083f, 0.01350912f, -0.38013223f, -0.05107485f, 
    -0.04124133f, 0.02168031f, -0.09364769f, 0.07277618f, -0.03166831f, -0.03052773f, -0.15990072f, 0.27089837f, 
    -0.06964531f, -0.00623713f, 0.20714493f, 0.13818100f, 0.13530517f, 0.08121757f, 0.22233613f, 0.00350654f, 
    -0.21649952f, -0.06270393f, -0.06564619f, 0.10344765f, -0.17305736f, 0.01265210f, 0.20809667f, 0.15326050f, 
    -0.11336240f, 0.23784496f, -0.27255264f, 0.10896166f, -0.11441339f, -0.14194334f, 0.27248955f, -0.04371661f, 
    0.31330770f, -0.09176019f, 0.05557614f, 0.02229868f, -0.09892178f, 0.01784438f, 0.04298332f, -0.06526602f, 
    0.14340958f, -0.10275145f, 0.08536816f, -0.40421742f, -0.15785010f, 0.03372681f, 0.14370969f, -0.11754617f, 
    -0.23565240f, -0.17748404f, 0.02005407f, -0.53147703f, 0.04232942f, 0.02516103f, 0.19585407f, -0.02700854f, 
    -0.13238464f, 0.23079874f, 0.06757727f, 0.01355226f, -0.22862592f, -0.12605447f, -0.05426411f, -0.24012850f, 
    -0.18513164f, -0.03086488f, -0.09614313f, -0.04932764f, -0.08878867f, -0.00178889f, 0.01267408f, 0.05037329f, 
    0.23687981f, -0.03157753f, -0.02916987f, 0.25812486f, -0.06697194f, 0.36055931f, -0.12349549f, 0.25298083f, 
    -0.15859765f, 0.26187927f, -0.11210150f, 0.04083940f, 0.09178778f, 0.10476048f, 0.10372359f, -0.00918569f, 
    -0.16942045f, -0.14807720f, -0.15235433f, -0.21257684f, 0.04350550f, 0.10613707f, -0.06445363f, -0.22819208f, 
    0.00878834f, -0.14104475f, -0.08105014f, 0.13250424f, -0.01224312f, 0.06274782f, -0.11161736f, -0.14664520f, 
    -0.03184744f, -0.22398716f, -0.12971748f, 0.06334854f, -0.01539989f, 0.00728071f, -0.19149260f, 0.11254612f, 
    0.01186603f, 0.24484189f, 0.24834314f, -0.48186418f, -0.05602143f, -0.18836693f, 0.02659574f, -0.10276925f, 
    0.06051837f, 0.12141545f, -0.40230998f, -0.17993727f, -0.18213302f, 0.01876390f, 0.20856009f, 0.09220790f, 
    -0.05773266f, -0.00735573f, 0.11477893f, 0.25106212f, 0.06829851f, -0.15700944f, 0.15345576f, -0.04383015f, 
    0.15022133f, 0.04054768f, -0.17070568f, -0.17312640f, -0.20879480f, -0.11989008f, -0.12385587f, -0.06598718f, 
    0.09721095f, -0.02792087f, -0.11774658f, -0.07505929f, 0.05099827f, 0.04430566f, 0.17590933f, 0.03121532f, 
    -0.00284145f, 0.02862437f, -0.02936921f, 0.00876916f, -0.09671139f, 0.02013906f, 0.14068642f, 0.18491919f, 
    0.00086009f, -0.04136175f, -0.08015645f, -0.10435462f, -0.05860941f, 0.07407390f, -0.16640489f, 0.14887604f, 
    -0.10531541f, 0.02600999f, -0.04073513f, -0.05593266f, 0.07818136f, -0.08659011f, 0.08326761f, 0.03694160f, 
    0.30361828f, 0.29112160f, -0.12974428f, -0.09864306f, 0.06798297f, 0.11663226f, 0.19024570f, -0.24114214f, 
    0.07896320f, -0.16684751f, 0.16834380f, -0.09232157f, -0.05871398f, 0.04668457f, -0.06693432f, -0.06892866f, 
    0.05470539f, 0.08747457f, -0.25067532f, -0.09046058f, 0.30858183f, 0.08595277f, -0.19691139f, 0.15902629f, 
    -0.01904503f, 0.10484538f, 0.12313510f, 0.28803322f, -0.09412271f, -0.19813260f, 0.11843324f, 0.05474758f, 
    0.07767037f, -0.09283058f, -0.13208841f, -0.07706189f, 0.16896878f, 0.27339944f, 0.11233992f, 0.03178319f, 
    -0.03953496f, -0.08250567f, 0.06042013f, 0.05550165f, 0.10050166f, -0.35535482f, -0.25296733f, 0.01212472f, 
    -0.04792114f, 0.11142818f, 0.13139437f, 0.00867418f, 0.00778554f, 0.19948991f, 0.04299719f, 0.03813206f, 
    -0.06515506f, -0.07253207f, 0.12434036f, 0.03967495f, 0.10225096f, 0.15433794f, -0.08797573f, -0.11948304f, 
    0.01426554f, 0.04743854f, -0.10296799f, -0.15840931f, 0.10157293f, 0.15557432f, -0.09470736f, -0.00582229f, 
    -0.34161788f, 0.11173099f, 0.06212540f, 0.27266216f, -0.13421252f, 0.20889424f, 0.16933124f, 0.13553841f, 
    -0.03729685f, 0.21758732f, 0.26950043f, 0.13080807f, 0.19400553f, 0.01466822f, -0.11654179f, -0.15953149f, 
    0.22249980f, 0.19988880f, -0.16529925f, -0.12316161f, 0.36283708f, -0.28557792f, 0.07498701f, -0.06687323f, 
    -0.12363848f, -0.04702364f, 0.02808692f, -0.01576458f, -0.39512566f, -0.43943059f, 0.06288511f, 0.03943194f, 
    0.05709541f, -0.09157126f, 0.19073671f, -0.01476626f, -0.00698593f, -0.28052700f, 0.09939594f, -0.03682319f, 
    -0.04652429f, 0.21939066f, 0.15926993f, 0.11593393f, -0.08086569f, 0.23831527f, -0.22253078f, 0.24650113f, 
    -0.37216225f, -0.17837845f, -0.00043931f, 0.13369730f, -0.00049004f, -0.12060566f, -0.21499166f, 0.01057419f, 
    0.09515758f, 0.00324154f, -0.32071841f, 0.17510116f, -0.24771091f, -0.01873299f, 0.15272360f, 0.50215995f, 
    0.17777428f, 0.12281153f, -0.05818519f, -0.00388510f, -0.36920485f, 0.16232890f, 0.22306256f, -0.00027927f, 
    0.23741187f, -0.26189446f, -0.04275140f, 0.15231487f, -0.06279730f, 0.02171255f, 0.04524500f, -0.12025198f, 
    -0.05788189f, -0.10963740f, 0.14461833f, -0.07585638f, 0.03450103f, 0.13532318f, -0.06784472f, -0.07564983f, 
    0.07490537f, 0.16812135f, -0.07523791f, 0.01973625f, -0.17982064f, -0.07160516f, 0.13319461f, 0.19152486f, 
    0.14312939f, -0.04971511f, 0.10653140f, 0.17779794f, -0.03285483f, 0.02335560f, -0.14022847f, 0.01061094f, 
    -0.08550096f, 0.12643211f, 0.22015277f, 0.03645276f, -0.13975672f, 0.06242598f, 0.30016169f, 0.09196138f, 
    -0.13136749f, -0.26604858f, 0.06840966f, 0.00872675f, -0.15200508f, -0.25284165f, -0.01611449f, -0.12832463f, 
    0.09519489f, 0.18229617f, 0.02973611f, 0.03139405f, 0.10030448f, 0.15464871f, -0.43998086f, -0.28834093f, 
    -0.36448503f, 0.11340455f, 0.25007281f, 0.03345970f, 0.37288466f, -0.02509753f, 0.06619671f, -0.00534841f, 
    -0.09829958f, 0.15712261f, -0.26895693f, -0.20116498f, 0.08061602f, 0.07704081f, 0.01670386f, -0.08345766f, 
    0.30557278f, -0.04885827f, -0.07901441f, 0.15087572f, -0.05740622f, -0.24041742f, 0.04645674f, 0.03277970f, 
    -0.18036260f, -0.32747445f, 0.20167731f, 0.27007478f, 0.09123189f, -0.04851346f, 0.01907842f, 0.03594426f, 
    -0.00068850f, 0.10345592f, -0.09586373f, -0.24105987f, 0.04621532f, -0.08141897f, -0.05988821f, 0.05987310f, 
    -0.03622251f, 0.04214625f, 0.07909453f, -0.07314827f, -0.16765538f, -0.13588166f, 0.22394279f, 0.16949485f, 
    -0.02464704f, 0.31309059f, 0.07440697f, -0.15347101f, -0.07170427f, 0.09356378f, 0.13109499f, 0.04444547f, 
    0.01174996f, 0.01043182f, 0.09035574f, -0.06434107f, -0.18379901f, 0.00045641f, -0.28608212f, -0.02098546f, 
    -0.12897773f, -0.18998043f, 0.25909778f, 0.08289268f, 0.07345112f, 0.09131157f, 0.07234381f, -0.53594530f, 
    -0.04975352f, -0.47588405f, -0.05206197f, 0.08134882f, -0.06087844f, -0.09143480f, 0.08680706f, 0.10704414f, 
    0.40988350f, 0.11858106f, -0.11694778f, 0.13634327f, -0.13116406f, -0.03077249f, 0.16935292f, 0.13419861f, 
    -0.00822837f, 0.01132971f, -0.11949769f, 0.16262686f, 0.05904084f, 0.14324252f, 0.13277885f, 0.12758064f, 
    0.17761531f, 0.23071517f, 0.31235212f, 0.27612078f, -0.01683950f, -0.24612814f, -0.09264915f, 0.09833098f, 
    0.17982799f, -0.04385207f, 0.31689566f, -0.31923777f, -0.12154435f, -0.39369765f, -0.24775615f, 0.02752706f, 
    0.20438659f, 0.01459238f, -0.02701172f, -0.49919942f, -0.12523717f, -0.02434176f, 0.01083659f, 0.31416443f, 
    -0.10895701f, 0.12088650f, -0.14772099f, -0.01129712f, -0.13060287f, 0.16698028f, -0.27619505f, 0.14275722f, 
    -0.10557421f, 0.01066189f, -0.00375311f, -0.00631686f, 0.22155012f, 0.26425859f, 0.11669731f, 0.06470470f, 
    -0.05166129f, -0.05843033f, 0.15901998f, 0.03214039f, 0.07056738f, -0.11838602f, -0.19016297f, 0.07918283f, 
    0.16227512f, 0.13066372f, -0.21633053f, -0.17020936f, 0.12712836f, 0.04494908f, -0.02974856f, -0.05881210f, 
    0.17220660f, 0.16456437f, 0.07385492f, 0.35683638f, -0.08112032f, -0.01855591f, -0.00498651f, -0.05826352f, 
    -0.45505762f, 0.38740784f, -0.06949688f, -0.01890165f, -0.01948753f, 0.09666332f, 0.21661048f, 0.04994079f, 
    0.00641891f, -0.08369963f, 0.03943610f, -0.23423997f, 0.09921557f, -0.10888050f, -0.05496096f, 0.10161574f, 
    -0.12582123f, 0.05289292f, -0.06440873f, 0.15923257f, -0.02472307f, -0.05807722f, -0.20256481f, 0.11219261f, 
    -0.02860143f, 0.11048061f, -0.15673980f, 0.72175008f, 0.02288584f, -0.00234138f, -0.14417787f, -0.18979792f, 
    0.07463223f, -0.05010911f, -0.10959280f, -0.01033069f, 0.40115055f, 0.05790506f, 0.00304624f, -0.08726361f, 
    0.01743596f, 0.04479072f, -0.09446640f, -0.01696281f, 0.10033891f, -0.44646773f, 0.12761720f, -0.43485013f, 
    0.07368576f, 0.20295496f, 0.17821714f, -0.04883370f, -0.15921588f, -0.00070628f, -0.10086184f, 0.27297199f, 
    -0.09466034f, 0.10231572f, 0.09915044f, 0.03535244f, 0.18438660f, 0.03182765f, 0.09716379f, -0.17597631f, 
    -0.17130618f, -0.46645823f, 0.08752012f, -0.04935424f, -0.19522971f, -0.01899385f, -0.08659886f, -0.24107923f, 
    0.70160872f, 0.29155880f, -0.09390455f, 0.04135115f, 0.15153994f, 0.02933692f, -0.12568128f, 0.01265215f, 
    0.07159176f, 0.32221785f, 0.24681076f, 0.15313542f, -0.11558961f, -0.11045089f, -0.06524327f, 0.02569570f, 
    0.12259669f, 0.04250433f, -0.14433987f, -0.24491906f, 0.00082323f, 0.04990872f, -0.02861593f, 0.02312319f, 
    0.19457589f, 0.26663488f, 0.08673754f, -0.38607192f, 0.01783123f, -0.36680543f, 0.01010630f, 0.13791363f, 
    -0.00143389f, 0.03539827f, 0.12070525f, -0.25921255f, -0.13609380f, -0.39435452f, 0.04414001f, 0.01062296f, 
    0.01283178f, -0.06892483f, 0.15275048f, -0.10796162f, -0.09930374f, -0.10693906f, -0.01713263f, -0.21871011f, 
    0.06372729f, 0.05164963f, 0.06485415f, 0.00617177f, 0.08555778f, 0.04249359f, 0.24069911f, 0.24606502f, 
    -0.19206753f, -0.04057991f, 0.06082178f, 0.16858949f, 0.11927765f, 0.05950859f, 0.12693824f, -0.07599127f, 
    0.02477424f, -0.00162370f, 0.10325941f, 0.12073777f, -0.01753109f, -0.02561371f, 0.00706549f, -0.03708917f, 
    -0.24395169f, -0.06521558f, -0.30212331f, -0.20495644f, 0.08207650f, -0.08759712f, -0.23648481f, 0.17023399f, 
    0.02253446f, 0.21114847f, -0.33973312f, -0.02497107f, 0.01755382f, -0.11710040f, -0.15920413f, -0.09474953f, 
    -0.02016169f, 0.05366021f, -0.25365269f, -0.24604614f, 0.02721567f, 0.02760871f, -0.22881733f, -0.02574621f, 
    0.08444609f, 0.05265572f, 0.04036618f, 0.08591535f, 0.10866944f, -0.16426024f, 0.17792107f, 0.01495109f, 
    0.14894515f, 0.15630478f, 0.01531466f, -0.06735640f, -0.58733970f, -0.43776816f, 0.00189033f, -0.11912911f, 
    0.09138189f, -0.15282290f, 0.10882068f, -0.10794788f, -0.28029099f, 0.35482690f, -0.04460872f, 0.06193225f, 
    -0.11676606f, 0.09985115f, -0.05475433f, -0.14148866f, 0.01382466f, 0.03646028f, -0.05046940f, 0.10529170f, 
    -0.02704190f, 0.08007287f, -0.00618420f, 0.09132727f, -0.24749088f, 0.12496968f, 0.06207106f, -0.21466284f, 
    -0.28739807f, -0.14786504f, 0.11968973f, -0.07752063f, -0.08970842f, 0.29162768f, -0.14976341f, -0.00645987f, 
    0.36316335f, -0.11915632f, 0.19602285f, -0.03662286f, -0.00226088f, -0.18257940f, 0.00189331f, 0.04001477f, 
    -0.01131613f, -0.33960578f, 0.14177591f, 0.26776066f, 0.10327121f, -0.18371020f, -0.03563929f, -0.01792388f, 
    0.07043362f, 0.15434127f, -0.02158653f, -0.21008223f, -0.17624010f, 0.08654763f, 0.16389555f, 0.10457895f, 
    -0.02881015f, -0.21008570f, -0.15209341f, 0.24368522f, -0.21551687f, -0.11646169f, 0.36493814f, 0.13810942f, 
    0.16056879f, 0.05446656f, 0.23406811f, 0.19954537f, 0.22670171f, -0.11358321f, 0.37565461f, 0.05792917f, 
    0.19983061f, 0.02711699f, 0.13587812f, 0.17366381f, -0.04996387f, -0.04215201f, -0.23937993f, 0.17111433f, 
    0.08720736f, -0.02635344f, 0.21086079f, 0.13589579f, -0.00062327f, 0.03136923f, 0.27204835f, -0.52121389f, 
    0.05216283f, -0.15406017f, 0.05568705f, 0.04853888f, -0.17831978f, 0.13937733f, 0.02091718f, -0.03634621f, 
    0.16513543f, -0.07165990f, -0.01201832f, 0.01413127f, -0.03905889f, 0.07469270f, 0.02308563f, 0.03114979f, 
    0.00467881f, 0.01447516f, -0.01397148f, -0.03919167f, -0.03449838f, -0.05364274f, 0.01873031f, -0.00738618f, 
    0.02248554f, -0.04983271f, 0.00080473f, 0.02542219f, -0.04075715f, -0.02407899f, -0.06002413f, -0.03068592f, 
    0.00459276f, -0.02952380f, 0.01660032f, -0.04240065f, -0.03301115f, -0.02735847f, 0.04791321f, -0.02636105f, 
    -0.08023398f, 0.04157929f, -0.06277963f, 0.01042898f, -0.01321207f, -0.01778724f, 0.00775647f, -0.01468130f, 
    0.05354986f, 0.07870625f, -0.00637100f, 0.07587881f, -0.01294967f, 0.03458643f, -0.02063560f, 0.00351961f, 
    0.00909182f, 0.01558717f, -0.03070476f, -0.01672865f, -0.06753043f, -0.03110436f, -0.02805728f, -0.05861593f, 
    0.00766666f, -0.05230317f, 0.01277097f, 0.03978765f, -0.01346860f, -0.02714401f, -0.07404469f, 0.04018148f, 
    0.00824705f, 0.04542636f, 0.03843804f, -0.01414087f, 0.01618414f, -0.02472177f, -0.02219001f, -0.02720015f, 
    -0.04085625f, 0.00385529f, -0.07555477f, -0.01228026f, -0.02089092f, -0.04124465f, -0.03994728f, -0.00406725f, 
    -0.03264312f, 0.01686508f, 0.03750949f, 0.03573690f, 0.02920504f, -0.05780552f, -0.02827682f, -0.04845934f, 
    -0.00484106f, 0.04630537f, -0.01199077f, -0.02936465f, -0.03338962f, 0.07632898f, -0.04123693f, -0.08274110f, 
    0.04190728f, 0.05320406f, 0.02278311f, 0.06246193f, -0.04402986f, -0.03012952f, 0.04735460f, 0.03163677f, 
    -0.00914097f, -0.01092584f, -0.00497188f, 0.10317898f, 0.01364376f, -0.00726172f, 0.01573971f, -0.05135174f, 
    -0.07799458f, 0.04380857f, 0.07092307f, 0.06300330f, -0.08391795f, -0.09107076f, 0.02805159f, -0.04385739f, 
    -0.01107821f, -0.03513689f, -0.01402717f, 0.01943764f, -0.07107561f, 0.03350084f, 0.04823317f, -0.05123361f, 
    0.04131065f, -0.01280637f, 0.02623476f, -0.05442577f, -0.04448697f, 0.04046862f, 0.04657695f, -0.02479702f, 
    -0.00108034f, 0.00838318f, 0.01438009f, 0.03051907f, -0.01852227f, -0.04901372f, -0.00130293f, -0.10476349f, 
    0.02785799f, -0.03434543f, 0.02997642f, -0.02948299f, 0.00105690f, -0.06196042f, 0.03669307f, -0.03353560f, 
    0.02626940f, 0.04391449f, -0.01508819f, -0.07639018f, 0.01625651f, -0.00369496f, 0.07174650f, -0.06217216f, 
    -0.01868682f, -0.10434336f, -0.06064104f, -0.00107726f, 0.05629821f, 0.01021518f, -0.06995355f, -0.03872417f, 
    0.03852274f, -0.03698289f, 0.03860729f, 0.01885279f, -0.06422510f, 0.01444107f, 0.07490417f, -0.08922335f, 
    0.00800021f, -0.02589425f, -0.01082391f, -0.03588089f, -0.05423010f, 0.01676807f, -0.00616106f, -0.00588156f, 
    -0.00163645f, -0.04779184f, -0.00323038f, -0.02980659f, 0.01444445f, -0.01588534f, 0.05789815f, -0.05036756f, 
    0.07641122f, -0.07197124f, 0.01284433f, -0.02715602f, 0.06059872f, -0.09166345f, 0.00293839f, -0.00029461f, 
    -0.03087632f, 0.04469022f, -0.03282624f, -0.04127946f, -0.01606568f, -0.01968888f, -0.09753051f, 0.01932143f, 
    -0.01321742f, 0.01285859f, -0.00917413f, -0.02292306f, 0.04759658f, -0.02634857f, -0.06932027f, -0.02292136f, 
    -0.00718195f, 0.00076975f, -0.01568484f, -0.01886483f, -0.03072201f, -0.03139722f, -0.05368505f, -0.05436931f, 
    0.03335446f, -0.00166558f, -0.06665525f, -0.02180337f, -0.07861342f, -0.03885621f, -0.02518380f, 0.01465483f, 
    0.01701424f, 0.01529896f, 0.01596770f, -0.01850718f, 0.00603848f, -0.02037808f, 0.06644356f, -0.06356933f, 
    -0.01668813f, 0.00027153f, -0.12626445f, -0.07875463f, -0.05292087f, -0.01230815f, -0.04631441f, 0.00214179f, 
    0.04067265f, 0.00368432f, -0.04291899f, -0.01244750f, -0.02962447f, 0.02761340f, 0.02288924f, -0.05668548f, 
    0.04556734f, -0.00217503f, -0.02378620f, -0.03099975f, 0.01971534f, -0.04305101f, 0.01806994f, 0.02303499f, 
    -0.04401947f, -0.03163318f, 0.00286918f, 0.04582696f, -0.01929183f, 0.01971715f, 0.00491366f, -0.01222787f, 
    -0.06933125f, -0.05508259f, -0.00128100f, 0.00685728f, 0.04483735f, -0.04306462f, -0.02707125f, -0.00624998f, 
    0.05055586f, -0.05741087f, 0.00726716f, -0.04031871f, 0.04593847f, -0.02101885f, 0.05021555f, -0.03194293f, 
    0.03246694f, 0.06891222f, -0.06221247f, 0.00325345f, -0.01440804f, -0.02509164f, 0.04743474f, -0.02919454f, 
    0.02925950f, 0.01523059f, 0.03129059f, 0.03147456f, -0.06188027f, 0.04787028f, -0.05446405f, -0.01803724f, 
    0.05508790f, -0.04294860f, -0.02932452f, -0.06038540f, 0.00197127f, 0.00681189f, 0.02459687f, 0.02713255f, 
    0.02427032f, -0.01802011f, -0.00994425f, -0.02838224f, -0.04067677f, -0.04858150f, -0.04811545f, 0.00705935f, 
    0.03976196f, 0.03002013f, -0.05995164f, 0.04833030f, -0.04396360f, -0.03981306f, -0.02794287f, 0.05075611f, 
    -0.01411853f, -0.02834177f, 0.01941245f, 0.03105275f, -0.03495570f, 0.02569195f, 0.02662555f, -0.03073606f, 
    -0.06006376f, 0.02393816f, -0.06234682f, 0.01566215f, 0.00114726f, -0.06659917f, 0.00522860f, -0.03756949f, 
    -0.05312396f, 0.02932700f, -0.02785021f, 0.02924407f, -0.00457156f, -0.05960706f, 0.01224734f, 0.02143412f, 
    0.03196590f, -0.05459214f, 0.04655704f, 0.02913431f, -0.05045735f, -0.03460611f, -0.00764262f, 0.01610008f, 
    -0.01012770f, -0.01810191f, -0.04885514f, 0.02213452f, 0.03518941f, 0.01539502f, -0.02380922f, -0.00026357f, 
    -0.06138886f, -0.01005961f, 0.05126252f, -0.00324890f, -0.03969852f, 0.00142713f, -0.04801204f, 0.03026082f, 
    0.04517342f, 0.00104253f, -0.03683575f, 0.02741319f, 0.00776497f, 0.02790194f, -0.00907568f, -0.03424537f, 
    0.00602149f, -0.00793377f, -0.03382985f, -0.05065921f, 0.02318620f, -0.03784017f, -0.04181112f, -0.01586539f, 
    0.01615935f, -0.01282033f, -0.01254470f, 0.04623932f, -0.01942358f, -0.01311269f, 0.03083113f, 0.04182978f, 
    0.00282776f, -0.02222056f, -0.01083418f, 0.00061033f, 0.05082464f, 0.03400205f, 0.00058443f, -0.01574790f, 
    -0.05423007f, 0.01324513f, -0.01608334f, 0.02593696f, -0.02958103f, -0.02007202f, 0.04205801f, -0.05300872f, 
    0.02205146f, -0.01163866f, 0.04658435f, -0.00361805f, 0.03374197f, 0.01872762f, 0.01610327f, -0.06265294f, 
    -0.04079775f, -0.05624133f, 0.00102557f, -0.00206805f, -0.03924381f, -0.03179959f, 0.05453961f, 0.01515984f, 
    -0.06267963f, -0.02411774f, 0.05447489f, -0.01557104f, -0.05505336f, 0.04782715f, 0.04430148f, -0.00105970f, 
    -0.03052519f, -0.01806825f, -0.00282118f, 0.04381473f, -0.01458797f, 0.01878307f, 0.00519058f, -0.01918110f, 
    0.00840541f, -0.01064854f, 0.03951342f, 0.03409977f, 0.00682253f, 0.03476361f, 0.05211092f, 0.03360077f, 
    0.02322447f, 0.03914109f, -0.04289623f, -0.03807586f, -0.01588531f, 0.01324688f, -0.06065783f, -0.02067225f, 
    -0.05534758f, 0.03400832f, 0.00118912f, -0.05706028f, -0.04929941f, 0.02153355f, -0.00694570f, -0.01255413f, 
    -0.03479259f, 0.01092846f, -0.05312690f, -0.05310523f, -0.01631759f, 0.01235460f, -0.05404606f, 0.01827563f, 
    0.03573019f, -0.04423126f, 0.04698114f, 0.00465736f, -0.02860465f, -0.02234441f, -0.05411376f, 0.03140403f, 
    0.04474693f, -0.03546628f, -0.05747277f, -0.02325821f, -0.04489619f, 0.00730578f, 0.01403666f, 0.04498271f, 
    0.02003386f, -0.01507718f, -0.00794303f, -0.02714111f, -0.02015169f, 0.04500081f, -0.04625335f, 0.04038426f, 
    -0.05649957f, 0.04091809f, -0.03176672f, -0.05117989f, -0.05990076f, -0.00983068f, -0.01939750f, -0.01615861f, 
    0.02947754f, -0.03275735f, -0.01580478f, 0.01732062f, 0.01207648f, 0.04041174f, 0.01517716f, 0.02422633f, 
    0.00020085f, -0.03079666f, 0.00900404f, -0.03679105f, -0.04735138f, -0.01869022f, -0.03953801f, -0.05302064f, 
    0.00192464f, -0.04931068f, 0.00554050f, 0.00862715f, 0.00517485f, 0.03797260f, 0.04504540f, 0.02960297f, 
    0.03508488f, 0.04492219f, -0.06519455f, 0.04139611f, -0.01321750f, 0.02495458f, 0.01831242f, -0.02979759f, 
    -0.02819793f, 0.01299389f, 0.04008434f, -0.06200577f, 0.01672736f, -0.02725535f, -0.01897682f, -0.05557008f, 
    -0.04045363f, 0.00523713f, -0.02400488f, -0.01622307f, -0.01549788f, 0.01172438f, 0.04754210f, 0.02561126f, 
    0.04117965f, 0.02199880f, -0.06323326f, 0.02063017f, -0.06926159f, -0.00180413f, 0.03144271f, 0.04159056f, 
    -0.03028488f, -0.04309659f, 0.00426234f, -0.03735828f, 0.01713475f, -0.02181762f, -0.05413532f, 0.05044221f, 
    -0.01070130f, -0.00492838f, -0.05700999f, -0.05255416f, -0.02474394f, 0.01660961f, 0.02155320f, 0.02493816f, 
    0.02916359f, -0.01329084f, 0.02381832f, 0.05279889f, 0.01607640f, -0.05839896f, -0.00275521f, 0.00827933f, 
    -0.04741726f, 0.02216593f, 0.03206288f, 0.00532177f, -0.06461716f, -0.05349639f, -0.01201995f, -0.06547068f, 
    -0.05989378f, -0.05028009f, 0.00623291f, -0.02664935f, 0.02762172f, 0.03629395f, -0.04105868f, 0.00725818f, 
    -0.01498850f, 0.02377360f, 0.02933245f, -0.00868333f, 0.02689360f, -0.05849136f, 0.02110780f, -0.01374771f, 
    -0.03309382f, -0.04669685f, -0.00060358f, 0.03109038f, -0.00906736f, -0.01507069f, -0.00927614f, 0.03411843f, 
    0.03520904f, -0.06014964f, -0.04489531f, -0.03492630f, -0.00439382f, 0.02314309f, 0.03286885f, 0.03379059f, 
    -0.01928776f, 0.02088290f, -0.02541039f, 0.02213407f, 0.01142794f, -0.03701968f, 0.01086930f, -0.02786616f, 
    0.03178833f, -0.01407468f, -0.02192412f, 0.02664767f, -0.01788927f, -0.00362031f, -0.05939635f, -0.01302270f, 
    -0.02783754f, -0.06788472f, 0.02365354f, 0.03733589f, 0.03950400f, 0.01356887f, -0.02977560f, -0.02831341f, 
    0.00100376f, 0.04398754f, 0.00816632f, 0.04195206f, 0.05000882f, -0.01166058f, 0.01046968f, -0.03439711f, 
    0.02986891f, -0.04806374f, 0.02426499f, -0.02224095f, 0.00717474f, -0.04226029f, -0.04812194f, -0.02558110f, 
    -0.04929573f, -0.02758126f, -0.06626365f, -0.02092581f, -0.03529978f, 0.01837374f, -0.01706064f, 0.01233623f, 
    -0.05131090f, 0.00871501f, 0.05076744f, -0.04000160f, 0.04445899f, -0.04215299f, -0.02027519f, -0.03571748f, 
    0.01464868f, -0.02503090f, -0.03643298f, -0.04214491f, 0.00020200f, -0.05178238f, 0.04423131f, 0.02717066f, 
    0.02550293f, 0.03672627f, 0.03206622f, 0.01281091f, 0.00607402f, -0.01861278f, -0.04762160f, -0.04868984f, 
    -0.00105602f, 0.00561923f, -0.03246496f, 0.00925559f, 0.03775379f, 0.00635243f, -0.04786031f, 0.00812901f, 
    -0.00910319f, 0.03369899f, -0.01129953f, -0.05584395f, -0.00303277f, -0.01269959f, 0.01693816f, -0.06406497f, 
    0.04657001f, -0.03080061f, 0.02462366f, -0.04877822f, -0.04657727f, -0.06278084f, -0.06512835f, -0.00529887f, 
    -0.01951081f, 0.02808777f, 0.04941904f, -0.01241364f, -0.01614281f, 0.00868717f, -0.06350441f, -0.06731983f, 
    -0.01301922f, -0.01321836f, 0.03078482f, -0.05365265f, 0.00392724f, -0.02600662f, -0.04346172f, -0.00886479f, 
    -0.06314798f, 0.00605517f, 0.01773522f, 0.00163748f, -0.05905300f, -0.01949970f, 0.00311474f, -0.04483020f, 
    0.01312552f, -0.02295016f, -0.00850235f, -0.01108694f, -0.04581980f, 0.03107244f, -0.00512866f, 0.01461382f, 
    -0.04564565f, 0.03457011f, 0.01786265f, 0.03464134f, -0.01844758f, 0.03150876f, 0.02899364f, 0.04078297f, 
    -0.06707606f, -0.05771717f, 0.01743689f, -0.00104997f, -0.02438743f, 0.00756291f, 0.02799673f, -0.01091638f, 
    -0.05181932f, -0.06150039f, -0.01416561f, 0.04000605f, 0.01970561f, 0.00563837f, -0.03266509f, -0.02210425f, 
    0.01594416f, -0.00851139f, -0.04156408f, 0.04272028f, 0.01359264f, 0.00901423f, -0.00437267f, -0.01408783f, 
    -0.04005147f, -0.06019846f, -0.02495451f, 0.02397776f, 0.01594269f, 0.00408680f, 0.01169395f, -0.03360675f, 
    -0.02248008f, -0.04019805f, 0.00187457f, -0.06610480f, 0.00423810f, -0.03683527f, -0.01851166f, -0.01662267f, 
    0.03934925f, 0.00699800f, -0.03748776f, -0.01997347f, 0.04931812f, -0.01006638f, -0.05525159f, 0.04550547f, 
    0.02079209f, -0.04623395f, -0.00098019f, -0.06198843f, -0.02781806f, -0.04071356f, -0.04655429f, -0.03167146f, 
    0.02787384f, -0.00526208f, -0.00088220f, -0.04532657f, -0.02527924f, 0.03067126f, 0.01181356f, -0.04972571f, 
    -0.02283728f, 0.02361133f, -0.00864734f, 0.04202373f, 0.03063387f, 0.04352576f, 0.03927263f, -0.05454726f, 
    0.00021110f, -0.00967307f, 0.05323660f, -0.04878319f, -0.05720900f, 0.00879948f, 0.01664655f, -0.04430488f, 
    0.03979347f, 0.00259724f, -0.01890392f, -0.01671284f, -0.00899650f, -0.05642616f, -0.05128787f, -0.02436581f, 
    0.02327044f, -0.03745238f, -0.02551988f, 0.01548267f, 0.00441587f, -0.03851039f, 0.04652325f, -0.06359483f, 
    0.03822747f, 0.03815910f, -0.04649903f, 0.02412630f, -0.01002072f, 0.05068545f, 0.01491897f, 0.00443249f, 
    0.00306842f, 0.01524882f, -0.02717454f, -0.01009136f, -0.02126765f, -0.06468954f, 0.04781258f, 0.00222813f, 
    0.03020516f, 0.01073482f, 0.01964290f, -0.05926067f, -0.03757316f, 0.02669524f, 0.00435914f, 0.01737825f, 
    0.03940199f, 0.02225679f, 0.02137542f, -0.00683334f, 0.00917715f, 0.00814224f, 0.02779951f, -0.04669819f, 
    -0.04144006f, -0.01253888f, 0.03467783f, -0.06559427f, -0.06097958f, 0.02489880f, -0.03131813f, -0.05691457f, 
    -0.06056245f, 0.04478694f, 0.01657633f, 0.00603972f, 0.00799905f, 0.04624020f, -0.00960080f, 0.04897557f, 
    -0.02543222f, -0.05113499f, 0.04095256f, 0.02642955f, -0.00450658f, 0.04135485f, -0.04981596f, 0.00455581f, 
    -0.02084862f, 0.01275661f, 0.01275695f, -0.05657409f, -0.04813996f, 0.01840395f, 0.03980211f, 0.03815968f, 
    -0.00287389f, -0.04305281f, 0.01880494f, -0.05773515f, 0.00998701f, 0.03181219f, 0.01178753f, -0.05653077f, 
    -0.03516955f, 0.00860050f, 0.01392081f, -0.04503093f, 0.00152419f, 0.05642644f, 0.04102044f, -0.03475314f, 
    0.01850472f, 0.02393241f, -0.03316411f, -0.00089716f, -0.03472708f, -0.04614736f, -0.02130910f, 0.01709585f, 
    0.02020838f, 0.04967239f, -0.03987385f, -0.03840953f, 0.02399870f, -0.02161811f, -0.02563378f, 0.04524190f, 
    0.02688426f, -0.01776593f, 0.00130046f, -0.01945402f, 0.00332415f, -0.05522036f, 0.03455960f, -0.04112673f, 
    -0.05795520f, -0.01539166f, 0.00425383f, -0.06845794f, -0.04521472f, 0.04594004f, 0.03107494f, -0.03917804f, 
    -0.06428520f, -0.03911869f, -0.03358376f, 0.03025636f, 0.03093345f, -0.03187805f, -0.02946899f, 0.03895940f, 
    0.05149488f, -0.00942800f, -0.04169751f, 0.04962463f, 0.04303150f, 0.00634949f, 0.00934867f, -0.05461350f, 
    -0.05372553f, 0.04216214f, 0.03217116f, 0.02527467f, 0.03193679f, 0.04300338f, -0.05905436f, 0.05515077f, 
    0.04739038f, -0.01075637f, -0.05457247f, -0.07031990f, 0.05000452f, 0.04143548f, -0.04961347f, -0.00867728f, 
    0.01884931f, -0.03005805f, -0.02145653f, 0.03073645f, 0.03738464f, 0.01729559f, 0.03350366f, -0.03023194f, 
    -0.06340672f, 0.01872195f, 0.04438453f, 0.03825344f, -0.05154788f, -0.04989797f, 0.04286920f, -0.05683050f, 
    -0.06578778f, 0.03980017f, -0.05087522f, -0.07284997f, 0.04892721f, -0.02813311f, -0.03256011f, -0.00283529f, 
    -0.02657770f, -0.03032413f, -0.00688887f, -0.05190898f, 0.00433862f, -0.03824654f, 0.04986015f, -0.04272759f, 
    -0.03987258f, 0.04530605f, -0.01669008f, -0.02181259f, 0.01455899f, 0.02404647f, -0.01882387f, 0.02607083f, 
    0.04383668f, -0.04181634f, 0.03330509f, 0.02384475f, 0.01389463f, -0.05220581f, -0.02760800f, -0.00771945f, 
    0.01372302f, -0.01612524f, -0.02302643f, 0.04033056f, 0.01372552f, -0.03295647f, 0.02404104f, -0.04269386f, 
    -0.01267959f, -0.05999481f, -0.02963709f, 0.00739328f, 0.01686341f, 0.04636731f, 0.02213985f, 0.04623105f, 
    -0.04478088f, 0.01729255f, 0.02784149f, -0.01693110f, 0.04316049f, 0.01754618f, 0.03304091f, -0.03656469f, 
    -0.05938924f, -0.02654437f, 0.01028893f, 0.03924746f, 0.04209803f, -0.01688450f, -0.06061643f, 0.03275736f, 
    -0.06390928f, -0.02491702f, 0.04095903f, -0.03994240f, -0.06046122f, 0.04293792f, -0.03539213f, -0.04306203f, 
    -0.00788039f, -0.01198373f, 0.02496675f, 0.01747815f, 0.00902987f, -0.01819445f, 0.03452541f, -0.04567175f, 
    -0.03364187f, -0.01699486f, -0.00904564f, 0.00591304f, -0.06384484f, -0.02996915f, -0.02444050f, -0.02241303f, 
    0.04717724f, 0.01033969f, -0.04937587f, -0.03063764f, -0.00616700f, 0.04801071f, -0.05130926f, -0.04048176f, 
    0.02483677f, -0.02483134f, -0.03243976f, -0.06188901f, 0.02249382f, -0.03601070f, -0.01823826f, 0.00037886f, 
    0.01793148f, -0.00044792f, -0.02036683f, -0.02392422f, -0.06123829f, -0.05085106f, -0.05733174f, 0.02753635f, 
    0.01080449f, 0.04046087f, -0.02293879f, 0.00155558f, 0.02630499f, -0.04529926f, 0.03099757f, 0.03819338f, 
    -0.03150523f, -0.00678023f, -0.03277250f, -0.00438447f, -0.03962237f, -0.02071908f, 0.01764947f, 0.01987281f, 
    -0.03699509f, -0.06187457f, -0.00505482f, -0.04056669f, 0.02661059f, -0.02453611f, -0.06086910f, -0.01336757f, 
    0.00498283f, 0.04533583f, 0.02600827f, 0.01183372f, 0.03922167f, 0.03247891f, -0.04869049f, 0.03610194f, 
    0.04213220f, 0.04379537f, -0.06485014f, -0.01741396f, -0.04445192f, 0.03054012f, 0.02852627f, -0.00384192f, 
    -0.02828435f, -0.06417914f, -0.02252263f, -0.04347555f, -0.01309762f, -0.01325885f, 0.02268196f, 0.03081591f, 
    0.04423023f, 0.00983721f, -0.06073016f, 0.02696555f, 0.03048495f, 0.01010304f, 0.02765949f, -0.01975639f, 
    -0.05632288f, -0.06036863f, 0.02066194f, 0.03919602f, -0.01273367f, -0.02536587f, 0.03310169f, -0.03355042f, 
    0.01137459f, 0.01295692f, -0.05289214f, 0.04124957f, 0.01811580f, -0.03443677f, -0.05743005f, -0.03054800f, 
    -0.06444697f, -0.00971892f, 0.03637465f, 0.02122485f, 0.01892677f, 0.05207597f, -0.04362807f, 0.01429419f, 
    -0.02304453f, 0.04002571f, -0.04267279f, -0.01211011f, -0.00064117f, -0.01495546f, 0.01171178f, 0.02121939f, 
    0.04110517f, 0.02563178f, -0.02291355f, -0.00550879f, -0.02005733f, -0.05441848f, -0.02186685f, -0.00683358f, 
    -0.02360167f, -0.05930144f, -0.06212128f, 0.01946671f, 0.04664600f, 0.01992696f, 0.00147961f, -0.03278027f, 
    -0.01522511f, -0.00206186f, 0.01256423f, -0.05125710f, 0.00060827f, -0.01409884f, -0.06161165f, -0.03271252f, 
    -0.06461184f, 0.02805008f, 0.00562357f, -0.00062370f, -0.05281030f, -0.04539729f, -0.00154915f, 0.01035368f, 
    -0.05805729f, 0.03958507f, 0.04666316f, -0.02139292f, -0.04107548f, -0.04311918f, 0.00414738f, 0.02080487f, 
    0.04141935f, 0.03318448f, 0.01588343f, 0.00894049f, -0.03650382f, -0.02809909f, -0.01283601f, 0.00145382f, 
    -0.04734560f, 0.04935871f, 0.00637108f, -0.01480139f, -0.05990231f, -0.00832766f, -0.02446515f, -0.01576484f, 
    0.00420537f, -0.04759689f, 0.00219919f, -0.02215919f, -0.03551648f, 0.02266915f, 0.04325829f, -0.04431820f, 
    0.02615099f, -0.05840834f, -0.06479459f, 0.01948959f, 0.01932959f, -0.06604914f, 0.00288349f, -0.03752219f, 
    0.00943400f, -0.01295326f, 0.02939346f, 0.03028514f, 0.01087530f, 0.02951609f, -0.00030997f, -0.05184167f, 
    0.04055048f, -0.04517497f, 0.01701823f, 0.00093013f, -0.04206544f, -0.06165820f, -0.02390450f, 0.02556357f, 
    -0.05808949f, -0.06395637f, -0.00304365f, 0.00160982f, -0.03279393f, 0.00778536f, -0.02345686f, 0.02598141f, 
    -0.00340669f, 0.04667962f, 0.03437961f, -0.06594235f, 0.03715187f, -0.05699174f, 0.03129064f, 0.03316690f, 
    0.00050752f, -0.00145715f, 0.02848485f, -0.00455719f, -0.04088929f, 0.02559278f, 0.04284082f, -0.02117670f, 
    -0.00317599f, 0.02586136f, 0.00221060f, -0.06857979f, -0.01296877f, -0.07310033f, 0.00439473f, -0.05431762f, 
    -0.02763814f, 0.04233927f, 0.03385217f, -0.06363703f, 0.04925830f, -0.00423688f, 0.04563984f, 0.04687293f, 
    -0.04521854f, 0.00275654f, 0.03095335f, -0.01317961f, -0.00272312f, -0.04747393f, -0.05152786f, -0.02107951f, 
    -0.01050879f, -0.05790881f, 0.04034475f, -0.01183868f, 0.02793374f, 0.04663144f, -0.00192042f, 0.02824438f, 
    -0.05435110f, -0.00387472f, 0.02239161f, -0.02752241f, -0.02729489f, 0.04649306f, -0.05269077f, -0.02420713f, 
    -0.03614229f, -0.05030159f, -0.00225734f, -0.05489352f, -0.01926855f, 0.00455501f, -0.00305424f, -0.04580303f, 
    0.00208459f, -0.02975720f, 0.01008954f, 0.03262469f, 0.02765549f, 0.00678424f, -0.05231072f, 0.02932731f, 
    -0.06123327f, 0.01168507f, -0.02662534f, -0.03068319f, -0.04164797f, -0.03576577f, 0.04564207f, 0.00446804f, 
    0.00827336f, -0.02866938f, -0.02301872f, -0.01644243f, -0.02118173f, -0.06648039f, -0.06958839f, -0.04602183f, 
    -0.05315237f, 0.01177046f, 0.04369710f, 0.00016514f, 0.02323402f, -0.01913697f, -0.00785714f, -0.02292515f, 
    0.01232525f, 0.04182282f, 0.03975971f, 0.00669237f, -0.05651383f, -0.00330372f, 0.01047015f, 0.04720021f, 
    -0.00895249f, -0.02971358f, -0.03105067f, 0.00442627f, -0.06387231f, 0.03315615f, -0.01350144f, -0.04282700f, 
    -0.06352489f, -0.05563841f, -0.02959896f, -0.00922879f, -0.01131614f, 0.00710672f, -0.00463418f, 0.01240953f, 
    -0.04592898f, -0.06050206f, 0.05524194f, -0.04289948f, 0.04257504f, 0.04431572f, 0.04471726f, 0.03887388f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.14858432f, -0.02840170f, -0.12964004f, -0.00618950f, -0.04602852f, -0.13851874f, -0.10535815f, 0.03990958f, 
    -0.13290401f, 0.03649540f, 0.02324476f, 0.03247390f, 0.15206301f, -0.02112829f, 0.15837461f, 0.12056939f, 
    -0.04894972f, -0.03601146f, 0.12397808f, 0.01270430f, 0.23145661f, -0.00702599f, 0.20467746f, 0.01797959f, 
    0.19636865f, 0.06343529f, 0.11846747f, -0.03997686f, 0.04870157f, -0.04498633f, 0.01535175f, 0.03962208f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.24061948f, -0.13438074f, -0.31744897f, -0.13819066f, 0.05064387f, 0.56142396f, -0.22166054f, 0.06995162f, 
    -0.28562197f, 0.10133077f, -0.03024461f, -0.29526228f, -0.86839044f, -0.01320106f, -0.19499519f, -0.00774514f, 
    0.14108124f, -0.13222891f, -0.86706549f, 0.00663559f, 0.18498464f, 0.00487343f, 0.47971523f, -0.15941793f, 
    0.53352618f, 0.17354973f, 0.13306779f, -0.14188829f, 0.13514763f, -0.09821609f, -0.02425773f, -0.15233552f, 
    0.99673122f, -0.09336917f, 0.43359998f, 0.02819955f, -0.48243493f, 0.38645500f, 0.00039531f, 0.10914526f, 
    -0.29465890f, -0.29180190f, 0.02473903f, -0.36583811f, -0.17673782f, -0.05598827f, -0.11666172f, -0.39835668f, 
    0.13689846f, 0.16506678f, 0.26818290f, -0.03909465f, -0.08874005f, 0.07415259f, 0.21293619f, 0.16243303f, 
    -0.28691962f, -0.37491187f, 0.43152025f, 0.01051909f, -0.13185047f, -0.14524090f, 0.05789542f, 0.11344271f, 
    -0.38647917f, 0.12088445f, -0.70341438f, -0.05479369f, -0.30769449f, 0.67357880f, -0.33095807f, 0.13679816f, 
    0.30508974f, 0.41411409f, -0.10351833f, 0.58043498f, -0.21845086f, 0.12573694f, 0.13782865f, -0.07859223f, 
    0.10048968f, 0.09442573f, 0.12565832f, -0.04785337f, -0.48587564f, -0.11115389f, -0.48933381f, -0.00911093f, 
    0.31983480f, -0.63546079f, -0.25043842f, 0.07126816f, 0.06407119f, -0.09347739f, 0.10314743f, 0.16578402f, 
    -0.90152293f, -0.13821723f, 0.67641902f, -0.11946042f, 0.66718274f, 0.33036473f, -0.41434237f, -0.09176252f, 
    -0.37525612f, -0.45814186f, 0.06270491f, 0.21403044f, -0.05571745f, 0.15039220f, -0.54486382f, 0.33932796f, 
    0.10731103f, 0.12073760f, 0.12701681f, -0.01104015f, 0.25229716f, -0.11335235f, -0.51598853f, 0.01398879f, 
    0.16495010f, -0.09198566f, -0.13339470f, -0.14798497f, 0.12412969f, 0.16910088f, -0.09859969f, -0.14518674f, 
    -0.17919642f, 0.09556706f, -0.43159482f, 0.04970911f, -0.02382603f, -0.17391399f, 0.45747274f, 0.03439965f, 
    0.11459745f, -0.48091009f, -0.11305942f, 0.12222672f, 0.15789360f, -0.12900355f, -0.25019839f, 0.43286389f, 
    0.13946591f, 0.02058129f, 0.34992233f, -0.10888249f, 0.17807081f, -0.06884143f, 0.47561216f, 0.13264105f, 
    -0.07131560f, 0.03812659f, -0.77357721f, 0.02690333f, 0.08532637f, 0.08586461f, 0.16570750f, 0.02744257f, 
    0.00333459f, -0.02592657f, 0.31528127f, 0.10733065f, -0.64106715f, -0.35399249f, 0.29328454f, -0.04478840f, 
    -0.81029892f, 0.29458350f, 0.07103649f, -0.56567490f, -0.01076389f, -0.07458806f, 0.39040738f, -0.42047414f, 
    -0.09087537f, -0.09806102f, -0.14589415f, 0.12993120f, -0.25071543f, 0.02139166f, 0.63091999f, 0.05774651f, 
    -0.54209596f, 0.38535044f, -0.07811336f, 0.12458539f, 0.15274593f, 0.04100686f, 0.13107790f, 0.09504928f, 
    -0.63437074f, -0.11843883f, -0.62966979f, 0.07532437f, 0.08209271f, -0.09779412f, -0.42341030f, 0.12121361f, 
    -0.34939623f, -0.31208843f, 0.00587518f, -0.00441810f, 0.73010480f, 0.13350791f, 0.53700966f, 0.21394069f, 
    -0.12835422f, 0.16330104f, -0.75769764f, 0.04090965f, 0.16011415f, 0.03102385f, -0.09969407f, 0.07722870f, 
    -0.60387355f, -0.17252895f, 0.24908602f, -0.03077587f, -0.17278089f, 0.15462168f, -0.08150025f, 0.07483041f, 
    -0.17992187f, 0.00120577f, 0.03692664f, -0.14174297f, 0.05062149f, -0.27571714f, 0.70306671f, -0.12881090f, 
    0.93810165f, -0.23490766f, -0.06647386f, 0.14297999f, -0.46799529f, 0.07700806f, -0.31066069f, -0.06897546f, 
    -0.02350051f, -0.09241188f, -0.23191172f, 0.07812690f, -0.20736760f, 0.12513773f, -0.34966320f, -0.05725940f, 
    -0.58822513f, 0.30886731f, -0.27052245f, 0.08932003f, 0.05827839f, -0.13931909f, -0.16235779f, -0.00823088f, 
    0.38547766f, 0.00679776f, -0.09040821f, -0.01889781f, 0.85452563f, -0.58777755f, 0.34295335f, -0.13336499f, 
    0.04981686f, 0.40647623f, -0.06336728f, -0.32529449f, 0.06652325f, -0.13755666f, -0.28531620f, -0.51074046f, 
    0.08223743f, 0.02887438f, 0.46144900f, -0.14093207f, -0.59271133f, -0.02699878f, -0.11277373f, -0.15236834f, 
    -0.56160522f, -0.29721808f, 0.14753024f, 0.13006407f, -0.13139644f, -0.11185615f, -0.04796139f, 0.02535696f, 
    -0.54727268f, 0.02280521f, -0.09747471f, 0.15218422f, -0.36654526f, -0.46796981f, 0.03528210f, 0.15819634f, 
    0.60354024f, -0.40267721f, -0.02723223f, -0.27014476f, -0.34196827f, -0.06386607f, 0.57026684f, 0.20104313f, 
    0.12618868f, -0.09597568f, 0.31142774f, -0.07403877f, -0.16199283f, -0.06879204f, -0.39458892f, -0.10277461f, 
    0.40130782f, 0.12898017f, 0.78542745f, 0.12413695f, -0.10999664f, -0.00056347f, 0.05249053f, -0.13112043f, 
    0.39407095f, -0.06577160f, 0.07046901f, 0.05927588f, -0.41453731f, -0.59706986f, -0.05019284f, 0.00919207f, 
    -0.62881547f, 0.23439351f, 0.09090798f, 0.61551017f, -0.21794952f, -0.06874938f, -0.15394826f, -0.28246599f, 
    0.10617285f, 0.13168339f, 0.27455300f, -0.14370787f, 0.84766638f, 0.10580366f, -0.71710914f, 0.07190198f, 
    0.32815570f, -0.14748286f, -0.20670371f, 0.10211632f, 0.13613510f, -0.16947238f, -0.08245978f, -0.13528931f, 
    -0.18446493f, 0.09879255f, -0.34320134f, -0.16190365f, 0.44016927f, -0.30826440f, -0.78915274f, 0.13880673f, 
    0.24214876f, 0.24584815f, -0.12117836f, 0.31818452f, 0.39052206f, 0.10804520f, -0.38171029f, 0.57702237f, 
    0.06170645f, -0.05273828f, -0.25870931f, -0.00175310f, -0.53583145f, 0.05364269f, -0.42266992f, -0.06740077f, 
    -0.19906567f, 0.66217232f, -0.45497793f, -0.07102928f, 0.07348643f, -0.05864666f, -0.12588342f, -0.03432431f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02327798f, -0.00403021f, -0.05857413f, -0.12072576f, -0.06101948f, 0.28994837f, 0.17127055f, -0.41887373f, 
    -0.09572942f, 0.01624606f, 0.10292725f, 0.15578085f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
