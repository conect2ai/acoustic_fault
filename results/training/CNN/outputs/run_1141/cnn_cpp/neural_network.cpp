#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.01443372f, -0.77270204f, -0.28627944f, 0.51508743f, -0.31534302f, -0.01762505f, 0.08937719f, -0.07452007f, 
    -0.15894680f, 0.02682564f, -0.31270525f, -0.33837837f, -0.20510212f, -0.20667030f, 0.27390030f, 0.20541672f, 
    0.30046684f, 0.27618280f, 0.06956786f, -0.03659287f, -0.34706575f, -0.16209462f, -0.26413411f, -0.40685523f, 
    -0.54816645f, 0.09688435f, -0.15799423f, 0.23287562f, 0.25989404f, 0.35233912f, 0.28301802f, -0.11242438f, 
    -0.37828797f, -0.27509007f, 0.02447346f, 0.16601914f, -0.02274476f, -0.03369283f, -0.13216154f, 0.47902593f, 
    -0.09813678f, -0.03274452f, -0.22858804f, -0.05373105f, 0.30794129f, -0.27183411f, 0.26157841f, -0.09658249f, 
    0.14748685f, -0.01005722f, 0.39914361f, 0.36546892f, -0.00009438f, -0.05635005f, -0.40667087f, -0.42306814f, 
    0.07346612f, 0.43754661f, 0.22296841f, -0.05988950f, 0.15234819f, -0.25969604f, -0.19546211f, -0.29451969f, 
    -0.02125209f, 0.20992033f, 0.29466876f, -0.24605149f, -0.10968354f, -0.25180253f, -0.27047956f, -0.09698845f, 
    -0.46350685f, -0.22905348f, -0.56811965f, 0.78351510f, 0.11298934f, -0.19523296f, 0.39154917f, 0.21684496f, 
    -0.33678201f, 0.15126316f, -0.19589961f, -0.00492545f, 0.47582495f, 0.10612939f, 0.10328415f, -0.15036543f, 
    -0.30406713f, -0.32376271f, -0.05225691f, -0.19970414f, 0.19384310f, 0.20113558f, -0.19969712f, -0.12242368f, 
    0.08612290f, 0.11254490f, 0.09547847f, -0.24469367f, -1.19704998f, 0.94719285f, -0.03411756f, -1.07854414f, 
    0.07695390f, 0.51618689f, 0.44665426f, 0.11847947f, -0.26003832f, -0.12943324f, -0.23993486f, -0.07026399f, 
    -0.23829123f, -0.40032843f, 0.33928150f, 0.00173464f, -0.17744291f, -0.13634792f, 0.05257823f, -0.07797345f, 
    0.00848914f, 0.08054175f, -0.07303479f, -0.10245723f, -0.18461609f, 0.09871174f, -1.04867494f, 0.29447761f, 
    0.27282375f, 0.07821578f, 0.43652332f, -0.30673099f, -0.58043480f, -0.33471620f, -0.14644597f, 0.21176040f, 
    -0.46699134f, -0.31719702f, -0.28981107f, 0.44040236f, -0.56283110f, -0.12026994f, 0.21331765f, 0.10080317f, 
    0.31855789f, 0.10677076f, -0.16182640f, -0.21144314f, -0.17681102f, 0.16403641f, -0.89931911f, -0.64330429f, 
    -0.70589763f, -0.57922113f, -0.21463126f, 0.75719845f, 0.40025502f, 0.27429309f, 0.32215396f, 0.27071664f, 
    0.38245514f, 0.08604762f, -0.05563517f, 0.41459459f, -0.26381639f, -0.37318489f, 0.29803187f, -0.10161096f, 
    -0.24890752f, -0.26667243f, -0.10923307f, -0.09740290f, 0.22080350f, 0.24741685f, -0.08043675f, -0.75742817f, 
    0.10018811f, 0.14294946f, 0.07108388f, -0.11216153f, 0.09871889f, -0.12361461f, -0.34828386f, -0.10059680f, 
    -0.08439335f, 0.16331823f, 0.10101939f, 0.02977630f, 0.06235007f, 0.12066464f, -0.02263679f, -0.55565989f, 
    -0.11125310f, 0.17014059f, -0.26134342f, 0.26462650f, 0.24679993f, 0.34576598f, 0.37891498f, 0.06378449f, 
    -1.10704315f, -0.04661391f, 0.21945582f, 0.40446845f, 0.67276603f, 0.09185705f, 0.44423106f, 0.40778732f, 
    0.25135431f, -0.22082041f, -0.20734312f, -0.26846009f, 0.33159038f, 0.47288802f, -0.19297202f, 0.13770126f, 
    -0.16157261f, -0.27978635f, -0.15729277f, 0.07423913f, 0.08493401f, -0.14392973f, -0.08169615f, 0.18025577f, 
    -0.07943062f, -0.83779299f, -0.46807581f, -0.54429549f, -0.59688020f, -0.15520312f, 0.34830546f, -0.25234130f, 
    -0.52936798f, -0.36021730f, 0.44329047f, -0.27531570f, -0.20105940f, 0.14756685f, 0.32995924f, -0.30603707f, 
    -0.09909907f, -0.36252287f, -0.25922474f, -0.02920851f, -0.39236516f, -0.19517846f, 0.19575310f, -0.02933853f, 
    -0.18375805f, -0.02713998f, -0.00948644f, 0.05052426f, 0.03922149f, 0.27195853f, -0.03631949f, 0.13415320f, 
    0.02635337f, -0.31170279f, -0.02246498f, 0.05968344f, 0.12722296f, 0.18897404f, -0.28336826f, -0.34874824f, 
    0.54390657f, 0.02550967f, -0.22527152f, 0.06963070f, 0.08875234f, 0.20232852f, 0.09817330f, 0.01620210f, 
    0.00526204f, 0.21288374f, -0.04034299f, 0.98895526f, -0.42786354f, -0.61845338f, -0.19457205f, 0.16083339f, 
    0.43330884f, 0.42953894f, 0.10861710f, -0.16738924f, -0.06325524f, -0.25001088f, 0.19374971f, -0.15648496f, 
    -0.25560448f, 0.01852739f, -0.23248453f, -0.24502569f, 0.37267593f, -0.08000798f, -0.01756002f, 0.10142875f, 
    -0.21558529f, -0.08373525f, 0.23899448f, 0.13438520f, -0.88169569f, -0.41637209f, -0.37104461f, -0.45696503f, 
    -0.23068447f, 0.58233505f, 0.58230072f, -0.73117632f, -0.54733986f, 0.07123255f, -0.07790515f, -0.01855973f, 
    -0.35536695f, -0.27380708f, -0.35460669f, -0.08229227f, -0.26058656f, 0.06764714f, 0.34289104f, -0.11525645f, 
    0.04001501f, -0.04541149f, -0.14892283f, -0.10018674f, -0.04940470f, 0.05008325f, -0.85073817f, -0.59104675f, 
    0.52733719f, 0.59146255f, -0.15880653f, 0.41204894f, -0.37458795f, -0.24681167f, -0.33163908f, -0.26390904f, 
    0.66596001f, -0.20344616f, -0.38079149f, -0.06534398f, -0.13495934f, -0.07676647f, 0.12160543f, 0.32024744f, 
    0.27371314f, 0.18498738f, -0.30608484f, -0.30050087f, 0.24623214f, -0.13707215f, -0.66783035f, 0.05002002f, 
    0.08440811f, -0.74843740f, -1.05243397f, 0.41383749f, -0.17202304f, -0.01948030f, 0.49343786f, 0.40572771f, 
    -0.28374776f, -0.30682531f, 0.57719803f, -0.68093795f, -0.21709257f, 0.22271235f, 0.03360583f, -0.01852395f, 
    -0.25462240f, -0.09261731f, 0.04622551f, 0.21611559f, -0.21943305f, -0.19347931f, 0.74822384f, 0.23506665f, 
    -0.25261483f, -0.39748704f, -0.35288146f, 0.20874318f, -0.79310715f, -0.57218713f, 0.30501148f, 0.47690943f, 
    -0.19098437f, 0.47729325f, -0.03438666f, 0.74064851f, -0.15828612f, 0.08003018f, -0.18586296f, -0.17938235f, 
    0.02183141f, -0.06424221f, -0.45961958f, -0.23875655f, 0.02909010f, 0.24223903f, -0.12297813f, 0.46247789f, 
    -0.61690366f, -0.17649542f, 0.36877838f, 0.75033623f, 0.35746175f, -0.34354568f, -0.75460732f, -0.59000403f, 
    0.18588942f, 0.24499251f, 0.05702025f, 0.18454562f, -0.49469891f, 0.41623554f, 0.29887173f, -0.06994960f, 
    -0.22661038f, 0.35294127f, -0.08765983f, 0.18048847f, 0.07592063f, -0.08569396f, 0.08733214f, 0.11746953f, 
    -0.05574511f, 0.91135663f, -0.58674884f, -0.84448618f, -0.42372605f, -0.74205482f, 0.25827512f, 0.32055816f, 
    0.29315531f, 0.00955928f, -0.16283232f, -0.04268141f, 0.69874793f, 0.33638889f, -0.34485570f, -0.39347756f, 
    -0.19767769f, -0.01150341f, 0.23906566f, -0.12784439f, 0.06360399f, 0.35990980f, -0.14999880f, -0.15982291f, 
    -0.36623627f, -0.43411028f, -1.16781592f, 0.02903461f, 0.63615024f, -0.45625928f, 0.00594882f, -0.55516070f, 
    -0.39140329f, -0.25322267f, 0.45971718f, 0.30371007f, -0.22011042f, -0.31829339f, -0.07856179f, 0.59630746f, 
    -0.35306481f, 0.25684246f, -0.10980447f, -0.35851333f, -0.20439686f, -0.03223180f, 0.03730275f, -0.13348021f, 
    -0.37841755f, -0.42486659f, -0.52975541f, 0.46533802f, -0.09562817f, -0.24547322f, -0.08450142f, 0.07496420f, 
    -0.09497642f, 0.13941047f, -0.57507676f, -0.32669473f, 0.43590206f, 0.19207379f, -0.25537160f, -0.10292197f, 
    0.15468921f, -0.09485457f, -0.06595735f, 0.26689017f, -0.10684401f, -0.08721448f, -0.39582196f, -0.31506056f, 
    -0.31392562f, -0.13058731f, -0.05352450f, -0.21096499f, -0.92433846f, -0.32399988f, -0.32303247f, -0.25739777f, 
    -0.18581758f, 0.10858971f, -0.02134605f, 0.39831671f, 0.46160418f, 0.79868925f, -0.13696209f, 0.03589832f, 
    0.09230254f, 0.16813031f, -0.32533380f, -0.17062424f, -0.06808809f, 0.14317107f, -0.02511172f, 0.40142179f, 
    0.01294152f, -0.02554540f, 0.21632347f, -0.05947909f, -0.24488170f, 1.00383604f, 0.98654580f, -0.10698272f, 
    -0.22069354f, -0.44977784f, -0.07171030f, 0.14173794f, -0.24669649f, -0.39158723f, -0.56090087f, 0.02189623f, 
    0.37090856f, -0.19151914f, 0.02883396f, -0.17576444f, 0.17035753f, -0.15055078f, -0.02192273f, 0.01812186f, 
    -0.06175594f, -0.07558012f, 0.31378955f, 0.06873881f, -0.17905366f, 0.34134567f, 0.31717476f, 0.41386646f, 
    -0.16617116f, -0.50083447f, 0.19395578f, 0.16716865f, 0.31772915f, 0.24192230f, -0.36812320f, -0.22763750f, 
    0.27891958f, 0.24185000f, -0.27055079f, 0.06086546f, -0.29929718f, 0.16535369f, 0.19305448f, -0.24253440f, 
    -0.03880319f, 0.09364686f, 0.26140845f, -0.10415355f, -0.24090236f, 0.25231758f, 0.10750370f, 0.09971731f, 
    -0.32045454f, -0.37293938f, -0.47148171f, -0.18453442f, -0.09652781f, -0.65534109f, -0.63495302f, -0.61002833f, 
    -0.79271638f, 0.38006452f, 0.06149110f, -0.01049582f, 0.11535317f, -0.29746154f, -0.21484901f, -0.26027802f, 
    -0.59060597f, -0.31861478f, -0.29409525f, -0.40607643f, 0.00478330f, -0.13097699f, -0.20980076f, -0.35770044f, 
    -0.53183430f, -0.45461029f, -0.13569286f, -0.60539412f, -0.49490595f, 0.06912904f, 0.28047463f, -0.44081503f, 
    -0.40979800f, 0.14642410f, -0.07522457f, -0.13016474f, -0.44020626f, -0.39155445f, -0.41457763f, 0.05165587f, 
    0.06589056f, -0.20286652f, 0.02665749f, -0.15430744f, -0.24109247f, -0.13705613f, 0.04329999f, -0.24254730f, 
    -0.04778289f, 0.57613403f, -0.02363927f, -0.23172438f, 0.29417795f, 0.53845662f, 0.19089498f, 0.60993695f, 
    -0.42865419f, -0.54832762f, -0.48287711f, -0.15917510f, 0.07832575f, -0.03429811f, -0.16140729f, 0.10082805f, 
    0.07145172f, -0.17501482f, -0.01384757f, 0.27926478f, 0.28809097f, 0.13804202f, 0.07418483f, -0.18094879f, 
    -0.30901915f, -0.52689147f, 0.58031291f, -0.17213966f, -0.33835018f, -0.00475910f, 0.15459102f, 0.11415803f, 
    0.34438115f, 0.33068448f, 0.18450139f, -0.23594156f, -0.19503455f, 0.29556078f, -0.01535382f, 0.04797632f, 
    -0.22985579f, -0.20348278f, -0.02513200f, 0.11413282f, -0.07297537f, 0.16126947f, -0.03467821f, 0.18564832f, 
    -0.15081576f, -0.23096153f, 0.28571707f, -0.40543637f, 0.31184500f, -0.04124148f, -0.66722804f, -0.51207334f, 
    0.44260836f, 0.21195923f, 0.14671339f, 0.06862094f, -0.15523332f, -0.17917740f, 0.29055855f, 0.19339959f, 
    0.00057838f, -0.12698835f, -0.03540550f, -0.39322925f, -0.35899636f, -0.59943694f, -0.42823011f, 0.01160210f, 
    0.40772721f, 0.41946390f, -0.13132338f, -0.24256065f, 0.55118489f, -0.58098483f, -0.31495973f, -0.47874993f, 
    0.43895584f, 0.39251834f, -0.05004217f, 0.07526720f, -0.04524594f, 0.03634379f, 0.16943686f, -0.32119825f, 
    0.05724914f, 0.12920395f, -0.03268521f, -0.01573741f, -0.09625690f, 0.19087189f, -0.11523210f, -0.14152911f, 
    -0.03229994f, -0.29992849f, -0.14048499f, 0.02441842f, -0.20177509f, 0.95537323f, 0.68443722f, 0.10535089f, 
    -0.44585142f, 0.25296292f, -0.24148303f, -0.07227793f, -0.05440745f, 0.23201001f, -0.26200429f, 0.00066239f, 
    -0.10797572f, -0.00584370f, -0.14241244f, 0.16648038f, -0.09115446f, 0.01068649f, 0.07813440f, -0.16760394f, 
    0.15808946f, -0.26835072f, 0.12435390f, 0.03693398f, 0.20096329f, -0.22929658f, 0.24828492f, -0.25001237f, 
    0.16367915f, 0.09170088f, 0.07801247f, -0.16367352f, -0.16949292f, -0.11508100f, 0.03860344f, -0.05843322f, 
    0.33775759f, -0.10394243f, -0.31547344f, 0.22328755f, 0.01170853f, 0.24269581f, 0.20077880f, 0.15894911f, 
    -0.23988913f, -0.34155247f, -0.18251362f, 0.20919207f, 0.34786117f, 0.00540168f, 0.34166965f, -0.14429837f, 
    -0.38048726f, -0.54294002f, -0.55195755f, -0.45791462f, -0.29220131f, -0.76393348f, -0.44140077f, -0.33457235f, 
    -0.88187319f, 0.14934203f, 0.08240403f, 0.50253868f, 0.22001231f, 0.23645648f, 0.23627752f, 0.24614529f, 
    0.14406599f, -0.03977386f, 0.06868964f, -0.02164661f, 0.11131519f, 0.34284043f, -0.01697787f, -0.13120405f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.11811300f, 0.05942880f, 0.08783754f, 0.05882753f, 0.18611890f, 0.33276138f, 0.26047489f, -0.04442788f, 
    0.68835658f, 0.09242580f, 0.32050425f, 0.33286989f, 0.26559818f, 0.26047990f, 0.04423666f, 0.22109289f, 
    0.07397214f, 0.13074374f, 0.16503869f, 0.15311961f, 0.33121485f, 0.36303407f, 0.00786680f, -0.01039218f, 
    -0.15482782f, -0.01804658f, 0.03303264f, 0.23430912f, 0.04739095f, 0.25571433f, 0.21399464f, -0.05264231f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.09753964f, 0.10250952f, -0.06952583f, -0.04941570f, 0.02152512f, -0.03007386f, -0.00543298f, 0.09977930f, 
    0.00365924f, -0.06885105f, -0.07829451f, 0.20227210f, 0.09352776f, 0.20025937f, -0.04421472f, -0.07161239f, 
    0.02012115f, 0.10802757f, 0.04061919f, 0.01237173f, -0.01186043f, -0.00583084f, 0.00192047f, -0.05405284f, 
    0.14208309f, 0.15131924f, 0.08384752f, -0.01672171f, -0.04739063f, -0.00591648f, 0.01008234f, -0.11321215f, 
    0.02340849f, 0.02672807f, 0.13513012f, 0.11398768f, 0.08984928f, 0.09994089f, 0.07661762f, 0.05436566f, 
    0.03341427f, -0.01418402f, -0.02459873f, -0.01944149f, -0.02037823f, -0.02367594f, 0.09643701f, -0.13580333f, 
    0.08142705f, -0.22061828f, -0.09226110f, 0.08408749f, 0.13984923f, -0.01349538f, -0.05463140f, 0.00523544f, 
    -0.00244300f, 0.00396435f, 0.09262617f, 0.13065869f, -0.19800501f, -0.01006301f, 0.13291660f, 0.08177487f, 
    -0.04858813f, 0.13533223f, 0.02336882f, -0.05447721f, 0.00753014f, -0.11485868f, 0.00124126f, -0.08992537f, 
    0.42884892f, 0.15970653f, -0.18784349f, 0.04484219f, -0.00460785f, -0.18983337f, -0.05371955f, 0.00417905f, 
    -0.00681089f, -0.00528156f, 0.01359147f, 0.06886622f, 0.11205960f, 0.12346385f, 0.00512381f, 0.08218515f, 
    0.09509678f, 0.05112441f, 0.09168699f, 0.25415638f, -0.03956665f, -0.03500265f, 0.02014383f, 0.07303190f, 
    0.04126123f, 0.03192623f, -0.06738901f, 0.01397849f, 0.05151994f, 0.10723463f, 0.00043498f, -0.10281157f, 
    0.04781589f, 0.05100577f, -0.12432282f, 0.00476525f, 0.06312004f, 0.14613540f, -0.02213198f, 0.14539862f, 
    -0.19895242f, -0.15349002f, -0.04188622f, 0.09763438f, 0.07104374f, 0.11005928f, 0.10761050f, -0.06068902f, 
    0.01538095f, 0.10658049f, -0.05703162f, -0.02532738f, 0.13848133f, -0.03526356f, 0.04720685f, -0.03219651f, 
    -0.04788748f, 0.04230331f, -0.05928816f, -0.04334505f, 0.09577188f, -0.10767762f, 0.07133672f, 0.18266253f, 
    0.15555017f, 0.07287700f, -0.07686652f, 0.05191641f, -0.18835200f, -0.06835730f, 0.04331117f, -0.03738784f, 
    -0.05623642f, -0.07543634f, 0.03265014f, 0.24578018f, -0.07308263f, -0.03902946f, -0.10953359f, 0.01057613f, 
    0.01286462f, -0.11095900f, -0.03923916f, 0.06164789f, -0.32025531f, -0.33860651f, 0.24937820f, 0.22371708f, 
    -0.09471390f, 0.14893611f, -0.07402215f, 0.11067294f, -0.03262395f, -0.05926942f, -0.04255949f, 0.06045260f, 
    -0.00174115f, 0.28977475f, 0.18973753f, -0.21719790f, -0.14161704f, 0.13582136f, -0.00416939f, -0.05568226f, 
    0.09830981f, -0.05226115f, 0.07703002f, -0.22147389f, -0.03122149f, -0.09471204f, 0.37557274f, 0.16267253f, 
    0.02848690f, 0.08235162f, -0.12535830f, 0.09080769f, -0.04534272f, -0.04256078f, 0.18471162f, -0.10551403f, 
    -0.17789046f, -0.13968556f, -0.07338384f, 0.13313664f, 0.00686305f, 0.02059699f, 0.10247104f, -0.01236303f, 
    -0.06554319f, 0.00338836f, 0.16520493f, -0.04988154f, -0.19036873f, 0.01073018f, 0.23523064f, -0.10486300f, 
    -0.14049874f, -0.17399772f, 0.03371963f, 0.13996635f, -0.03845462f, 0.09806166f, -0.04714007f, -0.10341159f, 
    -0.01653476f, 0.11903036f, -0.06077889f, 0.09934334f, -0.12581779f, -0.07889642f, 0.16985084f, -0.11256221f, 
    0.10792866f, 0.11727804f, 0.02061772f, 0.22158943f, -0.00898092f, 0.04353693f, -0.01336680f, 0.23804206f, 
    -0.01230835f, -0.03378220f, -0.09201773f, 0.05557889f, -0.02762778f, -0.00978821f, -0.04288866f, 0.02817894f, 
    0.19046931f, 0.15862682f, -0.15655567f, -0.24107753f, -0.04929453f, -0.19303802f, -0.08491313f, -0.12250122f, 
    0.07111834f, -0.02451932f, 0.00423739f, 0.01072644f, 0.02855465f, 0.09025588f, 0.34980422f, 0.04350780f, 
    -0.11585955f, -0.01963467f, 0.12644856f, 0.05144908f, 0.04079322f, 0.00155880f, 0.03150947f, 0.01144125f, 
    0.17860244f, 0.00046754f, 0.07870647f, -0.07855316f, -0.10235252f, 0.24330926f, 0.04491435f, 0.19791992f, 
    -0.00742104f, -0.03108771f, 0.07296747f, -0.05777586f, -0.14529623f, -0.05218002f, 0.15072687f, 0.24231765f, 
    0.02493893f, -0.07061259f, -0.07530470f, 0.01967397f, 0.04594849f, 0.06211465f, 0.01330319f, 0.10341392f, 
    -0.18997940f, -0.05418127f, 0.06862797f, 0.04550831f, 0.00703125f, -0.02561917f, -0.16298351f, -0.01895531f, 
    -0.02564357f, 0.01812021f, 0.00842254f, 0.02973825f, 0.17306948f, 0.06402136f, 0.10336757f, -0.11501911f, 
    0.00799634f, 0.04946321f, -0.17029569f, 0.12441783f, 0.10708099f, -0.00368486f, -0.01837293f, 0.18436453f, 
    0.12255707f, 0.03362875f, -0.04560943f, -0.02088437f, -0.00887212f, 0.18951523f, -0.04840617f, 0.07789870f, 
    -0.00407882f, -0.00892111f, 0.09944300f, -0.16578601f, -0.00487420f, 0.04168512f, 0.06698301f, 0.00378857f, 
    -0.01086942f, -0.07168257f, 0.03132453f, 0.00553647f, -0.12380023f, -0.28151545f, 0.02386976f, -0.03334342f, 
    -0.12356583f, -0.06034366f, 0.09008276f, 0.08758757f, -0.05930055f, -0.04496270f, 0.01445120f, -0.05960435f, 
    -0.05666759f, 0.08376765f, 0.07288777f, 0.08687021f, 0.41314745f, 0.13452247f, -0.02121264f, -0.08320253f, 
    -0.15151589f, 0.06603231f, -0.04609196f, 0.01178811f, 0.08078570f, 0.10201947f, 0.09064642f, -0.01541698f, 
    0.05947595f, 0.07401593f, -0.00005009f, 0.08131298f, 0.04189878f, -0.02998840f, 0.08726130f, 0.06521937f, 
    -0.01418548f, -0.04600967f, -0.13146006f, -0.12594762f, -0.11037420f, 0.07952686f, 0.32478252f, 0.07674017f, 
    -0.07916933f, -0.08017517f, -0.03485360f, -0.00989151f, 0.01586322f, -0.01289336f, -0.03670794f, -0.02987170f, 
    -0.00943580f, -0.16214955f, 0.06995561f, -0.10541689f, 0.13893098f, -0.12023561f, -0.08036627f, -0.18232283f, 
    0.16646907f, -0.00117006f, 0.03762032f, 0.25919893f, 0.23589332f, -0.07360166f, 0.03175166f, 0.05910388f, 
    0.16638681f, -0.01338677f, 0.07591984f, 0.07458582f, -0.11160248f, 0.00487210f, -0.00644282f, -0.00827738f, 
    -0.00298158f, 0.06899282f, -0.11595779f, 0.04520468f, 0.03715269f, -0.00609826f, 0.11195979f, -0.04073792f, 
    0.20050199f, 0.05409202f, 0.11638916f, 0.24431467f, 0.12362901f, -0.35588986f, -0.09489535f, 0.01307020f, 
    0.03455855f, 0.01619394f, 0.13837557f, 0.07898089f, 0.08497506f, -0.15086596f, 0.09068581f, -0.07947797f, 
    -0.68345994f, 0.23225154f, -0.02126279f, -0.07624399f, -0.04733714f, -0.07798246f, -0.08094103f, -0.06432167f, 
    0.12696266f, 0.01917505f, -0.05875828f, 0.04969111f, 0.26266223f, -0.33731338f, 0.17438871f, -0.21610563f, 
    0.00543055f, 0.12048845f, 0.01341324f, -0.03248186f, -0.01501789f, 0.04949206f, -0.13871853f, -0.03070636f, 
    0.15035151f, 0.14447811f, 0.33775875f, 0.13557851f, -0.14127880f, -0.08622313f, 0.01750256f, -0.09511019f, 
    0.02939290f, -0.07907122f, 0.12364794f, -0.01741873f, -0.15651819f, 0.05097878f, -0.03614942f, 0.21700171f, 
    0.10372189f, 0.00118084f, 0.21240690f, 0.18471326f, -0.07527872f, -0.11599780f, -0.06428580f, -0.07052789f, 
    -0.04997430f, -0.11312325f, 0.08675712f, 0.49442837f, 0.05933860f, 0.07108355f, 0.11422194f, 0.08369473f, 
    0.03160924f, 0.13476273f, 0.01678974f, -0.05833721f, 0.09732529f, 0.07763003f, 0.31802043f, 0.25869665f, 
    -0.04491597f, -0.02369217f, -0.00146897f, 0.02460260f, 0.05769556f, -0.18355227f, 0.04126617f, -0.11707166f, 
    0.05121750f, -0.03062946f, -0.00488694f, 0.12503654f, 0.09903795f, 0.01836733f, 0.01980358f, 0.07967778f, 
    -0.06180672f, 0.03937740f, -0.03258109f, 0.03325342f, 0.21670121f, -0.21567832f, 0.10112956f, -0.23469569f, 
    0.05606956f, -0.08511835f, 0.01003357f, -0.01457212f, -0.02046671f, 0.09607869f, -0.07331840f, -0.17267314f, 
    -0.07207249f, 0.04818797f, 0.30557647f, 0.01538770f, -0.11143418f, -0.00301191f, 0.02635175f, 0.08650414f, 
    0.11362838f, -0.01668151f, -0.07077990f, 0.05939274f, 0.04221873f, -0.46094701f, 0.14885294f, -0.22337428f, 
    -0.00950877f, -0.11825772f, 0.11819532f, 0.18557529f, 0.09662130f, 0.07525509f, -0.07345670f, 0.04399724f, 
    -0.20829774f, 0.33666158f, -0.27434886f, -0.08044985f, -0.17634405f, 0.04823303f, -0.03546494f, 0.08862182f, 
    0.04039814f, 0.05612152f, -0.05345397f, 0.02555696f, -0.09026598f, 0.01815835f, -0.03010127f, -0.15501440f, 
    0.01949920f, 0.08628137f, -0.04054347f, -0.20563248f, 0.12800057f, 0.04254554f, 0.07465728f, -0.07702816f, 
    -0.08955226f, -0.20398298f, -0.02229491f, 0.21960746f, -0.01249042f, -0.03938555f, -0.11292252f, 0.08095406f, 
    -0.06031879f, -0.01371130f, 0.08041755f, 0.03690644f, 0.14588210f, 0.08418997f, 0.20361702f, -0.22240366f, 
    0.01538810f, -0.13715395f, -0.07559980f, -0.17936942f, 0.22576506f, 0.03729510f, 0.12352679f, 0.03760852f, 
    -0.32477370f, -0.05161580f, -0.00274096f, 0.31384471f, -0.00727257f, 0.05597027f, -0.15077582f, -0.17278045f, 
    0.04504759f, -0.10719992f, 0.05334418f, 0.13259710f, 0.12077200f, -0.18233006f, 0.03987523f, -0.02455599f, 
    0.08881938f, -0.03757438f, -0.05361668f, -0.02380929f, -0.07651979f, 0.00450182f, 0.04354585f, 0.24890353f, 
    -0.01523525f, 0.24673384f, 0.14054991f, 0.27586892f, -0.12811601f, 0.04119615f, -0.01697081f, -0.16149749f, 
    0.05502758f, 0.01941384f, 0.08264889f, 0.15943334f, 0.24695814f, 0.03385738f, -0.38966197f, -0.28161377f, 
    0.00548451f, -0.09882819f, 0.09319823f, 0.12711930f, 0.08219786f, 0.02468491f, -0.10358843f, 0.06336782f, 
    0.15234275f, -0.01860211f, -0.04223191f, -0.09089822f, 0.08980114f, 0.00460050f, 0.02839004f, 0.08730665f, 
    0.10703986f, 0.08446606f, -0.15466945f, 0.05294591f, -0.02622362f, 0.15818164f, 0.05600687f, -0.15287176f, 
    -0.05345994f, 0.00077895f, -0.05719322f, -0.03895866f, -0.02735615f, -0.05169865f, -0.09291138f, -0.03146620f, 
    -0.06276596f, 0.22371326f, 0.18545754f, -0.12000363f, -0.13149919f, -0.08273658f, -0.06623895f, 0.13022093f, 
    0.02872072f, -0.04133663f, -0.03439122f, -0.04968312f, 0.10364702f, -0.06663802f, -0.16224298f, -0.32775533f, 
    0.18990129f, 0.03038448f, 0.01726724f, 0.20476019f, 0.09701417f, 0.09858967f, 0.12268481f, 0.14025441f, 
    0.04287583f, -0.06691493f, 0.08006077f, 0.13828804f, 0.03466910f, 0.03447362f, 0.01618281f, 0.09368692f, 
    0.08229019f, -0.04873623f, -0.05857652f, -0.18151663f, -0.22966629f, 0.13432725f, -0.14635417f, -0.26954857f, 
    0.08119755f, -0.05385293f, 0.09052514f, -0.08769470f, 0.13076907f, -0.21753448f, 0.07200374f, -0.01003641f, 
    0.21691471f, -0.08272453f, 0.13631707f, -0.03021568f, -0.01694706f, -0.01910086f, 0.05429507f, -0.10060082f, 
    0.10535958f, 0.25120446f, 0.19080782f, 0.06650361f, 0.24163760f, -0.07147956f, -0.12983301f, -0.00572084f, 
    0.12373460f, 0.04307817f, 0.13373969f, -0.07712269f, 0.00883832f, 0.01263579f, -0.01234166f, 0.00808887f, 
    0.08007017f, -0.05894244f, 0.12207268f, 0.10184073f, -0.01784584f, 0.02525251f, 0.04055529f, 0.03921855f, 
    0.05005043f, -0.04698382f, -0.04498598f, -0.00889503f, -0.00936627f, 0.15216108f, 0.17343503f, -0.15310264f, 
    -0.05569778f, -0.00807390f, 0.08442318f, -0.13549893f, 0.11296277f, 0.05676082f, -0.03277607f, 0.00938554f, 
    -0.05323207f, -0.00059145f, 0.02839659f, 0.02664796f, 0.01623491f, -0.00523665f, -0.01786985f, 0.00304363f, 
    -0.01144671f, 0.02541932f, -0.05146717f, -0.02650662f, -0.04009901f, -0.02275473f, -0.05108139f, 0.00267749f, 
    -0.00575629f, -0.04364800f, -0.04245893f, 0.01767814f, -0.01698599f, -0.05860077f, -0.01130333f, 0.02317689f, 
    0.03310912f, -0.00301689f, 0.01815184f, -0.01676477f, -0.01568247f, -0.01547735f, -0.03512155f, 0.00474344f, 
    -0.04405227f, -0.01290577f, 0.02716596f, 0.01020915f, -0.02022862f, -0.05285761f, -0.01852980f, -0.03269480f, 
    -0.02150199f, -0.02297887f, 0.02345562f, 0.00635028f, -0.05815577f, 0.02302642f, -0.02634206f, 0.01953995f, 
    0.03784123f, -0.04175377f, -0.01569160f, 0.01407935f, 0.02520078f, -0.02070737f, -0.01011866f, 0.02321601f, 
    0.02220133f, 0.00602670f, 0.03076710f, -0.01980480f, 0.02871969f, -0.01649921f, -0.01277823f, -0.01356173f, 
    -0.03344281f, -0.00098473f, 0.03815606f, -0.03602114f, 0.00062967f, 0.03681022f, 0.02232736f, -0.03549960f, 
    -0.02329932f, -0.00587248f, -0.00840882f, -0.06072503f, 0.03317316f, 0.02853472f, -0.00115978f, 0.02604549f, 
    -0.01747438f, -0.05811028f, 0.01813583f, -0.03463002f, 0.02043104f, 0.01961981f, 0.00795323f, 0.00566515f, 
    -0.01526961f, -0.02395250f, -0.00457685f, 0.04010096f, -0.01438706f, 0.03687171f, -0.05159744f, 0.02759961f, 
    0.02162809f, 0.03589676f, -0.01865197f, 0.01101643f, -0.03358264f, -0.02105168f, -0.02440771f, -0.03030400f, 
    -0.02989914f, 0.00261621f, 0.02836327f, -0.01375528f, -0.00316437f, -0.05826488f, 0.02001525f, 0.04094372f, 
    -0.02440411f, -0.00888465f, -0.05278429f, -0.01001408f, 0.00686085f, -0.04673798f, 0.00781287f, -0.02804913f, 
    -0.05511117f, 0.01340882f, -0.00928668f, 0.00843909f, 0.00718518f, -0.04958780f, 0.02079795f, 0.03828472f, 
    -0.03154958f, 0.00659566f, -0.01964569f, -0.03068053f, 0.00661618f, -0.00624245f, 0.04000690f, -0.04016862f, 
    -0.01755497f, -0.02335564f, 0.02744020f, -0.04850420f, 0.01619473f, -0.02693494f, -0.01090273f, 0.03724628f, 
    0.02108707f, 0.02824193f, 0.02322784f, 0.01840727f, 0.02910664f, -0.03878370f, 0.00105193f, -0.02119427f, 
    -0.05864326f, -0.04571323f, -0.00628892f, 0.00787453f, -0.01318852f, 0.01876885f, 0.02695172f, 0.01534473f, 
    0.02645530f, 0.03951809f, 0.00999507f, -0.04260517f, -0.05069476f, -0.04680026f, -0.01753111f, 0.03017870f, 
    -0.02881385f, -0.01100784f, 0.02309091f, -0.03612478f, 0.04136236f, 0.02095474f, -0.04442250f, -0.01420991f, 
    0.01556916f, -0.00588263f, -0.01291308f, -0.05561654f, -0.01345814f, -0.02275735f, 0.03319300f, 0.00107236f, 
    -0.00926767f, -0.00629436f, -0.03157999f, 0.01079395f, -0.04341459f, -0.02524557f, -0.03826208f, 0.02112262f, 
    0.02894024f, 0.02236764f, -0.04028516f, 0.02363272f, -0.02051084f, 0.02482533f, -0.03984400f, 0.02744553f, 
    -0.01550030f, -0.00468316f, 0.02832941f, -0.00005251f, 0.01090279f, -0.03709086f, -0.00815808f, -0.00598382f, 
    -0.04359943f, 0.03635059f, 0.01348723f, -0.01192339f, 0.01371866f, 0.04303973f, -0.00395425f, -0.02947655f, 
    -0.05750311f, -0.02836250f, -0.04640008f, -0.04590833f, -0.00932296f, 0.02297247f, -0.01485884f, -0.02382440f, 
    0.03430897f, -0.02110474f, -0.03770617f, 0.01525476f, -0.03387541f, 0.02275171f, -0.03563543f, -0.02493474f, 
    -0.03792807f, 0.02216052f, 0.00638312f, -0.02458908f, -0.03637876f, -0.02585303f, -0.05831977f, -0.03243204f, 
    0.01738245f, -0.00517451f, -0.00812844f, -0.01349049f, -0.00652416f, -0.00228187f, 0.01993710f, -0.05168549f, 
    -0.01180731f, -0.03193885f, -0.02713490f, -0.02190292f, -0.02323443f, -0.01276939f, 0.03207373f, -0.03894962f, 
    0.01015593f, -0.02002230f, -0.04938122f, -0.05489358f, -0.01884434f, 0.03382370f, -0.01870895f, -0.02265964f, 
    0.01737082f, -0.04499202f, 0.01902287f, -0.01461540f, -0.05330176f, -0.03744311f, 0.04108840f, 0.02233966f, 
    -0.04893476f, 0.01265755f, 0.01972384f, -0.00986531f, 0.01686015f, -0.00010941f, 0.00727746f, -0.01799669f, 
    0.00787928f, 0.02640811f, -0.05955581f, 0.01475578f, -0.00122678f, -0.03941449f, -0.01392915f, -0.02778650f, 
    0.01060560f, 0.00816638f, 0.01074684f, 0.00128831f, 0.03608834f, 0.00491565f, -0.01902320f, -0.02186891f, 
    0.03709467f, -0.00552808f, 0.03144308f, -0.05546264f, -0.00538346f, 0.00606129f, -0.03866273f, -0.05913607f, 
    0.01063141f, 0.01229779f, 0.02573002f, -0.01960828f, -0.05874640f, -0.03418219f, 0.03708164f, -0.01842673f, 
    0.02255532f, -0.04129067f, -0.05360161f, 0.02365051f, 0.01297018f, -0.02824292f, 0.03830314f, -0.05212329f, 
    -0.01963934f, 0.02036375f, -0.04985005f, 0.01854341f, 0.01697177f, -0.01810360f, -0.04619048f, 0.00082736f, 
    -0.00703210f, 0.03227019f, -0.04774383f, -0.00054351f, -0.04883102f, -0.05464486f, -0.01294589f, 0.03292173f, 
    -0.01224384f, -0.00832025f, 0.02445858f, -0.00304170f, -0.02194091f, 0.03160699f, 0.03556310f, -0.00390137f, 
    -0.02094280f, -0.00417569f, -0.01648363f, -0.04044779f, -0.00675273f, 0.03785350f, -0.05299297f, 0.03582039f, 
    -0.03097960f, -0.04246857f, 0.00404642f, 0.03172897f, 0.01226460f, -0.04751065f, -0.03768158f, 0.03721055f, 
    0.03258131f, -0.02988875f, 0.02186017f, -0.02146661f, 0.03983463f, -0.03277741f, -0.03619475f, -0.04005947f, 
    -0.05552578f, -0.00672433f, 0.03977532f, -0.05079652f, -0.03133472f, -0.05160179f, 0.00777819f, -0.05369095f, 
    0.02078848f, 0.04042451f, -0.02068986f, 0.01855502f, 0.03474401f, -0.05288223f, -0.00865965f, -0.04502702f, 
    -0.03529046f, 0.18742236f, 0.12347110f, 0.24710427f, 0.11984590f, -0.01103514f, 0.04378625f, 0.00868054f, 
    0.33424872f, 0.04357446f, -0.16633116f, 0.14780365f, -0.06863961f, 0.03191632f, -0.27204341f, -0.12580718f, 
    -0.16076678f, -0.05090497f, -0.03765454f, 0.04349406f, -0.01808690f, 0.09061910f, 0.01753104f, 0.16161273f, 
    -0.19486296f, -0.14084497f, 0.18422417f, -0.08739273f, 0.07344715f, -0.03253526f, -0.01957262f, 0.03963862f, 
    -0.13730282f, 0.12293461f, -0.07036376f, 0.14940295f, -0.33289975f, -0.17234281f, -0.10168558f, -0.05626161f, 
    -0.13174404f, -0.06073192f, -0.04110427f, -0.01490280f, -0.08289010f, 0.05064866f, -0.04547734f, 0.03791169f, 
    0.60616869f, -0.23386490f, 0.07140920f, 0.21581799f, 0.11126714f, 0.01199064f, -0.21244128f, -0.08298012f, 
    -0.23106048f, 0.04966831f, 0.05770543f, -0.08228825f, -0.16138680f, 0.19471663f, -0.14980832f, -0.03646662f, 
    -0.03962338f, -0.11397193f, -0.02505749f, -0.00154658f, 0.15566626f, -0.07906566f, 0.02303335f, -0.01417183f, 
    0.25888008f, 0.05446905f, -0.09629221f, 0.10121307f, 0.08421601f, 0.08970115f, 0.11609020f, -0.01948365f, 
    0.02555813f, 0.00323900f, -0.09225481f, 0.04184962f, 0.22154076f, 0.11132021f, 0.05544399f, 0.25369301f, 
    0.22919439f, 0.05586725f, 0.06196603f, 0.13931611f, 0.11070279f, -0.07599141f, 0.15860847f, 0.06776182f, 
    -0.31411251f, -0.33676383f, -0.05809812f, -0.18340351f, -0.00339164f, 0.06204264f, 0.00390621f, 0.00796212f, 
    0.01668036f, 0.03586684f, 0.11165405f, -0.00163198f, 0.22342812f, 0.14641421f, -0.00749107f, 0.43459398f, 
    -0.10695065f, -0.02070299f, 0.05565099f, -0.14627628f, 0.00619108f, -0.14616771f, 0.07818034f, -0.11074604f, 
    -0.05815745f, 0.02305391f, -0.12392105f, 0.00790250f, 0.03834992f, 0.03995202f, -0.03647344f, 0.04922942f, 
    0.05249672f, 0.00428193f, 0.06632961f, 0.09459867f, 0.28892043f, 0.10528313f, -0.08370379f, 0.09289548f, 
    -0.07583930f, 0.01094675f, -0.02026089f, -0.00237443f, -0.08636561f, 0.05903782f, 0.05808124f, 0.01819518f, 
    0.40362164f, 0.17299692f, -0.04840213f, 0.33000284f, 0.10869762f, 0.12698866f, -0.05067873f, -0.05703500f, 
    0.09491629f, -0.13797784f, -0.09094033f, 0.07078668f, 0.04882601f, 0.21929149f, -0.08610246f, 0.31308690f, 
    -0.01480745f, -0.04466986f, -0.07635114f, -0.02154392f, 0.10246164f, -0.07522136f, -0.06081026f, 0.02047350f, 
    0.54696304f, 0.34100515f, 0.09737138f, 0.05137052f, 0.02293710f, 0.10806543f, -0.00730934f, -0.17160827f, 
    -0.03811733f, 0.13698857f, 0.00476918f, -0.18209310f, 0.04715154f, 0.10290999f, 0.00740327f, -0.17756072f, 
    0.00967523f, 0.12541346f, 0.07029177f, 0.12186350f, 0.19104631f, -0.09696524f, 0.10803774f, -0.05124668f, 
    0.04852979f, 0.50099939f, -0.07013851f, -0.06710123f, 0.06396031f, -0.05398805f, 0.10358581f, 0.08432217f, 
    0.02901716f, -0.03466237f, 0.06947918f, 0.01214096f, 0.22667548f, -0.06718925f, -0.00259090f, 0.19640325f, 
    0.08976172f, 0.02178479f, -0.06122549f, -0.07204522f, 0.00728415f, -0.01130483f, -0.07785152f, -0.03800580f, 
    0.22856332f, 0.16383728f, 0.00141178f, -0.09825184f, 0.16360569f, -0.05518984f, -0.02378991f, 0.05272157f, 
    0.01698962f, 0.00568595f, 0.18232599f, -0.06072441f, -0.12037086f, -0.00344861f, -0.19165152f, 0.02255153f, 
    -0.06344137f, -0.01395288f, 0.00085177f, -0.01528899f, -0.27409586f, -0.00679970f, 0.08155044f, 0.05098950f, 
    -0.02380579f, 0.13128093f, -0.08451574f, -0.12686236f, 0.09593016f, 0.01641763f, 0.11963908f, -0.10100670f, 
    0.05767747f, -0.19135475f, -0.03751509f, -0.05965126f, -0.14344504f, -0.20328838f, 0.26663718f, -0.02644677f, 
    -0.16745101f, 0.06564166f, -0.26360375f, -0.08920513f, -0.12566295f, -0.00368023f, 0.04586284f, 0.13871042f, 
    -0.08699512f, -0.11632334f, -0.05074224f, -0.02485997f, -0.16228512f, 0.04853860f, 0.08755759f, 0.08903411f, 
    -0.03011377f, -0.05290784f, 0.19656941f, 0.03375272f, 0.07218201f, -0.07365303f, -0.14507362f, 0.14442885f, 
    -0.04314768f, -0.02356823f, 0.07684540f, 0.25253174f, -0.06034768f, 0.03925769f, 0.13499461f, 0.04425116f, 
    0.21667522f, 0.13982674f, 0.00653665f, 0.24382794f, 0.10150369f, 0.07339293f, -0.07479569f, -0.03725022f, 
    0.04587641f, -0.02617850f, -0.11746901f, 0.05368318f, 0.00269347f, 0.05573793f, -0.15803255f, 0.00828240f, 
    -0.06619583f, -0.01617424f, -0.29833478f, 0.09257655f, -0.22205313f, 0.07518428f, -0.00637292f, 0.09491561f, 
    0.02770246f, -0.17050765f, -0.16979349f, -0.05856604f, -0.04995671f, 0.12209343f, -0.13058393f, -0.00853358f, 
    -0.13204364f, 0.13739523f, 0.07306197f, 0.00804053f, -0.06038281f, -0.06356256f, 0.27722847f, 0.24710497f, 
    -0.08626775f, 0.01641713f, -0.01385312f, 0.13446608f, -0.08803631f, 0.03207570f, -0.11207283f, 0.10835206f, 
    -0.10430472f, -0.19649735f, -0.10246493f, 0.09241948f, 0.03517523f, 0.09056444f, -0.09630126f, -0.07153374f, 
    -0.08586567f, 0.08087153f, 0.13186687f, 0.02426397f, -0.04726589f, -0.09837776f, -0.03653981f, -0.20654424f, 
    -0.15607575f, -0.20708315f, -0.04757642f, -0.02477416f, -0.06710082f, 0.11686417f, 0.01459073f, 0.07017937f, 
    -0.03135929f, 0.02766179f, -0.04967330f, -0.02191408f, 0.05590430f, -0.03556014f, 0.13318622f, 0.00652299f, 
    0.04884975f, 0.17910106f, 0.02900085f, 0.11530451f, 0.14710324f, -0.04473595f, 0.19793625f, 0.30436680f, 
    -0.02553080f, -0.04727752f, 0.03355812f, 0.03230402f, -0.01916194f, 0.07493944f, 0.00694726f, 0.06424073f, 
    0.09269404f, -0.19084242f, -0.02422600f, -0.04825676f, 0.00950225f, 0.07117392f, -0.17828861f, 0.13250042f, 
    -0.15445608f, -0.06361331f, 0.07204220f, -0.38649601f, 0.12240290f, -0.27518263f, 0.13472055f, -0.09573748f, 
    -0.01611792f, 0.00520921f, 0.02974735f, -0.20419702f, 0.00851994f, 0.06014851f, -0.11236396f, 0.05596266f, 
    -0.08163144f, -0.13267267f, -0.14909138f, 0.13274497f, -0.01996012f, 0.07618007f, -0.01752069f, -0.02175179f, 
    -0.01188482f, -0.25811148f, 0.00759669f, -0.22768573f, 0.20936982f, -0.01436143f, 0.24995714f, -0.13434662f, 
    0.01479690f, -0.04660737f, -0.02862680f, -0.06449737f, -0.05175989f, -0.01052003f, -0.06154869f, 0.04060832f, 
    -0.49338600f, 0.43037984f, 0.13547021f, -0.06447568f, -0.13439305f, -0.00662495f, 0.14430092f, 0.24206463f, 
    0.16992430f, 0.09377737f, -0.16681735f, -0.00931654f, 0.36305121f, 0.05229495f, 0.20005596f, 0.04740968f, 
    0.10412033f, 0.07180846f, 0.07548252f, 0.06123867f, 0.01988212f, 0.07356264f, 0.13704035f, 0.01233715f, 
    -0.01752713f, -0.01873657f, -0.14165159f, -0.03383605f, -0.20046844f, -0.04697501f, -0.13075599f, 0.10534289f, 
    0.16076729f, -0.09303037f, 0.07115291f, 0.01059261f, -0.10197278f, -0.03695956f, 0.03862676f, -0.28038651f, 
    -0.01737393f, 0.10956526f, 0.09235460f, 0.11000875f, 0.07612233f, 0.18113802f, 0.05798681f, 0.05564182f, 
    0.03882283f, 0.09756970f, 0.22540513f, 0.37421110f, -0.18478110f, -0.08538532f, -0.06520586f, -0.10792328f, 
    0.20261467f, 0.15037811f, 0.03400256f, 0.10633681f, -0.10210356f, 0.04162314f, 0.03840896f, -0.21605018f, 
    0.22851337f, 0.13647583f, 0.18550435f, 0.13112302f, -0.02242151f, -0.00295963f, -0.15081508f, -0.08610507f, 
    0.07153447f, -0.14974427f, -0.00899198f, -0.09963246f, 0.07678019f, 0.13908032f, 0.03827333f, 0.00625663f, 
    0.17124544f, 0.18935084f, 0.09563335f, 0.11590599f, 0.21867730f, -0.19598293f, 0.26008508f, -0.33020365f, 
    -0.14228357f, -0.07118782f, 0.02787180f, 0.02622857f, 0.08713761f, 0.02847929f, 0.03276335f, 0.13138300f, 
    0.01090922f, 0.15153113f, 0.08208603f, -0.31374341f, 0.06784754f, 0.05448247f, 0.09219464f, 0.20066412f, 
    0.09349857f, 0.01543390f, 0.01033998f, 0.00313513f, 0.17888750f, -0.09065907f, 0.09002616f, -0.31373888f, 
    0.18520822f, 0.16798808f, 0.11536442f, 0.20650595f, -0.00281740f, 0.08034611f, 0.16690482f, 0.02587292f, 
    -0.22526495f, -0.07079570f, -0.03693667f, 0.10393243f, 0.19727351f, 0.12665738f, 0.15224533f, 0.24845038f, 
    0.01931568f, -0.14970274f, -0.00720712f, 0.12489553f, 0.07127812f, -0.02341700f, 0.00573124f, 0.15510190f, 
    0.14833078f, -0.09781203f, 0.16442813f, -0.01052738f, -0.01947606f, 0.13350549f, -0.07489338f, 0.17551681f, 
    0.24992022f, -0.23929071f, 0.15458183f, -0.13741122f, 0.10373566f, -0.01887073f, 0.08652158f, -0.10248919f, 
    0.12081990f, 0.06404866f, -0.03363119f, -0.14846092f, 0.00281680f, -0.06538118f, 0.24291916f, -0.27492690f, 
    -0.00276840f, -0.06016542f, -0.06365597f, 0.31923673f, -0.09545749f, -0.15708004f, 0.06721453f, -0.05528667f, 
    -0.24227080f, 0.19213788f, 0.16904332f, 0.20204388f, 0.26454917f, -0.10965291f, 0.03244481f, 0.23397811f, 
    0.02390169f, -0.16673096f, -0.20652252f, -0.25858361f, 0.28702176f, 0.01824991f, 0.20330846f, -0.16058154f, 
    0.02408030f, 0.07583269f, 0.10408620f, 0.02002796f, 0.11728562f, -0.12260791f, -0.08797177f, -0.32674411f, 
    -0.26923051f, -0.21193139f, -0.01526794f, 0.13247177f, -0.08491439f, -0.19681889f, -0.09564456f, 0.03015673f, 
    0.11992853f, 0.02059488f, 0.13841066f, 0.08112728f, -0.12311210f, 0.14880708f, -0.33433181f, -0.00112664f, 
    0.04988392f, 0.07834079f, 0.17441443f, 0.14627972f, 0.08203197f, 0.03770342f, -0.04689167f, 0.11749573f, 
    -0.23324962f, -0.10293434f, -0.06326442f, -0.01038888f, -0.00002695f, 0.06237258f, -0.08836051f, -0.08573881f, 
    0.15995668f, 0.14249721f, 0.08710995f, 0.22547874f, 0.17727204f, 0.08850294f, 0.08508826f, -0.17375512f, 
    0.01051722f, 0.10241286f, 0.15008712f, 0.02143931f, -0.03835412f, -0.05146621f, -0.16956273f, -0.07260987f, 
    0.04147904f, 0.11135092f, 0.15823846f, -0.15934297f, 0.00652796f, 0.03564502f, 0.05068664f, 0.11589670f, 
    -0.05604548f, -0.02420329f, -0.07303090f, 0.01182853f, -0.09276091f, -0.24163198f, 0.20835471f, -0.42590362f, 
    -0.04630076f, -0.02870004f, 0.06884011f, -0.01646172f, -0.15544559f, -0.00133528f, -0.21424428f, -0.28683048f, 
    -0.15099317f, -0.14891022f, 0.06365410f, 0.04900844f, -0.05635151f, -0.18797110f, 0.10010325f, -0.10183777f, 
    0.10393801f, 0.10276301f, 0.13546126f, 0.20567690f, -0.11531299f, 0.24418563f, -0.09005284f, -0.09436083f, 
    -0.06808948f, -0.05646718f, 0.05392108f, -0.01473671f, -0.00046825f, 0.18245700f, 0.05522523f, -0.04027408f, 
    0.22054183f, -0.19968309f, 0.08207265f, -0.04576577f, -0.07469648f, -0.02583924f, -0.12134310f, 0.02323685f, 
    0.11917414f, -0.15175836f, -0.14554869f, -0.13636798f, -0.20331343f, -0.02766434f, -0.24080679f, -0.00731723f, 
    0.12711559f, 0.07011825f, 0.05475663f, 0.09175809f, 0.07211256f, -0.11346086f, 0.00864013f, 0.06805634f, 
    -0.06842189f, -0.10711863f, -0.12395750f, -0.09543598f, 0.15848540f, 0.15917712f, 0.01206566f, 0.07776902f, 
    0.18064871f, 0.11303172f, 0.17531230f, 0.17390491f, -0.06295126f, 0.07891552f, -0.07552495f, -0.05286571f, 
    0.10473807f, 0.10222348f, 0.15695210f, 0.13312806f, -0.20822500f, -0.09858409f, 0.01252829f, -0.00234658f, 
    -0.23206292f, -0.19788548f, -0.02206895f, 0.07314772f, 0.03332840f, -0.13186781f, 0.02804143f, -0.03462733f, 
    0.17070463f, -0.08363925f, 0.14704640f, -0.00794295f, -0.00551605f, 0.15395838f, -0.21562865f, 0.01140649f, 
    0.11543660f, 0.03163536f, 0.00616396f, 0.00805495f, -0.02882145f, -0.07357104f, -0.01803432f, 0.09737246f, 
    0.16208006f, 0.19039130f, -0.10147355f, -0.04776476f, -0.03239202f, -0.03761452f, 0.08927564f, -0.14152776f, 
    0.31300354f, 0.16894141f, -0.01076159f, 0.14564115f, 0.23981842f, -0.07267015f, 0.03719891f, 0.12516068f, 
    -0.03087538f, -0.01554993f, -0.08445352f, -0.03062391f, -0.01155316f, -0.06477948f, 0.01328896f, -0.15903872f, 
    -0.41484281f, -0.09520744f, 0.27879843f, 0.04464819f, 0.18233439f, -0.18831864f, -0.04142227f, 0.01476562f, 
    0.17781995f, 0.04420635f, 0.08556008f, 0.17757232f, -0.16488372f, -0.07088189f, 0.23571961f, 0.24920022f, 
    0.11983914f, 0.18152368f, -0.04911967f, 0.09790722f, 0.07315876f, 0.10396408f, 0.05529059f, 0.16638063f, 
    -0.47473511f, 0.23296341f, 0.49562544f, 0.14543678f, -0.15746340f, -0.13464792f, 0.04124605f, 0.10175849f, 
    -0.02741463f, -0.15559110f, 0.11407580f, 0.09574535f, -0.28610456f, -0.24645770f, -0.12036951f, 0.03867125f, 
    0.18655953f, -0.14207368f, 0.05116006f, 0.04962185f, -0.13874330f, -0.15225521f, -0.06375816f, -0.20700730f, 
    -0.08100411f, -0.12600449f, -0.18072635f, 0.22091177f, 0.08018586f, -0.01436580f, 0.07770926f, 0.00810622f, 
    0.17403798f, 0.09493261f, 0.23062499f, 0.17916338f, -0.14326149f, -0.07518251f, 0.28604621f, 0.38873979f, 
    -0.08292724f, -0.02251574f, -0.04401176f, 0.18126114f, -0.04317766f, -0.05015424f, 0.04655584f, -0.01383519f, 
    0.04804685f, 0.02188687f, -0.09040885f, 0.09637734f, 0.28715840f, 0.09669556f, 0.10378272f, 0.15905878f, 
    0.00525138f, 0.06659932f, -0.06989142f, 0.08820476f, 0.27789882f, 0.16347228f, 0.42982098f, -0.14369789f, 
    -0.05069922f, -0.02140655f, 0.00388207f, 0.03829008f, -0.04190507f, 0.29913488f, 0.06935202f, 0.04077570f, 
    -0.32852390f, -0.05046514f, 0.41640508f, 0.27459091f, -0.08325306f, -0.04544067f, 0.09197570f, 0.05372093f, 
    -0.05618713f, 0.03476658f, 0.00132209f, -0.02847437f, -0.14173676f, 0.01252020f, -0.01176397f, 0.30519778f, 
    0.02403707f, 0.17041540f, 0.22399589f, 0.31565151f, 0.05997141f, 0.07127345f, -0.08505739f, 0.02958929f, 
    -0.17500396f, 0.36279356f, -0.17024231f, 0.25119758f, 0.09244925f, 0.05266810f, 0.00179023f, 0.01973116f, 
    -0.06910467f, -0.01461861f, -0.11457267f, 0.04494441f, -0.04019827f, -0.05597712f, -0.18764213f, 0.00630754f, 
    -0.12762225f, -0.02801363f, -0.08418480f, 0.10843378f, 0.05573914f, 0.06358925f, 0.08720116f, -0.05684056f, 
    -0.12043547f, -0.22099057f, -0.25181580f, 0.31441626f, 0.09708184f, 0.04340128f, 0.08411827f, 0.10716353f, 
    -0.01733526f, 0.00313858f, 0.08868518f, -0.02576600f, 0.06187773f, 0.31363413f, 0.22396941f, -0.03577214f, 
    -0.12239567f, 0.04795821f, 0.15475582f, -0.02065311f, 0.14817238f, 0.15232496f, 0.20216131f, 0.09310247f, 
    -0.10553422f, -0.45333505f, -0.12809692f, 0.27792743f, 0.11887214f, -0.00053114f, 0.06381577f, -0.14160641f, 
    0.15913905f, 0.06152228f, 0.14913689f, 0.14905277f, 0.08725797f, -0.08930396f, 0.10202807f, -0.08799876f, 
    0.15417497f, 0.09832408f, 0.02221252f, 0.13215007f, 0.18592384f, 0.08382862f, 0.12596886f, 0.21626078f, 
    -0.24441767f, 0.19643481f, 0.03136947f, 0.29119200f, -0.06723822f, 0.08502461f, 0.08784010f, 0.03367703f, 
    0.03660060f, -0.01569944f, 0.04044949f, 0.13929877f, 0.29341429f, 0.00205286f, 0.03476779f, -0.51065743f, 
    0.08294341f, 0.07451373f, -0.07510962f, 0.13088985f, 0.01328800f, -0.02272305f, 0.03347756f, 0.11675055f, 
    0.00081700f, -0.14187138f, -0.02604941f, -0.21712039f, 0.05516813f, 0.03985140f, 0.06783938f, 0.22688879f, 
    0.11498322f, 0.01500476f, -0.05138384f, 0.04355730f, -0.47037014f, -0.27252296f, 0.12930338f, -0.07854331f, 
    -0.00961901f, -0.05194998f, -0.09892577f, -0.17252547f, 0.12539366f, -0.06266730f, -0.00314189f, 0.07782068f, 
    -0.27205661f, -0.02668019f, 0.18035381f, 0.12268595f, -0.12797219f, -0.07560120f, -0.16990951f, -0.10754203f, 
    0.00282752f, 0.02729425f, 0.07312526f, 0.01805235f, -0.03032077f, 0.01036607f, -0.31905925f, -0.26922521f, 
    0.05520839f, -0.01485291f, -0.09282646f, 0.13358916f, 0.09833090f, -0.00719065f, 0.04365285f, -0.02253499f, 
    -0.06026684f, 0.01888823f, -0.02089309f, -0.01654363f, -0.04042835f, 0.02148673f, -0.08566602f, 0.04095952f, 
    0.03303835f, 0.13502957f, 0.13229088f, 0.14965963f, -0.26810062f, 0.20105501f, 0.17319843f, -0.22335976f, 
    -0.06615909f, -0.08180042f, 0.06603380f, -0.06487119f, 0.18108632f, -0.06291461f, 0.19479713f, 0.09229755f, 
    -0.04512342f, 0.06658493f, 0.19089489f, -0.13988812f, -0.05480222f, -0.10214350f, 0.00358228f, 0.07691770f, 
    0.02722300f, 0.10826615f, 0.26459539f, 0.04030773f, 0.38435870f, -0.03590648f, 0.41271093f, -0.06257091f, 
    0.00570887f, 0.08589193f, 0.03311290f, -0.04232669f, 0.05147285f, 0.08470773f, -0.00672802f, 0.09997366f, 
    0.01420547f, -0.01621955f, 0.01090908f, -0.00981477f, 0.07542621f, 0.07578902f, 0.00147915f, 0.05274614f, 
    0.02603235f, -0.06478155f, 0.06818022f, -0.04587384f, -0.46826223f, -0.15923452f, 0.09561509f, -0.00888322f, 
    -0.05272329f, -0.14403570f, 0.03587875f, -0.42208958f, 0.06931661f, -0.05636364f, -0.04468016f, -0.11081889f, 
    0.17734054f, -0.01454797f, -0.13139737f, -0.20955540f, -0.02307028f, 0.13351935f, 0.05986954f, 0.06912927f, 
    -0.21611598f, 0.03699081f, 0.27734008f, -0.05642266f, -0.15139773f, 0.03230779f, 0.15330699f, -0.21983421f, 
    0.05634326f, 0.03677236f, 0.29118115f, -0.12272287f, -0.03710611f, -0.01717485f, -0.08570468f, -0.09446662f, 
    0.16314925f, -0.22203998f, -0.20698094f, 0.09368449f, -0.07901817f, 0.00705661f, 0.04363805f, 0.16565633f, 
    0.09343242f, -0.09230854f, 0.23293415f, -0.10487988f, 0.24453901f, -0.09558702f, -0.14982420f, 0.01473234f, 
    0.11665500f, -0.09146004f, 0.07473726f, 0.16103604f, 0.21222985f, -0.15015721f, -0.08461334f, -0.02878420f, 
    0.01218669f, 0.41064069f, -0.10905303f, -0.07243162f, -0.20523547f, 0.07515191f, 0.17001426f, 0.17193316f, 
    0.21067291f, -0.08379845f, -0.10407381f, 0.14775044f, 0.28480938f, 0.05257312f, 0.23707242f, 0.18220118f, 
    0.11045417f, 0.03498799f, 0.17794849f, 0.06530978f, -0.05572331f, 0.14299311f, -0.09877866f, -0.02360508f, 
    0.14009699f, 0.07769710f, -0.28077951f, -0.07023479f, -0.05256829f, -0.04807125f, -0.19140418f, 0.09312806f, 
    0.04369852f, 0.04088197f, -0.00401001f, -0.09551621f, -0.09542608f, 0.24770272f, 0.13284194f, -0.08482675f, 
    -0.06660471f, 0.13018270f, 0.02096980f, 0.00386270f, 0.10826393f, 0.14047833f, -0.38682401f, -0.12792431f, 
    0.18868214f, 0.14815906f, -0.08060036f, -0.27975425f, 0.01768268f, 0.06971373f, -0.18521054f, 0.03285710f, 
    0.10045207f, 0.23205005f, -0.09119504f, -0.06049960f, 0.00590033f, 0.16933188f, -0.00922668f, -0.34911540f, 
    0.06337046f, -0.08894987f, 0.02798046f, 0.13621886f, 0.03334972f, -0.02564460f, -0.20575351f, 0.15546706f, 
    -0.10623498f, 0.04027286f, -0.09363239f, -0.22267197f, 0.00408947f, -0.00877122f, 0.11273512f, -0.07803809f, 
    0.02110269f, 0.12258460f, 0.00164147f, -0.13715521f, -0.51245886f, -0.03546842f, -0.43773505f, -0.14433843f, 
    -0.00483469f, -0.09051530f, -0.15785955f, 0.11803786f, 0.09577982f, -0.06784543f, -0.02522032f, 0.02760949f, 
    -0.18960258f, 0.05278490f, 0.01165956f, -0.16961773f, -0.02186161f, -0.03194915f, 0.07449421f, 0.04438504f, 
    -0.00505185f, 0.11166825f, 0.06327285f, 0.06873824f, -0.12828669f, -0.00557744f, 0.25409767f, -0.09835614f, 
    0.22716446f, 0.16280644f, -0.04332929f, 0.05215390f, -0.20575254f, 0.21322872f, 0.03937387f, -0.12681288f, 
    -0.01324706f, -0.20903182f, 0.31525487f, -0.05897903f, 0.04815157f, -0.04750319f, 0.08996674f, 0.16287944f, 
    0.05129160f, -0.10404184f, 0.03949089f, 0.24593399f, 0.22492053f, -0.01271218f, 0.37576690f, 0.29320812f, 
    -0.03994815f, 0.14985010f, -0.21247455f, 0.07735447f, -0.08315574f, 0.03539506f, -0.19535005f, -0.13480762f, 
    -0.28276253f, -0.29573694f, 0.49868566f, 0.09232648f, 0.01663931f, 0.23211962f, -0.01106284f, -0.09166142f, 
    0.18056074f, 0.01521279f, -0.07935317f, -0.03670431f, -0.35865206f, -0.23486355f, -0.19306731f, 0.14396738f, 
    -0.04343804f, -0.13298608f, 0.05790046f, 0.29034546f, -0.10228069f, -0.07095771f, 0.08534275f, -0.08909147f, 
    -0.10945605f, 0.13481000f, 0.18448927f, 0.09736919f, -0.01731917f, 0.06287533f, 0.15006290f, -0.11889703f, 
    0.07357679f, -0.15139721f, -0.16811170f, 0.12130605f, 0.07606003f, 0.17100856f, -0.00438867f, 0.02221984f, 
    -0.01602193f, 0.05115716f, -0.03200839f, 0.04296530f, -0.07603602f, -0.03513693f, -0.13139713f, 0.04520242f, 
    0.20917296f, -0.12355042f, -0.05206270f, -0.23539130f, -0.00108150f, -0.05023909f, -0.03533543f, 0.25835365f, 
    -0.12391279f, 0.13577443f, 0.11491033f, -0.08537626f, 0.05960760f, 0.23769660f, -0.16967936f, 0.39958268f, 
    0.15251431f, 0.01405793f, 0.36549294f, 0.03596605f, 0.00287047f, -0.09599982f, 0.01430080f, -0.25006935f, 
    -0.12343805f, 0.18777056f, -0.26275420f, -0.02327370f, -0.01314438f, 0.03788101f, -0.14867629f, -0.13061532f, 
    -0.07571585f, 0.01186336f, -0.05100399f, 0.00066390f, 0.27058294f, 0.37129980f, 0.36569655f, 0.23777165f, 
    0.08831750f, 0.02805388f, -0.01091474f, -0.13548890f, 0.03179042f, -0.22773942f, -0.00840807f, -0.02909176f, 
    -0.04898818f, -0.01208859f, 0.00176265f, -0.01990311f, 0.08725041f, -0.05681370f, 0.23498060f, 0.23385167f, 
    -0.02911000f, 0.00321216f, 0.10898715f, 0.04658754f, -0.42109686f, 0.01036181f, 0.13082197f, 0.08962680f, 
    -0.01702050f, -0.01402580f, 0.22008671f, -0.08166898f, 0.13223639f, -0.01885239f, -0.08709093f, -0.06352657f, 
    -0.29145470f, -0.04522949f, -0.27556798f, 0.07479455f, 0.05173907f, -0.17878452f, 0.10115144f, -0.02857141f, 
    0.06298336f, -0.03615120f, 0.14505363f, -0.01467842f, 0.37425646f, -0.01634518f, -0.22874160f, -0.03912021f, 
    -0.04001956f, -0.18151085f, 0.01347889f, -0.20704812f, 0.15465912f, -0.09311144f, 0.15574595f, -0.01121016f, 
    -0.13092743f, -0.10763877f, -0.21042654f, -0.06182127f, -0.18073528f, 0.06604848f, -0.07769545f, 0.17834961f, 
    0.13861839f, -0.03429795f, -0.12034667f, 0.22100385f, 0.05029457f, 0.07810915f, -0.38808751f, -0.06356438f, 
    -0.03213113f, 0.28025874f, -0.13027425f, 0.12097988f, 0.04096159f, -0.13942665f, 0.07902901f, -0.15871291f, 
    -0.09841702f, -0.22102688f, -0.00528998f, -0.03252945f, 0.00810646f, 0.12089803f, 0.12816194f, -0.08878320f, 
    -0.00108299f, -0.18924646f, 0.00834688f, -0.12527399f, 0.37202889f, 0.29180846f, 0.13262944f, 0.15040283f, 
    0.28778684f, 0.25890315f, 0.06752707f, 0.18087657f, -0.03245204f, 0.03602171f, -0.06927191f, -0.02017116f, 
    0.18921165f, 0.09404741f, -0.04247051f, 0.15858810f, -0.05184810f, -0.02407188f, -0.00166305f, 0.23568970f, 
    -0.10455706f, 0.00929299f, -0.05290101f, -0.03696350f, -0.00123648f, -0.74181712f, 0.00973247f, -0.28554195f, 
    0.10671185f, 0.08067420f, 0.01112893f, -0.04793021f, -0.00514318f, -0.10911871f, -0.05745713f, 0.06031543f, 
    -0.06777411f, -0.21812972f, -0.36242536f, -0.10573304f, -0.08902287f, -0.02154507f, 0.01362568f, 0.04617267f, 
    -0.03194901f, 0.04682953f, 0.05017152f, 0.07271854f, -0.06457271f, -0.63207597f, -0.41742274f, -0.22934259f, 
    0.04272993f, -0.04186966f, -0.04988230f, 0.01785215f, 0.07887660f, 0.07456180f, -0.09772025f, 0.06238644f, 
    0.07075679f, 0.21342522f, -0.08133391f, 0.01436874f, 0.04305714f, -0.05976508f, 0.00103005f, 0.04641852f, 
    0.06136997f, -0.07977732f, 0.16607013f, 0.02102488f, 0.07979639f, -0.08760327f, 0.27803224f, 0.24815108f, 
    -0.09709261f, -0.05822106f, 0.05759923f, -0.05115088f, 0.01405816f, -0.07043765f, -0.11802050f, -0.08956984f, 
    0.17818609f, -0.16644339f, -0.03987145f, 0.08330645f, 0.17212492f, 0.06418537f, -0.04215622f, -0.08278552f, 
    0.10202669f, 0.06595849f, 0.05314025f, 0.05429390f, 0.15908293f, 0.20398717f, 0.24242102f, 0.33201119f, 
    0.03381657f, 0.03791985f, 0.09131016f, 0.01954074f, 0.06827260f, 0.05743286f, -0.03976134f, -0.15516700f, 
    -0.54175115f, -0.02888885f, -0.21939842f, -0.08970085f, 0.17988496f, -0.09110108f, -0.15737611f, -0.04865539f, 
    -0.11403436f, -0.07576602f, 0.01027743f, -0.01654506f, 0.05800678f, -0.03080880f, 0.04445447f, -0.01104918f, 
    0.04174708f, 0.09614640f, -0.01454663f, 0.10139496f, 0.04444971f, 0.05606354f, 0.00991276f, -0.00035749f, 
    -0.01726825f, -0.32559070f, -0.14019158f, -0.21915121f, 0.07387534f, -0.01282620f, 0.19652767f, -0.07230083f, 
    0.07187670f, 0.05907508f, -0.08527252f, -0.06670938f, 0.14437620f, -0.26009318f, -0.24252567f, -0.44992250f, 
    0.08935240f, -0.05843007f, 0.06586827f, -0.03352112f, -0.03814221f, -0.06299783f, 0.03335524f, 0.06810290f, 
    -0.04823676f, 0.09372443f, -0.09228974f, 0.07896275f, -0.04096662f, 0.01775530f, -0.01935183f, 0.04473878f, 
    0.01895051f, 0.04992300f, 0.00714088f, -0.01524764f, 0.10991635f, 0.25732160f, 0.10547222f, -0.04891715f, 
    0.00094505f, -0.16766052f, 0.04949983f, 0.00916737f, -0.02182133f, 0.04160292f, -0.08727103f, 0.10293265f, 
    0.20103708f, -0.05596418f, -0.19787450f, 0.05666816f, 0.10675296f, -0.05742607f, -0.06340243f, 0.04918447f, 
    -0.05200112f, 0.11387838f, -0.15073621f, 0.16095111f, 0.22251306f, 0.17710076f, 0.24160494f, 0.06859896f, 
    0.18579005f, -0.11155813f, -0.02983364f, 0.12892857f, 0.02361852f, -0.03858234f, -0.10411671f, -0.14176516f, 
    0.47112408f, -0.16447645f, 0.21449694f, 0.02471964f, -0.06416360f, 0.14130700f, -0.04832654f, -0.08792632f, 
    0.25174150f, 0.00883516f, -0.08551863f, 0.02583693f, 0.08097303f, -0.12120200f, 0.08282957f, 0.05915942f, 
    0.00882348f, 0.06074102f, -0.06769335f, 0.09685821f, -0.01576103f, -0.07116887f, 0.03924512f, 0.15154536f, 
    -0.06753276f, 0.00868627f, 0.20921481f, 0.16783080f, 0.05848673f, 0.01239518f, 0.01161830f, -0.08127001f, 
    0.02423496f, -0.05958468f, 0.01711427f, 0.10319521f, 0.10286863f, -0.20542206f, -0.05238999f, -0.11218194f, 
    -0.03540799f, -0.11046371f, -0.09021907f, -0.02635644f, 0.16022585f, -0.01824865f, 0.03245870f, -0.00240020f, 
    0.06116165f, -0.45992115f, -0.13400818f, -0.11014239f, 0.19624138f, 0.11618281f, 0.07086529f, -0.00832982f, 
    -0.02255780f, -0.02616070f, -0.01114134f, 0.18228070f, 0.16602468f, 0.41556481f, -0.12976819f, 0.42291296f, 
    -0.08468238f, -0.10973404f, 0.12571745f, 0.02306462f, 0.05245918f, -0.03706245f, -0.15228540f, -0.03420807f, 
    -0.31887332f, -0.06619432f, -0.41666713f, 0.01279501f, 0.26418996f, -0.08009084f, 0.04240013f, -0.20865947f, 
    0.07361426f, 0.02386642f, -0.12848251f, -0.02380286f, 0.18742701f, 0.27563667f, 0.37318876f, 0.25318158f, 
    0.07412846f, 0.11812256f, 0.09467008f, 0.19432734f, 0.03272690f, -0.03187051f, 0.02771949f, 0.18027072f, 
    0.08790073f, 0.03749941f, 0.06662474f, 0.14556473f, 0.06511198f, 0.10465140f, 0.11793683f, 0.16367152f, 
    0.04420934f, 0.01922311f, 0.12578373f, 0.10432222f, 0.07316890f, -0.00822459f, -0.02415598f, -0.00940968f, 
    0.00956552f, 0.08496425f, 0.00721036f, -0.02545913f, 0.07144417f, -0.05349281f, 0.12030239f, 0.08986812f, 
    -0.02100844f, -0.60320568f, -0.20498876f, -0.21509118f, 0.16682148f, -0.07552697f, 0.02184745f, -0.15094614f, 
    -0.06246407f, 0.07542149f, -0.04257298f, 0.17594373f, -0.07870244f, 0.26550016f, -0.04781952f, 0.17315041f, 
    -0.00253116f, 0.04826829f, -0.00247530f, 0.05103203f, 0.03701254f, 0.13200532f, 0.13663982f, 0.00282406f, 
    0.08049984f, -0.31915534f, -0.09909251f, -0.35989469f, 0.05398468f, -0.05898695f, 0.05901549f, -0.14635703f, 
    0.02204446f, -0.17396487f, -0.01626782f, 0.05001389f, -0.26837277f, -0.40795693f, -0.55766898f, -0.18875049f, 
    -0.04705210f, 0.00409499f, -0.07538672f, -0.08011172f, 0.06041027f, -0.15895423f, 0.06205113f, -0.09886730f, 
    0.08012851f, -0.16688478f, 0.11228159f, -0.17633827f, 0.00205915f, 0.02649910f, -0.09039518f, 0.08795202f, 
    0.08964704f, 0.00402153f, -0.05917981f, -0.27288517f, 0.30358931f, 0.40625492f, 0.21483034f, 0.30555460f, 
    -0.00594186f, 0.09978010f, 0.10489243f, 0.28056672f, 0.00407970f, 0.00341020f, 0.02344508f, 0.00746883f, 
    -0.16291715f, 0.18651700f, -0.10299473f, 0.11532551f, 0.00890953f, 0.02109179f, 0.27674025f, 0.19378264f, 
    0.04734491f, 0.14031753f, 0.21785146f, -0.08067150f, -0.00537632f, 0.29771051f, -0.22717473f, -0.17974983f, 
    -0.09361812f, 0.02606095f, 0.03053440f, -0.03322752f, -0.06151401f, -0.02056584f, 0.07626639f, -0.06366281f, 
    0.21517697f, 0.08699859f, 0.17433190f, -0.07799596f, -0.10894798f, -0.03816915f, -0.02660322f, -0.03966080f, 
    -0.01844082f, 0.08480294f, 0.02649068f, -0.07795452f, 0.09334218f, 0.29741320f, 0.09333762f, 0.18365744f, 
    -0.09550279f, -0.07676533f, -0.15621828f, -0.03104739f, -0.17983916f, 0.04748075f, -0.04610834f, -0.21484992f, 
    0.11703391f, -0.31823584f, 0.23427179f, 0.07719826f, 0.12680925f, 0.05313829f, 0.01444751f, -0.02134186f, 
    0.01155043f, -0.00689586f, 0.26111305f, 0.18586580f, -0.42012376f, 0.10825311f, 0.07725679f, 0.33109045f, 
    0.13407119f, 0.14412272f, 0.19821785f, 0.03509403f, 0.06402839f, 0.09034798f, 0.23633350f, 0.13351083f, 
    -0.39936271f, -0.05739210f, -0.10674697f, 0.03148302f, 0.00960184f, -0.17375283f, -0.04840899f, 0.12164470f, 
    -0.11084536f, 0.25311029f, -0.05458199f, 0.01732420f, -0.08260771f, -0.28852686f, -0.05865931f, -0.02755376f, 
    0.04921186f, -0.02900050f, -0.02446318f, 0.20441988f, -0.06439596f, -0.03166892f, -0.02454985f, -0.00604187f, 
    0.00542433f, 0.07688653f, -0.28472343f, -0.15022090f, 0.10064919f, 0.10396904f, 0.00460211f, -0.07744405f, 
    0.03065774f, -0.03200097f, 0.11469272f, 0.21088684f, -0.06953099f, -0.03003904f, -0.11453598f, 0.05892623f, 
    -0.07602122f, -0.22490841f, -0.02462685f, 0.09009337f, 0.07879253f, 0.24479440f, 0.08924802f, -0.05081037f, 
    -0.09670240f, 0.08340969f, -0.14812663f, -0.04435422f, 0.04629801f, 0.04156008f, 0.01171111f, -0.02978749f, 
    -0.01455102f, -0.03927987f, 0.05182034f, -0.01549734f, -0.00400073f, 0.29661924f, -0.00907727f, 0.46658704f, 
    0.02562455f, -0.01050667f, -0.09258138f, 0.05937088f, -0.16506907f, 0.17431554f, 0.09863506f, 0.03403967f, 
    0.03208284f, -0.01654348f, -0.04196414f, 0.24866460f, 0.00293614f, 0.03017623f, 0.02394265f, 0.00433867f, 
    0.01531193f, 0.00822761f, 0.10276777f, -0.02836725f, -0.20406550f, 0.21790372f, -0.21593998f, 0.45824918f, 
    0.13993080f, 0.20291501f, 0.14639632f, 0.09118658f, 0.01929285f, 0.08282082f, -0.01749116f, 0.13485241f, 
    -0.01457745f, 0.17944100f, 0.36673215f, -0.13008818f, 0.16378012f, 0.10729769f, 0.06701373f, 0.08236945f, 
    0.07162485f, 0.15434884f, 0.03453536f, -0.17564313f, 0.14811836f, -0.25025618f, 0.08624145f, 0.01802791f, 
    0.09549621f, 0.05827892f, -0.13386655f, 0.42024836f, -0.08073780f, 0.10321932f, 0.08790753f, -0.08217256f, 
    -0.01882096f, 0.14347801f, -0.14084722f, 0.19027784f, 0.05039954f, 0.08636282f, 0.17742783f, 0.05422032f, 
    -0.02577760f, -0.02488485f, 0.15122312f, -0.10485774f, -0.12713993f, 0.22541806f, -0.10156970f, 0.28848690f, 
    -0.22968403f, 0.06447205f, 0.26593581f, 0.24902424f, -0.06502708f, 0.28263846f, 0.08847778f, -0.06449405f, 
    0.34351954f, -0.18139774f, -0.04834450f, -0.14539707f, 0.20862517f, -0.00459429f, 0.24878155f, 0.08862827f, 
    0.16498476f, 0.27793884f, 0.12685317f, -0.01288296f, -0.05673636f, 0.18786116f, 0.03963951f, 0.17841527f, 
    -0.03891010f, 0.03203958f, 0.06128150f, 0.15417583f, 0.13577780f, 0.01594883f, 0.21821836f, -0.01956904f, 
    0.08155569f, 0.06990769f, -0.24137360f, -0.19589956f, -0.02241152f, 0.01250141f, 0.00587781f, -0.09315902f, 
    0.15078439f, 0.19351019f, 0.06929757f, -0.03288618f, 0.25475723f, -0.06026001f, 0.54739344f, -0.03943283f, 
    -0.19856353f, 0.05573035f, -0.02283899f, 0.04914459f, -0.11552330f, 0.00529906f, 0.07165463f, 0.11490998f, 
    0.09751337f, -0.13157170f, 0.07951286f, -0.10607848f, -0.10457382f, 0.17728479f, 0.11591423f, 0.21628539f, 
    -0.00406811f, -0.11972347f, 0.06887749f, -0.04569095f, -0.47457555f, -0.52432227f, -0.09787536f, 0.15069927f, 
    0.02366511f, -0.12779720f, -0.09288616f, -0.00816177f, 0.10411517f, 0.18297264f, 0.06517205f, 0.09942849f, 
    -0.04051998f, -0.17433336f, -0.08176426f, 0.11963271f, -0.07511973f, 0.10756170f, -0.07004511f, -0.16708562f, 
    0.00393067f, 0.13712181f, 0.06725739f, -0.03864980f, -0.01982100f, 0.25753546f, -0.25154930f, -0.01341777f, 
    -0.02614885f, 0.15740795f, -0.04138704f, -0.01318024f, 0.00277960f, -0.15877435f, -0.00288046f, 0.01709368f, 
    -0.00542325f, -0.00862587f, -0.18017562f, -0.06950790f, -0.01879097f, 0.01797922f, -0.09419289f, 0.08905827f, 
    -0.08197687f, 0.11536434f, 0.07885435f, 0.07926118f, -0.34323347f, -0.12655592f, 0.26885274f, -0.07227035f, 
    -0.02953065f, 0.06846353f, 0.03574549f, 0.09641726f, -0.09366724f, 0.11795010f, 0.03652597f, 0.06654425f, 
    -0.24171883f, 0.12863311f, -0.03643444f, 0.01508596f, 0.00834213f, -0.00806534f, -0.08023470f, 0.04932551f, 
    -0.18217021f, 0.05639069f, 0.06471687f, 0.03866072f, 0.44965017f, 0.04585180f, 0.28539139f, -0.14755467f, 
    -0.11759778f, -0.06108944f, -0.12965797f, 0.10415815f, -0.04876771f, 0.12453295f, -0.07549937f, -0.07260175f, 
    -0.03323491f, 0.07690146f, -0.07508600f, -0.03371833f, -0.07094993f, 0.02639981f, 0.08658113f, 0.00365854f, 
    -0.14464828f, 0.01326712f, 0.01058438f, -0.09685250f, -0.42851830f, -0.33018708f, 0.04692022f, -0.09740821f, 
    -0.08421979f, -0.13556212f, -0.09609602f, -0.17566577f, -0.03609905f, -0.02082208f, -0.19599965f, -0.10393346f, 
    -0.00645001f, 0.16820478f, 0.15496817f, -0.00023042f, 0.02932743f, 0.11698503f, 0.03154428f, -0.06067975f, 
    0.09311908f, -0.06799985f, -0.06513410f, 0.22486645f, -0.28143716f, 0.12129715f, -0.26097929f, -0.03784285f, 
    0.00897879f, -0.03570239f, -0.06815328f, 0.02022700f, -0.09766589f, 0.06425222f, -0.03602483f, 0.07711564f, 
    0.05560136f, 0.06046819f, 0.11635083f, -0.14303945f, 0.03324879f, -0.11307126f, -0.11497840f, -0.11614208f, 
    0.07178628f, 0.05357288f, 0.01383695f, 0.27333236f, -0.51127005f, -0.09498908f, -0.04060926f, -0.19819780f, 
    -0.04833038f, -0.12487961f, -0.09874500f, 0.00270111f, -0.03113791f, -0.01732270f, -0.04986017f, -0.03931645f, 
    0.38867274f, -0.19319594f, -0.03194977f, 0.20906247f, 0.23752321f, -0.01730222f, -0.12605833f, -0.07739554f, 
    -0.17045590f, 0.00494472f, 0.00956778f, -0.04503255f, -0.14607701f, 0.20132343f, -0.09491966f, -0.07218859f, 
    -0.07008738f, 0.06584758f, -0.11452762f, 0.02482953f, -0.01703594f, -0.00760165f, -0.21819457f, -0.06672752f, 
    0.29868025f, 0.26066494f, 0.22721529f, 0.11792748f, 0.04474327f, 0.07432756f, 0.15986603f, -0.03857358f, 
    0.03522740f, -0.03591697f, -0.02758658f, 0.02405689f, 0.19879936f, 0.33138105f, 0.11958786f, 0.26560813f, 
    0.10803735f, 0.04070708f, 0.03672826f, 0.18340184f, -0.05814899f, -0.13539131f, 0.00646375f, -0.03933212f, 
    -0.14201790f, -0.37202835f, -0.14888163f, -0.43729648f, -0.04989218f, 0.07389508f, 0.05088362f, -0.01763332f, 
    -0.05006371f, 0.03457902f, -0.03477965f, -0.02911426f, 0.15336481f, 0.24749626f, 0.07594865f, 0.40553373f, 
    -0.03981477f, -0.04487626f, 0.08599144f, -0.10596000f, -0.00517339f, -0.08865725f, 0.16925505f, 0.01991933f, 
    -0.21495655f, -0.03074170f, -0.06129329f, 0.04017803f, 0.05029010f, -0.09337692f, -0.06807315f, 0.00273206f, 
    -0.11323162f, -0.08604984f, -0.09661717f, 0.01283221f, 0.01737447f, 0.19916603f, -0.12751468f, 0.09826920f, 
    -0.05123557f, 0.09674004f, -0.05899471f, -0.05836244f, 0.01584750f, 0.11339159f, -0.09829348f, -0.07674982f, 
    0.06751811f, 0.01695695f, 0.14513804f, 0.32176596f, 0.08027662f, 0.01305281f, -0.05085994f, -0.06683219f, 
    -0.02826976f, -0.01002658f, 0.01830809f, -0.05175438f, 0.01245550f, -0.10607378f, 0.11886484f, 0.20234551f, 
    -0.08685742f, -0.03975584f, -0.08081289f, -0.05225740f, 0.01649908f, -0.03160013f, -0.16910870f, -0.11444686f, 
    0.33039829f, 0.20242997f, 0.10461310f, 0.22410291f, -0.16551319f, 0.12921813f, 0.03985616f, -0.24089018f, 
    -0.04240446f, -0.04157186f, 0.06070856f, 0.01767674f, -0.15841699f, 0.11442364f, 0.14379954f, -0.01456476f, 
    -0.09512539f, 0.19690186f, 0.02327933f, -0.12162106f, 0.00017799f, -0.18769361f, 0.05255877f, -0.07850560f, 
    -0.35250467f, 0.15241915f, -0.02106068f, 0.07479110f, 0.04585932f, -0.04173872f, 0.01389739f, 0.01827136f, 
    -0.07143110f, -0.04841558f, -0.03354740f, 0.05612962f, 0.12908874f, 0.05929814f, 0.03074005f, 0.17654315f, 
    0.20767412f, -0.06416194f, 0.04442073f, -0.12006309f, 0.19180478f, -0.02219282f, -0.16371006f, -0.05271620f, 
    0.20027079f, 0.17877041f, -0.13249844f, 0.19764799f, -0.09343184f, 0.11244334f, -0.01788917f, -0.02547672f, 
    0.02326581f, -0.01839308f, 0.04897893f, 0.13349715f, -0.11344991f, 0.04633160f, -0.04828261f, 0.06877469f, 
    -0.03842903f, -0.07935809f, -0.08944275f, -0.01852555f, -0.18336238f, -0.01378084f, -0.01811695f, 0.24926156f, 
    0.01368428f, 0.25641859f, 0.05158974f, 0.06368475f, 0.00593921f, 0.01472284f, 0.16986872f, 0.05197817f, 
    0.04034467f, 0.10943881f, -0.08352749f, -0.09374437f, -0.14856023f, -0.21585526f, 0.14784060f, -0.10111745f, 
    0.08629511f, 0.06568325f, -0.03231194f, -0.09117739f, -0.06136892f, -0.03917102f, 0.01919364f, -0.04479802f, 
    0.19611882f, -0.10746858f, -0.07120188f, -0.14924608f, -0.00160711f, -0.09232847f, 0.04591895f, 0.10440571f, 
    0.04694581f, -0.00095763f, 0.06322277f, -0.06367750f, 0.04750537f, 0.14712310f, -0.02527202f, 0.16788071f, 
    0.07383884f, 0.01068061f, -0.06360386f, -0.03159465f, -0.05706400f, 0.04640291f, 0.06432254f, 0.10152589f, 
    -0.01697875f, 0.09582317f, 0.08957208f, 0.19680017f, 0.12688750f, -0.00873684f, -0.11657420f, 0.01733259f, 
    0.00540615f, -0.01291882f, 0.01616798f, 0.00864796f, 0.04383349f, -0.03315041f, -0.17176637f, -0.24497958f, 
    0.04260669f, -0.24101564f, -0.30313072f, -0.03379814f, -0.05245944f, 0.04456291f, -0.04280561f, 0.13905592f, 
    0.22614726f, 0.02812608f, -0.26833600f, -0.18050095f, -0.06895493f, 0.05920693f, -0.04287758f, -0.02035240f, 
    -0.00025118f, -0.11336252f, -0.08205003f, -0.14944524f, 0.35295618f, -0.04421096f, 0.17636895f, 0.21262647f, 
    0.10173383f, 0.03790918f, -0.00438212f, -0.04448568f, -0.01431300f, -0.21678422f, -0.01922083f, 0.12710199f, 
    -0.09876008f, 0.00295726f, -0.01960817f, 0.10209771f, -0.01536645f, 0.10662407f, -0.00462515f, 0.00504870f, 
    -0.08657602f, 0.13533998f, 0.15135239f, 0.06708332f, -0.38467580f, -0.20517388f, -0.18669149f, 0.05391558f, 
    -0.17173894f, -0.10483659f, -0.08027463f, -0.19184458f, -0.04337329f, 0.13606793f, 0.07277480f, 0.00902311f, 
    -0.09413879f, 0.03184177f, 0.01985040f, 0.05660009f, -0.01147110f, -0.00707969f, 0.07552607f, 0.01252422f, 
    -0.04261346f, 0.03121614f, -0.14249444f, -0.07101158f, 0.14816843f, 0.05265697f, 0.26021853f, 0.27325028f, 
    -0.07110042f, 0.10374391f, -0.00601875f, 0.10589257f, 0.18089645f, 0.12263286f, 0.04710406f, 0.03131608f, 
    -0.27824092f, 0.02538644f, -0.08745489f, 0.04406547f, 0.05450195f, 0.08908918f, -0.09308517f, -0.09177791f, 
    -0.02154930f, -0.06581151f, -0.23483191f, -0.04726088f, -0.08215117f, -0.09063053f, 0.00565509f, 0.04410938f, 
    0.01920233f, 0.00290482f, -0.02799187f, 0.03334276f, -0.04278689f, 0.16283739f, 0.12254349f, -0.13857055f, 
    0.06762920f, 0.02970957f, 0.14063618f, -0.15856692f, -0.01356782f, -0.02376780f, 0.00498523f, -0.08162943f, 
    -0.11044189f, 0.07911997f, -0.25278759f, -0.07593529f, -0.28412840f, 0.07393858f, 0.11437140f, -0.27799240f, 
    -0.06617995f, -0.05580897f, -0.06024384f, -0.10861105f, 0.06702305f, -0.00838418f, 0.10705914f, 0.01932725f, 
    0.73132670f, -0.49569845f, 0.23995867f, 0.33628279f, 0.17408732f, -0.16235505f, -0.02713258f, 0.00638290f, 
    0.00812636f, -0.16546941f, 0.06704896f, -0.01691306f, -0.46975908f, 0.20501988f, 0.03093402f, 0.15313920f, 
    -0.03044546f, 0.13226718f, -0.22396185f, 0.18464541f, 0.02725306f, 0.09472388f, -0.01857973f, -0.16063234f, 
    0.18405765f, 0.07122304f, 0.13746855f, -0.12033524f, -0.05811451f, -0.10390560f, 0.08808900f, 0.11978329f, 
    0.07876492f, 0.18544132f, 0.08269438f, 0.01306946f, 0.06030743f, -0.04263200f, 0.00603382f, 0.16783708f, 
    -0.04047064f, -0.04312493f, 0.04962443f, 0.16111656f, -0.09260091f, 0.06830439f, 0.12222046f, 0.04145480f, 
    0.13167165f, 0.28321764f, -0.02617735f, -0.12848124f, -0.04056861f, 0.12439001f, 0.01648826f, -0.06417366f, 
    0.10522301f, 0.06845879f, 0.07775195f, 0.04114572f, 0.03054847f, -0.01433956f, 0.20420694f, 0.35147431f, 
    -0.03960545f, -0.03243471f, 0.04027018f, 0.20582393f, -0.05731430f, -0.01090803f, 0.02001903f, -0.09951325f, 
    -0.06717515f, -0.02931026f, 0.00686322f, -0.05942016f, 0.14594655f, 0.05524455f, 0.05050574f, 0.04004868f, 
    -0.00979841f, 0.08376328f, 0.05719948f, -0.02387309f, 0.44214988f, 0.41080949f, 0.34958875f, 0.14716205f, 
    0.10443754f, -0.09834204f, 0.06970843f, -0.09729014f, 0.18349729f, 0.23103642f, 0.20759304f, -0.02050605f, 
    -0.11030992f, -0.16656893f, 0.26716238f, 0.26685679f, 0.02597242f, 0.00624932f, -0.04262127f, 0.05362551f, 
    0.01255388f, -0.05440931f, -0.08335896f, -0.10047537f, -0.30018586f, 0.10122005f, 0.30342731f, 0.22766882f, 
    -0.06528518f, 0.04770474f, -0.05875347f, -0.07437084f, -0.03305776f, -0.08623892f, 0.03399305f, 0.00744095f, 
    0.16660126f, 0.03493015f, 0.28346819f, 0.23841943f, -0.00450566f, 0.24658436f, -0.00020038f, -0.16398294f, 
    -0.08051117f, 0.02027634f, -0.06646779f, -0.02453393f, -0.51129884f, 0.11808833f, -0.14173493f, 0.26093566f, 
    -0.08795110f, 0.18208559f, 0.14107877f, -0.04809359f, 0.14366373f, 0.05780885f, 0.13489297f, 0.10848933f, 
    -0.25773141f, -0.01266079f, -0.17779787f, 0.00070943f, -0.04708743f, 0.07762882f, 0.21768162f, 0.17119882f, 
    -0.14890957f, 0.13230458f, 0.10686362f, -0.08809552f, -0.16771711f, 0.08000601f, 0.02186491f, -0.03326267f, 
    -0.07315035f, -0.07486694f, 0.11222742f, -0.01302549f, 0.08909147f, 0.04481543f, -0.08712891f, 0.03898431f, 
    0.22051822f, 0.14818344f, -0.25295922f, 0.05761645f, 0.00315089f, -0.00779014f, 0.04461383f, 0.11911475f, 
    -0.06497287f, 0.08312576f, -0.12019774f, -0.01043362f, -0.01569271f, -0.07628440f, -0.02253571f, 0.07277786f, 
    -0.01626928f, -0.03599583f, -0.02445225f, 0.03024660f, 0.07984398f, -0.08723765f, -0.04927763f, -0.14683947f, 
    0.20786533f, 0.23828971f, -0.02116220f, -0.09402967f, 0.02843175f, -0.02625315f, 0.04945361f, 0.14064978f, 
    -0.15615778f, 0.00946858f, -0.12508136f, -0.08102105f, 0.01555271f, -0.15717576f, 0.44268867f, -0.18308474f, 
    0.06607269f, -0.20322663f, 0.21375218f, 0.03480469f, 0.02034956f, -0.02567404f, -0.01369693f, 0.03445486f, 
    0.07942288f, -0.08669641f, 0.07119895f, -0.05865550f, 0.09919038f, -0.21009031f, 0.27327910f, -0.07068177f, 
    0.12279907f, -0.03414865f, 0.13866220f, 0.13906080f, -0.25968480f, -0.12427081f, -0.02078901f, 0.27952337f, 
    0.16742863f, 0.11333790f, 0.10625001f, 0.07033455f, 0.05900173f, 0.06382462f, 0.01638385f, -0.13125615f, 
    -0.14378792f, -0.25454280f, 0.11914328f, 0.15293579f, -0.00320200f, -0.05108271f, -0.21292245f, -0.09787197f, 
    -0.02038711f, -0.06684960f, -0.14218675f, -0.03524606f, 0.18042468f, 0.12067104f, 0.07383854f, 0.02111519f, 
    0.04506547f, -0.13569732f, -0.20739932f, 0.05272657f, 0.12698798f, -0.04950493f, -0.01080582f, 0.00567416f, 
    0.16503873f, 0.04970762f, 0.09476259f, -0.12623735f, 0.05432008f, -0.06975972f, -0.01597300f, -0.05985193f, 
    0.06583906f, 0.07319023f, -0.03256845f, 0.15348952f, 0.33248189f, 0.14447042f, 0.30997184f, 0.17517354f, 
    0.00770296f, -0.14417347f, 0.02278203f, 0.12677380f, 0.05430696f, 0.01620059f, 0.03059087f, -0.01848992f, 
    -0.02189931f, 0.23267940f, 0.02698926f, -0.12315450f, 0.01725374f, -0.00459099f, -0.06616657f, 0.03303598f, 
    -0.04274298f, 0.01248479f, 0.02940223f, -0.20159666f, -0.08956679f, 0.09883717f, 0.15748651f, 0.06427825f, 
    -0.20905149f, -0.21478899f, 0.11273698f, -0.07259952f, 0.06576384f, 0.13031675f, 0.05592190f, 0.01639474f, 
    0.03637119f, -0.02156829f, -0.04446204f, -0.08339314f, -0.11421130f, 0.02373487f, 0.12868230f, 0.08154763f, 
    -0.07171714f, 0.04011473f, 0.02427649f, 0.11074859f, -0.41708729f, -0.19347417f, -0.04187178f, 0.15095435f, 
    -0.03050429f, -0.06762107f, -0.09027360f, -0.15618826f, -0.10482065f, 0.00747374f, 0.02250057f, -0.01751497f, 
    -0.02587833f, -0.01988509f, -0.04984592f, -0.02860967f, 0.02015647f, -0.05000659f, -0.03714441f, 0.01597596f, 
    -0.00093946f, 0.00159082f, -0.03440630f, 0.03747207f, 0.03651734f, -0.04014640f, 0.04057155f, -0.04853069f, 
    -0.05164830f, -0.00558793f, -0.05300047f, -0.03493479f, 0.01951836f, -0.01155245f, 0.01322772f, -0.02245639f, 
    -0.01171416f, 0.02449563f, -0.03035271f, -0.02092675f, -0.01984560f, -0.03897486f, -0.03610034f, 0.01159252f, 
    -0.02373066f, 0.04430279f, 0.02088889f, -0.04341697f, -0.04866271f, -0.02203852f, -0.00102647f, -0.05663715f, 
    -0.03120997f, -0.01881450f, -0.01086816f, 0.01478379f, -0.04423472f, -0.03374028f, -0.01277635f, 0.00103865f, 
    -0.04430493f, -0.03788592f, 0.01414418f, -0.03704321f, 0.03163969f, -0.04954482f, 0.02706584f, 0.01652552f, 
    0.00514950f, 0.03151201f, -0.04092427f, -0.00026062f, -0.04024854f, 0.00824291f, 0.04038164f, 0.04143275f, 
    -0.03668075f, -0.00228219f, -0.03704321f, -0.02508380f, -0.01811432f, 0.00309657f, 0.00296606f, -0.04713447f, 
    0.03884375f, -0.00016813f, 0.01163126f, -0.04399434f, -0.03065277f, -0.02704805f, 0.01603534f, -0.05159567f, 
    0.03681523f, -0.02953598f, 0.02894576f, 0.03378696f, -0.05378599f, -0.02053430f, -0.01422615f, -0.02899379f, 
    -0.01807294f, -0.03645926f, -0.01042931f, 0.00552345f, -0.02616223f, 0.04890528f, -0.02033091f, -0.00604126f, 
    -0.04437517f, 0.04248209f, 0.00916689f, -0.00413018f, 0.01619896f, -0.05009088f, 0.00171624f, -0.05531289f, 
    -0.03052493f, -0.04035809f, -0.05304917f, 0.01988708f, -0.04988203f, 0.00935774f, -0.04822315f, -0.03392412f, 
    -0.04372871f, -0.03318522f, -0.00093217f, -0.05377181f, -0.05012175f, 0.03798837f, -0.05502308f, -0.04380472f, 
    0.01476862f, 0.03618316f, 0.00626274f, 0.03974779f, 0.04298400f, -0.01195461f, 0.01075517f, 0.01783484f, 
    -0.02074788f, -0.02690521f, -0.04514169f, -0.00399896f, -0.02311084f, -0.01271891f, 0.00321234f, 0.00015732f, 
    -0.02189168f, -0.04737526f, 0.03169197f, -0.03533444f, 0.01781014f, 0.00440931f, 0.03518898f, 0.02198803f, 
    0.01458529f, 0.00175979f, 0.04117926f, -0.01535558f, 0.00312744f, 0.01499926f, -0.05177390f, 0.01213469f, 
    0.02413315f, -0.04924298f, 0.01459916f, 0.01666655f, -0.00602637f, 0.02663897f, 0.03145988f, 0.03927368f, 
    -0.04565542f, -0.00751906f, 0.01820544f, 0.02444697f, -0.03195900f, -0.02507823f, 0.03061104f, -0.03437784f, 
    -0.05635258f, -0.03889869f, 0.01531522f, 0.01886599f, -0.04519096f, 0.02997687f, -0.03045503f, 0.02205806f, 
    0.01981205f, 0.01216462f, 0.04401468f, -0.04907478f, -0.01472843f, -0.00430397f, 0.03862621f, -0.00593068f, 
    0.01466542f, 0.01883359f, -0.02262554f, 0.02339882f, -0.00767464f, -0.02134445f, -0.01003667f, -0.05543390f, 
    0.00874694f, -0.03911235f, -0.01490642f, 0.03949874f, -0.00833566f, -0.00637594f, -0.04296474f, 0.01932596f, 
    -0.01855762f, 0.01412121f, 0.04416839f, -0.04978146f, -0.01404925f, 0.01047467f, -0.01706260f, 0.04881079f, 
    -0.03534982f, -0.04299403f, 0.02054030f, 0.04255243f, -0.01949514f, 0.03895748f, 0.01717290f, 0.04340921f, 
    0.04641943f, 0.04287991f, 0.00826032f, 0.03050280f, -0.02784640f, -0.01521704f, -0.05547734f, -0.04930030f, 
    0.02902329f, 0.03047278f, -0.02840154f, 0.03951583f, -0.01391691f, -0.03708670f, 0.03777312f, -0.01877526f, 
    0.02414932f, 0.03575706f, 0.03184970f, -0.02883153f, -0.02672770f, -0.05129388f, -0.04662538f, 0.01502100f, 
    -0.04308822f, -0.02114733f, 0.04232258f, -0.02665411f, -0.04503029f, -0.05196397f, 0.03772407f, -0.05126242f, 
    -0.02061595f, 0.02698119f, 0.01229176f, -0.01674027f, -0.04853630f, -0.01496147f, 0.01136741f, -0.01924068f, 
    -0.04612735f, 0.04402127f, 0.01614972f, -0.04872933f, -0.03742440f, -0.00839658f, -0.02264124f, 0.03516641f, 
    -0.04064620f, 0.04394475f, 0.00206230f, -0.05304950f, -0.01579349f, -0.01066313f, 0.03805088f, 0.02957621f, 
    0.01175505f, 0.04310299f, 0.03821071f, -0.00105101f, 0.02301230f, 0.00499120f, -0.03666959f, 0.02367801f, 
    -0.04965070f, 0.03536973f, -0.01180840f, -0.03530979f, -0.00172587f, -0.04132733f, -0.04565561f, -0.01893016f, 
    -0.02316974f, -0.01880108f, -0.00142870f, -0.00642047f, -0.00862733f, -0.04483375f, 0.01427227f, 0.03165310f, 
    -0.02650237f, 0.02905833f, 0.03518648f, 0.02809160f, -0.05337667f, -0.05169181f, -0.02033062f, -0.00688169f, 
    0.00459097f, -0.05084433f, -0.05395875f, 0.00255622f, -0.05329716f, 0.04230343f, -0.03166628f, -0.05556808f, 
    -0.03229456f, 0.01988077f, -0.04787822f, 0.03463441f, 0.02918064f, -0.05308799f, -0.04141805f, -0.02598250f, 
    -0.03460861f, -0.03952724f, 0.00158966f, -0.03445102f, -0.00095160f, 0.04070839f, -0.00284363f, -0.03956328f, 
    0.01079272f, -0.01340608f, 0.03568200f, -0.00370670f, -0.03481312f, 0.02700004f, -0.03308860f, -0.03024578f, 
    0.00652729f, -0.02023571f, 0.02000924f, -0.03299203f, -0.04400232f, -0.00594439f, 0.03932752f, 0.04274522f, 
    0.01319434f, -0.00068274f, -0.05444789f, -0.02179138f, -0.00009883f, 0.01665737f, 0.03855862f, 0.02056506f, 
    0.02233204f, -0.04326883f, -0.05121568f, -0.02932528f, -0.00131085f, 0.04376811f, 0.00723820f, 0.04294999f, 
    0.00803027f, -0.02066176f, -0.04715080f, 0.01725399f, -0.05100977f, 0.00518125f, -0.02932382f, -0.04214401f, 
    -0.01333536f, -0.02232359f, -0.02386066f, -0.03406855f, 0.00450321f, -0.02266916f, 0.02093790f, 0.00882579f, 
    0.01861812f, 0.01565847f, 0.04165065f, 0.04009903f, -0.01013459f, -0.04045792f, -0.03484412f, -0.02504892f, 
    0.04837472f, 0.03307636f, -0.06288046f, -0.05651823f, 0.03161469f, 0.03302772f, -0.08212031f, 0.19897053f, 
    0.00404619f, 0.10244356f, -0.13259655f, 0.03149594f, 0.14255221f, -0.03327569f, 0.06857032f, 0.06788820f, 
    0.05300392f, -0.06357837f, 0.02715697f, -0.03353094f, -0.02136232f, 0.08199666f, -0.02772373f, -0.00754411f, 
    0.04562508f, 0.01382088f, 0.14315705f, 0.04874450f, -0.09167582f, 0.02134441f, 0.09188639f, 0.15078118f, 
    -0.03309399f, -0.04684422f, -0.09794634f, 0.13215235f, 0.35402519f, 0.24667114f, 0.18854426f, 0.23483206f, 
    -0.01015684f, 0.06543833f, -0.02807937f, 0.02249657f, -0.03139269f, -0.02631938f, 0.00643285f, 0.04215508f, 
    0.09490082f, 0.08238570f, -0.12296786f, 0.07337069f, -0.04859056f, 0.06454965f, 0.02653737f, 0.02425919f, 
    -0.02833016f, -0.01909470f, -0.02699959f, 0.03659014f, -0.11801690f, -0.11928143f, -0.35115209f, -0.35727373f, 
    -0.07833115f, -0.13725427f, -0.14473891f, 0.09096508f, -0.01179905f, 0.05505956f, 0.01685735f, 0.00252248f, 
    0.44946155f, -0.35996360f, -0.48009816f, -0.20929413f, -0.03118866f, -0.00598611f, -0.04105380f, -0.07564956f, 
    0.12239851f, 0.14856568f, 0.21568830f, -0.01174933f, -0.08597752f, -0.02457775f, -0.14491495f, -0.04393568f, 
    -0.01572631f, 0.26780275f, 0.17575675f, 0.04140347f, -0.13166904f, -0.01743209f, -0.12018668f, -0.07310801f, 
    0.07444616f, 0.16296761f, 0.25050995f, 0.30664232f, -0.02895792f, 0.05566250f, -0.05517955f, -0.02879418f, 
    0.07167966f, 0.00664375f, 0.11992377f, 0.20504884f, -0.08629912f, -0.42106402f, -0.47815830f, -0.24022725f, 
    -0.10310684f, 0.08739132f, 0.00242990f, -0.00509054f, 0.09235357f, 0.03788721f, 0.17109747f, 0.09027765f, 
    0.07381850f, 0.04005263f, 0.01363478f, 0.06476025f, 0.07691374f, 0.00878711f, -0.02953300f, 0.03680295f, 
    -0.01501096f, -0.05839999f, -0.04616114f, -0.17858568f, 0.61847073f, 0.11925436f, 0.13518672f, 0.12319631f, 
    0.04457618f, -0.03617422f, -0.00268624f, -0.04036903f, 0.17585862f, 0.26075304f, -0.07614710f, 0.06363922f, 
    0.00712897f, -0.22307743f, -0.48334685f, -0.33321208f, -0.02643542f, 0.01118611f, -0.06516191f, 0.19101389f, 
    0.03975702f, 0.07133614f, 0.08372844f, 0.09627876f, 0.09434801f, -0.02238434f, -0.23658882f, -0.47347358f, 
    -0.07428371f, -0.06652441f, -0.21477070f, -0.05877040f, -0.01031634f, -0.01449710f, -0.12495602f, -0.01534168f, 
    -0.16345623f, -0.52292228f, -0.62193859f, -0.33972001f, -0.05913483f, -0.01409048f, -0.16355126f, 0.02187605f, 
    -0.14103439f, -0.01899465f, -0.08105062f, -0.04928664f, -0.23274162f, -0.22117078f, 0.13249364f, -0.23251437f, 
    -0.07400152f, 0.17278279f, 0.18753794f, -0.14870764f, 0.11717953f, 0.04601676f, -0.01227551f, -0.13589290f, 
    -0.04931438f, 0.07554412f, 0.12850688f, -0.24931397f, 0.18283592f, 0.09366648f, 0.16087702f, 0.04236588f, 
    -0.16147082f, -0.00573962f, -0.09070731f, -0.06853656f, 0.26693052f, -0.34510913f, 0.12629993f, -0.22056210f, 
    0.16801426f, -0.22169270f, 0.02851439f, 0.00616963f, 0.32735619f, 0.01936948f, 0.10654991f, 0.08626830f, 
    -0.26150563f, -0.06090473f, -0.07634331f, 0.08515028f, 0.10168087f, 0.07593715f, -0.00088931f, 0.12187554f, 
    -0.11310958f, -0.08892419f, 0.03672008f, 0.05096161f, 0.13592958f, 0.13571864f, 0.04649687f, 0.24094148f, 
    0.03178963f, 0.01531329f, 0.00665451f, -0.06388380f, 0.13471663f, 0.08472799f, -0.00895967f, 0.02799921f, 
    0.01041851f, 0.01694460f, -0.01329605f, -0.16039065f, 0.02425120f, -0.06317003f, 0.00044993f, -0.03918827f, 
    -0.11174502f, -0.10489438f, -0.12446461f, -0.09256937f, 0.23246436f, 0.21527551f, -0.05062778f, 0.31432110f, 
    0.01569873f, 0.04054888f, -0.02892112f, 0.14814368f, -0.15351692f, -0.03606771f, -0.11613061f, -0.07249456f, 
    0.04362707f, 0.07445890f, 0.01513334f, 0.09560958f, 0.14455250f, -0.06856288f, 0.05871958f, -0.11253200f, 
    -0.08671844f, -0.01925800f, -0.14149740f, 0.01817900f, 0.31345874f, 0.04396258f, 0.02374527f, 0.33852649f, 
    -0.08482221f, 0.00193250f, 0.10841941f, 0.39445081f, 0.00740981f, 0.15003633f, 0.14557533f, 0.11085709f, 
    -0.04880733f, -0.14848170f, -0.09893403f, -0.06825808f, -0.01490847f, -0.14378248f, -0.02373442f, 0.17342441f, 
    0.15058558f, 0.07813823f, 0.04632477f, 0.12153633f, 0.16593228f, 0.11387792f, 0.20830894f, 0.01387221f, 
    -0.01145497f, 0.06822708f, -0.08737271f, 0.14418142f, 0.09445206f, -0.00716670f, 0.14918056f, 0.03837153f, 
    0.21637014f, 0.10447875f, 0.13239612f, 0.03880417f, 0.06490048f, -0.03861755f, 0.01594415f, 0.03170513f, 
    0.11922591f, 0.06736006f, -0.03831299f, -0.02209711f, 0.10447197f, -0.09573056f, 0.03142212f, 0.05423879f, 
    -0.11430933f, -0.03934610f, -0.06460669f, -0.01533263f, -0.07610310f, -0.14545512f, 0.01815643f, -0.02973082f, 
    0.26553157f, 0.02764178f, 0.06104251f, 0.01461690f, -0.05386814f, 0.06802980f, -0.00269947f, -0.08915260f, 
    0.04100807f, -0.10993389f, -0.07677145f, -0.05872360f, 0.08479578f, 0.16284552f, 0.05223651f, 0.19740508f, 
    0.03032492f, -0.11598825f, 0.06514291f, 0.09646810f, -0.04737988f, -0.00210097f, -0.00127823f, -0.04569827f, 
    0.08941887f, -0.03362051f, 0.08359349f, 0.08171292f, 0.16364469f, 0.11108622f, -0.04415772f, -0.06880908f, 
    -0.18656497f, 0.02842693f, -0.07200675f, -0.02585079f, 0.26014498f, 0.04065590f, -0.19970420f, -0.16544801f, 
    0.16831879f, 0.11523855f, 0.09833592f, 0.47963664f, -0.13749467f, -0.02966553f, -0.01185126f, -0.13891470f, 
    -0.04361157f, -0.00425362f, 0.08411925f, -0.14165173f, -0.02801739f, -0.09262539f, -0.12067235f, -0.13994090f, 
    -0.11592680f, -0.20919190f, -0.01549948f, -0.00493399f, 0.03227758f, 0.18317576f, -0.00213058f, 0.08905546f, 
    0.02632145f, -0.06964969f, -0.00704245f, 0.05623356f, -0.04786406f, 0.08053901f, -0.08732324f, 0.11195502f, 
    0.18522556f, -0.05238627f, -0.21080782f, -0.01042497f, 0.06406932f, 0.03468073f, 0.03813972f, 0.00733752f, 
    0.16272698f, -0.19805026f, -0.06414799f, 0.17078264f, 0.39787155f, 0.32262895f, -0.03728793f, 0.16416393f, 
    -0.00355152f, -0.08779030f, 0.02273576f, 0.11071675f, 0.07804530f, -0.06362643f, 0.09458740f, -0.00454667f, 
    -0.41013891f, 0.27627039f, 0.01987288f, -0.03328070f, 0.10534962f, -0.03834211f, 0.00999375f, 0.09838362f, 
    0.10298441f, 0.04205564f, -0.15858069f, -0.06135008f, 0.23553899f, 0.05218054f, 0.14024939f, 0.05373630f, 
    0.05643465f, -0.00287354f, -0.06042734f, 0.08792774f, 0.15225841f, 0.04372686f, -0.05085453f, -0.10345315f, 
    -0.17261882f, 0.16401960f, 0.09456021f, -0.10021133f, -0.13342419f, 0.03525167f, 0.25717363f, 0.11796473f, 
    0.18752086f, -0.08440218f, -0.05771994f, -0.24690029f, -0.20807748f, 0.08883218f, 0.09543279f, 0.10818933f, 
    0.06720854f, 0.08687574f, 0.12443916f, -0.13205600f, -0.08871038f, 0.00389321f, 0.00353111f, -0.06577252f, 
    0.07441444f, -0.36570275f, 0.00506335f, 0.00575189f, 0.05607935f, -0.06674200f, 0.01132411f, 0.05519773f, 
    0.13399048f, 0.16003391f, 0.01465217f, 0.01020893f, -0.00061871f, 0.21423216f, 0.21534380f, 0.19029342f, 
    0.08075280f, 0.00398966f, 0.11561452f, 0.07126495f, 0.11956069f, -0.03063577f, 0.01677296f, -0.00986431f, 
    0.01090713f, 0.14469980f, 0.03452037f, 0.08549223f, 0.03915890f, -0.05883482f, 0.02170422f, -0.04411107f, 
    -0.01674439f, -0.01828776f, -0.07933497f, 0.03891927f, 0.20345935f, 0.14142938f, -0.13022074f, -0.21777174f, 
    -0.03477435f, 0.05974793f, -0.03752791f, 0.11105053f, 0.05933705f, -0.04573328f, -0.18774952f, -0.06802503f, 
    -0.01124360f, 0.24844821f, 0.20199022f, 0.21007878f, -0.05466693f, -0.00278549f, 0.12431078f, 0.02646198f, 
    -0.00267255f, 0.09300967f, 0.04620871f, 0.04228197f, -0.03656197f, -0.15318404f, 0.16124372f, 0.15268900f, 
    -0.07308027f, 0.18791080f, 0.19359335f, 0.17516424f, 0.06209408f, 0.07617162f, -0.18718942f, -0.06640041f, 
    -0.04627968f, 0.20694694f, 0.09352153f, 0.18572456f, -0.06154044f, -0.05395546f, 0.04645670f, -0.06071503f, 
    -0.07228845f, -0.03356723f, 0.00330092f, 0.02360922f, 0.08200448f, -0.11825361f, 0.18860495f, 0.02257357f, 
    -0.15779348f, 0.30813468f, 0.06089407f, -0.17024158f, 0.12635209f, 0.00311621f, 0.00058928f, -0.07110581f, 
    -0.32285130f, -0.03725902f, 0.28130919f, 0.20591252f, -0.09970817f, -0.17821819f, -0.19948670f, 0.15390195f, 
    0.01799087f, -0.07705344f, -0.05793592f, -0.02505871f, 0.22984162f, -0.21250735f, -0.28898296f, -0.01825754f, 
    0.04786599f, 0.07658195f, 0.21914195f, -0.02922546f, 0.12922113f, -0.05942980f, 0.17324997f, -0.30901498f, 
    -0.07717180f, -0.18335086f, 0.07045925f, 0.22519735f, 0.19208783f, 0.10878489f, -0.02382443f, 0.02215289f, 
    0.05478488f, -0.04374478f, -0.00878789f, 0.00883547f, -0.03402787f, 0.04647694f, 0.07140496f, -0.08660174f, 
    0.06969612f, -0.00294774f, -0.00341418f, -0.00341345f, 0.04422148f, -0.07454884f, -0.06204252f, 0.11997375f, 
    -0.24853417f, -0.16968751f, -0.15219395f, 0.08707248f, -0.03248101f, 0.00089529f, 0.17082472f, 0.17667866f, 
    -0.02713659f, -0.01381830f, -0.08547626f, -0.13545918f, 0.37855619f, 0.13095009f, -0.12606049f, 0.04757049f, 
    0.06454496f, -0.14490634f, -0.15280040f, -0.03139040f, -0.00736801f, -0.01677820f, 0.01053714f, 0.08652636f, 
    0.15056761f, 0.01953377f, -0.02088387f, 0.05146354f, 0.00517829f, -0.02631241f, -0.19147618f, 0.02551579f, 
    -0.13489896f, -0.10446751f, -0.00301757f, 0.07960653f, 0.04909391f, 0.27776155f, 0.17738268f, 0.09564592f, 
    -0.00012276f, -0.09116735f, -0.07637336f, -0.07891283f, 0.13728151f, -0.00837409f, -0.01567346f, 0.17418559f, 
    -0.00230056f, 0.24393421f, 0.13807774f, 0.09117980f, -0.00641249f, -0.10260534f, 0.05612335f, 0.01724816f, 
    -0.02259965f, 0.04350101f, 0.05327596f, 0.04563909f, 0.08198611f, 0.15819532f, -0.13427474f, -0.14453898f, 
    -0.04125179f, -0.16162357f, -0.11080345f, 0.04536235f, 0.00051772f, -0.02766163f, -0.09387922f, -0.02925038f, 
    0.11158132f, 0.03226115f, -0.09801941f, 0.06564885f, -0.05320098f, 0.02638860f, 0.02796309f, 0.06470882f, 
    -0.01368694f, -0.06871166f, 0.00827371f, 0.00852371f, -0.06427215f, -0.13184562f, -0.19407503f, -0.14912885f, 
    0.09081587f, 0.01359660f, 0.00213259f, 0.01250307f, -0.01087878f, -0.25249994f, 0.06182353f, -0.01574993f, 
    0.04937925f, -0.09076010f, -0.11773377f, -0.07175408f, -0.02341601f, 0.13983594f, 0.03007884f, 0.04913218f, 
    -0.00032217f, 0.04645814f, 0.07402086f, 0.05495801f, 0.25552776f, 0.06824004f, 0.09672393f, 0.19438922f, 
    0.07700727f, 0.03200838f, -0.05489106f, 0.01443946f, 0.03040668f, 0.04522264f, 0.02182703f, 0.13516751f, 
    0.04170576f, -0.03314710f, 0.09231135f, 0.10373200f, -0.01642328f, 0.06342976f, -0.12576824f, -0.04834898f, 
    -0.02395956f, -0.01585621f, -0.08091082f, -0.02802150f, 0.07439241f, 0.22761992f, 0.27329588f, 0.03592965f, 
    0.04131877f, 0.05640813f, 0.06458806f, -0.03805346f, 0.04189526f, 0.00587939f, -0.01839388f, 0.03719572f, 
    0.06067159f, 0.01222209f, -0.09734829f, -0.02590022f, 0.06357688f, 0.06724988f, 0.02680176f, 0.03036742f, 
    0.18135647f, 0.06362063f, -0.15425521f, 0.38445544f, 0.14558928f, -0.18492703f, 0.12992810f, -0.32816482f, 
    -0.01300143f, 0.01892217f, -0.16212481f, -0.04229666f, -0.19221374f, 0.01499133f, -0.03281616f, -0.12602377f, 
    -0.08513048f, 0.10189262f, -0.00337221f, 0.04408116f, -0.13667877f, 0.00895770f, 0.12281844f, -0.01763734f, 
    0.09569894f, 0.20470151f, 0.07331537f, 0.24144197f, 0.00272942f, -0.20004699f, 0.21045260f, -0.05268971f, 
    0.05125450f, 0.10248206f, 0.02329362f, -0.16638215f, -0.01303896f, -0.09410543f, -0.08059196f, 0.12736334f, 
    0.60236895f, -0.21676722f, -0.24134113f, 0.32428819f, 0.00542071f, 0.02972121f, -0.06382985f, -0.08653352f, 
    -0.06625798f, -0.08263002f, 0.15961331f, 0.12006073f, -0.10815826f, -0.01061148f, 0.23993368f, -0.06196514f, 
    -0.09092966f, -0.03293487f, 0.03662965f, -0.00568071f, -0.04447040f, -0.01087048f, -0.20288889f, -0.05470859f, 
    0.53181481f, 0.07994547f, 0.12998122f, 0.37731636f, 0.12537603f, 0.03511460f, -0.02019775f, -0.09894928f, 
    0.09929087f, 0.05588119f, -0.03008158f, 0.11300011f, 0.19130890f, 0.27381995f, -0.15943421f, 0.25705767f, 
    0.01273646f, 0.12127522f, -0.02465812f, 0.07199795f, -0.07522804f, -0.28863221f, -0.21909066f, -0.28894931f, 
    0.06630876f, 0.33520374f, -0.16201961f, 0.06209269f, -0.00127607f, -0.06120573f, -0.21447620f, -0.08621096f, 
    -0.03584053f, 0.01159679f, -0.08066589f, -0.10147092f, 0.14155304f, -0.00004014f, -0.05304205f, 0.09805641f, 
    -0.14608836f, -0.00362029f, 0.01648683f, 0.12967241f, 0.13193597f, -0.03675428f, 0.02814894f, 0.15204284f, 
    -0.12319679f, -0.15167469f, 0.05677959f, -0.30952412f, -0.02942912f, 0.01051084f, -0.12833732f, -0.20366764f, 
    -0.19264920f, -0.17001307f, -0.23791553f, -0.23578140f, -0.15648542f, -0.09759060f, 0.03769675f, -0.15077372f, 
    0.19559690f, -0.17135079f, 0.13473754f, -0.12039164f, -0.10964288f, -0.00029161f, 0.05603491f, -0.09990513f, 
    -0.05814247f, -0.17767616f, -0.03628254f, 0.08615723f, -0.01948642f, -0.01309303f, -0.10260299f, 0.08338843f, 
    0.10491500f, -0.04218273f, 0.06988692f, 0.05692514f, 0.00740565f, -0.02968148f, 0.12252241f, -0.25455520f, 
    -0.07379343f, -0.08180264f, -0.08755064f, 0.02061795f, -0.09703366f, -0.10423730f, -0.13824712f, -0.18515188f, 
    0.14285286f, 0.04778345f, -0.10123228f, 0.05561781f, -0.22214577f, 0.04511134f, -0.05827505f, 0.06331657f, 
    -0.00536215f, -0.01659584f, -0.09334798f, 0.01722929f, 0.00330823f, 0.02859369f, 0.12102011f, 0.14631128f, 
    0.16127487f, -0.15811647f, -0.00633681f, 0.06613051f, -0.08220018f, 0.06358691f, 0.04444544f, -0.35028455f, 
    0.19893135f, -0.05171178f, 0.11758401f, -0.01035199f, -0.01691684f, 0.00434839f, -0.01478348f, -0.23949556f, 
    -0.06242210f, 0.02207327f, -0.12571554f, -0.08372938f, -0.42004141f, 0.16067491f, 0.37000963f, 0.06308343f, 
    0.07667046f, -0.10577960f, 0.12637585f, -0.04844197f, 0.01163613f, 0.04309361f, -0.08697105f, 0.03022669f, 
    0.16071381f, 0.10110907f, -0.03719715f, 0.17308734f, -0.15288889f, 0.14456213f, -0.03749290f, -0.10756883f, 
    0.08337111f, 0.00034863f, 0.03897565f, 0.37629431f, 0.07018068f, -0.10624676f, 0.12288182f, 0.07094181f, 
    -0.05909669f, -0.04999388f, -0.16732632f, -0.22783667f, 0.07682255f, 0.25506449f, 0.06262355f, 0.21088262f, 
    0.44951573f, -0.00040784f, 0.03088665f, 0.10583114f, 0.15582798f, 0.02264660f, -0.02120376f, 0.01410747f, 
    -0.03142194f, 0.02520401f, -0.10631324f, 0.11727565f, -0.49705842f, 0.33015808f, 0.11592292f, 0.34289309f, 
    0.25802559f, -0.00927806f, -0.05309799f, -0.06114481f, -0.08746633f, -0.18650389f, 0.02427644f, -0.27060953f, 
    -0.11729349f, 0.15219142f, -0.12907369f, -0.18573570f, 0.11551413f, -0.17509960f, 0.08776585f, 0.02175954f, 
    -0.02011695f, -0.03213185f, -0.17570898f, -0.17080116f, -0.02957569f, 0.09277439f, 0.24623834f, 0.18147960f, 
    -0.03703234f, 0.01922906f, 0.08165192f, 0.07635803f, 0.28680757f, 0.09032020f, 0.21376456f, -0.00047476f, 
    -0.25954482f, -0.15600830f, -0.01536604f, 0.03225532f, 0.00515705f, -0.03514471f, 0.05247052f, 0.14458023f, 
    0.17152882f, 0.09140851f, 0.06087407f, 0.12656352f, 0.01844340f, 0.02155635f, 0.34758273f, 0.00613989f, 
    0.09120302f, 0.05558962f, 0.00213327f, 0.04107456f, 0.27343774f, 0.04354246f, 0.00397245f, 0.20469145f, 
    -0.03279047f, -0.09087548f, -0.08191980f, -0.14249985f, 0.24865323f, -0.01855222f, -0.05456189f, -0.10495672f, 
    0.17197028f, -0.05692034f, -0.00724366f, -0.11611166f, 0.27400154f, 0.24514559f, 0.12718676f, 0.32310009f, 
    0.02302150f, 0.04041221f, 0.05874362f, -0.20957623f, 0.17442386f, -0.08915245f, 0.01089713f, 0.09444760f, 
    -0.06567360f, -0.16393156f, 0.11641062f, 0.00689615f, -0.10209692f, -0.08384589f, 0.02045289f, -0.26332289f, 
    0.08740989f, 0.15975623f, 0.13079186f, 0.25268978f, -0.22645834f, 0.14744399f, -0.13380052f, 0.05345419f, 
    0.15638936f, 0.04639261f, -0.02563302f, -0.21889094f, -0.08323992f, -0.16180974f, 0.16083895f, -0.10744759f, 
    -0.01956719f, -0.21189293f, 0.11408622f, -0.09413617f, 0.08498829f, -0.07230397f, -0.15907209f, -0.08216769f, 
    -0.18696910f, -0.28003830f, -0.20512360f, -0.57300198f, 0.16217074f, 0.07950838f, 0.01453086f, 0.21017805f, 
    -0.00680407f, 0.03905006f, 0.12082841f, 0.24370478f, 0.13177349f, -0.00453754f, -0.12668855f, -0.19875666f, 
    -0.05087734f, -0.04990100f, -0.00759258f, -0.00571508f, 0.03412656f, 0.02391871f, 0.04137347f, -0.03333356f, 
    0.00797347f, 0.01981220f, 0.01037680f, -0.01273980f, 0.00653183f, -0.01738848f, 0.02158015f, -0.05054827f, 
    0.03616459f, -0.05616618f, 0.01858484f, 0.03297026f, -0.01641986f, -0.02196435f, -0.01759604f, -0.04735647f, 
    0.00465865f, 0.00072159f, -0.03374823f, 0.04263816f, -0.05045288f, -0.02168159f, -0.01449241f, 0.01187111f, 
    -0.04714462f, -0.01215653f, 0.00044860f, -0.02177795f, -0.02519952f, -0.03415186f, 0.03591652f, 0.05002040f, 
    -0.00481192f, 0.02550795f, -0.02948638f, -0.02318654f, 0.01052536f, -0.02634377f, -0.00820692f, -0.05431480f, 
    0.02401941f, 0.03939885f, 0.02961277f, -0.05363479f, 0.02403966f, -0.01364515f, -0.01701511f, 0.00285267f, 
    -0.05048040f, 0.02425796f, -0.02171027f, 0.03366663f, 0.03803401f, 0.02021533f, 0.00482320f, 0.01145668f, 
    -0.02106898f, -0.04410114f, -0.00157547f, 0.00086626f, 0.00982763f, -0.01837746f, 0.02456512f, 0.01174462f, 
    0.03080811f, 0.01004145f, -0.03835839f, -0.00019417f, -0.04703277f, 0.02019018f, -0.02208549f, -0.01620452f, 
    -0.02543612f, 0.01062717f, -0.01999559f, 0.01948009f, 0.00106786f, 0.03095390f, -0.03194448f, -0.03016447f, 
    -0.00524091f, 0.03477606f, 0.04027328f, -0.03121393f, -0.00502203f, 0.02324440f, -0.02677462f, 0.00390816f, 
    -0.04744068f, -0.03443167f, -0.04912863f, -0.05517587f, -0.04141961f, -0.05527131f, -0.01437301f, -0.04108773f, 
    0.04285216f, 0.02341385f, -0.00968295f, 0.02891565f, 0.03980542f, -0.03522282f, -0.01333753f, -0.00356799f, 
    -0.03883249f, -0.02355915f, -0.00314633f, -0.00725274f, -0.00656547f, -0.00830370f, -0.05306888f, 0.04128665f, 
    -0.00469244f, -0.02402517f, 0.04118127f, 0.03777593f, 0.01032829f, -0.02799664f, -0.01909355f, -0.04942883f, 
    -0.03178885f, 0.01636855f, 0.03018123f, 0.01165464f, -0.01454899f, -0.01107182f, -0.04934822f, -0.03891241f, 
    0.00135109f, 0.02050185f, 0.00552709f, 0.00724596f, 0.00842866f, 0.03835071f, -0.03053766f, 0.01232182f, 
    0.02155878f, -0.01984355f, 0.03321859f, 0.03569658f, -0.03373701f, 0.01328716f, -0.04552403f, -0.04830224f, 
    -0.01889077f, -0.02237852f, -0.00905819f, 0.00942121f, -0.05343129f, 0.02892229f, -0.05020298f, 0.04675383f, 
    -0.04384189f, -0.02962110f, 0.02540771f, 0.04218029f, -0.00644678f, -0.04691716f, 0.01503888f, -0.02570437f, 
    -0.01488183f, 0.01638060f, 0.03483303f, -0.01598430f, 0.01426918f, -0.02766827f, -0.00533032f, -0.05422363f, 
    -0.01775416f, -0.05792928f, 0.01899878f, -0.02836035f, -0.03161760f, 0.04680623f, -0.04382547f, -0.05043524f, 
    -0.02761099f, -0.00408246f, 0.03162188f, 0.00605353f, 0.04007604f, 0.01558580f, -0.00802965f, 0.00272407f, 
    0.03860740f, 0.00644328f, -0.04182969f, -0.03330607f, 0.00957415f, 0.01486566f, -0.03505459f, 0.01177923f, 
    0.00345753f, -0.03278987f, -0.00655653f, -0.03438754f, -0.00621933f, -0.05522419f, 0.01549232f, 0.04300578f, 
    0.00177525f, -0.01155915f, 0.00215421f, -0.01023206f, -0.00854943f, -0.01724222f, 0.04121026f, 0.00357783f, 
    -0.00455464f, 0.03929988f, 0.03830885f, 0.02370749f, 0.03103071f, -0.03414006f, -0.01784357f, 0.03867431f, 
    0.02876825f, -0.04914737f, -0.03912266f, -0.01138206f, -0.01755128f, 0.02725161f, 0.00018598f, -0.02724036f, 
    0.03439905f, -0.01270822f, 0.01472513f, 0.00016939f, -0.03259406f, 0.01384884f, -0.00978447f, 0.03730733f, 
    -0.03027274f, -0.00713793f, 0.03816743f, 0.01062772f, 0.03957764f, 0.03231712f, -0.02385934f, -0.00552155f, 
    -0.00364995f, -0.05054618f, -0.04355004f, -0.02171279f, -0.00711443f, 0.02599389f, 0.04439110f, 0.02706586f, 
    -0.01966522f, -0.03054267f, 0.01795697f, -0.02063096f, -0.02949665f, 0.04233896f, -0.00363435f, -0.02172753f, 
    0.04069751f, -0.03546486f, 0.01571047f, -0.00360778f, -0.05742930f, -0.00995383f, -0.03060238f, -0.03585959f, 
    -0.03936801f, 0.04001675f, -0.04385797f, 0.00313294f, 0.00569818f, -0.01920344f, -0.05045786f, 0.00781018f, 
    0.05196364f, -0.03752301f, -0.03570749f, 0.00260358f, -0.00662143f, 0.02993881f, -0.02439884f, 0.02541130f, 
    -0.03699875f, 0.02913370f, -0.05299271f, -0.03163656f, -0.03412775f, -0.05128387f, -0.02660229f, -0.01362369f, 
    0.00480069f, -0.03527440f, -0.00705146f, -0.02662834f, 0.00422254f, -0.04128382f, -0.04940290f, 0.04768553f, 
    0.03054390f, -0.05195545f, 0.00139710f, -0.01612556f, -0.03043122f, -0.04692453f, 0.02568363f, 0.03403450f, 
    0.04953591f, -0.03001945f, 0.03219876f, 0.04307426f, -0.05763416f, -0.02479783f, -0.05449232f, -0.00598796f, 
    0.01030377f, 0.04255903f, -0.03891310f, -0.01870947f, -0.00148767f, -0.00540241f, -0.00819373f, -0.00051458f, 
    0.04030493f, 0.03384382f, -0.02577053f, 0.02860877f, -0.04524106f, -0.02759836f, 0.03291112f, -0.05296344f, 
    -0.01763729f, 0.05013086f, 0.02033254f, 0.00918650f, -0.01806980f, -0.01802531f, -0.00962845f, -0.05205147f, 
    0.00146636f, -0.01244370f, -0.00554928f, 0.02638829f, -0.00815342f, 0.00934048f, -0.05191122f, -0.01975874f, 
    0.03934423f, -0.00511741f, -0.03108661f, 0.04143907f, -0.05515679f, 0.01521598f, 0.01812845f, -0.01155436f, 
    0.03007901f, 0.00369274f, 0.02315348f, 0.04481827f, -0.01555647f, 0.02666759f, 0.01601523f, 0.01373201f, 
    0.04383178f, -0.04707316f, -0.04623669f, -0.05231104f, 0.02373533f, 0.00043473f, -0.01520553f, 0.02187597f, 
    -0.05116806f, -0.03549187f, 0.00339273f, 0.02937988f, -0.01748152f, 0.01473074f, -0.04174941f, 0.03426748f, 
    -0.04101774f, -0.05978379f, -0.12679633f, 0.04838371f, 0.18681514f, 0.19556715f, 0.21037138f, 0.03604195f, 
    -0.06594286f, -0.01911311f, -0.03540140f, 0.02112310f, 0.22917841f, 0.16556697f, 0.02022583f, -0.01481611f, 
    -0.01069799f, 0.01793225f, 0.02482844f, -0.00704231f, 0.01726908f, -0.05579372f, 0.01578541f, -0.01064181f, 
    -0.04080151f, -0.04333328f, 0.01564076f, -0.09520891f, -0.08411100f, 0.01210354f, 0.00124109f, 0.02757132f, 
    0.12374994f, 0.08694241f, 0.09270975f, -0.08208930f, 0.41839907f, 0.40500510f, 0.21987890f, 0.23425958f, 
    -0.03892392f, -0.03812401f, 0.00404038f, -0.07261099f, -0.06812940f, 0.05164059f, 0.00230177f, 0.00871133f, 
    -0.26921275f, -0.10085313f, -0.20161460f, -0.20993513f, -0.05309625f, -0.00881531f, -0.03091517f, -0.05034351f, 
    0.05846220f, 0.10527290f, 0.10981381f, 0.02942883f, 0.16700076f, -0.12182784f, -0.09657649f, 0.06333249f, 
    -0.04768834f, 0.04382691f, 0.04715737f, 0.07633757f, 0.02035370f, -0.02834084f, 0.14776562f, 0.00763626f, 
    -0.05617246f, -0.36548534f, -0.36485311f, -0.17302436f, -0.12454727f, -0.05886076f, -0.06434181f, 0.14688300f, 
    0.04257871f, 0.06985381f, 0.04280231f, 0.06464455f, 0.09878266f, -0.11940921f, -0.32385239f, 0.00368157f, 
    0.03709672f, -0.04502880f, -0.07722617f, 0.00232636f, -0.08650652f, 0.00756055f, -0.02143188f, -0.09914170f, 
    0.26609620f, 0.06251071f, 0.12758145f, 0.05036054f, 0.00701226f, 0.04558387f, 0.06707252f, -0.11745404f, 
    0.16999421f, 0.03391328f, 0.03489317f, 0.29425630f, -0.12151429f, -0.22424047f, -0.42697683f, -0.19407184f, 
    0.02367510f, -0.04489529f, 0.10214180f, -0.07111979f, -0.12037396f, 0.06489138f, -0.05646962f, -0.11190943f, 
    0.08760777f, 0.12596725f, -0.04139534f, 0.06042636f, 0.11720417f, 0.14483184f, 0.05595197f, 0.01278778f, 
    -0.00470691f, 0.00109905f, 0.07863518f, -0.10101222f, 0.27359155f, -0.02793977f, 0.18575133f, 0.17927994f, 
    0.01077716f, -0.05308126f, -0.02639228f, 0.09749234f, 0.00374874f, 0.30066690f, 0.04684459f, 0.11878975f, 
    0.11562341f, -0.00504944f, -0.42194358f, 0.05075888f, 0.01865028f, -0.10620602f, 0.07832149f, 0.05513769f, 
    -0.04527893f, 0.00856457f, -0.02057272f, -0.05332883f, 0.16763444f, -0.08959389f, -0.27572680f, 0.31509194f, 
    -0.07506392f, 0.22811058f, 0.10572648f, 0.20247187f, -0.01064146f, -0.03361926f, -0.03021197f, 0.13507758f, 
    -0.25415227f, -0.08867206f, -0.30311736f, -0.10524163f, 0.13564298f, -0.24343163f, 0.13426276f, 0.03979916f, 
    -0.06191514f, 0.03639662f, 0.00655229f, -0.14460008f, 0.20191465f, -0.20523733f, 0.04285368f, -0.17451686f, 
    0.27562660f, -0.01349868f, -0.10550871f, 0.03998082f, -0.08431350f, 0.03608687f, 0.01486473f, 0.01514660f, 
    0.34754995f, 0.09263552f, -0.04809558f, 0.05751716f, 0.05842087f, 0.05494059f, 0.03743832f, 0.11509106f, 
    -0.09702086f, -0.10398740f, -0.00898626f, -0.07814775f, -0.07104053f, 0.02566414f, 0.12925677f, -0.03208685f, 
    -0.10742099f, 0.00617781f, 0.13121316f, -0.02899508f, -0.00728570f, 0.18940690f, -0.01692121f, -0.12712124f, 
    -0.04127049f, -0.27979001f, -0.14949426f, -0.14393084f, 0.20412384f, 0.09521914f, 0.08826229f, -0.10407636f, 
    0.13684195f, -0.01264406f, 0.18660326f, 0.06648121f, 0.03263954f, 0.13772064f, -0.02195443f, 0.23754925f, 
    0.02050693f, 0.00487519f, -0.03405530f, -0.05955838f, 0.03557109f, 0.25888136f, 0.17571625f, -0.01409978f, 
    0.12342583f, -0.10543321f, -0.17179783f, -0.13979793f, -0.05209406f, -0.03332047f, 0.08796533f, 0.16483210f, 
    0.06639963f, -0.06369353f, -0.06196719f, -0.02569425f, 0.13451248f, 0.25373814f, 0.26368904f, 0.26792413f, 
    -0.09636715f, -0.13997012f, 0.09870597f, 0.03260362f, -0.05412865f, 0.03180210f, 0.01521802f, -0.04725786f, 
    0.06324298f, 0.04165610f, 0.10081218f, -0.00976265f, 0.01886314f, 0.16003579f, 0.06311239f, -0.00596215f, 
    0.05319032f, 0.06648663f, -0.03705538f, -0.04699922f, 0.00114961f, -0.40728071f, 0.06537198f, -0.00443795f, 
    -0.09897935f, -0.06901518f, -0.00459689f, 0.08910305f, 0.00647858f, 0.04968080f, 0.11691036f, 0.04218444f, 
    0.02116034f, -0.04580680f, -0.13931499f, 0.06637975f, 0.04885703f, 0.01015078f, -0.01089418f, -0.01986823f, 
    -0.03197569f, 0.01429758f, -0.07180193f, -0.05559035f, 0.09046129f, 0.10491743f, 0.07532472f, 0.20693843f, 
    -0.03349067f, 0.08135892f, 0.11054818f, 0.07722200f, -0.05263454f, -0.03238375f, 0.03896360f, 0.18280561f, 
    0.04388598f, 0.10206956f, 0.10456315f, -0.05689777f, -0.05240838f, 0.05749355f, -0.00104532f, -0.03857503f, 
    0.09306233f, 0.18015096f, 0.00477204f, 0.16165112f, -0.28804550f, -0.14474769f, -0.02284086f, -0.05260884f, 
    -0.12466491f, 0.03341943f, -0.04176864f, -0.00042365f, 0.01542212f, -0.01352171f, -0.06383099f, -0.08706549f, 
    -0.04278034f, -0.18265533f, -0.00346230f, -0.00949113f, -0.04405836f, 0.00666200f, 0.00449011f, -0.05455193f, 
    -0.03929968f, 0.10816428f, -0.01907491f, 0.06326576f, 0.35140282f, 0.21791981f, 0.23711196f, 0.12441663f, 
    0.01095878f, -0.08515202f, -0.03154524f, 0.08294507f, -0.01791018f, -0.00600958f, 0.00426995f, -0.01113221f, 
    0.02887032f, 0.05633757f, 0.10148938f, 0.01220565f, 0.23650952f, 0.05016544f, -0.07097793f, 0.01337800f, 
    -0.12015025f, 0.05491359f, 0.03323840f, -0.05051835f, -0.07250652f, 0.03384295f, 0.06720800f, -0.24535483f, 
    0.00415234f, -0.19467446f, -0.21281536f, 0.05555323f, -0.16514648f, -0.14624774f, -0.11119407f, -0.02157485f, 
    0.10944683f, -0.00149010f, 0.03286528f, -0.23313355f, 0.07790963f, 0.03880990f, 0.02789259f, 0.17449628f, 
    0.15003459f, 0.16592720f, 0.11898091f, 0.42248169f, 0.24462655f, 0.19743611f, -0.02435151f, 0.12376118f, 
    0.16873744f, 0.15336998f, 0.05508400f, -0.03318593f, -0.05200473f, -0.09748252f, -0.03800531f, -0.01743642f, 
    0.02267768f, 0.06596155f, -0.28641149f, -0.09520866f, -0.01623205f, -0.03684686f, -0.02114797f, -0.03081333f, 
    0.18361746f, 0.13062988f, 0.27226600f, 0.28579700f, 0.25646830f, -0.15284218f, -0.09236070f, 0.30654642f, 
    0.02459174f, 0.06222738f, 0.02251456f, 0.20664413f, -0.03429837f, -0.17277770f, -0.11634176f, -0.06220838f, 
    -0.23555884f, 0.14179912f, -0.01284695f, -0.30377734f, -0.03489561f, 0.06097496f, 0.01841789f, 0.02682937f, 
    0.06808434f, 0.06338686f, 0.07037947f, 0.18339208f, 0.09975675f, -0.08532110f, -0.19570680f, 0.03351199f, 
    0.03019614f, 0.02461631f, 0.09693768f, -0.04861049f, 0.11132939f, 0.03367690f, -0.11668288f, 0.04354084f, 
    0.08500130f, 0.46183282f, 0.15596320f, 0.33681151f, 0.01020823f, -0.09169182f, -0.01634374f, -0.03872894f, 
    -0.19517110f, -0.03213729f, 0.00835970f, -0.03667314f, -0.06417985f, 0.21571591f, -0.23055553f, -0.01846327f, 
    0.20020610f, 0.11592744f, 0.14958672f, -0.07680325f, -0.19535804f, -0.25162539f, -0.41984829f, -0.26037765f, 
    -0.01223549f, -0.07890206f, 0.20452647f, 0.27945262f, 0.17691652f, 0.01114793f, -0.06482223f, 0.01722560f, 
    0.07252021f, 0.05560715f, 0.07610218f, 0.05588902f, 0.03790072f, 0.27724472f, -0.00253213f, 0.01886351f, 
    -0.16016626f, -0.10149156f, 0.02152316f, -0.06372999f, 0.07587443f, 0.02951436f, 0.02393533f, 0.10160413f, 
    -0.02923403f, 0.11552061f, -0.16352695f, 0.11692244f, 0.11840165f, 0.05421589f, 0.01770217f, -0.08759575f, 
    -0.08391759f, -0.04707708f, -0.17184274f, -0.12529254f, -0.18796195f, -0.17801988f, -0.10893246f, 0.02192209f, 
    -0.03494206f, 0.10779861f, -0.17990813f, 0.15532777f, -0.18291692f, 0.03275565f, -0.18741886f, -0.07709271f, 
    -0.05386450f, 0.05494318f, -0.11277229f, 0.08077542f, -0.00355613f, 0.10577018f, 0.00198518f, -0.12246079f, 
    -0.02549089f, 0.07241579f, 0.05712779f, 0.09251968f, -0.03707111f, -0.26616189f, 0.19163086f, 0.11331712f, 
    0.01550432f, 0.03018075f, -0.13052741f, 0.07398647f, -0.12191432f, 0.14583133f, -0.13709590f, -0.04702863f, 
    0.07976527f, 0.20003577f, -0.01944208f, -0.17384620f, -0.04784969f, -0.21385537f, 0.01420927f, 0.01959272f, 
    -0.07572187f, 0.01389583f, -0.00141938f, 0.00437912f, 0.25029722f, 0.12174479f, 0.48621517f, -0.21540710f, 
    0.06450272f, -0.00540047f, -0.05975454f, 0.20552611f, -0.00089755f, -0.08058043f, 0.05670163f, -0.21760361f, 
    -0.25996214f, 0.09584004f, -0.00704394f, 0.13848212f, 0.24930756f, 0.01724968f, -0.02853164f, 0.03730622f, 
    -0.07894487f, -0.03235403f, -0.04059898f, 0.01329657f, 0.01096262f, 0.01777973f, 0.23733945f, -0.22976965f, 
    0.00351749f, -0.11002839f, -0.00849951f, 0.13572297f, 0.11315452f, 0.23067398f, 0.07614083f, 0.10799803f, 
    -0.19152164f, -0.01745925f, -0.01169894f, 0.04287257f, 0.00321221f, -0.00695933f, 0.06258452f, -0.21069218f, 
    0.18800651f, 0.02959116f, 0.12901403f, 0.25632712f, -0.07780190f, 0.17254223f, -0.02015281f, 0.21760572f, 
    0.05137622f, -0.08308958f, -0.12648001f, -0.15241395f, 0.07514362f, 0.20442203f, 0.07634509f, 0.36612105f, 
    -0.15214314f, 0.17303446f, 0.21807794f, 0.16941619f, 0.01644038f, 0.01589220f, 0.07288415f, -0.03733030f, 
    -0.01335800f, 0.09510047f, 0.05647051f, -0.03793763f, 0.19265123f, -0.05040785f, -0.05316460f, 0.01491921f, 
    0.02128141f, 0.19982973f, 0.00846310f, 0.07900053f, -0.07538780f, -0.08123548f, -0.06208390f, -0.18070777f, 
    0.15076615f, 0.00033229f, 0.01248266f, -0.04098897f, -0.06753492f, 0.34691978f, -0.15602458f, 0.21273677f, 
    -0.08960053f, -0.01050106f, -0.12734072f, -0.11527018f, 0.15277570f, 0.17286466f, -0.03046679f, -0.04323886f, 
    -0.06271265f, 0.01299957f, -0.09910255f, -0.11856165f, 0.04533162f, 0.14690244f, 0.11125732f, 0.13047977f, 
    -0.03743327f, 0.19911797f, -0.04903471f, 0.00873080f, 0.16331129f, 0.14938487f, 0.12906808f, 0.02110073f, 
    -0.01164472f, 0.11710966f, 0.13660929f, 0.08663999f, 0.05228199f, -0.16434777f, -0.11322292f, 0.03275135f, 
    -0.08554514f, 0.10511448f, 0.10419691f, 0.12597969f, 0.16651638f, -0.00231200f, -0.01693424f, 0.24771047f, 
    -0.00878154f, -0.03392074f, -0.04522748f, 0.06119190f, 0.02953942f, 0.14333874f, -0.09566847f, 0.26324645f, 
    0.15071841f, -0.01465414f, 0.17921449f, -0.11332238f, 0.10514744f, -0.04363034f, -0.09653702f, -0.09324209f, 
    -0.07003301f, -0.09806448f, 0.06012918f, -0.15668613f, 0.00105649f, -0.18531349f, -0.05757445f, 0.13943981f, 
    -0.16170976f, -0.01602181f, 0.00905147f, 0.10101202f, -0.10729029f, -0.00989728f, -0.02471565f, -0.15052465f, 
    0.11915837f, 0.18417382f, 0.18307526f, 0.35432661f, 0.50183922f, 0.01906444f, -0.10749198f, 0.02013857f, 
    -0.01992892f, 0.27788883f, 0.05708249f, 0.01926570f, -0.07212430f, -0.01881470f, -0.00115592f, 0.00132606f, 
    -0.03909534f, -0.03409167f, 0.19045934f, 0.18676445f, 0.14844392f, 0.02081179f, 0.00441392f, -0.02537672f, 
    -0.09777907f, -0.14070442f, -0.18143862f, -0.39509320f, 0.32803726f, 0.19158217f, 0.14334041f, -0.11418463f, 
    -0.01884405f, 0.12282134f, -0.05796691f, 0.10380919f, 0.00749577f, 0.09135859f, -0.07306658f, -0.13798934f, 
    -0.03049736f, -0.09732842f, 0.14235066f, -0.10674893f, 0.21986778f, 0.11351670f, 0.12913097f, 0.00369373f, 
    -0.04442365f, -0.06790241f, -0.04972068f, -0.14020881f, 0.02276747f, 0.17881516f, -0.11293805f, -0.12334130f, 
    -0.12616742f, -0.21296319f, 0.00225573f, -0.10772325f, 0.00392028f, 0.12073535f, -0.00678430f, -0.06981426f, 
    -0.13563432f, -0.18039992f, 0.27642235f, 0.13677856f, 0.05042179f, 0.07613871f, -0.11896697f, -0.01404403f, 
    -0.11329565f, -0.19607846f, -0.17618477f, -0.06007159f, 0.11153310f, 0.29557723f, 0.32362869f, 0.18245193f, 
    -0.09061435f, -0.10754927f, -0.13247493f, -0.08632136f, -0.02070503f, -0.03761091f, 0.00043281f, -0.04099094f, 
    -0.18919355f, 0.40458962f, 0.14817183f, 0.10225089f, -0.00890866f, 0.12348124f, 0.03540304f, 0.12784915f, 
    0.02375397f, -0.01924000f, -0.12887175f, -0.07508199f, 0.31264189f, 0.25864801f, 0.05984183f, -0.24701385f, 
    0.08272243f, 0.09257390f, 0.07567330f, 0.17099799f, 0.14281599f, 0.10877777f, 0.00320484f, 0.01411383f, 
    0.08912546f, -0.06640148f, -0.36441800f, -0.30139545f, -0.10883248f, 0.04328842f, 0.02756781f, 0.03785494f, 
    0.15076701f, 0.06263849f, 0.05996088f, -0.12504914f, -0.10383213f, -0.12137190f, 0.17232497f, -0.12758505f, 
    0.04066508f, 0.12829584f, 0.13994329f, 0.30430514f, -0.00967848f, 0.13031656f, 0.07780787f, 0.04090744f, 
    0.18567687f, -0.06432827f, -0.09843754f, 0.14620392f, -0.06234968f, -0.01038018f, -0.02639436f, -0.00048418f, 
    0.19144025f, 0.14829448f, 0.05402561f, 0.04595647f, 0.20479034f, 0.19681479f, 0.06611343f, 0.10033041f, 
    0.19869420f, 0.14124075f, 0.07984514f, 0.06554390f, -0.01253995f, -0.05920364f, -0.04242814f, -0.05459549f, 
    -0.06523877f, 0.04107190f, 0.03428268f, -0.01524150f, -0.08380571f, -0.04779538f, -0.04235243f, 0.03102010f, 
    -0.03520733f, 0.09027968f, 0.05034177f, -0.02671979f, 0.33677652f, 0.18664956f, 0.02523663f, 0.38557842f, 
    -0.08662572f, -0.02753266f, -0.00129991f, -0.09746446f, 0.20440659f, 0.08503714f, -0.02864397f, 0.10819370f, 
    0.36688995f, 0.30533743f, 0.16686954f, -0.12618691f, 0.16509183f, 0.11569829f, 0.17417812f, 0.26637003f, 
    0.11186367f, -0.05227685f, -0.08404817f, 0.01544885f, 0.27922985f, 0.06837929f, -0.11115471f, -0.02423629f, 
    0.09850544f, 0.05208953f, 0.29706505f, 0.20495975f, 0.10799804f, 0.01385735f, 0.04151206f, 0.03674097f, 
    0.04236876f, 0.12732743f, 0.27719593f, -0.04219341f, 0.06778416f, 0.38438684f, 0.00834609f, 0.10123692f, 
    0.07275449f, -0.00790678f, 0.08818034f, 0.05118788f, -0.10624740f, -0.19369836f, -0.07713614f, 0.03805056f, 
    -0.09688265f, 0.34919557f, 0.20215584f, -0.27175561f, -0.01987709f, 0.15281287f, 0.08573976f, 0.09506586f, 
    -0.11122603f, 0.19801542f, 0.10791875f, -0.27641368f, -0.02857834f, -0.03828723f, 0.04101612f, 0.21714266f, 
    0.02120284f, 0.00029674f, 0.02936457f, -0.02006719f, 0.16771156f, -0.14248392f, -0.37429255f, 0.03770819f, 
    0.00019001f, -0.11548716f, 0.15371461f, 0.16016710f, -0.03299221f, 0.00819527f, 0.22700131f, -0.02177074f, 
    0.15362859f, 0.07812823f, 0.16766538f, 0.14470884f, 0.24533065f, 0.04739020f, -0.06238437f, 0.32155663f, 
    -0.09572810f, -0.07986347f, -0.10846305f, -0.23167360f, -0.06294338f, 0.16288064f, 0.12206575f, 0.11050370f, 
    0.03259765f, 0.02853114f, 0.05875593f, 0.02864467f, -0.05334440f, -0.14356452f, 0.01131834f, -0.10712861f, 
    0.02316582f, -0.04546501f, -0.23957862f, -0.22679399f, -0.03732421f, -0.10281454f, -0.06104479f, -0.06907748f, 
    0.08571108f, 0.08707751f, 0.03594101f, -0.12712455f, 0.09788311f, -0.03948054f, 0.07789370f, -0.21237405f, 
    -0.06062396f, -0.08567563f, -0.09752983f, 0.01896252f, -0.05525978f, 0.04998893f, -0.05412742f, 0.11755846f, 
    0.03830989f, 0.04136474f, -0.07927335f, -0.02371949f, -0.10307325f, -0.02193989f, 0.03668702f, -0.06602702f, 
    -0.04637318f, -0.13125743f, 0.02231919f, 0.20565915f, 0.16360460f, 0.04771404f, -0.13369748f, -0.04904928f, 
    0.00676036f, -0.02519833f, 0.08450393f, 0.06874675f, -0.06219101f, -0.01824202f, -0.10069732f, -0.09410168f, 
    0.30477649f, 0.27973101f, 0.17839167f, -0.14156917f, 0.03307357f, -0.01558302f, 0.01873282f, 0.15380433f, 
    0.03260448f, 0.00256844f, -0.22871174f, -0.04338432f, 0.15882345f, 0.20993277f, -0.14754076f, -0.17808983f, 
    -0.13053307f, -0.22742261f, -0.01382147f, 0.10553429f, -0.20265312f, 0.03944131f, -0.07673255f, -0.20709515f, 
    0.14977059f, 0.01110174f, -0.16026051f, 0.10448802f, -0.15624869f, -0.04588702f, 0.01808252f, -0.05939845f, 
    -0.03424769f, 0.00892261f, 0.01915041f, -0.00429023f, -0.06222778f, -0.29919186f, -0.10178420f, -0.06944513f, 
    0.03141449f, -0.04194931f, 0.03487494f, 0.13795733f, -0.00449780f, -0.04111613f, -0.09445099f, 0.04408755f, 
    0.00986016f, -0.05962495f, -0.11131633f, 0.14231190f, 0.02082131f, 0.01038002f, -0.01831643f, -0.02411942f, 
    -0.02666676f, 0.06321765f, -0.00063554f, -0.11795353f, 0.07306506f, 0.10261357f, 0.19862421f, 0.08478393f, 
    -0.09038682f, -0.12245303f, -0.14957422f, 0.04204436f, -0.00895300f, 0.11469062f, -0.05845250f, -0.03897044f, 
    -0.06134800f, -0.01522051f, -0.02473869f, 0.00582752f, -0.05809255f, 0.10048625f, 0.08354510f, 0.00224538f, 
    -0.10291738f, 0.09147158f, 0.07207602f, 0.10135590f, 0.11594410f, -0.03543104f, -0.00144939f, -0.18411945f, 
    0.13680863f, 0.08363483f, 0.08298276f, -0.02440361f, -0.11304924f, -0.06076903f, 0.06488498f, 0.01701243f, 
    -0.08408716f, -0.02137557f, -0.09514534f, 0.15745275f, 0.02883245f, -0.00525987f, 0.10011797f, 0.13065721f, 
    0.12367634f, 0.04681524f, 0.03348425f, 0.22208644f, 0.04853641f, -0.19333719f, -0.03967179f, -0.22341008f, 
    -0.01770399f, -0.02468510f, -0.14790329f, 0.05998487f, -0.12689388f, 0.05730094f, -0.03558042f, -0.14746274f, 
    -0.00077534f, 0.00017189f, -0.12167031f, 0.10296536f, -0.17301039f, 0.02586435f, 0.18979016f, -0.00497684f, 
    0.05963381f, 0.21014893f, -0.03011292f, 0.11962466f, -0.02199366f, -0.28907230f, 0.11597972f, -0.07618351f, 
    0.00861773f, 0.15431823f, 0.00715925f, -0.03287748f, -0.04164176f, 0.04067241f, -0.05766306f, 0.05476385f, 
    0.44644049f, -0.11967555f, -0.00157941f, 0.29047805f, -0.01189177f, -0.09780872f, -0.05258935f, -0.17891447f, 
    -0.02497486f, -0.07950233f, 0.14950848f, 0.06966045f, -0.20164630f, 0.02829489f, 0.22770829f, 0.10032630f, 
    -0.12972841f, 0.00083073f, 0.04243962f, -0.00573599f, -0.04480985f, 0.08157243f, -0.08649483f, -0.00252973f, 
    0.19203651f, -0.05428740f, 0.25069812f, 0.30537903f, 0.09715641f, -0.03552483f, -0.05578309f, 0.10071342f, 
    0.15607464f, 0.04894359f, 0.00385278f, 0.11718994f, 0.09322844f, -0.02525230f, -0.06044488f, 0.18820274f, 
    0.00685826f, 0.02538302f, -0.08946524f, 0.02241371f, -0.20317785f, -0.19676509f, -0.16398725f, -0.22247873f, 
    -0.05262788f, 0.44947344f, -0.29729292f, 0.06704827f, 0.14358190f, -0.03425628f, -0.16753773f, 0.05939887f, 
    -0.11808036f, 0.00563914f, 0.03934472f, -0.03904922f, -0.02328759f, -0.26346126f, 0.01414836f, 0.08727510f, 
    -0.04444050f, 0.06838376f, -0.06948093f, 0.11758061f, 0.05523845f, -0.09137699f, -0.02934572f, 0.02186382f, 
    -0.09919684f, -0.21947533f, -0.05096497f, -0.35386354f, 0.00972261f, -0.08041009f, -0.04495557f, -0.09984753f, 
    -0.08986253f, -0.03962957f, -0.06847884f, -0.18893129f, -0.10555008f, 0.12632553f, 0.13849382f, -0.29961646f, 
    0.05556303f, -0.20558909f, 0.18300314f, -0.07541296f, -0.19675544f, 0.04023141f, 0.15718922f, -0.08933047f, 
    -0.16284424f, -0.17181067f, -0.01531912f, -0.01244060f, -0.01942516f, -0.01030876f, -0.08961715f, 0.04354908f, 
    -0.00337701f, -0.03421916f, 0.10583188f, -0.02682631f, -0.06673217f, 0.30159122f, 0.04181934f, -0.16910093f, 
    -0.00431626f, -0.17672212f, -0.03457982f, 0.07694242f, -0.11302321f, -0.00046858f, -0.11031665f, -0.01326590f, 
    0.09003496f, 0.00873613f, -0.05011330f, 0.13926427f, 0.04645522f, 0.03983292f, -0.10914657f, 0.11501762f, 
    0.08596487f, 0.08218329f, -0.20854719f, 0.21272479f, -0.05988464f, 0.00205617f, -0.14163202f, 0.26583612f, 
    0.13301100f, -0.13125129f, -0.05101188f, -0.00493014f, 0.08401702f, 0.07777559f, -0.01758311f, -0.24509165f, 
    0.38282055f, -0.08957215f, -0.03816120f, 0.12667307f, 0.03514801f, 0.12554337f, -0.02924343f, -0.19021429f, 
    0.15546024f, 0.04136923f, -0.08842453f, -0.08819969f, -0.39589176f, 0.30191848f, 0.31410438f, 0.05566937f, 
    -0.03194713f, 0.03198064f, 0.06221117f, -0.02239921f, -0.08823736f, 0.05302820f, 0.06144164f, 0.07751222f, 
    0.09041620f, 0.00588758f, -0.00424407f, 0.13253418f, 0.01817112f, 0.09541948f, -0.00294332f, -0.06931785f, 
    0.07615651f, 0.05957188f, 0.06078758f, 0.23979484f, 0.02967493f, -0.26676047f, 0.07884900f, 0.05100060f, 
    -0.04270069f, -0.03452101f, -0.12181599f, -0.05748569f, 0.17567873f, 0.07891814f, 0.12932849f, 0.06902964f, 
    0.49584562f, -0.04423152f, 0.06691294f, 0.26388299f, 0.20267022f, 0.12165103f, -0.05775101f, -0.00613625f, 
    -0.03940727f, 0.00475071f, 0.03394429f, 0.23508707f, -0.32682270f, 0.36716342f, 0.29666877f, 0.18796028f, 
    0.12239198f, 0.02499679f, -0.19173305f, 0.02514463f, -0.10658103f, -0.14360771f, -0.00008524f, -0.16309585f, 
    -0.29671499f, 0.06920052f, -0.12413763f, -0.09745798f, 0.11389182f, -0.15036708f, 0.12216073f, 0.00062261f, 
    0.02960253f, 0.00414593f, -0.08683365f, -0.04663715f, -0.21904872f, 0.01058566f, 0.18283057f, 0.12817292f, 
    -0.02690897f, 0.04821607f, 0.06278729f, 0.00196674f, 0.09820032f, -0.01313207f, 0.13584924f, -0.06821601f, 
    -0.17149808f, -0.14974837f, -0.01455489f, 0.05974977f, -0.02268263f, 0.01014209f, 0.05293907f, 0.03283987f, 
    0.05523795f, 0.07389041f, 0.03369664f, 0.10114921f, -0.00113273f, 0.28814679f, 0.22958100f, 0.07900259f, 
    0.08979920f, 0.13976219f, 0.06417426f, 0.11778178f, 0.29966426f, 0.11475778f, 0.10529705f, 0.12056563f, 
    -0.01995326f, -0.11318588f, -0.03339266f, -0.20418258f, 0.18702540f, -0.14356154f, -0.02335297f, -0.09584098f, 
    0.03548279f, 0.10795233f, 0.03904270f, 0.06759524f, 0.16749385f, 0.23844153f, 0.08281657f, 0.18618278f, 
    -0.01569597f, 0.01015088f, 0.00325254f, -0.11899191f, -0.01228483f, -0.00902238f, 0.09891786f, -0.05227618f, 
    -0.09643734f, 0.00198897f, 0.13694407f, -0.12576884f, -0.02805676f, -0.13538797f, -0.00235048f, -0.13060172f, 
    0.11325415f, 0.07819866f, 0.13093080f, 0.10088658f, -0.30103093f, -0.00924091f, 0.05723466f, -0.06402370f, 
    0.04883842f, -0.06979922f, -0.11102501f, -0.14983596f, -0.02282319f, -0.02143771f, 0.04103053f, -0.15802556f, 
    0.00104748f, -0.24756069f, -0.06347804f, -0.12857315f, -0.00742490f, 0.01387800f, -0.19554265f, -0.04499361f, 
    -0.10107280f, -0.19393149f, 0.01914122f, -0.35213891f, -0.16533308f, -0.09482916f, -0.06381930f, 0.13997507f, 
    0.06378286f, 0.02324671f, 0.11262881f, 0.01934691f, 0.09653319f, -0.08941431f, -0.11895780f, -0.03443094f, 
    0.02873284f, -0.03142747f, -0.00353958f, 0.01666831f, 0.02614844f, -0.03919004f, -0.00220838f, -0.03683274f, 
    -0.04181366f, -0.03209221f, 0.04456338f, -0.02833355f, 0.01300068f, -0.02804089f, -0.02007803f, 0.03489432f, 
    0.02321217f, 0.01556115f, 0.00425307f, -0.02384059f, -0.03129802f, 0.01326153f, -0.02925730f, -0.00491308f, 
    -0.01864387f, -0.05853212f, 0.02304891f, 0.02002441f, -0.01904845f, -0.00224042f, -0.02683133f, -0.05383750f, 
    -0.05245029f, 0.03401873f, -0.01238182f, -0.01918474f, -0.03995677f, 0.01170463f, 0.02466406f, -0.05358358f, 
    -0.06000881f, -0.01360086f, -0.03917454f, 0.01853970f, 0.03672221f, -0.02150033f, -0.03367661f, 0.03099964f, 
    0.00370396f, -0.04585354f, 0.03983232f, -0.00137307f, -0.02549018f, -0.05477458f, -0.02927339f, -0.03739359f, 
    -0.02350014f, 0.01211688f, -0.00133450f, 0.03849914f, -0.02728236f, -0.02185877f, -0.02083898f, 0.04082810f, 
    -0.04573616f, 0.03446294f, 0.00813204f, 0.01243270f, -0.01663483f, -0.00264363f, -0.05213574f, -0.02216034f, 
    -0.03039893f, -0.00373546f, -0.02210397f, -0.01361933f, -0.01653441f, -0.01902906f, -0.05112219f, 0.03552059f, 
    -0.01456143f, 0.02654690f, 0.00926860f, -0.01618029f, -0.04244550f, 0.02681854f, 0.04160237f, 0.02274293f, 
    0.01521838f, 0.04271052f, -0.03842812f, -0.01691057f, -0.06026170f, -0.03326728f, 0.00826677f, -0.05220686f, 
    -0.04869822f, -0.05099482f, 0.03989976f, 0.01862677f, -0.01126954f, 0.04351518f, 0.02635599f, -0.05431383f, 
    -0.02886934f, -0.02617128f, 0.02650092f, -0.00460163f, -0.04896973f, -0.02850605f, -0.03385290f, -0.01992786f, 
    -0.04754156f, -0.03841116f, 0.04114829f, -0.04785301f, -0.02834263f, 0.02565629f, -0.02300127f, 0.00031912f, 
    -0.01419818f, -0.01302572f, -0.00946161f, -0.03661862f, 0.03937379f, -0.02641701f, 0.00183401f, -0.05137183f, 
    -0.02178452f, 0.02474018f, -0.02538389f, -0.00426334f, 0.00928265f, 0.04121144f, -0.01761607f, -0.02594807f, 
    -0.04075551f, 0.02928549f, -0.03513094f, 0.02636920f, 0.02935822f, 0.00890104f, 0.03064813f, -0.04436819f, 
    -0.04900116f, -0.01098805f, 0.00087478f, 0.02621957f, -0.05396599f, -0.02836037f, -0.03075476f, -0.04102303f, 
    -0.01086145f, -0.03056561f, -0.01496937f, -0.03881751f, 0.03213431f, 0.00665813f, -0.05035640f, 0.03688388f, 
    0.00673716f, -0.00877203f, 0.02808134f, 0.04696038f, -0.00040726f, 0.04189906f, 0.03800358f, 0.00853279f, 
    0.04082909f, -0.00846072f, -0.01394506f, -0.04112140f, -0.03018796f, 0.01415242f, -0.05544394f, 0.01396405f, 
    -0.04011859f, 0.02175197f, 0.02569747f, -0.02830455f, 0.01814578f, 0.04016624f, 0.01966997f, 0.01857306f, 
    -0.04899715f, 0.03070036f, -0.01783849f, -0.04083528f, -0.04012826f, -0.01481249f, -0.05718153f, -0.04274182f, 
    0.02591163f, 0.03961199f, -0.03082218f, -0.02082234f, -0.04800270f, -0.02423806f, -0.01152335f, -0.02329806f, 
    -0.02536898f, -0.02527549f, -0.02129633f, -0.05779942f, 0.00126144f, -0.04863898f, -0.02680284f, 0.00717369f, 
    -0.04925028f, -0.01318052f, 0.02889259f, -0.03094714f, -0.04328193f, 0.02994283f, 0.01425373f, 0.01280722f, 
    0.02050260f, 0.02014698f, 0.02994842f, -0.02565950f, -0.02243134f, -0.02091569f, -0.01069769f, 0.01911668f, 
    -0.01193574f, 0.03967063f, -0.02876405f, -0.01475848f, -0.04548325f, 0.01598733f, -0.02991226f, -0.02241476f, 
    -0.04912001f, 0.03730851f, -0.05629943f, 0.04144003f, 0.01918695f, 0.01542453f, -0.03021643f, -0.00070528f, 
    0.02216826f, 0.02710267f, 0.02346953f, 0.00556884f, -0.00624319f, -0.05611495f, 0.02035611f, 0.04447395f, 
    -0.03162443f, -0.00959426f, -0.03770660f, -0.04378933f, 0.02806070f, -0.05198200f, 0.01013842f, -0.02291016f, 
    -0.04957071f, -0.05496598f, -0.03011788f, 0.01062196f, -0.05280890f, 0.00924146f, -0.01001342f, 0.03654495f, 
    -0.05235620f, -0.02808666f, -0.03879476f, 0.03457318f, -0.05503151f, 0.01624508f, -0.00442272f, 0.04452868f, 
    0.03160454f, -0.04223899f, 0.03924605f, -0.01134078f, 0.02025565f, 0.04328389f, -0.01059463f, 0.01722128f, 
    -0.03687640f, -0.00907932f, 0.01832508f, -0.04135979f, 0.00636410f, -0.02123770f, -0.03644255f, 0.03932711f, 
    0.01466297f, -0.04634205f, -0.04442782f, -0.03442276f, 0.04368974f, -0.02753739f, -0.04835651f, 0.01582277f, 
    0.01691593f, -0.01854174f, -0.04872766f, 0.01678548f, -0.02755864f, -0.01259893f, -0.00890037f, -0.02996538f, 
    -0.04267127f, -0.05380090f, -0.03690043f, 0.00018770f, 0.03840042f, 0.01552997f, -0.03881604f, -0.01600913f, 
    0.02648047f, 0.04254895f, 0.01301855f, -0.02267293f, -0.05534979f, -0.03423698f, 0.04030179f, 0.03920279f, 
    0.04792881f, 0.04311631f, 0.02728775f, 0.03661521f, -0.01570640f, 0.03976237f, -0.02960802f, -0.05205968f, 
    0.00581508f, 0.03669297f, -0.04032643f, 0.01992337f, -0.01418279f, 0.03761788f, -0.00040070f, -0.01691133f, 
    -0.00907062f, -0.03906690f, -0.04666733f, 0.03895953f, -0.05081542f, -0.00593329f, 0.00649083f, -0.01500126f, 
    0.01835678f, 0.00708295f, -0.01819203f, -0.01977709f, 0.04301485f, 0.02685930f, -0.04067754f, -0.04526976f, 
    0.03403670f, -0.03680839f, 0.04348278f, 0.02165376f, 0.04054535f, -0.04754009f, 0.00573126f, -0.00172739f, 
    0.02165456f, -0.03231761f, 0.00898896f, -0.02392927f, -0.02347869f, -0.05191997f, -0.00217472f, 0.02342056f, 
    0.02037501f, -0.02597897f, -0.03665699f, -0.04145809f, 0.04490399f, -0.02643581f, -0.02782959f, -0.00604007f, 
    -0.01708582f, -0.04481630f, 0.01133798f, -0.01586461f, 0.00924215f, -0.03296297f, -0.01763736f, 0.01421537f, 
    0.07064655f, -0.03559028f, 0.02387621f, -0.07261912f, 0.04303971f, 0.16267359f, -0.06229121f, -0.06912244f, 
    0.21590532f, -0.03919730f, -0.02960754f, 0.26016071f, 0.09352935f, -0.17864597f, 0.02628195f, 0.08464199f, 
    0.04010822f, 0.04193335f, 0.09028005f, -0.06918401f, -0.04339161f, 0.00640081f, 0.10409616f, -0.07435670f, 
    -0.02378262f, 0.14260010f, 0.08334474f, 0.02740199f, 0.03877579f, 0.01433131f, 0.01785448f, 0.08880929f, 
    -0.01990704f, 0.05056710f, 0.26031718f, 0.02651687f, 0.04642288f, -0.30224851f, -0.14116119f, -0.05391192f, 
    -0.01546395f, -0.02269552f, 0.02305344f, -0.01137816f, -0.05157652f, 0.00911295f, -0.03392055f, -0.06756294f, 
    -0.36405760f, -0.10513599f, -0.03999026f, -0.10558381f, 0.01501626f, 0.09054202f, -0.03670689f, 0.06802001f, 
    -0.07775305f, 0.02091903f, 0.04108115f, 0.00130790f, 0.15892099f, -0.22023490f, -0.13581613f, -0.15616105f, 
    0.02438837f, 0.08740915f, -0.07977130f, -0.04635023f, 0.03971005f, -0.05274453f, 0.10429420f, 0.00272651f, 
    0.47225168f, 0.23660281f, 0.16800687f, -0.00794769f, -0.06892937f, -0.07874942f, -0.15253901f, 0.03760849f, 
    -0.00783345f, 0.02726151f, 0.13820277f, -0.12393961f, -0.09746221f, 0.12293410f, 0.01804655f, 0.08228956f, 
    -0.05153659f, -0.03386877f, 0.04624597f, 0.13298726f, 0.07048133f, -0.03901546f, -0.09683517f, 0.04498665f, 
    -0.10280586f, -0.10905173f, 0.49142286f, 0.20171785f, -0.02945379f, 0.02986857f, 0.00226030f, -0.08521127f, 
    0.12138838f, 0.10869857f, 0.03172300f, 0.09128729f, 0.12475870f, 0.19243279f, 0.07392215f, -0.05311774f, 
    -0.11115885f, -0.00382064f, -0.00327361f, -0.04891492f, -0.04108947f, 0.01299399f, -0.04702289f, -0.04384628f, 
    0.04926999f, -0.03831356f, -0.00732988f, 0.05399345f, 0.04577219f, 0.05928804f, 0.06231485f, -0.01213856f, 
    -0.04291998f, 0.00024484f, -0.01918113f, 0.04275557f, 0.46939656f, -0.33551508f, 0.19023332f, 0.02172043f, 
    0.05392628f, -0.02802114f, -0.06600480f, 0.01962419f, -0.10724882f, 0.18889007f, -0.10176556f, 0.04618953f, 
    0.12628841f, -0.05588116f, 0.04307266f, -0.08811699f, -0.00582013f, -0.01339708f, -0.06966983f, 0.06147959f, 
    0.07943924f, -0.08346082f, -0.16014674f, -0.01699770f, -0.14827548f, -0.45263895f, 0.41651699f, -0.00550071f, 
    0.04077727f, 0.04615469f, -0.19843636f, 0.03501438f, 0.02665432f, -0.05957756f, 0.08931795f, -0.02651568f, 
    -0.06350306f, 0.19335546f, 0.03859699f, -0.27615193f, -0.18176641f, 0.02091086f, 0.15829656f, -0.04031299f, 
    0.02730163f, -0.04650482f, 0.02647960f, -0.21718679f, -0.09040669f, 0.29902083f, 0.11758961f, -0.16827077f, 
    0.01086086f, -0.06595488f, 0.10711993f, 0.00487208f, 0.00779813f, 0.00728373f, 0.00301888f, 0.08437967f, 
    -0.40025634f, -0.13223661f, -0.05339040f, -0.05647110f, 0.07457320f, 0.04629933f, 0.18748510f, 0.06623242f, 
    -0.09390750f, -0.04837423f, 0.04577969f, 0.00680658f, 0.14345445f, -0.05124560f, 0.24121141f, -0.28930742f, 
    0.11278404f, -0.07508531f, -0.13637614f, -0.00617752f, 0.13499530f, 0.03776812f, -0.25764495f, 0.17855996f, 
    -0.18254627f, 0.20648444f, -0.17578465f, -0.10944735f, -0.15899859f, 0.06316201f, 0.00142373f, 0.02691508f, 
    0.04902325f, 0.04805871f, 0.07320440f, 0.04630549f, 0.10683633f, 0.00036247f, -0.14277883f, -0.00820670f, 
    0.02981443f, 0.05500787f, 0.00324643f, 0.05359596f, -0.10786487f, 0.13165580f, -0.10834903f, 0.03135987f, 
    -0.20925653f, 0.35402101f, 0.19152649f, -0.01311352f, -0.10271053f, -0.05715121f, -0.18917497f, -0.03589911f, 
    0.06689042f, 0.01724050f, -0.08913327f, 0.09423663f, 0.34767973f, -0.10206471f, -0.36534467f, -0.19107309f, 
    -0.13806388f, -0.04110502f, 0.32358393f, 0.00563813f, -0.03450081f, 0.07233021f, -0.01293258f, 0.03859967f, 
    0.10676274f, -0.00818265f, 0.12413459f, 0.01367358f, -0.02533244f, 0.01474850f, 0.03564922f, -0.00928454f, 
    -0.02793445f, 0.03823352f, 0.05719642f, 0.03567855f, 0.18118964f, 0.03733295f, -0.16503312f, 0.00514870f, 
    0.02671208f, 0.01100241f, 0.03016245f, 0.15816902f, 0.04992766f, 0.09214833f, -0.01810892f, 0.00342358f, 
    0.10888491f, 0.03188686f, 0.02831427f, -0.04279936f, 0.12324402f, 0.09279415f, -0.09163072f, 0.09418754f, 
    0.08907080f, -0.02281085f, -0.11764386f, -0.02822704f, 0.00366874f, -0.44731688f, 0.11228578f, 0.01771827f, 
    0.11691236f, 0.00732228f, 0.02505413f, -0.05021451f, -0.08668119f, 0.00491789f, 0.10520028f, 0.04693968f, 
    0.06830797f, 0.05292517f, 0.13260545f, 0.00680520f, 0.02522382f, -0.00661831f, -0.01134981f, 0.01061386f, 
    0.01052420f, 0.03878176f, -0.01676263f, -0.06660608f, -0.02977161f, 0.12024787f, 0.07838191f, -0.05748880f, 
    0.01031107f, -0.03573763f, -0.01909327f, 0.10834571f, 0.01323330f, -0.09308182f, 0.05174791f, 0.07592897f, 
    0.16648063f, -0.02313857f, -0.00381640f, 0.11435413f, 0.04941481f, -0.04202177f, -0.10403891f, -0.01674602f, 
    0.08872281f, 0.17552899f, -0.03451158f, 0.08279148f, 0.18473741f, 0.05045068f, -0.28922501f, -0.00093967f, 
    -0.02367008f, -0.00303553f, 0.15654409f, -0.01485989f, -0.03024026f, 0.03612546f, -0.00417361f, -0.07560423f, 
    -0.01330431f, -0.01683132f, 0.00187926f, 0.02019088f, 0.12319680f, 0.00721161f, 0.07062623f, 0.15392675f, 
    -0.05290953f, -0.02194348f, -0.09952381f, 0.02938522f, 0.15200882f, 0.28680751f, -0.02990899f, -0.13296434f, 
    -0.08443093f, -0.08005232f, -0.10337500f, 0.17201905f, -0.06853458f, 0.05426500f, 0.10085462f, 0.03077034f, 
    -0.13755912f, -0.01305206f, -0.08007918f, 0.09483162f, -0.11871289f, -0.04652868f, 0.15795676f, -0.20443177f, 
    0.01581883f, -0.08342107f, 0.09104259f, -0.01112753f, -0.01591944f, 0.07014282f, 0.02278994f, 0.15917702f, 
    0.07731512f, -0.03047800f, 0.00855895f, 0.01780469f, 0.03752022f, -0.02694204f, 0.04591019f, -0.04406458f, 
    0.21884909f, 0.06287452f, 0.05659266f, 0.00131464f, -0.02624714f, -0.03014406f, -0.00272412f, 0.05323433f, 
    -0.05567669f, 0.05998275f, 0.15378977f, -0.16828677f, 0.26825255f, 0.24686021f, 0.03968652f, 0.17473328f, 
    -0.03437570f, 0.00352745f, -0.07876442f, 0.01676693f, 0.04735702f, 0.09168721f, 0.03650007f, -0.06261168f, 
    -0.16806357f, 0.11016412f, -0.11006232f, -0.21203564f, -0.01454821f, -0.06913212f, 0.02147599f, -0.25028935f, 
    -0.19154416f, -0.09147996f, 0.01666300f, 0.10057362f, -0.11135433f, -0.47486657f, -0.03132243f, 0.30366004f, 
    0.11399263f, -0.03990038f, 0.01157923f, 0.05913339f, 0.04329895f, -0.02062153f, 0.09664018f, -0.06091124f, 
    -0.03477087f, -0.11748634f, -0.05212224f, -0.44807845f, -0.14239906f, -0.09535262f, -0.06348606f, 0.02566468f, 
    0.05561364f, 0.22600928f, 0.07994165f, -0.15792416f, -0.25096041f, -0.03169491f, 0.09721140f, 0.07896832f, 
    -0.10523494f, -0.08667964f, 0.11509712f, 0.13724656f, -0.03210609f, 0.03824555f, -0.00114446f, -0.03044589f, 
    0.30164167f, 0.17219409f, 0.13154791f, -0.12817365f, 0.13202412f, 0.01041263f, -0.03821510f, -0.01385514f, 
    0.00118192f, -0.02478719f, 0.00831629f, 0.04925386f, 0.00693470f, -0.05246884f, -0.11001438f, -0.44555378f, 
    -0.00165972f, -0.12136322f, 0.01967721f, -0.04392072f, -0.03147706f, 0.09536477f, -0.03386294f, -0.06994700f, 
    -0.02971476f, 0.05769520f, -0.03184785f, 0.13337038f, 0.04450824f, -0.10779536f, -0.03363548f, -0.05784570f, 
    0.01960668f, -0.03344470f, 0.03996423f, -0.03850888f, 0.21909633f, 0.32839796f, -0.05545083f, 0.14613388f, 
    0.08392786f, 0.02062787f, 0.07161612f, 0.09600221f, 0.21132179f, 0.06046563f, -0.10292862f, -0.02953542f, 
    -0.15369585f, -0.19427648f, 0.09253382f, -0.03844860f, -0.10383213f, -0.21206136f, 0.11641908f, -0.07170925f, 
    -0.09685958f, -0.00853162f, -0.01574493f, -0.01421051f, -0.34924269f, -0.15285474f, 0.00166306f, 0.29893991f, 
    0.14503130f, 0.18976404f, 0.08972210f, -0.05288783f, 0.00011634f, 0.03404420f, 0.01076718f, 0.08109426f, 
    -0.15883404f, -0.12195804f, 0.21811937f, -0.07356415f, 0.27711940f, -0.01261120f, 0.07646494f, 0.10216090f, 
    0.08661173f, 0.14241375f, 0.02780500f, -0.06960987f, 0.00165305f, 0.09099758f, -0.06198213f, -0.12325459f, 
    -0.11616579f, 0.34361544f, -0.09378701f, 0.12329954f, -0.07739786f, 0.07129124f, -0.00620643f, -0.04165500f, 
    -0.23521921f, -0.18370487f, 0.01073317f, 0.14459266f, 0.00601105f, 0.27018377f, 0.18511578f, 0.27044776f, 
    0.01777532f, -0.09826074f, 0.04646331f, 0.00595461f, 0.03215644f, 0.07326208f, -0.23418163f, -0.10624027f, 
    -0.08313641f, 0.08828585f, 0.06874479f, -0.23067722f, -0.01639249f, -0.03255013f, 0.03608511f, 0.07923102f, 
    -0.03199791f, -0.41851154f, -0.20063996f, -0.33198172f, -0.13048509f, 0.26681438f, -0.08498431f, -0.10689819f, 
    0.01386722f, 0.14683485f, 0.07068677f, 0.04922999f, 0.08172197f, 0.10544072f, -0.10835560f, -0.06203975f, 
    0.00790933f, 0.03533151f, 0.02346534f, 0.14912891f, 0.00762827f, 0.04763614f, 0.04523167f, 0.01390656f, 
    0.08837854f, -0.06426673f, 0.03445025f, -0.10812724f, -0.08155818f, -0.08626337f, -0.08973322f, 0.09679383f, 
    -0.24773526f, -0.05065732f, -0.09883919f, 0.00262021f, 0.82392079f, 0.07670140f, 0.09856151f, 0.12274812f, 
    -0.02424961f, -0.03563019f, 0.33825505f, -0.21746582f, 0.02198083f, -0.01458521f, 0.00469177f, -0.01873088f, 
    0.13585962f, 0.11186380f, -0.01877216f, 0.09269040f, 0.06901277f, -0.02280776f, 0.05203422f, -0.13700819f, 
    -0.04716926f, -0.00366434f, -0.13475735f, -0.01870144f, -0.11968859f, -0.07961910f, 0.17907140f, 0.13507909f, 
    0.13024710f, 0.06226834f, -0.15901022f, -0.09751206f, -0.08819699f, -0.09745820f, 0.13051619f, 0.10640128f, 
    -0.23493500f, -0.52957129f, -0.32548517f, -0.10380678f, 0.00351475f, 0.02969713f, 0.03952168f, 0.04257607f, 
    -0.05789133f, 0.04633506f, 0.00372297f, -0.09138958f, 0.03287478f, 0.11121305f, 0.05248825f, 0.48958024f, 
    0.02562083f, -0.09490062f, 0.21431683f, 0.01979562f, 0.18804583f, 0.06772035f, 0.16822527f, 0.04080915f, 
    0.14530553f, 0.16921340f, 0.01953734f, 0.04468265f, 0.05253224f, 0.03095863f, 0.03821405f, -0.01746876f, 
    -0.09364328f, 0.02991471f, 0.02183100f, -0.07346403f, 0.10682053f, -0.12556000f, -0.12855802f, -0.28641629f, 
    -0.07504645f, -0.05672354f, -0.03079513f, 0.14211047f, -0.02412006f, -0.06609729f, 0.25173014f, 0.03594236f, 
    0.08693587f, 0.13617092f, -0.07317761f, -0.06360888f, 0.01908362f, -0.01285994f, 0.01635230f, 0.07686586f, 
    0.11591484f, 0.11535829f, 0.09151053f, -0.04706202f, 0.33869135f, 0.22923471f, 0.12716322f, 0.09872714f, 
    -0.02341799f, 0.00466956f, 0.02391933f, -0.02096569f, 0.00585649f, 0.02800859f, -0.00906602f, -0.04901396f, 
    0.06259702f, -0.01245624f, 0.05616110f, -0.00433237f, -0.06629570f, -0.01011678f, 0.05016168f, -0.06776580f, 
    -0.08137874f, -0.08483201f, -0.10726937f, -0.01136794f, -0.12906170f, -0.06002183f, -0.32148567f, -0.34318936f, 
    0.02046467f, -0.01566059f, -0.25545403f, -0.13712302f, 0.11509322f, 0.00803507f, 0.05596627f, -0.01163686f, 
    -0.01816892f, -0.00668008f, -0.02003038f, 0.00294777f, -0.11608746f, -0.02358572f, -0.05603936f, -0.08484893f, 
    -0.12886699f, -0.00089831f, 0.05601439f, -0.11880407f, -0.22713922f, -0.01785826f, 0.10331246f, 0.20254703f, 
    0.07559574f, 0.02994214f, -0.04385148f, 0.08245006f, 0.06175776f, -0.08440538f, -0.06437599f, 0.09953253f, 
    0.21044049f, 0.13094029f, -0.24483289f, -0.09886511f, -0.04571348f, -0.05760390f, -0.05803221f, -0.03320439f, 
    0.22885962f, 0.11131968f, -0.00424700f, 0.00971953f, -0.02897775f, 0.12087715f, -0.10216423f, 0.07346497f, 
    -0.02596163f, -0.07740398f, -0.03814689f, -0.04922526f, 0.01623384f, -0.02806009f, -0.08014689f, 0.01472472f, 
    0.24010108f, -0.05303881f, 0.08531109f, -0.01124036f, -0.02964625f, -0.12209491f, 0.10490199f, 0.06554294f, 
    0.12366199f, 0.02307293f, 0.03037243f, 0.00086905f, -0.11688132f, 0.17158218f, 0.08857076f, 0.47369972f, 
    0.12630007f, 0.01904671f, 0.01399870f, 0.04496741f, -0.09185202f, 0.10595715f, -0.05990348f, 0.08733720f, 
    -0.55978543f, 0.16056973f, 0.47900230f, 0.15802835f, 0.02103873f, 0.04346136f, 0.09677000f, 0.06435286f, 
    0.11964782f, 0.05827124f, 0.05404475f, 0.05891260f, -0.10937438f, -0.10126235f, -0.22429527f, -0.08882914f, 
    0.10788241f, -0.05823084f, -0.01095539f, -0.11913157f, 0.09170556f, 0.13263804f, 0.00893176f, -0.05401618f, 
    0.15441117f, -0.04995660f, 0.00519609f, -0.27456307f, 0.00432703f, -0.00407570f, -0.00425143f, 0.00546280f, 
    0.07395353f, 0.06380585f, 0.08753959f, 0.09179067f, -0.21251245f, -0.03658129f, 0.06735550f, -0.00429756f, 
    0.15227607f, -0.04741050f, 0.09804549f, 0.02977970f, 0.03055971f, 0.04154788f, -0.01538369f, 0.12528615f, 
    -0.10481358f, -0.11872982f, -0.01084133f, 0.06852461f, 0.11948657f, 0.02765166f, 0.09268501f, 0.00793690f, 
    0.04337670f, 0.07527637f, -0.08694890f, -0.00158433f, -0.50325090f, 0.13222986f, -0.03360539f, -0.19349474f, 
    -0.08772466f, 0.05926090f, -0.11123828f, 0.02762427f, 0.14692657f, 0.00366674f, -0.02294653f, 0.07713802f, 
    -0.34513435f, 0.00793866f, 0.07946911f, 0.24448873f, -0.08918845f, -0.06776673f, 0.07593613f, -0.14876847f, 
    -0.15629087f, 0.17702456f, 0.09144013f, -0.01118609f, 0.02287021f, 0.25581959f, 0.09692069f, 0.35905892f, 
    -0.02225890f, 0.24243696f, 0.07670493f, -0.01989972f, 0.01000851f, 0.07365455f, -0.03127186f, -0.02815675f, 
    -0.07170003f, -0.22890140f, -0.00231076f, 0.54515344f, 0.16260594f, -0.22128633f, 0.17649445f, 0.01144974f, 
    -0.09461211f, 0.04184551f, 0.03488375f, 0.14414208f, 0.27638096f, 0.09665737f, 0.03774746f, 0.08559671f, 
    -0.02154818f, 0.06679656f, -0.05167459f, 0.15261501f, 0.03282173f, -0.03180508f, 0.04959588f, 0.00938208f, 
    0.08465092f, -0.20320280f, 0.03601797f, 0.30869094f, -0.06165748f, 0.03892757f, -0.00170844f, -0.13930218f, 
    0.05980216f, 0.04901372f, -0.18226996f, 0.08607621f, -0.09751057f, 0.08866521f, -0.09864651f, 0.17211595f, 
    0.07507487f, 0.20713606f, 0.09894727f, 0.04203654f, 0.06968683f, -0.02243183f, 0.06732523f, -0.05854800f, 
    0.16588324f, -0.19133981f, 0.01702390f, 0.08326487f, -0.00994415f, 0.10747100f, 0.21133032f, 0.01410981f, 
    0.01382799f, 0.06712052f, 0.02117280f, 0.14795336f, 0.06617328f, 0.12444118f, -0.05033237f, -0.06774221f, 
    -0.05111349f, 0.02170852f, 0.03843445f, -0.01200508f, 0.07289743f, 0.15294251f, 0.03255170f, 0.19289955f, 
    -0.16973904f, -0.13482521f, 0.05207998f, 0.20382823f, -0.02030326f, 0.07946265f, 0.24308652f, 0.34365216f, 
    0.00371709f, 0.14935547f, 0.10854516f, -0.05473097f, -0.03653776f, -0.03061814f, 0.04836701f, 0.09731173f, 
    0.33611912f, 0.16012087f, 0.08016239f, 0.01717921f, 0.08342572f, -0.06653390f, 0.08356033f, -0.04485227f, 
    -0.07851460f, -0.01836339f, 0.00503511f, -0.15175264f, 0.14704408f, -0.01375361f, -0.12119164f, -0.04556469f, 
    0.08571231f, -0.01644748f, -0.04859138f, -0.02968860f, -0.11562382f, 0.05363375f, 0.16635460f, -0.12326085f, 
    0.15766403f, 0.20164295f, -0.03767792f, -0.25366193f, 0.01217280f, -0.05469381f, 0.08270543f, 0.13192070f, 
    -0.29101786f, -0.22169675f, 0.03026952f, 0.15210286f, -0.09559934f, -0.02205151f, 0.03949380f, -0.15562402f, 
    -0.12522601f, -0.01261338f, 0.10591775f, -0.02383809f, -0.29279459f, -0.07440861f, 0.07268308f, 0.17575878f, 
    0.00559978f, 0.02197155f, 0.09511601f, -0.17063141f, 0.01395142f, -0.07992946f, -0.12300839f, -0.03605506f, 
    -0.22467990f, 0.10681263f, -0.04075328f, -0.12339480f, -0.00234902f, -0.00223059f, -0.01045523f, 0.00777299f, 
    0.09950038f, -0.03181684f, 0.06196387f, 0.20282638f, 0.13270682f, 0.12957028f, 0.05160943f, 0.05394876f, 
    -0.00479379f, -0.05317708f, 0.10422261f, -0.02840028f, 0.25235742f, 0.19294165f, 0.16519101f, 0.03708524f, 
    -0.21509951f, 0.19124477f, -0.05255128f, -0.17265804f, 0.04696739f, -0.08303457f, -0.00587993f, 0.16891098f, 
    0.05397449f, -0.12173369f, 0.02997582f, 0.02031259f, -0.09179383f, 0.03656356f, 0.16845270f, 0.14886913f, 
    0.03311468f, 0.12296046f, -0.08000463f, -0.05835840f, -0.00529219f, -0.06702273f, 0.01327215f, 0.01581015f, 
    -0.03075851f, -0.11747973f, -0.07163651f, -0.02010457f, 0.13904423f, 0.05975816f, 0.02688679f, 0.01954561f, 
    0.10917359f, -0.00531851f, 0.08907088f, 0.01962536f, -0.13744184f, -0.03098727f, -0.05029355f, 0.08025649f, 
    0.03832993f, -0.02648314f, -0.04587936f, -0.05240828f, 0.06918930f, -0.03567908f, -0.05179019f, -0.05361055f, 
    -0.03041003f, -0.06396420f, 0.04267109f, -0.03560219f, -0.06003679f, 0.08626840f, -0.09512658f, 0.03112356f, 
    -0.11603240f, 0.01532587f, -0.05452327f, -0.26750070f, -0.02574939f, -0.03712000f, 0.09157190f, -0.12768766f, 
    -0.00700303f, 0.12249321f, -0.04566263f, 0.00982984f, 0.09382921f, 0.08113454f, -0.00443241f, -0.00157737f, 
    0.05791249f, 0.15723699f, 0.05457345f, 0.03172377f, -0.07552671f, 0.05608123f, -0.02448232f, -0.05644836f, 
    -0.03144360f, -0.03363455f, -0.16284892f, -0.14262068f, -0.22906047f, 0.13197148f, 0.29947934f, -0.15612443f, 
    0.01664283f, -0.02026771f, -0.07913715f, -0.11240841f, 0.04577632f, 0.03949425f, 0.00141943f, 0.03137910f, 
    0.45014226f, -0.06029145f, 0.09290141f, 0.24452819f, -0.02838803f, -0.01300716f, 0.16042422f, 0.17775775f, 
    0.20582330f, 0.08007333f, -0.05790265f, -0.03158991f, -0.13040793f, 0.16324946f, 0.10293331f, 0.13770618f, 
    -0.06339350f, 0.00168079f, 0.00538504f, 0.11397650f, -0.02569670f, 0.08540299f, 0.03688209f, 0.04849678f, 
    -0.04140631f, -0.09709708f, -0.00820735f, 0.10120833f, -0.05865984f, -0.08233064f, 0.00953142f, 0.02062839f, 
    0.07819204f, -0.01257702f, 0.06848038f, 0.29080942f, 0.16606399f, -0.08118188f, -0.02250491f, -0.15871708f, 
    -0.02398051f, 0.03798222f, -0.02698182f, -0.00974561f, 0.02875525f, 0.14892434f, 0.14441870f, 0.03172856f, 
    0.22820237f, 0.42512727f, -0.12880053f, 0.05677142f, -0.05650015f, -0.01860691f, -0.00868200f, -0.01423275f, 
    -0.05381330f, -0.03253872f, -0.01168114f, 0.01088064f, -0.15706462f, -0.21765366f, -0.02432365f, -0.14143041f, 
    0.08263674f, 0.08093005f, 0.02194256f, 0.18728058f, 0.06009200f, 0.15450832f, 0.08174084f, 0.05666325f, 
    0.02244778f, -0.12911889f, 0.04571025f, -0.11780861f, 0.05545099f, 0.10795583f, -0.00468250f, 0.05747764f, 
    0.06894132f, 0.08963857f, -0.00150530f, 0.01585245f, -0.26244640f, -0.02342193f, 0.33798596f, 0.15971053f, 
    0.00194078f, -0.00203124f, -0.01102752f, -0.06380339f, 0.20668291f, -0.24614055f, 0.16856351f, 0.13095899f, 
    -0.19245075f, -0.16504583f, 0.00032919f, -0.14940919f, 0.06774897f, -0.05815499f, 0.00532616f, 0.09310562f, 
    0.04158420f, 0.05884295f, 0.04865349f, -0.02314042f, 0.14588133f, 0.23273423f, 0.08540217f, -0.22263017f, 
    0.02975071f, 0.03497963f, -0.03443667f, 0.07277194f, 0.03279051f, 0.00402876f, 0.14777373f, -0.04381563f, 
    -0.03643962f, -0.24662992f, 0.06722185f, 0.21510378f, 0.07174914f, 0.16938275f, -0.00666429f, 0.15080969f, 
    0.06007530f, -0.05335138f, 0.09292924f, 0.20905244f, -0.13014346f, -0.09031250f, -0.00622101f, 0.45969117f, 
    0.09364367f, -0.28220427f, 0.15348953f, -0.01976389f, 0.06864277f, 0.07841036f, 0.01624260f, 0.15934113f, 
    0.31079742f, -0.15169151f, 0.04814936f, -0.17688051f, 0.03884492f, 0.11345816f, 0.12434307f, -0.04183945f, 
    0.04797243f, 0.18141280f, -0.00118086f, -0.01461661f, -0.34289005f, 0.23052572f, 0.05869167f, 0.11096983f, 
    -0.06390630f, 0.01581815f, 0.12739451f, 0.28033453f, -0.02394594f, -0.08876590f, 0.11681531f, 0.06232367f, 
    0.11245787f, 0.21136069f, 0.05462373f, 0.10329605f, 0.18652485f, -0.05461406f, 0.14573731f, 0.11692800f, 
    -0.11970045f, 0.01209633f, -0.22678120f, -0.10841517f, 0.18024193f, -0.05940650f, 0.34736845f, 0.03091664f, 
    -0.01263788f, -0.00064280f, 0.10058626f, -0.01978491f, 0.23599537f, -0.09522947f, 0.03639439f, -0.16996400f, 
    0.24874823f, -0.08901616f, -0.10365081f, -0.01097005f, 0.03066129f, -0.05177618f, -0.05438506f, -0.07286629f, 
    0.12214455f, 0.05055321f, 0.14710480f, 0.00971797f, -0.61387032f, 0.13382570f, 0.24328534f, 0.10581830f, 
    0.11517722f, 0.22310841f, -0.00576183f, 0.10779501f, 0.13231434f, -0.02521740f, 0.02662917f, 0.01863244f, 
    -0.12988485f, -0.00108022f, 0.05116562f, -0.02481026f, 0.00580326f, -0.05768359f, 0.06029706f, -0.00963132f, 
    0.00866938f, 0.00398856f, 0.12485582f, 0.00941844f, -0.19603482f, -0.15682967f, 0.06661122f, -0.02611961f, 
    0.00259168f, 0.03880841f, 0.13071707f, -0.03725899f, 0.16915067f, 0.07125432f, -0.09534750f, -0.10872349f, 
    -0.18234186f, -0.25959393f, 0.08392289f, -0.12078618f, -0.12839349f, -0.05851007f, 0.03209566f, 0.00762020f, 
    0.04431869f, -0.04177300f, 0.09392548f, 0.05353267f, 0.06018841f, -0.01877725f, 0.23658156f, -0.09748088f, 
    -0.06574475f, 0.08612104f, 0.09141707f, -0.02031132f, 0.12900095f, -0.03818819f, -0.15085326f, 0.00943383f, 
    -0.06426568f, 0.01236857f, 0.04137747f, -0.03092418f, -0.09077872f, -0.08637669f, 0.06739350f, -0.11972643f, 
    0.11851536f, -0.03168515f, 0.14175703f, 0.10360260f, 0.26110390f, 0.21445797f, 0.06724278f, 0.16762745f, 
    0.02563257f, 0.00627686f, 0.10282936f, -0.10330211f, 0.03695366f, 0.28401396f, 0.00457733f, -0.08002965f, 
    0.01668202f, 0.07885388f, 0.11795959f, -0.12633502f, 0.04222788f, -0.08057484f, 0.00249287f, -0.01467211f, 
    0.04169538f, -0.09701039f, -0.11747594f, -0.16665132f, -0.20725432f, 0.13254896f, 0.05683244f, 0.03124231f, 
    -0.02983403f, 0.09152491f, -0.05511487f, 0.03685457f, 0.12210972f, -0.05984543f, 0.01575388f, 0.01452478f, 
    -0.06066569f, 0.02877206f, -0.06234821f, -0.01176786f, 0.00160725f, 0.03711242f, -0.03845504f, 0.00110392f, 
    0.07207301f, 0.01631061f, 0.10429180f, 0.09471928f, -0.32787544f, -0.29585668f, -0.15797517f, 0.02688616f, 
    0.14195015f, -0.04700182f, 0.17738096f, 0.01915754f, -0.00175525f, -0.02769384f, -0.02630414f, -0.03622888f, 
    -0.01410667f, 0.05263410f, -0.08325849f, 0.10916045f, 0.02548602f, 0.12678403f, 0.24072181f, 0.09297726f, 
    -0.01704106f, 0.12076063f, 0.01278429f, -0.12765200f, -0.08717502f, 0.10367386f, -0.04444581f, -0.08988786f, 
    -0.07915603f, 0.00490988f, 0.07038725f, 0.06001750f, 0.10533668f, 0.04806231f, 0.10948354f, 0.05094330f, 
    -0.16303690f, -0.14690717f, 0.20191735f, -0.06672590f, -0.06526998f, -0.01754895f, -0.12220301f, 0.06789652f, 
    -0.09787359f, 0.11620606f, -0.08891495f, -0.18410650f, -0.25962085f, 0.19075957f, -0.01857131f, 0.12958738f, 
    -0.07451784f, -0.01376835f, -0.05344170f, -0.08526906f, -0.11648475f, 0.11600245f, -0.07698714f, 0.09037068f, 
    0.47721633f, -0.06183156f, 0.02131743f, 0.08316869f, -0.10087589f, 0.07228120f, 0.03873229f, -0.06660453f, 
    -0.09302492f, -0.07678921f, 0.10256865f, 0.02647728f, 0.01596895f, 0.25306603f, -0.23208807f, 0.18729231f, 
    0.14339963f, -0.08992642f, 0.15252514f, -0.01489265f, 0.04045389f, 0.02560729f, 0.09363087f, 0.12092540f, 
    -0.35930064f, -0.18670544f, -0.09989464f, 0.00979955f, 0.20387201f, 0.17617109f, 0.06232445f, 0.04364746f, 
    -0.01734602f, 0.30776399f, 0.02091166f, 0.10571223f, 0.15378301f, -0.08121209f, -0.01401939f, -0.06922989f, 
    0.05801893f, 0.01369971f, -0.10969970f, -0.00300212f, 0.11072803f, 0.06699199f, -0.01761098f, 0.02245720f, 
    0.01286756f, 0.14868911f, -0.02067924f, -0.39836246f, -0.04515399f, 0.08367891f, 0.05498192f, 0.01733384f, 
    0.04303413f, 0.08183140f, 0.13630693f, 0.17389236f, 0.02078699f, -0.09794196f, -0.12733091f, -0.09556836f, 
    0.09403604f, -0.03303598f, -0.02086259f, -0.00340804f, -0.15027292f, -0.03099738f, -0.12576911f, -0.03089006f, 
    -0.08096889f, -0.00139448f, 0.02356865f, 0.01816803f, -0.04130660f, 0.01350766f, 0.09798578f, 0.00658222f, 
    0.04640980f, -0.02521831f, 0.17764109f, 0.03951100f, -0.28157064f, 0.22161794f, -0.11747850f, 0.51214325f, 
    -0.06549814f, 0.04638772f, 0.02423612f, -0.01933496f, 0.20304371f, 0.06100791f, 0.02259009f, 0.19850092f, 
    0.21152145f, 0.00127493f, -0.25341731f, 0.04172822f, 0.12947445f, 0.05294683f, 0.06176687f, -0.08855391f, 
    -0.04864768f, -0.01612349f, -0.03059788f, -0.05478407f, 0.23197363f, 0.55430120f, -0.33323178f, 0.19250005f, 
    0.15728961f, 0.09370911f, 0.17222820f, -0.11247474f, 0.02192810f, -0.03339063f, 0.05118586f, 0.04627099f, 
    0.13664083f, -0.24271378f, 0.23503050f, 0.16961122f, 0.31047231f, -0.04455908f, 0.02645692f, 0.04446151f, 
    -0.00971090f, 0.09662993f, 0.02169559f, 0.02715450f, 0.20388491f, -0.08396556f, -0.25051463f, 0.00695379f, 
    0.05296342f, 0.09414882f, 0.06176213f, 0.22700463f, -0.08198360f, 0.15008231f, 0.02134897f, 0.02196790f, 
    0.26908493f, 0.44776148f, -0.09654633f, -0.15853293f, 0.00264449f, 0.12281813f, 0.13067742f, 0.06219906f, 
    0.10893177f, 0.07069904f, -0.05287083f, 0.05531819f, -0.05095167f, -0.09300130f, -0.18032694f, 0.42939237f, 
    0.04045654f, 0.15487692f, 0.00106180f, 0.09621821f, -0.05910440f, 0.06900622f, -0.10944835f, 0.06621183f, 
    0.33596778f, 0.01387689f, -0.04442589f, -0.27609980f, 0.07902937f, -0.08871175f, -0.03655646f, 0.17474262f, 
    -0.04034141f, 0.07339918f, 0.04719245f, -0.09146295f, -0.11723526f, 0.05718193f, -0.12470958f, 0.09708589f, 
    -0.02349836f, 0.05359678f, 0.00155205f, 0.00692240f, 0.03921186f, 0.07762934f, 0.13277845f, -0.04831769f, 
    0.11427719f, -0.03237148f, 0.04629168f, -0.08191501f, 0.16857825f, 0.18329543f, 0.14710242f, 0.02243242f, 
    0.01654446f, 0.12154045f, -0.00380813f, -0.04646854f, -0.25168231f, -0.26709536f, 0.32163140f, 0.15806547f, 
    0.22329639f, 0.09394895f, -0.08619884f, -0.09901603f, -0.08766429f, 0.00617722f, 0.07493231f, -0.00658651f, 
    -0.17055827f, -0.01985095f, 0.02582220f, 0.07498176f, -0.04057429f, -0.11856074f, 0.20778759f, -0.07233533f, 
    0.05235371f, -0.07505987f, 0.11458680f, 0.03914938f, -0.00234943f, -0.21522060f, -0.18872917f, -0.04666342f, 
    0.03569262f, -0.01770201f, 0.04439701f, 0.06444158f, -0.08603600f, -0.10949042f, 0.02637801f, -0.13587222f, 
    0.23086984f, -0.12523533f, -0.16028875f, 0.10361087f, 0.12221321f, 0.18606868f, 0.12962478f, -0.07672790f, 
    -0.03006509f, -0.01232189f, -0.05426497f, 0.03559560f, -0.24721232f, 0.08452858f, -0.06998383f, 0.28207821f, 
    -0.03917933f, 0.04147890f, 0.08373903f, -0.08767006f, -0.04208614f, -0.01822330f, -0.02106580f, -0.03122962f, 
    -0.19055672f, -0.03845768f, 0.00265910f, 0.00573724f, -0.03376452f, -0.03520763f, -0.05679981f, -0.06131183f, 
    0.04393225f, 0.05286762f, 0.12810113f, 0.20531268f, 0.10874775f, -0.14495401f, 0.14023730f, 0.15616269f, 
    0.00607524f, 0.09558819f, -0.10924954f, 0.12165762f, 0.08673367f, 0.37208709f, -0.03530831f, 0.11565890f, 
    -0.27397534f, 0.02710054f, -0.18232554f, -0.01151474f, 0.05654119f, 0.02083708f, -0.10102594f, -0.00413080f, 
    0.00029188f, -0.03892671f, -0.08387292f, 0.04333888f, -0.30461600f, 0.00346133f, 0.18373068f, -0.02805735f, 
    -0.00480455f, -0.03313706f, -0.11204083f, 0.08883186f, -0.07946848f, 0.00474226f, -0.00443641f, 0.03779245f, 
    -0.05068412f, 0.02356977f, -0.02318553f, -0.03925597f, -0.01545344f, 0.03868057f, 0.01321225f, 0.01730656f, 
    0.01048357f, 0.11794589f, 0.06163465f, 0.11172760f, 0.07423310f, -0.29045317f, -0.24229117f, 0.05479635f, 
    0.13766925f, 0.05021681f, -0.06658982f, -0.00370770f, -0.06969253f, -0.00716840f, -0.05946826f, -0.01658753f, 
    -0.04722480f, 0.00003848f, 0.01422463f, -0.03544302f, -0.03331315f, -0.00332790f, -0.05502237f, -0.02833513f, 
    -0.03134490f, -0.01101728f, -0.01810082f, -0.02949699f, 0.03175290f, 0.04152450f, -0.01903201f, 0.00631195f, 
    0.01330712f, -0.00078875f, -0.04973699f, -0.00423508f, 0.02738287f, -0.01425065f, -0.03197600f, 0.03429301f, 
    0.01779362f, -0.04680050f, -0.05324674f, -0.03570695f, -0.05404328f, 0.01154699f, 0.03787504f, 0.02664694f, 
    -0.00417769f, -0.05130352f, -0.01472366f, 0.03508172f, 0.02108049f, -0.05025347f, -0.03556938f, -0.02742694f, 
    -0.01429574f, 0.03812139f, 0.00293911f, -0.04438028f, 0.01954409f, 0.01470350f, -0.00412446f, -0.04391358f, 
    -0.03916196f, 0.01150699f, -0.03553111f, -0.03633963f, 0.00257336f, -0.01710011f, 0.02064110f, -0.05165378f, 
    0.02304020f, -0.01349051f, 0.01293019f, 0.02675485f, -0.04246353f, -0.03956090f, -0.04761368f, -0.02930857f, 
    0.01502617f, -0.03109824f, 0.03358551f, -0.01155266f, 0.03185027f, 0.04247970f, 0.01791584f, -0.05551703f, 
    0.01296978f, -0.03997259f, -0.00428090f, -0.01586219f, 0.01026961f, -0.04836588f, 0.01600492f, -0.00993442f, 
    0.01688625f, 0.03463812f, -0.05367818f, 0.03833070f, -0.04882095f, 0.02764065f, -0.01419277f, -0.03536966f, 
    -0.03831359f, 0.02754510f, -0.00152118f, 0.01737117f, 0.00971342f, 0.00318025f, 0.03961902f, 0.03222288f, 
    -0.01386256f, 0.00634320f, -0.04324416f, 0.02886320f, -0.03589816f, -0.04975290f, -0.03753664f, -0.01419608f, 
    0.02463015f, 0.03849616f, -0.01527688f, 0.03479208f, 0.01225048f, 0.01621597f, 0.01300806f, -0.03051752f, 
    0.03596253f, 0.03733924f, -0.00438528f, 0.03837737f, 0.01217860f, 0.01708500f, -0.04985344f, -0.03294051f, 
    0.01631908f, 0.01095633f, -0.02875618f, 0.02843022f, 0.04398304f, 0.03842144f, 0.03604209f, -0.02685603f, 
    0.00497309f, -0.02951132f, -0.04513982f, -0.03772832f, 0.02332744f, -0.03330791f, 0.03834863f, -0.02774699f, 
    -0.01035543f, -0.00911719f, -0.01748615f, 0.03661019f, -0.03022896f, -0.02120659f, -0.00391243f, -0.00377727f, 
    -0.03049096f, -0.02997255f, -0.06045018f, 0.00036825f, -0.04662515f, -0.06016166f, -0.03236833f, -0.03765603f, 
    0.02702604f, 0.02541146f, 0.01844757f, 0.03205168f, 0.01181015f, -0.02740514f, 0.00600918f, -0.03876674f, 
    0.02117336f, -0.00364184f, 0.04650084f, -0.04516980f, -0.04149327f, -0.05588714f, -0.00270210f, -0.01583841f, 
    -0.01587862f, -0.04899011f, 0.01529317f, 0.01805693f, -0.00556720f, -0.03715132f, 0.03186227f, -0.05246484f, 
    -0.01254291f, -0.03369782f, 0.00040360f, -0.04685677f, -0.00584976f, -0.00542489f, 0.01453410f, 0.00432772f, 
    0.02956552f, 0.00429801f, -0.03728170f, 0.00484621f, -0.00123312f, 0.02713970f, -0.03392489f, -0.02002708f, 
    -0.02393131f, -0.04504445f, -0.04164187f, 0.02820776f, -0.05678063f, 0.01740885f, -0.05226849f, -0.01848613f, 
    -0.02384982f, -0.04692127f, -0.03033451f, -0.02109810f, -0.03071587f, 0.03409000f, -0.04223769f, -0.00045028f, 
    0.03446291f, 0.00612901f, -0.03631205f, -0.01448726f, 0.02930434f, -0.04196957f, -0.01122267f, 0.00693395f, 
    0.03043081f, 0.04166989f, -0.02567423f, -0.02190415f, 0.04117268f, -0.01102761f, 0.01080950f, -0.00421339f, 
    0.00939218f, -0.04760159f, 0.03433216f, 0.00914369f, -0.04854880f, -0.02660656f, -0.04346857f, -0.02210359f, 
    -0.03189661f, -0.05101502f, 0.03534871f, 0.01874696f, -0.05147420f, 0.00112952f, 0.01916416f, 0.03641290f, 
    0.03854690f, -0.02203930f, 0.03555169f, 0.04274927f, -0.05532407f, -0.01929264f, -0.03892345f, 0.03760855f, 
    0.01012394f, 0.02687254f, 0.04165970f, 0.02325695f, 0.04702115f, -0.04562002f, -0.03836272f, 0.02416505f, 
    -0.00953673f, -0.01447179f, -0.02143284f, 0.04357958f, -0.00177256f, 0.02473887f, -0.03045458f, -0.04576334f, 
    -0.03345394f, -0.01794613f, -0.04061740f, -0.02434882f, -0.02685882f, -0.05148038f, -0.01572220f, -0.05154444f, 
    -0.04011816f, 0.01751324f, -0.00397387f, -0.00738998f, -0.00285460f, -0.02290052f, -0.03435117f, 0.03975108f, 
    0.02779750f, -0.02384466f, -0.03751085f, -0.03586921f, -0.02389557f, -0.03575631f, 0.01265310f, -0.03114835f, 
    -0.03162013f, 0.03228726f, 0.04398814f, -0.01076526f, -0.03748588f, -0.03527490f, -0.04890171f, -0.02274381f, 
    0.04051157f, 0.01924652f, 0.04575390f, -0.02775581f, -0.00625105f, -0.02115856f, 0.02652301f, -0.03245931f, 
    0.00837857f, 0.00467006f, -0.02367003f, 0.03315580f, 0.01128421f, -0.02260426f, -0.04698922f, -0.01225248f, 
    0.01516801f, 0.02825815f, -0.03386303f, 0.01579846f, -0.05180363f, -0.02057542f, -0.02181040f, 0.00692744f, 
    0.02699960f, 0.00688561f, -0.01421597f, -0.05082868f, 0.02242562f, -0.04317144f, -0.04261205f, -0.04375609f, 
    0.03325193f, -0.03350542f, 0.04343859f, -0.02973531f, -0.05526244f, -0.00929501f, 0.02811937f, -0.04589939f, 
    -0.00538895f, -0.05721192f, 0.02719024f, 0.03917880f, -0.02375547f, -0.00073588f, -0.03568738f, 0.02144932f, 
    -0.04309618f, 0.03535637f, -0.02159767f, 0.00937306f, 0.02779427f, -0.00293104f, -0.04760224f, -0.00462315f, 
    -0.00737286f, -0.00701683f, -0.02694312f, 0.01902976f, 0.03947953f, 0.02521861f, 0.03315415f, -0.01990047f, 
    0.04099526f, -0.02391548f, -0.04736204f, -0.04923210f, -0.00916609f, -0.04251621f, -0.04093389f, -0.00903508f, 
    0.00417500f, -0.00607523f, 0.00811920f, -0.03689653f, -0.00276534f, 0.00324804f, 0.03975271f, 0.03241635f, 
    -0.01567338f, 0.00543591f, 0.01420282f, -0.01848622f, -0.00656494f, -0.03581778f, 0.01115519f, 0.01749662f, 
    -0.04481957f, -0.10078688f, -0.09779731f, 0.02598171f, -0.08463617f, -0.03033374f, -0.10731179f, 0.08326096f, 
    0.13404788f, -0.06410609f, 0.14440286f, -0.02398719f, 0.02587308f, -0.47062147f, 0.11571496f, 0.19101420f, 
    0.19792110f, 0.23910901f, 0.07234452f, -0.03155015f, -0.00324944f, -0.09784389f, 0.04761608f, -0.11425404f, 
    0.28676584f, 0.22367936f, -0.18086283f, -0.00899573f, -0.08296297f, 0.03471272f, 0.08521112f, 0.02005312f, 
    0.04500669f, 0.17891130f, 0.33433181f, -0.12844163f, 0.22806923f, -0.43351242f, -0.26718405f, -0.11316350f, 
    0.07147193f, 0.04272823f, -0.01176633f, -0.00901932f, -0.03603950f, 0.04855499f, -0.04515754f, -0.02057179f, 
    -0.35545006f, 0.20696141f, 0.02516046f, -0.26030359f, -0.03470608f, 0.00156963f, 0.12790489f, 0.03431650f, 
    0.17212617f, -0.01860946f, -0.01835887f, 0.11743297f, 0.04024071f, -0.31439137f, 0.19743210f, 0.20625257f, 
    0.09584286f, 0.05599480f, -0.00650177f, -0.04115978f, -0.03088444f, 0.02765497f, 0.10730972f, 0.15060332f, 
    -0.11125316f, 0.30120322f, 0.41145962f, 0.21477316f, -0.10166220f, -0.13285285f, -0.18296690f, -0.00830572f, 
    -0.06257609f, 0.08859976f, 0.17741549f, 0.01393970f, -0.31415653f, -0.01021062f, 0.00423218f, -0.06167603f, 
    -0.02052301f, -0.07760427f, -0.05545709f, 0.02712490f, 0.09726948f, 0.03606388f, -0.13183564f, 0.00887160f, 
    -0.10713843f, 0.09306350f, 0.39843175f, 0.24579382f, 0.08196986f, -0.01127909f, -0.13693140f, -0.09478293f, 
    0.15485647f, 0.09196085f, 0.14857586f, 0.10531195f, -0.25592190f, 0.06005317f, 0.18350370f, -0.30773529f, 
    0.05068919f, 0.01552161f, -0.01225954f, 0.11048336f, 0.00164762f, 0.03411613f, -0.06163968f, 0.10905099f, 
    0.09108122f, -0.24063520f, -0.06257667f, -0.00133157f, 0.10203970f, 0.03682242f, 0.14109011f, -0.06771208f, 
    0.05742938f, 0.04690208f, -0.03534478f, 0.02443767f, 0.01418441f, -0.09408183f, 0.22963211f, -0.45411140f, 
    0.05464327f, -0.04370437f, -0.04914739f, 0.01444968f, -0.05052772f, 0.05325544f, -0.07434043f, 0.15144657f, 
    -0.38960898f, -0.19332428f, 0.19235635f, -0.12286860f, -0.09586723f, -0.06214847f, -0.00456591f, -0.05351691f, 
    0.01606500f, 0.09656678f, -0.01276035f, -0.02585369f, -0.39056557f, -0.35887328f, 0.30293626f, -0.09060652f, 
    0.19847645f, 0.06002817f, -0.14878123f, 0.07704040f, 0.00552676f, 0.05733246f, 0.10769926f, 0.10876355f, 
    -0.33949375f, -0.01224003f, -0.07714495f, -0.06926700f, -0.03543329f, -0.19968596f, 0.16768377f, 0.04439363f, 
    0.02874918f, -0.03085696f, -0.02538304f, 0.00911948f, 0.15825938f, 0.33549976f, 0.08633304f, 0.00727326f, 
    0.03264662f, -0.28538930f, -0.08039615f, 0.15471309f, 0.01792353f, 0.05591444f, -0.14711644f, -0.02377061f, 
    -0.28252351f, -0.73212940f, -0.06787527f, 0.24444748f, 0.16203919f, 0.24512352f, 0.15748931f, -0.05768250f, 
    0.10143157f, 0.01886753f, -0.02323266f, 0.01590457f, -0.01581961f, 0.24493271f, 0.39461786f, -0.34270242f, 
    0.02706855f, 0.08325620f, -0.16251680f, 0.05122893f, 0.00923753f, 0.04330787f, -0.08292609f, 0.14212346f, 
    -0.46032599f, 0.02665135f, -0.00001161f, 0.02994274f, -0.03614848f, 0.04406019f, 0.15445875f, 0.01383036f, 
    0.04016810f, -0.06849977f, -0.00774850f, 0.10508452f, 0.28512001f, 0.00715685f, 0.06398180f, -0.13003993f, 
    0.07453073f, 0.09250031f, 0.08838454f, 0.10508601f, 0.05999230f, 0.10031493f, -0.07460577f, 0.09507625f, 
    -0.32674518f, 0.03587921f, 0.26357755f, 0.22336985f, -0.04112019f, -0.09295193f, -0.22982502f, 0.15093522f, 
    0.01791772f, 0.05661434f, 0.07909081f, 0.15132757f, 0.40709376f, -0.05581629f, -0.51057863f, -0.23033299f, 
    0.07948799f, 0.14174871f, 0.47603410f, 0.06905184f, 0.07763892f, 0.01756863f, 0.02786703f, -0.05111745f, 
    -0.06276467f, -0.06530220f, -0.03291085f, -0.08383034f, 0.13526602f, -0.05494716f, -0.03913942f, -0.14430083f, 
    0.11513177f, 0.09756005f, -0.01299845f, -0.09249069f, -0.04760878f, 0.11742149f, 0.08024105f, -0.08290186f, 
    0.07934474f, 0.17693847f, 0.10303554f, -0.03893736f, 0.07568346f, 0.03238071f, 0.00051425f, 0.01488683f, 
    -0.23276243f, -0.16272895f, 0.08624705f, -0.13983294f, -0.00286899f, 0.00262843f, 0.06488027f, 0.00093116f, 
    0.03362924f, 0.05739501f, 0.06308970f, -0.03213727f, -0.09677276f, -0.45348772f, 0.19147390f, 0.01734382f, 
    0.12564686f, 0.07333434f, 0.18166848f, -0.09759250f, 0.14178510f, -0.01247855f, 0.01529580f, -0.05335178f, 
    -0.14500131f, -0.02339204f, 0.15636185f, -0.07946511f, 0.07615048f, -0.12472633f, -0.02444913f, -0.07792886f, 
    0.06060946f, 0.00879455f, 0.03772602f, 0.11076406f, 0.07319822f, 0.44233611f, 0.05628110f, -0.30933097f, 
    -0.03170743f, -0.06234242f, 0.01437003f, -0.05806274f, 0.16469441f, 0.08897488f, 0.22560118f, -0.02478572f, 
    0.11993036f, 0.13971491f, 0.07788036f, -0.12741277f, 0.00574439f, -0.03724024f, -0.01043593f, 0.10253170f, 
    0.22756205f, 0.02773336f, -0.10458304f, -0.05882628f, 0.11349389f, -0.06893748f, -0.39766341f, -0.11623130f, 
    0.06651015f, 0.16733856f, 0.20566683f, -0.04694726f, 0.00760665f, -0.12149595f, 0.03422234f, -0.08459552f, 
    -0.00901139f, -0.12548791f, -0.05181330f, -0.03875078f, 0.14074454f, 0.18540758f, -0.01194604f, 0.06670006f, 
    0.04665628f, -0.07978956f, -0.00321595f, 0.01886453f, -0.24389316f, 0.22227225f, -0.16786170f, -0.16209491f, 
    0.05046567f, 0.10205964f, 0.02606790f, 0.03517925f, 0.02671353f, -0.01544453f, 0.00510232f, 0.05419458f, 
    0.00830596f, 0.07744397f, 0.05175250f, 0.20952727f, 0.06212882f, -0.15920496f, 0.00006740f, 0.11238741f, 
    0.13461335f, 0.04730032f, -0.00654103f, -0.19765022f, 0.00129261f, -0.05703858f, -0.09817912f, -0.02169824f, 
    0.01523642f, -0.06709513f, -0.05657695f, 0.00025553f, 0.06952094f, -0.02540858f, 0.03865816f, 0.04349886f, 
    0.06733556f, -0.21612521f, 0.10838003f, -0.04781079f, -0.07608306f, -0.02130453f, 0.01627959f, 0.03993605f, 
    -0.15042625f, -0.03790452f, -0.19282728f, -0.09018330f, 0.13889456f, 0.00124017f, 0.06785210f, 0.24434996f, 
    -0.10500125f, -0.09290432f, -0.08967667f, -0.02519274f, -0.10072699f, -0.04010014f, -0.01216802f, -0.08344060f, 
    -0.04792309f, 0.23741098f, 0.21992706f, -0.03146803f, 0.06728651f, 0.04935453f, -0.01973624f, -0.14017747f, 
    0.01880683f, -0.07454473f, 0.02360612f, -0.03928327f, -0.04461044f, 0.03971948f, 0.13220359f, -0.01590178f, 
    -0.02822558f, -0.03486544f, -0.00272866f, 0.01974037f, 0.11070985f, 0.01181858f, 0.05664421f, 0.05823629f, 
    -0.20212798f, -0.25986350f, -0.06814601f, -0.07905702f, 0.03531799f, 0.04360968f, 0.06270142f, 0.04151494f, 
    0.05741898f, 0.02579350f, 0.12693128f, -0.01302450f, -0.03286066f, -0.05027290f, 0.12740567f, 0.08905221f, 
    0.06872450f, -0.04708044f, 0.09759407f, 0.16254677f, -0.05907366f, -0.00694479f, 0.05795106f, -0.04421407f, 
    -0.21356003f, 0.03516816f, -0.11566328f, 0.06208478f, -0.00385643f, -0.10390830f, -0.05120059f, -0.05489704f, 
    -0.03439311f, -0.08504690f, 0.12025131f, 0.07117149f, 0.06411833f, -0.12322159f, 0.02190304f, 0.19354206f, 
    0.12018029f, 0.12594137f, -0.02853315f, 0.01030568f, -0.00816689f, 0.04204541f, 0.04381186f, -0.03657748f, 
    -0.00049088f, -0.05172672f, -0.08471522f, -0.01498503f, 0.06690752f, -0.00782495f, 0.09717837f, 0.11196041f, 
    0.02579989f, -0.00899746f, -0.00080837f, -0.02195405f, 0.55561519f, 0.31236359f, -0.06936972f, 0.05369081f, 
    -0.03599561f, -0.04519939f, 0.02862629f, -0.14836478f, 0.01772373f, 0.04728268f, -0.02280091f, 0.03662229f, 
    0.10520640f, 0.16447271f, 0.01002920f, 0.03734424f, 0.03287083f, 0.13231499f, 0.10322766f, 0.06741955f, 
    0.00005555f, -0.01476149f, 0.01604229f, 0.05929079f, 0.08961425f, 0.41209185f, -0.28833428f, 0.11369088f, 
    0.07165630f, -0.16178489f, 0.22660621f, -0.08531231f, 0.07160992f, -0.01820682f, -0.08145881f, 0.07357566f, 
    0.10015304f, 0.06589004f, -0.08746146f, 0.09773628f, 0.25115198f, 0.22161968f, -0.19619267f, 0.11995751f, 
    -0.13212372f, 0.12878475f, -0.09706478f, 0.00579979f, 0.06338441f, 0.01018210f, -0.22584642f, -0.08981427f, 
    0.04189394f, 0.18161692f, 0.17041989f, 0.11116582f, 0.16571331f, 0.13871972f, -0.03379035f, -0.03877468f, 
    0.16842185f, 0.13294549f, -0.08168466f, -0.08621866f, 0.04412010f, 0.03360692f, 0.04349547f, 0.24614233f, 
    0.10914700f, 0.08175217f, 0.06638639f, -0.04592650f, 0.29748210f, 0.01016763f, -0.24079268f, 0.05219559f, 
    -0.07080439f, 0.12006237f, -0.03798468f, -0.03781716f, -0.00359939f, 0.08071897f, 0.30213425f, 0.19475614f, 
    0.05508419f, -0.16757874f, 0.19735241f, 0.00251023f, 0.20649974f, 0.02343771f, -0.12807830f, 0.07168473f, 
    -0.09218016f, 0.10189915f, 0.12599064f, -0.21456711f, 0.09092680f, -0.04796107f, -0.04726762f, 0.00513094f, 
    -0.07257646f, -0.06370976f, 0.01607350f, 0.03082410f, 0.05564161f, -0.10654143f, 0.08540844f, -0.06387123f, 
    0.03995129f, -0.21011393f, -0.12939492f, -0.08044308f, 0.03097740f, 0.16608331f, 0.02078117f, -0.07690954f, 
    -0.05678252f, -0.06756827f, 0.02282893f, -0.03079817f, 0.33344471f, -0.00631861f, -0.03412941f, 0.00967296f, 
    -0.04963422f, 0.04840854f, -0.19323045f, -0.06975356f, -0.06245472f, -0.03643930f, -0.10467692f, 0.03554357f, 
    -0.10071903f, -0.03213962f, -0.14811099f, 0.00070880f, 0.15243921f, -0.10984374f, 0.09434245f, -0.04521754f, 
    0.04115392f, -0.02477090f, -0.06564804f, 0.07311117f, -0.04689685f, -0.05179365f, 0.08469468f, 0.05525945f, 
    0.02509120f, -0.02935707f, 0.07034307f, 0.13339669f, -0.06940053f, 0.01509649f, -0.01855387f, 0.08289895f, 
    0.21954946f, 0.13068940f, 0.05568072f, 0.09965023f, -0.02732889f, 0.09698164f, -0.02026114f, 0.02988416f, 
    -0.03762894f, 0.02504893f, -0.07912147f, 0.11567384f, 0.03170994f, 0.31238574f, -0.26214096f, 0.21081330f, 
    -0.11935603f, -0.06981278f, -0.04648301f, 0.00502549f, -0.02132939f, 0.05417016f, 0.12697265f, -0.06091978f, 
    0.17542605f, -0.00584038f, -0.06852257f, 0.05149087f, 0.01567864f, -0.03084889f, -0.11496590f, -0.03722743f, 
    -0.01469366f, 0.15742207f, -0.07737608f, 0.13394724f, -0.24087526f, -0.02901916f, -0.05584546f, -0.03222461f, 
    -0.09619458f, 0.01049777f, -0.04951574f, 0.10931909f, -0.00428792f, 0.13234146f, -0.01049553f, -0.09181582f, 
    0.13986601f, 0.05502573f, -0.04498121f, -0.14863648f, 0.03913844f, -0.02344141f, -0.05989951f, -0.10190697f, 
    -0.12795296f, -0.05065294f, 0.06464528f, -0.12905379f, 0.11628389f, -0.10462066f, 0.24953935f, -0.00904681f, 
    -0.05056709f, -0.12002910f, -0.09587660f, -0.04696840f, -0.00338782f, 0.05192706f, -0.12607442f, -0.08111905f, 
    -0.01645735f, 0.01950200f, 0.00651781f, -0.01806734f, -0.00006910f, 0.08948451f, -0.01729229f, -0.09885767f, 
    -0.07810792f, 0.02242404f, 0.01355477f, -0.08679446f, 0.02512957f, -0.05418320f, -0.03527213f, -0.01579746f, 
    0.03816461f, 0.06493942f, 0.08120354f, -0.10940920f, -0.12100796f, -0.10703053f, -0.07790798f, -0.05557896f, 
    -0.05872476f, -0.14406505f, -0.00458710f, 0.00107912f, 0.12081917f, 0.12140264f, 0.13983162f, -0.16024829f, 
    0.17994314f, 0.09744045f, 0.12031341f, 0.21154985f, -0.15475717f, -0.19953224f, 0.03519543f, 0.18537489f, 
    -0.08543126f, -0.06268051f, -0.20653068f, 0.03315648f, 0.10137003f, -0.05819611f, 0.07487492f, 0.01044581f, 
    -0.15305538f, -0.05076776f, 0.27548110f, 0.11525279f, -0.02382741f, -0.04475933f, 0.04479900f, -0.08685385f, 
    0.04091664f, 0.22078104f, 0.08286165f, 0.12874363f, -0.21525036f, -0.07401428f, 0.15945320f, -0.04943367f, 
    -0.14477569f, -0.11995072f, -0.14690934f, -0.20089827f, -0.10996696f, -0.04006425f, 0.09161940f, 0.00821395f, 
    0.00559928f, -0.07874241f, 0.06071331f, 0.16839641f, 0.02716378f, -0.02976969f, -0.07189779f, -0.09744220f, 
    0.01976810f, 0.05284284f, 0.13296339f, -0.00202723f, 0.04129683f, 0.07801460f, -0.11408065f, -0.23919833f, 
    -0.09242107f, 0.10879676f, -0.00259381f, 0.08009534f, -0.00759290f, -0.03315697f, 0.00510245f, -0.04312946f, 
    0.24990319f, -0.05650857f, 0.26913983f, -0.05630482f, -0.03393815f, 0.04584327f, 0.09207249f, 0.07091810f, 
    0.07954253f, 0.05490568f, -0.07371993f, 0.04787753f, 0.05932112f, -0.10150863f, 0.11895157f, 0.00426226f, 
    0.01613591f, -0.01192119f, -0.02552587f, 0.05345982f, -0.16494618f, -0.30441168f, 0.13233367f, -0.31593767f, 
    0.27639815f, 0.21251385f, 0.02928625f, -0.01360544f, -0.11598689f, -0.09723787f, 0.16710801f, -0.02243147f, 
    -0.06302073f, -0.07150275f, 0.08034499f, 0.00670509f, 0.15476221f, -0.08221660f, 0.11085775f, 0.15630347f, 
    0.05629921f, 0.13435376f, -0.01867164f, -0.05274261f, 0.00316484f, -0.00068274f, 0.09259252f, 0.09080034f, 
    -0.04314322f, -0.19091932f, 0.16998784f, 0.02322416f, -0.09245279f, 0.11201945f, -0.04963714f, 0.20006083f, 
    -0.08272158f, -0.28250375f, -0.06106994f, -0.09902591f, 0.38614213f, 0.24165820f, 0.14747031f, 0.13287632f, 
    -0.10686856f, -0.24065574f, 0.07178786f, -0.22055005f, 0.17641415f, 0.05019248f, 0.03634430f, -0.09489170f, 
    0.19936332f, -0.05282957f, 0.07609211f, -0.10279968f, 0.01864690f, 0.02878746f, 0.04105691f, 0.10632060f, 
    0.02843905f, -0.13607924f, 0.01772470f, 0.02864324f, 0.19453539f, 0.13980009f, -0.03616883f, -0.13961683f, 
    0.05232850f, -0.11885866f, 0.26828524f, -0.01060835f, 0.05240713f, -0.13839827f, 0.12014721f, -0.00869695f, 
    0.16571844f, 0.10818160f, -0.03526473f, 0.13257830f, 0.02352777f, 0.17433575f, -0.06591256f, -0.06022474f, 
    0.04910131f, 0.06220995f, -0.08394995f, 0.18418297f, -0.23487985f, 0.14764284f, -0.54722470f, -0.21069720f, 
    0.00678451f, 0.03013364f, 0.16068149f, -0.15878662f, -0.06085607f, 0.11944599f, -0.09996593f, 0.08744711f, 
    -0.19694385f, 0.19386083f, -0.44172582f, -0.26989105f, -0.03717127f, 0.08465234f, 0.04305433f, 0.27183625f, 
    0.07047059f, -0.16598700f, 0.00962325f, 0.05452431f, 0.16107625f, 0.11334006f, -0.19324772f, 0.14396325f, 
    0.05222565f, 0.09181563f, 0.09743777f, -0.15523055f, 0.11075175f, 0.07830708f, 0.02410088f, 0.38690767f, 
    0.23561054f, -0.00455460f, -0.09793471f, 0.02871581f, -0.04479814f, 0.24238040f, -0.10203601f, 0.06578849f, 
    0.03321400f, 0.06899623f, 0.12204086f, 0.04333103f, -0.04014038f, -0.24315244f, 0.09565300f, -0.02393357f, 
    -0.06367616f, -0.07749737f, -0.01307888f, -0.02940333f, 0.07993898f, 0.06267494f, 0.11998176f, 0.09768443f, 
    0.30757394f, 0.14782831f, 0.12652425f, 0.03693374f, -0.17428586f, 0.12319566f, -0.04314099f, -0.04223923f, 
    0.04615952f, -0.06007894f, 0.00740077f, 0.14906281f, 0.06924443f, -0.16754049f, -0.03027540f, -0.29657736f, 
    0.02203806f, -0.13828000f, -0.16888979f, -0.02245292f, -0.02067155f, -0.18759891f, -0.18410636f, 0.09273265f, 
    -0.01341366f, 0.03242448f, -0.05561692f, 0.23308879f, 0.07765867f, -0.43825561f, 0.17855559f, 0.01345790f, 
    0.12256779f, -0.09446192f, -0.22924666f, -0.09465882f, 0.01798580f, -0.03609589f, -0.19231150f, -0.13800146f, 
    -0.06223499f, 0.00363285f, -0.01876531f, 0.07793391f, -0.01216675f, 0.03077684f, 0.12773101f, 0.01866948f, 
    0.24784648f, 0.09837763f, -0.01500389f, -0.06416626f, -0.03967436f, 0.08226308f, -0.00185950f, 0.17910086f, 
    -0.00990671f, -0.04863416f, 0.02630020f, 0.00992937f, 0.02103134f, 0.09094429f, -0.09563077f, 0.30180180f, 
    0.17205761f, -0.14917617f, 0.06298041f, -0.03758202f, 0.00452736f, 0.00180874f, 0.17503281f, 0.03749299f, 
    0.31996188f, 0.22153869f, 0.06693229f, 0.05149391f, 0.01026867f, -0.28378075f, 0.07012536f, -0.10294930f, 
    -0.01279357f, 0.05895537f, -0.16016015f, 0.05664157f, 0.03253493f, -0.04534946f, 0.07668670f, 0.12886328f, 
    -0.02655319f, 0.06255205f, -0.10663725f, 0.13870752f, 0.01288477f, 0.13017333f, 0.04392342f, 0.25287178f, 
    0.20722446f, 0.11464404f, -0.02467966f, 0.01033849f, 0.00751471f, -0.11689870f, 0.00482037f, -0.07305207f, 
    0.07227829f, 0.28726432f, 0.11791793f, 0.02900647f, -0.29343399f, -0.07288576f, 0.33078048f, 0.11840186f, 
    -0.03831126f, -0.38047358f, 0.06296057f, -0.13349234f, -0.01563767f, 0.06469750f, -0.14547423f, -0.02512847f, 
    -0.16348474f, -0.01771962f, -0.10357853f, -0.14533155f, -0.15186244f, -0.01124413f, 0.04622478f, 0.02920638f, 
    -0.06150347f, -0.07343685f, -0.09002966f, 0.08855202f, 0.06818498f, -0.24564891f, -0.30455440f, -0.14487113f, 
    0.03257293f, 0.10079786f, 0.08065639f, -0.13860138f, -0.01615319f, -0.13782784f, -0.07699631f, -0.01228682f, 
    0.06615509f, 0.18014203f, 0.21150437f, -0.01675790f, 0.02667848f, -0.04372993f, -0.23022835f, 0.23474115f, 
    -0.02485195f, -0.02745918f, -0.05212723f, 0.21356355f, 0.06649263f, -0.21197258f, -0.02829960f, -0.10572813f, 
    -0.06619851f, -0.03204931f, -0.06365397f, -0.03440999f, 0.02567846f, 0.01050717f, -0.04074033f, -0.00680946f, 
    -0.20412393f, -0.11908943f, -0.00959239f, -0.01441930f, 0.04458823f, 0.00043439f, -0.03805438f, 0.02858853f, 
    -0.06730314f, -0.05594731f, 0.01893675f, 0.03381765f, -0.30262473f, -0.48264056f, -0.02789775f, -0.03408498f, 
    -0.10918913f, 0.01032507f, -0.10104837f, 0.01876178f, -0.02939593f, 0.00128617f, -0.02283023f, -0.10229293f, 
    0.41393101f, 0.31285971f, 0.19683701f, 0.25201175f, -0.00334916f, 0.03699020f, -0.01663369f, 0.05702601f, 
    -0.08996451f, -0.05434241f, -0.10591539f, -0.06628029f, -0.00338651f, 0.27836916f, 0.10377545f, -0.08249513f, 
    -0.09883549f, 0.02115079f, -0.00957121f, 0.08477182f, 0.05903681f, 0.01846577f, -0.15173602f, -0.05467603f, 
    0.49128360f, 0.09128326f, -0.12622988f, 0.14073867f, 0.01896665f, -0.07558591f, -0.07155115f, 0.01729666f, 
    -0.07783300f, -0.01867169f, 0.05187432f, -0.02479882f, 0.19214222f, 0.15333560f, 0.19084714f, -0.02286854f, 
    0.07476976f, 0.12604465f, 0.03825697f, 0.29200783f, 0.00371298f, -0.03299819f, 0.02123167f, 0.06153764f, 
    -0.21991000f, 0.17358761f, 0.19256827f, 0.24306601f, 0.03211472f, -0.03837245f, -0.11086504f, -0.00064529f, 
    -0.00693455f, 0.03163775f, 0.00239721f, -0.05027802f, 0.08810570f, 0.10224734f, 0.19304997f, 0.15224341f, 
    -0.13250114f, -0.01704249f, 0.01510306f, 0.02907848f, -0.03376095f, -0.08165170f, -0.04781103f, -0.09259161f, 
    -0.06010624f, -0.09755972f, 0.01081021f, -0.08917630f, 0.06933511f, -0.02213220f, 0.00146240f, 0.17005776f, 
    0.15170664f, 0.04770396f, 0.02470478f, 0.11459976f, 0.43646580f, 0.03261019f, 0.03559979f, -0.20334573f, 
    0.06579696f, -0.04531784f, 0.04649771f, -0.11381473f, 0.03737821f, 0.00015875f, 0.07632537f, 0.09577107f, 
    0.28542075f, 0.23095472f, 0.08932749f, -0.17809702f, 0.15960637f, 0.18068661f, 0.00523780f, 0.19984834f, 
    0.05342349f, -0.07631271f, -0.01674318f, -0.05822669f, -0.04868614f, 0.03740457f, 0.39485165f, -0.18994357f, 
    0.06820685f, -0.12064217f, 0.04485349f, 0.20856382f, -0.13331732f, -0.01001549f, 0.08718643f, -0.02812943f, 
    0.49922463f, 0.19593036f, 0.06269598f, -0.07701974f, -0.31236905f, 0.13839629f, 0.00405896f, 0.00623234f, 
    -0.01619799f, -0.06953023f, 0.03901576f, 0.18290330f, -0.35309982f, 0.24576670f, 0.19486144f, 0.14560595f, 
    0.08782297f, 0.02563009f, 0.20103504f, -0.29241669f, 0.01007748f, 0.05652527f, 0.03197438f, 0.09319954f, 
    -0.04847313f, 0.20295666f, 0.10577627f, -0.25413394f, 0.09714411f, -0.05174171f, 0.08010352f, 0.17528090f, 
    -0.00935695f, 0.05746367f, 0.01929551f, 0.03638832f, 0.26987332f, -0.04356831f, 0.21799852f, -0.21469060f, 
    -0.03636961f, -0.09700777f, -0.15522495f, 0.13500118f, -0.11813920f, 0.06055650f, -0.04605392f, -0.03243974f, 
    -0.10113100f, 0.48218557f, 0.05902450f, 0.18372256f, 0.03825729f, -0.20420982f, -0.05724670f, 0.15654677f, 
    -0.06237762f, -0.00252860f, -0.06411731f, -0.00561276f, -0.11255512f, -0.10285097f, 0.12265213f, 0.00189760f, 
    0.05902951f, -0.05529702f, 0.00903320f, -0.09409510f, -0.00916382f, -0.10647532f, 0.00347918f, -0.07820693f, 
    -0.09190567f, -0.03354946f, 0.10723655f, 0.04266793f, -0.00615058f, -0.10576445f, -0.07865940f, -0.05574602f, 
    -0.03208546f, 0.07481785f, -0.01708208f, 0.06011856f, -0.03107884f, -0.16459969f, -0.05139908f, -0.11856387f, 
    -0.05065734f, 0.12602492f, 0.00852868f, 0.09681614f, 0.02159289f, -0.01913972f, -0.19926664f, 0.05472475f, 
    -0.05588982f, -0.24063823f, -0.09162931f, -0.02932799f, 0.13142791f, -0.01071262f, 0.10140262f, 0.02702079f, 
    0.14732267f, 0.04114541f, 0.16461018f, 0.16036496f, 0.28723261f, 0.23690011f, -0.06571768f, 0.07311005f, 
    0.06084620f, 0.02579774f, 0.07009057f, 0.11057429f, 0.04292763f, 0.10667309f, -0.09124863f, -0.10420989f, 
    0.25044200f, 0.27646765f, 0.24229884f, -0.08147248f, 0.16686472f, 0.17456575f, 0.02258554f, 0.10344782f, 
    0.10081807f, -0.08665717f, -0.08423164f, -0.01201461f, 0.17054111f, -0.12342804f, 0.12186225f, -0.40254089f, 
    -0.10131925f, -0.16963312f, -0.05179663f, 0.16051117f, -0.11070536f, -0.14405479f, -0.13427900f, -0.08399636f, 
    0.14567629f, -0.16887236f, -0.04192255f, -0.07070810f, 0.01916388f, -0.02701890f, 0.01043785f, -0.02098745f, 
    0.03794867f, 0.13424313f, 0.03132146f, 0.00448647f, 0.26056194f, 0.06760836f, -0.00525942f, 0.25187448f, 
    -0.07822993f, -0.10820483f, -0.07492647f, 0.00925696f, -0.11530652f, -0.00149547f, -0.07858538f, 0.03571504f, 
    0.07165805f, -0.11560044f, 0.02962903f, 0.08119094f, -0.03097911f, 0.03924847f, -0.03038297f, -0.09742437f, 
    -0.04219784f, -0.07148636f, -0.01061934f, 0.05727454f, -0.33630651f, -0.31556851f, -0.39622825f, 0.07306418f, 
    -0.13832000f, -0.03426199f, -0.05309806f, -0.02352545f, 0.02350206f, 0.04330287f, 0.00959628f, 0.00268467f, 
    -0.04964873f, -0.05744681f, -0.12837103f, -0.12039167f, 0.07934643f, -0.00532507f, 0.12151448f, -0.00331434f, 
    -0.04190687f, 0.16057621f, 0.09196453f, 0.14530277f, 0.23687339f, 0.19303600f, -0.01301362f, 0.09977122f, 
    0.00143599f, 0.07127204f, 0.18380019f, 0.20566761f, -0.09656043f, 0.06385531f, 0.08707176f, 0.04062676f, 
    0.12647228f, 0.00449581f, 0.18423966f, -0.03888809f, -0.17480239f, -0.08977214f, 0.03668078f, 0.19100246f, 
    -0.19803905f, 0.02424296f, 0.04219069f, -0.01823372f, 0.00790743f, 0.01272117f, -0.00163451f, 0.00213882f, 
    0.00176976f, -0.06668986f, 0.03123243f, 0.01680274f, 0.02497432f, -0.08855879f, -0.06061149f, 0.17454343f, 
    -0.16014813f, -0.09573674f, -0.20222917f, 0.12547711f, 0.00544658f, 0.11480753f, 0.01410650f, 0.03617642f, 
    0.08967079f, -0.01066416f, 0.12823185f, 0.01643932f, 0.25595114f, 0.06276412f, -0.16724037f, 0.25573778f, 
    -0.03423517f, -0.01324622f, 0.04087829f, 0.06583174f, -0.01797539f, 0.03217833f, 0.04524448f, 0.02462172f, 
    -0.47899228f, 0.52826929f, -0.01899476f, -0.19612500f, -0.00842754f, 0.13513125f, 0.00681101f, 0.02026770f, 
    0.13234147f, -0.03598515f, 0.00754791f, 0.05280934f, 0.34441707f, -0.02248585f, 0.07393949f, 0.04554929f, 
    0.13340414f, -0.08724307f, 0.28584909f, -0.00888203f, 0.06110172f, 0.09633916f, -0.05347731f, 0.10649334f, 
    -0.25852326f, -0.05510003f, -0.19740085f, 0.04501316f, 0.08557541f, 0.13965628f, -0.05558190f, 0.01408519f, 
    0.08885792f, 0.03566174f, 0.03711801f, -0.14522834f, 0.08206382f, 0.20111646f, 0.16986114f, -0.15598921f, 
    0.02843948f, 0.08922115f, 0.03232638f, -0.30014995f, 0.06179033f, 0.03668849f, -0.08082552f, -0.01729468f, 
    -0.16510101f, -0.17804156f, 0.01275951f, 0.07822920f, 0.12734580f, -0.11471299f, -0.00904018f, 0.03350579f, 
    -0.02884543f, 0.04908813f, 0.00429034f, 0.08640405f, 0.00888203f, 0.02858722f, -0.08971506f, -0.31323558f, 
    0.12563927f, 0.14071690f, 0.03427305f, 0.00382916f, -0.00305394f, 0.03392620f, -0.04081378f, -0.04971973f, 
    -0.05007683f, 0.09663981f, -0.01825625f, 0.00952674f, -0.11768832f, -0.00665869f, 0.10399405f, -0.01623589f, 
    -0.01007288f, -0.01123837f, -0.01543691f, -0.00126579f, -0.30327559f, -0.16389498f, -0.29532295f, -0.00517946f, 
    -0.13867512f, 0.07017946f, -0.00851346f, 0.03945963f, -0.09365829f, -0.19745298f, 0.09815354f, 0.10609294f, 
    0.15605995f, 0.30028376f, -0.22471531f, -0.17521138f, 0.04685462f, 0.17162357f, 0.17596170f, 0.01949843f, 
    0.03223056f, 0.00858787f, 0.10963854f, -0.00508836f, 0.35330167f, 0.24357565f, -0.36589813f, 0.00961769f, 
    0.11146246f, 0.06025771f, 0.22827244f, 0.08888831f, -0.02416193f, 0.06368166f, -0.06460294f, -0.04077943f, 
    -0.10128909f, -0.11419668f, -0.07814076f, -0.11974153f, 0.10874643f, -0.10449853f, -0.00727749f, 0.07588577f, 
    0.00429357f, 0.01550359f, 0.02032684f, 0.10186446f, 0.61054552f, -0.12064805f, 0.09477542f, -0.13562043f, 
    0.13535246f, -0.06212766f, 0.14808734f, 0.18852624f, -0.08640085f, 0.04883064f, -0.05989204f, -0.02479833f, 
    0.26113838f, 0.19991881f, 0.23077916f, -0.05881036f, 0.09259967f, -0.07626068f, -0.01097598f, 0.00645667f, 
    0.17591426f, -0.04294923f, -0.08725367f, 0.07534555f, 0.12864208f, -0.08715566f, -0.27187625f, 0.07519095f, 
    0.00778024f, 0.17409424f, -0.05788470f, 0.10906187f, -0.07824475f, 0.04722248f, 0.19207160f, -0.11964291f, 
    -0.16793257f, -0.20517109f, 0.21008565f, -0.23440036f, 0.03989273f, -0.17500100f, -0.04933261f, -0.06499224f, 
    0.12692127f, 0.04407567f, 0.12339239f, -0.00871409f, -0.16056339f, 0.01069059f, -0.02096684f, -0.04423445f, 
    -0.00553159f, 0.05407719f, 0.02291953f, -0.00576592f, 0.17274497f, 0.04777503f, 0.21510702f, 0.13347581f, 
    -0.21174404f, -0.21412782f, -0.05882868f, -0.05685731f, 0.09324549f, 0.09408614f, 0.10738924f, 0.12498780f, 
    0.02740365f, 0.05516720f, -0.01157561f, 0.07223868f, 0.04087240f, 0.09032658f, -0.23510061f, 0.33886123f, 
    0.02296136f, 0.15973641f, -0.36737862f, -0.09458098f, -0.05724503f, -0.00142824f, 0.03338456f, -0.03948988f, 
    -0.09261259f, 0.05304464f, -0.04818875f, 0.05798545f, -0.09765615f, 0.11212099f, -0.13103618f, 0.05786894f, 
    -0.06214374f, -0.01002937f, 0.07605153f, 0.01153193f, 0.25694063f, 0.15568237f, 0.03058320f, -0.12297801f, 
    -0.13736954f, -0.10356103f, -0.01946190f, -0.05219710f, -0.07465340f, -0.17917106f, -0.07952213f, -0.10924001f, 
    0.23255688f, 0.23518813f, -0.02773476f, 0.00217626f, 0.02521678f, 0.17759977f, 0.22928309f, 0.08395617f, 
    0.04151110f, -0.02288765f, 0.04245358f, 0.17556214f, -0.14627077f, -0.00498106f, -0.11439759f, 0.07986914f, 
    -0.13689291f, 0.01519739f, 0.02063738f, -0.10312977f, -0.01468788f, 0.01022674f, -0.07541891f, -0.08063935f, 
    -0.06164058f, -0.10177075f, -0.03872151f, 0.02349970f, -0.02682932f, 0.05504169f, -0.00190873f, 0.09872784f, 
    -0.19348089f, 0.12406437f, 0.04104368f, 0.09053002f, -0.24310546f, -0.13288631f, -0.24284707f, -0.01610382f, 
    -0.01827842f, 0.06320154f, -0.05795484f, -0.07067553f, -0.07135632f, 0.26375979f, 0.03987797f, -0.01628484f, 
    -0.14608897f, -0.15294302f, -0.06395198f, 0.00683096f, 0.02789722f, -0.00049014f, 0.00981728f, 0.00331176f, 
    0.08557085f, -0.05214724f, 0.09523687f, 0.20376433f, 0.00537135f, -0.04453190f, 0.01293027f, 0.05150929f, 
    0.12933859f, 0.11510362f, -0.15776584f, 0.07343664f, -0.06490190f, -0.10286818f, 0.03621166f, 0.04279364f, 
    0.04757993f, 0.00665021f, 0.06714152f, 0.00585341f, 0.11536107f, 0.05136764f, -0.15163527f, -0.09279252f, 
    0.11105440f, -0.00912812f, 0.04577170f, -0.10495012f, 0.40948448f, 0.16363788f, 0.00291445f, -0.09400652f, 
    0.07426386f, 0.14869769f, 0.11158948f, 0.10586973f, 0.03703334f, 0.03649387f, 0.02510612f, -0.03375500f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02102032f, 0.13448073f, -0.00824177f, -0.07880878f, 0.20939495f, 0.20734933f, -0.03319559f, -0.00595145f, 
    0.08384591f, -0.10303999f, 0.10999232f, -0.05030275f, 0.14346424f, 0.14529830f, -0.13039035f, -0.05725527f, 
    0.14467102f, 0.02320772f, 0.11243073f, -0.04034588f, -0.03981828f, 0.04024934f, -0.05593727f, 0.16327484f, 
    0.09776786f, -0.06177861f, 0.00767398f, 0.15113072f, 0.03577894f, -0.03188595f, 0.06966719f, -0.03684352f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.28431100f, 0.08381806f, -0.05624500f, 0.18632190f, -0.22028826f, -0.67918640f, 0.20311551f, -0.08825899f, 
    -0.37072602f, 0.05171008f, -0.63468087f, 0.10450906f, -0.45797414f, 0.02864455f, -0.06956487f, 0.10945224f, 
    -0.13223839f, 0.29787070f, 0.26211888f, -0.40144849f, -0.02181830f, 0.20496948f, -0.09411643f, -0.27511066f, 
    -0.43176746f, 0.09968060f, -0.03207396f, -0.51774120f, -0.04782395f, 0.40250245f, 0.17204855f, 0.31201923f, 
    0.01877446f, 0.08668954f, -0.12333260f, 0.25724384f, -0.04315607f, 0.00263727f, -0.50655067f, -0.02979625f, 
    -0.06667680f, 0.14155106f, 0.13894297f, 0.03647726f, 0.50131172f, 0.18550658f, -0.94810605f, 0.05743836f, 
    0.17214489f, -0.23223095f, 0.33319235f, -0.79026413f, -0.12513344f, 0.22225355f, 0.13037463f, -0.35760847f, 
    -0.25126743f, -0.11707976f, -0.10622615f, -0.25812289f, 0.31513530f, 0.20718642f, 0.23135176f, -0.09890718f, 
    -0.05234589f, 0.29946136f, 0.03656641f, -0.04483692f, -0.23947787f, 0.31945142f, -0.45684183f, -0.64379972f, 
    -0.11538485f, 0.03806973f, 0.16483486f, -0.03152223f, -0.65034604f, 0.03236212f, 0.02806995f, 0.07080321f, 
    -0.28574964f, 0.02321284f, 0.04422156f, 0.16019160f, -0.07108987f, -0.07327018f, -0.42225602f, 0.08650798f, 
    0.08222912f, -0.13415849f, 0.10563663f, -0.15126908f, -0.05838822f, 0.33096501f, -0.01268941f, -0.25996870f, 
    -0.08799656f, -0.49253964f, -0.08833633f, 0.27492312f, -0.59070724f, -0.27802727f, -0.05240010f, 0.18056537f, 
    -0.06356382f, 0.06894651f, 0.24470730f, 0.04729357f, 0.24284865f, -0.13860297f, 0.15108663f, 0.01468071f, 
    -0.38072726f, -0.12372673f, -0.24594371f, 0.30118901f, 0.02893257f, -0.53853124f, -0.06486315f, 0.14924598f, 
    0.15039265f, 0.22028224f, 0.10222198f, -0.53192097f, 0.23709275f, 0.05020197f, 0.08861919f, -0.08140544f, 
    0.24925423f, 0.07328852f, -0.07172092f, 0.04561444f, -0.31908453f, -0.17145260f, 0.25555569f, 0.11939920f, 
    -0.32353956f, 0.24743408f, -0.15989994f, 0.01683055f, -0.40789437f, 0.20342107f, 0.25839555f, 0.13892457f, 
    0.19454774f, 0.22171086f, -0.30486241f, -0.07729405f, 0.09266378f, 0.13962539f, 0.23356771f, 0.21281502f, 
    -0.19136690f, -0.31594416f, 0.01298243f, -0.02874897f, -0.25493261f, -0.31547549f, 0.01105405f, -0.08384442f, 
    -0.32485399f, -0.01965297f, 0.03049404f, -0.20927180f, 0.44740400f, -0.04293529f, 0.43666890f, 0.13106279f, 
    -0.24974868f, -0.29769376f, -0.40074766f, -0.09398106f, 0.09693386f, 0.18768121f, -0.58916473f, -0.16715609f, 
    -0.35860932f, -0.03620844f, 0.14404708f, -0.33799794f, 0.06094699f, -0.21252488f, 0.01252697f, 0.16803025f, 
    0.09978669f, -0.10695111f, -0.14401807f, 0.18008839f, 0.10810990f, -0.31034204f, 0.12135871f, 0.33803505f, 
    -0.13537335f, 0.06055512f, 0.06280554f, -0.35698974f, -0.32158962f, 0.22150917f, -0.07073007f, -0.39430481f, 
    0.06056557f, -0.40204990f, 0.02799242f, 0.00608392f, -0.59540147f, -0.15115145f, -0.24357697f, 0.13715038f, 
    -0.09280284f, 0.04954018f, -0.59422952f, -0.05710648f, -0.07284273f, 0.26098663f, 0.18267128f, 0.40349475f, 
    -0.11787976f, 0.01353645f, -0.08336688f, 0.49185023f, -0.05564693f, 0.15549800f, -1.00322139f, -0.14497486f, 
    0.31944686f, 0.02320200f, 0.03103286f, -0.42828986f, -0.06384343f, -0.15185598f, 0.44304544f, -0.24663447f, 
    0.02361887f, -0.54873353f, 0.14873847f, -0.01857379f, -0.05968124f, -0.16449685f, 0.42933324f, 0.11694228f, 
    0.08177485f, -0.56593823f, 0.18981555f, 0.33418784f, -0.12483961f, -0.03513046f, 0.14309606f, -0.47156954f, 
    0.28386241f, -0.05197551f, 0.13131265f, -0.30134147f, -0.07449911f, 0.18446890f, -0.46117297f, -0.27956846f, 
    -0.31162477f, -0.43556440f, -0.13936684f, 0.22215278f, 0.33823842f, -0.04458356f, -0.65125346f, -0.33703688f, 
    0.02774395f, -0.51681268f, -0.15388404f, -0.13803329f, -0.04228254f, -0.15953340f, -0.10526302f, -0.01391133f, 
    0.38733643f, -0.76717544f, 0.12307578f, -0.20559917f, 0.10351992f, -0.26345605f, -0.44404438f, 0.32500392f, 
    0.39191630f, 0.34029862f, -0.03102084f, -0.29069939f, -0.01173186f, -0.06269699f, -0.35621819f, 0.14079641f, 
    0.17663561f, 0.18602483f, 0.10399673f, -0.06556424f, 0.13361412f, 0.01983826f, -0.31612390f, 0.23934744f, 
    -0.24530745f, -0.45769939f, -0.23528051f, -0.04626357f, 0.03004573f, -0.40894705f, 0.37727633f, -0.08106571f, 
    0.05802592f, 0.28993014f, -0.55635870f, 0.31062472f, -0.07905822f, 0.46525618f, -0.34590742f, -0.45322198f, 
    0.06935017f, -0.40703961f, 0.06172961f, 0.37772918f, -0.18948676f, -0.10930955f, 0.29476666f, -0.12085414f, 
    0.31353909f, -0.72946584f, -0.04511655f, 0.10658403f, 0.03149876f, -0.29178879f, 0.26547214f, -0.59634054f, 
    0.07965135f, 0.08607458f, 0.45830473f, 0.07119761f, -0.16824187f, -0.08771461f, -0.38577193f, -0.01765151f, 
    -0.45474690f, -0.16334920f, 0.17941412f, -0.50254178f, -0.04613616f, 0.10372192f, -0.35685426f, 0.02774676f, 
    0.28081623f, 0.14513302f, -0.05141401f, -0.06864739f, -0.46328422f, -0.47232795f, 0.30100670f, -0.41761759f, 
    0.41111907f, -0.12063345f, 0.01363857f, 0.10595012f, -0.37781483f, 0.20341913f, 0.05936974f, -0.31983569f, 
    0.41497463f, -0.36122069f, -0.42515397f, 0.07766348f, -0.28992835f, 0.07133796f, -0.26853493f, 0.08104221f, 
    0.23841886f, 0.36681914f, 0.08155051f, -0.21793798f, 0.16587913f, -0.31483266f, -0.02402941f, 0.00651631f, 
    -0.24469563f, 0.01998923f, 0.17536598f, -0.28853697f, 0.17930853f, -0.62849247f, -0.40393829f, 0.24994394f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09083033f, 0.12553309f, 0.23249164f, -0.10646563f, -0.09133875f, 0.04987169f, -0.16738145f, -0.22457463f, 
    0.13888370f, -0.21639474f, 0.08535083f, -0.07515708f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
