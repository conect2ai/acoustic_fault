#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.74970561f, -1.66159034f, -1.04686594f, -0.07128176f, -0.39079064f, -0.24171199f, 0.12413473f, 0.37354502f, 
    0.32982269f, -0.75723600f, -0.37470758f, -0.75974590f, -0.94226837f, 0.03740794f, -0.25875533f, 0.78993088f, 
    0.93693364f, 0.11670437f, 1.03144431f, 0.93715954f, 0.30944872f, -1.45107985f, 0.39919135f, -0.32000867f, 
    -0.12984705f, -0.26091707f, 0.09351001f, 0.89289439f, -1.30809891f, -0.73181826f, 1.22278762f, 0.83958542f, 
    0.37182179f, -0.19872454f, 0.03048322f, -0.25529319f, -0.79719126f, 0.22380778f, 0.17177761f, -0.49190608f, 
    -0.91409284f, -0.69055766f, 0.52747309f, -0.53499860f, 0.46394256f, -1.51222134f, -0.25781369f, -1.21640193f, 
    -0.27547866f, 0.21548483f, -0.05105636f, 0.90283144f, -0.66540134f, 0.06149450f, -0.45551169f, -0.26526502f, 
    0.17529373f, -1.10965967f, -0.87244070f, -1.34851074f, -0.58357298f, 0.01558445f, 0.39538220f, 0.33050090f, 
    1.25377285f, 0.28859809f, 0.91292942f, 1.29394472f, 0.95489806f, -0.12008125f, -0.06243466f, 0.32598895f, 
    1.24157500f, 1.21768391f, 0.73604476f, -0.26953626f, -0.79833496f, -0.24017103f, 0.40103880f, 0.77240425f, 
    -0.49226090f, -1.48664153f, -0.39416626f, 0.99762177f, 0.70727634f, 1.08687937f, 0.17785595f, 0.53957963f, 
    0.27337387f, 0.02031094f, -0.71145880f, -1.23419404f, -0.75668669f, -0.72849953f, 0.67448515f, 0.43325293f, 
    -0.44650489f, 0.25623003f, -0.35460922f, -1.38380384f, -0.75994927f, 0.14420180f, 0.70007330f, -0.67112726f, 
    -0.35828772f, 0.46409824f, -0.42884955f, -0.21380755f, -1.89488292f, 0.61826956f, -0.53900331f, -0.42805704f, 
    0.98882437f, 0.34164038f, -0.32173294f, -0.18939136f, 0.59292090f, -1.19117081f, -0.75471073f, -0.59394884f, 
    0.81578296f, 0.90666085f, 0.24235609f, -0.52983564f, -0.17683201f, -0.59319758f, 1.32991052f, 0.14536759f, 
    1.21811581f, 0.52962148f, -0.53758329f, 0.75016832f, 0.03776845f, 0.05495292f, 0.28781486f, -0.83196706f, 
    -0.76145542f, -0.20469157f, -0.94966638f, 0.70106018f, -1.13549614f, -0.59287578f, -0.55609685f, -0.16214125f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.08481892f, 0.15186007f, 0.06228594f, -0.15747651f, 0.49387237f, 0.24105623f, 0.08769298f, 0.44818228f, 
    0.01218524f, 0.10346793f, -0.58810019f, -0.07810558f, 0.24317484f, -0.04636796f, 0.45270833f, 0.02867367f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.27171588f, -0.13325267f, 0.01717742f, 0.24425712f, 0.08149757f, -0.07117689f, 0.18747969f, -0.19487505f, 
    -0.05293798f, -0.21789020f, 0.02389394f, 0.19939351f, 0.09391639f, -0.17481115f, 0.12305898f, 0.01645997f, 
    0.19061227f, -0.13448702f, 0.32507873f, 0.39474019f, -0.40767297f, -0.11366969f, 0.00773080f, 0.17537741f, 
    0.07208593f, 0.15969284f, 0.01153668f, -0.22116719f, -0.31945074f, 0.10657991f, 0.12169109f, 0.10199637f, 
    0.17562526f, -0.00608321f, -0.01822536f, -0.12481378f, -0.06392740f, 0.12346847f, 0.16541469f, -0.03266506f, 
    -0.22076651f, 0.14159861f, 0.20071140f, 0.14053068f, -0.10509985f, 0.12097716f, -0.01261354f, 0.14537300f, 
    -0.19273321f, 0.17305514f, -0.20899016f, -0.05040824f, 0.33624649f, 0.10149645f, 0.06271187f, -0.12267346f, 
    0.04585299f, -0.02012796f, 0.01513924f, -0.05743570f, 0.13642427f, 0.08385064f, 0.07979543f, -0.08950766f, 
    -0.51034480f, -0.28515774f, 0.30955115f, 0.30342332f, 0.32885480f, 0.11824661f, -0.02643538f, -0.04756913f, 
    0.64799982f, 0.02525504f, -0.14802074f, 0.12352031f, -0.12328680f, -0.12868565f, 0.16148908f, 0.19353305f, 
    -0.17435561f, -0.11625001f, 0.12468787f, -0.47994915f, 0.14983679f, -0.02448315f, 0.15598056f, 0.19599073f, 
    0.24359255f, 0.23947892f, -0.26186201f, 0.34903258f, -0.11879237f, 0.09046481f, -0.46096224f, -0.46681488f, 
    -0.02243590f, -0.18044113f, 0.16304225f, -0.21281354f, -0.08406342f, 0.00798212f, -0.35761735f, 0.10603053f, 
    -0.27149224f, 0.06642450f, -0.13178438f, -0.05310574f, -0.32397828f, 0.04537539f, 0.03932741f, -0.09525937f, 
    0.19372578f, 0.16388598f, -0.12782067f, 0.12466300f, -0.11595356f, 0.02106597f, 0.29838458f, 0.21393356f, 
    -0.22537248f, 0.09410841f, -0.20362131f, -0.26599103f, -0.09806514f, -0.00740077f, -0.10561781f, -0.34325141f, 
    -0.09448104f, 0.32614127f, -0.04092716f, 0.15440898f, 0.31169009f, -0.14731328f, -0.15870564f, -0.12177224f, 
    -0.03746137f, 0.11859211f, 0.08337110f, 0.41645610f, 0.02149547f, -0.17905515f, 0.11482617f, 0.04662354f, 
    -0.16849937f, -0.51982355f, 0.06510048f, -0.01882162f, -0.02809377f, 0.06827948f, 0.00180947f, -0.03505021f, 
    -0.08897761f, -0.40528405f, -0.65228271f, -0.05425963f, -0.04314832f, -0.24885909f, 0.05874693f, 0.17495140f, 
    -0.16911000f, -0.01821494f, -0.20647098f, 0.01464835f, -0.28890532f, -0.09957232f, 0.01193119f, 0.04717871f, 
    -0.05254275f, 0.11299354f, 0.12193272f, 0.64345586f, -0.35040554f, -0.45942971f, 0.19782969f, 0.04947606f, 
    -0.02575967f, -0.05022182f, 0.03101241f, 0.21423988f, -0.26443946f, -0.01888704f, -0.12643948f, 0.11337457f, 
    0.10158136f, 0.15841219f, 0.00937554f, 0.11425012f, 0.10103036f, 0.41872454f, -0.11518812f, -0.05241474f, 
    -0.07404498f, 0.33639148f, 0.07289167f, 0.10955856f, -0.28602394f, -0.17593125f, -0.25019318f, -0.05890508f, 
    0.05748253f, 0.04160850f, -0.17457853f, 0.00694811f, -0.11733336f, 0.24046944f, 0.05184070f, 0.07376827f, 
    0.36822021f, -0.30347067f, 0.00156767f, -0.11807127f, -0.17326872f, 0.32966632f, 0.22429062f, 0.20052934f, 
    0.21366812f, 0.26802737f, 0.36442053f, -0.29012373f, 0.00980005f, -0.07780343f, -0.06060497f, 0.12940772f, 
    0.28979251f, -0.47354087f, 0.41224951f, 0.48902845f, -0.10163447f, 0.13483627f, -0.14841893f, -0.14638029f, 
    -0.06006162f, 0.14111543f, -0.39849490f, 0.16105638f, -0.69565934f, -0.16518362f, 0.10832542f, -0.15828903f, 
    0.27155766f, 0.09990529f, -0.18965518f, -0.38131860f, -0.44183117f, 0.06747668f, -0.07057385f, 0.17764565f, 
    0.01904858f, -0.12756757f, -0.03411159f, -0.01398942f, 0.97870803f, 0.12576212f, -0.26849693f, 0.14826001f, 
    -0.04292692f, 0.01960362f, -0.01304062f, -0.17858860f, -0.12987265f, 0.46840897f, 0.25693074f, -0.02898296f, 
    0.04978086f, 0.07587700f, -0.15727858f, 0.05321675f, -0.25230837f, -0.00826485f, 0.07338987f, 0.09317696f, 
    -0.23228352f, -0.03910155f, 0.18442045f, -0.03115985f, -0.06904706f, 0.14824910f, 0.04448355f, -0.26550362f, 
    -0.53190601f, 0.35171390f, 0.09714478f, 0.29129955f, 0.01362281f, -0.07265513f, 0.07771823f, 0.02062163f, 
    0.00705327f, 0.42449975f, -0.27961123f, 0.18705662f, 0.04783206f, -0.04785602f, 0.05648245f, 0.04699445f, 
    -0.34548759f, 0.17576571f, 0.28954360f, -0.04726518f, -0.11853473f, -0.14464958f, -0.03474112f, -0.14062640f, 
    0.12237817f, 0.20654666f, -0.28757975f, -0.10052052f, 0.28362986f, 0.00473761f, -0.06698218f, 0.10821941f, 
    0.11576565f, 0.04362218f, 0.09531549f, -0.25397924f, 0.21582307f, -0.27024755f, -0.06427766f, 0.05713569f, 
    -0.03943776f, 0.23401022f, -0.04535712f, 0.28012604f, -0.03184072f, -0.23600273f, 0.24999656f, -0.08319984f, 
    -0.01320618f, -0.22246581f, 0.16345142f, -0.16949606f, 0.11986095f, 0.07442138f, 0.08999163f, -0.18851671f, 
    0.19557196f, -0.16330002f, 0.07117572f, 0.11920189f, -0.14206475f, 0.25331193f, 0.29419443f, -0.03454318f, 
    0.12610614f, -0.07810909f, -0.09084520f, -0.18588357f, 0.11382421f, -0.18612766f, 0.19548774f, -0.38746575f, 
    0.09173926f, 0.13134894f, 0.16335888f, -0.06369162f, 0.21482392f, 0.16167560f, -0.05188836f, -0.10156214f, 
    -0.26903567f, -0.82431054f, -0.24824916f, 0.25897712f, 0.15373479f, 0.09056479f, -0.09687674f, -0.08253222f, 
    -0.13437274f, 0.38415340f, 0.16765448f, 0.11154866f, -0.11379793f, -0.10780519f, 0.23838080f, 0.04131370f, 
    0.21454614f, 0.06044975f, -0.18231662f, 0.37668413f, 0.00734761f, -0.17802043f, -0.18683958f, -0.07729533f, 
    -0.23027739f, 0.15065114f, 0.22356038f, 0.38809466f, 0.25611609f, -0.18509054f, 0.08480234f, -0.25589451f, 
    -0.00310161f, 0.01077817f, -0.11669563f, -0.24669436f, -0.04518797f, 0.06061924f, 0.25083140f, 0.02014378f, 
    -0.22332691f, -0.01669084f, 0.00409942f, 0.04575055f, -0.24342681f, -0.14951910f, 0.40413556f, 0.10006693f, 
    0.10187061f, 0.07103691f, 0.31231335f, -0.08029797f, 0.02695847f, 0.18435571f, -0.27104178f, -0.37245220f, 
    -0.04008618f, -0.08569145f, 0.32778698f, 0.09971402f, 0.09467847f, 0.28783008f, -0.46871120f, -0.23063749f, 
    0.37823692f, 0.34052294f, 0.08012881f, -0.15605494f, -0.09070953f, 0.18169694f, -0.18168727f, 0.20901777f, 
    -0.54843646f, 0.55328113f, -0.30568555f, 0.34665737f, -0.01488384f, -0.02684068f, -0.05989211f, -0.23664141f, 
    -0.14562485f, 0.05050929f, -0.32590961f, -0.37053338f, 0.28912222f, 0.18097225f, 0.06039390f, 0.15329716f, 
    0.22411492f, -0.01363991f, -0.22857095f, 0.28483158f, 0.48293433f, -0.08456478f, -0.06484145f, 0.12248130f, 
    -0.29742905f, 0.19326833f, 0.06585678f, -0.31398776f, -0.30215460f, -0.62175989f, 0.26553953f, -0.02818642f, 
    0.02721821f, 0.01269968f, -0.12378869f, -0.14050445f, 0.33108467f, -0.00247812f, 0.31221059f, 0.11633566f, 
    0.03868799f, -0.00369423f, 0.00391016f, 0.06962655f, 0.14131197f, -0.51899773f, -0.04588159f, -0.04737834f, 
    0.04666714f, -0.11375397f, 0.11010478f, 0.14210221f, -0.10270908f, 0.10743741f, 0.39502439f, -0.06110424f, 
    -0.00442795f, 0.01062595f, 0.26123661f, 0.20562987f, 0.11837281f, 0.32367736f, 0.21793811f, -0.05035806f, 
    0.47479424f, 0.27784604f, 0.26186377f, 0.19521613f, 0.10116825f, 0.20141177f, 0.14211172f, -0.17698644f, 
    -0.03970375f, 0.03324578f, 0.44125709f, -0.35356808f, -0.00018546f, 0.04382430f, 0.21303399f, -0.00939778f, 
    0.22887467f, -0.38475218f, -0.33784693f, -0.27511141f, 0.08742111f, 0.07340903f, -0.17336926f, -0.17914875f, 
    0.11333628f, -0.26618436f, -0.23303898f, 0.19511084f, -0.97561610f, 0.05909397f, 0.05672790f, -0.05585759f, 
    -0.33823913f, -0.28863752f, -0.07382154f, -0.11557779f, -0.23639512f, -0.27375165f, -0.18757476f, 0.14870469f, 
    -0.13566931f, 0.20350949f, -0.16592318f, 0.17274596f, 0.16045596f, -0.65769458f, -0.15226194f, -0.05384683f, 
    0.19483992f, 0.00162143f, 0.14717120f, -0.28422090f, 0.25375435f, 0.15053411f, -0.25367990f, -0.60361230f, 
    0.24760656f, 0.00475143f, 0.21684286f, 0.13665253f, -0.08313801f, -0.12614606f, -0.07274107f, 0.02097123f, 
    0.20818457f, 0.14513008f, 0.07422145f, 0.10932460f, 0.21927541f, -0.03926228f, -0.10286061f, -0.24795701f, 
    -0.24202791f, -0.29894596f, 0.07819971f, -0.05293623f, 0.23229668f, 0.13621183f, 0.12572624f, -0.07418374f, 
    0.37960243f, 0.46442354f, 0.19405268f, 0.00113866f, 0.00298390f, -0.01668222f, 0.13831799f, 0.08952755f, 
    0.22971509f, 0.26258302f, -0.10394654f, -0.19261101f, -0.25900495f, -0.21494111f, 0.32146132f, -0.31519157f, 
    0.10332002f, 0.00281226f, -0.02578674f, -0.23678915f, -0.22495346f, 0.49854863f, 0.08745973f, 0.01390978f, 
    -0.18266666f, -0.03290045f, 0.03776203f, 0.05129245f, 0.04880433f, 0.61605704f, -0.13958567f, 0.00951907f, 
    -0.19774412f, 0.06710874f, 0.11856573f, -0.26732698f, -0.00377463f, -0.04607660f, -0.34837735f, 0.10836057f, 
    0.07615342f, -0.21683238f, 0.14514489f, 0.01013559f, -0.12987612f, 0.22279504f, -0.11692981f, -0.31918550f, 
    0.08104274f, 0.04458231f, 0.33134684f, -0.02974557f, -0.10864320f, -0.00476384f, -0.33058444f, -0.24948110f, 
    -0.29932177f, 0.11623362f, -0.06353956f, -0.30996275f, 0.05143764f, 0.17824638f, -0.00923530f, 0.31403092f, 
    0.12212352f, 0.18043269f, -0.26522070f, -0.04703873f, 0.01844763f, 0.08020829f, 0.09426662f, 0.17197943f, 
    0.20640856f, -0.46436870f, -0.05409576f, 0.30794007f, 0.05873846f, 0.08296578f, 0.18374141f, -0.05757468f, 
    -0.01640305f, 0.13099761f, 0.17036815f, -0.10156982f, -0.05785787f, 0.22751963f, -0.00016880f, 0.04348641f, 
    -0.01187615f, -0.01901531f, 0.09414780f, 0.15424566f, 0.43396562f, -0.12072021f, -0.17391632f, -0.01214521f, 
    0.12310350f, 0.22406898f, -0.17542544f, -0.20450389f, 0.31735972f, -0.07970906f, -0.11258002f, -0.07064524f, 
    0.03923537f, 0.03695579f, 0.01775024f, -0.29220700f, 0.07594836f, 0.20591956f, 0.04631659f, -0.07473126f, 
    -0.23322751f, 0.02522011f, -0.02362072f, -0.12217571f, -0.06965970f, 0.08584532f, 0.07450736f, 0.26365966f, 
    -0.22215202f, -0.00096816f, 0.00065929f, -0.11343291f, 0.07605549f, 0.05050721f, -0.19283962f, 0.02106413f, 
    -0.10478230f, 0.26347995f, 0.00569244f, -0.05158186f, -0.02078635f, 0.11430004f, 0.05697972f, -0.50318319f, 
    -0.07028404f, -0.64641666f, 0.09085706f, 0.17712149f, -0.09192208f, -0.21448269f, -0.15643181f, 0.02094415f, 
    0.05515387f, 0.51647365f, 0.39383638f, 0.00338412f, 0.25969723f, 0.01913542f, 0.04741643f, 0.02752327f, 
    0.29922441f, -0.02775833f, -0.16540542f, 0.27459767f, -0.20513104f, -0.03866173f, 0.26109171f, 0.03619287f, 
    -0.03397055f, 0.00803075f, -0.67986631f, -0.23139271f, 0.05600647f, -0.01473384f, -0.04153379f, -0.00311188f, 
    -0.17321669f, 0.01962852f, 0.00057774f, 0.31934670f, 0.00289908f, -0.11666752f, 0.13134456f, -0.08942479f, 
    -0.27105346f, 0.20495848f, -0.02868242f, -0.00686515f, -0.48085853f, -0.27979478f, -0.29547924f, 0.06939920f, 
    -0.00420800f, 0.21699001f, -0.08513836f, 0.00825591f, -0.07247319f, -0.11606558f, 0.33833855f, 0.17520854f, 
    0.32115355f, 0.12103479f, 0.08501443f, -0.04713476f, 0.01560398f, 0.10206986f, 0.26638928f, -0.13112332f, 
    -0.38252288f, -0.21788886f, 0.12803827f, -0.14190005f, -0.18230663f, 0.05080411f, -0.03743281f, 0.44384095f, 
    0.00985527f, -0.12945402f, -0.10985653f, -0.13839960f, -0.27576077f, 0.20351885f, 0.09106371f, -0.03374757f, 
    -0.55070126f, -0.01808450f, -0.30480978f, 0.01991733f, -0.10618131f, -0.11555291f, -0.06688601f, -0.20867920f, 
    0.09292454f, -0.00450411f, -0.27807945f, 0.16582125f, 0.03254990f, -0.06985414f, -0.25131607f, 0.09089961f, 
    -0.03115131f, 0.09687743f, 0.11529902f, 0.34349483f, 0.35527748f, 0.19463849f, 0.01634330f, -0.18074368f, 
    -0.05258384f, -0.17674279f, 0.02331289f, -0.06070499f, 0.15286636f, 0.34647933f, 0.14721759f, -0.32460171f, 
    -0.14619061f, 0.30233225f, 0.08463170f, -0.06331859f, -0.21163180f, -0.12787879f, 0.18468381f, 0.16269661f, 
    0.09385883f, 0.18466166f, -0.05772819f, -0.24380548f, 0.15234983f, 0.01572285f, 0.23192732f, 0.07630757f, 
    0.22618760f, -0.15986042f, 0.06926536f, 0.30561516f, 0.25331119f, -0.20923306f, -0.39517206f, 0.24948777f, 
    0.09042130f, 0.11815370f, 0.08567051f, -0.06371485f, -0.04327828f, 0.04500670f, 0.21778128f, 0.18446946f, 
    0.17188688f, -0.16076100f, 0.24163014f, -0.10340502f, 0.08164375f, -0.01911887f, -0.08760040f, -0.19013028f, 
    -0.00452669f, 0.18810487f, -0.20620425f, -0.17695145f, -0.24420111f, -0.26228678f, 0.07460885f, -0.09056799f, 
    -0.02976057f, 0.14431676f, -0.14039357f, -0.23329476f, 0.00448908f, -0.02906113f, 0.07533220f, -0.29966182f, 
    0.28002492f, -0.17518035f, -0.01900401f, 0.61195707f, 0.00611590f, 0.04301224f, 0.05672904f, 0.30641797f, 
    -0.33066514f, -0.11589793f, -0.09270799f, 0.05722770f, 0.18976937f, 0.22332928f, 0.06654309f, -0.09068899f, 
    -0.04695737f, 0.12731072f, 0.00454534f, 0.09514806f, 0.26013201f, 0.24784784f, 0.07889340f, -0.07473777f, 
    0.04577639f, -0.06881115f, -0.02294091f, -0.08212810f, 0.12422792f, -0.43617323f, -0.12232707f, 0.30573156f, 
    -0.00595354f, 0.13669537f, -0.06201318f, 0.30147299f, 0.15817784f, -0.08896419f, 0.22899663f, 0.07649871f, 
    -0.22723047f, -0.12415235f, -0.02340907f, 0.19235949f, -0.04715139f, -0.06582937f, 0.18590720f, 0.02935070f, 
    -0.37207687f, -0.12450699f, -0.02878133f, -0.19398339f, 0.09909714f, 0.05584992f, 0.02570078f, 0.10554056f, 
    -0.32561338f, -0.03313300f, -0.05695938f, 0.04437999f, 0.25312909f, 0.12242275f, -0.02071425f, 0.16657521f, 
    0.04298946f, 0.71830899f, 0.00178114f, -0.19673251f, -0.04030219f, -0.21843293f, 0.27910689f, 0.11261474f, 
    0.03429323f, -0.02618092f, 0.55674481f, 0.18506174f, -0.48864967f, -0.18661854f, 0.09368603f, -0.00300418f, 
    -0.31808087f, -0.09963080f, 0.15803099f, 0.05480091f, -0.24062689f, 0.33804172f, 0.01738880f, -0.25746238f, 
    -0.00190789f, 0.07576794f, 0.10873421f, 0.06061190f, 0.19128992f, 0.13315448f, -0.11769468f, -0.11139190f, 
    -0.11066999f, -0.03570043f, 0.09804650f, -0.00908075f, -0.01838970f, 0.68462163f, 0.12522963f, 0.07858746f, 
    -0.01771113f, -0.34502709f, -0.18712144f, -0.01675039f, -0.15303785f, -0.06107557f, -1.09307396f, 0.12258743f, 
    -0.18324834f, -0.07760117f, 0.23662746f, 0.00728853f, -0.04952967f, 0.05695555f, -0.11371392f, -0.17755769f, 
    -0.00539827f, -0.35368344f, -0.07749242f, 0.17907482f, -0.06449881f, 0.07511414f, -0.08179825f, -0.19336165f, 
    0.60767806f, 0.15874571f, 0.18225196f, 0.03615464f, -0.07560539f, -0.01798394f, 0.13930158f, -0.40627933f, 
    0.08223300f, 0.06197356f, 0.43011385f, -0.05732114f, 0.06192029f, -0.11147888f, 0.09734229f, -0.20668511f, 
    -0.07937187f, 0.17615899f, 0.23116201f, 0.27018237f, 0.25449297f, 0.11362977f, -0.23958446f, -0.09991385f, 
    -0.08061330f, 0.20701194f, -0.05026093f, 0.61273813f, 0.12088312f, 0.12255771f, 0.12022594f, -0.36895242f, 
    -0.02350772f, -0.05968636f, -0.03773248f, 0.02640520f, -0.08560525f, 0.15533286f, 0.29180920f, 0.20902181f, 
    0.00478492f, 0.01950924f, -0.22614619f, -0.22567435f, -0.02475477f, 0.41246274f, -0.05312689f, 0.10121205f, 
    -0.01993155f, 0.04967310f, -0.12337100f, -0.24451514f, -0.17831832f, 0.07315572f, -0.14129129f, 0.26769134f, 
    -0.01730077f, -0.01103943f, 0.04841838f, -0.02804895f, 0.04995427f, 0.10107705f, 0.21983320f, -0.08680258f, 
    0.06458567f, 0.15700619f, -0.08443164f, 0.15376373f, 0.02912775f, 0.12598649f, -0.12355365f, -0.19065315f, 
    0.02703564f, 0.26331037f, 0.16476463f, -0.07548710f, 0.12143396f, -0.11224399f, -0.09241001f, 0.12065134f, 
    -0.29463008f, 0.26523203f, -0.31348538f, -0.55872667f, -0.16714996f, -0.00993614f, -0.16309254f, -0.20817494f, 
    0.26924163f, -0.24704476f, -0.18519656f, -0.45604387f, 0.26175952f, -0.26475886f, 0.01308960f, -0.01492579f, 
    0.07204165f, -0.04053530f, 0.27879572f, 0.40429327f, -0.05397289f, -0.36765191f, 0.00851880f, 0.14769846f, 
    -0.18535763f, -0.25712052f, 0.10274015f, -0.31992188f, 0.45020044f, -0.33447599f, -0.04575020f, -0.21777897f, 
    -0.03616195f, 0.22757111f, 0.10572867f, -0.01480688f, -0.03319447f, -0.28848282f, -0.37493986f, 0.00855776f, 
    -0.01020755f, 0.03930677f, 0.10099439f, -0.25596595f, 0.40175554f, 0.07258639f, 0.41131508f, 0.31839624f, 
    -0.01511885f, -0.19556049f, 0.10148627f, 0.15952821f, -0.07770700f, 0.03875904f, -0.23588824f, 0.01945880f, 
    -0.08547344f, -0.34898776f, -0.00708967f, -0.13099092f, 0.13588402f, 0.06693982f, 0.00877949f, 0.14363758f, 
    0.15607880f, 0.39710045f, 0.40310216f, -0.01379360f, -0.12569249f, 0.19741578f, 0.04378885f, 0.23670480f, 
    0.10153412f, -0.19191080f, -0.19668905f, 0.19747131f, 0.01076381f, -0.10045277f, -0.02420665f, -0.08029144f, 
    -0.09876958f, -0.25997692f, -0.03930837f, -0.14144507f, 0.37053350f, -0.43732440f, -0.02721201f, 0.26638821f, 
    -0.30990914f, 0.19075683f, -0.13877353f, -0.38173884f, -0.19649740f, 0.08768197f, -0.16283286f, -0.00656505f, 
    -0.14377809f, 0.21029142f, 0.10547291f, 0.10195069f, -0.01879998f, -0.27300063f, 0.04525666f, -0.10429925f, 
    -0.24807361f, 0.02446619f, 0.06585704f, -0.05570829f, -0.11046878f, 0.41120580f, -0.00622672f, 0.04146213f, 
    -0.09091712f, 0.13673009f, 0.15565327f, -0.08050127f, -0.06455124f, -0.42576456f, 0.03027261f, -0.53252792f, 
    -0.15924805f, -0.07977096f, -0.08750017f, -0.01368029f, -0.32723635f, -0.01205677f, -0.07092025f, 0.13719450f, 
    0.19437803f, -0.13647158f, -0.03305810f, 0.09987321f, -0.15603846f, -0.02818710f, 0.00697415f, 0.15225734f, 
    -0.20548710f, -0.46888980f, 0.13968244f, -0.26513016f, -0.10484058f, -0.00377277f, -0.39674821f, 0.01770280f, 
    0.03920883f, 0.15889010f, 0.36372507f, 0.01484793f, -0.12221484f, 0.09176759f, -0.09506861f, -0.09236506f, 
    0.09063536f, 0.05503168f, 0.11456573f, 0.55651152f, 0.39490351f, 0.32844248f, 0.00525845f, 0.13346437f, 
    0.30725494f, -0.09133510f, 0.30504888f, 0.29591098f, 0.46651959f, -0.12814820f, 0.20451894f, -0.04109996f, 
    0.12774625f, -0.16822276f, 0.27835286f, -0.09674348f, 0.11327828f, -0.17260674f, -0.16147354f, 0.17466144f, 
    -0.16622429f, 0.02701138f, -0.29087231f, -0.18153030f, 0.16445209f, 0.32637614f, 0.44068193f, 0.37411588f, 
    0.40571716f, -0.01362986f, 0.27889684f, 0.15230504f, -0.05888188f, -0.06246672f, 0.25300828f, 0.14716572f, 
    -0.04636735f, -0.26293996f, -0.13246222f, -0.03146808f, 0.14865489f, -0.11343051f, 0.04976711f, 0.09216216f, 
    0.33328813f, -0.12328281f, 0.31233913f, -0.39574239f, 0.23463073f, -0.33560815f, -0.20847626f, -0.21700051f, 
    0.01154821f, 0.21051745f, 0.15159565f, -0.00525764f, -0.15076561f, 0.04925490f, 0.01765556f, 0.17586857f, 
    0.12857847f, 0.06279005f, 0.10331579f, 0.20514975f, -0.07644624f, -0.01565347f, 0.12729083f, -0.07688367f, 
    0.07672097f, -0.05139464f, -0.56691957f, -0.35980439f, 0.01101085f, 0.15393394f, -0.05877931f, -0.22303505f, 
    -0.25572520f, -0.33785838f, -0.05524247f, 0.45841274f, 0.22785102f, -0.40273413f, 0.24544035f, 0.05829718f, 
    -0.12690148f, 0.28680077f, 0.13427582f, 0.13997208f, 0.48717386f, 0.31446144f, -0.05929134f, -0.12707977f, 
    0.01471526f, 0.13969256f, 0.02627390f, -0.18404979f, 0.05036066f, 0.25227952f, 0.09746249f, 0.25989288f, 
    -0.19341640f, -0.01461831f, 0.13059297f, -0.05411410f, -0.06106868f, -0.01869094f, 0.36385873f, 0.00863442f, 
    0.23164164f, -0.03519506f, -0.05564889f, 0.21378814f, -0.33796611f, 0.19221166f, -0.39214683f, -0.78798997f, 
    -0.27324575f, -0.21900216f, 0.02548808f, 0.28560176f, -0.18039483f, 0.11173135f, -0.15250480f, 0.03573674f, 
    -0.44544664f, -0.73122221f, -0.24145308f, 0.11606476f, -0.20079887f, 0.07078074f, -0.04918828f, -0.17901732f, 
    -0.04816341f, 0.04034621f, 0.13588910f, 0.04558324f, -0.14518432f, 0.11152481f, -0.32751825f, 0.34257177f, 
    -0.03680155f, 0.20588203f, 0.15732028f, 0.21641444f, 0.16029391f, 0.14907151f, -0.06783117f, -0.33993030f, 
    0.24761871f, -0.01154393f, -0.25354686f, 0.00640957f, -0.04713253f, -0.04358946f, -0.06656115f, -0.08710729f, 
    0.14427748f, -0.38627106f, 0.05809755f, 0.05940821f, 0.37792471f, -0.01065793f, -0.12001996f, 0.21536800f, 
    0.19861940f, -0.12066214f, 0.24131376f, 0.14051099f, 0.18667112f, 0.41221172f, 0.23448452f, 0.10698075f, 
    0.09312521f, 0.10375313f, 0.08477853f, -0.11458792f, 0.24216507f, -0.20454490f, -0.92614102f, -0.77656686f, 
    0.30919951f, 0.05126049f, -0.08215647f, 0.03763487f, -0.14125411f, 0.00010009f, 0.16237183f, -0.28982782f, 
    -0.12270474f, -0.06544074f, -0.13393359f, -0.05436424f, 0.31916881f, -0.11002091f, 0.07556799f, -0.51192486f, 
    0.02840251f, -0.68340176f, 0.30056205f, -0.24180003f, -0.07120603f, 0.03257912f, 0.05750991f, 0.15839255f, 
    0.13596939f, 0.52116930f, -0.22515947f, 0.14851905f, -0.08043075f, 0.23851089f, -0.08454853f, 0.09335925f, 
    0.08657365f, 0.07663581f, 0.34851643f, 0.24187486f, -0.19091684f, 0.09768774f, 0.08017473f, 0.24944191f, 
    0.37344262f, -0.14168125f, 0.01796148f, -0.19415057f, -0.23328917f, 0.15666388f, -0.00588323f, 0.05032287f, 
    -0.24078615f, 0.12045992f, 0.08245989f, -0.19682550f, 0.24069421f, 0.24324921f, 0.34669331f, 0.09957507f, 
    0.10612318f, 0.00824765f, -0.01970110f, 0.17896603f, -0.10980938f, 0.43746251f, -0.19426505f, -0.10445087f, 
    -0.01744539f, 0.08749051f, 0.18512765f, 0.05035988f, -0.00443018f, -0.20535605f, 0.13538015f, 0.04284095f, 
    0.26741922f, 0.40277860f, -0.04640888f, -0.11546391f, -0.12579085f, -0.03835960f, 0.02191799f, -0.61665690f, 
    0.27829087f, 0.22044179f, 0.00532540f, 0.14140902f, 0.20699909f, -0.08085254f, -0.17531465f, 0.14836903f, 
    -0.50718850f, -0.41427100f, 0.60556346f, -0.04849650f, 0.02648552f, 0.20778063f, 0.02576355f, 0.00387869f, 
    -0.09816708f, 0.19633265f, 0.05348073f, -0.00664705f, -0.21310921f, 0.16130529f, -0.18541037f, 0.30420235f, 
    -0.08920425f, -0.14605044f, 0.28841960f, -0.58676577f, 0.26788720f, -0.59543175f, 0.08650114f, 0.38394174f, 
    0.03768331f, -0.10226496f, 0.09716727f, 0.08065873f, -0.03596022f, 0.06443880f, -0.37223971f, 0.06360891f, 
    -0.09591365f, -0.06399047f, 0.01866103f, -0.13795730f, 0.44509256f, 0.31361929f, -0.49091148f, -0.18476586f, 
    -0.07120230f, 0.06590993f, -0.01804573f, 0.07653192f, 0.24226017f, 0.43616322f, -0.17603023f, -0.10217238f, 
    -0.12560551f, 0.02486283f, 0.16186692f, -0.03688255f, 0.35412797f, 0.07759504f, -0.96904576f, -0.08127221f, 
    -0.12687398f, -0.01533636f, 0.38500983f, 0.05181967f, -0.06478858f, -0.03326144f, -0.03490972f, -0.27357432f, 
    0.10594880f, -0.02716608f, 0.11657231f, -0.05553935f, 0.35607806f, -0.07281245f, -0.04319751f, -0.05740812f, 
    0.08263079f, 0.09488605f, 0.42791730f, 0.17748471f, -0.11790332f, -0.28937945f, -0.21983629f, 0.12352802f, 
    0.03055272f, -0.13130377f, 0.06261994f, -0.18681780f, -0.12125484f, -0.02396108f, -0.08898485f, 0.17159392f, 
    0.03001768f, -0.13049187f, -0.16489424f, -0.27019519f, -0.50431854f, 0.06780877f, -0.04132255f, 0.12174587f, 
    -0.00563928f, -0.01859877f, 0.32556641f, 0.37208754f, -0.03708867f, -0.13340189f, -0.10001471f, 0.19363296f, 
    -0.05386991f, 0.12911673f, -0.09629321f, 0.22809526f, -0.09255975f, 0.35121149f, -0.37092820f, 0.15479369f, 
    -0.00979592f, -0.20058973f, -0.13193329f, 0.07291061f, -0.04484880f, -0.40026823f, 0.00433484f, 0.05954268f, 
    0.02175644f, 0.03577909f, 0.10730884f, -0.00780565f, 0.28215197f, -0.00172677f, -0.25940874f, 0.01458301f, 
    -0.31857783f, 0.04217840f, 0.07528169f, -0.22089615f, 0.24394295f, 0.08531334f, -0.00768527f, -0.32500282f, 
    -0.10318738f, -0.17099985f, -0.00093178f, -0.18752879f, -0.02097455f, 0.10539149f, 0.20166303f, 0.18711458f, 
    0.29256701f, -0.43304390f, -0.16728574f, 0.18717167f, 0.02939312f, -0.04566316f, -0.07971074f, 0.01334379f, 
    -0.30278915f, 0.05434135f, -0.14304270f, 0.14831477f, 0.16829281f, -0.08633956f, 0.07553347f, -0.07700581f, 
    -0.08472572f, 0.22481820f, 0.27013642f, 0.27481660f, 0.30563429f, -0.30680481f, -0.18143310f, 0.05232571f, 
    0.09442186f, 0.00952939f, 0.03654619f, -0.02777572f, -0.24084485f, 0.38685057f, 0.23779871f, -0.02019701f, 
    0.09893114f, 0.15228201f, -0.09608905f, 0.15028486f, -0.32591492f, 0.63256329f, 0.19231957f, -0.27772042f, 
    -0.18285471f, -0.00666383f, -0.07208467f, -0.01666086f, 0.11359312f, -0.02309978f, -0.34010610f, 0.27320719f, 
    -0.02595918f, -0.20325370f, -0.20062183f, -0.15193956f, -0.21851842f, 0.02471776f, 0.35771820f, -0.44466400f, 
    -0.06244698f, 0.24990118f, 0.33754015f, 0.03629972f, 0.03339713f, 0.16640787f, -0.07939354f, -0.38529211f, 
    0.27900955f, 0.25872886f, 0.06389532f, 0.05466136f, 0.24512519f, -0.26880786f, -0.08431179f, -0.32528090f, 
    -0.87629640f, -0.00673351f, 0.49213180f, 0.33240709f, 0.23609662f, -0.10440782f, -0.05639257f, 0.00300205f, 
    0.12639318f, -0.37229151f, 0.25908041f, 0.24666011f, 0.20780848f, 0.05231373f, -0.00291353f, -0.09904502f, 
    -0.24153727f, -0.08324170f, -0.35553920f, 0.12559201f, -0.37825114f, 0.00028694f, -0.04582997f, -0.46638012f, 
    -0.02637959f, 0.21601915f, 0.08529510f, 0.89073968f, -0.12523067f, 0.21453564f, -0.06269569f, -0.03879674f, 
    0.07972092f, -0.07032557f, 0.06267928f, -0.01783994f, -0.01222632f, 0.25104952f, -0.30154958f, 0.21796715f, 
    0.11018041f, 0.09443637f, 0.12696689f, -0.08271009f, 0.03619343f, -0.79709852f, 0.13965452f, -0.04612644f, 
    0.28326964f, -0.14754266f, 0.35610887f, 0.00597401f, 0.17012775f, -0.05936898f, 0.31080762f, -0.14863345f, 
    -0.40410125f, 0.25675833f, -0.17846648f, -0.06445757f, 0.39636633f, -0.01664789f, 0.20755903f, -0.20384707f, 
    0.04966333f, -0.15037639f, 0.25560284f, -0.05845043f, 0.28154728f, -0.13305572f, -0.15297988f, 0.15577155f, 
    0.19116002f, 0.52291095f, 0.08090446f, -0.03352163f, -0.09454858f, -0.04017106f, 0.13611087f, 0.01372790f, 
    -0.16457780f, -0.50253850f, -0.03745606f, 0.23774892f, 0.10599255f, -0.16220306f, -0.04325112f, -0.07629869f, 
    -0.04995370f, -0.06347814f, -0.64309263f, -0.25435200f, -0.09600303f, -0.11867518f, 0.20617543f, -0.00838589f, 
    -0.22234067f, 0.08973544f, 0.13637714f, -0.24054267f, -0.51509362f, -0.03481387f, 0.07990006f, 0.07606755f, 
    -0.01907421f, 0.14563629f, 0.25705433f, -0.05010849f, -0.26666808f, -0.17363474f, 0.64320189f, 0.01947097f, 
    -0.08191457f, 0.08110867f, -0.04216963f, -0.15817600f, -0.13162975f, -0.32919082f, -0.03563851f, 0.34886223f, 
    0.32749090f, 0.00562929f, 0.33919373f, -0.05533106f, 0.02880773f, 0.05825597f, 0.06370551f, 0.06210753f, 
    -0.00348982f, 0.04024009f, 0.01746072f, -0.38509557f, -0.03258760f, -0.12111494f, 0.05529582f, -0.21227209f, 
    0.00607011f, -0.21710347f, 0.09817132f, -0.01054150f, 0.27133572f, -0.11698385f, -0.03233473f, 0.21484931f, 
    -0.33896199f, -0.07859617f, 0.25397468f, 0.21721768f, -0.14945289f, 0.13232905f, 0.02691081f, -0.06030795f, 
    0.34851572f, 0.20431957f, 0.02240252f, 0.02367684f, 0.02157317f, 0.05055228f, -0.05579902f, -0.06210042f, 
    0.07820917f, -0.18687083f, 0.06439940f, -0.10701913f, 0.10055402f, 0.09225834f, 0.27452317f, 0.12322458f, 
    -0.05804575f, 0.08905243f, 0.18875870f, 0.00143933f, 0.24714831f, 0.46777028f, -0.03169873f, -0.26729351f, 
    -0.37371629f, 0.08573715f, 0.04943175f, 0.20481539f, 0.00905397f, 0.05833294f, 0.21651003f, 0.08597315f, 
    -0.13970332f, 0.05463967f, 0.06992321f, -0.06734201f, 0.03504160f, -0.68682289f, -0.10087410f, 0.07545255f, 
    0.06274776f, -0.01834533f, 0.11608777f, 0.06903864f, -0.06629295f, -0.20609233f, -0.08328052f, 0.17498802f, 
    -0.15978386f, -0.02498722f, -0.23213971f, 0.26991859f, 0.37137797f, 0.07152794f, 0.08199915f, 0.45639050f, 
    -0.06809787f, -0.00236268f, -0.21233338f, 0.06667893f, 0.02646299f, 0.39320180f, 0.06958389f, 0.18987586f, 
    -0.10114424f, -0.14168191f, 0.42363265f, 0.01526293f, 0.25621504f, 0.07798035f, 0.01621074f, 0.21752344f, 
    0.11334043f, 0.19386218f, -0.74640960f, 0.03559272f, -0.19678396f, -0.04730099f, -0.01307608f, 0.03679435f, 
    -0.10027552f, 0.33250681f, -0.24979153f, -0.02492729f, 0.22310951f, 0.07894813f, 0.09444281f, -0.00647326f, 
    -0.29841512f, -0.34601951f, -0.25715083f, -0.26233062f, -0.35838178f, -0.06044164f, -0.02234455f, -0.01233398f, 
    0.28364486f, -0.02376739f, 0.22741471f, -0.28955176f, -0.63731986f, -0.07822312f, 0.29167816f, 0.18567196f, 
    0.10657030f, 0.05126445f, -0.14753368f, 0.21625654f, 0.11384236f, -0.31697038f, -0.18841974f, -0.05543399f, 
    0.06738558f, -0.41549116f, 0.12096172f, -0.06417596f, -0.01056471f, -0.19588144f, 0.08991985f, 0.51861858f, 
    0.17925330f, 0.28861970f, 0.00498471f, 0.01535135f, -0.03000253f, -0.10628826f, 0.36871982f, -0.25576261f, 
    0.07070804f, -0.07154502f, -0.01098565f, 0.25328764f, 0.25321585f, -0.14640377f, 0.15260909f, -0.19680768f, 
    0.15224916f, -0.22231218f, 0.46570778f, 0.11041202f, -0.01929212f, 0.04838669f, -0.02436675f, -0.14600608f, 
    -0.22547588f, 0.28919917f, -0.25330725f, 0.13175742f, 0.02971675f, 0.02510055f, 0.10041821f, -0.14941241f, 
    0.00002154f, 0.02281985f, -0.08551560f, 0.15572305f, -0.33194214f, -0.03213179f, -0.26927537f, -0.17082059f, 
    -0.01321943f, -0.16073810f, -0.18759072f, 0.08852217f, 0.22601305f, 0.34726721f, -0.40487644f, 0.06302084f, 
    0.04698902f, 0.08723015f, 0.10280719f, 0.01862037f, -0.31233218f, -0.02031330f, -0.07706251f, 0.09251212f, 
    -0.11021676f, -0.28239739f, -0.12180042f, -0.06117324f, 0.03420752f, -0.36509717f, -0.27644354f, 0.19711578f, 
    0.22728787f, 0.24195445f, 0.04614820f, 0.05340906f, 0.15379407f, 0.28246975f, 0.12205972f, -0.16315220f, 
    -0.19094205f, 0.16502221f, 0.00349306f, -0.14822689f, -0.10832958f, 0.05446231f, -0.12524836f, -0.32212251f, 
    -0.06789871f, 0.29569957f, 0.01495190f, -0.04725003f, 0.23382173f, -0.08225014f, -0.15003085f, 0.07340141f, 
    -0.27894852f, 0.16770297f, -0.12768880f, 0.09546682f, 0.10359494f, -0.18201534f, 0.04004797f, 0.21601148f, 
    -0.13013443f, 0.17730489f, 0.20701040f, -0.18125615f, 0.04038155f, -0.07898505f, 0.13315780f, 0.09674916f, 
    -0.08158639f, -0.31307480f, 0.17683406f, -0.06605298f, 0.57047033f, 0.20205277f, 0.15357210f, 0.10635300f, 
    -0.03662473f, -0.00036720f, 0.04154961f, -0.23130916f, 0.27853906f, -0.22049072f, 0.02673524f, 0.02492180f, 
    -0.09861097f, 0.05372700f, -0.01876374f, 0.16314946f, 0.10196980f, -0.59627140f, 0.21175833f, 0.06365457f, 
    -0.00387869f, -0.13285705f, 0.05506278f, 0.00996625f, 0.03504981f, -0.70475268f, -0.05705892f, 0.26988190f, 
    0.39699796f, 0.10869853f, 0.15318926f, -0.05966512f, -0.12486727f, 0.33254579f, 0.37577447f, 0.19082288f, 
    -0.23450008f, 0.03027884f, 0.21096800f, -0.01715116f, -0.23761505f, -0.25483006f, 0.00335801f, 0.01452515f, 
    0.04861170f, 0.27903160f, 0.11127448f, -0.02488408f, 0.21242128f, -0.09521003f, 0.05301421f, 0.01330722f, 
    0.15078054f, 0.27964121f, -0.57589579f, -0.03616953f, 0.26322398f, -0.11355456f, 0.13305606f, -0.11437672f, 
    0.02577933f, -0.10590127f, -0.07589853f, -0.04533873f, -0.20784800f, 0.07447691f, 0.07370573f, 0.12762173f, 
    -0.05136084f, -0.05037707f, 1.07589543f, 0.14144796f, 0.16405332f, 0.09882594f, 0.17412709f, -0.04253458f, 
    0.06008825f, 0.05438359f, -0.05994689f, -0.20862618f, -0.16952732f, -0.20219718f, -0.21808733f, -0.02215220f, 
    0.21500838f, -0.24160478f, -0.03980140f, 0.05680806f, -0.00959041f, -0.05604063f, -0.21112867f, -0.10148764f, 
    0.03964139f, 0.00759813f, 0.03123017f, 0.22414851f, 0.05160259f, 0.14359328f, 0.14281522f, 0.33078334f, 
    -0.12316167f, -0.02273740f, -0.06765483f, -0.21143399f, -0.05217957f, -0.13953432f, 0.10896993f, -0.44483200f, 
    -0.22315647f, -0.09098922f, 0.04958068f, 0.08092389f, -0.17273290f, 0.22787632f, -0.08305044f, 0.24666665f, 
    -0.05136159f, 0.14215805f, 0.07100710f, 0.05223295f, -0.29893410f, -0.01160803f, -0.02730544f, -0.01248679f, 
    1.01146662f, 0.17986272f, 0.11016234f, 0.13526805f, -0.14500320f, 0.39924923f, 0.28199154f, 0.01239011f, 
    0.05823667f, -0.80069125f, -0.37657079f, 0.05669786f, -0.10415110f, 0.24178141f, -0.04459491f, 0.08551926f, 
    0.09390111f, -0.08056694f, 0.31076723f, -0.08527364f, -1.00731492f, -0.08442127f, 0.31914288f, 0.02793640f, 
    -0.21810111f, 0.19460955f, 0.03681664f, -0.40760252f, -0.13617685f, 0.12502043f, -0.17138298f, 0.07130510f, 
    -0.28849766f, 0.19662802f, 0.14313848f, -0.00843937f, -0.71510667f, -0.06523293f, 0.12884824f, -0.05069652f, 
    0.17423278f, -0.25516286f, 0.13172339f, 0.01238245f, 0.05763773f, -0.24376364f, -0.08548278f, -0.22724533f, 
    -0.05133591f, 0.03063921f, -0.12885198f, 0.08153562f, 0.06125130f, -0.34279507f, 0.67844731f, 0.23247643f, 
    0.52409184f, 0.06384863f, -0.06914894f, 0.32543012f, 0.32074615f, -0.15577644f, 0.10967693f, 0.00357959f, 
    -0.45658335f, 0.00300742f, -0.27702707f, -0.05636457f, 0.10802218f, -0.16605651f, -0.08734294f, -0.10999519f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.38669404f, 0.14734797f, -0.09674227f, 0.53268325f, -0.06069219f, -0.18557115f, 0.03926873f, 0.08699700f, 
    -0.32471430f, 0.17532861f, -0.01728810f, 0.07536453f, 0.13059288f, 0.24993938f, -0.04764342f, 0.00739710f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.24728596f, 0.84909993f, 0.09487491f, -0.06624864f, -0.00997468f, 0.12077326f, -0.39525858f, -0.28114778f, 
    0.27922630f, -0.33485660f, 0.23754972f, -0.30711439f, 0.17834590f, -0.47172016f, 0.05331250f, -0.43705350f, 
    -0.49176070f, 0.34763771f, -0.55593145f, 0.27331230f, -0.01520444f, 0.42621076f, -0.68114072f, 0.10678655f, 
    0.18447331f, 0.20973541f, 0.27899894f, -0.28214031f, -0.31275874f, 0.17811875f, -0.54842830f, 0.06432334f, 
    -0.28403082f, -0.27127352f, -0.58453399f, -0.47164547f, 0.34423056f, -0.54966462f, 1.33716917f, 0.00293955f, 
    -0.51146930f, -1.15902638f, 0.09650473f, -0.11751862f, 0.38596228f, 0.12868395f, 0.38170573f, 0.01524447f, 
    -0.27159670f, -0.41951719f, 0.36861470f, -0.61820209f, -0.39709684f, -0.67878437f, -0.01903227f, -0.14096679f, 
    -0.54966325f, 0.56433016f, 0.80678040f, 0.90594560f, -0.40612519f, -0.15159911f, -0.02999525f, -0.25377446f, 
    0.08592508f, -0.51130563f, 0.25717357f, 0.24645376f, 0.19163321f, -0.30877540f, -0.34285903f, 0.41419011f, 
    -0.15336227f, -0.20019506f, -0.07144833f, -0.31344736f, -0.19898376f, 0.46654984f, 0.35774380f, -0.84529960f, 
    0.03955933f, -0.04933526f, -0.33085448f, 0.55202031f, -0.20945640f, 0.19398236f, -0.18852055f, -0.54721391f, 
    0.48180655f, 0.15252133f, -0.34168386f, -0.60176909f, 0.14091341f, 0.40829414f, -0.72360212f, 0.07218828f, 
    -0.18630004f, -0.79536384f, 0.53493345f, 0.43372092f, -0.74254251f, 0.03206241f, 0.00396128f, 0.28011203f, 
    -0.29618230f, -0.72270542f, -0.25687200f, -0.39181820f, 0.27122122f, -0.11152638f, -0.00446574f, 0.77332717f, 
    -0.47197226f, -0.07950665f, 0.43189368f, -0.21597791f, 0.30017793f, 0.30923191f, -0.05915080f, -0.59075916f, 
    0.60316873f, -0.07003140f, -0.26728728f, -0.09935185f, -0.73287165f, -0.55592233f, 1.09016371f, -0.09028322f, 
    -0.69608092f, -0.17149262f, -0.23504192f, -0.14726965f, 0.72766531f, 0.73064208f, 0.01915171f, -0.48303810f, 
    -0.40829024f, -0.34149709f, -0.82989806f, 0.66729498f, 0.32632834f, 0.73928577f, -0.44692993f, -0.05250959f, 
    0.10949063f, 0.06368240f, -0.24822456f, 0.37696865f, -0.58642322f, -0.37449405f, -0.01096830f, 0.40480006f, 
    -0.34878799f, -0.10754168f, -0.55739546f, 0.47428650f, 0.62311900f, 0.20054573f, 0.42171246f, -0.36905318f, 
    0.09586558f, -0.43541723f, -0.15228561f, -0.52787846f, 0.13991708f, -0.00145437f, 0.83158439f, -0.61807406f, 
    -0.80504274f, 0.96574169f, 0.00969584f, -0.44983369f, -0.64964426f, 0.53617513f, -0.13091756f, -0.00467558f, 
    0.86615884f, -0.68010139f, 0.26275033f, -0.32742205f, 0.29913262f, -0.77078468f, -0.02228056f, 0.09125253f, 
    -0.31348917f, -0.44239259f, 0.25127631f, 0.24753539f, -0.18601349f, -0.49576905f, -0.10679299f, 0.10675401f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.13670072f, 0.00322064f, -0.01896973f, -0.13842617f, 0.12180199f, 0.00128013f, -0.14186516f, -0.65485281f, 
    -0.39250559f, 0.16354746f, 0.22841769f, -0.05760128f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
