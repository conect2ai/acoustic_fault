#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.01953816f, 0.56277823f, -0.57256502f, 0.01811805f, -0.28860077f, -0.42969131f, 0.24494410f, 0.11064042f, 
    0.86546206f, 1.41046393f, 0.90953523f, 1.25353193f, 0.28788331f, -0.62965947f, 0.38463053f, 0.19598807f, 
    0.38367632f, -0.12689887f, 0.97146624f, 0.94606686f, 0.99723113f, -1.19017303f, 0.19981176f, -1.13457537f, 
    0.25512308f, -0.16779347f, -0.09575150f, -0.33994839f, 0.61536413f, 0.92313457f, 1.20134866f, 0.59426737f, 
    0.07379764f, 0.74809736f, 0.59946072f, 0.12606086f, 1.54960752f, -0.57792544f, -0.53997231f, 1.09745204f, 
    -0.01802365f, -0.37310421f, -0.10946944f, 0.04499901f, -0.06311009f, 1.06056905f, 0.92375541f, -0.80891752f, 
    -0.85063624f, 0.50290775f, 0.57274210f, 0.15449551f, 0.23878945f, 0.08575131f, -0.86217886f, 0.89472896f, 
    0.91215581f, -0.74881268f, 0.37376821f, -0.19528511f, -0.84542018f, 0.32461491f, 0.36336941f, -0.21071783f, 
    -1.75243688f, -0.58081341f, -0.98943150f, -0.02280605f, -0.29942033f, 0.17860436f, 0.66582114f, 0.70299739f, 
    0.37392944f, -1.39506686f, 0.20606984f, 0.88125986f, -1.15351057f, 0.30419537f, 0.52050948f, 0.22273602f, 
    -0.05390762f, 1.12593925f, -0.72347432f, -1.12920213f, -0.51779383f, -0.55098337f, -0.91405070f, -0.62922359f, 
    -0.25590122f, -0.17565310f, 0.86184007f, 0.71186393f, 0.89445049f, 0.59278804f, 0.88356698f, 1.16387153f, 
    -0.51160508f, -0.22450851f, -0.18638112f, -0.75803912f, -0.32351181f, -0.41496214f, 0.30898014f, 1.39029086f, 
    -0.57341063f, 0.01297605f, -0.23923697f, -0.31078899f, -1.16718340f, 0.38709834f, 0.30603850f, 0.47867674f, 
    -0.12654297f, -0.89803427f, 0.37287307f, -0.05861294f, -0.77010214f, -1.39959967f, -0.20033778f, 0.72252250f, 
    0.65034777f, 0.93095171f, 1.19479191f, 0.41306862f, -0.45028430f, 0.07224915f, -1.15942049f, -1.05410838f, 
    -1.05632496f, 0.48961639f, 0.90996766f, 0.84662771f, -0.41799176f, 0.01273204f, -0.57102078f, 0.38541996f, 
    0.78418010f, -0.00832873f, 0.31761760f, -0.74243480f, -1.43127871f, 0.43205413f, 0.61917311f, -0.40890011f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03200634f, 0.37019253f, 0.43898416f, -0.08059187f, -0.57354218f, 0.09989733f, 0.08465034f, 0.41175282f, 
    0.27004007f, -0.01634218f, 0.64616692f, -0.01867252f, 0.13067099f, 0.14106750f, 0.40282586f, 0.07817210f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.07552375f, -0.06438270f, -0.04563846f, -0.13322668f, -0.12786166f, 0.06207289f, 0.04776376f, -0.16635007f, 
    -0.21740243f, 0.77420217f, -0.16117422f, -0.07779369f, 0.13643186f, 0.01719814f, 0.13965300f, 0.06558855f, 
    0.16756265f, -0.03801524f, 1.06021035f, 0.28677267f, -0.37866729f, 0.11575095f, 0.26734412f, 0.05544619f, 
    0.18631406f, -0.01130301f, 0.07710097f, 0.66984916f, -0.26651186f, -0.10890900f, 0.01267563f, 0.34907377f, 
    0.24467407f, 0.05221969f, -0.02496468f, 0.01566343f, -0.27391583f, -0.34481019f, 0.10944303f, 0.14933364f, 
    0.09649042f, -0.13860402f, 0.01207732f, 0.07342769f, -0.11186957f, 0.05703855f, 0.20366134f, 0.06794409f, 
    -0.09415395f, 0.30516836f, 0.05330528f, -0.01480571f, -0.00377147f, -0.05908209f, -0.17437284f, -0.00092312f, 
    0.01799970f, -0.42274827f, -0.20287785f, -0.26584527f, -0.03057690f, -0.41104433f, 0.04012018f, -0.16059072f, 
    0.13387293f, -0.45755732f, -0.03652006f, -0.17591552f, -0.19582348f, 0.14853117f, 0.07129345f, -0.06075498f, 
    -0.20279945f, -0.39372003f, -0.18506756f, 0.20102887f, 0.06047711f, 0.00798391f, -0.12989739f, 0.04797265f, 
    -0.02549538f, 0.10279484f, 0.36207196f, -0.19765118f, 0.04011486f, -0.00960270f, 0.00762861f, 0.16157185f, 
    0.23051572f, 0.12633739f, -0.55874997f, -0.21442373f, 0.01016183f, 0.16782466f, 0.22167712f, 0.09450463f, 
    0.01565555f, 0.08784370f, -0.03067110f, -0.17533886f, -0.07983887f, 0.08085439f, 0.06982832f, 0.01394040f, 
    0.04805804f, -0.31242019f, 0.19584204f, -0.07350016f, -0.26232788f, -0.13167869f, -0.18856689f, -0.01599516f, 
    -0.08730391f, 0.00525422f, -0.12353462f, 0.00903303f, -0.09533519f, -1.03780854f, -0.03992515f, 0.01004895f, 
    0.29579943f, 0.09514349f, 0.09085992f, -0.22846334f, 0.37441748f, 0.27726698f, -0.38649565f, 0.18535221f, 
    0.13033858f, -0.16456354f, -0.11009359f, 0.10799450f, -0.08882337f, -0.18277323f, -0.07485893f, 0.58284533f, 
    -0.20761368f, -0.06979457f, 0.22852819f, 0.12022007f, -0.02795751f, 0.19508894f, 0.14385530f, 0.09104109f, 
    -0.02028222f, 0.03419463f, -0.03651936f, 0.01457096f, -0.06588434f, -0.02622063f, 0.05662087f, -0.05335930f, 
    -0.07516236f, -0.08351966f, -0.06866737f, -0.02646559f, -0.00378140f, -0.04573554f, -0.01553775f, 0.07260539f, 
    -0.06121559f, 0.04070452f, -0.05179532f, -0.00448865f, 0.05701530f, -0.07933221f, -0.02435201f, 0.04225188f, 
    0.06745938f, -0.07998808f, 0.03139584f, -0.05905018f, 0.04326525f, -0.08019897f, 0.06413379f, -0.02664167f, 
    0.00144092f, -0.07419784f, 0.03776681f, 0.00168204f, -0.03843026f, 0.01130042f, -0.00727362f, 0.00109797f, 
    -0.02989236f, 0.05070189f, -0.03095339f, -0.07415714f, -0.02409659f, -0.03257265f, -0.06087333f, 0.03691516f, 
    -0.03784318f, -0.03068608f, -0.05777942f, -0.02845345f, -0.02238577f, -0.01819063f, -0.03402039f, -0.05081967f, 
    0.07103139f, 0.04850433f, -0.08112618f, -0.04170384f, 0.01667089f, 0.04477858f, -0.02579499f, -0.00599498f, 
    0.01402232f, -0.01562461f, -0.00568997f, -0.05369008f, -0.03969591f, 0.03179411f, -0.03812314f, -0.02214149f, 
    -0.06478584f, -0.03571314f, 0.07511915f, -0.05880614f, -0.02011750f, -0.04369373f, 0.02171643f, -0.00533265f, 
    -0.07889511f, 0.03947586f, -0.03610697f, -0.08211257f, -0.02836297f, 0.03275248f, -0.06032133f, -0.01996865f, 
    0.04707514f, 0.06455496f, -0.03809990f, 0.03098896f, 0.01493765f, 0.02928258f, -0.08251737f, -0.04411594f, 
    0.02124214f, 0.02510487f, -0.07053367f, -0.00024723f, 0.05356672f, -0.01468069f, -0.00866783f, 0.07187604f, 
    -0.00411490f, -0.01094184f, -0.00527107f, 0.05259158f, -0.00616328f, -0.00885289f, -0.06893875f, 0.01368176f, 
    0.07432475f, 0.01907285f, 0.06970952f, -0.03684720f, -0.00243796f, -0.01890581f, -0.05770015f, -0.02603156f, 
    0.05172019f, -0.03189189f, -0.02215913f, 0.04779388f, 0.03552305f, -0.04525809f, -0.04494400f, 0.04606508f, 
    0.01239360f, 0.01490373f, 0.01366105f, -0.01172690f, -0.05538895f, -0.00386194f, -0.02897818f, -0.04258590f, 
    0.06482185f, 0.03180742f, -0.06886721f, 0.00789262f, -0.00853813f, -0.02112421f, -0.07355647f, -0.00858133f, 
    0.25557855f, -0.29979056f, -0.84973818f, -0.07151651f, -0.10920656f, 0.10112528f, 0.07604113f, -0.21052286f, 
    0.02481135f, 0.08205616f, 0.09275853f, 0.00339276f, 0.12236957f, -0.22933018f, 0.01586708f, 0.01752955f, 
    -0.03181004f, 0.00937261f, 0.17548153f, -0.10568837f, -0.01392619f, 0.12590264f, -0.10983848f, 0.15272610f, 
    -0.15950832f, 0.08170450f, 0.02059952f, 0.05327184f, -0.10558019f, 0.56144726f, 0.05485501f, 0.31020093f, 
    -0.44483909f, 0.03799994f, -0.00078071f, -0.04030438f, 0.41946495f, -0.59887427f, -0.28037342f, -0.05800028f, 
    -0.12625177f, 0.04060429f, -0.08121865f, -0.16314262f, 0.13771825f, 0.09087455f, -0.32340530f, -0.13736777f, 
    -0.12499141f, -0.24233660f, -0.04170978f, 0.09647068f, 0.05662553f, 0.42682198f, -0.45744708f, 0.21143605f, 
    -0.18061726f, 0.25034726f, 0.18866253f, -0.14977372f, -0.17403346f, 0.05259834f, 0.08194027f, -0.29122519f, 
    -0.22865067f, 0.22254907f, -0.13711149f, 0.04173949f, -0.03204620f, 0.14956637f, 0.30373508f, 0.01666909f, 
    -0.01719380f, 0.13778561f, -0.23793806f, 0.27334875f, 0.30153647f, 0.03300519f, -0.09322070f, 0.03783130f, 
    -0.12172923f, -0.02710528f, -0.24952914f, 0.36023220f, 0.14195487f, 0.11259703f, -0.32083684f, -0.14405318f, 
    0.01691652f, -0.17117463f, 0.30218530f, 0.20528692f, -0.08227865f, -0.19717614f, -0.15692490f, 0.02521430f, 
    0.14774342f, 0.30242920f, 0.02272085f, 0.23215544f, 0.04475894f, 0.15277635f, -0.19032346f, 0.23512480f, 
    -0.16939996f, 0.13036902f, -0.23895179f, -0.14115500f, 0.20210768f, -0.09667652f, -0.24725062f, 0.04377065f, 
    -0.06880889f, 0.24309321f, -0.17196520f, 0.13274777f, -0.10666696f, -0.13665417f, 0.63686669f, 0.08276188f, 
    -0.08576440f, -0.19671427f, -0.06618430f, 0.10965572f, -0.17596909f, -0.00317359f, 0.22753872f, 0.59473771f, 
    -0.30263320f, 0.09169541f, -0.00844612f, -0.01418394f, 0.15864934f, 0.14977069f, -0.00872143f, -0.66459227f, 
    -0.27517435f, 0.01630957f, -0.24188209f, -0.00982573f, -0.07544051f, 0.18421388f, 0.23158160f, 0.21432854f, 
    -0.07443611f, -0.08577789f, -0.24840266f, 0.01289943f, -0.00396538f, -0.00221143f, -0.27145517f, -0.07193477f, 
    0.07883444f, -0.21429214f, -0.17546973f, 0.28032020f, 0.44146669f, 0.24887362f, -0.12361441f, -0.07545049f, 
    -0.02336439f, -0.08295466f, -0.22737354f, -0.54739851f, -0.12335499f, 0.31536925f, 0.29689130f, 0.06791703f, 
    0.13952631f, -0.03015131f, 0.07989589f, 0.18727641f, 0.08662620f, -0.09047104f, -0.36025319f, -0.08242475f, 
    0.13406400f, -0.06374697f, -0.17451224f, 0.11240588f, 0.39301601f, 0.42706448f, 0.07223894f, -0.39779356f, 
    -0.01788325f, -0.05880286f, 0.22296387f, 0.05781694f, -0.03186890f, 0.27508903f, -0.77937663f, -0.18554454f, 
    -0.10627187f, -0.10464462f, -0.12772822f, -0.10551609f, 0.09768999f, -0.12932408f, 0.17297794f, -0.06023235f, 
    -0.11749737f, 0.13853228f, -0.13356231f, -0.13436285f, 0.25297853f, -0.35791349f, -0.00835772f, -0.18455750f, 
    0.26130834f, 0.28072500f, -0.09095578f, -0.18588522f, -0.00586662f, -0.13406438f, 0.30114266f, 0.25034148f, 
    0.30362070f, 0.14367954f, 0.05074454f, -0.14823805f, -0.00884298f, 0.03203129f, 0.05662451f, 0.11018474f, 
    0.07232613f, 0.45110974f, 0.64524621f, -0.50804114f, -0.05422344f, 0.03755627f, -0.18544365f, 0.17854261f, 
    -0.13374975f, 0.22621353f, 0.03217349f, 0.00156616f, 0.19444177f, -0.09034169f, 0.14099911f, -0.17245741f, 
    -0.03129269f, 0.21412347f, 0.15490092f, -0.75067276f, -0.27953318f, -0.16057529f, -0.13638356f, 0.08496731f, 
    0.10342322f, 0.05749274f, 0.10815977f, -0.08650170f, -0.03011049f, -0.18524945f, 0.23229422f, 0.09280148f, 
    -0.24307984f, -0.12728302f, -0.06790137f, -0.01316481f, 0.13971190f, 0.25530165f, 0.16298272f, 0.21375260f, 
    -0.22023502f, -0.12406456f, -0.13537502f, -0.06337506f, 0.11311404f, -0.08106385f, -0.09895959f, 0.07158912f, 
    0.25265858f, -0.30511159f, -0.16682033f, 0.00835576f, 0.07473377f, 0.01151910f, -0.08260421f, 0.57103509f, 
    -0.23300326f, -0.19295518f, 0.00239421f, -0.18328473f, -0.02977553f, -0.03197476f, -0.00671015f, 0.04190079f, 
    -0.46967590f, -0.33340475f, 0.09254810f, -0.24904169f, 0.04218052f, 0.10820005f, 0.17535564f, -0.16302745f, 
    -0.03152724f, 0.17273332f, 0.09663292f, 0.02023496f, -0.16803259f, -0.00403531f, -0.06614281f, -0.02207422f, 
    -0.04665589f, -0.06243917f, 0.06767383f, -0.10052335f, 0.23575173f, -0.15611723f, -0.11429828f, 0.23913299f, 
    -0.25457206f, 0.19963519f, 0.31001446f, -0.34640571f, 0.06589022f, -0.18015705f, 0.21726814f, 0.05002334f, 
    0.03675974f, 0.00601238f, 0.12099463f, 0.00761849f, -0.21667388f, -0.22434491f, -0.09647737f, -0.05277941f, 
    0.03242534f, 0.17543551f, -0.03840876f, -0.06381395f, 0.07600453f, -0.31504601f, 0.10925154f, -0.36932981f, 
    -0.08122497f, -0.33326364f, -0.46980253f, -0.30561668f, -0.00025759f, -0.00763728f, 0.22549026f, -0.31083891f, 
    0.17637786f, 0.37292704f, -0.22821446f, 0.06565430f, -0.09116156f, 0.08958819f, 0.15472312f, -0.47022665f, 
    -0.17702071f, 0.19811295f, -0.09192871f, 0.48626137f, 0.01608781f, -0.00527040f, -0.06114349f, -0.01045955f, 
    -0.08566618f, -0.32738262f, 0.34978506f, 0.14903845f, 0.03999306f, 0.00922213f, -0.02300780f, 0.06839381f, 
    -0.20577157f, -0.33201241f, 0.09845482f, 0.27299455f, 0.07611720f, 0.11580051f, -0.02655334f, -0.20754290f, 
    0.07426135f, -0.07342049f, 0.28764650f, 0.18119450f, 0.11936072f, -0.01366567f, 0.16058056f, -0.27684650f, 
    0.23220465f, 0.04833298f, 0.21627696f, -0.10790443f, -0.35109842f, -0.26083687f, 0.07223495f, 0.26874101f, 
    0.02538725f, 0.23280965f, 0.02034002f, -0.41277036f, -0.43885031f, -0.21155831f, 0.07005294f, 0.26865628f, 
    0.21111123f, 0.17404975f, -0.00800253f, 0.33787328f, -0.20362704f, 0.15062562f, 0.51492441f, -0.10174346f, 
    -0.04705194f, -0.06674635f, -0.14938620f, -0.20331934f, 0.08500224f, 0.04141320f, 0.32219371f, 0.02217885f, 
    -0.67736453f, 0.38906255f, 0.19041623f, 0.07236754f, 0.21214221f, -0.10326068f, 0.11507974f, 0.37071157f, 
    0.23713972f, 0.28465408f, 0.04928389f, -0.03820001f, -0.06362291f, -0.04948893f, -0.00698802f, 0.04134163f, 
    0.01494619f, -0.02816511f, -0.06649844f, 0.01931555f, 0.00786538f, -0.00046883f, -0.05755633f, -0.03743757f, 
    -0.00355711f, 0.00105758f, -0.05788385f, 0.01560987f, -0.03168454f, -0.00893536f, 0.03391081f, -0.10156410f, 
    -0.03477835f, -0.10389780f, -0.09819303f, -0.04511136f, -0.10503799f, -0.03131448f, 0.03415352f, -0.05634986f, 
    -0.05768617f, -0.03854439f, 0.03986209f, -0.00458338f, -0.10481639f, -0.08822390f, -0.01632292f, -0.01417094f, 
    -0.07751402f, 0.02950877f, -0.09791779f, -0.00895028f, 0.02686002f, -0.08460709f, -0.02879836f, -0.00917892f, 
    0.01370203f, 0.05643729f, -0.05699513f, -0.01732599f, 0.00346663f, -0.04930791f, 0.03330898f, -0.08781575f, 
    0.07286453f, -0.04462828f, 0.06184667f, -0.09459111f, -0.08407296f, 0.02199997f, 0.00430628f, 0.01350355f, 
    0.04160154f, -0.04054722f, 0.05407114f, -0.10554552f, 0.00258818f, 0.03172849f, 0.04420155f, -0.04127075f, 
    -0.06057560f, 0.04904318f, 0.01098550f, -0.07190904f, -0.08388868f, -0.03634173f, -0.09790023f, -0.01800128f, 
    -0.02228076f, -0.03559959f, -0.00344262f, -0.05141919f, 0.01025600f, -0.02777149f, -0.07050569f, 0.02156347f, 
    0.05554125f, -0.00105289f, -0.05854485f, 0.01353898f, -0.01861881f, -0.04750333f, 0.00263633f, -0.05756748f, 
    -0.01482885f, -0.01186552f, -0.03033972f, -0.03503956f, 0.03286035f, -0.06260905f, -0.06866284f, 0.01630385f, 
    -0.07683980f, 0.04180525f, 0.03835449f, -0.09971873f, -0.08709561f, -0.05387618f, -0.01034199f, -0.05006586f, 
    0.05651598f, -0.04731129f, -0.03375297f, -0.04500453f, -0.07291199f, 0.03304224f, 0.02866189f, 0.02582005f, 
    0.03737371f, -0.05096541f, -0.07991485f, -0.08515947f, 0.04209604f, 0.05699344f, -0.06503873f, 0.05266436f, 
    0.01962654f, -0.02442712f, -0.00596769f, -0.02816874f, 0.05473961f, 0.00953102f, 0.01695459f, -0.08233237f, 
    0.02545869f, -0.04309307f, 0.06286501f, -0.05864727f, 0.01472325f, 0.05469649f, 0.03705667f, 0.04695486f, 
    0.04084286f, 0.05597305f, -0.05823245f, -0.05828030f, -0.07998571f, -0.00642834f, -0.07492793f, -0.07780252f, 
    -0.09457270f, 0.38393953f, 0.41331971f, 0.09219133f, 0.12056259f, -0.01559858f, 0.22236158f, 0.07643700f, 
    0.26030385f, 0.04129771f, -0.10989644f, -0.28627810f, -0.01778258f, 0.31298536f, 0.00526254f, -0.05524603f, 
    -0.15392652f, -0.16156548f, 0.08938134f, -0.23260704f, -0.05766919f, -0.19517745f, 0.05564558f, -0.19331695f, 
    -0.09224144f, -0.05828858f, 0.08777749f, 0.01310958f, -0.05722828f, 0.05336858f, 0.19191861f, 0.01398584f, 
    0.20129105f, -0.08501671f, -0.07954776f, -0.35915235f, 0.39689204f, -0.00748980f, -0.18080664f, -0.14318123f, 
    -0.17950049f, -0.09435813f, -0.55092400f, 0.15050885f, -0.24516793f, -0.25069222f, 0.15246740f, -0.27526724f, 
    0.02562466f, 0.12382784f, -0.24734375f, 0.07294542f, -0.14087178f, 0.12926468f, 0.42612717f, 0.02646817f, 
    0.43881986f, -0.00263518f, -0.15498494f, -0.20781124f, -0.03654759f, -0.02739301f, 0.01659486f, 0.40306726f, 
    -0.25774798f, 0.32689607f, -0.02430418f, 0.25948590f, -0.12986888f, 0.11979322f, -0.17367984f, -0.20111252f, 
    -0.07971369f, -0.26198584f, -0.41134581f, -0.04560365f, -0.25282636f, -0.29424566f, -0.06083114f, -0.01946008f, 
    -0.32419464f, 0.46641776f, 0.02553877f, -0.02703710f, -0.38533667f, 0.09991153f, -0.08772361f, 0.20365205f, 
    0.16438477f, 0.20323743f, -0.13498442f, -0.03535468f, 0.05094413f, 0.00881004f, 0.00890231f, 0.50776839f, 
    0.05104025f, 0.18889022f, -0.36194858f, -0.05762293f, 0.58437568f, 0.58570534f, 0.27437934f, -0.25045624f, 
    -0.22913080f, -0.28558969f, 0.21360132f, 0.50039339f, 0.32645389f, 0.00717330f, 0.24263646f, -0.22154428f, 
    -0.06672013f, -0.01325040f, 0.00702274f, 0.04863193f, 0.25615060f, 0.21471196f, -0.05257279f, -0.38275352f, 
    -0.06239359f, 0.28662741f, -0.11996498f, -0.01706900f, -0.05552107f, -0.35325599f, 0.03260659f, -0.31903186f, 
    0.62970811f, 0.19666493f, 0.16408302f, 0.38683093f, -0.07489832f, 0.15919632f, 0.25117856f, -0.33350751f, 
    -0.15524603f, -0.11260997f, 0.21735761f, -0.06038740f, -0.17911573f, -0.12521461f, -0.13235362f, -0.05611842f, 
    0.43666318f, 0.04714157f, 0.09842889f, -0.10897598f, -0.04057074f, 0.19148187f, 0.04639450f, 0.00145466f, 
    0.12063226f, -1.34939229f, -0.98451239f, -0.04151949f, 0.19056411f, 0.14646535f, 0.10074679f, 0.11927727f, 
    0.02963982f, -0.04862154f, -0.19959386f, 0.02158318f, 0.37765145f, 0.41157573f, 0.10965740f, 0.31665206f, 
    -0.34541231f, -0.06627843f, -0.00938193f, -0.33141497f, 0.25508153f, -0.28719759f, 0.12357084f, 0.08184025f, 
    -0.14687233f, 0.26092046f, 0.19734934f, 0.11713694f, -0.27958927f, 0.07921737f, -0.12195692f, -0.27473873f, 
    -0.22312446f, -0.27862120f, 0.05705107f, 0.35279667f, 0.09078465f, -0.61642838f, -0.42182344f, -0.30949685f, 
    -0.01389821f, 0.13655514f, -0.23817527f, -0.03930188f, 0.03543900f, -0.12923335f, -0.22036222f, -0.08998549f, 
    -0.03321540f, 0.12966749f, -0.26271573f, -0.03088075f, 0.11189393f, 0.12523611f, -0.02575604f, -0.25039652f, 
    0.00717046f, -0.09389981f, 0.14007099f, 0.03409458f, -0.24068350f, 0.14271547f, 0.15665588f, 0.18473946f, 
    0.18057312f, -0.30066288f, 0.02644305f, 0.10165539f, 0.01201915f, -0.06168986f, -0.10304245f, 0.13821907f, 
    0.07709145f, 0.01085849f, 0.44614372f, 0.45971364f, -0.01440537f, -0.19556068f, 0.02880700f, -0.10556424f, 
    -0.30487004f, -0.13717361f, -1.07580948f, -0.38524374f, -0.09255821f, 0.09239908f, 0.34568080f, 0.11728668f, 
    -0.09904519f, -0.04610609f, 0.02913115f, 0.44847700f, 0.31272796f, -0.22239576f, -0.05782681f, -0.15434016f, 
    0.08018135f, 0.15630688f, 0.07806704f, -0.08660045f, 0.52666771f, 0.27269587f, 0.37615970f, 0.18692355f, 
    -0.04439920f, -0.12396241f, -0.21773808f, -0.00773245f, 0.15261127f, 0.11944059f, -0.14430061f, 0.01093496f, 
    0.17488371f, -0.18922512f, 0.01305777f, -0.11149738f, 0.24007116f, 0.03675587f, 0.37675068f, 0.46444207f, 
    0.03607848f, 0.02722813f, 0.14829572f, -0.20799327f, -0.10328079f, 0.25067681f, 0.07852798f, 0.57415867f, 
    -0.19372918f, -0.14071102f, -0.14375407f, -0.15570800f, 0.03972876f, 0.05781671f, 0.15228081f, -0.07793266f, 
    0.06243815f, -0.00224117f, -0.03331857f, -0.04977527f, 0.02328851f, -0.04553014f, 0.03615844f, -0.04513723f, 
    0.05414750f, -0.02822460f, -0.02043571f, -0.08728553f, -0.08639172f, 0.04599011f, 0.06398652f, -0.07524727f, 
    0.05835535f, 0.00269153f, 0.03379760f, 0.03907251f, 0.05213197f, 0.00102510f, -0.02810844f, 0.02692001f, 
    -0.08668343f, -0.02453466f, 0.03094573f, 0.01402391f, -0.06838296f, 0.00157813f, -0.07638147f, -0.02992323f, 
    0.06394470f, -0.05531884f, 0.06910168f, -0.05643161f, -0.01280310f, -0.03700820f, -0.05952453f, 0.01954838f, 
    0.00115359f, -0.07212559f, -0.03269329f, 0.04162714f, -0.07245673f, -0.07483093f, 0.00399315f, 0.02677015f, 
    -0.00964634f, 0.03755890f, 0.06267129f, 0.05919965f, 0.01503792f, -0.05912382f, -0.04787940f, 0.01461560f, 
    -0.03968531f, -0.03048786f, -0.06330193f, -0.01903380f, -0.08768597f, -0.03999453f, -0.07922540f, 0.05307091f, 
    0.02923990f, -0.07269659f, 0.00695654f, -0.04572050f, 0.00583141f, -0.04797924f, -0.07509889f, -0.04561339f, 
    -0.03806672f, -0.06360430f, -0.01945680f, 0.01976947f, -0.08140333f, -0.09117623f, 0.05550436f, 0.03535797f, 
    0.05300947f, -0.07106215f, 0.08262460f, -0.07674303f, -0.08814192f, 0.04036124f, -0.00785936f, -0.03421260f, 
    -0.06575468f, -0.04315741f, 0.03487925f, -0.02354416f, -0.01264424f, -0.05868320f, -0.09109268f, 0.04691696f, 
    -0.05450625f, -0.03272725f, 0.05200320f, 0.05980075f, -0.07946903f, -0.07696217f, -0.01592344f, -0.08450641f, 
    0.02588915f, 0.03109674f, 0.03496650f, -0.06815750f, 0.03091907f, -0.06700091f, 0.04395828f, 0.01761356f, 
    -0.04957089f, -0.00639186f, 0.00559645f, 0.04589418f, -0.04000273f, -0.06132775f, 0.04704616f, -0.05474222f, 
    0.04242855f, 0.03398300f, 0.04696819f, 0.01829377f, -0.05595721f, -0.01227874f, -0.00745725f, -0.08392893f, 
    0.02973339f, 0.04637942f, -0.04334155f, -0.03916323f, 0.00913579f, 0.04146708f, 0.00825002f, 0.00594675f, 
    0.04768480f, 0.04450130f, 0.04320126f, 0.04556505f, -0.07329632f, 0.04738091f, 0.02541492f, 0.07147061f, 
    -0.20069230f, -0.37625709f, -0.27211896f, 0.45987770f, -0.09868333f, -0.31039900f, -0.11177123f, 0.20514834f, 
    0.02114384f, 0.02555160f, 0.25833887f, -0.09892222f, 0.18282045f, 0.07828486f, 0.09749559f, -0.20551607f, 
    -0.02720712f, 0.28368795f, -0.32731342f, -0.19321746f, -0.28192201f, 0.24399048f, 0.06349260f, 0.24540269f, 
    -0.33948860f, 0.13754444f, 0.03008117f, 0.54136050f, 0.32112956f, -0.23739240f, -0.00101690f, 0.07734020f, 
    0.00975823f, 0.04459554f, 0.19636118f, 0.26580614f, -0.07077352f, 0.00413738f, 0.19509412f, 0.12731154f, 
    -0.03675891f, -0.24968028f, 0.23616156f, 0.02842608f, -0.27460343f, -0.21356176f, 0.00287942f, -0.02821358f, 
    0.21076970f, 0.06067111f, -0.01038681f, -0.11154965f, -0.07432549f, -0.05715226f, -0.41459677f, -0.13209535f, 
    -0.03327959f, -0.02703154f, -0.09989440f, 0.02717688f, -0.04664915f, -0.11938170f, -0.01577537f, 0.40643826f, 
    0.11607929f, 0.07893022f, 0.06815936f, -0.18445216f, -0.02004369f, -0.31422362f, 0.02507289f, -0.20153816f, 
    -0.51390374f, 0.08987425f, -0.13041674f, -0.05634376f, -0.29071841f, -0.07409975f, 0.08242165f, -0.03742360f, 
    -0.27848113f, -0.09349945f, -0.03385550f, 0.28585097f, 0.09599454f, -0.11107379f, 0.21307553f, 0.04603421f, 
    0.14332411f, -0.19146091f, 0.29574567f, -0.13460590f, -0.08651502f, 0.29049557f, -0.11597238f, 0.01292487f, 
    0.05064364f, 0.19778962f, 0.23501346f, 0.01245658f, 0.10367565f, 0.27007475f, -0.10982345f, -0.09634104f, 
    0.25103670f, 0.07355766f, 0.10536473f, -0.29220632f, -0.35064551f, -0.27014959f, -0.06626236f, 0.04089848f, 
    0.07244643f, 0.01918709f, 0.19598192f, 0.25484905f, 0.01342763f, 0.27360153f, 0.16356765f, 0.20273405f, 
    0.00431588f, 0.06614494f, -0.10550611f, -0.17720011f, 0.05923821f, 0.08738849f, 0.40100005f, 0.37682366f, 
    0.77171367f, -0.11982505f, -0.09150308f, -0.08383015f, 0.02900308f, -0.08031054f, 0.07860326f, -0.30784974f, 
    -0.36469749f, -0.25438508f, -0.20833218f, 0.10624997f, -0.08886490f, 0.21346724f, -0.15171833f, 0.11635071f, 
    0.09534853f, 0.09284232f, -0.18880296f, -0.07211068f, -0.12648937f, -0.15546685f, 0.19402137f, -0.11772341f, 
    0.30998659f, 0.06061209f, 0.49676263f, 0.51849639f, 0.03870036f, 0.10823834f, -0.00266827f, 0.46628022f, 
    0.02642202f, -0.10568271f, -0.01444966f, 0.52207440f, 0.41984388f, -0.09157140f, 0.14716306f, 0.01577899f, 
    0.01204434f, -0.02784925f, 0.09877428f, -0.14733917f, -0.55911756f, 0.12789360f, 0.16738737f, -0.16545418f, 
    0.06733827f, -0.14064261f, 0.08660339f, -0.34789282f, -0.40670228f, -0.74330127f, -0.84839773f, 0.03845967f, 
    0.05482661f, -0.35246149f, 0.05295503f, -0.33007243f, 0.06340861f, -0.09432311f, 0.08006000f, 0.31910017f, 
    -0.21382695f, -0.09406985f, -0.16948870f, 0.05623123f, -0.02064109f, 0.03610796f, -0.06214443f, 0.00346374f, 
    -0.31162071f, -0.08660372f, 0.07302889f, 0.12087281f, 0.12637077f, 0.14579573f, 0.06762072f, -0.19223097f, 
    0.07342553f, -0.29439971f, 0.27071145f, 0.20345750f, 0.03889540f, 0.15449239f, -0.03714705f, 0.18272828f, 
    -0.60076100f, -0.00799944f, -0.18531828f, -0.25836575f, -0.06752652f, 0.12632707f, 0.01919406f, 0.06108507f, 
    -0.10550484f, 0.00112162f, -0.25252137f, -0.07445958f, 0.09752464f, 0.07664500f, 0.09459002f, -0.06186774f, 
    -0.13376853f, -0.05863592f, 0.48653111f, 0.44767287f, 0.22695795f, 0.37778023f, 0.18923308f, 0.20450994f, 
    0.05065556f, -0.00521125f, 0.07806918f, -0.58358872f, -0.52067941f, -0.27117509f, -0.18667202f, 0.28734049f, 
    0.25792873f, 0.00956710f, -0.36781028f, -0.26458994f, 0.36540267f, 0.05513665f, -0.36939305f, 0.15915488f, 
    0.21105143f, -0.19399151f, 0.14987904f, 0.42624465f, 0.30731532f, -0.26567397f, -0.00027098f, -0.24314684f, 
    0.09110700f, 0.02918595f, 0.03351240f, 0.07575715f, 0.04315819f, -0.05462879f, 0.15637006f, -0.34282848f, 
    -0.18775462f, 0.12377029f, 0.00366184f, 0.15270212f, -0.00808598f, -0.09100197f, 0.00376368f, 0.10926859f, 
    -0.22104335f, -0.01975901f, -0.24815841f, 0.00511021f, 0.08254847f, -0.01600949f, 0.09623275f, 0.14161046f, 
    0.07075395f, -0.08179278f, 0.07102185f, 0.05007518f, 0.03254841f, -0.01066177f, -0.03887479f, -0.01987885f, 
    -0.07738478f, 0.07107832f, 0.07729303f, 0.06173391f, -0.08080799f, -0.02809787f, -0.05018029f, 0.05867912f, 
    0.00797711f, 0.04969164f, -0.00259298f, 0.03918082f, -0.08711129f, -0.02767287f, -0.05499687f, 0.03661896f, 
    0.01814368f, 0.06615535f, -0.04784034f, 0.06711119f, -0.03888307f, -0.08749091f, -0.03302539f, -0.07314056f, 
    -0.08563901f, 0.01579334f, -0.08393023f, 0.00320061f, -0.01313899f, -0.00126802f, 0.00556435f, 0.04385833f, 
    -0.06976942f, 0.00781983f, -0.03465987f, 0.01504729f, 0.01693779f, -0.02948842f, -0.03836923f, -0.01114959f, 
    0.07134004f, 0.03476243f, -0.05103231f, 0.05617790f, 0.06751673f, -0.06726293f, -0.09348549f, 0.00361026f, 
    0.03986045f, -0.03397092f, -0.09045512f, 0.03089297f, -0.05065487f, -0.07196056f, -0.05718804f, -0.03729444f, 
    -0.06369717f, 0.06589492f, 0.06812035f, -0.04994689f, -0.06991598f, 0.05371801f, 0.04890738f, 0.03062450f, 
    -0.00132951f, -0.02318157f, 0.06338069f, -0.00555855f, 0.03340392f, -0.06383748f, -0.04012720f, 0.01548603f, 
    -0.07597098f, 0.03092845f, -0.03933394f, 0.02124595f, -0.07096184f, -0.00405347f, -0.09592933f, -0.06175283f, 
    0.07391353f, -0.08221903f, 0.06337204f, -0.01670562f, -0.00614777f, 0.05029928f, 0.01877031f, -0.02871764f, 
    -0.08765049f, -0.08235994f, -0.08763447f, -0.00291008f, -0.03718442f, -0.02177913f, -0.05040341f, -0.08318537f, 
    -0.05993473f, -0.02199760f, -0.07558817f, -0.05285669f, -0.06404175f, -0.05510871f, 0.07351980f, -0.04661407f, 
    0.07089192f, -0.05222245f, -0.02831384f, -0.09122236f, -0.06212346f, -0.05699430f, -0.06043869f, -0.04175720f, 
    -0.00491434f, 0.04373030f, -0.02968734f, 0.06696499f, 0.05810646f, -0.05933097f, -0.04871122f, -0.00006521f, 
    0.04307346f, -0.07388008f, 0.02010735f, -0.08993907f, -0.03975339f, 0.01478761f, 0.02314734f, -0.04576898f, 
    -0.03225437f, -0.07775143f, -0.03737575f, -0.07170221f, 0.03528921f, 0.06314861f, 0.05580012f, -0.04342917f, 
    -0.08090801f, 0.46175280f, -0.74481887f, 0.04812576f, -0.00684348f, -0.18920101f, -0.08648142f, -0.00275339f, 
    -0.14916584f, -0.83305144f, 0.06731606f, 0.11689167f, 0.09408846f, 0.26779693f, 0.10898194f, -0.16617838f, 
    0.11248773f, -0.06390406f, 0.24158114f, 0.44727522f, 0.02923048f, 0.33148828f, 0.07400008f, 0.15767278f, 
    -0.01167864f, -0.12962241f, 0.04290629f, 0.33292583f, -0.03444249f, 0.08999105f, -0.19906755f, 0.03070312f, 
    0.11674765f, 0.02746719f, -0.00819861f, -0.16399600f, 0.16813743f, -0.58562142f, 0.06852886f, -0.27905184f, 
    -0.19509467f, 0.04882404f, -0.02939961f, 0.01681156f, -0.07224812f, -0.05558043f, -0.01145236f, -0.25624001f, 
    -0.00941675f, -0.17750192f, 0.14365214f, -0.02419692f, -0.02400490f, 0.07465648f, 0.63226664f, 0.13881651f, 
    -0.08170895f, -0.27512091f, 0.21004194f, 0.14213879f, 0.01797214f, -0.04816633f, -0.14349082f, 0.60394841f, 
    -0.20019701f, 0.18424456f, -0.06931058f, -0.08057465f, 0.14621077f, -0.19219558f, 0.04190782f, -0.06195628f, 
    -0.68411016f, -0.10748084f, 0.18137711f, -0.11262303f, 0.00823283f, -0.19421667f, -0.05394652f, -0.01322040f, 
    -0.10896996f, -0.67856711f, -0.10718250f, 0.17486770f, -0.12194779f, 0.24429654f, 0.15565160f, -0.29266536f, 
    0.09747715f, 0.13381414f, -0.59249818f, 0.01464327f, -0.03251833f, 0.11062337f, 0.00494139f, 0.00631494f, 
    0.00589275f, -0.03125119f, 0.25881168f, 0.33231306f, -0.17403454f, -0.03156541f, -0.03966555f, 0.11571088f, 
    0.11696461f, 0.10256600f, -0.01533460f, 0.09502973f, 0.41316098f, -0.30934227f, -0.45122105f, -0.19339493f, 
    0.00848887f, -0.04414709f, -0.02418066f, -0.06022134f, -0.00072495f, 0.50888187f, 0.23562041f, -0.10018723f, 
    -0.09074242f, -0.00896436f, 0.25479954f, -0.15236452f, 0.00728546f, -0.05358773f, 0.13361089f, 0.16675836f, 
    -0.02871188f, -0.30338708f, -0.20840046f, -0.21097510f, 0.07413515f, 0.04018902f, 0.06671514f, 0.10596144f, 
    -0.31808874f, 0.03424745f, 0.10211784f, 0.01475608f, 0.02351872f, 0.06003596f, 0.26213160f, -0.04694408f, 
    0.00829642f, 0.00299083f, 0.03075092f, 0.05822513f, -0.06931899f, 0.03889171f, -0.07156146f, 0.06232988f, 
    -0.00611390f, 0.05195273f, 0.00308096f, -0.05477113f, -0.07399359f, -0.08488251f, -0.07459413f, -0.06461633f, 
    0.04485992f, -0.02054721f, 0.05485803f, -0.05085651f, 0.01779879f, 0.06519008f, -0.09365208f, 0.00403700f, 
    -0.08218937f, -0.05712248f, 0.06974807f, 0.00140225f, -0.03367091f, -0.04015785f, 0.03747150f, -0.03638941f, 
    -0.01527538f, -0.03027627f, -0.06254697f, 0.04875664f, -0.07567429f, 0.00170445f, -0.02640043f, 0.00950449f, 
    -0.03224214f, 0.03275519f, 0.06493227f, -0.02947945f, 0.03793292f, -0.08354803f, -0.00167623f, 0.06009730f, 
    0.00971306f, -0.07129362f, -0.07098841f, -0.05776434f, -0.02939455f, -0.07096079f, -0.09456593f, 0.06408193f, 
    0.02083722f, -0.06935781f, -0.05251835f, -0.00781595f, -0.06186774f, 0.04886813f, 0.03701160f, 0.04747478f, 
    -0.02860704f, -0.04760950f, -0.00454101f, 0.01889241f, 0.04135950f, -0.05986959f, -0.06868204f, -0.00836438f, 
    -0.03107766f, -0.06096288f, 0.03609262f, -0.09115332f, -0.04162546f, 0.06737985f, -0.07107878f, -0.03547966f, 
    -0.07564612f, -0.00585154f, -0.07905135f, -0.04132016f, 0.06661069f, -0.00837864f, -0.01231357f, -0.06705143f, 
    -0.08541359f, -0.09623288f, -0.05041281f, 0.04261624f, -0.00355739f, -0.02355899f, 0.04178184f, 0.00574958f, 
    -0.08731829f, 0.00888158f, 0.06867264f, -0.01383749f, 0.04285062f, 0.05383091f, 0.04622973f, -0.06477976f, 
    -0.08780756f, -0.00615350f, -0.01949132f, 0.00275028f, 0.00507652f, -0.06444188f, -0.09535518f, -0.04856927f, 
    -0.09197931f, 0.04964396f, -0.02538909f, 0.04894459f, -0.07460278f, -0.07706156f, 0.01019139f, -0.08404449f, 
    0.05975349f, 0.06448928f, -0.05236090f, -0.06500330f, 0.06538550f, 0.00871606f, 0.03764639f, -0.05991734f, 
    -0.07477399f, 0.04445772f, 0.00064811f, -0.05167044f, -0.08635658f, 0.00076013f, -0.07370042f, 0.02730031f, 
    -0.08557422f, 0.04204167f, -0.02574298f, -0.08140391f, -0.01773631f, 0.06560615f, 0.00120948f, 0.00360021f, 
    -0.02486793f, -0.07600594f, 0.03928735f, 0.10436533f, 0.06528083f, 0.14624959f, -0.03038134f, -0.15137932f, 
    0.15696071f, 0.10232698f, 0.10231239f, -0.02623792f, -0.16099717f, 0.28785518f, 0.07655538f, 0.06358764f, 
    -0.08421189f, -0.16955259f, -0.25913504f, 0.62024975f, -0.24607275f, -0.05333827f, -0.20742500f, 0.01215463f, 
    0.09466754f, 0.05027984f, -0.24155268f, 0.14968325f, 0.13082044f, -0.29564020f, -0.13766713f, 0.12592764f, 
    0.05945762f, -0.00103541f, -0.13195033f, -0.21017136f, 0.46591163f, -0.16897552f, 0.26485109f, -0.12399882f, 
    -0.17835529f, 0.22450231f, -0.06805702f, -0.03145911f, -0.03948982f, -0.58328211f, 0.26562971f, 0.04089169f, 
    -0.28755894f, -0.17602797f, 0.11101361f, 0.16696525f, -0.10619501f, 0.20584199f, -0.17459956f, 0.52591634f, 
    -0.16569395f, -0.09173155f, 0.05080684f, -0.17891262f, 0.06776022f, -0.09930553f, 0.00352790f, -0.26923954f, 
    -0.19886398f, 0.10491664f, 0.13395481f, -0.05643972f, 0.04027094f, 0.28903648f, -0.00144109f, -0.10762681f, 
    0.13057227f, -0.42245600f, -0.39505500f, 0.11363053f, 0.31729892f, -0.24369447f, 0.00302888f, 0.10882251f, 
    0.12511502f, 0.12759241f, -0.24347591f, 0.55579722f, -0.09570853f, 0.00934581f, 0.03665731f, 0.09701685f, 
    0.16783582f, 0.07439984f, 0.18468839f, -0.08137975f, -0.09190423f, 0.04001917f, 0.16714036f, 0.19555651f, 
    0.19490553f, 0.16422610f, 0.02886808f, -0.29264984f, -0.10763032f, -0.06537244f, -0.16102366f, -0.25027546f, 
    -0.16384123f, 0.09498485f, -0.18117931f, 0.01551711f, -0.09920941f, 0.03635110f, -0.44174740f, 0.13695145f, 
    -0.25038332f, -0.05384442f, -0.12438728f, 0.33320877f, 0.10051397f, 0.49701077f, 0.08605999f, -0.16463962f, 
    0.08693415f, 0.09985571f, 0.06692772f, -0.12429934f, -0.30383402f, -0.12482949f, -0.13521682f, 0.03159517f, 
    0.64720541f, -0.08435287f, -0.10761030f, 0.16785331f, -0.20521364f, 0.03137960f, 0.29068407f, -0.20096293f, 
    0.33530679f, -0.46264845f, 0.06637799f, 0.25844103f, 0.02412098f, 0.05504216f, 0.31795263f, 0.06349667f, 
    -0.12123520f, -0.06948239f, -0.30299756f, 0.03432846f, 0.24992405f, 0.29703894f, -0.13272578f, 0.02671649f, 
    -0.08028844f, 0.17422472f, -0.01872160f, 0.14306062f, -0.14784510f, 0.15998006f, 0.20335847f, -0.17970584f, 
    -0.09546711f, -0.00692488f, 0.19702131f, -0.07076870f, -0.22600307f, -0.03908646f, -0.01357744f, 0.13064069f, 
    -0.01492573f, -0.01033807f, 0.05401570f, -0.26156318f, 0.16431919f, 0.03964649f, -0.26752871f, -0.16257235f, 
    -0.29219604f, 0.08361153f, -0.13899085f, 0.14107057f, -0.58231801f, 0.00211730f, -0.12041829f, 0.00578842f, 
    -0.28322536f, 0.01905095f, 0.07431590f, -0.05770731f, 0.10976757f, 0.12202409f, 0.00467741f, 0.16015851f, 
    0.05115554f, -0.09705368f, 0.03374368f, 0.18718791f, 0.02462604f, 0.21171789f, 0.30197114f, -0.68316704f, 
    -0.33485529f, -0.02071552f, 0.04079393f, -0.01136567f, -0.07859665f, 0.01325645f, -0.12910481f, 0.09684265f, 
    -0.08372700f, 0.02971200f, 0.04949379f, 0.25082663f, -0.03820756f, -0.05246009f, 0.05952507f, -0.22887760f, 
    0.75928301f, 0.60185540f, 0.03997894f, 0.02098290f, 0.06754973f, 0.14213398f, 0.08029488f, -0.07163298f, 
    0.15235689f, -0.31835982f, 0.08140773f, -0.08027174f, 0.29988649f, 0.18310478f, 0.15267910f, -0.19643864f, 
    -0.03382139f, -0.09125156f, -0.20209070f, 0.05048086f, 0.20409998f, 0.14822936f, 0.07649449f, -0.02202784f, 
    0.07408734f, -0.04542293f, -0.02278120f, 0.04096936f, -1.06303561f, -0.44826621f, 0.23948117f, 0.15618819f, 
    0.14838339f, -0.04797974f, -0.14732985f, -0.09794869f, -0.63704807f, -0.61268795f, -0.33895990f, -0.06298136f, 
    0.05749245f, -0.19044079f, 0.16564217f, -0.02551715f, 0.08155467f, 0.27290118f, 0.10746409f, -0.02612149f, 
    0.14609259f, -0.23516975f, -0.23819919f, 0.01807918f, 0.12534797f, 0.00599423f, 0.27915820f, -0.12815474f, 
    0.03296664f, -0.09386995f, 0.03638537f, -0.03242069f, 0.09402293f, -0.05109030f, 0.02138230f, 0.17586415f, 
    0.07580806f, 0.10365759f, 0.01515701f, 0.16064681f, -0.05277921f, -0.04014868f, 0.27268764f, 0.09422803f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.10532174f, 0.00459422f, -0.06731076f, 0.05408806f, 0.29021478f, -0.07538735f, -0.05504085f, 0.24442562f, 
    -0.05352772f, 0.04498675f, 0.24603799f, 0.05541767f, -0.07766819f, 0.05080625f, 0.48153627f, 0.00018534f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.56648040f, -0.07816476f, 0.79737681f, -0.37624007f, 0.64511943f, 0.14336252f, -0.01688885f, -0.21897811f, 
    0.23835646f, 0.04603292f, -0.43037951f, 0.15348406f, -0.21627034f, 0.14109454f, 0.18569535f, -0.37434712f, 
    -0.47642666f, 0.07034532f, 0.58237332f, 0.25205812f, 0.24134554f, 0.01913442f, -0.31537524f, -0.31227958f, 
    -0.09680209f, -0.11938278f, 0.17570426f, -0.06268682f, 0.03587794f, -0.08000139f, -0.28700453f, 0.55434132f, 
    -0.07048921f, -0.01551569f, -0.38129967f, -0.37677631f, -0.51950920f, 0.11900761f, -0.10955133f, -0.65265095f, 
    -0.18288533f, 0.32753447f, -0.39168513f, 0.19868903f, 1.23001671f, -0.10413298f, 0.07357495f, 0.50740069f, 
    0.22235416f, 0.01523665f, -0.16891603f, 0.57434237f, -0.54070985f, 0.13951278f, 0.04894555f, 0.54752809f, 
    0.17571753f, -0.65336591f, -0.32697481f, 0.13184454f, 0.40140012f, -0.24033055f, 0.08842744f, -0.48724326f, 
    -0.13428721f, -0.17388645f, -0.37279767f, -0.13218960f, -0.03059231f, 0.02205291f, 0.39936873f, -0.19422661f, 
    -0.08380183f, -0.04278106f, 0.21330690f, 0.05856411f, -0.15605497f, 0.12560695f, 0.45195684f, -0.84983081f, 
    -0.16775867f, -0.19941168f, 0.12638049f, -0.43712741f, 0.52135909f, -0.07208366f, -0.33953348f, -0.08577380f, 
    -0.20295851f, 0.02150711f, 0.44741634f, -0.16540006f, -0.38024291f, -0.10050848f, -0.13485485f, -0.31876460f, 
    0.33883178f, -0.05789619f, -0.51124340f, 0.07056640f, 0.07018271f, 0.06945264f, 0.10070075f, -0.30457208f, 
    0.20216803f, -0.73607665f, 0.75233281f, 0.05879722f, 0.04192135f, 0.16885448f, -0.22648868f, -0.31864023f, 
    -0.76056039f, -0.06533630f, -0.15718016f, -0.28830710f, -0.51990277f, 0.02425024f, 0.82225639f, 0.35491106f, 
    0.07911297f, 0.75192142f, -0.51765585f, -0.13460235f, -0.32046422f, -0.21323454f, -0.47131538f, -0.64363545f, 
    0.02619324f, 0.15814777f, 0.37248540f, 1.11602771f, 0.33733544f, 0.10280693f, -0.75944746f, -0.52817643f, 
    -0.07572701f, 0.49223000f, -0.29379663f, 0.18328011f, -0.63990629f, 0.21214880f, -0.58825403f, 0.10942918f, 
    -0.05683241f, 0.10556875f, -0.83317345f, -0.20003828f, 0.38500735f, 0.12401773f, 0.10205350f, -0.29124421f, 
    -0.21281365f, 0.12306240f, -0.24527185f, -0.03189000f, -0.68612206f, -0.08758427f, 0.77492416f, 0.50558168f, 
    0.04937315f, 0.12454665f, -0.14914863f, -0.12732643f, -0.04380336f, -0.07925351f, -0.65771413f, 0.75048101f, 
    -0.08620489f, 0.49258769f, -0.52471209f, -0.16938128f, 0.34276918f, 0.06244999f, -0.35576713f, 0.23350850f, 
    1.06883848f, 0.23102987f, -0.33307090f, 0.13135937f, -0.29368252f, -0.12045211f, 0.26866472f, -0.11097381f, 
    0.13663752f, -0.27070844f, -0.16890776f, -0.14133149f, -0.07572364f, -0.08903110f, -0.32383171f, -0.07885763f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02040840f, 0.07335534f, -0.60145581f, 0.01013599f, 0.58088803f, -0.01731124f, 0.08794492f, -0.85089642f, 
    -0.48744547f, -0.29869643f, 0.45847622f, -0.13168430f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
