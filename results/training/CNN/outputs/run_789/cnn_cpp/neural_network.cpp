#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.49318075f, 0.29540908f, 0.13592076f, -0.64174253f, 0.27576599f, -0.22394815f, 0.01899517f, -0.29885232f, 
    -0.27423415f, -0.42733634f, 0.01418883f, 0.13598725f, 0.30407128f, 0.10460848f, 0.07947262f, -0.21565285f, 
    0.01578898f, -0.07304413f, 0.06593931f, -0.02580019f, -0.08681622f, 0.21603312f, 0.17334986f, 0.28334689f, 
    -0.09399898f, 0.88051093f, -0.53744179f, 0.71623588f, 0.45094600f, 0.19220382f, 0.31278792f, 0.07977363f, 
    0.15769680f, -0.13999288f, -0.16542535f, 0.04116272f, -0.04896217f, -0.02846290f, 0.19147234f, -0.03212355f, 
    0.00264770f, 0.07710752f, -0.00745661f, 0.08388083f, 0.06974617f, -0.18705042f, 0.08303197f, 0.06489551f, 
    0.02928679f, 0.03410663f, -0.08883955f, -0.59285527f, -0.40250126f, -0.19020322f, -0.20492500f, -0.16971101f, 
    -0.46809131f, -0.38852093f, 0.00947010f, 0.31297779f, -0.03518481f, 0.13203692f, -0.15071945f, 0.13807081f, 
    0.03375516f, -0.04523072f, 0.15286452f, 0.32012028f, 0.02999381f, 0.01452812f, 0.22062875f, -0.17363848f, 
    -0.05561999f, 0.12141283f, -0.01110494f, 0.59501421f, 0.44727653f, 0.35434058f, 0.66114080f, 0.46908715f, 
    -0.32149881f, -0.15991248f, 0.05430819f, -0.14438765f, -0.06571522f, -0.35028854f, -0.00165855f, 0.10635112f, 
    0.19405493f, 0.09293974f, 0.06176136f, -0.00711282f, 0.22929196f, 0.09723751f, 0.16843544f, 0.12451183f, 
    -0.07969271f, -0.17035866f, -0.00942132f, 0.05440405f, -0.17382130f, 0.24179026f, 0.19014449f, 0.01402801f, 
    0.71917832f, -0.15590553f, -0.68728465f, -0.34321827f, -0.56152755f, -0.12052076f, 0.32946184f, 0.17656517f, 
    -0.12597448f, 0.02784630f, 0.16008487f, 0.31509897f, 0.03518654f, -0.22840898f, -0.02031890f, 0.23214568f, 
    0.08245004f, 0.09236956f, 0.02627960f, 0.08677048f, -0.02416140f, 0.62072200f, 0.61284852f, 0.72911233f, 
    -0.00561464f, 0.40846622f, -0.47999710f, 0.08764797f, -0.02093264f, 0.08212801f, 0.05611238f, 0.13185574f, 
    0.36391258f, -0.11264742f, -0.05052987f, 0.16835397f, -0.10433865f, -0.11045568f, -0.05914710f, -0.10274648f, 
    0.14606901f, -0.00354107f, 0.17266206f, 0.27059701f, -0.00059391f, -0.01499998f, -0.29455906f, -0.63656360f, 
    0.42782906f, 0.73555863f, -0.49761644f, -0.05538744f, 0.07970430f, 0.05292821f, 0.24967454f, 0.06901058f, 
    -0.06619596f, -0.20275381f, 0.11921865f, -0.03492049f, -0.07670790f, -0.27059385f, -0.18691064f, -0.31884429f, 
    0.03214964f, -0.14947888f, 0.06136630f, 0.14444083f, -0.00401733f, -0.07702440f, 0.00507652f, -0.64049613f, 
    -0.46281210f, -0.10669213f, -0.07712094f, -0.38326052f, 0.33023766f, 0.70179617f, 0.09189632f, -0.12586829f, 
    0.44009876f, -0.23838919f, -0.19099030f, -0.18428230f, -0.29054278f, 0.02103472f, 0.01722694f, 0.17197929f, 
    -0.03161418f, 0.00573616f, 0.00070378f, 0.04965853f, -0.01218074f, -0.04824118f, -0.00676554f, -0.08609674f, 
    0.74802780f, -0.32634035f, -0.52772301f, 0.70424086f, 0.26150265f, 0.33466044f, 0.44773349f, -0.15595351f, 
    0.27083674f, 0.10372843f, 0.05875676f, 0.20605758f, -0.20329428f, 0.05428298f, 0.09463060f, -0.08239288f, 
    -0.22182173f, -0.06959137f, 0.15842532f, -0.13124308f, -0.03992446f, 0.00908545f, 0.26608431f, -0.00347426f, 
    -0.06588544f, 0.35731918f, 0.64431387f, -0.46534577f, -0.54825717f, -0.56228334f, 0.49376523f, -0.11629567f, 
    -0.42883512f, -0.30266818f, -0.17797473f, 0.06578130f, 0.25427672f, 0.19611016f, 0.21861999f, -0.02398000f, 
    0.07457990f, -0.19994886f, 0.05802536f, 0.07344943f, 0.03708367f, 0.05748392f, 0.11181296f, 0.07024278f, 
    -0.13990535f, 0.18623126f, 0.34943444f, 0.44203621f, -0.39668122f, 0.34282565f, 0.39005584f, 0.25019500f, 
    0.23525433f, 0.42642692f, 0.37992513f, 0.42298347f, -0.12401798f, -0.04824649f, -0.40649700f, -0.31422111f, 
    -0.01830123f, 0.01180949f, -0.21597959f, -0.32605860f, -0.00193908f, -0.07935394f, -0.17096154f, -0.04385574f, 
    -0.11154287f, -0.16586673f, -0.18846473f, -0.48083320f, -0.40583968f, -0.12056216f, 0.03317132f, -0.42957249f, 
    -0.20180148f, 0.26405817f, -0.26796135f, -0.38410062f, -0.06935471f, -0.10254049f, 0.18950698f, 0.08224203f, 
    0.33235168f, 0.35107809f, -0.11002737f, -0.27937555f, 0.03318554f, 0.19968840f, 0.14046392f, 0.07478643f, 
    -0.02046417f, 0.08685300f, -0.17337985f, -0.06737150f, -0.30032882f, -0.78653014f, -0.18175042f, 0.08701538f, 
    0.36187980f, -0.24724461f, 0.31216916f, 0.48967099f, -0.53700668f, 0.18944487f, 0.03955235f, 0.10020572f, 
    0.15830243f, 0.04632216f, 0.08172065f, 0.00458224f, 0.18546632f, 0.18548770f, 0.07776222f, -0.13382544f, 
    0.28190023f, -0.09023014f, -0.01957335f, 0.04301158f, -0.04820541f, 0.84272480f, -0.22101529f, -0.07123424f, 
    0.00890172f, 0.04148209f, -0.48825100f, 0.02908685f, -0.13851292f, -0.33748907f, -0.34164381f, -0.41013628f, 
    -0.28172591f, -0.23068757f, -0.33212528f, -0.29488567f, -0.32006094f, -0.08131469f, -0.12439463f, 0.03285266f, 
    -0.06173753f, 0.19758995f, 0.08640296f, -0.04687393f, -0.19860171f, 0.02578590f, -0.41976488f, -0.62634540f, 
    -0.02219368f, -0.38407528f, 0.09725016f, 0.25443438f, 0.16246744f, 0.50245464f, -0.02016129f, 0.25621989f, 
    0.04301449f, 0.01118187f, 0.13859604f, -0.00868082f, -0.07340842f, -0.16455467f, -0.27298591f, -0.20176509f, 
    -0.23969330f, -0.16210893f, -0.18510275f, -0.19815175f, 0.27122700f, -0.09923650f, 0.05702801f, -0.08205391f, 
    -0.48922637f, -0.61100322f, -0.46017209f, -0.21910585f, 0.35163638f, 0.52530366f, 0.05551479f, 0.16962887f, 
    0.10143881f, -0.37625769f, -0.11841658f, -0.07992147f, -0.05753802f, 0.03276214f, -0.25712439f, -0.02626067f, 
    0.08522874f, 0.13614534f, -0.24271689f, 0.01301607f, -0.10395607f, -0.23433405f, 0.07065612f, 0.18139824f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.01240731f, -0.08795005f, 0.29946712f, 0.00755005f, 0.10634038f, 0.12217207f, 0.00256857f, -0.12696673f, 
    -0.07104331f, 0.00562174f, 0.10996877f, 0.07459763f, 0.13102791f, 0.08712947f, -0.08976599f, -0.13983253f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04688832f, -0.01058134f, 0.05127512f, 0.01281731f, -0.02941455f, -0.01205157f, -0.05709811f, -0.05630691f, 
    0.00408729f, -0.00020057f, 0.06265451f, -0.00462868f, -0.04311966f, -0.00713341f, -0.03749401f, -0.01933116f, 
    -0.00162745f, 0.03401862f, 0.03989550f, 0.05146434f, 0.05994136f, -0.02039026f, 0.03399173f, -0.03991088f, 
    0.00199049f, -0.00487555f, 0.02030594f, -0.07466785f, -0.02283657f, 0.05212505f, -0.05533681f, -0.02918913f, 
    0.03816474f, -0.04113068f, -0.02388203f, -0.03533817f, 0.01801145f, -0.05346675f, -0.05844716f, -0.04378284f, 
    0.00262230f, 0.05695884f, -0.05904343f, -0.04254489f, -0.05964257f, 0.04562993f, -0.07104544f, 0.00815494f, 
    -0.06726272f, -0.03259161f, 0.00110614f, -0.05610552f, 0.03310309f, 0.05265681f, 0.00717704f, -0.07503604f, 
    0.02576904f, -0.04509679f, -0.06128674f, 0.01269261f, 0.03583033f, -0.02646941f, -0.03772914f, 0.05146354f, 
    0.04638891f, 0.02408306f, 0.04149821f, -0.07492062f, -0.05899319f, 0.00124732f, 0.01230521f, 0.02088588f, 
    -0.01342845f, -0.05672595f, 0.05853914f, -0.00122265f, 0.01965266f, -0.04722077f, -0.03226845f, 0.04042463f, 
    0.05421593f, -0.00953747f, 0.01757404f, 0.00062184f, -0.00042213f, -0.02651413f, 0.02358297f, 0.03147340f, 
    0.06406270f, -0.02538951f, -0.07257221f, -0.05897705f, -0.07056963f, -0.00347952f, 0.03940499f, -0.03878527f, 
    -0.06579500f, -0.02245262f, -0.00288520f, 0.01267604f, -0.07375731f, 0.01421524f, -0.01315599f, 0.00809905f, 
    -0.04533419f, -0.05182937f, -0.06254104f, -0.06186285f, 0.00397573f, 0.03653399f, -0.05236854f, 0.03541502f, 
    -0.02024878f, -0.05673823f, 0.03156961f, -0.05265105f, -0.03068796f, 0.01740157f, -0.04728304f, -0.03300272f, 
    -0.05921627f, 0.03224853f, -0.03868179f, 0.01346443f, -0.04392959f, 0.00467360f, 0.00015214f, 0.00924467f, 
    -0.05865212f, -0.01588596f, 0.05533684f, 0.00862493f, -0.06039978f, 0.03286611f, 0.05614967f, -0.01345844f, 
    0.03038946f, -0.04436162f, 0.01560882f, 0.03817543f, -0.02014653f, -0.03543395f, -0.02839789f, 0.04814839f, 
    -0.01347828f, -0.01965807f, -0.06518070f, -0.01114744f, 0.00987512f, -0.02899779f, 0.02127544f, -0.05792291f, 
    0.05939186f, 0.06250520f, 0.04041736f, -0.01021107f, -0.01983806f, -0.01723704f, -0.04051775f, -0.04015232f, 
    -0.00796962f, 0.02452302f, -0.03173225f, 0.06273965f, -0.00544683f, -0.01167188f, 0.04267759f, 0.05734663f, 
    0.04501573f, -0.06920441f, -0.07433607f, -0.05251474f, 0.04696672f, 0.03368475f, 0.04222368f, -0.01633313f, 
    -0.05856137f, 0.02021318f, 0.06398570f, 0.06157728f, -0.07152184f, -0.01192208f, -0.05283513f, 0.06375157f, 
    -0.06498446f, 0.04962535f, -0.03373542f, -0.06858437f, 0.01979804f, -0.06796800f, -0.02938796f, -0.07014695f, 
    0.03145437f, -0.07835064f, -0.16143033f, -0.17445505f, 0.03100683f, 0.03831914f, -0.03491411f, 0.11166327f, 
    0.12897071f, -0.00957691f, 0.06435511f, 0.05285403f, 0.41366032f, 0.02328864f, -0.14650275f, -0.17513485f, 
    0.14633705f, -0.00574715f, 0.00083151f, 0.03933155f, -0.02293234f, -0.05558358f, 0.00351707f, -0.00429677f, 
    -0.16560000f, -0.13402069f, 0.04554757f, -0.19762234f, -0.05301581f, 0.02455641f, 0.05055808f, 0.10587852f, 
    -0.02263518f, 0.10083918f, -0.08926901f, 0.09863424f, -0.10294817f, 0.03200756f, -0.12606534f, 0.07686413f, 
    0.10142217f, -0.02044611f, 0.01068551f, -0.01625364f, -0.02267556f, -0.11896712f, -0.16478658f, 0.04876949f, 
    0.08527919f, 0.07679775f, 0.01574618f, -0.12517656f, 0.08623865f, 0.10853650f, 0.02302295f, -0.01269591f, 
    0.00578320f, -0.02375041f, 0.04858342f, -0.13422897f, 0.08205570f, 0.04207415f, -0.03619152f, 0.06746769f, 
    0.01097468f, 0.10039137f, 0.10025739f, -0.05851171f, -0.04255589f, -0.07649219f, 0.05862014f, 0.00790299f, 
    0.07335331f, -0.09880581f, -0.06148282f, -0.02489877f, 0.00674814f, 0.04689185f, 0.07570551f, -0.17477706f, 
    0.06597185f, 0.15043108f, 0.02054880f, 0.16969012f, 0.20265625f, -0.29105455f, -0.04627037f, -0.14347936f, 
    0.05506383f, 0.02350337f, 0.02376264f, 0.03794984f, -0.00445893f, 0.07517099f, 0.00863880f, -0.00584728f, 
    0.08786746f, 0.02845410f, 0.04315760f, 0.07523347f, 0.12000187f, -0.04894183f, -0.10300767f, -0.08535807f, 
    0.00145923f, 0.10386515f, 0.03986261f, 0.03634198f, 0.12332688f, 0.05644985f, 0.27746123f, -0.21057685f, 
    0.04680840f, 0.13661465f, 0.11057650f, 0.10873329f, 0.05966333f, 0.07882102f, -0.11055113f, 0.04314689f, 
    0.09594741f, 0.02074282f, 0.08549976f, 0.01708011f, 0.14588322f, 0.11406139f, 0.08711987f, 0.11137569f, 
    0.08543330f, 0.02192089f, 0.21010934f, 0.04637872f, -0.05567666f, 0.05066665f, -0.13322327f, -0.05255169f, 
    -0.08077613f, -0.01971492f, 0.02725230f, -0.10934122f, -0.05564835f, -0.06662268f, -0.10371313f, -0.00905861f, 
    0.53506672f, -0.10414110f, 0.01216700f, 0.06704385f, -0.02184794f, 0.01104383f, 0.04285706f, 0.02141532f, 
    0.09718944f, 0.02384757f, 0.00339448f, -0.04523025f, -0.06148518f, 0.19465776f, -0.18893565f, 0.07143852f, 
    0.09880412f, -0.01111451f, 0.06443235f, -0.06206874f, 0.00918366f, 0.00089979f, 0.06690973f, 0.27179471f, 
    0.36616910f, -0.00901341f, -0.02144013f, 0.02597305f, 0.07360037f, 0.05068686f, -0.01341910f, 0.09584197f, 
    -0.02581326f, 0.06136164f, -0.02616615f, 0.02317672f, -0.19679314f, -0.00441457f, 0.05520180f, 0.03224619f, 
    0.06426234f, -0.08688203f, -0.03950407f, 0.13257337f, 0.00804946f, -0.02340640f, 0.00002333f, 0.12065081f, 
    0.02999555f, 0.04214043f, -0.05268104f, -0.07311099f, -0.04755984f, -0.06137343f, 0.04217759f, 0.03833474f, 
    -0.05496103f, 0.04840034f, 0.01790708f, 0.06284014f, 0.05982887f, 0.04538633f, 0.06083994f, 0.02837992f, 
    -0.06840129f, -0.07629915f, 0.02422468f, -0.00823563f, -0.02498400f, -0.07347892f, -0.01628767f, -0.06970971f, 
    0.02374405f, 0.01035652f, -0.06391905f, -0.02342728f, -0.03679912f, 0.02182430f, -0.04818117f, 0.02510362f, 
    -0.07533319f, 0.01625475f, 0.01699354f, -0.02568394f, -0.00180304f, -0.02273214f, -0.05848466f, 0.04032057f, 
    0.03378737f, -0.01785864f, -0.07229602f, 0.03341042f, -0.03235917f, -0.01932315f, 0.00285302f, 0.05530052f, 
    -0.02284744f, -0.04912034f, 0.03314802f, -0.01426233f, 0.04159170f, 0.02765704f, 0.01568692f, -0.01728223f, 
    -0.02323033f, -0.01182019f, 0.01475089f, 0.03035177f, 0.05245526f, -0.03667853f, -0.04372503f, 0.01590212f, 
    0.05261378f, 0.04268476f, 0.02014272f, 0.03651858f, 0.02294579f, 0.00617250f, -0.01626388f, -0.00099780f, 
    -0.05217193f, 0.00682259f, -0.07401218f, 0.04685111f, -0.02352961f, -0.07558642f, 0.01740257f, -0.07010703f, 
    -0.00085175f, -0.04125684f, 0.04424826f, -0.05939541f, -0.00308843f, -0.02606684f, -0.05620512f, 0.02156528f, 
    -0.03919150f, -0.07221784f, 0.03770474f, 0.01573822f, 0.04772829f, 0.03813344f, -0.07138905f, -0.00887083f, 
    0.02888074f, -0.04682275f, -0.07097816f, 0.01173153f, -0.02745891f, 0.02806273f, -0.02516287f, -0.03697131f, 
    -0.05368445f, -0.02979250f, 0.03075702f, -0.06046453f, -0.04670962f, 0.01474233f, -0.08094025f, -0.07462358f, 
    -0.03057302f, 0.04746720f, -0.05497176f, -0.02407928f, -0.05125856f, -0.04733515f, 0.01499975f, 0.04833614f, 
    -0.02043760f, 0.04246399f, 0.00293738f, -0.05185361f, -0.03853638f, -0.05407227f, -0.02342404f, -0.02475890f, 
    -0.06433096f, -0.07567475f, -0.00943849f, 0.01563139f, -0.02413149f, 0.01860147f, -0.02316662f, -0.02474993f, 
    -0.02626734f, 0.01047646f, 0.04007797f, -0.05423317f, -0.04199681f, -0.03252823f, 0.04655839f, 0.05735373f, 
    0.05957222f, -0.06335748f, -0.03066548f, -0.08586346f, -0.00674344f, -0.00510063f, -0.07819208f, -0.03129695f, 
    -0.03945098f, -0.00739963f, -0.06508262f, 0.01069440f, 0.01285124f, 0.04330171f, -0.00701828f, 0.01825154f, 
    -0.01064595f, 0.05716443f, 0.06663042f, -0.04931884f, -0.04353281f, -0.03811519f, -0.03101769f, -0.03784354f, 
    -0.00015212f, 0.02967666f, 0.03078059f, -0.02713655f, 0.05516414f, -0.07423779f, -0.05801253f, 0.05672449f, 
    0.03583964f, 0.00600133f, 0.05405514f, 0.04355185f, -0.06681155f, -0.05556710f, -0.04719788f, -0.07120462f, 
    -0.02662785f, -0.07163633f, 0.02355342f, 0.04165901f, -0.00433879f, -0.06105421f, 0.00058224f, -0.05882276f, 
    -0.40430886f, 0.17853530f, 0.07037742f, -0.02363977f, 0.02946269f, 0.12419891f, 0.08752359f, -0.02937290f, 
    0.06260811f, -0.00740085f, 0.00329063f, -0.10179980f, 0.14474204f, 0.00266447f, 0.03302820f, 0.34493542f, 
    -0.21052985f, 0.00236430f, -0.07148921f, -0.11330022f, 0.06562845f, 0.11113810f, 0.00540984f, -0.00106541f, 
    0.01908333f, -0.33126426f, 0.04757879f, 0.05794149f, -0.03483837f, 0.02489079f, 0.00325719f, 0.05278227f, 
    0.03361309f, -0.08159304f, -0.07389700f, 0.01117606f, 0.25163037f, -0.03656543f, 0.06244136f, 0.29935375f, 
    -0.15710331f, -0.15632373f, -0.03519989f, -0.05582364f, -0.00756771f, 0.01863364f, 0.13175493f, 0.05488413f, 
    -0.06190990f, 0.04251270f, 0.30126438f, 0.00136624f, -0.09022132f, 0.09794505f, -0.08910138f, -0.16009305f, 
    -0.02043880f, 0.05446073f, -0.05819675f, 0.18016958f, 0.03443563f, 0.09712635f, -0.11378200f, 0.09458893f, 
    -0.08495255f, -0.06463809f, -0.00623215f, 0.24746020f, 0.18011442f, -0.00066177f, 0.05260301f, 0.04622472f, 
    -0.19693512f, 0.12289728f, -0.49093914f, 0.36853546f, 0.15134156f, -0.01245055f, 0.06395350f, -0.17636667f, 
    -0.01624243f, -0.08090445f, -0.05048665f, -0.00597402f, 0.15511853f, 0.12335379f, -0.00871118f, -0.12531343f, 
    0.14250092f, 0.09677586f, 0.03368603f, 0.03077286f, 0.16802469f, 0.02246878f, -0.03423064f, 0.02325103f, 
    0.17687204f, -0.27459380f, 0.00201130f, 0.28513312f, -0.17968467f, -0.05479299f, 0.00976740f, -0.10231517f, 
    -0.01045342f, 0.17892756f, -0.01441575f, 0.08115070f, -0.11802210f, -0.06023011f, 0.06632959f, -0.32277861f, 
    -0.07008526f, 0.09679274f, -0.06455415f, 0.12187249f, -0.00357782f, -0.03874436f, 0.02552636f, 0.06160150f, 
    0.27431872f, -0.08002713f, 0.11432529f, -0.11842305f, -0.02486859f, -0.07943658f, 0.00150291f, -0.10527567f, 
    -0.05781327f, -0.03860189f, -0.08514055f, 0.08379485f, -0.29367876f, -0.09094988f, -0.12122530f, 0.05787152f, 
    0.14157137f, 0.07360583f, -0.00746485f, 0.02599965f, 0.07230546f, -0.03210763f, 0.06474964f, -0.02378862f, 
    -0.24883769f, 0.15041499f, -0.23020832f, 0.00701756f, 0.17231387f, 0.01077206f, 0.01340517f, 0.15715396f, 
    0.13375993f, 0.09038865f, 0.08021416f, 0.06651298f, 0.16074069f, -0.12580280f, 0.02212206f, 0.18543172f, 
    0.02195363f, 0.01304838f, -0.03388548f, -0.09136267f, 0.04670484f, 0.06553265f, -0.04798459f, -0.08114102f, 
    -0.24861827f, 0.05446797f, -0.18620750f, -0.55661261f, -0.00715666f, -0.02361407f, 0.09275125f, 0.17900522f, 
    -0.04800132f, 0.05921655f, -0.02572333f, -0.05600433f, 0.12933885f, -0.11644515f, -0.19924197f, -0.49094003f, 
    0.15268980f, 0.08743188f, 0.01470558f, 0.12689529f, 0.01694579f, 0.01815227f, 0.15578660f, 0.00213764f, 
    0.01448200f, 0.16452600f, 0.03759164f, -0.10087424f, 0.06865189f, -0.13452616f, 0.04940873f, 0.06072352f, 
    0.06920813f, 0.14415169f, 0.18176381f, 0.02441035f, -0.44475877f, 0.28292653f, 0.10996388f, -0.02018649f, 
    0.10154624f, 0.07228664f, -0.01871224f, -0.14430989f, 0.02756236f, -0.05835536f, 0.00138969f, 0.09457560f, 
    0.02754785f, 0.03274393f, 0.00941829f, 0.19828400f, 0.11872609f, 0.12413923f, 0.12399635f, 0.05808731f, 
    0.21761680f, 0.10966091f, 0.20809591f, 0.06416813f, 0.11978704f, -0.18384002f, 0.06282012f, 0.19451852f, 
    -0.00349284f, -0.03586730f, 0.08717681f, -0.12979570f, -0.04272116f, 0.16654575f, -0.00039353f, 0.06255571f, 
    -0.21783382f, 0.09609108f, 0.16661389f, 0.01757725f, 0.00061060f, 0.01436923f, -0.13300559f, 0.00961739f, 
    -0.02254692f, 0.12058821f, -0.00661871f, 0.19102900f, -0.18005444f, -0.09914193f, 0.08981288f, -0.06842910f, 
    -0.00850615f, -0.00444865f, 0.10333727f, -0.16713068f, 0.02350817f, 0.06513065f, 0.03833942f, 0.05805989f, 
    -0.37865528f, 0.13567400f, -0.25793847f, -0.12060801f, 0.05610027f, -0.01345836f, 0.05441839f, 0.01209932f, 
    -0.05061358f, 0.00651910f, -0.01747502f, 0.04964115f, -0.65819728f, 0.20721793f, -0.11034860f, 0.13260616f, 
    0.11516196f, -0.03708575f, -0.04864753f, 0.10779195f, 0.12261913f, 0.03578846f, 0.00112922f, 0.00665113f, 
    0.01231523f, 0.14725691f, -0.09702696f, -0.35696548f, 0.11032625f, 0.05036047f, 0.04175338f, -0.11659400f, 
    -0.02075925f, 0.06417572f, 0.07157481f, 0.12098534f, -0.41148981f, 0.04428453f, 0.16979678f, -0.18876882f, 
    0.02649505f, 0.11234129f, 0.01287940f, 0.01682664f, 0.02470342f, 0.02427882f, 0.04983683f, -0.01195503f, 
    0.31302953f, -0.00830556f, 0.06348045f, -0.04915556f, 0.01809726f, -0.04114214f, -0.00588531f, -0.10869726f, 
    -0.02980139f, 0.09331821f, 0.01403998f, -0.02931558f, -0.23691717f, -0.12863788f, -0.16506094f, -0.16776605f, 
    0.08101857f, 0.01796034f, 0.07077193f, 0.13766903f, 0.00455291f, 0.00388840f, 0.01411987f, 0.06131405f, 
    -0.21422763f, -0.00181993f, -0.23907951f, -0.07582346f, 0.09535771f, 0.02455613f, -0.05909260f, 0.02706956f, 
    -0.03891007f, -0.04276742f, -0.05829242f, -0.00436639f, 0.14070557f, -0.07931522f, 0.14009902f, 0.13623509f, 
    0.06780477f, -0.00376747f, -0.04484026f, 0.08721094f, 0.08232187f, 0.12945442f, 0.05924652f, -0.07626093f, 
    -0.26978657f, 0.21005809f, -0.26270291f, -0.06145429f, 0.09353475f, -0.06252231f, 0.03257250f, 0.08861978f, 
    -0.01791371f, -0.07681745f, 0.05898879f, 0.00624713f, -0.26608211f, -0.13977154f, -0.02219895f, 0.14690505f, 
    0.10941458f, 0.04109145f, 0.08680677f, 0.14323084f, -0.08058778f, -0.01098235f, 0.14352450f, -0.05007976f, 
    0.05719680f, 0.03496693f, 0.04579103f, 0.01219414f, 0.05697557f, -0.07820988f, -0.00272924f, 0.00218138f, 
    -0.07177766f, -0.06375291f, -0.02079916f, -0.05188758f, -0.06693746f, -0.06357659f, 0.05346827f, 0.02736180f, 
    0.04272347f, 0.04912187f, -0.07204613f, 0.04308225f, -0.00306142f, -0.08785723f, 0.05393109f, 0.02756175f, 
    0.03236680f, 0.05669273f, -0.05884099f, 0.00817860f, -0.05402214f, 0.01066821f, -0.00554042f, 0.04701911f, 
    -0.03700252f, -0.05166926f, 0.02753033f, 0.00555706f, -0.07112403f, -0.03750436f, -0.03865699f, -0.00406380f, 
    -0.00575199f, 0.04082052f, 0.02884354f, -0.02584498f, -0.04356618f, 0.04217213f, -0.02967627f, 0.04779867f, 
    -0.02989140f, 0.04088486f, 0.05997665f, 0.00755371f, 0.03022998f, -0.06270742f, -0.05480817f, -0.00726358f, 
    -0.08150595f, -0.02512362f, -0.02427798f, 0.02765791f, 0.01708603f, 0.06839927f, -0.07306488f, 0.02334673f, 
    0.00460062f, -0.05125865f, -0.02970197f, -0.03023452f, -0.00345908f, -0.02425473f, -0.04966845f, -0.00501635f, 
    0.00945788f, 0.03318116f, -0.00850223f, -0.00737299f, -0.01378736f, -0.02053877f, -0.05728470f, -0.00496733f, 
    0.03041783f, -0.06981532f, -0.01647788f, 0.00040258f, -0.01310850f, -0.02305578f, -0.05429478f, -0.06075053f, 
    -0.05089222f, -0.00025398f, -0.02723706f, -0.03045695f, -0.03164089f, 0.00507981f, 0.00237924f, -0.07639653f, 
    -0.06466516f, -0.06694993f, -0.03342960f, -0.04641138f, -0.05725588f, -0.00989669f, -0.00704894f, -0.06299920f, 
    0.06039149f, 0.01063857f, -0.05972764f, 0.06854995f, -0.05821378f, -0.02843080f, 0.06306247f, -0.02081247f, 
    -0.04873108f, 0.02966602f, 0.05774654f, -0.00083949f, 0.03855408f, -0.02283415f, 0.05118873f, 0.05483132f, 
    0.06323303f, -0.07048228f, 0.02448496f, 0.06171886f, 0.00596544f, -0.05737594f, 0.04586080f, -0.05763713f, 
    0.02676528f, -0.04468957f, -0.00168183f, 0.04598609f, -0.04512375f, 0.04004836f, 0.00019325f, -0.07156949f, 
    -0.06133202f, -0.05971671f, 0.00420904f, -0.03873658f, 0.01391519f, -0.00421958f, 0.04045407f, -0.05446431f, 
    -0.02006407f, -0.04582421f, 0.00325423f, 0.04969953f, 0.04750959f, 0.01729827f, -0.07498823f, -0.02259712f, 
    -0.02787258f, -0.03369723f, -0.06907768f, 0.04311632f, -0.05050428f, 0.01481796f, -0.02887247f, 0.03875364f, 
    -0.07298872f, -0.00356523f, -0.03527878f, -0.04261955f, 0.03986749f, -0.05945126f, 0.04559861f, 0.02681144f, 
    -0.04214435f, -0.00965511f, 0.05249447f, 0.02948220f, 0.05717969f, -0.01236271f, 0.01861851f, 0.01088164f, 
    0.01395411f, -0.01207733f, -0.06764906f, 0.04144496f, 0.00711477f, -0.00605686f, -0.07499325f, 0.02952615f, 
    0.01030949f, 0.06149299f, -0.01951187f, 0.03759279f, -0.04970946f, 0.01936274f, -0.07854332f, -0.01489106f, 
    -0.02563020f, 0.12841173f, 0.20262378f, -0.00566403f, -0.08438539f, 0.00075644f, -0.16569249f, -0.05498056f, 
    0.08783745f, -0.01703111f, -0.14239708f, 0.07286888f, 0.32323989f, -0.03792079f, 0.07869487f, 0.26323938f, 
    -0.12635636f, -0.08954470f, -0.14504993f, -0.13667247f, -0.06463957f, -0.13700511f, -0.08416115f, -0.03150520f, 
    -0.00356813f, -0.01364154f, 0.12812157f, 0.14246260f, 0.03461223f, -0.13354459f, -0.00077853f, 0.01856527f, 
    0.06393170f, 0.08467747f, -0.01944111f, 0.01741678f, 0.24167842f, 0.13466206f, 0.21120371f, 0.11154608f, 
    -0.20860194f, -0.21883412f, -0.01173278f, -0.05244106f, 0.04747861f, -0.18752667f, -0.01375051f, -0.08693621f, 
    -0.03349710f, 0.06825414f, 0.16062440f, -0.01455698f, -0.06005091f, 0.04355701f, -0.15025590f, -0.08839425f, 
    0.00506867f, -0.12339810f, -0.09257992f, -0.11613275f, -0.04671240f, 0.04352654f, 0.01970276f, -0.02100115f, 
    -0.02761426f, -0.04569725f, -0.27204114f, 0.02908215f, -0.13939194f, -0.14358740f, -0.14098822f, 0.03945872f, 
    0.06471486f, -0.04345072f, -0.08104312f, 0.17387663f, 0.18199706f, -0.13140282f, 0.08833633f, -0.11635303f, 
    -0.12625307f, 0.01175975f, -0.09377477f, 0.04689788f, 0.30789334f, 0.04022878f, 0.10789189f, -0.54265934f, 
    0.09230383f, 0.04748655f, 0.04133686f, 0.05805953f, -0.05411596f, -0.11373864f, 0.01576306f, 0.21152192f, 
    0.13202538f, 0.09956168f, 0.00302618f, -0.04439048f, 0.10124829f, 0.03317234f, 0.03157416f, -0.00999398f, 
    0.10630751f, -0.01273832f, -0.00258044f, -0.06144074f, 0.20263986f, 0.06593699f, -0.02022659f, 0.09648179f, 
    -0.18282631f, 0.05332414f, 0.07090900f, -0.13700394f, -0.04100985f, -0.08000094f, 0.03759792f, 0.06577185f, 
    -0.09989564f, -0.05078122f, 0.19641720f, -0.21844061f, -0.21059172f, 0.04512473f, 0.11204410f, 0.00078743f, 
    -0.08548024f, 0.01009567f, 0.18209760f, -0.01778883f, -0.07358038f, -0.00585382f, 0.12573619f, -0.03264378f, 
    0.06886063f, 0.04722934f, -0.08913565f, 0.01292989f, 0.10375891f, -0.04182743f, 0.06910560f, 0.12864493f, 
    -0.32675415f, 0.10571053f, 0.10145663f, -0.10275668f, 0.08914085f, -0.05777661f, 0.02742175f, 0.06725593f, 
    0.01639658f, -0.00208341f, -0.22269303f, -0.02104951f, 0.43405822f, 0.05519973f, 0.14337134f, 0.04776155f, 
    -0.04959607f, 0.22784238f, 0.00681600f, -0.12184136f, 0.00486596f, 0.09752482f, 0.13396047f, 0.07366028f, 
    0.08379798f, 0.01402798f, -0.14350675f, -0.24877469f, 0.03558937f, 0.14718707f, 0.04736672f, 0.03317966f, 
    -0.08304460f, 0.12153473f, -0.02465378f, 0.07716914f, 0.09662832f, 0.02084332f, -0.20587313f, -0.48563835f, 
    0.00987953f, 0.00295006f, 0.12006635f, 0.10991928f, 0.10601561f, 0.07704096f, -0.00710710f, 0.26367268f, 
    -0.02056440f, -0.03120167f, -0.14868835f, 0.24781582f, 0.04343644f, -0.09016818f, -0.00436597f, -0.21150564f, 
    0.09774446f, 0.03316481f, -0.03780380f, -0.03117855f, -0.15845451f, -0.18049303f, -0.18649471f, -0.12133463f, 
    0.12722726f, -0.18196067f, -0.07925204f, -0.07315014f, 0.11908498f, 0.13818882f, -0.09364306f, 0.04006681f, 
    0.30201393f, 0.09495060f, -0.03460544f, 0.07726121f, 0.04078898f, 0.08202544f, -0.00571540f, -0.10100845f, 
    -0.00448266f, -0.07289379f, 0.06206221f, -0.15772274f, -0.10163622f, -0.00408872f, -0.12623104f, -0.10316908f, 
    -0.06146163f, -0.09078448f, -0.13832977f, -0.03939471f, 0.05650943f, 0.10877705f, -0.04168556f, -0.03051649f, 
    0.12939779f, -0.04123070f, -0.11110710f, 0.06078331f, -0.07002283f, -0.15297732f, 0.08334447f, 0.23770067f, 
    -0.04918206f, 0.03100510f, 0.02813054f, 0.10623036f, 0.35250601f, -0.02603937f, -0.03140558f, -0.15198928f, 
    0.01143048f, 0.00445418f, 0.01018652f, 0.01191842f, 0.17898451f, 0.05067356f, 0.05918711f, -0.01701994f, 
    0.06558961f, 0.04538487f, 0.12547249f, 0.10019764f, -0.01479238f, -0.08044349f, -0.10014710f, 0.13284825f, 
    -0.01213253f, -0.01544541f, 0.06190617f, -0.01574421f, 0.01718040f, 0.04489841f, 0.20894971f, 0.16752912f, 
    0.03395827f, 0.19708985f, 0.04107460f, -0.09725412f, -0.05811450f, 0.03591747f, -0.07985622f, 0.00748011f, 
    -0.28787491f, -0.10774271f, -0.10541663f, 0.13212438f, 0.09237278f, -0.03772240f, 0.00949554f, -0.00955650f, 
    -0.04588959f, -0.00229970f, -0.09526096f, -0.02080691f, 0.03929992f, 0.12703994f, -0.35811877f, 0.13778327f, 
    0.20528957f, -0.12712295f, -0.16026080f, -0.19706464f, 0.17800146f, 0.00645308f, 0.04035784f, 0.09730723f, 
    -0.05110206f, 0.00623046f, -0.19115850f, -0.01249818f, 0.05436118f, 0.10966872f, -0.04698458f, -0.02802625f, 
    -0.10088328f, 0.02121191f, -0.08947681f, -0.03146986f, 0.25836608f, 0.08442938f, -0.04390799f, 0.12608774f, 
    -0.00110055f, 0.08557666f, 0.08587856f, -0.03157991f, 0.02241454f, 0.02892413f, -0.00432012f, 0.12889500f, 
    -0.10228360f, 0.19025838f, -0.04315913f, 0.11880203f, -0.03389253f, -0.02929021f, 0.16075197f, 0.09728795f, 
    0.07088250f, 0.01198330f, 0.02466706f, 0.07089318f, -0.10939825f, 0.00455464f, -0.02178384f, 0.01730304f, 
    -0.00581999f, -0.08065820f, 0.07400189f, -0.18042979f, 0.07387948f, -0.12882495f, -0.20726295f, -0.16319074f, 
    -0.35776883f, 0.09943546f, -0.01230785f, -0.06449849f, -0.02577286f, -0.04004737f, 0.16467023f, 0.04630075f, 
    0.02470185f, -0.02545381f, 0.02439117f, -0.02172688f, 0.22472481f, 0.10289130f, 0.00687830f, 0.14166568f, 
    -0.10310927f, 0.06176292f, 0.06841728f, -0.06765741f, 0.14628169f, 0.01592469f, 0.12357138f, -0.07010245f, 
    0.01134309f, -0.01923681f, 0.02235259f, 0.06603236f, 0.00288976f, -0.03221606f, 0.00637129f, -0.00175629f, 
    0.05151619f, -0.06796221f, 0.01600024f, -0.04762363f, 0.05339073f, 0.01444483f, 0.00314588f, -0.01132709f, 
    0.05043497f, 0.03905103f, 0.05540989f, -0.06714336f, 0.06679614f, -0.01360530f, -0.05944610f, -0.01295902f, 
    0.04416570f, 0.01655880f, -0.03680758f, 0.02084391f, -0.06896707f, 0.05184403f, -0.06064009f, 0.03815838f, 
    -0.05475075f, 0.05758455f, -0.05283654f, 0.01746988f, -0.06382664f, 0.02920365f, 0.00094916f, -0.00451431f, 
    0.02762156f, -0.02128679f, 0.02196955f, -0.06469445f, 0.00595159f, -0.06261574f, -0.06609651f, 0.06466164f, 
    -0.03920384f, 0.01160329f, -0.03871713f, 0.06295307f, -0.02801904f, -0.03635155f, 0.04499946f, -0.04536439f, 
    -0.06868601f, -0.02987458f, 0.02087913f, -0.03387643f, 0.04329870f, -0.07080963f, -0.01035091f, 0.01797445f, 
    0.02360501f, 0.02823875f, 0.02476618f, -0.04926207f, 0.03945616f, -0.04894540f, 0.00200945f, 0.04516869f, 
    0.01154478f, -0.00647018f, 0.00250616f, 0.04764112f, -0.00291857f, 0.00437432f, -0.04722849f, -0.01636681f, 
    -0.05146364f, -0.05540607f, -0.02573891f, -0.05520159f, -0.04044331f, -0.07242078f, -0.06573899f, -0.03153179f, 
    0.04930976f, -0.00217201f, 0.04953948f, -0.03204413f, -0.03013576f, -0.04521644f, -0.04790779f, -0.06952585f, 
    0.04557473f, 0.02534372f, -0.04969002f, -0.03725192f, 0.02899085f, -0.06157186f, -0.07291549f, 0.06362548f, 
    -0.04897323f, -0.06301661f, -0.03183724f, -0.02850293f, -0.01787220f, -0.07076521f, 0.04278228f, 0.02888016f, 
    -0.01248437f, -0.04594098f, -0.00624529f, -0.05510473f, -0.00138039f, -0.05579085f, -0.02535406f, 0.05538070f, 
    0.05404871f, -0.04993551f, -0.04364586f, 0.04287913f, 0.01490776f, -0.04045862f, -0.07695615f, 0.05862890f, 
    -0.00804006f, -0.02139974f, -0.06833304f, 0.01128202f, 0.01302558f, -0.07328849f, 0.05663422f, -0.02529311f, 
    -0.01193095f, -0.04250350f, 0.01205960f, 0.01111518f, 0.05419154f, -0.03384291f, 0.04377309f, 0.00931196f, 
    -0.01564341f, -0.07741024f, -0.06530329f, 0.04762978f, -0.05867058f, -0.02759627f, 0.05246522f, 0.02136768f, 
    -0.05929998f, -0.04218506f, -0.04668254f, 0.03289100f, 0.03549335f, -0.07180895f, -0.01535436f, -0.06253687f, 
    -0.03248304f, -0.05121784f, 0.02787803f, 0.06237848f, -0.00731183f, 0.03984243f, 0.02991439f, -0.06803315f, 
    -0.01848841f, -0.03884970f, -0.03543854f, -0.00390812f, -0.04934308f, 0.06483763f, -0.01632003f, 0.04527949f, 
    0.06303437f, -0.05473551f, 0.00851612f, -0.01761618f, 0.02396086f, -0.06152209f, 0.03347306f, -0.07183129f, 
    -0.03627824f, 0.00220624f, -0.06863043f, -0.04281239f, -0.06446412f, 0.04592166f, 0.06744334f, -0.00566200f, 
    -0.12403610f, -0.04430351f, 0.04610462f, -0.06526840f, 0.02723780f, -0.02310314f, 0.02828800f, 0.05071753f, 
    0.03563866f, 0.13452199f, -0.03817949f, 0.10209718f, 0.19322041f, -0.07009418f, 0.13398215f, 0.03955656f, 
    -0.04418531f, -0.11188945f, -0.03560692f, -0.11836578f, 0.01837568f, 0.11736292f, 0.14477427f, -0.03234398f, 
    -0.14880410f, 0.20413624f, -0.03553356f, -0.08619680f, -0.05834741f, -0.07266190f, 0.00838727f, -0.05796973f, 
    0.03968339f, -0.01397278f, 0.01099741f, 0.05274726f, 0.16308245f, 0.03675660f, 0.03951513f, 0.02220198f, 
    0.07581244f, 0.00889170f, -0.01338742f, 0.05407300f, 0.06262121f, -0.00223311f, -0.02851186f, -0.06606144f, 
    0.05405068f, -0.04737369f, 0.07881256f, -0.07110596f, 0.04978318f, 0.03885445f, -0.01118380f, 0.04459235f, 
    -0.01945103f, 0.05097977f, -0.06810913f, -0.10045787f, -0.04900993f, 0.17026703f, 0.06510608f, 0.22441220f, 
    -0.05813992f, -0.05568409f, -0.01968233f, 0.11324633f, 0.02977109f, 0.08284678f, -0.12784544f, 0.02015893f, 
    -0.06086455f, -0.18414727f, 0.12464964f, -0.14913720f, -0.03027888f, 0.00796016f, 0.03580905f, 0.01003666f, 
    -0.01596072f, 0.00344993f, -0.01265359f, 0.06291942f, -0.12421569f, -0.39351135f, -0.24137738f, 0.01959617f, 
    -0.13848671f, -0.02127977f, 0.01361807f, -0.06661458f, 0.03687099f, 0.08765277f, 0.02645358f, -0.06179917f, 
    0.43317398f, -0.40819761f, 0.04197154f, 0.08027799f, -0.05600765f, 0.01060152f, -0.01732736f, -0.08504325f, 
    0.10425311f, 0.03788075f, -0.03021791f, 0.07201037f, 0.32576764f, -0.11903291f, -0.18452589f, 0.07027418f, 
    0.11219354f, 0.01730890f, -0.02812283f, 0.00445941f, 0.12073229f, 0.03302556f, 0.05082322f, 0.03589734f, 
    -0.08502099f, 0.03376281f, 0.02495640f, 0.22573529f, 0.01867558f, 0.02743563f, 0.03028170f, 0.05128888f, 
    0.02817433f, 0.03011793f, -0.03490082f, 0.03467416f, -0.20623642f, 0.13695328f, -0.00295570f, 0.05643649f, 
    -0.01888700f, -0.01802373f, 0.02314295f, -0.08768470f, -0.04490497f, -0.00990518f, 0.08871415f, 0.00919004f, 
    -0.02445537f, 0.03853928f, 0.09786369f, 0.07864597f, -0.05684173f, 0.07673966f, 0.03713738f, 0.02315569f, 
    0.04233510f, 0.05908549f, 0.03291528f, 0.05279197f, -0.00567041f, -0.04749348f, -0.08428850f, -0.11242674f, 
    0.19550154f, 0.08274849f, 0.10022373f, 0.08711202f, 0.12354193f, -0.08693718f, 0.07378105f, 0.11258584f, 
    0.07258029f, -0.14552942f, 0.03314483f, 0.08749974f, -0.02823147f, 0.08232057f, 0.12723941f, -0.01720615f, 
    -0.04440527f, 0.01514935f, 0.05489891f, 0.15713796f, 0.07195164f, -0.14756627f, 0.01459138f, -0.09798245f, 
    0.10096038f, 0.01038408f, -0.03130261f, -0.08282346f, 0.04802875f, 0.09869269f, 0.08612891f, -0.00958955f, 
    0.09757881f, -0.12095503f, -0.05203876f, 0.08900323f, -0.03640533f, -0.00029697f, -0.06735972f, 0.05361750f, 
    -0.01819838f, -0.16698003f, 0.03177764f, 0.18122022f, 0.17031772f, 0.21842369f, 0.00881776f, -0.28853011f, 
    0.18591918f, 0.01449837f, 0.01206197f, 0.12473840f, -0.02689043f, -0.21316426f, -0.00984103f, -0.02159816f, 
    -0.02310731f, -0.00396704f, -0.01765767f, -0.02940558f, 0.04275135f, -0.01967315f, 0.10476275f, -0.08629215f, 
    0.06473636f, 0.09630011f, -0.00312738f, 0.06458289f, -0.01177326f, 0.11159560f, 0.02162588f, 0.01311217f, 
    0.13579468f, -0.07974869f, 0.11682113f, -0.12248211f, 0.04745619f, -0.04737770f, -0.10946921f, -0.14261541f, 
    -0.01199421f, 0.06331340f, -0.14707391f, 0.06377867f, 0.00314013f, -0.05917346f, -0.02153805f, 0.03450957f, 
    0.06251799f, -0.03169093f, 0.09598462f, -0.21361743f, 0.11215510f, -0.15840390f, 0.10274240f, -0.01832259f, 
    0.07904740f, 0.02058204f, -0.18997830f, -0.14733568f, -0.06046307f, -0.05431445f, -0.00149879f, -0.00479711f, 
    0.10216978f, 0.12044000f, 0.15133612f, -0.16702352f, -0.05510094f, -0.01178957f, -0.02360849f, 0.12421501f, 
    0.10420363f, 0.02015889f, -0.10877971f, 0.09713344f, -0.19498880f, -0.05691252f, 0.16158883f, 0.01819060f, 
    -0.08283217f, 0.07713816f, 0.03342267f, 0.06184034f, 0.01062006f, 0.03320916f, 0.07795877f, 0.19681974f, 
    -0.15466614f, 0.40662050f, -0.16713339f, -0.08137071f, 0.05551520f, -0.00291054f, 0.10411432f, -0.04219992f, 
    -0.04375770f, -0.08749207f, 0.09522094f, -0.03305086f, 0.02155998f, 0.00237775f, 0.03955323f, 0.16636343f, 
    0.11584552f, 0.09899276f, -0.01585840f, -0.14392391f, 0.14245099f, -0.02040939f, 0.01272531f, -0.00688583f, 
    -0.14428344f, -0.00050537f, -0.04939152f, 0.09137472f, 0.10281097f, 0.15078291f, 0.13537754f, 0.16889332f, 
    0.02418478f, 0.08873159f, 0.18836655f, 0.02210594f, -0.02408889f, -0.08527143f, 0.09138416f, -0.13535033f, 
    0.07442930f, 0.01682760f, 0.03227140f, 0.00470853f, 0.08775523f, -0.01517279f, -0.16114433f, 0.01710471f, 
    -0.00843543f, 0.03599327f, -0.04029265f, -0.15183777f, 0.07006091f, -0.16176726f, 0.03824532f, -0.03556541f, 
    0.02172441f, 0.09504790f, 0.00872546f, 0.01460014f, 0.01843704f, 0.09104127f, 0.02442011f, -0.02334657f, 
    0.08337904f, -0.01337102f, 0.01999406f, -0.22427931f, -0.12919100f, 0.00582637f, 0.14795204f, 0.11767887f, 
    -0.01288070f, 0.12671553f, -0.16173200f, 0.13774890f, 0.20974623f, 0.00485679f, -0.06877974f, 0.05437312f, 
    0.08067763f, 0.01926815f, 0.11187379f, -0.01331163f, -0.35917258f, -0.04012119f, 0.14123841f, 0.11775683f, 
    -0.06485245f, -0.04838790f, 0.14156069f, 0.08538046f, 0.03055816f, 0.12546450f, -0.09741326f, 0.07675195f, 
    -0.12243189f, -0.06594294f, -0.19587088f, -0.15548836f, 0.10633954f, 0.19213104f, 0.10875645f, -0.02386790f, 
    0.04482963f, 0.02424010f, -0.00585458f, -0.09351497f, -0.00865448f, -0.17696311f, 0.00726873f, 0.09256712f, 
    -0.05064867f, -0.01701784f, -0.01854749f, 0.03170012f, 0.01519636f, 0.09207087f, 0.02536918f, 0.03470881f, 
    0.05127938f, -0.14144287f, 0.07194204f, -0.11374477f, 0.09042638f, -0.00008864f, 0.08615560f, 0.13595971f, 
    -0.04245369f, -0.04731732f, -0.03844230f, 0.11634407f, -0.03388824f, -0.11173432f, -0.12918602f, -0.00842016f, 
    0.09294368f, 0.10389102f, -0.09132394f, 0.02212853f, 0.03057344f, 0.06016998f, 0.04434872f, 0.01978926f, 
    0.30237859f, 0.12115833f, 0.06096428f, -0.02480747f, 0.10541798f, 0.06036136f, 0.13951556f, 0.01653576f, 
    -0.05126311f, 0.06004874f, 0.07076042f, 0.06648863f, 0.08616044f, 0.21195553f, -0.08608773f, 0.11495385f, 
    -0.03417584f, 0.00841406f, 0.06893905f, 0.03266019f, 0.07005333f, 0.00029660f, -0.05359707f, 0.07595838f, 
    -0.02060941f, -0.11837983f, -0.19338249f, 0.08035350f, 0.05939934f, 0.04428401f, 0.07775377f, -0.04873371f, 
    0.05949334f, 0.10907765f, 0.07401317f, 0.03568416f, 0.32841516f, -0.17775479f, -0.09895325f, -0.13819413f, 
    0.01129965f, -0.15951586f, 0.06719514f, -0.01486823f, 0.10783973f, -0.02888821f, -0.03367010f, -0.10300658f, 
    0.12075816f, -0.24673067f, 0.13650584f, 0.04407592f, 0.07611414f, 0.00823293f, 0.00920879f, -0.00421182f, 
    0.07945406f, 0.08733526f, 0.07499807f, -0.02504190f, 0.04124125f, -0.06805410f, 0.03585154f, -0.22118892f, 
    -0.04172513f, 0.10603238f, 0.04546279f, 0.10277785f, 0.03390608f, 0.05039257f, -0.00793336f, 0.02194179f, 
    0.18626942f, -0.11061437f, 0.05395970f, -0.00393533f, 0.04806595f, -0.04127267f, 0.03363389f, 0.05531442f, 
    0.07353684f, 0.03741989f, -0.00962262f, 0.03781961f, -0.04738316f, 0.00114938f, -0.11494870f, -0.03815368f, 
    -0.03279379f, 0.02760527f, 0.02471230f, -0.02561633f, 0.12210056f, -0.01967197f, 0.07452763f, -0.04143529f, 
    0.19742377f, 0.05615191f, 0.03689568f, 0.22717538f, -0.02122744f, 0.01701339f, 0.07794109f, 0.01230495f, 
    -0.01408934f, -0.14293082f, 0.10991818f, 0.17142329f, -0.17654587f, 0.19936103f, -0.09987216f, -0.01194947f, 
    0.13358672f, 0.07426789f, 0.07000631f, 0.12167038f, 0.16851076f, 0.02633462f, -0.00422121f, 0.02201810f, 
    0.14564210f, 0.07160591f, 0.04300793f, -0.12029212f, -0.08227982f, 0.01676018f, 0.01573769f, 0.10090295f, 
    0.08877768f, 0.05741091f, 0.05700217f, -0.07927101f, 0.07103085f, 0.02342368f, -0.11856180f, -0.00536249f, 
    0.03425822f, 0.05112034f, -0.03111135f, 0.02109815f, -0.03831138f, -0.08320673f, 0.11429344f, 0.14252865f, 
    -0.00630625f, -0.05571095f, -0.02756586f, -0.01204948f, 0.03105696f, -0.03112040f, 0.01158833f, -0.06732433f, 
    0.00049594f, -0.02753022f, -0.06576582f, -0.01334593f, 0.06202089f, -0.00317313f, -0.03542647f, 0.03504353f, 
    0.04926642f, 0.00832504f, 0.05730338f, 0.00363328f, -0.07295796f, -0.01722036f, 0.03422801f, 0.02252019f, 
    -0.07634655f, -0.01527457f, 0.04570478f, -0.02323435f, -0.03470112f, -0.00291934f, 0.04113462f, 0.05306247f, 
    0.01774437f, -0.00091156f, -0.02427799f, 0.02256291f, 0.04941469f, 0.03323060f, -0.06329921f, 0.01302404f, 
    -0.06001712f, 0.03818379f, -0.03254680f, 0.04559623f, -0.04810918f, -0.03346991f, 0.04840966f, -0.02562250f, 
    -0.04628708f, -0.05137950f, -0.00816267f, 0.03015413f, -0.05481961f, 0.00678312f, 0.01332972f, -0.06959981f, 
    0.05424705f, 0.03933470f, -0.06028344f, -0.02350038f, 0.05464015f, -0.04686379f, -0.01367813f, -0.03367390f, 
    -0.02670385f, -0.00612206f, 0.06000812f, -0.04301404f, -0.06194418f, 0.05986293f, 0.03122150f, -0.04245050f, 
    -0.04675983f, -0.07263511f, -0.08218870f, 0.04245370f, -0.04714672f, 0.02630539f, -0.04329127f, 0.02356740f, 
    -0.03657001f, 0.05256309f, 0.05856080f, -0.07559036f, 0.03390883f, -0.01201238f, -0.01795403f, -0.04293290f, 
    -0.06215880f, 0.03624473f, -0.00668235f, -0.04023498f, 0.05940926f, -0.07248017f, 0.00199277f, -0.03921319f, 
    -0.04977660f, -0.07603388f, 0.04526285f, 0.01699205f, -0.02600699f, -0.06361967f, 0.00846466f, 0.05235733f, 
    -0.06783418f, 0.06819484f, 0.00872127f, 0.06133201f, -0.02771359f, -0.07488559f, -0.06876918f, 0.06774990f, 
    -0.04122771f, 0.03808434f, -0.07338807f, -0.06340743f, 0.02670458f, 0.05324252f, -0.01747143f, 0.00643097f, 
    -0.03265127f, 0.01116260f, -0.02438461f, -0.05078378f, -0.03641987f, 0.06024851f, -0.04870896f, -0.00246878f, 
    -0.06531933f, 0.02087714f, 0.00027678f, -0.06847015f, -0.02245301f, -0.02230849f, 0.00261647f, -0.07283406f, 
    0.00175034f, 0.06951957f, -0.05891861f, 0.04761727f, -0.07257220f, -0.07557423f, 0.00795462f, -0.04297225f, 
    -0.00723058f, -0.01334653f, 0.02231431f, 0.02362524f, 0.03947769f, -0.05289278f, 0.00286273f, 0.05727893f, 
    -0.05965711f, -0.02173301f, 0.04622369f, -0.00621548f, 0.06686182f, 0.05082899f, -0.05210936f, -0.04501762f, 
    -0.00904192f, -0.03823659f, -0.07860351f, 0.02931093f, 0.03161933f, -0.04903409f, -0.01774651f, -0.04768974f, 
    0.06562460f, 0.05831058f, -0.06689809f, -0.03544518f, -0.02577117f, 0.02781250f, -0.06688320f, 0.05703580f, 
    -0.08029249f, -0.02482600f, 0.03415895f, -0.03774002f, -0.02976812f, -0.03259741f, 0.05093992f, 0.00903693f, 
    0.06449949f, -0.01433066f, -0.07257290f, -0.05608592f, -0.05499778f, -0.01023314f, 0.02314499f, 0.01468208f, 
    0.11845839f, -0.00688380f, 0.06289702f, 0.12752017f, 0.04014204f, -0.00463420f, 0.06674894f, 0.03788533f, 
    0.06266113f, 0.14965980f, -0.09390104f, 0.08592736f, -0.49963000f, 0.05393125f, 0.24309844f, 0.05382177f, 
    0.02894242f, 0.02511598f, -0.01863398f, -0.03700505f, 0.04023595f, 0.07247689f, 0.02372795f, 0.00772648f, 
    0.04524096f, 0.15273191f, -0.11038794f, 0.10629032f, 0.07173530f, 0.01617424f, -0.03846617f, -0.08678908f, 
    0.09858553f, 0.01282038f, 0.12592685f, -0.06940365f, 0.13096860f, 0.01628061f, 0.08162708f, -0.07140046f, 
    0.07545394f, 0.02048195f, -0.05145532f, 0.02943659f, -0.03593697f, 0.03878386f, 0.06527085f, 0.16199687f, 
    0.01460491f, -0.02296654f, -0.03926104f, 0.13513133f, 0.09917708f, -0.01684557f, 0.05129419f, 0.04083800f, 
    -0.21038572f, 0.05151472f, -0.09090616f, 0.14963943f, 0.00599735f, 0.20625807f, 0.12917182f, 0.14748886f, 
    -0.07220909f, -0.01524576f, 0.11751013f, 0.09086104f, 0.00379851f, -0.01231248f, -0.07317838f, 0.01120416f, 
    -0.23253568f, -0.00345507f, 0.01757494f, -0.01977170f, 0.02421332f, 0.05255920f, -0.15776619f, 0.12234965f, 
    -0.07381482f, -0.01885157f, 0.08501531f, -0.10261127f, -0.21342801f, -0.03361335f, -0.31677234f, 0.20443460f, 
    -0.05867166f, -0.02523017f, -0.05618472f, -0.06546469f, -0.01299794f, 0.00681808f, -0.00945739f, -0.18812476f, 
    0.10302327f, -0.29345301f, 0.17663808f, -0.23425773f, 0.05288772f, -0.06892915f, -0.05770589f, -0.04780996f, 
    0.11350903f, -0.06353378f, -0.06617689f, 0.02657367f, 0.07420278f, -0.23843907f, -0.15006663f, 0.19805616f, 
    -0.00081245f, -0.11383735f, 0.10813209f, 0.17174049f, -0.03382817f, -0.01748806f, 0.02215463f, -0.06773421f, 
    0.20538345f, -0.01671233f, 0.00004305f, -0.03720630f, 0.08464972f, -0.03545937f, 0.04024744f, -0.12386964f, 
    0.00172075f, -0.05678441f, -0.07140803f, -0.11098820f, -0.09470259f, 0.02932346f, -0.07498810f, 0.09824806f, 
    0.03919048f, -0.00321706f, -0.04209416f, 0.14627473f, -0.04493241f, -0.02450004f, 0.03380461f, 0.09709255f, 
    0.01268553f, 0.03919057f, 0.06202548f, -0.04793801f, 0.07138177f, 0.02535650f, 0.06789090f, 0.04935025f, 
    0.01646462f, -0.09993325f, 0.07221574f, 0.00593876f, -0.09858719f, -0.11257893f, 0.10936695f, -0.07285607f, 
    0.07345514f, 0.07340992f, -0.00806108f, 0.14837955f, 0.12237764f, 0.01009945f, -0.04589967f, 0.03028596f, 
    0.02787174f, -0.07473687f, 0.01564834f, 0.10458006f, -0.03608090f, 0.00228268f, 0.17544152f, -0.06805759f, 
    -0.01073541f, -0.09680306f, -0.00478680f, 0.10124323f, 0.20122294f, -0.01572194f, -0.14216782f, 0.01923925f, 
    0.04356640f, 0.01456795f, -0.02880755f, -0.08234597f, -0.04007391f, 0.02216601f, 0.06976710f, -0.09185796f, 
    -0.02361704f, -0.04106973f, -0.04712483f, 0.03539318f, 0.00066524f, 0.01864457f, -0.04760298f, -0.06662048f, 
    0.01028249f, -0.00068781f, -0.02497738f, 0.01087273f, 0.05260457f, -0.07541867f, 0.00429536f, -0.07176095f, 
    -0.05341693f, 0.05577662f, -0.06434578f, -0.02523793f, 0.04601057f, -0.01711454f, 0.05638139f, 0.00252534f, 
    0.01468470f, 0.02634216f, -0.00154019f, -0.05924658f, 0.01056601f, 0.02939189f, -0.03302495f, 0.00239227f, 
    -0.01984445f, 0.01485745f, -0.06255979f, 0.02273952f, -0.03846778f, 0.00622136f, 0.00412538f, -0.05960456f, 
    0.01350726f, -0.06104507f, -0.06768662f, -0.02311678f, 0.02188624f, 0.03138531f, 0.00495894f, 0.05648314f, 
    0.00474486f, -0.05788150f, 0.05887682f, 0.04195024f, -0.01801172f, -0.06899285f, -0.04606077f, -0.06042673f, 
    -0.00093590f, -0.04457284f, -0.05577331f, -0.03442792f, -0.02066059f, -0.07501785f, 0.02063219f, -0.03917411f, 
    0.06537419f, -0.06926905f, 0.04176823f, -0.01612611f, -0.00223146f, 0.05663141f, -0.04717570f, -0.02152780f, 
    -0.00401445f, 0.05490829f, -0.02254203f, 0.05998413f, -0.05482586f, -0.07383079f, 0.02641687f, -0.03445930f, 
    -0.02270238f, -0.02882374f, 0.02048602f, -0.06329513f, -0.00431814f, -0.03243113f, -0.05475597f, -0.03941073f, 
    -0.06320862f, -0.00773759f, 0.03004112f, 0.04108017f, 0.01995816f, 0.05973469f, 0.03837479f, -0.03049183f, 
    -0.01762671f, 0.04538578f, -0.06592245f, 0.01065497f, -0.05046112f, -0.04983873f, 0.01782642f, 0.00465144f, 
    -0.00751388f, -0.06731912f, -0.03004873f, 0.02945274f, -0.05547688f, -0.07068906f, -0.02529222f, -0.05405330f, 
    0.05306414f, 0.03008010f, 0.00599292f, 0.00861724f, 0.05097763f, -0.00316064f, -0.04108174f, -0.06628966f, 
    -0.01232700f, -0.04384878f, -0.03911507f, 0.05091037f, -0.03070810f, -0.07105583f, -0.02161492f, -0.00350770f, 
    -0.05943362f, 0.00062104f, -0.06371111f, 0.04953918f, -0.06556007f, 0.05719705f, 0.05044910f, -0.06828741f, 
    -0.03105263f, -0.07174586f, 0.04886255f, -0.05146419f, -0.05527505f, -0.04272311f, 0.02443162f, 0.06053232f, 
    0.01927269f, 0.03326086f, 0.03610651f, -0.02267290f, 0.04922251f, 0.00356098f, -0.00150364f, 0.03361941f, 
    -0.06649435f, -0.04489167f, 0.00054229f, 0.04884855f, 0.02084809f, 0.04024887f, -0.05015633f, 0.01664560f, 
    0.00856914f, -0.05380288f, -0.06919707f, 0.05053449f, -0.03684114f, -0.01190299f, -0.04824027f, -0.04805860f, 
    -0.06022242f, 0.06638688f, -0.00647092f, -0.00055915f, 0.03337714f, 0.01167350f, 0.05314142f, -0.04479975f, 
    -0.06990401f, 0.00522418f, 0.03918581f, -0.06096733f, 0.05807617f, -0.00850054f, -0.03189911f, -0.04363192f, 
    -0.02362678f, -0.02114440f, 0.05746902f, 0.00976327f, 0.03348921f, 0.05064942f, -0.01257285f, 0.03139465f, 
    0.19521834f, -0.07731185f, -0.11423870f, -0.11750002f, 0.13985349f, 0.07608855f, -0.09552953f, 0.12402125f, 
    0.02884534f, -0.06696837f, 0.02150384f, -0.03386614f, 0.45301041f, -0.08220363f, 0.05137360f, -0.08098164f, 
    -0.06834478f, 0.10444229f, 0.02358042f, 0.01309391f, -0.05111479f, 0.05417924f, 0.16711019f, -0.00530280f, 
    -0.38053736f, 0.01056901f, -0.10018333f, -0.17104134f, 0.07103362f, 0.08067478f, -0.06475741f, -0.09823892f, 
    -0.10844964f, -0.00602912f, -0.00699965f, -0.09540746f, -0.13623062f, 0.12203069f, 0.15736896f, -0.36952102f, 
    -0.06232101f, -0.07867580f, -0.12463670f, 0.09718040f, -0.03313465f, 0.04717765f, -0.04010455f, -0.06614184f, 
    0.14088860f, 0.14935584f, 0.08872088f, -0.22100505f, 0.03435178f, 0.09049924f, 0.13908631f, -0.02846909f, 
    0.09694544f, -0.03403296f, 0.05165781f, -0.01738933f, -0.18915121f, 0.09875967f, 0.13351998f, 0.02145115f, 
    0.15602928f, -0.01962362f, -0.06484707f, 0.01797166f, -0.11283363f, 0.02029451f, 0.05051443f, 0.11566940f, 
    0.61342055f, -0.09992030f, 0.21192552f, -0.00870979f, 0.02199438f, -0.18305418f, 0.01733720f, -0.10294837f, 
    0.00638001f, 0.11041213f, -0.02772408f, 0.04726849f, 0.42510176f, -0.21542984f, -0.04245077f, -0.04720314f, 
    0.01165519f, 0.09335013f, 0.03101297f, -0.06479739f, -0.07383958f, 0.02026689f, 0.11589712f, 0.09639950f, 
    0.03282005f, -0.07888510f, -0.04727794f, -0.02736393f, -0.03873791f, -0.00553104f, 0.11128204f, 0.09107073f, 
    0.00464749f, 0.01349126f, 0.03979721f, -0.07915147f, 0.00638880f, 0.17984739f, 0.04227839f, 0.18030548f, 
    0.03201975f, 0.20155220f, 0.19027017f, -0.02313445f, 0.02216035f, 0.00716533f, -0.16068892f, 0.07287730f, 
    -0.41270453f, 0.05570763f, 0.12684879f, -0.06049961f, -0.06562930f, -0.04314725f, 0.01101133f, -0.05310564f, 
    -0.04729707f, -0.09662518f, -0.00956577f, 0.18954915f, 0.01809728f, -0.16469944f, -0.02502727f, -0.08613291f, 
    -0.09322222f, 0.05613705f, 0.05289904f, -0.10996870f, -0.09993988f, 0.06003649f, -0.02645230f, -0.11625301f, 
    0.21768424f, -0.32400215f, 0.15137698f, -0.02851199f, -0.00318965f, 0.06882016f, 0.01581195f, 0.15783376f, 
    0.14890334f, 0.04289895f, -0.00792562f, 0.06273691f, 0.00580762f, 0.07480846f, -0.06925106f, -0.05401145f, 
    -0.09804934f, -0.00412487f, 0.05737628f, 0.07606979f, -0.17540795f, 0.03330415f, 0.15613577f, 0.14495912f, 
    0.20930952f, -0.41731280f, 0.09992385f, 0.15259495f, -0.02422316f, 0.16965939f, -0.01747639f, -0.11088648f, 
    0.18256634f, 0.06067704f, 0.04059656f, 0.04455183f, 0.03537958f, -0.01380372f, 0.02049801f, -0.14376688f, 
    0.01615583f, 0.18676959f, 0.03263914f, 0.01790159f, -0.09262183f, 0.06130152f, -0.06286759f, 0.11467846f, 
    0.11684612f, 0.11139815f, -0.03448955f, 0.16734968f, 0.04549449f, 0.10681543f, -0.15070850f, 0.14171652f, 
    0.14653100f, -0.05233188f, 0.11707510f, 0.04716230f, -0.08763700f, -0.39624029f, -0.14474621f, 0.17160508f, 
    -0.09920377f, 0.00148478f, 0.10287505f, 0.05279570f, -0.01264430f, -0.07756662f, -0.09246678f, 0.14224790f, 
    0.17157996f, -0.07296633f, -0.11837683f, -0.04296069f, 0.05879063f, 0.04401609f, -0.08253204f, -0.11294430f, 
    0.08301975f, 0.07639722f, -0.00749340f, 0.04891261f, -0.32353210f, -0.16683023f, 0.10344358f, -0.11252531f, 
    -0.11365026f, -0.11271210f, 0.00201847f, -0.00046663f, 0.07011035f, -0.05674942f, -0.02690084f, 0.07672595f, 
    0.32782301f, 0.12994573f, 0.17016862f, -0.08519589f, -0.02819295f, 0.03149166f, 0.01501182f, 0.17836522f, 
    -0.00424256f, 0.06232201f, 0.13906549f, 0.01625781f, 0.12280057f, -0.23133771f, -0.09594795f, -0.23148848f, 
    0.08104213f, -0.02171437f, -0.02902357f, -0.02222652f, -0.10317519f, -0.09126920f, -0.00456272f, -0.03774834f, 
    0.32857502f, 0.12750207f, 0.09921388f, 0.21302120f, 0.10672988f, 0.03885860f, 0.00994024f, -0.03422055f, 
    0.00298008f, 0.06346689f, -0.05725243f, 0.06789988f, 0.25153854f, 0.25095707f, -0.07901971f, -0.21324542f, 
    0.05212830f, 0.11543547f, 0.19117683f, 0.15867953f, -0.10936323f, -0.06013915f, 0.03901060f, -0.05830013f, 
    -0.44571233f, 0.17053893f, -0.02506008f, 0.05686092f, 0.05944841f, -0.05495621f, 0.01511594f, -0.07358401f, 
    0.13454841f, -0.06487247f, 0.01160993f, -0.02033705f, -0.09599170f, 0.15111677f, 0.19450027f, -0.01358514f, 
    0.03970511f, -0.00328962f, -0.06437671f, 0.08101858f, 0.07312949f, 0.03394642f, -0.05118914f, 0.07309482f, 
    -0.10326051f, -0.08154328f, 0.05653398f, -0.29646519f, 0.01042612f, 0.00343372f, 0.05236203f, -0.14437878f, 
    -0.06811554f, -0.00617407f, -0.03500012f, -0.00272298f, -0.00057127f, -0.09782484f, -0.11567713f, 0.08068352f, 
    -0.07550596f, 0.14249076f, 0.05022210f, 0.04868598f, 0.01730366f, -0.01599549f, -0.01788816f, 0.05549690f, 
    -0.02214503f, 0.07706999f, -0.03115802f, 0.00767384f, -0.03259063f, 0.11415730f, 0.06615642f, 0.06054033f, 
    -0.04348739f, 0.03333771f, 0.05568346f, 0.00779133f, -0.19226044f, 0.21798751f, 0.10482050f, 0.16197492f, 
    -0.07960954f, -0.04922441f, -0.08716648f, 0.07560393f, -0.04936854f, 0.07899168f, -0.12100327f, -0.04767251f, 
    -0.03238324f, 0.13628581f, 0.07891220f, -0.01105633f, -0.02544445f, 0.00952162f, -0.00716045f, -0.06942908f, 
    0.08122359f, 0.07866799f, 0.11013118f, -0.08364277f, 0.04719704f, 0.03889297f, -0.15238880f, -0.06563870f, 
    0.00854164f, 0.03841451f, 0.08248140f, 0.01241575f, 0.00613163f, -0.00205361f, 0.05247775f, 0.06876741f, 
    0.07256152f, -0.20792833f, -0.24929740f, 0.25097764f, 0.09029925f, -0.03735070f, 0.11765360f, 0.16525157f, 
    0.00339517f, 0.04501336f, 0.07682446f, -0.01029775f, 0.09694289f, -0.07320856f, -0.10731667f, 0.04942354f, 
    -0.03173848f, 0.08281419f, 0.05185349f, -0.04102451f, 0.00862019f, 0.00960705f, -0.06919173f, 0.00679334f, 
    -0.03111073f, -0.00390660f, -0.12229256f, -0.09402895f, 0.02945312f, 0.05414336f, -0.01164792f, -0.00622517f, 
    0.03734190f, -0.07356773f, 0.13453209f, -0.11401399f, -0.04410045f, -0.04723618f, -0.13244155f, -0.08483050f, 
    0.19994569f, 0.02771456f, -0.03435773f, -0.12517208f, -0.05985422f, 0.02979099f, 0.02808817f, 0.11804934f, 
    0.19176133f, -0.12484600f, -0.20739996f, 0.08675999f, -0.08180659f, 0.01470168f, 0.05948115f, -0.07101324f, 
    -0.09743018f, 0.06631964f, -0.06735931f, 0.08561168f, 0.43534750f, 0.06879791f, -0.09652808f, 0.08401616f, 
    0.00336300f, 0.10897402f, 0.08848046f, -0.08993110f, -0.13593364f, -0.13181120f, -0.11911941f, -0.14415759f, 
    0.13731369f, -0.04988439f, 0.03351575f, -0.11722786f, 0.08768605f, 0.07437252f, 0.02271496f, -0.00193904f, 
    0.13886969f, 0.14743751f, 0.15607813f, -0.03793082f, 0.25439629f, 0.16210298f, -0.08047398f, 0.04564601f, 
    0.20210750f, 0.12505154f, 0.07422522f, 0.16925214f, -0.08596431f, 0.14668056f, -0.01323265f, -0.22138524f, 
    -0.18709634f, -0.11055118f, 0.18435830f, -0.17271566f, 0.08404259f, 0.00286114f, -0.13442749f, -0.07445274f, 
    -0.02871456f, -0.07228214f, -0.07705262f, -0.19686496f, 0.08336356f, 0.17043370f, 0.02668450f, 0.09114329f, 
    0.03053238f, -0.11855644f, -0.03076017f, 0.10443616f, 0.13125269f, 0.09236705f, 0.05612819f, -0.05365774f, 
    0.22931805f, 0.16871588f, -0.00549724f, -0.22147267f, 0.24687850f, -0.05450540f, -0.07720158f, -0.10542060f, 
    0.06035656f, 0.10874530f, 0.03610648f, 0.00011132f, 0.25907370f, -0.04599441f, -0.16464441f, -0.00607304f, 
    -0.08298776f, -0.01394269f, 0.12931319f, -0.01045603f, -0.07901163f, -0.02245749f, -0.10444211f, -0.11080173f, 
    0.47036740f, -0.13465093f, -0.01803781f, 0.07691572f, -0.04506082f, 0.12917592f, 0.03786182f, -0.06361074f, 
    0.06640153f, -0.11110666f, 0.05745156f, -0.03658012f, -0.19479947f, -0.02544848f, -0.18613714f, 0.22303903f, 
    0.00944516f, -0.13483803f, 0.03986309f, 0.12509842f, -0.05266730f, 0.15269354f, -0.12060014f, 0.04479389f, 
    0.09738038f, -0.13603233f, 0.04939284f, 0.09014133f, 0.01859184f, 0.01971083f, 0.24929006f, 0.02645754f, 
    0.08391621f, 0.04465587f, 0.02470952f, -0.11098000f, 0.24198596f, 0.24777502f, 0.04028675f, 0.11413492f, 
    0.07556725f, 0.04755806f, -0.17186099f, 0.05817661f, -0.09561268f, -0.06125013f, 0.08870652f, -0.06432497f, 
    0.10425082f, 0.04939445f, 0.08203443f, 0.15886249f, 0.03096271f, 0.02552770f, -0.06191446f, -0.10413205f, 
    0.00947228f, 0.05665162f, -0.06956011f, 0.05996050f, -0.26873252f, -0.09699053f, -0.11096638f, 0.26942381f, 
    0.05375724f, 0.03719430f, -0.09691989f, -0.03656334f, 0.06312450f, -0.04628677f, -0.04987048f, 0.04752413f, 
    0.18672362f, 0.15908964f, 0.06791687f, 0.01305124f, -0.00614675f, -0.02146082f, -0.07301521f, -0.00813120f, 
    0.01555937f, -0.08890297f, 0.05401504f, 0.03258324f, -0.01878197f, -0.22178498f, -0.15957400f, 0.13831134f, 
    0.00705643f, -0.02237893f, -0.09374801f, -0.01607340f, 0.02113773f, -0.09166922f, 0.06002894f, 0.00850622f, 
    0.02033502f, -0.11553933f, -0.11257395f, 0.19251217f, 0.09696371f, -0.04526347f, -0.00850547f, 0.08373294f, 
    0.02699513f, 0.05282274f, -0.05537771f, -0.00747218f, 0.00781483f, -0.08740578f, -0.29420674f, 0.06790540f, 
    0.04161046f, 0.08167145f, 0.00199326f, 0.01755048f, 0.13498414f, 0.03819927f, -0.00739980f, 0.01559312f, 
    0.00734338f, -0.05829846f, 0.16656284f, 0.10787498f, 0.14501585f, 0.08899782f, 0.02545517f, 0.12994520f, 
    -0.01166779f, -0.03133639f, 0.11095468f, 0.01471239f, -0.01168086f, 0.18044357f, 0.14967483f, 0.04281599f, 
    -0.03785853f, -0.09895202f, 0.08680730f, 0.16617508f, -0.02727688f, -0.02871433f, -0.00455893f, -0.01993961f, 
    0.17807563f, -0.15230326f, -0.00710633f, 0.14603330f, 0.14314204f, 0.06608000f, -0.03095791f, -0.09628887f, 
    0.09351499f, -0.03079481f, -0.10485443f, 0.00667248f, 0.25368631f, 0.01525864f, -0.24439953f, -0.03784303f, 
    -0.08647976f, -0.02191167f, -0.01586651f, 0.15109794f, -0.02497411f, 0.01572488f, -0.04058891f, 0.04666152f, 
    0.02148641f, 0.03314123f, -0.22254717f, -0.07771787f, 0.05043605f, -0.02752157f, 0.02219562f, -0.02594127f, 
    -0.01625357f, 0.08028819f, 0.05160892f, -0.07649612f, 0.28333962f, 0.15465000f, 0.10590646f, 0.02757283f, 
    0.04097072f, 0.00234288f, -0.04855871f, 0.09217758f, 0.00903621f, -0.02382243f, -0.01410030f, 0.11621711f, 
    -0.01728977f, 0.07841400f, 0.04392836f, 0.19607943f, -0.04406468f, -0.03573591f, 0.11539970f, 0.08094121f, 
    -0.06998567f, 0.00092278f, 0.01464068f, -0.02452213f, -0.15948780f, 0.08330344f, 0.21792528f, -0.00202172f, 
    -0.08603021f, 0.12087116f, -0.07159801f, -0.00450309f, 0.11072664f, -0.00971581f, -0.03897234f, -0.02081241f, 
    0.17025539f, 0.16123046f, 0.11691025f, 0.03985186f, -0.07202937f, 0.08970205f, -0.15403140f, 0.03713763f, 
    -0.00488494f, 0.01078798f, -0.05782343f, -0.13384581f, 0.29540318f, 0.10123091f, -0.00653781f, 0.08861618f, 
    -0.02911846f, -0.04546568f, 0.15959071f, 0.00818017f, -0.05838074f, -0.02798388f, 0.02912236f, 0.00304901f, 
    -0.07305057f, 0.01320534f, -0.00568156f, -0.04326221f, 0.04642743f, -0.05612753f, 0.04182529f, -0.04197512f, 
    0.04800583f, -0.06285295f, -0.03209561f, 0.02600584f, 0.05164475f, -0.05934973f, -0.03570529f, -0.08644415f, 
    -0.02105968f, -0.00893464f, 0.01521597f, 0.04144878f, 0.03394835f, 0.05176800f, -0.03261146f, -0.01620957f, 
    -0.07723864f, -0.01889985f, -0.04702863f, 0.03805024f, -0.00401193f, -0.02969623f, -0.01736570f, 0.02889165f, 
    -0.07037126f, 0.04726201f, -0.04592757f, -0.03096621f, 0.00419363f, 0.02267795f, -0.04545689f, 0.04614699f, 
    0.05498492f, -0.02147890f, 0.03155416f, -0.02550528f, -0.01431874f, -0.08839635f, 0.03577845f, -0.04075901f, 
    0.06426268f, -0.03365112f, -0.07680005f, 0.00867453f, -0.00736034f, 0.02855445f, 0.02971526f, 0.02754871f, 
    -0.07926004f, 0.00179010f, 0.04031137f, -0.02515216f, 0.00324823f, -0.03266414f, -0.03601167f, -0.01074692f, 
    -0.06279987f, 0.03256223f, -0.00652206f, -0.02699004f, 0.00065105f, 0.01345033f, 0.00362853f, -0.06665470f, 
    -0.07055462f, -0.05870762f, -0.05266404f, 0.02136319f, -0.02715302f, -0.06705058f, -0.05359463f, -0.02774831f, 
    -0.06895535f, 0.01367501f, -0.05953311f, -0.04420008f, -0.00263781f, 0.00422826f, 0.00241062f, -0.04090260f, 
    -0.06537603f, -0.04387328f, -0.03747262f, -0.01763007f, 0.02704714f, 0.02504719f, -0.06247267f, 0.05000882f, 
    -0.01646094f, -0.06320167f, 0.03232599f, -0.05139388f, -0.05916305f, -0.02536377f, -0.06300960f, -0.08855572f, 
    -0.05940244f, 0.04559378f, -0.02177332f, -0.05679030f, 0.03785802f, -0.00677546f, -0.04778162f, 0.01828564f, 
    -0.06510197f, 0.03317761f, -0.00782066f, 0.01193229f, -0.04360514f, -0.05788895f, -0.00618435f, 0.01449654f, 
    0.04464142f, -0.04356686f, -0.08363703f, 0.02856676f, -0.07748963f, -0.08211911f, 0.00207977f, -0.01191942f, 
    -0.01754814f, 0.01080269f, -0.07077401f, -0.00382005f, -0.06936874f, 0.00046956f, -0.06188204f, -0.01193801f, 
    0.01211701f, -0.08225814f, -0.00688992f, -0.03805044f, 0.04834212f, -0.00229513f, -0.03809385f, -0.03290819f, 
    -0.07094676f, -0.03776329f, 0.01319576f, 0.04880575f, 0.01616248f, 0.01227921f, -0.04162768f, 0.04989950f, 
    0.02208354f, -0.03417932f, -0.02704160f, -0.01808242f, 0.03401304f, -0.04819605f, 0.00276433f, -0.03904685f, 
    -0.06151604f, -0.04985146f, 0.01959806f, 0.01652866f, 0.03433230f, 0.01472461f, -0.02443197f, 0.03360969f, 
    -0.06971516f, -0.08681433f, -0.04348779f, 0.03094992f, 0.02164442f, -0.03114156f, -0.06032754f, -0.05436494f, 
    -0.01648009f, -0.01736244f, -0.02951139f, 0.02106628f, 0.05906600f, -0.05920199f, -0.06987604f, 0.01205739f, 
    0.06302983f, -0.03285528f, 0.01770450f, 0.03352206f, 0.02759737f, 0.01199301f, -0.04798962f, -0.07519766f, 
    0.09740227f, 0.09379850f, -0.03860026f, 0.23143233f, 0.06850519f, -0.19534752f, -0.00299328f, -0.02027803f, 
    -0.02426076f, 0.01573285f, -0.02607921f, 0.00885959f, -0.17070206f, 0.17077151f, -0.01285285f, 0.16622081f, 
    -0.03069688f, -0.03036669f, 0.07581168f, -0.15948357f, -0.03206379f, 0.02260663f, 0.07886253f, 0.15611912f, 
    -0.01165422f, 0.11144604f, 0.05154252f, 0.07897133f, 0.07153305f, 0.05475480f, -0.11738139f, -0.07989662f, 
    0.10715797f, 0.00192441f, 0.07446364f, -0.07436701f, -0.22182779f, -0.10345666f, 0.01651599f, 0.02181533f, 
    -0.00459877f, 0.04134362f, -0.07874405f, 0.04646309f, -0.03556998f, 0.14779207f, 0.27202094f, -0.01033862f, 
    -0.00991136f, -0.01359098f, -0.04922459f, 0.11045611f, -0.03716476f, -0.12254362f, -0.06165812f, 0.15876044f, 
    0.04984250f, 0.10434704f, -0.02256597f, 0.28877687f, 0.06517217f, -0.12345310f, -0.14023952f, 0.02581306f, 
    0.08298060f, -0.01916758f, 0.04475566f, 0.02351892f, -0.05981525f, 0.04713789f, 0.02661145f, 0.06807560f, 
    0.37397894f, -0.16260190f, 0.10772066f, 0.07110547f, -0.02130258f, -0.15249646f, -0.19260821f, 0.14764844f, 
    0.02123632f, 0.10179839f, -0.00066048f, -0.22544774f, 0.05798877f, 0.20917508f, 0.08133839f, 0.18466902f, 
    -0.04523908f, 0.05567190f, 0.05384009f, -0.06753325f, -0.06542537f, -0.03160581f, -0.21406645f, -0.03487092f, 
    -0.18444268f, 0.05187168f, -0.04879772f, 0.11854249f, 0.10730506f, -0.00736104f, 0.19894797f, 0.06195932f, 
    0.01482265f, -0.02272346f, 0.06204064f, -0.05410562f, -0.15734375f, 0.35116285f, -0.12929638f, 0.00377380f, 
    0.09059740f, -0.20174825f, -0.06112942f, -0.06875508f, 0.03142266f, -0.09850436f, 0.10914852f, -0.00540971f, 
    0.08687276f, 0.07884045f, -0.12767662f, 0.01584793f, 0.14593655f, 0.00062758f, -0.08645441f, -0.07692177f, 
    -0.16140410f, 0.00613239f, -0.16514480f, -0.03776194f, 0.25988090f, -0.03678045f, -0.03254073f, 0.07849830f, 
    0.01646558f, -0.12112560f, 0.01752242f, -0.14563492f, -0.01676851f, 0.14807642f, 0.07831151f, -0.02357308f, 
    -0.10545935f, -0.03479917f, 0.10051170f, 0.02707327f, -0.12145601f, -0.02709673f, 0.09211063f, 0.20869078f, 
    0.11029094f, 0.02411955f, -0.00077581f, -0.04577621f, -0.12223954f, -0.06859729f, -0.00132357f, 0.12544388f, 
    -0.14355071f, -0.04816944f, -0.08525322f, 0.00247460f, 0.08975060f, -0.01124343f, -0.05319204f, -0.24320073f, 
    -0.21697024f, 0.01646535f, 0.08410580f, 0.06008306f, -0.13833600f, 0.00403465f, 0.06640209f, -0.05860716f, 
    0.12976754f, -0.13407581f, 0.06208218f, -0.05477873f, 0.20460117f, 0.09258758f, 0.03356799f, 0.09333750f, 
    -0.17749634f, 0.04750980f, -0.04486563f, -0.01091438f, 0.04448300f, -0.08901145f, -0.05773503f, -0.16072406f, 
    -0.12371435f, -0.14139356f, -0.20629813f, -0.25568539f, 0.06208582f, 0.03612087f, 0.09289669f, 0.05300470f, 
    0.06749932f, 0.09717084f, 0.12523627f, 0.03329797f, 0.23352349f, 0.02038760f, 0.12257278f, 0.03579575f, 
    -0.01346417f, 0.08166348f, 0.08074557f, -0.04034279f, 0.05847821f, 0.12803037f, 0.02119579f, 0.12608242f, 
    -0.13224581f, -0.14735845f, -0.01739811f, -0.06027009f, 0.01252726f, 0.05350414f, 0.14366201f, 0.07836210f, 
    -0.03328406f, 0.09328272f, 0.05705133f, 0.11041437f, 0.01868609f, 0.04331892f, -0.04212475f, -0.04971386f, 
    0.06099013f, 0.05015366f, -0.00764819f, 0.04214692f, -0.03493253f, 0.09729357f, -0.03264691f, 0.11993463f, 
    0.19302055f, 0.07755824f, 0.09964568f, -0.28180331f, 0.07997090f, 0.09063350f, 0.09103487f, 0.01697026f, 
    -0.07080209f, 0.07857020f, -0.01682520f, 0.09330361f, 0.06426249f, 0.18957423f, 0.17140795f, 0.09572706f, 
    0.04330824f, -0.00289651f, 0.00263293f, -0.01193603f, -0.03531244f, 0.03933349f, -0.04241320f, 0.11275340f, 
    -0.01515290f, -0.13294673f, -0.05005976f, 0.05921248f, -0.05031903f, -0.05820948f, -0.03354664f, 0.01515454f, 
    -0.06695070f, 0.14005920f, 0.03982972f, -0.00443415f, 0.03588077f, -0.30507231f, -0.14464700f, -0.09730607f, 
    -0.06346619f, -0.05892744f, 0.05028252f, -0.02276786f, 0.06563091f, 0.08250789f, -0.02807235f, 0.00670452f, 
    0.10928729f, -0.17057823f, 0.12240453f, 0.03717782f, 0.04292799f, -0.01838426f, 0.05444532f, 0.10702513f, 
    0.03154439f, 0.09207942f, 0.04856849f, 0.12312381f, 0.02322759f, 0.11868600f, 0.11721665f, -0.20112702f, 
    0.04880410f, 0.14367829f, 0.02191676f, 0.02657014f, 0.08178189f, -0.02312102f, 0.08581926f, 0.09429664f, 
    0.20657161f, 0.10145610f, 0.01996028f, 0.08509865f, 0.19447167f, -0.01842264f, 0.03386019f, 0.00073538f, 
    0.03534897f, -0.00671632f, 0.01521606f, 0.04197794f, -0.08867864f, -0.04372834f, -0.18348616f, -0.04054414f, 
    -0.12177202f, 0.09596989f, 0.11995327f, -0.02393050f, -0.01817083f, 0.06934790f, 0.06623592f, -0.02313633f, 
    0.30615696f, 0.04330842f, -0.02017729f, 0.06870016f, -0.01135400f, 0.00876721f, 0.06917509f, 0.12081657f, 
    0.04189963f, -0.02486449f, 0.11090340f, 0.06682204f, -0.06382205f, 0.03705515f, -0.09910544f, 0.00984828f, 
    0.10523105f, -0.00212021f, 0.07712022f, 0.03479958f, 0.08711585f, -0.03296875f, 0.00939574f, 0.07971825f, 
    0.15987062f, -0.04100327f, 0.09161462f, -0.03750222f, -0.07183585f, 0.02074323f, 0.06441909f, 0.01628081f, 
    0.05191870f, -0.06556956f, 0.00629878f, 0.08945244f, 0.03728744f, -0.00596285f, -0.00238508f, -0.14112042f, 
    0.06284937f, 0.04405520f, -0.10527638f, 0.03156908f, 0.06715772f, -0.00057818f, -0.01361888f, -0.01995555f, 
    -0.07587539f, 0.02423671f, 0.18125036f, -0.01861735f, -0.03991013f, -0.00290855f, 0.08070637f, 0.20868033f, 
    0.11038554f, 0.00949084f, 0.06391690f, 0.08333717f, 0.09794160f, 0.21131808f, 0.08800528f, 0.08381929f, 
    -0.06223915f, 0.03154009f, 0.04024071f, 0.01053238f, -0.06195986f, -0.05165898f, -0.05787349f, 0.06325546f, 
    -0.19732805f, -0.07534168f, -0.11276393f, 0.02619275f, 0.17752074f, -0.05463285f, 0.07861572f, -0.00406719f, 
    0.00218041f, 0.05786834f, 0.00158528f, 0.01359498f, 0.31608027f, 0.25053331f, 0.15096501f, 0.07166213f, 
    0.08594049f, 0.07571543f, 0.08058811f, 0.01557589f, 0.04516021f, 0.02958487f, 0.14756893f, 0.00584069f, 
    -0.03472272f, 0.04990902f, 0.25804964f, 0.29532921f, -0.12152690f, 0.02972537f, -0.04183675f, 0.00218359f, 
    -0.01758900f, -0.04108110f, 0.05888220f, 0.00717016f, 0.00535712f, 0.14547212f, 0.20967038f, 0.08092678f, 
    -0.10309991f, 0.02798464f, 0.00236634f, 0.03203218f, 0.07219676f, -0.00235704f, 0.00209474f, 0.14439149f, 
    -0.10819258f, -0.01022146f, -0.06065968f, 0.03392778f, -0.00458382f, 0.00953378f, 0.04853904f, 0.12288427f, 
    0.02221279f, -0.01055709f, 0.01475944f, 0.02780017f, -0.30152524f, -0.10453811f, -0.18822394f, -0.04677513f, 
    0.02033066f, 0.16348486f, -0.02642410f, -0.06003560f, 0.12658550f, 0.00018760f, 0.05144439f, 0.03684115f, 
    -0.03287409f, 0.07472923f, 0.12441000f, -0.15356606f, -0.03865599f, -0.01040158f, 0.10191320f, 0.04969040f, 
    0.13214518f, -0.05166670f, 0.04619964f, -0.01437613f, 0.02037414f, -0.07507227f, 0.08504184f, 0.02734660f, 
    -0.02564825f, 0.10274176f, 0.02643126f, -0.08799983f, -0.00215596f, -0.13543676f, -0.00379999f, 0.11809748f, 
    0.02442657f, 0.13119276f, 0.12609898f, -0.02149120f, -0.06304477f, -0.08767537f, 0.02238569f, 0.02302815f, 
    0.02601006f, 0.00894671f, -0.08386698f, -0.04362399f, -0.37858397f, -0.09539998f, 0.00605442f, -0.04671466f, 
    0.12637454f, 0.01591078f, 0.02269560f, 0.07996168f, 0.11766437f, 0.02133522f, 0.14483945f, 0.04892947f, 
    -0.50274897f, 0.07391279f, -0.03746626f, -0.30695862f, 0.20098515f, 0.01088826f, -0.06012467f, 0.02823838f, 
    0.04303941f, 0.02138156f, -0.05646354f, -0.02169036f, 0.14897318f, 0.01379866f, 0.03164251f, 0.05998690f, 
    0.09838692f, -0.01884711f, -0.07993971f, 0.07899380f, 0.00468411f, 0.05385038f, 0.01471469f, -0.08439433f, 
    -0.20566049f, -0.14458202f, -0.05357050f, -0.10582704f, 0.03012163f, 0.02216476f, 0.01806826f, -0.12900910f, 
    0.04800728f, 0.11254813f, -0.02031710f, 0.14992411f, -0.05102528f, -0.07847854f, -0.04959378f, -0.10080218f, 
    0.11147141f, 0.11916109f, -0.03664050f, -0.00518295f, 0.18143983f, 0.13667352f, 0.05596194f, 0.04517750f, 
    0.08402316f, -0.01127824f, 0.31341311f, 0.17585504f, -0.01601879f, 0.02933104f, -0.10070217f, 0.11644600f, 
    0.04855682f, 0.10374139f, -0.01857370f, 0.13640144f, -0.03896766f, -0.17407872f, 0.10143810f, -0.08636053f, 
    0.05529083f, -0.01308293f, -0.16120012f, 0.04173645f, 0.10257550f, 0.01788022f, 0.06126612f, 0.10469187f, 
    0.18601628f, 0.29757553f, -0.16583659f, 0.05052508f, 0.03195060f, -0.00442769f, -0.05623354f, -0.12344598f, 
    -0.06285281f, 0.02822724f, 0.00499663f, -0.00410426f, 0.00900116f, 0.13009818f, 0.14390302f, -0.21712929f, 
    -0.04189355f, 0.03070780f, 0.02605222f, 0.03550707f, 0.05446623f, -0.09092885f, -0.04414292f, -0.04781874f, 
    -0.05519619f, -0.00804714f, 0.01256202f, 0.25960612f, 0.05298854f, -0.10085412f, 0.07621575f, 0.11412612f, 
    -0.03877072f, -0.02011960f, 0.08413967f, -0.06275165f, 0.01126852f, 0.07173762f, 0.10196840f, 0.03284199f, 
    -0.06561150f, -0.01595445f, -0.11095605f, 0.04370930f, -0.01259224f, 0.00322721f, -0.06903176f, 0.01730226f, 
    0.04489754f, 0.17428833f, 0.26876128f, -0.11317777f, 0.03348388f, -0.08624974f, 0.00932724f, 0.04704771f, 
    0.09932903f, -0.01265418f, 0.07158064f, 0.11507399f, -0.27108946f, -0.16014679f, -0.15818809f, -0.06529848f, 
    0.04872408f, 0.15937255f, -0.01799054f, -0.03633674f, -0.08753754f, -0.10878605f, 0.08733564f, 0.07260154f, 
    -0.06309114f, -0.18789883f, -0.03710714f, -0.02821074f, 0.06575477f, -0.03752275f, 0.02351671f, -0.01653512f, 
    0.04440200f, -0.01410023f, -0.03652529f, 0.04329971f, 0.32275039f, -0.15430002f, -0.17079116f, 0.39622560f, 
    0.04688873f, 0.13767065f, 0.12562431f, 0.03584928f, 0.03891458f, 0.05422581f, -0.03339411f, 0.03590044f, 
    -0.41290531f, 0.02704807f, -0.04166328f, -0.00714325f, -0.04853664f, -0.03289777f, -0.08404952f, 0.02996733f, 
    0.08016465f, -0.07546612f, 0.05682250f, -0.02694519f, -0.19674537f, 0.20789628f, 0.14519081f, 0.09741574f, 
    0.06787653f, 0.17171527f, -0.03395983f, 0.13175817f, -0.08302388f, -0.01804059f, 0.06281705f, 0.12021495f, 
    -0.26202387f, 0.17673534f, 0.04634492f, -0.12418766f, 0.18933834f, 0.02912539f, 0.13185117f, -0.07130580f, 
    -0.02790176f, 0.09467796f, -0.01460947f, -0.03960410f, -0.00211223f, 0.11690971f, 0.08103781f, -0.05809383f, 
    0.02497165f, 0.14572184f, 0.01941206f, -0.04387140f, -0.03126043f, -0.13829729f, 0.12736128f, 0.24351387f, 
    0.04194471f, -0.05482415f, -0.04808291f, 0.08584882f, 0.16205616f, 0.14475605f, 0.10408809f, -0.04810652f, 
    -0.04922324f, 0.02232512f, 0.07501205f, 0.06710801f, 0.17502417f, -0.16038634f, -0.14719635f, 0.04495477f, 
    -0.06149498f, -0.01629559f, 0.12759714f, -0.13125835f, 0.00576692f, 0.11400458f, 0.02384074f, 0.15367696f, 
    0.02235907f, 0.04775587f, -0.22495459f, 0.00767933f, 0.11774739f, 0.22149999f, -0.00759417f, -0.03586958f, 
    0.05449576f, -0.05940446f, -0.14582546f, -0.03370252f, -0.16350240f, -0.22727354f, -0.06562474f, -0.11387036f, 
    0.06200707f, -0.09772307f, -0.13195255f, 0.04206881f, 0.02708138f, 0.13946681f, 0.01965992f, -0.08652578f, 
    0.20048302f, -0.04071606f, -0.01128935f, -0.15298904f, -0.01691192f, -0.02119658f, 0.06452917f, -0.00422620f, 
    -0.04392652f, -0.01030963f, -0.02289101f, -0.00677779f, -0.18475515f, 0.06928512f, -0.11421187f, -0.10213180f, 
    -0.04211483f, 0.05815019f, -0.02093653f, 0.10592955f, 0.19501702f, -0.07150212f, -0.19346091f, 0.00327492f, 
    0.26560721f, 0.09903813f, -0.00310571f, -0.05789518f, 0.06722752f, -0.03521181f, 0.02799360f, 0.08045787f, 
    0.02758278f, -0.04145809f, 0.14808849f, -0.17148928f, 0.16149877f, 0.22143827f, -0.10869543f, 0.03705551f, 
    0.03236394f, 0.06897403f, 0.01604493f, 0.03178186f, 0.06190109f, 0.03188506f, -0.02175389f, 0.07317723f, 
    0.09367508f, 0.03687790f, -0.04150259f, -0.03213669f, 0.03187002f, 0.16403815f, -0.06264354f, -0.10708746f, 
    0.12623763f, 0.10815836f, 0.05801956f, 0.08057663f, 0.10252503f, -0.39031288f, -0.00491371f, -0.07854225f, 
    -0.13510674f, 0.01316675f, 0.02826439f, -0.08721133f, 0.01448813f, 0.01355834f, -0.01783980f, -0.01766125f, 
    0.09885770f, -0.35472599f, -0.06193362f, 0.07548980f, -0.02851911f, -0.02738677f, -0.01449268f, 0.11638576f, 
    -0.02440262f, 0.01788917f, -0.10430518f, 0.14775279f, 0.06884126f, -0.25519994f, -0.08008846f, 0.04299779f, 
    0.03567983f, 0.00942315f, 0.03896807f, -0.02930269f, 0.05113604f, -0.03174534f, -0.08978280f, 0.05764152f, 
    -0.05653990f, -0.24779306f, -0.14467627f, 0.09921435f, 0.13377413f, 0.02428145f, 0.20593260f, 0.24995118f, 
    0.09281843f, 0.00417123f, 0.04151123f, 0.04656533f, 0.07526257f, 0.05492220f, -0.02905260f, 0.11085825f, 
    -0.07780266f, -0.01853134f, 0.07443377f, 0.00645650f, 0.08718307f, 0.00824783f, -0.02696878f, -0.02804459f, 
    0.22710189f, 0.11033307f, 0.00499656f, 0.23384166f, 0.01996309f, -0.03535986f, 0.11713154f, 0.14927909f, 
    0.09366588f, -0.13715282f, 0.04357112f, 0.09952050f, -0.20766944f, 0.23018417f, 0.12851255f, -0.22027242f, 
    0.16059022f, 0.07568844f, 0.08358766f, -0.20890537f, 0.08743485f, -0.01633087f, -0.04203703f, 0.09500304f, 
    0.16861254f, 0.17094214f, -0.02660399f, -0.07586361f, -0.01833504f, 0.01888265f, 0.06530099f, 0.15779361f, 
    0.04589977f, 0.02100850f, -0.02542461f, -0.03198652f, 0.00438395f, -0.27032259f, 0.02561072f, 0.07052576f, 
    -0.11600915f, -0.11151081f, 0.14334653f, -0.00534452f, 0.01335867f, 0.01027767f, 0.04172000f, 0.07610277f, 
    0.29243895f, 0.21813928f, 0.13801087f, 0.07627561f, 0.21444857f, 0.02423477f, 0.00444326f, -0.00801863f, 
    0.05016505f, 0.01516921f, -0.05349291f, -0.05384845f, -0.45525777f, -0.26277289f, -0.06867244f, -0.09543674f, 
    -0.13864930f, -0.14265195f, -0.00814259f, 0.02451762f, 0.02969257f, 0.04478445f, 0.02315816f, -0.04800510f, 
    0.37611318f, 0.10218709f, -0.08022696f, 0.05060921f, 0.05250303f, 0.07251628f, 0.02674475f, 0.02981485f, 
    0.07680070f, 0.04718527f, 0.05101096f, -0.05402926f, -0.17167215f, -0.16090466f, 0.20146507f, -0.12188385f, 
    -0.13348708f, -0.05818518f, -0.08608781f, -0.00262919f, -0.05998784f, -0.05154193f, 0.05901274f, -0.06830025f, 
    0.11529079f, 0.17850405f, -0.06779321f, -0.02079441f, 0.11779729f, 0.09983803f, -0.12047502f, 0.04099891f, 
    0.13219303f, -0.00167294f, 0.08305556f, 0.03149080f, -0.48558411f, -0.09355991f, 0.05551337f, -0.12279461f, 
    -0.00513766f, -0.00164684f, -0.04205271f, -0.03783837f, -0.01308772f, 0.00909987f, -0.01677771f, 0.09669611f, 
    0.14828147f, 0.25503075f, 0.16578966f, 0.05188676f, 0.06319558f, 0.02649904f, -0.03218104f, -0.01801717f, 
    0.05008323f, -0.13726005f, -0.01438350f, -0.03437806f, -0.01588298f, 0.25904438f, 0.00968800f, 0.00469669f, 
    0.10045184f, 0.09021689f, 0.10654414f, 0.05944646f, -0.08122874f, 0.00562997f, 0.13904080f, 0.10841150f, 
    -0.16345508f, 0.04409669f, -0.19561268f, -0.03962748f, -0.08534775f, -0.00905607f, 0.02877235f, -0.01725310f, 
    0.03712629f, -0.09313568f, -0.02430700f, -0.08064883f, -0.01803678f, -0.14617871f, -0.07543774f, 0.29422265f, 
    0.03334239f, -0.00564513f, -0.03244422f, 0.18812302f, -0.05010442f, 0.03322170f, -0.09039247f, -0.05830447f, 
    -0.13432339f, -0.10417373f, -0.09646977f, -0.12033504f, -0.03574523f, -0.00492942f, -0.03603319f, -0.05832305f, 
    0.02860419f, -0.11330323f, 0.04090210f, 0.00255050f, 0.25862989f, 0.08685935f, 0.00269802f, 0.09278483f, 
    0.07299428f, 0.06731449f, 0.02529387f, 0.08661288f, 0.05899955f, 0.09237493f, -0.14492306f, -0.01294679f, 
    0.05541606f, 0.03249642f, 0.06416123f, -0.02477884f, 0.07238066f, 0.00274405f, -0.09476781f, 0.02545695f, 
    0.03286889f, 0.03404231f, -0.05391166f, -0.08548051f, 0.03713490f, 0.07688396f, 0.34786707f, 0.01952500f, 
    -0.05821297f, 0.05391170f, 0.03591605f, -0.11639166f, 0.04297231f, 0.00578853f, -0.02980881f, -0.00720146f, 
    0.13191555f, 0.20103724f, -0.16002870f, 0.03237301f, 0.05644538f, 0.06776834f, -0.09786449f, 0.08197112f, 
    0.04971864f, -0.05447600f, -0.03814764f, -0.06529516f, 0.11456124f, 0.01865422f, -0.00843193f, 0.08416968f, 
    -0.09893173f, 0.08543365f, 0.27586856f, -0.01474500f, -0.08215796f, 0.04649752f, -0.07455282f, -0.06876065f, 
    0.04009778f, 0.06368603f, -0.00073389f, 0.08326970f, -0.04286429f, -0.09922980f, -0.03352520f, 0.00654027f, 
    0.04734749f, -0.05976848f, 0.06906989f, 0.16867995f, -0.04835030f, 0.17791829f, 0.07670385f, 0.00717221f, 
    0.13533649f, 0.05801122f, -0.00599579f, -0.05341786f, 0.06018760f, -0.05688096f, -0.03231569f, 0.10305566f, 
    -0.05679390f, -0.02342859f, 0.01918683f, 0.08222864f, 0.05005429f, 0.01912167f, 0.02389707f, 0.05555438f, 
    -0.00108162f, 0.12372384f, 0.05376939f, -0.00886998f, -0.00928182f, -0.10412996f, 0.10160761f, 0.14444311f, 
    0.02486626f, -0.00409414f, 0.06333055f, -0.05536306f, -0.03913458f, 0.13810036f, 0.09280250f, 0.00801621f, 
    -0.21165946f, 0.03855679f, 0.02586410f, 0.12263352f, 0.04392447f, -0.11432521f, 0.02142209f, 0.18246213f, 
    0.07393380f, 0.04840259f, -0.04495309f, 0.11375795f, -0.05145376f, -0.22170435f, -0.01287261f, -0.15416281f, 
    0.00067456f, -0.00212041f, -0.07605053f, -0.06898991f, 0.07370621f, 0.09609781f, 0.00477598f, -0.04090488f, 
    0.17183088f, 0.00084833f, 0.11335166f, -0.06601590f, 0.10860170f, -0.09488783f, 0.01729979f, 0.14922914f, 
    0.09051481f, -0.04321218f, 0.02461412f, 0.05624536f, -0.22315736f, 0.25128287f, 0.01449836f, 0.09213301f, 
    -0.02006885f, 0.02918433f, 0.06930252f, -0.06027839f, -0.01975736f, -0.02110705f, -0.00150042f, 0.03194653f, 
    -0.13472748f, 0.41899633f, -0.09407382f, -0.03346734f, 0.12892634f, -0.11958437f, 0.13404304f, 0.05268365f, 
    -0.01525271f, -0.06735073f, 0.10149813f, 0.06411831f, -0.08756071f, 0.25467142f, -0.00054175f, 0.01724568f, 
    0.15337503f, -0.01345033f, -0.05609654f, -0.11963688f, 0.03874030f, -0.02444207f, 0.09976920f, -0.00518039f, 
    -0.02256196f, 0.12288591f, 0.07279745f, -0.00823003f, -0.01555606f, 0.02326974f, -0.05772724f, 0.02599470f, 
    -0.01099702f, 0.05085938f, -0.04802420f, 0.05682848f, -0.10406239f, -0.21829465f, 0.10693541f, -0.07960712f, 
    0.07693597f, -0.03493753f, 0.14161398f, -0.03621140f, -0.00366910f, 0.11479849f, 0.17584687f, 0.04550620f, 
    -0.40658969f, 0.05268690f, -0.04260064f, -0.23614872f, 0.20209292f, -0.03941443f, 0.05129524f, -0.02682135f, 
    0.06617430f, 0.13033520f, 0.00764652f, -0.04093014f, 0.01476210f, -0.12029715f, 0.14623661f, 0.07494204f, 
    -0.13720305f, 0.02351403f, -0.03131318f, 0.04620102f, 0.10351644f, 0.01745336f, 0.12341472f, -0.04430762f, 
    -0.25521883f, 0.03708669f, 0.02479104f, 0.03138371f, 0.04415565f, -0.12029351f, -0.05240328f, -0.08708392f, 
    0.14369640f, -0.11233937f, 0.05723314f, -0.03112136f, -0.18965919f, -0.00219646f, 0.10826203f, 0.07384309f, 
    0.01995524f, -0.01071840f, 0.06042985f, -0.00042938f, 0.10043440f, 0.03443747f, -0.07051982f, -0.04933641f, 
    -0.03025402f, -0.07294904f, -0.01745875f, -0.02253867f, -0.07638099f, -0.01037453f, -0.00572667f, 0.03863420f, 
    -0.04711240f, 0.00967190f, 0.04885083f, -0.06501426f, 0.05673947f, -0.01120509f, -0.05829300f, -0.04556862f, 
    -0.04300646f, -0.07407290f, 0.04112407f, -0.06200977f, 0.05769113f, 0.06088241f, 0.04611437f, 0.03086730f, 
    -0.03276064f, 0.03131765f, 0.05656258f, 0.04292703f, -0.02358390f, -0.06878559f, -0.05957069f, -0.01714938f, 
    0.05890542f, -0.00942601f, -0.03260695f, -0.07298645f, 0.00147962f, 0.03605402f, 0.05207666f, -0.00720304f, 
    -0.08005142f, 0.01397847f, -0.02552389f, -0.04211357f, -0.01971093f, -0.05703028f, -0.06453103f, 0.00994035f, 
    -0.04189726f, 0.00916271f, -0.06628969f, -0.06521280f, 0.05631170f, 0.00666159f, -0.02559817f, -0.03975759f, 
    0.02312582f, -0.01900427f, -0.02192666f, -0.03983997f, 0.00659258f, -0.04206569f, 0.01811477f, 0.04831362f, 
    -0.05937553f, -0.02450026f, -0.05394270f, 0.05316959f, 0.03730090f, -0.05629338f, -0.07884855f, 0.05057345f, 
    0.05335283f, -0.07573529f, 0.04792117f, 0.00966411f, -0.05120266f, -0.03136420f, 0.00424863f, -0.03755172f, 
    0.06208498f, -0.04732688f, -0.05556165f, -0.04498463f, -0.04045504f, 0.00557420f, 0.01710486f, -0.05235175f, 
    0.01788644f, 0.02800556f, -0.01865632f, -0.02219797f, 0.03533322f, 0.06514070f, 0.04385103f, 0.04368552f, 
    -0.01033441f, -0.03645560f, 0.02506717f, -0.04439707f, -0.06444171f, -0.00960711f, 0.00781298f, -0.02117068f, 
    -0.01914842f, -0.02053213f, 0.05208641f, -0.01137074f, -0.01601811f, 0.01295756f, -0.01191647f, -0.03347457f, 
    0.05870380f, 0.02832150f, -0.06587511f, 0.03225442f, 0.02608253f, 0.02923629f, -0.04959517f, 0.06039097f, 
    0.01203489f, 0.03825409f, 0.02418196f, 0.01591536f, 0.05417328f, -0.06451718f, -0.04885374f, 0.02196948f, 
    0.00999188f, 0.04858711f, 0.01881359f, 0.02470106f, 0.03825846f, 0.06987096f, -0.05186750f, -0.00190568f, 
    -0.02243640f, -0.07141179f, -0.03545025f, -0.01071004f, 0.04020860f, -0.04909028f, -0.01935901f, -0.06461690f, 
    -0.00048103f, -0.05342552f, -0.04879455f, 0.05315703f, -0.00870160f, -0.00252765f, -0.05709507f, 0.05209432f, 
    -0.00711267f, -0.07308116f, -0.00623964f, -0.05753080f, -0.02878441f, -0.00938977f, -0.04288759f, -0.01972118f, 
    -0.05481643f, -0.01018747f, 0.02695731f, -0.00043861f, -0.02162847f, -0.03779062f, 0.04817589f, -0.07790389f, 
    -0.02498862f, -0.07778157f, 0.02099339f, -0.05672444f, 0.05938849f, 0.00969847f, 0.05938923f, -0.04978594f, 
    0.03756329f, -0.04733771f, -0.01140790f, -0.02872203f, -0.04795217f, -0.00407157f, 0.02322197f, 0.05390948f, 
    -0.05282650f, -0.06128651f, 0.06127745f, -0.07330664f, -0.01243617f, 0.05759384f, -0.04274276f, 0.03796246f, 
    0.02521998f, 0.05135576f, -0.01032600f, 0.00514118f, 0.00038978f, 0.03514431f, -0.05435522f, -0.04987581f, 
    -0.11152730f, -0.05453299f, -0.08013158f, 0.16927534f, -0.31517744f, 0.22296026f, 0.09275293f, -0.13505998f, 
    0.14371219f, 0.03003892f, -0.09969833f, 0.10813689f, -0.00561072f, -0.16675949f, -0.07820957f, -0.13019980f, 
    -0.01709612f, 0.07719041f, 0.03973146f, -0.01023913f, -0.17756180f, -0.15967046f, -0.03477051f, -0.02712134f, 
    0.06398872f, 0.09292217f, 0.05931042f, 0.01598840f, 0.02311071f, 0.04820602f, -0.04768394f, 0.31533355f, 
    0.14513779f, 0.04269833f, 0.08848742f, -0.10927314f, 0.12165155f, -0.20336321f, -0.07818469f, -0.12923822f, 
    0.01947953f, -0.04222762f, -0.07665280f, 0.32825631f, 0.02448267f, 0.07660078f, -0.14025015f, 0.01618019f, 
    -0.00574603f, -0.09187126f, 0.01555233f, -0.27123874f, -0.01563330f, 0.13852437f, -0.10627501f, 0.27917752f, 
    0.07157567f, 0.02035944f, -0.01939709f, 0.05677296f, 0.06465991f, 0.01344990f, 0.08366446f, -0.12292065f, 
    0.01929943f, -0.03579527f, 0.03104077f, -0.40355217f, -0.07280312f, 0.19606312f, -0.13989167f, 0.08289398f, 
    0.15613376f, -0.02623875f, 0.03061049f, -0.00363994f, -0.19500747f, -0.18757102f, 0.38420701f, 0.12957147f, 
    -0.05421732f, -0.02857354f, 0.11596682f, 0.16485544f, -0.02171329f, 0.00675320f, 0.04634550f, 0.02898692f, 
    0.26995721f, 0.13041396f, 0.09070542f, -0.14529641f, 0.03877470f, 0.05670870f, 0.02750166f, -0.08691191f, 
    -0.04436424f, -0.10053243f, -0.09913857f, -0.04580683f, 0.10598337f, -0.08983929f, -0.15915605f, 0.08664777f, 
    -0.01883077f, -0.11095282f, 0.04185989f, 0.07756248f, 0.05918672f, 0.00421083f, -0.04806703f, -0.01221602f, 
    0.13247071f, -0.07562784f, -0.06479692f, 0.14628568f, -0.04676494f, -0.08958874f, 0.08391100f, 0.17299753f, 
    0.07553023f, 0.00760714f, 0.16066791f, -0.13507552f, 0.02324240f, 0.02354164f, 0.14864106f, -0.29635853f, 
    0.07986867f, -0.14659330f, -0.19192763f, 0.11510156f, 0.06596429f, -0.04449629f, -0.04104232f, -0.03375298f, 
    0.18051255f, -0.05971802f, 0.12846906f, 0.00588802f, -0.00699370f, -0.11865027f, 0.04545150f, -0.13636163f, 
    -0.02917344f, 0.00140347f, -0.09047479f, 0.00636041f, 0.01846298f, 0.16251460f, 0.16011876f, -0.16872551f, 
    0.17021988f, 0.11268274f, 0.00645942f, -0.09975526f, -0.01539208f, 0.04671392f, 0.06997290f, 0.08454636f, 
    0.23178729f, 0.14538229f, -0.03649765f, 0.16860189f, 0.12256320f, 0.09495822f, -0.11053657f, 0.06575657f, 
    -0.04745140f, 0.09624095f, 0.02003453f, 0.01016890f, -0.17919973f, 0.01293531f, 0.24747184f, 0.24658792f, 
    -0.13961321f, -0.15917592f, 0.14416403f, 0.02812384f, -0.12824015f, 0.05836014f, 0.04409166f, 0.06804295f, 
    -0.09331521f, -0.04991636f, -0.24382506f, 0.04686959f, 0.06877799f, 0.11100378f, 0.02395117f, -0.09453603f, 
    -0.15414570f, -0.10142549f, -0.10102269f, -0.02547785f, 0.02466602f, -0.06939520f, -0.24529719f, -0.04224418f, 
    0.04724650f, -0.00974767f, -0.01049985f, 0.06465930f, 0.03332814f, 0.01223993f, -0.13612115f, -0.04756972f, 
    0.30609891f, -0.20786621f, 0.11570463f, 0.03122780f, -0.02031039f, 0.00414211f, 0.08828352f, 0.02895949f, 
    0.07053588f, 0.02052477f, 0.02110431f, -0.00889222f, 0.01892480f, 0.01181059f, -0.22583503f, 0.11695772f, 
    0.09427711f, -0.01481796f, -0.08475027f, 0.03644548f, 0.06917226f, 0.03257918f, -0.04887161f, -0.00540632f, 
    0.21849334f, 0.05027162f, -0.05250860f, 0.01371127f, 0.01061083f, 0.07051916f, 0.00718722f, -0.03450618f, 
    0.05033641f, 0.00632517f, -0.02808446f, 0.03803929f, 0.32488453f, -0.00594079f, -0.12594984f, -0.06679565f, 
    -0.01975425f, 0.07370833f, 0.02054182f, 0.02949146f, -0.00269781f, -0.09236186f, 0.07533908f, -0.07528473f, 
    -0.05825201f, 0.04990284f, -0.28630596f, 0.22265182f, -0.04042637f, 0.15625791f, 0.00290020f, -0.03784960f, 
    0.01986579f, 0.08791219f, 0.03522059f, 0.01087686f, 0.36149037f, 0.26705289f, 0.33490676f, -0.00710987f, 
    0.08177048f, 0.02372802f, 0.11017158f, 0.15032300f, 0.10412993f, 0.06961019f, 0.06034072f, -0.01306802f, 
    -0.03736589f, -0.04355552f, 0.02618355f, 0.14413419f, 0.08240352f, 0.09407800f, -0.07533483f, 0.00878874f, 
    -0.03667528f, -0.02093049f, -0.00283927f, -0.01713344f, -0.09648968f, 0.05486467f, 0.10414261f, -0.24209590f, 
    -0.04888677f, -0.05383410f, 0.01596316f, -0.07958120f, -0.01653598f, 0.07861540f, -0.02406676f, 0.04113494f, 
    0.28327537f, -0.10943266f, 0.01076668f, -0.03580812f, 0.10937873f, 0.05060080f, 0.12758200f, -0.04282762f, 
    0.02263355f, 0.05748554f, 0.07452863f, 0.10222925f, 0.27088237f, 0.01836824f, -0.11237261f, 0.06662770f, 
    0.03417069f, 0.01027570f, -0.05279975f, -0.00535247f, 0.06364568f, -0.06049186f, -0.12406095f, -0.01916313f, 
    0.22844908f, 0.13302484f, -0.09252862f, 0.14094378f, -0.08402403f, -0.09505260f, -0.03374105f, -0.02071293f, 
    -0.00475882f, -0.12127770f, 0.04179062f, 0.04715059f, -0.10983737f, 0.11718260f, -0.00845957f, 0.15051083f, 
    -0.05402045f, -0.10920622f, -0.03004186f, -0.07058509f, -0.05465557f, 0.03612809f, -0.07850575f, -0.10553052f, 
    -0.05099679f, 0.24159123f, -0.01683720f, -0.15905407f, -0.00010577f, 0.03011853f, -0.00989521f, 0.15589744f, 
    0.10203154f, 0.10886165f, 0.08793589f, -0.15354280f, 0.12594861f, 0.18091941f, 0.08262969f, 0.20453693f, 
    0.04401001f, -0.11408215f, -0.00675322f, 0.05620403f, 0.04319957f, -0.14625733f, 0.03769796f, -0.03488091f, 
    0.13145700f, 0.02905651f, -0.18908571f, 0.18292591f, 0.15509671f, 0.11497647f, 0.03804909f, 0.02694967f, 
    0.03968074f, 0.03575202f, 0.04764683f, 0.09656286f, -0.36372924f, -0.09750270f, -0.11148370f, -0.07668144f, 
    0.07969005f, -0.12267452f, -0.00197969f, 0.09682123f, 0.02141002f, -0.06539740f, -0.00655236f, -0.02181469f, 
    0.30661112f, -0.12154932f, -0.22391570f, 0.06419144f, 0.18603291f, 0.05671125f, 0.09311680f, -0.04838773f, 
    -0.06694940f, 0.07427236f, 0.02356513f, -0.03700494f, -0.27182734f, 0.08987891f, 0.11724702f, -0.23768629f, 
    0.00203461f, 0.05864999f, -0.03578717f, 0.01367702f, -0.05573262f, -0.01559641f, -0.02606112f, 0.05458657f, 
    0.26348397f, 0.20629166f, -0.06298676f, 0.02714639f, 0.13567092f, -0.01860501f, 0.14939444f, 0.23776256f, 
    0.05083815f, 0.03233463f, 0.19734883f, 0.20816509f, 0.04240524f, -0.04256788f, 0.07684759f, -0.26541123f, 
    0.05028808f, 0.06936868f, -0.12881312f, -0.06703389f, -0.09970549f, 0.07608973f, 0.00119757f, 0.01455850f, 
    0.15067239f, 0.20495391f, 0.04150204f, 0.18498941f, 0.05910118f, -0.04644791f, 0.03049920f, -0.01320405f, 
    0.08830071f, 0.03940967f, -0.06991140f, -0.01804379f, -0.07365319f, 0.03812369f, -0.16389449f, -0.05045995f, 
    0.01558174f, 0.20050466f, -0.01632060f, -0.06280641f, -0.03134971f, -0.01489679f, 0.00917500f, 0.06540720f, 
    -0.45777541f, 0.00942533f, -0.09442154f, -0.09495248f, 0.15126507f, -0.00263914f, 0.11042801f, 0.02714904f, 
    0.05236178f, -0.06728608f, 0.04602589f, -0.00214035f, -0.18638213f, -0.08674593f, 0.22189713f, 0.21169950f, 
    0.07800937f, 0.00842111f, 0.03656859f, 0.02192538f, 0.03307366f, -0.04252160f, 0.00416825f, 0.07650580f, 
    -0.17356007f, -0.07809718f, 0.00918133f, -0.17124738f, 0.08402814f, 0.02244907f, 0.09839771f, 0.04792595f, 
    0.00828536f, -0.08928837f, 0.00069208f, 0.06639656f, 0.09564433f, -0.03058264f, 0.00301660f, 0.07695421f, 
    -0.00085112f, 0.04204100f, 0.13071315f, 0.07413333f, 0.04244267f, 0.16240710f, -0.01125692f, -0.04548375f, 
    -0.06759126f, 0.17184030f, -0.15729849f, -0.04990801f, 0.11808855f, 0.05403340f, 0.08106670f, 0.17920709f, 
    0.00580245f, -0.02393598f, 0.08787823f, 0.09762291f, -0.27354571f, 0.02913959f, 0.21907596f, 0.04857092f, 
    -0.05869348f, -0.05846694f, 0.13214116f, 0.00277100f, -0.03970085f, -0.03620018f, -0.03511258f, -0.00227248f, 
    -0.12031952f, 0.11214440f, -0.20685782f, -0.16403444f, -0.06733178f, -0.13790506f, 0.05922172f, 0.09361736f, 
    0.10340678f, 0.08394518f, 0.10690838f, -0.07139059f, 0.08023169f, -0.11626092f, 0.00553376f, 0.13831006f, 
    -0.01344467f, 0.01026118f, -0.00392193f, -0.06971348f, 0.15507613f, 0.04480326f, 0.00259718f, 0.01222923f, 
    0.03034643f, 0.11458705f, -0.09450227f, 0.08087761f, 0.01497409f, 0.06067805f, 0.05742115f, -0.06988636f, 
    -0.00147695f, 0.09123642f, -0.08930353f, -0.03006443f, -0.46187350f, 0.12599452f, -0.00202932f, 0.05432523f, 
    0.03224408f, -0.11786290f, -0.08400140f, -0.22719200f, 0.07232556f, 0.11396619f, 0.07014493f, 0.02878493f, 
    0.16877712f, 0.17411286f, 0.04604074f, 0.23402053f, 0.06905989f, 0.12410239f, 0.06722957f, 0.02816621f, 
    -0.05627103f, -0.03411220f, 0.10279825f, -0.04902597f, -0.04655872f, -0.08198334f, 0.03529270f, -0.05355260f, 
    -0.01574055f, -0.05717732f, -0.05846326f, -0.05578016f, 0.03521750f, 0.04322065f, 0.02049477f, 0.08116235f, 
    -0.00724871f, 0.05819801f, -0.17734286f, -0.07022760f, 0.12038655f, -0.11444756f, -0.06844594f, 0.07477155f, 
    0.07154083f, 0.05320342f, -0.03274302f, 0.10940605f, -0.15434250f, 0.03684311f, -0.03123951f, 0.06421749f, 
    0.07231569f, 0.02860765f, 0.05459395f, -0.07877029f, 0.05700537f, 0.08234986f, 0.00205210f, 0.11039472f, 
    0.03281176f, -0.03618681f, 0.11969261f, -0.05753462f, -0.02929867f, 0.00353152f, -0.20628753f, 0.08021242f, 
    0.02209809f, 0.02294590f, 0.09203760f, 0.00771574f, -0.14230387f, 0.10077963f, 0.03958688f, 0.28851703f, 
    -0.00809895f, -0.02669707f, 0.07200710f, -0.03391610f, 0.05437374f, -0.01028580f, 0.03602524f, 0.06334187f, 
    0.10913866f, -0.13990115f, -0.02596594f, 0.00353444f, -0.10001337f, -0.09341853f, -0.01588185f, 0.07037377f, 
    -0.15531936f, 0.00746547f, -0.13521698f, 0.11066812f, -0.17236648f, -0.08988760f, -0.37168875f, 0.17975795f, 
    0.14173572f, -0.06360938f, -0.04373642f, -0.06009191f, 0.10353672f, -0.02471250f, -0.00717046f, -0.01701500f, 
    0.07888501f, -0.07474773f, -0.17004199f, 0.04090771f, -0.02805553f, -0.02364161f, -0.04898335f, 0.00528856f, 
    -0.02994034f, -0.05643634f, -0.03464694f, 0.01398247f, 0.31958881f, 0.11093063f, 0.02539978f, 0.17606518f, 
    -0.07745954f, -0.08414122f, 0.02754611f, 0.03916756f, 0.01904615f, 0.01096588f, -0.05227788f, 0.00982814f, 
    -0.04923391f, 0.01690613f, 0.02597351f, 0.11396215f, -0.05708175f, 0.00946524f, 0.07000322f, 0.20892553f, 
    -0.01858871f, 0.11209009f, 0.12436902f, 0.00548535f, -0.00632278f, -0.10526428f, 0.36296651f, 0.01799743f, 
    -0.00840477f, 0.02071561f, 0.09895584f, -0.03214192f, 0.05920614f, -0.03617913f, -0.06745639f, -0.10517112f, 
    -0.02427368f, 0.13976920f, 0.09674510f, -0.01678568f, -0.09545084f, 0.03446280f, 0.11246082f, 0.00230626f, 
    -0.02151761f, -0.02092331f, 0.02662360f, 0.03653080f, 0.24857043f, 0.00633119f, -0.01522768f, 0.08050046f, 
    -0.03791041f, 0.01077809f, 0.06924246f, -0.06992853f, -0.05493987f, 0.07929160f, 0.02554783f, -0.12825584f, 
    -0.01348300f, 0.05605681f, 0.04714035f, -0.01775254f, -0.00731633f, -0.04262620f, 0.01196240f, -0.05172149f, 
    -0.04923027f, 0.05908763f, -0.01063922f, 0.02932091f, 0.05115728f, -0.05862503f, -0.03004429f, -0.06217329f, 
    0.01632822f, 0.00277461f, 0.03967418f, -0.01494049f, -0.02585719f, -0.06390427f, 0.05604024f, -0.01381045f, 
    -0.01371947f, 0.02332014f, -0.02937012f, -0.04025828f, -0.00252161f, -0.06848340f, 0.04219278f, 0.01066151f, 
    0.04574978f, 0.01662697f, -0.05626224f, 0.01972496f, -0.06471676f, -0.03015510f, 0.02557160f, -0.04407373f, 
    -0.06192052f, -0.07572194f, -0.00139529f, 0.02588002f, -0.07316161f, 0.06180982f, -0.00376356f, -0.06996960f, 
    -0.00562135f, -0.00601146f, -0.03399972f, 0.00725105f, 0.00301649f, -0.01521101f, 0.04165316f, -0.01652966f, 
    0.04776552f, 0.01446154f, -0.04505439f, 0.00715093f, -0.07372052f, 0.03016316f, -0.03146175f, 0.00873752f, 
    0.03359289f, -0.01471011f, -0.07624536f, 0.01750465f, -0.00401578f, -0.07608426f, 0.03272920f, -0.00607585f, 
    -0.03221766f, -0.06562004f, 0.02793031f, 0.05484360f, 0.03011066f, -0.06020948f, -0.06723617f, 0.01028544f, 
    -0.04559381f, -0.06838599f, 0.04928852f, -0.01608600f, 0.00958791f, -0.05775012f, 0.04965821f, -0.03160024f, 
    -0.07557198f, -0.03519708f, -0.02005471f, -0.00192398f, 0.04370460f, -0.03329798f, -0.07274536f, -0.01412834f, 
    0.02267900f, -0.03330588f, 0.00829089f, -0.03977747f, -0.05507389f, -0.06561115f, 0.04571045f, -0.07708944f, 
    0.04462598f, -0.04803091f, -0.04948790f, -0.05474431f, -0.04779682f, 0.04577399f, 0.02622372f, -0.07490239f, 
    0.00360868f, -0.04931099f, 0.04354390f, -0.03253305f, -0.05988703f, 0.04810068f, -0.01184489f, 0.03929346f, 
    -0.02710344f, 0.04491242f, -0.00729084f, -0.00733710f, 0.00595142f, -0.05961535f, -0.06983031f, -0.02889651f, 
    -0.03822812f, 0.04634796f, 0.03031356f, 0.03025443f, -0.07712271f, -0.01712508f, -0.05674100f, -0.03547065f, 
    -0.03663568f, -0.02887955f, 0.01236935f, -0.00746280f, -0.04358855f, 0.04756609f, 0.04118637f, 0.05799157f, 
    -0.07229554f, 0.00094694f, 0.05681232f, -0.06294382f, -0.06413814f, -0.06478990f, 0.04827960f, 0.04396760f, 
    -0.05617923f, 0.02618599f, -0.03632117f, 0.02933356f, 0.05392860f, -0.00855724f, 0.01289625f, -0.07604368f, 
    -0.07144052f, 0.04363298f, -0.01586483f, -0.03256112f, -0.01603098f, -0.07281117f, 0.03300897f, 0.01773614f, 
    -0.07240433f, -0.00965066f, 0.04445215f, -0.04403713f, -0.06064215f, -0.01214581f, -0.03010461f, 0.06437949f, 
    0.02557442f, -0.01470992f, 0.02846074f, -0.03575306f, -0.01937371f, -0.03521955f, 0.00842921f, -0.01497301f, 
    -0.07611854f, 0.00029354f, 0.01893913f, 0.05851608f, 0.03480412f, -0.02047036f, -0.04878360f, 0.05018370f, 
    0.09746373f, 0.10541440f, 0.18333998f, 0.19289406f, -0.09329245f, 0.02867547f, -0.11539474f, 0.08164077f, 
    -0.01192974f, -0.13099548f, -0.08943098f, 0.07556909f, -0.05312786f, 0.00824782f, -0.02374355f, -0.13580632f, 
    0.07499851f, 0.00778300f, -0.12161935f, 0.04975493f, -0.00234679f, -0.07815801f, -0.02773779f, 0.01633227f, 
    0.18248881f, 0.12420657f, 0.02756016f, 0.05743749f, -0.04794338f, -0.08116214f, 0.04373448f, 0.04836355f, 
    -0.04409935f, 0.01066402f, -0.13833030f, -0.00532144f, 0.05885292f, 0.21540704f, 0.03096203f, -0.00495687f, 
    -0.02007495f, 0.05404209f, 0.01769594f, -0.11606052f, 0.01309645f, -0.04439227f, -0.09359195f, 0.00249283f, 
    -0.00641814f, -0.02477924f, 0.01884352f, 0.36503410f, -0.09430344f, 0.01376032f, -0.12709905f, 0.08261204f, 
    0.07979330f, -0.02900825f, -0.01699319f, -0.12510069f, 0.14357041f, -0.09557933f, -0.04240584f, 0.01953269f, 
    -0.03266222f, -0.04606177f, -0.10242517f, -0.02753718f, -0.05020748f, -0.03464377f, -0.00888329f, -0.01951580f, 
    0.10296568f, 0.15775760f, 0.15511686f, -0.13385408f, 0.07436572f, 0.09103525f, 0.00008716f, -0.00194037f, 
    0.06324095f, 0.04026647f, 0.01046634f, 0.16163191f, -0.09723926f, 0.06152322f, 0.25943008f, -0.06003908f, 
    0.05223419f, 0.21704778f, 0.07778178f, 0.19448411f, -0.10039847f, 0.02310575f, 0.18260834f, 0.12685429f, 
    -0.19407456f, 0.20681645f, 0.02953202f, -0.00345626f, 0.03479931f, 0.10479380f, -0.04934106f, -0.06029034f, 
    0.01864861f, -0.00196707f, 0.03611244f, -0.07093603f, 0.22911030f, -0.00617110f, 0.01944974f, 0.20916690f, 
    0.04288515f, 0.01291191f, -0.03745782f, -0.01925817f, 0.02919972f, 0.09412070f, -0.00548572f, 0.03567452f, 
    -0.31349438f, -0.05401187f, -0.01186954f, -0.10816357f, -0.10048763f, 0.01555488f, 0.09731556f, 0.14371726f, 
    0.07026046f, 0.02843899f, 0.12796968f, 0.06249797f, -0.04971490f, 0.11204006f, 0.11648556f, -0.10651708f, 
    0.24543124f, 0.06494954f, -0.03677140f, 0.15248573f, 0.04228427f, -0.10736797f, -0.06450098f, -0.02306064f, 
    -0.30420786f, 0.13451327f, 0.05711369f, -0.08487004f, 0.12660210f, 0.03021872f, 0.08938945f, -0.10527124f, 
    -0.07466284f, 0.09167489f, -0.11600395f, -0.10135113f, 0.12981614f, 0.22113070f, 0.08025865f, 0.00712387f, 
    -0.00642018f, -0.03561065f, -0.03138054f, -0.02990420f, -0.01439741f, -0.01480066f, 0.11151315f, 0.06037424f, 
    -0.18566117f, -0.00136545f, -0.14014348f, 0.05213551f, 0.12355460f, -0.01263642f, 0.03438425f, 0.11325508f, 
    0.10317492f, 0.09741227f, 0.11191369f, -0.04073969f, -0.14355581f, 0.04130798f, 0.07572030f, 0.14403643f, 
    0.04372967f, -0.06521808f, 0.20672652f, -0.09884554f, 0.02381062f, 0.18339302f, 0.04559706f, 0.19418208f, 
    -0.00781362f, -0.11572378f, -0.03997655f, 0.03241196f, 0.07280777f, 0.07490004f, -0.01635638f, -0.02912067f, 
    -0.09680378f, -0.16272509f, 0.03255069f, -0.13553141f, 0.37158683f, -0.06040994f, -0.27571821f, -0.17788656f, 
    0.05434066f, -0.06648742f, 0.05947113f, 0.11672757f, 0.03092905f, -0.14564657f, -0.06187776f, -0.03558271f, 
    0.02327002f, -0.05885215f, 0.14703584f, -0.09217701f, 0.02320631f, 0.06525355f, 0.09060215f, 0.03182330f, 
    0.02944649f, -0.02192368f, -0.07755677f, 0.03547083f, -0.07968449f, 0.05047503f, -0.05032293f, -0.07822089f, 
    0.05029715f, 0.02400131f, 0.06001849f, -0.08316937f, 0.03149618f, -0.00796140f, -0.02922734f, -0.06266823f, 
    -0.05305942f, -0.04195840f, -0.11280297f, -0.19973113f, -0.10103727f, -0.01707758f, -0.06809591f, -0.03182780f, 
    0.03607721f, -0.01819271f, -0.01897442f, -0.04800562f, 0.07664941f, -0.20786175f, -0.04162446f, -0.15060516f, 
    0.01923654f, 0.14943971f, -0.04309033f, -0.20461562f, -0.11244075f, 0.01849360f, 0.08596491f, -0.00839799f, 
    0.17669511f, 0.01402719f, 0.05357996f, 0.04213905f, -0.01705751f, 0.03280912f, 0.09786486f, -0.09213746f, 
    -0.03723350f, -0.03180305f, -0.09777144f, 0.12296991f, 0.27047169f, 0.14865606f, 0.20005651f, 0.00278834f, 
    0.09998972f, 0.15899879f, 0.09850322f, 0.15249810f, -0.08264165f, 0.05464205f, 0.09271741f, 0.12053477f, 
    -0.14340682f, 0.19862224f, -0.11844207f, 0.03496581f, 0.06722689f, 0.05969292f, 0.02461529f, 0.08246960f, 
    -0.05560591f, 0.01430876f, 0.03490436f, -0.14596756f, -0.19079451f, 0.17230491f, 0.30170351f, -0.14866571f, 
    -0.04616921f, 0.04342920f, 0.08677246f, -0.03616341f, 0.00398380f, 0.02584074f, 0.01574108f, 0.09734610f, 
    -0.01860338f, 0.06332933f, 0.09681530f, -0.11126548f, -0.05603482f, 0.07405935f, -0.00793082f, 0.03984065f, 
    0.11102533f, 0.06912043f, 0.07044387f, 0.06943922f, 0.12553842f, -0.07880706f, -0.02252181f, 0.01041838f, 
    0.05654132f, -0.08860797f, -0.01063660f, -0.04468061f, 0.03081864f, 0.03717368f, -0.10154416f, -0.11966828f, 
    0.27467331f, -0.18145327f, -0.04756141f, 0.12269596f, 0.01256256f, 0.06372461f, -0.04212525f, -0.05158359f, 
    0.01376000f, -0.02832275f, 0.02883632f, -0.03498952f, 0.07490993f, 0.06437701f, -0.20571049f, 0.11608561f, 
    -0.06244737f, -0.03288340f, 0.05721019f, -0.13683189f, -0.14859861f, 0.06431513f, 0.07769902f, 0.05955517f, 
    0.04352590f, 0.05932510f, -0.05237751f, 0.06862832f, 0.02970839f, 0.04766706f, -0.09402590f, 0.11681248f, 
    0.08927982f, 0.15932901f, 0.05892941f, -0.02101874f, -0.23053996f, 0.14914209f, 0.22180311f, 0.07261354f, 
    0.01273063f, -0.01448558f, 0.09024333f, 0.15624169f, 0.06717226f, -0.00364512f, -0.06235380f, 0.05157632f, 
    -0.09373830f, -0.02025357f, -0.22670615f, -0.09850867f, 0.01837343f, -0.05230806f, 0.10565407f, 0.03969884f, 
    0.07965939f, 0.08127672f, 0.06820278f, 0.05031997f, -0.17566092f, 0.08374228f, 0.20439456f, 0.01660777f, 
    0.07059494f, -0.10481108f, 0.00507570f, -0.20103237f, 0.01505986f, 0.10083279f, 0.12181810f, 0.10057219f, 
    -0.09878811f, 0.09222774f, 0.02444769f, -0.01964829f, 0.01717379f, 0.03624856f, -0.03499457f, -0.00717605f, 
    -0.01914405f, 0.10423771f, 0.08525406f, 0.02051549f, -0.07515308f, 0.00173543f, 0.01410446f, -0.09350434f, 
    0.12843849f, -0.04335130f, -0.08420140f, -0.00366743f, -0.00584904f, 0.07702044f, 0.11746391f, 0.02509788f, 
    0.06103635f, 0.02342956f, -0.03289047f, -0.04863435f, 0.06902396f, -0.05083520f, 0.13833918f, 0.15640199f, 
    0.04897238f, 0.11386392f, -0.01338683f, 0.14496551f, 0.12301716f, 0.03608852f, 0.09231357f, 0.03364690f, 
    0.13706900f, -0.02932030f, 0.02697305f, -0.02927274f, 0.08464168f, 0.17546210f, -0.02983276f, 0.13050345f, 
    0.16612758f, -0.24020898f, 0.06677159f, -0.12459599f, 0.02198045f, -0.08389482f, -0.13348415f, 0.15409537f, 
    0.04140420f, 0.07498385f, 0.09735804f, 0.01084599f, -0.22292370f, -0.28895143f, -0.20084625f, 0.04366729f, 
    -0.16285518f, -0.03846456f, -0.01708900f, -0.14592569f, -0.02531331f, 0.06493959f, -0.09029835f, -0.01945458f, 
    0.19414315f, -0.17100607f, 0.02346528f, -0.02253660f, -0.00644941f, -0.16376047f, 0.11246762f, 0.05444918f, 
    -0.02525422f, -0.00818475f, 0.03876011f, 0.05539059f, 0.06226346f, 0.17046274f, -0.25771025f, 0.09519257f, 
    0.19406760f, -0.05233356f, -0.05008989f, -0.04183509f, 0.14223602f, -0.09591320f, 0.07760087f, 0.12054305f, 
    -0.05227533f, -0.01290424f, -0.18777196f, 0.16926727f, 0.12796810f, 0.03241548f, 0.03100988f, 0.07916605f, 
    -0.08176351f, 0.07432021f, -0.02460874f, 0.06335236f, -0.07426567f, -0.10552265f, -0.02918899f, -0.05229422f, 
    -0.05763917f, -0.01474019f, 0.08658803f, -0.20047559f, 0.05254524f, 0.05645165f, 0.11458153f, 0.03076164f, 
    -0.12246713f, -0.02773523f, 0.07188234f, 0.01468211f, 0.05477135f, -0.05804766f, 0.09888969f, 0.01046855f, 
    0.17441829f, -0.01027899f, 0.13554467f, 0.05304280f, -0.19619283f, -0.08103587f, 0.00438783f, -0.06728619f, 
    0.06396747f, 0.11212905f, 0.08112128f, 0.06855170f, 0.17606992f, -0.11920363f, -0.00179731f, 0.06200657f, 
    -0.09348717f, -0.06070293f, 0.08763266f, 0.07760145f, -0.05800560f, 0.03291047f, 0.16475263f, -0.06749702f, 
    0.04406212f, 0.00327175f, -0.00723175f, 0.03385562f, 0.09242473f, -0.14494674f, -0.09587166f, -0.16704960f, 
    -0.09839667f, 0.09521070f, -0.09669615f, -0.01141628f, 0.03569324f, 0.13516091f, 0.00024968f, -0.12915912f, 
    0.00862612f, -0.10567373f, 0.01876023f, 0.35011870f, -0.10391004f, 0.00394615f, 0.05119283f, 0.21883695f, 
    0.03105743f, -0.01042589f, -0.00839466f, 0.02517775f, 0.12779717f, -0.14240585f, 0.05775255f, -0.00281405f, 
    -0.01526639f, 0.00689416f, 0.07174416f, -0.07141762f, 0.02966928f, -0.08735020f, -0.02292111f, -0.00411042f, 
    0.15187731f, 0.07955408f, -0.17509395f, -0.03653222f, 0.06414579f, -0.02968667f, 0.00858255f, -0.06252288f, 
    0.02468741f, -0.04713166f, 0.03146743f, -0.06893460f, 0.02406807f, 0.28961459f, -0.03822402f, -0.32793152f, 
    0.08583278f, 0.15746149f, 0.03275891f, -0.01808016f, -0.06190279f, 0.08104353f, 0.07277462f, -0.01026676f, 
    0.04550519f, -0.08013379f, -0.10388058f, 0.24323939f, -0.17657763f, -0.00513896f, 0.01237209f, 0.19263016f, 
    -0.14388421f, 0.03101835f, -0.04108122f, 0.02460910f, 0.39852864f, 0.07067712f, 0.09107905f, 0.05352468f, 
    -0.06464162f, 0.00715971f, -0.06505752f, 0.06332150f, -0.10619821f, -0.02038363f, 0.04321407f, -0.09290999f, 
    0.07282485f, 0.09009972f, 0.10514064f, -0.09362182f, 0.02988487f, -0.04337460f, 0.00059432f, 0.03764758f, 
    0.03721204f, 0.12765971f, -0.00622962f, -0.02872089f, -0.02080843f, 0.00562372f, -0.14604421f, 0.06163631f, 
    0.14664739f, 0.18706338f, 0.06993697f, 0.04344297f, -0.04629166f, 0.02864314f, -0.01785270f, -0.03875060f, 
    -0.22881436f, -0.16347292f, 0.20264331f, -0.21931790f, 0.04923890f, -0.02690870f, -0.01013618f, 0.00086035f, 
    0.08429562f, -0.02751229f, -0.07709388f, -0.11942603f, 0.17665651f, -0.06525283f, -0.00634641f, 0.30967376f, 
    0.07831018f, -0.02239186f, 0.00151738f, -0.00150359f, 0.13689783f, -0.06307440f, 0.12286685f, -0.01789596f, 
    -0.13378072f, 0.19436425f, -0.03159792f, -0.27396449f, 0.02716898f, -0.04691890f, 0.03231791f, -0.13737833f, 
    -0.00659040f, 0.04121673f, -0.02271433f, -0.00533344f, -0.08768749f, 0.06192127f, -0.01738194f, 0.11950576f, 
    0.09597303f, 0.17659515f, 0.05461393f, 0.08723403f, -0.04375248f, -0.05962520f, 0.10077360f, -0.03143626f, 
    -0.19097561f, 0.12936953f, -0.06915474f, -0.13266438f, 0.05931591f, 0.03346331f, 0.01531046f, -0.07168437f, 
    0.10190206f, -0.03970793f, 0.02203471f, -0.03609930f, -0.01857826f, 0.00261064f, -0.10413475f, 0.01845217f, 
    0.05435572f, -0.05742406f, 0.00760751f, 0.00794511f, -0.00975695f, 0.00405061f, -0.06095465f, 0.05628781f, 
    -0.35020676f, -0.17931370f, -0.07809184f, -0.00870170f, 0.08593516f, 0.03429417f, 0.13717169f, 0.01464948f, 
    0.10116709f, 0.13800195f, 0.07772792f, 0.04448418f, 0.15258007f, -0.00065881f, -0.05050366f, -0.05676443f, 
    0.04786017f, 0.01263522f, -0.05833971f, -0.15018158f, 0.11963651f, 0.09986833f, 0.05346235f, 0.00951412f, 
    -0.20114613f, -0.01881899f, -0.07413479f, -0.21291952f, 0.05799720f, -0.05668810f, 0.10167021f, -0.01324706f, 
    -0.01815453f, 0.10766078f, 0.02213115f, -0.01415799f, 0.12643631f, -0.08971244f, 0.01868287f, 0.15005496f, 
    -0.05625939f, -0.06162963f, -0.02165800f, -0.12104103f, 0.06087033f, 0.16581677f, 0.11581492f, 0.05350079f, 
    0.05155493f, 0.13190281f, -0.02413552f, 0.05747241f, 0.04232968f, 0.02792973f, 0.11708022f, 0.09692237f, 
    0.08977363f, -0.05093520f, 0.12293782f, -0.02951214f, 0.18181190f, -0.20632145f, -0.06467201f, 0.20287654f, 
    -0.02123385f, -0.02181612f, -0.06573936f, 0.11811567f, 0.07411842f, -0.00312091f, 0.04176222f, 0.04176296f, 
    -0.08222196f, -0.08966357f, -0.05548196f, -0.16703014f, 0.03033046f, -0.01928551f, -0.09116940f, -0.00369253f, 
    -0.02811075f, -0.00637216f, -0.07521935f, 0.19295530f, 0.14996541f, -0.04355377f, -0.04884841f, 0.19178894f, 
    -0.05680316f, -0.06272646f, 0.00426476f, 0.04324097f, 0.09255777f, 0.01593190f, -0.03372931f, 0.06147021f, 
    -0.28518894f, -0.05289914f, 0.07721734f, 0.18729518f, 0.00546559f, -0.01421981f, 0.02850308f, 0.13088565f, 
    -0.13649385f, -0.00352889f, 0.12658653f, -0.00481282f, -0.03794942f, 0.05738277f, -0.07048588f, 0.17902528f, 
    0.00444597f, -0.14300027f, -0.04680997f, 0.00672277f, -0.00405968f, 0.01292145f, -0.07219870f, -0.00947824f, 
    0.23565704f, -0.20736405f, 0.05686091f, 0.11439970f, -0.10480624f, -0.03522740f, 0.00412498f, -0.12255266f, 
    -0.00422091f, 0.01894565f, -0.04660899f, 0.09658574f, 0.19389021f, -0.00676839f, -0.21627653f, -0.13594089f, 
    0.07096701f, 0.00508651f, -0.08871958f, 0.04336204f, 0.06045171f, 0.04730486f, 0.13235907f, 0.03380342f, 
    0.17029564f, -0.03019527f, 0.09002497f, 0.22439587f, 0.04080776f, -0.07737270f, -0.08505699f, -0.07178097f, 
    0.04138535f, 0.03459590f, -0.07448693f, -0.05863057f, -0.06666723f, -0.03706455f, -0.04117292f, 0.08553481f, 
    0.05508096f, 0.01146552f, 0.01849261f, -0.08210361f, -0.02624590f, 0.11705628f, 0.06518363f, 0.07230681f, 
    -0.12472273f, 0.04785958f, -0.07223128f, 0.08431156f, 0.02280777f, 0.06289783f, 0.05488192f, 0.03356666f, 
    0.07411547f, 0.02616261f, 0.07692104f, 0.03941882f, 0.08925388f, -0.10958514f, -0.06798731f, 0.07331808f, 
    0.03629022f, 0.01082414f, -0.06385542f, 0.08643010f, 0.11202324f, -0.01694572f, -0.02333570f, -0.12723520f, 
    -0.07435580f, 0.06351634f, 0.05455875f, 0.02555089f, 0.02072465f, 0.07009456f, -0.02464205f, 0.03598303f, 
    -0.18371539f, -0.01392261f, -0.04619731f, 0.02393367f, 0.19508229f, -0.06397107f, -0.08383591f, -0.15791775f, 
    0.14349049f, -0.03360714f, -0.08578108f, 0.01595252f, 0.06664553f, 0.02547852f, 0.17015798f, -0.10353656f, 
    0.08867827f, 0.10668997f, 0.08002566f, 0.05045939f, 0.03153695f, 0.08990139f, 0.04279054f, -0.05207928f, 
    0.02564790f, -0.05732402f, 0.07912779f, 0.01709322f, -0.15191309f, -0.00975666f, -0.14698775f, -0.06249643f, 
    -0.00828430f, -0.06536382f, -0.10262109f, -0.04631649f, 0.09594369f, -0.13125895f, -0.01113322f, 0.09186941f, 
    0.17899594f, 0.15623170f, 0.10088819f, 0.10535158f, -0.05943156f, 0.03124179f, -0.07535509f, 0.03336534f, 
    0.15191701f, 0.04431478f, 0.01927458f, -0.02935357f, -0.07232828f, -0.21480976f, -0.05237908f, 0.11704773f, 
    -0.05724908f, -0.13971996f, 0.01218257f, -0.06662371f, 0.07413055f, 0.02945409f, 0.01330297f, -0.01751399f, 
    -0.14612153f, -0.16318931f, -0.21105263f, 0.13237083f, 0.10250050f, -0.01874243f, -0.15725163f, 0.00866232f, 
    0.14799646f, 0.06903405f, 0.05788307f, -0.02058661f, -0.09120712f, -0.25836048f, -0.19729796f, -0.01116574f, 
    -0.04729518f, 0.03833887f, -0.07515415f, -0.07723140f, 0.03294731f, 0.10476151f, 0.07377448f, 0.06305733f, 
    0.11280971f, 0.13160759f, 0.07786690f, -0.14024414f, 0.06909714f, 0.14224179f, 0.06765673f, 0.06497820f, 
    0.10098822f, -0.04450482f, 0.09312616f, 0.10654069f, -0.24769725f, 0.01959051f, 0.18855913f, 0.07436572f, 
    -0.06132505f, -0.04872407f, 0.06290391f, 0.18998034f, -0.12506978f, 0.02276000f, 0.11771656f, 0.12921691f, 
    0.02769128f, 0.14984277f, -0.19475652f, 0.04928735f, -0.00615530f, 0.04260022f, -0.03642313f, -0.07095606f, 
    -0.00960015f, 0.06137796f, 0.01416626f, -0.04949336f, 0.15277857f, 0.09162402f, -0.15231213f, 0.12817970f, 
    0.06976375f, 0.02015922f, -0.05058848f, 0.02982121f, -0.00157442f, 0.07920393f, -0.02595586f, -0.11177535f, 
    -0.03093881f, -0.03642357f, -0.20692156f, -0.04179047f, -0.00044675f, -0.01062751f, -0.00004840f, -0.04128218f, 
    0.11274526f, -0.03457556f, 0.17944998f, -0.02920331f, 0.15088272f, 0.05274941f, 0.15331544f, -0.09162176f, 
    0.11170595f, -0.01869936f, 0.03157146f, -0.00551780f, -0.00523999f, 0.08558490f, -0.18108834f, 0.09127141f, 
    -0.11421970f, -0.15450926f, 0.05139403f, -0.02256783f, 0.12062864f, -0.12300240f, -0.00246616f, -0.11866436f, 
    0.03402820f, 0.11505695f, -0.02800402f, 0.00255388f, 0.00627748f, 0.17835952f, 0.18868871f, 0.07115129f, 
    -0.01776315f, 0.01876739f, -0.04497877f, -0.14814565f, 0.09018827f, 0.04925236f, -0.03955457f, 0.06926962f, 
    -0.03573634f, 0.06994763f, 0.01333216f, 0.03331599f, 0.16408861f, 0.01961461f, -0.09353935f, 0.15381674f, 
    0.00361891f, 0.03170853f, 0.10119093f, -0.03928228f, -0.19280368f, -0.02308160f, 0.17717920f, 0.23672371f, 
    -0.05583526f, -0.03109854f, 0.22604285f, 0.14153132f, -0.06998002f, 0.03558492f, 0.01805135f, -0.09637537f, 
    0.01715077f, 0.09068851f, -0.01613114f, -0.25377989f, 0.17326550f, 0.04580569f, -0.04080479f, -0.02819390f, 
    0.05871433f, 0.18561752f, 0.09861791f, -0.10254072f, 0.08194347f, 0.11514776f, 0.14818029f, 0.25230843f, 
    -0.07474814f, 0.04822962f, 0.01898866f, -0.17081502f, -0.01145937f, 0.05327592f, 0.05951048f, 0.08229250f, 
    -0.28416008f, 0.04014765f, 0.19828749f, 0.01505648f, -0.08073457f, 0.06974358f, 0.00013562f, 0.06764520f, 
    0.05511229f, 0.00930904f, 0.03973831f, 0.14605737f, 0.12797432f, -0.22246079f, -0.04661662f, 0.30627042f, 
    0.06250776f, -0.08092387f, -0.08103228f, 0.10003094f, 0.04429286f, 0.05075886f, 0.14222448f, -0.06833244f, 
    -0.05272058f, -0.09778008f, 0.03478394f, -0.17019959f, 0.04095484f, 0.06203752f, 0.03770134f, -0.10085357f, 
    0.09611110f, 0.11316728f, -0.12232228f, -0.05152996f, -0.10560115f, 0.01922641f, -0.04846837f, 0.21875542f, 
    0.06453730f, 0.09955427f, 0.07591750f, -0.04183756f, 0.08981632f, 0.17124677f, -0.08810522f, 0.02259986f, 
    0.13846651f, -0.27899787f, 0.04779803f, -0.04020394f, -0.01604133f, 0.06038249f, 0.02136699f, 0.06716977f, 
    -0.12877259f, -0.05034103f, -0.02061121f, -0.10470524f, 0.16551682f, -0.09071608f, 0.09446284f, -0.04844943f, 
    -0.11169870f, -0.08211048f, 0.01013435f, 0.06120690f, 0.12763833f, 0.05611162f, -0.01728533f, -0.07848137f, 
    0.49732342f, -0.10016514f, 0.04811100f, 0.05499600f, -0.16967461f, -0.10746977f, 0.04811723f, 0.03087330f, 
    -0.07819716f, 0.07220936f, -0.00106256f, 0.06061863f, 0.07896537f, 0.16093791f, -0.32073990f, -0.11264543f, 
    -0.03526305f, -0.06923670f, -0.05661229f, 0.01909338f, 0.05844267f, 0.05601653f, -0.03653948f, 0.03252037f, 
    0.21978652f, 0.11201376f, 0.06103731f, 0.12670508f, 0.07641836f, -0.11609476f, -0.14165805f, 0.02957021f, 
    -0.01149232f, -0.00612974f, -0.05293047f, -0.00590264f, 0.16414164f, 0.04579763f, 0.01520504f, -0.17804720f, 
    0.01101472f, -0.05411509f, -0.04803741f, -0.09046271f, -0.08272132f, -0.03054657f, 0.01002790f, 0.02705976f, 
    0.10870109f, -0.19019754f, 0.16264766f, 0.09923258f, -0.07581255f, -0.05918515f, -0.00453389f, 0.00884061f, 
    0.11868442f, 0.05873822f, -0.04178980f, 0.08145908f, 0.06934984f, -0.16508092f, -0.01634933f, -0.06831387f, 
    -0.00056937f, 0.13300143f, -0.02360509f, 0.03905026f, 0.13576902f, 0.05581269f, -0.00169177f, -0.10950116f, 
    0.22957067f, -0.06076259f, 0.22657110f, 0.11524557f, -0.03720338f, 0.16223018f, -0.05289001f, -0.10626660f, 
    -0.11807236f, -0.09561261f, 0.03162264f, -0.03325611f, 0.15403169f, 0.15318726f, 0.07376426f, -0.14237076f, 
    -0.05623781f, 0.13758551f, -0.04622344f, 0.16234156f, -0.08995067f, 0.01426249f, 0.00749160f, -0.02594452f, 
    -0.04254000f, -0.15553917f, -0.25463971f, 0.00119583f, 0.01241732f, 0.02492871f, 0.07269850f, 0.07272357f, 
    -0.04701431f, -0.01390478f, -0.00525046f, 0.05061282f, -0.29163045f, 0.27664918f, 0.27957830f, 0.00021240f, 
    0.07106638f, -0.03401474f, -0.10127757f, -0.18957537f, -0.03395483f, 0.07212742f, 0.10315785f, 0.10572027f, 
    -0.26484495f, -0.13372684f, -0.07002827f, 0.02018211f, 0.04947950f, -0.00078936f, 0.01179051f, -0.10365606f, 
    0.03711573f, -0.09273200f, 0.03257884f, -0.03591119f, 0.05605207f, 0.28077608f, 0.01707063f, 0.02184475f, 
    0.23785703f, 0.08883695f, -0.08826925f, -0.07465888f, 0.00586359f, 0.01367671f, 0.12630528f, 0.06986792f, 
    0.17640521f, 0.10842256f, -0.01376533f, 0.22912747f, -0.01832034f, 0.01900466f, 0.04667741f, -0.03151385f, 
    -0.02602808f, 0.06371016f, 0.05201462f, 0.00309948f, 0.19529320f, 0.36051649f, 0.03100219f, 0.16947137f, 
    0.00689323f, -0.02874487f, 0.04970557f, 0.09620700f, -0.00110296f, 0.09259044f, 0.00205701f, 0.12584339f, 
    0.10252578f, -0.21818756f, -0.09095957f, -0.31160101f, 0.12609558f, 0.08931563f, -0.15644950f, 0.01389605f, 
    0.06242990f, 0.17022873f, 0.09280719f, -0.04583666f, 0.01891587f, -0.31463057f, -0.16313641f, 0.02922388f, 
    -0.01621510f, 0.01784822f, 0.09295130f, -0.05546056f, -0.00669698f, -0.04423635f, -0.02566280f, -0.16007866f, 
    0.20231764f, -0.20524092f, 0.19144097f, -0.32918099f, 0.00792780f, -0.12058216f, -0.08603637f, 0.14043495f, 
    0.04306157f, 0.03165003f, -0.00670479f, 0.06603009f, 0.01218417f, -0.03475810f, -0.38113961f, 0.18155445f, 
    -0.00222290f, -0.02979608f, 0.09735668f, 0.07781749f, 0.06883865f, 0.04548927f, 0.05697812f, -0.09092703f, 
    0.25237527f, 0.03365662f, -0.20645474f, -0.16821128f, 0.11295098f, -0.07313599f, -0.05805679f, 0.03073095f, 
    0.06501453f, 0.05508536f, -0.02292069f, 0.03470207f, -0.03941147f, -0.18345729f, -0.27279451f, -0.13124856f, 
    0.01333265f, 0.08027910f, 0.12317069f, 0.02581323f, -0.05443398f, -0.11190028f, 0.09540174f, -0.02890758f, 
    0.32022774f, -0.13597696f, 0.07024021f, -0.08482286f, 0.00267547f, 0.05339827f, -0.00615088f, 0.06192670f, 
    -0.06212734f, 0.00188897f, -0.02595174f, 0.13159606f, -0.31551456f, -0.01074608f, 0.05026607f, -0.04994303f, 
    0.13295682f, 0.01830639f, 0.09405227f, 0.09501721f, 0.03265968f, -0.02778969f, -0.00206424f, 0.05776768f, 
    0.03216701f, -0.12289819f, 0.06230746f, -0.04547912f, -0.00470308f, 0.07731500f, 0.18149720f, -0.02478957f, 
    -0.00663734f, 0.02261915f, 0.10335463f, 0.04193217f, 0.08142058f, -0.07569178f, -0.09312394f, 0.02481080f, 
    -0.01324988f, 0.08649623f, -0.07702086f, -0.04062811f, -0.07723495f, 0.01671757f, 0.04926978f, 0.00388060f, 
    0.05865283f, -0.07857451f, 0.00248294f, 0.01149500f, -0.06002914f, 0.04921354f, -0.04607859f, -0.01264232f, 
    -0.11263305f, -0.05515528f, -0.12422080f, -0.10910548f, 0.43439028f, -0.23667856f, -0.16218089f, -0.23494318f, 
    -0.04070073f, -0.00292259f, 0.07941495f, 0.14028235f, -0.03833157f, -0.10665783f, -0.04511493f, -0.00449568f, 
    0.16901074f, 0.04663710f, 0.08465374f, -0.09255580f, -0.06915399f, 0.05403581f, 0.02499501f, -0.06621554f, 
    0.05748682f, 0.01984370f, -0.07489678f, 0.03204450f, -0.10319553f, 0.10160426f, -0.02750311f, -0.18728416f, 
    -0.03933775f, -0.07514533f, 0.01834445f, -0.15403055f, 0.05905218f, -0.21544822f, -0.13674541f, -0.04072719f, 
    0.00862640f, -0.09250007f, -0.20267047f, -0.05240301f, 0.06213774f, 0.07551458f, 0.06799529f, 0.02044308f, 
    -0.00894970f, -0.01823719f, 0.07652155f, -0.16933143f, 0.06758492f, -0.09987883f, 0.01956463f, 0.06272488f, 
    0.04390700f, 0.07995999f, -0.10490205f, -0.07555613f, -0.11518519f, -0.04076344f, -0.00841694f, -0.11138128f, 
    0.24816479f, -0.00970326f, 0.08961808f, -0.00071689f, -0.06289057f, 0.08255084f, 0.03635362f, -0.11713271f, 
    0.04939480f, 0.11888126f, 0.06865519f, 0.11572590f, 0.38296190f, 0.04966437f, 0.17953840f, -0.03551773f, 
    0.03137959f, 0.02262828f, 0.02277506f, 0.15814798f, -0.08178694f, 0.03813526f, 0.14491928f, 0.05706201f, 
    -0.15955472f, -0.00790691f, -0.01137114f, 0.03280709f, 0.07672912f, 0.06624697f, -0.11499751f, -0.09436668f, 
    -0.08989643f, -0.06700830f, 0.07921455f, 0.00074640f, 0.21401843f, -0.02793916f, 0.17746791f, 0.21195830f, 
    -0.03533277f, 0.09646056f, 0.00600032f, 0.11615430f, -0.02967930f, 0.13385758f, -0.05878530f, 0.09947785f, 
    -0.32952619f, 0.02157257f, -0.00376438f, -0.19712512f, 0.09075899f, 0.10403365f, -0.01255861f, 0.06406910f, 
    0.09836907f, -0.07156906f, 0.22942044f, 0.19405849f, 0.30660784f, 0.03888609f, 0.07308908f, 0.03964670f, 
    -0.07314150f, 0.00950476f, -0.16586792f, -0.08085654f, -0.06269988f, 0.02159146f, -0.19154198f, -0.04494489f, 
    0.43089968f, -0.09612239f, 0.15378557f, 0.17250885f, -0.13481781f, 0.05740766f, -0.00301266f, -0.00925303f, 
    -0.04149682f, 0.03029152f, -0.04865757f, 0.02033702f, 0.00960489f, 0.12445389f, -0.21667324f, 0.03042377f, 
    0.03835462f, 0.02843189f, 0.01433139f, -0.10398196f, -0.10670080f, 0.01902003f, 0.00690423f, 0.21316992f, 
    0.27873388f, 0.00055135f, 0.03571955f, 0.10979976f, -0.02684433f, 0.04008463f, -0.03644521f, 0.03841189f, 
    0.00072735f, 0.19808540f, 0.10435732f, 0.01697857f, -0.01479943f, 0.15031807f, 0.18455534f, 0.02843402f, 
    0.00959578f, -0.12284964f, 0.00083613f, 0.09515345f, 0.08053409f, 0.02545428f, -0.06228492f, 0.18044597f, 
    -0.03429222f, 0.03183604f, 0.05954309f, -0.05445211f, -0.06609537f, -0.04027566f, -0.02249988f, 0.02010212f, 
    -0.03592451f, -0.03640043f, -0.08300655f, 0.01142291f, -0.03884203f, 0.03338174f, 0.01175100f, -0.09527978f, 
    -0.08275259f, -0.07212931f, -0.07505169f, 0.04082720f, -0.06129243f, 0.02516342f, -0.01473665f, 0.02957522f, 
    -0.06178181f, 0.04147669f, 0.05759783f, -0.03375920f, -0.03629442f, 0.04822855f, 0.01133230f, 0.04551206f, 
    0.02056082f, -0.05446734f, -0.02978635f, 0.03155795f, 0.06121598f, -0.07942462f, 0.04445424f, 0.01566545f, 
    -0.02315044f, -0.00211838f, -0.00470908f, -0.01808926f, -0.04813210f, -0.01187341f, -0.05304734f, 0.01644899f, 
    -0.01929922f, -0.05204290f, -0.02504879f, -0.00193028f, -0.06036514f, -0.06181028f, 0.01130278f, 0.04643826f, 
    -0.04001784f, -0.03091771f, 0.04303376f, 0.03333117f, 0.02783676f, -0.00824961f, -0.00671017f, 0.04292728f, 
    -0.07630428f, 0.03572124f, -0.01796190f, -0.01809680f, -0.05999493f, -0.02551486f, 0.05295392f, -0.05414242f, 
    -0.06845851f, -0.01071613f, -0.06535088f, -0.05636029f, 0.04036499f, -0.06113016f, -0.01265275f, -0.04554841f, 
    0.03960639f, 0.00929707f, -0.03893398f, -0.03705477f, -0.00304846f, -0.05952478f, -0.02323611f, -0.04333464f, 
    -0.07690578f, -0.05117361f, 0.04459540f, 0.04595098f, -0.06808951f, 0.04443096f, -0.06117562f, -0.05996255f, 
    0.05149667f, -0.05989527f, 0.02123985f, -0.02605773f, -0.02923480f, -0.00326249f, 0.04428506f, -0.07962774f, 
    0.05448341f, -0.00167651f, 0.01478613f, -0.00054887f, -0.08103123f, 0.00336054f, -0.06621335f, -0.07614843f, 
    -0.04397108f, 0.03285581f, 0.04707828f, 0.00131909f, 0.06016740f, -0.08502030f, -0.07240455f, -0.00378378f, 
    -0.07898048f, 0.04185792f, 0.01699655f, 0.00217171f, 0.00977028f, -0.03142731f, 0.02939003f, 0.02651398f, 
    0.01992906f, -0.01186385f, 0.02411718f, -0.00071998f, -0.00290272f, -0.01780270f, 0.05492365f, 0.01703016f, 
    0.01078354f, 0.05098538f, -0.00125413f, 0.00961993f, 0.02406908f, 0.04354967f, -0.05285161f, -0.06740758f, 
    0.02799889f, -0.06049612f, 0.04444483f, -0.02584927f, -0.01260971f, -0.02582908f, -0.00218810f, 0.02122953f, 
    0.05130762f, 0.05745568f, 0.01714192f, -0.00780597f, 0.05887539f, -0.02885049f, 0.01462903f, -0.06705506f, 
    -0.02021515f, 0.04531112f, -0.04243094f, -0.06731220f, -0.04497145f, -0.04713925f, 0.04262348f, -0.03366233f, 
    -0.04855866f, 0.04045366f, 0.05013603f, -0.05547898f, -0.06479172f, 0.06078326f, -0.01297748f, -0.03308407f, 
    -0.03157616f, 0.04005333f, -0.01079180f, -0.04946858f, -0.04264439f, -0.04476513f, 0.06794103f, 0.04600214f, 
    0.01623582f, 0.01043751f, 0.01151197f, -0.06768345f, -0.00334310f, 0.04503116f, 0.02068234f, -0.05720062f, 
    0.01766641f, 0.02014705f, 0.02150110f, -0.04088181f, 0.05798647f, -0.02388331f, -0.07167222f, 0.02435199f, 
    -0.06665707f, 0.06459162f, -0.04083702f, -0.01640688f, -0.04540103f, -0.00583806f, 0.04570128f, -0.05452909f, 
    0.01845587f, 0.04393475f, -0.01381695f, -0.02374945f, 0.03632046f, -0.02911631f, 0.00362907f, -0.06523743f, 
    -0.07153554f, -0.01529614f, -0.00541642f, 0.02015452f, -0.02137268f, -0.02408534f, 0.03216007f, 0.06341837f, 
    -0.07212245f, -0.03804689f, 0.06428016f, -0.06109256f, -0.04492002f, -0.01619956f, 0.02592236f, -0.01795586f, 
    0.03780263f, -0.02805136f, -0.05819276f, -0.02602812f, 0.04049180f, 0.07006227f, -0.04265072f, 0.01929742f, 
    -0.05641012f, -0.06626635f, 0.01307707f, 0.02029831f, -0.03760229f, -0.04869567f, 0.03276365f, -0.05586442f, 
    -0.00737757f, 0.00980541f, -0.01117987f, -0.01110642f, 0.03878092f, -0.03863084f, 0.02023802f, 0.03431422f, 
    -0.01615819f, 0.05413388f, 0.00546438f, -0.04819141f, -0.03164871f, 0.02262497f, -0.02860746f, 0.02500837f, 
    -0.06244622f, -0.07052979f, 0.02950899f, -0.06609941f, -0.04185443f, 0.01219835f, 0.05284596f, 0.00009548f, 
    -0.05115893f, -0.03813212f, -0.04044355f, -0.01785457f, -0.00803680f, -0.04389274f, 0.01123903f, -0.02095040f, 
    -0.06998882f, -0.01736367f, -0.00345486f, -0.03541622f, -0.05919347f, -0.06260889f, 0.06612182f, -0.00774010f, 
    -0.03557279f, 0.01245901f, 0.03432625f, -0.00689640f, -0.05337782f, -0.02282183f, -0.01945825f, 0.02505733f, 
    0.04429281f, -0.04622231f, -0.00103496f, -0.03024579f, 0.01697346f, -0.00151979f, 0.00485315f, 0.04369551f, 
    0.03558744f, -0.07088012f, 0.03569464f, 0.00725372f, -0.04502974f, 0.05599204f, -0.00919596f, -0.06557340f, 
    -0.06363723f, -0.02212524f, 0.01228085f, 0.00710842f, -0.06262547f, -0.05765538f, -0.06658590f, 0.01244799f, 
    -0.03467543f, -0.02430201f, -0.04612233f, -0.04726945f, -0.04533649f, -0.03979507f, -0.06236352f, 0.06133344f, 
    0.00655958f, -0.02481553f, -0.04615268f, 0.03349420f, -0.05452582f, 0.00814908f, -0.00562686f, 0.06262463f, 
    0.00746502f, 0.02858741f, 0.01343295f, 0.02609857f, 0.01272074f, 0.06174334f, 0.03248455f, -0.04865721f, 
    -0.05056123f, 0.02202713f, 0.04041571f, -0.03230726f, 0.02408177f, -0.05463371f, 0.04468571f, 0.06221152f, 
    -0.06712250f, -0.06097466f, -0.03837229f, 0.03460002f, 0.05930166f, -0.01137507f, 0.00524852f, -0.01336748f, 
    -0.01995439f, 0.03140653f, -0.01405360f, 0.02972936f, -0.05310421f, -0.03005268f, 0.03331569f, -0.02914089f, 
    -0.00327383f, 0.03277118f, 0.02576998f, -0.02969527f, -0.03767041f, -0.03208527f, 0.04255711f, -0.06584776f, 
    0.02138777f, 0.01992881f, -0.00487051f, 0.00662940f, 0.04754783f, 0.01134134f, -0.03000909f, -0.00302312f, 
    -0.23989592f, -0.09589043f, -0.17922564f, -0.08579039f, -0.03337488f, -0.00619491f, 0.17034695f, -0.02740394f, 
    0.03082808f, -0.03574026f, 0.00547353f, 0.03209705f, 0.36898145f, 0.18445916f, 0.07847414f, -0.12605779f, 
    0.10791036f, -0.14592908f, -0.06312946f, -0.02599362f, 0.07615156f, 0.02715992f, -0.01175984f, 0.01001248f, 
    -0.02628459f, -0.06788194f, 0.01464463f, -0.12648958f, -0.01085086f, 0.00126995f, 0.15766600f, 0.00696297f, 
    -0.03999886f, 0.03570360f, 0.01379030f, -0.02704787f, 0.25991601f, 0.19414683f, -0.04374631f, 0.19222765f, 
    0.08197980f, 0.08602132f, 0.02153371f, 0.02363901f, 0.11811471f, 0.02972326f, -0.09535039f, 0.02474334f, 
    -0.09715714f, 0.05441524f, -0.05195693f, -0.11383922f, -0.06208698f, -0.05796448f, 0.04965500f, -0.02676499f, 
    -0.07428646f, 0.04072165f, 0.07038030f, -0.05113477f, 0.41646442f, 0.14839023f, 0.12468813f, 0.15198793f, 
    -0.03570281f, 0.07692283f, 0.07178088f, -0.01846089f, 0.13494422f, 0.05748914f, 0.05379908f, 0.06428417f, 
    -0.33223605f, 0.05683590f, -0.11857497f, -0.05166668f, -0.01520307f, -0.03156737f, -0.06052045f, -0.02690160f, 
    -0.01235986f, -0.00713949f, 0.05366495f, 0.15495931f, -0.21839434f, -0.28564408f, -0.12993878f, 0.10701508f, 
    0.03623553f, -0.03037509f, -0.05223996f, -0.12191228f, 0.03498400f, 0.04537002f, -0.07642387f, -0.10846345f, 
    0.21617924f, -0.05414669f, 0.07886750f, 0.11164393f, 0.00702271f, 0.02949550f, 0.02148971f, -0.01041177f, 
    0.02841800f, 0.05366374f, -0.07998109f, 0.04411712f, 0.05727831f, -0.11875535f, -0.04949464f, -0.10410175f, 
    0.19551688f, 0.07305923f, 0.02419048f, -0.14062984f, 0.01273371f, 0.02424538f, 0.10549083f, 0.04152409f, 
    0.13229036f, 0.00540392f, 0.05013372f, 0.17617081f, 0.17269337f, 0.02259793f, 0.11512135f, 0.05019871f, 
    0.14394358f, 0.07665502f, 0.09299480f, 0.03534272f, -0.21151263f, 0.09102010f, -0.06186277f, 0.06566702f, 
    -0.00463168f, 0.01251874f, 0.11200805f, -0.05042130f, 0.04678037f, 0.09950116f, -0.09464718f, -0.06937333f, 
    -0.03718798f, 0.07409047f, -0.05227280f, 0.07363733f, -0.07313610f, 0.04397747f, 0.02184615f, -0.05158895f, 
    0.04430866f, -0.10443026f, 0.08385579f, 0.03499798f, -0.02422788f, 0.01714057f, -0.25645912f, 0.04626223f, 
    0.15978074f, 0.03050564f, -0.00634634f, -0.02992880f, 0.02845106f, -0.07527987f, -0.07918425f, 0.03990042f, 
    -0.14749786f, 0.03347548f, 0.00190970f, 0.04579608f, 0.10705191f, -0.03335930f, 0.18745477f, 0.07670087f, 
    -0.02796956f, -0.01696092f, 0.01338981f, 0.05751044f, -0.15744115f, -0.06080832f, 0.05482826f, -0.01190156f, 
    0.07884991f, -0.14191213f, -0.06438510f, 0.04689017f, 0.16504489f, 0.10116917f, 0.06898644f, -0.13088728f, 
    -0.11933380f, -0.03405461f, 0.19010863f, -0.08309136f, -0.11328276f, -0.09259837f, -0.02411231f, -0.00617756f, 
    -0.00040765f, -0.15672663f, 0.02466542f, -0.02545047f, 0.61765140f, -0.09719781f, -0.25131047f, -0.03862348f, 
    -0.02475464f, -0.00220859f, 0.10501778f, 0.13462211f, 0.03888962f, -0.09131937f, -0.06386891f, 0.06289367f, 
    0.06726802f, -0.02521365f, 0.22148006f, -0.05832891f, 0.03478125f, -0.01977832f, 0.14058223f, 0.10116003f, 
    -0.02320144f, -0.03818166f, -0.08190246f, 0.05313530f, 0.16652456f, -0.08109902f, -0.12621550f, 0.14234743f, 
    -0.05258684f, -0.02773868f, 0.00850477f, -0.01556678f, 0.05589477f, -0.10040647f, -0.07186951f, -0.11515316f, 
    -0.27786297f, -0.17946950f, 0.03777458f, -0.01768604f, -0.06090254f, 0.00183572f, -0.09953159f, 0.00961542f, 
    0.12324339f, -0.00547735f, 0.01733296f, -0.16608982f, 0.15123332f, -0.20898545f, -0.10315483f, -0.11900719f, 
    0.09273838f, 0.01904999f, 0.00303956f, -0.06240685f, -0.00847246f, -0.07487555f, 0.00617407f, -0.12863715f, 
    -0.10289323f, 0.08994147f, 0.05026421f, 0.14121240f, 0.02462596f, 0.00962847f, 0.17813194f, -0.05818989f, 
    0.02457350f, 0.02768983f, -0.00275856f, 0.15307648f, 0.06137975f, 0.24374136f, 0.29468223f, -0.02434519f, 
    0.00381145f, 0.11437262f, 0.00957105f, 0.10966305f, 0.01450762f, 0.01211094f, 0.04874958f, 0.07243595f, 
    -0.03095407f, 0.30746245f, -0.21573599f, 0.32909703f, 0.07455260f, 0.06443583f, -0.08163925f, -0.09017923f, 
    -0.00787821f, 0.02360154f, 0.07470255f, 0.02054646f, 0.25053900f, 0.21739267f, 0.25779924f, -0.17451139f, 
    0.00556003f, 0.05008234f, -0.04754739f, 0.08656699f, -0.03986955f, 0.16562557f, -0.04025315f, 0.11363681f, 
    -0.04009534f, 0.08508170f, 0.11686320f, 0.05768042f, -0.03398577f, 0.09649076f, -0.04674045f, 0.02457834f, 
    0.12662108f, 0.06294012f, 0.14310999f, 0.10809302f, -0.06073980f, 0.02855680f, 0.19319426f, 0.00749123f, 
    0.00592322f, -0.05761480f, -0.10501352f, 0.00436993f, 0.10746681f, 0.00142709f, -0.04274243f, -0.05372388f, 
    -0.13362388f, 0.07880315f, -0.17180935f, 0.08101401f, -0.04452736f, -0.02195075f, -0.05347203f, -0.12579730f, 
    -0.00969708f, 0.01421318f, -0.07054520f, -0.06961620f, 0.18137813f, 0.17768294f, -0.14710835f, 0.06454920f, 
    -0.02147933f, -0.04179690f, -0.08614171f, -0.04844239f, -0.16919254f, 0.04848175f, 0.00781907f, 0.08076546f, 
    0.05392190f, 0.13125281f, 0.01998140f, 0.07127625f, 0.15826014f, -0.05262331f, -0.07047364f, 0.05948212f, 
    -0.07847486f, 0.15360619f, 0.07409769f, -0.11140222f, -0.23086804f, 0.14313570f, 0.12849908f, -0.05021441f, 
    0.09822989f, -0.11473159f, 0.08912477f, 0.12504613f, 0.06810672f, -0.02291838f, 0.01787469f, 0.03769800f, 
    0.07534594f, 0.13313347f, 0.14763100f, 0.02198318f, -0.00015652f, 0.09376527f, -0.09344153f, 0.03616153f, 
    -0.09634544f, -0.04780832f, -0.11376694f, 0.00390513f, -0.03202245f, -0.03592814f, -0.03101842f, -0.21657695f, 
    0.04471259f, 0.05344660f, -0.09974029f, 0.14795306f, -0.05832348f, -0.02647963f, -0.07860513f, -0.09079537f, 
    0.19923003f, 0.02873693f, 0.09573199f, 0.15588856f, 0.06877396f, 0.03204251f, -0.02510570f, -0.05558014f, 
    0.01210323f, 0.06368090f, -0.10669255f, -0.01308732f, 0.00094544f, 0.20268731f, -0.03588102f, -0.03339191f, 
    0.01469926f, -0.02127582f, 0.01155100f, -0.02399600f, 0.09878977f, -0.11327105f, -0.09289825f, -0.01974513f, 
    0.01797312f, 0.12058944f, 0.07374703f, 0.18335833f, 0.07206432f, -0.02547405f, -0.11891104f, 0.01017718f, 
    0.11951970f, -0.05405824f, 0.16145013f, -0.19749068f, -0.15712541f, 0.06218731f, 0.01288768f, -0.02504364f, 
    0.05830045f, -0.05757171f, -0.03588166f, 0.00969004f, 0.05824121f, 0.01376527f, 0.00508511f, -0.00536624f, 
    0.12489211f, 0.18125948f, 0.02071686f, -0.03910743f, 0.04014839f, 0.10171093f, -0.01287768f, -0.09057961f, 
    0.11146874f, -0.08512577f, -0.07193005f, 0.11842475f, 0.02589673f, -0.03496744f, 0.28182539f, 0.00984091f, 
    -0.08515579f, 0.17524917f, 0.06161653f, 0.07913432f, -0.01484084f, 0.01977605f, 0.07010903f, 0.17988233f, 
    -0.03882820f, 0.02634429f, -0.02945329f, -0.07875464f, -0.00387822f, 0.02543927f, 0.11754259f, 0.10552245f, 
    -0.04508507f, -0.05447298f, 0.01288505f, -0.01080864f, -0.11024190f, -0.23271239f, -0.00661695f, 0.12427834f, 
    0.01538923f, 0.04488987f, 0.11916925f, -0.11963031f, -0.01716281f, -0.00049396f, -0.05119173f, 0.03817794f, 
    -0.19282970f, -0.17080338f, 0.06350549f, 0.02939890f, -0.08909153f, 0.01750145f, 0.15952793f, 0.13488139f, 
    0.10149232f, -0.00331758f, 0.18416268f, 0.04390602f, 0.11515883f, 0.19952509f, 0.18926562f, -0.03492777f, 
    0.19616322f, 0.05218577f, -0.02232075f, 0.13835917f, -0.05439238f, -0.07747283f, -0.13830903f, -0.07334785f, 
    -0.14932154f, 0.02645077f, 0.08778062f, -0.01391029f, 0.09311695f, -0.10092600f, 0.05611937f, -0.01772251f, 
    -0.09319818f, 0.05373673f, -0.01944483f, 0.00209048f, 0.21265128f, 0.23650259f, 0.22336522f, -0.10332181f, 
    0.02943628f, 0.06288360f, 0.06385712f, -0.11407485f, -0.13956146f, 0.00624827f, 0.06975489f, 0.00409093f, 
    0.05038532f, 0.10375682f, -0.17090438f, 0.07575747f, 0.17130260f, 0.15160955f, 0.00179846f, 0.08344205f, 
    0.01940195f, 0.03549934f, -0.03591666f, -0.03874139f, -0.12407253f, -0.04568311f, 0.06701138f, 0.22810583f, 
    -0.10042238f, -0.00810765f, 0.23618485f, -0.09104101f, -0.09842037f, -0.00156727f, -0.05568552f, 0.08177288f, 
    0.08782279f, 0.10771673f, -0.17191663f, -0.33286053f, 0.01856568f, 0.04168680f, 0.05366306f, -0.09561926f, 
    -0.10462242f, 0.04307633f, 0.01177208f, 0.00008221f, -0.10928103f, 0.03125399f, -0.10260148f, 0.03838350f, 
    0.15604593f, -0.02238689f, 0.07545610f, 0.17167746f, 0.00428652f, 0.08002722f, -0.03159965f, -0.11158024f, 
    0.07798270f, -0.21467677f, 0.14152005f, 0.08038882f, 0.08485693f, 0.11423159f, 0.22859517f, 0.04874893f, 
    -0.03261703f, 0.07281092f, -0.04475337f, 0.17060982f, -0.11251580f, -0.19960506f, 0.00099347f, 0.30004075f, 
    0.02533096f, -0.01083234f, 0.06975050f, 0.04956545f, 0.12512934f, -0.02101485f, -0.04489404f, -0.04307224f, 
    0.04611974f, 0.09027897f, 0.09288759f, -0.15883967f, 0.05932273f, -0.00690856f, -0.05739529f, -0.06361564f, 
    0.13757339f, -0.01520275f, 0.10399257f, -0.08836919f, -0.24703182f, -0.00444516f, -0.01537701f, -0.08838813f, 
    -0.05413787f, 0.03115186f, 0.02890872f, -0.08339030f, 0.14964457f, 0.07100131f, 0.04539843f, -0.00314270f, 
    -0.09362458f, -0.00108233f, -0.27982688f, 0.14213739f, -0.07195564f, 0.00866007f, 0.10079008f, 0.01040297f, 
    -0.00497211f, -0.07900403f, -0.00321798f, -0.01252916f, 0.10583780f, 0.11446569f, 0.06961963f, 0.00022738f, 
    -0.02620079f, -0.17815866f, -0.01645003f, 0.01781440f, 0.01431516f, -0.00743104f, 0.05331673f, -0.00186212f, 
    0.10808510f, 0.16820619f, -0.14084473f, 0.23008215f, 0.09131191f, 0.03855599f, -0.00836183f, 0.03327594f, 
    -0.01429677f, 0.07110263f, 0.02232381f, 0.13755441f, -0.33439973f, -0.08344490f, 0.25942031f, -0.33730415f, 
    -0.07612894f, 0.03258609f, -0.01204509f, -0.06148630f, -0.11870547f, 0.05334030f, -0.05358327f, 0.02374234f, 
    0.26920030f, -0.21327245f, 0.14421158f, 0.15997025f, 0.04223178f, 0.15850236f, 0.08456920f, 0.11226899f, 
    0.06148079f, 0.09159155f, 0.14980459f, 0.05643291f, 0.18193349f, -0.04010486f, -0.09905744f, 0.02654079f, 
    -0.13233511f, -0.02043236f, -0.08496793f, 0.00349844f, 0.07930173f, 0.04761868f, -0.09989756f, 0.13787892f, 
    0.29809994f, 0.11355092f, -0.19445610f, 0.21408287f, -0.08964019f, -0.02945149f, -0.06234360f, 0.04922141f, 
    -0.08501989f, 0.03537266f, 0.02010895f, -0.07907304f, 0.03931786f, -0.03461119f, 0.06673020f, 0.10063724f, 
    -0.15994948f, -0.00532647f, -0.02701173f, -0.05126815f, 0.00570193f, -0.02815114f, -0.03734414f, 0.01700504f, 
    0.28552580f, 0.29964438f, -0.14410152f, 0.02662324f, -0.07384540f, -0.05608683f, -0.18739231f, 0.19780500f, 
    -0.07039783f, 0.06416854f, -0.03515368f, -0.04884953f, -0.06780171f, 0.05429780f, 0.08979814f, 0.14978969f, 
    -0.04484376f, -0.17843732f, 0.08038793f, 0.16689074f, 0.00686401f, -0.17241539f, -0.04809710f, 0.00114726f, 
    0.01337085f, 0.04949789f, 0.00626015f, -0.01107131f, -0.07309981f, -0.03093372f, 0.01319178f, -0.01310960f, 
    0.03525607f, -0.05123817f, -0.07932214f, 0.06129573f, -0.02663659f, -0.02671588f, -0.04298591f, 0.02925189f, 
    0.02066047f, 0.04697918f, -0.02222713f, 0.01703964f, 0.03978510f, 0.04706969f, 0.02441452f, -0.05428651f, 
    -0.06756639f, 0.02899192f, 0.02948618f, -0.08182238f, -0.03306570f, -0.00741878f, -0.05551942f, -0.07404123f, 
    -0.02999631f, -0.06416876f, -0.06370243f, -0.02940599f, 0.03360667f, -0.03134031f, 0.03598390f, -0.01314083f, 
    -0.06466847f, -0.06075307f, 0.03311591f, -0.05880333f, -0.05397475f, -0.03464260f, -0.06558857f, 0.05616242f, 
    -0.07404165f, 0.01256847f, -0.01733400f, 0.00066657f, -0.02976018f, 0.02064831f, -0.06990962f, -0.04264950f, 
    0.05843747f, -0.00803242f, -0.05968061f, -0.07423481f, -0.04675423f, -0.01029564f, -0.08090473f, -0.05963461f, 
    -0.03250879f, -0.00426112f, -0.00047685f, -0.07336408f, 0.04650158f, 0.02103176f, 0.02507853f, 0.05647565f, 
    -0.04672383f, -0.01132469f, -0.01503924f, -0.07508548f, -0.03826955f, 0.02594873f, 0.05964568f, 0.02030947f, 
    -0.08176089f, 0.01817902f, -0.07879192f, -0.00002615f, -0.06630820f, 0.00436408f, -0.00167678f, -0.02845345f, 
    0.03615538f, 0.03345816f, -0.04932080f, -0.04766069f, -0.06853163f, 0.05852935f, 0.00998142f, -0.05378952f, 
    -0.01447426f, 0.06129941f, -0.03535759f, -0.04467422f, -0.04395214f, -0.01851303f, 0.02968836f, -0.06077604f, 
    -0.04415523f, -0.04672475f, -0.03565011f, -0.03519272f, -0.00348345f, -0.05522441f, -0.05563193f, 0.05448474f, 
    -0.07812416f, -0.00726372f, 0.00463245f, -0.03613666f, -0.04100148f, 0.03925243f, -0.06196071f, 0.02353754f, 
    -0.04456885f, 0.03991790f, 0.01506966f, -0.00245761f, -0.07460201f, 0.01735085f, 0.01163152f, -0.07660294f, 
    -0.01790084f, -0.03306376f, -0.02718721f, 0.03198781f, 0.01307228f, -0.03555620f, 0.03527945f, 0.05341578f, 
    -0.02333962f, 0.04354348f, -0.01327973f, 0.02953961f, -0.04410953f, -0.01087827f, 0.02653065f, -0.03304657f, 
    0.04981590f, -0.07050642f, 0.00623715f, -0.05976557f, 0.00454365f, -0.08007164f, 0.00976748f, -0.02457580f, 
    -0.03951011f, -0.06256882f, 0.03701599f, -0.01968705f, 0.01217982f, 0.01881930f, 0.04984365f, -0.04821117f, 
    0.01227298f, -0.02775848f, -0.06153829f, -0.05913325f, 0.03409395f, 0.00544328f, -0.04308802f, 0.01155604f, 
    -0.03952876f, 0.00928818f, 0.02520780f, -0.02540310f, -0.00408663f, -0.08233773f, -0.01951325f, -0.01032327f, 
    -0.04938347f, -0.00122200f, -0.03691237f, -0.06376031f, -0.07293946f, -0.03109409f, -0.01837721f, -0.00212301f, 
    0.01263556f, 0.05046595f, -0.02859157f, -0.06639580f, -0.05453042f, -0.04567597f, 0.00196020f, -0.00589660f, 
    -0.01511091f, 0.10856534f, 0.04461186f, -0.21311043f, 0.07514129f, -0.04262851f, -0.01240245f, -0.06323987f, 
    -0.06395842f, 0.12294571f, -0.00442035f, -0.05748243f, 0.18763542f, 0.11470348f, -0.01508234f, 0.21036218f, 
    -0.12495734f, 0.07979588f, 0.06069375f, 0.01372776f, -0.03166963f, 0.04049187f, -0.03745936f, -0.00591225f, 
    0.02020515f, 0.02354221f, 0.23436159f, 0.01162677f, 0.01162974f, 0.04452914f, 0.05110501f, 0.12240544f, 
    0.13755564f, 0.00973408f, -0.02910751f, 0.04912308f, 0.33593982f, -0.05178348f, 0.02614225f, 0.45072839f, 
    -0.04299925f, -0.03682799f, -0.00704022f, 0.00492615f, 0.05249640f, -0.04549117f, 0.14419857f, -0.00447930f, 
    -0.14053954f, -0.03204429f, 0.10168625f, 0.12463492f, 0.06764201f, 0.06927869f, -0.12782513f, -0.24803177f, 
    0.08123303f, 0.00146483f, -0.06615883f, -0.02291590f, -0.04894250f, 0.01379194f, -0.05985168f, 0.15456320f, 
    -0.10418770f, 0.05404536f, 0.10369983f, 0.11229350f, 0.05767231f, -0.04048727f, -0.05921250f, -0.07057669f, 
    -0.10545225f, 0.01085288f, -0.14419778f, 0.19796012f, -0.03782804f, 0.10316845f, 0.11305197f, -0.02862974f, 
    -0.04749193f, -0.03621336f, 0.03888160f, -0.06365143f, 0.33610421f, 0.30541399f, 0.38120154f, 0.11276363f, 
    0.05963017f, -0.01632957f, 0.08310788f, 0.21221885f, 0.04144999f, -0.05824052f, -0.02877967f, -0.02177361f, 
    0.37522718f, 0.00927496f, 0.08688384f, 0.20893608f, -0.09599700f, 0.14442736f, -0.13445212f, -0.00919989f, 
    -0.04940596f, 0.10191716f, 0.02683492f, -0.06559318f, 0.01144481f, 0.06586880f, -0.06879817f, -0.27463797f, 
    -0.15345918f, -0.05270608f, -0.05721380f, 0.06908206f, -0.08432595f, 0.09517198f, 0.01896342f, -0.04939504f, 
    0.38044459f, 0.06417771f, 0.18796633f, 0.19016051f, -0.04338549f, -0.01026850f, 0.05815436f, -0.02407068f, 
    0.05849830f, 0.01855971f, 0.06659532f, -0.11977830f, 0.20441374f, 0.03162372f, 0.00033022f, -0.09591619f, 
    0.16061763f, 0.04073224f, -0.03008390f, 0.04621487f, -0.02278716f, -0.02807898f, -0.06729376f, -0.04877611f, 
    -0.13485102f, -0.08581612f, 0.03637057f, 0.12824300f, -0.06684728f, 0.03745038f, -0.02608250f, 0.09028482f, 
    0.01553821f, 0.02068704f, 0.02589218f, -0.02976778f, 0.28864747f, 0.02191306f, 0.09058503f, 0.06728129f, 
    -0.06384244f, 0.05713328f, -0.12400293f, 0.00869240f, 0.04226689f, 0.07457142f, 0.08387659f, -0.12777427f, 
    0.13139512f, 0.09208968f, 0.04765363f, -0.03371479f, 0.06225578f, 0.05409510f, -0.05595890f, 0.10849205f, 
    -0.14417274f, 0.00743506f, -0.07953816f, 0.03146957f, 0.11537451f, 0.26530853f, 0.06199564f, 0.00639979f, 
    0.03810017f, -0.00687530f, 0.07545804f, 0.21118097f, -0.01669860f, -0.13719945f, 0.16234609f, 0.03013873f, 
    0.03479817f, 0.00466771f, -0.15866849f, 0.19166467f, -0.02908064f, -0.13950320f, -0.04447139f, -0.03200696f, 
    0.04063269f, -0.00659252f, 0.00460278f, 0.11953232f, 0.09193017f, 0.00150954f, -0.08570483f, -0.05082717f, 
    0.14870629f, -0.07900124f, 0.16172354f, -0.10460758f, 0.12005036f, -0.02582524f, -0.01523809f, 0.07870344f, 
    0.17106366f, 0.03753410f, -0.13668482f, 0.04725030f, 0.09012039f, 0.06403977f, 0.02836864f, -0.03566047f, 
    -0.03358833f, 0.08439697f, 0.06442900f, -0.09898351f, -0.21535560f, -0.03628775f, -0.00449494f, -0.25906941f, 
    -0.03409640f, -0.01615701f, -0.07790386f, -0.09171686f, -0.05147971f, 0.09619337f, 0.06095162f, 0.02544379f, 
    -0.00359519f, 0.02881067f, -0.01673435f, -0.09288002f, 0.03289746f, -0.12434529f, 0.00481508f, 0.14701726f, 
    -0.11442342f, 0.04525010f, -0.02210777f, 0.24055676f, 0.12640586f, -0.16031693f, 0.15389131f, -0.14584185f, 
    0.09295451f, -0.00224787f, -0.06457423f, -0.08279020f, -0.03906738f, 0.02907212f, -0.07297710f, -0.02205068f, 
    0.06431244f, 0.10553244f, 0.24433649f, 0.02057058f, 0.02137933f, -0.17339653f, -0.09752298f, 0.07838918f, 
    -0.06590215f, 0.04912629f, -0.05968402f, 0.10712539f, -0.14752945f, 0.24599196f, -0.15825389f, 0.05058431f, 
    0.06725553f, 0.10336139f, 0.06754792f, -0.12671103f, -0.13345169f, -0.00823481f, -0.06684603f, -0.02227367f, 
    -0.43710062f, 0.27922741f, -0.08289800f, 0.03595766f, 0.20299357f, -0.03018587f, 0.03467729f, -0.03132077f, 
    0.09436681f, -0.01069649f, 0.13769944f, -0.11285862f, -0.03413574f, 0.20369387f, 0.16084677f, 0.11075766f, 
    0.16012120f, 0.01310668f, -0.05601601f, 0.02835347f, 0.16745245f, -0.00264063f, 0.13445382f, 0.01124923f, 
    -0.12750159f, 0.09222951f, -0.03326130f, -0.09478499f, 0.11737169f, 0.08936764f, -0.08693305f, 0.00583615f, 
    -0.03045120f, -0.00070836f, -0.06198325f, 0.11908376f, -0.02470046f, -0.11758924f, -0.07204490f, 0.16453548f, 
    -0.03474536f, 0.07350448f, 0.13434762f, -0.03732380f, 0.02708457f, 0.02933235f, 0.07038857f, 0.10643228f, 
    -0.04480640f, 0.24216931f, -0.07320677f, -0.03800318f, 0.01271568f, 0.10549257f, 0.10691465f, -0.03080506f, 
    0.01479821f, 0.02758944f, 0.07928772f, -0.10969217f, -0.07980347f, -0.12832347f, -0.09935839f, 0.18482395f, 
    -0.08800615f, 0.05123325f, 0.09055138f, 0.04317050f, -0.11191271f, -0.03458250f, -0.03937568f, 0.09302128f, 
    -0.12317787f, 0.00904115f, -0.01643495f, -0.04526404f, -0.03735566f, -0.04739300f, 0.15058242f, -0.00914215f, 
    0.08575231f, -0.06072260f, 0.03280078f, -0.04618612f, -0.04913362f, 0.08386151f, 0.02453306f, 0.09722530f, 
    0.09818386f, 0.05108837f, -0.05278656f, -0.03322774f, 0.03028017f, 0.08648790f, -0.00004045f, -0.15560474f, 
    -0.02216416f, -0.09553957f, -0.14521596f, -0.13738786f, -0.03730044f, 0.14518867f, 0.02529809f, 0.01918335f, 
    0.03010316f, 0.14603657f, 0.04999835f, -0.11312714f, 0.14595227f, -0.09275727f, 0.14792889f, -0.03021401f, 
    -0.02976351f, -0.03019561f, -0.02560893f, 0.03350425f, 0.08243708f, 0.10324084f, 0.08387257f, -0.05304902f, 
    0.12986617f, -0.00557020f, -0.02406176f, 0.06826719f, 0.18293838f, 0.18514849f, 0.07235785f, 0.06697402f, 
    0.03039056f, -0.07500817f, 0.09404967f, 0.07103830f, 0.06320728f, 0.02789620f, 0.02320471f, -0.19445391f, 
    -0.11944623f, -0.05195401f, 0.02071369f, 0.11525396f, -0.00043156f, 0.00098553f, -0.18745740f, 0.10353292f, 
    0.11457151f, 0.04195382f, 0.02932944f, -0.24299136f, 0.04630173f, 0.05039321f, 0.04496235f, -0.12637831f, 
    -0.13129522f, -0.00994488f, 0.04131852f, 0.12284204f, -0.13671577f, 0.23389590f, 0.22407818f, 0.02306330f, 
    -0.05294240f, -0.07325535f, 0.10240728f, -0.02290194f, -0.04957012f, -0.06074473f, -0.02045076f, 0.01383664f, 
    -0.13798580f, 0.07394396f, -0.06163718f, 0.08900718f, -0.06931590f, 0.06685234f, 0.01979963f, -0.03846770f, 
    -0.08753324f, 0.08213961f, -0.02288541f, 0.06893408f, 0.11254891f, -0.05529945f, -0.22603926f, -0.00563071f, 
    0.07493083f, -0.04086808f, -0.10288066f, -0.01769889f, -0.01354906f, 0.06843269f, -0.12307273f, -0.06278519f, 
    -0.01626753f, -0.38914874f, 0.09474554f, 0.00498520f, -0.00577732f, 0.00672944f, -0.07851414f, 0.01595897f, 
    0.11562402f, -0.05404242f, 0.02276269f, 0.07574242f, -0.13003030f, -0.29084983f, 0.25839904f, 0.00109955f, 
    -0.09522124f, 0.04430452f, 0.09021496f, 0.05009088f, -0.00614532f, 0.07866907f, 0.00009626f, -0.09697337f, 
    0.09626815f, -0.05570566f, 0.06615752f, 0.05970957f, 0.15359466f, 0.12325048f, 0.09395689f, 0.00430446f, 
    0.07908271f, -0.03963912f, -0.01227645f, 0.03999698f, -0.05497987f, -0.00315310f, -0.11375074f, 0.16120400f, 
    -0.12760979f, 0.18685722f, -0.03842016f, -0.00264127f, -0.01586749f, -0.06665078f, 0.00258935f, -0.09703241f, 
    0.33867279f, 0.10638024f, -0.11668919f, 0.13202034f, -0.03618207f, 0.20742755f, -0.00466274f, 0.09277110f, 
    -0.00587951f, -0.13898098f, 0.10333963f, 0.01447642f, 0.04241371f, -0.09157282f, -0.08769301f, 0.03072014f, 
    0.06993660f, 0.06542941f, 0.03217791f, 0.04334935f, -0.11029324f, 0.05254492f, -0.12449548f, 0.14372326f, 
    0.22104269f, -0.00820170f, -0.10422016f, -0.00540120f, -0.13179104f, 0.01412148f, 0.07098585f, 0.03344558f, 
    -0.10451502f, -0.02324332f, -0.02473503f, 0.03255471f, 0.07106126f, -0.04401329f, -0.11023112f, -0.00611668f, 
    0.15149070f, -0.01705486f, -0.16020463f, 0.04602420f, 0.08077605f, -0.01351970f, 0.12721884f, 0.00719844f, 
    0.12970209f, -0.05606205f, 0.07378845f, 0.25474155f, -0.01320606f, -0.06501231f, 0.01935658f, 0.03225794f, 
    -0.02104613f, -0.13060176f, 0.11710282f, 0.09298656f, 0.06696932f, -0.07505950f, -0.12346432f, -0.19392860f, 
    0.14654250f, -0.07893521f, -0.00101724f, 0.12797944f, 0.02194040f, -0.13804477f, -0.06870378f, 0.02971556f, 
    0.08836022f, 0.02989399f, -0.11777624f, -0.00123958f, -0.02695183f, -0.08926533f, -0.00258808f, 0.04003833f, 
    0.00521262f, 0.05139152f, -0.09556923f, -0.05286420f, -0.05263541f, 0.03778286f, -0.01256389f, -0.10310158f, 
    0.07152356f, -0.04898213f, -0.01223235f, -0.06678883f, -0.04218955f, -0.04909487f, -0.04296346f, 0.01925204f, 
    -0.00351138f, -0.07472493f, -0.01952502f, 0.22193089f, 0.07824961f, -0.03180803f, -0.00165339f, 0.18573892f, 
    -0.00386982f, 0.01102412f, 0.01089204f, -0.02630104f, 0.17871407f, -0.17451385f, 0.02441389f, -0.15007916f, 
    0.07095695f, 0.05344342f, -0.13692811f, -0.03559046f, -0.05909543f, -0.02973063f, 0.03966479f, 0.02019221f, 
    -0.03712363f, 0.15412228f, 0.21049896f, -0.02883308f, 0.05359256f, -0.15096855f, 0.06376891f, 0.11298577f, 
    0.04611120f, 0.06540911f, -0.00405222f, 0.14621419f, -0.18161593f, -0.01460288f, 0.01845514f, -0.11742730f, 
    -0.03872237f, 0.16143969f, 0.08179311f, 0.03219095f, -0.11510147f, -0.05613275f, 0.06417297f, 0.10979353f, 
    -0.32821843f, 0.34379932f, -0.14927065f, -0.02405446f, 0.20396636f, 0.00486257f, 0.13072987f, -0.08131953f, 
    -0.00356960f, 0.01577908f, 0.08742279f, -0.03159944f, 0.09518442f, 0.20098642f, 0.23485450f, 0.09852412f, 
    0.07197964f, 0.08976612f, -0.08682364f, 0.03257345f, 0.10932928f, 0.05124030f, 0.01047208f, 0.01226620f, 
    -0.11906958f, 0.01976928f, -0.04578564f, -0.11481694f, 0.04061642f, 0.05499174f, 0.03008045f, -0.03123786f, 
    -0.00956099f, 0.11639261f, 0.05047882f, 0.03131530f, -0.19789761f, -0.14259855f, 0.12817015f, 0.03159883f, 
    0.06511571f, 0.02427743f, 0.04693485f, 0.07848299f, -0.00411188f, 0.00000899f, 0.05739507f, 0.05688659f, 
    -0.17454901f, 0.08552169f, -0.16935948f, -0.07201650f, 0.12768392f, 0.05543858f, 0.07406841f, -0.13064052f, 
    0.09598472f, 0.01935381f, -0.02682211f, -0.01398969f, -0.20509203f, 0.18534409f, -0.09138068f, 0.00112446f, 
    0.00884574f, -0.03628600f, 0.03788752f, -0.00336831f, 0.02262915f, -0.02960763f, 0.09632451f, 0.07265782f, 
    -0.19472826f, 0.10390895f, -0.11674479f, 0.00927561f, 0.11331978f, -0.02963200f, -0.05126807f, 0.03841084f, 
    0.17218064f, 0.00369256f, 0.04450018f, -0.04409132f, -0.16771410f, -0.11075585f, 0.00263071f, 0.12366968f, 
    0.02390462f, 0.05100968f, 0.10127958f, -0.04411253f, 0.01928659f, 0.01984816f, -0.05353180f, 0.00006401f, 
    0.02005787f, -0.06237744f, -0.21415871f, -0.05899420f, -0.07684796f, -0.01971808f, -0.00057695f, 0.08333298f, 
    0.08093045f, -0.02495785f, 0.04272734f, -0.08603644f, 0.03031951f, 0.01006282f, -0.06725085f, -0.18295904f, 
    0.16878246f, 0.01814157f, 0.11601935f, 0.17187682f, 0.05605439f, -0.01133269f, -0.05074467f, 0.08664495f, 
    0.08790524f, -0.23923917f, -0.03313522f, 0.05132029f, 0.18117602f, 0.12264890f, 0.13035309f, 0.08899019f, 
    -0.02191750f, 0.00903024f, 0.03922056f, -0.01004845f, -0.00249251f, 0.16022496f, 0.11920150f, -0.11093440f, 
    -0.02564327f, 0.02365960f, 0.05946420f, 0.02900936f, -0.06581498f, 0.04465765f, -0.09507403f, 0.10207119f, 
    0.07431544f, 0.14009933f, 0.20783585f, -0.11799457f, -0.04590902f, 0.00819542f, 0.01206643f, 0.04003768f, 
    0.06395916f, -0.08093432f, 0.12107828f, 0.14848150f, 0.07849646f, 0.11983126f, 0.26644272f, -0.19279173f, 
    -0.03424953f, 0.01685057f, -0.03179895f, 0.01615367f, -0.05497770f, -0.06583007f, 0.07054149f, 0.08693758f, 
    -0.24663197f, 0.19337288f, -0.21997751f, 0.08882059f, 0.06218735f, 0.09666000f, 0.13892122f, 0.01794917f, 
    -0.01587885f, 0.07211929f, -0.03806959f, 0.04725170f, -0.09957480f, 0.07089164f, -0.22869852f, -0.04337801f, 
    -0.00024525f, 0.06263525f, -0.06012677f, -0.08818164f, -0.01179916f, 0.02984688f, -0.09341319f, -0.06204911f, 
    -0.47784233f, 0.18723798f, -0.03433895f, 0.02971951f, 0.15118040f, 0.08740826f, 0.00275273f, 0.08830290f, 
    0.06171845f, -0.03202709f, 0.18223086f, 0.05626214f, -0.24580738f, -0.02138356f, 0.40111542f, -0.13831678f, 
    -0.01762412f, 0.01676162f, 0.11643711f, -0.07985358f, 0.05310523f, -0.01559310f, -0.01185530f, 0.05435050f, 
    0.12380925f, -0.10040440f, 0.15995266f, -0.09073536f, 0.05830345f, 0.07924727f, 0.05393366f, 0.09355245f, 
    0.09971000f, 0.06802964f, -0.02018169f, 0.02208636f, -0.21480905f, -0.09975810f, -0.06732780f, 0.13986784f, 
    0.01731583f, 0.07606736f, 0.04181276f, 0.10478504f, 0.02175169f, 0.12243923f, 0.02027391f, -0.02789269f, 
    0.05857540f, 0.18624349f, -0.21796280f, -0.09133705f, 0.02540329f, 0.09909161f, -0.10096904f, 0.08040157f, 
    -0.00763237f, -0.01645091f, 0.12110984f, 0.02850460f, 0.00700500f, 0.11868239f, -0.13552460f, 0.12221768f, 
    -0.07126657f, 0.00787080f, 0.05340991f, -0.06061439f, -0.04546454f, -0.03081826f, -0.05712525f, 0.00348025f, 
    -0.17268284f, 0.03058195f, -0.18137759f, -0.12353141f, 0.00703180f, -0.08430045f, 0.11821529f, 0.07055195f, 
    0.05343478f, 0.08221134f, 0.05708368f, 0.02848131f, -0.23563020f, -0.03276512f, 0.02323831f, 0.03283136f, 
    0.16951887f, -0.03053840f, -0.07717969f, -0.00414391f, 0.18195997f, -0.04255624f, -0.01587429f, 0.00218969f, 
    0.04523978f, -0.02995821f, -0.01893118f, -0.07463359f, -0.01432395f, -0.06971932f, -0.02063337f, -0.00793911f, 
    0.03643593f, -0.02356988f, -0.01578051f, -0.07302216f, 0.01251496f, -0.04676598f, -0.01359604f, -0.06983307f, 
    -0.04362487f, 0.00487369f, -0.00385443f, 0.04149655f, -0.03153165f, -0.04684516f, 0.06275646f, -0.06677032f, 
    0.01632827f, -0.07548524f, -0.03939212f, -0.03515499f, -0.01708188f, -0.04161350f, -0.05586626f, 0.06432734f, 
    -0.05981853f, -0.03218878f, 0.01724474f, -0.05833730f, -0.00483682f, 0.00841529f, -0.04693056f, -0.04642072f, 
    0.00577183f, -0.03203806f, -0.07631437f, 0.01703638f, 0.02927870f, 0.01906750f, 0.01165462f, -0.07404685f, 
    -0.03257639f, 0.04078908f, -0.05353739f, -0.00872906f, -0.05689250f, -0.04802974f, 0.04874904f, 0.01484339f, 
    0.05908372f, 0.00370443f, -0.04300839f, -0.01768044f, 0.03769666f, -0.07508286f, -0.01629293f, -0.01063350f, 
    0.06093095f, -0.02623540f, 0.06051466f, 0.02613681f, -0.02843976f, -0.05623240f, 0.06425437f, -0.04244469f, 
    -0.06221909f, -0.00987163f, 0.02222871f, 0.00419955f, 0.04017726f, -0.05149306f, 0.00383531f, -0.04903625f, 
    -0.04203602f, -0.03459791f, -0.01522195f, -0.05626416f, -0.01452543f, -0.02195282f, -0.07176068f, 0.02089839f, 
    -0.04036318f, 0.00363938f, -0.03893335f, 0.00632292f, 0.03788273f, 0.03193466f, 0.00113983f, -0.04425820f, 
    0.01522938f, -0.01395167f, -0.05375790f, 0.05955366f, -0.04319774f, 0.00814470f, 0.04812545f, -0.04757971f, 
    0.06235955f, 0.05695866f, 0.01096896f, 0.02666212f, 0.02654978f, 0.05572696f, 0.06166074f, 0.04277032f, 
    -0.01125772f, 0.04744788f, 0.04709037f, -0.07586677f, -0.06629096f, 0.01675675f, -0.02679180f, -0.06542925f, 
    -0.03754728f, -0.02697470f, -0.06672803f, -0.05216652f, -0.05005706f, -0.04291313f, -0.03301020f, 0.04035345f, 
    0.06025895f, 0.01842178f, 0.05705628f, -0.02108452f, -0.04116217f, -0.00071076f, -0.00898702f, -0.05573563f, 
    0.03420059f, 0.01103789f, -0.05328277f, 0.02817369f, -0.07411023f, -0.01154594f, -0.02593627f, 0.04446335f, 
    -0.06617130f, 0.02353179f, -0.00697453f, 0.06004186f, -0.00190499f, 0.05340312f, -0.06343785f, 0.03045846f, 
    -0.06505768f, -0.05761657f, 0.03032156f, -0.05750701f, -0.01135418f, 0.02028035f, 0.02778171f, 0.03291097f, 
    0.05073074f, 0.03877502f, -0.05749131f, 0.02702765f, -0.00888999f, 0.04286105f, -0.01320428f, -0.04168109f, 
    0.05236221f, -0.03583367f, -0.03935617f, -0.04718953f, -0.03552833f, 0.04062459f, -0.02843969f, 0.02788766f, 
    0.01091094f, 0.04159577f, 0.06579429f, -0.04016226f, -0.05407620f, 0.06096311f, -0.04933340f, 0.06082149f, 
    0.00292136f, -0.06861808f, 0.00907269f, -0.01514381f, 0.06135799f, 0.00464531f, 0.04231785f, -0.02523981f, 
    -0.11226245f, 0.08167589f, 0.12024528f, 0.11108603f, -0.09786777f, 0.10539686f, 0.07216185f, 0.14190727f, 
    0.05408137f, -0.00005272f, -0.11974780f, 0.06283063f, 0.00582694f, -0.09070399f, 0.10894192f, 0.05046967f, 
    -0.00300932f, -0.07115890f, -0.08797877f, -0.01207128f, -0.00524171f, -0.02061327f, -0.07178861f, 0.00488505f, 
    0.10057979f, 0.02527945f, -0.05811880f, -0.02160781f, -0.02946255f, -0.06435999f, 0.06344894f, 0.03441430f, 
    0.07063355f, 0.03334184f, 0.01154719f, 0.04994213f, 0.34780589f, 0.11003759f, -0.05872924f, 0.10468583f, 
    -0.07259703f, -0.05971222f, 0.00865585f, 0.01988384f, 0.16026044f, -0.05294544f, -0.08986536f, -0.07765727f, 
    -0.02344155f, -0.03924269f, 0.10285328f, 0.29204971f, -0.02116664f, 0.03116381f, -0.01568903f, 0.08701264f, 
    0.05680998f, -0.01682263f, -0.03642277f, -0.11648358f, 0.11604746f, 0.31112361f, -0.04860523f, 0.18988693f, 
    -0.11247726f, -0.02767207f, -0.00602414f, 0.19220412f, 0.08708820f, -0.02949594f, -0.07358581f, -0.03490506f, 
    -0.40974876f, 0.06756582f, 0.01644434f, 0.05028949f, -0.00523119f, 0.10801955f, 0.01432293f, 0.08803464f, 
    0.05272586f, -0.05928352f, 0.10166632f, 0.14289652f, -0.30827552f, -0.24444255f, -0.06739698f, -0.05935139f, 
    -0.13183023f, -0.05800854f, -0.05436245f, 0.05371254f, -0.07423890f, 0.01719672f, -0.03033008f, 0.09958750f, 
    0.28961998f, -0.37823820f, 0.10933498f, 0.03713992f, -0.04321494f, 0.00708046f, -0.09158348f, -0.08018768f, 
    0.08679971f, -0.04331480f, 0.04102471f, 0.07235112f, 0.37936810f, -0.34661448f, -0.12852158f, 0.04024302f, 
    -0.00762821f, -0.01628540f, 0.13588625f, -0.00522976f, 0.06211419f, -0.05270512f, -0.02929898f, -0.04528141f, 
    -0.17926866f, -0.20753475f, 0.03457503f, 0.03883865f, 0.05739679f, -0.04974524f, 0.12608483f, 0.01696192f, 
    0.06695228f, -0.09606827f, 0.08030836f, 0.07608909f, -0.25479487f, 0.24618240f, -0.01318562f, 0.02673557f, 
    0.10323524f, 0.04996399f, -0.06382265f, 0.09639581f, -0.08450828f, -0.05728903f, -0.00989457f, -0.03067730f, 
    -0.20732075f, 0.22896498f, 0.01983761f, -0.00105202f, 0.02737337f, -0.01441306f, 0.01364600f, -0.04968881f, 
    0.01704822f, -0.06477851f, 0.06841253f, 0.07662556f, 0.05279983f, 0.15547898f, 0.02183900f, -0.14352864f, 
    0.10795768f, 0.14507838f, 0.01143156f, -0.09172589f, 0.02862972f, 0.02665041f, 0.03614968f, 0.10000425f, 
    -0.08491153f, 0.03174577f, -0.19181578f, -0.12068946f, 0.09223036f, 0.02122494f, -0.00495502f, 0.12561993f, 
    -0.16945753f, 0.14800227f, -0.07313336f, 0.14679891f, 0.11942372f, -0.21324018f, -0.07424695f, -0.06708047f, 
    0.11189588f, -0.14440396f, 0.06377052f, -0.00731254f, 0.04386323f, 0.07211944f, 0.08784691f, 0.13420247f, 
    -0.14096834f, 0.01500063f, 0.20206349f, 0.41901317f, -0.13289709f, -0.09900332f, 0.04839316f, 0.01721390f, 
    -0.05191313f, -0.00311413f, -0.09293585f, 0.07728612f, 0.09612754f, -0.15239641f, -0.00300889f, 0.06074751f, 
    0.00671843f, -0.00259319f, -0.04267639f, -0.10122155f, 0.06607593f, 0.04591428f, -0.11008412f, -0.02325775f, 
    0.18392693f, 0.24641280f, -0.12224336f, 0.05040735f, 0.00554742f, -0.08128013f, -0.07013180f, -0.05116162f, 
    0.05993038f, -0.16124292f, -0.06709982f, -0.06174369f, 0.19911574f, 0.08010056f, 0.00792862f, -0.10420740f, 
    -0.00690691f, -0.02379503f, -0.03349045f, -0.01583622f, 0.06365544f, 0.03930035f, 0.08587975f, 0.00218984f, 
    -0.06875692f, -0.21105403f, -0.03211820f, 0.28895086f, -0.05854200f, 0.00776338f, -0.04234460f, 0.10525750f, 
    -0.12766463f, 0.01204007f, -0.09051056f, 0.10983690f, 0.33411846f, 0.06205928f, -0.07186134f, -0.01886790f, 
    -0.04153320f, -0.06951234f, 0.04433075f, 0.03265007f, 0.10387529f, -0.01388498f, 0.01793539f, -0.00476112f, 
    -0.16161597f, 0.08774025f, 0.12124963f, 0.17673756f, 0.10159647f, 0.00275881f, 0.03021042f, 0.01174269f, 
    -0.05646141f, -0.01332057f, 0.04199333f, -0.04343295f, -0.01999930f, 0.27349007f, 0.05141433f, 0.14542896f, 
    -0.00039573f, 0.08910444f, -0.00012828f, -0.00613397f, 0.00396740f, 0.00316635f, -0.01825880f, -0.12257066f, 
    -0.11780620f, -0.11630162f, 0.19229320f, 0.02209632f, 0.09389199f, 0.04254672f, -0.07657143f, -0.11697332f, 
    0.06373022f, -0.01356479f, 0.07701406f, -0.14973918f, 0.36516672f, -0.02510739f, -0.12768516f, 0.12236628f, 
    -0.07614626f, -0.02483013f, -0.02712962f, -0.01061968f, 0.05821098f, -0.05028198f, 0.11682502f, -0.04083294f, 
    -0.01362167f, 0.12447661f, 0.03330228f, -0.12078214f, -0.01667473f, -0.16002150f, -0.00784875f, -0.03288019f, 
    0.07692672f, -0.02677904f, -0.06034933f, -0.12109475f, 0.03429152f, 0.05015181f, 0.00934138f, 0.17356545f, 
    0.11864223f, 0.06246403f, 0.02243822f, 0.10122421f, -0.05418557f, -0.03033498f, -0.00773920f, 0.00362521f, 
    -0.39307949f, 0.26122800f, 0.00629198f, -0.00737369f, 0.03734937f, 0.05832284f, 0.00149185f, 0.06595606f, 
    0.07978585f, -0.01265525f, 0.00756458f, 0.01219250f, -0.08722478f, -0.08080419f, 0.00150317f, 0.02919239f, 
    0.03148320f, -0.01350201f, -0.12126360f, 0.00918110f, 0.01487601f, -0.00365565f, -0.05700582f, 0.04183996f, 
    -0.27801368f, 0.01885751f, 0.03522077f, 0.00585052f, 0.00611504f, -0.03798394f, 0.14394292f, 0.05744366f, 
    -0.01775054f, 0.07546454f, 0.00767902f, -0.03662689f, 0.39118907f, 0.01426120f, -0.16236316f, -0.09242893f, 
    0.02577038f, 0.04981998f, -0.03284887f, -0.12643078f, 0.13148671f, -0.04037760f, 0.10209800f, -0.08591465f, 
    -0.15136738f, 0.02409653f, -0.11158277f, -0.04579666f, -0.02200665f, -0.06857909f, 0.13400336f, -0.08094765f, 
    -0.02855654f, 0.11034950f, -0.01748944f, -0.05540085f, -0.04522311f, 0.14716326f, -0.06431890f, 0.26780501f, 
    -0.09395090f, 0.07391112f, 0.15350296f, -0.05965326f, 0.09640742f, 0.10994944f, -0.06510337f, -0.02212573f, 
    -0.01580710f, -0.21471010f, -0.08200657f, 0.00682107f, 0.00804990f, -0.02307644f, -0.01453846f, 0.04637884f, 
    0.00992373f, 0.02260357f, 0.05876973f, -0.01792127f, 0.03954715f, 0.00708130f, -0.06615052f, 0.18868548f, 
    0.07999058f, 0.05377574f, -0.09301730f, 0.01225922f, -0.07584970f, 0.21259476f, 0.17707059f, 0.02299367f, 
    -0.08185147f, -0.05380661f, 0.12055090f, 0.00736312f, 0.03207918f, 0.03405068f, -0.07487530f, -0.03292579f, 
    0.09771806f, 0.08995648f, 0.01475960f, 0.25594181f, 0.15083241f, 0.03644304f, -0.00332004f, -0.06203662f, 
    -0.00034333f, 0.07293387f, 0.00691324f, 0.06190103f, 0.07427715f, -0.00153053f, 0.02325765f, -0.07424109f, 
    -0.08447298f, -0.06234475f, -0.15479365f, 0.26274875f, 0.06684356f, -0.02154061f, 0.03714215f, 0.10301905f, 
    -0.05050130f, 0.07352312f, 0.00356811f, -0.08830599f, 0.30855432f, 0.37037408f, 0.11618504f, 0.13682406f, 
    0.04522428f, -0.02430792f, 0.08940022f, -0.04589344f, 0.12272990f, 0.03408183f, -0.06965153f, -0.06183091f, 
    0.12047178f, 0.20568280f, 0.08926798f, 0.16615641f, -0.11684295f, -0.02235070f, 0.04485109f, 0.06017465f, 
    -0.05518747f, 0.03237760f, -0.04960457f, -0.04281157f, -0.23852997f, 0.02594665f, 0.00745759f, -0.34496102f, 
    -0.11456767f, -0.07661554f, -0.08470155f, 0.01991261f, -0.02076623f, 0.01152385f, 0.12389308f, 0.02510001f, 
    0.43033099f, 0.14762692f, 0.15530026f, 0.07541773f, -0.00496055f, -0.02529958f, 0.03088370f, -0.01904895f, 
    -0.06877039f, 0.04424886f, -0.07073601f, -0.06606381f, 0.13153228f, -0.12419060f, -0.09957258f, 0.03970729f, 
    0.05439975f, -0.00343281f, -0.02736525f, 0.03897215f, 0.06143817f, 0.04146257f, 0.08058589f, 0.05820125f, 
    -0.11596185f, 0.09389127f, -0.09348145f, -0.05163772f, -0.10112505f, 0.04538716f, -0.07014394f, 0.15936379f, 
    0.07153714f, -0.02422648f, 0.01775567f, 0.00484356f, -0.07071256f, -0.20863017f, -0.04415129f, 0.13120741f, 
    -0.15849732f, 0.00336057f, -0.12464877f, 0.15263736f, 0.08509795f, 0.04140362f, -0.00140647f, -0.18029514f, 
    -0.22326338f, 0.13159184f, 0.07076379f, -0.15968966f, -0.08412767f, -0.01536669f, 0.05753471f, 0.09698602f, 
    -0.05027516f, -0.00975293f, -0.06343656f, -0.05183604f, 0.25317851f, 0.11284061f, 0.00274025f, -0.09598240f, 
    -0.06601746f, 0.06580256f, -0.01939761f, 0.11164364f, 0.12695897f, -0.04331679f, 0.05579045f, -0.17036326f, 
    -0.00797277f, 0.05566544f, 0.07741532f, -0.07641906f, -0.00856536f, -0.05528699f, 0.04826880f, -0.01348272f, 
    0.11540017f, 0.15419126f, -0.00522011f, 0.00399122f, 0.04289546f, -0.09796771f, 0.06657696f, 0.20647702f, 
    -0.10987099f, 0.01200593f, 0.18101300f, -0.05079530f, 0.07054374f, 0.14296979f, 0.00760112f, 0.13046704f, 
    -0.07377262f, -0.03989040f, -0.09965459f, -0.06114959f, 0.16330829f, -0.02989005f, 0.06643050f, 0.06016372f, 
    0.03172333f, -0.05620243f, 0.10008844f, 0.08277782f, 0.11723418f, -0.13405485f, 0.15184242f, -0.07955617f, 
    -0.03969000f, -0.05279331f, -0.06944014f, 0.15991442f, -0.10218374f, 0.16218252f, 0.17217165f, 0.14806081f, 
    -0.01443661f, 0.14890142f, 0.20427722f, 0.01460886f, 0.02104399f, 0.05562855f, 0.17821933f, -0.11931643f, 
    -0.08938211f, 0.03059201f, -0.10349564f, 0.31351978f, -0.24290405f, 0.04629373f, 0.09960809f, 0.00185714f, 
    0.00321942f, -0.08960894f, -0.00140118f, 0.05983381f, -0.02097489f, -0.05399347f, 0.00948904f, 0.05139883f, 
    0.05389486f, -0.17723338f, -0.07482211f, 0.26943570f, 0.05989044f, -0.08554583f, 0.08438610f, -0.01605934f, 
    -0.04186325f, -0.02091705f, 0.02794509f, -0.09826756f, 0.18088998f, 0.16928382f, -0.27736327f, -0.08605403f, 
    0.00895786f, 0.01070511f, -0.07293268f, -0.12133870f, 0.11432880f, 0.00359874f, -0.01936709f, -0.06068337f, 
    0.06456228f, -0.25750482f, 0.03128756f, 0.06662233f, -0.06245279f, -0.10624868f, 0.03455976f, -0.04190644f, 
    0.06892724f, 0.07514391f, 0.04209289f, -0.03005811f, 0.00115592f, 0.13998729f, -0.03953033f, -0.19957374f, 
    -0.17116901f, 0.02307897f, 0.04042719f, 0.01411034f, 0.04060945f, -0.09555139f, -0.02686549f, 0.14972241f, 
    0.07937268f, 0.04483860f, 0.03973641f, -0.00785576f, -0.08406101f, -0.01467796f, -0.18270552f, -0.15389541f, 
    -0.19087616f, -0.03130844f, -0.12795696f, -0.01925594f, -0.14688042f, 0.02080074f, -0.07894342f, 0.11956628f, 
    -0.02996444f, 0.03356113f, 0.12363076f, -0.00791849f, -0.06909749f, 0.08646859f, 0.30217406f, 0.07956108f, 
    -0.13681619f, 0.02876575f, -0.02089922f, -0.02720971f, 0.01995179f, 0.07268681f, -0.03446056f, 0.12778042f, 
    -0.00369339f, 0.08741617f, 0.09200671f, 0.06624725f, 0.00982952f, -0.10869471f, 0.06004192f, 0.02717915f, 
    -0.03328966f, 0.01675352f, -0.02432869f, 0.26793507f, 0.05930131f, 0.01703929f, -0.07790481f, -0.15895067f, 
    -0.00599803f, -0.10856628f, 0.00187522f, -0.17022768f, -0.19275019f, 0.04938532f, 0.08611786f, -0.08473957f, 
    -0.06650624f, 0.00265210f, 0.02203984f, -0.02442858f, 0.32715178f, 0.06540569f, -0.18171482f, -0.29143962f, 
    0.01728334f, 0.01189097f, -0.02926118f, 0.03449737f, 0.03196111f, -0.01188262f, 0.00902544f, 0.03828180f, 
    0.42913935f, 0.17001469f, 0.11695257f, 0.12716708f, 0.19042104f, -0.15373611f, -0.06775573f, 0.01629660f, 
    0.06629496f, 0.10253622f, -0.00891852f, 0.15286183f, -0.32564813f, 0.00272026f, 0.10981200f, 0.01743318f, 
    -0.14951491f, 0.09206952f, 0.04597065f, -0.05646802f, 0.00701678f, -0.08747877f, 0.02429822f, -0.08641273f, 
    0.13042317f, 0.27481198f, -0.15756667f, 0.10470382f, 0.17811696f, 0.08429326f, -0.05716708f, -0.12959163f, 
    0.04083213f, 0.04094512f, 0.09112038f, 0.02563332f, -0.23484388f, -0.11934894f, 0.31542188f, -0.27147675f, 
    -0.09637442f, -0.02182096f, 0.08345375f, -0.07421342f, -0.12173362f, -0.04742276f, 0.07067153f, -0.00337497f, 
    0.09384571f, 0.01522257f, -0.03293776f, 0.02130646f, -0.09657611f, 0.04974331f, -0.02947885f, -0.02393304f, 
    -0.09145451f, 0.00056026f, -0.03558053f, 0.13915521f, -0.43990687f, -0.00670056f, 0.14474282f, -0.15556972f, 
    -0.06423052f, -0.10027287f, -0.02500419f, -0.03248043f, -0.06824953f, 0.04594207f, -0.13858649f, 0.05959130f, 
    0.26374704f, 0.03283202f, 0.22223200f, 0.05730507f, 0.02779374f, -0.12162741f, -0.05648364f, -0.08583251f, 
    0.00422132f, -0.15638985f, 0.03525726f, -0.09310907f, 0.09339510f, 0.22745164f, -0.12851447f, 0.18109186f, 
    0.12917362f, 0.09724995f, 0.06148651f, -0.07538158f, 0.08002862f, -0.04637826f, 0.14643328f, 0.13714956f, 
    -0.17580210f, 0.09242623f, -0.01306897f, -0.18392032f, -0.04681267f, -0.09946386f, 0.03403279f, -0.09030177f, 
    0.04126496f, -0.11893136f, -0.06578771f, -0.04616811f, -0.07293957f, 0.03836656f, 0.06568125f, 0.37265548f, 
    -0.03281820f, -0.00014565f, -0.00565175f, 0.20652466f, -0.08163019f, 0.07683904f, 0.03807443f, 0.02070801f, 
    -0.15893897f, 0.17226839f, 0.12580982f, -0.04167282f, -0.18125685f, -0.01370718f, -0.21412677f, -0.14837205f, 
    -0.11429499f, -0.06719112f, -0.13628283f, -0.06685328f, 0.20946920f, -0.01669497f, 0.07063586f, 0.19710734f, 
    0.06571594f, -0.07676494f, -0.02975833f, -0.03144986f, -0.10957858f, 0.03251478f, 0.12367799f, 0.13380185f, 
    0.03805332f, -0.16775091f, 0.05298278f, -0.11357491f, 0.02411420f, 0.10128585f, -0.01762616f, -0.02157366f, 
    0.10786022f, 0.09572288f, -0.02276932f, 0.03184192f, 0.26129967f, -0.09442854f, 0.17226617f, 0.14640172f, 
    -0.16149992f, -0.05731740f, 0.03890116f, 0.09647626f, -0.02129769f, 0.10362776f, 0.03853648f, -0.05452239f, 
    0.26628670f, -0.05413800f, 0.00284864f, 0.15794899f, -0.03261479f, -0.04674343f, -0.04339188f, -0.12482457f, 
    0.10863706f, -0.13331853f, -0.05036097f, 0.20096865f, 0.23298484f, 0.07401406f, -0.02726750f, 0.06201417f, 
    0.08003315f, 0.22503483f, 0.04252356f, -0.15546091f, 0.01298675f, -0.00320632f, -0.05609354f, 0.06554283f, 
    0.05989209f, -0.05192290f, 0.21167876f, 0.09347136f, -0.18534413f, -0.06106573f, -0.03244128f, 0.09134466f, 
    0.03948908f, 0.00503484f, -0.06964235f, 0.13031228f, 0.24179138f, 0.27446130f, 0.21613605f, -0.03158374f, 
    -0.01047161f, 0.05393652f, 0.01290332f, 0.09826428f, -0.05708212f, -0.03361514f, 0.06378124f, -0.17433375f, 
    -0.07294524f, 0.16483550f, 0.02470563f, 0.19764185f, 0.07636201f, 0.03511119f, 0.04684076f, 0.01999668f, 
    -0.02392674f, -0.00338799f, 0.04550250f, 0.04453479f, 0.28805059f, 0.23481499f, 0.14677690f, 0.05213728f, 
    -0.07602488f, 0.09410038f, 0.17393403f, 0.00782648f, 0.06217188f, -0.07499367f, -0.00885309f, -0.04376987f, 
    -0.20919962f, -0.08046427f, 0.06474707f, 0.02656830f, -0.12498650f, -0.01446091f, -0.04444271f, -0.11646603f, 
    0.00086672f, -0.11171614f, 0.04494961f, -0.02281703f, -0.09135542f, 0.10829671f, 0.29292279f, 0.08161835f, 
    -0.04734555f, -0.09623799f, 0.01969147f, -0.01870681f, 0.00104778f, -0.01144331f, 0.07179844f, 0.03159538f, 
    -0.20824806f, 0.16865441f, -0.01602908f, -0.16704623f, -0.13307104f, -0.01393665f, 0.05003174f, -0.01059206f, 
    -0.16057438f, -0.02317887f, -0.08263426f, 0.06354918f, -0.24661538f, 0.14223273f, -0.08219986f, 0.12646325f, 
    0.09991933f, 0.11182962f, -0.09957937f, -0.00529385f, -0.03321252f, -0.04557245f, 0.15893331f, 0.02786065f, 
    0.11178920f, -0.01609398f, 0.01952885f, -0.15539505f, -0.10353240f, 0.08550681f, -0.00184752f, -0.04185299f, 
    -0.01506586f, -0.04301512f, -0.01105191f, 0.03934668f, 0.01984388f, -0.21411334f, 0.04366337f, 0.08206704f, 
    0.01039076f, -0.00895736f, 0.03106234f, 0.06904342f, -0.05442423f, 0.04574481f, 0.07871684f, -0.09388024f, 
    -0.10220768f, 0.10109348f, 0.19282253f, 0.05155125f, 0.03671801f, 0.04157159f, 0.10703421f, 0.01398720f, 
    0.08875878f, -0.03881330f, 0.10338275f, -0.01419788f, -0.12208764f, 0.10213692f, 0.06554181f, 0.08834656f, 
    0.13604560f, -0.02678078f, -0.07176261f, 0.05722842f, -0.01815319f, 0.03551791f, -0.05741998f, 0.07996129f, 
    -0.18924551f, 0.01700016f, 0.01996864f, -0.14988934f, -0.02396214f, 0.13710919f, -0.11136754f, -0.00570059f, 
    -0.05702831f, -0.00662321f, -0.01281289f, -0.02215247f, 0.40837750f, -0.11571334f, -0.00937843f, 0.03579220f, 
    -0.04534528f, 0.06129690f, 0.06887005f, 0.04350609f, -0.16229992f, -0.01668733f, 0.23240009f, 0.02398835f, 
    -0.06435098f, -0.02782341f, -0.11209112f, 0.07019330f, 0.02497707f, 0.01567555f, 0.08902004f, 0.09379870f, 
    -0.14682540f, -0.02847986f, -0.08496717f, 0.12862408f, -0.03246517f, 0.12605962f, 0.06555133f, 0.04610810f, 
    0.17247032f, 0.01260987f, 0.06835351f, -0.05404996f, -0.00987991f, 0.03582291f, 0.03199594f, 0.03643256f, 
    0.03210571f, 0.01605608f, 0.05044633f, 0.08945611f, -0.01870693f, 0.00702727f, 0.06840363f, 0.13937066f, 
    0.00772364f, 0.01629675f, 0.01805818f, 0.11260070f, 0.05066958f, 0.23736985f, 0.18531869f, 0.04415857f, 
    0.05986834f, 0.09042814f, 0.03540471f, 0.04581859f, -0.07537999f, -0.10987621f, 0.03448157f, 0.00413331f, 
    -0.13727678f, -0.13084760f, -0.07366860f, 0.09987724f, 0.08275056f, 0.00107420f, -0.05658379f, 0.03224672f, 
    0.01128702f, 0.09339193f, 0.00977778f, 0.01687474f, 0.06855156f, 0.16858414f, 0.15911497f, -0.01689115f, 
    0.02845185f, -0.00938306f, 0.07829135f, -0.05623536f, 0.02951801f, -0.00800877f, 0.01446413f, 0.05772239f, 
    -0.04648890f, 0.14428714f, 0.16777037f, 0.10715224f, -0.01726860f, 0.09483586f, 0.08553846f, 0.11992424f, 
    -0.00450343f, 0.03476823f, 0.12062403f, 0.07015024f, -0.10707052f, 0.01300886f, 0.28954208f, -0.07373887f, 
    0.01236625f, -0.01156079f, -0.07437650f, 0.02304007f, -0.08251946f, -0.00378195f, 0.04756677f, 0.03828587f, 
    -0.03328509f, 0.15120882f, -0.04125997f, -0.00959467f, 0.03524910f, -0.06064953f, 0.08876390f, 0.04459144f, 
    0.07643344f, 0.01074061f, 0.01637663f, 0.04821626f, -0.21342182f, 0.05457382f, -0.13366984f, -0.07451017f, 
    0.09320153f, 0.06119056f, -0.02648498f, -0.08084047f, 0.04058874f, -0.13520236f, 0.06490370f, 0.11110711f, 
    -0.23157370f, 0.27002934f, 0.04947982f, -0.17011809f, 0.10488304f, -0.04600831f, 0.12191737f, 0.03363597f, 
    -0.00404567f, -0.05024774f, 0.13135070f, -0.01738684f, -0.05870007f, -0.08975285f, 0.19457462f, 0.13682100f, 
    -0.03684660f, 0.06570990f, 0.04156358f, 0.00263619f, -0.01927033f, -0.05507715f, -0.03521082f, 0.00800661f, 
    -0.11951967f, 0.07057191f, 0.07526676f, -0.08620311f, -0.09829637f, 0.05419904f, 0.00491913f, 0.02769524f, 
    0.02543586f, 0.09984354f, -0.06110843f, 0.07819729f, -0.29443231f, -0.18590507f, -0.05206845f, -0.01234829f, 
    0.07853618f, 0.10298314f, 0.04220133f, 0.03691665f, 0.02848476f, 0.05912794f, 0.19353433f, -0.00455465f, 
    -0.34319234f, 0.07592503f, -0.05725637f, -0.26141825f, 0.14398979f, 0.03448731f, -0.01059755f, -0.05430565f, 
    -0.05751053f, 0.03806921f, -0.00686403f, -0.03576566f, 0.11849359f, -0.05972306f, -0.05381438f, 0.03132552f, 
    0.00757456f, -0.04774436f, 0.08775364f, 0.02685228f, 0.00206517f, -0.01324865f, 0.16721639f, 0.02755277f, 
    -0.12476132f, -0.11216719f, -0.14205228f, -0.09172656f, 0.05721492f, -0.01965257f, 0.12353145f, -0.02338094f, 
    0.04959302f, 0.08410066f, 0.03316333f, 0.02506915f, -0.20053405f, -0.04273301f, 0.00441809f, -0.02417170f, 
    0.13969743f, 0.11215745f, 0.08417932f, -0.09925420f, 0.12383942f, 0.09153531f, -0.12294687f, 0.03829990f, 
    0.17579836f, 0.18778963f, 0.22102074f, -0.09301154f, 0.08070928f, 0.05522102f, 0.00147440f, 0.11004176f, 
    0.13458441f, 0.04438439f, -0.04404597f, 0.13467284f, -0.66753864f, -0.09317961f, -0.02349526f, -0.04046872f, 
    0.05582524f, 0.12469290f, -0.07303432f, 0.02472260f, -0.03413559f, -0.05445262f, -0.03370632f, 0.13484874f, 
    0.05748964f, 0.13061303f, -0.04138034f, 0.12010558f, 0.01081672f, -0.06762484f, -0.03030271f, 0.10654213f, 
    0.01683239f, 0.10454939f, 0.01797242f, 0.08180047f, -0.16641340f, -0.33712333f, -0.04241252f, 0.07138141f, 
    0.05425587f, 0.06675269f, 0.05110772f, -0.05104077f, 0.02376452f, 0.01884697f, 0.12841026f, 0.02760633f, 
    0.12232088f, 0.15250568f, 0.12407444f, 0.21596250f, 0.15541267f, 0.05511598f, -0.05219617f, 0.03323562f, 
    0.12579077f, -0.05234948f, 0.03086312f, -0.05629651f, -0.57787389f, -0.11398119f, -0.06969567f, -0.13275801f, 
    0.14481543f, 0.05999212f, 0.06696426f, -0.05478762f, 0.11533941f, 0.08320582f, -0.03966010f, 0.00360855f, 
    0.15632726f, 0.11560406f, 0.04082957f, -0.06670234f, 0.03204801f, 0.11761956f, 0.02856953f, 0.17505914f, 
    0.07428307f, -0.04806431f, 0.12625305f, -0.01382787f, -0.26728719f, -0.14385425f, -0.00965567f, -0.08064812f, 
    -0.04026591f, -0.09094561f, -0.01469764f, 0.12323673f, -0.06344167f, -0.08476210f, 0.12536561f, 0.01026196f, 
    0.13313492f, 0.21894126f, -0.09502662f, -0.13195877f, 0.08855630f, -0.01589096f, 0.04913541f, -0.07147565f, 
    0.10183973f, -0.06974353f, 0.07283305f, 0.12755160f, 0.06813499f, -0.05336659f, 0.09359472f, 0.06216628f, 
    0.06598413f, -0.00496673f, 0.11123538f, 0.22774810f, -0.13208790f, -0.00713987f, -0.10490254f, -0.04211568f, 
    -0.02232406f, -0.13175569f, -0.15787488f, -0.03794533f, -0.06227262f, -0.06145000f, -0.09722356f, -0.06174470f, 
    -0.05308049f, 0.01938214f, 0.03250042f, 0.06117971f, -0.08195612f, 0.01381176f, 0.16172343f, -0.19151457f, 
    -0.07919431f, 0.01594980f, -0.01402778f, 0.12132590f, -0.06250174f, 0.08496111f, 0.07508378f, 0.11738063f, 
    -0.01831737f, 0.00275308f, 0.08561145f, 0.02002683f, 0.20054939f, 0.01159014f, 0.08248819f, -0.04031405f, 
    -0.14115697f, 0.04132837f, -0.07644339f, -0.03895979f, -0.04870733f, 0.05620284f, 0.37160003f, -0.16187184f, 
    0.05384171f, 0.11039774f, 0.09850607f, 0.06494932f, 0.12548892f, 0.00416300f, 0.08601574f, 0.10304745f, 
    0.12134444f, 0.08810769f, 0.01600516f, -0.03096430f, 0.02079927f, -0.02354526f, -0.22649901f, -0.06319204f, 
    -0.03725052f, -0.04590634f, 0.00344220f, -0.06405491f, -0.10998372f, -0.16207811f, -0.04618276f, 0.08650127f, 
    -0.10086527f, -0.05436687f, 0.10886868f, 0.12187316f, -0.05974445f, -0.05154174f, -0.08555114f, -0.00856945f, 
    0.19218028f, 0.21239422f, 0.02387619f, -0.01439143f, 0.16019493f, 0.08750458f, -0.08535764f, -0.03622712f, 
    0.09612044f, 0.03490989f, -0.11461975f, 0.13934146f, -0.45354626f, -0.31517914f, 0.00448692f, -0.01129051f, 
    0.00709837f, 0.05986808f, -0.05767751f, 0.01757066f, 0.02229738f, 0.16831155f, 0.04385259f, 0.08018223f, 
    0.16919971f, 0.05229742f, 0.02113866f, 0.00780977f, -0.03536447f, 0.02105064f, -0.00718860f, -0.11446169f, 
    0.02462939f, 0.05139574f, 0.06982759f, 0.08902744f, -0.36121646f, -0.31305972f, -0.09194784f, -0.23600620f, 
    0.00835989f, -0.04983275f, 0.01741547f, -0.00086866f, 0.05854949f, 0.08236671f, 0.01709850f, 0.15296280f, 
    0.28743154f, 0.13185996f, 0.08884743f, -0.07065268f, 0.20729525f, -0.00745296f, 0.00325038f, -0.01662020f, 
    -0.07989138f, 0.08175903f, 0.06921185f, -0.00949080f, -0.13417225f, 0.08540390f, -0.19641504f, 0.01234662f, 
    0.05650973f, -0.07386204f, -0.01958003f, 0.06191093f, -0.04313521f, 0.08701202f, 0.00850117f, 0.06932331f, 
    0.11714014f, -0.14008540f, 0.02222941f, 0.15740100f, 0.02270263f, 0.01054438f, -0.06402250f, 0.05248248f, 
    0.14385259f, 0.01172223f, 0.02469505f, -0.03313686f, 0.14999378f, 0.02697415f, -0.04919142f, -0.06764700f, 
    -0.16546945f, -0.17471445f, 0.06768212f, -0.06683299f, -0.00036356f, 0.01552479f, 0.03948024f, -0.02481592f, 
    0.01485431f, -0.37092519f, -0.18681577f, -0.00435081f, 0.08405130f, -0.00204523f, 0.04637559f, 0.08816674f, 
    0.03709399f, 0.06048056f, -0.07270645f, 0.03100647f, 0.07555810f, -0.05674255f, -0.10053489f, 0.12102804f, 
    -0.09795519f, 0.02260413f, -0.05784211f, 0.16605629f, -0.05669503f, 0.02213192f, -0.01023973f, -0.01029048f, 
    -0.08517287f, -0.25433946f, -0.26746675f, -0.07350935f, -0.02447271f, -0.01618741f, 0.06457287f, 0.04668835f, 
    0.01086094f, -0.03430104f, 0.09589466f, 0.05621221f, 0.13354596f, 0.16712686f, -0.03297853f, 0.02055628f, 
    -0.08180857f, 0.03241164f, 0.02225390f, -0.00372566f, 0.02195003f, 0.04517975f, -0.06575517f, 0.12276741f, 
    0.27060124f, 0.01897883f, 0.04638208f, 0.16908047f, -0.05922445f, -0.02446473f, -0.02192781f, 0.03418875f, 
    -0.00693478f, 0.05026713f, 0.07450473f, 0.09357074f, -0.27404609f, 0.02571946f, 0.21442491f, -0.10334047f, 
    0.05569154f, 0.07904413f, 0.13067737f, 0.00740081f, 0.12118687f, -0.00216276f, 0.03432047f, 0.08775577f, 
    0.22836757f, 0.18337527f, -0.01529747f, -0.10322376f, -0.18831077f, -0.04324524f, 0.02942755f, 0.05140916f, 
    0.04035063f, 0.06627820f, -0.13489057f, -0.05053529f, 0.26618984f, -0.05161074f, -0.13840701f, -0.00686021f, 
    -0.21756452f, -0.08198590f, 0.01715621f, -0.01807830f, -0.03268344f, -0.02875349f, 0.08387639f, -0.05109799f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03905120f, -0.04761363f, 0.03425473f, -0.03000428f, 0.06138203f, -0.01899939f, -0.11598116f, -0.01028613f, 
    0.01771064f, 0.02338172f, -0.04116780f, 0.11826575f, 0.05063447f, 0.03803533f, -0.07302780f, -0.02808050f, 
    0.09384517f, -0.01667679f, 0.00021341f, 0.00095665f, 0.05319965f, 0.01812853f, -0.05185489f, 0.14924866f, 
    0.15148512f, 0.04399293f, 0.01857239f, 0.03836335f, 0.00926534f, -0.08281803f, 0.20380765f, 0.08651484f, 
    0.04771863f, 0.06729628f, -0.00772540f, 0.09355698f, 0.06520574f, 0.00536783f, 0.07304261f, -0.00947849f, 
    0.09401865f, -0.01247563f, 0.06152819f, -0.00937641f, 0.06229151f, -0.02220492f, 0.02296934f, 0.03042086f, 
    -0.02288918f, -0.08582495f, 0.04109376f, 0.05040340f, 0.01810289f, 0.09713041f, -0.06909585f, 0.01826335f, 
    -0.03201351f, -0.08697505f, 0.05749816f, 0.12413262f, 0.01142422f, -0.01178875f, 0.12324902f, 0.19401382f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.05766800f, -0.01148371f, 0.10424386f, -0.49876869f, -0.20278953f, 0.09317281f, -0.03495918f, -0.00465646f, 
    -0.09803012f, 0.18437766f, 0.04028387f, -0.04644217f, -0.02972100f, 0.09363377f, 0.09702158f, 0.40485808f, 
    0.31718460f, 0.07921073f, 0.20087971f, -0.05139756f, 0.32930499f, 0.11058136f, 0.03799545f, 0.16901186f, 
    0.02419214f, 0.05806863f, 0.24456894f, 0.10692616f, -0.04392684f, -0.18893559f, -0.01961989f, 0.01973201f, 
    0.10835142f, -0.05075287f, -0.14116633f, 0.35106856f, 0.12064543f, 0.15280041f, 0.14309981f, 0.19898108f, 
    -0.07289415f, -0.10417511f, 0.00828439f, -0.00530125f, -0.11407141f, 0.05272250f, -0.19481386f, -0.21915567f, 
    0.09052479f, -0.07073820f, 0.24266583f, -0.07698704f, 0.16946027f, -0.20174769f, -0.07007052f, 0.01200728f, 
    0.17793551f, 0.06270549f, 0.16498353f, 0.25014350f, -0.16902429f, 0.12172972f, 0.22962810f, 0.22230269f, 
    -0.00386226f, 0.16202864f, 0.03469105f, 0.21447930f, 0.02521268f, 0.09404974f, -0.11652105f, 0.30945000f, 
    0.06148402f, -0.16300549f, 0.04208609f, 0.23811099f, -0.00527120f, -0.23081852f, 0.11019405f, -0.11424550f, 
    0.25251976f, 0.33232450f, 0.23702532f, 0.11230010f, -0.05040548f, 0.03952421f, -0.08850466f, -0.22033136f, 
    -0.00116925f, 0.15415251f, -0.00956290f, -0.04681035f, -0.02695787f, 0.43390495f, 0.14179595f, 0.05566718f, 
    -0.10722179f, 0.04248781f, 0.15105283f, -0.08591729f, -0.10768031f, -0.08031370f, 0.20952350f, 0.03905638f, 
    0.04617311f, 0.06160681f, -0.11210727f, 0.09730712f, 0.01369282f, 0.14414662f, -0.14280218f, 0.22891593f, 
    -0.10275143f, 0.09613007f, 0.10813777f, -0.11007758f, 0.14609748f, 0.03902281f, 0.11328365f, -0.08089639f, 
    -0.02248847f, 0.19254489f, 0.05571798f, -0.22070809f, -0.16994934f, -0.04929379f, 0.12947507f, 0.19275138f, 
    0.06149490f, -0.04243768f, 0.10324725f, 0.40178254f, 0.16645223f, 0.10246425f, 0.54173040f, -0.25835282f, 
    -0.10586774f, -0.08161751f, -0.00058078f, -0.17388324f, -0.02874272f, 0.07229429f, 0.01833880f, 0.12729171f, 
    -0.10425955f, -0.03535620f, -0.00984294f, -0.04387914f, 0.11128833f, -0.08995588f, 0.05948741f, 0.03590664f, 
    -0.19440152f, 0.10625404f, -0.07689401f, -0.06013343f, 0.03613174f, 0.07602278f, -0.00849112f, -0.00728532f, 
    0.06844401f, 0.13602264f, -0.01563358f, -0.25452673f, -0.05074810f, -0.08940421f, -0.10124934f, 0.02759357f, 
    0.01886534f, 0.08078055f, 0.08229316f, -0.11717908f, -0.09408400f, 0.15217422f, 0.19458055f, -0.00416414f, 
    -0.02918617f, 0.16279942f, -0.16446002f, -0.10591768f, -0.16147685f, 0.11859076f, 0.04942454f, 0.16218425f, 
    0.19655564f, 0.18810175f, 0.07317051f, 0.31160668f, 0.32727394f, 0.19674042f, 0.11840722f, -0.26542470f, 
    -0.10891055f, -0.17546332f, -0.02706957f, 0.47198197f, 0.01053520f, -0.05783540f, 0.11325016f, 0.11563524f, 
    0.08713757f, 0.15296063f, -0.43259141f, 0.18192032f, 0.00047114f, 0.15818535f, -0.03859319f, 0.08353616f, 
    0.07113592f, -0.25308228f, 0.18596540f, -0.10612401f, 0.12436362f, 0.11436277f, -0.00767665f, 0.06708688f, 
    0.27196702f, -0.00787482f, -0.00134324f, -0.10031942f, -0.28466129f, 0.04337699f, 0.18652800f, 0.26320019f, 
    -0.10506918f, -0.08450790f, -0.24039569f, 0.11922432f, -0.17279947f, 0.24699943f, -0.09226011f, 0.07203244f, 
    -0.02981105f, -0.03779464f, 0.00334915f, -0.00380774f, -0.03085269f, -0.15565282f, 0.11895668f, 0.22707401f, 
    -0.02027910f, 0.16979748f, 0.05303095f, 0.27085456f, -0.14820413f, 0.07064591f, -0.06010268f, 0.14988458f, 
    -0.03221595f, 0.16319239f, 0.33690590f, -0.08750360f, -0.13517106f, -0.07932023f, 0.05573061f, 0.25455797f, 
    0.03832312f, -0.17237134f, -0.10012331f, 0.05283247f, 0.24271905f, 0.09356780f, 0.22969389f, 0.53413308f, 
    -0.11439399f, -0.19278567f, 0.08110768f, 0.11865154f, 0.02253742f, 0.01599457f, 0.10604897f, -0.34045714f, 
    0.37089071f, -0.10435446f, 0.31594381f, -0.12247051f, 0.41440248f, -0.09052529f, 0.11503225f, -0.08835743f, 
    -0.07071539f, 0.05601358f, 0.27157471f, 0.06241907f, 0.05878757f, 0.24959812f, 0.12890387f, 0.03571039f, 
    0.06743070f, 0.08560377f, -0.18604690f, 0.03359176f, 0.03328967f, 0.03697925f, 0.21465522f, -0.06148974f, 
    -0.07877973f, -0.29037252f, 0.04412636f, 0.00006013f, 0.08981732f, 0.10930742f, 0.09828417f, -0.05766784f, 
    -0.09289616f, 0.19056669f, 0.03469664f, -0.12806974f, 0.18237112f, 0.04975886f, -0.05200336f, 0.00710883f, 
    0.34614801f, 0.07645439f, 0.05579041f, -0.09614577f, -0.11877406f, -0.02065309f, 0.31010818f, -0.18951046f, 
    0.11994497f, 0.25026837f, 0.02671930f, 0.02786447f, 0.07079563f, -0.08845053f, -0.14562063f, 0.02261779f, 
    0.09608010f, 0.02996382f, 0.15354152f, -0.07250072f, -0.07139836f, -0.12328266f, 0.05942918f, -0.10268699f, 
    0.02187675f, -0.00179632f, -0.07920454f, 0.00990783f, -0.20799841f, 0.06879608f, -0.09241515f, -0.02333859f, 
    0.05116900f, -0.08433637f, -0.03605581f, -0.09070412f, -0.16615541f, -0.06999558f, 0.01105093f, -0.25973403f, 
    -0.12423457f, -0.10800041f, 0.23013528f, 0.12778662f, -0.00119679f, -0.02531421f, 0.03104120f, -0.03064238f, 
    -0.07861698f, 0.17769217f, -0.09825508f, -0.04723693f, 0.19701096f, 0.20134190f, -0.02511866f, 0.11200818f, 
    0.06992356f, -0.14620878f, -0.03001924f, -0.02735079f, 0.18766500f, 0.12206931f, -0.04214697f, 0.10576937f, 
    -0.14083616f, -0.00475784f, -0.06626990f, -0.38181403f, -0.07514736f, -0.07250448f, 0.01660648f, -0.04764704f, 
    0.10555605f, 0.06043253f, -0.10145622f, -0.23777789f, -0.06930477f, -0.07736793f, -0.17282689f, -0.00403941f, 
    -0.07038293f, -0.03049092f, 0.13005587f, -0.01321682f, 0.05884662f, 0.28872219f, -0.11555504f, -0.05756815f, 
    -0.23785651f, -0.01586265f, 0.21031965f, -0.05988748f, -0.10921516f, -0.15127246f, -0.08928300f, 0.27790818f, 
    0.21014246f, 0.16124851f, -0.00058789f, -0.06575304f, 0.49451977f, -0.00071780f, 0.14269342f, 0.13086306f, 
    0.02171084f, 0.24890323f, -0.13520536f, 0.00463068f, 0.04013356f, -0.10512233f, 0.20626317f, -0.07674064f, 
    0.24581423f, 0.13746266f, 0.06159446f, -0.02363242f, -0.04385947f, -0.14196278f, 0.21875663f, 0.01200914f, 
    0.05025204f, 0.08586167f, -0.08061099f, 0.05965145f, -0.03763133f, -0.19293727f, 0.09090330f, 0.24645332f, 
    0.00615721f, -0.06658075f, -0.39152271f, 0.10444787f, 0.14008471f, -0.08635704f, 0.27358603f, 0.09805910f, 
    -0.07683383f, 0.08700184f, 0.07751511f, 0.56155354f, 0.14038391f, 0.13385572f, 0.06646785f, -0.02700052f, 
    -0.00473512f, 0.00316395f, -0.01513733f, 0.18936747f, -0.09311423f, -0.01930541f, -0.12278754f, -0.06214933f, 
    -0.38594645f, 0.01546298f, -0.00763043f, 0.09541459f, 0.08284770f, 0.15401608f, 0.03457508f, -0.25149685f, 
    -0.04079513f, -0.24220940f, -0.00578804f, 0.06147477f, 0.06040285f, 0.28425586f, -0.18103901f, 0.05073582f, 
    -0.02569936f, -0.05740865f, -0.08778722f, 0.06897186f, -0.23996918f, 0.23227695f, -0.13511327f, 0.30028492f, 
    0.32875797f, -0.10897339f, 0.06304742f, -0.11196032f, 0.12151581f, -0.00812023f, -0.08296724f, 0.28289148f, 
    -0.05847307f, 0.32566103f, -0.20546712f, 0.22164619f, -0.26878762f, -0.00421608f, -0.05301114f, -0.02863430f, 
    -0.12016351f, 0.19834583f, 0.21111195f, -0.06051431f, 0.20687290f, 0.05024928f, -0.24261191f, -0.10830285f, 
    0.03782420f, -0.03503105f, -0.06004649f, -0.20187327f, -0.23631877f, -0.12701394f, -0.22352442f, 0.38312873f, 
    0.08000030f, 0.01484921f, 0.04241016f, -0.11219425f, -0.12505166f, 0.11167859f, -0.01643203f, -0.37382498f, 
    0.10348128f, 0.33344644f, 0.25536662f, -0.07795270f, -0.10211273f, -0.08538391f, -0.11908602f, 0.17880321f, 
    -0.08842774f, 0.07915621f, -0.12898932f, -0.02131469f, 0.03009489f, 0.22699057f, -0.13030255f, 0.16079165f, 
    -0.10301751f, 0.19038905f, 0.05802675f, -0.08686945f, 0.15799940f, 0.09250525f, 0.15575911f, -0.12136406f, 
    0.01905202f, 0.32044515f, -0.02034152f, -0.06235895f, 0.09859306f, 0.17645514f, -0.04011420f, 0.04529539f, 
    0.06137009f, 0.09595722f, 0.15304993f, -0.14859764f, 0.03095677f, -0.23519383f, -0.11156844f, 0.19300911f, 
    0.42537245f, -0.02256664f, -0.26181823f, -0.09957106f, 0.14249726f, -0.20116238f, -0.31009936f, -0.08578768f, 
    -0.09492964f, -0.06478575f, 0.11459688f, -0.06252483f, -0.09796450f, -0.05502667f, 0.05900148f, 0.11564872f, 
    0.10212961f, -0.10040486f, 0.01937472f, -0.02852655f, -0.11395156f, -0.07842246f, -0.11926517f, -0.10413605f, 
    0.02821113f, 0.02264571f, -0.05675901f, 0.12135065f, 0.06822169f, 0.08305532f, 0.07845946f, -0.08916892f, 
    0.03196208f, 0.07498175f, -0.11950497f, 0.09721327f, -0.13771860f, -0.02819474f, -0.02147222f, -0.01342498f, 
    0.11930500f, 0.05657825f, 0.04809361f, 0.07758450f, -0.02314643f, -0.05160364f, -0.02964688f, -0.10190259f, 
    -0.05220319f, 0.02794296f, 0.02980773f, 0.01558851f, -0.06552749f, -0.04555756f, -0.08285091f, 0.05166778f, 
    0.11602482f, -0.03430666f, -0.04383856f, 0.02073156f, -0.01734491f, 0.02879161f, -0.12029889f, 0.09590957f, 
    -0.14375408f, -0.11900527f, 0.01435704f, -0.10222096f, -0.02365125f, -0.04570205f, 0.08403498f, 0.02214076f, 
    -0.02322567f, 0.11162718f, 0.10583621f, -0.43336543f, 0.05901205f, 0.06237928f, -0.22362371f, 0.08520157f, 
    -0.00472289f, -0.07182734f, 0.11383897f, -0.09323431f, 0.04067318f, -0.14093855f, -0.01976901f, 0.35355601f, 
    0.14938919f, 0.13934097f, 0.08543766f, -0.05939491f, 0.20411190f, -0.08023613f, -0.32515350f, -0.01860962f, 
    0.03922320f, 0.28134075f, -0.05029765f, 0.03854432f, -0.20400195f, 0.06732595f, 0.00812752f, 0.05887298f, 
    -0.10609590f, -0.06237679f, 0.41833338f, -0.11359357f, -0.19866852f, -0.04440144f, 0.18409424f, 0.04142665f, 
    -0.43510440f, 0.28348461f, -0.11063437f, 0.02061407f, -0.09065852f, 0.22078395f, 0.06645055f, 0.14357625f, 
    -0.11773995f, -0.05435124f, 0.31485811f, 0.18400964f, 0.02301122f, 0.01825890f, -0.02817145f, -0.36459583f, 
    -0.04057362f, -0.01151854f, -0.04573855f, 0.32080725f, 0.09338071f, -0.14814419f, -0.09881125f, 0.26632831f, 
    0.07270438f, 0.00673535f, 0.06421401f, 0.09222401f, 0.34523520f, 0.05706991f, -0.21445474f, 0.50955123f, 
    -0.05677250f, 0.09659519f, -0.26718241f, 0.05045214f, 0.07879274f, 0.33584663f, 0.01474740f, -0.24794020f, 
    0.05724449f, 0.33220148f, 0.12227465f, -0.10592085f, 0.32487848f, -0.00906888f, 0.13646863f, -0.12841508f, 
    -0.05461119f, 0.05102407f, -0.02714240f, 0.05376924f, -0.03405276f, 0.02645776f, 0.18769884f, 0.15662090f, 
    -0.02859494f, -0.03610632f, -0.29040852f, 0.23605248f, 0.03840082f, 0.02530415f, -0.03877117f, -0.02409733f, 
    0.25834504f, -0.30323118f, -0.06965502f, 0.06549291f, 0.01380835f, -0.22778521f, -0.10858276f, -0.10033939f, 
    0.10508576f, -0.10762907f, 0.07925555f, 0.04680876f, 0.05897329f, 0.17287339f, -0.06347165f, 0.13815701f, 
    0.13251522f, 0.14406677f, 0.04857605f, 0.02873002f, -0.10866251f, 0.09448415f, 0.04705444f, 0.20637986f, 
    -0.04287323f, -0.12677312f, -0.03732244f, -0.10503308f, 0.18997331f, 0.05892716f, 0.18011940f, 0.06101727f, 
    0.03527020f, -0.05346455f, 0.10286855f, -0.00086843f, 0.04432053f, 0.08738129f, 0.07341646f, -0.03605776f, 
    0.16214791f, -0.15729423f, 0.00261666f, 0.07448537f, -0.01698288f, -0.11133132f, 0.11218791f, 0.21381378f, 
    0.06052208f, 0.37604311f, 0.14338367f, 0.10648155f, 0.00234040f, -0.07053042f, 0.19986080f, 0.24689467f, 
    -0.09961022f, 0.03675976f, 0.05071100f, -0.14996150f, -0.13299455f, -0.08384845f, 0.07251657f, 0.04019891f, 
    -0.24764135f, 0.01915330f, 0.10042462f, 0.09949748f, -0.07422873f, -0.07479490f, 0.21682653f, 0.25211030f, 
    -0.05113273f, -0.09029546f, -0.12045273f, -0.08117447f, 0.07957420f, 0.04689509f, 0.01046508f, 0.10220772f, 
    -0.04758338f, 0.01613546f, 0.04075222f, 0.22622576f, 0.04025793f, 0.00481863f, 0.44194791f, 0.34406576f, 
    -0.04162821f, 0.21899143f, -0.08149623f, 0.11715003f, -0.40886092f, -0.07812403f, -0.01564801f, 0.15349416f, 
    -0.08759219f, 0.16967092f, 0.23525277f, 0.14447181f, 0.05105964f, -0.29098099f, 0.07987654f, 0.26941657f, 
    0.00949063f, 0.06902859f, 0.04293506f, 0.03541683f, -0.16251865f, 0.02312532f, -0.07499841f, 0.06787745f, 
    0.18238598f, -0.05672937f, 0.01716314f, -0.11514632f, 0.05735564f, 0.21000281f, -0.09342279f, 0.06708352f, 
    0.01605637f, 0.07052367f, 0.24109514f, 0.14221765f, 0.00106701f, 0.17343800f, 0.11851294f, 0.11299967f, 
    0.03265874f, 0.33450273f, -0.00823671f, 0.02414800f, 0.15976673f, 0.28356355f, 0.17843707f, -0.13045430f, 
    0.01996839f, 0.03038069f, -0.12881251f, 0.06417408f, -0.02341591f, -0.10975525f, 0.06691115f, 0.06418778f, 
    -0.03403661f, 0.07954938f, -0.23138244f, -0.23536931f, -0.07193348f, -0.08487085f, -0.44950989f, -0.01848519f, 
    0.09237339f, 0.09909228f, 0.02643544f, 0.27486718f, -0.02610775f, -0.02855857f, 0.12754482f, 0.09203655f, 
    0.03209721f, 0.21746847f, 0.02928672f, 0.07369337f, 0.07340623f, -0.06144343f, -0.03067873f, 0.12497239f, 
    -0.05895996f, 0.03147786f, -0.15631978f, -0.09039414f, -0.12130167f, 0.25292984f, 0.35263786f, -0.00457561f, 
    -0.13871205f, -0.10524569f, 0.00737718f, -0.03940101f, -0.13715044f, -0.12222618f, 0.04301505f, -0.27989465f, 
    0.08802518f, -0.00488568f, -0.00919056f, 0.19824001f, 0.20764582f, 0.21358633f, -0.08702866f, 0.12934324f, 
    0.18334264f, 0.05414874f, 0.04384776f, -0.01774606f, 0.29697078f, 0.11908599f, 0.00372710f, -0.18311690f, 
    -0.13366756f, -0.01011146f, 0.15051021f, 0.17798613f, 0.14460082f, 0.11533397f, -0.12134358f, 0.28265926f, 
    0.21163614f, 0.05049515f, 0.19695459f, 0.01062638f, 0.24303630f, 0.24775912f, -0.31042320f, -0.35685796f, 
    -0.10396047f, -0.11895303f, 0.07530573f, -0.07816026f, -0.09317304f, -0.03975742f, -0.01036613f, 0.04649367f, 
    -0.07742615f, -0.02875439f, -0.00532200f, 0.07194895f, 0.04696904f, -0.06534367f, -0.11156079f, 0.01250393f, 
    0.09361564f, -0.13999681f, -0.01729926f, -0.01616529f, 0.04689958f, 0.03115286f, -0.12087281f, -0.02301743f, 
    -0.05807924f, -0.11219814f, -0.05737914f, 0.01757325f, -0.13382453f, 0.07189761f, -0.04238552f, 0.08354983f, 
    0.07144594f, 0.04577234f, -0.12342165f, -0.09330566f, 0.01906375f, -0.04652701f, 0.02720257f, -0.03968402f, 
    -0.02480124f, -0.00110921f, -0.01325071f, 0.03919058f, -0.13734198f, -0.06487112f, 0.01704101f, -0.08002099f, 
    0.05668412f, 0.01438763f, 0.04500906f, 0.03899741f, -0.01446934f, -0.06284980f, -0.12372278f, 0.02218823f, 
    -0.04465507f, -0.05300623f, -0.05659666f, -0.06516389f, -0.10389895f, 0.04162249f, 0.05352742f, -0.09046515f, 
    -0.03541359f, -0.09128918f, -0.02062082f, 0.11341950f, -0.04435121f, 0.11550818f, -0.01855501f, 0.02422074f, 
    0.00885012f, 0.01761129f, -0.03810246f, -0.06547222f, 0.07561235f, 0.02328054f, -0.00193132f, -0.07963327f, 
    0.00182387f, 0.03601154f, -0.05903553f, 0.00966151f, -0.04449436f, -0.15136272f, -0.09485638f, 0.01913262f, 
    0.01145960f, -0.09709279f, -0.04009760f, 0.01719076f, 0.00404638f, -0.13982426f, -0.11631370f, 0.06243227f, 
    0.02543284f, 0.03496799f, -0.00718738f, 0.05783403f, -0.14042214f, -0.08690521f, -0.01933893f, 0.01017082f, 
    0.05400784f, 0.07624365f, -0.07626130f, 0.00592323f, -0.09832399f, -0.11452693f, 0.00352364f, 0.00924509f, 
    -0.01815538f, -0.05819301f, -0.00560162f, -0.05826664f, -0.01572604f, -0.07307830f, 0.03194106f, 0.03304941f, 
    0.04396674f, 0.05119624f, -0.04758880f, -0.10942379f, -0.06780596f, -0.12501399f, -0.11434143f, -0.07922031f, 
    -0.05935836f, 0.23159698f, 0.07060935f, -0.20040664f, 0.04211034f, 0.05651316f, 0.34900931f, -0.33848831f, 
    0.10662275f, 0.16486745f, 0.24155517f, -0.05618821f, -0.08644734f, 0.12780853f, 0.08090152f, 0.13489304f, 
    -0.07663298f, -0.03004381f, -0.01071626f, 0.11458648f, -0.35807571f, 0.01181381f, 0.23281094f, 0.11899685f, 
    -0.05467540f, 0.04452102f, -0.05755593f, -0.01534339f, 0.23816901f, -0.25668770f, -0.04995923f, -0.28948978f, 
    -0.02397060f, 0.22876650f, 0.09131312f, -0.20440213f, -0.00965737f, 0.04262702f, 0.09536451f, -0.04157674f, 
    -0.16824798f, 0.19413750f, 0.07850244f, 0.05537777f, 0.02686830f, 0.12013929f, 0.00663324f, 0.06912541f, 
    -0.05904854f, -0.10192428f, -0.10006794f, 0.18309328f, 0.12570754f, 0.11882698f, 0.08323055f, 0.30805221f, 
    -0.03354881f, -0.21202365f, -0.09968919f, 0.03347520f, 0.16170371f, 0.21933109f, 0.10889260f, 0.05909179f, 
    0.01337622f, 0.21656854f, 0.10947608f, 0.02667315f, 0.05910362f, -0.02723522f, 0.27375445f, -0.30516440f, 
    -0.05592130f, -0.03123682f, -0.16928688f, 0.09947936f, 0.11258611f, 0.02219989f, -0.06888282f, -0.01577532f, 
    0.07805967f, 0.01224448f, 0.24362460f, -0.01753480f, -0.25367007f, -0.00518267f, -0.06611333f, 0.08814134f, 
    0.10089885f, 0.05688545f, -0.06135793f, 0.10935597f, 0.10690571f, -0.05281538f, -0.16553578f, -0.03720620f, 
    -0.04342234f, -0.03343374f, 0.03167317f, -0.08707631f, -0.22019877f, 0.04273221f, 0.17253560f, -0.02124660f, 
    -0.12718032f, 0.10171505f, 0.11300819f, -0.00605899f, -0.28828192f, -0.01975451f, 0.00349688f, 0.03555019f, 
    -0.05658635f, 0.00820007f, -0.24161822f, 0.10909497f, 0.11136535f, -0.11962334f, -0.11238921f, 0.13970082f, 
    -0.06364074f, -0.12580849f, 0.14332168f, -0.04243561f, -0.13327946f, -0.10696464f, 0.30556330f, 0.19129877f, 
    -0.10078719f, 0.06374410f, -0.05974314f, -0.25447160f, -0.04751416f, -0.05243459f, 0.25579685f, -0.34845185f, 
    -0.12288710f, 0.15142137f, -0.07658924f, 0.11246245f, -0.10284217f, 0.11048438f, 0.07291469f, 0.28645501f, 
    0.11062680f, -0.03537325f, 0.06192344f, 0.00157468f, -0.04517100f, 0.12776238f, -0.02263458f, 0.07790458f, 
    0.05613589f, -0.08220198f, 0.03019476f, 0.06516314f, 0.14838113f, -0.14085786f, 0.00650511f, -0.18743940f, 
    0.03475155f, 0.15140881f, -0.05303998f, 0.09273691f, 0.01478398f, -0.10602269f, -0.10126961f, 0.11188666f, 
    -0.06518412f, -0.06099270f, -0.04043568f, 0.05985461f, -0.15594506f, 0.08895069f, -0.07087380f, -0.04180152f, 
    -0.05016766f, 0.02145158f, 0.04500262f, -0.12777932f, 0.17326051f, -0.14711136f, -0.07922199f, 0.00663295f, 
    0.08859738f, -0.11921860f, -0.00092363f, 0.10271338f, 0.03710491f, 0.00428736f, 0.03310125f, 0.09461407f, 
    -0.06084498f, 0.14540513f, 0.01699234f, 0.17633139f, -0.00986521f, -0.10097309f, -0.18388943f, 0.11714865f, 
    0.11948088f, -0.12310056f, 0.17213547f, -0.08658791f, -0.09590074f, 0.04811814f, 0.07725437f, -0.05896481f, 
    -0.07516176f, 0.41498113f, -0.12805524f, -0.02297983f, -0.00237132f, 0.03428551f, 0.04742143f, 0.02862855f, 
    -0.12066823f, 0.04632794f, -0.14671467f, 0.00609933f, -0.12135404f, 0.24482614f, -0.00914097f, 0.00799757f, 
    0.02842824f, 0.02985034f, 0.20746718f, -0.03811352f, 0.29739386f, 0.04830896f, 0.02060208f, -0.13843185f, 
    0.01854858f, 0.23002361f, -0.07807843f, 0.11396350f, 0.30103418f, 0.13227496f, 0.07458512f, -0.12083637f, 
    0.11792890f, 0.12018285f, 0.03772849f, 0.11997635f, -0.03040093f, 0.29427820f, -0.00213197f, -0.04109554f, 
    0.17832451f, 0.05817916f, -0.14487381f, -0.08482336f, 0.12655725f, -0.01751107f, -0.41966182f, -0.16292304f, 
    -0.07384747f, 0.25844225f, -0.11630906f, 0.23744717f, -0.47380072f, 0.12260451f, 0.17522360f, -0.40914160f, 
    0.11444708f, 0.07599349f, -0.08382934f, 0.27689645f, 0.08614530f, -0.10957200f, 0.03004787f, 0.34698209f, 
    0.29991856f, 0.03133018f, 0.09265471f, 0.02782905f, -0.39082015f, 0.16805170f, -0.03233908f, -0.08454401f, 
    0.30324337f, -0.05683951f, -0.15765689f, 0.05717490f, -0.10721459f, 0.18658371f, 0.08666509f, -0.12830079f, 
    -0.03615781f, -0.07786838f, 0.14813077f, -0.05005176f, 0.04590182f, -0.16758403f, -0.13647279f, -0.14551622f, 
    0.13843606f, 0.28977451f, -0.03512833f, -0.05024792f, -0.20033552f, 0.11420925f, 0.16014956f, 0.13894713f, 
    -0.01552728f, 0.10291220f, -0.04946306f, 0.17558143f, -0.07573908f, 0.18712677f, 0.02135108f, 0.05012401f, 
    0.00000227f, 0.01277947f, 0.19785216f, -0.04722818f, -0.13119791f, -0.03692088f, 0.15554912f, 0.21360904f, 
    -0.09263359f, 0.17774664f, -0.07955820f, 0.43317702f, 0.71826684f, -0.10855019f, -0.08783273f, -0.07431889f, 
    -0.11921071f, 0.00773383f, -0.10716440f, 0.23669595f, 0.05427868f, 0.18292685f, -0.03214630f, -0.52371228f, 
    0.06485444f, -0.00162542f, -0.04790432f, -0.08256095f, -0.15586284f, 0.17448105f, 0.01670818f, -0.01691798f, 
    0.24212024f, -0.09396620f, -0.05328762f, -0.00940561f, 0.17420635f, 0.27671748f, -0.00706627f, -0.12130693f, 
    0.03874254f, 0.11707646f, -0.06694864f, -0.07807950f, -0.08835003f, 0.13647045f, -0.02645601f, -0.04849874f, 
    0.05670780f, -0.09678397f, -0.01419613f, 0.07966726f, 0.07874020f, 0.15956776f, 0.07409494f, 0.42365593f, 
    -0.02293616f, 0.03929045f, -0.14109726f, 0.25722122f, -0.02008753f, 0.30476883f, -0.05748976f, 0.21541665f, 
    -0.17787234f, -0.02776450f, 0.04053519f, -0.15991646f, -0.00788057f, 0.00761788f, 0.26617062f, 0.04313282f, 
    0.11806722f, 0.02654910f, 0.05874248f, 0.09309609f, -0.03445218f, -0.06135037f, -0.10176437f, -0.04717389f, 
    -0.05634411f, -0.09026988f, 0.01820280f, 0.03024824f, -0.10552461f, -0.00746735f, 0.03165737f, 0.14157505f, 
    -0.07801340f, 0.05725578f, -0.09159854f, 0.08664112f, -0.07157581f, -0.05305037f, -0.10044138f, 0.03485895f, 
    0.04369812f, 0.08498105f, 0.06909319f, -0.10616319f, -0.00237052f, -0.12496699f, -0.10718937f, -0.03572251f, 
    -0.07130826f, -0.08621054f, 0.00678626f, -0.05390533f, -0.03782305f, 0.08690398f, -0.14064595f, 0.06266039f, 
    -0.09460655f, 0.03995197f, 0.06163524f, -0.09804752f, 0.00821636f, 0.01692391f, -0.08695427f, -0.05629519f, 
    0.05108039f, -0.06442948f, 0.01419735f, 0.04193901f, -0.05506535f, 0.01413675f, 0.10615627f, 0.03618119f, 
    0.03180398f, -0.12284925f, -0.10099149f, 0.06534333f, 0.00993391f, -0.12164802f, -0.06371260f, 0.05810447f, 
    0.07512847f, -0.00355801f, -0.01070908f, -0.00868155f, -0.07555032f, -0.01310188f, 0.34078148f, 0.03782171f, 
    -0.08381732f, -0.02320958f, 0.33415622f, -0.05679075f, -0.05502703f, -0.26409972f, -0.07419775f, -0.17717473f, 
    0.20041405f, -0.18107623f, -0.06126207f, -0.12723519f, -0.08603860f, -0.02590301f, 0.11431863f, 0.24790640f, 
    0.03041652f, -0.02095138f, 0.26470724f, 0.00738292f, -0.07803507f, 0.17606816f, 0.01255764f, -0.28384301f, 
    0.09574470f, 0.24754518f, 0.00333542f, -0.09893250f, 0.15654036f, 0.01338963f, 0.12886643f, -0.22446789f, 
    -0.19551206f, -0.06061450f, 0.05443837f, -0.06430511f, -0.04448023f, 0.35068637f, 0.16569021f, 0.03968048f, 
    -0.01769076f, 0.06538966f, 0.33033833f, -0.15425898f, 0.32157925f, 0.20648541f, 0.00026693f, 0.18491742f, 
    0.12433933f, 0.00207183f, -0.16807757f, -0.11544120f, -0.01895604f, 0.20135888f, 0.07605664f, -0.18804595f, 
    0.08843047f, 0.15591870f, 0.00975795f, -0.14053242f, 0.21824640f, -0.01969768f, -0.06744526f, -0.19229478f, 
    0.04345804f, 0.05890424f, 0.23164204f, -0.05144239f, -0.05268452f, 0.15300453f, -0.11344859f, -0.21390890f, 
    -0.11677243f, 0.04277022f, 0.14872248f, -0.11009490f, -0.01389555f, -0.01680330f, -0.03356038f, 0.01394082f, 
    -0.17640963f, -0.09044989f, 0.04656158f, -0.00863511f, 0.36359230f, -0.02536722f, -0.28006649f, -0.00526763f, 
    0.05475089f, -0.01193201f, 0.11716189f, -0.03951677f, -0.15275449f, 0.11740422f, 0.35324883f, 0.28507581f, 
    0.06747346f, 0.00325670f, -0.11339596f, 0.06242619f, 0.11242873f, 0.13740163f, -0.11478273f, 0.10586208f, 
    -0.07748078f, 0.14422014f, 0.00293708f, -0.12841596f, 0.07719564f, -0.25346160f, 0.02352334f, -0.07212131f, 
    -0.05251395f, 0.01847683f, -0.02060481f, 0.02809140f, 0.10572726f, -0.11163595f, 0.04533172f, 0.01339501f, 
    -0.02680990f, -0.16065772f, -0.11232784f, 0.49636433f, 0.23342186f, -0.05651600f, 0.10628321f, 0.13125724f, 
    0.12334335f, 0.19103299f, -0.27253056f, -0.02604569f, 0.02300178f, 0.41897619f, 0.07595338f, -0.17080574f, 
    -0.42584834f, 0.04847695f, 0.17548259f, 0.05649162f, -0.04952882f, 0.09626497f, 0.17597567f, 0.10167759f, 
    0.08227134f, -0.17062128f, -0.12982202f, 0.04533884f, 0.09494250f, -0.03668442f, -0.16567811f, 0.25343224f, 
    -0.07691492f, -0.00822698f, -0.26810628f, -0.02947135f, 0.09071194f, 0.25960779f, 0.03643770f, 0.22207671f, 
    0.01324211f, -0.09982714f, -0.11573631f, -0.06815717f, 0.02775635f, 0.05627559f, -0.00319684f, -0.06028719f, 
    -0.11215124f, 0.18525168f, -0.17593585f, 0.16831903f, -0.14849174f, 0.02902929f, 0.05670561f, 0.28783628f, 
    0.26704371f, 0.08158921f, 0.07607727f, 0.14148626f, 0.14578341f, -0.01169282f, -0.14404474f, -0.01150291f, 
    0.10750046f, 0.16321723f, -0.05907886f, 0.25084829f, 0.08163513f, 0.08271627f, -0.15270460f, 0.18481903f, 
    0.06382935f, -0.02967503f, -0.17423432f, 0.18694411f, -0.08304863f, 0.10521798f, -0.03398952f, -0.28314129f, 
    0.08963572f, 0.12131399f, -0.05659489f, -0.06765059f, -0.25817251f, 0.18122685f, -0.00081952f, 0.08072156f, 
    0.15185733f, -0.19921453f, 0.02467057f, 0.04227387f, -0.11441683f, 0.14580850f, 0.15982230f, -0.13639472f, 
    -0.07953857f, -0.12211525f, 0.17934559f, -0.10392222f, 0.05451648f, 0.12768605f, -0.19147354f, -0.07995388f, 
    -0.07291196f, 0.19980799f, -0.08783192f, 0.00688176f, 0.19928265f, 0.16248158f, 0.00045285f, -0.01746149f, 
    -0.03090413f, -0.12614113f, 0.00667735f, 0.24847920f, 0.11835309f, 0.29101446f, 0.01812376f, 0.14972723f, 
    0.10131912f, -0.05301240f, 0.01513290f, -0.04529596f, 0.00203667f, 0.05320366f, -0.32533392f, 0.10775428f, 
    0.00425327f, -0.02512775f, -0.00020486f, -0.02795510f, -0.00827604f, -0.02937445f, -0.08982748f, 0.00165991f, 
    0.05486267f, 0.03986151f, 0.08708335f, 0.04457571f, 0.11839017f, -0.11414385f, 0.00859815f, -0.04241297f, 
    -0.14910056f, 0.07713740f, -0.03008503f, -0.04891555f, 0.06723060f, -0.02214183f, -0.10773972f, 0.08994545f, 
    -0.01277000f, -0.03643943f, -0.11565224f, 0.01034314f, -0.14441788f, -0.01843795f, -0.11197386f, -0.02573974f, 
    -0.01468846f, -0.13935015f, 0.04285137f, -0.10164241f, -0.12095158f, -0.09916093f, -0.07844662f, -0.04738719f, 
    0.05592024f, 0.07608941f, -0.04988669f, -0.07468933f, -0.05169769f, -0.01833947f, -0.06579597f, -0.06838773f, 
    0.08577892f, -0.07323579f, -0.04654653f, -0.01422003f, -0.11441129f, -0.06992842f, 0.03849518f, -0.05066958f, 
    -0.11866078f, 0.00896748f, -0.05123108f, 0.04449693f, 0.05583181f, 0.08611558f, 0.05184928f, -0.04874834f, 
    -0.05030473f, -0.03720502f, 0.09852019f, -0.14659008f, -0.01388579f, 0.00521846f, 0.03539222f, 0.01834311f, 
    0.04961769f, -0.01843719f, 0.00330513f, 0.00949956f, 0.09765594f, -0.00543440f, 0.02716099f, -0.12357050f, 
    0.00050387f, -0.05313156f, -0.13113147f, -0.01675326f, -0.13216406f, 0.09197503f, -0.03169870f, -0.16014999f, 
    -0.12399279f, 0.07651289f, 0.04188658f, -0.08424950f, -0.10355077f, -0.11945698f, -0.07717717f, -0.14936924f, 
    0.06245294f, 0.04080704f, 0.00830789f, 0.00013206f, -0.00354703f, -0.11981139f, 0.06892193f, 0.06734439f, 
    0.06554468f, -0.08741824f, 0.04845131f, 0.09055443f, 0.03773382f, -0.05575270f, 0.04765913f, 0.09082949f, 
    0.00771093f, -0.14276695f, 0.03765500f, -0.12905966f, -0.03371483f, -0.07167282f, 0.07366380f, -0.04343865f, 
    0.10177730f, -0.11877896f, -0.03131789f, 0.00874199f, -0.13982981f, -0.07871158f, 0.02220559f, 0.02052669f, 
    -0.04866473f, 0.25844660f, 0.05771190f, -0.19476402f, -0.39865699f, 0.08817194f, -0.33726206f, -0.07853551f, 
    0.00229562f, 0.22369017f, 0.18797696f, 0.16346157f, 0.05566676f, -0.18498221f, -0.01636257f, 0.16069704f, 
    -0.19200537f, 0.02710661f, 0.02651135f, -0.01080440f, -0.25676739f, 0.10765552f, -0.03744977f, 0.19335285f, 
    0.43723220f, -0.02413255f, -0.12780015f, -0.04969246f, 0.23481482f, -0.02701753f, 0.06301128f, 0.07680447f, 
    0.11693309f, 0.00221740f, 0.01397721f, 0.09597495f, 0.04737868f, -0.00320347f, 0.12585008f, 0.06973716f, 
    0.09071374f, 0.28295246f, 0.10005478f, 0.02505414f, 0.18876486f, 0.05125118f, 0.21919908f, 0.09263948f, 
    0.11154894f, 0.04909818f, -0.03625362f, 0.10447812f, -0.00578205f, 0.03505832f, 0.03074858f, 0.16962805f, 
    -0.17287730f, -0.19167711f, -0.22006823f, -0.24396637f, -0.08544956f, 0.02720856f, -0.09158451f, 0.22146527f, 
    0.03524390f, 0.01714995f, 0.05138282f, -0.38542405f, -0.00994426f, 0.05228296f, 0.26346710f, -0.09593690f, 
    -0.07384832f, -0.15754668f, 0.08975828f, 0.03466488f, 0.10530078f, -0.08025040f, 0.03732711f, 0.37262294f, 
    0.40090585f, 0.37972385f, -0.35168815f, -0.09180550f, 0.05901995f, 0.05212331f, 0.27615857f, 0.15863790f, 
    -0.26721185f, 0.01849758f, 0.22879694f, -0.03993755f, -0.23408554f, -0.24921082f, 0.13157326f, -0.19521466f, 
    -0.10372476f, 0.10781051f, 0.15567343f, 0.06740369f, 0.23251277f, -0.16681175f, -0.28973386f, -0.21381521f, 
    0.17148480f, 0.09818228f, -0.00818772f, 0.02991180f, -0.05689314f, -0.06693394f, -0.02267807f, -0.16592605f, 
    -0.04895455f, -0.07985914f, 0.33894208f, -0.02328206f, 0.21809588f, 0.30999196f, -0.04221784f, -0.23613594f, 
    -0.11087443f, 0.09405416f, 0.17098111f, 0.19282483f, 0.22631918f, 0.26634672f, -0.22771017f, -0.36384842f, 
    0.00989044f, -0.14044484f, -0.00211603f, -0.13003460f, 0.08707969f, -0.02663356f, 0.11403412f, -0.21964678f, 
    -0.02356318f, 0.21066491f, 0.00466319f, 0.04601835f, -0.07101989f, -0.01555431f, 0.12080540f, -0.03412082f, 
    -0.27660507f, -0.43890232f, 0.21308877f, 0.03236829f, -0.01700821f, 0.01016729f, 0.08046079f, 0.23901236f, 
    0.01833449f, 0.07390877f, 0.23513199f, 0.08093297f, 0.27568272f, -0.22137065f, -0.16029656f, 0.13112390f, 
    -0.05336691f, 0.22030465f, -0.21344830f, 0.13820794f, -0.08000270f, 0.12637359f, 0.10161358f, 0.24677335f, 
    0.00109741f, -0.17356415f, -0.02981828f, 0.06564464f, -0.05691629f, 0.08615900f, 0.20270212f, 0.02829477f, 
    -0.11052809f, 0.06943620f, -0.14014333f, -0.22233197f, -0.01261086f, -0.21027233f, -0.05115907f, 0.25234878f, 
    0.15470222f, 0.01388538f, -0.11887289f, -0.07160298f, 0.14412342f, 0.08298580f, 0.40235332f, -0.15080203f, 
    -0.00698976f, -0.16632667f, 0.01711011f, 0.57984090f, -0.00413266f, 0.06069968f, 0.12759261f, 0.05509940f, 
    -0.06476736f, -0.01925785f, -0.13455978f, -0.12558571f, 0.06517167f, 0.04248510f, 0.12706634f, -0.40966138f, 
    -0.08941809f, 0.06621771f, 0.19296174f, 0.11017180f, -0.06767448f, -0.17841554f, 0.04357849f, 0.22422400f, 
    0.02639894f, 0.04687539f, -0.07666869f, 0.12613197f, -0.00404221f, 0.13047409f, -0.05800402f, 0.09432838f, 
    -0.09953780f, 0.23196492f, 0.05280340f, -0.21783979f, 0.27065739f, 0.11494974f, 0.12228333f, -0.11850237f, 
    -0.04965903f, 0.15319377f, -0.00977759f, 0.06753874f, 0.15221731f, 0.28633171f, 0.01788403f, -0.10093211f, 
    -0.02635900f, 0.14708474f, -0.06094615f, -0.09182052f, 0.10521203f, -0.14962611f, -0.00809598f, 0.29619515f, 
    0.51776433f, 0.20574936f, 0.03598742f, 0.01686901f, 0.18651222f, -0.11986583f, -0.16732293f, -0.20696777f, 
    -0.01387077f, -0.17876181f, 0.08087317f, -0.28269130f, 0.14485744f, 0.07844412f, -0.10286953f, 0.41789839f, 
    -0.03193720f, -0.12277332f, 0.24270292f, -0.18026032f, -0.09507308f, 0.33368006f, 0.05886363f, -0.17675790f, 
    0.09103464f, 0.30670455f, 0.09595432f, 0.03686254f, 0.33161905f, -0.14121568f, 0.15192606f, 0.02421323f, 
    -0.16743325f, 0.02887809f, 0.26417249f, 0.11267988f, 0.27782279f, 0.04504756f, 0.15459290f, 0.25262123f, 
    0.11717160f, 0.14478140f, -0.05830492f, 0.01075236f, 0.34152839f, 0.01146486f, -0.05506573f, -0.00010506f, 
    0.20987874f, -0.09153590f, 0.00752627f, 0.04003312f, -0.05455855f, -0.23759337f, 0.08782539f, -0.25529024f, 
    0.00482582f, 0.06112704f, 0.21592444f, -0.21835037f, 0.07373358f, -0.14351764f, 0.08943328f, -0.10766756f, 
    0.15683138f, 0.09062495f, -0.04684903f, 0.18698516f, -0.00729997f, 0.18532532f, -0.07533679f, -0.07669531f, 
    -0.03175206f, 0.18994038f, -0.11437880f, -0.03410343f, 0.30456674f, -0.04452046f, -0.22317311f, 0.06075530f, 
    -0.00043620f, -0.16142204f, 0.12311165f, 0.13199538f, -0.05734783f, -0.25301000f, -0.11585750f, -0.04862133f, 
    0.09876948f, 0.14240617f, -0.12869632f, -0.10656875f, 0.03752954f, 0.21444595f, -0.06781527f, -0.38031325f, 
    0.02177098f, 0.02904124f, 0.13888383f, 0.00025199f, 0.11748599f, 0.34474528f, -0.04214718f, -0.16136196f, 
    -0.08443704f, -0.05565909f, 0.36153206f, -0.09552951f, -0.33363739f, 0.03775034f, 0.00852251f, 0.10805202f, 
    -0.03852386f, 0.09254353f, 0.07261117f, -0.00218722f, 0.14323270f, 0.30648312f, -0.13552269f, 0.43029830f, 
    0.11921298f, 0.16221832f, 0.04695630f, -0.13182519f, 0.12865528f, 0.22237612f, -0.04442324f, -0.19267313f, 
    -0.35537934f, 0.17040539f, -0.19526498f, -0.20744891f, -0.10329876f, -0.03648189f, -0.11145366f, -0.31574371f, 
    -0.00769865f, 0.05410156f, -0.09983323f, -0.38033941f, 0.20164652f, -0.10527561f, -0.35765332f, 0.36688325f, 
    0.10590351f, -0.16057734f, 0.26283523f, -0.02825468f, 0.12103520f, 0.08016288f, -0.10779253f, 0.00849834f, 
    -0.01047664f, -0.12787561f, 0.03732850f, 0.06926555f, -0.02268894f, 0.16929644f, -0.08960250f, 0.14657545f, 
    0.30086246f, 0.17298101f, 0.06573323f, -0.03458541f, 0.00236880f, 0.15811190f, 0.24200384f, 0.21543400f, 
    0.11858634f, 0.03322204f, -0.08602110f, 0.18988627f, 0.16411355f, -0.03673864f, -0.07612233f, -0.22887358f, 
    0.16042839f, -0.04579872f, 0.10530712f, -0.06637689f, 0.06192194f, -0.30984291f, 0.17983839f, 0.24059652f, 
    0.07687107f, -0.19015345f, 0.20017692f, 0.19316994f, 0.19790322f, 0.35569873f, 0.07544477f, -0.05273912f, 
    -0.05875492f, 0.09323996f, -0.00063876f, 0.15853621f, 0.13912067f, 0.11871610f, -0.02088695f, 0.23118015f, 
    0.09252956f, -0.01836148f, -0.00154305f, 0.49837571f, 0.23001689f, -0.11307624f, 0.21379265f, -0.17471124f, 
    0.01724194f, -0.08860636f, -0.46513069f, 0.24333328f, -0.10003322f, 0.26325870f, 0.02052723f, 0.04693754f, 
    -0.02002039f, 0.17518373f, 0.19750664f, 0.08393364f, 0.00584545f, 0.14333715f, 0.13821030f, -0.03381445f, 
    -0.22934176f, 0.08324120f, 0.02719495f, 0.09599888f, -0.17236793f, 0.04403560f, 0.02470405f, 0.12055198f, 
    -0.11429213f, -0.22916602f, -0.26245707f, -0.08561575f, -0.09028167f, 0.07480711f, -0.08484709f, 0.24852589f, 
    0.11109404f, -0.22123383f, -0.05681124f, 0.11346351f, -0.12619111f, -0.15121275f, -0.20778453f, 0.19078305f, 
    -0.06663495f, 0.18923020f, -0.14500815f, 0.23413937f, -0.26603895f, 0.03998890f, 0.07795493f, -0.00268639f, 
    0.01447448f, 0.21434811f, 0.49187621f, 0.12283942f, -0.04338511f, 0.08475611f, 0.18610349f, 0.09928810f, 
    0.00438570f, 0.18862535f, -0.00938941f, -0.16071612f, -0.28614652f, 0.02540356f, -0.05668020f, -0.39821708f, 
    0.03247554f, 0.07101423f, -0.18216071f, 0.18288630f, -0.07553238f, 0.38251978f, -0.01891571f, 0.33376989f, 
    0.10979731f, 0.23687465f, -0.06835988f, 0.06533071f, -0.11639941f, 0.13097686f, -0.02759292f, 0.02101278f, 
    0.18927473f, 0.02747611f, -0.23826429f, -0.06722550f, 0.04488442f, -0.04880634f, 0.03570703f, -0.05132563f, 
    -0.03197968f, -0.07292254f, -0.23093577f, 0.04744716f, 0.08348388f, -0.04106174f, -0.27751204f, 0.06555649f, 
    0.44694948f, 0.14928801f, -0.10604857f, 0.00231551f, -0.15084903f, -0.33521211f, 0.07639056f, 0.02826978f, 
    0.00849084f, 0.04998884f, -0.07724606f, 0.24840397f, -0.10056443f, 0.03880863f, -0.10759912f, 0.05588916f, 
    -0.11093688f, 0.03516496f, 0.20362687f, 0.18549213f, 0.01704670f, 0.09345103f, 0.08079527f, 0.45784485f, 
    -0.11182024f, 0.11381861f, -0.09114835f, 0.37895057f, 0.01752578f, -0.04190936f, -0.01820145f, -0.12668905f, 
    0.02615899f, -0.05995784f, -0.09687634f, 0.22423998f, 0.04482047f, -0.18778236f, -0.07131922f, -0.07852201f, 
    0.01345513f, -0.20896599f, -0.04764628f, -0.07353521f, -0.33020535f, 0.00777973f, -0.00697454f, -0.22708134f, 
    0.10707544f, 0.10749055f, -0.07535632f, -0.12292531f, 0.28851902f, 0.37259781f, 0.05069784f, 0.02996479f, 
    -0.04461594f, 0.04486135f, 0.22376046f, -0.05673238f, -0.09437921f, 0.10490397f, 0.03362883f, 0.17018284f, 
    0.02338940f, 0.07221580f, -0.01614540f, -0.04917276f, -0.06670111f, -0.03360907f, 0.22994329f, 0.42854872f, 
    0.10564516f, 0.26217723f, -0.38279793f, 0.03223389f, -0.22349773f, -0.10939172f, 0.08285645f, 0.04163035f, 
    -0.24040176f, 0.09436136f, -0.04270081f, -0.31510547f, -0.10569821f, -0.06030598f, 0.00177284f, 0.17599046f, 
    -0.03455646f, 0.00293216f, 0.06009686f, -0.05144510f, -0.03568718f, 0.11046453f, 0.09444979f, 0.05765584f, 
    -0.01198465f, -0.06020256f, 0.06331973f, -0.05225775f, 0.00263840f, -0.07971898f, 0.07896298f, 0.02566004f, 
    -0.15137097f, -0.15160567f, 0.06505820f, -0.04434706f, -0.01194929f, 0.03802091f, -0.04435260f, -0.10219929f, 
    -0.08019926f, -0.12052502f, 0.02333913f, 0.07599796f, 0.04225343f, 0.00627673f, -0.03918530f, 0.07047512f, 
    -0.10166809f, 0.05294427f, -0.05319219f, -0.11124212f, -0.02728672f, -0.09175196f, -0.11327201f, -0.00412680f, 
    0.01997805f, 0.03772099f, -0.10669270f, 0.08043569f, -0.08226825f, -0.10613057f, -0.09636723f, -0.09807860f, 
    0.04172082f, -0.03279266f, 0.00127581f, 0.00122563f, 0.05922164f, -0.10038702f, -0.04425848f, -0.09328757f, 
    0.03877089f, -0.11657744f, -0.11699533f, 0.03467529f, -0.12864262f, 0.08331869f, -0.09598044f, -0.13998476f, 
    0.12236863f, -0.02469421f, 0.01908681f, -0.11309574f, 0.18965387f, -0.00254995f, -0.07303825f, -0.19993432f, 
    0.04918775f, 0.06592660f, 0.03019653f, -0.04173997f, -0.01016548f, 0.05712964f, -0.12118801f, 0.08142298f, 
    -0.14627044f, -0.22845335f, 0.04177269f, -0.04192114f, -0.13791721f, -0.13455124f, 0.14089906f, 0.05964236f, 
    0.05559241f, 0.15654966f, 0.01290175f, 0.00825107f, 0.06247159f, 0.10095023f, 0.02327356f, 0.00647512f, 
    0.02103108f, 0.10889205f, 0.04800135f, 0.01226301f, 0.00545554f, -0.07021536f, 0.00985212f, -0.05946872f, 
    0.02785278f, -0.11931037f, -0.01239858f, -0.10926016f, -0.10906187f, 0.04188279f, 0.18972537f, 0.05004730f, 
    0.04486956f, 0.06582659f, -0.14132875f, -0.01575636f, 0.12574108f, -0.10424683f, 0.10235374f, -0.01571408f, 
    0.05068323f, -0.12813984f, -0.08209370f, -0.02768756f, -0.05595667f, 0.07186090f, 0.21843329f, -0.00584447f, 
    0.01492070f, 0.01038253f, -0.10884778f, -0.37513956f, -0.14639458f, -0.06834377f, -0.00476089f, 0.08025984f, 
    0.05196756f, 0.10332697f, 0.19704920f, 0.15110993f, -0.00917177f, 0.34856069f, 0.07439336f, -0.00659498f, 
    0.14335552f, 0.16632445f, 0.13736236f, 0.07993998f, 0.12875915f, 0.07872219f, 0.13146055f, 0.25994113f, 
    0.05112659f, 0.05355032f, 0.09808732f, 0.10750086f, 0.27415079f, -0.11477191f, 0.12733671f, 0.04406223f, 
    -0.02081765f, 0.20186612f, -0.21371323f, 0.21119846f, 0.17947826f, -0.09777945f, -0.13114518f, -0.17135692f, 
    0.28100276f, -0.12278488f, -0.07159615f, -0.03526010f, 0.08574208f, -0.23229088f, -0.02829132f, -0.26280096f, 
    -0.10116540f, -0.09268136f, 0.02824068f, -0.06566836f, 0.08495031f, -0.07069273f, -0.01782618f, 0.10869697f, 
    0.17317368f, -0.17120704f, -0.11533207f, 0.03670878f, -0.02454942f, 0.07758792f, 0.31300279f, 0.34189984f, 
    -0.06063926f, -0.14394593f, 0.08861124f, -0.26080063f, 0.04352181f, -0.07558575f, -0.28150654f, 0.24529243f, 
    0.10256036f, -0.06817314f, 0.20228608f, -0.03868492f, 0.07830579f, 0.13494512f, 0.09583879f, -0.19320859f, 
    0.08672505f, -0.08622212f, 0.15205538f, -0.11621740f, 0.00536453f, -0.23321955f, -0.20672742f, 0.12655157f, 
    0.23407537f, 0.38726416f, -0.05870641f, 0.03553715f, 0.26402175f, -0.02953893f, 0.21860653f, 0.23480400f, 
    -0.00332573f, 0.23273268f, -0.02782154f, -0.03903643f, 0.01512900f, 0.04061571f, 0.38391051f, -0.28603506f, 
    -0.25772673f, 0.22837016f, 0.08256591f, -0.07555659f, -0.21176633f, 0.07361136f, 0.20377997f, -0.02809666f, 
    0.08912141f, 0.01098282f, 0.18032941f, 0.12160648f, 0.20969525f, 0.04735781f, -0.07721065f, 0.20141762f, 
    0.13700910f, -0.21598455f, -0.37909767f, 0.18611592f, -0.00709776f, -0.06371637f, 0.37293053f, 0.34115991f, 
    0.02589907f, 0.09588980f, -0.07754441f, 0.12757427f, 0.14504902f, -0.08330828f, 0.45400897f, -0.16207863f, 
    0.08143484f, -0.17098039f, 0.11337960f, -0.12950665f, 0.06006133f, -0.13397534f, 0.05985162f, -0.17036378f, 
    0.14744076f, 0.08936096f, 0.09097133f, -0.09190036f, -0.04980823f, -0.14668162f, 0.15512080f, -0.02800061f, 
    -0.24046896f, 0.22032055f, 0.16320571f, -0.08798157f, 0.09112979f, 0.06884141f, -0.02983903f, -0.18850854f, 
    -0.03409875f, 0.18086126f, 0.31343746f, -0.29208365f, 0.04450768f, 0.02300575f, 0.05832915f, -0.13590604f, 
    -0.19951610f, -0.03640767f, 0.03524301f, -0.10257265f, -0.14883609f, 0.32261914f, 0.06164955f, 0.18072529f, 
    0.04683862f, 0.12999143f, 0.08329076f, 0.02770587f, 0.19341858f, 0.16910782f, -0.11031257f, -0.15645812f, 
    0.03944197f, 0.19020271f, 0.00507092f, 0.17787488f, 0.19867639f, 0.11340481f, 0.12807359f, -0.27605307f, 
    -0.09543335f, 0.06882817f, -0.12010557f, -0.00478269f, -0.13140874f, -0.04909629f, 0.01826365f, -0.01066254f, 
    -0.09951969f, -0.13714601f, 0.09611423f, 0.09196766f, -0.05795192f, -0.13580948f, -0.10381711f, 0.02378478f, 
    -0.05483573f, -0.08271157f, -0.12506507f, 0.02613427f, 0.08207054f, -0.02769804f, 0.10077782f, -0.03512528f, 
    -0.02369456f, -0.13267384f, -0.13428409f, 0.11185855f, 0.00286485f, -0.06352341f, -0.05932181f, -0.03495173f, 
    0.08663881f, 0.03290660f, 0.04477318f, 0.07959890f, -0.13221017f, -0.13351740f, 0.08797056f, -0.06776351f, 
    -0.07695682f, -0.09119319f, 0.06527925f, -0.10059823f, -0.06534547f, -0.09885188f, -0.10819360f, -0.09989270f, 
    -0.01146722f, 0.08199783f, 0.02362575f, -0.07000776f, 0.01301910f, -0.04545086f, -0.11972822f, 0.03578082f, 
    -0.08756615f, -0.04590082f, -0.02781156f, 0.07202131f, -0.05988599f, 0.08889997f, 0.05700148f, -0.12708643f, 
    -0.00178955f, 0.13659599f, -0.05805135f, 0.07809106f, 0.07759712f, 0.02031048f, 0.37323761f, -0.31151015f, 
    0.09078394f, 0.12975860f, 0.28024277f, -0.05233844f, 0.09102537f, -0.15350763f, -0.11689983f, 0.26507553f, 
    -0.04832572f, -0.47142777f, -0.04820538f, -0.05088646f, -0.08295625f, 0.01690280f, 0.21066597f, 0.24494846f, 
    -0.04498728f, 0.09734088f, 0.25262788f, 0.06639798f, -0.11000982f, -0.23646969f, 0.03790281f, -0.02039357f, 
    -0.08291761f, 0.05032200f, -0.02680040f, 0.27623090f, -0.15251635f, 0.02872339f, -0.06231473f, 0.11438744f, 
    -0.18145187f, 0.00072122f, 0.11742406f, 0.02916269f, 0.08058751f, 0.31857127f, -0.01086087f, 0.03595405f, 
    0.00087738f, -0.01030105f, 0.20430671f, -0.05343464f, 0.22310761f, 0.01711969f, -0.02104320f, 0.13783100f, 
    0.01969258f, 0.03879420f, 0.11861692f, -0.02202265f, 0.10259520f, 0.15266296f, 0.08784974f, -0.23463754f, 
    -0.12901422f, 0.05153330f, 0.04412405f, 0.33460817f, 0.12763682f, 0.10781507f, 0.42874795f, -0.28859660f, 
    0.04161725f, 0.13298444f, 0.23097077f, 0.05478321f, -0.01145364f, -0.20613708f, -0.00737518f, 0.07271265f, 
    -0.04366531f, -0.24040571f, -0.27483550f, 0.11177105f, -0.27931365f, 0.10904039f, 0.21731313f, 0.13869831f, 
    -0.20872398f, 0.01985515f, 0.23212992f, 0.09197319f, -0.28240120f, -0.23080207f, 0.16788590f, -0.29090023f, 
    0.03798190f, 0.20298950f, 0.01118926f, -0.02350408f, 0.09886690f, 0.10475199f, -0.22541791f, -0.24167971f, 
    -0.24672693f, -0.10021295f, -0.02570578f, 0.03128453f, 0.20760733f, 0.27102372f, 0.00727228f, 0.11189777f, 
    0.03580044f, 0.10946621f, 0.26113603f, 0.24135400f, 0.14813331f, 0.31978688f, 0.04706939f, 0.03800610f, 
    0.07080910f, -0.05950050f, 0.27227557f, 0.06684053f, 0.12769860f, 0.33283940f, -0.02349062f, -0.45124114f, 
    -0.08005047f, 0.18271595f, -0.09361991f, -0.18566768f, -0.45365766f, -0.06141885f, 0.09015235f, -0.10065239f, 
    -0.03421843f, -0.18072543f, 0.06843444f, 0.23737951f, -0.02480160f, -0.21420439f, -0.08417198f, 0.19454132f, 
    0.37105069f, 0.39798656f, 0.14519836f, 0.04818814f, -0.09841944f, 0.05410510f, -0.07552972f, 0.00787685f, 
    0.18741225f, -0.02192480f, -0.11339033f, 0.03070427f, 0.23474064f, 0.27124009f, 0.14153843f, -0.28946456f, 
    -0.05579313f, 0.23994233f, 0.20621973f, -0.16817714f, 0.16494116f, -0.17130831f, -0.08016552f, 0.00452793f, 
    0.02065980f, 0.29448095f, 0.09460344f, 0.06643273f, -0.04772389f, 0.15853402f, 0.15246220f, -0.07866357f, 
    0.06084156f, -0.00594716f, -0.09497068f, -0.12500775f, 0.17446321f, 0.05047189f, -0.05832744f, -0.04665864f, 
    0.05049373f, 0.02011699f, -0.23730071f, -0.08595468f, -0.17675048f, 0.02765289f, 0.08558220f, 0.05338860f, 
    0.11461475f, -0.00702781f, 0.02386741f, 0.44260296f, -0.49026799f, 0.02608483f, 0.29533678f, 0.21505424f, 
    0.10098459f, -0.03967160f, -0.22459319f, -0.05074198f, 0.08317196f, -0.17674172f, -0.08301101f, 0.25530508f, 
    0.16666788f, 0.25038451f, 0.23896684f, -0.09230048f, 0.12086865f, -0.03405239f, -0.00957718f, -0.03064172f, 
    -0.16753279f, -0.02620067f, 0.05826263f, 0.00212236f, -0.09151988f, 0.04337405f, -0.11388800f, 0.04001720f, 
    -0.05751376f, 0.21400779f, 0.17442025f, -0.02048066f, 0.27152032f, 0.19499291f, 0.07866416f, 0.27228442f, 
    -0.18323812f, 0.23000471f, -0.11780290f, -0.11639620f, -0.02561587f, 0.09061465f, 0.00263461f, -0.06003917f, 
    -0.09444010f, 0.17153284f, 0.10554233f, -0.28360194f, 0.03439869f, -0.26467294f, -0.07099675f, 0.03645887f, 
    0.35304725f, 0.25233930f, 0.27628204f, -0.12406204f, 0.04189620f, -0.04680625f, -0.26664752f, -0.12741058f, 
    -0.10911500f, 0.16866904f, 0.00572149f, -0.19014186f, -0.47741923f, 0.03283115f, 0.05001872f, -0.09293830f, 
    -0.03522278f, 0.30046561f, 0.01134285f, 0.10670567f, -0.08866675f, -0.00470576f, -0.06810085f, 0.09270214f, 
    -0.00284415f, 0.01363069f, 0.10976484f, -0.10728872f, -0.28244928f, 0.16943003f, 0.05169911f, 0.26915354f, 
    0.10650596f, -0.20499502f, -0.12781766f, 0.07211136f, -0.01162906f, -0.24173146f, 0.01409599f, -0.12171401f, 
    0.00022416f, 0.13120462f, -0.17576058f, 0.24927326f, 0.12377778f, 0.10148863f, 0.05568545f, 0.19395198f, 
    0.24504898f, 0.15799521f, 0.06584590f, -0.08507140f, 0.11693729f, 0.07565999f, -0.06327041f, -0.28069907f, 
    -0.02641138f, 0.02316322f, -0.12227129f, 0.10942721f, 0.03196387f, -0.09989606f, 0.01425031f, 0.24501806f, 
    -0.02681536f, -0.16686891f, 0.14778529f, -0.09872778f, -0.05201128f, -0.11888966f, 0.06858627f, 0.07764614f, 
    -0.00016439f, -0.02287612f, -0.10013458f, 0.08923683f, 0.39105511f, 0.08198482f, 0.02457740f, 0.21255492f, 
    -0.10375342f, -0.24371144f, 0.13530770f, -0.14424360f, 0.00855197f, -0.06984048f, -0.08309429f, -0.16497733f, 
    0.33894059f, -0.17583187f, 0.09406538f, -0.07557409f, 0.27922213f, -0.10435400f, -0.02603810f, 0.07099252f, 
    -0.01844238f, 0.38429108f, 0.25907892f, 0.11777905f, -0.24924785f, 0.01620168f, 0.36398831f, 0.17694949f, 
    -0.10411892f, -0.01819561f, 0.00143763f, 0.10095746f, 0.10782231f, 0.06948100f, 0.10147075f, -0.21386635f, 
    -0.26888919f, 0.05382261f, 0.06536840f, -0.00439313f, -0.13005883f, -0.12280865f, 0.08857957f, 0.22695141f, 
    -0.10527296f, 0.00094654f, 0.28520015f, -0.00767675f, 0.16215897f, 0.11709131f, -0.06900062f, -0.16826785f, 
    0.03542537f, 0.09300306f, 0.04914399f, 0.33709803f, 0.03026425f, 0.18433996f, 0.42104220f, 0.07933028f, 
    -0.10827168f, -0.04600288f, -0.13266240f, -0.12724471f, -0.60496050f, 0.09220499f, 0.28768128f, -0.22405803f, 
    0.00487681f, 0.10511347f, 0.28208888f, 0.04516354f, -0.02806120f, -0.13172533f, -0.08604316f, 0.45236075f, 
    -0.00337077f, 0.05784072f, -0.08982168f, -0.05962367f, -0.13115726f, 0.04643441f, 0.02204090f, 0.05932046f, 
    0.12984671f, -0.02650709f, -0.07593907f, -0.08217739f, 0.19243094f, -0.01777697f, 0.11684778f, 0.02661361f, 
    0.05792455f, 0.23698740f, 0.25668219f, -0.09342095f, 0.02454585f, -0.13599548f, 0.05046581f, 0.10681431f, 
    0.06256609f, 0.27777737f, 0.02376371f, -0.06747936f, -0.01958542f, -0.06109081f, 0.29754016f, -0.09463735f, 
    -0.11043082f, 0.05478449f, -0.11884364f, -0.01459495f, -0.00708250f, -0.16314474f, -0.07470585f, 0.01374412f, 
    -0.03002425f, -0.04217390f, -0.18443994f, 0.20775120f, 0.15440753f, 0.03814677f, -0.19541441f, 0.00894465f, 
    -0.05158199f, -0.01215845f, -0.05770636f, 0.14557540f, 0.27875784f, -0.03906673f, -0.48393068f, 0.29947960f, 
    0.00809163f, 0.14109018f, -0.07608376f, 0.05341951f, 0.10462205f, 0.15666877f, 0.04164605f, -0.12921475f, 
    -0.07049172f, -0.19459642f, 0.09797001f, -0.01229965f, 0.12077232f, 0.11384401f, -0.06346492f, 0.02531443f, 
    0.18148375f, 0.17159197f, -0.16458084f, -0.01187104f, -0.05108568f, -0.08419336f, 0.14474401f, 0.37746748f, 
    0.12000458f, -0.04306363f, -0.13511738f, 0.17065926f, -0.18544692f, 0.09413454f, -0.03486802f, 0.09632020f, 
    0.10486483f, -0.11747665f, -0.05253492f, -0.05006783f, 0.17419912f, -0.22573556f, 0.12848110f, 0.19501461f, 
    -0.11045096f, -0.05753994f, 0.12450511f, 0.03437698f, -0.19761394f, 0.09031423f, 0.05419861f, 0.03086611f, 
    -0.12927625f, 0.00936555f, 0.16069829f, 0.05239719f, 0.08446042f, -0.13809833f, -0.18062004f, 0.14844216f, 
    0.03446069f, 0.16562651f, -0.13170056f, -0.44995314f, -0.16025357f, 0.07225125f, -0.05171575f, -0.02267319f, 
    -0.07422713f, 0.04273862f, 0.16307782f, 0.10620640f, 0.04722615f, -0.03339023f, 0.04634231f, 0.30551925f, 
    0.30849290f, 0.20945659f, 0.02890142f, 0.06529258f, 0.27831861f, 0.18100876f, -0.11914396f, 0.02737516f, 
    0.18875217f, 0.11022478f, 0.11596390f, 0.08203161f, -0.02923857f, 0.02732234f, 0.05670222f, 0.17976765f, 
    -0.11586866f, 0.01012902f, 0.09247804f, 0.20281914f, 0.10533309f, 0.07859448f, 0.04742246f, 0.19082096f, 
    0.16364598f, 0.00697942f, -0.09092657f, -0.10049315f, 0.06703530f, -0.11870438f, -0.10764773f, -0.04249712f, 
    0.02837052f, -0.04046519f, -0.04134805f, -0.09080094f, 0.08682977f, -0.22845314f, 0.12339145f, -0.28404537f, 
    -0.15176648f, -0.01230526f, -0.06774874f, 0.24398965f, -0.17652647f, -0.08022776f, 0.12150905f, 0.42242232f, 
    -0.01580366f, 0.08915818f, 0.00250059f, 0.19675069f, -0.33869708f, 0.03634965f, -0.13631032f, 0.04266020f, 
    0.04941810f, 0.30225143f, -0.24766032f, 0.14520594f, 0.07220882f, 0.26578814f, -0.06383333f, 0.20297652f, 
    -0.21001661f, 0.12593324f, -0.04691839f, -0.10712796f, 0.16894276f, 0.01523871f, 0.07093449f, 0.19165958f, 
    0.10834073f, -0.19606896f, -0.01322756f, 0.03853834f, -0.10717848f, 0.07974585f, 0.00744734f, 0.06646438f, 
    -0.04672992f, -0.07421578f, -0.19381876f, 0.22377862f, 0.27542114f, 0.20530687f, -0.09215586f, -0.04055982f, 
    0.13134843f, -0.02754773f, -0.04368527f, 0.01718059f, 0.10542067f, -0.01511475f, -0.10925166f, -0.26042154f, 
    -0.05793852f, 0.02953931f, -0.03869348f, 0.12648028f, -0.08924256f, -0.05291103f, -0.06813766f, 0.12121120f, 
    0.41125661f, -0.00127598f, 0.23983039f, -0.03938156f, 0.04520275f, -0.02956123f, -0.28074512f, -0.02372671f, 
    0.07851665f, 0.07854930f, 0.03872298f, -0.45887688f, 0.14802429f, -0.08071110f, -0.28483692f, 0.09579360f, 
    -0.06695302f, -0.24269880f, 0.07922225f, -0.18627086f, 0.05183060f, -0.15732874f, -0.09252719f, 0.29154822f, 
    0.22640184f, 0.01525638f, -0.01951454f, -0.00001061f, 0.08307189f, 0.01891916f, -0.10402456f, -0.01514963f, 
    -0.18398540f, 0.30798891f, 0.13134426f, 0.07488703f, -0.29152557f, -0.10733946f, 0.24145456f, 0.15716547f, 
    -0.06332175f, 0.12074969f, 0.37434477f, -0.03631445f, -0.01078405f, -0.11515041f, 0.25953197f, -0.06301915f, 
    -0.06588250f, 0.30526477f, -0.00197652f, -0.12122972f, -0.10135099f, 0.17767042f, -0.00953196f, 0.13393407f, 
    0.00064215f, 0.06467032f, 0.35903135f, 0.13745531f, -0.05221347f, 0.15343490f, -0.07353857f, -0.41161922f, 
    -0.20570591f, -0.09858077f, -0.13530031f, 0.26689208f, 0.02004160f, -0.02685999f, 0.09136656f, 0.09313717f, 
    0.09984237f, -0.13538963f, 0.00276508f, -0.01306157f, -0.14625773f, 0.04093067f, -0.05669859f, -0.09494036f, 
    -0.11065137f, -0.08210528f, -0.06033632f, -0.08347566f, -0.05829314f, 0.05287318f, -0.03642136f, 0.06253930f, 
    -0.06895983f, 0.06854727f, -0.02591390f, -0.03879230f, -0.02143949f, -0.12393382f, -0.10737315f, -0.09257010f, 
    -0.02473776f, -0.07889194f, 0.12424670f, -0.10092878f, 0.03105932f, 0.07313724f, 0.00212135f, -0.00370177f, 
    0.06403041f, 0.05277454f, 0.11259720f, 0.02437208f, 0.07850905f, -0.01964831f, 0.03387176f, 0.05436488f, 
    0.08032443f, 0.08551949f, -0.04003829f, 0.12208417f, -0.09124296f, -0.06908911f, -0.06833458f, 0.01752441f, 
    0.11817561f, 0.07913677f, -0.10053004f, 0.00664820f, -0.12900357f, -0.10769735f, 0.11333811f, -0.09343004f, 
    0.13200791f, -0.11112554f, 0.13862939f, -0.10564793f, -0.06531932f, -0.02264444f, -0.04388681f, 0.09211568f, 
    0.07114029f, -0.12123370f, 0.11428641f, -0.10596789f, -0.01968587f, 0.11140422f, 0.00894503f, 0.09503400f, 
    -0.10132654f, 0.04412932f, -0.02922396f, 0.06592401f, -0.10889734f, 0.07881577f, 0.11446966f, -0.07417919f, 
    -0.11993128f, 0.01129047f, 0.01143102f, -0.08267011f, 0.01792092f, -0.10398138f, -0.00062342f, 0.02538985f, 
    0.02614287f, 0.00236664f, 0.10510682f, 0.00232709f, -0.01908764f, -0.09337350f, -0.01401648f, -0.01003254f, 
    0.08505136f, 0.07946710f, 0.03802313f, -0.00642846f, -0.05650040f, 0.03994508f, 0.04567924f, -0.09428782f, 
    -0.10350686f, -0.11170082f, 0.10191343f, -0.12141924f, -0.11784212f, 0.03540014f, -0.13860942f, -0.11755605f, 
    -0.10607119f, -0.09401157f, 0.01040909f, -0.05862059f, -0.07161351f, 0.07165964f, -0.12376499f, -0.10676166f, 
    -0.08336761f, 0.08255005f, -0.07302430f, -0.11032163f, 0.00091190f, -0.00133551f, 0.05777596f, -0.03549025f, 
    -0.01214798f, 0.21406549f, 0.07018624f, 0.11407313f, 0.25144953f, 0.07025085f, -0.00550756f, -0.30081689f, 
    0.09740159f, 0.11927723f, 0.24239841f, -0.02455423f, 0.02837125f, -0.05778931f, -0.11788213f, 0.12867106f, 
    -0.33707839f, -0.14601314f, -0.03263753f, 0.10938467f, -0.22813542f, 0.12633637f, 0.21754234f, -0.08902947f, 
    -0.02647890f, -0.13692009f, -0.00594760f, -0.10704022f, 0.29285607f, -0.04523464f, -0.11418034f, 0.08900283f, 
    -0.03940345f, 0.01122231f, 0.16794431f, -0.01740002f, -0.07277989f, -0.10437771f, 0.13769922f, 0.10289876f, 
    0.18443041f, -0.00345974f, -0.03521039f, -0.00214840f, 0.14153445f, -0.00601093f, 0.21278970f, 0.07121786f, 
    0.06242639f, 0.22441085f, -0.19574921f, -0.03611555f, -0.05140779f, 0.18529443f, 0.02491948f, 0.01013996f, 
    -0.27582702f, -0.15282235f, -0.15699230f, -0.03068039f, 0.29211336f, 0.17621563f, 0.19946407f, -0.08241964f, 
    -0.10648218f, 0.10209754f, -0.04477631f, -0.00622249f, 0.03233774f, -0.10935668f, -0.01184536f, -0.03211389f, 
    0.02497119f, -0.05391477f, -0.10653042f, 0.00912277f, -0.06279451f, 0.04807373f, 0.09052667f, 0.09307645f, 
    0.02360967f, 0.04570633f, 0.31057352f, -0.08219281f, 0.01858698f, -0.10318521f, -0.30006653f, 0.17404854f, 
    -0.21159096f, 0.18126576f, -0.14346434f, -0.04891320f, 0.03771001f, 0.08772508f, -0.12347613f, -0.04481411f, 
    0.06003790f, -0.02224836f, 0.12130021f, -0.33391485f, -0.10036620f, 0.06666398f, -0.02135246f, 0.06183068f, 
    -0.40427881f, 0.21516243f, -0.00631751f, 0.09186970f, -0.27110919f, 0.19334802f, 0.12930043f, 0.19939585f, 
    -0.00156649f, 0.18478633f, 0.09181890f, 0.10254344f, -0.06705678f, -0.31844682f, -0.01242529f, 0.04440751f, 
    0.08043207f, -0.10514293f, -0.04996570f, 0.22981635f, 0.09907230f, -0.15925546f, 0.22965825f, 0.30644855f, 
    0.01228818f, 0.05143460f, 0.02433425f, -0.27971646f, 0.20780520f, 0.00782687f, 0.04021155f, -0.12910827f, 
    -0.03105531f, 0.10555444f, -0.11904725f, -0.08555453f, -0.06275005f, 0.04121790f, -0.00529279f, 0.16926512f, 
    0.09241405f, 0.16349740f, 0.15676647f, 0.07637256f, 0.36990517f, 0.08253397f, -0.02602843f, 0.01108683f, 
    -0.30449513f, 0.10447659f, 0.19067265f, 0.07095636f, -0.00570578f, -0.11378280f, -0.18246016f, 0.08298407f, 
    0.07169317f, 0.01975327f, 0.06504309f, 0.18018477f, 0.02455028f, 0.09747892f, 0.22704975f, 0.32924774f, 
    0.13050836f, 0.04479965f, 0.12387995f, 0.03789647f, -0.15879725f, 0.07308652f, 0.03078656f, -0.16582821f, 
    -0.09213179f, 0.13564423f, 0.04000043f, -0.18674192f, 0.02157546f, -0.29654166f, -0.06342743f, -0.31144035f, 
    -0.11082207f, -0.02885667f, 0.06501768f, 0.39703289f, -0.12432063f, 0.00310035f, 0.28153914f, 0.08684972f, 
    -0.09240459f, 0.26094288f, -0.08648438f, -0.11625328f, 0.44406399f, -0.08321992f, -0.62451059f, -0.04822898f, 
    -0.12359490f, 0.27453557f, 0.14334130f, 0.11956023f, -0.11323881f, 0.04443550f, -0.07809831f, -0.15933648f, 
    -0.64205372f, 0.05562355f, -0.03874010f, 0.10662182f, 0.05529330f, 0.22824855f, -0.09865804f, -0.24908778f, 
    0.04793740f, -0.17619507f, 0.09930844f, -0.09889745f, 0.32467580f, -0.07823113f, -0.28967097f, 0.06078207f, 
    0.12654670f, -0.28157237f, -0.05283007f, 0.31466150f, -0.20857631f, 0.16005763f, -0.06202058f, 0.29828796f, 
    0.19046812f, -0.05401198f, -0.04179423f, -0.11964492f, 0.31461698f, 0.04264732f, -0.14768331f, 0.36063895f, 
    -0.07952966f, 0.12113616f, -0.13832343f, 0.01673029f, -0.20342948f, -0.13883491f, 0.03111834f, -0.09897910f, 
    -0.11981553f, 0.20059733f, -0.03999158f, 0.04525660f, 0.05069708f, -0.15693426f, -0.08393952f, -0.09933804f, 
    0.09354766f, -0.08607170f, -0.08655871f, 0.27526799f, 0.07406761f, -0.00290555f, 0.07944087f, 0.31026039f, 
    0.05713490f, 0.16077104f, -0.22557099f, 0.16844150f, -0.02945516f, 0.28530863f, 0.10035168f, -0.11473663f, 
    0.14642324f, 0.13234195f, -0.00845954f, 0.04997772f, 0.16292335f, 0.14802814f, 0.11972528f, 0.13675492f, 
    0.01288716f, -0.18349940f, 0.05569495f, 0.01226181f, -0.32603925f, -0.03438377f, 0.06422956f, -0.08966140f, 
    -0.11844681f, 0.10991651f, -0.25594267f, -0.07084425f, 0.35274923f, -0.01302641f, -0.21215977f, -0.33694661f, 
    0.15292087f, -0.33616087f, -0.07894044f, -0.05925164f, 0.11554210f, -0.21081798f, -0.09702694f, -0.18860762f, 
    -0.04918510f, 0.02341156f, 0.15597604f, 0.17754351f, -0.07275361f, 0.18989573f, 0.09846478f, 0.19843285f, 
    0.40207803f, -0.06599822f, 0.21771276f, -0.04334572f, 0.11624015f, 0.08800068f, -0.18672343f, -0.16154268f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.06693375f, 0.02555826f, -0.12746206f, 0.10668436f, -0.06355373f, -0.08436232f, 0.10827455f, 0.11253490f, 
    0.05517310f, -0.10374289f, -0.03703377f, 0.05619455f, -0.02481974f, -0.04668622f, 0.18580607f, -0.09724409f, 
    -0.09440368f, 0.11529146f, 0.05925754f, -0.05142749f, -0.08707873f, 0.05022934f, 0.10681739f, 0.03056772f, 
    0.13069938f, -0.05276484f, 0.00881474f, -0.02806535f, -0.01093045f, -0.08715469f, 0.16459681f, 0.11924398f, 
    0.01901468f, 0.06231885f, 0.13611341f, -0.09479532f, 0.11225115f, 0.08648885f, 0.17110044f, -0.12165883f, 
    -0.14651482f, -0.08677564f, 0.06139652f, 0.14227238f, 0.04072638f, -0.12838876f, 0.18444248f, 0.16609187f, 
    -0.09561779f, -0.10267881f, -0.01914530f, 0.04643209f, -0.08294632f, -0.05125532f, 0.16772856f, -0.03723598f, 
    -0.04167502f, -0.01753841f, -0.02269169f, 0.06124509f, -0.03222560f, -0.05684596f, -0.00888831f, 0.13803779f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.21123311f, 0.15671855f, 0.23219287f, 0.16956905f, 0.20727609f, -0.01725597f, -0.56809175f, 0.11273034f, 
    -0.27877769f, -0.00000934f, -0.44542873f, -0.39343974f, -0.12148598f, 0.18305422f, 0.11953234f, 0.04400328f, 
    0.02805045f, -0.03618136f, 0.07543965f, -0.06506293f, 0.10777072f, 0.19203870f, 0.07881165f, -0.03799067f, 
    0.19494195f, -0.21164510f, 0.02005571f, 0.10252522f, 0.07208038f, 0.01882654f, -0.15306857f, -0.10069188f, 
    -0.02685174f, 0.22415982f, -0.55467188f, 0.09139872f, -0.36540771f, 0.12588622f, -0.24492611f, 0.18825327f, 
    -0.12368509f, -0.10760272f, -0.57861233f, -0.51725191f, 0.26099786f, -0.07649157f, 0.15385054f, 0.21457139f, 
    0.10149870f, 0.35787687f, -0.09621690f, -0.05121362f, -0.01669391f, -0.20074412f, -0.46800828f, -0.00881764f, 
    -0.15557608f, -0.01884475f, -0.03266820f, -0.03540140f, -0.36173421f, -0.31975621f, -0.39322707f, -0.03519923f, 
    -0.18781611f, -0.05407811f, -0.00747102f, 0.08247463f, -0.24248010f, 0.04162623f, -0.09913693f, 0.18913817f, 
    0.33673257f, -0.13109498f, 0.32382712f, 0.14524899f, -0.24487330f, 0.07023678f, 0.13092005f, 0.01898518f, 
    0.02584901f, -0.02737346f, 0.13776723f, -0.36999154f, 0.18541722f, -0.03796410f, 0.20293617f, 0.05374070f, 
    -0.29706863f, 0.06096461f, 0.28857243f, 0.20668925f, -0.02096118f, -0.05774391f, 0.03019606f, -0.29353377f, 
    -0.18676129f, 0.13994287f, -0.25543261f, -0.10045850f, -0.13457979f, 0.21218148f, 0.05266165f, 0.02169164f, 
    -0.10586127f, -0.19369973f, -0.23082486f, 0.07275555f, -0.13848545f, 0.06225513f, -0.10336340f, 0.00285398f, 
    -0.32909375f, -0.06337685f, 0.07895543f, -0.31844461f, -0.25461662f, 0.16328228f, -0.30904886f, 0.15440618f, 
    0.11854616f, 0.01485773f, 0.04342134f, 0.17247005f, 0.26466361f, -0.08297820f, 0.17570008f, 0.05709151f, 
    -0.32960081f, 0.23702076f, -0.06845952f, -0.16248025f, -0.04069721f, -0.22722442f, 0.18064985f, 0.18856518f, 
    -0.21829781f, 0.10815870f, -0.21475817f, -0.01821990f, -0.16972743f, 0.15870604f, -0.14883491f, 0.10378034f, 
    0.07674703f, -0.09630483f, 0.06508520f, -0.04999070f, 0.10512315f, 0.20989692f, 0.24087055f, -0.06868644f, 
    -0.25297314f, 0.01576396f, -0.16431677f, 0.04558827f, -0.12141072f, 0.00674164f, 0.19226272f, -0.16992687f, 
    -0.27173698f, -0.41372058f, 0.01576797f, 0.29415607f, 0.04633682f, -0.00551800f, 0.26147711f, 0.33873510f, 
    -0.09269274f, -0.06005882f, -0.05733963f, -0.10796834f, 0.00234656f, -0.06240107f, -0.51114237f, -0.50962842f, 
    0.31703135f, -0.19153097f, -0.09737600f, -0.40786928f, 0.10923280f, -0.06491894f, 0.01940726f, -0.19482224f, 
    -0.15622622f, 0.11116160f, 0.02125161f, 0.18013895f, -0.11471325f, -0.12598330f, 0.09255962f, -0.34963718f, 
    0.13414633f, 0.03734981f, 0.01270322f, -0.07257561f, 0.06142385f, -0.18017781f, 0.18277715f, -0.56310743f, 
    -0.16383834f, 0.04547569f, -0.11361784f, -0.14875978f, 0.17964536f, -0.10343689f, -0.27907681f, 0.08506086f, 
    -0.08707504f, 0.23896186f, 0.38962573f, 0.18288738f, -0.41885710f, 0.11079466f, 0.06063139f, 0.10566618f, 
    0.00357764f, 0.26829585f, -0.07895786f, -0.17313585f, -0.10856336f, 0.00643480f, -0.08969176f, -0.35578936f, 
    0.22651932f, -0.05941376f, -0.08177951f, -0.19469406f, -0.21738765f, 0.12722564f, 0.17141934f, 0.08896293f, 
    -0.13909052f, 0.15472203f, 0.13059434f, 0.13100709f, 0.08907687f, 0.02705476f, 0.02768305f, -0.19003205f, 
    0.14051901f, -0.03590627f, 0.16792174f, 0.06964537f, 0.01514314f, -0.21015555f, 0.09398584f, -0.21449846f, 
    -0.07717777f, 0.07699128f, -0.11806330f, -0.06663536f, 0.18121065f, 0.14934695f, -0.56105548f, -0.30933562f, 
    -0.07872308f, -0.19177984f, 0.18567288f, -0.14540544f, 0.15237704f, 0.05506267f, 0.19983317f, 0.03338676f, 
    -0.18999806f, -0.09819694f, -0.30648264f, -0.14508024f, 0.13933855f, -0.03755971f, 0.02524981f, 0.08116104f, 
    0.08123200f, 0.11234124f, -0.38008836f, -0.12676093f, 0.02096586f, -0.31756976f, 0.13854097f, -0.00282984f, 
    0.16419075f, 0.17581870f, 0.02840906f, -0.07213569f, -0.00847282f, 0.05981056f, -0.03580431f, -0.17320113f, 
    0.28556451f, 0.03859066f, 0.11166681f, 0.06569363f, 0.14351766f, -0.24949713f, -0.37864929f, 0.09329759f, 
    -0.11069862f, 0.19913678f, -0.04697797f, 0.20478715f, 0.20392728f, -0.02124879f, 0.20035149f, 0.15591000f, 
    -0.27879977f, -0.34205931f, -0.22913443f, 0.12787206f, -0.03459039f, 0.07948591f, -0.26393595f, -0.30813330f, 
    -0.00918807f, -0.04297433f, 0.06642375f, 0.25134581f, -0.32021189f, -0.05943673f, 0.20571458f, -0.18757743f, 
    0.08420953f, -0.14273436f, 0.16264650f, -0.04412276f, 0.19062541f, -0.00159794f, -0.22813940f, -0.01053413f, 
    0.00783090f, -0.07514020f, 0.11617369f, 0.29460987f, -0.07106686f, -0.42885718f, 0.16520189f, -0.10241292f, 
    -0.06707424f, -0.02166654f, -0.04740455f, 0.03833122f, 0.12047283f, -0.16077174f, 0.09227992f, 0.06420419f, 
    0.00197469f, -0.33299083f, 0.03380414f, 0.08978559f, -0.10834278f, -0.04039091f, -0.38934967f, 0.32441258f, 
    -0.13223344f, -0.03001381f, 0.27185774f, -0.19289103f, 0.09921604f, 0.23188600f, 0.08412647f, -0.63912237f, 
    -0.06544046f, -0.16174470f, 0.16991101f, -0.55931926f, 0.19686191f, 0.11941874f, -0.02451386f, 0.13727991f, 
    -0.25747141f, 0.00157373f, -0.13116871f, 0.08738589f, -0.24858083f, -0.04711643f, -0.10016720f, 0.07015792f, 
    -0.29677847f, 0.09060808f, -0.08618048f, -0.11870670f, 0.23505761f, 0.07300904f, -0.18625915f, 0.27574852f, 
    0.16906884f, -0.46888354f, 0.06156229f, -0.06778966f, -0.57323116f, -0.40853858f, 0.06551811f, -0.22009973f, 
    -0.50550240f, 0.07518467f, -0.04252021f, -0.30387422f, -0.09352805f, 0.20868999f, 0.16700286f, 0.01318163f, 
    0.07075170f, 0.18215992f, 0.02016461f, 0.27053580f, 0.04338114f, 0.15711820f, -0.18068202f, 0.00023407f, 
    -0.05949712f, -0.17611255f, -0.06615544f, 0.00015256f, 0.04557006f, 0.06328223f, 0.24383742f, 0.25405249f, 
    0.07450145f, -0.24064077f, -0.10566746f, -0.64276379f, 0.07255290f, -0.22169186f, 0.29816914f, -0.18207853f, 
    -0.00609316f, -0.03391489f, 0.12755710f, -0.25375924f, -0.16765878f, -0.04189353f, 0.19823770f, 0.14479104f, 
    -0.01560577f, -0.01844356f, 0.28895456f, -0.26050302f, 0.31540233f, -0.00974593f, 0.12838879f, 0.16997206f, 
    -0.07100100f, -0.04687650f, 0.09885701f, 0.18498084f, -0.11877530f, -0.01897245f, -0.35722658f, -0.05776897f, 
    0.02537880f, 0.06187237f, 0.19936553f, -0.40361568f, 0.04460326f, -0.37681434f, 0.09418153f, 0.16915311f, 
    0.10580388f, -0.03807352f, 0.20120732f, -0.22239628f, 0.11617531f, 0.12494357f, -0.27328065f, -0.05968405f, 
    -0.02956325f, -0.12133639f, -0.08688231f, -0.06916459f, 0.23353159f, -0.26151398f, -0.42226398f, -0.02294647f, 
    -0.09035320f, 0.13765825f, -0.16111748f, -0.29107264f, 0.05597419f, 0.02678006f, -0.31373614f, 0.06184055f, 
    -0.23412503f, 0.11222652f, 0.29908600f, 0.08469548f, -0.09183522f, -0.21794432f, -0.29038045f, -0.04869070f, 
    -0.11609126f, 0.00887727f, -0.11627972f, 0.01767752f, 0.18644111f, -0.02600776f, -0.28049201f, -0.16216032f, 
    0.11097582f, 0.28061104f, -0.41124579f, 0.16967441f, 0.19956638f, -0.06938544f, 0.11588489f, -0.12258593f, 
    0.30401900f, -0.03658679f, -0.01313475f, -0.16579293f, 0.10435807f, 0.17546092f, 0.00456107f, -0.24337576f, 
    0.30132130f, 0.07546898f, -0.31841269f, -0.02748738f, 0.26096341f, -0.16186409f, -0.17290655f, 0.18744133f, 
    -0.01744529f, 0.06725439f, -0.20983826f, 0.10279121f, -0.31421086f, 0.14120767f, 0.09027098f, -0.07295878f, 
    0.00511750f, -0.43178812f, -0.35149422f, 0.13007157f, -0.17714119f, -0.50203645f, -0.10155094f, 0.05774841f, 
    -0.23356113f, 0.28306442f, 0.14062500f, -0.28877488f, 0.05468195f, -0.09841238f, -0.07570821f, -0.01881650f, 
    0.27036983f, -0.17917706f, 0.12877145f, 0.19089556f, -0.29778305f, 0.11436270f, -0.15598327f, -0.10940222f, 
    -0.02461335f, -0.07103705f, -0.08246591f, -0.16374096f, -0.25184324f, -0.07478279f, 0.04920326f, -0.39178026f, 
    -0.28735998f, 0.25451475f, 0.12177800f, -0.13616988f, -0.27240303f, 0.01873910f, 0.24216583f, 0.14301971f, 
    0.07312422f, 0.04908475f, -0.04798321f, -0.03506112f, -0.26556233f, 0.41672373f, 0.28632873f, -0.17516334f, 
    0.07014846f, 0.16160069f, -0.21324165f, -0.50498879f, -0.09680451f, 0.30664995f, -0.27256823f, -0.28588730f, 
    -0.08532616f, -0.04260306f, 0.24261530f, -0.18279882f, -0.08461779f, 0.16508679f, 0.13119356f, 0.04246956f, 
    0.05864421f, 0.11475610f, -0.18807952f, -0.00429500f, 0.18673904f, 0.07105802f, 0.12165098f, -0.03965734f, 
    0.19437073f, 0.04441208f, -0.59996641f, 0.22718857f, 0.01072568f, -0.00592407f, 0.10523462f, 0.28024518f, 
    -0.44025192f, -0.35449699f, -0.12087620f, 0.35152432f, 0.07536092f, -0.28110099f, -0.14295076f, -0.13085277f, 
    -0.08444700f, -0.14622569f, -0.13746974f, 0.01305599f, 0.19045246f, 0.03002548f, 0.10569254f, 0.24895707f, 
    0.16671373f, -0.28648624f, 0.02543902f, 0.12641625f, -0.08030685f, -0.17707956f, 0.08159925f, -0.28811511f, 
    0.32813925f, 0.00011459f, -0.11318377f, 0.04372726f, -0.13901973f, 0.09028062f, 0.00314836f, -0.15392388f, 
    0.14200734f, 0.15384962f, -0.37018898f, 0.35429141f, 0.09356265f, -0.03940692f, -0.04300438f, -0.05713090f, 
    -0.23139705f, -0.05561638f, 0.23903070f, 0.23413885f, 0.19240785f, -0.08471500f, -0.32648110f, 0.06407779f, 
    -0.10149819f, -0.37081450f, 0.05161457f, -0.14048937f, -0.31771883f, 0.04350650f, 0.03802962f, -0.05417151f, 
    -0.21096969f, -0.46354198f, -0.17609541f, -0.02830988f, 0.03830284f, 0.02275992f, -0.04938960f, -0.26989496f, 
    -0.23369355f, -0.25046551f, 0.00997573f, 0.00975650f, 0.32031116f, 0.23161505f, 0.10411696f, 0.15540433f, 
    -0.16023898f, -0.03460258f, 0.00813593f, 0.15457729f, -0.28347448f, -0.09768386f, -0.20820828f, -0.29564282f, 
    -0.14837477f, -0.14795651f, -0.20056345f, 0.28596938f, -0.21420772f, 0.30052513f, 0.23512541f, -0.09746674f, 
    0.21270077f, 0.00101055f, 0.09042083f, -0.52120858f, 0.02693270f, 0.00244376f, 0.02182707f, -0.05465584f, 
    0.06614380f, 0.08588583f, -0.32124990f, -0.10477401f, 0.19709234f, 0.00575277f, 0.20155913f, -0.43685487f, 
    0.37879801f, -0.11790024f, -0.51814574f, 0.19506596f, -0.11440686f, 0.24877524f, 0.02986926f, 0.04260866f, 
    0.01103807f, -0.04167869f, -0.16465862f, -0.07494877f, 0.17066485f, -0.04693938f, 0.05013474f, -0.00839870f, 
    0.20287949f, -0.09977826f, -0.02549848f, 0.19324115f, -0.04657153f, -0.07922321f, 0.19628146f, -0.23829931f, 
    -0.01773014f, 0.21856238f, 0.14700489f, -0.34553975f, 0.11098486f, -0.35223454f, -0.12403369f, -0.06594604f, 
    -0.02021527f, -0.02757478f, 0.26650327f, 0.16855353f, -0.14332522f, 0.10695210f, -0.14573498f, -0.19706738f, 
    0.22736374f, 0.05395665f, 0.20108537f, -0.10014556f, -0.04139619f, -0.02634888f, -0.03705927f, 0.17519428f, 
    -0.42624646f, -0.11691994f, 0.03150334f, -0.36206415f, -0.33646971f, -0.31393281f, -0.26381007f, 0.12787001f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.18115409f, 0.07318660f, -0.03647486f, 0.09411854f, 0.10053080f, 0.04660559f, -0.06153335f, -0.21974225f, 
    0.10839763f, 0.02574377f, -0.04853434f, -0.11345568f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
