#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.05473015f, -0.22811776f, 0.27666256f, -0.32095799f, 0.07853230f, -0.30140761f, 0.73895729f, 0.01177713f, 
    0.49444479f, -0.11217807f, 0.81818765f, 0.70189804f, -0.18677297f, -0.33797705f, -0.45131379f, 0.39831918f, 
    0.44099668f, -0.20496571f, -0.33265907f, -0.04745006f, 0.81377214f, -0.63770890f, 0.16547203f, 0.63478798f, 
    -0.45953903f, 0.34414080f, -0.40332809f, 0.33319423f, 0.04014590f, 0.54358828f, 0.81354332f, -0.11333208f, 
    -0.39396724f, 0.42446300f, 0.46998096f, -0.13595897f, -0.84601766f, -1.09345746f, -0.56103539f, 0.65531927f, 
    0.23115443f, -0.40599039f, 0.19090678f, 0.13571385f, 0.79723895f, 0.11649225f, 0.25653994f, 0.52511120f, 
    0.69944280f, -0.69783860f, -0.11267029f, -0.08495010f, 0.06844857f, 0.06813882f, -0.93217337f, -0.32884243f, 
    0.91550803f, -0.70657873f, -0.59453952f, 1.03903520f, -0.16713719f, 0.59516823f, 0.20021375f, 0.39957494f, 
    0.75790232f, -0.48709565f, -0.37300208f, -0.07098462f, 0.35046047f, -0.39677751f, 0.41639796f, 0.10798102f, 
    -0.59269148f, 0.37680855f, 0.61955917f, 0.87225544f, 0.45239249f, -0.06554414f, -0.05227529f, 0.10450411f, 
    0.40641937f, -0.43279585f, -0.65298682f, -0.94104362f, 0.06143349f, -0.23433955f, -0.79180801f, -0.34156168f, 
    -0.65887702f, -0.11763560f, -0.16600786f, 0.51781410f, 0.59577763f, -0.94276756f, -0.84054357f, -0.81829870f, 
    -0.29929781f, -0.61450899f, -0.82007098f, -0.03598761f, -0.50681287f, -0.19723140f, 0.27192473f, -0.39791426f, 
    0.13892980f, 0.01546233f, 0.65592134f, 0.50840139f, 0.28205979f, 0.26594126f, 0.15661262f, 0.00114911f, 
    0.40215605f, 0.54311270f, 0.05986076f, -0.76157820f, -0.06403979f, -0.58629453f, 0.58173007f, 0.50576228f, 
    -0.21782200f, 0.19767350f, 0.76620728f, -0.02836506f, -0.76109123f, -0.33943582f, 0.39398733f, -1.35714030f, 
    1.03125823f, -1.10249639f, -1.07071710f, -0.80438685f, 0.04317255f, 0.70161200f, -0.21786417f, -0.74728525f, 
    -0.41890815f, -0.10856947f, 1.91074920f, -0.42574444f, -0.88320416f, -0.18466434f, -0.49928308f, -0.29385859f, 
    0.27854025f, -0.20000282f, -0.65931541f, 0.40013292f, 0.09662964f, 0.78407687f, 0.94813216f, -0.84338123f, 
    -0.72400677f, 0.48154673f, 0.36950251f, -0.27662072f, -0.65967381f, -0.83401757f, 0.77389199f, 0.18346582f, 
    -0.32238162f, -0.55355722f, 0.59795064f, 0.03255893f, -0.12606508f, 0.34542128f, 0.28745821f, 0.56091112f, 
    0.15349129f, 0.39852008f, 0.27948895f, 0.30465853f, 0.25554648f, 0.55406970f, -0.03469076f, 0.29120022f, 
    0.08254754f, -0.12939329f, 0.41563252f, -0.60304630f, -0.18746227f, 0.51005894f, 0.05658605f, 0.14898555f, 
    0.71895993f, 0.76935548f, 0.17140441f, 0.58633071f, -0.25978366f, -0.19299445f, 1.50431287f, -1.42899334f, 
    -0.48305362f, -0.08323390f, 0.18410136f, -0.28164011f, 0.49944678f, -0.16646962f, -1.10236275f, -0.38498780f, 
    -0.01666037f, 0.84607387f, 0.67239588f, 0.23903807f, -0.49062881f, -0.24942921f, -0.47428581f, -1.26917994f, 
    -1.22340560f, -0.81505096f, 0.37044150f, -0.04231078f, 0.44973275f, -0.05007636f, -0.55963677f, -0.51264596f, 
    1.18759322f, 0.30217355f, 0.05795603f, -0.47115332f, -0.43423918f, 0.01977020f, -0.20604189f, 0.47254947f, 
    0.21844798f, 0.05201678f, -0.24992698f, -1.11784172f, 1.06284273f, -0.73580503f, -0.28626546f, -0.83079028f, 
    0.79631793f, -0.65016174f, 0.94586557f, -0.58609450f, 0.59411460f, -0.04675250f, -0.20604765f, -0.40802392f, 
    0.11976738f, -0.47606480f, 0.41953075f, -1.55960906f, 0.72315347f, -0.74166065f, -0.04304175f, 0.65159053f, 
    -0.77560961f, -0.26172021f, -0.29656604f, -0.20061447f, 0.82438022f, -0.02840583f, -0.00543094f, 0.47491655f, 
    -0.48062688f, -0.29633656f, 0.38632527f, -0.20184401f, -0.20515330f, -0.96420670f, -0.51569885f, -0.44618374f, 
    0.44691667f, 0.47239548f, -0.27010417f, 0.55533719f, 0.85854596f, -0.10568908f, -0.02718639f, 0.37270391f, 
    -0.33810776f, -0.76178300f, 0.15647474f, -0.84261966f, 0.65048397f, 0.80684412f, 0.34670374f, -0.76068872f, 
    -0.28346387f, -0.26402047f, -0.79370642f, -0.63092309f, -0.60745180f, -0.56802756f, -0.66162968f, -0.04170802f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14065273f, 0.20303284f, 0.20605485f, -0.36884439f, 0.51865727f, 0.25677121f, -0.03285009f, 0.24870043f, 
    -0.27610937f, 0.13728574f, -0.47687355f, 0.25213611f, 0.55582702f, 0.18410130f, 0.25910187f, -0.11475960f, 
    -0.19239537f, 0.37516442f, -0.18080284f, -0.08005171f, 0.40019584f, 0.18708624f, -0.04629125f, 0.23616678f, 
    0.34077305f, 0.15098017f, 0.15096676f, -0.10288501f, 0.58580303f, -0.13129921f, -0.08430769f, -0.22847167f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.08861495f, -0.22857197f, -0.00734161f, 0.01798524f, -0.27327612f, 0.03150803f, 0.01740527f, -0.01547745f, 
    0.03767253f, -0.30800718f, -0.09660329f, -0.06493862f, 0.06079329f, -0.12072318f, -0.10553669f, -0.05621112f, 
    0.04979244f, 0.20469588f, 0.02570307f, -0.22542915f, 0.15871388f, 0.06239227f, -0.05793427f, 0.13851905f, 
    -0.22353868f, -0.09677153f, -0.08885875f, -0.07580476f, 0.15337372f, 0.01430805f, 0.02709596f, -0.16744992f, 
    -0.12135401f, 0.25709453f, 0.03614319f, 0.21817833f, -0.10989816f, -0.07080285f, 0.23135026f, 0.13805217f, 
    0.08457118f, -0.07086044f, 0.01185935f, 0.00112974f, 0.02469635f, -0.09705403f, 0.03632626f, 0.01244801f, 
    -0.17310986f, -0.15955985f, -0.09614034f, 0.14528340f, -0.04401831f, -0.03802482f, 0.50320280f, -0.92088789f, 
    0.12598827f, -0.27483618f, 0.14858170f, -0.46677941f, 0.12352673f, -0.08769993f, -0.10971446f, 0.21371827f, 
    -0.03977855f, 0.00846847f, 0.05866773f, -0.06990802f, -0.03214872f, 0.14325428f, 0.03561573f, 0.06363373f, 
    0.14240472f, 0.07913251f, 0.05508660f, -0.25745273f, -0.53771955f, -0.10668070f, 0.12351368f, 0.20052558f, 
    0.02739211f, -0.31586257f, 0.12624316f, 0.11092851f, -0.07016744f, 0.05001433f, -0.01618207f, 0.03608356f, 
    -0.05241968f, -0.08825053f, -0.45515138f, 0.04403494f, 0.57544744f, -0.02043127f, -0.00610758f, -0.08650825f, 
    0.16195709f, -0.04113585f, 0.13048835f, 0.09806513f, -0.14088942f, -0.00857370f, -0.12651764f, 0.07235086f, 
    0.06894983f, -0.04907865f, 0.04823256f, 0.02525569f, 0.02020613f, 0.05399392f, 0.13390140f, 0.03153180f, 
    0.05075378f, -0.07379100f, 0.27805361f, 0.10781962f, -0.01276370f, 0.09101204f, 0.08160847f, 0.09350726f, 
    -0.01931471f, -0.00375999f, 0.03530116f, 0.01769521f, -0.08217744f, -0.19632094f, 0.43638411f, -0.37969354f, 
    0.48106149f, -0.05808756f, -0.14549382f, -0.07387675f, 0.07908428f, -0.16860038f, -0.11722773f, -0.63199919f, 
    0.18654165f, -0.20698330f, -0.11561346f, -0.20109670f, -0.05949080f, 0.08338229f, 0.15746339f, -0.04339737f, 
    -0.07802695f, -0.01597320f, -0.17344911f, -0.13671865f, 0.34737581f, -0.51063424f, 0.21496908f, 0.16428179f, 
    0.02641768f, 0.13757679f, -0.01811272f, 0.24765705f, 0.09765046f, 0.09007686f, -0.13976415f, 0.28600305f, 
    0.10366844f, 0.05951880f, -0.06523316f, 0.08351313f, -0.07914595f, -0.25668627f, -0.27993086f, -0.07165279f, 
    0.09942125f, 0.17073473f, 0.15515880f, -0.01488636f, 0.07379652f, -0.00954662f, 0.04194009f, -0.18588755f, 
    -0.04791900f, -0.36266470f, -0.34871939f, -0.01954435f, 0.21728459f, 0.25112000f, 0.04485279f, -0.11848827f, 
    -0.16993502f, -0.42735347f, 0.07592089f, 0.05040161f, 0.07462069f, 0.75273556f, -0.13991293f, -0.06887608f, 
    -0.13774590f, 0.07859299f, 0.04906428f, 0.18960564f, 0.21713410f, -0.13396025f, -0.13692538f, 0.12110545f, 
    -0.10377478f, 0.05253396f, -0.26935527f, 0.15739743f, -0.09376059f, 0.18566522f, -0.08469594f, -0.15163378f, 
    0.32627800f, -0.06151239f, 0.01084257f, 0.03670304f, 0.10467283f, -0.05453404f, 0.03344991f, -0.03487864f, 
    -0.10981951f, -0.05695452f, -0.20961165f, 0.07774610f, -0.01953573f, -0.05710468f, 0.00477821f, 0.01208517f, 
    -0.06547275f, -0.26473600f, 0.46996635f, 0.02801353f, 0.06922121f, 0.15065339f, -0.03786960f, 0.16254687f, 
    0.10225585f, 0.03441972f, -0.03740263f, -0.08123402f, -0.32404786f, 0.11026704f, -0.01755263f, -0.17511082f, 
    0.16445902f, 0.01849751f, -0.20668699f, -0.89327264f, 0.26762909f, -0.15304635f, -0.17789954f, -0.09869263f, 
    0.33084017f, 0.02673929f, 0.07521330f, -0.08254396f, -0.03032561f, 0.18479738f, -0.31380519f, 0.13549273f, 
    0.11260988f, -0.06321453f, 0.15360689f, 0.00154317f, 0.05854508f, -0.05072667f, 0.08379133f, 0.11021929f, 
    -0.02094488f, 0.03790991f, 0.04923461f, -0.00206771f, -0.07494501f, 0.10810440f, -0.30220032f, -0.01564618f, 
    0.09544516f, 0.02766026f, -0.22891930f, 0.09271139f, -0.10272221f, 0.05722561f, 0.05574384f, -0.30570480f, 
    -0.09275278f, 0.21195304f, -0.08269558f, -0.08336923f, 0.00958762f, 0.10460430f, -0.06064615f, -0.06382520f, 
    -0.09235891f, 0.00769402f, -0.04546347f, -0.06214755f, 0.00717181f, 0.07084021f, -0.01453678f, 0.23862590f, 
    0.03797093f, -0.19677222f, 0.22796568f, 0.09875271f, 0.06219512f, -0.10106745f, 0.14462882f, 0.07905342f, 
    0.06585779f, 0.01040635f, -0.02683882f, -0.00929131f, 0.25496227f, 0.11194345f, 0.02149947f, 0.16111735f, 
    -0.04761874f, 0.13545303f, 0.02066096f, -0.07875755f, -0.05240477f, -0.01739184f, -0.03481247f, 0.02883433f, 
    -0.05248155f, -0.27132994f, 0.23013611f, 0.09312405f, -0.11395014f, 0.06344832f, 0.12803060f, 0.19131939f, 
    0.13718913f, -0.01157687f, -0.05025744f, 0.03894583f, 0.11666228f, -0.14086080f, -0.05689516f, 0.08772950f, 
    0.03541626f, -0.02277249f, 0.07437769f, 0.11946914f, 0.08576845f, -0.01785917f, -0.00685396f, -0.08156301f, 
    0.16133061f, 0.24340601f, -0.02778969f, 0.01023876f, -0.10039205f, 0.15548666f, 0.03066628f, 0.09556017f, 
    0.08819298f, 0.24212286f, 0.01853411f, 0.13262889f, 0.08867943f, -0.00399327f, -0.03115471f, 0.24182321f, 
    -0.04732958f, -0.01956523f, -0.02494146f, 0.22452722f, 0.01899332f, -0.11494718f, -0.17464355f, 0.12892748f, 
    -0.00411720f, -0.04543073f, 0.02059689f, 0.16907775f, 0.02556455f, 0.03329475f, -0.13391563f, 0.03180136f, 
    0.04410060f, 0.02668618f, -0.49534091f, -0.49272564f, -0.71521217f, -0.01587885f, 0.15014859f, 0.13658361f, 
    0.03228537f, -0.17473313f, -0.36111936f, 0.00467402f, -0.02552450f, 0.01696215f, -0.04006201f, 0.00086569f, 
    -0.07552163f, -0.05217901f, 0.11884335f, 0.12894841f, 0.01255926f, -0.06203675f, 0.16158213f, -0.12822215f, 
    0.01499576f, -0.09428715f, 0.11433652f, -0.25114512f, -0.14251275f, -0.02587548f, -0.08546351f, 0.09401435f, 
    -0.04643003f, -0.05679018f, -0.11729094f, 0.03942544f, -0.30416441f, -0.21507770f, -0.28162092f, -0.34758854f, 
    -0.38978967f, 0.14296886f, -0.03368443f, 0.16257153f, -0.03710491f, 0.17302425f, 0.11253389f, 0.03425583f, 
    0.13832614f, 0.11974253f, 0.05054618f, 0.12972671f, -0.08339258f, -0.10961057f, -0.21633339f, -0.16266699f, 
    -0.01847202f, -0.09981430f, -0.05175000f, -0.21697073f, 0.00833295f, -0.18934464f, -0.15531017f, -0.15780853f, 
    -0.04676985f, 0.06545835f, 0.05979512f, 0.06257600f, -0.02795325f, 0.03910309f, 0.19370924f, -0.15761569f, 
    -0.11891301f, 0.30561063f, -0.08515461f, -0.05644862f, 0.00588245f, 0.12964019f, 0.15906613f, -0.23911366f, 
    -0.23273419f, -0.10295908f, 0.09884270f, -0.11927707f, 0.01556483f, 0.14188208f, -0.17037810f, -0.12412606f, 
    0.04392797f, -0.09657809f, 0.11194640f, -0.25960693f, -0.05479581f, 0.07133664f, -0.00489783f, 0.10110467f, 
    0.21673284f, -0.18084130f, -0.02657189f, 0.07819617f, 0.15577404f, 0.07085427f, 0.04417830f, 0.25129396f, 
    -0.02844984f, 0.11937758f, 0.11659099f, 0.05451461f, -0.05455569f, 0.36219570f, -0.14506277f, 0.00540893f, 
    0.01950129f, 0.26715770f, 0.13829480f, -0.08779157f, -0.04475665f, -0.23989524f, -0.33172199f, -0.23275882f, 
    0.15652142f, -0.03210659f, 0.12052118f, 0.02943357f, -0.04028608f, -0.13959420f, 0.00871286f, -0.17511553f, 
    0.00325274f, 0.07343774f, 0.13429393f, 0.03044225f, 0.03157966f, 0.05880821f, 0.06870698f, -0.01744191f, 
    0.22543883f, 0.20172544f, 0.16162544f, 0.13705756f, -0.07437588f, 0.15282483f, 0.15806253f, 0.05540401f, 
    0.00349248f, -0.01263773f, -0.03010462f, 0.11534259f, 0.10286137f, -0.04541659f, 0.19546285f, 0.05200955f, 
    -0.16450895f, 0.34515992f, 0.12591265f, -0.37805954f, 0.11648971f, 0.62362450f, 0.10144021f, -0.01413337f, 
    -0.00992252f, 0.05763748f, -0.28523532f, 0.03147631f, -0.16610183f, 0.15184113f, -0.03861329f, -0.07405694f, 
    0.22379862f, 0.17164554f, 0.02239605f, 0.20534308f, 0.25631616f, -0.38718310f, 0.00427992f, 0.00574069f, 
    -0.06198123f, -0.02150268f, 0.07645936f, -0.08029545f, 0.01364679f, 0.03934586f, -0.20388654f, -0.21204929f, 
    -0.35780001f, -0.06757733f, -0.26104051f, -0.04557829f, 0.07476255f, 0.27002183f, 0.14461887f, -0.01102842f, 
    -0.27145875f, -0.15019767f, -0.03888933f, 0.08316677f, 0.05991691f, 0.04903706f, 0.08730195f, 0.16297728f, 
    -0.02389923f, 0.16580780f, 0.08752660f, 0.07615821f, 0.02753741f, -0.10403785f, 0.06311113f, 0.08372957f, 
    0.04495810f, -0.30376840f, -0.15941076f, 0.09219712f, 0.06572057f, 0.15174134f, 0.09501837f, 0.00094146f, 
    -0.02168085f, -0.04176996f, -0.04677113f, -0.06257669f, 0.01865987f, -0.07578190f, -0.12575033f, 0.01866092f, 
    -0.23708323f, 0.08541296f, -0.27085799f, -0.07388452f, 0.04167165f, -0.07953512f, 0.28989908f, 0.02772324f, 
    -0.06647851f, 0.22129875f, 0.01321522f, -0.05023456f, 0.40595603f, 0.27122736f, 0.18907706f, -0.10368594f, 
    -0.13160400f, -0.06951890f, 0.10158728f, 0.07374641f, 0.17953986f, -0.32343507f, -0.11238882f, 0.04413566f, 
    0.05188913f, 0.12646699f, -0.01413934f, 0.18064153f, -0.03599835f, -0.07274868f, 0.10837418f, 0.25789586f, 
    0.23143047f, 0.15191466f, -0.19819392f, -0.31372535f, 0.04339146f, 0.08983614f, 0.07324679f, 0.09032366f, 
    -0.12417836f, -0.07655363f, 0.02653207f, -0.07436173f, 0.04484860f, 0.03313137f, 0.18562210f, -0.08949487f, 
    0.03878328f, -0.02260657f, -0.06282517f, 0.31001213f, -0.09939680f, -0.14613293f, 0.05135078f, -0.08615427f, 
    -0.03138843f, 0.14148645f, 0.12218174f, -0.07656156f, 0.00370201f, -0.00250628f, 0.11605357f, 0.07575295f, 
    -0.04007484f, 0.11480700f, -0.47711059f, 0.31331617f, 0.24054714f, 0.10319594f, 0.05965591f, 0.05088129f, 
    -0.05095819f, -0.15428774f, -0.53434426f, 0.21407500f, 0.26155162f, 0.09217462f, 0.02608992f, -0.11705165f, 
    -0.17790410f, 0.08721747f, 0.07912071f, 0.14535095f, -0.02245110f, -0.12331261f, 0.01490388f, 0.09865510f, 
    -0.07893513f, -0.00108939f, -0.20471025f, -0.07948815f, -0.25344089f, 0.00550277f, -0.08341556f, 0.07531626f, 
    0.10611715f, -0.04515279f, 0.13263486f, -0.30943045f, -0.27768764f, -0.21172836f, 0.04636148f, 0.55618894f, 
    0.29627341f, -0.04183363f, 0.14959048f, 0.05908579f, 0.13430572f, 0.05817662f, -0.05303875f, 0.48144889f, 
    0.23168418f, -0.25645620f, 0.13057385f, -0.06042847f, 0.23030427f, -0.19994798f, -0.11665308f, -0.23172589f, 
    0.04449897f, -0.13085541f, 0.00452418f, -0.08399992f, 0.01610179f, -0.00490675f, -0.03741942f, -0.00600968f, 
    -0.10305168f, -0.10753328f, -0.26431304f, -0.19329132f, 0.00236573f, -0.11518649f, 0.07512560f, -0.23852153f, 
    0.06148880f, -0.25755933f, 0.03144415f, -0.00609478f, -0.01533793f, 0.17851180f, 0.11252110f, -0.07375704f, 
    0.00102774f, 0.03500799f, -0.00740548f, -0.02902129f, -0.06338978f, 0.06362186f, 0.00659752f, 0.10070254f, 
    0.16180319f, 0.13614151f, 0.13926764f, -0.22979610f, 0.05074117f, -0.11610585f, -0.05073305f, 0.14472574f, 
    0.01475564f, -0.00334712f, -0.08068933f, 0.05377704f, -0.04275075f, 0.22881253f, -0.05073779f, 0.14557102f, 
    -0.05047555f, -0.03441363f, 0.22497548f, -0.29175457f, 0.05184309f, -0.16091423f, 0.03093129f, -0.04178097f, 
    -0.07356994f, 0.08416942f, -0.03879457f, 0.16220194f, -0.21997604f, -0.20803133f, -0.20166567f, 0.02048555f, 
    -0.11533836f, -0.17909265f, -0.01056414f, 0.11933707f, -0.06211316f, -0.00153444f, -0.15197641f, 0.10121317f, 
    -0.35865155f, -0.38565111f, 0.03428461f, 0.06176315f, 0.11056565f, 0.02255137f, 0.19559827f, 0.04506337f, 
    0.25863394f, 0.29926819f, 0.17294119f, -0.04913652f, 0.03499511f, 0.04326580f, -0.00916381f, 0.04294962f, 
    0.00661966f, -0.03122239f, -0.29808059f, -0.05557935f, 0.03434335f, 0.02255116f, 0.21464646f, -0.01998282f, 
    0.02004157f, 0.06385788f, -0.24146819f, 0.32617807f, 0.32023740f, 0.18948157f, -0.01105838f, 0.03910879f, 
    0.11453695f, -0.00396599f, 0.02286926f, -0.01672768f, -0.15786424f, -0.15917304f, 0.01246996f, 0.06894764f, 
    0.10910891f, 0.03379885f, 0.08495145f, 0.01716142f, -0.37293997f, 0.42344296f, 0.30667588f, 0.16556434f, 
    -0.03271997f, 0.30660513f, -0.42666593f, 0.06266862f, 0.01445105f, 0.17319109f, 0.14517815f, 0.42191571f, 
    0.32822773f, -0.20796718f, 0.39481768f, 0.05302200f, 0.12539215f, 0.07954039f, 0.17231853f, 0.24826546f, 
    0.19151948f, 0.09478619f, 0.11142633f, 0.13015045f, 0.05596790f, 0.04659309f, -0.07660355f, -0.12975593f, 
    -0.17754734f, 0.17812133f, 0.38331634f, -0.14075184f, 0.01953244f, -0.01994119f, -0.14219338f, 0.04698643f, 
    0.10623947f, -0.34495047f, -0.55610758f, -0.10346939f, -0.08695835f, 0.03911836f, -0.22581699f, -0.15789515f, 
    0.02106813f, 0.14490484f, -0.56649083f, -0.33602223f, -0.01039728f, 0.14908226f, -0.09064213f, 0.00557159f, 
    -0.01185426f, 0.15294321f, -0.15086792f, -0.31594172f, -0.40232342f, -0.16046318f, 0.05356782f, -0.21341491f, 
    0.14464669f, 0.04151189f, 0.14245549f, 0.01194474f, 0.21552683f, 0.13901182f, -0.28352275f, 0.15148523f, 
    -0.02945820f, 0.26464012f, -0.04476296f, 0.09171408f, 0.10774516f, -0.43992737f, -0.25435615f, 0.17435431f, 
    -0.37057850f, -0.02592025f, -0.09031837f, 0.10762408f, 0.09625889f, -0.02800174f, -0.81662315f, -0.29852405f, 
    0.54874712f, -0.12297765f, 0.07613446f, -0.05639701f, 0.17956851f, 0.06928968f, 0.22349714f, -0.09396986f, 
    -0.51980662f, -0.62237990f, -0.09667255f, -0.01057086f, 0.19714817f, 0.06134079f, -0.10044298f, -0.08791648f, 
    -0.27108806f, -0.07566842f, -0.41791290f, -0.32065699f, -0.21902347f, -0.26583099f, 0.15385562f, 0.16123195f, 
    0.21073106f, 0.53961235f, 0.12219729f, 0.36504427f, 0.08769108f, 0.14556614f, 0.09316182f, 0.20202343f, 
    -0.01435150f, 0.11936847f, -0.28977731f, -0.00365451f, -0.14807944f, -0.07909496f, -0.01708011f, -0.29931781f, 
    0.02060744f, -0.01843216f, 0.24911468f, -0.12202574f, -0.07158115f, 0.03744642f, 0.09580108f, 0.16313183f, 
    0.04161963f, -0.13888577f, 0.06514993f, 0.32326189f, -0.15985154f, 0.05296671f, 0.18541738f, -0.00056743f, 
    -0.23727369f, -0.05859048f, 0.10342401f, 0.02661987f, 0.07537298f, -0.99265921f, -0.18295212f, 0.20280130f, 
    0.00038235f, -0.09755740f, -0.01041261f, 0.13935043f, 0.00253513f, -0.03047842f, 0.10315079f, 0.30672422f, 
    0.06748647f, -0.49170890f, -0.05839713f, -0.19740310f, 0.20685698f, -0.14338149f, 0.16861834f, 0.70200658f, 
    0.25081775f, -0.23896249f, -0.03258156f, 0.10245901f, 0.18967314f, 0.02631507f, 0.08492718f, 0.08727078f, 
    0.20849742f, -0.41857302f, -0.33533993f, 0.28188667f, -0.04218011f, -0.40243155f, 0.24149145f, 0.05754025f, 
    -0.00895485f, -0.26092762f, 0.43224493f, 0.17500658f, -0.09904441f, -0.04828370f, -0.30751920f, -0.09125257f, 
    0.10554887f, -0.15226850f, -0.18253210f, -0.17512539f, -0.37088421f, -0.11248756f, -0.12699820f, 0.10584965f, 
    0.26418009f, 0.01216061f, 0.23337922f, 0.27027187f, -0.27023685f, -0.47840491f, 0.18826143f, -0.01934029f, 
    0.15390868f, -0.01932666f, 0.17063273f, -0.13621868f, -0.06858702f, -0.31040221f, -0.36666012f, -0.21675372f, 
    -0.14227387f, -0.15336984f, 0.27923027f, 0.04694202f, 0.07043920f, -0.57077569f, -0.39052233f, -0.46684551f, 
    -0.25684014f, -0.08724523f, -0.04309896f, 0.02599484f, 0.03856281f, -0.10700621f, 0.55509490f, -0.12525688f, 
    -0.26373088f, -0.07478962f, -0.19531560f, -0.13883653f, 0.21348035f, 0.14299829f, -0.18410768f, 0.61745161f, 
    -0.01208812f, 0.18339449f, 0.16927986f, 0.00102847f, 0.07551104f, -0.04207486f, 0.03033136f, -0.06158860f, 
    -0.07693677f, -0.66647768f, -0.69621348f, -0.19937427f, -0.13193190f, -0.09251115f, 0.04020108f, 0.02861488f, 
    0.04760551f, 0.28231484f, 0.07308052f, 0.01591867f, 0.05053759f, 0.30074382f, 0.11475911f, 0.01822459f, 
    0.14298031f, 0.13433792f, -0.48134694f, -0.45545325f, -0.37011418f, -0.28388658f, -0.15153526f, -0.09026274f, 
    -0.01846814f, 0.01799741f, 0.00959604f, 0.10250530f, 0.40551290f, 0.02260192f, 0.12581648f, 0.01355582f, 
    0.30434075f, 0.13074952f, 0.05308457f, 0.01509341f, -0.24498466f, -0.20895442f, -0.46924850f, 0.02291992f, 
    0.10318487f, 0.04991191f, -0.12971316f, 0.25599605f, 0.00331968f, -0.03801785f, -0.27668068f, -0.63848305f, 
    0.06216088f, 0.08952247f, 0.36999032f, -0.13058536f, 0.06264939f, 0.10195606f, 0.35752970f, 0.31616664f, 
    0.18271676f, -0.23325063f, -0.27731049f, -0.15222992f, 0.16406545f, 0.10707618f, 0.06851349f, 0.41524410f, 
    0.37632746f, 0.33240142f, -0.08716283f, 0.05485316f, 0.13574205f, 0.11922279f, 0.08212852f, 0.05744921f, 
    0.12262941f, 0.07355685f, 0.01691954f, 0.09757916f, -0.04215370f, 0.00789467f, 0.22326469f, -0.03972106f, 
    -0.17605409f, -0.13443360f, -0.47961465f, 0.17720248f, 0.05093088f, -0.03520019f, -0.04267789f, -0.04340546f, 
    0.09740622f, 0.04363795f, -0.40192175f, -0.13073087f, 0.00209742f, -0.06742669f, 0.00830564f, 0.03558619f, 
    0.23318321f, 0.17005181f, -0.09130260f, 0.08553919f, 0.01503258f, 0.07527266f, -0.06017965f, -0.00971471f, 
    -0.02372469f, 0.19771133f, -0.03388508f, 0.09801663f, 0.45663461f, -0.00360708f, 0.42611298f, -0.21803921f, 
    -0.13424265f, -0.13161124f, 0.06883389f, 0.04761358f, 0.10644861f, -0.28890768f, -0.37302136f, -0.26158670f, 
    0.03072038f, -0.12589300f, 0.00858452f, -0.08076984f, 0.24934268f, -0.00647581f, -0.16450131f, 0.47475398f, 
    0.26670858f, 0.04222672f, 0.13593513f, -0.15135477f, 0.06679168f, 0.18136078f, -0.34077787f, -0.48288068f, 
    -0.42131755f, -0.16809671f, -0.03274209f, -0.01851520f, 0.06902503f, -0.15283349f, 0.03709900f, -0.16779222f, 
    0.13988388f, 0.05404759f, 0.13144214f, -0.34665442f, 0.02039973f, 0.09792167f, 0.11055782f, 0.01077020f, 
    0.03148660f, 0.16896538f, 0.44377074f, 0.20515226f, 0.00428617f, 0.14464025f, -0.15291935f, 0.06318650f, 
    0.00989252f, -0.05245928f, 0.33749333f, 0.08071819f, -0.05977331f, -0.00550947f, 0.01144459f, 0.11522178f, 
    0.00134582f, 0.04720707f, 0.09186032f, 0.18582465f, 0.23253825f, 0.17356615f, -0.04519996f, -0.04312721f, 
    -0.01203751f, 0.12089345f, 0.14032465f, 0.00312477f, -0.10752635f, -0.13734093f, -0.02711170f, 0.02165338f, 
    -0.05765171f, 0.01502015f, 0.17861062f, -0.02329894f, 0.06583758f, -0.13466440f, -0.20374787f, -0.16203386f, 
    -0.02629049f, -0.04975371f, 0.01865381f, 0.28581303f, -0.03213079f, 0.02497289f, 0.17088127f, 0.56449527f, 
    0.33528543f, -0.08298619f, -0.01077425f, 0.17609772f, -0.05754796f, -0.10524745f, -0.10593203f, -0.42918724f, 
    0.09093890f, 0.27979285f, -0.05504516f, 0.00415354f, -0.10671967f, 0.07359888f, 0.02619936f, 0.10731257f, 
    -0.35018295f, -0.24251591f, 0.16696489f, -0.03894908f, -0.13983983f, -0.15286985f, 0.01302903f, -0.02771240f, 
    0.13843030f, -0.08964641f, -0.14892331f, -0.25445473f, -0.11520538f, -0.03439234f, 0.21036419f, 0.02873327f, 
    0.00509944f, 0.07591184f, -0.01643729f, 0.10289431f, 0.21675780f, -0.18536748f, -0.03671551f, 0.07774981f, 
    0.15765721f, -0.03081317f, 0.05191470f, -0.13798907f, -0.08034503f, 0.22956496f, 0.07479326f, -0.01458331f, 
    0.09308137f, 0.20437224f, -0.06781331f, 0.05858703f, 0.04834039f, 0.09904979f, 0.08734617f, -0.23137587f, 
    -0.03143176f, 0.10215741f, 0.02437218f, 0.00944894f, 0.16925132f, -0.28758496f, -0.69136548f, -0.14750546f, 
    -0.20517899f, -0.04127500f, 0.27848667f, -0.03238540f, 0.00744885f, -0.20387213f, -0.32632026f, 0.00540930f, 
    0.15121911f, -0.04135476f, -0.01191225f, -0.23228247f, 0.18221191f, 0.01227417f, -0.14991646f, 0.11150791f, 
    0.09317021f, 0.31880748f, 0.01843581f, 0.15151374f, -0.17004645f, 0.18955943f, 0.05876808f, 0.04015552f, 
    -0.47469547f, -0.40959215f, -0.27623492f, 0.15640900f, 0.02188181f, -0.03562947f, 0.04187048f, 0.17242724f, 
    -0.00691207f, -0.17245349f, 0.30968639f, 0.54330665f, -0.21073276f, -0.20568801f, -0.08072725f, 0.03627317f, 
    0.01187906f, 0.12563762f, -0.14960247f, -0.33606863f, -0.17435618f, -0.00874361f, 0.03817066f, 0.04389203f, 
    -0.10851184f, -0.14972423f, 0.07107931f, -0.04420451f, -0.15255398f, 0.16759251f, -0.17337410f, 0.03720190f, 
    -0.01144556f, 0.09182054f, 0.00535069f, 0.12073820f, -0.08870808f, -0.25391310f, -0.49870363f, 0.05342195f, 
    0.03474034f, 0.01747429f, 0.00451988f, -0.08963157f, -0.01246210f, 0.53645843f, -0.05652626f, 0.44494632f, 
    -0.09428622f, -0.29880336f, -0.10890925f, 0.16026258f, 0.06794529f, 0.08177341f, 0.05616093f, 0.06740002f, 
    0.13805139f, -0.01443247f, -0.17177054f, -0.01456942f, 0.10036363f, -0.13423859f, -0.03191066f, 0.14392707f, 
    0.34955308f, 0.21856491f, -0.08958562f, 0.13105799f, -0.15201347f, 0.10293653f, 0.04286704f, -0.02461524f, 
    -0.02519435f, -0.22263019f, 0.01208962f, -0.15577155f, -0.00781762f, -0.10079746f, 0.03275401f, 0.28360236f, 
    0.17786530f, 0.30683005f, -0.40154061f, -0.09162201f, 0.16459760f, -0.13524011f, -0.25562209f, 0.06706801f, 
    0.04820142f, 0.07261357f, 0.44324595f, 0.06089622f, -0.15806256f, -0.12128229f, 0.07918230f, 0.00927631f, 
    0.08241311f, 0.02162944f, 0.21036297f, -0.22878294f, -0.20655096f, -0.11457009f, -0.20523480f, -0.34181812f, 
    -0.16729040f, 0.02270813f, 0.06620982f, -0.03474373f, -0.45239738f, 0.34441504f, 0.33285201f, 0.01166507f, 
    0.07995596f, 0.01973133f, -0.06019278f, -0.02398732f, 0.02243403f, -0.10319301f, -0.14558354f, 0.08557533f, 
    -0.05752151f, 0.01009203f, -0.21143299f, 0.31297609f, 0.11135456f, 0.07638200f, 0.36409402f, -0.81741899f, 
    -0.38088936f, -0.32006916f, -0.12736206f, -0.00640255f, 0.10994557f, 0.19129097f, 0.02795840f, 0.08147727f, 
    0.08567066f, 0.13622636f, -0.05854072f, 0.00227075f, 0.15967619f, 0.03510286f, -0.07365151f, 0.08616069f, 
    -0.07676490f, -0.25456333f, -0.40324274f, -0.28290534f, -0.25862503f, 0.05992707f, 0.28567892f, -0.18139644f, 
    0.03963643f, -0.01189213f, -0.05389790f, -0.11041392f, -0.01703061f, -0.00305619f, -0.02414383f, 0.08620969f, 
    0.11981729f, 0.19695015f, -0.34103236f, -0.15407334f, -0.41533116f, -0.61242235f, -0.07051533f, -0.02002918f, 
    0.05931778f, 0.02387838f, 0.00845459f, -0.41118866f, -0.21128669f, -0.02431626f, -0.02980278f, -0.03116325f, 
    0.06841194f, 0.20055526f, -0.05310722f, -0.13640825f, -0.17027266f, 0.15469000f, -0.02022361f, 0.05947947f, 
    0.10284003f, -0.16613540f, -0.04398259f, 0.03149098f, 0.16395997f, 0.16757242f, 0.01400101f, -0.13341954f, 
    0.03168024f, -0.04683614f, -0.11887484f, 0.05910854f, 0.28391227f, 0.22434305f, -0.08155391f, -1.01728964f, 
    -0.81594718f, -0.18352096f, 0.06432884f, 0.15682411f, 0.21870776f, 0.02545644f, -0.09393570f, 0.20000367f, 
    -0.13892737f, 0.22925180f, -0.03154657f, 0.05000995f, -0.13534215f, 0.10006097f, 0.14205790f, -0.05213461f, 
    -0.36447030f, 0.08156633f, 0.09719384f, 0.38083503f, 0.11673500f, -0.21393125f, 0.07029499f, 0.15589312f, 
    0.24330783f, -0.01327749f, 0.16725266f, 0.12854983f, 0.14007917f, 0.03944266f, -0.16984293f, 0.15807268f, 
    0.16200700f, 0.09314685f, -0.13488308f, 0.21447538f, -0.15162152f, -0.18644248f, -0.00503469f, 0.12435436f, 
    0.06169185f, -0.19225882f, -0.04731656f, -0.07630528f, -0.09637829f, -0.08220099f, -0.08323134f, 0.08285245f, 
    -0.26347131f, -0.04593549f, -0.19427603f, 0.12399246f, -0.11840214f, -0.01173610f, -0.02902126f, -0.01535684f, 
    -0.05208962f, 0.11592171f, 0.25284401f, -0.08700089f, 0.18093491f, 0.12890017f, -0.42607969f, 0.27459329f, 
    0.17813702f, -0.03671252f, 0.27679902f, 0.22909829f, 0.13047066f, 0.07314181f, 0.32534277f, -0.18591624f, 
    -0.03333034f, 0.01292383f, 0.19139273f, -0.06613983f, 0.04100142f, -0.03844550f, 0.22580370f, -0.02183701f, 
    -0.06660696f, -0.13428290f, -0.04789934f, 0.03918191f, 0.06905289f, -0.08380766f, 0.05610053f, 0.02365524f, 
    0.25037062f, 0.11624049f, -0.01388035f, -0.13572545f, -0.12067153f, -0.13387617f, 0.20525157f, -0.08011160f, 
    0.05239360f, 0.13620572f, -0.34092447f, 0.34822607f, 0.22009170f, 0.06160006f, -0.32272476f, 0.03244838f, 
    0.08687495f, 0.10608284f, 0.09296101f, -0.00869687f, -0.08689133f, 0.13249661f, -0.16413395f, 0.15118894f, 
    0.05897599f, 0.11183684f, 0.05027155f, 0.30218923f, -0.15386787f, -0.04084748f, -0.04452712f, 0.22906311f, 
    -0.03315800f, -0.04221119f, 0.02244201f, 0.25593039f, -0.09218680f, 0.22370373f, 0.21619827f, 0.12996531f, 
    0.07793561f, 0.00868405f, 0.13608763f, 0.11102454f, 0.22832914f, -0.54023701f, 0.00956683f, 0.27200270f, 
    -0.30383945f, 0.02910458f, 0.00540419f, -0.15617201f, 0.02942250f, -0.16651040f, -0.13800335f, -0.67708421f, 
    -0.04480721f, -0.03481084f, -0.05270207f, -0.25405073f, 0.01665990f, 0.05213745f, -0.09385954f, 0.16848475f, 
    -0.09242086f, -0.09230102f, -0.25099784f, -0.00882407f, -0.20163332f, 0.10276517f, 0.09941165f, 0.12806590f, 
    -0.10853557f, -0.13122897f, -0.05890168f, 0.03464132f, 0.08460557f, -0.05002420f, 0.20728356f, 0.19892389f, 
    0.15893102f, 0.07704273f, 0.27419254f, -0.00259629f, 0.01935443f, 0.16165832f, -0.03105450f, 0.04700503f, 
    0.26740611f, 0.02275519f, 0.03152385f, 0.08923654f, 0.10131857f, -0.01841778f, 0.00116726f, -0.15010260f, 
    0.08304533f, 0.00859553f, 0.07053652f, 0.09117777f, 0.34743410f, -0.10251483f, -0.04425503f, 0.05954063f, 
    -0.03884034f, -0.00849498f, 0.05308815f, -0.12013268f, -0.28975633f, -0.59259748f, -0.57296330f, -0.04919999f, 
    0.03248883f, 0.05949609f, 0.07795564f, -0.00656041f, -0.07524689f, -0.03488141f, 0.20109515f, -0.06233801f, 
    -0.13719085f, -0.17392930f, -0.04771746f, 0.09632891f, 0.09776021f, -0.15263700f, 0.19931547f, -0.38287017f, 
    0.07826384f, -0.11697721f, -0.20601267f, 0.08367473f, 0.18657416f, 0.16476372f, 0.32190755f, -0.05680087f, 
    -0.03506704f, 0.20122486f, -0.09960140f, 0.23349947f, -0.20955178f, 0.23718159f, 0.03226047f, 0.06660755f, 
    0.17406896f, 0.04335606f, -0.19778344f, -0.09287205f, -0.03389651f, -0.06106405f, -0.00925365f, 0.10281914f, 
    -0.08699995f, -0.04414816f, -0.26793888f, -0.86894470f, -0.15554217f, 0.12401512f, 0.09865122f, 0.08623704f, 
    -0.07032514f, 0.06468326f, -0.22377932f, 0.17410988f, 0.38416761f, -0.00015337f, -0.24437734f, -0.04964928f, 
    0.30342224f, 0.19863023f, 0.20741166f, -0.20549685f, -0.22510858f, -0.14405239f, 0.10768496f, 0.01147070f, 
    -0.04974703f, 0.13785402f, -0.01237813f, 0.02164679f, 0.03735777f, 0.24062966f, 0.03883503f, -0.00597310f, 
    0.00130170f, -0.01212924f, -0.06952215f, 0.07066938f, 0.00039490f, 0.01101309f, 0.34261271f, -0.02558126f, 
    0.06146386f, -0.01467920f, -0.00481998f, -0.02379850f, -0.03824314f, -0.05322592f, 0.46613520f, 0.34276307f, 
    0.21531886f, -0.17385951f, 0.11682246f, -0.09945656f, 0.24900153f, 0.15124950f, 0.22410597f, -0.47905853f, 
    0.32197967f, -0.70796090f, -0.27661231f, -0.20699511f, 0.36263028f, 0.05401557f, 0.05838058f, -0.01722729f, 
    -0.31400034f, 0.32838762f, -0.40631020f, -0.05619645f, 0.20418109f, -0.08416440f, -0.11134452f, -0.00247686f, 
    -0.19845180f, -0.14339088f, 0.30913958f, 0.11367591f, -0.06772257f, -0.06325001f, -0.03599348f, 0.05199559f, 
    -0.00738177f, 0.06462511f, -0.00908987f, 0.05416020f, -0.08739708f, -0.11789218f, 0.00378714f, -0.04316994f, 
    0.00994988f, 0.09521637f, 0.03960703f, -0.00591538f, 0.25283119f, 0.12000475f, -0.11318035f, -0.05310905f, 
    -0.16341135f, -0.05837404f, 0.05977071f, -0.16487278f, 0.10474548f, 0.03905483f, -0.16978367f, -0.07375701f, 
    0.13023673f, -0.05887005f, 0.03216441f, 0.03952901f, 0.08682152f, -0.07826829f, -0.34090093f, -0.03795920f, 
    -0.05478042f, 0.45097420f, -0.18337533f, 0.10463697f, 0.20485525f, -0.04421799f, -0.03011362f, -0.30557147f, 
    -0.37001982f, -0.17999762f, -0.01198242f, 0.22094823f, -0.25742730f, -0.19878742f, -0.18206841f, -0.25248134f, 
    -0.67541981f, -1.06098604f, -0.27986616f, -0.00720800f, 0.16967526f, 0.03298949f, -0.11119282f, 0.02612301f, 
    -0.02357232f, 0.03243687f, 0.12531300f, -0.17256981f, 0.02593840f, -0.15206857f, 0.10383505f, 0.20664875f, 
    0.11751605f, 0.10278384f, 0.36264104f, -0.43291333f, -0.03750578f, 0.26752877f, -0.12906623f, -0.06417921f, 
    0.07947838f, -0.09310116f, 0.06312328f, 0.12144018f, -0.00202513f, -0.06335479f, -0.07100049f, -0.12679878f, 
    0.15442388f, 0.11658106f, -0.00465714f, -0.22889289f, -0.13236700f, -0.90182573f, -0.28803778f, 0.11631219f, 
    0.24233051f, 0.07726904f, 0.07744003f, -0.20729136f, -0.09779642f, 0.14671752f, -0.07992319f, -0.01244956f, 
    -0.11289687f, 0.03188337f, -0.00615269f, 0.14845712f, 0.01816306f, -0.28702992f, -0.34952217f, -0.21993256f, 
    0.00265103f, 0.25195605f, 0.06020528f, 0.22303367f, 0.04994634f, -0.02350135f, -0.47289008f, 0.14623274f, 
    0.34537619f, -0.19076039f, 0.22838944f, -0.11362717f, -0.00528846f, 0.36334065f, 0.09490434f, -0.11322703f, 
    0.13771185f, -0.04982083f, -0.03402272f, -0.03406436f, 0.12111926f, 0.10144386f, 0.02306282f, 0.16242833f, 
    0.20681421f, -0.07236456f, -0.01082755f, 0.02227261f, 0.08691470f, 0.03087616f, 0.00571345f, -0.05706556f, 
    -0.08301860f, -0.12537962f, 0.04464835f, 0.17268825f, -0.02275813f, -0.08805483f, 0.08761624f, -0.04777155f, 
    0.14877674f, -0.04590084f, 0.15103538f, 0.19936877f, 0.09775586f, -0.02625957f, 0.00985662f, -0.09280930f, 
    -0.05645485f, 0.23963690f, 0.16516204f, 0.00769071f, -0.12338547f, -0.14262491f, -0.10084951f, -0.15872860f, 
    0.08583064f, 0.15043864f, -0.00274105f, -0.14780053f, 0.23629792f, -0.17636381f, -0.29744169f, 0.13164647f, 
    0.11873453f, -0.05185949f, 0.09452962f, -0.22974586f, 0.01533405f, -0.37990177f, -0.06634596f, 0.12117071f, 
    -0.01945625f, -0.00397977f, 0.11990380f, 0.11031605f, 0.00034552f, -0.18189672f, 0.39082608f, -0.28901711f, 
    -0.13939635f, 0.03309875f, -0.21009694f, 0.12416738f, -0.12235288f, -0.07312268f, -0.44728059f, -0.26933989f, 
    -0.33282602f, 0.09399477f, -0.03959820f, 0.09756050f, 0.07842857f, 0.09875312f, -0.19435763f, 0.07675986f, 
    -0.15451866f, -0.16126686f, -0.00914390f, -0.14195883f, 0.02354066f, 0.13915126f, 0.04650229f, -0.03943021f, 
    -0.15729192f, 0.04881109f, -0.08409271f, -0.31114626f, 0.14662023f, 0.01957984f, 0.05231298f, -0.01753025f, 
    0.07079744f, -0.06144246f, 0.24606068f, 0.02216653f, 0.10975693f, -0.05877946f, -0.30493006f, -0.31796426f, 
    -0.11895781f, 0.09513235f, 0.01787572f, 0.10078415f, -0.00067972f, -0.05756082f, -0.04236669f, 0.17223066f, 
    -0.01463330f, -0.10030010f, -0.14331438f, -0.12086511f, -0.21229896f, 0.09939837f, 0.33606890f, 0.07847697f, 
    0.05402187f, 0.02591697f, 0.01843977f, 0.05530535f, 0.15995495f, 0.01908460f, 0.28260061f, 0.19377437f, 
    0.02256930f, 0.03684352f, -0.01696045f, -0.03088917f, 0.16579545f, 0.10000248f, 0.95143425f, -0.27136821f, 
    -0.27481586f, 0.20030682f, 0.09533017f, -0.10614167f, -0.11491951f, 0.09257702f, -0.11344896f, 0.17210612f, 
    -0.26494211f, -0.65742218f, -0.07747250f, -0.24392584f, 0.04148040f, 0.01879832f, 0.06642129f, 0.19741797f, 
    0.13935298f, -0.11038837f, -0.18179238f, -0.15338974f, -0.06168203f, 0.00503016f, 0.06220340f, 0.01465654f, 
    -0.03434145f, -0.01786155f, 0.00667539f, -0.11741947f, 0.04785275f, 0.15007105f, 0.14067799f, 0.02190542f, 
    -0.02668384f, -0.05265020f, -0.04248025f, -0.14906345f, 0.17080019f, 0.02965838f, 0.07836939f, 0.00471637f, 
    -0.09263241f, -0.11786643f, 0.04177714f, -0.56766170f, -0.02663075f, -0.05110355f, 0.07550612f, -0.08291706f, 
    -0.05142237f, -0.03098643f, 0.00886500f, 0.03226364f, 0.01739553f, -0.06162095f, 0.09929947f, -0.03667438f, 
    0.04340288f, 0.10692506f, 0.18368807f, 0.11995282f, 0.01409988f, -0.03162073f, -0.40766063f, -0.27891693f, 
    0.18453974f, 0.01323325f, 0.14803906f, 0.16341411f, -0.07226634f, 0.04954389f, 0.08667026f, -0.12097759f, 
    0.05616966f, -0.14889735f, -0.11783278f, 0.01661636f, 0.06170581f, -0.00437988f, 0.16842003f, 0.14578480f, 
    -0.08252873f, -0.10208261f, -0.03031072f, 0.21061447f, 0.25083926f, -0.01335469f, 0.01699195f, -0.05385680f, 
    -0.22822893f, 0.03192735f, 0.07895289f, -0.11422776f, -0.02169443f, 0.04268233f, 0.10901848f, -0.04656626f, 
    0.08705113f, 0.00368086f, -0.38603085f, -0.23137772f, 0.38371783f, 0.17699736f, 0.04234143f, 0.05654602f, 
    -0.10926060f, 0.13820314f, 0.26348445f, -0.30841535f, -0.17338009f, 0.33415678f, 0.03812581f, -0.03639205f, 
    -0.02066158f, 0.21289016f, 0.13729349f, 0.10293287f, -0.03633350f, -0.17444977f, -0.07357116f, 0.11437496f, 
    0.16243438f, 0.13587363f, -0.11473332f, -0.12232154f, -0.15238538f, -0.22891195f, -0.03152593f, 0.04115895f, 
    -0.13513507f, 0.05715696f, 0.10562058f, 0.03604892f, 0.12461899f, 0.08851665f, 0.14160724f, -0.01767041f, 
    0.07127046f, 0.00678935f, 0.16071600f, -0.05374955f, -0.19085288f, -0.32755134f, 0.00044155f, -0.01524553f, 
    0.18526348f, -0.17969798f, -0.04558544f, -0.08042089f, -0.07665905f, -0.09686489f, -0.15738936f, 0.25794688f, 
    -0.10666551f, -0.35117823f, 0.13172525f, -0.11480831f, -0.11073491f, 0.00988699f, 0.05154928f, 0.03083548f, 
    0.11896105f, -0.14365263f, 0.08876621f, -0.02087408f, -0.01567503f, -0.01501600f, 0.14586179f, 0.24495624f, 
    0.07771756f, -0.05877464f, 0.16782603f, -0.22943869f, -0.03029260f, 0.25563970f, -0.04948889f, 0.11826810f, 
    0.01445180f, -0.01088740f, -0.13330284f, 0.02194040f, 0.05537884f, -0.04667977f, -0.01887433f, 0.01318144f, 
    0.16203500f, -0.04358366f, 0.33442080f, -0.10129209f, -0.23841932f, -0.03634236f, -0.16210645f, 0.06055531f, 
    0.00018078f, -0.21749493f, 0.03322035f, 0.09345990f, 0.16456169f, -0.09792352f, 0.11572008f, 0.07173783f, 
    -0.06099809f, -0.18783881f, 0.03650707f, -0.06398035f, 0.02110495f, -0.20669228f, -0.08981738f, 0.22181010f, 
    -0.01087965f, -0.04890639f, 0.00811809f, -0.02518381f, 0.06108210f, -0.07059859f, -0.19655040f, 0.19466799f, 
    -0.02200194f, -0.17090231f, 0.07043560f, -0.23237477f, 0.12300610f, 0.11119907f, 0.11298873f, 0.02188109f, 
    0.03227053f, 0.06050062f, 0.10697914f, 0.01700213f, 0.04558963f, 0.16050442f, 0.16886209f, 0.35907388f, 
    -0.45817423f, -0.27440685f, -0.02179129f, 0.12134830f, 0.05302004f, -0.06862481f, 0.05088090f, 0.02255589f, 
    0.20235103f, 0.05271364f, -0.14222842f, -0.05294989f, -0.11604590f, 0.23143128f, -0.03040961f, -0.00858990f, 
    0.00035537f, -0.02395472f, -0.12604730f, -0.24632439f, 0.00276259f, -0.20074162f, -0.05594422f, -0.04238364f, 
    0.10921934f, -0.09593720f, -0.11343394f, -0.02986479f, -0.10654971f, 0.09584671f, 0.11756416f, 0.04433551f, 
    -0.00269026f, 0.01600779f, 0.06843671f, 0.24732704f, -0.11064100f, -0.25899971f, 0.14828615f, 0.09388293f, 
    -0.04266556f, 0.05586638f, 0.15505745f, -0.06531285f, 0.06729732f, -0.20848431f, -0.10337784f, 0.21502782f, 
    -0.09597359f, -0.04078515f, 0.00820028f, 0.18159823f, -0.03046746f, 0.12826306f, -0.10874424f, -0.58185148f, 
    -0.16166086f, -0.05925888f, -0.04416310f, -0.08536752f, 0.02957265f, 0.21381354f, 0.01296315f, -0.10786953f, 
    0.05877851f, 0.01126413f, -0.10182089f, 0.29191774f, -0.30924791f, -0.06476815f, 0.02590795f, -0.24949345f, 
    0.14434686f, -0.38342720f, 0.31069952f, 0.08803137f, -0.24235553f, -0.00208406f, -0.13774809f, 0.12132870f, 
    0.17207290f, -0.10668411f, -0.15011324f, 0.11182383f, 0.00689993f, -0.18517348f, 0.11642855f, 0.04655932f, 
    0.00567884f, 0.17575233f, -0.17523277f, -0.12632249f, 0.04125356f, -0.02595937f, -0.01019982f, 0.01535987f, 
    0.07434791f, 0.15492144f, 0.22924498f, -0.45423937f, -0.26663548f, -0.10170974f, -0.15801081f, -0.03489826f, 
    -0.01280920f, 0.05726231f, 0.12785596f, 0.22726338f, -0.19519731f, 0.02106483f, -0.08231837f, 0.07457332f, 
    0.04390382f, 0.03843619f, 0.15847704f, 0.01571836f, 0.32095781f, -0.13712269f, 0.14553431f, 0.29702625f, 
    -0.08783948f, -0.09448631f, 0.06210116f, 0.31624290f, 0.07128178f, 0.19971135f, -0.08718961f, 0.13070969f, 
    -0.24246393f, -0.14579199f, 0.02961806f, -0.14064448f, -0.18919465f, -0.16372114f, -0.05519963f, 0.13877407f, 
    0.13935180f, 0.00402846f, -0.15308709f, -0.07679152f, 0.09389441f, -0.13626432f, 0.12212621f, 0.03190188f, 
    -0.15495150f, 0.21968956f, 0.11960390f, 0.13461567f, -0.00943532f, 0.04922701f, -0.02707696f, 0.00122387f, 
    0.15010221f, 0.12727286f, -0.03400866f, 0.13303809f, 0.06798936f, 0.30368322f, 0.31447971f, 0.02707108f, 
    0.08102023f, 0.30377665f, 0.08995225f, -0.07504555f, 0.03719538f, 0.02301395f, 0.09462003f, -0.00529324f, 
    -0.03285700f, 0.29113901f, 0.02030321f, -0.03343089f, 0.00926317f, 0.22202758f, -0.07268992f, 0.03351900f, 
    -0.00699002f, 0.06897096f, 0.02304552f, -0.11278857f, 0.11722470f, 0.05210719f, 0.02898174f, -0.08727803f, 
    0.04980069f, 0.09754422f, -0.13885999f, 0.22006822f, 0.13978936f, 0.06106361f, -0.13272455f, 0.05227010f, 
    -0.03481095f, -0.07647647f, -0.03570821f, -0.01847308f, -0.08911903f, -0.09745254f, -0.10692155f, -0.06886350f, 
    0.05142801f, -0.16727361f, -0.15106702f, -0.16263731f, 0.16774578f, 0.21327111f, 0.07036754f, -0.02794295f, 
    -0.26153320f, -0.27020881f, -0.09844316f, 0.12530741f, -0.15003388f, 0.04074789f, 0.13585062f, -0.11621469f, 
    0.13566901f, 0.02533850f, 0.15755624f, 0.17295232f, 0.13874374f, 0.12304953f, 0.01396834f, 0.11682259f, 
    0.08670206f, 0.10640125f, 0.29496136f, 0.11520937f, -0.05389888f, 0.06882816f, 0.16091552f, 0.10129708f, 
    0.05914317f, 0.14605562f, -0.04783868f, -0.02839407f, 0.10408449f, 0.12582873f, 0.05136006f, -0.01544123f, 
    -0.23577201f, 0.15355058f, -0.06430972f, -0.03608419f, 0.08457360f, 0.13147043f, -0.10433292f, 0.04826201f, 
    0.17888233f, 0.03035947f, -0.06432695f, 0.03751221f, 0.38133562f, -0.11938409f, -0.38646767f, -0.13403562f, 
    -0.08259390f, -0.04265190f, 0.16441078f, 0.09891228f, 0.13794810f, -0.12063622f, 0.00248694f, 0.07677451f, 
    0.05265922f, 0.08760618f, -0.00278393f, 0.02134387f, -0.20633459f, 0.02908395f, 0.51997745f, 0.32828301f, 
    -0.25970259f, 0.24970490f, -0.15838274f, -0.32490274f, 0.08121110f, 0.03048329f, -0.10355780f, -0.13474770f, 
    0.06346538f, 0.29157400f, 0.05385596f, -0.19200197f, 0.16123866f, 0.00871247f, -0.18065254f, 0.14226657f, 
    0.21520591f, 0.12953837f, 0.05869273f, -0.33237088f, -0.32425618f, -0.36056924f, 0.01276363f, -0.15379684f, 
    -0.00738713f, 0.26534802f, 0.14762874f, -0.11106800f, 0.07472838f, -0.06297795f, 0.01763484f, -0.16143839f, 
    0.09042345f, -0.05438367f, 0.09735146f, 0.02678202f, 0.21026157f, -0.11598837f, -0.05178275f, 0.04063115f, 
    -0.10660385f, -0.02688389f, -0.05794518f, 0.02326977f, 0.01152833f, -0.06948188f, -0.09239578f, -0.15773514f, 
    0.02805046f, 0.12328639f, 0.05124866f, 0.02100229f, 0.05799188f, 0.00836064f, 0.16402143f, -0.17543910f, 
    0.15138353f, -0.16075748f, 0.00065242f, -0.22437452f, 0.10426708f, 0.03066565f, 0.00934730f, 0.21978165f, 
    -0.11465514f, 0.14285858f, -0.14930075f, 0.10021423f, -0.01510232f, 0.10364342f, 0.15380646f, -0.36735597f, 
    -0.13224925f, -0.12163522f, -0.04525239f, 0.13723630f, 0.09625235f, 0.20346904f, -0.21598822f, 0.37485087f, 
    0.20083138f, -0.31157297f, -0.01920784f, 0.01438931f, -0.00966792f, -0.12950848f, -0.02566782f, 0.24669403f, 
    0.30685452f, -0.24006283f, 0.20311967f, -0.04635967f, 0.26110119f, -0.39883947f, -0.03577996f, 0.04135882f, 
    -0.04603560f, -0.24734299f, -0.28714827f, 0.18672283f, -0.02415668f, -0.00216294f, -0.15116985f, -0.09652787f, 
    0.21867116f, -0.01267558f, -0.02158040f, 0.08541244f, 0.07541446f, 0.10802028f, -0.42985135f, -0.30235773f, 
    -0.07142465f, -0.05321937f, -0.00081068f, -0.15254959f, 0.03916806f, 0.13500531f, -0.04954219f, -0.09593324f, 
    0.03335467f, -0.02577670f, 0.10188717f, -0.10690766f, 0.05795329f, 0.06681082f, 0.09671241f, -0.08649933f, 
    -0.20996119f, -0.50381142f, -0.00272073f, -0.09753378f, -0.01209620f, -0.17536272f, 0.01286178f, -0.35294360f, 
    -0.10055745f, -0.29849690f, 0.18562955f, 0.00594566f, -0.22003384f, -0.01184928f, 0.42134270f, 0.05095072f, 
    -0.11555842f, -0.28893730f, 0.23344123f, -0.30078802f, 0.13334876f, -0.20285095f, -0.13805856f, 0.75131249f, 
    -0.06731868f, 0.22228530f, 0.01430921f, -0.08566863f, -0.09351358f, 0.08655388f, 0.12326944f, -0.15500396f, 
    -0.25328168f, -0.11074460f, 0.37425748f, 0.07390276f, -0.00243122f, 0.01967197f, 0.25096872f, -0.00450568f, 
    0.32732335f, -0.01378308f, -0.23286894f, -0.25712910f, -0.12068887f, -0.30958369f, 0.16825849f, -0.07989074f, 
    0.22170050f, -0.03851672f, -0.40629879f, -0.15280567f, -0.25186631f, 0.13438958f, -0.01479044f, -0.10864878f, 
    0.10077084f, 0.56080747f, 0.01773866f, 0.79206181f, -0.04919690f, -0.31618077f, 0.04566844f, 0.03524867f, 
    -0.15119845f, -0.03102201f, -0.21815990f, -0.14406797f, -0.39342627f, -0.26404351f, -0.09627002f, -0.12716317f, 
    0.11586688f, 0.11164735f, 0.06267311f, 0.02070741f, 0.04110536f, 0.36963931f, -0.16404170f, -0.26537171f, 
    0.14328349f, -0.16667536f, 0.13456337f, 0.04639756f, 0.01434310f, 0.07050527f, 0.23537555f, 0.25227848f, 
    0.13680224f, -0.11721136f, 0.03286849f, 0.17600043f, 0.10948390f, -0.28793979f, -0.03717798f, 0.41535383f, 
    0.04703788f, -0.04038475f, 0.05429595f, -0.01862934f, -0.09414465f, -0.02486865f, 0.25857449f, -0.06262939f, 
    -0.05047427f, -0.07716028f, 0.02713274f, 0.04013163f, -0.00842886f, 0.01783116f, -0.23457415f, -0.03783267f, 
    0.07038063f, 0.10891005f, 0.10706907f, 0.26957521f, 0.02923760f, -0.12292918f, -0.13249525f, 0.04512292f, 
    -0.02848447f, -0.12475831f, 0.10393044f, 0.14886513f, 0.12516627f, -0.01046248f, 0.07899394f, -0.07839128f, 
    -0.05570042f, -0.02768584f, 0.16437286f, -0.02343857f, 0.17845182f, 0.16674189f, 0.06587977f, -0.03772528f, 
    -0.18630263f, -0.14411202f, 0.09283704f, 0.00794310f, -0.28524530f, 0.36017078f, 0.26505423f, -0.16018556f, 
    -0.02996117f, -0.02765330f, -0.07983442f, 0.00449212f, 0.08215483f, 0.06773614f, 0.14914484f, 0.19686529f, 
    0.10899089f, 0.00353126f, -0.37939748f, 0.16331418f, 0.15329134f, 0.01095335f, -0.08164911f, 0.51594442f, 
    -0.12193590f, -0.07293230f, 0.05668768f, -0.19317710f, 0.04544372f, 0.32565391f, 0.07385205f, 0.11373110f, 
    0.03128311f, 0.24089095f, 0.03746566f, -0.25027803f, 0.12292624f, -0.02010966f, 0.02227594f, 0.00499059f, 
    -0.04588243f, 0.15820085f, -0.01596097f, 0.04929335f, 0.03438655f, -0.07187050f, -0.01505112f, 0.10017770f, 
    -0.17786373f, -0.29534328f, 0.45276970f, 0.00204970f, 0.01292055f, 0.06609624f, -0.00993137f, 0.02251657f, 
    -0.03630383f, 0.08156648f, -0.81251705f, -0.24940032f, -0.29652700f, 0.04505681f, 0.12424037f, -0.03818064f, 
    0.02013797f, -0.12044763f, -0.01166369f, 0.02366152f, -0.02612082f, 0.12812136f, -0.20969968f, -0.02498925f, 
    0.01883385f, -0.17073919f, 0.18861893f, -0.12522870f, 0.04419610f, -0.02568559f, 0.09323809f, 0.03131339f, 
    -0.19039288f, -0.06599890f, 0.02561395f, 0.17855287f, 0.04728882f, 0.01974589f, 0.11996868f, 0.00139160f, 
    0.02793100f, -0.03681375f, -0.02397190f, 0.02167009f, 0.21120940f, 0.06674624f, -0.86267442f, -0.72240615f, 
    -0.07538784f, -0.19726956f, 0.07175444f, -0.01703844f, 0.03972090f, -0.12041511f, -0.15558526f, -0.53924364f, 
    0.02144218f, 0.61374146f, -0.07325334f, -0.00134434f, -0.04404832f, -0.10447472f, 0.06434643f, -0.01764035f, 
    -0.14155531f, 0.04976135f, 0.10750179f, -0.25341895f, 0.08903299f, -0.06213655f, -0.06475490f, 0.15785350f, 
    0.19036484f, -0.10327093f, 0.40348497f, -0.02876075f, 0.05790726f, -0.20988669f, 0.09229485f, -0.07389709f, 
    0.25775403f, 0.16653693f, 0.06195554f, -0.07597554f, 0.03481409f, 0.06488276f, 0.09958855f, 0.08312137f, 
    -0.07170194f, 0.04434510f, -0.11477934f, 0.08511063f, 0.12974314f, 0.29462197f, 0.02677850f, 0.01104276f, 
    -0.10501566f, 0.04945319f, 0.00858821f, 0.12010033f, 0.05886329f, 0.01943692f, 0.16773243f, -0.10963249f, 
    -0.07808453f, 0.03984313f, 0.00273832f, -0.10190083f, -0.17720884f, 0.09440593f, -0.23725735f, 0.17880324f, 
    0.02548140f, -0.29817110f, 0.30613595f, -0.05486932f, 0.05113795f, 0.13498281f, -0.21590747f, -0.25148433f, 
    -0.13943329f, -0.12631664f, 0.04925264f, -0.18080394f, -0.09714311f, -0.09033619f, 0.19278815f, -0.16073945f, 
    0.53253794f, -0.00310709f, -0.02869096f, -0.09481275f, -0.06295659f, -0.06967176f, -0.06272815f, 0.12349184f, 
    0.31241980f, 0.15102462f, 0.41495666f, -0.10027988f, 0.01944081f, 0.09720218f, -0.03079182f, 0.03940563f, 
    0.02938185f, -0.14025123f, -0.02490345f, 0.32475066f, -0.06867522f, -0.18417561f, 0.01231937f, -0.09894183f, 
    0.00882517f, 0.39798483f, 0.14897020f, 0.51086557f, -0.06348536f, -0.22040844f, 0.15502958f, -0.02371086f, 
    -0.02606661f, 0.01587427f, 0.11937331f, -0.26058054f, -0.12751189f, 0.37582725f, -0.07908022f, 0.03662720f, 
    0.00530577f, -0.22112493f, 0.03014987f, 0.14351179f, 0.07386650f, 0.41634378f, 0.27851686f, 0.02018491f, 
    0.16187683f, -0.04389207f, 0.00836686f, 0.05577068f, 0.14465842f, -0.13339445f, -0.16062836f, 0.15612011f, 
    -0.04853219f, -0.02330427f, -0.04400734f, -0.01892642f, -0.05412787f, -0.02857598f, -0.10184226f, -0.68055618f, 
    -0.09037640f, 0.08841878f, -0.11907287f, -0.13550317f, -0.10536432f, -0.15644394f, -0.19471943f, -0.35908931f, 
    0.03157968f, -0.36787781f, -0.01611198f, -0.06407836f, -0.03244778f, -0.09169989f, -0.04393144f, -0.03169332f, 
    -0.08787467f, 0.08548339f, -0.02804237f, 0.10527748f, 0.04307007f, 0.02487040f, 0.16194807f, 0.01285445f, 
    0.26215631f, -0.08550058f, 0.09059364f, 0.00598655f, 0.16655210f, -0.10968537f, -0.09740780f, -0.00425387f, 
    0.11134408f, 0.12008908f, -0.45166656f, 0.38957605f, 0.00715139f, 0.03902888f, 0.01803872f, -0.01345907f, 
    -0.07861701f, 0.01308942f, -0.17014976f, 0.00214487f, -0.04576854f, 0.07113364f, -0.10674480f, 0.05921698f, 
    -0.02015057f, -0.02818028f, 0.08652405f, 0.03276218f, 0.13777877f, 0.18433575f, 0.17716664f, 0.06382444f, 
    0.16207074f, 0.00986741f, -0.12870324f, 0.13850161f, 0.01629568f, 0.04127095f, -0.24759944f, 0.25232112f, 
    -0.17188987f, 0.01832174f, -0.14525507f, -0.02928135f, 0.04213119f, -0.04776211f, -0.37603426f, 0.56710625f, 
    -0.07662056f, 0.04003632f, 0.33676744f, 0.13204952f, 0.03826943f, -0.06852154f, -0.10292584f, -0.23418675f, 
    0.05703935f, 0.01420082f, 0.02144095f, 0.07510135f, -0.03110686f, -0.17043231f, -0.13199408f, -0.01799184f, 
    -0.06195514f, -0.09298433f, 0.00925293f, -0.09022625f, 0.07748750f, -0.08328687f, -0.07944888f, -0.00706771f, 
    0.22620942f, 0.13717663f, 0.03721099f, -0.01461598f, 0.07917231f, 0.14274284f, -0.04970954f, 0.05296901f, 
    0.07910431f, -0.08672845f, 0.26643467f, -0.34731391f, -1.04673636f, -0.24750164f, -0.00970570f, -0.15967447f, 
    -0.01092288f, 0.02302365f, 0.14274490f, 0.06428822f, 0.02555536f, -0.01339958f, -0.01762666f, 0.04468602f, 
    0.06327597f, 0.08771711f, -0.05070066f, -0.02206569f, -0.24382079f, 0.01571692f, 0.07830527f, -0.02039591f, 
    -0.03667867f, -0.08157894f, -0.04538339f, -0.01752947f, 0.05034008f, -0.66589880f, 0.04957356f, 0.03661272f, 
    -0.00292308f, 0.00035904f, -0.06436791f, 0.00022156f, -0.07526212f, 0.06784297f, 0.26822817f, -0.15227091f, 
    -0.55140132f, -0.48677164f, 0.05748834f, 0.29668605f, -0.06150188f, -0.02459758f, 0.15113175f, 0.39698830f, 
    -0.31998304f, 0.09263290f, 0.09346905f, 0.12317997f, -0.12813704f, -0.04394504f, 0.10731851f, -0.23294570f, 
    -0.53622520f, -0.04671928f, 0.58402538f, 0.04508630f, -0.05562972f, -0.08321454f, 0.15801337f, 0.13006823f, 
    -0.14567256f, 0.30675486f, 0.06683115f, 0.37456927f, 0.02126211f, -0.09624220f, -0.13213874f, -0.06734339f, 
    0.01620773f, 0.09282399f, 0.05771660f, -0.05522035f, -0.03786531f, -0.02326998f, -0.04682254f, 0.08056931f, 
    -0.08631613f, -0.06914813f, -0.03061400f, -0.06331161f, 0.10160747f, 0.07394426f, 0.01239525f, 0.01054874f, 
    -0.16904663f, -0.02563187f, 0.15312164f, -0.02108007f, -0.15634350f, 0.12321648f, -0.03481446f, -0.02044206f, 
    0.01461094f, -0.00565743f, -0.03412421f, 0.04597745f, -0.14447396f, -0.70087349f, -0.04554241f, 0.05949810f, 
    0.06713359f, 0.12643637f, 0.19913499f, -0.02398023f, -0.00930585f, 0.04389108f, -0.01156313f, -0.38370207f, 
    -0.19239593f, 0.12544346f, 0.14093946f, 0.00626504f, -0.07593091f, 0.03676685f, 0.02641941f, -0.10862676f, 
    0.10020304f, -0.40482450f, -0.06298264f, -0.02763244f, -0.04131876f, 0.01876279f, -0.03663920f, -0.05665233f, 
    0.04197592f, -0.06317121f, -0.22534910f, -0.09281510f, -0.17590255f, 0.09008358f, -0.02411197f, -0.00328225f, 
    0.11257194f, 0.21960080f, 0.13865885f, 0.22159719f, -0.06945681f, 0.17981143f, -0.27352676f, 0.02521985f, 
    -0.03702023f, -0.14609183f, 0.26045948f, -0.12165216f, -0.26596552f, -0.29396105f, 0.06380226f, 0.08451925f, 
    0.01344563f, 0.00024875f, 0.04947947f, 0.16383259f, 0.16524327f, 0.11173633f, 0.17781490f, 0.11085797f, 
    0.10897839f, 0.03409512f, 0.10222358f, -0.24683133f, 0.13111016f, -0.34409168f, 0.04792659f, -0.04366746f, 
    -0.02459574f, -0.08895846f, 0.04381145f, -0.10275121f, -0.04509023f, -0.04146202f, 0.02383376f, 0.05325416f, 
    -0.01867253f, 0.03642835f, 0.16048720f, -0.04793483f, -0.15434940f, 0.06782546f, -0.15818191f, -0.02249943f, 
    0.08553797f, 0.18000445f, 0.06371769f, 0.15258685f, 0.06227348f, -0.05140075f, 0.24995725f, 0.06195591f, 
    0.24148817f, 0.04977116f, -0.07293621f, 0.08890722f, -0.01806262f, -0.01289461f, 0.05193121f, 0.00598055f, 
    0.09247177f, -0.17543781f, -0.13145158f, 0.01044590f, -0.00926179f, 0.21226195f, 0.08783256f, 0.04988203f, 
    0.10966795f, -0.13371719f, -0.63669693f, 0.08296198f, -0.05591321f, -0.04648613f, -0.08771925f, -0.08140352f, 
    -0.00906159f, 0.11620253f, 0.14274718f, -0.09852427f, -0.26165625f, -0.04134580f, -0.02322675f, 0.05881601f, 
    0.24976338f, 0.10110624f, -0.02970054f, -0.27592137f, -0.24387386f, -0.25490999f, -0.28593159f, -0.18777633f, 
    -0.15763338f, 0.07369048f, 0.16793598f, 0.00831125f, -0.21689385f, 0.20256203f, 0.68089414f, 0.20764856f, 
    0.22354186f, 0.15641944f, 0.08057547f, 0.20941766f, 0.21557365f, -0.09697746f, -0.28310707f, -0.15624696f, 
    0.06893881f, -0.06606945f, -0.12669331f, 0.05392324f, 0.24335422f, 0.09003255f, 0.35266516f, -0.78699267f, 
    -0.90148830f, -0.06059905f, -0.22542241f, -0.09702953f, 0.08645797f, 0.17033538f, -0.24307255f, 0.19327627f, 
    -0.03197854f, -0.23249336f, -0.29171085f, 0.06050779f, 0.03541452f, -0.08708604f, 0.21348938f, 0.07768794f, 
    -0.14789218f, -0.10161635f, -0.13605927f, -0.28356174f, -0.35034084f, -0.29987770f, 0.04776166f, 0.20423505f, 
    0.05387305f, -0.09354474f, 0.13506792f, 0.47805503f, 0.14853282f, 0.10429621f, -0.01999202f, 0.22518648f, 
    0.06290613f, -0.00155636f, -0.24651957f, -0.35326967f, -0.03806136f, 0.00786488f, -0.05625686f, -0.11630046f, 
    -0.19106871f, 0.12691508f, 0.02260459f, -0.13737595f, -0.02130719f, 0.07819325f, -0.00787120f, 0.18523361f, 
    0.11817355f, 0.08462011f, 0.14161365f, 0.10928423f, 0.00984908f, -0.05323117f, -0.13109057f, -0.06519888f, 
    0.00167409f, -0.02455979f, -0.01964467f, 0.00988095f, 0.17816141f, 0.00921701f, -0.08005630f, -0.24080762f, 
    0.12196653f, 0.14508450f, 0.03812122f, 0.13473319f, -0.01161107f, 0.04311423f, 0.03949517f, -0.42765114f, 
    -0.27065834f, -0.25221717f, -0.09369943f, -0.14815366f, 0.01443627f, 0.14397347f, -0.00774709f, -0.10668573f, 
    0.31050232f, 0.28665772f, 0.16706514f, 0.07747631f, -0.14995269f, 0.08403745f, 0.02402111f, 0.03760058f, 
    -0.11614181f, -0.07342306f, -0.11450388f, -0.07584152f, 0.10401930f, -0.40794688f, 0.05927491f, -0.15946493f, 
    -0.00357220f, 0.12524009f, 0.06926615f, -0.01320432f, 0.09251536f, 0.09249149f, 0.08802529f, 0.11569563f, 
    0.05796784f, 0.07240691f, -0.12847175f, 0.01867201f, -0.13819447f, -0.34019399f, 0.09500451f, -0.19646142f, 
    0.14374168f, 0.14397731f, 0.10031901f, -0.10478933f, -0.15915798f, -0.21271685f, -0.11841654f, -0.14082289f, 
    -0.08220143f, -0.17404953f, -0.06500381f, -0.02691745f, -0.05824742f, -0.05426821f, 0.06876557f, -0.14353475f, 
    -0.05931515f, 0.06495927f, 0.13952386f, 0.11014619f, 0.15823764f, 0.58355075f, -0.09511147f, -0.17998858f, 
    -0.06037695f, -0.14647619f, -0.15985453f, -0.03898022f, 0.12161360f, 0.16318335f, -0.25559056f, 0.22037992f, 
    0.26728672f, 0.01853934f, -0.06665599f, -0.25123501f, 0.12946673f, -0.02967276f, 0.09161607f, -0.20441286f, 
    0.43041724f, 0.40635285f, 0.11205727f, 0.13704826f, -0.14954765f, 0.08307452f, -0.00624184f, 0.25468838f, 
    -0.24974315f, -0.05699847f, -0.19801460f, -0.08184270f, 0.05485673f, -0.14326839f, 0.11949481f, -0.12761717f, 
    0.20505729f, -0.02311037f, -0.05492500f, 0.13427919f, 0.01588984f, -0.00759982f, 0.08944485f, 0.20620437f, 
    0.06748394f, 0.11981730f, -0.04889760f, -0.05602284f, -0.31794697f, -0.05302816f, -0.08645840f, 0.02876155f, 
    -0.04877056f, -0.07552590f, 0.25866151f, -0.26032713f, 0.01938089f, 0.06873775f, 0.15122698f, -0.07405859f, 
    0.01294835f, -0.02702256f, -0.11253910f, 0.11599913f, 0.05469322f, 0.24753191f, -0.03784741f, 0.22259188f, 
    0.04669842f, -0.00039416f, 0.22896320f, 0.22348253f, 0.45194024f, -0.43677130f, -0.01840629f, 0.54695988f, 
    0.08415933f, 0.01939799f, 0.15410350f, 0.01499221f, 0.12160012f, 0.06278865f, -0.21646173f, -0.40026611f, 
    -0.25885960f, 0.09423736f, -0.07493817f, 0.05339006f, -0.05055732f, -0.13865626f, -0.08651842f, -0.24733493f, 
    -0.06860128f, 0.20408082f, 0.04798642f, -0.01391383f, 0.01549114f, 0.15823765f, -0.04603857f, 0.00084736f, 
    0.21177465f, 0.04944083f, 0.00121357f, 0.10022162f, -0.04065779f, -0.03169302f, 0.07058984f, 0.05240733f, 
    -0.15171923f, 0.11966012f, -0.36710060f, -0.49225047f, -0.11642433f, -0.00991317f, -0.00574472f, 0.18423952f, 
    0.14094386f, -0.06030624f, -0.29358459f, 0.02846435f, -0.24390841f, 0.21012981f, -0.08260537f, 0.19285657f, 
    0.11631492f, 0.03669189f, 0.11170922f, 0.21438979f, -0.52307856f, -0.27411199f, -0.07103226f, 0.08287585f, 
    0.02244142f, 0.06112180f, 0.29879740f, 0.05205869f, -0.19134289f, 0.06073923f, 0.48553804f, -0.07024506f, 
    0.01987422f, -0.19936970f, 0.11120948f, 0.12755708f, 0.03313907f, 0.00098295f, -0.17818452f, 0.07874847f, 
    -0.04319554f, 0.19107120f, 0.09214991f, 0.19121999f, -0.00769799f, -0.14263566f, -0.91360408f, -0.61833471f, 
    -0.59858537f, -0.17505193f, -0.31500292f, -0.05076610f, 0.03809209f, -0.22908917f, -0.07755741f, 0.11262941f, 
    0.09798281f, -0.20857584f, 0.09722104f, -0.17500861f, 0.18679731f, 0.23715566f, -0.00674974f, -0.16075909f, 
    -0.21497895f, -0.28251091f, -0.02912168f, -0.11518544f, -0.08062922f, -0.05262260f, 0.05598150f, -0.19875097f, 
    0.00975292f, 0.02580060f, -0.25349373f, -0.03718431f, -0.06774960f, -0.11521991f, -0.12678887f, 0.02946873f, 
    0.09444670f, 0.13505229f, -0.58084273f, -0.11171179f, -1.38625705f, -0.05501586f, -0.12108721f, -0.05653331f, 
    -0.02294174f, 0.04865630f, 0.11208579f, -0.05919375f, 0.10269026f, 0.30479634f, -0.11727167f, -0.04473217f, 
    -0.05325100f, 0.19111221f, -0.09257557f, 0.09592532f, 0.11959787f, 0.08514254f, 0.17379983f, -0.02758387f, 
    -0.09993692f, 0.01478235f, 0.23682700f, 0.14231023f, 0.28657886f, -0.10227040f, 0.00148716f, -0.09995159f, 
    -0.03763585f, -0.06674040f, -0.06200680f, -0.03668568f, 0.05545143f, 0.45411485f, 0.70954877f, -0.12768461f, 
    -0.87067711f, 0.08009670f, -0.16160356f, 0.15517469f, 0.03297816f, -0.11714152f, -0.09386105f, 0.01427928f, 
    -0.88633764f, -0.63623655f, -0.47669059f, -0.03034540f, -0.05159754f, 0.12994812f, -0.01007237f, 0.16093403f, 
    0.10630089f, -0.03884848f, 0.12685306f, 0.04590917f, -0.18559624f, -0.18227446f, 0.01005047f, 0.18798082f, 
    0.17122974f, -0.12948257f, -0.39855364f, -0.87531418f, 0.05671801f, 0.04126547f, 0.13101099f, 0.10926349f, 
    0.27949739f, 0.11874442f, 0.04858393f, 0.03789939f, 0.05718604f, 0.12430469f, 0.02822738f, -0.14306152f, 
    0.10803784f, 0.10196315f, 0.08295002f, -0.08516965f, -0.08107400f, -0.16899584f, -0.07459323f, -0.08110783f, 
    -0.14287987f, 0.08056072f, -0.05543173f, -0.04789113f, 0.08216740f, 0.21223608f, 0.27358764f, 0.04128127f, 
    0.01571912f, -0.08489804f, 0.06746099f, 0.26097983f, 0.20110182f, -0.32270303f, 0.34858820f, -0.71614128f, 
    -0.09179717f, 0.02808389f, 0.45086476f, 0.08872273f, -0.01897798f, 0.00260735f, 0.06723364f, 0.18571495f, 
    0.19050744f, -0.08162782f, -0.11122271f, -0.03461061f, 0.14771163f, 0.03896819f, 0.26343125f, 0.10108758f, 
    0.08510540f, 0.74128097f, 0.10519232f, -0.09413663f, 0.01740361f, 0.04206515f, 0.02224180f, 0.11917780f, 
    0.37898171f, -0.07843539f, -0.38172969f, 0.25973010f, -0.10855933f, 0.17515220f, 0.16015297f, -0.06074874f, 
    -0.08946776f, 0.28807127f, -0.73528296f, -0.18211794f, -0.04059353f, -0.19212756f, 0.14727129f, 0.17999418f, 
    0.09858743f, -0.04843422f, 0.70975101f, -0.43069836f, -0.34126788f, 0.21981227f, 0.09549343f, 0.03051822f, 
    0.14373210f, -0.11454394f, -0.14490849f, -0.61730689f, -0.30496791f, -0.49139807f, -0.09639841f, 0.03616774f, 
    0.01079687f, 0.12258873f, -0.01724114f, 0.09969261f, 0.65235364f, -0.18857199f, -0.15080665f, 0.13142858f, 
    0.16743968f, 0.09974855f, 0.04130353f, 0.05834773f, 0.03794687f, -0.50723040f, -0.26156244f, 0.73664713f, 
    -0.02943182f, 0.09705184f, -0.21157667f, -0.03811927f, 0.04027213f, 0.02532976f, 0.16284434f, -0.07823335f, 
    0.08636320f, 0.09831455f, 0.07298274f, 0.11393335f, 0.04987307f, -0.08708555f, -0.15166698f, -0.35433903f, 
    0.29830310f, -0.09218480f, -0.02709942f, -0.25471315f, -0.08924795f, 0.03088599f, 0.03656502f, 0.19594866f, 
    0.10969341f, -0.00514452f, -0.04706310f, 0.04455443f, -0.02028386f, 0.05147962f, -0.10202763f, 0.10561927f, 
    -0.02840928f, 0.00427095f, 0.21895109f, 0.06688117f, -0.02802258f, -0.04786036f, -0.03866128f, -0.00652608f, 
    -0.08917843f, -0.25087267f, -0.00297286f, 0.14955740f, 0.40187952f, 0.07144739f, 0.04330258f, 0.11363029f, 
    0.02924430f, -0.08374074f, 0.06127581f, 0.14805362f, 0.02114651f, 0.13196518f, -0.05679918f, -0.12559807f, 
    -0.12468816f, 0.14558806f, -0.13331245f, -0.15555340f, 0.00831100f, -0.13932364f, -0.31005254f, 0.02008190f, 
    0.10150503f, -0.00739271f, 0.02347334f, 0.00603631f, 0.06050210f, 0.13938445f, 0.06778905f, 0.13428070f, 
    0.10077444f, 0.02575975f, 0.03615032f, 0.28291428f, -0.06732505f, -0.14453752f, -0.39683554f, 0.14330785f, 
    0.22444171f, -0.00381271f, -0.09877603f, -0.09109095f, -0.15997398f, -0.07222271f, -0.17942157f, 0.04296470f, 
    0.17542671f, 0.16513231f, 0.17816046f, -0.02542068f, -0.00025550f, 0.01131789f, -0.18609902f, 0.06419308f, 
    0.08187456f, 0.05808594f, 0.08304834f, -0.06045295f, -0.13592227f, -0.13611485f, -0.04515055f, -0.18726186f, 
    -0.11251007f, 0.17409374f, -0.29181278f, -1.62845433f, -0.01612076f, -0.11018719f, -0.11511187f, 0.01574323f, 
    0.06725398f, 0.11658500f, -0.15373947f, 0.13265319f, 0.09551978f, -0.05977269f, 0.00604814f, -0.02352973f, 
    0.03724580f, -0.00117094f, -0.01198402f, 0.15352945f, -0.02710669f, -0.14937568f, 0.17376043f, -0.06079911f, 
    -0.09878021f, 0.05292894f, 0.02890975f, 0.03090897f, 0.15049440f, 0.13112235f, 0.27037016f, 0.02938432f, 
    0.07149808f, 0.07996968f, -0.10358468f, 0.10631578f, -0.01812125f, 0.12952666f, 0.13352084f, 0.19277184f, 
    -0.04601770f, 0.00558831f, 0.08316228f, 0.01703944f, 0.10177987f, -0.12911347f, 0.20345011f, 0.48567316f, 
    -0.85157698f, 0.02057395f, 0.04481643f, 0.11543167f, -0.10687039f, 0.00687244f, -0.10884039f, -0.75935614f, 
    -0.89889950f, -0.95314199f, -0.05522414f, -0.09542994f, -0.23540251f, 0.08636458f, 0.06664085f, -0.02982979f, 
    0.06315068f, -0.24988934f, -0.08818088f, 0.00712159f, -0.17208511f, -0.09191579f, 0.09682226f, -0.21022351f, 
    -0.24983603f, 0.17169851f, 0.09043913f, 0.01767517f, 0.10453324f, 0.04204816f, 0.15722850f, -0.07193991f, 
    0.02238265f, -0.09570269f, 0.11689936f, 0.05419229f, 0.19939041f, 0.00425285f, -0.13149227f, -0.21163522f, 
    -0.10623690f, -0.11354914f, -0.00598021f, 0.08360382f, 0.09545662f, 0.22667561f, 0.02398393f, 0.07843874f, 
    -0.01517996f, -0.10948087f, -0.11851748f, -0.06741431f, 0.08528002f, 0.03433591f, 0.18442798f, -0.08944692f, 
    -0.02098147f, -0.18863879f, -0.10045283f, -0.04196260f, 0.09143166f, -0.73947829f, 0.03481681f, -0.00596267f, 
    0.24036774f, 0.15374689f, 0.13034771f, 0.00484314f, 0.00376555f, 0.15864098f, -0.00319343f, -0.02212201f, 
    -0.08400047f, -0.11494673f, -0.26736283f, -0.21317790f, 0.00618151f, -0.04927951f, -0.12158464f, -0.98007387f, 
    -0.69304317f, -0.58042550f, -0.04477008f, -0.15001346f, -0.13259178f, 0.01162437f, 0.02326306f, 0.10401233f, 
    0.07200601f, 0.15350819f, 0.07712013f, 0.10644057f, -0.00475062f, -0.03244401f, -0.04196636f, -0.08216049f, 
    -0.10517965f, -0.23055598f, -1.11502230f, -1.04600799f, -0.10190400f, -0.05554628f, -0.10413280f, 0.02137945f, 
    0.22826052f, 0.03729514f, 0.22354977f, 0.02969376f, 0.18471280f, 0.14756314f, 0.03908495f, 0.15561059f, 
    0.00580238f, 0.00869331f, 0.05482674f, -0.19516630f, -0.34796840f, -1.46850491f, 0.09821215f, -0.04157738f, 
    -0.31836301f, 0.01923638f, 0.12109999f, 0.11130001f, 0.29642245f, -0.00772611f, 0.21776399f, 0.18507792f, 
    0.00599059f, 0.11073158f, 0.13142313f, 0.24894972f, -0.07941736f, -0.02427277f, -0.10815937f, -0.02244337f, 
    -0.10892493f, -0.00163633f, -0.18230753f, -0.02012390f, -0.07142643f, -0.00112257f, -0.03746645f, 0.04827411f, 
    -0.13843983f, 0.05793154f, 0.18020655f, -0.05458070f, 0.00843724f, 0.05216046f, -0.10584811f, 0.15086350f, 
    -0.13283305f, -0.77508724f, -0.04254753f, -0.03949789f, -0.03693172f, -0.07872409f, 0.08244155f, 0.07429866f, 
    -0.07205148f, -0.10469303f, -0.19672470f, -0.08906281f, 0.05802858f, -0.00360521f, 0.13262451f, -0.08712714f, 
    -0.02746969f, 0.17257239f, 0.25319436f, 0.19300406f, -0.08693321f, -0.10526362f, -0.01141845f, 0.05162226f, 
    -0.00817150f, -0.05621070f, -0.05800397f, -0.02172358f, 0.16498266f, 0.07879487f, -0.02431759f, -0.03706114f, 
    0.02870938f, 0.14000848f, -0.19857982f, 0.06406569f, 0.18381988f, -0.26123995f, -0.06753774f, -0.06204864f, 
    0.06793351f, 0.04755210f, -0.02860144f, -0.11949801f, -0.19178024f, -0.10971497f, -0.25783494f, -0.06828735f, 
    -0.09764487f, 0.01273119f, -0.04970154f, 0.04225774f, -0.03308078f, 0.18032166f, 0.19759829f, 0.12721057f, 
    -0.13154766f, -0.05939786f, -0.07556522f, -0.02308019f, 0.02881656f, -0.08079256f, 0.00013067f, -0.37404987f, 
    0.35535213f, 0.47505847f, -0.05243930f, -0.01153565f, 0.09442586f, 0.01314341f, -0.25861654f, 0.47407413f, 
    -0.21359220f, 0.16122530f, -0.01644496f, 0.21696503f, -0.21201061f, 0.21018670f, 0.09519438f, 0.03175661f, 
    -0.05124350f, -0.05751221f, -0.18476160f, 0.17642045f, -0.11377260f, -0.07985040f, 0.06198314f, -0.07269847f, 
    -0.02342399f, -0.15598212f, -0.08674787f, -0.28998467f, 0.02007584f, -0.00557140f, 0.20504485f, 0.06481004f, 
    -0.01904125f, 0.00057306f, 0.38475019f, -0.04064427f, 0.56611580f, -0.04896356f, -0.09220608f, 0.01305823f, 
    -0.04040974f, -0.04265787f, 0.10268348f, -0.11480748f, 0.05840211f, -0.14564346f, 0.05550173f, -0.00816668f, 
    0.08256666f, -0.02335049f, 0.09385643f, -0.14980391f, 0.04959716f, -0.05274293f, 0.05022941f, -0.10350941f, 
    0.00660506f, -0.11946710f, -0.04589299f, -0.01907594f, 0.26801631f, -0.16235313f, 0.06015347f, 0.14352342f, 
    -0.11689260f, -0.05849949f, -0.14494172f, -0.04028814f, 0.22102118f, 0.23488475f, 0.05107538f, -0.00945833f, 
    0.27139714f, -0.20589201f, -0.19286369f, 0.00749517f, 0.15570010f, -0.01922427f, 0.03797594f, -0.95718688f, 
    0.06617944f, -0.64710701f, 0.08626781f, -0.26593062f, 0.20323336f, 0.22753462f, 0.15400064f, -0.05668626f, 
    -0.11388370f, 0.05013919f, -0.49008062f, -0.31982008f, 0.09060752f, 0.12292539f, 0.05850351f, -0.03395530f, 
    0.33797532f, 0.29909295f, -0.12992661f, 0.56475574f, -0.02621357f, 0.04094221f, -0.23164009f, 0.03329650f, 
    0.22130707f, 0.01026437f, 0.10470110f, -0.03305471f, -0.14389209f, -0.08125436f, -0.07383153f, 0.00526395f, 
    0.14571662f, 0.11394399f, 0.06224303f, 0.08408967f, 0.10720824f, -0.04464019f, 0.01083762f, -0.07874821f, 
    -0.08792884f, 0.09028012f, 0.01358708f, 0.06699752f, 0.12461121f, -0.05278192f, -0.23916143f, -0.00531088f, 
    -0.10886408f, -0.15822893f, 0.05991323f, -0.04421828f, -0.01086051f, 0.45439309f, -0.57428437f, -0.31605396f, 
    0.06193771f, 0.26410544f, -0.19868484f, 0.26210883f, 0.09707719f, -0.12787883f, -0.03670445f, -0.29976258f, 
    -0.42677471f, 0.05180679f, -0.33756706f, 0.26805341f, -0.03293417f, -0.15875097f, 0.09974153f, 0.12438493f, 
    -0.12134428f, -0.11497191f, 0.09845735f, -0.10879371f, 0.14837161f, 0.06571382f, 0.03810094f, 0.08667743f, 
    0.51973915f, 0.06631609f, 0.33436865f, -0.08204143f, 0.03681628f, -0.14850534f, 0.02091391f, 0.00400273f, 
    0.01707567f, -0.16577414f, 0.00413154f, -0.70939982f, 0.05772897f, -0.07915159f, -0.11355984f, 0.11269478f, 
    -0.14891143f, -0.02498235f, 0.11609694f, 0.30209869f, -0.15641558f, -0.00712354f, -0.15726224f, -0.11691748f, 
    -0.05598566f, 0.08080295f, -0.03600718f, -0.79871440f, -0.24027501f, -0.58806270f, 0.11265241f, -0.04068629f, 
    0.01554337f, 0.04973367f, -0.00220880f, 0.10650975f, 0.03910622f, 0.16574205f, 0.07743111f, -0.12285142f, 
    0.08313210f, 0.00278241f, 0.08426078f, 0.13168697f, 0.15213858f, -0.21046156f, -0.14769408f, -0.40586099f, 
    0.06489433f, -0.04617801f, -0.04567318f, 0.08174767f, -0.11137892f, 0.10892630f, 0.10867460f, 0.12148502f, 
    -0.12406620f, -0.07427081f, 0.08582845f, 0.01952615f, 0.03665218f, 0.04515506f, -0.04773815f, 0.21040820f, 
    -0.19106124f, -0.14442363f, -0.01571408f, 0.09210445f, -0.05725985f, 0.03915719f, 0.05296582f, 0.08459970f, 
    0.14693227f, -0.03087620f, 0.13436924f, 0.02776554f, 0.14041127f, -0.05839362f, -0.12209113f, -0.26442647f, 
    -0.86746049f, 0.07069054f, -0.11579187f, -0.10282115f, -0.09876234f, -0.05458060f, -0.00963369f, 0.06603535f, 
    -0.09932952f, -0.01309641f, 0.24768655f, 0.11912499f, -0.36920518f, 0.00654919f, 0.11996382f, 0.17179969f, 
    0.06422388f, 0.03554213f, 0.03371982f, 0.14858148f, -0.15136012f, -0.02668615f, 0.17236677f, 0.03532079f, 
    0.11680177f, 0.00013717f, 0.03330302f, -0.09136408f, -0.16085818f, 0.07365961f, 0.19408272f, 0.04474664f, 
    -0.13808727f, -0.05717299f, 0.06416200f, 0.23167720f, -0.19745232f, 0.17499703f, 0.08102035f, -0.06126070f, 
    0.20565124f, 0.15466830f, 0.16675425f, 0.06624678f, 0.06590257f, -0.02858122f, -0.07412458f, 0.33386257f, 
    -0.04204005f, -0.54614586f, 0.10085228f, -0.05833407f, -0.16990769f, 0.10847549f, -0.16393039f, 0.04686826f, 
    -0.14260310f, -0.06095856f, 0.01874167f, 0.00141242f, 0.04848956f, 0.23700286f, 0.21974298f, -0.14463474f, 
    0.06633954f, -0.08915416f, 0.01538461f, 0.12903039f, 0.03994853f, 0.04290339f, -0.27151182f, 0.05102436f, 
    0.08649269f, -0.13278906f, -0.26334229f, -0.16681609f, 0.02213548f, 0.11019709f, -0.06003115f, 0.04156519f, 
    0.04369384f, 0.08013881f, 0.11146216f, -0.09228552f, 0.03912613f, 0.02107546f, -0.24070898f, -0.02028411f, 
    0.08654516f, 0.12748122f, 0.08615585f, 0.02464790f, 0.15773618f, 0.17414273f, 0.11895777f, 0.08680147f, 
    -0.02376599f, 0.02602341f, -0.28125229f, -0.40585509f, 0.06801008f, 0.08316315f, -0.07352444f, 0.12462077f, 
    0.13160421f, 0.01913203f, 0.11090863f, 0.00371306f, -0.07510611f, 0.20706163f, -0.06275657f, -0.49968246f, 
    0.06047972f, 0.13628906f, 0.02880580f, 0.13830194f, -0.10974179f, 0.05988501f, -0.30174422f, 0.19307764f, 
    -0.18922639f, -0.04020876f, 0.05914982f, -0.04832351f, 0.05020947f, -0.04809587f, -0.00290917f, 0.02910746f, 
    -0.14433748f, -0.05502682f, -0.17871614f, 0.20997666f, -0.20025267f, 0.02318931f, 0.23556890f, 0.20669124f, 
    -0.02440755f, 0.00638242f, -0.06890863f, -0.10035823f, -0.04026937f, -0.16567685f, -0.00350116f, 0.03257247f, 
    0.31951293f, -0.24408117f, -0.03938606f, -0.26750574f, -0.04221987f, -0.09216496f, 0.07621691f, 0.09331396f, 
    0.21792918f, -0.04129163f, 0.00571004f, -0.07376501f, 0.03486773f, 0.09585781f, -0.03703195f, 0.03614929f, 
    -0.03330228f, -0.13444106f, -0.17360841f, 0.05236141f, -0.09320085f, -0.22207624f, 0.04064672f, 0.15699883f, 
    0.08582649f, 0.23873805f, 0.15332827f, -0.05709383f, 0.02407844f, -0.00563108f, 0.09324841f, 0.07320730f, 
    0.07772893f, 0.13379550f, -0.02400532f, -0.12961517f, -0.01158238f, -0.00510809f, 0.00491143f, 0.08589367f, 
    -0.09790266f, -0.15739048f, -0.01437758f, 0.09038392f, 0.25588241f, 0.00465651f, 0.01642972f, 0.36415553f, 
    0.27848789f, -0.10391609f, 0.06564210f, -0.22128013f, 0.06852870f, 0.16494188f, 0.28395674f, -0.05617667f, 
    0.02738906f, 0.14388643f, -0.04945575f, 0.18176775f, 0.03305598f, 0.05012940f, 0.18001889f, 0.14446045f, 
    -0.07940990f, 0.09273399f, -0.06080205f, -0.02796555f, -0.07779776f, 0.09915695f, 0.17800625f, 0.00660646f, 
    -0.09587751f, -0.25978276f, -0.17436294f, 0.27905560f, -0.05381348f, 0.02763669f, 0.01146841f, 0.06913666f, 
    0.13937567f, 0.13804367f, -0.06923302f, 0.12726492f, -0.10801387f, 0.08607765f, 0.06776999f, 0.09115927f, 
    0.03002849f, 0.11207563f, 0.01713344f, 0.17311907f, -0.48973605f, -0.27011558f, -0.16868016f, -0.10283505f, 
    0.03577262f, 0.05466703f, 0.11607888f, 0.28989542f, -0.03561625f, 0.06539090f, -0.10160609f, -0.03911776f, 
    -0.08238728f, 0.26585692f, -0.06378838f, 0.11674317f, -0.00215513f, -0.18715036f, -0.15013702f, 0.29172119f, 
    0.02720881f, 0.01112269f, -0.03579783f, 0.29814920f, -0.02090852f, 0.08005782f, 0.17572406f, 0.02214920f, 
    0.12188298f, 0.14525539f, -0.00284410f, -0.30515811f, -0.08793123f, -0.78619432f, -0.61477631f, -0.20412590f, 
    -0.17064703f, -0.30438551f, -0.18242310f, 0.26136523f, -0.18704380f, -0.08467553f, -0.03285684f, 0.01563853f, 
    -0.00779597f, 0.09865462f, 0.06937443f, -0.05705895f, -0.12187881f, -0.30179569f, -0.01826201f, 0.00676891f, 
    0.08390768f, 0.30239999f, 0.34835908f, -0.07109700f, -0.27837312f, 0.18744443f, 0.02456386f, -0.09570208f, 
    -0.05161661f, -0.18357557f, 0.06817176f, 0.37294707f, -0.22897734f, -0.07822564f, 0.07770287f, 0.14643887f, 
    0.02168905f, -0.16810855f, 0.02955263f, -0.03709793f, -0.10341657f, -0.05413432f, -0.22859505f, -0.00917318f, 
    -0.09718197f, -0.21376278f, 0.26002961f, -0.23813999f, 0.08375226f, -0.10232501f, -0.14576890f, -0.17315362f, 
    -0.05044724f, -0.09458826f, 0.05624847f, -0.14786857f, -0.13005316f, 0.00255372f, 0.25489748f, 0.12554754f, 
    -0.13771628f, 0.04465057f, -0.04161963f, 0.14602581f, 0.15275434f, -0.40009195f, 0.23876685f, -0.11339119f, 
    -0.29576400f, -0.07101110f, -0.06612311f, -0.07648113f, 0.00581528f, -0.19231823f, -0.20844068f, -0.34915555f, 
    0.11451608f, -0.01075596f, 0.11148995f, 0.06859202f, 0.16051759f, 0.12569614f, 0.06054603f, 0.03782446f, 
    -0.31054735f, -0.06989634f, -0.22265567f, -0.05151137f, -0.05199676f, -0.09961156f, 0.14178067f, -0.05170297f, 
    -0.35094142f, 0.11970533f, -0.18208182f, -0.05100404f, 0.00291844f, -0.15558277f, 0.06154512f, -0.01136880f, 
    0.03387293f, 0.09278163f, 0.06859265f, 0.12512156f, 0.25315467f, 0.18409453f, -0.01709193f, -0.04893663f, 
    0.07349274f, 0.00091932f, 0.04650487f, -0.09030745f, -0.03401307f, 0.16844486f, 0.00264950f, -0.01477465f, 
    -0.18525316f, 0.20089301f, -0.02703832f, -0.11466375f, -0.31400487f, 0.13752344f, 0.23987730f, -0.04936467f, 
    0.11876822f, -0.15187977f, 0.14948125f, -0.08529914f, -0.14953664f, 0.05182732f, 0.22213025f, 0.09286119f, 
    -0.06667805f, -0.06402924f, -0.06783240f, 0.06095687f, -0.03713048f, 0.15876363f, 0.36687422f, -0.11408231f, 
    0.17738560f, -0.23172623f, -0.24890096f, -0.11391714f, 0.05533620f, 0.17385069f, -0.11636265f, -0.09210605f, 
    -0.18408756f, -0.16941009f, -0.00662006f, -0.02112325f, 0.05774003f, 0.06598262f, 0.18885462f, 0.11988661f, 
    -0.09203235f, -0.18177587f, 0.18939699f, -0.12801865f, -0.08459894f, -0.00044114f, -0.09466739f, 0.18717742f, 
    -0.10406002f, -0.16194801f, -0.01045632f, 0.18227282f, 0.21393551f, -0.07656267f, 0.16066042f, -0.01919755f, 
    0.14180039f, -0.14840268f, -0.14287080f, -0.06873791f, 0.01809957f, 0.01016734f, 0.05655012f, -0.02513791f, 
    0.40239146f, 0.10960001f, -0.14739405f, -0.18035620f, 0.27630281f, -0.04709004f, -0.28463745f, 0.11651643f, 
    -0.00162813f, 0.00294558f, -0.00819856f, -0.09914734f, -0.10017155f, 0.10937496f, 0.00386016f, -0.04064025f, 
    0.12358166f, -0.10211093f, 0.15160291f, -0.24755894f, -0.04980323f, -0.16082528f, 0.19719879f, 0.12392841f, 
    0.25142816f, 0.04938034f, 0.30462378f, -0.07600228f, 0.16409527f, 0.25258404f, 0.25354227f, 0.12002080f, 
    -0.34604767f, -0.18648581f, -0.05284751f, -0.16364653f, 0.16939305f, -0.06477910f, 0.07307965f, 0.23374359f, 
    -0.17542495f, -0.19503549f, -0.03488842f, -0.00792592f, 0.43858060f, 0.05527458f, 0.09182170f, 0.05735056f, 
    -0.11779807f, 0.26022199f, 0.13752051f, -0.00828249f, -0.16315636f, 0.19923511f, -0.03466120f, 0.02020887f, 
    0.11856700f, 0.05657301f, -0.32005394f, 0.43573871f, -0.22533511f, 0.02809924f, 0.10743528f, 0.06146229f, 
    0.20036638f, 0.25463313f, 0.24935803f, -0.08592750f, 0.18616526f, 0.03187202f, 0.01510135f, -0.20485231f, 
    0.07045487f, 0.15722510f, -0.06390198f, 0.25930333f, -0.35072494f, -0.09135568f, -0.22503924f, -0.00439151f, 
    0.01790504f, 0.06807015f, 0.20850922f, 0.28156784f, -0.00800267f, 0.02181123f, 0.19955042f, -0.15822102f, 
    -0.05749034f, 0.09660852f, 0.00678752f, 0.13350113f, -0.14060310f, -0.03999155f, -0.00163973f, 0.06182413f, 
    -0.33667910f, 0.19022827f, 0.08352599f, 0.12182550f, -0.43852827f, 0.10174287f, -0.14684975f, 0.03662532f, 
    0.22645837f, -0.08296654f, -0.00870609f, -0.16539410f, -0.17201145f, 0.05076404f, 0.05171483f, 0.04213254f, 
    -0.08902269f, -0.10226890f, 0.08206124f, -0.08880574f, -0.20367828f, 0.10245243f, 0.10179905f, 0.12643754f, 
    -0.00706097f, 0.14934804f, -0.00321375f, -0.17397967f, -0.08416971f, 0.10452737f, -0.06958481f, 0.15131448f, 
    0.14049524f, -0.24664629f, -0.34838220f, 0.15987109f, 0.14626992f, 0.02951601f, -0.09157337f, -0.10333993f, 
    0.34196815f, -0.04243305f, -0.11949889f, -0.20704187f, 0.12891710f, 0.14132456f, 0.13318576f, 0.01724820f, 
    -0.53709978f, -0.12625836f, 0.01514236f, -0.25722474f, -0.19584180f, -0.05088353f, 0.19028607f, -0.27783796f, 
    -0.03068733f, 0.08259282f, 0.17667249f, 0.04909993f, 0.35440689f, 0.00524888f, -0.05565896f, -0.10921989f, 
    -0.08697731f, 0.05079549f, 0.17189416f, -0.00025189f, 0.23170660f, -0.24934040f, -0.30481952f, -0.18319800f, 
    -0.10866953f, -0.06100542f, 0.08941204f, 0.18254365f, 0.10478099f, 0.07532948f, -0.38633797f, -0.03587434f, 
    0.17597872f, 0.52015883f, 0.21712881f, 0.02539843f, 0.08838020f, 0.07192685f, 0.28870371f, 0.20301917f, 
    -0.13968252f, -0.04204148f, -0.12669870f, 0.19801773f, 0.15892512f, -0.04759005f, -0.17897002f, 0.09668930f, 
    -0.22652084f, -0.20540431f, -0.12369436f, 0.07269411f, -0.28699636f, 0.02481438f, -0.01422154f, -0.00984755f, 
    0.02035215f, -0.04213941f, 0.22047187f, -0.16547096f, 0.01103568f, -0.09045573f, -0.00786677f, -0.06174663f, 
    -0.02431017f, -0.13331904f, -0.08495905f, -0.50623053f, -0.02572994f, 0.13499829f, 0.00077049f, 0.05448810f, 
    0.28113332f, 0.14995866f, -0.36822447f, 0.15492660f, 0.04485288f, -0.07095451f, -0.01523195f, 0.01773394f, 
    -0.00767883f, 0.17287149f, 0.13930801f, 0.18441436f, 0.00189209f, -0.16711658f, 0.06982031f, -0.13720492f, 
    0.08877922f, 0.04388426f, -0.06738614f, -0.35578176f, -0.20103431f, -0.04298931f, -0.16667362f, 0.08782464f, 
    -0.00210450f, -0.02919843f, -0.06810278f, -0.00980107f, -0.39026126f, -0.18703601f, 0.19695476f, 0.11884153f, 
    0.24187110f, 0.24183112f, 0.02525478f, 0.19308195f, -0.00129303f, 0.16623048f, -0.08733702f, -0.29846513f, 
    -0.35027850f, 0.00792147f, 0.01200577f, -0.06406182f, -0.00155883f, 0.01507494f, -0.39099783f, -0.16852482f, 
    -0.11111311f, -0.15277468f, -0.18186848f, -0.07574751f, 0.11547343f, -0.34320414f, -0.18042904f, -0.12024060f, 
    -0.39548913f, 0.14369644f, 0.15064336f, -0.12010150f, 0.02264552f, 0.12826304f, 0.04453298f, 0.04195903f, 
    -0.12911257f, 0.19428854f, -0.17314072f, -0.27376884f, -0.10774632f, -0.12166505f, -0.11530924f, -0.09360339f, 
    -0.17447323f, -0.06622516f, 0.15371937f, -0.16490783f, -0.09351949f, -0.02827433f, 0.01854799f, 0.01431841f, 
    0.04037837f, 0.04910547f, -0.20670708f, -0.02665620f, -0.17630364f, -0.22988701f, -0.01831727f, 0.11140996f, 
    -0.03987184f, 0.07230506f, -0.09644680f, 0.12886980f, 0.11394256f, 0.30016810f, 0.49795115f, 0.19654188f, 
    -0.00100938f, 0.34647664f, 0.22264916f, -0.01734669f, 0.19421375f, 0.23524939f, -0.51385331f, -0.25626385f, 
    -0.01322921f, 0.12107480f, -0.13034333f, 0.12137414f, -0.04103209f, -0.30480576f, -0.09840555f, -0.34814182f, 
    -0.16988221f, -0.25641012f, 0.15532385f, -0.18216282f, -0.01827402f, -0.15527001f, -0.00597305f, -0.10935110f, 
    0.20747237f, -0.48227218f, -0.24063216f, -0.00400297f, 0.10841646f, -0.07516944f, -0.02547584f, -0.18458819f, 
    0.22058553f, 0.09612132f, 0.22910497f, -0.04580835f, 0.04365657f, 0.28201994f, -0.04613967f, 0.06271386f, 
    -0.14272828f, 0.00916883f, 0.39188492f, -0.07490637f, -0.07880287f, -0.03981413f, 0.12555633f, 0.04093183f, 
    -0.09021633f, 0.21137230f, -0.22315943f, -0.51502681f, 0.26747388f, 0.31200635f, 0.13544881f, -0.21046324f, 
    0.09904196f, 0.11711513f, -0.18464325f, -0.12885576f, 0.17508410f, -0.10020316f, -0.19626684f, 0.08373231f, 
    0.23554088f, -0.02283433f, -0.18661906f, -0.09843302f, -0.08790135f, 0.03752414f, 0.07824771f, 0.18614551f, 
    -0.00050947f, -0.14659496f, 0.22548106f, 0.13951728f, -0.01710624f, 0.18653588f, -0.12394220f, 0.20109165f, 
    0.31056428f, 0.05032234f, 0.06460252f, 0.23030351f, 0.17560890f, 0.26093435f, 0.19653048f, -0.00997869f, 
    0.17819397f, 0.35293049f, 0.05928045f, 0.06349671f, 0.01754915f, 0.15713987f, 0.11749402f, -0.19700474f, 
    -0.10685577f, 0.00336150f, -0.08529913f, -0.05496874f, 0.14390317f, 0.14071605f, 0.03420892f, 0.07916287f, 
    0.22194186f, -0.29922450f, -0.14430276f, 0.28840983f, 0.04981066f, -0.00092687f, -0.09365579f, -0.07151955f, 
    -0.01195989f, 0.07784835f, 0.11534621f, -0.00971703f, 0.00622112f, -0.03815176f, 0.12173039f, 0.09188113f, 
    0.01146825f, 0.00384548f, 0.24380651f, -0.07645611f, -0.02929368f, 0.05310941f, -0.05321422f, -0.22835700f, 
    -0.21263067f, 0.01268798f, 0.03311649f, 0.02850016f, 0.01158456f, 0.51335216f, 0.04534052f, -0.14292026f, 
    0.17987458f, -0.07455376f, 0.17090857f, 0.06376889f, 0.03318715f, 0.01528607f, 0.18947127f, 0.05993393f, 
    0.01961374f, 0.01665855f, -0.17623255f, 0.23035283f, -0.00461546f, 0.06460615f, -0.17367789f, -0.20506078f, 
    -0.00574007f, 0.00560388f, 0.00635973f, 0.12130504f, 0.32043383f, 0.00003969f, 0.14535682f, 0.28796050f, 
    0.02531241f, 0.02342761f, -0.08662662f, -0.03568463f, 0.35800582f, -0.01759451f, -0.21700642f, 0.03935371f, 
    0.02962928f, 0.07152548f, -0.03599101f, -0.05463906f, -0.30045831f, 0.10602678f, 0.14302367f, -0.01505309f, 
    -0.02690320f, -0.14204991f, -0.05395272f, -0.55285853f, -0.00699883f, 0.01312251f, -0.13711990f, -0.12346132f, 
    -0.15087961f, 0.05680551f, -0.93226779f, -0.14096515f, -0.21747136f, -0.00169956f, 0.06330055f, -0.07556088f, 
    -0.00729117f, -0.11605062f, -0.12180717f, -0.02093345f, 0.01524299f, -0.17907065f, -0.00033878f, -0.00432599f, 
    0.03533882f, 0.14695327f, -0.05880043f, 0.12265629f, 0.00714443f, 0.13870819f, 0.05600466f, 0.05958434f, 
    -0.19619493f, -0.15416433f, -0.16036113f, -0.03183664f, 0.23594640f, 0.03299909f, 0.18925762f, -0.09205835f, 
    0.13965347f, -0.14174899f, -0.02130718f, 0.07782515f, 0.15205705f, 0.31197780f, -0.45158353f, -0.40236372f, 
    -0.29896006f, 0.09988437f, 0.09155671f, -0.00183558f, 0.09747617f, 0.06913077f, -0.13162225f, -0.26325563f, 
    0.03862736f, -0.04964167f, -0.14345026f, -0.03108764f, 0.06829927f, 0.32200912f, -0.19908164f, -0.24558797f, 
    -0.12975498f, 0.32505724f, -0.32309759f, -0.03756955f, -0.04573143f, -0.00821116f, -0.16938326f, 0.32442835f, 
    0.10476868f, 0.22728893f, 0.45509726f, -0.03691318f, 0.13612926f, -0.00728582f, 0.10762331f, -0.10498227f, 
    0.34306824f, -0.12330431f, 0.16403569f, 0.08218937f, -0.10421686f, -0.01634287f, -0.27017474f, -0.06698712f, 
    -0.08237879f, -0.18456775f, 0.00472092f, 0.13188738f, 0.18009503f, 0.12062091f, -0.11835672f, -0.07412054f, 
    -0.24295050f, 0.14440626f, -0.13540918f, 0.10218668f, 0.05044790f, 0.15130495f, 0.09157132f, -0.03826242f, 
    -0.06978785f, 0.17131613f, 0.10135701f, -0.08567740f, 0.11275840f, 0.30045819f, -0.27227411f, -0.05774451f, 
    0.18978120f, 0.02673782f, 0.30670002f, 0.08478738f, 0.06311599f, 0.28584528f, -0.25665459f, -0.21386799f, 
    -0.11719542f, -0.07625137f, 0.03597187f, 0.01470620f, 0.01997246f, -0.24389797f, 0.00020931f, -0.25182974f, 
    -0.11779080f, -0.75982803f, -0.07922065f, -0.11184387f, 0.01145152f, 0.03706672f, -0.14300546f, -0.14494008f, 
    0.35342428f, -0.02858068f, 0.02119695f, 0.01940547f, -0.02362118f, 0.08734230f, 0.03618483f, -0.12089359f, 
    0.16031513f, -0.08000386f, -0.18502641f, 0.14375818f, 0.03733478f, -0.03954526f, -0.15147054f, -0.04098086f, 
    -0.00034671f, 0.30859470f, 0.07302335f, 0.18067887f, -0.03741615f, 0.02749337f, 0.13073601f, -0.02198421f, 
    -0.04056229f, 0.10854883f, 0.18713678f, -0.12797795f, 0.05564054f, 0.14266257f, 0.03278309f, -0.09674270f, 
    0.07409184f, -0.00834566f, -0.28431174f, -0.05940704f, 0.13014381f, 0.22751594f, 0.09608404f, 0.07129703f, 
    0.12517178f, 0.00199521f, 0.05856157f, 0.18435045f, 0.11917513f, -0.06584185f, 0.17543139f, 0.29295683f, 
    -0.09528486f, 0.07486431f, -0.07590839f, 0.11004799f, 0.15168111f, -0.04238961f, -0.23021914f, -0.28237504f, 
    0.18183398f, 0.31659871f, -0.05868767f, -0.06730510f, 0.01603570f, -0.02651981f, 0.26218310f, -0.11283259f, 
    0.07615157f, -0.21243432f, 0.03885301f, -0.10663580f, -0.03869035f, 0.03681993f, -0.18584692f, -0.02180092f, 
    -0.08313799f, 0.08127546f, 0.07837981f, 0.08888225f, 0.03660509f, 0.05432249f, -0.03814311f, -0.04339070f, 
    -0.04415531f, -0.43862572f, 0.02058959f, 0.09250805f, -0.00597997f, 0.03581447f, 0.00886226f, -0.09029631f, 
    0.20902531f, -0.00980646f, 0.09396149f, 0.11995217f, -0.07158805f, 0.05290832f, -0.03537925f, -0.12886451f, 
    0.08539695f, 0.04864307f, -0.10691671f, -0.14128882f, 0.24897960f, -0.05125436f, -0.04339951f, 0.03659954f, 
    -0.16549592f, 0.07382703f, 0.18579701f, 0.15333505f, 0.35973218f, 0.18270959f, -0.46400791f, -0.13507853f, 
    0.08062255f, 0.04662745f, 0.08068731f, 0.01244668f, -0.06949645f, -0.01469927f, 0.13591906f, 0.16901211f, 
    0.05843617f, 0.07716811f, -0.11599159f, -0.07004209f, 0.11828589f, 0.18347298f, 0.12204595f, 0.37969118f, 
    0.35004228f, 0.07409354f, 0.23382539f, 0.00949477f, -0.02488269f, 0.07909596f, -0.05986878f, 0.00271046f, 
    -0.04435651f, -0.02436258f, -0.12030052f, 0.10284043f, 0.04353016f, 0.10059682f, 0.09973230f, -0.20281932f, 
    -0.03517435f, 0.16700624f, -0.11126091f, 0.00628636f, 0.05292211f, -0.21851280f, 0.13285045f, 0.06438281f, 
    0.04948012f, -0.07475090f, -0.24551314f, -0.38048697f, -0.01522546f, -0.00964936f, -0.08541793f, 0.05696007f, 
    -0.16754387f, 0.02748759f, -0.15469220f, -0.44477037f, -0.04930042f, 0.06182657f, 0.12559396f, -0.02382123f, 
    0.18912114f, -0.04015275f, 0.38701171f, 0.24694744f, 0.11190972f, -0.05449270f, 0.00781322f, -0.00616444f, 
    -0.02448622f, -0.00526714f, -0.02549586f, -0.10970718f, 0.06209848f, 0.11396913f, 0.07990223f, -0.10740108f, 
    0.01384408f, -0.23716414f, 0.05708672f, 0.08235405f, -0.08072437f, 0.04244094f, 0.16198386f, 0.03966732f, 
    -0.02713894f, -0.04096466f, -0.20529692f, -0.05009675f, 0.03120369f, 0.03914391f, -0.73576140f, -0.26077968f, 
    0.34896094f, 0.01049752f, 0.11822527f, 0.06275844f, 0.04856378f, -0.12648499f, -0.04693100f, -0.10867473f, 
    0.02746975f, -0.11673013f, -0.07206339f, -0.07898288f, -0.15735425f, -0.00793955f, 0.08161739f, -0.03160428f, 
    0.15251225f, 0.31244522f, 0.28163594f, -0.08438461f, 0.02390167f, 0.12080181f, -0.15303130f, 0.15502223f, 
    0.00481746f, 0.35211778f, -0.16001450f, -0.09242092f, -0.02195074f, 0.17827828f, -0.06753436f, 0.01732637f, 
    0.38359743f, -0.17712940f, 0.06389008f, 0.00743635f, -0.05832992f, -0.04683876f, -0.29005343f, -0.15875100f, 
    0.01963868f, -0.03039908f, -0.06017328f, -0.06299863f, 0.10429791f, 0.02963405f, -0.00340266f, -0.02445005f, 
    -0.21207607f, 0.16175693f, 0.22739634f, 0.07209510f, 0.03725689f, 0.22271617f, -0.05386846f, -0.08950168f, 
    -0.07342361f, -0.21435022f, 0.05133077f, 0.04992922f, -0.14689833f, -0.03890458f, -0.00563134f, -0.45049372f, 
    0.18587846f, 0.35582203f, 0.31076282f, 0.14217171f, -0.00781603f, -0.29101443f, 0.18770003f, 0.03573793f, 
    0.09516105f, -0.01141263f, 0.00774978f, 0.00072725f, 0.07894728f, -0.02743883f, 0.05105098f, 0.25759166f, 
    -0.05973775f, -0.33578956f, -0.04747829f, -0.10544778f, -0.11003389f, 0.11739333f, -0.00081684f, -0.16045871f, 
    0.08319122f, -0.29161286f, 0.19906491f, -0.09871777f, 0.01779725f, 0.01113823f, -0.07338115f, -0.04562711f, 
    0.09330770f, -0.12910275f, 0.07739855f, 0.04932491f, 0.06993289f, -0.08693486f, -0.09016817f, -0.03177267f, 
    0.15476571f, 0.05859881f, -0.15243755f, 0.00252830f, 0.03214673f, 0.03583334f, -0.00217655f, 0.08807326f, 
    0.01975595f, -0.06080192f, 0.05487562f, 0.08230981f, -0.19609554f, -0.30234984f, 0.01901379f, 0.02115683f, 
    0.06938071f, 0.07240601f, -0.07071028f, -0.10585427f, -0.12542163f, -0.10483493f, 0.10098372f, -0.01402178f, 
    -0.01196373f, -0.06493931f, 0.13571945f, -0.08001276f, -0.00122374f, -0.02023660f, -0.00281558f, -0.06867957f, 
    -0.00947957f, 0.27388468f, 0.08944300f, 0.14335552f, 0.03909846f, -0.14756413f, 0.04655178f, 0.05835470f, 
    0.19833925f, -0.07984039f, 0.29452655f, 0.08380184f, -0.05243932f, -0.08475129f, -0.12878084f, 0.01059265f, 
    -0.08695760f, 0.22073948f, -0.06098059f, 0.06507523f, -0.13973966f, -0.08741733f, -0.13515922f, 0.37525338f, 
    -0.09075353f, -0.00701248f, 0.12745415f, 0.08669279f, 0.13629456f, -0.01812133f, 0.11365814f, -0.03644584f, 
    0.36765710f, -0.26154396f, 0.14921221f, 0.11675216f, 0.02522732f, -0.03133837f, -0.17774908f, 0.04200768f, 
    -0.01920187f, 0.06542806f, -0.24908577f, 0.35704884f, -0.32854462f, -0.02689674f, 0.08935279f, -0.13660264f, 
    0.18325610f, 0.10367583f, -0.01620649f, -0.20506002f, -0.10763972f, 0.14388743f, -0.02626962f, 0.08337878f, 
    -0.16770013f, 0.22601354f, -0.20725071f, 0.02415163f, -0.19624613f, 0.00628982f, 0.13643785f, 0.10066568f, 
    0.11814981f, 0.20541415f, 0.06864441f, 0.10442359f, 0.13243207f, -0.20940931f, -0.11460890f, 0.03126652f, 
    -0.08626968f, 0.02934113f, -0.08476447f, -0.08577719f, 0.14598115f, 0.14974295f, -0.38371345f, 0.14016853f, 
    -0.44929525f, -0.01492989f, 0.02327752f, 0.02028701f, -0.05081163f, -0.09463014f, -0.04149227f, -0.29214558f, 
    -0.08930194f, -0.06391430f, -0.12817617f, 0.02111679f, 0.01872006f, 0.10234910f, 0.01770309f, -0.11041577f, 
    -0.06063213f, -0.02983391f, -0.07096195f, 0.01264041f, -0.06687969f, -0.10907894f, 0.00447060f, 0.04583913f, 
    0.02795206f, 0.13329993f, 0.11862127f, 0.39015201f, 0.08943357f, 0.00222215f, -0.15492044f, 0.06037113f, 
    0.11672557f, -0.01106393f, -0.25003582f, -0.36793011f, 0.26660612f, 0.04566253f, 0.04705804f, -0.25645974f, 
    0.00552405f, 0.08785947f, -0.03870720f, -0.13769500f, -0.03225032f, -0.01088517f, 0.17924193f, 0.04260593f, 
    0.09993713f, 0.09440053f, 0.01597964f, -0.04751119f, -0.22083043f, 0.00605055f, 0.09553238f, 0.02947476f, 
    -0.09816052f, 0.02094150f, 0.14427011f, -0.09639908f, 0.10265503f, -0.39564908f, 0.03847201f, -0.54046535f, 
    0.01881110f, -0.00778550f, -0.15015416f, 0.15908760f, -0.05408872f, 0.06386429f, -0.53669208f, -0.09108198f, 
    0.44419271f, -0.30204812f, -0.00533689f, 0.09642200f, -0.01836102f, 0.11018871f, 0.12783964f, 0.05338858f, 
    0.04644343f, 0.24122053f, 0.07277095f, -0.07208204f, -0.26371491f, 0.03333742f, -0.03239948f, -0.18559983f, 
    -0.42232025f, 0.08613758f, 0.56560212f, -0.10043593f, -0.12901874f, -0.13539356f, -0.15555121f, -0.19154884f, 
    -0.06554004f, -0.40746668f, -0.20611614f, 0.13069724f, 0.24573973f, 0.09487130f, -0.07287253f, -0.07136664f, 
    -0.06153394f, 0.10673638f, -0.06124552f, -0.04238559f, -0.01150055f, -0.05219869f, -0.08834428f, -0.08798940f, 
    0.11437604f, 0.08835880f, -0.15578836f, -0.18059069f, 0.42627603f, 0.11633722f, -0.13848929f, 0.06490590f, 
    -0.10056937f, 0.24454181f, 0.09725996f, 0.04330521f, -0.17032568f, 0.09231957f, 0.00264396f, -0.08549435f, 
    -0.06785283f, -0.03659280f, 0.07151186f, 0.06662391f, -0.04675623f, -0.12943798f, 0.14880590f, 0.00787667f, 
    0.20861690f, 0.37031406f, -0.00900918f, 0.18328099f, -0.01284656f, -0.42718008f, -0.18789932f, -0.08847027f, 
    0.32890505f, 0.10559464f, 0.05378428f, -0.15326217f, -0.00558469f, -0.06779454f, -0.15389723f, -0.07598499f, 
    0.22503506f, 0.46813691f, -0.01222432f, -0.07199705f, 0.01611004f, 0.19612272f, 0.10833807f, -0.01697510f, 
    -0.36334175f, -0.00323153f, 0.08735321f, -0.12378993f, -0.14258777f, 0.11021645f, -0.05209393f, 0.14174034f, 
    0.06700207f, 0.19873077f, 0.35240346f, 0.35314158f, 0.07210513f, 0.11924315f, -0.40996757f, -0.00169419f, 
    0.01174220f, 0.03851765f, -0.02823914f, 0.14727338f, 0.26173303f, -0.28719857f, 0.12545286f, 0.38882795f, 
    0.00675258f, 0.15157007f, -0.07318777f, -0.07420427f, 0.01312717f, 0.17828618f, 0.15993273f, 0.06092260f, 
    -0.02910160f, 0.00165871f, 0.12255497f, -0.17665620f, 0.20626041f, -0.41374499f, 0.49662423f, -0.10625321f, 
    -0.19482675f, 0.05573885f, 0.06346440f, -0.05013267f, 0.10493284f, -0.35947102f, -0.11548305f, 0.00423707f, 
    -0.09009691f, -0.02459796f, 0.02563608f, -0.08324081f, -0.14577022f, 0.04855826f, -0.16008459f, -0.02446279f, 
    0.06881596f, 0.25668418f, -0.02242563f, 0.04258849f, -0.02651867f, -0.01234428f, 0.08663493f, -0.13421078f, 
    0.16817445f, 0.33971578f, 0.21815842f, 0.00908182f, 0.05863184f, 0.13379240f, 0.08246535f, -0.03875741f, 
    0.01408327f, -0.01048152f, 0.00889937f, 0.01584767f, -0.04267747f, 0.04532527f, -0.00068833f, -0.04149631f, 
    -0.03568347f, 0.01757609f, -0.03733833f, -0.04038822f, 0.03488338f, -0.03520367f, 0.02198274f, -0.00342341f, 
    0.03131656f, -0.00371346f, -0.04462895f, 0.04871229f, -0.03250967f, 0.00885110f, -0.01149316f, 0.01323875f, 
    0.00286342f, -0.05208468f, 0.02244156f, 0.01370753f, -0.03587633f, -0.00280947f, 0.01624149f, -0.06549563f, 
    -0.01167573f, 0.01268023f, -0.01958823f, -0.01968332f, -0.02948738f, 0.03601773f, 0.03785867f, -0.00186761f, 
    -0.03253432f, -0.05617584f, -0.01717916f, 0.04442681f, -0.04176052f, 0.04677832f, 0.04236296f, 0.00729532f, 
    -0.03066150f, 0.03119302f, 0.01539556f, 0.01210016f, 0.03408749f, -0.02109057f, 0.03307464f, 0.00149754f, 
    -0.04185271f, 0.03872284f, 0.02716617f, 0.04236947f, -0.05614555f, -0.03476354f, 0.02812086f, 0.03563472f, 
    -0.00939809f, -0.03249383f, -0.01499221f, -0.05914647f, 0.00647116f, 0.01510268f, 0.01473568f, 0.03956776f, 
    0.01027277f, 0.04939221f, 0.02256749f, -0.02984329f, 0.03443966f, -0.05903178f, -0.01454500f, -0.00944108f, 
    -0.04531160f, -0.00820657f, 0.04330322f, 0.01185870f, 0.01459733f, 0.01954764f, -0.05900725f, -0.03229649f, 
    -0.03132217f, -0.02740476f, -0.03712033f, -0.06866932f, 0.01387493f, 0.03060847f, -0.02901134f, -0.01777389f, 
    -0.01703469f, -0.02846045f, -0.00202328f, -0.01433135f, -0.01077770f, -0.03544054f, -0.03109877f, -0.03286991f, 
    0.03360565f, -0.04408962f, 0.03015357f, -0.01760669f, 0.04438513f, 0.01610227f, 0.02156430f, -0.02116065f, 
    -0.06772693f, -0.01609696f, -0.00035691f, -0.03122563f, 0.04334011f, -0.04002384f, 0.04261535f, -0.00411050f, 
    -0.03704533f, 0.02223617f, -0.06964806f, -0.00746101f, 0.04874155f, -0.06639890f, 0.01560274f, -0.04564695f, 
    -0.02863618f, -0.05652583f, 0.02427066f, 0.03256672f, -0.05333434f, -0.01144605f, 0.00734744f, -0.03507087f, 
    -0.01714482f, -0.00442228f, -0.01578426f, 0.01614635f, -0.02020605f, -0.01769911f, -0.02722523f, -0.05763248f, 
    -0.03406210f, -0.01947290f, -0.00063242f, -0.02225810f, 0.03247770f, -0.03899783f, 0.01696375f, 0.03705365f, 
    -0.02576043f, 0.00738625f, 0.02857052f, -0.04111350f, -0.00354810f, -0.02331926f, 0.02155999f, 0.03167798f, 
    0.01965477f, 0.02516034f, -0.00218412f, 0.00743969f, 0.04337237f, 0.01391452f, -0.05612824f, 0.03856130f, 
    0.04516611f, -0.04412292f, 0.02200125f, 0.03028970f, -0.01247933f, 0.04505640f, -0.05332714f, 0.01062148f, 
    0.02007761f, -0.02868969f, 0.02396325f, -0.05275264f, -0.02479053f, -0.00578305f, -0.01419503f, -0.02892176f, 
    0.04162565f, -0.00630705f, -0.04117939f, -0.05706739f, -0.03463484f, -0.03849841f, 0.04436320f, -0.04839477f, 
    -0.03720885f, -0.04080540f, 0.01223685f, -0.06087124f, 0.02618545f, -0.04004303f, 0.03850221f, 0.00805051f, 
    -0.01395221f, -0.07406618f, -0.02765169f, -0.03095856f, 0.00646668f, -0.04765216f, 0.02058842f, -0.05482350f, 
    0.03224113f, 0.03019191f, -0.02744869f, -0.05227100f, -0.03823339f, 0.00313449f, -0.03341855f, -0.05684698f, 
    0.03587795f, 0.00586352f, -0.03193530f, -0.02532188f, 0.04107046f, -0.04695423f, -0.00799603f, -0.02540042f, 
    0.00224857f, -0.03584145f, 0.03112916f, 0.02341098f, -0.05849223f, -0.01723948f, 0.02396035f, -0.00884719f, 
    -0.00862875f, -0.06292347f, -0.01725249f, -0.00832348f, 0.01438926f, -0.01415815f, 0.01110429f, -0.06267587f, 
    0.03495653f, -0.06821703f, -0.03559336f, -0.05585660f, -0.01657831f, 0.00650479f, -0.00891021f, -0.00221647f, 
    -0.00584686f, 0.03825740f, 0.04615564f, 0.03772357f, -0.02153811f, 0.02590546f, -0.05700176f, -0.02794189f, 
    0.01500597f, -0.02962345f, 0.00122444f, -0.01319472f, 0.03597113f, -0.07201365f, -0.01566558f, -0.04764788f, 
    -0.02169398f, -0.06321935f, 0.04745935f, -0.01362203f, -0.00153524f, 0.01824618f, -0.03659327f, -0.03563189f, 
    -0.02193892f, -0.00691265f, -0.01563401f, 0.04658254f, -0.01152144f, 0.03258506f, 0.03151395f, -0.06001781f, 
    -0.01478248f, 0.01702825f, 0.04426589f, -0.02314382f, 0.02872203f, 0.00437969f, -0.04522590f, 0.01989885f, 
    -0.04264379f, -0.18280590f, -0.06372117f, 0.23841405f, 0.14426091f, -0.07750237f, -0.34930024f, -0.25801203f, 
    -0.66890234f, 0.02804517f, 0.22963364f, -0.20052564f, -0.09283791f, 0.11319289f, 0.02879186f, -0.05014740f, 
    0.02320623f, -0.05885437f, 0.15221176f, 0.02017692f, -0.20468679f, -0.08260672f, 0.08539524f, 0.10373548f, 
    0.01108706f, -0.02998038f, 0.01046880f, -0.06098009f, 0.05493107f, -0.05433350f, 0.12380732f, 0.03620881f, 
    0.04654394f, -0.25332671f, -0.01822309f, 0.07159089f, 0.20598976f, -0.22358741f, -0.18107194f, 0.07496741f, 
    0.07686929f, -0.06566414f, 0.02828425f, -0.01370865f, -0.27563092f, 0.11690941f, 0.22897446f, -0.14882997f, 
    -0.00243316f, -0.04689312f, -0.00707042f, 0.04745239f, 0.04043420f, -0.09928073f, 0.59787405f, 0.12779404f, 
    -0.27137741f, -0.08034142f, 0.03786804f, 0.17983036f, -0.05195781f, -0.13693868f, -0.07010677f, -0.16252120f, 
    -0.01932524f, -0.16716456f, -0.08067591f, 0.01448647f, -0.07947558f, 0.20359577f, 0.05083277f, -0.08721143f, 
    0.03901653f, 0.04876047f, -0.05506833f, 0.05779792f, 0.13104035f, 0.08445466f, -0.12216487f, -0.11716434f, 
    -0.40374446f, 0.07054336f, 0.07774965f, 0.12234251f, -0.02065478f, 0.02837293f, -0.14275469f, -0.11773749f, 
    0.00146821f, 0.09788750f, 0.38145936f, 0.42460275f, 0.33801049f, -0.12396538f, 0.18233864f, 0.15438983f, 
    0.04086964f, -0.10960574f, -0.01140965f, -0.11020240f, -0.06192492f, -0.00707466f, 0.16293313f, 0.02379135f, 
    0.05382986f, -0.16275455f, -0.29205278f, -0.21598741f, -0.09220670f, 0.00980669f, -0.21194498f, 0.11802757f, 
    0.24265076f, 0.08225220f, 0.09063430f, -0.00063467f, -0.28239003f, 0.25909162f, 0.03746589f, -0.40644825f, 
    0.07215013f, 0.23712350f, -0.00695850f, 0.09945437f, -0.03679848f, -0.18410765f, -0.18005055f, 0.18685640f, 
    0.13270795f, 0.29951656f, 0.15528156f, 0.12706915f, 0.07587253f, -0.03700035f, -0.01940369f, 0.11312527f, 
    0.12104958f, 0.15312770f, -0.03335347f, 0.20332065f, -0.12680590f, -0.09775320f, 0.12510957f, 0.18602611f, 
    -0.04536083f, 0.18652286f, -0.00116784f, 0.02677827f, 0.09949440f, 0.25387508f, -0.07463457f, 0.06641906f, 
    0.01422948f, -0.17726594f, 0.10440861f, -0.08941777f, -0.01241888f, 0.00164943f, -0.30664593f, 0.20525444f, 
    0.00251543f, -0.10263989f, -0.01757281f, -0.02289221f, -0.04873404f, 0.05872410f, 0.06224873f, 0.03549179f, 
    -0.29231390f, -0.22737426f, -0.40276700f, -0.00696623f, 0.06483807f, -0.19362815f, 0.03091248f, 0.04363291f, 
    0.11807337f, 0.09674682f, 0.07274198f, 0.14497623f, -0.00656180f, 0.00786763f, -0.11013710f, 0.00321423f, 
    0.14879906f, 0.11861019f, -0.37244013f, -0.33293381f, -0.25965646f, 0.13949282f, 0.29602820f, 0.10815004f, 
    0.02556581f, -0.05549763f, -0.27334750f, 0.02798730f, 0.13708287f, 0.12164882f, 0.32029891f, -0.01570781f, 
    0.01252005f, -0.00434338f, 0.07836138f, 0.19158332f, -0.19717935f, -0.16334710f, -0.03276764f, 0.13322687f, 
    0.01159713f, 0.15837231f, -0.12169029f, 0.02138823f, 0.22989072f, -0.05227807f, 0.05478157f, 0.15969637f, 
    -0.25759646f, 0.14363733f, 0.05025072f, -0.24528095f, -0.06649029f, -0.07264035f, 0.20919064f, -0.03558836f, 
    0.06723033f, -0.18854709f, 0.16938446f, 0.43193597f, -0.05789374f, 0.09031857f, -0.13061358f, -0.10751134f, 
    0.08192109f, 0.20042910f, 0.01737180f, 0.07659421f, 0.18392757f, 0.12691638f, -0.29872021f, -0.02970922f, 
    0.07759731f, 0.11386662f, -0.04298882f, 0.54640371f, -0.03714747f, -0.04860887f, -0.09308175f, -0.09346655f, 
    -0.14251181f, -0.11789019f, 0.08200007f, 0.35243616f, -0.40002066f, 0.22666261f, 0.06352364f, 0.00386650f, 
    -0.07942996f, -0.06218613f, 0.05606290f, 0.12876576f, -0.07938629f, 0.17678791f, -0.05907543f, 0.00844258f, 
    0.11827596f, 0.20340200f, 0.14972030f, 0.25594020f, -0.03429858f, 0.07033594f, -0.12434344f, 0.03581756f, 
    0.00029445f, 0.38732624f, 0.20438503f, 0.08583534f, -0.40312466f, -0.69848341f, -0.34468448f, 0.09419313f, 
    0.06011996f, 0.26251212f, -0.16922161f, 0.02456159f, 0.02980945f, -0.11277346f, -0.05623550f, 0.12456425f, 
    0.08967132f, 0.03617970f, -0.01825765f, 0.02719614f, 0.00737875f, 0.06951568f, 0.03316594f, -0.03984384f, 
    0.04733984f, 0.05960913f, -0.00475782f, -0.03800751f, 0.08806505f, -0.17641872f, 0.17852743f, 0.00126419f, 
    -0.14698108f, -0.11172208f, 0.06168807f, 0.04342150f, 0.21243571f, 0.00344067f, 0.12502068f, -0.03294845f, 
    0.01293538f, 0.09954726f, 0.05828025f, 0.14031456f, -0.06001533f, -0.02411606f, 0.14992167f, -0.03019879f, 
    -0.07158650f, 0.24707882f, -0.00747103f, -0.03361176f, -0.02674356f, -0.02780218f, -0.11703394f, 0.07143639f, 
    -0.03153791f, 0.07105327f, 0.08994226f, 0.07764073f, -0.14671454f, 0.15133673f, 0.09738306f, -0.00152758f, 
    0.12183136f, 0.02917090f, 0.03455568f, 0.09308287f, 0.14347012f, -0.03130591f, -0.30791578f, -0.30504906f, 
    -0.06873228f, -0.23345721f, -0.04460455f, -0.37818435f, 0.20511967f, 0.06501271f, -0.03158516f, -0.09556477f, 
    0.09381009f, 0.02908409f, 0.05153150f, 0.05317983f, 0.05674498f, 0.20109406f, -0.06734654f, -0.07506101f, 
    0.20283276f, 0.05182865f, -0.00520467f, -0.00337989f, -0.16925049f, -0.02220785f, 0.05324849f, -0.09403490f, 
    -0.05893435f, -0.16119182f, -0.01991923f, -0.18385221f, -0.25278068f, -0.33074921f, -0.10018939f, -0.10865625f, 
    0.11608030f, -0.13213685f, -0.11099815f, -0.28062761f, -0.08886856f, -0.28080332f, -0.28117323f, -0.16983248f, 
    -0.08553686f, 0.02462772f, -0.04141323f, 0.05543803f, -0.01274160f, -0.11587957f, 0.01486768f, -0.01362717f, 
    -0.02742766f, 0.08885316f, 0.05023038f, -0.00589402f, 0.22857447f, 0.09000279f, 0.19814298f, 0.03784323f, 
    0.09092636f, -0.01210002f, 0.04812917f, 0.13084058f, 0.07669839f, 0.06427994f, 0.07807200f, 0.17444348f, 
    -0.00609011f, 0.08605915f, -0.08755367f, 0.22279711f, 0.07973398f, 0.04793747f, -0.03285833f, 0.05937923f, 
    -0.02812124f, -0.17178202f, 0.02209557f, 0.00349068f, -0.24986258f, -0.16226795f, -0.10571459f, -0.20822965f, 
    0.19446960f, -0.28956497f, -0.14131178f, 0.12441352f, 0.03354982f, -0.04321146f, -0.01171296f, -0.27413264f, 
    0.35162362f, 0.07949226f, -0.05943555f, -0.04901925f, 0.07587994f, 0.03536847f, -0.25356662f, 0.17096899f, 
    -0.22778480f, -0.11513857f, -0.00852260f, 0.16959673f, 0.04017869f, -0.03092949f, -0.02615702f, 0.12986276f, 
    0.12328623f, -0.06569698f, 0.16546762f, 0.02062817f, 0.01861084f, 0.08141687f, -0.03203117f, -0.03637230f, 
    0.15657367f, -0.00456997f, -0.03945192f, 0.15725966f, -0.01949660f, 0.14285536f, 0.10202762f, -0.10007504f, 
    -0.07121091f, 0.07316017f, -0.09358974f, -0.07553313f, 0.18433535f, 0.00015235f, 0.07934285f, -0.02702784f, 
    -0.02242903f, -0.09374737f, 0.11681309f, 0.01209498f, 0.00334598f, -0.13671249f, 0.09645240f, -0.19158944f, 
    0.03398686f, 0.25387061f, 0.10383809f, 0.43860874f, 0.07805730f, 0.12464713f, 0.42612347f, 0.43888959f, 
    0.22614612f, -0.15048192f, -0.24182990f, -0.12935506f, -0.14076856f, -0.15851025f, -0.08589490f, 0.16126165f, 
    0.37733379f, 0.11698968f, -0.22637054f, -0.32665658f, -0.14232752f, -0.13214090f, 0.04704019f, -0.09735668f, 
    -0.13626669f, 0.11890312f, -0.00200193f, 0.11200029f, 0.05065705f, 0.00588891f, 0.02618371f, -0.01383212f, 
    -0.03174668f, -0.11199287f, 0.08853471f, -0.17993611f, 0.24387951f, -0.23908854f, 0.21319258f, 0.00894302f, 
    0.15142219f, -0.12021556f, 0.20896469f, 0.09359139f, -0.02043909f, 0.07230221f, 0.09263755f, -0.02737147f, 
    0.07699102f, 0.08015860f, -0.00338114f, 0.04637422f, -0.22013308f, -0.10892916f, -0.20407450f, -0.21465649f, 
    -0.35564190f, -0.18872051f, 0.08737863f, -0.11979852f, 0.32140195f, 0.01803857f, -0.02325728f, 0.17575228f, 
    0.11410114f, -0.05375670f, 0.12843053f, 0.12310179f, 0.00969552f, 0.04198761f, -0.14198916f, -0.04722162f, 
    -0.04640730f, -0.08621844f, -0.08490019f, 0.15459552f, 0.15729327f, -0.18892847f, 0.18655421f, 0.10878428f, 
    0.04176483f, 0.10272758f, -0.04801829f, 0.07894752f, -0.00572695f, -0.07561314f, 0.08660462f, -0.21821217f, 
    -0.19674920f, -0.17214881f, -0.29591361f, -0.15762204f, -0.18122034f, -0.06032068f, 0.06020875f, -0.09862805f, 
    -0.02921337f, 0.02964805f, 0.01891224f, -0.04596834f, 0.02132360f, -0.03627846f, 0.04894606f, -0.01451858f, 
    -0.04780374f, 0.02480288f, 0.03540604f, -0.06076186f, 0.01422934f, -0.01702029f, -0.03803942f, 0.03213309f, 
    -0.05376405f, 0.01753960f, 0.02713718f, 0.03826534f, -0.01551226f, -0.02729557f, -0.01471143f, 0.03299449f, 
    0.00552939f, 0.01350589f, -0.05864683f, -0.05247384f, 0.04461053f, -0.00273805f, 0.00148923f, 0.02557291f, 
    -0.02520986f, -0.00751872f, 0.04777175f, 0.03645833f, 0.01672393f, 0.03168327f, 0.04108790f, 0.03289973f, 
    -0.05679194f, 0.02034970f, -0.00705905f, -0.04963160f, 0.03775353f, 0.03895635f, 0.03166696f, -0.03802174f, 
    -0.02456984f, -0.02204048f, 0.00512393f, -0.05193548f, 0.01944939f, -0.03074097f, 0.00910565f, 0.03848018f, 
    -0.05872276f, -0.02970273f, -0.00036311f, -0.00508643f, 0.00715039f, -0.01793996f, -0.03871627f, 0.00208224f, 
    -0.02365752f, -0.06382514f, -0.02806079f, -0.05153659f, -0.01641341f, -0.02736484f, 0.00028829f, -0.03290318f, 
    -0.03866251f, -0.00874455f, -0.03080904f, -0.04072630f, -0.01403511f, 0.04130855f, 0.02306303f, -0.04269680f, 
    0.02148542f, -0.06307783f, 0.00360578f, -0.00233393f, -0.03895319f, -0.01587716f, -0.05193057f, 0.00238513f, 
    0.03014579f, 0.01783401f, 0.02221382f, -0.03553548f, 0.04819364f, 0.02716791f, -0.00876184f, -0.05262815f, 
    0.03184655f, 0.02939211f, -0.05399175f, -0.03045176f, -0.02565707f, 0.05090336f, 0.03169600f, -0.04076428f, 
    0.02072977f, -0.05232183f, -0.02591830f, 0.00403199f, 0.03017004f, -0.01703878f, 0.04709512f, -0.06362297f, 
    -0.02142979f, 0.01028578f, -0.00067248f, -0.02745557f, 0.02843913f, -0.03996558f, -0.05223754f, -0.01535314f, 
    -0.03429805f, -0.04176867f, -0.05425051f, -0.03450834f, -0.04758688f, 0.02618316f, -0.04555456f, -0.03448957f, 
    -0.01744503f, -0.03932774f, 0.00122627f, -0.01154951f, 0.02420528f, 0.02408701f, -0.06082640f, -0.02995620f, 
    -0.04839902f, 0.04743776f, -0.06006363f, 0.03207073f, 0.00971912f, 0.02498245f, -0.01006041f, 0.00385922f, 
    -0.06009511f, -0.01033858f, 0.03859599f, 0.04528814f, 0.01564335f, -0.01375310f, -0.01765732f, 0.04937974f, 
    -0.06368100f, -0.05727047f, -0.01556935f, -0.04110581f, 0.02464825f, 0.02365376f, -0.01517321f, -0.01207400f, 
    -0.01379000f, 0.00477444f, 0.04304931f, -0.04949099f, 0.02379066f, 0.00227931f, -0.03851744f, 0.00259330f, 
    0.03311658f, 0.02488991f, -0.04879671f, 0.04957710f, -0.00253254f, -0.00315591f, -0.01599573f, -0.05181443f, 
    0.00776740f, 0.02438252f, 0.01488068f, -0.05797011f, 0.01506399f, -0.03945063f, -0.02218506f, 0.03534767f, 
    -0.03126659f, 0.00608259f, 0.03303474f, -0.05720463f, 0.01055306f, -0.01696250f, 0.01438036f, 0.01609389f, 
    -0.05655239f, -0.04828827f, 0.04509789f, -0.02625783f, -0.05233426f, -0.01018279f, 0.00540548f, 0.00639888f, 
    0.04005659f, 0.02509735f, -0.04542376f, 0.02241875f, -0.02144969f, -0.00720071f, -0.06211029f, 0.02729131f, 
    0.00285825f, -0.00753854f, 0.04389280f, -0.04320273f, 0.02976168f, 0.03988202f, -0.06207501f, -0.01713255f, 
    0.02979289f, 0.02233806f, -0.01056224f, 0.00759450f, -0.03407508f, -0.00014607f, 0.03950605f, -0.03080641f, 
    -0.04126263f, -0.05849154f, 0.04545567f, -0.03396453f, 0.00439074f, 0.00953486f, -0.02005796f, 0.02803284f, 
    -0.02497436f, 0.00619760f, 0.00011995f, 0.03644670f, -0.03884847f, 0.01929961f, -0.06018296f, -0.01620209f, 
    0.02509663f, -0.05646860f, -0.02732326f, 0.03189271f, -0.01253009f, 0.04859753f, -0.05267822f, 0.04613851f, 
    -0.04278814f, -0.05389871f, -0.06061694f, -0.01406848f, -0.04533762f, -0.01459943f, 0.00287408f, -0.03052781f, 
    -0.01447042f, -0.01734752f, 0.04149944f, -0.00509616f, -0.00813322f, -0.03725476f, 0.02115461f, -0.03960650f, 
    -0.00576086f, -0.04756830f, -0.02563415f, -0.04883577f, 0.03346541f, 0.02430148f, 0.02788824f, 0.05268057f, 
    -0.05702361f, 0.03605513f, -0.02237110f, -0.05617907f, 0.04002110f, -0.02682749f, -0.00136811f, -0.00607810f, 
    0.01428908f, -0.05741104f, 0.00091596f, 0.00392123f, 0.00603608f, -0.04512709f, 0.01138844f, -0.06402404f, 
    -0.03942410f, -0.06024440f, 0.00596500f, 0.00573549f, -0.04289536f, -0.01591638f, 0.00657321f, 0.04223127f, 
    -0.05109524f, -0.03401202f, -0.02807805f, -0.05260365f, -0.00884087f, 0.04752046f, 0.03618179f, -0.01338764f, 
    0.02099487f, 0.02717583f, -0.02741096f, 0.00834187f, 0.02526046f, -0.06145244f, -0.01180942f, 0.01837246f, 
    -0.00586032f, 0.02717034f, -0.01841566f, -0.05708769f, -0.05658759f, -0.03368183f, 0.04674333f, -0.02511094f, 
    0.03592549f, 0.05581093f, -0.04303158f, -0.00992503f, -0.05086124f, -0.02359152f, 0.05118024f, -0.01219751f, 
    -0.06024659f, -0.01287525f, 0.05250485f, 0.00487492f, -0.04077982f, -0.01823386f, 0.01437859f, 0.01551136f, 
    -0.04119615f, -0.03453157f, 0.04256529f, -0.03375697f, -0.04483239f, -0.00851695f, 0.03409006f, 0.04598448f, 
    -0.03898266f, -0.02825538f, 0.01856259f, 0.00515127f, -0.06014530f, 0.01646809f, -0.02095147f, -0.02251479f, 
    0.04277853f, -0.04024414f, -0.03712047f, 0.01365567f, -0.03579866f, -0.03105612f, -0.05010262f, 0.00467044f, 
    0.02625523f, -0.01934460f, 0.01059008f, -0.02966589f, 0.04199669f, -0.03425337f, 0.01239209f, 0.04960300f, 
    0.03143701f, -0.04798665f, 0.05470469f, -0.02346298f, 0.00701631f, 0.03518077f, 0.01776051f, -0.03297193f, 
    -0.02266665f, 0.04900638f, 0.01281764f, 0.03533988f, -0.04903974f, -0.00211539f, -0.02272137f, -0.06443711f, 
    0.01566275f, -0.00024965f, 0.01656896f, 0.03913300f, 0.05031571f, -0.04557592f, -0.05916968f, -0.06334618f, 
    -0.05292485f, -0.05345222f, 0.04818458f, 0.00616346f, 0.01881761f, -0.01996858f, -0.05415564f, -0.05722288f, 
    0.00669651f, -0.00360321f, 0.00992034f, -0.02158883f, -0.02786355f, -0.05039067f, 0.01751408f, 0.04785153f, 
    -0.05605225f, -0.01790358f, -0.02510379f, 0.02066483f, -0.03446719f, -0.01799250f, 0.00988202f, 0.04895711f, 
    -0.05720649f, -0.05110095f, 0.03441881f, -0.00945271f, 0.02336861f, -0.00480586f, -0.01526689f, 0.02291004f, 
    -0.00006719f, -0.00527328f, -0.01645458f, 0.02398036f, 0.03696703f, -0.03978431f, -0.00051751f, 0.05206189f, 
    0.00111436f, -0.04555924f, 0.03237541f, 0.04112863f, -0.06345368f, -0.02577801f, -0.02038467f, 0.01248831f, 
    -0.00308696f, -0.05403035f, 0.01940587f, 0.01945444f, -0.04915620f, -0.06030758f, -0.03413360f, -0.03311393f, 
    0.02545910f, -0.02546739f, -0.00123796f, 0.03580727f, -0.02930935f, -0.06022634f, -0.06028036f, -0.05479631f, 
    -0.00754134f, -0.02812034f, 0.01630636f, -0.02658923f, 0.00906051f, -0.04408804f, -0.03596667f, 0.03256070f, 
    0.02879051f, 0.02268489f, -0.01919546f, 0.03093686f, 0.00031073f, -0.04350479f, 0.03507271f, -0.01055014f, 
    0.02395147f, -0.03071521f, 0.03035880f, 0.02932151f, -0.00321656f, -0.03443425f, 0.01915381f, -0.00337253f, 
    -0.02632790f, 0.05334418f, 0.01002211f, -0.04800535f, 0.01498233f, 0.01344769f, 0.01783048f, 0.00541979f, 
    0.00101154f, -0.06221930f, -0.03877898f, -0.03675994f, 0.03299161f, 0.02436575f, -0.03657711f, 0.04473481f, 
    0.04884436f, -0.04434147f, -0.04621489f, -0.02446631f, -0.01371110f, -0.04978303f, 0.05322919f, -0.05332590f, 
    -0.03508009f, 0.02875992f, -0.02612782f, 0.03972437f, -0.04298357f, 0.02141903f, -0.01835282f, 0.03630363f, 
    -0.06119631f, -0.01520513f, 0.04881212f, -0.03848166f, -0.04880941f, 0.03140815f, 0.00206113f, -0.00179652f, 
    -0.00753653f, 0.01985843f, 0.04747228f, -0.01874399f, 0.00348651f, 0.00381192f, 0.02088271f, 0.04107234f, 
    -0.01829875f, 0.04767378f, 0.03402660f, -0.03037789f, -0.05396719f, 0.01060811f, 0.02288945f, 0.03559520f, 
    0.03610414f, 0.01333020f, -0.05128619f, -0.04258380f, -0.03010934f, -0.03777443f, 0.03941546f, 0.01024070f, 
    -0.02243297f, -0.01603376f, 0.03169075f, 0.01513246f, 0.02536581f, -0.01151771f, -0.06281599f, -0.03464437f, 
    0.05164121f, 0.00050652f, 0.00093629f, -0.02671450f, -0.06290383f, 0.01625763f, 0.03119980f, 0.02703151f, 
    -0.03817181f, 0.03547973f, 0.01814222f, -0.00313087f, 0.04545549f, -0.04701544f, -0.04741048f, 0.03757399f, 
    -0.04509832f, -0.05204652f, -0.04713045f, 0.03921618f, -0.01742836f, 0.03797036f, -0.06306960f, -0.04990017f, 
    -0.01806913f, 0.06494997f, -0.00491208f, 0.14658535f, 0.05641707f, 0.21515851f, -0.01103832f, 0.05107368f, 
    0.12336509f, 0.21394420f, 0.14874196f, 0.34298638f, 0.01818919f, -0.04662454f, 0.06813332f, -0.10836364f, 
    -0.00086469f, 0.19429292f, 0.08679290f, 0.01265560f, 0.09212534f, 0.00642285f, -0.04048766f, 0.10795094f, 
    -0.03980543f, -0.04942170f, 0.00435003f, -0.07803264f, 0.08462516f, 0.05697895f, -0.17242657f, -0.03477206f, 
    0.01716678f, -0.08856993f, 0.28841341f, 0.11698860f, -0.11176328f, -0.13844150f, 0.02382738f, -0.19726017f, 
    -0.06251445f, 0.14593442f, -0.11895093f, 0.11771005f, 0.05284028f, 0.14233437f, 0.07176304f, 0.09641255f, 
    -0.03460608f, -0.05803805f, 0.05334213f, 0.15045892f, 0.24282485f, 0.11022456f, 0.15444927f, -0.01184300f, 
    0.42689463f, 0.18676533f, 0.08428955f, -0.09088449f, 0.17946193f, 0.06101500f, 0.01739029f, 0.26071075f, 
    -0.07410402f, 0.12143812f, 0.06657538f, 0.17829525f, -0.03453270f, 0.00811877f, 0.13975042f, 0.00417767f, 
    -0.03424380f, -0.09653872f, -0.02198280f, -0.06649199f, 0.09398541f, -0.04924893f, 0.03985998f, 0.03098597f, 
    -0.01918254f, 0.05407334f, 0.09662922f, -0.34242103f, -0.01262195f, -0.15043487f, -0.00787755f, 0.08037192f, 
    0.05020713f, -0.03943883f, -0.28048885f, -0.70790958f, -0.14626199f, 0.02038120f, -0.07839992f, 0.19457658f, 
    0.01960594f, -0.07987382f, -0.11616992f, 0.01230569f, -0.06448258f, 0.04187251f, 0.06635077f, 0.01081605f, 
    0.13100863f, -0.00594491f, 0.12161606f, -0.00109541f, -0.05514076f, 0.02343175f, 0.08265612f, -0.12241057f, 
    0.05186328f, -0.06678715f, -0.05971397f, -0.01099033f, 0.10889246f, -0.10900164f, -0.12848206f, 0.02687783f, 
    -0.10779089f, 0.01074644f, -0.00351364f, 0.06665551f, 0.08171240f, 0.01592777f, 0.12019118f, 0.04807901f, 
    -0.37325335f, 0.11158057f, 0.06160275f, 0.24223247f, -0.06701409f, -0.09997267f, -0.10849811f, -0.41286138f, 
    -0.18825519f, -0.01738316f, -0.01916096f, 0.02282759f, 0.03481103f, -0.06066785f, -0.14910547f, -0.08617654f, 
    -0.04958490f, -0.06994159f, -0.22886297f, -0.09855546f, 0.10105450f, -0.15855290f, -0.25724855f, 0.04067728f, 
    0.10307119f, 0.35528007f, -0.02403329f, 0.11949027f, 0.06215568f, 0.14223062f, -0.14600702f, -0.00624069f, 
    0.05974454f, -0.00164836f, -0.00227283f, -0.01541827f, -0.10036489f, -0.00156005f, 0.03759035f, 0.04691088f, 
    -0.07005888f, -0.00456533f, 0.01439488f, -0.01533660f, -0.04979683f, 0.06581414f, -0.17745692f, -0.13701351f, 
    -0.06973510f, 0.07675725f, 0.01839144f, 0.02750438f, 0.02767352f, 0.06381736f, -0.12341400f, -0.01572950f, 
    0.01543209f, -0.05234263f, -0.04305430f, -0.10479685f, 0.00628790f, 0.10936550f, -0.38459587f, -0.21903650f, 
    0.22436935f, 0.17433727f, 0.08876787f, 0.19920664f, 0.06697369f, -0.01300169f, -0.19110306f, -0.30949360f, 
    -0.40997687f, -0.01116249f, 0.10348585f, -0.18117334f, 0.00484445f, -0.29249072f, 0.09427206f, -0.08283043f, 
    -0.02794519f, -0.03915983f, 0.00883569f, -0.23309913f, -0.38504359f, 0.01646878f, 0.03478502f, 0.08317192f, 
    0.36542404f, -0.02056331f, 0.11246043f, 0.16497444f, 0.06117110f, 0.00798828f, -0.00086910f, 0.11777452f, 
    0.12404463f, 0.06055694f, 0.09731641f, 0.02249693f, 0.01026340f, -0.12124898f, 0.02450531f, -0.06308610f, 
    0.05636195f, 0.01717510f, 0.14709651f, 0.35208273f, -0.02417467f, 0.09181805f, -0.02731408f, 0.00838526f, 
    0.02322733f, 0.10666610f, 0.17040151f, -0.13157526f, -0.20102537f, -0.30561060f, 0.16410178f, 0.06534069f, 
    0.09292494f, 0.07325461f, -0.02687372f, -0.01500368f, 0.14713477f, 0.03193526f, 0.26304296f, -0.00849285f, 
    0.05591887f, 0.04691257f, -0.01637579f, 0.03347872f, 0.20462930f, -0.20798366f, -0.22216359f, -0.24009630f, 
    -0.16409560f, 0.00910636f, -0.03163717f, -0.07668079f, 0.04335006f, -0.09860700f, 0.20228232f, 0.01102474f, 
    -0.15033522f, 0.13474126f, 0.07504394f, 0.15666792f, -0.05974499f, -0.07274910f, 0.15909138f, 0.06862670f, 
    0.14906040f, -0.09661298f, -0.04507233f, -0.11520208f, -0.10577630f, 0.13956282f, 0.16712739f, -0.06415439f, 
    -0.01865883f, -0.00880190f, -0.07408772f, 0.02739431f, -0.06417304f, -0.31123996f, 0.14405341f, 0.18264486f, 
    0.15267423f, -0.12568496f, 0.01391038f, 0.26263902f, 0.11326945f, 0.07841636f, -0.15729447f, 0.25533947f, 
    -0.00153812f, -0.07746221f, 0.09078153f, -0.24984749f, 0.11249404f, -0.10375717f, 0.21486579f, 0.23649918f, 
    -0.05082229f, -0.04928493f, -0.20678347f, -0.20171316f, -0.06123505f, -0.03094347f, -0.07125299f, -0.00819787f, 
    -0.09936526f, 0.22213076f, -0.00240673f, -0.03402278f, -0.03116630f, -0.13821051f, -0.08949088f, 0.05821507f, 
    -0.07101940f, -0.04453597f, 0.09821477f, 0.09177582f, 0.02606105f, -0.16049187f, 0.03395506f, 0.07431974f, 
    0.09635469f, -0.00004952f, 0.09127887f, 0.16450711f, -0.07321638f, -0.13974965f, 0.16461641f, -0.12280681f, 
    0.07398300f, 0.27640700f, 0.05575794f, -0.20280214f, 0.23590834f, -0.19795607f, 0.14900932f, -0.03684096f, 
    0.00200437f, 0.16290313f, -0.04599954f, 0.15223426f, -0.03962800f, 0.04229049f, 0.09908961f, -0.06183500f, 
    -0.19820821f, -0.02211389f, -0.08703439f, 0.18705919f, -0.07295562f, 0.09908440f, -0.09655018f, 0.01504439f, 
    -0.16086406f, 0.02684336f, -0.14648634f, 0.02176613f, 0.01216008f, 0.10350647f, -0.05757244f, 0.05275492f, 
    -0.19851647f, -0.09652870f, -0.49521717f, -0.16923696f, 0.16014421f, 0.04548694f, 0.04227057f, 0.08878490f, 
    -0.03519379f, 0.03500457f, -0.19411497f, -0.01134746f, 0.02625102f, -0.06584129f, -0.03804178f, -0.06875809f, 
    -0.08102279f, 0.00337735f, 0.14470716f, 0.09693751f, 0.01519125f, -0.08325994f, -0.04835584f, 0.00265035f, 
    -0.00229851f, 0.22756235f, -0.14979666f, -0.24097562f, -0.26674417f, 0.11095873f, -0.13542734f, -0.04112661f, 
    -0.12581827f, 0.00852686f, 0.18693373f, -0.23084588f, -0.04882681f, -0.27355477f, 0.24533233f, -0.16684726f, 
    -0.31210101f, 0.19856693f, -0.02294712f, 0.12932594f, 0.18877977f, -0.02146524f, 0.17341840f, -0.05711995f, 
    -0.01568480f, 0.05903342f, 0.01058254f, -0.11935239f, 0.08015241f, -0.14924239f, 0.18561892f, 0.02188125f, 
    0.13062897f, -0.12340754f, 0.03249520f, -0.14215054f, 0.13612272f, 0.07576137f, -0.06391002f, -0.01532105f, 
    -0.22676079f, -0.29847503f, -0.23858775f, 0.11499954f, 0.10595958f, 0.08314672f, 0.00128894f, -0.18288821f, 
    0.20577729f, 0.09555017f, -0.13474078f, 0.00317854f, 0.01267921f, 0.12683223f, 0.26216063f, 0.11450451f, 
    -0.06819152f, 0.13744353f, -0.04260935f, -0.10963806f, -0.28238919f, -0.00786420f, -0.09110703f, 0.03194689f, 
    0.01350674f, -0.14656405f, 0.13611870f, -0.26531932f, 0.07859213f, -0.06895873f, -0.08501287f, 0.07239172f, 
    0.27084905f, 0.24259833f, 0.04944221f, 0.10205193f, 0.05895969f, 0.20191762f, -0.03037201f, 0.31625035f, 
    0.08011741f, -0.17101128f, 0.20494859f, 0.16303246f, 0.17599081f, -0.20376818f, -0.08952934f, -0.00232356f, 
    -0.06512312f, 0.01933031f, -0.07842880f, 0.20372005f, -0.37325871f, -0.02401508f, -0.16101553f, -0.02155298f, 
    -0.00077243f, -0.06999037f, -0.04730892f, 0.09403133f, 0.07284851f, -0.24679184f, -0.05318424f, 0.03624311f, 
    0.00249004f, 0.06231593f, 0.19919486f, 0.04067997f, 0.06312554f, -0.11157961f, 0.09618724f, 0.03342549f, 
    0.03817385f, 0.23725776f, 0.12350127f, -0.19009958f, 0.03542290f, 0.02079654f, 0.01795986f, 0.13053124f, 
    -0.12739643f, -0.06997067f, 0.09131709f, 0.18748234f, 0.14604738f, -0.00771408f, -0.06871737f, 0.07717484f, 
    0.03747908f, 0.22361378f, -0.07386006f, -0.14624205f, 0.08255690f, 0.50814140f, -0.03548733f, 0.00201291f, 
    0.11676579f, -0.17973728f, -0.00110280f, -0.03914078f, -0.12688595f, 0.14445817f, 0.30261964f, -0.00442751f, 
    0.15352495f, 0.07371522f, 0.04104656f, 0.11312358f, -0.05919546f, -0.26051146f, 0.14663869f, -0.05899547f, 
    -0.18050149f, 0.15439095f, -0.08246310f, 0.08074138f, 0.01526922f, 0.00889130f, -0.17929219f, -0.08996397f, 
    -0.08764441f, -0.09097061f, -0.27317631f, -0.36016411f, 0.09691890f, 0.28988802f, 0.03231781f, 0.02226560f, 
    -0.18552607f, -0.00083680f, 0.13887262f, 0.15589376f, -0.04776170f, 0.02996372f, -0.01405854f, -0.05311688f, 
    0.09824752f, 0.13413757f, 0.13941173f, 0.07822949f, -0.05875204f, 0.15922686f, -0.00175341f, -0.49325970f, 
    -0.52246463f, -0.15358119f, -0.44969779f, -0.15824445f, -0.35493755f, 0.02053917f, 0.14530247f, 0.02415896f, 
    -0.08838048f, 0.08521307f, -0.05103095f, -0.27742237f, -0.07633409f, 0.07492922f, -0.07403688f, -0.12904693f, 
    -0.01348058f, 0.06335299f, 0.37385616f, 0.02618516f, 0.00068243f, 0.09152683f, -0.02006152f, 0.06609663f, 
    0.08941865f, -0.05547565f, -0.21361430f, -0.09068647f, -0.32323679f, 0.19578084f, -0.06702159f, 0.22925493f, 
    0.04238842f, 0.03357716f, 0.03022088f, 0.12908867f, -0.19356845f, -0.17877711f, -0.20001164f, -0.26251733f, 
    -0.05306799f, 0.11518701f, 0.10114562f, 0.01918268f, 0.08834189f, 0.13043618f, -0.08871640f, 0.29029408f, 
    0.16770251f, 0.21024033f, -0.27127427f, -0.26474270f, -0.11365773f, 0.21092506f, 0.16626550f, -0.06587995f, 
    -0.29091063f, -0.32397026f, 0.02734045f, 0.00037751f, 0.06964851f, -0.02422839f, 0.00758322f, 0.13048813f, 
    -0.00996232f, -0.01581377f, 0.09845272f, 0.16799463f, 0.15211616f, 0.06661202f, -0.26038975f, -0.11414281f, 
    -0.04408057f, 0.07916743f, 0.10909276f, -0.30775145f, 0.29940051f, 0.20393938f, 0.19436941f, -0.06202270f, 
    0.11197526f, -0.01876217f, 0.33353233f, 0.34218609f, 0.31658480f, -0.17138855f, 0.03542038f, -0.01286944f, 
    -0.01141131f, 0.06586224f, -0.10049942f, -0.04131548f, 0.35326859f, -0.19929253f, 0.14386551f, -0.03261653f, 
    0.07719401f, -0.16005608f, -0.39861369f, -0.04936065f, 0.10976897f, -0.27131414f, -0.12119754f, 0.14621378f, 
    0.04059232f, -0.02127950f, 0.08998382f, 0.09733485f, 0.24200329f, 0.21455288f, -0.26911244f, -0.15102234f, 
    0.24532202f, 0.00756707f, -0.02851542f, -0.02316558f, 0.10182505f, 0.20683031f, -0.22286507f, 0.46895644f, 
    -0.08009472f, 0.05892399f, -0.01290309f, 0.27902761f, -0.05794093f, -0.05098106f, 0.18379585f, -0.08945049f, 
    0.31674135f, -0.42064539f, 0.22740023f, 0.17098805f, -0.07203086f, -0.15267137f, 0.03730640f, 0.12800008f, 
    -0.38928559f, -0.32765582f, 0.03488598f, 0.03603840f, 0.22053321f, -0.04738461f, -0.02944106f, 0.19874895f, 
    0.68098629f, 0.29335144f, 0.06422982f, -0.15420264f, -0.06817195f, -0.06887691f, -0.15970394f, -0.13442457f, 
    0.15452911f, 0.10749061f, -0.00103247f, -0.02570003f, -0.00641279f, 0.05221941f, 0.04939011f, 0.11324705f, 
    -0.40798876f, -0.16574119f, -0.05863480f, -0.17485130f, -0.19394557f, 0.06501151f, 0.09724287f, 0.04249865f, 
    0.13681172f, 0.13826752f, 0.04753987f, 0.35878989f, -0.13580769f, -0.15395662f, 0.02875911f, 0.04680157f, 
    0.01429122f, -0.00429563f, -0.33706698f, -0.08471344f, 0.24476442f, -0.03220774f, 0.02588962f, -0.22102186f, 
    -0.23242919f, 0.13015988f, -0.08986235f, -0.05036888f, -0.26579186f, 0.10715326f, -0.29337719f, -0.13347666f, 
    -0.24534467f, 0.16043960f, 0.05249080f, 0.05718444f, 0.12554075f, 0.19875345f, 0.25636026f, -0.08544832f, 
    -0.04879810f, -0.24502182f, 0.27791193f, 0.31829515f, -0.06326324f, 0.11321200f, 0.12663552f, 0.17044117f, 
    -0.24851902f, -0.18643939f, -0.22212845f, 0.08237927f, 0.03125397f, 0.09706195f, 0.12956038f, -0.04839382f, 
    0.02918495f, -0.08112510f, -0.09044159f, -0.15887688f, 0.21667314f, 0.25825307f, 0.05992403f, 0.07105920f, 
    0.11903112f, 0.06289496f, -0.33903900f, -0.06640109f, -0.13136946f, -0.05417380f, -0.06606220f, 0.16473728f, 
    0.03944682f, 0.00971241f, 0.16315848f, 0.09539645f, 0.04939790f, 0.04460320f, 0.02278431f, 0.17424138f, 
    0.22181372f, 0.01273942f, -0.03437407f, 0.11188127f, -0.12513649f, 0.00978216f, -0.37914240f, 0.04289205f, 
    0.16822380f, 0.20061232f, 0.11453281f, 0.05871832f, 0.02934125f, -0.17448995f, -0.06547592f, -0.02620688f, 
    0.37105885f, 0.11578234f, -0.14695752f, 0.14213200f, -0.18356220f, 0.13459243f, 0.31795880f, 0.29182744f, 
    -0.06867287f, -0.19141479f, -0.10183670f, 0.04261433f, -0.36749992f, -0.62873858f, -0.25499079f, 0.30396581f, 
    0.08901631f, 0.01456280f, 0.28431326f, -0.01583801f, 0.11319380f, -0.18024735f, -0.01966342f, -0.07028434f, 
    0.03321813f, 0.06374089f, -0.11469384f, 0.03689267f, -0.11121277f, -0.29754540f, -0.06863021f, -0.28193647f, 
    -0.21850497f, 0.17276928f, -0.24910644f, -0.14741310f, 0.02754925f, -0.11221617f, -0.32277256f, -0.03277001f, 
    0.05998261f, -0.07306340f, 0.06284293f, 0.13756523f, -0.25121328f, 0.04326772f, 0.13926537f, -0.03560320f, 
    0.10833420f, -0.04950858f, 0.07755048f, 0.07589573f, -0.12477622f, -0.04271602f, 0.05354548f, -0.05024051f, 
    -0.03982132f, -0.12304801f, 0.01228367f, -0.09368953f, -0.47156623f, 0.43507889f, 0.33940756f, 0.01954461f, 
    -0.02056948f, -0.19246249f, -0.27332193f, 0.12367996f, 0.02926430f, 0.19453952f, -0.02848590f, 0.37143189f, 
    0.09223787f, 0.06102846f, -0.10656468f, 0.13738905f, 0.06059029f, -0.22510637f, -0.59742689f, -0.01266351f, 
    0.05922124f, -0.19286725f, -0.03621882f, -0.13376908f, -0.06502406f, -0.04632816f, 0.04963065f, 0.36769095f, 
    -0.14700717f, 0.11504078f, 0.05590918f, 0.01468711f, -0.07533863f, 0.05703168f, 0.14174540f, -0.10152733f, 
    -0.15914157f, -0.16736445f, 0.13592146f, 0.09631938f, -0.01052867f, 0.02439725f, -0.29430708f, -0.10386820f, 
    -0.34755749f, -0.01543723f, 0.01806195f, -0.00585336f, 0.04085448f, 0.12484577f, 0.01824945f, 0.06075408f, 
    0.08882938f, 0.16441445f, -0.45369437f, -0.15010609f, -0.57333124f, -0.01343777f, -0.28612599f, 0.04134782f, 
    0.04327355f, 0.04206090f, -0.05077487f, -0.06772276f, 0.27948505f, 0.08633980f, -0.13175689f, -0.07092526f, 
    -0.06796387f, -0.18177465f, 0.12940550f, -0.11102119f, 0.04717772f, 0.07052386f, 0.01482241f, 0.00518628f, 
    0.10442919f, 0.00367948f, 0.26089799f, 0.04157571f, 0.03597983f, -0.00268267f, 0.08191893f, -0.02332081f, 
    -0.07097855f, 0.14911669f, -0.00756662f, 0.14732535f, 0.10766613f, 0.02596101f, -0.05782575f, -0.30849010f, 
    -0.47088584f, 0.13057949f, -0.21522848f, -0.02053264f, -0.03937487f, -0.30382043f, 0.01745980f, -0.36074266f, 
    -0.01857780f, 0.22718664f, -0.21680667f, -0.05929114f, 0.20011511f, 0.16831359f, 0.16719067f, 0.17209397f, 
    -0.02475727f, -0.04828027f, 0.25234452f, 0.07626560f, -0.03039429f, 0.27188963f, 0.19611932f, -0.19238593f, 
    0.45194247f, 0.11082184f, -0.37034556f, -0.05871359f, 0.21322386f, -0.10644648f, 0.31744671f, 0.17214251f, 
    0.11932412f, 0.07992783f, 0.20154519f, 0.13289608f, -0.01022198f, 0.01385611f, -0.03255058f, -0.18590188f, 
    -0.05545799f, -0.01621545f, -0.12356876f, 0.09638999f, -0.14011675f, -0.10499225f, 0.02135260f, 0.08005507f, 
    -0.16316143f, -0.01906112f, -0.09189310f, -0.19400924f, 0.08093152f, 0.12850952f, 0.19076183f, -0.03483990f, 
    0.04554927f, -0.10595298f, 0.11288029f, 0.11523496f, 0.02222149f, 0.22976722f, -0.52272522f, 0.05463791f, 
    -0.04302727f, -0.09795126f, -0.00749593f, 0.08581702f, 0.18857409f, -0.10315783f, -0.28182247f, 0.28655767f, 
    0.08452069f, 0.07378339f, 0.23833077f, 0.02167315f, -0.09043606f, 0.06449981f, 0.21651387f, 0.01071549f, 
    0.25547296f, 0.42594513f, -0.02182186f, 0.09351527f, 0.07261951f, -0.09481999f, 0.14943030f, 0.19480664f, 
    0.74233407f, 0.03169170f, -0.01968406f, 0.05637725f, 0.12692297f, 0.03466043f, 0.07117681f, 0.03107324f, 
    -0.26507023f, -0.05594147f, -0.23828234f, -0.05938930f, 0.27626860f, -0.22711670f, -0.08678132f, 0.11169115f, 
    0.19609216f, 0.00383843f, 0.47822872f, 0.01156619f, -0.16771524f, -0.05056881f, -0.02139319f, 0.06906135f, 
    0.08767591f, -0.04361580f, -0.17672494f, -0.62722290f, -0.44927827f, -0.00024517f, 0.09509819f, 0.16517664f, 
    0.14348154f, 0.08396608f, 0.09947156f, 0.08834099f, 0.44835827f, 0.14615391f, 0.27200711f, 0.12243288f, 
    0.17005908f, 0.03746539f, 0.05547948f, 0.19556142f, 0.01816070f, -0.63986444f, 0.19535352f, 0.31025302f, 
    -0.05173298f, 0.12465344f, -0.21262079f, -0.36432567f, 0.02595970f, 0.03125351f, 0.09347919f, -0.22167647f, 
    -0.36696064f, -0.22909868f, -0.02578983f, -0.31710255f, -0.20312713f, -0.03592652f, -0.26285428f, -0.13983223f, 
    -0.19006449f, -0.25121889f, 0.02582174f, -0.14701015f, 0.14862080f, -0.01921317f, 0.00068740f, 0.12958705f, 
    0.11734866f, -0.09411482f, -0.06421416f, 0.07609656f, -0.32769799f, 0.03742962f, 0.08995330f, -0.09645988f, 
    -0.12477849f, -0.06932714f, 0.33553946f, -0.33279908f, 0.06739982f, 0.18251401f, -0.06778855f, 0.10168301f, 
    0.07984568f, -0.25939724f, -0.09736567f, 0.21383607f, -0.00323521f, -0.14175220f, 0.01303187f, 0.15251251f, 
    -0.05960080f, 0.20571689f, -0.18439800f, 0.06608111f, 0.11431449f, -0.19161449f, 0.12955579f, 0.24963862f, 
    -0.24101962f, 0.14461124f, -0.10388310f, -0.16014144f, 0.03167628f, -0.12172193f, -0.18795119f, 0.12653862f, 
    -0.09921411f, 0.06999801f, 0.03447717f, -0.05371129f, -0.12352456f, -0.09749559f, 0.27097204f, -0.08316283f, 
    0.02553199f, -0.03041193f, -0.08302226f, -0.01002417f, -0.05775253f, 0.07578573f, 0.17265244f, 0.17605835f, 
    -0.15016289f, 0.05505554f, 0.20228112f, 0.00456893f, -0.02078580f, 0.22571410f, 0.05607980f, 0.05243699f, 
    0.04638562f, 0.00047343f, 0.00963483f, 0.07378617f, -0.03852190f, -0.01588109f, 0.26797616f, -0.23220767f, 
    -0.10550670f, 0.04047247f, -0.22965357f, 0.16885194f, -0.10368093f, 0.12928835f, -0.07388936f, 0.01315418f, 
    -0.05274739f, -0.08918879f, -0.37152687f, -0.25474834f, 0.03749149f, -0.03328934f, 0.11961046f, 0.05085652f, 
    -0.27753073f, 0.06340124f, 0.06143537f, 0.25384274f, -0.10020807f, 0.17729038f, 0.04968847f, -0.04191944f, 
    0.09757417f, -0.05349603f, 0.23995093f, -0.01363177f, -0.15330993f, 0.04464387f, 0.02350109f, -0.17039721f, 
    -0.09219602f, 0.15605448f, -0.10423041f, -0.03130001f, -0.03309184f, -0.07105574f, -0.02212238f, 0.13073701f, 
    -0.17610726f, 0.18867946f, 0.14748135f, 0.12098926f, -0.10543212f, -0.02072268f, -0.02974225f, 0.03539192f, 
    -0.09092733f, -0.22789411f, 0.16296367f, 0.00330104f, 0.17295121f, -0.28176811f, -0.16007009f, 0.14112258f, 
    0.35844678f, 0.13694248f, 0.26948991f, 0.02819691f, 0.06006930f, -0.04428675f, 0.09025897f, -0.02329041f, 
    -0.00837985f, -0.54547173f, 0.01708958f, -0.13941717f, 0.15777798f, -0.07434648f, -0.25254548f, 0.10533021f, 
    -0.04190685f, -0.20788145f, 0.12796591f, 0.01932665f, 0.17596209f, 0.10172524f, -0.23125435f, 0.37830603f, 
    -0.00302910f, -0.20894258f, 0.09019341f, -0.12039205f, -0.12461444f, 0.06842141f, 0.07894647f, -0.20266570f, 
    0.11548264f, -0.28758645f, -0.01584136f, -0.15097827f, 0.02547948f, -0.16544828f, 0.07292733f, 0.21229397f, 
    0.09912126f, 0.03042064f, 0.09951481f, -0.15810096f, 0.15497516f, 0.06441948f, 0.11066442f, 0.16358098f, 
    0.01325611f, 0.09837090f, 0.00302933f, -0.10323738f, -0.07416964f, -0.01145080f, -0.03650863f, -0.03222109f, 
    0.02936715f, 0.13929132f, -0.05491975f, 0.09892304f, -0.00851449f, 0.15129782f, 0.67151105f, 0.29015687f, 
    0.09456931f, 0.29055843f, -0.08378907f, -0.05956437f, 0.27340224f, -0.08433820f, 0.15584458f, 0.06830511f, 
    -0.09061962f, -0.06567863f, -0.12896970f, 0.38549691f, -0.13569953f, 0.06502380f, 0.04758416f, 0.25103313f, 
    -0.31301174f, -0.35986269f, -0.03181434f, -0.07869300f, 0.08785640f, -0.10692718f, -0.01623806f, 0.03987113f, 
    -0.03533727f, -0.16070211f, 0.29250601f, -0.00764599f, 0.10756635f, -0.22060923f, -0.06464283f, 0.09127004f, 
    0.06365259f, -0.17564745f, -0.04605518f, -0.29733479f, -0.10233197f, 0.24813314f, -0.09809837f, -0.13105595f, 
    -0.24250236f, -0.10495401f, -0.13773324f, 0.39576724f, 0.77243108f, 0.11400099f, -0.00645200f, -0.09778819f, 
    -0.18912128f, -0.28378564f, 0.25788254f, -0.28972566f, 0.09955591f, 0.29870704f, 0.03343650f, -0.05344650f, 
    0.18232544f, 0.10814060f, 0.33804289f, 0.25454783f, -0.01337799f, -0.05695145f, 0.22054525f, 0.03002257f, 
    -0.02363408f, -0.14492802f, -0.00535029f, -0.17488000f, -0.18338101f, -0.05446341f, 0.01023663f, -0.09552448f, 
    0.04901179f, 0.10587716f, -0.00684629f, -0.01435325f, 0.02448098f, 0.06421876f, 0.04145258f, 0.09210326f, 
    0.24478713f, -0.10143234f, 0.20194054f, -0.12552391f, 0.11542885f, 0.14413971f, 0.01308140f, 0.13529179f, 
    -0.40559915f, -0.07100782f, 0.01385733f, 0.07372525f, 0.12368750f, 0.10951651f, -0.28797489f, 0.10138306f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.25504792f, 0.32728040f, -0.07973564f, 0.03030779f, -0.02045188f, 0.22905976f, 0.06572320f, 0.10104067f, 
    0.20996054f, -0.09197637f, 0.03263301f, -0.03914240f, 0.31297871f, 0.36100411f, 0.35825220f, 0.14226544f, 
    0.00629563f, 0.03079824f, 0.17411844f, 0.10665656f, 0.03576234f, 0.19689474f, 0.01256607f, -0.19285063f, 
    0.29975232f, -0.05907383f, -0.01475543f, 0.27673930f, 0.13154833f, -0.11541118f, 0.21855681f, -0.01997214f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.11021149f, -0.17812444f, 0.23015325f, 0.72538984f, 0.23508276f, -0.78286338f, -0.22679853f, 0.36029381f, 
    -0.02757189f, 0.29371855f, -0.10690150f, 0.38029891f, -0.81111252f, -0.04487554f, 0.06509065f, 0.03119279f, 
    0.02569574f, -0.35018840f, -0.26404616f, -0.18279016f, -0.03396356f, -0.51235843f, -0.05718056f, 0.03994378f, 
    -0.27381241f, -0.03828475f, -0.01828741f, -0.13007209f, -0.21415907f, 0.13307373f, -0.03623872f, -0.11802267f, 
    -0.54925138f, 0.22088993f, 0.07807694f, 0.36461419f, -0.18045658f, -0.20084816f, 0.01524434f, -0.15680739f, 
    -0.18998571f, 0.08651084f, 0.07812028f, 0.30064660f, 0.23803474f, -0.05228595f, 0.31801537f, 0.15069391f, 
    -0.17841440f, -0.41992971f, 0.26097384f, 0.24789900f, -0.00865675f, 0.28876156f, -0.10157678f, -0.29431030f, 
    0.25515428f, -0.14428370f, -0.13997301f, 0.29138988f, -0.16735822f, -0.12513866f, -0.02825508f, -0.47052479f, 
    0.41928455f, 0.29011735f, -0.21169646f, -0.91091245f, 0.11916566f, 0.28097567f, -0.39936745f, 0.09817536f, 
    0.10061184f, -0.15471369f, 0.23949160f, -0.29967433f, 0.64382815f, -0.18254311f, 0.06347075f, -0.72637105f, 
    0.28395513f, -0.47560766f, -0.38208893f, 0.02325505f, -0.29877731f, 0.09312247f, 0.01129448f, -0.04811915f, 
    -0.00122319f, -0.00971094f, -0.15592895f, -0.12078641f, 0.04518626f, 0.20538570f, 0.07072966f, -0.37908408f, 
    -0.20594731f, -0.37696627f, 0.24874209f, -0.26003993f, -0.21449095f, 0.11086103f, -0.36163807f, 0.22272405f, 
    0.41992271f, 0.59070754f, -0.71212721f, -0.58684510f, 0.07617251f, -0.31213251f, -0.74877942f, -0.59862775f, 
    0.15058571f, 0.49921063f, -0.70283860f, -0.62998235f, 0.01394206f, 0.24851201f, -0.13616480f, 0.52309239f, 
    0.37770897f, -0.05221650f, -0.08873550f, -0.23505725f, -0.20529985f, 0.13080965f, -1.18017948f, -0.18000200f, 
    -0.09906164f, -0.27975252f, 0.10255767f, -0.01412474f, 0.68215036f, -0.84370470f, 0.03423300f, -0.25458756f, 
    -0.52193058f, -0.27647656f, -0.09258202f, -0.22665821f, -0.11695503f, 0.12285339f, 0.02811235f, -0.30285889f, 
    0.24918832f, -0.03247377f, 0.20733826f, -0.18519384f, -0.00411106f, 0.19499941f, -0.16668852f, 0.12007549f, 
    0.38381046f, -0.08611079f, 0.03956997f, -0.25663888f, -0.41588038f, 0.00482759f, -0.01719948f, 0.31955552f, 
    0.63582444f, 0.26458281f, 0.18361101f, 0.20126046f, -0.09262675f, -0.53519118f, 0.14497247f, 0.10127451f, 
    0.14233515f, -0.21960475f, -0.27351984f, -0.39765972f, 0.11142518f, -0.20769876f, 0.07633252f, 0.15728433f, 
    -0.01348243f, -0.47449535f, 0.45208213f, -0.06685364f, -0.37159643f, -0.26559547f, 0.01143690f, -0.24000835f, 
    0.07719395f, 0.10387469f, -0.13522576f, -0.25366786f, 0.35468018f, 0.20113117f, -0.23126735f, 0.25822759f, 
    -0.12082390f, -0.14928122f, -0.32868388f, -0.69581306f, -0.63451606f, 0.53770483f, -0.26408112f, -0.03893182f, 
    -0.35956156f, -0.43214065f, 0.14159302f, -0.05281425f, 0.08519173f, 0.66231936f, -0.44520113f, -0.49682504f, 
    0.16419759f, 0.04070617f, -0.37731573f, 0.41035032f, 0.32743669f, -0.40976566f, -0.11614662f, 0.05591603f, 
    -0.05257905f, 0.01995007f, -0.09180462f, -0.12822752f, 0.01817222f, -0.09351306f, 0.44827113f, 0.02556518f, 
    0.38999975f, -0.25106335f, -0.12089045f, -0.16000287f, 0.11196595f, 0.08252753f, 0.43667525f, -0.31120351f, 
    -0.34818727f, 0.36341462f, 0.05714500f, -0.22993642f, -0.26688620f, -0.37404686f, -0.41841722f, 0.36548910f, 
    -0.16346166f, 0.00574073f, -0.19463298f, 0.11170879f, 0.34457678f, -0.17916904f, 0.06450007f, 0.10519206f, 
    -0.04975739f, -0.01209309f, -0.11807387f, 0.11965337f, -0.28640726f, -0.15246144f, -0.17457855f, 0.08530931f, 
    -0.00790370f, 0.13048619f, 0.28474575f, -0.47986242f, -0.25085858f, 0.65084517f, 0.47090355f, 0.82102168f, 
    0.07314891f, -0.04322021f, -0.29185396f, -0.05583848f, -0.07879297f, -0.07929365f, 0.11085823f, -0.18465461f, 
    -0.24006200f, 0.34727857f, 0.30425832f, 0.20526348f, -0.37415749f, -0.20784441f, -0.10479888f, -0.30336711f, 
    -0.15052037f, 0.07150342f, -0.08836983f, -0.01172305f, 0.51546967f, -0.73826534f, -0.32965469f, -0.14505680f, 
    0.27693012f, -0.08987304f, -0.38802999f, -0.09926659f, -0.02216644f, -0.50610119f, -0.52292651f, -0.08209230f, 
    0.30932853f, 0.05068636f, -0.44443652f, -0.28620642f, -0.01960621f, 1.01311636f, 0.08617944f, 0.55203378f, 
    0.20856608f, 0.37554851f, -0.19538891f, -0.55080974f, 0.03165119f, -0.01924697f, -0.10635258f, 0.23256667f, 
    0.14087819f, 0.10795003f, 0.14332235f, -0.03163993f, -0.22291034f, -0.25510204f, 0.11036928f, 0.02531084f, 
    -0.12582432f, 0.34745851f, 0.02160539f, -0.47762808f, 0.02849487f, -0.05717307f, -0.02188306f, -0.63978207f, 
    0.30277777f, -0.41453627f, -0.22547145f, 0.64498979f, -0.44616437f, -0.24448855f, -0.50709426f, -0.93548238f, 
    -0.00245197f, 0.04759676f, 0.43438494f, -0.13819312f, 0.13171324f, 0.59458250f, 0.16159590f, -0.25002521f, 
    -0.08516966f, 0.11458384f, -0.06868625f, -0.09575758f, -0.22457871f, -0.31549212f, -0.37648413f, 0.77361733f, 
    -0.72675371f, 0.11244906f, 0.08219613f, -0.52862340f, 0.04476485f, 0.28147656f, -0.17400150f, -0.72238356f, 
    0.59887838f, -0.44722435f, 0.52677464f, 0.32486358f, -0.17271961f, -0.83877069f, -0.10561733f, 0.33830002f, 
    0.24035504f, 0.16178747f, -0.84301245f, -0.13656555f, -0.06415278f, 0.05875075f, -0.11318000f, 0.00933594f, 
    -0.34968272f, -0.14068751f, -0.16273382f, 0.53059345f, 0.18586291f, -0.29079947f, 0.26788330f, 0.07057578f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.25159109f, 0.23807298f, 0.04790184f, 0.03589120f, 0.06006760f, 0.21266952f, -0.30052313f, -0.29846528f, 
    -0.25613636f, 0.19524741f, -0.01263791f, 0.14376503f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
