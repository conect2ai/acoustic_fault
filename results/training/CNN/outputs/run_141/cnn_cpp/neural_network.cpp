#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.43185866f, -0.64437091f, -0.07676429f, 0.47700560f, 0.18915239f, -0.48099914f, 0.67378676f, 0.23913410f, 
    -0.42879391f, 0.29374495f, 0.30192244f, 0.27036312f, 0.22358181f, 0.19665277f, 0.19787638f, 0.18203607f, 
    0.24976334f, 0.01821764f, 0.32457516f, -0.11087172f, 0.00654237f, -0.02287318f, -0.03875788f, 0.15910037f, 
    -0.17499331f, 0.52699161f, 0.13445978f, 0.38215029f, 0.43449780f, 0.31852886f, 0.48183522f, 0.48246297f, 
    0.37651321f, -0.05533987f, 0.18499725f, -0.49568057f, -0.12306326f, -0.26169163f, 0.15648103f, 0.04957210f, 
    -0.21203041f, -0.18121110f, -0.04977334f, 0.06599730f, 0.04086759f, -0.04259208f, 0.04483638f, -0.17999622f, 
    0.05334048f, 0.07599116f, -0.19882962f, -0.15316316f, -0.22148544f, -0.77064562f, -0.16473000f, -0.19091409f, 
    0.01716796f, 0.00109531f, 0.58643454f, -0.33658978f, -0.37799406f, 0.02429426f, -0.18884316f, -0.15413766f, 
    -0.16076033f, -0.00300463f, -0.13158268f, -0.21193403f, -0.14302239f, -0.03661428f, -0.02469688f, -0.25812644f, 
    -0.16583240f, -0.21860321f, 0.05435198f, 0.79233378f, 0.27145511f, -0.29357457f, 0.46814072f, 0.54586560f, 
    0.30573803f, -0.40857512f, -0.01732639f, -0.08180821f, 0.07572979f, -0.11622855f, -0.04130011f, -0.26840591f, 
    0.01793055f, -0.05334393f, 0.14429778f, -0.13589676f, -0.05324349f, 0.10304908f, 0.13840148f, 0.32379237f, 
    0.08638471f, 0.18877152f, -0.33739749f, 0.08134957f, 0.04575060f, -0.46906224f, -0.72885680f, -0.57392848f, 
    -0.39924738f, 0.31845978f, 0.56874853f, 0.17386524f, -0.06254588f, 0.20155522f, -0.11041044f, 0.17595877f, 
    -0.28769198f, 0.10815936f, 0.07498849f, 0.01596384f, 0.15116157f, 0.26346454f, 0.05536159f, -0.02450594f, 
    0.01538821f, -0.07721844f, 0.01871002f, -0.29014531f, 0.13734387f, -0.74619818f, -0.03986018f, -0.27168781f, 
    -0.00383522f, -0.65008479f, 0.59103215f, 0.48380473f, -0.36222437f, 0.37569615f, 0.08775029f, -0.11773613f, 
    -0.16217768f, 0.15524781f, -0.06352467f, 0.04159070f, -0.09323281f, 0.04010849f, -0.00746239f, -0.01152786f, 
    -0.05234439f, 0.00715846f, -0.02344597f, -0.08699803f, 0.07762741f, -0.00604581f, 0.62658989f, 0.46287593f, 
    0.57116008f, 0.69719744f, 0.37851426f, -0.41574019f, 0.15372999f, -0.29789087f, 0.06892060f, 0.32172495f, 
    0.25887334f, 0.05639017f, 0.01895342f, 0.21057466f, -0.17679064f, -0.08257461f, 0.09505757f, 0.28577921f, 
    -0.08566276f, -0.26890042f, -0.13359950f, -0.07115879f, 0.04287649f, -0.14624648f, -0.10131133f, 0.72315812f, 
    0.45272258f, -0.11341032f, -0.71540290f, -0.58183247f, -0.07604705f, -0.25344643f, -0.17259492f, -0.21342137f, 
    0.09068520f, 0.08480123f, 0.13661313f, -0.04915405f, 0.04272792f, -0.05442161f, -0.01810823f, 0.04323515f, 
    -0.40149537f, -0.08692323f, 0.04277547f, -0.08251403f, -0.08659004f, 0.21245746f, -0.06411890f, 0.14261043f, 
    -0.98297930f, 0.26063654f, -0.33927369f, -0.15810615f, 0.37290135f, -0.10764004f, 0.53008038f, 0.24059115f, 
    -0.08615345f, -0.12417337f, -0.15049848f, -0.16759607f, 0.22521539f, -0.03388035f, 0.09328233f, -0.06077265f, 
    -0.31242740f, -0.11051487f, 0.02268113f, -0.00060877f, 0.10597654f, 0.08928563f, 0.11779920f, 0.17380597f, 
    0.09662602f, 1.01828623f, 0.00446793f, -0.11336480f, -0.45617238f, 0.25370729f, -0.12472404f, -0.17652285f, 
    0.50341821f, 0.34622407f, -0.11832613f, -0.36511779f, -0.10375366f, 0.23073685f, -0.29328185f, -0.20034039f, 
    -0.15221383f, -0.03743790f, 0.07888258f, 0.03169893f, -0.12049153f, -0.02352322f, 0.00137332f, -0.01068265f, 
    -0.01955935f, -0.05310546f, -0.26600567f, -0.34635475f, -0.42649117f, -0.41740444f, -0.15768898f, -0.37740102f, 
    -0.51780683f, -0.50580686f, -0.06947910f, 0.32284898f, 0.28802618f, -0.12232906f, 0.17074472f, -0.08639681f, 
    -0.15731792f, -0.13784637f, 0.15252602f, 0.08742273f, 0.19303076f, 0.17355144f, -0.08765475f, -0.16122121f, 
    -0.02839883f, 0.14357632f, -0.03725131f, -0.47642952f, 0.37277120f, 0.67435169f, -0.60708672f, -0.53607649f, 
    0.02776548f, -0.04416766f, -0.21990158f, -0.17743331f, -0.21478999f, -0.03388196f, 0.38111767f, -0.23768702f, 
    -0.03765733f, -0.02052404f, -0.09436637f, 0.06214019f, -0.13594694f, -0.00836063f, -0.06755540f, 0.21631922f, 
    0.26145032f, 0.10423954f, 0.18603204f, -0.00836154f, -0.39494216f, 0.07085919f, -0.33283180f, -0.06849321f, 
    0.08821528f, 0.02417940f, 0.44220990f, 0.38768134f, 0.45900539f, 0.54869473f, -0.22354823f, -0.21786487f, 
    0.27437583f, -0.36967450f, -0.31267557f, -0.04362722f, -0.03021268f, 0.11839962f, -0.14475642f, -0.38460797f, 
    -0.12551625f, -0.02546976f, -0.35571867f, -0.10503444f, -0.05628067f, 0.54700297f, 0.47589892f, 0.48041490f, 
    0.56993437f, 0.44502330f, 0.12465925f, 0.23906344f, -0.42543572f, 0.43367806f, -0.18059938f, -0.11804124f, 
    0.13749537f, 0.01380356f, 0.00366186f, 0.13203596f, -0.09055550f, -0.02377931f, 0.16663080f, -0.28915372f, 
    0.17576653f, 0.03591400f, 0.07476565f, 0.00259095f, 0.02237175f, 0.04580673f, -0.40336516f, 0.42845681f, 
    0.41286772f, 0.24862008f, 0.38384783f, 0.28903550f, -0.66551530f, -0.78312713f, -0.37864223f, -0.43986452f, 
    0.16358101f, -0.12147109f, 0.26556244f, 0.29773757f, -0.12820967f, 0.00320648f, 0.08646492f, 0.13176893f, 
    0.06744101f, 0.14313985f, -0.04724013f, -0.06709357f, 0.05325285f, -0.00401429f, 0.04797399f, -0.62455863f, 
    0.77749354f, -0.46134010f, -0.05300834f, -0.01322183f, 0.17807005f, -0.22127806f, -0.49026918f, 0.05966696f, 
    -0.06842476f, -0.19468135f, -0.12986429f, -0.19145693f, 0.15436244f, -0.06164364f, 0.01401869f, 0.20038392f, 
    0.04763628f, -0.20336573f, -0.32851326f, 0.03434757f, 0.21448661f, 0.23973796f, -0.12749436f, -0.05741967f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.21200985f, 0.09012802f, 0.08120682f, -0.09982194f, -0.05725021f, -0.11398108f, 0.17191154f, 0.01109633f, 
    0.21614891f, 0.08978011f, 0.04318276f, 0.00317038f, 0.13629106f, -0.06964648f, 0.08084584f, 0.00872505f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.06596452f, -0.04141859f, -0.05666834f, -0.04983078f, 0.04693227f, -0.02448667f, 0.00856617f, 0.00424874f, 
    -0.03047969f, -0.02597760f, -0.06292915f, 0.00873465f, 0.02135249f, -0.02847959f, 0.00415874f, 0.02233178f, 
    -0.01509997f, -0.04977396f, 0.02274104f, -0.04856030f, 0.00176999f, -0.04160955f, 0.01296840f, -0.04604282f, 
    -0.06456028f, -0.02963488f, -0.02703153f, -0.00565267f, -0.00186519f, 0.01217322f, 0.01465682f, 0.01943731f, 
    0.05564925f, 0.05169186f, 0.01049140f, 0.01935657f, -0.05539748f, -0.04244723f, -0.06937157f, 0.06177672f, 
    -0.02900577f, -0.05456887f, -0.02878551f, -0.02959918f, -0.01059503f, -0.00216864f, -0.02566574f, -0.00087685f, 
    -0.01386592f, -0.03384642f, -0.03806287f, -0.02333955f, 0.00269214f, 0.04440460f, 0.04875142f, 0.05017175f, 
    0.05464198f, -0.07063355f, -0.00437217f, -0.01664232f, 0.00253804f, -0.03200208f, -0.03582185f, -0.05492928f, 
    0.00640125f, 0.02569682f, -0.00433933f, -0.05636987f, 0.00455973f, 0.03074948f, -0.04943909f, -0.04398661f, 
    0.06861709f, -0.05401992f, -0.04184271f, -0.00927526f, 0.04939595f, 0.01278601f, 0.03100767f, 0.04712379f, 
    0.06567597f, -0.04849003f, -0.03892937f, 0.06870358f, -0.04599452f, -0.01838770f, -0.05927115f, -0.02002475f, 
    -0.04513287f, 0.06091771f, 0.01360618f, -0.05911436f, -0.03625502f, 0.06725018f, -0.01037455f, 0.06529423f, 
    -0.05195691f, 0.03355557f, 0.01307478f, -0.04723053f, 0.02864432f, -0.05647554f, 0.04972729f, 0.01644199f, 
    -0.03462584f, -0.03839630f, 0.04034088f, -0.05063349f, -0.06871891f, -0.03519756f, -0.06723794f, -0.02279011f, 
    -0.05723725f, 0.06603844f, 0.06175651f, -0.07109274f, 0.06767866f, -0.05308129f, 0.02487579f, -0.05317999f, 
    0.03459084f, -0.04337053f, 0.01573689f, 0.04756038f, 0.04858777f, -0.02160391f, -0.01164518f, -0.04445387f, 
    -0.03166898f, -0.05271591f, -0.00597936f, 0.05227717f, -0.03676395f, 0.01848328f, -0.01213105f, -0.04300018f, 
    0.00841166f, -0.02350077f, -0.03982582f, -0.05190876f, 0.05988649f, -0.00772563f, 0.05575829f, 0.02468004f, 
    0.01055054f, -0.03354693f, 0.04658960f, -0.03861748f, -0.04662645f, -0.06610840f, -0.01378530f, -0.02772870f, 
    0.03221744f, 0.02902613f, -0.02447377f, -0.04684472f, -0.04363976f, 0.05502709f, 0.04390846f, 0.03964627f, 
    0.00999596f, -0.06710755f, -0.07158790f, 0.02687518f, -0.02478440f, 0.01701535f, -0.06721322f, 0.03158132f, 
    0.01913544f, -0.02590449f, -0.02348259f, 0.04545368f, 0.06461996f, -0.04939712f, 0.01522923f, 0.06840257f, 
    -0.05962487f, -0.01873665f, -0.06854252f, -0.02235914f, 0.05131323f, -0.02286180f, -0.05063382f, 0.05489077f, 
    0.00960290f, -0.06695657f, -0.02846465f, 0.05454287f, -0.01768839f, -0.04245093f, -0.00687744f, -0.03976835f, 
    0.04829337f, 0.18240896f, -0.00262704f, 0.11519599f, -0.03295122f, 0.00803945f, 0.06699920f, 0.01982682f, 
    -0.03341948f, -0.02323791f, -0.02699617f, 0.00278718f, -0.09297168f, -0.22829930f, -0.11841593f, -0.15624641f, 
    -0.00137346f, -0.07918536f, -0.06706049f, -0.05553097f, 0.01889277f, -0.01965457f, 0.10194226f, 0.10768478f, 
    -0.00516433f, 0.14181028f, 0.11524408f, 0.00216532f, -0.00388297f, 0.01718344f, 0.04926414f, 0.14483054f, 
    0.07430387f, -0.02750918f, -0.03851986f, 0.13684662f, 0.13818765f, 0.00754615f, -0.18034264f, 0.31459314f, 
    0.11328467f, 0.00501140f, -0.14803827f, -0.07707378f, 0.03980033f, 0.05240942f, 0.02799362f, 0.06227193f, 
    0.17252667f, -0.07406656f, 0.09979373f, 0.20083322f, -0.18061450f, 0.06972010f, 0.12609346f, -0.05449983f, 
    -0.14437039f, 0.03228349f, 0.01561361f, -0.06759292f, 0.24636899f, -0.04220090f, -0.04244182f, -0.04165158f, 
    -0.13672999f, -0.07366611f, 0.05858183f, 0.09934075f, -0.08389531f, -0.08328346f, -0.11000470f, 0.00319099f, 
    -0.05387868f, -0.14127477f, -0.21117385f, 0.05644108f, 0.18235828f, 0.07964972f, -0.01199660f, -0.05446199f, 
    -0.03660948f, -0.03998827f, 0.06920724f, -0.02308906f, -0.01026092f, -0.19789170f, 0.06640830f, -0.11147787f, 
    -0.04625141f, 0.06691606f, 0.00380111f, 0.00953750f, 0.08512280f, 0.10829098f, 0.09116746f, 0.19575422f, 
    0.04759328f, 0.26211351f, 0.04465684f, -0.02325885f, 0.01678204f, 0.14170150f, 0.01949661f, 0.03279343f, 
    0.14531735f, 0.07761234f, 0.05621677f, 0.13908358f, -0.25483939f, 0.15515144f, -0.12302830f, -0.15098120f, 
    -0.07879312f, -0.00650932f, 0.08354549f, -0.02352061f, 0.08709647f, 0.06915095f, 0.05033436f, 0.05874800f, 
    0.22165827f, 0.08939468f, 0.12674269f, -0.03229738f, -0.02740308f, 0.01363352f, 0.07677423f, 0.06728460f, 
    0.07573301f, 0.03502569f, 0.02519551f, 0.00949135f, 0.20543732f, 0.13441402f, 0.00777428f, -0.11540203f, 
    -0.07335618f, 0.14964131f, 0.09964764f, -0.00374728f, -0.04146405f, -0.05601142f, 0.06350972f, -0.08055511f, 
    0.06956226f, 0.15221214f, -0.14027709f, 0.06094819f, -0.11962029f, -0.12124187f, -0.00545312f, 0.04180717f, 
    0.05968967f, 0.09501024f, 0.01141090f, 0.02416899f, 0.00778138f, -0.25523379f, -0.15207341f, -0.04680772f, 
    0.00058254f, -0.03469936f, -0.21718565f, 0.05803939f, 0.02963790f, -0.02109288f, 0.04904883f, 0.05793487f, 
    -0.05856617f, 0.05063854f, -0.13395751f, 0.14058453f, 0.18548775f, 0.01448076f, -0.01654271f, 0.11416523f, 
    0.02139479f, -0.03009713f, -0.11509278f, -0.09425587f, 0.18751542f, 0.18635876f, -0.21720701f, -0.20192489f, 
    -0.02625418f, -0.06443632f, -0.03951650f, -0.00493018f, 0.07580877f, -0.08596630f, 0.12357128f, 0.10307822f, 
    0.13470836f, -0.08287070f, 0.12636070f, -0.09861936f, -0.09695728f, -0.05077676f, -0.09294419f, -0.09011688f, 
    0.01758506f, 0.00174017f, -0.01472360f, -0.03880515f, 0.40256488f, 0.06770428f, 0.01448132f, -0.01382934f, 
    -0.03616899f, 0.05204840f, 0.01891265f, 0.02136388f, 0.08235912f, -0.05791854f, -0.14409624f, -0.02655205f, 
    0.25961497f, 0.16379531f, 0.14860451f, 0.15062699f, 0.00741553f, -0.12666360f, 0.07479031f, 0.00730982f, 
    -0.07641833f, -0.17669798f, 0.11299787f, 0.03532541f, -0.20513666f, 0.29136980f, -0.03958853f, -0.17738053f, 
    -0.06429126f, 0.05294809f, -0.11730441f, 0.00936502f, -0.22670728f, -0.02472438f, -0.00412932f, 0.03259650f, 
    0.34077117f, 0.27362329f, 0.18491773f, 0.18843643f, 0.08679513f, 0.14028218f, 0.01106795f, 0.01644883f, 
    -0.03108641f, 0.01886599f, 0.01350663f, 0.10142821f, 0.05846691f, 0.24886891f, 0.32986352f, 0.19841710f, 
    0.16707580f, 0.03150811f, 0.13133058f, 0.06433087f, 0.00748556f, -0.02595409f, 0.05570013f, 0.02386651f, 
    0.11065193f, -0.15844433f, -0.18226522f, -0.33792806f, 0.06309628f, -0.04147886f, -0.00151233f, -0.09884314f, 
    -0.05107848f, -0.17780197f, 0.03479698f, -0.14655523f, 0.17078604f, 0.17450395f, -0.14683816f, 0.02870804f, 
    -0.05472441f, -0.06300426f, -0.03129986f, 0.00753193f, -0.07018532f, -0.05838179f, 0.04720308f, 0.03871350f, 
    0.01004016f, -0.11823151f, 0.18444142f, 0.12683669f, -0.05248610f, -0.04698956f, -0.16707176f, 0.03306081f, 
    -0.04194178f, -0.00824963f, -0.03761942f, -0.03373429f, 0.45729560f, -0.16885488f, -0.10752299f, -0.00612508f, 
    -0.05111748f, -0.02374571f, 0.02375603f, -0.04813626f, 0.01090908f, 0.02689523f, -0.04093950f, -0.02025213f, 
    0.08417170f, 0.20432913f, 0.14274456f, 0.02105281f, 0.03788646f, -0.01628448f, 0.00637397f, -0.04421344f, 
    -0.05537091f, 0.01997214f, -0.17513315f, -0.06313450f, 0.25075233f, -0.12665249f, -0.02004974f, 0.05458544f, 
    0.18225136f, 0.00004375f, -0.04082485f, -0.02292885f, -0.09038635f, -0.05541607f, -0.03066225f, 0.10831269f, 
    -0.04580963f, -0.01681446f, 0.07771251f, 0.11223412f, 0.02350755f, 0.02418337f, -0.00382913f, -0.14477560f, 
    -0.03751037f, 0.03787264f, 0.06315842f, -0.05688582f, -0.19992131f, -0.04135995f, -0.08457886f, -0.15360296f, 
    0.08275960f, 0.01601088f, -0.01803605f, -0.07138013f, -0.01635394f, -0.07578508f, -0.02276148f, -0.03596993f, 
    -0.35736588f, -0.04174364f, -0.05513474f, -0.08609951f, -0.05758734f, 0.01242920f, -0.00187438f, -0.06677654f, 
    -0.05355409f, 0.06659753f, -0.01838178f, -0.06891178f, -0.24774645f, -0.02402017f, 0.02784029f, 0.11762335f, 
    0.18495250f, 0.04609643f, 0.00871923f, -0.04972987f, -0.03466066f, 0.12367117f, 0.13613826f, -0.14210936f, 
    0.07244110f, -0.05432616f, -0.07325415f, -0.02046183f, 0.07463215f, 0.06463761f, -0.00915153f, 0.04687047f, 
    0.01184479f, -0.10270480f, 0.01957467f, -0.07792750f, 0.04591303f, -0.09362570f, 0.05762792f, -0.07124483f, 
    -0.03493844f, -0.06133309f, 0.04715471f, -0.05119394f, 0.06401086f, -0.06609149f, -0.06094240f, -0.02437722f, 
    0.02199132f, -0.05702375f, 0.01231424f, -0.06575611f, 0.01667883f, 0.06533783f, 0.04285719f, -0.02862538f, 
    -0.00780264f, -0.04121209f, -0.09613295f, -0.04366579f, 0.02306884f, 0.03811218f, 0.02507461f, 0.02168827f, 
    0.04593863f, -0.09797695f, -0.01195582f, -0.03315036f, 0.10037913f, -0.04306864f, -0.04117392f, 0.06786097f, 
    0.11306074f, 0.02404270f, -0.01601529f, 0.04299377f, 0.07513352f, -0.02217347f, -0.00407499f, -0.02964759f, 
    -0.03813189f, -0.02747641f, 0.00216081f, -0.08019159f, 0.03815012f, 0.12919432f, 0.03794806f, 0.08711305f, 
    -0.06103511f, -0.04839445f, 0.06874423f, -0.06570590f, -0.02378406f, 0.02205455f, 0.01753552f, -0.07714710f, 
    0.09854434f, -0.01289703f, -0.02508536f, -0.06557572f, -0.08228914f, -0.06293658f, 0.07700552f, 0.05201375f, 
    -0.02126828f, 0.00773522f, -0.07456872f, -0.05579371f, -0.02255369f, -0.03956126f, 0.12331153f, -0.00354051f, 
    0.09464091f, -0.14383931f, -0.00245935f, -0.06413877f, -0.05338783f, -0.01276876f, -0.07148816f, -0.05050081f, 
    -0.12546754f, 0.00185095f, -0.02830155f, 0.04026109f, 0.00769703f, -0.00024693f, 0.06882748f, 0.01299953f, 
    -0.04395353f, 0.03204605f, -0.11262407f, -0.01475502f, 0.02307565f, 0.02223342f, -0.05596465f, -0.02336048f, 
    0.04070908f, -0.01489469f, -0.03465174f, -0.05943386f, 0.09030384f, -0.01260302f, -0.06151785f, 0.00332362f, 
    -0.10770085f, -0.02851290f, 0.01274774f, -0.01564184f, 0.07249383f, 0.00023700f, 0.00676584f, -0.02115112f, 
    -0.03398415f, -0.03109479f, -0.06243572f, 0.03113501f, -0.05054736f, 0.01711974f, 0.03985200f, -0.00700838f, 
    0.04354493f, 0.07081772f, 0.04079260f, -0.07320967f, 0.07824823f, 0.02581861f, -0.00063070f, -0.02505021f, 
    -0.10468838f, -0.00940545f, -0.10938613f, -0.04197629f, 0.06273612f, -0.03064756f, -0.10712188f, -0.07077075f, 
    -0.04423393f, -0.09962486f, -0.06266763f, -0.05452602f, 0.01608422f, 0.03652881f, 0.04971734f, -0.04317931f, 
    -0.01695971f, -0.08818239f, 0.01195819f, 0.07951279f, -0.07088292f, -0.04846963f, -0.08464257f, -0.02065789f, 
    0.05709414f, 0.05467783f, 0.02578278f, -0.00149113f, -0.01408620f, -0.06246104f, -0.02629091f, -0.02999028f, 
    0.07305295f, -0.03384351f, -0.05694402f, 0.05699471f, -0.12425272f, -0.03015723f, -0.02106970f, -0.00781566f, 
    -0.05225474f, -0.03215377f, -0.03154960f, -0.02191418f, -0.04379565f, -0.03151715f, 0.05053699f, -0.05579204f, 
    -0.09881691f, 0.03053332f, -0.20318204f, -0.02130986f, 0.07442819f, -0.01880229f, -0.04654821f, 0.00612017f, 
    0.11562346f, -0.01007241f, -0.08189181f, -0.07948357f, -0.29322827f, -0.06816214f, -0.15289298f, -0.02975243f, 
    0.24466279f, -0.05385368f, 0.08554552f, -0.01039218f, -0.02564282f, -0.06304100f, -0.03735974f, 0.04447506f, 
    0.21865834f, 0.05696081f, -0.14944431f, -0.06476944f, -0.00842643f, -0.00047298f, 0.05300187f, -0.07949231f, 
    0.04465058f, -0.07344609f, 0.27697936f, -0.01371551f, 0.08541808f, 0.07264201f, 0.05710842f, 0.02108410f, 
    0.06360540f, 0.10122953f, -0.05108442f, -0.03553819f, 0.08113175f, -0.01030077f, 0.20902689f, -0.01676934f, 
    -0.12926053f, -0.00676643f, -0.09704021f, 0.01039512f, 0.10003539f, 0.06948762f, 0.07601016f, -0.09371276f, 
    0.07470589f, -0.04284992f, -0.05278245f, 0.04509726f, 0.79397905f, 0.05681674f, -0.17542915f, -0.08144513f, 
    -0.02993679f, 0.09165982f, 0.02207044f, -0.05331462f, 0.07738665f, -0.07376099f, -0.00850934f, 0.01680597f, 
    -0.08290406f, 0.13691446f, 0.04430389f, -0.11519689f, 0.13724294f, -0.03417628f, -0.18131709f, 0.00300736f, 
    -0.06851335f, 0.10568563f, 0.01347613f, -0.03177126f, -0.20320904f, -0.08739026f, 0.00623438f, 0.27227557f, 
    0.09529307f, 0.15333210f, 0.05332130f, -0.01959217f, -0.00297795f, -0.04583721f, 0.13644564f, 0.09733861f, 
    0.27760211f, -0.08530992f, -0.05787992f, 0.20081453f, 0.00368762f, -0.04166675f, -0.04605834f, -0.04133256f, 
    0.13429208f, -0.12467857f, -0.01504141f, 0.18172079f, -0.02722571f, -0.01187128f, 0.13345061f, -0.03783428f, 
    0.06783339f, 0.13642816f, -0.03690796f, -0.02320164f, 0.14090617f, 0.22068173f, 0.05758714f, 0.05495115f, 
    0.22567081f, -0.06643529f, 0.10855645f, -0.18406181f, 0.05923760f, -0.05382684f, -0.00613322f, -0.03366363f, 
    -0.13613819f, 0.10957848f, -0.16240695f, -0.12569226f, 0.08663712f, 0.08316434f, 0.17084494f, 0.03038373f, 
    0.02148901f, 0.06034486f, -0.16672306f, -0.13926767f, -0.05008352f, 0.08645397f, 0.07319779f, 0.27874914f, 
    -0.01510997f, -0.09935038f, -0.01430301f, 0.02885503f, 0.01239906f, -0.03446641f, 0.12676930f, 0.05310606f, 
    0.00034462f, 0.09313599f, -0.06162839f, 0.11825950f, -0.25968096f, 0.26561990f, -0.10563405f, -0.21136928f, 
    0.24327749f, -0.18264550f, -0.18852346f, 0.12788637f, -0.00567713f, -0.11144800f, -0.07627236f, -0.07280802f, 
    0.04685014f, 0.24482267f, 0.15204957f, -0.06632575f, 0.05898053f, -0.13912837f, -0.15203215f, 0.00600092f, 
    0.02703299f, -0.10739431f, -0.07410679f, -0.08431170f, 0.21643299f, 0.11277685f, 0.24015372f, 0.23525269f, 
    0.05126769f, 0.07313725f, -0.11190902f, 0.01274145f, -0.18531042f, 0.06046237f, -0.03418522f, 0.11009832f, 
    -0.01333291f, 0.07761603f, -0.01821437f, -0.04699228f, 0.00815660f, 0.03060339f, -0.09878452f, 0.08755758f, 
    0.07791060f, 0.04225382f, 0.07996267f, 0.06937221f, 0.25908473f, 0.15406026f, -0.07869724f, 0.14121114f, 
    0.03475526f, 0.09903259f, -0.09356751f, -0.02489438f, 0.00496075f, 0.08784911f, 0.02108096f, -0.11426407f, 
    0.08867424f, -0.16856924f, 0.13286041f, -0.02683957f, 0.09316513f, 0.05998360f, 0.01031526f, 0.17121516f, 
    -0.14659126f, -0.06155328f, -0.23959821f, 0.07012095f, 0.09673641f, -0.01390576f, 0.08304566f, 0.08486069f, 
    0.04188661f, -0.10387172f, -0.00378379f, -0.06414193f, 0.06771727f, 0.02928018f, 0.00677411f, 0.02434903f, 
    0.07651837f, 0.03737687f, 0.02488895f, -0.12927689f, 0.10107020f, 0.05629123f, -0.02196150f, 0.02907789f, 
    0.00991925f, -0.01825628f, 0.00642889f, 0.10164373f, -0.42953032f, -0.11757182f, -0.00429836f, -0.01577656f, 
    0.19362362f, -0.04898788f, -0.01501452f, 0.01982788f, 0.02801167f, -0.05749365f, 0.04181554f, -0.06441505f, 
    -0.19293600f, -0.23331392f, 0.10729240f, 0.29807723f, 0.14834741f, -0.08607774f, -0.03118072f, 0.03310455f, 
    0.05437045f, -0.12319396f, 0.02613960f, -0.11353526f, 0.05875260f, 0.17051798f, 0.33677241f, -0.16481464f, 
    0.01324831f, -0.16541263f, 0.03748884f, -0.04443877f, -0.04368515f, 0.06533657f, -0.20341843f, 0.04464866f, 
    0.08091960f, 0.08419105f, -0.07283383f, -0.13539496f, -0.01561719f, 0.02200299f, 0.01688881f, 0.09067114f, 
    -0.02286145f, 0.01599700f, 0.06625249f, -0.13012499f, 0.12305667f, -0.12246749f, 0.02133849f, 0.02471902f, 
    0.05151688f, -0.04033756f, 0.00363500f, 0.01467900f, 0.10593619f, -0.10771585f, -0.08181212f, 0.04613700f, 
    -0.05194424f, 0.04754885f, 0.21008542f, 0.03423017f, -0.01681609f, 0.04174234f, 0.10237367f, 0.11351702f, 
    0.12716416f, -0.04031928f, 0.10126444f, 0.15143792f, -0.20314795f, 0.03327566f, 0.10065208f, -0.07989193f, 
    0.10894537f, -0.02538009f, 0.02049000f, 0.13636033f, 0.01717640f, 0.02922340f, -0.12572029f, 0.03160847f, 
    0.26063180f, 0.00958595f, 0.03755863f, 0.09141196f, -0.01460455f, 0.04215909f, -0.04382785f, 0.08083808f, 
    -0.04895897f, -0.08443023f, 0.01122185f, -0.18094231f, 0.06100341f, -0.23315150f, 0.14216864f, 0.18299390f, 
    0.10499093f, 0.04486693f, 0.00620426f, -0.04552111f, 0.07270607f, 0.02625415f, 0.02703292f, 0.04056467f, 
    -0.11072356f, -0.00745631f, 0.03419915f, 0.01334863f, 0.01491562f, 0.12385157f, 0.02602928f, 0.05663155f, 
    -0.07002676f, 0.04153829f, 0.12517352f, 0.07538703f, 0.02657729f, -0.07856929f, 0.03170791f, -0.15284954f, 
    -0.07644333f, 0.08194733f, 0.08504999f, 0.06118561f, 0.16303369f, -0.02856886f, -0.04032616f, -0.05302676f, 
    -0.19459337f, -0.07259263f, 0.03599075f, -0.35103837f, 0.19848181f, -0.03619358f, -0.05641803f, 0.06731478f, 
    0.07710702f, -0.02381971f, 0.04369430f, 0.09836720f, -0.00384093f, 0.16130765f, 0.04371904f, -0.11155827f, 
    0.07613041f, 0.03452231f, -0.11211277f, -0.00855876f, -0.10358815f, 0.05593092f, 0.09503861f, -0.21927182f, 
    0.37710679f, -0.10447554f, 0.16600057f, 0.14220382f, 0.08482642f, 0.13864730f, -0.01411007f, 0.00159709f, 
    -0.13329022f, -0.00842452f, -0.15130837f, -0.01833211f, -0.02819980f, -0.01731354f, 0.02060639f, 0.16088578f, 
    -0.02709995f, -0.09132458f, 0.03761641f, -0.01379971f, 0.01364199f, 0.06229735f, -0.01454862f, 0.05967832f, 
    -0.07245095f, 0.10949355f, -0.10334370f, 0.09462440f, 0.06486353f, 0.04882994f, -0.05726755f, 0.02175926f, 
    0.12264405f, 0.07585744f, -0.06150706f, 0.25510782f, -0.34045756f, 0.13416533f, -0.14001004f, 0.06423916f, 
    0.07153014f, -0.08650047f, 0.10952296f, -0.01500404f, 0.08998310f, -0.00031897f, -0.01802014f, -0.14527102f, 
    -0.27207175f, -0.06180025f, -0.01261416f, 0.03428013f, 0.05999894f, 0.02565021f, -0.08384908f, -0.05550333f, 
    -0.00789450f, -0.05743239f, 0.05630764f, -0.08917731f, -0.28995845f, -0.00475295f, 0.14006586f, 0.03179392f, 
    0.04885556f, -0.04588632f, 0.02879408f, -0.06343910f, 0.12130686f, 0.02645339f, -0.15471391f, 0.02562507f, 
    -0.11830433f, 0.06789746f, -0.00247934f, -0.11136679f, 0.02634380f, 0.02687253f, 0.03707155f, -0.00906305f, 
    0.00252995f, 0.05356123f, 0.07228043f, -0.07782748f, 0.12131587f, -0.40764838f, 0.15289785f, -0.09916663f, 
    -0.03247454f, 0.05851338f, -0.11142419f, -0.12380368f, -0.00710475f, -0.22047539f, 0.06788676f, 0.04692525f, 
    0.03730518f, 0.16071469f, 0.00780718f, 0.19857980f, 0.11615326f, 0.03732755f, 0.10900865f, 0.01387526f, 
    0.09317389f, -0.12495176f, 0.18404017f, 0.05485919f, -0.01814242f, 0.01091607f, 0.06043771f, 0.00805040f, 
    0.14769292f, -0.11237238f, -0.00898199f, 0.14748605f, 0.02610322f, -0.01120162f, -0.16650166f, 0.03253717f, 
    0.06087587f, 0.16650403f, -0.08070514f, -0.17710838f, 0.05320803f, 0.03565624f, -0.03073584f, -0.07713350f, 
    0.01771651f, -0.13650332f, -0.05501398f, -0.13322000f, -0.22409211f, -0.06067066f, 0.13591202f, -0.03968012f, 
    0.11589158f, 0.01893123f, -0.01750206f, -0.02746347f, -0.08014214f, 0.13068688f, 0.08236924f, 0.00610560f, 
    -0.11916891f, 0.12348596f, 0.12356806f, 0.07247548f, -0.00253066f, 0.04613485f, -0.01992546f, 0.07391790f, 
    -0.02957953f, 0.14152384f, 0.16909751f, 0.11735126f, 0.05992563f, 0.11328414f, 0.23455141f, 0.06357175f, 
    0.03138244f, 0.03061232f, 0.04446564f, 0.00409103f, 0.00083181f, 0.07715825f, -0.02958974f, 0.00395791f, 
    -0.33251420f, 0.13077700f, -0.00185758f, -0.16334075f, 0.26513848f, -0.05061305f, 0.01298710f, 0.07908872f, 
    -0.03393790f, -0.02728684f, 0.00412367f, 0.11802012f, 0.20122235f, 0.08131161f, 0.01469033f, -0.13853650f, 
    0.18020980f, 0.12548684f, -0.07627140f, 0.07491020f, -0.03487511f, 0.04865676f, 0.03360162f, -0.13480827f, 
    0.29726538f, -0.06309593f, 0.06420550f, 0.08244043f, -0.04140626f, 0.21089412f, -0.07117432f, -0.02173744f, 
    -0.14353657f, -0.12893583f, -0.13015479f, 0.07389520f, -0.05872880f, 0.02621749f, 0.04933318f, 0.16746472f, 
    0.21660580f, -0.13245334f, 0.00903824f, -0.12810630f, 0.10208663f, 0.09157356f, -0.06675906f, 0.03140245f, 
    0.09403596f, 0.14029436f, 0.03651544f, 0.19280182f, -0.06700416f, 0.12546307f, -0.06634510f, -0.10913070f, 
    0.04797398f, 0.06256878f, 0.07800764f, 0.05409861f, -0.14216499f, 0.00643964f, -0.03840767f, 0.01795150f, 
    0.02921190f, -0.10281815f, 0.01154497f, 0.05485157f, 0.07539501f, -0.14032522f, -0.05161813f, -0.15926073f, 
    -0.02754178f, -0.14273971f, -0.16966508f, 0.00255693f, 0.27083194f, 0.03037423f, -0.05484603f, 0.02984244f, 
    0.09418461f, -0.10602511f, 0.06248759f, 0.00174835f, -0.05899293f, 0.05304945f, 0.06909283f, -0.13829422f, 
    -0.10836274f, -0.12627235f, -0.02765678f, -0.15375170f, 0.14816904f, 0.02757704f, -0.05315439f, 0.02151003f, 
    -0.29575664f, 0.04046605f, 0.19367445f, -0.03218242f, 0.05651386f, 0.14762346f, 0.12686458f, 0.09931529f, 
    -0.01785319f, 0.03444210f, 0.09468818f, 0.02268651f, -0.03272234f, -0.02703853f, -0.06092162f, -0.15133925f, 
    0.04476206f, 0.04940566f, -0.08969113f, -0.15366901f, 0.17509449f, -0.10714238f, 0.07640757f, -0.11934492f, 
    0.17473300f, 0.20311829f, -0.13009724f, 0.20601733f, 0.10200681f, 0.00800326f, 0.12394464f, -0.08422382f, 
    -0.01390234f, -0.02584241f, 0.18564217f, 0.10942535f, 0.09154875f, 0.04628542f, 0.08214078f, 0.04520459f, 
    0.03386452f, 0.01157054f, 0.09557506f, 0.13422456f, 0.12237101f, 0.01043870f, -0.17641295f, -0.13218236f, 
    0.00541891f, 0.06889424f, -0.12357967f, -0.05953993f, -0.01837025f, -0.16368675f, -0.03189614f, 0.07808248f, 
    -0.01334912f, -0.24046418f, 0.01437565f, -0.23568429f, -0.06007425f, -0.22745021f, 0.12040306f, 0.12910810f, 
    0.08351913f, 0.06626011f, -0.08551066f, 0.07683833f, 0.10321509f, 0.15791868f, 0.00798768f, 0.01293544f, 
    -0.24525687f, -0.14939804f, -0.10677545f, 0.19859579f, -0.02571048f, 0.00075662f, 0.02792448f, -0.04829468f, 
    0.03259159f, 0.15032668f, 0.16425402f, 0.11314893f, -0.13632800f, 0.07311704f, -0.01783617f, 0.06382506f, 
    -0.03499528f, -0.00269833f, -0.02589698f, -0.03667920f, 0.16246185f, 0.00106722f, 0.11147683f, 0.03286488f, 
    -0.37171024f, 0.25927976f, -0.10451510f, 0.28222644f, -0.19143948f, -0.11232576f, 0.09192245f, 0.05512495f, 
    -0.05620044f, 0.07851607f, 0.04168536f, 0.02519144f, -0.18336274f, -0.24015664f, -0.07224991f, 0.03722282f, 
    -0.00360098f, -0.02088334f, 0.01324319f, 0.05037428f, 0.05707943f, 0.00047626f, 0.09128791f, 0.06821880f, 
    -0.00285920f, -0.04049782f, 0.21741705f, -0.03311623f, -0.21404533f, -0.10944624f, -0.04017999f, -0.06399972f, 
    -0.10646819f, 0.18131906f, 0.01961007f, 0.00926397f, 0.04567511f, -0.26341859f, -0.19776788f, 0.32240215f, 
    0.17042005f, 0.18502042f, -0.04011564f, -0.10900628f, 0.19338344f, -0.03416482f, -0.06563903f, 0.05191373f, 
    0.16314027f, -0.00855687f, -0.13832036f, 0.17408937f, -0.12868182f, 0.01718148f, -0.01950878f, -0.08811931f, 
    -0.08029854f, 0.23822229f, 0.00913369f, -0.11792459f, -0.19131306f, -0.26199004f, -0.09718592f, -0.02877488f, 
    -0.18342870f, -0.01726790f, -0.01684500f, 0.09549656f, -0.01117401f, -0.13837063f, -0.10946064f, 0.01516133f, 
    -0.06834434f, -0.08969577f, 0.01254834f, 0.12494382f, 0.07262728f, 0.02945605f, -0.01311572f, 0.07726806f, 
    0.13777588f, -0.06603854f, -0.00186950f, 0.05060345f, 0.34812775f, -0.21312019f, -0.14311936f, -0.00774703f, 
    0.03276291f, 0.15274747f, -0.14466248f, -0.01826925f, 0.09085073f, 0.17377658f, 0.00528221f, 0.06882720f, 
    -0.07042018f, 0.37019882f, 0.10231227f, 0.00557601f, -0.08511461f, -0.00570461f, 0.02752716f, -0.03293612f, 
    -0.11307224f, 0.10262679f, 0.03761386f, 0.03359368f, -0.22441587f, -0.16136388f, 0.13607310f, -0.02780071f, 
    -0.04965270f, 0.01307164f, 0.05478558f, -0.00403471f, 0.06213164f, 0.09568144f, -0.00150651f, 0.18514928f, 
    0.28655198f, 0.07276093f, -0.13179746f, 0.05988913f, -0.02408420f, 0.09812680f, 0.21220791f, -0.03123586f, 
    0.05322779f, 0.10967831f, 0.02770690f, 0.00463209f, 0.17901719f, 0.04384956f, -0.16243201f, -0.04922924f, 
    -0.00503404f, 0.12928233f, 0.04835547f, -0.07552273f, -0.01910916f, 0.02937931f, 0.05660734f, 0.04591716f, 
    -0.28946376f, 0.02035671f, 0.15574427f, 0.17676340f, -0.03036605f, -0.08600629f, 0.14670995f, 0.07609031f, 
    0.01609934f, 0.03695475f, 0.03685324f, 0.06563435f, 0.22120945f, -0.10644902f, 0.05507614f, 0.06760500f, 
    -0.05928325f, -0.01769774f, -0.12105498f, 0.05178188f, -0.01111975f, -0.09790894f, 0.02529234f, -0.02372413f, 
    0.08542520f, -0.12991834f, 0.04016353f, 0.13916828f, 0.20202821f, 0.04167326f, -0.05014023f, 0.11437066f, 
    0.02846777f, -0.11432332f, -0.04371056f, 0.06407021f, 0.23224443f, 0.10112791f, -0.15408231f, -0.11512004f, 
    0.03709436f, 0.06642047f, 0.01068502f, 0.12728553f, 0.12790701f, 0.04187256f, 0.13702784f, -0.02400462f, 
    0.05040548f, 0.00631883f, 0.04948290f, 0.03977541f, 0.04708553f, 0.03462923f, -0.02591513f, -0.07633573f, 
    0.06604602f, 0.00147675f, -0.06874308f, -0.05277257f, -0.06279892f, -0.05540001f, -0.02052215f, -0.03127852f, 
    0.03485354f, -0.04473110f, 0.06473430f, 0.00334897f, 0.00298585f, -0.06175695f, 0.02608846f, -0.05835480f, 
    0.04577985f, -0.06766042f, 0.00229747f, 0.02522146f, -0.00058483f, -0.01283857f, 0.06044996f, 0.03106208f, 
    0.01142773f, -0.01697975f, -0.04934076f, 0.05507810f, 0.00582169f, -0.05935602f, 0.05686764f, -0.06012149f, 
    -0.05935268f, -0.02445011f, 0.05305782f, -0.03593614f, 0.01877714f, 0.04302660f, -0.07055032f, -0.01266869f, 
    -0.02778834f, -0.07122182f, -0.04600125f, 0.00560832f, -0.07428759f, 0.06500959f, 0.04065364f, -0.03816389f, 
    -0.04859951f, -0.04439387f, 0.05001955f, 0.01180614f, -0.07680173f, -0.02955702f, -0.05408487f, -0.03860652f, 
    -0.06573810f, 0.03093559f, -0.02650509f, 0.03015554f, -0.01609541f, -0.00449562f, -0.01081160f, -0.06038700f, 
    -0.05602510f, 0.01517343f, -0.06902344f, -0.05926828f, -0.01448542f, 0.03990242f, 0.01806356f, 0.02526998f, 
    -0.01322921f, 0.03790109f, -0.00336807f, -0.04287223f, -0.07227647f, -0.01551627f, 0.05723479f, -0.05455360f, 
    0.01182908f, -0.06986662f, -0.02911636f, -0.04683408f, -0.02297653f, -0.06393595f, -0.04353178f, -0.03279212f, 
    -0.04173992f, 0.02457163f, -0.02836556f, -0.04788124f, 0.05556990f, 0.02414398f, -0.06343004f, 0.01297960f, 
    -0.02897770f, -0.01942545f, 0.05981033f, -0.02969658f, -0.01021505f, 0.05663668f, 0.00534840f, -0.03767905f, 
    -0.05382651f, -0.01306187f, -0.03605284f, 0.03887146f, -0.07676736f, -0.04229628f, 0.06425448f, -0.07733373f, 
    -0.05156789f, 0.05936957f, 0.05877620f, 0.00578692f, 0.04443620f, 0.00957140f, 0.02850361f, 0.00600752f, 
    -0.00399622f, 0.00899800f, -0.07190645f, -0.05498850f, 0.03685903f, -0.07451101f, -0.06981165f, -0.06498114f, 
    0.04117230f, -0.00771894f, 0.02766209f, -0.07261780f, 0.01789068f, 0.00633184f, -0.05180893f, -0.03609094f, 
    -0.02407514f, 0.03787648f, 0.02666491f, 0.04263717f, 0.04164277f, -0.03990961f, -0.03614536f, 0.00205423f, 
    -0.07775605f, -0.07312612f, -0.06392978f, 0.05707811f, -0.03784906f, -0.05316185f, 0.00615378f, -0.01736120f, 
    0.00153784f, -0.01749243f, 0.05843252f, 0.04934612f, -0.05565959f, -0.03914881f, -0.04097578f, -0.00040096f, 
    -0.04457836f, -0.03051371f, 0.04974747f, 0.05509642f, -0.04821856f, 0.01640278f, -0.07102253f, -0.05914459f, 
    -0.04706059f, -0.03979303f, 0.01156541f, -0.04888003f, -0.04206647f, 0.03331806f, -0.00919623f, 0.02516133f, 
    0.04255979f, -0.06692273f, 0.04750267f, -0.01529154f, -0.03287642f, -0.03965387f, 0.05772843f, 0.06280375f, 
    -0.09826366f, 0.20432563f, -0.12480469f, -0.04814753f, 0.09959012f, 0.04103860f, -0.02769765f, -0.01849741f, 
    -0.13746615f, -0.02973927f, 0.02776748f, 0.06259444f, -0.15460500f, -0.33190668f, -0.12699921f, -0.38504952f, 
    0.12726681f, 0.14623518f, -0.08862758f, 0.01700552f, -0.01686450f, -0.01261653f, 0.09010200f, -0.12964697f, 
    0.08236340f, 0.01660478f, 0.06415258f, 0.09675406f, 0.01168459f, 0.14492649f, -0.14782418f, -0.02028163f, 
    0.05688304f, 0.02805106f, -0.19010787f, 0.06211737f, -0.07521831f, 0.03654333f, 0.01005476f, 0.00297430f, 
    0.25580171f, -0.15119687f, -0.09566960f, -0.03630608f, -0.05725507f, 0.05232218f, 0.08146544f, 0.15436822f, 
    0.28835189f, 0.08130982f, -0.05886783f, 0.04254135f, -0.09485637f, -0.03534564f, -0.02926868f, -0.10915013f, 
    -0.00379430f, -0.07944442f, 0.03971547f, -0.07325019f, 0.23142508f, 0.01424034f, -0.05666459f, 0.12611920f, 
    -0.11698178f, -0.01462296f, -0.07104535f, -0.06828685f, -0.02259119f, -0.09926808f, -0.05261143f, -0.06935161f, 
    0.25187734f, -0.12138399f, -0.19530740f, -0.05313741f, 0.17538251f, 0.01349189f, 0.04287896f, 0.00421896f, 
    0.04702963f, 0.05794516f, 0.03787852f, 0.03294427f, 0.03027136f, 0.09611527f, 0.24657281f, -0.02469224f, 
    0.00682538f, -0.08551749f, -0.04984699f, -0.11068611f, 0.25923955f, 0.03137650f, -0.02838429f, -0.00522836f, 
    -0.04869815f, 0.04210459f, 0.13279290f, 0.03616509f, -0.08915119f, 0.09410556f, 0.20848763f, 0.11450708f, 
    0.10960048f, 0.07495093f, 0.16862598f, 0.00378695f, -0.43700597f, 0.22554512f, -0.00286216f, -0.00817336f, 
    0.03359013f, -0.06570739f, 0.10158528f, -0.03741634f, 0.19555403f, -0.03746355f, 0.12940699f, -0.09571679f, 
    0.11160400f, 0.03006489f, 0.06452468f, -0.02705799f, 0.02059249f, 0.16635394f, -0.10994251f, 0.00057474f, 
    -0.21683073f, -0.10206312f, 0.08714785f, 0.11943943f, -0.07475491f, 0.08609655f, 0.02709883f, 0.13035455f, 
    -0.06568915f, -0.04878961f, -0.22250316f, 0.06382237f, 0.12791732f, 0.00610898f, 0.13314283f, 0.07500184f, 
    0.05394915f, 0.08631146f, -0.10472696f, 0.01814921f, -0.05844933f, -0.10098061f, 0.03777635f, -0.07763656f, 
    0.01931533f, -0.32389963f, 0.05134899f, -0.14628893f, 0.10862361f, -0.24425463f, -0.08038854f, -0.10082010f, 
    -0.00643846f, 0.04960653f, 0.10171129f, 0.15863371f, 0.05776954f, 0.01622042f, 0.04139552f, 0.07911351f, 
    0.11041667f, -0.23201674f, -0.03618725f, 0.18939826f, -0.09100428f, 0.04956734f, 0.23219471f, -0.11563126f, 
    0.04503996f, 0.03408762f, 0.07366677f, 0.16403683f, -0.17369103f, -0.14710721f, 0.02835623f, 0.15563422f, 
    0.03324783f, 0.07389809f, 0.03380923f, -0.12891643f, 0.04948175f, -0.03710915f, -0.05776207f, -0.11012110f, 
    0.05430090f, 0.08750723f, 0.09242284f, -0.04822856f, -0.23840518f, 0.04886064f, -0.10794058f, 0.06583069f, 
    -0.07990580f, -0.08699265f, -0.05441501f, -0.04771965f, -0.13138491f, -0.37176239f, 0.00713382f, -0.08332215f, 
    -0.06658999f, 0.04106073f, 0.08449616f, 0.01847029f, 0.08112221f, -0.15406613f, 0.14483581f, 0.02332956f, 
    0.31519756f, 0.08892806f, 0.26833281f, 0.01080633f, -0.04074278f, 0.08657449f, 0.16881613f, 0.04495316f, 
    -0.04857076f, -0.04179368f, 0.04636563f, 0.07140724f, -0.04788009f, -0.07297494f, -0.10569552f, 0.01152707f, 
    -0.01791314f, 0.01025913f, -0.09556496f, -0.01685133f, 0.03538400f, 0.01018533f, 0.04746919f, 0.14021914f, 
    0.51551092f, -0.04657995f, 0.04052213f, 0.05858573f, -0.10784341f, -0.04997046f, 0.01472469f, -0.04195547f, 
    -0.04341415f, -0.09050996f, 0.11554835f, -0.14770505f, -0.03451954f, 0.14003746f, 0.21847446f, 0.15843314f, 
    0.13402329f, -0.15387020f, -0.03877732f, 0.07028912f, 0.03490349f, 0.07628462f, 0.03246528f, -0.02272156f, 
    -0.32531962f, -0.30233118f, -0.07747150f, 0.01098347f, 0.04370835f, 0.07832704f, -0.08361824f, 0.00501663f, 
    -0.13788530f, -0.18808410f, 0.06515757f, -0.12933649f, 0.02317000f, -0.38856682f, 0.00151642f, 0.09106755f, 
    0.12071051f, -0.09872779f, -0.08635425f, 0.14207277f, -0.02176270f, 0.15806188f, -0.05883033f, 0.14886725f, 
    -0.08198322f, 0.18742999f, 0.09164691f, 0.10114484f, 0.00024032f, -0.13391298f, 0.03356764f, 0.08097149f, 
    -0.02099211f, 0.09722948f, -0.16425264f, 0.13985427f, 0.12079686f, -0.44246286f, 0.07683127f, 0.13425915f, 
    -0.04889632f, 0.02029162f, -0.01276188f, 0.11465047f, 0.02504127f, 0.11700531f, -0.11065792f, 0.05997486f, 
    0.24859934f, 0.16476083f, 0.01921611f, -0.00958402f, 0.03880563f, 0.13648535f, 0.05750210f, 0.06076776f, 
    -0.09118559f, -0.01051670f, 0.10559933f, 0.00281218f, -0.11479528f, 0.04299316f, -0.09586962f, 0.08875927f, 
    0.09079743f, 0.03560578f, -0.05085646f, -0.01005667f, -0.14702903f, 0.13765961f, -0.09495261f, 0.11231384f, 
    0.03960574f, 0.13066384f, -0.02784193f, -0.00055462f, -0.00892218f, 0.04130188f, 0.06112329f, 0.07293367f, 
    0.02991917f, -0.03547769f, -0.03900828f, -0.13709855f, -0.49185151f, -0.18618234f, 0.01712298f, -0.10329740f, 
    0.09797752f, -0.00060695f, 0.06480009f, -0.00156763f, -0.04311342f, 0.00122836f, 0.07828059f, 0.01036842f, 
    0.05392972f, 0.11051811f, 0.02683820f, 0.16740231f, 0.26142433f, 0.04315538f, -0.04127683f, 0.11745571f, 
    -0.19656827f, 0.10456287f, 0.02546207f, -0.03581458f, 0.12534818f, 0.14793400f, -0.22052488f, 0.13158600f, 
    0.04039264f, -0.01439415f, -0.04449121f, -0.06514124f, -0.19568591f, -0.04682724f, 0.12270028f, 0.08412508f, 
    0.03854362f, -0.01027152f, -0.03598313f, 0.02389995f, -0.05602008f, 0.06287048f, -0.02681423f, -0.05212626f, 
    -0.00231637f, 0.02293777f, 0.00358366f, 0.05114753f, 0.00353733f, 0.00030533f, -0.06082689f, -0.01809417f, 
    0.02202147f, -0.00507163f, 0.01637870f, -0.00016261f, 0.05397051f, 0.03586172f, 0.00446601f, -0.04427887f, 
    0.06841148f, 0.03301222f, -0.00663278f, -0.06821381f, -0.06814834f, 0.04209220f, -0.01556956f, 0.03595717f, 
    0.01109656f, -0.05557167f, -0.00877253f, -0.06985381f, 0.00358198f, -0.05351452f, -0.02647312f, -0.00617304f, 
    -0.06267746f, 0.04428350f, -0.05316829f, 0.04671503f, 0.06719259f, 0.03302828f, 0.04539215f, 0.00801560f, 
    -0.00458643f, -0.00692103f, -0.06376729f, -0.02798805f, 0.00686601f, -0.06753133f, -0.06752791f, 0.05463510f, 
    -0.03203433f, 0.03313617f, 0.00535280f, -0.02827600f, -0.03198294f, -0.04602092f, 0.05486809f, 0.02910021f, 
    -0.02268515f, 0.01344143f, 0.01842060f, 0.06344516f, -0.04046199f, -0.01204843f, -0.04685759f, -0.03547952f, 
    -0.00082410f, 0.02491938f, 0.01816760f, 0.04607425f, 0.04123522f, 0.03127151f, -0.02020284f, -0.01845271f, 
    0.00683267f, -0.04979719f, 0.03329104f, 0.00113456f, -0.06847713f, -0.04715402f, -0.03166802f, 0.02968019f, 
    -0.02644751f, 0.00272331f, -0.07165830f, 0.03396075f, 0.02120947f, 0.01259402f, 0.03943957f, -0.07667504f, 
    0.00338812f, -0.03347738f, 0.01269927f, -0.02743903f, 0.03405482f, -0.00408803f, -0.02915822f, -0.07267193f, 
    -0.04137732f, 0.06593230f, 0.03354387f, 0.03363871f, 0.06739028f, -0.00650286f, -0.00887829f, -0.03761043f, 
    -0.01967526f, 0.06332224f, 0.06022286f, -0.05323497f, -0.00119327f, -0.00248977f, 0.05087557f, -0.04287337f, 
    -0.00467574f, 0.06380536f, 0.07056307f, -0.02568256f, 0.02125613f, -0.07244183f, -0.05307304f, -0.01048736f, 
    -0.02225819f, -0.05010157f, -0.01477086f, -0.01251893f, -0.04423499f, 0.04123263f, -0.00940940f, -0.05126306f, 
    -0.05650149f, 0.00188655f, -0.02771195f, -0.06708699f, -0.00564326f, 0.03552810f, -0.06703740f, -0.00818773f, 
    0.06362236f, 0.03940907f, -0.02891292f, -0.02217375f, -0.07635888f, -0.03798988f, -0.02953867f, 0.02326309f, 
    -0.01142160f, 0.05577681f, 0.03688134f, -0.02716459f, -0.01661645f, -0.05514990f, -0.05749518f, 0.01260327f, 
    -0.02350258f, -0.06788146f, 0.01085616f, -0.07155574f, -0.02457851f, -0.01031184f, -0.07255054f, -0.04135400f, 
    -0.03251186f, -0.03672397f, 0.00362924f, -0.03239035f, -0.01544276f, -0.07946911f, -0.05218048f, -0.06365632f, 
    0.05801338f, -0.02427701f, 0.03161724f, 0.00296911f, -0.04924150f, 0.04309633f, 0.03580389f, -0.07271031f, 
    -0.05853654f, -0.02866948f, 0.03484435f, -0.03604571f, 0.01881428f, -0.02126326f, 0.05442825f, -0.04456150f, 
    0.04258548f, 0.01498606f, -0.00403535f, 0.05666264f, -0.06526225f, -0.01364461f, -0.03005585f, 0.00936408f, 
    -0.02644733f, -0.02820279f, -0.07025954f, -0.07645645f, 0.05804875f, 0.00394584f, 0.04095682f, 0.05536734f, 
    -0.02367544f, -0.00603204f, -0.01677775f, -0.07551622f, -0.04893262f, 0.05600223f, -0.04260672f, -0.04757389f, 
    -0.03851175f, 0.00789279f, -0.01584892f, -0.04377433f, 0.01562199f, -0.03241935f, -0.03416663f, -0.04163366f, 
    -0.02703556f, 0.02520145f, 0.00927371f, -0.00073594f, 0.05261062f, 0.01993228f, -0.01577043f, -0.06220847f, 
    0.04682504f, -0.02945976f, -0.01141204f, 0.02755927f, -0.05530186f, -0.07706005f, -0.05973210f, 0.06106977f, 
    0.05170988f, 0.04422382f, -0.00343130f, -0.04312487f, -0.03063399f, -0.06300503f, -0.03245904f, -0.04710351f, 
    -0.04950101f, -0.06851278f, -0.07763381f, -0.03947989f, -0.06376696f, -0.01155640f, 0.02414326f, 0.01112908f, 
    -0.05697320f, -0.00921600f, 0.03620869f, 0.03604320f, 0.01853477f, -0.07329057f, -0.07338862f, -0.05542754f, 
    -0.06952289f, -0.07681244f, -0.01162533f, 0.02693515f, -0.05541216f, 0.05857556f, 0.05842575f, 0.06118046f, 
    -0.00198625f, -0.06913665f, -0.04315414f, 0.00219819f, -0.03049821f, 0.02863317f, -0.00518431f, -0.00083498f, 
    -0.07083169f, 0.03655647f, 0.03679950f, -0.03912143f, 0.00088125f, 0.04919022f, -0.00386248f, -0.06890066f, 
    0.01159101f, -0.01132776f, 0.05223503f, -0.04478486f, -0.00212906f, 0.05910432f, -0.07250156f, 0.02743614f, 
    0.01800080f, -0.02203823f, 0.02460203f, 0.03429750f, -0.00416448f, -0.02320615f, -0.07840636f, -0.00453403f, 
    -0.04971061f, 0.04742055f, 0.05879388f, -0.02521171f, -0.07487670f, 0.05184397f, -0.07662224f, 0.03672210f, 
    -0.07238449f, 0.05982297f, -0.00124113f, -0.03927257f, 0.06090445f, -0.04295078f, 0.04101231f, -0.01465411f, 
    0.01531898f, 0.05973221f, 0.04518341f, -0.06298626f, -0.05381407f, 0.00876280f, 0.00251536f, 0.04044678f, 
    -0.07029994f, -0.04964127f, -0.03892822f, -0.07251330f, 0.03210763f, -0.07416543f, -0.06855797f, 0.03227814f, 
    -0.02095487f, 0.03259860f, 0.01976041f, 0.03582839f, -0.07135212f, 0.01911871f, -0.05739218f, -0.06361043f, 
    0.01519029f, -0.06322062f, -0.03196403f, 0.04968263f, 0.06037439f, -0.02755368f, -0.01425371f, 0.02991650f, 
    0.05845803f, 0.04615299f, -0.02162366f, 0.02568042f, 0.01537580f, -0.03568393f, -0.03365865f, 0.01023035f, 
    -0.03845552f, -0.06075794f, -0.06975783f, -0.05662957f, -0.07223895f, 0.01682559f, -0.03229713f, 0.03502052f, 
    -0.07686794f, 0.05104126f, 0.05005822f, 0.03227229f, 0.04272411f, -0.00954851f, -0.02675752f, -0.02906084f, 
    0.05356892f, -0.04782254f, -0.05006840f, 0.00253645f, -0.00902576f, -0.07163889f, -0.02515659f, 0.02826865f, 
    -0.20035183f, 0.17046019f, -0.12601489f, 0.24122372f, -0.02226109f, 0.06779994f, -0.13711840f, 0.12091065f, 
    0.01241314f, -0.01101310f, 0.07036579f, 0.15653440f, 0.04372508f, -0.00863307f, -0.07356130f, 0.11816564f, 
    -0.00110428f, 0.01018087f, -0.02282022f, 0.00765804f, 0.00157715f, 0.09717966f, 0.10914773f, 0.01400140f, 
    -0.06141410f, 0.09981600f, 0.13040034f, -0.20062143f, -0.05826224f, -0.00133425f, 0.08667039f, 0.15921275f, 
    -0.04330390f, -0.07163566f, -0.10314677f, -0.12180004f, 0.37301087f, -0.20543909f, 0.13843350f, 0.23489878f, 
    -0.08092000f, -0.07458252f, -0.02407767f, 0.02942794f, 0.07608408f, -0.01702071f, 0.04988431f, 0.01638284f, 
    0.11209416f, -0.02346434f, 0.13515157f, -0.13339685f, -0.01509608f, -0.00693788f, 0.15900780f, -0.03277094f, 
    0.04859492f, -0.00822287f, 0.07972823f, 0.13812859f, 0.06338987f, 0.14404930f, -0.05356660f, -0.06498863f, 
    0.01847561f, -0.01730958f, 0.03550009f, 0.04351718f, 0.01991850f, 0.01773179f, -0.03330235f, -0.02857250f, 
    0.07162074f, -0.17209353f, -0.05741095f, 0.30272335f, -0.18781187f, -0.06322669f, 0.06938152f, 0.03371677f, 
    0.11682271f, 0.03360371f, 0.06046384f, 0.00947479f, -0.18009475f, -0.29261062f, 0.18025413f, -0.29298362f, 
    0.04090650f, -0.01777767f, 0.09636422f, 0.04969084f, -0.14192094f, 0.05945609f, 0.05723067f, -0.04871496f, 
    0.08744190f, 0.26234147f, -0.20316468f, -0.32944191f, 0.06309974f, 0.10825567f, 0.08109303f, -0.05716352f, 
    0.08217105f, 0.00341929f, -0.10474606f, 0.01032954f, -0.06571011f, -0.27410910f, 0.14193156f, -0.20177615f, 
    0.06613150f, 0.00355331f, 0.04562748f, -0.06755628f, 0.00382859f, 0.04758784f, -0.04103187f, 0.07918776f, 
    0.07134154f, -0.17125008f, 0.13594705f, 0.03582911f, -0.11973824f, -0.00219635f, 0.08509740f, 0.09675423f, 
    0.12881824f, -0.11069872f, 0.04946562f, 0.05870505f, -0.36205581f, 0.28345799f, 0.06719567f, -0.06510826f, 
    -0.12076040f, 0.16427664f, 0.06148558f, 0.03069979f, 0.14696449f, 0.13774921f, -0.00100127f, -0.00236455f, 
    0.10925257f, 0.15425846f, -0.19950013f, 0.08688232f, 0.03578896f, 0.03468068f, -0.03993116f, -0.09025059f, 
    -0.02675476f, -0.03426220f, 0.00940466f, -0.11298493f, -0.01621927f, -0.06809882f, -0.04418683f, 0.09498602f, 
    -0.12506908f, 0.01441295f, 0.09825481f, 0.01210591f, 0.03521554f, 0.05418537f, -0.00236815f, 0.12875566f, 
    -0.14084253f, 0.28258714f, 0.12271857f, -0.07207116f, -0.02965007f, 0.04387728f, -0.01536006f, 0.05270103f, 
    0.09035029f, -0.00548107f, -0.00796951f, 0.04290301f, 0.19979118f, -0.09345748f, 0.01453712f, -0.15226391f, 
    0.11415163f, -0.11724439f, 0.09727471f, -0.06926171f, 0.21285188f, 0.09206368f, -0.01251961f, 0.01005795f, 
    0.33525679f, -0.12124994f, -0.07728397f, -0.05880658f, 0.11767719f, 0.06295013f, -0.03875049f, 0.11452272f, 
    0.11222561f, -0.02551338f, 0.05035948f, 0.11295899f, 0.01939104f, -0.10397384f, 0.08556464f, 0.06183219f, 
    -0.25595516f, 0.04899953f, -0.20831469f, -0.01709579f, 0.02228095f, 0.00444950f, -0.00544862f, -0.01152251f, 
    0.13681273f, -0.04743150f, -0.01634329f, -0.15845834f, 0.09886693f, 0.13598396f, 0.10216386f, 0.11603153f, 
    0.07644439f, -0.00996146f, -0.02535815f, -0.05132093f, -0.08981191f, -0.03614317f, 0.09438049f, -0.18883173f, 
    -0.15215619f, 0.07373646f, -0.09533908f, 0.13586386f, -0.03093250f, 0.08644994f, 0.01019546f, 0.03146312f, 
    0.36850366f, -0.12257625f, -0.14753944f, -0.35120270f, 0.06133224f, 0.13554223f, -0.01226999f, -0.05486785f, 
    0.00858714f, -0.03188539f, 0.07952631f, 0.03398933f, 0.40965420f, 0.21394591f, -0.08570189f, 0.08761752f, 
    0.02705120f, 0.16210119f, 0.01019435f, -0.11436827f, 0.07676562f, 0.15935341f, 0.06077840f, -0.04314422f, 
    -0.03150262f, 0.03835627f, -0.00217230f, -0.00794225f, -0.06275284f, -0.04972462f, 0.00263606f, -0.06635207f, 
    0.02026415f, -0.00967245f, 0.01585864f, -0.02114895f, -0.16039953f, 0.09779672f, 0.10694809f, 0.18812093f, 
    0.08070771f, -0.11112756f, -0.02839630f, 0.20465274f, 0.00602442f, -0.13618363f, -0.01395706f, 0.04617353f, 
    0.07940091f, 0.00450227f, 0.04959006f, 0.05538187f, 0.01298816f, -0.00678056f, 0.07217602f, 0.01881984f, 
    0.02871428f, 0.11543936f, -0.10743561f, -0.00820730f, -0.21150538f, -0.09325126f, 0.31459939f, 0.20193602f, 
    0.03441825f, 0.02533861f, 0.16630071f, 0.00664909f, 0.03200045f, 0.04266858f, -0.02098388f, -0.02519297f, 
    -0.16319114f, 0.16028787f, -0.08269159f, -0.32623461f, -0.03709928f, -0.03859109f, -0.10668439f, -0.11337177f, 
    -0.23334101f, -0.08759125f, -0.05155873f, 0.08723211f, -0.45604542f, 0.08650123f, -0.01342564f, 0.30885923f, 
    0.08258985f, 0.14195397f, -0.11900011f, 0.02072896f, 0.09512674f, 0.11161348f, 0.01007059f, 0.04645031f, 
    0.10676004f, 0.12491972f, -0.04461314f, -0.18555841f, 0.10352858f, -0.06648550f, -0.17429301f, -0.07420221f, 
    0.07953037f, 0.01926935f, -0.05291741f, 0.08754745f, -0.45819435f, -0.05971988f, 0.09527193f, -0.00260519f, 
    0.00587662f, 0.01788849f, 0.09470501f, 0.12717427f, -0.01893232f, 0.00220511f, 0.05580423f, 0.03353484f, 
    0.35509917f, -0.05580691f, -0.09403395f, -0.01208267f, 0.10009567f, -0.07544376f, 0.19161731f, 0.00768958f, 
    0.07901906f, 0.00712180f, 0.05178783f, 0.10797478f, -0.12435178f, 0.02111663f, -0.03321175f, 0.20292926f, 
    0.06414579f, 0.01055317f, 0.00013448f, 0.05440870f, -0.06926981f, 0.09486838f, 0.01698928f, -0.15223284f, 
    -0.01995163f, -0.12651516f, 0.15874138f, 0.18126716f, -0.08317318f, 0.05511998f, 0.00757856f, -0.10152048f, 
    0.13424984f, -0.05382548f, -0.04246062f, 0.10049988f, -0.32021442f, -0.12464510f, 0.18183497f, 0.13294409f, 
    -0.06625734f, -0.08439576f, 0.14673598f, 0.15760767f, -0.04349428f, 0.12627456f, -0.05825652f, -0.31351587f, 
    0.03756312f, 0.09367426f, 0.27985552f, 0.05165810f, 0.10710603f, -0.32973698f, -0.18127853f, -0.37327930f, 
    0.03206104f, 0.27987230f, 0.11137636f, -0.01116739f, 0.06622849f, 0.00243702f, -0.31220546f, -0.09358775f, 
    -0.11333996f, 0.15747604f, 0.09859923f, 0.16676219f, -0.06039241f, -0.05540257f, -0.16102214f, -0.20739579f, 
    -0.10914849f, -0.04432135f, 0.19415058f, 0.07384861f, 0.09674764f, -0.00101336f, -0.24231385f, -0.25945354f, 
    -0.06419483f, 0.19358568f, 0.03353348f, 0.16707195f, -0.17750436f, 0.05868219f, 0.26759815f, 0.16409788f, 
    0.17764178f, -0.09794715f, -0.21636188f, -0.04948436f, -0.04231611f, -0.03490457f, 0.17301272f, 0.27461252f, 
    0.01656988f, 0.02542685f, -0.12941894f, 0.00116498f, -0.06659658f, 0.05383386f, 0.06742097f, 0.03263781f, 
    0.07693136f, -0.09426913f, -0.01041070f, -0.12103915f, 0.18330668f, -0.09145095f, 0.13441056f, -0.34982806f, 
    -0.04050298f, 0.11442452f, -0.09108543f, 0.09702561f, -0.06319944f, 0.07787521f, -0.05390212f, 0.03085458f, 
    -0.17096248f, 0.03178512f, 0.20811813f, -0.05135496f, -0.01717315f, 0.01947135f, -0.01576563f, -0.08172448f, 
    0.02910301f, -0.07524192f, -0.01430799f, 0.00034463f, 0.22535717f, -0.27634722f, 0.06917781f, -0.02147875f, 
    0.11383301f, -0.04024793f, -0.11347634f, 0.18858162f, -0.05212738f, -0.02794402f, -0.14139165f, 0.00197724f, 
    0.14267887f, -0.00558336f, 0.11890230f, 0.22307211f, -0.13770886f, 0.06225248f, -0.03280992f, -0.19212179f, 
    0.10561472f, -0.11839628f, 0.08850019f, -0.08778786f, -0.05208014f, -0.13781340f, -0.13861760f, -0.29667842f, 
    0.15663348f, -0.13638170f, -0.02115412f, 0.12240420f, -0.01723126f, 0.11516815f, -0.14014380f, 0.11717114f, 
    -0.37433219f, 0.00584768f, 0.15330821f, 0.13366458f, -0.01141523f, -0.13887766f, 0.04512452f, -0.03656220f, 
    0.10259876f, 0.04057104f, 0.01105573f, 0.22192279f, -0.17776825f, 0.26348352f, -0.02813165f, -0.11229762f, 
    -0.05610997f, 0.07680332f, 0.06583441f, 0.11740956f, -0.03035471f, 0.03722860f, -0.05537397f, -0.27597117f, 
    -0.21776572f, -0.13835019f, -0.05287834f, -0.20314763f, 0.20713066f, -0.01899865f, 0.13500710f, -0.01990005f, 
    0.01886918f, -0.05257929f, 0.06625886f, 0.03092667f, -0.12032595f, 0.10223949f, -0.01800802f, 0.06933817f, 
    0.09462055f, 0.10445001f, 0.21377647f, 0.09969367f, -0.12442883f, -0.02250119f, -0.12886319f, 0.10230865f, 
    0.06038092f, -0.00547310f, 0.03947589f, -0.12966877f, -0.06056512f, -0.01218464f, -0.00799973f, -0.03394229f, 
    -0.05033276f, 0.05732363f, -0.05561083f, 0.09137394f, -0.03184074f, -0.05535049f, -0.05209320f, -0.03259268f, 
    0.07493321f, -0.10592666f, 0.05181818f, -0.02901753f, -0.04976939f, 0.02711380f, 0.06301018f, -0.04232106f, 
    0.21633549f, -0.15999602f, 0.19326127f, -0.07283641f, 0.06550179f, 0.07308246f, 0.00768605f, 0.03918629f, 
    -0.08498067f, -0.14134395f, -0.09502108f, -0.03594738f, -0.27697450f, 0.14963321f, -0.09818760f, 0.03222556f, 
    -0.02636290f, -0.02461037f, 0.08091684f, -0.07475977f, -0.02069827f, 0.03432787f, 0.02430427f, 0.17997049f, 
    0.25207758f, 0.06790394f, 0.08546399f, 0.17966534f, -0.02857064f, 0.16679762f, -0.03965954f, 0.01906171f, 
    0.04923082f, 0.00206205f, 0.09006789f, -0.02247086f, -0.20806411f, 0.13854270f, 0.03233183f, 0.24124138f, 
    0.14461130f, -0.02363853f, 0.08146615f, 0.09863187f, 0.00860285f, 0.08941308f, 0.14003879f, -0.05987413f, 
    -0.56111872f, -0.15612969f, 0.11739542f, -0.01074832f, -0.07404709f, -0.04457918f, -0.06708848f, -0.05904036f, 
    -0.02041041f, -0.07741123f, 0.11046071f, -0.00407418f, -0.20313726f, -0.17530228f, 0.10827176f, 0.11418025f, 
    0.07027709f, -0.03178920f, -0.16859610f, -0.01375942f, 0.11988658f, 0.00679095f, -0.01803663f, 0.00618704f, 
    0.26113230f, -0.07058161f, 0.02802568f, 0.13869917f, -0.02237749f, -0.03364158f, 0.09829612f, 0.15883268f, 
    0.09306699f, 0.04891003f, 0.02973467f, 0.05171869f, -0.02299303f, -0.28829744f, 0.20183432f, 0.08075071f, 
    -0.08582302f, -0.00215053f, -0.03662954f, 0.05857481f, 0.04150455f, -0.00219654f, -0.07088818f, -0.00230308f, 
    0.07236052f, 0.14820993f, 0.08303826f, 0.03397511f, 0.05916264f, 0.11292201f, -0.00349914f, -0.01771970f, 
    0.15236728f, -0.05854024f, 0.08307208f, 0.02701378f, 0.00931974f, 0.11554703f, 0.00597053f, 0.10903905f, 
    0.12968609f, 0.02980720f, -0.04956495f, 0.09239126f, -0.08603475f, -0.06088972f, -0.06739489f, 0.08376991f, 
    0.22864266f, 0.04888495f, 0.01270576f, 0.01717075f, -0.06600149f, -0.00704713f, -0.02558885f, 0.00899377f, 
    -0.03553652f, -0.08173597f, -0.01891564f, -0.01113212f, -0.58833212f, -0.11532074f, 0.07639597f, -0.17170756f, 
    0.06607306f, -0.04288338f, 0.02594767f, -0.03890815f, -0.01945787f, 0.06479160f, 0.06128709f, 0.07065605f, 
    -0.13263151f, 0.19176115f, -0.03161242f, 0.03475771f, 0.04060452f, 0.02752895f, 0.04387489f, 0.07408222f, 
    -0.00571764f, 0.10860892f, 0.07944941f, -0.17896901f, 0.05055792f, 0.16569372f, -0.09902511f, 0.10803017f, 
    -0.05872473f, 0.04421575f, -0.06941324f, -0.02055312f, -0.06974449f, 0.01041123f, 0.07920349f, -0.04546097f, 
    -0.05616915f, 0.00453587f, -0.06070932f, -0.06643432f, 0.00388011f, -0.03785639f, 0.04791482f, 0.01404837f, 
    -0.05958850f, -0.00974707f, -0.04121323f, -0.03429117f, -0.05077338f, -0.06547207f, -0.04334643f, 0.05760988f, 
    0.04467219f, 0.00684544f, -0.02731309f, -0.03227549f, 0.03760732f, 0.04947920f, -0.07999645f, -0.05034553f, 
    0.06596623f, 0.01196091f, -0.00410600f, -0.03390724f, 0.02181187f, 0.00769538f, 0.03385477f, -0.01689656f, 
    -0.07345213f, -0.06066173f, 0.02851493f, 0.02061609f, 0.00275662f, 0.04029210f, -0.00174456f, -0.04746517f, 
    -0.01879792f, 0.01424665f, -0.06509207f, 0.04832353f, 0.06025132f, 0.01275156f, -0.00084982f, -0.05100425f, 
    -0.03321751f, 0.02241755f, -0.04621679f, -0.02126557f, -0.07941776f, -0.03780498f, -0.02895215f, -0.00688819f, 
    0.00762390f, -0.05221887f, 0.04808472f, 0.03741265f, 0.01486999f, -0.02900586f, -0.03484550f, 0.06003457f, 
    -0.01558353f, -0.03387076f, -0.00458390f, 0.02294316f, -0.03613022f, 0.01345885f, -0.00648358f, 0.00393007f, 
    0.02218677f, 0.03290978f, -0.02608110f, -0.05516580f, -0.00749050f, 0.04026022f, -0.07689882f, 0.01265612f, 
    0.02262936f, -0.05799525f, -0.00740001f, -0.06183082f, -0.02779002f, -0.04160352f, -0.06293147f, -0.01296679f, 
    -0.07560457f, 0.00595697f, -0.03275003f, -0.03798798f, 0.00058964f, -0.00929994f, -0.00514181f, -0.02475504f, 
    -0.01549497f, -0.00468890f, 0.03891921f, -0.00488028f, 0.01004805f, 0.05816192f, -0.02397809f, 0.03571850f, 
    0.03747014f, -0.03097972f, -0.03774682f, -0.00096839f, -0.07481923f, -0.05684965f, -0.06359655f, 0.00327841f, 
    0.03685702f, -0.01435119f, 0.05063121f, -0.06942043f, 0.01636189f, 0.03839291f, 0.03818495f, 0.02127437f, 
    0.06686225f, -0.04517984f, 0.06119261f, 0.05525662f, 0.04158055f, -0.04481308f, -0.07501444f, 0.00670820f, 
    0.05720806f, 0.05381192f, -0.02650224f, -0.01951503f, -0.05049654f, -0.05290792f, 0.01378279f, -0.02427337f, 
    -0.00198844f, 0.04388782f, -0.01563193f, 0.01902706f, -0.02862575f, 0.03092290f, -0.01462514f, 0.02108303f, 
    -0.07577839f, -0.05665970f, -0.07372695f, 0.02151229f, -0.01502499f, -0.01716287f, -0.00234115f, -0.03544612f, 
    -0.02392749f, 0.00655830f, 0.00150084f, -0.06039825f, -0.06874764f, 0.02857097f, 0.00677774f, -0.02169231f, 
    0.02896688f, 0.00676344f, -0.06805775f, 0.01676272f, -0.05856613f, -0.04473363f, 0.02503983f, -0.01553750f, 
    0.00905416f, -0.04952122f, -0.05597627f, -0.06905743f, -0.05638719f, -0.03433125f, -0.05209660f, -0.00861119f, 
    0.03669356f, -0.05572043f, -0.00504109f, -0.01978976f, -0.02402304f, -0.03335688f, 0.03612035f, -0.02958760f, 
    -0.00785044f, -0.07260885f, -0.07157107f, -0.07002275f, -0.03785959f, -0.03230976f, -0.00704380f, 0.00698684f, 
    0.45264137f, -0.05298592f, -0.07816243f, -0.01311495f, -0.10675750f, 0.03243859f, -0.08183345f, -0.02537310f, 
    0.05688500f, -0.04019911f, 0.13198134f, 0.07318709f, 0.20863321f, 0.29848623f, -0.07508089f, 0.02976217f, 
    0.08267744f, 0.05396179f, -0.05054786f, -0.05123155f, 0.06125384f, 0.03859323f, 0.04337875f, 0.03809195f, 
    -0.17505838f, -0.05576225f, 0.00113779f, -0.01264072f, 0.08945950f, 0.07025915f, -0.05673334f, 0.25133312f, 
    -0.04629093f, 0.03107659f, -0.21055554f, 0.02825258f, -0.10456473f, 0.05518537f, -0.05749104f, 0.09089974f, 
    0.07682870f, -0.08377753f, 0.06148037f, -0.05452825f, 0.04294784f, 0.04089629f, 0.04668124f, 0.09154154f, 
    0.05750742f, 0.09997590f, 0.08811074f, -0.11673265f, 0.00709754f, -0.04384238f, -0.01843595f, 0.18390505f, 
    0.06877015f, 0.00017851f, -0.04400494f, 0.04346764f, -0.34023473f, -0.11545397f, 0.08989687f, 0.07740484f, 
    0.08357342f, -0.18179838f, -0.05824425f, 0.00099527f, 0.04109462f, 0.09026831f, 0.03611302f, 0.00266798f, 
    0.01717884f, -0.06114074f, 0.04230408f, 0.09700688f, 0.11498293f, -0.08461430f, 0.00032007f, -0.12461150f, 
    0.07965650f, -0.11596876f, 0.02217824f, -0.06239582f, 0.13860910f, 0.15627752f, 0.30709893f, -0.18587716f, 
    0.05286221f, -0.04370558f, 0.05234208f, -0.06538129f, -0.07408544f, 0.03306132f, -0.08618833f, 0.16245376f, 
    0.42626902f, -0.12740050f, -0.14789966f, -0.08497313f, 0.09887207f, 0.03080777f, -0.01565830f, 0.06025273f, 
    0.02468089f, 0.12836418f, 0.05911965f, -0.05040355f, -0.04622190f, 0.07783560f, 0.02628248f, 0.02948851f, 
    0.01905048f, -0.03839086f, 0.05188109f, 0.11772105f, 0.05484477f, -0.12305825f, -0.02751605f, 0.00543970f, 
    -0.02402257f, -0.20589356f, 0.20648548f, -0.00810685f, 0.00577097f, 0.00441865f, -0.01123153f, 0.24212152f, 
    -0.01159803f, -0.00804967f, 0.21957660f, 0.12605657f, -0.25416976f, -0.18751502f, -0.10965902f, -0.30393904f, 
    0.09758689f, -0.10364661f, 0.03783441f, 0.02581777f, 0.07553408f, -0.02462962f, 0.10527311f, -0.01409007f, 
    0.49101064f, 0.05206385f, 0.03640802f, 0.16074830f, 0.08459765f, 0.07144558f, -0.07956016f, 0.13697864f, 
    0.11500197f, -0.06435975f, 0.02760558f, -0.04455074f, -0.01357296f, -0.21537177f, -0.00651651f, 0.06387577f, 
    0.08377986f, 0.02895040f, 0.01651965f, -0.05490091f, 0.11122037f, 0.01913205f, 0.11311234f, 0.00353872f, 
    -0.11367177f, 0.00442381f, -0.17243730f, -0.17218025f, 0.12652242f, 0.13875291f, -0.07468170f, -0.03900700f, 
    0.06591224f, 0.07491526f, -0.05809248f, -0.09448643f, -0.23180859f, -0.38395232f, 0.03368779f, -0.10198312f, 
    0.11137553f, 0.12938291f, 0.01916751f, 0.14000753f, 0.06452816f, -0.09003285f, -0.01599251f, 0.04170571f, 
    -0.04829968f, 0.04130156f, -0.06144713f, -0.04517095f, -0.01044565f, 0.00804737f, -0.02136520f, -0.04763617f, 
    0.06477480f, -0.04783594f, 0.06525055f, 0.02422365f, 0.04597651f, -0.05509617f, -0.06311239f, 0.00262389f, 
    -0.05374644f, -0.06637723f, -0.03398961f, 0.01335013f, -0.07031453f, -0.02464304f, -0.01878751f, -0.01546848f, 
    -0.06658509f, -0.05392259f, -0.06712760f, 0.05450765f, -0.05266909f, -0.07479051f, -0.05598632f, 0.05547355f, 
    -0.03165141f, -0.01135247f, -0.01360336f, -0.03135705f, -0.05314682f, 0.02991598f, -0.02594201f, -0.05335623f, 
    0.00068370f, 0.00425269f, -0.00636034f, -0.06777888f, 0.02455795f, 0.01284815f, 0.04248129f, 0.05033832f, 
    -0.00643209f, 0.06172515f, -0.01620243f, -0.00820408f, 0.00049550f, 0.03910961f, -0.04432151f, -0.04403272f, 
    0.03913116f, -0.06277130f, -0.05754526f, -0.01648683f, 0.00294648f, -0.03589681f, -0.04189601f, 0.01509755f, 
    -0.02234134f, -0.00856679f, -0.00302247f, 0.01393639f, 0.00768947f, 0.00402157f, 0.01537215f, 0.06374466f, 
    -0.06795214f, -0.07201990f, -0.02805308f, 0.03496148f, 0.04293897f, -0.02678015f, -0.06158310f, 0.05877283f, 
    0.05204422f, -0.06077514f, -0.04387233f, 0.01540466f, -0.03588369f, 0.01343416f, 0.01773860f, -0.05247414f, 
    0.02438942f, 0.02485817f, 0.05171290f, -0.06320310f, 0.01258520f, -0.06926601f, -0.05802620f, -0.01432534f, 
    -0.03765509f, 0.03038841f, 0.06385603f, 0.00756638f, -0.03436888f, -0.04890645f, 0.06249274f, 0.00166389f, 
    -0.05954402f, -0.01348100f, 0.02486984f, -0.00319002f, -0.02970804f, 0.05326942f, -0.00308883f, 0.02128161f, 
    0.02154258f, -0.01898809f, 0.04735639f, -0.00045333f, 0.02270723f, 0.02876168f, 0.00540332f, 0.05757131f, 
    -0.05284165f, 0.04103090f, 0.03564036f, -0.04587899f, -0.04250273f, -0.05163460f, -0.03987860f, -0.00606482f, 
    0.00744784f, 0.02019250f, 0.02012121f, -0.06255104f, 0.07287432f, -0.06290829f, 0.05080865f, -0.06457181f, 
    0.01652266f, -0.03183852f, -0.05999054f, 0.06444623f, 0.02755396f, 0.01853201f, -0.00351283f, 0.04365553f, 
    -0.00520225f, -0.06583257f, 0.01152670f, 0.03083988f, 0.04684174f, 0.07657972f, -0.07046914f, -0.05055793f, 
    0.02171094f, 0.05676983f, -0.07394271f, -0.06866909f, 0.05467201f, 0.01185642f, 0.03893632f, -0.04960571f, 
    0.00927297f, 0.00215645f, -0.04958726f, -0.02701811f, -0.04402040f, -0.04215825f, -0.04117496f, 0.01818562f, 
    0.06146248f, -0.02503156f, -0.06945987f, -0.03398814f, 0.03766336f, -0.06363361f, -0.05609671f, -0.03097864f, 
    -0.05992373f, -0.00721426f, -0.03940354f, -0.02627302f, 0.03702973f, -0.04248669f, 0.02454687f, 0.02423511f, 
    -0.07315671f, 0.01509095f, 0.01433082f, 0.03110911f, -0.02185832f, 0.01374435f, 0.00136786f, 0.05341440f, 
    0.11918397f, -0.03395961f, -0.13395277f, 0.07327010f, -0.03351962f, 0.09011730f, 0.15703350f, 0.11357827f, 
    0.01945527f, -0.12677848f, 0.11321157f, 0.00092513f, 0.07412960f, -0.10006461f, 0.17208730f, -0.06689423f, 
    -0.23294362f, -0.07898603f, -0.07678008f, 0.02609143f, 0.02585964f, -0.02818182f, -0.05205664f, 0.06813949f, 
    0.05569223f, 0.10985918f, -0.11049398f, 0.03669072f, -0.00990438f, 0.12626562f, 0.01091240f, -0.11184723f, 
    -0.00134515f, 0.15689903f, 0.09339975f, 0.02636955f, 0.07588070f, 0.00662668f, 0.09918048f, -0.12544008f, 
    -0.04801525f, -0.01852188f, -0.09716017f, 0.09924860f, 0.02984688f, 0.06905627f, -0.07265609f, 0.04703389f, 
    0.31845120f, -0.10113039f, -0.23085020f, -0.06166928f, 0.01487525f, 0.08144884f, 0.02839920f, -0.04358381f, 
    -0.06189280f, 0.08099236f, 0.09553269f, 0.00397125f, 0.34338176f, 0.04334302f, 0.02300391f, 0.02266666f, 
    -0.09138820f, 0.22617111f, 0.01413782f, 0.01484358f, 0.02461646f, 0.17878880f, 0.06519774f, -0.02324909f, 
    0.35980892f, 0.18243870f, -0.01897239f, -0.18746305f, -0.02481270f, 0.04278900f, -0.02252797f, 0.06760718f, 
    0.01852637f, 0.02970029f, 0.06621140f, 0.12264774f, 0.22928311f, 0.11585857f, -0.14830551f, 0.18083571f, 
    0.09029625f, -0.11058942f, -0.08084723f, 0.03025785f, -0.03208107f, -0.05088730f, 0.00757998f, 0.03260839f, 
    -0.24745654f, 0.00391188f, 0.05776133f, 0.07677516f, 0.05697932f, 0.05455098f, 0.00385665f, -0.05259266f, 
    0.03423541f, 0.03287826f, -0.02676282f, 0.11899821f, -0.18795945f, 0.10121334f, 0.19422509f, 0.09410188f, 
    0.07441437f, -0.01568314f, 0.00855522f, 0.00377728f, 0.01266674f, -0.08734559f, 0.04331857f, -0.04729390f, 
    0.09548797f, 0.03424154f, -0.21823560f, -0.12148145f, 0.03485152f, -0.05115561f, -0.09636445f, -0.16952571f, 
    -0.12516937f, -0.03600481f, -0.05369831f, 0.09017909f, -0.10758352f, -0.09517034f, -0.19856152f, 0.33417392f, 
    0.01632817f, 0.03145737f, -0.02810911f, -0.10056840f, -0.00664898f, 0.11834324f, 0.09583663f, -0.09577292f, 
    -0.30982214f, -0.03693125f, -0.05675754f, -0.13784951f, 0.06074144f, 0.05293486f, -0.05286516f, -0.07761484f, 
    0.06435797f, -0.02832291f, -0.07784759f, -0.00120016f, -0.00736142f, 0.09488150f, 0.15593667f, 0.09339370f, 
    -0.12852253f, -0.02094783f, -0.05747458f, -0.04209200f, 0.01507376f, 0.06217125f, -0.02395442f, -0.02126372f, 
    0.31348890f, -0.18425174f, -0.01502207f, 0.10582675f, -0.09238689f, -0.05459617f, 0.09933221f, -0.00921048f, 
    0.03032588f, -0.04504256f, 0.06950901f, 0.05304368f, -0.20578822f, 0.08266074f, 0.02844060f, 0.16355881f, 
    0.15321551f, -0.07012313f, -0.05361566f, -0.04931071f, -0.06737415f, 0.08820555f, 0.13958278f, -0.04560616f, 
    -0.20596194f, -0.03027515f, 0.11423922f, -0.27051142f, 0.09499940f, -0.00922593f, 0.01268345f, 0.05240541f, 
    0.00526939f, 0.00325419f, 0.01983292f, 0.08481562f, 0.09475665f, 0.17270881f, 0.29783803f, -0.11954728f, 
    -0.08344401f, 0.06332624f, -0.08062591f, -0.02353685f, -0.03757293f, 0.12180695f, 0.09462153f, -0.05791147f, 
    0.25809124f, -0.17928956f, -0.03090170f, 0.24402846f, 0.12081597f, 0.17775200f, -0.00188511f, -0.07496953f, 
    -0.05669025f, 0.14242709f, -0.02834667f, 0.01158686f, 0.01316737f, -0.26354489f, 0.06435421f, 0.08735212f, 
    -0.03449680f, -0.05936468f, 0.15296051f, 0.00339884f, 0.05134092f, -0.07954549f, -0.09197711f, -0.00658111f, 
    -0.18175155f, -0.15774022f, -0.32870802f, -0.17186709f, 0.03422013f, -0.11140210f, -0.06646797f, 0.04683601f, 
    0.00889442f, 0.14310606f, 0.08081324f, 0.05719027f, -0.50472564f, -0.03012422f, -0.14110470f, -0.19965270f, 
    0.01095514f, 0.07729389f, 0.08752766f, 0.10722578f, -0.04021136f, -0.07925709f, -0.01606379f, -0.15291718f, 
    0.01215929f, 0.04030935f, 0.16744776f, 0.17271431f, -0.04374679f, 0.16812983f, 0.13644746f, -0.16253424f, 
    0.07574589f, -0.23967385f, 0.08328388f, 0.05203134f, -0.21071857f, -0.12541120f, -0.02380584f, 0.14091222f, 
    0.05964673f, -0.05789472f, 0.07610689f, -0.00467093f, 0.07070734f, 0.02261818f, -0.16181158f, -0.07790829f, 
    -0.46320501f, 0.16015844f, -0.18245535f, -0.09990440f, 0.06914338f, -0.04485517f, 0.11982483f, 0.03659179f, 
    -0.02279968f, 0.06577203f, -0.03083885f, -0.01894259f, 0.14468087f, -0.29666823f, 0.09819063f, -0.02973113f, 
    0.07652340f, 0.02708892f, 0.03782229f, -0.13728154f, 0.01106046f, -0.08696036f, 0.03479722f, 0.01834748f, 
    -0.19105434f, 0.02724722f, -0.25680348f, 0.38641697f, 0.13231531f, -0.01674521f, 0.00477262f, 0.07361823f, 
    -0.01931451f, -0.10970183f, 0.14017251f, 0.14102384f, -0.22569531f, -0.03509788f, -0.06161828f, 0.23451346f, 
    0.07045898f, -0.16755956f, 0.05350926f, 0.20159164f, -0.06424177f, 0.13635911f, -0.12287766f, -0.06331921f, 
    -0.12513700f, 0.09945589f, -0.16762348f, -0.27752480f, 0.03797625f, 0.08709585f, -0.01581578f, -0.09289894f, 
    -0.09064420f, -0.10443713f, -0.00331283f, -0.11994472f, 0.09734650f, 0.12015502f, 0.20986317f, 0.19537078f, 
    0.01710851f, 0.16934696f, 0.08534971f, -0.10329437f, -0.06500439f, 0.11246698f, 0.09737558f, 0.09363724f, 
    0.20141955f, 0.01259352f, 0.19382675f, 0.30854023f, -0.10699842f, 0.04205101f, 0.07530449f, 0.03446888f, 
    -0.08355749f, 0.09050795f, 0.13936211f, 0.19040221f, 0.23000240f, 0.17348246f, 0.24058998f, 0.19929194f, 
    -0.02964290f, -0.06780770f, 0.09653498f, 0.05412743f, -0.00920781f, 0.14123486f, -0.01071665f, -0.01462872f, 
    0.02493804f, -0.05118589f, -0.00237301f, 0.03164018f, -0.06508412f, -0.06606464f, -0.04434854f, -0.01845697f, 
    0.05282851f, -0.02034900f, 0.05111320f, -0.07165187f, -0.06808732f, -0.05839149f, 0.06204982f, -0.06075308f, 
    -0.00539775f, -0.03764252f, 0.04181163f, -0.00335132f, 0.03578446f, 0.04278982f, -0.03579371f, -0.01782145f, 
    0.00753168f, 0.03772154f, -0.07738176f, -0.04422255f, 0.06395008f, 0.02189447f, -0.02291065f, 0.02848598f, 
    0.04950090f, -0.05208138f, -0.06530999f, -0.07539327f, -0.03359718f, -0.06126153f, -0.01749896f, -0.00999811f, 
    -0.00860614f, -0.06257644f, 0.01537767f, 0.01735397f, -0.02103527f, -0.05752359f, 0.05404014f, 0.02050585f, 
    0.06270123f, 0.01738010f, -0.07486515f, 0.01058450f, 0.04282028f, -0.01809717f, -0.00898400f, -0.01153194f, 
    -0.07074494f, 0.02542734f, -0.03427009f, -0.05913378f, 0.01828906f, -0.05502166f, -0.07363170f, 0.03255970f, 
    0.01979453f, -0.06586235f, 0.00195005f, 0.06100680f, -0.06877382f, -0.00568492f, -0.05197277f, 0.02833145f, 
    -0.05992778f, 0.01722676f, -0.00799713f, 0.06223757f, 0.00234125f, -0.05797599f, 0.00384380f, 0.04206643f, 
    0.00491668f, -0.04256885f, 0.05803320f, 0.04612844f, -0.05760990f, 0.06472753f, -0.05075999f, 0.04910427f, 
    0.02286596f, -0.00554000f, -0.07280491f, -0.01915487f, -0.04407771f, -0.04480838f, -0.07332408f, 0.04549636f, 
    -0.02811445f, -0.06494230f, -0.02085489f, 0.01409232f, -0.02343841f, 0.00642004f, -0.07502016f, -0.01434788f, 
    -0.02718548f, 0.05140765f, -0.07196487f, 0.02176208f, 0.03397175f, -0.06094400f, 0.04773452f, 0.04971594f, 
    0.05806988f, 0.00189303f, 0.01038228f, -0.05280913f, -0.00103165f, -0.07383572f, -0.00815591f, -0.05227135f, 
    -0.06457983f, -0.05548308f, 0.03952583f, -0.07264171f, -0.00731370f, -0.06965280f, -0.06652030f, -0.05175106f, 
    0.00663138f, -0.01740191f, 0.00794410f, 0.02200586f, -0.06312363f, -0.03736725f, -0.01251331f, -0.05362875f, 
    -0.00976290f, 0.04731530f, 0.02849861f, 0.00327544f, -0.01883490f, 0.02873685f, -0.01229097f, -0.05000532f, 
    0.06413865f, -0.00875602f, 0.00903892f, -0.05322662f, -0.00624818f, 0.01643279f, -0.01211798f, 0.04621297f, 
    -0.06975507f, -0.00567050f, -0.01169292f, 0.00068837f, -0.04073891f, -0.02164306f, 0.03437601f, -0.00502521f, 
    0.02062286f, -0.05129071f, -0.05404958f, -0.02272334f, -0.07347958f, -0.06630014f, -0.07573449f, -0.05264815f, 
    -0.06282212f, 0.01055382f, 0.05543538f, 0.02032660f, 0.06273472f, -0.01116404f, -0.04445018f, 0.06574116f, 
    0.03050091f, 0.06358533f, -0.00029832f, 0.00440743f, 0.05005177f, 0.04438251f, -0.00347512f, -0.01717990f, 
    0.05517606f, -0.07389577f, 0.05028065f, -0.07594594f, -0.05690913f, 0.00699016f, 0.01341474f, -0.06389285f, 
    0.40869570f, -0.08872581f, 0.16926479f, -0.11782552f, 0.05498140f, 0.09146591f, -0.01597198f, -0.03562872f, 
    -0.06427266f, -0.00427623f, -0.02958903f, -0.12496558f, -0.17962408f, -0.12761565f, 0.09609200f, -0.22650072f, 
    -0.04082267f, -0.00899425f, 0.06426080f, -0.04650937f, 0.10108696f, 0.01502339f, -0.02089981f, -0.00597852f, 
    0.12524985f, 0.19937950f, -0.09645485f, 0.19867688f, 0.15179347f, -0.00103266f, 0.13602589f, -0.00553842f, 
    0.17240494f, 0.15403032f, 0.13003102f, 0.07018837f, -0.13764204f, 0.18654817f, 0.00581254f, -0.17548905f, 
    -0.01118660f, 0.00968942f, -0.04539229f, -0.01975567f, -0.12759820f, 0.00910713f, 0.01520197f, -0.02149282f, 
    0.07796875f, 0.00247159f, 0.20094547f, 0.24676353f, -0.03164603f, 0.10010527f, 0.03979354f, -0.00366306f, 
    -0.04295799f, -0.04732132f, -0.02729919f, -0.06980035f, 0.41124898f, 0.30671072f, 0.15528034f, 0.16326533f, 
    -0.00128529f, 0.09276780f, 0.00147029f, 0.05003778f, -0.09460776f, -0.06178712f, 0.05852891f, 0.00155488f, 
    0.10270940f, 0.15607582f, -0.10066726f, -0.12394334f, -0.06162843f, 0.13864353f, -0.02468676f, -0.03429647f, 
    -0.11455465f, 0.12709145f, 0.04674032f, 0.11153451f, -0.11992344f, 0.10097956f, -0.20248003f, 0.25308576f, 
    -0.06654277f, -0.00249870f, -0.02496545f, 0.06548432f, 0.05792858f, -0.01884963f, 0.11819869f, -0.03799130f, 
    -0.19211870f, -0.09829316f, 0.10974230f, 0.30384791f, 0.03471245f, 0.04798234f, -0.05284369f, 0.06930427f, 
    -0.03970737f, -0.00348970f, 0.00626087f, 0.13603824f, -0.06030522f, 0.44028521f, -0.14950930f, 0.09644061f, 
    -0.00700771f, -0.02868626f, -0.01457371f, 0.04658170f, -0.08011959f, 0.14521582f, 0.11542447f, -0.04276115f, 
    -0.03472177f, 0.06644391f, -0.00721367f, -0.01454104f, 0.02563087f, 0.03384120f, -0.06460739f, -0.07337560f, 
    -0.06351072f, 0.07039649f, 0.02031715f, -0.08435851f, 0.36464489f, -0.04334179f, -0.08364347f, 0.09827276f, 
    0.05924170f, 0.04731494f, -0.17168429f, -0.02786054f, -0.13534132f, -0.11775345f, -0.02284143f, 0.09754107f, 
    0.04990442f, 0.02694926f, 0.05653428f, -0.04798596f, -0.05602802f, -0.00954651f, 0.18541346f, -0.05287576f, 
    -0.00588039f, 0.13629223f, 0.00205618f, 0.11572420f, -0.10105214f, 0.04554062f, -0.02050542f, -0.13764299f, 
    0.05202160f, 0.04220080f, -0.05324006f, -0.04289759f, -0.15040326f, -0.08554524f, -0.02892967f, -0.01613257f, 
    0.16679631f, -0.03070846f, -0.07824266f, 0.21744622f, -0.00861504f, -0.04097549f, 0.01828089f, 0.06031553f, 
    -0.13415232f, -0.09322499f, -0.10404716f, -0.02832518f, 0.02225491f, 0.18010369f, -0.04157072f, 0.13897187f, 
    -0.00925935f, -0.03839476f, -0.13977365f, -0.03502443f, -0.11688074f, -0.04937856f, 0.02783710f, 0.10587964f, 
    -0.02690285f, 0.01930859f, -0.02872327f, 0.04099803f, 0.01829267f, -0.02571658f, 0.02386223f, -0.02369421f, 
    0.03846125f, -0.00536259f, -0.07175946f, 0.03933203f, 0.01447289f, 0.02538598f, -0.02947036f, -0.00721594f, 
    0.05633514f, -0.00540546f, 0.00621251f, 0.04463332f, -0.02473916f, 0.03533003f, -0.00935606f, 0.00736939f, 
    -0.06337229f, -0.03117729f, -0.00101486f, -0.03742554f, -0.00447165f, -0.02546307f, -0.02362612f, 0.02375074f, 
    -0.04439389f, -0.06482295f, -0.05056249f, -0.00858412f, 0.03513573f, -0.01326599f, -0.07168813f, 0.01444825f, 
    -0.05200346f, 0.00434887f, 0.05244560f, 0.05018521f, -0.04502361f, 0.04941269f, -0.07774422f, -0.04215045f, 
    -0.02228670f, 0.02397649f, -0.04276963f, -0.03614097f, -0.07435597f, 0.04264793f, -0.03063863f, -0.00163705f, 
    0.00209635f, -0.04884541f, -0.06469199f, -0.03826293f, -0.02635035f, 0.05223545f, 0.03230809f, 0.01570027f, 
    0.01894852f, -0.02819294f, -0.07884647f, -0.04412472f, 0.01959936f, -0.07150651f, 0.02771340f, 0.00421026f, 
    0.04991629f, -0.04303696f, -0.04179507f, 0.05758753f, 0.05213427f, 0.05782050f, 0.01736758f, -0.06605604f, 
    0.04665390f, -0.07204809f, 0.03826472f, 0.01983694f, -0.06151146f, 0.03463390f, -0.05162526f, -0.06167476f, 
    -0.06157790f, 0.00457254f, -0.01327953f, -0.08444208f, 0.04041947f, 0.02072220f, 0.02024312f, -0.00261854f, 
    0.05935712f, -0.06820662f, 0.03816200f, -0.04187367f, 0.06001423f, -0.05935236f, -0.08486031f, -0.06093840f, 
    0.05181727f, 0.01025180f, 0.05486217f, -0.02564205f, -0.01296740f, -0.06872347f, -0.05545329f, -0.07142247f, 
    -0.05033875f, -0.03889109f, -0.02381800f, -0.06964444f, -0.05710778f, 0.03434517f, 0.00257823f, 0.00644294f, 
    -0.03592112f, -0.03662484f, -0.03710152f, -0.04455562f, 0.05346895f, -0.05384470f, -0.05968481f, 0.03588675f, 
    -0.03853492f, 0.01741344f, -0.02488542f, 0.01542482f, 0.01543088f, 0.02907125f, -0.05457007f, 0.04234255f, 
    0.01795284f, 0.04476289f, -0.06456223f, 0.04959037f, -0.02455301f, 0.00589511f, 0.04013480f, 0.01308088f, 
    0.00032704f, 0.00588106f, 0.02110266f, -0.04760535f, -0.03252178f, 0.05455518f, 0.01738939f, -0.04940542f, 
    0.04243835f, 0.03549570f, 0.01062292f, 0.04515853f, -0.06212277f, -0.01544350f, -0.07277931f, 0.04542369f, 
    -0.08576027f, -0.06546444f, -0.06894956f, -0.06704682f, -0.05269816f, -0.07541848f, -0.05646966f, 0.04803485f, 
    0.02569174f, -0.03009146f, 0.00892969f, -0.00127556f, 0.00768387f, 0.00191376f, 0.05495756f, 0.05307719f, 
    0.02093573f, 0.01078511f, 0.02245917f, -0.00364493f, 0.01206618f, -0.00655616f, 0.04416730f, -0.05546936f, 
    0.03294003f, -0.05862380f, -0.01527297f, -0.07073551f, -0.04483333f, -0.00509076f, 0.02206820f, -0.00761917f, 
    0.20116852f, 0.09970761f, -0.05406867f, 0.02196751f, -0.04671662f, -0.00982356f, -0.08101501f, 0.01177954f, 
    -0.01328098f, 0.02344971f, -0.04784449f, 0.04430483f, -0.13812385f, -0.01099512f, -0.18859503f, -0.07679725f, 
    0.09839290f, -0.13499704f, 0.01069840f, -0.02070247f, -0.04101969f, -0.07322736f, 0.09681451f, 0.01944203f, 
    0.01074820f, 0.16411352f, 0.10659951f, 0.00121327f, -0.02605080f, 0.10760810f, 0.00305386f, 0.07244721f, 
    -0.01461991f, 0.00392842f, -0.04557762f, -0.02568494f, -0.04426021f, 0.04052707f, 0.01285042f, 0.21787283f, 
    0.16162087f, 0.06774063f, 0.10067380f, 0.07789721f, 0.00874457f, -0.06611598f, -0.01232825f, -0.02666639f, 
    0.07993636f, 0.08692009f, 0.26315078f, 0.22458166f, -0.19140510f, -0.03151841f, 0.02876439f, 0.02450716f, 
    0.01556164f, 0.04469300f, -0.01031541f, 0.05716186f, 0.47960961f, 0.20038560f, -0.06553777f, 0.05736112f, 
    -0.12187422f, -0.03460940f, 0.02259900f, 0.12786245f, -0.05216923f, -0.05030741f, -0.06681580f, 0.09602077f, 
    -0.16055703f, -0.16301690f, -0.05330409f, 0.22327067f, 0.04755405f, 0.06223541f, -0.08437619f, 0.05188864f, 
    0.01473369f, 0.12592387f, 0.05944350f, -0.04528242f, -0.36193913f, -0.17391108f, 0.10926069f, -0.08994949f, 
    0.12926462f, 0.07107192f, 0.06625328f, 0.00763315f, -0.01045288f, 0.10000080f, 0.10399336f, 0.05784976f, 
    0.16817161f, 0.11621387f, 0.00462121f, 0.03848999f, -0.04966738f, -0.02172927f, 0.04357248f, 0.03556978f, 
    0.05699079f, 0.06511958f, 0.10583699f, 0.11751676f, -0.24288611f, -0.03432447f, -0.08923492f, -0.12366573f, 
    -0.05772645f, 0.02801062f, -0.00069920f, -0.01180170f, -0.02114599f, 0.05675184f, 0.05638359f, -0.05364246f, 
    0.23343581f, 0.06649392f, 0.17312095f, -0.02859696f, -0.04153058f, 0.04342292f, 0.02440685f, 0.09660783f, 
    0.11060684f, 0.00133217f, 0.13911475f, -0.07671285f, 0.20229822f, 0.14649002f, 0.07371439f, -0.04499145f, 
    0.00463134f, 0.14133345f, -0.01420731f, -0.00757022f, 0.06887031f, -0.02912831f, -0.05245655f, 0.05938277f, 
    0.26908645f, 0.18643188f, -0.05211072f, 0.15425055f, 0.01667697f, -0.07465409f, 0.01766377f, 0.03287063f, 
    0.02233976f, 0.02151482f, -0.05786927f, 0.02066596f, -0.17827168f, -0.13640723f, -0.11101191f, 0.03206364f, 
    0.12252236f, -0.02886403f, -0.05409738f, 0.07011347f, 0.07358471f, 0.02670000f, -0.05948173f, -0.02745831f, 
    -0.15337613f, 0.25375229f, -0.08328603f, 0.10590515f, 0.13182192f, -0.02474998f, -0.04078766f, 0.02707763f, 
    0.02151438f, 0.02592122f, -0.02309784f, -0.05079192f, 0.24704696f, 0.08291714f, -0.24053210f, -0.12255286f, 
    0.05030056f, -0.11658516f, -0.00183730f, -0.06022913f, -0.00598695f, -0.07941355f, -0.02865195f, 0.03992232f, 
    -0.43068656f, 0.09133507f, -0.09514336f, 0.12341224f, 0.06166280f, -0.04223493f, 0.05922175f, -0.07042668f, 
    0.05671667f, 0.01687747f, 0.05846354f, -0.05994480f, 0.24765506f, 0.18255952f, -0.05754631f, 0.13586445f, 
    0.12006478f, 0.01037981f, -0.01335038f, 0.07443231f, 0.00110059f, 0.08390207f, 0.04237754f, -0.06175046f, 
    -0.14815466f, 0.05687641f, 0.09069029f, -0.06718525f, -0.03848916f, 0.01811236f, -0.05527236f, 0.00286709f, 
    -0.06290307f, 0.03264956f, 0.06150051f, 0.00864738f, 0.32391116f, -0.04125947f, 0.10449181f, 0.25788873f, 
    0.02661952f, 0.04697816f, 0.04787145f, -0.02921805f, 0.09415905f, -0.12168735f, 0.05420062f, -0.04790131f, 
    -0.28958750f, 0.23694919f, 0.00760875f, 0.00015954f, 0.06089647f, -0.07119950f, 0.01471023f, 0.06454176f, 
    0.04553417f, 0.06307770f, -0.08038714f, 0.07288465f, -0.02392913f, -0.14993523f, 0.10747843f, -0.18200096f, 
    -0.05874275f, -0.04135425f, -0.01778553f, -0.00659860f, 0.08280444f, -0.04357004f, -0.12349924f, -0.05102861f, 
    0.18414295f, -0.06097478f, 0.00801619f, 0.19298607f, 0.05752993f, -0.01892021f, 0.00649961f, 0.05558610f, 
    0.06164011f, -0.03791453f, -0.05016557f, 0.01792625f, 0.12385178f, 0.22631188f, 0.07034238f, -0.34761614f, 
    -0.09906923f, 0.11238874f, 0.21187526f, -0.03795239f, 0.07657172f, 0.02008335f, 0.00240355f, 0.03357754f, 
    -0.15456337f, 0.14340132f, 0.01529279f, -0.15710205f, -0.04617120f, 0.02746995f, 0.04647583f, -0.00803873f, 
    0.02565231f, -0.03634068f, 0.13691646f, -0.01575678f, 0.20289439f, 0.01131074f, -0.06872188f, -0.20348477f, 
    0.03979785f, 0.00479097f, -0.09714415f, -0.13716389f, 0.00755486f, -0.03774447f, -0.01716147f, -0.05350677f, 
    -0.17990947f, -0.13393544f, 0.07422823f, 0.06393102f, -0.00385528f, -0.11428034f, 0.15264386f, 0.01866231f, 
    0.13850792f, -0.01103241f, 0.01820243f, 0.14365326f, 0.21611579f, 0.07808059f, 0.15745696f, -0.32520375f, 
    -0.06549058f, -0.01942807f, 0.13003150f, 0.00593124f, 0.08867954f, -0.02545335f, -0.11890841f, 0.04596469f, 
    0.08318403f, 0.04150498f, 0.09450869f, 0.23303236f, 0.07212318f, 0.15451421f, 0.08614479f, 0.05762635f, 
    0.01937664f, -0.00696329f, 0.13890243f, -0.10709962f, 0.45365995f, -0.06230109f, 0.10702020f, 0.25001565f, 
    0.06818458f, 0.06896215f, -0.10241240f, -0.02672368f, 0.09296832f, 0.08376477f, -0.09868552f, -0.04247602f, 
    -0.30110583f, -0.00616974f, 0.12000878f, -0.02821254f, -0.03868074f, 0.03277236f, -0.11526389f, 0.01436624f, 
    0.09193483f, 0.01939959f, 0.03602676f, 0.09971447f, 0.14797987f, -0.09832445f, 0.15780064f, -0.18888111f, 
    -0.06985097f, 0.00635904f, 0.06117588f, -0.10837364f, 0.24519871f, 0.13900191f, -0.06178706f, -0.00023122f, 
    0.24023892f, 0.05938555f, -0.13037173f, -0.06361283f, -0.06252876f, 0.16499208f, 0.05360561f, 0.10786038f, 
    0.00772149f, 0.00392277f, 0.07960989f, 0.04236598f, 0.10619878f, 0.06636258f, 0.21727078f, 0.08533569f, 
    -0.06796870f, 0.03195668f, -0.08062080f, 0.03544692f, 0.08754400f, 0.14658618f, -0.01086706f, -0.00486936f, 
    0.02712617f, -0.22009887f, -0.05738178f, 0.11225179f, 0.00131936f, 0.09418845f, -0.05740703f, -0.02209452f, 
    -0.01291570f, 0.05852035f, -0.01138314f, -0.02826605f, -0.13214846f, -0.06316184f, 0.01346493f, -0.15123647f, 
    0.08761233f, -0.04981959f, 0.06293998f, -0.01867584f, 0.15700886f, 0.16069466f, -0.01591722f, 0.13794482f, 
    -0.03749249f, -0.06185805f, -0.07431915f, -0.09465747f, 0.08706710f, -0.07573797f, -0.06100035f, 0.08665465f, 
    0.04382545f, -0.02149047f, 0.01017593f, 0.02492181f, -0.30375972f, -0.20533781f, -0.02119173f, 0.01624573f, 
    -0.03197927f, 0.00409808f, -0.00562606f, -0.04163614f, -0.01140820f, 0.09657849f, 0.11683256f, 0.05305317f, 
    0.14645608f, 0.21724170f, 0.24058001f, -0.11326463f, 0.04303398f, 0.04853857f, 0.00541786f, 0.04064276f, 
    0.05886226f, -0.06817758f, 0.08580019f, 0.17896976f, 0.04857391f, 0.03442472f, 0.18271460f, 0.17232355f, 
    0.02670964f, 0.05261570f, 0.07761374f, -0.10862656f, -0.02781816f, -0.05495504f, -0.09576655f, -0.03946384f, 
    -0.04720976f, 0.02587168f, -0.13934216f, 0.01220321f, 0.01901162f, 0.03021640f, 0.13375422f, 0.03338940f, 
    0.07465755f, 0.03402403f, 0.00831487f, -0.07855684f, -0.09218877f, -0.07554261f, 0.17004862f, 0.09508473f, 
    0.03906865f, 0.02606489f, 0.06013642f, -0.00578614f, 0.07645464f, -0.16622113f, 0.01816897f, 0.02107653f, 
    -0.08020637f, -0.17519978f, -0.03663637f, 0.10888885f, -0.04795427f, 0.12036527f, 0.00820659f, 0.09485406f, 
    -0.08343067f, 0.02488270f, -0.00946684f, 0.05900444f, -0.40504304f, -0.15856892f, -0.26744661f, -0.02167206f, 
    -0.12127475f, -0.02315191f, 0.01241344f, 0.12220196f, 0.00160593f, 0.11999007f, 0.11268664f, 0.01838787f, 
    0.01063440f, -0.02516050f, 0.10773002f, -0.00476155f, -0.00268957f, 0.03110159f, 0.05488616f, 0.04779494f, 
    0.09480312f, -0.06920037f, 0.04392682f, -0.04626893f, 0.05596764f, 0.06551892f, 0.26404393f, 0.05838611f, 
    -0.01244302f, 0.08271048f, 0.11291000f, 0.12896237f, 0.05731788f, 0.12170045f, 0.17730698f, 0.09197570f, 
    0.20944743f, -0.03592738f, 0.07092949f, -0.01739586f, -0.02287761f, 0.15886454f, 0.14291702f, 0.00135873f, 
    -0.04296590f, 0.03636429f, 0.06200431f, 0.14631374f, -0.17385620f, -0.24993750f, 0.05213003f, 0.01042644f, 
    0.09676540f, 0.08938034f, 0.04740649f, 0.07311586f, 0.08029295f, 0.01010809f, -0.05568359f, -0.11373547f, 
    -0.04192629f, -0.07888339f, -0.01882253f, 0.05123432f, 0.01148702f, 0.05926705f, -0.04224825f, -0.03204271f, 
    -0.00591391f, 0.03650698f, -0.00007659f, -0.01540892f, -0.07979111f, -0.04029898f, 0.02979372f, -0.00662333f, 
    -0.01411104f, 0.04784487f, -0.04580583f, 0.01403724f, 0.04371351f, -0.02204697f, -0.07225213f, -0.04470797f, 
    -0.07278552f, 0.01883849f, -0.00708112f, 0.05182532f, 0.05317094f, 0.01376189f, -0.00605804f, -0.02212400f, 
    0.01230628f, -0.05730757f, 0.01678755f, -0.07786267f, -0.01949372f, -0.04817175f, -0.02578421f, 0.00130714f, 
    0.05429477f, 0.05556813f, 0.00449514f, 0.02782997f, -0.07360268f, -0.06579278f, -0.06138815f, 0.06352168f, 
    -0.02424049f, 0.01697773f, -0.07288396f, -0.04789561f, -0.04029744f, -0.01805569f, 0.03505306f, 0.00164117f, 
    0.06362934f, 0.02156072f, 0.02183278f, -0.00949632f, -0.02737949f, -0.06197379f, 0.02322196f, -0.02208574f, 
    0.02461340f, 0.02489863f, 0.00230324f, -0.04904805f, -0.01353973f, -0.05750810f, 0.05472292f, -0.01101775f, 
    -0.04141451f, -0.07767823f, -0.07874341f, 0.05670562f, -0.02709694f, 0.05750978f, -0.04119886f, -0.02142501f, 
    -0.05297934f, -0.01879312f, -0.06347821f, -0.03930293f, -0.06638940f, 0.03275110f, -0.03316366f, 0.02006334f, 
    -0.03573547f, 0.02468020f, 0.02183841f, -0.06234216f, -0.06835712f, -0.02258560f, 0.03394681f, -0.01048778f, 
    -0.03243404f, -0.00016367f, -0.07224282f, 0.05720956f, -0.04058513f, -0.01788720f, 0.06307361f, -0.02967132f, 
    -0.00596625f, -0.04923255f, -0.05098698f, 0.01509009f, 0.00093486f, 0.05267978f, 0.04861080f, 0.05917993f, 
    -0.07805175f, -0.05912601f, -0.05373992f, -0.01788655f, 0.00602089f, 0.04367365f, -0.07140911f, -0.04886481f, 
    0.02991687f, -0.05551734f, -0.06855670f, -0.05248942f, -0.01961790f, -0.07112682f, 0.04882421f, -0.04699560f, 
    -0.04776373f, -0.02407311f, 0.01396973f, -0.04223284f, 0.04798086f, -0.06648522f, -0.01136388f, 0.00831429f, 
    0.03084045f, -0.04157238f, -0.03057135f, 0.04357575f, 0.02402332f, -0.07948864f, 0.05807416f, 0.03552595f, 
    -0.01849205f, -0.00362637f, 0.05370246f, -0.06936332f, 0.04595290f, -0.02441853f, -0.07836779f, -0.02591430f, 
    -0.02234541f, -0.04196522f, -0.07030933f, -0.03092058f, -0.01190111f, -0.03822130f, -0.01273446f, 0.03494396f, 
    0.03868003f, -0.02276364f, -0.02432694f, -0.01151775f, 0.02711911f, 0.02462171f, 0.01549012f, 0.00759333f, 
    0.04757306f, -0.04998746f, -0.07783405f, -0.04637297f, -0.00912977f, 0.03991071f, 0.02521147f, -0.03159634f, 
    0.05523950f, 0.00375367f, 0.00012181f, 0.01847626f, -0.00549867f, -0.04025291f, 0.01826514f, -0.01540208f, 
    0.05259342f, 0.05791130f, -0.03195051f, 0.03878710f, 0.02643899f, 0.04626781f, -0.06612018f, 0.03183734f, 
    -0.08367668f, 0.09374837f, -0.05415180f, 0.00721086f, 0.08881871f, 0.08035886f, -0.23947401f, -0.02043738f, 
    0.07670064f, -0.00806305f, -0.03527452f, -0.06382637f, -0.07030392f, -0.02788803f, 0.01728015f, 0.11151282f, 
    0.00763257f, 0.01599162f, 0.07403088f, 0.04165839f, -0.04931049f, -0.00892296f, -0.02284442f, -0.00079292f, 
    0.09236681f, 0.11620562f, 0.04557614f, -0.06862344f, 0.12934458f, 0.00093842f, 0.16753797f, 0.11361836f, 
    0.00417371f, -0.10185201f, -0.00504885f, -0.05820077f, 0.27929011f, -0.15238051f, 0.17381814f, 0.12144152f, 
    -0.16295752f, -0.04554033f, 0.03799818f, 0.05060901f, -0.07266762f, -0.02556135f, 0.07817322f, -0.06314589f, 
    -0.02037081f, -0.03045061f, -0.00404841f, -0.18046495f, 0.09699249f, -0.00426095f, 0.14948601f, 0.04028784f, 
    0.04980769f, -0.02007309f, -0.01811257f, 0.20720753f, 0.24257497f, 0.20763557f, -0.07374715f, 0.01906689f, 
    0.01656193f, 0.03593621f, -0.00758945f, 0.02168896f, 0.08901987f, -0.04071952f, 0.06496882f, 0.10287699f, 
    -0.17424820f, -0.06245313f, -0.03596198f, 0.16343391f, -0.14324270f, -0.06764454f, -0.07811541f, 0.05473936f, 
    -0.02059702f, 0.13199139f, -0.03854746f, -0.09438845f, -0.39024785f, -0.16775079f, 0.32173365f, -0.19236448f, 
    0.05174302f, -0.03311389f, 0.19943887f, 0.14410105f, -0.10865903f, 0.01428189f, 0.07021192f, -0.07835713f, 
    0.29553407f, 0.12866911f, -0.09276803f, -0.15251793f, 0.09128068f, -0.13514689f, -0.06252892f, 0.03638544f, 
    0.12097505f, 0.07739712f, 0.00689640f, 0.07522348f, 0.18826351f, -0.16126776f, 0.24625893f, -0.10813443f, 
    0.01757916f, 0.09581296f, 0.00181454f, 0.05797821f, -0.07649569f, -0.03031985f, -0.02064358f, 0.05785046f, 
    0.01726564f, -0.14643416f, 0.23513667f, -0.06776628f, -0.13072829f, 0.06303817f, 0.09808748f, 0.15636337f, 
    0.00252139f, -0.04658205f, 0.10580160f, -0.13356574f, -0.39765024f, 0.19406272f, 0.25347921f, 0.06821683f, 
    -0.07644882f, 0.05789241f, -0.12513490f, -0.03416855f, -0.04337211f, 0.05574131f, 0.02585885f, 0.09873375f, 
    0.15546452f, 0.22479200f, -0.15292694f, -0.08744743f, 0.15745534f, 0.00193891f, -0.05792811f, -0.02640096f, 
    -0.06781720f, -0.11500102f, 0.01971555f, -0.03634993f, -0.17084926f, 0.08608446f, -0.15020561f, -0.06820511f, 
    0.05705106f, -0.05351031f, 0.08490925f, -0.02947571f, 0.00580467f, 0.04226378f, -0.16007434f, 0.05874358f, 
    -0.09105387f, 0.37028638f, 0.17749278f, -0.03003792f, -0.01256138f, -0.00578315f, 0.04055869f, -0.03149258f, 
    -0.00774704f, -0.04756859f, 0.02809655f, 0.02075514f, 0.30417928f, 0.01102117f, 0.08881324f, 0.03540005f, 
    0.05424640f, 0.08724274f, 0.06645799f, -0.04755445f, 0.02030883f, 0.03367965f, -0.08866825f, -0.01130918f, 
    -0.06391855f, -0.07570843f, -0.01779006f, -0.12257414f, 0.14902754f, 0.06106678f, -0.14820200f, 0.00610590f, 
    0.02470042f, 0.04310516f, 0.05816283f, -0.10363677f, -0.03916630f, 0.18467824f, 0.09804075f, -0.03704235f, 
    -0.06511867f, -0.01718262f, 0.13550022f, -0.07728688f, -0.01112879f, 0.12947696f, 0.10621484f, 0.05318089f, 
    0.26081237f, -0.00073052f, -0.10289297f, 0.13053635f, 0.08697972f, 0.04758184f, 0.15741009f, 0.05795236f, 
    0.00468991f, 0.07727212f, 0.00022754f, 0.02825258f, 0.19920190f, 0.02439813f, 0.09961908f, -0.12389424f, 
    -0.09548051f, -0.10693485f, 0.12751086f, 0.02032416f, 0.00519133f, 0.03441525f, 0.17761691f, -0.01652020f, 
    -0.19413872f, -0.12841742f, -0.06107657f, -0.13642822f, 0.32363585f, -0.00864976f, 0.03489305f, 0.11348850f, 
    0.07550617f, -0.02394396f, -0.00791592f, 0.21510279f, -0.06226678f, 0.18996152f, -0.06653614f, 0.02703009f, 
    0.20201349f, 0.06562075f, 0.03596100f, -0.00935558f, 0.02325736f, 0.05808363f, 0.07579572f, 0.04478509f, 
    0.07083993f, 0.19002664f, 0.08259889f, -0.00528924f, -0.21059696f, 0.07274530f, 0.09341277f, 0.01204461f, 
    0.14348936f, 0.06189708f, 0.00319501f, 0.02749832f, -0.28092182f, -0.08388450f, 0.28769425f, -0.00358369f, 
    0.06396908f, 0.04350242f, 0.21843690f, 0.11322165f, -0.10724125f, -0.04011532f, -0.05668327f, -0.15512709f, 
    0.06190465f, -0.13528429f, -0.15347598f, -0.08566412f, 0.04123852f, -0.05192253f, 0.05829684f, 0.14411488f, 
    -0.01793512f, 0.01231522f, 0.00024690f, 0.06335703f, 0.39496681f, -0.08420292f, 0.16898640f, -0.04995719f, 
    -0.01140552f, 0.12066999f, 0.07378351f, -0.07531203f, 0.09918618f, -0.11835165f, -0.02037128f, 0.02526310f, 
    0.02438045f, -0.22261985f, 0.16073680f, 0.14469838f, -0.04574402f, -0.01415486f, 0.01911248f, 0.00376688f, 
    0.00175708f, -0.01749946f, -0.00888285f, 0.03707198f, -0.29858568f, 0.08286649f, 0.16823941f, 0.19153757f, 
    -0.01367110f, 0.01640490f, -0.14714637f, 0.06422926f, 0.06492162f, 0.08427992f, -0.11411107f, 0.01073568f, 
    0.04153104f, 0.03107908f, -0.10146236f, -0.16500837f, 0.17896986f, 0.10086663f, 0.09467158f, 0.01473392f, 
    0.01492800f, -0.00244778f, -0.03421637f, 0.04587621f, -0.01990495f, 0.31055611f, -0.04844369f, -0.15973864f, 
    -0.05540178f, -0.03744217f, 0.02485238f, -0.04453146f, 0.07971215f, 0.04813853f, -0.06589721f, 0.12809190f, 
    -0.02980349f, 0.13889699f, 0.22781152f, 0.03312328f, -0.11723369f, 0.06865521f, 0.08555649f, -0.07716673f, 
    -0.09334273f, -0.05442118f, 0.21938336f, 0.21987101f, 0.05071891f, -0.16290234f, 0.44427589f, 0.26357660f, 
    0.00512368f, 0.16689157f, 0.07003847f, 0.04783020f, -0.05785741f, 0.08757064f, -0.08267073f, -0.04348694f, 
    -0.02009076f, -0.05348322f, 0.05407225f, 0.03984986f, 0.02180369f, -0.03160435f, 0.01264556f, -0.01188294f, 
    -0.04450917f, -0.05832633f, 0.00852408f, 0.07579572f, 0.05199553f, -0.05065218f, -0.04398539f, -0.04285176f, 
    -0.02772653f, -0.07232506f, -0.06045495f, 0.04911797f, 0.00163289f, -0.03748218f, 0.02958331f, 0.05245393f, 
    -0.02626001f, -0.07957185f, 0.05731208f, 0.04135172f, -0.04604126f, -0.03403969f, 0.02646532f, 0.01170895f, 
    -0.06747451f, -0.05135764f, 0.00834367f, 0.03055598f, -0.06350236f, -0.07661010f, -0.04228650f, 0.00028037f, 
    -0.03692127f, -0.07652914f, 0.03409773f, -0.02750989f, -0.04173690f, -0.07105045f, 0.05546081f, 0.04065473f, 
    -0.07163122f, -0.01829526f, 0.02325846f, -0.05178047f, -0.05966705f, 0.01179993f, 0.06091004f, -0.05635944f, 
    0.05350201f, 0.03563046f, 0.07391883f, -0.06689104f, 0.03122929f, 0.00850488f, 0.05934857f, -0.05695085f, 
    0.05230083f, -0.04810778f, -0.04445975f, 0.06010563f, 0.03346130f, -0.07501183f, 0.02078404f, 0.06294890f, 
    0.05956751f, 0.02083338f, -0.02505432f, -0.00841310f, 0.00395583f, 0.03065127f, 0.02514557f, 0.00421571f, 
    -0.01771822f, 0.00893775f, 0.00623645f, -0.04877862f, -0.07628056f, 0.02695315f, 0.06352210f, -0.05549145f, 
    0.01512510f, 0.01536824f, 0.04825680f, 0.00853980f, 0.05523399f, -0.06152377f, -0.00511960f, -0.03444201f, 
    0.04028222f, -0.04556526f, -0.04730397f, -0.06050823f, -0.05825553f, -0.01559372f, -0.03532811f, 0.00297229f, 
    0.01689116f, 0.03983371f, 0.00910396f, 0.01761948f, -0.02642798f, 0.05260540f, -0.01622160f, -0.08582351f, 
    -0.03556152f, -0.05607218f, 0.05178412f, 0.05470030f, -0.05844212f, -0.00744544f, -0.01520060f, -0.06928109f, 
    -0.02531417f, 0.01193272f, -0.04783979f, 0.02741549f, -0.03091613f, 0.05281675f, 0.03317069f, 0.04854231f, 
    -0.03743370f, -0.06839710f, -0.03402834f, 0.03809395f, -0.02991297f, 0.06196399f, -0.07556844f, 0.03694043f, 
    0.01577615f, 0.03406798f, -0.05558858f, 0.07050071f, -0.02339198f, 0.06802472f, -0.03662977f, -0.05386975f, 
    0.00835985f, 0.05478749f, -0.00395507f, 0.06180638f, 0.06342769f, -0.06361727f, 0.04256141f, 0.00218933f, 
    -0.02873183f, -0.04501335f, -0.04644579f, -0.06755622f, -0.03064297f, -0.04246778f, -0.06676503f, 0.02425480f, 
    0.03548806f, 0.03581451f, 0.04356152f, -0.03192879f, 0.01259888f, 0.02592184f, -0.04224804f, -0.00114769f, 
    0.01099608f, -0.07196607f, 0.05602682f, 0.00802452f, -0.06732164f, -0.06256411f, 0.01729120f, -0.05421053f, 
    0.01433385f, -0.03393851f, -0.06075013f, -0.07158600f, -0.03888555f, -0.00760864f, -0.04672426f, 0.02668863f, 
    -0.07470376f, -0.07661162f, 0.01077941f, 0.01478993f, -0.05649393f, 0.04979641f, -0.05624149f, -0.05409125f, 
    0.04062901f, 0.13502696f, 0.04618862f, -0.03950650f, 0.01598665f, 0.06883673f, -0.09542060f, -0.08467219f, 
    -0.02985991f, 0.09238748f, -0.08984745f, -0.06686691f, -0.19926012f, -0.04029435f, -0.23033962f, -0.10672981f, 
    0.14139013f, 0.05066678f, 0.17293720f, -0.02567367f, 0.05883582f, -0.12988451f, -0.01037891f, 0.18838981f, 
    0.13309285f, 0.07544067f, 0.05616213f, 0.05400034f, 0.03222175f, -0.03247085f, 0.09991687f, 0.03302782f, 
    0.11648703f, 0.03238503f, 0.02286335f, -0.07115824f, 0.00223942f, 0.11903055f, -0.16049869f, 0.01089485f, 
    0.14716142f, 0.07355526f, 0.04900306f, -0.07064954f, 0.01551625f, -0.00431130f, 0.19047947f, 0.06512009f, 
    0.05287368f, -0.04606189f, 0.26438618f, 0.29979193f, -0.02626226f, 0.03119938f, -0.02559808f, 0.05455273f, 
    -0.03049144f, -0.00112499f, -0.07933607f, -0.07891449f, 0.00407081f, 0.06901565f, 0.02847242f, 0.17549899f, 
    0.14537853f, -0.02559665f, 0.11079434f, 0.19255577f, -0.05685405f, -0.05796285f, -0.00900610f, 0.08642404f, 
    -0.25474876f, -0.05248777f, -0.07403231f, -0.08089130f, -0.07110305f, 0.05066517f, 0.06024995f, -0.12655956f, 
    -0.06290666f, 0.14379127f, -0.04328175f, -0.09743285f, -0.18618006f, -0.16966723f, -0.01815558f, 0.03644662f, 
    -0.07643393f, 0.01437598f, -0.02419936f, -0.01876169f, 0.04309611f, 0.06922729f, 0.09906126f, -0.03604405f, 
    0.26074776f, -0.15265647f, 0.03759552f, 0.10473444f, 0.02957989f, 0.02935801f, -0.01804401f, 0.15440750f, 
    -0.13908429f, -0.08893878f, 0.10306995f, 0.07763686f, 0.04058166f, 0.22509624f, -0.14576714f, -0.01180014f, 
    -0.15001653f, -0.00480560f, 0.08764718f, 0.13940315f, -0.11411899f, 0.01421917f, 0.01088074f, -0.07364566f, 
    0.28767911f, 0.01510659f, 0.15311448f, 0.08524769f, -0.06638037f, -0.03433809f, -0.02039517f, -0.00074878f, 
    -0.00961061f, 0.07502575f, -0.00503347f, -0.08107905f, 0.24594848f, 0.01947787f, 0.26869234f, -0.04485838f, 
    0.07740621f, 0.04223276f, -0.03839190f, -0.09247974f, -0.04093522f, -0.06037173f, 0.03894402f, -0.02717942f, 
    0.17367847f, -0.05425512f, -0.02598625f, 0.05033026f, 0.09913523f, 0.05285437f, 0.19319549f, 0.04614378f, 
    0.02128055f, 0.05024369f, 0.01147385f, 0.09568448f, -0.18597828f, 0.09719580f, -0.19779983f, -0.15797798f, 
    0.09772260f, 0.04692303f, -0.03076132f, -0.02332208f, 0.03785938f, -0.14632860f, -0.12209221f, 0.12516443f, 
    -0.22251794f, 0.19978249f, 0.07232359f, 0.00670601f, 0.00669825f, 0.00633356f, -0.04974952f, -0.03860461f, 
    0.05927563f, 0.01323063f, -0.03358887f, -0.15178575f, 0.16540185f, 0.01357737f, 0.00938854f, 0.01402945f, 
    -0.05964994f, 0.06314917f, 0.02566347f, -0.00895569f, -0.02029486f, -0.04301022f, -0.04798128f, 0.04393550f, 
    -0.04662090f, -0.03163737f, -0.00319022f, -0.07464837f, -0.06224186f, 0.03685525f, 0.05826782f, 0.04074582f, 
    -0.06275115f, -0.07340468f, 0.01934963f, -0.06777330f, -0.06855547f, 0.03410450f, 0.05469730f, 0.05446295f, 
    -0.06851649f, -0.03359720f, -0.06349392f, 0.04688030f, 0.02149437f, -0.06497716f, -0.07417203f, -0.05565368f, 
    0.04981974f, -0.03568216f, -0.04613338f, -0.00113351f, -0.05918076f, 0.04216954f, -0.07965650f, 0.03187694f, 
    0.00397104f, -0.02688830f, 0.02679712f, 0.05333375f, -0.05676224f, -0.07185464f, -0.01836361f, 0.01697036f, 
    -0.04575486f, -0.04208702f, 0.06864120f, 0.03564886f, -0.07320630f, -0.06305892f, 0.02441534f, 0.00885732f, 
    0.03560199f, -0.00261136f, -0.01489258f, -0.04289029f, -0.04107185f, 0.03157878f, 0.00956110f, -0.08095104f, 
    0.00276757f, 0.05177396f, -0.01692809f, -0.06407968f, 0.04868481f, -0.00059254f, -0.06245336f, -0.02872830f, 
    0.00447353f, -0.03520371f, -0.03678668f, -0.05222414f, -0.07801390f, 0.04705804f, 0.01827680f, -0.06605152f, 
    -0.05305296f, -0.05272177f, -0.02272577f, 0.00456700f, -0.04837658f, 0.01797275f, -0.00634329f, 0.06136300f, 
    0.00817217f, -0.00259984f, 0.02151577f, -0.08530220f, -0.02003710f, -0.06776242f, 0.01498723f, -0.06445894f, 
    -0.08556660f, -0.07504117f, -0.05069391f, 0.00899814f, 0.01788734f, -0.04657249f, 0.05967329f, -0.04660906f, 
    0.01121971f, 0.02922387f, 0.04287806f, -0.04536990f, -0.07907904f, -0.03585421f, 0.04822009f, 0.01778132f, 
    -0.00923363f, 0.01620259f, 0.03942621f, 0.00157751f, -0.03673410f, -0.07217661f, -0.03526415f, 0.01194721f, 
    0.01329722f, -0.05163877f, -0.01675618f, 0.01174491f, 0.04674147f, 0.04826792f, -0.07252058f, -0.06528389f, 
    0.00021238f, 0.03533428f, 0.04355908f, -0.08169711f, -0.01282480f, -0.01899830f, 0.02218691f, -0.02610211f, 
    0.00415691f, -0.03344936f, -0.05801311f, -0.06161929f, 0.01957628f, -0.02109516f, 0.05343155f, 0.03191686f, 
    0.03321583f, 0.05459084f, 0.03100449f, 0.04878111f, -0.00335949f, 0.00323787f, 0.00831502f, 0.04783082f, 
    -0.03057361f, -0.07506096f, -0.06469999f, 0.05091067f, -0.05695860f, 0.04329109f, -0.05092011f, -0.01520697f, 
    -0.02250812f, 0.02018875f, -0.04376898f, -0.05548380f, 0.03750855f, -0.07489306f, -0.00936569f, 0.00400335f, 
    -0.06606248f, -0.02046267f, -0.02847654f, -0.05698654f, 0.02407870f, 0.03881221f, 0.04783463f, 0.02169328f, 
    -0.05118259f, 0.01922361f, 0.01640506f, 0.01592863f, -0.04888164f, -0.07164393f, 0.00508990f, -0.04462422f, 
    0.02602605f, 0.04680301f, -0.03831808f, -0.01316313f, 0.06408365f, -0.03497763f, -0.00869029f, -0.02288500f, 
    0.00257397f, 0.02855390f, 0.01617518f, 0.06296970f, -0.06740376f, 0.04736532f, 0.05537588f, -0.00423373f, 
    -0.00739960f, 0.04539121f, -0.03870720f, 0.05545376f, -0.06488349f, 0.02201792f, -0.03787233f, -0.04426252f, 
    -0.01199315f, -0.04407901f, -0.03823648f, 0.03174114f, 0.05456480f, 0.04491216f, -0.03235156f, -0.02716837f, 
    -0.02210908f, -0.06381684f, 0.01565806f, -0.02025225f, 0.02211074f, -0.07406528f, 0.05349403f, -0.00457527f, 
    -0.04956978f, -0.01928202f, -0.06614356f, -0.03231332f, -0.01586938f, -0.03253273f, -0.03000744f, 0.01410291f, 
    0.01331825f, 0.03521622f, 0.00749468f, -0.03285686f, -0.06196297f, 0.03308220f, -0.02649603f, 0.00384424f, 
    0.01319876f, 0.05784813f, 0.00737063f, -0.08248668f, 0.03812823f, -0.05616274f, -0.03425652f, 0.06067662f, 
    0.00377609f, -0.02705336f, -0.01204110f, -0.08143996f, -0.01214019f, -0.03658379f, -0.02720329f, -0.01076188f, 
    -0.01602163f, -0.03204311f, -0.07882109f, 0.03045977f, -0.02422671f, -0.01371927f, 0.04437610f, 0.04210492f, 
    -0.02869927f, -0.06871354f, 0.05908233f, -0.05978023f, 0.03067546f, 0.00421920f, 0.00641969f, 0.02155590f, 
    -0.00062424f, 0.05377711f, -0.05326266f, -0.01531742f, 0.04370476f, 0.06043831f, -0.03800800f, -0.00542227f, 
    0.00245635f, -0.07793930f, 0.01678100f, -0.06474970f, 0.01226707f, 0.02337156f, -0.02391477f, 0.00208561f, 
    -0.00986515f, -0.00386331f, -0.02313163f, 0.03818391f, -0.04007334f, 0.05704981f, -0.02911014f, -0.04806485f, 
    0.00623846f, 0.04096817f, 0.03697345f, -0.01379144f, -0.05205980f, -0.03591851f, -0.04650261f, -0.01492945f, 
    -0.00865795f, -0.04033286f, -0.02302855f, -0.03393416f, 0.01031646f, -0.05506431f, -0.06510569f, 0.03759876f, 
    -0.05944205f, -0.01143689f, -0.04568091f, 0.01309611f, 0.02709447f, 0.02866063f, 0.03835244f, 0.00697571f, 
    0.00760397f, -0.05636041f, -0.04556474f, -0.03519196f, -0.04466273f, 0.01986192f, -0.06529130f, -0.06448023f, 
    0.04925216f, -0.04877836f, 0.04642956f, 0.00742863f, 0.02356327f, 0.00799623f, -0.07299782f, -0.00210100f, 
    0.00364093f, -0.00726374f, 0.00255960f, -0.07191752f, 0.01379883f, -0.00845959f, 0.01181492f, -0.03590547f, 
    0.00103560f, -0.07653616f, -0.04544523f, 0.05102301f, -0.03818968f, -0.02179918f, -0.02861276f, 0.05553483f, 
    0.00057548f, -0.06981973f, 0.00353666f, -0.04264884f, 0.03264848f, 0.05646781f, 0.00025230f, -0.01293713f, 
    0.05005426f, -0.06333791f, -0.03655538f, 0.04347579f, -0.00365817f, 0.01743114f, -0.03139806f, -0.05789721f, 
    0.05779684f, -0.03858816f, 0.00527066f, -0.00986226f, 0.03302720f, -0.07941972f, -0.02337563f, 0.04387580f, 
    0.03388116f, 0.05302978f, 0.01651525f, -0.07701285f, 0.01400688f, 0.02340258f, 0.05697506f, -0.04545131f, 
    -0.05006186f, -0.04260392f, 0.00005953f, -0.03338156f, -0.01053169f, 0.04771103f, 0.03108654f, -0.07563883f, 
    0.46873495f, -0.07299014f, 0.02557487f, -0.01710975f, -0.06052458f, 0.07501995f, 0.02566210f, 0.11216346f, 
    0.09307540f, 0.01328301f, 0.16434450f, 0.06927761f, 0.27370483f, 0.05041481f, 0.19352429f, 0.12779081f, 
    -0.01533839f, 0.08044075f, -0.06370046f, -0.02949771f, 0.06060236f, 0.04952553f, -0.01883887f, -0.12856466f, 
    -0.01372238f, 0.06941599f, -0.03734631f, -0.13491048f, 0.04785946f, 0.13450156f, -0.02368403f, 0.13721442f, 
    -0.03599347f, 0.00826898f, -0.20190647f, -0.00786257f, -0.12235206f, 0.03352153f, 0.18578161f, -0.12334956f, 
    0.05166874f, -0.10493065f, -0.02679561f, 0.08238397f, -0.01527929f, 0.08344527f, 0.03798585f, -0.01909888f, 
    0.40220216f, 0.11928876f, 0.08640168f, -0.17981857f, 0.06420139f, -0.00903367f, 0.02848652f, 0.03180178f, 
    0.09735580f, -0.05143848f, 0.00807785f, 0.01454919f, 0.23002018f, 0.11349022f, 0.08790543f, 0.02840209f, 
    0.00143745f, -0.00190120f, -0.03157568f, 0.03668647f, 0.01988547f, 0.07207392f, -0.00374686f, -0.01178463f, 
    0.20991339f, -0.01731167f, 0.00078526f, 0.07551838f, 0.17403992f, 0.00480850f, -0.03611507f, -0.07553654f, 
    -0.04660091f, -0.11839804f, 0.05780717f, 0.00673272f, -0.10484958f, 0.15023607f, 0.09297912f, -0.15363219f, 
    0.12778406f, -0.17620608f, -0.00446716f, 0.04373179f, 0.03443210f, -0.03125668f, -0.08280703f, 0.08728664f, 
    0.05543476f, 0.10603508f, 0.00697384f, -0.07988821f, 0.10249629f, 0.05751190f, -0.04395228f, -0.02155532f, 
    0.12086046f, 0.03987899f, -0.00534550f, -0.01576437f, -0.08332557f, -0.03711463f, 0.10290277f, 0.03058557f, 
    0.05974563f, 0.00946516f, -0.05970209f, 0.05847536f, 0.04636019f, -0.03105650f, 0.04096970f, -0.01383975f, 
    -0.26078537f, -0.08612282f, 0.07996897f, -0.21716952f, 0.00352447f, -0.03209172f, 0.00978116f, -0.00229758f, 
    -0.08387546f, -0.02280062f, 0.19793366f, 0.01927697f, -0.24811839f, -0.00044859f, -0.14377818f, -0.10888752f, 
    0.05859859f, 0.00588118f, 0.02335525f, 0.08388633f, 0.12034568f, 0.14375779f, 0.08039014f, -0.03209709f, 
    0.38405684f, 0.15051977f, -0.03566519f, 0.04115346f, 0.11173335f, 0.05681451f, -0.16845842f, 0.07426473f, 
    0.00040976f, -0.14016508f, -0.01042115f, -0.13111944f, 0.08522437f, -0.30529729f, 0.07172113f, 0.25588095f, 
    0.07771558f, 0.07840317f, 0.02072663f, 0.03647512f, 0.07753387f, 0.07963169f, -0.01054308f, 0.03504052f, 
    0.04006077f, -0.03943558f, -0.18864813f, -0.06518167f, -0.02498721f, 0.08633601f, 0.00152009f, -0.12592266f, 
    -0.05882534f, 0.14391054f, 0.05899369f, 0.06807469f, -0.40745291f, -0.14983109f, -0.10148279f, -0.16657506f, 
    0.12553367f, -0.09148667f, -0.02623402f, 0.02114435f, 0.04986602f, -0.08288246f, 0.00715628f, -0.01215689f, 
    0.27623120f, 0.05030315f, -0.06591647f, 0.11180563f, -0.06620228f, 0.13673642f, 0.18410295f, 0.05648724f, 
    -0.05500168f, -0.00143023f, 0.12223535f, 0.10648193f, 0.23321269f, 0.05586718f, 0.03965952f, 0.04914569f, 
    -0.02645292f, 0.09370615f, -0.03348143f, 0.04617989f, 0.05835972f, 0.02989148f, -0.07339344f, 0.16858530f, 
    -0.15994169f, -0.11183400f, -0.03654981f, -0.06111541f, -0.05573297f, -0.01138790f, -0.10924988f, 0.00664140f, 
    0.00891907f, 0.05836624f, 0.04144613f, 0.10431431f, 0.00065935f, -0.04573191f, 0.06332372f, 0.01064996f, 
    0.17691474f, -0.06484046f, 0.03838449f, 0.03799945f, 0.13501348f, 0.01623637f, -0.06802873f, 0.05033955f, 
    0.14399612f, 0.00534630f, -0.09357337f, 0.09047719f, 0.08959132f, -0.06478457f, 0.00834007f, 0.07019543f, 
    0.08614346f, 0.14027946f, 0.05381969f, -0.08709176f, -0.16343722f, -0.20011552f, -0.02480155f, -0.07550415f, 
    -0.05069490f, -0.03878576f, -0.08407085f, 0.01112076f, 0.07260611f, 0.07023852f, -0.04742485f, 0.08590224f, 
    0.21470000f, 0.11177979f, 0.02708737f, 0.02399847f, 0.20867917f, -0.04926306f, 0.06022243f, 0.10492530f, 
    0.14311834f, -0.07085019f, 0.03879566f, 0.13537563f, 0.23614997f, 0.05546211f, -0.04560836f, 0.02758088f, 
    0.07620002f, -0.02707964f, -0.06352821f, -0.06940760f, 0.01458632f, 0.15762262f, 0.00499653f, 0.18053728f, 
    0.01167111f, 0.00230710f, -0.11772277f, 0.05375507f, 0.04480005f, 0.14738509f, 0.03328019f, -0.09013736f, 
    0.00856017f, 0.03374077f, -0.02296941f, -0.07747399f, -0.20216835f, 0.01431701f, -0.04776080f, 0.01281317f, 
    0.02895640f, -0.03762103f, 0.07627190f, -0.01355604f, 0.15678850f, -0.06070907f, -0.00028688f, 0.11922974f, 
    0.06215689f, -0.06463604f, -0.01365829f, -0.06904781f, 0.01636490f, 0.12439156f, 0.07167161f, 0.04241867f, 
    -0.01919510f, -0.01458169f, 0.11401432f, 0.15809581f, -0.10170026f, -0.27448496f, -0.32392281f, -0.20569675f, 
    -0.00258982f, -0.04394413f, 0.09218205f, -0.05704110f, 0.11654107f, 0.07165302f, 0.12072498f, -0.00474253f, 
    0.02926319f, -0.15054742f, 0.10915443f, 0.12865353f, -0.05926426f, 0.07379125f, -0.05704579f, 0.17214115f, 
    0.09848516f, -0.01779877f, 0.11209374f, -0.03531921f, 0.20874019f, -0.05253884f, 0.29231203f, 0.16487586f, 
    0.00365109f, 0.08836624f, -0.07348467f, -0.01663253f, 0.14072238f, 0.03511267f, 0.19592226f, 0.04083929f, 
    0.02668526f, -0.11884574f, 0.00306698f, 0.04723244f, 0.12302224f, 0.09672329f, -0.00351124f, 0.01096494f, 
    0.03340306f, 0.04850374f, 0.08039755f, -0.03437980f, -0.26266709f, -0.19553834f, -0.09882197f, -0.13212533f, 
    0.15131173f, 0.08038021f, 0.00394825f, 0.01342742f, 0.14553581f, -0.02467785f, 0.07321393f, -0.00985191f, 
    0.24374306f, -0.01190169f, 0.04273266f, -0.17480598f, 0.20987441f, -0.04763572f, -0.04265347f, -0.01188153f, 
    -0.11190573f, -0.01322676f, 0.10462310f, 0.03577971f, -0.03071977f, 0.16570927f, -0.20254566f, -0.07729804f, 
    0.33414647f, 0.10028508f, 0.14761704f, 0.03636660f, 0.04762691f, 0.05002176f, 0.00288078f, 0.01549899f, 
    0.06964456f, -0.20039494f, 0.09711272f, 0.14137308f, 0.02229373f, 0.04589952f, -0.06503435f, 0.15011035f, 
    0.04354541f, 0.07892510f, -0.01839644f, 0.07331179f, -0.28328028f, 0.33088869f, -0.22419222f, -0.00808797f, 
    0.18266031f, -0.11084224f, 0.16010390f, -0.18576786f, 0.05726967f, 0.07540339f, 0.11613229f, 0.08089626f, 
    -0.18942970f, 0.23310582f, 0.23909153f, 0.36775318f, 0.01561506f, 0.05002706f, -0.16083342f, 0.02009841f, 
    -0.05008767f, -0.05754508f, -0.03327186f, -0.08362541f, -0.63837177f, -0.13344316f, 0.16180088f, 0.17948337f, 
    0.11531908f, -0.06194817f, -0.04479014f, -0.05303238f, -0.01246227f, 0.01388470f, 0.00271575f, 0.07234760f, 
    -0.20221306f, -0.01074624f, -0.02888625f, -0.20865464f, 0.20574467f, 0.07320502f, -0.07090758f, -0.02885678f, 
    0.05719408f, 0.07214458f, 0.07820048f, 0.02263198f, 0.06865432f, 0.10413979f, 0.26616767f, 0.08329581f, 
    -0.03481392f, 0.01119043f, 0.04955934f, -0.06117566f, 0.06398961f, 0.02953650f, -0.07786013f, 0.03387050f, 
    0.29128903f, -0.41486832f, 0.01587228f, 0.21004057f, 0.06109515f, -0.08053136f, -0.03697418f, 0.04434780f, 
    -0.11243170f, -0.00827138f, 0.20966457f, -0.05637523f, 0.11287694f, 0.23526397f, -0.15637539f, 0.15842746f, 
    0.02845271f, 0.09492153f, 0.07308299f, 0.10787697f, 0.07852124f, 0.05429525f, -0.00324587f, 0.00419063f, 
    0.05165568f, -0.08383562f, 0.17981815f, 0.17593901f, 0.02238502f, 0.07652338f, -0.02747307f, 0.17508982f, 
    0.03934757f, 0.10481455f, 0.12315467f, 0.02208466f, 0.22236592f, -0.31406650f, 0.15829538f, -0.33266973f, 
    -0.02260051f, -0.04886714f, 0.02172766f, 0.03419529f, -0.02752921f, -0.04523547f, -0.05143531f, 0.09130108f, 
    0.43392459f, -0.09378931f, 0.17720440f, 0.14092739f, 0.02902549f, -0.01541137f, 0.04077094f, 0.16308005f, 
    0.00372698f, 0.09317024f, 0.00846535f, 0.03831796f, -0.14232695f, -0.06867006f, -0.10801296f, -0.17139906f, 
    0.16317210f, 0.08725633f, -0.05373641f, -0.08160501f, 0.07789514f, 0.02350158f, 0.07294881f, -0.06356136f, 
    -0.22247300f, -0.02519450f, -0.15730423f, -0.06940756f, 0.08874557f, 0.20922267f, -0.04505607f, 0.06905332f, 
    -0.05829906f, 0.07568944f, -0.03545331f, -0.08098416f, -0.22427712f, -0.32911736f, 0.08020198f, -0.04568831f, 
    -0.15009522f, 0.23521410f, -0.05842501f, 0.17850041f, -0.06087231f, -0.16070516f, -0.14213803f, 0.16606455f, 
    -0.09088909f, -0.08035015f, 0.16754268f, 0.11932694f, 0.04844217f, -0.11879800f, 0.06305606f, -0.10798396f, 
    0.05629901f, 0.04618324f, -0.09051038f, -0.12233353f, -0.32257769f, -0.14327615f, -0.06681218f, -0.05935601f, 
    0.10734557f, -0.09753480f, 0.08453895f, 0.02091125f, 0.05332832f, -0.04914122f, 0.16408448f, 0.10599753f, 
    -0.04637069f, 0.19519250f, -0.03104338f, -0.00588483f, 0.00925419f, -0.06824154f, 0.11917102f, -0.10873407f, 
    0.06564014f, 0.08761244f, 0.23316616f, 0.02833503f, 0.01720938f, -0.05121611f, 0.00309198f, 0.17005591f, 
    -0.01053561f, 0.23165579f, 0.03841086f, 0.04626261f, -0.00793044f, -0.06550652f, 0.04035272f, -0.14156234f, 
    -0.19040343f, -0.02402163f, 0.04206812f, 0.14915374f, -0.20454267f, -0.01402444f, 0.09777060f, 0.00855605f, 
    0.00207294f, -0.01825613f, 0.02364038f, 0.09500642f, 0.55245185f, 0.11247797f, 0.06169496f, 0.06140856f, 
    -0.06104601f, 0.03731477f, 0.00822179f, 0.06031625f, 0.02394721f, -0.15772744f, 0.01766815f, 0.12767829f, 
    -0.15106477f, -0.05398537f, 0.09608421f, 0.25016001f, -0.05005876f, 0.08138942f, -0.03695042f, 0.02408751f, 
    -0.04137155f, 0.20800044f, -0.02856791f, 0.05639575f, -0.13877885f, -0.12546511f, -0.23359174f, 0.00937143f, 
    -0.01065450f, 0.21814884f, 0.13855787f, 0.11240505f, 0.00312527f, 0.00224245f, 0.13447273f, -0.10806671f, 
    -0.06803345f, 0.18068218f, 0.08546565f, 0.15245177f, -0.05326618f, -0.06203316f, -0.02463686f, -0.03485040f, 
    0.14931977f, -0.00003475f, 0.01252042f, 0.06729800f, -0.05585366f, 0.09632440f, -0.00336154f, -0.06507311f, 
    -0.00269368f, 0.03306003f, 0.03720074f, 0.07066606f, -0.07727323f, 0.21788399f, -0.02667210f, 0.13388023f, 
    -0.07895790f, 0.15029164f, 0.10210395f, 0.05571435f, -0.03435434f, 0.09072836f, -0.02108087f, 0.00292502f, 
    -0.02186506f, 0.07710108f, -0.09723379f, -0.05774337f, 0.33054736f, 0.22967128f, 0.12717324f, -0.17414317f, 
    -0.04592272f, 0.02836356f, -0.05401053f, -0.01871888f, -0.07622315f, -0.04107741f, -0.09831530f, 0.04888556f, 
    -0.05103842f, 0.01143944f, -0.00294924f, 0.11377659f, -0.04680613f, 0.00979251f, 0.18793255f, -0.05515234f, 
    -0.01506051f, 0.13021630f, -0.06696866f, 0.08792148f, 0.02384629f, 0.15007664f, 0.01436817f, -0.08065519f, 
    0.17869918f, -0.04162339f, -0.05491202f, 0.01844066f, -0.07830151f, -0.03920814f, -0.13103889f, -0.11659069f, 
    0.16598488f, 0.15038246f, 0.15409276f, 0.10170878f, 0.10685984f, -0.02923549f, -0.11411584f, 0.06095584f, 
    -0.00080036f, -0.14302373f, -0.11088470f, -0.01102734f, 0.55106676f, 0.33429170f, 0.02382932f, 0.05510670f, 
    0.05369136f, 0.03750285f, -0.04622351f, 0.01654372f, 0.02018604f, 0.08863788f, -0.03624019f, 0.09142006f, 
    0.01548621f, -0.00664742f, -0.11246506f, 0.01260206f, 0.04875551f, 0.10558575f, -0.02093533f, 0.03396674f, 
    0.04663571f, 0.10452986f, -0.02864595f, -0.10388042f, -0.16125266f, 0.04557451f, 0.02474674f, -0.06877882f, 
    0.08116506f, 0.01159238f, 0.10857626f, 0.09979311f, 0.01617132f, 0.03035098f, -0.02274833f, 0.17790729f, 
    0.07341177f, -0.02984976f, -0.09280580f, 0.15575950f, 0.07914507f, -0.01416330f, -0.04389608f, -0.08409693f, 
    0.19867362f, 0.05150811f, 0.18545343f, 0.02472785f, -0.07262421f, 0.26237020f, 0.07778742f, -0.09916960f, 
    0.14838523f, -0.00165397f, 0.02339517f, -0.07260629f, 0.00301508f, -0.06863309f, 0.12525296f, -0.02601356f, 
    -0.21590593f, -0.05896605f, 0.10038811f, 0.26704103f, 0.23538855f, -0.02955252f, -0.01447774f, -0.00962317f, 
    0.07667949f, -0.02670158f, -0.10269083f, -0.10388215f, -0.01660086f, -0.13594002f, -0.03580520f, 0.07853794f, 
    0.01514303f, 0.05631666f, -0.01105354f, -0.04774509f, -0.06413358f, 0.02617491f, 0.00748746f, 0.09736379f, 
    0.14467701f, 0.31945556f, 0.02781616f, -0.25996965f, -0.02868294f, -0.07954615f, 0.02253932f, -0.02921574f, 
    0.04036454f, 0.23716931f, -0.15160529f, 0.09837116f, 0.22092195f, 0.08128112f, 0.11444694f, 0.29888937f, 
    -0.04236241f, 0.17636964f, 0.03582617f, -0.07419687f, 0.07027617f, 0.06453600f, 0.15253033f, 0.00239530f, 
    0.12574187f, -0.38586164f, -0.14510228f, 0.17472330f, 0.01943321f, -0.04159641f, -0.06098294f, -0.01755640f, 
    -0.10246376f, -0.02753094f, -0.03791019f, 0.14271955f, 0.03052456f, 0.31457818f, -0.00686028f, 0.14951003f, 
    -0.00292216f, 0.07321274f, 0.08861337f, 0.06531078f, 0.07237867f, -0.01982339f, 0.09348577f, 0.00711695f, 
    0.22472498f, -0.22818373f, 0.03356070f, 0.13087226f, 0.10582216f, 0.05746590f, 0.09935254f, 0.02398052f, 
    -0.01509208f, 0.13450578f, -0.16194107f, -0.06734629f, 0.06022393f, -0.18225233f, -0.00822287f, 0.00972889f, 
    -0.06578629f, 0.03408164f, -0.02578253f, -0.16122514f, -0.07392337f, -0.09272615f, 0.11701868f, -0.01199217f, 
    -0.10871498f, -0.13936806f, -0.00270646f, 0.01476582f, -0.02656587f, -0.00975323f, 0.17746706f, 0.14383405f, 
    -0.00216627f, 0.13782902f, 0.05660771f, 0.14632161f, 0.00480089f, 0.34495568f, 0.02580000f, -0.13748802f, 
    -0.01837992f, -0.02332791f, -0.06412089f, -0.00464578f, -0.03969717f, -0.04041862f, -0.05548365f, -0.00829541f, 
    0.00107661f, 0.13174266f, 0.13177471f, -0.02516382f, -0.18684925f, 0.05280558f, -0.00517002f, -0.13461863f, 
    0.06412736f, -0.05902275f, 0.03960213f, 0.06960867f, -0.17369935f, -0.11809663f, 0.21288750f, 0.17239480f, 
    0.00132195f, 0.20733178f, 0.03627789f, 0.01944841f, -0.07321793f, -0.01071766f, 0.00942884f, 0.08773825f, 
    0.35338897f, -0.03096582f, -0.02743337f, 0.19743758f, -0.19563447f, 0.12496262f, -0.11175905f, 0.03722908f, 
    -0.02658444f, -0.01620045f, -0.06947067f, -0.06174731f, 0.25908750f, 0.08979443f, -0.06833321f, 0.04091560f, 
    -0.10376791f, -0.03053386f, 0.01772238f, -0.01432489f, 0.11143818f, 0.11705419f, -0.02084410f, -0.04083349f, 
    -0.25826660f, 0.29411510f, 0.04880809f, -0.11176836f, -0.07363727f, 0.06712690f, 0.04180772f, 0.11531140f, 
    0.01006377f, -0.02481105f, -0.00207356f, -0.11180282f, 0.33004314f, -0.19816199f, 0.12347968f, 0.10599258f, 
    -0.05394530f, -0.07596681f, -0.00200986f, -0.00237918f, -0.01089409f, 0.06702327f, -0.06286771f, -0.01229490f, 
    0.18888906f, -0.02485379f, 0.15484473f, -0.20071471f, 0.03700935f, -0.03739106f, 0.07185983f, 0.04518439f, 
    -0.01747538f, -0.07697649f, 0.10287596f, 0.06495497f, 0.33741751f, 0.20224318f, 0.15605228f, 0.03568098f, 
    0.01057010f, -0.05995078f, -0.01059200f, 0.06788660f, -0.02021552f, 0.01597474f, -0.08524852f, 0.10849778f, 
    0.15172295f, -0.11278007f, -0.10789410f, 0.29287222f, 0.00186725f, 0.05122674f, -0.08626820f, -0.00711836f, 
    0.06464813f, 0.04878094f, -0.08961473f, -0.02368979f, -0.02823898f, -0.07031193f, 0.05766008f, -0.39698556f, 
    0.08134016f, 0.01469153f, 0.06777987f, 0.05039027f, -0.14088704f, 0.10127482f, 0.10948526f, 0.05109035f, 
    0.09138182f, 0.29378438f, -0.06204880f, -0.18922396f, 0.07226089f, 0.00452955f, 0.02229468f, -0.11591295f, 
    0.05427141f, 0.02307708f, -0.05364057f, -0.02319452f, -0.05271627f, 0.06805587f, -0.07700156f, -0.17017901f, 
    0.10613737f, -0.14907336f, 0.07894087f, -0.04700292f, 0.03963154f, 0.01699223f, 0.04402832f, -0.07127977f, 
    -0.01558480f, -0.19300124f, 0.20347330f, -0.06624837f, -0.01280598f, -0.05611975f, 0.10974443f, 0.08037114f, 
    0.02898023f, 0.01562465f, 0.14179711f, -0.08410455f, -0.11377397f, 0.20077047f, -0.11080883f, -0.10693266f, 
    -0.09450734f, 0.13095425f, -0.03086257f, -0.09002306f, -0.02297023f, 0.03283633f, 0.10901867f, -0.03716454f, 
    0.16420953f, 0.15985192f, -0.12677766f, 0.17258692f, 0.02503562f, 0.04045120f, 0.05519007f, -0.09070976f, 
    -0.02952971f, 0.07215454f, -0.05797122f, -0.04928021f, 0.24459423f, -0.11285056f, -0.08631907f, 0.22952341f, 
    -0.06689228f, -0.04236684f, -0.01058199f, -0.05419691f, 0.11611151f, -0.07599649f, -0.07914566f, 0.16554122f, 
    -0.10866343f, 0.11302044f, 0.01395938f, 0.03956836f, 0.03348304f, -0.02985371f, -0.00953953f, 0.02687036f, 
    -0.07602181f, -0.04800990f, 0.01293386f, -0.11836807f, 0.07848138f, -0.12658051f, -0.24921514f, -0.29032496f, 
    0.04237420f, -0.15032379f, 0.03807804f, -0.12712695f, 0.14776479f, -0.08200509f, 0.02231655f, -0.06758354f, 
    -0.33246708f, 0.17255585f, -0.08907731f, 0.01025878f, 0.14202191f, 0.00214795f, 0.11301038f, 0.08822333f, 
    0.14498605f, -0.00471671f, 0.05383670f, 0.10598672f, -0.09464664f, -0.11083040f, 0.02183833f, -0.04059632f, 
    0.08577809f, -0.01271360f, 0.00331828f, -0.03498473f, -0.01334135f, -0.07588223f, -0.09737767f, -0.06820086f, 
    0.19645751f, -0.03409290f, 0.12290879f, -0.04294254f, 0.05574011f, 0.10111493f, 0.00211851f, 0.03463219f, 
    -0.08991409f, -0.04092906f, 0.03403873f, 0.07884266f, -0.12999913f, 0.17489587f, -0.07121477f, -0.07996257f, 
    -0.01838486f, 0.14535247f, 0.03082545f, 0.00960436f, 0.12524202f, 0.00896136f, 0.01224720f, 0.10800820f, 
    -0.00996629f, 0.01837690f, -0.16561452f, -0.01018415f, 0.07450143f, 0.27663577f, -0.17579785f, -0.11788794f, 
    0.10554110f, 0.15136889f, 0.02905047f, 0.07771301f, -0.07402018f, -0.09947009f, -0.11530929f, 0.04103603f, 
    0.05545240f, 0.13521698f, -0.03253154f, -0.14388339f, 0.09420276f, 0.03169622f, 0.02983917f, -0.15400040f, 
    -0.01424423f, 0.19508252f, -0.02206428f, -0.21988925f, 0.06038467f, -0.00166754f, 0.05250618f, 0.01201403f, 
    -0.01219878f, 0.04167360f, 0.08260033f, 0.02423689f, 0.12420423f, 0.13461415f, 0.01088956f, 0.13013880f, 
    -0.02889253f, 0.04493522f, -0.17408235f, -0.04763261f, 0.08960262f, -0.07799107f, -0.11921089f, -0.02598567f, 
    -0.07737372f, -0.20945628f, 0.18441014f, 0.16340539f, -0.03724183f, -0.02847193f, 0.04113858f, 0.12393449f, 
    -0.03431187f, 0.00733971f, 0.02933828f, 0.07742261f, 0.08990098f, -0.13858049f, 0.20703875f, 0.04171166f, 
    -0.04733182f, 0.15272607f, -0.01490747f, -0.00594454f, 0.11403722f, -0.04703332f, 0.11128854f, -0.03930989f, 
    0.04289321f, 0.12475953f, -0.19090948f, -0.01639872f, 0.05743000f, 0.04943741f, -0.00143520f, -0.09197307f, 
    -0.02266870f, -0.02893809f, -0.09681167f, 0.15818126f, -0.07930404f, -0.02032593f, 0.22886267f, 0.33778930f, 
    -0.00023455f, 0.03364673f, -0.00957181f, 0.06105028f, 0.07749676f, 0.03564106f, 0.06208647f, 0.07840870f, 
    -0.16508150f, -0.09317941f, 0.03035319f, -0.01274538f, 0.03299902f, -0.06700182f, 0.02270707f, -0.01995338f, 
    0.01821904f, -0.00148082f, -0.03052830f, 0.05348303f, -0.21527669f, 0.12450004f, 0.02868805f, -0.13633814f, 
    0.02886327f, -0.11184835f, -0.07133569f, 0.14275160f, 0.04858618f, 0.06713271f, 0.05488127f, -0.10606271f, 
    -0.01550048f, -0.14893615f, 0.05027450f, -0.09035022f, -0.15191180f, -0.08612337f, 0.07882837f, 0.03917259f, 
    0.19393066f, 0.08682863f, 0.09725957f, 0.16674098f, -0.21553096f, 0.10877511f, 0.24597597f, 0.37529784f, 
    -0.00342441f, 0.09889903f, -0.02965479f, 0.20503834f, -0.08459148f, 0.05562332f, 0.05603179f, 0.00438301f, 
    0.15320954f, -0.13316029f, 0.02064211f, 0.00058834f, 0.00452083f, 0.01163091f, 0.24595134f, 0.08550742f, 
    0.02548228f, 0.05011162f, 0.02285857f, -0.04337798f, 0.31449506f, 0.37077633f, -0.03519756f, 0.21867302f, 
    0.10474890f, 0.09567769f, -0.03244296f, 0.08171085f, 0.01158720f, 0.14654373f, -0.07658757f, 0.20110497f, 
    -0.40692756f, -0.14346123f, -0.04999821f, 0.03652113f, -0.00002820f, -0.07822848f, -0.03564237f, -0.06793331f, 
    -0.16321032f, -0.09842163f, 0.10922468f, -0.02690930f, 0.01976892f, 0.07618421f, 0.10704714f, 0.04008460f, 
    0.02483497f, 0.08077036f, 0.01464019f, -0.02482737f, 0.07974981f, -0.02918663f, 0.02405663f, -0.03943044f, 
    -0.46358001f, 0.13774821f, -0.12129623f, 0.08283591f, -0.01883761f, -0.00079392f, 0.07214522f, 0.07134709f, 
    0.00850235f, -0.13936283f, -0.09720977f, -0.13863152f, -0.18201734f, -0.42257053f, 0.00731915f, -0.15382223f, 
    0.04568063f, 0.05476956f, 0.00010798f, -0.04693225f, 0.02358064f, 0.05542340f, 0.00421174f, 0.07530852f, 
    0.06513645f, 0.17911638f, 0.27019978f, 0.19251728f, 0.10938234f, -0.02709957f, -0.09526473f, 0.00379015f, 
    0.08183461f, 0.00003765f, -0.00528324f, 0.10459214f, 0.08710625f, 0.24215919f, -0.14253271f, 0.11384939f, 
    -0.02805900f, 0.33051553f, 0.06143309f, -0.16590165f, 0.07022065f, 0.04158968f, 0.11576312f, -0.04474484f, 
    0.04634108f, -0.13744782f, -0.21498343f, -0.00481095f, 0.02897065f, -0.00813054f, -0.06343853f, -0.06949283f, 
    -0.06445630f, -0.08664478f, -0.00326639f, 0.04147423f, -0.17655492f, -0.00658103f, -0.13218337f, 0.11303968f, 
    0.06075961f, 0.04307935f, 0.03322532f, 0.03692275f, -0.00395022f, 0.13496986f, 0.09665886f, 0.09546701f, 
    -0.39348003f, -0.17148791f, -0.00706254f, 0.00592545f, 0.05318031f, -0.03577964f, 0.08228748f, -0.01690030f, 
    -0.03680050f, 0.09983807f, -0.06848992f, 0.03393783f, 0.29095533f, -0.17699520f, -0.10260766f, -0.38510418f, 
    -0.02179687f, -0.09635756f, 0.18133445f, -0.17181543f, -0.01201289f, 0.04639339f, 0.02082297f, 0.06138687f, 
    -0.01858929f, -0.26216742f, 0.16644798f, 0.25902304f, 0.03779395f, 0.16840181f, 0.03979205f, 0.13275376f, 
    -0.03601033f, 0.19248316f, 0.17361937f, 0.16792473f, 0.29257339f, 0.21202143f, 0.29753450f, 0.30587220f, 
    0.09799306f, -0.05000198f, -0.16156316f, -0.14515321f, 0.03146764f, 0.03368517f, 0.10018566f, 0.03261208f, 
    -0.02717604f, 0.17146716f, 0.10231534f, -0.04788551f, 0.00388317f, 0.01571818f, -0.18054859f, 0.08208054f, 
    -0.00906501f, 0.00895701f, -0.10381672f, -0.00413408f, -0.15222524f, -0.04374222f, 0.19970438f, 0.06205921f, 
    -0.08704512f, 0.06963550f, -0.03435414f, 0.00727214f, 0.07212013f, 0.09423692f, 0.02519112f, 0.08855710f, 
    -0.06735720f, -0.02042912f, 0.05507270f, 0.03990578f, -0.04319569f, 0.03713116f, -0.03678553f, 0.02903143f, 
    0.04615925f, 0.03901789f, -0.05132029f, 0.05611908f, -0.04181510f, -0.05312719f, -0.05305547f, -0.03883802f, 
    0.04607153f, 0.05228795f, -0.00601138f, 0.03118298f, 0.03268769f, -0.01032946f, -0.01684931f, 0.00251716f, 
    -0.07544515f, -0.05230022f, -0.07044429f, 0.05119902f, 0.05533950f, 0.03559627f, -0.07554178f, -0.04439704f, 
    -0.03328891f, 0.02756099f, -0.03633111f, 0.05092807f, -0.03276536f, 0.04897400f, 0.02415376f, -0.00628972f, 
    -0.01403648f, -0.00775555f, -0.07391649f, -0.06271429f, -0.00199951f, -0.02345733f, -0.04474567f, 0.06236455f, 
    -0.00755925f, 0.05511522f, -0.02300174f, 0.04955370f, -0.02586469f, -0.07999574f, -0.02085459f, 0.00774867f, 
    -0.02757520f, 0.04044207f, -0.01801811f, -0.00845762f, 0.03488701f, -0.05006596f, -0.00413225f, -0.04357817f, 
    -0.05502713f, 0.05106218f, -0.01089807f, 0.03168747f, -0.04551286f, -0.01254117f, -0.04210527f, 0.04176812f, 
    -0.04009241f, 0.02050656f, 0.02469206f, 0.04967113f, -0.05213582f, -0.05122987f, -0.00462367f, 0.01863296f, 
    -0.07720038f, -0.01232786f, -0.05731191f, 0.01329134f, -0.02970215f, 0.06497291f, -0.06574833f, 0.02776082f, 
    -0.05749059f, 0.01837179f, -0.00812422f, -0.02281093f, 0.04125650f, 0.01414603f, 0.04153015f, -0.05701207f, 
    0.02054896f, -0.06473604f, 0.03492986f, -0.05734388f, -0.03362667f, 0.04438221f, -0.01017938f, 0.00062263f, 
    0.05383052f, -0.03810140f, 0.00365481f, -0.07541794f, -0.03314634f, -0.06930865f, -0.06947432f, 0.02839415f, 
    -0.06034765f, 0.05020840f, 0.00388083f, -0.02652587f, 0.05411137f, 0.03243869f, -0.07221450f, -0.06193838f, 
    0.03990807f, -0.03184407f, -0.03063064f, -0.05112245f, 0.05706723f, -0.06463931f, 0.06440442f, 0.06482171f, 
    0.00647165f, -0.01726856f, 0.01470918f, 0.05124814f, -0.00920480f, -0.03761510f, 0.03317157f, -0.01950251f, 
    -0.03188235f, 0.06152004f, -0.02276325f, -0.00893248f, -0.01215513f, 0.02972120f, 0.00791594f, 0.01823013f, 
    -0.05592991f, 0.05200617f, -0.03914065f, -0.06988245f, -0.05119946f, -0.01040069f, -0.03337639f, -0.03368402f, 
    0.04552313f, -0.06402266f, -0.01019460f, -0.05224568f, 0.06135359f, -0.03385050f, -0.00328145f, -0.00517198f, 
    -0.02780863f, 0.01165995f, -0.01442095f, 0.01425763f, -0.00010127f, -0.03048655f, 0.01868967f, 0.05649294f, 
    -0.06570128f, -0.06416814f, 0.01100162f, -0.04036523f, -0.05062502f, -0.05341241f, -0.01108443f, 0.00014923f, 
    -0.03787361f, -0.04378138f, -0.00788713f, 0.04312361f, -0.01281313f, -0.02370774f, 0.04868970f, 0.03003084f, 
    0.06782047f, -0.04962139f, 0.02050393f, -0.05789214f, -0.06029345f, -0.04414719f, 0.05137686f, 0.00500694f, 
    0.00802692f, 0.07489066f, -0.06364250f, 0.04729443f, -0.00523054f, -0.05481683f, -0.07911432f, -0.06276450f, 
    -0.06206922f, 0.02501958f, -0.00829822f, 0.04611292f, -0.03875690f, -0.00846194f, 0.00068392f, -0.03413972f, 
    -0.02867378f, -0.05912316f, -0.03873730f, 0.02704377f, -0.03464958f, 0.02829318f, -0.08444092f, 0.01987392f, 
    -0.01202240f, -0.03476747f, -0.03212308f, 0.00610349f, 0.04861913f, 0.01982068f, -0.03456370f, 0.05821273f, 
    -0.06060312f, -0.04104290f, -0.07360770f, -0.05567718f, 0.03673666f, -0.07732672f, -0.00996163f, -0.07981941f, 
    0.03887617f, -0.05654008f, -0.01213495f, -0.08036847f, -0.00389866f, -0.01594684f, 0.05245676f, -0.07676131f, 
    0.01233785f, -0.01705016f, -0.03190229f, -0.00216835f, -0.04934291f, 0.05337913f, 0.02997311f, -0.01998654f, 
    0.01341196f, -0.06355454f, -0.03727716f, -0.07473329f, -0.01777136f, -0.03502701f, -0.08298866f, -0.00187378f, 
    -0.07402526f, 0.03677141f, -0.04877597f, -0.07976740f, 0.01924771f, -0.07415578f, -0.01288512f, -0.08097990f, 
    -0.04773950f, -0.06371336f, -0.02702157f, 0.00747372f, -0.01394520f, 0.00236047f, -0.04998465f, -0.00987776f, 
    -0.06543822f, -0.08536253f, -0.05894007f, -0.05368396f, -0.04018116f, 0.05240286f, -0.01422354f, -0.02189832f, 
    -0.00995177f, 0.04256712f, 0.03168291f, -0.03237032f, -0.04316657f, 0.05021020f, 0.01237603f, -0.00764118f, 
    -0.02154624f, -0.00081755f, 0.00885109f, -0.04941993f, -0.00314203f, 0.05041746f, 0.01143481f, 0.01736102f, 
    -0.01143309f, -0.02721654f, -0.04732767f, -0.06985477f, -0.05748071f, 0.05119086f, 0.01777678f, -0.06084625f, 
    -0.05941526f, 0.06714125f, -0.01668458f, 0.02763354f, -0.00818607f, 0.00147881f, -0.01113968f, -0.01022068f, 
    -0.05356311f, -0.01294519f, -0.04583711f, 0.01651315f, -0.03688660f, -0.01632119f, -0.08370019f, -0.06366390f, 
    -0.02399825f, 0.01645850f, -0.01035200f, 0.00657158f, 0.03165085f, -0.00865682f, 0.03702793f, -0.05195724f, 
    0.02373101f, 0.04721896f, 0.02854769f, -0.00655385f, -0.06346597f, -0.02405394f, 0.04815929f, -0.06604560f, 
    -0.00061512f, -0.02724094f, 0.04993472f, -0.01344079f, 0.01687509f, 0.01597903f, 0.06122191f, 0.02365873f, 
    -0.00458324f, 0.00320878f, -0.07004193f, -0.02664299f, -0.01624053f, -0.01941911f, 0.03780622f, 0.04180999f, 
    -0.04232905f, 0.00130299f, -0.03257763f, -0.01671139f, -0.04646079f, -0.04564253f, -0.07787853f, -0.02202461f, 
    -0.05848546f, 0.01471136f, -0.06770286f, 0.00302294f, 0.00798932f, 0.04882172f, -0.08197016f, -0.02275648f, 
    -0.03261999f, 0.04375960f, 0.00450012f, 0.01995474f, 0.01626196f, -0.05427542f, 0.04460350f, -0.02395107f, 
    0.00852984f, -0.06488711f, -0.01597760f, 0.03819646f, 0.00211723f, -0.02560977f, 0.05284901f, -0.01013546f, 
    -0.37163448f, 0.17830543f, -0.02159132f, 0.02265259f, 0.07812279f, -0.04142954f, 0.05453090f, -0.11438988f, 
    -0.02686015f, 0.04257306f, 0.00346397f, -0.11391104f, -0.07870869f, -0.05053236f, -0.05826154f, -0.06433281f, 
    -0.07661789f, -0.01501325f, 0.09520856f, -0.07037438f, 0.03476530f, -0.09076797f, -0.01649617f, 0.12520801f, 
    0.05952515f, -0.00629212f, 0.11194045f, 0.11213994f, 0.01567860f, -0.10704579f, 0.05234209f, -0.03658960f, 
    0.08577134f, 0.16152078f, 0.35501024f, 0.23528741f, 0.27746716f, -0.10269032f, -0.00103260f, 0.23748329f, 
    -0.01974835f, 0.12479474f, -0.07935572f, -0.03804741f, 0.01057124f, -0.08696658f, -0.05958229f, 0.06843400f, 
    -0.04734205f, -0.18601170f, -0.16393112f, -0.02954210f, 0.21397027f, 0.03421661f, 0.05337454f, 0.01405175f, 
    0.16508041f, 0.14587161f, -0.05536249f, -0.08241274f, -0.13582392f, -0.13907130f, -0.01030223f, -0.16707452f, 
    0.04101840f, 0.13777663f, 0.02005914f, 0.03302184f, -0.02237959f, 0.07703908f, -0.04414335f, 0.11177991f, 
    0.22829723f, 0.04868699f, 0.11485165f, 0.06310369f, -0.06858917f, 0.02504627f, 0.10670719f, -0.08499698f, 
    0.16929039f, -0.00264964f, 0.05417028f, 0.04468844f, 0.41985863f, 0.00592865f, -0.12426079f, 0.11812097f, 
    -0.06943853f, 0.14232731f, 0.06004392f, 0.12036093f, -0.05661236f, 0.08477239f, 0.07293012f, 0.11558432f, 
    -0.17289737f, 0.21519233f, 0.02681336f, -0.02575105f, 0.08510265f, -0.01343125f, 0.01933611f, -0.00730336f, 
    -0.06464189f, -0.03504390f, 0.05735568f, 0.01066265f, 0.29361382f, 0.06874283f, 0.03477830f, 0.02071290f, 
    0.06929892f, 0.02556841f, 0.07057250f, 0.00515771f, 0.07960131f, 0.07665815f, 0.02185184f, 0.04716087f, 
    0.13618480f, -0.09680727f, -0.17424875f, 0.15428066f, 0.01256550f, -0.02515342f, 0.03725883f, -0.03212611f, 
    0.09669498f, 0.01635471f, -0.09991056f, -0.01417728f, 0.04660113f, 0.10114842f, 0.24608928f, 0.29940110f, 
    -0.06385417f, 0.12600602f, -0.12096495f, -0.08828259f, 0.02017538f, 0.07685935f, -0.01900933f, 0.08867817f, 
    -0.37062863f, -0.10543013f, -0.01027878f, -0.13054548f, 0.10480144f, 0.15725008f, 0.09861758f, 0.07190489f, 
    0.11131687f, 0.23117323f, 0.08293182f, 0.09455733f, 0.30706140f, 0.17752090f, -0.00475359f, 0.02155164f, 
    -0.23172656f, 0.00806013f, 0.00808947f, -0.10835855f, 0.05219346f, -0.14457268f, -0.08909407f, -0.04281491f, 
    0.29115745f, -0.15510817f, 0.21960442f, 0.05846067f, 0.07316828f, 0.02260306f, 0.01332144f, -0.02568877f, 
    0.01187462f, -0.02939896f, -0.11180557f, 0.09331701f, 0.27861843f, 0.14495294f, 0.30860701f, 0.20839970f, 
    -0.05479546f, 0.15418741f, 0.00005518f, 0.15053083f, -0.03820563f, 0.14170437f, 0.13006088f, 0.10537554f, 
    0.37216455f, 0.00356673f, 0.02831926f, 0.02782380f, 0.03071146f, 0.09492019f, 0.13143696f, -0.08591796f, 
    0.02048439f, -0.01908528f, 0.00173927f, -0.07641707f, -0.14791067f, -0.12777165f, -0.01572344f, -0.04199884f, 
    0.01943782f, -0.00041680f, -0.06609344f, -0.03640753f, 0.00686241f, -0.01578541f, -0.08392511f, 0.02906468f, 
    -0.15948801f, 0.00133637f, -0.21064530f, 0.07786758f, 0.04310788f, -0.10786189f, 0.04083255f, -0.08885762f, 
    0.15787803f, 0.11686961f, 0.12035713f, -0.01501337f, -0.06956580f, 0.08040312f, -0.03311912f, -0.26322630f, 
    0.12271617f, 0.05237909f, -0.04774537f, 0.06888358f, -0.00643130f, 0.05061399f, 0.03567272f, -0.03675207f, 
    0.04998390f, -0.15088549f, -0.12526864f, 0.13080288f, 0.00126533f, -0.12018389f, 0.03612764f, 0.03447717f, 
    -0.00787889f, 0.03867883f, -0.07306172f, -0.19107433f, 0.17308497f, -0.09205684f, -0.00474983f, 0.11350936f, 
    -0.10998877f, 0.03306307f, -0.09543123f, 0.02298291f, -0.11866333f, 0.09667952f, 0.02934402f, 0.03975965f, 
    0.16435871f, 0.23809338f, -0.00675761f, -0.15922788f, 0.04398254f, 0.06759791f, -0.02488207f, -0.01570542f, 
    -0.05658169f, 0.09149538f, -0.05016005f, 0.02731643f, 0.16533004f, 0.08606030f, -0.16845314f, 0.16507424f, 
    -0.05503727f, 0.06679622f, -0.01659110f, 0.01500110f, 0.08594483f, 0.04559475f, 0.01810503f, 0.08996983f, 
    -0.06534701f, -0.08575550f, -0.02122401f, 0.25779036f, 0.09308126f, 0.02264027f, -0.05108817f, -0.05199993f, 
    -0.02511103f, -0.00760098f, 0.03009653f, 0.04871346f, -0.14478338f, 0.30594328f, -0.00731357f, 0.13870429f, 
    0.09124909f, 0.06732883f, 0.19515561f, 0.12551299f, -0.00706135f, 0.06683527f, 0.06224512f, 0.05895398f, 
    0.01477299f, 0.00877468f, -0.06356261f, -0.19028370f, 0.03590738f, -0.01285899f, -0.09268750f, -0.02058333f, 
    -0.03514411f, 0.04730855f, -0.11605037f, -0.01092223f, 0.06882162f, -0.18936464f, -0.19235557f, -0.03207959f, 
    0.04722226f, -0.03715909f, -0.14772463f, -0.15712757f, -0.00059629f, -0.06780446f, 0.10129560f, 0.01645923f, 
    -0.09308060f, -0.20184605f, 0.07750539f, -0.03499039f, 0.04467287f, 0.02309094f, 0.08939094f, 0.06255104f, 
    -0.00609330f, 0.14496757f, -0.00822586f, 0.05243219f, 0.11185943f, 0.13858169f, 0.00510542f, -0.05158613f, 
    -0.08103717f, 0.03832121f, -0.05006784f, 0.04944455f, -0.01564348f, -0.02736597f, 0.04601397f, -0.06529528f, 
    0.27574369f, -0.11773865f, -0.06271338f, 0.01792221f, -0.02515369f, 0.06035841f, 0.05687791f, -0.08135388f, 
    -0.01332524f, -0.02861429f, -0.11034257f, 0.00620356f, -0.11429056f, -0.19100533f, -0.02853244f, 0.06354106f, 
    0.09574972f, 0.08032248f, -0.06563330f, 0.01316290f, -0.07252170f, -0.08990814f, 0.01868739f, -0.02107088f, 
    -0.06497891f, -0.02775645f, -0.06554906f, -0.06345975f, 0.00136805f, 0.03106202f, 0.05411428f, 0.04411628f, 
    -0.05393412f, -0.04575108f, 0.01658921f, -0.03454293f, 0.05333600f, 0.06523785f, -0.06714883f, -0.04304412f, 
    -0.01703743f, -0.06706186f, -0.03043284f, -0.07128914f, -0.00129915f, -0.06974420f, -0.00295039f, 0.04960098f, 
    0.02484188f, -0.06654211f, 0.01555177f, -0.06650843f, 0.00606346f, -0.06322993f, -0.02541157f, 0.06095544f, 
    -0.04408741f, 0.04471831f, 0.00218406f, -0.00459179f, 0.05124960f, -0.04272436f, -0.06179840f, 0.02684195f, 
    0.03282627f, -0.05006493f, -0.02366798f, -0.05104654f, 0.01943768f, 0.03357036f, -0.02477146f, 0.01743704f, 
    -0.04537911f, 0.00758496f, -0.01937897f, 0.03290788f, 0.00550736f, 0.00828015f, -0.01457992f, -0.06286497f, 
    0.05339848f, -0.07397897f, 0.03361182f, 0.01262299f, -0.00276682f, 0.01495337f, -0.03400108f, -0.05384437f, 
    -0.02077055f, 0.06379802f, -0.04248632f, 0.01387596f, 0.00755776f, -0.05189810f, -0.00826268f, -0.00880233f, 
    -0.03916725f, -0.02678436f, -0.03185020f, 0.00101222f, -0.00235453f, -0.05502471f, -0.01307664f, -0.05380630f, 
    -0.04069227f, 0.00743968f, 0.05123819f, 0.00576147f, 0.04438053f, 0.01955773f, 0.05776691f, -0.00920638f, 
    -0.01378277f, -0.06913772f, -0.04669115f, -0.01770077f, 0.01347528f, 0.00946448f, 0.00977901f, -0.06432385f, 
    -0.02113466f, -0.03933457f, -0.01244892f, 0.04890912f, 0.00100009f, -0.03367560f, -0.02857491f, 0.06345107f, 
    -0.04192212f, -0.05729062f, 0.02388185f, 0.01964124f, 0.03289146f, 0.02090898f, 0.05773436f, -0.02781085f, 
    -0.04568411f, 0.03934829f, -0.05320429f, -0.05554939f, -0.05531879f, -0.01953051f, 0.00287261f, -0.03499358f, 
    -0.04086431f, 0.06570540f, 0.00457538f, 0.01831277f, -0.06654631f, -0.05035141f, 0.04252068f, -0.07784104f, 
    -0.05546679f, -0.05782840f, 0.04000898f, 0.03625502f, 0.03868268f, -0.04844846f, -0.05468470f, 0.02838161f, 
    -0.03535754f, 0.06567887f, -0.01721611f, 0.02407749f, 0.05050112f, -0.00264708f, 0.04350559f, 0.01446698f, 
    -0.04657708f, 0.02117386f, 0.06563647f, -0.01928992f, 0.00605758f, 0.00010452f, -0.01749026f, -0.03029919f, 
    0.00340897f, -0.06965223f, -0.07683261f, -0.03151458f, 0.04761510f, 0.05162603f, 0.01992211f, 0.00030181f, 
    -0.05016918f, 0.05719941f, -0.02253352f, 0.03962528f, 0.05886510f, 0.04986607f, -0.02743954f, 0.04134923f, 
    -0.07382947f, -0.00577838f, 0.01520756f, 0.04876782f, -0.07284582f, -0.02361635f, -0.04131994f, -0.05284953f, 
    -0.04813669f, -0.06768388f, 0.05089242f, 0.00584315f, -0.03152187f, -0.04635656f, -0.03818431f, -0.07503286f, 
    0.05573436f, 0.04048951f, 0.05268618f, -0.04265457f, -0.04267590f, -0.04248832f, -0.00011199f, 0.01607060f, 
    0.00151326f, -0.02107457f, -0.05430349f, 0.03679811f, -0.00395735f, -0.03085599f, -0.05576283f, -0.07331245f, 
    0.05636337f, -0.00266213f, 0.01323258f, -0.07984123f, 0.04550090f, 0.01224158f, 0.01693166f, 0.06308424f, 
    -0.04520907f, -0.07367297f, 0.01182740f, -0.05202585f, -0.05719531f, 0.00439158f, -0.04244779f, -0.04329578f, 
    -0.05061751f, -0.02435661f, -0.05475857f, 0.06339876f, -0.04634393f, -0.04082154f, 0.01968816f, -0.01363345f, 
    0.01087334f, -0.01607579f, -0.05670715f, 0.05002450f, 0.00145802f, -0.04348242f, -0.05103364f, 0.05888978f, 
    0.03881431f, 0.06407765f, -0.03034866f, -0.06853461f, -0.05694067f, -0.07788528f, -0.06861950f, -0.05519928f, 
    -0.02890613f, 0.02768543f, -0.03052747f, -0.03190465f, -0.02547589f, 0.05689874f, 0.02880962f, 0.00788610f, 
    0.00428478f, -0.04234726f, -0.02282756f, 0.01471142f, -0.07365014f, 0.02092137f, 0.01155648f, -0.05706614f, 
    -0.06392623f, 0.03638433f, -0.06908840f, -0.01549617f, 0.01600004f, -0.04628056f, 0.04203815f, 0.03288801f, 
    0.06178615f, -0.02710490f, 0.05784545f, 0.04229823f, 0.01397911f, -0.02218086f, -0.02522676f, -0.06321856f, 
    -0.02763716f, -0.06528257f, 0.05190630f, -0.06082541f, -0.07627554f, -0.06123852f, -0.03925994f, 0.06431111f, 
    0.01629197f, -0.01259135f, 0.00595151f, -0.00152080f, 0.03465250f, -0.01441680f, -0.04557488f, 0.05156020f, 
    0.06347258f, -0.06245351f, 0.06123188f, -0.03148214f, -0.05439531f, -0.02286777f, -0.06689831f, 0.06156626f, 
    0.03105063f, 0.01998499f, -0.07764237f, 0.02648276f, -0.06906356f, 0.06741159f, 0.01796402f, -0.01429870f, 
    -0.04445484f, 0.06750095f, 0.02244000f, -0.00703005f, -0.05707347f, -0.06215888f, 0.01765002f, 0.03676624f, 
    0.03365399f, 0.04175606f, -0.01545055f, -0.06717066f, -0.01752695f, -0.07343394f, -0.00260857f, -0.02350611f, 
    -0.04966488f, 0.02477173f, -0.04542515f, 0.00404672f, 0.01031307f, -0.04123598f, 0.04766695f, -0.04216566f, 
    0.05384873f, -0.00401151f, 0.05861795f, 0.00377969f, 0.01624594f, 0.04655160f, -0.02786305f, 0.02038674f, 
    -0.07289843f, -0.02459787f, 0.05428709f, 0.02084250f, -0.01102106f, 0.02863711f, -0.01697028f, 0.01755360f, 
    -0.03355399f, 0.01585066f, -0.02517001f, 0.02437550f, -0.02180438f, -0.05411348f, 0.00816272f, 0.05568940f, 
    0.03463824f, -0.07686607f, -0.05566422f, -0.00179556f, -0.04326068f, 0.03244906f, 0.02241492f, -0.02491755f, 
    -0.01044796f, 0.00375119f, -0.00940688f, -0.05368291f, 0.02975516f, 0.02143212f, 0.03165042f, -0.05406453f, 
    -0.02336567f, -0.08250362f, -0.03344961f, -0.02768804f, -0.05412788f, -0.04494726f, -0.03097257f, -0.00199584f, 
    0.04817853f, -0.05358719f, -0.05304201f, 0.05939136f, -0.07214037f, -0.02330855f, 0.03150405f, -0.02007970f, 
    0.02396639f, -0.02060047f, 0.01163852f, 0.01760691f, -0.01490599f, -0.05618940f, 0.03964705f, -0.06382189f, 
    -0.01771465f, 0.04022602f, 0.04135929f, 0.01138846f, 0.03726222f, 0.05478372f, 0.02118486f, -0.03121776f, 
    -0.01610857f, 0.01657091f, -0.07412300f, -0.05334527f, 0.03297878f, -0.02218149f, 0.01281206f, 0.01422734f, 
    0.05622752f, -0.06242725f, 0.01583823f, -0.06011350f, -0.00390462f, 0.01981718f, -0.01007682f, -0.07454089f, 
    -0.02167307f, -0.07145913f, -0.05363104f, 0.05083202f, -0.00025750f, -0.04624395f, 0.03031506f, 0.03517713f, 
    0.00358516f, 0.00026471f, 0.06164303f, 0.00903971f, 0.01196957f, -0.01315038f, 0.02700643f, -0.00101329f, 
    0.00968371f, -0.04716695f, -0.05506102f, 0.03356698f, -0.05289867f, 0.03484914f, 0.01625050f, -0.03961069f, 
    -0.00050905f, 0.04912703f, 0.04589214f, 0.01511527f, -0.05446288f, 0.00262232f, 0.02066776f, -0.04947806f, 
    0.01549072f, -0.06927231f, -0.07143708f, 0.06288431f, 0.00077169f, 0.06231531f, -0.02909060f, 0.04005319f, 
    -0.01079187f, 0.04576010f, -0.02538763f, -0.05223353f, -0.00577857f, -0.05224535f, 0.02270023f, -0.05670515f, 
    -0.05999556f, -0.07628464f, -0.02017532f, 0.03699735f, 0.05943089f, -0.05959826f, 0.05589100f, 0.04680520f, 
    0.05189896f, -0.06489602f, -0.05653856f, 0.03448083f, -0.07090287f, 0.01687988f, -0.02265816f, -0.05404197f, 
    0.00216050f, -0.02036230f, 0.05016608f, 0.01900878f, 0.02994510f, 0.04199168f, -0.00890512f, -0.01704573f, 
    -0.07583986f, 0.03882272f, 0.01584709f, -0.04497610f, -0.06149585f, -0.07381438f, -0.01023904f, 0.03954402f, 
    0.03281124f, -0.04731177f, -0.04731484f, -0.04423742f, -0.06053395f, 0.02177132f, 0.01080550f, -0.06524561f, 
    0.02508526f, -0.05399921f, -0.05521664f, 0.03445681f, -0.08276048f, -0.03713629f, 0.03124277f, -0.05566511f, 
    -0.05449485f, -0.03091338f, -0.06609993f, 0.04707887f, -0.07072249f, 0.01346658f, -0.03783534f, -0.06654882f, 
    -0.01912454f, 0.03537765f, 0.06068828f, 0.01795798f, -0.00088123f, -0.07076426f, -0.06680866f, 0.04585288f, 
    -0.02748812f, -0.05014332f, 0.00357762f, 0.02051365f, 0.02317328f, 0.03181064f, -0.01415522f, -0.07424882f, 
    -0.03315266f, -0.03706523f, -0.02023237f, -0.06776894f, 0.01602237f, 0.01319262f, 0.00752461f, -0.04751762f, 
    0.05891047f, -0.02856191f, -0.01078855f, 0.05974895f, -0.05574406f, 0.03230872f, -0.03540276f, 0.02123483f, 
    0.04482778f, 0.02762273f, 0.00286952f, -0.01417890f, 0.01359040f, 0.03043615f, -0.06196211f, 0.02091871f, 
    -0.05079750f, 0.00302532f, 0.03149596f, -0.03808527f, 0.00830306f, 0.02814903f, 0.04835332f, -0.05118509f, 
    0.03364398f, 0.02469909f, 0.05568061f, -0.01518253f, -0.00931583f, -0.05476383f, -0.04119172f, -0.04673104f, 
    -0.14938192f, -0.03954834f, 0.08996897f, 0.10023871f, -0.07392610f, -0.16803451f, 0.11503057f, -0.06036539f, 
    -0.01812102f, -0.04606267f, -0.11772714f, -0.02380138f, -0.24276902f, -0.18792462f, -0.01498988f, -0.14778312f, 
    -0.04286783f, -0.04674572f, 0.03730509f, -0.04310567f, -0.03154632f, -0.10308740f, 0.19957557f, -0.03655294f, 
    -0.10461988f, 0.06253988f, 0.10273245f, 0.14348117f, -0.04988658f, -0.10902111f, 0.09035908f, -0.16041644f, 
    -0.02733174f, 0.09102897f, 0.19561201f, 0.17213044f, -0.01437262f, 0.00786889f, -0.14969620f, 0.15126821f, 
    0.10006274f, 0.18472090f, -0.00180012f, 0.02028096f, 0.04604858f, -0.10991527f, -0.01351941f, -0.07659904f, 
    -0.18051055f, -0.10074709f, -0.08591727f, 0.07351456f, -0.13804491f, -0.00742606f, 0.02311451f, -0.02042008f, 
    -0.06951711f, 0.00127206f, 0.03942937f, -0.13765103f, 0.11698748f, -0.10246053f, -0.06854048f, -0.09980910f, 
    -0.15256464f, 0.01662029f, 0.02129534f, 0.17912821f, -0.06294896f, -0.19201386f, -0.14423686f, 0.10526700f, 
    -0.09637177f, -0.09363725f, 0.02992132f, 0.11682129f, 0.17648302f, 0.10282338f, 0.07399318f, -0.06677978f, 
    0.06331583f, 0.02272389f, -0.02432302f, 0.01605796f, 0.00800865f, -0.03884020f, -0.22127692f, 0.11087857f, 
    -0.04661893f, 0.16451645f, -0.10570266f, 0.05534185f, -0.00006297f, 0.11835426f, -0.04653814f, 0.07020605f, 
    -0.28751200f, 0.25611883f, 0.17452027f, 0.15916619f, -0.05171407f, 0.03863462f, 0.07588713f, 0.04474487f, 
    0.06151073f, -0.05033407f, 0.02608084f, 0.13854024f, -0.20531954f, 0.24954340f, -0.06897894f, -0.01745876f, 
    -0.05046839f, 0.04680634f, 0.10342850f, 0.11228873f, -0.10050881f, 0.21110885f, -0.09780191f, 0.06890303f, 
    -0.04380673f, 0.08287119f, -0.11596765f, 0.05045383f, 0.10423118f, 0.01336828f, -0.06185942f, -0.06708511f, 
    0.05541342f, 0.11369108f, 0.01351092f, -0.03661766f, 0.22773542f, 0.05219150f, -0.00338433f, -0.05018374f, 
    -0.01306155f, 0.01557269f, 0.04699409f, 0.04288251f, -0.07519339f, 0.00523460f, 0.01707886f, 0.07967807f, 
    -0.28455225f, 0.09436167f, 0.12606135f, -0.04742739f, -0.08073752f, -0.00364468f, 0.13270074f, 0.04975289f, 
    0.09153922f, 0.20066860f, -0.00581276f, 0.11739244f, 0.19310577f, -0.06018886f, 0.06910238f, 0.06012039f, 
    0.04497536f, 0.01103495f, -0.05744827f, -0.11109356f, -0.04787737f, -0.07932187f, -0.00758263f, -0.05337502f, 
    0.31565219f, -0.15471913f, -0.04045681f, 0.18755732f, 0.15127268f, -0.03142961f, 0.03516097f, 0.09701965f, 
    0.03554197f, -0.07772874f, -0.17336272f, -0.07402238f, 0.43040320f, 0.24205481f, -0.12401096f, 0.06370278f, 
    -0.12874240f, 0.05507746f, -0.08707859f, 0.16017936f, -0.09037939f, -0.00206825f, -0.00297329f, 0.02866703f, 
    0.08850012f, 0.18396299f, 0.05899920f, -0.13341923f, 0.06933433f, 0.11327321f, -0.12621626f, 0.00271423f, 
    -0.04842923f, 0.02207591f, -0.14852248f, -0.12071212f, -0.02778305f, 0.05599134f, -0.07197160f, -0.17571688f, 
    -0.01535615f, -0.03331686f, 0.23403408f, -0.04622376f, 0.06350412f, 0.05214761f, 0.07404965f, 0.10155633f, 
    0.14435823f, 0.23553020f, -0.00752151f, 0.24623346f, -0.04753730f, 0.05680677f, 0.19014491f, 0.18791527f, 
    0.09669068f, 0.04614285f, 0.06899088f, 0.00922260f, 0.40994444f, -0.07417634f, 0.02251050f, 0.11842195f, 
    0.11421515f, -0.10745106f, 0.03979446f, -0.19675301f, -0.02542619f, -0.07302039f, 0.12249175f, -0.05649844f, 
    0.09178033f, -0.04298869f, 0.21733919f, 0.31013504f, 0.14662060f, -0.05824577f, 0.18338846f, 0.12151726f, 
    -0.07798866f, -0.12864655f, -0.09403519f, 0.15271263f, 0.09591308f, 0.21193771f, 0.11399584f, 0.11685441f, 
    0.08311816f, -0.01055463f, 0.09147926f, 0.15943421f, -0.06184622f, -0.08286288f, -0.08620447f, 0.04953801f, 
    0.17401451f, -0.14709958f, -0.06519261f, -0.01862928f, -0.01071647f, 0.03179804f, 0.12097460f, -0.05755644f, 
    0.07228357f, 0.04531460f, -0.12989986f, -0.01883974f, -0.11897468f, -0.21259119f, 0.05487353f, -0.08432604f, 
    0.00277456f, -0.16502328f, 0.13515390f, -0.03471102f, -0.11177498f, -0.03912273f, 0.10460501f, -0.07665636f, 
    -0.22133505f, 0.15413117f, -0.14411978f, -0.19656926f, 0.09254845f, -0.05699713f, -0.06356235f, -0.02094256f, 
    -0.05520428f, -0.14327942f, 0.04511080f, 0.10534331f, 0.30131751f, 0.29494837f, -0.22977239f, -0.15459576f, 
    -0.08367375f, -0.09735883f, 0.04753008f, -0.11605193f, -0.04251588f, -0.04858050f, -0.01543058f, 0.00443168f, 
    0.24913193f, -0.07898514f, 0.22359814f, 0.29734364f, -0.06085490f, -0.05785022f, 0.06328592f, 0.11869073f, 
    0.07521471f, 0.00395166f, 0.04639368f, -0.14228225f, 0.20926359f, 0.04014581f, 0.15675834f, 0.15335827f, 
    -0.11376712f, 0.01266211f, -0.25056052f, -0.00729376f, -0.06701198f, -0.07104402f, -0.01202092f, -0.04008219f, 
    -0.04551155f, 0.15247348f, -0.18306106f, -0.00306161f, 0.04392342f, 0.09385512f, 0.16706108f, -0.02997898f, 
    0.10475466f, 0.04493043f, 0.01184746f, -0.03129281f, 0.14856356f, 0.01526443f, -0.24204740f, 0.02318110f, 
    -0.02183291f, 0.00072028f, 0.02608711f, -0.07525637f, 0.02401066f, -0.14690523f, -0.08476970f, 0.12799366f, 
    -0.10738517f, 0.12731561f, 0.13092029f, 0.20557663f, -0.04424330f, 0.10987610f, -0.04242897f, -0.04618940f, 
    -0.18656306f, -0.02504612f, 0.01813303f, 0.13367328f, 0.30046332f, 0.02814791f, -0.06553475f, -0.18527369f, 
    -0.03773598f, 0.06286421f, 0.07169854f, -0.24349035f, 0.05810924f, 0.05217124f, -0.06505185f, 0.12605913f, 
    -0.05560868f, -0.07930642f, -0.13638787f, 0.21002868f, -0.18229984f, 0.03774058f, -0.10690850f, 0.03359953f, 
    0.04718487f, 0.05696821f, -0.03405586f, -0.00389518f, 0.06058744f, 0.19248748f, 0.06364634f, 0.20937163f, 
    -0.04217707f, -0.08232852f, -0.00109718f, 0.04587920f, -0.00416852f, 0.03906805f, -0.07457884f, 0.10622269f, 
    -0.17360300f, 0.04238002f, 0.04672436f, -0.08994249f, 0.05827969f, -0.04274706f, 0.05633637f, 0.06902717f, 
    0.08436643f, -0.01332431f, 0.05327949f, -0.01892891f, 0.19477952f, -0.11568470f, 0.10926580f, -0.09425832f, 
    -0.20417881f, -0.00322194f, -0.04130451f, 0.01575745f, -0.10034211f, -0.08891740f, 0.02931501f, -0.05426838f, 
    -0.01266616f, -0.04337199f, 0.00959407f, -0.28611371f, 0.08466119f, -0.00682963f, 0.08392794f, 0.13524792f, 
    0.10607018f, -0.06152113f, -0.03928762f, -0.00821342f, -0.13985133f, -0.07270972f, 0.05375661f, -0.02336898f, 
    0.16840534f, 0.04496235f, 0.03124753f, 0.00156191f, 0.10576413f, 0.11585695f, 0.04058467f, 0.18726009f, 
    0.10169742f, 0.02125220f, 0.05635060f, 0.20361432f, -0.13681506f, -0.02978560f, -0.05893016f, -0.04378942f, 
    0.11636101f, 0.06907470f, 0.00994237f, 0.03260379f, 0.01955098f, -0.08988958f, 0.14038083f, -0.09956102f, 
    0.08504508f, 0.04173983f, 0.06040778f, 0.12370746f, -0.18383746f, -0.06292697f, 0.05509282f, -0.00565744f, 
    0.19890821f, 0.08812118f, -0.24673684f, -0.20691176f, -0.01125213f, -0.09337461f, -0.08272114f, -0.00639044f, 
    -0.06319019f, 0.03736439f, 0.01442403f, -0.00638413f, 0.29101482f, -0.20181419f, 0.18469946f, -0.01027952f, 
    0.10060526f, 0.00264798f, 0.10735280f, 0.08502402f, 0.00082802f, -0.03738108f, 0.03217867f, 0.10099494f, 
    -0.07095729f, -0.28289643f, 0.07200804f, -0.06012502f, -0.05768843f, 0.09667180f, -0.02690015f, 0.09768353f, 
    -0.04795396f, 0.05276434f, -0.03930396f, -0.05781832f, -0.28706607f, 0.09747662f, -0.00734242f, -0.08666500f, 
    -0.01812113f, -0.01436875f, -0.02659552f, -0.04693820f, -0.00861247f, 0.05032469f, 0.04151934f, 0.07247837f, 
    0.09538763f, -0.00011577f, 0.03542706f, 0.04158293f, 0.15769479f, 0.14125082f, 0.04288042f, -0.02979359f, 
    0.06087469f, 0.01211621f, 0.03313485f, 0.12929134f, 0.06476621f, 0.23175371f, -0.00538092f, 0.00812218f, 
    -0.13694900f, -0.02063923f, 0.10954913f, -0.02312269f, 0.10373913f, -0.05866089f, -0.04807473f, 0.04148868f, 
    0.01856518f, 0.13335480f, 0.14277981f, -0.26611513f, 0.05729520f, 0.07160087f, 0.05155348f, -0.05428704f, 
    0.00078500f, -0.07277285f, -0.05984338f, 0.08015364f, 0.08893608f, -0.17424271f, 0.17524146f, -0.05106821f, 
    0.00458180f, 0.05550459f, 0.01818906f, -0.07630469f, 0.04643365f, 0.05917384f, 0.02385103f, 0.05219194f, 
    -0.31734163f, -0.07527474f, 0.14227447f, -0.10579910f, -0.02570061f, -0.12059055f, -0.02342905f, 0.04065622f, 
    0.05290420f, 0.01551817f, 0.01323201f, 0.04034048f, 0.07232469f, 0.04007019f, 0.05718710f, 0.07882860f, 
    0.07781956f, -0.04300962f, 0.03710230f, 0.12574472f, -0.17078841f, 0.04569853f, 0.17173058f, -0.08396792f, 
    0.24756980f, -0.01100017f, 0.22500715f, 0.18031766f, -0.01431049f, -0.04433474f, 0.03172290f, -0.15342410f, 
    -0.10843772f, -0.05983676f, 0.06036965f, -0.01698996f, 0.13375369f, -0.13623595f, 0.04114207f, 0.22177242f, 
    -0.19180673f, 0.09659547f, 0.04894717f, -0.00401104f, -0.03172426f, -0.02764452f, -0.07202376f, 0.02739455f, 
    -0.26250356f, 0.18203592f, -0.05128175f, 0.16403106f, -0.12457830f, 0.00968153f, -0.02495711f, -0.00720382f, 
    0.00402799f, -0.00595133f, -0.09154186f, 0.16841500f, -0.15356159f, 0.12315321f, -0.06856958f, 0.06309582f, 
    -0.00766767f, -0.01571030f, 0.05753291f, 0.07775656f, 0.05456682f, -0.01311025f, 0.01595495f, -0.04360054f, 
    -0.22995895f, -0.13304187f, 0.04487796f, 0.17071958f, -0.07038825f, 0.05785453f, 0.08463788f, 0.05690835f, 
    0.00193604f, -0.10792104f, 0.07736942f, -0.00791485f, -0.15177199f, -0.08784186f, -0.24223813f, 0.12513700f, 
    -0.03482889f, 0.12952277f, 0.14549507f, -0.02991429f, 0.04868059f, -0.02764240f, -0.17617808f, -0.02140787f, 
    -0.11227144f, 0.24593565f, 0.05901735f, -0.16843018f, -0.07965506f, -0.05844429f, -0.06470126f, 0.00693471f, 
    -0.00240873f, -0.04449439f, -0.00024888f, 0.01619262f, 0.38812417f, -0.44871357f, 0.11327329f, -0.00275724f, 
    -0.05109379f, -0.05412982f, -0.14696258f, -0.22548459f, -0.04028529f, -0.03281708f, -0.03931725f, 0.06897575f, 
    -0.00618082f, 0.19014652f, -0.08318895f, 0.26898304f, 0.07148135f, 0.00162773f, 0.15916407f, 0.04677521f, 
    0.11273906f, -0.03384500f, 0.06133134f, 0.08443606f, 0.14321639f, 0.24624971f, -0.01295862f, -0.04838504f, 
    0.05479104f, -0.13973874f, 0.03791221f, 0.11998361f, -0.04903292f, -0.02667150f, -0.14371000f, 0.02812633f, 
    -0.12074369f, 0.10192087f, 0.14685003f, 0.06417405f, -0.01324813f, -0.00853690f, -0.04175632f, -0.07265557f, 
    -0.07499796f, -0.07247309f, 0.06296067f, -0.06841774f, -0.03195447f, 0.05298436f, 0.17898168f, 0.06270532f, 
    -0.00482199f, -0.00229511f, -0.08024259f, -0.01281206f, -0.11685159f, 0.06140921f, 0.02008530f, 0.04548112f, 
    -0.20346275f, 0.14673880f, 0.13717096f, 0.13580331f, 0.03922592f, -0.00388645f, -0.07216871f, 0.06640451f, 
    -0.01353526f, 0.08922502f, 0.02612308f, 0.03106716f, 0.20735285f, 0.36193016f, 0.13979606f, 0.12635343f, 
    0.07290768f, 0.01047341f, -0.08045828f, -0.03109234f, 0.00259161f, 0.25229913f, 0.08598417f, 0.06887625f, 
    -0.34217682f, 0.05544351f, -0.11519647f, -0.09209493f, 0.11670516f, 0.08099620f, 0.00000352f, 0.02320182f, 
    -0.01729371f, 0.03876808f, 0.01099626f, -0.14288406f, -0.31971970f, -0.04310497f, -0.05442013f, -0.12087312f, 
    0.04901088f, 0.02086237f, 0.16974108f, 0.06803397f, 0.02786399f, -0.07462991f, -0.03466167f, 0.12775162f, 
    0.15288465f, 0.05899020f, -0.05459085f, 0.20744319f, 0.08216444f, -0.10674391f, 0.09581787f, -0.01385725f, 
    0.03905678f, 0.06991889f, 0.19349913f, 0.07016057f, 0.01188025f, 0.20707929f, -0.11558422f, -0.04614446f, 
    -0.01012300f, 0.05572933f, 0.04126230f, 0.00541208f, 0.07043012f, -0.08306839f, 0.08159688f, -0.03630551f, 
    -0.17456740f, -0.09389818f, -0.08909401f, 0.20616411f, 0.18474199f, 0.14494418f, -0.02983025f, 0.00271823f, 
    -0.04132189f, 0.11456957f, -0.00487394f, -0.10635597f, 0.06815711f, -0.08856010f, -0.14893135f, 0.02519176f, 
    0.03980977f, 0.12166183f, -0.03148079f, -0.04443693f, -0.00562611f, -0.01408873f, 0.01832514f, 0.03061010f, 
    -0.00370195f, 0.13990307f, 0.07139885f, -0.30290762f, -0.12711366f, -0.01107170f, 0.02991615f, 0.09828060f, 
    0.05763373f, 0.15850081f, -0.07143852f, -0.01306446f, 0.12758437f, 0.00751042f, -0.01544128f, 0.34094167f, 
    -0.01582459f, 0.14191431f, -0.10260385f, 0.05142169f, 0.00465193f, -0.02342670f, 0.15467107f, 0.01319830f, 
    0.02694297f, -0.22186427f, 0.01896873f, 0.25535488f, -0.05387863f, 0.07349185f, 0.10574438f, 0.04804950f, 
    -0.05577916f, -0.00258133f, -0.00180689f, 0.10513470f, 0.11302283f, 0.06675044f, -0.00704331f, 0.09258816f, 
    -0.02758865f, 0.12041478f, 0.05517835f, -0.00822091f, 0.01407491f, 0.03762669f, 0.02877278f, 0.01186239f, 
    0.32883117f, -0.07671085f, -0.10331455f, 0.15490003f, 0.11443710f, 0.10119208f, 0.00866894f, -0.09241386f, 
    -0.05746033f, 0.05849817f, -0.14485604f, 0.00772112f, 0.12171947f, -0.02989997f, 0.11780524f, 0.27100065f, 
    -0.01956476f, 0.10697111f, -0.11430204f, -0.03851762f, 0.01808695f, 0.00899187f, 0.04356465f, 0.11622195f, 
    -0.27341223f, -0.09215336f, -0.02146625f, -0.12232728f, 0.00966846f, 0.08883461f, 0.13175522f, 0.10106820f, 
    -0.02399679f, 0.24228363f, 0.00122201f, 0.08208159f, -0.05350608f, 0.34133163f, -0.10823435f, -0.19069929f, 
    -0.11587955f, -0.14154495f, -0.03848860f, 0.07453146f, 0.03107285f, -0.08153152f, -0.08934022f, -0.05016178f, 
    0.14770980f, -0.01096444f, 0.05902160f, 0.05535815f, -0.08992370f, -0.06822632f, 0.06482821f, 0.02575536f, 
    0.07985689f, -0.12842311f, -0.00006466f, 0.09639965f, 0.16439968f, -0.00260198f, 0.28250170f, 0.32570538f, 
    -0.07328442f, 0.17290471f, 0.04206669f, 0.07590836f, -0.08616957f, -0.01182318f, -0.05777547f, 0.05206458f, 
    -0.04479520f, -0.07383700f, -0.08133937f, -0.04470492f, -0.04625231f, 0.04419742f, 0.02642305f, 0.03159986f, 
    0.02199499f, -0.06096141f, 0.00723210f, 0.00490299f, -0.06599492f, 0.04901350f, 0.00066802f, 0.03684686f, 
    0.05273918f, 0.04890411f, -0.02984016f, -0.03162485f, 0.03972941f, 0.02992653f, -0.00712649f, 0.05070803f, 
    0.00756558f, 0.00652024f, -0.05456093f, -0.06672969f, 0.01870467f, -0.06166682f, -0.01426346f, 0.00623398f, 
    -0.02460875f, -0.03031170f, -0.03635062f, -0.02317439f, 0.00862250f, 0.05532286f, 0.02028569f, -0.07195602f, 
    -0.04024957f, 0.04728955f, 0.05554968f, 0.02343478f, 0.04554158f, -0.05318825f, 0.02108483f, 0.02302010f, 
    -0.02132743f, -0.01148743f, 0.00537168f, -0.07214524f, -0.02501671f, 0.03803100f, 0.05573175f, -0.03730360f, 
    -0.06058168f, 0.02984864f, -0.07860625f, -0.04576205f, 0.04769476f, -0.03461043f, -0.05552033f, -0.05917411f, 
    -0.00577310f, -0.06568063f, 0.06095386f, 0.02504787f, 0.03677747f, -0.01711689f, 0.04319972f, -0.04084348f, 
    -0.04331561f, 0.04215089f, -0.06008867f, 0.04573502f, 0.01345968f, -0.07421814f, -0.05445310f, -0.03387416f, 
    -0.02955413f, 0.01329141f, -0.04453409f, -0.01031802f, -0.03753812f, 0.01318273f, -0.06236862f, -0.05082862f, 
    -0.02648914f, -0.00437642f, 0.00835174f, -0.03571967f, -0.00357401f, 0.04600898f, -0.02835668f, 0.04828157f, 
    0.02120401f, -0.04560658f, -0.03168820f, 0.04434163f, 0.02503147f, 0.06115542f, -0.07932243f, -0.00171126f, 
    -0.06692019f, -0.04603753f, 0.03674947f, -0.01410984f, -0.02504143f, 0.01570309f, -0.01086943f, -0.07765421f, 
    -0.07278316f, -0.06608232f, -0.04265557f, 0.03285065f, 0.03476283f, 0.01867425f, 0.03859877f, -0.06798702f, 
    -0.06638976f, -0.07773612f, -0.01331011f, -0.05922581f, -0.03657670f, 0.03930360f, -0.00735734f, -0.06411845f, 
    0.03996481f, -0.07938614f, 0.03602761f, -0.01006594f, -0.06242456f, -0.05591991f, 0.00675013f, -0.05381862f, 
    0.03697105f, -0.06303570f, -0.05110233f, 0.05027732f, -0.04412128f, 0.01152669f, 0.01261392f, 0.01711084f, 
    -0.01324226f, 0.00230126f, -0.04323623f, -0.00406879f, -0.07442103f, -0.00956756f, -0.02273970f, 0.06184652f, 
    -0.02338573f, -0.05818953f, 0.02284571f, 0.02272191f, -0.07210702f, -0.02153197f, 0.02151955f, -0.05399763f, 
    0.03269519f, -0.08194615f, -0.00947280f, -0.00384908f, 0.03729984f, -0.04744061f, -0.03901531f, -0.04022257f, 
    0.02009206f, -0.03648277f, 0.03889035f, -0.01806915f, 0.02340474f, 0.01770208f, -0.02920214f, -0.05071560f, 
    -0.04270097f, 0.01838357f, -0.00119195f, 0.00088437f, -0.00663759f, -0.04012543f, 0.05056515f, 0.02854912f, 
    0.01588812f, 0.03110140f, 0.04208498f, -0.01466340f, 0.04542080f, -0.02603579f, -0.06926708f, 0.04072871f, 
    -0.17072943f, 0.18619405f, -0.00840202f, -0.07616847f, 0.11954874f, 0.03786715f, 0.03022425f, 0.02459064f, 
    0.02541232f, -0.03378793f, 0.01041676f, 0.10335606f, 0.03243845f, -0.18679814f, -0.06899647f, -0.23966552f, 
    0.00518689f, -0.03754238f, 0.00610363f, -0.00757881f, 0.03022581f, 0.06593064f, 0.08349663f, -0.12872341f, 
    0.18811591f, 0.02495952f, 0.14278728f, 0.16864628f, 0.00478249f, 0.09072831f, 0.01055614f, 0.04601846f, 
    -0.07668000f, 0.09290653f, -0.03413344f, 0.14099053f, 0.00960554f, -0.11181245f, -0.14550650f, 0.15665773f, 
    0.19354980f, -0.05394195f, -0.04686638f, -0.10231546f, 0.00254469f, 0.05421086f, 0.00593733f, 0.13449588f, 
    0.06259328f, -0.06707620f, -0.17286786f, 0.14790392f, -0.07855408f, -0.05189428f, -0.10823855f, -0.02502695f, 
    0.02134883f, 0.05010054f, -0.09508143f, -0.03681465f, -0.09905658f, -0.14647244f, -0.11717515f, -0.13394766f, 
    -0.18751210f, -0.01162304f, 0.02499940f, 0.01355037f, -0.08704185f, -0.14470726f, 0.00015431f, -0.11538387f, 
    0.19030130f, -0.25171047f, -0.04881176f, 0.07453845f, 0.16052231f, 0.12577362f, 0.05612349f, -0.02993167f, 
    0.04799531f, -0.08182698f, 0.08869047f, 0.12418905f, 0.09746808f, -0.01465726f, 0.00949307f, 0.02624307f, 
    -0.10212681f, -0.17936361f, 0.01891016f, 0.00573134f, 0.07379623f, 0.14380819f, -0.06830347f, 0.08839820f, 
    -0.31296530f, 0.20153236f, 0.07866617f, 0.04500961f, 0.03230204f, 0.16380849f, 0.19473061f, -0.05269093f, 
    0.13497958f, 0.07978702f, 0.03228363f, 0.02690553f, -0.36573982f, 0.05204799f, 0.02090714f, -0.00170606f, 
    0.00622437f, -0.02670769f, 0.02484857f, -0.14303201f, 0.15104684f, -0.06619746f, 0.02367505f, 0.07422974f, 
    0.13751480f, 0.22685193f, -0.05105657f, 0.05378306f, 0.05317272f, 0.00625188f, -0.02195498f, -0.02367271f, 
    0.02835218f, -0.15467103f, 0.24609572f, 0.30707589f, 0.05483267f, 0.14621072f, 0.02340584f, 0.12591803f, 
    -0.09777299f, -0.04797896f, -0.01133853f, 0.21853870f, 0.08124156f, 0.11344665f, 0.01341400f, -0.13343765f, 
    -0.10523481f, 0.02823413f, -0.19573559f, -0.14969139f, -0.02714625f, -0.01731925f, 0.04273786f, -0.10721035f, 
    0.03900275f, -0.18325326f, -0.00910149f, -0.15901877f, 0.14693105f, -0.39571807f, 0.01227126f, 0.03746466f, 
    0.06665338f, 0.09801672f, -0.03234962f, 0.06489851f, 0.04464803f, 0.08599605f, 0.15540117f, 0.00667699f, 
    0.21589334f, -0.31718576f, -0.05822859f, 0.21381450f, 0.00441217f, 0.06533697f, 0.09848528f, -0.06408335f, 
    -0.04778760f, 0.00296018f, 0.12351964f, 0.14659393f, 0.13389613f, 0.07983284f, -0.04992700f, 0.05935935f, 
    0.01229966f, 0.01670842f, -0.02836501f, -0.00298363f, 0.06614365f, -0.08101888f, 0.06867614f, -0.03833168f, 
    -0.12472142f, 0.13116036f, -0.04131836f, 0.07616772f, -0.01583402f, 0.04417562f, 0.14023092f, 0.06780016f, 
    -0.03651383f, 0.02068285f, 0.07596432f, 0.13795085f, 0.33858880f, -0.11412676f, 0.02009029f, -0.02928736f, 
    -0.14127083f, 0.02390936f, -0.12027781f, -0.02878610f, 0.02288749f, 0.07316876f, -0.01064849f, -0.11522178f, 
    0.01069357f, 0.15026264f, 0.18801166f, -0.09646641f, -0.09398087f, 0.18631895f, -0.08717804f, 0.08456227f, 
    -0.08398614f, -0.09629695f, -0.10901842f, 0.06988433f, 0.12670794f, -0.14026742f, 0.16310681f, 0.17363630f, 
    0.05480730f, -0.13264143f, -0.18972883f, -0.06313742f, 0.00397419f, 0.09211897f, -0.11309505f, 0.03362321f, 
    0.42019454f, 0.04537326f, -0.00795797f, -0.07025129f, 0.03464177f, 0.14106596f, 0.02285193f, -0.08943037f, 
    0.06071079f, 0.06353044f, 0.06512170f, -0.03086730f, -0.07347771f, 0.01210816f, -0.03015431f, -0.01345098f, 
    -0.08948524f, 0.04432774f, 0.02016145f, 0.07010891f, -0.08044121f, 0.11022320f, -0.04957371f, -0.11684750f, 
    0.34286237f, -0.13308302f, -0.06680625f, 0.09708585f, 0.13937424f, -0.05859841f, -0.05410275f, -0.04482462f, 
    0.12442721f, -0.22514965f, -0.00510226f, -0.03419732f, 0.38886175f, 0.14463843f, -0.04593803f, -0.18881235f, 
    -0.03246540f, -0.18184087f, -0.06219596f, -0.04557341f, -0.02355170f, 0.08856757f, -0.00442829f, 0.08952184f, 
    -0.28534713f, 0.14563601f, 0.12946284f, -0.04202495f, 0.01671200f, 0.24246474f, 0.05577182f, 0.05896671f, 
    -0.00795087f, 0.11550388f, 0.04310570f, 0.05984491f, -0.06750055f, -0.13627291f, 0.02839655f, -0.10454960f, 
    0.01913801f, -0.02954040f, -0.05219667f, -0.19837111f, 0.16637824f, -0.11792447f, 0.06861331f, -0.08702683f, 
    0.26097158f, 0.24522427f, -0.13945316f, -0.01117265f, -0.01980959f, -0.04905577f, 0.04986004f, -0.01970335f, 
    -0.03172732f, -0.06641521f, 0.17193212f, 0.16553341f, -0.04026629f, 0.04870215f, -0.03932054f, 0.24861394f, 
    0.04488963f, 0.18533145f, 0.18074375f, -0.03999180f, 0.12895831f, 0.13579507f, 0.09386446f, -0.05243107f, 
    -0.08530670f, 0.11447408f, -0.09323472f, -0.08350500f, 0.00110990f, -0.00871316f, -0.17769013f, -0.01120692f, 
    0.06011230f, -0.13575652f, 0.05229009f, -0.12552397f, 0.16274047f, -0.29577026f, 0.12555167f, 0.24949668f, 
    -0.04856168f, 0.09719869f, 0.04318248f, -0.06260252f, 0.06723884f, 0.06786624f, 0.10143197f, 0.01810401f, 
    -0.09474362f, -0.28653938f, -0.07403961f, 0.11751164f, -0.07844345f, -0.11072405f, 0.08020423f, -0.02673254f, 
    0.12457634f, 0.12745661f, 0.05984258f, 0.07521793f, -0.25924763f, -0.04137126f, -0.05428481f, 0.04688342f, 
    0.02354114f, -0.12823357f, -0.03462250f, 0.02090949f, 0.21084143f, 0.00888099f, 0.20812772f, -0.05766422f, 
    -0.32581535f, 0.09693050f, 0.02136260f, -0.10606637f, 0.27257559f, -0.10953336f, 0.08507341f, 0.01964974f, 
    0.07330108f, -0.02092781f, 0.05744193f, -0.05122698f, -0.10790537f, 0.08027703f, 0.08523294f, -0.07124598f, 
    0.23200926f, 0.08232842f, -0.02439790f, -0.04526069f, 0.00525420f, -0.00324953f, -0.04551771f, -0.03079492f, 
    0.30091688f, -0.10849945f, -0.08550875f, 0.08502515f, 0.02982052f, 0.07437511f, -0.10798059f, 0.01276984f, 
    0.02138107f, 0.10774238f, 0.08459596f, 0.10216756f, -0.19452034f, 0.17252587f, -0.11509930f, -0.00346626f, 
    0.02051647f, 0.02934096f, 0.05995778f, -0.01055134f, 0.02284818f, -0.04194415f, 0.08133982f, 0.07028174f, 
    -0.25949839f, 0.12992589f, -0.15150839f, 0.13408965f, 0.14342371f, 0.15521617f, -0.06120659f, -0.06714624f, 
    0.03907852f, 0.01024751f, -0.08521514f, 0.06169051f, -0.14435029f, -0.03546669f, -0.11938506f, -0.00082956f, 
    -0.02864309f, 0.16022435f, 0.00869751f, -0.11672635f, 0.01694304f, -0.07474375f, 0.00859557f, -0.04785066f, 
    -0.10526550f, 0.14503324f, 0.06475232f, -0.19355540f, 0.12493756f, -0.06795006f, 0.07841892f, -0.05704721f, 
    -0.01030846f, 0.03111774f, -0.04375939f, -0.04629343f, 0.08262420f, 0.11842306f, -0.12526079f, 0.29300800f, 
    -0.01348861f, 0.17312370f, -0.03969784f, -0.03199285f, 0.20893335f, 0.11270271f, -0.05179022f, -0.05549500f, 
    -0.07138254f, -0.17175539f, 0.14922670f, 0.18089081f, 0.03925287f, -0.05927737f, 0.02440436f, 0.02314460f, 
    -0.05328408f, -0.11596732f, 0.02810122f, 0.02598719f, 0.04316000f, 0.07130417f, -0.05170120f, 0.01539386f, 
    -0.04929043f, 0.16188052f, -0.07082380f, -0.05564380f, 0.10893590f, -0.07762845f, -0.00394788f, -0.07045127f, 
    0.06770972f, 0.05137812f, 0.01939722f, 0.11949582f, 0.19739109f, -0.00677457f, -0.02628048f, -0.08473069f, 
    0.03966533f, 0.05240948f, -0.05200869f, 0.09101960f, 0.23037495f, -0.08628867f, 0.08775101f, 0.04002781f, 
    0.02590386f, -0.02443810f, 0.00302475f, 0.01246808f, -0.03699296f, -0.06791218f, -0.04628284f, 0.10577353f, 
    -0.03361719f, -0.09672739f, 0.08750155f, -0.01141161f, 0.01963205f, -0.02744387f, 0.06885720f, 0.06079770f, 
    0.04659972f, 0.01433681f, 0.00121762f, 0.07176173f, 0.01728782f, 0.22771525f, 0.02561118f, -0.10302608f, 
    0.08144444f, 0.06077993f, -0.17376949f, 0.06636746f, -0.08572184f, 0.05815019f, -0.01705960f, -0.10235263f, 
    -0.11794416f, -0.03517725f, 0.09928188f, 0.13365190f, -0.11583710f, 0.05544946f, -0.06175978f, 0.02977053f, 
    0.01128259f, -0.02665885f, 0.08928514f, 0.00783071f, -0.12804383f, -0.03088170f, 0.20810871f, 0.27363274f, 
    -0.15109032f, 0.19617778f, -0.06765049f, 0.04558167f, -0.13845699f, 0.00872520f, -0.13073017f, 0.06983178f, 
    -0.01956535f, 0.06535977f, -0.06663542f, -0.06757706f, 0.04840894f, 0.03163068f, -0.03614693f, 0.03507528f, 
    0.06367246f, 0.05313453f, -0.00865801f, -0.00702853f, -0.03689303f, -0.07723078f, -0.07452906f, 0.03660067f, 
    0.04869946f, -0.00483658f, -0.06878909f, 0.06012210f, -0.03172395f, 0.00035526f, -0.05497615f, -0.03712664f, 
    -0.06158691f, 0.05495673f, -0.00813213f, 0.03953173f, 0.02051780f, -0.06456289f, -0.06858519f, -0.06976265f, 
    0.04812577f, 0.06109202f, 0.04367795f, 0.04443645f, -0.05957221f, 0.01519799f, 0.04086736f, 0.03369288f, 
    -0.06466921f, -0.02557472f, -0.02709003f, 0.05744558f, -0.00211167f, -0.02787022f, 0.03205035f, -0.06147750f, 
    0.05664948f, -0.05421593f, 0.03012331f, -0.00657503f, -0.00518087f, -0.00376809f, -0.05975079f, 0.04125252f, 
    -0.03363466f, -0.06050035f, 0.06065144f, -0.06714894f, -0.03622296f, -0.00187566f, -0.06341725f, -0.06649372f, 
    0.02003821f, 0.06253909f, -0.05389366f, 0.02887737f, -0.02172581f, -0.00217463f, -0.00661490f, -0.01895092f, 
    -0.02828179f, 0.05459215f, -0.07084540f, 0.05830940f, -0.05310485f, 0.03612996f, -0.04263724f, 0.02497934f, 
    -0.02628638f, 0.04012090f, 0.03725262f, -0.00510427f, 0.04071399f, 0.00576251f, -0.07196651f, -0.01614077f, 
    -0.02275326f, -0.06966923f, -0.03260297f, 0.01111061f, 0.00963215f, 0.02331628f, -0.03204605f, -0.04736725f, 
    -0.07187183f, -0.06435931f, -0.03268614f, 0.03753949f, -0.02688313f, 0.02775744f, -0.03125408f, -0.00815204f, 
    0.06710207f, -0.04480713f, -0.06130070f, -0.03027622f, -0.01413519f, -0.01201382f, -0.06832325f, 0.06489370f, 
    -0.01391342f, 0.01343695f, -0.06654971f, -0.04699419f, -0.02228517f, 0.01806267f, -0.05154565f, 0.01657755f, 
    -0.05316220f, -0.02660690f, 0.02761664f, -0.04986984f, -0.07380096f, 0.06371441f, -0.04113502f, 0.05678631f, 
    -0.04420527f, -0.03530231f, -0.03105650f, -0.04395496f, -0.02654752f, -0.00518362f, 0.03901261f, -0.06234239f, 
    -0.00238115f, -0.02280211f, 0.04902050f, 0.06795973f, 0.07257234f, -0.02788740f, -0.03165207f, -0.03339512f, 
    0.01486716f, -0.02035234f, 0.02950489f, -0.06680605f, -0.04685944f, -0.07135318f, 0.00161996f, 0.00716777f, 
    0.04856516f, -0.04234454f, 0.00057905f, -0.04131123f, 0.01111120f, 0.05484075f, 0.04524905f, 0.03218159f, 
    -0.06523222f, -0.06833103f, 0.06322087f, -0.00053711f, -0.07091480f, 0.04280178f, 0.05180150f, -0.06583525f, 
    0.05012970f, -0.06447745f, 0.00994323f, 0.02273751f, 0.06251281f, -0.04589277f, -0.03440536f, 0.05341633f, 
    -0.01060824f, -0.03750633f, -0.07088426f, -0.02501295f, -0.01840585f, 0.03035274f, -0.03475560f, 0.03950720f, 
    -0.02977703f, -0.02617579f, -0.01369657f, -0.07169539f, 0.00844633f, -0.04140723f, -0.01909552f, 0.00170858f, 
    -0.39034268f, -0.05440411f, 0.16473131f, -0.11739936f, 0.06348112f, -0.06183928f, 0.06159717f, -0.06082823f, 
    -0.05108515f, 0.08432294f, -0.09158588f, -0.02729288f, -0.05743368f, 0.01196729f, -0.03638828f, -0.03348888f, 
    0.03580050f, -0.04830476f, 0.13997188f, -0.02950641f, 0.00722498f, -0.00988206f, -0.02754248f, -0.02985500f, 
    0.10898810f, 0.11643402f, 0.10026561f, 0.14133887f, -0.01402185f, -0.05882123f, 0.06487828f, -0.05247426f, 
    -0.01593234f, -0.00899725f, 0.03354178f, 0.04583522f, 0.00733076f, 0.11058106f, 0.00582199f, 0.14433172f, 
    -0.09963173f, 0.12411705f, 0.00357174f, -0.06350110f, -0.05799387f, -0.01867140f, -0.03082862f, -0.04092343f, 
    -0.14221953f, 0.08156382f, 0.02400448f, 0.13866881f, 0.00911845f, 0.12331475f, -0.00900538f, -0.03214875f, 
    0.00478559f, 0.00514565f, 0.01463045f, 0.05626613f, 0.00286652f, 0.19115920f, 0.03456688f, 0.05097244f, 
    0.05997780f, 0.08214444f, 0.03251440f, 0.09570707f, 0.06337380f, -0.04521036f, 0.00561950f, -0.01973672f, 
    -0.09201322f, -0.10057237f, -0.04448509f, 0.00099756f, -0.01720220f, 0.06277712f, 0.05059088f, 0.01604763f, 
    -0.06161234f, -0.01301423f, 0.09315931f, -0.07285188f, -0.13097222f, -0.03381039f, -0.21550834f, -0.03165667f, 
    -0.09228681f, 0.00761084f, 0.04561188f, 0.02074615f, 0.02216499f, -0.06428450f, -0.03652374f, -0.06258646f, 
    -0.14062659f, 0.03767285f, 0.19602053f, 0.08599686f, 0.09457622f, -0.06172849f, 0.08100691f, 0.13593544f, 
    -0.06092709f, -0.00851877f, 0.02661387f, 0.11854837f, 0.27295586f, 0.05432271f, -0.01829443f, 0.04451116f, 
    -0.06811430f, -0.04335628f, -0.14020076f, -0.10897546f, -0.04394485f, 0.12718722f, 0.04997813f, 0.04197817f, 
    0.00228338f, 0.24519333f, -0.06385031f, 0.10567512f, 0.07400837f, -0.02986474f, -0.06506237f, -0.07636812f, 
    0.05488835f, 0.10618204f, -0.00407008f, -0.06323557f, 0.41177559f, 0.23912607f, 0.16245389f, 0.21158396f, 
    0.09610397f, -0.03562158f, 0.03784207f, 0.08451346f, -0.05405177f, -0.03891116f, -0.21976909f, 0.00479602f, 
    -0.16582045f, 0.11932245f, -0.02610569f, -0.12154457f, -0.06828896f, 0.00015158f, -0.00972304f, -0.10448372f, 
    0.02474745f, 0.08727143f, 0.06636731f, 0.10315211f, -0.01987051f, 0.16477294f, -0.01356463f, 0.04855333f, 
    -0.02580244f, -0.01369536f, 0.00290604f, 0.02272589f, -0.02202263f, 0.01924983f, -0.07442270f, 0.03263864f, 
    -0.15860574f, 0.04584448f, 0.02061224f, 0.20201539f, 0.01095486f, 0.01237814f, -0.06682640f, 0.13614017f, 
    0.01934168f, 0.03368827f, 0.03394992f, -0.05480444f, 0.27542940f, 0.28872606f, -0.03849131f, 0.10602691f, 
    0.00300272f, -0.00699606f, -0.04926050f, 0.04585001f, -0.10932773f, 0.08279225f, -0.00126819f, 0.00373522f, 
    0.40193471f, -0.23563266f, 0.18397830f, -0.13294196f, -0.02261688f, 0.04201735f, 0.13950492f, 0.15625501f, 
    -0.02720437f, 0.00125890f, 0.04774194f, 0.08913504f, -0.13947095f, 0.01316551f, 0.09891185f, -0.01178521f, 
    0.01749287f, -0.12438340f, -0.13965118f, 0.00103798f, -0.01293508f, 0.04549765f, -0.02625999f, -0.08244576f, 
    0.09421885f, -0.00855727f, -0.06033304f, 0.14632039f, 0.15494333f, 0.27107754f, -0.02802310f, -0.05699587f, 
    -0.02960514f, 0.00414742f, -0.00664278f, -0.02055543f, -0.37511042f, 0.12459446f, -0.00069065f, -0.13730215f, 
    -0.03649674f, 0.04194969f, 0.09898343f, 0.12023693f, -0.00533568f, 0.19600749f, 0.06113338f, -0.06000736f, 
    -0.16541179f, 0.03669002f, -0.05511166f, 0.05383533f, -0.07526530f, -0.05078224f, -0.01880307f, 0.03300006f, 
    0.03922157f, -0.17114475f, 0.08344261f, 0.08213824f, 0.31537184f, 0.12052019f, 0.00006268f, 0.02775574f, 
    -0.07135150f, -0.00356229f, 0.01067562f, 0.03813617f, -0.06749693f, -0.03056725f, 0.07509777f, -0.06719257f, 
    -0.20772198f, 0.03755973f, 0.02761659f, -0.05776088f, 0.09544475f, 0.05599798f, 0.01037197f, 0.01143090f, 
    -0.05222357f, 0.03907882f, 0.09756777f, 0.02387892f, -0.30036163f, 0.27245778f, -0.03163961f, 0.18605287f, 
    0.03496726f, 0.06688650f, 0.11849151f, -0.01131822f, 0.17897119f, -0.10452731f, -0.07722888f, -0.05646175f, 
    0.01995100f, -0.23583646f, 0.06664210f, 0.22215526f, 0.00674740f, -0.03098883f, 0.02847436f, -0.09443645f, 
    0.13044567f, 0.12405115f, -0.00682198f, 0.00251816f, -0.25315771f, 0.08942495f, 0.13324326f, 0.11289208f, 
    0.06424624f, -0.01135638f, -0.00588229f, 0.13776876f, -0.06741063f, 0.07574531f, -0.00123793f, 0.09497222f, 
    -0.37603518f, 0.23671189f, 0.07606179f, -0.13157898f, 0.14245306f, 0.16324258f, -0.13909400f, -0.06562516f, 
    -0.05256033f, -0.04533847f, 0.06599861f, 0.01669582f, 0.19046894f, 0.02343354f, -0.07309058f, -0.14154342f, 
    0.09798780f, -0.19281255f, 0.16409126f, 0.12777661f, -0.05386127f, -0.01315278f, -0.02538290f, 0.15088688f, 
    0.11030969f, 0.10481865f, 0.06495793f, -0.01605909f, -0.11181992f, -0.04855670f, -0.00472509f, -0.03042071f, 
    -0.05900220f, -0.05098439f, -0.10106337f, 0.01139299f, -0.32673168f, -0.01571814f, 0.09771927f, -0.05752221f, 
    0.19318806f, 0.04880926f, 0.05329853f, 0.04882732f, -0.07665457f, 0.15369451f, 0.03696712f, -0.09496355f, 
    0.25239244f, -0.03291452f, -0.06252775f, 0.02629721f, 0.06757563f, 0.03141737f, 0.00282722f, 0.04334075f, 
    -0.05149277f, 0.03506903f, 0.06186127f, -0.08184079f, -0.07047094f, 0.22620359f, -0.00622056f, 0.03052901f, 
    0.06182410f, -0.11660108f, -0.13942410f, 0.08376002f, -0.07668559f, -0.07226762f, -0.03214522f, -0.01259179f, 
    0.13250384f, -0.07623125f, -0.03658361f, 0.03923015f, 0.07586753f, -0.11044621f, -0.02422554f, -0.00206090f, 
    -0.05162654f, 0.02288896f, 0.03000734f, -0.02211696f, -0.39965588f, -0.14594470f, -0.30925074f, -0.02377338f, 
    -0.00109029f, 0.09043603f, -0.07752445f, -0.02534081f, -0.00253668f, -0.17659263f, 0.04978665f, 0.16901913f, 
    -0.04374682f, -0.04237740f, 0.09739539f, -0.11324690f, 0.06100792f, 0.05022433f, 0.16603294f, 0.06467492f, 
    0.10739513f, 0.10978746f, 0.20344898f, -0.00713647f, -0.18922079f, 0.06513667f, -0.25263390f, 0.02551723f, 
    -0.16235068f, 0.13956514f, -0.03164740f, -0.00762716f, 0.03623232f, 0.01677396f, 0.05596488f, 0.11842820f, 
    0.07010001f, -0.10964855f, 0.00840325f, -0.00643860f, -0.07129044f, 0.01170274f, 0.14493293f, 0.08861414f, 
    -0.09850314f, -0.11846260f, 0.05981009f, -0.01837321f, 0.30862319f, 0.00555200f, -0.14624077f, -0.03247265f, 
    -0.02964209f, -0.09606522f, 0.02237580f, 0.10535297f, 0.03198389f, -0.03129350f, -0.05259483f, 0.11373312f, 
    -0.49844199f, -0.03379405f, -0.07837965f, -0.18814978f, 0.08979364f, -0.03820195f, -0.09101441f, -0.06868114f, 
    -0.03673470f, 0.11901969f, -0.03207123f, 0.08199812f, -0.03193190f, -0.07939229f, 0.31328437f, 0.13314252f, 
    -0.03577158f, 0.17558211f, -0.06740677f, 0.03631862f, 0.07414662f, 0.10759341f, 0.10400689f, 0.00833085f, 
    0.42138153f, 0.00953547f, 0.04647760f, 0.17782688f, -0.11190720f, -0.06783588f, 0.05347656f, 0.10617013f, 
    0.06047205f, -0.02545411f, 0.08008482f, 0.07151028f, -0.23953828f, 0.03468318f, 0.07546394f, 0.13539593f, 
    -0.02116308f, 0.09931013f, 0.12480317f, 0.12336350f, 0.08923944f, 0.09547388f, -0.02083935f, 0.15859951f, 
    0.21562332f, 0.06157060f, 0.16553552f, -0.13206916f, 0.00150100f, 0.15362316f, -0.06346668f, 0.04518661f, 
    -0.14426127f, 0.09493456f, -0.13626510f, -0.12376929f, -0.04599068f, 0.17342563f, 0.20722333f, -0.09799170f, 
    0.05422297f, 0.11196404f, -0.07245344f, -0.13033696f, 0.00715333f, 0.01131837f, 0.07179946f, 0.15034404f, 
    0.20554732f, -0.16735780f, -0.03654155f, 0.03463674f, 0.07495276f, 0.03368188f, 0.12033016f, 0.13362603f, 
    0.09442284f, 0.12299845f, 0.08572641f, 0.13836792f, -0.39933825f, -0.04237330f, -0.32343957f, -0.32676199f, 
    0.10990357f, -0.10761392f, -0.02448179f, 0.06279101f, -0.05336417f, -0.13920417f, -0.03560348f, 0.05503936f, 
    0.29630280f, 0.14763841f, -0.00718006f, -0.14199659f, 0.24534959f, -0.01504987f, 0.01327126f, 0.05231234f, 
    -0.01489289f, 0.00575382f, -0.09941288f, 0.01635860f, 0.34433511f, 0.09166165f, 0.02216528f, 0.02092205f, 
    -0.02842043f, 0.04196639f, -0.02142759f, 0.04243480f, -0.15692045f, -0.01970379f, 0.03937768f, 0.01090371f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03062334f, 0.09126684f, -0.07127515f, -0.09595342f, 0.07611552f, 0.05554765f, 0.11380042f, 0.15026833f, 
    0.09331810f, -0.03721814f, 0.05116657f, 0.14340495f, -0.04550696f, -0.05160488f, -0.04152606f, 0.09135874f, 
    0.03467483f, 0.11384252f, -0.04823565f, 0.14218394f, 0.03124782f, 0.04322969f, -0.00501482f, -0.04927704f, 
    0.00190270f, -0.06574012f, 0.03269452f, -0.02047197f, 0.12380045f, -0.03388837f, 0.01021648f, 0.04939128f, 
    -0.02908972f, 0.07193742f, -0.02123691f, 0.00921720f, 0.07803994f, 0.05544062f, 0.00590306f, -0.01516582f, 
    -0.02453787f, -0.00360759f, 0.08501291f, -0.00143198f, -0.03650010f, -0.03364449f, 0.06339210f, -0.01145087f, 
    -0.06776502f, -0.02703930f, -0.08270050f, 0.05840840f, -0.03614122f, 0.07029701f, 0.02254483f, 0.05831590f, 
    0.04936510f, 0.14024906f, 0.12218602f, -0.00672285f, -0.04671897f, 0.02237842f, -0.01511753f, 0.16252850f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.01020654f, 0.08815926f, -0.32764941f, -0.07267477f, 0.19322047f, 0.02639010f, -0.14839736f, -0.11144284f, 
    0.23292473f, 0.07424338f, -0.11213968f, -0.13673972f, -0.07572433f, 0.01778544f, 0.41839021f, 0.01476351f, 
    0.19118048f, -0.11080757f, -0.07654937f, -0.12549874f, -0.06879897f, 0.09814698f, 0.34411198f, 0.06523417f, 
    -0.04215089f, 0.08739951f, 0.11656234f, 0.03923894f, 0.02247539f, 0.03693308f, 0.22481480f, 0.07717447f, 
    0.06567651f, -0.04475367f, -0.10139958f, 0.08459096f, -0.01103843f, 0.11285999f, -0.31300429f, 0.28807095f, 
    -0.06142488f, 0.35430926f, -0.14270751f, 0.04399502f, -0.00326651f, -0.00480910f, 0.12487298f, -0.04330510f, 
    0.09978442f, -0.10189231f, -0.11656151f, 0.13365406f, 0.16770931f, 0.13007312f, 0.21459469f, 0.01028527f, 
    0.07351855f, 0.12171051f, -0.02654062f, -0.18188071f, 0.00362447f, -0.07390837f, -0.01091503f, 0.01607239f, 
    -0.07107988f, -0.15289234f, -0.16090821f, 0.07662764f, -0.10695403f, 0.08845293f, -0.00527839f, -0.09262988f, 
    -0.03794730f, -0.11430782f, 0.00276367f, 0.08485249f, 0.10039194f, -0.10125586f, 0.09779488f, 0.08885932f, 
    0.07061695f, -0.14025265f, -0.09766403f, -0.11055106f, 0.01955834f, -0.08995070f, -0.05054746f, 0.07980449f, 
    0.03284975f, -0.04356398f, -0.12959909f, 0.08598521f, 0.03514815f, -0.03512853f, -0.07568223f, -0.04740585f, 
    -0.10013661f, -0.12890822f, 0.10647304f, 0.10927431f, -0.05213208f, -0.07393090f, -0.01682319f, -0.00512111f, 
    -0.02278982f, 0.04504470f, -0.04313006f, -0.11649768f, 0.02888849f, -0.02044006f, -0.14290765f, -0.06721619f, 
    0.00568739f, 0.08699797f, -0.05455282f, -0.11877505f, -0.11976226f, 0.07290437f, -0.12276693f, 0.06176416f, 
    0.01006140f, -0.07500170f, 0.11238305f, -0.17859603f, -0.05667219f, -0.03690380f, -0.07359291f, -0.14907052f, 
    0.07310922f, 0.00102155f, 0.15896760f, 0.09502027f, 0.14933953f, -0.14582445f, 0.20664631f, -0.03347109f, 
    0.09003989f, 0.12406289f, -0.47863621f, -0.14933260f, 0.10295548f, -0.00173112f, 0.25085896f, -0.19626950f, 
    0.44782770f, -0.13926248f, 0.12158532f, -0.29991695f, 0.01175160f, 0.13575552f, 0.55356413f, 0.11509229f, 
    0.09366418f, -0.08383451f, 0.09832820f, 0.27151969f, -0.02960446f, 0.04524663f, 0.15611228f, 0.18633243f, 
    0.03895539f, 0.08065176f, 0.00134095f, 0.09997638f, -0.00804135f, -0.10565635f, -0.28133228f, 0.22070019f, 
    -0.07003608f, 0.21153870f, -0.05087492f, 0.24683736f, 0.04047337f, 0.04686312f, 0.02068274f, -0.14361478f, 
    0.03117909f, -0.03871174f, 0.09324756f, 0.02562239f, 0.16485792f, 0.03310227f, 0.45875931f, -0.04919183f, 
    -0.12027969f, 0.04933501f, -0.11964244f, 0.08048515f, -0.01413037f, 0.15224639f, 0.10877535f, -0.20927215f, 
    -0.04353605f, -0.12707472f, 0.20685270f, -0.12768899f, 0.13845660f, 0.21453843f, 0.41989213f, -0.08068611f, 
    -0.14196923f, 0.07668281f, -0.06718612f, 0.13622956f, 0.00919486f, -0.12137482f, 0.26472533f, 0.02928879f, 
    -0.18375026f, 0.31667784f, 0.08410226f, 0.04466327f, -0.08375860f, -0.17445189f, 0.12357196f, 0.08325572f, 
    -0.12100694f, 0.11023342f, 0.17366500f, 0.09306478f, -0.17345460f, -0.11947842f, 0.47467729f, 0.18303663f, 
    0.10753362f, 0.07131497f, -0.07245926f, 0.04905922f, -0.09606754f, -0.25184464f, -0.13651611f, 0.10274787f, 
    -0.06934242f, 0.04838036f, -0.04482862f, -0.15225233f, 0.02503513f, -0.01081380f, 0.07042741f, -0.42424896f, 
    -0.10701568f, 0.10561717f, 0.05706840f, -0.11060714f, 0.18232179f, 0.14529698f, 0.37174907f, 0.08557244f, 
    -0.06141927f, -0.05237925f, -0.17203543f, 0.09493313f, 0.08220977f, 0.22103351f, -0.11234513f, 0.05174980f, 
    -0.07795088f, 0.08882827f, -0.06322559f, -0.06028446f, 0.25332636f, -0.13218576f, -0.11887899f, 0.24462929f, 
    0.20160906f, 0.09180267f, 0.10938605f, -0.21532431f, 0.00029493f, -0.04984466f, 0.01933159f, -0.07042552f, 
    0.03194820f, -0.11078626f, 0.11958030f, -0.18828531f, -0.11434661f, 0.17068832f, -0.15249360f, -0.09625955f, 
    0.17558616f, -0.10311297f, 0.10401966f, 0.02738609f, -0.07261143f, -0.10643321f, -0.11745118f, 0.03360881f, 
    -0.05903926f, 0.27412865f, 0.10461154f, -0.07648987f, -0.15608412f, 0.03774786f, 0.10706349f, -0.01539245f, 
    0.27096111f, -0.09161185f, 0.18171799f, -0.04515416f, 0.10089450f, -0.12313835f, 0.13797422f, 0.19054815f, 
    -0.00256707f, -0.05788786f, 0.00625355f, -0.06007553f, 0.21492985f, -0.11897481f, -0.14165971f, 0.30703980f, 
    0.03815378f, 0.12812388f, -0.01696393f, 0.28735983f, 0.07758322f, 0.24280895f, -0.12459870f, -0.04948756f, 
    -0.01352663f, -0.05405782f, -0.02576870f, -0.12413172f, 0.00696990f, 0.15830632f, 0.34498274f, 0.18201034f, 
    0.43469131f, -0.04987596f, -0.05085287f, 0.00966198f, -0.04622291f, 0.10871086f, 0.15464234f, -0.21491490f, 
    -0.16530839f, 0.29767516f, -0.07556014f, 0.09821451f, 0.00377119f, -0.11928881f, 0.29167885f, -0.02932548f, 
    -0.33777213f, -0.09982278f, 0.10760881f, 0.20514405f, 0.06906788f, 0.00253703f, 0.03284005f, -0.01668642f, 
    -0.03249683f, -0.09535782f, 0.01655645f, -0.12278492f, -0.15687203f, 0.11504598f, 0.08742639f, -0.12337930f, 
    0.01288518f, -0.26081672f, 0.25127143f, 0.25714815f, 0.03350420f, -0.05831248f, 0.09152590f, -0.11023947f, 
    0.02082741f, 0.11765133f, 0.10059576f, -0.02970062f, -0.17988417f, 0.07660877f, 0.28107214f, 0.13720979f, 
    0.05297784f, 0.16157633f, 0.06866980f, 0.14471513f, 0.12958556f, -0.02288196f, -0.11042916f, 0.01035740f, 
    0.03461432f, -0.13445552f, 0.56440657f, -0.00370205f, -0.26969025f, 0.03034191f, -0.06977478f, -0.05997562f, 
    -0.05227995f, 0.09803294f, 0.20745724f, 0.04011139f, 0.12671526f, 0.09191288f, -0.32745293f, -0.03527832f, 
    0.00510137f, -0.14328738f, -0.08497836f, 0.05536199f, -0.06893136f, 0.29298660f, 0.15368141f, 0.09313191f, 
    0.23736982f, -0.09398451f, -0.16592665f, -0.10073807f, 0.12805098f, 0.02744424f, -0.27316076f, -0.04387215f, 
    0.06460110f, 0.05469402f, 0.07817178f, -0.03998272f, 0.18467242f, 0.10584892f, 0.13590316f, -0.11482473f, 
    0.17615807f, -0.00493601f, -0.00134593f, 0.24074389f, -0.07185013f, -0.11544489f, 0.15073469f, 0.39623547f, 
    -0.07523773f, -0.10183418f, -0.09741691f, 0.02683553f, 0.15362710f, -0.11767188f, 0.00569827f, 0.06346632f, 
    0.02060805f, 0.09280310f, 0.18273248f, 0.07349841f, -0.01464979f, 0.04286548f, 0.09893181f, -0.17105688f, 
    -0.03417230f, 0.04871094f, -0.13230023f, 0.01579700f, -0.05570373f, -0.09978199f, -0.05163902f, -0.00005630f, 
    -0.12799522f, -0.08023278f, -0.08293333f, 0.00744311f, -0.05011521f, -0.09808572f, 0.05894566f, 0.04799253f, 
    0.05549289f, 0.04799645f, 0.01940550f, 0.07641593f, -0.10879414f, 0.09165388f, -0.00550013f, -0.00481588f, 
    -0.12338164f, -0.04410340f, -0.12831710f, -0.06030550f, -0.03045153f, 0.08477049f, 0.02912890f, -0.06542644f, 
    0.06611225f, 0.08068771f, 0.02112320f, -0.00761646f, -0.02224115f, 0.07926963f, -0.12014991f, -0.08963420f, 
    0.02957859f, -0.13459255f, 0.01594193f, 0.00564026f, 0.06409702f, 0.11669919f, -0.06107449f, -0.12556806f, 
    0.10620479f, 0.00126453f, 0.02351840f, -0.10142937f, 0.09333105f, 0.04615689f, 0.06752776f, -0.01097634f, 
    -0.11093768f, -0.06390495f, -0.00454882f, -0.02485401f, 0.03073227f, 0.01342419f, -0.07476565f, -0.13242711f, 
    -0.06559268f, -0.28684455f, -0.26224124f, 0.07013709f, 0.44235179f, -0.19080995f, 0.22298871f, 0.04471227f, 
    0.07321434f, 0.04936909f, 0.18257865f, -0.20067286f, -0.04986854f, 0.10860381f, -0.20395423f, 0.01613800f, 
    0.06404246f, -0.10414086f, -0.08141524f, -0.34064829f, 0.11597187f, 0.15178460f, 0.32560956f, -0.11613877f, 
    0.14286084f, 0.03916658f, -0.13475943f, 0.02056260f, 0.15355544f, 0.01331866f, 0.18069483f, 0.20838605f, 
    -0.07804768f, -0.07360370f, -0.11020097f, 0.10784494f, -0.16812618f, -0.12181836f, -0.01276130f, 0.18528788f, 
    0.20201086f, -0.43114495f, 0.25612274f, -0.03583129f, -0.07344428f, -0.10509972f, 0.08178825f, 0.01186376f, 
    0.10921329f, -0.04192546f, -0.06468205f, 0.01157183f, -0.07359272f, -0.12682381f, 0.12161561f, 0.34031993f, 
    -0.06976590f, 0.17849694f, -0.12436103f, 0.26465046f, -0.06617094f, 0.05709077f, 0.01378236f, -0.12053335f, 
    -0.03488067f, 0.10072739f, 0.35416847f, 0.08458798f, -0.26913425f, 0.23380242f, 0.01708919f, 0.20550220f, 
    -0.11343958f, -0.11843328f, -0.07051212f, 0.03387847f, -0.12133710f, -0.09927180f, 0.17375240f, 0.04694337f, 
    0.01376182f, -0.08684546f, -0.01413200f, 0.21544756f, -0.02926356f, 0.12504749f, 0.32313550f, 0.04186811f, 
    0.03664147f, 0.08973690f, -0.03174780f, 0.17192738f, 0.05291383f, 0.05224388f, 0.06954161f, 0.01207082f, 
    -0.03673715f, -0.25698659f, -0.02423568f, 0.03355120f, 0.28653187f, 0.18179706f, -0.06286434f, -0.04482323f, 
    0.02110288f, 0.32172030f, -0.10737524f, 0.03719350f, -0.07234186f, 0.00582948f, -0.07468622f, -0.25357574f, 
    -0.04087535f, 0.11286344f, 0.03970154f, -0.26459929f, 0.13078697f, 0.11351294f, 0.00893681f, -0.20899789f, 
    0.05692713f, 0.16257241f, 0.42314616f, -0.22258732f, -0.04645272f, -0.08176338f, -0.07994458f, -0.31723627f, 
    0.02041659f, 0.01009743f, 0.07204305f, -0.05139050f, -0.01453939f, -0.06461233f, 0.12580322f, 0.07275809f, 
    -0.09237401f, 0.07523660f, -0.12312506f, 0.11745809f, 0.04970802f, 0.03757732f, 0.04996118f, 0.03793232f, 
    0.02389944f, 0.02748348f, 0.10345870f, 0.03623400f, -0.06213726f, 0.03541898f, -0.10703158f, -0.00687248f, 
    -0.07674921f, -0.08181778f, -0.04950516f, -0.02020229f, -0.10264553f, 0.09988017f, -0.04955472f, -0.03821674f, 
    -0.10679761f, -0.11981174f, -0.00750927f, -0.00855366f, -0.11837717f, -0.12627755f, -0.11849940f, -0.09556652f, 
    -0.00919654f, 0.10589374f, -0.07506365f, 0.01681463f, 0.08147866f, 0.00652488f, -0.10905787f, -0.06585114f, 
    -0.06577247f, 0.08027084f, -0.08349113f, 0.08990030f, 0.10410630f, 0.06923458f, -0.12158066f, -0.08376790f, 
    0.01475491f, 0.11459395f, -0.07608075f, 0.09928986f, 0.12300667f, 0.03952594f, 0.12501511f, -0.01860979f, 
    -0.00243872f, -0.19153629f, -0.05419162f, 0.04044339f, 0.32135031f, 0.03424062f, 0.27383673f, 0.12764686f, 
    -0.08569538f, -0.07495540f, 0.21923970f, 0.03768108f, -0.04221520f, -0.08656058f, -0.00818537f, 0.25036305f, 
    -0.10911409f, 0.19792272f, 0.08829723f, -0.01339021f, -0.01833031f, 0.05617115f, 0.11233013f, -0.06077582f, 
    0.09424888f, -0.07495740f, 0.03877397f, -0.19333035f, 0.19210242f, -0.11478675f, 0.20893122f, 0.11475584f, 
    0.09768330f, 0.05129341f, -0.07700568f, 0.00829834f, 0.00898201f, -0.12638587f, 0.05792849f, 0.00615177f, 
    0.16655885f, -0.42536575f, 0.16255665f, -0.16611569f, -0.02540153f, -0.06369738f, -0.17097910f, 0.13026974f, 
    -0.03727360f, 0.03051905f, -0.00268737f, -0.22233577f, -0.13837937f, -0.10367549f, 0.07517724f, 0.04937244f, 
    0.12179756f, -0.01596064f, -0.14237867f, 0.19947274f, 0.07228137f, 0.00341238f, 0.29338732f, 0.07399948f, 
    0.02406028f, 0.17638412f, -0.02876084f, 0.06781796f, 0.16527785f, 0.19344155f, 0.29967791f, 0.14928663f, 
    -0.09410320f, -0.07250240f, 0.44547379f, 0.06529876f, 0.08868517f, 0.10841821f, 0.04988092f, 0.42973503f, 
    -0.26317820f, 0.24913280f, -0.07192302f, 0.11297147f, -0.01435954f, 0.04780276f, -0.07061364f, -0.02930889f, 
    0.01880164f, 0.01150403f, 0.16873252f, -0.16829950f, -0.11576732f, -0.06550488f, 0.26887235f, -0.00311409f, 
    0.00487991f, 0.17868891f, -0.10931458f, -0.00379469f, 0.22817458f, -0.15022302f, -0.03519372f, 0.04003461f, 
    -0.16691031f, -0.07274351f, 0.26412851f, -0.42102766f, -0.06334291f, 0.09541389f, 0.12010780f, -0.07556703f, 
    -0.10046681f, 0.07694276f, 0.08572072f, -0.05153807f, -0.09193856f, -0.21846561f, -0.13635781f, -0.05278867f, 
    0.00697128f, 0.19121733f, 0.22175851f, 0.17488752f, -0.07736196f, 0.07642985f, 0.23351845f, 0.25608084f, 
    -0.12090980f, -0.05546027f, 0.04779083f, -0.06116328f, 0.02204464f, 0.11006182f, -0.07012898f, -0.11325525f, 
    -0.00429407f, 0.05459934f, -0.45231381f, -0.07416718f, 0.05507607f, -0.11571287f, 0.32301420f, -0.10989510f, 
    0.19070888f, 0.01443067f, -0.06837358f, 0.36926138f, 0.10026322f, -0.25573459f, -0.26883137f, 0.05681194f, 
    -0.15148917f, -0.05436768f, 0.06834801f, 0.17509831f, 0.11136999f, 0.08027230f, 0.26357904f, 0.08842837f, 
    -0.01680830f, 0.27856636f, 0.03127250f, -0.03080368f, 0.03856263f, -0.02748189f, 0.30113396f, 0.10450898f, 
    0.07083085f, 0.37712505f, -0.11544622f, 0.28743434f, -0.08791161f, 0.04940350f, -0.00910096f, -0.21093225f, 
    0.07502866f, -0.01952695f, 0.11511999f, -0.25706854f, 0.03917691f, 0.13498704f, 0.05912163f, -0.09397952f, 
    -0.08842396f, -0.35869917f, -0.18880107f, -0.14462128f, -0.03049901f, 0.05027644f, -0.07718594f, 0.07373417f, 
    0.02721821f, 0.14562225f, -0.18382172f, -0.04376413f, 0.14994815f, -0.00290602f, -0.02664321f, -0.21200669f, 
    0.15640849f, -0.12414204f, -0.06906631f, 0.01426405f, -0.04897440f, -0.07739428f, 0.35495147f, 0.30718672f, 
    0.13450435f, -0.14943500f, 0.10783659f, 0.01600388f, 0.00928257f, -0.02463802f, -0.04689515f, 0.01469627f, 
    -0.25335479f, -0.04615822f, -0.03150373f, -0.06839796f, 0.15560278f, -0.07946189f, 0.33537659f, 0.14347754f, 
    -0.03141798f, -0.04053014f, -0.01914180f, 0.03191554f, 0.05768768f, -0.02154751f, -0.24446809f, 0.09682979f, 
    0.06140261f, 0.10753196f, 0.06975807f, -0.04231767f, 0.07637858f, 0.08858471f, 0.19134855f, -0.06473064f, 
    0.11636985f, -0.04255340f, 0.02853246f, 0.10308335f, 0.03323117f, 0.33247375f, -0.14179258f, 0.20288233f, 
    0.11929475f, -0.04979656f, -0.10181347f, -0.13909075f, 0.09557693f, -0.08671512f, -0.11268886f, 0.28451318f, 
    0.02186863f, 0.22103190f, -0.38220879f, -0.05594951f, 0.31881440f, -0.10309271f, -0.01807868f, 0.11881585f, 
    0.29596856f, 0.04638055f, 0.13496779f, -0.12708251f, -0.09320140f, 0.10608289f, -0.23990358f, 0.00983210f, 
    0.00991629f, -0.12250237f, 0.02717064f, -0.08819883f, 0.06485572f, 0.18317382f, -0.20685427f, -0.09804647f, 
    0.26881492f, 0.06222983f, 0.21533345f, 0.10936771f, -0.04917047f, 0.03679918f, -0.32736781f, -0.20812428f, 
    -0.09951499f, -0.18182752f, -0.03868301f, 0.04596066f, 0.09532396f, 0.17189953f, -0.14702141f, 0.30273077f, 
    0.02589114f, -0.04985055f, 0.16709387f, 0.21453294f, -0.04463823f, -0.08918937f, -0.03142728f, 0.17579411f, 
    0.00373448f, -0.08596106f, 0.05197453f, 0.41070944f, -0.14777318f, -0.22206157f, 0.05787374f, -0.04410038f, 
    0.09302492f, 0.21976495f, 0.16320109f, 0.11602826f, 0.00349289f, 0.10727368f, 0.17666882f, 0.14370082f, 
    -0.07512344f, 0.07165431f, -0.03249016f, -0.09905304f, -0.05295030f, 0.01046844f, -0.12854756f, 0.08955079f, 
    0.02519696f, 0.10354445f, -0.10074979f, -0.02841867f, 0.11069623f, -0.06685019f, 0.02847919f, -0.08240985f, 
    0.09441967f, -0.00897204f, 0.08827652f, 0.11124335f, 0.10116199f, -0.08468881f, -0.00674609f, -0.11411852f, 
    -0.13066499f, 0.04503974f, -0.09835763f, -0.10454240f, -0.01240771f, 0.03880036f, -0.03830469f, -0.03227844f, 
    0.06424926f, 0.03845653f, 0.01818623f, 0.07873182f, -0.12095874f, -0.11487355f, 0.08215954f, -0.03568846f, 
    0.10100597f, 0.00499048f, -0.06739146f, -0.02165932f, -0.12000750f, 0.02574831f, -0.01193995f, 0.10566423f, 
    0.06341866f, 0.01996909f, 0.11139694f, -0.06449299f, -0.12802611f, 0.01165721f, -0.08805005f, 0.00950832f, 
    0.10760968f, 0.05801180f, -0.09535845f, -0.11535504f, -0.05086238f, -0.01340021f, 0.10359545f, 0.00250744f, 
    0.08224025f, 0.23107715f, -0.10431655f, 0.01907477f, -0.03085708f, -0.06290322f, -0.12258229f, -0.14343701f, 
    0.14280251f, 0.10170314f, -0.05801209f, 0.29965448f, 0.11581830f, -0.11262560f, -0.25213978f, 0.05013206f, 
    0.02098172f, 0.22520892f, -0.02306003f, 0.13674471f, -0.02626923f, -0.00498860f, -0.13277766f, 0.02811861f, 
    0.30801094f, -0.08823575f, 0.15483777f, -0.20163257f, 0.10654828f, -0.02215317f, -0.22098275f, 0.03095314f, 
    -0.09712432f, 0.28016606f, -0.08105742f, -0.00808567f, 0.10767727f, 0.17815463f, 0.20097244f, 0.16654515f, 
    0.23699977f, 0.02734239f, -0.16642410f, -0.02658147f, -0.11469198f, -0.09969955f, -0.04101488f, 0.36020193f, 
    -0.05719158f, 0.05916990f, -0.11782305f, 0.27353144f, 0.12083811f, -0.06694009f, -0.16091864f, 0.07994176f, 
    0.08579205f, -0.02985317f, -0.11887616f, -0.03034071f, -0.06760880f, -0.15090880f, 0.10398327f, 0.21163093f, 
    -0.06055567f, 0.07314029f, -0.14241198f, -0.04535484f, -0.17245172f, 0.15615484f, -0.10575766f, -0.03558978f, 
    0.30340987f, 0.07421140f, 0.04163396f, 0.16077834f, 0.05341731f, -0.00779270f, 0.29380581f, 0.16945770f, 
    0.04775255f, -0.26250875f, -0.07269619f, 0.02352441f, 0.02188339f, 0.25059727f, 0.35698336f, 0.09188864f, 
    0.00999116f, -0.06163422f, -0.13839395f, 0.02490557f, 0.00400269f, 0.12892048f, -0.00733910f, 0.16102421f, 
    -0.11180130f, -0.11286192f, -0.12978971f, -0.10265111f, -0.15087086f, 0.10828879f, -0.35801530f, 0.00682636f, 
    -0.03088779f, 0.16114907f, -0.05748088f, -0.08275988f, -0.09810965f, -0.10144880f, 0.20917441f, 0.05672640f, 
    0.05411628f, 0.03063210f, 0.02558110f, 0.32367620f, 0.21220823f, 0.20454212f, 0.09283879f, 0.02514375f, 
    0.03471210f, 0.18682742f, 0.30572164f, -0.01931519f, -0.07319513f, -0.09338403f, -0.28459212f, -0.10925681f, 
    0.02851743f, 0.10222511f, -0.12300766f, -0.11945806f, -0.12529364f, 0.03226885f, 0.03325406f, -0.03907386f, 
    0.08687609f, -0.08410767f, 0.04841339f, -0.13824081f, 0.02399538f, 0.03466003f, 0.00225717f, -0.02176973f, 
    -0.03768063f, -0.01195528f, 0.03946856f, -0.05197424f, 0.02447082f, -0.04442374f, -0.09831902f, -0.01452558f, 
    -0.04098786f, -0.07029992f, 0.05564752f, -0.11311838f, -0.08231846f, -0.00253280f, 0.00016408f, 0.02875053f, 
    -0.04644240f, -0.08582842f, -0.00321275f, 0.11668721f, -0.12372343f, 0.00507635f, -0.06972025f, -0.02165874f, 
    0.03896438f, -0.09075813f, 0.03905096f, -0.06143439f, -0.06186387f, 0.06867817f, -0.01232572f, -0.05712426f, 
    -0.08774140f, -0.04181650f, 0.02524279f, 0.02967139f, 0.10224865f, -0.13586892f, -0.04081528f, -0.05431037f, 
    0.07357925f, -0.08165937f, -0.00530768f, -0.10444652f, 0.03706208f, 0.02289430f, 0.08684317f, -0.01024092f, 
    0.02074148f, -0.11489157f, 0.21529746f, -0.11519546f, 0.13385004f, 0.19564027f, 0.01925398f, -0.00689600f, 
    0.01599874f, -0.02395339f, -0.16464952f, 0.07063307f, 0.07815228f, 0.10121657f, -0.05092742f, -0.11773951f, 
    -0.08100855f, 0.12577106f, 0.00688843f, 0.34136751f, -0.08988452f, 0.01611125f, -0.27779290f, 0.10767531f, 
    -0.20638867f, -0.01768438f, -0.01134181f, 0.09120860f, 0.00909151f, -0.10138748f, -0.11043976f, 0.03992011f, 
    0.11241882f, 0.10045824f, -0.01797438f, 0.10151803f, 0.08030122f, 0.18729080f, 0.41591805f, -0.05215028f, 
    0.17209008f, -0.27551991f, 0.19037509f, 0.26604411f, -0.04223656f, -0.10901560f, -0.07945842f, 0.02242750f, 
    -0.04783850f, 0.06386839f, -0.08796605f, -0.03403437f, -0.15923220f, 0.20851409f, -0.04648151f, 0.03783061f, 
    0.05162523f, -0.12254568f, -0.18017803f, 0.18727925f, -0.07968213f, -0.17632751f, -0.03856924f, 0.29654655f, 
    0.12143885f, 0.19152695f, -0.10754007f, -0.08640060f, 0.13420032f, -0.05994800f, -0.00508879f, -0.01835923f, 
    -0.21062265f, 0.00747201f, -0.13566729f, 0.11584380f, -0.09024641f, -0.08855108f, -0.09923135f, 0.07299422f, 
    -0.18943985f, 0.24079433f, -0.02737959f, 0.05201844f, -0.06088314f, -0.12146875f, 0.01522956f, 0.05125051f, 
    0.20277672f, -0.11315504f, 0.12422139f, -0.00997307f, 0.06011812f, 0.08493347f, -0.05132775f, 0.08633920f, 
    -0.10743396f, 0.01743920f, 0.05812005f, -0.11345246f, 0.20448434f, -0.04223398f, 0.12324940f, 0.01709853f, 
    0.01711489f, 0.13008261f, -0.42260495f, -0.01642215f, 0.10833982f, 0.00028222f, -0.21411727f, 0.00679378f, 
    0.02936135f, 0.01234007f, -0.06176552f, 0.11218499f, 0.05251780f, -0.03420294f, 0.04064820f, -0.18375258f, 
    0.00511039f, 0.02002941f, -0.34761730f, -0.05186522f, -0.08155206f, -0.24434292f, 0.19760181f, 0.05280268f, 
    0.02022755f, 0.05795938f, -0.04018642f, 0.08859893f, 0.05190852f, -0.08368265f, -0.01175553f, 0.10003471f, 
    0.02392975f, -0.11060046f, -0.10687465f, -0.01768491f, 0.09733663f, 0.01607853f, -0.08429839f, 0.01618968f, 
    0.06583831f, 0.00471376f, -0.11499704f, 0.02441403f, -0.05517352f, -0.10204273f, -0.01080042f, -0.10247712f, 
    -0.07384177f, -0.10171384f, -0.13683562f, 0.07616597f, -0.08156972f, 0.08511107f, 0.09076861f, 0.08828043f, 
    -0.05958042f, 0.04745250f, 0.06646632f, -0.04463860f, -0.11967214f, 0.02879707f, -0.00273528f, 0.08066142f, 
    -0.09518822f, 0.00117000f, -0.07210200f, 0.02015943f, 0.01756448f, 0.00458691f, -0.11143538f, 0.05018605f, 
    -0.03264925f, -0.06208873f, 0.09490214f, -0.05227262f, -0.10386943f, 0.04311298f, -0.05528156f, -0.08814333f, 
    -0.10843485f, -0.06728137f, -0.06637744f, 0.03129373f, 0.10367071f, 0.08960696f, 0.03132816f, 0.10198755f, 
    -0.09710535f, 0.15782893f, 0.30150962f, 0.02536710f, 0.07810730f, -0.12699720f, 0.34461939f, 0.08762000f, 
    0.06454851f, -0.10599855f, -0.33574378f, 0.40695083f, -0.04627304f, -0.04331167f, 0.11171874f, -0.33002609f, 
    0.03132921f, 0.37523490f, 0.13335334f, -0.23693265f, -0.02918546f, -0.10493725f, 0.11293972f, 0.03890415f, 
    0.05928121f, 0.02223431f, 0.05021753f, -0.10930057f, -0.18856503f, -0.04387154f, 0.13619457f, 0.05466080f, 
    0.01942322f, 0.05768827f, 0.10457852f, 0.00499466f, -0.14200249f, -0.08378662f, 0.08816456f, 0.16537531f, 
    -0.04202713f, -0.02383517f, -0.00098117f, 0.07716268f, 0.06197281f, 0.11605203f, 0.03968691f, -0.33969480f, 
    -0.07835910f, 0.10946137f, -0.06808057f, 0.02468961f, 0.18089248f, -0.03478114f, 0.31561708f, -0.02604957f, 
    0.08704636f, -0.01761519f, -0.03668912f, 0.04705039f, 0.03084812f, 0.26232740f, -0.10157111f, -0.02922359f, 
    0.00368944f, 0.16439891f, 0.02157836f, 0.04927995f, 0.05432035f, -0.19994956f, 0.05627947f, 0.15831555f, 
    0.28197941f, -0.02617262f, -0.03694469f, 0.48736611f, -0.13523710f, -0.09795114f, -0.08769432f, -0.10383505f, 
    0.05290575f, 0.26567873f, -0.02659531f, -0.21110366f, 0.07034943f, 0.04324006f, 0.01943900f, 0.10480984f, 
    0.25064823f, 0.03392316f, 0.20297165f, -0.16155744f, -0.13043571f, -0.03174809f, -0.04058310f, -0.12848878f, 
    0.05752369f, 0.22231193f, -0.10630666f, -0.10883974f, -0.27527368f, -0.08063820f, 0.08047810f, 0.16363177f, 
    0.02985629f, -0.16267546f, 0.10024237f, -0.28066468f, 0.09231547f, 0.04572396f, 0.14455298f, -0.01806759f, 
    0.10120323f, 0.01471735f, -0.01951427f, 0.36375895f, 0.16372643f, -0.03639339f, 0.11576804f, 0.26962772f, 
    -0.00005302f, 0.19908249f, -0.01270206f, 0.02016800f, -0.02051594f, 0.22388461f, -0.05953526f, 0.29024389f, 
    -0.10139592f, 0.00639821f, 0.35708529f, -0.01001705f, -0.00547027f, 0.13998461f, 0.22897917f, 0.31639546f, 
    0.12724265f, 0.12064296f, 0.12497567f, -0.22137651f, -0.06903844f, -0.04731454f, -0.10364114f, -0.17289992f, 
    -0.19307366f, 0.17617722f, -0.04269499f, 0.08149448f, -0.02764708f, -0.15604065f, 0.10663855f, -0.03464305f, 
    -0.23288906f, 0.06181242f, -0.09494613f, 0.19246425f, -0.01064367f, 0.00861557f, -0.13446000f, -0.00982969f, 
    -0.05611608f, 0.11966404f, -0.08575902f, 0.11936213f, -0.12424055f, 0.03903152f, 0.24586540f, 0.05540732f, 
    0.09078734f, -0.20922919f, 0.31421089f, 0.13704179f, -0.02365886f, 0.10405825f, 0.11854998f, -0.16440435f, 
    -0.06300920f, -0.11864164f, 0.06698292f, -0.04934542f, -0.08936720f, -0.02637571f, 0.20987235f, 0.20177604f, 
    0.02661162f, -0.05372612f, 0.13222465f, 0.33695248f, 0.07030860f, 0.06949908f, -0.12323007f, -0.06905018f, 
    0.10831711f, 0.00681310f, 0.28505233f, 0.13545883f, 0.24057227f, -0.07626318f, 0.05168750f, 0.11203729f, 
    -0.26149604f, -0.05909799f, 0.18221156f, 0.14732829f, 0.02812592f, -0.07689746f, -0.02610908f, 0.57618791f, 
    -0.17329930f, 0.18306449f, 0.02499180f, 0.05126858f, -0.07085021f, 0.27496457f, -0.04796750f, -0.11526701f, 
    0.23429301f, -0.02566489f, 0.10226214f, -0.24940643f, -0.05163695f, -0.11496732f, 0.20169322f, 0.15796189f, 
    0.06907798f, -0.05494652f, -0.07903728f, 0.04451048f, 0.43228582f, 0.06714937f, -0.14253129f, -0.08991150f, 
    -0.11391254f, 0.11962854f, 0.12474000f, -0.17279430f, 0.00238177f, 0.00177637f, -0.02022571f, 0.24351165f, 
    -0.02498226f, 0.02876490f, -0.00046150f, -0.23111214f, -0.04179173f, 0.03425376f, -0.04205598f, -0.04685444f, 
    -0.04197972f, -0.11018889f, 0.14260103f, 0.01091894f, 0.11030678f, -0.08291394f, 0.27412432f, 0.10671529f, 
    0.08474472f, 0.04950418f, -0.07210402f, 0.07540661f, -0.02632075f, 0.08952738f, 0.01072033f, -0.10269320f, 
    0.08936683f, 0.06587369f, -0.06882807f, -0.10612568f, 0.09781493f, 0.06774151f, -0.03798277f, -0.06359790f, 
    -0.08562607f, -0.12786371f, 0.07617228f, -0.02400551f, 0.01114343f, -0.03212373f, -0.12568374f, -0.00072977f, 
    0.04949411f, -0.02458831f, 0.02428228f, -0.12102196f, -0.04664862f, -0.05782538f, -0.02157621f, -0.12479188f, 
    0.05468555f, 0.04764007f, -0.00180549f, -0.04604088f, 0.02734638f, -0.06404122f, 0.04146665f, 0.08007117f, 
    -0.00675871f, -0.14526598f, -0.05971717f, -0.12174540f, 0.02084336f, 0.07407621f, -0.09501566f, 0.07176793f, 
    -0.12390490f, 0.06985256f, -0.11388722f, 0.01748586f, -0.10817688f, -0.06306395f, 0.08609803f, 0.03486838f, 
    0.07725791f, -0.05028502f, -0.08626086f, -0.15760398f, -0.02508429f, -0.04190877f, 0.05535826f, 0.07676559f, 
    -0.02999853f, 0.31179255f, 0.11969330f, -0.08087390f, -0.22435671f, 0.18178065f, 0.09174794f, 0.10729777f, 
    0.27174148f, 0.03538752f, 0.02461513f, 0.32922062f, -0.01587881f, 0.08794372f, 0.09099677f, 0.17266071f, 
    -0.04514525f, 0.28269190f, 0.04502000f, 0.19604929f, -0.06623459f, 0.02272805f, -0.10538319f, -0.02726749f, 
    -0.12659185f, 0.00416249f, 0.02981344f, 0.02168524f, 0.13845532f, -0.06424741f, -0.11963936f, -0.07535469f, 
    0.10217813f, -0.04714414f, -0.05694728f, 0.11060068f, 0.15813638f, 0.18783236f, -0.13320422f, -0.12356686f, 
    -0.20646796f, 0.28834841f, -0.00635314f, -0.03401930f, 0.08126599f, 0.07784551f, -0.08033879f, -0.10384726f, 
    -0.02552882f, -0.12223806f, 0.08287954f, 0.00762398f, -0.14556345f, -0.05494003f, 0.01385968f, -0.23885284f, 
    0.02476624f, 0.13949281f, 0.33981073f, -0.07690655f, -0.06681803f, -0.17635119f, -0.06075837f, 0.01449697f, 
    -0.11558777f, 0.08627837f, -0.10477664f, 0.03605649f, -0.08129720f, -0.12219092f, 0.09395013f, 0.04269449f, 
    -0.08847095f, -0.04147226f, 0.06490830f, -0.11554796f, -0.05992808f, -0.03100343f, -0.10698903f, 0.03701283f, 
    0.01012488f, 0.05749196f, 0.04895820f, -0.10144284f, -0.11268416f, 0.05300917f, -0.09670342f, 0.11241190f, 
    0.00191610f, -0.12948582f, -0.02727788f, 0.09244022f, 0.02109894f, -0.05848479f, -0.02050416f, -0.00218315f, 
    0.02664142f, -0.11111514f, -0.11369128f, 0.04259872f, -0.11523816f, -0.05668889f, -0.01976569f, 0.11360060f, 
    -0.05244637f, -0.09987539f, -0.11501029f, 0.00566463f, 0.02040331f, 0.10924418f, -0.11325874f, -0.05586664f, 
    0.03249303f, -0.07092406f, 0.04073415f, 0.08295347f, -0.05491575f, 0.01668411f, -0.05251154f, -0.00405839f, 
    -0.04162512f, 0.01823995f, 0.04808693f, -0.05799142f, 0.10993716f, -0.05007684f, -0.04155068f, -0.07423747f, 
    0.08264451f, -0.12066951f, 0.13213614f, 0.04592956f, 0.14883704f, -0.04864151f, -0.17568310f, -0.14175539f, 
    -0.02139729f, 0.08986454f, -0.16831523f, -0.14647895f, 0.05929771f, -0.08391349f, 0.41441861f, 0.15659517f, 
    0.35148081f, -0.11103041f, -0.04011914f, 0.18344247f, -0.11645378f, 0.19357969f, -0.14258654f, 0.10698787f, 
    -0.00005721f, 0.12027445f, 0.15591051f, 0.20684494f, 0.06802543f, 0.11482325f, 0.27457210f, 0.03864511f, 
    -0.02766278f, -0.00805968f, 0.01165829f, -0.04581982f, 0.31449062f, 0.17665598f, -0.23612310f, 0.10066734f, 
    0.17844398f, 0.47437754f, -0.04221416f, 0.34574491f, 0.03036781f, -0.02740638f, 0.04858389f, 0.04883878f, 
    -0.04867810f, 0.07831110f, -0.05154333f, -0.37807429f, 0.03487824f, 0.27532408f, -0.08243356f, -0.00566672f, 
    0.06883579f, -0.22113204f, 0.08075876f, -0.25697625f, 0.00642825f, -0.19476421f, -0.02545307f, -0.19649747f, 
    -0.04579425f, 0.02430810f, 0.08885816f, 0.10838879f, 0.07081151f, 0.04457945f, -0.22013091f, 0.04989167f, 
    0.23185684f, -0.03521791f, -0.01095007f, -0.12602317f, -0.00063904f, -0.02570789f, -0.08737678f, -0.21814696f, 
    -0.01726054f, -0.12339115f, 0.11841357f, 0.10873023f, -0.05956949f, 0.19496669f, -0.24492493f, 0.05081937f, 
    0.01422664f, 0.07150564f, 0.10582951f, 0.09947788f, 0.11050150f, -0.12047045f, -0.31380183f, -0.13363688f, 
    -0.04492217f, -0.03326284f, -0.00738914f, 0.07138237f, 0.09133964f, 0.24334133f, 0.06142202f, 0.09288076f, 
    0.13578948f, 0.19138958f, -0.07977581f, 0.38412562f, 0.02817225f, -0.06263044f, 0.06918132f, 0.23569587f, 
    0.04917416f, -0.03526981f, -0.05523756f, -0.09064325f, -0.02806022f, -0.05184988f, -0.19959231f, 0.06639936f, 
    -0.12041259f, -0.02452492f, 0.19743221f, 0.16866829f, 0.04553846f, -0.24128325f, 0.06147418f, 0.08190518f, 
    -0.06582539f, 0.27548143f, -0.05034450f, 0.08771130f, -0.22924852f, 0.10852040f, 0.20474727f, 0.37727723f, 
    0.08264773f, -0.03678339f, 0.44650263f, 0.44453180f, 0.04060065f, 0.12719779f, 0.16630185f, 0.08688559f, 
    -0.12382085f, 0.06909719f, 0.11472385f, 0.08820515f, 0.10306254f, 0.17845400f, 0.27716541f, 0.02954825f, 
    0.02316842f, -0.06696707f, 0.23979776f, 0.00640957f, 0.07401012f, -0.08787747f, -0.15734255f, -0.10060561f, 
    0.01099902f, 0.00431302f, -0.01299062f, 0.00160302f, 0.23840459f, 0.07136802f, -0.10382966f, 0.03404179f, 
    -0.12217812f, 0.04377980f, 0.04791784f, -0.17911491f, -0.06697265f, -0.04221522f, -0.06271593f, -0.01933960f, 
    0.12914991f, 0.03094893f, -0.07737293f, 0.20295864f, 0.10175368f, -0.17731525f, -0.02521236f, -0.04999882f, 
    -0.02972090f, 0.49853712f, 0.34011418f, -0.07051728f, -0.02462441f, -0.06288840f, 0.05767602f, -0.07280312f, 
    -0.00030412f, 0.04060952f, 0.55835521f, -0.15863550f, 0.09140538f, 0.17065047f, -0.05510004f, -0.06661242f, 
    0.10617940f, -0.04288286f, -0.13157208f, 0.25406745f, -0.05539078f, 0.06831233f, -0.02865039f, 0.22657105f, 
    0.10510304f, 0.07969893f, 0.08007310f, -0.13974889f, 0.07281926f, 0.09356311f, 0.11776532f, -0.05481455f, 
    0.03653764f, -0.00486336f, -0.02425621f, -0.04979849f, -0.20457959f, -0.03267789f, 0.22148083f, 0.00667167f, 
    0.10896923f, 0.14553119f, -0.07860055f, 0.05378890f, 0.09247124f, -0.24785259f, -0.10182354f, 0.23780797f, 
    -0.30508804f, 0.12766406f, -0.05200211f, -0.12889567f, -0.01508611f, -0.12277445f, 0.09286459f, -0.23000889f, 
    0.12431775f, 0.04246656f, 0.09605138f, 0.10154860f, 0.16673015f, 0.16796504f, 0.05703700f, -0.10721505f, 
    -0.00300340f, -0.01009371f, 0.12232480f, -0.19788614f, -0.05754231f, 0.26976228f, -0.18640940f, 0.01243380f, 
    0.02453940f, 0.06958269f, -0.11178042f, -0.03876122f, 0.01391380f, 0.18783432f, 0.28906476f, 0.29227760f, 
    -0.06216061f, -0.00798008f, 0.01647853f, -0.47453797f, -0.01641261f, 0.07747796f, 0.21241543f, -0.24134833f, 
    -0.03685614f, -0.16071779f, 0.01761472f, 0.16614820f, -0.04415543f, -0.15558711f, -0.01278090f, 0.01293151f, 
    -0.06829371f, 0.03197869f, 0.14531246f, 0.36667559f, 0.14342523f, 0.04557383f, 0.17520656f, -0.08462933f, 
    -0.07841800f, -0.09092964f, 0.10868759f, 0.07968712f, 0.22476505f, 0.06558214f, -0.03004489f, 0.14102328f, 
    -0.12736273f, 0.20461479f, 0.00825825f, 0.08355789f, -0.03034215f, -0.02631372f, 0.00460197f, -0.23848030f, 
    -0.02114758f, -0.08616108f, 0.03661635f, -0.03626174f, 0.21005699f, 0.10002372f, 0.12304189f, -0.19255899f, 
    -0.00397524f, 0.00672116f, 0.06105014f, 0.06137028f, -0.02673671f, 0.09954629f, 0.04061350f, -0.38865623f, 
    0.02215350f, 0.06033938f, -0.08665416f, 0.06701726f, 0.32653663f, -0.00622338f, 0.22722326f, 0.18457824f, 
    -0.31193441f, 0.01945856f, 0.32360893f, -0.20666690f, 0.08752616f, -0.10734088f, 0.12738411f, -0.07583949f, 
    -0.42642805f, 0.03347800f, -0.01212601f, 0.09667952f, 0.01660893f, -0.10464446f, -0.15326652f, 0.01018933f, 
    0.24782759f, 0.05742993f, 0.27460617f, 0.05997516f, -0.19462688f, -0.04094193f, 0.36727548f, 0.24918737f, 
    -0.10453587f, 0.35621676f, -0.03415046f, 0.03420094f, 0.15041275f, -0.20993640f, 0.11380908f, 0.03224536f, 
    0.11631791f, 0.09725324f, 0.04860432f, -0.19358066f, 0.05131571f, -0.02009497f, -0.05817859f, -0.10315863f, 
    0.04480295f, -0.12439113f, 0.05727006f, -0.20068260f, 0.29572028f, -0.04799969f, -0.00659828f, 0.05609811f, 
    0.00211444f, -0.03104104f, -0.07991095f, 0.12632559f, 0.05914587f, -0.05693248f, -0.23384373f, 0.15260822f, 
    0.08812962f, -0.04745055f, 0.24418898f, 0.08816072f, -0.01483606f, 0.02597530f, 0.02326027f, 0.14489385f, 
    0.06437389f, -0.03431778f, -0.01545619f, -0.16599722f, -0.00751077f, -0.05462251f, -0.15329787f, -0.15529618f, 
    -0.01828817f, -0.03560118f, -0.06013796f, -0.01848202f, 0.02805599f, 0.00812151f, 0.22978348f, -0.07573960f, 
    -0.01916521f, -0.06912420f, -0.29228437f, 0.02114943f, 0.18726842f, 0.00877632f, 0.02350277f, 0.28208786f, 
    0.07538324f, -0.02915859f, -0.07265275f, 0.07451416f, -0.17024669f, 0.15007500f, 0.26861760f, -0.17458856f, 
    0.32611850f, -0.22860888f, 0.26501164f, 0.09538029f, 0.01100038f, -0.06291206f, 0.14080043f, 0.24242680f, 
    0.12116270f, 0.01159460f, -0.04341029f, -0.02171288f, 0.10384689f, 0.07232514f, -0.11025622f, 0.34852290f, 
    -0.01838657f, -0.00426888f, 0.05434157f, 0.35633087f, -0.10434239f, -0.13358833f, -0.32706633f, -0.27140337f, 
    0.12156148f, 0.13386381f, -0.09764349f, -0.08228704f, -0.32955274f, 0.06725158f, 0.18529244f, 0.17639317f, 
    -0.03787418f, 0.02874589f, 0.46259221f, 0.31480426f, 0.11674252f, -0.09345081f, 0.06210738f, -0.18039195f, 
    -0.19764386f, -0.00233024f, 0.07859249f, 0.36156267f, -0.01679509f, -0.06648107f, 0.06384614f, 0.06497560f, 
    -0.00798800f, 0.12582834f, 0.13347800f, 0.04219540f, 0.08463875f, 0.06718837f, -0.04921519f, 0.01325959f, 
    0.10826188f, 0.06050804f, 0.05186217f, -0.08110617f, 0.11494417f, 0.18080227f, 0.37702078f, -0.20963693f, 
    -0.07650419f, -0.01609145f, -0.16028078f, 0.06778257f, -0.00361141f, -0.08024166f, 0.10320923f, 0.21792926f, 
    -0.06344700f, 0.02432631f, 0.02060035f, -0.07391690f, 0.06428426f, -0.11987291f, -0.19047153f, -0.16539498f, 
    -0.03499061f, 0.39810210f, 0.06191564f, -0.11979793f, 0.07756890f, -0.21680985f, -0.00978983f, -0.01231830f, 
    -0.11166547f, -0.09208494f, 0.35712382f, -0.05642080f, -0.02775995f, -0.18162505f, 0.10141844f, 0.05249280f, 
    -0.00964655f, 0.01601648f, 0.04989260f, 0.17996410f, 0.02581885f, 0.10983622f, -0.01799409f, 0.02211514f, 
    0.05746106f, 0.11261437f, 0.06438871f, 0.00004991f, -0.04129657f, -0.02536812f, -0.03575122f, 0.08144811f, 
    -0.01019993f, 0.02567662f, 0.17052990f, -0.02356746f, 0.02394652f, 0.06012042f, 0.03901123f, -0.05583653f, 
    -0.06272957f, 0.08170386f, -0.10459317f, -0.03437458f, -0.04539162f, 0.10011729f, -0.02083552f, -0.11558193f, 
    0.09458550f, 0.02344643f, -0.02795001f, -0.16734709f, 0.06158480f, -0.04278585f, -0.12858209f, -0.01920045f, 
    -0.03064899f, -0.11599201f, -0.07277210f, -0.32481554f, -0.03617231f, 0.01270267f, 0.10806847f, -0.00451301f, 
    -0.08975735f, -0.07662544f, 0.14036201f, 0.00633704f, 0.11655191f, 0.00724297f, 0.00039262f, 0.14459670f, 
    0.08727230f, 0.29191324f, -0.71701944f, -0.12557073f, 0.23656185f, -0.08861709f, -0.13988550f, -0.04834285f, 
    -0.06780192f, -0.00057080f, -0.05656048f, -0.28106764f, -0.00882588f, -0.02453879f, 0.06543910f, -0.33269861f, 
    -0.19659218f, -0.40402788f, -0.08561122f, -0.07549523f, -0.08564351f, -0.10292225f, -0.17859428f, 0.05732352f, 
    0.13395391f, -0.03104850f, 0.14127602f, 0.20416938f, -0.18057753f, -0.03863191f, 0.24108914f, 0.12498279f, 
    -0.11447455f, 0.19771855f, 0.00977749f, 0.12922505f, -0.27054867f, -0.08634660f, -0.04328218f, 0.29419070f, 
    0.19104496f, 0.33154225f, -0.28225410f, 0.11868683f, -0.10442777f, -0.09738582f, 0.18895373f, 0.04748096f, 
    -0.04098170f, 0.09053072f, -0.11992618f, 0.34544319f, 0.39676055f, 0.03673946f, -0.10061222f, 0.18580319f, 
    0.02804526f, 0.07854600f, -0.28500465f, 0.15568610f, 0.02856975f, 0.05391970f, -0.18019542f, 0.18106262f, 
    -0.01664403f, -0.05658762f, -0.00723826f, -0.04740980f, -0.12194423f, -0.13835625f, 0.07696044f, -0.05669027f, 
    -0.08919590f, 0.06680369f, -0.12470770f, -0.13183546f, 0.00314470f, -0.09671035f, -0.11083953f, 0.10550976f, 
    0.01019431f, -0.04197285f, -0.10594474f, 0.07034725f, -0.06898974f, -0.05633552f, -0.00447114f, -0.04174749f, 
    -0.08539838f, -0.04758682f, 0.09395853f, -0.02872973f, 0.05329172f, -0.09010721f, 0.01510173f, -0.06120137f, 
    0.10142832f, 0.08783161f, -0.07215764f, 0.02110382f, 0.03601257f, -0.10054234f, -0.11729098f, -0.09707604f, 
    0.02175229f, 0.08183613f, -0.04946431f, 0.01017013f, -0.00643719f, 0.11090060f, 0.01084780f, 0.06088080f, 
    -0.06099698f, -0.12565333f, 0.03818920f, -0.09020878f, 0.10720460f, -0.10473710f, -0.13530105f, -0.11545150f, 
    0.09643398f, 0.02926708f, -0.07861485f, -0.07995313f, -0.05592138f, -0.02912769f, 0.06853200f, 0.07849134f, 
    -0.09490398f, -0.03573527f, -0.00852716f, -0.02983579f, 0.05327208f, 0.16843608f, 0.06980678f, 0.06201921f, 
    0.08478389f, 0.10066356f, -0.08641186f, 0.13024612f, -0.07885658f, 0.06890666f, 0.06938282f, -0.02184440f, 
    -0.01901607f, 0.29550934f, -0.09415230f, 0.12553079f, 0.09572713f, -0.11797483f, -0.12234101f, 0.08457022f, 
    0.11118416f, 0.09686031f, 0.22937772f, -0.10331766f, 0.00811877f, 0.06796334f, 0.28585571f, 0.06375895f, 
    -0.07887203f, 0.30436468f, 0.04326113f, 0.03439691f, -0.06806720f, -0.14956880f, 0.15662579f, 0.03475038f, 
    0.07186209f, 0.13054770f, -0.09006773f, -0.29929388f, 0.03419045f, 0.05741152f, -0.05724361f, 0.00376306f, 
    -0.05761412f, 0.09901091f, -0.05509716f, 0.00991559f, 0.28386542f, 0.03413024f, 0.04522272f, 0.12045670f, 
    0.05000031f, -0.17057656f, 0.06879568f, -0.12061851f, -0.08474099f, 0.05975368f, -0.08789679f, 0.10489088f, 
    -0.09063700f, -0.19658895f, 0.06339480f, -0.05796204f, 0.03265344f, -0.00348141f, 0.02732637f, -0.08904843f, 
    -0.33013296f, 0.06667884f, -0.09488137f, -0.20828180f, -0.05803255f, 0.08802190f, -0.34926829f, -0.13620934f, 
    0.15947978f, 0.00263388f, 0.05048394f, 0.25083259f, -0.11619331f, -0.15488969f, 0.06772152f, 0.00705566f, 
    0.28523001f, 0.00318270f, -0.08333436f, -0.00854954f, 0.07418860f, -0.04454932f, -0.17501315f, 0.21661526f, 
    -0.08603153f, 0.19285403f, -0.02255250f, 0.09934742f, 0.09759017f, -0.02019872f, 0.50777519f, 0.06625510f, 
    0.22976615f, -0.01562975f, -0.00713883f, 0.22031371f, 0.12230015f, 0.09388138f, 0.02588030f, 0.13105042f, 
    -0.07781345f, 0.00951444f, 0.05028131f, -0.04624364f, 0.06361771f, 0.14394081f, -0.25360152f, 0.11986930f, 
    0.00201080f, -0.14184302f, -0.30577371f, 0.20353323f, 0.12072221f, -0.11440010f, 0.18062355f, 0.14525068f, 
    0.11525503f, -0.02355853f, 0.10354957f, 0.09429197f, 0.02498402f, -0.12203973f, 0.01548421f, -0.05557217f, 
    -0.05836494f, -0.08592117f, -0.13922332f, -0.00267958f, 0.02913544f, -0.08565825f, -0.02485392f, 0.00632057f, 
    0.08665420f, -0.12756936f, -0.10242096f, 0.03399849f, -0.05541267f, 0.10144749f, 0.06167425f, 0.02847038f, 
    0.06868655f, 0.09771836f, 0.00472296f, -0.12834688f, -0.06473167f, -0.02411743f, -0.01995529f, 0.04793291f, 
    -0.10924390f, -0.01791722f, -0.02899361f, -0.00788550f, -0.03181360f, -0.00020290f, -0.08759287f, -0.02869968f, 
    -0.04656734f, -0.09921789f, 0.07664058f, 0.09399097f, 0.07124408f, -0.07469542f, -0.10021742f, -0.06012496f, 
    0.02053921f, -0.04208428f, -0.03071322f, 0.08339342f, -0.04365997f, -0.09397686f, -0.04614138f, -0.03861146f, 
    0.01599105f, -0.14182602f, 0.00553524f, -0.03382222f, 0.05656448f, -0.02717028f, -0.10907818f, -0.13360234f, 
    0.12427206f, -0.16913472f, 0.13230722f, 0.05602882f, -0.25890270f, 0.05592823f, 0.29053441f, 0.31612170f, 
    -0.20399763f, -0.00788697f, 0.23009539f, -0.07582036f, 0.08085646f, 0.10975665f, 0.03113896f, -0.02231187f, 
    0.02426622f, -0.05450084f, -0.00873754f, 0.05117593f, 0.10748650f, 0.07155736f, 0.28502306f, 0.04059457f, 
    0.17575210f, -0.11479085f, 0.03693298f, 0.23698354f, -0.03916307f, -0.01011211f, -0.16752948f, 0.11713795f, 
    0.04921761f, -0.22741924f, 0.07235301f, 0.08048570f, 0.27945912f, 0.00908614f, 0.07889901f, 0.00181696f, 
    -0.08511363f, 0.17239302f, -0.06138515f, 0.10897377f, -0.09400225f, 0.02993950f, -0.09324563f, -0.17847061f, 
    0.10354831f, 0.03154840f, -0.04119111f, 0.06280471f, 0.02539428f, -0.02478346f, 0.01532723f, -0.19414233f, 
    0.09511201f, 0.27605227f, 0.12822804f, -0.00806901f, -0.10926356f, 0.03884545f, 0.20972091f, -0.34089640f, 
    0.12103666f, -0.21995036f, 0.25665072f, -0.04231069f, 0.13171244f, -0.08849061f, -0.19606464f, -0.28289795f, 
    -0.27753964f, -0.09436192f, -0.49288192f, 0.08758812f, -0.09038219f, -0.07066061f, -0.23116042f, 0.38743520f, 
    -0.09673558f, -0.01333297f, -0.04744932f, 0.20926499f, -0.12092584f, 0.20588487f, 0.10669424f, 0.03923385f, 
    0.21519281f, 0.03839344f, -0.09043315f, -0.19873926f, 0.10183662f, 0.11018839f, 0.02217016f, 0.07530644f, 
    0.01312008f, -0.20104630f, -0.11117689f, -0.06328919f, 0.06749526f, 0.10150230f, 0.05264310f, 0.09526881f, 
    0.21164620f, -0.13386579f, 0.00223602f, 0.27612743f, -0.09292278f, 0.10488416f, -0.01607470f, 0.24624923f, 
    -0.03108835f, 0.05444562f, 0.09612416f, 0.03145865f, -0.29022169f, 0.04286272f, -0.33789176f, 0.07430521f, 
    -0.03637291f, -0.26085702f, -0.24650773f, 0.00132716f, -0.09183738f, 0.00457544f, 0.33514258f, 0.11672684f, 
    -0.08656673f, -0.00571145f, -0.11181316f, 0.05905148f, -0.09455399f, -0.09194731f, -0.10115758f, -0.05593576f, 
    -0.01165189f, 0.07203053f, 0.07639602f, 0.03370026f, 0.06192534f, 0.03779326f, 0.08640469f, 0.03281090f, 
    -0.01437369f, -0.05406461f, -0.11783597f, -0.07096245f, 0.04007879f, 0.06784750f, -0.06117104f, -0.09971412f, 
    -0.08401514f, 0.03910358f, -0.03473737f, -0.09700723f, -0.02575690f, 0.05789071f, 0.11616724f, 0.01995463f, 
    -0.02259611f, -0.10482553f, 0.09013292f, 0.07196265f, 0.01805440f, -0.02992301f, 0.03429913f, -0.00250406f, 
    -0.10318512f, -0.10350396f, -0.09039837f, -0.01297520f, -0.08981065f, -0.07466735f, 0.06403735f, -0.10275851f, 
    0.12161785f, -0.05872929f, 0.05802581f, -0.11463468f, -0.00480513f, 0.00554545f, 0.06520087f, -0.04420446f, 
    -0.06929593f, -0.02042185f, 0.02377860f, 0.00470236f, 0.00270860f, -0.11823504f, 0.03443817f, -0.02846407f, 
    0.11229120f, -0.05416253f, -0.05689208f, 0.08958445f, -0.10592161f, 0.22511362f, 0.28578100f, 0.29794028f, 
    0.22513419f, 0.01974825f, 0.29639629f, -0.05086013f, 0.03046697f, -0.10137562f, 0.35742271f, -0.01064291f, 
    0.12341247f, -0.21512805f, 0.11905404f, -0.07788946f, 0.04811829f, 0.11597799f, 0.34102225f, -0.11274798f, 
    -0.30458811f, 0.06540718f, -0.06617787f, 0.34477636f, 0.08618245f, -0.08402799f, 0.19921461f, 0.13697979f, 
    -0.02494423f, -0.25769314f, 0.12399912f, -0.04006681f, -0.08427422f, 0.17025280f, -0.18316910f, -0.01678898f, 
    -0.08257478f, 0.09906953f, 0.14089933f, 0.06689375f, -0.09126799f, -0.10334279f, 0.19475459f, -0.36113176f, 
    0.09624097f, -0.03434616f, -0.10767572f, 0.17039080f, -0.11045397f, 0.09541482f, 0.33426905f, -0.08438525f, 
    -0.11287712f, 0.32734329f, 0.38570192f, -0.03902026f, -0.02353449f, -0.03026467f, -0.06026027f, -0.00584272f, 
    -0.09044789f, 0.23875362f, -0.18075365f, -0.03353403f, 0.10591506f, 0.08062735f, 0.21272336f, 0.33471751f, 
    0.13392004f, -0.00964430f, -0.01287421f, -0.09902390f, 0.09388708f, 0.11555441f, 0.09409084f, -0.35889214f, 
    -0.13524947f, 0.09577984f, -0.02366734f, 0.01092501f, -0.11335109f, -0.12633298f, -0.08478627f, -0.11627112f, 
    0.09551738f, 0.00780506f, 0.28874722f, 0.20105502f, -0.11686157f, 0.04341862f, -0.07242780f, -0.00303111f, 
    -0.07839316f, 0.27356240f, 0.02420044f, -0.03415436f, -0.08369786f, 0.06102820f, 0.16993287f, 0.17398228f, 
    0.12216890f, 0.06157707f, -0.11475407f, -0.09209168f, -0.10531665f, -0.07432155f, -0.04546231f, -0.16085824f, 
    -0.02187490f, 0.05060875f, 0.08775374f, 0.23261033f, 0.15272754f, -0.18601197f, 0.16312091f, 0.06822732f, 
    0.11714648f, 0.07277671f, 0.17525744f, 0.04828466f, -0.03305738f, 0.25180766f, 0.02943197f, -0.16604732f, 
    -0.01917900f, 0.04911756f, 0.32761735f, 0.07313201f, 0.09753963f, -0.02946827f, 0.20013119f, 0.01603625f, 
    -0.27484706f, -0.01955770f, -0.16338854f, 0.02727354f, 0.06704652f, -0.03873466f, -0.06148268f, 0.02373579f, 
    -0.04164251f, 0.15059979f, 0.11604444f, -0.06612320f, 0.02115107f, 0.00078543f, -0.02760639f, -0.11115611f, 
    0.14389190f, 0.06146638f, -0.01408682f, -0.34497556f, -0.15918872f, 0.11820446f, -0.05945126f, 0.19190596f, 
    -0.10472980f, 0.31171450f, 0.12350412f, 0.02624241f, -0.24425215f, -0.13801406f, 0.28366819f, -0.17625587f, 
    0.17637448f, -0.16461085f, 0.10033437f, -0.12510784f, -0.06697248f, 0.09225079f, -0.10546063f, -0.12938863f, 
    0.06621124f, 0.11777827f, 0.09755661f, -0.32120284f, 0.08652324f, -0.09788420f, 0.13942978f, 0.26703182f, 
    0.03070588f, -0.07455628f, 0.01717503f, -0.00253274f, 0.12178513f, 0.17325045f, -0.05310936f, 0.17706600f, 
    -0.04060978f, -0.04334716f, -0.17033738f, -0.05429301f, 0.20345156f, -0.09333830f, 0.09341886f, 0.15286054f, 
    0.05399254f, 0.04537443f, 0.39372635f, 0.18009858f, 0.05571300f, -0.05551694f, -0.09430484f, 0.39835614f, 
    -0.18410009f, 0.11119079f, 0.01352570f, -0.25481725f, 0.06290273f, 0.22247984f, 0.27639848f, -0.04269342f, 
    0.20789227f, -0.10403719f, -0.07614930f, -0.19945872f, 0.10111656f, 0.05879271f, -0.06901623f, 0.07155956f, 
    0.12499961f, -0.09483256f, 0.11073854f, 0.00785665f, -0.18687540f, -0.08395867f, -0.18193200f, 0.24012776f, 
    0.03542512f, -0.44419765f, 0.24390958f, -0.26736751f, 0.10508939f, 0.08754095f, 0.13281102f, 0.10366853f, 
    -0.02422652f, 0.08123482f, 0.05511033f, 0.42639622f, -0.15047622f, -0.01869810f, 0.00509368f, 0.30026501f, 
    0.09892783f, 0.31296244f, -0.13694045f, 0.22183497f, -0.07061746f, 0.17617099f, 0.26368287f, 0.20048524f, 
    -0.03308116f, -0.01251044f, 0.32329077f, -0.09024682f, -0.07531389f, 0.18264253f, 0.14019413f, -0.08517651f, 
    0.03870169f, -0.02247569f, -0.41954851f, 0.11416656f, -0.03745295f, -0.08157048f, -0.21243195f, -0.19178173f, 
    -0.03589512f, 0.19247687f, -0.10678544f, 0.20904136f, 0.07118053f, -0.27608678f, 0.07983050f, -0.04226328f, 
    0.18209262f, -0.07270238f, 0.05174614f, 0.16837236f, -0.20939347f, -0.00634963f, -0.01387692f, -0.02211344f, 
    0.11559758f, 0.15902235f, 0.08100696f, 0.08972554f, 0.04775633f, 0.03564655f, 0.30702376f, 0.18588360f, 
    -0.13359086f, -0.04250859f, -0.06406735f, 0.31255084f, 0.10642937f, -0.09313891f, 0.10758315f, -0.21774611f, 
    -0.05611355f, -0.01687498f, -0.12221405f, 0.18847841f, -0.10511123f, 0.10356895f, 0.29114395f, -0.17151020f, 
    0.10301567f, -0.21226625f, -0.24957590f, 0.16263628f, 0.03929805f, 0.22364889f, 0.26931024f, 0.19800317f, 
    0.08164920f, 0.01527097f, -0.09309125f, -0.01161443f, 0.08060928f, -0.00019967f, -0.02378398f, -0.08958437f, 
    -0.10416242f, 0.11195497f, 0.00801541f, 0.02349252f, -0.04065453f, 0.00063436f, -0.06501944f, -0.04617915f, 
    -0.06663175f, 0.10758983f, -0.10611914f, -0.13078684f, 0.04811639f, 0.05843178f, -0.07875073f, 0.02782479f, 
    -0.00979155f, 0.02323068f, -0.06198632f, -0.04142265f, -0.02968462f, 0.09174417f, -0.03801702f, -0.00670429f, 
    -0.06826577f, 0.06274945f, -0.00312750f, -0.09597230f, -0.04951192f, -0.04215803f, 0.04798599f, -0.09685711f, 
    -0.08047135f, -0.07902341f, 0.06920940f, -0.05430603f, -0.07042404f, -0.03449340f, -0.06129297f, -0.02192316f, 
    0.05512166f, 0.09597667f, 0.11510556f, -0.03887133f, -0.05503350f, -0.02978309f, 0.03434647f, 0.11206751f, 
    0.02501297f, -0.00078345f, 0.00611632f, 0.07594232f, 0.09591642f, -0.01948772f, 0.03927800f, -0.12428597f, 
    0.05062485f, -0.04667990f, -0.18075837f, -0.03294385f, -0.00380879f, 0.20268264f, 0.25659174f, 0.00572444f, 
    -0.12385800f, 0.09852614f, 0.20300904f, 0.18311213f, 0.02056862f, -0.03910039f, 0.25865805f, 0.18431778f, 
    -0.18644369f, 0.15839092f, -0.06597450f, 0.37313649f, -0.01921965f, -0.08427402f, 0.07501103f, 0.02880673f, 
    -0.15195787f, 0.02647329f, 0.22233364f, -0.11107644f, 0.16262579f, 0.04582357f, 0.42885926f, 0.21720220f, 
    0.09887610f, 0.03889237f, -0.09764403f, 0.05729308f, 0.29056337f, 0.03588968f, 0.20763364f, -0.18128234f, 
    0.03154182f, 0.12212853f, -0.09230096f, -0.11507719f, -0.01271888f, -0.11610945f, -0.19566548f, -0.16588689f, 
    0.05970429f, 0.01641153f, 0.00412852f, -0.29109371f, 0.05095418f, 0.20433715f, -0.23038006f, -0.09900641f, 
    0.09988084f, -0.03368055f, -0.16346812f, -0.04207271f, 0.01317570f, -0.31559268f, 0.08001842f, 0.08559543f, 
    -0.00836129f, 0.19530222f, 0.06176908f, 0.03549403f, 0.39487940f, -0.11825980f, -0.25446966f, -0.13013841f, 
    -0.09779302f, -0.03346066f, -0.09010946f, 0.00861845f, -0.05547200f, 0.06476486f, -0.09644672f, 0.25996470f, 
    -0.11850463f, 0.21599719f, -0.06366311f, 0.02063330f, -0.12744160f, 0.16900878f, -0.59375465f, 0.04263997f, 
    0.22804177f, -0.10531640f, 0.15089849f, -0.09417240f, 0.08239701f, -0.05370808f, -0.03119224f, -0.12061433f, 
    -0.10917274f, 0.14400642f, 0.10753051f, -0.02883148f, 0.07288310f, -0.01905846f, 0.15475222f, -0.02170178f, 
    0.13993703f, 0.11166797f, 0.00769477f, 0.26742089f, 0.08373749f, 0.08294805f, -0.11489106f, 0.32145837f, 
    -0.00605686f, -0.04084646f, 0.11320942f, -0.04679152f, -0.06410898f, -0.11911225f, -0.22488682f, 0.00165936f, 
    -0.10775606f, -0.14703262f, -0.19138545f, 0.11600205f, 0.04175224f, -0.09467247f, 0.26771757f, 0.19865040f, 
    0.00430776f, -0.10494985f, -0.43821135f, 0.07927208f, 0.22699557f, 0.08686735f, 0.20099701f, -0.20990658f, 
    -0.02532184f, -0.06972106f, -0.08796696f, 0.01148175f, 0.01395686f, 0.13178787f, -0.08594384f, 0.09691575f, 
    0.12237160f, 0.18055236f, -0.02809825f, 0.01551357f, 0.11683924f, -0.04444060f, 0.28088865f, 0.05888640f, 
    0.18861634f, -0.04222683f, 0.14329676f, -0.10181139f, 0.17643516f, 0.11382440f, 0.33513501f, 0.16383649f, 
    -0.01124710f, 0.07231521f, 0.06262738f, -0.05200098f, -0.08614329f, 0.01117767f, 0.04529816f, 0.33736211f, 
    -0.01366104f, -0.16093351f, -0.10269010f, -0.08523656f, 0.00632997f, 0.09577177f, 0.00106991f, 0.17810269f, 
    -0.05357029f, 0.09404320f, -0.00747557f, 0.18688977f, 0.03239217f, 0.01475398f, 0.25812832f, 0.08578818f, 
    0.01282556f, -0.05651888f, -0.51343274f, 0.02194794f, 0.01378788f, -0.11363401f, 0.38932565f, 0.30570325f, 
    -0.11364487f, -0.01758961f, 0.02410379f, 0.03198512f, -0.11150230f, 0.09210158f, -0.28300071f, -0.10384043f, 
    0.08743602f, 0.00511447f, 0.31380451f, 0.01964219f, 0.00953528f, -0.07085696f, 0.33559999f, 0.09744202f, 
    0.13505700f, -0.06700315f, -0.00951469f, 0.14707761f, 0.03379987f, 0.08600058f, -0.13810256f, 0.10319099f, 
    0.04654006f, 0.10884782f, -0.03505590f, 0.08411238f, 0.00839805f, -0.01200648f, 0.34905165f, 0.22971734f, 
    -0.01216042f, 0.04486961f, -0.04904972f, -0.07378007f, 0.09975629f, 0.12020443f, -0.10848325f, -0.05514359f, 
    0.08130392f, 0.25019094f, -0.00902297f, -0.20021804f, -0.07212916f, 0.01818296f, 0.14394115f, 0.08726794f, 
    -0.10620803f, -0.04348855f, -0.08534952f, -0.29294738f, 0.26462412f, 0.14091417f, -0.31495097f, -0.03024195f, 
    -0.11910413f, 0.01093134f, 0.13599139f, -0.05918298f, -0.05289249f, -0.10440536f, -0.23698315f, -0.01151339f, 
    0.09072407f, -0.06285283f, -0.26617792f, -0.10220223f, 0.35720828f, -0.09255381f, -0.30741572f, -0.22240873f, 
    -0.04053796f, 0.03511575f, -0.00807145f, -0.15678300f, -0.02299332f, 0.03275784f, 0.05129296f, 0.11049806f, 
    0.28667220f, -0.03986994f, -0.11410549f, 0.08832350f, 0.10560848f, 0.26233295f, -0.41309461f, -0.07344402f, 
    0.03565456f, -0.08835989f, 0.00642291f, 0.02560474f, 0.09092885f, 0.05005312f, 0.19127607f, 0.00515304f, 
    -0.06704623f, 0.18462364f, 0.05976386f, -0.10218127f, 0.03552609f, 0.16147390f, -0.01049522f, 0.03681660f, 
    0.31562611f, 0.14582458f, 0.14350376f, 0.07492726f, -0.10997237f, 0.12233385f, 0.13190687f, 0.33815080f, 
    0.02145148f, -0.03341146f, 0.10018986f, -0.15976693f, 0.07692609f, 0.29938239f, -0.26209906f, 0.10875658f, 
    -0.07845252f, -0.07201322f, -0.14050047f, -0.06744103f, 0.00358815f, -0.26019654f, -0.12530626f, 0.31523782f, 
    -0.03132619f, -0.09627809f, -0.12452520f, 0.07218849f, 0.06487772f, -0.02537020f, -0.12055508f, 0.00128940f, 
    0.03447784f, -0.02179284f, -0.01226184f, 0.04681101f, -0.05022362f, -0.07568710f, -0.09219706f, -0.01295558f, 
    -0.14374849f, -0.01846733f, 0.04514995f, -0.13852154f, -0.06759527f, -0.06345713f, 0.00945426f, 0.00869448f, 
    -0.05199484f, -0.07015312f, -0.12957595f, 0.04835507f, 0.06303976f, 0.06604759f, -0.10235526f, 0.05146315f, 
    -0.03799659f, -0.02390693f, 0.04053684f, -0.01637173f, -0.14106534f, 0.01170805f, 0.10319674f, -0.04452123f, 
    -0.06889913f, 0.05646667f, -0.07188866f, -0.07201037f, 0.00965133f, -0.09461789f, -0.14573175f, -0.10696842f, 
    -0.02294853f, 0.04318322f, -0.05042425f, 0.07636788f, -0.07850901f, -0.06091588f, -0.00093055f, -0.11046960f, 
    0.00084153f, -0.00571503f, 0.04329804f, -0.08773669f, -0.10019037f, 0.05356206f, -0.08961053f, 0.01440389f, 
    -0.10453281f, -0.28543764f, 0.46337387f, -0.08490382f, -0.43334001f, 0.19915037f, 0.25795847f, 0.14020510f, 
    -0.02370086f, -0.07541335f, -0.19142310f, 0.26332510f, 0.08671606f, 0.08267293f, -0.05159900f, -0.02870580f, 
    -0.17633651f, 0.12233881f, 0.04776931f, 0.19179681f, 0.11082323f, -0.00661824f, 0.55395925f, 0.09253961f, 
    -0.06992602f, -0.08152907f, -0.28020310f, -0.01874876f, 0.26780003f, 0.12473755f, -0.15179814f, 0.21086150f, 
    0.10470667f, -0.03047504f, -0.07513805f, -0.02872276f, -0.00843753f, 0.18901049f, -0.07387716f, -0.15968379f, 
    0.07105035f, -0.17310748f, -0.03981680f, 0.09359256f, -0.10422312f, 0.09863618f, 0.18511496f, 0.05633681f, 
    0.08143234f, -0.04919482f, -0.07941034f, -0.22740524f, 0.23233843f, 0.16206135f, 0.17911039f, -0.07487096f, 
    0.02792290f, 0.09950343f, -0.02041838f, 0.14659989f, 0.07561812f, 0.14384612f, -0.17013103f, -0.46935102f, 
    0.08269157f, -0.02819058f, 0.10986627f, -0.02943365f, -0.05312528f, -0.03319319f, -0.00441140f, -0.10343892f, 
    -0.01711820f, -0.10031089f, 0.06827039f, -0.10680560f, -0.11671609f, -0.10514720f, -0.06893912f, -0.09484142f, 
    0.06373403f, 0.05010324f, -0.09637450f, -0.06137195f, 0.03352968f, 0.02801015f, -0.10036368f, -0.11970086f, 
    -0.02660353f, -0.00578596f, -0.02807344f, -0.12673444f, -0.00869309f, -0.00238709f, -0.08775357f, -0.13306090f, 
    0.05501889f, -0.07366108f, 0.09864283f, -0.00171120f, -0.15698087f, 0.08035698f, -0.01552300f, -0.04913760f, 
    -0.00503597f, -0.13662098f, 0.04060805f, 0.03207351f, 0.12371805f, -0.02454381f, -0.15709402f, -0.01185135f, 
    0.06021044f, 0.08891243f, -0.05086698f, -0.01327796f, -0.06248401f, 0.03968541f, -0.04378407f, -0.05143997f, 
    -0.09767157f, 0.10397760f, -0.05381763f, 0.05445764f, -0.10795112f, -0.00349933f, -0.02930093f, -0.12136383f, 
    -0.00841354f, -0.29608929f, 0.42600554f, -0.11748378f, 0.08679053f, 0.08866888f, 0.00672794f, 0.03267813f, 
    -0.10454027f, 0.10908981f, 0.00460838f, -0.22355458f, -0.08208247f, -0.06928866f, -0.30861586f, -0.02188705f, 
    -0.05938002f, -0.31633019f, 0.03102125f, 0.14633328f, 0.08106633f, 0.21447256f, 0.18732807f, 0.06057679f, 
    0.10098464f, 0.07313696f, -0.26042467f, 0.35910839f, 0.09433900f, 0.09912702f, -0.22937147f, 0.28201282f, 
    -0.07536776f, -0.07139490f, -0.10590101f, -0.09676432f, 0.07314105f, 0.09359821f, 0.13033113f, -0.08008096f, 
    0.17929743f, -0.30874822f, 0.33789256f, 0.31914827f, -0.07654457f, -0.03826592f, 0.18632253f, 0.15530828f, 
    0.01233628f, -0.06099903f, -0.07967943f, 0.01228945f, -0.07541519f, 0.11375361f, -0.04666373f, 0.33597645f, 
    0.09798731f, -0.07604743f, 0.13373135f, 0.36726841f, -0.10632425f, -0.00513044f, -0.05657502f, -0.15733089f, 
    0.04968353f, 0.29110834f, -0.37534836f, -0.13467535f, 0.07055728f, 0.25125688f, -0.09320971f, 0.09431261f, 
    0.10856101f, -0.03402361f, 0.11466477f, -0.02528198f, 0.02349669f, -0.03498200f, -0.05515250f, -0.28649938f, 
    -0.21492034f, 0.23859718f, 0.10206393f, 0.33747056f, 0.00561887f, -0.21589360f, -0.50932050f, -0.07580945f, 
    0.17835552f, 0.07962882f, 0.10495792f, 0.12795736f, -0.03745750f, -0.03257352f, -0.03146333f, -0.17023374f, 
    -0.09506141f, 0.17818740f, 0.04511010f, -0.01787347f, 0.11319385f, 0.14617839f, 0.49160504f, 0.08999979f, 
    -0.12797745f, 0.17703898f, -0.22991595f, 0.14467117f, 0.05222560f, -0.01620544f, 0.02055421f, 0.08217783f, 
    -0.09546233f, -0.11405806f, -0.01226473f, 0.09824928f, 0.03003775f, -0.09415178f, -0.23131578f, -0.17555596f, 
    0.07552992f, 0.20182942f, -0.17313628f, 0.02024590f, -0.02174723f, -0.09646547f, 0.11998121f, 0.30195436f, 
    -0.06029283f, 0.06801703f, -0.02336206f, -0.05583953f, 0.17497557f, -0.18967737f, -0.19931902f, -0.15647309f, 
    0.03242319f, 0.07991153f, -0.32781097f, 0.05015456f, 0.05210028f, 0.04620946f, 0.14418016f, -0.05347854f, 
    0.31143969f, 0.09381189f, 0.10380071f, -0.16139972f, -0.06737810f, 0.05879332f, -0.15244421f, 0.01778616f, 
    0.24403360f, 0.00085294f, 0.19114180f, 0.11006688f, -0.17956774f, -0.06481945f, 0.06510341f, 0.11976615f, 
    0.03781848f, 0.12363370f, -0.03762107f, -0.02044648f, -0.06851773f, -0.09296480f, -0.20870070f, 0.30506667f, 
    0.02675527f, 0.17192788f, 0.15322353f, -0.04316185f, 0.01956059f, 0.09536470f, 0.19441018f, 0.09288183f, 
    0.01152261f, 0.04302661f, 0.01531809f, 0.28157762f, 0.01539199f, 0.15208606f, -0.05304104f, 0.09782518f, 
    0.06107983f, -0.08214764f, -0.04710735f, -0.09759060f, -0.02284248f, 0.18103881f, -0.08979674f, 0.27044347f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09147185f, 0.01728689f, 0.07179064f, -0.00744247f, 0.02503697f, 0.10936796f, 0.04321025f, -0.06356385f, 
    -0.02669720f, 0.04530771f, 0.10160238f, 0.07598375f, 0.06471343f, 0.15551488f, 0.02721254f, 0.10345140f, 
    0.03207518f, 0.17316453f, 0.02341553f, -0.10297147f, 0.10041429f, -0.04092783f, 0.02035924f, 0.00411941f, 
    0.00801066f, 0.17789696f, 0.10797481f, 0.06660444f, 0.13934049f, 0.10369430f, 0.14756498f, 0.00560393f, 
    0.03804064f, -0.11491343f, -0.03948726f, -0.00420303f, 0.03964571f, 0.09464896f, 0.05956278f, 0.08566204f, 
    -0.11328516f, 0.06174782f, 0.12216032f, -0.12756722f, -0.06970610f, 0.12169485f, -0.04083674f, 0.05938049f, 
    0.08962301f, -0.03239534f, 0.19808193f, -0.15144759f, 0.02737997f, 0.18950135f, 0.12561607f, -0.07226536f, 
    -0.02382342f, 0.17262398f, -0.07047291f, 0.13744880f, -0.15007991f, 0.15227377f, 0.07255289f, 0.05973301f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.15769702f, 0.08546609f, 0.25523660f, 0.30489776f, -0.08993603f, -0.18379462f, -0.41686487f, -0.02827413f, 
    0.00272792f, 0.07825006f, 0.06971768f, -0.11469559f, 0.06988522f, 0.19179627f, 0.22372717f, -0.23634079f, 
    -0.02594289f, -0.44096294f, 0.04836754f, -0.04483361f, -0.24082042f, -0.14819053f, -0.05610048f, -0.31688899f, 
    -0.45243984f, -0.13060327f, 0.12603126f, -0.11256048f, -0.14552395f, 0.10136750f, 0.27067426f, -0.19420463f, 
    -0.14468895f, 0.24253516f, 0.22870986f, 0.28942305f, -0.21272156f, -0.39541620f, -0.14127724f, 0.27962986f, 
    0.00769560f, 0.04337760f, -0.11663298f, 0.10359372f, -0.10313569f, -0.40950957f, -0.10048516f, 0.12511343f, 
    -0.05269577f, -0.44483709f, -0.23787093f, -0.19232094f, -0.11442491f, 0.12791282f, -0.08453414f, -0.09363517f, 
    0.30711043f, 0.17623349f, -0.07595219f, -0.32693273f, -0.08919700f, -0.08569288f, -0.22886810f, 0.23472650f, 
    0.06942465f, -0.10038490f, 0.10471456f, -0.03682756f, -0.32427126f, 0.11136916f, 0.14135680f, -0.09902660f, 
    -0.40412953f, 0.23759961f, -0.03777857f, -0.45679143f, -0.23540120f, 0.14789304f, 0.14177482f, -0.34861681f, 
    -0.05963140f, -0.10396273f, 0.23364161f, 0.06950850f, -0.03775610f, -0.12189393f, 0.00017341f, 0.20565644f, 
    0.18090111f, -0.02712698f, -0.05491400f, -0.09993092f, 0.24257168f, -0.00502358f, 0.20744070f, 0.08599107f, 
    0.11974371f, 0.18171376f, 0.02569277f, -0.41728047f, 0.09283099f, 0.21831264f, 0.07461197f, -0.43901965f, 
    0.00649494f, -0.10269372f, -0.09830700f, 0.07208587f, -0.01088772f, -0.02636936f, -0.10016916f, 0.08754192f, 
    -0.25585371f, 0.16312809f, -0.44433236f, -0.06192344f, -0.05201393f, 0.16527031f, -0.44081485f, -0.31779355f, 
    0.23995049f, 0.02650631f, -0.04709623f, 0.34703758f, -0.08323404f, -0.01915037f, -0.16316546f, -0.10886838f, 
    0.09047725f, -0.11309872f, -0.03836582f, -0.18680374f, -0.25214988f, -0.56802183f, 0.08343700f, -0.04285592f, 
    -0.34490457f, 0.01113286f, 0.10406716f, 0.05112173f, -0.18077567f, 0.10748316f, -0.10961799f, 0.03399681f, 
    -0.07194506f, 0.33546486f, -0.17391345f, 0.00511614f, -0.12058885f, 0.28154409f, 0.10379056f, -0.46528268f, 
    -0.28795812f, -0.53670967f, 0.06433121f, -0.05539230f, -0.03707442f, 0.00280285f, 0.14841484f, 0.14837940f, 
    0.01429974f, -0.44031247f, 0.09632706f, 0.14209510f, -0.32114536f, 0.18223435f, -0.13493419f, 0.26978293f, 
    -0.08040565f, -0.03014798f, 0.25058964f, -0.02069911f, 0.17522168f, 0.00487529f, -0.03606511f, -0.33528689f, 
    0.00414006f, -0.48642698f, -0.43838972f, 0.07130550f, 0.05624016f, 0.25133100f, 0.27671638f, 0.27666131f, 
    0.05828161f, 0.13333428f, 0.10109730f, -0.22084680f, 0.12745470f, -0.28892842f, 0.29951048f, -0.12855682f, 
    0.13122232f, -0.11163738f, 0.10339097f, 0.20907605f, -0.12986018f, 0.02467064f, -0.25696087f, 0.07821076f, 
    0.01457828f, -0.29063329f, -0.06976154f, -0.17700066f, 0.16700859f, -0.12546287f, 0.13350548f, 0.07230069f, 
    -0.12377658f, 0.02757437f, 0.07419128f, 0.01144770f, -0.27551755f, -0.19383964f, -0.01985327f, 0.09205966f, 
    0.24673375f, -0.02203256f, -0.24313824f, 0.12449080f, -0.00670130f, 0.06054482f, -0.53934383f, -0.40739104f, 
    0.14838520f, 0.25456315f, -0.16963257f, -0.12937497f, -0.43872991f, -0.02892421f, -0.17073053f, 0.25170666f, 
    0.09571736f, 0.03806563f, -0.21259977f, 0.09562257f, 0.01585915f, -0.09587900f, -0.06192539f, -0.03159235f, 
    0.11898068f, -0.41193509f, 0.24531424f, 0.24939643f, -0.04914495f, -0.27569386f, -0.21363971f, 0.23567937f, 
    -0.27259174f, -0.24640296f, -0.12795731f, -0.28957558f, -0.19671959f, -0.42919230f, 0.06546566f, 0.18989410f, 
    0.10836402f, -0.11528756f, 0.31769067f, 0.17631035f, 0.02431547f, 0.28018311f, -0.23285180f, -0.11769816f, 
    0.10946402f, -0.23211847f, -0.05174160f, 0.01359922f, -0.33555257f, 0.24405524f, 0.02336408f, -0.04222574f, 
    0.07164261f, -0.07130751f, -0.09393548f, 0.07554867f, 0.05982927f, -0.16107230f, -0.05428048f, 0.09476556f, 
    -0.02423925f, 0.22740065f, -0.67738289f, 0.07432796f, -0.15601403f, 0.04595317f, 0.04183282f, 0.01068563f, 
    -0.23853388f, -0.36285350f, 0.18934005f, 0.01004136f, 0.11990172f, -0.14596757f, -0.07365579f, 0.29882208f, 
    -0.04117460f, -0.04632424f, 0.03074310f, -0.05165998f, -0.21753231f, -0.61720389f, 0.03989303f, 0.03190663f, 
    0.25184822f, 0.16136695f, -0.16296804f, 0.17862619f, 0.06245616f, -0.07735987f, -0.24183542f, 0.08548054f, 
    -0.21377259f, 0.02432644f, -0.09957915f, 0.00848705f, -0.10360210f, -0.01191676f, -0.01869222f, 0.01552023f, 
    -0.09366611f, 0.02343516f, 0.07205747f, 0.22596061f, -0.08838511f, 0.07370390f, 0.18728523f, 0.04409683f, 
    0.24562654f, -0.02037738f, -0.03561336f, 0.20719816f, 0.09167824f, -0.28673580f, -0.04853366f, -0.14991373f, 
    0.09891310f, -0.19421558f, 0.02114941f, 0.08920742f, -0.08007422f, -0.01899381f, 0.04148922f, -0.10954163f, 
    -0.34505329f, 0.16634031f, -0.02074618f, -0.03472141f, -0.25222412f, 0.07024938f, -0.09625600f, -0.15225972f, 
    0.11472339f, 0.15043339f, 0.06765420f, -0.00056112f, 0.22277874f, 0.20992425f, -0.15492567f, -0.34161451f, 
    -0.12368733f, -0.27315858f, 0.14874971f, 0.07102811f, 0.21929780f, -0.06622487f, 0.10897367f, 0.13081804f, 
    -0.09974885f, -0.63256329f, 0.12971531f, -0.11277688f, 0.06008017f, 0.13460501f, -0.38261962f, 0.04862832f, 
    -0.11585239f, -0.09296410f, -0.12036503f, 0.27347666f, 0.04230885f, 0.22369047f, -0.16573687f, -0.38065755f, 
    0.09035497f, -0.05209260f, 0.17996882f, -0.62265182f, -0.02782755f, -0.04165378f, 0.20598416f, -0.10681161f, 
    0.21220568f, -0.37643763f, 0.11265238f, 0.11077395f, -0.23045461f, -0.26760197f, 0.16469353f, 0.20632569f, 
    0.01900633f, 0.08158086f, 0.02318665f, 0.01256433f, 0.00392824f, -0.22488120f, 0.06833974f, -0.39097196f, 
    -0.09723679f, -0.04552617f, 0.12714422f, 0.06179113f, -0.11077355f, -0.00080442f, 0.13849992f, 0.15192826f, 
    -0.32483867f, -0.00704918f, -0.43924239f, -0.38632149f, 0.07582782f, -0.68679065f, -0.00421208f, -0.01378637f, 
    0.05426895f, -0.43558493f, 0.11406723f, 0.06725586f, -0.35126838f, 0.39475596f, 0.04333140f, -0.12504320f, 
    -0.37316757f, -0.38558906f, 0.21427757f, -0.03864249f, 0.10233332f, -0.42319784f, 0.15898053f, 0.19361629f, 
    -0.18281394f, 0.24541168f, 0.09999636f, -0.05217900f, 0.01606238f, 0.20246917f, -0.31265473f, 0.14230496f, 
    -0.41557533f, -0.03480493f, 0.16892663f, 0.14561671f, 0.10923230f, -0.19088255f, 0.23338898f, 0.03172325f, 
    -0.03628467f, 0.07009762f, -0.11405134f, 0.08579100f, 0.15020828f, -0.08828491f, -0.37017888f, -0.25754309f, 
    0.01291787f, 0.00857182f, -0.42151684f, 0.01321874f, -0.20830533f, -0.03156596f, 0.11843059f, 0.17565936f, 
    0.09300014f, 0.07857389f, 0.23967895f, -0.04478284f, -0.13644470f, 0.06269205f, -0.00979340f, -0.26884344f, 
    0.02974384f, 0.19949688f, 0.00535114f, 0.19786219f, -0.05502290f, -0.15090722f, 0.14889888f, -0.14056163f, 
    -0.10957161f, 0.12036545f, 0.01242902f, -0.01837520f, 0.12155829f, -0.07593568f, 0.10802770f, -0.39983970f, 
    0.14226903f, 0.33193862f, -0.05497246f, 0.20047656f, 0.03949310f, -0.19999284f, 0.23270598f, -0.15803500f, 
    -0.22502750f, -0.29212236f, 0.04786098f, 0.16314812f, -0.04476625f, -0.05094937f, -0.20653291f, 0.10238563f, 
    -0.13860931f, -0.13742046f, -0.02492288f, -0.36403668f, -0.23015080f, 0.16436706f, 0.07201193f, 0.08872065f, 
    -0.23428762f, 0.17121932f, -0.12845615f, -0.21137647f, 0.06026112f, -0.05938988f, -0.27322283f, 0.37547064f, 
    0.00038267f, -0.18361093f, -0.12746441f, 0.06245811f, 0.01939508f, -0.04406958f, -0.05160082f, -0.20753039f, 
    -0.28629553f, 0.20728569f, -0.06315438f, -0.07418922f, 0.27389699f, 0.10521005f, 0.02498198f, 0.24181084f, 
    0.23074576f, -0.21707766f, 0.33473083f, -0.43225339f, -0.33400422f, 0.14952204f, -0.10724323f, -0.47533339f, 
    0.04527935f, -0.44776788f, -0.00331975f, -0.00751391f, 0.33274344f, -0.10390773f, 0.11366992f, 0.14146785f, 
    0.18655977f, -0.20463565f, -0.16519184f, 0.32587942f, -0.02488617f, -0.21354282f, 0.34885055f, -0.53317165f, 
    -0.40289390f, -0.17240782f, 0.01725072f, -0.10424300f, -0.12420166f, 0.02983711f, 0.18427314f, -0.30125621f, 
    -0.34527919f, 0.05521629f, -0.59715694f, 0.00291438f, -0.02369141f, 0.07544898f, 0.02172431f, -0.11132259f, 
    -0.08928640f, -0.29621240f, 0.00350694f, 0.03194817f, 0.02211507f, 0.30058703f, 0.06594841f, -0.24029177f, 
    -0.05612022f, 0.12837002f, -0.33658952f, 0.05613537f, 0.33206239f, -0.40994033f, 0.04538602f, -0.40948734f, 
    -0.07519801f, 0.23697983f, -0.13946001f, 0.09334286f, -0.16918762f, 0.13065235f, -0.01870918f, 0.04781166f, 
    -0.44100565f, -0.01922091f, -0.22537495f, 0.07477149f, 0.17498700f, 0.02132212f, -0.05071013f, -0.02490104f, 
    0.03386176f, 0.05037312f, 0.29434729f, 0.00357994f, -0.45932141f, 0.05949714f, -0.01703523f, -0.30024749f, 
    -0.06307220f, 0.17910001f, -0.14136593f, 0.21078946f, 0.06393704f, 0.13166453f, 0.15986037f, 0.02490874f, 
    0.04048947f, 0.20068224f, -0.04348647f, -0.11488735f, -0.04127855f, 0.16770485f, 0.25096884f, -0.07728856f, 
    -0.12277311f, 0.00056083f, -0.38772675f, 0.08421915f, -0.12915298f, 0.11459002f, -0.36388072f, 0.03541195f, 
    0.00289500f, -0.08206610f, 0.06290332f, 0.38231629f, 0.34647211f, -0.07724117f, 0.11164427f, 0.01028771f, 
    0.06498344f, 0.03920987f, -0.19142614f, -0.02317649f, 0.00767774f, -0.02655534f, -0.12372579f, -0.02513448f, 
    0.06127711f, -0.00244663f, 0.34118795f, -0.08198407f, 0.24052376f, 0.00243348f, -0.04789450f, -0.03037499f, 
    0.23402269f, -0.15989897f, -0.15148036f, 0.07302647f, -0.22350667f, 0.16288345f, 0.11586340f, -0.55333406f, 
    -0.11484898f, -0.00304786f, -0.40496412f, 0.06183451f, -0.25098675f, -0.21080248f, -0.00721707f, -0.09347913f, 
    -0.01608163f, 0.17362919f, 0.11208156f, -0.20582458f, 0.01730810f, 0.37444440f, 0.28408760f, 0.04984725f, 
    -0.09747348f, 0.03020535f, 0.09188686f, -0.16343981f, -0.07044112f, -0.44348586f, 0.04737754f, -0.15455952f, 
    -0.03427174f, -0.10384777f, -0.22939512f, -0.45816743f, 0.33330292f, -0.06651748f, 0.20327604f, -0.09810580f, 
    0.11078689f, -0.18210565f, -0.09866490f, -0.24651180f, 0.04245238f, -0.54785568f, 0.01574877f, 0.25750288f, 
    -0.00047599f, 0.14818025f, 0.18062715f, -0.08245497f, -0.20116311f, -0.35717946f, 0.05261742f, -0.28536710f, 
    0.19370131f, 0.05489409f, -0.20573989f, -0.08160792f, 0.05436987f, -0.12144519f, -0.11535979f, 0.15944251f, 
    0.19392972f, -0.28845823f, -0.19992509f, 0.01499537f, 0.16159958f, 0.05277890f, 0.05525592f, 0.31319079f, 
    -0.06912452f, -0.12062834f, -0.13527003f, -0.10969666f, -0.24628906f, -0.47530025f, 0.07227474f, -0.08185253f, 
    0.19199052f, -0.36947560f, 0.10690461f, -0.51174814f, -0.09333266f, -0.38233560f, 0.03751534f, -0.34195602f, 
    0.20633911f, 0.13397832f, -0.05360045f, -0.29503274f, -0.01076507f, 0.04205403f, 0.04888542f, 0.04587507f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.01174242f, 0.02347328f, -0.12097360f, 0.02044169f, 0.07017205f, -0.04423427f, 0.08776124f, -0.21430871f, 
    -0.14250989f, 0.08157898f, 0.14361542f, 0.03020419f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
