#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.55807859f, 0.43737650f, 0.88440102f, 0.93937391f, -0.29378799f, -0.84816349f, 0.06706837f, 0.18018845f, 
    0.37600634f, 0.19817097f, 0.61188614f, -0.96834660f, 0.18318170f, -0.50297290f, -0.75395352f, 0.36017027f, 
    0.24752352f, 0.60840869f, 0.92308503f, 1.16532481f, 0.31426758f, -0.88930583f, -1.00529790f, 0.01176505f, 
    0.07462707f, 0.14349027f, -0.07157440f, 0.79843754f, 1.10961568f, -0.00654840f, 0.77618623f, -0.65023136f, 
    -0.12961408f, 0.05621908f, -0.40790096f, 0.06407648f, -0.58458114f, -0.75396419f, 0.44919220f, -0.12695889f, 
    0.77604502f, -0.67451972f, 0.35452604f, -0.23459707f, -0.43292254f, 0.79351050f, -0.72674400f, -0.93979824f, 
    -0.62726426f, -0.08537769f, 0.16368338f, -0.38089922f, 0.02537981f, 0.24967617f, -0.57138062f, -0.91870165f, 
    0.84832138f, -0.03398133f, -0.60316861f, 0.09812434f, -0.22931299f, 0.00396569f, -0.25201213f, -0.39052954f, 
    1.07320559f, 0.83463252f, 0.53821141f, 0.33875254f, 0.22992222f, -0.49994498f, -0.12521859f, -0.00731447f, 
    0.64236492f, -0.96787763f, 0.63114899f, -0.52837414f, -0.69909614f, -0.60423565f, -0.10044441f, -0.25028658f, 
    -0.08305635f, -0.20643798f, -0.67272627f, -0.51163352f, -0.77117568f, -1.03408909f, -0.59161663f, 0.35465685f, 
    0.05548670f, -0.44855011f, -0.90519118f, -0.18852510f, -0.47306776f, -0.47796318f, 0.92175758f, 0.43035629f, 
    -0.19273506f, 0.43005911f, 0.24045491f, 0.67345953f, -0.28383309f, 0.97767270f, 0.56231517f, -0.14126498f, 
    0.47164521f, 0.51118213f, 0.24219680f, 0.21160334f, 0.86076915f, 0.55395502f, -0.45204291f, 0.50844455f, 
    0.82215977f, 0.37031087f, 0.14443055f, -0.19361891f, 0.00143963f, -0.56441402f, -0.93174553f, -1.05969942f, 
    -0.72955441f, 0.32956791f, 0.52005833f, 0.30561340f, -0.21368754f, 0.05075541f, -0.64766771f, -1.06706297f, 
    -0.70193744f, 0.90405792f, 0.71296126f, 0.54055393f, -0.16958490f, -0.31151572f, -0.04811158f, 0.40936360f, 
    1.17918336f, -0.55788529f, -0.39750046f, 0.74702525f, -0.24961571f, 0.32746330f, 0.17845780f, -0.15784465f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.10674389f, 0.03525328f, 0.43591812f, 0.02135409f, -0.12574618f, 0.28055564f, -0.00987963f, 0.21250924f, 
    -0.07585582f, 0.01787362f, 0.01821375f, 0.22497286f, 0.32068825f, -0.15517218f, 0.30479744f, 0.01304990f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00457012f, 0.00929460f, -0.05434540f, -0.00746134f, -0.06076243f, -0.03050997f, 0.04465376f, 0.03840464f, 
    -0.04249253f, 0.00939463f, -0.02096917f, 0.02843961f, 0.00821931f, -0.00185598f, 0.01706063f, -0.00232411f, 
    0.02081311f, 0.04529732f, 0.00686135f, -0.04179679f, 0.03569247f, 0.03212092f, -0.01027416f, -0.05672540f, 
    0.01210550f, 0.04412319f, 0.03737356f, -0.00216076f, -0.05588030f, -0.02729391f, -0.03130371f, -0.03932692f, 
    0.00844524f, 0.03997803f, 0.02081697f, 0.01110469f, 0.05456401f, 0.03517875f, 0.01193089f, -0.05738287f, 
    -0.04831835f, -0.03864975f, 0.01225769f, -0.00344968f, 0.00230856f, -0.05139570f, -0.05601000f, -0.04813934f, 
    -0.01317116f, -0.03002401f, 0.03256882f, 0.00871240f, 0.03441137f, -0.02297681f, 0.03123812f, -0.04465904f, 
    -0.03022531f, -0.04024848f, -0.02794673f, 0.02387674f, 0.04582029f, 0.01162852f, -0.05467454f, 0.00531042f, 
    0.03542583f, 0.01770183f, 0.03799560f, 0.01056458f, 0.02880584f, 0.03376267f, 0.00054323f, -0.03283269f, 
    0.01647951f, -0.02322479f, -0.04771569f, -0.01974660f, 0.03494016f, 0.04553674f, -0.01382085f, 0.02211587f, 
    -0.01537510f, 0.03919976f, -0.05495116f, 0.02545624f, -0.05394404f, 0.04036015f, -0.04259149f, 0.01238450f, 
    0.01050082f, -0.03192732f, 0.00329366f, 0.04549294f, -0.05897761f, -0.05841364f, 0.03884319f, -0.03216343f, 
    -0.03249656f, 0.01936026f, -0.02213748f, -0.03507546f, -0.00260678f, -0.06461231f, 0.02652482f, -0.06281643f, 
    -0.02594821f, 0.00539929f, -0.01742242f, 0.03302005f, 0.02218631f, -0.02230103f, -0.04555566f, -0.01145464f, 
    0.01748960f, -0.04830103f, -0.00619667f, -0.01995939f, -0.05443136f, -0.03574411f, -0.05138268f, -0.05682297f, 
    -0.05167240f, -0.02999132f, 0.00161867f, 0.02658268f, 0.04592028f, 0.01332833f, 0.04657867f, -0.03378833f, 
    0.04248225f, -0.01701994f, -0.03874104f, 0.03243754f, -0.05717114f, 0.01548827f, -0.05199294f, 0.01506293f, 
    -0.01078771f, -0.03348506f, -0.05534322f, -0.00801749f, -0.04597712f, 0.02371141f, -0.02486923f, -0.03358939f, 
    -0.04545445f, 0.00541882f, 0.00775205f, 0.01630986f, 0.00153365f, -0.06130171f, 0.01310451f, -0.01183634f, 
    -0.01956443f, -0.00256966f, 0.04499100f, -0.02114361f, 0.04059120f, -0.01086907f, 0.02717158f, 0.00210931f, 
    0.03999612f, -0.01084140f, -0.05292942f, 0.00693132f, 0.03944886f, 0.01970292f, 0.02486305f, -0.05013173f, 
    -0.00236971f, 0.00556567f, 0.03581205f, -0.00614081f, -0.05498229f, -0.03782136f, -0.00933938f, -0.00638189f, 
    0.04413003f, -0.03934936f, -0.03452672f, -0.02427334f, -0.03554245f, -0.01171164f, -0.00890131f, 0.04146199f, 
    -0.01316629f, 0.01149213f, -0.00581701f, 0.01948750f, 0.02296977f, 0.00127566f, 0.00233716f, 0.00400569f, 
    -0.02083510f, 0.03947185f, -0.02540275f, -0.01856604f, 0.00212655f, -0.05350422f, 0.01218121f, -0.00077079f, 
    -0.01959471f, 0.02806532f, 0.00860139f, 0.00986763f, -0.04910112f, -0.05162393f, 0.04176519f, -0.03770412f, 
    -0.01284838f, -0.03526925f, 0.02908468f, -0.01327440f, -0.02552934f, -0.03983435f, 0.00527506f, -0.05691906f, 
    0.02212057f, -0.03494909f, -0.02119442f, -0.03841164f, 0.00275882f, -0.03227970f, -0.01741040f, 0.03823875f, 
    0.01745354f, -0.05790631f, 0.02242008f, -0.06528403f, 0.04366420f, -0.00104008f, 0.00413660f, 0.04780499f, 
    -0.01830749f, 0.02099238f, 0.02797298f, 0.01403612f, 0.01660828f, 0.00024827f, 0.04312498f, 0.03390335f, 
    0.04500165f, -0.01036849f, 0.01101562f, -0.05559790f, -0.00154533f, 0.04019883f, -0.04471349f, -0.00263749f, 
    -0.05659776f, -0.04064884f, 0.01042470f, 0.04351449f, 0.00302426f, -0.06064086f, 0.02782320f, -0.05472248f, 
    0.02803737f, -0.01367551f, 0.00603038f, -0.05221173f, -0.05217133f, -0.00727016f, -0.01379626f, -0.00857117f, 
    0.04426000f, 0.02315065f, 0.06237697f, 0.02691913f, 0.03282040f, 0.01663214f, -0.01672877f, 0.03326573f, 
    0.05531218f, 0.01658789f, -0.00770088f, 0.00763997f, -0.01106606f, 0.03875704f, -0.04862184f, -0.00986147f, 
    0.02686309f, -0.03385890f, 0.01305387f, 0.00573278f, -0.04990819f, 0.04868108f, 0.02146440f, -0.04357514f, 
    0.01784797f, 0.04136392f, 0.01118354f, -0.05157803f, 0.00167253f, 0.01683172f, 0.02873821f, -0.05481737f, 
    -0.04102027f, -0.04693706f, -0.02832256f, 0.04036206f, -0.04613138f, -0.05284930f, -0.01865157f, 0.00033929f, 
    -0.02577692f, 0.00013343f, 0.00958603f, -0.02315411f, 0.04021656f, 0.01061972f, -0.00257238f, -0.02421737f, 
    -0.04552970f, -0.02194416f, -0.03006085f, -0.00786856f, -0.05418449f, -0.03974784f, -0.02078034f, -0.01831271f, 
    -0.17353493f, 0.12317027f, -0.18575771f, -0.09269609f, 0.04169121f, 0.12535025f, 0.06917898f, -0.10295616f, 
    0.21796033f, 0.03978054f, -0.02110253f, -0.01804304f, -0.02765596f, 0.12647434f, 0.11005155f, -0.03307825f, 
    0.17616296f, -0.06404123f, -0.00691679f, -0.02434778f, 0.22430947f, -0.05679952f, -0.12381697f, 0.07265100f, 
    -0.17917171f, -0.00923756f, 0.18356429f, -0.05803730f, 0.05789860f, -0.10550482f, 0.06614624f, -0.04300769f, 
    0.09223189f, 0.04220507f, 0.05283412f, 0.04914642f, 0.07557714f, 0.03316452f, 0.04015922f, 0.20889375f, 
    -0.02059654f, -0.25463057f, -0.08994644f, 0.19032499f, 0.05780911f, -0.06610723f, 0.01582810f, -0.03552099f, 
    -0.10725749f, -0.00624360f, 0.15935862f, 0.08387067f, 0.07175877f, -0.03135148f, 0.24028175f, -0.00995895f, 
    0.14111663f, 0.06874280f, 0.06016292f, 0.11571402f, 0.04530782f, -0.05334871f, -0.15237810f, -0.02044119f, 
    -0.28523952f, 0.19403198f, -0.05955819f, -0.05172366f, 0.02506133f, 0.01674877f, 0.09692807f, 0.09960339f, 
    0.08845134f, -0.07919782f, 0.03052637f, 0.02937263f, -0.09220691f, 0.05121128f, 0.09390637f, 0.03320164f, 
    -0.40448987f, 0.40015811f, 0.17746678f, -0.13863072f, 0.00919199f, -0.03446367f, 0.04505221f, -0.01426106f, 
    0.10143737f, -0.02493944f, -0.06826784f, 0.05810217f, 0.07317660f, 0.10228429f, -0.03511274f, 0.03175031f, 
    0.05732126f, -0.03646953f, 0.06581504f, 0.07931035f, 0.05730825f, 0.61211491f, -0.21341629f, 0.17591254f, 
    0.02533184f, 0.17381242f, -0.13712378f, 0.06587533f, 0.05416244f, -0.12269694f, 0.08286739f, 0.19239253f, 
    0.01852104f, -0.04701704f, 0.11670485f, 0.11744500f, 0.10467956f, -0.05574198f, 0.12322611f, 0.02934651f, 
    0.06766865f, -0.06583979f, 0.14501651f, 0.02854844f, 0.58093411f, 0.09046883f, 0.03805308f, -0.18828773f, 
    0.03995455f, -0.09202937f, 0.05453454f, 0.07498030f, -0.00461100f, 0.07631595f, -0.04443474f, -0.02562455f, 
    0.03827608f, -0.04622293f, 0.18350132f, 0.04349478f, -0.22319241f, 0.02855067f, -0.17965057f, -0.14993800f, 
    -0.20241648f, 0.08720354f, 0.05495393f, 0.00415909f, 0.15304591f, 0.09676772f, 0.11971837f, -0.01352386f, 
    -0.03086069f, -0.02374681f, 0.10901315f, 0.05478334f, 0.18902887f, -0.01228969f, 0.08662898f, 0.08752625f, 
    -0.25230163f, 0.14061186f, 0.03585659f, 0.43683955f, 0.17020512f, -0.00600899f, -0.18625325f, -0.00497306f, 
    -0.01009267f, 0.03343994f, 0.03509493f, 0.09796155f, -0.16168250f, 0.06695463f, -0.01206364f, 0.04543465f, 
    0.09193434f, 0.19757681f, -0.12729350f, 0.02051482f, 0.13543722f, 0.16828012f, -0.11134296f, 0.12766862f, 
    0.12525088f, 0.06170814f, -0.07443581f, 0.00750376f, 0.08908956f, 0.00334445f, 0.04629947f, 0.05990768f, 
    0.06559120f, -0.09274224f, 0.05080689f, -0.06018995f, -0.05874929f, 0.00676817f, 0.13400918f, 0.16133405f, 
    -0.23814657f, 0.27772740f, 0.16228296f, 0.05635705f, 0.03302500f, 0.08209901f, -0.14231755f, 0.07420018f, 
    0.01978244f, -0.01531736f, -0.08370463f, 0.14481068f, -0.05741001f, 0.13651076f, -0.05871652f, -0.08075887f, 
    0.11382949f, -0.05221386f, 0.01049583f, -0.08410063f, -0.09924880f, -0.21586931f, -0.16954538f, -0.10213576f, 
    0.07763210f, 0.20744444f, 0.05403377f, -0.08987117f, 0.03666342f, 0.12516607f, 0.02060442f, -0.07547269f, 
    0.00477592f, 0.11792921f, -0.00489888f, -0.01115019f, -0.02363061f, -0.07769296f, -0.17235436f, 0.03663157f, 
    -0.19533093f, -0.05921775f, -0.18351725f, 0.03139644f, -0.24577560f, 0.15233646f, 0.16630727f, 0.12247382f, 
    -0.19850774f, 0.08608849f, 0.06021924f, -0.06853221f, 0.16278271f, 0.02208792f, 0.08721545f, 0.03693438f, 
    0.05471697f, 0.00803092f, -0.02454406f, -0.02978960f, -0.39403003f, 0.10490976f, 0.05806949f, -0.14498188f, 
    0.09901070f, 0.16396695f, 0.03509139f, 0.01735814f, -0.00058746f, -0.11072766f, -0.08466952f, 0.10124421f, 
    -0.08343119f, -0.06170222f, -0.00876106f, -0.08000032f, 0.08388973f, 0.01888161f, 0.05823035f, -0.03004136f, 
    -0.26800951f, -0.03922530f, 0.13096991f, 0.14832866f, 0.18485253f, 0.04016186f, -0.08163390f, 0.19328322f, 
    0.04325877f, -0.01129501f, -0.06896683f, -0.05366755f, 0.17609164f, 0.07988427f, 0.03459072f, -0.07891379f, 
    -0.10917387f, 0.11258782f, 0.04525978f, 0.03013808f, -0.32020897f, -0.19868553f, -0.04439038f, 0.12036449f, 
    -0.09514013f, 0.02633012f, 0.03259557f, 0.00293252f, -0.03702028f, -0.01079646f, 0.04818253f, 0.14382114f, 
    -0.09785682f, -0.08855212f, 0.04362705f, 0.00945364f, 0.13419253f, 0.01101477f, 0.07395461f, 0.14489204f, 
    -0.47016102f, 0.52144736f, -0.24209119f, -0.30713314f, 0.01485416f, -0.01939473f, -0.05753702f, -0.11711767f, 
    -0.04046777f, 0.12192331f, -0.11951602f, 0.00147283f, 0.14106330f, 0.00227903f, 0.02221084f, -0.03936918f, 
    0.00053126f, 0.06710041f, -0.02899481f, 0.02292881f, -0.38927552f, 0.02011365f, 0.09620567f, -0.16689025f, 
    0.05760082f, 0.06904475f, -0.12882265f, 0.14410031f, 0.02918174f, -0.07341303f, -0.11210251f, 0.00659516f, 
    0.05827103f, -0.00897407f, 0.03368737f, -0.11255654f, 0.09427731f, 0.03897066f, 0.07691117f, -0.04533684f, 
    -0.13980947f, -0.21699502f, 0.23283079f, -0.02911801f, -0.22549699f, -0.09100883f, -0.15241359f, 0.09788735f, 
    -0.12678382f, 0.00487022f, -0.05169050f, 0.00756068f, -0.01336585f, 0.04293603f, -0.12145174f, -0.10300304f, 
    0.04329882f, 0.08499783f, -0.08279940f, 0.01510139f, -0.38707870f, -0.09553441f, 0.33757961f, -0.25699252f, 
    0.00242265f, 0.06999918f, -0.09701214f, 0.09976838f, -0.05688711f, 0.05326369f, -0.08437451f, -0.04490665f, 
    0.01995137f, -0.05345297f, 0.02692959f, 0.06994146f, -0.01129372f, -0.03649403f, -0.09844982f, 0.10752814f, 
    0.24903125f, 0.14246303f, 0.02543806f, 0.08753082f, 0.01078439f, -0.11727788f, 0.15850413f, 0.04563180f, 
    -0.00762028f, 0.15324356f, 0.14295462f, 0.12463805f, -0.12091545f, 0.08583733f, 0.01990865f, 0.08885491f, 
    -0.06233323f, -0.03830534f, 0.16734080f, -0.01315915f, 0.15442634f, 0.04143806f, -0.01348003f, 0.22677480f, 
    0.05155798f, 0.05118998f, 0.21010607f, -0.01013157f, 0.05394645f, 0.10742429f, -0.13469559f, 0.00794635f, 
    0.04113553f, 0.04248889f, 0.11419648f, 0.06365281f, -0.14329810f, 0.02477588f, 0.03636635f, -0.06700896f, 
    0.64775991f, -0.01232348f, -0.22670387f, 0.04732838f, 0.18814318f, -0.00428483f, 0.10682992f, 0.06407374f, 
    0.05872895f, 0.04962989f, 0.02375544f, 0.00016914f, 0.03214020f, -0.16631018f, -0.10487457f, 0.14897747f, 
    0.08315469f, -0.06828795f, -0.04499801f, 0.05303887f, 0.02124477f, -0.11214740f, -0.08001214f, -0.22143419f, 
    -0.03413904f, 0.00438189f, 0.02598452f, -0.00138105f, -0.06373576f, 0.00794063f, -0.00021148f, 0.05564829f, 
    0.06299219f, 0.04679142f, 0.08269671f, -0.03607566f, 0.04060511f, -0.06751317f, -0.16461137f, -0.03997749f, 
    0.13432346f, -0.12548299f, 0.09788439f, -0.05336767f, -0.40197992f, -0.14241692f, -0.03147746f, -0.11367401f, 
    0.07242975f, -0.04770039f, -0.06947658f, 0.00228186f, -0.04909508f, 0.00878323f, 0.01509360f, 0.00705143f, 
    -0.00898734f, -0.08851797f, 0.02618290f, 0.07127871f, 0.25579467f, 0.02741069f, 0.24379948f, 0.12283388f, 
    -0.04918439f, -0.08612388f, 0.12441608f, 0.07822911f, -0.11450715f, 0.01546381f, 0.10754563f, -0.01841821f, 
    0.08455085f, 0.02909914f, -0.08651644f, -0.00255201f, -0.05544151f, -0.14395088f, 0.01167016f, 0.04287816f, 
    0.56374532f, -0.22748797f, 0.09564380f, 0.06622318f, 0.12253869f, 0.02380978f, 0.10865939f, -0.02567354f, 
    0.06003793f, 0.17951348f, 0.02874332f, -0.01550114f, -0.07097709f, -0.16827965f, 0.02918161f, -0.05377830f, 
    0.06049339f, 0.04272570f, -0.02256725f, 0.00879251f, -0.03679639f, 0.11678242f, 0.06490598f, -0.33745787f, 
    0.00847980f, 0.08526125f, 0.04147274f, 0.02130057f, 0.02553130f, 0.08249462f, -0.02846149f, -0.02227208f, 
    -0.12235983f, 0.20303187f, -0.00253337f, -0.00504267f, -0.00068962f, -0.07283399f, -0.08061083f, 0.15276878f, 
    0.10975271f, 0.08256965f, 0.12721919f, -0.02995416f, 0.02505907f, -0.00956210f, 0.02525797f, 0.09645411f, 
    -0.02277784f, -0.10951483f, 0.01611294f, 0.05479950f, 0.03040419f, 0.01781719f, 0.03079107f, 0.04836966f, 
    0.13743287f, 0.02359035f, -0.05731458f, 0.00680437f, 0.49659824f, -0.18114164f, -0.01606173f, 0.23049012f, 
    0.13215105f, 0.02900343f, 0.29853556f, -0.15459418f, 0.12140634f, 0.06554949f, -0.04232545f, -0.04563706f, 
    0.07642550f, -0.04755018f, 0.00143271f, -0.05083314f, 0.04620622f, 0.04859364f, -0.04890709f, -0.12596829f, 
    0.01701831f, 0.29509789f, -0.02254215f, 0.25928491f, 0.14334010f, 0.14757323f, 0.03337208f, -0.02009441f, 
    0.13286982f, 0.08689648f, 0.12897405f, 0.01227424f, -0.02825617f, 0.10838245f, -0.03548958f, 0.05470248f, 
    -0.06232483f, 0.00896206f, 0.05918441f, -0.02819442f, -0.15503752f, -0.27384841f, 0.20855634f, -0.16940093f, 
    0.01039498f, -0.09715505f, -0.01685688f, -0.02682045f, -0.09866345f, 0.05083053f, 0.12540433f, 0.06457089f, 
    -0.02972391f, -0.02430550f, 0.01717897f, 0.11101796f, 0.00042085f, 0.04202250f, -0.05210311f, 0.04334413f, 
    -0.05623192f, -0.02991799f, -0.00667318f, 0.02206480f, -0.03608489f, -0.00445849f, 0.02519638f, 0.01940730f, 
    -0.06029294f, -0.02769060f, -0.06455828f, 0.00067589f, -0.03078885f, 0.00497835f, 0.01484483f, -0.05259899f, 
    -0.03487465f, 0.01244352f, -0.00764927f, 0.03806557f, -0.00446926f, -0.02667818f, 0.04138839f, 0.02224166f, 
    0.03240189f, 0.03457607f, 0.04885871f, -0.05363674f, 0.02650128f, 0.04097034f, 0.04146209f, -0.00587155f, 
    0.02011508f, 0.01278665f, 0.02271890f, -0.03811963f, 0.05050603f, -0.05833415f, -0.01944802f, 0.03809499f, 
    0.01046438f, -0.04114025f, -0.05829198f, -0.00235250f, -0.00535326f, 0.02584666f, -0.05266183f, -0.04415346f, 
    0.02109709f, -0.06070192f, -0.03900795f, -0.00102344f, 0.02592519f, -0.00682687f, -0.05021754f, 0.00154094f, 
    -0.01426104f, -0.03533087f, 0.00738376f, 0.00783839f, -0.00453491f, 0.04683263f, 0.01364005f, 0.05069152f, 
    -0.00610004f, 0.01481783f, 0.03338400f, 0.01084948f, 0.03390429f, -0.02026819f, 0.00536045f, -0.06090062f, 
    -0.02274671f, 0.05047701f, -0.04490664f, -0.03722067f, -0.01758170f, -0.02723764f, -0.00220617f, 0.03486255f, 
    -0.01149740f, 0.04143306f, 0.04208780f, -0.04331307f, 0.01572703f, -0.04180388f, -0.00635105f, 0.03417092f, 
    -0.00073735f, 0.03727273f, 0.02387320f, 0.04830436f, 0.03426140f, 0.04088796f, 0.02026411f, -0.04232504f, 
    -0.02953841f, 0.04335238f, 0.01363096f, 0.00765587f, 0.02802948f, -0.01866085f, 0.04893573f, 0.03512672f, 
    0.03537811f, 0.03377391f, -0.01423632f, -0.04865200f, 0.04691694f, -0.03280548f, 0.03816950f, 0.02021312f, 
    0.00867968f, 0.02191334f, 0.01251600f, -0.04517482f, 0.01925549f, 0.04130639f, -0.01196090f, -0.03355194f, 
    -0.04077500f, 0.04566946f, 0.03292180f, 0.04207028f, -0.03015622f, -0.00942690f, 0.00241774f, -0.00952884f, 
    -0.00732373f, -0.05108637f, -0.06594002f, 0.01514740f, 0.01103740f, 0.01059185f, -0.01631508f, 0.02401288f, 
    -0.06176204f, 0.00059640f, -0.04018569f, 0.01732906f, -0.01262403f, -0.01146628f, 0.00524374f, -0.05744860f, 
    -0.03722202f, -0.05878482f, 0.03542241f, 0.01366243f, -0.03003727f, 0.01912908f, -0.04247969f, -0.00538178f, 
    -0.06145579f, -0.04092355f, -0.00597626f, -0.00487193f, 0.03669821f, 0.04738323f, -0.00578565f, -0.02089147f, 
    0.00560180f, -0.03202979f, -0.00753323f, -0.04531024f, -0.03038731f, 0.00674943f, -0.05112428f, 0.02338630f, 
    0.02086327f, 0.00257255f, -0.02480147f, -0.04828767f, -0.01770711f, 0.01621033f, -0.02599070f, -0.01907401f, 
    0.03976436f, -0.00830208f, 0.00037587f, -0.04691660f, -0.01372044f, 0.01936395f, -0.00940729f, -0.04853560f, 
    -0.04146131f, 0.03670114f, -0.03291328f, -0.02369564f, 0.04674822f, 0.00494572f, -0.04053903f, 0.02702033f, 
    -0.04607468f, -0.01692562f, -0.00788503f, 0.02393421f, -0.04715718f, 0.04403504f, -0.01376220f, -0.06176890f, 
    -0.00111463f, -0.00005512f, -0.03354858f, 0.01067049f, 0.03401552f, -0.02524158f, -0.03189854f, -0.05804494f, 
    0.02827747f, -0.01351689f, -0.00647322f, -0.02797427f, 0.05185954f, -0.01371882f, -0.03529140f, 0.01677887f, 
    0.02764047f, -0.03780805f, 0.02009343f, -0.05166415f, -0.03709667f, -0.05065053f, 0.00776101f, -0.04738425f, 
    0.05185178f, 0.04213504f, -0.02842250f, -0.02452807f, 0.00075880f, -0.01634418f, 0.00168606f, -0.05505471f, 
    -0.01953155f, 0.04159895f, -0.04968501f, -0.00050829f, -0.04886783f, -0.05184747f, -0.04185067f, 0.05465219f, 
    -0.02044888f, -0.05807086f, 0.02817186f, -0.04447073f, -0.05408743f, -0.05755444f, 0.02903706f, -0.03620467f, 
    -0.00579772f, -0.02122193f, 0.01830832f, 0.01724268f, 0.00335055f, 0.01450114f, -0.05854253f, -0.02390170f, 
    0.01755659f, -0.03768069f, -0.01715853f, -0.03902343f, -0.00831224f, -0.03746920f, 0.04514129f, -0.05178399f, 
    -0.04954652f, 0.00489750f, 0.03631044f, -0.04231068f, -0.02048033f, -0.01829175f, -0.01248920f, 0.04976846f, 
    -0.01724820f, 0.02612549f, -0.02303833f, 0.04489176f, -0.01062300f, 0.04302396f, -0.04968525f, -0.00431436f, 
    -0.02540886f, -0.00356371f, 0.00702399f, -0.00061000f, 0.00307878f, -0.02672044f, 0.03299677f, -0.04010298f, 
    -0.01319055f, 0.01295630f, -0.01835349f, -0.03954469f, 0.04145863f, -0.00919654f, -0.01958733f, -0.00623169f, 
    -0.03186096f, 0.00332717f, -0.03059923f, 0.00628509f, 0.00387386f, -0.00761369f, 0.02475007f, 0.01043919f, 
    0.03316206f, -0.02458972f, 0.02607032f, 0.01062739f, -0.00886739f, -0.06381416f, 0.03098010f, -0.04829702f, 
    -0.03268339f, -0.04583560f, -0.04354706f, 0.03778336f, -0.05742416f, -0.00839210f, -0.04522149f, -0.03674754f, 
    0.38643643f, -0.05534811f, -0.02686672f, -0.06608900f, 0.06445912f, 0.03138546f, 0.20954561f, 0.03356893f, 
    0.03532084f, -0.04778265f, 0.09893982f, -0.13216035f, 0.04875250f, -0.04472739f, -0.02662999f, 0.10677572f, 
    -0.05344900f, -0.05705507f, 0.07993816f, 0.11140239f, 0.18819933f, -0.04683694f, -0.27792966f, -0.08411165f, 
    -0.07675140f, 0.19949102f, -0.16755794f, 0.03054960f, 0.02732619f, -0.04725576f, 0.09152693f, 0.24397106f, 
    0.03428921f, -0.18595862f, 0.19889452f, -0.05631822f, -0.00630864f, 0.00337616f, 0.01100590f, -0.03427046f, 
    -0.11475950f, -0.24175592f, -0.38332054f, -0.05718751f, 0.01921669f, 0.08551900f, 0.13697609f, 0.14192426f, 
    0.05385104f, -0.15344524f, 0.16138038f, 0.19332315f, -0.04151420f, 0.01738682f, -0.05109840f, 0.05517327f, 
    0.00239820f, -0.00381866f, -0.03127105f, -0.03287490f, -0.00482740f, 0.01020516f, -0.00443545f, 0.16481613f, 
    0.07975324f, 0.05341103f, 0.10215609f, -0.12801553f, 0.09749076f, -0.08882222f, -0.02744381f, -0.08919707f, 
    0.12211314f, 0.07861348f, 0.00436054f, -0.27988043f, 0.09531404f, -0.08297006f, 0.02566476f, -0.15248638f, 
    -0.01829762f, -0.23754442f, -0.25264010f, -0.11435246f, 0.13025358f, 0.00633025f, -0.08737049f, -0.11123230f, 
    0.02897062f, 0.24948163f, 0.02004615f, -0.07021112f, -0.00936824f, 0.13981681f, 0.17843635f, 0.06228888f, 
    0.11737533f, -0.00952066f, 0.14899781f, -0.09912105f, 0.40159562f, 0.39246544f, 0.07929415f, -0.23784904f, 
    -0.06594777f, -0.05872076f, -0.01507839f, -0.08391311f, 0.08637261f, -0.00131063f, -0.00250031f, 0.05385909f, 
    -0.08519792f, 0.00877229f, 0.05923958f, 0.10651015f, 0.03014982f, 0.13346580f, 0.12239626f, 0.00168955f, 
    -0.16573182f, -0.04353122f, 0.21599597f, -0.30168501f, 0.01205968f, -0.26040211f, 0.14329596f, -0.07312159f, 
    0.06828869f, -0.09616871f, -0.03690090f, -0.05112688f, 0.02797558f, 0.15300517f, 0.12354524f, -0.07709060f, 
    -0.04350587f, 0.00029190f, 0.06100582f, 0.05223794f, 0.35981023f, 0.19728167f, -0.24365471f, -0.11488659f, 
    0.13080755f, -0.02597172f, 0.18097594f, -0.02767189f, -0.00172356f, 0.14102820f, -0.00922238f, 0.15663189f, 
    0.03432652f, 0.08514546f, -0.14613627f, 0.02028731f, -0.04882474f, -0.13477786f, -0.01372854f, -0.01686064f, 
    -0.33842215f, 0.10496479f, -0.23576418f, -0.27515909f, 0.27015087f, 0.10325424f, 0.16386200f, 0.05120641f, 
    -0.12175475f, -0.15350169f, 0.17833190f, -0.08010407f, 0.06128924f, -0.09374691f, -0.12437713f, -0.00013549f, 
    0.09664556f, -0.00026780f, 0.04712531f, -0.02027540f, 0.05764242f, 0.23337349f, -0.24490170f, -0.23050208f, 
    -0.19371864f, 0.15910116f, -0.06943020f, 0.01033463f, 0.00978664f, 0.05735155f, -0.04045728f, -0.01670718f, 
    0.00959812f, 0.00590432f, -0.10514684f, -0.01554439f, -0.11159359f, 0.14781168f, -0.02728700f, -0.02983059f, 
    0.00329958f, 0.08343358f, 0.11889517f, 0.26978639f, 0.23359890f, -0.04757081f, -0.03136466f, -0.09652892f, 
    -0.13105443f, 0.16346182f, -0.09716205f, -0.13897549f, -0.00999872f, 0.07949354f, -0.03405523f, 0.24181294f, 
    0.10805248f, -0.03087449f, -0.01379035f, -0.04379442f, -0.22466002f, 0.33837736f, 0.02247021f, -0.13915613f, 
    0.28807509f, 0.10613159f, -0.13495614f, -0.18367825f, 0.02779992f, 0.04870139f, 0.07145493f, -0.10672989f, 
    0.08268223f, -0.08538020f, -0.04496618f, 0.07099798f, 0.05702838f, -0.02893692f, -0.05126690f, -0.11089014f, 
    0.33316493f, -0.30035055f, 0.10630079f, 0.08156234f, -0.30221894f, -0.00553341f, 0.02481446f, -0.02047879f, 
    0.06849232f, 0.04932548f, -0.08765487f, -0.02283709f, 0.04397742f, 0.00622586f, -0.00948019f, -0.11855780f, 
    -0.06461912f, -0.15283567f, 0.00459426f, 0.03281598f, 0.58353329f, -0.20754966f, 0.29684654f, 0.24398202f, 
    0.08190405f, 0.07352769f, -0.08219253f, 0.03206782f, -0.03197182f, 0.25452432f, -0.04036566f, -0.11522897f, 
    0.20798126f, -0.06405494f, 0.11061111f, 0.10742576f, -0.05168318f, 0.00510326f, 0.05560403f, 0.08888255f, 
    0.09858023f, -0.22837111f, 0.18388255f, 0.15237248f, 0.31017926f, -0.14959371f, -0.12347998f, -0.05466561f, 
    0.04817285f, 0.29184580f, -0.06589644f, 0.09201095f, 0.10670953f, 0.02289028f, 0.05383207f, -0.14896740f, 
    -0.00605832f, -0.06694171f, -0.01470919f, 0.06125338f, 0.35510194f, 0.13154291f, -0.27277109f, -0.04486057f, 
    -0.14441636f, -0.08391687f, -0.08136757f, 0.08113939f, -0.08537945f, 0.05644673f, -0.02314525f, 0.12497758f, 
    0.13242687f, 0.12485930f, -0.09148385f, 0.03092898f, -0.00190769f, -0.13167033f, -0.00407698f, 0.10978145f, 
    -0.04186801f, 0.01810710f, 0.03131088f, 0.00729185f, 0.00198010f, -0.00740259f, 0.03769316f, -0.05286515f, 
    0.03558844f, -0.06058085f, -0.02497542f, -0.00632320f, -0.04824360f, -0.05465081f, 0.02469267f, -0.02150024f, 
    -0.03694389f, -0.02973738f, 0.03237145f, 0.04903961f, -0.05573167f, -0.01650771f, -0.02932300f, -0.00914010f, 
    0.04783169f, -0.03570717f, -0.00028330f, -0.02967062f, -0.06108069f, 0.00346674f, -0.03548003f, -0.02918780f, 
    -0.05031954f, -0.03409376f, -0.01340621f, 0.01289681f, 0.02414917f, -0.04730877f, -0.01363750f, -0.03990471f, 
    -0.05241477f, -0.00095613f, 0.03143690f, -0.05619225f, -0.05220142f, 0.03567132f, 0.04962468f, 0.00245814f, 
    0.04571194f, 0.01076630f, -0.04959588f, -0.00589325f, 0.02044727f, 0.03737163f, -0.04779740f, -0.01950960f, 
    0.01672331f, 0.00863399f, 0.01347553f, -0.05857177f, -0.01429417f, -0.00956712f, -0.00001978f, -0.03511458f, 
    -0.00374047f, 0.00535038f, -0.04323736f, 0.03903758f, -0.02031447f, -0.04047551f, 0.01818615f, 0.01603647f, 
    -0.04382180f, -0.00506918f, 0.00564243f, -0.01409348f, 0.00517569f, 0.02607989f, 0.00426106f, -0.02282964f, 
    0.05583476f, -0.00809737f, -0.01218159f, -0.03369077f, 0.01558306f, 0.03754494f, 0.03090837f, 0.03555281f, 
    0.05011906f, 0.01762866f, 0.00425126f, 0.04784210f, -0.01005378f, 0.00571880f, 0.02121425f, 0.04340743f, 
    0.02287238f, -0.05517198f, 0.04687042f, -0.04863816f, -0.00169036f, 0.03647986f, 0.03161343f, -0.00225831f, 
    -0.01329916f, -0.01962117f, 0.04146601f, 0.02632418f, 0.01328369f, -0.01729433f, 0.04401766f, -0.06017021f, 
    0.03953829f, -0.04964554f, -0.05063267f, 0.04673315f, -0.02175544f, -0.01160125f, -0.01224914f, 0.03635013f, 
    -0.00735319f, 0.02061417f, 0.01605751f, 0.03695007f, 0.00013497f, -0.00893218f, 0.03187967f, 0.00791584f, 
    -0.04674745f, -0.05666919f, 0.02334039f, -0.01752483f, -0.00574065f, 0.04736112f, -0.03981164f, 0.01173061f, 
    -0.01004531f, -0.00589443f, 0.04259418f, -0.00179047f, 0.02415776f, -0.02614765f, -0.01310015f, -0.00126799f, 
    -0.02875816f, -0.04078437f, -0.05958499f, -0.04385071f, 0.03193191f, 0.01927454f, -0.05788912f, -0.00867016f, 
    0.02130856f, 0.03386683f, -0.01564629f, 0.03764386f, 0.00990323f, 0.00049300f, -0.01498190f, -0.05853014f, 
    -0.04873780f, -0.00657492f, -0.01508482f, -0.03136440f, -0.03599407f, 0.02088908f, 0.00550829f, 0.03641711f, 
    -0.02979746f, -0.05105039f, -0.06002729f, -0.05158981f, 0.02571616f, -0.00723776f, -0.03458008f, 0.01218998f, 
    -0.01242011f, 0.01200091f, 0.00690414f, 0.03008627f, 0.00089983f, -0.01573010f, -0.00552847f, -0.00032522f, 
    0.03791192f, -0.02108196f, -0.02257195f, 0.04960672f, -0.03707660f, 0.04425891f, 0.02880486f, -0.00741268f, 
    -0.03278428f, -0.02129211f, 0.01119286f, 0.02427918f, 0.01112884f, -0.02361125f, -0.01396161f, 0.03789859f, 
    -0.04153535f, 0.03710480f, -0.03200412f, -0.05848464f, 0.04306750f, -0.03092413f, 0.02599445f, 0.02186202f, 
    -0.00810832f, 0.01182335f, 0.03580983f, -0.00342030f, 0.03972118f, -0.03671378f, 0.02585013f, -0.00869012f, 
    -0.04903306f, 0.04814597f, -0.01414846f, -0.03162352f, -0.00299120f, 0.01780349f, -0.04283549f, -0.03762742f, 
    0.01007205f, -0.01604972f, 0.04922843f, 0.01348373f, -0.01566472f, 0.00113951f, -0.03621433f, -0.03526768f, 
    0.03357507f, -0.06077628f, -0.05544363f, 0.03404597f, -0.05923530f, 0.01859090f, -0.00480872f, -0.01335467f, 
    -0.04071072f, -0.03485997f, -0.03415117f, 0.01645543f, -0.05405778f, -0.02262091f, -0.04048540f, -0.02278546f, 
    -0.01907162f, -0.02837533f, -0.01226394f, -0.00098523f, -0.01722887f, -0.02344540f, -0.05437107f, -0.04881264f, 
    -0.04272888f, -0.02507847f, -0.04136884f, -0.05303006f, -0.04520668f, -0.00703507f, -0.04641005f, 0.03303478f, 
    -0.03558480f, -0.01763511f, 0.04885991f, -0.01067945f, -0.02982525f, 0.01989732f, -0.02038221f, 0.03306758f, 
    -0.04848304f, 0.00723197f, -0.02640052f, 0.04835436f, 0.03145368f, 0.04766944f, 0.00258598f, 0.01427815f, 
    -0.03129027f, -0.00748762f, -0.04603317f, -0.04900861f, 0.00942244f, 0.02696455f, -0.00752934f, 0.01990963f, 
    -0.05474304f, -0.00531571f, -0.03987514f, -0.03545746f, -0.05646348f, -0.05597278f, -0.02345950f, -0.03679010f, 
    -0.00158007f, 0.04512380f, 0.01819150f, 0.01574277f, 0.02581240f, -0.03360589f, 0.00755729f, -0.01870747f, 
    0.00754876f, -0.04921428f, 0.02123546f, -0.01982008f, -0.03659211f, -0.00462761f, -0.03658511f, 0.04087841f, 
    0.00292059f, -0.02448902f, 0.03015295f, -0.05486296f, -0.04365287f, -0.05577264f, 0.01237253f, -0.05129923f, 
    -0.05972951f, -0.05773823f, -0.02523905f, -0.04534659f, -0.00685626f, -0.05067242f, -0.03870867f, -0.00179806f, 
    0.01136297f, -0.04206597f, -0.01463637f, -0.00106291f, 0.01043476f, -0.00875556f, 0.01391428f, -0.01265960f, 
    -0.05654591f, -0.04403920f, -0.03874350f, -0.01952842f, -0.05650960f, -0.04490765f, -0.04112353f, -0.03977447f, 
    0.01659710f, 0.04249917f, 0.02481051f, -0.00928582f, -0.05570517f, 0.01230368f, 0.04747023f, 0.00256083f, 
    0.03805565f, -0.05622416f, 0.01115455f, 0.02627220f, 0.03043388f, 0.01280741f, 0.03075618f, -0.01023956f, 
    0.00254119f, 0.02436820f, 0.02981956f, -0.05678720f, -0.05377806f, -0.05778386f, -0.04318759f, -0.00979357f, 
    0.02329206f, -0.03777972f, -0.03273876f, 0.02513593f, -0.02373368f, 0.01552978f, -0.04359642f, -0.04026781f, 
    -0.06113504f, -0.05030998f, 0.01593913f, -0.05836597f, 0.03219648f, -0.04552642f, -0.05294178f, -0.05868075f, 
    0.01232128f, 0.04070679f, 0.02008337f, -0.05232028f, -0.02604426f, -0.01140472f, -0.01150997f, 0.02267359f, 
    0.00241099f, 0.00158071f, 0.04507383f, -0.01968130f, -0.03313681f, -0.01948033f, 0.00920971f, -0.01990408f, 
    0.01457987f, -0.04801470f, -0.00297668f, 0.02258817f, -0.02081397f, -0.01517919f, -0.01573213f, -0.01378354f, 
    -0.03838767f, -0.03206554f, 0.01118231f, -0.05513336f, -0.02803145f, 0.00777208f, -0.00214461f, 0.00072754f, 
    0.02284909f, -0.04934682f, 0.03476752f, 0.04359486f, -0.05961237f, -0.05936928f, 0.04059076f, -0.02287206f, 
    -0.01369543f, -0.04632493f, 0.03492163f, 0.01101608f, 0.00116393f, 0.02764568f, -0.00799363f, 0.04061166f, 
    0.04697801f, -0.01174731f, -0.00079088f, -0.01196783f, -0.00409574f, 0.02401710f, -0.02741512f, 0.01847629f, 
    0.04540887f, 0.02446088f, 0.03566265f, -0.04203691f, -0.04164477f, -0.02699848f, 0.02511157f, -0.05080810f, 
    0.01891579f, -0.02019212f, 0.02335631f, 0.04357618f, 0.03056058f, 0.04690274f, 0.00635675f, -0.02510013f, 
    -0.05286200f, -0.01936629f, -0.05740953f, 0.00744204f, 0.03973813f, 0.02977346f, 0.02682780f, -0.05490163f, 
    0.02938091f, 0.03435345f, 0.01913925f, -0.04234663f, -0.05286092f, 0.01694614f, 0.03927962f, -0.02104299f, 
    0.03617582f, -0.03005211f, -0.04657099f, 0.01959866f, 0.03921230f, -0.02621797f, -0.04178440f, 0.00658429f, 
    0.04011057f, 0.03431267f, 0.03513047f, 0.02848727f, 0.03207673f, 0.02400362f, -0.06127702f, -0.05969976f, 
    -0.03172476f, -0.04555446f, 0.01271621f, -0.01772405f, 0.00974867f, 0.02390402f, -0.03028961f, -0.02129452f, 
    0.01009020f, 0.01608925f, 0.04608356f, 0.03347620f, 0.03922936f, -0.01565586f, 0.02665927f, -0.01554745f, 
    -0.01450084f, -0.00823991f, -0.03941697f, -0.01630005f, 0.02254677f, 0.04353777f, 0.00887305f, 0.03987626f, 
    -0.05447552f, -0.03642883f, 0.04351803f, 0.01470756f, 0.03698433f, -0.02072570f, -0.05990372f, 0.03640048f, 
    -0.04610086f, -0.04464050f, 0.03223287f, 0.00837211f, -0.05160806f, -0.03674486f, 0.03878073f, 0.01569563f, 
    0.05665258f, -0.00670601f, 0.00462955f, -0.00302077f, -0.01509340f, 0.03641850f, 0.00660467f, -0.06160368f, 
    0.02589035f, 0.05227748f, -0.00873996f, -0.04085248f, -0.00417559f, -0.02732719f, -0.04690107f, -0.04425886f, 
    -0.04315199f, 0.02032948f, -0.05108623f, -0.00383343f, -0.02510452f, -0.02268412f, 0.02546210f, 0.01788392f, 
    0.01865768f, -0.03102661f, 0.00042428f, 0.03293345f, -0.05325719f, -0.03135699f, -0.02872732f, -0.02783094f, 
    0.03560026f, 0.02922186f, -0.03429144f, 0.01723758f, -0.03564605f, -0.00607119f, -0.04370960f, -0.02533737f, 
    -0.01200470f, -0.04487498f, -0.01443020f, 0.02813882f, 0.00394147f, -0.00914938f, 0.00307959f, -0.04453803f, 
    -0.02972064f, 0.00234442f, 0.01961746f, -0.04582764f, -0.00731684f, 0.02261809f, 0.01062182f, 0.03247694f, 
    -0.00893537f, -0.05932279f, 0.03037823f, -0.03773575f, -0.04480762f, 0.02747504f, 0.04811566f, -0.03073936f, 
    -0.04538499f, 0.01841683f, -0.02113394f, -0.04857565f, -0.04753916f, -0.02429819f, -0.04821518f, 0.03995681f, 
    -0.06346782f, 0.00694811f, 0.01597714f, -0.00151619f, 0.01145989f, 0.04120490f, 0.01307448f, -0.01128685f, 
    -0.01705821f, 0.04613646f, -0.04862205f, -0.04383615f, -0.05192061f, 0.02444927f, -0.03124915f, -0.03382518f, 
    0.00609120f, -0.02291870f, -0.02961994f, 0.03608428f, -0.01079775f, 0.00867814f, -0.00864059f, -0.03566493f, 
    -0.00143471f, 0.00555279f, -0.02323144f, -0.06002649f, -0.02580973f, -0.04297897f, 0.02987664f, -0.05753268f, 
    -0.03969479f, -0.02476994f, -0.05695778f, -0.01812251f, 0.02931077f, -0.04511893f, 0.03737948f, -0.01433637f, 
    0.04112184f, -0.00007247f, 0.03261956f, 0.00613753f, -0.04893033f, -0.05694018f, -0.00843807f, 0.04601881f, 
    -0.05422290f, -0.00388211f, -0.05559251f, 0.02600369f, 0.01835670f, -0.05563994f, -0.00292093f, 0.02988307f, 
    0.00012759f, -0.03069449f, 0.03923792f, -0.05914951f, -0.02792083f, -0.00056157f, 0.02624239f, -0.02410966f, 
    0.02769906f, 0.02166716f, -0.00428062f, 0.01198392f, -0.05676372f, 0.03869203f, 0.03860777f, -0.06267115f, 
    0.02925921f, 0.00155793f, -0.04234982f, 0.00411624f, -0.03367548f, -0.03092060f, 0.02297010f, 0.04133637f, 
    -0.03794535f, 0.04124159f, 0.02488410f, -0.02198559f, 0.01130255f, 0.01740286f, 0.00534803f, 0.01684122f, 
    -0.04903848f, -0.04668773f, 0.00537733f, 0.01804332f, -0.01096324f, -0.02784622f, 0.00564481f, 0.04730728f, 
    -0.05433001f, -0.01225665f, 0.03307066f, -0.02877375f, -0.05632140f, 0.03015391f, -0.01509250f, -0.04787279f, 
    -0.02236970f, -0.02591147f, -0.01897472f, -0.05577813f, -0.04811004f, -0.01540981f, 0.03523261f, -0.06284460f, 
    -0.05654523f, 0.00990060f, -0.01548920f, -0.06012908f, -0.00371313f, -0.03404725f, -0.06021376f, 0.02409527f, 
    0.04305335f, 0.03433035f, 0.01219082f, -0.01756504f, 0.03151918f, 0.01442653f, -0.05054345f, -0.02796246f, 
    -0.06171991f, -0.01754020f, -0.05418077f, 0.01940893f, 0.00575180f, -0.05535745f, -0.00363263f, 0.03398030f, 
    -0.03389108f, 0.00315394f, -0.00935644f, 0.05198474f, 0.00786125f, -0.05005829f, 0.01046087f, -0.04276710f, 
    0.01426915f, -0.03962103f, 0.00065818f, -0.01656212f, -0.05950579f, -0.00370256f, 0.02983826f, -0.04127857f, 
    -0.04583648f, 0.01202933f, -0.04187858f, 0.03242198f, -0.03370321f, -0.04572687f, 0.01306784f, -0.00371296f, 
    0.04073774f, -0.05505598f, 0.00646137f, -0.05992531f, 0.04246077f, -0.03874041f, 0.01161808f, -0.04652822f, 
    0.04415428f, -0.05334336f, -0.03958744f, 0.01345779f, -0.00440848f, -0.03075620f, -0.05524076f, -0.03775390f, 
    0.00512281f, 0.00286232f, -0.02989260f, -0.06153657f, 0.02395656f, 0.01518646f, 0.04328382f, 0.00333852f, 
    -0.05357673f, 0.01125395f, 0.00118719f, -0.00823213f, -0.02561175f, 0.02934068f, -0.05917214f, -0.00252972f, 
    -0.00192863f, -0.05328697f, 0.00253501f, -0.02019710f, 0.01680197f, 0.00505728f, -0.05400147f, -0.02951381f, 
    0.04057512f, 0.01023426f, -0.02861862f, 0.02845880f, -0.03373099f, 0.04458376f, 0.01740678f, -0.04168542f, 
    -0.03645898f, -0.04897756f, 0.01592155f, 0.01153877f, 0.00258316f, -0.05414244f, 0.04480296f, -0.03178050f, 
    0.04242568f, -0.01580563f, -0.04843200f, -0.01582473f, 0.00023782f, -0.05143973f, -0.01766742f, -0.05179770f, 
    -0.03967052f, 0.05178764f, 0.02157229f, -0.02661778f, -0.04834280f, -0.02494647f, 0.01141255f, 0.04960561f, 
    -0.01755702f, 0.01287415f, -0.01482406f, -0.02373691f, 0.03511868f, 0.02179774f, 0.04057029f, -0.05383132f, 
    -0.05820043f, -0.01741487f, -0.01298850f, -0.05593512f, -0.02078058f, 0.02131384f, 0.04318394f, 0.00748982f, 
    -0.02490164f, -0.05489963f, -0.05711582f, -0.02703297f, -0.05328521f, 0.03058841f, -0.02658278f, 0.00998165f, 
    -0.04378639f, -0.00804304f, 0.02790374f, -0.01217911f, -0.04366688f, 0.01887861f, -0.03842582f, -0.03843252f, 
    -0.00995224f, 0.02965067f, -0.00720457f, 0.01276531f, 0.02873219f, 0.00589809f, 0.00851207f, -0.04524954f, 
    -0.03209641f, -0.05432076f, 0.01848016f, -0.00118304f, -0.05596273f, -0.00000516f, 0.01904563f, -0.01683350f, 
    0.04131483f, -0.00143808f, 0.03259930f, -0.00161751f, 0.01122466f, 0.04772403f, -0.04182169f, 0.03578449f, 
    -0.03811847f, -0.05893691f, 0.03730812f, -0.01955716f, -0.06116063f, 0.01310783f, 0.04294515f, 0.01143594f, 
    -0.05138107f, 0.00082836f, -0.03579299f, 0.00268911f, -0.00089680f, 0.03316150f, -0.00368774f, 0.00267872f, 
    -0.01580247f, -0.01715474f, 0.02478057f, 0.01619545f, -0.04211923f, -0.05729347f, -0.01554273f, 0.03523318f, 
    0.00718653f, -0.01115324f, 0.00575666f, 0.02225626f, 0.00498055f, -0.04489205f, -0.05541445f, -0.05167812f, 
    -0.03853971f, 0.02660165f, -0.04304251f, -0.03607154f, -0.00628796f, 0.02478850f, 0.02895602f, 0.02199447f, 
    -0.03509644f, -0.05029972f, -0.03972343f, -0.04714028f, -0.00870177f, -0.02158732f, -0.05137001f, -0.00496944f, 
    -0.01685105f, 0.02030517f, -0.01236248f, 0.04258366f, -0.01170378f, -0.00380492f, -0.04004551f, -0.00801861f, 
    0.02056563f, 0.00417014f, 0.03140546f, 0.01796061f, -0.02800073f, -0.00758760f, 0.00742884f, 0.03979746f, 
    0.04137783f, 0.00722028f, 0.04493597f, -0.00800852f, 0.03632994f, -0.01773352f, -0.04056951f, 0.02238571f, 
    -0.15186471f, -0.25886616f, 0.04850470f, 0.13082312f, -0.11001203f, 0.11278591f, 0.11436542f, 0.01692787f, 
    -0.15451719f, 0.08287516f, 0.06102491f, 0.01396189f, 0.05581526f, -0.11458725f, 0.07939432f, -0.03969209f, 
    0.06003863f, 0.05633901f, 0.15666190f, 0.10550867f, 0.31121790f, 0.07261389f, -0.14240451f, -0.07652265f, 
    0.14441444f, 0.07290586f, -0.09795363f, 0.23939310f, 0.02728725f, 0.09320497f, 0.08261871f, 0.15331724f, 
    0.15299055f, -0.16143708f, 0.11569601f, 0.06510352f, 0.07836845f, -0.16560104f, 0.08791407f, 0.02586672f, 
    0.06531488f, 0.03551699f, -0.15807433f, 0.01748245f, 0.29884297f, 0.05220798f, 0.04604485f, -0.06258570f, 
    0.07689153f, -0.02110908f, 0.07455854f, -0.01617429f, -0.09043338f, 0.25895602f, 0.05382122f, 0.07629553f, 
    0.04547384f, 0.02926042f, -0.01161439f, -0.01311080f, 0.00508502f, -0.17679892f, -0.04146674f, -0.08914953f, 
    0.22919780f, 0.16917658f, -0.07278801f, 0.03380449f, -0.02473978f, -0.00669537f, 0.07114521f, -0.04650611f, 
    -0.00537269f, 0.09613176f, -0.12176222f, -0.03150769f, -0.07433803f, -0.03993202f, 0.18290322f, -0.03106429f, 
    -0.22853032f, 0.09847408f, -0.19928311f, -0.01132251f, -0.04242264f, -0.07250817f, 0.02687115f, 0.02621158f, 
    -0.01790974f, 0.01928340f, -0.01700313f, -0.10607789f, -0.17709129f, 0.07154857f, 0.02235008f, 0.18310903f, 
    0.07663571f, -0.03519495f, 0.03246389f, -0.04505266f, 0.02208354f, -0.14884062f, 0.20753771f, -0.07655375f, 
    -0.10636827f, -0.05487626f, 0.00915548f, 0.07302768f, 0.14661226f, -0.05711117f, 0.09072689f, 0.08997063f, 
    -0.06731111f, 0.02359634f, 0.02049576f, -0.01093392f, -0.07112709f, -0.02395236f, -0.02464270f, 0.07744119f, 
    -0.18183997f, 0.37914041f, 0.07823607f, 0.15127650f, -0.17601347f, -0.29554152f, 0.06381746f, -0.05146316f, 
    0.12309629f, -0.04477990f, 0.05511789f, 0.04318582f, 0.08136094f, 0.00415379f, 0.02101952f, -0.07414116f, 
    0.03655358f, -0.10688572f, -0.17913668f, -0.01349909f, -0.40030894f, 0.17260660f, -0.13488628f, -0.09074397f, 
    0.04710780f, 0.05602617f, 0.12532257f, -0.14567082f, -0.03816656f, 0.02309087f, 0.06214920f, 0.02947623f, 
    0.14925443f, -0.18823697f, 0.02852656f, 0.02050681f, 0.00557613f, 0.06369000f, 0.10491802f, 0.17503087f, 
    -0.26793942f, -0.00363528f, 0.15045469f, -0.00175584f, 0.14686263f, 0.04076901f, -0.01733542f, 0.02616743f, 
    0.04359623f, -0.04136624f, 0.22969884f, 0.10798009f, 0.07418365f, -0.05306839f, 0.03573531f, -0.07017741f, 
    -0.01022239f, -0.13179208f, -0.07117836f, -0.27873799f, 0.35414761f, 0.12604636f, 0.13788664f, -0.05095376f, 
    -0.01906921f, 0.08860166f, -0.07172661f, -0.04304812f, -0.06600745f, -0.05526953f, -0.11093047f, -0.02869948f, 
    0.10353347f, 0.18311198f, -0.14954753f, 0.11066704f, -0.04602915f, -0.02607872f, -0.10697778f, -0.14137745f, 
    -0.13604638f, 0.16581276f, -0.08340585f, 0.00756403f, -0.10813380f, 0.00615080f, -0.15839891f, -0.06118267f, 
    0.04620712f, 0.12192433f, 0.00202785f, 0.00967445f, -0.05164658f, -0.02213002f, -0.08535055f, 0.18145353f, 
    0.00395647f, -0.01397408f, -0.09850673f, -0.00637761f, -0.37174550f, -0.03549698f, 0.24621354f, 0.06288879f, 
    0.10031611f, 0.01640863f, 0.09014086f, -0.04781447f, 0.03497679f, 0.09475173f, 0.16603899f, -0.02474341f, 
    0.15087774f, -0.14449288f, -0.00550510f, 0.11694455f, -0.03362680f, 0.06168082f, 0.03770373f, 0.04609138f, 
    0.50614351f, 0.00587055f, 0.04295272f, -0.22723737f, -0.11315587f, -0.02227064f, -0.01548060f, 0.01275770f, 
    -0.02300185f, 0.02983918f, 0.00554848f, 0.09365698f, -0.05675968f, -0.01061894f, 0.01551773f, -0.14298333f, 
    0.03617538f, 0.08207653f, 0.15109469f, 0.05039864f, 0.26415488f, -0.07763577f, 0.08452440f, -0.01874937f, 
    -0.20886517f, 0.15697542f, -0.00423737f, -0.01105078f, 0.02476602f, -0.10013442f, -0.03312916f, 0.02097234f, 
    -0.05275043f, 0.03887685f, -0.09188290f, -0.04115291f, 0.10037031f, 0.13455564f, -0.17774984f, -0.00811150f, 
    0.11538254f, 0.27582905f, 0.02063438f, 0.09228024f, -0.16770741f, -0.09440814f, 0.05352674f, -0.00186215f, 
    -0.01018084f, -0.08744525f, 0.01719866f, -0.01314085f, -0.05683250f, -0.16584994f, 0.00373922f, -0.00533781f, 
    0.05298344f, 0.05635455f, 0.02440881f, 0.08081076f, 0.44382417f, -0.00049335f, -0.30611551f, -0.21099056f, 
    -0.01581661f, -0.23513672f, -0.01935252f, -0.14258899f, -0.00813697f, 0.15445539f, 0.06246285f, -0.05928920f, 
    0.12527704f, 0.07036837f, 0.15227132f, 0.02303907f, -0.03250983f, -0.01448867f, 0.08840978f, 0.04277058f, 
    -0.01839931f, 0.02666448f, 0.00166188f, 0.00967797f, 0.00561448f, -0.01435259f, 0.02950807f, -0.04562883f, 
    0.02315888f, 0.00658552f, -0.03969644f, -0.00298890f, 0.01295717f, 0.04443531f, 0.01657440f, -0.05735965f, 
    0.01974892f, -0.01663414f, 0.01230918f, -0.05864148f, -0.00822214f, -0.05071938f, -0.01419241f, 0.00877510f, 
    -0.05887705f, 0.00702970f, 0.01661377f, 0.00789399f, 0.04650895f, 0.04309432f, -0.00779611f, -0.03185875f, 
    -0.02608222f, -0.00955015f, 0.01291533f, -0.02792439f, 0.01967692f, -0.03383639f, -0.02851782f, -0.00670507f, 
    -0.01070394f, -0.00177469f, -0.02617098f, -0.02241479f, -0.03255839f, -0.06002416f, -0.02198012f, -0.05623138f, 
    -0.05553475f, 0.03058666f, 0.03793088f, -0.06053810f, 0.04574497f, 0.01384861f, -0.04476029f, -0.03732980f, 
    -0.03960108f, -0.04027670f, -0.03918479f, -0.02826639f, -0.00565607f, 0.01170425f, -0.05415313f, 0.00894969f, 
    -0.01380344f, 0.00408977f, 0.01101251f, -0.00053380f, -0.03088849f, -0.02847096f, -0.00267716f, 0.00721450f, 
    -0.00572419f, -0.00738299f, -0.00561515f, 0.02686563f, -0.05056890f, 0.02623481f, 0.01728996f, 0.01897962f, 
    -0.03516826f, 0.02597808f, 0.01659764f, -0.04035083f, -0.05536254f, -0.02685404f, -0.05657598f, 0.02014788f, 
    0.00772882f, 0.01595820f, 0.01640522f, 0.00218395f, -0.03938457f, -0.03678494f, -0.05227188f, -0.03517099f, 
    -0.04890465f, -0.03650141f, 0.01266302f, -0.05766265f, 0.02272822f, -0.05921742f, -0.01379407f, 0.00006532f, 
    -0.02738382f, -0.05931810f, 0.00746756f, 0.04576651f, -0.00361910f, -0.04527232f, -0.00917373f, -0.00308350f, 
    -0.05397238f, 0.03795711f, 0.02926552f, -0.03981892f, -0.04661207f, -0.04884950f, -0.04294196f, -0.02448883f, 
    0.00286393f, 0.04026361f, -0.01004150f, -0.03818649f, -0.01543194f, 0.04636666f, 0.04479366f, 0.00093410f, 
    0.04624232f, -0.02610940f, 0.00554928f, -0.03739727f, -0.03399424f, -0.01553206f, 0.02857621f, -0.00722641f, 
    -0.04172969f, 0.00678618f, -0.02479397f, 0.00337639f, 0.00632962f, -0.04855600f, 0.00009492f, 0.03309296f, 
    -0.02369007f, -0.02566563f, 0.03621347f, -0.01810872f, 0.03601198f, -0.05308894f, -0.03938631f, -0.05343914f, 
    0.03300220f, -0.04913445f, -0.02174067f, -0.00357441f, 0.01021581f, -0.02482285f, 0.01145268f, 0.04897866f, 
    -0.01365077f, 0.00060627f, -0.01429519f, 0.00868767f, 0.02978016f, -0.03893997f, 0.04667551f, 0.04779465f, 
    -0.00445366f, -0.00741971f, 0.03874853f, -0.05244829f, -0.01025294f, -0.00367113f, -0.00270371f, -0.05045589f, 
    0.03695492f, -0.05372418f, -0.05418835f, 0.02896259f, 0.00752549f, 0.00276099f, -0.01482203f, 0.03686521f, 
    0.00997774f, -0.04065662f, 0.03585756f, 0.02629703f, -0.02974632f, 0.03515484f, -0.05263145f, -0.04791363f, 
    0.00305662f, -0.04834326f, 0.01241853f, -0.00785270f, 0.04243702f, 0.02199068f, 0.01640618f, -0.00589446f, 
    -0.04553337f, -0.02789273f, 0.00562339f, 0.02803175f, 0.03599260f, -0.05498197f, 0.02655515f, -0.05277845f, 
    -0.05228402f, -0.05420277f, 0.00528723f, -0.01715310f, -0.03591492f, -0.05564620f, 0.00010095f, -0.05603050f, 
    0.01496646f, -0.03906628f, -0.00559817f, -0.04072083f, 0.01230561f, 0.01352724f, -0.01473436f, -0.03574149f, 
    0.04408813f, -0.01339879f, -0.02239868f, 0.00886490f, 0.02097072f, 0.02768298f, -0.03487866f, 0.03640321f, 
    0.02280382f, 0.04265548f, -0.00085455f, -0.05111959f, -0.04255585f, 0.04360434f, 0.02590015f, -0.05853556f, 
    0.03377734f, -0.03418574f, -0.01945958f, -0.03592784f, 0.05007893f, 0.00926064f, -0.05413108f, 0.04824853f, 
    0.00925662f, 0.03603184f, -0.01752756f, -0.02098814f, -0.03376547f, 0.00714608f, 0.01162096f, -0.00253757f, 
    -0.05286895f, -0.00153944f, 0.01618557f, 0.04237787f, -0.03321011f, -0.05417590f, -0.05164416f, -0.03607887f, 
    0.02760133f, 0.04787286f, -0.03253236f, 0.04041783f, 0.02013613f, -0.03979140f, -0.01847877f, 0.04162067f, 
    -0.05353474f, -0.01767453f, 0.03917805f, -0.00323732f, 0.03383759f, -0.04745717f, 0.03189301f, -0.05602246f, 
    -0.05542917f, 0.01177451f, -0.03374693f, 0.01488422f, -0.00333924f, 0.01785756f, 0.02527823f, -0.05413436f, 
    0.03311091f, 0.04753850f, -0.02470714f, -0.01306885f, -0.01180817f, 0.01163192f, 0.04318027f, 0.00255106f, 
    -0.04424880f, -0.05715238f, -0.04051308f, 0.00833506f, -0.04311482f, -0.05856964f, -0.03104691f, -0.02037103f, 
    -0.01414156f, 0.02889437f, 0.02513919f, -0.05126570f, 0.04815590f, -0.04511078f, -0.01842708f, -0.05072566f, 
    0.00755668f, 0.04205118f, 0.00988192f, -0.01444767f, 0.00792735f, -0.01952131f, 0.04951483f, -0.03920424f, 
    0.39591271f, -0.15332094f, 0.27548268f, -0.05104562f, 0.01658400f, -0.08141323f, 0.07302418f, 0.03192993f, 
    -0.06118057f, 0.05515536f, 0.18396521f, 0.01277031f, 0.11988910f, 0.01628491f, -0.00974483f, 0.12220674f, 
    -0.05125403f, -0.03349756f, -0.02262109f, 0.01987489f, -0.03538464f, -0.01024152f, 0.05170257f, -0.09472899f, 
    -0.02635984f, 0.08245400f, 0.05259455f, 0.10957709f, 0.04711395f, 0.04698486f, 0.10200767f, -0.02906460f, 
    -0.06078282f, 0.00994696f, 0.04424071f, 0.14029865f, -0.07423157f, 0.09892530f, 0.12472451f, 0.01712089f, 
    0.23315671f, 0.34578669f, 0.16768767f, 0.06551713f, 0.01534344f, 0.07980454f, 0.04544597f, 0.08176786f, 
    0.12871957f, -0.07100952f, 0.03190688f, -0.02458265f, 0.17063645f, 0.04285463f, 0.08459843f, -0.04357614f, 
    -0.00952763f, 0.05822235f, 0.02537204f, -0.01720104f, 0.24119064f, 0.04264481f, 0.21979076f, 0.02948169f, 
    0.03176092f, -0.02410656f, 0.17211349f, 0.06838930f, -0.13050257f, 0.00850519f, 0.14955820f, 0.04937961f, 
    0.02603092f, 0.00744162f, 0.22112560f, 0.06400709f, 0.18685523f, -0.01425859f, -0.06317466f, 0.04068213f, 
    0.05947402f, -0.50267065f, -0.34984675f, 0.20779659f, 0.00349515f, 0.29826352f, 0.01285566f, -0.09004945f, 
    -0.07031269f, 0.06339931f, 0.04417366f, -0.03406160f, -0.04123015f, -0.12062750f, -0.01777622f, 0.02713747f, 
    0.10475882f, 0.01148839f, -0.01745167f, 0.07606421f, -0.52631128f, -0.23344013f, -0.11015345f, 0.01331638f, 
    -0.18315929f, 0.02253278f, -0.07939671f, 0.04232299f, -0.04654170f, 0.07178043f, 0.15630724f, -0.05435477f, 
    -0.08913900f, 0.10710528f, 0.01306925f, -0.00622107f, 0.01075502f, 0.10907385f, 0.00125954f, 0.14679499f, 
    -0.27215204f, -0.04513115f, -0.12631109f, -0.18512233f, -0.33208445f, 0.04255873f, -0.06372181f, 0.00103653f, 
    -0.03434077f, 0.03221128f, 0.08937817f, -0.00295689f, 0.15563090f, 0.06241680f, 0.05646642f, 0.13259132f, 
    0.04704772f, 0.12598145f, 0.00027158f, 0.08664840f, 0.27517420f, -0.16544408f, 0.25879708f, 0.10972082f, 
    0.03859043f, 0.01499290f, 0.11521140f, -0.02898076f, -0.05001412f, -0.09390189f, -0.04258781f, 0.01328029f, 
    0.08940964f, 0.15275112f, 0.10282250f, -0.12856531f, 0.03139375f, -0.01056102f, 0.08192649f, -0.06100611f, 
    -0.09712737f, -0.07559796f, -0.17844994f, -0.35317072f, -0.09366003f, 0.11935461f, 0.14754884f, -0.04401077f, 
    0.05584393f, -0.08782777f, 0.01133725f, -0.08033427f, 0.13856815f, 0.08275757f, 0.14693908f, -0.04497281f, 
    0.13613912f, 0.09822555f, 0.08768538f, -0.05483995f, -0.16087225f, -0.08997609f, 0.05825039f, -0.12732656f, 
    -0.16366433f, -0.02085029f, 0.14220051f, 0.06440868f, 0.09606514f, -0.05363804f, 0.06960206f, 0.08407833f, 
    -0.03247074f, 0.12900952f, 0.13479051f, 0.11388075f, 0.21035682f, 0.06411356f, -0.06630380f, -0.05104592f, 
    -0.11800775f, -0.26401547f, -0.32994759f, -0.00821855f, -0.10563309f, -0.01596740f, 0.09402313f, -0.07203738f, 
    0.16049568f, 0.06397028f, 0.03128550f, -0.08246331f, 0.11952569f, -0.10229013f, 0.06139934f, -0.00156311f, 
    -0.01578237f, 0.01628227f, -0.00832997f, 0.33874449f, 0.34874851f, 0.32165074f, 0.05787560f, 0.06847087f, 
    -0.12454308f, 0.06767903f, 0.09066620f, 0.05479144f, -0.03083926f, -0.12615703f, 0.10447951f, 0.14328331f, 
    0.06071338f, 0.04591694f, 0.06133183f, 0.10719528f, 0.06423254f, 0.08210067f, 0.21565451f, 0.04041908f, 
    0.19928057f, 0.22672538f, 0.16953240f, 0.10316423f, 0.13025767f, 0.19299698f, 0.02886550f, 0.10513067f, 
    0.06946404f, 0.11998530f, 0.14246158f, 0.16578020f, -0.01180833f, 0.00465198f, 0.03023796f, 0.10098912f, 
    -0.10416014f, 0.07220144f, 0.03539786f, 0.06178737f, -0.19808675f, -0.04627938f, -0.26817241f, 0.06880266f, 
    -0.29341272f, -0.02723316f, -0.07740937f, -0.01070253f, 0.07128619f, 0.01206635f, -0.04589601f, 0.05678917f, 
    -0.08503295f, 0.01025248f, 0.14408606f, 0.09035640f, -0.10516278f, -0.06127572f, -0.05641885f, 0.15095903f, 
    0.26767936f, -0.13863982f, -0.10040805f, -0.21835600f, -0.04711442f, 0.08628633f, -0.01828288f, -0.05013557f, 
    0.11223581f, 0.29980800f, -0.06601609f, 0.04217391f, -0.10406958f, -0.07055309f, 0.09604688f, 0.01882868f, 
    0.09883048f, -0.02971152f, -0.07364560f, 0.08672477f, 0.52433527f, 0.26569209f, 0.12827021f, -0.00049490f, 
    0.05901169f, 0.17377909f, 0.10664673f, 0.05265692f, -0.09016100f, 0.04789326f, -0.01630205f, -0.07936693f, 
    0.28924552f, 0.00769350f, 0.06390100f, 0.05654511f, -0.01226108f, 0.03642622f, -0.00395955f, 0.00727615f, 
    0.03094386f, -0.04811812f, -0.00134013f, -0.00640131f, -0.04665310f, -0.03166519f, -0.02637066f, 0.01478951f, 
    -0.03443890f, -0.06250334f, -0.05992707f, -0.00496359f, -0.01654494f, 0.01156397f, -0.02094882f, 0.02872351f, 
    0.03965801f, 0.04010899f, 0.00740458f, -0.02321976f, 0.00252823f, -0.05071636f, -0.00127091f, -0.04028319f, 
    -0.00280519f, -0.01876511f, -0.00061812f, 0.00511632f, -0.00593489f, -0.05436736f, 0.05226849f, 0.02167923f, 
    -0.00318181f, -0.02699737f, -0.00318191f, 0.02274082f, -0.02079915f, -0.01010779f, 0.04671668f, -0.04054256f, 
    -0.05211992f, 0.02570970f, 0.00970514f, -0.05459745f, 0.00551030f, -0.00599061f, -0.02342774f, 0.04735422f, 
    0.02026280f, 0.00728049f, 0.01612172f, -0.00119236f, 0.04165383f, 0.01481958f, -0.02984438f, 0.03874741f, 
    0.04743602f, -0.02251213f, -0.06141660f, 0.03711884f, -0.01983650f, -0.02454357f, -0.02350348f, 0.04688288f, 
    -0.00318966f, -0.04881032f, 0.04448391f, -0.03900459f, -0.03396937f, 0.01329143f, 0.01642515f, -0.01435886f, 
    0.04419417f, 0.01724343f, -0.03336994f, -0.02625690f, -0.03261489f, -0.05196911f, 0.03314510f, 0.02776377f, 
    0.03218542f, -0.02948409f, -0.03771693f, 0.01316591f, 0.01426132f, -0.04817776f, 0.00373398f, 0.03444511f, 
    0.02976204f, -0.02617928f, -0.04676411f, 0.03556315f, 0.01782100f, -0.03325817f, 0.03378826f, 0.04923166f, 
    0.02627486f, 0.00845135f, -0.02889205f, -0.05147954f, -0.00221202f, -0.02630043f, -0.03291165f, -0.05200361f, 
    -0.01103042f, 0.03252703f, 0.00474880f, 0.00081670f, 0.03637818f, -0.04388514f, 0.00122423f, 0.02075911f, 
    0.01022621f, -0.06413990f, -0.04302768f, -0.04443444f, -0.02504381f, -0.02226580f, 0.00511257f, 0.01990469f, 
    -0.03622064f, -0.00444046f, 0.00256666f, -0.05432797f, 0.01777888f, -0.04817823f, -0.00806800f, -0.02451638f, 
    0.05084325f, 0.00292567f, 0.01606446f, 0.05285467f, -0.03835990f, -0.03705825f, 0.02582205f, 0.03810287f, 
    -0.03331884f, 0.03383988f, -0.01690564f, -0.05271893f, 0.01712537f, -0.02238213f, -0.04461759f, 0.03638752f, 
    0.00551755f, 0.01975459f, -0.01796377f, -0.01501162f, -0.00963059f, -0.01007784f, 0.02405073f, 0.02772244f, 
    -0.01345617f, -0.02454944f, -0.06122679f, 0.05122312f, 0.03296331f, 0.03120665f, -0.02772145f, 0.00564771f, 
    -0.02064513f, -0.03301195f, -0.02740530f, 0.01500348f, 0.02369773f, 0.05087493f, -0.00871279f, -0.05585935f, 
    0.04475020f, 0.00611080f, -0.03645995f, -0.00296036f, -0.05256406f, -0.05108818f, 0.02195328f, -0.02557281f, 
    -0.04924468f, -0.04949161f, 0.04980201f, -0.04593126f, -0.00248251f, -0.03176912f, -0.05139928f, -0.01554931f, 
    0.04467873f, -0.02105208f, -0.02918898f, 0.01193319f, -0.02011814f, 0.02841217f, -0.04941671f, 0.02858934f, 
    -0.05669704f, 0.03741557f, -0.04460064f, 0.04344326f, -0.03144220f, -0.00496898f, 0.03075295f, -0.01986355f, 
    0.03485714f, 0.00571640f, -0.01246588f, 0.02475880f, -0.04112334f, 0.04533007f, -0.03529642f, -0.06091376f, 
    0.02816730f, -0.04797995f, -0.02364081f, 0.03125333f, -0.03181633f, -0.04203953f, 0.00336966f, 0.04312269f, 
    0.00653257f, 0.04317233f, -0.00929612f, 0.00480171f, 0.01926962f, 0.03592224f, -0.06315579f, -0.04140572f, 
    0.01354953f, 0.03685030f, -0.00396128f, 0.03761570f, 0.00696846f, -0.00335841f, 0.00591656f, -0.02916068f, 
    -0.04930311f, -0.04564247f, 0.04679177f, -0.02360714f, 0.01732879f, 0.00944929f, 0.03812138f, 0.01190699f, 
    0.02060122f, -0.01375363f, 0.04490293f, -0.05320929f, -0.00738718f, 0.04871096f, 0.01565641f, 0.00492229f, 
    -0.06335504f, 0.04148619f, -0.02352120f, -0.02802132f, -0.01100114f, -0.02109077f, 0.02012719f, -0.02303421f, 
    -0.04034956f, 0.00098652f, 0.01031284f, -0.03958871f, 0.02621896f, -0.04225786f, -0.01631162f, -0.01382395f, 
    0.00294747f, 0.00563448f, 0.00355920f, 0.04540424f, 0.04736876f, 0.01963671f, -0.04278661f, 0.01672257f, 
    -0.00550892f, -0.02254223f, 0.04931164f, 0.02523957f, 0.00848683f, -0.00385065f, -0.02398227f, -0.03564783f, 
    0.03881190f, -0.04813347f, -0.00720593f, -0.05895395f, -0.02805020f, -0.02843582f, -0.02401861f, -0.05423025f, 
    0.03876995f, 0.02094615f, 0.04152616f, -0.00032033f, 0.01324713f, -0.01170036f, 0.00642549f, -0.05029039f, 
    0.03051708f, -0.03580556f, -0.03268776f, -0.00412231f, -0.06000602f, -0.05451097f, -0.03862291f, -0.00187237f, 
    0.04299529f, -0.04782699f, 0.02983113f, -0.03555998f, -0.02994990f, -0.01507505f, -0.06268539f, -0.04469902f, 
    0.00256322f, -0.06564443f, 0.00970987f, -0.01811798f, -0.02157495f, -0.03112414f, 0.02572191f, 0.00626852f, 
    -0.02125796f, -0.03600506f, -0.03966387f, -0.00191779f, -0.05258662f, -0.04634149f, -0.06237294f, -0.02614469f, 
    -0.04789709f, -0.02611999f, 0.01951432f, -0.03603201f, 0.04569764f, -0.00251427f, -0.02136594f, 0.03283835f, 
    -0.00278864f, -0.00884574f, 0.01609921f, -0.03305263f, 0.01945712f, 0.02069943f, 0.04063407f, 0.03739845f, 
    0.00238919f, -0.01903197f, 0.00457804f, -0.03343084f, -0.00643709f, -0.05653616f, 0.04406940f, 0.02763976f, 
    -0.03199464f, 0.00344355f, -0.05508717f, 0.02633151f, -0.00049666f, 0.02034942f, -0.02620607f, -0.02282011f, 
    -0.05990798f, -0.03814101f, -0.03310869f, -0.02705644f, 0.03677365f, -0.04132143f, -0.00979489f, -0.02749876f, 
    0.04475405f, 0.03248176f, -0.05638915f, 0.03588195f, -0.00641571f, 0.03335504f, 0.01779267f, -0.05558947f, 
    0.02624389f, -0.00255257f, 0.00758319f, -0.05959089f, -0.05284616f, -0.06113176f, 0.04669064f, 0.02582252f, 
    0.01084873f, 0.00900509f, 0.00739651f, 0.04240295f, 0.01893088f, -0.06051216f, -0.01737187f, -0.04363561f, 
    0.00106964f, 0.00653206f, -0.05282264f, -0.03582900f, -0.06152516f, -0.05870055f, -0.03702272f, -0.03530407f, 
    -0.01375909f, -0.04211575f, -0.03735836f, 0.00323567f, 0.03780366f, -0.05566379f, -0.01898594f, -0.06063373f, 
    -0.01193170f, 0.01402384f, -0.03940558f, -0.01407861f, -0.00968183f, -0.02435479f, -0.02902501f, -0.00665773f, 
    -0.03824390f, -0.03034367f, -0.02947653f, -0.03400552f, -0.05240536f, -0.00819825f, 0.00742429f, -0.01097822f, 
    -0.04212054f, -0.04240995f, 0.02373489f, -0.00415991f, 0.04404360f, 0.03031772f, -0.05402863f, -0.01316812f, 
    -0.02242895f, 0.04148731f, 0.02430567f, 0.01739850f, -0.03828397f, 0.01477545f, 0.03177164f, -0.03501206f, 
    -0.02633897f, 0.02620368f, 0.00723183f, 0.00850651f, -0.04868262f, 0.00273241f, -0.05804299f, -0.01312363f, 
    0.02516695f, 0.02543406f, 0.02271544f, 0.05518778f, -0.06124085f, -0.00140616f, 0.00015310f, -0.05584792f, 
    -0.01666548f, 0.02326789f, 0.02193230f, -0.02119895f, -0.04343738f, 0.04522217f, -0.01089444f, -0.01627063f, 
    -0.06405354f, -0.05421141f, -0.01891849f, -0.01899287f, -0.04720610f, 0.03988344f, 0.03282904f, 0.00940269f, 
    -0.02700566f, -0.01957797f, -0.04478251f, -0.01757435f, 0.04821284f, -0.05488754f, 0.01094351f, 0.04678077f, 
    0.01828302f, 0.04025871f, 0.02149228f, -0.05060912f, -0.01212459f, 0.05672187f, -0.04743438f, 0.03559383f, 
    0.04384930f, -0.02943121f, 0.04868088f, -0.05925233f, 0.04817160f, -0.02793746f, 0.04964063f, -0.05341165f, 
    -0.01411833f, 0.03583536f, 0.01759091f, 0.02828879f, 0.00679755f, 0.02018297f, -0.04400507f, 0.00181020f, 
    -0.01128003f, 0.01795260f, 0.04330439f, -0.00036823f, 0.02394651f, 0.00417653f, -0.02423324f, 0.03769376f, 
    0.00385049f, -0.05181789f, -0.02722688f, 0.01738345f, 0.01409291f, -0.05482406f, -0.02723851f, 0.04830635f, 
    0.00625752f, -0.00888474f, 0.03962753f, 0.01440274f, -0.02583931f, -0.03606532f, 0.03130855f, -0.01879410f, 
    -0.02299782f, 0.03072368f, -0.01805983f, -0.03398010f, -0.00088813f, -0.02694573f, -0.00748698f, 0.04729998f, 
    -0.03525899f, 0.03799224f, -0.01440491f, -0.02749747f, -0.00191179f, 0.05217370f, 0.04083182f, 0.04380046f, 
    0.02941566f, 0.03288875f, -0.05063839f, -0.00626477f, -0.01232132f, 0.01837676f, 0.01214878f, 0.00848366f, 
    -0.02441116f, 0.03897289f, -0.01213239f, 0.00409401f, 0.03933781f, 0.04561699f, -0.01231447f, -0.01714547f, 
    -0.01131085f, 0.02599509f, 0.02494921f, -0.03608088f, 0.04191332f, -0.05132678f, 0.03611656f, 0.03755755f, 
    -0.03188193f, -0.03360847f, -0.04964896f, 0.01964832f, 0.01785260f, 0.01373082f, -0.04806393f, -0.02187550f, 
    0.02086851f, -0.03115373f, -0.03971007f, -0.03034917f, 0.01444654f, -0.02083558f, -0.00227313f, 0.05755067f, 
    0.03491784f, -0.02083356f, 0.00313295f, -0.06332149f, -0.03606138f, -0.01333966f, -0.01684810f, 0.01332241f, 
    0.00042288f, 0.03478551f, 0.04264772f, -0.01041652f, 0.02062198f, -0.03287787f, 0.04449981f, -0.03348799f, 
    -0.01901112f, 0.02411247f, -0.04874501f, -0.06144507f, -0.01461213f, -0.01005274f, -0.00604320f, 0.00753536f, 
    0.00703934f, -0.02212101f, 0.04842908f, 0.02916595f, -0.02525055f, -0.01918418f, 0.01478303f, 0.00947886f, 
    -0.05581504f, 0.00480787f, -0.03045754f, 0.03243692f, -0.04001864f, 0.02450926f, -0.02753334f, 0.02622563f, 
    -0.02946302f, -0.00804081f, 0.00135953f, -0.04661493f, -0.00051425f, 0.01186851f, -0.04586118f, -0.06160109f, 
    -0.02068065f, -0.00646599f, 0.01695826f, -0.04966950f, -0.01338371f, -0.01656279f, -0.00308923f, 0.02702424f, 
    -0.59827429f, -0.04163654f, 0.22891115f, -0.07084419f, -0.02624677f, -0.12192471f, -0.05224785f, -0.05542100f, 
    -0.24384059f, 0.14891212f, -0.09007271f, 0.05930837f, 0.06209860f, 0.00775062f, 0.07137621f, 0.04766611f, 
    -0.02804677f, -0.04333100f, 0.01456338f, -0.14608188f, -0.36847743f, -0.20548636f, 0.10861769f, 0.13192213f, 
    0.29454434f, -0.11127984f, -0.11025304f, 0.20005710f, 0.03815585f, 0.06109640f, -0.02134068f, -0.02649469f, 
    0.01525655f, -0.02217260f, 0.10129754f, -0.06657616f, -0.01813554f, -0.20810236f, 0.05767903f, -0.08397940f, 
    0.52405620f, 0.12031616f, 0.11782367f, 0.06559885f, 0.07666102f, -0.15684809f, -0.14434001f, -0.01333668f, 
    0.02902475f, 0.11823519f, -0.04871710f, -0.01157946f, -0.08399763f, 0.10974354f, 0.04505348f, -0.10300696f, 
    -0.04516812f, -0.00388641f, 0.02603879f, 0.05716805f, 0.47912210f, -0.00444370f, 0.14972207f, -0.14649601f, 
    0.21058913f, -0.13597579f, -0.06567153f, -0.02239477f, -0.03960269f, 0.16182798f, -0.03616105f, -0.04495484f, 
    -0.00950179f, 0.07854569f, 0.01645399f, 0.14545716f, 0.01433208f, -0.10256267f, 0.04750400f, -0.02033786f, 
    -0.31128418f, 0.12788898f, -0.22448565f, -0.11964278f, -0.04285680f, -0.03871153f, 0.10134922f, -0.00545906f, 
    0.10022617f, 0.14155512f, -0.02758282f, 0.05865641f, -0.00992463f, -0.09140939f, -0.02878939f, -0.07845671f, 
    -0.01203197f, -0.02053271f, 0.05034735f, -0.02883860f, -0.13249825f, -0.23764220f, 0.00351749f, 0.18996190f, 
    0.09798745f, -0.01973241f, 0.06357397f, -0.03785552f, 0.07674996f, 0.06584302f, -0.15579942f, 0.15784539f, 
    0.00226193f, 0.10130404f, 0.11491703f, -0.00729750f, -0.09619489f, 0.02748412f, -0.14343487f, -0.06678450f, 
    -0.09081131f, 0.29299071f, -0.44603905f, 0.33961269f, -0.08739084f, 0.05660053f, 0.07336794f, 0.09213619f, 
    0.08862807f, 0.18571812f, -0.04530869f, -0.05620542f, 0.02388329f, -0.00571597f, 0.00609021f, 0.03243694f, 
    0.04762486f, -0.02683207f, -0.21110439f, 0.02657548f, 0.18598101f, -0.04053622f, 0.26673511f, -0.02666620f, 
    0.22041272f, -0.09918359f, -0.00028635f, 0.11346500f, -0.02552889f, -0.09056728f, -0.00229026f, -0.01952349f, 
    0.24491888f, 0.01653452f, -0.01619693f, -0.00454577f, -0.00305926f, 0.01133997f, -0.00853866f, -0.01459701f, 
    0.29178551f, -0.27764693f, -0.08947631f, -0.09035999f, -0.02609070f, -0.00335333f, -0.08940606f, 0.12845545f, 
    0.00556114f, -0.00663707f, -0.00432848f, 0.03767580f, 0.11516203f, 0.17233485f, 0.07883271f, -0.11189713f, 
    -0.00040468f, -0.01090944f, 0.01142441f, 0.16013785f, -0.08958092f, -0.28697282f, -0.14611073f, 0.19470342f, 
    0.12496075f, -0.15190525f, 0.06984657f, 0.07993929f, 0.09244845f, 0.05746927f, 0.00275869f, 0.07116988f, 
    0.10626181f, 0.11974763f, 0.06081317f, 0.11464283f, 0.00893203f, -0.08578535f, 0.00162879f, -0.07975099f, 
    -0.04973717f, 0.04096443f, -0.11183701f, 0.05174461f, 0.00791698f, 0.18295367f, 0.06896853f, -0.03449609f, 
    0.11768396f, 0.10235547f, 0.05108639f, 0.02420072f, 0.03871530f, -0.13030808f, 0.13457006f, 0.06242184f, 
    -0.04351524f, -0.06357012f, -0.11634316f, 0.05730994f, 0.32587305f, -0.05726899f, 0.24384679f, -0.05596386f, 
    -0.27818540f, 0.05088773f, -0.02479978f, 0.09955993f, 0.02885720f, 0.08742590f, 0.15798037f, -0.05353112f, 
    -0.05776992f, 0.02997535f, -0.04268847f, -0.06134487f, -0.02283626f, -0.16447093f, 0.01884980f, 0.07748188f, 
    0.28538290f, 0.17092687f, 0.20299947f, 0.02189251f, 0.14824116f, -0.01636254f, 0.12686586f, -0.02371253f, 
    0.03331884f, -0.17131349f, 0.04432077f, 0.12275392f, -0.04145513f, 0.04820759f, 0.08871349f, 0.06674093f, 
    0.11919948f, -0.02310885f, -0.04256707f, 0.08702122f, -0.15476972f, 0.22591327f, -0.28050730f, 0.23596583f, 
    -0.06051164f, 0.12021981f, 0.14697511f, -0.12211299f, 0.13796954f, 0.10531906f, -0.00073598f, -0.05832795f, 
    -0.00182105f, 0.08701661f, -0.03742959f, 0.14791532f, 0.03557298f, 0.13974129f, -0.03456055f, -0.19611444f, 
    -0.16269635f, 0.31354564f, -0.31716844f, 0.09162635f, -0.40960765f, 0.39738512f, 0.16119872f, -0.05017363f, 
    -0.13788518f, 0.07403276f, 0.08605424f, -0.00755186f, -0.01663037f, 0.05331002f, -0.05771930f, 0.17929052f, 
    0.06791937f, 0.02033835f, -0.02162151f, 0.06070342f, 0.27820557f, -0.19073381f, 0.25272056f, -0.10317115f, 
    0.06261811f, -0.13733515f, 0.08616883f, -0.20489949f, 0.05650807f, -0.06506553f, 0.13357966f, -0.01070505f, 
    -0.04056453f, -0.05460414f, 0.03219500f, -0.06083131f, -0.01884812f, -0.04599861f, -0.12086742f, -0.01474551f, 
    0.08243670f, 0.36947301f, 0.22805530f, -0.11781005f, -0.01960018f, 0.11301290f, -0.12395543f, -0.04535984f, 
    0.12278818f, -0.07338445f, -0.07074432f, 0.13798411f, -0.15832658f, 0.09781844f, 0.03398918f, -0.04409426f, 
    0.00095446f, -0.08299381f, -0.20740989f, -0.21853085f, -0.06415559f, -0.02179031f, 0.13327688f, 0.01761786f, 
    -0.19111599f, -0.19297472f, 0.16112086f, 0.03104157f, -0.03372331f, 0.04562758f, -0.16498584f, -0.17158410f, 
    -0.10635925f, 0.03383721f, -0.00040635f, -0.07646058f, -0.10697275f, 0.03272001f, 0.03430535f, 0.05210309f, 
    0.06998447f, -0.42792973f, 0.27922344f, 0.29361114f, 0.09060659f, -0.25836620f, -0.04625504f, 0.09379496f, 
    -0.03044927f, 0.10372699f, -0.10360926f, -0.01445575f, 0.05371840f, -0.17939603f, 0.07574473f, -0.07649179f, 
    0.04275703f, 0.06192401f, 0.04345549f, -0.05849664f, 0.06336405f, 0.20650889f, 0.04169197f, 0.07141775f, 
    0.15231366f, -0.14339392f, 0.00633586f, 0.05491804f, -0.07763617f, 0.15006100f, 0.07579482f, -0.02047860f, 
    -0.02343468f, -0.22837749f, -0.02126878f, 0.00703502f, 0.12233775f, 0.00632765f, -0.08645187f, 0.08033853f, 
    -0.26479170f, 0.13624242f, -0.05747383f, 0.05977446f, -0.09970178f, 0.05479082f, 0.04076432f, 0.00271873f, 
    0.05850385f, -0.06388304f, -0.05418954f, 0.10776355f, 0.09980337f, -0.07698576f, -0.05327106f, -0.12318332f, 
    0.01323749f, -0.09242690f, 0.11485580f, 0.05396445f, 0.00871852f, 0.03724850f, -0.26584873f, 0.20553133f, 
    -0.27127603f, 0.05431053f, 0.02359286f, -0.08913127f, -0.05289024f, 0.08135588f, -0.11828153f, 0.04391950f, 
    0.07094678f, 0.11304022f, 0.03363691f, 0.03971630f, -0.12588689f, 0.09508885f, -0.01526659f, -0.02273639f, 
    0.35713723f, -0.16479926f, -0.07929472f, -0.13494240f, -0.08723923f, 0.27859530f, -0.08620395f, 0.01111021f, 
    -0.05933278f, 0.12306409f, 0.07086071f, 0.00028802f, -0.01367474f, -0.02949071f, -0.07928762f, 0.00312807f, 
    0.03368885f, 0.02009899f, 0.24132268f, -0.03076977f, 0.34097415f, -0.18064931f, 0.14366381f, 0.20676480f, 
    -0.01452952f, -0.05815821f, -0.15029927f, 0.19916239f, 0.13622054f, -0.14000741f, -0.02581144f, 0.08213182f, 
    -0.04316764f, 0.16627060f, 0.07149930f, 0.08527815f, 0.17762898f, -0.04233908f, -0.01235051f, -0.08667773f, 
    0.12898989f, 0.01496727f, 0.10953470f, 0.20710984f, -0.31821471f, -0.03089353f, 0.08844013f, -0.03775446f, 
    0.02773974f, 0.11125543f, -0.01770681f, 0.03577477f, 0.00685207f, 0.06306186f, 0.00867268f, -0.08821585f, 
    0.08449392f, 0.24447949f, 0.09235542f, 0.03844504f, -0.19776833f, -0.06524090f, 0.14084867f, 0.42410120f, 
    0.05047781f, -0.16403177f, 0.17342289f, 0.14497925f, 0.11705002f, -0.07127850f, 0.11138063f, 0.07942847f, 
    0.12028421f, -0.17347617f, 0.28564775f, 0.06236477f, 0.12967578f, 0.11562249f, 0.03519898f, 0.13639821f, 
    -0.26688352f, 0.05338304f, -0.01546314f, 0.01507358f, 0.00190311f, 0.03303809f, 0.02408827f, 0.01799999f, 
    0.12691748f, -0.02185058f, -0.00266240f, -0.01168278f, -0.01135876f, 0.08045116f, 0.03846095f, -0.09031636f, 
    -0.02122076f, -0.01098619f, 0.15017697f, 0.07277680f, 0.40917519f, -0.05208559f, -0.11823819f, 0.05773016f, 
    -0.22073391f, 0.02780278f, 0.18785760f, 0.12031207f, -0.00876404f, -0.22007814f, -0.02366847f, 0.03858694f, 
    -0.03934597f, 0.14845389f, -0.04326240f, -0.00455909f, -0.03728768f, -0.07694007f, -0.07856701f, 0.03967018f, 
    -0.02359980f, 0.17307763f, -0.01885929f, 0.07219040f, 0.26132104f, 0.04213899f, -0.04488458f, -0.07203480f, 
    0.08124363f, 0.06925859f, 0.02762914f, -0.07046163f, 0.07729465f, 0.05209855f, 0.04598323f, 0.18821539f, 
    0.11536334f, 0.05419708f, -0.09749465f, 0.07813956f, -0.37951535f, -0.04729803f, -0.44212723f, 0.06771798f, 
    -0.00758616f, -0.02708209f, -0.00002750f, 0.05658634f, 0.09106211f, 0.09025047f, 0.04295862f, 0.02002709f, 
    -0.05574143f, 0.09916872f, 0.00896396f, 0.10441114f, -0.00826089f, 0.03373797f, 0.11751943f, -0.05308040f, 
    -0.36577329f, 0.00514470f, -0.20456941f, 0.06436631f, -0.01496914f, 0.27572942f, 0.01220055f, 0.03935300f, 
    -0.07694928f, 0.07923293f, 0.01008648f, -0.04053684f, -0.02528212f, 0.10847471f, 0.11555918f, 0.10042049f, 
    -0.00356988f, 0.11352040f, 0.10870324f, 0.04835211f, -0.17718488f, -0.09810158f, 0.38278207f, -0.10861035f, 
    0.30958354f, -0.01754437f, 0.00770458f, 0.11916092f, 0.06932983f, -0.03152670f, -0.00927877f, 0.00346461f, 
    -0.14794771f, -0.08241417f, -0.04821254f, -0.07329173f, 0.05988203f, -0.04680943f, 0.05556828f, 0.13280761f, 
    0.07140423f, -0.21616961f, 0.13566712f, 0.29228798f, 0.20115624f, -0.06902313f, -0.02668037f, 0.01476961f, 
    0.02567355f, 0.05463357f, 0.06111942f, 0.17921874f, -0.06610847f, 0.07627183f, -0.02378880f, 0.02200789f, 
    0.01357774f, -0.07002576f, -0.02096280f, -0.00652418f, 0.36848557f, -0.35538810f, 0.07772323f, 0.24665436f, 
    0.20362251f, 0.05049773f, 0.18426166f, -0.12234756f, -0.07844807f, 0.01482593f, 0.01322646f, -0.04577221f, 
    -0.13603243f, 0.10653336f, -0.01466091f, 0.10965521f, 0.09056549f, 0.17409831f, -0.17288835f, -0.06194421f, 
    0.37941396f, 0.38110161f, 0.17744620f, -0.20219110f, 0.04620247f, 0.01252038f, 0.06085065f, -0.09251479f, 
    0.02032774f, 0.10304414f, 0.13177949f, 0.13366315f, 0.12796172f, -0.11545351f, 0.10422841f, 0.15669104f, 
    0.13099663f, -0.11798349f, 0.12618761f, 0.07607105f, 0.45447305f, 0.00595440f, -0.06123614f, -0.04992737f, 
    -0.03742642f, -0.06934769f, -0.01553726f, 0.05629527f, 0.07218958f, -0.03891120f, 0.08687765f, 0.19937497f, 
    -0.00987985f, 0.14308374f, 0.02755093f, 0.09466321f, 0.04445447f, 0.12631616f, -0.15027864f, 0.10270370f, 
    0.22562031f, 0.09302798f, 0.29390728f, 0.22192796f, 0.12218408f, -0.08543950f, -0.03530654f, 0.17295709f, 
    0.12096641f, -0.20309928f, -0.08679888f, 0.04666487f, 0.16168831f, -0.01014087f, 0.00771201f, 0.03047974f, 
    -0.13392316f, -0.03079139f, -0.17578876f, 0.17755668f, 0.03510714f, -0.11457390f, 0.06809744f, 0.15705158f, 
    0.33327293f, 0.16997612f, -0.12457187f, 0.07787275f, -0.05520406f, -0.06245982f, 0.00144706f, 0.05592739f, 
    0.08299699f, -0.01764360f, -0.04085036f, 0.00129847f, 0.13124306f, -0.00784539f, 0.03279128f, 0.08390131f, 
    -0.34510869f, 0.11500900f, -0.16404516f, 0.20147599f, 0.07149319f, -0.01362330f, 0.00036663f, -0.04627998f, 
    0.07025581f, -0.02538631f, 0.07305399f, 0.06414977f, 0.01231373f, -0.04046013f, 0.12093781f, 0.01707193f, 
    -0.02475677f, -0.05866528f, 0.30752116f, 0.06816687f, -0.40227661f, -0.06183102f, -0.00859289f, 0.11669504f, 
    0.04993111f, -0.10949332f, 0.02530840f, 0.12294810f, -0.04281280f, 0.22100613f, 0.08439638f, -0.14300075f, 
    -0.08945617f, 0.16673321f, 0.06742997f, 0.00819805f, 0.05539294f, -0.15212189f, -0.15923515f, 0.03749105f, 
    0.37407550f, 0.03655763f, 0.11893098f, 0.28611603f, 0.17226514f, 0.09832813f, -0.07521769f, 0.04625063f, 
    0.02082436f, 0.09217975f, -0.14546616f, -0.01707062f, -0.02184626f, 0.02676475f, -0.01498904f, 0.29791287f, 
    -0.01387521f, 0.09496234f, 0.23859620f, 0.20053867f, 0.04247181f, -0.24105449f, -0.16040045f, 0.06452720f, 
    0.03146307f, -0.02180613f, -0.01267504f, 0.11130180f, 0.06048214f, -0.06891032f, -0.01016489f, -0.11179700f, 
    -0.05481277f, -0.14063156f, 0.04469889f, 0.08953892f, 0.06292657f, 0.06001896f, 0.30117795f, 0.11389399f, 
    -0.08813195f, 0.40449020f, -0.21587658f, -0.13359872f, -0.02283327f, 0.02131667f, -0.04841862f, 0.02807831f, 
    0.07334553f, -0.10085433f, -0.01865840f, -0.00116960f, 0.03984411f, 0.04557501f, 0.12966658f, -0.05496831f, 
    -0.01042575f, -0.01764528f, 0.03323120f, -0.07113875f, 0.02994539f, -0.38677087f, -0.21758473f, -0.00950429f, 
    -0.04203071f, -0.05591210f, 0.04001094f, 0.10217322f, 0.01196695f, 0.15156339f, -0.01299208f, 0.19829328f, 
    -0.06922740f, 0.03767444f, 0.17374852f, -0.05290662f, -0.01748714f, 0.01082111f, -0.14951715f, -0.04296608f, 
    -0.65199202f, -0.31237450f, -0.06461161f, -0.05625778f, 0.03064486f, 0.10373513f, 0.13482037f, 0.17965439f, 
    0.04640709f, 0.15116346f, 0.02179743f, 0.12978038f, 0.07302273f, 0.10496085f, 0.04715446f, -0.05242373f, 
    0.03103922f, 0.01086121f, -0.21349886f, 0.06751314f, -0.55735284f, 0.50468653f, -0.24537395f, -0.05591756f, 
    -0.05837050f, -0.05923833f, -0.14751641f, 0.09597444f, -0.04163744f, -0.09736535f, 0.08794510f, -0.00140694f, 
    0.03697473f, 0.01643726f, -0.00674075f, 0.05515438f, 0.00904043f, -0.08190870f, 0.18423425f, 0.07876820f, 
    0.26845959f, -0.21217799f, -0.00271875f, -0.20045999f, -0.23168890f, 0.00621153f, 0.14987054f, 0.09327408f, 
    -0.02149234f, -0.12804651f, -0.05156972f, 0.10971756f, 0.07665565f, 0.20411097f, -0.10749869f, 0.01181260f, 
    0.00606249f, -0.01522924f, -0.08807009f, -0.00719851f, -0.23230115f, 0.00350834f, 0.19605705f, 0.10261255f, 
    0.09342590f, 0.17154226f, 0.17465255f, 0.17114592f, 0.07841781f, -0.02276517f, -0.05311188f, 0.12240760f, 
    0.05843897f, -0.10923671f, 0.09537711f, -0.17072207f, 0.11754429f, 0.09236621f, -0.15890184f, -0.15060946f, 
    0.10463994f, -0.16347407f, -0.16506754f, 0.22351891f, 0.16985808f, 0.06163419f, -0.02347031f, 0.03835037f, 
    0.01918007f, 0.13102397f, 0.03774028f, -0.02118418f, 0.01802246f, -0.12695925f, -0.12009292f, 0.10234278f, 
    -0.01808423f, 0.02055549f, 0.10425243f, 0.03511855f, 0.19038719f, 0.20539731f, -0.01343439f, 0.01687790f, 
    0.36211509f, 0.16873446f, -0.02153079f, 0.21860074f, 0.18432096f, -0.05317765f, 0.00277420f, 0.14158852f, 
    -0.00777851f, -0.07655484f, -0.07672375f, 0.10035644f, 0.09595494f, 0.09939212f, 0.06348847f, -0.10673644f, 
    0.03590225f, 0.09110013f, 0.06466027f, -0.25914705f, -0.13322929f, 0.20344003f, 0.17215900f, -0.00174748f, 
    0.13863239f, 0.02162498f, -0.01402214f, 0.00101222f, -0.01159728f, 0.12037576f, -0.13131484f, -0.02077132f, 
    -0.01143944f, 0.00821778f, -0.03642618f, -0.09684289f, -0.14186442f, -0.08394008f, -0.09666540f, 0.06410334f, 
    0.07969791f, -0.02851698f, 0.09390844f, 0.04936856f, 0.04263893f, -0.02250063f, -0.01591424f, -0.00002091f, 
    -0.11177736f, 0.18899289f, 0.02205550f, -0.10503035f, 0.00946884f, 0.00061858f, -0.05521053f, -0.08484203f, 
    0.30374914f, 0.06637073f, 0.23506330f, 0.47841978f, 0.32767463f, -0.07166396f, -0.06450942f, 0.07452010f, 
    0.08343218f, 0.10356651f, 0.12947322f, -0.07739333f, 0.04886610f, 0.10297747f, 0.18995541f, 0.04789252f, 
    0.04249422f, 0.00598550f, 0.04056211f, 0.05103949f, 0.19278942f, -0.23282304f, 0.31092346f, 0.07709537f, 
    0.46577868f, -0.00427337f, 0.17238978f, -0.02427936f, -0.00103678f, 0.14574254f, 0.01533534f, -0.10413265f, 
    0.01902060f, 0.01483006f, 0.08144774f, -0.01583746f, 0.04289060f, -0.00717069f, -0.00695195f, 0.14040570f, 
    0.27324665f, 0.07784378f, 0.08614559f, 0.17371033f, 0.05649679f, -0.04584952f, -0.00640047f, 0.19439927f, 
    0.08136255f, 0.05897471f, 0.00171094f, -0.11645368f, 0.18522002f, -0.01977886f, 0.07097033f, 0.12937701f, 
    0.09728828f, -0.01760806f, -0.00148303f, 0.00078953f, -0.35251018f, -0.38963261f, -0.02056286f, -0.08088811f, 
    -0.11210964f, -0.12941314f, 0.02371551f, -0.07313274f, 0.02729032f, -0.07268366f, 0.06132454f, -0.08504760f, 
    -0.00732035f, 0.05983099f, -0.04622058f, 0.09311286f, -0.07229444f, -0.13398542f, -0.04685135f, 0.05085059f, 
    0.19825467f, 0.06516506f, 0.07767321f, -0.16988695f, 0.07758133f, -0.04901206f, 0.10765827f, 0.11586690f, 
    0.11500052f, 0.02312262f, -0.03672202f, 0.05625641f, 0.05452774f, -0.01529048f, 0.04472522f, 0.17985469f, 
    -0.01667348f, -0.22783169f, 0.03228718f, 0.05925472f, 0.41904485f, 0.24474144f, 0.15419531f, -0.08023517f, 
    -0.01627332f, 0.07319381f, -0.04623900f, 0.07053170f, -0.19023918f, 0.07810339f, -0.02956264f, -0.10964104f, 
    0.01024868f, -0.02438561f, -0.17699873f, 0.04458907f, 0.08706427f, -0.03403237f, 0.11023581f, -0.00205444f, 
    0.44397998f, -0.24578901f, 0.01018886f, 0.00615078f, -0.16518112f, -0.00070959f, 0.02948910f, -0.02220933f, 
    0.01852075f, -0.03988623f, -0.06800681f, 0.06731046f, 0.07622168f, -0.07402770f, 0.03633640f, 0.12093142f, 
    0.11874564f, 0.00170027f, -0.06104191f, 0.07979380f, -0.24293301f, -0.22388943f, 0.08378239f, 0.09952056f, 
    -0.09417094f, -0.13849095f, 0.00678253f, 0.08110470f, 0.00481384f, -0.12243255f, -0.01995731f, 0.02782166f, 
    -0.06177733f, 0.02701128f, 0.07754304f, 0.09045836f, 0.06431782f, -0.02409535f, 0.11275038f, 0.12050515f, 
    -0.31273580f, -0.19526377f, 0.15503941f, -0.11465913f, -0.04934631f, -0.09886856f, 0.01438922f, 0.04851541f, 
    0.05382973f, -0.07480375f, -0.13691033f, 0.02069483f, -0.16633798f, 0.03400231f, -0.01727662f, -0.06835529f, 
    0.03371144f, 0.03636669f, -0.02042739f, 0.13301745f, 0.59384006f, -0.21418811f, 0.14431295f, 0.10552580f, 
    -0.14393744f, -0.13900022f, -0.00439047f, 0.01588793f, -0.02564147f, -0.02588851f, -0.08563494f, 0.09816152f, 
    0.06584899f, 0.01978603f, 0.11221242f, 0.02375939f, 0.10180963f, -0.00615588f, -0.04731014f, 0.15599464f, 
    0.61874151f, -0.03062841f, -0.03246264f, -0.02135669f, -0.25282288f, -0.11526714f, -0.00071585f, -0.06351703f, 
    0.07954392f, -0.03434858f, -0.03286052f, 0.08539071f, 0.03162950f, 0.04403861f, -0.05115698f, -0.02443576f, 
    -0.06716624f, -0.05095229f, -0.11018967f, 0.05823146f, -0.07991306f, -0.02120175f, 0.00972498f, -0.03135411f, 
    -0.02468131f, 0.04137552f, 0.10512422f, -0.09111925f, 0.11444578f, 0.18986644f, 0.01890598f, -0.00011777f, 
    0.18977129f, 0.07796738f, -0.06310967f, -0.05073212f, 0.03509277f, 0.02629224f, 0.06779955f, 0.03214831f, 
    -0.00919042f, -0.02884888f, 0.02816017f, 0.02906271f, -0.04657208f, -0.01650516f, 0.00098687f, -0.02774637f, 
    -0.06426146f, -0.05393849f, -0.05813010f, -0.03969386f, -0.02165640f, 0.00665752f, -0.06372166f, 0.02874870f, 
    0.01786578f, 0.01820566f, -0.03738884f, 0.03211804f, -0.00405341f, -0.02098751f, 0.04495051f, -0.03403957f, 
    0.01514502f, -0.04143411f, 0.01492758f, -0.06045225f, 0.00893336f, 0.00023004f, 0.03784543f, -0.01183471f, 
    -0.04661109f, 0.04880120f, 0.03351223f, 0.04134702f, -0.05822910f, -0.04788576f, -0.00486519f, -0.05418267f, 
    0.00034434f, -0.00573294f, -0.05603928f, -0.05559370f, 0.00790360f, 0.02233336f, 0.02498146f, 0.03729940f, 
    0.03906609f, -0.06255129f, -0.05532963f, -0.00597864f, -0.02742184f, 0.01048799f, 0.01215715f, 0.03395246f, 
    0.03358908f, -0.06196997f, 0.00552680f, 0.02311527f, -0.01759945f, -0.01032194f, 0.04652566f, 0.00803401f, 
    -0.06367231f, -0.00688279f, -0.03301484f, -0.03490428f, -0.02395363f, 0.04290200f, -0.01664981f, 0.01570927f, 
    -0.02820865f, 0.03139523f, -0.05087388f, -0.03359383f, -0.02319541f, 0.02641748f, -0.03201202f, 0.00315866f, 
    -0.01566697f, -0.02317668f, 0.01459256f, -0.03502808f, 0.03363144f, -0.02597417f, 0.01276797f, -0.05004634f, 
    0.02246620f, -0.02317489f, -0.05603478f, -0.06305669f, -0.02339672f, -0.01487660f, 0.02793066f, 0.01499781f, 
    0.03214986f, -0.02786414f, -0.04386063f, 0.03538016f, 0.00309438f, 0.04512190f, -0.04550187f, -0.04942568f, 
    -0.02437500f, -0.03622055f, 0.01640532f, 0.00633982f, -0.03278006f, 0.03471898f, -0.01865918f, 0.00311951f, 
    -0.00514769f, 0.02560348f, -0.01776976f, -0.02759793f, -0.06325697f, -0.04370636f, 0.01248418f, 0.03709306f, 
    0.02503298f, 0.01974721f, -0.04398141f, 0.00905386f, 0.04141298f, 0.03082905f, -0.05911964f, 0.00712966f, 
    -0.04557227f, -0.05470679f, 0.04022038f, -0.06077925f, 0.01661708f, 0.04742966f, -0.04733172f, -0.05311542f, 
    0.03679420f, 0.00175836f, 0.00910862f, 0.02514090f, 0.03199669f, -0.01692130f, -0.05032305f, 0.02497607f, 
    -0.03392993f, 0.01966917f, 0.03759041f, -0.04893894f, -0.00363729f, -0.03792322f, 0.00524567f, 0.04504944f, 
    -0.03646873f, -0.02761460f, 0.04408069f, -0.04499228f, -0.04627471f, 0.01337713f, 0.03449932f, -0.00024255f, 
    0.02065242f, -0.06079115f, -0.01909075f, 0.04684775f, -0.04994855f, -0.04367614f, -0.02347029f, -0.01512843f, 
    0.03355811f, 0.01013559f, -0.02843845f, -0.05588897f, -0.02563723f, -0.05253144f, 0.00721955f, 0.04089195f, 
    0.01657147f, 0.03455503f, -0.05178041f, -0.06072151f, -0.03333510f, -0.03309749f, 0.02961191f, 0.00338754f, 
    -0.02299189f, 0.04302672f, 0.04432158f, -0.00195572f, -0.04967035f, 0.02138313f, 0.00509280f, 0.04189153f, 
    0.03090171f, 0.04772578f, 0.04068262f, 0.03695450f, 0.04042323f, 0.03348872f, 0.03031763f, 0.03565382f, 
    0.02333540f, 0.01439900f, 0.04113177f, -0.04003321f, -0.01293908f, 0.01513967f, -0.00020207f, -0.06011695f, 
    0.01965854f, 0.02443698f, 0.00921009f, -0.05520113f, 0.00877981f, -0.02351041f, -0.00326921f, 0.01304204f, 
    0.02260552f, 0.02092415f, -0.05138107f, -0.03774647f, -0.05200112f, 0.00559128f, -0.03173434f, -0.04543340f, 
    0.02163920f, 0.01921569f, 0.04381645f, -0.03508551f, -0.05117928f, 0.00920212f, -0.06086881f, -0.02019615f, 
    0.02360963f, -0.05765744f, 0.00202438f, -0.05067585f, -0.05174506f, -0.04825784f, -0.03076835f, -0.04656712f, 
    -0.01378372f, 0.02547987f, -0.04615977f, 0.02656250f, -0.01721273f, 0.02177767f, -0.00639602f, -0.00033117f, 
    -0.04729715f, -0.02083572f, 0.03825100f, 0.03188013f, -0.05076062f, -0.00360181f, -0.01334624f, 0.02272625f, 
    0.02168346f, -0.00030408f, -0.04896016f, -0.04114929f, -0.02341658f, -0.02544346f, -0.03954498f, -0.06084015f, 
    0.02185401f, 0.00377063f, -0.00522977f, -0.02575921f, 0.03149292f, -0.03304337f, -0.05344957f, 0.02023910f, 
    -0.04258190f, 0.03817813f, 0.00070570f, 0.01182439f, -0.06011375f, 0.03435929f, -0.01524861f, -0.04570966f, 
    -0.01622858f, -0.03962224f, -0.05369765f, -0.06112019f, 0.02735193f, -0.06229989f, -0.01786187f, 0.01443086f, 
    0.04732523f, -0.04626495f, -0.04374138f, -0.04356706f, -0.01468527f, -0.00409801f, 0.00026834f, -0.06063308f, 
    -0.02715346f, -0.02129893f, -0.02511710f, -0.00786229f, -0.01710438f, -0.04147597f, 0.04276576f, 0.00843821f, 
    0.03913717f, 0.02868103f, -0.01292119f, 0.02244544f, -0.01504803f, -0.02016895f, 0.00622886f, -0.03533533f, 
    -0.04124625f, 0.00965136f, 0.01332643f, 0.01159745f, -0.01804402f, -0.02789848f, 0.03708342f, -0.00964366f, 
    -0.04044505f, -0.01605186f, -0.01948939f, -0.02040748f, -0.02335081f, -0.02660249f, -0.05233679f, -0.05366585f, 
    -0.01978614f, 0.01584407f, -0.01927894f, -0.02974862f, -0.03957207f, -0.02236965f, 0.04952307f, -0.02526138f, 
    -0.03303510f, 0.01565944f, -0.03779319f, -0.00167277f, -0.01006687f, -0.03089826f, -0.04284465f, 0.00152480f, 
    0.01533824f, -0.05229826f, 0.00004775f, -0.05351762f, 0.02341600f, 0.00278863f, -0.01841574f, -0.01197972f, 
    -0.04020974f, -0.02008308f, -0.01380416f, -0.04707151f, 0.04221481f, -0.02308841f, -0.02536958f, 0.04655113f, 
    0.03763289f, -0.05655918f, -0.01007173f, -0.02348257f, -0.02712357f, -0.03723355f, -0.04816024f, 0.02626202f, 
    -0.00814099f, 0.04687866f, 0.01604013f, -0.04210879f, 0.01111382f, -0.00409707f, 0.01662948f, 0.00688008f, 
    -0.01231982f, -0.02252818f, -0.05252066f, -0.05836628f, 0.02986267f, 0.01832755f, -0.01727152f, 0.02253187f, 
    0.04372046f, -0.03514922f, -0.01653805f, -0.05696631f, 0.00128291f, -0.04317315f, -0.01864959f, -0.01506940f, 
    -0.04435989f, -0.02260821f, -0.01149108f, -0.02912449f, -0.02993455f, 0.04007807f, -0.02428068f, -0.06042515f, 
    0.01465220f, -0.03261333f, 0.01112466f, 0.04133470f, 0.03176070f, 0.05040927f, -0.00730588f, 0.03703926f, 
    -0.04884982f, -0.01260952f, -0.05578628f, -0.04835161f, -0.03829453f, 0.03514775f, 0.05163592f, 0.04633007f, 
    -0.04471717f, 0.04102528f, 0.02397598f, -0.00645559f, -0.01609889f, -0.04149128f, -0.03988923f, -0.00223807f, 
    0.02360100f, -0.05007948f, -0.03554637f, 0.04954196f, -0.02118012f, -0.05600760f, 0.02408760f, 0.04807265f, 
    0.00900010f, -0.04224575f, 0.02549019f, -0.04933813f, 0.04240772f, 0.02994480f, 0.01985166f, 0.02522424f, 
    0.04896560f, -0.05383794f, 0.05193470f, 0.03743165f, 0.03054779f, 0.00181255f, 0.03135725f, -0.00214246f, 
    0.03893787f, 0.00909537f, -0.05841469f, 0.05257315f, -0.04343672f, 0.03883746f, -0.05746034f, -0.04747631f, 
    -0.00871456f, 0.01826648f, -0.00417103f, 0.04510276f, -0.04736540f, -0.00431829f, 0.02878383f, -0.01555902f, 
    -0.03805088f, -0.03148195f, -0.00029560f, -0.02040040f, -0.01853528f, -0.05777096f, 0.00983263f, 0.00469013f, 
    -0.06009920f, 0.00710097f, -0.02991403f, 0.01608259f, 0.04076376f, -0.05757208f, 0.03541775f, 0.00369869f, 
    -0.01405489f, -0.04250453f, 0.01767066f, -0.01817778f, -0.03586480f, -0.00522373f, -0.02398388f, 0.02792067f, 
    -0.03743056f, -0.04484008f, -0.05097158f, 0.01673495f, 0.02800689f, 0.04943962f, -0.04524919f, 0.00479951f, 
    -0.03106848f, -0.03397557f, -0.00597733f, -0.00525059f, -0.05128954f, -0.05983856f, -0.02093767f, -0.00100707f, 
    0.02643184f, 0.00182878f, -0.02526095f, 0.00646612f, -0.02262020f, 0.02439704f, -0.00300816f, 0.05233598f, 
    0.04828399f, -0.04427673f, -0.01498400f, 0.01311748f, 0.03744019f, -0.06256653f, 0.03378400f, -0.04665117f, 
    0.04846894f, -0.00874146f, -0.04544605f, -0.03340936f, 0.02402502f, -0.02132593f, -0.05845011f, -0.02938288f, 
    -0.02191146f, -0.00512865f, 0.04538042f, -0.03232478f, -0.02828601f, 0.04697429f, -0.00340865f, 0.04115989f, 
    -0.05655290f, 0.02387322f, 0.02372994f, -0.01915214f, -0.03151259f, 0.00943556f, -0.02676799f, -0.01281301f, 
    0.00994086f, 0.05305886f, 0.04152711f, 0.04221775f, -0.02049233f, 0.04304392f, -0.00350723f, -0.03797092f, 
    -0.01638613f, 0.04738456f, -0.01348230f, 0.02689490f, -0.04532299f, 0.04217447f, 0.02309618f, 0.01305635f, 
    -0.06063359f, -0.05324351f, -0.00805396f, -0.03847125f, -0.00226309f, -0.01875510f, 0.04906765f, 0.02144429f, 
    0.02049434f, 0.03761701f, 0.03432498f, -0.05172591f, 0.04265951f, -0.02130962f, -0.01669532f, -0.01215677f, 
    0.01484887f, 0.03150466f, -0.00039209f, 0.03371013f, -0.01731749f, -0.02005558f, 0.02312962f, -0.05776348f, 
    -0.00707636f, 0.05225869f, -0.04372255f, 0.03020249f, -0.05706983f, 0.00227249f, 0.03236631f, 0.04317782f, 
    -0.03956082f, -0.05749253f, 0.04411840f, -0.04578087f, -0.05435426f, -0.04308321f, -0.03335114f, 0.03839481f, 
    -0.04691252f, -0.03205477f, -0.00954913f, -0.02087650f, 0.02103615f, 0.01803928f, 0.03933451f, 0.04907324f, 
    0.04473638f, 0.00492135f, -0.00623003f, -0.05260326f, 0.00656281f, -0.04454915f, -0.01467783f, -0.03567899f, 
    -0.05533410f, -0.04293104f, -0.00735165f, -0.00571632f, -0.01014524f, 0.03394050f, 0.01447602f, -0.01483385f, 
    -0.01405201f, 0.01468665f, -0.00404965f, -0.06057315f, 0.04061625f, -0.04251092f, -0.03652292f, -0.05561924f, 
    -0.02679188f, 0.01915635f, 0.01320582f, -0.04440320f, 0.00895553f, 0.02820947f, -0.02786848f, 0.04116958f, 
    -0.05299661f, 0.01153637f, -0.05395148f, -0.04254079f, 0.04484083f, -0.02515037f, 0.01614059f, 0.04954104f, 
    -0.02005291f, -0.03958108f, 0.00957103f, -0.04340664f, 0.04265976f, 0.01346354f, -0.04225305f, -0.03760929f, 
    0.01397649f, 0.02191708f, -0.04987702f, 0.05198118f, -0.02732002f, -0.01519580f, 0.02350993f, -0.04629624f, 
    0.02266306f, -0.05359482f, -0.05659774f, 0.03383620f, -0.04146377f, -0.04269656f, -0.05798200f, 0.04244483f, 
    0.01038962f, -0.00352042f, -0.01466620f, -0.01140524f, 0.04272552f, -0.06103874f, 0.00536409f, -0.01465613f, 
    0.01357517f, 0.03422498f, 0.04534224f, 0.01413466f, -0.02296138f, -0.03830491f, 0.00192463f, 0.00990868f, 
    -0.00932469f, -0.00235667f, -0.05615644f, 0.00294136f, -0.03970535f, -0.03213354f, -0.00841979f, 0.00561843f, 
    0.01165938f, 0.01101229f, 0.01763423f, -0.01216284f, 0.04604679f, -0.00717844f, 0.02444114f, -0.05641313f, 
    0.03763777f, 0.04868522f, -0.01835243f, 0.03847162f, 0.04736909f, -0.05033057f, -0.05546232f, 0.03910228f, 
    -0.02811874f, -0.00177753f, -0.04128640f, 0.03770241f, -0.02407162f, 0.01495637f, 0.03082397f, -0.05742661f, 
    -0.00214970f, -0.04813601f, 0.03720900f, -0.00494913f, -0.02612774f, 0.05092824f, 0.03176318f, 0.02196892f, 
    -0.03035495f, 0.01418004f, -0.03663636f, -0.03778098f, -0.01067826f, 0.04008637f, -0.05231496f, 0.01291852f, 
    -0.01959246f, -0.05710284f, -0.05208464f, 0.03498000f, 0.00686636f, -0.01109027f, -0.02983063f, 0.01052767f, 
    -0.02659658f, -0.03052102f, -0.01141260f, -0.00222784f, 0.04576739f, -0.00344408f, 0.03228122f, 0.02857255f, 
    -0.02100021f, 0.02946136f, -0.02805671f, -0.04240745f, 0.01437062f, 0.03610083f, -0.00234778f, 0.02839303f, 
    0.02637661f, -0.03152766f, -0.04526339f, -0.01124617f, 0.03852074f, 0.01212981f, 0.00681102f, -0.05262733f, 
    -0.03405640f, 0.00359115f, -0.05077558f, 0.05017782f, -0.01591675f, -0.01437289f, -0.04530375f, 0.03613403f, 
    -0.01356179f, 0.02533801f, -0.04258968f, -0.00967644f, -0.01764827f, 0.03894618f, 0.03646163f, 0.01108611f, 
    -0.01206801f, 0.01389141f, -0.00348312f, -0.02661662f, 0.04117528f, -0.02261468f, -0.00083679f, 0.02517211f, 
    0.02527357f, 0.03143107f, -0.02599327f, 0.00422779f, 0.01959281f, -0.00811757f, -0.05295376f, 0.00157469f, 
    -0.00059929f, -0.02855485f, 0.03465462f, 0.02942788f, 0.03630205f, -0.05240503f, 0.00265277f, -0.04406273f, 
    -0.00387244f, 0.00834260f, 0.01599987f, -0.01761582f, 0.04006458f, -0.04380466f, 0.04651044f, -0.05099995f, 
    0.04519043f, 0.00620798f, -0.01065232f, -0.06054937f, -0.02980989f, -0.04852472f, -0.01086321f, 0.02978192f, 
    -0.05045488f, -0.03617393f, -0.03402618f, 0.03541236f, -0.01474713f, 0.01994166f, 0.02010433f, -0.03889346f, 
    0.02038637f, -0.00849473f, -0.04051214f, -0.03434606f, 0.02573737f, -0.03009920f, 0.02604053f, -0.05215795f, 
    -0.03082153f, -0.03233088f, 0.00491103f, 0.00070622f, -0.03882998f, -0.03334289f, 0.01740869f, -0.00524692f, 
    -0.03875456f, 0.04284744f, 0.02189305f, -0.05316501f, -0.01588560f, 0.04785347f, -0.04638830f, 0.00533330f, 
    -0.06335561f, 0.05745712f, -0.01004694f, -0.02393597f, -0.02142556f, -0.06547940f, -0.00074728f, -0.03159888f, 
    -0.02554981f, 0.00503156f, -0.00141338f, 0.02319141f, -0.03668011f, -0.01880630f, -0.02873500f, -0.02825287f, 
    0.04638838f, -0.05528308f, -0.04336908f, 0.04156603f, -0.01236482f, 0.02434847f, -0.05892576f, 0.00624192f, 
    -0.02245347f, 0.01272710f, -0.02819065f, 0.02468297f, 0.00537395f, -0.04731890f, -0.00122578f, 0.00659839f, 
    0.02551424f, 0.03042299f, 0.04051373f, 0.00781572f, 0.03678185f, 0.00748981f, -0.01948078f, -0.00176780f, 
    -0.03174228f, 0.00025328f, 0.01033123f, 0.00238497f, 0.02267312f, -0.02592347f, -0.04697195f, 0.05348882f, 
    -0.06239974f, -0.03367707f, -0.02289452f, 0.01326329f, -0.05235996f, -0.00484958f, 0.01566491f, 0.03656991f, 
    0.04913855f, -0.04853798f, -0.02394627f, -0.02026948f, -0.02483087f, -0.01206818f, -0.05418979f, 0.04661820f, 
    -0.02396409f, -0.04340345f, 0.03417755f, 0.02253616f, 0.03174754f, 0.02469778f, -0.04367001f, -0.01307304f, 
    -0.00053921f, -0.02844666f, 0.01707705f, -0.03272957f, 0.02985485f, -0.03781697f, -0.05499545f, 0.04858036f, 
    -0.02980179f, -0.02869788f, 0.03707415f, 0.02398378f, -0.01434083f, -0.04603071f, -0.00146399f, 0.01365910f, 
    0.00616691f, -0.03095851f, -0.05646376f, -0.01894606f, -0.03436020f, -0.00410015f, 0.01092483f, 0.03630442f, 
    0.03140558f, -0.00762523f, -0.03514188f, -0.02102407f, -0.03881509f, -0.02853888f, -0.03779036f, 0.04290701f, 
    0.17292799f, 0.14531827f, -0.06024826f, -0.00404859f, 0.01038512f, 0.14513566f, 0.05642901f, -0.04262565f, 
    0.18542147f, -0.08426787f, -0.02818079f, -0.05403559f, -0.11782195f, 0.08902802f, 0.03211824f, 0.11461385f, 
    0.04040452f, -0.06144577f, 0.07624070f, -0.09664451f, -0.02213682f, 0.21745938f, -0.04314945f, -0.08783049f, 
    -0.13250016f, 0.04827483f, 0.03141779f, -0.08046837f, 0.01987255f, -0.13026638f, -0.10475894f, 0.06111035f, 
    0.05972201f, -0.01765548f, -0.08130413f, -0.02512295f, -0.17940965f, 0.28378063f, -0.03919904f, 0.05138784f, 
    0.01989723f, -0.33488357f, -0.21144617f, -0.13348708f, 0.08434863f, -0.01457925f, 0.10059512f, 0.09013654f, 
    -0.06193646f, -0.01690182f, 0.09053268f, 0.07907968f, 0.03687261f, -0.22699815f, -0.00673494f, -0.05141071f, 
    0.03755308f, 0.04379331f, 0.05159706f, 0.07491666f, 0.26959321f, 0.19231144f, -0.03881200f, -0.12208389f, 
    0.00488057f, 0.08974776f, -0.02031929f, -0.01771756f, -0.00966941f, -0.00788383f, 0.03138812f, -0.05851139f, 
    0.01194982f, -0.00197757f, -0.00290330f, 0.02309563f, 0.05244689f, -0.01083686f, -0.14853644f, 0.09125784f, 
    -0.06467792f, 0.29001474f, 0.41262648f, 0.01773274f, 0.25573787f, -0.02635696f, 0.00138155f, -0.06255950f, 
    0.17179652f, 0.01902581f, 0.04514647f, 0.15915550f, 0.14888246f, 0.27718189f, 0.03649509f, -0.04050916f, 
    -0.03712726f, -0.10390560f, 0.18035255f, -0.13962248f, 0.24913403f, 0.68767595f, -0.00722413f, 0.13628906f, 
    -0.02321963f, 0.15036961f, -0.00463535f, -0.16278009f, -0.08021791f, 0.00072799f, -0.06362847f, 0.14980805f, 
    0.03518875f, 0.04395067f, 0.12721859f, 0.04346296f, -0.00975647f, 0.03173861f, -0.00920681f, -0.03082630f, 
    0.43238556f, -0.29967821f, 0.07957562f, -0.08276002f, 0.48078626f, -0.05432043f, 0.11942779f, -0.05078923f, 
    0.00558348f, -0.10448011f, -0.02937535f, -0.05441647f, -0.06659663f, 0.02671525f, 0.04460058f, -0.04807909f, 
    0.05870260f, 0.03646384f, 0.06399833f, 0.05711807f, 0.10593416f, -0.34049937f, -0.14089973f, -0.13552280f, 
    0.01554211f, 0.00212183f, -0.01650211f, 0.08939877f, 0.08527396f, 0.00008155f, 0.02597111f, -0.04296110f, 
    -0.09513790f, 0.17823069f, -0.11386009f, 0.13356161f, 0.12595890f, -0.10234884f, -0.00659676f, -0.01832311f, 
    0.01117743f, 0.04085613f, -0.14904755f, 0.13776895f, 0.11837126f, -0.01428227f, 0.03545148f, -0.07665412f, 
    0.05146037f, -0.04090812f, 0.01534413f, 0.00881586f, -0.23147844f, 0.05148315f, -0.24821198f, -0.04631391f, 
    0.20384480f, 0.25082770f, -0.03485136f, 0.03222168f, -0.03824545f, 0.10588022f, -0.02370221f, 0.14073591f, 
    0.10276338f, -0.10125578f, -0.02055410f, -0.00792298f, -0.07169683f, -0.06148514f, 0.00087967f, 0.06164944f, 
    -0.00161004f, -0.23183796f, -0.07385338f, -0.06260874f, 0.02016338f, 0.08948188f, 0.08678050f, -0.00432932f, 
    0.26754734f, 0.16749436f, 0.31212366f, 0.11939327f, -0.02022169f, -0.06268279f, -0.05649943f, -0.01879256f, 
    -0.06169277f, -0.02026626f, -0.08821008f, 0.05217836f, -0.07517567f, 0.09573632f, -0.01232135f, 0.00370064f, 
    0.08951121f, -0.00932841f, 0.21243405f, -0.12792274f, 0.21013035f, -0.15134762f, -0.32862008f, -0.37018979f, 
    -0.08093224f, 0.12914558f, 0.00635740f, 0.04635934f, 0.02727979f, -0.06641772f, -0.16251342f, -0.02710620f, 
    -0.05611847f, 0.12084074f, 0.00994038f, -0.03577113f, -0.11857826f, -0.14745185f, -0.09408192f, 0.07200572f, 
    -0.26212916f, -0.04049636f, 0.07356501f, -0.07425182f, -0.24949406f, -0.01645605f, 0.00367555f, 0.09297425f, 
    0.03435745f, 0.12901229f, -0.07204684f, -0.04243160f, 0.09273762f, -0.00700042f, -0.07984903f, 0.09796478f, 
    0.02701725f, -0.06102969f, -0.10780856f, 0.04185488f, 0.27226931f, -0.03586506f, 0.15443027f, 0.06558671f, 
    -0.02136275f, -0.03517601f, 0.05238195f, -0.04506437f, -0.05610735f, 0.15545188f, -0.01204138f, 0.00729385f, 
    0.00749572f, -0.04278780f, 0.11939150f, 0.00545964f, -0.02035630f, 0.11729203f, 0.09858255f, -0.07349888f, 
    -0.07272970f, -0.03764703f, 0.28607017f, 0.20869304f, 0.17854051f, 0.07788318f, -0.02663238f, 0.10071717f, 
    0.05189097f, 0.11601932f, -0.10854044f, -0.10406888f, 0.11658586f, 0.05486204f, 0.05317825f, -0.16511847f, 
    -0.09039323f, 0.07748055f, 0.07899620f, 0.02555852f, -0.04124312f, -0.04149765f, 0.20521043f, -0.18159737f, 
    0.14354256f, -0.00320235f, 0.01767081f, 0.12875459f, 0.06386498f, 0.05638554f, 0.00332572f, 0.12837765f, 
    -0.05648103f, -0.01652728f, -0.11920448f, 0.02229976f, -0.01048779f, -0.01155722f, 0.06444020f, 0.07513277f, 
    -0.15394849f, -0.12700319f, 0.04955532f, 0.18988845f, -0.10631635f, 0.07511055f, 0.21844764f, -0.10637034f, 
    -0.09033994f, 0.06373961f, -0.09655215f, 0.04809004f, -0.02308389f, 0.04897056f, 0.17424358f, -0.01964731f, 
    0.16104805f, 0.06672846f, 0.11636859f, -0.08371133f, 0.22762054f, 0.10846653f, 0.09343132f, 0.04561358f, 
    0.13587002f, 0.04162765f, -0.09512142f, 0.24083523f, 0.06934104f, 0.09043175f, 0.06631563f, -0.10107769f, 
    -0.00000298f, -0.05922284f, -0.06047789f, 0.03822981f, 0.06868505f, -0.07254834f, 0.14124668f, 0.05232850f, 
    0.30709374f, 0.04605145f, -0.12013748f, 0.06105075f, 0.29106867f, 0.00770525f, 0.09256384f, 0.03878299f, 
    -0.03003235f, 0.00339151f, -0.00997470f, -0.06643282f, -0.00168597f, 0.25509161f, 0.13275445f, -0.03862149f, 
    0.06015309f, 0.06387463f, -0.09705079f, -0.04276969f, 0.16349390f, -0.14565451f, -0.15160267f, -0.12354678f, 
    0.03626098f, 0.23223528f, -0.15583247f, 0.24726357f, -0.18638729f, 0.12851466f, 0.07249260f, 0.02762001f, 
    -0.10681962f, 0.07865865f, -0.05619950f, 0.05885099f, -0.19751872f, 0.00035718f, 0.08443990f, 0.00342032f, 
    -0.27105176f, 0.36910361f, 0.05141948f, 0.17394303f, 0.18227227f, 0.03274437f, 0.07418440f, 0.00302076f, 
    0.05280320f, -0.06501628f, -0.01543353f, -0.00798516f, -0.02757132f, 0.00625626f, -0.12873320f, 0.06011475f, 
    0.04177622f, 0.03429127f, 0.24926610f, 0.07542997f, -0.05188012f, -0.09942949f, -0.02807471f, 0.26328516f, 
    0.12805396f, 0.05119791f, -0.07077470f, 0.11399338f, 0.02123137f, 0.01275961f, 0.09935933f, 0.13543020f, 
    -0.02537149f, -0.06790281f, 0.12652762f, -0.09652048f, 0.00505122f, -0.04837458f, -0.02666683f, 0.06393207f, 
    0.15729888f, 0.21567471f, -0.03326090f, 0.40191787f, 0.24008630f, -0.09460618f, 0.04540249f, -0.09493195f, 
    0.20291461f, 0.12760048f, 0.04278067f, 0.07811003f, 0.21156049f, 0.08454840f, 0.09829095f, -0.05295543f, 
    0.20057942f, -0.07506177f, -0.18707958f, -0.02920842f, -0.56711543f, -0.28380391f, 0.08537319f, -0.24237399f, 
    -0.45306146f, 0.12706473f, 0.10158647f, -0.10164153f, 0.02113291f, -0.00189750f, 0.02027550f, 0.06281406f, 
    0.11439645f, -0.10317286f, 0.09012742f, 0.04639361f, -0.00286081f, 0.11129164f, 0.08322304f, 0.17793715f, 
    -0.22421744f, 0.03397075f, 0.21671413f, 0.27485034f, 0.31992033f, 0.03930486f, -0.06077050f, -0.05977168f, 
    0.14274789f, 0.04728572f, 0.03632810f, 0.12151461f, -0.00168860f, 0.02464722f, 0.09610726f, -0.04184088f, 
    0.03839547f, -0.01726824f, -0.21970436f, -0.27881816f, 0.35293576f, 0.05083678f, 0.24218716f, 0.15158829f, 
    0.26473162f, 0.08441366f, -0.05632288f, -0.09668191f, -0.14536957f, 0.01998235f, -0.06175156f, 0.13902953f, 
    0.30632281f, 0.09140562f, 0.03284185f, 0.00529690f, -0.00358826f, -0.11956294f, 0.05710876f, -0.08056004f, 
    -0.04770954f, 0.12513988f, -0.33770263f, -0.16960034f, -0.17225397f, 0.00446503f, -0.12694947f, -0.07298660f, 
    0.15272668f, -0.02209875f, 0.03617349f, 0.23734459f, -0.10512388f, -0.10582309f, 0.00100377f, 0.01693703f, 
    -0.07100328f, -0.06958591f, 0.00884809f, 0.00518937f, -0.38141835f, -0.21866699f, 0.27227598f, 0.13356443f, 
    -0.15319231f, -0.01674192f, 0.23322439f, 0.06581440f, 0.06102386f, 0.04333605f, 0.16837621f, 0.00390239f, 
    0.03626579f, 0.00911612f, 0.06085046f, 0.04473017f, -0.01036910f, 0.07103825f, -0.00343608f, 0.16729145f, 
    0.25027424f, 0.13034241f, 0.03403536f, -0.27165964f, -0.13097979f, 0.04081501f, -0.04571370f, 0.21315151f, 
    -0.08539815f, 0.05244179f, 0.07585774f, 0.10496863f, 0.07260515f, -0.03588803f, 0.12041243f, -0.04477147f, 
    0.05855829f, 0.17111841f, 0.07415527f, 0.06376412f, 0.00503138f, -0.22057074f, -0.21868142f, -0.20832974f, 
    -0.21665129f, 0.06068578f, 0.00200892f, -0.09349958f, -0.06258120f, -0.22418946f, -0.01404401f, 0.16890833f, 
    -0.12608151f, 0.01283496f, -0.11366228f, -0.14041696f, 0.08055203f, 0.13053912f, -0.12759037f, -0.09588657f, 
    -0.03168166f, 0.34111649f, -0.19368900f, -0.06217178f, -0.13403557f, 0.03992961f, -0.06597938f, 0.14121406f, 
    0.04880738f, -0.10376140f, 0.07784873f, -0.06448586f, 0.01766152f, -0.15411544f, 0.02388192f, 0.04196654f, 
    -0.07960597f, 0.07054126f, -0.03385726f, -0.04447703f, 0.07052685f, -0.13504227f, 0.14401585f, -0.15643020f, 
    -0.07793744f, -0.20394273f, 0.03259995f, -0.02528801f, -0.06074478f, 0.15007040f, 0.14014566f, -0.09634542f, 
    0.05590430f, 0.02416051f, 0.11834008f, -0.02470869f, 0.03756995f, -0.00098382f, 0.15537465f, 0.19217804f, 
    -0.03363043f, -0.02497226f, 0.00238008f, -0.00585184f, 0.02567385f, 0.00848858f, -0.02912028f, -0.03642728f, 
    -0.05746021f, 0.00548965f, 0.01978537f, -0.02529158f, 0.04031407f, -0.05961844f, -0.03554071f, -0.04011649f, 
    -0.04028085f, 0.03358969f, -0.02122281f, 0.02103444f, 0.01385255f, 0.01210830f, -0.02930210f, -0.01000277f, 
    -0.01849837f, 0.00538314f, 0.00513621f, -0.05573949f, -0.04847608f, -0.00297124f, -0.02760568f, -0.01403037f, 
    -0.02184343f, -0.04464301f, 0.04051353f, 0.02281087f, -0.02103377f, -0.06071064f, -0.03541579f, 0.04852046f, 
    -0.05127806f, 0.02459988f, -0.04272689f, -0.06245931f, 0.02831103f, -0.02449951f, 0.02344867f, 0.01273116f, 
    0.01996775f, 0.00734786f, -0.02155209f, 0.02867999f, -0.01783937f, -0.02200140f, -0.00323188f, -0.01153886f, 
    -0.05236718f, 0.01554448f, -0.04111243f, 0.02581759f, -0.04976526f, 0.01414668f, -0.03314632f, -0.05144450f, 
    0.03149763f, 0.03461012f, -0.05521988f, -0.03296700f, -0.02063857f, -0.04953369f, -0.01894831f, -0.02930829f, 
    -0.03248157f, -0.03749304f, -0.01662863f, 0.03712672f, -0.00051949f, 0.00181924f, 0.01847818f, -0.05933274f, 
    -0.03819295f, 0.05625059f, -0.03972896f, 0.03753155f, -0.04378343f, 0.02350340f, 0.00476673f, 0.04918994f, 
    0.00792365f, -0.01111663f, -0.01062888f, 0.01169811f, 0.01913829f, 0.00490197f, -0.03306489f, -0.04915288f, 
    0.00058695f, -0.04637636f, -0.02933900f, -0.00497521f, -0.01671813f, -0.01052121f, -0.01463571f, -0.04830370f, 
    0.01123722f, 0.01635773f, 0.01501779f, 0.00404696f, 0.04830439f, 0.01320823f, -0.04151564f, 0.03399061f, 
    0.02416470f, 0.03104310f, -0.03178171f, 0.03902145f, -0.01892062f, 0.05365167f, 0.03367822f, -0.05328817f, 
    -0.01899746f, 0.03764125f, -0.04159582f, -0.01394850f, 0.00933068f, -0.02788679f, 0.02028913f, 0.03002610f, 
    0.02930505f, 0.01894362f, -0.04024957f, -0.00506805f, 0.01080011f, -0.01046076f, 0.00361107f, 0.02605801f, 
    0.02152847f, 0.05493372f, -0.05109715f, -0.02182858f, 0.03741165f, 0.00644972f, 0.01665691f, -0.03769940f, 
    0.04730139f, -0.02026697f, -0.01875675f, 0.04070669f, -0.00581975f, -0.03816632f, 0.02988461f, -0.03624691f, 
    0.03303608f, 0.03964263f, 0.02609720f, -0.03630005f, 0.01724569f, -0.05895260f, -0.02884275f, 0.00713651f, 
    0.00561126f, 0.01154262f, -0.02159572f, 0.00781098f, 0.01036966f, -0.04184192f, -0.03811749f, 0.02818574f, 
    0.02570206f, 0.00713909f, -0.02974951f, 0.04077543f, -0.01685916f, -0.05023247f, 0.02561017f, 0.04904192f, 
    -0.01639950f, 0.05376796f, -0.02567606f, -0.04614210f, 0.00401492f, -0.00090626f, -0.00433636f, 0.02061176f, 
    0.01199391f, -0.01164493f, 0.01316717f, -0.03344405f, 0.04134378f, -0.04778989f, 0.04382349f, 0.04015402f, 
    -0.02329510f, 0.04516677f, -0.00633308f, 0.00002145f, -0.04858145f, 0.04696115f, -0.01020350f, -0.02678480f, 
    -0.04985677f, 0.01580060f, -0.00479996f, -0.04119317f, -0.00347824f, -0.03938947f, 0.04364853f, -0.02075880f, 
    -0.00736651f, 0.03673036f, 0.00051288f, -0.05273761f, -0.05505745f, -0.03953658f, 0.02218306f, -0.02595413f, 
    0.03196769f, -0.05373962f, -0.00980980f, 0.00533606f, -0.04380411f, -0.03805495f, 0.03212960f, 0.02706494f, 
    0.00442431f, -0.04180334f, -0.01681248f, -0.01773365f, -0.00975514f, -0.01468534f, -0.01975170f, 0.03884863f, 
    0.04859819f, -0.05230173f, -0.00078215f, 0.01827149f, 0.03667675f, 0.00290752f, 0.03748716f, -0.03798581f, 
    0.04619466f, -0.01554733f, 0.02882660f, -0.04672800f, 0.01350336f, -0.02892653f, 0.04817731f, -0.04329220f, 
    -0.00751130f, -0.03354947f, 0.02241294f, 0.02504777f, 0.00210576f, -0.00948489f, 0.02364349f, -0.02088748f, 
    0.04394159f, 0.02044601f, 0.02290370f, 0.03282195f, -0.01858290f, 0.01023527f, 0.04177757f, 0.00425848f, 
    0.04433654f, 0.05411246f, -0.01734340f, 0.02622418f, -0.00581574f, -0.04056720f, 0.02337935f, -0.03620465f, 
    0.03538877f, -0.00003277f, 0.04952157f, -0.00552644f, -0.05920257f, 0.01025480f, -0.00570252f, -0.01615193f, 
    0.03288252f, -0.00895956f, 0.01776543f, -0.00144220f, 0.02781028f, 0.01746366f, -0.03538362f, -0.03692454f, 
    -0.00315582f, -0.02598769f, -0.02540255f, -0.04248100f, 0.02614352f, -0.02043803f, 0.02925719f, 0.01536843f, 
    -0.05720284f, -0.03823628f, -0.05195782f, -0.01456664f, 0.01053026f, 0.03317796f, -0.02348618f, 0.01025417f, 
    0.00925734f, -0.02669693f, 0.00738816f, -0.02650566f, -0.05262436f, -0.02224970f, -0.02125018f, -0.01834574f, 
    -0.05677163f, -0.04994914f, 0.05367230f, -0.04088820f, 0.00527073f, 0.00315033f, -0.02846611f, 0.03205990f, 
    0.30752674f, 0.05225198f, -0.35656965f, -0.03659757f, 0.08565894f, 0.06193468f, 0.02979813f, -0.03974165f, 
    0.23585227f, 0.06078212f, 0.01725592f, -0.11493967f, -0.01088223f, 0.01447423f, 0.01295816f, 0.14960882f, 
    -0.04838201f, -0.09331692f, 0.06316948f, 0.07652161f, -0.20861839f, 0.21924494f, 0.02823547f, -0.11995976f, 
    -0.19173779f, 0.12615897f, 0.09412801f, -0.14187491f, 0.00500673f, -0.07695865f, 0.00805696f, 0.01557249f, 
    -0.06869531f, 0.00624526f, -0.10237670f, -0.00236195f, -0.06175514f, 0.09818199f, 0.08644954f, 0.05197887f, 
    -0.16084976f, 0.27799952f, 0.00360928f, -0.01362247f, -0.40860331f, 0.15392458f, 0.18847129f, 0.03760885f, 
    -0.05084011f, 0.06590012f, 0.03327768f, 0.05723452f, 0.02219580f, -0.05786741f, -0.00045364f, -0.03082790f, 
    0.02033410f, -0.04334614f, 0.02197169f, 0.07259677f, -0.16029444f, 0.25205106f, 0.02973063f, 0.14599584f, 
    -0.44114116f, 0.18475983f, 0.20096734f, -0.08927472f, -0.00593248f, -0.07926552f, 0.03513157f, 0.04184239f, 
    0.19192567f, -0.01777929f, 0.20885000f, -0.08144359f, -0.04142142f, 0.07714839f, -0.04354695f, 0.04356657f, 
    0.27505705f, -0.06789206f, 0.06871068f, 0.00698735f, 0.30694580f, 0.15266153f, -0.05458388f, -0.02795412f, 
    -0.10608023f, -0.01500760f, -0.02246571f, -0.14735374f, 0.17237794f, -0.03524178f, -0.05079941f, -0.01787772f, 
    0.08230709f, 0.03652352f, 0.04456913f, 0.06733405f, -0.18385363f, 0.44129777f, -0.11849374f, -0.04681692f, 
    0.21939591f, 0.09639686f, 0.00506254f, -0.01587819f, -0.02476678f, -0.05052544f, 0.02355564f, -0.03975537f, 
    -0.00467396f, 0.08211169f, 0.06066966f, 0.10035630f, 0.16984189f, 0.16329408f, 0.08705544f, 0.10086443f, 
    0.20246813f, -0.18827906f, 0.03558012f, -0.21327220f, 0.63279009f, 0.14758982f, 0.01049334f, 0.06031433f, 
    -0.07802508f, -0.01195056f, 0.00662871f, -0.05459323f, 0.08600663f, 0.10871217f, 0.08527797f, 0.17335370f, 
    0.09403659f, 0.10562867f, 0.26638445f, -0.01618200f, 0.25646514f, -0.17734496f, -0.03290565f, 0.01891816f, 
    -0.43005931f, 0.05617651f, 0.07543196f, -0.06610081f, 0.00982387f, -0.01523077f, 0.04754892f, 0.01094222f, 
    -0.05466770f, 0.15342583f, -0.00316281f, -0.02284741f, 0.11261805f, -0.18353572f, -0.05364520f, -0.05954831f, 
    -0.10135935f, 0.17889892f, -0.40366647f, -0.24838644f, 0.28689870f, -0.10300028f, -0.11401684f, 0.01047223f, 
    0.03410048f, -0.05198834f, -0.09535240f, -0.06176367f, 0.12146723f, 0.13407356f, -0.01305675f, 0.14236934f, 
    0.19641857f, 0.12437733f, -0.02407146f, 0.07350044f, 0.02963611f, 0.32143009f, -0.17995818f, -0.44286045f, 
    0.12340112f, -0.02300816f, 0.03394842f, 0.05294605f, 0.09801632f, -0.01136338f, -0.01330407f, 0.15654221f, 
    -0.06203552f, -0.06144930f, 0.00797137f, 0.04287349f, 0.03518800f, 0.03920433f, 0.09983877f, 0.06228189f, 
    0.15844284f, -0.48440218f, 0.08837047f, 0.16745222f, 0.07708447f, -0.00189155f, 0.14105444f, 0.05861545f, 
    0.01956658f, 0.00210179f, -0.09949840f, -0.00257382f, 0.02762160f, -0.03373359f, -0.04956546f, 0.02794246f, 
    0.04008898f, -0.11111730f, 0.00645345f, 0.08173577f, 0.34672073f, 0.20137329f, -0.17441873f, 0.03227893f, 
    0.17757738f, 0.04358919f, 0.04751004f, 0.02394882f, -0.01443990f, 0.03907881f, -0.10542852f, -0.04145536f, 
    -0.03590252f, 0.00528655f, 0.00267098f, 0.02950370f, 0.08986673f, -0.03596062f, -0.03289460f, -0.04679582f, 
    -0.46385917f, 0.04461116f, -0.09230760f, 0.15323287f, -0.11855303f, 0.20545280f, 0.03234281f, 0.15450834f, 
    -0.09166844f, 0.16165885f, 0.04603056f, 0.07135068f, 0.05504649f, 0.00227226f, 0.06475592f, 0.05936328f, 
    -0.11842965f, -0.07358428f, -0.16684920f, -0.04211007f, -0.12647395f, -0.14773919f, 0.26298749f, -0.13110460f, 
    0.32434514f, -0.01658133f, 0.02862861f, -0.03028027f, -0.11284762f, -0.08900706f, -0.05283083f, 0.00453376f, 
    0.05534828f, -0.14854246f, 0.01533326f, 0.02865868f, 0.01216655f, -0.17496245f, 0.04506507f, 0.19378000f, 
    0.02925956f, -0.29508129f, 0.08334506f, -0.01104610f, 0.26622769f, -0.05002502f, -0.07360144f, -0.00054378f, 
    0.01532449f, 0.16206637f, -0.07505985f, -0.03332830f, 0.00212925f, 0.12226828f, 0.01289477f, -0.02633465f, 
    -0.11873280f, 0.01061771f, -0.11996299f, -0.04473436f, -0.15992761f, 0.05599302f, 0.14153598f, 0.29282862f, 
    -0.22996907f, 0.22281338f, 0.14726083f, 0.06492721f, 0.01263507f, 0.02757236f, -0.00144467f, -0.00638838f, 
    0.01596364f, -0.00759366f, -0.14421757f, 0.16526854f, -0.03650683f, 0.01108699f, -0.08553174f, 0.09889999f, 
    -0.15701048f, 0.02922805f, 0.03141514f, -0.08178239f, -0.00511065f, -0.05709415f, 0.13383047f, 0.02199374f, 
    -0.11401750f, 0.08060479f, 0.06863317f, -0.04132259f, 0.25154880f, 0.05625752f, 0.16108213f, 0.01244499f, 
    -0.01596696f, 0.08702964f, 0.02145229f, 0.15884930f, -0.14313743f, -0.04290047f, 0.04673163f, 0.04078158f, 
    -0.01345658f, -0.04558427f, -0.11323821f, -0.03620370f, -0.09375165f, 0.04506581f, 0.10949603f, 0.03536254f, 
    0.03146298f, 0.07061435f, 0.00689126f, 0.04452603f, 0.15447241f, -0.20994870f, 0.12833481f, 0.12734979f, 
    -0.18600571f, 0.38691583f, 0.03238923f, 0.17091332f, -0.17825092f, 0.00638631f, 0.02492948f, -0.05362975f, 
    0.03036745f, -0.01920985f, -0.01659091f, 0.00710407f, -0.02065194f, 0.27072203f, 0.08965908f, 0.08739486f, 
    0.04318484f, 0.01368458f, -0.03134726f, 0.07971586f, -0.33621636f, -0.00463103f, 0.18735759f, 0.15465684f, 
    -0.14585453f, 0.20590419f, 0.00952741f, 0.05183396f, -0.04717699f, 0.08990639f, 0.03104733f, 0.03485282f, 
    0.12711498f, -0.01205287f, 0.13291471f, 0.01378044f, -0.09185144f, 0.07832872f, 0.22988510f, -0.01363554f, 
    0.06833995f, -0.13606146f, -0.29999083f, -0.21770222f, -0.21929951f, 0.15858799f, 0.01324971f, -0.06176110f, 
    -0.22517246f, -0.00007498f, 0.04691269f, 0.00475806f, -0.12989968f, -0.11782105f, -0.10666456f, 0.11549737f, 
    0.12680186f, 0.19557732f, -0.08856703f, -0.04333743f, -0.21811411f, -0.24592400f, -0.03466190f, -0.21973306f, 
    -0.04947716f, -0.05877099f, 0.02197546f, 0.06665220f, 0.13910466f, 0.00130318f, 0.10596008f, -0.06514580f, 
    0.07706752f, 0.07004361f, -0.10024399f, 0.02637817f, 0.10099460f, -0.01092763f, 0.12127347f, 0.03217186f, 
    -0.31835496f, 0.19235663f, -0.10491125f, -0.02769596f, -0.12552334f, 0.14217092f, -0.03333960f, -0.05361395f, 
    0.02479751f, -0.07080617f, 0.04867844f, -0.01060143f, 0.03132315f, 0.01933041f, 0.03738508f, 0.03915312f, 
    -0.04035241f, 0.04238261f, -0.13133089f, 0.02745664f, 0.20961536f, 0.42593953f, 0.12986842f, 0.09540571f, 
    -0.04687817f, 0.12246530f, 0.09439017f, -0.10755371f, -0.04086348f, 0.10840687f, 0.03338792f, 0.11332415f, 
    0.14470845f, -0.14382432f, 0.12012472f, -0.06550360f, -0.02460345f, 0.17110813f, 0.14688109f, 0.05008889f, 
    -0.14854568f, -0.07027096f, -0.00159622f, -0.20058629f, -0.01676234f, -0.04848135f, -0.06502080f, 0.01367562f, 
    -0.02106071f, -0.05390486f, 0.02141365f, 0.04178542f, 0.09138916f, 0.00263741f, 0.13806139f, 0.00505530f, 
    -0.00905938f, -0.14670868f, -0.07879808f, -0.05920268f, -0.09522146f, 0.04871065f, -0.02323962f, -0.14986567f, 
    0.06059184f, 0.14155412f, -0.04450009f, -0.11053912f, 0.07359646f, 0.08387931f, 0.07517347f, -0.00228468f, 
    0.02138940f, 0.22503947f, 0.07173345f, 0.03869977f, 0.01014683f, -0.03236326f, -0.14389448f, 0.02759195f, 
    -0.11200450f, -0.26917166f, -0.13421759f, 0.10783452f, 0.25735250f, 0.07607900f, 0.17661537f, 0.13798583f, 
    0.02298694f, 0.05374151f, 0.13844976f, -0.11401358f, 0.13581547f, 0.05979238f, -0.00738173f, -0.00548452f, 
    -0.05261363f, 0.06203146f, -0.11347178f, 0.00461782f, -0.02259397f, 0.39631581f, 0.30395561f, 0.30199605f, 
    0.28381762f, 0.10232020f, 0.07566699f, -0.05395201f, -0.01084844f, 0.18834463f, 0.09449183f, 0.03984120f, 
    0.12017930f, -0.03052786f, -0.00123163f, 0.07056574f, 0.04165134f, 0.16618328f, 0.12708779f, 0.00204223f, 
    0.42821661f, 0.28522888f, 0.01162396f, 0.15368956f, 0.15154782f, 0.17415926f, 0.01152029f, 0.03260633f, 
    -0.10182247f, 0.06743163f, 0.21252176f, 0.06338999f, 0.09298749f, -0.07153443f, 0.11562183f, -0.01209830f, 
    0.05501360f, 0.05634836f, 0.19053532f, -0.07905970f, -0.25806195f, 0.07977018f, 0.11999124f, -0.07614183f, 
    0.38475212f, 0.20776729f, 0.15697923f, -0.08775374f, 0.15120150f, -0.11812265f, 0.04709253f, -0.01885181f, 
    0.04739504f, -0.04692790f, -0.15673973f, -0.01945392f, 0.04697883f, -0.00676341f, -0.10874449f, -0.00519293f, 
    -0.09914345f, 0.13951625f, 0.05879715f, -0.00874945f, 0.17816594f, -0.02303996f, 0.03993475f, -0.03109439f, 
    -0.06166686f, -0.00069980f, 0.11654796f, 0.08699054f, -0.08069085f, -0.02734087f, 0.03292079f, 0.16081275f, 
    0.12418853f, -0.02748247f, 0.01708248f, -0.06163774f, 0.06613565f, -0.04904495f, -0.16630583f, 0.23613736f, 
    -0.12379363f, 0.06087697f, -0.02869122f, 0.04589675f, -0.10894812f, -0.04136239f, 0.10882874f, -0.06072209f, 
    -0.02091629f, 0.02084928f, 0.04899174f, 0.11662126f, 0.00429644f, 0.07641238f, 0.02483682f, -0.00429143f, 
    0.11711989f, -0.11108285f, 0.18913981f, 0.31292197f, 0.02007880f, 0.07799279f, 0.07759871f, 0.14034219f, 
    0.15451854f, -0.12671624f, -0.05368869f, 0.07593632f, -0.08988932f, -0.05384155f, 0.03126572f, -0.03460407f, 
    -0.00784007f, -0.10479594f, -0.00286408f, 0.10870735f, 0.24575083f, 0.02400333f, 0.07252958f, 0.26282439f, 
    0.07348788f, -0.16574728f, 0.00816957f, -0.13166758f, -0.16458967f, 0.15764534f, 0.00943155f, -0.02326359f, 
    -0.07478863f, 0.11079513f, -0.08106554f, -0.14215654f, 0.02006226f, -0.24038269f, -0.05984429f, 0.06341513f, 
    0.12914948f, 0.20869821f, -0.13324440f, 0.25285572f, 0.23757702f, -0.16284166f, -0.00611173f, -0.03784009f, 
    -0.01665952f, 0.06321739f, 0.06718417f, -0.06544422f, -0.01976609f, 0.09794946f, 0.07079607f, 0.09103271f, 
    0.00093988f, -0.15934025f, -0.01047129f, 0.08919308f, 0.11663995f, 0.20433295f, -0.23911765f, 0.28890547f, 
    -0.00106845f, -0.10209493f, -0.10205159f, -0.01581114f, 0.17999214f, 0.11642338f, -0.01667428f, 0.01423642f, 
    0.07866369f, -0.00545854f, -0.15710661f, 0.01174684f, -0.12170315f, -0.02540727f, 0.22956160f, -0.00046053f, 
    -0.11899993f, 0.51482707f, 0.08837084f, -0.25014642f, -0.03029994f, -0.01633983f, -0.06550182f, 0.12496880f, 
    0.07209286f, -0.19815651f, -0.14318064f, 0.03604197f, 0.15619531f, -0.14297080f, -0.01819759f, -0.01316571f, 
    0.01581069f, 0.10783251f, -0.08477167f, 0.00617738f, 0.41592956f, -0.01851915f, 0.22786917f, -0.26313099f, 
    0.22018442f, 0.01114818f, 0.03664970f, 0.03072334f, -0.02813564f, -0.10716631f, -0.00137312f, -0.01133052f, 
    0.06433020f, -0.05143426f, -0.15229069f, 0.07167687f, 0.14835742f, 0.06588762f, 0.10210334f, -0.02446334f, 
    -0.23014218f, 0.12213567f, 0.27291843f, 0.15879332f, 0.10084091f, 0.14063837f, 0.13115169f, 0.00535816f, 
    -0.04009603f, -0.03829404f, 0.06069638f, -0.00630884f, 0.04995145f, 0.12314595f, 0.06066674f, -0.04258233f, 
    0.00885297f, -0.03904581f, 0.07809135f, -0.05867883f, 0.07225084f, 0.46128845f, -0.01860014f, 0.22037300f, 
    -0.13052227f, 0.01693849f, -0.11218084f, 0.15147761f, 0.08299509f, 0.01026602f, -0.02824221f, -0.01744118f, 
    -0.01488570f, -0.11327270f, -0.04720451f, 0.10380747f, -0.00720069f, 0.06951673f, 0.08702992f, 0.06832988f, 
    0.16577770f, 0.30414018f, 0.27155265f, 0.47233504f, 0.51000708f, -0.02464200f, -0.08231490f, -0.02460898f, 
    -0.06369036f, 0.19901386f, 0.03531632f, -0.04636728f, 0.07947288f, 0.01142532f, -0.06682666f, 0.11940572f, 
    -0.12939776f, 0.04421587f, 0.04791034f, -0.01397383f, -0.06526810f, 0.09919383f, -0.22894752f, 0.05494452f, 
    0.45710847f, 0.21033816f, 0.02717279f, -0.12972951f, 0.15305357f, 0.22959310f, -0.10907953f, -0.09441629f, 
    -0.05803547f, 0.04107292f, 0.04707430f, -0.03573372f, -0.01295439f, 0.09229703f, -0.04871221f, 0.05643668f, 
    -0.53760469f, 0.20699772f, 0.05615025f, -0.03761252f, 0.26290417f, 0.12933728f, 0.06895991f, 0.12210459f, 
    -0.13772303f, -0.00980037f, 0.08646142f, -0.04242507f, 0.03910762f, 0.09180189f, -0.08009358f, -0.08097053f, 
    -0.03949074f, 0.00370390f, 0.02551644f, -0.15046589f, -0.27400225f, -0.06270923f, 0.10497916f, 0.38014033f, 
    0.17609915f, -0.07840344f, -0.03170754f, -0.03531308f, 0.00185579f, 0.12393659f, -0.04001526f, -0.06016087f, 
    0.00202414f, -0.14000361f, -0.05041233f, 0.02656255f, -0.08588194f, -0.02374186f, -0.07861581f, -0.11287747f, 
    0.09337952f, 0.00933056f, -0.15566042f, 0.04953818f, 0.02323767f, -0.01830355f, -0.03357157f, -0.10728788f, 
    -0.08784444f, 0.09749483f, 0.02129666f, 0.01543240f, 0.08067127f, -0.00630785f, 0.08458347f, 0.02742803f, 
    -0.05373348f, -0.08516007f, -0.01853057f, -0.00279601f, -0.41964892f, 0.05266075f, 0.14060216f, -0.25732285f, 
    0.43396160f, 0.25239795f, 0.10416839f, 0.10519347f, -0.03302799f, 0.05606234f, 0.11208379f, -0.11973415f, 
    -0.02432223f, -0.03616324f, -0.11303671f, 0.10372377f, 0.01611322f, 0.04589087f, 0.17127082f, -0.00681254f, 
    -0.44381613f, -0.14223021f, -0.15494257f, -0.13393992f, 0.15929583f, 0.05601383f, 0.09696350f, 0.17676342f, 
    -0.05455622f, -0.13829353f, 0.10772195f, 0.04940086f, 0.06967948f, -0.02626761f, 0.00053338f, 0.08946677f, 
    0.10015540f, 0.04054040f, 0.00589352f, -0.02610236f, -0.17823800f, 0.01069411f, -0.15202047f, 0.23053047f, 
    -0.03987278f, -0.03107199f, -0.11723564f, 0.01241019f, 0.04216151f, -0.01684232f, -0.03794602f, -0.04625466f, 
    -0.13582951f, -0.01172480f, -0.06788717f, 0.02786352f, -0.01223370f, -0.15991710f, 0.05799561f, 0.02950893f, 
    0.17601827f, 0.47936219f, 0.20710270f, -0.24372278f, 0.12651378f, 0.15477355f, 0.01406237f, -0.06706184f, 
    0.01522897f, -0.08030094f, -0.07295018f, 0.09043251f, 0.02401961f, -0.02483335f, -0.17915019f, -0.05476168f, 
    -0.01036884f, 0.05008382f, -0.06886492f, 0.04187736f, 0.25722745f, -0.25334445f, -0.06132708f, -0.03014076f, 
    -0.11800712f, 0.00985651f, 0.04210155f, 0.13013832f, -0.02969987f, -0.02814113f, -0.09894361f, 0.01427565f, 
    0.05175643f, -0.12628178f, 0.13444796f, 0.03879740f, 0.09782101f, 0.11528528f, 0.06950387f, 0.04302614f, 
    -0.38868400f, -0.58063978f, 0.33363110f, 0.25875163f, 0.18188003f, -0.11857033f, -0.10261944f, 0.18892653f, 
    -0.05889526f, -0.06039645f, -0.00068346f, 0.07117800f, 0.00524350f, 0.04152865f, -0.04926775f, 0.16029756f, 
    -0.04536609f, 0.06059634f, -0.03480774f, -0.14800024f, -0.34896821f, -0.14172918f, 0.05552129f, 0.17181714f, 
    0.38928148f, -0.14702435f, 0.02343520f, 0.13684112f, -0.04772598f, -0.00477849f, -0.02767724f, 0.00864230f, 
    -0.05928316f, -0.00421958f, -0.07033456f, -0.03766111f, 0.05635090f, -0.00325542f, -0.09201404f, -0.02042542f, 
    0.05228598f, -0.11006393f, -0.27895278f, 0.03729862f, -0.18388827f, -0.05720784f, 0.02140291f, -0.05669965f, 
    0.05605027f, 0.24367572f, 0.15169960f, -0.00989928f, -0.07219067f, -0.09652105f, 0.13680436f, 0.12821086f, 
    0.08485860f, 0.01516872f, 0.04847405f, 0.04332890f, 0.35177657f, -0.37461558f, -0.09670947f, 0.01392276f, 
    -0.19998935f, -0.05300752f, -0.02052685f, -0.00597620f, -0.01935480f, 0.22774740f, -0.08772232f, 0.05258000f, 
    0.07557362f, 0.06311691f, -0.04111444f, 0.08762565f, -0.11565935f, 0.02712226f, 0.12837979f, 0.05786372f, 
    0.31957051f, -0.00845684f, -0.03743188f, -0.24937756f, -0.53311509f, -0.08532428f, 0.06225098f, 0.02666972f, 
    -0.00522773f, -0.04077747f, 0.06421825f, 0.07723505f, 0.00128701f, -0.03835449f, -0.01984186f, -0.02426667f, 
    0.08425169f, -0.07767969f, 0.19141427f, 0.08413612f, 0.07457332f, 0.30732870f, -0.13871323f, -0.12511054f, 
    0.18911584f, 0.00558562f, 0.02350560f, 0.06690785f, 0.01539676f, 0.12824623f, -0.01008094f, 0.11447319f, 
    -0.00438108f, -0.06810495f, 0.12606172f, 0.02496162f, 0.00958038f, 0.00729178f, -0.09707360f, -0.00096574f, 
    -0.16821423f, 0.08526299f, 0.37737188f, 0.21661395f, -0.36581707f, -0.01454146f, 0.38468772f, -0.01013445f, 
    -0.01757525f, 0.05840999f, 0.16662417f, 0.04109935f, 0.04897991f, -0.11652062f, -0.01705075f, 0.01109110f, 
    -0.04674912f, -0.03089406f, 0.23927748f, -0.03641732f, 0.16148734f, -0.05126902f, 0.26122782f, 0.40787879f, 
    -0.21873112f, 0.07308722f, 0.15423253f, 0.06432546f, 0.03509965f, -0.02282851f, 0.02098978f, -0.06235178f, 
    0.01885667f, 0.06980573f, 0.10911302f, -0.06156238f, 0.10279962f, 0.09359565f, 0.07602081f, 0.12936081f, 
    -0.07109904f, 0.11367218f, -0.15972933f, -0.11156476f, 0.06403168f, -0.04643311f, -0.16372946f, -0.03751686f, 
    -0.00994957f, 0.18535399f, -0.07899807f, -0.09329809f, -0.00938391f, 0.08292881f, 0.10190832f, 0.00250155f, 
    0.10791647f, 0.06732403f, 0.06477987f, 0.04229360f, -0.33172250f, 0.15705733f, 0.10400328f, 0.02152445f, 
    -0.02249154f, 0.00328937f, 0.03619239f, 0.07606436f, 0.14498127f, -0.06544258f, -0.01188030f, 0.08719029f, 
    0.03400141f, -0.02401598f, 0.09662409f, -0.00554606f, 0.00503976f, -0.00615254f, -0.01739671f, -0.00127671f, 
    0.23624516f, -0.31070223f, 0.03647360f, -0.01625342f, 0.00482089f, -0.03831058f, -0.09298680f, -0.11240018f, 
    0.16893020f, 0.02305394f, -0.02967824f, -0.12333236f, 0.10940388f, 0.12369709f, 0.00114239f, 0.08109137f, 
    0.08340164f, 0.00641299f, 0.00959722f, 0.08817316f, 0.46229300f, -0.42592788f, -0.41524988f, 0.15724532f, 
    -0.03229291f, 0.01152876f, -0.12806180f, 0.07783218f, 0.14466785f, 0.17090772f, 0.04446095f, 0.03765780f, 
    0.10264894f, 0.10401841f, 0.02282155f, 0.01609527f, 0.07440364f, 0.11914726f, 0.06471972f, 0.05400546f, 
    0.04769336f, -0.02050581f, -0.28391993f, -0.02959091f, 0.03621909f, -0.00376387f, -0.09464884f, -0.11426547f, 
    0.12343639f, 0.09597754f, 0.10316200f, 0.06174969f, 0.07937248f, 0.03086756f, 0.16228475f, 0.00708567f, 
    0.01020148f, -0.02122713f, 0.03837940f, 0.06771727f, -0.18558303f, 0.00278200f, -0.02641889f, -0.07681422f, 
    0.24770106f, -0.07187964f, -0.00628160f, 0.14434236f, 0.03014493f, -0.01131986f, 0.07240000f, -0.02043755f, 
    -0.01736973f, 0.01178528f, 0.07610413f, 0.07252771f, 0.11651822f, -0.01311536f, -0.06364450f, 0.05057215f, 
    -0.04168841f, -0.03506628f, 0.04577163f, 0.01748534f, -0.02287839f, 0.00616251f, -0.02315570f, -0.00082731f, 
    -0.03238296f, -0.04831807f, -0.06072791f, -0.04947291f, -0.02531762f, -0.05872612f, 0.02680242f, -0.00761528f, 
    0.04341770f, -0.00914289f, 0.03585409f, -0.04146119f, 0.03606275f, 0.00870657f, -0.05287735f, -0.02670130f, 
    -0.03867895f, -0.00567609f, 0.01545821f, -0.00773465f, 0.04649157f, -0.00084043f, -0.05285916f, 0.01297599f, 
    -0.03416288f, -0.00612493f, 0.03273735f, 0.04886426f, 0.01478962f, 0.03652345f, -0.01157869f, -0.00817936f, 
    0.03023504f, -0.04247113f, -0.04909365f, -0.02377052f, -0.00682820f, 0.02814214f, -0.05539336f, 0.03861263f, 
    0.02301869f, 0.01120645f, -0.00288732f, 0.00134537f, -0.00283213f, -0.02915700f, -0.04951979f, 0.01845138f, 
    -0.05369905f, 0.04008139f, -0.02779550f, 0.03218152f, 0.04486290f, -0.06068571f, 0.04297518f, -0.00509535f, 
    0.04719090f, 0.02757050f, 0.03625352f, -0.06110642f, 0.00068874f, 0.01101394f, -0.04148398f, -0.02738248f, 
    0.01682201f, 0.02965104f, 0.02603235f, -0.01338241f, 0.02421705f, -0.05358375f, -0.04266888f, -0.01243122f, 
    -0.06240130f, -0.03851290f, -0.01463915f, -0.01470455f, 0.03698858f, 0.03122148f, -0.03943897f, 0.01963735f, 
    0.04082741f, -0.00870809f, -0.01714872f, 0.01655961f, -0.02315740f, 0.00416063f, -0.06311666f, 0.04546092f, 
    0.01072080f, -0.05042452f, 0.01881460f, -0.03339949f, -0.01516692f, -0.01879666f, 0.02205960f, -0.04717076f, 
    0.00899330f, 0.02458800f, 0.03829981f, -0.04724038f, -0.06170026f, -0.04821635f, -0.00056186f, -0.02090635f, 
    -0.02711237f, 0.00318740f, 0.02330444f, 0.01556686f, 0.03071794f, -0.01641250f, -0.00054531f, -0.00364512f, 
    0.00755492f, -0.00667697f, -0.04962207f, -0.05558648f, -0.05207707f, -0.06367029f, -0.02820094f, 0.04758870f, 
    -0.01368230f, 0.01238486f, 0.00449036f, 0.02227202f, 0.02614121f, -0.01493061f, -0.03378328f, 0.03556007f, 
    -0.03076500f, -0.05813758f, -0.03914462f, -0.01655221f, -0.03978094f, -0.05293770f, -0.05582871f, -0.05430475f, 
    0.03983135f, -0.02028090f, -0.04596579f, 0.00814710f, -0.01668678f, 0.01538310f, -0.06132126f, -0.01212905f, 
    -0.02567424f, 0.03717701f, 0.02307418f, 0.02458102f, -0.00702042f, 0.04045791f, -0.00424591f, 0.01934186f, 
    -0.05263167f, -0.04106769f, 0.02454063f, -0.01959298f, -0.03670186f, -0.03205736f, -0.03272782f, -0.04650929f, 
    -0.03341134f, 0.00029668f, 0.03474064f, -0.01246878f, 0.00385768f, 0.04113533f, 0.00338113f, -0.05975700f, 
    0.03492627f, -0.01146310f, 0.01938170f, 0.03878373f, -0.03239445f, -0.00374614f, -0.00125734f, -0.03818417f, 
    -0.04357030f, -0.03423575f, 0.03053017f, 0.00945990f, -0.04911346f, -0.04038347f, 0.04074831f, -0.02024275f, 
    -0.01652694f, -0.05862352f, 0.03902236f, 0.03407464f, -0.06161742f, -0.00082212f, 0.03563763f, -0.00460831f, 
    -0.00557342f, 0.03925137f, -0.02766882f, -0.03565131f, 0.04140239f, -0.03915896f, -0.02725035f, -0.03512270f, 
    0.02370604f, -0.01643058f, -0.02033870f, -0.02008921f, 0.03174819f, -0.03475616f, -0.03836825f, -0.02235654f, 
    0.00104770f, -0.00520426f, -0.04164127f, 0.03125728f, -0.02322364f, 0.02669809f, 0.00588261f, -0.05886568f, 
    -0.03538260f, 0.01950430f, 0.00417065f, 0.00078023f, -0.05308563f, 0.02710618f, 0.03726743f, -0.04650406f, 
    0.01568542f, -0.05365694f, 0.01641807f, -0.06406223f, 0.02750467f, 0.01279995f, -0.00660502f, 0.02355779f, 
    0.03704696f, 0.04056975f, -0.00318403f, -0.02011853f, 0.02893437f, 0.00654679f, -0.04909171f, -0.00823684f, 
    -0.05021368f, -0.03719639f, -0.02696249f, 0.04161536f, -0.06304196f, -0.02452190f, 0.00260824f, 0.02382326f, 
    -0.03935303f, -0.03927260f, 0.01840937f, -0.00328140f, -0.05689856f, 0.00669881f, -0.04274591f, 0.02637829f, 
    0.00341818f, 0.04599277f, -0.05630672f, 0.02054456f, 0.01885679f, -0.02807662f, 0.03580068f, -0.03000635f, 
    0.01311335f, -0.00108202f, 0.02799764f, -0.03167985f, -0.02688212f, 0.02370039f, -0.01907293f, 0.00149726f, 
    -0.00234746f, 0.00365942f, 0.00233177f, -0.05504414f, 0.00323649f, -0.00798362f, -0.02811442f, -0.03430095f, 
    -0.00037005f, 0.03481800f, -0.01929728f, -0.01012503f, 0.02248236f, -0.04043349f, -0.00348309f, -0.03357882f, 
    0.00666334f, -0.02982987f, 0.01543084f, 0.02603652f, -0.02035195f, 0.04672718f, 0.01567107f, -0.00369611f, 
    -0.00608765f, -0.04361926f, 0.03294061f, 0.03396154f, 0.04296581f, -0.00390002f, 0.02063564f, -0.02700032f, 
    0.00838702f, 0.01313605f, -0.05468492f, -0.05868911f, -0.02028524f, -0.02611271f, 0.03423716f, -0.01653010f, 
    0.02826583f, 0.01901599f, -0.01497988f, 0.04770790f, -0.03792883f, 0.01226349f, -0.03224889f, 0.02584716f, 
    0.01564476f, 0.02383404f, -0.01953533f, -0.06402138f, 0.04448415f, -0.05291812f, 0.03598958f, 0.01318969f, 
    0.02354075f, -0.02664755f, -0.04464361f, -0.01058008f, 0.04344482f, 0.03625790f, 0.00449663f, 0.00030952f, 
    0.05301360f, 0.01383686f, -0.00710274f, 0.03442404f, 0.04338027f, -0.05956140f, -0.02574690f, -0.05908256f, 
    -0.00057013f, -0.00895414f, -0.01367938f, 0.02245529f, 0.02751824f, -0.00637672f, -0.05141552f, -0.05653026f, 
    0.03975351f, 0.00193601f, -0.00836569f, 0.03824434f, -0.02452116f, -0.03741632f, -0.01776718f, -0.04367700f, 
    0.04330780f, 0.02602052f, -0.03303031f, -0.00573605f, -0.02285465f, -0.01890587f, -0.04702809f, 0.04440444f, 
    -0.00892706f, -0.05452037f, -0.05793353f, 0.02225495f, 0.00035874f, 0.03601711f, -0.02553263f, -0.05316478f, 
    -0.04117984f, 0.04462760f, 0.04460115f, 0.00824029f, 0.00774075f, -0.01632166f, -0.05834317f, 0.02333652f, 
    -0.00647210f, -0.00815229f, -0.04523613f, -0.03491807f, -0.05447755f, -0.05216758f, 0.02927724f, 0.02022321f, 
    -0.00122021f, -0.01412417f, -0.04446966f, 0.02139905f, 0.04753550f, -0.02479547f, -0.05277221f, 0.04408448f, 
    0.02804572f, -0.01543923f, -0.00640095f, -0.03485766f, 0.02383751f, 0.00118388f, 0.04007629f, 0.00921183f, 
    -0.01850203f, 0.01081532f, 0.03654690f, -0.04284606f, 0.00316436f, -0.01595074f, -0.01805412f, -0.05113487f, 
    -0.06132788f, -0.00046256f, -0.03196360f, 0.01227848f, -0.01448786f, -0.05815033f, -0.03953366f, 0.02754410f, 
    -0.00375066f, 0.00496993f, 0.02387429f, -0.03006087f, -0.05692995f, -0.02396304f, -0.06363752f, 0.00911679f, 
    -0.00754292f, -0.03961474f, -0.05254114f, 0.01888781f, -0.04407030f, -0.05524173f, 0.04092574f, -0.06119353f, 
    -0.02581309f, -0.05224574f, -0.00934340f, 0.03391651f, -0.06310647f, 0.03994251f, 0.03687282f, -0.04168179f, 
    0.02810418f, -0.03125349f, -0.05982872f, 0.03103736f, -0.00482524f, -0.05475586f, 0.04431802f, -0.02285872f, 
    -0.05922923f, -0.05598909f, 0.02599727f, 0.03451164f, 0.04517544f, -0.01346818f, -0.05410269f, 0.02848519f, 
    -0.05525120f, -0.04190830f, -0.03185412f, 0.03705446f, -0.02893734f, -0.02540556f, -0.02778841f, -0.00396960f, 
    0.03685837f, 0.01559151f, 0.03250509f, -0.05831103f, -0.01436001f, -0.05325672f, -0.01923522f, -0.05871210f, 
    0.04747556f, 0.00509353f, 0.02554589f, -0.01942465f, 0.00193716f, -0.01748569f, -0.03159777f, -0.06033951f, 
    0.03546060f, 0.03677332f, 0.02587478f, -0.04901196f, 0.03212798f, 0.02030644f, 0.01938011f, 0.02009502f, 
    -0.02128692f, -0.05721615f, -0.02846810f, -0.02154046f, -0.04038420f, 0.00215559f, 0.03424783f, -0.04442693f, 
    -0.00146714f, 0.04259618f, 0.01073514f, -0.03838906f, 0.01135588f, -0.03343091f, -0.01228980f, 0.04108656f, 
    0.01912962f, 0.01566801f, 0.00093207f, 0.05616388f, 0.02512212f, 0.03280300f, -0.00860679f, 0.02460163f, 
    -0.04368239f, 0.01678467f, 0.04615682f, 0.03083847f, -0.06229555f, -0.01437324f, -0.04300525f, 0.02938214f, 
    -0.04420988f, -0.03474946f, -0.06072444f, 0.00104186f, -0.04809925f, 0.02384283f, 0.01346841f, -0.01599788f, 
    -0.04036441f, -0.00475410f, 0.00593469f, -0.04816933f, -0.03886622f, -0.05850823f, 0.01593067f, 0.01013452f, 
    0.04110494f, -0.05806784f, 0.02831143f, 0.01049649f, 0.02548533f, -0.03015442f, -0.03946226f, -0.04047559f, 
    -0.03725319f, 0.02869626f, -0.03724962f, -0.05258766f, 0.03815318f, -0.03888816f, 0.00425004f, -0.03795313f, 
    0.01778507f, 0.02495084f, 0.00043806f, -0.03187402f, 0.00241461f, 0.04021641f, 0.01531142f, 0.00542278f, 
    -0.01770591f, 0.00619396f, 0.02503732f, -0.02733128f, 0.03950356f, -0.01408440f, 0.05084522f, 0.02221701f, 
    0.04954656f, 0.01461109f, -0.02452930f, 0.02097850f, -0.02035733f, 0.04947929f, -0.02835276f, -0.02817846f, 
    0.03287844f, -0.03466545f, -0.02604746f, 0.01935208f, 0.02954605f, 0.01471158f, 0.03052793f, 0.04770796f, 
    -0.04947618f, -0.06602185f, -0.06107745f, -0.04336004f, -0.02879258f, 0.01907877f, -0.04610786f, 0.04560284f, 
    -0.01230387f, 0.03843293f, 0.01218951f, -0.01341029f, -0.03961270f, -0.03978857f, -0.01917386f, -0.03539868f, 
    0.01187247f, 0.02356626f, 0.04437621f, 0.03181106f, -0.01821331f, 0.04213283f, 0.00555187f, -0.02732997f, 
    -0.02984472f, -0.03905305f, 0.03715793f, 0.04265415f, 0.02357559f, -0.01205155f, -0.03033373f, -0.02239153f, 
    0.03134583f, -0.02457250f, -0.06346644f, -0.05630530f, 0.01483270f, 0.00558340f, 0.02134579f, -0.02127241f, 
    0.03834244f, 0.03158481f, 0.03208473f, 0.03643402f, -0.03616814f, -0.02003495f, 0.00541246f, 0.03634856f, 
    0.00710440f, -0.01648481f, -0.02996524f, 0.01643229f, -0.01219750f, 0.04337724f, -0.02791961f, -0.02593781f, 
    -0.05499246f, 0.04506609f, -0.02884511f, -0.04711017f, 0.03952795f, -0.04311018f, 0.02960196f, -0.03775871f, 
    -0.03729217f, -0.00985109f, -0.01508811f, 0.00781317f, 0.01475430f, -0.02506023f, 0.04145340f, -0.01554641f, 
    -0.01412507f, -0.05887997f, -0.01885048f, 0.00277575f, 0.00835805f, 0.01049632f, 0.00614421f, 0.03514003f, 
    -0.03092522f, -0.05785235f, -0.02105612f, 0.02781996f, -0.03701215f, 0.00268365f, -0.06088953f, 0.04866061f, 
    -0.01925207f, 0.01531153f, -0.03856498f, 0.02217996f, -0.05430984f, 0.03585027f, -0.05838327f, 0.02493052f, 
    -0.03584668f, -0.00327382f, -0.03708200f, -0.00675302f, -0.01144143f, 0.04852735f, -0.03238520f, -0.02812134f, 
    -0.02559101f, 0.04965178f, 0.04168206f, -0.05414270f, 0.01972151f, -0.03609804f, 0.03267262f, -0.01816543f, 
    -0.02196267f, 0.01725042f, -0.01646812f, -0.03387731f, -0.04131425f, -0.05182195f, -0.01199814f, -0.03255627f, 
    0.00913361f, -0.05955202f, -0.01730389f, -0.02726083f, 0.03269998f, -0.03837423f, 0.00933334f, 0.02691938f, 
    -0.04632860f, -0.00756478f, 0.01702020f, -0.00372573f, -0.00803920f, -0.01194287f, 0.04007975f, -0.02338573f, 
    0.04361571f, -0.00888234f, 0.03265566f, -0.02218992f, -0.03599904f, -0.06046152f, 0.03543813f, -0.01227145f, 
    0.02889379f, -0.05786514f, -0.00136725f, -0.00334134f, -0.03004614f, -0.02835351f, 0.03490999f, 0.02645754f, 
    -0.05225918f, 0.04555258f, -0.01817008f, 0.03706526f, 0.00666142f, 0.02569812f, 0.02007663f, -0.02106163f, 
    0.04148110f, 0.00653964f, -0.04050786f, -0.02785750f, 0.03452747f, -0.02762352f, -0.01009568f, -0.05246685f, 
    -0.01951036f, -0.05154321f, -0.03390914f, -0.00342582f, -0.00828588f, -0.05067773f, 0.00773760f, 0.02038388f, 
    -0.05115017f, -0.02107099f, -0.01701338f, -0.04253367f, -0.00527673f, -0.01109282f, -0.05916417f, 0.03363451f, 
    -0.00874868f, 0.01384626f, -0.05751572f, 0.03480114f, 0.03162819f, -0.01811722f, -0.05053367f, -0.02020555f, 
    -0.04583586f, -0.04879439f, -0.05516207f, 0.02647402f, -0.03650707f, -0.03418226f, 0.00560620f, 0.00851508f, 
    -0.04569166f, 0.03120202f, 0.03992570f, -0.05558029f, -0.05053499f, 0.05061580f, -0.00359307f, -0.00461167f, 
    0.03175282f, 0.02452905f, -0.01359840f, 0.05018896f, -0.03619688f, -0.00989964f, 0.03850478f, -0.05100059f, 
    -0.03885261f, -0.00807450f, 0.02518326f, -0.04321677f, 0.01041002f, -0.03167098f, 0.03110695f, -0.02359182f, 
    0.04258450f, -0.01341925f, -0.00250642f, -0.00625181f, 0.04462543f, 0.01323777f, 0.01523296f, 0.03010796f, 
    0.00444052f, 0.02722562f, 0.01122240f, -0.05487252f, -0.04813695f, -0.04229008f, 0.03677249f, -0.03920249f, 
    0.00729872f, 0.02255953f, 0.03779597f, -0.02763176f, -0.03008937f, 0.00647220f, -0.01696564f, 0.00917577f, 
    -0.00420482f, -0.00834662f, -0.01482701f, 0.05015690f, -0.05396110f, -0.00813786f, -0.01790419f, -0.00512306f, 
    0.02096385f, 0.01399817f, -0.00844241f, 0.01599206f, -0.00005932f, -0.05722981f, 0.04014853f, 0.01908807f, 
    0.03640950f, -0.01866172f, 0.00303240f, 0.02951312f, -0.01512306f, 0.00297941f, -0.01146724f, -0.00821641f, 
    0.03912601f, -0.00415066f, -0.03447741f, 0.04459846f, 0.03344951f, -0.04407948f, -0.01072972f, -0.00684770f, 
    0.02518870f, -0.06045471f, 0.04357002f, -0.00635400f, -0.02800511f, -0.03493919f, -0.02718552f, 0.02760442f, 
    -0.01235131f, -0.05131161f, 0.03317586f, -0.01920850f, -0.02670752f, -0.00737227f, -0.00190209f, -0.01843042f, 
    -0.05055366f, 0.00410278f, -0.04375334f, -0.03826271f, 0.01676827f, -0.03819958f, -0.03391830f, 0.04376156f, 
    0.04087223f, -0.04284190f, -0.00097195f, -0.00742333f, -0.00863781f, -0.04924016f, -0.02948794f, 0.02866489f, 
    -0.02645021f, 0.04054894f, -0.03520995f, 0.02644578f, 0.02006900f, 0.00062550f, -0.03670164f, -0.03372427f, 
    0.04989749f, 0.03314099f, 0.04990307f, -0.01953891f, -0.03834456f, -0.02195787f, 0.00603345f, -0.03846094f, 
    -0.02651249f, 0.01501621f, -0.00130435f, -0.04518986f, -0.02632284f, -0.04721688f, -0.05992197f, -0.03071666f, 
    0.02269202f, -0.02830672f, -0.04955145f, 0.05010578f, -0.03114905f, -0.02309035f, -0.03329756f, 0.03247434f, 
    -0.00202065f, 0.01847325f, 0.01092664f, -0.03897529f, -0.04501978f, 0.03406723f, -0.00342071f, 0.01297230f, 
    -0.02865977f, -0.02019396f, -0.05459242f, -0.06007289f, -0.02276737f, -0.02552232f, -0.06027937f, 0.00277921f, 
    -0.03536751f, 0.03954785f, -0.00191685f, 0.01035533f, 0.04469586f, 0.01879125f, -0.02765912f, 0.03791284f, 
    0.01743357f, 0.02532217f, -0.05690219f, -0.03146232f, 0.01877903f, -0.03981939f, 0.02373053f, -0.03028649f, 
    -0.02334083f, -0.05815108f, 0.03063570f, -0.02267465f, 0.01650687f, 0.03707329f, -0.05735698f, -0.05430897f, 
    -0.00989244f, 0.00139462f, 0.02691307f, -0.00968908f, 0.04217945f, -0.00554944f, 0.00076950f, -0.02460309f, 
    -0.01265694f, 0.02263923f, 0.01496784f, 0.02084146f, -0.00607646f, 0.04192243f, -0.00812033f, -0.03682701f, 
    -0.03740340f, 0.00587150f, 0.01135294f, -0.04670874f, -0.02777291f, -0.00628481f, -0.05971656f, 0.02659118f, 
    0.02875186f, -0.01151976f, -0.01998849f, 0.03731801f, 0.00452111f, 0.03100163f, 0.00587162f, 0.03601689f, 
    0.01844680f, -0.05601503f, -0.05287055f, -0.00982044f, -0.03593753f, -0.02209099f, -0.00251564f, -0.04188494f, 
    -0.00362760f, 0.01970826f, -0.01900727f, -0.04812444f, -0.02737652f, -0.05202354f, -0.01024333f, 0.01580430f, 
    0.03295581f, -0.04779671f, -0.05670244f, 0.01448389f, -0.00733349f, 0.01043256f, -0.00113788f, -0.04177732f, 
    0.01096244f, -0.05813488f, -0.05613479f, 0.04106390f, 0.03786106f, -0.02844642f, 0.02863425f, -0.04601152f, 
    -0.01741616f, -0.03468399f, 0.03282129f, -0.02032194f, 0.05109612f, 0.01773134f, -0.04361509f, 0.03411542f, 
    -0.00525820f, 0.03176776f, -0.04340620f, 0.04798106f, 0.00126451f, -0.01261145f, 0.04670931f, 0.00838795f, 
    0.02028905f, -0.02606635f, 0.01850417f, -0.00548975f, -0.02053995f, -0.03113977f, -0.04116293f, -0.02238339f, 
    -0.00131504f, 0.01638811f, -0.04229529f, -0.05373489f, -0.01356772f, -0.05084291f, -0.05183187f, 0.02071670f, 
    -0.01569730f, 0.04476938f, -0.00632517f, -0.06031454f, 0.02436972f, -0.00354124f, -0.01993275f, -0.06114766f, 
    0.00261872f, 0.04246084f, 0.03370308f, -0.04578988f, 0.04832016f, 0.02016446f, -0.00866296f, 0.00659382f, 
    0.04856906f, 0.01194589f, -0.00853747f, 0.00981551f, -0.04645614f, -0.05520337f, -0.03078497f, -0.01989206f, 
    0.00868005f, -0.00413826f, -0.04831049f, 0.02795012f, 0.01625942f, -0.06329011f, 0.04357535f, -0.01755605f, 
    0.04089655f, -0.00587123f, -0.05063280f, -0.02675656f, 0.04372048f, 0.04049931f, 0.03949918f, -0.03918213f, 
    -0.04317976f, -0.02001217f, -0.04949728f, 0.03831360f, -0.03250517f, 0.00558619f, -0.04826447f, 0.04394717f, 
    0.00603530f, -0.02751465f, 0.04496101f, 0.02216512f, -0.05376682f, -0.05319703f, -0.02345814f, -0.01967316f, 
    0.02651221f, 0.01215724f, 0.04091701f, -0.03935933f, -0.05680190f, -0.04685440f, -0.01408024f, -0.01213862f, 
    -0.03322440f, 0.00753377f, -0.01217219f, 0.01506703f, -0.04731295f, -0.02371485f, 0.01191311f, 0.02033577f, 
    0.02753043f, -0.04282514f, -0.04987108f, -0.04758660f, -0.05956182f, 0.04237708f, -0.01346972f, -0.04986771f, 
    -0.01421292f, -0.05154081f, 0.04163932f, 0.03182382f, -0.00554250f, -0.04133049f, -0.00182612f, 0.03196250f, 
    -0.02474563f, -0.01415609f, -0.02546279f, 0.04313179f, 0.00017346f, 0.04338716f, -0.04375909f, -0.00174967f, 
    0.02423515f, 0.01823580f, 0.04551812f, 0.04207639f, -0.02891430f, 0.02648265f, 0.01647711f, -0.06106836f, 
    -0.01412340f, -0.01339343f, 0.03066451f, 0.01422983f, -0.04685116f, 0.01958978f, -0.01974747f, 0.03483687f, 
    -0.04015042f, -0.01060892f, -0.04295864f, 0.04861213f, 0.03875312f, -0.03075968f, -0.00193239f, 0.01442326f, 
    -0.05241164f, -0.05841033f, 0.02174004f, 0.00358367f, 0.04055712f, -0.03107953f, 0.02727876f, -0.01431166f, 
    -0.04789006f, -0.00373855f, -0.02155152f, 0.02655423f, -0.00605224f, -0.02834385f, 0.04172592f, 0.00111584f, 
    0.03187216f, -0.03923778f, -0.03357195f, -0.06076297f, 0.03715505f, -0.04972485f, 0.04158734f, 0.02922117f, 
    -0.03833706f, -0.03835184f, -0.05272700f, -0.04290596f, 0.03391996f, 0.03498064f, 0.03382885f, -0.05111069f, 
    -0.01021009f, -0.03348359f, 0.04102968f, 0.03278405f, -0.01204169f, 0.01187514f, 0.02154120f, -0.01875331f, 
    0.00333548f, 0.00023298f, 0.01686979f, -0.03672238f, -0.02698406f, -0.03216384f, -0.02412734f, -0.02715358f, 
    -0.03005002f, 0.00524095f, 0.04240014f, -0.01482088f, -0.02555165f, -0.02924156f, 0.02005050f, -0.06573714f, 
    -0.01340428f, 0.03163046f, -0.02939627f, -0.02869878f, 0.00131514f, -0.05441396f, 0.04555156f, -0.04861248f, 
    0.04424516f, -0.00812719f, 0.00041616f, -0.04227807f, 0.03696347f, 0.04573069f, -0.01452363f, -0.02661572f, 
    0.00454353f, -0.03474357f, -0.03571094f, -0.02377825f, 0.00685871f, 0.00775847f, 0.03304464f, 0.00975092f, 
    0.17728458f, 0.08135117f, 0.21004130f, -0.01950295f, -0.11083764f, -0.02984787f, 0.01880516f, 0.10756318f, 
    -0.20005667f, -0.11367235f, 0.02938105f, 0.06142263f, -0.06540563f, -0.04111077f, -0.07238731f, -0.01912547f, 
    -0.12286243f, 0.07713501f, 0.00589012f, 0.00370539f, 0.00281778f, -0.03354236f, -0.10063654f, -0.06723341f, 
    0.08197148f, 0.10852453f, -0.07921194f, -0.02819328f, -0.11120278f, 0.09181115f, -0.01024004f, 0.13720417f, 
    0.09355053f, -0.09616096f, 0.12659141f, 0.12174864f, 0.02817934f, 0.27222916f, -0.16449413f, 0.01547333f, 
    0.13890074f, 0.14889534f, 0.12491056f, -0.24659584f, 0.20150170f, -0.09420725f, -0.08265332f, 0.01251936f, 
    -0.00676385f, -0.16189386f, 0.09192115f, 0.10334296f, 0.08930811f, -0.14577478f, -0.11627818f, 0.05928466f, 
    0.07996739f, 0.00345092f, -0.00225319f, -0.03743433f, 0.47107783f, -0.02072899f, 0.13166897f, -0.18630338f, 
    0.16529596f, -0.09308106f, -0.08545987f, -0.06409860f, 0.03602729f, -0.04620724f, -0.00233823f, 0.02982198f, 
    -0.00992257f, 0.03781934f, -0.02751694f, 0.12240695f, 0.13332650f, -0.05835874f, -0.19588210f, 0.03453926f, 
    0.29744467f, -0.47829917f, 0.10344249f, -0.11855132f, -0.29762104f, -0.06528029f, 0.06373671f, 0.04555697f, 
    0.07170942f, 0.11032331f, 0.04470841f, 0.11022348f, -0.00605034f, 0.12213554f, 0.11470017f, 0.05313985f, 
    -0.20802918f, -0.15551263f, -0.11684686f, -0.13751331f, 0.20183283f, 0.04534792f, 0.03015733f, 0.06825686f, 
    -0.15893728f, 0.10841042f, 0.03071905f, 0.05985451f, 0.01833787f, -0.03026643f, -0.07705875f, 0.16080533f, 
    -0.05234516f, 0.04240840f, 0.00450364f, -0.01123911f, -0.01886631f, -0.08746845f, 0.06603963f, -0.03194389f, 
    -0.22204658f, -0.24155134f, -0.08710687f, -0.14361764f, -0.39317799f, -0.35055801f, 0.15031958f, -0.05770556f, 
    -0.00198131f, -0.02981114f, 0.04527221f, 0.03267185f, -0.14220490f, -0.08628725f, 0.05152168f, -0.04107854f, 
    -0.09160637f, 0.08867694f, 0.08653154f, 0.14969578f, 0.28100133f, 0.17706116f, -0.10341046f, 0.03957392f, 
    0.43348017f, -0.07697739f, 0.08568173f, 0.09613861f, -0.03222623f, 0.12836686f, 0.05705436f, -0.06863479f, 
    0.06861789f, 0.16555189f, 0.04336605f, -0.04813701f, -0.03974592f, -0.05753070f, -0.09168136f, 0.05008402f, 
    0.14674564f, -0.14229372f, 0.16900338f, -0.06991948f, -0.24039954f, 0.09874634f, 0.14678496f, -0.06579001f, 
    -0.05826720f, -0.19176263f, 0.02832170f, 0.08444677f, -0.13035634f, -0.14456178f, -0.17720877f, -0.06692430f, 
    0.03306516f, 0.09445860f, 0.24090469f, 0.11359303f, -0.19367324f, -0.46065086f, 0.13066100f, 0.14316356f, 
    -0.32720345f, -0.04845580f, 0.08587881f, 0.03208712f, -0.05000602f, -0.12407942f, 0.13963573f, -0.05920833f, 
    -0.11558903f, -0.01769214f, -0.14508280f, 0.09810774f, -0.01686756f, 0.15215622f, 0.05577486f, -0.00133903f, 
    0.20881005f, 0.39051425f, 0.07220199f, 0.01023606f, 0.06460412f, 0.00105557f, 0.09068985f, -0.06478271f, 
    0.07161424f, 0.09594487f, 0.03359151f, -0.15828678f, -0.07606997f, 0.02015542f, 0.02162561f, -0.00273195f, 
    -0.02298703f, 0.04585660f, 0.07602607f, -0.02574903f, -0.02619211f, 0.14385140f, -0.09253594f, -0.30945021f, 
    -0.03159191f, -0.11328518f, -0.01459384f, -0.01497585f, -0.00221516f, 0.05008128f, 0.04760154f, 0.09163322f, 
    -0.01276804f, 0.02550098f, 0.01052991f, -0.11978105f, -0.00109586f, 0.10472412f, -0.00605573f, 0.07597522f, 
    0.19912718f, -0.12647966f, 0.06907789f, -0.02170181f, 0.13589048f, 0.05449561f, -0.01573604f, 0.03405385f, 
    0.12378670f, 0.01469587f, 0.00351446f, -0.07268755f, -0.04814266f, 0.07594648f, -0.01144700f, 0.01507558f, 
    -0.07223349f, 0.02288577f, -0.03755225f, -0.04595305f, 0.16142203f, 0.34937245f, -0.06133179f, 0.34524477f, 
    -0.21862285f, 0.02775807f, 0.03122774f, -0.03398753f, 0.00280987f, 0.08006345f, 0.03267888f, -0.22677475f, 
    0.05924648f, 0.09462941f, 0.08739825f, -0.05016658f, -0.10934491f, 0.02145855f, 0.06387132f, 0.00830325f, 
    0.15780005f, 0.03924262f, 0.22161931f, 0.02589220f, 0.01371941f, 0.01806765f, 0.12070084f, -0.10246658f, 
    0.09808799f, 0.08871195f, 0.02100403f, -0.01974863f, -0.02416369f, 0.14008872f, -0.02954283f, 0.00923443f, 
    0.10059150f, -0.05711271f, -0.04399849f, 0.04718160f, 0.39351150f, 0.30766478f, -0.02333215f, -0.30796772f, 
    0.15240981f, 0.08178993f, -0.05248882f, 0.15402709f, -0.03386597f, 0.08033993f, -0.06200140f, 0.04710726f, 
    0.11463053f, 0.00771797f, 0.13870564f, -0.03074363f, -0.06538513f, 0.07879200f, -0.07244933f, -0.11168104f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04678981f, 0.08951087f, 0.02205085f, -0.00861817f, 0.00788113f, -0.00080926f, 0.00982115f, -0.06093394f, 
    0.05094861f, -0.03185621f, 0.08316971f, 0.03227309f, -0.02921868f, 0.08513290f, 0.04773355f, 0.01659160f, 
    0.09062626f, -0.05479741f, -0.04747201f, -0.03198033f, -0.07267303f, 0.15004116f, -0.02937786f, -0.00013221f, 
    0.10520443f, 0.06055887f, 0.08624588f, 0.03159953f, 0.02780814f, 0.04560796f, -0.01605031f, -0.09325956f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.05991031f, -0.11006530f, -0.26305759f, -0.11978412f, 0.37712485f, 0.08687047f, -0.17194015f, -0.16212012f, 
    0.56529450f, 0.06375151f, 0.18954758f, 0.14351797f, -0.14926176f, 0.08998121f, -0.07203349f, -0.15996097f, 
    0.22446147f, -0.10261583f, 0.12103708f, -0.09150150f, -0.17652303f, 0.33589748f, -0.00560406f, -0.23019557f, 
    -0.18295744f, 0.01900974f, 0.17829660f, 0.08929934f, 0.06788491f, -0.13663141f, -0.12743972f, 0.19262409f, 
    0.07159767f, -0.13493213f, 0.43636960f, -0.08433492f, 0.27751076f, 0.15565719f, 0.09130409f, -0.04769428f, 
    -0.11726717f, 0.16471319f, -0.34130678f, -0.04115983f, -0.01353508f, 0.29381087f, -0.07183680f, -0.02916322f, 
    0.14362352f, 0.17145607f, -0.16099533f, 0.10981742f, 0.09377733f, -0.22155991f, -0.01554641f, 0.01612837f, 
    0.05939799f, 0.13005474f, -0.07851310f, -0.08285174f, 0.08438767f, 0.15076996f, 0.15895246f, 0.03411062f, 
    0.05602957f, 0.17808945f, 0.14847593f, -0.08600724f, -0.12310813f, -0.08732216f, -0.08257291f, -0.09597546f, 
    -0.46055540f, 0.10757407f, -0.20709701f, 0.07726762f, -0.04730701f, -0.13847910f, 0.35207093f, 0.06508031f, 
    -0.02504809f, 0.05746602f, -0.02908916f, 0.10237672f, 0.20602596f, 0.08538221f, 0.15583280f, 0.09723268f, 
    -0.01017679f, 0.45241982f, 0.23278919f, -0.08990093f, -0.16486081f, 0.05413773f, 0.13720338f, 0.05357416f, 
    0.06785648f, 0.03371891f, 0.07303524f, 0.08357119f, 0.20256260f, -0.05952219f, 0.00013080f, -0.00986010f, 
    0.20141131f, -0.15330862f, -0.25935364f, -0.09861031f, -0.15187891f, 0.39451763f, 0.02637174f, -0.14059027f, 
    -0.03454008f, 0.10465175f, 0.00493441f, 0.14390083f, 0.18643357f, 0.16312835f, 0.16322863f, -0.03194726f, 
    0.19651537f, 0.33661771f, -0.23973459f, -0.00303109f, 0.15968312f, -0.08514080f, -0.15743977f, -0.43087476f, 
    0.15790485f, 0.01756261f, -0.04246644f, 0.01429797f, 0.24737298f, 0.09003789f, -0.14852381f, 0.02704767f, 
    0.53018802f, 0.15156820f, -0.13753539f, -0.10877571f, -0.15289828f, -0.03333787f, -0.38356429f, 0.30105576f, 
    0.34688559f, 0.16958460f, -0.14140718f, 0.08902957f, -0.20516352f, 0.01044093f, 0.06334087f, -0.38976347f, 
    0.15252289f, 0.20013846f, 0.30840868f, -0.02733089f, 0.12397014f, -0.10527671f, 0.09328934f, 0.30614060f, 
    0.14139290f, 0.27402356f, 0.48472208f, 0.04914004f, 0.07605964f, -0.05516367f, 0.01270502f, -0.17572117f, 
    0.05318293f, 0.07596111f, -0.34423277f, 0.01707304f, 0.09884909f, 0.12775636f, -0.40095165f, -0.05737105f, 
    0.30553538f, 0.07893258f, 0.02171045f, 0.09157272f, 0.01998533f, 0.04651298f, -0.10208609f, -0.03852544f, 
    0.12805833f, -0.22282106f, -0.15877773f, -0.11921023f, 0.07292568f, -0.12494555f, 0.08844166f, -0.10739765f, 
    -0.16502358f, 0.28747538f, 0.22230977f, -0.00507624f, -0.53105706f, 0.10794926f, -0.12928812f, 0.04024747f, 
    -0.16311961f, -0.07629819f, -0.02069875f, -0.12600061f, -0.07409021f, 0.18395899f, -0.20798348f, 0.38256961f, 
    0.11970600f, -0.13077582f, -0.15341724f, -0.04329843f, -0.09883817f, 0.24766676f, 0.10263372f, 0.29004684f, 
    0.10482369f, -0.19736375f, -0.28022897f, 0.09020666f, -0.03788304f, 0.15909730f, -0.07278612f, -0.09489907f, 
    0.08850792f, 0.04896450f, -0.10678546f, -0.14143112f, 0.48452508f, -0.17721362f, -0.02902213f, 0.17230161f, 
    -0.19976011f, 0.08145350f, -0.02880742f, -0.18244572f, -0.17526041f, -0.31467336f, -0.32856512f, 0.38419521f, 
    0.09428271f, 0.10173471f, -0.14215241f, -0.01996593f, 0.47353446f, 0.04062093f, 0.14868824f, 0.45027861f, 
    -0.20798054f, 0.16812421f, -0.16943350f, 0.17202242f, 0.08314467f, -0.06528953f, -0.09255552f, 0.21557379f, 
    -0.09439083f, -0.38766500f, 0.35145876f, -0.03984991f, -0.08168120f, 0.07113522f, -0.06863123f, 0.09360553f, 
    -0.12864265f, -0.02453077f, 0.15180637f, 0.16614449f, -0.01852815f, 0.24250494f, 0.32333693f, 0.21334177f, 
    0.04931138f, -0.05225440f, -0.14918995f, 0.01098351f, -0.24443832f, 0.01251883f, 0.11353078f, -0.35055116f, 
    0.01527107f, 0.03048689f, 0.60776752f, -0.10413721f, -0.15333350f, -0.12365379f, 0.10086853f, 0.24076781f, 
    0.07584010f, 0.35009894f, -0.07940439f, 0.03602198f, 0.77456194f, 0.09414911f, -0.03664272f, 0.12705283f, 
    0.11016236f, -0.11712299f, 0.15412399f, -0.14547034f, -0.02381965f, -0.25426650f, -0.08696187f, -0.34900677f, 
    -0.40002862f, -0.12729996f, -0.14685255f, -0.06154699f, 0.15727596f, -0.19089140f, 0.16219833f, 0.19988836f, 
    0.32583874f, 0.00651226f, 0.38561696f, -0.01450743f, -0.03439338f, -0.00494507f, -0.16967957f, 0.09805482f, 
    -0.06149926f, 0.28476793f, 0.10616395f, 0.02995624f, -0.00050665f, 0.01149768f, 0.00359269f, -0.01457334f, 
    -0.10101771f, -0.16513626f, 0.30472881f, -0.12718503f, 0.08951291f, 0.14066994f, 0.18528384f, 0.05735598f, 
    -0.55808473f, 0.00185663f, -0.14829853f, 0.02579641f, 0.37715530f, 0.08775357f, -0.06253640f, 0.24079490f, 
    0.29022020f, -0.03689634f, -0.48663667f, -0.10442538f, 0.07299623f, 0.15174253f, 0.14669523f, 0.46271896f, 
    -0.03482990f, 0.02860138f, 0.52648485f, -0.07973256f, -0.13330631f, -0.09874441f, 0.01911081f, -0.01416392f, 
    0.05697178f, -0.18008590f, -0.42929834f, 0.14201193f, 0.06504311f, 0.16843097f, -0.07542268f, -0.05923627f, 
    0.23423220f, 0.05040863f, 0.13861041f, 0.13622391f, 0.20952408f, 0.06168457f, -0.11033720f, 0.13970542f, 
    -0.14254120f, 0.36231080f, -0.28327698f, 0.12790306f, -0.08163074f, 0.05349737f, -0.15664053f, 0.04844709f, 
    0.14797598f, 0.13726942f, 0.26924354f, -0.03549057f, -0.04343530f, -0.06346326f, -0.14659323f, 0.05517653f, 
    0.16706522f, -0.07498796f, 0.34284204f, 0.04051758f, -0.10187566f, -0.00829207f, 0.14661503f, -0.18816502f, 
    -0.15485874f, -0.14125264f, -0.00877683f, 0.09776776f, -0.40665969f, 0.33198789f, 0.03702953f, 0.13119262f, 
    0.35744080f, -0.10110161f, -0.07566178f, -0.16875376f, -0.09463569f, 0.13202219f, -0.13242035f, -0.39539582f, 
    -0.06892478f, -0.01841697f, 0.55032265f, 0.04870155f, 0.03699599f, 0.15940942f, 0.00416922f, -0.12857501f, 
    -0.16125771f, 0.00667114f, 0.09524568f, 0.06723960f, 0.11756764f, -0.02503877f, -0.04511530f, -0.16873623f, 
    -0.11081312f, -0.13145056f, 0.09034315f, 0.09378174f, -0.30109918f, -0.06205852f, -0.10659799f, 0.49273276f, 
    0.38487440f, 0.17216538f, 0.35578582f, -0.14354467f, 0.04200733f, -0.02089519f, 0.04629927f, -0.33908808f, 
    0.15465358f, -0.02039904f, 0.58950502f, 0.09774311f, -0.15890463f, 0.13727301f, 0.03324055f, -0.03888592f, 
    -0.13760345f, 0.10406274f, 0.01305398f, -0.16725986f, -0.10067304f, -0.11939110f, 0.31615931f, -0.05800056f, 
    0.44266742f, 0.09080287f, 0.09116549f, 0.01194110f, 0.42553425f, 0.26918843f, 0.16729723f, 0.04882127f, 
    -0.17775658f, -0.42917350f, 0.37474191f, 0.15775326f, -0.10428283f, -0.09301646f, -0.04423005f, 0.06016538f, 
    0.01086572f, -0.13005920f, -0.05019294f, 0.03855509f, -0.12713541f, -0.08596035f, 0.14915717f, -0.13646221f, 
    -0.14911200f, 0.08908137f, -0.14841512f, -0.04551948f, -0.16100501f, 0.12728955f, -0.21049009f, 0.07277399f, 
    0.03151792f, 0.14921650f, 0.14542356f, 0.03641316f, 0.10026905f, 0.12155528f, -0.00399025f, -0.19715236f, 
    -0.09872606f, -0.11605813f, -0.17449652f, -0.17116180f, 0.15955496f, 0.13209617f, -0.02369713f, 0.02954661f, 
    0.15179585f, 0.10503404f, -0.34446424f, 0.01719809f, -0.22146705f, -0.05055748f, 0.08381497f, 0.15386455f, 
    -0.17958036f, -0.09367150f, 0.26845494f, 0.17393224f, -0.10039201f, 0.59375918f, 0.54907054f, 0.19790405f, 
    -0.28002861f, 0.11162319f, 0.16416131f, -0.06173018f, -0.27924752f, -0.02038282f, 0.16017109f, -0.01455492f, 
    0.04129422f, 0.50977182f, 0.12298429f, -0.05515574f, -0.05627792f, -0.11932777f, -0.01748874f, -0.30699885f, 
    0.08675921f, -0.16918468f, 0.47126389f, -0.04730744f, -0.37074047f, 0.10269720f, 0.01828881f, -0.00447192f, 
    0.30907249f, 0.00432589f, 0.20016606f, 0.15252401f, 0.02591342f, 0.33597207f, 0.17388219f, -0.05505326f, 
    0.16073307f, -0.03787792f, -0.06171613f, 0.00249745f, -0.02717892f, 0.30524102f, -0.07252677f, -0.27870905f, 
    0.01799278f, -0.33703646f, 0.31989944f, -0.07469209f, -0.04525538f, 0.05363939f, 0.04859428f, 0.05775949f, 
    -0.12207534f, 0.18963473f, 0.21217044f, -0.03671308f, 0.25803587f, 0.14681131f, -0.17892718f, 0.14928807f, 
    -0.16685893f, -0.02033962f, -0.04830072f, -0.01629878f, 0.09763963f, -0.11479624f, -0.06026874f, 0.23930719f, 
    0.56244206f, 0.07031975f, -0.11786783f, -0.00223225f, 0.37862682f, -0.10637428f, 0.16359781f, 0.54291898f, 
    -0.25591996f, -0.27513483f, -0.13293882f, -0.08951121f, 0.08763705f, 0.15472211f, 0.05504029f, -0.21694905f, 
    0.13058756f, -0.24869493f, -0.40572903f, -0.11782662f, 0.33050823f, 0.00959887f, 0.10989439f, 0.10071698f, 
    0.36468884f, -0.11574137f, 0.20476800f, -0.12752777f, 0.02551083f, -0.05220366f, -0.40937838f, -0.09421996f, 
    0.41009420f, 0.05656049f, 0.02400970f, -0.14905061f, -0.46597847f, 0.27984366f, 0.07682547f, 0.30762741f, 
    0.34330848f, 0.19109650f, -0.18519557f, 0.01321711f, 0.14507018f, 0.14332230f, -0.06092112f, -0.08709970f, 
    0.08161513f, 0.52567428f, 0.18151532f, -0.15873599f, 0.33092716f, 0.15853621f, -0.11106219f, 0.10269891f, 
    0.44595730f, -0.10991309f, -0.24178934f, -0.08971110f, -0.16736609f, -0.04897140f, -0.19985959f, -0.04839917f, 
    -0.20915459f, -0.07591555f, -0.10471712f, -0.15765868f, 0.42923343f, 0.34146443f, 0.06081871f, -0.02288847f, 
    -0.13327692f, 0.14680125f, -0.04852629f, -0.13229325f, -0.05315498f, 0.03437608f, 0.16352344f, -0.13533317f, 
    0.09970910f, -0.00045069f, -0.17107524f, 0.03247172f, -0.22158453f, 0.00886367f, -0.09227849f, -0.03039557f, 
    -0.39485741f, -0.04063917f, 0.30842078f, 0.07082901f, 0.08806513f, 0.47781482f, 0.26892251f, 0.51835042f, 
    -0.33263212f, -0.03300958f, -0.13698554f, -0.09446112f, -0.23007901f, -0.12473979f, 0.03610069f, 0.13384964f, 
    0.20010027f, 0.03649648f, -0.19134836f, -0.13434987f, 0.14886916f, 0.16478410f, -0.00237937f, 0.51561153f, 
    0.17172511f, 0.11352617f, -0.06888558f, -0.07729435f, 0.19087391f, -0.12470299f, 0.13223311f, -0.12745543f, 
    0.19063935f, -0.14215410f, -0.18814921f, 0.07064017f, -0.07907914f, -0.52354884f, 0.03278392f, 0.06523125f, 
    -0.03924632f, 0.13596807f, 0.00871486f, 0.04694794f, 0.03419358f, -0.01321482f, -0.06606529f, -0.06041563f, 
    0.17509232f, 0.37434024f, 0.38624159f, 0.02621999f, -0.16488580f, 0.00467827f, 0.13094349f, 0.22904159f, 
    0.14531095f, 0.58570200f, -0.23197080f, 0.09046900f, -0.17779228f, 0.00535543f, 0.04027338f, -0.01705227f, 
    0.15978225f, -0.16027348f, -0.32019198f, -0.14209163f, -0.13573711f, -0.31423101f, -0.05312988f, 0.25838026f, 
    0.01572986f, 0.13637023f, 0.10887408f, 0.15104948f, -0.23676471f, 0.26362768f, 0.08687467f, 0.03130149f, 
    0.13045077f, 0.39233330f, 0.26536039f, 0.15023245f, 0.10550642f, 0.14256108f, -0.04995213f, -0.59110498f, 
    0.06011444f, 0.01490873f, -0.03767797f, -0.13925225f, 0.11336600f, -0.00096132f, 0.16215721f, 0.12289818f, 
    -0.16711617f, 0.06086114f, -0.08362022f, -0.17641155f, 0.13228160f, -0.18409084f, 0.07509908f, -0.23256062f, 
    0.02665359f, 0.02622989f, 0.00568177f, 0.16143604f, 0.10450872f, 0.08851906f, 0.15076622f, 0.10337815f, 
    -0.13911551f, -0.07501204f, -0.23531236f, 0.17052798f, 0.07330815f, -0.02397962f, -0.01332244f, -0.10421430f, 
    -0.03202383f, 0.22613540f, -0.00880865f, -0.02922165f, -0.28663254f, -0.10809879f, 0.09708711f, -0.09424589f, 
    0.08880668f, -0.00818032f, -0.12056577f, -0.15091635f, -0.15717167f, 0.62548327f, 0.36584380f, 0.14600590f, 
    -0.10024596f, -0.07350293f, -0.01545281f, -0.10090286f, 0.25871006f, 0.30211228f, 0.12507765f, -0.09327357f, 
    -0.12725742f, 0.07096162f, -0.19660497f, 0.02621460f, 0.13316046f, -0.09553091f, 0.16620880f, -0.17194371f, 
    0.12319436f, -0.26252803f, -0.08596110f, 0.04266894f, -0.02013385f, -0.00826167f, -0.17204079f, -0.12229868f, 
    0.17838499f, 0.01347573f, 0.18905580f, -0.04952135f, 0.11762683f, 0.45446324f, -0.22143587f, 0.36103815f, 
    0.23253487f, 0.07023913f, -0.15561777f, 0.09145518f, -0.18916693f, 0.17293076f, -0.09623376f, -0.48716193f, 
    -0.03902850f, 0.02192440f, -0.01084604f, 0.08645704f, 0.10621434f, -0.09751638f, 0.14193651f, 0.22790873f, 
    0.02902081f, -0.04062422f, -0.19566980f, -0.00895046f, -0.05593852f, -0.17031296f, 0.14814310f, -0.07126351f, 
    -0.28316712f, -0.16077843f, 0.21127160f, -0.08610944f, -0.00587029f, -0.31933129f, 0.04423475f, 0.23981495f, 
    0.52082163f, -0.08261748f, 0.15586653f, 0.06705757f, 0.18159328f, 0.00293246f, -0.07306285f, 0.54324669f, 
    0.01187303f, 0.11555167f, -0.22016495f, 0.08983262f, 0.17895633f, 0.04201611f, -0.06370296f, -0.38848385f, 
    0.16383158f, -0.04049646f, -0.14321037f, -0.03638702f, 0.10270660f, -0.11528604f, 0.13317086f, 0.08388599f, 
    0.04121162f, 0.02728908f, 0.05888468f, 0.03725668f, 0.12585190f, -0.10715605f, -0.05622711f, -0.12352693f, 
    -0.13648103f, -0.10516285f, 0.16325983f, -0.07452179f, -0.03381168f, -0.17198133f, -0.08669939f, 0.07321882f, 
    -0.07980014f, -0.02595145f, -0.11396689f, -0.02157568f, 0.02287101f, 0.09099698f, 0.02165642f, 0.08417812f, 
    0.02428067f, 0.32849833f, 0.28107697f, -0.02067682f, 0.43487900f, -0.12951918f, 0.03572904f, -0.10314269f, 
    -0.23753472f, -0.01365737f, -0.15994725f, 0.12959920f, -0.08735393f, 0.07155455f, 0.39026478f, -0.05427326f, 
    0.08079983f, -0.00334102f, -0.01509702f, 0.07659572f, 0.51092577f, -0.00954970f, -0.10648274f, 0.02675752f, 
    -0.33649009f, -0.21165414f, 0.43778673f, 0.07805603f, 0.08957560f, 0.02303837f, -0.14156227f, 0.15892437f, 
    -0.10981409f, 0.10773473f, -0.11928241f, 0.08303076f, -0.08810335f, 0.00402405f, -0.10900676f, -0.17008379f, 
    -0.12542915f, -0.16601567f, -0.02587551f, -0.10909276f, -0.13521405f, -0.08685697f, 0.10717597f, -0.00089614f, 
    0.08764875f, 0.12887423f, -0.12173647f, -0.10428721f, -0.14713685f, -0.12675187f, 0.14904781f, -0.10159954f, 
    -0.16120510f, 0.06844038f, -0.03247648f, 0.00332006f, -0.16917482f, 0.01067089f, -0.06365120f, -0.07783713f, 
    -0.04686549f, 0.33994597f, -0.39802003f, -0.15226677f, -0.33257702f, 0.17028265f, -0.01839782f, 0.08379886f, 
    0.23383380f, -0.07970458f, -0.11183807f, -0.01281317f, 0.01167889f, -0.10949988f, 0.22785833f, 0.37533867f, 
    -0.03481005f, -0.03372306f, 0.06663805f, -0.13718455f, 0.12393498f, 0.20236318f, -0.09070743f, -0.25956926f, 
    -0.20496331f, 0.34038559f, -0.02534570f, 0.09395151f, -0.07650624f, -0.14496958f, 0.04324419f, -0.12641372f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.05285098f, -0.13281626f, -0.01936343f, 0.06443103f, -0.00334710f, -0.08122082f, 0.13451822f, 0.03568532f, 
    -0.04118762f, 0.02456613f, -0.14848156f, 0.07266045f, 0.00921925f, 0.12808514f, 0.18551770f, -0.09581380f, 
    -0.03426478f, 0.00587401f, 0.05588822f, 0.26556194f, -0.01568090f, -0.09734285f, 0.21048637f, 0.13521105f, 
    -0.10382018f, 0.02975153f, 0.11663967f, 0.01785528f, 0.09162182f, -0.11711428f, 0.08240125f, 0.17140913f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.14908528f, -0.24536192f, 0.04191556f, -0.42656994f, 0.19258264f, -0.58438122f, 0.27768299f, -0.30833012f, 
    0.29895732f, -0.64379656f, 0.06270440f, -0.65859038f, -0.38286620f, -0.61048657f, 0.05678159f, 0.04136493f, 
    0.16085537f, 0.22441268f, -0.39616939f, -0.41058648f, -0.38259998f, 0.34977433f, -0.09079881f, -0.26065481f, 
    0.00832999f, 0.12582318f, 0.44665861f, -0.46924603f, 0.08033480f, -0.09339046f, -0.15833713f, 0.23297864f, 
    0.32787377f, 0.41620296f, -0.45721740f, 0.18925600f, 0.28955498f, 0.24605635f, -0.43734744f, -0.34673542f, 
    0.28141093f, 0.05530817f, -0.32120961f, 0.38864061f, -0.00916767f, 0.07280564f, -0.15427454f, -0.09935394f, 
    0.22889274f, 0.16210116f, -0.21451399f, 0.32180893f, -0.09383187f, -0.04792167f, -0.18132082f, -0.39048672f, 
    0.10148418f, -0.16870032f, 0.40278289f, -0.46331787f, 0.10064884f, -0.08889967f, 0.08783389f, -0.54927319f, 
    0.24780908f, -0.19886205f, 0.00773039f, -0.58693069f, 0.17192113f, -0.75308961f, -0.63437068f, 0.27460352f, 
    0.27590910f, 0.10515670f, 0.02598986f, -0.90204179f, -0.06478075f, 0.13836510f, 0.41605046f, 0.15931480f, 
    -0.75443417f, 0.29138717f, 0.01910873f, 0.15898390f, -0.06276892f, -0.24126875f, 0.09508696f, -0.55737567f, 
    0.08343135f, -0.61694849f, -0.11085318f, -0.15724692f, -0.16128333f, 0.14463177f, -0.02151165f, -0.49492615f, 
    0.23899309f, -0.71372646f, 0.16423737f, -0.11466031f, 0.02734825f, -0.56583035f, -0.37458280f, 0.17451113f, 
    -0.19644222f, -0.02265635f, -0.40438235f, -0.25544670f, -0.53032947f, -0.58611476f, 0.23965630f, -0.14150067f, 
    -0.07445391f, -0.12241271f, 0.15541796f, -0.09458796f, 0.21462385f, -0.69816250f, 0.11509557f, 0.32996982f, 
    0.10863239f, 0.00772043f, -0.19364130f, 0.21837601f, -0.03629733f, 0.31960481f, -0.01518427f, 0.37543389f, 
    -0.27893552f, 0.20079029f, 0.28026742f, 0.07474858f, -0.22286817f, -0.32748729f, -0.24369512f, -0.18180114f, 
    0.05732868f, 0.27592760f, 0.05857331f, 0.12405967f, -0.03871527f, 0.26047072f, -0.00933951f, -0.20366205f, 
    0.20260084f, -0.12713851f, -0.28622901f, -0.46925011f, 0.23964275f, 0.08053850f, 0.12939407f, 0.27619785f, 
    0.15838899f, -0.03315021f, -0.49154991f, -0.45979702f, 0.11916800f, 0.25639731f, 0.04592447f, 0.02583189f, 
    -0.03631848f, -0.28106296f, 0.07367075f, 0.37312242f, -0.26625091f, -0.04395807f, 0.14546707f, -0.52588069f, 
    -0.13636509f, -0.29970410f, 0.04398360f, 0.17631212f, 0.27166817f, 0.17269854f, -0.19913290f, -0.14425398f, 
    0.30957258f, 0.13065854f, -0.72310507f, 0.23566869f, -0.15126739f, -0.07388880f, -0.14460708f, 0.24360631f, 
    0.03604367f, 0.12464224f, -0.07511974f, 0.10916223f, -0.16123688f, -0.63069099f, 0.12018717f, 0.28424370f, 
    -0.43102711f, -0.12340883f, 0.31432924f, -0.23229255f, -0.00755267f, -0.41306761f, 0.18006596f, 0.29133993f, 
    0.03928791f, -0.16049373f, -0.16095963f, -1.38608265f, -0.24466343f, 0.29038173f, -0.17767254f, -0.07159769f, 
    0.20367631f, -0.50984049f, 0.19339983f, 0.22988634f, -0.80285293f, 0.18009469f, 0.19756928f, 0.16728200f, 
    -0.07463203f, -0.36053386f, -0.21697012f, 0.46642262f, -0.07916768f, -0.34813729f, 0.14396974f, 0.03562525f, 
    -0.36830071f, 0.15528221f, 0.08477540f, 0.42041823f, -0.13721664f, 0.24828206f, 0.11101733f, 0.20120975f, 
    -0.60561317f, -0.24103296f, -0.05852478f, 0.41793424f, -0.47037095f, -0.10381617f, 0.09424479f, -0.13255252f, 
    -0.19670050f, -0.33084619f, 0.19636542f, -0.03284253f, 0.33782300f, -0.60221440f, -0.09812975f, 0.00394764f, 
    0.00580261f, 0.11508660f, -0.46701092f, 0.02304520f, 0.12914316f, 0.02877723f, 0.13552149f, -0.24003941f, 
    0.17284906f, -0.19142494f, -0.43469769f, -0.03523876f, 0.07474615f, 0.02644159f, -0.70557183f, 0.05886142f, 
    -0.44280377f, 0.59357202f, 0.38708684f, -0.09283503f, 0.10416108f, 0.04684674f, -0.47498971f, -0.08784700f, 
    -0.15147687f, -0.34930339f, -0.25437039f, 0.38859585f, 0.07954976f, -0.07590637f, 0.24932756f, -0.17507933f, 
    -0.04393288f, -0.56877726f, -0.36817873f, 0.00978264f, -0.10471158f, -0.27384830f, 0.09855021f, -0.41463894f, 
    -0.20038527f, -0.03705344f, -0.12967575f, -0.24800146f, -0.84105498f, -0.06288172f, 0.18363768f, -0.10200240f, 
    -0.06820240f, -0.09240878f, 0.02837931f, -0.16086812f, 0.06496558f, 0.16186918f, 0.38952562f, -0.02891642f, 
    0.13038857f, 0.26957494f, 0.47105902f, -0.26503307f, -0.27255383f, 0.10626677f, -0.44006559f, -0.37312868f, 
    -0.09780522f, 0.00262649f, -0.24706650f, 0.28935802f, 0.11943594f, 0.28152248f, 0.08794309f, -0.60924804f, 
    -0.01988783f, -0.44557104f, -0.33906192f, -0.19899920f, 0.34446713f, 0.52306032f, 0.45049134f, -0.32703975f, 
    -0.09121454f, -0.18944591f, -0.40095046f, -0.03820778f, 0.26078117f, 0.34723288f, 0.20342933f, 0.08733023f, 
    -0.70117062f, 0.30992851f, 0.11208693f, 0.15165475f, 0.15799533f, -0.63211429f, 0.06503558f, 0.42525253f, 
    0.16150203f, -0.26872760f, -0.07701711f, -0.19075739f, 0.09806090f, -0.25088209f, -0.13568391f, -0.02855724f, 
    0.01374601f, -0.74481404f, -0.29327217f, -0.05217568f, 0.12972522f, -0.33348137f, 0.33850068f, 0.48790377f, 
    -0.58053184f, -0.12000765f, 0.14083673f, -0.31351453f, -0.22740024f, -0.40746260f, -0.33072013f, 0.08867351f, 
    -0.08137030f, -0.41915694f, 0.22636276f, 0.19025832f, 0.20168729f, 0.17684239f, -0.22840554f, 0.11648617f, 
    -0.13665655f, -0.03800350f, 0.14978419f, 0.07316130f, 0.03491697f, -0.13148843f, 0.00840681f, 0.21504375f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.03197764f, -0.13605262f, -0.10473762f, 0.02321692f, 0.10748720f, 0.10870157f, -0.11335034f, -0.12186175f, 
    0.00501780f, -0.00945670f, 0.10660983f, -0.14713638f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
