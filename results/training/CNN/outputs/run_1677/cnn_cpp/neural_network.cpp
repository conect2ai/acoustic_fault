#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.37450534f, -0.17214982f, 0.20886666f, -0.05940786f, -0.09618127f, 0.43296888f, 0.19036573f, 0.37306026f, 
    -0.54518926f, -0.60022032f, 0.15310173f, -0.34576374f, -0.07374244f, -0.14323497f, -0.01418172f, -0.41382021f, 
    -0.13202041f, -0.07364617f, 0.07056397f, 0.13903454f, 0.64974356f, -0.07441025f, -0.31740534f, -0.16438417f, 
    -0.40758705f, -0.83583891f, -0.66619873f, 0.03067763f, -0.49216595f, -0.71814007f, 0.31718633f, 0.34284443f, 
    0.29140446f, 0.48886284f, 0.56951445f, -0.07592363f, 0.13480125f, -0.00882312f, 0.36489576f, 0.11383599f, 
    0.18828808f, -0.05412898f, -0.30917308f, 0.05205797f, -0.18673125f, -0.04021994f, -0.20752294f, 0.32020637f, 
    -0.06668709f, -0.17817622f, 0.46531031f, 0.10237591f, 0.05221885f, -0.24810393f, 0.59262598f, -0.07658130f, 
    -0.41286772f, -0.42530817f, 0.00718144f, 0.23866242f, -0.19274195f, 0.53722918f, 0.16858405f, -0.38171995f, 
    -0.16849053f, -0.50494701f, -0.03976857f, -0.05479677f, 0.26521137f, -0.19874477f, 0.09252541f, 0.12037967f, 
    -0.06397200f, 0.14935851f, -0.25670502f, 0.42852789f, 0.09178115f, -0.54873639f, 0.22918700f, 0.19445240f, 
    0.26766345f, -0.36165321f, -0.04773650f, 0.31107950f, 0.21488126f, 0.03589014f, 0.02148223f, 0.43410748f, 
    -0.44051388f, -0.62905896f, 0.08095454f, -0.26006448f, 0.24062827f, -0.09491982f, -0.36104125f, -0.30033633f, 
    0.04684603f, 0.35955977f, 0.11864141f, -0.38589704f, 0.21041586f, -1.09718263f, -0.69759184f, -0.50564593f, 
    0.49507999f, -0.29276791f, -0.09663549f, 0.01109482f, 0.20992708f, -0.08372860f, -0.47971213f, -0.50607127f, 
    0.30440906f, -0.37662649f, 0.30047584f, -0.06613585f, -0.09756684f, -0.00324728f, 0.10198857f, -0.31844202f, 
    -0.18311894f, -0.09081015f, -0.22194022f, -0.14284411f, 0.21007347f, 0.52532101f, 0.30272797f, 0.38118991f, 
    -0.52785087f, -0.60384429f, -0.44530901f, 0.14873374f, 0.20766073f, -0.00437879f, -0.11626457f, -0.02436403f, 
    -0.15674457f, 0.71338207f, -0.49783742f, -0.13801295f, 0.14473924f, 0.12806474f, -0.05616630f, 0.13461399f, 
    -0.24786821f, -0.10556399f, 0.01065103f, 0.25556979f, 0.25180945f, -0.18728155f, 0.31754416f, 0.45895517f, 
    0.14021656f, 0.10920639f, -0.16546662f, -0.10615215f, -0.00531549f, 0.15915687f, 0.06318079f, 0.19083618f, 
    -0.15743151f, -0.22703589f, 0.11181963f, 0.05598256f, -0.02675542f, -0.07986955f, -0.28526258f, -0.23516676f, 
    0.13674875f, -0.17157444f, -0.44503090f, -0.08522633f, 0.44424152f, -0.07617218f, -0.03540615f, 0.22833139f, 
    -0.15467532f, -0.11233991f, 0.25425175f, 0.42733803f, -0.06680405f, 0.60155958f, -0.57726866f, -0.63685560f, 
    -0.57103950f, 0.29334000f, 0.47657743f, 0.15892877f, -0.54680622f, -0.27193713f, 0.10133227f, -0.07492930f, 
    0.32250175f, 0.50048149f, 0.01332976f, -0.18162875f, -0.40434760f, 0.14422709f, -0.18881041f, -0.19875205f, 
    -0.51764190f, -1.12003446f, -0.00058912f, 0.75246376f, 0.66963822f, 0.48383930f, 0.27075246f, -0.66076988f, 
    -0.62312216f, -0.37175667f, 0.09633455f, 0.63119638f, -0.10619745f, -0.37885788f, -0.45913455f, -0.27233198f, 
    -0.23413534f, -0.26716319f, -0.05803534f, 0.07699970f, -0.06678525f, -0.17881623f, -0.25698584f, 0.18379523f, 
    -0.12979184f, -1.07506669f, -0.80354166f, -0.45658612f, -0.19297923f, -0.52864802f, -0.36731774f, -0.47939804f, 
    -0.28259456f, -1.01159883f, -0.69384992f, -0.27101865f, -0.06801971f, -0.04803915f, 0.13755323f, -0.26838017f, 
    0.37448251f, -0.23564622f, 0.05519995f, -0.23234545f, -0.37783128f, 0.03737941f, 0.06032999f, -0.27277023f, 
    -0.38188657f, 0.35910812f, -0.40709093f, -0.32217950f, -0.42079839f, 0.86464417f, 0.24993515f, -0.50371546f, 
    -0.70012158f, -0.32291487f, 0.74226731f, 0.69609237f, 0.21515194f, -0.10915262f, -0.16068414f, -0.11033344f, 
    0.46210951f, -0.39129591f, 0.15330161f, 0.27496442f, -0.43298078f, 0.02537447f, 0.11972062f, -0.07745510f, 
    -0.16999389f, 0.30627039f, 0.18561582f, 0.18735431f, 0.42293495f, 0.05706721f, 0.10118464f, -0.84980023f, 
    -0.72176325f, -0.55346036f, -0.68324375f, -0.27345958f, -0.01279167f, 0.50109762f, 0.34184435f, 0.46431360f, 
    0.05705904f, 0.42530516f, -0.14293103f, -0.18506418f, -0.04070447f, -0.54551935f, -0.72369432f, -0.02404940f, 
    0.03029961f, -0.01681832f, 0.15644100f, -0.10760871f, 0.47624549f, 1.24248719f, 0.53029025f, -1.01996350f, 
    -0.65284187f, -0.14568408f, -0.32150042f, 0.06526384f, -0.56820536f, -0.70073724f, 0.04470548f, 0.37544310f, 
    0.23968337f, -0.14061384f, 0.20054542f, 0.15246889f, 0.25083423f, 0.14900081f, 0.15234700f, -0.30309907f, 
    -0.07631914f, 0.16807601f, -0.26632074f, 0.02366377f, 0.33047268f, 0.42031541f, -0.54576701f, -0.80138850f, 
    -0.84249598f, -0.38892969f, 0.78596956f, 0.19937396f, -0.01405388f, 0.17864615f, 0.16940305f, 0.33635414f, 
    0.19891834f, 0.25126961f, -0.19416966f, -0.16216733f, 0.02842832f, -0.34320143f, 0.25536332f, -0.50954247f, 
    -0.42408070f, -0.22445762f, 0.16776171f, 0.05798550f, 0.26376805f, 0.44235560f, -0.21137294f, 0.29394254f, 
    0.22381069f, 0.16391258f, 0.05456024f, 0.17031579f, 0.36780137f, 0.25205636f, 0.41350508f, 0.11957897f, 
    -0.14032727f, -0.37216100f, 0.44287196f, -0.28192452f, -0.36229300f, 0.15701291f, -0.21129416f, -0.14656726f, 
    -0.22149709f, -0.00509207f, 0.14725102f, 0.20291303f, -0.22875391f, -0.05919902f, 0.47313702f, -0.39284083f, 
    -0.36030185f, -0.36863014f, -0.52026552f, -0.75894326f, 0.58020347f, 0.15345508f, 0.06348946f, 0.15272033f, 
    0.45954564f, 0.17191833f, 0.31706777f, -0.65133142f, -0.34588712f, -0.50428730f, -0.67756021f, -0.14127986f, 
    -0.08209803f, -0.45637140f, -0.56705904f, -0.16076423f, -0.27845702f, -0.18660702f, -0.35815525f, -0.32292053f, 
    1.27142572f, 0.66647214f, -0.66465300f, -0.59364325f, -0.39210585f, -0.24700160f, -0.09744059f, 0.04988454f, 
    -0.12766720f, 0.36518535f, -0.04661610f, 0.08588210f, -0.02321912f, -0.37242427f, -0.13226245f, -0.03976886f, 
    -0.07210418f, 0.00959442f, -0.38582042f, -0.30471984f, -0.45257795f, -0.42933619f, -0.49426815f, -0.52457958f, 
    -0.66106880f, 0.63815773f, -0.65424812f, -0.85061133f, -0.92991793f, -1.10404706f, 0.56674969f, -0.21207356f, 
    0.30869800f, 0.40114343f, 0.05611886f, -0.07123100f, -0.03176747f, 0.31162378f, -0.06161102f, -0.01864928f, 
    0.23916973f, -0.24586923f, 0.16917105f, -0.07397970f, 0.29698420f, -0.23162811f, -0.20362005f, 0.08310664f, 
    -0.23987599f, -0.25149456f, 1.20589006f, 0.76197046f, 0.42641777f, -0.41638541f, -0.81527048f, 0.24820651f, 
    0.45267266f, -0.28738308f, -0.37036923f, 0.00899223f, 0.09597254f, 0.29664430f, -0.34033656f, -0.45713973f, 
    -0.00586535f, 0.00962978f, -0.03654299f, 0.09545500f, -0.00267833f, -0.17663622f, -0.16009270f, 0.14320502f, 
    -0.07774917f, -0.22780061f, 0.22129881f, -0.29087645f, 0.33119154f, -0.02096893f, -0.27414882f, -0.12087654f, 
    -0.52366728f, 0.76903969f, -0.25186783f, 0.18107441f, -0.34956720f, 0.06353323f, -0.07846233f, -0.21480693f, 
    -0.29772758f, 0.11307272f, 0.25644809f, -0.31574187f, 0.46512625f, 0.12970114f, 0.04260441f, 0.22930005f, 
    -0.38515252f, 0.14616913f, -0.43294150f, -0.00566192f, -0.32690823f, -0.45127717f, 0.18227826f, 0.00206756f, 
    0.51022017f, -0.76379180f, 1.23398745f, -0.99966466f, 0.04838825f, 0.50850332f, 0.05050285f, -0.33624804f, 
    -0.02864266f, 0.34731820f, 0.01422354f, 0.13464089f, -0.34559676f, -0.32497483f, 0.00078099f, 0.26956481f, 
    -0.21197788f, 0.15396729f, 0.26411885f, 0.01712080f, 0.01539280f, -0.01600099f, -0.09061578f, 0.35560325f, 
    0.46386364f, -0.39061913f, -0.39676908f, -0.27309322f, -0.67434090f, -0.95007575f, -1.02152407f, 0.12137547f, 
    -0.23611057f, -0.35661209f, -0.49233618f, -0.05286684f, 0.16478273f, 0.14385352f, 0.30932090f, 0.08649043f, 
    -0.05584023f, -0.27020094f, 0.04626315f, 0.01904873f, 0.04174775f, -0.37973663f, 0.11190829f, -0.03138924f, 
    -0.10776827f, 0.13106741f, -0.11036360f, 0.04199903f, 0.33804342f, 0.26766083f, 0.30418012f, 0.06767480f, 
    -0.10126516f, -0.08868190f, 0.00219254f, 0.62338215f, -0.21748355f, -0.21979047f, -0.05595350f, -0.36115634f, 
    0.36814106f, -0.17627801f, 0.38104248f, -0.04922019f, 0.10761268f, -0.07966376f, -0.18927622f, -1.00827539f, 
    -1.15159643f, -0.72659683f, 0.20673528f, 1.13302112f, 0.66890371f, 0.86511856f, -0.79285604f, -0.42996868f, 
    0.58007824f, 0.01953457f, 0.03106632f, -0.32758236f, 0.01718228f, -0.26327908f, -0.10350797f, 0.12659217f, 
    0.26571983f, 0.29509950f, -0.07822408f, 0.20400383f, -0.27456325f, -0.04068675f, -0.18447278f, -0.10069536f, 
    -0.46123156f, -0.13696387f, 0.17152503f, 0.07754359f, 0.09541593f, -0.02258431f, 0.28522143f, 0.38977101f, 
    -0.25296628f, 0.17397662f, -0.02951997f, 0.25105050f, 0.08960588f, 0.06730481f, -0.07540917f, 0.00185450f, 
    0.13694799f, 0.11187328f, -0.04056391f, -0.15092765f, 0.24359086f, 0.42139959f, 0.22519381f, 0.17577378f, 
    -0.12537472f, -0.17358263f, 0.09851240f, 0.22956029f, -0.05141322f, -0.39789718f, 0.10210307f, -0.07630576f, 
    0.20024183f, -0.14299807f, -0.35412580f, 0.40929914f, -0.01287242f, 0.08516253f, 0.45893502f, -0.16111232f, 
    0.13209161f, -0.34508023f, -0.25166672f, 0.13354608f, -0.16855550f, -0.21236116f, 0.19808733f, 0.58868349f, 
    0.13929474f, -0.11653709f, -0.39953899f, -0.10050110f, -0.04948710f, 0.14682560f, 0.20291917f, -0.65291506f, 
    -0.79667372f, -0.63234681f, -0.25657558f, -0.35949588f, -0.14348783f, 0.12309474f, -0.17798211f, 0.12327302f, 
    0.23945718f, 0.04719463f, -0.28708082f, 0.01805257f, 0.06222272f, -0.11495675f, 0.24474888f, 0.32613814f, 
    -0.02824589f, 0.17110470f, 0.33493450f, -0.99679935f, -0.45536381f, -0.63046294f, -0.78431684f, -0.90326381f, 
    0.10396058f, 0.23942386f, -0.12596926f, -0.26096261f, 0.13707490f, 0.10580445f, 0.04393920f, -0.00536605f, 
    0.04093699f, 0.13106860f, -0.35466060f, 0.07415020f, -0.30573365f, -0.38512281f, -0.03269942f, -0.19402264f, 
    -0.16037157f, -0.00747528f, -0.08658887f, -0.35548136f, -0.31279838f, -0.96327782f, -0.33461520f, 0.21593601f, 
    -0.25401610f, -1.16656804f, -0.91000342f, -0.78066415f, -0.35276431f, -0.60470289f, 0.69147682f, 0.37456253f, 
    0.27636987f, 0.25160101f, 0.13449684f, 0.07027183f, 0.03193810f, -0.18425782f, 0.06430561f, -0.32450297f, 
    -0.10696606f, 0.00435975f, -0.10215193f, 0.07431544f, 0.09339221f, -0.61077422f, -0.66154563f, -0.51596379f, 
    -1.04515457f, -0.96383840f, 0.94269186f, -0.15165943f, -0.31848398f, 0.43280914f, 0.06104663f, -0.30324733f, 
    -0.71208507f, -0.25009051f, -0.06925707f, -0.28470400f, -0.16492933f, -0.09433246f, -0.09949813f, -0.04239104f, 
    -0.12019414f, -0.06263256f, 0.30687764f, 0.39511383f, -0.18931028f, 0.20661785f, -0.45842603f, -0.84488493f, 
    0.36772206f, 0.65290648f, -0.03324690f, 1.23740327f, 0.74732631f, -0.49076453f, -0.60024494f, -0.26355964f, 
    -0.30901098f, -0.05836565f, -0.11475682f, 0.03661728f, 0.15029070f, 0.14586833f, -0.28342855f, -0.17179480f, 
    0.12374651f, 0.03935926f, 0.14618374f, -0.10367694f, 0.00598262f, 0.28201067f, -0.13831399f, -0.69820362f, 
    0.08663528f, -0.40164268f, -0.53619224f, -0.18112287f, -0.39617935f, -0.53430796f, -0.05745954f, -0.52939385f, 
    0.27836758f, -0.18183169f, 0.18261845f, 0.06038485f, -0.26898295f, -0.32685187f, 0.29842803f, 0.33344066f, 
    0.05332963f, 0.34249762f, 0.20579429f, -0.03003190f, -0.21259001f, -0.23558101f, 0.25427088f, 0.04770730f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11535444f, -0.01434189f, 0.32974687f, 0.42507866f, 0.44601908f, 0.36828190f, 0.28093126f, 0.18790482f, 
    0.29303235f, -0.22857267f, 0.45655203f, -0.16462563f, 0.37924761f, 0.50459409f, -0.06129091f, 0.19648743f, 
    -0.02192976f, 0.20524234f, 0.60676169f, 0.03970788f, 0.32727984f, 0.07329656f, 0.26241556f, 0.40396416f, 
    -0.26216409f, -0.02216015f, 0.31663010f, -0.09534705f, 0.03031878f, -0.26348928f, 0.26008281f, -0.09961973f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.22469251f, -0.34876460f, -0.32422987f, -0.07529576f, -0.07118132f, 0.00059214f, -0.03981114f, 0.08173718f, 
    -0.13495831f, 0.00868760f, -0.09044787f, 0.09409130f, -0.05959497f, -0.10309549f, 0.00710592f, 0.04603945f, 
    0.09309105f, 0.06151491f, 0.00301906f, 0.06918105f, 0.12376045f, 0.02618858f, -0.05103651f, 0.10833973f, 
    -0.96318978f, 0.01105309f, -0.63656497f, 0.13176943f, 0.01040822f, -0.04388155f, 0.00005665f, 0.00267268f, 
    -0.06557795f, -0.06057452f, 0.03117130f, -0.00396497f, -0.58634156f, -0.20518522f, -0.18013048f, 0.20129812f, 
    0.09598045f, -0.06673216f, 0.07098147f, 0.05220694f, -0.08720913f, -0.15627639f, -0.00256716f, 0.14839756f, 
    0.18834338f, -0.04192881f, 0.14376581f, -0.04077380f, 0.09004069f, 0.13934319f, 0.27968338f, -0.12557770f, 
    -0.15722235f, -0.13530278f, -0.05054348f, -0.03923187f, -0.08529206f, -0.31226444f, 0.03129724f, 0.03667681f, 
    -0.13298276f, -0.09199895f, -0.12337715f, -0.32592860f, -0.09281006f, -0.18195009f, -0.17149371f, 0.13610084f, 
    -0.22977379f, -0.84150046f, -0.13666368f, -0.09155381f, 0.06718661f, -0.05102444f, 0.01172053f, 0.01595913f, 
    -0.03532755f, -0.07759754f, 0.05856632f, -0.08549726f, 0.14745820f, 0.02935346f, -0.22357285f, 0.09477502f, 
    0.08833853f, -0.49474356f, -0.05863632f, -0.21709536f, -0.12546299f, 0.04365721f, 0.08835392f, 0.02943548f, 
    0.51904804f, 0.01048571f, -0.02423667f, -0.04770521f, -0.10970853f, -0.22232822f, 0.05255503f, -0.23294456f, 
    -0.09617960f, -0.15040010f, 0.09138704f, -0.24306369f, 0.46560359f, 0.22934708f, -0.09045756f, -0.27890581f, 
    0.09070024f, 0.14282614f, 0.26977709f, 0.19762303f, -0.03230590f, -0.08157489f, -0.01654194f, 0.04359043f, 
    -0.22625647f, 0.40817142f, 0.23492597f, -0.41726089f, -0.14755833f, 0.05996400f, 0.03571856f, -0.12932268f, 
    -0.23425944f, -0.15522820f, -0.15432020f, -0.10675739f, 0.25941691f, 0.02560785f, -0.08244326f, -0.26856589f, 
    -0.17190549f, 0.01947187f, -0.15040964f, -0.08573769f, -0.02196653f, 0.07378244f, -0.03072722f, -0.06045027f, 
    0.23578775f, -0.29509461f, -0.18456855f, 0.17537756f, -0.03720536f, -0.18112449f, -0.08651989f, -0.12750785f, 
    0.02458393f, 0.10422567f, 0.07430235f, -0.06534003f, 0.07488143f, -0.17735167f, -0.42038566f, -0.04686472f, 
    0.04151084f, 0.07451454f, -0.06839897f, -0.49040505f, -0.07987482f, -0.16273783f, -0.21475650f, 0.04475500f, 
    -0.16652066f, -0.09882915f, -0.33259428f, -0.20063663f, 0.02809481f, 0.07340774f, 0.08032873f, 0.09650864f, 
    0.09618817f, 0.03549605f, -0.11166202f, -0.07843560f, 0.15593895f, 0.01283562f, 0.02472256f, 0.00558658f, 
    0.05498727f, 0.03573410f, -0.04760485f, -0.16748309f, -0.08527582f, 0.15983324f, 0.00310305f, 0.12914903f, 
    -0.42759067f, 0.02903281f, -0.39871189f, 0.19287665f, 0.00199387f, 0.05814873f, -0.10073306f, -0.09353084f, 
    -0.18236229f, -0.04078399f, -0.00720835f, 0.19907548f, 0.28422260f, -0.11428789f, -0.12036694f, -0.03166297f, 
    0.11097145f, 0.17164464f, -0.08757055f, -0.01721789f, -0.00971661f, 0.04233376f, 0.14922011f, 0.10991698f, 
    -0.51326668f, -0.91748399f, -0.65682870f, 0.11408350f, 0.05575423f, 0.04924785f, -0.04962686f, -0.03092024f, 
    -0.16348185f, -0.03131893f, 0.02028065f, 0.00235274f, 0.01614683f, -0.17074515f, 0.00479285f, 0.05648816f, 
    -0.06507477f, -0.10852110f, -0.09228607f, -0.22235969f, 0.00063343f, -0.00326072f, 0.17822607f, 0.08477067f, 
    -0.14189966f, 0.46236983f, 0.17674957f, -0.26374218f, -0.18770000f, -0.11736666f, -0.07858945f, -0.20351437f, 
    -0.16546415f, -0.04056153f, -0.14192316f, 0.01645458f, 0.32885963f, 0.08096933f, -0.06521837f, -0.24926986f, 
    0.15115368f, 0.05094440f, 0.05480254f, 0.02120484f, -0.07097346f, 0.02098330f, 0.02574859f, 0.06608646f, 
    0.02945280f, -0.18003659f, -0.06288080f, 0.09288057f, 0.05330308f, 0.02250921f, 0.01884107f, 0.00503055f, 
    -0.11521311f, -0.35024506f, -0.54804075f, -0.27618989f, 0.52131706f, 0.29381835f, -0.26379871f, -0.00713484f, 
    -0.13751359f, 0.02850247f, 0.10207886f, -0.16222434f, -0.00012066f, -0.03613228f, 0.00127539f, 0.09856013f, 
    0.04126766f, 0.04402733f, 0.08254030f, 0.08442779f, -0.07700786f, -0.04561653f, 0.07460891f, 0.04436116f, 
    -0.21591753f, -0.09374626f, -0.07977382f, -0.04404700f, 0.01664113f, -0.18490846f, -0.07180651f, 0.04291777f, 
    0.16859150f, 0.12515514f, -0.02214027f, -0.05625927f, -0.05349392f, 0.08135543f, -0.27749586f, -0.06378835f, 
    0.25803429f, 0.32104361f, 0.00780250f, -0.33785233f, -0.06606615f, -0.00829435f, -0.11210690f, -0.08714563f, 
    0.03713857f, -0.04857663f, -0.02786859f, -0.05375243f, 0.28044647f, 0.15920833f, -0.04708174f, -0.15588346f, 
    0.06666809f, 0.12944585f, -0.08030633f, -0.13514899f, -0.26551431f, -0.23173448f, 0.00802936f, -0.01504545f, 
    0.36394429f, 0.44788328f, 0.00613645f, -0.43579572f, 0.08251977f, -0.13446943f, 0.08348676f, 0.02258061f, 
    0.01781787f, 0.01969387f, -0.05029847f, 0.02709439f, 0.28627452f, 0.07100701f, 0.06653421f, -0.15803926f, 
    0.02646999f, 0.27318907f, -0.02080041f, 0.14748487f, 0.00137396f, 0.01517444f, -0.02267936f, -0.00749944f, 
    0.56592351f, -0.05807450f, -0.36274797f, -0.16559377f, -0.14972268f, -0.05893349f, 0.08636998f, -0.11830498f, 
    -0.11375754f, -0.22887824f, 0.01839405f, -0.07335763f, 0.32202923f, 0.40835467f, -0.24908970f, -0.07124545f, 
    0.18800524f, 0.21293607f, 0.05386858f, 0.03883204f, 0.05638251f, 0.04442318f, 0.07421892f, 0.09641532f, 
    0.52517831f, -0.01227945f, 0.13898201f, -0.15924609f, 0.02543703f, -0.21083854f, -0.23964842f, -0.07021851f, 
    0.02056827f, -0.02885232f, -0.00122326f, -0.14153455f, -0.06800850f, -0.18721841f, -0.17827639f, -0.11423340f, 
    0.03913338f, 0.02907649f, -0.00338871f, -0.11676554f, -0.14855662f, -0.05018793f, 0.12784810f, -0.08599545f, 
    0.31751376f, 0.23801672f, -0.08568362f, 0.40721592f, 0.07009307f, -0.02192812f, -0.06246221f, 0.06697246f, 
    -0.04164334f, -0.06620844f, 0.01491840f, 0.12909876f, -0.04298021f, 0.37157711f, 0.14677949f, 0.21968041f, 
    -0.05350581f, -0.01643144f, 0.06334858f, 0.06459664f, -0.00645633f, 0.15083838f, -0.02223464f, 0.13488443f, 
    -0.09284610f, 0.16508994f, -0.09065881f, 0.03391448f, 0.03398547f, 0.12477665f, 0.08184391f, -0.19686125f, 
    0.04857395f, -0.00857198f, -0.01698181f, -0.34872007f, 0.29101771f, -0.17452504f, 0.20215261f, -0.14240183f, 
    0.06963792f, -0.05932334f, -0.00299855f, -0.16813989f, -0.06668492f, 0.07113077f, -0.05062183f, 0.06710059f, 
    0.13308048f, 0.33907786f, 0.36998418f, 0.18557401f, -0.04303681f, 0.02502640f, 0.01310345f, -0.08262952f, 
    0.06279916f, 0.07598209f, 0.08625316f, -0.14545572f, -0.03814014f, -0.03477098f, -0.07917318f, 0.03706194f, 
    -0.20044024f, 0.07175586f, -0.09933762f, 0.01978102f, 0.14249355f, -0.07932801f, 0.13506173f, 0.07270591f, 
    0.22536166f, -0.34395805f, -0.24872702f, 0.08691350f, -0.18472435f, -0.11848408f, 0.14059256f, -0.12869433f, 
    -0.06407273f, 0.02356670f, -0.16371126f, 0.11619154f, -0.12028567f, 0.20327459f, 0.32673046f, 0.34697098f, 
    0.05687252f, 0.02258852f, 0.13195173f, -0.15753250f, 0.00385420f, 0.03621670f, -0.02715912f, -0.01725737f, 
    -0.87448275f, 0.37843463f, 0.09260957f, -0.07315873f, 0.04262577f, 0.13073789f, -0.04606820f, -0.09458096f, 
    0.08304822f, -0.11760970f, -0.07169750f, 0.02277814f, -0.53046864f, -0.33016846f, -0.10757898f, -0.48354271f, 
    -0.04250934f, -0.08574685f, -0.05918239f, 0.09859753f, -0.05137867f, -0.16077004f, 0.06743393f, 0.11980456f, 
    0.18138060f, -0.29347610f, -0.06818935f, -0.17683293f, -0.05890459f, 0.03808078f, 0.07078962f, -0.06198198f, 
    -0.06494853f, 0.22077712f, -0.01919219f, 0.14567858f, 0.21538463f, -0.32683063f, -0.38664594f, -0.50311607f, 
    -0.00210392f, 0.08167160f, 0.05637701f, 0.05593708f, 0.10997715f, 0.17702183f, 0.04004964f, 0.04233745f, 
    0.01152922f, 0.20982687f, 0.15661801f, 0.19469179f, -0.09132621f, 0.03438761f, 0.06120943f, -0.05799990f, 
    -0.01417268f, -0.01710675f, 0.03416978f, 0.11836153f, 0.16747794f, 0.01536776f, -0.17233494f, -0.48692280f, 
    -0.05961955f, 0.08744212f, -0.12993115f, 0.14031996f, -0.13392915f, -0.44098312f, -0.48467219f, -0.11060105f, 
    0.25596046f, -0.28940457f, 0.23412354f, -0.22474574f, 0.04488020f, 0.02345737f, -0.09642068f, 0.06485240f, 
    -0.01166972f, -0.21457496f, -0.48812601f, -0.15192562f, 0.29827788f, 0.08070151f, -0.00295899f, -0.16787079f, 
    -0.14321350f, 0.13974097f, -0.26661977f, -0.43386537f, 0.08607996f, -0.07021840f, -0.05245757f, -0.13564225f, 
    0.66824836f, -0.16677172f, 0.44485995f, 0.08790746f, -0.05533250f, -0.03475366f, -0.04223704f, -0.00660954f, 
    -0.01294275f, 0.12383820f, -0.05676038f, -0.00600456f, -0.19534224f, -0.38443097f, 0.00331440f, -0.04995301f, 
    0.15179276f, 0.16411580f, -0.24652967f, -0.03766230f, -0.14868702f, -0.13369982f, -0.07919125f, -0.09675708f, 
    0.31484970f, -0.10463117f, -0.22369990f, -0.37001842f, -0.19977835f, 0.03509103f, 0.13020635f, 0.11816987f, 
    -0.07067619f, 0.16055180f, 0.17797036f, -0.17585270f, -0.26132765f, -0.21847929f, -0.27141562f, -0.65860349f, 
    -0.10077777f, -0.17337671f, -0.05666869f, 0.32992765f, 0.01332384f, 0.14209670f, 0.00368958f, 0.01041808f, 
    0.10691063f, -0.01347386f, 0.13731870f, 0.05857171f, -0.03722873f, -0.04197036f, -0.04011412f, 0.00615477f, 
    0.08786486f, -0.14355963f, 0.05207090f, 0.06593244f, 0.37724030f, -0.09812833f, -0.06866620f, -0.07374556f, 
    0.00471837f, 0.03280779f, 0.08684058f, 0.04263316f, 0.20091714f, -0.29139939f, -0.13254772f, -0.05975142f, 
    -0.02092159f, -0.04511148f, 0.06916809f, 0.01090564f, 0.09742121f, 0.04149424f, -0.01318131f, 0.03239997f, 
    -0.22881553f, -0.09539189f, -0.09708887f, -0.03526058f, 0.03656418f, -0.29832935f, -0.12016411f, -0.09707597f, 
    -0.12079775f, 0.03439939f, 0.14790903f, 0.11113450f, -0.12932271f, -0.01866700f, -0.12602416f, 0.07709913f, 
    0.01428258f, 0.12449442f, -0.05461104f, 0.19931005f, -0.19696331f, -0.09427187f, -0.10318424f, 0.10975847f, 
    -0.13202463f, 0.08188214f, 0.07201333f, 0.03556123f, 0.20585793f, -0.00290246f, 0.24755606f, 0.02933913f, 
    0.11153536f, 0.18647145f, -0.08724673f, -0.14230101f, -0.02772435f, 0.03609025f, 0.10693912f, -0.01092566f, 
    -0.41445538f, 0.15298255f, -0.08207595f, 0.07477297f, -0.28760403f, 0.04304205f, 0.02865433f, 0.13785727f, 
    0.02485473f, -0.05964391f, -0.00298260f, 0.08499821f, 0.26066419f, 0.47982842f, 0.27978528f, -0.05526050f, 
    0.07488415f, 0.08245097f, 0.20049672f, 0.28558648f, -0.03269920f, 0.03770964f, 0.03804953f, -0.22589311f, 
    0.26482847f, -0.36501023f, 0.22869724f, 0.15885372f, -0.00324062f, -0.13735780f, 0.14184628f, 0.20458055f, 
    0.01373978f, -0.00529204f, 0.30263895f, 0.00255590f, 0.02486802f, 0.13930704f, 0.09765451f, 0.26091912f, 
    -0.07607711f, 0.02725030f, -0.17330028f, -0.34175265f, 0.01215629f, -0.07622885f, -0.13171676f, 0.01073108f, 
    0.34514233f, 0.11069959f, -0.31972980f, -0.16968492f, 0.03300599f, -0.06227374f, 0.06243374f, 0.09677266f, 
    0.00899739f, 0.14701334f, -0.08758389f, 0.05599023f, 0.31745687f, 0.36343932f, 0.21982196f, 0.11608773f, 
    0.01511146f, -0.01841849f, 0.17656569f, -0.10596285f, -0.13300043f, -0.15295312f, 0.12331420f, 0.11654915f, 
    -0.13056514f, -0.11811794f, 0.35155419f, -0.07116153f, -0.05613372f, -0.01331277f, 0.02647742f, 0.06764597f, 
    0.03721755f, -0.07337794f, 0.03756518f, 0.00717575f, -0.25366053f, -0.09974580f, 0.18716612f, 0.00294075f, 
    0.04288892f, -0.02894581f, 0.07116116f, -0.08227129f, 0.03611530f, -0.22917804f, 0.33511809f, -0.09391709f, 
    0.06307401f, 0.23443617f, 0.18531583f, 0.15006660f, 0.00986062f, -0.08668920f, -0.15339775f, 0.02475487f, 
    -0.08927825f, 0.01335618f, 0.06019150f, -0.19875267f, -0.01158843f, -0.05025165f, 0.04061059f, -0.11026805f, 
    -0.11411497f, -0.05437479f, 0.12279736f, -0.00664776f, 0.07353064f, -0.11583450f, 0.09391377f, 0.02207256f, 
    -0.18000299f, -0.19597387f, 0.00019785f, -0.10290655f, 0.03514127f, 0.05275153f, 0.04095079f, -0.03333546f, 
    0.00471669f, -0.06561852f, -0.02278655f, -0.00712882f, -0.01491105f, -0.06373071f, -0.09126023f, -0.09635992f, 
    0.04539558f, 0.01703146f, -0.10977985f, -0.07469718f, 0.15003124f, -0.27218881f, 0.04074716f, -0.02001418f, 
    0.27321762f, 0.29222596f, -0.31939399f, -0.19199575f, 0.03813491f, 0.01674689f, -0.01008410f, 0.21309437f, 
    -0.03475669f, -0.01166037f, 0.01372829f, -0.14708149f, -0.50892568f, -0.65824115f, -0.12864354f, -0.21412513f, 
    -0.00230013f, -0.04265497f, -0.20063424f, -0.07114615f, 0.07139458f, -0.08226108f, -0.00961731f, -0.04294945f, 
    -0.23228057f, -0.17697227f, -0.14160192f, 0.22524938f, 0.05851652f, 0.17974730f, -0.04976994f, 0.03871255f, 
    0.06318618f, 0.13916168f, 0.10663293f, 0.18061632f, -0.77359545f, -0.45172289f, -0.03759214f, -0.50342304f, 
    0.09323771f, -0.01677798f, -0.30181208f, -0.25545496f, 0.04556790f, 0.03481996f, -0.22718158f, 0.14631519f, 
    -0.09885161f, -0.19134541f, 0.25550547f, -0.20292456f, 0.30050686f, -0.16412129f, -0.50177842f, -0.08249858f, 
    0.07972459f, -0.09102115f, -0.00930825f, -0.02936088f, -0.12980179f, 0.49428111f, 0.29802099f, 0.25457466f, 
    0.09793901f, 0.06564818f, -0.02149019f, -0.12544659f, -0.26579750f, -0.09479168f, -0.06243660f, 0.07047256f, 
    -0.19817194f, -0.27840981f, -0.42513588f, -0.02405017f, -0.04144154f, 0.05973716f, 0.00566935f, 0.03639010f, 
    0.07502612f, -0.13119207f, 0.02865577f, -0.18061815f, 0.02974692f, 0.35334834f, 0.30970541f, -0.00391869f, 
    -0.00418886f, 0.01455844f, 0.06832395f, 0.05625913f, 0.01592669f, 0.00859373f, -0.04097149f, 0.13834897f, 
    -0.15075652f, 0.10008115f, 0.05453628f, -0.08301011f, -0.05518803f, -0.03064734f, -0.00533509f, -0.21550350f, 
    0.08399329f, 0.18267101f, 0.09749001f, 0.23205778f, -0.24309003f, 0.61127371f, 0.09027778f, 0.32419363f, 
    0.00096836f, -0.10423294f, 0.28970012f, -0.25068584f, 0.01681971f, 0.14060327f, 0.06463546f, 0.05460354f, 
    -0.31884968f, -0.01828637f, 0.29767972f, -0.95183283f, 0.04062356f, -0.06648508f, -0.17534779f, 0.14106894f, 
    0.06991623f, 0.07091752f, -0.05737472f, -0.05027661f, 0.10519703f, -0.15536818f, 0.00560881f, -0.25785980f, 
    -0.01852529f, -0.07253996f, 0.05577820f, 0.02625296f, -0.08404959f, 0.05447341f, 0.05032214f, -0.09918280f, 
    0.18667336f, -0.28443733f, 0.01621042f, -0.02910007f, 0.17198253f, -0.08829842f, -0.04815851f, 0.03664095f, 
    0.06263409f, 0.03460964f, 0.12863237f, -0.15746665f, -0.88070112f, 0.06105653f, -0.11505789f, -0.25248507f, 
    -0.15031649f, -0.10037739f, 0.08756050f, -0.23351866f, -0.00960490f, -0.08642633f, -0.00219407f, 0.02662608f, 
    -0.05331391f, 0.04701467f, -0.05879866f, 0.12131269f, -0.03748195f, -0.02158541f, 0.08072172f, 0.07630073f, 
    -0.00173009f, -0.15762445f, 0.29456446f, -0.06321310f, -0.00491191f, -0.47171408f, 0.31424421f, 0.04534989f, 
    -0.07418636f, -0.04750496f, 0.02282986f, 0.26778901f, 0.06949033f, 0.02315951f, 0.09508052f, -0.12985018f, 
    -0.03278701f, -0.09446535f, -0.01936666f, 0.07098685f, -0.08783795f, 0.01407535f, 0.10055348f, -0.02823099f, 
    0.08785515f, -0.29183331f, 0.00915903f, -0.03586840f, 0.04482210f, -0.09327105f, -0.11564391f, -0.08903008f, 
    0.11476566f, -0.22160655f, 0.18089861f, -0.05391743f, -0.01027582f, -0.07937753f, 0.06695689f, -0.07777493f, 
    -0.39503151f, -0.35347682f, -0.22994126f, -0.01602132f, 0.18605749f, 0.11555644f, -0.09894522f, 0.13994239f, 
    -0.01226618f, -0.00878198f, -0.09655877f, -0.05754940f, 0.25324163f, 0.29628700f, 0.48567873f, 0.34789628f, 
    -0.16410440f, -0.02646217f, 0.18136738f, 0.03745251f, -0.02318577f, -0.02701050f, -0.05227406f, 0.00637817f, 
    -0.61048055f, -0.54859698f, -0.65157318f, -0.18546852f, -0.06481885f, 0.00672688f, -0.06347790f, -0.11546366f, 
    0.06106155f, 0.01575955f, 0.02373242f, 0.03106035f, -0.76476133f, 0.44262263f, 0.55412048f, 0.38580510f, 
    -0.14455046f, 0.10624672f, -0.04485091f, -0.04781235f, -0.04594601f, -0.10741846f, 0.02621474f, -0.00617637f, 
    0.06806694f, 0.12538479f, 0.26194370f, 0.16087118f, 0.21036702f, -0.31914496f, 0.07352328f, 0.14666459f, 
    -0.05525609f, 0.11498985f, 0.05557930f, 0.00262276f, -0.12774904f, -0.17909738f, -0.11879202f, 0.18121493f, 
    0.18591577f, -0.07510996f, -0.01579717f, -0.18515155f, -0.03852732f, 0.01987816f, 0.03809369f, 0.04968940f, 
    -0.23997703f, 0.39817074f, 0.11082849f, 0.32769063f, -0.09976162f, 0.14656579f, 0.12774245f, -0.03559088f, 
    -0.01511916f, 0.07088986f, 0.25293586f, -0.10795603f, 0.37362421f, -0.14800912f, 0.05516285f, 0.21527132f, 
    0.12169109f, 0.31879151f, 0.04515897f, -0.02952594f, -0.28104109f, -0.15750302f, -0.07582140f, 0.02231359f, 
    -0.61366647f, 0.20677651f, 0.06562497f, -0.11516057f, -0.20481585f, -0.34362233f, 0.01428168f, -0.32600459f, 
    0.00935594f, -0.09960794f, -0.21902899f, 0.27628979f, -0.39142859f, -0.08333992f, -0.40606415f, -0.52730131f, 
    0.01631489f, 0.28873250f, -0.07565935f, -0.16347162f, -0.09295592f, 0.08811083f, -0.07504388f, 0.14578648f, 
    -0.15089919f, 0.28354037f, -0.33215174f, 0.09538853f, -0.01943482f, -0.10045528f, -0.08343733f, -0.02066378f, 
    0.05596981f, 0.19732532f, -0.07763577f, -0.10584515f, 0.08255031f, 0.20905650f, -0.05769674f, 0.22271250f, 
    -0.00358390f, -0.14932624f, 0.00971573f, -0.12645598f, -0.03355710f, 0.11124402f, 0.02296027f, 0.02276975f, 
    -0.35840675f, 0.04873495f, 0.12562671f, -0.19385402f, -0.18586016f, 0.00480350f, -0.24250756f, -0.10837080f, 
    -0.08444046f, -0.08858503f, 0.27256015f, 0.02667488f, -0.12517771f, 0.37342021f, -0.06756270f, 0.36580402f, 
    0.02303186f, 0.00306018f, 0.07970084f, -0.11803205f, 0.17453082f, -0.02751003f, 0.04972737f, 0.08862698f, 
    -0.65262067f, 0.65028507f, -0.51663142f, 0.09945364f, 0.04475126f, 0.03780972f, -0.08106279f, 0.00227435f, 
    -0.13249592f, -0.11659871f, 0.01359119f, 0.14171004f, -0.09434871f, -0.12083066f, -0.17805870f, 0.13361819f, 
    0.10154282f, -0.00866309f, -0.10530433f, 0.07918049f, -0.12285697f, 0.12510349f, -0.05483976f, -0.06038377f, 
    0.32451704f, -0.09446338f, -0.09792107f, -0.45788276f, -0.08153553f, -0.15485819f, -0.27991796f, -0.00504257f, 
    -0.14761835f, 0.27228603f, -0.18521145f, -0.07758836f, 0.08396219f, 0.02053962f, -0.01406630f, 0.22518916f, 
    0.08969012f, 0.10142439f, 0.19844082f, 0.08945867f, -0.00000076f, -0.08270396f, -0.05821454f, 0.06469585f, 
    -0.06470785f, -0.03702862f, 0.55975246f, 0.03107582f, -0.01522901f, 0.06008966f, -0.22664918f, 0.08436599f, 
    -0.01267924f, -0.03572373f, -0.07054155f, 0.00997375f, -0.15221860f, 0.11932963f, -0.20057219f, 0.26349124f, 
    0.16772087f, -0.00021024f, 0.00319682f, -0.05366602f, 0.13775304f, 0.05195465f, 0.21787377f, -0.15864335f, 
    0.15529503f, -0.51416188f, 0.06081578f, -0.26230398f, 0.29827347f, 0.23379299f, -0.06839363f, 0.15844725f, 
    -0.20950004f, 0.12396828f, 0.27872309f, -0.16293758f, 0.03442361f, -0.13266173f, 0.00775650f, 0.22828613f, 
    0.10340039f, 0.11905973f, -0.00661315f, -0.19289120f, -0.04956812f, 0.04126469f, -0.10049954f, -0.05391952f, 
    -0.29445073f, -0.00710220f, -0.01196551f, 0.22082163f, -0.20563327f, 0.01980364f, -0.10862396f, 0.02344037f, 
    0.04069950f, 0.10618446f, -0.08335082f, 0.04701484f, -0.27410161f, -0.17205840f, -0.14285386f, 0.35958481f, 
    -0.01318129f, 0.08526882f, 0.20873113f, -0.05434199f, 0.10002953f, 0.04338638f, 0.05464965f, 0.05429807f, 
    -0.97939605f, -0.09006609f, 0.12593223f, 0.16924985f, -0.12533554f, -0.25659209f, -0.27703187f, -0.06907742f, 
    0.04360471f, 0.06773415f, -0.02881644f, -0.11684532f, 0.74729824f, 0.04959259f, 0.13673234f, -0.21924616f, 
    -0.16492866f, -0.16521506f, -0.19079652f, -0.00305847f, 0.01564851f, -0.07989945f, 0.22918719f, -0.19295871f, 
    -0.00006688f, 0.10760483f, -0.47969851f, -0.43906745f, 0.05045004f, 0.10152704f, 0.00906793f, 0.11748704f, 
    0.03288994f, -0.34982547f, -0.01300511f, -0.38973686f, -0.16358009f, -0.06723650f, 0.11206879f, 0.37132460f, 
    -0.08045001f, 0.01689746f, 0.14948538f, 0.17274427f, 0.03933737f, 0.08628838f, -0.10956614f, 0.14153354f, 
    -0.36000672f, -0.16361170f, -0.01223995f, -0.01280320f, 0.09463380f, -0.02587864f, -0.00152871f, -0.01739681f, 
    -0.07616083f, -0.13617370f, -0.08028162f, 0.00323191f, -0.07011353f, 0.38675007f, -0.69070464f, -0.43487427f, 
    0.27822280f, -0.07968955f, -0.03852410f, -0.08621543f, -0.17890178f, -0.07904314f, -0.10713392f, 0.03865010f, 
    0.13362063f, -0.21853641f, -0.32357803f, -0.21012850f, 0.11811911f, 0.11734226f, -0.30510986f, -0.15264641f, 
    0.04147710f, 0.08013435f, -0.18874055f, 0.04292345f, 0.11088707f, -0.17721592f, 0.14188567f, 0.06128369f, 
    -0.00211855f, 0.10325361f, -0.34515783f, 0.01515735f, -0.03803778f, 0.10230272f, 0.30459064f, -0.13581382f, 
    0.15724082f, -0.03273019f, -0.00783964f, 0.00745309f, 0.05426350f, 0.20237710f, 0.02245818f, 0.06826362f, 
    0.01999284f, -0.11697004f, 0.18296207f, -0.02633083f, 0.01640085f, -0.24145630f, 0.03835542f, 0.26749277f, 
    0.14261763f, -0.07854241f, 0.06363194f, 0.02578469f, -0.04342908f, 0.14245772f, -0.14293043f, 0.06297602f, 
    0.04784732f, -0.07983825f, -0.36046520f, 0.05024190f, 0.14975308f, 0.13118446f, 0.17178558f, 0.31447202f, 
    -0.00562779f, -0.05895180f, 0.14082670f, -0.19286160f, 0.13406232f, -0.19925770f, 0.03880514f, 0.27342775f, 
    0.12114603f, 0.01209792f, -0.08249674f, 0.02584469f, 0.04041479f, 0.12309024f, -0.03079887f, 0.08649299f, 
    -0.87001151f, 1.02506852f, -0.22791579f, 0.10711300f, 0.09300466f, 0.16516419f, -0.11253704f, -0.02053187f, 
    -0.41699588f, -0.16236448f, 0.07605960f, -0.05666140f, 0.13470571f, -0.16941686f, -0.15058732f, 0.04875858f, 
    -0.08241055f, -0.02623001f, 0.16901168f, -0.20466472f, -0.15572383f, 0.04610786f, 0.02012874f, 0.12375064f, 
    -0.10272657f, -0.07882878f, -0.22804852f, -0.11295983f, 0.22693740f, 0.12502369f, -0.04383092f, -0.15623288f, 
    0.01462869f, -0.09587781f, -0.01877498f, -0.05387396f, -0.05122297f, 0.19432275f, -0.07055206f, 0.07604926f, 
    -0.06730339f, -0.13604386f, 0.07900809f, -0.01394453f, 0.08088978f, -0.13745975f, -0.08271022f, 0.09046740f, 
    0.01355619f, -0.04869900f, -0.17373239f, -0.16115367f, 0.08593240f, -0.07331169f, 0.12794210f, -0.02160678f, 
    -0.06231711f, 0.06464768f, -0.04201803f, -0.17531909f, -0.21462452f, -0.37731725f, -0.22825471f, -0.19335467f, 
    -0.01247185f, -0.02908945f, 0.00852918f, -0.00154526f, 0.03575349f, -0.19033076f, 0.06672084f, -0.32387838f, 
    -0.08892014f, -0.19288409f, -0.00763059f, -0.17607203f, -0.13107096f, 0.16507572f, -0.30789968f, -0.03964967f, 
    -0.11432218f, -0.07973557f, -0.04286419f, 0.10681322f, -0.18757461f, 0.10138110f, -0.14571372f, 0.00524281f, 
    -0.13466543f, 0.05349617f, -0.07445751f, 0.04075829f, 0.01720597f, -0.15730968f, -0.11245394f, -0.23261356f, 
    -0.23314328f, -0.56253302f, -0.22110052f, 0.16833225f, -0.00210143f, -0.02583680f, 0.01052413f, 0.03326755f, 
    0.04355549f, -0.00257355f, -0.03653459f, -0.02487781f, 0.05132516f, 0.00012108f, 0.16337420f, 0.15161686f, 
    0.01857729f, -0.19786626f, 0.05664938f, -0.00901308f, -0.32512325f, 0.06092483f, 0.03926077f, -0.02196827f, 
    0.14038856f, -0.34179193f, 0.30010977f, -0.08594555f, 0.04205175f, 0.02315334f, -0.06928238f, -0.06804297f, 
    -0.12644783f, 0.22383039f, -0.01087690f, 0.10531714f, 0.07188587f, -0.10174870f, 0.11669616f, 0.03461301f, 
    -0.19208100f, 0.02417299f, 0.09881271f, -0.03189114f, 0.02728392f, -0.04611631f, 0.07045545f, 0.06146712f, 
    -0.28916213f, -0.09831768f, -0.05816336f, 0.07323317f, -0.08279318f, -0.18425123f, -0.02312595f, -0.16661900f, 
    -0.39624223f, -0.18619043f, -0.19602855f, 0.11258917f, 0.05931237f, 0.33821848f, 0.36000362f, 0.37481630f, 
    0.13800435f, 0.00848825f, 0.01858428f, -0.08072245f, -0.01733748f, 0.09744549f, 0.10287542f, -0.05894766f, 
    0.13834263f, 0.35927913f, -0.32486802f, 0.16658780f, 0.06654293f, -0.00542242f, 0.18273760f, -0.13605009f, 
    0.03704085f, -0.09547106f, 0.01528707f, -0.22724907f, 0.09080139f, 0.02377490f, -0.08024538f, 0.17424658f, 
    0.04328168f, -0.10973052f, -0.05906963f, -0.26370659f, -0.13373435f, -0.33578813f, 0.00649909f, -0.08232921f, 
    0.12251525f, -0.08607793f, -0.02251497f, -0.01221892f, 0.08502044f, 0.08870149f, 0.06464900f, 0.09684459f, 
    0.00705524f, -0.01695819f, 0.08393145f, -0.23388219f, 0.04587117f, 0.07014984f, -0.00249421f, 0.09304395f, 
    0.00050330f, -0.24436948f, 0.03255689f, 0.03931618f, 0.16209435f, -0.10584261f, 0.08645134f, 0.21846272f, 
    0.06415349f, -0.09661863f, -0.11560529f, -0.02249734f, 0.07319166f, -0.02119290f, 0.05153142f, -0.09309550f, 
    0.25114495f, -0.00710069f, 0.20867796f, 0.39712700f, -0.28211579f, -0.01145895f, 0.17583181f, 0.10144865f, 
    0.02046552f, -0.26842859f, -0.02666052f, -0.00992832f, -0.04061443f, -0.07542513f, -0.09111985f, 0.13850617f, 
    0.19811264f, 0.16220309f, -0.50425386f, 0.00244827f, 0.20715226f, 0.02612661f, 0.05144000f, 0.00303679f, 
    0.04285617f, 0.09102120f, 0.08257694f, -0.09370233f, -0.24100493f, 0.14120601f, -0.28643784f, 0.07832665f, 
    0.14009675f, -0.04918630f, -0.24105190f, -0.20488138f, 0.11190881f, 0.05988950f, -0.09528029f, 0.03044052f, 
    0.12162205f, -0.01260022f, -0.16326763f, 0.31651735f, -0.15181525f, -0.14287452f, -0.03512398f, -0.03849907f, 
    -0.32740176f, -0.04037813f, -0.16592214f, 0.14971611f, 0.14369115f, 0.34259224f, 0.16444007f, 0.16154423f, 
    0.10201438f, 0.08297762f, -0.05903026f, 0.08119750f, 0.04393565f, -0.07669162f, 0.00598927f, -0.07323775f, 
    0.02173604f, 0.11275899f, -0.10960425f, -0.02994387f, -0.01622298f, 0.07576878f, 0.05739369f, 0.06125829f, 
    -0.06613368f, 0.00062862f, -0.45316827f, 0.07584005f, -0.28732148f, -0.26796061f, 0.12134176f, 0.16511945f, 
    -0.35530210f, -0.01372275f, -0.31987968f, -0.24787973f, -0.19796345f, 0.08086078f, 0.00240498f, -0.03719423f, 
    0.18678141f, 0.14934090f, 0.07885617f, 0.06927478f, 0.12644184f, 0.06301969f, 0.06829791f, -0.03395512f, 
    0.22851273f, -0.08151456f, -0.01793486f, -0.05590660f, 0.13783474f, 0.29054627f, 0.08228830f, 0.09125285f, 
    0.08504675f, 0.11222540f, -0.07904003f, 0.07992372f, 0.07305454f, -0.49926862f, -0.07075974f, -0.05305140f, 
    -0.09729367f, 0.11233309f, 0.24439876f, 0.17634672f, 0.02496906f, -0.00881401f, 0.01270142f, -0.01424015f, 
    0.04843713f, -0.03700412f, -0.08119850f, 0.01774206f, 0.03706041f, 0.12452251f, 0.09454869f, 0.14574763f, 
    -0.11283334f, -0.22017631f, 0.00560578f, -0.09922960f, 0.10626881f, -0.01929466f, 0.05015402f, 0.13499646f, 
    0.21403866f, 0.11712753f, 0.56372464f, 0.30136308f, -0.15368438f, -0.01257676f, -0.05031344f, 0.16642477f, 
    0.05891022f, 0.06340938f, -0.06381005f, 0.05616897f, -0.18421525f, 0.07345789f, 0.02575345f, 0.11406717f, 
    -0.08932661f, -0.09015279f, -0.15393817f, -0.22381754f, 0.02453011f, -0.06126048f, 0.04085101f, 0.02592406f, 
    0.34931171f, -0.59783375f, -0.07212079f, -0.09738486f, 0.03252680f, -0.00182205f, -0.02467896f, -0.14053124f, 
    -0.01844766f, -0.00345253f, -0.17934436f, 0.02514110f, -0.05426984f, -0.13679850f, 0.14329274f, 0.13754562f, 
    -0.17109802f, -0.15791607f, -0.06505648f, 0.01846778f, 0.10511538f, 0.12804073f, -0.02067853f, -0.09286121f, 
    0.02168870f, -0.22771214f, -0.25472391f, 0.17176259f, -0.23342548f, 0.00024678f, -0.14633596f, 0.21485896f, 
    -0.02258219f, -0.04280927f, -0.04935313f, -0.07330676f, -0.58192283f, -0.52650940f, -0.18361382f, -0.12228765f, 
    0.02658438f, -0.02192786f, -0.14844295f, 0.17675644f, 0.20242250f, 0.07168723f, -0.00843364f, -0.13755836f, 
    0.05079603f, -0.25536230f, 0.02780779f, -0.35495743f, -0.08742675f, 0.11541072f, -0.03078400f, 0.08903043f, 
    0.03724097f, 0.00332129f, 0.10941439f, -0.04724385f, 0.70957756f, -0.29645243f, -0.00877717f, -0.11858831f, 
    -0.03427285f, 0.06498857f, -0.09518849f, -0.00186291f, 0.04342835f, -0.05825999f, 0.04625124f, 0.01565333f, 
    0.21586199f, 0.01995054f, 0.27005392f, 0.11105605f, 0.07312993f, -0.25343433f, -0.08327316f, 0.06120478f, 
    -0.00096800f, -0.07257319f, -0.03147937f, 0.19917920f, 0.03726422f, 0.16426469f, -0.38773632f, 0.01052890f, 
    0.13743293f, 0.10723826f, -0.11433283f, 0.06591351f, 0.23358877f, 0.09672397f, 0.14763124f, -0.10960370f, 
    0.13194975f, -0.30461305f, -0.18857017f, 0.00219270f, 0.08146711f, 0.00158624f, -0.02628980f, 0.00103682f, 
    0.08447713f, 0.15908654f, -0.19163705f, 0.10084763f, 0.09799369f, 0.06607050f, 0.01146188f, -0.36743468f, 
    0.11860463f, -0.15231495f, 0.04675446f, 0.06845958f, -0.07444459f, 0.21359898f, -0.16696873f, 0.09089354f, 
    0.16216767f, 0.11310413f, 0.27561504f, -0.08321509f, 0.05284698f, -0.05433694f, 0.01009593f, 0.10834426f, 
    0.24253583f, -0.17754175f, 0.10208084f, 0.01806210f, 0.01700524f, 0.20989229f, 0.15178238f, -0.11958973f, 
    0.21173707f, 0.01258913f, -0.09800489f, 0.11544133f, 0.08439430f, -0.05550836f, 0.04097945f, 0.10324617f, 
    0.35725608f, -0.49751937f, 0.12144506f, 0.14217134f, -0.23667015f, -0.16065334f, 0.17345317f, 0.22276413f, 
    0.13274361f, 0.05173294f, 0.11044187f, -0.05079916f, 0.07869995f, 0.20478888f, -0.00634283f, -0.12381669f, 
    -0.10408267f, -0.03530852f, -0.04873870f, -0.00919883f, -0.09492708f, -0.05925630f, -0.05446940f, -0.22167088f, 
    -0.27400196f, 0.16160268f, -0.55959004f, 0.05092526f, 0.15456146f, 0.19183339f, -0.16081068f, 0.09004008f, 
    -0.05060790f, -0.11751123f, 0.13676812f, 0.03270561f, -0.15092105f, -0.07936670f, 0.01059822f, -0.26262650f, 
    -0.09278460f, 0.09293052f, 0.07496344f, 0.01939753f, 0.20000860f, -0.11821610f, -0.07179752f, 0.06040778f, 
    -0.08474085f, -0.10196840f, 0.03962748f, 0.36619493f, 0.09931864f, -0.08735493f, -0.08246209f, 0.00350682f, 
    -0.01211721f, -0.12921123f, -0.00902612f, 0.28749162f, -0.20181334f, -0.03771833f, -0.06469817f, -0.17108490f, 
    -0.02255500f, 0.02997882f, 0.09343058f, -0.00834861f, 0.00088754f, -0.26316452f, 0.12148798f, -0.34847689f, 
    0.30137721f, -0.11548374f, -0.22339958f, -0.04316813f, -0.02117448f, 0.04745043f, 0.12882252f, 0.00405868f, 
    -0.03646348f, -0.47860667f, -0.30731016f, -0.78835285f, 0.25877854f, -0.17812224f, -0.18777521f, -0.26420930f, 
    0.07730330f, 0.10279302f, -0.27927905f, 0.33095258f, -0.18460651f, -0.19338121f, 0.08086110f, -0.04523310f, 
    0.09408794f, 0.07283498f, -1.11849213f, 0.05219201f, 0.12406939f, -0.00635424f, -0.03299561f, 0.01106690f, 
    0.22167248f, -0.18314959f, -0.02394709f, 0.08579455f, -0.05847045f, 0.43767366f, -0.23976624f, 0.03529188f, 
    -0.21111378f, -0.10460214f, 0.21696135f, 0.21265161f, 0.00076441f, 0.06600160f, -0.05940586f, 0.26171440f, 
    -0.69818187f, -0.32552823f, 0.40451983f, 0.26696292f, 0.11492407f, -0.16638167f, 0.04283745f, -0.15011933f, 
    0.17713432f, -0.10623018f, -0.15070538f, 0.28623897f, 0.29604802f, 0.19784877f, 0.11623654f, 0.04432632f, 
    0.00152627f, -0.07312993f, 0.11160562f, -0.07004992f, 0.07986411f, -0.02606259f, 0.05491806f, -0.00473393f, 
    0.03538535f, -0.16388181f, -0.03639850f, -0.09153476f, 0.06309932f, -0.03095202f, -0.08913659f, -0.15153557f, 
    0.00536915f, 0.44892204f, 0.31089795f, -0.13539720f, -0.56667334f, 0.14934902f, 0.31195992f, -0.36580148f, 
    -0.13129696f, -0.15419015f, 0.15746471f, 0.09311938f, -0.10908671f, 0.07982735f, -0.03642784f, 0.06943917f, 
    -0.04407186f, -0.09839159f, -0.15239796f, 0.05779827f, -0.09159097f, -0.15901615f, -0.13366508f, -0.09144915f, 
    0.06426965f, 0.05614836f, 0.07699306f, -0.03234998f, -0.22855717f, -0.05937086f, -0.25360870f, -0.12734060f, 
    0.10345497f, -0.05989640f, 0.01022455f, -0.29540491f, -0.00803099f, 0.08507761f, 0.05265155f, -0.14823192f, 
    -0.00347544f, -0.03776060f, 0.20383328f, -0.13705380f, 0.14310336f, 0.16822304f, 0.33856305f, 0.07351190f, 
    0.12932283f, 0.04445835f, -0.00272753f, 0.15403534f, -0.19983207f, 0.13214660f, -0.19806816f, -0.24287663f, 
    0.02776406f, 0.08589692f, -0.07660768f, 0.06000675f, -0.00748863f, -0.05010254f, -0.06534343f, -0.16141279f, 
    0.22915946f, 0.03685304f, 0.17151962f, -0.08050876f, 0.28533894f, 0.03876630f, -0.06076233f, -0.39940655f, 
    -0.01661560f, -0.07093716f, -0.05627044f, 0.12717655f, -0.13798217f, -0.07708688f, -0.21434961f, -0.21681188f, 
    0.03614083f, -0.09152259f, 0.15461764f, -0.14854448f, -0.01574720f, -0.04037596f, 0.00072135f, 0.16862331f, 
    -0.08523577f, 0.06023317f, -0.06349990f, -0.11574263f, -0.14467359f, -0.11647452f, -0.08793729f, 0.02269865f, 
    0.27614287f, 0.20915696f, -0.36638626f, 0.00039531f, -0.15258849f, 0.16291340f, 0.14378296f, -0.08635082f, 
    0.20531684f, 0.16306798f, -0.02828971f, 0.35079092f, -0.04764019f, 0.02791750f, 0.11145913f, 0.10393168f, 
    -0.16056503f, 0.20060217f, 0.22911598f, -0.13471013f, 0.10748938f, 0.14795172f, 0.00263004f, -0.42993614f, 
    0.01464280f, 0.03842155f, 0.14087717f, 0.10843454f, 0.02512178f, 0.21735463f, 0.29650837f, 0.18814524f, 
    -0.01727437f, 0.08384860f, -0.11044797f, 0.10402165f, 0.03691895f, 0.02238473f, 0.19082341f, 0.14685769f, 
    0.00088662f, -0.37532502f, -0.30424875f, -0.04003450f, 0.14211394f, 0.12473720f, 0.00922162f, 0.01618575f, 
    -0.03170032f, -0.00954143f, -0.06315932f, 0.00668879f, 0.09960018f, -0.10302977f, -0.17585582f, -0.09696222f, 
    -0.04386115f, 0.02039403f, -0.12655491f, 0.11168387f, -0.06803703f, 0.17209093f, -0.21170817f, -0.07015981f, 
    -0.50768638f, 0.10646933f, -0.13574187f, 0.01238589f, -0.27773461f, -0.08028970f, 0.21059129f, 0.10165588f, 
    0.05680579f, -0.03064935f, 0.12878646f, 0.02568678f, 0.34535411f, -0.07365672f, -0.31272280f, 0.03586812f, 
    -0.04014401f, -0.07517926f, 0.17689602f, 0.14158614f, 0.03613461f, 0.13469368f, -0.27164283f, -0.07504262f, 
    -0.07993273f, 0.19394979f, -0.09084713f, -0.04246695f, -0.01255038f, 0.03661132f, 0.05872644f, 0.07119086f, 
    -0.11812958f, -0.06270232f, -0.00792379f, -0.13421479f, -0.29647344f, -0.26702824f, 0.06046141f, 0.22627112f, 
    0.12521367f, 0.16671388f, 0.13427727f, -0.12075079f, 0.01132547f, 0.08090792f, -0.03887821f, 0.04303303f, 
    -0.59335637f, -0.26515836f, 0.10137900f, 0.36212265f, 0.16906786f, 0.07417177f, 0.12360671f, 0.03084394f, 
    0.00699145f, 0.04333193f, 0.14744548f, -0.08385953f, -0.70595944f, -0.73811704f, -0.53036320f, -0.36290082f, 
    -0.14039408f, -0.51540518f, 0.12252391f, -0.70729095f, -0.01899992f, 0.01529503f, -0.04498865f, -0.00604575f, 
    -0.03075243f, -0.18292026f, -0.29961222f, 0.29705909f, 0.00820555f, 0.13110168f, 0.00448468f, 0.21871467f, 
    0.04152372f, 0.07820475f, -0.03887602f, -0.04640329f, 0.64945918f, -0.57826865f, -0.37714404f, -0.57947153f, 
    -0.20450661f, -0.07432554f, 0.00976598f, 0.13527146f, 0.02148433f, 0.18855412f, -0.11794367f, -0.07052533f, 
    0.42919272f, -0.38272592f, 0.01260143f, -0.31223872f, 0.01707776f, 0.00477817f, 0.25452828f, -0.15879345f, 
    0.09811483f, -0.16800448f, -0.04769394f, -0.02787024f, -0.02691086f, 0.66404754f, 0.32747570f, 0.19183451f, 
    0.04324935f, -0.17947479f, 0.00184635f, 0.27456430f, -0.01040747f, 0.17344755f, 0.02406807f, -0.11351868f, 
    -0.00813880f, 0.06282685f, 0.01783136f, -0.25629812f, 0.02609847f, 0.00547530f, 0.06327091f, -0.00524284f, 
    -0.01838175f, -0.02059530f, -0.08587220f, -0.05079644f, -0.13450848f, 0.02622467f, 0.12688635f, 0.27932218f, 
    -0.09900961f, 0.02885133f, -0.03595978f, -0.01688544f, 0.05137462f, 0.22441667f, 0.25034294f, 0.23321922f, 
    0.42377299f, 0.03606375f, -0.38568509f, -0.16994549f, 0.04380188f, 0.00601792f, 0.07698010f, 0.13442139f, 
    0.08254432f, 0.28326523f, 0.18399389f, 0.07413441f, 0.14268890f, 0.54116166f, -0.06349588f, 0.22344330f, 
    0.03440206f, 0.14522775f, -0.09520746f, 0.21403861f, 0.21456723f, -0.03653790f, -0.04892369f, 0.13328923f, 
    0.21023010f, -0.05797635f, -0.07365056f, -0.31231827f, 0.10668026f, -0.04432069f, 0.14217815f, -0.12372736f, 
    -0.07896798f, -0.05605121f, 0.03524964f, 0.01468038f, -0.09628788f, -0.13698636f, 0.40036097f, 0.24517661f, 
    -0.04204962f, 0.13289349f, 0.29879361f, -0.28065461f, 0.11185376f, 0.04830954f, -0.02813179f, 0.16216828f, 
    -0.00458765f, -0.40797752f, -0.15913220f, 0.32090220f, -0.05204922f, -0.01548107f, -0.08009776f, 0.18867004f, 
    0.16075070f, -0.06598925f, 0.29570141f, 0.09230253f, -0.88730419f, -1.39131582f, -0.23712520f, 0.05452062f, 
    -0.04734595f, 0.08869297f, -0.06143252f, -0.48714599f, 0.04089202f, -0.00753025f, 0.02985716f, 0.09346199f, 
    0.01082923f, 0.20585182f, 0.13488138f, -0.01271873f, -0.00425102f, 0.06653918f, -0.06177781f, -0.06660426f, 
    -0.18141134f, 0.12373737f, -0.02349155f, -0.03217477f, -0.31149411f, -0.33399698f, 0.35679919f, 0.26920187f, 
    0.07457976f, -0.17101315f, 0.04041594f, 0.13454004f, 0.05819336f, 0.21827865f, 0.10253462f, -0.04996122f, 
    -0.09103777f, -0.06406344f, -0.05447244f, -0.03876310f, -0.05746149f, -0.02697252f, -0.11372206f, 0.03274308f, 
    -0.13297610f, 0.10703129f, -0.01920803f, 0.04402198f, -0.19630386f, 0.07107909f, 0.31672034f, -0.07850463f, 
    -0.13191392f, -0.04293438f, -0.16460299f, -0.09367698f, -0.00873612f, 0.11116295f, 0.05325829f, -0.10777093f, 
    -0.80716616f, -0.78225124f, -0.69478118f, 0.05157084f, 0.05848042f, -0.26628309f, -0.25936556f, -0.47362444f, 
    -0.02154555f, -0.10128859f, -0.04869447f, -0.00521594f, -1.02260232f, 0.00466139f, 0.36804247f, 0.08323527f, 
    -0.18495023f, 0.09841336f, -0.03957832f, -0.13555269f, -0.07517266f, -0.08364644f, 0.04147381f, 0.07443181f, 
    -0.95647520f, -0.76036507f, -0.35393125f, -0.44664821f, -0.28289941f, -0.16960163f, -0.32589462f, -0.41525501f, 
    -0.05226326f, -0.05032063f, -0.07402688f, -0.07079664f, -0.58154178f, -0.85901064f, -0.30382034f, 0.02627782f, 
    0.13797857f, -0.32068837f, -0.04120927f, -0.20969705f, -0.02610851f, -0.02974730f, -0.01836420f, -0.01168580f, 
    -0.38612899f, -0.24753825f, -0.03985411f, 0.18546662f, 0.16069762f, 0.04569921f, 0.11250593f, -0.26950812f, 
    0.11210794f, 0.01578239f, 0.06431987f, -0.07191890f, -0.62540573f, -0.73630619f, -0.55768687f, -0.14127941f, 
    -0.27508608f, -0.07017926f, -0.09679288f, 0.06036720f, 0.05486947f, 0.05513904f, -0.13728496f, -0.04739188f, 
    -0.19878677f, 0.19032478f, -0.10322241f, 0.11747277f, 0.02104342f, -0.10087127f, 0.02203674f, -0.09763385f, 
    -0.11834504f, 0.01033747f, 0.05903509f, -0.15279526f, 0.48263034f, -0.20700118f, -0.08486791f, -0.13709520f, 
    -0.01864930f, 0.04135996f, -0.05715691f, -0.05927007f, 0.18024217f, 0.02882114f, -0.03106217f, 0.02789260f, 
    -0.30104679f, -0.09174258f, 0.05636063f, -0.21879812f, 0.04815974f, -0.06649893f, -0.00570173f, -0.07878473f, 
    0.04787671f, 0.08127737f, 0.04651349f, -0.08872999f, -0.03270619f, 0.09224245f, 0.06041883f, -0.26298445f, 
    0.11563747f, -0.01617064f, 0.02694170f, -0.08845379f, 0.10803217f, -0.20209023f, -0.02094552f, -0.35574183f, 
    -0.45541871f, -0.50917768f, -0.11999454f, -0.15513776f, -0.04977593f, -0.06314398f, 0.14161566f, -0.01521274f, 
    -0.02577066f, 0.00814192f, 0.01612111f, -0.08036908f, -0.34197605f, 0.16969538f, -0.14564878f, 0.17946011f, 
    -0.04853239f, 0.08710372f, -0.06737088f, -0.04911407f, -0.02748240f, -0.07936996f, -0.05616101f, -0.02856758f, 
    -0.11016186f, 0.10710095f, -0.04331037f, -0.06332210f, 0.00146213f, -0.04262701f, -0.04626609f, -0.08142695f, 
    0.05090202f, -0.01224447f, -0.05378726f, -0.04354915f, -0.04853891f, 0.22729655f, 0.00334788f, -0.12696646f, 
    0.07816271f, -0.15248148f, 0.03542456f, 0.13862865f, -0.24502650f, 0.03862776f, 0.10462862f, 0.06483070f, 
    -0.06957953f, 0.14986414f, 0.13304058f, -0.37539807f, -0.07665635f, 0.05951400f, 0.08787936f, 0.19404827f, 
    -0.19537598f, 0.07907771f, -0.04489623f, -0.10105136f, -0.19305065f, -0.22720477f, -0.16976988f, 0.24998522f, 
    0.20414937f, -0.13722530f, 0.09643970f, 0.17941201f, 0.07539376f, -0.01096112f, 0.00536406f, -0.05288843f, 
    0.70826918f, -0.81030154f, 0.13858266f, -0.29853976f, -0.07789618f, 0.06215513f, -0.17442909f, -0.05467414f, 
    -0.16352646f, 0.08674249f, -0.13562857f, -0.14946143f, -0.56815279f, -0.56758386f, -0.03911484f, 0.37743136f, 
    -0.02356540f, 0.01356484f, -0.06857368f, 0.15846437f, 0.02885028f, -0.32419965f, 0.17819664f, 0.01981340f, 
    -0.52778035f, 0.58269453f, -0.13294283f, 0.18918712f, -0.17062792f, -0.14872889f, 0.04126350f, 0.04192217f, 
    0.06782030f, 0.00510459f, 0.04635821f, 0.00736642f, -0.32512680f, -0.44487008f, -0.20999454f, -0.25558075f, 
    -0.26348147f, 0.02378320f, 0.05491405f, 0.07320103f, 0.03554009f, -0.02128125f, 0.01908378f, 0.03507093f, 
    0.06073472f, 0.07403959f, -0.13731843f, -0.10442534f, 0.15460248f, 0.06120009f, 0.03388625f, -0.00065225f, 
    0.04576747f, 0.06633440f, -0.16090888f, -0.08767740f, 0.29272220f, -0.54980385f, 0.10681375f, -0.03081205f, 
    -0.04391448f, -0.08923635f, -0.20312113f, -0.09930684f, 0.12983325f, 0.11952303f, 0.07272769f, -0.06172784f, 
    -0.38286066f, -0.08698010f, 0.08015428f, 0.08253511f, -0.00660473f, -0.04508139f, 0.04827270f, 0.01421244f, 
    0.00548260f, 0.15160093f, 0.21393791f, 0.09798855f, -0.72806883f, -0.36111307f, -0.20756154f, -0.21407320f, 
    -0.37698412f, 0.03869075f, 0.16733825f, 0.04695046f, 0.04460371f, -0.03169302f, -0.06807153f, -0.03783368f, 
    -0.13399936f, 0.22933938f, 0.15349334f, 0.01175701f, 0.08594790f, -0.00142765f, -0.00031701f, -0.00852320f, 
    0.04242107f, -0.06143546f, 0.14327098f, -0.05943886f, -0.02762387f, 0.10371175f, -0.14185049f, 0.11541186f, 
    0.11994033f, -0.25935492f, 0.06569441f, -0.24339893f, -0.03439588f, 0.02024598f, 0.12012593f, 0.09025050f, 
    0.49259847f, -0.01036654f, 0.03854132f, -0.42818430f, -0.19104800f, 0.01971644f, 0.06336964f, -0.20488486f, 
    -0.01960347f, -0.01439779f, -0.10858381f, -0.45638695f, -0.36849737f, 0.14719722f, -0.06159469f, 0.01551869f, 
    0.20392601f, 0.13223477f, -0.04731325f, 0.05897854f, -0.01409584f, -0.07683185f, 0.02272458f, 0.04856465f, 
    0.01092596f, 0.07429907f, -0.04508151f, -0.04353144f, -0.00615772f, 0.00275814f, -0.01596641f, -0.02036463f, 
    -0.33571029f, -0.09780930f, -0.28834191f, -0.12174279f, 0.92037213f, -0.37054560f, 0.15445146f, -0.40343422f, 
    -0.04831653f, 0.25149122f, -0.16737390f, 0.10742160f, 0.09201830f, -0.04683985f, -0.01287926f, -0.16031055f, 
    0.07296923f, 0.11088369f, -0.09324393f, -0.00982013f, -0.05373901f, -0.06463028f, 0.12307651f, 0.01350606f, 
    -0.02081284f, 0.00195071f, 0.11108847f, 0.02645663f, -0.32396814f, 0.22780809f, -0.00599334f, 0.11445995f, 
    0.03433532f, 0.01061376f, 0.10875916f, 0.03473965f, -0.01165103f, 0.08143122f, 0.06695945f, 0.03560849f, 
    -0.69211972f, -0.46438488f, 0.41595337f, 0.33864012f, 0.04220803f, -0.12505355f, -0.14032622f, -0.05503416f, 
    0.04067933f, -0.01313470f, 0.01196509f, -0.00971867f, 0.52698189f, -0.45313224f, -0.38515323f, -0.36877918f, 
    -0.14571102f, -0.13982975f, 0.02197797f, 0.13188471f, 0.07821638f, 0.00658830f, 0.03020836f, 0.02038146f, 
    -0.69821835f, -0.79740053f, -0.18122263f, 0.84791052f, -0.10464711f, 0.07036433f, 0.21496433f, 0.13695827f, 
    0.00509424f, 0.02013286f, 0.07010242f, 0.03485972f, -0.35706785f, -0.26142281f, -0.34972912f, -0.17907760f, 
    0.01353863f, 0.15054081f, -0.07680520f, 0.19717826f, 0.09998555f, -0.04867419f, -0.03291559f, -0.05432765f, 
    0.17472722f, -0.10409639f, 0.08288494f, -0.24497630f, 0.00376357f, 0.21714704f, 0.03536658f, 0.13589098f, 
    -0.23592289f, 0.11058301f, 0.13288827f, 0.02338389f, -0.01653130f, -0.33730108f, -0.21276093f, -0.12498334f, 
    0.14463611f, -0.00660613f, 0.08774044f, 0.08155800f, 0.04850990f, -0.03512347f, 0.02275787f, 0.04075402f, 
    -0.03944108f, -0.06201299f, 0.25132847f, 0.15301789f, 0.00794099f, -0.11010196f, 0.12003028f, 0.01489989f, 
    -0.06071599f, 0.08988073f, 0.02475808f, 0.00691516f, -0.33142838f, -0.23025724f, -0.07998180f, -0.12134714f, 
    -0.00353861f, 0.14493430f, -0.03064318f, 0.19585684f, 0.02795186f, 0.09948348f, 0.03626824f, -0.31293330f, 
    0.24518381f, 0.15447541f, 0.03394354f, -0.19708049f, -0.03091466f, -0.21654435f, 0.04938955f, -0.02479473f, 
    -0.07105757f, 0.05615447f, 0.06606971f, 0.07657022f, -0.30997455f, 0.17718355f, -0.09787426f, -0.04556912f, 
    -0.17343293f, -0.18029718f, 0.05456007f, -0.03575684f, 0.00751302f, 0.12300739f, -0.24504904f, 0.17562144f, 
    0.54815650f, -0.43821475f, -0.11649465f, -0.14267954f, 0.21711093f, 0.31179920f, 0.13063011f, -0.10695436f, 
    0.11708846f, -0.11064217f, -0.10958426f, -0.00368854f, -0.47530168f, 0.10339016f, 0.05888693f, 0.30989873f, 
    0.06329726f, 0.11888708f, -0.07058165f, 0.10550216f, 0.06759927f, 0.01421747f, 0.04088984f, 0.14578426f, 
    -0.01974444f, 0.20947975f, 0.18091723f, -0.19265105f, 0.01999772f, -0.01464387f, -0.08222254f, 0.02047701f, 
    -0.01615611f, -0.01846885f, 0.06627896f, 0.14399846f, -0.04349603f, 0.01297377f, -0.01436408f, 0.16048154f, 
    -0.04919166f, -0.01041010f, -0.12173779f, -0.00071001f, -0.01260435f, 0.01232574f, -0.21005368f, -0.07577235f, 
    0.58912021f, 0.15248217f, -0.40848622f, -0.29950714f, -0.13850269f, 0.02265473f, 0.11487391f, -0.13860296f, 
    0.11250231f, 0.00559593f, 0.15191592f, 0.11777572f, 0.02129658f, -0.23104376f, -0.75740474f, -0.34559578f, 
    -0.03440281f, -0.12247253f, -0.08632334f, -0.18569377f, -0.00182426f, -0.04053206f, -0.11048114f, 0.06276359f, 
    0.57098758f, -0.07075082f, -0.42985803f, -0.30871221f, 0.37236044f, -0.20680615f, 0.20205061f, -0.13240740f, 
    0.10318398f, 0.03556819f, 0.19556038f, 0.10714461f, 0.22176294f, -0.23343034f, -0.29001853f, -0.16534881f, 
    0.20678836f, -0.15440361f, 0.00506936f, 0.21524078f, -0.06867628f, 0.08230859f, 0.07547531f, -0.09491615f, 
    -0.63665909f, -0.02858380f, 0.23101318f, 0.31561583f, -0.06154554f, -0.04817065f, -0.19386061f, 0.12168410f, 
    0.04458619f, 0.03031380f, 0.11481109f, 0.13659258f, -0.57915109f, -0.46011162f, -0.07248111f, 0.25246620f, 
    0.08552618f, 0.06088332f, 0.09740587f, 0.07455237f, 0.12363420f, 0.06481175f, 0.02443375f, 0.11403222f, 
    -0.05052940f, 0.21426921f, -0.02609967f, -0.08718637f, -0.12923424f, -0.10484334f, -0.05039467f, -0.08336487f, 
    -0.03237759f, 0.10845938f, 0.00511272f, 0.14948361f, -0.48728293f, 0.01523347f, 0.09245602f, 0.32050410f, 
    0.01578369f, 0.07581371f, 0.08381801f, 0.16196847f, -0.11554738f, 0.03263932f, -0.16887954f, -0.45782372f, 
    -0.66298157f, -0.08603077f, 0.01851616f, 0.05070685f, 0.03536149f, 0.08030430f, 0.01860887f, 0.02027472f, 
    -0.46928877f, -0.21601635f, -0.35581067f, -0.48390332f, -0.17352545f, -0.60446638f, -0.19225603f, 0.31857044f, 
    0.30152515f, 0.19085191f, 0.22498672f, -0.02928741f, -0.19227180f, 0.11375882f, -0.07222925f, -0.19342411f, 
    -0.84665942f, 0.18781598f, 0.24887982f, 0.28932646f, -0.04075701f, -0.01023873f, -0.21760164f, 0.02242170f, 
    -0.16942054f, -0.00324042f, -0.10981764f, -0.01841090f, 0.13602559f, -0.35239154f, 0.21443193f, -0.15005417f, 
    0.15572226f, 0.13658588f, -0.13523205f, 0.14182004f, -0.06801527f, -0.04247259f, -0.23594525f, -0.35725722f, 
    0.37678799f, -0.22564259f, 0.03583091f, -0.29009020f, 0.02046381f, 0.13851738f, -0.08223736f, -0.02612417f, 
    0.14785679f, 0.13536628f, 0.11008918f, 0.12405951f, 0.08370968f, 0.28541180f, 0.15062082f, 0.08552700f, 
    0.02314811f, -0.18398638f, -0.31980759f, -0.39469218f, -0.00503771f, 0.06864422f, -0.01726105f, 0.06078482f, 
    -0.08986141f, 0.05421389f, 0.09044210f, -0.22603098f, -0.11775123f, 0.01276682f, -0.00991060f, -0.05404479f, 
    0.05134327f, -0.01172456f, 0.22430170f, 0.16730760f, 0.22336598f, 0.07624155f, -0.33161581f, 0.00390909f, 
    -0.18454152f, -0.20016666f, 0.05671370f, 0.16522807f, 0.06561556f, -0.02200919f, 0.03566930f, 0.13356635f, 
    -0.10768926f, -0.06798720f, -0.11694244f, -0.09437566f, -0.10512210f, 0.02956611f, 0.00965428f, 0.06823019f, 
    0.06897725f, 0.08258265f, 0.06365331f, 0.07449229f, 0.01949799f, -0.02967026f, -0.16212276f, -0.13683459f, 
    -0.13469878f, -0.01334377f, -0.05428333f, 0.01380049f, 0.02729359f, 0.30807325f, 0.15063706f, 0.12280160f, 
    0.43376154f, -0.24269281f, -0.06234178f, -0.08573702f, -0.03773134f, -0.01435895f, -0.24783510f, 0.02833906f, 
    0.06472934f, 0.09163733f, 0.05821995f, 0.05950359f, -0.60533857f, -0.72717011f, -0.62900734f, -0.25843114f, 
    0.11613708f, 0.31519216f, 0.13675340f, 0.10787177f, -0.01724522f, -0.00405931f, -0.04736410f, -0.09903633f, 
    0.33187255f, -0.46543649f, -0.40102890f, -0.13963901f, -0.28031355f, 0.04291221f, -0.00968198f, 0.08136034f, 
    0.02590851f, 0.01694647f, 0.05887269f, -0.06729686f, -0.11935305f, -1.01820612f, -0.50575620f, 0.19907327f, 
    0.17639449f, -0.05369886f, 0.08640903f, 0.03607321f, -0.07759625f, -0.04797693f, 0.06678614f, 0.25696582f, 
    0.10538974f, -0.15120408f, -0.00139050f, -0.22457923f, -0.19161421f, 0.04570682f, 0.07648742f, -0.01893278f, 
    0.17246088f, 0.03266988f, 0.01405974f, 0.00234484f, -0.21836981f, -0.31403819f, -0.45296231f, 0.01435120f, 
    -0.12572400f, 0.32818905f, 0.26563770f, -0.16498511f, 0.04403739f, -0.06861848f, -0.02862040f, -0.06178246f, 
    -0.38673109f, -0.28343543f, 0.07944337f, -0.12611830f, 0.04601694f, 0.14589031f, 0.06918114f, 0.17399332f, 
    0.09064074f, 0.01125257f, -0.00460270f, 0.17736320f, 0.18298392f, 0.44549122f, 0.09586152f, 0.18672854f, 
    -0.13125473f, -0.16193855f, -0.26557514f, -0.23808312f, -0.00611556f, 0.01963216f, 0.12324557f, 0.17971215f, 
    0.09645511f, -0.55061638f, -0.12214351f, 0.07886604f, 0.09439247f, 0.09367613f, 0.16271891f, -0.09591030f, 
    0.10680830f, -0.15321752f, -0.13381340f, -0.09963315f, 0.11011297f, -0.25827837f, 0.12599477f, 0.15542403f, 
    0.08554886f, 0.04638741f, -0.00489093f, -0.10338433f, 0.15895464f, 0.15054552f, -0.13855319f, -0.15340236f, 
    0.14698705f, -0.35610673f, 0.08725774f, 0.11942087f, 0.05868237f, -0.10250007f, 0.09451592f, -0.03136802f, 
    -0.03289449f, 0.05582496f, -0.02676871f, 0.08860223f, -0.35537159f, 0.29155183f, -0.34860772f, -0.39610982f, 
    0.07505126f, 0.02445458f, 0.08918238f, 0.02866860f, -0.06841734f, -0.05499861f, -0.08056733f, -0.07901341f, 
    -0.18256070f, -0.10848080f, -0.13133101f, 0.15564668f, 0.09037843f, -0.00081364f, 0.00880191f, -0.10588679f, 
    0.03072797f, 0.00272499f, 0.06422666f, -0.00159494f, 0.19165184f, -0.59210008f, 0.09992193f, -0.43633643f, 
    -0.01834972f, 0.08160990f, -0.00749163f, 0.27395162f, 0.05579871f, 0.03574390f, -0.13217731f, -0.10200256f, 
    -0.59796053f, -0.87689543f, 0.24706158f, -0.16548245f, 0.00943692f, 0.11378348f, -0.41363397f, 0.04335837f, 
    -0.05882293f, 0.15361817f, 0.16199523f, -0.10094251f, -0.48039436f, 0.14051697f, -0.10700137f, 0.16505626f, 
    -0.27739266f, 0.11407927f, 0.07269069f, 0.30448213f, 0.07112477f, 0.06566009f, 0.07697801f, -0.00684154f, 
    0.13160759f, -0.26795089f, 0.61572278f, 0.03121944f, -0.01364405f, -0.12931095f, -0.06405240f, -0.26998997f, 
    0.12277164f, 0.02872415f, 0.07205645f, 0.02010893f, 0.40243971f, 0.46237844f, -0.35005680f, 0.01860647f, 
    -0.12628835f, 0.02908594f, -0.00766984f, 0.00465816f, 0.17555435f, 0.00761930f, -0.00439415f, 0.06448540f, 
    -0.40696836f, 0.51238811f, -0.61731696f, -0.20191650f, -0.12192287f, -0.12517470f, 0.24473123f, 0.22081099f, 
    -0.06314903f, -0.12006374f, -0.24493651f, -0.08520935f, 0.55919093f, 0.06733602f, 0.61778629f, -0.55682403f, 
    -0.01141209f, -0.12135700f, -0.22162041f, -0.10718544f, -0.14753504f, 0.04006229f, -0.03513818f, -0.02458271f, 
    -0.11575190f, -0.06595071f, -0.16421047f, 0.29718074f, 0.10140675f, 0.00676981f, 0.00656995f, -0.03555337f, 
    -0.04728052f, 0.15459721f, -0.41336685f, -0.27791139f, 0.03951525f, -0.07473423f, 0.15064624f, -0.13313489f, 
    0.03010991f, -0.00322088f, -0.04052787f, -0.00726294f, 0.01556863f, 0.18495472f, 0.09438908f, 0.04747535f, 
    -0.00090702f, 0.25541550f, 0.36179388f, -0.34671912f, 0.02082502f, 0.00888932f, 0.23885953f, 0.07957274f, 
    0.10090234f, 0.13475855f, 0.21140596f, 0.17380014f, 0.23606110f, 0.16860604f, 0.47251591f, -0.70420086f, 
    -0.04775858f, -0.20641235f, 0.00559052f, -0.07862626f, -0.12138537f, 0.04260106f, 0.18703967f, 0.12939452f, 
    0.02706002f, -0.27596852f, -0.29244742f, -0.18828458f, -0.14573775f, 0.17855769f, 0.23339984f, 0.11036587f, 
    0.04217752f, 0.08457709f, -0.11350203f, -0.05763848f, -0.59558976f, 0.05246692f, -0.20832990f, -0.23722549f, 
    0.06966566f, 0.01854965f, 0.04275020f, -0.14560612f, 0.11868523f, -0.01827615f, -0.15932009f, -0.00971980f, 
    -0.34013560f, -0.07004461f, -0.18043254f, -0.17405215f, 0.32838020f, 0.10641923f, -0.06905672f, -0.06688009f, 
    -0.15020187f, -0.24771586f, 0.05007502f, -0.12531058f, 0.02909567f, -0.33152241f, -0.22685680f, -0.07760124f, 
    0.03168486f, -0.00292532f, -0.06701668f, 0.41260132f, 0.05706423f, 0.05738958f, 0.02957934f, -0.01527798f, 
    0.08386145f, 0.02119147f, -0.00081909f, 0.24278700f, 0.06001257f, -0.01000759f, 0.00269150f, -0.05335904f, 
    0.26858714f, -0.06675456f, -0.31730032f, 0.10605747f, -0.04644251f, -0.68174326f, 0.29036424f, 0.29701012f, 
    0.09232771f, -0.01019471f, -0.41574353f, -0.04803132f, 0.01712255f, -0.08723786f, 0.01134587f, 0.10748609f, 
    -0.04857555f, 0.02372517f, 0.12199180f, 0.18732059f, 0.25567174f, 0.18032844f, 0.11155005f, 0.18206140f, 
    0.25130221f, -0.06090633f, 0.00637184f, 0.00623599f, 0.40258622f, 0.34049314f, -0.16984485f, -0.12819013f, 
    0.04416044f, -0.21803096f, -0.08249101f, 0.13247560f, 0.20685279f, -0.25889573f, -0.08219827f, 0.04223916f, 
    -0.05557572f, -0.09280805f, -0.44803855f, -0.08782133f, 0.04462063f, -0.13202749f, 0.16558211f, -0.05386290f, 
    0.01023176f, -0.07632343f, -0.09735592f, -0.05602003f, -0.27790776f, 0.19580001f, 0.02099222f, -0.25035658f, 
    -0.10425857f, -0.06895585f, -0.07612075f, 0.09956695f, 0.07946162f, -0.03333935f, 0.06620048f, 0.07702312f, 
    0.07048649f, 0.07098158f, 0.19728726f, 0.00254250f, 0.13860169f, -0.29699266f, 0.05937551f, 0.25510573f, 
    -0.12779626f, 0.04873868f, 0.01622537f, -0.03987613f, 0.08818407f, -0.30984861f, -0.08991770f, -0.30816841f, 
    -0.41221341f, -0.13648978f, -0.12724033f, 0.10707603f, 0.04366164f, -0.03369042f, 0.04751122f, -0.10178827f, 
    -0.21017151f, -0.13952510f, 0.24560599f, -0.25350672f, -0.22843556f, 0.26123896f, -0.35832492f, 0.10785250f, 
    0.01714480f, -0.19997422f, -0.07318500f, 0.07885502f, -0.41654867f, 0.11193785f, 0.41261417f, -0.11247578f, 
    -0.19440840f, -0.43294445f, -0.06365907f, -0.21287018f, 0.05835806f, 0.09835466f, 0.05363391f, -0.04398505f, 
    -0.10877224f, -0.30760244f, 0.22496367f, 0.31169519f, -0.16427231f, 0.13168657f, 0.03443182f, 0.12255108f, 
    0.01759525f, -0.26191542f, -0.22515188f, -0.17356764f, 0.18084738f, 0.27507368f, 0.07210496f, -0.26817003f, 
    0.16737898f, -0.23404306f, -0.00792322f, 0.11679958f, -0.13324831f, 0.04297765f, -0.22657193f, -0.27371141f, 
    -0.45636952f, 0.23339884f, 0.02253959f, -0.18544626f, -0.20204975f, -0.04047487f, 0.24282655f, 0.05113500f, 
    0.00669053f, 0.21220143f, 0.15694882f, 0.08953677f, -0.31313771f, 0.27445653f, -0.33516446f, 0.20874704f, 
    -0.17648809f, 0.07255565f, 0.05635711f, -0.02002553f, 0.11736207f, -0.09259015f, 0.18713008f, 0.22955969f, 
    -0.28962079f, 0.41036913f, 0.12640482f, 0.13900150f, -0.05221488f, 0.13963330f, 0.06213209f, 0.16936569f, 
    0.03975241f, 0.06051984f, 0.10786866f, -0.00239383f, 0.10527436f, -0.46996796f, 0.34090972f, 0.14613587f, 
    -0.13418584f, -0.01976361f, -0.00796750f, 0.32289416f, -0.19934654f, 0.00612861f, 0.10324474f, 0.21778490f, 
    -0.11823744f, -0.28004920f, -0.21836087f, -0.12270783f, -0.15701139f, -0.04836810f, 0.04929114f, 0.00783735f, 
    0.02347020f, 0.07531235f, -0.21973071f, 0.09050645f, -0.22619949f, -0.32478318f, 0.25551218f, -0.04488028f, 
    -0.01654587f, 0.15138201f, -0.22527441f, -0.03665467f, 0.05713367f, -0.21359685f, -0.07450514f, -0.23489949f, 
    -0.50980341f, 0.07101102f, -0.05591416f, 0.14403307f, 0.02033447f, 0.16270976f, -0.10451475f, -0.03326486f, 
    0.06567733f, -0.17307901f, -0.17033762f, -0.19608246f, -0.00900264f, 0.05182739f, -0.36723775f, 0.22942810f, 
    -0.30448598f, 0.01761521f, -0.31420082f, 0.20782486f, -0.02571019f, 0.19878724f, 0.02871861f, 0.05942350f, 
    -0.68797410f, 0.27003258f, -0.24017105f, -0.12100958f, -0.13591005f, 0.17249472f, 0.20079118f, 0.10937138f, 
    -0.14476348f, 0.00233423f, 0.08836349f, -0.00761757f, -0.48529413f, -0.42740420f, 0.36111507f, 0.05516384f, 
    -0.04760005f, 0.26359549f, 0.16125602f, -0.19424167f, -0.09745920f, 0.09696542f, -0.06578825f, 0.09876134f, 
    0.13766092f, -1.02219212f, 0.03790942f, 0.00439858f, -0.17352401f, 0.03029855f, 0.36526030f, -0.16616054f, 
    -0.16882880f, 0.06668229f, -0.07501211f, 0.07754155f, 0.22311766f, 0.20943205f, -0.02443463f, 0.25983572f, 
    0.05948244f, -0.07716496f, 0.03662764f, 0.00140193f, 0.05093155f, 0.03269799f, 0.24798791f, 0.18427928f, 
    -0.16756618f, -0.16265501f, 0.29947931f, -0.51415384f, -0.32430917f, 0.00825745f, 0.16735537f, -0.21124166f, 
    0.13469855f, -0.26598242f, 0.19330181f, 0.12319288f, 0.12421577f, -0.02378207f, -0.00671527f, 0.01541111f, 
    0.10798085f, -0.05609047f, -0.00484787f, 0.11122246f, -0.16060251f, -0.32380646f, -0.44702685f, -0.55067301f, 
    -0.12266126f, 0.43822071f, -0.11211495f, 0.05088490f, 0.07191336f, -0.12919042f, -0.01853628f, 0.13679358f, 
    -0.16369329f, -0.32915330f, -0.19846715f, -0.55067563f, -0.20856224f, -0.21264429f, -0.14726704f, 0.48513073f, 
    0.05593121f, -0.36350924f, -0.01074651f, 0.02704557f, 0.03158687f, 0.04499677f, -0.20015548f, -0.30234900f, 
    -0.00766936f, -0.06349792f, 0.23657344f, -0.03066398f, -0.19539826f, -0.16643393f, -0.00455726f, -0.04170873f, 
    -0.14405802f, -0.17374456f, 0.00650430f, 0.12309057f, 0.22917992f, -0.02320215f, 0.67403126f, 0.37865850f, 
    0.00696877f, -0.14421852f, 0.03430241f, 0.05594851f, -0.14160003f, -0.28769231f, -0.03937577f, 0.12075590f, 
    -0.40423328f, 0.27974167f, 0.77789313f, 0.26878008f, -0.03535299f, 0.09691661f, 0.18106848f, 0.19846560f, 
    -0.02891802f, 0.20507032f, -0.13670425f, 0.15603098f, -0.04046018f, -0.40263656f, -0.08668026f, -0.08385357f, 
    -0.01610408f, 0.23281237f, -0.16961080f, -0.27158761f, -0.04071220f, -0.04974653f, 0.06771228f, 0.04053890f, 
    -0.17188165f, 0.15452796f, 0.08679436f, -0.36520508f, -0.16275632f, -0.09074559f, 0.08923976f, 0.14019376f, 
    0.13614374f, 0.16265965f, -0.02096579f, -0.09294675f, -0.56716645f, 0.21942012f, 0.05892414f, 0.14706969f, 
    0.11589020f, 0.09404593f, 0.06887426f, -0.16226780f, -0.20258507f, 0.04235282f, 0.05548605f, -0.06382950f, 
    -0.12013084f, -0.19279587f, 0.26771095f, -0.29260090f, -0.03412286f, -0.27145344f, -0.22898026f, -0.19547366f, 
    -0.02842895f, 0.22834352f, 0.03279891f, 0.11669540f, 0.16827022f, 0.30289596f, 0.09745263f, 0.15239754f, 
    -0.29343531f, 0.07190478f, -0.03497229f, 0.14716533f, 0.01336219f, 0.16225034f, 0.02417651f, 0.26193824f, 
    -0.34549326f, 0.05250390f, -0.07457703f, 0.20602547f, -0.14473014f, 0.07928153f, 0.01714055f, 0.07075720f, 
    0.02190601f, 0.19745900f, 0.12384827f, 0.05362107f, -0.04066400f, -0.15530993f, -0.23597600f, -0.09431526f, 
    -0.00785961f, -0.06047970f, -0.15882184f, 0.00524031f, -0.07947219f, 0.06284316f, -0.04237441f, -0.30227503f, 
    -0.62396252f, -0.05929219f, -0.15070824f, 0.15517603f, 0.10987995f, 0.04097870f, -0.05184120f, -0.10673709f, 
    -0.15886988f, 0.25182575f, -0.02806881f, 0.00550998f, 0.06046573f, -0.01676521f, -0.24009700f, 0.17417143f, 
    0.04225071f, -0.18307844f, 0.06645825f, -0.02747576f, -0.06051112f, 0.13609837f, -0.22320750f, -0.08868124f, 
    0.08949030f, 0.27472830f, 0.08505834f, 0.04231733f, -0.00771443f, 0.10485519f, -0.26062074f, 0.10252299f, 
    -0.00406439f, 0.16714485f, -0.04056292f, 0.12246402f, -0.01934148f, -0.37443975f, 0.16882402f, -0.00862254f, 
    0.03320898f, 0.17106998f, 0.09983098f, 0.07497402f, -0.15784012f, -0.02518305f, 0.09088074f, -0.07869351f, 
    -0.21634042f, 0.25542599f, 0.10732055f, -0.20991449f, -0.15015568f, 0.08044241f, 0.15342875f, -0.05295857f, 
    0.07217157f, -0.04545376f, 0.06966542f, 0.30216908f, -0.18697530f, -0.02401621f, -0.18766245f, -0.23068453f, 
    0.04281908f, -0.06824979f, 0.19797665f, 0.02080411f, -0.01971798f, -0.04282262f, -0.15655178f, 0.04788471f, 
    0.38253078f, 0.30677095f, 0.29032770f, 0.32366505f, -0.08379353f, 0.26839408f, -0.01773053f, -0.02004799f, 
    -0.13595109f, 0.03050545f, -0.05112387f, -0.03519259f, 0.00449487f, 0.04301192f, 0.11953000f, 0.32071733f, 
    0.04467440f, 0.09169806f, 0.01682722f, 0.12937945f, -0.13423230f, 0.11620943f, 0.03592852f, -0.05633032f, 
    -0.22156455f, -0.40186691f, 0.04416607f, -0.21691303f, 0.00494225f, -0.18081377f, -0.07502234f, -0.02470825f, 
    -0.07207607f, 0.12127600f, 0.14559862f, 0.05294194f, 0.22316414f, -0.09485444f, 0.72928238f, -0.15080783f, 
    0.06146874f, -0.05460130f, -0.10904926f, 0.13464919f, -0.02196144f, -0.05594739f, 0.07055084f, -0.04104879f, 
    0.45387837f, -0.04895799f, 0.10317246f, -0.08494631f, -0.02365319f, 0.05490363f, 0.01853268f, 0.07578405f, 
    0.01717355f, -0.02997819f, 0.05350497f, 0.02348691f, 0.07108804f, 0.22398046f, -0.15298383f, 0.23316507f, 
    -0.37451145f, 0.16233894f, -0.07851310f, -0.01627490f, -0.06389101f, 0.11828608f, -0.04821325f, -0.08612151f, 
    -0.58075809f, 0.00042778f, -0.28826785f, 0.26461989f, 0.09607697f, 0.06332158f, 0.05554940f, -0.06664108f, 
    0.07534289f, -0.03901438f, -0.01379857f, 0.11893354f, 0.05279515f, -0.31641939f, 0.04848543f, -0.07646412f, 
    -0.11311799f, -0.00483909f, -0.07626895f, -0.23645142f, 0.02524981f, -0.04834308f, -0.00891929f, -0.06103985f, 
    0.12978138f, 0.21657084f, -0.12632418f, 0.29256934f, 0.20637847f, -0.15903728f, 0.11151706f, 0.03713220f, 
    0.19691654f, 0.00741227f, 0.10620952f, -0.20036523f, -0.08316915f, 0.23832752f, -0.25319496f, 0.13657217f, 
    0.11508495f, -0.01087287f, 0.10189680f, 0.03492808f, 0.00104472f, 0.11509437f, 0.26050055f, 0.15708919f, 
    0.32798153f, -0.03875678f, 0.62842661f, -0.05674861f, -0.03979182f, -0.01172167f, -0.23207691f, 0.05209827f, 
    -0.03809055f, -0.03108351f, 0.10131488f, 0.00204719f, -0.81978649f, 0.07446048f, 0.22554739f, 0.18179329f, 
    -0.07769070f, -0.08396398f, -0.05842883f, 0.25227273f, -0.25272205f, -0.07957922f, -0.27867246f, -0.32934693f, 
    0.04005838f, -0.23619890f, 0.16577093f, -0.17983758f, -0.04708402f, -0.02802248f, -0.16921057f, -0.01674325f, 
    -0.18303709f, 0.06791864f, -0.08972785f, -0.28129008f, -0.30308181f, 0.18955059f, -0.44568583f, -0.28788900f, 
    0.03289390f, 0.02729522f, 0.03674177f, -0.03392376f, -0.03923831f, 0.15161401f, 0.18308260f, 0.18869740f, 
    0.01015556f, -0.00287817f, 0.20397262f, 0.12200123f, -0.04885782f, 0.15986753f, -0.08566948f, 0.14108983f, 
    -0.04220822f, 0.16888364f, 0.18910748f, 0.04813332f, -0.27618420f, -0.33069527f, 0.33979779f, -0.29091796f, 
    -0.26191011f, -0.13519703f, 0.07290392f, 0.14554660f, 0.00883417f, 0.04501241f, -0.06236442f, -0.14260344f, 
    -0.00262755f, 0.19705863f, 0.16868648f, 0.18383978f, -0.15004197f, 0.08180086f, -0.00639682f, -0.07377535f, 
    -0.08181853f, 0.05836151f, 0.10854693f, -0.06129074f, 0.10762460f, 0.18855359f, -0.17273065f, 0.35440975f, 
    -0.19996862f, 0.41913527f, -0.04487529f, 0.08679318f, -0.12312622f, 0.17306392f, 0.11539610f, -0.05420113f, 
    -0.27425745f, 0.27869394f, -0.54327214f, 0.52148813f, 0.28648779f, 0.12707268f, 0.11167254f, -0.14934745f, 
    0.24512054f, 0.10887247f, -0.29170004f, 0.02353249f, 0.08492037f, -0.09140711f, 0.07107443f, 0.02725260f, 
    -0.35610157f, -0.13810647f, -0.05791079f, -0.31721720f, -0.00668793f, -0.02952085f, -0.03789022f, -0.03899761f, 
    -0.05863343f, -0.25011083f, -0.00241192f, 0.00656080f, 0.02729137f, 0.02826962f, 0.04150560f, 0.11014540f, 
    0.01291122f, 0.08745814f, 0.04426281f, 0.08145691f, -1.01594806f, 0.41506943f, -0.98191124f, 0.56310606f, 
    0.19399430f, 0.05440275f, 0.22733045f, -0.17943953f, -0.10498895f, 0.17829086f, 0.16644263f, 0.02304314f, 
    -0.25720233f, 0.00781246f, -0.08084041f, -0.06506589f, -0.04553318f, 0.10643089f, 0.14097844f, -0.09332650f, 
    0.00048839f, -0.10233368f, -0.01642665f, -0.27293238f, -0.13418072f, -0.14065017f, 0.37679511f, 0.29154024f, 
    0.03249699f, 0.11076892f, -0.06150050f, 0.10103352f, -0.11874870f, -0.28422660f, -0.19086955f, 0.15086506f, 
    0.19865024f, 0.11786039f, 0.06629926f, 0.12162164f, -0.08737974f, -0.30745390f, -0.08049907f, -0.14302330f, 
    0.02848371f, -0.13012107f, -0.05520290f, -0.07576125f, -0.29906237f, -0.12173011f, -0.38669053f, -0.39015639f, 
    -0.42510480f, -0.20520149f, 0.04462634f, -0.04412299f, 0.10080909f, 0.15101022f, -0.03094585f, -0.00663761f, 
    -0.21107478f, -0.56219304f, -0.26942521f, 0.11257687f, -0.06412732f, -0.21177852f, -0.07896696f, -0.24238811f, 
    0.04200557f, -0.07461574f, 0.04448769f, -0.02971332f, 0.16877492f, -0.09583528f, 0.21955374f, -0.22687756f, 
    0.00535891f, 0.27323499f, -0.06058829f, -0.21623093f, 0.01933962f, -0.04740078f, 0.06424489f, -0.10160094f, 
    -0.95532656f, 0.26924983f, -0.53872705f, 0.20838937f, 0.07190951f, -0.03694767f, 0.23614004f, -0.08478684f, 
    -0.12935594f, -0.28322515f, -0.06880359f, 0.07994055f, 0.25115457f, 0.08219410f, 0.24800836f, -0.44892162f, 
    -0.07159232f, -0.31785452f, 0.02495725f, 0.17355676f, 0.00850099f, -0.04234849f, -0.13055237f, -0.09291252f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.23183870f, 0.08869467f, 0.09585401f, -0.12461413f, -0.08772866f, 0.09650686f, -0.03277664f, -0.22695412f, 
    0.09241023f, 0.04991731f, 0.01419970f, -0.04663451f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
