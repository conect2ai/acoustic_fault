#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.47933912f, 0.15076925f, 0.59263837f, 0.40168154f, -0.41371813f, -1.26691961f, 0.21879248f, 0.85500985f, 
    0.54869580f, -0.86307025f, -1.00456476f, -0.79951859f, -0.99446434f, -1.36966717f, -0.53140318f, -0.64546430f, 
    -0.03758095f, -0.78369361f, -0.94727820f, -1.65465915f, 1.40607119f, 0.46075439f, 0.52457058f, 1.28201747f, 
    -0.11837771f, -0.16494308f, -0.11413143f, 2.15490413f, -0.06611220f, -0.46967751f, 0.24375506f, 0.27829108f, 
    0.14294191f, -0.16430618f, -0.33037004f, 0.55504030f, -1.18812072f, -0.11338022f, -1.03408849f, -0.34645605f, 
    1.31454444f, 0.47177786f, 0.27802241f, 0.34558472f, 0.67904830f, -1.16459370f, 1.52650988f, 0.43255246f, 
    -1.56313086f, 0.42858511f, -0.00315347f, -0.23230882f, -0.23308805f, -0.12795818f, -0.58962679f, -1.65716100f, 
    -0.66924876f, 1.21922052f, -0.06418950f, 0.39442277f, -0.38316059f, -0.14936356f, -0.24713987f, 1.52391112f, 
    0.11254530f, -0.74941653f, -1.13004565f, -1.53975081f, -0.34399062f, -0.22805557f, 0.38933998f, 0.12848994f, 
    1.49545443f, 1.26462543f, 1.27202034f, -0.37678942f, -0.86430174f, -0.44389766f, 0.73077530f, 0.91821939f, 
    -0.23730180f, -1.61387694f, 1.49886405f, 1.40345347f, 0.77520746f, -0.00246346f, 0.54922014f, -0.13955612f, 
    -0.02823289f, -0.13168535f, 0.53774363f, -1.43727458f, -1.29563880f, -0.95374572f, 1.27802300f, 1.13166749f, 
    0.26732188f, -0.04851622f, -0.50815123f, -0.61948651f, -1.55226529f, -1.11023450f, 0.05641179f, 0.35472175f, 
    -0.85266441f, -0.54867017f, 0.63793850f, 0.26689032f, 1.35101509f, 1.57934618f, 1.04738271f, 0.39793357f, 
    -0.38359398f, 0.75712979f, 0.15269127f, -0.68715924f, 0.37079388f, -1.21142209f, 0.09385772f, -0.74873370f, 
    0.58893597f, 1.49640417f, 0.45600998f, -0.57818866f, -0.42079231f, -0.72998291f, -0.33895871f, 1.18695986f, 
    -1.03249562f, 0.77671856f, 0.61640269f, -1.35756552f, 0.52688873f, -0.52489775f, -0.15648590f, 0.59242982f, 
    1.15248108f, -1.18381011f, -0.84649187f, 0.18431556f, -1.26566398f, 0.11301915f, 0.41915640f, 0.49334687f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.21299829f, 0.19446172f, 0.36945024f, 0.36457911f, 0.33230102f, 0.49746034f, 0.15917355f, 0.24524766f, 
    0.17410369f, -0.01498939f, 0.09159850f, 0.37248552f, 0.43098640f, -0.10114269f, 0.09124412f, 0.06972870f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.69671571f, -0.29302976f, 0.27803701f, 0.02307530f, 0.16051124f, 0.11068812f, -0.12096426f, -0.19083032f, 
    -0.13970032f, 0.06058979f, -0.03420346f, 0.28119302f, -0.06347632f, -0.07672700f, -0.01981190f, -0.13316347f, 
    0.11283143f, -0.05610736f, -0.13338602f, -0.19085324f, -0.12881835f, -0.71776992f, -0.26191261f, 0.55086672f, 
    -0.35337538f, 0.11291994f, -0.09335673f, 0.05792866f, 0.05243741f, 0.06631817f, -0.03717908f, -0.22378510f, 
    -0.04247053f, -0.02888091f, -0.05954165f, 0.11655391f, 0.03715385f, 0.07904457f, -0.09067727f, -0.08749509f, 
    -0.61672837f, 0.20166002f, 0.18574393f, 0.11624584f, -0.56828350f, -0.05767894f, 0.16530424f, 0.06173443f, 
    0.12500690f, -0.13768552f, 0.09180063f, -0.06975706f, -0.18053411f, -0.03385010f, -0.02435551f, -0.02356945f, 
    0.08492387f, -0.03742104f, 0.20262539f, 0.12277187f, 0.25616795f, -0.32511076f, -0.03972891f, 0.01395321f, 
    0.38758069f, 0.06722682f, -0.16697815f, 0.03963018f, 0.23615654f, -0.07455313f, -0.20913850f, -0.00364068f, 
    0.09369793f, 0.06449124f, -0.20828201f, 0.08812244f, -0.01233898f, -0.16516253f, -0.03592485f, 0.06401930f, 
    0.10528039f, 0.37091136f, -0.04989852f, -0.19888960f, -0.26251602f, 0.09321164f, -0.01743663f, -0.15760845f, 
    0.09065173f, -0.10969307f, -0.00200002f, -0.01424284f, -0.25999337f, 0.13353200f, 0.10356630f, 0.05098753f, 
    -0.00304064f, 0.08362208f, 0.06351436f, -0.12043862f, -0.01625045f, -0.15410051f, -0.21709904f, 0.05235747f, 
    0.36052591f, -0.10196114f, -0.19653714f, 0.00746230f, -0.11209261f, 0.00444410f, -0.09059165f, -0.10767418f, 
    -0.06115618f, -0.05911237f, -0.04946985f, -0.02252669f, 0.01982931f, -0.01868154f, 0.04389228f, -0.08666264f, 
    0.14434686f, -0.23323955f, -0.07891627f, -0.09784514f, -0.60922593f, 0.20294739f, 0.16979748f, 0.11465304f, 
    0.11885762f, -0.12113625f, 0.05222235f, 0.00143253f, 0.09715807f, 0.02458136f, -0.11904240f, 0.20570529f, 
    0.07361634f, 0.06846324f, 0.03101106f, 0.01555200f, 0.25068301f, -0.33005840f, 0.25864634f, 0.00257798f, 
    0.17040420f, -0.15706629f, -0.06585937f, -0.15414189f, 0.20396107f, -0.04145700f, -0.05327184f, -0.00875844f, 
    0.04699722f, -0.02446147f, 0.09378644f, 0.01499742f, 0.01002014f, -0.07484298f, 0.30599195f, -0.02262549f, 
    0.25675690f, 0.06019790f, -0.01682824f, -0.19370298f, 0.19165298f, -0.15199760f, -0.27071863f, -0.08715221f, 
    0.19094080f, -0.00264355f, 0.01186892f, -0.05733305f, -0.01254191f, 0.06095918f, -0.04927035f, 0.07111229f, 
    -0.06774721f, 0.07222980f, 0.08818113f, 0.03187560f, -0.21948469f, 0.09990910f, 0.32890487f, 0.10488225f, 
    0.32588720f, -0.22238782f, -0.22649287f, 0.13946222f, -0.11382627f, 0.10447574f, 0.06007482f, -0.04322930f, 
    0.13759676f, 0.01638466f, 0.06401552f, 0.09608219f, -0.16367933f, -0.03692136f, -0.15368825f, -0.00218372f, 
    -0.36919224f, 0.42432269f, -0.15068454f, -0.10678102f, -0.12994719f, -0.07091507f, 0.11213933f, -0.20228939f, 
    -0.01487005f, 0.02659356f, -0.02041079f, 0.02033291f, 0.04031792f, 0.09054427f, 0.01512088f, -0.00306540f, 
    -0.06848253f, -0.02199724f, -0.08259588f, -0.11017513f, -0.49813569f, -0.48713365f, -0.06193870f, 0.03057903f, 
    -0.51979673f, 0.09394148f, -0.11030446f, 0.13385752f, -0.05331293f, 0.01147586f, -0.14173943f, -0.00522181f, 
    -0.01399467f, -0.17186329f, 0.06510258f, -0.08991651f, -0.01049463f, 0.04975811f, -0.11664120f, 0.15444511f, 
    0.19722188f, 0.14756323f, 0.06735414f, -0.44712749f, 0.12125232f, -0.40385488f, -0.34971663f, -0.05431994f, 
    -0.01002990f, 0.01988585f, 0.02275551f, -0.05362775f, 0.06527983f, -0.03342589f, -0.05907600f, 0.11401187f, 
    0.07757742f, -0.02588302f, -0.14086869f, 0.11487351f, 0.59327155f, 0.44180492f, 0.39659929f, -0.18198632f, 
    -0.19471404f, 0.27390069f, 0.20569393f, -0.15178193f, 0.09247742f, -0.09425147f, 0.01488135f, 0.01031778f, 
    -0.15834686f, 0.00573601f, -0.06784015f, 0.02469521f, 0.27477753f, -0.13176398f, -0.04196803f, 0.00913766f, 
    0.73845154f, -0.29210910f, 0.06895048f, -0.24715458f, 0.32284439f, -0.25332487f, 0.07715774f, 0.19034892f, 
    -0.00374077f, -0.12049893f, 0.09623828f, 0.16683032f, 0.10066983f, 0.15107001f, 0.06281894f, 0.05435019f, 
    -0.08852026f, 0.21148661f, -0.14907677f, -0.27359301f, -0.47568595f, -0.08612635f, 0.12635826f, -0.25415924f, 
    0.30648467f, -0.12444405f, 0.04131501f, -0.10210997f, 0.06282580f, 0.28675243f, 0.06897775f, 0.04493488f, 
    0.00048935f, -0.07487301f, -0.04525629f, -0.21797688f, -0.03030069f, 0.10154826f, -0.06174882f, -0.14494085f, 
    -0.62622887f, -0.30283779f, 0.02214536f, 0.07656930f, -0.01613319f, -0.09187142f, -0.00892197f, 0.03989071f, 
    -0.06383516f, 0.10693656f, -0.01023364f, -0.07887547f, -0.05649238f, -0.06821380f, -0.15928067f, 0.03674694f, 
    0.01344462f, -0.03832618f, -0.12307295f, 0.17200951f, -0.13150948f, -0.12350280f, 0.07695369f, -0.40839294f, 
    -0.19347315f, 0.00247864f, -0.06523474f, 0.12272943f, 0.02225972f, 0.10843530f, -0.02542942f, -0.01074320f, 
    0.07041387f, 0.17400083f, -0.06933632f, -0.26249349f, 0.10960028f, -0.23161452f, -0.31719032f, -0.15796712f, 
    -0.21139242f, 0.28809920f, -0.20712225f, 0.20466770f, -0.41795099f, 0.02697121f, 0.06838986f, -0.03816058f, 
    -0.12006511f, 0.15516074f, 0.01509868f, -0.00274692f, -0.22184749f, -0.02924637f, 0.03467327f, 0.05012288f, 
    0.04493768f, 0.11936353f, 0.06215961f, 0.04803604f, 0.45481589f, -0.28491980f, 0.31694260f, 0.04807797f, 
    -0.12660785f, -0.04051073f, -0.33264154f, -0.04644814f, -0.06633501f, 0.05150703f, 0.25299746f, 0.09672561f, 
    -0.03759860f, -0.00546427f, 0.07523838f, -0.19641124f, 0.02777003f, -0.07762115f, 0.07580818f, -0.07844666f, 
    0.36740714f, 0.09099760f, -0.22618902f, 0.04526039f, 0.07601096f, 0.10503481f, 0.10612426f, 0.01178240f, 
    0.03718958f, 0.06573242f, -0.05029203f, -0.13384174f, 0.05707004f, -0.08107564f, 0.18366687f, 0.22861041f, 
    0.03329665f, -0.01011193f, -0.12193124f, 0.06516347f, -0.30748028f, 0.19527270f, -0.59411383f, -0.61676723f, 
    -0.20272845f, 0.07855637f, 0.29307035f, -0.06270122f, 0.06691802f, 0.06965041f, -0.07089204f, -0.22182956f, 
    0.03673318f, 0.11062209f, -0.06227926f, -0.06565139f, -0.11743367f, 0.03137026f, -0.21061778f, -0.00853380f, 
    0.24761274f, 0.00334492f, -0.22163951f, -0.06604154f, -0.50702125f, 0.07718264f, 0.14035703f, -0.03349854f, 
    -0.14158908f, 0.10780156f, 0.24225739f, 0.01887681f, -0.00593493f, 0.01271944f, -0.00010447f, -0.05570630f, 
    0.07708912f, -0.10369502f, -0.05847762f, 0.03983203f, 0.05042859f, -0.43075797f, 0.14034943f, -0.00271009f, 
    -0.10156678f, 0.13523173f, 0.00565185f, 0.08107163f, 0.08925260f, -0.20405051f, -0.15813784f, -0.01563405f, 
    -0.07096090f, 0.18035309f, -0.03537073f, 0.01990665f, -0.28152356f, -0.06718818f, -0.11578892f, -0.16306792f, 
    0.06410083f, 0.11355580f, 0.22364417f, 0.01658192f, 0.05441393f, -0.14007115f, -0.11850253f, -0.00451761f, 
    0.03491905f, -0.04256853f, -0.04955868f, -0.02138664f, 0.03354827f, 0.10206826f, -0.10630541f, -0.01233796f, 
    0.15284947f, -0.09053910f, -0.09183520f, -0.02503641f, -0.18068504f, 0.08089120f, -0.26605785f, -0.10492904f, 
    0.13140512f, 0.02241940f, 0.24508758f, -0.00547432f, -0.29791000f, 0.08178064f, -0.05765944f, 0.07484769f, 
    0.14006296f, -0.07917641f, -0.01567540f, 0.09007435f, -0.19487737f, 0.09414906f, 0.08617949f, 0.19445956f, 
    0.54343730f, -0.75402474f, -0.01495176f, 0.13128194f, 0.05407661f, -0.24167214f, 0.03437608f, -0.03311383f, 
    0.06574748f, 0.01870732f, 0.08693034f, 0.08572951f, -0.09178896f, 0.11918259f, -0.10103893f, 0.13266508f, 
    -0.14389019f, 0.06899296f, -0.06382146f, 0.04228794f, 0.33430371f, -0.17618282f, -0.06131947f, -0.03351172f, 
    -0.22515014f, 0.02911932f, 0.02520365f, 0.06644633f, 0.27991807f, 0.28070259f, -0.15245287f, -0.09210379f, 
    0.17025113f, 0.14942199f, -0.06411406f, 0.08051702f, 0.07927897f, -0.09674597f, -0.06459659f, 0.03470365f, 
    0.39292875f, 0.24953374f, 0.28387994f, 0.36904675f, 0.69387728f, -0.09483157f, -0.12645677f, 0.17586176f, 
    0.06072547f, 0.11964030f, -0.19965927f, 0.02388643f, -0.01443902f, 0.23245518f, -0.08876935f, 0.04014682f, 
    0.01896048f, 0.13920279f, -0.00475223f, 0.00899988f, -0.48639932f, -0.06608839f, -0.29682493f, -0.06178587f, 
    -0.07257123f, -0.01387434f, -0.04294941f, -0.19004907f, -0.14030468f, 0.03428382f, 0.23086749f, 0.24825008f, 
    -0.11421610f, -0.09242334f, 0.11562758f, -0.03772557f, -0.07463869f, 0.02103324f, -0.05312910f, 0.06776129f, 
    -0.40232316f, -0.31931773f, -0.18640025f, -0.20947944f, 0.17454657f, 0.05616527f, -0.14648281f, -0.20229274f, 
    -0.07699782f, -0.02813984f, -0.02177882f, -0.00080341f, -0.02721773f, -0.15976392f, 0.03662936f, -0.12618834f, 
    0.00955520f, -0.18865766f, 0.24062930f, -0.07837792f, 0.52854460f, -0.26034385f, -0.00301411f, -0.43631396f, 
    0.04124089f, -0.10765553f, -0.12807140f, 0.14456403f, 0.07352483f, 0.08735207f, -0.07350596f, 0.03782443f, 
    0.15032382f, 0.14504404f, 0.28755760f, 0.06840734f, -0.22400716f, -0.07980470f, -0.08840038f, 0.01774211f, 
    0.54773855f, -0.10909007f, -0.14888741f, -0.18942724f, -0.26452625f, 0.06294847f, -0.08176629f, -0.13560709f, 
    0.16915327f, 0.02440662f, -0.05498498f, 0.02112311f, 0.02418449f, -0.10642074f, 0.11039506f, 0.10043588f, 
    0.00655181f, 0.11584812f, 0.15797570f, -0.16358127f, -0.39160460f, -0.56521064f, -0.45975599f, -0.14785378f, 
    -0.74563271f, -0.15185277f, 0.04507652f, -0.02156973f, -0.10314640f, -0.29780838f, 0.02089312f, 0.11914769f, 
    0.08261429f, -0.02426862f, -0.10654800f, -0.13417639f, -0.08380522f, 0.09951222f, 0.06303252f, -0.22481227f, 
    0.14467953f, -0.18693009f, -0.05526504f, -0.12058798f, 0.02554745f, -0.27087629f, -0.10182204f, 0.06809980f, 
    0.09466868f, -0.06288888f, 0.09202351f, 0.00102558f, 0.03896331f, -0.17496543f, 0.17175345f, -0.02429695f, 
    -0.17350814f, -0.17743960f, 0.09914123f, -0.06603830f, -0.35980928f, -0.04394867f, 0.01782314f, -0.19133484f, 
    -0.10885676f, -0.03891009f, -0.12343350f, 0.18159388f, 0.14284882f, 0.23625520f, -0.24608515f, 0.06063748f, 
    -0.00491141f, 0.11777087f, -0.11397050f, -0.05287286f, -0.08834346f, 0.13124508f, 0.11514628f, 0.05883291f, 
    0.30979243f, 0.10452067f, 0.24777833f, 0.01771574f, 0.06934913f, -0.22103351f, -0.10038681f, -0.23630378f, 
    0.04927058f, 0.09019488f, 0.09318757f, -0.14402282f, -0.03824466f, -0.01514704f, -0.16956304f, 0.00270539f, 
    -0.13000338f, 0.02171952f, 0.04397846f, 0.13436225f, 0.24854293f, -0.09440286f, -0.89672190f, -0.32002422f, 
    -0.24283044f, 0.16701946f, 0.18037590f, 0.08429738f, -0.08570156f, -0.13794956f, -0.09022427f, -0.06003989f, 
    -0.08336218f, -0.04210132f, 0.05245248f, -0.05342054f, 0.09275088f, 0.06658919f, -0.04229615f, -0.01104174f, 
    -0.16472940f, -0.08073299f, 0.33508769f, 0.31107861f, 0.34763879f, -0.24149169f, -0.07547968f, -0.32603776f, 
    0.09547625f, 0.09570403f, -0.07823449f, -0.15919760f, -0.11572812f, 0.08388565f, 0.20021744f, -0.05554213f, 
    0.05324385f, -0.13272440f, 0.13214633f, 0.05452561f, -0.22188528f, -0.01361659f, 0.01095322f, -0.27453259f, 
    -0.22307009f, 0.01993046f, 0.16185981f, 0.18075907f, -0.07178161f, 0.07053066f, 0.08129935f, 0.08749583f, 
    -0.02204908f, -0.19573766f, -0.07537554f, 0.03437041f, 0.12965126f, 0.14803991f, 0.06416274f, -0.11090782f, 
    -0.21410014f, 0.13214205f, 0.03869729f, -0.16651249f, 0.10543208f, 0.04409318f, 0.15519984f, 0.22496301f, 
    -0.09307871f, -0.22656411f, -0.11226840f, 0.01696144f, -0.07451748f, -0.20112731f, 0.00000837f, 0.09266855f, 
    -0.01769905f, 0.00475811f, -0.07833577f, -0.06932151f, 0.56331372f, 0.16468395f, -0.37397128f, -0.04465974f, 
    0.02209796f, -0.18012708f, 0.17316811f, 0.15513447f, -0.00594002f, -0.14653797f, -0.15476502f, 0.07103313f, 
    0.12547708f, 0.10835620f, -0.00837857f, -0.04130877f, 0.04927788f, -0.18010932f, -0.04031950f, -0.01216720f, 
    0.75060076f, 0.10090090f, 0.07460542f, 0.30321133f, -0.25829348f, -0.03141646f, -0.26337734f, 0.10826936f, 
    0.05740532f, 0.17381991f, 0.04488162f, 0.00904101f, 0.14936776f, 0.13988930f, 0.02469967f, 0.07945963f, 
    -0.11530185f, -0.08917089f, -0.03833108f, 0.00440947f, 0.34586141f, -0.63023120f, 0.13932331f, -0.15716499f, 
    0.19306903f, -0.31560871f, -0.01131554f, -0.24435717f, 0.11797436f, -0.00043574f, 0.04156990f, -0.11240648f, 
    -0.08503107f, 0.07447789f, 0.02088805f, -0.04148126f, 0.10929789f, 0.07679337f, -0.09125695f, -0.03527111f, 
    -0.22469416f, 0.11926109f, 0.04014337f, -0.13513589f, 0.06435827f, 0.14457059f, 0.10775053f, 0.16118026f, 
    0.04325540f, -0.16445871f, -0.00878018f, 0.02119616f, 0.07320087f, 0.04184670f, -0.08869982f, -0.15333320f, 
    -0.00940070f, -0.00959137f, -0.38000286f, 0.01617912f, 0.52213603f, -0.05588900f, 0.11502536f, 0.10360376f, 
    0.27050850f, -0.12097020f, -0.10113510f, -0.05617246f, 0.11809181f, 0.24150451f, 0.04158989f, -0.06506374f, 
    0.00909675f, 0.07506739f, 0.00029745f, -0.07581365f, -0.16000804f, -0.01153337f, -0.15124874f, -0.22167772f, 
    0.24769425f, -0.31134093f, 0.12069778f, -0.40126240f, -0.12425020f, 0.20312510f, -0.09885190f, 0.08883728f, 
    -0.03930573f, 0.15437216f, -0.18708390f, -0.16484576f, -0.11351899f, 0.05157026f, 0.00240712f, -0.00041976f, 
    -0.37604034f, -0.00071739f, -0.01158712f, -0.07074096f, 0.07096519f, 0.10175457f, -0.11577339f, -0.61322427f, 
    -0.34580484f, 0.27497071f, 0.16654326f, 0.10437197f, -0.20995268f, 0.01868703f, -0.03524690f, -0.05333526f, 
    0.00769057f, -0.26793569f, -0.05719577f, -0.05759672f, -0.02429220f, 0.26457638f, -0.02688023f, -0.10472324f, 
    0.27535623f, 0.22321387f, 0.20161827f, 0.04285265f, 0.00136842f, 0.22398540f, 0.05304017f, -0.00960905f, 
    0.02682332f, 0.09147316f, -0.07581782f, 0.11320452f, -0.19523878f, -0.03585666f, -0.15918322f, -0.06683733f, 
    -0.02410017f, -0.09779156f, -0.15081020f, 0.00070913f, 0.12625387f, 0.27906540f, 0.20954385f, 0.25426275f, 
    0.02010240f, -0.10077885f, -0.12751815f, -0.01987375f, -0.07641232f, -0.04411756f, -0.12300324f, -0.03763490f, 
    -0.01388818f, -0.06412533f, 0.00580431f, 0.04833344f, 0.07093103f, 0.23360620f, 0.13929760f, 0.01258267f, 
    0.36879754f, -0.25780743f, 0.21584885f, -0.29754260f, -0.18947382f, -0.16369234f, -0.22242790f, -0.13805115f, 
    -0.06147243f, -0.11087642f, -0.05181719f, -0.05266160f, 0.11778551f, 0.00539663f, 0.02425211f, -0.11374810f, 
    0.09606042f, -0.07855708f, 0.04509661f, 0.01240466f, 0.01941005f, -0.32496050f, -0.00979596f, -0.10087546f, 
    -0.06957427f, -0.10061492f, 0.08774210f, -0.00586473f, 0.11336412f, -0.00045419f, -0.05564084f, -0.07351324f, 
    -0.06437850f, 0.04539594f, -0.13615063f, 0.01611756f, 0.02285652f, -0.13149273f, -0.07717599f, 0.02947522f, 
    -0.34864515f, 0.20308100f, -0.07722202f, -0.13612752f, -0.20706579f, -0.08523698f, -0.16787280f, -0.03574806f, 
    -0.06324192f, 0.00935251f, 0.00424353f, 0.05249849f, -0.14365798f, -0.04568675f, 0.04502407f, 0.12166191f, 
    0.01903716f, -0.09894370f, 0.15851830f, 0.03822141f, -0.33789492f, 0.54023612f, 0.16428334f, -0.03587848f, 
    0.30731541f, 0.00936118f, 0.14952627f, -0.16201483f, 0.06141071f, -0.00528121f, -0.08268195f, -0.04618057f, 
    -0.05697566f, -0.02500729f, -0.26852351f, -0.10825302f, 0.07418153f, -0.03874956f, 0.13934024f, -0.00288022f, 
    0.05249403f, 0.03613007f, -0.31834352f, -0.07346774f, -0.04192548f, -0.06097802f, -0.07800537f, -0.00866561f, 
    0.10074744f, 0.02171528f, 0.06223121f, -0.03537500f, 0.13495319f, -0.13078339f, 0.11869209f, -0.09187262f, 
    0.01481916f, 0.09933333f, -0.02662717f, -0.00282240f, 0.31812304f, 0.05286701f, 0.21919799f, 0.19218460f, 
    0.29698601f, 0.05224046f, 0.08027612f, -0.14808445f, 0.02622747f, -0.06477205f, 0.21978229f, 0.00875881f, 
    -0.09425780f, -0.07254902f, -0.06589816f, 0.00388486f, -0.04015618f, 0.12175270f, 0.09894058f, 0.05152085f, 
    -0.34605923f, -0.74955368f, -0.57706505f, 0.35869172f, 0.29602182f, -0.06571993f, -0.04432674f, 0.17489541f, 
    0.00662332f, -0.12193945f, -0.10523570f, 0.01491815f, -0.15268524f, -0.30125830f, 0.07599153f, -0.04629944f, 
    -0.16126904f, 0.14245398f, 0.04255082f, -0.17010640f, -0.03887533f, -0.00556651f, -0.17208493f, -0.29945448f, 
    -0.12701294f, 0.00803800f, -0.09154342f, 0.05646360f, 0.20437112f, -0.06354967f, 0.12561405f, 0.10139666f, 
    0.00785287f, 0.07033736f, -0.12208109f, -0.11979278f, 0.02512596f, -0.15539785f, 0.04795827f, 0.02967104f, 
    -0.01615529f, -0.42600238f, 0.02450114f, 0.05968940f, -0.17687468f, -0.06786051f, -0.20807637f, 0.16962025f, 
    -0.01431369f, -0.03912749f, -0.12893510f, 0.02203959f, -0.05346151f, 0.08213860f, 0.09287946f, 0.02987074f, 
    0.02562817f, -0.01890616f, -0.10914348f, 0.10330995f, 0.18828537f, 0.18345708f, -0.17508005f, 0.12396345f, 
    -0.09728876f, -0.14111505f, -0.03894074f, -0.09837668f, -0.00678353f, -0.00629665f, -0.01473931f, 0.01969742f, 
    0.03230728f, 0.00298392f, 0.04188813f, 0.02290242f, -0.12834881f, 0.14757466f, -0.06249120f, -0.07098288f, 
    -0.38067752f, -1.15575278f, -0.73002565f, -0.08543690f, 0.05423459f, -0.18748917f, 0.04208468f, -0.01591306f, 
    0.00207261f, -0.10916077f, 0.09935447f, -0.03777767f, 0.00791520f, 0.09637181f, -0.01148357f, 0.04255951f, 
    0.06727371f, -0.08718653f, 0.06542660f, -0.05968189f, -0.70666295f, 0.21087156f, 0.17799874f, -0.15221015f, 
    -0.16383608f, -0.20326748f, -0.16701247f, 0.12766728f, 0.09792329f, 0.03526253f, -0.14477238f, -0.08223039f, 
    0.00191024f, 0.02544987f, 0.04035377f, 0.10510720f, 0.09807508f, -0.00583119f, 0.24183851f, 0.08510047f, 
    0.74457818f, 0.28819266f, -0.19791839f, 0.04731134f, 0.13714118f, 0.07507301f, 0.03824472f, 0.05345702f, 
    0.10169452f, 0.04729952f, -0.17488134f, -0.10176571f, -0.15164524f, 0.15872350f, 0.03213638f, -0.07413771f, 
    0.11189089f, 0.03490013f, 0.05709493f, 0.13895175f, 0.26638812f, 0.03308189f, 0.06817308f, -0.03480547f, 
    0.22924647f, -0.07539727f, 0.15885212f, 0.02086477f, -0.13285279f, 0.04999018f, -0.01616514f, -0.05876695f, 
    -0.00775186f, -0.04556533f, -0.07351571f, 0.12343740f, -0.00659405f, 0.18478404f, 0.13446619f, 0.15868123f, 
    -0.29956815f, 0.36362332f, 0.20453134f, -0.45270237f, -0.11374692f, -0.02702430f, 0.13071021f, -0.19232433f, 
    -0.02025246f, -0.16189192f, 0.10566331f, -0.11106560f, -0.04211784f, 0.03789126f, 0.14982216f, -0.10472904f, 
    0.00960396f, -0.09061093f, -0.07228456f, -0.00156803f, 0.07630444f, -0.06353577f, -0.15196934f, 0.08375204f, 
    0.15889500f, 0.05221006f, 0.08111072f, -0.01359565f, 0.17843677f, 0.08478229f, 0.10625391f, 0.07085132f, 
    0.02109605f, -0.06960538f, 0.11258122f, -0.16973606f, -0.05013066f, -0.03200978f, 0.29085627f, 0.08492304f, 
    -0.21170002f, 0.15883359f, -0.10761014f, -0.35416865f, 0.25066954f, -0.02763938f, 0.06568225f, 0.05907005f, 
    0.26279828f, -0.05684343f, -0.03388594f, -0.08145279f, 0.08452685f, 0.00790812f, -0.03708642f, -0.00868763f, 
    0.07332331f, -0.25953341f, 0.06404825f, -0.04456452f, 0.49538031f, 0.20629890f, -0.20538178f, -0.14280523f, 
    -0.50421625f, -0.08993625f, 0.05755971f, -0.12673073f, -0.04163718f, -0.04770816f, 0.00018109f, 0.05183269f, 
    0.21018521f, 0.05754086f, 0.00090155f, -0.09359562f, 0.09355304f, -0.01210106f, -0.01768247f, -0.01676872f, 
    -0.39158610f, -0.03010416f, 0.03842821f, -0.04948604f, 0.19769207f, 0.12959686f, -0.01358298f, 0.07597961f, 
    -0.04485022f, 0.08579694f, 0.13318925f, 0.02604520f, -0.13370414f, 0.09444961f, -0.03533028f, 0.09783559f, 
    -0.01942843f, 0.03201266f, 0.13470149f, -0.18429498f, -0.11502945f, 0.23571807f, 0.22380044f, 0.25926113f, 
    -0.12855557f, 0.00429158f, -0.15641470f, 0.22830559f, -0.12578323f, 0.00755122f, 0.06305100f, -0.00411915f, 
    -0.19653249f, 0.04612005f, 0.05050392f, 0.00456247f, -0.01296558f, -0.02438945f, -0.05126759f, -0.11072939f, 
    -0.86413205f, -0.15256429f, -0.33876887f, 0.19768643f, 0.23469476f, 0.07078610f, -0.06151163f, 0.10925271f, 
    0.02266093f, 0.02908266f, 0.14574645f, -0.06970820f, 0.03155203f, -0.04363387f, 0.04577697f, 0.12518975f, 
    0.02467763f, 0.05870892f, 0.09589056f, 0.20101947f, -0.05916288f, -0.29149324f, -0.11697778f, 0.37110868f, 
    -0.31761670f, -0.31323248f, -0.00141848f, -0.06419068f, -0.23144931f, 0.02461149f, -0.00590205f, 0.09992356f, 
    0.03045884f, -0.07304350f, -0.07668517f, -0.07081234f, 0.07544331f, 0.19831380f, -0.02265226f, 0.17243801f, 
    -0.55655843f, -0.72905648f, 0.24616170f, 0.30603036f, 0.14562795f, -0.17789035f, -0.02541552f, -0.15960383f, 
    -0.03768881f, 0.09079704f, 0.21726356f, -0.11618595f, 0.02589904f, -0.04501842f, 0.12073815f, -0.02684217f, 
    -0.14364204f, 0.03619337f, -0.02685389f, 0.00913193f, 0.66948026f, 0.53110647f, -0.44873297f, -0.31163856f, 
    -0.07195578f, -0.14095706f, -0.05283045f, 0.04318316f, 0.21113405f, 0.06615305f, -0.08842664f, 0.04613448f, 
    -0.05187154f, -0.06711502f, -0.05269069f, -0.02463472f, 0.03798373f, -0.08840020f, -0.09168128f, -0.02375144f, 
    -0.44922984f, 0.37766692f, 0.05404729f, -0.09234100f, 0.15008990f, 0.04132895f, 0.01562541f, -0.01260389f, 
    0.00968556f, 0.06320678f, 0.05188159f, -0.08073589f, 0.09012034f, -0.02911980f, -0.01253238f, 0.06522059f, 
    0.08183700f, 0.07198533f, 0.14123586f, -0.23212057f, -0.35945946f, 0.43218669f, 0.09284271f, 0.10661590f, 
    -0.05570689f, 0.12443405f, -0.02116936f, -0.08198950f, 0.25508747f, -0.03028805f, -0.02163227f, 0.19120704f, 
    -0.06943453f, 0.10353204f, 0.00583013f, 0.05187098f, -0.15489990f, -0.07722653f, 0.04693802f, 0.00394858f, 
    -0.01359457f, -0.25473198f, 0.16974360f, 0.04424178f, 0.04491967f, 0.03352715f, 0.00875710f, -0.25577268f, 
    0.04872804f, 0.14470078f, 0.00396334f, -0.00372990f, 0.04942601f, -0.09606215f, -0.07806851f, 0.04619147f, 
    -0.09223073f, -0.22759971f, 0.10913273f, 0.06501362f, -0.18095170f, -0.12033632f, -0.04400405f, 0.05112539f, 
    0.26582730f, 0.16462179f, -0.10673396f, 0.09819331f, -0.01858903f, 0.06407329f, -0.17621149f, -0.08300351f, 
    0.20661542f, 0.18994181f, 0.07037418f, -0.03573715f, 0.11491980f, 0.11222526f, 0.17701060f, -0.17336850f, 
    -0.46484286f, -0.04736004f, -0.05589208f, -0.16495888f, -0.22546850f, 0.02202542f, 0.06412852f, 0.08063681f, 
    -0.17401631f, 0.09747677f, -0.02995916f, 0.08215109f, 0.06929427f, -0.05869571f, -0.00871913f, -0.11596312f, 
    0.21497306f, -0.07983028f, -0.20109987f, 0.10651942f, -0.09599570f, -0.23093230f, 0.07500631f, 0.07959987f, 
    -0.13002253f, -0.02662875f, 0.00169641f, 0.00924101f, -0.20819142f, -0.27324876f, -0.00584847f, -0.08515730f, 
    -0.05529421f, -0.12364562f, 0.03654414f, -0.16141862f, 0.03438624f, -0.18167579f, -0.00798864f, -0.11464370f, 
    -0.05679772f, -0.24284092f, -0.18188314f, 0.08654491f, -0.07046077f, -0.12041795f, 0.09121179f, -0.11219066f, 
    0.05678070f, 0.06353612f, -0.19722128f, 0.12610459f, 0.13721476f, 0.10075941f, 0.11133792f, -0.03139256f, 
    0.12439394f, -0.07735012f, 0.21490288f, -0.07502808f, -0.11799125f, 0.04553077f, -0.10472696f, -0.07919991f, 
    0.20694031f, 0.24278452f, -0.02685888f, 0.03311155f, 0.08382723f, 0.23654573f, 0.03099464f, 0.07969899f, 
    0.12731473f, -0.00259110f, 0.14415076f, -0.06440618f, -0.04106204f, 0.03435876f, -0.35545808f, -0.02011244f, 
    -0.47240895f, 0.25874713f, -0.11014357f, -0.00297536f, -0.29288694f, 0.18124075f, -0.11268715f, 0.04331214f, 
    -0.16741166f, -0.00579946f, -0.02134064f, -0.00328408f, 0.05502263f, -0.03136163f, -0.13872327f, 0.05629717f, 
    -0.09031917f, 0.19721743f, -0.00726692f, -0.02719653f, 0.20138223f, 0.21348514f, 0.12590052f, 0.11475358f, 
    0.34790316f, -0.02772084f, -0.03139563f, 0.05168263f, -0.01401301f, 0.10738878f, 0.10961013f, -0.06198517f, 
    -0.09468841f, -0.09975920f, 0.01873975f, 0.21487555f, -0.16691975f, 0.06129650f, -0.01594564f, 0.04573178f, 
    -0.96827900f, -0.13730085f, -0.14685290f, -0.31122598f, 0.00733914f, 0.10452963f, 0.03070678f, 0.24942385f, 
    0.05367445f, -0.12823750f, 0.19325486f, 0.17015594f, 0.25460607f, 0.00368957f, -0.00002213f, 0.11857242f, 
    -0.02094498f, -0.02124091f, -0.07854459f, 0.16058974f, 0.22182374f, -0.08363742f, 0.03509662f, 0.42445830f, 
    -0.22442855f, -0.15986960f, -0.09208013f, -0.07177853f, 0.14150205f, 0.11858031f, 0.07087864f, 0.11263504f, 
    0.10923576f, 0.09087031f, 0.18702938f, -0.14910690f, -0.25245881f, 0.00023074f, -0.16181985f, -0.25810829f, 
    -0.45824525f, 0.16871104f, -0.40295634f, -0.11110438f, -0.07264757f, 0.14350373f, 0.11622684f, 0.04227319f, 
    -0.07648182f, -0.03683537f, 0.00424991f, 0.08570546f, -0.00619727f, -0.17143169f, 0.02237719f, 0.08636744f, 
    0.08304638f, -0.22933544f, 0.01151041f, -0.05546305f, -0.11458565f, -0.04644900f, -0.09126214f, 0.00542328f, 
    0.12777816f, -0.14090303f, -0.22620915f, -0.01417269f, 0.03503926f, 0.03890971f, -0.09433169f, -0.15468298f, 
    0.06990551f, 0.12977707f, 0.11074951f, 0.02264071f, 0.01818474f, -0.25173604f, -0.13899976f, -0.06793431f, 
    0.18597406f, 0.15878341f, -0.01982385f, 0.22580004f, 0.11049353f, -0.16925752f, 0.00511444f, 0.08837075f, 
    0.08502439f, 0.08426660f, -0.11822768f, -0.10014849f, -0.00494183f, 0.12195900f, 0.26792902f, -0.04126061f, 
    0.16617574f, 0.08224452f, -0.03679759f, -0.03920747f, -0.69351351f, -0.35544765f, 0.45446989f, 0.33363155f, 
    -0.39857996f, 0.12191637f, -0.17157924f, -0.06903706f, -0.11742385f, -0.09504566f, 0.03621180f, -0.02710224f, 
    -0.05809321f, -0.03133376f, 0.09266274f, -0.15117942f, 0.08074525f, 0.22375943f, 0.05340831f, -0.03060615f, 
    -0.52560586f, -0.06398164f, -0.15616916f, -0.17521630f, -0.09235989f, 0.08882720f, -0.01801268f, -0.05404432f, 
    -0.03903731f, -0.21281739f, -0.00791589f, -0.00343064f, -0.17949958f, -0.07453045f, -0.11073247f, -0.08098838f, 
    0.01844253f, 0.08427127f, 0.08689648f, 0.07036269f, -0.73900819f, -0.17317344f, -0.45176232f, -0.04685172f, 
    0.07730452f, 0.14109221f, 0.21209933f, 0.03608663f, -0.04468214f, 0.01112834f, -0.00822485f, 0.04423304f, 
    0.07068075f, -0.11016164f, 0.01349760f, -0.20352070f, 0.14698356f, -0.10120660f, 0.00333873f, -0.21601826f, 
    0.26190120f, 0.14408477f, 0.13686413f, 0.13071720f, -0.24910311f, 0.08214162f, 0.03384700f, 0.03755218f, 
    -0.13539246f, 0.04517132f, 0.06656368f, 0.06475336f, 0.00640041f, -0.06478257f, 0.09014346f, 0.09821285f, 
    -0.16144204f, 0.09786638f, 0.13633765f, 0.01136429f, 0.01737260f, 0.44184461f, -0.03018113f, -0.24785154f, 
    -0.04153023f, 0.07309239f, 0.10685951f, 0.16536716f, -0.09640543f, -0.09824472f, 0.20287140f, -0.13616145f, 
    -0.18730892f, -0.15618721f, 0.04030549f, 0.00489955f, -0.12203091f, 0.01905414f, 0.05048872f, 0.03289397f, 
    -0.21511829f, 0.02091990f, 0.23585808f, 0.00878999f, -0.05662858f, -0.04363272f, -0.11636993f, 0.16210787f, 
    0.00506905f, 0.10346557f, 0.03018353f, -0.03058073f, 0.11767146f, -0.22677521f, -0.19612823f, -0.05235519f, 
    0.00552038f, -0.19880903f, 0.05705316f, 0.09796844f, -0.09252869f, -0.12864150f, 0.26340383f, 0.54195148f, 
    0.05014415f, -0.23349111f, -0.08036066f, 0.04339055f, -0.05726292f, 0.14250933f, 0.18339501f, -0.18399654f, 
    -0.02176907f, 0.15177971f, -0.08944396f, 0.11529297f, -0.03781176f, -0.55061024f, -0.05424627f, 0.07918508f, 
    0.38453090f, -0.19614853f, 0.05143951f, 0.17266953f, 0.20146085f, 0.15475847f, 0.00266674f, 0.02596646f, 
    -0.07149193f, -0.30361795f, 0.11955192f, -0.04649823f, -0.00239526f, 0.00021737f, -0.21605383f, -0.03775695f, 
    -0.07749777f, 0.07251659f, -0.09100106f, -0.14557213f, -0.26672816f, 0.22544286f, -0.32312748f, -0.74462587f, 
    0.18548238f, 0.03506963f, -0.06475855f, -0.01994535f, -0.12596676f, -0.00690823f, -0.09372482f, 0.01310254f, 
    -0.11725516f, -0.17101571f, -0.03505879f, 0.04006269f, -0.12778656f, 0.05020078f, 0.27119160f, 0.17781545f, 
    0.16889636f, -0.93989515f, -0.04745353f, 0.12466816f, 0.01274442f, -0.00147218f, -0.05455325f, 0.02077043f, 
    0.01129607f, 0.07049248f, -0.06772779f, -0.00670442f, 0.06974177f, 0.04179912f, 0.15876329f, -0.03290185f, 
    0.05621446f, -0.01320672f, -0.03399400f, -0.06006957f, -0.23469932f, -0.13117054f, -0.01323238f, 0.07508349f, 
    0.25849026f, -0.07387296f, 0.30729377f, -0.13087475f, 0.03311589f, 0.10505318f, -0.16157973f, 0.00675473f, 
    0.18050009f, -0.01610778f, -0.11265114f, 0.09832397f, 0.06944617f, -0.00178302f, 0.03900047f, 0.00486221f, 
    -0.45651850f, -0.20363046f, -0.11074995f, 0.13701528f, 0.12876184f, -0.14589025f, 0.01515090f, 0.05001211f, 
    -0.12606791f, 0.01832472f, -0.02509112f, -0.05674192f, -0.02812229f, 0.05613130f, 0.06172940f, -0.19777229f, 
    -0.08868351f, 0.03447654f, -0.00066661f, -0.13753553f, -0.02669671f, -0.18411142f, 0.16434734f, -0.19124673f, 
    0.11916873f, 0.15897286f, -0.18813311f, 0.11682966f, -0.03375261f, -0.16357379f, -0.14491864f, 0.14345904f, 
    -0.17913218f, -0.03049246f, -0.06505758f, 0.04569747f, 0.04884981f, 0.10721914f, 0.34437901f, 0.15220572f, 
    -0.10970195f, -0.28779006f, -0.07638442f, -0.75500983f, 0.22124861f, -0.29235873f, 0.03152415f, 0.05429348f, 
    0.06846857f, 0.02471737f, -0.16492648f, 0.10143544f, -0.01479798f, 0.15652855f, 0.09233277f, -0.07982534f, 
    -0.01683194f, 0.06609386f, -0.06074572f, -0.02279136f, 0.31235099f, 0.14556095f, -0.06294201f, -0.16696489f, 
    -0.25541750f, 0.05497828f, 0.11097432f, 0.07152829f, -0.01598968f, 0.16013087f, 0.00686435f, -0.12252855f, 
    0.02966698f, 0.06513818f, -0.12303492f, -0.01731858f, 0.11519889f, 0.10395642f, 0.10186799f, 0.09091707f, 
    -0.37742531f, 0.47282383f, 0.08108608f, 0.17022690f, -0.48990825f, -0.05453745f, -0.00776580f, -0.04086128f, 
    -0.01935651f, -0.02558827f, 0.03114476f, 0.06732364f, -0.10786574f, -0.01503425f, -0.22985862f, 0.00813658f, 
    -0.01466548f, -0.08174317f, -0.04280101f, -0.02305823f, 0.34367740f, -0.13966765f, -0.12708969f, 0.12268943f, 
    0.15983880f, -0.17645374f, -0.22575402f, 0.04622018f, 0.21958867f, 0.13243037f, 0.07207404f, -0.04153765f, 
    -0.00954010f, -0.06948819f, 0.00144977f, -0.07331735f, -0.03179790f, -0.03685934f, -0.16468459f, -0.15279123f, 
    0.15743017f, -0.31335613f, -0.06513850f, -0.14514023f, 0.31955215f, 0.17625368f, -0.14782891f, 0.06308400f, 
    0.07817490f, -0.02640810f, -0.01797513f, -0.03499950f, 0.13581911f, 0.08914453f, 0.01897433f, -0.00620695f, 
    0.06546082f, -0.12139004f, 0.02976282f, 0.18280518f, 0.26301476f, 0.05944546f, -0.00385075f, -0.71411121f, 
    0.26930663f, -0.17266299f, -0.01138315f, -0.00370631f, -0.19434930f, -0.13470876f, 0.13283950f, -0.03649023f, 
    0.01805239f, -0.00863438f, 0.09376712f, 0.07287397f, -0.08870848f, 0.03108782f, 0.12667286f, 0.11543408f, 
    -0.64043981f, 0.58784604f, 0.00750900f, 0.31934637f, -0.54099202f, -0.01423158f, -0.09583510f, 0.04413643f, 
    0.09900144f, -0.00620966f, -0.00580288f, 0.03233187f, 0.01203796f, 0.02050893f, 0.17275159f, -0.12611473f, 
    0.08314788f, -0.16806868f, -0.00344250f, -0.14018127f, 0.23427276f, -0.63222438f, -0.08961947f, -0.02165513f, 
    -0.10842678f, -0.05892115f, -0.00496246f, -0.00675939f, -0.03744612f, -0.02745037f, -0.05887701f, -0.01918129f, 
    0.11410294f, 0.10827957f, 0.13271075f, 0.08478279f, -0.06996858f, 0.03048958f, -0.22627567f, 0.03992520f, 
    -0.03266093f, -0.02298643f, -0.12274459f, 0.45767161f, 0.21138823f, -0.05961629f, 0.12954240f, -0.00909670f, 
    0.12054736f, -0.13739815f, -0.13565291f, 0.04630183f, -0.08780917f, -0.05087908f, 0.17858824f, 0.03872719f, 
    0.05352936f, 0.29690331f, -0.20481767f, 0.06712816f, -0.37465695f, 0.16027954f, -0.05869386f, 0.29245618f, 
    -0.12696381f, 0.31081665f, 0.09034877f, 0.01782236f, 0.05604767f, -0.01270315f, -0.24951565f, 0.03131068f, 
    -0.15369746f, 0.08813007f, -0.22878651f, 0.08989026f, 0.04576394f, 0.25125119f, 0.00359472f, -0.04635018f, 
    0.04189415f, -0.09323537f, 0.06271631f, 0.06703900f, -0.09777622f, 0.08690275f, -0.09494850f, -0.00624680f, 
    0.02092061f, 0.03185945f, -0.04654615f, 0.09934430f, 0.05794208f, -0.16058947f, 0.00351596f, -0.00617008f, 
    0.03609164f, 0.11909998f, 0.12809117f, 0.11413922f, 0.09185649f, 0.18092823f, 0.24799636f, 0.21439105f, 
    0.27767268f, 0.11224973f, 0.13056922f, -0.14576222f, -0.14430480f, -0.08316267f, -0.10621554f, -0.08899419f, 
    -0.12700164f, -0.08846552f, -0.00182356f, -0.07753442f, -0.06132916f, -0.00415603f, 0.17438816f, 0.07143278f, 
    0.05580526f, -0.35004577f, 0.01019964f, 0.13509355f, 0.43933603f, 0.11297631f, 0.14172179f, -0.11635481f, 
    0.18506889f, -0.04683256f, 0.01000097f, -0.09029072f, 0.01985418f, -0.02253482f, -0.17510396f, -0.13621432f, 
    -0.01025989f, -0.05886221f, -0.05489264f, -0.06768542f, -0.14738008f, 0.26126593f, -0.20707175f, -0.18093731f, 
    -0.21054785f, 0.00680115f, 0.09863111f, -0.05753357f, -0.15709187f, 0.03903653f, -0.13429542f, -0.08868828f, 
    -0.00406194f, -0.13199988f, 0.00809437f, 0.01990849f, 0.07356562f, -0.01942310f, -0.04687076f, -0.01582633f, 
    0.09419207f, -0.27984571f, 0.33440891f, -0.08001282f, -0.12431888f, 0.08125254f, -0.04048560f, 0.07732181f, 
    -0.10462392f, -0.05715892f, -0.00603973f, 0.10353684f, 0.01737653f, 0.14749992f, -0.19654286f, -0.01050595f, 
    0.02842702f, 0.08222419f, 0.01347714f, -0.10793890f, 0.26046535f, -0.57911104f, 0.28698435f, 0.12051401f, 
    -0.05020023f, 0.18761976f, -0.03496905f, -0.09919856f, -0.15168770f, 0.05115023f, -0.17868307f, -0.12098582f, 
    -0.13942678f, -0.02432145f, -0.17004247f, -0.09624568f, 0.06271561f, -0.11644471f, -0.07368936f, -0.02680509f, 
    0.06423688f, 0.19471183f, 0.35355514f, 0.31061435f, 0.27601668f, 0.05751816f, 0.16719176f, -0.00253605f, 
    0.06420834f, -0.11677220f, -0.24352790f, 0.05621656f, 0.06891470f, -0.02320619f, -0.11147266f, 0.04254639f, 
    -0.07646788f, 0.07441359f, -0.00244919f, 0.01602905f, 0.08645605f, 0.34265113f, -0.28757516f, -0.00747769f, 
    0.21635135f, -0.14978360f, 0.07027991f, -0.22269295f, -0.11504671f, 0.04606902f, -0.17796388f, -0.07253547f, 
    0.04737515f, -0.10976742f, -0.03564017f, -0.07669000f, -0.03704187f, 0.06979457f, -0.04529580f, 0.07692672f, 
    -0.63335538f, -0.13612726f, -0.45498961f, -0.19689465f, -0.01940912f, 0.03987622f, -0.15989591f, -0.15158129f, 
    -0.01995578f, -0.14488083f, -0.11136344f, 0.03533462f, 0.07852428f, -0.16166314f, -0.03041895f, -0.11343209f, 
    -0.03717121f, -0.02391797f, -0.01692959f, 0.17949888f, 0.04886024f, -0.38433918f, 0.24076401f, 0.10429994f, 
    -0.33779973f, 0.19676068f, 0.00085181f, -0.03057923f, -0.06328963f, -0.13932715f, -0.07682253f, -0.12353665f, 
    -0.23658878f, -0.21254840f, -0.13514712f, -0.01322385f, 0.03457355f, -0.05583295f, -0.03371521f, -0.04968985f, 
    0.33985138f, 0.04802880f, 0.33688244f, -0.18664430f, 0.21354260f, -0.15430550f, 0.17379180f, 0.01554498f, 
    -0.10070496f, -0.00947608f, 0.03334831f, 0.07003844f, -0.11828303f, -0.02277276f, -0.08953142f, 0.00776306f, 
    -0.01392691f, 0.00141412f, 0.07319534f, -0.15209658f, 0.05540345f, 0.07177775f, 0.35831597f, 0.03649753f, 
    0.30058804f, 0.06851406f, 0.16221151f, 0.02856833f, -0.05557233f, 0.02446281f, -0.15302368f, 0.02370171f, 
    -0.14925036f, -0.02355497f, -0.05101376f, -0.11047877f, 0.11657305f, 0.11198635f, 0.00236155f, -0.04363276f, 
    -0.20789927f, -0.10793802f, -0.30174014f, -0.48209232f, -0.57325083f, 0.00687381f, -0.06571166f, -0.10390393f, 
    -0.05098790f, -0.20270224f, -0.03014004f, -0.13303903f, 0.02115844f, -0.08941966f, -0.03787327f, -0.11250892f, 
    -0.03901794f, -0.05276500f, -0.09122393f, 0.05764819f, -0.10263843f, 0.07794423f, 0.27580664f, -0.03996504f, 
    -0.04473431f, 0.15459692f, 0.05006483f, 0.02710178f, 0.20166861f, -0.05666085f, -0.03384604f, -0.03725637f, 
    0.19038562f, 0.04464449f, -0.28596145f, 0.04630011f, -0.09467260f, -0.01840300f, -0.01929106f, -0.01376333f, 
    -0.84909302f, 0.24455194f, 0.07207580f, 0.08311086f, 0.06593213f, 0.05682228f, -0.14002505f, -0.11827375f, 
    0.15971954f, -0.07333677f, -0.00580717f, 0.08643494f, 0.00160394f, -0.04583334f, -0.13838060f, 0.18012975f, 
    0.05916073f, 0.26868001f, 0.01819260f, -0.00031447f, -0.42075184f, 0.21013893f, -0.04550705f, 0.06964672f, 
    0.23155566f, 0.12508138f, -0.26818746f, -0.01194569f, 0.20764430f, -0.19637229f, -0.01398121f, 0.12228337f, 
    -0.01453685f, 0.06496470f, -0.07836706f, -0.03360995f, -0.11075119f, 0.11365245f, -0.01235827f, -0.08200653f, 
    0.01559162f, -0.34013987f, -0.02208753f, -0.23274049f, -0.36845937f, -0.04429564f, -0.11396573f, 0.08136013f, 
    -0.04107911f, -0.06156224f, 0.14587006f, -0.01473858f, 0.09754328f, 0.04457674f, 0.05421981f, 0.11777125f, 
    -0.15556686f, -0.08044156f, 0.03226928f, 0.00941210f, -0.29208198f, -0.17643408f, 0.16317637f, -0.77100438f, 
    -0.54248595f, 0.13957621f, 0.03362064f, -0.25387403f, 0.02350555f, -0.15387191f, 0.06694173f, 0.06260312f, 
    -0.13226627f, 0.08898880f, -0.16265652f, -0.13613388f, 0.01965241f, 0.01476421f, -0.48315358f, -0.03355715f, 
    0.03722593f, -0.17987138f, 0.26217815f, 0.14638785f, 0.31431806f, -0.11496175f, -0.06094516f, -0.10387752f, 
    -0.19816747f, 0.05688908f, 0.01778268f, -0.08532166f, -0.00406123f, -0.01463831f, -0.02164714f, 0.07776079f, 
    -0.02561766f, 0.16827074f, -0.12342802f, 0.07681121f, -0.00818420f, 0.13583498f, 0.02737916f, 0.01735361f, 
    -0.04251501f, -0.15216832f, -0.01723682f, -0.06710572f, -0.12944172f, -0.12568805f, 0.22443485f, 0.08724546f, 
    -0.02000370f, -0.13723041f, -0.04325683f, -0.25185218f, 0.07703717f, -0.03929332f, 0.13705091f, -0.03083253f, 
    0.00985013f, -0.01129729f, 0.16215621f, 0.22728071f, 0.08563333f, -0.20625450f, -0.01905711f, -0.11436659f, 
    -0.09219663f, 0.11522967f, 0.01874897f, -0.04896550f, 0.06532001f, 0.13105713f, 0.02390947f, 0.05492918f, 
    -0.03849360f, -0.02032915f, 0.06228514f, 0.02654727f, -0.39726159f, -0.11860844f, -0.13560556f, -0.03667350f, 
    0.00059364f, 0.07806402f, -0.15144657f, -0.12657663f, -0.15263458f, 0.11670723f, 0.02606697f, 0.09115998f, 
    0.11591674f, -0.12011396f, 0.07276139f, 0.01637693f, -0.02416562f, -0.06634583f, 0.04748332f, 0.01162445f, 
    -0.38978934f, -0.04169232f, 0.49133027f, -0.11478952f, 0.05255549f, -0.13400941f, -0.16068421f, 0.04747803f, 
    -0.00288787f, -0.00713417f, -0.02498675f, 0.02734485f, -0.23538227f, 0.04546924f, 0.05066642f, -0.14951433f, 
    0.12755351f, -0.08307126f, 0.00085765f, -0.08592844f, -0.28145131f, -0.01874990f, -0.34981385f, -0.44740447f, 
    -0.29895350f, -0.01945583f, -0.02265742f, -0.08161914f, 0.04581501f, -0.17565212f, 0.18501420f, 0.06433322f, 
    -0.03180476f, 0.09149812f, 0.02201146f, 0.01910389f, 0.01875759f, -0.19569197f, 0.05079288f, 0.09978428f, 
    0.20671174f, 0.08628799f, -0.48385414f, -0.00660066f, 0.20687005f, 0.20055366f, 0.23429424f, -0.02332970f, 
    -0.05547589f, -0.02043256f, 0.03447667f, 0.02291299f, 0.06906085f, 0.12273422f, -0.04323694f, 0.01240801f, 
    0.18367720f, 0.13044780f, 0.03834676f, -0.11486560f, 0.25399202f, 0.07868420f, 0.04808490f, -0.09813102f, 
    0.12281995f, 0.01453650f, -0.09928793f, -0.25348654f, -0.00600207f, -0.12499757f, 0.02590178f, -0.12217729f, 
    -0.14067055f, 0.01928855f, -0.00770024f, -0.02898384f, -0.00117194f, 0.03037618f, -0.06678096f, 0.09079494f, 
    -0.27045524f, 0.42891318f, 0.00915708f, -0.12193649f, 0.04329462f, -0.03590756f, -0.18384258f, 0.06529795f, 
    -0.03301473f, 0.09431682f, 0.10078616f, 0.00480048f, -0.20306155f, 0.04282478f, 0.09129405f, -0.03455324f, 
    -0.01179454f, 0.10108460f, 0.12029380f, 0.09526371f, -0.31057814f, -0.01027497f, 0.17848648f, -0.24924512f, 
    -0.29283103f, 0.01684108f, 0.03651584f, 0.04454749f, -0.10809925f, -0.12525716f, 0.09702484f, 0.05164840f, 
    -0.04575964f, -0.01985085f, -0.02114023f, 0.10979991f, -0.05462860f, -0.11837996f, -0.03855091f, 0.05797491f, 
    0.16449118f, 0.12349028f, -0.20729752f, 0.10843005f, 0.31450447f, 0.18140846f, 0.20789878f, -0.23201223f, 
    -0.05908602f, -0.09284086f, 0.04547583f, 0.06700525f, 0.00394829f, -0.29673964f, 0.03314170f, -0.25685933f, 
    0.17998382f, 0.13463080f, 0.12737675f, -0.10524922f, 0.21993025f, -0.02824739f, 0.01149159f, 0.13904910f, 
    0.21806905f, -0.18670668f, -0.16597311f, -0.03703083f, -0.14610772f, 0.12539017f, -0.11198366f, -0.13196868f, 
    -0.25047866f, -0.18592575f, 0.02671627f, 0.05325085f, 0.03998278f, -0.04663961f, 0.07230375f, -0.13937666f, 
    -0.01798709f, 0.23523518f, -0.40393183f, 0.04577068f, -0.20971097f, 0.11872540f, -0.06562882f, -0.20785294f, 
    -0.06607481f, 0.07415296f, 0.17260772f, -0.03420529f, 0.11574329f, 0.14533369f, 0.15039898f, 0.05632398f, 
    0.04413668f, -0.22253150f, 0.29314208f, -0.10729317f, 0.06539389f, 0.24132471f, -0.62767649f, -0.05865118f, 
    -0.07264622f, -0.11243235f, -0.09724862f, -0.21115650f, -0.12346534f, 0.00695040f, 0.02041883f, 0.17099591f, 
    0.15978809f, -0.04842836f, 0.17619729f, 0.05085451f, -0.21145259f, -0.26631755f, 0.13357593f, 0.17439547f, 
    -0.11168857f, -0.04253720f, -0.20899685f, -0.04622212f, 0.30336520f, 0.03107307f, 0.00927534f, 0.16806316f, 
    0.04881767f, 0.09964326f, 0.02661870f, -0.13430810f, 0.04361014f, -0.03879956f, -0.09041730f, 0.12461082f, 
    -0.12468889f, 0.10246503f, -0.12320676f, 0.01930605f, 0.13874322f, -0.19865336f, -0.00944244f, 0.16587572f, 
    -0.22421382f, -0.32299191f, 0.11469854f, -0.02460108f, -0.08452193f, -0.00570980f, 0.08308761f, -0.03627120f, 
    -0.04501869f, 0.17538780f, 0.07813362f, 0.12882023f, 0.19611117f, 0.05601432f, 0.08282432f, 0.06906556f, 
    0.87565589f, 0.02675342f, -0.07288836f, -0.12418689f, 0.03745275f, 0.11610334f, -0.11359638f, 0.08056188f, 
    -0.01295162f, -0.04009470f, 0.02067386f, 0.11858874f, -0.00433974f, 0.23731086f, 0.08869743f, 0.09604555f, 
    0.03049440f, -0.19565400f, -0.07444393f, 0.02767996f, -0.60166454f, 0.24756466f, -0.00609326f, 0.14252298f, 
    -0.12822740f, 0.16052011f, 0.13949384f, 0.03329031f, -0.00697897f, -0.14165846f, -0.19747661f, -0.15992425f, 
    0.03547701f, 0.04658848f, 0.23510823f, 0.17561717f, -0.05112156f, 0.06950250f, -0.26166809f, 0.03545890f, 
    0.62157255f, -0.63716489f, 0.03025688f, 0.20586607f, -0.02972339f, -0.10913892f, 0.02505500f, -0.13990214f, 
    0.18946803f, -0.05785650f, -0.12747100f, 0.10660023f, -0.15065494f, -0.07898816f, 0.01806044f, -0.42507252f, 
    0.00470685f, -0.04735108f, 0.02924453f, 0.07173531f, 0.58464879f, -0.88194561f, 0.28820089f, -0.09027655f, 
    0.04391202f, -0.09577129f, -0.04743828f, 0.06676688f, 0.09505025f, 0.08520684f, 0.09511984f, 0.02494363f, 
    0.15517427f, -0.18241143f, -0.12746659f, 0.16436906f, 0.11546448f, 0.03470175f, 0.05557672f, 0.02241823f, 
    0.27657303f, -0.13032886f, -0.08823813f, 0.14206235f, 0.10280672f, 0.09549381f, -0.00597265f, -0.08051761f, 
    -0.02170185f, 0.25412968f, -0.18529196f, -0.01985697f, 0.20630060f, 0.15204220f, 0.03378278f, 0.06838936f, 
    -0.13882920f, 0.07826549f, 0.04355188f, -0.11705571f, -0.40444770f, 0.05063013f, 0.04944851f, -0.07172902f, 
    -0.37886369f, -0.00722751f, -0.04840776f, -0.00781633f, -0.14737211f, 0.16569528f, -0.01979592f, -0.00241686f, 
    -0.10812594f, -0.07896326f, 0.09236015f, -0.21091883f, 0.12100114f, 0.02803585f, 0.13678727f, -0.08248925f, 
    0.20609151f, -0.05112609f, 0.33091599f, -0.59162390f, -0.71652347f, 0.07597748f, 0.01625885f, 0.04479215f, 
    -0.16445604f, 0.08063402f, -0.18697545f, 0.15225564f, 0.14006305f, -0.31513542f, 0.01022516f, -0.13811310f, 
    -0.00873486f, -0.14751439f, 0.23105545f, -0.07370407f, -0.19524899f, -0.54977536f, 0.11658163f, -0.07725476f, 
    -0.13886301f, 0.11895764f, 0.05226576f, -0.10632885f, -0.08020770f, -0.04831545f, -0.05815019f, -0.12340979f, 
    0.04774437f, 0.28984264f, -0.04733594f, 0.06219856f, 0.14266813f, -0.21109539f, 0.02473673f, -0.16184676f, 
    -0.36632684f, 0.17047875f, -0.27635300f, 0.25185734f, -0.20789899f, -0.03233525f, 0.03595422f, -0.12610939f, 
    -0.01223840f, 0.10646830f, -0.12501174f, 0.08203523f, 0.17320757f, -0.00009330f, 0.16688406f, 0.01002901f, 
    -0.01649485f, 0.06219984f, -0.21273166f, -0.12699208f, -0.34973383f, -0.28777051f, -0.05328073f, 0.37659743f, 
    0.07558055f, 0.05192265f, -0.06204627f, 0.01300365f, -0.27016160f, 0.08848587f, -0.00198873f, -0.00309360f, 
    -0.16419652f, 0.00809376f, -0.03351526f, 0.03919766f, -0.19439997f, 0.11592264f, 0.03661121f, 0.12769414f, 
    0.05298165f, -0.27548444f, 0.21472473f, 0.00958611f, -0.28911406f, -0.11872059f, 0.15694758f, 0.02058039f, 
    -0.08513229f, -0.06487890f, 0.08096149f, -0.05969635f, -0.17854656f, -0.13036332f, -0.07886498f, 0.08641770f, 
    -0.05286695f, -0.07466545f, -0.23735076f, 0.00246177f, -0.08908226f, -0.39696136f, -0.08999610f, 0.32216787f, 
    -0.03541389f, 0.09909287f, 0.15792878f, 0.04707424f, 0.04329580f, 0.12947963f, -0.05286559f, -0.16187456f, 
    0.08804219f, 0.06551157f, -0.03793362f, 0.00123715f, -0.06485340f, -0.16600443f, 0.00341543f, 0.19467859f, 
    -0.76801252f, -0.18562326f, 0.32828963f, -0.21990772f, 0.23027819f, 0.14215620f, 0.12883736f, -0.06969369f, 
    0.04100182f, -0.02296499f, -0.01813253f, -0.02245180f, -0.13147646f, 0.04039088f, -0.10104043f, 0.13097647f, 
    0.08262067f, 0.08565702f, -0.17435473f, 0.10776661f, -0.31638220f, -0.15633784f, 0.07396367f, -0.26265806f, 
    -0.06438125f, -0.07965093f, 0.03101377f, 0.06729782f, 0.10381731f, -0.12528269f, -0.01163212f, 0.08200814f, 
    -0.12505181f, -0.04720107f, -0.21138738f, -0.01447839f, 0.07432699f, 0.35906881f, 0.05509632f, 0.20356171f, 
    0.27068198f, 0.32071763f, -0.44672447f, 0.06235614f, 0.16735102f, -0.05248871f, -0.13729516f, 0.09856401f, 
    -0.04722401f, 0.10814550f, 0.00947099f, 0.03463345f, 0.27536824f, -0.02254761f, 0.03765514f, 0.07534280f, 
    0.20539778f, 0.14207220f, 0.12358333f, 0.16532981f, 0.29109907f, -0.01797280f, 0.15230826f, 0.02270508f, 
    -0.06998328f, 0.05866363f, 0.08799234f, 0.16171990f, -0.02266225f, 0.01277332f, -0.01620596f, -0.01697861f, 
    -0.13514203f, -0.07494254f, -0.17768805f, 0.13613655f, -0.10095351f, -0.60911798f, -0.32089823f, -0.18910418f, 
    -0.06563913f, 0.14785285f, -0.14123574f, -0.02630639f, 0.08474191f, -0.03768101f, 0.07644621f, -0.13959005f, 
    0.09208219f, 0.00737489f, -0.08621048f, 0.11994042f, -0.06015712f, -0.16726516f, 0.03655159f, -0.09608857f, 
    0.06943479f, 0.20821181f, -0.12234273f, 0.16912027f, -0.94674903f, -0.83884537f, -0.03719648f, -0.02321919f, 
    0.02419333f, 0.05272654f, -0.00347433f, 0.25467235f, -0.09468377f, -0.02148945f, 0.21774335f, -0.07244875f, 
    0.03090431f, 0.03979977f, 0.08446140f, 0.03175427f, 0.02805822f, -0.03059055f, 0.05426809f, 0.12594245f, 
    0.25459954f, -0.01535449f, -0.04639855f, 0.06679929f, -0.15485683f, -0.27984920f, -0.06915393f, 0.02069740f, 
    0.02029828f, 0.09793878f, -0.06066745f, 0.09977611f, 0.01682327f, -0.04406430f, 0.05082504f, 0.04516742f, 
    0.24472833f, 0.05176822f, -0.09237767f, 0.05519452f, -0.31084239f, 0.29866660f, 0.05930986f, 0.10963016f, 
    0.17376865f, 0.04284553f, 0.04247229f, -0.09610567f, 0.13100606f, 0.17538707f, 0.02258453f, 0.08261117f, 
    0.13374415f, 0.15359396f, 0.18412280f, 0.11788944f, -0.17981693f, 0.00424672f, -0.18613976f, 0.03929745f, 
    0.23094718f, 0.15389967f, 0.13942136f, -0.09469134f, -0.13489392f, -0.22773378f, -0.22178435f, 0.16625790f, 
    -0.00057906f, 0.00147797f, 0.04677830f, 0.07553279f, -0.17456588f, -0.13105254f, -0.20775111f, -0.04666706f, 
    -0.08760511f, 0.01565499f, -0.04508686f, -0.01537954f, -0.13251999f, -0.17254375f, 0.25656804f, 0.11759868f, 
    0.14521885f, 0.14309713f, 0.10655197f, 0.12945923f, 0.04986803f, 0.02573437f, -0.04178081f, 0.10010529f, 
    -0.00039311f, 0.09437966f, -0.08243521f, 0.10395987f, -0.05450371f, -0.25570014f, -0.18767171f, -0.14342001f, 
    -0.60086751f, -0.28603050f, -0.05613110f, -0.27301696f, -0.20523892f, 0.09949745f, 0.03404289f, -0.06879753f, 
    -0.08213155f, 0.00838995f, 0.04801302f, 0.14179146f, 0.02817566f, 0.28069970f, -0.01997978f, 0.18973204f, 
    0.13420080f, -0.01742052f, -0.14082868f, -0.02882271f, -1.05978680f, 0.00019020f, -0.33569297f, -0.14590378f, 
    0.00989143f, 0.14430633f, -0.00016078f, -0.19504391f, -0.04937810f, 0.07810248f, 0.11926065f, 0.13892663f, 
    -0.00254068f, -0.10325415f, 0.08869179f, 0.01234931f, 0.00380694f, 0.26402146f, 0.02376124f, 0.03169935f, 
    0.20287162f, -0.20756836f, -0.02287430f, 0.01649081f, 0.24074715f, -0.17256118f, 0.05815077f, 0.04503438f, 
    -0.12865186f, -0.05904352f, 0.00464855f, -0.01345265f, -0.00835364f, -0.15143828f, -0.01559124f, -0.23394670f, 
    0.07784922f, 0.02158848f, -0.00106790f, 0.10951135f, 0.35201705f, 0.24228954f, -0.09429574f, 0.02875900f, 
    -0.32070053f, -0.10911092f, -0.00248148f, 0.07188030f, 0.09144889f, -0.06176721f, -0.07628922f, 0.04847997f, 
    0.13021651f, -0.09458227f, -0.06731170f, 0.00808535f, 0.06626393f, -0.32566461f, -0.01320013f, 0.02256654f, 
    -1.03799212f, -0.60693073f, -0.39008540f, -0.26568568f, -0.06930069f, 0.15422720f, -0.01042748f, -0.09271544f, 
    -0.22775806f, 0.03619219f, 0.02545313f, -0.12254976f, -0.07076865f, 0.11343198f, 0.09056479f, -0.01050912f, 
    -0.04223094f, 0.16226842f, 0.04807932f, 0.09717748f, 0.34584609f, -0.06561429f, -0.20146206f, 0.07715447f, 
    -0.07024363f, -0.29865086f, 0.01430083f, -0.13865452f, 0.07267810f, -0.00412811f, 0.01357308f, 0.10570538f, 
    -0.19729085f, -0.13011152f, 0.02334746f, -0.17926735f, -0.10584922f, 0.02292126f, -0.06893922f, -0.12356507f, 
    -0.33894247f, -0.05716887f, -0.40374953f, 0.08641640f, -0.25834507f, 0.05628207f, 0.02261633f, 0.13640478f, 
    -0.00648884f, -0.02713444f, 0.23454972f, 0.06221217f, 0.02538954f, -0.15127727f, 0.16091989f, -0.01774347f, 
    -0.18701173f, -0.04828360f, 0.16780120f, -0.02471777f, 0.00274994f, -0.18294536f, -0.00806198f, 0.17934600f, 
    0.04404093f, 0.14655676f, 0.08892787f, -0.03319938f, 0.15079100f, -0.09880503f, -0.05064803f, 0.13479593f, 
    0.01478089f, -0.04055992f, 0.08862647f, 0.08115052f, 0.10940299f, -0.18297307f, 0.06000243f, -0.18825798f, 
    -0.06940408f, 0.08638638f, 0.02298771f, 0.31229171f, 0.05827734f, -0.18837576f, 0.09293131f, 0.21955745f, 
    0.07430056f, -0.13586967f, 0.08613809f, -0.33150631f, -0.15744059f, 0.14331736f, 0.21681315f, 0.21404432f, 
    0.06692272f, 0.08827569f, 0.05837654f, -0.03548224f, 0.18331057f, 0.20917998f, -0.26545572f, -0.27291739f, 
    0.15641437f, -0.26674151f, -0.26728314f, -0.09896807f, -0.09338346f, -0.21523382f, 0.03263592f, -0.04429926f, 
    -0.11771741f, 0.09596315f, 0.04406923f, 0.22321646f, -0.08658177f, 0.11039902f, 0.24877495f, 0.06866430f, 
    -1.04906774f, 0.22657682f, -0.02442893f, -0.24778974f, 0.21423455f, -0.14686686f, 0.04723733f, -0.12862152f, 
    0.10717385f, 0.06333201f, 0.05881508f, 0.00188314f, 0.27236566f, -0.07029485f, -0.15241513f, -0.12048700f, 
    -0.14706728f, 0.05144056f, -0.24596350f, -0.14035536f, -0.16815032f, 0.34848529f, -0.11943878f, 0.08667763f, 
    -0.12357559f, 0.26069543f, -0.14795063f, 0.00954430f, 0.08506356f, 0.10907199f, 0.04636401f, 0.05747359f, 
    -0.12256059f, -0.01416902f, 0.12688716f, -0.04191709f, 0.16288145f, 0.13000949f, -0.19666339f, -0.04837199f, 
    0.06591702f, -0.08084894f, 0.05956181f, -0.01103638f, -0.03512384f, 0.01219342f, 0.02199054f, 0.06825207f, 
    -0.09835503f, 0.01651940f, -0.15843965f, -0.30973113f, 0.13012749f, -0.18875851f, -0.08287987f, 0.07987937f, 
    0.06297567f, 0.04809985f, -0.19518465f, -0.19632760f, -0.17873268f, 0.10426696f, -0.15337452f, 0.11301868f, 
    -0.19366758f, -0.26825872f, 0.18835592f, -0.11779296f, 0.09043837f, -0.03722345f, 0.06749466f, 0.00515829f, 
    0.04053611f, 0.02840717f, 0.01675312f, 0.16821711f, 0.11529893f, -0.01343613f, 0.09937126f, 0.25393143f, 
    0.28817898f, -0.28164524f, 0.18829672f, -0.10835475f, 0.14855848f, -0.20968236f, -0.04302346f, -0.15638565f, 
    0.00132004f, -0.41066346f, -0.04376249f, -0.12880459f, 0.07073396f, 0.09619561f, -0.20419614f, -0.07121044f, 
    -0.24947959f, -0.01680496f, -0.10552375f, -0.00564269f, -0.00865557f, 0.59075487f, -0.19716422f, -0.05556370f, 
    0.46032703f, 0.18677905f, -0.10681886f, -0.00393566f, -0.02317227f, -0.09994043f, 0.20515212f, 0.19746950f, 
    0.03398211f, -0.02870404f, 0.02254491f, 0.01008363f, 0.08439886f, 0.08651549f, -0.08504058f, 0.17414178f, 
    0.79863316f, 0.11094432f, -0.25704807f, -0.11984671f, 0.07872516f, 0.13644069f, -0.02351754f, -0.07785859f, 
    -0.01138273f, 0.02256844f, 0.27758700f, 0.04650099f, 0.08430755f, 0.03313826f, 0.08000764f, 0.05773006f, 
    -0.16383077f, -0.06790712f, 0.05232303f, 0.17463186f, -0.41495085f, -0.11342541f, 0.04069520f, 0.09481157f, 
    0.19676803f, -0.15830262f, 0.25725082f, -0.04919335f, 0.02437162f, -0.14214890f, -0.07613280f, -0.00272052f, 
    0.11509948f, 0.14003384f, 0.01642940f, 0.05394417f, 0.04445479f, -0.11860102f, 0.06223893f, -0.03445235f, 
    -0.54263669f, 0.24222793f, 0.00593238f, 0.00157201f, -0.13211901f, 0.15217640f, -0.02231819f, 0.16806148f, 
    -0.03141676f, 0.04100400f, 0.09243604f, -0.08463075f, 0.03294251f, -0.15607457f, -0.02221513f, -0.00101654f, 
    0.09731960f, -0.24855125f, -0.02043965f, -0.02214063f, 0.34522718f, 0.03910849f, -0.03508244f, 0.03149138f, 
    0.03542119f, -0.12493262f, -0.22968365f, 0.00855165f, -0.24399330f, -0.16643168f, 0.22694217f, -0.00907040f, 
    0.02699575f, 0.01562751f, -0.06697097f, 0.03892629f, -0.18767947f, 0.10234350f, -0.05863373f, -0.08624970f, 
    0.63164759f, -0.14390567f, -0.50266296f, -0.29713595f, -0.59318060f, -0.02011824f, -0.01651168f, -0.10607336f, 
    0.10563866f, 0.03057910f, -0.01704730f, -0.00264272f, -0.11276510f, -0.10439710f, 0.03841610f, -0.06019196f, 
    -0.02612431f, -0.06627447f, -0.13456945f, 0.02692693f, -0.27236953f, -0.19448709f, 0.06439177f, -0.12960295f, 
    -0.22479214f, -0.08538458f, 0.02099947f, -0.07244527f, 0.11068194f, -0.07006595f, -0.28155336f, 0.14051048f, 
    0.19782859f, 0.11493573f, -0.05478606f, -0.21690193f, -0.01870773f, -0.05869516f, -0.30455154f, -0.02856680f, 
    0.24803965f, -0.24985202f, -0.41979313f, 0.24642406f, -0.15614367f, -0.12503362f, 0.05834143f, 0.03497834f, 
    -0.01901666f, -0.07068890f, 0.02807387f, -0.08936416f, -0.01221188f, 0.15044276f, -0.22305171f, 0.10314419f, 
    -0.01871138f, -0.08942073f, -0.25287342f, -0.24388143f, 0.33516777f, 0.15066046f, -0.23023912f, 0.13245314f, 
    -0.03910318f, 0.10084955f, 0.09489760f, -0.20240319f, -0.02777376f, 0.07314850f, 0.04367464f, 0.00857072f, 
    -0.05233249f, 0.04372966f, 0.08738708f, -0.08086579f, 0.09986871f, 0.18920508f, -0.22295839f, 0.02584977f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11858045f, 0.10591050f, -0.01838869f, -0.09107453f, 0.00320944f, 0.07443240f, -0.07126390f, -0.13158216f, 
    -0.03842495f, 0.06118418f, 0.07557902f, 0.01950335f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
