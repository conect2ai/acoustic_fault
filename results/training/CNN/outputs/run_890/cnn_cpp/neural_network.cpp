#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.49946782f, 0.06446524f, 0.68709648f, 0.49963763f, 0.96013343f, 0.86164075f, 0.31917194f, 0.58466893f, 
    -0.33389062f, 0.21004006f, -0.06772108f, 0.04768340f, 0.32646254f, -0.05206535f, -0.01561962f, -0.26308763f, 
    -0.03550440f, 0.15108092f, 0.12747467f, 0.02525137f, 0.25266123f, -0.07436987f, -0.28016254f, 0.04710868f, 
    0.13886102f, -0.79928607f, -0.44728848f, -0.58058572f, -0.50087416f, -0.74684578f, 0.85558534f, 0.39736181f, 
    -0.10930065f, 0.47470555f, 0.56669480f, -0.25501221f, -0.32371992f, 0.21662883f, -0.22354639f, -0.39838699f, 
    -0.07495611f, -0.11257252f, 0.14307597f, 0.04878602f, -0.06709019f, -0.03692001f, -0.39815351f, -0.14944866f, 
    -0.19737764f, 0.17359099f, -0.78270990f, 0.32294187f, 0.51979041f, -0.86567539f, 0.21892479f, 0.86586726f, 
    -0.63096279f, -0.62044853f, -0.06683426f, -0.89312506f, -0.23686495f, -0.22480057f, -0.19113666f, -0.03699420f, 
    -0.44909763f, -0.00143047f, 0.15494591f, -0.18371972f, -0.37950575f, -0.12017803f, 0.21966255f, 0.33626613f, 
    0.19153693f, 0.13889636f, -0.19897313f, -0.13813369f, -0.53062904f, 0.15314092f, 0.02155958f, 0.67536175f, 
    0.51676935f, -0.48148546f, -0.67206550f, -0.19771934f, -0.45840123f, -0.20803833f, 0.55569410f, 0.27121735f, 
    0.21950816f, 0.47333863f, 0.24041525f, 0.03983455f, 0.10520855f, 0.07119770f, 0.04961421f, -0.04764474f, 
    0.08079844f, 0.14131124f, -0.09077843f, 0.04148167f, 1.01160014f, 0.07961039f, 0.08166686f, -0.71214902f, 
    -0.54163706f, -0.71433973f, -0.64087534f, -0.09074915f, -0.24005403f, -0.35908756f, -0.15757972f, 0.14630482f, 
    -0.09980346f, 0.26615316f, 0.15409440f, -0.09939412f, -0.32169151f, -0.20070149f, 0.07543679f, 0.11679871f, 
    0.19105999f, 0.27588508f, 0.09682304f, -0.33532372f, -0.02673407f, 1.08788073f, 0.20133241f, 0.47455674f, 
    1.28704619f, 0.79150927f, -0.28343168f, 0.01951258f, 0.17325237f, 0.13491800f, 0.06439307f, -0.36457440f, 
    -0.22246845f, -0.18925378f, -0.21656364f, -0.18036853f, -0.07452283f, -0.07409436f, -0.01382171f, -0.08453504f, 
    -0.02694259f, 0.08369673f, -0.17257136f, 0.00329326f, -0.07858084f, 0.20539910f, -0.11922315f, -0.62800366f, 
    -0.63036096f, 0.40838096f, 0.77009523f, 0.23153560f, 0.61280680f, 0.01182148f, 0.71612257f, 0.30271602f, 
    0.00606926f, 0.06506444f, -0.20648254f, 0.01525646f, -0.26060075f, -0.32895890f, -0.36055720f, -0.49226269f, 
    -0.33953094f, -0.10564619f, 0.02470923f, -0.13506846f, 0.15909290f, -0.18896808f, 0.01148439f, -0.45817986f, 
    -0.36574006f, 0.44068563f, 0.79362774f, 0.20621850f, -0.74694908f, -0.52757704f, -0.29219866f, 0.26733941f, 
    -0.53685921f, -0.27668300f, -0.10007741f, 0.02589997f, -0.17009689f, 0.00746904f, -0.35520786f, -0.05888356f, 
    0.30155900f, 0.03488785f, 0.12382058f, -0.09636547f, -0.15655747f, -0.46477115f, 0.03227628f, -0.21785593f, 
    -0.63143659f, -1.43135607f, -0.62466103f, 0.12361906f, 0.06694114f, -0.72474432f, 0.33439463f, 0.29772785f, 
    -0.13810097f, -0.28104874f, 0.19624415f, 0.11567143f, -0.01284070f, 0.04460656f, 0.13225070f, 0.02202659f, 
    -0.02159493f, -0.11266756f, -0.27767050f, -0.19307102f, 0.01487745f, -0.00620239f, 0.00815623f, 0.18785298f, 
    0.10363152f, 1.32334471f, 0.80675393f, 0.06713589f, 0.36183551f, 0.55508143f, 0.45157373f, 0.25941190f, 
    -0.39862272f, 0.14058892f, 0.07552623f, 0.14258808f, 0.16205224f, -0.18459925f, -0.00413794f, -0.04762588f, 
    0.15825440f, 0.01696451f, -0.01345727f, 0.02324779f, -0.19309454f, 0.32749003f, 0.44462723f, 0.32614708f, 
    0.03643360f, 0.08233733f, 0.51956505f, 0.76763123f, -0.57091886f, 0.41637769f, 0.52849877f, 0.48325902f, 
    -0.62229633f, -0.91537386f, -0.39562139f, 0.08075085f, 0.33925962f, 0.29343259f, -0.01011121f, 0.32111034f, 
    -0.19507827f, -0.12975018f, -0.28865439f, 0.18956509f, -0.17562479f, 0.03511114f, -0.21170828f, -0.11242494f, 
    -0.13845497f, -0.03825715f, 0.14449698f, -0.20306680f, -0.37625098f, -0.75934607f, -0.25190777f, -0.14180526f, 
    -0.36487785f, -0.77204657f, 0.41163546f, 0.50096077f, 0.25888324f, -0.49439254f, -0.27990273f, 0.03539558f, 
    0.09535666f, -0.51589006f, 0.21428597f, 0.12860930f, 0.27507839f, -0.04241629f, -0.03382803f, -0.04246953f, 
    0.30789638f, -0.25599310f, 0.49368358f, 0.04546118f, 0.22882651f, -0.61538780f, -0.73763180f, -0.65460372f, 
    -0.03624909f, 0.04069996f, 0.81296289f, 0.06583644f, -0.51170778f, 0.00760473f, 0.01153872f, -0.26650113f, 
    -0.22421919f, -0.33667853f, -0.24227850f, -0.34236804f, 0.41944584f, 0.12386019f, -0.07586698f, -0.27850375f, 
    -0.17592932f, -0.20299071f, -0.12191059f, -0.24156575f, -0.21817550f, -0.68060780f, -0.75858796f, -0.69667804f, 
    -0.33426160f, -0.68329853f, -0.45009291f, 0.22526212f, -0.38512897f, -0.21262281f, 0.11189649f, 0.36663944f, 
    0.61410731f, 0.17029008f, 0.30244926f, -0.07744244f, 0.28870139f, -0.13674165f, 0.07457289f, 0.35160553f, 
    -0.14408828f, -0.16344117f, 0.02382685f, 0.17007813f, -0.44321874f, 0.06773002f, -0.96064764f, 0.21571240f, 
    -0.55038530f, -0.34200630f, 0.18708664f, -0.15018585f, 0.98483074f, -0.10255839f, 0.10565727f, 0.38753656f, 
    -0.22335137f, -0.09750168f, -0.03039735f, -0.22099663f, 0.37235051f, 0.15440597f, 0.04879216f, 0.18806759f, 
    0.14861017f, -0.08503459f, 0.17899407f, 0.13982539f, 0.20431444f, 0.38696840f, 0.04231791f, -1.03185475f, 
    -0.72433990f, 0.12670380f, 0.98087692f, 0.27042395f, 0.10914104f, 0.03414107f, -0.36408192f, 0.15772535f, 
    -0.16701990f, 0.55387658f, 0.07753021f, -0.16512562f, 0.21548837f, -0.19774082f, 0.05837909f, 0.23425882f, 
    0.26254085f, -0.18155432f, 0.17735569f, 0.02498081f, -0.03113760f, 0.29289886f, 0.01316119f, -0.15643302f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.27092186f, -0.19770910f, 0.22988941f, 0.14784662f, 0.31174809f, 0.09585916f, 0.06289916f, -0.00852170f, 
    0.35050410f, 0.21763109f, 0.21693292f, -0.06008704f, 0.02363530f, 0.13372800f, 0.10556604f, 0.31628975f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.43607837f, 0.01068287f, 0.15441376f, -0.07563907f, 0.01800600f, 0.00401247f, 0.03549359f, -0.00448815f, 
    -0.00843552f, -0.00073284f, -0.05185530f, -0.00589291f, 0.04962337f, -0.08470637f, -0.35105914f, -0.14053874f, 
    0.05705889f, 0.11273830f, -0.16105352f, -0.15649803f, -0.07342731f, -0.10955514f, -0.06596379f, -0.03621093f, 
    0.14201877f, 0.00150214f, 0.28144163f, 0.12570554f, -0.09027211f, 0.00480614f, -0.03976907f, 0.11694454f, 
    0.06739862f, -0.04653037f, 0.04343321f, -0.01489803f, -0.11070572f, -0.15042564f, 0.16558541f, 0.22203523f, 
    0.03913795f, 0.16434234f, -0.00118332f, 0.14717937f, -0.02062408f, 0.08171792f, 0.10851908f, 0.04628419f, 
    0.18877962f, 0.26277000f, 0.24208280f, 0.21651953f, -0.06309792f, -0.00404326f, -0.11679626f, -0.15507466f, 
    0.07463344f, 0.06062745f, 0.12252550f, -0.04551524f, 0.02438032f, -0.07416260f, -0.02664508f, 0.11921681f, 
    -0.03666932f, -0.04003875f, 0.03889456f, -0.07907137f, 0.09478550f, 0.11926422f, 0.07916732f, 0.10197219f, 
    -0.33128485f, 0.32557741f, 0.01602713f, -0.11903287f, -0.01417882f, -0.07387203f, 0.14229593f, -0.02321387f, 
    -0.00525237f, -0.06717274f, 0.10248969f, -0.11271172f, -0.09969419f, 0.03591722f, 0.12930599f, 0.03777931f, 
    -0.09120557f, -0.01739117f, 0.19747458f, 0.10880181f, 0.23410149f, -0.00162920f, 0.08274554f, -0.02375073f, 
    -0.80394900f, 0.35140824f, -0.18808839f, 0.03518438f, 0.19489923f, -0.10526425f, 0.03363668f, 0.05260557f, 
    -0.00184631f, 0.13241287f, -0.11773860f, 0.01458512f, 0.07937978f, 0.00654130f, -0.01595346f, 0.04955541f, 
    0.12174185f, -0.00480828f, 0.06166535f, 0.06665899f, 0.07914469f, -0.02597979f, -0.04719994f, -0.03161935f, 
    0.10557579f, 0.15139055f, 0.26768172f, 0.21563287f, -0.05444607f, 0.04653793f, 0.02523164f, 0.07524396f, 
    -0.08283002f, -0.18373410f, -0.03188073f, 0.16052297f, 0.36137077f, 0.07131205f, -0.05097760f, 0.09775514f, 
    0.05583749f, 0.18460247f, 0.01992693f, -0.12882639f, 0.02023480f, 0.08066896f, 0.06397096f, -0.07251574f, 
    -0.49735117f, 0.03034744f, 0.13737391f, -0.03668191f, 0.11327205f, 0.16041198f, 0.04113512f, 0.02190873f, 
    0.00298963f, 0.12577046f, -0.04500230f, 0.16403970f, -0.35533518f, -0.16816787f, 0.08426480f, 0.08183161f, 
    0.05897783f, 0.00445664f, -0.10586608f, 0.10314060f, 0.23956169f, 0.16825593f, 0.05100300f, -0.02043203f, 
    -0.22174919f, 0.06618277f, 0.17190456f, -0.01113461f, 0.07301071f, 0.04190768f, 0.21872851f, 0.12156796f, 
    -0.02329916f, -0.10586191f, -0.05756159f, 0.02607319f, -0.17070365f, 0.07353055f, 0.22282177f, -0.11530646f, 
    0.00826022f, 0.02788598f, 0.07245500f, -0.06850307f, 0.10275872f, 0.08916877f, -0.14686054f, 0.00513967f, 
    -0.12142234f, -0.01528650f, -0.22005780f, 0.02185023f, -0.00470712f, 0.08161100f, 0.09168009f, 0.02716760f, 
    0.08767629f, 0.03578602f, -0.12161360f, 0.09924319f, 0.01726318f, 0.08508252f, -0.06505430f, -0.43527216f, 
    -0.04659742f, -0.00208506f, 0.19149582f, 0.06397083f, 0.07164199f, -0.00106644f, -0.02964123f, 0.18217476f, 
    0.18672092f, -0.06967204f, -0.06402624f, -0.01263022f, -0.14381506f, 0.01638440f, 0.10061862f, -0.01702451f, 
    -0.01977122f, -0.10232276f, -0.00599508f, 0.02823353f, 0.06359471f, 0.10383583f, -0.04274730f, -0.00142262f, 
    0.07104015f, -0.07889680f, -0.02328290f, -0.20085499f, 0.07577430f, 0.01245035f, 0.05379196f, 0.03425969f, 
    0.33301657f, -0.07390746f, -0.00019154f, 0.24249764f, 0.11427467f, 0.03997896f, 0.02223175f, 0.18523774f, 
    -0.11497127f, -0.01083937f, -0.06182792f, 0.05096401f, 0.10908274f, -0.08290586f, 0.02694651f, 0.14551947f, 
    -0.27177870f, 0.05562517f, 0.06885840f, 0.00160794f, 0.08604614f, -0.09819832f, 0.17807244f, 0.03622076f, 
    -0.05154158f, 0.09734964f, 0.04744995f, 0.13525698f, 0.03255802f, 0.04637535f, -0.00894571f, -0.11953381f, 
    -0.10255987f, 0.13291307f, 0.06448267f, 0.09584039f, 0.04543186f, 0.14997886f, -0.02001157f, 0.17944103f, 
    -0.09872637f, 0.04782658f, 0.24234392f, -0.10563105f, 0.02990020f, -0.10494372f, -0.06319206f, 0.22760288f, 
    0.10295993f, 0.15253235f, -0.18402326f, 0.34358534f, -0.12579025f, -0.05735645f, -0.02179084f, -0.10083292f, 
    -0.09084455f, -0.02838855f, 0.16125590f, -0.06458744f, -0.08992232f, 0.12266992f, 0.09134531f, -0.04490727f, 
    -0.10370818f, -0.01302702f, -0.17212880f, 0.04422022f, -0.11341289f, 0.01260165f, -0.06595263f, -0.11162119f, 
    0.28393933f, 0.06042690f, 0.04916666f, 0.08385982f, -0.08542778f, -0.14710310f, -0.02586677f, 0.06464233f, 
    0.15558790f, 0.20938915f, -0.06465402f, -0.00993920f, 0.22714078f, 0.02163894f, -0.02011240f, -0.35524184f, 
    -0.03959881f, -0.08669443f, 0.13581479f, 0.11300816f, -0.09528191f, 0.10367775f, -0.00498037f, -0.00260049f, 
    0.05075555f, -0.11936893f, 0.11525308f, -0.10243396f, -0.04748826f, -0.02489443f, -0.12792231f, 0.19090024f, 
    -0.05074060f, 0.05425197f, -0.02770923f, 0.10099988f, -0.10774467f, -0.02697373f, -0.12485861f, 0.10681075f, 
    -0.03027309f, 0.12027328f, 0.02619802f, -0.01764952f, -0.06216712f, 0.18044139f, -0.12205736f, 0.05483434f, 
    -0.05600737f, 0.08254673f, 0.12271409f, -0.24449730f, 0.15961221f, 0.11533698f, 0.03591792f, 0.02858798f, 
    -0.08932445f, -0.12079267f, -0.10210261f, 0.04742181f, -0.16682392f, 0.30480704f, -0.15445286f, 0.23171213f, 
    0.20238099f, 0.08090730f, 0.01394892f, 0.21239576f, 0.05661529f, 0.06558287f, 0.11093576f, -0.20589153f, 
    0.17423284f, 0.28986886f, -0.19386394f, 0.16261053f, -0.13660872f, -0.02357893f, -0.04667197f, 0.11486212f, 
    -0.02901630f, 0.13011931f, -0.10318775f, 0.06602284f, -0.48024806f, -0.21283050f, -0.10234434f, -0.07859629f, 
    0.11349104f, 0.15182802f, 0.16552466f, 0.10720547f, 0.09084530f, 0.11000334f, 0.09127922f, 0.07081586f, 
    -0.21619099f, 0.15712215f, 0.01801930f, -0.33916026f, -0.03868467f, -0.06002107f, -0.07570329f, 0.05377228f, 
    0.13737130f, -0.02850019f, 0.03453670f, -0.33114493f, 0.11350127f, 0.12380963f, 0.26545134f, -0.02845789f, 
    -0.11427037f, -0.08315238f, 0.09983139f, 0.01976971f, 0.17677696f, -0.00383763f, 0.07272130f, 0.04742242f, 
    -0.31238878f, -0.12100639f, 0.06144919f, -0.07518429f, 0.25414070f, 0.00479929f, -0.17943880f, -0.16641168f, 
    -0.10716859f, -0.07313056f, 0.09335917f, 0.00021092f, 0.23545258f, -0.03858521f, -0.27455449f, 0.46889299f, 
    -0.12012713f, 0.09219705f, 0.05606627f, 0.14709945f, -0.02478108f, 0.03863718f, -0.02345537f, -0.01216737f, 
    0.29490629f, -0.09102292f, -0.15375318f, 0.14299546f, 0.19644696f, 0.15491468f, -0.08694915f, -0.07874877f, 
    -0.03103305f, 0.11653434f, -0.13571227f, -0.09175995f, -0.28713357f, -0.02355828f, -0.21419038f, 0.28332517f, 
    0.08212885f, 0.05604863f, -0.00945663f, -0.14354323f, 0.01910046f, 0.06173483f, -0.15907538f, 0.08988463f, 
    0.04752064f, -0.20251724f, -0.17304213f, 0.15657054f, -0.03934713f, 0.01428798f, -0.00745931f, 0.06406432f, 
    0.04780539f, -0.17214364f, 0.04652735f, 0.10991093f, 0.09788178f, 0.04043897f, 0.13197400f, 0.17554903f, 
    -0.24153413f, -0.09137454f, -0.10739858f, 0.03682794f, -0.03545329f, 0.02238617f, -0.05185679f, 0.15057184f, 
    -0.10193299f, -0.06256220f, 0.23318218f, -0.18823664f, 0.00214797f, 0.02408708f, -0.11920248f, 0.02394544f, 
    0.03765390f, 0.27891797f, -0.06233278f, 0.01372394f, -0.12082964f, -0.13648610f, 0.06568587f, -0.30935225f, 
    -0.16472936f, 0.08575402f, 0.08793871f, 0.04384564f, 0.05883619f, 0.15589945f, 0.06813402f, 0.12662910f, 
    0.48694488f, -0.34329003f, -0.05451642f, -0.20417014f, 0.05286792f, -0.12397580f, -0.05852751f, 0.07854257f, 
    0.12994212f, -0.09596527f, 0.02465999f, -0.25154528f, -0.38618976f, -0.23112069f, -0.49989098f, -0.23486261f, 
    -0.07885188f, 0.02867550f, 0.16133717f, 0.02494337f, 0.03341240f, 0.10446300f, -0.07559760f, -0.09540313f, 
    0.08186581f, 0.07033019f, -0.10467417f, -0.29005787f, -0.06890213f, 0.13526249f, 0.05903685f, 0.02422119f, 
    0.22054707f, 0.13693631f, 0.11665917f, 0.07199843f, -0.36858645f, 0.24777088f, -0.05381654f, 0.30998021f, 
    0.12440177f, 0.13594444f, -0.02409414f, 0.16744612f, 0.07393368f, -0.01999338f, -0.00434885f, 0.01184393f, 
    -0.07163726f, 0.01470482f, 0.03939712f, 0.01487243f, -0.00997259f, 0.01274835f, -0.04168893f, -0.03654826f, 
    0.04716971f, -0.03886244f, -0.02808378f, -0.02703231f, 0.00695575f, -0.05221181f, -0.07693189f, -0.00275340f, 
    0.02787437f, 0.05182022f, -0.05470407f, 0.02456723f, -0.05299441f, -0.01705686f, -0.05492127f, -0.03514662f, 
    0.04766584f, -0.04650602f, 0.05813690f, 0.03669893f, -0.04319450f, 0.06561339f, -0.02796520f, 0.05222636f, 
    -0.05682972f, -0.02786531f, -0.00436497f, -0.03645738f, 0.04035246f, -0.06427902f, -0.04768068f, -0.02395961f, 
    0.03695619f, -0.01015821f, -0.05448135f, 0.01443778f, -0.07766003f, 0.02302843f, -0.06965040f, 0.03180753f, 
    -0.07666552f, 0.04634767f, -0.00364636f, -0.00724203f, -0.05507984f, 0.04915445f, -0.02813704f, -0.05255483f, 
    -0.07540429f, 0.04113053f, -0.01415974f, -0.04357066f, -0.03464910f, -0.02308896f, 0.02693785f, 0.06001108f, 
    0.05867364f, -0.03506912f, 0.00542227f, 0.02178153f, -0.00395158f, -0.05245800f, -0.03857059f, 0.04390061f, 
    -0.03362903f, -0.02525952f, -0.00705773f, -0.01684865f, -0.03536826f, 0.01514243f, -0.00519508f, -0.04572542f, 
    -0.03345137f, 0.06835421f, 0.00472058f, -0.06564101f, -0.03750676f, 0.05641198f, 0.03135477f, 0.03709202f, 
    -0.00873351f, 0.05322180f, -0.07838529f, 0.00948781f, -0.04583779f, -0.01382229f, -0.03194033f, -0.01274150f, 
    -0.02499471f, 0.00091096f, -0.01025617f, -0.01985002f, -0.01132078f, -0.01015916f, 0.04220401f, 0.05128415f, 
    0.00905892f, 0.02414820f, 0.03055279f, -0.07641026f, -0.00879948f, -0.02389511f, 0.03930257f, 0.04301243f, 
    0.02757710f, 0.04957383f, 0.06671645f, -0.04830126f, -0.07954786f, 0.04540430f, -0.04970215f, 0.04947761f, 
    -0.03270896f, 0.04613549f, 0.02142719f, -0.03431905f, 0.02320121f, -0.01875247f, -0.04820180f, 0.05197052f, 
    -0.02741711f, -0.04832302f, 0.01793995f, -0.05074265f, 0.03863775f, -0.08292019f, -0.04042501f, 0.02620767f, 
    -0.00247364f, -0.02335157f, -0.03164999f, 0.05296990f, 0.01708812f, 0.04135300f, -0.03694692f, -0.01879886f, 
    -0.02128798f, -0.06192246f, -0.03877529f, 0.06784824f, -0.04844117f, -0.07765274f, -0.00951130f, -0.01718739f, 
    -0.01171521f, -0.02718854f, -0.05086081f, 0.04349934f, 0.03388025f, 0.05176849f, 0.04276661f, -0.03550256f, 
    0.04481768f, 0.05784584f, -0.03968611f, -0.01714535f, 0.05366344f, -0.00315673f, 0.01585742f, -0.02848541f, 
    -0.07787535f, -0.03428874f, -0.02792927f, -0.01500286f, -0.04497991f, -0.06136199f, -0.01658234f, -0.07342605f, 
    0.02922608f, -0.04933972f, -0.01783304f, -0.04602073f, 0.04293151f, 0.05511694f, -0.02848106f, 0.06323463f, 
    0.00544518f, -0.02666665f, -0.01284264f, -0.02362888f, 0.00941139f, 0.01550578f, -0.01226981f, -0.06541502f, 
    0.00117006f, 0.03063237f, 0.03916541f, 0.00214969f, -0.07539887f, -0.06780092f, -0.06213837f, 0.04103817f, 
    -0.05364241f, 0.01399156f, 0.03275027f, 0.00281910f, -0.03745282f, -0.06225957f, -0.00205714f, 0.04651798f, 
    -0.08186158f, -0.03445018f, 0.04302667f, 0.02854858f, -0.02716943f, -0.07915020f, -0.06935287f, 0.04936182f, 
    -0.03673315f, -0.05702011f, -0.00672064f, 0.03723713f, 0.05005668f, 0.04629643f, 0.00219981f, -0.01120469f, 
    -0.06145533f, 0.01343417f, 0.06191084f, 0.03030350f, -0.06028852f, 0.05431522f, -0.03495278f, 0.02798968f, 
    -0.03133258f, 0.02279707f, 0.01271033f, 0.00895739f, 0.02070809f, -0.00297345f, -0.05004263f, -0.03846976f, 
    -0.05151130f, -0.06622106f, 0.05362856f, -0.05822044f, 0.02083447f, -0.04663125f, -0.04195178f, 0.04903613f, 
    -0.06602955f, 0.05941866f, -0.05789436f, -0.00786467f, -0.07217657f, -0.08191529f, 0.01143946f, 0.05764028f, 
    0.02079195f, -0.05142226f, 0.04219723f, -0.05912078f, -0.00826982f, -0.02865374f, 0.02457977f, 0.02307981f, 
    0.02690643f, 0.02917741f, 0.04027512f, 0.02740829f, 0.01573474f, 0.01619091f, -0.00323464f, -0.05638965f, 
    0.01147024f, -0.01876164f, -0.04997492f, 0.04656325f, -0.04002633f, 0.06635053f, 0.04859174f, -0.03335369f, 
    0.03705063f, 0.01876058f, -0.01261047f, 0.05462935f, -0.03390568f, 0.04343407f, 0.06037899f, -0.02142987f, 
    -0.07845214f, -0.01503502f, -0.06352444f, 0.02562292f, -0.04188058f, -0.02529572f, -0.00982689f, -0.02897900f, 
    -0.04187172f, 0.03192509f, -0.04622615f, -0.07512327f, 0.01537365f, 0.03844025f, -0.07729822f, 0.02599419f, 
    -0.01376209f, 0.04322639f, 0.05755946f, 0.04007458f, 0.05533414f, 0.03170058f, 0.01729655f, -0.03640433f, 
    0.00184861f, 0.05814397f, 0.03134666f, -0.01813464f, 0.05412672f, -0.06949982f, 0.03527327f, 0.05888381f, 
    -0.00361593f, 0.06051113f, -0.08012228f, 0.01971584f, -0.05176903f, 0.05019064f, -0.04314704f, -0.08006424f, 
    -0.06495567f, 0.01414206f, -0.07329084f, -0.04358185f, -0.07841001f, 0.04827388f, 0.00568001f, -0.03350778f, 
    0.04396469f, 0.04135856f, -0.02821206f, -0.07556017f, -0.06496714f, 0.00581483f, -0.04173147f, 0.05470349f, 
    0.04803457f, -0.06921312f, -0.04114358f, -0.07140885f, -0.02630271f, 0.03019023f, 0.04930270f, -0.00226792f, 
    0.04364503f, -0.05455882f, 0.02177023f, -0.07545764f, -0.03784125f, 0.05899329f, -0.04699901f, 0.01007539f, 
    -0.06758450f, 0.05646168f, -0.05718651f, -0.00945022f, -0.08285437f, -0.02749124f, -0.06497968f, 0.04153858f, 
    -0.05912693f, -0.06037356f, 0.02248347f, -0.08087853f, -0.01102581f, -0.04961478f, -0.04374659f, -0.06073282f, 
    0.03770023f, -0.07420694f, -0.01154795f, -0.01314341f, -0.02638101f, 0.05924136f, -0.05322041f, 0.05868826f, 
    0.28340784f, 0.39674672f, -0.25756720f, 0.27050430f, 0.13851102f, 0.13142899f, 0.03738621f, 0.12171920f, 
    -0.02046604f, 0.11122242f, 0.08217156f, -0.01875446f, -0.44347668f, -0.35658073f, 0.07066011f, -0.06974961f, 
    0.21824785f, 0.03543062f, 0.09266061f, 0.17841393f, -0.18653749f, -0.00991180f, -0.06072044f, 0.17194663f, 
    0.01200163f, 0.21469609f, 0.03830676f, -0.32586020f, -0.14870003f, 0.00023069f, -0.05982164f, -0.08367082f, 
    0.07102012f, 0.04299695f, 0.02582934f, 0.09455088f, -0.07112382f, 0.05210887f, 0.05244939f, -0.00836883f, 
    -0.04394272f, -0.02188370f, 0.01458719f, -0.07828653f, 0.21066260f, 0.05677048f, -0.11813846f, -0.07435599f, 
    -0.22336558f, 0.04791520f, 0.10615601f, -0.06690447f, -0.09699609f, -0.01062563f, -0.02540374f, -0.16473572f, 
    0.06014939f, -0.02570876f, 0.15980431f, 0.04234834f, 0.49345285f, 0.28807721f, 0.08646122f, 0.38362262f, 
    0.07010111f, -0.00350913f, 0.02393581f, 0.02139340f, 0.03759870f, -0.04161065f, 0.13722877f, 0.04366895f, 
    -0.11060197f, -0.05446066f, -0.08585813f, 0.17411812f, 0.19816622f, 0.13107796f, -0.03496475f, 0.03511208f, 
    -0.07795511f, 0.09318122f, 0.17785211f, 0.17925338f, 0.08045834f, -0.00969156f, -0.18123084f, 0.22371912f, 
    -0.06610083f, 0.05188964f, -0.13418151f, -0.07976817f, -0.02856711f, -0.06936735f, 0.21292923f, 0.06044282f, 
    -0.58578217f, -0.00225780f, -0.17723136f, -0.13127649f, 0.10122938f, 0.06454369f, 0.08936474f, 0.17939280f, 
    0.02867769f, -0.08797327f, -0.06425150f, -0.01007214f, 0.23184541f, 0.17100321f, 0.20411524f, 0.07423255f, 
    0.18292464f, 0.15362097f, -0.10187531f, 0.10611023f, 0.09194067f, -0.00709703f, -0.02351268f, 0.01702433f, 
    -0.40258124f, 0.16751590f, 0.30517507f, 0.03901852f, -0.11749337f, -0.07719690f, -0.05254214f, -0.05547676f, 
    0.04406561f, 0.00761000f, 0.02826416f, -0.01600599f, -0.23731449f, -0.33108222f, -0.00605500f, 0.13483846f, 
    -0.04643500f, 0.08917184f, -0.05102132f, 0.12576634f, 0.03311779f, -0.01417908f, 0.04165385f, 0.09532462f, 
    -0.38053930f, -0.12513009f, 0.01375849f, -0.14936358f, 0.16208535f, -0.22195731f, -0.06109544f, 0.26099119f, 
    0.01263269f, -0.01291532f, 0.02141366f, -0.01328819f, -0.45068496f, -0.18091664f, -0.14372487f, -0.06568390f, 
    0.13559595f, 0.07857273f, 0.04551180f, 0.04860761f, 0.06077911f, -0.00227840f, -0.09357885f, -0.12648155f, 
    -0.04674980f, -0.07981405f, -0.07149329f, -0.06429149f, 0.24087572f, 0.07350361f, 0.01863400f, -0.04578779f, 
    0.05483636f, -0.04585639f, -0.00491627f, -0.09611843f, -0.17821853f, 0.22092380f, 0.03074264f, 0.10976188f, 
    0.15190122f, 0.06549728f, 0.00014073f, 0.06527621f, 0.11037911f, 0.19122183f, -0.03876372f, 0.09295190f, 
    -0.26032779f, 0.17276819f, -0.03360415f, 0.14928764f, 0.11420930f, -0.07800566f, -0.05825734f, 0.11255896f, 
    -0.01851236f, -0.03082558f, 0.16093194f, 0.06047256f, 0.04851973f, -0.08691259f, 0.15314847f, -0.19241440f, 
    0.06861041f, 0.00800221f, -0.02065869f, 0.05376329f, 0.00864055f, -0.04969214f, -0.00875961f, -0.02535487f, 
    -0.09140310f, -0.10785805f, 0.18823150f, -0.39868724f, 0.10804477f, -0.02423989f, 0.04914703f, 0.02281750f, 
    0.12868629f, -0.00271359f, -0.06733020f, 0.01305456f, 0.05035261f, -0.03390026f, 0.05356973f, 0.16196302f, 
    0.08005355f, -0.02298050f, 0.05397011f, -0.11244502f, 0.12787639f, 0.05520469f, 0.08639792f, 0.13343467f, 
    0.21725838f, -0.04257620f, 0.27971086f, -0.29109177f, 0.17572275f, 0.23801132f, -0.06553178f, 0.04297924f, 
    0.16816415f, 0.17624943f, -0.12198206f, 0.14085355f, -0.06206579f, -0.33035979f, -0.15390718f, 0.52544099f, 
    -0.04754944f, -0.13509986f, -0.02098190f, 0.02593944f, 0.13918757f, 0.05299332f, -0.01753249f, -0.01253615f, 
    0.03165658f, 0.32191852f, -0.19923751f, 0.20682643f, 0.09464633f, -0.00990892f, 0.12099047f, 0.04251331f, 
    0.02077668f, 0.10304113f, -0.01363120f, -0.09894928f, -0.28805184f, 0.14716609f, 0.03099573f, 0.21611713f, 
    -0.01541410f, -0.02274553f, -0.07794436f, 0.12853116f, 0.03114298f, -0.08978415f, 0.10196251f, 0.06656551f, 
    -0.50030881f, 0.12966320f, -0.11815714f, 0.10973337f, 0.08198306f, -0.10853678f, 0.01321751f, 0.14956690f, 
    -0.02787015f, 0.05769035f, -0.11256772f, 0.02822788f, 0.36023408f, -0.26369986f, -0.00852598f, 0.05179244f, 
    -0.00067148f, -0.02025759f, -0.00602335f, 0.04596283f, 0.05046884f, -0.03968660f, -0.00975084f, 0.05231509f, 
    0.34832892f, -0.17637813f, 0.16274349f, -0.03227418f, 0.06976493f, 0.16699731f, 0.16238214f, 0.01061277f, 
    0.04453669f, -0.05666650f, 0.14413166f, -0.00947727f, -0.00149825f, -0.09898859f, 0.11665922f, -0.00953785f, 
    -0.05560718f, 0.05161145f, 0.05408894f, 0.05106815f, 0.05140783f, 0.06208057f, 0.00382544f, 0.01754216f, 
    -0.38490760f, 0.11101235f, -0.03707986f, -0.12342387f, 0.06555614f, 0.01341861f, 0.00814587f, -0.02151496f, 
    -0.03695424f, -0.02605603f, 0.00642414f, -0.07493313f, 0.08955229f, -0.08036008f, -0.12796515f, -0.13508044f, 
    -0.06690567f, 0.00520182f, 0.17324288f, 0.04348443f, 0.09983260f, 0.08194064f, 0.06518026f, 0.12463687f, 
    0.14620429f, 0.16173317f, -0.07976609f, -0.05749344f, -0.10407488f, 0.05280553f, 0.04731837f, -0.05898054f, 
    0.08690125f, 0.15543076f, -0.06538358f, -0.04613280f, -0.24601860f, 0.09897809f, 0.03730384f, 0.23763587f, 
    0.14922190f, -0.09039105f, 0.03052796f, 0.19703497f, -0.02260435f, -0.08358241f, 0.01965591f, 0.11909271f, 
    -0.13404903f, -0.22805150f, -0.08620787f, 0.04733814f, 0.00044964f, -0.08709814f, 0.20255613f, 0.04129181f, 
    0.19148487f, -0.03635545f, 0.12105730f, -0.02509750f, -0.05606786f, 0.10960758f, -0.17842871f, -0.15405276f, 
    -0.19332530f, 0.02986815f, 0.11252573f, -0.00454409f, -0.04790769f, 0.05404705f, -0.07241710f, 0.02339074f, 
    0.35855550f, 0.10291024f, 0.01866905f, -0.06548594f, -0.11852297f, -0.04932577f, 0.01911588f, 0.12049761f, 
    -0.07708350f, 0.12914382f, -0.03143179f, 0.10041590f, -0.12492719f, -0.16703551f, 0.17511159f, 0.04727714f, 
    0.06051827f, 0.07190351f, 0.00853797f, -0.05685220f, 0.01331636f, -0.10559443f, -0.12491702f, -0.15509430f, 
    -0.11716966f, -0.12435789f, 0.04267212f, 0.00351081f, -0.07223889f, 0.03540420f, -0.02217301f, -0.01464415f, 
    0.08500154f, 0.11216397f, 0.07206945f, 0.00563590f, 0.22243862f, -0.01683846f, 0.13257511f, 0.16892700f, 
    -0.16053252f, 0.13321912f, 0.02266747f, 0.17196521f, 0.12110299f, 0.06056887f, 0.19435748f, -0.03037227f, 
    0.19546862f, -0.06298792f, -0.10388543f, 0.09834464f, 0.03454373f, 0.04401503f, 0.09505109f, -0.02419076f, 
    -0.06958456f, 0.08920000f, 0.20925821f, 0.21274315f, 0.16220108f, 0.16151828f, 0.13208304f, -0.02818615f, 
    0.11085296f, 0.05298788f, 0.01634240f, -0.04018680f, 0.14950456f, -0.06053592f, -0.02036903f, 0.02947156f, 
    -0.19864112f, 0.25353807f, -0.08172289f, -0.18665029f, -0.07563245f, -0.14714535f, -0.06555729f, -0.10003845f, 
    -0.02934117f, 0.02474749f, 0.07798365f, -0.02779266f, 0.02516034f, -0.41210181f, -0.03296940f, 0.16334184f, 
    -0.14379011f, 0.02865207f, -0.11027546f, 0.10203533f, 0.00357484f, 0.02507261f, 0.03910417f, 0.12434534f, 
    0.46348703f, -0.28705043f, 0.10718764f, 0.30542350f, 0.01274530f, -0.06221267f, -0.04824911f, 0.10508318f, 
    0.25431249f, 0.00967104f, -0.01458585f, 0.00689923f, -0.17021903f, 0.07056883f, -0.04870204f, 0.09201968f, 
    -0.15707204f, -0.07923253f, 0.03310803f, -0.03320845f, 0.15465784f, 0.08058072f, -0.13644406f, 0.12260595f, 
    -0.50268811f, 0.04037840f, 0.23277102f, -0.05238915f, -0.05186534f, -0.09487940f, -0.00139655f, 0.04426589f, 
    0.12637159f, -0.05872012f, -0.00990204f, 0.15961289f, 0.17002721f, 0.29438430f, 0.21080434f, -0.07718141f, 
    -0.07909667f, -0.16585705f, -0.03621224f, 0.07909825f, 0.06785840f, 0.13985544f, 0.00551204f, 0.08053448f, 
    -0.36269388f, 0.37545344f, 0.05499043f, -0.09356453f, -0.04691297f, -0.02135944f, -0.06466613f, 0.09541708f, 
    -0.02283848f, 0.09444913f, -0.15489435f, 0.07648609f, 0.12548521f, 0.04688343f, 0.03371575f, -0.00676989f, 
    -0.03056801f, -0.03312888f, 0.04105042f, 0.20388389f, -0.02484856f, -0.11010323f, 0.13669890f, -0.07370464f, 
    -0.01581204f, -0.03388369f, -0.04782909f, 0.05970432f, -0.01768365f, -0.04539046f, -0.07507645f, -0.05066872f, 
    -0.01527413f, -0.04248725f, 0.01963282f, -0.05716824f, 0.02702930f, -0.04019378f, 0.05283416f, -0.04958789f, 
    -0.03693715f, 0.03246689f, 0.05448718f, -0.05248285f, -0.05944048f, -0.01373035f, -0.05870834f, -0.05744294f, 
    -0.02777547f, 0.05109053f, -0.02487141f, -0.02124335f, -0.04819704f, 0.06067084f, 0.05792033f, -0.06553350f, 
    -0.01446418f, -0.03932558f, 0.01166179f, -0.04665053f, -0.06562406f, -0.04033967f, 0.02041066f, -0.07545661f, 
    0.05484973f, -0.00324153f, 0.04907868f, -0.00329524f, -0.06199243f, 0.05294256f, -0.04217143f, -0.06550131f, 
    0.05053832f, -0.03826003f, -0.01759039f, -0.04059504f, 0.03151897f, -0.06007830f, -0.00643396f, -0.00991726f, 
    0.03087209f, 0.05124343f, 0.01873467f, -0.00454854f, 0.04238502f, 0.04794174f, 0.00419424f, -0.02086809f, 
    -0.04692953f, -0.01088122f, -0.03053319f, 0.05259249f, -0.04715453f, 0.00215472f, 0.00785440f, 0.02462335f, 
    -0.08223794f, -0.05665767f, 0.01426443f, -0.06788827f, -0.07226723f, 0.02693920f, -0.04154038f, 0.00081408f, 
    -0.07680349f, 0.03036772f, -0.04731813f, -0.07776898f, 0.00554331f, -0.03397826f, -0.05011082f, -0.06059432f, 
    0.02080111f, 0.01060171f, -0.02592939f, -0.06905529f, 0.04838044f, -0.07541917f, -0.03872792f, -0.03941345f, 
    -0.05444941f, -0.07184613f, -0.08528072f, -0.01172758f, -0.07538457f, -0.05061799f, -0.05837866f, -0.00816234f, 
    0.02589143f, -0.00392870f, 0.00862350f, 0.00378372f, -0.06572803f, -0.04344152f, 0.01023544f, -0.06669397f, 
    -0.04133123f, 0.06211821f, 0.06284009f, -0.07794670f, -0.03363033f, 0.04965094f, -0.05052121f, -0.03902116f, 
    -0.06119829f, -0.07155225f, 0.03763283f, 0.04051082f, -0.01760278f, 0.04333854f, -0.04940413f, -0.05173018f, 
    0.04837452f, 0.03340239f, 0.05280146f, 0.02030592f, -0.02500799f, -0.00841114f, 0.01987556f, 0.04969042f, 
    -0.01613610f, 0.02843413f, -0.08802209f, -0.07946607f, -0.01623895f, -0.00493577f, -0.06477047f, -0.07065596f, 
    0.00280208f, -0.02607686f, -0.04481858f, 0.00608380f, 0.05543181f, -0.01626475f, 0.03723272f, 0.05452498f, 
    -0.02681227f, 0.02899756f, 0.00331683f, 0.01644429f, -0.08207077f, -0.08617214f, 0.05864144f, 0.00533070f, 
    -0.00325331f, -0.03135323f, -0.03005690f, -0.06148377f, -0.04305772f, -0.02916175f, 0.05491759f, 0.06666881f, 
    0.03700676f, 0.05481181f, 0.00243548f, 0.04985576f, -0.00995274f, 0.00299034f, -0.07146565f, -0.05993036f, 
    0.04896881f, -0.06506909f, -0.01148948f, 0.02840192f, -0.04064278f, 0.05632281f, -0.06492801f, -0.00839485f, 
    -0.05395926f, 0.01436703f, 0.02337486f, -0.00982057f, -0.01853987f, 0.05585029f, -0.00812434f, -0.01969578f, 
    -0.06581970f, -0.06139270f, -0.06968436f, -0.06932842f, -0.03421092f, 0.01019259f, -0.06427921f, -0.06072569f, 
    -0.06168519f, 0.00859995f, -0.06871785f, 0.04153552f, -0.05768028f, -0.00264151f, 0.06132336f, -0.00437397f, 
    0.05743773f, 0.06169353f, 0.04112647f, 0.00592859f, -0.00663585f, -0.03551590f, -0.05662042f, -0.03203831f, 
    0.00322832f, 0.05208772f, -0.02429505f, 0.03814123f, 0.03814634f, 0.02531271f, -0.04951657f, 0.02334232f, 
    0.03828160f, 0.04110100f, -0.03220550f, -0.04038498f, -0.06554735f, 0.04314502f, -0.04358623f, -0.06838384f, 
    0.00144893f, 0.04038431f, 0.02632293f, -0.03592764f, 0.05401581f, -0.05138275f, -0.05665540f, -0.04959229f, 
    -0.04655462f, 0.05709117f, 0.02380932f, 0.02450637f, 0.04745767f, -0.06340594f, 0.05266347f, -0.07348370f, 
    -0.04221073f, -0.07295585f, 0.02453953f, -0.00430162f, 0.05867950f, 0.01622890f, 0.05952093f, -0.02005771f, 
    0.03992483f, 0.01628447f, -0.07555152f, 0.03868755f, -0.02268219f, 0.05205141f, 0.02130161f, 0.02426121f, 
    -0.07444651f, -0.03554184f, -0.06963153f, -0.02224610f, 0.01787446f, 0.02595347f, -0.06912590f, 0.06923771f, 
    0.00756021f, -0.02245446f, 0.03944211f, -0.07319832f, 0.03759911f, -0.03111749f, 0.04275288f, -0.06471263f, 
    -0.02910155f, -0.04404033f, -0.00578275f, -0.07856286f, 0.05148244f, 0.00179408f, -0.03941906f, -0.02521919f, 
    -0.07892012f, -0.06457895f, -0.07156830f, 0.05509700f, -0.04665304f, 0.05995357f, -0.02865512f, 0.02972339f, 
    -0.04321183f, 0.06380730f, -0.03141997f, -0.04372275f, -0.04659032f, -0.05876064f, -0.05789072f, 0.00092666f, 
    0.04043166f, 0.03216451f, -0.06201616f, -0.05674595f, -0.02376291f, 0.04985120f, 0.03416154f, 0.00774417f, 
    0.03487689f, -0.05014628f, -0.04813153f, -0.06905852f, 0.04982857f, 0.01158639f, -0.06567843f, -0.05469783f, 
    0.00799179f, 0.02198887f, 0.05957138f, 0.03847849f, -0.00214406f, -0.06862847f, -0.04457018f, 0.01330395f, 
    -0.04962307f, 0.02315862f, -0.04331370f, -0.03996066f, 0.03261872f, -0.01001202f, -0.00259820f, 0.05541552f, 
    0.00865538f, -0.02772050f, -0.01721886f, 0.03490474f, -0.05987783f, -0.00952800f, -0.07103465f, 0.02512975f, 
    -0.06198998f, 0.03314373f, -0.06348434f, 0.00565918f, -0.01799205f, -0.04142671f, 0.03205286f, 0.01579476f, 
    -0.07789594f, 0.02289881f, -0.05119936f, 0.01827814f, -0.00828887f, 0.05326483f, -0.06335654f, 0.02751630f, 
    -0.01354716f, -0.01420520f, -0.06621718f, 0.02718833f, 0.00821994f, -0.04975945f, -0.07706112f, 0.01500040f, 
    -0.06929622f, 0.01950804f, 0.04503037f, -0.07074127f, 0.04087865f, 0.02608179f, -0.07043589f, -0.07318369f, 
    0.04249859f, -0.06482054f, -0.05703950f, -0.07300490f, 0.05610477f, -0.06248370f, 0.03485169f, 0.01149121f, 
    0.09233782f, -0.20029826f, 0.02785318f, -0.01194807f, 0.03545592f, -0.05313907f, 0.07229856f, -0.09772689f, 
    0.12512885f, -0.07030007f, -0.16079691f, 0.03043004f, -0.05113129f, -0.11826996f, 0.02917040f, -0.01329200f, 
    0.00123698f, 0.18515064f, -0.00198365f, 0.01917518f, -0.00376640f, 0.08488734f, -0.03229057f, 0.10379985f, 
    0.38539392f, 0.10387181f, -0.02417469f, 0.24875334f, -0.05067852f, 0.01116954f, -0.07190146f, 0.12814657f, 
    -0.05475834f, -0.08085960f, 0.05338274f, 0.14425409f, -0.14251254f, 0.05469014f, -0.02109307f, 0.12197730f, 
    0.08681373f, 0.10325047f, -0.07410210f, -0.01043254f, 0.03371028f, -0.11596813f, -0.18067339f, -0.19405971f, 
    0.07697105f, 0.25159669f, -0.14566907f, 0.11325295f, -0.07423793f, 0.15751056f, -0.02669812f, -0.17693232f, 
    0.15985270f, -0.12500906f, 0.17369333f, -0.10410310f, -0.08157168f, 0.12842710f, 0.06344275f, -0.29086816f, 
    0.08459459f, -0.04901876f, 0.10721547f, -0.07482385f, 0.00808870f, 0.11074065f, 0.16850224f, 0.05007383f, 
    -0.21556062f, 0.16427127f, 0.14316648f, 0.03109627f, -0.01879669f, -0.04669873f, 0.03611835f, -0.04608488f, 
    -0.05011890f, 0.06003676f, 0.27077904f, 0.16780168f, 0.18779929f, -0.10395505f, 0.42714778f, -0.04575037f, 
    0.06509411f, 0.00412470f, 0.19381146f, -0.03890863f, 0.21321297f, 0.07677498f, 0.01435101f, -0.02473254f, 
    -0.08164084f, 0.05460463f, 0.17192130f, -0.04774787f, 0.03146053f, -0.00844047f, 0.00121394f, -0.15320928f, 
    0.06142816f, 0.13174361f, 0.02761323f, -0.04328970f, -0.20950289f, 0.53195596f, -0.07308921f, 0.00477996f, 
    0.16486740f, 0.05880174f, 0.00997209f, -0.02710057f, -0.12119180f, -0.02633296f, -0.03844190f, -0.11632130f, 
    -0.06026534f, 0.53285593f, -0.07372406f, 0.18725321f, 0.06323233f, -0.05399020f, -0.14921898f, -0.03758997f, 
    0.03587800f, -0.03781316f, 0.02048750f, 0.11813954f, 0.08301075f, 0.15739632f, 0.02747035f, 0.04432150f, 
    -0.02831040f, 0.09826573f, 0.11682548f, 0.05494460f, -0.07056168f, 0.08185615f, -0.06879487f, 0.05816658f, 
    -0.32304600f, 0.04023124f, 0.13537170f, 0.08064393f, 0.02214583f, 0.09826222f, 0.14226608f, -0.00491682f, 
    -0.01242143f, 0.15821673f, 0.08579768f, 0.33141705f, -0.13355693f, -0.04684474f, 0.25742802f, 0.09281385f, 
    0.15927164f, 0.09477426f, -0.07212676f, -0.23876402f, 0.10441810f, 0.05560530f, -0.06329593f, -0.00156778f, 
    -0.07471010f, -0.03346799f, 0.26780894f, 0.23603657f, 0.01924054f, -0.13643089f, 0.14277637f, 0.07161239f, 
    -0.25885329f, -0.12279964f, -0.03483724f, 0.15852308f, -0.02279868f, -0.03087715f, 0.32630831f, -0.12209843f, 
    -0.15075037f, 0.09221403f, 0.05359140f, -0.06902161f, 0.03610551f, 0.14901946f, -0.18998870f, -0.10378243f, 
    -0.00183904f, -0.06357226f, -0.04305768f, 0.03106769f, -0.04615571f, 0.03705829f, 0.01131673f, -0.05546466f, 
    -0.00839700f, 0.02217812f, 0.03681086f, -0.07352798f, -0.00329218f, -0.00029977f, 0.04018351f, -0.05450638f, 
    0.01089483f, -0.01981498f, -0.04538552f, -0.05826510f, 0.05395140f, -0.00390577f, 0.01415938f, -0.04999314f, 
    -0.05386611f, -0.02885583f, -0.04009163f, -0.00215263f, 0.03464283f, -0.01703716f, 0.03341928f, 0.00611112f, 
    -0.03737745f, -0.05403090f, 0.05127447f, 0.00172281f, -0.01467850f, 0.02289341f, -0.01797097f, -0.03051867f, 
    -0.04928154f, 0.03901111f, 0.06311662f, -0.07151932f, 0.03336433f, -0.08253219f, -0.02006632f, -0.06549907f, 
    -0.04049156f, -0.01144786f, 0.01687842f, -0.01198928f, -0.04564972f, -0.06934430f, -0.03301648f, 0.03775365f, 
    -0.00845354f, -0.03698330f, -0.07276244f, -0.04953584f, -0.02482698f, 0.03530172f, 0.05195992f, -0.04752162f, 
    -0.03273418f, 0.00098612f, 0.05843495f, -0.03417018f, -0.07606968f, 0.03357664f, 0.05015094f, 0.00629475f, 
    -0.08599864f, -0.00992269f, -0.06449230f, -0.07211076f, -0.01575540f, 0.06312164f, -0.06827396f, 0.00029326f, 
    -0.00656789f, -0.02573247f, 0.06573818f, -0.04994400f, -0.02609314f, -0.02323092f, -0.04493890f, 0.02967152f, 
    0.01060318f, -0.05069426f, -0.06096715f, 0.04389875f, -0.00566381f, -0.05029455f, 0.04721177f, -0.02080724f, 
    -0.07183634f, 0.05331179f, 0.06163050f, -0.05397332f, 0.06191640f, 0.05957397f, 0.05052828f, -0.04379232f, 
    -0.01684304f, -0.02266864f, 0.04585948f, 0.00733657f, -0.04244202f, 0.02750709f, -0.02214357f, -0.04013570f, 
    -0.05291290f, -0.06942456f, 0.04864738f, -0.04755216f, 0.01367257f, 0.01753899f, -0.01636261f, -0.07469838f, 
    0.00503276f, 0.03051133f, 0.01502076f, -0.06967470f, -0.03932820f, -0.02445814f, -0.05466342f, -0.08012345f, 
    0.04043570f, 0.01842046f, 0.03176498f, 0.01475998f, -0.02379642f, 0.00171486f, 0.02552253f, -0.00212438f, 
    0.01883777f, 0.05412114f, 0.03710762f, 0.06454659f, 0.04279678f, -0.02827409f, 0.04613543f, -0.05727997f, 
    0.05107190f, -0.04959220f, 0.03063963f, 0.05098336f, -0.05902044f, 0.06491134f, 0.03455241f, -0.02984991f, 
    0.02965838f, -0.05985083f, -0.04893043f, 0.01742870f, -0.02015406f, 0.01526044f, -0.00501788f, 0.03049524f, 
    -0.05187022f, 0.03472024f, -0.04372251f, 0.00873479f, 0.02084005f, -0.01690236f, -0.00324518f, -0.01113081f, 
    -0.05486026f, -0.04748759f, -0.05872940f, -0.02120110f, -0.02622558f, -0.07496032f, -0.00835472f, 0.02654635f, 
    0.06304276f, -0.03644314f, -0.06803129f, 0.00196059f, 0.04834050f, -0.05123031f, -0.03555403f, -0.06769951f, 
    0.06388292f, -0.04173291f, 0.03684445f, -0.03449588f, 0.03358009f, -0.03742290f, 0.04141675f, -0.02707682f, 
    -0.05309941f, 0.00921078f, -0.01416712f, 0.02273063f, 0.00967422f, -0.02609794f, -0.02517395f, -0.00577119f, 
    -0.03453930f, 0.06306752f, 0.05622091f, 0.04807046f, -0.04867460f, 0.00019196f, 0.05198319f, -0.04929586f, 
    0.03762764f, 0.02556929f, 0.02226384f, 0.02064683f, -0.03433874f, -0.02265630f, 0.03964715f, 0.04257692f, 
    -0.06074428f, -0.04647144f, -0.02505653f, 0.02783540f, 0.05644028f, -0.07249124f, 0.01646054f, -0.03572310f, 
    0.00074616f, -0.01111239f, 0.00061436f, 0.04304922f, -0.05728618f, 0.01435279f, 0.02824550f, -0.01316707f, 
    -0.01977214f, 0.03317027f, -0.07547227f, -0.02508756f, -0.06092542f, 0.01483814f, -0.05624610f, -0.04762725f, 
    0.04100478f, -0.07551914f, 0.04091007f, -0.00562795f, -0.07644230f, 0.06750456f, 0.01654081f, -0.03642407f, 
    0.03865173f, -0.06234112f, -0.05189746f, -0.00697317f, 0.00411939f, -0.05063260f, -0.07003418f, -0.02148600f, 
    0.03596692f, -0.07349164f, 0.00200123f, -0.01006249f, -0.04628495f, -0.03051353f, 0.02745393f, 0.05005221f, 
    -0.06856119f, 0.00140072f, -0.04470769f, 0.00335463f, -0.00609297f, 0.04764524f, -0.03124051f, -0.05593368f, 
    0.06250908f, -0.06902234f, -0.01885388f, -0.01512902f, -0.03387056f, 0.04425779f, -0.04636590f, -0.01615220f, 
    -0.04974506f, -0.01536174f, -0.06504124f, -0.01669246f, 0.01069279f, 0.00517217f, 0.01746823f, 0.04179806f, 
    -0.02949548f, -0.07713091f, -0.03856529f, -0.03759288f, -0.07611760f, 0.05841827f, -0.06770724f, 0.02270487f, 
    -0.01211244f, -0.00505665f, -0.02208399f, 0.03688637f, 0.03176517f, -0.05251198f, -0.00835247f, 0.04947907f, 
    0.04034271f, -0.01639550f, 0.04763949f, -0.02198140f, -0.00706287f, -0.01133932f, -0.03918704f, -0.06629097f, 
    0.04885414f, -0.05497842f, 0.01423112f, -0.02117340f, -0.06352696f, 0.03065263f, -0.05481417f, 0.05575769f, 
    -0.02166967f, -0.03518060f, -0.06591871f, -0.06614871f, 0.01203815f, 0.03860808f, -0.07269739f, -0.06764416f, 
    0.06069181f, -0.03981982f, -0.06059092f, -0.06066175f, -0.02090026f, 0.00165684f, -0.03720673f, -0.05963696f, 
    0.00580808f, -0.01385351f, 0.04098855f, 0.00696167f, 0.05299980f, 0.04649159f, -0.01958729f, -0.00895173f, 
    -0.07183902f, -0.03573951f, -0.05127509f, 0.01620906f, 0.06031257f, -0.04344852f, 0.01595940f, -0.03361252f, 
    0.01221473f, -0.03021752f, 0.04925808f, 0.02318175f, -0.03132213f, -0.06481276f, -0.04145980f, 0.05336960f, 
    -0.06968558f, -0.06039269f, -0.03555357f, -0.02378649f, -0.03696392f, -0.04831436f, 0.04816590f, 0.01898817f, 
    -0.02026868f, -0.07689081f, -0.07405657f, -0.02156259f, -0.01442242f, -0.00439829f, 0.01128225f, 0.05565592f, 
    -0.07327225f, 0.04432124f, 0.05908107f, -0.02912689f, -0.05470968f, 0.02422730f, 0.00121832f, 0.01581035f, 
    0.33711824f, 0.02222342f, 0.08149115f, 0.01376583f, -0.04333611f, -0.06875897f, -0.02566742f, 0.05737787f, 
    0.11197244f, 0.05850447f, 0.07648371f, 0.01883880f, -0.26419789f, -0.05993716f, 0.14007860f, 0.36963594f, 
    -0.15044008f, -0.07380772f, 0.05030096f, 0.06440364f, 0.00931203f, 0.02896661f, -0.00578513f, -0.02809207f, 
    0.09647569f, 0.09590004f, -0.19885996f, 0.16548038f, 0.10008829f, 0.05106015f, 0.05159524f, 0.01490984f, 
    -0.01571784f, 0.15159628f, -0.03439857f, 0.02628165f, 0.20484504f, -0.00437690f, 0.05239815f, 0.03929701f, 
    -0.00670385f, 0.02581795f, -0.00878277f, 0.16963704f, 0.16589983f, -0.08158319f, -0.11253943f, 0.15327223f, 
    -0.17494124f, -0.06296111f, -0.05595222f, -0.15760204f, -0.03746248f, -0.00296278f, 0.10530785f, 0.07016199f, 
    0.00004154f, 0.06405254f, 0.05631128f, 0.04231017f, 0.12011416f, 0.03775306f, 0.10673796f, -0.17681268f, 
    0.10094714f, 0.05411733f, 0.06180879f, 0.14677928f, -0.05526034f, 0.03618621f, -0.13871209f, 0.02622236f, 
    0.45580357f, -0.40300032f, 0.00566869f, -0.06465551f, -0.10762434f, -0.04448564f, 0.06865087f, 0.11360763f, 
    0.02775170f, -0.11642284f, -0.05062443f, 0.05693315f, -0.04324556f, -0.02753705f, -0.13535932f, -0.14279340f, 
    0.06890751f, -0.05914387f, -0.22598417f, 0.07061395f, -0.12197623f, 0.05074215f, 0.11736831f, 0.04476614f, 
    0.34892440f, -0.06076997f, 0.19450049f, -0.16268550f, -0.03180833f, 0.13600448f, -0.00546442f, -0.11274325f, 
    -0.02519977f, -0.09187893f, 0.09215014f, 0.07402071f, 0.12666379f, -0.35856259f, -0.00433876f, 0.24035050f, 
    -0.03744998f, -0.07846818f, 0.05317973f, -0.09504651f, 0.04909082f, 0.08910448f, 0.07471688f, 0.02480222f, 
    0.01806541f, -0.36830351f, -0.16071671f, 0.03797184f, 0.15499374f, 0.04212990f, -0.06101481f, -0.14136522f, 
    0.12361163f, 0.05770595f, 0.12012184f, 0.05195501f, -0.17995876f, 0.06284150f, -0.07774540f, 0.04483132f, 
    0.00139160f, -0.15715183f, 0.02960943f, 0.03615196f, 0.23943681f, 0.04179354f, -0.01096275f, -0.06483441f, 
    0.32171544f, -0.10326453f, -0.18248466f, 0.09376556f, 0.01322490f, -0.02826268f, 0.07100836f, -0.01604935f, 
    0.11008200f, -0.17381020f, -0.04660055f, -0.04653931f, 0.43664682f, 0.40957218f, 0.09945194f, -0.05919532f, 
    -0.06379848f, -0.11097711f, -0.07470964f, 0.06367262f, -0.07161946f, -0.08951548f, 0.07886357f, -0.01460549f, 
    -0.13375175f, 0.05156244f, -0.08080328f, 0.27027941f, -0.16109434f, -0.09905490f, -0.01947836f, 0.09155277f, 
    0.03298684f, 0.17425953f, 0.07337790f, -0.09225461f, 0.20956483f, -0.02832514f, 0.09558455f, -0.14746203f, 
    0.05119809f, -0.02461428f, -0.10897635f, -0.00107011f, -0.10480564f, 0.00840860f, 0.15605213f, 0.19082583f, 
    0.20472123f, 0.18972069f, -0.16587661f, -0.03230575f, 0.15680313f, -0.04161350f, 0.06278654f, 0.10538967f, 
    0.08224314f, -0.03197092f, 0.12542623f, 0.01693371f, -0.19304214f, 0.10632981f, 0.16328508f, -0.07144429f, 
    -0.07241510f, -0.12379685f, -0.06008318f, -0.06397916f, -0.02808255f, 0.03073849f, 0.02151298f, -0.01749995f, 
    0.23925807f, 0.08332423f, -0.11721517f, -0.32840848f, 0.30697733f, -0.05136177f, -0.11205007f, 0.21491109f, 
    0.15501568f, -0.00806839f, 0.18833208f, -0.02037487f, 0.17050578f, 0.33640176f, -0.33195549f, -0.26516744f, 
    0.22127132f, 0.06624770f, 0.03197634f, -0.05507802f, -0.01273005f, 0.07539541f, -0.13827690f, 0.02264556f, 
    -0.10251939f, -0.24629201f, 0.04895208f, 0.06586882f, 0.02112956f, 0.08512628f, 0.10253081f, -0.01950950f, 
    0.15253527f, 0.14468607f, -0.02725604f, 0.00111876f, -0.55116308f, -0.20733489f, 0.04065091f, -0.21222638f, 
    -0.00574679f, -0.05866468f, -0.05505873f, -0.02356786f, 0.02503815f, 0.12385169f, -0.04552121f, 0.08389946f, 
    0.29206535f, -0.08901000f, -0.04083644f, 0.25554907f, 0.00324152f, -0.03329343f, -0.05927048f, -0.00276704f, 
    0.05710011f, -0.08563000f, 0.08941816f, 0.16429225f, 0.19682634f, 0.35743934f, 0.21659495f, 0.22817346f, 
    0.01096108f, -0.11594626f, 0.06241093f, 0.09325000f, -0.04118148f, 0.11044160f, -0.10941332f, -0.05646867f, 
    0.22589897f, -0.16950767f, 0.09054152f, 0.01937172f, 0.03756480f, 0.05645326f, 0.12256989f, 0.16009587f, 
    0.06022808f, 0.02046096f, -0.10158544f, 0.00142036f, -0.78413033f, -0.11301348f, -0.22924562f, -0.13167930f, 
    0.05197116f, 0.01087946f, 0.12677468f, -0.02078683f, 0.07230891f, 0.10692906f, 0.12507956f, 0.20868768f, 
    -0.02770287f, 0.16836074f, -0.16621947f, -0.22864583f, 0.13571340f, 0.28554791f, -0.10464205f, 0.03163307f, 
    0.13241097f, 0.01537091f, 0.02537853f, -0.04747850f, -0.39473653f, -0.06427918f, 0.19917572f, 0.11450257f, 
    0.00758894f, -0.12710804f, -0.01539618f, 0.14605908f, 0.04138585f, -0.06988099f, -0.04389011f, 0.13757278f, 
    0.13182326f, -0.05686069f, -0.09733466f, 0.10728417f, -0.12611151f, -0.14204699f, -0.13711059f, 0.16015057f, 
    -0.06971208f, -0.16618378f, 0.04441475f, -0.06534217f, 0.00924226f, -0.06389578f, 0.04934848f, -0.10427224f, 
    0.02598491f, 0.12862091f, 0.08434065f, 0.04957662f, 0.04175808f, -0.01950679f, 0.17537412f, 0.05068928f, 
    0.03643999f, -0.19877195f, -0.13205817f, 0.12665479f, -0.10594719f, -0.09794228f, -0.02547166f, -0.11655846f, 
    0.06590140f, -0.00132831f, 0.10655364f, -0.06375174f, 0.25912067f, 0.18072519f, 0.23294541f, 0.20148896f, 
    -0.07741204f, 0.01714358f, -0.03377510f, 0.13678482f, 0.08193918f, -0.10699702f, 0.02558215f, 0.07442405f, 
    -0.03162535f, -0.01312528f, -0.01769771f, 0.02820680f, 0.02374635f, 0.02231851f, 0.05148181f, 0.05651312f, 
    0.00080067f, -0.07551230f, 0.00409692f, -0.05893943f, -0.03961802f, 0.07215878f, -0.01475569f, 0.01423501f, 
    -0.05480212f, 0.05265033f, 0.02349304f, -0.02101172f, 0.00484020f, 0.02799666f, 0.05951852f, -0.00057446f, 
    0.02384493f, -0.07027495f, -0.00818900f, -0.03636559f, -0.00603497f, -0.04367080f, -0.03737238f, 0.06344954f, 
    -0.02710316f, -0.01637399f, 0.00080969f, -0.03689067f, -0.05077834f, -0.03758113f, 0.03095469f, -0.05356785f, 
    0.06165221f, 0.04074370f, -0.01089991f, 0.00749969f, -0.06787452f, -0.00125080f, 0.01208573f, 0.06208875f, 
    -0.05163822f, 0.02746406f, -0.02605671f, 0.01286018f, -0.06265118f, 0.03707748f, 0.03237943f, 0.04631872f, 
    -0.04633783f, -0.05957830f, -0.01378263f, -0.01414060f, 0.00551291f, -0.02291837f, -0.04623450f, -0.02017707f, 
    0.00341241f, -0.03511779f, -0.02678813f, -0.07561476f, -0.06871671f, 0.02436363f, -0.02965654f, -0.04384571f, 
    -0.03683532f, -0.07204309f, -0.02703622f, -0.04298439f, -0.02808991f, 0.02487047f, -0.02998052f, -0.06500639f, 
    -0.02197546f, 0.00672058f, 0.01872158f, 0.02814487f, 0.00869086f, -0.05945758f, -0.06935614f, -0.02622885f, 
    0.01059043f, -0.00095101f, -0.05818455f, 0.06185355f, 0.02143053f, 0.06194014f, -0.03198673f, -0.03624641f, 
    0.00304026f, -0.05176026f, 0.06045801f, 0.00618521f, 0.05953398f, -0.07390794f, 0.02136278f, 0.05724375f, 
    -0.04589011f, 0.04632426f, -0.05270603f, -0.03586844f, -0.00613179f, 0.00610750f, -0.07031527f, -0.03564674f, 
    0.00335129f, -0.01471742f, -0.05814882f, -0.03226549f, 0.02530436f, -0.00766192f, 0.03244335f, -0.02636652f, 
    -0.04557015f, 0.04367511f, -0.00369298f, -0.02794177f, -0.02907922f, 0.00491230f, 0.04201098f, -0.02785617f, 
    -0.00355193f, -0.07301215f, -0.05991985f, -0.05930584f, -0.06672175f, 0.01585957f, -0.07546891f, -0.07212054f, 
    -0.03739241f, 0.04250209f, 0.01188787f, 0.00638764f, 0.01364986f, -0.03167600f, 0.04180866f, 0.04967451f, 
    0.00593079f, 0.04164716f, -0.00786661f, 0.00673958f, 0.04789924f, -0.01417855f, 0.02086600f, 0.00759727f, 
    0.01650203f, 0.00569895f, -0.04399632f, -0.02567199f, -0.03437274f, 0.05559787f, 0.01015497f, -0.03734538f, 
    0.00664335f, -0.02935618f, -0.05451185f, 0.02179150f, 0.05566215f, -0.07055078f, -0.03418990f, 0.04389669f, 
    -0.05960094f, -0.05244431f, 0.01980368f, 0.00132181f, -0.01949349f, -0.04778223f, -0.00181371f, -0.07733085f, 
    -0.00898877f, 0.01579015f, 0.04484031f, -0.00535093f, 0.01931183f, -0.06413886f, -0.00782489f, -0.01075757f, 
    -0.05219825f, 0.03812975f, 0.05848499f, -0.06703167f, -0.07745366f, -0.06457701f, 0.06532399f, 0.03056427f, 
    0.16616972f, 0.10759268f, 0.16277696f, 0.23388965f, -0.08029623f, -0.11931071f, -0.11760139f, -0.01033757f, 
    -0.09548713f, 0.07133623f, -0.03465784f, -0.02704153f, 0.29813525f, -0.00546669f, 0.30287746f, -0.00461559f, 
    0.09456287f, -0.03753548f, 0.14494896f, 0.12564212f, 0.09471742f, 0.02793561f, -0.05726834f, -0.06471394f, 
    -0.45491469f, -0.28610876f, 0.10741644f, 0.01603136f, 0.01043854f, -0.08421745f, 0.00742749f, -0.18273680f, 
    -0.03593026f, 0.12764363f, -0.13324888f, -0.02063125f, 0.03833167f, -0.10471392f, 0.15580168f, -0.03314795f, 
    -0.12181954f, -0.00133475f, 0.01297790f, -0.06419811f, 0.00574649f, -0.01095071f, -0.01700265f, 0.08088251f, 
    -0.09708478f, 0.20172325f, -0.12431233f, -0.47767419f, 0.12558088f, -0.01191168f, -0.02789313f, 0.03877914f, 
    0.00707393f, -0.02969963f, -0.11362185f, 0.01592739f, 0.33621937f, 0.10317694f, -0.08778477f, 0.52167308f, 
    0.12478676f, 0.09919870f, -0.01590548f, 0.12825301f, -0.00458357f, 0.05304012f, -0.00425675f, -0.06506572f, 
    0.13369215f, -0.00963006f, 0.11548258f, 0.14540663f, 0.01462064f, 0.06418967f, -0.08711701f, 0.09790631f, 
    0.13073847f, 0.14209335f, -0.15119441f, -0.12063522f, -0.17540111f, -0.23922007f, -0.41246325f, 0.01669715f, 
    0.04056537f, 0.05485023f, -0.14429611f, -0.03660521f, -0.18810104f, -0.04093838f, -0.03455163f, -0.01605845f, 
    0.09673075f, 0.09756734f, 0.19148356f, 0.00429403f, -0.08590771f, 0.03374547f, -0.03433570f, -0.06008077f, 
    0.05473509f, -0.09680147f, 0.12354366f, 0.17654993f, 0.79243433f, 0.07676702f, 0.24366610f, 0.12186227f, 
    -0.03507294f, -0.08995104f, 0.02106012f, 0.00217143f, -0.04279027f, -0.07774372f, -0.00094719f, -0.09741353f, 
    0.11190201f, -0.21677466f, 0.02612300f, -0.12911755f, 0.00393195f, -0.13713205f, -0.07515845f, -0.10175678f, 
    0.00116485f, 0.14052108f, -0.00262496f, -0.06421138f, -0.01403421f, 0.09056520f, -0.11088120f, -0.16993736f, 
    -0.00407809f, -0.00798357f, 0.04752465f, 0.06882362f, 0.17538202f, -0.07086740f, 0.13211147f, -0.00901596f, 
    0.18080738f, 0.05234951f, 0.13780120f, -0.10348368f, 0.08088194f, -0.03498544f, 0.03727027f, -0.12846747f, 
    0.08466998f, 0.04812531f, 0.00486204f, -0.13102466f, 0.24676238f, 0.08707236f, -0.04530444f, -0.21072209f, 
    -0.02085981f, -0.11984877f, 0.09153145f, -0.07618538f, 0.01830824f, -0.12827152f, 0.00363653f, -0.06307150f, 
    0.38244858f, 0.37608245f, -0.08280153f, -0.14464420f, 0.06318875f, 0.11210003f, -0.05571476f, -0.05324000f, 
    0.08488744f, 0.09381901f, -0.01266255f, 0.11902741f, -0.11874337f, -0.22566400f, -0.07334135f, 0.17951256f, 
    0.09497959f, 0.01856986f, -0.05369690f, -0.00215653f, -0.02785848f, 0.05428206f, 0.05730022f, 0.18432143f, 
    0.18922305f, 0.49710533f, -0.06505807f, 0.15752076f, -0.02044960f, -0.01505748f, -0.08279164f, -0.02861719f, 
    -0.15522259f, -0.04514242f, -0.05379857f, -0.19388792f, -0.03242438f, 0.17267260f, 0.34635955f, 0.26106232f, 
    0.29425284f, -0.04279447f, 0.02940538f, 0.11926685f, -0.09230882f, 0.16550964f, 0.19117826f, 0.06934990f, 
    0.08578399f, 0.29031092f, -0.04825992f, -0.41933665f, -0.01527336f, -0.03580600f, -0.03457212f, -0.03519851f, 
    0.02743786f, 0.02577993f, -0.11207612f, -0.05318180f, -0.16457146f, 0.10597003f, -0.00388817f, -0.11609869f, 
    -0.10394884f, -0.02251598f, -0.05866711f, -0.06467971f, 0.04365129f, 0.11945710f, 0.09326483f, 0.05703170f, 
    -0.03894553f, -0.29462475f, 0.03965372f, -0.01847648f, 0.00729192f, 0.00747006f, -0.04456646f, 0.00130093f, 
    -0.09778163f, 0.03610934f, -0.08356584f, -0.02080439f, 0.35272565f, 0.02933013f, 0.08269382f, 0.52711207f, 
    -0.11519831f, 0.00327399f, 0.14480792f, -0.05415477f, 0.02444591f, -0.02102802f, -0.05191996f, -0.03320177f, 
    0.03740470f, 0.27276078f, 0.00192368f, 0.05496050f, 0.13439552f, 0.22608840f, -0.12574853f, 0.03536129f, 
    -0.04938752f, -0.03971779f, -0.00813942f, -0.07473742f, -0.20367369f, -0.15464489f, -0.18299112f, 0.07332657f, 
    -0.04379719f, 0.07134623f, 0.00662892f, -0.10789683f, -0.04522380f, -0.01085355f, 0.04256241f, -0.10898781f, 
    0.24668443f, -0.05291136f, 0.07703914f, 0.10268342f, 0.01470035f, 0.03830134f, -0.01668031f, 0.23940796f, 
    -0.07011480f, -0.00487473f, -0.10622335f, 0.14345303f, 0.03818987f, 0.02771830f, 0.32657692f, 0.10238205f, 
    -0.00572490f, 0.10960633f, -0.02398410f, -0.01097931f, -0.04346795f, -0.13128346f, -0.09706056f, 0.08216482f, 
    -0.36126703f, -0.05308843f, 0.11965700f, -0.01158875f, -0.11604436f, 0.05805345f, -0.03468110f, -0.02692828f, 
    -0.08932436f, -0.06812229f, 0.01033162f, -0.10063641f, 0.03067931f, -0.21625681f, 0.03892609f, 0.17346126f, 
    0.12710509f, 0.16528642f, 0.00344649f, 0.06805977f, -0.02610324f, -0.03936557f, 0.06142567f, 0.02064697f, 
    0.09711765f, 0.21391547f, 0.19510761f, -0.03378836f, -0.03320668f, -0.11684960f, -0.22321205f, 0.02905167f, 
    0.18990654f, -0.03585636f, -0.00837600f, -0.16225551f, 0.03012898f, -0.10400490f, 0.18855785f, 0.17588694f, 
    -0.01344910f, 0.03586602f, 0.01462221f, 0.17081290f, 0.15053640f, 0.07527387f, 0.11308885f, 0.14065434f, 
    -0.02177437f, 0.10502805f, -0.02211065f, -0.13529474f, 0.07952809f, 0.08931090f, 0.03694217f, -0.07800148f, 
    0.22581372f, -0.04057834f, 0.03163406f, 0.09870759f, -0.34384963f, -0.03161868f, -0.04354523f, -0.01360319f, 
    0.05295887f, 0.05474739f, -0.03328982f, -0.11183427f, 0.03445143f, -0.05875164f, -0.03703542f, 0.04862664f, 
    0.05373552f, 0.00758252f, -0.00487115f, 0.03571244f, -0.00245510f, 0.03290991f, -0.03219709f, 0.05818478f, 
    0.02113028f, -0.05962330f, 0.02939988f, -0.03895392f, -0.02284070f, 0.06007785f, 0.04200089f, 0.01364858f, 
    0.05946911f, -0.01670195f, 0.01010265f, -0.03681419f, 0.03493780f, -0.03922380f, -0.03535318f, -0.05408402f, 
    -0.06121778f, 0.05159867f, 0.01298507f, -0.01065744f, -0.05161719f, -0.03134906f, -0.01632366f, -0.06743664f, 
    0.00566781f, -0.04193547f, -0.01490187f, 0.00426889f, 0.03259916f, -0.01294445f, 0.00247201f, 0.01602387f, 
    0.05053192f, -0.03818372f, 0.01133497f, 0.00895169f, -0.02242978f, -0.07681244f, -0.06988295f, 0.04757512f, 
    0.02853575f, -0.03785423f, 0.04875850f, -0.06729659f, 0.03656128f, -0.00620558f, -0.07602230f, 0.02167764f, 
    0.05289723f, 0.01449637f, -0.04918847f, -0.06620413f, -0.02718179f, -0.05265590f, 0.03296324f, -0.01004560f, 
    0.06486858f, -0.06381833f, -0.01436685f, -0.05682369f, 0.05455654f, 0.02898001f, -0.01483732f, -0.05246139f, 
    0.01360471f, 0.07177647f, -0.01625646f, 0.02939417f, -0.05348887f, -0.06989336f, 0.06101553f, 0.06733456f, 
    0.04856958f, 0.03904999f, 0.00826160f, 0.03931175f, -0.03742905f, 0.01796786f, 0.01500501f, 0.02288658f, 
    -0.04029943f, -0.02636873f, 0.01735878f, -0.04360170f, -0.07704880f, 0.04300835f, 0.03745199f, -0.05252146f, 
    0.02691926f, -0.05471892f, -0.07063940f, -0.07946519f, 0.04632432f, -0.01150661f, -0.03323513f, 0.06406385f, 
    0.00460624f, -0.02871289f, -0.02257222f, 0.05757605f, -0.06165656f, -0.05036503f, -0.02131454f, 0.01266840f, 
    0.04550536f, -0.00491842f, -0.04008869f, 0.00672747f, 0.06023207f, -0.03096906f, 0.05244603f, -0.08160695f, 
    -0.06233976f, 0.00451434f, -0.05772075f, -0.04460969f, 0.02513693f, -0.01029534f, -0.03610582f, -0.00126276f, 
    0.02161727f, -0.06539061f, 0.04012270f, -0.03747498f, -0.04333812f, -0.05467125f, -0.00712379f, -0.06091175f, 
    0.06293648f, -0.01692890f, -0.01620437f, 0.00444336f, -0.01137966f, 0.05648018f, -0.04893766f, -0.06095637f, 
    -0.08036305f, 0.02277300f, -0.03134560f, -0.03459863f, -0.03993845f, -0.04837604f, 0.06162782f, -0.03083444f, 
    -0.03559382f, 0.05566765f, -0.06109738f, 0.00800778f, 0.04204480f, -0.05773801f, 0.00947291f, -0.01868554f, 
    -0.05768954f, 0.02564580f, -0.04463346f, -0.06302714f, 0.03056773f, 0.04089304f, 0.02149037f, -0.02624939f, 
    -0.01925650f, 0.04657748f, -0.06575512f, 0.01615035f, -0.03078657f, -0.03304846f, 0.05280162f, 0.02944212f, 
    0.03056961f, -0.07547129f, 0.03109420f, -0.04637871f, -0.06736688f, -0.03891835f, -0.05150695f, -0.03287707f, 
    0.05274959f, -0.04556616f, 0.00887919f, 0.06722012f, -0.06579495f, -0.07207105f, -0.02229224f, -0.03803831f, 
    -0.02773374f, 0.23867564f, 0.08303099f, 0.04314115f, -0.01714090f, 0.13354817f, 0.00266138f, 0.07274463f, 
    0.02094176f, -0.01253767f, 0.00668736f, -0.02344176f, -0.38124359f, -0.14491799f, -0.11632938f, -0.23912716f, 
    0.09622047f, -0.08729371f, -0.14345199f, -0.13760175f, -0.12251401f, 0.06921568f, 0.22449347f, -0.06138942f, 
    0.42287302f, -0.12294898f, -0.00433661f, -0.14897108f, 0.05079689f, -0.03881271f, 0.07094924f, 0.12002181f, 
    0.12967546f, 0.01736180f, -0.06146586f, 0.01771477f, -0.15464081f, 0.07898173f, 0.02423896f, 0.11593486f, 
    -0.00837334f, 0.00132925f, -0.01345233f, 0.08325096f, 0.00798861f, 0.10783210f, 0.13583983f, 0.18782476f, 
    0.16577268f, -0.20986928f, 0.05948081f, 0.25640586f, -0.06125075f, 0.11542743f, 0.01619693f, 0.11026975f, 
    0.02258598f, 0.07923213f, 0.12237916f, -0.02723221f, 0.24549811f, -0.14160162f, 0.39235947f, 0.21706584f, 
    -0.17992391f, -0.07845663f, 0.06079702f, -0.03818511f, 0.07257773f, 0.04971407f, 0.03787861f, 0.04105042f, 
    0.19582832f, 0.08458583f, -0.07528829f, -0.03772789f, 0.05328878f, 0.04410594f, 0.03164604f, -0.06253335f, 
    -0.04683991f, -0.01987512f, 0.04382712f, -0.05642173f, -0.04465866f, 0.15879942f, 0.05594208f, 0.08696440f, 
    -0.02192979f, 0.01793869f, 0.14609230f, 0.05241195f, -0.01021891f, 0.02801081f, 0.07936910f, 0.05010964f, 
    -0.23957822f, 0.07890274f, -0.19096628f, 0.12863529f, -0.00955781f, -0.04212084f, 0.12825419f, 0.21988602f, 
    -0.07858163f, -0.03280107f, -0.02585096f, -0.04813613f, -0.30335209f, -0.16690813f, 0.15485413f, 0.00629077f, 
    -0.09374505f, 0.06222066f, -0.15783980f, 0.03111305f, -0.00077907f, -0.05361504f, -0.16683128f, 0.10637292f, 
    0.17893744f, -0.07963801f, 0.12932976f, 0.09310057f, -0.13354217f, 0.13371937f, -0.01307668f, 0.11069697f, 
    0.06712683f, -0.16229074f, -0.00375017f, 0.10520454f, -0.04122097f, 0.00509702f, 0.11119305f, -0.16343573f, 
    -0.03384358f, 0.11324295f, -0.11266867f, 0.07335286f, -0.03495708f, -0.15575822f, 0.06529747f, 0.10909373f, 
    -0.02154217f, -0.09047376f, -0.09692958f, -0.13643664f, 0.00344946f, 0.11246888f, -0.17543712f, 0.30607665f, 
    0.03952618f, -0.07647405f, -0.06861981f, 0.15609987f, -0.08984689f, -0.10225613f, -0.22886190f, 0.04026400f, 
    -0.09179259f, 0.15404822f, -0.04497623f, 0.20177653f, 0.16696310f, 0.11293114f, 0.04781544f, 0.08590935f, 
    -0.41686979f, 0.09665824f, -0.07224003f, -0.15736902f, -0.09874579f, 0.06708794f, 0.15490533f, -0.10289192f, 
    0.14755751f, -0.03375513f, -0.07446197f, -0.02791622f, -0.25412577f, 0.21884871f, -0.00513075f, 0.03103986f, 
    0.16287158f, 0.05245985f, 0.02980322f, -0.02825654f, 0.02959959f, 0.07736353f, 0.07431783f, -0.06206799f, 
    0.14622490f, 0.05561309f, -0.14031222f, 0.00383567f, 0.07905862f, 0.08657870f, 0.09128685f, 0.04680137f, 
    0.03883017f, 0.04141200f, -0.04736027f, 0.13321409f, 0.42853460f, 0.26521972f, 0.05051609f, -0.09857557f, 
    0.05415850f, -0.23294854f, 0.01816842f, 0.02487144f, 0.02089692f, 0.13254645f, 0.00108656f, 0.19686557f, 
    -0.34428513f, -0.21209435f, 0.11501409f, -0.29037479f, -0.02519197f, 0.00489213f, 0.01349619f, -0.23150000f, 
    -0.03401073f, 0.00028948f, 0.04721066f, 0.07629958f, -0.01916231f, 0.09018731f, 0.02889338f, -0.22821730f, 
    0.12347358f, -0.05638982f, 0.01590823f, -0.18253699f, -0.15364081f, -0.09010191f, 0.10171287f, 0.01545946f, 
    -0.13455941f, -0.18224590f, 0.13271874f, 0.12318648f, 0.05251702f, -0.06758478f, 0.02122402f, 0.06845639f, 
    -0.20461470f, -0.14117347f, -0.07586473f, 0.11257354f, 0.05119519f, 0.10023513f, -0.03422331f, 0.13283306f, 
    -0.20274815f, 0.10706442f, -0.07959171f, 0.09914913f, -0.00497283f, 0.05057710f, 0.06782940f, -0.01697311f, 
    0.03319792f, 0.01375981f, 0.10860219f, 0.25016698f, -0.00999420f, 0.07192958f, -0.07075341f, -0.04576950f, 
    0.04907358f, 0.12173783f, 0.01293315f, 0.08113723f, 0.32559267f, 0.09863913f, -0.08948427f, 0.14790080f, 
    -0.17785588f, 0.13056222f, 0.13978887f, 0.02220046f, -0.03450984f, -0.03814863f, -0.09369861f, 0.06487802f, 
    0.33449870f, -0.15650126f, -0.28339478f, 0.28663257f, -0.01453564f, 0.10564663f, 0.08741327f, 0.11377767f, 
    0.07546453f, -0.00290306f, 0.14534611f, -0.08105280f, -0.11743069f, 0.02404627f, 0.07876711f, -0.19060516f, 
    0.02357042f, -0.04964561f, -0.03011565f, 0.04306687f, 0.02043966f, 0.13513209f, 0.19313510f, 0.02698599f, 
    0.05166256f, -0.04993374f, 0.22934648f, -0.16624010f, -0.09150306f, -0.15072194f, -0.07186580f, 0.06955956f, 
    0.04977847f, 0.17910010f, -0.15646745f, -0.17225006f, -0.11429396f, -0.23478222f, 0.11456867f, 0.06847860f, 
    0.01538943f, -0.01190750f, 0.08597078f, -0.04461443f, -0.01367565f, 0.01102459f, 0.03953966f, 0.08936632f, 
    0.14756760f, 0.05217142f, 0.02232159f, -0.13438848f, -0.10801335f, 0.01392627f, -0.11550942f, 0.26414347f, 
    -0.00065780f, 0.00140858f, -0.01865389f, -0.02463268f, -0.23022173f, -0.16584767f, -0.04931519f, 0.09355691f, 
    -0.14415614f, 0.12092263f, 0.05270761f, 0.20768471f, -0.04059757f, 0.06292846f, -0.22273132f, -0.07096314f, 
    0.35019884f, -0.09054138f, 0.03078449f, -0.28654048f, 0.10076977f, 0.10783748f, -0.14246018f, -0.00135510f, 
    0.01358612f, 0.06745750f, 0.03950086f, 0.00052917f, 0.30033389f, 0.21727502f, -0.28644538f, 0.24979116f, 
    0.01140707f, 0.09341865f, 0.01022075f, 0.13328061f, 0.04554845f, -0.05445041f, 0.09220534f, -0.03419999f, 
    -0.22161719f, 0.11098725f, -0.04204935f, -0.02856906f, -0.10828293f, -0.23000792f, 0.12444071f, 0.19137099f, 
    -0.04850572f, 0.02350277f, 0.06343585f, 0.01558831f, 0.21852361f, 0.16000293f, 0.09216464f, 0.39761648f, 
    0.01071049f, -0.12512119f, 0.06921745f, 0.13383184f, 0.04355516f, -0.03563215f, 0.02629944f, -0.05662729f, 
    -0.09774612f, 0.10209822f, 0.09048910f, -0.22557858f, 0.06795134f, 0.19484998f, -0.04991758f, -0.02338261f, 
    -0.13233098f, -0.12563454f, -0.01892775f, 0.05806561f, 0.04325708f, -0.10609889f, 0.32835412f, 0.07525941f, 
    0.07945282f, -0.01081369f, 0.02617446f, 0.13029329f, 0.06892367f, -0.24975288f, -0.15483983f, -0.05147204f, 
    -0.23332970f, 0.14980929f, 0.18935117f, -0.26696134f, 0.10495359f, 0.03252938f, -0.08561102f, -0.04659373f, 
    -0.01669106f, 0.03882720f, -0.08844332f, 0.02146696f, -0.09003253f, -0.00555856f, -0.41054139f, 0.18958075f, 
    0.12129197f, -0.00946661f, -0.05999880f, 0.06361046f, 0.15726332f, 0.05994148f, -0.04657136f, -0.09596929f, 
    0.02564663f, 0.06098581f, -0.10919709f, 0.00898795f, 0.15986429f, -0.00135666f, -0.02380934f, 0.22736010f, 
    0.01865683f, 0.13876490f, -0.02088377f, -0.10135726f, -0.23613131f, -0.13169146f, -0.11490895f, 0.20023948f, 
    0.03888537f, -0.03955148f, -0.13366129f, 0.02488502f, 0.00082710f, 0.00513650f, -0.05763744f, -0.01332216f, 
    0.12466505f, -0.03944417f, -0.09789472f, -0.00286727f, 0.07967859f, -0.00746872f, -0.11130264f, 0.03920642f, 
    -0.05227473f, 0.14669608f, -0.06298579f, 0.01939549f, 0.44378603f, -0.26628026f, 0.01908869f, 0.03079561f, 
    -0.06175059f, -0.11646826f, 0.05525940f, 0.01529514f, -0.01806617f, 0.02053903f, 0.01094632f, 0.03836518f, 
    0.03169079f, -0.28662500f, 0.07445475f, -0.09602457f, 0.16271897f, -0.03799675f, 0.14689085f, -0.07054606f, 
    -0.10151006f, 0.05822447f, 0.14322883f, -0.06302376f, 0.34882355f, -0.09486607f, -0.13909364f, 0.39218113f, 
    0.10037421f, -0.06094919f, 0.01832605f, -0.03163841f, 0.14302342f, 0.18697740f, 0.08897601f, -0.02703150f, 
    -0.22728638f, 0.00739077f, 0.12120651f, 0.09492912f, 0.00149881f, -0.11781169f, 0.25469863f, -0.12537356f, 
    0.04698545f, 0.04635501f, -0.00380050f, -0.03023343f, 0.32858855f, 0.03325131f, 0.13255726f, -0.14046009f, 
    0.09484002f, -0.05079722f, 0.02656917f, 0.08601260f, 0.03975482f, -0.03989160f, -0.07283578f, 0.07846238f, 
    0.29355705f, 0.13273461f, -0.08329343f, 0.09642958f, 0.00353125f, -0.05060298f, 0.06434135f, 0.11675163f, 
    0.07368913f, 0.09745752f, 0.14775491f, -0.05301176f, 0.08271275f, -0.05661983f, -0.03285291f, 0.05838382f, 
    -0.04117703f, -0.06017182f, -0.22057091f, 0.09369648f, 0.01860952f, -0.02936972f, 0.14168634f, 0.16868936f, 
    0.46726269f, 0.01203201f, -0.07373574f, 0.13724320f, 0.10665970f, 0.10297793f, -0.11333716f, -0.04838596f, 
    -0.05597816f, 0.06981755f, -0.03633795f, 0.00268219f, -0.09813521f, -0.39034593f, 0.12614919f, -0.23123452f, 
    0.09535810f, 0.20613816f, 0.03042040f, 0.03676028f, 0.01770534f, 0.00499447f, -0.01352984f, 0.12089190f, 
    -0.31235829f, -0.25214332f, 0.04407647f, -0.05582391f, -0.10862585f, -0.16886063f, -0.02771013f, -0.04380216f, 
    0.11624111f, 0.06781157f, 0.12780310f, 0.07272097f, -0.04372696f, 0.09176013f, -0.16395113f, -0.09655177f, 
    -0.01104996f, -0.02652718f, 0.05925569f, -0.02480822f, -0.00482149f, 0.18807867f, 0.06547868f, -0.02134323f, 
    0.16590898f, 0.18361786f, -0.00043437f, -0.04066246f, -0.01025734f, 0.13459292f, 0.07926524f, -0.02453275f, 
    0.09784117f, -0.08081141f, -0.02095642f, -0.01139682f, -0.12357546f, 0.19890408f, 0.11877381f, -0.08448403f, 
    0.24816245f, -0.11969555f, 0.05224773f, -0.04527361f, -0.00371332f, 0.03636597f, 0.15182434f, -0.01034978f, 
    -0.25419298f, 0.15340613f, 0.19377527f, 0.14463532f, 0.01958111f, -0.06421059f, -0.01042298f, -0.02632856f, 
    0.12972988f, 0.06860697f, 0.07243410f, 0.02988789f, 0.08700377f, 0.01886809f, 0.12539747f, -0.01531652f, 
    -0.07697849f, 0.01264772f, 0.07178258f, 0.09740094f, 0.09958474f, 0.04628015f, 0.04731160f, -0.01214315f, 
    -0.29845351f, -0.05381287f, 0.05350616f, 0.11909230f, 0.10075863f, 0.13008626f, 0.24275884f, -0.01230828f, 
    0.07649350f, 0.03741387f, 0.08601882f, 0.00957572f, 0.05601177f, 0.45709759f, -0.00051409f, -0.03711035f, 
    0.11401410f, 0.24566931f, 0.12654911f, 0.06263987f, -0.01405845f, 0.02906032f, 0.02247657f, -0.04753706f, 
    -0.20915644f, 0.39936107f, 0.01441579f, -0.14058273f, 0.02954134f, 0.19200237f, -0.20251688f, -0.01915074f, 
    0.04934691f, 0.04919834f, -0.00512332f, 0.02954810f, -0.32129404f, -0.12066374f, 0.23577385f, -0.28903049f, 
    -0.07073297f, 0.02046731f, -0.02085829f, 0.22555928f, -0.14750035f, 0.00546484f, 0.05214492f, -0.00199794f, 
    -0.11888053f, -0.01149955f, -0.27979448f, 0.01822801f, 0.13673772f, 0.06496693f, -0.04333087f, 0.21478982f, 
    -0.06829428f, 0.10775881f, 0.04482773f, 0.04326418f, -0.40635327f, -0.34113300f, -0.12902106f, -0.00956489f, 
    0.16140433f, 0.07597011f, 0.09218934f, -0.06988619f, -0.00401436f, -0.04439327f, -0.01264799f, -0.10484713f, 
    0.19971325f, -0.32995370f, -0.00352708f, 0.04821709f, 0.06529853f, 0.14189786f, 0.09060769f, -0.08546256f, 
    -0.02945666f, -0.00097105f, -0.04033834f, -0.03188294f, 0.01072026f, 0.07325817f, 0.23978582f, 0.13177083f, 
    0.05383395f, 0.06836163f, 0.14585504f, 0.04662158f, 0.05552097f, 0.06664979f, -0.13217874f, 0.10927694f, 
    0.21674235f, 0.17949267f, 0.23897089f, -0.04411234f, 0.12330062f, 0.04845154f, -0.19402033f, -0.01341226f, 
    0.03613453f, 0.04938062f, 0.15932323f, -0.08012211f, 0.26124859f, 0.30367246f, -0.08592852f, 0.12983339f, 
    0.17305918f, -0.02785084f, -0.14351143f, -0.16569792f, -0.08071841f, -0.07374959f, 0.08415300f, -0.12123092f, 
    -0.43215930f, 0.05702719f, 0.04555856f, 0.08781037f, 0.15038693f, -0.05401415f, -0.00695085f, -0.05938250f, 
    0.15983726f, 0.05862069f, -0.04416764f, -0.05473704f, 0.14645915f, 0.04811558f, 0.02667277f, -0.18348546f, 
    -0.00705888f, -0.08598450f, 0.00888472f, 0.06713735f, -0.16525444f, 0.17621697f, 0.18663716f, 0.10018943f, 
    -0.13128269f, -0.14878489f, 0.07996117f, 0.14847559f, 0.00251517f, -0.14077331f, 0.04445893f, 0.16903850f, 
    -0.05924438f, 0.04970273f, -0.00103845f, -0.01646492f, 0.04511809f, -0.08823249f, -0.01183418f, -0.06905609f, 
    -0.09772237f, 0.04712532f, -0.17788722f, 0.02535897f, -0.03747427f, -0.07445560f, -0.10016149f, -0.04163702f, 
    0.15702225f, -0.15518856f, 0.04440625f, -0.02693587f, -0.09643267f, -0.10293128f, -0.11236530f, 0.00036746f, 
    0.16940470f, -0.13127424f, -0.15946619f, -0.10913348f, 0.27413747f, 0.08663370f, -0.09580570f, -0.08493590f, 
    -0.04277403f, 0.03807553f, -0.10125329f, 0.11960288f, -0.07422808f, 0.17045048f, 0.07681099f, -0.10972054f, 
    0.23836221f, -0.26536733f, 0.09935410f, -0.03242542f, 0.06108913f, 0.19549249f, -0.05816491f, 0.15301394f, 
    0.00677632f, 0.01709304f, 0.02713544f, 0.07302303f, -0.34156844f, -0.16574997f, 0.17622152f, -0.13910584f, 
    0.00870380f, -0.04752017f, 0.08743309f, 0.11193365f, 0.24522407f, 0.16616708f, 0.07795292f, 0.19997726f, 
    -0.17742318f, -0.12584336f, -0.06168899f, -0.05292267f, 0.02585526f, 0.11516724f, 0.03518694f, 0.04787915f, 
    0.00634739f, 0.07922121f, 0.01028313f, 0.05943667f, -0.21052553f, -0.09306637f, 0.13688998f, 0.12999541f, 
    0.20570073f, 0.09666372f, -0.09213804f, -0.07882220f, 0.10814194f, -0.11292285f, 0.15681653f, 0.02422443f, 
    0.29689738f, 0.21172553f, -0.04783711f, -0.08918128f, -0.08602429f, -0.00225662f, -0.15243626f, -0.11225659f, 
    0.07853168f, -0.12123260f, -0.04143836f, -0.26964441f, 0.01708465f, -0.03936237f, 0.02139254f, -0.07453230f, 
    0.03310616f, -0.03181885f, 0.03532381f, 0.04903723f, -0.00202132f, -0.14558131f, 0.17544095f, -0.04386361f, 
    0.07043164f, -0.03585182f, -0.03382792f, 0.00135652f, -0.05287422f, 0.18877977f, -0.00087064f, 0.00352682f, 
    0.21401560f, 0.16868390f, 0.11447781f, 0.06277407f, 0.24127054f, -0.12350640f, 0.03535766f, -0.06517711f, 
    0.04124791f, -0.02546409f, 0.07216202f, -0.05644934f, -0.02106215f, -0.03072391f, 0.04202729f, 0.19845384f, 
    -0.04351652f, -0.00916154f, -0.01853755f, -0.02637194f, 0.03371610f, 0.03348292f, -0.07335755f, -0.07215299f, 
    0.05663544f, 0.00193353f, 0.03784626f, 0.01053494f, -0.04557337f, -0.03701809f, 0.01322098f, 0.00755735f, 
    0.02327265f, -0.04864850f, -0.00556030f, 0.06223843f, -0.04737780f, 0.04341848f, 0.00346288f, -0.06197545f, 
    -0.03213730f, -0.00496977f, 0.05845214f, -0.00393458f, -0.02018647f, -0.00698153f, -0.03437969f, 0.00957371f, 
    0.03054005f, 0.04722225f, -0.04473941f, -0.00023636f, -0.06898724f, -0.00959358f, 0.05901747f, -0.03999976f, 
    -0.01400058f, 0.02267955f, -0.03104478f, -0.03191115f, -0.04669468f, -0.05158402f, 0.02291846f, -0.00691336f, 
    0.02035492f, -0.00865444f, -0.04301083f, -0.00035910f, -0.07124943f, 0.01483243f, 0.05961239f, -0.04085804f, 
    -0.02788031f, -0.06118747f, -0.00245150f, -0.06593824f, 0.03695104f, 0.05160271f, 0.02158402f, 0.03122034f, 
    0.02675889f, -0.06226455f, -0.02352807f, 0.06429249f, -0.04324145f, 0.04989628f, -0.06266550f, -0.03883233f, 
    -0.01266338f, 0.00865438f, 0.05824415f, 0.04479810f, -0.05508346f, -0.04443659f, -0.01158260f, 0.03747120f, 
    -0.03521623f, 0.03657839f, 0.00905153f, 0.04146713f, -0.01333565f, 0.06606176f, -0.06905347f, -0.05779374f, 
    -0.04816449f, -0.00019008f, 0.06648848f, -0.06184310f, -0.06469553f, -0.04708056f, 0.01893803f, -0.01150304f, 
    -0.05940950f, 0.01000301f, -0.03400740f, -0.03378389f, -0.06863808f, -0.03439509f, -0.04459190f, -0.01726684f, 
    0.01727594f, -0.02877105f, -0.04684309f, 0.02506262f, 0.06387809f, 0.04290024f, 0.06463136f, 0.02921503f, 
    -0.00104241f, -0.07721050f, -0.01096753f, -0.00992564f, -0.05447014f, 0.03102413f, -0.07442247f, -0.06214233f, 
    0.02784676f, 0.05672268f, -0.04001932f, -0.02337199f, -0.07237729f, 0.03114359f, -0.02203215f, -0.02381524f, 
    0.01812189f, 0.01048890f, 0.03716873f, -0.01083493f, 0.06192396f, -0.01950859f, 0.02627914f, -0.00085159f, 
    0.05023783f, -0.00037303f, -0.06678713f, -0.00571488f, -0.01064878f, 0.03729861f, 0.05331504f, 0.03301907f, 
    -0.05176471f, 0.04701380f, -0.00212713f, 0.03486416f, 0.00944406f, -0.07524168f, -0.03398375f, -0.03586210f, 
    -0.06523933f, -0.07053993f, -0.01447841f, 0.05294159f, -0.07167122f, 0.02772386f, -0.02531839f, 0.03918106f, 
    0.03472434f, 0.01580160f, -0.03375573f, -0.04356604f, 0.02740525f, 0.02236216f, 0.01912338f, 0.04229050f, 
    -0.01762039f, 0.05281714f, -0.03238327f, 0.00570841f, -0.07323144f, -0.06804401f, -0.04309196f, -0.03949193f, 
    -0.01934280f, 0.04444415f, -0.07228550f, -0.06516599f, -0.04210053f, -0.07307558f, 0.01180600f, 0.00044227f, 
    -0.03655599f, -0.03552395f, -0.07357261f, 0.03060204f, -0.07713874f, 0.05040197f, -0.03830026f, -0.03608201f, 
    0.13250302f, -0.23818035f, 0.08059545f, 0.01082918f, -0.02592708f, -0.01302706f, -0.06559557f, -0.04877368f, 
    0.05961445f, -0.01525474f, -0.11595962f, 0.07047233f, 0.25412750f, -0.13397256f, 0.01613581f, -0.36334401f, 
    -0.11544437f, 0.08473393f, 0.08437626f, -0.02607116f, 0.14217792f, -0.09434444f, -0.15432806f, 0.05495062f, 
    -0.17088792f, -0.31835386f, -0.01353537f, 0.12065002f, -0.03587337f, -0.06224039f, 0.15087070f, -0.08173414f, 
    0.03040950f, 0.14860572f, -0.02949893f, -0.03185344f, 0.15946668f, -0.15950228f, 0.06645126f, -0.03369324f, 
    -0.04147309f, -0.02844212f, 0.07745201f, -0.11487962f, 0.08224121f, 0.03760109f, 0.06931251f, 0.07644286f, 
    0.15178488f, 0.14102374f, -0.12091607f, -0.19532920f, 0.05756331f, 0.01846796f, -0.03733471f, 0.23020148f, 
    -0.01883175f, 0.02592164f, -0.03070685f, 0.14838511f, 0.12988001f, -0.11510971f, 0.13300969f, 0.12778246f, 
    -0.04236376f, -0.04552760f, 0.02228474f, 0.15685746f, 0.07105389f, -0.10418646f, 0.11293589f, 0.04119284f, 
    0.33023870f, -0.11758599f, 0.18751206f, 0.09285527f, 0.11835502f, 0.05586220f, 0.03428072f, -0.10652973f, 
    0.00325828f, 0.22845384f, -0.00497226f, 0.00330210f, 0.09192589f, -0.05024543f, 0.04952568f, -0.02032058f, 
    0.01163864f, 0.00329227f, -0.02364682f, 0.06752032f, 0.01192358f, -0.01819183f, -0.07174332f, 0.14095768f, 
    0.11172079f, 0.20473868f, 0.14573552f, 0.04392901f, 0.03367922f, 0.06368988f, 0.03652759f, -0.19147956f, 
    -0.01460859f, -0.10228803f, 0.17025752f, -0.02484552f, 0.26240578f, -0.01537665f, -0.03924621f, 0.16469155f, 
    -0.01145103f, 0.07205355f, -0.11630991f, 0.02322850f, -0.09677787f, 0.04008955f, 0.09668998f, -0.09658379f, 
    0.51062882f, -0.08822761f, -0.17701893f, 0.05962895f, -0.02066002f, -0.00343870f, 0.02540099f, 0.05512838f, 
    0.24736416f, 0.27204829f, -0.12707461f, -0.04401469f, -0.14093176f, 0.15906601f, 0.04384834f, -0.51496959f, 
    -0.06120240f, -0.11318222f, 0.02793225f, 0.02806049f, 0.09156920f, 0.01663461f, -0.10870329f, 0.08126785f, 
    0.28206244f, 0.15877740f, -0.10157872f, -0.14045215f, 0.02935004f, 0.03789586f, 0.00550880f, 0.03021789f, 
    0.08271682f, 0.02801629f, -0.00898818f, 0.07696463f, 0.04902597f, 0.22661442f, -0.06153549f, -0.07310759f, 
    -0.12456731f, -0.03938280f, 0.04856843f, -0.07151957f, -0.13102473f, 0.02519540f, 0.10282300f, -0.00726334f, 
    0.09295793f, 0.17868443f, -0.02630394f, 0.01395891f, 0.06748939f, 0.08675118f, -0.10189685f, -0.08544320f, 
    -0.00722075f, 0.11399587f, -0.03211153f, 0.10695615f, 0.07542876f, -0.05009290f, -0.04404880f, 0.24945629f, 
    0.09271185f, -0.04935504f, 0.06280787f, 0.21618721f, -0.07619449f, 0.02016192f, 0.04052373f, -0.06574853f, 
    0.00703771f, -0.07551914f, 0.00025440f, 0.02114147f, -0.07015991f, -0.07363613f, -0.04711398f, -0.02393143f, 
    -0.02749869f, 0.05856302f, -0.05407403f, -0.04980283f, -0.01054059f, -0.05603823f, -0.07430796f, -0.06885128f, 
    -0.06745375f, -0.05009745f, -0.02870271f, -0.05978518f, -0.00190542f, -0.04198455f, -0.06694766f, 0.04411356f, 
    0.01025485f, 0.05258287f, -0.07068297f, 0.02158176f, 0.00630738f, 0.02346906f, 0.05499143f, 0.00611134f, 
    -0.07293396f, 0.06194287f, -0.06989763f, -0.01407781f, 0.05481080f, 0.01495288f, -0.00858501f, 0.05059668f, 
    -0.03014174f, 0.03639467f, 0.04030044f, 0.04963200f, -0.01113043f, -0.06599201f, -0.02830394f, 0.02394479f, 
    0.04678995f, -0.06365448f, 0.05447492f, 0.03741134f, 0.06538869f, -0.03479017f, 0.00557594f, 0.03246274f, 
    -0.05941124f, -0.04528922f, 0.02808965f, -0.00304862f, 0.00932132f, 0.04993104f, 0.03297570f, -0.03049815f, 
    -0.04358961f, 0.04399896f, -0.04744498f, 0.03033362f, 0.01931391f, 0.02598875f, -0.04655045f, 0.03029701f, 
    0.04770179f, 0.00867020f, -0.04403442f, 0.06681402f, -0.00805246f, -0.05425949f, -0.03761725f, 0.00935611f, 
    -0.05333344f, -0.01543857f, -0.00974074f, 0.01892065f, 0.01566542f, -0.02735699f, 0.02978400f, -0.01260193f, 
    0.03916230f, -0.07188135f, 0.05772391f, -0.00707971f, -0.01438332f, 0.00716641f, -0.04183548f, 0.05300805f, 
    -0.02484386f, -0.05492375f, 0.00340719f, 0.05490614f, 0.02467621f, 0.00188526f, 0.03243602f, -0.04985444f, 
    0.01223662f, 0.00834330f, -0.05191914f, -0.06916227f, -0.01731789f, -0.04282669f, 0.02965626f, -0.02383097f, 
    0.02815172f, -0.03106419f, -0.05072905f, -0.05322845f, 0.04034660f, -0.02553808f, -0.01899600f, -0.03955519f, 
    0.02141091f, -0.06052927f, -0.04546465f, -0.00906623f, 0.01376837f, -0.01621601f, 0.04657100f, -0.06533314f, 
    0.01086988f, 0.00581121f, -0.04528147f, 0.04853416f, 0.02719481f, -0.04322550f, -0.01072525f, -0.04308567f, 
    0.00997914f, -0.00961285f, -0.03843361f, 0.00086681f, 0.02884794f, 0.01666483f, -0.06241353f, 0.01717381f, 
    -0.00898230f, 0.03334583f, 0.04247276f, -0.00290829f, 0.00169322f, -0.01871476f, -0.00862696f, 0.01609304f, 
    0.03868251f, 0.05017699f, -0.07775792f, -0.00945090f, -0.01237333f, 0.03759727f, -0.05065382f, 0.05913559f, 
    -0.00419710f, -0.06409199f, 0.03040000f, -0.07376926f, -0.04631355f, -0.05181627f, -0.04028115f, 0.00319088f, 
    0.00211136f, 0.00145390f, 0.00172324f, -0.04375123f, -0.06807391f, 0.00158122f, 0.01892962f, -0.00143021f, 
    -0.06043152f, 0.00327003f, 0.05581453f, 0.02533873f, -0.06638363f, -0.07245829f, 0.02685838f, 0.03634847f, 
    0.01946418f, -0.07260913f, 0.05654171f, 0.00987748f, 0.05515130f, 0.03403141f, -0.03271858f, 0.05596823f, 
    0.21591787f, 0.01425389f, -0.09532034f, 0.03630666f, -0.02947961f, 0.02910364f, 0.06132706f, 0.01665383f, 
    0.01237122f, 0.20131859f, 0.05383289f, 0.19519046f, -0.20798314f, -0.09375616f, 0.06819859f, -0.01324881f, 
    -0.12129648f, -0.26639828f, 0.06275911f, 0.01722006f, 0.10289846f, 0.07098807f, 0.08056898f, 0.10538276f, 
    0.14418583f, -0.39098996f, -0.31802788f, -0.07601003f, 0.08858658f, 0.07725913f, 0.02323420f, -0.12390199f, 
    0.00651667f, 0.03061584f, 0.05604812f, 0.08712018f, 0.35174346f, 0.14190011f, 0.00679457f, 0.10381219f, 
    0.06661414f, -0.02953576f, 0.06508294f, 0.09533758f, 0.07737491f, -0.18508114f, -0.10676754f, 0.15574957f, 
    -0.02808563f, -0.03131051f, 0.02862508f, 0.00339527f, 0.10580414f, 0.12252332f, 0.24332659f, 0.03849812f, 
    -0.02943511f, -0.07931275f, -0.13733424f, 0.15548523f, -0.26303622f, 0.15339513f, -0.00669735f, -0.35502940f, 
    0.07444502f, 0.07845728f, -0.05486218f, 0.11143594f, 0.00728553f, -0.00275114f, -0.04471639f, 0.14961898f, 
    0.29650584f, -0.28705585f, 0.04380686f, 0.20021819f, 0.05373812f, 0.07073005f, 0.09575474f, 0.03024640f, 
    0.13200700f, 0.12001694f, 0.04280906f, 0.12133107f, -0.12053808f, 0.14364910f, -0.12283847f, 0.14159773f, 
    -0.11069590f, 0.06082483f, -0.05912232f, 0.08890168f, -0.15096247f, -0.03409806f, -0.03193735f, 0.17817792f, 
    0.54243863f, -0.05210310f, -0.23945013f, 0.29037920f, -0.15734738f, 0.04104481f, 0.03593776f, 0.09058060f, 
    0.07245330f, -0.13179266f, 0.06644632f, -0.06224916f, 0.11980040f, -0.10122903f, -0.10198104f, -0.11525770f, 
    -0.00744304f, -0.01332691f, 0.01371461f, -0.04290075f, -0.10466935f, 0.05481088f, 0.08789105f, 0.07356513f, 
    0.31096709f, -0.02532094f, -0.07508440f, -0.23929574f, 0.20905973f, -0.01688677f, 0.07257962f, -0.00518002f, 
    0.04107330f, 0.17342657f, 0.07612093f, -0.01319490f, -0.10945708f, -0.09433719f, -0.09393528f, -0.09514809f, 
    -0.15969366f, -0.30169034f, -0.01473732f, 0.10537991f, 0.04548502f, 0.05919103f, -0.08600664f, 0.05004640f, 
    0.44061595f, -0.19761722f, -0.22887950f, 0.20822404f, 0.06517646f, -0.06302008f, -0.04257863f, 0.26214182f, 
    0.02502587f, -0.01507834f, 0.09030709f, -0.01675693f, 0.03726338f, 0.02367699f, -0.23599647f, 0.03588193f, 
    -0.16126429f, 0.04705129f, 0.07122874f, -0.01704861f, -0.11854441f, 0.01295850f, -0.07356885f, 0.06329415f, 
    0.30675703f, -0.28909329f, -0.19075215f, 0.07360045f, -0.04603981f, -0.01060249f, -0.19123937f, 0.02706694f, 
    0.01346053f, -0.05886207f, 0.04157517f, -0.09213647f, 0.32172576f, 0.31258485f, -0.05970077f, 0.18792915f, 
    0.13396646f, -0.04057070f, -0.13395406f, 0.14310849f, -0.04098997f, -0.12193076f, 0.16554181f, -0.06852429f, 
    -0.20810756f, -0.14653805f, -0.15679267f, -0.07797813f, -0.02354427f, -0.06550855f, 0.16577344f, -0.01271670f, 
    0.05030427f, -0.03799869f, -0.10571022f, 0.08783341f, 0.21751046f, 0.18365416f, -0.03957579f, -0.01136467f, 
    -0.06173302f, -0.11993877f, 0.08504288f, 0.29868865f, 0.12134067f, 0.03471424f, -0.00273249f, 0.04761190f, 
    0.07304161f, 0.21880913f, 0.03390977f, 0.14051192f, -0.02284525f, 0.16850975f, -0.02908714f, -0.04211697f, 
    -0.19631541f, -0.13386199f, 0.10152876f, 0.14376247f, 0.17376214f, -0.07281581f, 0.08242901f, 0.10492154f, 
    0.12872022f, 0.14190681f, -0.10035714f, -0.16687608f, 0.04517718f, -0.16356191f, -0.21660173f, -0.03983716f, 
    -0.05387655f, 0.16714080f, 0.04472359f, -0.05275780f, 0.02329772f, 0.00752759f, -0.09406348f, 0.00082578f, 
    -0.02443995f, -0.02310678f, -0.06794959f, 0.00758063f, -0.01557538f, -0.06113106f, -0.36642057f, 0.03358472f, 
    -0.01797857f, 0.13022636f, 0.02267526f, 0.09631994f, 0.04438378f, 0.01893053f, 0.10077687f, 0.00159889f, 
    -0.06234853f, 0.06234908f, -0.11813737f, 0.13068676f, 0.07072434f, 0.06630400f, 0.01225532f, 0.00927930f, 
    -0.09231821f, 0.16306722f, 0.15472659f, 0.13394520f, -0.05421820f, -0.08756723f, 0.06423565f, 0.17317292f, 
    -0.00589501f, 0.02904020f, 0.10653556f, -0.16363575f, 0.04828827f, -0.16631943f, -0.22527619f, 0.17041892f, 
    0.34627017f, 0.11500864f, 0.00017531f, 0.14609642f, -0.10574069f, -0.11952803f, -0.12288129f, -0.06360147f, 
    0.08010057f, 0.05584028f, 0.08201101f, 0.00642460f, 0.23409112f, 0.02541684f, 0.01522057f, -0.06458369f, 
    -0.06253701f, -0.06126496f, -0.01772812f, 0.02701091f, -0.08478510f, -0.08012962f, -0.02855393f, -0.10650443f, 
    0.13860551f, -0.06321649f, 0.15595582f, 0.02459764f, -0.00755910f, -0.24191692f, 0.00127232f, -0.05110493f, 
    -0.05479137f, 0.21497713f, 0.04432333f, -0.08373553f, 0.27663794f, 0.15942654f, -0.17284314f, 0.17888065f, 
    -0.03792915f, -0.08151691f, 0.12116108f, -0.09129589f, -0.06595772f, 0.19585080f, -0.04128188f, -0.05544017f, 
    -0.14637966f, -0.13810268f, 0.30261278f, 0.07225879f, -0.01488420f, -0.02207488f, 0.07154816f, -0.02512449f, 
    -0.08312893f, 0.13449745f, 0.12048945f, 0.08207669f, 0.21302566f, 0.07052376f, 0.20142734f, -0.04850525f, 
    -0.03339248f, 0.01504189f, 0.13829552f, -0.06976172f, -0.09184960f, 0.15773521f, -0.21010232f, -0.02219232f, 
    0.28377494f, 0.23725301f, 0.12844229f, 0.07310327f, 0.15763924f, 0.06242960f, -0.13496707f, 0.17075129f, 
    -0.12781192f, -0.01449956f, -0.00047284f, 0.15111166f, 0.09034907f, -0.08420617f, -0.11615442f, 0.20477660f, 
    -0.05417467f, 0.05876744f, -0.10190850f, 0.10270329f, 0.03569797f, -0.03257965f, 0.07221835f, -0.20458204f, 
    0.22251484f, -0.34217414f, 0.26138020f, 0.09688561f, 0.10599026f, 0.10846756f, -0.14596160f, 0.04390102f, 
    0.05897241f, 0.07553381f, -0.00517019f, 0.05426736f, 0.17966948f, -0.27176222f, -0.07334313f, -0.06587868f, 
    -0.16357374f, 0.11018944f, -0.02627542f, -0.08135186f, 0.05281813f, 0.01283852f, -0.17429057f, -0.10141795f, 
    -0.37720698f, -0.39046526f, 0.10650443f, 0.26931787f, 0.09425815f, -0.04673453f, 0.05894969f, -0.14993405f, 
    0.08178161f, 0.11117638f, 0.01870647f, -0.03431796f, 0.19544932f, -0.00483346f, 0.09976340f, -0.03797253f, 
    -0.08703743f, 0.05780356f, -0.02013502f, 0.12835652f, -0.01047077f, 0.15022826f, 0.01210062f, 0.09467924f, 
    0.00780717f, 0.24769451f, -0.02604436f, -0.13603418f, -0.04705593f, 0.00751798f, 0.00176771f, 0.01699840f, 
    0.14366196f, 0.06335493f, 0.04783638f, 0.08053991f, -0.15663113f, 0.03712906f, 0.10023909f, -0.40518871f, 
    0.28127170f, 0.05051694f, -0.04712906f, 0.12014987f, 0.07444851f, -0.01354629f, 0.00588934f, 0.07588208f, 
    0.23203494f, -0.34312633f, 0.20392108f, -0.05623051f, -0.09246473f, -0.07437623f, 0.02107209f, 0.07152056f, 
    0.21061847f, -0.03678189f, -0.15951718f, 0.00845354f, 0.02111605f, -0.01472623f, 0.05025232f, -0.11806430f, 
    0.00804984f, -0.04665751f, -0.07407182f, 0.06291097f, 0.00366598f, 0.20140643f, 0.11011998f, -0.04374918f, 
    -0.03242783f, 0.03017070f, 0.13347742f, -0.20278934f, 0.10265768f, 0.09080073f, 0.00122489f, -0.09231812f, 
    0.05712097f, -0.02024592f, 0.13595238f, 0.02506180f, 0.15654986f, -0.05336607f, -0.14711216f, 0.07609910f, 
    0.16871761f, -0.03206362f, 0.08056401f, -0.03764210f, 0.02013232f, 0.07085991f, 0.23145981f, 0.07287011f, 
    0.14294007f, 0.01569795f, -0.13010029f, 0.02871813f, 0.23921788f, 0.05259044f, -0.00411955f, 0.00413389f, 
    0.05783906f, 0.11765000f, 0.08195411f, 0.17291810f, -0.25589687f, 0.17079954f, 0.07628296f, -0.13568301f, 
    -0.02592266f, -0.00952163f, -0.01938480f, 0.00403049f, 0.09436278f, -0.09263723f, -0.00994750f, 0.03720044f, 
    0.22220317f, 0.07961831f, -0.19025290f, -0.01495510f, 0.06355666f, 0.00072738f, -0.02826158f, -0.10937805f, 
    0.03255008f, -0.08235633f, -0.10848413f, -0.09439971f, 0.07901669f, 0.10275777f, -0.03766828f, -0.14690395f, 
    -0.06952978f, -0.09608362f, -0.04443313f, -0.09746481f, -0.07126979f, -0.20738606f, 0.14670715f, 0.00098565f, 
    0.13579749f, -0.14958096f, -0.04497482f, 0.23163943f, -0.09001964f, 0.00255155f, -0.02533553f, 0.06265381f, 
    0.03343467f, 0.10212226f, 0.06866214f, -0.03687737f, 0.25974613f, -0.26647422f, 0.15616417f, 0.00128499f, 
    0.04779818f, -0.12679060f, 0.14096029f, 0.03133648f, -0.06784645f, 0.12938049f, 0.01470022f, 0.11429898f, 
    -0.22915216f, 0.25547180f, -0.18065888f, -0.17954317f, 0.12122317f, 0.08513140f, 0.01418494f, 0.14580065f, 
    0.02618276f, -0.02123646f, 0.01435516f, 0.01912236f, 0.18217424f, 0.10432211f, -0.09160677f, 0.25464907f, 
    0.13865033f, 0.00665487f, -0.02559325f, -0.00016686f, 0.08001781f, -0.05438504f, 0.05002978f, -0.01835511f, 
    -0.15689179f, 0.39928532f, 0.14558257f, -0.02449654f, 0.08864166f, 0.13500191f, 0.04937100f, -0.02465527f, 
    -0.07717537f, -0.10883451f, 0.22760059f, 0.20164195f, -0.02927935f, 0.10302258f, -0.16124578f, 0.11772545f, 
    0.17629451f, -0.04954118f, 0.02379095f, 0.17947654f, -0.08348376f, 0.02834072f, 0.15532157f, 0.01939943f, 
    -0.07775296f, -0.00467921f, 0.32154053f, 0.27170080f, -0.03589292f, -0.05254385f, 0.01609232f, -0.17798270f, 
    -0.06743313f, -0.10164460f, -0.00785738f, -0.09131055f, -0.29409096f, 0.24374492f, -0.27424797f, -0.22333898f, 
    0.01186991f, 0.02005533f, 0.01956841f, -0.07791136f, 0.01985700f, 0.00785069f, -0.04390224f, 0.01987460f, 
    -0.49320385f, 0.17335735f, -0.15036070f, -0.12375058f, 0.02655291f, -0.01161564f, 0.00004068f, 0.09256162f, 
    0.05037364f, -0.08171068f, 0.04878560f, 0.01260916f, 0.04455260f, 0.25358194f, 0.05100699f, -0.05237699f, 
    -0.00329721f, -0.06622995f, -0.01001257f, 0.04344088f, -0.02494089f, 0.03085983f, 0.05487822f, 0.03489420f, 
    -0.33117801f, -0.05878365f, -0.16538517f, 0.12884742f, 0.18602630f, 0.10373207f, 0.06104314f, 0.09464411f, 
    -0.07913338f, 0.19020791f, -0.01834745f, -0.03952204f, -0.30342185f, 0.18515013f, -0.01242547f, -0.06722733f, 
    0.11520325f, 0.01643921f, 0.18466777f, 0.03659441f, 0.18374187f, -0.00438789f, -0.04691638f, -0.05006842f, 
    -0.32859319f, 0.09608831f, 0.15152465f, -0.06816572f, 0.04674581f, -0.02452747f, 0.05672541f, 0.02612082f, 
    -0.14563115f, -0.07329696f, 0.08232412f, 0.00110234f, 0.37596029f, -0.01014244f, 0.00358936f, 0.37617639f, 
    0.10060472f, 0.09360930f, -0.02313929f, -0.10732230f, -0.05651952f, 0.17059760f, 0.19934924f, -0.06129987f, 
    -0.03782451f, 0.08189011f, 0.04874100f, 0.17445765f, -0.09173002f, 0.07224894f, 0.20660871f, -0.10966834f, 
    -0.17053501f, 0.03168900f, 0.11781882f, -0.10897588f, -0.02646661f, 0.02633198f, 0.02871299f, 0.20103762f, 
    0.22626765f, 0.03973752f, 0.14502147f, 0.03022357f, 0.01080275f, 0.10456785f, -0.08994852f, -0.06805616f, 
    0.10933930f, -0.19901817f, 0.17517184f, 0.05772655f, 0.05926697f, -0.03877634f, -0.03875962f, 0.05559379f, 
    -0.06383574f, -0.00923045f, 0.16988675f, -0.05736686f, 0.09025802f, 0.25549111f, -0.10418633f, -0.16572334f, 
    -0.04610943f, -0.02291985f, -0.07159913f, -0.02380759f, 0.15461442f, -0.11902526f, 0.00744438f, 0.02953279f, 
    0.41476080f, 0.07156309f, -0.23994058f, 0.07729855f, -0.04722239f, -0.05596632f, 0.09579063f, 0.17142038f, 
    0.04911931f, 0.18813178f, 0.12141020f, 0.00427841f, -0.43652952f, -0.08861794f, 0.34261027f, 0.13821179f, 
    -0.29644203f, -0.16718727f, 0.13544019f, 0.05532427f, 0.00560986f, 0.04720812f, 0.06565264f, 0.01238331f, 
    0.18002146f, -0.02895555f, -0.32064837f, -0.12526214f, 0.06024457f, 0.01239063f, 0.03272497f, 0.11715535f, 
    0.00716245f, 0.09190807f, 0.11181869f, 0.12288748f, 0.17203401f, 0.09834371f, -0.11964662f, 0.07475112f, 
    -0.04826582f, -0.04124705f, 0.16603474f, -0.00515609f, 0.17843802f, -0.08258448f, -0.25039402f, -0.06571218f, 
    -0.00792579f, -0.05202081f, -0.09773682f, -0.16519156f, 0.14599277f, 0.08762679f, 0.13587692f, -0.05722402f, 
    0.12452383f, 0.06046270f, 0.06392846f, 0.05227183f, -0.09845787f, 0.13766813f, 0.02382647f, -0.24749653f, 
    0.23691942f, -0.06479848f, 0.05625640f, 0.04886230f, -0.00054001f, 0.06287411f, -0.03397172f, 0.02426357f, 
    0.32998231f, -0.31141332f, -0.01330843f, 0.24906260f, 0.06335687f, 0.00280217f, 0.11532550f, 0.19064432f, 
    0.11346007f, -0.07463332f, 0.07496383f, 0.10167366f, -0.20672059f, 0.03388026f, 0.01534288f, -0.10325297f, 
    0.03974664f, -0.04534774f, -0.20517538f, -0.03650957f, -0.03696638f, 0.01127772f, -0.02091209f, -0.06347588f, 
    0.44037974f, 0.04448113f, 0.18734273f, -0.05991082f, -0.11619449f, 0.06707524f, 0.07569806f, -0.06221230f, 
    0.06249830f, 0.00160139f, 0.07826859f, 0.15229917f, 0.10030234f, -0.05921289f, -0.15915750f, 0.24502006f, 
    -0.11547040f, 0.10338312f, -0.07305131f, -0.00578732f, 0.00543587f, 0.09019744f, 0.03882965f, 0.01296960f, 
    0.08111694f, -0.07805437f, -0.26937544f, -0.07426891f, 0.32670498f, 0.02969989f, -0.14852668f, -0.04323553f, 
    0.16437656f, 0.07383610f, 0.03924863f, 0.00699322f, -0.17259845f, -0.03822491f, -0.07503989f, -0.04736460f, 
    -0.17679933f, -0.30611038f, 0.06401238f, 0.15116972f, 0.12121997f, 0.10562678f, -0.04808321f, 0.03765907f, 
    0.25469819f, -0.15702470f, -0.31716412f, 0.11959170f, 0.10945278f, -0.17683066f, -0.00762618f, 0.00622463f, 
    0.10038718f, -0.10751620f, 0.09851713f, 0.06485587f, 0.42022780f, 0.39238882f, 0.05370609f, -0.16473687f, 
    -0.00013010f, -0.06098558f, 0.07059402f, -0.08485632f, -0.07687894f, 0.05513930f, 0.10533358f, -0.09317058f, 
    0.13444254f, -0.10486279f, -0.10537874f, 0.39381826f, -0.06304324f, -0.14077051f, -0.02419599f, -0.00246192f, 
    -0.07025483f, 0.16843478f, 0.01144171f, -0.03162086f, 0.20185809f, 0.17498410f, 0.03591493f, -0.01722210f, 
    0.03605497f, -0.01325524f, -0.05310156f, 0.15954936f, -0.12695380f, -0.09971580f, 0.08327635f, 0.15504573f, 
    -0.04864511f, -0.05013449f, -0.03218982f, -0.04456773f, 0.02602617f, 0.05812545f, -0.07060895f, 0.03488835f, 
    0.03603366f, -0.05268965f, 0.05126283f, 0.05450035f, 0.03011197f, -0.03900587f, 0.02085533f, -0.04818858f, 
    -0.02866280f, 0.00626210f, -0.05837508f, -0.00364739f, -0.05931440f, -0.07879268f, -0.00407775f, 0.03438381f, 
    -0.03273075f, -0.00157758f, 0.02766825f, -0.06041292f, 0.03045902f, 0.04883236f, -0.02084629f, -0.01843433f, 
    -0.00599572f, 0.02123796f, -0.05868864f, -0.07879077f, 0.00899511f, -0.05406279f, -0.01501487f, -0.03123632f, 
    -0.01778159f, -0.06581844f, 0.04929134f, -0.06734862f, 0.05866075f, -0.02334784f, 0.04934952f, -0.00718849f, 
    -0.01622776f, 0.04439466f, 0.01345946f, -0.01505778f, -0.03416124f, 0.01702890f, 0.01614344f, -0.07498947f, 
    0.02511941f, 0.04560615f, 0.02027401f, 0.03558972f, -0.07585634f, -0.05553712f, 0.01021970f, -0.06126030f, 
    0.02425381f, -0.00543824f, 0.00162559f, 0.00184626f, -0.01973801f, -0.07142515f, -0.03157574f, 0.00383761f, 
    0.02704492f, 0.04499049f, -0.05581380f, -0.07258335f, -0.02096093f, -0.06904840f, -0.05412026f, -0.03703523f, 
    0.05578144f, -0.00401490f, -0.02848116f, -0.07803258f, 0.02607292f, -0.01499326f, -0.05405929f, 0.02021121f, 
    -0.01436739f, -0.05250963f, -0.06011720f, 0.02159652f, 0.06191691f, -0.07556688f, -0.05252031f, -0.00053448f, 
    -0.02886661f, -0.05080135f, -0.02579425f, -0.01436174f, -0.02688364f, -0.03625590f, 0.06185064f, -0.01263249f, 
    0.04380921f, 0.01565834f, -0.02679269f, 0.04720702f, 0.01182865f, 0.01940023f, -0.03134215f, -0.06481962f, 
    0.02275010f, -0.04191732f, -0.02582663f, -0.05619286f, 0.04066611f, -0.02849683f, 0.03306656f, -0.05023779f, 
    -0.04078196f, -0.07982841f, -0.06007434f, 0.01382020f, -0.01021692f, 0.04688900f, -0.03703137f, -0.06766234f, 
    -0.00289900f, 0.01706024f, -0.07955790f, -0.01878691f, -0.08032274f, 0.05320209f, -0.02253736f, -0.07785299f, 
    0.02767606f, -0.02986508f, 0.02188715f, 0.06470023f, 0.01073801f, -0.04365449f, 0.02690806f, -0.03151692f, 
    0.03953580f, -0.07014731f, 0.03799554f, 0.04876450f, -0.07185813f, -0.05886526f, 0.01353875f, 0.01425678f, 
    -0.05191968f, 0.03718086f, 0.04683297f, -0.05586456f, 0.03086972f, -0.04186019f, -0.00002294f, 0.02223117f, 
    -0.02796985f, -0.03360846f, -0.00749334f, -0.05305928f, 0.02655511f, -0.07470803f, 0.02608910f, 0.05331830f, 
    0.06192223f, -0.07558279f, 0.06078907f, 0.00272423f, 0.01386062f, 0.05000799f, -0.04463243f, -0.04466749f, 
    -0.02163084f, -0.00133563f, -0.02719840f, 0.05361186f, -0.06885044f, 0.03009200f, -0.02770941f, 0.03539738f, 
    0.05431257f, 0.04046120f, -0.00779187f, 0.03572135f, -0.06592730f, 0.04432355f, 0.01722553f, -0.05625030f, 
    -0.04531538f, -0.06551544f, -0.07699464f, -0.01410983f, -0.05892346f, 0.06496167f, -0.02892694f, 0.06079516f, 
    -0.04417010f, -0.02288648f, 0.00230071f, 0.05783691f, -0.01636141f, 0.05857975f, 0.00835814f, -0.05688427f, 
    -0.02534499f, -0.02581518f, 0.03212791f, 0.06212402f, 0.03057144f, 0.06130023f, -0.03068319f, 0.02455635f, 
    -0.00767908f, 0.00748931f, 0.00256581f, -0.01038240f, -0.00579258f, -0.06169644f, -0.04371786f, -0.03013286f, 
    -0.01417017f, 0.04977590f, 0.00530790f, -0.06758373f, 0.02636284f, 0.04515475f, -0.05688392f, -0.04738550f, 
    -0.06950868f, 0.02817987f, -0.02649871f, -0.00265482f, -0.02866687f, -0.00670279f, 0.04106595f, -0.05266389f, 
    -0.02212222f, 0.05041033f, -0.05510547f, -0.02247835f, 0.02903675f, 0.00742843f, -0.03158874f, -0.02703572f, 
    -0.04752348f, -0.00910957f, -0.05422122f, -0.02813673f, -0.04948221f, 0.01660947f, -0.02312204f, -0.05778547f, 
    -0.00972017f, 0.04124328f, 0.00194713f, -0.05322213f, -0.06851173f, -0.06577449f, 0.05341615f, -0.05434193f, 
    0.03231302f, 0.06206279f, 0.00365877f, 0.01371291f, -0.04781568f, 0.01999754f, -0.02368312f, -0.02542921f, 
    0.06271669f, -0.01856821f, -0.07667092f, -0.04968038f, -0.06809019f, -0.01850072f, -0.00843601f, -0.05424053f, 
    0.02656155f, 0.04488682f, -0.04587138f, 0.00366684f, 0.04212769f, 0.03894022f, 0.01575955f, 0.01850787f, 
    0.03902478f, -0.00090237f, -0.03444605f, 0.03748370f, -0.05399228f, -0.02956181f, 0.02251193f, -0.05006633f, 
    0.00719091f, 0.05479696f, -0.02506724f, -0.02638947f, 0.06107356f, 0.01589414f, -0.02564261f, 0.01735133f, 
    -0.01881485f, -0.05060241f, -0.04408986f, 0.05052361f, 0.04232424f, -0.00740143f, -0.01840718f, 0.02659712f, 
    0.04655205f, -0.05304901f, -0.03790636f, 0.00067222f, 0.04193455f, 0.00148035f, 0.00001261f, -0.06891637f, 
    -0.03771969f, -0.07666312f, -0.01861319f, 0.03681489f, -0.06614702f, -0.06449747f, -0.01038547f, -0.05562662f, 
    -0.01556097f, 0.02744873f, 0.03137194f, -0.04370857f, 0.04968969f, 0.03898011f, -0.06580969f, 0.00681962f, 
    -0.05265524f, 0.04128927f, -0.05711736f, 0.02313687f, -0.01278054f, 0.00956320f, 0.03584254f, -0.04043704f, 
    -0.00250739f, -0.00753092f, 0.06353790f, -0.07953151f, 0.00397854f, -0.03106820f, 0.04731520f, 0.00613049f, 
    -0.04530868f, 0.01099209f, 0.04685710f, 0.02937264f, -0.05941160f, -0.04818649f, 0.02634896f, -0.00983549f, 
    -0.03494653f, -0.05130054f, -0.00635610f, -0.05757794f, -0.06768093f, -0.07028949f, -0.05629940f, 0.04506341f, 
    -0.01005567f, 0.00036613f, 0.03517031f, 0.01766262f, -0.06402949f, -0.05956423f, -0.05065894f, 0.00630361f, 
    0.00763672f, -0.05998342f, -0.04390299f, 0.03951643f, 0.05944680f, -0.04789939f, 0.04488705f, -0.03624390f, 
    -0.07238203f, 0.00274316f, 0.00180640f, 0.04537584f, -0.02193834f, 0.03237642f, -0.00055497f, 0.05493783f, 
    0.03473687f, -0.08052779f, -0.05563289f, -0.05824149f, -0.00558763f, 0.03798094f, -0.06306099f, 0.05977396f, 
    0.00810791f, -0.04759740f, -0.08223940f, 0.03421471f, -0.06948081f, 0.04447247f, 0.03040105f, -0.01045688f, 
    0.00544557f, 0.01104251f, 0.05983850f, -0.07095875f, -0.06183895f, 0.00383091f, -0.03038745f, 0.04593140f, 
    -0.00003461f, -0.08269917f, -0.04033162f, -0.00954477f, -0.04235223f, -0.06508975f, 0.00489263f, -0.03657306f, 
    -0.05604608f, -0.06541310f, -0.01304838f, -0.07198096f, -0.07962239f, 0.00140821f, 0.04823289f, -0.07520087f, 
    0.05715398f, -0.01131889f, -0.07991379f, -0.00050872f, 0.04959852f, -0.00286207f, -0.05018952f, -0.02163741f, 
    0.01891497f, -0.00467503f, -0.01684953f, 0.01913811f, -0.07786857f, 0.02333985f, -0.05406967f, -0.06167220f, 
    0.04934443f, -0.01671610f, -0.07604168f, -0.03480577f, -0.05344901f, 0.03230194f, -0.04972072f, 0.05252898f, 
    0.02369131f, 0.02568581f, -0.05551408f, -0.07660284f, -0.07944164f, -0.06891465f, 0.01238695f, -0.03082239f, 
    0.05901247f, -0.05898730f, -0.05063309f, -0.08333603f, -0.05478130f, -0.05819291f, -0.04514105f, -0.01817092f, 
    0.05230226f, -0.08204699f, -0.00489122f, -0.07849732f, -0.03524869f, 0.04165775f, 0.03382128f, -0.01279045f, 
    -0.04978925f, -0.07784948f, 0.01198027f, -0.06509049f, -0.03490990f, -0.00011481f, 0.04163190f, -0.02742614f, 
    -0.01424543f, 0.00048331f, -0.03760643f, -0.08401763f, -0.02061225f, 0.05292542f, -0.01497512f, -0.00898967f, 
    -0.05103251f, 0.05040685f, -0.07959526f, -0.00932053f, -0.07594502f, 0.01865844f, 0.05195091f, -0.05484203f, 
    -0.03758228f, -0.04235914f, 0.01929918f, -0.05871297f, -0.04209785f, 0.00703995f, -0.04330384f, 0.02174159f, 
    -0.01242944f, 0.03777536f, -0.02158558f, -0.06430034f, -0.05402463f, -0.02740922f, -0.06086344f, -0.06637437f, 
    -0.03519611f, -0.00957045f, -0.00216306f, 0.03281540f, 0.04844007f, -0.00423385f, -0.07764827f, -0.00014837f, 
    0.00069951f, -0.00311025f, 0.05726269f, 0.04776527f, -0.06510817f, -0.03709586f, 0.05233234f, -0.03723585f, 
    -0.02317816f, 0.05016799f, -0.06973890f, -0.04687458f, -0.05318327f, -0.05907100f, 0.04334887f, 0.02715101f, 
    -0.08334220f, 0.04009810f, -0.05729685f, 0.03123822f, 0.03356774f, 0.00712544f, -0.02160509f, -0.02217731f, 
    -0.00170718f, -0.03183514f, -0.01809387f, 0.04438656f, -0.07568135f, -0.06409641f, -0.06750869f, 0.04165350f, 
    -0.03178584f, -0.00506997f, -0.01061623f, -0.05790899f, -0.05780681f, -0.00565566f, -0.02209692f, 0.01138582f, 
    -0.00246964f, 0.00296408f, -0.03647855f, 0.00634463f, 0.02809726f, -0.02504712f, 0.00550181f, 0.05571552f, 
    0.31753901f, -0.08668437f, -0.01491380f, -0.03724936f, 0.06383721f, 0.14300881f, 0.24786302f, -0.10781036f, 
    0.23552762f, 0.06284412f, -0.07441352f, 0.20532048f, -0.03191792f, -0.13908714f, -0.12619117f, 0.08001380f, 
    -0.03267029f, -0.04267113f, 0.08081533f, 0.03395748f, 0.12666367f, 0.25123563f, 0.02586157f, 0.20596069f, 
    0.39980111f, -0.13184218f, -0.21918690f, 0.21556522f, -0.04763175f, 0.15269592f, -0.15780035f, 0.09989787f, 
    -0.08934261f, -0.09492122f, 0.17341177f, 0.17148359f, 0.04580076f, 0.21276523f, -0.09328185f, -0.00006608f, 
    0.10993887f, 0.11708699f, -0.07225967f, 0.01755549f, -0.03911402f, -0.16375436f, -0.23993818f, -0.15047589f, 
    -0.17923819f, 0.09965766f, -0.15062574f, 0.27174762f, -0.12926786f, -0.02368693f, 0.13776506f, -0.09564592f, 
    -0.02064139f, -0.23112290f, 0.10974623f, 0.01197446f, -0.07004436f, 0.40728560f, 0.17229164f, -0.51076663f, 
    0.05751433f, 0.11230204f, 0.14945155f, 0.10112618f, -0.03907786f, 0.05544830f, 0.12079313f, 0.11463816f, 
    -0.20239216f, -0.04641777f, 0.09624512f, -0.01334635f, -0.06758440f, 0.07028363f, -0.03234709f, -0.03448282f, 
    -0.02035946f, 0.03724816f, 0.23400660f, 0.33770263f, 0.39959317f, 0.13195933f, 0.31153521f, -0.09109960f, 
    -0.03650300f, 0.22857755f, 0.16784047f, -0.02650637f, 0.08941726f, 0.01382210f, -0.11683542f, -0.02626639f, 
    0.47555846f, -0.06928361f, -0.12265535f, 0.04366523f, -0.07782225f, 0.00523143f, 0.02504195f, -0.14843202f, 
    0.14868976f, 0.07504663f, 0.20759836f, -0.21249393f, -0.26497918f, 0.36670023f, 0.07669555f, -0.17075889f, 
    0.16145894f, 0.04944359f, -0.01604587f, -0.04360311f, -0.09770354f, 0.03686156f, 0.07543001f, -0.13133666f, 
    -0.09383146f, 0.45876136f, -0.00570527f, -0.00704633f, 0.03156927f, -0.09775729f, -0.10196216f, 0.03980025f, 
    -0.03428738f, 0.00635457f, -0.09505284f, 0.01128546f, -0.12435382f, 0.03752130f, -0.02340343f, 0.26120713f, 
    -0.04388016f, -0.16715215f, 0.08102772f, 0.01697084f, -0.03280120f, 0.08851604f, -0.17366008f, 0.09303932f, 
    -0.06150953f, -0.18305230f, -0.03974606f, 0.15872476f, -0.00351159f, 0.06542958f, 0.03847699f, 0.26596820f, 
    -0.13056403f, 0.13708486f, 0.01860024f, 0.22005154f, -0.40747911f, -0.11518099f, 0.05632973f, 0.09905379f, 
    0.08879453f, 0.13455191f, -0.06346170f, -0.00148646f, 0.01887382f, 0.13799816f, -0.15137804f, -0.09825584f, 
    0.01103943f, -0.39865544f, 0.17474174f, 0.01452460f, 0.08388557f, -0.11283743f, -0.04615372f, 0.05997859f, 
    -0.17922972f, -0.24942829f, 0.05388074f, 0.02011104f, 0.43085992f, 0.09706055f, 0.12309548f, -0.09110984f, 
    -0.18050633f, 0.09726994f, -0.07927075f, -0.07663081f, 0.07801341f, -0.00652531f, -0.08287551f, -0.21434788f, 
    -0.30079186f, -0.11132925f, 0.00731925f, -0.02109910f, 0.02500376f, 0.00609584f, 0.06729893f, 0.07742529f, 
    -0.11578672f, 0.04073838f, -0.07424521f, -0.07949358f, 0.14019957f, 0.25193563f, 0.02430742f, -0.04562395f, 
    0.15820201f, 0.01298295f, 0.12398463f, 0.12963898f, -0.06716067f, -0.07179696f, 0.18653022f, -0.03163678f, 
    0.42335635f, 0.03634783f, 0.09978332f, 0.14903602f, 0.11623798f, -0.08693930f, -0.04077721f, 0.03211700f, 
    -0.18518296f, 0.08036934f, 0.04774004f, -0.07941582f, 0.26656097f, -0.00133136f, -0.04777862f, 0.01793424f, 
    0.02886072f, 0.18522146f, -0.07155311f, -0.04198479f, -0.03299488f, 0.03840670f, -0.15018313f, -0.14507803f, 
    0.15979560f, 0.01101358f, -0.10050735f, 0.11950628f, -0.13934037f, 0.05771990f, 0.09975735f, 0.05242305f, 
    -0.13562523f, 0.02392828f, 0.06939622f, 0.23188616f, -0.18477532f, -0.59624708f, -0.09725451f, -0.05041193f, 
    -0.16847198f, 0.08406267f, 0.04019271f, 0.00364443f, -0.05406507f, 0.01979591f, 0.08655579f, 0.01666969f, 
    0.21232131f, 0.05738423f, -0.01564795f, 0.02067803f, 0.01145578f, 0.09306188f, 0.09325187f, -0.25218406f, 
    -0.05964076f, 0.04055867f, 0.01528949f, 0.04065595f, 0.00398650f, -0.08175887f, 0.22816436f, 0.35012770f, 
    0.00349817f, -0.09699254f, -0.06565046f, 0.03289393f, -0.23907034f, -0.01834128f, -0.02637081f, 0.06972980f, 
    0.52312297f, -0.07521315f, 0.10462759f, 0.18389739f, -0.22788577f, -0.04878441f, 0.05391062f, -0.12497690f, 
    -0.00990660f, 0.09707028f, -0.11533214f, 0.07593416f, -0.59610194f, -0.14766367f, -0.37882766f, -0.06576218f, 
    0.01352310f, -0.04642171f, -0.10814814f, -0.09940455f, -0.21671607f, -0.06216045f, 0.00673665f, 0.07058964f, 
    0.02098988f, 0.14707482f, -0.15932830f, 0.13845797f, 0.00907980f, -0.11774255f, 0.08464836f, -0.02230930f, 
    -0.16439234f, -0.02697259f, 0.05334914f, -0.13314123f, 0.20576186f, 0.11927788f, 0.16528422f, 0.08639162f, 
    0.15504739f, -0.02289152f, -0.16447140f, -0.01415199f, -0.10980676f, -0.09378878f, -0.02001244f, 0.06847604f, 
    0.31468412f, 0.06035384f, 0.12890236f, -0.00495929f, -0.20328124f, 0.08118127f, 0.00021234f, 0.08577676f, 
    -0.07259371f, 0.22554137f, -0.00239673f, -0.01615997f, 0.25613782f, 0.04542242f, 0.07602004f, 0.09269683f, 
    -0.14496921f, 0.08773597f, -0.11991897f, -0.03141072f, -0.17786525f, 0.02899973f, -0.06551137f, 0.05167063f, 
    0.01472640f, 0.26825842f, 0.03042584f, 0.16335225f, 0.06814193f, -0.01178560f, 0.03632969f, 0.01450133f, 
    -0.02908214f, -0.14663209f, 0.04756763f, 0.10791251f, 0.00463128f, 0.09395884f, 0.13570806f, 0.13131905f, 
    -0.02035597f, 0.04316559f, -0.11698840f, -0.04254232f, -0.13705108f, -0.09732001f, 0.07031550f, -0.10538448f, 
    -0.01168152f, -0.05480160f, -0.00759787f, -0.05438717f, 0.05859915f, -0.01191128f, -0.07083794f, -0.03816010f, 
    0.02326719f, -0.08224183f, 0.04708410f, -0.06903259f, -0.00461967f, -0.04464940f, -0.00402076f, -0.01159515f, 
    -0.06512057f, -0.05271388f, -0.03685448f, -0.03448499f, -0.05237575f, -0.04544091f, -0.01071667f, 0.03646464f, 
    -0.06207936f, -0.02213758f, -0.03206586f, -0.00908433f, 0.04223421f, 0.04887785f, -0.02121406f, 0.05680266f, 
    -0.07131750f, -0.01471261f, 0.01394673f, -0.01412846f, -0.06338447f, -0.03105114f, 0.00834283f, 0.05295284f, 
    -0.06114922f, -0.00586449f, -0.01303169f, 0.06599131f, 0.00590254f, -0.04431289f, 0.02520821f, -0.05150810f, 
    -0.04100265f, -0.00270597f, -0.04556303f, 0.01360013f, 0.06025767f, 0.04412363f, 0.06461720f, 0.06073160f, 
    0.04518481f, 0.00274113f, 0.00208525f, -0.06954035f, -0.03025852f, -0.03354408f, -0.03130408f, 0.05532481f, 
    0.04907057f, 0.01595295f, -0.05986096f, 0.01863460f, -0.08004834f, -0.04459554f, 0.02592416f, -0.01685853f, 
    0.02415145f, -0.05166360f, -0.03229443f, -0.07342300f, -0.00811724f, 0.04516800f, 0.00080010f, 0.00869514f, 
    0.02883181f, -0.01213148f, -0.05535692f, -0.01102315f, -0.07332251f, -0.06521323f, -0.04707497f, -0.00266499f, 
    0.03687214f, 0.02487809f, -0.03826547f, 0.04621371f, -0.06161932f, -0.07363100f, -0.04754440f, 0.02112227f, 
    -0.02651676f, -0.03706685f, -0.00299990f, -0.06747073f, 0.02204635f, 0.02184074f, -0.07614086f, -0.00765667f, 
    0.05560645f, 0.00012821f, -0.03244821f, -0.00629375f, 0.00483748f, -0.04676160f, -0.04645281f, -0.02392328f, 
    -0.02678857f, -0.05557480f, 0.03371264f, -0.05372782f, -0.02599042f, 0.01032254f, 0.00357308f, -0.06589609f, 
    0.02091537f, 0.07178272f, 0.02236959f, -0.03535707f, 0.03481828f, -0.02983458f, -0.06349622f, 0.00136579f, 
    -0.01477062f, 0.00466663f, 0.02696285f, -0.03952681f, -0.00897064f, 0.03338949f, 0.06051078f, 0.01891045f, 
    -0.03048977f, 0.03319493f, 0.05106912f, -0.01197336f, -0.06989148f, 0.02772243f, -0.04971304f, -0.02044851f, 
    0.02380649f, 0.04408385f, 0.06241326f, 0.02848492f, -0.02526982f, 0.06061787f, 0.04126039f, 0.05553213f, 
    0.02120770f, 0.01656813f, -0.00910730f, 0.04075414f, -0.03666310f, 0.04981941f, -0.06392961f, -0.01153967f, 
    0.00264690f, -0.02853655f, 0.05744439f, -0.07016416f, 0.01350615f, 0.06413364f, -0.07479257f, 0.00121823f, 
    0.04080110f, 0.05116133f, 0.06076143f, -0.03249919f, 0.05851007f, 0.04790876f, -0.07193727f, 0.02101973f, 
    -0.07432003f, -0.07210907f, -0.06785133f, -0.05710394f, -0.05399700f, -0.02904342f, 0.04650187f, -0.04645883f, 
    -0.06872046f, 0.03688574f, 0.04246480f, -0.03322173f, 0.04677575f, -0.05543242f, 0.06319635f, -0.04174085f, 
    -0.31140783f, 0.21225400f, -0.02428927f, -0.00826890f, -0.08238031f, 0.06969915f, 0.02229819f, -0.02678235f, 
    -0.17170310f, 0.09088429f, -0.08810862f, -0.07890128f, -0.12985018f, -0.07348576f, -0.05496385f, 0.10653186f, 
    0.11173967f, -0.04911593f, -0.05104891f, -0.00907198f, 0.06039543f, 0.04227767f, 0.04465286f, -0.13262083f, 
    -0.05670096f, 0.02337289f, 0.17659308f, 0.26160526f, 0.04418103f, 0.10241146f, 0.07144830f, 0.02226708f, 
    -0.06182940f, -0.07541741f, 0.09700538f, -0.00036852f, 0.16255584f, 0.00141800f, -0.07378113f, 0.28203431f, 
    -0.02280520f, -0.06664301f, 0.01487370f, 0.15063810f, 0.08174008f, 0.06692795f, 0.08250654f, 0.19166669f, 
    0.28791055f, 0.23003393f, 0.13962838f, 0.05194245f, 0.02334301f, -0.15216170f, 0.14823772f, -0.06748560f, 
    0.00167541f, -0.08074693f, -0.09628636f, -0.11139788f, -0.22664638f, -0.02225845f, -0.20953734f, -0.05395003f, 
    0.13527715f, -0.04208468f, -0.06791487f, -0.01694797f, 0.12871796f, -0.00977090f, -0.12635177f, 0.05545896f, 
    -0.11153561f, 0.19771396f, -0.09439122f, -0.26840112f, 0.09537090f, -0.06911176f, 0.06282428f, 0.02925320f, 
    0.02930065f, -0.07010984f, 0.00588041f, -0.07209420f, -0.15599240f, -0.06695765f, -0.08704586f, 0.00114251f, 
    -0.02010750f, -0.14392971f, -0.05624587f, 0.11804226f, -0.06742174f, 0.05503156f, 0.13675423f, -0.02567804f, 
    -0.18477009f, 0.08571187f, -0.05169336f, 0.14960168f, 0.05579298f, 0.05699912f, -0.07380850f, 0.11077650f, 
    -0.06076809f, 0.09551912f, -0.10975505f, 0.00897379f, 0.09325294f, 0.03173254f, 0.02379007f, -0.04330476f, 
    -0.02854834f, 0.05918875f, -0.01177306f, -0.08262531f, 0.02117567f, -0.07475801f, -0.09647481f, -0.02971395f, 
    -0.06054448f, 0.10160518f, 0.03435686f, 0.01472106f, 0.00145475f, 0.06154749f, 0.16375439f, -0.06029424f, 
    -0.16533153f, -0.10937320f, 0.14170824f, -0.02890245f, 0.57096434f, 0.12011053f, -0.07185245f, 0.01988480f, 
    0.15716846f, 0.12420908f, -0.09318984f, -0.09546370f, -0.00423971f, -0.01986982f, 0.08317865f, -0.13192025f, 
    0.30941489f, -0.15371773f, -0.12355420f, 0.12686898f, 0.08361404f, 0.11621477f, 0.19376022f, -0.06532533f, 
    -0.15686457f, 0.14652604f, 0.11705842f, 0.02231736f, 0.01133922f, 0.00037219f, -0.09846611f, 0.15089828f, 
    0.01204659f, 0.10162685f, -0.07162704f, -0.03947037f, 0.04859611f, 0.08025718f, 0.01026598f, 0.03998557f, 
    0.03938971f, -0.15337403f, 0.09192058f, 0.07314821f, 0.14090675f, -0.03855005f, 0.00988789f, 0.05407192f, 
    -0.00375526f, -0.12477930f, 0.09901173f, -0.12598020f, -0.17777695f, 0.15770985f, 0.06775812f, -0.15936376f, 
    0.09371636f, -0.00460914f, 0.02618277f, -0.17636237f, 0.06334961f, 0.10891898f, 0.02311934f, 0.12069145f, 
    -0.05943500f, 0.05246602f, -0.05498686f, -0.07430702f, 0.01646900f, -0.06519523f, -0.03866437f, 0.02361492f, 
    -0.06009033f, -0.04528713f, 0.03593042f, 0.02205763f, 0.01905963f, 0.06389765f, 0.05332603f, -0.02053282f, 
    -0.02809704f, 0.03180306f, 0.05656661f, -0.02065055f, -0.05170990f, -0.00204709f, 0.06161443f, -0.02528306f, 
    -0.04305185f, -0.05775116f, -0.07136673f, -0.06404385f, 0.01738627f, 0.02678720f, -0.01173984f, -0.05698841f, 
    0.03770206f, 0.02746803f, -0.05226531f, 0.01624481f, 0.05466526f, -0.05505037f, -0.01360635f, 0.04029454f, 
    -0.00767134f, -0.00059649f, -0.05939215f, -0.04863736f, -0.07860071f, -0.02396147f, 0.00340737f, -0.05822560f, 
    -0.05781435f, -0.01005038f, -0.05508041f, 0.04729921f, 0.05826123f, -0.04180223f, -0.07104349f, 0.03816023f, 
    -0.03146805f, -0.07858569f, 0.04454063f, -0.07845610f, -0.05793284f, -0.06925962f, 0.04609362f, 0.03975549f, 
    -0.00295064f, 0.03056705f, 0.01664080f, -0.03406842f, 0.05972953f, 0.06001665f, -0.04405807f, 0.02833947f, 
    0.02987560f, -0.08397023f, 0.04127248f, 0.03768608f, -0.01361150f, -0.06095744f, -0.06241957f, -0.05718844f, 
    -0.07108576f, 0.05040991f, -0.02287412f, 0.02101148f, -0.07006314f, -0.00011039f, -0.00402004f, 0.04499635f, 
    -0.05240327f, 0.05160044f, -0.00158958f, -0.08126909f, -0.03216626f, -0.00609824f, 0.00326924f, 0.00023416f, 
    0.02188178f, -0.02626937f, 0.02412012f, -0.00129784f, -0.03416279f, -0.04746024f, -0.05559910f, -0.04444182f, 
    -0.01345286f, -0.07551701f, -0.04821042f, 0.00363159f, 0.00886053f, -0.06389727f, -0.05776744f, -0.06480087f, 
    -0.04706549f, 0.05389405f, -0.03096609f, 0.05620098f, 0.05702627f, -0.01099805f, -0.06462499f, 0.06061706f, 
    -0.04385948f, 0.03971848f, 0.03038608f, -0.06276675f, -0.02330666f, -0.02803860f, -0.07250845f, 0.03448452f, 
    -0.00225756f, 0.05735633f, -0.06028205f, 0.03648031f, -0.04744713f, -0.01786906f, -0.05920051f, -0.03034149f, 
    -0.03494770f, 0.00586654f, -0.01577447f, -0.05127385f, 0.03751098f, -0.07841304f, -0.05620643f, 0.01492271f, 
    -0.07086542f, -0.06600454f, -0.03223048f, 0.01567508f, -0.00251219f, -0.00461855f, 0.04030310f, -0.04103281f, 
    -0.07828788f, 0.05084656f, 0.02355231f, -0.04605413f, -0.01645949f, -0.04521511f, -0.01855892f, -0.03979602f, 
    -0.02590923f, 0.02580683f, 0.01829112f, 0.04159156f, -0.02243110f, 0.04935397f, 0.04640274f, -0.01026996f, 
    -0.03350015f, 0.02849130f, -0.06456416f, 0.00282173f, -0.05837950f, -0.07285029f, -0.03965563f, -0.01083501f, 
    0.01519488f, 0.04550439f, -0.08231760f, -0.02827500f, 0.00985979f, 0.01723462f, 0.04002620f, -0.07298687f, 
    -0.03000076f, -0.04815507f, -0.01012154f, 0.02090434f, -0.05356641f, 0.05617206f, -0.00838074f, 0.01614881f, 
    -0.01995318f, 0.00098686f, -0.08312603f, 0.00294970f, 0.01289069f, 0.01228853f, -0.06335726f, -0.05629224f, 
    0.00622869f, -0.00377737f, 0.02897902f, -0.05430095f, -0.05006140f, -0.00469759f, -0.05177093f, 0.05291360f, 
    -0.03645394f, 0.05357301f, -0.01016444f, 0.04311921f, 0.00807975f, -0.03551871f, 0.05148082f, -0.05465056f, 
    0.05972112f, -0.06530745f, -0.04037113f, 0.02215168f, -0.05688263f, -0.00552573f, 0.05516886f, 0.03023526f, 
    0.00055403f, -0.04068462f, -0.02533806f, -0.04660155f, -0.07460867f, -0.08007819f, 0.05118744f, -0.01977575f, 
    -0.00024030f, -0.01279195f, -0.03978918f, -0.02564096f, -0.03491185f, -0.05035589f, -0.02433066f, -0.08389280f, 
    0.00004226f, 0.01422843f, -0.02439545f, 0.02651512f, 0.04894133f, -0.07881151f, 0.05000705f, 0.04095254f, 
    -0.04232514f, -0.07568526f, -0.00455282f, -0.02865892f, -0.07844476f, -0.06794930f, -0.01671752f, 0.05084972f, 
    0.03400321f, -0.06845827f, 0.00725835f, -0.07434315f, -0.03730443f, -0.06157459f, -0.05128513f, -0.07320976f, 
    -0.01617069f, 0.00071320f, -0.02911344f, -0.00959778f, -0.02586094f, -0.01609544f, -0.00184827f, -0.00399121f, 
    0.03194965f, 0.02145076f, -0.01379603f, 0.04851298f, -0.01054037f, -0.07043628f, 0.03462031f, -0.05326403f, 
    0.05306381f, 0.03693026f, -0.07236146f, 0.06006969f, 0.00604700f, 0.01259742f, -0.02897186f, 0.00103472f, 
    -0.01136594f, -0.01241920f, 0.01785070f, -0.02271346f, -0.06386694f, 0.02003636f, 0.02576656f, -0.07779013f, 
    -0.02976524f, -0.02380782f, 0.03011660f, 0.00529097f, -0.03489566f, -0.01478483f, -0.01794181f, -0.04461165f, 
    0.05273331f, -0.01330149f, 0.00987724f, 0.00774637f, -0.00933251f, 0.01042054f, 0.02080839f, 0.02950731f, 
    -0.00671717f, -0.06089196f, -0.05552146f, 0.05366097f, -0.04916718f, 0.05878437f, -0.00033391f, -0.05055991f, 
    0.00596782f, -0.06419234f, -0.02201653f, -0.03167350f, -0.06702936f, 0.04318786f, -0.02011917f, -0.00698645f, 
    0.05413245f, 0.05976985f, -0.04637301f, 0.00854698f, -0.05592625f, 0.02212201f, -0.01884059f, 0.03866749f, 
    -0.07945641f, -0.02857991f, 0.01598932f, -0.05653058f, 0.00613149f, -0.04145326f, 0.02406504f, -0.06825294f, 
    -0.03253483f, -0.03087191f, -0.00397122f, -0.02101258f, -0.06768260f, 0.05915193f, 0.00803289f, 0.05279998f, 
    0.02956799f, 0.00463054f, 0.00881591f, -0.03233002f, 0.05031893f, -0.05012014f, -0.05813504f, 0.04116618f, 
    0.05249995f, -0.06213516f, 0.01085155f, -0.04035451f, 0.05399052f, -0.06551229f, 0.04347664f, -0.04292779f, 
    -0.05133021f, 0.04000084f, -0.02611920f, 0.01138660f, 0.04783330f, -0.00186700f, -0.03592240f, -0.02267936f, 
    -0.03229042f, 0.05366237f, 0.02118607f, -0.02093066f, 0.04326411f, -0.04401232f, -0.02215114f, -0.02981026f, 
    -0.07903701f, 0.32626942f, -0.02784413f, 0.10235738f, 0.04323731f, 0.18141547f, -0.01913920f, 0.02279512f, 
    -0.02049806f, 0.09531642f, 0.08362620f, -0.16729110f, -0.19602898f, -0.09908456f, -0.01281060f, 0.13886704f, 
    0.33073738f, 0.07129230f, -0.08918925f, -0.10003098f, 0.01327288f, 0.12029944f, 0.26712710f, 0.03532485f, 
    0.25091875f, 0.02432630f, 0.13385785f, -0.20442067f, 0.01476236f, 0.07711997f, 0.09316932f, 0.02411379f, 
    0.00111821f, 0.00012285f, -0.12487573f, 0.02480807f, -0.34003502f, 0.00348461f, 0.13690601f, -0.08685863f, 
    0.02428712f, -0.06011184f, -0.06386365f, 0.15428399f, 0.06388181f, 0.02771350f, 0.09344521f, 0.17557785f, 
    0.12407593f, -0.29324317f, 0.20083722f, 0.13879402f, -0.05822299f, -0.12423760f, 0.08681378f, 0.08566459f, 
    -0.10757458f, 0.09463660f, 0.10715043f, -0.10173211f, 0.50745815f, 0.23987050f, 0.27381018f, 0.41643998f, 
    -0.10441729f, 0.09600905f, 0.11050372f, 0.06801546f, 0.02780003f, 0.04995025f, -0.02564437f, 0.06586214f, 
    -0.02649077f, 0.09148282f, -0.07948366f, -0.10592157f, -0.00535789f, 0.12608436f, 0.00739890f, -0.01321980f, 
    0.03356692f, -0.04177453f, 0.09707227f, -0.06898115f, 0.02149767f, 0.06201084f, -0.13904847f, -0.06171307f, 
    0.01627196f, 0.25134102f, -0.01452697f, 0.02968689f, -0.10483745f, -0.03609289f, 0.06164317f, 0.02675526f, 
    -0.36378255f, -0.01823356f, -0.18152161f, 0.04251257f, 0.12394113f, -0.00785899f, 0.01518889f, 0.31379634f, 
    0.03690198f, -0.14679810f, -0.11548083f, -0.07198961f, 0.19925630f, -0.13087997f, 0.27405769f, 0.06351429f, 
    -0.03535264f, -0.06242633f, -0.08596483f, 0.03899102f, 0.05129706f, 0.03802556f, -0.09226526f, 0.06090229f, 
    -0.19081606f, -0.24680568f, 0.25962660f, 0.01057457f, -0.18459962f, 0.02238963f, -0.01960448f, -0.05961160f, 
    -0.09139506f, -0.23724747f, -0.05603183f, 0.01155743f, 0.15784769f, -0.20349389f, -0.04157671f, 0.14639042f, 
    0.06170734f, 0.14844900f, 0.01927990f, -0.10706497f, 0.06770277f, -0.08564918f, 0.02572052f, 0.09160703f, 
    -0.02569363f, 0.07945853f, -0.04164857f, -0.15683532f, 0.06068328f, 0.05500220f, -0.13397670f, 0.12927550f, 
    0.18131585f, -0.07286362f, 0.01807313f, 0.06388029f, -0.19512083f, -0.15211496f, -0.13102122f, 0.12668177f, 
    0.05534895f, 0.11462456f, -0.13902354f, 0.24538594f, 0.15774931f, 0.10843511f, 0.08389932f, 0.12342317f, 
    -0.38008261f, 0.06335841f, 0.01150521f, -0.38370699f, -0.04772829f, 0.07827220f, -0.03243330f, -0.10403102f, 
    0.20431687f, -0.06336927f, 0.03174515f, 0.02677777f, -0.35476905f, 0.12918182f, -0.11311154f, -0.19021493f, 
    0.11167587f, 0.08899412f, 0.05887821f, -0.20916773f, 0.15621698f, -0.02270130f, 0.00314604f, 0.00041235f, 
    -0.25939861f, 0.15075073f, 0.17496619f, -0.10592666f, 0.01930468f, 0.03833411f, -0.11089688f, 0.13248503f, 
    -0.04485667f, 0.04264774f, 0.06200366f, -0.09865571f, 0.35758850f, 0.32561094f, -0.23015065f, 0.09527113f, 
    0.14281760f, 0.03029038f, 0.02786617f, -0.05352286f, -0.06428402f, -0.09688221f, 0.06671309f, -0.07109401f, 
    -0.40961838f, 0.19661409f, 0.21799602f, 0.04888087f, 0.05684246f, -0.07550371f, 0.08345468f, -0.07088269f, 
    0.04637106f, 0.02639972f, -0.13924560f, -0.02224630f, 0.04273986f, -0.06891844f, 0.26960537f, 0.05125459f, 
    -0.01322933f, 0.03496713f, 0.00567818f, -0.01285840f, -0.02311602f, 0.06503194f, 0.19666924f, 0.15929478f, 
    -0.07067210f, -0.10237045f, 0.23032355f, -0.03805793f, -0.02111933f, -0.10876088f, -0.06829049f, 0.14717589f, 
    -0.11527164f, 0.11366697f, -0.03944065f, -0.01437228f, 0.28369692f, -0.28923929f, -0.06104328f, 0.39559880f, 
    -0.37741819f, 0.02381228f, -0.06697211f, 0.07429145f, 0.04892300f, -0.07471727f, -0.00709804f, 0.05176993f, 
    0.08606803f, 0.06235420f, -0.14565755f, -0.18080798f, 0.04381391f, -0.00571246f, -0.03284616f, -0.01232104f, 
    -0.06693158f, 0.02610460f, -0.18969022f, -0.06514679f, -0.07038740f, -0.02114266f, -0.25894925f, 0.07470661f, 
    0.06694239f, -0.03721239f, -0.01014778f, 0.09173328f, -0.02638029f, -0.00990917f, 0.01499444f, 0.09034945f, 
    -0.09289528f, -0.03218905f, 0.01645900f, 0.09149386f, 0.12402623f, 0.01513901f, -0.05800186f, 0.15568481f, 
    -0.11283705f, -0.02144409f, 0.00380375f, 0.18775848f, 0.09389141f, -0.44197267f, 0.26904786f, -0.00096414f, 
    -0.12437274f, -0.08501624f, -0.02292170f, -0.02043245f, 0.03907381f, 0.11192036f, -0.00551390f, 0.10431051f, 
    0.07174879f, -0.45927200f, 0.17227058f, 0.17780778f, -0.13840860f, -0.01668795f, 0.17020957f, 0.02103967f, 
    -0.09722341f, 0.01897114f, -0.00868564f, -0.01226983f, 0.19459105f, 0.08864266f, 0.04430101f, 0.11457939f, 
    0.17747170f, 0.14442447f, 0.02685122f, -0.13959350f, 0.09896766f, -0.05431800f, 0.16714458f, -0.02189249f, 
    0.06812231f, 0.24861398f, 0.26113257f, -0.10017892f, 0.03368134f, 0.11924409f, 0.06116406f, -0.17027393f, 
    0.08038903f, -0.06325808f, 0.01747341f, -0.21356374f, 0.27530989f, 0.05853223f, -0.00293202f, 0.00570279f, 
    -0.09813424f, 0.01642721f, 0.10656897f, 0.22051352f, -0.09419341f, -0.07683241f, 0.04900798f, 0.16547114f, 
    -0.14590307f, 0.41626737f, -0.11629597f, -0.30838999f, 0.06531791f, 0.19227603f, 0.06900085f, 0.12353947f, 
    0.23210657f, 0.17333651f, 0.02605153f, 0.04323279f, -0.15303081f, -0.07601463f, -0.29543447f, 0.07619879f, 
    0.08751156f, 0.02952281f, 0.04116894f, -0.04980591f, 0.06070773f, -0.04883163f, 0.24988449f, 0.08970965f, 
    -0.07687803f, 0.08969302f, 0.08351144f, -0.08549254f, 0.11195773f, 0.13374074f, 0.03981910f, 0.04901942f, 
    0.07193671f, 0.03805390f, 0.24109054f, 0.04323348f, -0.12280925f, -0.32189661f, -0.21715851f, 0.09619844f, 
    -0.20751971f, -0.00049632f, -0.13909939f, -0.15876476f, -0.04692759f, -0.08543298f, 0.04034935f, -0.07694165f, 
    -0.02414509f, 0.08643622f, 0.11701073f, -0.01102758f, -0.03136516f, 0.08688714f, -0.02958295f, 0.11356699f, 
    0.02971028f, 0.01502082f, 0.00686439f, 0.00652660f, -0.06831668f, 0.00568260f, 0.00774750f, 0.20214024f, 
    0.08251701f, 0.02146672f, 0.02809254f, 0.22320092f, 0.00394320f, 0.06607105f, 0.15508762f, 0.01382801f, 
    0.10147087f, 0.08399962f, 0.20259131f, 0.23418763f, -0.05146207f, 0.00830647f, 0.03519202f, -0.04336357f, 
    0.17296621f, 0.07179584f, 0.14459525f, -0.00403340f, 0.07125007f, 0.17534089f, 0.23764290f, -0.15860163f, 
    0.05502818f, -0.15766393f, -0.03811148f, -0.04621365f, 0.08343592f, 0.14390928f, 0.06988812f, 0.06870919f, 
    -0.22615393f, 0.07328019f, -0.05203063f, -0.19723789f, -0.05775035f, -0.12339958f, 0.15738152f, 0.19640899f, 
    0.02501006f, -0.19347259f, 0.04777371f, 0.03518105f, 0.04334516f, 0.22868937f, 0.01720488f, -0.25463554f, 
    -0.01253035f, 0.02132307f, -0.13247040f, 0.18291272f, 0.11289157f, 0.05102858f, 0.24273194f, -0.06780621f, 
    -0.77460134f, 0.32012171f, -0.10099003f, -0.21067861f, 0.17143057f, 0.02300117f, 0.04869972f, 0.09047333f, 
    -0.00932272f, 0.00427125f, -0.08633846f, 0.04662529f, 0.06693348f, -0.18150038f, -0.12149084f, 0.06116010f, 
    -0.02391409f, -0.00457075f, 0.04143347f, 0.07305300f, 0.20113859f, 0.12602939f, 0.03482692f, 0.09629327f, 
    0.09663981f, -0.20079082f, 0.05247349f, 0.14344051f, 0.06948006f, 0.15434419f, 0.08499302f, 0.01013412f, 
    -0.03803426f, -0.20767875f, 0.02630846f, 0.15743858f, 0.03558825f, 0.07914984f, 0.02294178f, 0.12358747f, 
    -0.02814743f, 0.00681141f, 0.00505646f, -0.03114427f, 0.13209261f, -0.03439880f, 0.12490607f, 0.02893357f, 
    -0.16771883f, -0.02342191f, -0.21918216f, -0.01101200f, 0.11371905f, 0.04252566f, 0.12408739f, -0.02475844f, 
    0.05898140f, -0.11490618f, 0.09879378f, 0.06325034f, -0.00303630f, 0.18448007f, -0.12377900f, 0.02731806f, 
    0.18650697f, 0.01863100f, -0.01275292f, 0.03465238f, 0.11620213f, 0.00343607f, 0.08059681f, 0.08349638f, 
    -0.37373823f, -0.12229300f, 0.02311662f, 0.05617471f, -0.14960472f, -0.04191811f, 0.14545001f, 0.03552912f, 
    -0.00232489f, 0.07955951f, 0.03633339f, -0.12661871f, 0.08486018f, 0.22058797f, 0.12534675f, -0.35847771f, 
    -0.02103761f, -0.05826040f, -0.01050243f, 0.01835847f, 0.09670524f, -0.05200393f, 0.01422212f, 0.15542345f, 
    0.32296970f, 0.01853099f, 0.05584076f, -0.16136354f, -0.06542037f, 0.19403891f, 0.01981197f, 0.04401611f, 
    0.08693358f, 0.16389206f, -0.01506872f, 0.09337525f, -0.01844907f, -0.11526804f, -0.09148842f, -0.06306479f, 
    0.02640624f, 0.04019255f, -0.00762009f, -0.06819618f, 0.06956248f, 0.07255124f, 0.09402175f, 0.11616227f, 
    -0.21398662f, -0.15869793f, -0.22313678f, 0.37266511f, -0.06347296f, -0.03415981f, 0.14165097f, -0.13790756f, 
    0.08508735f, 0.09981039f, 0.04014336f, 0.04571127f, 0.02825701f, 0.07946694f, -0.09949311f, -0.16395633f, 
    -0.03815330f, -0.04635421f, -0.00790964f, 0.17992194f, -0.16676053f, 0.01619879f, 0.01988409f, 0.14383613f, 
    0.08856409f, -0.01102737f, 0.01551613f, 0.39648250f, -0.13473248f, -0.15997148f, 0.24410063f, 0.22317606f, 
    -0.02877666f, -0.10928766f, 0.01068660f, -0.05800712f, 0.19875886f, 0.33215198f, 0.23401143f, -0.40223253f, 
    0.01372605f, 0.16249146f, -0.06485857f, 0.09105101f, -0.14014214f, -0.03128662f, -0.00986655f, 0.16543999f, 
    0.12176076f, -0.25297531f, 0.20177816f, -0.16291098f, -0.05508402f, 0.05718602f, -0.02675508f, -0.02192833f, 
    0.19617939f, 0.02655891f, -0.02456734f, 0.14166905f, 0.28353104f, 0.19143347f, -0.06768478f, -0.23477775f, 
    0.02702666f, 0.09527563f, -0.03729246f, -0.01157006f, -0.02657668f, 0.00486447f, 0.04693123f, -0.00235555f, 
    0.23869039f, -0.16845770f, -0.07837906f, 0.10913742f, -0.00734646f, 0.18117863f, 0.07353406f, -0.05908895f, 
    0.11621124f, -0.08304188f, 0.15364739f, 0.00646040f, -0.20822521f, 0.17771466f, 0.07308423f, -0.12766369f, 
    0.03916623f, -0.00038588f, -0.00247177f, 0.10182456f, -0.00933621f, 0.11998647f, 0.05995972f, 0.02131297f, 
    -0.00304707f, 0.00833782f, -0.08202760f, -0.09207434f, 0.06415748f, -0.00501250f, 0.00005347f, 0.05632318f, 
    -0.02366500f, 0.01747677f, -0.16538469f, 0.01859574f, -0.11517018f, -0.02761670f, -0.06733585f, -0.21850413f, 
    0.00706556f, 0.06343582f, 0.06629323f, -0.08424883f, -0.01236209f, -0.11964840f, 0.05377276f, -0.02834929f, 
    0.55939221f, 0.04426875f, -0.29492739f, 0.02913299f, 0.10298803f, 0.15542489f, -0.00349292f, 0.11219118f, 
    0.10151153f, 0.02419739f, -0.01337935f, -0.01771715f, -0.10927600f, -0.04650008f, -0.16056554f, 0.16983171f, 
    -0.00820771f, 0.11033551f, -0.03926134f, 0.03609557f, -0.16275428f, -0.04658018f, -0.05265873f, -0.06919913f, 
    -0.07525524f, -0.29496330f, 0.04005526f, -0.13314922f, 0.13818675f, 0.12439623f, -0.02357965f, 0.12514548f, 
    0.01185441f, -0.01140908f, 0.05060062f, -0.00797775f, 0.31615731f, 0.21813636f, -0.09099064f, -0.18799683f, 
    0.10303262f, 0.05855483f, -0.01683050f, 0.01301148f, 0.01850475f, 0.00516249f, 0.01619798f, 0.01933589f, 
    -0.20508899f, -0.38913891f, 0.43385461f, -0.05255815f, 0.06537861f, 0.03898248f, -0.14331056f, -0.07735096f, 
    0.14913337f, -0.02989451f, 0.02259903f, 0.10563451f, 0.46057647f, 0.24983038f, -0.25267306f, -0.28340182f, 
    -0.07758144f, 0.06029525f, 0.09076110f, -0.11327029f, -0.06648856f, -0.06095777f, -0.11175999f, -0.06616440f, 
    -0.14079884f, -0.20039701f, 0.15984768f, 0.32620305f, 0.06027687f, -0.01650581f, 0.00109595f, -0.09252513f, 
    0.03894896f, 0.10202797f, -0.16813423f, -0.08958295f, 0.31030586f, -0.03024968f, 0.05376608f, -0.02764526f, 
    -0.00497514f, 0.08356854f, 0.03326652f, 0.04733097f, -0.05463246f, 0.12605108f, 0.13618770f, 0.07788730f, 
    -0.08177470f, 0.18727213f, -0.07615726f, 0.08401220f, 0.03069550f, -0.01611085f, 0.06961088f, 0.19376947f, 
    0.02002212f, 0.04944386f, 0.08048256f, 0.11807626f, -0.15624617f, -0.29803389f, 0.07382724f, -0.21793097f, 
    -0.08186650f, -0.00162863f, -0.12551023f, 0.05036623f, 0.04082173f, 0.00114986f, 0.07891159f, 0.11717083f, 
    0.34128869f, -0.21797261f, -0.00512607f, -0.14396653f, -0.18307424f, -0.08399975f, 0.06873401f, -0.01328034f, 
    0.04665132f, 0.03843752f, -0.02250707f, 0.06603384f, 0.42252743f, 0.09010445f, 0.16830444f, 0.18059970f, 
    0.09750265f, 0.02111932f, 0.07552548f, 0.15387820f, 0.04766277f, 0.10576823f, 0.04465168f, 0.05626949f, 
    0.40596366f, -0.18202265f, -0.00968777f, -0.16434748f, 0.00558718f, -0.07613301f, -0.04105890f, -0.12543432f, 
    0.08003706f, 0.03712985f, 0.16589823f, -0.08687520f, -0.28334293f, -0.26695094f, -0.06850728f, -0.08021072f, 
    0.03621376f, -0.08573450f, 0.03902157f, -0.01200199f, 0.14556082f, 0.10445819f, 0.20663771f, 0.13975953f, 
    0.52415740f, -0.03694240f, 0.01863417f, 0.12080164f, 0.09476737f, 0.00421648f, 0.09883776f, 0.07130589f, 
    0.11185460f, 0.16229098f, -0.05377704f, 0.09382318f, -0.13675895f, 0.15331484f, 0.04990194f, -0.04949902f, 
    0.08462077f, 0.03419418f, 0.06878994f, -0.17041421f, 0.08969612f, -0.17433023f, 0.03015543f, 0.04472498f, 
    -0.00707955f, 0.00814231f, 0.16232951f, -0.09978659f, -0.01380001f, 0.18302606f, -0.00259762f, 0.05650045f, 
    -0.03895058f, 0.03974305f, -0.12874718f, 0.01591913f, -0.13189156f, 0.02432885f, -0.11419947f, -0.10313539f, 
    -0.10553215f, 0.04336634f, -0.03098511f, -0.02101846f, -0.09583019f, -0.10710907f, 0.01016259f, 0.05715346f, 
    -0.05700042f, 0.20359185f, 0.08474793f, 0.05227585f, 0.04355151f, 0.03417241f, 0.03283308f, 0.14725929f, 
    0.04620050f, 0.06101527f, 0.01757331f, 0.14475706f, 0.46660608f, -0.26685011f, 0.01519613f, 0.11855611f, 
    -0.03108116f, -0.08144008f, 0.14219114f, 0.19645976f, -0.03696810f, 0.06706009f, 0.05539245f, -0.00651299f, 
    -0.01661510f, 0.04471654f, 0.16160925f, 0.11500906f, 0.05450482f, 0.04896435f, 0.00882465f, -0.03122304f, 
    -0.03642381f, 0.11145424f, 0.11128759f, -0.06600454f, -0.31900609f, -0.27689183f, -0.05157171f, 0.26691324f, 
    -0.08337107f, 0.02052637f, -0.09197984f, -0.08264990f, -0.13738304f, 0.01296735f, -0.05096364f, -0.06452965f, 
    0.25898424f, 0.08422048f, 0.05845914f, 0.21912232f, -0.07820551f, 0.01522439f, 0.04082320f, 0.05604801f, 
    0.01189581f, 0.07478856f, -0.09180801f, -0.01295948f, -0.18020239f, -0.13713741f, 0.25140452f, 0.17168188f, 
    -0.12603045f, 0.05701047f, -0.06555122f, 0.19689852f, 0.01475876f, -0.08848209f, -0.02659151f, 0.07709889f, 
    -0.00008192f, 0.17039238f, 0.04119916f, 0.11623688f, -0.12915567f, -0.10025132f, 0.02044569f, -0.00573103f, 
    0.15006879f, -0.03259771f, 0.11019747f, -0.07239752f, 0.37606481f, 0.12032293f, 0.16154191f, 0.03744817f, 
    0.10617448f, 0.01248713f, 0.09227965f, 0.03331709f, 0.04509706f, 0.10811784f, 0.01673837f, 0.11550184f, 
    0.06261328f, -0.09313335f, -0.04128449f, -0.33471420f, -0.08919512f, 0.03940022f, 0.15754396f, 0.07732345f, 
    0.00303196f, -0.14578228f, 0.04444928f, 0.06091082f, -0.16544633f, -0.09851269f, 0.01769307f, -0.24470070f, 
    0.12003148f, 0.05810486f, -0.08820496f, 0.01393962f, -0.05057012f, 0.11055569f, 0.22812457f, -0.11161708f, 
    -0.44743571f, 0.23224777f, 0.07292292f, -0.32530031f, 0.08822475f, -0.06686033f, 0.04571844f, 0.07569117f, 
    -0.05434438f, 0.00484669f, -0.09198819f, 0.01644981f, 0.34737960f, -0.19929053f, 0.12871049f, 0.18948765f, 
    0.03986387f, -0.01440151f, -0.07828041f, 0.02034410f, 0.03397774f, -0.02807125f, 0.00945898f, 0.08983223f, 
    0.00439245f, -0.14350608f, 0.01825060f, 0.27359331f, 0.05925662f, -0.01507370f, 0.08018970f, -0.11204027f, 
    -0.08896146f, -0.14402494f, 0.07395717f, 0.19223015f, 0.10037147f, 0.11987574f, -0.15806332f, 0.19524856f, 
    0.06517961f, 0.08066183f, -0.04410254f, -0.03189844f, 0.18837534f, -0.03881495f, 0.05549193f, -0.01760546f, 
    -0.10495944f, -0.04055122f, 0.05397496f, 0.07505687f, 0.11150772f, 0.08837685f, 0.13351364f, -0.10268892f, 
    0.14900626f, -0.09262286f, 0.04106142f, 0.11809804f, 0.12497161f, 0.16141140f, 0.07368393f, 0.02015051f, 
    0.12565511f, 0.02475806f, -0.06906728f, 0.03531810f, 0.15957433f, -0.08869100f, 0.14134236f, 0.06858671f, 
    -0.58334666f, 0.17451513f, -0.01581298f, 0.13713901f, -0.08523564f, -0.01249183f, 0.13468856f, 0.02086548f, 
    0.01067478f, -0.09405021f, -0.11620685f, -0.10953319f, -0.21533114f, -0.06471562f, 0.25032601f, -0.32794759f, 
    0.05213759f, 0.11535572f, 0.05478816f, -0.21984519f, 0.07891303f, 0.08127386f, 0.09923707f, 0.02323334f, 
    -0.07150043f, 0.02646636f, -0.00540136f, 0.00446679f, -0.00429092f, -0.08448213f, 0.00005661f, 0.00152465f, 
    -0.09867735f, -0.03531956f, 0.01295014f, 0.00698269f, -0.04285149f, 0.03920589f, -0.11002281f, -0.06601827f, 
    -0.04020697f, -0.04499267f, -0.03273798f, -0.05187792f, -0.05286121f, -0.05557359f, -0.08780110f, -0.00297160f, 
    0.04192619f, 0.03581169f, 0.02440271f, 0.02539306f, -0.02043466f, 0.01878978f, 0.05312268f, -0.01864866f, 
    0.03498499f, 0.05838114f, -0.04428045f, 0.02158877f, -0.00312550f, -0.03783841f, -0.04385775f, 0.01905686f, 
    -0.04320037f, -0.04215275f, 0.01963655f, 0.01912150f, -0.03883224f, -0.00212958f, -0.00194249f, -0.00046071f, 
    -0.00594782f, -0.07822369f, 0.03950877f, -0.01646083f, 0.04363874f, 0.06207617f, 0.06829835f, 0.00622948f, 
    -0.06177745f, 0.03852705f, 0.04575959f, 0.02046960f, 0.04114391f, -0.02037127f, 0.07475534f, 0.02546340f, 
    0.04706940f, -0.04236384f, -0.05114188f, 0.02320400f, -0.06959617f, 0.02513631f, 0.02784051f, -0.01628852f, 
    -0.04522214f, -0.06579164f, 0.02189343f, -0.08265555f, -0.08521966f, 0.01464370f, 0.05115235f, 0.04503622f, 
    -0.08977016f, -0.06956993f, 0.04509443f, -0.01644032f, -0.00230883f, 0.06953678f, -0.00728058f, -0.07759098f, 
    0.05101858f, -0.00306978f, -0.05196044f, -0.00413038f, -0.06091190f, -0.03043347f, -0.07043581f, -0.04546803f, 
    -0.02008565f, -0.02765654f, -0.10102218f, 0.03639737f, -0.01369136f, 0.01819785f, 0.04594663f, -0.03857712f, 
    -0.02762350f, -0.07477103f, 0.04220666f, -0.03976940f, -0.01978421f, 0.01172084f, -0.06007165f, -0.06524765f, 
    -0.10417653f, 0.00344553f, -0.02066130f, 0.03531178f, -0.06031870f, -0.00200992f, -0.02833569f, -0.04103038f, 
    0.03408552f, -0.06259008f, -0.08129405f, 0.04968639f, -0.05732272f, 0.06050107f, -0.01011926f, 0.00912928f, 
    -0.06556388f, -0.01381733f, 0.01300212f, -0.02636106f, -0.04231174f, -0.03679708f, -0.05571444f, -0.03751177f, 
    0.01739462f, -0.03589608f, 0.02623098f, -0.01730701f, 0.00741660f, -0.04409350f, -0.05184810f, -0.08303803f, 
    -0.05643705f, 0.04288622f, -0.04964184f, -0.05657722f, 0.00435593f, 0.04764528f, -0.04063804f, 0.07675054f, 
    -0.07300665f, -0.00588854f, -0.01577391f, 0.01757791f, 0.01436513f, -0.08738788f, 0.03632150f, -0.06078776f, 
    0.05019902f, 0.04842255f, 0.02665737f, 0.02411855f, 0.01020523f, -0.01428156f, 0.05977852f, -0.05375239f, 
    -0.00219295f, 0.03609101f, -0.05691645f, -0.03536614f, -0.00499531f, 0.02160439f, 0.06023441f, 0.04759854f, 
    -0.01733896f, 0.05240818f, 0.03022402f, -0.07203028f, -0.04824999f, -0.07557216f, 0.02728088f, -0.03950036f, 
    -0.05729344f, -0.06677686f, -0.06663492f, 0.03886844f, 0.01006274f, -0.06473558f, -0.03896702f, -0.06425476f, 
    -0.00879747f, 0.01343006f, 0.03452798f, 0.02723736f, -0.03388391f, -0.05922051f, -0.03118392f, 0.04299710f, 
    -0.00809115f, -0.01611448f, -0.05408612f, 0.03709063f, -0.05666196f, 0.03351726f, -0.05796757f, 0.04880589f, 
    -0.00692185f, 0.03076178f, 0.01154449f, -0.01267375f, 0.06004003f, -0.04815297f, -0.06928130f, 0.05070191f, 
    0.04693047f, 0.00575896f, -0.07541922f, -0.03756284f, -0.01312665f, -0.00453491f, 0.05026925f, 0.01154084f, 
    0.04033671f, -0.02642354f, 0.00849866f, 0.01238122f, -0.01918487f, -0.03240323f, -0.08255987f, 0.04091290f, 
    -0.06952467f, -0.02633899f, -0.04209353f, -0.02402951f, -0.04626196f, -0.00920869f, 0.01489977f, -0.01934047f, 
    -0.07249395f, -0.03649585f, 0.00691186f, 0.01909017f, -0.05433152f, -0.07263368f, 0.01910431f, 0.05657204f, 
    -0.03454157f, -0.07300932f, 0.04932503f, -0.03426831f, 0.02897712f, 0.05532262f, -0.00599020f, 0.01831725f, 
    -0.04954157f, 0.04145631f, -0.07744905f, 0.00904045f, 0.02730942f, 0.01688764f, 0.01036281f, -0.07434408f, 
    -0.03092377f, -0.01866688f, -0.08997162f, 0.03458291f, -0.04307755f, 0.03750785f, -0.05161746f, 0.01705246f, 
    -0.07004088f, 0.01491810f, -0.05151082f, -0.00603474f, -0.08281114f, -0.06524566f, -0.09478676f, -0.04252914f, 
    -0.04904126f, 0.03998253f, -0.08197249f, -0.07273187f, -0.01215962f, -0.00206330f, -0.03784617f, -0.05633642f, 
    -0.06547436f, 0.00201495f, -0.06230658f, -0.04356955f, -0.07723288f, -0.09681531f, -0.03769100f, -0.06743068f, 
    -0.07097825f, -0.08953612f, -0.07883541f, -0.05429452f, -0.00410306f, -0.00526365f, 0.03264180f, 0.04934171f, 
    -0.06041549f, 0.01487969f, -0.06151050f, -0.02920132f, -0.01955805f, -0.01731908f, -0.01201783f, 0.02620926f, 
    -0.07047250f, 0.00464718f, -0.00754234f, -0.08406197f, -0.06514156f, -0.01659063f, -0.00700144f, 0.01435167f, 
    0.04478626f, -0.04850670f, -0.00834440f, -0.07596727f, -0.08484130f, 0.02868451f, -0.02206157f, -0.00314483f, 
    0.01938483f, -0.01271312f, -0.00284465f, -0.00066058f, 0.04146506f, -0.08193192f, -0.01999697f, 0.01600750f, 
    -0.01185509f, -0.00033821f, -0.02067144f, 0.02498822f, 0.00706527f, 0.01716514f, -0.03017372f, -0.04075801f, 
    -0.07928835f, -0.05175934f, -0.01169070f, -0.04083812f, -0.01349466f, -0.03378803f, 0.05976884f, 0.04069662f, 
    0.00097827f, 0.03770074f, 0.04322767f, -0.07232016f, 0.05471580f, -0.07647081f, -0.01254907f, 0.06128820f, 
    0.00354254f, 0.04530707f, 0.01322712f, 0.03380977f, 0.02422088f, 0.04054778f, 0.03362907f, -0.02754200f, 
    0.01008835f, -0.01952748f, 0.01664274f, -0.05250522f, 0.03089323f, 0.01412357f, 0.00986761f, 0.02191028f, 
    -0.01299204f, -0.02665087f, 0.03806549f, 0.02861276f, 0.02191622f, -0.00501256f, 0.00242088f, -0.00783927f, 
    0.07890543f, 0.17940918f, 0.21126141f, -0.10043593f, 0.12283285f, 0.05613421f, -0.21982813f, 0.04157943f, 
    0.05140341f, -0.00441453f, 0.08412560f, -0.04062480f, 0.50531328f, 0.19827154f, -0.16765174f, 0.12239176f, 
    0.08003329f, 0.09024221f, -0.00147109f, -0.16531976f, 0.07379160f, -0.00374457f, 0.04630088f, 0.06136365f, 
    -0.70159131f, 0.12882504f, 0.22422093f, 0.07246651f, 0.09649032f, -0.02388127f, 0.10571993f, -0.24005871f, 
    0.12914127f, 0.02484020f, 0.00468389f, -0.00009834f, -0.11919702f, 0.05729764f, -0.10942443f, -0.20766328f, 
    0.06012443f, -0.11171202f, 0.13167444f, 0.01519744f, -0.13330875f, 0.27127650f, 0.28551671f, 0.01758606f, 
    -0.13206361f, 0.00856536f, 0.13555378f, 0.03438704f, 0.06966224f, -0.10806133f, -0.12150391f, 0.10529654f, 
    -0.10303650f, -0.00961315f, -0.15408158f, -0.01143522f, 0.02209623f, 0.04684274f, -0.01157308f, 0.08052102f, 
    -0.15429252f, -0.08306588f, -0.12743276f, 0.05918828f, 0.02287376f, -0.09926341f, 0.10892855f, -0.07301975f, 
    -0.10065205f, 0.07190658f, 0.17239453f, -0.07066783f, 0.01205206f, -0.14151709f, -0.14937955f, 0.09103718f, 
    0.01055599f, 0.06221793f, -0.29449013f, -0.12239892f, 0.28884104f, 0.19216731f, -0.14855911f, -0.16132554f, 
    -0.04017726f, -0.01945133f, -0.08625982f, 0.02376538f, 0.02237723f, 0.15178221f, 0.04412245f, -0.08262131f, 
    -0.15795289f, -0.15035567f, 0.06301954f, -0.12373034f, 0.15831037f, 0.22829303f, 0.06166996f, 0.06827733f, 
    0.02919402f, 0.09651382f, 0.03443745f, 0.01240234f, -0.20692854f, 0.06560072f, 0.10093926f, -0.02032364f, 
    0.02071302f, -0.05262452f, 0.12491974f, 0.01958846f, 0.25164220f, 0.14132985f, 0.08064883f, 0.21025859f, 
    -0.21172954f, -0.12682723f, 0.12832732f, -0.12968470f, -0.04830221f, 0.03440408f, -0.07893316f, -0.02106457f, 
    0.03217883f, 0.10671162f, -0.06811015f, 0.04966711f, -0.08110523f, -0.05140402f, 0.14991744f, -0.07720299f, 
    0.26305538f, 0.12312411f, -0.00683637f, -0.18529959f, 0.10803048f, -0.10652862f, 0.14027809f, 0.04569711f, 
    0.20386653f, 0.28841624f, -0.04110619f, -0.16419145f, -0.05748430f, -0.00065196f, -0.05543210f, -0.14658396f, 
    0.06319367f, -0.05776408f, -0.15143616f, -0.24460745f, 0.09732761f, -0.04931507f, 0.02154642f, 0.01933692f, 
    0.03168859f, -0.00887669f, 0.09047932f, 0.08360174f, -0.04430977f, -0.10441159f, 0.06178492f, -0.07846743f, 
    0.26786476f, -0.05727816f, 0.07090686f, -0.12659453f, 0.15310313f, 0.12776040f, -0.01111229f, 0.00713568f, 
    0.16729844f, 0.24517481f, 0.10087315f, 0.01010604f, 0.06601549f, 0.00955097f, -0.09363534f, -0.04561194f, 
    0.02397780f, -0.00725296f, 0.09224813f, -0.00548682f, 0.09060459f, 0.05798940f, -0.02677248f, 0.14414024f, 
    -0.34969321f, 0.21042018f, -0.22692981f, -0.33291838f, -0.09521800f, 0.04206228f, 0.00689151f, 0.06750272f, 
    0.04925011f, 0.03033937f, 0.05684686f, -0.08896083f, -0.11405796f, 0.26884791f, 0.35299999f, 0.23020515f, 
    0.19103687f, -0.08531880f, 0.08907299f, 0.08277244f, -0.01277923f, -0.20398164f, 0.00685553f, -0.03492818f, 
    0.14277038f, 0.31254855f, -0.22369148f, 0.30384442f, 0.14777260f, -0.02413533f, -0.05337935f, -0.23472315f, 
    -0.11052780f, -0.10673212f, 0.11067548f, -0.10742787f, 0.26707003f, 0.12574592f, -0.38128760f, 0.09187885f, 
    0.12075200f, -0.08748279f, 0.07263976f, 0.02771857f, 0.00269804f, 0.01347675f, 0.06507502f, 0.06822225f, 
    0.32843569f, 0.08338989f, 0.05465799f, 0.13077192f, 0.09097633f, 0.01780858f, -0.03347199f, -0.01096408f, 
    -0.03684556f, 0.00857455f, -0.14722960f, 0.02126293f, -0.31338447f, -0.28358623f, -0.27077505f, -0.37309945f, 
    -0.08369842f, -0.12938979f, -0.11832286f, -0.15052345f, 0.10147123f, -0.14715205f, 0.09101105f, 0.04663773f, 
    0.10315085f, 0.09013747f, -0.21353650f, -0.06562800f, 0.06942142f, 0.06161082f, 0.04836212f, 0.11792792f, 
    0.13990606f, -0.05429781f, -0.05751214f, 0.06675121f, 0.00635955f, 0.03481986f, 0.15978232f, -0.04915628f, 
    0.04990587f, -0.10119875f, -0.09370428f, 0.05517182f, -0.13578714f, 0.07361621f, -0.01048205f, 0.01553021f, 
    0.31744832f, -0.05997095f, 0.11183557f, 0.41012275f, -0.10249810f, 0.06398879f, -0.02535607f, -0.01691107f, 
    -0.18280335f, -0.02277136f, -0.16348803f, 0.06703915f, -0.40669906f, 0.00746227f, -0.31103483f, -0.03459232f, 
    -0.07412481f, -0.01493052f, 0.01258203f, -0.07416851f, -0.07665128f, -0.08729973f, -0.02578874f, 0.08879757f, 
    -0.09591170f, 0.11951660f, -0.36871183f, -0.01381855f, 0.20317535f, -0.02467935f, -0.00552798f, -0.03355252f, 
    0.13934405f, 0.02399439f, 0.11536119f, 0.00456787f, 0.44786179f, 0.11252366f, 0.13766910f, 0.09119612f, 
    0.17443195f, 0.04076060f, 0.02129923f, -0.08381391f, -0.16376372f, 0.05947169f, 0.11714224f, -0.12597458f, 
    0.25806400f, 0.03085032f, -0.00478373f, 0.41417429f, -0.02027557f, -0.00900952f, 0.09611628f, -0.14451903f, 
    -0.06522726f, 0.13352139f, 0.10450689f, -0.08669981f, 0.38506374f, 0.15949936f, 0.07110031f, 0.17320117f, 
    -0.06242317f, 0.10417879f, 0.09589592f, 0.01927700f, -0.28866431f, -0.01302029f, -0.11217066f, -0.05014296f, 
    0.06504941f, -0.07186019f, 0.12104876f, 0.27542868f, 0.13135095f, -0.00427227f, 0.03009631f, 0.14629728f, 
    0.00849618f, 0.13142021f, 0.18127674f, 0.04339899f, -0.00837296f, 0.24923028f, 0.05411135f, -0.08580001f, 
    0.05722600f, -0.09895399f, -0.10239421f, 0.04816857f, -0.12129392f, 0.00380860f, -0.01535379f, 0.05095592f, 
    -0.20842566f, 0.17822489f, 0.24934609f, 0.00421438f, -0.07841265f, -0.01522457f, -0.13186948f, -0.10023224f, 
    -0.15241173f, -0.06814704f, 0.01951324f, -0.10600400f, -0.13429020f, 0.20119593f, 0.16435270f, 0.04378298f, 
    0.30352858f, 0.10657011f, 0.08340510f, 0.04828443f, -0.11938771f, -0.05869570f, 0.14243695f, -0.11248641f, 
    0.31538939f, 0.21358180f, 0.16041537f, -0.03074040f, 0.12058921f, 0.01286007f, 0.02948252f, 0.05531806f, 
    -0.00242620f, 0.03534145f, -0.24930157f, -0.06127978f, 0.00731121f, 0.07100907f, -0.06734781f, -0.03246071f, 
    -0.13031764f, 0.10172697f, -0.06696235f, -0.12530653f, 0.09271836f, 0.15195657f, -0.00232629f, 0.04499039f, 
    0.14818357f, -0.10163260f, 0.07832249f, -0.03725401f, 0.02890637f, -0.05334209f, 0.00831044f, 0.03815274f, 
    0.03592704f, 0.20457847f, -0.11287580f, 0.01550380f, 0.04125749f, -0.36046794f, 0.04941281f, 0.45316151f, 
    -0.04013256f, -0.05994723f, -0.08264207f, -0.13322917f, 0.00609571f, 0.02450379f, 0.13659099f, -0.09031647f, 
    0.17157860f, 0.22386466f, -0.24797307f, -0.05693999f, 0.06612339f, 0.17415395f, -0.05390742f, 0.01577041f, 
    0.03908129f, -0.00361730f, 0.02715360f, -0.14708373f, -0.16601302f, -0.21362670f, 0.08710948f, 0.17290248f, 
    0.08534116f, -0.12510656f, 0.02977090f, -0.04898432f, -0.02617505f, -0.00250069f, 0.00790415f, -0.16718090f, 
    0.13714898f, -0.13189687f, 0.25048837f, -0.00507779f, 0.10031066f, -0.06191073f, -0.12917605f, 0.12507387f, 
    0.00984408f, 0.11701965f, -0.24133882f, 0.15111268f, -0.21887846f, -0.31353074f, -0.00322048f, 0.01819157f, 
    0.08926373f, 0.09374821f, -0.04138232f, -0.10408820f, -0.01390294f, 0.06364701f, -0.12496619f, 0.01313868f, 
    0.02248719f, 0.07028262f, 0.00177418f, 0.19774032f, -0.12482949f, 0.09616771f, 0.01672780f, 0.14858636f, 
    -0.07630959f, -0.03809854f, 0.15098691f, -0.08421593f, 0.05482384f, -0.04631390f, 0.15695859f, 0.01454308f, 
    0.18181168f, 0.15775117f, -0.09230220f, -0.09026442f, 0.01423727f, -0.12957500f, 0.06006417f, -0.07847872f, 
    -0.05957227f, 0.03545438f, 0.22055528f, 0.07514226f, -0.04386692f, 0.02750606f, -0.16108634f, 0.06035517f, 
    0.07472049f, 0.04337800f, -0.06436627f, -0.07145341f, 0.16713201f, 0.03025446f, 0.10218489f, 0.08698372f, 
    -0.06754082f, 0.13446619f, 0.06521861f, 0.06003693f, 0.02195064f, -0.09016030f, 0.05782749f, 0.12807654f, 
    -0.37486768f, 0.31998712f, -0.09950911f, 0.03286648f, 0.08082755f, 0.06670634f, 0.16839683f, 0.00190448f, 
    0.16942891f, -0.02792573f, -0.03491821f, 0.00035970f, -0.29177305f, -0.16225620f, 0.10163340f, 0.06195863f, 
    0.03638861f, -0.01637793f, 0.07580343f, -0.14623077f, -0.06165297f, 0.02932471f, -0.04581713f, -0.01972411f, 
    0.30962381f, 0.21778075f, 0.07670968f, -0.00595709f, -0.01775379f, 0.00844591f, -0.12334500f, -0.11843797f, 
    -0.00852462f, 0.04588500f, 0.14906839f, 0.03692944f, -0.45058686f, -0.11608450f, 0.23461877f, -0.23831607f, 
    0.04493096f, -0.08961214f, -0.13431029f, -0.01811188f, 0.08785786f, 0.02575722f, 0.02789822f, -0.28623351f, 
    -0.39099929f, -0.31054288f, 0.27564487f, 0.03743817f, 0.18756443f, -0.18151967f, 0.03698295f, 0.12479129f, 
    0.19403325f, 0.00408130f, 0.02201725f, 0.02819168f, -0.03047421f, 0.15783428f, -0.21959984f, 0.32538757f, 
    0.06442420f, 0.04278694f, -0.01518726f, 0.21106286f, 0.13913637f, 0.19765846f, 0.15717687f, 0.09434254f, 
    0.03815755f, -0.01934066f, -0.00420461f, -0.00272890f, 0.01867307f, 0.19919878f, 0.05267540f, -0.07330200f, 
    0.13386948f, 0.11351839f, 0.04599684f, 0.08039784f, -0.17590761f, -0.13732196f, -0.40758672f, -0.07744573f, 
    0.33073521f, -0.06747609f, -0.01976175f, -0.20891009f, 0.12146658f, 0.06263295f, 0.11717761f, 0.04514347f, 
    -0.01599884f, 0.05752406f, -0.10857376f, 0.16927077f, 0.03062284f, 0.03434724f, -0.03160537f, 0.03532618f, 
    0.04176415f, 0.07823033f, -0.03635479f, -0.27361721f, -0.68046117f, -0.26206645f, -0.30722377f, 0.19014409f, 
    -0.16084494f, -0.08465763f, -0.19080348f, 0.08035648f, 0.06390423f, 0.22448687f, 0.21620703f, -0.08684009f, 
    -0.20137492f, -0.14923914f, 0.11786012f, 0.32042903f, -0.12125638f, -0.15600309f, -0.18276121f, 0.12581369f, 
    -0.00008329f, 0.16073050f, -0.16204536f, 0.02354280f, 0.30195698f, 0.41235346f, -0.11992877f, -0.14145452f, 
    0.20296973f, 0.16544396f, 0.13515297f, 0.01215598f, -0.03747329f, -0.03748591f, 0.07926361f, 0.13681017f, 
    -0.25737891f, 0.24371125f, 0.15695797f, -0.02152070f, 0.21622406f, 0.18828557f, -0.02609339f, 0.07090674f, 
    -0.03499480f, 0.18333316f, 0.19615079f, 0.00323916f, -0.21804118f, -0.26976541f, 0.12416467f, 0.05840885f, 
    -0.20936348f, 0.09163064f, -0.15198041f, 0.21272945f, -0.13422281f, 0.04859685f, 0.09893320f, -0.18036845f, 
    -0.28811178f, -0.03691354f, -0.08662850f, 0.03731499f, 0.02665376f, -0.07497955f, -0.13355938f, 0.05704802f, 
    0.15250298f, 0.01801887f, -0.05620340f, -0.09301523f, -0.15740241f, -0.38140252f, 0.11616495f, -0.05853369f, 
    -0.22525077f, -0.11824919f, -0.08357192f, 0.02403142f, 0.06640206f, 0.02928250f, 0.17571512f, 0.09406934f, 
    0.04720793f, -0.04600275f, -0.02091764f, 0.17961065f, -0.09734967f, -0.14546829f, 0.12447489f, 0.11109763f, 
    0.08927596f, -0.04793758f, 0.10485225f, -0.05233284f, -0.27895552f, -0.22166240f, 0.14296752f, 0.29299182f, 
    0.02142438f, -0.05842651f, -0.02819038f, -0.10682548f, 0.08652320f, 0.18051960f, 0.06457366f, 0.16622412f, 
    0.01191412f, 0.00016695f, -0.00254328f, 0.01863818f, 0.03525626f, -0.06223052f, 0.06545789f, -0.06301797f, 
    0.05645846f, 0.01011470f, 0.06287052f, 0.02050294f, -0.01925346f, -0.03308406f, -0.04719745f, 0.05576270f, 
    -0.05465057f, 0.05210877f, -0.06375310f, 0.00460067f, 0.04424088f, -0.02184263f, 0.01408597f, -0.00924307f, 
    -0.02825335f, 0.04619760f, -0.06314275f, -0.05722839f, 0.04101474f, -0.00384824f, -0.04020087f, -0.02667743f, 
    0.04583414f, -0.04887962f, 0.02575083f, -0.05485999f, 0.04562308f, 0.00279115f, 0.04821942f, -0.05018661f, 
    0.01536565f, -0.01729329f, 0.01952403f, -0.01375810f, 0.03594148f, 0.00338284f, 0.06126475f, -0.01770537f, 
    -0.01503125f, 0.02958132f, -0.02730402f, 0.02053704f, -0.05383934f, -0.00042226f, 0.03209011f, 0.00016296f, 
    0.06558648f, -0.05862075f, 0.01383673f, 0.04776909f, 0.03479275f, -0.00091593f, -0.02950971f, 0.05072147f, 
    0.03361144f, -0.03368835f, 0.05270923f, -0.00264863f, 0.06227471f, -0.02559124f, 0.02552745f, -0.03393817f, 
    -0.07140353f, 0.03955356f, 0.04127118f, -0.07370787f, 0.05706950f, 0.04031879f, -0.04871199f, -0.05374672f, 
    0.03024893f, 0.03683681f, -0.07464698f, 0.00010157f, -0.01983098f, -0.05849276f, 0.03854172f, -0.07014764f, 
    -0.04256593f, 0.05886855f, -0.04002320f, 0.05057842f, 0.02560238f, 0.02350139f, 0.03028942f, -0.05560647f, 
    -0.04163318f, -0.00449151f, 0.01002251f, -0.03758168f, -0.03000804f, 0.06577938f, 0.01708862f, -0.04089464f, 
    -0.02587941f, -0.07501766f, -0.00101140f, -0.00939920f, -0.00431206f, -0.04382300f, -0.05065352f, -0.06021608f, 
    -0.06296764f, -0.03831080f, -0.02750256f, 0.04939832f, -0.03553897f, 0.06065201f, -0.03302493f, -0.04726096f, 
    -0.03019290f, 0.04650573f, 0.02195814f, 0.03471299f, 0.04262578f, -0.04577389f, -0.03831314f, 0.05822797f, 
    0.03408555f, 0.04493326f, -0.07546258f, -0.06149503f, -0.07247879f, 0.00978279f, 0.05499722f, 0.00381780f, 
    -0.03160378f, -0.02186529f, -0.03786252f, -0.07679996f, -0.06220077f, -0.04300911f, -0.07795323f, -0.07405174f, 
    0.00699905f, 0.06285071f, -0.06948075f, -0.03883418f, -0.01575683f, 0.04260971f, -0.07035612f, 0.01222365f, 
    -0.05932534f, 0.02868386f, -0.07510264f, -0.06305693f, -0.02866746f, -0.05472187f, -0.06263037f, 0.01221979f, 
    -0.07611213f, -0.07063188f, 0.00029831f, -0.04731408f, 0.06482537f, -0.06483026f, 0.03029827f, 0.04113724f, 
    -0.07279717f, -0.03286360f, 0.01780143f, -0.01166409f, -0.00751726f, -0.05214958f, 0.01997930f, -0.07199922f, 
    -0.06143419f, -0.03343598f, -0.05366467f, -0.02597267f, -0.04435570f, 0.06240214f, -0.06816820f, 0.01318622f, 
    -0.02487763f, -0.03340077f, -0.05087017f, -0.07558967f, -0.00024884f, -0.04028410f, -0.04075363f, -0.05593300f, 
    -0.48275641f, -0.21525376f, 0.21622051f, 0.13571990f, -0.09464161f, 0.06009586f, -0.00288321f, -0.04808726f, 
    -0.16356583f, 0.03867649f, -0.05742013f, 0.12595485f, 0.05590739f, 0.00700003f, -0.22475889f, -0.27777535f, 
    0.14901938f, -0.04637089f, 0.04165011f, 0.02501840f, 0.02697166f, 0.03800172f, -0.06894534f, -0.08040109f, 
    0.01693335f, -0.33319122f, 0.14167491f, 0.31868160f, -0.05217612f, -0.05234745f, 0.03010410f, -0.11878416f, 
    -0.01320839f, -0.09804409f, -0.19093016f, -0.18198837f, 0.28553396f, -0.04370475f, 0.10994551f, 0.26609212f, 
    -0.02578473f, 0.15936430f, 0.02451957f, 0.17943220f, 0.10133649f, 0.01249358f, 0.07572200f, 0.15646014f, 
    0.24702267f, 0.26771307f, -0.03945830f, -0.01459148f, -0.00256057f, 0.02829060f, 0.10206814f, 0.03306607f, 
    -0.00813470f, -0.01722762f, -0.04499159f, 0.01312474f, -0.19146767f, -0.12240192f, -0.06038255f, 0.13916759f, 
    0.02082814f, 0.10528356f, -0.02839823f, -0.09017988f, 0.04035344f, 0.03951223f, 0.06585182f, 0.14980885f, 
    -0.01813579f, 0.11865170f, -0.08108833f, -0.07844248f, -0.04498044f, -0.01437406f, 0.15141016f, -0.13772067f, 
    0.10043322f, 0.13420081f, -0.03438903f, -0.11609210f, -0.08427579f, -0.07435151f, -0.08690693f, 0.19026040f, 
    -0.03214206f, -0.02153446f, 0.03783860f, 0.11412691f, -0.09014230f, 0.04060350f, 0.07162672f, 0.08225036f, 
    0.16051421f, 0.06864668f, -0.18389989f, 0.16700384f, 0.02936757f, -0.03413381f, -0.10315249f, -0.02359253f, 
    -0.02958257f, 0.08493873f, 0.03519469f, -0.01444322f, 0.12941159f, -0.18502888f, 0.03905221f, -0.04843453f, 
    0.10298135f, -0.03517410f, 0.01873177f, -0.07344027f, -0.11119810f, 0.00312730f, 0.05815930f, -0.09507371f, 
    0.43570217f, 0.02688707f, 0.08884112f, 0.03976550f, 0.01388843f, -0.23630090f, 0.28539863f, -0.03953338f, 
    -0.06656191f, 0.00377579f, -0.01234154f, -0.04408927f, 0.25472665f, 0.12152791f, -0.08427508f, -0.07876953f, 
    -0.01719700f, 0.03705818f, -0.03527086f, -0.08695660f, -0.03749138f, -0.08563270f, 0.03066517f, 0.01942079f, 
    0.07510217f, -0.15415408f, 0.04528278f, 0.05612012f, 0.04708301f, 0.16097587f, 0.01351929f, 0.02067805f, 
    -0.01811176f, 0.13896510f, -0.09759182f, 0.01888035f, -0.17929138f, -0.08936006f, -0.18560366f, 0.10311375f, 
    -0.08985785f, 0.05823169f, -0.11495662f, -0.03171309f, 0.02012016f, 0.03866887f, -0.10543697f, 0.12777577f, 
    -0.10838705f, 0.06795602f, 0.03258223f, -0.10561174f, 0.05389429f, 0.04390500f, 0.07219373f, 0.11974338f, 
    0.03720630f, -0.21045583f, 0.08297295f, 0.00254903f, 0.05061359f, 0.08709081f, -0.02977258f, 0.10693163f, 
    0.23462692f, 0.01618574f, 0.07250754f, 0.11400127f, -0.02448603f, 0.11306453f, 0.13225634f, -0.03195585f, 
    -0.07541569f, 0.09389421f, 0.05250817f, 0.10629477f, 0.06259941f, -0.03604148f, -0.07036360f, 0.02591850f, 
    0.02099836f, -0.00063948f, 0.23370144f, -0.00437402f, -0.11546861f, 0.11577096f, 0.07714204f, -0.02976077f, 
    0.03129922f, -0.13239902f, -0.06385113f, 0.09778191f, -0.10370467f, 0.04426736f, 0.11229914f, -0.00929075f, 
    0.16966949f, -0.04271258f, -0.06035472f, -0.33620596f, 0.07126277f, -0.02522196f, 0.11283230f, -0.02634152f, 
    0.09353811f, 0.18635474f, -0.22741847f, -0.07694993f, 0.05315552f, -0.04363829f, 0.16401611f, 0.00574561f, 
    -0.04863212f, -0.10164998f, -0.01569293f, -0.06558946f, -0.00349005f, 0.21064483f, 0.11646615f, 0.21469888f, 
    -0.06160362f, -0.28822434f, 0.18515527f, -0.12149904f, 0.01923953f, 0.10546331f, 0.03527493f, 0.06592967f, 
    0.05381392f, 0.21582438f, 0.00691759f, 0.20418343f, 0.20932396f, -0.39428863f, 0.21900864f, 0.49744537f, 
    -0.10492367f, 0.04173253f, 0.08073128f, 0.06241304f, 0.10569212f, 0.04005967f, 0.07125035f, -0.04418781f, 
    0.52508938f, -0.11735293f, -0.11653994f, 0.20070231f, -0.04455328f, 0.03979405f, 0.02109584f, 0.07185771f, 
    0.06775326f, 0.04174427f, -0.14405046f, -0.06829416f, -0.12759556f, 0.05027042f, -0.08283735f, 0.21106750f, 
    0.09365442f, 0.03262847f, -0.01202433f, 0.04512383f, -0.13517921f, -0.01073996f, 0.08769964f, 0.03985324f, 
    0.05034560f, -0.10699800f, 0.03453778f, -0.01069415f, 0.07835267f, -0.06354410f, 0.07595721f, 0.22930695f, 
    -0.02735132f, -0.06294629f, -0.09041472f, 0.06641863f, 0.03748956f, -0.72377503f, 0.12954527f, 0.18868063f, 
    -0.14557290f, 0.02954831f, -0.04689777f, 0.09083975f, 0.09388459f, 0.07370244f, 0.02705011f, 0.25981143f, 
    0.14373086f, -0.31766951f, 0.18083563f, -0.06740425f, 0.03457923f, 0.14676376f, -0.01056727f, 0.03527909f, 
    0.08374318f, -0.00759762f, 0.01213864f, -0.03100236f, -0.25530982f, -0.22031608f, 0.04943307f, 0.07699498f, 
    -0.08044186f, -0.07398382f, -0.03724792f, 0.10440378f, 0.08493383f, -0.15620491f, -0.04850549f, 0.08437865f, 
    -0.00284948f, -0.01195927f, 0.09092341f, -0.09877437f, -0.01188739f, -0.11674614f, -0.14121729f, 0.02479294f, 
    0.24970509f, -0.17484988f, -0.20906746f, -0.20029671f, 0.12952775f, 0.15576963f, -0.11279093f, -0.11460277f, 
    -0.24411067f, -0.09984783f, 0.03210178f, 0.21986508f, 0.00161658f, -0.00230123f, 0.21838363f, 0.22895063f, 
    -0.21160579f, 0.25334069f, -0.21291906f, -0.11859579f, -0.16403812f, -0.05951245f, 0.04832844f, -0.01617510f, 
    0.28674731f, 0.21654545f, -0.00381039f, -0.01952765f, -0.04796081f, -0.02102484f, -0.04102002f, 0.07336529f, 
    0.08656468f, -0.04305326f, 0.02885307f, 0.16343376f, -0.00978657f, -0.06998962f, 0.14924467f, 0.15708131f, 
    -0.22684480f, -0.26813060f, 0.20963143f, 0.13178621f, 0.03711885f, -0.00222063f, 0.02548348f, -0.03788826f, 
    0.02684394f, 0.11274227f, -0.19167396f, 0.15309772f, 0.26087433f, -0.15293908f, -0.02122950f, -0.30827332f, 
    0.00106885f, 0.05055509f, -0.03588538f, 0.03793920f, 0.10781818f, 0.04524794f, -0.10320564f, 0.08025596f, 
    -0.26557639f, -0.45610678f, 0.15076852f, 0.19991328f, -0.10550696f, -0.07124556f, 0.16102079f, -0.15309863f, 
    0.06650461f, 0.00983838f, -0.05094078f, 0.07138561f, 0.18193692f, -0.08628628f, 0.13491587f, 0.13512407f, 
    0.04811732f, 0.05929179f, -0.06399634f, 0.05835495f, -0.06522311f, -0.15021591f, 0.00988406f, 0.12596670f, 
    0.23842427f, 0.41639984f, 0.09388037f, -0.14324035f, 0.05983911f, 0.02778102f, 0.11120820f, 0.05628837f, 
    -0.07877379f, -0.09038738f, -0.12476944f, 0.09795265f, -0.05311999f, -0.02462383f, -0.13860458f, 0.13791507f, 
    0.04538834f, 0.01527445f, -0.09533865f, 0.03223277f, 0.03656907f, 0.13551821f, 0.09280547f, 0.06510520f, 
    -0.17074732f, 0.09761418f, 0.13695705f, -0.06265048f, 0.07731336f, 0.08156692f, 0.09688266f, -0.08213453f, 
    0.08291855f, 0.17718993f, 0.08691885f, -0.02805877f, -0.02693548f, 0.01190631f, -0.06914493f, 0.16441244f, 
    -0.11936336f, -0.05402021f, 0.04529623f, 0.09556585f, -0.01024685f, -0.06171746f, 0.04945461f, 0.17279421f, 
    -0.10361928f, 0.14711323f, -0.15792461f, 0.16358787f, 0.09690702f, -0.08365762f, -0.02718617f, -0.01241524f, 
    0.12189668f, 0.04839687f, 0.07294666f, -0.06313501f, 0.75932890f, 0.11560289f, 0.10472073f, -0.14195414f, 
    0.09088274f, 0.00913151f, 0.02974300f, -0.00818078f, -0.07684827f, -0.12187778f, -0.01289683f, -0.29184505f, 
    0.55290931f, 0.01178902f, 0.22243868f, -0.08796526f, -0.00257381f, -0.23281801f, 0.24336293f, 0.06159919f, 
    -0.00115649f, 0.15437743f, -0.10922593f, 0.00717524f, 0.12422964f, 0.08237273f, -0.12621967f, -0.13511778f, 
    0.01130337f, -0.02543213f, -0.01933783f, -0.09683780f, 0.00194926f, -0.02071807f, -0.02645588f, 0.07601017f, 
    -0.05890376f, -0.10438741f, 0.05823389f, 0.02847396f, 0.11266379f, 0.17761536f, 0.16418914f, 0.02489261f, 
    -0.08692024f, 0.09862846f, -0.04555647f, 0.18241659f, -0.20473538f, -0.12239102f, -0.22808246f, 0.03974951f, 
    0.01193961f, 0.04412356f, 0.04718889f, -0.04920250f, 0.01899712f, -0.06853966f, -0.16490042f, 0.01080703f, 
    0.27902028f, 0.04999828f, 0.08637431f, -0.17852922f, 0.06851645f, 0.10464955f, -0.06376179f, 0.02522435f, 
    0.01097177f, -0.16869520f, -0.05758871f, 0.02649559f, 0.09084854f, -0.02692458f, -0.11201721f, 0.20001604f, 
    0.11542537f, 0.11154977f, 0.01485894f, 0.17665718f, 0.00998211f, 0.12361061f, -0.04740235f, -0.08712411f, 
    0.10338192f, 0.08222791f, -0.19922052f, -0.06749929f, -0.04696845f, -0.03992498f, -0.07181452f, 0.01322510f, 
    -0.09469239f, 0.21491750f, 0.05969337f, -0.24140316f, -0.20058492f, 0.01460872f, 0.34940228f, 0.28707513f, 
    0.18158783f, 0.02994357f, 0.05462053f, -0.03302768f, 0.02763118f, 0.05796922f, 0.03049967f, 0.06325363f, 
    -0.06406043f, 0.24551013f, -0.02215345f, 0.14349425f, -0.14967193f, -0.00835758f, -0.13651097f, 0.03796854f, 
    -0.16431759f, -0.01400279f, 0.06840765f, -0.04957557f, -0.23018789f, -0.00614947f, -0.13439298f, 0.05066268f, 
    -0.07130842f, -0.17397924f, -0.02900559f, 0.11268193f, 0.10512324f, -0.08827226f, -0.09928659f, 0.00616112f, 
    0.31340024f, 0.03227472f, -0.02288720f, 0.04384645f, -0.03771676f, -0.09617427f, 0.07454674f, -0.11538608f, 
    -0.05581339f, -0.07402240f, -0.11894695f, -0.12748756f, 0.29478845f, 0.02375544f, 0.04585994f, -0.13082300f, 
    0.07370467f, -0.01660926f, 0.03503530f, -0.07245023f, 0.05334224f, 0.08242749f, 0.12526511f, 0.11178224f, 
    -0.18754469f, -0.07042488f, 0.01471802f, -0.01245949f, -0.04740966f, 0.13440067f, -0.04686816f, -0.05446393f, 
    0.19684054f, -0.05618491f, 0.00952329f, 0.04204130f, -0.29189605f, -0.21608098f, -0.00708094f, -0.22489139f, 
    -0.06060622f, 0.01312302f, -0.14368036f, -0.15836050f, 0.00701956f, 0.05457202f, 0.14527200f, -0.14516075f, 
    -0.06693094f, 0.21360996f, 0.24334855f, 0.22545500f, -0.02670651f, 0.12207472f, 0.00401242f, 0.04877829f, 
    -0.16928564f, -0.01826244f, -0.07456271f, 0.13704957f, 0.21987501f, 0.14931443f, -0.16959535f, 0.16488265f, 
    -0.02327267f, 0.05442000f, -0.10488205f, -0.03706831f, 0.03808619f, -0.11473117f, -0.05700339f, -0.02329724f, 
    -0.44078758f, 0.14237849f, -0.24568625f, -0.06656442f, 0.05319465f, -0.00413943f, -0.10854264f, -0.07509370f, 
    0.02703658f, -0.08843509f, -0.04246583f, -0.07513732f, 0.37779295f, 0.20123161f, 0.10128586f, 0.07672065f, 
    0.11342294f, 0.05436129f, -0.06255273f, 0.08359498f, -0.04597844f, -0.03642820f, -0.02702845f, -0.04425779f, 
    0.29189223f, 0.22284612f, -0.11009111f, 0.09888846f, 0.17846492f, 0.00163445f, 0.03228746f, -0.01295661f, 
    0.14805201f, 0.11553653f, 0.05056337f, 0.06061281f, 0.42742255f, 0.36386377f, 0.20190585f, 0.21101667f, 
    0.12061322f, 0.04617856f, 0.12836264f, 0.11063531f, -0.12974499f, 0.01828340f, -0.14329258f, -0.10861213f, 
    -0.25188729f, 0.06255399f, 0.10358941f, 0.14772964f, -0.00429886f, 0.01237217f, -0.03714076f, 0.05159111f, 
    0.09426403f, -0.05621479f, 0.03497351f, -0.06141599f, -0.33429664f, 0.17644174f, 0.07689090f, -0.21632975f, 
    -0.10392079f, 0.01469617f, -0.04491864f, -0.14899786f, -0.10656814f, 0.14713635f, 0.01661998f, -0.04166131f, 
    -0.02346857f, -0.07667819f, 0.28655916f, 0.07683079f, 0.02126479f, 0.16260190f, -0.00247784f, -0.10727809f, 
    -0.07119449f, 0.05746734f, 0.03263746f, 0.09341157f, -0.01796087f, -0.24907005f, -0.12080633f, 0.02865976f, 
    0.03229625f, -0.06694357f, -0.05521996f, -0.02856275f, 0.02125054f, 0.07030265f, -0.09822638f, -0.23370463f, 
    -0.23138702f, -0.58021140f, 0.20564403f, 0.37805772f, -0.03704335f, 0.01421926f, 0.01445671f, -0.09754965f, 
    0.07977491f, -0.00290725f, 0.02690158f, -0.06476858f, 0.07983315f, -0.06522327f, 0.15586524f, 0.24575797f, 
    -0.04500372f, 0.03949196f, 0.00237178f, 0.25215977f, 0.01545877f, -0.06593180f, 0.20983100f, 0.23038150f, 
    -0.04381038f, 0.36789763f, 0.10098337f, 0.02907177f, -0.11475590f, -0.13623899f, 0.32225460f, 0.02533315f, 
    0.11410502f, -0.03199993f, -0.07381264f, -0.08745786f, -0.03763647f, 0.16784270f, 0.00659032f, -0.46113318f, 
    0.19612065f, 0.14803049f, -0.02463356f, 0.03802339f, 0.20227793f, 0.10646018f, -0.05261791f, 0.10721106f, 
    -0.02422185f, -0.20984472f, -0.09166073f, -0.38478845f, 0.01816759f, -0.03050817f, 0.06153572f, 0.06271926f, 
    0.11895920f, 0.13681281f, 0.04761836f, -0.08539879f, 0.02178850f, -0.07872306f, -0.21319407f, 0.01618038f, 
    -0.02448855f, -0.03170028f, 0.02298358f, 0.16330718f, -0.01195453f, 0.16583274f, 0.13501823f, 0.02380824f, 
    0.00229826f, -0.10053745f, -0.11328730f, -0.11936765f, 0.05989050f, -0.08538322f, 0.01712269f, -0.01882746f, 
    0.00399877f, 0.07194304f, 0.10409086f, -0.07282224f, 0.44263521f, 0.11413717f, 0.04034580f, -0.18123877f, 
    0.12771748f, 0.03663608f, 0.07839569f, -0.02810642f, -0.00685458f, 0.01392454f, 0.04819649f, -0.05983141f, 
    0.09068287f, 0.15778562f, 0.13145204f, 0.06271292f, 0.05193797f, 0.03241443f, 0.01049254f, -0.06066878f, 
    -0.00193461f, -0.03553818f, 0.06742601f, 0.14174327f, 0.12866978f, 0.08424921f, -0.13341437f, 0.15318574f, 
    -0.04462647f, 0.13822949f, 0.02739889f, -0.10869372f, 0.19716516f, -0.14300482f, -0.03057128f, 0.04454304f, 
    -0.00495144f, -0.17237304f, -0.04401813f, 0.08060388f, 0.20189926f, 0.04129133f, 0.04688617f, 0.03145844f, 
    0.08397985f, 0.11040907f, 0.00489225f, 0.03660016f, -0.42185515f, -0.26901278f, -0.15572284f, 0.02175402f, 
    0.06995703f, -0.05454247f, -0.09493333f, 0.00344699f, 0.04884366f, -0.09323853f, -0.01392344f, -0.01299967f, 
    0.01910531f, -0.21996452f, 0.07152411f, 0.05488114f, -0.13816637f, -0.10010611f, 0.03676879f, 0.07518850f, 
    0.01496879f, -0.18943754f, 0.05301275f, 0.06867983f, 0.21157305f, -0.22150250f, 0.13168029f, -0.13103136f, 
    -0.02278447f, -0.00917496f, -0.10051542f, -0.07192612f, 0.07091995f, 0.19142509f, 0.03452776f, 0.05198196f, 
    0.43284318f, -0.04968622f, 0.04906943f, 0.26316246f, 0.06245530f, -0.04662453f, 0.10851416f, -0.00275545f, 
    0.10794711f, -0.01005588f, -0.09300730f, 0.02400519f, 0.28413641f, 0.11737344f, 0.27741787f, 0.17268239f, 
    0.07507116f, 0.04761986f, -0.07043292f, 0.17037933f, 0.14466994f, 0.07693082f, -0.06684161f, 0.10986830f, 
    -0.16483684f, 0.01591602f, -0.02354240f, -0.23325501f, -0.05820553f, -0.10766913f, -0.11469331f, -0.01142857f, 
    0.03085645f, 0.01335520f, 0.09309455f, 0.01058779f, -0.24370924f, 0.00787054f, 0.00119394f, -0.26027289f, 
    0.08042137f, 0.06273645f, -0.02235579f, -0.10434882f, -0.14630802f, 0.01412752f, 0.00581063f, -0.23735495f, 
    -0.26307750f, -0.06840400f, -0.14956020f, -0.26216704f, -0.05842427f, 0.12352896f, -0.02165658f, 0.01701694f, 
    -0.00967031f, -0.08894703f, 0.06975387f, -0.09032470f, 0.15794815f, 0.26569030f, -0.03553508f, 0.15893851f, 
    0.07955982f, 0.03653511f, 0.04887825f, 0.03500030f, -0.10870519f, 0.00720029f, 0.06651743f, -0.06200051f, 
    -0.13721727f, 0.07067221f, 0.27100858f, 0.28580043f, -0.14522162f, 0.03380922f, -0.22824584f, -0.04589067f, 
    0.11230466f, 0.12760942f, 0.30827120f, 0.15146844f, 0.17309698f, -0.27669635f, -0.01571530f, -0.03856962f, 
    -0.11842377f, 0.14866735f, 0.09107232f, -0.04202056f, 0.04208839f, -0.01222723f, -0.26040998f, -0.00680346f, 
    0.31580275f, -0.22814953f, 0.14712527f, -0.20002392f, -0.14888418f, 0.11415292f, 0.04192362f, -0.10273914f, 
    0.10024394f, 0.07731397f, 0.12250189f, 0.02705355f, 0.17529513f, 0.49991590f, 0.14319812f, -0.15681818f, 
    0.15197195f, -0.00522655f, 0.04943096f, 0.06339699f, -0.22782910f, -0.02719240f, 0.14425559f, -0.01124954f, 
    -0.22901651f, 0.34879929f, -0.08507343f, -0.17569734f, -0.03075601f, 0.02590827f, -0.21013612f, -0.04974985f, 
    0.05002403f, 0.04184409f, 0.13664982f, -0.06787720f, -0.58819491f, -0.05840386f, 0.07661065f, 0.18191798f, 
    -0.04364695f, 0.13470264f, 0.11040951f, 0.19959700f, -0.03349170f, -0.03599155f, -0.13915437f, 0.04574708f, 
    -0.25880229f, 0.14173542f, 0.20781744f, -0.09992523f, -0.00241482f, -0.08951064f, -0.15822186f, 0.04869370f, 
    0.07429343f, 0.11163398f, 0.03292458f, 0.04830571f, -0.15042044f, -0.28269115f, 0.24394241f, -0.02344435f, 
    -0.03623926f, 0.09609325f, -0.11374313f, -0.07622966f, -0.05806077f, -0.01635002f, -0.07963479f, -0.02870638f, 
    0.32784289f, -0.02446473f, 0.14110231f, 0.12210780f, 0.07806022f, 0.02241285f, 0.00626032f, -0.12262423f, 
    -0.02689176f, 0.01582710f, -0.05081686f, 0.06484119f, 0.10840028f, -0.33843228f, 0.04958342f, 0.19981831f, 
    -0.22494519f, 0.05131645f, 0.07430812f, 0.05635933f, 0.10455327f, -0.01208343f, -0.14925392f, -0.05068732f, 
    0.03925285f, -0.20374545f, 0.00107158f, 0.10183505f, -0.00673303f, -0.18434994f, 0.17792092f, 0.03959883f, 
    0.08211644f, -0.12408336f, -0.02509997f, -0.02852775f, 0.11002333f, -0.05689365f, -0.07218369f, 0.19821250f, 
    -0.10558657f, 0.06161626f, -0.01720295f, 0.01602487f, -0.05193532f, -0.02557440f, -0.07684705f, 0.07009238f, 
    0.28184953f, 0.21390201f, -0.05579083f, -0.03933995f, -0.07534099f, 0.10410316f, -0.09986617f, 0.10159577f, 
    -0.01417546f, 0.08190805f, 0.02218101f, 0.09179199f, -0.17481750f, -0.16665004f, 0.26306707f, 0.12229036f, 
    -0.00310099f, 0.10806976f, -0.00128128f, -0.01550041f, 0.06414172f, -0.24807021f, -0.17510568f, -0.15048727f, 
    -0.12490350f, 0.06907393f, -0.14341486f, -0.09229698f, -0.09380634f, 0.12052383f, -0.17107740f, -0.06965479f, 
    0.16761808f, -0.03713366f, 0.06520428f, -0.04457350f, 0.30147317f, 0.13497852f, 0.12462892f, -0.02342597f, 
    -0.00219846f, 0.05869415f, 0.05701431f, 0.07068092f, -0.05159803f, 0.12505475f, 0.04710858f, 0.05355827f, 
    -0.03235772f, -0.10187726f, 0.00772023f, 0.07221484f, 0.04887297f, -0.02372422f, 0.07832018f, 0.09597445f, 
    -0.09131069f, 0.01794296f, 0.27864963f, 0.22050151f, 0.08716292f, -0.16595463f, 0.15944938f, -0.07059490f, 
    0.14752164f, 0.06091310f, 0.05958609f, -0.08808864f, 0.11680257f, -0.00021572f, -0.06278662f, -0.04523996f, 
    -0.11414632f, 0.20827952f, 0.10043876f, -0.33525464f, -0.03594127f, -0.06205186f, -0.05107984f, -0.06723736f, 
    0.03068762f, 0.01355844f, 0.04366105f, -0.03789582f, 0.23014551f, 0.02391019f, -0.02744996f, 0.09906575f, 
    0.01260431f, -0.08256756f, -0.10871890f, 0.06763398f, 0.04583959f, -0.05033256f, 0.09551863f, -0.10186164f, 
    0.08448088f, -0.11475901f, -0.05932493f, 0.30850512f, -0.05914920f, -0.05274180f, -0.11060747f, -0.04881489f, 
    0.02817924f, 0.09859344f, -0.02932042f, 0.04011922f, -0.11186559f, 0.07904469f, -0.01782674f, 0.29543722f, 
    -0.03462538f, -0.07931424f, 0.02537036f, 0.04149400f, 0.09849166f, 0.04695847f, -0.06014780f, 0.00677934f, 
    -0.43384230f, 0.05848653f, 0.24845721f, -0.03614261f, 0.01155862f, 0.01622173f, 0.06455970f, -0.08462289f, 
    -0.02229031f, 0.07164800f, -0.01109367f, 0.14598116f, 0.13640922f, 0.27072001f, 0.32550722f, -0.08982977f, 
    0.13013987f, -0.02888284f, 0.03304194f, -0.02172776f, 0.08974318f, 0.04083011f, -0.02933820f, 0.05906415f, 
    -0.21284708f, 0.32731536f, 0.15863715f, 0.10975955f, -0.10036153f, -0.14500971f, -0.03435638f, 0.03603926f, 
    -0.09306806f, -0.04382494f, -0.04550924f, 0.09850951f, -0.09972151f, -0.17532776f, 0.09885752f, -0.12581068f, 
    -0.19523163f, -0.00143527f, -0.05129399f, 0.04397839f, -0.00676255f, -0.01807457f, -0.07235810f, -0.08038660f, 
    0.12719405f, 0.16761491f, -0.23244260f, -0.00943425f, 0.04809653f, -0.14712459f, 0.17368229f, 0.05815000f, 
    0.01634024f, 0.01537602f, 0.03556535f, 0.10386728f, -0.07483827f, 0.16286570f, 0.15096880f, 0.23374277f, 
    -0.01625357f, -0.26640147f, 0.02740902f, 0.16324358f, -0.00961249f, 0.09059102f, 0.13845100f, 0.11134061f, 
    0.30228445f, 0.17398189f, -0.05279674f, -0.45508820f, 0.07300556f, 0.11737532f, -0.18507132f, 0.02697770f, 
    -0.18978941f, -0.07384484f, 0.20894989f, 0.07473680f, -0.00649674f, 0.23802397f, 0.07089590f, -0.04296757f, 
    0.10787494f, 0.03990601f, 0.02452782f, -0.10394135f, 0.09491064f, -0.21982214f, -0.16693786f, -0.07738803f, 
    -0.14501588f, -0.21507409f, 0.14422184f, -0.05571104f, -0.05358991f, 0.12657587f, 0.10315639f, -0.14293028f, 
    0.07386772f, 0.02130045f, -0.02777007f, 0.00886969f, -0.23222080f, 0.20703574f, -0.13241510f, -0.06536566f, 
    0.15192965f, 0.01623915f, 0.10322347f, 0.06121048f, 0.05037095f, 0.12958524f, -0.00403324f, 0.00465040f, 
    -0.15143596f, 0.06590437f, -0.06032918f, 0.30469996f, 0.04766198f, 0.14553258f, 0.02737748f, 0.18371964f, 
    -0.03411856f, 0.00593830f, 0.23528638f, 0.22852118f, -0.05843018f, 0.09708187f, 0.16161005f, 0.18483986f, 
    0.00063237f, 0.02487163f, -0.00198547f, -0.04969680f, 0.01554004f, -0.01176760f, -0.07856677f, 0.05343705f, 
    0.30301973f, -0.04308811f, -0.23608752f, 0.19242190f, -0.05464026f, 0.03854862f, 0.02524743f, 0.13134605f, 
    0.05621159f, -0.00293975f, -0.03353073f, -0.09702972f, -0.06597538f, 0.10828970f, -0.14815147f, -0.00756903f, 
    0.03001129f, 0.01464071f, 0.06148663f, 0.02689537f, -0.02218883f, -0.04063245f, 0.03820925f, -0.04377804f, 
    -0.19543447f, 0.06788214f, 0.04503331f, -0.24409193f, 0.01180218f, 0.03407886f, 0.04790116f, 0.04583579f, 
    -0.04851852f, 0.00679306f, 0.06800304f, -0.14085063f, 0.04232071f, -0.25340396f, -0.11358497f, 0.44037297f, 
    -0.09518494f, -0.17555557f, 0.05706491f, 0.07161117f, -0.03064346f, 0.14415829f, -0.10222764f, 0.08031186f, 
    -0.31353500f, -0.14521174f, 0.08030515f, 0.23374353f, -0.11887055f, -0.14417002f, 0.12577935f, 0.09965538f, 
    -0.15890335f, 0.01454384f, 0.06853452f, 0.02418120f, 0.12680653f, -0.04858221f, 0.13949518f, 0.01438846f, 
    0.06241272f, 0.07752480f, 0.11317014f, 0.07772182f, -0.02345185f, 0.11164781f, -0.23591636f, -0.04822971f, 
    0.21910706f, -0.31316549f, 0.09093617f, 0.10469409f, -0.10691202f, -0.16389418f, -0.05806055f, -0.02015736f, 
    -0.08020553f, -0.02929532f, 0.04663794f, 0.07404661f, 0.17517963f, 0.18201703f, 0.01369703f, 0.17715405f, 
    -0.04296614f, -0.05913178f, -0.14815207f, 0.14627889f, 0.05191804f, -0.12881806f, 0.02241709f, -0.07057934f, 
    -0.16035159f, 0.04991101f, -0.19238839f, -0.17072086f, 0.01787268f, -0.07399245f, 0.11119869f, -0.07678574f, 
    0.04655944f, -0.02705116f, 0.06588444f, 0.08541787f, -0.09608056f, 0.15892985f, -0.14329804f, -0.15728979f, 
    -0.19824520f, 0.03995475f, -0.00042860f, -0.00365376f, 0.03954225f, -0.06983382f, -0.00450356f, 0.02283643f, 
    0.33457935f, 0.37048972f, 0.04086005f, 0.05164687f, 0.03637507f, 0.08886693f, -0.09840675f, 0.28628999f, 
    -0.07312120f, -0.07875933f, 0.18034552f, -0.01120222f, -0.05170190f, 0.11276291f, -0.30572504f, 0.13827153f, 
    0.13918562f, 0.06276421f, 0.07994438f, 0.00692024f, 0.13982055f, -0.03157605f, -0.07367156f, -0.16363665f, 
    0.13459195f, -0.01772406f, -0.05280047f, 0.37469977f, 0.08342511f, 0.15039030f, -0.10273322f, -0.08093663f, 
    0.09419748f, 0.00307159f, 0.05712923f, 0.00184090f, -0.44476491f, -0.18868630f, -0.04630580f, -0.26369768f, 
    -0.05997639f, -0.08709112f, 0.03762500f, -0.07154042f, 0.06246528f, 0.02734568f, 0.03559944f, 0.12558357f, 
    -0.13625348f, 0.17162141f, -0.11390395f, 0.09252428f, -0.00780533f, -0.02074528f, 0.10330333f, 0.00040157f, 
    0.00973809f, -0.07978287f, 0.21368226f, 0.11091457f, 0.06346531f, 0.12487838f, 0.39053568f, 0.02292909f, 
    0.09569647f, -0.06083480f, 0.16520274f, -0.06983999f, 0.22343163f, 0.09914100f, -0.02505369f, 0.03182917f, 
    -0.03212879f, 0.02025923f, 0.05782129f, 0.08207527f, 0.02646652f, -0.00923108f, 0.07012475f, -0.09314315f, 
    -0.00462284f, 0.19312111f, -0.07085288f, 0.02060346f, -0.61477315f, 0.20174557f, -0.18747716f, 0.05032485f, 
    -0.00060653f, 0.10417674f, 0.04228182f, 0.03543721f, 0.10853825f, 0.00459260f, -0.01822732f, 0.05491422f, 
    -0.03893681f, 0.32290450f, 0.00961212f, 0.13976526f, 0.07996725f, 0.04554544f, -0.00092317f, 0.07743089f, 
    0.10597084f, 0.04746038f, 0.03263724f, 0.04243367f, 0.15411006f, 0.19554235f, 0.15126006f, -0.04271869f, 
    -0.03774533f, -0.03915577f, 0.12049586f, 0.08421908f, -0.12370685f, 0.18395662f, 0.02541316f, -0.05380935f, 
    -0.14970355f, -0.09022286f, 0.01614090f, 0.15812190f, -0.07185174f, 0.01534255f, 0.05641257f, 0.00197746f, 
    -0.17206402f, 0.07568250f, 0.05038056f, 0.16971186f, -0.01882520f, 0.13925590f, 0.15015090f, 0.07031299f, 
    0.06442279f, 0.08693524f, 0.09839685f, -0.15726216f, -0.08344180f, 0.24809425f, -0.01912462f, -0.04605706f, 
    -0.11829991f, -0.05114274f, 0.07868019f, 0.20087551f, 0.11033794f, -0.13827601f, 0.16925301f, 0.14614534f, 
    -0.16983677f, 0.02495085f, 0.07786958f, 0.13180140f, 0.06797040f, 0.29431969f, 0.13158004f, 0.01347843f, 
    -0.06156022f, -0.05533088f, 0.09527945f, 0.08613435f, 0.01233318f, 0.03196872f, -0.08054984f, -0.03692915f, 
    -0.17750418f, 0.00563310f, 0.03739272f, -0.23270482f, 0.05891847f, -0.12097847f, 0.10271534f, 0.07766175f, 
    0.06987316f, -0.11318462f, 0.02079665f, 0.14499225f, 0.40183589f, 0.45902404f, -0.09827358f, 0.11851896f, 
    -0.01855247f, -0.06494348f, 0.15224288f, 0.38566634f, 0.05268500f, 0.00249185f, -0.07724377f, 0.18172909f, 
    0.19942278f, 0.30412281f, 0.22317716f, -0.25342119f, 0.08403550f, 0.02497578f, -0.10750297f, 0.04663461f, 
    -0.06254232f, 0.06804494f, 0.09388336f, 0.09732275f, -0.14274706f, -0.11697932f, 0.07491063f, -0.21765658f, 
    0.10192809f, -0.01128626f, -0.22842847f, -0.14550407f, 0.07328971f, -0.21779209f, -0.32681066f, -0.18235202f, 
    -0.17164318f, -0.30345500f, -0.11903540f, 0.03608092f, -0.02815286f, 0.06612308f, 0.09186302f, -0.11888033f, 
    -0.10278485f, -0.10231554f, 0.02968911f, 0.13845287f, 0.07552939f, -0.07472696f, -0.09047198f, 0.30566436f, 
    0.13057527f, -0.08325962f, -0.10744415f, -0.17956103f, -0.05778767f, 0.15991648f, 0.10264651f, 0.01656296f, 
    -0.02740198f, 0.03043184f, -0.25207049f, 0.01999156f, 0.13553740f, 0.16556598f, -0.08036185f, 0.15776478f, 
    -0.11457602f, 0.10729362f, 0.15237331f, 0.17225994f, 0.14123483f, -0.07600676f, 0.17713630f, 0.27849030f, 
    0.08144085f, 0.06602384f, -0.18835531f, -0.07010775f, 0.04133210f, -0.05428039f, -0.10033733f, 0.14019500f, 
    0.44360518f, 0.02127320f, -0.16063946f, -0.09489289f, 0.07013426f, -0.20050278f, -0.18229239f, 0.03421306f, 
    0.09082230f, 0.16294469f, 0.05818360f, -0.11515313f, 0.14379187f, -0.25755745f, 0.06844117f, -0.10450437f, 
    -0.07805753f, -0.07581409f, -0.09085507f, -0.17211181f, -0.05220274f, 0.10360225f, 0.12187202f, 0.09449670f, 
    -0.01273030f, -0.14612013f, 0.35222328f, -0.06472997f, -0.06415603f, -0.06563152f, 0.06379825f, 0.13280448f, 
    0.07401768f, -0.02171833f, 0.06722387f, -0.06078883f, 0.13738282f, -0.16884047f, -0.18946698f, 0.41392201f, 
    0.07264761f, -0.13545132f, 0.05485781f, 0.08677921f, 0.04559031f, 0.29242322f, -0.10909313f, 0.04702863f, 
    -0.47443631f, -0.09482833f, 0.48773846f, -0.01872667f, -0.12433472f, -0.13546953f, 0.18286720f, -0.00364936f, 
    0.00068662f, 0.17031460f, -0.07026830f, 0.12338094f, 0.31078345f, -0.08800665f, 0.17962730f, -0.20447868f, 
    0.08924630f, -0.07830936f, -0.02325284f, 0.14865647f, 0.08874962f, 0.04205692f, -0.28679895f, -0.22248222f, 
    0.25177547f, 0.29801494f, -0.07136647f, -0.05318917f, 0.14790365f, -0.05561910f, 0.02478813f, 0.11517683f, 
    -0.09824180f, -0.11447328f, -0.30036840f, 0.08254983f, 0.26394561f, -0.00325128f, 0.08835379f, 0.17668144f, 
    0.07954534f, -0.04357407f, -0.31072459f, -0.08795022f, -0.00663017f, -0.03266563f, -0.02917469f, -0.08572422f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01454670f, 0.04304522f, -0.08534007f, -0.05195586f, -0.06125865f, 0.05951080f, 0.07545049f, 0.06101211f, 
    -0.06961010f, 0.01957121f, 0.01852281f, -0.06027221f, 0.02433414f, 0.08543655f, 0.07302581f, -0.01561595f, 
    -0.05235301f, -0.11065793f, 0.04866939f, 0.08193152f, -0.05029018f, -0.04722248f, 0.08185582f, 0.11554122f, 
    0.03023239f, -0.02581920f, -0.02505150f, 0.20653690f, -0.11239272f, 0.10766848f, 0.05003260f, 0.13378175f, 
    -0.02888815f, -0.04224822f, -0.05207118f, -0.03832543f, -0.09194268f, -0.00176983f, -0.01523491f, -0.07040405f, 
    0.04832421f, 0.07060422f, -0.04995514f, 0.17378649f, 0.07131598f, -0.00123760f, -0.00244327f, 0.03586543f, 
    -0.01437898f, 0.03831987f, 0.11416364f, -0.08196303f, 0.18023999f, -0.05574859f, 0.04638361f, 0.05888164f, 
    -0.03769765f, 0.10689877f, 0.03362931f, -0.05063220f, -0.07248224f, -0.02851307f, 0.04898338f, -0.12780814f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.25003272f, 0.17554019f, 0.02855738f, -0.01912615f, -0.08353917f, 0.00650544f, 0.30987248f, 0.18171702f, 
    0.05409537f, -0.00661700f, -0.08318311f, 0.03258191f, -0.01585256f, -0.63367212f, -0.65379888f, -0.12231223f, 
    0.22681355f, 0.04413220f, 0.07490199f, -0.06817563f, 0.28687114f, 0.09634125f, -0.09747136f, -0.13560641f, 
    -0.01290213f, 0.19909754f, 0.11511552f, -0.35010359f, 0.31104806f, -0.24718390f, 0.05003507f, -0.54964083f, 
    -0.04243705f, 0.02381024f, 0.03168174f, -0.28144461f, -0.69437057f, -0.07793929f, -0.18222542f, -0.06752536f, 
    0.03350404f, 0.07177075f, 0.34678483f, -0.17345586f, -0.27882597f, 0.07700050f, -0.30356860f, -0.02107116f, 
    -0.04673987f, 0.20473908f, -0.58024943f, -0.05729564f, -0.29370445f, 0.04944461f, 0.13612871f, 0.02335342f, 
    0.28085831f, -0.53203708f, -0.18660964f, 0.10546255f, 0.13828905f, -0.11077835f, -0.13865820f, 0.44564936f, 
    -0.36573389f, 0.07031623f, 0.79931605f, 0.04218920f, -0.06247298f, 0.20350932f, 0.06699990f, -0.06645937f, 
    -0.01366429f, 0.03200597f, -0.44916457f, 0.05234426f, -0.03594968f, 0.20538761f, -0.19622403f, 0.03996959f, 
    0.30450022f, 0.21006469f, 0.10393826f, 0.17527397f, 0.10888712f, -0.09700065f, -0.07743545f, 0.02889910f, 
    -0.04114451f, 0.22391273f, -0.10678160f, 0.15015972f, -0.06389363f, -0.07766103f, -0.35167977f, 0.15009905f, 
    -0.11996669f, -0.07389489f, 0.02559627f, -0.28287733f, 0.15347382f, -0.00541804f, -0.02140151f, 0.02966781f, 
    -0.04836477f, 0.24157000f, 0.19448893f, -0.17661422f, 0.14495310f, -0.22427700f, 0.00342579f, 0.06695127f, 
    -0.01576010f, -0.02876115f, 0.10519078f, 0.02310591f, -0.11586309f, 0.00974455f, 0.01692328f, 0.25376144f, 
    -0.00578930f, 0.33770138f, -0.06832538f, -0.16677888f, -0.20972693f, -0.17794746f, -0.36634991f, -0.40622503f, 
    -0.48164910f, -0.38924956f, -0.37180552f, -0.10987497f, 0.11225828f, -0.28590542f, -0.15937753f, -0.18417020f, 
    -0.07698831f, -0.07072805f, -0.12847239f, 0.03414975f, -0.05018297f, 0.23777753f, 0.02210897f, 0.11356364f, 
    0.31905672f, 0.01230847f, -0.10258125f, -0.48249006f, 0.18450759f, 0.32646254f, -0.20571104f, 0.15298139f, 
    -0.05909026f, -0.13750771f, -0.10592981f, 0.20289625f, 0.19638935f, 0.16091891f, -0.19017835f, 0.08893354f, 
    -0.06250660f, 0.08100752f, 0.07877179f, 0.23727205f, 0.05283990f, -0.01931513f, -0.15336974f, -0.02889858f, 
    -0.04154682f, -0.11358812f, -0.14477405f, -0.39642152f, -0.03927273f, 0.15412259f, -0.14660954f, -0.11784389f, 
    -0.02584255f, -0.10565474f, -0.48699400f, -0.14117998f, -0.19484399f, 0.02284487f, 0.04170205f, 0.06027918f, 
    0.08838808f, -0.66117871f, 0.24144959f, 0.38111910f, 0.12770520f, 0.31942675f, -0.47832170f, 0.44526231f, 
    0.11473799f, 0.16839196f, -0.50271797f, 0.06976479f, 0.03054008f, -0.68691826f, 0.09025934f, 0.27613220f, 
    -0.03287107f, 0.05821807f, 0.15254764f, 0.10333859f, -0.10640619f, -0.05161669f, 0.12527454f, 0.09969918f, 
    -0.64858776f, -0.17838435f, 0.04674732f, 0.31641066f, -0.34409943f, -0.19365342f, -0.39567664f, -0.40668952f, 
    -0.10310431f, 0.08050413f, 0.10177166f, 0.02723452f, 0.14894602f, -0.18819855f, -0.31300411f, -0.00204175f, 
    0.02395255f, 0.11354209f, -0.05051193f, -0.00588817f, 0.31770676f, 0.02752473f, 0.00045415f, 0.07698581f, 
    0.09677125f, -0.12243637f, -0.07468359f, -0.18291518f, -0.31794584f, 0.27132481f, -0.03809477f, 0.04298250f, 
    -0.01478710f, -0.81146491f, 0.09753175f, 0.26546001f, 0.13132645f, 0.09711296f, 0.30268908f, 0.18985307f, 
    -0.00323267f, -0.31176129f, -0.18203309f, -0.07133582f, 0.06371003f, -0.07842556f, 0.19211963f, 0.19030939f, 
    0.17914778f, -0.07530661f, -0.00699353f, 0.05057919f, -0.07632634f, 0.30592632f, 0.10601120f, 0.22971536f, 
    0.06269436f, -0.02099449f, 0.07250851f, 0.07152911f, 0.10028994f, 0.01079707f, -0.03571942f, -0.03989149f, 
    -0.32823440f, 0.13735764f, 0.03460468f, 0.16518596f, -0.07974131f, 0.07526869f, -0.17722179f, -0.33450204f, 
    0.07247553f, -0.42609078f, -0.02714172f, -0.09828936f, 0.01691411f, -0.48037082f, 0.20184904f, 0.08929177f, 
    -0.05568617f, 0.07191221f, -0.01134608f, 0.05465592f, -0.40160093f, 0.06349318f, 0.02283116f, -0.00614442f, 
    -0.07465087f, 0.31550360f, -0.13062756f, 0.20966397f, -0.19240895f, -0.64966726f, 0.28968701f, -0.05581284f, 
    -0.00030200f, -0.31901073f, -0.05041292f, -0.06700764f, -0.22412498f, 0.01364567f, -0.26504600f, 0.08729157f, 
    -0.23537071f, 0.21639755f, -0.27654952f, -0.07487787f, 0.28244263f, 0.31307331f, 0.02419363f, 0.30472925f, 
    0.37030488f, -0.12692094f, -0.46382579f, -0.02817201f, -0.01761741f, -0.03332200f, -0.00427611f, -0.21069516f, 
    0.02161438f, 0.02323300f, -0.03635388f, 0.04154611f, 0.00408459f, -0.19138873f, -0.26970467f, 0.00939070f, 
    -0.28572944f, -0.06413264f, -0.06622638f, 0.23559675f, -0.04701157f, -0.28215674f, 0.01421767f, 0.20785184f, 
    -0.10673887f, -0.15714088f, -0.00011504f, -0.21267012f, -0.44037327f, 0.12269755f, 0.12602045f, -0.41860500f, 
    0.09173635f, -0.00199514f, 0.02561140f, -0.03626530f, 0.08506534f, -0.12043079f, 0.30009434f, 0.04166845f, 
    -0.03053238f, 0.31288227f, 0.15173952f, 0.26449299f, 0.18076666f, 0.12540969f, 0.31315631f, 0.12528650f, 
    -0.09083817f, 0.19792329f, -0.44030365f, 0.07980850f, 0.39832470f, -0.03384675f, 0.24499482f, -0.02183563f, 
    0.09306099f, -0.07740615f, 0.33951068f, -0.26992971f, -0.22606617f, -0.48789108f, -0.15997708f, -0.70071942f, 
    -0.10801539f, 0.10461531f, -0.41522986f, -0.10043891f, 0.06563206f, 0.04389669f, -0.30911994f, 0.21551609f, 
    -0.04850296f, -0.09007376f, 0.29043606f, -0.12177208f, -0.06051943f, 0.06050587f, 0.21505800f, -0.04702404f, 
    -0.44530153f, -0.28972071f, 0.05721497f, 0.07813913f, 0.19573650f, -0.71717542f, 0.13849932f, -0.04855893f, 
    0.07360453f, 0.24106368f, -0.00383355f, 0.11425461f, -0.09306051f, 0.18504949f, -0.18309225f, 0.14167893f, 
    -0.07060178f, -0.12758476f, 0.04747459f, 0.45774829f, -0.31899151f, 0.10708654f, -0.46504173f, 0.11101386f, 
    0.10367046f, -0.01179221f, -0.50027746f, 0.04025577f, 0.33964372f, 0.19721292f, -0.04150397f, 0.00598434f, 
    0.05923392f, -0.06208459f, -0.78994113f, -0.62503570f, -1.05577409f, -0.04852825f, -0.16262974f, -0.08929454f, 
    -0.03289986f, -0.22552170f, 0.02735543f, 0.23862952f, 0.22338088f, -0.03324027f, 0.05070089f, -0.15572548f, 
    -0.16406226f, -0.05329046f, 0.05538258f, -0.07601058f, -0.11190915f, -0.19065522f, -0.64999866f, -0.23152176f, 
    -0.01959507f, -0.03422072f, 0.25837144f, -0.06171767f, 0.04465850f, 0.07166262f, -0.22109228f, 0.06527770f, 
    0.12834097f, 0.15277968f, -0.07100344f, -0.24196826f, -0.20103702f, -0.06772020f, -0.35157761f, 0.10046747f, 
    -0.11826941f, -0.22540665f, -0.05064576f, -0.40473518f, 0.18193942f, -0.24435975f, 0.24124761f, -0.06954789f, 
    0.10905465f, 0.10730133f, -0.01043132f, 0.13187839f, 0.22064516f, 0.07049907f, 0.18395557f, 0.00951898f, 
    0.07944721f, -0.05426765f, 0.12720971f, -0.32553667f, 0.04520159f, -0.09856253f, 0.00617003f, -0.01414127f, 
    -0.07393374f, 0.18361320f, 0.26501548f, 0.11634960f, -0.02203665f, -0.08018637f, -0.08975216f, -0.37139493f, 
    -0.47149864f, 0.28893584f, -0.47268277f, 0.16773738f, 0.12194919f, -0.14422025f, 0.16044155f, 0.17507659f, 
    -0.03801895f, -0.40746707f, -0.52461576f, 0.09616674f, -0.02272423f, 0.20161870f, 0.25678447f, -0.05971442f, 
    0.02018327f, 0.11676029f, 0.17149234f, -0.06598426f, -0.06738634f, 0.11963475f, 0.17797641f, 0.00750005f, 
    0.25354940f, 0.17573011f, -0.00318828f, -0.02868899f, -0.52317512f, -0.13568118f, 0.25958523f, 0.03883491f, 
    0.07933803f, 0.10458039f, 0.05679652f, -0.39411169f, -0.34267873f, 0.21995367f, -0.45782304f, 0.18792714f, 
    0.06698117f, -0.12325960f, 0.05096602f, -0.48962352f, -0.39084780f, 0.04929293f, -0.24905378f, -0.07982380f, 
    0.07678037f, -0.07373577f, -0.18218005f, -0.00880379f, -0.45743418f, -0.26782173f, 0.14943613f, -0.11665221f, 
    0.00593966f, 0.04040486f, -0.18680868f, 0.21025251f, 0.40139300f, -0.02543317f, -0.51327890f, 0.18602726f, 
    -0.25707111f, 0.09183092f, -0.23045057f, 0.26685426f, 0.23703666f, -0.29180953f, -0.10129738f, -0.47512510f, 
    -0.01483339f, 0.11947940f, 0.25702268f, -0.06033518f, -0.07632103f, 0.09197727f, 0.05010303f, -0.71711278f, 
    0.09715995f, 0.01005796f, 0.17111169f, 0.03226714f, 0.03045013f, -0.50741196f, 0.29545712f, -0.04809085f, 
    -0.28426328f, -0.00469630f, -0.09412783f, 0.02405661f, 0.21471833f, -0.22299434f, 0.35487872f, -0.20601358f, 
    0.08156230f, -0.16060255f, 0.02148769f, 0.20742422f, -0.01139719f, -0.14394735f, 0.26741269f, 0.04228739f, 
    -0.02151332f, -0.01912072f, -0.11167859f, 0.26466835f, 0.02476001f, 0.04838287f, 0.28787291f, -0.01053672f, 
    0.06310210f, -0.07089001f, -0.63173896f, -0.16984934f, 0.09164001f, -0.42377916f, -0.56492668f, 0.03357318f, 
    -0.04069402f, -0.06458959f, 0.34827825f, -0.31325188f, 0.60825187f, -0.09465380f, 0.04529523f, -0.39233273f, 
    0.10131381f, -0.02911534f, 0.02780125f, 0.17203043f, -0.61028981f, 0.27200240f, 0.14490345f, -0.18277538f, 
    -0.26781502f, -0.17720248f, -0.06474637f, 0.07668781f, -0.03915136f, -0.76117474f, 0.12489749f, 0.02580699f, 
    -0.01177189f, 0.06880201f, -0.40238041f, 0.08669616f, 0.04267622f, 0.24900635f, 0.53490269f, -0.08056509f, 
    -0.40413281f, -0.27506366f, -0.05058418f, -0.11429322f, 0.18646930f, 0.08748194f, -0.41312173f, 0.46180290f, 
    0.09923303f, -0.03642959f, -0.12088256f, 0.13322116f, -0.05599974f, 0.13947469f, 0.24919647f, 0.21697854f, 
    -0.06238245f, 0.07259797f, 0.06360971f, -0.26598850f, 0.02296764f, 0.03146610f, -0.07933572f, 0.10768873f, 
    0.07358336f, -0.35332802f, 0.20561361f, 0.10189346f, 0.02840955f, 0.25453055f, -0.42275020f, -0.06656975f, 
    0.09869210f, 0.41496772f, 0.23767279f, -0.08275302f, -0.04674013f, 0.09455363f, -0.18867561f, 0.24796163f, 
    -0.36528450f, -0.30982491f, -0.50947440f, -0.62796724f, -0.30210689f, 0.11590097f, 0.11424340f, -0.04954044f, 
    0.14051525f, -0.04989019f, -0.36507869f, -0.08345467f, 0.10515599f, -0.39996886f, 0.04506741f, 0.03614144f, 
    0.06768799f, -0.10797267f, 0.14905933f, -0.00437163f, 0.02737929f, 0.22731200f, -0.49887693f, -0.04923891f, 
    0.15540513f, -0.70739532f, 0.06286243f, -0.28057367f, -0.41361985f, 0.13607582f, -0.10637314f, -0.46585137f, 
    -0.09959129f, 0.24877088f, -0.10183716f, 0.12013461f, 0.20446682f, 0.31216195f, 0.03121108f, 0.25860769f, 
    -0.03778183f, -0.09457269f, -0.03159420f, -0.02434502f, -0.36680785f, 0.04218439f, 0.29178706f, 0.07716748f, 
    -0.05399111f, -0.40530381f, -0.17787905f, 0.18437722f, 0.03297123f, 0.01485135f, 0.22745125f, -0.04780447f, 
    -0.03235404f, -0.29853314f, 0.00105105f, -0.42495796f, -0.15191150f, 0.04899573f, 0.22621734f, -0.26051009f, 
    0.30820972f, 0.17371845f, 0.24937916f, -0.84460014f, 0.20581293f, -0.16810936f, 0.00569411f, -0.25432023f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.07768317f, -0.08504912f, -0.12940571f, -0.08750726f, -0.11030765f, 0.08949300f, -0.03417306f, -0.17609856f, 
    0.04818244f, 0.12010175f, 0.18239741f, 0.05193127f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
