#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.23048250f, 0.00224120f, -0.82943225f, 0.09269597f, -0.27910468f, -0.72450644f, -0.07399741f, 0.36615384f, 
    0.08138905f, 0.21155283f, -0.57726794f, -0.08050781f, 0.27905306f, -0.28540269f, -0.34419429f, -0.30437863f, 
    -0.22528836f, 0.40228269f, -0.05570613f, -0.08772246f, 0.38839117f, 0.49886653f, -0.23219651f, 0.06504326f, 
    0.25492370f, -0.36264941f, -0.02512997f, -0.49361151f, -0.27636960f, -0.24265970f, 0.62781733f, -0.37429059f, 
    -0.39275622f, 0.26901475f, -0.47163105f, 0.04201588f, -0.25654393f, -0.14276600f, -0.21324264f, -0.18948579f, 
    0.24801198f, 0.45751205f, -0.40295577f, 0.05528863f, -0.03178791f, -0.40184593f, 0.41625595f, 0.32145339f, 
    -0.19175738f, -0.20577791f, 1.12032890f, 0.55574340f, -0.05821244f, 0.20218393f, 0.44684607f, 0.06977798f, 
    0.18895188f, 0.20708862f, 0.48385483f, -0.00908960f, -0.20266214f, -0.11991619f, -0.28112727f, -0.38566741f, 
    -0.24049555f, -0.31267467f, -0.23798306f, 0.10700931f, -0.09239151f, -0.06867056f, 0.17852186f, -0.01141708f, 
    -0.01331846f, -0.05296162f, 0.06049746f, -0.12802950f, -0.18364266f, -0.20984852f, -0.67894971f, 0.03719904f, 
    -0.54302746f, -0.11814958f, -0.59788901f, -0.80638933f, -0.33772585f, -0.09071366f, 0.45609272f, 0.23436269f, 
    0.12596919f, -0.50273508f, -0.01982179f, -0.00710917f, 0.34167472f, 0.17086314f, 0.41577062f, 0.20651081f, 
    -0.16151997f, -0.01148281f, -0.07212904f, -0.05193042f, -0.63265258f, -0.18593475f, -0.65205121f, -0.58692741f, 
    -0.11349983f, -0.17239356f, 0.84475708f, 0.34628233f, 0.47867498f, 0.70476145f, -0.22883984f, -0.26000145f, 
    0.05993038f, -0.42593285f, -0.21258947f, 0.15817419f, 0.26556143f, 0.02478007f, 0.08474280f, 0.06817351f, 
    -0.01304711f, -0.10551498f, -0.38823912f, -0.15271063f, 0.13043615f, -0.43886566f, -1.09902775f, -0.37270182f, 
    0.75325269f, -0.61902130f, -0.41452208f, 0.25477439f, 0.28052655f, -0.01256363f, -0.30695522f, 0.36120087f, 
    0.16728091f, -0.09041651f, 0.48941284f, 0.30471224f, -0.26093170f, 0.16383599f, 0.20427619f, 0.05083188f, 
    -0.40804312f, 0.08819861f, 0.11763371f, -0.13675262f, 0.10433283f, -0.37604481f, 0.67357200f, -0.20754237f, 
    0.25991866f, 0.71917367f, 0.54925960f, -0.09099479f, -0.08361027f, -0.25743216f, -0.27278981f, 0.38294220f, 
    0.54662585f, 0.03501948f, -0.35548404f, 0.32794929f, -0.43077517f, 0.33503667f, 0.09726300f, 0.40970454f, 
    0.10394171f, 0.47887006f, -0.34593710f, 0.00109838f, 0.41317394f, -0.21471274f, -0.38244447f, 1.14570594f, 
    0.51671362f, -0.95596683f, -0.68254787f, -0.55316871f, 0.00643757f, -0.21847299f, 0.04541722f, -0.14164861f, 
    -0.63173687f, 0.03559158f, 0.08982950f, 0.36766973f, -0.01778102f, -0.04326199f, 0.16710654f, 0.05784656f, 
    -0.02698827f, -0.19369817f, 0.14895938f, 0.06614826f, 0.23086165f, 0.11078583f, 0.02154481f, 0.23101731f, 
    0.33838066f, 0.97541481f, 0.58772409f, 0.69701099f, 0.64883059f, 0.39567080f, -0.30827206f, -0.76379955f, 
    0.28577247f, -0.17491488f, 0.02851190f, 0.06953303f, -0.10904150f, 0.20222695f, -0.25390080f, 0.01176311f, 
    0.22790810f, 0.24710932f, 0.03537122f, 0.20423555f, 0.17983688f, 0.02628078f, -0.22871579f, -0.23311830f, 
    0.03427743f, 0.90670961f, 0.07778850f, -0.58323473f, 1.09906387f, 0.79076809f, 0.41031611f, 0.57541203f, 
    0.01522961f, 0.62512302f, -0.22823131f, -0.17613733f, -0.29760960f, -0.41163641f, -0.32302186f, -0.31413236f, 
    0.03334448f, -0.24443457f, -0.20526215f, -0.07059716f, -0.10364026f, 0.08916825f, 0.03334824f, -0.13522874f, 
    -0.14130901f, -0.14634883f, -0.07034578f, -0.71783721f, -0.07642814f, -0.47222325f, 0.36992002f, 0.22559249f, 
    -0.46368566f, -0.38023996f, -0.39062566f, 0.19018544f, -0.38269857f, 0.44412026f, -0.12095859f, 0.04398667f, 
    0.31606123f, 0.15349315f, 0.30591097f, 0.34715885f, -0.07016384f, -0.35724846f, 0.43672431f, -0.12830554f, 
    0.01404488f, -0.00764731f, 0.15634446f, -0.20627090f, 0.25745201f, -0.27391997f, 0.02331563f, 0.61477143f, 
    -0.32418060f, -0.64332956f, -0.53969204f, -0.58387458f, -0.12481348f, 0.05944244f, -0.08614533f, -0.21902791f, 
    -0.07334971f, -0.51388639f, 0.25275970f, -0.03703618f, -0.67600906f, -0.33560637f, -0.05072689f, -0.19716187f, 
    0.11251399f, 0.29228601f, -0.36716810f, 0.15203132f, 0.84393072f, 0.61154199f, 0.52581334f, 0.14160664f, 
    -0.26049888f, 0.22539344f, -0.14546923f, 0.01487286f, 0.18436193f, 0.31800836f, 0.41934413f, 0.51646268f, 
    -0.40610018f, 0.27873883f, -0.12546480f, 0.15638511f, 0.10275815f, 0.36632994f, -0.04599052f, -0.39349353f, 
    0.19777678f, 0.34061632f, -0.15658446f, -0.04430739f, 0.28903395f, -0.86744994f, 0.46778825f, -0.06477689f, 
    -0.55234826f, -0.55028510f, 0.85509956f, -0.15149395f, 0.19660455f, 0.08161361f, 0.29084492f, -0.49232987f, 
    -0.38075569f, -0.41306373f, -0.13799931f, -0.36422068f, -0.43770260f, -0.14706589f, -0.48928273f, -0.32560515f, 
    -0.16071270f, -0.10636096f, -0.01682492f, 0.02846068f, 0.20096453f, 0.17009293f, 0.08602472f, -0.30282041f, 
    0.27454981f, -0.27163586f, 0.39189181f, 0.60347104f, -0.59831339f, -0.25356624f, 0.10571682f, -0.29768148f, 
    0.28969991f, 0.22710463f, 0.23987445f, 0.27233690f, 0.12765035f, 0.37384084f, -0.19317304f, -0.58723420f, 
    -0.03243568f, -0.52141964f, 0.03427748f, -0.26378837f, 0.01140149f, 0.27763778f, 0.51889312f, 0.96014792f, 
    -0.09692606f, -0.55042404f, -0.69978678f, 0.37861851f, -0.17794085f, -0.48106408f, -0.27425849f, 0.31770486f, 
    0.28689715f, -0.38078406f, 0.02371545f, 0.25002134f, -0.02740792f, -0.06275570f, 0.17613807f, -0.04602320f, 
    0.15102106f, 0.32744259f, 0.13285989f, 0.00610000f, 0.26982349f, -0.07750937f, -0.29554316f, 0.50914389f, 
    0.99613333f, 0.46847749f, 0.83101511f, -0.49158779f, -0.66271436f, 0.07228126f, -0.87852514f, 0.21408796f, 
    0.41415015f, 0.38684043f, 0.07399936f, -0.13994640f, -0.40962163f, -0.25027233f, 0.28019035f, -0.00328166f, 
    0.08620009f, -0.09500705f, -0.20847987f, -0.02459536f, 0.23109561f, 0.29893810f, -0.13180886f, 0.32005545f, 
    -0.10926727f, 0.36593744f, 0.70238429f, 0.44375646f, 0.66562694f, 0.17801166f, 0.30738428f, 0.15076655f, 
    0.21620230f, -0.07363636f, 0.25096393f, 0.11450424f, 0.01382696f, 0.12278651f, 0.14601128f, 0.04614027f, 
    0.15096977f, -0.30266574f, 0.29663691f, -0.06061957f, -0.24932234f, 0.18645038f, 0.04042273f, -0.30417392f, 
    0.06579026f, -0.24862142f, 0.10910778f, 0.26010710f, 0.77144927f, 0.31832871f, 0.17705643f, 0.71063614f, 
    -0.15319434f, -0.89749682f, -0.75300229f, 0.04936457f, 0.29219958f, 0.28890449f, 0.25216439f, -0.19081908f, 
    -0.27924940f, -0.24970999f, -0.34835306f, 0.18593110f, -0.12653325f, -0.38370258f, 0.25767207f, 0.24531169f, 
    0.06012228f, 0.31210551f, -0.19794729f, 1.08582115f, -0.26536462f, 0.41670367f, -0.90478581f, -0.34233043f, 
    0.69399512f, -0.07155301f, 0.37174922f, -0.03005172f, -0.00673090f, -0.23010819f, 0.11468898f, -0.45137441f, 
    0.09877686f, 0.05667525f, -0.18989304f, 0.08150248f, 0.11374640f, 0.10237860f, -0.03346612f, 0.17116311f, 
    0.30809951f, -0.30842280f, 0.05653320f, 0.09873460f, -0.04129794f, -0.69714409f, 0.34533316f, -0.30348644f, 
    -0.42659083f, 0.58362949f, 0.10917211f, 0.73118973f, 0.04830418f, -0.17523950f, -0.13544019f, -0.53635263f, 
    -0.01565812f, -0.01303072f, 0.02584873f, 0.27068964f, -0.01992013f, -0.55282640f, -0.06326053f, 0.07326553f, 
    -0.32479325f, 0.13444041f, 0.25824577f, -0.00170431f, 0.40038916f, -0.15690583f, 0.13330200f, 0.44538254f, 
    -0.03841817f, -0.17209378f, 0.06981805f, -0.64099193f, -0.35375717f, -0.76653314f, -0.32646927f, -0.34542149f, 
    0.32327682f, 0.33195683f, -0.22800820f, 0.53890449f, -0.13048944f, -0.31983626f, 0.26829195f, -0.13607229f, 
    0.49864489f, 0.13563143f, 0.26466540f, -0.17831396f, 0.05249505f, 0.45934376f, -0.64307064f, -0.14942409f, 
    -0.17239334f, 0.19636452f, -0.32460567f, -0.41021830f, -0.13261230f, -0.20922683f, 0.32559693f, 0.26690066f, 
    0.28919700f, 0.45915380f, -0.55231404f, 0.01000458f, -0.12508555f, -0.12428512f, 0.17927216f, 0.03355443f, 
    0.11392850f, 0.53700721f, 0.44740042f, 0.24243280f, 0.45860326f, -0.03265958f, 0.10955821f, -0.42647177f, 
    0.41936648f, -0.28275293f, -0.77215004f, -0.63002396f, 0.39132631f, 0.51823795f, -0.08002032f, -0.00590202f, 
    0.51305342f, 0.50604081f, -0.18610944f, -0.25766015f, -0.11036796f, -0.14828935f, 0.21708165f, -0.04956632f, 
    -0.13061142f, 0.10679297f, 0.33976328f, -0.30435842f, -0.08820640f, 0.10146412f, -0.44207209f, 0.15329410f, 
    0.85980856f, 0.35042912f, 0.11248282f, 0.27098086f, 0.04520623f, -0.14746848f, 0.20366591f, -0.23421097f, 
    0.14259630f, 0.28604180f, 0.01319171f, 0.21856607f, -0.12746845f, 0.13825545f, 0.44032764f, 0.18602180f, 
    -0.19600418f, 0.40096921f, 0.09041922f, 0.11403362f, 0.36444986f, 0.41039112f, 0.09068573f, 0.32963189f, 
    0.02728524f, -0.65290934f, -0.34463146f, -0.43159527f, -0.17522517f, -0.13447472f, -0.46357387f, -0.52051836f, 
    -0.27677470f, 0.07493497f, 0.06432958f, -0.47205299f, 0.18404695f, -0.07812247f, -0.12482142f, -0.38564467f, 
    0.01730033f, -0.20002975f, 0.35392049f, -0.46375954f, -0.34371927f, -0.26431692f, 0.29022110f, -0.22027975f, 
    0.08356121f, 0.00281532f, -0.11475616f, -0.19414297f, 0.44285503f, 0.28789052f, 0.71657413f, -0.49775109f, 
    0.69117051f, 0.40798140f, -0.39149976f, 0.72701591f, -0.39078075f, 0.22976153f, 0.08251579f, -0.49481401f, 
    -0.05714824f, -0.17344870f, -0.11719748f, 0.19562148f, 0.10777192f, -0.23895305f, 0.40310097f, 0.02079951f, 
    0.10574030f, -0.10144309f, 0.20811868f, -0.00117477f, -0.66106242f, 0.42022565f, 0.57885092f, 0.01961106f, 
    -1.05335295f, -0.23359774f, 0.02217739f, -0.48183843f, -0.50374067f, 0.31071761f, 0.22623323f, 0.29510191f, 
    -0.26042372f, -0.08389822f, -0.48486528f, 0.28730062f, -0.06142322f, 0.18349771f, -0.59148115f, -0.40346843f, 
    0.03732393f, -0.18836778f, 0.15277743f, 0.34218922f, -0.40253502f, 0.37467080f, 0.42420623f, 0.10895116f, 
    0.21394369f, -1.07977629f, 0.37414962f, -0.45584011f, -0.85417664f, -0.43674889f, -0.03116487f, 0.31111592f, 
    0.06093438f, 0.14943019f, 0.34322083f, 0.23344229f, 0.13258280f, 0.08578905f, -0.11988892f, -0.09440649f, 
    0.23242834f, 0.17710149f, 0.23613663f, 0.02923391f, -0.28619719f, -0.59225798f, -0.42670149f, -0.07982175f, 
    0.40758592f, -0.13361694f, -0.16425803f, 0.71717596f, 0.07545676f, -0.45384994f, 0.05626053f, -0.28584641f, 
    -0.07213002f, -0.43692276f, 0.54879642f, 0.03691484f, 0.26496580f, -0.14014584f, -0.59408170f, 0.21854754f, 
    0.11195669f, 0.03256081f, 0.18667211f, 0.14221857f, -0.00665522f, 0.05205825f, -0.63710940f, -0.73100257f, 
    0.24999236f, -0.14635690f, 0.14413454f, -0.26219240f, 0.50737071f, -0.32786131f, 0.29573521f, 0.39618626f, 
    -0.51468831f, -0.09847961f, -0.43751061f, 0.06478009f, -0.43902686f, 0.03043702f, -0.12647171f, 0.17675382f, 
    0.06269638f, -0.10829065f, 0.00326260f, -0.15387514f, -0.08573078f, -0.17793907f, 0.04478526f, 0.67386204f, 
    -1.19865119f, -0.51498622f, 1.01543272f, 0.49684313f, -0.91872633f, 0.77996266f, 0.36413142f, -0.33737797f, 
    0.20806579f, 0.35244185f, 0.18158537f, -0.34966397f, -0.03063271f, 0.16022992f, -0.04494077f, -0.08406185f, 
    -0.02134090f, -0.03556238f, -0.09719776f, 0.02036816f, -0.01673609f, -0.02593925f, 0.01254463f, -0.03043828f, 
    -0.60699964f, -1.05273771f, 0.17557879f, 0.13363515f, 0.22426325f, -0.31539837f, 0.91721922f, 0.62752646f, 
    -0.39780551f, -0.04921482f, 0.05040510f, -0.03022575f, 0.01106778f, -0.21914069f, 0.14862017f, -0.53340673f, 
    -0.12701239f, -0.33099416f, -0.22980914f, -0.31039187f, 0.18534172f, -0.05611754f, -0.02924479f, -0.20522520f, 
    0.01414145f, 0.00072240f, 1.25617981f, 0.71986985f, -0.13620499f, 0.39977446f, 0.16819328f, 0.42641544f, 
    -0.58872026f, -0.43666494f, -0.32434672f, -0.06252258f, 0.11714093f, 0.18202296f, 0.23687606f, 0.13707066f, 
    -0.19134243f, 0.17787564f, -0.22191939f, -0.10130361f, -0.04385521f, -0.07680541f, -0.14227515f, 0.01634932f, 
    -0.12479469f, -0.00611959f, 0.21834767f, -0.39587328f, -0.41132271f, 0.21941990f, 0.45715460f, -0.30862170f, 
    -1.06057918f, -0.33157924f, -0.43807009f, 0.11336751f, -0.01322752f, 0.36621496f, 0.30283797f, 0.13845789f, 
    0.31550208f, 0.05583964f, 0.08119769f, -0.29844493f, -0.14186798f, 0.13029321f, 0.11825293f, 0.11236073f, 
    -0.07714159f, 0.14840898f, -0.10877431f, 0.49904588f, -1.07325852f, -0.39549932f, -0.01795095f, 0.13144116f, 
    0.85462230f, -0.14486521f, 0.19329080f, 0.60564238f, 0.24112748f, -0.41064817f, 0.16550454f, -0.21448404f, 
    0.42130062f, 0.02504427f, -0.17348003f, 0.04471581f, 0.18848181f, 0.22592539f, 0.12061550f, -0.06136404f, 
    -0.03805314f, 0.03555901f, 0.08857129f, 0.15974493f, -0.58436316f, -0.41651961f, -0.54392755f, -0.60287672f, 
    -0.64847136f, -0.00397638f, -0.01446915f, -0.33723316f, -0.09143236f, -0.18569981f, 0.15446952f, 0.07611471f, 
    0.27210462f, -0.07455179f, 0.00906969f, 0.06390396f, 0.19684409f, 0.55279905f, 0.06345288f, -0.05741454f, 
    0.05610046f, 0.07491308f, -0.39701095f, 0.00494849f, 0.28843984f, -0.22511202f, -0.32612956f, -0.71982694f, 
    -0.56725395f, -0.21298461f, 0.01286247f, -0.01466693f, 0.35812524f, 0.61287725f, -0.23591357f, -0.34767166f, 
    -0.37260485f, -0.05052036f, -0.22143793f, -0.42798507f, 0.45844293f, 0.27011633f, -0.29396528f, -0.21310243f, 
    -0.00029919f, -0.01481778f, 0.10923878f, 0.38496977f, -0.12831786f, -0.17765243f, 0.73456442f, -0.75474805f, 
    -0.03905665f, -0.13338821f, 0.61839312f, 0.62235177f, 0.70424521f, -0.06468914f, -0.29619312f, -0.00493003f, 
    -0.12963367f, 0.16728295f, -0.15328158f, -0.03814527f, 0.04250123f, 0.03907854f, 0.14258307f, 0.18546988f, 
    0.08914501f, -0.11681820f, 0.07209061f, 0.16951528f, 0.18650964f, 0.10612580f, 0.11544456f, -0.57148105f, 
    -0.20992938f, 0.41917723f, -0.22864239f, 0.07622074f, 0.40714538f, 0.41064784f, 0.16420177f, 0.47668609f, 
    0.45364469f, 0.28581300f, -0.31986868f, 0.42686677f, 0.24316160f, -0.36260629f, -0.42144907f, -0.22167194f, 
    -0.11561790f, 0.06957615f, -0.00137523f, -0.56364542f, 0.08958651f, -0.15792803f, -0.12698936f, 0.06879004f, 
    0.97596771f, 0.37056381f, -0.06886156f, -0.75017107f, 0.65017408f, -0.19959947f, 0.02436896f, 0.06296462f, 
    -0.34855086f, -0.66573769f, 0.03449668f, -0.27109769f, -0.06487078f, 0.12287804f, -0.10629187f, 0.00710342f, 
    0.18529151f, -0.44884852f, -0.08683218f, 0.07658312f, -0.12377796f, -0.13499528f, 0.26401213f, -0.20871730f, 
    -0.33810568f, 0.15975088f, -0.51404673f, -0.83943009f, -0.64612401f, -0.48147440f, 0.15121104f, 0.79295069f, 
    0.49152526f, 0.55567563f, 0.47283876f, -0.20824648f, -0.11925887f, -0.07671330f, -0.24601643f, -0.32079604f, 
    -0.24375913f, 0.00048876f, 0.10757652f, 0.40066624f, -0.18997164f, -0.11951178f, -0.02396854f, -0.24607094f, 
    -0.28208160f, -0.05823131f, -0.44263595f, 0.32175490f, -0.75244200f, -0.13236485f, -0.18303093f, 0.77518505f, 
    -0.15866274f, -0.36492109f, 0.08667636f, -0.07411701f, -0.01660323f, 0.09589715f, 0.32801327f, 0.56093466f, 
    0.36801669f, 0.37620106f, 0.11246359f, -0.04575319f, -0.34396347f, -0.22415088f, 0.21938898f, 0.19799155f, 
    0.06420530f, -0.35023612f, 0.35216767f, 0.74734503f, 0.69093734f, 0.28034827f, 0.10377097f, -0.47569984f, 
    -0.51758921f, 0.08912675f, 0.50197417f, 0.54866475f, 0.12079628f, -0.22795925f, -0.00180516f, 0.05936456f, 
    -0.13774949f, -0.42994374f, 0.42226130f, -0.06691191f, -0.09966419f, -0.09632411f, 0.06118333f, -0.33806130f, 
    -0.20481490f, -0.10615987f, 0.22205256f, 0.28653193f, 0.43795460f, 0.47146529f, 0.51745808f, -0.48666206f, 
    -0.86822748f, -0.08733649f, -0.84762263f, -0.06865085f, -0.35269788f, 0.05999750f, 0.20309211f, -0.19844969f, 
    0.10326982f, -0.18337680f, 0.09737780f, -0.39163950f, -0.21780023f, -0.12438718f, -0.26964471f, -0.35653111f, 
    0.11337467f, 0.21154055f, -0.32373583f, 0.11337074f, -0.24346176f, -1.03506351f, 0.63272804f, 0.94644034f, 
    0.35810518f, -0.74727219f, -0.77698511f, 0.03269905f, 0.40194497f, 0.36661956f, -0.17352839f, -0.05928929f, 
    0.18740351f, -0.20822668f, 0.02997012f, 0.11920013f, 0.04970782f, 0.04233389f, 0.17416102f, -0.00795651f, 
    -0.00684321f, 0.17966348f, 0.07886324f, -0.28124055f, -0.20862943f, -0.22362290f, -0.97201300f, -0.57357407f, 
    0.66263795f, 0.38198918f, 0.37501892f, 1.07940352f, -0.32909146f, 0.16191377f, 0.05004700f, -0.62373871f, 
    0.16881035f, -0.33266428f, 0.32375112f, 0.35287377f, 0.02245286f, -0.00218495f, 0.13159071f, 0.08703589f, 
    -0.28702351f, 0.28879321f, -0.22987999f, 0.16202483f, -0.12357096f, -0.09039132f, -0.17842466f, 0.38344306f, 
    0.06656812f, 0.53517008f, 0.37173098f, 0.28211206f, -0.17484747f, -0.70538616f, -0.31755579f, -0.35549441f, 
    -0.28288934f, -0.17431414f, 0.17410569f, 0.13288790f, -0.12746197f, 0.25776216f, -0.13193086f, -0.00823775f, 
    0.03792841f, -0.14514226f, 0.65178686f, 0.04121327f, -0.13929570f, 0.27588072f, 0.40526873f, -0.22699694f, 
    0.79245484f, -0.30824655f, 0.51516837f, 0.80686998f, 0.35447878f, 0.56189746f, -0.08611841f, 0.01849643f, 
    0.42902309f, 0.16840413f, 0.08498199f, -0.25523096f, -0.13237703f, -0.20685455f, 0.33335227f, 0.24952880f, 
    -0.21152180f, -0.32706812f, -0.35437831f, -0.15883029f, -0.22586095f, -0.01715810f, 0.51956159f, 0.02211547f, 
    0.19619110f, -0.56718397f, -0.52956438f, -0.11695847f, -0.45591080f, -0.64082378f, -0.11587610f, 0.46965808f, 
    0.61371917f, -0.27220225f, 0.06873205f, -0.04698320f, 0.25767902f, -0.33972874f, 0.01033365f, 0.41179594f, 
    0.16380081f, 0.06669103f, -0.18116762f, -0.00029224f, -0.20588891f, 0.01725545f, 0.00011313f, 0.26084083f, 
    0.01416116f, 0.45764497f, 0.70308876f, 0.22953665f, -0.53421885f, 0.01893920f, 0.68072844f, -0.51598597f, 
    -0.41943944f, 0.48710638f, 0.55833918f, -0.06011207f, -0.61777735f, -0.34789106f, 0.32254404f, -0.25834250f, 
    -0.44434389f, -0.46724397f, -0.03176583f, 0.04895393f, -0.35870177f, -0.36343810f, 0.28394806f, -0.08945780f, 
    -0.04264105f, 0.00679871f, -0.25942206f, -0.58772784f, -1.29995906f, -0.69765162f, 0.07932758f, 0.09985667f, 
    0.13239740f, 0.57251990f, 0.14091466f, -0.24299258f, 0.28169104f, 0.12831168f, 0.14520107f, 0.11652189f, 
    0.13436484f, -0.07060348f, -0.00410329f, -0.04810873f, -0.46621659f, 0.10313620f, 0.12894264f, -0.06005995f, 
    -0.13335034f, 0.02386433f, -0.13229120f, -0.00766344f, 0.29457667f, 0.58395946f, -0.75709289f, 0.85256302f, 
    -0.88067842f, 0.08267497f, 0.22202040f, -0.45303100f, -0.44946846f, -0.09026144f, 0.38064533f, 0.29267305f, 
    0.24221420f, 0.28776631f, 0.01174715f, -0.10613997f, -0.46738100f, 0.18323228f, 0.00127705f, -0.17722790f, 
    0.00458898f, 0.04373028f, 0.04844858f, 0.22058699f, 0.09254035f, 0.67394495f, 0.24555355f, 0.74001360f, 
    0.60763335f, 0.47164479f, 0.72064811f, -0.27933115f, 0.52613091f, 0.05765381f, -0.32647234f, -0.16058470f, 
    -0.26877558f, -0.28391534f, 0.20029217f, 0.31030902f, 0.20534469f, -0.13369133f, 0.15473574f, -0.01776403f, 
    -0.11790217f, -0.01458734f, 0.22259086f, 0.31781045f, 0.18315461f, 0.46477327f, 0.59273493f, 0.42961237f, 
    -0.60610890f, -0.30099338f, -0.20410155f, 0.27157193f, 0.04806289f, 0.67706037f, 0.67201006f, 0.55926353f, 
    0.34854323f, 0.14450043f, -0.50593567f, -0.57826167f, 0.11114804f, -0.10194442f, -0.32958820f, -0.23179859f, 
    0.11549571f, -0.26568756f, -0.22145446f, 0.01217867f, -0.00311223f, 0.17059456f, -0.05504277f, -0.94390357f, 
    0.49145955f, -0.06735182f, -0.24089788f, 0.26163036f, -0.23959756f, 0.30283049f, 0.24583863f, -0.60544634f, 
    -0.60753578f, -0.59596431f, 0.05734492f, 0.46977127f, 0.39637789f, 0.21342644f, -0.38561314f, -0.22446580f, 
    -0.21935153f, 0.11764403f, -0.00211979f, 0.18732341f, 0.08698292f, 0.08607847f, 0.18876784f, 0.05956881f, 
    0.81172854f, 0.64932513f, 0.69053930f, 0.61273676f, 0.50707030f, -0.53074086f, 0.38929632f, 0.03299787f, 
    -0.05447835f, 0.11053932f, 0.04362174f, 0.15977335f, 0.25330037f, -0.02169838f, -0.11793641f, -0.34108838f, 
    0.40747049f, 0.08708020f, -0.29767126f, 0.00457756f, -0.28153589f, 0.42729628f, -0.02848947f, 0.21652235f, 
    0.06834496f, 1.07734168f, 0.45141608f, -0.10434810f, 0.77431357f, 0.50150245f, -0.20728850f, -0.25974658f, 
    0.32625774f, -0.49249017f, 0.04248167f, -0.49126813f, -0.25429916f, 0.21103889f, -0.15624033f, 0.36171663f, 
    0.10286238f, -0.12377749f, 0.10366260f, 0.12971136f, 0.39177963f, 0.13810854f, -0.07446347f, -0.14399073f, 
    -0.21064362f, -0.04199263f, 0.14379817f, -0.20764512f, 0.35415569f, -0.56037915f, -0.80005598f, -0.21885675f, 
    0.49498668f, 0.05598167f, -0.35138404f, -0.58628780f, 0.03975276f, 0.18201436f, -0.37825146f, -0.33182010f, 
    -0.42421523f, 0.00670929f, -0.18120340f, 0.24500932f, 0.36184347f, 0.00557089f, -0.08142174f, 0.11772097f, 
    0.27327099f, -0.03332916f, -0.25876895f, -0.65700847f, -0.73794866f, -0.53406113f, -0.16868542f, 0.19622067f, 
    -0.42519829f, -0.13955167f, -0.16221486f, 0.12543815f, -0.35363385f, 0.43596676f, 0.31941754f, -0.14639926f, 
    0.36642852f, -0.18657948f, 0.41985872f, 0.08240495f, -0.03627571f, 0.25771040f, -0.02864038f, 0.14658332f, 
    0.21970659f, -0.06571397f, -0.34217396f, 0.32065657f, 0.20914268f, -0.26749146f, 0.15911327f, 0.47524974f, 
    0.42381036f, -0.06564555f, 0.13854343f, -0.16300224f, 0.00612344f, 0.56810904f, -0.06409055f, 0.19415542f, 
    0.26312682f, 0.15394725f, -0.39650795f, -0.48791096f, -0.28338647f, 0.18253131f, 0.09691968f, -0.07514410f, 
    0.24694343f, 0.38911575f, 0.21244723f, 0.11798650f, -0.26847640f, -0.28277048f, 0.30514723f, -0.15344010f, 
    -0.82552797f, -0.38055226f, 0.66152322f, -0.12158921f, -0.42320630f, -0.41149786f, -0.61932707f, 0.21617021f, 
    0.14356187f, -0.17809375f, 0.38708577f, 0.07165819f, 0.12301318f, 0.06395556f, -0.10882741f, -0.22128938f, 
    0.13364913f, 0.22920325f, -0.31490183f, 0.03168109f, -0.22576435f, -0.23429854f, 0.05233118f, -0.66605586f, 
    -0.79728317f, -0.00602408f, 0.30332962f, -0.64323962f, -0.11383609f, 0.62559861f, 0.30638155f, -0.28329077f, 
    0.04900573f, -0.01258515f, 0.06716181f, 0.17679486f, -0.20903699f, 0.07086959f, 0.00427934f, 0.08535360f, 
    -0.44030365f, -0.30874094f, -0.10104158f, 0.06980680f, 0.13950169f, 0.26241109f, 0.32006341f, 0.53036636f, 
    0.77242434f, 0.70869476f, 0.17472172f, 0.61973381f, -0.08201877f, -0.65346980f, -0.60141689f, -0.12552227f, 
    -0.46694574f, 0.13746506f, 0.45028374f, 0.14806619f, 0.07629888f, 0.08477968f, 0.04062114f, -0.07568856f, 
    0.10815594f, -0.06916298f, 0.42841446f, -0.20114163f, -0.21959119f, 0.06055407f, 0.02967431f, 0.02927602f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10187189f, 0.10160004f, 0.10067198f, 0.09788332f, 0.09083766f, 0.33249256f, -0.00050858f, 0.14881337f, 
    0.12989727f, 0.11711384f, 0.18317942f, 0.28700119f, 0.12918477f, -0.13515373f, 0.14849587f, 0.12428043f, 
    0.23806804f, 0.30230415f, 0.15661709f, 0.03427003f, 0.10820965f, 0.24963404f, 0.14489032f, 0.03623050f, 
    0.07615629f, 0.29908288f, 0.25672606f, 0.29504710f, 0.22314559f, 0.21060289f, 0.14659201f, 0.16682522f, 
    0.20968285f, 0.07933132f, 0.28025201f, 0.15924272f, 0.15437561f, 0.12160175f, 0.16979890f, 0.03248267f, 
    0.22548166f, -0.02710060f, 0.16881447f, 0.12988393f, 0.22433804f, 0.14382811f, 0.02219079f, 0.13167407f, 
    0.11916122f, 0.01051085f, -0.01103385f, 0.28649309f, 0.20382012f, 0.06473059f, -0.01692864f, 0.19158380f, 
    0.25719598f, 0.12014621f, -0.00443307f, 0.25751236f, 0.31342116f, 0.24044718f, 0.04293959f, 0.07450740f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.18244064f, 0.10039294f, -0.09431280f, 0.05335709f, -0.05236594f, -0.05371284f, -0.01184940f, 0.00324797f, 
    -0.01852722f, -0.09562510f, -0.01333285f, 0.08760809f, 0.07518287f, -0.30361432f, 0.10422227f, -0.09855892f, 
    -0.08095945f, 0.05852904f, -0.02559302f, -0.09662908f, 0.02004058f, -0.00137323f, 0.10304869f, -0.07383054f, 
    0.14953810f, 0.06255445f, 0.02312796f, 0.04890734f, -0.08569922f, -0.02063753f, -0.05112001f, 0.04968366f, 
    -0.03470354f, 0.11344919f, 0.04208382f, -0.05483370f, -0.30345440f, -0.22463967f, 0.08518385f, -0.18732294f, 
    -0.02112918f, 0.00294599f, 0.07850038f, -0.02287274f, 0.02281178f, -0.11252309f, -0.04546807f, -0.00709521f, 
    0.28792387f, 0.29559734f, 0.00948443f, -0.34701651f, 0.07330622f, 0.11103120f, -0.03446395f, 0.05020807f, 
    0.00116738f, -0.00966593f, -0.03591432f, 0.04601575f, -0.14866376f, -0.06974149f, -0.22490144f, 0.10241576f, 
    0.08003069f, 0.00682805f, -0.02638057f, 0.04973944f, -0.01179670f, -0.11635482f, -0.05647944f, 0.02426305f, 
    0.25342423f, -0.12786101f, -0.05042367f, 0.23437040f, -0.27971807f, 0.08171805f, -0.02451717f, 0.06918571f, 
    0.15123555f, 0.09426510f, -0.02274993f, -0.13604294f, -0.24492486f, 0.01969032f, 0.10120852f, -0.20103475f, 
    -0.12698650f, -0.02065148f, 0.08194338f, 0.09254495f, -0.02021926f, -0.04201030f, -0.08553782f, 0.03877438f, 
    0.05788439f, 0.05792608f, -0.01202469f, 0.04965667f, -0.17008245f, -0.10949778f, 0.01366774f, 0.03515619f, 
    0.01201055f, 0.11141983f, -0.06983024f, 0.02940602f, 0.02378202f, 0.14046040f, 0.08188907f, 0.32000318f, 
    -0.14602944f, 0.05316139f, -0.00139156f, 0.09480071f, -0.03030310f, 0.04772991f, 0.03345760f, -0.07141387f, 
    -0.15632676f, -0.27558625f, 0.19750290f, -0.13451095f, 0.02433159f, 0.12167162f, 0.05390672f, 0.10256031f, 
    -0.00765384f, 0.00238942f, -0.00279921f, 0.03877990f, 0.02104261f, -0.12613420f, 0.11142334f, 0.02886272f, 
    -0.01506474f, -0.03740764f, -0.08169892f, -0.01450284f, -0.13319868f, -0.00086943f, 0.01654053f, -0.18373896f, 
    0.05274060f, -0.09044684f, -0.11673171f, -0.01264819f, -0.17204410f, -0.06331416f, 0.03045956f, -0.02322128f, 
    -0.03799889f, 0.13532291f, -0.05301835f, 0.02643730f, 0.39899957f, -0.02021729f, 0.02980817f, -0.11871010f, 
    0.02677949f, 0.07161890f, 0.11629160f, 0.09465452f, -0.11777185f, -0.00489230f, 0.05723758f, -0.00398018f, 
    0.04463587f, -0.30080402f, 0.11307674f, -0.08552851f, -0.00135362f, -0.06636428f, -0.08949016f, -0.12618156f, 
    0.06318443f, 0.05925961f, 0.16482866f, -0.04290853f, 0.04516048f, -0.16381566f, 0.05428903f, -0.19985704f, 
    0.07835954f, 0.01163340f, 0.13341160f, -0.01930515f, 0.06302850f, -0.06605172f, 0.04136112f, -0.01259898f, 
    0.06349497f, -0.05400110f, -0.08626800f, 0.06323209f, -0.13030525f, -0.04060830f, -0.08524892f, -0.06992301f, 
    -0.03419745f, 0.02122819f, -0.09593009f, 0.07299181f, 0.01477042f, 0.02140255f, -0.08970271f, 0.03640244f, 
    -0.16812718f, 0.00619901f, 0.02809143f, -0.02903784f, -0.03740090f, 0.04609600f, -0.06170221f, -0.13372545f, 
    -0.19273184f, 0.12424038f, 0.02489961f, 0.07752172f, -0.21419355f, -0.07724994f, 0.02235372f, 0.00069775f, 
    -0.07930959f, 0.11318951f, -0.06684177f, -0.06814522f, 0.33896175f, -0.04565729f, -0.01377483f, -0.21776983f, 
    -0.07542892f, 0.01533916f, -0.07405745f, -0.10563325f, -0.22604413f, 0.04710410f, -0.09665097f, 0.17993261f, 
    0.19835334f, -0.00897245f, 0.05902058f, -0.13662924f, 0.05803298f, 0.02916539f, 0.05666607f, 0.04301428f, 
    -0.02386905f, 0.01438813f, 0.03258237f, -0.03073098f, -0.18217227f, 0.18033372f, 0.06138822f, -0.03309275f, 
    0.07162106f, -0.01716148f, 0.04479328f, 0.08815682f, -0.02252890f, -0.01218084f, -0.07702598f, 0.06017134f, 
    -0.03391494f, -0.09021565f, -0.14502652f, 0.04777239f, 0.00460918f, -0.08607247f, -0.00087570f, 0.07632203f, 
    0.13275515f, 0.01801715f, 0.03358597f, -0.12020745f, 0.33650905f, -0.02652541f, 0.10076407f, -0.35416961f, 
    0.03474475f, 0.01831895f, 0.14285716f, 0.02960846f, 0.07345586f, -0.01657222f, -0.01033273f, 0.08125638f, 
    0.15852514f, -0.06205554f, -0.06050322f, -0.10689920f, -0.07452988f, 0.00183099f, -0.03820813f, 0.00166947f, 
    0.09170008f, 0.04992333f, -0.02842241f, -0.02147969f, -0.08870032f, -0.20023343f, -0.16395424f, 0.03478142f, 
    -0.05467502f, -0.07771312f, -0.03073891f, -0.09719729f, -0.00132678f, 0.00990481f, -0.04472441f, -0.05392168f, 
    -0.16701144f, -0.02934019f, 0.04063651f, 0.03420551f, -0.08927990f, -0.02070730f, -0.02230758f, -0.01215163f, 
    0.01580790f, 0.00677330f, -0.17301275f, 0.09051274f, 0.11901735f, -0.14034729f, -0.23482987f, 0.21995232f, 
    -0.14613266f, -0.05941427f, 0.05003591f, -0.13827446f, -0.01071238f, 0.00545593f, -0.06751370f, 0.05176741f, 
    -0.05592863f, 0.08927600f, -0.07277367f, 0.17189610f, 0.11085731f, -0.05084193f, 0.01183489f, -0.06948454f, 
    -0.06066015f, 0.02046739f, -0.02388402f, -0.09072214f, -0.23505495f, 0.01023958f, 0.16043481f, 0.01385801f, 
    -0.05052648f, 0.13162780f, -0.14060540f, 0.02501868f, 0.06253449f, 0.04593407f, -0.17024982f, -0.04056395f, 
    -0.12662335f, -0.09798012f, 0.04557954f, -0.00706610f, -0.05819912f, 0.00016528f, 0.05423319f, 0.08736466f, 
    -0.06377545f, 0.01149588f, -0.12003685f, -0.05616537f, 0.04597123f, 0.06102880f, -0.02831534f, 0.30262581f, 
    -0.15744250f, 0.01842766f, -0.07428567f, -0.11270458f, -0.03281809f, -0.03622245f, -0.03581513f, 0.03501868f, 
    -0.30387998f, 0.12359070f, 0.06774418f, 0.14527592f, 0.03815461f, -0.07995197f, 0.01413339f, -0.04549634f, 
    -0.06974173f, 0.01680680f, -0.02316091f, 0.08288224f, -0.16728698f, 0.05409838f, -0.00604701f, -0.22247280f, 
    -0.16709490f, -0.10601912f, 0.06951312f, 0.06329304f, 0.03775322f, -0.10009032f, -0.03109071f, 0.05150554f, 
    0.12340425f, -0.22356860f, 0.08187966f, 0.01509409f, 0.05321367f, 0.00029758f, 0.01907470f, -0.06253637f, 
    -0.12613915f, 0.02687132f, 0.05420849f, 0.01827699f, 0.31550634f, -0.11516397f, -0.08035383f, 0.03384414f, 
    0.11496143f, 0.03806553f, 0.06649046f, -0.03704496f, -0.05875742f, -0.02800431f, 0.04012760f, 0.00688497f, 
    0.00318097f, -0.14089568f, 0.00575921f, -0.23586774f, 0.00160537f, -0.06782127f, 0.04533177f, 0.01074313f, 
    -0.00046629f, -0.04323532f, -0.05449985f, -0.00627630f, 0.03701678f, 0.09123228f, -0.08044779f, -0.27261859f, 
    0.01078837f, 0.02886241f, 0.06877147f, -0.02442801f, -0.04980781f, 0.06773891f, 0.07272190f, -0.06260940f, 
    -0.02368816f, 0.03644582f, 0.16292557f, 0.01377846f, -0.05681271f, 0.00150328f, -0.00223493f, 0.00250349f, 
    -0.03423291f, 0.07731639f, 0.05869790f, 0.00506765f, 0.10936345f, -0.02802720f, -0.05838013f, -0.04656811f, 
    0.08865310f, -0.03228806f, -0.04657249f, 0.00411100f, -0.01159451f, 0.03401731f, -0.02851034f, 0.09141765f, 
    0.10922384f, 0.12593088f, 0.05443714f, -0.36464560f, -0.13821667f, 0.05231917f, -0.03699035f, 0.07669248f, 
    -0.01576563f, -0.10278335f, -0.02607013f, -0.17361884f, 0.11533136f, 0.17589779f, -0.08310008f, -0.31973505f, 
    0.11928277f, -0.01088863f, 0.09084163f, -0.03894950f, 0.01504879f, 0.03142498f, 0.03725841f, 0.10369989f, 
    0.21685293f, -0.14819688f, 0.00007622f, -0.08823518f, -0.04530647f, 0.03191943f, -0.11778978f, -0.05894017f, 
    0.07973156f, 0.05114206f, 0.01907436f, 0.17124264f, -0.03436283f, 0.07826410f, -0.04880702f, 0.12557688f, 
    0.00114463f, -0.13152282f, -0.04953186f, 0.03653724f, -0.00963063f, 0.04262743f, 0.10479020f, -0.06195302f, 
    -0.34188133f, 0.02841292f, -0.00877396f, 0.00391967f, -0.04381307f, 0.02402576f, -0.02601833f, -0.13339533f, 
    -0.13420583f, -0.08127993f, 0.01818558f, -0.01689732f, -0.21862715f, 0.11015928f, -0.04363597f, 0.40356305f, 
    -0.07593831f, -0.00891386f, 0.07984678f, -0.07643098f, -0.03543085f, 0.02509379f, 0.04605202f, -0.01613202f, 
    -0.29985324f, -0.17659481f, 0.16044146f, 0.17914310f, 0.04489581f, 0.02396501f, -0.02089746f, -0.03279526f, 
    -0.05940660f, -0.05579155f, 0.05526969f, -0.03977808f, 0.22518390f, -0.01122958f, -0.10440076f, 0.05116646f, 
    0.06946105f, -0.09092041f, 0.01498590f, -0.00727485f, -0.03832174f, -0.12169024f, -0.18263142f, 0.08610930f, 
    0.17568155f, -0.11056986f, -0.05610934f, 0.31637785f, -0.05874376f, 0.13126002f, -0.04276596f, 0.10250672f, 
    -0.08447613f, 0.02565229f, -0.01281653f, -0.11625980f, -0.17340301f, -0.02970197f, 0.13715029f, -0.17103042f, 
    0.06765088f, 0.11760557f, -0.02743629f, 0.04223301f, 0.21922548f, 0.00312326f, 0.00283918f, 0.04593776f, 
    0.04719800f, 0.18299235f, 0.12448782f, 0.00119927f, 0.02548685f, 0.17139834f, 0.00720423f, -0.00972368f, 
    0.06109651f, 0.14784770f, 0.03035839f, 0.10064691f, -0.19691759f, 0.06623281f, -0.08356612f, -0.16514762f, 
    0.00454450f, 0.01516568f, -0.02924170f, -0.04131406f, 0.01885805f, 0.05102971f, 0.02871196f, -0.11356431f, 
    -0.00236983f, 0.22649702f, -0.09283250f, -0.03302069f, -0.22907358f, -0.01203293f, -0.02762080f, -0.03932923f, 
    0.00751658f, 0.00353454f, -0.11306822f, 0.05530782f, 0.18536256f, -0.17481351f, -0.00843591f, 0.15095726f, 
    -0.11540664f, -0.01020587f, -0.05874735f, 0.00814839f, -0.08493744f, -0.05182143f, -0.04971668f, -0.09662463f, 
    0.08518156f, 0.00910844f, 0.01005289f, -0.23529024f, 0.11608388f, -0.04992016f, 0.13241023f, -0.03196994f, 
    0.02339160f, 0.06111469f, 0.01276756f, -0.02971126f, -0.35709932f, 0.12286055f, 0.04942188f, 0.04055561f, 
    0.00672610f, -0.02629635f, -0.01636632f, -0.01853659f, 0.14425644f, -0.07354365f, 0.02749567f, 0.01296827f, 
    0.11866052f, 0.11583793f, -0.10115474f, 0.07117780f, -0.13228048f, -0.15355147f, -0.00677880f, 0.00274588f, 
    -0.03215860f, -0.05941426f, -0.07702756f, -0.07607529f, 0.25683087f, 0.09541612f, -0.06470460f, 0.08253621f, 
    -0.09315447f, 0.04120119f, -0.02634602f, 0.06283169f, 0.00435800f, -0.00252332f, -0.00765575f, 0.00215484f, 
    -0.37040588f, 0.14966825f, 0.21118887f, 0.03429790f, -0.05910167f, 0.09639648f, -0.01362614f, 0.04441266f, 
    0.06940914f, 0.09653590f, 0.12307327f, -0.13365349f, -0.30669454f, -0.06243303f, -0.12553176f, 0.08960801f, 
    -0.04234655f, -0.06773444f, 0.06901095f, 0.07343777f, -0.00388491f, -0.00517731f, -0.13164815f, -0.06298487f, 
    0.06699149f, -0.06981856f, -0.08414660f, 0.11574366f, -0.04485866f, -0.02831270f, -0.07117323f, -0.01752027f, 
    -0.08412736f, 0.06291752f, -0.03607285f, -0.02261217f, -0.26278740f, 0.06731283f, 0.03947553f, -0.20253924f, 
    -0.11048017f, 0.10860461f, 0.03582538f, -0.00645370f, 0.03338070f, -0.02933807f, 0.06642984f, 0.05552166f, 
    -0.08904802f, 0.29112312f, -0.06027912f, 0.08704116f, 0.01641525f, 0.01057119f, -0.01934014f, -0.07874367f, 
    -0.05371322f, 0.13037367f, 0.00803552f, -0.06817642f, 0.07465894f, 0.07377572f, 0.19405466f, -0.21671546f, 
    -0.17512394f, -0.07479841f, 0.03873824f, 0.09824095f, 0.08141510f, -0.06533579f, -0.07228816f, 0.03189556f, 
    -0.05004150f, -0.11400174f, -0.17970711f, -0.22040647f, 0.08786231f, 0.02704141f, -0.09374586f, 0.01363943f, 
    0.00438908f, -0.15484160f, -0.01181506f, 0.03141681f, -0.19717717f, 0.04401647f, -0.03725227f, -0.06226208f, 
    0.13387796f, 0.01971740f, 0.12824586f, -0.04194530f, 0.07600982f, 0.04684619f, -0.05871607f, -0.05144523f, 
    0.17006156f, -0.05324173f, 0.09552284f, 0.19748800f, -0.06089094f, -0.04335992f, 0.00762779f, -0.03622598f, 
    0.03183427f, -0.24212256f, -0.16540533f, 0.02695925f, -0.04034768f, -0.00600867f, 0.06749628f, -0.08804855f, 
    0.09458803f, -0.01320907f, -0.06141257f, 0.02448646f, 0.01767270f, 0.10184136f, 0.14473598f, -0.02358171f, 
    0.09956559f, -0.08660258f, -0.10039622f, -0.10157435f, 0.17935385f, -0.10497637f, -0.10805172f, 0.00187395f, 
    0.11556618f, -0.00218938f, 0.02043967f, -0.00199892f, -0.07174297f, -0.02736324f, -0.25853235f, 0.22765677f, 
    -0.05220946f, 0.04282744f, -0.02538648f, 0.08424173f, 0.00762931f, -0.04593931f, 0.06899091f, 0.18064091f, 
    0.09689872f, -0.14821029f, 0.10977745f, 0.04137926f, 0.09008212f, -0.16251194f, 0.04749082f, -0.08168406f, 
    -0.07816950f, -0.10323840f, 0.06009358f, 0.10817241f, 0.26304984f, -0.44944543f, 0.02919443f, -0.31153864f, 
    -0.11207638f, -0.10774200f, 0.00633411f, 0.02428655f, -0.10966510f, 0.05413060f, 0.06681813f, -0.02096166f, 
    0.19843777f, -0.19696948f, 0.02934479f, 0.21002920f, -0.06325220f, -0.00794164f, -0.01601249f, 0.00813593f, 
    -0.10463275f, -0.00385445f, 0.05195474f, -0.08627892f, 0.20130713f, -0.25108966f, 0.06386834f, 0.20641631f, 
    0.03331001f, 0.12495987f, -0.10080542f, -0.00081434f, 0.01276145f, 0.19645324f, -0.11750465f, -0.06576681f, 
    0.23713297f, 0.02565088f, 0.07675440f, -0.04457648f, -0.02322659f, -0.04767929f, 0.03119406f, 0.05090253f, 
    0.03702687f, -0.00508812f, 0.04433117f, 0.06190364f, 0.06501665f, -0.21911313f, -0.03555222f, -0.36951759f, 
    0.07086659f, 0.03554071f, 0.09007680f, -0.01716127f, 0.08355554f, -0.06031137f, -0.17805418f, 0.08876384f, 
    0.15556854f, 0.05984155f, 0.15447561f, 0.10077525f, 0.01768260f, 0.04043279f, -0.13477242f, -0.02602712f, 
    -0.10720281f, -0.13663942f, -0.00846165f, -0.09349696f, -0.52602702f, -0.07162391f, 0.02822375f, -0.05545400f, 
    -0.03993149f, -0.09027509f, -0.06076652f, -0.10383233f, 0.07196030f, 0.07461336f, -0.19633083f, -0.21911363f, 
    -0.15891668f, 0.08571558f, 0.12660716f, -0.00403778f, -0.09742537f, 0.10037553f, 0.06406921f, 0.10729212f, 
    0.05973916f, 0.00572793f, -0.29455784f, 0.08671135f, 0.22502445f, -0.22669622f, 0.11991421f, -0.17174973f, 
    0.13587449f, -0.08763298f, -0.05128333f, 0.04294029f, -0.17718923f, -0.05284505f, 0.06761400f, -0.00738170f, 
    -0.13796383f, 0.12809037f, -0.05493898f, -0.00685968f, -0.04392478f, -0.10179256f, 0.10852507f, 0.06209333f, 
    0.02285912f, -0.01630687f, 0.06473299f, -0.04144478f, 0.14290093f, 0.10470933f, 0.09649450f, 0.19626386f, 
    -0.04489809f, -0.04615467f, 0.04697337f, -0.01010456f, 0.10174495f, 0.02340359f, 0.05123555f, 0.14299437f, 
    0.05630080f, 0.05113695f, 0.13115941f, -0.09702421f, -0.03791368f, 0.05945053f, 0.00583552f, -0.02075290f, 
    -0.03153540f, -0.11482748f, 0.16191447f, -0.11726695f, 0.14847781f, -0.13638961f, 0.03465744f, -0.10781256f, 
    0.10486881f, -0.02060501f, -0.01909734f, 0.05369874f, 0.03585461f, 0.07242892f, 0.06938405f, -0.14012249f, 
    -0.38853008f, -0.01751094f, -0.07010412f, -0.02115808f, -0.06471070f, -0.06662558f, 0.07145737f, -0.02371579f, 
    0.01030429f, 0.09333116f, -0.02871872f, 0.08317108f, -0.06545752f, -0.16699061f, -0.17361696f, 0.01525566f, 
    -0.14208791f, 0.10190892f, -0.08631014f, -0.04396881f, 0.07176580f, 0.03900900f, 0.09405968f, -0.00754216f, 
    -0.18142290f, -0.10124777f, -0.23580022f, 0.01890327f, 0.04286128f, 0.05354381f, 0.00107385f, 0.05933793f, 
    0.05194385f, -0.07044180f, 0.07524262f, 0.14639626f, -0.18442583f, -0.13807398f, -0.14489843f, -0.25098306f, 
    -0.17554282f, -0.08893184f, -0.02194995f, -0.01103028f, 0.04025147f, 0.01922566f, -0.05222610f, 0.07470446f, 
    0.15917237f, -0.09342955f, 0.08810576f, 0.18620393f, -0.12461183f, -0.10516443f, 0.01739451f, -0.03301975f, 
    -0.04283713f, 0.10018586f, -0.02553243f, 0.14673087f, 0.03745030f, 0.01215906f, -0.01039452f, -0.24473971f, 
    -0.02891323f, 0.00757327f, -0.02909643f, 0.03345264f, 0.02958926f, -0.25970051f, -0.05620877f, -0.06078231f, 
    0.09679163f, 0.23041426f, -0.03110520f, 0.10773923f, 0.10404573f, 0.15145802f, -0.03502250f, 0.08913018f, 
    0.02048548f, 0.10166356f, 0.06908461f, -0.01987384f, -0.31041977f, -0.20095053f, -0.09187104f, 0.14684372f, 
    0.09167746f, 0.04905856f, -0.16304460f, 0.15434162f, 0.06458238f, 0.08005227f, 0.03907138f, -0.10321113f, 
    -0.32870951f, 0.03770780f, -0.17541651f, -0.13007969f, -0.09709407f, 0.02794422f, -0.03883409f, -0.02892910f, 
    0.09945243f, 0.02307473f, 0.04710913f, 0.05370368f, 0.05565498f, 0.00401142f, -0.34882537f, 0.07472364f, 
    -0.09469502f, 0.02860888f, 0.09663611f, -0.12249175f, -0.01855470f, 0.07288091f, -0.16222897f, 0.02347149f, 
    0.03224408f, 0.02120853f, -0.08121781f, 0.10964669f, 0.09553912f, 0.02308414f, -0.03597758f, -0.04405129f, 
    0.07772570f, -0.00149025f, -0.08461953f, -0.16724569f, 0.11748628f, -0.42763549f, 0.06286130f, 0.12813739f, 
    -0.18899727f, 0.00781819f, 0.02535550f, 0.07943782f, -0.04713355f, 0.05195253f, -0.02084368f, 0.01987641f, 
    0.13323833f, 0.01547203f, -0.09533994f, 0.04623157f, -0.03120088f, 0.01771080f, 0.00757174f, 0.01140818f, 
    -0.01603491f, -0.10845989f, 0.00974188f, -0.15440944f, 0.11070969f, 0.19272038f, 0.02220442f, -0.09691961f, 
    -0.08320930f, 0.10140647f, 0.07388324f, -0.08712361f, 0.12750015f, 0.00281279f, 0.00934566f, 0.02583364f, 
    -0.20672691f, -0.00828484f, 0.07046092f, -0.07094388f, -0.02924038f, -0.06745595f, 0.00055137f, 0.01866451f, 
    -0.01379357f, 0.05830819f, -0.04428588f, 0.04017467f, 0.34384862f, -0.21892178f, 0.02912350f, -0.14587510f, 
    0.00824753f, 0.02980275f, -0.08954196f, -0.01174703f, 0.02185059f, -0.02428392f, 0.11836910f, 0.02186395f, 
    0.06670521f, 0.07576043f, 0.02636639f, 0.02473977f, 0.02597195f, 0.18719807f, 0.10335363f, 0.11189496f, 
    -0.00107998f, -0.02524664f, 0.05031544f, 0.02355167f, -0.09686725f, -0.07196906f, 0.08720955f, -0.16021660f, 
    0.00545599f, -0.04814746f, -0.04081579f, 0.05232339f, 0.14242043f, 0.03222662f, -0.02048978f, 0.01889698f, 
    0.30869257f, -0.08722464f, -0.08177455f, -0.08007069f, 0.00078536f, 0.00848344f, 0.00146045f, 0.02048473f, 
    0.16743571f, -0.05257104f, -0.03813660f, 0.02007006f, -0.20329240f, 0.12113156f, 0.03343685f, -0.00208524f, 
    -0.18737534f, -0.00606502f, 0.03060189f, -0.02180381f, -0.20132066f, -0.00745795f, -0.04151492f, -0.05003459f, 
    0.05379825f, 0.02399198f, -0.07047119f, -0.16152796f, 0.13095491f, -0.14571188f, 0.12006074f, 0.02207391f, 
    -0.13061325f, 0.10992587f, -0.07058897f, 0.15837003f, 0.14131878f, -0.25732687f, 0.03299497f, -0.13883005f, 
    0.14641996f, -0.05051280f, -0.04024478f, -0.01087002f, -0.01161091f, -0.06275276f, -0.01083204f, -0.02964203f, 
    -0.27866355f, 0.00938669f, -0.03968034f, -0.03357109f, -0.05531911f, -0.16164045f, 0.10104161f, -0.06119148f, 
    0.07058828f, 0.05510851f, -0.06068045f, -0.15148537f, 0.19565974f, 0.05458812f, -0.00053488f, -0.00749751f, 
    -0.05794763f, -0.15775988f, -0.08716455f, -0.03822865f, -0.10315016f, -0.14749092f, -0.02357485f, -0.00175673f, 
    -0.01151703f, 0.08393075f, -0.00633103f, -0.13861112f, -0.07946315f, 0.00398045f, 0.09822222f, 0.09274969f, 
    0.00803186f, -0.05404242f, -0.00895241f, 0.04021758f, -0.43248239f, -0.03408127f, -0.18996127f, -0.20894577f, 
    0.08562459f, -0.01326323f, -0.06363076f, -0.01391559f, -0.09771234f, -0.09052075f, 0.00785331f, 0.06704060f, 
    -0.15486756f, 0.36463711f, -0.18614359f, -0.00968978f, 0.02599500f, 0.10221633f, -0.02317447f, -0.17079276f, 
    -0.00462030f, 0.12312443f, -0.01350852f, -0.00951169f, -0.05440715f, 0.02903745f, 0.03207736f, 0.06047668f, 
    -0.08212055f, 0.11005329f, 0.04383890f, -0.03311130f, -0.04103087f, -0.01356034f, 0.12979425f, 0.01948826f, 
    0.01152138f, 0.03203437f, 0.21292092f, 0.05487673f, -0.07518134f, 0.05078107f, -0.02769553f, 0.00257593f, 
    0.10061555f, -0.07293409f, 0.02059192f, 0.05546017f, -0.02920390f, -0.05326421f, -0.17898256f, 0.01409165f, 
    -0.06454313f, 0.03220483f, 0.00174540f, 0.03588212f, -0.07446679f, 0.07969675f, -0.09953904f, -0.03072614f, 
    0.08280876f, -0.08392183f, -0.01596163f, 0.00018736f, -0.07545951f, -0.13200156f, 0.04081579f, 0.01834176f, 
    -0.00627177f, -0.12318595f, -0.28154725f, -0.04054718f, 0.37135521f, 0.02583857f, -0.03543605f, 0.04481642f, 
    -0.05732760f, -0.01550639f, 0.02935854f, -0.02498669f, -0.08700156f, 0.01681682f, -0.05948898f, 0.13974245f, 
    0.11679981f, -0.34983218f, -0.14213531f, 0.05020958f, -0.01876198f, 0.02175929f, 0.02501487f, 0.13375670f, 
    0.18842609f, 0.04140183f, -0.06236551f, 0.03554965f, 0.06938701f, 0.18213269f, 0.06963333f, 0.15538882f, 
    -0.13148972f, 0.03125666f, 0.04598197f, -0.02677137f, 0.00193361f, 0.08154514f, 0.04855810f, 0.09718029f, 
    0.24418864f, -0.14615852f, 0.17153502f, -0.06820498f, -0.07251434f, -0.06690890f, -0.12391455f, -0.01913888f, 
    0.07461069f, -0.10744938f, -0.11497996f, 0.14737977f, -0.04723962f, 0.04494986f, -0.13244894f, -0.19424680f, 
    0.03606422f, 0.05400164f, -0.06374017f, 0.00898877f, -0.08591346f, 0.01653673f, -0.03955480f, -0.17615518f, 
    0.23561303f, 0.10231786f, 0.08636677f, 0.22340912f, -0.09436314f, 0.03551449f, 0.09720550f, -0.04265549f, 
    0.06612742f, -0.01326191f, 0.08070087f, -0.03982544f, 0.12327957f, -0.08941840f, 0.04171421f, 0.22427288f, 
    -0.05322710f, -0.06343129f, -0.04842972f, 0.00892029f, 0.04001126f, 0.01084592f, -0.08525876f, 0.04524362f, 
    -0.01563608f, -0.24136829f, -0.38175234f, 0.01477783f, 0.13540618f, -0.13574526f, 0.02001498f, -0.07332394f, 
    -0.02153355f, -0.09926186f, -0.05453969f, 0.08089955f, 0.04207222f, 0.01456001f, -0.01713862f, -0.02130129f, 
    -0.06389947f, 0.13424696f, -0.01328786f, 0.15516695f, 0.01341379f, 0.11168285f, 0.00516972f, 0.12588532f, 
    -0.00173013f, 0.05163901f, -0.02277429f, 0.16460729f, -0.05056497f, 0.06688550f, 0.07899633f, 0.07321679f, 
    0.15289298f, -0.08538000f, 0.02200119f, -0.05999739f, -0.12153166f, -0.05345172f, 0.01618125f, -0.00160157f, 
    -0.06184260f, -0.04156153f, 0.05731606f, 0.01111571f, -0.06183090f, 0.10156117f, -0.13856374f, -0.04058255f, 
    -0.07392041f, -0.30578202f, -0.04646760f, 0.05822774f, 0.05695444f, 0.08007044f, -0.12394901f, 0.05968830f, 
    -0.01597248f, -0.18027388f, 0.02313075f, 0.06096914f, -0.00086874f, -0.08198652f, 0.00716338f, 0.16855985f, 
    -0.03680568f, 0.00391042f, 0.00547475f, -0.05306498f, 0.00511274f, 0.04256961f, 0.03245845f, -0.05612227f, 
    0.19273464f, -0.05082146f, -0.12749125f, 0.23077229f, 0.03203376f, -0.04686554f, 0.05674452f, -0.12737338f, 
    0.00718234f, 0.02833464f, 0.00734242f, 0.08337313f, -0.11848849f, -0.16636363f, 0.02903083f, -0.06833270f, 
    0.01594591f, -0.00433155f, 0.02220084f, -0.03553339f, -0.06574617f, 0.03805578f, -0.02892939f, -0.01329245f, 
    0.20876375f, 0.12253694f, 0.01632592f, -0.10152722f, 0.09455504f, -0.04056437f, 0.03983438f, 0.12134364f, 
    -0.10056467f, 0.06369250f, 0.07742398f, -0.05166781f, -0.14505765f, 0.17507866f, -0.06344612f, -0.18659419f, 
    -0.00894427f, -0.08391006f, 0.06489473f, -0.08057563f, 0.00699567f, 0.02898001f, -0.06627254f, -0.11544576f, 
    0.16319849f, 0.05790060f, 0.06582189f, 0.20613448f, -0.03143812f, -0.11349370f, 0.06490698f, 0.07094982f, 
    -0.01591154f, 0.07708295f, 0.00175347f, -0.00987246f, 0.32109419f, -0.19385819f, -0.10644887f, -0.05380464f, 
    -0.11015339f, 0.02545050f, -0.04290427f, -0.01724673f, -0.03598665f, -0.04021159f, -0.04648736f, -0.00974309f, 
    -0.03782430f, -0.02822749f, -0.06300658f, 0.04754682f, -0.05052645f, 0.06022263f, -0.06884240f, 0.02398387f, 
    -0.14058942f, -0.01841247f, -0.09682364f, -0.00621637f, -0.28926387f, -0.16464777f, -0.17098749f, -0.20651165f, 
    0.01462807f, -0.14686199f, 0.13127831f, -0.09388438f, -0.06956229f, 0.03479060f, -0.02614342f, 0.00779083f, 
    0.17086478f, -0.14249216f, -0.06804503f, 0.11482614f, 0.11382766f, 0.01042641f, 0.04217310f, -0.12737703f, 
    0.03699375f, -0.02819074f, -0.04903629f, 0.00572032f, 0.16997243f, -0.12836941f, -0.02966418f, -0.14565600f, 
    0.04564257f, -0.01682858f, -0.02174512f, 0.09032077f, 0.03665566f, 0.07104436f, 0.03094401f, 0.03109589f, 
    -0.12874889f, -0.12581584f, 0.07842888f, -0.22752360f, -0.08853406f, -0.05235593f, -0.07452980f, 0.04076426f, 
    -0.04570026f, -0.08820580f, -0.01676190f, -0.08822489f, -0.08779628f, 0.00982309f, -0.19155063f, -0.09148995f, 
    0.03738051f, 0.02646948f, -0.03904639f, -0.11589660f, -0.05171633f, 0.00386891f, 0.12310009f, -0.11800441f, 
    0.02453641f, -0.04679755f, 0.02372402f, -0.09912007f, 0.02584375f, 0.06445334f, 0.05864252f, -0.02174857f, 
    0.01174113f, -0.02105208f, 0.05152303f, -0.04269562f, 0.27957338f, 0.15261163f, -0.16398598f, 0.02470393f, 
    0.06475657f, 0.04560514f, -0.09975329f, 0.02127261f, -0.05541728f, 0.16793625f, 0.07763697f, 0.02367602f, 
    -0.01690920f, 0.05448470f, -0.03709979f, -0.00380871f, 0.01572311f, -0.03714328f, -0.07003795f, 0.08068267f, 
    -0.03204682f, -0.04787754f, -0.05288451f, -0.18830359f, -0.21847525f, -0.06519247f, -0.06174069f, -0.06571567f, 
    0.08317683f, 0.03135701f, 0.08729747f, 0.04478534f, -0.00206599f, 0.02942849f, -0.05475772f, 0.04561273f, 
    -0.27748492f, 0.09582188f, 0.19644515f, -0.10671315f, -0.02809095f, -0.01827111f, 0.06302784f, 0.01285416f, 
    -0.01384614f, -0.07325549f, 0.03033628f, 0.00303639f, 0.04826581f, 0.02855982f, -0.00844917f, 0.02404169f, 
    0.08135076f, -0.03366097f, 0.02992412f, -0.03994035f, 0.00863371f, 0.02683217f, -0.08945294f, -0.02744934f, 
    0.08660547f, -0.05688701f, -0.00279665f, -0.14122294f, -0.11683629f, 0.05219373f, 0.01276470f, 0.05481221f, 
    -0.05684158f, 0.08600447f, -0.13361710f, 0.02682624f, -0.40100229f, 0.19981977f, 0.05467404f, -0.13499211f, 
    -0.03092474f, -0.08724341f, 0.10615885f, -0.00275561f, -0.04378374f, -0.08602343f, -0.04461805f, 0.01047626f, 
    -0.10505914f, 0.11884950f, -0.00083317f, 0.09068324f, 0.02349661f, -0.08513664f, -0.15231811f, 0.10228408f, 
    -0.01930218f, -0.00397310f, -0.00607600f, -0.05182398f, -0.14575402f, 0.03826747f, -0.11680829f, -0.11830846f, 
    -0.04586675f, -0.01783699f, 0.02695204f, 0.05417132f, 0.00644817f, 0.08073077f, -0.10846828f, 0.06552440f, 
    0.06235815f, -0.16142842f, 0.09745526f, -0.01115794f, -0.01333266f, -0.01686542f, -0.10860585f, -0.01240034f, 
    -0.05350371f, -0.09772027f, 0.09789135f, 0.08845370f, 0.17501248f, 0.09896551f, 0.22162101f, 0.04040409f, 
    -0.02160752f, -0.03003319f, 0.05970061f, 0.05453363f, -0.08231463f, 0.00524849f, 0.05012556f, -0.06808172f, 
    0.08930981f, 0.01589111f, 0.04554251f, -0.17199390f, 0.07664200f, 0.06645089f, 0.03460708f, 0.00575368f, 
    0.11305688f, 0.03858820f, 0.06025131f, -0.04713047f, -0.20991324f, -0.13063370f, -0.15745167f, -0.01540084f, 
    -0.04977956f, -0.05142621f, -0.03159947f, -0.04389272f, 0.05188081f, 0.13645504f, -0.02632689f, 0.02370581f, 
    0.19588822f, -0.04452999f, -0.01755926f, 0.09291148f, 0.04929650f, -0.05358894f, 0.00559440f, -0.07797895f, 
    0.01094040f, 0.00233325f, -0.03338616f, 0.10962187f, 0.35759124f, -0.00239421f, -0.29944080f, -0.01138001f, 
    -0.07335457f, 0.02957390f, -0.02954535f, -0.03902290f, 0.00137980f, 0.05383735f, -0.08797172f, -0.15933594f, 
    0.22074910f, 0.07182200f, -0.29717714f, -0.20380092f, 0.05088503f, -0.02070896f, -0.03962732f, 0.01151163f, 
    -0.05545480f, -0.07139544f, -0.03162897f, -0.11139818f, 0.32828838f, -0.01032799f, -0.13948460f, 0.00432544f, 
    -0.11713362f, -0.00142422f, -0.04312798f, 0.01222686f, 0.03808827f, -0.04972897f, 0.08865800f, -0.01718459f, 
    0.13328692f, -0.11680822f, -0.18273133f, -0.05944358f, -0.04494043f, -0.07679362f, 0.03773584f, -0.00894469f, 
    -0.03297340f, -0.03593674f, -0.01782924f, 0.07067763f, 0.46594539f, -0.10853249f, 0.01038473f, -0.12150455f, 
    0.07695724f, 0.07495013f, 0.02496973f, 0.04962838f, -0.00387613f, -0.01979217f, 0.08476189f, -0.01378670f, 
    0.28839654f, -0.04913587f, -0.01058765f, 0.05879277f, -0.00993712f, -0.02235668f, 0.02123843f, 0.05369469f, 
    0.11774373f, 0.00460942f, 0.01504910f, -0.08371461f, 0.17829554f, -0.06215246f, -0.12488504f, -0.03026158f, 
    0.09769827f, 0.00546497f, 0.04510527f, -0.12801684f, -0.00382577f, 0.07978976f, -0.06901652f, -0.03255271f, 
    -0.02453298f, -0.02179775f, 0.01192966f, -0.18628345f, -0.00068143f, -0.00088555f, -0.09324493f, -0.02303881f, 
    -0.01155107f, -0.06329884f, 0.04502940f, -0.04772452f, -0.19321629f, 0.04324675f, 0.05151138f, 0.12281077f, 
    -0.01170249f, -0.00241798f, -0.04126021f, 0.03425489f, -0.08190151f, -0.02376801f, -0.07865018f, -0.03734591f, 
    -0.02855707f, -0.00457566f, 0.05642727f, -0.01504557f, -0.09584046f, -0.22088911f, 0.02278543f, 0.01422403f, 
    -0.05062352f, 0.03283232f, -0.02148991f, -0.01323011f, -0.06026281f, 0.05869598f, -0.04801307f, 0.19009049f, 
    0.01798947f, -0.03215398f, 0.01322311f, 0.01062323f, -0.00543862f, -0.00429105f, 0.00106977f, -0.02904209f, 
    -0.16918011f, -0.07216809f, 0.12936486f, -0.11006669f, -0.00135869f, -0.01713661f, 0.01053600f, -0.09789854f, 
    -0.05128321f, -0.12030275f, -0.03393220f, 0.06794356f, 0.23540023f, 0.10062119f, 0.00467138f, 0.07054512f, 
    0.01682115f, 0.05692019f, 0.00779516f, -0.00601216f, -0.01047253f, 0.03515626f, 0.01095387f, -0.07115777f, 
    -0.16520388f, 0.00198852f, -0.06562085f, -0.25459152f, 0.05731267f, -0.04791187f, 0.08471014f, -0.09209289f, 
    0.00246327f, -0.01908782f, 0.01025468f, -0.09195164f, 0.20161764f, 0.19141415f, 0.12916873f, 0.22242637f, 
    -0.07795924f, -0.16103229f, 0.09489931f, 0.11190101f, -0.05427333f, -0.01403665f, -0.03472821f, -0.00522327f, 
    0.10293221f, 0.08032342f, -0.01080019f, -0.07899162f, 0.01205345f, -0.06813165f, -0.08929947f, 0.00752565f, 
    -0.06758471f, -0.06027893f, -0.13625230f, -0.00541451f, 0.03947372f, 0.09032547f, -0.15317756f, 0.11956766f, 
    -0.05213379f, 0.07069814f, 0.08272638f, 0.11062758f, -0.12204145f, 0.02965306f, -0.01529576f, -0.08331032f, 
    -0.23249525f, -0.00169611f, 0.02951022f, -0.32433385f, -0.16484162f, 0.00006974f, 0.02297642f, -0.03224373f, 
    0.03630809f, -0.00480120f, -0.02187972f, 0.06534623f, 0.08798312f, 0.09544984f, -0.34995145f, -0.07602450f, 
    -0.07967807f, 0.06851634f, 0.10367844f, -0.03046142f, -0.08558204f, 0.01724136f, -0.00903473f, 0.00692180f, 
    0.07106243f, -0.04566034f, 0.08271444f, 0.05582185f, -0.20437084f, 0.04469747f, -0.10617568f, -0.11810485f, 
    0.02743211f, -0.11764620f, -0.04920604f, -0.08210047f, -0.11107276f, 0.09955092f, -0.15855928f, 0.02062837f, 
    0.02117104f, 0.05819675f, -0.03525114f, 0.01036459f, -0.11439381f, -0.06132772f, 0.07421177f, -0.05242503f, 
    -0.06226034f, 0.06860028f, -0.00259861f, -0.08292498f, 0.01434918f, 0.07422575f, -0.08701885f, 0.07565782f, 
    0.03094355f, 0.10932238f, 0.06807402f, -0.14234993f, 0.18223120f, 0.15818188f, 0.08065695f, 0.13653935f, 
    -0.10294267f, -0.07879785f, -0.08352995f, 0.09997828f, 0.05342921f, -0.04216852f, 0.03190191f, -0.11035773f, 
    -0.20278333f, 0.08580901f, -0.11874708f, -0.00412715f, 0.04876349f, 0.00322241f, 0.04485808f, 0.06845915f, 
    0.06393824f, 0.03821649f, -0.05127261f, -0.03600140f, 0.21529970f, -0.18829367f, 0.19765058f, 0.05752191f, 
    -0.16966827f, -0.04120651f, -0.06832846f, 0.03253768f, 0.03638480f, -0.05382755f, 0.05336192f, -0.07463904f, 
    0.01754895f, -0.00113785f, -0.04327109f, -0.10029722f, 0.09605348f, 0.00843484f, 0.05517175f, -0.01827027f, 
    -0.07261811f, 0.03827159f, -0.09386298f, -0.06376306f, -0.18051882f, 0.09961501f, -0.00901928f, -0.07796348f, 
    0.12866831f, -0.01315955f, -0.08789632f, -0.00600718f, 0.06939651f, -0.02127185f, 0.06431280f, -0.02577447f, 
    0.04821402f, 0.06589234f, 0.12087934f, 0.17288820f, -0.08621799f, -0.05881869f, 0.09777345f, 0.06473493f, 
    -0.00901087f, -0.03462822f, 0.17363459f, -0.14118625f, 0.02484247f, 0.06005167f, -0.23223126f, -0.16355874f, 
    -0.00235876f, 0.03701177f, 0.02587976f, 0.03517715f, -0.00257275f, 0.03887843f, 0.00929493f, 0.03657106f, 
    0.09391982f, 0.10868558f, -0.03449331f, 0.06195696f, 0.04271999f, 0.02815579f, 0.05255191f, -0.00074723f, 
    0.00352185f, 0.11266889f, -0.13194744f, -0.03716522f, 0.00023875f, 0.04325883f, 0.03737108f, -0.07020441f, 
    0.09505530f, -0.03105172f, -0.00103383f, -0.00057512f, -0.00113955f, -0.05435871f, 0.01154333f, 0.01665771f, 
    -0.23006636f, -0.06382702f, -0.03224726f, -0.18215424f, -0.14436758f, -0.04603287f, -0.01381001f, -0.12591407f, 
    -0.04215645f, 0.02808042f, 0.05287421f, -0.03654233f, 0.16491863f, -0.15380803f, -0.04470899f, -0.06574501f, 
    -0.11241979f, -0.08641724f, 0.03883513f, 0.00732584f, -0.06234493f, -0.03812032f, -0.02056114f, -0.01689780f, 
    -0.02870865f, 0.00252923f, -0.05182371f, 0.01658269f, -0.01881760f, 0.05571254f, -0.05041299f, -0.04942954f, 
    -0.10360879f, 0.04372599f, -0.01731054f, 0.03715889f, -0.00142699f, 0.06797718f, 0.01120970f, -0.18788205f, 
    -0.03855380f, -0.11028185f, 0.06315292f, 0.04815171f, 0.00615689f, -0.00658253f, -0.05023000f, -0.09063511f, 
    0.29572204f, -0.13049380f, -0.13899855f, 0.16470005f, -0.13524701f, -0.10650351f, 0.00146488f, -0.00805664f, 
    0.06988121f, 0.09373610f, 0.06339685f, -0.02077067f, 0.15213752f, -0.02026412f, -0.09459769f, 0.05312098f, 
    0.12821969f, 0.01024018f, 0.10583319f, -0.11452946f, -0.07434901f, -0.00152934f, 0.02594475f, -0.08847750f, 
    0.21445782f, -0.08138078f, -0.01214121f, -0.03110093f, 0.02771501f, -0.12672421f, 0.05607950f, -0.00789975f, 
    -0.13919352f, 0.02979570f, -0.05236429f, 0.07037507f, 0.14634158f, 0.01735826f, -0.01088229f, 0.14281067f, 
    -0.11800221f, 0.09126519f, -0.01294421f, 0.12078772f, 0.05763092f, -0.00938531f, 0.05390012f, -0.02457490f, 
    -0.13091326f, -0.27820718f, -0.14115235f, -0.22819698f, 0.01621335f, 0.02550142f, -0.09808091f, 0.02056934f, 
    -0.00171010f, 0.01502667f, -0.03060344f, 0.04331390f, -0.06274855f, 0.24105710f, 0.04717829f, -0.01484158f, 
    0.01814916f, 0.10117749f, 0.01881317f, -0.03398677f, 0.09434511f, -0.02109115f, -0.04947735f, 0.07387155f, 
    -0.30025944f, 0.07448362f, -0.16080883f, -0.10711832f, -0.09318268f, -0.02131994f, 0.00851414f, -0.00748252f, 
    -0.02326733f, -0.02825153f, -0.03978913f, 0.02683945f, 0.06920512f, -0.09831487f, 0.04261290f, -0.09895813f, 
    -0.03772216f, -0.02184686f, 0.06275017f, 0.01844619f, 0.01515207f, -0.03628575f, -0.02687695f, -0.01693406f, 
    -0.25513127f, -0.01929099f, 0.14535859f, 0.14252950f, 0.00676983f, 0.22246505f, 0.01361649f, 0.03582988f, 
    -0.03714919f, 0.06415645f, 0.00122441f, -0.06159206f, 0.16913565f, -0.07903485f, 0.01638637f, 0.03909355f, 
    -0.06416249f, 0.01739284f, -0.00999683f, 0.17369835f, -0.02341390f, 0.01534055f, -0.08144873f, -0.01599045f, 
    0.31144407f, -0.22846180f, -0.25770041f, 0.24674751f, -0.08111050f, 0.03088894f, 0.00279123f, -0.05249254f, 
    -0.05091416f, 0.06254204f, -0.03639143f, -0.05265314f, 0.02175091f, -0.22860011f, -0.01994440f, -0.12272565f, 
    -0.07201444f, -0.04804489f, 0.06162613f, -0.02001938f, 0.03196584f, 0.07028211f, 0.15717445f, -0.10173997f, 
    0.09040868f, 0.10672331f, -0.02420404f, 0.25276086f, -0.02154340f, 0.11118498f, -0.01979869f, -0.06149328f, 
    0.06887280f, 0.03353770f, -0.09674813f, 0.03043387f, 0.15990326f, 0.12479056f, -0.01171078f, 0.07382561f, 
    -0.09415346f, 0.09162959f, -0.10179242f, 0.01246748f, 0.05015736f, 0.10931321f, -0.02812769f, -0.11818679f, 
    -0.31760716f, -0.37336573f, -0.28877175f, 0.08863802f, -0.19003190f, -0.12091663f, -0.03482802f, -0.01999371f, 
    0.01596718f, 0.01797963f, -0.11520823f, -0.06197485f, -0.05793274f, 0.06997830f, 0.07569645f, -0.08197172f, 
    -0.01560334f, -0.00817037f, 0.09612766f, 0.12387586f, 0.00384586f, -0.00145003f, 0.03922958f, -0.01109678f, 
    0.13368039f, 0.03910921f, -0.08426763f, 0.06673081f, 0.00558682f, 0.01656594f, 0.05941720f, -0.17808810f, 
    0.04778406f, 0.12486145f, 0.00503865f, -0.00107080f, 0.04495781f, 0.05172838f, 0.03083117f, -0.07171569f, 
    -0.06728250f, -0.03866249f, 0.08163522f, -0.08892190f, 0.04654691f, 0.08741310f, -0.06892520f, 0.00977898f, 
    -0.20333907f, -0.27750176f, -0.24683830f, -0.07247216f, -0.11834218f, 0.10406329f, 0.04058514f, 0.05210758f, 
    0.01932002f, 0.01431776f, -0.02314544f, -0.02717488f, -0.28398204f, -0.32970187f, -0.13015394f, 0.13680464f, 
    -0.13406302f, -0.03197810f, 0.06079309f, -0.06746653f, 0.04222153f, -0.02616137f, 0.04690340f, -0.00993797f, 
    0.05853333f, -0.18255019f, 0.02371996f, 0.21103653f, 0.07694963f, -0.05628297f, -0.06957933f, 0.01587617f, 
    0.01974959f, 0.04034382f, -0.03895363f, 0.03268638f, -0.01847393f, -0.11652924f, 0.12559241f, -0.01175460f, 
    0.01590101f, 0.04251440f, 0.06702091f, 0.09547684f, 0.03995816f, 0.05961433f, -0.00083840f, -0.08080924f, 
    0.07421561f, -0.17362009f, 0.03208733f, -0.03162744f, 0.01787199f, 0.02210544f, -0.07228196f, -0.07207376f, 
    -0.12626980f, 0.06811473f, 0.05396783f, -0.03927883f, 0.10575815f, -0.05777213f, 0.04499280f, -0.00081954f, 
    0.14088014f, 0.03043604f, -0.02351232f, 0.06173944f, 0.10803293f, 0.02608952f, -0.07704651f, 0.08359634f, 
    -0.08425672f, 0.15522857f, 0.03924303f, -0.00450197f, 0.05196407f, 0.00354849f, -0.04849714f, 0.07002968f, 
    -0.14461596f, 0.02875256f, 0.01133941f, -0.07084825f, -0.21682228f, 0.06952658f, -0.07210492f, -0.29184046f, 
    -0.03758225f, 0.09062045f, -0.10168169f, 0.04424999f, 0.06504220f, -0.15511365f, -0.04147093f, 0.05712822f, 
    -0.28008264f, -0.22154197f, -0.19347796f, -0.15913856f, -0.02627039f, -0.08387700f, -0.16241352f, 0.00340311f, 
    -0.01891902f, -0.09878605f, -0.01673633f, -0.00154977f, 0.11396302f, 0.12811367f, 0.04765720f, 0.02748668f, 
    -0.12158182f, -0.07112972f, -0.06525501f, 0.08011323f, 0.02182394f, 0.02551893f, 0.08209450f, 0.02791706f, 
    -0.43829021f, 0.04190194f, 0.16790266f, 0.02598345f, 0.06707485f, -0.03440585f, -0.07459667f, -0.04034138f, 
    -0.04820821f, 0.04137123f, -0.07535442f, 0.00608002f, 0.00495067f, 0.12470910f, 0.16411130f, 0.15295856f, 
    -0.07341482f, 0.00157549f, 0.09629207f, -0.01328111f, -0.12071902f, 0.03168892f, -0.06169812f, -0.01662611f, 
    -0.24562627f, 0.19132908f, 0.22107692f, 0.11553115f, 0.14977784f, 0.06639767f, -0.13407323f, -0.07392131f, 
    0.00031399f, 0.01588240f, 0.02008623f, -0.07570600f, -0.12066472f, 0.13328022f, 0.20295185f, 0.00774501f, 
    -0.03208807f, -0.11896631f, -0.01978689f, 0.03940567f, -0.06954816f, -0.11556043f, 0.12064278f, -0.00793413f, 
    0.01856676f, 0.18705678f, 0.12365765f, 0.03471503f, -0.08228678f, -0.15587448f, -0.00017441f, 0.02034596f, 
    -0.01102411f, -0.05339824f, 0.11871517f, -0.00026150f, -0.07666691f, -0.01651947f, 0.20484971f, 0.01213585f, 
    0.04152668f, 0.04615010f, 0.09571995f, -0.04666836f, -0.05875833f, 0.05988667f, -0.05437821f, -0.02690305f, 
    0.14357808f, 0.18227114f, 0.07345966f, 0.07429904f, 0.04449029f, 0.03086079f, 0.06630571f, 0.01254749f, 
    -0.00591362f, 0.02968176f, -0.01805053f, 0.03310118f, 0.27006787f, -0.22266015f, 0.19195597f, 0.11111722f, 
    -0.11072555f, 0.00927958f, 0.07688595f, 0.13786106f, -0.02075817f, 0.03241961f, 0.04388741f, 0.00241009f, 
    0.22225034f, 0.12481334f, -0.06261898f, 0.16246927f, 0.00135533f, 0.05227754f, -0.08063076f, -0.05972534f, 
    -0.04699757f, -0.02487126f, 0.08341997f, -0.14562126f, -0.03059657f, 0.15282084f, -0.21538354f, 0.02841149f, 
    -0.02113396f, 0.07203211f, -0.04356128f, -0.06495440f, -0.01100872f, -0.01983189f, 0.06702005f, 0.03455490f, 
    -0.02208426f, -0.01967206f, -0.10613210f, -0.18378522f, -0.14776792f, -0.11986662f, -0.02631153f, 0.02279724f, 
    -0.08277671f, -0.08117141f, -0.14135846f, 0.13058488f, -0.05861911f, 0.00603847f, -0.05493132f, 0.07307430f, 
    -0.13967940f, -0.05456173f, 0.02850306f, -0.04217322f, -0.05903564f, 0.06417313f, -0.00029338f, -0.01733586f, 
    -0.23303111f, -0.03623030f, -0.12863187f, 0.07100448f, -0.09653515f, 0.06659194f, 0.02983366f, -0.00150326f, 
    -0.06281891f, -0.00947883f, -0.06211968f, 0.08438456f, -0.02282757f, -0.02387154f, -0.01666771f, -0.13826668f, 
    0.07544976f, -0.08970141f, -0.07140040f, -0.07929226f, 0.02983060f, -0.18312472f, 0.04264593f, 0.12466698f, 
    -0.06029401f, 0.01342068f, 0.11204484f, -0.02690921f, 0.06603143f, 0.06908292f, -0.08566677f, 0.09254666f, 
    0.09343708f, -0.11160569f, 0.04728386f, -0.11266222f, -0.09959474f, -0.09653988f, -0.10142421f, -0.04786690f, 
    -0.17966357f, -0.01338571f, 0.04773084f, -0.07726730f, -0.08829663f, -0.03385953f, 0.04113836f, 0.08949830f, 
    0.18460985f, 0.12449206f, -0.11781444f, -0.00036746f, -0.03643433f, -0.05744050f, -0.00726734f, 0.00916991f, 
    -0.02387586f, -0.03094674f, -0.00209807f, -0.00761136f, 0.03282075f, -0.21676320f, -0.26981819f, -0.07101443f, 
    -0.11357287f, 0.00772225f, 0.02217410f, 0.09019858f, -0.11797851f, 0.03733961f, 0.04625249f, -0.00057515f, 
    0.25781775f, -0.12893687f, -0.10461456f, 0.11230933f, 0.03513015f, 0.04753841f, -0.00406474f, -0.03422813f, 
    -0.01215576f, 0.08934610f, 0.03757393f, 0.03502100f, -0.44628477f, 0.28960285f, 0.08478904f, -0.11592713f, 
    -0.02162677f, 0.00296969f, 0.02292625f, 0.13693109f, -0.04611782f, 0.01217264f, 0.01087037f, 0.05438747f, 
    0.16006634f, -0.11845803f, 0.00358436f, 0.18247396f, 0.06563915f, -0.08227198f, -0.07399544f, 0.04778155f, 
    0.02785698f, 0.04241850f, -0.05499924f, -0.07267202f, 0.05772828f, -0.21846183f, 0.00078854f, 0.18222190f, 
    0.13715188f, 0.03206123f, -0.07148033f, 0.05151183f, -0.05424120f, 0.00449444f, -0.04798203f, -0.17568947f, 
    -0.18848178f, -0.04383219f, -0.18644992f, -0.08820798f, -0.10374343f, 0.11007429f, -0.08158639f, -0.04915502f, 
    0.04595929f, 0.07530445f, 0.02810166f, 0.01348115f, 0.22695449f, -0.04236619f, 0.15145229f, -0.21335575f, 
    -0.02195233f, -0.16991894f, -0.01437430f, -0.06255008f, -0.06671400f, -0.05075263f, 0.00822754f, 0.01011536f, 
    0.05810456f, 0.01221442f, 0.08838658f, -0.00539027f, 0.05926688f, -0.05679315f, -0.09946089f, -0.07856301f, 
    -0.03157755f, 0.13056469f, -0.12935141f, 0.06770951f, 0.02732344f, -0.07551181f, -0.05078802f, -0.00167638f, 
    -0.00712474f, -0.08323198f, 0.01755215f, -0.01467989f, -0.08856377f, 0.01379646f, 0.07932150f, -0.07074960f, 
    0.15631256f, -0.06563137f, -0.03963285f, 0.07722971f, 0.04131347f, -0.01353778f, 0.04356268f, 0.03379617f, 
    0.01841779f, 0.08848855f, -0.01154681f, 0.04490870f, -0.56904167f, -0.15570265f, -0.10991254f, 0.01294109f, 
    -0.14796275f, -0.07280978f, 0.02370899f, -0.07894242f, 0.02788190f, -0.14412133f, -0.02270532f, -0.03841958f, 
    0.01147598f, -0.07879940f, -0.09610874f, -0.07217199f, -0.03449651f, 0.01436560f, 0.01749529f, -0.02329508f, 
    -0.04336887f, -0.02749792f, -0.05237886f, 0.02409000f, 0.08527902f, 0.23889109f, 0.16534948f, -0.15261596f, 
    0.04177456f, -0.05617411f, -0.01668055f, 0.06762875f, -0.00875272f, -0.03227283f, -0.02360067f, 0.08109268f, 
    -0.51934099f, -0.39987081f, -0.07396080f, 0.01601199f, -0.11318907f, 0.03558703f, -0.03871538f, 0.01412905f, 
    -0.11967570f, -0.04653582f, -0.11072715f, 0.00988351f, 0.27946118f, -0.37458742f, 0.01798422f, 0.06105319f, 
    -0.03284841f, 0.09101265f, 0.03502173f, -0.09010416f, 0.04729321f, -0.08576696f, 0.08211310f, 0.02039659f, 
    -0.04305258f, 0.20262456f, 0.05674054f, -0.00595075f, -0.00140340f, -0.00587040f, -0.11870051f, 0.01027867f, 
    0.03414854f, 0.00484193f, 0.08498624f, 0.05534180f, 0.00473073f, 0.06071863f, 0.01367430f, 0.01735785f, 
    -0.07763219f, -0.08834770f, 0.01509761f, -0.08493778f, -0.08467488f, 0.01760823f, 0.04594957f, -0.07136797f, 
    -0.18316375f, 0.10508183f, 0.07340515f, 0.02199011f, -0.03942302f, 0.01511738f, -0.07936451f, -0.04477964f, 
    0.01561222f, 0.06381301f, -0.05939683f, 0.01727518f, 0.28614378f, 0.13890076f, -0.00839586f, -0.04513124f, 
    0.01961790f, -0.03100739f, 0.05618937f, 0.03649240f, -0.07851763f, -0.03045727f, 0.01100489f, -0.04295609f, 
    0.29109994f, 0.05150702f, 0.14816339f, 0.12235487f, -0.06413613f, -0.09654897f, 0.00506164f, -0.14566496f, 
    -0.06947702f, 0.04095571f, -0.03301338f, -0.00741849f, 0.06416721f, -0.29124394f, -0.03500253f, 0.15491059f, 
    0.04922191f, 0.00218910f, 0.03496195f, 0.01106771f, -0.00395920f, -0.03739056f, -0.05647944f, -0.19420375f, 
    0.08630466f, -0.11261243f, 0.01532467f, 0.03700553f, -0.07177455f, -0.05431834f, -0.01821159f, 0.02465234f, 
    -0.05318750f, 0.04161664f, -0.06187301f, -0.08783568f, 0.02976877f, 0.05018568f, -0.07156342f, -0.02895134f, 
    -0.04950644f, 0.04400722f, 0.01679418f, 0.06026028f, 0.02611842f, 0.01235132f, 0.05758863f, 0.07607619f, 
    0.17924872f, -0.14490633f, 0.06638035f, -0.00514989f, 0.00825905f, -0.07694238f, 0.07564856f, 0.01184069f, 
    -0.04419804f, -0.02293770f, -0.02070243f, 0.01794282f, 0.02440419f, -0.04330749f, 0.18246870f, 0.11003210f, 
    -0.03058865f, -0.02904906f, 0.10470638f, 0.05087965f, 0.13250487f, 0.00923760f, -0.01578330f, -0.00510966f, 
    -0.29326162f, -0.14133473f, 0.16405192f, 0.21818680f, -0.00651510f, -0.00163448f, 0.11767939f, 0.07432766f, 
    -0.08407383f, 0.02048008f, 0.09728066f, -0.01247687f, -0.23138276f, 0.11084425f, -0.01188011f, -0.07695441f, 
    0.12231386f, 0.01567964f, -0.16366236f, -0.03225119f, 0.01472437f, 0.02289282f, -0.20275426f, 0.00460591f, 
    -0.15999819f, -0.07018449f, -0.02644906f, -0.17582604f, -0.03079164f, 0.11254395f, 0.08218488f, -0.01734734f, 
    0.07541298f, 0.00277881f, -0.09594947f, -0.07206603f, 0.09191924f, 0.05944753f, -0.09195603f, 0.00253870f, 
    -0.02973986f, 0.01357759f, 0.09100974f, -0.03956076f, -0.05325300f, 0.16431540f, 0.04316295f, -0.02262681f, 
    -0.02081011f, 0.14414926f, 0.04579987f, 0.01440452f, -0.05043548f, 0.05675925f, 0.07568263f, 0.06275879f, 
    0.07873521f, -0.15002547f, -0.02369251f, 0.01027539f, 0.36407480f, 0.03288372f, -0.11866671f, -0.00251253f, 
    -0.05353255f, 0.00293954f, 0.17033669f, 0.05074857f, -0.01305984f, -0.00616770f, 0.05301132f, 0.07733886f, 
    -0.06859847f, 0.08174846f, 0.06467035f, 0.00262697f, 0.01606330f, -0.06738320f, 0.03567642f, 0.03758186f, 
    -0.01492871f, -0.02560971f, -0.06881776f, -0.05806434f, 0.01062466f, 0.12154862f, 0.12126900f, 0.12189826f, 
    -0.09801860f, -0.00335215f, -0.00377432f, 0.07426064f, -0.04001473f, 0.03550240f, 0.06167956f, 0.06333296f, 
    -0.29365429f, -0.17042458f, 0.02587206f, -0.04605838f, -0.04256579f, 0.03516549f, -0.00342032f, 0.02442182f, 
    0.10979366f, -0.02688834f, -0.12947865f, 0.00912798f, 0.36058620f, -0.19732665f, -0.04659000f, 0.07818148f, 
    0.02442808f, 0.00044859f, -0.02623262f, 0.06041236f, 0.02426404f, -0.03163084f, -0.04147302f, 0.11322617f, 
    0.10771127f, 0.07327342f, 0.11284024f, -0.17769754f, -0.05525040f, 0.01422510f, -0.05517840f, -0.04070840f, 
    0.01475650f, -0.11519845f, 0.00139540f, -0.05849966f, -0.03768048f, -0.14666866f, -0.13365000f, 0.11909772f, 
    -0.15593252f, -0.06096156f, 0.16712449f, 0.02236123f, 0.00352693f, 0.05397379f, -0.04374954f, -0.07503974f, 
    -0.01423437f, -0.27120489f, 0.14132616f, -0.10215132f, 0.02836890f, 0.08504918f, 0.02152250f, -0.11017732f, 
    0.02855410f, 0.06080399f, 0.08020005f, 0.03319139f, -0.05589625f, -0.04488333f, -0.09226886f, 0.01635369f, 
    -0.00537468f, -0.01234664f, 0.08772390f, 0.15948735f, -0.02593334f, 0.00301463f, 0.00147338f, 0.05141125f, 
    -0.36322099f, 0.12457468f, 0.18001883f, -0.16708869f, -0.06008346f, -0.08115810f, -0.16637346f, 0.02744196f, 
    -0.08610163f, -0.14621982f, -0.08449551f, 0.13792661f, -0.20165919f, -0.10374856f, 0.20504312f, -0.20702875f, 
    0.16905098f, 0.03354162f, -0.01716572f, -0.15069737f, 0.04832481f, 0.03430383f, 0.03036407f, -0.04258229f, 
    -0.16339673f, -0.10575297f, 0.06401461f, 0.01985002f, -0.00645208f, 0.10495048f, -0.26180953f, -0.08153884f, 
    0.03324160f, -0.18199517f, 0.03641808f, 0.00683536f, -0.10894185f, -0.11268662f, 0.17490420f, -0.00987953f, 
    0.03392613f, -0.00968383f, -0.11394219f, -0.02663347f, 0.03226335f, -0.04848305f, 0.05799414f, 0.03690483f, 
    0.19512019f, 0.07332448f, -0.04658038f, -0.01924380f, -0.02653021f, 0.06138460f, 0.00046836f, 0.04619090f, 
    -0.19654632f, -0.02973087f, 0.00372941f, -0.17286491f, -0.07773590f, -0.08013310f, 0.13205710f, 0.22401924f, 
    -0.03694401f, 0.03777038f, 0.07267204f, 0.04300540f, -0.20332715f, 0.08874395f, 0.06992319f, -0.05159280f, 
    -0.06865210f, -0.07204519f, 0.09783512f, 0.04017740f, -0.08673913f, -0.05847105f, -0.01129708f, -0.07464099f, 
    0.05215336f, -0.02036455f, -0.06677091f, -0.03368658f, 0.11499415f, -0.01239537f, 0.09569691f, 0.12518144f, 
    0.02894874f, 0.01542383f, 0.06854433f, 0.10330784f, -0.04080025f, 0.03182872f, 0.02208541f, 0.07181357f, 
    -0.20644166f, 0.15760623f, -0.03964898f, 0.08417918f, -0.05719446f, -0.05314775f, -0.00588636f, -0.02970721f, 
    -0.01764462f, -0.05259303f, 0.07315755f, 0.01165892f, -0.19256933f, -0.09079870f, 0.09902640f, -0.10765365f, 
    0.04104405f, 0.03898200f, -0.01016554f, 0.01028400f, -0.00352331f, 0.03011791f, -0.01877873f, 0.01542534f, 
    -0.23609093f, -0.06763299f, 0.27500859f, 0.15672247f, 0.04019658f, -0.03377168f, -0.08831423f, -0.09055137f, 
    0.04509867f, 0.00991851f, -0.02987027f, 0.06083095f, -0.34961924f, 0.01773619f, -0.00674337f, -0.07339303f, 
    0.10940015f, -0.07743123f, 0.02619568f, 0.02771370f, -0.10480618f, -0.00832896f, 0.02371920f, 0.02799506f, 
    -0.07784317f, 0.07632094f, 0.00547104f, 0.03933111f, 0.03146898f, 0.03761269f, -0.05113178f, -0.04590051f, 
    0.01763114f, 0.12882593f, 0.02805660f, 0.10529055f, -0.31832585f, 0.22170202f, -0.10093723f, -0.08052900f, 
    0.12417100f, -0.05848450f, -0.01236616f, -0.03649339f, -0.00269523f, 0.02564502f, 0.00363195f, 0.01020069f, 
    -0.52214074f, 0.04971253f, -0.14959115f, -0.16902260f, -0.06038585f, -0.01354541f, -0.01517588f, 0.08581048f, 
    -0.08120434f, -0.06380120f, 0.02975130f, 0.10766019f, -0.26789105f, 0.15729657f, 0.04395857f, -0.02204724f, 
    0.01239025f, 0.07435235f, 0.00809627f, 0.03882159f, 0.01361686f, 0.09960537f, 0.07078998f, -0.04221023f, 
    -0.12201696f, -0.10798891f, 0.00684204f, 0.21434471f, -0.10253460f, 0.02828152f, -0.02640434f, -0.07996833f, 
    0.16076528f, -0.03182624f, -0.02595191f, -0.02039072f, -0.51273835f, 0.17143099f, -0.08201804f, 0.17098138f, 
    0.00073924f, -0.09507494f, 0.02928387f, -0.17768443f, 0.02866796f, -0.02214672f, -0.17036951f, -0.05720210f, 
    0.02515375f, 0.05915115f, 0.18439998f, -0.00067955f, 0.09537638f, 0.00781050f, 0.12623571f, 0.12668873f, 
    0.01376769f, 0.04575963f, -0.04491837f, 0.07881280f, -0.03204865f, -0.13068239f, -0.02184379f, 0.12696163f, 
    -0.04281751f, -0.01071742f, -0.06583461f, 0.01145379f, 0.01711163f, -0.00414377f, -0.01353423f, 0.05667698f, 
    -0.15401489f, 0.04829836f, 0.04618564f, -0.19163963f, 0.12706821f, -0.02929222f, -0.05027704f, -0.07343568f, 
    0.00397138f, -0.01570565f, -0.04058643f, -0.09424455f, -0.04739548f, 0.21055187f, -0.13139969f, 0.03622076f, 
    0.07382740f, -0.01823464f, 0.05983009f, 0.12126959f, 0.06100342f, -0.10549891f, 0.07348488f, -0.03897745f, 
    0.17884713f, -0.07178608f, 0.09679577f, -0.05128130f, -0.06081222f, -0.01812327f, -0.08367716f, 0.03838461f, 
    0.05445439f, -0.11376080f, 0.04459211f, 0.01097166f, -0.48699304f, 0.05210894f, 0.20882395f, 0.24938180f, 
    -0.04659019f, 0.10097325f, 0.12755518f, 0.02105623f, 0.04941299f, 0.10177483f, 0.11678789f, 0.00810135f, 
    0.05468086f, -0.15343016f, -0.00267887f, 0.04160354f, 0.07592782f, 0.01508649f, 0.03716846f, -0.04384559f, 
    0.08393310f, -0.06291264f, 0.10047419f, -0.00950683f, -0.06080393f, -0.07462635f, 0.09671313f, -0.10018288f, 
    -0.01902082f, -0.05854759f, 0.09170286f, -0.00071256f, -0.04292179f, 0.07403285f, 0.06211775f, -0.07436722f, 
    0.05195504f, -0.24434452f, 0.07129574f, -0.17314117f, 0.02873145f, 0.05892423f, 0.01934874f, -0.15956821f, 
    0.02069878f, 0.12638144f, -0.04149632f, -0.02291653f, 0.11225435f, -0.06819691f, 0.00917479f, -0.17299314f, 
    -0.04613568f, 0.11200443f, 0.09623826f, 0.02419959f, 0.07063568f, -0.06553960f, -0.12491473f, -0.05695633f, 
    0.05421013f, 0.31079102f, -0.11111354f, -0.48861188f, 0.06377287f, -0.05191520f, 0.00970704f, 0.06274603f, 
    0.02815673f, -0.07098436f, -0.04064729f, 0.03354051f, -0.17218031f, -0.07971725f, 0.08378972f, 0.11382168f, 
    -0.09261260f, 0.03583519f, -0.06139179f, -0.10746499f, 0.01058336f, -0.01552759f, -0.06909544f, 0.06618656f, 
    0.01264176f, 0.19101639f, -0.00681791f, -0.05820680f, -0.04326054f, -0.08081787f, 0.02764440f, 0.07684279f, 
    -0.05546628f, 0.01301942f, 0.08101340f, 0.10406374f, -0.18905354f, -0.02102993f, -0.03464522f, 0.01885424f, 
    0.00248810f, 0.04602597f, -0.01876406f, 0.06697394f, -0.10103475f, -0.12238777f, -0.09417877f, 0.02701384f, 
    0.28187808f, -0.30095068f, 0.01217952f, 0.11717603f, -0.04428776f, -0.01991280f, -0.02951559f, -0.11898953f, 
    -0.07003510f, 0.01545603f, -0.07841932f, 0.07256590f, -0.51596081f, 0.12109773f, -0.01854295f, 0.11236651f, 
    0.06580565f, -0.01565605f, 0.06339270f, 0.01608943f, 0.04279248f, 0.04475148f, 0.00347847f, -0.01895514f, 
    -0.24592303f, -0.08741512f, -0.05507733f, -0.10214594f, 0.05695287f, -0.05185769f, -0.05588940f, -0.15096395f, 
    0.01194429f, -0.10085213f, -0.04384718f, 0.00532386f, 0.10825375f, 0.15166692f, 0.02877120f, 0.04381183f, 
    -0.02405826f, -0.05658259f, -0.01531318f, 0.02672025f, 0.04984199f, 0.03043368f, -0.00061972f, -0.05896407f, 
    -0.32328597f, -0.21233688f, -0.04652690f, 0.14376120f, -0.03685285f, 0.02325131f, -0.04165751f, -0.10466366f, 
    -0.01507154f, 0.02464107f, 0.04610147f, 0.02236678f, -0.08785977f, 0.05889685f, 0.03443871f, -0.08434318f, 
    0.10486620f, -0.13521431f, -0.00145259f, -0.05684889f, -0.06677029f, -0.13417356f, -0.00707471f, 0.05771330f, 
    0.07958307f, -0.01104190f, 0.12817599f, 0.03932538f, -0.09071498f, 0.08886487f, -0.07161666f, 0.07725791f, 
    0.09885864f, 0.04527589f, -0.08192613f, -0.05003326f, 0.32184571f, 0.07782774f, 0.03224118f, 0.05836572f, 
    -0.00554513f, 0.03640626f, 0.06814425f, -0.04197606f, 0.10641787f, 0.00103213f, 0.09889521f, -0.05071981f, 
    0.18740273f, 0.00325123f, 0.24121726f, -0.20312576f, -0.02596226f, 0.06618206f, 0.06157929f, -0.01615772f, 
    -0.00264284f, 0.12712093f, 0.09002564f, -0.00460146f, 0.01458334f, 0.07052126f, -0.00582393f, 0.01268961f, 
    0.03236926f, -0.03797367f, 0.00097661f, -0.02569162f, 0.13993059f, 0.03113716f, 0.00818822f, -0.14521718f, 
    -0.10143815f, 0.08792905f, 0.14850305f, -0.02006692f, -0.02423738f, 0.08137856f, -0.02712337f, -0.05270728f, 
    -0.06434783f, -0.09767012f, -0.08402055f, 0.01587247f, 0.04613142f, 0.13900594f, 0.15607436f, -0.08147713f, 
    0.00999254f, -0.07506983f, 0.08812460f, 0.00316550f, -0.06038989f, 0.01799083f, 0.06635925f, 0.00399804f, 
    -0.08799169f, 0.01541339f, -0.25940847f, -0.00772982f, -0.08613632f, -0.01261555f, 0.01848048f, -0.06170083f, 
    -0.03448097f, -0.04705556f, -0.02278351f, 0.00722211f, -0.33803943f, 0.04198561f, 0.09355676f, 0.09111360f, 
    -0.05017934f, 0.04854185f, -0.00585959f, -0.01734994f, -0.04253681f, -0.07289743f, 0.07751401f, -0.07059140f, 
    -0.06533507f, -0.08428720f, 0.03325141f, 0.08800865f, 0.07579197f, 0.16050357f, -0.03810625f, 0.17348783f, 
    0.11283486f, -0.05005499f, 0.07154854f, -0.26697707f, -0.02506916f, 0.07876636f, 0.04267484f, -0.04040819f, 
    0.02480600f, 0.03779514f, 0.06723959f, 0.12955059f, -0.01501171f, 0.08609214f, -0.30563563f, 0.02080960f, 
    0.11936992f, -0.05427651f, 0.00374726f, -0.04320999f, -0.00474732f, -0.00630482f, -0.11752506f, 0.03455216f, 
    0.02760130f, -0.03721421f, 0.09317534f, -0.06043608f, 0.03293414f, -0.09602593f, -0.11652257f, 0.23229365f, 
    -0.03486402f, -0.13864407f, 0.09556638f, -0.02215265f, -0.09963064f, 0.07952320f, 0.10902160f, 0.18915109f, 
    -0.00658113f, -0.00739154f, -0.12562224f, -0.16841587f, -0.01463033f, 0.08673756f, -0.15031683f, -0.16618045f, 
    0.10460404f, -0.01646820f, -0.03068222f, 0.00088867f, -0.45556572f, -0.03381560f, -0.06668421f, -0.10285331f, 
    0.07609437f, -0.02661780f, -0.08153764f, 0.10215858f, -0.03139040f, 0.08623604f, 0.12657395f, -0.22291093f, 
    -0.14179006f, 0.10725326f, 0.05352513f, 0.01877427f, -0.01313108f, -0.03595933f, -0.02710227f, -0.04066517f, 
    0.14687242f, 0.04890346f, 0.18274790f, 0.10681333f, -0.01524284f, 0.15745474f, 0.08507185f, 0.14884587f, 
    0.03462283f, -0.01210185f, 0.06828468f, -0.02609847f, -0.04540424f, 0.00541973f, -0.07599346f, 0.02973413f, 
    0.00410347f, -0.08939226f, 0.16161382f, -0.03091648f, 0.10092355f, 0.06518486f, -0.02052219f, -0.03599703f, 
    -0.00294764f, 0.05694461f, 0.07548356f, 0.16603890f, -0.08710059f, 0.17549053f, 0.13047160f, -0.33002481f, 
    -0.06911141f, -0.18879518f, -0.14876457f, -0.16182598f, 0.03218817f, 0.00051792f, -0.14456536f, -0.02402693f, 
    -0.12130470f, 0.00967855f, -0.06688210f, 0.05888667f, 0.04103572f, -0.04982661f, -0.08920123f, 0.02436897f, 
    0.07114198f, 0.03987025f, 0.11039753f, -0.06860483f, -0.02407821f, 0.11033761f, 0.06101709f, 0.23674883f, 
    -0.03394078f, -0.05487635f, 0.13624741f, -0.01664847f, 0.00784815f, -0.04318154f, -0.05426344f, 0.12900452f, 
    -0.02090621f, 0.15071750f, -0.12414514f, 0.05208930f, 0.03284018f, 0.10413219f, 0.06453335f, 0.00601344f, 
    -0.02839092f, -0.16747099f, 0.13299234f, 0.04472134f, 0.00758714f, -0.09825487f, 0.05078441f, 0.11568236f, 
    0.15325165f, -0.05030804f, 0.07542411f, -0.00836425f, 0.04159056f, -0.22724633f, -0.06448033f, -0.27172235f, 
    -0.17636225f, -0.00782581f, -0.04990069f, 0.18541802f, 0.11780123f, -0.02524485f, 0.03681361f, 0.09420836f, 
    -0.04288023f, -0.12932096f, -0.03015793f, 0.11868837f, 0.02647209f, 0.01545654f, 0.08652228f, -0.12830891f, 
    -0.11207568f, 0.01012043f, -0.09469628f, 0.02695820f, -0.04217197f, -0.07355127f, 0.13619126f, 0.10044589f, 
    0.21520747f, -0.08280358f, -0.04172228f, 0.08753546f, 0.03337240f, -0.16923423f, -0.02346815f, 0.03800822f, 
    0.08193414f, 0.05591265f, 0.01272108f, -0.04858234f, -0.06247743f, 0.05494917f, 0.09729368f, -0.01216813f, 
    0.06209813f, 0.17457055f, -0.04091091f, 0.08189970f, -0.07996579f, -0.10237968f, -0.02165370f, 0.00570031f, 
    -0.03591334f, -0.17518860f, 0.12926970f, 0.31631067f, -0.08718625f, 0.02662385f, 0.07741131f, 0.01266038f, 
    0.06934217f, 0.00312852f, 0.05388662f, -0.04484551f, -0.06388204f, -0.07120191f, -0.03740057f, 0.19309801f, 
    -0.11540566f, -0.01651481f, -0.12487490f, 0.04681568f, 0.18599877f, 0.00215090f, 0.08057607f, -0.06966899f, 
    -0.05545042f, -0.00653710f, -0.12601723f, 0.05592077f, 0.02276549f, 0.07991997f, 0.18651892f, -0.07254317f, 
    0.01761208f, 0.11796159f, -0.06118333f, -0.04526769f, 0.02528250f, 0.04081762f, 0.08104488f, 0.15701415f, 
    -0.15019077f, -0.04087869f, 0.00531707f, 0.00801703f, -0.28187120f, 0.05335555f, 0.05741239f, 0.06531604f, 
    -0.10818513f, -0.11731118f, 0.05110893f, -0.00806847f, 0.08007549f, -0.12540686f, 0.07780790f, -0.10759056f, 
    -0.00172272f, 0.09604917f, -0.23450719f, 0.14443567f, 0.04630889f, -0.12813632f, -0.13574003f, 0.01419832f, 
    0.09828173f, -0.03914484f, -0.01611894f, -0.14024433f, -0.06307109f, 0.02380032f, -0.06126700f, 0.05727880f, 
    -0.00620249f, 0.01585852f, -0.05466892f, -0.08289360f, 0.06761716f, 0.01576589f, 0.03120101f, 0.08138655f, 
    0.01311952f, -0.04255841f, 0.04169766f, 0.00760944f, -0.09383583f, 0.07115581f, -0.16964380f, 0.12655228f, 
    0.10904978f, 0.11372206f, 0.03007933f, 0.05044046f, -0.03913411f, 0.01286467f, 0.07247790f, -0.05720271f, 
    -0.01655388f, 0.01603617f, 0.10686709f, -0.41077897f, -0.07173485f, -0.06282604f, 0.05196289f, 0.00577391f, 
    0.03088148f, -0.07888021f, -0.00128611f, -0.16254435f, 0.16426475f, 0.14202814f, 0.12417886f, -0.12140648f, 
    -0.02589725f, 0.02353374f, 0.01286842f, 0.01027337f, -0.10971397f, -0.24771315f, 0.05926463f, 0.08748373f, 
    0.20843439f, 0.06039599f, 0.02836283f, -0.05396814f, 0.00607045f, 0.01081053f, 0.03419444f, 0.05389800f, 
    0.02342831f, -0.01822731f, 0.06945285f, 0.07139566f, -0.15459958f, 0.04558799f, -0.14484279f, -0.10297640f, 
    0.02819771f, 0.02990052f, 0.08744578f, 0.00209800f, -0.05082288f, -0.01814091f, 0.11746285f, -0.01056638f, 
    0.10014221f, 0.21002431f, -0.06357262f, -0.03568916f, 0.09790761f, 0.05380431f, 0.01544657f, -0.12797818f, 
    -0.00188231f, -0.09392711f, -0.06102799f, -0.17148976f, -0.41162995f, 0.05204552f, 0.02674748f, -0.23303503f, 
    0.07748950f, -0.03592840f, -0.04638971f, -0.05447058f, 0.09291904f, -0.17168099f, -0.09013589f, -0.01885311f, 
    -0.28086141f, 0.13540044f, -0.12604173f, -0.20824635f, 0.04417059f, 0.01169314f, 0.04525089f, 0.01744020f, 
    -0.05188522f, 0.01434928f, -0.15458408f, -0.29062945f, -0.09168543f, -0.10034601f, 0.17573214f, 0.30404070f, 
    -0.03118533f, 0.07039855f, 0.01390409f, 0.12392865f, -0.09809503f, 0.02505933f, 0.07790494f, -0.00199667f, 
    -0.01680221f, 0.03431119f, 0.02592910f, 0.03245584f, -0.00013367f, -0.02384702f, -0.05123050f, 0.06569670f, 
    -0.15996990f, 0.06505670f, 0.02362188f, 0.10598157f, -0.29522949f, 0.06522150f, -0.08805972f, -0.04236151f, 
    0.00347303f, 0.06541502f, -0.00640344f, -0.04365532f, 0.14008430f, 0.03262567f, 0.09472942f, -0.01289769f, 
    -0.39706773f, -0.08836641f, -0.12988326f, 0.07750650f, 0.06157488f, -0.04202238f, -0.06367178f, -0.02462699f, 
    0.12194131f, 0.01848845f, 0.22060870f, 0.00506245f, 0.15318145f, -0.12247305f, -0.22451870f, -0.06155566f, 
    0.12094817f, 0.18845488f, 0.07610402f, -0.01258331f, -0.00198135f, 0.04266091f, -0.24318208f, -0.07114146f, 
    -0.06779912f, 0.09390615f, 0.13083397f, 0.01909186f, -0.03885810f, 0.06025518f, 0.00558075f, 0.09289315f, 
    0.08769322f, -0.03541217f, 0.02878128f, 0.03683259f, 0.00415434f, -0.18949977f, 0.03643321f, -0.03463779f, 
    -0.11140145f, 0.00708473f, -0.06204960f, -0.26286334f, -0.02895092f, -0.15898199f, -0.08975761f, -0.11650985f, 
    0.00420348f, 0.00942941f, 0.15416889f, 0.30086067f, -0.07339969f, -0.00576843f, 0.04022191f, -0.05624671f, 
    0.04351510f, 0.08138403f, -0.13267033f, 0.12518546f, 0.11161277f, -0.10894854f, -0.30374259f, -0.11371940f, 
    0.04212024f, 0.03544071f, -0.17335393f, -0.05063991f, 0.04961266f, -0.05190787f, -0.09763417f, 0.03274034f, 
    -0.31120521f, 0.09879010f, -0.02164186f, 0.00105011f, -0.11155610f, 0.05699387f, 0.00772824f, 0.00266114f, 
    -0.02761886f, 0.10078117f, 0.06255078f, 0.15210386f, 0.19319054f, 0.06720957f, -0.04171831f, 0.03842739f, 
    -0.11463793f, 0.18659241f, 0.02527912f, -0.16771325f, -0.00720331f, -0.05293129f, -0.04447989f, 0.11384626f, 
    -0.08401255f, -0.03106762f, 0.04184928f, 0.16163640f, 0.06882515f, -0.09588906f, -0.02672136f, 0.12603161f, 
    0.03237065f, -0.09227897f, -0.15056239f, -0.15178339f, 0.04519108f, -0.04983333f, -0.06078516f, 0.11009005f, 
    -0.03086943f, -0.15420377f, -0.14977388f, 0.13742946f, 0.13290939f, 0.07477368f, 0.01681638f, 0.00280954f, 
    -0.35778049f, -0.44018501f, 0.26391497f, 0.07154588f, -0.04942963f, 0.13568823f, 0.04956466f, -0.09567793f, 
    -0.01783274f, 0.09486382f, 0.05006696f, 0.00924189f, 0.03452201f, -0.02424101f, -0.06962004f, 0.04039355f, 
    -0.04595968f, -0.09662103f, 0.04400418f, -0.02608927f, -0.09769706f, -0.01108768f, 0.06105977f, 0.12301517f, 
    0.00521843f, 0.13011974f, -0.09038243f, 0.11363278f, 0.06639472f, 0.01944767f, 0.08495183f, -0.06301363f, 
    0.06923503f, 0.04186426f, -0.27413961f, -0.02233695f, -0.26393226f, -0.10219719f, -0.20365444f, -0.03817904f, 
    0.04841843f, 0.02233360f, 0.12280905f, 0.03463959f, 0.22928594f, 0.02441991f, -0.11871438f, 0.05919054f, 
    0.03320830f, -0.15541123f, 0.07778215f, -0.13617784f, -0.01814715f, -0.06154754f, 0.05898299f, -0.00868658f, 
    -0.07530061f, -0.24750106f, 0.08263940f, -0.28122237f, -0.66024131f, -0.14526397f, -0.27035302f, -0.23877577f, 
    0.05930306f, 0.04517544f, -0.00099076f, -0.05764467f, -0.04769923f, 0.04761634f, -0.01972567f, -0.00580266f, 
    -0.08544086f, 0.23400910f, 0.18257393f, 0.02669658f, 0.00017044f, 0.04175762f, 0.07893511f, 0.09676071f, 
    -0.16794950f, -0.16656998f, 0.14491814f, -0.05387432f, -0.03950626f, 0.04917012f, 0.05534727f, 0.15241230f, 
    0.01920867f, 0.10657984f, 0.22184248f, 0.02901071f, 0.12425344f, -0.03174124f, 0.08377554f, 0.03998791f, 
    0.35024741f, -0.01601523f, -0.14253472f, -0.20080063f, 0.03995898f, -0.01930024f, -0.07610251f, -0.17351092f, 
    -0.06859169f, -0.06842382f, -0.10644820f, -0.03972111f, -0.19746891f, -0.09364688f, 0.00408260f, 0.27308947f, 
    -0.01447456f, 0.09186393f, -0.01134123f, 0.13514282f, -0.02069265f, 0.12097148f, 0.12839748f, -0.01569437f, 
    0.00544888f, 0.00612889f, 0.13309863f, 0.01173551f, -0.04545700f, -0.05106555f, 0.02534986f, -0.02900851f, 
    0.05403123f, -0.06046297f, 0.08856759f, 0.06655445f, -0.11733054f, 0.01412017f, 0.06140735f, -0.22830552f, 
    0.06363415f, -0.04896079f, -0.03225246f, -0.04716408f, -0.15118465f, 0.01155698f, -0.01298714f, 0.10234076f, 
    -0.06328936f, -0.07668112f, -0.17760143f, 0.10683608f, -0.03567810f, -0.03135485f, -0.04126065f, 0.17273691f, 
    0.17555557f, -0.03983228f, -0.07350007f, -0.08810115f, -0.04809321f, -0.13063830f, -0.09792864f, 0.02309114f, 
    0.09104109f, 0.00090500f, -0.07425266f, -0.10824792f, -0.07304613f, 0.05637458f, 0.02220033f, 0.07422055f, 
    -0.11826637f, -0.05956544f, 0.07520115f, -0.14933147f, 0.10786915f, -0.17887893f, 0.03939002f, -0.01129334f, 
    0.04957816f, -0.02884685f, 0.04669680f, -0.05459498f, -0.41803700f, -0.31857377f, 0.06572544f, 0.07099521f, 
    0.01732838f, 0.04872227f, -0.05596238f, -0.02442747f, 0.13442479f, 0.08600219f, 0.10503091f, -0.00149710f, 
    -0.42620739f, 0.02243713f, -0.05192783f, -0.24025953f, 0.08088924f, 0.07005079f, 0.02845914f, -0.02187400f, 
    0.01421062f, -0.03466642f, 0.01394898f, 0.13230391f, 0.07508516f, 0.04065718f, 0.03690447f, 0.11788859f, 
    -0.13634048f, 0.05704769f, 0.06793501f, -0.00751804f, -0.15619537f, 0.03205864f, 0.10957585f, 0.23779143f, 
    -0.19520764f, 0.11078870f, 0.16605130f, -0.20679608f, -0.06313830f, -0.10811832f, 0.06664881f, -0.09814961f, 
    -0.09432261f, 0.02799239f, 0.03930872f, 0.07199589f, 0.04282099f, 0.07241383f, 0.04689784f, -0.01488238f, 
    -0.12926018f, 0.01928219f, -0.15803459f, -0.11385545f, -0.04085936f, 0.12121184f, 0.13738252f, 0.09958092f, 
    -0.34387693f, 0.11519679f, 0.01298783f, 0.00678176f, -0.05147173f, -0.05841618f, 0.12751439f, 0.06606863f, 
    -0.09015726f, -0.05090128f, -0.05164845f, 0.15105261f, 0.01665816f, -0.18905784f, -0.25272790f, -0.00467984f, 
    0.06027171f, 0.06364542f, -0.16110684f, -0.02555752f, -0.02090625f, -0.22164582f, -0.08238742f, 0.05006812f, 
    -0.35738155f, -0.25059363f, -0.19103268f, -0.08204200f, 0.03492597f, -0.03845648f, 0.08923365f, -0.09112573f, 
    -0.06484939f, 0.00313446f, 0.05421446f, 0.02429200f, 0.01733132f, 0.08159252f, 0.17230679f, -0.04661195f, 
    0.03008021f, 0.00345823f, 0.28870219f, -0.04215342f, 0.02904879f, -0.01849917f, -0.00777798f, -0.00526395f, 
    0.21313526f, 0.14230016f, 0.00954388f, -0.23784405f, -0.09212138f, 0.12487236f, -0.01601348f, 0.07589312f, 
    -0.14434972f, 0.03926532f, -0.17043619f, -0.08681794f, 0.12496754f, -0.22118422f, -0.37638581f, 0.22785711f, 
    0.06340772f, -0.00321284f, -0.13681249f, -0.11304723f, 0.15558289f, -0.12616572f, 0.09170546f, -0.02702848f, 
    0.02554870f, 0.21123661f, 0.06961872f, -0.27830297f, -0.09467666f, 0.00203739f, 0.03950268f, -0.03561892f, 
    0.11506733f, -0.04442224f, -0.04585857f, -0.04604721f, -0.15498683f, 0.00353742f, -0.08113398f, -0.05821660f, 
    0.09210011f, 0.05169607f, 0.04544253f, 0.13339853f, -0.00222507f, -0.12514266f, 0.07062802f, 0.01424713f, 
    0.00713752f, -0.00861114f, 0.00902202f, -0.05179343f, 0.06291722f, 0.09044801f, -0.04934291f, -0.07025263f, 
    -0.00681256f, 0.01520972f, 0.00086434f, 0.08260848f, -0.05716254f, 0.11021221f, -0.36221755f, -0.14062986f, 
    -0.04863868f, 0.05552409f, -0.00771494f, -0.00683490f, -0.11274531f, -0.06930788f, 0.01820952f, -0.12711056f, 
    -0.09705564f, 0.26469743f, 0.02441218f, 0.06314817f, -0.15908551f, -0.12412848f, 0.01917922f, 0.03393446f, 
    0.01773396f, 0.05364645f, -0.01869893f, -0.07462108f, 0.12797305f, -0.00474245f, -0.12216830f, 0.05801746f, 
    -0.19759792f, 0.10071572f, 0.02194212f, -0.01812045f, -0.16082205f, 0.12371425f, 0.02894546f, 0.20541951f, 
    0.01422313f, -0.10603601f, -0.18856706f, 0.01812410f, -0.04346853f, -0.03685517f, 0.01870889f, -0.02421554f, 
    -0.19573694f, 0.03431295f, 0.09513167f, -0.09435133f, 0.08071104f, -0.05065989f, -0.00623792f, 0.06275541f, 
    0.05471361f, 0.18006955f, 0.10220162f, -0.01056434f, 0.11560787f, -0.12056479f, -0.10265772f, -0.08153684f, 
    -0.49263325f, 0.23120718f, -0.15004034f, 0.31220579f, 0.05871172f, 0.04178249f, 0.02199356f, 0.01692887f, 
    -0.00523718f, -0.01846562f, 0.03602641f, -0.11142815f, 0.14240079f, 0.12262709f, 0.04163422f, -0.14372279f, 
    -0.05886804f, -0.13762067f, 0.01757879f, 0.02325654f, -0.01843015f, 0.11626404f, 0.05175626f, -0.00844512f, 
    0.16115290f, -0.01552046f, -0.10964456f, -0.00990685f, 0.01920086f, -0.03408103f, -0.07729025f, 0.02977637f, 
    -0.03758527f, -0.00988250f, 0.01994270f, 0.02995864f, -0.10367825f, 0.13623060f, -0.29545411f, 0.34722546f, 
    -0.05515773f, -0.02828266f, 0.07571864f, 0.00714697f, -0.07534210f, -0.07147042f, -0.06098036f, -0.04734818f, 
    0.08553850f, -0.24819097f, -0.18220551f, 0.05959060f, -0.03114092f, 0.12500596f, -0.01188147f, -0.12812991f, 
    0.00426476f, -0.10803264f, -0.00838783f, 0.05220028f, 0.03647034f, 0.01920566f, 0.02067415f, -0.02694972f, 
    0.10040183f, 0.02108249f, 0.08677863f, 0.00676818f, 0.09501019f, -0.06823602f, 0.05556013f, -0.19018179f, 
    0.00265842f, 0.08424565f, -0.07035009f, -0.12502439f, -0.02218685f, 0.01877308f, 0.01576504f, -0.12298112f, 
    0.02045431f, -0.00913156f, 0.07173958f, -0.20632453f, -0.22177927f, -0.09049859f, -0.36291680f, 0.21959537f, 
    -0.01359498f, 0.01043827f, 0.13559055f, 0.07767593f, 0.09576565f, -0.04025022f, 0.04137746f, -0.09155615f, 
    -0.21800345f, 0.10048378f, 0.07934469f, -0.02865274f, 0.04415689f, -0.03490875f, 0.00985185f, -0.03337630f, 
    -0.10657932f, -0.09427513f, -0.01664072f, -0.08420360f, -0.10777228f, -0.07336169f, -0.08077410f, -0.23564506f, 
    0.02114631f, -0.02934249f, 0.00405670f, -0.06125131f, 0.05928888f, 0.13754670f, -0.00894394f, 0.10186600f, 
    0.16790739f, -0.12865570f, 0.16976555f, 0.17062265f, 0.09510248f, 0.06271441f, -0.02335769f, 0.01432103f, 
    0.02739601f, -0.01683407f, -0.00587248f, 0.14764668f, 0.13084683f, -0.14502366f, 0.10156500f, -0.18001938f, 
    -0.03648420f, 0.11319231f, 0.09386012f, 0.08931633f, 0.19000691f, 0.07207491f, -0.05831042f, 0.00464509f, 
    0.05357554f, -0.04235362f, -0.03581664f, -0.08385831f, 0.10539100f, 0.04137387f, 0.05032255f, -0.01318231f, 
    -0.17997599f, 0.05964394f, -0.04252546f, -0.06855318f, 0.09858894f, -0.06976450f, -0.04999366f, -0.00383772f, 
    0.13067742f, 0.02927661f, 0.04417314f, -0.07785168f, -0.05223364f, 0.09115484f, 0.12892717f, -0.09986772f, 
    0.05986564f, -0.14037004f, -0.01425389f, -0.05094800f, 0.01852795f, 0.06175135f, -0.03028049f, 0.08060690f, 
    0.00088451f, 0.01315362f, 0.09135767f, 0.06863284f, 0.52718186f, 0.02639197f, 0.06585296f, -0.11577182f, 
    -0.05320634f, 0.04705039f, 0.02713554f, 0.06560269f, -0.03984137f, 0.00882189f, 0.10390165f, 0.00477317f, 
    0.32118353f, -0.35693967f, 0.02863757f, 0.11938372f, -0.03397301f, 0.02951578f, -0.04789681f, 0.00202052f, 
    0.05087562f, -0.04063189f, 0.12749466f, 0.13899183f, 0.05053374f, 0.02917069f, 0.07155601f, -0.05968250f, 
    0.01284528f, -0.08991814f, 0.01912702f, 0.08101011f, -0.03735407f, -0.04699962f, -0.12196349f, 0.01006327f, 
    0.12132972f, 0.06168422f, -0.01115308f, -0.12567832f, -0.01793158f, -0.00371739f, 0.01901591f, -0.08278584f, 
    0.03827456f, -0.17808050f, 0.02421517f, -0.12513514f, -0.13342676f, -0.05429276f, 0.09525206f, -0.20971301f, 
    -0.09673706f, -0.04776989f, 0.05323590f, 0.06048752f, -0.05893472f, 0.04391284f, -0.15835823f, -0.04192876f, 
    0.02252384f, -0.11259663f, -0.39741889f, -0.00466851f, -0.05164554f, 0.02053361f, -0.04162169f, -0.02037747f, 
    -0.06363413f, 0.07987468f, -0.11192530f, -0.05444884f, -0.16602676f, -0.04307654f, 0.10046972f, -0.04751988f, 
    -0.08305801f, -0.10210623f, 0.00178802f, -0.04691503f, -0.00456271f, -0.00429759f, 0.05851562f, 0.08490193f, 
    0.27708656f, -0.10568912f, 0.07530946f, 0.02594291f, 0.06346508f, -0.05544094f, -0.04450867f, 0.09559564f, 
    0.04101253f, 0.02893487f, -0.05242199f, 0.00424573f, 0.09812342f, -0.24273232f, -0.15264294f, 0.09384425f, 
    -0.08698478f, 0.03458176f, 0.03315928f, -0.01938840f, 0.08055922f, 0.01843469f, -0.01685919f, 0.11193421f, 
    -0.14710440f, 0.09067489f, -0.15415454f, -0.01681429f, -0.07760532f, -0.02558569f, -0.06156680f, 0.06098216f, 
    -0.02279087f, 0.05836065f, 0.09594294f, -0.03312348f, -0.23545660f, -0.12459237f, -0.16201404f, -0.14251821f, 
    -0.00701911f, 0.02005446f, 0.01562089f, -0.02837186f, 0.03067864f, 0.03977517f, 0.13282399f, 0.11885056f, 
    0.00103997f, -0.07822361f, 0.07285515f, 0.12061264f, 0.01744894f, -0.05813824f, -0.13042633f, -0.02781015f, 
    -0.11329479f, 0.03251990f, -0.00029572f, -0.16383143f, -0.31809682f, 0.13802207f, 0.18660304f, 0.08340698f, 
    0.12242506f, -0.05027348f, 0.05554540f, 0.14956664f, 0.10121735f, 0.10686304f, 0.06483495f, -0.05930031f, 
    -0.23991553f, -0.00862007f, -0.11309820f, 0.20362142f, 0.06606088f, -0.03918064f, -0.06358065f, 0.08455109f, 
    -0.14539663f, 0.02882529f, 0.06825810f, 0.05907807f, 0.28268880f, -0.09921148f, 0.24902374f, -0.14192913f, 
    0.07183365f, -0.05422237f, 0.11016116f, 0.00699929f, -0.04515872f, 0.01488580f, 0.00761691f, -0.15151565f, 
    0.18538599f, -0.40925446f, -0.01156282f, -0.06636500f, -0.01746881f, 0.13478686f, -0.00723710f, -0.02811311f, 
    0.04425134f, -0.04574232f, -0.07416344f, -0.00155760f, -0.04106015f, 0.12385295f, 0.15737820f, -0.30173454f, 
    0.03727118f, 0.13722080f, 0.03518747f, 0.09836975f, -0.02197218f, -0.05004656f, -0.03270657f, 0.00964886f, 
    -0.06809090f, -0.01842647f, 0.10613600f, -0.17170489f, -0.13637491f, -0.05504035f, 0.05605111f, -0.03076448f, 
    -0.03842373f, 0.06362575f, 0.05562166f, 0.02874203f, -0.03574624f, -0.07668212f, -0.19273753f, -0.08411755f, 
    -0.02501005f, 0.03011181f, -0.06136428f, -0.20072819f, -0.20854278f, -0.03044640f, 0.14610574f, -0.12131979f, 
    -0.31149888f, 0.21234497f, 0.11694233f, 0.01747300f, -0.04029825f, 0.03460386f, 0.11830248f, -0.02890399f, 
    -0.02309372f, 0.10210913f, 0.05429382f, 0.10744314f, 0.09719665f, -0.03311965f, -0.01183712f, -0.12889624f, 
    -0.07851845f, 0.03638820f, -0.01368648f, 0.02295368f, 0.10309129f, -0.09688843f, -0.01486838f, 0.12302754f, 
    0.02138595f, 0.11630128f, 0.16352546f, 0.19201422f, -0.03430218f, 0.06923400f, -0.10402880f, -0.02366760f, 
    0.04412575f, 0.02412558f, -0.00585758f, -0.04432837f, -0.19990981f, 0.06652920f, 0.10405847f, -0.08377694f, 
    0.04437273f, -0.05353975f, -0.06014295f, 0.06135233f, -0.11171668f, -0.02036566f, -0.05014572f, -0.04399001f, 
    -0.44377872f, 0.02937375f, -0.09004688f, 0.12368914f, 0.13545093f, -0.01057901f, -0.00516535f, 0.03471498f, 
    0.06970946f, 0.08009468f, 0.05445058f, 0.08146549f, 0.04581257f, -0.19505256f, 0.00541100f, 0.06804433f, 
    -0.04010656f, 0.03155477f, -0.08064938f, -0.12075887f, 0.01668090f, -0.02804061f, -0.08361498f, 0.06557938f, 
    -0.01653334f, 0.20583916f, 0.08532766f, -0.14028803f, 0.03376636f, -0.00235648f, -0.00481214f, -0.00249690f, 
    -0.04894111f, 0.08580440f, 0.03026493f, -0.00008778f, -0.04680360f, 0.09681286f, 0.19517991f, -0.29871958f, 
    -0.10162933f, 0.04235148f, -0.05845281f, 0.06446013f, -0.02389947f, -0.13762411f, 0.00800568f, -0.05675393f, 
    0.05631329f, -0.18183786f, -0.11432292f, 0.12244138f, 0.10368166f, -0.00662743f, 0.01032411f, -0.04090494f, 
    -0.11706678f, 0.06066493f, -0.03906482f, 0.07580832f, -0.14178355f, 0.01802170f, 0.02420262f, -0.04509464f, 
    0.07227011f, 0.00522006f, 0.01188602f, 0.01128851f, -0.04985716f, -0.10228197f, 0.07676285f, -0.12785763f, 
    0.19541459f, -0.08808067f, 0.03652421f, 0.02961079f, -0.01075650f, -0.01959496f, -0.09032944f, -0.11633696f, 
    -0.03216132f, 0.06516141f, 0.03497383f, 0.00614705f, 0.26747200f, -0.07230067f, -0.15043201f, 0.11525309f, 
    0.03585299f, 0.06894791f, -0.02758224f, 0.03140673f, -0.13786067f, -0.10012379f, -0.01326395f, 0.06095739f, 
    -0.16553685f, -0.08703993f, 0.12235888f, -0.22765031f, 0.13292138f, -0.11462473f, -0.03820511f, -0.03700829f, 
    0.10344143f, -0.02093197f, 0.01626131f, -0.10220416f, 0.02170816f, 0.22307435f, 0.06678699f, -0.18604088f, 
    -0.09533684f, 0.00722134f, -0.03238310f, -0.01996963f, 0.09605999f, -0.02178623f, -0.17074239f, 0.06340816f, 
    0.13103184f, 0.07878878f, 0.12163298f, 0.04661903f, -0.05603280f, -0.02789016f, -0.04791786f, -0.09160795f, 
    -0.01543312f, 0.15385316f, 0.03126247f, 0.03327890f, 0.04685181f, 0.18309067f, 0.01822907f, 0.14299029f, 
    0.09531976f, 0.00537079f, 0.00454992f, 0.09885450f, -0.07624482f, 0.00897494f, 0.10397143f, -0.02590553f, 
    -0.03464765f, 0.01789169f, -0.13710380f, -0.09742174f, 0.00852281f, 0.03156669f, -0.04989481f, -0.07289089f, 
    -0.01414800f, 0.01265425f, 0.02028850f, -0.00639919f, 0.08142130f, -0.04113384f, 0.10723274f, 0.16447955f, 
    -0.00466526f, -0.04900384f, -0.11329918f, -0.06427991f, 0.03887116f, -0.01292109f, -0.06605501f, -0.08907487f, 
    -0.05937963f, 0.11335211f, 0.14880842f, 0.09267622f, 0.08341555f, -0.00083914f, 0.06765424f, -0.00982444f, 
    0.04271715f, 0.01708707f, 0.02356812f, -0.00162558f, 0.25289819f, 0.08908128f, 0.17152183f, 0.00742118f, 
    -0.11959383f, 0.01956239f, -0.02524660f, -0.08781812f, -0.00802241f, 0.04079794f, -0.07513400f, -0.11687489f, 
    -0.08825699f, -0.00146593f, -0.22703114f, -0.06204431f, -0.08383862f, -0.01346029f, -0.03226202f, -0.05174949f, 
    -0.05421330f, -0.02723430f, 0.00570396f, -0.09804872f, 0.02208809f, 0.15207471f, -0.07205343f, 0.13595326f, 
    0.00827615f, -0.02181678f, -0.05357794f, 0.02610827f, 0.03625227f, 0.07201897f, 0.04938339f, 0.00987527f, 
    -0.34302586f, 0.17094871f, -0.01675122f, -0.07771704f, -0.03670067f, 0.00513612f, 0.03291040f, -0.05041943f, 
    -0.07773039f, -0.02198135f, -0.02983044f, 0.03519239f, -0.05073984f, 0.20125698f, 0.00589247f, -0.08838469f, 
    -0.10045607f, -0.02214532f, -0.00020111f, -0.10588629f, -0.03762584f, -0.07161792f, -0.03005110f, -0.12879792f, 
    -0.06639773f, -0.03018218f, 0.02759678f, 0.03958143f, 0.00881111f, -0.01533137f, -0.01146480f, -0.03967941f, 
    -0.02565171f, -0.07218315f, 0.02793201f, -0.01102130f, -0.08651915f, -0.10381325f, 0.03964834f, 0.16067116f, 
    -0.04192946f, -0.00364033f, -0.16127972f, 0.00018059f, -0.10566363f, -0.00146823f, 0.05742522f, -0.00974741f, 
    -0.29104546f, 0.03260142f, -0.08172061f, -0.13650604f, 0.13025121f, 0.07207908f, 0.06456870f, -0.01517268f, 
    -0.01579731f, 0.10448667f, 0.03476619f, 0.04821926f, 0.12054428f, 0.17199565f, 0.08122305f, 0.18947560f, 
    0.15966621f, 0.05587623f, 0.05655845f, 0.02267216f, -0.02904877f, 0.02812754f, 0.07140559f, 0.00977371f, 
    -0.11596370f, 0.00890661f, -0.16811772f, 0.00070318f, -0.00462567f, 0.02823114f, -0.06392597f, 0.02170874f, 
    -0.00827319f, -0.01148456f, -0.00606034f, -0.08527335f, 0.04337934f, 0.05347110f, -0.15760000f, 0.07987687f, 
    0.02882268f, -0.05247699f, -0.08493639f, -0.04629897f, -0.03172005f, -0.04221406f, 0.05499473f, -0.03781836f, 
    -0.02920515f, -0.06962731f, -0.19336735f, -0.15775834f, 0.02204475f, 0.00881999f, -0.04301794f, -0.03495682f, 
    -0.11075075f, -0.00483947f, -0.02813612f, 0.03141567f, -0.12025394f, 0.07414858f, -0.01597831f, -0.18601289f, 
    0.03825506f, 0.04463607f, -0.01822543f, -0.08434414f, -0.04685340f, -0.02757811f, -0.07078404f, -0.02951586f, 
    -0.08993220f, -0.19358587f, -0.22303145f, 0.02583871f, -0.03350087f, -0.12192667f, 0.00319752f, -0.08187318f, 
    -0.12747586f, 0.06134148f, -0.13944547f, 0.01122883f, -0.04699834f, -0.01190504f, -0.36230472f, 0.04734696f, 
    -0.04807116f, -0.11072185f, 0.03811860f, 0.04898142f, -0.00791313f, -0.07975291f, 0.05452684f, 0.02065248f, 
    0.04298846f, 0.10653429f, -0.01510729f, 0.09568429f, 0.01092439f, 0.05695684f, -0.05067520f, 0.04729113f, 
    0.06306361f, -0.01247004f, -0.03168264f, -0.00963007f, 0.11424363f, -0.02254962f, -0.00350141f, 0.09389835f, 
    -0.03622729f, -0.12106611f, -0.09075130f, -0.01107364f, -0.08391473f, 0.04755023f, -0.04677046f, -0.06496740f, 
    0.00201683f, -0.01126793f, 0.16723748f, 0.08048082f, 0.03394204f, -0.04517047f, -0.02719516f, -0.06660636f, 
    -0.06102237f, -0.04235311f, 0.04955401f, -0.12485657f, 0.00452938f, 0.21172158f, 0.11398385f, 0.16644411f, 
    0.09792809f, 0.04186290f, -0.02041038f, -0.08495535f, 0.05528070f, -0.00386017f, 0.01013751f, -0.11112147f, 
    -0.10382827f, 0.04900933f, -0.11032938f, -0.05774755f, -0.01722738f, -0.03163936f, -0.00177382f, -0.02307337f, 
    0.00539211f, -0.00103805f, 0.00422452f, -0.03620594f, 0.00225433f, 0.03415299f, 0.11268044f, 0.02841838f, 
    0.09056830f, -0.02179924f, -0.03859603f, -0.07818225f, -0.07411726f, 0.01513098f, -0.07004136f, -0.05677132f, 
    0.15547001f, -0.18164943f, -0.00270707f, 0.01340626f, 0.00258699f, -0.02026059f, -0.03515544f, -0.02063828f, 
    -0.01119174f, -0.01838803f, 0.01620474f, -0.02187909f, 0.23181108f, -0.13287650f, 0.04823739f, 0.01611807f, 
    -0.08134550f, -0.09144763f, -0.01736122f, -0.04012124f, -0.05137277f, 0.01002168f, -0.02405553f, -0.00650522f, 
    0.17779037f, -0.18348414f, 0.10215829f, 0.05721939f, -0.07560632f, -0.14538531f, 0.01090157f, -0.02993775f, 
    0.01703827f, -0.03163391f, -0.01575566f, -0.01001072f, 0.14803973f, -0.14383920f, 0.14067528f, -0.07090411f, 
    -0.01108561f, -0.00720778f, 0.00345951f, -0.00664673f, -0.01588222f, 0.03332601f, -0.04498639f, 0.05848984f, 
    -0.03863998f, 0.09281509f, 0.11551334f, -0.07365298f, 0.06058365f, 0.10781679f, 0.04862786f, 0.04135631f, 
    -0.11194721f, 0.00267866f, -0.02023983f, 0.02190256f, 0.25115204f, 0.02769042f, 0.04657041f, -0.17674914f, 
    -0.09559184f, -0.03356223f, -0.01068051f, -0.00623307f, -0.04027393f, 0.00014091f, -0.03525239f, -0.03986752f, 
    0.15792251f, -0.23507306f, 0.05881911f, -0.04184712f, 0.00223514f, 0.01954637f, -0.10378085f, 0.00529871f, 
    -0.08613206f, 0.03908577f, -0.07809012f, 0.00879809f, -0.04481902f, -0.11842567f, 0.01652490f, 0.08472399f, 
    0.00667444f, -0.01831006f, -0.01719857f, -0.03848928f, -0.08222470f, 0.00490601f, -0.00988863f, 0.00135581f, 
    -0.04118500f, 0.03280538f, -0.07073868f, -0.08096675f, -0.05901926f, -0.03904001f, -0.06778558f, -0.03823816f, 
    -0.03864172f, -0.00515514f, -0.04815428f, 0.03057154f, 0.07767282f, 0.05866462f, 0.00339534f, 0.03552448f, 
    -0.06029446f, 0.01723195f, 0.00958253f, -0.06322774f, -0.06412040f, 0.02650487f, -0.05630085f, -0.12946661f, 
    0.08815534f, 0.14704221f, 0.06413416f, 0.18227194f, 0.14963420f, 0.00172371f, 0.00326703f, -0.04446052f, 
    -0.00323595f, -0.00031352f, 0.00001137f, -0.05304383f, 0.16527593f, 0.15971020f, 0.09697629f, 0.11571602f, 
    0.11125959f, 0.03633286f, 0.01518793f, 0.00042637f, 0.00604635f, 0.01944926f, 0.06160882f, -0.03928605f, 
    -0.22196615f, -0.07074120f, 0.03177373f, -0.00633270f, -0.02138470f, 0.01325019f, 0.00874755f, -0.06665669f, 
    0.00259384f, 0.09257458f, -0.05199136f, -0.01923465f, -0.05396451f, 0.13423873f, 0.03244247f, 0.00307622f, 
    0.03190840f, 0.02195428f, -0.03431403f, -0.02733209f, 0.03719659f, 0.05910978f, -0.04692768f, -0.02613152f, 
    -0.12266235f, -0.12745242f, -0.07243888f, 0.13622648f, -0.01646226f, -0.01390828f, -0.04832482f, -0.05325617f, 
    -0.07483675f, -0.04327936f, 0.03878805f, -0.10375052f, 0.04953432f, 0.18796398f, 0.14738162f, 0.02300121f, 
    0.03185478f, 0.04529065f, 0.02375896f, -0.09993104f, 0.02417501f, 0.11031982f, -0.01890129f, -0.07556774f, 
    -0.14291289f, 0.07222827f, 0.00109596f, 0.01199472f, 0.01635438f, -0.02759183f, -0.00417641f, 0.02776494f, 
    -0.03270867f, 0.02667380f, 0.02683876f, -0.01510161f, -0.08927219f, -0.12611203f, -0.08521640f, -0.23934039f, 
    -0.03426066f, -0.00205604f, -0.02344177f, -0.02289587f, -0.01021800f, 0.03648940f, -0.03557298f, -0.06092468f, 
    -0.05497314f, -0.10230269f, -0.04867659f, 0.08891046f, 0.03192326f, -0.06033361f, -0.04509442f, -0.00601531f, 
    -0.09159488f, -0.04267514f, 0.02888635f, -0.03181352f, 0.31997448f, -0.21908805f, -0.00698713f, -0.02356325f, 
    0.11850486f, 0.01451474f, -0.06765930f, -0.20011647f, -0.00066713f, -0.03666076f, -0.02678067f, -0.00584614f, 
    -0.09967730f, 0.03511472f, 0.03452283f, 0.03759139f, -0.03611195f, -0.05064166f, -0.03676027f, -0.01394530f, 
    -0.06378779f, -0.04857709f, 0.04090087f, -0.09919459f, -0.03154150f, -0.10871892f, -0.10380740f, -0.06486610f, 
    -0.07164551f, -0.02614872f, -0.11069626f, -0.00665087f, -0.02399096f, 0.04756759f, 0.04287666f, -0.04634429f, 
    -0.06201353f, 0.11235441f, -0.17538106f, -0.12936334f, -0.02366517f, 0.00911125f, -0.09051321f, -0.09013645f, 
    -0.04258836f, -0.00058553f, -0.09511690f, -0.12509120f, 0.13801056f, 0.07530741f, 0.19710600f, 0.19978353f, 
    0.09281987f, 0.13339086f, 0.06439198f, -0.00135907f, 0.05059265f, -0.04336641f, 0.03351616f, -0.01397240f, 
    0.15732011f, 0.03788133f, -0.11152234f, -0.02146459f, 0.01617839f, 0.05752107f, -0.13808507f, -0.04968324f, 
    -0.12928106f, 0.04310839f, 0.02661906f, -0.02051019f, 0.02055357f, 0.02131076f, 0.15454401f, -0.03419521f, 
    0.08383556f, 0.06512943f, -0.00965604f, -0.02562902f, -0.04504316f, 0.07314856f, -0.08851582f, -0.02645489f, 
    -0.08530967f, 0.07204448f, 0.01011938f, 0.03795761f, -0.19173774f, -0.05867270f, 0.04716394f, -0.01048954f, 
    -0.01464674f, 0.02860281f, 0.05467287f, 0.00913532f, 0.09505253f, -0.04232201f, -0.05697566f, -0.09884743f, 
    -0.02798520f, 0.01137880f, -0.04534099f, -0.07068527f, -0.00552525f, 0.09264769f, 0.02212030f, -0.01186240f, 
    -0.15887088f, 0.06302138f, -0.13572745f, -0.06922391f, -0.04407745f, -0.04463977f, -0.03156288f, 0.02291174f, 
    0.02580474f, 0.02712429f, 0.06943028f, -0.14360487f, 0.20043549f, -0.06127433f, 0.10148684f, 0.10684504f, 
    0.01763775f, -0.00140302f, -0.05465734f, -0.04028923f, -0.03203267f, -0.00008550f, -0.04530529f, -0.00337507f, 
    -0.08915757f, -0.07103577f, -0.06214776f, -0.11460481f, 0.01530751f, 0.00159052f, -0.07029011f, -0.03937234f, 
    -0.01508111f, -0.00619916f, -0.00493199f, -0.01347810f, -0.30037412f, 0.09296402f, 0.06972881f, -0.05866494f, 
    -0.01670657f, -0.02637780f, -0.00116481f, -0.01455960f, -0.04654429f, -0.02990102f, 0.00663159f, -0.10714708f, 
    0.13322407f, 0.05199764f, 0.11121394f, 0.15305333f, 0.06052689f, 0.05476262f, 0.08197593f, -0.04513149f, 
    -0.01276562f, -0.02059873f, -0.03717138f, -0.08495256f, -0.01688377f, -0.04116061f, 0.15344100f, 0.01416401f, 
    0.03468380f, 0.03738220f, -0.00664139f, -0.09170713f, -0.09081293f, -0.02515597f, -0.07574209f, -0.00796264f, 
    -0.07282755f, -0.05766211f, -0.13797037f, -0.15170269f, 0.00461196f, 0.02124370f, -0.03444742f, -0.02870230f, 
    -0.15693213f, -0.02253933f, 0.00131994f, -0.07607952f, 0.05666171f, 0.11904604f, -0.01322573f, 0.21256967f, 
    0.03667860f, -0.04614449f, 0.02315616f, -0.04746476f, -0.01678475f, -0.06626531f, -0.01670193f, -0.01618577f, 
    0.22034366f, 0.11846042f, 0.13063930f, -0.01145977f, 0.01713044f, 0.09730026f, 0.01460835f, -0.00828679f, 
    -0.03206941f, 0.07681020f, 0.03587526f, -0.00227415f, -0.41851735f, -0.03365053f, -0.10455364f, 0.03894026f, 
    -0.09663237f, -0.07163835f, -0.01970445f, -0.02243864f, -0.10828563f, 0.03653624f, 0.03092964f, -0.04641768f, 
    -0.01149885f, 0.06680142f, 0.08665096f, -0.07592044f, 0.03460184f, 0.03583059f, -0.11507339f, 0.14438881f, 
    0.00638811f, -0.07342459f, -0.00540579f, -0.13208006f, -0.24305959f, 0.00855113f, -0.01825526f, -0.13597976f, 
    -0.00636276f, -0.11132566f, -0.03341848f, 0.03476808f, 0.01038528f, -0.06704397f, -0.08292691f, -0.03151809f, 
    0.10589722f, -0.04284586f, -0.00181253f, 0.11469609f, 0.02418863f, -0.04293876f, 0.00937337f, 0.00516998f, 
    -0.03632991f, 0.04505794f, 0.01795796f, -0.07323205f, -0.14558585f, 0.07360704f, -0.15806231f, -0.16128005f, 
    -0.06715190f, -0.01396202f, -0.00496075f, -0.02424352f, 0.04758690f, 0.02851447f, 0.03702099f, -0.03808532f, 
    -0.09594133f, 0.09568998f, 0.16323875f, 0.14576752f, -0.11818603f, 0.08489077f, -0.11320674f, -0.11097835f, 
    0.02282513f, -0.08224744f, -0.13462617f, -0.03358553f, 0.01022389f, -0.20305075f, 0.18443204f, -0.14810379f, 
    -0.00333779f, -0.18504646f, -0.01748002f, 0.13334182f, 0.02976301f, 0.04199373f, 0.01422073f, 0.01979391f, 
    -0.09637571f, -0.17622079f, 0.02998370f, 0.12977654f, 0.16687095f, -0.04016198f, 0.05472923f, -0.01509412f, 
    -0.00023452f, 0.00553242f, 0.11093774f, 0.15183005f, -0.15728618f, 0.27754146f, -0.09008120f, -0.20050064f, 
    0.06069601f, 0.08184917f, -0.05983953f, 0.01305411f, 0.17674951f, -0.04259982f, 0.06038351f, 0.00617005f, 
    -0.05908081f, -0.19895598f, 0.05128607f, 0.22697519f, 0.17026311f, -0.03741126f, -0.08798148f, -0.00757417f, 
    0.07135309f, 0.05361874f, 0.14056568f, -0.07438727f, 0.24806745f, -0.05659415f, 0.13304943f, 0.09603529f, 
    -0.09106198f, -0.07353732f, -0.01959748f, -0.03719546f, -0.03248295f, -0.03207027f, -0.03214358f, 0.00554360f, 
    -0.33966196f, 0.01528865f, -0.04951513f, -0.11509374f, -0.11574524f, -0.06654262f, 0.00609949f, 0.00281273f, 
    0.01717011f, 0.05703451f, 0.00419656f, 0.04195679f, -0.21303470f, 0.06517852f, -0.14409792f, -0.08003348f, 
    0.01136990f, 0.05061123f, -0.05204578f, 0.02176856f, 0.03860690f, 0.03842583f, -0.04010077f, -0.02974353f, 
    0.10415203f, 0.02476384f, -0.05629017f, 0.03583110f, 0.07227665f, -0.03229091f, 0.03244451f, 0.06181560f, 
    0.02367743f, -0.09321540f, 0.04338605f, 0.07337246f, -0.05862944f, 0.04532851f, 0.06761485f, -0.21301121f, 
    -0.06792855f, 0.06323728f, 0.04999743f, -0.08684230f, 0.09408720f, -0.23804879f, -0.03882550f, -0.15205131f, 
    -0.12026980f, 0.00352403f, -0.01951003f, 0.00113645f, -0.00029643f, 0.15469192f, 0.10017585f, -0.13061869f, 
    0.05148493f, 0.10290547f, 0.05418172f, 0.00274594f, -0.23121260f, 0.13460578f, -0.07036789f, -0.10035157f, 
    -0.04773950f, 0.05259254f, -0.24005593f, -0.00678095f, 0.06415733f, -0.06533359f, 0.06670500f, 0.05231053f, 
    0.14615975f, 0.10814410f, -0.22338326f, -0.15574561f, 0.01720670f, -0.04211847f, 0.02036272f, -0.01778029f, 
    0.04137473f, -0.00774421f, -0.09297925f, 0.01324879f, 0.10634463f, -0.07866374f, -0.03116211f, 0.14982036f, 
    0.09107122f, -0.00454607f, -0.06817365f, 0.00889815f, 0.00021759f, -0.00122710f, 0.06416550f, -0.06892681f, 
    -0.03026191f, -0.09268356f, -0.11190669f, 0.05205667f, 0.04897670f, 0.02276113f, 0.08432639f, -0.02123089f, 
    0.10199814f, -0.03704503f, 0.02534151f, 0.03448125f, 0.13018158f, 0.21180223f, -0.19367325f, -0.10712734f, 
    -0.13143268f, 0.04402599f, -0.02869635f, 0.01831298f, 0.05520101f, 0.02276730f, 0.00539305f, 0.00402620f, 
    -0.02091783f, 0.15319264f, 0.07279242f, -0.17211035f, -0.09328309f, 0.02961689f, 0.06967632f, -0.11848028f, 
    -0.06667129f, -0.05221298f, -0.05708535f, -0.09537931f, -0.00356989f, -0.15409672f, -0.15755552f, -0.32185516f, 
    0.02557961f, -0.04308228f, 0.04437456f, -0.01390816f, 0.09342708f, 0.12046019f, -0.05767330f, -0.04497921f, 
    -0.12085172f, -0.02546033f, 0.03076622f, -0.01829660f, -0.04358453f, -0.00801074f, 0.08583041f, 0.00983486f, 
    0.13378307f, 0.05961740f, -0.19853951f, 0.13453573f, 0.04583127f, 0.27828845f, 0.00919915f, 0.06990098f, 
    0.08666150f, -0.03742968f, -0.02744409f, 0.08313434f, -0.12949081f, -0.04289331f, -0.10355864f, 0.07450339f, 
    0.09160787f, 0.07976266f, -0.08712061f, 0.07098231f, 0.03115313f, 0.04731283f, -0.01765583f, -0.01646181f, 
    0.06516146f, -0.12813905f, 0.06127539f, 0.02410290f, -0.19300982f, -0.06315613f, 0.09962016f, -0.18320373f, 
    -0.03152809f, -0.01209804f, -0.14349942f, -0.02393928f, 0.02326754f, -0.16997875f, -0.05763232f, -0.06455734f, 
    0.21346806f, 0.04057354f, 0.01753193f, 0.10637727f, -0.00517222f, -0.05930966f, 0.02491334f, -0.04146350f, 
    0.00173371f, 0.01175200f, -0.07284617f, -0.03180698f, -0.18338749f, -0.17183244f, 0.01989309f, -0.14090106f, 
    0.05823561f, -0.00899351f, 0.00533516f, -0.04697520f, -0.03594555f, -0.06872549f, -0.00567832f, 0.09954313f, 
    -0.07248736f, -0.08852066f, -0.21110794f, -0.10528689f, -0.05316601f, -0.09127144f, 0.03513556f, -0.05372270f, 
    0.06216314f, 0.06894904f, 0.05699644f, 0.03094091f, -0.04887665f, -0.09582411f, -0.03844538f, 0.00726066f, 
    0.07419284f, -0.04335583f, 0.05715770f, -0.09023905f, 0.01052997f, -0.01470445f, 0.00694495f, 0.05105996f, 
    -0.08606557f, -0.12980254f, 0.06597994f, 0.00787750f, -0.05175089f, 0.01619900f, 0.01607630f, -0.08014526f, 
    0.07835677f, -0.09290477f, 0.06393671f, -0.03339363f, -0.07865585f, 0.13249865f, -0.09530516f, -0.07621991f, 
    0.02403050f, -0.12821373f, 0.02002792f, 0.04996768f, 0.00052714f, -0.05004654f, -0.00623313f, -0.01881422f, 
    0.07450247f, -0.13205853f, 0.07263838f, 0.03861829f, 0.01217031f, 0.01567043f, -0.02756389f, -0.03412819f, 
    0.10163299f, 0.03057174f, -0.08149808f, -0.11975656f, 0.09574210f, -0.04215572f, -0.13813257f, 0.12983319f, 
    0.09652306f, -0.00934184f, -0.05343866f, -0.03291557f, 0.01332123f, 0.06258097f, -0.04930910f, -0.00696856f, 
    -0.08257507f, 0.05575683f, -0.13063738f, -0.12727965f, -0.08100028f, -0.10686674f, 0.05576105f, 0.03026397f, 
    0.05787803f, 0.12681474f, -0.00687624f, -0.00967340f, 0.03806878f, 0.04988005f, 0.09054900f, 0.04748079f, 
    -0.11734399f, -0.03416685f, 0.06194287f, -0.01723775f, -0.03163026f, 0.02456233f, 0.04226266f, -0.04430944f, 
    -0.13929376f, 0.06302999f, 0.00915525f, -0.12673043f, 0.01332768f, 0.01509652f, -0.05885483f, -0.02813952f, 
    -0.02812601f, -0.03163100f, 0.10638855f, -0.00980471f, -0.18286318f, -0.03141931f, 0.12485436f, -0.02151512f, 
    -0.03105405f, -0.07552344f, 0.02729978f, 0.03849909f, -0.03655675f, -0.10905604f, -0.10707293f, 0.02103719f, 
    0.03411546f, 0.12996370f, -0.08311090f, -0.00427837f, -0.08274462f, -0.07953374f, -0.00323329f, -0.04876403f, 
    0.08589645f, -0.02557370f, 0.01939107f, 0.10479416f, 0.08159602f, -0.10144570f, 0.11781932f, 0.11795100f, 
    -0.01461003f, -0.00283649f, -0.07262332f, -0.00695201f, -0.00994005f, -0.04544437f, 0.14024311f, -0.16512577f, 
    -0.15602303f, 0.01241486f, -0.07316383f, -0.07268073f, -0.01937140f, 0.00358311f, -0.07192992f, -0.01317383f, 
    0.06184518f, 0.09549077f, -0.05133122f, -0.02446770f, 0.01301228f, 0.11841603f, 0.08565568f, 0.14355294f, 
    -0.17944840f, 0.07356867f, -0.15515266f, 0.05805980f, -0.00182037f, -0.07542922f, 0.00231721f, -0.06903955f, 
    -0.01027142f, -0.00770850f, 0.05509824f, -0.10945926f, 0.07525238f, -0.04153469f, -0.07106391f, 0.01483784f, 
    0.03903196f, 0.05502788f, 0.04799404f, -0.00476103f, 0.07675359f, -0.07703811f, -0.11633217f, 0.05131169f, 
    0.13065183f, 0.02616076f, -0.06174597f, -0.06428371f, -0.06362756f, 0.03403919f, -0.06054951f, 0.14738673f, 
    0.17061870f, 0.08179535f, -0.15887800f, -0.21617651f, 0.02446486f, -0.01494497f, -0.03128677f, 0.02572650f, 
    0.08204143f, 0.04416620f, 0.00473651f, -0.01076644f, 0.12379065f, -0.18538027f, 0.05304357f, -0.02215085f, 
    0.03127814f, -0.08017386f, -0.04422447f, 0.00824507f, 0.09832477f, 0.09101568f, -0.01024345f, -0.05118546f, 
    -0.07608578f, -0.07245715f, 0.04925534f, 0.01182988f, -0.06405511f, -0.16047196f, -0.07989497f, 0.05730420f, 
    -0.03332500f, 0.17477138f, 0.01556003f, -0.00934924f, -0.20690002f, -0.18058029f, -0.07229988f, -0.04732154f, 
    0.01454544f, -0.08391120f, 0.07660183f, -0.09188281f, 0.03164039f, 0.10469352f, -0.04815029f, -0.04730877f, 
    0.03087820f, -0.02296102f, 0.10458427f, 0.11447725f, 0.04462955f, -0.02889096f, -0.02740754f, -0.08736727f, 
    -0.02834583f, 0.01940338f, -0.08343196f, -0.07363335f, 0.04762574f, -0.06827187f, 0.05609211f, 0.00739222f, 
    -0.02440077f, 0.02802518f, 0.01730040f, -0.01769346f, 0.01759835f, 0.05299994f, 0.00679832f, 0.07829172f, 
    -0.14684525f, -0.19050376f, -0.01688136f, -0.16496500f, 0.01927674f, -0.10682965f, -0.03307759f, 0.09425942f, 
    0.04293802f, -0.01171971f, 0.04138283f, -0.03401969f, -0.17837641f, 0.02620309f, 0.21378541f, 0.03924311f, 
    -0.06515127f, -0.03048290f, -0.05781193f, 0.01362205f, -0.00647462f, -0.03842764f, 0.00753629f, 0.04459715f, 
    0.18575865f, -0.09617732f, -0.23270580f, -0.06903051f, 0.08566145f, -0.12744759f, -0.00718569f, -0.12029022f, 
    -0.01290807f, -0.01133449f, 0.17028545f, -0.00509879f, 0.05382081f, 0.09102463f, 0.05507708f, 0.11914514f, 
    0.04920763f, 0.06001086f, -0.10212076f, -0.05213401f, 0.06827127f, 0.11188656f, -0.06250194f, -0.00899233f, 
    0.01048082f, 0.20869146f, -0.04280251f, 0.09666659f, 0.04283425f, -0.04770849f, 0.00543293f, 0.05413547f, 
    -0.11221030f, -0.12675789f, -0.16781823f, 0.10395272f, -0.01671401f, -0.06379167f, -0.05736501f, -0.18914185f, 
    -0.02486997f, 0.01907787f, -0.09496644f, -0.13035257f, 0.03014866f, 0.07613809f, 0.03390716f, -0.10847303f, 
    0.13983922f, -0.12847143f, -0.03075704f, 0.16122726f, 0.16402699f, 0.06228898f, -0.07154428f, -0.07754991f, 
    0.04230917f, -0.10385341f, 0.03954552f, 0.02544473f, -0.06373767f, -0.02335099f, -0.06494150f, 0.13458337f, 
    0.11352526f, -0.04475889f, -0.04257127f, -0.04745116f, 0.03888826f, 0.10033553f, 0.05605630f, -0.05898211f, 
    0.10557470f, -0.01726687f, -0.07240040f, -0.13739847f, 0.06039872f, -0.05016725f, 0.09572888f, -0.03450621f, 
    0.04489860f, -0.02733739f, 0.00673580f, 0.03545492f, -0.12675665f, -0.06693234f, 0.07160769f, -0.16218612f, 
    0.01897371f, 0.02198192f, -0.03597067f, -0.01368606f, 0.03973169f, -0.03964560f, 0.03270707f, 0.12032560f, 
    0.05460263f, -0.05374603f, 0.04937517f, 0.07053383f, -0.06287748f, -0.02809289f, 0.02532023f, 0.08124392f, 
    0.02260172f, -0.01606107f, 0.02187886f, -0.14984201f, 0.14143653f, 0.17459367f, -0.16165559f, -0.18928879f, 
    0.07369184f, -0.11655678f, -0.08038584f, -0.02873278f, -0.00630551f, -0.05996666f, 0.03296883f, 0.05105342f, 
    -0.27158707f, 0.06260133f, 0.15048942f, -0.14517191f, -0.06016008f, 0.01606333f, 0.06349141f, 0.07211680f, 
    0.01245840f, -0.05082030f, -0.03554124f, 0.01328073f, -0.06195506f, -0.18672797f, -0.13010991f, 0.01622099f, 
    0.11548730f, 0.10770636f, -0.10909583f, -0.06505578f, -0.07202048f, 0.10063346f, 0.01104149f, 0.00455884f, 
    0.00960967f, -0.17437167f, 0.06279265f, -0.00633789f, -0.02940361f, -0.00196806f, 0.16201755f, -0.06846920f, 
    -0.11239181f, 0.17636794f, -0.09294502f, 0.17556064f, -0.23270085f, -0.18080574f, -0.05027716f, 0.17468818f, 
    0.11881142f, -0.00590894f, 0.08574246f, 0.08174159f, -0.03387738f, -0.06476318f, 0.10103865f, -0.09423486f, 
    -0.29748246f, 0.26546347f, 0.02184231f, 0.09995957f, 0.01963026f, 0.01823116f, -0.08631979f, -0.05704543f, 
    0.00833843f, 0.07274007f, -0.01411117f, -0.06464502f, -0.11103661f, -0.05844465f, 0.03668531f, -0.12456840f, 
    0.08774903f, 0.07036803f, 0.01305430f, 0.05602568f, -0.01648441f, 0.05517612f, -0.10629452f, -0.07596728f, 
    0.12500536f, -0.40306130f, 0.08760985f, -0.06131042f, 0.05960674f, -0.01815809f, 0.03378440f, 0.14061958f, 
    -0.11157033f, -0.00447246f, -0.00933251f, 0.06248629f, 0.03958266f, -0.03881424f, -0.09496619f, 0.07578907f, 
    -0.09946004f, 0.04812394f, 0.02390100f, -0.06871677f, 0.03043931f, -0.02420693f, -0.02713542f, -0.03294090f, 
    -0.10542846f, 0.24983597f, 0.08021619f, -0.13465609f, 0.10351171f, -0.03589633f, 0.05192503f, -0.01795745f, 
    0.05821809f, 0.01694738f, -0.12737335f, 0.00670235f, -0.25636467f, 0.07783148f, 0.33350286f, 0.01280050f, 
    0.06785932f, 0.08252461f, -0.02616690f, 0.01555197f, 0.04854319f, -0.12703419f, -0.08260623f, -0.00181494f, 
    -0.30576155f, 0.14625859f, 0.05922297f, -0.23118810f, -0.04133660f, -0.01456318f, -0.07325537f, 0.03301622f, 
    -0.13754748f, -0.04345892f, -0.12083405f, -0.15507674f, -0.55927634f, 0.28716469f, -0.11312442f, 0.02113044f, 
    0.18915753f, -0.03627161f, 0.02041716f, -0.09176058f, -0.06211818f, -0.02975971f, 0.08476789f, 0.07769846f, 
    0.04385111f, 0.13316254f, -0.26725051f, -0.04879476f, 0.00929577f, -0.01559687f, 0.00925533f, -0.13143025f, 
    -0.00663040f, -0.02615294f, -0.06557316f, 0.00472153f, -0.11256653f, -0.04874997f, 0.07848464f, -0.14285865f, 
    -0.08199217f, 0.09224406f, -0.03123759f, 0.02675947f, 0.16272351f, 0.02929305f, 0.03620474f, -0.00063562f, 
    0.16157752f, 0.12349767f, 0.16417821f, -0.10924137f, 0.11021512f, 0.05149785f, 0.01387561f, -0.04315298f, 
    -0.02391166f, 0.14870395f, -0.02358548f, -0.16353810f, -0.29861179f, -0.05834126f, 0.01963714f, -0.11935302f, 
    0.03269624f, -0.04471531f, -0.05895548f, -0.05604351f, 0.06604509f, 0.06461983f, 0.17131121f, 0.17180435f, 
    0.10703865f, 0.18812904f, -0.21778052f, -0.12784044f, -0.01606701f, -0.09261302f, 0.01442197f, 0.00190648f, 
    0.01760851f, 0.15326996f, 0.14402512f, 0.04307787f, -0.24479680f, 0.22802618f, 0.02760222f, 0.07201179f, 
    -0.01451470f, -0.08378479f, -0.13894503f, -0.02500401f, -0.00356442f, 0.09667486f, -0.17413834f, -0.06059316f, 
    0.47138852f, 0.06044987f, 0.21249239f, -0.09316145f, -0.04616680f, 0.11218841f, 0.04730579f, -0.03548894f, 
    -0.10133322f, -0.05898990f, -0.04260693f, -0.00360130f, -0.10592072f, 0.07171147f, 0.07093585f, -0.05125711f, 
    0.10359837f, 0.06504879f, 0.06528001f, -0.15976529f, -0.02114264f, 0.01420298f, -0.11554692f, -0.03650695f, 
    -0.17532665f, 0.20575809f, -0.18767279f, -0.38915175f, 0.14688037f, 0.11956812f, -0.01830173f, 0.04717011f, 
    -0.00100617f, 0.01342508f, 0.04998992f, 0.04409783f, 0.35489860f, 0.20294504f, 0.04385807f, 0.21875241f, 
    0.01612493f, 0.03346267f, 0.00079096f, 0.03246299f, -0.09759491f, 0.04627809f, -0.08309764f, 0.08397443f, 
    0.45540625f, 0.05066262f, -0.00118300f, -0.05873702f, 0.11371224f, -0.13940062f, 0.04305926f, 0.12862653f, 
    -0.02474194f, 0.03285557f, 0.00000724f, 0.09889736f, 0.05882392f, 0.12968740f, -0.14625242f, -0.17610537f, 
    0.00938148f, -0.02518179f, 0.05433616f, -0.11893962f, -0.06909030f, -0.08282001f, -0.10992969f, 0.00491228f, 
    -0.18538238f, -0.28263524f, 0.05033278f, 0.09008044f, -0.06344835f, 0.06943081f, -0.01556763f, -0.06776480f, 
    0.06838471f, -0.04729171f, 0.02488389f, -0.10406572f, -0.17136982f, -0.13971190f, 0.12253668f, -0.13904653f, 
    0.03702553f, 0.02869831f, -0.12009455f, 0.10167173f, 0.06081314f, -0.01981398f, -0.01119251f, -0.03687628f, 
    -0.12238370f, 0.20437890f, -0.01474075f, -0.01688423f, 0.00937740f, 0.04729309f, 0.04118580f, -0.06007384f, 
    -0.16143347f, 0.03746702f, -0.05718906f, -0.02651794f, -0.10621002f, -0.13187310f, 0.05855481f, 0.09936433f, 
    -0.13207369f, -0.00993011f, 0.05623085f, -0.01350676f, -0.09548608f, 0.01660470f, -0.01284104f, 0.02495351f, 
    0.08096249f, -0.21243338f, 0.01607606f, -0.07745913f, 0.01641240f, 0.02440795f, 0.06216778f, -0.20357344f, 
    -0.06663788f, -0.01654448f, -0.06734455f, -0.10324198f, -0.06366615f, 0.18169050f, -0.13536771f, 0.00797672f, 
    -0.01655035f, -0.04979775f, -0.00550567f, 0.01285367f, -0.05067645f, -0.03349946f, 0.05697779f, 0.05572836f, 
    0.12224060f, -0.07548528f, -0.04455150f, -0.00855663f, -0.16620611f, 0.00772301f, 0.04836126f, 0.11550841f, 
    0.00508990f, -0.04626165f, -0.05080551f, -0.05490038f, 0.13351122f, -0.12864687f, 0.03880028f, -0.00020265f, 
    -0.13980579f, 0.05978931f, 0.02715822f, 0.01036887f, 0.08907971f, -0.00738486f, 0.00664908f, 0.01019137f, 
    -0.02925061f, -0.31598285f, 0.16665384f, -0.08994541f, -0.00190622f, -0.07293709f, 0.03449624f, 0.03058298f, 
    -0.12796335f, 0.07838564f, 0.04953661f, 0.17702521f, -0.41460669f, 0.07206479f, -0.07400788f, -0.02929970f, 
    0.00658695f, -0.05241399f, -0.02011813f, -0.02099949f, -0.01266610f, 0.02925233f, 0.15131214f, 0.10386860f, 
    0.08300767f, -0.18123944f, 0.07951783f, -0.03488353f, 0.03758814f, 0.02222069f, 0.01367226f, -0.13923672f, 
    0.01607870f, 0.02002330f, 0.00391896f, 0.10821772f, 0.10998840f, -0.14302529f, -0.00040921f, -0.33335611f, 
    0.03702328f, 0.02805467f, -0.16314113f, 0.07210241f, -0.02989864f, 0.02634378f, 0.00588692f, -0.00369364f, 
    -0.23200758f, 0.02670598f, -0.03421975f, -0.04752163f, 0.03594103f, 0.06117389f, 0.03955640f, -0.06260017f, 
    -0.03278248f, 0.00089490f, 0.00101948f, 0.00390807f, 0.09517423f, 0.13105458f, 0.02662515f, -0.00454914f, 
    0.12744124f, -0.01310824f, 0.03780274f, 0.09101188f, 0.05339254f, 0.01147936f, 0.02316835f, 0.07353096f, 
    -0.19636086f, -0.29914734f, 0.06692512f, 0.07138062f, 0.03570100f, 0.01990818f, -0.07121100f, -0.06958573f, 
    -0.09571483f, -0.04582960f, -0.09211606f, -0.03039845f, -0.03776065f, -0.01088262f, 0.02638741f, 0.13846518f, 
    0.02443779f, -0.01637720f, -0.10865666f, 0.07177935f, -0.02262806f, -0.03634726f, 0.10197672f, 0.02136070f, 
    -0.01403102f, 0.20018058f, -0.39857319f, 0.22690949f, 0.12164860f, 0.02336469f, -0.02675938f, -0.01761923f, 
    -0.17312931f, -0.01261237f, -0.02280473f, -0.13346766f, -0.14458925f, -0.18491037f, 0.05594185f, -0.11147339f, 
    0.08752561f, -0.07597028f, 0.02031879f, 0.06512243f, -0.01985603f, 0.21094194f, 0.05108280f, 0.12393243f, 
    -0.09379990f, -0.17244796f, -0.24579640f, 0.12135940f, 0.05384947f, 0.12963682f, 0.01166205f, -0.03487444f, 
    -0.00455342f, -0.03528132f, 0.07594483f, -0.02802521f, -0.22329918f, -0.24093610f, 0.06937218f, 0.01438673f, 
    0.11168732f, 0.04936772f, -0.01562531f, 0.10353959f, -0.04963301f, 0.07909853f, -0.08749212f, 0.01719092f, 
    -0.18503726f, 0.01717385f, 0.13753147f, 0.07472637f, 0.00583229f, 0.07254121f, 0.00517084f, 0.02544019f, 
    -0.09092143f, -0.18929562f, -0.19644541f, 0.04222863f, 0.09016748f, -0.00943518f, 0.17663988f, -0.00686379f, 
    0.08682985f, -0.04635879f, -0.05623574f, -0.03525363f, 0.06747052f, -0.07333363f, 0.06175739f, 0.03998715f, 
    0.21117795f, 0.07317239f, 0.18082075f, 0.01249016f, -0.06400971f, 0.01477977f, 0.02227370f, -0.06862590f, 
    0.03129815f, -0.01541947f, 0.11170821f, 0.02340116f, 0.17183085f, -0.01966148f, 0.12492634f, 0.26899567f, 
    0.01887767f, 0.06220976f, -0.00478117f, -0.12240511f, 0.07984035f, -0.01916725f, 0.00648068f, 0.02202834f, 
    0.30519620f, 0.18800959f, -0.33509976f, -0.10561243f, 0.01827927f, -0.10795077f, -0.00504191f, 0.12945567f, 
    0.03481891f, -0.06964659f, -0.00346783f, 0.00182230f, -0.01608370f, 0.01817484f, -0.00571096f, -0.17057340f, 
    -0.00599792f, -0.04686010f, -0.13568483f, 0.10051552f, 0.06173850f, 0.01735255f, -0.07352774f, -0.05709178f, 
    0.05735004f, 0.06651301f, -0.14893399f, -0.27564296f, 0.16438690f, 0.00413870f, -0.02531699f, -0.04399756f, 
    -0.01469545f, -0.04989549f, 0.05122479f, 0.01902923f, 0.03207837f, -0.07700673f, 0.03058945f, 0.13180161f, 
    -0.02267559f, -0.11365287f, 0.01457278f, -0.06950443f, -0.10233985f, 0.04487447f, 0.03152413f, -0.06022234f, 
    -0.14625445f, 0.17083584f, -0.18131989f, 0.03214961f, -0.11196939f, 0.02980512f, -0.08585948f, 0.04427825f, 
    0.07665903f, 0.07712440f, 0.10927997f, 0.01333759f, 0.06140187f, -0.20618731f, -0.10078356f, 0.09990019f, 
    0.07913023f, 0.07638001f, -0.05089951f, -0.08022500f, 0.00722482f, 0.12485183f, 0.04002199f, -0.15525883f, 
    -0.44875476f, 0.09807106f, 0.12154987f, -0.05964012f, 0.07185407f, 0.04625534f, 0.10169116f, -0.00323595f, 
    -0.00935468f, 0.10050583f, 0.05328611f, -0.03253305f, 0.14209871f, -0.04034376f, -0.25252050f, -0.23993431f, 
    0.15189259f, -0.01658463f, -0.10823430f, -0.07212075f, -0.09704335f, 0.01837653f, -0.13531919f, -0.03188156f, 
    -0.02467105f, 0.22230525f, 0.16889040f, 0.09279256f, -0.16698596f, 0.03658992f, -0.01183242f, 0.19442439f, 
    0.08102926f, 0.10673276f, 0.11981098f, -0.10238052f, 0.44346690f, -0.36938736f, -0.11345988f, 0.04319958f, 
    0.00240217f, -0.07655607f, 0.11428032f, 0.06854139f, 0.05560767f, 0.03590259f, -0.04311065f, -0.00231167f, 
    -0.11640145f, -0.08938394f, -0.07560587f, -0.14158021f, 0.07148130f, 0.03188649f, 0.04090763f, -0.07726451f, 
    -0.12773779f, -0.05523469f, -0.04224562f, 0.00891014f, -0.32204628f, 0.02044228f, -0.24516761f, -0.00978085f, 
    -0.10412221f, -0.04268622f, 0.13884744f, -0.00653277f, -0.06513313f, 0.00443786f, -0.07624348f, -0.03913282f, 
    0.06437702f, -0.06779409f, -0.04940088f, 0.03994722f, 0.11576690f, 0.03422108f, -0.04797098f, 0.04640362f, 
    -0.03453789f, -0.06469020f, -0.01059848f, 0.13395661f, 0.06603214f, -0.08247369f, -0.04645852f, 0.21611498f, 
    0.01122127f, 0.09301215f, 0.01439811f, -0.08601555f, 0.03049346f, 0.09431213f, -0.08515376f, 0.05589502f, 
    -0.11540776f, 0.12744603f, -0.08393674f, -0.15894558f, -0.04110667f, 0.06344477f, 0.05976796f, -0.00696777f, 
    -0.03241138f, 0.00887853f, -0.07303342f, 0.08324613f, -0.39774066f, -0.09795383f, 0.04205911f, 0.03713775f, 
    0.07564034f, 0.02209848f, -0.13628164f, 0.06109107f, 0.12796886f, -0.08009708f, 0.05815770f, -0.02365862f, 
    0.08116229f, -0.13218223f, -0.06181462f, 0.23059802f, -0.24149451f, 0.04863869f, -0.08471140f, 0.12349377f, 
    -0.06088518f, 0.04734947f, -0.02680301f, 0.02463005f, -0.10886414f, 0.08045346f, -0.03444723f, -0.36457366f, 
    0.07119123f, -0.02437735f, -0.06570697f, 0.04830829f, 0.01477178f, -0.00837676f, -0.00450058f, -0.10703755f, 
    0.00635774f, 0.09302330f, 0.06670502f, 0.11648412f, 0.04181661f, 0.13434602f, -0.03011592f, 0.03940175f, 
    0.02798361f, 0.04962849f, 0.07490039f, -0.03504338f, -0.03100112f, 0.05923434f, 0.06736016f, -0.03707703f, 
    0.10396682f, -0.17408247f, 0.09277924f, -0.14916855f, 0.06377236f, -0.00951430f, -0.05457523f, -0.01900581f, 
    -0.39497364f, -0.42908299f, -0.05282145f, -0.09551536f, -0.08688670f, 0.05543494f, 0.05062680f, -0.13600382f, 
    0.06080446f, -0.04883762f, -0.09182706f, -0.02226742f, 0.32228220f, 0.03731345f, 0.04066723f, -0.12382009f, 
    -0.01605367f, -0.01061285f, -0.00698182f, -0.01410765f, -0.07039777f, 0.01448025f, 0.08316434f, 0.05672350f, 
    0.19661330f, 0.06649972f, 0.00199793f, -0.02726197f, -0.10605216f, -0.09839580f, -0.06782524f, -0.05482028f, 
    -0.01592575f, 0.01345459f, -0.04264452f, -0.04575878f, 0.07337296f, 0.02168436f, 0.08863256f, 0.06903958f, 
    -0.00724131f, 0.01044145f, 0.03973105f, 0.02234795f, -0.10508882f, 0.07486899f, 0.06230162f, 0.12909707f, 
    -0.05044924f, -0.27416229f, -0.05585119f, -0.09649071f, 0.08420256f, -0.27181104f, 0.03009990f, -0.01107008f, 
    -0.06041615f, -0.00650955f, 0.09020083f, 0.07979854f, -0.28793970f, -0.26821321f, 0.17989667f, 0.02797511f, 
    0.03235384f, 0.09599502f, -0.03898944f, -0.08128098f, 0.03477430f, -0.08507319f, 0.05908836f, 0.06844322f, 
    -0.54767638f, -0.25528130f, -0.05927296f, -0.33227310f, 0.07876053f, -0.06666361f, -0.13103586f, 0.03505000f, 
    0.08902434f, 0.00064115f, 0.03613800f, 0.01457242f, -0.09408043f, -0.23518331f, -0.12700753f, -0.04515991f, 
    -0.07739326f, -0.04665013f, 0.02427022f, -0.03659132f, -0.02059840f, -0.07933710f, -0.19896626f, 0.00390652f, 
    0.10195379f, 0.01301726f, -0.04723715f, -0.02635633f, 0.03181132f, 0.00580242f, -0.01187248f, 0.00076330f, 
    -0.08051972f, 0.04756703f, 0.14498152f, 0.00511608f, 0.35423118f, 0.06338821f, 0.04221084f, -0.01329905f, 
    0.16166405f, -0.10710717f, 0.13035804f, 0.03426167f, 0.07514714f, -0.07039126f, -0.10419332f, 0.07943036f, 
    -0.48737741f, -0.23424943f, -0.09028616f, 0.03349007f, 0.09525432f, 0.04978631f, -0.04150010f, -0.03342189f, 
    0.02306767f, -0.01665810f, 0.05108125f, 0.11806162f, -0.16526809f, 0.10518714f, -0.06811025f, -0.10014151f, 
    -0.25279722f, -0.00097323f, -0.00871678f, -0.12139741f, 0.05143100f, -0.16086777f, -0.20925322f, -0.20338495f, 
    0.09834261f, 0.02264500f, 0.03628936f, 0.02216802f, 0.08237823f, 0.01737633f, 0.00302689f, 0.05266139f, 
    -0.01877115f, -0.08069958f, 0.00731090f, 0.00961182f, -0.24091849f, -0.16119093f, 0.14965588f, 0.15275520f, 
    0.05153971f, 0.06317248f, -0.00398446f, 0.07295227f, 0.00157890f, 0.02476010f, 0.06196690f, 0.05857834f, 
    -0.37910467f, -0.13041016f, 0.14311150f, 0.19687545f, 0.13983101f, 0.03088157f, -0.00936704f, -0.06965436f, 
    -0.01363386f, 0.09168128f, -0.12220304f, 0.15070377f, -0.29196802f, -0.12693001f, -0.05552078f, -0.19350183f, 
    0.05502518f, 0.05655704f, -0.15797304f, -0.06977304f, -0.03549894f, -0.07950340f, 0.03605105f, 0.03755888f, 
    -0.02303477f, 0.10517552f, 0.01846005f, -0.05026817f, 0.09300124f, -0.00498817f, 0.03982834f, 0.00104233f, 
    0.04537450f, -0.01356638f, 0.10905807f, -0.02446315f, -0.17814498f, -0.21984711f, -0.02024779f, 0.13052575f, 
    -0.01060076f, 0.04067184f, -0.08307276f, -0.00794059f, 0.13864335f, 0.02136048f, 0.01735539f, -0.03950519f, 
    0.12716894f, 0.05094199f, 0.13379402f, -0.06222444f, -0.16030762f, -0.03309690f, 0.10747211f, 0.04217641f, 
    0.14936365f, 0.07538769f, -0.00950348f, 0.01034715f, 0.23561952f, 0.16385494f, 0.00642721f, 0.02457056f, 
    0.03963625f, 0.06122250f, 0.00153420f, 0.04930517f, 0.01222562f, 0.04436931f, 0.07528041f, 0.02753384f, 
    0.17265277f, 0.07981163f, 0.01579578f, 0.09675787f, -0.06437469f, -0.15782884f, 0.12458704f, -0.02459291f, 
    0.12656945f, 0.14876774f, 0.09045004f, 0.10758463f, 0.02909424f, -0.06752954f, -0.05842808f, 0.03328539f, 
    -0.03062801f, -0.09816635f, -0.02029165f, -0.02981223f, -0.03712054f, 0.02029340f, -0.10754549f, 0.08713481f, 
    -0.26824659f, -0.22211759f, 0.06401773f, 0.16071741f, 0.01414636f, 0.04672042f, 0.06076670f, 0.05856873f, 
    0.14299265f, 0.10817530f, 0.12183625f, 0.04502399f, 0.13589509f, 0.10694152f, -0.03367218f, 0.01152853f, 
    0.02948889f, -0.03146283f, 0.03937053f, -0.09091103f, -0.02198887f, -0.13054177f, 0.04672628f, -0.11100140f, 
    0.08937082f, -0.03120042f, -0.10728320f, -0.05883494f, -0.01833765f, 0.05531661f, 0.00049052f, 0.07542217f, 
    0.04151010f, 0.07551543f, 0.09319994f, 0.03464943f, 0.13704792f, 0.21176913f, 0.08673120f, -0.06293497f, 
    0.19050913f, 0.08403788f, 0.01321431f, 0.07266506f, 0.05790706f, 0.00899318f, 0.06128362f, -0.01960805f, 
    0.09885505f, 0.03637368f, -0.04974695f, 0.03003020f, -0.04739278f, 0.00124327f, 0.12483908f, 0.07688836f, 
    0.01735720f, -0.05207071f, 0.03863223f, 0.04642488f, 0.21152461f, -0.06295420f, -0.08872074f, 0.01790955f, 
    -0.04678324f, -0.05205688f, 0.01414651f, 0.03431824f, 0.05391189f, 0.11427595f, -0.09714846f, 0.01187728f, 
    0.14068946f, -0.00616835f, -0.09822635f, 0.04400584f, 0.00808630f, 0.00719426f, -0.03867820f, -0.01323428f, 
    0.01817282f, 0.03621779f, -0.04063249f, -0.10798089f, -0.13292797f, -0.18270487f, -0.22069277f, 0.11202978f, 
    0.04245624f, 0.01831710f, -0.07192416f, 0.06762920f, -0.03841390f, -0.01005649f, -0.06552562f, 0.00701277f, 
    0.17956840f, 0.03598542f, -0.11746933f, 0.09135962f, -0.09076446f, -0.09936384f, -0.11514504f, 0.02231659f, 
    -0.01005040f, -0.08894403f, -0.15778440f, -0.11149828f, -0.57077861f, 0.04848213f, -0.22942530f, -0.20412047f, 
    0.10531978f, -0.02338499f, -0.15077980f, -0.12314276f, 0.04728258f, -0.00673937f, 0.00465396f, -0.09790886f, 
    0.28125042f, 0.00953179f, 0.02103700f, -0.03798208f, 0.05514026f, 0.05856153f, 0.12251838f, 0.04253311f, 
    -0.00615397f, -0.00266494f, -0.05690655f, 0.04837685f, -0.03439399f, -0.01632300f, 0.05120159f, 0.04307166f, 
    -0.08143641f, 0.09014399f, 0.07036428f, 0.04374015f, 0.01393239f, 0.10756207f, 0.06283811f, 0.03070214f, 
    0.05514453f, 0.09706271f, -0.09955233f, -0.03563067f, -0.05767677f, 0.07291502f, 0.00242251f, -0.01144361f, 
    -0.01980759f, 0.02305292f, 0.10333423f, -0.06873357f, 0.13104199f, -0.09176367f, 0.07541905f, -0.11271106f, 
    -0.17148383f, -0.09425452f, 0.02838822f, -0.06293940f, -0.03794629f, -0.03108809f, 0.03447242f, 0.04012320f, 
    0.08725110f, 0.02172999f, 0.01204844f, 0.01824307f, -0.10802942f, 0.01190783f, -0.01828913f, 0.08111333f, 
    -0.05279572f, 0.03417448f, 0.11134486f, -0.02792112f, 0.11712939f, 0.11020456f, 0.01848884f, -0.00863620f, 
    -0.08669410f, -0.10045554f, -0.09168444f, 0.07653828f, 0.00002237f, 0.09086361f, -0.10526226f, -0.17383699f, 
    -0.06911802f, -0.03849080f, 0.07925096f, -0.07737422f, 0.01316076f, -0.08381069f, -0.00872236f, 0.02714735f, 
    -0.07397997f, 0.06414424f, -0.03066450f, 0.00947496f, 0.26662374f, -0.05116327f, -0.04988773f, -0.12396770f, 
    -0.16300049f, -0.02707067f, 0.01869369f, -0.12593149f, 0.02902781f, -0.14755829f, -0.08534070f, -0.15480651f, 
    0.11986117f, -0.04504595f, -0.10353542f, 0.03331820f, 0.06742288f, -0.00040931f, 0.09011544f, 0.03928919f, 
    -0.03278524f, -0.01169991f, 0.05767728f, 0.01981596f, -0.43879691f, -0.19398837f, 0.08875690f, -0.06643058f, 
    0.09516881f, 0.05615691f, -0.00693706f, -0.14034250f, 0.11708686f, -0.08288610f, -0.16001852f, 0.07985213f, 
    -0.17450793f, 0.17144868f, 0.12145048f, 0.10501795f, 0.11078310f, 0.09917391f, 0.00229229f, -0.04780613f, 
    0.01110924f, -0.01953879f, -0.12466404f, -0.02024127f, -0.30718520f, 0.09057997f, -0.11763566f, -0.03443462f, 
    0.07544993f, -0.07977162f, -0.09567971f, -0.05448336f, -0.10883733f, 0.10507789f, -0.05398444f, 0.06039010f, 
    -0.03628046f, 0.19932035f, -0.01143578f, -0.07595368f, 0.08802398f, -0.16351077f, 0.03450244f, 0.09260514f, 
    0.04833229f, -0.04518407f, 0.00053239f, 0.02721606f, 0.12812062f, 0.07898967f, 0.12476547f, -0.09857234f, 
    0.01005663f, 0.03510020f, 0.06258819f, 0.01935023f, 0.01529566f, 0.15762644f, 0.01372653f, 0.20908244f, 
    -0.26615748f, -0.23501201f, -0.00375935f, 0.02270936f, -0.01818253f, -0.02597518f, 0.04133863f, -0.06119772f, 
    0.06272630f, -0.04910499f, -0.01745627f, 0.11497784f, 0.10021041f, 0.00333694f, 0.01103568f, -0.04869957f, 
    -0.12413062f, 0.10226823f, 0.02287921f, 0.00936103f, 0.08954927f, 0.08394853f, 0.01218603f, -0.00832028f, 
    -0.23053047f, -0.33961925f, -0.04874216f, -0.02079378f, -0.04782352f, 0.03812337f, 0.03004715f, 0.07890087f, 
    -0.02756805f, -0.12468556f, 0.05536657f, 0.04439862f, 0.20516354f, 0.12379973f, 0.05036881f, 0.05627418f, 
    -0.11459515f, -0.08123795f, -0.01432056f, 0.03370224f, -0.03157513f, -0.01451002f, -0.09808277f, 0.04153668f, 
    -0.12704319f, -0.09918692f, 0.01868632f, 0.01363226f, 0.00194522f, 0.01519090f, -0.01012581f, 0.05794575f, 
    0.15604037f, -0.02294594f, 0.00319013f, 0.03538534f, -0.42125332f, -0.33939198f, -0.06996552f, -0.18764096f, 
    0.04883780f, -0.00545223f, -0.04051839f, 0.05065617f, 0.03718307f, 0.13585702f, 0.04646507f, 0.07786006f, 
    -0.00309290f, -0.17670308f, -0.07661217f, -0.07341925f, -0.15451248f, 0.04332080f, 0.06801124f, -0.09045260f, 
    0.06875731f, -0.06677815f, -0.18017270f, 0.04884402f, 0.05594968f, -0.03262324f, -0.09046614f, 0.08105081f, 
    -0.05374119f, 0.06762174f, 0.03408895f, -0.02012552f, 0.09063846f, 0.16752495f, -0.05316335f, -0.07058408f, 
    -0.41469032f, -0.24777216f, -0.11591979f, -0.19051462f, 0.07964395f, -0.00334719f, -0.01250057f, -0.06998424f, 
    0.08179883f, 0.02995099f, 0.07784610f, 0.02082559f, -0.44062871f, -0.28960744f, -0.10582142f, -0.07679241f, 
    0.02200672f, 0.00376060f, -0.02204229f, 0.10666826f, -0.01562361f, 0.05892803f, -0.03758812f, 0.03672160f, 
    -0.00587205f, -0.08280765f, 0.12248702f, -0.04429412f, -0.12464316f, -0.03234162f, 0.04591589f, -0.01644434f, 
    0.00101947f, -0.05527324f, -0.00464456f, -0.14159155f, 0.21719900f, 0.05289572f, 0.02229314f, -0.05874091f, 
    0.07805863f, 0.09356916f, 0.01641227f, 0.07667404f, 0.01755052f, 0.09241584f, 0.05658153f, 0.09526539f, 
    0.15132557f, -0.17298450f, -0.04873703f, -0.07366881f, -0.03717947f, -0.02444941f, 0.06354489f, 0.03307326f, 
    0.07810748f, 0.09036658f, 0.11920833f, -0.00391520f, 0.00426974f, -0.19128324f, -0.07421861f, -0.09469630f, 
    0.00588832f, -0.00741742f, -0.09982575f, -0.04752154f, -0.04637587f, 0.03846169f, -0.01353598f, -0.00022890f, 
    0.09310710f, -0.21254778f, -0.07677265f, -0.06272659f, 0.09682209f, 0.04245097f, -0.06641334f, 0.09792734f, 
    -0.00715457f, -0.00547595f, 0.01146046f, -0.08423188f, -0.13991059f, -0.04399746f, -0.05570476f, -0.33087489f, 
    0.03530515f, 0.00081783f, -0.04874181f, 0.00768102f, 0.09123805f, 0.08867428f, 0.05813432f, 0.08230329f, 
    -0.23496966f, 0.20460153f, -0.08859402f, 0.00175412f, -0.04325237f, 0.03169047f, -0.02947956f, -0.23081139f, 
    0.12568606f, 0.03894452f, -0.01691827f, -0.07277253f, 0.14143522f, -0.06268085f, -0.06333371f, -0.03947988f, 
    0.00757683f, -0.10642473f, -0.07458633f, -0.13103448f, -0.06961428f, -0.18760428f, 0.04491324f, 0.01379404f, 
    -0.08746447f, 0.10539312f, -0.17625184f, -0.11887275f, 0.09733967f, 0.08720511f, 0.01432143f, 0.04567968f, 
    0.06890435f, -0.06283876f, 0.07234172f, -0.00235793f, 0.00538967f, 0.04127445f, -0.15464406f, 0.14315844f, 
    -0.01863851f, 0.06348290f, -0.07205071f, 0.00090719f, -0.04269702f, -0.05831144f, -0.04787369f, -0.10967528f, 
    -0.07136641f, 0.10036011f, 0.00173189f, 0.00552475f, -0.12520713f, -0.03023542f, 0.13340703f, -0.04068358f, 
    -0.07547940f, -0.05378206f, -0.01932270f, -0.10831883f, -0.05752082f, 0.18871781f, 0.10684675f, -0.06713071f, 
    0.02475153f, 0.02356215f, -0.04766207f, -0.22984679f, 0.00141453f, -0.01163317f, 0.02966432f, -0.09181413f, 
    0.09162897f, -0.02356063f, -0.04837386f, -0.00291157f, 0.09721629f, -0.07877213f, -0.05311068f, 0.05562438f, 
    -0.06637651f, -0.10278618f, -0.05667166f, -0.01095809f, 0.00696925f, 0.09288616f, -0.12076434f, 0.07280910f, 
    0.11428013f, -0.00467765f, -0.02564261f, -0.05773858f, -0.05714120f, 0.02405340f, 0.02129989f, -0.00336001f, 
    0.21876797f, -0.02880589f, -0.19162536f, 0.00418027f, -0.02266789f, 0.01446484f, -0.04948841f, 0.00079790f, 
    -0.02332723f, 0.03343521f, 0.04178309f, -0.00620596f, -0.26787671f, -0.37302831f, 0.03061238f, -0.20866419f, 
    -0.00608770f, 0.11534032f, 0.05548486f, 0.01145366f, 0.03926548f, 0.00596152f, 0.04484580f, 0.02543900f, 
    0.13926172f, 0.00041973f, -0.07163398f, 0.02743137f, -0.16872522f, 0.06356224f, 0.08264148f, 0.06984001f, 
    -0.02269348f, -0.05143308f, -0.00763555f, -0.10913411f, -0.01319492f, -0.05472607f, -0.19586472f, 0.03991431f, 
    0.05519452f, -0.02170033f, -0.01509047f, 0.04940700f, 0.01943659f, 0.04822831f, 0.09688583f, 0.05358883f, 
    0.47332102f, -0.14047313f, 0.03077242f, -0.25613505f, 0.01282736f, -0.08956101f, -0.02024474f, 0.03499673f, 
    -0.02309334f, 0.07923906f, -0.03958738f, 0.00826155f, -0.27633479f, -0.06567516f, -0.04546095f, -0.04872423f, 
    -0.13249715f, -0.01182372f, -0.14090037f, -0.07385331f, -0.06283712f, 0.02047434f, 0.03491539f, 0.04950948f, 
    0.10023829f, -0.24896708f, 0.03603700f, 0.07051437f, 0.04278638f, 0.00423884f, 0.03102671f, 0.10677537f, 
    -0.04439646f, 0.04996531f, -0.03593673f, -0.00135449f, 0.11624505f, 0.25348860f, -0.24060324f, 0.21018676f, 
    0.01863898f, -0.10369461f, -0.08243312f, -0.10415757f, 0.02626038f, 0.10385213f, -0.08628797f, 0.01175735f, 
    0.25392768f, 0.14168078f, 0.04774278f, -0.26747757f, 0.01014552f, 0.05198832f, -0.18173032f, 0.08181340f, 
    -0.01764424f, -0.02281809f, 0.06053355f, 0.11856787f, 0.15533586f, -0.18204686f, -0.12956251f, -0.09771157f, 
    -0.05403564f, -0.04938757f, -0.02845955f, -0.04163045f, 0.05313811f, 0.02064529f, 0.00835184f, -0.00598348f, 
    0.28244841f, -0.17349601f, -0.18772584f, 0.19570042f, 0.00966166f, -0.07347009f, 0.03543155f, -0.10777240f, 
    0.04644069f, -0.02141956f, -0.05120233f, 0.01772639f, -0.13391440f, -0.23870660f, -0.03446645f, -0.11984289f, 
    -0.07135864f, -0.10727945f, 0.00470830f, 0.05288343f, -0.13806958f, -0.02381490f, 0.03525937f, 0.06032624f, 
    -0.27234113f, -0.00529211f, 0.07828145f, 0.05834901f, 0.06861593f, -0.10993075f, 0.02984923f, 0.14864686f, 
    -0.04780819f, -0.08470313f, 0.02855437f, -0.03430944f, 0.00979481f, -0.01565741f, -0.01497192f, 0.13471994f, 
    -0.11580566f, 0.03624586f, 0.07976548f, 0.09695448f, 0.06982578f, -0.11959635f, -0.08021905f, 0.02959096f, 
    0.14543869f, 0.12627764f, -0.04028871f, -0.16629197f, -0.03693922f, 0.02456224f, -0.07977338f, -0.00272121f, 
    -0.05982497f, -0.03062423f, -0.01569859f, -0.14400916f, 0.05526510f, -0.17954169f, -0.08309384f, 0.18740684f, 
    -0.05985697f, 0.00117731f, -0.00738019f, -0.01088127f, 0.02289904f, 0.04693590f, 0.04016067f, -0.13486932f, 
    0.16110428f, 0.05327665f, -0.01730699f, -0.02881363f, -0.03226360f, -0.00418382f, 0.01129807f, 0.00459358f, 
    -0.02904267f, -0.09789025f, -0.11208310f, -0.02599095f, 0.08987255f, 0.11516749f, -0.07564640f, -0.10634806f, 
    -0.07841719f, -0.08492575f, 0.08788081f, -0.14462923f, 0.03468933f, 0.09851947f, 0.00445458f, 0.02927593f, 
    -0.31653878f, 0.08950795f, -0.22827500f, -0.14220338f, 0.05224444f, -0.05993859f, -0.03338608f, 0.03166832f, 
    0.01529718f, -0.00532139f, 0.04578597f, 0.02813779f, -0.28245166f, 0.08816893f, -0.10108072f, 0.02906612f, 
    0.15853761f, -0.08068255f, -0.01954390f, -0.01180951f, -0.02285173f, 0.07894457f, -0.02330332f, 0.03777642f, 
    0.15103234f, 0.01744112f, -0.07077745f, 0.09183770f, -0.00062722f, -0.00049340f, 0.01492349f, 0.08505996f, 
    -0.08016652f, -0.04600595f, 0.01589666f, -0.07232789f, -0.01915679f, 0.15379529f, 0.13083579f, 0.11913146f, 
    0.05284093f, -0.03712637f, -0.09757018f, 0.02003280f, 0.05883190f, -0.02547820f, 0.04524556f, 0.01431333f, 
    -0.11576582f, 0.08683079f, -0.09312233f, -0.05969448f, -0.06699204f, -0.02294452f, 0.05221760f, 0.04004283f, 
    0.03282689f, -0.05723174f, -0.01062819f, -0.05753258f, -0.24625526f, 0.21969718f, -0.10255665f, -0.02120534f, 
    0.11282592f, -0.02401269f, 0.08231701f, -0.00583755f, -0.03712042f, -0.02738480f, 0.00461504f, -0.03903237f, 
    -0.38079190f, 0.10513661f, 0.00217782f, -0.06196955f, 0.05594816f, 0.00363128f, 0.04143288f, -0.00252832f, 
    0.04106827f, 0.04173481f, 0.10998031f, 0.11570633f, 0.26077592f, -0.04613249f, -0.33960554f, 0.17987338f, 
    -0.02987884f, -0.02464236f, -0.00693603f, -0.05688647f, 0.02701027f, -0.04989272f, 0.06756281f, 0.11343107f, 
    -0.01449327f, 0.03539326f, -0.11675351f, 0.00188906f, 0.10833126f, -0.05800423f, 0.07363681f, 0.14436218f, 
    -0.01722632f, 0.04200961f, -0.07257280f, -0.01526907f, 0.06289429f, -0.15451296f, -0.04252029f, -0.00431593f, 
    0.00664993f, -0.04850869f, -0.09932334f, 0.14173380f, -0.08243848f, -0.05676485f, -0.06659240f, -0.01210401f, 
    0.11080706f, -0.02458724f, -0.07454243f, 0.04629231f, -0.15539943f, -0.04742951f, -0.09238464f, -0.11810325f, 
    0.03754072f, -0.04939275f, 0.00872294f, -0.14448862f, 0.03808667f, 0.12997764f, -0.06455300f, -0.01031706f, 
    0.08456761f, -0.13737565f, -0.06046178f, -0.09633958f, -0.07535297f, -0.00307149f, 0.10128395f, -0.03844287f, 
    -0.14145923f, -0.23678452f, 0.00796001f, 0.09859206f, -0.01562220f, 0.04373845f, 0.09506044f, -0.10268156f, 
    -0.04658476f, -0.03229969f, 0.01675622f, -0.05246072f, -0.18849543f, -0.06697767f, 0.01159290f, -0.00875592f, 
    0.14404500f, 0.07749990f, 0.12074708f, 0.13092785f, 0.08456693f, -0.00278902f, -0.07521523f, -0.01214855f, 
    0.10600671f, 0.06813154f, -0.09072283f, 0.27104908f, -0.03457300f, 0.06122584f, 0.05027345f, -0.03070569f, 
    0.07676668f, 0.03348686f, 0.01026224f, 0.02430367f, -0.07890236f, 0.02799019f, -0.07909385f, -0.00111676f, 
    0.01577593f, -0.08357821f, -0.06011746f, -0.00305450f, -0.00626890f, 0.03082113f, -0.05871677f, -0.02435018f, 
    0.11582861f, -0.05908966f, 0.00264972f, -0.02852538f, 0.08397656f, 0.09150386f, 0.02492939f, 0.01926811f, 
    -0.00402821f, -0.09037900f, 0.01582964f, 0.02594002f, -0.02187552f, 0.14289978f, -0.02289844f, -0.13690893f, 
    -0.01990893f, 0.05431248f, -0.00282578f, 0.05840881f, -0.01323085f, 0.02875915f, -0.01970110f, -0.17022964f, 
    0.32544160f, 0.09420951f, -0.02013124f, -0.03749392f, -0.04395742f, -0.05119554f, -0.12228521f, 0.02734960f, 
    0.12524536f, 0.05792124f, 0.09776595f, 0.03709288f, 0.06334790f, 0.08015822f, 0.05229480f, -0.03050872f, 
    -0.11263830f, 0.05373440f, -0.05994590f, 0.00652633f, -0.07093567f, -0.09652694f, 0.01035490f, 0.03818418f, 
    -0.04222036f, -0.21491222f, 0.10816713f, 0.13429350f, -0.09295560f, 0.00434543f, 0.01031560f, 0.09995282f, 
    -0.03151863f, -0.08219084f, 0.11759884f, 0.10284971f, 0.11600096f, 0.08604849f, -0.03590449f, 0.04040047f, 
    0.02228147f, -0.06553584f, -0.02557680f, 0.07818116f, 0.00896989f, 0.01862503f, 0.00137154f, -0.04570729f, 
    -0.02089459f, -0.31810546f, 0.01199297f, -0.17970327f, -0.00522322f, -0.07504208f, -0.00115420f, 0.11999293f, 
    -0.03113839f, 0.00161475f, 0.04581862f, 0.06873240f, -0.17051075f, 0.14348526f, 0.06895474f, 0.06550388f, 
    -0.07858669f, -0.08579475f, 0.00679796f, 0.02435932f, -0.06979413f, 0.05231864f, 0.12648536f, -0.06938070f, 
    -0.29512030f, 0.40839553f, -0.15817913f, -0.04536789f, 0.09859450f, -0.01655263f, 0.03976496f, 0.01154280f, 
    0.12587819f, 0.07470249f, 0.16277795f, 0.03123324f, 0.06263980f, 0.08144255f, -0.00173614f, 0.03645053f, 
    0.10328867f, 0.00496021f, 0.07983761f, -0.04936013f, 0.02017476f, -0.11519165f, 0.02080668f, -0.02328474f, 
    0.25532326f, -0.19728617f, -0.08274221f, 0.02481708f, 0.16558148f, -0.00187683f, -0.10057593f, -0.07633859f, 
    -0.01610474f, 0.02590565f, -0.06198155f, -0.05184729f, 0.09731998f, -0.39414424f, -0.02118858f, -0.22182424f, 
    0.00027842f, -0.03086584f, 0.05324796f, 0.04391625f, -0.00871532f, -0.08383390f, 0.03313570f, -0.07052184f, 
    -0.25880229f, 0.16780108f, 0.01568318f, -0.01878942f, 0.14200170f, 0.09416460f, -0.02458005f, 0.07371256f, 
    0.01358976f, 0.01677447f, 0.02715471f, -0.15624951f, -0.33590043f, 0.05362149f, 0.16628240f, 0.05542619f, 
    -0.01372351f, -0.06811229f, 0.04808160f, 0.05015619f, -0.01757756f, -0.12946832f, 0.02613636f, 0.12409379f, 
    0.10618643f, 0.01410367f, -0.23964386f, -0.10133073f, 0.04578169f, -0.03839973f, -0.00320929f, 0.01993762f, 
    0.05430483f, 0.07759737f, -0.11539540f, -0.07640877f, -0.23249578f, 0.18340629f, -0.03586442f, 0.08199361f, 
    0.06288059f, 0.00212290f, 0.00020371f, 0.01910114f, 0.03123541f, -0.07130676f, -0.13465574f, -0.00037815f, 
    -0.03634657f, 0.02609655f, 0.04602647f, 0.03373298f, -0.08472420f, 0.05332508f, -0.06231858f, -0.10474594f, 
    -0.08887920f, -0.02003956f, -0.03773224f, -0.09847251f, 0.01279280f, 0.11146058f, 0.03821576f, -0.12644517f, 
    -0.01695856f, -0.02315854f, 0.03496256f, -0.04009598f, 0.03739939f, -0.14740725f, -0.02925400f, -0.05063873f, 
    -0.00464062f, -0.01005000f, -0.05801294f, 0.01898891f, 0.11938506f, 0.00711306f, 0.07538517f, 0.03732529f, 
    0.03916074f, -0.00769872f, -0.02645651f, 0.06224183f, 0.06115411f, -0.29860416f, -0.17889786f, 0.20472164f, 
    0.00992661f, 0.03674706f, 0.00867469f, -0.04297415f, 0.00180662f, -0.00194416f, -0.00757153f, 0.02925954f, 
    -0.05669907f, 0.20368004f, 0.04793030f, -0.03103318f, 0.09572060f, -0.02988402f, 0.06046377f, 0.02120798f, 
    -0.00240805f, 0.08955865f, -0.00146811f, -0.01281505f, 0.34436816f, -0.02791459f, -0.34061283f, 0.22817668f, 
    0.02431341f, -0.06509902f, -0.09137585f, 0.04515358f, 0.03747877f, 0.02823027f, 0.03054434f, 0.01519288f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04994458f, -0.01365158f, -0.00476384f, -0.00591525f, -0.01894158f, -0.00007571f, -0.03167536f, -0.08658040f, 
    -0.02690289f, -0.00368405f, 0.03088757f, 0.01433154f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
