#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.18997347f, -0.24235506f, -0.63630199f, -0.79433423f, 0.01686371f, 0.07976275f, 0.43141454f, 0.29624066f, 
    0.12958650f, 0.31185940f, -0.20220731f, -0.36122674f, -0.46453795f, -0.25717393f, -0.20525083f, 0.22619247f, 
    -0.10376108f, -0.16993392f, 0.24890423f, -0.23332423f, -0.11004560f, -0.29748470f, 0.07556982f, -0.10658399f, 
    -0.22763725f, -0.20135213f, 0.11770714f, -0.64813900f, 0.09148396f, 0.14168431f, 0.31955904f, 0.91614991f, 
    -0.46550357f, -0.70065552f, -0.38185945f, -0.01187912f, 0.27865645f, -0.21389365f, -0.03943134f, 0.16789199f, 
    0.19318710f, -0.53845567f, -0.29194060f, 0.20719865f, -0.30842969f, 0.22279254f, -0.09367373f, -0.22079135f, 
    0.30164537f, -0.08927497f, 1.16130555f, -0.95407510f, -0.46415845f, 0.24932356f, -0.46549538f, 0.83299118f, 
    0.62343508f, 0.04028478f, -0.43293342f, 0.10732852f, -0.27184537f, 0.19844852f, -0.03801347f, -0.16457358f, 
    0.13880469f, 0.09521884f, -0.02923547f, 0.28660196f, -0.32733589f, -0.17016134f, 0.14380893f, -0.19613506f, 
    -0.13258566f, 0.04808976f, 0.20222184f, 0.62670368f, 0.41836065f, 0.54556090f, -0.23322928f, -0.87859201f, 
    -0.20045288f, -0.10763960f, 0.29981753f, 0.14452098f, -0.62350345f, -0.21643744f, -0.24598804f, 0.38041198f, 
    0.01100129f, -0.25999832f, 0.26151559f, 0.28725097f, -0.03187254f, -0.23378563f, -0.17482518f, -0.17389587f, 
    -0.02269598f, 0.13504991f, 0.20919488f, 0.15500170f, 0.22649482f, 0.14899527f, -0.35220888f, -0.03119736f, 
    0.51517296f, 0.29586288f, 0.60890967f, -0.01094404f, -0.36764765f, -0.61238575f, -0.40224013f, -0.09342602f, 
    -0.10732623f, 0.37451351f, -0.22776009f, -0.14716341f, -0.15828873f, 0.03161355f, 0.06463902f, 0.06711523f, 
    0.12589215f, -0.01785809f, -0.22332229f, -0.16966194f, 0.12249540f, -0.21442987f, -0.63384283f, -0.60005295f, 
    0.46801466f, 0.20211509f, -0.43466449f, -0.23038876f, -0.16169704f, 0.30612504f, -0.05224168f, -0.30023840f, 
    -0.29479951f, -0.25064996f, 0.43731204f, 0.04652419f, 0.37097535f, 0.05832508f, 0.27188233f, 0.16251779f, 
    0.26082045f, -0.07144759f, -0.08954807f, -0.14114819f, -0.26411140f, -0.30288351f, -0.01268571f, 0.05830992f, 
    -0.65206993f, -0.32948434f, -0.64165014f, 0.22526684f, -0.18449651f, -0.08999968f, 0.22155942f, -0.00027197f, 
    0.42710656f, 0.21064952f, 0.23697945f, 0.27522832f, -0.02488615f, -0.14958854f, 0.02880266f, -0.03596693f, 
    0.02317043f, -0.06658763f, -0.17881416f, -0.11385980f, 0.06254087f, -0.10416656f, -0.04230342f, 0.43521738f, 
    -0.27023783f, -0.72040540f, -0.45830268f, -0.19045952f, -0.14747679f, 0.34170511f, 0.33441824f, -0.15034835f, 
    -0.29113477f, 0.03751976f, -0.10828084f, -0.17877325f, -0.21980754f, -0.37531236f, -0.26821056f, -0.30033869f, 
    -0.09029295f, 0.21711490f, -0.25663987f, 0.29173476f, 0.36963448f, 0.37363598f, 0.17001438f, 0.35563365f, 
    -0.70178819f, -0.55551320f, 0.02950300f, -0.19533087f, -0.11308903f, -0.43280390f, -0.55300015f, -0.37950140f, 
    -0.47445983f, -0.09306329f, -0.06176167f, 0.02284621f, -0.03930011f, 0.23622984f, -0.17782383f, 0.02511725f, 
    -0.36383501f, -0.24108890f, -0.28461310f, -0.52286762f, -0.22119065f, -0.00549498f, 0.15299876f, -0.23007743f, 
    -0.01030050f, -0.59096164f, 0.20590924f, 0.02623502f, 0.16052437f, 0.27316734f, -0.19404410f, -0.04932444f, 
    0.60132825f, -0.18966158f, 0.07257672f, 0.20940325f, 0.27876002f, -0.30717063f, -0.49927956f, 0.24289642f, 
    0.13206652f, 0.28233358f, -0.41440746f, -0.34799632f, 0.31161603f, 0.16868687f, 0.37202984f, 0.11954517f, 
    -0.18197717f, -0.19493304f, 0.46089154f, 0.80993932f, 0.63091969f, -0.23526525f, -0.26289681f, -0.55010188f, 
    -0.32154974f, -0.10600489f, 0.03651445f, -0.31929523f, -0.17585385f, -0.36270261f, -0.21317737f, 0.34752122f, 
    -0.24447297f, 0.24729195f, 0.20841272f, 0.37375528f, -0.04451388f, -0.10623911f, 0.04624876f, -0.02292911f, 
    -0.12413436f, -0.06724211f, -0.17379270f, 0.47645971f, 0.42675003f, 0.19380935f, -0.38952002f, -0.01147797f, 
    0.14949223f, 0.15743288f, -0.15625054f, -0.13348015f, 0.30692658f, -0.05165333f, -0.00600989f, -0.00712698f, 
    -0.22104207f, 0.08409423f, 0.10925944f, -0.07118867f, -0.17404094f, -0.18789618f, 0.02331546f, -0.06731398f, 
    -0.09389411f, -0.19624981f, -0.32223105f, -0.12006220f, 0.21919978f, 0.38054049f, 0.35056472f, -0.21647273f, 
    -0.17530200f, 0.10120247f, 0.39917362f, 0.16710952f, 0.15533125f, -0.00973581f, -0.00910089f, 0.30093917f, 
    -0.16352217f, 0.33980995f, -0.03621076f, -0.18787713f, 0.13002461f, -0.25214872f, -0.03779325f, -0.17164598f, 
    0.03010214f, 0.07889051f, 0.22655818f, 0.23918472f, 0.19906428f, -0.38218391f, 0.21267757f, -0.02039564f, 
    0.31164360f, -0.37494496f, -0.32526809f, 0.06489035f, 0.46604097f, 0.02709079f, -0.03135822f, 0.07754617f, 
    0.37491935f, 0.11673782f, -0.23710814f, -0.32727766f, 0.15002993f, -0.37037933f, 0.12283552f, -0.40506789f, 
    0.28825697f, 0.23835343f, -0.35499391f, 0.19235006f, 0.25913674f, 0.01801582f, -1.03747833f, -0.52074045f, 
    -0.59345907f, -0.21370544f, 0.05880043f, 0.36173323f, 0.44146413f, 0.51856714f, 0.50420284f, 0.38417220f, 
    0.26796305f, 0.32509381f, 0.23252095f, -0.26688275f, -0.10663643f, -0.27308992f, -0.17551732f, -0.18555544f, 
    -0.09728467f, -0.32379621f, 0.06678049f, 0.35945770f, 0.00912791f, -0.01096276f, 0.41859889f, 0.25104332f, 
    -0.63996726f, 0.31883508f, 0.57949996f, 0.44145873f, -0.26261032f, -0.56924832f, -0.40580940f, 0.03890354f, 
    -0.16659436f, 0.07950408f, 0.18548322f, 0.30855060f, 0.04136526f, -0.35822180f, -0.14357111f, 0.19086459f, 
    -0.00873450f, -0.05132390f, -0.06427736f, 0.21891519f, -0.12097939f, -0.06268317f, 0.30365887f, 0.08529645f, 
    -0.60641253f, -0.27969173f, -0.50390500f, -0.00457106f, 0.71629512f, -0.37342793f, -0.17656137f, -0.24373698f, 
    -0.05682909f, -0.00963330f, 0.67768991f, -0.43901351f, -0.01608313f, -0.24317420f, -0.03020596f, 0.10567314f, 
    0.18412612f, -0.06162438f, 0.14897303f, -0.33327305f, 0.20888139f, -0.20884052f, 0.26081225f, 0.25369224f, 
    0.16969822f, 0.76668757f, 0.93782979f, 0.37848470f, -0.22346243f, -0.27381638f, -0.42213157f, -0.31430820f, 
    0.08065524f, -0.19712305f, -0.32023409f, -0.05251341f, 0.26442996f, 0.05452774f, 0.19229862f, -0.46067891f, 
    0.03103509f, -0.07334527f, -0.13363574f, 0.34054592f, -0.01540460f, 0.15178429f, -0.10763048f, -0.26638281f, 
    -0.10135397f, 0.04913493f, 0.83748406f, -0.09813660f, -0.66964287f, -0.84190500f, -0.99469209f, 0.29148081f, 
    -0.07353526f, 0.23713036f, 0.28002697f, 0.28085524f, 0.05937770f, 0.26702708f, -0.14228219f, 0.07103758f, 
    0.20380959f, -0.04615692f, -0.06112330f, 0.15311579f, 0.13251562f, -0.19971046f, 0.24545605f, -0.16166221f, 
    -0.03127521f, -0.00664820f, 0.14060068f, 0.32754645f, 0.07523208f, 0.02826233f, 0.00923688f, -0.22926125f, 
    0.04169909f, -0.05308376f, 0.25721404f, 0.13393016f, 0.02435677f, -0.15245362f, 0.06669794f, 0.08370021f, 
    -0.11868533f, -0.15691113f, -0.15712424f, 0.03277377f, -0.37707210f, -0.06382313f, 0.24423553f, 0.22546817f, 
    0.17572007f, -0.28124574f, -0.08319503f, 0.29900798f, -0.59741360f, 0.46629584f, -0.07072932f, -0.64087778f, 
    -0.49821809f, 0.33225089f, 0.64720213f, 0.08224417f, -0.04314195f, -0.34276316f, -0.01667980f, 0.03104409f, 
    -0.22773913f, -0.34363034f, -0.06544245f, -0.32229453f, -0.11642009f, -0.25789800f, 0.28555754f, -0.21037696f, 
    0.11997964f, -0.16661605f, 0.12043709f, -0.34754273f, -0.51733655f, -0.02107255f, -0.39998335f, -0.51484305f, 
    -0.26305297f, -0.19704311f, 0.00422870f, 0.18895686f, -0.31180266f, -0.29874212f, -0.24851418f, -0.22770776f, 
    -0.14181273f, 0.12916031f, 0.18877125f, 0.24660031f, -0.11169403f, -0.15079048f, -0.02142110f, 0.22262292f, 
    0.12926312f, -0.23651069f, -0.28164303f, 0.08568731f, -0.19849201f, -0.46483162f, 0.03010854f, -0.00714413f, 
    0.27801648f, 0.11442075f, 0.28723118f, 0.24280174f, 0.34364295f, -0.16995914f, 0.17969544f, -0.13628115f, 
    -0.17413859f, -0.08624605f, 0.18608980f, 0.04821277f, -0.02846633f, 0.22792491f, 0.19491641f, -0.16954619f, 
    -0.38958615f, -0.15582287f, -0.46980733f, 0.11132914f, 0.39433756f, -0.00457493f, -0.16163690f, 0.39362535f, 
    0.34000066f, -0.09942096f, 0.22931258f, -0.74495989f, -0.79530358f, -0.70654583f, -0.49728379f, -0.57950354f, 
    -0.58019722f, 0.21469374f, -0.06376552f, -0.14670034f, 0.17438826f, 0.26003566f, -0.08811828f, 0.27096176f, 
    -0.00189734f, 0.04397798f, -0.33229375f, -0.02862882f, 0.05778906f, 0.08988132f, -0.28465143f, -0.05857586f, 
    -1.03379989f, 0.70177335f, -0.46212384f, -0.37446049f, -0.78743762f, 0.22654751f, 0.28106105f, 0.16094290f, 
    0.26175898f, 0.19834305f, -0.22285049f, 0.06031429f, 0.19611523f, -0.10849726f, -0.09915817f, 0.09194310f, 
    0.07829164f, -0.27568811f, -0.06347969f, 0.02568491f, -0.14939526f, 0.33486030f, -0.09482872f, -0.24090873f, 
    -0.04750771f, 0.41212898f, -0.17444384f, -0.10740944f, 0.25892520f, -0.35595715f, -0.32485920f, -0.30611318f, 
    0.27547473f, 0.19450882f, 0.15154469f, -0.17740040f, -0.39070842f, 0.21754311f, -0.08133715f, 0.38336131f, 
    0.12202381f, 0.10145222f, -0.34744686f, -0.02298592f, 0.22644451f, -0.00353325f, 0.10500035f, -0.26670980f, 
    0.12297998f, -0.02755205f, -0.75683141f, -0.07201220f, -0.52093846f, 0.24467976f, -0.05941588f, 0.10019582f, 
    0.07600776f, -0.18215536f, -0.39773142f, 0.42131901f, 0.50099427f, 0.05160361f, 0.15830058f, -0.09202079f, 
    0.31494534f, -0.20037867f, -0.14482644f, -0.02045799f, 0.08225583f, -0.29665387f, 0.23715207f, 0.28574672f, 
    0.12269693f, 0.28597307f, -0.00247061f, -0.11269111f, 0.11728151f, -0.48393101f, -0.67779988f, -0.30150428f, 
    0.05682215f, -0.41743600f, 0.06607162f, -0.12658526f, -0.74161673f, 0.43986920f, -0.20726769f, 0.32793683f, 
    -0.32307228f, 0.04157285f, -0.27947095f, -0.42185244f, -0.07966597f, -0.27282375f, -0.38409114f, 0.03936512f, 
    0.14018199f, -0.00344549f, -0.21318591f, 0.49935719f, -0.57541919f, -0.40949321f, -0.15443830f, -0.11531282f, 
    -0.11093357f, -0.36533082f, -0.20505369f, -0.62445152f, -0.31608516f, 0.03871295f, -0.15127049f, -0.38339382f, 
    -0.07602260f, 0.36124095f, -0.38234159f, -0.13310477f, -0.23616852f, -0.24977243f, 0.08771549f, -0.14672534f, 
    -0.24345306f, -0.31928986f, -0.48879951f, -0.41400397f, -0.30387530f, -0.21439002f, -0.86282772f, 0.23986213f, 
    -0.04556684f, 0.64530063f, 0.22208820f, 0.21189049f, -0.32542479f, -0.21201669f, -0.10936254f, 0.47279152f, 
    -0.14044011f, -0.32689324f, 0.01814814f, -0.18629192f, -0.27577308f, -0.21512882f, -0.13777772f, 0.05376819f, 
    -0.12297671f, -0.00030737f, 0.05574844f, -0.24142003f, -0.22667362f, -0.24498133f, -0.76680660f, -0.17153010f, 
    0.58708310f, -0.01229518f, 0.15997946f, 0.05201285f, 0.15246131f, -0.48077375f, -0.19611280f, -0.18357147f, 
    -0.34035188f, 0.82625866f, -0.26914564f, -0.22331388f, -0.05437157f, -0.04224717f, 0.36697701f, -0.15491043f, 
    -0.27749071f, -0.23340511f, 0.25633910f, -0.14240368f, -0.23218232f, -0.22318138f, -0.00509822f, 0.03608050f, 
    0.18694180f, 0.14912814f, 0.02617294f, 0.13428684f, -0.25704271f, -0.36794689f, -0.39674136f, 0.39357615f, 
    0.32172111f, 0.21926832f, 0.13831466f, -0.64423847f, -0.38454777f, 0.67328709f, -0.27531990f, 0.14504482f, 
    0.04071320f, 0.10484895f, -0.07118675f, 0.05761526f, 0.04735299f, 0.05716208f, 0.05343939f, -0.29245299f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.11246064f, 0.28717440f, 0.23500298f, 0.26577267f, -0.07090855f, -0.18735988f, 0.17059876f, 0.06511271f, 
    -0.09169791f, 0.27506962f, 0.16877195f, 0.17912094f, -0.11190055f, 0.15156332f, 0.14008535f, 0.04281164f, 
    0.22453006f, 0.01083236f, 0.30024612f, 0.19081372f, 0.14189121f, -0.25498104f, 0.14563291f, -0.03061084f, 
    0.21997863f, 0.30178714f, -0.15461428f, -0.19807397f, -0.07222107f, 0.20971079f, 0.15726869f, 0.05276085f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.46155167f, 0.06647741f, 0.21191639f, -0.11178885f, -0.16202503f, -0.14287099f, -0.07193302f, 0.06833647f, 
    0.07339009f, -0.05316382f, -0.22314075f, -0.11519486f, 0.00567075f, -0.09544963f, 0.28192648f, -0.06224266f, 
    0.08184475f, 0.03344657f, 0.16305952f, 0.35663706f, 0.16984355f, 0.16288620f, 0.06227571f, 0.07103717f, 
    -0.00472071f, 0.05301249f, 0.13301310f, -0.14550647f, -0.06211299f, 0.03152252f, -0.09156378f, 0.07646907f, 
    0.01199347f, -0.03813554f, 0.06698101f, 0.06554724f, 0.09982424f, 0.20377222f, -0.24811102f, -0.13021493f, 
    0.10135853f, -0.11154123f, -0.03998352f, -0.00481343f, -0.05314569f, -0.00621612f, 0.06622036f, 0.04979220f, 
    -0.45867950f, 0.25040495f, 0.08301005f, -0.36617398f, -0.20890319f, 0.07448992f, -0.03055288f, -0.03685856f, 
    0.01036117f, 0.04976384f, -0.03841370f, -0.09236897f, -0.35537052f, -0.18357384f, 0.02874495f, 0.09717954f, 
    0.11373405f, -0.01712713f, 0.04373013f, -0.03703706f, -0.07037474f, -0.05567399f, -0.09432971f, -0.04050216f, 
    -0.08223183f, 0.12956241f, -0.01770145f, 0.01260070f, 0.01337604f, 0.00262643f, 0.13331421f, 0.05987623f, 
    0.09185898f, -0.11421800f, -0.03683591f, -0.06844107f, -0.05554108f, -0.08940546f, 0.24789083f, -0.03404970f, 
    -0.04629148f, 0.14821246f, -0.19200179f, -0.05927004f, 0.05527969f, 0.00986759f, 0.02628611f, 0.04680678f, 
    -0.19355553f, -0.03418809f, 0.16574655f, 0.04564136f, 0.08049453f, -0.06726032f, 0.12341078f, -0.03204120f, 
    0.21498998f, 0.14564091f, 0.01668962f, 0.17621192f, -0.07714043f, 0.04752523f, -0.05710046f, 0.06912092f, 
    -0.07776444f, -0.17393346f, 0.06045078f, -0.03320092f, 0.08826258f, 0.11367667f, 0.15164764f, 0.15717144f, 
    0.17162316f, -0.03190263f, -0.09662772f, 0.11477556f, 0.03322800f, -0.05559985f, -0.16520546f, 0.10483454f, 
    -0.07526735f, -0.03541063f, -0.06438828f, -0.16573627f, 0.12643330f, 0.06143733f, -0.00269597f, -0.06743671f, 
    -0.10255666f, -0.05793412f, -0.02511192f, -0.00378218f, 0.09291025f, 0.09269462f, 0.00912337f, 0.08185033f, 
    -0.18679646f, -0.09949593f, -0.02897727f, -0.04991655f, -0.15591557f, -0.00589334f, -0.07683405f, -0.06257138f, 
    0.07851541f, 0.12900618f, 0.03688974f, 0.13398948f, 0.17097469f, 0.17517157f, -0.16272603f, 0.15098727f, 
    -0.01511301f, -0.04370268f, -0.01196217f, 0.05856526f, 0.05987430f, -0.10531667f, 0.09328696f, -0.01231314f, 
    -0.25598836f, -0.16346791f, 0.05491512f, -0.13856755f, -0.24875703f, -0.02328661f, -0.06948066f, 0.04527427f, 
    0.24005426f, -0.05825572f, 0.10717033f, 0.01995530f, 0.31364098f, -0.08418518f, -0.16183847f, -0.12672231f, 
    -0.15358077f, 0.13719958f, -0.03111923f, 0.14036278f, 0.01075355f, -0.05679335f, 0.05997711f, 0.00139450f, 
    -0.15650319f, -0.02037798f, 0.08428689f, 0.22980753f, -0.00689737f, 0.06064432f, 0.13244106f, 0.23266843f, 
    0.06607957f, -0.06171758f, 0.07536307f, 0.18265766f, 0.35107702f, -0.13602594f, 0.04026087f, 0.00389681f, 
    -0.20602058f, 0.03126781f, -0.21551061f, -0.06566466f, -0.13883376f, -0.12658401f, -0.08629334f, -0.18571645f, 
    -0.01348331f, 0.24387684f, -0.04009478f, -0.05298070f, -0.05319909f, -0.03410653f, 0.08435573f, 0.15705410f, 
    0.16188255f, -0.04554348f, -0.08949071f, -0.10421646f, -0.00349698f, -0.03763458f, 0.24246185f, -0.01175161f, 
    -0.11551473f, -0.18260553f, -0.10488401f, -0.04828842f, -0.07133749f, 0.00957236f, 0.01849702f, 0.04944561f, 
    -0.06029015f, 0.09357730f, 0.13368629f, -0.07022628f, 0.03688464f, 0.00090444f, 0.17458157f, 0.04473315f, 
    0.03526049f, 0.03012394f, -0.08050497f, -0.11108719f, -0.19842571f, 0.02188529f, 0.16924706f, -0.01998441f, 
    0.01614730f, -0.04965798f, -0.09067068f, -0.02663867f, 0.12395934f, 0.04323262f, -0.13700967f, -0.14788465f, 
    -0.11066350f, -0.17497000f, -0.08778356f, -0.06682985f, -0.08481374f, -0.03373625f, 0.02392696f, -0.10836396f, 
    0.12504949f, -0.12163546f, 0.06111125f, 0.13938242f, -0.11466139f, 0.15153408f, 0.08081060f, 0.14101361f, 
    0.08149373f, -0.06726506f, -0.04015790f, -0.26559556f, 0.04817366f, 0.01464558f, 0.07555760f, 0.02706553f, 
    0.09995461f, 0.14493461f, 0.10340794f, 0.08799122f, 0.01100213f, 0.04702561f, 0.11012054f, 0.21474943f, 
    0.01621323f, -0.02983852f, 0.04618280f, 0.01084201f, 0.13714792f, -0.01204725f, -0.06526953f, 0.16846457f, 
    0.14051484f, -0.01343555f, 0.12930487f, 0.12705295f, 0.13855791f, 0.06844021f, 0.05613114f, 0.12573592f, 
    -0.14056936f, -0.06048927f, -0.07332747f, 0.00905322f, -0.08461817f, -0.07901277f, 0.01752723f, 0.31505060f, 
    0.06860840f, 0.16189374f, -0.01924386f, -0.13556270f, -0.08732637f, -0.01444074f, 0.21388786f, 0.12477675f, 
    -0.13353045f, 0.10766912f, 0.09006564f, 0.01515455f, 0.05364163f, 0.00681406f, 0.08906643f, 0.14245296f, 
    -0.18931678f, 0.00633209f, 0.10608450f, 0.06038236f, -0.05254264f, -0.06088666f, 0.04338702f, -0.10671936f, 
    0.14436774f, 0.07426865f, -0.13878575f, -0.00149172f, 0.10247198f, 0.04551276f, 0.08671344f, -0.01979210f, 
    0.11860105f, 0.00449482f, 0.03176645f, 0.15096235f, 0.13489577f, -0.09288798f, -0.13711868f, -0.08596770f, 
    0.12434847f, -0.14284860f, 0.17323975f, 0.17757358f, 0.15337805f, -0.02362699f, 0.02503897f, 0.00215314f, 
    -0.01720577f, -0.08315003f, 0.20098983f, 0.12648016f, -0.25116152f, 0.03061965f, -0.08696239f, 0.32661059f, 
    0.19750434f, -0.15431994f, 0.09592879f, 0.11141310f, -0.08247098f, 0.11090928f, 0.04788711f, 0.00279665f, 
    0.09294638f, 0.35359702f, -0.00046371f, -0.01081749f, 0.10090421f, 0.15657270f, 0.03422341f, 0.02267812f, 
    0.09438193f, -0.09852809f, 0.02192920f, -0.03557697f, 0.06596985f, 0.20845538f, 0.11107685f, -0.03988411f, 
    -0.02357531f, 0.03697813f, 0.09279449f, 0.02505334f, 0.06023936f, 0.04720755f, 0.12643822f, 0.00107389f, 
    0.68139929f, -0.68464947f, -0.33685431f, -0.09634852f, -0.08723921f, -0.00754614f, 0.08397716f, 0.08720765f, 
    0.09113836f, 0.00628048f, 0.02207706f, 0.05147456f, 0.00700090f, -0.32950404f, -0.24658312f, -0.03484374f, 
    0.08593500f, 0.13437726f, 0.15878263f, -0.04857326f, 0.17598610f, 0.04763259f, -0.08021338f, 0.13442773f, 
    -0.12565552f, -0.41687244f, -0.44251162f, 0.04383575f, 0.04379616f, -0.10237034f, -0.04845965f, -0.05926162f, 
    -0.12629786f, 0.08535634f, -0.06002506f, 0.08473796f, 0.27354461f, 0.06205712f, 0.32973838f, -0.11525372f, 
    0.13499655f, 0.06509721f, 0.21425131f, 0.15320148f, 0.05024175f, 0.01244942f, -0.15903750f, -0.15092765f, 
    0.23339760f, -0.14309697f, -0.18924095f, -0.34273356f, -0.05032769f, -0.12725061f, -0.11811738f, 0.19392221f, 
    -0.05465170f, 0.01113502f, 0.05818685f, -0.01386127f, 0.28208917f, 0.10828698f, -0.05022809f, -0.03196371f, 
    -0.01030007f, 0.04329510f, 0.10127015f, 0.06561571f, -0.01749950f, -0.06256547f, -0.09408212f, 0.02454174f, 
    0.19707249f, 0.26554173f, 0.22260033f, -0.02483839f, 0.03204081f, 0.11199834f, 0.10653090f, 0.09964775f, 
    -0.04483683f, -0.06703582f, 0.00554481f, -0.08868587f, -0.35350129f, 0.03479983f, 0.10052304f, 0.20256197f, 
    0.05439281f, 0.14471421f, -0.09975751f, -0.03758989f, -0.00435486f, 0.02798335f, 0.17293794f, -0.16731048f, 
    -0.24694723f, 0.15628661f, -0.21642886f, -0.08822443f, 0.04872023f, 0.09317493f, -0.00081134f, 0.02959602f, 
    -0.00774224f, 0.13827649f, -0.14891279f, 0.05072978f, -0.27029923f, -0.52990168f, -0.33096427f, 0.10162719f, 
    -0.01553765f, -0.04246455f, 0.12766391f, 0.01860407f, -0.00937999f, -0.13080852f, -0.03819517f, -0.08143067f, 
    -0.12766726f, -0.49760389f, -0.65786421f, -0.08119049f, -0.04986159f, 0.06818713f, 0.00712649f, -0.16407594f, 
    0.12791412f, 0.18930446f, -0.09340882f, 0.07781605f, -0.22352342f, -0.36265254f, -0.01540761f, 0.26130688f, 
    0.08585013f, -0.05195150f, -0.08134062f, 0.00793584f, 0.00858404f, 0.01390241f, 0.13575023f, 0.17935297f, 
    -0.18113588f, -0.06502853f, -0.11657909f, 0.01599377f, -0.03054569f, 0.09422025f, -0.00225174f, -0.13025720f, 
    0.03681085f, 0.15898332f, -0.03474524f, 0.10481008f, -0.14333971f, -0.00857510f, 0.04055906f, -0.54620230f, 
    -0.09809541f, 0.07659514f, 0.17508996f, 0.04551485f, 0.10609254f, -0.04144493f, 0.05746872f, 0.01642383f, 
    0.15050893f, 0.25679329f, 0.29789311f, -0.05291626f, -0.03492933f, 0.08893882f, 0.16477533f, 0.19553901f, 
    0.03867283f, -0.09275123f, 0.05395485f, -0.11936749f, -0.15785247f, -0.13224965f, -0.62393880f, -0.00386826f, 
    0.01811135f, -0.15047988f, 0.16211067f, -0.01542647f, -0.16407262f, -0.04523265f, -0.08220003f, 0.05683968f, 
    0.55814558f, -0.54469210f, -0.08592537f, -0.46593609f, 0.08761422f, 0.07091530f, 0.04745070f, 0.16774945f, 
    -0.03101567f, 0.12159541f, -0.04919518f, -0.01974404f, -0.05130339f, -0.55420214f, -0.46665129f, 0.02590667f, 
    -0.07230952f, -0.16333166f, -0.09668695f, -0.12586723f, 0.14187235f, -0.12788641f, 0.09594510f, 0.09064349f, 
    -0.09257280f, 0.28002241f, -0.14790998f, -0.10694978f, -0.03946652f, 0.07712021f, 0.11643534f, 0.10037566f, 
    0.04507594f, -0.02192796f, 0.03756602f, 0.06894718f, 0.37266636f, 0.08431231f, 0.06431191f, -0.11175351f, 
    0.13397495f, 0.06478856f, 0.04099553f, 0.11057539f, -0.09361979f, -0.08175968f, -0.01611177f, 0.05482468f, 
    -0.09826574f, -0.54922187f, -0.13465290f, -0.02218327f, 0.09506454f, -0.08950590f, -0.04757653f, -0.18341666f, 
    0.05189431f, -0.00104029f, -0.01024602f, 0.02900053f, 0.29675433f, 0.29663208f, 0.09846508f, -0.23433053f, 
    -0.03328062f, -0.10882818f, 0.08668841f, 0.21644512f, -0.12649247f, 0.05741318f, 0.05717576f, 0.17268629f, 
    -0.27887022f, 0.11098058f, -0.12577151f, -0.08984732f, 0.12240522f, 0.05796192f, -0.05529962f, 0.02075748f, 
    0.06861603f, 0.14893158f, 0.02059940f, 0.07448947f, 0.03245277f, -0.10774760f, 0.19055653f, -0.14635648f, 
    0.25237715f, -0.09023142f, -0.04429851f, 0.01875845f, 0.14320961f, -0.01982998f, 0.00458591f, 0.06703603f, 
    -0.12116352f, 0.13453405f, 0.11008220f, -0.12082221f, -0.05446163f, 0.14173253f, 0.01022580f, -0.06412704f, 
    0.01297152f, 0.01049924f, -0.08415088f, -0.12934743f, 0.26531339f, 0.28310916f, -0.02168917f, -0.06884401f, 
    0.03421474f, 0.04511202f, 0.19288078f, 0.06114309f, -0.12086936f, -0.11496884f, -0.07084437f, -0.00028894f, 
    0.27233943f, 0.15807715f, 0.13669851f, 0.03781167f, 0.06671052f, 0.09647663f, 0.02429122f, 0.12405077f, 
    -0.15780841f, -0.19383457f, -0.00486416f, -0.01840448f, 0.28984395f, -0.13752274f, -0.02886863f, -0.03739139f, 
    -0.05022797f, 0.05408855f, -0.00239302f, 0.07406769f, -0.00507641f, 0.05862661f, 0.06273533f, -0.01496345f, 
    0.04245510f, 0.20863952f, 0.06926545f, -0.05852678f, 0.02929543f, 0.07234114f, 0.08813605f, 0.20432834f, 
    0.10243831f, -0.15932181f, 0.14690790f, -0.13129745f, 0.05125793f, -0.01330405f, 0.12158264f, 0.04868185f, 
    0.01863588f, 0.05475355f, -0.07574896f, 0.12975442f, 0.20304719f, 0.03297633f, 0.09694873f, -0.15326612f, 
    -0.00266544f, -0.03835971f, 0.00385551f, -0.03586054f, 0.00914742f, -0.02992327f, 0.01463023f, -0.04716786f, 
    0.01539151f, -0.03788926f, -0.01919569f, -0.02969567f, -0.03188303f, -0.02912345f, -0.05322878f, -0.03898855f, 
    0.00805892f, 0.00955715f, -0.02538626f, -0.03525421f, -0.03705283f, 0.04042814f, 0.02492991f, -0.00743680f, 
    0.03652705f, 0.03066038f, -0.01797823f, 0.00278076f, 0.04106671f, -0.02162663f, -0.03123306f, -0.01525888f, 
    0.02179301f, 0.02767620f, -0.01487797f, 0.03929517f, 0.01410888f, -0.01939381f, 0.01565659f, -0.05703294f, 
    -0.03205830f, -0.04092237f, 0.03675238f, 0.00954049f, -0.02706602f, -0.04229089f, -0.03002007f, -0.01299728f, 
    -0.00508493f, 0.02713618f, -0.01813634f, -0.01372492f, -0.03484768f, -0.00167096f, -0.03968219f, 0.04611317f, 
    0.00919675f, 0.00205221f, -0.01202762f, -0.02992931f, -0.03347143f, 0.00327724f, 0.01212741f, 0.02897816f, 
    0.01128912f, -0.05250148f, -0.02085417f, 0.00584536f, 0.00940135f, 0.03651257f, -0.04193731f, -0.01314713f, 
    -0.02275481f, -0.01628040f, -0.00646434f, 0.02787910f, -0.00680118f, 0.01667278f, 0.00125686f, 0.01600788f, 
    -0.01488211f, 0.04202846f, 0.02649731f, 0.02112470f, -0.05775348f, -0.04490065f, 0.03810238f, 0.03983595f, 
    -0.00862491f, -0.03845865f, 0.00476857f, 0.02003919f, 0.01087194f, 0.01971150f, -0.01781124f, -0.01764935f, 
    -0.00610823f, -0.01987008f, -0.01872290f, 0.00346109f, -0.04743155f, 0.03287566f, -0.03226670f, -0.00939810f, 
    -0.04490557f, -0.00938849f, 0.03223562f, -0.02081904f, 0.03326412f, 0.00373615f, -0.02925103f, -0.01718899f, 
    0.02889493f, -0.03180991f, 0.01221511f, 0.04616372f, 0.04127059f, -0.02697881f, 0.01201383f, -0.01711662f, 
    0.03550270f, -0.03244072f, -0.05552797f, -0.02822179f, -0.03572336f, 0.00422461f, 0.01894880f, 0.04215907f, 
    -0.00438725f, 0.01282940f, 0.01555600f, -0.03053760f, -0.04602011f, 0.00790001f, 0.00012223f, 0.03802332f, 
    -0.02936820f, 0.00806914f, 0.02053879f, -0.04754538f, -0.03016877f, -0.00034050f, -0.04504772f, -0.02520145f, 
    -0.02056225f, 0.01068933f, 0.00107642f, 0.03917629f, -0.03879586f, -0.00557436f, 0.00095817f, 0.01949100f, 
    -0.03728579f, 0.01894216f, -0.00122679f, 0.00084787f, 0.03915221f, 0.03886067f, 0.02598015f, -0.03041920f, 
    0.04052849f, -0.03052928f, 0.02145578f, -0.05468389f, -0.05229431f, -0.01655580f, -0.05288939f, -0.05012212f, 
    -0.01166505f, 0.00748194f, 0.01130550f, 0.01396509f, 0.03142978f, -0.00477237f, -0.02578088f, -0.01292544f, 
    -0.04244769f, 0.02490873f, 0.02952568f, 0.03045165f, -0.03059183f, -0.01586978f, 0.01967631f, -0.05789893f, 
    0.03135782f, -0.02746623f, -0.04450338f, 0.03274171f, 0.03628047f, -0.05185191f, 0.02437637f, -0.04879546f, 
    0.01281862f, 0.03905255f, 0.00412303f, 0.02210604f, 0.02628595f, 0.00258301f, -0.02670778f, -0.03470054f, 
    -0.02857888f, -0.00790211f, -0.02837371f, 0.01126378f, -0.05051690f, -0.05718975f, -0.05852998f, 0.02506492f, 
    -0.00411239f, -0.03979789f, -0.01417007f, 0.02929547f, -0.01352129f, -0.04167783f, -0.01912968f, -0.02310951f, 
    -0.02192184f, -0.01067472f, 0.01778702f, -0.04487382f, -0.01066354f, 0.00616581f, 0.02420604f, 0.03313255f, 
    0.03004321f, 0.00580114f, -0.03818105f, -0.04057690f, -0.00391044f, -0.03602397f, -0.05520730f, -0.00169908f, 
    0.02043775f, 0.02826101f, 0.02421989f, -0.02454264f, 0.00920074f, -0.04985983f, -0.04025479f, -0.01645689f, 
    0.03073860f, 0.01105799f, -0.02757782f, -0.02031586f, 0.01971436f, -0.04139936f, -0.05030204f, -0.00895014f, 
    -0.01892662f, 0.03953815f, 0.04199157f, 0.02405120f, 0.00461596f, 0.01488886f, -0.00197088f, -0.04271414f, 
    -0.04764705f, -0.00663079f, -0.02013719f, -0.01531984f, -0.04718940f, 0.03249388f, -0.05449530f, 0.01120851f, 
    0.02506211f, 0.01638630f, 0.04329208f, 0.00840863f, 0.01103199f, 0.04152408f, -0.02612110f, 0.00379549f, 
    -0.02416229f, -0.02141790f, -0.02049362f, -0.02057527f, -0.01731766f, 0.01295039f, -0.04622993f, 0.02109558f, 
    -0.03790200f, -0.05018940f, 0.00661712f, -0.04164406f, 0.00572267f, -0.05842320f, 0.00593599f, 0.00008854f, 
    -0.02005250f, -0.04645551f, 0.03376186f, -0.01359419f, -0.03307805f, -0.05563498f, -0.02168065f, -0.03672793f, 
    -0.02402880f, 0.03671211f, -0.05447713f, -0.01613970f, -0.01637053f, -0.03467873f, -0.03273018f, 0.00889977f, 
    -0.02054535f, 0.04316028f, -0.05242737f, -0.04870622f, 0.01404512f, 0.00146182f, -0.02186400f, -0.01536366f, 
    0.00217311f, 0.00762610f, -0.04155069f, 0.00710185f, -0.00475892f, -0.04384352f, 0.00013122f, -0.02507053f, 
    0.04067204f, -0.00211416f, -0.04219475f, 0.00453031f, -0.02668693f, 0.04286994f, 0.02450776f, 0.03001572f, 
    -0.05642147f, 0.00702512f, -0.01447893f, -0.05225108f, -0.05678344f, -0.00760298f, 0.01145102f, 0.03359918f, 
    0.00050300f, -0.00087204f, 0.03059796f, -0.03410939f, 0.01845586f, -0.00119598f, -0.03443639f, -0.04673573f, 
    0.02316611f, 0.00238595f, -0.01079559f, -0.04437529f, -0.03045843f, -0.03850352f, -0.04222189f, -0.00093377f, 
    0.03877226f, -0.05257411f, 0.03385622f, 0.04206140f, 0.01913041f, 0.03489425f, 0.01021725f, -0.01110695f, 
    0.03575071f, -0.04605860f, -0.00359155f, -0.01738635f, 0.03841497f, 0.01323307f, 0.01676424f, 0.03516012f, 
    0.00944660f, -0.03647401f, -0.05668767f, -0.04646971f, 0.01921907f, 0.03664409f, 0.01985331f, 0.01102055f, 
    0.00355629f, 0.03463437f, -0.01228901f, 0.01285733f, -0.02300893f, 0.01868031f, 0.00510607f, -0.02258284f, 
    -0.15975562f, 0.25872391f, 0.03035163f, -0.26985389f, 0.04821469f, -0.05899504f, -0.10928298f, -0.17995618f, 
    0.05180472f, -0.06976395f, -0.20453836f, -0.10959207f, 0.05627609f, 0.02210889f, -0.06189882f, 0.18979552f, 
    -0.09080109f, 0.09782600f, 0.06467424f, 0.34675089f, 0.06555471f, 0.10733864f, 0.00715227f, 0.27376336f, 
    0.25194123f, 0.13666539f, -0.17774928f, 0.13344620f, -0.04210186f, -0.05556405f, -0.06923994f, 0.04802049f, 
    0.05542806f, -0.14098850f, -0.07050651f, 0.06243340f, 0.36881587f, -0.02738211f, 0.20132965f, 0.07002213f, 
    0.07448542f, -0.05827082f, 0.05390857f, -0.05594620f, -0.01834418f, 0.03854953f, 0.00751050f, 0.11866038f, 
    0.09038266f, 0.19635484f, 0.01069521f, 0.00370815f, -0.19168051f, -0.03809802f, -0.12941948f, -0.02425248f, 
    -0.09224046f, -0.03402327f, 0.03630099f, -0.05464965f, -0.28322241f, 0.09814108f, 0.04184417f, -0.09397779f, 
    0.06147172f, -0.17446478f, -0.13166641f, 0.03694699f, 0.01183308f, -0.10951186f, 0.00203700f, -0.23340952f, 
    -0.28573456f, -0.33151859f, -0.14449000f, -0.06090061f, 0.02825451f, -0.06351744f, 0.02360564f, -0.04230366f, 
    -0.06321642f, -0.11319215f, 0.00290459f, -0.07451826f, 0.28296977f, 0.13762210f, 0.22861142f, 0.06574788f, 
    0.00110376f, 0.22506732f, -0.04150470f, 0.00131431f, -0.01433681f, 0.00408571f, 0.01635001f, 0.09231617f, 
    -0.13725689f, 0.07433001f, 0.32027608f, 0.26967496f, 0.18542604f, -0.05691772f, 0.11880424f, 0.02675458f, 
    0.10432122f, 0.09680689f, 0.00261132f, 0.09130589f, -0.09909727f, 0.08756725f, 0.12764801f, 0.02948689f, 
    0.02713743f, 0.01339110f, -0.05403025f, 0.01795925f, 0.03549109f, 0.07989147f, 0.04605188f, 0.10772284f, 
    0.45240334f, -0.03758207f, 0.33200884f, 0.07193502f, 0.09745824f, -0.05712305f, -0.08973136f, 0.07814350f, 
    -0.14737932f, -0.08872269f, -0.01564572f, -0.04582446f, 0.11318660f, 0.09141225f, 0.10326989f, 0.08711914f, 
    -0.05389078f, 0.00621288f, -0.02023720f, -0.02061475f, -0.02520351f, -0.04898899f, -0.12218235f, 0.00161825f, 
    0.09763858f, -0.03449185f, 0.03858064f, 0.04540556f, 0.01002400f, -0.01068503f, -0.04973806f, -0.01150872f, 
    0.07121040f, 0.16744547f, 0.05111339f, 0.14537878f, 0.11558516f, 0.02047111f, 0.10593397f, 0.03058484f, 
    0.10467007f, -0.01901351f, 0.03810808f, 0.00518938f, 0.14163674f, -0.03502377f, 0.06971329f, 0.10264698f, 
    -0.25517711f, -0.26577297f, -0.32520360f, -0.03635613f, -0.16221540f, 0.05206113f, -0.09418732f, -0.04200283f, 
    0.14198615f, 0.05049752f, 0.13575046f, -0.00021808f, 0.17679729f, 0.30352321f, 0.04762716f, 0.06868887f, 
    0.02265703f, -0.10501957f, -0.01036089f, -0.08459783f, -0.02036739f, 0.01333680f, 0.06572399f, 0.10859712f, 
    -0.40324754f, 0.14309265f, 0.00637262f, 0.26316357f, 0.02894066f, 0.24152020f, 0.20980161f, 0.10074861f, 
    0.03372235f, -0.09961441f, 0.05722130f, 0.12847732f, 0.29091090f, -0.06053197f, 0.56668824f, 0.19662458f, 
    0.08733129f, 0.00001764f, -0.22813308f, -0.05835775f, -0.19413698f, -0.11426297f, -0.00076568f, -0.01664146f, 
    -0.09046555f, -0.42655671f, 0.05398941f, -0.16935466f, -0.12032221f, -0.00381063f, -0.07889327f, 0.15812157f, 
    0.05538900f, -0.13317949f, 0.00808982f, -0.13032804f, 0.17606373f, 0.01502217f, 0.10624395f, 0.10056555f, 
    -0.10465395f, -0.02940509f, -0.07993015f, -0.06358033f, -0.05217435f, -0.04342686f, -0.06984334f, -0.00909950f, 
    0.15238279f, 0.16390254f, 0.01249808f, -0.16934854f, 0.10439243f, 0.01369876f, -0.02448150f, 0.00533982f, 
    -0.15685453f, -0.04922096f, -0.21584523f, -0.21785636f, 0.17989635f, 0.24112244f, 0.21372686f, 0.21101810f, 
    0.03372568f, -0.09497879f, -0.08921465f, -0.02181281f, 0.00575691f, 0.03759755f, -0.07803375f, -0.19157703f, 
    0.11052795f, 0.00445828f, 0.10583499f, 0.14995489f, -0.05011889f, -0.06442484f, -0.00961833f, -0.04094393f, 
    0.00261229f, 0.02159266f, -0.00107453f, 0.07320486f, 0.04712374f, 0.17044830f, 0.17821132f, -0.05361890f, 
    -0.02101437f, -0.18119976f, -0.11836655f, -0.06793953f, -0.02623078f, -0.00744077f, 0.10567117f, 0.01300428f, 
    -0.11601243f, 0.04503081f, 0.07776705f, -0.06940597f, 0.13442232f, 0.07230044f, -0.12255412f, 0.05319008f, 
    -0.04896976f, -0.06251136f, 0.03198260f, -0.21033973f, 0.06328908f, -0.06447878f, 0.13672841f, 0.00289537f, 
    0.09799841f, -0.04312211f, 0.00825892f, 0.32390362f, 0.20798635f, 0.05412755f, 0.01561940f, 0.03432000f, 
    -0.15214472f, 0.03803558f, -0.27978906f, -0.01457173f, 0.07559666f, 0.05121724f, 0.06087783f, 0.10093302f, 
    0.05383154f, 0.07317439f, -0.06589681f, -0.07801415f, -0.04918462f, 0.01523702f, 0.27542144f, 0.31307879f, 
    -0.04018055f, 0.29647732f, 0.01871977f, 0.20854393f, -0.06118599f, -0.04076735f, -0.04675575f, 0.09962161f, 
    0.05234321f, 0.17894900f, 0.12114794f, 0.24930209f, 0.13173687f, -0.17016940f, -0.04989268f, -0.05567099f, 
    -0.01134427f, -0.01481474f, -0.06366785f, -0.18350351f, 0.03387891f, 0.07541238f, -0.15777746f, -0.00198893f, 
    -0.05145862f, 0.02749473f, 0.01037198f, 0.07181934f, -0.06450059f, -0.11989844f, -0.15078944f, -0.10681999f, 
    0.10410608f, 0.10130157f, 0.13265026f, 0.10222559f, 0.12093929f, 0.00880744f, 0.12519290f, 0.16804972f, 
    0.07233241f, -0.09700724f, -0.03447671f, 0.11411311f, -0.06365880f, 0.25608078f, 0.12126957f, 0.18095616f, 
    0.11846399f, -0.14859034f, -0.00543867f, 0.14603525f, -0.09947681f, 0.05922752f, -0.07732718f, -0.05003833f, 
    -0.04910986f, -0.01053501f, 0.02087102f, 0.02463948f, -0.00942210f, -0.05621436f, 0.01331929f, -0.01823187f, 
    0.01141543f, 0.02392073f, 0.01190821f, 0.02568539f, 0.02707867f, -0.01865986f, -0.04582673f, 0.01080458f, 
    -0.01277866f, 0.03249918f, -0.03290084f, 0.01953693f, -0.01971086f, 0.03984226f, -0.00421845f, -0.01796325f, 
    0.01833553f, -0.01703916f, -0.00808076f, -0.03087845f, -0.02308287f, -0.04427506f, -0.03316910f, -0.03863201f, 
    0.01589950f, 0.02069808f, 0.02535144f, -0.03896482f, -0.02846709f, -0.02352408f, -0.04386362f, 0.00506080f, 
    0.00163983f, 0.02332048f, -0.03367545f, 0.01775101f, 0.04174485f, -0.03158477f, -0.00740369f, 0.03221908f, 
    0.04174586f, -0.02821729f, -0.02253929f, -0.00532577f, 0.01692110f, -0.03196439f, 0.01921015f, 0.04286287f, 
    -0.03369964f, 0.03357403f, -0.02228366f, -0.03334729f, 0.03634461f, -0.05052511f, 0.00442216f, 0.00953404f, 
    -0.03852695f, 0.02984038f, -0.00142758f, -0.03783698f, 0.01404935f, 0.03880790f, 0.02736472f, 0.04093344f, 
    -0.02886695f, 0.03167157f, 0.02272459f, 0.00589666f, -0.00216100f, 0.00363461f, 0.03455864f, -0.00896393f, 
    -0.05403829f, 0.01690143f, 0.02658542f, -0.02562498f, -0.03453134f, -0.02633479f, -0.00656970f, -0.01190992f, 
    0.03309315f, -0.01598068f, -0.04130649f, -0.03773889f, -0.00370628f, -0.02685706f, -0.03342185f, 0.01646053f, 
    -0.05620689f, 0.04010567f, -0.05382332f, 0.02575984f, -0.00877097f, 0.04148011f, -0.00423046f, 0.02395451f, 
    -0.01481677f, 0.04149494f, -0.02794166f, -0.05290778f, -0.04829663f, -0.03385904f, -0.04005019f, -0.02094224f, 
    0.00775182f, 0.04472233f, -0.03956992f, -0.03625880f, 0.01098441f, -0.00928180f, 0.00412622f, -0.04700465f, 
    -0.05038707f, 0.02671722f, -0.00071986f, 0.01020417f, -0.02730559f, -0.04120690f, -0.04575869f, -0.00208713f, 
    -0.05308322f, 0.00739494f, 0.01227019f, 0.01398170f, 0.02895733f, 0.04325157f, -0.02365255f, -0.04462191f, 
    0.03722724f, 0.00890451f, 0.03882644f, 0.02618975f, -0.02731541f, -0.00079983f, 0.02250673f, -0.05202121f, 
    -0.04067937f, -0.00553309f, -0.01485530f, -0.00797457f, -0.04349178f, 0.04227782f, -0.05503870f, 0.00402350f, 
    -0.03093460f, -0.04382871f, 0.03825250f, 0.01849509f, -0.02565180f, -0.04410120f, -0.05063136f, -0.02524202f, 
    0.00429304f, -0.04430441f, 0.03043005f, -0.05100861f, -0.05500473f, -0.00077411f, -0.03576384f, -0.01973558f, 
    -0.03797045f, -0.00934743f, 0.00238572f, -0.05200921f, -0.01467355f, -0.04612144f, 0.01219836f, 0.00133619f, 
    -0.01349099f, -0.03090973f, 0.02108459f, -0.01860216f, -0.03230194f, 0.01063680f, 0.00680862f, 0.00738779f, 
    -0.04222937f, 0.00614287f, 0.01789945f, -0.00793337f, 0.00503239f, 0.03341287f, 0.00628274f, -0.03812417f, 
    -0.01955977f, 0.02377623f, -0.00134850f, 0.02092681f, 0.03063203f, 0.01015905f, -0.04382404f, -0.00482431f, 
    -0.05473639f, -0.05680750f, -0.02343135f, 0.01367606f, 0.03530656f, -0.01939383f, -0.04326636f, 0.01053123f, 
    -0.01388428f, -0.04719998f, -0.02039871f, 0.00295404f, -0.01140498f, -0.01211071f, 0.00991239f, -0.01611740f, 
    -0.03479423f, 0.03357586f, 0.04115932f, 0.04162177f, 0.01936224f, -0.00041000f, 0.02778300f, 0.01282533f, 
    0.03379431f, 0.03515624f, 0.00284146f, 0.02049540f, 0.00362233f, 0.02090153f, -0.03012085f, -0.02621808f, 
    -0.02800344f, 0.01181358f, -0.02283587f, -0.02218560f, -0.04948436f, -0.02633902f, 0.01556733f, -0.05668788f, 
    -0.02378455f, -0.00945685f, 0.02940992f, -0.05506711f, -0.04227588f, -0.03367440f, -0.05407429f, 0.00153581f, 
    0.03196031f, -0.05240060f, -0.03749356f, 0.01734327f, -0.04531902f, 0.00736078f, -0.02075923f, 0.00982429f, 
    -0.00969445f, 0.01547604f, 0.01143042f, -0.02728741f, -0.04414247f, -0.01148695f, -0.01917639f, -0.03226233f, 
    -0.02274088f, 0.01164362f, 0.00448910f, -0.03009239f, -0.00247466f, 0.00492285f, -0.04188802f, -0.04247657f, 
    -0.04135182f, -0.01809436f, -0.03560541f, 0.04239868f, 0.03227015f, -0.00133976f, 0.04332721f, 0.02043429f, 
    0.01536158f, -0.04723169f, -0.02626548f, -0.00872065f, 0.03904247f, -0.03032133f, -0.05249483f, -0.00977618f, 
    0.04501310f, -0.04163986f, -0.01995616f, -0.03932793f, -0.02195745f, -0.02045129f, -0.04464434f, 0.00174350f, 
    0.04233416f, -0.01938532f, -0.00883744f, -0.03400380f, -0.05317318f, 0.04079269f, -0.04910937f, 0.01691639f, 
    -0.01384724f, -0.03462972f, -0.03019980f, 0.03404341f, -0.03891951f, -0.05590839f, -0.03717748f, 0.00621339f, 
    -0.00014618f, -0.00846819f, -0.04764577f, 0.01154802f, 0.02046168f, 0.01365988f, -0.01098237f, 0.00609072f, 
    0.04043052f, -0.02688257f, -0.03089966f, 0.00086644f, 0.01577398f, -0.00326843f, -0.02795798f, -0.01046167f, 
    0.00624389f, -0.03295152f, -0.03999137f, 0.01770422f, -0.04167376f, -0.02489106f, 0.01568400f, -0.01584920f, 
    0.03041442f, 0.04194488f, -0.05304678f, -0.00996909f, -0.02328806f, -0.02577239f, -0.03500512f, 0.03674258f, 
    0.03225742f, -0.02160647f, 0.02621982f, -0.03970625f, 0.01077646f, -0.04455609f, -0.03655959f, -0.02747461f, 
    -0.04058448f, -0.04664968f, -0.01940398f, 0.00364171f, 0.02704110f, -0.02125138f, 0.03602349f, 0.00510661f, 
    -0.04063997f, -0.04969625f, -0.01395370f, -0.00853190f, 0.03870843f, 0.00609921f, 0.03049786f, 0.00217468f, 
    0.01526197f, 0.03187713f, -0.00214072f, 0.01672831f, -0.02016352f, 0.03807236f, 0.03479134f, 0.01493459f, 
    0.02983108f, -0.00522120f, -0.04902345f, 0.00217687f, 0.02241537f, 0.03492257f, 0.01483266f, 0.02365115f, 
    0.00224624f, -0.02644910f, 0.00988742f, 0.02316712f, -0.00015574f, 0.04512543f, -0.04511739f, -0.01770441f, 
    0.00281107f, -0.00318336f, -0.02155660f, -0.01833102f, -0.04906293f, -0.05202897f, 0.00452795f, 0.00828127f, 
    -0.00159062f, 0.04971466f, 0.02888248f, 0.01228864f, -0.02487916f, -0.04015058f, -0.05436748f, 0.00978905f, 
    0.02486860f, -0.00668342f, 0.02721706f, -0.00435598f, -0.01936195f, -0.04635270f, -0.02296423f, 0.03521117f, 
    -0.00648663f, -0.00110066f, 0.01245687f, -0.03137534f, 0.04389681f, -0.01290380f, -0.01105080f, 0.04112619f, 
    -0.00728517f, -0.01112018f, 0.00629092f, -0.05030706f, 0.02999398f, -0.00412169f, 0.03672139f, -0.01739961f, 
    -0.00371714f, 0.00091613f, -0.02075941f, -0.02130320f, -0.02671209f, -0.02035270f, 0.04389896f, -0.03107912f, 
    0.00388488f, 0.02049059f, 0.02849013f, -0.02253064f, 0.04184976f, -0.04143619f, 0.00929637f, 0.02259357f, 
    -0.05022242f, -0.00262153f, -0.01826751f, -0.00341914f, -0.04775750f, 0.00156868f, -0.02556539f, -0.01438357f, 
    -0.03961625f, 0.00485389f, 0.04022249f, 0.02931401f, -0.01743352f, -0.03014232f, -0.00042669f, -0.04249305f, 
    -0.03087828f, -0.01356581f, 0.02430028f, -0.04422445f, -0.01519371f, 0.00536878f, 0.00556743f, 0.01387719f, 
    0.01474657f, 0.01414711f, 0.02355272f, 0.03610542f, -0.01462011f, 0.02907781f, 0.02729215f, 0.00654905f, 
    0.01799598f, 0.00508284f, -0.00392376f, -0.04705950f, -0.03700069f, 0.02095575f, -0.00808080f, 0.03926126f, 
    0.01463467f, -0.00295281f, -0.02918506f, -0.02476818f, -0.04303626f, -0.01685541f, -0.00138750f, -0.05146788f, 
    0.02197793f, -0.03083726f, 0.00541389f, -0.04258989f, -0.01266230f, 0.04112225f, 0.03320229f, -0.00829660f, 
    -0.01869928f, 0.01797525f, 0.02471099f, -0.00208554f, 0.01784323f, 0.02412447f, -0.00849526f, 0.01659427f, 
    0.02591744f, -0.03255655f, -0.01630493f, 0.02640438f, 0.00884923f, 0.03943663f, 0.03477133f, -0.01318970f, 
    0.00571262f, -0.02943710f, -0.00039662f, -0.02334668f, 0.01137375f, -0.04756574f, 0.03250205f, -0.04289734f, 
    0.02332959f, -0.00992924f, -0.00459584f, -0.00355530f, -0.02917547f, 0.00532299f, 0.02981885f, -0.04025590f, 
    -0.01027908f, -0.01430038f, -0.02601949f, -0.05405893f, -0.02160275f, -0.00679637f, -0.03963091f, -0.04466570f, 
    -0.04688503f, 0.04185915f, 0.02613020f, -0.05062223f, 0.04090046f, 0.02727219f, 0.01266886f, -0.02012438f, 
    -0.04386217f, 0.04331760f, -0.03724563f, -0.04670748f, 0.00830470f, -0.02005964f, 0.00405240f, 0.02356348f, 
    0.00989785f, -0.04139734f, -0.02236316f, 0.02705572f, -0.00243876f, -0.00859109f, 0.01873495f, -0.00460690f, 
    -0.03357276f, -0.03609625f, 0.02985871f, -0.03961360f, -0.01272263f, -0.02488802f, -0.01859283f, 0.01048611f, 
    -0.00527807f, -0.01953035f, 0.00491925f, 0.02316787f, -0.00242023f, 0.02906276f, 0.04432860f, 0.00618138f, 
    0.00779041f, -0.00031534f, 0.00441692f, 0.03554813f, -0.00576663f, 0.00459724f, -0.01947017f, -0.03977488f, 
    -0.01154768f, -0.01448401f, -0.00887287f, -0.00184031f, -0.01295202f, -0.02710723f, 0.00910646f, -0.03198999f, 
    0.01466783f, -0.03227664f, 0.00258522f, -0.02041169f, -0.03863225f, -0.01502589f, -0.00599431f, 0.03632840f, 
    -0.00857048f, 0.00816214f, -0.03253328f, -0.03155283f, 0.03200725f, -0.00796633f, -0.01651063f, 0.02877641f, 
    -0.03134468f, 0.02189422f, 0.03743406f, -0.04474037f, -0.02814414f, -0.02873209f, -0.04190905f, -0.03735265f, 
    -0.00084310f, 0.00986508f, -0.03368392f, 0.04812470f, -0.03343455f, -0.02505253f, -0.02538325f, -0.00546282f, 
    -0.03755073f, -0.01249781f, -0.01696463f, -0.04780217f, -0.01457279f, -0.03228119f, -0.02962373f, 0.01718139f, 
    0.03178968f, -0.00928313f, -0.02511151f, -0.02266285f, -0.04509617f, -0.01336104f, -0.01778017f, 0.02995465f, 
    0.02747225f, -0.03837108f, 0.01942314f, 0.00528573f, 0.04224261f, -0.02709992f, 0.02172041f, -0.04992238f, 
    -0.05658754f, 0.00253462f, 0.01008819f, -0.01250012f, -0.02289441f, 0.00430473f, 0.00994369f, -0.03372027f, 
    0.00015295f, -0.04731700f, 0.00899555f, 0.01499017f, 0.00531207f, 0.00606107f, 0.00553855f, 0.00525375f, 
    0.04280150f, -0.02677299f, -0.02839943f, -0.04828214f, -0.01600429f, -0.03019454f, -0.03127915f, 0.02278904f, 
    -0.01858774f, 0.02976236f, 0.03428590f, -0.01901877f, 0.02244229f, 0.00132145f, -0.00134253f, -0.03002531f, 
    0.01589510f, -0.04659093f, -0.02338185f, 0.01961812f, -0.03077323f, 0.01921343f, 0.02294784f, -0.03791200f, 
    -0.02639551f, -0.01921137f, -0.04191497f, -0.05068471f, 0.02397004f, -0.03546481f, -0.00603319f, 0.03995267f, 
    -0.04266342f, 0.03206401f, 0.00511490f, -0.00023120f, -0.03059791f, 0.04402106f, -0.01455746f, -0.01738815f, 
    0.02105134f, -0.03339586f, -0.05598087f, 0.04096634f, 0.04754496f, -0.00817768f, 0.04083937f, 0.00065050f, 
    0.02905418f, -0.04816113f, 0.01327914f, -0.00115624f, -0.00989564f, 0.04270912f, -0.00882948f, -0.00265530f, 
    0.03236014f, -0.03849167f, -0.00576692f, 0.04280933f, -0.04388371f, -0.02050711f, 0.01582342f, -0.00397232f, 
    -0.05531647f, 0.03455847f, -0.00314216f, 0.02942414f, -0.03760385f, -0.01661890f, 0.00436605f, 0.03650277f, 
    -0.04319073f, 0.00280880f, 0.04308901f, -0.02986742f, -0.00493293f, -0.00108672f, -0.02614386f, -0.04646513f, 
    -0.03433532f, -0.04066464f, -0.03127584f, 0.01787164f, -0.02492998f, -0.02650179f, -0.05551090f, -0.01743771f, 
    -0.03052123f, -0.04184588f, -0.04585654f, -0.01893699f, -0.01144302f, -0.04451456f, 0.03135474f, 0.00952849f, 
    -0.00003658f, -0.01124265f, -0.00460543f, 0.01835084f, -0.02460336f, -0.03273256f, 0.00336107f, -0.04560439f, 
    0.01767129f, -0.03951443f, -0.01359664f, -0.02430793f, 0.05164543f, 0.01557087f, 0.00037499f, -0.00816044f, 
    0.00488694f, -0.02583466f, 0.01254666f, -0.00697012f, 0.02255510f, -0.02891687f, -0.00623006f, 0.03159822f, 
    -0.04439527f, 0.01966375f, -0.04111393f, -0.04546473f, 0.01946174f, -0.05264953f, 0.00012168f, -0.00337230f, 
    0.00067599f, -0.05512511f, -0.00110290f, 0.00089811f, 0.03705456f, -0.00431926f, -0.04998845f, 0.03478306f, 
    -0.01755672f, 0.00439108f, -0.00683749f, -0.04732151f, -0.04959833f, 0.02638437f, -0.05084452f, 0.04113528f, 
    -0.02801927f, -0.05142468f, 0.00641506f, 0.01640264f, -0.01589108f, -0.01371677f, 0.03103605f, -0.02151771f, 
    0.02287077f, -0.02200794f, 0.01676169f, 0.03154684f, -0.03939193f, 0.00973966f, -0.01494687f, 0.02269983f, 
    0.00540829f, 0.01543124f, -0.04001926f, -0.04181614f, -0.00853602f, 0.02522887f, -0.02201145f, -0.02494737f, 
    0.01355933f, 0.03925305f, 0.03324721f, -0.03105102f, 0.02852071f, -0.05582817f, 0.04305050f, -0.00860143f, 
    -0.05000575f, 0.00676004f, 0.03759860f, -0.05377372f, 0.02899492f, -0.05306478f, -0.04826645f, -0.00416962f, 
    0.01573361f, -0.00952128f, 0.04163803f, -0.02607562f, 0.02326756f, 0.03952880f, 0.01715251f, 0.03328175f, 
    0.00349009f, 0.03190525f, 0.01237365f, -0.04061572f, 0.02563151f, -0.01044438f, 0.01905849f, -0.03360329f, 
    -0.05550008f, -0.00965116f, 0.00600578f, -0.02344462f, -0.01653368f, 0.02887218f, 0.02373538f, 0.00647523f, 
    -0.04067398f, -0.02679249f, 0.04611713f, -0.00286620f, 0.00448823f, 0.00627121f, 0.02701411f, -0.03587906f, 
    0.02687380f, 0.04121859f, 0.03409199f, -0.05422100f, 0.01045223f, -0.04722589f, -0.01412387f, 0.00007489f, 
    -0.02401254f, -0.01138594f, 0.03954594f, 0.00335144f, 0.03884463f, -0.01544391f, -0.04778572f, -0.03222154f, 
    -0.05324799f, 0.03929956f, 0.03070978f, 0.04116664f, 0.01345134f, 0.02075186f, -0.04433271f, -0.00366750f, 
    -0.01569272f, -0.05013724f, 0.00978860f, -0.04578493f, 0.03099372f, 0.00092888f, 0.01319687f, 0.00802449f, 
    0.02339247f, 0.02989660f, -0.03615893f, 0.03431530f, 0.01625068f, -0.01559971f, 0.00900184f, -0.04141492f, 
    -0.04654351f, -0.00760388f, -0.00669977f, -0.01439027f, 0.02080345f, -0.04072488f, 0.00508028f, -0.01440675f, 
    0.00080635f, -0.02516671f, -0.01802013f, -0.04816595f, -0.00490838f, 0.02871084f, 0.00934550f, -0.03375392f, 
    -0.04901050f, -0.01763709f, -0.01982072f, -0.04790200f, -0.04694734f, 0.02916986f, 0.02698494f, 0.03383356f, 
    -0.05790259f, 0.00779159f, 0.00233914f, -0.02881952f, 0.02088207f, -0.00918349f, -0.04800133f, -0.01321858f, 
    -0.00930438f, 0.03051919f, -0.02620908f, -0.02463366f, 0.04729711f, -0.02196050f, -0.04583124f, -0.00682956f, 
    -0.00933963f, 0.03827925f, -0.03668130f, 0.02836045f, 0.03951780f, 0.02145943f, 0.00005286f, 0.00774860f, 
    0.00769670f, 0.02255587f, -0.01347569f, 0.00945469f, -0.05064283f, 0.02611497f, -0.04084456f, -0.04661233f, 
    -0.01515198f, -0.05153925f, -0.03585105f, -0.00789544f, 0.01481576f, -0.04915465f, 0.03005833f, 0.04248361f, 
    -0.04001166f, -0.00565764f, 0.03391604f, 0.03312278f, -0.01152639f, -0.01433394f, 0.03768161f, -0.03686092f, 
    -0.02319630f, -0.04016406f, -0.01663047f, 0.00710385f, -0.04102742f, 0.03106944f, -0.01316844f, -0.03173649f, 
    0.04874030f, -0.02223772f, 0.04565272f, -0.03372902f, 0.04029397f, 0.03142329f, 0.00417826f, -0.01458072f, 
    -0.02271399f, -0.01794074f, 0.04246654f, -0.01384199f, -0.01830051f, -0.01634635f, 0.05000399f, 0.04058582f, 
    -0.02359883f, -0.01111747f, 0.02547210f, -0.04799417f, 0.04778853f, 0.04158339f, -0.03767802f, -0.02776573f, 
    0.03175535f, -0.05923201f, -0.01347898f, -0.01061615f, 0.01399585f, 0.01637466f, -0.04628159f, -0.03308343f, 
    -0.04919671f, -0.04759453f, 0.04286935f, 0.01595284f, -0.04681591f, -0.02370465f, 0.02502839f, -0.03395132f, 
    -0.04450166f, 0.00935730f, -0.01094392f, -0.01528697f, 0.04632476f, -0.04188470f, 0.01913003f, -0.01713705f, 
    0.00269340f, -0.00867818f, -0.03782552f, -0.00683237f, 0.02406402f, -0.02790121f, 0.03731943f, 0.00442486f, 
    -0.01304417f, -0.01019246f, -0.01504708f, 0.03702273f, 0.00988128f, 0.00733702f, 0.03525150f, -0.04775873f, 
    -0.04913861f, -0.05610294f, -0.01367854f, -0.04765370f, -0.01200665f, -0.00184361f, -0.04054172f, 0.02169759f, 
    0.00581541f, 0.04056974f, 0.03759829f, 0.01515863f, -0.01253195f, 0.00217204f, 0.02467977f, -0.04183246f, 
    -0.01282749f, -0.01300512f, -0.04458343f, 0.01244552f, -0.04697637f, 0.00879586f, 0.02342891f, 0.01433507f, 
    0.01836093f, 0.02158643f, 0.02416369f, -0.02136371f, -0.03348385f, -0.00055646f, 0.00521139f, -0.04245281f, 
    -0.00524017f, -0.04237372f, 0.02443500f, 0.02033556f, 0.02117526f, 0.02674649f, 0.00738799f, -0.05351180f, 
    -0.00935904f, -0.03148609f, 0.00684287f, 0.03678221f, -0.04692316f, -0.04759895f, -0.02991419f, -0.04392595f, 
    -0.02670272f, 0.03686790f, 0.00676970f, 0.02130199f, 0.03665935f, 0.02625605f, -0.04156693f, -0.01519834f, 
    -0.04876515f, -0.03889906f, 0.02919314f, 0.02696804f, 0.03226406f, -0.01295863f, -0.01271197f, -0.04739263f, 
    0.02691151f, -0.04184640f, 0.00434092f, -0.02446504f, 0.02164439f, -0.05010834f, -0.02402173f, -0.00378045f, 
    -0.03018829f, 0.04034129f, 0.00279284f, -0.00442572f, -0.00110240f, -0.01104356f, -0.04902368f, -0.00722821f, 
    -0.11262689f, 0.12409693f, -0.08222603f, -0.24858782f, 0.01861906f, -0.03555984f, 0.07545988f, 0.09258554f, 
    0.09316695f, -0.10282154f, 0.03446476f, 0.13163169f, 0.11092690f, 0.62260079f, -0.33698946f, 0.10214679f, 
    0.05120975f, -0.18619347f, 0.00904674f, -0.07827190f, -0.08288310f, -0.04823100f, -0.10292342f, 0.02391628f, 
    -0.71940970f, 0.16376585f, -0.29335347f, -0.03043237f, -0.20263427f, 0.00853411f, -0.00017801f, 0.26291466f, 
    -0.12250384f, -0.13654745f, -0.15974233f, -0.02004691f, -0.01411711f, -0.09593562f, 0.03590049f, 0.20900276f, 
    0.05730620f, 0.17689830f, -0.09747065f, 0.25174171f, -0.09602904f, -0.08565170f, 0.00595527f, -0.06068331f, 
    0.08091106f, 0.12999955f, -0.22072431f, -0.07350234f, -0.03253128f, 0.15216340f, 0.02002428f, 0.08593307f, 
    0.05299586f, -0.01321431f, -0.03168975f, -0.06124413f, 0.32922682f, -0.02775927f, 0.27304175f, -0.14304113f, 
    0.12414069f, 0.10567208f, 0.05713418f, 0.07886300f, -0.05392579f, 0.15054086f, 0.07051836f, 0.09920057f, 
    0.33965772f, -0.16811882f, -0.17858331f, 0.17316197f, -0.05577969f, -0.09793922f, -0.03132433f, -0.03324616f, 
    0.04083634f, 0.03210654f, 0.03821032f, 0.04779793f, -0.03609855f, -0.02712682f, -0.14219461f, -0.02818764f, 
    0.07132922f, 0.16348815f, -0.04590886f, -0.02544003f, 0.06098107f, -0.04659868f, -0.10973118f, -0.01366974f, 
    0.21309063f, 0.23974113f, 0.21056257f, -0.08823515f, -0.00152500f, -0.01808816f, 0.08254479f, -0.12812987f, 
    0.16826710f, -0.08392708f, -0.03885512f, 0.07920120f, -0.05788137f, -0.02138518f, 0.02307967f, -0.07382453f, 
    -0.15551883f, -0.09969471f, 0.05540719f, 0.00981642f, -0.04432089f, 0.02403286f, 0.09821624f, -0.06811049f, 
    0.14372800f, 0.12776476f, 0.10041259f, 0.04387869f, 0.04194179f, 0.14256953f, 0.03302295f, 0.08161236f, 
    0.05336121f, 0.04293538f, -0.00643407f, -0.04027986f, -0.04523162f, 0.02260357f, -0.08840469f, 0.02824366f, 
    -0.00179213f, 0.06715951f, 0.07622873f, -0.09171233f, 0.06171494f, 0.05915541f, 0.13639943f, 0.16833812f, 
    0.01442447f, -0.10981891f, 0.04213584f, -0.10497828f, -0.05934834f, 0.13963301f, 0.04422911f, -0.10927275f, 
    -0.22143355f, 0.02188664f, -0.06129998f, -0.03159055f, 0.10081007f, -0.04901570f, -0.03536192f, -0.14350654f, 
    -0.03707526f, -0.14700247f, -0.08275889f, 0.10678156f, -0.03126345f, 0.00794361f, 0.14017373f, -0.05809582f, 
    0.29931608f, -0.06743019f, -0.20855992f, -0.14505395f, -0.01048077f, 0.02309238f, -0.08156858f, -0.01879094f, 
    0.01750343f, -0.07913310f, 0.09281386f, -0.15936917f, 0.02168255f, 0.10172863f, 0.47730690f, -0.19224188f, 
    -0.03660057f, 0.04196246f, 0.12637272f, 0.36583486f, -0.02060647f, -0.06260773f, -0.01156818f, -0.07441093f, 
    0.11185042f, 0.06102011f, 0.19647790f, 0.11042398f, -0.06556963f, 0.19998340f, -0.10537177f, 0.15936832f, 
    -0.10130319f, -0.16941647f, 0.03785311f, -0.06734095f, 0.06256250f, -0.11183265f, 0.09636025f, -0.00968388f, 
    -0.03891394f, -0.06151596f, -0.09889768f, 0.17649817f, -0.04954674f, 0.06262876f, -0.11453518f, -0.03829313f, 
    -0.39792633f, -0.29008082f, -0.27502584f, -0.09038935f, -0.19523773f, 0.01122210f, -0.06258733f, -0.00629049f, 
    -0.05033888f, -0.05956149f, -0.00143555f, 0.03460227f, 0.11103350f, -0.19612837f, 0.02416838f, 0.00875278f, 
    -0.05362978f, -0.02427307f, -0.04540143f, -0.00340661f, 0.11985746f, -0.10083149f, -0.05188625f, -0.08343716f, 
    0.03806233f, 0.23233072f, -0.34907144f, -0.00111727f, 0.02508474f, -0.06786848f, 0.09434494f, 0.05182751f, 
    0.06980199f, -0.01275183f, -0.01657285f, 0.05604504f, 0.06995205f, 0.22727807f, -0.11819774f, -0.13282251f, 
    0.05243866f, -0.14703441f, 0.07272878f, 0.12816347f, 0.07011949f, 0.09736895f, -0.02432723f, 0.12321464f, 
    0.10311450f, -0.07854996f, -0.23699296f, 0.05186608f, -0.08115326f, 0.05753731f, 0.07943673f, -0.19511944f, 
    -0.05045639f, -0.04273722f, 0.15209328f, 0.05790920f, 0.07192403f, 0.22189434f, 0.23657066f, 0.25698027f, 
    0.09971924f, 0.08367922f, -0.00849493f, 0.02946078f, -0.03017332f, 0.05068086f, 0.10835407f, 0.04808849f, 
    0.28299239f, -0.08845697f, -0.04147096f, -0.29248306f, -0.09190121f, -0.04096143f, 0.06711656f, 0.11130827f, 
    0.19828357f, -0.06144159f, -0.06791262f, 0.03257175f, 0.03467108f, -0.14006625f, 0.33505988f, -0.15435383f, 
    0.05875961f, 0.04550235f, -0.00235921f, 0.08758211f, -0.02849848f, 0.08730687f, -0.03391400f, -0.02145158f, 
    0.14946145f, 0.48455775f, -0.00988178f, 0.20918973f, 0.03990930f, 0.00331261f, 0.13860449f, -0.05721607f, 
    0.10916302f, -0.08451750f, -0.24538404f, -0.25076485f, 0.22632140f, 0.09083445f, 0.03400094f, 0.21586683f, 
    -0.08989564f, 0.10654613f, 0.07358575f, -0.05835979f, 0.05757284f, -0.02851463f, 0.03649926f, 0.03899045f, 
    0.11258620f, 0.07734324f, 0.05312959f, -0.06739716f, -0.02590410f, 0.06272830f, -0.05279076f, 0.01817738f, 
    0.08855353f, 0.04709188f, 0.03104496f, 0.07854868f, 0.09315766f, 0.05261514f, 0.10036712f, 0.21269403f, 
    0.02646608f, 0.04323369f, 0.06605151f, -0.08223429f, 0.10489464f, 0.02539244f, 0.01509168f, 0.32361555f, 
    0.19379464f, 0.13783343f, 0.17568956f, 0.19447869f, 0.06797064f, -0.02470431f, 0.00817759f, 0.01437018f, 
    -0.08643121f, 0.01803550f, 0.09578400f, 0.00730638f, -0.14335087f, 0.36240801f, 0.10002994f, 0.16290437f, 
    0.09686892f, -0.06092292f, -0.01298213f, -0.05833799f, 0.05452184f, 0.00562389f, 0.06143945f, 0.02826348f, 
    -0.03855232f, -0.04394757f, 0.04329853f, 0.04228081f, -0.03688930f, 0.03636761f, 0.00257790f, -0.01375401f, 
    -0.00680426f, -0.03531009f, -0.00116588f, -0.01890247f, -0.05108139f, -0.05144442f, -0.01330542f, -0.05706806f, 
    -0.03448164f, -0.05515284f, 0.02484581f, -0.00166791f, 0.00121837f, 0.00215465f, -0.01037752f, -0.03744796f, 
    0.02547724f, -0.04579282f, -0.00170762f, 0.01366698f, 0.01656196f, -0.02237241f, -0.02338383f, -0.02577963f, 
    -0.02994491f, 0.03544009f, 0.02487973f, -0.05017734f, -0.01256489f, -0.04996864f, 0.00944231f, 0.01521181f, 
    -0.05137903f, -0.00403000f, 0.01680445f, 0.01713979f, 0.04517151f, -0.01941286f, -0.00144121f, 0.04212014f, 
    -0.03768070f, 0.00292013f, 0.00108307f, -0.05897034f, 0.03097947f, -0.00974543f, 0.00478874f, -0.02091664f, 
    -0.00917005f, 0.04089949f, -0.02104924f, 0.02077898f, 0.02966090f, -0.04201096f, -0.00648135f, -0.02602917f, 
    0.01126485f, 0.03781205f, -0.04547736f, -0.01370667f, -0.02176008f, -0.03955289f, -0.01980326f, 0.00912216f, 
    0.00704751f, 0.02335540f, 0.04333907f, -0.01230702f, 0.00813150f, 0.02151851f, 0.00798463f, -0.03703372f, 
    0.02670247f, 0.01544013f, -0.01545106f, 0.03098934f, -0.00445609f, -0.02677896f, 0.01327695f, -0.01477300f, 
    -0.02448482f, -0.04717762f, 0.00392039f, 0.03527963f, 0.04524887f, 0.03916042f, -0.04113268f, -0.03254092f, 
    0.02047339f, -0.03808383f, 0.03433256f, 0.02250882f, -0.01230037f, -0.05984485f, 0.01652185f, 0.00951704f, 
    -0.03504889f, 0.02751555f, -0.00688805f, -0.00988754f, 0.02341145f, 0.03730394f, 0.02449142f, -0.02633627f, 
    0.01152756f, 0.03142652f, 0.02410802f, 0.01653537f, -0.04446202f, -0.03346460f, -0.05851137f, -0.00691868f, 
    -0.05032442f, -0.05192311f, -0.02061239f, -0.05008811f, -0.02779872f, 0.01145185f, -0.02782694f, -0.03740473f, 
    0.00761917f, -0.02247569f, 0.02649609f, -0.02394987f, -0.03920746f, -0.02165426f, 0.03149296f, -0.01521582f, 
    0.00693183f, -0.02355999f, -0.01847948f, -0.03593568f, 0.02160025f, 0.01711501f, -0.01666115f, 0.02462232f, 
    0.01944480f, -0.05650107f, -0.03980504f, -0.00086987f, -0.02723868f, -0.04742366f, -0.03929969f, -0.03695608f, 
    0.04072966f, 0.00394908f, -0.05389738f, 0.01372311f, -0.00929116f, 0.00815393f, -0.05720398f, -0.05930765f, 
    -0.04992034f, -0.03826179f, -0.03787738f, 0.02753695f, 0.01475383f, -0.01395972f, -0.05358551f, 0.03327756f, 
    0.01879557f, -0.01392749f, 0.04420232f, -0.03245014f, -0.03872578f, 0.01854633f, 0.03295923f, 0.04682666f, 
    -0.01872435f, -0.03095194f, -0.02746047f, -0.05272935f, -0.03067262f, -0.02940210f, 0.00538887f, 0.02771105f, 
    0.03255552f, -0.02132463f, 0.02629859f, -0.05145908f, -0.01652067f, -0.04793643f, 0.01904826f, -0.04761214f, 
    -0.05302135f, 0.03795898f, -0.02614784f, -0.04234031f, 0.02920206f, 0.00449717f, -0.05563972f, 0.00580883f, 
    -0.05220903f, 0.01708091f, -0.00644188f, -0.01690053f, 0.00013003f, 0.02802148f, -0.01446758f, 0.02208383f, 
    0.05351225f, -0.03133303f, 0.01674312f, 0.03482413f, 0.00763230f, -0.02267757f, 0.00929198f, 0.04171820f, 
    0.02754630f, -0.01607012f, 0.00501583f, 0.04469352f, -0.00994444f, -0.00560992f, -0.05631357f, 0.00841212f, 
    0.03186221f, 0.03767809f, 0.04308914f, 0.01649422f, 0.00338028f, 0.00733479f, -0.01388579f, -0.02173724f, 
    -0.02879589f, 0.03303478f, -0.04403665f, 0.01233298f, -0.03392738f, -0.05327715f, -0.01749815f, -0.01507380f, 
    -0.04789798f, 0.03146341f, -0.02198803f, 0.03401794f, 0.01714555f, 0.03943657f, -0.00484836f, 0.03916802f, 
    -0.02681540f, 0.01110161f, 0.01702256f, 0.01732643f, 0.00522139f, -0.04087529f, -0.02532386f, -0.03356400f, 
    -0.01494511f, -0.00378901f, -0.04596996f, 0.02236702f, 0.02815622f, -0.05054466f, 0.00282230f, 0.04711856f, 
    0.01034550f, 0.03747850f, -0.05131909f, 0.02061692f, 0.00859457f, -0.04632172f, 0.01300023f, -0.05060313f, 
    0.02232207f, 0.02519850f, 0.03743769f, 0.02872845f, -0.03276461f, 0.01045844f, 0.02394305f, 0.01465903f, 
    0.04404677f, 0.01903917f, 0.00951636f, -0.02795901f, 0.00648460f, -0.04053469f, 0.03062137f, -0.00146109f, 
    0.03173601f, -0.01467020f, 0.02899624f, 0.00262107f, 0.02465018f, -0.02584080f, 0.02514914f, 0.02872093f, 
    -0.01910824f, 0.00803529f, -0.02614702f, 0.01323862f, 0.02244979f, 0.02201561f, 0.03813166f, -0.00726944f, 
    -0.02177691f, 0.01582313f, -0.01142345f, -0.00848564f, -0.00328568f, 0.03942632f, -0.02194437f, -0.03003721f, 
    0.01688842f, -0.05066707f, -0.01627135f, -0.00728910f, 0.00171697f, 0.03391777f, 0.03305758f, -0.04185395f, 
    0.01027189f, -0.01574724f, 0.03445901f, -0.01892902f, -0.02304896f, -0.02833583f, 0.00178893f, 0.01693339f, 
    -0.05368580f, -0.01724336f, -0.00878400f, -0.02056076f, -0.03122159f, 0.03202215f, -0.04489648f, 0.02030770f, 
    0.03644748f, -0.05031273f, -0.01934727f, -0.05265175f, -0.00836661f, -0.02009329f, 0.03193846f, 0.01096230f, 
    -0.02911294f, 0.04612607f, 0.01167304f, -0.01070447f, -0.02857550f, -0.04641489f, 0.01703071f, 0.03662877f, 
    -0.01187528f, 0.01047862f, -0.00837129f, 0.01562455f, 0.00220449f, -0.04470189f, 0.03239330f, -0.00974569f, 
    0.00288915f, -0.00763152f, -0.02512046f, 0.00686986f, 0.00892677f, 0.03011564f, -0.03924768f, -0.01622114f, 
    0.00319992f, 0.03848868f, -0.05565244f, 0.02915761f, -0.02967058f, 0.02274684f, -0.04659500f, 0.02515448f, 
    -0.00098885f, 0.04385862f, -0.05198666f, -0.05418397f, -0.02887877f, -0.02547598f, -0.01054451f, 0.00554119f, 
    -0.00961786f, -0.22811197f, -0.12224533f, -0.03857777f, 0.04390113f, -0.01720424f, 0.09552483f, 0.01824429f, 
    -0.01991122f, 0.11764072f, 0.23772524f, 0.03447414f, -0.20780374f, 0.21613626f, 0.08400549f, 0.17484587f, 
    0.09102021f, 0.09008155f, 0.22280465f, 0.07620629f, 0.11771155f, 0.05306118f, 0.25109914f, -0.01417979f, 
    -0.52633268f, 0.40444329f, 0.25182775f, 0.05239052f, 0.07409592f, -0.06601755f, 0.10756890f, -0.03047170f, 
    0.04208653f, 0.07450222f, 0.08070540f, -0.01362411f, -0.01239363f, 0.04288878f, 0.02528570f, 0.13922518f, 
    0.02823528f, 0.06062774f, 0.07806793f, 0.00725081f, 0.00133611f, 0.12768802f, 0.01137913f, -0.01252185f, 
    0.10555363f, 0.16469572f, 0.15407924f, -0.00248235f, -0.01903424f, 0.03128969f, -0.03551857f, -0.10831594f, 
    0.03421011f, -0.03859552f, -0.02888468f, 0.05193096f, -0.02517015f, -0.15254340f, -0.40986010f, 0.11543074f, 
    -0.01420491f, 0.05571522f, 0.12642789f, 0.15951882f, 0.05388493f, -0.04483642f, 0.00555256f, 0.03549790f, 
    -0.10805153f, -0.01547041f, 0.02347064f, -0.02236574f, -0.00884465f, 0.01421669f, -0.01282046f, -0.00193152f, 
    0.03533430f, -0.03260418f, 0.11246360f, 0.04479358f, -0.18325430f, -0.09686030f, 0.05238997f, 0.13897531f, 
    -0.05721387f, -0.06717334f, 0.12794392f, 0.05574477f, 0.02642476f, 0.07224920f, 0.13962963f, 0.08380639f, 
    -0.16585334f, -0.22144300f, -0.11129645f, 0.09651971f, 0.01365270f, -0.04236195f, -0.13160111f, -0.02945698f, 
    -0.05899850f, 0.03650760f, 0.02043677f, -0.01870888f, 0.10537332f, 0.01853354f, -0.14821875f, -0.03269873f, 
    0.05522869f, -0.02916555f, 0.05346131f, -0.00548528f, 0.12857889f, -0.00805802f, 0.27068171f, -0.12298077f, 
    0.14735445f, -0.19022527f, 0.19582562f, 0.00523286f, -0.11136215f, 0.19925515f, 0.25504577f, 0.12279124f, 
    -0.03431439f, 0.00958463f, -0.01036322f, -0.05510546f, 0.08754441f, 0.07784223f, 0.06639523f, -0.02990712f, 
    -0.12645054f, -0.04575934f, -0.07019422f, -0.01044157f, 0.07662450f, 0.01740557f, 0.06167843f, 0.00905187f, 
    -0.07532211f, -0.04480752f, -0.08464739f, -0.14163314f, -0.02948822f, -0.04977382f, -0.11495822f, -0.03310939f, 
    0.00241687f, -0.04430166f, -0.03177645f, 0.02764957f, 0.08941267f, 0.19250195f, -0.06169093f, 0.17633574f, 
    0.13100380f, -0.06179093f, 0.01073369f, -0.02786239f, -0.01871577f, 0.14757100f, -0.05991622f, 0.12646858f, 
    0.07934058f, 0.09127492f, 0.12866025f, -0.05445888f, 0.00559966f, -0.07590353f, -0.05732497f, -0.06827583f, 
    0.01563276f, 0.15579340f, 0.24832237f, 0.19237944f, 0.12317276f, -0.19476007f, -0.07683288f, -0.00331958f, 
    0.12494255f, 0.06715586f, -0.02082029f, -0.11945496f, -0.01063790f, 0.09723391f, 0.01763811f, -0.05909130f, 
    -0.00582262f, -0.23767464f, -0.13163549f, -0.01436317f, -0.03867266f, -0.05365590f, 0.10698932f, 0.07913146f, 
    -0.01157190f, 0.04814523f, 0.16273002f, -0.04205536f, 0.08960328f, 0.03558586f, 0.12124707f, -0.06825107f, 
    -0.02912517f, 0.06638917f, 0.17468338f, 0.07310344f, 0.00556725f, 0.03977881f, 0.02862852f, -0.01286576f, 
    -0.05829310f, 0.14972152f, -0.06664244f, 0.16575582f, -0.02814724f, -0.04708385f, 0.08805256f, 0.23871341f, 
    0.21999148f, 0.01873365f, 0.07761653f, 0.03534996f, 0.05142576f, -0.06026868f, 0.07013019f, -0.07439224f, 
    0.02964653f, -0.07568897f, -0.03479273f, -0.08291298f, 0.00268971f, 0.08303634f, 0.02672257f, -0.01716435f, 
    0.02288560f, -0.02662650f, 0.13507320f, 0.17814268f, -0.00783505f, 0.13325267f, 0.19893675f, -0.03690535f, 
    0.11833826f, 0.15782562f, 0.14521869f, -0.01367294f, -0.18130258f, -0.02419757f, -0.08071069f, 0.15916036f, 
    -0.05374388f, 0.05884344f, 0.04948916f, 0.03324316f, 0.10046387f, -0.09284439f, -0.07843838f, 0.01561560f, 
    0.02669291f, 0.19445519f, -0.05020973f, -0.09824735f, -0.02557802f, 0.00098004f, -0.15237686f, -0.02078625f, 
    0.03139528f, -0.10948825f, 0.02264979f, 0.03088304f, -0.13293929f, -0.26592800f, -0.02255623f, 0.30953479f, 
    0.06092133f, 0.22434980f, 0.11936741f, -0.01289410f, 0.06109885f, -0.10702089f, -0.05016095f, -0.04116466f, 
    0.18579501f, -0.02511564f, 0.04564089f, 0.14133947f, 0.11948789f, 0.08730744f, 0.05728930f, 0.08459637f, 
    -0.00737226f, 0.08318816f, 0.06151597f, 0.18664354f, 0.34126514f, -0.05221147f, -0.22428100f, 0.07515808f, 
    0.10655652f, 0.03409104f, 0.21234907f, 0.07899541f, 0.22610891f, 0.06967138f, 0.06238518f, 0.07118476f, 
    0.02169047f, -0.08724660f, -0.07690822f, -0.03538519f, -0.00009051f, -0.02636809f, 0.08477599f, -0.07553455f, 
    0.15295424f, 0.14821981f, 0.12696633f, 0.07566512f, -0.18404187f, -0.13887322f, 0.01818348f, 0.16865017f, 
    0.02994106f, -0.04085577f, -0.07654940f, 0.06446759f, 0.08464713f, 0.04967535f, 0.09967627f, 0.01818392f, 
    -0.30394554f, -0.23538844f, -0.10178871f, 0.09858598f, -0.01293373f, 0.02341051f, 0.01418551f, -0.02672292f, 
    0.05966293f, 0.02963263f, -0.07054117f, -0.01121440f, -0.22750115f, 0.14928432f, 0.13388696f, -0.03517979f, 
    0.05858603f, 0.04511419f, 0.00372138f, 0.07060742f, -0.00844735f, 0.01607052f, 0.16000234f, 0.12844858f, 
    -0.09729685f, -0.00894659f, -0.00716677f, 0.14057133f, -0.00971683f, 0.17274687f, 0.02996725f, 0.04761698f, 
    -0.09215984f, 0.02063052f, 0.06784093f, 0.17940763f, 0.15978698f, -0.28500268f, -0.06178217f, -0.00375959f, 
    0.02129187f, 0.16224754f, 0.03142676f, -0.02313928f, -0.01723885f, 0.05437007f, 0.04706218f, 0.01701239f, 
    0.46118590f, -0.01383860f, 0.27110958f, 0.20113292f, 0.03199256f, -0.07320101f, 0.11062291f, 0.02014766f, 
    -0.04440627f, 0.05650223f, 0.10626975f, -0.00253314f, 0.14224935f, -0.18517259f, 0.40496477f, 0.07704602f, 
    -0.02981082f, 0.03582787f, 0.09993095f, 0.18876763f, -0.03798028f, 0.05137713f, 0.09866755f, 0.13542253f, 
    0.12040795f, 0.27032951f, 0.41803670f, 0.06118361f, 0.05640978f, 0.05178793f, -0.02551967f, 0.02623132f, 
    -0.05902577f, 0.10733272f, 0.05278758f, 0.14690454f, -0.00796894f, 0.08405495f, 0.10527539f, -0.09056614f, 
    -0.02736334f, 0.09503822f, 0.15635809f, 0.03344415f, -0.06161178f, -0.01619661f, 0.00150720f, 0.07900923f, 
    0.33100733f, 0.13194321f, 0.18653992f, 0.10643118f, 0.01991198f, -0.04912738f, 0.07772534f, -0.09157805f, 
    0.07546104f, 0.03398716f, -0.10271124f, -0.13227059f, -0.31753799f, 0.03862223f, -0.32371756f, 0.01802403f, 
    0.02908957f, -0.04825234f, 0.00338089f, 0.00693985f, -0.10626099f, 0.01490931f, 0.00139171f, -0.06424153f, 
    -0.06563205f, 0.05366479f, -0.00914796f, -0.07040161f, -0.04285423f, -0.06751709f, 0.09591655f, -0.01620750f, 
    0.17157593f, 0.14519788f, -0.02173630f, 0.10400021f, -0.12842551f, 0.14544500f, 0.18504746f, 0.09442724f, 
    -0.04866346f, -0.05867238f, 0.16540048f, 0.06078334f, -0.01513178f, 0.01410386f, -0.04759123f, -0.06449554f, 
    -0.16602053f, -0.12349044f, -0.20492719f, 0.34356064f, 0.04014285f, 0.05297112f, -0.03655000f, 0.16421729f, 
    -0.13466953f, -0.03602954f, -0.05407372f, -0.00515403f, 0.21986049f, -0.16298993f, 0.04425391f, -0.06472397f, 
    0.11291863f, 0.08109743f, 0.05194771f, 0.00464452f, 0.01000398f, 0.08667950f, -0.07260989f, 0.23463570f, 
    0.07862149f, -0.12032577f, -0.02188411f, -0.20598730f, -0.12479147f, -0.10384910f, 0.21338059f, 0.04938057f, 
    -0.06070542f, 0.00479230f, 0.05776296f, 0.09161808f, 0.09804950f, 0.12966788f, 0.16014676f, -0.02976587f, 
    -0.03032238f, -0.06109200f, -0.06437133f, -0.00581317f, 0.08244547f, 0.07815447f, 0.02610915f, 0.04298322f, 
    0.02392664f, -0.02301617f, 0.06444978f, -0.09300507f, -0.12888472f, -0.06512583f, 0.05550418f, -0.00595421f, 
    -0.00661760f, -0.11979488f, 0.14349043f, 0.00376822f, -0.01562852f, 0.13946240f, 0.12496193f, -0.09551118f, 
    0.02216353f, 0.15873483f, 0.01418546f, 0.04132144f, 0.14958419f, -0.02460914f, -0.11830462f, 0.07576742f, 
    0.37804228f, 0.26066297f, 0.18397155f, 0.11576578f, -0.04487567f, -0.03045233f, 0.06043851f, -0.03052775f, 
    -0.12101947f, 0.07744542f, 0.04439189f, 0.05248852f, -0.48558345f, 0.10963672f, -0.06918157f, 0.14377372f, 
    -0.01434987f, -0.16817045f, 0.12217952f, -0.03224434f, -0.02518592f, -0.04509160f, 0.00945031f, -0.07246705f, 
    -0.27733600f, -0.20357130f, -0.23174503f, 0.18660720f, -0.04656631f, -0.05971137f, -0.01157128f, -0.06662651f, 
    -0.06393819f, 0.04673600f, 0.04630979f, 0.01966785f, -0.19558659f, 0.12930499f, 0.05429013f, -0.28343213f, 
    -0.18566099f, -0.13801979f, 0.07229093f, 0.24204889f, 0.08842120f, 0.09681943f, 0.06173881f, 0.02247646f, 
    0.02230685f, 0.46958753f, 0.17536120f, -0.06543016f, -0.11403808f, 0.04858557f, 0.02732464f, -0.07973657f, 
    0.11197978f, 0.21056195f, -0.09062840f, -0.03862882f, 0.04038718f, 0.04034634f, -0.03349112f, -0.03129272f, 
    -0.04510689f, 0.02540182f, 0.03724274f, -0.05467016f, 0.08523054f, 0.02407390f, -0.05735642f, -0.03626626f, 
    0.37361389f, -0.09420715f, 0.35417020f, 0.15123305f, -0.00844956f, -0.16293149f, 0.03015972f, 0.07330257f, 
    0.03674427f, -0.00562720f, 0.02021517f, 0.09764793f, -0.23412614f, -0.05438147f, 0.20509686f, 0.02253036f, 
    -0.01245176f, 0.02111469f, 0.08405412f, -0.02429357f, -0.08208805f, -0.04676586f, 0.00726819f, -0.17899784f, 
    0.12895578f, 0.11011790f, 0.08018560f, 0.06480352f, 0.03711197f, -0.04876640f, 0.06391420f, 0.06511505f, 
    -0.11397815f, 0.06652332f, 0.04274499f, 0.01467034f, -0.31774682f, -0.37271580f, -0.29566902f, 0.10112824f, 
    0.03018542f, 0.09545849f, -0.01907245f, -0.11945178f, -0.02243177f, -0.01930998f, -0.08001988f, -0.00572720f, 
    0.43551278f, 0.10537259f, 0.26260528f, 0.21209449f, -0.04878861f, -0.06502729f, 0.23780191f, -0.09602015f, 
    -0.00224917f, -0.06824838f, 0.04518574f, 0.12538642f, 0.03365449f, 0.12117692f, -0.17245145f, 0.12167718f, 
    -0.07581728f, 0.21032898f, 0.08147003f, -0.08412568f, -0.01756533f, 0.09868781f, 0.04633844f, -0.05448516f, 
    0.09600528f, -0.06918973f, 0.07443728f, 0.00274712f, 0.05028633f, -0.04532534f, -0.02941924f, 0.03808328f, 
    -0.19920030f, 0.06408416f, 0.14826570f, 0.04413952f, -0.28479034f, -0.10064483f, 0.07613236f, 0.01076421f, 
    -0.00558921f, 0.08028626f, -0.03253440f, 0.05527405f, 0.00892532f, -0.00745256f, -0.11941200f, 0.02408453f, 
    -0.06267580f, 0.02058015f, -0.07092807f, 0.03095134f, 0.09685787f, 0.03280614f, 0.11418512f, 0.02581750f, 
    -0.11545429f, 0.04359549f, 0.08933958f, 0.00588372f, -0.11141942f, 0.17480198f, -0.09100398f, 0.03291147f, 
    -0.00364055f, -0.02441341f, -0.01855432f, 0.07233424f, 0.00147380f, -0.00447320f, 0.00793600f, -0.14253967f, 
    -0.02685154f, -0.20650695f, -0.04573726f, -0.13576664f, -0.00973486f, 0.11320554f, 0.16515261f, 0.10559327f, 
    0.03415003f, 0.05853194f, -0.14559725f, 0.02089540f, 0.23597080f, -0.21992648f, 0.13574032f, -0.12614982f, 
    0.03859053f, 0.23879758f, 0.13467835f, -0.09691590f, 0.06673921f, 0.05549100f, 0.03656265f, 0.00586657f, 
    0.54893637f, 0.13102037f, -0.16346610f, -0.01254383f, 0.19140439f, 0.03189703f, 0.12479405f, -0.15343516f, 
    0.11191761f, 0.01573508f, 0.04292102f, 0.02981414f, 0.01827794f, 0.08457336f, 0.08412644f, 0.06410463f, 
    -0.10139977f, 0.09283517f, 0.05391011f, 0.15011270f, 0.04526541f, -0.09016508f, 0.14367528f, 0.19287299f, 
    0.27164617f, 0.04963041f, 0.08534751f, 0.11422066f, -0.03339412f, -0.01124028f, 0.00828363f, -0.08760612f, 
    0.07718214f, 0.00349528f, -0.01361454f, -0.05660991f, 0.19878733f, 0.08326520f, 0.20440644f, 0.17447065f, 
    -0.06685333f, 0.01606851f, 0.05837112f, -0.13834406f, 0.08140230f, -0.04917168f, -0.03339338f, 0.06576570f, 
    0.61241245f, 0.14682491f, 0.00797096f, 0.29566997f, -0.16804309f, -0.13995901f, -0.05963533f, -0.10447709f, 
    -0.03705078f, -0.05665630f, -0.02611533f, -0.03451931f, 0.13012511f, 0.19630736f, -0.19933900f, 0.01543409f, 
    0.12255063f, -0.10414316f, 0.04685586f, 0.10031500f, -0.02003075f, -0.03181718f, -0.05464495f, -0.18385565f, 
    -0.23496737f, -0.36299926f, -0.26454931f, -0.23882996f, 0.01789998f, 0.00237842f, -0.04958289f, 0.01484726f, 
    -0.10586840f, 0.01066865f, 0.06836858f, -0.00672064f, 0.17508857f, 0.15729743f, -0.04065190f, 0.13452227f, 
    -0.02582034f, -0.04937834f, 0.28125718f, 0.11754420f, -0.09129772f, 0.05134170f, 0.13484663f, 0.11588746f, 
    0.07310080f, 0.03171622f, -0.06856896f, 0.08797137f, 0.15187261f, 0.03964140f, -0.03526886f, 0.31800711f, 
    -0.08720712f, 0.01557066f, 0.01243790f, -0.01516303f, 0.02520565f, -0.01045218f, 0.02963349f, -0.12480005f, 
    0.12298730f, 0.00005607f, -0.15003914f, 0.08098949f, -0.07084294f, 0.10283578f, -0.04235063f, 0.01625312f, 
    -0.03329103f, -0.05889463f, 0.29487082f, -0.00800557f, -0.10116627f, -0.03500437f, 0.07430150f, 0.09245148f, 
    -0.11540231f, 0.01177303f, -0.00514846f, 0.00858383f, -0.05586128f, 0.05735980f, 0.19311951f, 0.05214444f, 
    -0.08456580f, -0.06666534f, -0.10904497f, -0.07364137f, 0.04946941f, -0.03375006f, -0.10044629f, -0.12248228f, 
    -0.02358774f, 0.07592496f, -0.06539375f, -0.06985408f, -0.11645654f, -0.14772220f, -0.08945453f, -0.13168444f, 
    -0.03161987f, -0.01476080f, -0.07147709f, 0.11564117f, 0.00995622f, 0.00915840f, 0.29028502f, -0.05066004f, 
    0.05672266f, 0.10431327f, 0.06376779f, -0.04061391f, 0.06424982f, 0.07336038f, 0.01269414f, 0.13351226f, 
    0.13195394f, -0.07138413f, -0.24508439f, -0.05710942f, -0.04046920f, -0.02682555f, -0.02332785f, -0.02915435f, 
    0.00248021f, 0.24248149f, 0.04802275f, 0.12559792f, -0.16932079f, 0.06778791f, -0.07098843f, 0.03211170f, 
    0.20225170f, -0.18230943f, 0.17697872f, -0.24642505f, -0.05100230f, -0.07126169f, 0.00740819f, -0.00042537f, 
    0.08122355f, 0.03376678f, -0.09712757f, -0.13520508f, 0.03143073f, 0.07233614f, 0.29039770f, 0.03219794f, 
    0.06643228f, -0.01842913f, 0.02641722f, 0.05771850f, -0.03983223f, 0.14380458f, 0.27086025f, 0.08824810f, 
    -0.02522182f, -0.17501266f, -0.06136512f, 0.07799342f, -0.09626962f, -0.04947878f, 0.02817344f, 0.11557789f, 
    -0.01181975f, -0.42732045f, -0.05484153f, -0.30569166f, -0.02425794f, -0.02859904f, 0.10055307f, 0.06028846f, 
    -0.05292557f, -0.05815199f, 0.03206953f, 0.00611115f, 0.03739724f, 0.08429933f, -0.04635213f, 0.14171663f, 
    -0.01436109f, -0.12738165f, -0.06652876f, -0.11768529f, -0.04401968f, -0.02100540f, -0.05593001f, -0.06624939f, 
    0.11136284f, 0.00595737f, 0.01753389f, 0.01053838f, -0.00228228f, 0.10295281f, 0.01968088f, 0.11222275f, 
    0.05726324f, 0.03393018f, 0.02165095f, -0.02799844f, 0.20721319f, -0.01849763f, -0.04207050f, -0.09192408f, 
    0.15251651f, 0.05017338f, 0.08985173f, -0.01093755f, -0.08457787f, 0.03467495f, -0.00220540f, -0.09802173f, 
    0.15193385f, 0.14856568f, 0.05594118f, 0.14058335f, -0.11143699f, -0.13382839f, 0.01464763f, -0.06726654f, 
    -0.14044222f, 0.09396622f, -0.05850171f, -0.17261052f, 0.07470945f, -0.18588838f, 0.06597362f, -0.04092308f, 
    -0.03240510f, 0.06805666f, -0.04590232f, 0.25243664f, -0.13529515f, 0.00513539f, -0.05973196f, 0.09651471f, 
    -0.04999296f, -0.01648919f, -0.08288854f, 0.05151014f, 0.12557976f, 0.12086656f, -0.06413506f, 0.02484025f, 
    -0.10414098f, 0.05134321f, 0.06311826f, 0.05658260f, -0.01803022f, -0.03061384f, -0.03248469f, -0.01599675f, 
    0.17199641f, -0.03704410f, -0.02082439f, -0.05752611f, 0.03699365f, -0.01456623f, -0.04142960f, 0.03004719f, 
    0.04459977f, -0.19091965f, -0.09723490f, -0.15908411f, -0.02818809f, 0.07450968f, -0.02545269f, -0.10685082f, 
    0.04192981f, -0.03844632f, -0.01130664f, 0.01851776f, -0.06454996f, -0.01819970f, -0.14510098f, 0.10910603f, 
    0.11785235f, 0.19118944f, 0.09860240f, 0.20070133f, -0.05083277f, 0.06828517f, 0.05277012f, 0.13543758f, 
    0.11719120f, -0.02532639f, -0.04515050f, 0.07353763f, 0.17623098f, -0.05772016f, -0.00862757f, 0.14442901f, 
    -0.10157071f, -0.04844526f, 0.11718133f, -0.17398942f, 0.00808942f, 0.12406642f, -0.13768587f, 0.02326903f, 
    -0.08818295f, -0.01771627f, 0.02140944f, 0.01799230f, 0.07627688f, 0.02957124f, -0.00414980f, -0.12547252f, 
    -0.12370878f, 0.16504382f, -0.01088939f, -0.14387104f, -0.04491814f, 0.12383264f, 0.04775489f, 0.33648071f, 
    0.10210977f, 0.07079080f, -0.05028897f, -0.00258528f, 0.16643225f, -0.05564620f, 0.26958737f, -0.19160987f, 
    -0.08308546f, 0.01740612f, -0.11911268f, 0.08795580f, 0.00147134f, -0.02444591f, -0.07986928f, -0.09016792f, 
    0.04028044f, 0.03154970f, 0.01565120f, 0.04251197f, -0.01531149f, -0.04805648f, 0.02143570f, 0.01454748f, 
    -0.01533008f, -0.04741061f, -0.03287733f, -0.05832463f, -0.05278383f, 0.03572618f, -0.03139688f, 0.01018334f, 
    -0.01675197f, -0.02297017f, -0.03698584f, 0.01639284f, -0.02790076f, -0.04591161f, 0.03496182f, -0.02390661f, 
    -0.00515532f, -0.04179238f, 0.02881935f, -0.02124130f, -0.03960578f, 0.04211474f, -0.02355866f, -0.01595709f, 
    -0.03109381f, 0.00087126f, -0.00893345f, -0.03864575f, 0.00262833f, -0.02312574f, 0.02477564f, -0.01378693f, 
    0.03429638f, -0.01930581f, 0.04682301f, -0.03825702f, -0.05775099f, 0.01766088f, -0.02545075f, -0.02460963f, 
    -0.03160684f, 0.04061891f, 0.01153841f, -0.01754887f, 0.00487628f, 0.00134002f, -0.03095358f, -0.01884032f, 
    -0.04501057f, 0.01248927f, -0.03594010f, -0.04635987f, 0.02333521f, 0.03265974f, -0.00010247f, 0.03069580f, 
    0.03224446f, 0.03558377f, -0.01384473f, 0.04644651f, -0.05198517f, -0.00222516f, -0.05685003f, -0.04299026f, 
    0.00380893f, -0.01239815f, -0.01405747f, -0.02105290f, 0.03932875f, -0.00666958f, 0.04048688f, 0.03107668f, 
    0.02764664f, 0.01695815f, -0.04938306f, -0.00313308f, -0.03473040f, -0.02189830f, 0.01016965f, -0.00578828f, 
    -0.03795853f, -0.00247234f, -0.03453565f, 0.03540383f, -0.04884160f, -0.00973481f, -0.01411578f, 0.01807723f, 
    0.03976015f, 0.03849445f, -0.01408627f, -0.05164375f, 0.01648688f, 0.03653178f, -0.04883806f, 0.03662115f, 
    -0.02136686f, 0.02086467f, -0.01330833f, -0.00467733f, 0.04102525f, -0.04555387f, 0.00976714f, -0.04499513f, 
    -0.05101039f, -0.01617654f, 0.04256032f, -0.04019196f, 0.01896906f, -0.03759395f, -0.00663425f, -0.04396002f, 
    -0.04373342f, 0.00839962f, 0.01711783f, -0.04416412f, -0.04838127f, 0.01138544f, 0.02147391f, 0.02115618f, 
    -0.03570366f, 0.02003465f, 0.03658648f, -0.04377358f, -0.02655925f, 0.02982596f, 0.02919432f, -0.02018157f, 
    -0.05111932f, -0.02308479f, -0.04702907f, -0.03659798f, -0.05543546f, 0.00991762f, 0.04662990f, -0.04399446f, 
    0.00653413f, -0.01349214f, 0.00709186f, -0.04668862f, 0.03951004f, -0.04435217f, -0.01696339f, 0.00955002f, 
    0.03921231f, -0.00234204f, -0.01955315f, -0.01604149f, 0.01469265f, -0.05121395f, -0.01627636f, 0.01398099f, 
    -0.00474989f, -0.03331032f, -0.04937883f, 0.01998355f, 0.01729721f, -0.05023175f, -0.00769368f, -0.00473330f, 
    -0.02225171f, -0.00704948f, -0.04039631f, -0.02213998f, -0.05000894f, -0.02342888f, 0.02343685f, -0.05464574f, 
    -0.02101151f, 0.04528449f, 0.01333049f, -0.01672269f, 0.01248637f, -0.05268611f, 0.03756399f, 0.02047757f, 
    -0.01877526f, -0.04296095f, -0.01195819f, 0.03601830f, 0.02557911f, -0.04851230f, -0.02362491f, -0.02748542f, 
    0.00831775f, 0.01992412f, -0.04227056f, -0.05533053f, -0.03146128f, 0.03249904f, -0.05469195f, 0.01472279f, 
    -0.04659717f, 0.01182252f, -0.01646790f, -0.05396511f, -0.02751429f, -0.03065522f, -0.03588035f, -0.02915611f, 
    -0.00765358f, 0.04780035f, -0.04291308f, -0.03876096f, 0.03471671f, 0.01067092f, 0.01056001f, -0.03524755f, 
    0.03024363f, 0.00358515f, -0.00623224f, -0.02738856f, -0.01030994f, -0.05202267f, -0.00686766f, -0.05662192f, 
    -0.01482628f, -0.05185679f, 0.03453292f, 0.02307775f, -0.02204158f, 0.00443066f, 0.02932787f, 0.02286739f, 
    -0.02199285f, 0.02109032f, -0.05663157f, -0.03419409f, -0.00891080f, -0.03001378f, -0.01343525f, -0.02465671f, 
    -0.02031342f, -0.02990091f, 0.00627290f, 0.01300617f, -0.02555452f, 0.03950193f, 0.03458321f, -0.00533978f, 
    0.00126405f, -0.01232518f, -0.05221232f, 0.03729642f, -0.00085591f, 0.02247782f, -0.00227318f, 0.01387647f, 
    0.00579490f, 0.01750698f, 0.00309678f, -0.00063710f, -0.01922311f, 0.04078327f, -0.03987618f, -0.03260250f, 
    -0.03651551f, -0.03673369f, -0.00395245f, 0.03926479f, 0.01015731f, 0.02821949f, 0.04101650f, -0.02000173f, 
    -0.01816256f, 0.01292832f, 0.01398361f, -0.03642840f, -0.03116342f, 0.00030415f, -0.00318087f, 0.04150509f, 
    -0.03008686f, -0.05542320f, -0.05458117f, 0.00607022f, -0.04212694f, -0.05720494f, -0.03362498f, -0.05397211f, 
    -0.04085243f, 0.00197574f, -0.05313749f, 0.02901389f, -0.00642514f, -0.05247459f, -0.02498109f, -0.06072455f, 
    -0.05385551f, 0.02255992f, -0.00595114f, 0.03844175f, 0.02689121f, -0.05122777f, -0.00100245f, -0.00045869f, 
    -0.00899220f, -0.02663432f, -0.04241673f, -0.03997790f, -0.02338419f, -0.05185134f, -0.01953895f, -0.03911475f, 
    -0.04299662f, -0.01918887f, 0.04076470f, -0.05096854f, 0.02698353f, -0.03846692f, -0.01226855f, 0.01586095f, 
    0.03569274f, -0.00912058f, 0.01688235f, -0.00669581f, 0.00405151f, -0.01321800f, -0.01532455f, -0.01457138f, 
    0.00818593f, 0.02935377f, -0.01777214f, 0.00044167f, 0.03404260f, 0.01176298f, 0.03884194f, 0.00639499f, 
    -0.02096556f, -0.03895029f, 0.02692709f, -0.01477515f, -0.05031516f, 0.00604042f, 0.01257564f, -0.02029607f, 
    0.02711258f, -0.04462355f, -0.01714422f, -0.00313148f, -0.00060688f, -0.00140097f, 0.00361111f, -0.00839745f, 
    0.00621439f, 0.00945772f, -0.03800304f, -0.05403700f, 0.04000590f, -0.03063505f, 0.03630986f, -0.02878759f, 
    0.00366029f, 0.01340281f, 0.01143606f, -0.03771217f, -0.04265442f, 0.02761646f, -0.05402656f, 0.01213818f, 
    -0.02158079f, -0.02926398f, 0.02449407f, -0.04419886f, -0.03552064f, -0.02142269f, 0.00147442f, -0.02002197f, 
    0.02120323f, 0.00236571f, -0.00053955f, -0.01109671f, 0.03764556f, -0.02799908f, -0.02602055f, -0.04759891f, 
    0.32868463f, 0.20654802f, 0.07046381f, 0.02162420f, 0.07815011f, 0.12585503f, 0.06759999f, 0.00737448f, 
    -0.00810024f, -0.00084157f, 0.01650997f, 0.18134524f, 0.12700318f, 0.31925729f, -0.19370990f, 0.18995561f, 
    0.11649480f, 0.07585557f, -0.17626515f, -0.04585437f, -0.16616902f, -0.19652386f, -0.00127082f, -0.08166551f, 
    -0.22474585f, 0.31452662f, -0.37231356f, 0.04121252f, -0.02191146f, -0.08589759f, -0.02672660f, 0.05853587f, 
    -0.02778939f, 0.00753796f, 0.04340022f, -0.08548660f, 0.46795109f, -0.32508081f, 0.20043647f, -0.23462263f, 
    -0.26975214f, -0.01385156f, -0.00542830f, -0.01561130f, -0.00732795f, 0.14898229f, -0.05497544f, 0.09475742f, 
    0.44948849f, -0.13965325f, -0.28373143f, 0.26796192f, -0.03946004f, 0.05340165f, -0.10042717f, 0.06198107f, 
    -0.01225209f, -0.02107434f, -0.04579119f, 0.03896855f, 0.19676758f, 0.29332638f, 0.14393350f, -0.05104919f, 
    0.10863757f, -0.05840666f, -0.08693577f, 0.06779071f, -0.12981372f, 0.01746888f, 0.03969855f, 0.06826845f, 
    0.04703491f, -0.02806066f, -0.06680853f, 0.24174713f, 0.06392100f, 0.03426968f, 0.04724370f, -0.09065647f, 
    0.06557646f, 0.00398895f, -0.01148881f, 0.02220627f, 0.29573107f, 0.20221680f, -0.08919730f, 0.11125329f, 
    0.02707676f, 0.10387708f, -0.10871460f, -0.02513234f, -0.02884248f, -0.05296273f, -0.03674789f, -0.04698483f, 
    0.22036847f, 0.23129742f, -0.02205446f, -0.05860893f, 0.05316202f, 0.09268463f, -0.04532962f, 0.08534969f, 
    -0.20438524f, -0.18800122f, -0.08965103f, -0.01217081f, -0.18430473f, -0.04059589f, 0.11412540f, -0.05184037f, 
    0.07570718f, 0.01532930f, 0.14617409f, 0.09484694f, 0.00270314f, 0.03749926f, 0.02697694f, -0.00912430f, 
    0.13042220f, -0.13497549f, 0.20605785f, -0.11821644f, -0.18133666f, -0.13850215f, -0.06459401f, 0.06203217f, 
    0.04067572f, 0.10524386f, 0.01519268f, -0.03243292f, -0.11979558f, -0.14867404f, -0.09717923f, -0.10520679f, 
    0.00686835f, -0.00124710f, 0.04164050f, 0.06499584f, -0.00284607f, -0.01329762f, 0.11246058f, 0.01105969f, 
    0.10650016f, -0.15846203f, 0.02170210f, -0.04576156f, 0.01482575f, 0.00520161f, 0.03452263f, -0.03948620f, 
    -0.09789900f, 0.04430715f, 0.02071400f, -0.04134625f, -0.14766172f, -0.22775878f, 0.22924688f, -0.25892571f, 
    0.05218704f, 0.03646836f, 0.01253933f, 0.15127778f, 0.14303328f, 0.07740947f, 0.12115961f, 0.01147166f, 
    -0.28255835f, 0.07183225f, 0.18012883f, 0.04131649f, 0.14364767f, 0.07138949f, 0.11608627f, 0.01111055f, 
    -0.02477020f, -0.01138279f, 0.05202411f, 0.03666622f, -0.23169738f, 0.17425410f, 0.00348159f, 0.15330018f, 
    0.11752086f, 0.12822136f, -0.00579454f, 0.09421889f, -0.04093684f, 0.00812430f, 0.02491301f, 0.04921684f, 
    0.01079855f, 0.19608797f, 0.06618919f, 0.03382889f, 0.04409689f, 0.11588585f, 0.10050905f, -0.12054573f, 
    -0.05996941f, -0.07928070f, -0.07702649f, 0.01415728f, 0.00634036f, -0.25532138f, 0.26448059f, -0.10537647f, 
    -0.03783718f, 0.01471519f, -0.11080141f, -0.01134540f, 0.01033804f, 0.08401386f, 0.01923761f, 0.03015341f, 
    0.24632187f, -0.01749877f, 0.00442873f, 0.16608734f, 0.02499462f, 0.04062287f, -0.07479632f, 0.06471016f, 
    -0.01478179f, -0.07331227f, 0.10060330f, -0.07412121f, 0.01166899f, -0.11337086f, -0.12045239f, -0.02035157f, 
    -0.01205134f, -0.01253490f, 0.01478623f, 0.05265832f, 0.06312992f, -0.07627746f, -0.06287333f, -0.01638884f, 
    0.26107004f, 0.09985063f, -0.02664853f, -0.04490850f, 0.01410575f, 0.00265126f, -0.12918952f, -0.06848877f, 
    0.07493345f, 0.03814761f, 0.03009573f, 0.11507465f, 0.08759784f, -0.00672552f, -0.08561100f, 0.02190663f, 
    0.09847537f, -0.07850705f, 0.07855179f, -0.00596896f, -0.06134423f, 0.09192114f, 0.04914555f, -0.06402038f, 
    -0.07127902f, -0.23355530f, -0.12612364f, 0.00394462f, -0.00157376f, 0.03536065f, 0.04180874f, 0.04738088f, 
    -0.14072734f, 0.18556857f, -0.00182193f, 0.04831775f, 0.12985601f, -0.19075796f, 0.05561448f, -0.14082679f, 
    -0.03924865f, 0.07187145f, 0.13676839f, 0.21658860f, -0.05099001f, 0.04277466f, -0.04134129f, 0.08810548f, 
    0.19334957f, 0.03018307f, 0.17899504f, -0.09450118f, 0.07478707f, 0.11010496f, -0.04135980f, 0.01264524f, 
    -0.11613075f, -0.01136471f, -0.03295788f, 0.00472064f, -0.06699662f, 0.04357998f, 0.22931969f, -0.09317216f, 
    -0.02549873f, 0.01089556f, -0.14392823f, 0.19431531f, -0.07387407f, 0.04043944f, -0.01665443f, -0.03388860f, 
    -0.20228502f, 0.24487959f, 0.15280505f, 0.08317290f, 0.14284082f, 0.13450636f, 0.21228342f, -0.03264367f, 
    0.03348154f, -0.07949976f, -0.05020106f, -0.02083377f, 0.25291705f, 0.03226663f, 0.03619409f, 0.08151422f, 
    0.08337967f, 0.09237591f, 0.00593446f, 0.05118014f, -0.12556978f, -0.22412600f, -0.00403562f, -0.07732048f, 
    0.22584762f, 0.17041312f, 0.04178930f, 0.00601934f, 0.06789692f, -0.00958385f, -0.03587489f, 0.06973094f, 
    -0.05753923f, 0.02484342f, -0.00897056f, -0.02243510f, -0.09275115f, 0.19108111f, -0.04654141f, 0.17010486f, 
    -0.11224744f, 0.02949937f, -0.03956284f, -0.07518200f, -0.10056638f, 0.02020667f, 0.02889634f, 0.21649320f, 
    -0.00118564f, 0.16826600f, 0.16795014f, 0.07343116f, -0.10829467f, 0.08146649f, -0.08414489f, 0.01499790f, 
    -0.00386504f, 0.00318604f, 0.03891862f, 0.16911362f, -0.08411636f, 0.28108823f, -0.02455390f, 0.03991330f, 
    0.08418404f, -0.11985767f, -0.00057490f, -0.06770571f, 0.06116631f, -0.04704048f, 0.00462700f, -0.03438807f, 
    0.26998684f, 0.21142110f, 0.04947494f, -0.04251496f, 0.11562464f, 0.02962898f, 0.03088962f, -0.08308989f, 
    -0.05105381f, 0.06117570f, 0.12963824f, 0.09595888f, -0.02333051f, 0.34707135f, -0.24063954f, 0.32285699f, 
    0.11772393f, 0.00833600f, 0.03786277f, 0.10246653f, 0.05203850f, -0.12072822f, 0.06541339f, 0.00574917f, 
    -0.50320566f, 0.52013350f, -0.18306878f, 0.03256869f, -0.06015189f, -0.05210289f, 0.08277988f, 0.13088320f, 
    -0.02769958f, -0.02007354f, 0.00395486f, -0.00842934f, 0.34397715f, -0.31664166f, 0.43357638f, -0.13583188f, 
    -0.14342646f, -0.09821051f, -0.01340694f, -0.00021952f, -0.02382202f, 0.08177736f, 0.00309826f, 0.13098980f, 
    0.39268857f, 0.11970332f, -0.11017352f, 0.11991026f, -0.10075640f, -0.01248925f, -0.05876634f, -0.06419641f, 
    -0.01393261f, -0.01347862f, 0.04911510f, 0.11915855f, 0.17057052f, 0.17659946f, -0.08879603f, -0.00078001f, 
    0.07317102f, -0.05611643f, 0.00786236f, 0.12887257f, 0.00035442f, 0.04081002f, 0.08305856f, 0.00032442f, 
    -0.09520940f, -0.20204848f, -0.12447134f, 0.18286085f, -0.03740198f, 0.07754210f, 0.12191840f, -0.01669472f, 
    -0.04273765f, 0.01734438f, -0.17209576f, -0.05625055f, 0.18126951f, 0.10816753f, 0.01225864f, 0.18101521f, 
    -0.02727918f, 0.18315488f, -0.23067062f, -0.09168692f, 0.00776194f, -0.00562187f, 0.05905101f, 0.02432686f, 
    0.13127418f, 0.04753451f, -0.05823754f, -0.00007539f, 0.10715754f, -0.06982826f, -0.04350911f, -0.06268567f, 
    -0.00319475f, -0.04135563f, -0.07224529f, -0.01910166f, -0.10726263f, -0.01695021f, -0.01799966f, -0.09063228f, 
    0.05440973f, -0.05553456f, -0.04444129f, 0.12835334f, -0.01750082f, -0.01256806f, 0.16676357f, 0.03351492f, 
    0.22157870f, -0.40385780f, 0.56339169f, -0.05404739f, -0.09946283f, 0.04560798f, 0.01977719f, 0.07869065f, 
    -0.10293645f, 0.01892898f, -0.00834086f, -0.07216481f, -0.08990867f, -0.07607581f, 0.03849825f, -0.08272252f, 
    -0.10970511f, 0.05523822f, -0.02667519f, 0.00624802f, 0.01739000f, -0.02196451f, -0.01665626f, 0.01600896f, 
    -0.08663308f, -0.19098078f, 0.03234979f, -0.03996487f, -0.04382978f, -0.03318483f, -0.09388946f, -0.00630291f, 
    -0.16331159f, 0.07233062f, 0.08564036f, 0.11677818f, 0.08866081f, -0.06293841f, 0.20318757f, -0.21283789f, 
    0.07136197f, -0.11058652f, 0.03314601f, 0.22036527f, 0.06653176f, 0.04919760f, 0.19782279f, 0.03520735f, 
    -0.38091195f, -0.10873410f, 0.00923219f, -0.01753243f, 0.04175198f, -0.00926259f, -0.01280604f, 0.07155909f, 
    -0.07483428f, -0.03564404f, 0.17652096f, -0.06469037f, -0.01864909f, 0.30269018f, -0.08277509f, 0.07467900f, 
    0.10275835f, -0.03668597f, -0.09430094f, 0.00509961f, -0.09665857f, 0.02587724f, -0.01482699f, -0.02111145f, 
    -0.08789282f, 0.16926482f, -0.07206754f, 0.05499497f, 0.08226712f, 0.14457040f, 0.19280699f, 0.02123180f, 
    0.03780114f, -0.00289529f, 0.09324419f, 0.05347485f, 0.13854568f, -0.24151041f, 0.60304898f, -0.06793533f, 
    -0.01247445f, 0.01688488f, -0.14648890f, -0.09033605f, -0.20004103f, -0.04097623f, -0.03070293f, -0.01774468f, 
    -0.09866866f, -0.08258715f, -0.16627680f, 0.22932695f, 0.00645500f, 0.07563173f, 0.07521090f, 0.13800633f, 
    -0.06314162f, -0.11816491f, -0.02765527f, -0.05187686f, 0.00336283f, -0.07966770f, 0.05312083f, -0.05462677f, 
    -0.02360460f, -0.04489391f, -0.04052508f, 0.03632456f, 0.04623574f, -0.09604485f, 0.05407272f, 0.06503388f, 
    0.29093954f, 0.09824692f, 0.07324087f, 0.04540193f, 0.04387648f, 0.13270323f, 0.07261410f, -0.06016464f, 
    0.07753288f, 0.06671805f, -0.00975285f, 0.01457349f, 0.01907655f, 0.05734399f, -0.17549163f, 0.11694571f, 
    0.00332067f, -0.11708609f, 0.08039273f, -0.03442600f, 0.01540573f, 0.08520803f, -0.04086469f, -0.08905115f, 
    -0.05935003f, -0.11602905f, -0.07373744f, -0.02788688f, -0.08566718f, -0.03132508f, 0.02775145f, -0.01469188f, 
    -0.13533646f, 0.12677543f, 0.02045239f, 0.02613839f, -0.04115780f, -0.29387411f, 0.15626578f, -0.09082069f, 
    0.01710862f, 0.07097799f, 0.11435666f, 0.06230504f, -0.02529605f, 0.01681988f, -0.01962548f, 0.06074318f, 
    0.30396539f, 0.04279003f, 0.14444950f, 0.06049321f, 0.04959431f, 0.06180076f, -0.04982773f, 0.06169957f, 
    -0.12021999f, 0.11218518f, -0.06860643f, 0.03596250f, 0.05650776f, -0.04341081f, 0.21654180f, 0.01279581f, 
    0.01246597f, 0.06797310f, 0.08419862f, 0.15869744f, 0.05610898f, -0.00476055f, -0.00254974f, -0.02732911f, 
    -0.22280440f, 0.13883907f, -0.11932094f, 0.02072072f, -0.00058174f, -0.04204032f, 0.07676132f, 0.07990237f, 
    0.08804043f, -0.06280941f, -0.00364972f, -0.06128910f, 0.12297162f, -0.08136973f, 0.00907660f, 0.16508757f, 
    0.15862629f, 0.06973565f, -0.14897946f, 0.10968905f, -0.00556981f, 0.02061524f, 0.04280520f, 0.02203005f, 
    0.13138251f, -0.00523418f, -0.03751398f, 0.07277458f, 0.07188947f, -0.12921746f, -0.10610706f, -0.03678192f, 
    0.00615371f, 0.03996966f, 0.04261113f, -0.05510852f, -0.20242327f, 0.25340393f, -0.11017143f, 0.05316895f, 
    0.00538186f, 0.06095843f, 0.00753021f, 0.03892695f, -0.03543554f, 0.01190956f, 0.15783669f, 0.16103920f, 
    0.08523200f, 0.24708888f, 0.04008672f, -0.00223766f, 0.03580026f, 0.13002656f, -0.11630908f, 0.11457373f, 
    0.05212653f, 0.06395703f, 0.00198559f, 0.15079583f, 0.01043519f, 0.26934549f, 0.00002424f, 0.20944838f, 
    0.03014114f, -0.06585561f, -0.07325830f, -0.00127797f, 0.01501536f, 0.00588542f, -0.03816455f, -0.01995117f, 
    -0.48172310f, 0.16095464f, 0.32308745f, 0.06746667f, -0.09359280f, -0.08442182f, 0.09873512f, -0.04112339f, 
    0.02532257f, -0.21410625f, 0.05061595f, 0.02422900f, 0.00723880f, 0.00957017f, 0.16588239f, -0.47610387f, 
    0.16322006f, 0.07900513f, 0.04378686f, 0.00024326f, 0.06619391f, 0.09893989f, 0.01945688f, -0.02679025f, 
    -0.37447280f, 0.08452766f, 0.12465975f, -0.32044414f, -0.04266514f, 0.01862688f, -0.07114954f, 0.12402547f, 
    0.15237586f, 0.10291190f, 0.04044755f, 0.00303317f, -0.26528272f, 0.22565049f, -0.34346521f, -0.08620890f, 
    0.04476676f, 0.06819931f, 0.00842493f, -0.03804696f, 0.11870386f, -0.07465711f, 0.13822356f, -0.00552755f, 
    -0.16282997f, 0.04865338f, -0.17982638f, -0.29678807f, -0.19811542f, -0.09439225f, 0.07415915f, 0.07234976f, 
    -0.01212264f, 0.00264282f, 0.02896139f, -0.03659776f, -0.07175034f, -0.17077200f, -0.10206085f, 0.26582649f, 
    0.01122599f, -0.05267186f, 0.11732569f, 0.12324601f, 0.00913965f, -0.06460799f, 0.01207958f, -0.00684621f, 
    0.13057946f, 0.31920573f, 0.06291616f, -0.01491439f, -0.09205645f, -0.02995641f, 0.01635414f, 0.08115645f, 
    -0.03602229f, -0.03869390f, 0.10175291f, 0.00994315f, -0.04780158f, -0.05501162f, 0.18381198f, -0.20025977f, 
    -0.07644183f, 0.00739752f, -0.11803280f, -0.11033737f, 0.03375892f, 0.11692418f, 0.12167564f, 0.02803160f, 
    -0.07918204f, -0.05989173f, 0.00554419f, -0.25835896f, 0.13981849f, -0.04836623f, 0.10597207f, 0.09543280f, 
    0.12813945f, -0.06968492f, -0.03723369f, -0.01949788f, -0.17046949f, -0.02132534f, -0.05527036f, 0.28752214f, 
    0.02900122f, -0.07678971f, 0.01932364f, 0.07485490f, 0.18972540f, 0.00044069f, 0.11674739f, 0.14185879f, 
    -0.28340924f, 0.07133475f, -0.34934747f, 0.10203824f, 0.03974434f, 0.13862182f, 0.10396330f, 0.05081438f, 
    -0.15927914f, -0.03120629f, -0.03724633f, -0.07027116f, -0.16562735f, -0.02825445f, -0.14960288f, -0.08058797f, 
    -0.11971773f, -0.03548633f, 0.06768236f, 0.01796956f, 0.17939076f, 0.04820171f, 0.03739854f, 0.17701311f, 
    -0.24835131f, 0.04343621f, -0.02131474f, -0.06841897f, -0.14197272f, -0.08561915f, -0.15717828f, -0.11296661f, 
    0.07050546f, 0.10069568f, 0.05450047f, 0.06604053f, 0.05093152f, 0.18454514f, -0.02634175f, 0.18923050f, 
    0.00005793f, -0.04040591f, -0.15026394f, -0.07564468f, 0.16668089f, -0.08267649f, 0.11710183f, -0.01697268f, 
    -0.19460109f, 0.04614548f, 0.43092507f, 0.28792986f, -0.10546532f, -0.15333606f, -0.09366354f, -0.04072538f, 
    -0.01609188f, 0.03056809f, 0.05973364f, 0.08977517f, 0.31065172f, -0.35442939f, -0.21788165f, -0.06883166f, 
    0.01041339f, 0.17761800f, 0.04036540f, 0.17565785f, 0.09320682f, 0.04756400f, 0.04788921f, -0.06790315f, 
    -0.11600149f, -0.01433494f, 0.00984443f, -0.05029162f, 0.22645628f, 0.10447562f, 0.15702596f, 0.16837628f, 
    0.01027612f, -0.09811897f, -0.00654359f, 0.19924332f, -0.29090318f, 0.01672393f, -0.28974569f, 0.19311090f, 
    0.02189048f, 0.12284869f, 0.02696846f, -0.03755618f, -0.14388427f, -0.05230901f, -0.10789593f, -0.12765130f, 
    -0.07479732f, 0.43894160f, 0.09885151f, -0.05831479f, -0.08392144f, -0.06100410f, 0.00218680f, 0.14053302f, 
    0.05957729f, -0.00154208f, 0.02059766f, 0.01508800f, -0.19039598f, -0.02534054f, -0.03795220f, 0.22459459f, 
    -0.01049932f, -0.12137499f, -0.09714603f, -0.02164406f, 0.00664576f, -0.04419477f, 0.14949912f, 0.10582965f, 
    -0.16955981f, 0.22441566f, 0.12073310f, -0.08640323f, -0.10144218f, 0.03935666f, 0.11989004f, 0.04766919f, 
    0.09345726f, 0.06334008f, 0.12999313f, -0.09858180f, -0.10313550f, -0.06789264f, -0.10989470f, -0.11751802f, 
    0.08259545f, -0.15548100f, 0.02321044f, -0.02829482f, 0.04973760f, -0.00690537f, -0.05581186f, -0.07168839f, 
    -0.09380756f, -0.07037563f, -0.22448573f, 0.07831125f, 0.03710958f, 0.03873389f, -0.03505756f, -0.07808162f, 
    0.12474383f, 0.03254190f, 0.08390991f, 0.16210303f, -0.04553908f, -0.04262686f, -0.08280578f, -0.05551891f, 
    0.05912438f, 0.13587961f, 0.04291126f, -0.01549595f, 0.02203815f, 0.01518163f, 0.05654269f, 0.01129487f, 
    0.01536560f, 0.19768253f, -0.09102542f, 0.24235386f, -0.08584352f, -0.01494496f, 0.11363272f, 0.21859242f, 
    0.08634501f, 0.02826988f, 0.10491350f, -0.00527668f, 0.01392988f, 0.10813732f, -0.10650988f, 0.11005349f, 
    0.13007268f, 0.05118384f, 0.03329468f, 0.00755429f, 0.06713836f, 0.10373238f, 0.11160824f, 0.16344780f, 
    0.06078782f, -0.12429143f, 0.10227276f, -0.08180892f, -0.16392405f, -0.01883642f, -0.07489266f, 0.10922126f, 
    0.04387680f, 0.04331122f, -0.01942436f, -0.12548284f, -0.17129605f, 0.05764948f, -0.11712096f, -0.26274613f, 
    -0.02215868f, -0.02839263f, 0.19086063f, -0.11927845f, 0.02696171f, 0.02264275f, 0.03452582f, 0.02294306f, 
    -0.20525165f, 0.01124590f, 0.14728770f, -0.08246072f, -0.03385611f, 0.00594610f, -0.01067540f, 0.07485705f, 
    0.10925049f, -0.06951196f, 0.05797518f, -0.09927714f, 0.05775385f, 0.02404620f, 0.27524486f, 0.03556149f, 
    0.02495657f, 0.00602715f, 0.04324514f, 0.06755909f, 0.04489020f, 0.11123807f, 0.06410037f, -0.01954087f, 
    0.12268252f, 0.00399181f, 0.15261206f, -0.06080699f, 0.00200933f, 0.07186354f, -0.16973227f, 0.15274031f, 
    -0.11026452f, -0.07836726f, 0.00547763f, -0.00072367f, -0.04865634f, -0.09585077f, -0.13692173f, 0.00321321f, 
    -0.09194679f, -0.01271521f, -0.11990960f, 0.14815491f, 0.13233012f, 0.11567051f, 0.02730305f, 0.02232291f, 
    -0.08442933f, 0.22272167f, 0.13534091f, 0.20855951f, -0.00150012f, 0.01907928f, -0.08835417f, 0.01446008f, 
    0.08537123f, 0.00323871f, -0.05888628f, 0.03303939f, 0.19467159f, -0.14397396f, 0.11928427f, -0.32153410f, 
    -0.06994978f, 0.02742886f, -0.11318470f, 0.00945226f, -0.09801906f, 0.04602886f, -0.05147596f, 0.02374487f, 
    0.26327500f, -0.33564305f, -0.06315281f, -0.12829092f, -0.07771862f, 0.05918311f, -0.13068591f, 0.02870830f, 
    -0.04018107f, -0.01029672f, 0.13540488f, 0.05328110f, -0.53011799f, -0.07294372f, -0.31938002f, 0.18678120f, 
    0.15273376f, 0.12293333f, -0.01932651f, 0.15706450f, 0.02844795f, -0.07096959f, 0.13313471f, -0.20504014f, 
    -0.18007292f, -0.27759993f, -0.06239744f, -0.35907266f, -0.00992568f, -0.05688456f, 0.11547048f, 0.15652245f, 
    0.02597685f, 0.02158129f, -0.07389895f, -0.06925490f, 0.03372318f, -0.03700164f, 0.28787753f, 0.05970873f, 
    0.00578022f, -0.07679477f, -0.04233783f, 0.05442825f, 0.01824759f, 0.06112698f, -0.01097322f, 0.13643904f, 
    0.23682760f, 0.10159581f, 0.02400525f, -0.02553323f, -0.02036415f, -0.04851460f, 0.01554916f, 0.03154685f, 
    0.00299723f, 0.06008488f, 0.15365130f, 0.13077374f, 0.08904058f, -0.03263665f, 0.10098106f, -0.08286293f, 
    0.09505623f, 0.06707431f, 0.11262721f, 0.07609918f, -0.06249654f, -0.11047897f, -0.07926352f, -0.00289305f, 
    0.06973223f, 0.15104035f, 0.06460754f, -0.01663928f, -0.05388499f, 0.00723305f, 0.05939192f, 0.06170858f, 
    0.09614184f, 0.01311042f, 0.04762302f, -0.00989061f, -0.19545460f, -0.01936318f, 0.11286993f, 0.12969717f, 
    0.02340502f, 0.16516806f, 0.06215792f, -0.16667373f, 0.10438956f, 0.06940490f, -0.10743240f, 0.14850996f, 
    -0.27806619f, 0.28581491f, -0.46920618f, 0.23662065f, 0.24196860f, 0.03561908f, 0.02510597f, -0.02977042f, 
    0.04055911f, -0.02643157f, -0.07365826f, -0.01728314f, -0.16340598f, -0.14189626f, -0.18079102f, -0.00780964f, 
    0.02995232f, 0.05262828f, 0.06034515f, -0.06402456f, 0.01393723f, 0.10194292f, 0.06407219f, 0.11618591f, 
    -0.10666639f, -0.06645838f, -0.11558072f, 0.03202150f, 0.04890793f, 0.02699162f, 0.01531173f, 0.04515081f, 
    0.00467678f, 0.04695049f, 0.04619976f, 0.02834865f, -0.04368262f, -0.09992591f, 0.00695418f, -0.05441280f, 
    0.03068505f, 0.02308761f, -0.03096241f, -0.04775771f, 0.09120240f, -0.08661456f, 0.07356013f, -0.00545886f, 
    0.35004058f, 0.12099303f, 0.09571372f, 0.20047235f, 0.00215129f, 0.06209783f, -0.07250752f, -0.01837107f, 
    -0.04221122f, -0.08900835f, -0.03881041f, -0.03504947f, 0.01102265f, 0.07417637f, 0.19437207f, -0.09337123f, 
    0.04119803f, 0.09780271f, 0.13071363f, 0.37479413f, -0.05815690f, -0.04251567f, 0.01782811f, -0.12258440f, 
    0.08717539f, 0.16026355f, 0.20089847f, -0.04372288f, 0.06569816f, 0.00569660f, -0.10264916f, 0.09808231f, 
    -0.00465597f, -0.09765764f, -0.13976049f, -0.02805421f, -0.49062601f, -0.03098238f, -0.26387489f, 0.10113702f, 
    0.00715501f, -0.07487141f, 0.04030331f, 0.07320488f, 0.01769613f, -0.00442227f, -0.09126816f, -0.01882943f, 
    -0.17045179f, 0.12653609f, 0.31275219f, -0.29121277f, 0.01220913f, -0.00836417f, 0.05135657f, -0.04161530f, 
    -0.14115055f, 0.12235622f, -0.08017972f, 0.15455645f, -0.21587196f, -0.13564819f, -0.14906222f, 0.02845118f, 
    0.03122018f, -0.00781159f, -0.00422132f, 0.13366748f, 0.07758707f, -0.03926869f, -0.14242399f, -0.05892362f, 
    -0.05674803f, 0.04643252f, -0.11740178f, -0.08985387f, 0.01895496f, -0.12757504f, 0.00888485f, 0.07361397f, 
    -0.07124830f, -0.00210603f, 0.04857677f, 0.10199088f, 0.12736288f, 0.06864634f, 0.16498949f, -0.18725449f, 
    0.08794941f, -0.04172011f, 0.02823895f, 0.13432111f, -0.03384773f, 0.05443420f, 0.04289678f, 0.06844567f, 
    -0.15021738f, -0.08964038f, -0.06601342f, 0.08893729f, 0.15170307f, -0.12849239f, 0.00919984f, -0.09291365f, 
    0.00715561f, -0.04258484f, 0.04805448f, -0.01886304f, 0.08029589f, 0.38083732f, -0.00619577f, -0.12180316f, 
    0.01131691f, -0.11672997f, -0.01441993f, 0.10856125f, 0.02939525f, 0.09233779f, -0.01674614f, -0.02798017f, 
    -0.08087824f, 0.11294841f, -0.10102706f, 0.02873392f, -0.12917128f, -0.01661400f, 0.09449285f, -0.07336060f, 
    0.07237008f, -0.04094397f, 0.05640228f, 0.04988873f, -0.33759591f, -0.03804708f, -0.06664986f, -0.21054640f, 
    0.16893220f, 0.06554755f, -0.04885225f, -0.02760825f, 0.03649766f, 0.05033709f, 0.00727682f, 0.15732326f, 
    0.14307474f, 0.01122689f, 0.03392126f, 0.06749380f, 0.12388111f, 0.15924506f, -0.10552146f, -0.05039462f, 
    0.00905676f, -0.11914026f, -0.10561333f, 0.01255570f, 0.11173019f, 0.16567017f, -0.03695057f, -0.23016144f, 
    -0.04288863f, -0.00340516f, 0.15188727f, 0.03942768f, -0.00940849f, 0.03968960f, -0.04496765f, -0.08877519f, 
    0.11441776f, 0.08869646f, 0.10957109f, -0.05206711f, 0.05208055f, 0.06317980f, -0.01107924f, 0.10140426f, 
    0.01899505f, -0.02120958f, 0.01371669f, 0.04886942f, 0.20926604f, -0.10455187f, 0.16046107f, 0.20096233f, 
    -0.00247774f, -0.11697030f, -0.07556749f, -0.05782183f, -0.02533168f, 0.15101631f, 0.02338342f, 0.04206464f, 
    0.03829734f, 0.06520669f, 0.10986610f, -0.04089497f, 0.06996189f, -0.04646615f, 0.02430076f, 0.02994827f, 
    -0.06147548f, -0.01051253f, -0.00261319f, -0.06833287f, -0.13329959f, -0.02199638f, -0.01491432f, -0.05744158f, 
    -0.01214163f, 0.08035907f, -0.00954871f, 0.01002182f, -0.01773864f, -0.13530926f, -0.02705445f, 0.08573389f, 
    -0.02681298f, 0.03596217f, 0.01852654f, -0.02095702f, 0.03420246f, 0.01080726f, -0.01454964f, 0.04430660f, 
    0.03921258f, 0.01547410f, -0.00395852f, 0.03607955f, -0.02702861f, 0.00437826f, 0.01465860f, 0.04336844f, 
    -0.03674905f, 0.02630141f, 0.02196766f, -0.02872438f, 0.03684061f, -0.01632625f, 0.01869391f, -0.05019842f, 
    0.03015234f, 0.00308954f, -0.02035870f, -0.03535312f, -0.04268487f, -0.04304142f, -0.00921480f, 0.01889815f, 
    -0.03751876f, -0.03090235f, -0.00471704f, 0.03404154f, -0.03633181f, -0.04458730f, 0.04072945f, 0.03069100f, 
    -0.02754344f, -0.01913134f, -0.04600888f, -0.03626272f, -0.02528979f, -0.01384722f, -0.00932126f, 0.03301979f, 
    -0.03147160f, -0.01414616f, -0.03510200f, 0.04017864f, -0.01044929f, -0.04711136f, -0.04686214f, -0.01451433f, 
    -0.02497919f, -0.03325552f, 0.02851760f, 0.00908095f, -0.02769639f, -0.01263065f, 0.01567810f, -0.02905609f, 
    0.03635663f, 0.00399042f, 0.02410517f, 0.02957654f, -0.00955158f, -0.05470290f, -0.04096517f, -0.05596330f, 
    0.04173405f, -0.04836595f, -0.05654512f, -0.05352328f, -0.00353325f, 0.03604780f, 0.03135889f, -0.05123328f, 
    -0.01431870f, -0.04051452f, -0.00666198f, 0.03147517f, -0.02459750f, -0.03474553f, 0.04233120f, -0.05247692f, 
    -0.02815027f, 0.03190531f, 0.00840329f, -0.04869207f, -0.04504833f, -0.02636184f, -0.02762005f, -0.02774406f, 
    -0.02850047f, 0.01412514f, 0.01492723f, 0.01117367f, 0.01841553f, -0.02701220f, -0.02394793f, -0.04238899f, 
    0.00678447f, 0.02313385f, -0.02463849f, -0.05028223f, -0.05077517f, 0.02378963f, 0.01811618f, 0.00195873f, 
    -0.01136114f, -0.04924488f, -0.00137092f, 0.00222308f, -0.01699914f, -0.01099290f, 0.04303628f, 0.04535972f, 
    0.01651853f, 0.00638806f, 0.03435622f, 0.01767199f, -0.02110849f, 0.04464119f, -0.04378750f, 0.00484972f, 
    0.00965934f, -0.04711979f, 0.02052693f, -0.02815607f, -0.04707029f, -0.02361848f, -0.00185371f, -0.02475841f, 
    -0.03188554f, -0.02666649f, -0.00710117f, -0.04197908f, -0.01115516f, 0.01943000f, -0.01792176f, 0.03049216f, 
    -0.00124640f, -0.03785492f, -0.00284831f, 0.00087795f, 0.00222366f, -0.04794594f, -0.00613283f, -0.04384538f, 
    -0.03440390f, 0.03663621f, 0.03643603f, 0.02666149f, -0.03388839f, -0.01375843f, 0.02862267f, -0.00093323f, 
    0.01738247f, 0.02440285f, -0.03777792f, 0.00821232f, -0.00026368f, 0.01734162f, -0.00125054f, -0.02648550f, 
    -0.03367722f, -0.00585433f, -0.04824643f, 0.02768772f, 0.04221778f, -0.00404807f, 0.00473501f, -0.05601203f, 
    0.00976283f, -0.00772903f, 0.03248468f, -0.00831320f, -0.03893920f, 0.00648903f, -0.02780062f, -0.04932771f, 
    -0.02045105f, -0.00356234f, -0.00679058f, -0.00534758f, 0.00701290f, 0.03674431f, -0.02524856f, -0.05192516f, 
    -0.04713137f, 0.03095349f, -0.02125930f, -0.03375998f, -0.01152667f, 0.00210760f, -0.05351770f, 0.01504766f, 
    -0.02504435f, -0.04404015f, -0.01733511f, -0.01615362f, -0.02637947f, -0.03691394f, 0.04320483f, -0.01456067f, 
    -0.03469717f, -0.03591940f, -0.00427851f, -0.03049151f, -0.04530313f, -0.00985825f, -0.01329164f, -0.04790595f, 
    0.04967444f, -0.04562755f, -0.02308724f, -0.01137239f, -0.04205935f, -0.04415249f, -0.03472533f, 0.02281798f, 
    0.01246962f, -0.01533418f, 0.02885671f, 0.01935701f, -0.05206699f, 0.03942847f, 0.03784151f, 0.02144547f, 
    -0.05125532f, -0.05139666f, -0.00074970f, -0.01277756f, 0.02316239f, 0.01180075f, 0.00186847f, -0.04893666f, 
    -0.05505012f, -0.01087143f, -0.01098793f, 0.00042627f, -0.01125728f, 0.00010461f, -0.05288227f, -0.02430519f, 
    0.00098816f, 0.00965084f, -0.03875496f, 0.04039548f, -0.01893510f, -0.03049299f, 0.03801464f, -0.02031641f, 
    -0.01731195f, -0.03644584f, -0.02494200f, 0.04341543f, -0.02085044f, -0.00149260f, -0.03505927f, 0.02782518f, 
    -0.02286512f, -0.04410335f, -0.00555110f, 0.00803662f, 0.02343890f, -0.04410316f, -0.05502478f, 0.02425181f, 
    0.02500586f, -0.02562973f, -0.02713388f, -0.01861252f, 0.00979778f, -0.01897934f, 0.01309038f, 0.03433218f, 
    0.01481164f, 0.04003198f, -0.02251714f, -0.03599456f, 0.01916859f, -0.04944340f, 0.03920884f, -0.02148351f, 
    0.00457189f, 0.00483207f, -0.03275339f, 0.04539429f, -0.00743610f, -0.02449330f, 0.03457236f, -0.03666385f, 
    -0.03943904f, 0.01002427f, 0.04277094f, -0.03665137f, 0.01093206f, -0.03792306f, 0.02718595f, -0.03545485f, 
    -0.03581097f, 0.02971580f, 0.01902517f, -0.04721544f, -0.02563839f, 0.00211120f, 0.02507980f, 0.00249212f, 
    -0.00264018f, -0.02588785f, -0.03254781f, -0.04329233f, -0.05154115f, 0.03996676f, -0.01764189f, 0.01562908f, 
    0.03969128f, -0.05237562f, -0.03221891f, 0.01052126f, 0.01045233f, -0.01090593f, -0.04492125f, -0.02498603f, 
    0.01943971f, -0.03700987f, -0.02046625f, -0.03042360f, 0.03637117f, 0.02064235f, -0.05492318f, 0.02540687f, 
    -0.03166494f, -0.01618380f, -0.04011348f, -0.04366371f, 0.03891097f, -0.02012633f, 0.04153858f, -0.02703360f, 
    -0.01198668f, -0.05448528f, -0.01670166f, -0.03951107f, -0.05617749f, 0.00783200f, -0.02723635f, -0.02608576f, 
    0.00411469f, 0.04321230f, -0.02640963f, 0.00557982f, -0.00930473f, -0.05579678f, 0.04443972f, 0.02912871f, 
    0.03826105f, 0.02827899f, -0.00928740f, -0.01712795f, 0.01296190f, 0.03941912f, -0.02370169f, -0.01407109f, 
    -0.03677214f, -0.01199735f, -0.02165966f, -0.00473115f, 0.03855719f, 0.00768189f, -0.00609691f, -0.05550272f, 
    -0.04522650f, 0.00279633f, -0.01469129f, -0.00748585f, 0.01695920f, -0.05454161f, -0.02990076f, 0.01716070f, 
    -0.35472786f, 0.06717610f, -0.09712224f, 0.00094116f, 0.04381088f, -0.10263365f, -0.03545733f, -0.17103660f, 
    0.15079620f, -0.18489735f, -0.04716156f, 0.05278418f, -0.04596777f, 0.04481501f, 0.08775051f, -0.37003639f, 
    0.04434875f, 0.09844092f, -0.04565119f, 0.01313834f, 0.05539253f, 0.00719986f, -0.07404488f, 0.06871492f, 
    0.33048263f, -0.46696293f, 0.04782558f, -0.18741132f, 0.00469445f, 0.00974480f, -0.06734141f, -0.00308084f, 
    0.17178743f, 0.04787669f, -0.02621436f, -0.14992169f, 0.01171124f, 0.24035336f, -0.33768031f, 0.30608305f, 
    0.31143171f, -0.04747009f, 0.00327578f, 0.01537885f, 0.10180728f, -0.16028175f, 0.11209410f, -0.00760207f, 
    -0.04127149f, 0.00979599f, 0.06233740f, -0.09111886f, -0.12055272f, 0.00170484f, -0.02607894f, 0.04413668f, 
    -0.07984319f, -0.07363822f, -0.01015115f, -0.00654557f, -0.00613458f, -0.09935262f, 0.19772169f, 0.11567025f, 
    0.16089578f, -0.10355087f, 0.07299478f, 0.05677722f, 0.09186520f, 0.01468376f, -0.06807778f, 0.03594584f, 
    -0.05133091f, -0.03220504f, 0.02355007f, -0.28686967f, -0.00565659f, -0.04143916f, -0.09605376f, 0.11054181f, 
    -0.05435633f, 0.01237113f, 0.13670419f, -0.05462848f, 0.13257417f, -0.03654861f, 0.12549657f, -0.12546018f, 
    0.01828331f, -0.00420656f, 0.07320115f, -0.04168399f, 0.00835438f, 0.09144723f, 0.14142865f, -0.00273577f, 
    -0.02268526f, 0.05202119f, 0.22093458f, 0.04889827f, 0.12435246f, 0.05564049f, 0.20420977f, 0.10610120f, 
    0.21271212f, 0.02744039f, -0.01701158f, -0.06230168f, -0.21327193f, 0.14785677f, -0.12424556f, 0.20752013f, 
    0.07180765f, -0.04441692f, -0.02043146f, -0.11276388f, 0.11735008f, 0.05532811f, 0.03746298f, 0.03329672f, 
    -0.10698792f, 0.19191675f, -0.26621506f, 0.19168760f, 0.14389612f, 0.14454082f, 0.03919806f, 0.09100598f, 
    -0.04307679f, -0.00712816f, 0.01691234f, -0.06591453f, -0.07465057f, -0.01359289f, -0.06272518f, 0.15592919f, 
    0.05684082f, -0.00354073f, -0.01015916f, -0.04112253f, 0.23358598f, 0.00364162f, -0.03563778f, 0.06738576f, 
    -0.28643703f, 0.07442629f, -0.08283403f, 0.13990258f, -0.05120304f, -0.01845412f, -0.16337158f, -0.05447660f, 
    0.18004215f, 0.09759925f, 0.02575538f, 0.16703391f, 0.01652519f, 0.01967280f, -0.17191729f, 0.31152549f, 
    0.08210655f, -0.16878495f, -0.08519477f, -0.22645307f, 0.05188274f, -0.01539227f, -0.05543278f, 0.09447078f, 
    -0.10261073f, -0.22974843f, -0.07035135f, 0.13471001f, 0.00375488f, -0.06681893f, -0.07714331f, -0.12444853f, 
    0.04046745f, 0.12957698f, 0.03536950f, 0.12928711f, 0.44600013f, -0.30454981f, -0.04749403f, -0.06367756f, 
    0.04593831f, 0.19343074f, 0.08628195f, -0.06143490f, 0.00674169f, -0.03823905f, 0.00383794f, -0.01540559f, 
    0.08450878f, 0.11549278f, 0.20824569f, -0.15392064f, 0.20031923f, 0.00516757f, 0.20557436f, 0.20054515f, 
    0.04179870f, -0.00159957f, 0.03501582f, 0.07922536f, 0.05860710f, 0.21675296f, -0.38586035f, 0.41156873f, 
    0.11025444f, -0.02074843f, 0.09915730f, 0.10208396f, -0.02217147f, -0.11164205f, -0.06008737f, 0.00496893f, 
    -0.03850218f, -0.27512997f, 0.04508733f, -0.47618318f, 0.02480872f, 0.02314364f, 0.00086799f, -0.03344408f, 
    0.00398392f, -0.06587823f, 0.06967389f, -0.00868913f, 0.05228481f, -0.12435871f, 0.02665119f, 0.25682464f, 
    0.05163093f, -0.07791980f, -0.10240209f, -0.07725358f, -0.07634537f, 0.07299456f, -0.00232555f, 0.13212834f, 
    -0.34796181f, 0.19313885f, -0.19679770f, -0.18475208f, -0.08986145f, 0.02456784f, -0.00662979f, 0.03545628f, 
    0.06324638f, -0.09555051f, 0.00697408f, -0.06151772f, 0.06882738f, 0.07909802f, -0.03106467f, -0.20519608f, 
    0.06424057f, -0.01208807f, -0.14790463f, 0.10485859f, -0.06404878f, -0.01024651f, -0.05715210f, -0.06951024f, 
    0.01171941f, -0.10932298f, -0.09660110f, 0.20860463f, -0.02604447f, -0.03168662f, -0.06450429f, -0.12229664f, 
    0.15886386f, -0.06744031f, 0.06933547f, 0.01989904f, 0.27271834f, 0.34094936f, 0.12028164f, 0.12340441f, 
    -0.06142576f, -0.05350625f, -0.09449871f, 0.25250757f, 0.01502215f, 0.00832681f, 0.10963448f, 0.01692502f, 
    -0.48948613f, 0.07229013f, -0.35578105f, -0.04408296f, 0.06367273f, 0.02044411f, -0.13612553f, 0.03783524f, 
    0.15763079f, -0.00805048f, 0.08272129f, -0.07366450f, 0.09793352f, -0.02722708f, -0.12325409f, -0.04817829f, 
    0.27007109f, -0.16000389f, -0.00667111f, 0.02894465f, 0.10793952f, 0.07734460f, 0.00282924f, 0.11626040f, 
    0.09134760f, -0.15310366f, -0.01690313f, -0.10078138f, -0.02799476f, 0.06288204f, -0.05531694f, 0.07269255f, 
    0.12510604f, -0.00231441f, -0.08809865f, -0.07418361f, -0.06115919f, 0.18338375f, -0.01374069f, -0.02570826f, 
    -0.03139842f, 0.07253884f, 0.17488530f, 0.09666483f, -0.05814758f, 0.05047847f, 0.02881641f, 0.04072695f, 
    -0.08676799f, 0.04592552f, 0.14317684f, 0.02586352f, 0.01852699f, -0.05634551f, 0.04692230f, 0.12304063f, 
    0.12484836f, -0.08054562f, -0.02917671f, -0.02719590f, 0.15862902f, -0.15086246f, 0.16717325f, 0.05428585f, 
    0.05756002f, 0.03053858f, -0.08900935f, 0.03476999f, 0.00817468f, 0.04412265f, -0.11530528f, -0.08574951f, 
    -0.11075805f, 0.07774983f, 0.03843277f, 0.00806963f, 0.08389502f, -0.09040225f, -0.09368543f, 0.16543949f, 
    -0.03616701f, -0.09388451f, 0.03946903f, 0.05108481f, -0.03727164f, -0.17035779f, 0.01422204f, 0.00044166f, 
    0.01320715f, -0.02818737f, -0.05376913f, 0.10409301f, -0.00812545f, 0.07246650f, 0.01419281f, -0.01040525f, 
    0.03025120f, -0.00135300f, 0.01528645f, 0.01032086f, -0.02233939f, 0.01815711f, 0.02244493f, 0.02289271f, 
    0.00730320f, 0.01876999f, 0.00397535f, -0.04212900f, -0.01138274f, -0.01506646f, -0.00620278f, -0.02705743f, 
    -0.01370339f, 0.03342255f, -0.05123173f, -0.03725968f, 0.03294013f, -0.04438950f, 0.00592412f, -0.00606020f, 
    0.04098673f, 0.03501219f, -0.01253582f, -0.02054186f, -0.05359675f, 0.01220930f, -0.04831971f, 0.00118430f, 
    0.04249364f, -0.03266519f, 0.04105808f, -0.02737069f, -0.03498991f, -0.00679551f, 0.03963162f, 0.02333730f, 
    -0.05616195f, 0.02409286f, -0.00862859f, 0.03502479f, 0.02371737f, 0.04348940f, -0.05643526f, -0.04211759f, 
    0.00972856f, 0.04105435f, -0.03456195f, -0.04795928f, -0.00120358f, -0.03390701f, -0.03873486f, -0.03012367f, 
    0.03188027f, -0.03349290f, 0.00539137f, -0.02543238f, -0.03447455f, -0.03350645f, -0.00343223f, 0.04033403f, 
    0.04178161f, -0.04383777f, -0.05307452f, -0.00034366f, -0.01769236f, -0.03917469f, 0.04013172f, 0.00219448f, 
    -0.03632117f, 0.00784892f, -0.01006434f, -0.05375393f, 0.04203880f, 0.00799980f, 0.02283133f, 0.02518294f, 
    -0.04291213f, -0.02937186f, -0.02212478f, -0.04800534f, -0.03733683f, -0.03080791f, -0.05159265f, -0.02322942f, 
    0.01769985f, 0.02072949f, 0.00137417f, 0.00706213f, -0.02714124f, 0.01717879f, -0.05124012f, 0.00832928f, 
    -0.02961648f, -0.01592682f, -0.03793607f, 0.03522861f, -0.01848021f, -0.01999869f, 0.03194320f, -0.05112820f, 
    -0.01411211f, -0.02944817f, 0.03392108f, 0.03892710f, 0.01535942f, -0.04353002f, 0.03847992f, -0.00500587f, 
    0.03366246f, -0.00751546f, -0.02880505f, 0.00638800f, -0.05578642f, 0.01604780f, -0.02031278f, -0.05562096f, 
    0.03866403f, 0.03573243f, 0.03342398f, 0.00516965f, 0.00202278f, 0.00672535f, 0.03009657f, -0.00157388f, 
    0.01408708f, 0.00128596f, 0.02867477f, -0.00117406f, 0.02297779f, -0.04066699f, -0.02174680f, 0.01156800f, 
    0.04455624f, 0.03263142f, -0.03628165f, -0.03686787f, 0.01063248f, 0.02417863f, 0.01960326f, -0.01579243f, 
    -0.04893358f, -0.01306582f, 0.01046087f, 0.01195585f, -0.03492457f, 0.00942723f, 0.02466352f, -0.00376874f, 
    -0.01391242f, 0.00209132f, -0.01745718f, -0.02881429f, 0.04287123f, -0.00926153f, 0.03203087f, -0.00911177f, 
    -0.00084927f, -0.00593700f, -0.02784504f, -0.05670080f, -0.03010576f, -0.03373063f, -0.00934230f, 0.01903850f, 
    0.01801734f, 0.04109050f, -0.02052942f, -0.04004712f, 0.01880546f, 0.02416682f, 0.03714618f, -0.02563731f, 
    -0.02611866f, 0.04217877f, -0.05059490f, 0.00140520f, -0.00202044f, -0.01708340f, -0.05625752f, -0.05697278f, 
    -0.02171421f, -0.02471517f, 0.04332742f, 0.01234472f, -0.04645920f, -0.01829011f, -0.03410769f, -0.01529461f, 
    -0.05287271f, 0.03027881f, -0.02946546f, -0.00924537f, 0.01141324f, -0.00230831f, 0.04486416f, -0.04451600f, 
    -0.00738327f, -0.02672431f, -0.00498381f, 0.00136165f, -0.01846763f, -0.04309233f, -0.04933871f, 0.03055814f, 
    0.03034176f, 0.04834767f, -0.01446222f, -0.05313081f, -0.05122534f, -0.04444302f, -0.04823037f, -0.02079029f, 
    0.03248406f, -0.02758275f, 0.02098547f, -0.04131769f, 0.00146599f, 0.02508652f, 0.03930660f, -0.03290379f, 
    -0.02346952f, -0.01727149f, 0.01736554f, -0.03937449f, -0.04662961f, -0.04779967f, 0.02688308f, 0.02208597f, 
    -0.02876809f, -0.04179879f, -0.00930907f, -0.01711579f, -0.02882371f, 0.03615906f, -0.02717202f, 0.00161629f, 
    0.00604572f, -0.04752323f, -0.00915736f, -0.04235973f, 0.02871899f, -0.02543357f, -0.04415425f, 0.02565366f, 
    -0.05268568f, -0.01396370f, -0.03436284f, 0.03597397f, 0.01931639f, 0.00310261f, -0.03832643f, 0.02091701f, 
    -0.04662795f, 0.00614640f, 0.00597064f, 0.00511512f, -0.02410888f, 0.03324884f, -0.02191420f, -0.02804408f, 
    0.00463437f, -0.00943479f, 0.02188033f, -0.01168362f, -0.00176065f, -0.02850816f, -0.03226627f, -0.00100801f, 
    -0.05184481f, 0.04245694f, 0.00969032f, -0.05638613f, -0.00164776f, 0.00874957f, -0.03301045f, 0.00307924f, 
    -0.02031778f, -0.05562846f, 0.00820445f, -0.05231109f, 0.00178372f, -0.04366801f, 0.02887901f, -0.05602629f, 
    -0.01371704f, 0.02032176f, 0.01474381f, 0.01564858f, -0.03389939f, 0.03244077f, 0.02053919f, 0.03258010f, 
    -0.04875874f, -0.04370910f, -0.01137495f, 0.03955087f, -0.02985604f, 0.01143020f, -0.02961686f, 0.00484196f, 
    -0.01249821f, 0.00594733f, -0.04828734f, 0.00822022f, 0.02214852f, 0.03111500f, 0.03917727f, -0.03059937f, 
    0.01829011f, 0.03063439f, -0.00312311f, -0.02961181f, -0.04492959f, 0.03309373f, -0.00767900f, 0.04445741f, 
    0.04006835f, -0.05698492f, -0.05643672f, -0.02837351f, -0.04842444f, 0.00769850f, 0.03473757f, 0.03408273f, 
    -0.00860730f, 0.03192281f, 0.00181031f, -0.00362938f, -0.00916215f, 0.01308183f, 0.02515466f, -0.00270046f, 
    -0.03318391f, -0.05425055f, 0.02962534f, -0.02931488f, 0.03643735f, -0.04321597f, -0.02545871f, -0.00808864f, 
    -0.03074576f, 0.03921827f, -0.01192807f, -0.01992153f, -0.03993689f, -0.01719732f, -0.03568988f, -0.04294462f, 
    -0.05275189f, 0.01830972f, 0.02479673f, 0.01714533f, -0.01062876f, -0.04739147f, -0.00576647f, -0.04375631f, 
    0.03528861f, 0.03140004f, -0.03017682f, 0.03059832f, -0.03275120f, -0.05609103f, -0.04043746f, -0.04807609f, 
    -0.00737417f, 0.04421953f, 0.01763419f, -0.03948170f, -0.01681413f, 0.00372470f, -0.01145822f, -0.05445744f, 
    -0.01586482f, 0.02811880f, -0.03575010f, -0.01631762f, -0.01238480f, -0.00494146f, 0.04063492f, -0.02112534f, 
    0.15618660f, -0.27560064f, -0.32335594f, -0.07419627f, 0.17380598f, 0.00827711f, -0.05827567f, -0.03755219f, 
    -0.04450729f, 0.03361747f, -0.07962903f, 0.04127407f, 0.07881748f, 0.06977709f, -0.04577897f, 0.07045697f, 
    -0.19039306f, 0.15850966f, -0.03993300f, 0.15425910f, -0.04532843f, -0.10472070f, 0.05224595f, 0.07103369f, 
    -0.17807101f, 0.01372650f, 0.01487660f, 0.09769917f, 0.08379676f, 0.03912266f, -0.07367679f, 0.08390831f, 
    -0.01046292f, -0.12776044f, -0.00936603f, -0.12225532f, -0.28432140f, 0.19258013f, 0.08912184f, 0.61081630f, 
    0.08983557f, -0.06771246f, 0.00211665f, 0.08512225f, -0.04112753f, -0.04394659f, 0.21988583f, -0.07042964f, 
    0.25708109f, 0.11255435f, 0.24699233f, -0.10062633f, -0.10945791f, 0.05320032f, 0.00162974f, -0.04284928f, 
    -0.02745734f, -0.09894848f, -0.07857954f, 0.11509364f, -0.03949537f, 0.09061403f, -0.23511972f, 0.08661545f, 
    -0.05557597f, -0.05032037f, -0.19878812f, 0.00214170f, -0.13658616f, -0.09787557f, -0.08205055f, -0.01575890f, 
    -0.28332290f, -0.27948490f, -0.08127777f, -0.01853492f, 0.05612932f, 0.06269407f, 0.14066251f, 0.15777121f, 
    -0.00514187f, 0.00176441f, 0.05244365f, -0.08982994f, 0.05141655f, -0.03080149f, 0.18892694f, 0.28839615f, 
    0.06064100f, 0.05528606f, 0.07407299f, 0.05628654f, 0.00639151f, 0.13047469f, 0.07008182f, 0.22527155f, 
    0.03430689f, -0.00191046f, -0.01541203f, 0.31137404f, 0.02168035f, -0.00489346f, 0.01439623f, 0.16265424f, 
    0.08788808f, 0.12287349f, -0.00472039f, 0.09739542f, 0.07971434f, 0.03815022f, 0.02425200f, -0.02122322f, 
    -0.04533547f, 0.14217556f, -0.02923298f, 0.07140602f, -0.05473972f, 0.02885392f, 0.05316497f, 0.06270809f, 
    0.22456102f, 0.17620613f, 0.05233154f, 0.23031242f, 0.02952478f, -0.14192331f, 0.09270595f, 0.03839533f, 
    0.06999093f, 0.04171192f, -0.02059332f, -0.05223620f, -0.19602813f, 0.10788338f, 0.03259414f, -0.06182989f, 
    -0.07066764f, -0.05318900f, 0.00206629f, -0.07657824f, 0.02242415f, 0.01517669f, -0.00612486f, 0.01976545f, 
    -0.10374465f, 0.17842013f, -0.01747723f, -0.03301724f, 0.13088168f, 0.07602157f, 0.01148815f, -0.05530242f, 
    0.15104441f, 0.15025079f, 0.11474581f, 0.28135657f, 0.11527527f, 0.14154892f, 0.17024270f, -0.14317556f, 
    0.00158969f, 0.14643574f, -0.04098487f, -0.10017611f, 0.12135196f, 0.04981922f, 0.07613667f, 0.08930559f, 
    0.62109858f, -0.06152626f, -0.24415289f, -0.15894435f, 0.04079425f, 0.06397843f, 0.02179233f, 0.02980968f, 
    0.25536793f, 0.13419053f, 0.05135140f, -0.06366235f, 0.26198179f, 0.03024203f, 0.17779379f, 0.11856413f, 
    0.13201071f, -0.09852494f, 0.13115276f, -0.18038237f, -0.01806748f, 0.02821802f, 0.00616262f, -0.08296644f, 
    0.07605267f, -0.07868985f, -0.03965493f, 0.22240046f, 0.03341638f, -0.06497789f, -0.12570116f, -0.04720330f, 
    -0.02905107f, 0.00777752f, 0.06050178f, 0.07669044f, -0.04483126f, 0.26315093f, 0.25713214f, 0.33831832f, 
    0.00438569f, -0.17540424f, -0.00659813f, 0.07575637f, 0.03658717f, 0.08182847f, 0.03205264f, 0.00935688f, 
    -0.42200559f, -0.31445512f, 0.07336643f, -0.02427168f, 0.00139472f, -0.06513611f, 0.19938582f, 0.11907715f, 
    -0.02062131f, -0.00300533f, 0.09235999f, -0.06898633f, 0.02955894f, 0.00016401f, 0.26395354f, 0.13701129f, 
    0.03023931f, -0.04048882f, -0.01102169f, -0.04019154f, -0.03452169f, 0.09768500f, 0.00040107f, 0.06780188f, 
    0.19367294f, -0.18521926f, 0.00076487f, 0.20772456f, 0.01977170f, -0.09424460f, -0.06219022f, 0.06031553f, 
    -0.15543212f, -0.03564886f, -0.13152578f, -0.10337806f, -0.05747543f, 0.04234134f, 0.00805966f, 0.14724825f, 
    -0.01658011f, -0.02280736f, 0.01262556f, 0.16082388f, -0.02900903f, -0.01400433f, -0.04138649f, -0.03009213f, 
    -0.04481494f, 0.29948124f, 0.14912809f, -0.11284001f, -0.02995716f, -0.03083374f, 0.00275699f, -0.01956582f, 
    -0.01442231f, 0.06688917f, 0.10052639f, -0.01811482f, 0.09576761f, 0.19576064f, 0.03011233f, 0.37454128f, 
    0.00796928f, -0.00733287f, -0.01905491f, 0.13501468f, -0.04201156f, -0.01364539f, -0.04108514f, -0.06200771f, 
    0.22128791f, -0.21463683f, -0.02460934f, -0.02892510f, -0.08360759f, 0.06170075f, 0.02415261f, 0.02068382f, 
    -0.09941568f, -0.04776025f, 0.08893628f, -0.12398111f, 0.06891503f, -0.06054876f, -0.16260490f, -0.16878705f, 
    -0.04398582f, -0.06624836f, 0.03797014f, 0.00928271f, -0.04137443f, 0.04735387f, 0.02256033f, -0.08815397f, 
    0.27493113f, -0.04863056f, -0.08732646f, -0.11449877f, 0.21765625f, 0.08441804f, -0.00007202f, 0.03870410f, 
    0.23697785f, 0.10043050f, 0.16964090f, 0.10939014f, 0.01143101f, -0.10520396f, 0.18405972f, 0.46585909f, 
    -0.02275660f, 0.03210963f, 0.09381445f, 0.21024607f, 0.03138909f, 0.13889937f, 0.05851028f, 0.08847283f, 
    -0.12253888f, 0.02674205f, 0.00285090f, 0.08168194f, 0.15153882f, 0.01430821f, 0.05593885f, 0.04649521f, 
    0.15579554f, 0.13952436f, 0.04497406f, -0.03579644f, -0.20823741f, 0.13523045f, -0.08012811f, 0.10547266f, 
    0.02355361f, -0.00485105f, -0.04771694f, -0.13186260f, 0.08496534f, 0.00222181f, -0.16885537f, -0.09749216f, 
    -0.07105388f, 0.00847636f, -0.08883293f, 0.03656438f, 0.10565162f, -0.07851852f, 0.07592500f, -0.01558635f, 
    -0.11751294f, 0.13064218f, 0.02623255f, 0.07166741f, 0.03806732f, -0.05557156f, -0.06685469f, -0.28069499f, 
    -0.22406006f, 0.03946243f, 0.00858546f, 0.01600095f, -0.15415102f, 0.10308839f, -0.04120519f, 0.03495556f, 
    -0.01163338f, 0.04911139f, -0.03398249f, 0.02716276f, -0.01954651f, 0.01947342f, -0.04774133f, -0.02593528f, 
    0.01325375f, -0.01923088f, -0.00175369f, -0.05335691f, 0.01382507f, -0.03580041f, -0.00453454f, -0.01527387f, 
    0.00191307f, -0.00761555f, -0.01738640f, -0.00050352f, -0.03747899f, 0.01264435f, -0.04747806f, -0.05686391f, 
    0.02760372f, -0.00850371f, 0.03342671f, -0.03088411f, -0.01728767f, 0.03276558f, -0.05606304f, -0.05647063f, 
    -0.04575231f, -0.00664403f, -0.04340454f, 0.00655768f, -0.04965471f, 0.02797655f, 0.02440462f, 0.02662582f, 
    -0.01831622f, 0.03218303f, 0.03058162f, -0.01119671f, 0.01483594f, -0.00834458f, 0.03586189f, -0.05060192f, 
    0.02975417f, 0.02665202f, -0.02544966f, -0.04925304f, 0.01642368f, -0.05942073f, 0.01321077f, 0.00910894f, 
    0.02079051f, -0.00687454f, 0.03845438f, -0.02806684f, 0.01619515f, -0.02454910f, 0.02095740f, -0.04566948f, 
    0.04112513f, -0.05849645f, 0.03432493f, -0.02675570f, -0.02567055f, -0.05715423f, 0.03236762f, -0.01690593f, 
    -0.05842522f, 0.02001069f, 0.01389928f, -0.05625150f, -0.02800903f, 0.02798622f, 0.02702274f, -0.00345113f, 
    0.01001439f, -0.04911570f, -0.03449621f, -0.04394567f, -0.02713760f, -0.00609425f, -0.05423865f, -0.04954361f, 
    0.01467248f, 0.02135147f, -0.01413463f, 0.03577173f, 0.03953707f, -0.04799855f, 0.01558562f, -0.03525786f, 
    0.01717920f, 0.02312787f, -0.00175778f, -0.01715303f, -0.01857974f, 0.04177485f, 0.01543461f, 0.02385521f, 
    -0.03572249f, -0.02491358f, 0.00138292f, 0.04062478f, -0.02329231f, 0.03617614f, 0.00222011f, -0.02396537f, 
    0.03375768f, 0.00104472f, 0.00612333f, 0.01829352f, 0.02767906f, 0.02445377f, -0.00502723f, -0.04158507f, 
    0.02444188f, -0.00702348f, -0.05610433f, -0.01379872f, 0.03724523f, 0.01652367f, -0.02203702f, 0.02624177f, 
    -0.05050297f, 0.02999159f, 0.00466860f, -0.03219313f, -0.04057594f, -0.00585468f, 0.02886110f, 0.00194914f, 
    -0.01032285f, -0.00715438f, -0.04527334f, 0.02032446f, -0.00298754f, -0.01022905f, -0.02735954f, -0.02389586f, 
    0.03756901f, 0.01113341f, -0.04523478f, -0.02300212f, -0.05695109f, -0.00233899f, 0.03707074f, -0.03512635f, 
    -0.04573119f, -0.04503959f, -0.01880252f, 0.02471891f, 0.00910143f, -0.05288116f, -0.02470535f, 0.00529237f, 
    -0.01728704f, -0.04782623f, -0.04437939f, 0.02182777f, 0.02234600f, -0.04516661f, -0.01624415f, 0.01150313f, 
    -0.04361419f, -0.00727824f, 0.01058408f, 0.02551893f, -0.00623326f, 0.02512111f, -0.00653200f, 0.03804038f, 
    0.03071242f, -0.05503493f, -0.04866694f, -0.01788155f, -0.01743468f, 0.02541729f, 0.02594110f, -0.01188711f, 
    -0.04241456f, -0.04978163f, 0.01761066f, -0.00516978f, -0.00952288f, -0.00397639f, -0.00824282f, -0.01185906f, 
    -0.05251831f, 0.04191468f, 0.02028742f, 0.02658241f, 0.00567382f, -0.00917665f, -0.05867660f, 0.02025193f, 
    -0.01581070f, -0.04406664f, 0.00887763f, -0.05432963f, 0.03991942f, -0.01918095f, 0.03206767f, 0.02085254f, 
    0.00752416f, -0.02817988f, -0.04426389f, -0.02002614f, -0.03364198f, 0.02700834f, 0.00170301f, -0.01537272f, 
    0.00995503f, -0.03234852f, -0.04123573f, -0.03540459f, -0.00180644f, 0.00838149f, -0.04497808f, 0.02178572f, 
    0.01625101f, 0.00628159f, -0.02931903f, -0.03157003f, 0.03974751f, 0.03858843f, -0.06026762f, 0.02145425f, 
    -0.00726673f, -0.04773968f, -0.02435788f, -0.00348531f, -0.00673079f, -0.01859293f, -0.01807106f, -0.05924870f, 
    -0.04389426f, -0.03499715f, 0.00365588f, 0.00902661f, -0.02001477f, 0.02603229f, 0.01951370f, -0.00581978f, 
    -0.05323958f, -0.04963818f, 0.02836916f, -0.04923984f, 0.03655592f, 0.02578474f, 0.03253387f, -0.05118027f, 
    -0.00856473f, 0.04524693f, -0.00850196f, -0.02621054f, -0.05171692f, -0.05046269f, -0.00712856f, -0.01527096f, 
    -0.01494207f, -0.03075467f, 0.00944249f, -0.01940451f, 0.03289350f, 0.03371490f, -0.02670823f, -0.00765648f, 
    -0.03798009f, 0.02072171f, 0.02819019f, -0.03920768f, 0.00410147f, 0.04401369f, -0.01053752f, 0.01464848f, 
    0.00183289f, 0.01377738f, -0.00591142f, -0.01636218f, 0.03212899f, -0.05124740f, -0.05827730f, -0.04273689f, 
    -0.04092744f, 0.02289527f, 0.03455255f, -0.00668870f, -0.04898272f, -0.03866773f, 0.03532663f, 0.01986476f, 
    -0.04427018f, -0.05933056f, 0.03068504f, -0.01615221f, -0.06038844f, -0.01882986f, 0.01014188f, -0.02357335f, 
    0.01486253f, -0.04931269f, -0.05872535f, 0.02485173f, 0.03553400f, 0.02768563f, -0.04568475f, 0.03810155f, 
    0.03677116f, -0.01995379f, 0.01846113f, -0.04118001f, 0.00733843f, -0.00611152f, -0.04953085f, -0.05429218f, 
    0.00278064f, -0.04976773f, -0.00037393f, 0.01170244f, 0.02025362f, -0.02757964f, -0.02205868f, 0.02271084f, 
    -0.00643056f, -0.01004272f, 0.01223094f, -0.04322738f, -0.01299994f, -0.03235218f, -0.02561291f, 0.03896036f, 
    0.01277354f, -0.05163175f, 0.03595440f, -0.04970119f, -0.01392558f, 0.03910427f, -0.01804960f, 0.02076506f, 
    0.01077640f, 0.02112995f, -0.03915465f, -0.01232457f, 0.03281962f, -0.04767583f, -0.04123166f, 0.02404194f, 
    0.00793892f, 0.03146804f, -0.01219126f, 0.02589121f, 0.02907067f, -0.06045108f, 0.01325557f, 0.01331999f, 
    0.00986225f, -0.01526978f, 0.02234658f, -0.06106559f, -0.00727340f, -0.02981279f, -0.02264575f, -0.02714126f, 
    0.01076734f, -0.00899716f, -0.04650181f, 0.03368504f, -0.03124397f, -0.01799376f, -0.05223886f, -0.00417808f, 
    0.00319287f, -0.05555814f, 0.03628111f, 0.00808100f, 0.01806035f, -0.01493516f, -0.00794901f, -0.02825258f, 
    -0.01131178f, 0.03327955f, 0.00857643f, 0.03836007f, -0.00082093f, -0.04622273f, -0.03842004f, -0.00589654f, 
    -0.03436951f, -0.04946136f, 0.01139394f, -0.03695209f, 0.02217627f, 0.01852900f, 0.02721193f, 0.00246832f, 
    -0.04693906f, 0.03117990f, 0.03590437f, 0.04272801f, -0.02579231f, -0.02170696f, -0.05287794f, 0.01105027f, 
    0.02593333f, 0.02911285f, -0.01140199f, -0.02025141f, -0.00414882f, -0.04093694f, -0.03856651f, 0.04589716f, 
    -0.01111149f, -0.01808329f, -0.00781432f, -0.02436951f, -0.05850089f, 0.00677516f, -0.00799155f, 0.00423260f, 
    0.03838222f, 0.03863017f, 0.01731627f, -0.04747213f, -0.01772917f, -0.00591678f, 0.04891565f, 0.01173700f, 
    -0.04931390f, 0.03090668f, -0.02933269f, -0.06028578f, -0.04735864f, 0.02322404f, 0.03780327f, -0.00561110f, 
    -0.03390736f, -0.04520274f, 0.02567721f, -0.01079200f, -0.03491412f, -0.02108042f, 0.00028632f, -0.04692622f, 
    -0.04601866f, 0.01589367f, 0.03300111f, 0.00888300f, 0.01030539f, 0.03036981f, 0.01737239f, 0.00597631f, 
    0.00700347f, 0.03541549f, -0.03687894f, 0.02143739f, -0.00716140f, 0.02485818f, -0.02868318f, -0.02415507f, 
    0.03883846f, 0.01472202f, 0.03925607f, 0.04160629f, 0.02948608f, 0.00749784f, -0.03057088f, 0.00576118f, 
    0.04269531f, -0.02624317f, -0.02437617f, 0.03832685f, -0.03112411f, 0.02602178f, 0.00839065f, 0.03887599f, 
    -0.03529448f, -0.02990739f, 0.02863023f, -0.00289981f, -0.01354377f, 0.01003036f, -0.02264242f, -0.05641210f, 
    0.01731137f, -0.04816908f, -0.04879868f, 0.01489495f, -0.04013061f, 0.04203051f, -0.03938475f, 0.00075704f, 
    -0.03070756f, 0.00761109f, -0.01732189f, -0.03823315f, 0.02280589f, -0.00240109f, -0.04721213f, 0.02852571f, 
    -0.02444080f, -0.00420085f, 0.02496027f, -0.03516386f, -0.03960189f, 0.02623079f, -0.00668284f, 0.03595228f, 
    0.00016921f, 0.01401864f, -0.00396442f, 0.03979741f, -0.00628565f, -0.02361515f, -0.03745113f, -0.00148191f, 
    0.02905772f, 0.01534133f, -0.05161413f, 0.04647917f, 0.04009712f, -0.03490649f, 0.03142575f, -0.05671202f, 
    -0.02145444f, -0.04413089f, 0.03147566f, -0.04539958f, -0.04510632f, 0.02881799f, 0.00446363f, -0.05753770f, 
    0.02593288f, 0.02151789f, -0.04314678f, -0.04248463f, 0.02092955f, -0.01170847f, -0.03770303f, -0.03213307f, 
    0.00192827f, 0.01762282f, 0.00756843f, -0.05355828f, -0.00853371f, 0.01033081f, -0.00659524f, 0.00538971f, 
    -0.02010022f, -0.01788378f, -0.04253598f, -0.00302075f, -0.04361773f, -0.02418272f, 0.00512974f, -0.00930997f, 
    -0.01192814f, -0.02246444f, -0.00617245f, 0.00672833f, 0.00443306f, 0.02679843f, -0.02849127f, -0.02065334f, 
    -0.00276636f, 0.02438333f, 0.03871699f, -0.04842330f, 0.00715824f, -0.01662369f, -0.04188195f, 0.00419939f, 
    0.03299591f, -0.05070363f, 0.00002249f, -0.01813262f, -0.02986434f, -0.05366584f, -0.00749772f, -0.05155112f, 
    -0.05191848f, -0.00863835f, -0.00746174f, 0.02380341f, 0.01971296f, 0.02192311f, -0.04926104f, 0.04060522f, 
    0.03596658f, -0.00585124f, -0.04774696f, -0.04418886f, -0.02141228f, 0.02195731f, 0.03610983f, -0.00775032f, 
    -0.03611831f, -0.02953598f, 0.03345617f, -0.01580637f, 0.01940137f, -0.04264765f, -0.03979885f, -0.03573148f, 
    0.02620180f, -0.04073878f, -0.02820032f, -0.01158464f, -0.05119834f, -0.01519195f, -0.05361365f, 0.01312040f, 
    0.03664593f, -0.01160392f, 0.02299817f, 0.02762565f, -0.04927146f, -0.05679547f, -0.01030598f, 0.03801556f, 
    0.03105264f, -0.03539537f, 0.02380661f, -0.04064193f, -0.03940029f, 0.03746911f, -0.03639363f, 0.00704689f, 
    0.03505241f, 0.00871302f, 0.00890219f, 0.04690368f, -0.04154932f, -0.03993447f, -0.02947930f, 0.02214296f, 
    -0.05174439f, 0.00268648f, 0.02283647f, -0.00268492f, 0.01710365f, -0.02038743f, -0.04248792f, 0.04042684f, 
    0.04134776f, 0.02410973f, -0.02031770f, -0.00236817f, -0.03738385f, 0.02477355f, -0.02974415f, 0.01400436f, 
    -0.01255483f, -0.03519651f, 0.00750289f, 0.02578509f, 0.04138919f, -0.05777133f, 0.03111282f, -0.04652885f, 
    -0.02539349f, -0.01983596f, 0.03176932f, -0.02821141f, 0.01459029f, 0.03381542f, 0.00806543f, 0.04926424f, 
    0.00799986f, -0.00491471f, 0.01426692f, -0.00484817f, 0.02287946f, -0.03935127f, 0.04011719f, 0.00405198f, 
    -0.05369493f, -0.02859098f, 0.02859935f, -0.02156873f, 0.04092462f, 0.00266528f, -0.04067633f, -0.01309266f, 
    -0.05549237f, 0.04300527f, 0.02107668f, -0.04015123f, 0.00682944f, 0.03843822f, 0.00033650f, -0.01627380f, 
    0.02312606f, 0.04367607f, 0.02457178f, -0.02317951f, 0.00465675f, -0.00117187f, 0.01367472f, 0.02152187f, 
    -0.02834073f, -0.03841807f, -0.01288856f, -0.04539327f, -0.02636849f, -0.03027013f, -0.04085455f, -0.00388355f, 
    0.01397325f, -0.01465707f, 0.03871126f, 0.05222863f, -0.03795401f, -0.02744727f, 0.04393202f, 0.03409344f, 
    0.01674628f, -0.03471823f, 0.01756617f, 0.04836654f, -0.05543140f, 0.00458554f, 0.02372311f, -0.03941052f, 
    -0.04730259f, -0.04484561f, -0.03437721f, 0.01260963f, 0.04138735f, -0.04559084f, 0.01429645f, 0.02367778f, 
    -0.00477113f, -0.03686250f, -0.02870920f, -0.01402474f, -0.02759616f, 0.04049517f, -0.04582598f, -0.04002339f, 
    0.02761031f, 0.03774633f, -0.05337470f, 0.01332873f, -0.05358351f, -0.00016888f, 0.03303687f, -0.04351690f, 
    -0.05773572f, -0.04579117f, 0.01746801f, -0.03497970f, -0.05001891f, 0.04780655f, 0.00760835f, -0.00055612f, 
    -0.01563851f, -0.00731006f, -0.01509737f, 0.02988238f, 0.02668161f, -0.01079582f, -0.03700880f, 0.04425994f, 
    -0.28856078f, 0.01215560f, 0.14018130f, -0.05694964f, -0.13017453f, 0.07294613f, -0.06669167f, 0.19571623f, 
    -0.04550198f, 0.10403045f, -0.04791863f, -0.08230605f, 0.03616610f, -0.21870586f, 0.10894059f, 0.24749035f, 
    -0.03641123f, -0.04464078f, -0.02891935f, 0.01212334f, -0.00841818f, 0.14358827f, 0.01897764f, 0.01837038f, 
    0.24138811f, 0.10747066f, -0.12977178f, 0.10069039f, -0.06766792f, -0.04157809f, -0.01715282f, 0.08766902f, 
    0.01153273f, 0.03196939f, 0.17553718f, 0.26111171f, 0.05909760f, -0.14100248f, 0.21671291f, -0.27761385f, 
    -0.04871558f, -0.01395054f, 0.05401513f, 0.08994946f, -0.09204125f, 0.15856504f, -0.17508456f, -0.00347722f, 
    -0.55882919f, -0.07842906f, 0.20109107f, 0.00451935f, -0.02460573f, 0.07709392f, -0.09738140f, -0.07673644f, 
    0.00494434f, 0.00006314f, -0.11098380f, 0.12468714f, -0.11416471f, 0.05830539f, 0.01233521f, -0.08748560f, 
    0.05360854f, 0.18102647f, 0.05510633f, -0.05724028f, -0.02227552f, -0.02850797f, -0.03058183f, 0.02834089f, 
    0.02452125f, 0.18065234f, 0.10743155f, 0.05636772f, -0.02510522f, -0.05383321f, -0.04280924f, -0.00042601f, 
    0.14121126f, 0.00921032f, 0.01337387f, 0.04811761f, -0.06390718f, -0.18156473f, -0.02869685f, -0.11521050f, 
    0.01349450f, 0.07160160f, -0.09823315f, 0.14033012f, -0.00402432f, -0.04159673f, -0.12836929f, -0.07202416f, 
    -0.09423093f, 0.04621651f, -0.07696348f, -0.19559383f, -0.04126037f, 0.04308610f, 0.09390027f, -0.13359351f, 
    -0.03981723f, 0.01798046f, -0.03491307f, 0.01717299f, -0.12508391f, 0.00930297f, 0.09944520f, -0.05372275f, 
    -0.17425919f, 0.07493825f, -0.00025560f, 0.01066715f, 0.07313056f, -0.15255779f, 0.20005152f, -0.13636452f, 
    0.08883635f, 0.05308152f, -0.23600365f, -0.10735777f, 0.01128646f, 0.00816055f, 0.01951154f, -0.06741733f, 
    -0.02423736f, -0.02038275f, -0.16236766f, -0.02599499f, 0.09899644f, 0.05915227f, 0.01301349f, -0.07653207f, 
    -0.03257627f, -0.10097827f, 0.02442100f, 0.05436125f, -0.12986735f, 0.07794088f, 0.12778157f, 0.15884878f, 
    0.07822262f, -0.07341889f, 0.11788490f, -0.12171537f, -0.00255058f, -0.05559142f, 0.01505837f, -0.03149625f, 
    -0.01613244f, -0.01122126f, -0.05798031f, -0.18926276f, 0.00918356f, -0.07649467f, 0.09183911f, 0.10759091f, 
    0.00083015f, 0.10348827f, -0.03861953f, 0.14426863f, -0.01848926f, -0.10518115f, 0.13174319f, 0.02001519f, 
    -0.20364466f, 0.20182979f, 0.35452849f, 0.00157867f, -0.10472813f, -0.12031209f, -0.11666608f, -0.03637027f, 
    -0.01559519f, 0.05585699f, 0.11408661f, -0.02739188f, -0.09426790f, 0.06377981f, -0.08013220f, -0.15169245f, 
    0.02075468f, 0.17373876f, -0.04294967f, 0.28975582f, -0.08988801f, -0.10408282f, 0.00854292f, -0.06538837f, 
    -0.12364836f, 0.01653482f, 0.03841671f, 0.31587443f, 0.00063892f, 0.03306103f, -0.11732632f, 0.06710207f, 
    -0.12067857f, -0.10622331f, 0.01223315f, -0.12614632f, 0.19482769f, -0.17224750f, -0.09220186f, -0.17462133f, 
    0.03227266f, 0.02530188f, 0.15137829f, -0.01906507f, -0.14839402f, -0.05625825f, -0.11360656f, -0.09396186f, 
    0.40374622f, 0.22186431f, -0.03019657f, -0.00076045f, 0.01284127f, -0.08392223f, -0.01213644f, 0.14003009f, 
    0.07218472f, 0.05263739f, -0.05398468f, -0.07591733f, 0.01166645f, 0.01733089f, 0.09529559f, -0.01753992f, 
    -0.07901156f, 0.00289137f, 0.06020137f, -0.07231376f, 0.02049038f, -0.07398146f, 0.02673860f, -0.11008608f, 
    -0.09070483f, -0.02638213f, 0.19629206f, -0.05321732f, 0.02157042f, 0.01998723f, -0.04078075f, -0.04671945f, 
    -0.00665948f, 0.07296795f, -0.02324336f, 0.09548473f, -0.06689190f, 0.03090095f, -0.00285443f, 0.05094122f, 
    0.00244649f, 0.08977216f, -0.03234403f, -0.05317661f, 0.08778200f, 0.03461042f, -0.05120563f, 0.16837892f, 
    -0.08714496f, 0.00262215f, 0.11014344f, 0.00176688f, -0.00618399f, 0.01982761f, -0.12760668f, 0.01744689f, 
    0.03292244f, -0.03883430f, 0.09588532f, 0.07495999f, 0.00354765f, 0.06383345f, -0.09289600f, -0.10156009f, 
    0.15272582f, -0.03377945f, 0.13729587f, -0.12434044f, -0.00191183f, -0.01525297f, 0.00700978f, 0.06759167f, 
    -0.12667933f, 0.17679745f, 0.19087598f, -0.13362882f, -0.04115845f, 0.05235650f, 0.10184767f, 0.15440685f, 
    0.06797728f, 0.10687821f, -0.07242195f, -0.00210232f, 0.05977326f, 0.06691182f, 0.09444068f, -0.04681882f, 
    -0.09085769f, 0.05678392f, 0.14324364f, 0.18244611f, 0.16418159f, -0.10590591f, -0.00474436f, -0.05048643f, 
    -0.26327688f, 0.16033089f, -0.04423766f, 0.03617450f, -0.05627827f, -0.06879198f, 0.03206496f, 0.08361194f, 
    -0.19867815f, 0.01314387f, -0.07776459f, -0.00488357f, 0.12162683f, -0.13791268f, 0.16269068f, -0.10918374f, 
    -0.03191226f, -0.14057055f, -0.09857441f, -0.07608023f, -0.07952496f, -0.13460465f, -0.06889393f, -0.01932230f, 
    0.11342864f, 0.07437040f, -0.13188319f, -0.12462102f, -0.01936324f, 0.11661190f, 0.09530664f, -0.12442189f, 
    -0.00726623f, 0.09583371f, -0.03199494f, 0.13778140f, 0.11480299f, -0.13327527f, 0.07191744f, 0.08271577f, 
    -0.06551562f, 0.10520019f, 0.02701965f, -0.03229564f, 0.10462420f, 0.00687591f, 0.12281132f, 0.08068360f, 
    0.07650492f, -0.14522722f, 0.16247638f, 0.20839661f, 0.05096421f, 0.07751343f, 0.14751264f, -0.11210566f, 
    0.10517848f, 0.01174253f, 0.14959073f, 0.01832283f, 0.00154261f, 0.33884528f, -0.19492790f, 0.24070363f, 
    0.03783390f, 0.05653581f, 0.13649464f, -0.04875614f, -0.04345832f, -0.10197388f, 0.03970433f, -0.01872829f, 
    0.02438450f, 0.05184700f, 0.00078488f, 0.02648166f, -0.00792778f, 0.00627691f, 0.00455491f, -0.01834694f, 
    0.01589544f, -0.02429858f, -0.00253475f, 0.04016020f, -0.04894713f, -0.02507320f, -0.00591375f, 0.03235289f, 
    0.02379352f, 0.02544835f, -0.01448622f, 0.02606840f, 0.02296684f, -0.03818945f, 0.02933995f, -0.02276810f, 
    0.01416207f, 0.03383063f, -0.05861849f, 0.00050337f, 0.00547761f, -0.02509439f, -0.05608547f, 0.03980532f, 
    -0.03465821f, -0.01110375f, -0.00727429f, -0.04834459f, 0.04022513f, -0.01891619f, -0.05359131f, -0.04317777f, 
    -0.04569003f, 0.04032375f, 0.03735679f, 0.03302396f, -0.05597676f, -0.03753909f, -0.00496000f, -0.02214889f, 
    0.02959879f, 0.02275643f, 0.04176547f, -0.04124516f, -0.05979803f, 0.04171956f, 0.03555149f, 0.01935962f, 
    -0.01191458f, 0.00184054f, -0.04615200f, 0.00605362f, -0.03201290f, -0.01552213f, -0.05702982f, 0.03368851f, 
    -0.01497423f, -0.02189487f, -0.04065021f, 0.00909377f, 0.01000923f, -0.00416540f, -0.01564697f, -0.00518487f, 
    -0.05373454f, -0.02058838f, 0.02447982f, -0.02623950f, -0.02668987f, 0.00209851f, -0.02829178f, 0.01190428f, 
    -0.01977164f, -0.02935104f, -0.03755539f, 0.03531609f, -0.03143699f, -0.01344167f, -0.03995265f, 0.01204557f, 
    -0.02045737f, 0.04252155f, -0.02542731f, -0.02611872f, -0.04418302f, -0.01351402f, 0.02363054f, -0.00716416f, 
    -0.01962842f, -0.00111046f, 0.00514635f, -0.05018463f, -0.03430244f, -0.00931504f, -0.04112586f, 0.01460207f, 
    -0.01018382f, 0.00546358f, -0.00543266f, -0.04072276f, -0.02397412f, -0.01453882f, -0.05258420f, 0.00046505f, 
    -0.02747513f, -0.00926451f, -0.02818572f, -0.00710980f, -0.02444559f, 0.02800537f, -0.01308876f, 0.00221203f, 
    -0.03218456f, 0.02457922f, 0.01591961f, 0.03159218f, 0.02869754f, -0.03042960f, -0.00690748f, 0.04527568f, 
    -0.05824666f, -0.03891632f, 0.03931469f, -0.05218749f, -0.03985689f, 0.00988165f, 0.03957923f, -0.03076713f, 
    -0.04313006f, 0.00858632f, 0.02687231f, 0.00306468f, 0.02010727f, 0.02567953f, 0.01359386f, -0.04422545f, 
    -0.00707806f, 0.02702540f, -0.00772680f, 0.02262646f, 0.03930121f, -0.01064002f, 0.02127950f, -0.05161003f, 
    -0.05440881f, 0.02291753f, -0.02697002f, 0.04024750f, -0.01871920f, -0.05322948f, -0.04651592f, 0.02171131f, 
    -0.03142256f, 0.02128318f, 0.03488781f, -0.04345319f, -0.03212122f, 0.04302734f, 0.00563700f, -0.01786838f, 
    -0.02272146f, 0.01420297f, -0.01067120f, 0.01067375f, 0.01675167f, -0.02913552f, -0.04926035f, 0.03063188f, 
    -0.03329948f, 0.04952508f, -0.04379797f, -0.01543491f, 0.03080067f, -0.01005213f, -0.04146083f, 0.00225160f, 
    0.02230709f, 0.00018250f, 0.03147939f, 0.02710319f, -0.05802801f, 0.01767756f, 0.00918099f, 0.00928328f, 
    -0.00974609f, 0.00052508f, 0.01994183f, -0.01720080f, -0.04652360f, -0.00282531f, 0.02024616f, -0.00471673f, 
    -0.03358521f, -0.03656624f, 0.02658521f, 0.04350900f, -0.00073372f, 0.03090519f, -0.04375375f, -0.04077463f, 
    -0.05474298f, -0.00331744f, 0.03347918f, -0.00243288f, 0.03255141f, 0.01024036f, -0.00237289f, -0.05890671f, 
    0.01623176f, -0.05059777f, 0.02742340f, -0.03612708f, -0.02112517f, -0.03269926f, -0.03411528f, -0.04498197f, 
    0.03541072f, 0.04085634f, -0.05841877f, -0.03940516f, 0.02991226f, 0.02456353f, 0.01957237f, 0.04193977f, 
    0.01047018f, -0.04217288f, 0.00096690f, -0.00865531f, -0.01650410f, 0.00987031f, -0.02517669f, 0.02114699f, 
    0.01004570f, -0.03147900f, -0.04048603f, -0.00045583f, -0.04190928f, -0.00130078f, -0.04711294f, 0.03732889f, 
    -0.03636218f, 0.04154760f, -0.00422625f, -0.01435595f, 0.03751719f, 0.02423638f, -0.03814834f, -0.04567265f, 
    -0.04077575f, -0.04519805f, -0.01057370f, 0.00354475f, -0.02036380f, -0.03547097f, -0.01731443f, -0.05870579f, 
    0.02470893f, -0.01106917f, -0.03944026f, -0.02401254f, -0.02551820f, -0.04014557f, 0.01670592f, -0.03042899f, 
    -0.03036134f, 0.02818598f, -0.02051749f, 0.03509240f, 0.02069645f, 0.01210270f, 0.01222279f, 0.02825822f, 
    0.00081441f, -0.01130909f, -0.00004630f, -0.03531776f, -0.00522551f, -0.00606665f, -0.01327682f, -0.04530010f, 
    0.03434317f, 0.03935294f, -0.04794453f, 0.04163348f, -0.02190772f, -0.04246656f, -0.02032076f, 0.04357697f, 
    0.04067490f, 0.01521873f, 0.03159209f, -0.00336353f, -0.03542054f, 0.00753078f, -0.04239494f, -0.04655396f, 
    0.03151719f, -0.01918899f, -0.03022732f, -0.03073342f, -0.05513456f, -0.05204864f, -0.00161570f, 0.02157823f, 
    0.01534981f, -0.05839615f, -0.00568217f, -0.03022758f, 0.02007308f, -0.05201725f, -0.05104120f, 0.02697881f, 
    0.00883123f, -0.04739352f, -0.04671897f, -0.00646074f, -0.03583806f, -0.04143298f, 0.02399068f, 0.00431836f, 
    -0.00565686f, 0.02779336f, -0.00486749f, 0.01340010f, 0.02547717f, 0.04347885f, -0.00302397f, -0.02228301f, 
    0.04340722f, -0.04039142f, -0.04080511f, -0.00056457f, -0.05493089f, 0.03708071f, 0.02800788f, -0.00695888f, 
    -0.03123147f, -0.03187314f, -0.00710182f, -0.02344681f, 0.02608820f, 0.04667570f, 0.02371977f, -0.00368772f, 
    -0.00481285f, 0.00813166f, -0.02405649f, -0.04527935f, 0.00114895f, 0.02441956f, 0.01340986f, -0.03172397f, 
    -0.03321667f, -0.02897846f, 0.04499588f, -0.00982518f, -0.01609497f, -0.04988755f, 0.04001714f, -0.02103336f, 
    0.01163479f, -0.01020676f, 0.05067613f, -0.02164677f, -0.02158520f, 0.01257703f, -0.03381337f, -0.04354403f, 
    0.00691993f, 0.01898309f, 0.04528138f, -0.03136064f, -0.05576311f, -0.06072089f, -0.01569828f, 0.01220476f, 
    -0.00967857f, 0.03920146f, -0.00894094f, -0.05388838f, -0.04228084f, -0.03421022f, -0.02227257f, -0.03624976f, 
    -0.04842542f, -0.04391484f, -0.00248727f, 0.02811791f, -0.04159282f, -0.04334308f, -0.00613984f, -0.05702738f, 
    0.02889570f, -0.03935613f, 0.04122523f, -0.01029262f, 0.00009627f, 0.02030973f, -0.05730369f, -0.02027481f, 
    -0.00739017f, -0.05241489f, -0.02784670f, 0.00652281f, -0.01178158f, -0.01647671f, 0.01132796f, 0.01104853f, 
    -0.03493786f, -0.03088756f, -0.02987739f, 0.02163697f, -0.00406186f, 0.00455420f, -0.04806699f, -0.03980550f, 
    0.00992020f, -0.04181799f, -0.05084622f, -0.02145172f, -0.03666010f, -0.04574960f, 0.01461083f, 0.00900586f, 
    -0.03763923f, 0.02554760f, 0.02176006f, -0.04378802f, -0.00272207f, -0.03846494f, 0.01337547f, -0.02105670f, 
    -0.04598911f, -0.01972894f, 0.01513977f, 0.00635922f, -0.02082574f, -0.01006315f, 0.01849873f, -0.01089536f, 
    -0.04285794f, -0.01221066f, -0.01501461f, -0.00812925f, -0.03829866f, -0.00891491f, -0.01670046f, 0.00963688f, 
    -0.03418070f, -0.01011767f, 0.01509956f, 0.00440851f, 0.04229560f, 0.00206584f, 0.02846243f, -0.01339625f, 
    -0.05011066f, -0.01407688f, 0.00314962f, -0.05552441f, 0.02452093f, -0.01293787f, -0.05803457f, 0.01187890f, 
    0.02714948f, -0.02042346f, -0.03023562f, 0.01806515f, -0.01391879f, -0.04166656f, -0.01480941f, 0.02456627f, 
    -0.02969437f, 0.01986220f, 0.01782619f, 0.02077996f, -0.01835688f, 0.03449004f, -0.02519559f, -0.04030335f, 
    0.00501999f, -0.01419189f, 0.02803626f, -0.04226144f, -0.05380949f, -0.04452426f, -0.02547315f, -0.04761726f, 
    -0.00458561f, -0.05351236f, -0.00342733f, -0.04113031f, 0.01184475f, 0.03054651f, 0.00797040f, -0.01954906f, 
    -0.04251422f, -0.01034713f, 0.02888492f, 0.02637775f, 0.04550619f, -0.01389471f, -0.02313133f, -0.01386184f, 
    0.03155780f, -0.03798272f, -0.04060550f, 0.02755146f, -0.00652982f, -0.04401803f, -0.02728318f, 0.03004154f, 
    0.00556111f, -0.04326640f, -0.04323657f, 0.04099869f, 0.00602256f, -0.04626890f, 0.03068461f, -0.04302822f, 
    -0.02909740f, 0.05502200f, 0.03707192f, -0.01688678f, -0.01908165f, 0.00908740f, -0.02620219f, 0.01426651f, 
    -0.01739945f, -0.02746026f, -0.02822998f, -0.01261734f, -0.03709362f, 0.01683100f, -0.00451199f, -0.03520818f, 
    -0.05338661f, -0.01132001f, 0.00054757f, 0.00148306f, -0.01042890f, 0.00269656f, -0.00545538f, 0.03233736f, 
    0.03852528f, -0.04329323f, -0.01541990f, 0.02082272f, -0.01981764f, 0.03822071f, -0.01072800f, -0.02372388f, 
    -0.05555137f, 0.00242778f, -0.05326831f, -0.04549801f, 0.05178906f, 0.01743449f, 0.02207445f, -0.04598204f, 
    0.01780451f, -0.03823416f, -0.00029642f, -0.02816556f, 0.03127781f, -0.01477154f, 0.03990570f, -0.04420840f, 
    -0.00749132f, -0.02200276f, 0.00278578f, -0.01649564f, 0.04300678f, 0.02605348f, 0.03334748f, 0.00135352f, 
    -0.02069837f, -0.02093180f, 0.00497509f, 0.02652137f, -0.00997284f, 0.01865994f, 0.01173249f, 0.04299171f, 
    0.00187008f, -0.03154287f, -0.03124821f, 0.03434125f, 0.02883140f, -0.01746169f, -0.03948482f, -0.03018943f, 
    0.00123249f, -0.04762638f, -0.03787508f, 0.01962040f, 0.02623204f, -0.04068873f, -0.00303016f, -0.02780502f, 
    -0.01523843f, 0.02868089f, -0.02229434f, -0.00990996f, 0.03224231f, -0.01714893f, 0.01394916f, -0.04724719f, 
    0.01566271f, 0.02355427f, -0.01128488f, 0.02633297f, -0.00527901f, -0.02643031f, -0.02185958f, -0.05860096f, 
    -0.03194593f, 0.01858341f, -0.03004752f, 0.03679043f, 0.03443874f, -0.00110796f, -0.00039598f, -0.00110237f, 
    -0.00008730f, 0.03762439f, -0.05684743f, 0.00702955f, 0.02800098f, -0.04166438f, 0.02051088f, -0.02408537f, 
    0.02484593f, 0.01620612f, -0.02902443f, 0.01818232f, 0.03452860f, 0.02905329f, 0.03778869f, 0.02560581f, 
    -0.01033897f, -0.01535557f, 0.00152118f, -0.01690322f, 0.00023996f, 0.00658751f, 0.01231292f, 0.04220370f, 
    -0.00700692f, 0.03408778f, 0.03476037f, -0.03030867f, -0.05721911f, -0.01119643f, 0.03333858f, -0.01665516f, 
    -0.00544612f, 0.03560286f, -0.01620996f, -0.04584436f, -0.04858774f, -0.01057598f, -0.01638129f, 0.01292075f, 
    0.01551203f, -0.04649640f, 0.03975843f, -0.01361699f, -0.03610941f, -0.03506526f, -0.02492639f, 0.01530170f, 
    -0.01499304f, -0.03389420f, 0.00860414f, 0.01885252f, 0.01069342f, -0.03466311f, 0.03587686f, -0.02787557f, 
    0.01605712f, 0.03592406f, 0.02089017f, 0.03589916f, 0.01110322f, 0.04086039f, -0.00229956f, -0.03264322f, 
    -0.03301527f, -0.02758067f, 0.00109549f, -0.01796264f, 0.00827095f, -0.05259151f, -0.02408476f, 0.00853696f, 
    0.03907057f, -0.04321111f, -0.04433573f, 0.00608641f, -0.04049093f, 0.03248755f, -0.02902942f, -0.01446592f, 
    0.03254778f, 0.02033737f, -0.01638587f, 0.02358695f, 0.00588577f, -0.04585658f, -0.05631870f, 0.00444112f, 
    0.00300117f, 0.04406444f, -0.04332594f, -0.04445332f, 0.01840511f, -0.02935458f, -0.03176136f, -0.01210984f, 
    -0.00882602f, 0.03651359f, -0.05535858f, 0.00831535f, 0.02959484f, -0.03858044f, -0.01861848f, -0.04648415f, 
    -0.05449522f, 0.01390600f, 0.00277859f, 0.03309782f, 0.01346882f, 0.01641323f, 0.00451592f, -0.04086297f, 
    -0.04444043f, 0.02028702f, -0.05519815f, 0.01210824f, 0.04347689f, 0.01609276f, 0.03973835f, 0.01147145f, 
    -0.02469508f, -0.01930699f, 0.01494577f, -0.04492328f, -0.00326399f, -0.03807100f, -0.00495576f, -0.01580929f, 
    0.01513558f, -0.00602389f, 0.01620705f, 0.02683548f, -0.00728309f, -0.02584900f, -0.00296634f, 0.02056651f, 
    -0.04528722f, -0.03871661f, -0.00045278f, -0.00707432f, -0.01573462f, -0.00374627f, 0.04104573f, -0.01979988f, 
    0.03369000f, 0.03181102f, -0.03979116f, 0.02926920f, 0.00446257f, -0.05997959f, 0.02417177f, -0.02362939f, 
    0.03337625f, -0.03341593f, -0.00145655f, 0.01821436f, -0.04470978f, 0.02083454f, 0.02669174f, 0.00448628f, 
    0.01600690f, 0.02704513f, 0.00533387f, 0.01445793f, -0.05310323f, -0.04455710f, -0.03388124f, -0.00159448f, 
    -0.00943755f, 0.02137935f, 0.02327560f, -0.00267022f, -0.02129679f, 0.01147235f, -0.03292290f, 0.00685095f, 
    -0.00237352f, -0.00439055f, 0.00327729f, -0.02080925f, -0.03842882f, -0.04750421f, -0.01075218f, -0.02959275f, 
    -0.05283340f, -0.00092467f, -0.02699254f, -0.03332395f, -0.05468519f, -0.02181629f, 0.03913690f, -0.03682930f, 
    -0.03790881f, -0.01333265f, -0.02641213f, -0.01763170f, -0.03463108f, 0.02935673f, -0.01146859f, 0.03136913f, 
    -0.01175518f, 0.02708395f, -0.00500970f, 0.02980433f, 0.01323320f, -0.05187273f, -0.01067277f, -0.02794570f, 
    -0.02213742f, 0.00144094f, -0.01909081f, 0.03641154f, -0.05987078f, -0.05653047f, 0.01539025f, 0.02005048f, 
    0.01585515f, 0.00282596f, -0.04047652f, -0.04900921f, 0.02133539f, -0.00865494f, 0.02295375f, -0.05642746f, 
    -0.04035416f, 0.02387187f, -0.00907776f, -0.05683245f, -0.01487635f, 0.03563911f, -0.01495766f, 0.04171499f, 
    0.01301510f, -0.02124867f, -0.00823551f, 0.00855951f, -0.05890648f, -0.02605261f, -0.00455971f, 0.02332857f, 
    -0.02095906f, -0.00454497f, -0.04660064f, -0.05801873f, -0.04771624f, 0.00001013f, 0.03594032f, -0.04802432f, 
    -0.04344682f, -0.00824649f, 0.03946934f, -0.04129616f, 0.00814596f, 0.03412464f, -0.05139728f, -0.05678695f, 
    0.02922452f, -0.03235142f, 0.01360701f, -0.01374915f, 0.00138607f, 0.03661328f, -0.05397043f, -0.02406771f, 
    -0.06065639f, -0.02371825f, -0.03815761f, -0.04845518f, 0.00206885f, 0.02620662f, 0.02543018f, 0.01442605f, 
    0.03099433f, -0.00756553f, -0.04032508f, -0.00807740f, -0.02863146f, -0.01292847f, -0.04044001f, 0.03844871f, 
    0.03312701f, 0.04934828f, 0.00100763f, 0.01210955f, -0.01204361f, -0.01349616f, 0.02940157f, -0.02048599f, 
    0.00049426f, -0.00679869f, -0.00588091f, -0.03708984f, 0.00201649f, 0.04064923f, -0.02704911f, -0.01425740f, 
    0.03426923f, -0.05679909f, 0.01980438f, 0.02339704f, 0.00815530f, -0.03545135f, -0.00889697f, 0.02533093f, 
    0.03052032f, 0.02962043f, -0.00497174f, -0.05875381f, -0.05824430f, 0.04717923f, -0.02746855f, -0.05011317f, 
    -0.00412282f, 0.02724883f, 0.00446051f, -0.00525837f, 0.00105867f, -0.00549360f, 0.03946109f, -0.02862755f, 
    -0.02742204f, -0.01609318f, -0.02227270f, -0.00113403f, -0.04933555f, -0.01021990f, 0.02708837f, 0.01824517f, 
    0.02332399f, -0.05166636f, -0.02522374f, -0.02699708f, 0.01661480f, -0.05924533f, 0.04080558f, -0.05690091f, 
    0.02299183f, -0.01197037f, -0.01311569f, 0.03704499f, 0.01888163f, 0.03861265f, 0.01912452f, -0.01053918f, 
    0.01357905f, 0.00534479f, 0.03416692f, -0.01671315f, 0.01303362f, -0.01280322f, -0.04107298f, -0.02222669f, 
    -0.03320348f, -0.03300414f, -0.00765421f, -0.01874682f, 0.01119504f, 0.00434930f, 0.02027640f, -0.00282256f, 
    -0.01351868f, -0.01378008f, -0.03743544f, -0.02395689f, -0.03900569f, -0.02567955f, 0.02536687f, -0.03804354f, 
    0.00640102f, -0.03850491f, -0.02755480f, -0.03559372f, -0.00621264f, -0.05250156f, -0.03186748f, -0.00763233f, 
    0.03585517f, 0.00041883f, -0.02004796f, 0.03821498f, -0.03848242f, 0.02507601f, 0.02173532f, 0.03253905f, 
    0.01693493f, 0.03642147f, -0.04634961f, -0.01202765f, -0.04355660f, -0.00371122f, -0.03310809f, -0.03015175f, 
    0.01816614f, -0.00472632f, 0.03715092f, -0.01405785f, -0.02184435f, -0.01383446f, 0.04143319f, -0.04629039f, 
    -0.03875799f, 0.02706258f, 0.02438360f, -0.00486806f, 0.00542562f, -0.00349129f, -0.04751598f, -0.04810079f, 
    -0.00414127f, -0.02418435f, -0.02535002f, 0.02762729f, -0.02058104f, -0.05124475f, -0.04204455f, -0.04485433f, 
    0.00613679f, -0.00754427f, 0.02853757f, 0.04273934f, -0.03585442f, -0.01309893f, -0.00111815f, 0.01775808f, 
    -0.01558028f, 0.00135275f, 0.03096886f, -0.04829262f, -0.02533286f, -0.00453887f, -0.01237172f, -0.02065773f, 
    0.01985982f, -0.04642689f, 0.00786187f, -0.05497849f, -0.01226786f, 0.01989188f, 0.00044162f, -0.05254618f, 
    0.01137026f, 0.02249778f, -0.02784393f, 0.02028448f, -0.03251316f, 0.00058731f, 0.00757682f, 0.02309781f, 
    0.02864093f, 0.05799781f, -0.00064062f, -0.01726412f, 0.03008722f, -0.02451592f, -0.02237369f, -0.04460941f, 
    -0.03616309f, 0.00639981f, 0.04598463f, 0.00284877f, -0.02788895f, 0.03336475f, -0.02295413f, -0.03515213f, 
    0.02566051f, 0.03727159f, -0.05211780f, 0.03639142f, 0.03044061f, -0.03551738f, -0.00305736f, 0.02807519f, 
    0.00708458f, -0.02393024f, -0.03656286f, -0.03516668f, -0.03614654f, 0.03650818f, -0.02301349f, -0.00070266f, 
    -0.02591076f, -0.03487284f, -0.03487395f, -0.04127496f, 0.03458274f, -0.01987134f, -0.01654065f, -0.03472686f, 
    -0.00983294f, -0.03084409f, -0.00563499f, -0.00029954f, -0.05704812f, -0.00346064f, -0.00802556f, 0.03896182f, 
    -0.00384263f, -0.01926017f, 0.03779783f, -0.02340657f, -0.03904093f, -0.00776033f, 0.01452814f, -0.01905723f, 
    0.03469139f, -0.05339681f, -0.02559995f, -0.05621034f, 0.02096367f, -0.01378744f, -0.03166261f, -0.01942084f, 
    -0.03110114f, -0.05522452f, -0.03219496f, 0.01295129f, -0.02805740f, -0.01795910f, -0.00292459f, 0.03912950f, 
    0.14706701f, -0.02913051f, 0.09450885f, 0.36961091f, 0.01691117f, -0.06634681f, -0.10221750f, -0.24954388f, 
    0.13920347f, 0.01531871f, -0.01917271f, 0.09713086f, 0.37192065f, -0.18968183f, 0.01979210f, -0.19257523f, 
    0.10226438f, 0.02442451f, 0.03370881f, -0.02262240f, 0.04458082f, 0.05349253f, -0.13389884f, -0.01802821f, 
    0.50231975f, -0.26790437f, 0.19166347f, -0.17050581f, 0.00212721f, -0.11954275f, -0.29044065f, -0.17347243f, 
    0.31128225f, 0.12072064f, 0.14164600f, 0.09469792f, -0.29684702f, 0.01372688f, -0.28127000f, 0.23741828f, 
    0.04273611f, 0.02432613f, -0.02631258f, 0.09164919f, -0.01396296f, -0.10604520f, 0.00054700f, -0.23780377f, 
    0.37075454f, -0.04222738f, -0.06866833f, 0.03083183f, 0.04032890f, -0.15460494f, 0.26925641f, 0.17646860f, 
    0.04693405f, -0.02355978f, -0.11347600f, -0.15950340f, -0.15986823f, -0.17278482f, 0.01350280f, -0.04690432f, 
    0.02458838f, 0.06854920f, -0.01049221f, 0.00907943f, 0.07629170f, 0.05291737f, -0.04090128f, 0.23161504f, 
    0.21748519f, 0.22205320f, 0.04181344f, -0.23003004f, -0.03463849f, -0.08109945f, -0.10229322f, -0.02727225f, 
    0.19629629f, 0.10644629f, 0.17047881f, 0.21635146f, -0.06421348f, 0.07291296f, 0.12899813f, 0.17281274f, 
    0.18299402f, -0.03914548f, 0.20493053f, 0.06488730f, -0.08528519f, -0.04950896f, -0.14818875f, -0.17850658f, 
    0.14227359f, 0.05650223f, 0.10130242f, 0.09581759f, 0.01788467f, 0.15419370f, 0.04734785f, 0.12808239f, 
    0.03944050f, 0.00298491f, 0.09126907f, 0.01247430f, 0.06064547f, -0.10024369f, -0.09644559f, 0.20888083f, 
    0.23131971f, 0.08394283f, -0.02943878f, -0.22404164f, 0.13024761f, 0.06152937f, -0.13391525f, 0.29317316f, 
    -0.25459895f, 0.18961073f, -0.19545466f, 0.15656380f, 0.10880011f, 0.02052327f, 0.08019941f, 0.08892965f, 
    0.11512338f, -0.10089803f, -0.01220249f, 0.01079707f, 0.03745565f, -0.02957030f, -0.02175230f, 0.10102346f, 
    -0.04300860f, -0.15513466f, -0.11475515f, -0.11516560f, 0.11176905f, 0.05413502f, 0.09735113f, 0.23268430f, 
    -0.04701046f, 0.00877176f, -0.13893506f, 0.21611454f, 0.01814516f, -0.15259723f, -0.20949011f, -0.08466738f, 
    0.00901512f, -0.20728120f, -0.08004463f, 0.03483402f, -0.12510285f, 0.01133143f, -0.14650683f, -0.04656722f, 
    -0.00863528f, -0.04358763f, -0.04415623f, -0.18087889f, -0.09140614f, -0.05074028f, -0.18838553f, -0.12627646f, 
    0.37342197f, 0.14599274f, 0.06748142f, 0.30448556f, -0.01395229f, -0.04503858f, -0.08664456f, -0.19894543f, 
    0.12839429f, 0.01926642f, -0.17239048f, -0.04068803f, -0.21254817f, -0.03670847f, 0.03227760f, -0.02523788f, 
    0.13640343f, 0.16219437f, -0.03568300f, 0.00179522f, -0.06582312f, -0.15147237f, -0.01592007f, -0.16344965f, 
    0.07759079f, 0.05228264f, 0.07303908f, -0.16214152f, 0.15960729f, 0.03918749f, 0.00622334f, -0.05250263f, 
    -0.09223593f, -0.01673133f, -0.05420936f, -0.08740582f, -0.32808447f, 0.25207961f, -0.23411089f, 0.20777683f, 
    0.07646660f, -0.07379092f, 0.09271217f, 0.12395778f, 0.27273601f, -0.11678416f, -0.06757607f, -0.04947534f, 
    -0.01814900f, 0.19496226f, 0.27962682f, -0.27106851f, -0.11713001f, -0.09845487f, -0.19504465f, -0.26074669f, 
    0.12536436f, 0.06567141f, 0.01749604f, 0.24516211f, -0.01177267f, 0.01632669f, -0.15127796f, 0.08763183f, 
    0.14818802f, -0.00383428f, -0.01358073f, 0.04268809f, -0.16018727f, -0.12976772f, -0.14422613f, 0.01918058f, 
    0.05072222f, -0.08669306f, -0.05666611f, 0.05605847f, -0.06031728f, -0.08765983f, -0.02209863f, -0.01883996f, 
    0.04479134f, -0.02705430f, 0.06248713f, 0.11889143f, 0.03027306f, -0.06922700f, 0.06268168f, -0.21196789f, 
    0.09146956f, 0.05052460f, 0.04153937f, 0.06630049f, 0.04643866f, -0.00055069f, 0.21195289f, 0.09137972f, 
    0.09261325f, 0.03810956f, 0.11400643f, 0.11108829f, 0.12958796f, -0.09740601f, 0.05623099f, -0.07682711f, 
    0.05567744f, -0.08226961f, 0.06230032f, -0.06446488f, 0.08529374f, 0.31106743f, -0.03855690f, -0.02347613f, 
    0.06994095f, 0.01121504f, -0.06628897f, 0.18710110f, 0.07089171f, -0.04551894f, -0.06024788f, 0.06036230f, 
    0.12084504f, 0.02586301f, -0.12084656f, 0.13893755f, -0.13223763f, -0.13638389f, -0.07610788f, -0.18303227f, 
    0.12529853f, -0.06796548f, 0.12948802f, 0.21400256f, -0.45305073f, 0.02544337f, -0.22101986f, -0.22093561f, 
    0.09719603f, 0.02561239f, -0.07798219f, -0.26106235f, -0.12707944f, 0.05943676f, -0.11760724f, 0.11036406f, 
    0.31878138f, -0.14960137f, 0.07414845f, -0.14462240f, 0.07929492f, 0.07610690f, -0.10662751f, 0.07560582f, 
    -0.12122175f, -0.12151343f, -0.02170330f, -0.17063443f, 0.07040471f, 0.23885706f, -0.12627244f, -0.06547875f, 
    0.08211216f, 0.01426208f, 0.16758510f, 0.06406964f, -0.01196942f, 0.00378809f, -0.01511880f, -0.04175718f, 
    -0.08738817f, 0.05670643f, 0.10658204f, -0.10966054f, -0.06891230f, 0.08271483f, 0.00850611f, 0.10538381f, 
    0.01897720f, 0.02979396f, 0.11944941f, 0.08779402f, 0.26808113f, -0.04953131f, 0.09950216f, 0.15783733f, 
    -0.01184906f, -0.12360637f, -0.10290912f, -0.04996936f, 0.02220627f, 0.13626975f, -0.01569580f, 0.14510374f, 
    0.16378094f, 0.05836216f, -0.07871552f, -0.03449304f, 0.09052716f, -0.13981648f, -0.02323667f, 0.10238092f, 
    0.00380163f, 0.03561249f, -0.00453380f, 0.10664718f, -0.16979516f, -0.39957762f, 0.16702722f, -0.23480771f, 
    0.00940776f, 0.13167721f, -0.10494038f, -0.04663860f, 0.12954867f, -0.03591337f, -0.00617074f, 0.14839821f, 
    0.33307925f, -0.06881957f, -0.07368983f, 0.00726494f, -0.03100317f, 0.09633566f, 0.09093590f, 0.14602025f, 
    0.01620877f, -0.00271387f, 0.05859099f, 0.14913806f, 0.10869797f, 0.33934626f, -0.22231558f, 0.06731714f, 
    -0.00105941f, 0.11149450f, 0.10031700f, 0.00692625f, -0.02800670f, 0.05002343f, -0.01772073f, -0.02899102f, 
    -0.79311991f, 0.16510375f, 0.17645235f, 0.06670890f, -0.06599217f, 0.20560862f, 0.08317211f, 0.10155269f, 
    0.04658272f, -0.12684804f, 0.07672542f, 0.11636052f, -0.55399251f, 0.21871385f, 0.15242912f, 0.40506661f, 
    0.16136548f, -0.00054829f, -0.29827619f, 0.21563998f, 0.00235482f, -0.00805475f, 0.08549225f, -0.06937235f, 
    0.33278239f, 0.19280557f, -0.04014386f, -0.00270240f, -0.18320411f, -0.14375141f, 0.13538212f, -0.01625289f, 
    -0.07558615f, -0.02321876f, -0.06006850f, 0.00955953f, 0.39979360f, -0.06516888f, -0.11281376f, -0.06985563f, 
    0.11297098f, 0.19629031f, 0.15427075f, 0.04472245f, -0.13129298f, -0.16951245f, 0.08364180f, -0.01923689f, 
    0.03383572f, -0.21850887f, -0.14714268f, 0.35143587f, 0.00187490f, 0.07565111f, 0.08361597f, 0.02256978f, 
    -0.06203856f, 0.05393330f, 0.00729913f, 0.02332541f, -0.10204790f, -0.11035088f, -0.11015916f, 0.15282652f, 
    0.06864052f, 0.02187262f, 0.03186076f, 0.06035296f, -0.10489765f, 0.04349059f, 0.02232985f, 0.15333539f, 
    0.32567018f, -0.10857881f, -0.26920062f, -0.20717703f, 0.02693563f, 0.00269086f, -0.06344148f, 0.11025836f, 
    0.02617443f, -0.07180267f, -0.03052480f, -0.00213783f, 0.19485867f, -0.07133270f, -0.01694311f, -0.13656890f, 
    -0.08411368f, 0.05215348f, 0.16332856f, -0.08553864f, 0.05341214f, -0.00646119f, -0.01447113f, 0.02979909f, 
    -0.37090990f, 0.19135295f, 0.37990209f, 0.08049254f, 0.16230968f, -0.00012480f, -0.01141271f, -0.01091989f, 
    0.02848888f, -0.10196274f, -0.04911905f, -0.14469968f, -0.37156945f, 0.09740337f, -0.01032586f, -0.03512876f, 
    -0.05228199f, -0.09188855f, -0.14354329f, -0.16108721f, -0.04409856f, -0.03990278f, 0.09755683f, 0.06246279f, 
    -0.22571281f, 0.08213529f, -0.05975800f, -0.24487025f, -0.10960526f, 0.01100303f, -0.12958527f, -0.05830222f, 
    -0.13503571f, -0.08538504f, 0.07171617f, 0.07818783f, 0.25548714f, 0.12921856f, 0.00527734f, -0.07640103f, 
    -0.08027323f, 0.12124291f, -0.06702616f, 0.07018249f, 0.10340348f, 0.05125473f, -0.04448538f, 0.09516271f, 
    0.30162391f, -0.01841315f, -0.27563474f, 0.03193563f, 0.06424883f, 0.03502870f, 0.13335766f, 0.02985130f, 
    0.20464474f, 0.03872994f, 0.06786448f, -0.12680160f, 0.30959424f, 0.16409390f, 0.25177819f, 0.01333186f, 
    0.15135626f, -0.12026421f, -0.01345908f, 0.05733140f, -0.03457434f, 0.07500940f, -0.02799828f, -0.15984818f, 
    0.39514023f, -0.04233214f, -0.23586777f, -0.02633507f, 0.01014078f, 0.15795945f, -0.08382918f, 0.12287682f, 
    -0.07665688f, -0.08813722f, 0.01222375f, 0.08644257f, -0.49132690f, 0.15389936f, 0.36843714f, 0.06891112f, 
    0.04469864f, -0.05210227f, -0.12603435f, 0.18637183f, -0.08107354f, -0.03059078f, 0.01688549f, -0.06008701f, 
    -0.72876871f, 0.03026528f, 0.05289981f, 0.44322082f, 0.01504925f, 0.12003396f, 0.12816441f, 0.15836717f, 
    -0.19731185f, 0.01176094f, 0.00155129f, 0.13528600f, -0.20334646f, 0.07267995f, 0.08958881f, -0.04697519f, 
    -0.00710573f, -0.05013561f, -0.01857906f, -0.06427532f, -0.07834274f, -0.00986264f, 0.11069961f, 0.09115802f, 
    0.27468815f, 0.06754250f, -0.02838371f, 0.29344058f, -0.05799450f, 0.02789343f, 0.06002673f, 0.00817340f, 
    0.04345580f, 0.14329576f, 0.03634842f, -0.05269348f, -0.03869199f, -0.16969781f, -0.13211489f, -0.01562677f, 
    0.04654856f, -0.04853329f, 0.20176554f, 0.11032835f, 0.03355402f, -0.14809187f, -0.01989644f, -0.00430714f, 
    -0.05240973f, 0.24130365f, -0.16878939f, -0.10267124f, -0.10472754f, -0.08578092f, -0.01433650f, -0.01674970f, 
    0.04080879f, 0.09612087f, 0.09805868f, 0.12280934f, -0.26121214f, -0.11272930f, 0.15412846f, 0.22169960f, 
    0.14544497f, 0.24816225f, 0.06619470f, 0.00901051f, 0.09268109f, -0.06290415f, -0.09538221f, -0.00800321f, 
    0.68825066f, -0.23520267f, 0.03322376f, 0.26377925f, -0.09007856f, 0.09229258f, 0.11658046f, 0.15367542f, 
    -0.06680070f, -0.01814020f, -0.02216619f, 0.01685604f, -0.17416263f, 0.10234630f, 0.02870083f, 0.05885159f, 
    0.08390348f, 0.13932650f, 0.08443335f, -0.14249536f, -0.02250192f, -0.02233922f, -0.00351824f, 0.00011374f, 
    0.30755606f, -0.11686312f, -0.14721505f, -0.06252269f, 0.00259008f, -0.06330700f, 0.01683738f, -0.03415306f, 
    0.08284068f, -0.09286395f, -0.07224128f, -0.16336387f, -0.03624370f, -0.23630626f, -0.24277930f, 0.18737821f, 
    0.21315575f, 0.05772059f, 0.02734934f, 0.00153656f, 0.02501928f, 0.13409868f, -0.00827238f, -0.09400633f, 
    0.01860275f, -0.01114581f, -0.08728474f, -0.08114057f, 0.02947848f, -0.06234295f, -0.05760913f, 0.06554199f, 
    0.08349089f, -0.03671532f, -0.02018092f, -0.08716925f, 0.15636970f, 0.18967459f, -0.03844313f, 0.02126353f, 
    -0.07558746f, -0.11599818f, 0.08500066f, -0.05055537f, 0.03094047f, 0.19026418f, 0.11288048f, 0.14816079f, 
    0.33367556f, 0.28883633f, 0.00582471f, -0.10771699f, 0.07933100f, 0.05251411f, -0.06060913f, 0.01193611f, 
    -0.01724876f, 0.20369838f, -0.18590279f, -0.02400952f, -0.00561330f, 0.04557753f, 0.13290863f, -0.21259797f, 
    -0.05698046f, 0.16880842f, -0.00083214f, -0.07579994f, -0.04715930f, -0.01968201f, -0.00840536f, 0.12423426f, 
    0.16859651f, 0.24787802f, 0.11586276f, -0.02715078f, -0.02775168f, 0.08341924f, 0.08485390f, -0.05309258f, 
    0.07361007f, 0.03991579f, -0.01737800f, 0.01500850f, 0.07658804f, 0.24100617f, -0.05219105f, -0.13080581f, 
    0.15833715f, 0.10838658f, 0.06004491f, 0.08123486f, 0.17255498f, 0.07883597f, 0.14777777f, -0.12576127f, 
    -0.28255326f, 0.20914127f, 0.13353646f, -0.15278469f, 0.05100303f, -0.04862202f, 0.00744893f, -0.03849052f, 
    0.30353448f, 0.11904032f, 0.04774664f, -0.02179310f, 0.12098209f, -0.13282037f, -0.05553882f, -0.08674037f, 
    -0.08670351f, -0.00761125f, -0.11156070f, -0.01526432f, 0.00225152f, -0.07314336f, 0.01876229f, 0.15274987f, 
    0.48974752f, 0.18485683f, -0.40430447f, 0.22020218f, -0.10556663f, -0.09310365f, 0.06678040f, 0.02543269f, 
    -0.01278253f, -0.00577912f, -0.00536832f, -0.05718817f, 0.12264778f, 0.01821356f, -0.13595273f, -0.00793882f, 
    0.04875278f, -0.01837620f, 0.06452572f, 0.08631152f, 0.01101011f, -0.03711057f, 0.04485690f, -0.05549907f, 
    0.03734883f, 0.04483638f, -0.08424819f, 0.16741490f, 0.05778993f, 0.11424857f, 0.14158861f, -0.02329675f, 
    0.06089759f, 0.00962440f, -0.16595517f, -0.12653708f, 0.11391148f, 0.01874811f, 0.09304922f, 0.18107155f, 
    -0.10132634f, 0.13080353f, -0.16721338f, -0.12815705f, 0.13918798f, 0.05442284f, 0.18892598f, 0.13102128f, 
    0.16229433f, 0.12056345f, 0.04906450f, -0.05720599f, 0.13668348f, -0.04834658f, -0.02773039f, 0.07017648f, 
    -0.09483807f, 0.02337349f, -0.00443598f, 0.00897163f, 0.01800221f, -0.20593144f, -0.04878955f, -0.03166215f, 
    0.26404977f, -0.29688337f, 0.01621923f, -0.05801383f, -0.11552414f, 0.00898976f, 0.09653088f, 0.26425326f, 
    -0.23901173f, -0.21563114f, 0.37014744f, 0.01658980f, 0.02620986f, 0.19274950f, -0.04985896f, 0.13069926f, 
    -0.07199598f, 0.02914200f, -0.00468858f, -0.04955838f, -0.14327139f, -0.11042079f, 0.04092985f, 0.00917051f, 
    0.00669719f, -0.06429144f, -0.06600832f, -0.00655864f, 0.11044302f, -0.22124967f, -0.15863866f, -0.08761729f, 
    -0.19261527f, -0.10501242f, -0.09267157f, -0.03147990f, -0.11118111f, -0.11164659f, -0.08101667f, -0.06901780f, 
    -0.05467264f, 0.05434738f, 0.14970735f, 0.17118150f, 0.12193982f, -0.04347487f, 0.03613914f, -0.06035389f, 
    0.01411561f, -0.05546185f, -0.01117125f, 0.07324530f, 0.04869627f, 0.00329611f, 0.14426735f, 0.01311973f, 
    -0.47417021f, -0.12890664f, 0.03097177f, 0.09136527f, 0.03892051f, 0.07429132f, 0.11088089f, 0.04284185f, 
    0.04494072f, 0.02314170f, 0.04684564f, 0.11572783f, -0.04331902f, -0.03405106f, -0.33284834f, -0.13301468f, 
    -0.05464739f, 0.01128983f, -0.12833045f, -0.27314296f, 0.03508658f, 0.04840802f, 0.06059806f, 0.11844206f, 
    -0.02811456f, 0.14904359f, -0.15039252f, -0.22454002f, 0.12102974f, 0.21693590f, 0.34780142f, 0.04728939f, 
    0.11283356f, 0.07666457f, 0.20069924f, 0.28531206f, -0.25169519f, -0.16263384f, 0.17353255f, 0.17495571f, 
    -0.03591292f, 0.15346406f, -0.06089113f, -0.22701828f, -0.09129545f, -0.00906114f, -0.03899052f, -0.04863400f, 
    -0.03242931f, -0.02578123f, -0.10098499f, 0.25955504f, 0.13968742f, 0.11032565f, -0.06799173f, -0.00919886f, 
    0.16111766f, -0.12650210f, 0.02089600f, 0.02578307f, -0.13328555f, -0.06762833f, -0.01956701f, -0.03926268f, 
    -0.02537580f, -0.08531398f, -0.05568273f, 0.00818083f, -0.00238799f, -0.07836066f, 0.09503486f, 0.17895493f, 
    0.21039659f, 0.14910252f, 0.07871169f, 0.10957845f, -0.02775502f, 0.09318640f, 0.19075772f, 0.02103197f, 
    0.00214221f, 0.04377982f, -0.05359707f, -0.12185586f, 0.04964134f, -0.02321331f, -0.07092558f, 0.06982096f, 
    0.06667862f, -0.06322553f, -0.01083226f, -0.14962417f, 0.03923563f, -0.07309931f, -0.01177534f, -0.19199577f, 
    -0.04700929f, -0.20061244f, -0.13809517f, 0.00949753f, -0.10362109f, -0.02286779f, 0.08232436f, 0.06530727f, 
    -0.04965204f, -0.04138196f, -0.20957893f, 0.13104568f, -0.14358093f, -0.20568454f, 0.12360689f, -0.06565001f, 
    0.05739601f, 0.16083848f, 0.01108849f, 0.00612629f, 0.02768368f, -0.08675681f, 0.01406630f, 0.11147745f, 
    0.25246680f, 0.06693031f, 0.06162442f, 0.30221787f, 0.11458545f, 0.14061901f, -0.02037721f, 0.07722536f, 
    -0.02715740f, 0.09115999f, -0.03505915f, 0.08287361f, -0.13175656f, -0.05454302f, 0.11674412f, 0.11083232f, 
    0.11481528f, 0.04513557f, -0.00652532f, -0.07113777f, 0.00748369f, -0.05166715f, 0.03493837f, 0.08165285f, 
    -0.12067506f, -0.11322889f, -0.00257551f, -0.00098195f, -0.17839383f, 0.02275653f, 0.02943242f, -0.01367024f, 
    0.19520608f, 0.04109633f, 0.02355668f, -0.02948290f, 0.09346423f, 0.02969817f, -0.01036347f, 0.19468728f, 
    0.19122076f, 0.22658141f, -0.00448557f, -0.09601504f, 0.01852886f, 0.00671421f, 0.07891018f, 0.07407360f, 
    0.04358637f, 0.04423329f, 0.11465687f, -0.02427380f, -0.07016160f, -0.03795561f, -0.17228349f, -0.04176604f, 
    -0.16086057f, -0.22396308f, -0.13366677f, -0.21388431f, 0.15694100f, 0.30065736f, -0.03481210f, -0.16795324f, 
    0.07874578f, -0.04391551f, 0.07613864f, 0.16842489f, -0.08831694f, -0.03459229f, -0.11451401f, -0.11483648f, 
    0.22144245f, 0.30518588f, 0.19649816f, -0.06499168f, 0.04335372f, -0.09518369f, -0.11161182f, 0.30963680f, 
    0.05033848f, -0.08161067f, 0.01942087f, 0.04473558f, -0.22110669f, -0.08380511f, 0.18475708f, -0.05313747f, 
    0.16494790f, -0.12749925f, -0.05386463f, 0.09971830f, 0.07619578f, 0.07679760f, 0.08345421f, 0.05312332f, 
    0.00941071f, 0.04950112f, -0.02888742f, 0.01078631f, -0.00793689f, -0.02847581f, -0.00589393f, -0.01753870f, 
    0.00092253f, 0.04417943f, -0.03994406f, 0.01906323f, 0.01329846f, -0.05292510f, -0.03768312f, -0.03245920f, 
    0.02933420f, -0.03436199f, -0.02212872f, -0.00369529f, -0.00594097f, -0.01615229f, 0.01865742f, 0.00029343f, 
    0.02411798f, 0.03427766f, -0.00003121f, -0.01444056f, 0.02052178f, -0.02642339f, -0.05224726f, -0.00721364f, 
    -0.00965812f, -0.04410369f, -0.05154833f, -0.00814388f, 0.03313369f, -0.00688544f, -0.00081691f, -0.03759478f, 
    0.00103138f, -0.00117423f, 0.03401789f, -0.05713299f, 0.02731162f, -0.02527483f, 0.00645908f, 0.03664916f, 
    -0.04390170f, -0.03073854f, 0.04275871f, -0.03328916f, 0.02692394f, -0.04397696f, 0.03469890f, 0.03484730f, 
    0.04239189f, -0.03713222f, 0.02331860f, -0.05647257f, -0.03228018f, 0.04267112f, 0.02244802f, 0.01810145f, 
    0.01280342f, 0.01101627f, 0.04149892f, -0.04002842f, -0.01783064f, 0.00627517f, -0.03654323f, -0.02904887f, 
    -0.01374324f, 0.02687108f, -0.04195125f, -0.02772909f, -0.00748665f, -0.00711688f, -0.00462263f, 0.00195297f, 
    0.02189477f, 0.01728436f, 0.03925320f, 0.00455110f, 0.04881451f, -0.00296043f, -0.02442038f, -0.01587949f, 
    0.03923714f, -0.02903322f, -0.04861900f, -0.03488563f, -0.00783754f, 0.03048489f, -0.02106677f, 0.00142144f, 
    0.03443226f, 0.03256459f, 0.03455071f, 0.01913214f, 0.04004670f, 0.00248412f, -0.01588434f, 0.02476478f, 
    -0.03616707f, -0.05165466f, -0.04499675f, -0.03117986f, 0.03511256f, -0.04439479f, 0.04209887f, 0.01224920f, 
    -0.04770441f, -0.04253728f, 0.03295457f, -0.02308480f, 0.00813785f, -0.00722177f, -0.00954840f, -0.01630305f, 
    -0.05402608f, -0.01793697f, -0.00876648f, -0.00595206f, -0.02762492f, -0.04993794f, 0.02901998f, -0.01262459f, 
    -0.00286272f, 0.03099711f, -0.04919501f, 0.04019821f, -0.01223429f, -0.00231401f, 0.00490165f, 0.02184788f, 
    -0.04073872f, -0.04160354f, -0.04205470f, -0.04302148f, 0.01209189f, -0.04458715f, -0.02908200f, -0.03659873f, 
    -0.02802242f, -0.05605157f, -0.03780822f, 0.04054329f, -0.04758340f, -0.03119832f, 0.03483597f, 0.00882729f, 
    -0.03547554f, -0.03124472f, -0.03156617f, 0.01521454f, 0.00406310f, 0.03405250f, 0.01709489f, -0.02941325f, 
    0.04100803f, -0.04059400f, 0.02296770f, -0.04494929f, -0.01807826f, 0.00878656f, 0.03227090f, -0.02061075f, 
    0.00679441f, 0.04046498f, -0.04049345f, -0.00085127f, -0.02589214f, -0.01114988f, 0.03726679f, 0.03092165f, 
    -0.01167726f, -0.03009888f, -0.02456416f, -0.04958048f, -0.03572259f, -0.04517012f, 0.03808207f, 0.02960947f, 
    0.02560211f, -0.00414101f, -0.01695350f, 0.01978804f, -0.00142630f, 0.04030281f, -0.01472935f, -0.04999536f, 
    0.02170437f, -0.03912872f, -0.00290992f, -0.03444572f, 0.03087429f, -0.02502838f, 0.00430341f, -0.02975099f, 
    -0.04410233f, 0.03237060f, -0.03428395f, -0.05201308f, -0.02184272f, -0.02024055f, -0.05204603f, -0.01980466f, 
    -0.03254585f, 0.01470780f, 0.00371410f, 0.04104256f, 0.00090222f, -0.05195068f, 0.04263018f, -0.05162459f, 
    -0.01884550f, 0.02684465f, 0.03188789f, -0.05019974f, 0.01520773f, 0.00421076f, 0.04274920f, 0.04251180f, 
    -0.04751861f, 0.03746829f, -0.03732962f, 0.01558425f, 0.01674168f, -0.05714848f, 0.02326436f, 0.01885344f, 
    -0.00588534f, -0.01533710f, -0.05389911f, 0.02566811f, -0.02258386f, 0.02996395f, -0.03791783f, 0.02681574f, 
    0.01727545f, -0.00922534f, -0.04377211f, 0.02406009f, 0.00300267f, 0.00859435f, -0.01784467f, 0.02213221f, 
    0.02134665f, -0.02195761f, -0.01125541f, -0.04856044f, 0.04728432f, -0.03990542f, -0.01382827f, 0.02826191f, 
    -0.03736723f, -0.02080522f, -0.04926555f, -0.03413626f, 0.00235521f, -0.03787117f, 0.01762511f, -0.02315006f, 
    0.00233551f, -0.04361214f, -0.00487975f, 0.04270845f, 0.02497315f, -0.00703926f, -0.05585289f, 0.03474956f, 
    -0.02684271f, 0.03249332f, 0.04295113f, -0.04913928f, -0.04766585f, -0.02626545f, 0.03768168f, 0.03758753f, 
    -0.04539666f, -0.00337739f, -0.05079556f, 0.03565390f, -0.05257973f, -0.05248949f, 0.00382694f, 0.02634830f, 
    -0.02736126f, 0.04499916f, -0.04482103f, -0.04605770f, -0.05361613f, -0.00813749f, -0.04222532f, -0.03800736f, 
    -0.03336102f, -0.04582659f, -0.03987931f, 0.00530372f, -0.00011378f, 0.02509013f, 0.03923147f, 0.02008567f, 
    -0.02383656f, 0.01659280f, -0.04248546f, -0.01108551f, -0.04810159f, -0.02288189f, -0.02238375f, 0.02413497f, 
    -0.02676816f, -0.04254133f, -0.04910480f, -0.04141499f, -0.04700445f, -0.04478325f, -0.04398360f, -0.04794104f, 
    -0.03819345f, -0.05733426f, -0.01616471f, 0.00747618f, -0.01750858f, 0.04294942f, -0.04470909f, 0.00121464f, 
    0.03957105f, 0.04050405f, 0.01641174f, 0.03820997f, -0.02109184f, -0.04801547f, -0.00484224f, 0.03171728f, 
    0.02874686f, -0.03364475f, 0.01169477f, 0.01237309f, -0.05593138f, -0.00172568f, 0.02117039f, -0.03899228f, 
    -0.02247265f, -0.05468306f, -0.01755697f, -0.04439489f, -0.02777840f, -0.01964204f, -0.03470318f, -0.03523684f, 
    -0.01143981f, 0.02176372f, -0.05027076f, -0.03895873f, -0.03816992f, 0.00845500f, -0.04293031f, 0.04252852f, 
    0.01142327f, 0.03135026f, 0.00495192f, 0.02350601f, -0.04692193f, 0.03022017f, 0.01173463f, 0.01494472f, 
    0.00242024f, 0.04108915f, 0.00033645f, -0.02864199f, -0.03618971f, 0.01072647f, 0.01555126f, 0.02589914f, 
    -0.03774676f, 0.04023515f, -0.03948165f, -0.01617395f, -0.04364915f, -0.02998808f, 0.04140484f, 0.04147624f, 
    0.03878153f, -0.03031465f, 0.04549845f, 0.00756764f, -0.04091570f, 0.02830603f, 0.01083244f, -0.00223148f, 
    -0.00965652f, 0.01781562f, -0.01850344f, 0.00392511f, -0.01315279f, 0.03723301f, -0.03942887f, -0.03463549f, 
    -0.00675136f, 0.00511360f, -0.01690667f, 0.02156829f, 0.03957614f, 0.02448490f, 0.00132989f, 0.03873522f, 
    0.00516224f, 0.01128740f, -0.01687964f, 0.00153378f, -0.05069000f, -0.00349142f, -0.03175323f, 0.00862368f, 
    -0.02275272f, 0.04076863f, 0.02061145f, 0.00955195f, -0.02180408f, -0.00972333f, 0.01580432f, 0.02012054f, 
    -0.01707370f, 0.03560929f, -0.04679319f, 0.03292156f, 0.01070185f, 0.00227607f, -0.01219069f, -0.05108257f, 
    -0.02029608f, 0.01982679f, -0.05261352f, -0.03275782f, 0.02551503f, -0.04695308f, -0.00521801f, -0.01992002f, 
    -0.05843842f, -0.04938613f, -0.01683299f, 0.00659734f, -0.00660276f, -0.05452741f, -0.03713274f, -0.01349036f, 
    -0.03168322f, -0.03939174f, -0.04148155f, -0.03874870f, -0.05079690f, -0.02259152f, -0.03827899f, 0.02563433f, 
    0.02886221f, -0.04534419f, -0.03843425f, 0.03374895f, -0.01391623f, -0.05671139f, 0.02151157f, 0.00752840f, 
    0.02791736f, 0.03164892f, -0.01484893f, -0.04007039f, 0.04776090f, 0.03566162f, 0.02662200f, 0.04401408f, 
    -0.00342166f, 0.01768470f, -0.00965667f, -0.02096829f, -0.02966784f, 0.02764443f, 0.04065419f, 0.01583763f, 
    -0.00457540f, -0.01790795f, -0.03221513f, -0.02852141f, -0.02500188f, 0.02213386f, -0.04655878f, -0.03024358f, 
    0.00356542f, 0.01339569f, 0.02843674f, -0.04009243f, -0.01895785f, -0.03423133f, -0.02609414f, -0.04183027f, 
    0.04431766f, -0.02979802f, -0.00395092f, 0.00381291f, 0.03854461f, -0.01591123f, -0.04190498f, 0.03760224f, 
    -0.04479347f, -0.03811225f, -0.02840756f, -0.03056016f, -0.00335462f, 0.03753870f, -0.00508313f, -0.01382614f, 
    0.02732923f, 0.03744995f, 0.00852556f, -0.00102605f, 0.01820581f, -0.04135656f, -0.02554576f, -0.04845562f, 
    -0.02271939f, -0.04658914f, -0.02403046f, 0.03505820f, -0.04816461f, -0.05026590f, -0.01664009f, 0.02371937f, 
    0.03763057f, -0.00948969f, -0.02651139f, 0.03417877f, -0.03097044f, 0.00483704f, -0.00693195f, -0.02246851f, 
    -0.05031707f, 0.02888612f, 0.01124548f, -0.00724148f, -0.03766100f, -0.01331525f, 0.00013857f, -0.04104978f, 
    -0.04870715f, -0.02510593f, 0.04587290f, 0.00383017f, -0.01142919f, 0.01506570f, -0.02991950f, -0.04275895f, 
    -0.01272217f, -0.03123551f, -0.01360276f, 0.02186036f, 0.00883101f, -0.04175960f, -0.04987563f, 0.00606834f, 
    0.00888112f, -0.03474124f, -0.04276602f, 0.02105992f, -0.02312265f, -0.01885424f, 0.02770207f, 0.00306877f, 
    0.00268866f, -0.00666781f, -0.03822885f, -0.05743945f, 0.01421643f, 0.02782335f, -0.00844269f, 0.03849735f, 
    -0.03447257f, 0.02717963f, -0.03892893f, 0.01862545f, -0.00032196f, 0.01651579f, 0.01596972f, 0.02898316f, 
    -0.01450420f, -0.04191668f, -0.01162217f, -0.02024978f, -0.05823543f, 0.00894736f, 0.00918961f, -0.05123317f, 
    -0.00782791f, -0.04204449f, -0.03108888f, -0.01674598f, 0.01266184f, 0.03573689f, -0.04322091f, -0.03354932f, 
    -0.04667643f, 0.01870928f, -0.02495332f, -0.01161402f, -0.01593439f, 0.04446424f, 0.04072125f, 0.00636193f, 
    0.00145024f, -0.01261193f, 0.00011657f, -0.04066319f, 0.00226262f, 0.03488043f, -0.05371641f, 0.01875306f, 
    0.02488451f, 0.02665747f, 0.01567125f, -0.01813230f, 0.02689853f, 0.01296177f, -0.03499620f, 0.00185598f, 
    -0.01688967f, 0.03142582f, -0.00648150f, 0.02113517f, -0.05591558f, 0.01678369f, 0.00046400f, -0.02284274f, 
    -0.01640175f, 0.01980562f, -0.01056195f, -0.02718233f, -0.00955903f, -0.02496275f, -0.01586801f, 0.00162885f, 
    -0.04281390f, 0.00968689f, 0.04872518f, 0.01268247f, 0.03121549f, 0.03001153f, -0.01630170f, 0.02168832f, 
    -0.00578003f, -0.02894923f, 0.00414095f, -0.05071814f, -0.04449712f, -0.02046949f, -0.03475496f, -0.04262552f, 
    0.04111180f, -0.02223842f, 0.01409539f, 0.01307057f, 0.03972318f, -0.03232037f, -0.04069780f, 0.02580262f, 
    0.02291846f, 0.04540366f, 0.00015113f, -0.03643334f, -0.05229077f, 0.00302343f, -0.00452202f, 0.01190685f, 
    0.01560459f, 0.01324814f, 0.00843305f, -0.02746436f, -0.05634629f, -0.02155483f, 0.00523172f, -0.02076056f, 
    -0.02939549f, 0.03443555f, 0.01320326f, 0.03424242f, -0.03896795f, 0.03675849f, 0.02235193f, -0.02576627f, 
    0.00875079f, -0.05320588f, -0.02819043f, 0.02447686f, 0.04430130f, 0.03649332f, 0.02252095f, -0.00338024f, 
    0.01749300f, 0.04533949f, 0.04237633f, -0.04213612f, -0.03462431f, -0.01497847f, -0.04292824f, -0.03538843f, 
    -0.01298381f, 0.02475584f, -0.01697533f, 0.02532147f, -0.03111603f, -0.02443384f, -0.04099787f, -0.02079019f, 
    -0.01365430f, -0.02533662f, 0.03354675f, -0.00225647f, -0.01171423f, 0.00350867f, -0.04191225f, -0.02266773f, 
    -0.02913484f, -0.00892656f, 0.00516448f, -0.04500112f, 0.01196008f, 0.02509684f, 0.00190981f, 0.02055994f, 
    0.02904677f, 0.03074491f, -0.04116202f, -0.00181965f, -0.02982602f, -0.02236334f, -0.03566896f, -0.04683399f, 
    -0.03640030f, -0.01732382f, -0.02553230f, -0.03447024f, -0.03616889f, 0.00682012f, 0.02708900f, -0.05164241f, 
    -0.03523204f, -0.03703037f, -0.03201668f, 0.00952343f, -0.05127738f, 0.01056997f, -0.05189998f, 0.02063020f, 
    -0.04352502f, -0.04683330f, -0.06129034f, -0.03901173f, -0.04030234f, 0.02426102f, 0.02103331f, -0.00089527f, 
    0.04727037f, 0.02514732f, 0.01554669f, 0.02975708f, -0.03803531f, -0.05367559f, -0.03352637f, 0.04157255f, 
    0.02015042f, 0.02641833f, -0.01818330f, -0.01775675f, 0.03454890f, -0.00445490f, -0.01912765f, -0.01637041f, 
    0.03058469f, -0.00187570f, 0.01115568f, -0.04207332f, -0.03677183f, 0.03139278f, -0.03375340f, -0.00841942f, 
    -0.01631804f, 0.03029155f, -0.02846589f, -0.03594632f, -0.04453307f, -0.00714541f, 0.00219092f, -0.05486465f, 
    -0.01852850f, 0.02202245f, -0.05112911f, -0.02095277f, -0.02297045f, 0.03265418f, 0.03962828f, 0.03976368f, 
    0.00752157f, 0.00718506f, -0.05668152f, 0.04156134f, 0.02316978f, 0.01475269f, -0.02095130f, -0.05629856f, 
    -0.02146090f, 0.01295671f, -0.00135531f, -0.04479616f, 0.02671144f, -0.02209686f, 0.02757984f, 0.00233579f, 
    -0.02136784f, 0.01904486f, 0.00943601f, -0.00708070f, 0.03976034f, -0.01132562f, 0.00256028f, -0.02105303f, 
    -0.01546938f, -0.01201578f, 0.01942164f, -0.04043956f, 0.02493075f, 0.01630627f, -0.04525564f, 0.04304227f, 
    0.01553036f, -0.04298053f, -0.02741917f, -0.02141857f, 0.03091324f, -0.01526402f, -0.04002943f, -0.00490655f, 
    -0.02563819f, 0.01667797f, -0.04196896f, 0.00988981f, -0.02023693f, 0.00531031f, 0.03584483f, 0.03143188f, 
    0.02609384f, 0.02094795f, 0.02218780f, 0.01726813f, 0.02235715f, -0.00305025f, -0.02116455f, 0.02347057f, 
    -0.03236551f, 0.04078377f, -0.00584338f, -0.04511091f, -0.05068929f, -0.03929728f, -0.04039183f, 0.00579263f, 
    -0.02126526f, -0.01407532f, 0.00457754f, -0.01601825f, 0.03971779f, 0.04561047f, -0.01443802f, -0.04977536f, 
    -0.02150518f, -0.02827361f, -0.04301583f, -0.02357156f, 0.01293468f, 0.01359492f, -0.03669358f, -0.02757963f, 
    -0.01802528f, -0.00870313f, -0.02125438f, 0.00452704f, -0.03104672f, 0.01672934f, 0.03703257f, 0.03204941f, 
    -0.02802510f, -0.05652700f, 0.04330553f, -0.04178127f, -0.04408089f, -0.04176956f, 0.03141864f, -0.01082635f, 
    -0.03367435f, -0.00831101f, -0.03803614f, -0.04592853f, -0.01541116f, 0.03779306f, 0.01230024f, 0.01487190f, 
    0.02514671f, 0.00700327f, -0.02588802f, 0.02402199f, 0.00230809f, -0.02388957f, -0.03212790f, 0.02974223f, 
    0.01075640f, -0.04876804f, -0.05194902f, -0.00737229f, -0.01476337f, -0.01515672f, -0.02716559f, 0.02303092f, 
    -0.03612816f, 0.03766460f, 0.01696697f, -0.00039988f, 0.00379662f, -0.05331146f, -0.03250846f, -0.00884153f, 
    -0.03429660f, 0.01993639f, -0.04760438f, 0.00160957f, -0.01314654f, 0.00154932f, 0.03329223f, -0.02252619f, 
    -0.04082000f, -0.03257290f, -0.01537893f, -0.03528165f, -0.04661789f, 0.03697678f, 0.04167612f, 0.03019148f, 
    -0.00452971f, -0.02069144f, 0.03905468f, -0.03097735f, -0.04310237f, -0.03529670f, 0.02914042f, -0.04900646f, 
    0.01194392f, -0.02970263f, -0.00062584f, -0.01840476f, -0.01263213f, -0.04667880f, -0.03605272f, 0.04338746f, 
    -0.04084952f, -0.04740004f, -0.00942381f, -0.00820037f, -0.01071697f, 0.02939082f, -0.02052694f, -0.04668764f, 
    -0.00971757f, 0.01893383f, 0.02708633f, 0.01631168f, 0.00217248f, -0.02144084f, 0.03054528f, -0.04517590f, 
    -0.03504533f, 0.01725172f, -0.03661974f, -0.01128256f, -0.03233091f, -0.01796407f, 0.03470211f, 0.04224811f, 
    0.04164822f, 0.03480590f, -0.00170304f, -0.01163179f, 0.02864647f, -0.01413992f, -0.01950843f, -0.04512093f, 
    -0.01175760f, 0.03330804f, -0.02765646f, -0.01070143f, -0.02811280f, -0.02598673f, -0.01346220f, -0.01724268f, 
    -0.01809640f, 0.00101321f, 0.01911941f, -0.04339895f, -0.01846703f, 0.03512615f, -0.00808401f, -0.01936991f, 
    0.03068119f, -0.01499886f, -0.03014338f, -0.01493330f, 0.01805699f, 0.03411204f, 0.00372908f, 0.02750486f, 
    -0.01474844f, -0.04396167f, -0.02381526f, -0.05139991f, -0.05226430f, 0.03307249f, -0.05355763f, -0.04891487f, 
    -0.01017433f, 0.04358880f, 0.03019892f, -0.01177722f, 0.04202335f, -0.03800794f, -0.01332865f, -0.00516018f, 
    0.02653977f, 0.00327295f, -0.03240971f, 0.01918832f, 0.03806644f, 0.02507073f, -0.03929512f, -0.00915222f, 
    0.00926746f, 0.01774230f, 0.04332666f, 0.01543016f, 0.01695811f, 0.03680630f, 0.00528600f, -0.02669060f, 
    -0.01409860f, 0.00128118f, 0.00890936f, -0.01594730f, 0.01984805f, 0.01677713f, -0.04962992f, 0.00031584f, 
    0.01885638f, -0.02826113f, 0.02919490f, 0.01753724f, -0.01037905f, 0.00233484f, -0.05488830f, 0.04610359f, 
    -0.05238224f, -0.02890921f, -0.05494076f, 0.01533527f, -0.02035634f, -0.00524751f, 0.02881538f, 0.04021866f, 
    -0.05620866f, -0.05156548f, -0.05182002f, 0.02006559f, -0.00014636f, 0.03134418f, 0.02024797f, -0.03638961f, 
    -0.04467602f, -0.04916611f, 0.02274286f, -0.03128175f, -0.04337654f, 0.03433236f, -0.03324357f, 0.01161914f, 
    -0.04501153f, -0.01122561f, -0.01041978f, 0.01214652f, -0.05330188f, 0.03987061f, 0.02011502f, -0.00692209f, 
    -0.00488029f, 0.00248133f, 0.03715704f, 0.02928311f, -0.03747344f, 0.03540639f, 0.03196634f, 0.03544670f, 
    -0.00220269f, -0.02238944f, -0.03234920f, 0.03906950f, 0.00248525f, 0.03719600f, -0.02872233f, 0.03105549f, 
    -0.00377230f, 0.03552976f, -0.03644590f, 0.00508728f, 0.01621581f, 0.03491133f, 0.02339327f, -0.00646572f, 
    -0.02643847f, 0.00770666f, -0.00490612f, -0.00614177f, -0.02963648f, -0.03108351f, 0.00231093f, -0.00476101f, 
    0.00991590f, -0.00212808f, -0.01320993f, 0.04382681f, 0.02864532f, -0.02904424f, 0.02073012f, -0.01007741f, 
    -0.04214921f, 0.02265748f, -0.00553332f, 0.03377064f, -0.05133664f, 0.01116402f, 0.01233088f, 0.04047127f, 
    -0.00523285f, 0.01329800f, -0.04198690f, -0.05033694f, -0.01718425f, -0.00101816f, -0.05579504f, 0.00694675f, 
    -0.23383670f, 0.15297738f, -0.09640093f, -0.29697540f, -0.07154487f, 0.04734901f, -0.03128009f, 0.02667298f, 
    0.14332764f, -0.07459781f, -0.30299392f, -0.27765569f, 0.07619607f, 0.19702363f, 0.32536277f, -0.31527039f, 
    -0.00283921f, 0.11261364f, 0.08531655f, 0.23713656f, 0.12329721f, 0.10135885f, 0.09525216f, 0.00179807f, 
    0.17967236f, -0.08350112f, 0.13823146f, 0.00712781f, -0.03051609f, -0.07885479f, -0.16819136f, 0.04978761f, 
    0.14137970f, 0.02057602f, -0.02418969f, -0.07012069f, -0.00508312f, 0.08786964f, -0.15388115f, 0.18026844f, 
    -0.00307678f, 0.03607869f, 0.02979573f, 0.06111643f, 0.07963832f, -0.05847640f, 0.02106113f, 0.20139989f, 
    -0.02668889f, 0.24483640f, -0.05264452f, 0.04448813f, -0.31755686f, -0.07062913f, -0.07395376f, 0.04874877f, 
    -0.05868843f, -0.00762214f, 0.00023380f, -0.09005196f, -0.06361420f, 0.04539269f, -0.08622444f, -0.04052974f, 
    0.28229654f, 0.01814714f, 0.10008197f, 0.02442504f, -0.01179798f, 0.06920198f, -0.14764641f, -0.31826854f, 
    -0.08841698f, -0.14170504f, -0.24061173f, -0.19377750f, -0.04504083f, -0.06015426f, 0.00208436f, 0.14143260f, 
    -0.16106750f, -0.08618341f, -0.03841871f, -0.10305703f, 0.10412402f, -0.10779166f, 0.04632320f, 0.05881727f, 
    -0.11524135f, -0.00455954f, -0.00959680f, 0.13417381f, 0.10771330f, 0.20654428f, 0.10831225f, 0.20547144f, 
    -0.04314656f, 0.18372305f, 0.11394913f, -0.02164734f, 0.16342278f, 0.00523785f, 0.18610252f, 0.10389771f, 
    0.08899231f, 0.05716702f, -0.11512495f, -0.03663274f, -0.13240661f, -0.00054498f, 0.04649078f, 0.15692344f, 
    -0.03506794f, -0.23229571f, -0.06684269f, -0.01926598f, -0.01559215f, 0.04384828f, 0.23492980f, 0.13402554f, 
    -0.22684138f, 0.08987612f, -0.17834017f, 0.08446080f, 0.02214587f, 0.14743853f, 0.01205427f, 0.04655184f, 
    -0.22532012f, -0.03594010f, -0.16573295f, -0.05874756f, -0.10813455f, 0.11477505f, 0.10826775f, 0.20836796f, 
    -0.06369068f, -0.05835903f, -0.03857699f, 0.02456071f, 0.01763645f, -0.15675804f, -0.20652507f, -0.11916120f, 
    -0.17670850f, 0.03411870f, -0.01060631f, 0.03973517f, -0.19832677f, -0.14270343f, -0.04982197f, -0.10349583f, 
    0.19099468f, 0.19473758f, 0.07029710f, 0.22651865f, 0.09076274f, -0.00303265f, 0.05554443f, 0.21783103f, 
    -0.07049702f, 0.07924743f, -0.03462442f, 0.03871968f, 0.14243074f, -0.11537499f, 0.20224880f, 0.15941051f, 
    -0.29721874f, -0.35153538f, -0.12816349f, -0.19731729f, -0.25847822f, -0.03745266f, -0.07549971f, -0.07868766f, 
    0.21890950f, 0.03112412f, 0.17464676f, 0.10838202f, 0.27584958f, -0.17212841f, -0.21643840f, -0.23515299f, 
    0.04291460f, 0.15860537f, 0.01287527f, -0.14102533f, 0.07939526f, 0.12234140f, 0.22160338f, 0.15983084f, 
    -0.09176293f, 0.06545012f, -0.04739311f, 0.08699711f, 0.14150426f, 0.23982471f, 0.33411750f, 0.19320442f, 
    0.12566829f, -0.05253763f, 0.12414605f, 0.29353240f, -0.18461974f, -0.00754542f, -0.17860998f, 0.27393797f, 
    -0.11965574f, -0.01901512f, -0.07700463f, 0.02350351f, -0.15393023f, -0.06247047f, -0.17636721f, -0.02743759f, 
    0.00623889f, -0.33655646f, -0.22936414f, -0.26755410f, -0.02352045f, -0.16567641f, 0.10008087f, 0.26682064f, 
    0.05562883f, 0.01777387f, 0.11353032f, -0.03924977f, 0.04077437f, 0.01236680f, 0.11451713f, 0.14316249f, 
    -0.15934664f, -0.22651650f, -0.07353132f, -0.02650451f, 0.10720497f, 0.06298200f, 0.09631597f, 0.19089529f, 
    -0.04038822f, 0.28648990f, -0.10589346f, -0.13630460f, -0.08738631f, -0.02282145f, 0.09472850f, 0.07265455f, 
    0.03526357f, -0.09655279f, -0.32286340f, -0.22339772f, 0.13184005f, 0.10298192f, -0.03573791f, -0.12822179f, 
    0.17383981f, -0.06001642f, -0.09083777f, -0.08058116f, -0.08151286f, -0.08363269f, -0.07062183f, -0.17206909f, 
    -0.01230698f, -0.01686683f, 0.03101097f, 0.05387990f, -0.14909069f, -0.10090835f, 0.02534984f, -0.24461325f, 
    0.18522492f, -0.04195593f, -0.04211246f, 0.17533778f, 0.14607835f, 0.14235967f, 0.07229982f, -0.07188931f, 
    0.03098110f, -0.03404356f, 0.07186862f, 0.07132957f, -0.07046821f, 0.05497937f, 0.09450549f, 0.02030283f, 
    -0.20455524f, 0.06185228f, -0.17973450f, -0.08663490f, 0.07869803f, 0.07784097f, 0.06768277f, 0.17095786f, 
    0.01808717f, 0.06556106f, -0.07274699f, -0.08388785f, 0.07115848f, 0.02851298f, 0.08491628f, 0.12413517f, 
    0.25151211f, -0.00670477f, 0.10967978f, 0.11405616f, 0.14783607f, 0.04425797f, 0.17378095f, 0.11262684f, 
    -0.06425648f, -0.11558377f, -0.06949536f, -0.14930101f, -0.22684419f, 0.08564270f, 0.03685446f, 0.20441411f, 
    0.05864287f, 0.04480761f, -0.00073665f, -0.01631221f, 0.00907774f, 0.03858674f, 0.03091658f, 0.08258069f, 
    0.08304360f, 0.20643693f, 0.21181254f, 0.08273909f, -0.01671737f, -0.09559404f, 0.01458178f, 0.14074579f, 
    0.07725950f, 0.18118392f, 0.08607349f, -0.00252902f, 0.01161404f, -0.08100304f, -0.09909247f, -0.07268094f, 
    -0.03573134f, -0.16060692f, -0.22865713f, -0.31010857f, 0.40738174f, 0.09263834f, 0.17254388f, -0.12414875f, 
    0.05189316f, -0.00703187f, 0.09604046f, 0.08926629f, -0.02089188f, -0.05281809f, -0.24127325f, -0.37688836f, 
    0.09172688f, 0.09194876f, 0.23605064f, 0.09000898f, 0.04472175f, 0.03192589f, 0.01198669f, 0.26352793f, 
    -0.00017910f, -0.18900195f, 0.07629807f, -0.07942892f, -0.11357923f, 0.10392253f, 0.14787307f, -0.10960855f, 
    0.04523753f, -0.09352595f, -0.03863548f, 0.20966277f, 0.06648810f, 0.16734506f, 0.08219342f, -0.08113632f, 
    0.26744047f, 0.24582842f, 0.18199649f, 0.21657434f, 0.03897491f, 0.11451340f, 0.06660982f, 0.09431101f, 
    -0.04333722f, -0.02604712f, -0.18310276f, 0.01573986f, 0.37870961f, -0.03468402f, 0.11156002f, 0.19257188f, 
    -0.13377509f, -0.07595070f, 0.03532744f, 0.09137575f, -0.04394703f, -0.11580483f, -0.03881582f, -0.04745570f, 
    0.23336467f, -0.10464871f, -0.04374178f, -0.00374637f, 0.02063312f, -0.02599674f, -0.10420305f, -0.00164479f, 
    -0.11329716f, -0.04331339f, 0.27321810f, 0.13496806f, -0.00744355f, -0.35894215f, 0.09425991f, -0.12424645f, 
    -0.18704301f, 0.00595594f, -0.06031463f, 0.02794031f, -0.05767903f, -0.00091643f, 0.05987442f, -0.02883164f, 
    -0.05146095f, -0.15156770f, -0.18161838f, 0.00909438f, 0.01384966f, -0.04230772f, 0.05832638f, 0.01025798f, 
    0.00649999f, 0.02901470f, -0.09227166f, -0.03735810f, -0.03682854f, 0.21396837f, 0.17117950f, 0.03257984f, 
    -0.01587839f, 0.19342926f, -0.09986673f, -0.14963380f, -0.13805595f, 0.01686439f, -0.05293106f, 0.02894259f, 
    0.09112733f, 0.07039375f, -0.04757190f, 0.19510451f, 0.08073068f, 0.04906953f, 0.03168994f, 0.08838677f, 
    0.12600540f, 0.18085200f, -0.02503946f, -0.01011533f, 0.20949346f, 0.30953544f, 0.13107106f, 0.24510613f, 
    0.04452164f, 0.10234609f, -0.09866126f, -0.09843587f, -0.02418783f, -0.05557063f, -0.19661963f, -0.01280817f, 
    0.20371969f, 0.17290138f, 0.12999107f, 0.18872392f, -0.00055482f, -0.00573165f, 0.03359919f, 0.06488965f, 
    -0.03761915f, -0.10489129f, -0.07531474f, 0.02729047f, -0.02761109f, -0.21174312f, 0.05737919f, -0.20114595f, 
    -0.06145164f, 0.04367459f, 0.04119707f, -0.03752461f, -0.05044648f, 0.10439038f, -0.11555699f, 0.14423610f, 
    -0.08412787f, 0.07957479f, -0.06174191f, -0.09617294f, -0.05894850f, -0.10223681f, -0.10017031f, 0.11539057f, 
    0.12623858f, -0.00075100f, 0.01270849f, 0.02280043f, -0.09573578f, -0.12481516f, -0.20306392f, -0.18128696f, 
    -0.07316348f, -0.05280394f, 0.00410411f, -0.08255590f, -0.10228544f, 0.11287823f, 0.07567243f, -0.04144989f, 
    0.06857865f, -0.18635549f, -0.11344541f, -0.03764827f, 0.01188441f, 0.07993875f, 0.03355767f, -0.00943048f, 
    -0.06691203f, -0.06121485f, -0.04600378f, -0.04608270f, -0.02544758f, -0.16377701f, 0.07082405f, -0.34329799f, 
    0.02624813f, 0.13791153f, -0.04475141f, 0.11409743f, 0.04125107f, -0.17644618f, 0.06458565f, 0.00334374f, 
    0.26299003f, 0.16934323f, -0.02568444f, -0.00327297f, -0.03127735f, 0.11645617f, 0.03580996f, 0.12005066f, 
    0.13533202f, 0.00039281f, 0.08484818f, -0.01948790f, -0.47083849f, 0.15335126f, 0.06621391f, -0.04311348f, 
    0.01389253f, -0.02787071f, 0.03564728f, 0.20042916f, -0.01848676f, -0.07137883f, -0.00985962f, 0.05448092f, 
    0.19011058f, 0.23967043f, 0.21497318f, 0.35241932f, -0.04201909f, 0.08388703f, -0.15999410f, -0.04496507f, 
    -0.08001818f, -0.07899147f, -0.01341419f, -0.02190856f, -0.35286754f, -0.31308961f, 0.01523090f, -0.16409762f, 
    -0.12087802f, -0.10171475f, -0.13502684f, -0.02324854f, -0.00541424f, 0.02547529f, 0.03240186f, -0.06151281f, 
    0.02070390f, 0.20593092f, 0.07938305f, 0.14116769f, 0.01938521f, 0.05018282f, -0.04622012f, 0.06828669f, 
    0.06660371f, 0.08656829f, -0.04414942f, -0.02733295f, -0.01769555f, -0.08271225f, -0.14743958f, -0.17336206f, 
    -0.07266397f, 0.06170385f, 0.02001114f, 0.02329217f, -0.04325873f, -0.04279010f, -0.10564616f, -0.04670843f, 
    0.26396686f, -0.04031219f, 0.08669331f, 0.14739132f, -0.02346799f, -0.16212624f, -0.08672950f, -0.01604016f, 
    -0.08954918f, -0.06887621f, -0.12541841f, -0.03180031f, 0.11199476f, 0.11378060f, 0.20129874f, 0.14998776f, 
    0.07987706f, 0.08050256f, 0.17445311f, 0.00449425f, -0.02168169f, 0.01923395f, -0.01128887f, -0.07942186f, 
    -0.22055134f, -0.21193853f, -0.03635997f, -0.17109627f, -0.01722714f, -0.06631360f, 0.05827470f, -0.07012656f, 
    -0.14651610f, 0.11944502f, 0.06703151f, 0.02456042f, -0.02291425f, 0.12851021f, 0.11015803f, 0.08957518f, 
    0.06005798f, -0.11761823f, 0.04809812f, -0.03219812f, -0.06147936f, -0.06304727f, 0.00098419f, -0.08066900f, 
    0.34170961f, 0.04462683f, 0.36741081f, 0.19893129f, 0.00601521f, 0.06735294f, 0.16956891f, 0.04175938f, 
    -0.06119502f, -0.06937685f, -0.03400683f, 0.01395160f, -0.26159599f, -0.00285273f, 0.02444194f, -0.15136559f, 
    -0.15384002f, 0.13265619f, -0.20171550f, 0.00548080f, -0.18581772f, -0.02448462f, -0.04486992f, -0.05171465f, 
    -0.04862825f, 0.16891806f, 0.04600691f, 0.09378651f, 0.05845165f, 0.08499434f, 0.07567291f, 0.03677095f, 
    -0.01444764f, -0.01960601f, 0.01421883f, 0.01011992f, 0.28709686f, 0.08440895f, 0.24353375f, 0.28416121f, 
    -0.09075578f, 0.06253071f, -0.06332356f, -0.07397132f, -0.07940227f, -0.08556082f, -0.05343216f, -0.00523554f, 
    0.22324175f, 0.24223144f, 0.03967851f, 0.04745480f, 0.08409268f, 0.01748397f, -0.02114636f, 0.00310240f, 
    0.06651597f, 0.07258167f, 0.05467676f, 0.03120520f, 0.11462289f, -0.01940702f, -0.19525395f, 0.02339364f, 
    -0.11825906f, -0.05513968f, -0.01099068f, -0.06891483f, -0.02260452f, 0.03247600f, -0.19003351f, 0.01842024f, 
    0.30041918f, 0.04516602f, 0.16046423f, 0.11330402f, 0.02988086f, -0.16026960f, 0.02993582f, -0.12171088f, 
    -0.00116169f, 0.03755448f, 0.02689754f, -0.10823476f, -0.26033294f, 0.11295199f, 0.00391321f, -0.06037531f, 
    -0.00599826f, -0.04630530f, 0.09834302f, -0.02652395f, -0.06626482f, -0.02477654f, 0.04057273f, 0.02938972f, 
    0.02108477f, 0.03135707f, -0.01012047f, -0.02350526f, -0.04438967f, -0.03446260f, -0.00913722f, 0.03754435f, 
    -0.02581431f, 0.04013132f, -0.02160387f, -0.01858611f, -0.01113022f, -0.03407301f, 0.01024158f, 0.02034311f, 
    -0.04100557f, 0.01505514f, 0.00228362f, 0.00657359f, -0.01769002f, 0.00850798f, -0.00528277f, -0.02776975f, 
    0.00227634f, -0.01782690f, 0.00011129f, 0.00487188f, 0.00871599f, 0.02598372f, -0.03643077f, -0.04832687f, 
    -0.02843277f, -0.03736543f, 0.00968306f, 0.01275254f, -0.00213346f, -0.00918186f, -0.03833705f, -0.04024777f, 
    0.02640966f, 0.02587572f, 0.01431945f, 0.03931696f, 0.01604299f, 0.01965856f, -0.00960427f, -0.04578098f, 
    -0.04065648f, -0.02162338f, 0.01228316f, 0.01866801f, -0.03581841f, -0.00054805f, -0.00569613f, 0.01316549f, 
    0.01767672f, 0.00597138f, -0.05423571f, -0.03462367f, 0.02481909f, 0.02618918f, -0.02054169f, 0.05113672f, 
    0.04287701f, 0.03798491f, -0.04283444f, -0.05684136f, 0.01535031f, 0.05584763f, 0.01281909f, 0.03716433f, 
    0.04414666f, 0.03121158f, 0.02770389f, -0.01852437f, -0.02929356f, 0.02975886f, 0.01098659f, 0.01277030f, 
    -0.03423873f, -0.05138604f, 0.00624167f, 0.02265917f, -0.00555228f, -0.02762795f, -0.04292538f, 0.00418858f, 
    -0.02920547f, 0.03413798f, 0.02658394f, -0.04363305f, -0.04677796f, 0.01534824f, -0.01030279f, 0.02731572f, 
    -0.00009457f, -0.03725804f, -0.02215931f, -0.03411556f, -0.03996714f, 0.02116320f, 0.03143885f, -0.02663856f, 
    0.02760056f, 0.04120722f, 0.00053489f, -0.04538038f, -0.00737732f, 0.02437278f, -0.03857638f, 0.01893872f, 
    0.01890714f, -0.00354146f, 0.02349663f, 0.01031527f, -0.05873743f, -0.04240531f, 0.03158901f, -0.03955255f, 
    -0.01088904f, 0.01812931f, 0.01545910f, -0.01586619f, -0.04748798f, 0.00403263f, 0.01417998f, 0.04509540f, 
    0.00927077f, -0.00149617f, 0.01640587f, 0.02464581f, -0.03075141f, -0.01357398f, -0.02891729f, 0.03410881f, 
    0.03404781f, -0.02689150f, 0.02110586f, -0.00505583f, -0.02359108f, 0.02020762f, -0.02581306f, 0.03154938f, 
    0.01069791f, -0.05567281f, -0.01055340f, -0.05349662f, -0.04319228f, -0.03351393f, -0.00096166f, 0.03956484f, 
    -0.01300215f, 0.00020949f, 0.00378938f, -0.01799418f, 0.03618044f, -0.00778150f, 0.01113356f, 0.02294778f, 
    -0.02464492f, 0.02342106f, -0.04697062f, -0.03572201f, 0.01330557f, -0.05433863f, 0.00559730f, -0.03862077f, 
    -0.01531323f, -0.03017984f, 0.01126354f, -0.01370986f, 0.01755443f, 0.00584739f, 0.03922570f, 0.02512128f, 
    -0.05271504f, -0.00828541f, -0.03157414f, 0.03250657f, -0.01418675f, -0.00883393f, -0.01122727f, 0.01758272f, 
    -0.01740644f, -0.01311736f, 0.00990214f, 0.03806761f, 0.01507931f, -0.05883321f, 0.03875711f, 0.00616121f, 
    -0.03258295f, -0.04868699f, 0.02805434f, 0.00854015f, 0.03287506f, 0.00165263f, -0.00226292f, 0.05046110f, 
    -0.02407033f, 0.01182822f, -0.05432979f, -0.04736583f, -0.05053504f, -0.01558057f, -0.00574696f, 0.03732914f, 
    -0.03120601f, -0.00386846f, -0.00927018f, -0.01566876f, 0.02591673f, 0.01616732f, -0.04380248f, 0.00606833f, 
    0.01515970f, 0.05418003f, 0.00921333f, -0.04341627f, 0.00724380f, -0.01670120f, 0.00407365f, -0.04660213f, 
    0.03360612f, -0.02922297f, -0.02731378f, -0.03435540f, 0.00299628f, 0.02646360f, -0.00154758f, 0.00673041f, 
    -0.02620480f, -0.02258622f, 0.03093337f, -0.01188998f, -0.02189492f, 0.01866511f, -0.02461100f, 0.00213491f, 
    -0.00578199f, 0.00336988f, 0.01571858f, -0.01825292f, -0.05157078f, -0.05671168f, 0.01726740f, -0.03736751f, 
    0.03772742f, -0.00850258f, 0.02356972f, 0.02395127f, -0.04468866f, -0.00017709f, -0.04127010f, 0.05552628f, 
    -0.00690507f, -0.04576694f, -0.00440635f, -0.04487675f, -0.02465964f, 0.00425285f, 0.02596639f, -0.02173858f, 
    -0.02132574f, 0.00076863f, -0.04640611f, 0.02340408f, 0.03135711f, 0.03815175f, 0.00728792f, 0.03793682f, 
    -0.05557927f, -0.02082496f, 0.04624104f, 0.01567825f, -0.02051246f, 0.02273195f, -0.04116450f, 0.00433910f, 
    -0.03025685f, -0.02136886f, -0.00825281f, 0.02710333f, -0.00644964f, 0.00346414f, -0.03658824f, -0.00266617f, 
    -0.04195748f, 0.00207710f, -0.00171119f, 0.01326431f, -0.03995599f, 0.03126770f, -0.03359740f, -0.01106979f, 
    0.01228198f, 0.03250962f, 0.00093651f, 0.00153082f, -0.02951043f, -0.01945768f, -0.01799842f, 0.00901885f, 
    0.02713196f, 0.02078443f, 0.03154499f, -0.05615641f, -0.02005113f, -0.02836074f, -0.03019139f, -0.03427308f, 
    -0.04814725f, -0.03157842f, -0.02289044f, -0.02367576f, -0.04877868f, -0.05836637f, 0.01516053f, 0.00874657f, 
    -0.03942613f, 0.02887209f, -0.03164726f, 0.03093391f, 0.03881484f, 0.04435503f, 0.00731100f, -0.04101672f, 
    0.04672366f, -0.03269997f, 0.01139440f, 0.04024696f, -0.01847992f, -0.04996331f, -0.00992298f, 0.02885300f, 
    0.00078459f, -0.02651065f, 0.03706866f, -0.01226613f, -0.03329046f, -0.01330668f, -0.03698310f, 0.01787194f, 
    -0.03597156f, -0.01815968f, -0.02743674f, -0.04172255f, -0.00877354f, -0.04219910f, 0.04161942f, 0.04637003f, 
    -0.00778927f, -0.05320926f, 0.03849255f, -0.01889527f, 0.00544915f, 0.00634674f, 0.03231969f, -0.01698192f, 
    -0.04114095f, 0.00521485f, 0.04058405f, 0.02383692f, 0.00585922f, 0.04056108f, -0.00962570f, 0.01209219f, 
    0.02129124f, -0.03234425f, 0.01204994f, 0.04993084f, -0.03519228f, -0.01785964f, 0.01613684f, -0.04967652f, 
    0.02225790f, -0.02191910f, 0.00106082f, -0.03503645f, -0.02987308f, 0.03941096f, -0.02434924f, -0.01533438f, 
    0.28490347f, 0.10436361f, 0.12696332f, -0.04405916f, 0.02180110f, 0.10138121f, 0.09030926f, 0.09047532f, 
    0.05372614f, 0.13699645f, -0.07790415f, -0.08958384f, 0.06181397f, -0.27927339f, 0.30298752f, 0.27030453f, 
    -0.09050915f, 0.02494997f, 0.20620321f, 0.19395626f, 0.01661673f, 0.13225655f, 0.22146940f, 0.12201827f, 
    0.48702374f, -0.09196945f, 0.20160502f, 0.27563640f, 0.00557753f, 0.09557700f, 0.02538083f, -0.09154868f, 
    -0.00237304f, 0.07942426f, 0.09378177f, 0.19552791f, 0.25158307f, 0.12722988f, 0.31598705f, -0.12514712f, 
    0.01465605f, -0.05861748f, 0.06824248f, -0.17960645f, 0.06403755f, 0.08420015f, -0.08555421f, 0.07798744f, 
    0.18901697f, 0.10962344f, 0.08228450f, 0.21872467f, -0.16514483f, -0.20721282f, -0.04021350f, -0.14863580f, 
    0.02241829f, 0.05332091f, 0.00785245f, -0.05594565f, -0.18651187f, -0.04571341f, -0.01604832f, -0.14957014f, 
    0.09447616f, 0.11669269f, 0.14976327f, 0.01023487f, -0.15616094f, -0.15245242f, -0.07641695f, -0.20978892f, 
    -0.18753269f, -0.17561279f, -0.22219302f, -0.11673180f, -0.07842241f, -0.03906525f, 0.08679001f, 0.07975502f, 
    0.07334669f, 0.03298984f, -0.02275985f, 0.02897397f, -0.03589029f, 0.11125547f, 0.00728537f, -0.04710860f, 
    0.01131870f, -0.00425840f, 0.10727298f, 0.09727255f, -0.11015923f, -0.06533640f, -0.11722565f, -0.05583937f, 
    -0.08311898f, -0.10595260f, -0.11334768f, 0.11185372f, 0.11259786f, 0.07577691f, 0.00467968f, 0.04753372f, 
    -0.08184500f, 0.08933662f, 0.00235026f, 0.00340493f, 0.15691918f, -0.04800995f, 0.12653831f, -0.17531233f, 
    0.05309705f, 0.06305688f, -0.01144567f, 0.05485209f, -0.00071519f, 0.10232320f, -0.08333199f, 0.10669514f, 
    -0.03214354f, 0.00055894f, 0.40481022f, -0.15568787f, 0.01899540f, -0.17261985f, -0.08875542f, 0.05802218f, 
    -0.08508664f, -0.02343191f, -0.05444420f, -0.00015339f, 0.11880271f, 0.07993658f, 0.24118111f, 0.03139970f, 
    -0.01057442f, -0.10886298f, -0.12465221f, -0.04303418f, -0.06087115f, 0.07296357f, -0.06324966f, -0.08215825f, 
    0.08305828f, 0.09445854f, 0.00356853f, -0.10786339f, -0.12137898f, -0.05672652f, -0.00590782f, -0.05539094f, 
    0.06023848f, -0.04137263f, 0.01710589f, 0.06437550f, 0.07358398f, 0.03585384f, 0.07594234f, 0.00687810f, 
    0.04969143f, 0.11179573f, 0.12567185f, 0.02493174f, 0.02368797f, -0.02073039f, 0.04497609f, 0.12735559f, 
    -0.03891730f, -0.06270799f, -0.28683591f, -0.11766399f, -0.12225574f, 0.05378349f, 0.04702763f, 0.06924399f, 
    0.10208115f, 0.11742791f, 0.01168952f, -0.06825704f, -0.20039305f, 0.29399207f, -0.10905439f, -0.04260400f, 
    -0.07172699f, -0.10679785f, 0.08820988f, -0.08978222f, -0.05394480f, -0.08970330f, 0.01368192f, 0.01143263f, 
    0.03228466f, -0.08408181f, -0.19741146f, 0.04432290f, -0.07409488f, 0.02412056f, 0.13560717f, -0.01566574f, 
    -0.01856537f, -0.03226695f, -0.01971943f, -0.01002657f, 0.10666178f, 0.09968200f, 0.20526832f, -0.23008336f, 
    -0.10034740f, -0.24365383f, -0.21533927f, 0.06780482f, -0.05093048f, -0.05024121f, -0.00190499f, 0.03250585f, 
    0.08085490f, -0.06105786f, -0.05576323f, -0.04814794f, -0.03762280f, 0.07803612f, 0.21178943f, 0.08296752f, 
    0.04022965f, -0.00608378f, -0.13330366f, -0.00755333f, 0.09076582f, 0.26817930f, 0.13957378f, 0.01084615f, 
    -0.12286905f, -0.05100580f, 0.00807117f, -0.06771076f, -0.08566581f, 0.05285149f, -0.00270139f, 0.01381539f, 
    0.01386986f, -0.00229265f, 0.12146162f, 0.01195547f, 0.04005405f, 0.01441376f, 0.02412052f, 0.15580450f, 
    -0.00923667f, 0.04872247f, -0.13762954f, 0.04944477f, 0.05157311f, -0.06162098f, 0.19509019f, -0.08067865f, 
    0.07999735f, 0.19389167f, 0.08009985f, -0.05052479f, -0.14220795f, -0.08773760f, 0.00063731f, -0.04994136f, 
    0.12881082f, 0.12326217f, 0.16341412f, 0.05171747f, -0.08707859f, -0.07996625f, -0.00254830f, -0.03479083f, 
    -0.04090727f, 0.14109735f, 0.03117436f, 0.04714232f, -0.29361776f, -0.11861431f, -0.08389296f, -0.19178307f, 
    -0.02464559f, -0.12029377f, -0.08431242f, -0.21260543f, -0.04979679f, -0.05152265f, -0.01101288f, 0.10979246f, 
    -0.10700446f, 0.02238566f, 0.19288741f, 0.12033056f, 0.05564133f, 0.16779204f, 0.08771607f, -0.02314138f, 
    0.02323632f, 0.03691717f, -0.04482689f, 0.04757335f, 0.03418593f, 0.15561886f, 0.12624675f, 0.21205120f, 
    0.07410207f, 0.19631661f, 0.05676326f, -0.09375785f, 0.07899937f, -0.00754424f, -0.02255830f, -0.00552533f, 
    -0.16826913f, -0.23653564f, -0.21499763f, -0.14183074f, 0.00917199f, -0.03080822f, 0.03990052f, 0.10319588f, 
    -0.09257788f, 0.02229799f, 0.06632748f, -0.05541192f, -0.20186663f, -0.11588109f, -0.11244696f, -0.21252692f, 
    0.03991684f, 0.10603516f, -0.00831954f, 0.05590668f, -0.00302848f, 0.08454343f, -0.02244740f, 0.07377239f, 
    0.18925133f, 0.00266206f, -0.12202245f, 0.02578777f, 0.16917756f, 0.03371380f, 0.03186136f, 0.01551014f, 
    -0.13366227f, 0.00788392f, 0.08010509f, -0.08894317f, 0.25980613f, 0.02852406f, -0.23161727f, -0.16438136f, 
    -0.01044718f, -0.01983690f, 0.05926223f, 0.15778384f, 0.14051396f, -0.00250483f, 0.09555037f, -0.17865160f, 
    0.12909329f, -0.03129137f, 0.04043551f, -0.05927930f, 0.12197912f, 0.11298587f, 0.18092397f, 0.12302406f, 
    0.15174749f, 0.12460144f, 0.01056764f, -0.00894706f, 0.14076221f, 0.05248961f, 0.22787423f, 0.05168247f, 
    0.10257570f, 0.17214425f, -0.00305709f, 0.07037801f, -0.02216770f, -0.01624844f, -0.07507879f, -0.12176163f, 
    -0.22133626f, -0.25384590f, 0.01615274f, 0.02249646f, 0.01226156f, -0.02019074f, -0.09944140f, 0.15094686f, 
    -0.04146574f, 0.12198106f, -0.04583514f, -0.10042101f, 0.01442579f, -0.25101995f, 0.35354954f, 0.03365035f, 
    0.12323792f, 0.09084240f, -0.05298734f, 0.07818469f, 0.05713798f, 0.10669857f, -0.02542850f, -0.06976860f, 
    0.12443046f, 0.03109798f, 0.00431910f, -0.04618764f, 0.03008823f, -0.05685764f, -0.14453918f, 0.00582932f, 
    -0.03516952f, 0.02232739f, 0.10301185f, 0.10699674f, -0.04885165f, 0.08548539f, -0.17751223f, 0.07899573f, 
    -0.00511906f, -0.10612314f, 0.07875114f, 0.19124047f, -0.04244792f, 0.00579490f, -0.00948349f, -0.07321545f, 
    -0.55531627f, -0.14096880f, 0.54550374f, 0.02705605f, 0.05190669f, 0.03288759f, -0.02055538f, 0.03416292f, 
    0.11844226f, 0.08301610f, -0.14749353f, 0.09371082f, -0.27188799f, 0.16461201f, -0.21587622f, 0.04483734f, 
    -0.11666033f, 0.18105420f, -0.10725548f, -0.05288998f, -0.00882949f, -0.00589385f, -0.00989849f, 0.08406515f, 
    -0.01951891f, 0.20445940f, 0.20707308f, 0.07916347f, 0.06556565f, 0.03839798f, 0.00652503f, -0.05856526f, 
    0.07948934f, 0.02227826f, 0.02066344f, 0.02533949f, 0.05685565f, 0.00491445f, 0.07380607f, 0.02509243f, 
    0.01799877f, -0.11319999f, 0.08414552f, 0.08786327f, -0.00260054f, 0.04607135f, -0.04808687f, 0.04808712f, 
    -0.21542072f, -0.00903039f, -0.04498409f, 0.19537814f, -0.09016493f, 0.01153111f, 0.04492057f, 0.00270557f, 
    -0.00064422f, 0.14603008f, 0.02632724f, 0.03204236f, -0.03113092f, -0.09314989f, 0.08680747f, 0.00435502f, 
    -0.10862634f, 0.04403704f, 0.00275023f, 0.04891958f, 0.09623773f, -0.02854186f, 0.20442538f, 0.02944187f, 
    0.14242627f, 0.16508666f, -0.62185401f, 0.06533270f, -0.06866989f, -0.03854985f, 0.10889423f, 0.03148906f, 
    0.03050365f, -0.00215350f, -0.12641488f, 0.01905775f, 0.09367014f, 0.04022244f, -0.06711645f, -0.08341823f, 
    -0.07542280f, -0.14191771f, 0.10053197f, 0.01947196f, -0.02237992f, 0.03386611f, 0.01180885f, 0.04861987f, 
    0.05339083f, -0.00604214f, 0.05004870f, -0.17271492f, -0.01585394f, -0.08060072f, 0.00650987f, -0.05784024f, 
    0.12020081f, 0.02794425f, 0.09026973f, -0.16677165f, -0.12419211f, -0.02541609f, 0.00920679f, -0.00542054f, 
    -0.06126694f, 0.18339042f, -0.10397285f, 0.04641666f, 0.14223018f, -0.12713578f, -0.01369079f, -0.07016899f, 
    0.33469626f, 0.19849147f, 0.37951559f, 0.06612819f, -0.04163663f, -0.10433952f, -0.14299820f, -0.02010793f, 
    0.05424273f, -0.01467481f, 0.05913116f, 0.15603492f, -0.23577996f, -0.35537741f, -0.15224724f, 0.06509250f, 
    0.01680989f, 0.13402294f, 0.10789217f, 0.16950570f, -0.06936647f, -0.03683597f, -0.00422169f, -0.05617153f, 
    -0.11458620f, -0.08794883f, 0.06032428f, 0.41773036f, 0.02076128f, -0.10670216f, -0.17920183f, -0.08396248f, 
    -0.05228991f, 0.07057361f, -0.06058891f, -0.00221291f, -0.02278184f, -0.01668895f, -0.43580624f, -0.17713924f, 
    -0.02010800f, -0.07099523f, 0.28757086f, 0.07902359f, 0.08017414f, 0.02754331f, -0.09076531f, -0.10520238f, 
    0.24639225f, 0.30146101f, 0.19406956f, -0.01745646f, 0.02135183f, -0.24073555f, -0.02965231f, -0.01712266f, 
    0.13301258f, 0.18379207f, 0.06261722f, -0.13090965f, 0.02854333f, -0.00068873f, 0.02464774f, -0.08614373f, 
    -0.09282932f, -0.01755411f, 0.11449201f, -0.02892001f, 0.04712189f, 0.00684368f, -0.05944273f, -0.05863039f, 
    0.00902578f, -0.18218817f, 0.23876111f, 0.09959789f, 0.15543219f, -0.06371278f, -0.04570322f, 0.06773660f, 
    -0.01511976f, -0.03844534f, -0.06030318f, -0.00158314f, -0.12627186f, 0.12356276f, 0.09437046f, 0.00748133f, 
    -0.01905447f, 0.06767615f, -0.05207655f, 0.08753283f, 0.06800123f, -0.01847584f, 0.00693611f, 0.13211635f, 
    -0.11954568f, 0.03702082f, 0.18677634f, -0.10460174f, 0.02041940f, -0.03927697f, -0.12340027f, 0.09089872f, 
    -0.03421960f, -0.10515042f, 0.02405901f, -0.05847633f, 0.06491639f, 0.15480466f, -0.22487128f, 0.19161256f, 
    0.09617128f, 0.02250763f, 0.16980268f, -0.04698132f, 0.00488085f, 0.05612972f, -0.05462968f, -0.00777076f, 
    0.04929458f, 0.01057328f, 0.20420913f, -0.05260233f, -0.00945832f, -0.03442378f, 0.16617402f, 0.05755358f, 
    0.05205580f, 0.11038283f, 0.00832040f, 0.01991810f, 0.06112508f, 0.09373139f, -0.14853013f, -0.10946697f, 
    -0.11902314f, -0.02858938f, 0.03234538f, 0.11261060f, 0.04726387f, 0.05420938f, 0.04313099f, -0.00380014f, 
    -0.02832111f, 0.02262101f, 0.09040284f, 0.03741702f, -0.01550270f, 0.01105701f, 0.00855075f, -0.06032981f, 
    -0.04024170f, 0.11297134f, 0.09878808f, 0.12647143f, 0.02199922f, -0.13239507f, 0.22104599f, 0.20042628f, 
    -0.11929305f, -0.10241374f, 0.05761073f, 0.08343983f, 0.04070698f, 0.01240177f, 0.02356656f, 0.02992469f, 
    -0.18206950f, -0.02133902f, -0.06355809f, -0.01080456f, 0.01090173f, 0.12966116f, 0.19585982f, -0.01788957f, 
    0.05398186f, 0.19302651f, -0.03637966f, 0.14258409f, -0.10207860f, -0.05948621f, 0.16944036f, 0.11646868f, 
    0.04727390f, 0.06164939f, 0.03198236f, -0.08245181f, 0.06986053f, -0.02740556f, -0.07301157f, -0.04654497f, 
    -0.11521553f, -0.42760995f, 0.09211589f, 0.25929990f, 0.08318806f, 0.07794952f, 0.21551012f, -0.16612571f, 
    -0.01077275f, 0.05171468f, 0.04988794f, -0.03027685f, -0.06689837f, -0.06861439f, -0.31269842f, -0.10302816f, 
    -0.13918900f, 0.13743997f, 0.13085251f, -0.13776791f, -0.17636812f, -0.06562565f, 0.04727840f, 0.03515633f, 
    0.28427547f, -0.15756641f, 0.07058125f, 0.03358230f, -0.08019431f, -0.05241313f, 0.16630828f, 0.24509285f, 
    0.04908502f, 0.09451699f, 0.01593434f, 0.15855823f, 0.08978244f, 0.19862308f, -0.02880338f, 0.28504649f, 
    0.24379012f, -0.16781276f, 0.15327026f, -0.05191516f, -0.04660061f, 0.12560940f, 0.07996526f, -0.06882146f, 
    0.05385704f, 0.16488612f, 0.19141436f, 0.07751514f, -0.09256845f, -0.09850249f, 0.21895829f, -0.14642403f, 
    0.19275124f, 0.12333103f, 0.13487028f, 0.11110578f, 0.15636568f, -0.04178436f, -0.13628289f, -0.10215230f, 
    -0.00459420f, 0.08098540f, -0.11219061f, -0.16253664f, -0.14841534f, -0.06718281f, -0.02560329f, -0.17007871f, 
    0.13755177f, 0.16831593f, -0.06866632f, 0.26363608f, 0.14811704f, -0.07107773f, 0.04063737f, -0.05770006f, 
    -0.15398195f, 0.09056149f, -0.03781159f, -0.17284773f, -0.11887733f, -0.38505617f, -0.05782664f, -0.13845982f, 
    -0.06449700f, 0.33821318f, 0.02707555f, -0.04921234f, 0.03062787f, 0.01178821f, 0.13987640f, 0.13485061f, 
    0.23168442f, 0.07756952f, -0.00444322f, 0.25503612f, -0.18305479f, 0.09332911f, -0.06955110f, 0.04549788f, 
    0.29802921f, 0.10355362f, 0.05838496f, 0.03159389f, -0.34298477f, 0.12209949f, -0.05136512f, 0.23769131f, 
    0.09610682f, -0.08042490f, -0.01700996f, -0.12697181f, -0.11440803f, -0.15087454f, -0.11809775f, -0.18476653f, 
    0.18676762f, -0.07057632f, 0.09515570f, 0.14698102f, -0.06523588f, 0.05477375f, -0.06076882f, -0.09571599f, 
    0.00281712f, -0.09169738f, 0.00708926f, 0.08602922f, 0.47607732f, -0.16810913f, -0.21883979f, -0.20146419f, 
    0.04612631f, -0.07600279f, 0.12700099f, -0.00912940f, 0.01697862f, -0.10473853f, -0.02518952f, -0.02003584f, 
    -0.24411321f, -0.23544984f, 0.21854927f, -0.04606815f, -0.07079794f, 0.13597554f, 0.00122463f, -0.03094632f, 
    0.10284106f, -0.07162154f, 0.07021492f, -0.01294764f, 0.10407191f, -0.14872672f, -0.02259146f, -0.00360287f, 
    -0.05565494f, -0.05923716f, -0.09948372f, 0.04201695f, 0.13837421f, 0.09512749f, 0.19579564f, 0.06303775f, 
    0.12055800f, -0.03083337f, -0.18922065f, 0.08484412f, -0.06866745f, -0.05020029f, -0.13810332f, 0.01688899f, 
    -0.29718634f, -0.43986139f, -0.22658327f, -0.16730674f, 0.03787112f, 0.14167245f, -0.26046306f, 0.01026039f, 
    -0.04012268f, -0.12554148f, 0.13344948f, -0.10980695f, -0.17591411f, 0.13361722f, -0.11159704f, -0.25455207f, 
    0.17772663f, 0.21192642f, -0.12784223f, -0.13786598f, -0.22416642f, -0.14293973f, 0.07515340f, 0.11729833f, 
    0.09781683f, -0.02251070f, -0.03322857f, 0.05662236f, -0.38962036f, 0.05235504f, 0.30056056f, -0.05149715f, 
    0.06489678f, 0.09805114f, -0.00205503f, -0.20547670f, -0.04154746f, -0.16582868f, -0.13138080f, -0.07277262f, 
    0.26207915f, -0.20626684f, 0.00832642f, -0.12197421f, -0.08656769f, 0.04939749f, -0.01320873f, -0.05836317f, 
    -0.11317643f, 0.06430101f, -0.14743836f, -0.21537513f, -0.05942564f, -0.18196943f, -0.16446663f, -0.07723055f, 
    0.06750649f, 0.11242503f, -0.09872887f, -0.25521588f, 0.09676448f, -0.03740266f, 0.01797474f, -0.10648234f, 
    0.12608600f, 0.23069206f, -0.49929354f, 0.68782842f, -0.05751910f, 0.13761607f, 0.00198016f, -0.00439555f, 
    0.07251005f, -0.05085450f, 0.07838687f, 0.05643253f, 0.00386443f, 0.05273499f, -0.01013195f, -0.11019098f, 
    0.03020045f, -0.04025711f, -0.11609372f, -0.02799191f, -0.22344528f, -0.05949903f, -0.11864156f, -0.11253105f, 
    0.10759409f, -0.02544196f, 0.00667925f, 0.24948585f, -0.00648295f, -0.09555122f, 0.00909685f, 0.04480069f, 
    0.13079344f, 0.02252995f, 0.10126652f, 0.19807076f, -0.25556353f, -0.08749744f, -0.02124235f, 0.17914887f, 
    0.05423439f, 0.14927524f, 0.18171059f, -0.01019098f, 0.05817698f, -0.02371769f, 0.11356194f, 0.13109337f, 
    0.16439626f, -0.07193103f, 0.09703495f, -0.15773050f, -0.21195939f, 0.04370009f, -0.01053493f, 0.01178653f, 
    -0.04250249f, 0.02733970f, 0.09803273f, 0.01958504f, -0.32664692f, -0.16506444f, 0.24250574f, 0.37824842f, 
    0.08496770f, 0.16814241f, 0.03264968f, -0.11964046f, 0.10398299f, -0.10902071f, -0.12988308f, -0.03975744f, 
    0.46871617f, -0.12424374f, 0.29606739f, 0.37762448f, 0.06603473f, -0.09297886f, 0.14575917f, 0.02001409f, 
    0.15490906f, -0.11954430f, 0.09204680f, 0.26087716f, -0.05818586f, -0.08995450f, -0.04873619f, 0.16726750f, 
    -0.11362223f, 0.16112801f, 0.06493846f, -0.08920839f, -0.15819126f, 0.00938607f, -0.10905939f, -0.07492320f, 
    0.17447211f, 0.03438010f, 0.11463613f, -0.15912963f, -0.03158432f, -0.14131564f, 0.01309660f, -0.02427170f, 
    -0.06853420f, -0.10482490f, -0.12875055f, -0.24571970f, 0.08870406f, 0.07078297f, 0.03649119f, 0.13881573f, 
    0.17294285f, -0.03696952f, -0.12255933f, -0.15372314f, 0.13144541f, -0.02556439f, 0.09835789f, -0.07177580f, 
    -0.10019547f, -0.10310640f, -0.05490554f, 0.04679151f, 0.01881182f, 0.05600066f, 0.00622807f, -0.07072319f, 
    0.01576191f, 0.06898353f, -0.00648460f, 0.15780915f, 0.07107597f, 0.08575182f, -0.00165756f, -0.07001284f, 
    0.05392509f, -0.11176241f, -0.10693166f, -0.00936503f, 0.12086153f, 0.15702401f, 0.11335403f, 0.21075395f, 
    0.22719441f, 0.01087683f, 0.00318415f, 0.24476556f, 0.09964102f, -0.07841717f, 0.00488987f, -0.00985163f, 
    0.07503687f, 0.05594720f, 0.10685617f, 0.03749303f, -0.13934176f, -0.41661447f, 0.00637429f, -0.12953492f, 
    0.14571615f, 0.27121583f, 0.08478491f, -0.02091606f, 0.06904484f, -0.11991809f, -0.04860035f, 0.05970355f, 
    0.01391259f, 0.02549825f, 0.04210581f, -0.05900471f, -0.00865276f, 0.00382946f, -0.00464065f, -0.04166563f, 
    -0.05010138f, -0.01450471f, 0.02816951f, -0.03242370f, -0.03503668f, -0.01385620f, -0.03875834f, -0.03340871f, 
    0.01943660f, 0.03822204f, -0.01297866f, -0.02579386f, 0.04651725f, -0.04617957f, 0.03525641f, 0.02141100f, 
    -0.03365130f, -0.03433497f, -0.02536932f, 0.02264196f, -0.05793616f, -0.05329171f, -0.01665704f, 0.01637601f, 
    -0.03429383f, 0.02434635f, -0.01041493f, 0.01749472f, 0.00474905f, -0.01671819f, -0.05452716f, 0.03069894f, 
    0.02149243f, 0.04455889f, 0.00161304f, 0.01092498f, 0.02214379f, -0.02035380f, -0.00628874f, -0.02992029f, 
    0.02476990f, 0.01090208f, 0.01204141f, 0.01090681f, -0.05035766f, -0.00829967f, 0.02297468f, 0.01035102f, 
    -0.03418484f, 0.00777241f, -0.05466262f, -0.02778119f, 0.02098702f, -0.02641376f, -0.00422147f, -0.05160542f, 
    -0.00055879f, 0.03355518f, 0.01891917f, 0.02243070f, -0.01058270f, -0.04318709f, -0.05449797f, 0.00576077f, 
    -0.00892975f, -0.02450362f, -0.02066488f, 0.01718200f, -0.05069559f, -0.02549354f, -0.04520150f, -0.04156771f, 
    -0.04862928f, 0.00498530f, 0.04260843f, -0.05020246f, 0.00013585f, -0.00701961f, -0.05002558f, -0.00511963f, 
    0.00880640f, -0.02945334f, -0.03169636f, 0.00627128f, -0.04991633f, -0.01421061f, -0.01189447f, -0.00609285f, 
    0.00599799f, 0.02484273f, 0.01374814f, 0.03392998f, 0.02367382f, -0.01054353f, -0.03218970f, 0.00412166f, 
    0.03898007f, 0.03646017f, 0.04025122f, 0.02685217f, 0.02456095f, 0.02848502f, -0.00125831f, 0.00718511f, 
    -0.04876516f, -0.02985930f, 0.01759811f, 0.03248716f, 0.04000921f, -0.03168522f, -0.04213257f, -0.05050462f, 
    -0.00853775f, 0.02194675f, 0.01210048f, -0.00120579f, -0.01772769f, 0.03724963f, -0.00263129f, 0.00340857f, 
    -0.01451578f, 0.04848839f, 0.03047770f, -0.04359402f, -0.01024600f, -0.01347556f, 0.00931858f, -0.02764595f, 
    0.00219786f, -0.05855938f, -0.04891117f, 0.03357411f, -0.05494357f, -0.03173852f, -0.00727652f, -0.04917124f, 
    0.01274983f, 0.00640106f, -0.04016269f, -0.03844400f, -0.02657348f, -0.00589693f, 0.01964486f, 0.00883398f, 
    0.01839706f, 0.02325688f, -0.03932124f, -0.05327693f, 0.02354557f, -0.05746622f, -0.01029154f, 0.02393438f, 
    -0.01488442f, 0.02618536f, 0.03779054f, 0.03417917f, 0.03096583f, 0.00559272f, 0.01134662f, -0.04442960f, 
    0.02812460f, -0.01921118f, 0.04070334f, 0.01717449f, 0.00045116f, -0.04704610f, -0.03991614f, -0.00492397f, 
    0.02960451f, 0.03335847f, 0.04430492f, -0.02966176f, -0.02691588f, 0.03172418f, 0.03998323f, 0.02557134f, 
    -0.01445818f, 0.02836586f, 0.01206798f, 0.02897614f, -0.02525891f, 0.00990655f, 0.04266946f, 0.00884849f, 
    -0.03376294f, 0.03699383f, -0.03219437f, 0.00376764f, -0.03497310f, -0.02858618f, -0.01494733f, -0.02090459f, 
    -0.00400759f, 0.03916091f, -0.05380985f, 0.04227624f, 0.04543299f, -0.04628313f, -0.03450633f, -0.00765207f, 
    -0.01319591f, -0.02960925f, -0.03802568f, -0.02538899f, -0.04539591f, -0.02375159f, -0.00825536f, -0.04723711f, 
    -0.03952241f, 0.02976871f, -0.00316251f, -0.00340191f, -0.01511503f, -0.04638146f, -0.02983896f, 0.02064861f, 
    -0.02761604f, 0.02950650f, -0.04060472f, 0.02670905f, 0.02079493f, -0.02268846f, -0.03781158f, 0.00578642f, 
    0.03152660f, -0.04544149f, -0.02148296f, 0.01941801f, 0.03726421f, -0.00061986f, 0.00205794f, 0.01267545f, 
    0.00277046f, -0.05793697f, 0.03036419f, 0.03235085f, -0.05396226f, -0.05297459f, -0.02630926f, -0.05221765f, 
    -0.01843249f, 0.03484707f, 0.01877279f, 0.04130565f, -0.00912623f, -0.05886848f, 0.00273131f, 0.02625749f, 
    0.02114161f, 0.00649808f, 0.04391081f, 0.00554014f, -0.00142366f, 0.04368289f, -0.04541046f, -0.05284338f, 
    -0.04681388f, -0.00127318f, 0.01841394f, 0.00286599f, -0.01934170f, 0.04304184f, -0.03537401f, 0.02783020f, 
    -0.01356332f, 0.04250571f, -0.03088091f, -0.04408285f, -0.03680279f, 0.00090320f, -0.02124749f, 0.03814669f, 
    -0.05535574f, -0.02744296f, -0.00385525f, 0.03528721f, 0.04482875f, -0.02754905f, 0.03928834f, 0.00474550f, 
    -0.01728333f, -0.01113271f, -0.02634673f, -0.04009187f, 0.03396858f, -0.01491459f, -0.00925404f, 0.03497119f, 
    0.01983711f, -0.03699648f, 0.04226130f, 0.03668654f, 0.00113097f, 0.00301241f, -0.06290018f, 0.03208338f, 
    0.01824178f, -0.03328441f, -0.00470020f, -0.00698771f, 0.03354218f, -0.03870104f, -0.01469729f, 0.01707090f, 
    0.03925594f, 0.00641752f, -0.02337309f, 0.02522014f, 0.03093620f, 0.02190883f, 0.03678162f, -0.05517413f, 
    0.01019989f, -0.04465586f, -0.01636254f, -0.02132682f, -0.02812169f, -0.03795785f, 0.03629809f, 0.01782284f, 
    0.03918390f, -0.01815850f, -0.04422927f, 0.01957807f, -0.00951005f, 0.03194055f, -0.01995699f, -0.02014954f, 
    0.03092115f, -0.03683853f, -0.05554477f, 0.01224872f, -0.04552518f, -0.04034775f, -0.05216483f, 0.01771530f, 
    0.04409119f, 0.02924060f, -0.01309385f, 0.03420398f, -0.02923794f, -0.04786005f, -0.03695262f, 0.02998474f, 
    0.03438671f, 0.04640588f, -0.04777438f, -0.03355223f, 0.01696038f, 0.01183620f, 0.01533820f, -0.03338337f, 
    -0.05135775f, -0.06102457f, 0.00850243f, -0.01015618f, 0.03101745f, -0.04486233f, -0.00686907f, 0.01504333f, 
    -0.04646316f, -0.02676304f, -0.04731220f, -0.01487429f, 0.01794161f, -0.03006751f, 0.01300640f, 0.04827374f, 
    0.01132610f, -0.03795632f, -0.03309382f, -0.02294535f, -0.03994938f, 0.02088645f, -0.02789626f, -0.04473826f, 
    -0.02205474f, -0.01343890f, -0.00298357f, 0.01599303f, 0.01450089f, -0.03855572f, -0.05737223f, -0.00675855f, 
    -0.03169214f, 0.02065570f, -0.00026280f, -0.04119198f, 0.00306378f, -0.03773382f, -0.01112673f, -0.02708772f, 
    -0.00254424f, 0.02507055f, -0.05722209f, -0.02304091f, -0.00520151f, -0.03934946f, -0.05863620f, -0.04540273f, 
    -0.01452346f, 0.03324637f, -0.04817088f, -0.00396035f, 0.00834953f, 0.01512480f, -0.03377241f, -0.02814908f, 
    0.02166962f, 0.01703965f, 0.00675063f, 0.00575776f, -0.02045600f, -0.03494261f, -0.03385783f, 0.01059019f, 
    0.02832551f, -0.00319849f, -0.02244932f, 0.00253267f, 0.01966494f, -0.03774459f, 0.01935880f, -0.02347537f, 
    0.02820737f, -0.01087846f, 0.03143494f, -0.00046043f, 0.02315219f, 0.04406726f, -0.03920080f, 0.03997263f, 
    -0.01276035f, -0.00470784f, -0.03489815f, 0.03743862f, -0.01479784f, -0.05054095f, -0.03067699f, 0.04648133f, 
    0.04209001f, 0.05184038f, -0.04642742f, -0.01364271f, 0.04910357f, -0.01294007f, 0.01824360f, -0.05832866f, 
    0.03180580f, -0.03534704f, -0.02349339f, 0.01459630f, 0.00921274f, 0.04704750f, -0.03917117f, 0.03123111f, 
    -0.05609009f, -0.02881152f, -0.03655309f, 0.01533690f, -0.04126324f, -0.01770868f, -0.03181415f, 0.01199599f, 
    -0.03910191f, -0.04961510f, -0.04240562f, 0.01679125f, -0.03975004f, 0.04685118f, -0.01501022f, -0.04045102f, 
    0.01375041f, 0.00384457f, 0.02663059f, -0.04980930f, -0.03763843f, -0.03458386f, -0.04217886f, 0.02225701f, 
    -0.04298990f, -0.04343843f, -0.03727026f, 0.02430558f, 0.02863594f, -0.03806384f, -0.02243813f, -0.01325265f, 
    0.02215623f, 0.04313614f, -0.02621542f, -0.00284273f, 0.02629925f, 0.04028207f, 0.00728144f, 0.01746360f, 
    -0.02563952f, -0.00842683f, 0.01234697f, 0.02779442f, -0.01180927f, -0.00454963f, -0.05425796f, -0.04692112f, 
    -0.01036060f, -0.01305573f, 0.03498956f, 0.04205352f, 0.01803843f, 0.04762510f, -0.05776729f, -0.02557352f, 
    -0.00782545f, 0.00846658f, -0.01606242f, 0.02096704f, 0.01406413f, -0.00595954f, -0.01534618f, -0.00008067f, 
    -0.01955329f, 0.00318921f, -0.04075800f, -0.00186153f, -0.02618201f, -0.03530248f, -0.04502902f, -0.00455722f, 
    0.01710985f, 0.03007742f, -0.05047071f, 0.02706126f, -0.00221755f, -0.05765722f, -0.00855006f, -0.00102539f, 
    0.01402774f, -0.05567532f, 0.00615166f, 0.03538084f, 0.00246939f, 0.01266573f, 0.03474114f, -0.05581133f, 
    -0.02555152f, -0.03426023f, -0.00586846f, 0.02340783f, -0.01213454f, -0.01101538f, 0.02136794f, -0.04869467f, 
    -0.01736360f, -0.04940595f, 0.03287932f, 0.03135845f, -0.02523198f, -0.03642517f, 0.00627668f, 0.00851056f, 
    -0.01095142f, 0.00864736f, -0.02435693f, -0.04811960f, -0.03268124f, 0.02426132f, -0.04069088f, -0.00644208f, 
    0.00773557f, -0.04479982f, -0.02212891f, 0.00282605f, 0.00051943f, -0.00401830f, 0.04054131f, -0.05420291f, 
    -0.04750635f, 0.02539933f, 0.01688574f, -0.00003295f, 0.00241949f, 0.00260959f, -0.02072494f, 0.02216229f, 
    -0.04161534f, -0.00959716f, -0.02331319f, -0.02556952f, 0.05206355f, -0.01200696f, -0.01999481f, -0.00213054f, 
    -0.03434103f, -0.01362769f, 0.00240575f, -0.05868954f, -0.01139421f, -0.05718740f, -0.05541340f, -0.00194820f, 
    -0.03016572f, -0.03968499f, 0.03389947f, -0.04970428f, -0.00509565f, -0.00779949f, 0.00539104f, -0.05098334f, 
    -0.04225124f, 0.03335325f, -0.03955970f, -0.05696822f, -0.05824140f, -0.04926977f, 0.00908747f, -0.05373821f, 
    0.04483998f, 0.04021816f, 0.03961909f, 0.00842966f, 0.02231610f, -0.04703817f, -0.03970957f, 0.03268220f, 
    0.04644296f, 0.02761313f, 0.01561167f, -0.00142500f, 0.04105030f, 0.01191479f, -0.00246926f, -0.01065555f, 
    0.02791118f, 0.00328775f, -0.01642890f, -0.02162034f, -0.00499167f, -0.03453753f, 0.00982182f, 0.01094287f, 
    -0.04990686f, -0.01398416f, -0.00642409f, 0.00132623f, -0.04533301f, -0.05291528f, 0.02867357f, -0.00895599f, 
    -0.03694934f, -0.00616700f, -0.05395600f, -0.00787234f, -0.03241078f, 0.01461224f, -0.03596697f, 0.05351615f, 
    -0.02583450f, 0.00395901f, -0.02405982f, 0.03209467f, -0.00083165f, 0.01324419f, -0.01854919f, 0.04971856f, 
    -0.03992057f, -0.04530812f, 0.03760078f, -0.01747636f, -0.05193131f, -0.00357673f, 0.02754427f, 0.03323592f, 
    0.03239347f, -0.04790934f, -0.04935016f, 0.02680441f, 0.02683157f, -0.01907427f, -0.05055841f, 0.02248641f, 
    0.04030742f, -0.04959028f, -0.04571746f, 0.00344818f, 0.01108365f, 0.01790239f, -0.02179970f, -0.02676086f, 
    0.04044748f, -0.01299157f, -0.02431754f, 0.02685591f, -0.00129910f, 0.04161674f, 0.02898112f, -0.01213979f, 
    -0.03980711f, 0.03993756f, 0.00872540f, 0.03950961f, 0.03551662f, -0.03691662f, -0.03165038f, 0.03246686f, 
    0.00554730f, 0.02801929f, 0.00388916f, 0.01458463f, 0.03674410f, -0.03069014f, -0.00417325f, -0.00638401f, 
    -0.00470444f, -0.02435900f, 0.01256070f, -0.04108040f, -0.00603338f, -0.01847963f, 0.03491987f, -0.03265141f, 
    -0.04048870f, 0.02057890f, 0.04982075f, 0.00065913f, -0.01314129f, 0.02229534f, -0.04132618f, 0.01734187f, 
    -0.00850618f, 0.03718389f, -0.01899197f, 0.02672379f, -0.04782164f, 0.02881731f, -0.02290548f, 0.01425510f, 
    0.02805316f, -0.00050276f, 0.00876980f, -0.05477891f, -0.04048263f, 0.03470979f, -0.05734840f, 0.00771029f, 
    0.04818970f, -0.00902436f, 0.00344873f, 0.00562360f, 0.01731050f, 0.04014345f, -0.05664849f, -0.03404198f, 
    -0.02487453f, -0.03415843f, -0.00760006f, 0.02106456f, -0.05796155f, 0.03941513f, -0.02389439f, -0.02501999f, 
    -0.04853685f, -0.00878687f, 0.02674227f, -0.03083824f, -0.00845306f, 0.04636509f, 0.04529069f, 0.00040421f, 
    -0.02745526f, -0.05114919f, -0.00589346f, -0.00333805f, -0.01637521f, 0.01825812f, 0.01396672f, -0.01264171f, 
    -0.02202771f, -0.02303657f, -0.00397116f, 0.00488884f, -0.05365456f, 0.01215154f, 0.02169859f, 0.00971779f, 
    0.02448792f, -0.00974717f, 0.02482804f, -0.02063284f, -0.02983954f, -0.03881907f, -0.02688848f, 0.01737616f, 
    -0.04527386f, -0.01065387f, 0.03892854f, 0.04396009f, 0.00221740f, -0.00734438f, -0.04252927f, 0.03382289f, 
    0.03005362f, -0.02071283f, -0.03505183f, -0.00010225f, 0.01125670f, 0.02459348f, -0.02549213f, -0.03063162f, 
    0.03516605f, -0.04462314f, -0.03667872f, -0.00683845f, 0.02381511f, 0.02943599f, 0.00980432f, 0.02996043f, 
    -0.02458798f, -0.01503562f, 0.01873423f, 0.00959604f, 0.04623975f, 0.02859640f, -0.04950661f, -0.01128574f, 
    -0.00948367f, 0.02304222f, 0.03106724f, 0.02848785f, 0.03493956f, 0.02313240f, -0.01805044f, 0.01959772f, 
    -0.00733045f, 0.03537200f, 0.03047732f, 0.00277040f, -0.04341341f, 0.03846337f, -0.03150769f, -0.03267160f, 
    -0.05017244f, 0.02599394f, -0.03815681f, 0.00040803f, 0.03630403f, -0.03403687f, 0.03526037f, -0.05115046f, 
    -0.03001683f, 0.03282934f, 0.01530574f, -0.02649685f, 0.03364431f, 0.01107148f, -0.04987586f, 0.03687569f, 
    -0.05166035f, 0.02118598f, -0.00673296f, -0.00332706f, -0.03932047f, -0.03488774f, 0.04204676f, -0.02349368f, 
    0.05359741f, 0.02258108f, -0.01462315f, -0.01838201f, -0.05513531f, -0.03436390f, 0.02616389f, 0.03655475f, 
    -0.03094953f, -0.00865225f, 0.01228678f, -0.04249942f, -0.05587149f, -0.03001168f, 0.01016252f, -0.02396196f, 
    0.02563940f, -0.05339223f, -0.02727763f, 0.01240236f, -0.03087293f, -0.03203294f, 0.03915219f, -0.04489093f, 
    0.04473085f, 0.03983627f, -0.01970079f, -0.03885731f, 0.04288223f, -0.00402333f, -0.01345261f, -0.03841135f, 
    0.00783744f, -0.00654974f, 0.03239388f, -0.02456761f, -0.05218539f, 0.02370589f, -0.02513340f, 0.02006345f, 
    0.04413084f, -0.01721628f, 0.00275864f, -0.05164365f, 0.00472175f, 0.01736514f, -0.03223486f, 0.00949120f, 
    -0.05044319f, 0.04179313f, 0.00556176f, 0.03618662f, -0.03195248f, 0.00057728f, -0.03327220f, -0.04474419f, 
    -0.05403375f, 0.03107185f, -0.04331104f, -0.04871048f, -0.04727254f, 0.01157607f, -0.03022668f, -0.01393304f, 
    -0.02732572f, 0.04928670f, -0.04924851f, -0.05080719f, -0.03987264f, 0.03256646f, -0.01044856f, -0.05415425f, 
    -0.00363807f, 0.00664803f, -0.03909828f, -0.04460875f, -0.00334028f, -0.04650820f, -0.03439059f, -0.03033758f, 
    0.01985850f, -0.04071208f, -0.03546393f, 0.03148651f, -0.02084345f, -0.04467217f, 0.01932585f, -0.04472516f, 
    -0.00186677f, 0.02730091f, 0.01078633f, 0.00480064f, -0.04417637f, -0.04827783f, 0.01806499f, -0.02749570f, 
    0.02930972f, 0.03359730f, 0.03108308f, 0.00166818f, 0.00084182f, -0.01243039f, -0.03112800f, 0.01213391f, 
    0.03436943f, -0.00555540f, -0.05322922f, 0.01685482f, 0.00389780f, 0.03396912f, -0.03512536f, 0.03385163f, 
    0.03187189f, 0.01686454f, 0.03827626f, 0.02700409f, 0.04505838f, -0.03672305f, 0.01827071f, -0.01420986f, 
    0.04209936f, 0.00466445f, -0.00427617f, 0.04228193f, -0.04543252f, 0.03137404f, -0.01465810f, 0.02335110f, 
    -0.01808353f, 0.01883304f, 0.03898469f, -0.01250441f, 0.00335696f, -0.03497420f, -0.04604821f, 0.02182962f, 
    -0.02920733f, 0.03878601f, 0.01135696f, -0.04554160f, -0.02510756f, -0.03475165f, 0.02010714f, -0.01705820f, 
    0.00806632f, 0.00045535f, -0.01597703f, -0.04244417f, -0.00202066f, -0.01892988f, -0.01966083f, 0.01945150f, 
    -0.01699979f, 0.04472044f, 0.00784173f, 0.03045279f, -0.01951310f, -0.03038334f, -0.01181913f, -0.04647645f, 
    -0.01502913f, -0.00303949f, 0.02094056f, -0.02567554f, 0.01203814f, -0.00066803f, -0.05329825f, -0.01175782f, 
    0.02858796f, -0.01043905f, -0.02932458f, -0.02849501f, 0.04537910f, -0.02520441f, 0.03397606f, -0.04969385f, 
    -0.02326010f, -0.04984170f, -0.00040876f, 0.01490848f, 0.02382066f, 0.03320013f, 0.01180679f, 0.02276093f, 
    0.02544622f, 0.03251199f, -0.02225597f, 0.01970361f, 0.00355330f, 0.01300058f, -0.04449213f, 0.00459882f, 
    -0.01422911f, 0.00934280f, -0.04877492f, 0.01655858f, 0.00777147f, -0.03889764f, -0.01362002f, -0.00339897f, 
    0.01759508f, -0.05589173f, -0.05137210f, -0.02712589f, 0.03585409f, -0.00091485f, -0.04800371f, 0.01051547f, 
    0.04069481f, -0.02934814f, 0.02845605f, 0.00045099f, -0.02125557f, 0.03846082f, -0.05022461f, 0.03077017f, 
    0.03833726f, 0.02783021f, 0.01849271f, -0.03783676f, -0.01536051f, 0.00942808f, -0.02110889f, 0.02388796f, 
    -0.00561788f, 0.01133960f, -0.01531728f, 0.01268630f, -0.03077111f, -0.01380835f, -0.01344672f, 0.01851425f, 
    -0.01665182f, 0.02856945f, -0.00343618f, -0.01679482f, -0.00869706f, -0.03256754f, -0.05359998f, -0.00514325f, 
    0.04938003f, 0.00625298f, 0.00420728f, 0.03477162f, -0.03901818f, -0.00888774f, 0.03926236f, -0.01838753f, 
    0.00175683f, -0.01819923f, -0.02076167f, -0.03605346f, -0.03454337f, -0.02772449f, 0.04096369f, 0.04721401f, 
    -0.01576597f, 0.03138572f, 0.00043835f, -0.02182471f, -0.01060006f, 0.03626177f, -0.00338128f, 0.03935212f, 
    -0.04243465f, 0.02286300f, -0.03920728f, 0.03506429f, 0.03753454f, -0.05510500f, -0.05847737f, -0.04265690f, 
    0.00939182f, -0.04198933f, -0.00914585f, -0.04356698f, -0.04606052f, -0.01798391f, 0.00216898f, -0.01652399f, 
    -0.47033408f, -0.03792976f, 0.06333858f, -0.01562006f, -0.07690431f, -0.03170663f, -0.05441354f, 0.10642163f, 
    -0.01103661f, 0.00613714f, -0.09624673f, -0.01970762f, 0.02236290f, 0.00758714f, 0.26981270f, -0.08121604f, 
    0.17332253f, 0.07876084f, -0.03411233f, -0.10852632f, -0.04566551f, 0.06588187f, -0.01080229f, -0.03175395f, 
    -0.12798060f, -0.08565789f, -0.00489844f, -0.01389074f, 0.00850442f, 0.08620227f, -0.05590222f, 0.02781741f, 
    -0.12794800f, -0.01270732f, 0.00482670f, 0.02695270f, -0.14776552f, 0.23452744f, -0.32431212f, 0.04152311f, 
    0.02541061f, 0.07230479f, 0.06398582f, 0.13564898f, 0.03787614f, 0.08665422f, -0.03897846f, -0.05099807f, 
    -0.65603966f, -0.13900530f, 0.23113644f, -0.15877469f, 0.07956310f, 0.19253394f, -0.00086092f, 0.09568059f, 
    0.11100927f, -0.01101575f, -0.09394383f, 0.13204983f, -0.15869033f, 0.01063772f, 0.08103015f, -0.06024654f, 
    0.06862698f, 0.14197850f, 0.02829061f, -0.01204785f, -0.01284580f, 0.06692266f, -0.11846635f, 0.15524150f, 
    0.17995176f, 0.24858874f, 0.07084907f, -0.01118083f, -0.01645106f, -0.05008122f, 0.00955182f, 0.00261647f, 
    0.03060901f, -0.07435209f, 0.10106515f, 0.02602833f, -0.05298623f, -0.19067720f, -0.03010405f, -0.13516966f, 
    -0.03700267f, -0.06408831f, -0.02440361f, 0.08466084f, 0.04300021f, 0.05363470f, -0.11578508f, 0.07269214f, 
    -0.10490646f, 0.19537766f, 0.09453671f, -0.00260205f, -0.04035930f, -0.06263673f, 0.15597197f, -0.12359399f, 
    0.02019248f, 0.09122724f, 0.04273197f, 0.07932982f, -0.06555224f, 0.04534861f, 0.19442774f, 0.16771837f, 
    -0.10282551f, -0.02659722f, -0.05802814f, -0.01504890f, 0.11501388f, -0.10968086f, 0.34248915f, -0.33646944f, 
    0.00777617f, 0.31611413f, -0.53225833f, 0.17306262f, -0.02874418f, 0.08884599f, -0.01597463f, -0.03475737f, 
    0.04289312f, 0.06547468f, -0.08315232f, -0.00370016f, 0.07016941f, 0.04935094f, -0.09264430f, 0.06853469f, 
    -0.02132147f, -0.03617060f, 0.16715136f, 0.00836424f, 0.04846697f, 0.07142565f, 0.05203812f, 0.08860073f, 
    0.13231848f, 0.04254272f, 0.02181115f, -0.04382585f, 0.14068133f, -0.05263593f, 0.06417693f, -0.05507072f, 
    0.12458892f, 0.06651595f, -0.01007845f, -0.13368294f, -0.10335762f, -0.06268469f, -0.01517338f, 0.19240443f, 
    -0.09070472f, 0.03388664f, -0.12751798f, 0.09958357f, -0.14248316f, -0.08696391f, 0.12741189f, -0.02154250f, 
    0.25489336f, 0.10000017f, 0.32827336f, -0.09687825f, -0.08394017f, -0.12962793f, -0.08247437f, -0.06941096f, 
    0.01613372f, -0.03754473f, 0.08487532f, 0.12686749f, 0.04137457f, -0.31739318f, 0.04518311f, -0.11309289f, 
    -0.07770131f, 0.22137982f, 0.12044241f, 0.28154778f, 0.00608805f, -0.02139721f, 0.00871394f, -0.06999685f, 
    -0.07283713f, -0.10598116f, 0.15193574f, 0.22556071f, 0.03199843f, 0.04331099f, -0.12946464f, 0.06727757f, 
    0.00380232f, 0.03595484f, -0.00160508f, -0.00369924f, 0.11817122f, 0.06940681f, -0.69096303f, 0.05686589f, 
    0.04488406f, -0.05337184f, 0.11874370f, 0.09950599f, 0.02405969f, 0.15781744f, -0.10859997f, 0.01283266f, 
    0.23535617f, 0.09834341f, -0.06581877f, -0.18605459f, -0.07809682f, -0.20441182f, 0.11208900f, 0.03872511f, 
    0.10993628f, 0.01695636f, 0.10214614f, -0.05265032f, -0.02733301f, -0.09192165f, 0.02575296f, -0.00712876f, 
    0.06435589f, -0.00253691f, 0.11065718f, -0.02122777f, 0.09602372f, -0.00640550f, -0.02598891f, -0.04950947f, 
    -0.15205908f, 0.07433135f, -0.02834307f, -0.08189142f, 0.02334864f, -0.08205200f, 0.00026084f, -0.05757209f, 
    0.02398175f, -0.04317828f, 0.04416470f, 0.04863546f, -0.04854953f, 0.06592836f, 0.02054485f, -0.10419939f, 
    0.00737890f, 0.04236574f, -0.08710802f, 0.06220191f, 0.03320394f, 0.07828610f, -0.04264983f, 0.18650837f, 
    -0.02905667f, 0.03291672f, 0.05710117f, 0.00036410f, 0.05646588f, 0.01938271f, -0.10834023f, -0.06315312f, 
    0.16953900f, -0.21629964f, -0.01664626f, 0.03200656f, 0.21039939f, 0.30972680f, -0.15862934f, 0.06950451f, 
    0.09843284f, 0.06002743f, 0.13983053f, -0.08642714f, 0.07013751f, 0.01455113f, -0.01293226f, 0.01933004f, 
    -0.18626747f, 0.08566893f, 0.04642654f, -0.29219967f, -0.04445018f, -0.08269446f, 0.12928441f, 0.12107331f, 
    0.13514556f, 0.03601412f, -0.02676609f, 0.00128894f, 0.14236443f, 0.04472056f, -0.03441788f, -0.04181340f, 
    0.03343690f, -0.01819671f, 0.03468264f, 0.04719107f, 0.06485821f, -0.07722202f, -0.00803010f, 0.03667372f, 
    0.09286750f, 0.09807449f, 0.10219810f, -0.00472011f, 0.05092999f, 0.00990247f, 0.00003802f, -0.08485428f, 
    0.11979352f, 0.10441402f, 0.04940687f, 0.01226238f, 0.16581632f, 0.06559473f, 0.15256597f, 0.01551733f, 
    -0.11213718f, -0.13107894f, 0.09907104f, -0.11417457f, 0.05296994f, 0.00366326f, 0.16401903f, 0.00329221f, 
    -0.07482477f, 0.05811188f, -0.05221050f, -0.06274151f, -0.10018989f, 0.07393786f, 0.14973980f, -0.08062816f, 
    -0.01691766f, 0.11781514f, -0.15088028f, 0.09251349f, 0.12105449f, -0.07949375f, 0.31441769f, 0.13684624f, 
    0.03272807f, 0.07601048f, 0.02326705f, -0.07868117f, 0.15969643f, -0.01725480f, -0.13837555f, -0.02338601f, 
    -0.07774151f, -0.19880807f, 0.17334171f, 0.28420684f, 0.06634560f, 0.00261240f, 0.12238134f, -0.04680035f, 
    -0.08707727f, -0.01761825f, 0.22675064f, -0.08073195f, -0.08982790f, 0.02812649f, -0.18503566f, 0.07573628f, 
    -0.07142290f, -0.02519073f, 0.09656758f, -0.02809177f, -0.04716791f, 0.08863398f, 0.09010423f, -0.10376640f, 
    0.02996238f, 0.00648685f, -0.04301996f, 0.01386891f, -0.03552157f, -0.04429084f, -0.00441662f, -0.03355255f, 
    -0.00180851f, 0.01920482f, -0.06069703f, 0.00913195f, 0.00318020f, 0.02115771f, -0.05648242f, -0.00168132f, 
    -0.05520635f, 0.02379299f, -0.03992464f, -0.02444160f, -0.04173196f, -0.02085324f, 0.01760130f, 0.02193440f, 
    0.01155104f, -0.05022711f, -0.03323577f, 0.03900610f, -0.03496357f, 0.00251442f, -0.03066276f, -0.01707128f, 
    0.00165668f, -0.04020662f, -0.02925397f, -0.00738264f, -0.03052875f, -0.03499058f, 0.01005925f, -0.00221546f, 
    0.02927875f, 0.03809534f, -0.04948777f, -0.05739868f, -0.00234878f, -0.03903279f, 0.00237277f, 0.04328831f, 
    -0.02739240f, 0.01634596f, -0.00108541f, 0.00565324f, -0.05524164f, -0.03193644f, 0.01094793f, 0.03810209f, 
    -0.05862984f, 0.00082563f, -0.01282480f, -0.05586078f, -0.00966047f, -0.05184361f, 0.00923190f, -0.04880808f, 
    -0.00260693f, 0.02637559f, 0.02805387f, -0.01123498f, -0.02043713f, -0.05976488f, -0.00533495f, 0.03179216f, 
    -0.00475019f, -0.01047928f, -0.03121207f, 0.01685172f, 0.03779786f, -0.01013558f, 0.02351944f, -0.02824640f, 
    -0.00243707f, 0.01114908f, 0.01418424f, 0.00860213f, 0.03706717f, 0.00026385f, -0.01965217f, -0.02552059f, 
    -0.01811574f, -0.00298292f, -0.05376334f, -0.03986033f, -0.00580515f, 0.02336409f, -0.05765019f, 0.00360231f, 
    -0.05644378f, -0.00614198f, 0.02282205f, 0.02765103f, 0.02100840f, -0.01465892f, 0.02394030f, 0.01765435f, 
    -0.03754275f, 0.02822779f, -0.01028767f, 0.00012448f, -0.02297688f, -0.03106724f, 0.04379885f, -0.01029261f, 
    0.03355704f, 0.02044100f, -0.03851683f, -0.02373322f, -0.02238502f, -0.04189912f, -0.03977591f, 0.03969893f, 
    -0.04889868f, -0.02784608f, -0.05413290f, -0.02183280f, -0.04610179f, -0.02592624f, 0.00945750f, 0.02385943f, 
    -0.05863746f, 0.03640379f, -0.01871780f, -0.02680079f, 0.00313325f, -0.04431367f, -0.00164203f, -0.03960615f, 
    0.03236468f, 0.02453068f, 0.01950265f, -0.00409967f, 0.03987363f, 0.02580839f, -0.01472184f, 0.03504836f, 
    -0.02064565f, 0.02163071f, -0.01690144f, 0.02750108f, -0.01821034f, 0.01129665f, -0.04790545f, 0.02613319f, 
    -0.04111446f, 0.03659298f, -0.04264803f, -0.00400225f, 0.01686472f, -0.01166035f, 0.00050641f, 0.04524922f, 
    0.01680578f, -0.01471789f, -0.05581201f, -0.04709119f, -0.05555942f, -0.05150418f, 0.00278130f, -0.01714854f, 
    -0.04623143f, -0.04437501f, -0.01381678f, -0.03002437f, -0.00605706f, -0.03271302f, 0.03254388f, 0.03133763f, 
    0.00736238f, 0.03240812f, -0.03661755f, -0.04580192f, -0.00555548f, -0.02981188f, 0.01755105f, 0.03983006f, 
    -0.00360387f, -0.01915258f, 0.01796603f, -0.05910889f, 0.04196581f, -0.01118048f, -0.00659655f, -0.01708223f, 
    0.02902351f, -0.03139997f, 0.04087102f, 0.01706683f, -0.05041803f, 0.04501925f, 0.04118992f, 0.03278186f, 
    0.00468152f, 0.03195155f, -0.05179012f, 0.02871068f, -0.01555627f, -0.05336910f, -0.03313807f, -0.03536931f, 
    0.00399941f, 0.00129428f, -0.00624084f, -0.01768786f, -0.00102228f, -0.01093884f, -0.05514061f, -0.02711585f, 
    0.02767817f, -0.04224400f, -0.00076305f, -0.01378953f, 0.04030188f, 0.02255663f, 0.03734082f, 0.02875684f, 
    0.03683604f, -0.02444529f, -0.00333049f, -0.04430265f, -0.00384051f, -0.03982233f, 0.00314831f, -0.00562954f, 
    -0.03518398f, 0.00750762f, -0.01626251f, 0.04284454f, 0.04393541f, -0.05045671f, -0.00165244f, -0.00163399f, 
    -0.00699131f, -0.01257671f, 0.01900251f, -0.03742734f, -0.05173627f, -0.05915708f, 0.01054963f, 0.03498445f, 
    0.02436403f, -0.01565721f, 0.02767511f, -0.00642912f, 0.00626871f, -0.04869685f, 0.02206849f, 0.01123841f, 
    -0.06001108f, 0.03989461f, -0.05567673f, 0.01835974f, -0.03200198f, 0.03827337f, -0.01339055f, -0.04911964f, 
    -0.02230315f, 0.02800622f, 0.02860961f, 0.01729481f, 0.00253888f, -0.04576544f, -0.05868184f, 0.00565666f, 
    -0.03311413f, -0.02235078f, -0.01947711f, -0.05554964f, -0.01885086f, 0.02107343f, 0.02453693f, 0.03178922f, 
    -0.05694765f, 0.00091433f, -0.01807298f, 0.01303167f, -0.04623502f, -0.02572145f, 0.01307167f, -0.00838491f, 
    -0.04696806f, -0.05907054f, -0.02890748f, 0.02391398f, -0.00060701f, -0.03974610f, 0.03673900f, 0.00387624f, 
    0.02342344f, -0.01225239f, 0.00641340f, 0.03277946f, -0.00913073f, 0.03766160f, 0.03116061f, 0.00365006f, 
    -0.01674574f, 0.02652406f, -0.04177725f, -0.03884005f, 0.02396495f, -0.03600676f, -0.05175335f, -0.04056257f, 
    0.00637273f, -0.04460312f, 0.00116577f, 0.02604954f, -0.01402278f, -0.01658010f, 0.03371454f, 0.01338638f, 
    0.04010939f, -0.01993866f, -0.03960196f, 0.02140526f, 0.02744078f, -0.02498736f, -0.04650331f, -0.05096407f, 
    0.00805554f, -0.00756989f, -0.04543322f, -0.02419718f, -0.01460898f, 0.00275407f, -0.00612263f, 0.03551510f, 
    -0.00957594f, 0.01385977f, 0.02212654f, -0.00577089f, -0.01544503f, 0.00866871f, -0.03714599f, 0.01646528f, 
    0.03053934f, 0.00739890f, 0.03688573f, -0.03306922f, 0.03977026f, -0.01546524f, 0.03254900f, 0.02321089f, 
    -0.00996261f, 0.03071040f, -0.05551792f, 0.03548818f, -0.02806954f, -0.00023143f, -0.00224977f, -0.00861363f, 
    0.00372996f, -0.04932648f, -0.01285436f, 0.03116273f, -0.04215311f, -0.03249820f, -0.04129788f, -0.02935018f, 
    0.01849181f, 0.02533401f, 0.00964017f, 0.00413238f, -0.04583466f, 0.01683398f, -0.02800347f, -0.04513932f, 
    -0.01624565f, 0.00195372f, -0.00324812f, -0.03782633f, 0.01322701f, 0.01219184f, -0.04098544f, 0.02044604f, 
    -0.32567373f, -0.62798220f, -0.72745204f, -0.36630383f, -0.09478547f, -0.02288709f, 0.03439051f, 0.17374961f, 
    -0.03364163f, 0.07198074f, 0.13263328f, 0.10762068f, -0.02265104f, -0.07483412f, -0.05094480f, 0.17203453f, 
    0.02650381f, -0.04798894f, -0.04196309f, -0.02251934f, -0.07455803f, 0.05578014f, -0.03194935f, 0.26841968f, 
    0.49266729f, 0.01820743f, -0.07737401f, -0.00028637f, 0.04803262f, -0.09809551f, 0.05369821f, 0.02391023f, 
    0.17309672f, 0.32713810f, 0.12783013f, 0.03575189f, 0.54831105f, 0.17570311f, 0.20471424f, 0.01866397f, 
    -0.02460421f, -0.07521803f, 0.01758291f, 0.01597462f, -0.00153394f, -0.03871798f, -0.07037219f, -0.05967665f, 
    0.31141666f, 0.35248327f, 0.38831735f, 0.52760214f, -0.00521845f, -0.06447259f, 0.01275625f, -0.07201684f, 
    -0.02504292f, 0.03112567f, 0.03059417f, 0.04656890f, -0.22203001f, 0.16139431f, -0.16615573f, -0.14264610f, 
    -0.09181846f, -0.11572455f, -0.23208645f, -0.17723823f, -0.25223947f, -0.15429352f, -0.04368981f, -0.03482719f, 
    -0.09871965f, -0.13478737f, -0.11449778f, -0.10251021f, -0.04478992f, 0.03082442f, -0.01123512f, 0.07198279f, 
    0.21438435f, -0.05427633f, -0.01952312f, -0.14411448f, 0.07476937f, 0.25087377f, -0.23625192f, -0.20121460f, 
    0.08963408f, -0.13427030f, 0.03594754f, -0.08764482f, -0.01921422f, 0.00265761f, 0.00755895f, -0.04100171f, 
    -0.54033971f, -0.35966343f, -0.27707517f, -0.30053127f, 0.08491457f, 0.11919908f, 0.05351435f, 0.01447179f, 
    0.03781736f, 0.02997625f, -0.04304427f, -0.05750124f, 0.03675281f, 0.08045024f, 0.09799984f, -0.02727037f, 
    0.11197709f, 0.03013745f, -0.07118332f, 0.02688708f, 0.02480101f, 0.00842002f, -0.09441697f, 0.08120807f, 
    0.27848002f, 0.17295964f, 0.05490491f, 0.24671559f, -0.04192315f, 0.03358313f, 0.18761507f, 0.17879158f, 
    -0.01916707f, -0.01249460f, 0.04499988f, -0.05411379f, 0.14597699f, 0.11251836f, 0.03191335f, 0.11092912f, 
    -0.06217230f, -0.00802406f, 0.04198806f, -0.03231078f, 0.28053623f, 0.23279840f, 0.04688173f, 0.24012630f, 
    0.16206878f, 0.09240262f, 0.16102192f, 0.09522659f, -0.04033742f, -0.04535070f, 0.01250959f, -0.01722658f, 
    0.00905329f, 0.01572440f, -0.08761542f, -0.05179582f, 0.02860572f, 0.08924363f, 0.10888994f, -0.00342767f, 
    0.07460920f, -0.01119052f, 0.04292683f, -0.14753015f, 0.23426415f, 0.03462918f, -0.07609669f, -0.03688541f, 
    -0.01272095f, 0.08341391f, -0.10427700f, -0.20116450f, -0.13112468f, -0.10780602f, -0.08597074f, -0.06728105f, 
    0.02946457f, 0.05564564f, 0.06537410f, 0.08594138f, -0.05880717f, 0.07962634f, 0.08790065f, 0.07008933f, 
    0.16897987f, 0.02342245f, 0.09750308f, 0.00059128f, -0.13138121f, -0.06726394f, -0.08464317f, -0.00554647f, 
    -0.59807479f, -0.11100494f, -0.13974845f, -0.39816260f, 0.11904041f, 0.01170070f, -0.09941628f, -0.10781667f, 
    -0.11900313f, -0.06004682f, -0.13826853f, -0.12752244f, 0.27713820f, 0.11204967f, 0.15021867f, 0.27207714f, 
    0.05010823f, -0.02998247f, 0.15852590f, -0.03505360f, -0.04075658f, -0.00971908f, -0.03697809f, 0.03130664f, 
    0.06130566f, -0.28378507f, -0.12529564f, -0.14002725f, -0.09808812f, -0.00224361f, -0.06116765f, -0.02306891f, 
    0.11760783f, -0.01781881f, -0.08465069f, -0.12664786f, 0.29379055f, 0.23025601f, 0.12202936f, 0.14729010f, 
    0.03160933f, 0.02270261f, -0.03836181f, 0.02784110f, 0.00083455f, -0.06548457f, -0.03495255f, -0.01742953f, 
    -0.21938339f, -0.30909276f, -0.10374350f, -0.14576519f, -0.05080857f, 0.01532590f, -0.03910478f, 0.09797589f, 
    -0.05872343f, -0.13386600f, -0.01867646f, 0.10500760f, 0.03297185f, -0.06158955f, -0.19418821f, -0.26987353f, 
    -0.09738120f, 0.11402665f, -0.05075034f, 0.00925411f, -0.06465396f, -0.01240825f, -0.02745725f, 0.01966812f, 
    0.25191727f, 0.12031999f, 0.33230817f, 0.14835218f, -0.00291045f, -0.00357342f, -0.04851131f, -0.01284207f, 
    -0.04065518f, 0.13750196f, 0.16534972f, 0.07041924f, 0.27760562f, -0.13007057f, -0.13180082f, 0.05568202f, 
    0.09325356f, 0.12632103f, 0.26611325f, 0.17524759f, -0.16516845f, 0.02610997f, 0.05159081f, -0.13359082f, 
    -0.52862543f, -0.55954725f, -0.25658095f, -0.53469014f, -0.14752010f, -0.12437570f, 0.06324514f, 0.00894028f, 
    0.21240425f, 0.04989416f, 0.13628608f, 0.11582258f, 0.06217349f, 0.16014543f, 0.12296948f, 0.07225262f, 
    0.01741917f, 0.11271173f, 0.03508967f, 0.20451085f, 0.06429107f, -0.08580457f, -0.07557380f, -0.02661654f, 
    -0.04543832f, 0.01959019f, -0.10297542f, -0.00386792f, -0.02289255f, -0.03178202f, -0.01203298f, 0.07538100f, 
    -0.07816306f, -0.08656710f, -0.09313644f, -0.12283164f, -0.31787494f, -0.45936066f, -0.33740446f, -0.12377836f, 
    -0.09191152f, 0.05702437f, 0.07198723f, 0.20943774f, -0.00254980f, -0.18720120f, -0.08029554f, -0.02289748f, 
    -0.10068298f, -0.17527950f, -0.18826902f, -0.00468196f, 0.11264343f, 0.03199144f, 0.17019039f, 0.10368594f, 
    -0.03176447f, 0.00252745f, 0.07693027f, 0.16463682f, 0.10968666f, 0.19035898f, 0.00741058f, 0.06861766f, 
    -0.07935694f, 0.02155956f, 0.02800728f, -0.04457547f, 0.02073930f, 0.09071697f, -0.10284980f, 0.09567783f, 
    -0.25180942f, -0.11727601f, 0.13970034f, 0.04119205f, 0.00082722f, 0.01878101f, 0.16716640f, 0.13945945f, 
    0.13148518f, -0.05045458f, 0.19721726f, 0.17709520f, 0.06853008f, 0.19964546f, 0.15305984f, 0.09706256f, 
    -0.00360757f, 0.11908401f, -0.06337050f, -0.02507731f, -0.05949245f, 0.01962698f, 0.02703303f, 0.02695839f, 
    -0.00522881f, 0.01642417f, 0.02050916f, 0.01175310f, -0.04926593f, -0.01208963f, 0.01048521f, -0.04818762f, 
    -0.02878050f, -0.02972748f, 0.03547301f, 0.04368893f, 0.02273399f, 0.01353018f, -0.01765442f, -0.03850099f, 
    -0.00839357f, -0.03288066f, -0.03583447f, 0.02192378f, 0.00933198f, -0.02204724f, 0.02400012f, -0.04629649f, 
    -0.02958833f, 0.02567836f, 0.03119718f, 0.01640295f, -0.01853372f, 0.01899844f, -0.04169609f, -0.01362986f, 
    -0.03811390f, 0.02250952f, -0.02823389f, -0.03815737f, -0.03575666f, -0.00621280f, 0.04043932f, 0.04111718f, 
    -0.05128701f, 0.04427076f, 0.03615562f, -0.04011436f, -0.02292713f, -0.03302927f, -0.04442390f, -0.04804956f, 
    -0.04060905f, -0.04749056f, -0.02321380f, -0.04977268f, -0.03539057f, 0.03861793f, -0.01736961f, 0.02355371f, 
    -0.05595526f, -0.00546262f, 0.00687793f, -0.00132174f, -0.00725194f, 0.01292680f, -0.03251790f, -0.02140223f, 
    -0.04243009f, 0.00921896f, -0.04542469f, -0.03623664f, 0.03655748f, -0.01018454f, -0.00425843f, -0.00078535f, 
    -0.04408588f, 0.02252484f, -0.04738670f, -0.02951761f, 0.03878528f, 0.01667302f, -0.01374317f, -0.03442584f, 
    -0.04695500f, 0.03555632f, -0.00392849f, -0.02224992f, -0.03413220f, 0.02350667f, 0.02664672f, -0.04617177f, 
    -0.04999262f, 0.03499161f, -0.04732726f, -0.02562692f, -0.03874235f, 0.04776591f, -0.05318114f, 0.01960546f, 
    -0.04979394f, -0.04229319f, -0.03825942f, -0.00243910f, -0.01720551f, 0.01612395f, -0.03600282f, 0.01026532f, 
    0.04799308f, -0.00648666f, 0.04941030f, 0.00338043f, -0.02742432f, 0.03399542f, 0.02696470f, 0.03398075f, 
    -0.00434881f, 0.04526011f, -0.03452072f, 0.00835508f, -0.01367411f, 0.00403025f, -0.00254434f, -0.04189579f, 
    0.00267927f, -0.03552262f, -0.03609809f, 0.03949764f, -0.04749845f, 0.00798834f, 0.03870292f, 0.04208251f, 
    0.01728842f, -0.03215678f, 0.01006074f, -0.01576441f, 0.01130766f, 0.04276948f, -0.00309094f, -0.00813108f, 
    0.02377673f, -0.00052245f, 0.00288945f, -0.05330103f, -0.04646070f, 0.03424374f, -0.00168871f, 0.01540830f, 
    -0.02210759f, -0.00220088f, -0.02510616f, 0.01733686f, -0.00339597f, -0.04079641f, -0.03705338f, 0.04396395f, 
    0.03091307f, 0.01133277f, 0.00911946f, -0.00275253f, -0.04929609f, -0.03562877f, 0.03818934f, -0.02495345f, 
    0.01053169f, 0.03650432f, -0.02537500f, 0.03082303f, -0.03703125f, 0.02127489f, 0.02250948f, 0.01540699f, 
    -0.03226018f, -0.01305265f, -0.01730768f, 0.00744637f, -0.03853482f, -0.04878217f, -0.04298733f, -0.05059626f, 
    -0.03166309f, 0.00548051f, 0.03294782f, -0.02096012f, -0.02431819f, 0.01629248f, -0.02646084f, 0.00096420f, 
    0.03167518f, -0.00014090f, 0.00925289f, 0.03465283f, 0.00613358f, -0.03990906f, 0.02006100f, 0.00782582f, 
    -0.04695614f, -0.01108274f, 0.02357581f, -0.03285029f, 0.04136639f, -0.00025964f, 0.00256531f, 0.04420192f, 
    0.00588517f, 0.00056750f, -0.05516745f, -0.03499795f, -0.03333429f, -0.05198603f, 0.02705521f, -0.03375117f, 
    0.01413802f, 0.03215137f, 0.02567737f, -0.00278289f, -0.04122869f, -0.03204012f, -0.02082991f, 0.02541039f, 
    -0.02090656f, -0.00166291f, -0.05001379f, 0.01168871f, -0.02053233f, 0.02148359f, 0.02699404f, -0.05328244f, 
    0.00284187f, -0.02408481f, -0.01268193f, 0.02639131f, -0.01249571f, -0.04363858f, 0.01176340f, 0.02427260f, 
    -0.01431367f, 0.00787875f, -0.05277297f, -0.03785838f, -0.01070250f, 0.02388731f, -0.04238071f, -0.01266718f, 
    -0.04037251f, -0.04413073f, 0.02175356f, 0.01054933f, -0.04808818f, -0.00537138f, 0.00530895f, 0.02231852f, 
    -0.01947843f, -0.02255404f, -0.00413434f, 0.02436603f, -0.01397285f, -0.04090233f, -0.03750109f, 0.02803924f, 
    -0.00286933f, -0.00546734f, -0.02869063f, 0.00256684f, 0.02607820f, -0.03875136f, 0.03348240f, -0.01126075f, 
    -0.00222110f, 0.02419011f, 0.01452076f, -0.04623229f, 0.00467142f, 0.00070861f, 0.00097531f, 0.03510433f, 
    -0.04480527f, -0.02696146f, -0.02988927f, -0.03371300f, 0.02765851f, 0.00131334f, -0.04254623f, 0.01966428f, 
    0.02411158f, 0.02685841f, 0.02348123f, -0.02365900f, 0.05101584f, 0.04538361f, -0.04878942f, -0.05428134f, 
    0.01602092f, 0.01804527f, 0.01608912f, -0.02236035f, 0.00592686f, -0.01797414f, -0.03644843f, -0.01586438f, 
    0.03232472f, -0.03249845f, 0.02164240f, -0.02165754f, -0.03224942f, 0.01870686f, -0.02578142f, -0.01259684f, 
    -0.03384670f, 0.02938065f, 0.02556307f, 0.01080562f, 0.02506887f, 0.00081172f, 0.00062296f, -0.03621299f, 
    -0.04197386f, 0.02522498f, 0.03586857f, -0.00894025f, -0.02225584f, 0.00397092f, 0.04375849f, 0.04474566f, 
    0.01526366f, -0.03634360f, -0.02152772f, -0.02084221f, 0.00936594f, -0.04884130f, 0.01984388f, 0.01870740f, 
    -0.00849724f, -0.02456573f, -0.00735489f, -0.02193448f, 0.02514262f, -0.04523846f, -0.04898993f, -0.01777321f, 
    -0.03971333f, -0.03294097f, -0.02459652f, 0.00905499f, 0.00043148f, -0.03434223f, 0.02692950f, 0.01348046f, 
    -0.04473555f, -0.04732106f, 0.01999924f, -0.03675466f, -0.00712677f, 0.02114961f, 0.04366685f, -0.02455457f, 
    -0.05364922f, 0.00932177f, -0.01352653f, -0.01402951f, 0.03823094f, -0.03976704f, -0.02546154f, -0.00071513f, 
    0.00585648f, -0.01547860f, 0.04797167f, -0.04729975f, 0.01853407f, 0.00817425f, -0.02147080f, 0.00450457f, 
    -0.02130818f, 0.02917865f, -0.03271917f, -0.00404779f, -0.04983658f, -0.02790460f, -0.01559692f, 0.02690510f, 
    -0.03101586f, 0.00054077f, 0.00868940f, -0.03431238f, -0.01825452f, -0.03853386f, 0.02192799f, 0.03456261f, 
    0.27573615f, 0.11541963f, -0.02657169f, -0.00884125f, -0.02739700f, 0.09622605f, 0.03114344f, 0.01381780f, 
    0.07215154f, -0.07430851f, -0.30279848f, -0.14225717f, 0.34246299f, -0.26873657f, 0.20217364f, -0.26111212f, 
    -0.14178114f, 0.17171758f, -0.14986639f, 0.18811837f, 0.00820661f, -0.01752069f, -0.08598790f, 0.06389711f, 
    0.79374212f, -0.36991274f, -0.03112176f, 0.03264779f, -0.01006363f, 0.08649732f, -0.08604515f, 0.00892511f, 
    0.13145179f, -0.05549007f, 0.13369600f, 0.08103671f, -0.18884622f, 0.18508229f, 0.07232977f, 0.17372951f, 
    0.04070016f, 0.00548996f, -0.07180733f, -0.04409971f, -0.03111302f, -0.07130475f, 0.14995056f, 0.07859923f, 
    0.18216859f, -0.01362705f, 0.05785607f, 0.20183001f, -0.06667269f, -0.08354043f, 0.03336379f, -0.03505694f, 
    -0.01333338f, 0.08938905f, 0.03509976f, -0.00490161f, -0.03059216f, 0.13562371f, 0.19095391f, -0.10804585f, 
    0.07891417f, 0.11463734f, 0.02387453f, -0.11153433f, -0.07351079f, -0.05631742f, -0.05696193f, -0.10110737f, 
    0.04074951f, -0.12166578f, -0.13711442f, -0.04981412f, 0.05671614f, 0.10097186f, 0.12294316f, 0.21263653f, 
    0.10050642f, 0.07778469f, -0.04658223f, -0.07912278f, 0.31487751f, 0.19846064f, 0.03251518f, 0.08213530f, 
    0.09385575f, 0.05551672f, 0.11776599f, 0.00646623f, -0.00563759f, 0.04287264f, -0.04412234f, 0.08808748f, 
    0.20687072f, 0.23459476f, 0.00494588f, 0.01521443f, 0.04198296f, 0.12073217f, 0.10891586f, 0.35834691f, 
    0.10289076f, 0.10126525f, 0.00362970f, 0.01981424f, -0.05095096f, -0.07190194f, 0.16355871f, 0.04827771f, 
    -0.01620859f, -0.06852887f, 0.00177532f, -0.02560387f, -0.20015489f, 0.17470846f, -0.15762515f, 0.29372597f, 
    -0.26264963f, 0.21443127f, -0.13031930f, 0.05495413f, 0.13347630f, -0.07343086f, -0.26746792f, -0.06672537f, 
    -0.03394326f, -0.05501611f, -0.04662194f, -0.01482491f, -0.07032987f, 0.01315879f, -0.09008594f, 0.08321184f, 
    0.03336956f, 0.02908295f, 0.01973912f, 0.00728223f, 0.06823239f, 0.00225755f, -0.07191456f, -0.00293660f, 
    -0.04692295f, 0.05809055f, 0.08092538f, 0.07340639f, -0.07069228f, -0.00295336f, 0.06324035f, 0.04076121f, 
    0.07931223f, -0.01784614f, 0.22071922f, 0.22453411f, 0.06898917f, 0.03286500f, 0.11724047f, -0.03565845f, 
    -0.16491850f, 0.10004206f, 0.07717653f, -0.10920243f, 0.08757696f, -0.08686681f, 0.06706548f, 0.03720724f, 
    0.28612825f, 0.02146527f, -0.23358557f, -0.04480780f, -0.09458274f, 0.03343144f, 0.08194630f, -0.03689404f, 
    0.20931064f, 0.08065844f, -0.09227548f, -0.16647212f, -0.10425288f, 0.11527298f, 0.03042744f, -0.05038254f, 
    0.01910989f, -0.05719110f, 0.05490613f, -0.14401463f, -0.05165209f, -0.05319559f, 0.01119835f, 0.04516138f, 
    0.20223916f, 0.33540311f, -0.13310772f, 0.08336522f, 0.07631077f, 0.07934579f, 0.01570696f, -0.06227085f, 
    0.01040565f, 0.02715277f, -0.02720061f, 0.13718997f, -0.22138481f, 0.11785240f, -0.10085422f, 0.25435197f, 
    -0.02796283f, -0.15473303f, -0.15060101f, -0.13697076f, -0.00531685f, -0.06329491f, 0.05085088f, 0.00016508f, 
    -0.05202812f, -0.24060482f, 0.02498836f, -0.09855720f, 0.01016731f, 0.05256915f, 0.00961878f, 0.04429778f, 
    -0.17565739f, -0.05150857f, -0.03982971f, -0.10538393f, -0.02542607f, 0.13372654f, 0.05504495f, 0.21939744f, 
    -0.01574636f, 0.03362426f, 0.02367240f, 0.04363955f, 0.02053784f, 0.02734533f, 0.06769483f, 0.06358334f, 
    0.18256246f, -0.08044218f, -0.05474393f, 0.01207224f, 0.08363532f, -0.00194319f, -0.12942240f, 0.15902074f, 
    -0.13593480f, -0.13297325f, -0.20190413f, -0.14103337f, 0.28370962f, 0.07738004f, 0.11426609f, -0.17553684f, 
    0.10277701f, 0.09085309f, 0.06487118f, 0.05919641f, 0.04019311f, -0.08776294f, 0.04066779f, -0.02544970f, 
    0.03750172f, -0.03124866f, 0.17176558f, -0.06508385f, 0.02134771f, -0.11007847f, 0.12802382f, 0.00205840f, 
    -0.06639531f, 0.25547475f, -0.08562478f, 0.06033895f, 0.00339143f, 0.21252927f, -0.06093892f, -0.22365046f, 
    0.05063041f, -0.10549526f, -0.10232849f, 0.18105119f, -0.10744959f, 0.15215202f, 0.04975941f, 0.05214306f, 
    -0.04611418f, -0.05209479f, -0.02467491f, 0.08935042f, 0.08103681f, 0.14458489f, -0.06449618f, 0.01564644f, 
    -0.14831351f, -0.00322453f, -0.11802826f, -0.07880966f, -0.20168881f, 0.08594476f, 0.13381268f, 0.06466688f, 
    0.08680456f, 0.15563615f, -0.14042675f, -0.06172989f, -0.29007661f, -0.00251449f, 0.05365009f, -0.05031988f, 
    -0.00535965f, 0.02725921f, 0.01926468f, -0.04174925f, -0.07276001f, 0.10449311f, -0.00996775f, 0.20923606f, 
    -0.12195720f, -0.04108377f, 0.02456328f, 0.01139054f, 0.21402062f, 0.04440574f, -0.08413246f, 0.05745677f, 
    0.05998114f, 0.21821679f, 0.22915329f, 0.15550788f, -0.08706079f, 0.07753342f, -0.05000694f, 0.12147855f, 
    0.28114364f, 0.19517978f, 0.04206791f, -0.07401213f, 0.03281195f, 0.00404838f, 0.02352240f, 0.19731537f, 
    0.13293056f, 0.01287570f, 0.04580241f, -0.08965320f, 0.44370559f, -0.07769100f, -0.09690151f, 0.01048980f, 
    0.00884391f, 0.02440732f, 0.06656510f, 0.03742762f, 0.05414440f, 0.14299321f, -0.26713681f, -0.23763798f, 
    0.24608003f, 0.08596227f, 0.14586948f, -0.11703103f, 0.07879542f, -0.20408204f, 0.06821560f, 0.13500112f, 
    0.08702993f, 0.01956136f, -0.12921128f, -0.06979818f, -0.12577581f, 0.18253075f, 0.16364259f, -0.25659385f, 
    0.04509902f, 0.03052078f, -0.10417333f, 0.13215005f, -0.03774211f, -0.14419933f, 0.02552507f, 0.03956794f, 
    -0.35623515f, -0.03761960f, 0.12757458f, 0.01471694f, -0.13346234f, -0.20221902f, -0.03547740f, 0.14073847f, 
    0.02959175f, -0.09588847f, -0.07652111f, 0.01001591f, 0.06944155f, 0.07056532f, 0.25261176f, -0.18728638f, 
    0.20203994f, -0.11796053f, 0.09115159f, 0.09638766f, 0.05157577f, 0.05334751f, -0.16604976f, -0.03436727f, 
    -0.41432568f, 0.28229776f, 0.25394356f, -0.31421775f, 0.02830666f, -0.00882812f, -0.11148687f, 0.09097762f, 
    0.02717342f, 0.11507490f, 0.07156143f, 0.01750442f, -0.04167977f, 0.43511173f, -0.62193024f, 0.13138141f, 
    0.02636950f, 0.02877878f, -0.14253290f, 0.04013368f, -0.11580479f, -0.09780478f, 0.11267055f, -0.18905807f, 
    -0.08743868f, 0.29594672f, 0.18533908f, -0.20292972f, 0.02257154f, 0.04645302f, 0.08860632f, 0.04339037f, 
    0.04547000f, 0.14111824f, -0.10610282f, -0.03937745f, -0.28530300f, -0.11949137f, -0.07775654f, 0.26671460f, 
    -0.02822982f, 0.06616756f, -0.03741215f, 0.00923262f, -0.06702701f, 0.05460324f, -0.01666596f, 0.13788664f, 
    0.22019832f, 0.38029328f, 0.22130373f, 0.23167858f, -0.03220046f, 0.02718509f, 0.07328147f, -0.01437991f, 
    0.16890788f, -0.07515837f, 0.08853132f, -0.00871314f, -0.18202975f, 0.06716397f, 0.17323281f, 0.01782112f, 
    -0.01407098f, 0.02273733f, -0.07535352f, -0.16548389f, -0.01475643f, 0.08720250f, -0.03910716f, -0.12982273f, 
    -0.17463911f, -0.06824990f, 0.12834458f, 0.19424902f, 0.06661041f, -0.08263844f, 0.07694655f, -0.06294187f, 
    0.20128536f, -0.07423705f, 0.00189582f, 0.05807866f, 0.17502302f, -0.04243315f, -0.18790887f, 0.03700295f, 
    -0.01882322f, -0.07528868f, 0.24256659f, 0.05437946f, 0.21554700f, 0.07138269f, 0.07827741f, 0.12495693f, 
    -0.07359285f, 0.00905284f, -0.36980084f, 0.19051801f, -0.04260223f, 0.14872004f, -0.00790436f, -0.05231786f, 
    0.00875190f, -0.08917163f, 0.02363414f, -0.07445242f, 0.06035352f, -0.06947169f, -0.17462823f, -0.11181586f, 
    -0.07522836f, -0.03071854f, -0.04342781f, -0.05274712f, 0.19479494f, 0.10002157f, 0.14421679f, 0.23091640f, 
    -0.17927229f, -0.15485749f, -0.15084779f, -0.06182376f, 0.05465700f, -0.04448737f, -0.12372539f, -0.16404374f, 
    -0.00440286f, 0.01866495f, -0.02164960f, 0.00960561f, 0.11391731f, 0.33831161f, -0.31953308f, -0.04246010f, 
    -0.04450098f, -0.02650161f, -0.07653781f, -0.07251383f, -0.04213758f, 0.08551311f, -0.04620758f, -0.20950328f, 
    0.31142184f, 0.06520060f, 0.05785039f, -0.01811292f, -0.11997682f, -0.14051910f, -0.08423263f, 0.10462607f, 
    0.05525115f, -0.05932013f, 0.07484402f, 0.03905939f, 0.07864613f, -0.50963980f, 0.07897411f, 0.02815244f, 
    0.05104944f, 0.01992368f, -0.06553083f, 0.18224958f, -0.04461490f, -0.01283930f, -0.04229566f, -0.07815553f, 
    -0.15712006f, -0.19141147f, 0.11909431f, 0.24087548f, 0.01752446f, -0.03612472f, 0.03381149f, 0.07338513f, 
    -0.02152737f, -0.06351677f, -0.03243629f, 0.01914629f, -0.15219113f, -0.03416042f, -0.46735024f, 0.03341060f, 
    -0.05666328f, 0.04338577f, 0.00167345f, -0.10038508f, 0.13882579f, 0.00223375f, 0.00439471f, -0.17313504f, 
    -0.10135251f, 0.61055058f, 0.13183436f, 0.15579438f, -0.04052357f, -0.01942930f, 0.00602623f, -0.08137979f, 
    0.11956648f, -0.00013712f, 0.04455252f, 0.00328272f, -0.06344240f, -0.03323613f, -0.03604559f, -0.04928741f, 
    0.03599199f, -0.07620294f, -0.11448300f, -0.06599294f, -0.01341853f, 0.11515825f, -0.05381387f, 0.06533463f, 
    0.05778868f, 0.12356807f, 0.13161203f, 0.11383812f, 0.02533778f, -0.15659760f, 0.01790176f, -0.00596148f, 
    -0.05165130f, -0.01339144f, 0.05908150f, 0.03478152f, -0.33447185f, -0.03337645f, 0.05851493f, -0.03613639f, 
    -0.04267726f, -0.07470262f, 0.00822793f, 0.10705944f, 0.05755531f, -0.04464668f, -0.04872916f, -0.00488764f, 
    -0.08792888f, -0.05657410f, -0.22154604f, -0.06036972f, -0.09433755f, 0.13876252f, -0.00565363f, -0.01848465f, 
    0.14151770f, -0.04008498f, 0.07978073f, 0.02390290f, -0.09932114f, 0.03866553f, 0.07503431f, 0.45175734f, 
    0.09872975f, 0.16318393f, 0.03475016f, -0.17751463f, 0.03922245f, -0.08600175f, 0.02411766f, -0.06522676f, 
    0.28890732f, 0.08016677f, 0.02972153f, 0.11350454f, 0.00439685f, -0.08260516f, 0.19635171f, 0.15286097f, 
    0.11082245f, -0.05970125f, 0.10892823f, 0.07899763f, -0.00736268f, -0.01405735f, -0.31224036f, 0.14080676f, 
    -0.06905093f, 0.06910543f, 0.00555578f, 0.00590023f, -0.08946159f, 0.10947319f, 0.00972463f, 0.10961421f, 
    0.24583179f, -0.10270166f, 0.19584803f, 0.03626094f, 0.08634207f, 0.02009443f, 0.03688433f, 0.12631835f, 
    0.06174731f, 0.06991682f, -0.04420854f, -0.18368517f, -0.14083406f, 0.05933177f, 0.19941550f, 0.23143323f, 
    -0.07660738f, -0.07636787f, 0.11528499f, 0.01194766f, 0.06464693f, -0.09201442f, 0.00594411f, 0.02410909f, 
    -0.35285074f, -0.08600087f, 0.09721848f, 0.12760593f, -0.02848489f, 0.04180877f, 0.11058857f, -0.02339827f, 
    0.11073334f, 0.09280195f, -0.05898359f, 0.11480302f, -0.04715747f, 0.03329817f, 0.25778437f, 0.05487742f, 
    0.05160216f, -0.07649243f, -0.00026973f, 0.01524389f, 0.09979900f, 0.05602615f, -0.03156743f, 0.13195260f, 
    0.05880730f, -0.25315595f, 0.14098062f, 0.27250183f, 0.08796380f, -0.15171604f, -0.03696932f, -0.01575896f, 
    -0.09496538f, -0.04005855f, 0.10629632f, 0.05629419f, -0.22111863f, -0.41545472f, -0.15425722f, -0.03510614f, 
    -0.01733221f, 0.12170658f, 0.03434471f, -0.03147582f, 0.03009480f, 0.10601535f, 0.15929693f, 0.15110329f, 
    -0.04252268f, -0.00730629f, -0.05767562f, -0.03044895f, 0.00172229f, -0.01462515f, -0.00216018f, 0.03756100f, 
    0.00537607f, 0.03414471f, -0.01300975f, -0.02528038f, 0.00823173f, -0.04639294f, -0.00639536f, 0.02566455f, 
    -0.03235405f, 0.00441581f, -0.00742583f, -0.00443617f, 0.04050535f, 0.01113512f, 0.01106414f, -0.03276986f, 
    -0.03847802f, -0.02024399f, -0.03256970f, -0.01955429f, 0.00979204f, 0.03978170f, -0.03833918f, 0.03727951f, 
    -0.05299701f, 0.00286784f, -0.00253005f, 0.04083149f, -0.01585669f, 0.03439047f, -0.03223322f, 0.00482003f, 
    -0.03359645f, -0.01984957f, -0.00152311f, -0.01734387f, -0.05491350f, -0.04288269f, -0.00754690f, -0.03523695f, 
    -0.00446811f, 0.03435220f, 0.00033529f, -0.00112936f, -0.02040713f, -0.04113208f, -0.04119406f, 0.01475609f, 
    -0.03718829f, -0.02331413f, -0.03575056f, 0.01574721f, 0.04758722f, 0.03549151f, 0.00459321f, -0.00198399f, 
    0.01589803f, 0.03446621f, 0.02788497f, -0.05565801f, 0.01067077f, 0.04175210f, -0.05534464f, 0.03806393f, 
    -0.04986469f, 0.03817973f, 0.02247707f, -0.02131047f, -0.01767151f, -0.03892174f, -0.05356043f, 0.01828648f, 
    -0.02748833f, -0.04916266f, 0.01384177f, -0.02284701f, 0.03783444f, -0.04091210f, -0.02023351f, 0.02306018f, 
    0.00425208f, 0.04120664f, 0.03879798f, 0.02525602f, -0.02908596f, -0.01094335f, 0.03022769f, -0.03925348f, 
    -0.01889292f, 0.02447053f, 0.00964485f, -0.03891044f, -0.00202971f, 0.02593821f, 0.02614541f, 0.02182257f, 
    0.00572247f, 0.01300853f, -0.00066448f, -0.01327873f, -0.01304690f, -0.01799988f, -0.02850988f, 0.00341001f, 
    -0.04830727f, 0.00534052f, -0.02150508f, 0.00760022f, 0.00366191f, 0.01342031f, -0.04525550f, -0.02065504f, 
    -0.04440713f, -0.04822658f, 0.00888006f, 0.03964186f, 0.02372387f, -0.05106160f, -0.00449927f, -0.02445484f, 
    -0.00132220f, 0.00990639f, 0.00999205f, -0.00681881f, 0.02906997f, 0.00430027f, 0.00002257f, 0.00687618f, 
    -0.02551736f, -0.03886192f, 0.03262958f, 0.00703484f, -0.00324172f, -0.05127318f, 0.03276731f, 0.03228321f, 
    -0.03631269f, -0.03113787f, 0.03859230f, 0.02709106f, -0.04100776f, 0.04827183f, -0.02049244f, -0.03502094f, 
    -0.01864821f, -0.03084385f, 0.02887024f, -0.03951613f, -0.01724575f, -0.01789159f, -0.00135827f, 0.03787062f, 
    0.01519244f, 0.03859671f, -0.00536267f, -0.02684075f, -0.05759427f, 0.01588495f, -0.04843693f, 0.01637475f, 
    -0.03354507f, 0.00313224f, -0.00301638f, 0.03942731f, -0.01157959f, -0.00399974f, 0.00602713f, -0.04210183f, 
    -0.03264454f, 0.02005936f, -0.04991943f, 0.01692283f, -0.03142327f, -0.03111876f, -0.04649593f, 0.03711987f, 
    0.00651120f, 0.01271309f, 0.01290112f, 0.03276062f, -0.01560089f, -0.05642392f, 0.00894504f, -0.04529437f, 
    0.04124111f, 0.00034972f, -0.00787965f, 0.03648777f, -0.02007873f, -0.05898010f, -0.02405486f, -0.03468101f, 
    -0.03634844f, -0.00310066f, -0.05613235f, -0.04773600f, -0.01266445f, 0.01012930f, 0.02966335f, -0.00515147f, 
    -0.05715592f, 0.03544997f, -0.01256378f, 0.01919145f, -0.01190507f, -0.01892964f, 0.02174701f, -0.01233961f, 
    0.03546611f, 0.01863756f, -0.00562140f, 0.01873525f, -0.01846733f, -0.02997517f, 0.03440445f, -0.02325915f, 
    -0.02317439f, -0.02984116f, 0.03946806f, -0.05583269f, 0.03631367f, 0.00127656f, -0.02505767f, -0.02487255f, 
    0.03181130f, -0.01124686f, -0.04509458f, 0.02031284f, 0.01423047f, -0.05314135f, 0.00225836f, -0.02440518f, 
    -0.01649100f, -0.00219190f, 0.00139573f, -0.04683363f, -0.04339737f, 0.00995941f, -0.02065696f, -0.02718671f, 
    -0.00126439f, -0.03016105f, 0.03158030f, -0.05271498f, 0.00126675f, 0.02188927f, -0.05465144f, -0.04061089f, 
    0.00375113f, -0.02167344f, -0.00292739f, 0.03601083f, -0.05004985f, 0.00140882f, -0.05397681f, 0.00766279f, 
    -0.04374430f, -0.00042860f, -0.05271415f, -0.04867273f, 0.04972534f, 0.03989894f, -0.01683461f, 0.04522511f, 
    -0.00125270f, -0.03842080f, 0.02936221f, 0.03264371f, -0.05345095f, 0.02529388f, -0.06075029f, -0.02824995f, 
    0.03653701f, 0.00929234f, -0.05245956f, -0.00760624f, -0.04230730f, -0.05414777f, -0.03925143f, -0.04679996f, 
    0.00830213f, -0.05792368f, 0.01003117f, 0.03348513f, 0.04084693f, -0.03675695f, 0.03716319f, -0.02733088f, 
    -0.03978834f, -0.03013235f, -0.05321183f, 0.02642321f, -0.04928616f, -0.05944595f, 0.01758024f, 0.01041748f, 
    -0.00176428f, 0.01442817f, 0.01741014f, -0.03256313f, 0.03534226f, 0.02562214f, 0.03917766f, -0.00709292f, 
    -0.00348261f, -0.04540023f, -0.02783929f, 0.02857879f, 0.03915741f, -0.03111287f, -0.04072016f, -0.03380137f, 
    0.02437662f, -0.04711287f, 0.03651303f, -0.01976301f, -0.03484161f, -0.01129694f, 0.00764315f, 0.01072691f, 
    -0.03912020f, -0.02819825f, 0.00200453f, -0.00877195f, 0.04119864f, -0.02157636f, 0.02842397f, -0.02982606f, 
    -0.04685258f, -0.01926910f, 0.01614935f, -0.00657293f, -0.05391364f, 0.04278130f, 0.03362276f, -0.05608657f, 
    -0.04923673f, -0.03318045f, -0.04323706f, -0.03939055f, 0.00311530f, -0.01428507f, -0.04527449f, 0.01373737f, 
    -0.04920176f, 0.03604177f, -0.00847837f, 0.02433020f, 0.01687114f, -0.04787670f, -0.03266313f, -0.05048076f, 
    -0.05107519f, 0.01503703f, 0.02144066f, -0.02606313f, 0.01726107f, -0.02253112f, -0.00045621f, -0.03772397f, 
    -0.04656010f, -0.00294907f, -0.03948923f, 0.01495760f, -0.00370187f, 0.01291821f, 0.01460526f, -0.00178032f, 
    -0.02833194f, 0.02027010f, 0.02123246f, -0.03060291f, -0.00756075f, -0.02941000f, -0.02904598f, -0.00073296f, 
    0.08959111f, 0.16613019f, -0.01148441f, 0.22868530f, 0.03030747f, -0.10268867f, -0.04016480f, -0.02886521f, 
    0.03169333f, -0.15934524f, -0.07757799f, 0.03369378f, 0.02109538f, 0.00174192f, 0.07492457f, -0.07948670f, 
    0.01799978f, -0.03359889f, -0.02939104f, -0.09266441f, 0.01132475f, -0.08892554f, -0.02328931f, 0.16236596f, 
    0.58959496f, -0.35975832f, 0.16153617f, -0.08187786f, -0.08532678f, 0.09275777f, 0.07277372f, 0.01822526f, 
    0.07846109f, 0.00598293f, 0.01799139f, -0.05201852f, 0.05903548f, 0.22433476f, -0.13653952f, -0.02422442f, 
    0.16414210f, 0.06780450f, 0.04861142f, -0.13215576f, 0.01703442f, -0.07896294f, 0.11331086f, -0.09453408f, 
    0.15494639f, 0.03146042f, -0.11840487f, 0.00904907f, -0.00793578f, -0.08379170f, 0.10765655f, 0.03004768f, 
    -0.00403022f, 0.04656204f, 0.02043051f, -0.08601123f, 0.11478839f, -0.13125101f, 0.46465036f, 0.08655145f, 
    0.01471326f, -0.00442908f, 0.02022981f, -0.02160345f, -0.00213490f, 0.07367591f, -0.00376638f, 0.00423107f, 
    0.08151605f, -0.06452671f, -0.05895288f, -0.17421749f, 0.05158552f, 0.02988029f, -0.01680922f, 0.22013187f, 
    0.05865595f, 0.06992724f, 0.10837140f, 0.02455481f, 0.12661919f, 0.27656803f, 0.07694323f, -0.07132620f, 
    0.16304205f, -0.08980347f, 0.17089826f, -0.03702752f, -0.10066788f, -0.04654576f, -0.05009982f, -0.15840419f, 
    0.18024984f, 0.02474076f, 0.25676748f, 0.17288487f, 0.05593891f, 0.15099671f, 0.09587903f, 0.07046112f, 
    0.05673528f, -0.14888972f, -0.00459930f, -0.11217236f, 0.11747403f, 0.14798339f, -0.06383704f, 0.06947505f, 
    0.13106407f, 0.00576326f, 0.02329119f, 0.00796035f, -0.04390378f, 0.19253497f, -0.27540472f, 0.05200074f, 
    -0.06813461f, 0.16615540f, -0.11603385f, 0.07439816f, 0.11836170f, 0.01917029f, -0.14939898f, -0.06996937f, 
    0.01054217f, 0.00871346f, 0.21098927f, 0.10015891f, 0.10240791f, -0.01095039f, -0.05239377f, 0.04729683f, 
    0.12082176f, 0.06182331f, 0.01024905f, 0.01682048f, 0.16918717f, 0.01916629f, 0.01076398f, 0.09922443f, 
    0.09199023f, 0.13814484f, -0.00154092f, 0.07661419f, -0.00636549f, 0.10075986f, 0.00145837f, -0.02557023f, 
    0.00973780f, -0.12048274f, -0.08191889f, -0.05950270f, 0.01558778f, 0.16807318f, -0.06581778f, 0.12294307f, 
    0.06813933f, -0.01214119f, 0.18093669f, -0.14313760f, -0.10046492f, 0.04499779f, -0.15016954f, -0.05575961f, 
    0.34605950f, 0.08693655f, -0.31258309f, -0.08527362f, 0.00282895f, 0.00985149f, -0.06808538f, -0.04197596f, 
    -0.13733979f, -0.02783037f, -0.03548107f, -0.00795587f, 0.01530530f, 0.02149967f, 0.22042328f, -0.00496426f, 
    0.03799768f, 0.03737464f, 0.09162316f, 0.04964895f, -0.01764209f, -0.03653157f, -0.00304047f, -0.02445211f, 
    0.23911157f, 0.08933543f, 0.34524512f, -0.12617132f, 0.11682090f, -0.02791063f, 0.04274797f, 0.02671016f, 
    -0.02462070f, 0.03879215f, -0.07096189f, -0.10327210f, -0.02106905f, 0.15563051f, -0.32557386f, 0.02131441f, 
    0.03909739f, -0.06681904f, -0.15614934f, -0.04597291f, 0.12401457f, 0.05560361f, 0.14761311f, 0.14754269f, 
    0.05922437f, -0.11933631f, -0.00964761f, -0.32282576f, 0.00949251f, 0.04278792f, -0.04007515f, -0.04982411f, 
    -0.11781894f, 0.08586651f, 0.05287934f, 0.02406060f, 0.14552234f, -0.01279244f, -0.00865730f, 0.10733861f, 
    0.06610723f, 0.04766743f, -0.07049866f, 0.02663562f, -0.07543524f, 0.05828622f, -0.05496509f, 0.00901940f, 
    -0.19789258f, 0.06772416f, -0.20800865f, -0.09411783f, 0.00028535f, -0.10772012f, -0.09259343f, 0.01071274f, 
    0.00982008f, -0.16223395f, 0.08231359f, 0.12002631f, 0.15045868f, -0.02993404f, 0.08431302f, -0.21598411f, 
    0.04038626f, -0.00095234f, 0.02303179f, 0.10566925f, -0.09351863f, 0.00625427f, 0.02792137f, 0.03549772f, 
    0.18944600f, -0.01019304f, 0.06260416f, -0.03033455f, 0.02637854f, -0.01510881f, 0.07598065f, -0.06487123f, 
    -0.01731806f, 0.11333711f, 0.08772174f, -0.14566959f, 0.17902669f, 0.41374356f, 0.12539023f, 0.03890328f, 
    -0.02238525f, -0.05227533f, -0.12597094f, 0.17322123f, -0.05399229f, -0.04448218f, 0.00884845f, -0.03993969f, 
    -0.33988786f, -0.02540030f, -0.30492982f, -0.04439466f, -0.03991141f, -0.08562036f, -0.13727167f, -0.08506143f, 
    0.07335795f, -0.14221567f, 0.08078357f, 0.00134286f, 0.06326200f, -0.01188177f, -0.04069742f, -0.00762105f, 
    0.05719171f, 0.04828425f, -0.14219584f, -0.13495103f, -0.11286305f, 0.13469374f, 0.01116259f, -0.01054081f, 
    0.19056982f, 0.11091619f, 0.12769277f, 0.00116026f, 0.08037659f, 0.03250310f, -0.01710050f, 0.01368092f, 
    -0.12690054f, -0.00366210f, -0.05298710f, -0.01904875f, 0.01499551f, 0.39945185f, -0.09885739f, -0.19993587f, 
    0.04382462f, -0.02645333f, 0.17984049f, 0.09764027f, -0.11305783f, -0.04242942f, -0.09876548f, -0.01795736f, 
    0.10656365f, -0.00373776f, 0.12591957f, 0.09223452f, -0.06223935f, -0.01158225f, -0.08068693f, 0.14823538f, 
    -0.04362053f, -0.03717408f, 0.13550353f, 0.11361931f, 0.23568425f, -0.23785989f, 0.00295714f, 0.01682828f, 
    -0.04416815f, -0.07192004f, -0.12962782f, 0.01342896f, 0.00030886f, 0.08643884f, 0.00138222f, 0.06393029f, 
    0.01042840f, 0.02810134f, -0.14111015f, -0.09527631f, -0.04975856f, -0.16637054f, -0.00396646f, 0.00281499f, 
    0.04073128f, -0.04680240f, -0.00973565f, -0.03960057f, -0.00743886f, -0.12991147f, 0.10041782f, -0.04794370f, 
    0.04991896f, 0.06043687f, -0.06809989f, 0.10975298f, 0.12122380f, -0.03468800f, 0.04066997f, -0.08097135f, 
    0.04324133f, -0.08710381f, -0.04546346f, 0.00672287f, -0.07305735f, 0.11736442f, -0.14457597f, 0.06906676f, 
    0.10435957f, 0.13373026f, 0.03048996f, 0.03634296f, 0.12652786f, -0.18798512f, 0.09152942f, 0.07842189f, 
    -0.10227651f, 0.06295132f, -0.23567382f, 0.03002710f, 0.01607641f, 0.01870273f, 0.00991019f, 0.07656811f, 
    0.54227591f, -0.48829949f, -0.21891277f, 0.13087493f, -0.08126254f, -0.19221808f, -0.14882044f, -0.05761839f, 
    0.06394909f, -0.04383843f, 0.12120762f, 0.12479182f, -0.28744292f, -0.22466247f, -0.08043014f, 0.00676188f, 
    0.12562887f, 0.08566707f, -0.03961766f, 0.01356738f, -0.15194432f, -0.04316289f, -0.03584933f, -0.07463041f, 
    -0.53570330f, -0.36205775f, 0.40629157f, -0.07185964f, 0.08372804f, 0.15113956f, -0.12901959f, -0.06578190f, 
    0.12512752f, 0.06043781f, -0.09129428f, 0.20130792f, -0.08540907f, 0.04698651f, 0.10283600f, -0.08737986f, 
    -0.05100336f, 0.08208347f, -0.01816437f, -0.07026569f, 0.13097703f, 0.01437143f, -0.12464492f, 0.07394244f, 
    0.07157598f, 0.07260691f, 0.17053232f, -0.09872048f, -0.03557653f, -0.03923398f, -0.03114112f, 0.08017874f, 
    0.10391131f, 0.09515136f, -0.03490683f, 0.00093339f, 0.02498625f, -0.04069536f, 0.07267718f, 0.08742729f, 
    0.15428297f, -0.00846825f, -0.02734360f, -0.00115490f, -0.05054345f, -0.10507798f, -0.07497382f, -0.00752391f, 
    0.11330704f, 0.16366631f, 0.07450878f, 0.06693014f, -0.05590891f, 0.06520158f, 0.11029241f, 0.00122267f, 
    0.00398176f, 0.12990744f, 0.05642836f, 0.05962792f, -0.28857461f, 0.05076600f, 0.09599224f, 0.02700621f, 
    -0.07164736f, 0.06588101f, -0.08790249f, -0.15241858f, -0.06236080f, -0.01273478f, 0.00275866f, -0.04995020f, 
    0.05192229f, 0.28292045f, -0.40189993f, 0.03498431f, 0.27147278f, 0.20595461f, 0.07125244f, -0.10327185f, 
    0.10513000f, -0.02816785f, -0.16395497f, 0.08087440f, -0.02049874f, -0.02630813f, -0.13724291f, -0.10127907f, 
    0.09199312f, -0.01524727f, 0.10002825f, -0.01934531f, -0.16372028f, -0.02276942f, 0.09909058f, 0.08616135f, 
    0.28866288f, 0.02008492f, 0.01317514f, 0.09291244f, 0.12197623f, 0.15647934f, 0.15182528f, 0.19841258f, 
    -0.03226301f, -0.06055200f, 0.08199741f, -0.13260165f, -0.29222298f, -0.09349952f, 0.03105676f, -0.09348486f, 
    -0.05467495f, 0.06831232f, -0.05487176f, -0.08964143f, -0.06314624f, -0.08945519f, 0.03817243f, -0.04098216f, 
    0.40393654f, 0.25209588f, 0.11648583f, 0.14258948f, -0.07614569f, -0.09148631f, -0.07261717f, -0.03661293f, 
    0.00375940f, -0.01943643f, -0.04985337f, -0.04475364f, -0.05059621f, 0.00251050f, 0.05307687f, -0.08400363f, 
    0.21196075f, 0.08273759f, -0.05499810f, 0.00018743f, -0.00222434f, -0.03821293f, -0.08469274f, -0.07729583f, 
    -0.02084046f, 0.03521146f, 0.14188771f, 0.16131024f, -0.02043131f, 0.01337820f, -0.15597093f, -0.03603579f, 
    -0.09574551f, 0.07496572f, -0.08499893f, -0.13961503f, 0.13614585f, 0.12144484f, -0.41854838f, -0.09677026f, 
    0.18678439f, 0.15854461f, 0.12666534f, -0.12049988f, 0.07106003f, -0.01254424f, 0.05914804f, 0.03617555f, 
    0.20059371f, -0.14051698f, 0.22250235f, -0.15383653f, 0.01503420f, -0.07139710f, 0.03103928f, 0.01926459f, 
    0.00512144f, 0.07921496f, -0.05969405f, -0.04224801f, -0.13342784f, 0.03016749f, 0.01205568f, -0.04906489f, 
    -0.06012374f, 0.07708284f, 0.02160204f, -0.00304336f, -0.13767014f, -0.05570618f, -0.10090926f, -0.11523072f, 
    -0.03647900f, -0.09589885f, 0.07043462f, 0.02915458f, 0.11779158f, 0.04524250f, -0.15042582f, 0.02078463f, 
    -0.08886054f, 0.07836469f, -0.04524730f, 0.11842437f, 0.16021679f, 0.07041334f, 0.11338067f, 0.09195381f, 
    -0.04471055f, 0.06701321f, -0.06704064f, 0.10485227f, 0.17887598f, 0.01320518f, 0.00677542f, 0.22005969f, 
    -0.12731588f, -0.04397884f, 0.15967071f, -0.07547080f, 0.16975890f, -0.04423354f, -0.09261435f, 0.11841170f, 
    0.04991714f, -0.00724569f, 0.06648487f, 0.14035240f, 0.21264000f, 0.26442200f, -0.10990172f, 0.00211761f, 
    -0.00556336f, -0.10339735f, 0.10787575f, 0.13377722f, -0.03132493f, 0.13425089f, -0.06609102f, 0.04280831f, 
    -0.11827823f, 0.09042457f, 0.06930292f, -0.12937245f, -0.05510280f, -0.08854932f, -0.11332973f, -0.01537871f, 
    0.09283697f, 0.04233585f, 0.04586066f, -0.00598030f, -0.04950764f, -0.04322881f, -0.00057502f, -0.39738142f, 
    -0.04431394f, 0.04797513f, -0.01117944f, 0.02716479f, -0.01999836f, -0.05077411f, -0.06314474f, -0.16948193f, 
    -0.12036926f, 0.22486685f, 0.00862535f, 0.05758585f, -0.00534534f, -0.04794068f, -0.01773647f, 0.10647156f, 
    -0.18103260f, -0.05938270f, -0.01708761f, 0.05340347f, 0.20453034f, 0.12929247f, 0.15407397f, 0.09041668f, 
    -0.05727233f, -0.16636527f, 0.06179419f, 0.02353646f, -0.00098479f, 0.13190590f, -0.07722576f, -0.03165907f, 
    0.06628836f, 0.08382623f, -0.05035248f, -0.00905253f, 0.00745993f, 0.06938966f, 0.03056199f, -0.02041140f, 
    0.01034362f, 0.12016276f, 0.00107092f, 0.21141276f, 0.06770957f, -0.24844235f, -0.02398554f, 0.10192471f, 
    -0.04508997f, 0.02414002f, -0.03188391f, -0.18367127f, 0.06579457f, 0.11026503f, 0.05251620f, 0.11430970f, 
    -0.04704751f, -0.03349430f, 0.00943450f, 0.20590401f, 0.09404276f, -0.01339146f, 0.12531072f, -0.12166968f, 
    0.08274963f, 0.08372831f, 0.04335160f, 0.00694801f, -0.01581064f, 0.11160053f, -0.27333450f, -0.00266842f, 
    0.16957268f, 0.09094330f, 0.19022562f, -0.25283387f, -0.19212440f, -0.21616386f, -0.04395095f, 0.03142801f, 
    0.11459567f, 0.23937476f, 0.31228587f, 0.36513245f, 0.11704501f, -0.03577282f, -0.07607384f, -0.17210028f, 
    0.03996249f, 0.03943992f, 0.05580578f, 0.07212282f, 0.26469681f, -0.13477084f, 0.07122524f, -0.12182775f, 
    -0.01465808f, -0.06400337f, 0.03750095f, 0.14039904f, -0.06501444f, -0.14114745f, -0.00431296f, 0.05304017f, 
    0.22263487f, -0.27296999f, 0.01624169f, -0.17166908f, 0.02338193f, 0.02881275f, -0.17733639f, -0.14997281f, 
    -0.04759574f, 0.02029758f, 0.08796858f, 0.13226494f, -0.29581958f, -0.17699806f, -0.30459845f, -0.04123693f, 
    0.11930273f, -0.07101860f, -0.00517361f, 0.00625025f, 0.02487781f, -0.09112570f, 0.05491300f, -0.19827822f, 
    0.03369265f, -0.19265673f, -0.06289706f, -0.37358880f, 0.09944749f, -0.06441469f, 0.08077320f, 0.05593658f, 
    0.05405862f, 0.03940294f, 0.01421794f, -0.02569599f, -0.10585874f, 0.03289507f, 0.14526050f, 0.26546681f, 
    -0.07346497f, -0.04100833f, -0.07301560f, 0.03594232f, 0.11268950f, 0.05446249f, 0.10257263f, 0.08346820f, 
    0.01278852f, 0.12083198f, 0.18304610f, 0.04631560f, -0.00281124f, 0.03034760f, 0.02417845f, -0.03165413f, 
    0.03937188f, 0.06906667f, 0.09550059f, 0.20186375f, 0.04254270f, 0.31324071f, 0.39292637f, 0.12076786f, 
    0.12111808f, 0.06880639f, 0.05993693f, 0.09554853f, -0.07990728f, -0.06147661f, -0.01480107f, -0.26868469f, 
    0.00919791f, 0.02266802f, 0.18354686f, 0.38364124f, 0.01066006f, 0.00853526f, -0.04184622f, 0.12151369f, 
    0.14314047f, -0.05076481f, 0.08127045f, 0.09207062f, -0.07799377f, -0.18095033f, -0.22676149f, 0.02133706f, 
    0.13078991f, 0.09235329f, -0.00235965f, -0.08055704f, 0.15705989f, 0.08911248f, -0.25762996f, 0.20447636f, 
    -0.08950032f, -0.01440483f, -0.22702438f, -0.00923409f, 0.14003964f, 0.03194600f, 0.06681999f, 0.01932372f, 
    0.08615480f, -0.12932745f, 0.09836440f, 0.08447863f, -0.16705035f, -0.19292313f, -0.16720960f, -0.21482167f, 
    0.03655050f, -0.00952051f, -0.12791918f, -0.07200604f, -0.04728557f, 0.11019681f, 0.14427017f, 0.14958179f, 
    -0.26514801f, -0.31496570f, -0.36221185f, -0.01726600f, 0.04680677f, -0.03976105f, -0.06733447f, 0.03148578f, 
    -0.03883709f, -0.05437246f, -0.03194686f, -0.19532473f, -0.13131191f, 0.03847150f, -0.23171611f, -0.19618803f, 
    0.14497973f, -0.11036905f, 0.00527636f, -0.00704621f, -0.02269586f, 0.04568193f, -0.23211527f, -0.16379103f, 
    0.13739341f, 0.17121312f, -0.09358568f, 0.27944174f, 0.15222342f, 0.09329966f, -0.09412848f, -0.03360683f, 
    -0.04980766f, -0.00425471f, 0.01346488f, -0.05839561f, -0.16875429f, 0.01955796f, 0.08302124f, 0.16407147f, 
    0.07617983f, 0.05909226f, 0.06779230f, 0.08931611f, 0.00970980f, -0.02774897f, -0.02663197f, -0.14201419f, 
    0.06810229f, 0.19746579f, 0.26451421f, 0.10595690f, -0.05756256f, -0.07891496f, 0.00781775f, -0.06750849f, 
    -0.00391750f, 0.06752072f, -0.06412901f, -0.05989438f, -0.46039894f, 0.02416886f, 0.04816347f, -0.15079322f, 
    0.05531397f, -0.00093434f, -0.09364003f, 0.07502463f, 0.10307094f, -0.09641970f, 0.10884939f, -0.00462292f, 
    -0.18122667f, 0.29402694f, 0.43771166f, -0.01943532f, -0.00584804f, 0.11439711f, -0.01594768f, -0.19741093f, 
    0.01536813f, 0.09202375f, -0.03633892f, 0.13379033f, -0.17518257f, -0.21675789f, -0.12531705f, -0.15684870f, 
    0.06540804f, 0.06315324f, -0.05051601f, 0.07780964f, -0.04684226f, 0.00212635f, -0.09282627f, 0.00729069f, 
    0.16533898f, 0.03077351f, 0.04316532f, 0.09124215f, 0.05496714f, -0.02656672f, 0.00574000f, -0.00945217f, 
    -0.09508278f, 0.03361147f, 0.11353292f, 0.14984983f, 0.05458082f, 0.06880337f, 0.34299195f, 0.19171363f, 
    0.13124025f, 0.00642029f, 0.15422153f, 0.18346350f, 0.06281320f, 0.09486466f, 0.07968867f, 0.01013520f, 
    -0.16047971f, -0.13924983f, -0.17313838f, -0.06196526f, 0.08921625f, -0.10127322f, 0.00708146f, -0.04481532f, 
    -0.05590029f, -0.04228053f, 0.02293445f, -0.11867896f, -0.03194293f, 0.22529829f, 0.12652104f, 0.05379394f, 
    0.07724009f, -0.04869438f, -0.14483131f, 0.17177343f, 0.04174869f, 0.03580384f, -0.06320293f, 0.00736065f, 
    0.16040806f, 0.21518169f, 0.09038156f, 0.34293881f, -0.00172084f, -0.05581439f, -0.02506029f, -0.06770044f, 
    0.03893140f, -0.10678384f, 0.18096365f, 0.13813746f, -0.26711208f, -0.12036476f, -0.40731975f, -0.23733820f, 
    -0.04134198f, -0.10429525f, -0.09767824f, -0.14546183f, 0.01372724f, 0.12806779f, -0.10784090f, 0.07246790f, 
    0.15853824f, -0.09230153f, -0.05117692f, 0.06562915f, 0.21300779f, -0.07364153f, -0.13839014f, -0.05618005f, 
    0.03864144f, -0.04374510f, 0.03023179f, -0.01899708f, 0.06294844f, 0.31993303f, 0.22944084f, 0.07684977f, 
    0.04015188f, 0.07905207f, 0.01552387f, 0.12781055f, -0.00701031f, 0.07362179f, -0.07518567f, -0.05070549f, 
    -0.06264106f, 0.02442909f, 0.07691552f, 0.16234390f, 0.06662597f, -0.09533092f, -0.07102127f, 0.07778476f, 
    0.02296753f, -0.00757687f, 0.01544995f, 0.01136102f, -0.16849051f, -0.04650814f, -0.03606971f, 0.11310276f, 
    0.00807181f, -0.15721364f, -0.12385003f, -0.01954495f, 0.01078867f, 0.12893771f, 0.05644152f, 0.16964611f, 
    0.03793408f, 0.08480522f, -0.06330112f, 0.01025065f, 0.07092873f, -0.05091778f, -0.04693549f, 0.00463826f, 
    0.01720866f, 0.04430461f, -0.13760757f, 0.11620813f, -0.11082217f, -0.42734030f, -0.05761403f, -0.09108227f, 
    -0.08682080f, 0.11615293f, 0.01545560f, -0.16328394f, 0.05823078f, -0.11377974f, -0.06301631f, 0.17868260f, 
    -0.07901742f, -0.09112138f, -0.23258981f, -0.00700810f, 0.17300063f, 0.15659903f, 0.14195400f, 0.02228606f, 
    -0.12789519f, -0.01038161f, 0.19430450f, 0.28405264f, -0.18039420f, 0.37514266f, -0.37066650f, -0.02020682f, 
    0.14794123f, -0.02406771f, -0.06593606f, -0.20541514f, -0.05588130f, -0.09040950f, -0.12258373f, -0.08079663f, 
    -0.82544661f, 0.04307068f, -0.31633779f, -0.22346576f, 0.06819666f, -0.05021029f, 0.02776990f, -0.06089066f, 
    0.16491471f, 0.00288098f, -0.07498399f, -0.05379928f, -0.16465782f, -0.11974874f, -0.23334599f, 0.34460431f, 
    0.05537884f, 0.02803736f, -0.18841374f, 0.13688241f, 0.03646538f, -0.02194990f, 0.07521801f, -0.15817928f, 
    0.16951299f, 0.22040616f, -0.13444450f, 0.09101424f, 0.06245369f, 0.02444265f, -0.01146919f, 0.07374337f, 
    -0.04183225f, -0.04098298f, 0.06179510f, -0.11203303f, 0.37750882f, 0.03305856f, 0.00710257f, 0.05951601f, 
    -0.08111132f, 0.10605973f, -0.00952647f, 0.01771388f, 0.03609749f, -0.01976152f, 0.04404632f, 0.13325639f, 
    -0.02817515f, -0.06590360f, 0.07493614f, 0.27109155f, 0.10108504f, 0.11679793f, 0.03276056f, -0.08859883f, 
    -0.00788339f, -0.02163948f, -0.00095532f, -0.06751204f, 0.02661113f, -0.01199389f, -0.00974896f, 0.15767092f, 
    0.10169829f, 0.01836498f, -0.14615186f, -0.11256326f, 0.12954180f, -0.01356081f, 0.11566056f, 0.01397753f, 
    0.19593368f, 0.04766681f, 0.12584212f, -0.07794538f, 0.02936791f, 0.04894913f, -0.06022636f, -0.05225135f, 
    0.07736851f, -0.10236512f, 0.00872082f, 0.02038242f, -0.08957554f, -0.03296118f, -0.15325075f, -0.04192302f, 
    0.03668508f, -0.06437584f, 0.01041705f, 0.04592436f, 0.12444407f, -0.16520660f, 0.07841907f, -0.06256719f, 
    0.00815970f, 0.09311507f, 0.16833778f, 0.39458296f, -0.21809459f, 0.22140083f, 0.09902973f, 0.07722304f, 
    0.04988880f, 0.00637691f, 0.01160050f, -0.12919687f, -0.38928583f, -0.18011542f, -0.28614292f, -0.01136581f, 
    -0.08062536f, 0.06457654f, -0.02328790f, -0.05846408f, 0.17805658f, 0.01494773f, 0.07437687f, 0.07758033f, 
    -0.29405776f, -0.03176525f, -0.09372556f, 0.20121662f, 0.17189167f, -0.01305285f, -0.15402140f, -0.10819922f, 
    0.00624175f, 0.08351940f, -0.08299340f, 0.02834355f, 0.08766831f, 0.05934062f, -0.13234381f, -0.03008489f, 
    0.08082484f, -0.13198698f, -0.02236129f, -0.23983136f, 0.08580592f, 0.11513903f, -0.04462242f, -0.07427400f, 
    -0.17530183f, -0.11215224f, 0.12105255f, 0.07044435f, 0.18057151f, -0.01410590f, -0.00933918f, -0.03066495f, 
    -0.03012156f, 0.00345224f, 0.05434931f, 0.08549090f, 0.59087980f, -0.27775618f, 0.24655718f, -0.03135651f, 
    0.01131472f, 0.02305385f, -0.07313576f, 0.11190780f, -0.00332270f, 0.06021283f, -0.09076907f, -0.10036208f, 
    0.20395704f, 0.01789203f, 0.15804453f, -0.12703796f, -0.00888235f, -0.04416922f, 0.01813295f, 0.04816108f, 
    -0.03625312f, -0.02062466f, -0.06903904f, 0.02163698f, -0.02886521f, 0.01036189f, 0.00565178f, 0.49466693f, 
    -0.08697779f, 0.24721384f, 0.11446036f, -0.02864847f, 0.05381619f, -0.00784659f, 0.02459663f, -0.03748564f, 
    -0.42395216f, -0.19052900f, -0.14205027f, 0.44312435f, 0.16088645f, 0.10257839f, -0.11164260f, -0.05326149f, 
    -0.03069336f, -0.07520146f, 0.08740106f, 0.11566635f, -0.17370500f, -0.27319509f, -0.01301798f, 0.03090942f, 
    0.07543858f, -0.03529554f, -0.09718121f, 0.03915321f, 0.00996365f, -0.08662115f, 0.05499952f, 0.08751004f, 
    0.00779028f, 0.03479281f, -0.19967607f, 0.19676289f, 0.08650289f, 0.01311559f, 0.03597171f, -0.05553475f, 
    0.09702414f, 0.09126962f, 0.17944500f, 0.04293909f, 0.04725348f, 0.05379869f, -0.14802013f, 0.19106863f, 
    0.02995250f, 0.00913105f, 0.12123118f, 0.00484393f, 0.03946916f, -0.02971050f, 0.06792597f, 0.18572390f, 
    -0.26857522f, -0.04271906f, -0.11107654f, -0.09860498f, 0.00808682f, 0.09525237f, -0.13160889f, 0.07270862f, 
    0.03621486f, 0.02268881f, 0.05822195f, -0.05039939f, 0.33120573f, 0.20266782f, 0.37035897f, 0.36428261f, 
    -0.08469979f, 0.30677396f, 0.09063824f, 0.21675770f, -0.05243596f, -0.01224362f, 0.00033072f, -0.02286386f, 
    0.12389148f, -0.19948331f, -0.04923284f, 0.11151642f, 0.06698985f, 0.05416773f, 0.11030658f, 0.05826626f, 
    -0.06031123f, -0.08546597f, 0.07628130f, 0.13629724f, 0.02965558f, -0.20510493f, -0.08403083f, -0.17782694f, 
    -0.07735842f, -0.07406142f, -0.05040271f, 0.04712440f, 0.02650779f, -0.02359479f, -0.02157835f, -0.06561959f, 
    0.10445771f, 0.06097000f, -0.04160658f, -0.06844962f, 0.03171599f, -0.03750748f, 0.01273612f, -0.12924631f, 
    0.21462263f, -0.07397588f, -0.16577710f, -0.26518112f, 0.19984064f, 0.02716180f, -0.04952437f, 0.31745085f, 
    0.10555550f, -0.06813487f, 0.07543401f, 0.05364459f, 0.10439113f, -0.04896881f, 0.14522766f, -0.09834117f, 
    -0.10365262f, 0.01958701f, 0.15658101f, 0.05816676f, -0.06495012f, 0.14759080f, 0.10140962f, 0.03583983f, 
    0.08878566f, 0.08753415f, 0.03399373f, 0.14105955f, -0.14437193f, 0.12321194f, 0.22041981f, 0.10776863f, 
    0.06161433f, -0.08849160f, -0.07939743f, -0.10426335f, -0.05954281f, 0.10717745f, -0.04301195f, 0.31480181f, 
    0.18117322f, 0.22439706f, 0.09169722f, 0.14009029f, 0.01263359f, -0.02177396f, -0.18994635f, -0.05180948f, 
    -0.09568469f, -0.04251460f, -0.06590898f, 0.11920884f, -0.14976482f, -0.16424546f, -0.19385424f, -0.19145820f, 
    -0.13490655f, -0.13251339f, -0.06175867f, -0.00197117f, -0.02990397f, -0.03176761f, -0.09606471f, 0.17573017f, 
    -0.04786981f, -0.03562367f, 0.01915746f, 0.04045233f, 0.02341680f, 0.02672287f, 0.03788971f, -0.03097326f, 
    -0.03835091f, 0.00775339f, -0.03932588f, 0.00185502f, 0.00698835f, -0.04623004f, -0.05507222f, -0.03677863f, 
    -0.00015104f, 0.00993489f, 0.03770429f, -0.03331595f, -0.03003867f, -0.00243772f, -0.01685409f, 0.01811899f, 
    -0.04314439f, 0.00296271f, 0.02999743f, 0.04075816f, -0.00164981f, -0.04538380f, -0.01662163f, -0.03327524f, 
    0.02745957f, 0.01074400f, 0.02646603f, 0.00441716f, -0.05581180f, -0.05131680f, -0.03046803f, 0.04446403f, 
    -0.05084651f, -0.04427729f, -0.04760705f, 0.01991306f, -0.01602037f, -0.04983437f, -0.00769759f, -0.05382795f, 
    0.01518200f, 0.00182341f, 0.01875384f, -0.03398719f, 0.00625267f, -0.01482391f, 0.03759240f, -0.01201896f, 
    -0.04170041f, -0.02621918f, -0.04193961f, -0.05209878f, -0.00260744f, 0.00728770f, 0.02749497f, -0.01636183f, 
    -0.03781060f, -0.04061560f, 0.01267251f, 0.03955900f, -0.05463472f, -0.04694974f, -0.01108567f, 0.00923036f, 
    -0.04590065f, 0.02476095f, -0.02642893f, -0.05386284f, 0.00451615f, -0.01666734f, -0.00717619f, -0.03587433f, 
    -0.02343731f, 0.01202820f, 0.01445331f, -0.03603353f, -0.01715296f, -0.04660922f, -0.00605509f, 0.01008378f, 
    -0.01297989f, -0.03082622f, 0.01787639f, 0.03873711f, -0.03975880f, -0.04732081f, -0.03881700f, 0.02957288f, 
    -0.00321340f, -0.00041360f, 0.00130153f, 0.03406813f, -0.03819832f, -0.04174171f, 0.03329432f, -0.02754413f, 
    -0.01262099f, -0.02414487f, -0.02216098f, 0.00894860f, -0.02071795f, -0.00367947f, -0.05137892f, -0.01681036f, 
    0.01754926f, -0.02529202f, 0.01132945f, -0.00548325f, -0.05476999f, 0.00415451f, 0.02075130f, -0.03593460f, 
    -0.03589968f, -0.05462730f, -0.04254179f, -0.00274589f, -0.03937199f, 0.02020277f, 0.03408596f, 0.03723223f, 
    0.03845315f, -0.04070102f, 0.03845501f, 0.04412707f, 0.01952434f, -0.03184410f, -0.00572989f, -0.00241236f, 
    -0.00381210f, -0.00817341f, 0.01884734f, -0.05222842f, -0.02741794f, -0.04221360f, -0.03286162f, -0.04384629f, 
    -0.05033428f, 0.03861383f, 0.02843519f, 0.02967839f, 0.04172851f, 0.02801410f, 0.02008536f, 0.02853753f, 
    0.02274135f, -0.02019322f, 0.00110522f, -0.01505979f, 0.04191037f, 0.01626854f, -0.05345702f, -0.03832977f, 
    -0.00514997f, -0.00214536f, -0.04583133f, -0.03706256f, 0.02460520f, -0.05432359f, -0.00203565f, -0.02770082f, 
    -0.00049986f, -0.02386843f, -0.03646933f, -0.04493877f, -0.04649355f, -0.02212118f, 0.03703534f, -0.02195426f, 
    -0.00803051f, 0.03773158f, 0.03314778f, -0.03848992f, -0.02814145f, 0.03944158f, -0.05281538f, -0.02449766f, 
    0.00262749f, -0.04072713f, -0.01363512f, 0.01724188f, 0.00258179f, -0.03288106f, 0.02024559f, 0.03357170f, 
    0.04266240f, 0.03543946f, -0.04436593f, 0.03115512f, 0.01288988f, -0.05591850f, 0.00466518f, -0.05349851f, 
    -0.01476132f, -0.00434524f, 0.02920201f, 0.03548497f, 0.03911316f, -0.04132075f, -0.03302151f, 0.00160512f, 
    0.04431500f, -0.02286097f, -0.04061802f, -0.00059834f, -0.02949619f, -0.04408999f, 0.04471296f, -0.00510755f, 
    0.00243398f, -0.00387522f, -0.05067344f, -0.02728783f, -0.01514805f, -0.01049560f, -0.04024735f, 0.00076880f, 
    -0.01457860f, 0.02614623f, -0.00434764f, -0.00497451f, 0.04304558f, -0.05289577f, 0.02341229f, -0.05211006f, 
    0.04496207f, -0.01099355f, -0.02099831f, -0.02592764f, -0.01539849f, 0.02075881f, -0.01651589f, 0.00686683f, 
    -0.04932604f, -0.01333470f, 0.04481980f, 0.02449520f, 0.03799221f, -0.02787430f, 0.00483523f, -0.00725499f, 
    -0.05037639f, 0.02561701f, -0.02979991f, -0.03544517f, 0.03807321f, -0.04649164f, -0.05552736f, -0.04316822f, 
    -0.02837002f, 0.01879845f, 0.03666748f, -0.03475092f, 0.02533243f, -0.00589914f, -0.01836101f, 0.03875585f, 
    0.01458005f, -0.05362238f, 0.03510885f, 0.00919449f, -0.01841196f, 0.02703519f, 0.02670986f, -0.02521162f, 
    0.03213222f, 0.00385397f, -0.03008426f, -0.01506693f, 0.01382472f, 0.03446835f, -0.02245395f, 0.01366339f, 
    -0.03350003f, -0.05467635f, -0.05254217f, -0.02159775f, -0.02632057f, 0.01535090f, -0.02203841f, -0.00144760f, 
    -0.02444841f, -0.03722463f, -0.00082918f, -0.02552193f, 0.03137575f, 0.00190768f, -0.01981405f, 0.00571119f, 
    0.01420316f, -0.05500779f, 0.02762448f, 0.00605674f, -0.05523428f, -0.05286525f, -0.00281074f, 0.00354481f, 
    0.01055934f, 0.03900664f, 0.00775732f, -0.02502620f, -0.02371473f, -0.02040756f, -0.00177831f, -0.03872950f, 
    0.01273543f, 0.02702903f, 0.03110647f, -0.05323743f, 0.03234768f, -0.04406922f, -0.01615595f, 0.01533834f, 
    0.03445644f, -0.00267195f, -0.04019048f, -0.00563005f, -0.03888124f, -0.05603591f, -0.04002010f, -0.03848771f, 
    -0.04447955f, -0.04944321f, 0.00468196f, -0.03673258f, -0.01495225f, -0.04156663f, -0.00299010f, 0.01933040f, 
    0.00672411f, 0.00152879f, 0.01190347f, -0.00003441f, -0.03386235f, -0.00714031f, 0.02083093f, 0.03966985f, 
    -0.04595295f, 0.03988425f, 0.00975783f, 0.01594347f, 0.01653629f, -0.00403920f, 0.03685530f, -0.01660702f, 
    -0.05565604f, -0.03116946f, -0.02027469f, -0.04661798f, -0.01720116f, -0.01011537f, -0.05549175f, 0.03667073f, 
    0.00617940f, -0.03276899f, -0.03279334f, 0.00963509f, 0.01811014f, 0.03650330f, -0.02096987f, 0.01328012f, 
    -0.01933713f, 0.00651413f, -0.02562865f, 0.00821169f, 0.01780731f, -0.02170873f, 0.04597211f, 0.02382977f, 
    0.03948513f, 0.03746787f, 0.00658020f, 0.00068149f, -0.01278042f, 0.04222609f, -0.02594032f, -0.04433063f, 
    -0.44949618f, 0.18819286f, 0.14951327f, 0.00250965f, -0.11378590f, 0.00774798f, 0.02290373f, 0.17694108f, 
    -0.04302686f, -0.10698186f, -0.05912074f, 0.02407030f, -0.09415612f, -0.09709542f, -0.07511609f, 0.11683220f, 
    0.09320123f, -0.25206012f, 0.14015323f, -0.07082533f, -0.00834410f, 0.07384311f, -0.05067784f, -0.01970550f, 
    0.26521048f, -0.00011662f, -0.10808069f, -0.14128533f, 0.00007251f, 0.02246019f, 0.04198769f, 0.04591727f, 
    -0.01907174f, 0.10291487f, -0.05662423f, 0.08571976f, 0.43363100f, -0.08907478f, 0.06003817f, -0.30010635f, 
    -0.01520785f, 0.04339093f, 0.07873127f, -0.03788440f, -0.00349401f, 0.07847110f, -0.02451902f, 0.06443010f, 
    -0.39207271f, 0.04565414f, -0.07186332f, -0.01850481f, 0.15218963f, 0.13951518f, -0.03734645f, 0.04832553f, 
    0.00412820f, -0.01896304f, 0.06731263f, 0.05318591f, -0.12578744f, -0.16478321f, 0.36394143f, -0.03165353f, 
    -0.07051759f, 0.07501786f, 0.00605043f, -0.04867225f, -0.02253826f, 0.01375288f, 0.01775989f, 0.10507473f, 
    0.13054587f, 0.15298618f, 0.10617109f, 0.04373900f, -0.01091100f, 0.00920741f, -0.00155372f, -0.05505428f, 
    0.07701657f, -0.00148284f, -0.12715921f, -0.04875340f, -0.02145023f, -0.03534296f, 0.00731675f, -0.19040394f, 
    0.03464475f, 0.09950940f, -0.16913335f, -0.06800327f, 0.06439389f, 0.02000520f, -0.14063862f, -0.15479887f, 
    -0.05446316f, -0.02588704f, 0.19705993f, -0.07777669f, 0.01870770f, -0.01312476f, 0.06665320f, -0.28231385f, 
    0.02063314f, -0.01427502f, 0.07611417f, 0.01563152f, -0.03426856f, 0.10160007f, 0.01812420f, 0.15703051f, 
    0.02154388f, 0.04760329f, 0.02265781f, -0.07375643f, 0.06069255f, -0.04062160f, 0.08263212f, 0.01785328f, 
    0.13719481f, 0.07659043f, 0.15031792f, -0.02227192f, 0.03752575f, 0.11732473f, -0.07917602f, 0.00896826f, 
    0.13101062f, 0.05386319f, 0.03382823f, -0.03357079f, 0.24812852f, -0.05179355f, -0.03880564f, 0.09696692f, 
    0.06568217f, 0.05809927f, 0.06858346f, 0.05364077f, 0.00778098f, 0.01212143f, 0.04235720f, 0.04051090f, 
    0.21200407f, -0.00496610f, 0.02247169f, 0.15110755f, 0.04501270f, 0.08898700f, 0.07341218f, 0.04428172f, 
    0.02340600f, -0.06095630f, -0.12417325f, -0.00414957f, 0.04112500f, 0.00204882f, -0.12717733f, 0.05009878f, 
    0.12421557f, -0.15987204f, 0.13536461f, 0.07196948f, -0.12706140f, -0.04082114f, 0.06804494f, -0.04880241f, 
    -0.28126162f, -0.04355703f, 0.01141081f, -0.10404085f, -0.01099055f, 0.06126430f, -0.02083737f, 0.15032759f, 
    0.06541450f, -0.05228417f, 0.01436117f, -0.03292000f, 0.10802379f, 0.16048975f, 0.09354144f, -0.05680598f, 
    -0.08476885f, 0.14746827f, -0.10155592f, 0.27550000f, -0.04002881f, -0.06112469f, 0.02533837f, -0.00880600f, 
    -0.16106060f, 0.01726350f, 0.16540730f, 0.02793083f, -0.00859330f, 0.02022884f, -0.07233337f, 0.10675892f, 
    0.02625209f, -0.02283828f, -0.00052076f, -0.18501830f, 0.40054137f, -0.05097069f, 0.05615657f, -0.00977807f, 
    0.11106063f, 0.02597820f, -0.05577090f, -0.19136664f, -0.02852422f, -0.10342395f, -0.02488946f, 0.07782135f, 
    0.31040326f, 0.02318424f, -0.14767738f, -0.02170438f, 0.03738875f, 0.16113545f, -0.02457612f, 0.00376772f, 
    0.04417555f, -0.06502007f, -0.06682542f, 0.03957368f, 0.25513729f, 0.09482120f, 0.01868703f, -0.01779344f, 
    -0.02939922f, 0.03812061f, 0.03318129f, 0.10774718f, 0.02991084f, -0.07779957f, -0.02012915f, 0.06635047f, 
    -0.22328869f, 0.14898573f, -0.11800636f, -0.17373510f, 0.00349172f, -0.07150105f, 0.15585616f, -0.02989732f, 
    0.03829833f, -0.01636799f, 0.02269375f, 0.15960439f, -0.11136821f, 0.00587030f, 0.11639670f, -0.01044348f, 
    -0.04518249f, 0.01547546f, 0.02137278f, -0.01809437f, 0.01530773f, 0.06699429f, -0.09813850f, 0.07055033f, 
    0.18391196f, -0.10480037f, 0.08600395f, 0.13655449f, 0.09804236f, 0.15049867f, 0.00977447f, -0.03089532f, 
    0.08436767f, -0.04200175f, 0.07208913f, -0.03067275f, -0.01353991f, 0.17412601f, 0.10677452f, -0.09881838f, 
    -0.03976806f, -0.15566052f, -0.06836909f, -0.10845672f, 0.04560594f, -0.02164765f, -0.00729102f, -0.02284258f, 
    -0.14695200f, 0.11423143f, 0.03502088f, -0.00071530f, -0.01125156f, -0.10308730f, 0.00652791f, 0.07975032f, 
    0.10536509f, -0.06869886f, -0.06134894f, 0.01883902f, 0.10081889f, -0.03562415f, 0.15742493f, 0.14899217f, 
    -0.03694772f, 0.04787820f, 0.03507262f, 0.06091709f, 0.11373595f, -0.16143417f, -0.09713022f, 0.10169902f, 
    -0.15045893f, 0.11732764f, 0.00683822f, 0.10920590f, -0.02017650f, -0.08191098f, 0.01763694f, 0.03617482f, 
    0.03309630f, -0.00607926f, -0.13583697f, -0.14246354f, 0.00026168f, 0.16928913f, 0.09910505f, -0.20816734f, 
    -0.12361257f, 0.02849389f, -0.01873526f, -0.20046753f, -0.01293283f, -0.00200013f, 0.01333968f, -0.10609055f, 
    0.03600808f, 0.06464332f, 0.06062266f, 0.02389311f, -0.06188430f, 0.00610229f, 0.02258444f, -0.06503437f, 
    -0.14982380f, -0.08601476f, -0.03147370f, 0.11872764f, 0.08798689f, -0.12121234f, 0.02000801f, -0.11515464f, 
    -0.04331496f, 0.02044430f, 0.01846770f, 0.03200111f, 0.02566803f, 0.11565376f, 0.07865889f, 0.13104063f, 
    0.15317781f, -0.04886327f, 0.02711835f, 0.19052131f, 0.05632268f, -0.05681351f, -0.07777879f, 0.00549753f, 
    0.05375983f, -0.07357509f, 0.13112786f, 0.00476749f, -0.01489942f, 0.26909956f, -0.02204298f, 0.42666462f, 
    0.09930357f, -0.09643658f, 0.03225378f, -0.04597184f, -0.01527277f, 0.01726697f, 0.01756919f, -0.01879933f, 
    -0.21773356f, -0.04882080f, 0.10004540f, 0.08389910f, -0.05706763f, 0.05722887f, -0.02037324f, 0.35242370f, 
    -0.01260881f, 0.01469529f, 0.22666535f, 0.25990304f, 0.08951006f, 0.18012896f, 0.06242504f, 0.17877136f, 
    -0.07081508f, 0.04253715f, -0.14871708f, -0.10330582f, -0.18071653f, 0.01008073f, -0.00256862f, 0.04157116f, 
    -0.40519637f, -0.04086149f, -0.14210308f, -0.23479608f, -0.15254472f, -0.10534014f, -0.01180548f, 0.18069389f, 
    -0.03561349f, 0.09552526f, -0.02172076f, 0.10280582f, -0.32908839f, 0.18567102f, -0.16067398f, 0.25134301f, 
    0.19109567f, 0.06741176f, 0.01570781f, 0.26963601f, -0.20333457f, -0.04503832f, 0.10980455f, -0.30571431f, 
    -0.38295996f, -0.04596344f, 0.24846275f, -0.04036218f, 0.01246255f, 0.14879277f, -0.00357339f, -0.04146625f, 
    0.00695169f, 0.18259951f, -0.13643834f, 0.10835225f, 0.10291439f, -0.07854008f, 0.16449346f, -0.01152897f, 
    0.09886061f, 0.10246668f, 0.02457552f, 0.10346802f, 0.12353101f, -0.01739132f, 0.00866914f, 0.17235108f, 
    0.37961894f, 0.21445701f, 0.22449811f, -0.07266942f, -0.11125556f, -0.07658132f, 0.10004308f, 0.11056548f, 
    0.11459757f, 0.11146218f, -0.05160427f, 0.01607795f, -0.14082046f, -0.16768499f, -0.01009438f, -0.07580861f, 
    0.15603659f, -0.03285834f, -0.17456743f, 0.00387147f, -0.23605233f, -0.13877071f, -0.08664816f, -0.09676709f, 
    0.06344238f, 0.10049631f, 0.02893388f, -0.09354478f, -0.11251797f, 0.09445743f, 0.13744651f, -0.07808058f, 
    0.15551002f, -0.09319669f, -0.00591304f, 0.11693823f, -0.19149928f, 0.12617368f, 0.07731083f, -0.00317860f, 
    -0.13638201f, 0.17852774f, 0.07750098f, -0.10315349f, 0.12511644f, -0.14647307f, 0.10845450f, -0.03204119f, 
    0.03749530f, 0.26336664f, -0.34827992f, 0.28590286f, 0.13679230f, 0.10394177f, 0.21603972f, -0.11987665f, 
    -0.05277001f, -0.01860929f, -0.05209260f, -0.04806791f, -0.07056202f, -0.16384132f, -0.26020813f, -0.11621241f, 
    -0.03499855f, 0.04650646f, 0.07659987f, -0.17091472f, 0.05455645f, 0.05182482f, 0.26895586f, 0.25605950f, 
    -0.06345190f, -0.07223587f, -0.12469120f, -0.15822615f, 0.02861248f, 0.07578388f, -0.05882108f, -0.10901037f, 
    -0.20642643f, -0.18747357f, -0.02105005f, -0.25724664f, -0.07058574f, 0.02683303f, -0.15491344f, 0.08245227f, 
    0.00883949f, 0.01841290f, -0.04536217f, -0.02055513f, 0.08871377f, 0.00167087f, 0.00529083f, -0.17982264f, 
    0.22491811f, 0.24577227f, 0.26563889f, 0.09685767f, -0.09484520f, -0.32180637f, -0.18726064f, -0.14606616f, 
    -0.03101137f, -0.04898428f, 0.04320788f, -0.14430164f, 0.06073584f, -0.31938371f, 0.20646182f, 0.07938755f, 
    0.17529045f, 0.06695306f, -0.00084711f, 0.18350597f, -0.16110568f, -0.11689282f, -0.20162192f, -0.37732080f, 
    0.04271501f, 0.00293090f, 0.26529300f, 0.16880053f, 0.07120995f, 0.01207066f, -0.27664289f, 0.17609257f, 
    -0.23120537f, -0.10985980f, 0.01089266f, -0.17113997f, 0.05002910f, 0.20138016f, -0.24110141f, -0.04307246f, 
    0.11515960f, 0.03130126f, 0.19709030f, 0.07672310f, -0.08667444f, 0.03702411f, -0.16111597f, -0.07369037f, 
    -0.00103106f, 0.19469002f, 0.06019595f, -0.30655903f, -0.06152503f, -0.14120722f, 0.08442020f, 0.06437011f, 
    -0.07002440f, 0.11253232f, -0.07865974f, 0.02057689f, -0.04688735f, -0.12668359f, -0.08984121f, -0.05755109f, 
    -0.05772029f, 0.01955214f, 0.03037352f, -0.16404042f, -0.13808435f, -0.14065209f, -0.05701268f, -0.08925676f, 
    -0.12001154f, 0.05094877f, -0.03686145f, 0.01899550f, -0.08049500f, 0.02590699f, 0.09532660f, 0.11705760f, 
    0.13470556f, 0.12225505f, 0.24869570f, 0.22249910f, -0.05626592f, 0.11502530f, 0.03813145f, -0.05842242f, 
    -0.06383016f, 0.02195691f, 0.01288977f, 0.33293778f, 0.22064242f, 0.03589818f, -0.09953865f, 0.31091347f, 
    -0.01462625f, 0.05116322f, -0.11689537f, -0.02500257f, 0.04073830f, 0.05509409f, -0.23170912f, -0.16278602f, 
    0.04937937f, 0.04286926f, 0.14023237f, 0.14751944f, 0.26038495f, 0.34783441f, 0.04805448f, 0.26440793f, 
    0.04006848f, 0.14768746f, 0.19578680f, 0.10466364f, -0.02327731f, 0.06110539f, -0.02828950f, -0.05857366f, 
    0.08411226f, 0.15742207f, -0.05328340f, -0.29036695f, -0.11501676f, -0.06929041f, 0.20252396f, 0.15557343f, 
    0.21516785f, 0.01191494f, 0.13221069f, 0.09530871f, 0.01039244f, 0.07063453f, -0.06220609f, -0.25249580f, 
    0.05329031f, 0.07088283f, 0.15883029f, 0.07788660f, -0.04035887f, -0.04120621f, -0.02947965f, 0.01390042f, 
    0.02803831f, 0.26353544f, 0.13787583f, 0.11987311f, 0.04117378f, -0.07990522f, -0.09362398f, -0.08811381f, 
    -0.10326247f, -0.10080387f, -0.28453550f, -0.29992419f, 0.11089566f, 0.00856934f, 0.05725488f, 0.01820995f, 
    -0.07371580f, -0.27874050f, 0.10915788f, 0.05119180f, 0.02921169f, -0.01935905f, -0.03270210f, -0.11961966f, 
    -0.05248217f, -0.00780624f, -0.03639984f, -0.02388874f, 0.01680674f, 0.08024450f, 0.09932031f, 0.14171843f, 
    0.20365363f, 0.07176503f, -0.07216135f, 0.30101743f, -0.00745934f, -0.10191201f, 0.31229201f, 0.33810306f, 
    -0.04070988f, 0.06841514f, -0.03027300f, -0.14068581f, 0.21897967f, 0.24102791f, 0.19747207f, 0.37009230f, 
    -0.08806717f, -0.04274103f, 0.11945570f, 0.34096658f, -0.01178593f, 0.05831803f, 0.08726230f, -0.15368430f, 
    0.01949829f, 0.09791540f, 0.26310727f, 0.12449805f, 0.12154080f, 0.10495289f, -0.29370254f, 0.05014490f, 
    -0.03715220f, 0.13032445f, 0.00359672f, -0.35215944f, -0.11207439f, -0.10009348f, 0.02928932f, 0.14645468f, 
    -0.44572309f, 0.06854302f, 0.05480167f, -0.06310263f, -0.03990411f, -0.05631619f, -0.10220155f, -0.03903460f, 
    0.06980481f, 0.01020249f, 0.21671143f, 0.12178098f, -0.19889326f, 0.23637512f, -0.08513319f, 0.07267077f, 
    -0.05887937f, 0.05370379f, 0.10813037f, -0.06281061f, 0.00262597f, 0.09860950f, 0.08448578f, 0.04802560f, 
    -0.51012862f, -0.10069535f, 0.15281706f, 0.09535838f, -0.08378526f, -0.04091965f, 0.05212121f, 0.01749651f, 
    0.02032080f, 0.02278400f, -0.07482658f, 0.10480715f, -0.25908354f, 0.11775848f, 0.01904495f, 0.08205156f, 
    0.31767040f, 0.16552077f, 0.05256948f, 0.15099792f, 0.14996499f, -0.01230063f, -0.04147916f, 0.03185277f, 
    -0.24509807f, 0.03104683f, -0.03463606f, -0.29173678f, -0.00638139f, 0.08908673f, -0.01315903f, 0.05138608f, 
    0.01913761f, -0.00984517f, -0.00592590f, -0.06399102f, 0.23557444f, -0.29552516f, 0.07325315f, -0.07659708f, 
    0.19350982f, -0.07489628f, 0.31970194f, 0.17260897f, 0.19242385f, 0.08521432f, 0.07500937f, 0.03761958f, 
    0.10517733f, 0.13376734f, 0.25275642f, -0.07292008f, -0.06870002f, -0.18380032f, -0.12402895f, 0.01119788f, 
    -0.04192651f, 0.07611722f, 0.21370439f, 0.10104061f, -0.16415721f, -0.34328288f, -0.02311679f, -0.29273632f, 
    0.04188998f, 0.03355328f, -0.04937299f, 0.03230226f, -0.07224690f, -0.07049789f, 0.06466638f, -0.08624530f, 
    -0.10107964f, -0.11446936f, 0.03244654f, -0.27548641f, -0.00226039f, -0.07873826f, 0.07800394f, -0.12643996f, 
    -0.00046962f, -0.02008315f, 0.04266663f, 0.00051810f, -0.09563141f, 0.16143875f, -0.08030743f, -0.02193683f, 
    0.03121589f, 0.23043223f, 0.02699295f, -0.08130088f, 0.22489831f, -0.02717366f, 0.21045244f, -0.11229956f, 
    -0.06789180f, -0.05779825f, 0.00847417f, -0.05004682f, 0.20431857f, 0.23375784f, 0.31764415f, 0.20092198f, 
    -0.04285615f, 0.01666082f, -0.06386978f, 0.02097686f, -0.03270154f, -0.01302457f, 0.04623403f, -0.00370998f, 
    -0.04547942f, -0.03453695f, -0.01782239f, -0.04770439f, -0.09977753f, -0.00506237f, 0.16961610f, 0.13776292f, 
    -0.17015661f, -0.09188932f, -0.09371446f, -0.15088166f, 0.01600297f, 0.04652996f, -0.07299042f, 0.03042721f, 
    0.05548165f, 0.05303214f, -0.01755354f, -0.01419820f, 0.10291307f, 0.03252674f, -0.09541851f, 0.26617938f, 
    0.11472430f, -0.05361560f, 0.01389742f, -0.05237911f, 0.02870807f, 0.02057107f, 0.03383707f, 0.10723878f, 
    -0.13418165f, -0.14287269f, 0.16022064f, 0.25673434f, 0.05367749f, 0.02165612f, -0.02948727f, -0.01201627f, 
    0.00271807f, 0.01756392f, 0.12098391f, 0.14871125f, 0.32142642f, -0.20239465f, 0.03243567f, -0.11122320f, 
    0.06098042f, 0.14620623f, 0.17164937f, 0.19075255f, -0.00391172f, -0.02539575f, 0.00213286f, -0.09285178f, 
    0.06262885f, -0.12785928f, 0.10974543f, -0.14377333f, 0.10242175f, 0.04585385f, 0.03456933f, 0.33682638f, 
    0.04206099f, -0.02970768f, 0.06529836f, -0.12941557f, 0.05436953f, 0.02040954f, -0.04223891f, -0.17969181f, 
    -0.02439252f, 0.07611135f, 0.19716528f, 0.35088038f, -0.06535088f, -0.07389036f, -0.07006755f, 0.02452261f, 
    -0.07183953f, 0.13179094f, 0.14067526f, -0.12570979f, -0.01160256f, -0.00203448f, 0.11878715f, 0.13019195f, 
    0.07772116f, 0.10361257f, 0.08109950f, 0.25289667f, -0.02773017f, -0.09643603f, -0.00164270f, -0.09875181f, 
    0.00703753f, -0.00336030f, 0.02970224f, 0.00139741f, 0.02894214f, -0.00856333f, 0.04447995f, -0.06422456f, 
    -0.44149140f, 0.26685122f, -0.10597347f, -0.03871519f, -0.13534279f, 0.02003323f, 0.20297143f, 0.01819821f, 
    0.21814989f, 0.14280023f, 0.19847172f, 0.19998638f, -0.04927526f, -0.14264573f, -0.12510481f, -0.13279173f, 
    -0.03538752f, -0.03424605f, -0.02143125f, 0.17219900f, 0.00173108f, 0.01208513f, -0.00066612f, -0.01384694f, 
    -0.03176880f, 0.02386671f, -0.23380019f, -0.02718189f, 0.07384726f, 0.04973277f, -0.06398186f, -0.05617880f, 
    0.13146560f, -0.11748269f, 0.12143953f, 0.22716336f, 0.01298345f, 0.10276029f, 0.04646474f, 0.09129378f, 
    0.05478049f, -0.00178272f, 0.02302597f, -0.03653001f, 0.09850673f, -0.03750176f, -0.00544357f, -0.02219721f, 
    -0.40441182f, 0.15974586f, -0.25824383f, -0.18571439f, -0.01017592f, 0.01405341f, -0.00308810f, 0.07818596f, 
    0.20635976f, 0.12149013f, 0.18576513f, 0.12360061f, 0.24575132f, 0.01549591f, -0.05075998f, 0.00645096f, 
    0.21297137f, -0.04638708f, 0.23112100f, 0.11530864f, 0.20500697f, 0.11004877f, 0.04390706f, 0.21155643f, 
    0.05728697f, -0.03799856f, -0.08452196f, 0.01461327f, 0.12506238f, -0.04830076f, 0.06771892f, -0.09224314f, 
    0.05514029f, -0.00816156f, -0.16415994f, -0.08356391f, -0.20049934f, -0.08395763f, -0.19141366f, -0.35828614f, 
    -0.04760755f, -0.16591497f, -0.05493189f, -0.05474170f, 0.03748704f, 0.05596527f, -0.04080618f, -0.09923366f, 
    0.00301566f, -0.13507491f, 0.03827557f, -0.14819472f, 0.05715123f, 0.08638636f, -0.08497615f, -0.06738688f, 
    0.07967500f, -0.02650259f, 0.01972786f, 0.05965375f, 0.06647534f, -0.13584262f, 0.19281293f, 0.12722099f, 
    0.00561417f, 0.04015217f, 0.04600200f, -0.08105481f, 0.07398013f, -0.01151436f, 0.34602997f, 0.20314519f, 
    -0.12703221f, 0.11234505f, -0.04188558f, 0.07986173f, 0.10440052f, 0.34688178f, 0.06433405f, 0.01643500f, 
    0.04700940f, 0.09197753f, 0.10675082f, -0.01751444f, 0.21637322f, -0.01649409f, -0.09126008f, 0.14622787f, 
    0.08107951f, 0.18020540f, 0.17298678f, -0.08259010f, 0.10177614f, 0.08818437f, -0.02070405f, 0.03265054f, 
    0.05584316f, -0.00368857f, 0.16009545f, 0.24748239f, 0.08399082f, -0.00921062f, 0.00366640f, -0.12330440f, 
    -0.06195853f, 0.16373712f, 0.20890972f, 0.11242328f, -0.03536941f, -0.20839854f, 0.00780460f, 0.40947410f, 
    -0.01131978f, 0.03825902f, 0.04636332f, 0.12592165f, -0.00585629f, -0.15248658f, 0.11812171f, 0.07327458f, 
    0.24166177f, 0.37382150f, -0.06805368f, 0.03931726f, 0.05051679f, -0.02547750f, 0.02492410f, -0.04781829f, 
    -0.06657910f, 0.11950976f, 0.19386442f, 0.13148989f, 0.38254759f, -0.10117312f, 0.45882788f, -0.23246334f, 
    -0.11158226f, -0.17644046f, 0.06526511f, -0.12367169f, -0.04239886f, 0.08558274f, -0.02443543f, -0.13978639f, 
    0.10415332f, 0.00581401f, 0.36327693f, 0.00654123f, 0.00321981f, 0.02033163f, -0.13191044f, -0.16917565f, 
    -0.04484737f, -0.05936434f, 0.05101851f, 0.13644449f, -0.24235728f, 0.03986447f, -0.15349436f, 0.25521994f, 
    -0.15186702f, -0.20255843f, -0.14134692f, -0.02723887f, 0.03887837f, -0.09261756f, 0.10778028f, -0.01367853f, 
    -0.34014952f, 0.00561094f, 0.14529614f, 0.09233283f, -0.00640136f, 0.02409737f, -0.00203807f, -0.08932325f, 
    0.09117591f, 0.08153884f, -0.05801036f, 0.04982263f, 0.06517574f, 0.20559515f, 0.29451805f, 0.06525794f, 
    0.03640089f, -0.02597919f, -0.06142521f, -0.01137101f, -0.14982961f, -0.07965422f, 0.02118307f, -0.21345073f, 
    -0.18976071f, -0.13191703f, -0.01078381f, 0.23467238f, -0.08889191f, -0.01659540f, -0.06180155f, -0.03234350f, 
    0.00697209f, -0.01150561f, 0.08021307f, 0.01549786f, -0.01034434f, 0.10045374f, -0.07505547f, -0.04551757f, 
    -0.00072029f, 0.23772243f, -0.06252021f, 0.11430205f, 0.17682491f, 0.07323889f, -0.07394042f, -0.04077556f, 
    0.55605590f, -0.26666263f, 0.25084120f, 0.02138568f, -0.06932157f, -0.06117025f, 0.12829304f, 0.00337258f, 
    0.00434493f, -0.04920318f, 0.01903611f, -0.03822887f, 0.18890341f, 0.06010493f, 0.04701972f, -0.19292954f, 
    -0.04354257f, -0.04170209f, -0.04555772f, -0.06485888f, 0.05072738f, 0.18712132f, 0.23823303f, 0.14500885f, 
    0.11231042f, -0.07250699f, 0.02283010f, 0.01390133f, 0.07730414f, -0.02751096f, 0.06259541f, -0.05151595f, 
    -0.09752928f, -0.08651773f, -0.05746248f, -0.08599529f, -0.07576724f, 0.06494400f, 0.13145946f, -0.04750600f, 
    0.19414862f, -0.02607694f, 0.05510901f, 0.00918314f, 0.00742748f, 0.13266724f, -0.12551831f, 0.03878148f, 
    -0.16579895f, 0.23370697f, 0.23537274f, 0.13648273f, 0.00355443f, -0.06540317f, -0.09393883f, 0.06154623f, 
    -0.14609626f, 0.17906035f, -0.00034478f, 0.02846670f, -0.06824934f, 0.17409286f, -0.12489809f, 0.38298717f, 
    0.14201020f, -0.03595513f, 0.03909307f, 0.02469933f, -0.16914183f, -0.13851678f, -0.09925910f, -0.08453880f, 
    -0.15917566f, -0.01446786f, 0.05826620f, 0.13880312f, 0.09061516f, -0.14634006f, 0.00165943f, -0.09382912f, 
    -0.07296022f, -0.03800943f, -0.08746264f, -0.14800216f, 0.39227995f, 0.00538651f, 0.61002380f, -0.15703480f, 
    -0.01077387f, -0.00141000f, -0.00660042f, -0.07693527f, 0.03250432f, -0.04921551f, 0.08214324f, 0.04846875f, 
    0.13562950f, 0.29545167f, 0.22097453f, 0.09393769f, -0.01743778f, -0.04479311f, 0.10077649f, 0.06080443f, 
    -0.06254277f, -0.00145853f, -0.05751088f, 0.00473931f, 0.13110331f, 0.09258375f, 0.06914526f, -0.03016317f, 
    0.04713516f, 0.02393864f, -0.05995719f, 0.00870291f, -0.05232138f, -0.03387139f, -0.05579351f, -0.11486322f, 
    0.07365093f, -0.14729810f, 0.28674883f, 0.02719545f, 0.05124185f, 0.02544902f, -0.01354846f, -0.04762540f, 
    0.04745710f, 0.12933078f, 0.15707153f, 0.17055070f, -0.16528459f, -0.10072094f, 0.14022736f, 0.22986649f, 
    -0.06977426f, -0.02162932f, -0.01157083f, 0.07115211f, 0.07498534f, 0.08506904f, 0.05178059f, -0.00580854f, 
    0.05593402f, 0.16480586f, 0.09372459f, 0.05370498f, 0.01099833f, -0.00313605f, -0.08595138f, 0.07486929f, 
    -0.12599140f, 0.12461027f, 0.20780253f, 0.00857409f, -0.10263520f, -0.22484207f, -0.11558624f, 0.05092515f, 
    -0.07506786f, -0.13284269f, -0.07887782f, -0.03340663f, 0.03932503f, -0.01767842f, -0.04556733f, -0.05284975f, 
    0.02399658f, 0.15019006f, 0.19153792f, 0.09452872f, -0.00308370f, -0.08087627f, -0.05306782f, -0.07086381f, 
    0.00718968f, 0.00725827f, 0.02724784f, 0.04446063f, 0.08556308f, 0.06109636f, -0.11932727f, -0.02553861f, 
    -0.04074559f, -0.05508713f, 0.19559203f, 0.18926239f, 0.13623968f, -0.06314053f, -0.07406129f, 0.07359943f, 
    -0.24221739f, -0.05545205f, -0.13662013f, 0.03289209f, 0.13896035f, -0.07163231f, -0.06005666f, 0.07529629f, 
    -0.04043988f, -0.08344871f, -0.00936098f, -0.03258795f, -0.20103501f, -0.06030530f, 0.20340154f, 0.05746423f, 
    -0.02218178f, -0.10723969f, -0.19093962f, 0.16010094f, -0.00922736f, 0.02114118f, -0.08202367f, -0.11848671f, 
    -0.18877842f, -0.13505039f, -0.07463685f, 0.18595572f, 0.03792460f, 0.00898761f, 0.14652535f, -0.02883516f, 
    0.03317023f, 0.23796260f, 0.16207102f, 0.14956826f, -0.46651691f, 0.02172547f, -0.15403281f, 0.13707723f, 
    -0.07983212f, 0.04450031f, -0.10280184f, -0.10455561f, 0.02630729f, 0.10543137f, 0.27082029f, 0.12058570f, 
    -0.16868925f, -0.13693216f, -0.16378991f, 0.02149745f, -0.01671058f, 0.17490421f, 0.07058086f, -0.06856641f, 
    0.10992617f, 0.17118043f, -0.13286987f, 0.21703359f, 0.14753686f, 0.04834159f, -0.16298741f, 0.18769257f, 
    -0.01097724f, 0.08469870f, 0.11248176f, -0.18488467f, -0.06101839f, -0.05971859f, -0.15014355f, 0.03146225f, 
    -0.01792869f, -0.00188857f, 0.01722681f, -0.05352351f, 0.05080887f, -0.02889238f, 0.01935611f, 0.01851594f, 
    0.01392049f, -0.03422346f, 0.02244935f, -0.03330535f, 0.01621636f, -0.02560046f, 0.04337544f, -0.01884792f, 
    -0.01120881f, 0.01605754f, -0.05564559f, 0.00191645f, 0.03771014f, -0.02273590f, -0.02709835f, -0.02942474f, 
    -0.05388991f, -0.03555104f, 0.01485276f, 0.00238110f, 0.00130564f, -0.01585914f, -0.04666454f, 0.01343029f, 
    0.04313765f, 0.01798530f, -0.00308066f, -0.02301028f, -0.05308140f, 0.02204437f, -0.05490574f, -0.04075658f, 
    -0.01269470f, -0.02486014f, -0.05187372f, -0.00865017f, -0.03062849f, 0.00345416f, -0.00797217f, 0.01492758f, 
    -0.02032336f, 0.03958711f, -0.02435432f, -0.01379320f, 0.03398188f, 0.00107510f, 0.04159776f, -0.01348197f, 
    0.02461663f, -0.00460964f, -0.00190654f, -0.01202711f, -0.01367430f, 0.01787820f, -0.02311660f, -0.04304631f, 
    0.04332184f, -0.05514485f, -0.03931998f, -0.03249155f, -0.00342795f, -0.04626989f, -0.04410794f, 0.02480744f, 
    -0.03957660f, 0.00662647f, -0.03514751f, -0.01188932f, 0.01266008f, 0.02865488f, -0.01334170f, -0.02868180f, 
    -0.04963505f, -0.02038397f, -0.01424840f, -0.03974110f, 0.04193309f, 0.00825180f, 0.01095043f, -0.03752299f, 
    0.04289807f, 0.00132258f, 0.01831691f, -0.04812396f, -0.05017583f, -0.03520821f, -0.00814165f, -0.03050445f, 
    0.02758832f, 0.02819184f, 0.00547105f, -0.01718681f, -0.00402030f, -0.02687328f, 0.01349911f, -0.03897663f, 
    -0.01214103f, 0.01976560f, 0.03263289f, -0.01692015f, 0.01755811f, 0.00192127f, 0.01497057f, 0.01212141f, 
    -0.02402380f, -0.02434726f, 0.00388125f, -0.03213221f, -0.00379760f, -0.04951081f, 0.01224835f, 0.00746941f, 
    -0.04997761f, 0.00232494f, -0.02683363f, 0.00726748f, -0.02466340f, -0.04325016f, -0.02327119f, -0.00591533f, 
    0.02933338f, -0.00215956f, -0.03405314f, 0.01465519f, -0.00608865f, 0.01373105f, -0.02343024f, -0.02699952f, 
    -0.03694320f, -0.04945516f, 0.02141050f, 0.00961074f, -0.01071534f, -0.03827916f, -0.05500093f, -0.01469703f, 
    0.02840976f, 0.02510105f, -0.02579971f, 0.00030029f, -0.00385089f, 0.02740377f, -0.03848773f, -0.02642507f, 
    -0.03896846f, -0.05249404f, -0.01945040f, -0.04387400f, 0.03522648f, -0.05499141f, -0.03476894f, -0.03507611f, 
    0.03377467f, 0.04404628f, -0.04062574f, -0.02879638f, 0.02449162f, 0.01521300f, 0.00950984f, -0.01130325f, 
    -0.04364870f, 0.02628962f, 0.00426421f, 0.03901220f, 0.03943598f, -0.05049981f, 0.01841740f, -0.04585638f, 
    -0.02041524f, -0.04549378f, -0.01053132f, 0.01379608f, -0.01536364f, 0.03292676f, 0.00925468f, 0.00590738f, 
    0.04240895f, 0.00542517f, 0.03304389f, -0.02328887f, -0.05209948f, 0.03056114f, 0.03913879f, 0.01843216f, 
    -0.05547769f, -0.00988111f, -0.02430223f, -0.03738661f, 0.01335960f, 0.02843446f, 0.01262739f, -0.00605475f, 
    0.03608175f, -0.01262352f, -0.02621193f, 0.03520234f, -0.05347847f, -0.02315513f, -0.00775055f, -0.02733439f, 
    -0.04487821f, -0.04610595f, -0.01576268f, 0.03891644f, 0.01322050f, 0.01664425f, 0.00183444f, -0.01800556f, 
    -0.05305629f, 0.03866950f, 0.03114573f, -0.01424946f, 0.01315053f, 0.00559604f, 0.01427133f, -0.02017584f, 
    -0.03204370f, 0.04029169f, 0.00888570f, -0.04060095f, 0.02004727f, -0.02539339f, -0.00479653f, 0.02811806f, 
    -0.05540603f, 0.00311183f, -0.02601338f, -0.01265435f, 0.03068476f, -0.02088458f, -0.02839917f, 0.01810937f, 
    -0.04875002f, 0.01738080f, -0.01102320f, 0.03685861f, -0.04271214f, 0.01156766f, -0.04683204f, -0.00957376f, 
    0.00241225f, -0.04230578f, -0.04437810f, -0.02155683f, -0.03410340f, 0.01284238f, -0.01260271f, 0.00783168f, 
    0.02722399f, -0.02241785f, -0.04763347f, 0.00547301f, -0.04870547f, -0.01939775f, 0.03816407f, 0.01566643f, 
    -0.01509753f, -0.02287117f, 0.03196273f, 0.01825829f, -0.01212384f, -0.03145520f, -0.00212615f, 0.01210976f, 
    0.03795649f, 0.03471664f, -0.03601406f, -0.01043344f, -0.02190966f, -0.01724013f, 0.04439857f, -0.01325734f, 
    -0.02630530f, -0.03891212f, -0.02054998f, -0.02778287f, 0.03424097f, -0.03296874f, -0.00269699f, 0.02731576f, 
    -0.02917375f, -0.00363250f, -0.02857449f, -0.03589081f, -0.00455095f, -0.03629215f, 0.01247205f, 0.00177867f, 
    0.03944902f, -0.00721853f, 0.02080154f, -0.05458340f, 0.04009354f, -0.02609451f, 0.03017402f, 0.04069661f, 
    0.03253431f, 0.04030186f, -0.03037615f, 0.04171381f, -0.01384844f, -0.03800121f, -0.04687652f, -0.05577711f, 
    0.04153881f, -0.00792385f, -0.04431797f, 0.00968407f, -0.02392756f, 0.02729696f, -0.04283429f, 0.00043073f, 
    0.03104781f, -0.04319654f, -0.02422594f, 0.04103163f, -0.00394171f, 0.01099895f, -0.04241010f, -0.02972721f, 
    -0.01441921f, 0.02261377f, -0.01067823f, 0.02415905f, -0.04966849f, 0.02455109f, 0.02624919f, -0.03223256f, 
    -0.05196077f, -0.03992707f, -0.04456676f, -0.02365659f, -0.02985784f, -0.02448048f, -0.03687966f, -0.05048083f, 
    0.00513758f, -0.04923171f, -0.02322968f, -0.04791506f, -0.02947967f, -0.03752460f, 0.00926028f, -0.00519847f, 
    -0.00417347f, -0.02599548f, 0.00065984f, 0.01028430f, 0.02615678f, 0.03704663f, -0.00915121f, -0.01221466f, 
    -0.02802199f, 0.02061130f, 0.02684894f, 0.02136072f, 0.00982007f, -0.00196269f, -0.01781751f, 0.00224041f, 
    0.02841390f, -0.02619690f, -0.03917538f, 0.03062645f, 0.02696001f, 0.02715367f, 0.01777233f, -0.01562914f, 
    -0.02470452f, 0.00800108f, -0.03211177f, -0.04936329f, -0.01515845f, -0.04606999f, 0.01236990f, 0.00890858f, 
    -0.05539550f, -0.01175882f, -0.03124843f, 0.03180065f, -0.05153004f, -0.02994707f, 0.01663652f, 0.03281959f, 
    -0.02000987f, 0.04267108f, 0.00863828f, -0.00715009f, 0.01301055f, 0.01425670f, -0.01508410f, -0.05473271f, 
    -0.02983826f, 0.04097281f, -0.01303089f, -0.04076974f, 0.02761645f, 0.02424819f, -0.01956122f, -0.01330302f, 
    -0.03523666f, 0.03019935f, 0.02044523f, -0.03738908f, 0.03598333f, -0.02618208f, -0.00858433f, -0.03630252f, 
    -0.05179916f, -0.02043183f, 0.04075370f, -0.00955273f, 0.01014933f, 0.00613312f, 0.03138297f, 0.00745753f, 
    -0.04979169f, 0.02102447f, 0.03881549f, -0.03741441f, -0.01319715f, 0.03071416f, -0.04021523f, -0.04763903f, 
    -0.01401090f, -0.01272648f, 0.00584381f, -0.03470339f, -0.00560778f, -0.03401668f, 0.02664608f, 0.02831342f, 
    -0.01482813f, 0.00000368f, -0.01451933f, -0.03290692f, -0.03385430f, -0.04368047f, 0.03354544f, 0.01550784f, 
    -0.02732584f, 0.03845971f, -0.03071054f, -0.03108876f, -0.01126332f, -0.01895230f, 0.01068577f, -0.01717162f, 
    0.03979269f, -0.01891487f, -0.04798776f, -0.04422826f, 0.03849554f, -0.03314567f, -0.00554968f, -0.05635941f, 
    -0.03784337f, -0.02782568f, 0.03372445f, -0.04061526f, -0.04524162f, 0.01783707f, 0.01310087f, 0.00355917f, 
    -0.05432961f, 0.02976539f, 0.02568171f, 0.00196581f, -0.00746122f, 0.03386817f, -0.00291138f, -0.01655316f, 
    -0.04348094f, -0.04598421f, -0.02350300f, -0.01076419f, 0.00443210f, 0.00826081f, -0.03994819f, -0.05233297f, 
    0.03311140f, 0.04034252f, -0.02082321f, 0.04241407f, -0.03607168f, -0.00586734f, 0.02371092f, -0.03216965f, 
    0.03789283f, -0.03985497f, 0.00146126f, 0.02271367f, 0.00379775f, 0.00738834f, 0.03168310f, 0.03555705f, 
    -0.04269110f, -0.02100707f, 0.01969632f, 0.01233088f, -0.00153515f, -0.01278595f, -0.01839082f, -0.02465400f, 
    -0.02472771f, 0.01356188f, 0.00759083f, -0.00584234f, -0.02520591f, -0.03190943f, -0.00048311f, -0.02600300f, 
    -0.00574361f, 0.03089648f, 0.01334518f, 0.02598423f, 0.03952571f, -0.04185956f, 0.01992619f, -0.02893596f, 
    0.05986986f, -0.02087398f, -0.02574151f, -0.02663092f, -0.04770857f, -0.05268694f, -0.00182348f, -0.04749659f, 
    -0.03662176f, 0.02284692f, -0.04592282f, -0.01383239f, -0.00452380f, -0.00254817f, -0.00212737f, 0.01564463f, 
    0.02560506f, 0.02939448f, 0.04277579f, -0.03015512f, 0.02605199f, -0.05273467f, 0.02426508f, -0.01483166f, 
    -0.00630665f, -0.02666212f, -0.03766385f, -0.05511184f, -0.00343089f, -0.03808329f, -0.04183013f, 0.00086036f, 
    -0.03407491f, 0.00420530f, 0.03953632f, -0.04768283f, -0.00289251f, 0.02788594f, 0.03655712f, 0.02649680f, 
    -0.01173354f, -0.02996222f, -0.01212621f, 0.02728694f, -0.00817501f, 0.02030012f, -0.01171539f, -0.04262780f, 
    -0.05343660f, -0.04434495f, -0.00569728f, 0.00817515f, -0.05594530f, -0.02125280f, 0.01911954f, 0.04193217f, 
    -0.05512425f, -0.00428204f, -0.01884107f, -0.04648741f, 0.02410701f, 0.01436587f, 0.04237638f, 0.04938835f, 
    -0.03569979f, -0.03959394f, -0.00892476f, -0.01922217f, 0.04349932f, -0.01914555f, -0.00020355f, -0.01013909f, 
    0.01283243f, 0.04820209f, 0.00118540f, -0.03383212f, -0.03080358f, -0.03248720f, 0.00778261f, 0.02474577f, 
    0.04424275f, -0.04937041f, 0.04336845f, 0.04191082f, -0.00691480f, 0.01091295f, 0.01930103f, -0.04974670f, 
    -0.04277641f, -0.01880168f, -0.02092950f, 0.03573007f, -0.04510311f, 0.02432655f, 0.03580664f, -0.02305957f, 
    -0.03204188f, 0.02974007f, -0.03925746f, 0.00179110f, 0.01882104f, 0.04695976f, -0.05390533f, -0.00995793f, 
    0.04077574f, -0.01042222f, -0.03818154f, -0.00233923f, -0.03818269f, -0.00712907f, 0.03760025f, -0.03150416f, 
    -0.02075646f, 0.00938823f, 0.03655449f, -0.00947388f, 0.04008519f, 0.02072132f, -0.04548438f, -0.04631662f, 
    0.02736025f, 0.01888941f, 0.01698613f, -0.00425539f, -0.05389931f, -0.03534202f, -0.00130330f, -0.00771132f, 
    -0.04831992f, 0.02333778f, 0.01588425f, -0.04478109f, 0.00077819f, 0.01941377f, 0.03675453f, -0.00588803f, 
    -0.05376238f, 0.03795633f, 0.03057075f, -0.01056949f, -0.03979149f, 0.03115930f, -0.03611578f, 0.01577715f, 
    0.00416359f, 0.01097196f, -0.02958510f, -0.00096787f, 0.00856959f, 0.00665438f, 0.01140204f, -0.03777258f, 
    0.01958145f, 0.03729740f, 0.03315371f, -0.04983993f, -0.03076117f, -0.02815193f, -0.02206388f, 0.00767603f, 
    -0.00319763f, 0.01609061f, 0.01268379f, -0.03589172f, -0.03009060f, -0.01281812f, 0.01974474f, 0.01124361f, 
    -0.00793343f, 0.04135952f, -0.01970918f, 0.02366597f, 0.04536480f, -0.03559998f, -0.04818050f, 0.04056988f, 
    0.01127391f, 0.02850685f, -0.00785933f, -0.04020060f, 0.03173089f, 0.00912788f, 0.01796418f, 0.02358851f, 
    0.02299826f, 0.02709921f, -0.01232230f, 0.01461345f, -0.04370196f, -0.03146890f, -0.04362597f, -0.03438674f, 
    -0.03866573f, 0.01510515f, -0.02802132f, 0.01401488f, 0.01692020f, 0.00085060f, 0.01042929f, -0.01422095f, 
    -0.05374143f, -0.02390466f, -0.01143648f, -0.00298551f, -0.05526293f, -0.03635393f, 0.00863978f, -0.00624344f, 
    -0.00090221f, 0.04014083f, -0.00862808f, 0.02361889f, 0.00448589f, -0.05373203f, -0.00461272f, -0.04957946f, 
    0.01114215f, 0.02102763f, 0.00379074f, 0.00035677f, -0.03085107f, 0.02332816f, -0.05322111f, 0.04025072f, 
    0.04394002f, -0.02416963f, 0.03813111f, -0.04074901f, -0.02286495f, -0.00893402f, 0.00268497f, 0.03367592f, 
    0.03479655f, 0.02451576f, -0.03896797f, 0.02578326f, 0.00606257f, -0.02758268f, 0.00356226f, -0.03192112f, 
    -0.31593612f, 0.15666169f, -0.06600478f, -0.25488347f, 0.00860408f, 0.08570465f, 0.06277896f, 0.07016337f, 
    0.00313311f, -0.02729796f, -0.08436548f, -0.13642979f, -0.21055983f, 0.03984110f, 0.03744270f, -0.00322939f, 
    0.17657420f, -0.01823591f, 0.08901053f, 0.08048091f, 0.05034970f, 0.16464201f, 0.15177546f, -0.00201347f, 
    0.31415224f, -0.10172632f, -0.14074425f, 0.01638946f, 0.00132713f, 0.00930921f, 0.07705785f, -0.01605525f, 
    0.16738752f, 0.02513429f, 0.00129341f, 0.02985549f, 0.28940696f, -0.01198673f, -0.04902360f, -0.23672700f, 
    0.20498483f, -0.05375737f, -0.05166005f, -0.08074995f, 0.08192231f, 0.02415692f, -0.00615403f, 0.07763960f, 
    -0.27533206f, 0.11409198f, -0.04270200f, 0.09826290f, -0.08639676f, -0.07301313f, -0.19148369f, -0.09228280f, 
    -0.09301801f, 0.02465055f, 0.06428299f, -0.04322315f, -0.06972552f, -0.11145951f, 0.14243016f, -0.11923761f, 
    0.11071125f, 0.03429528f, 0.16886064f, 0.02934088f, 0.00505035f, -0.15797617f, -0.07561790f, -0.20834643f, 
    -0.07848510f, -0.06699409f, -0.09136645f, -0.19125979f, -0.09232420f, -0.03110620f, -0.08342291f, 0.11516592f, 
    -0.07245565f, -0.07257894f, -0.00433377f, -0.11816016f, 0.05487389f, -0.08815620f, -0.05209265f, -0.09965450f, 
    -0.07629747f, 0.04728533f, -0.07729960f, -0.05005836f, -0.02184633f, 0.01619108f, 0.00501486f, 0.01058690f, 
    -0.04996774f, 0.06414438f, 0.18094157f, -0.19838211f, 0.12017644f, -0.03464057f, 0.10660247f, -0.12151711f, 
    0.10268076f, 0.05298727f, -0.01380185f, 0.00751250f, -0.08788417f, 0.13127764f, -0.04745564f, 0.05853288f, 
    -0.02975528f, -0.06786370f, 0.00198362f, 0.08049463f, -0.00459977f, 0.00631629f, 0.19276269f, 0.07379311f, 
    0.03501656f, -0.11288995f, 0.15077195f, 0.00583242f, 0.08578303f, 0.12191646f, 0.01751299f, 0.13046651f, 
    -0.11392563f, 0.02725589f, -0.03029631f, -0.12501200f, 0.04025822f, -0.05371757f, 0.06042193f, 0.13264178f, 
    -0.01101709f, 0.01515547f, 0.05004669f, 0.10505962f, 0.15668011f, 0.04905336f, -0.03673230f, -0.03192591f, 
    0.03634065f, 0.00735109f, 0.02126972f, 0.08963667f, -0.04762979f, 0.01819642f, -0.07000247f, -0.05883113f, 
    0.12399990f, 0.15807955f, 0.04448079f, 0.18802945f, 0.11789867f, -0.01072896f, 0.01426292f, 0.30983362f, 
    -0.02474769f, -0.14242995f, 0.02257514f, -0.14293553f, 0.05393346f, -0.06497958f, 0.00544390f, 0.08788989f, 
    -0.52766937f, -0.08396554f, 0.02472577f, -0.02004275f, -0.14868213f, -0.04606374f, 0.01842960f, 0.04566745f, 
    0.14755063f, 0.13555935f, 0.10314490f, 0.13823862f, 0.32072556f, -0.03452389f, -0.05567984f, -0.10206620f, 
    -0.02677756f, 0.23754925f, 0.00171857f, -0.14094672f, 0.12026879f, 0.00526615f, -0.00340132f, 0.06215759f, 
    -0.02142869f, 0.11839417f, 0.04252930f, -0.12863456f, 0.02166655f, 0.16341966f, 0.32834762f, 0.13826120f, 
    0.01116658f, -0.10982975f, -0.02814331f, -0.01010599f, 0.30512023f, -0.14430803f, 0.02654970f, 0.25119221f, 
    0.16039777f, 0.10794286f, -0.02902712f, -0.06223014f, -0.12538916f, -0.11128694f, 0.02103653f, -0.03177778f, 
    0.36778778f, -0.25837016f, -0.28973618f, -0.02900534f, 0.05804205f, 0.00026006f, 0.09258714f, 0.31240854f, 
    0.01117843f, -0.09956335f, -0.00663567f, -0.07927903f, 0.11452707f, 0.04953481f, 0.08785721f, 0.09733263f, 
    -0.09160628f, -0.10076027f, -0.03961268f, -0.03485917f, -0.04726746f, 0.01014669f, 0.09795047f, 0.10456457f, 
    -0.24617197f, 0.18083566f, -0.05346819f, -0.16733962f, -0.00557123f, 0.14144985f, 0.12138715f, 0.02000986f, 
    -0.00260775f, 0.06163549f, -0.04766139f, -0.07933633f, 0.09915589f, 0.04967222f, -0.10947415f, 0.04396431f, 
    0.05912246f, 0.06211263f, -0.03236760f, -0.06793051f, -0.03881893f, -0.01721894f, -0.10064305f, -0.06392801f, 
    0.09765734f, -0.11539723f, 0.16182075f, 0.08213399f, -0.02620289f, 0.07378707f, -0.02873771f, -0.02817074f, 
    0.08555423f, -0.00878036f, 0.02055318f, 0.18441634f, 0.11739049f, 0.13151968f, 0.12020558f, -0.10324652f, 
    -0.06266653f, -0.10756037f, 0.08251051f, -0.03659631f, -0.00430175f, 0.07998607f, 0.14408465f, 0.02403332f, 
    -0.46351099f, 0.08343752f, -0.02970173f, -0.00011426f, 0.11889146f, 0.11256292f, -0.06038649f, 0.17655733f, 
    0.01701166f, 0.18358280f, -0.03131684f, 0.02372932f, 0.24661297f, -0.02849150f, 0.16242135f, 0.18380274f, 
    0.15656720f, -0.06770898f, 0.17089811f, 0.24507509f, 0.17684451f, -0.03261798f, 0.05367517f, 0.07724125f, 
    -0.11912320f, 0.04054108f, -0.08197815f, -0.05927258f, -0.17595050f, -0.05699226f, 0.00838714f, 0.14852728f, 
    0.03502844f, 0.04751087f, -0.10708647f, -0.16328783f, -0.06736520f, 0.02679595f, -0.00572782f, -0.14982051f, 
    0.03612646f, 0.12487379f, -0.05139070f, -0.05874043f, -0.05954064f, 0.02625665f, 0.09344771f, -0.01478221f, 
    0.08937243f, 0.02313724f, 0.17599124f, -0.00991144f, -0.00300669f, -0.01585175f, 0.03559248f, -0.01531361f, 
    0.02871002f, -0.10681999f, 0.05511603f, -0.05315490f, 0.24229476f, 0.04802861f, 0.07632552f, -0.24375294f, 
    0.04398439f, 0.01011475f, 0.00312887f, 0.11043424f, 0.05922444f, -0.05791778f, 0.10604400f, -0.06804036f, 
    0.04738696f, 0.14669244f, 0.18016346f, 0.11201692f, -0.01371913f, 0.04604571f, -0.01846885f, 0.11858796f, 
    0.12178702f, -0.14978705f, 0.15620613f, 0.03797941f, -0.06446980f, 0.15856059f, -0.05053687f, 0.15394802f, 
    0.11176068f, 0.04063918f, 0.10518682f, 0.27178860f, 0.03644091f, -0.00614371f, -0.05226473f, -0.01816503f, 
    -0.12136883f, 0.24367456f, 0.05370035f, 0.07636088f, 0.13664149f, 0.03556501f, -0.03912193f, -0.15728435f, 
    0.01823475f, -0.00902268f, 0.06995537f, 0.05020227f, 0.16409333f, 0.01336108f, 0.05716210f, -0.23870087f, 
    0.14501633f, 0.02291692f, -0.18712781f, -0.01733269f, -0.00497277f, -0.07024398f, -0.06753627f, -0.01823936f, 
    0.34069321f, -0.08565114f, -0.17229961f, -0.24378279f, -0.06710377f, -0.16265880f, -0.19173019f, -0.03534928f, 
    0.13318880f, 0.12151548f, -0.00883575f, -0.07745724f, 0.14589089f, -0.29357919f, -0.29819596f, -0.21083881f, 
    -0.01539890f, -0.04902594f, 0.12171356f, -0.00989678f, 0.05484428f, -0.03650685f, 0.01169308f, -0.02692848f, 
    0.00261501f, -0.21124688f, -0.06110954f, 0.06484404f, -0.00586329f, -0.04010336f, 0.05089443f, 0.01397009f, 
    0.01642739f, -0.07108634f, -0.03160140f, -0.07076252f, -0.07776862f, 0.20780210f, 0.10474360f, 0.10883499f, 
    0.05644030f, -0.23618667f, -0.06430653f, 0.02807954f, 0.00316157f, 0.08791450f, -0.01203648f, 0.03457301f, 
    0.03645483f, 0.21159688f, 0.04099287f, -0.23022728f, -0.05810693f, -0.12174091f, -0.04822822f, -0.03163264f, 
    -0.02377321f, 0.08099867f, 0.13699625f, 0.01174389f, 0.32944816f, 0.11282212f, 0.03162852f, -0.02587092f, 
    0.07939452f, -0.05673076f, 0.00949889f, 0.00578325f, 0.01787939f, -0.04485105f, -0.01020744f, -0.00136064f, 
    0.05081689f, 0.25827497f, 0.15423886f, -0.19439445f, 0.07754150f, 0.05770757f, 0.14345516f, 0.04752405f, 
    0.04769050f, -0.02391665f, -0.04127657f, -0.02270886f, -0.26124692f, -0.03614550f, -0.04699358f, 0.26167560f, 
    0.14379199f, -0.02074133f, -0.12534052f, 0.05257121f, 0.06630483f, 0.02756769f, 0.14840847f, 0.06770934f, 
    0.07180978f, 0.05050355f, -0.46961194f, 0.08556214f, -0.01531381f, 0.06339291f, 0.04816892f, 0.15281449f, 
    0.00831971f, 0.11946899f, -0.04304967f, -0.00476457f, 0.06941783f, -0.09633921f, -0.10569008f, 0.00718564f, 
    -0.07253169f, -0.10732100f, 0.08395245f, -0.00155565f, 0.18899199f, -0.01765185f, -0.03205945f, 0.03631665f, 
    0.03087805f, -0.12127133f, -0.00214865f, 0.07611255f, 0.02854904f, -0.08618020f, 0.01029638f, -0.11510750f, 
    0.07029964f, 0.12876953f, -0.00733980f, 0.05618669f, -0.23661706f, -0.15433691f, 0.19197792f, 0.07738259f, 
    0.04928193f, -0.04454349f, -0.07054823f, -0.07421760f, 0.10644656f, -0.06247173f, 0.10518615f, 0.03206652f, 
    -0.11234891f, 0.25248292f, 0.41811079f, 0.29374337f, 0.03297573f, -0.15302239f, -0.12589049f, -0.15442564f, 
    -0.08208457f, 0.06713837f, 0.04767943f, 0.25014204f, -0.17234538f, -0.19512020f, -0.23384666f, -0.04162470f, 
    0.08806658f, 0.27023986f, 0.11849982f, 0.17858128f, 0.06499916f, -0.05355624f, -0.01135319f, -0.10395472f, 
    -0.18530737f, 0.27174079f, 0.34541216f, -0.16429001f, 0.26626441f, 0.03169842f, 0.26310351f, -0.00494013f, 
    -0.03102346f, -0.01025234f, -0.00825631f, -0.03618274f, -0.06649094f, -0.09848735f, -0.33031929f, 0.19945297f, 
    0.07930464f, 0.07652417f, 0.21005815f, -0.03352055f, 0.04227604f, -0.01349756f, -0.13161141f, -0.05822093f, 
    0.39428797f, 0.05349740f, 0.14224808f, -0.45664093f, -0.04362587f, -0.14427395f, -0.07325298f, 0.08483414f, 
    0.10841358f, 0.10184295f, 0.11616018f, -0.07036208f, 0.02032615f, -0.08154864f, -0.11841695f, 0.12238137f, 
    0.03356469f, -0.03436372f, -0.00467405f, 0.01757356f, 0.07914436f, -0.10069893f, -0.00485544f, -0.03122064f, 
    -0.13017358f, 0.11973161f, -0.05387532f, -0.17604013f, 0.00737479f, 0.02140832f, -0.09038153f, -0.01909171f, 
    0.08573243f, 0.01119007f, 0.03937721f, 0.08715980f, 0.20732848f, 0.05536588f, -0.06486064f, -0.26866251f, 
    0.09893221f, -0.03588117f, -0.07376257f, -0.07445234f, -0.04540199f, 0.13320637f, 0.06278020f, -0.06808995f, 
    0.07499518f, -0.17232049f, 0.09733193f, 0.10556505f, 0.06703500f, 0.08666527f, -0.01637102f, -0.05744923f, 
    -0.02193065f, -0.01860430f, 0.05115688f, 0.04765892f, 0.51559621f, 0.24607489f, -0.15934171f, -0.38144484f, 
    -0.04606570f, 0.02682425f, 0.12989959f, 0.33871347f, -0.06493470f, 0.02852376f, 0.03003172f, 0.00027300f, 
    -0.38049233f, 0.30312374f, -0.25756034f, -0.16091256f, 0.05087984f, -0.04430491f, -0.11698109f, 0.03633802f, 
    0.11514377f, 0.04693916f, 0.05011337f, 0.11732008f, -0.01036104f, -0.10342246f, -0.08997610f, -0.24398807f, 
    0.13659422f, -0.08723190f, -0.03127754f, 0.08889196f, 0.11565411f, 0.14288853f, 0.07897732f, 0.07006934f, 
    -0.03035935f, 0.01253480f, 0.22648419f, -0.04830083f, -0.01187255f, 0.11600660f, -0.05138153f, -0.04874083f, 
    0.02890492f, 0.03908632f, -0.00215030f, 0.03706604f, 0.25286540f, 0.31748754f, -0.04716961f, -0.08314367f, 
    -0.05993750f, -0.02534300f, 0.14902301f, 0.06736680f, -0.03581389f, -0.14775084f, 0.00907234f, 0.00546930f, 
    0.06020956f, 0.20217916f, 0.11734754f, -0.01301191f, -0.00558135f, 0.10608262f, 0.00590461f, 0.01943084f, 
    -0.00174465f, 0.00378014f, 0.00913094f, 0.05718962f, -0.01920590f, -0.04328337f, 0.18375933f, 0.13521904f, 
    0.07742743f, 0.00443002f, -0.14332594f, -0.07180312f, -0.04601016f, -0.02030743f, -0.06602744f, 0.08466547f, 
    -0.12556779f, 0.01750913f, 0.06964765f, 0.02106189f, 0.00919715f, -0.03173533f, -0.06629323f, 0.14182919f, 
    0.04843575f, -0.10741297f, 0.06034713f, 0.08778942f, -0.04037688f, -0.11900279f, -0.24954645f, 0.02726604f, 
    -0.03446972f, -0.13852723f, -0.02148710f, 0.07014609f, 0.16543962f, 0.14097516f, -0.05687064f, -0.02838903f, 
    0.03782857f, -0.02021209f, -0.00093218f, -0.04990126f, 0.00979004f, 0.00505810f, -0.04028697f, 0.00279733f, 
    0.02205975f, -0.05667873f, 0.01235563f, 0.03936365f, -0.02862293f, -0.02183384f, 0.00980256f, -0.03174888f, 
    -0.02192852f, -0.03293914f, -0.00416046f, 0.04549871f, 0.03663240f, 0.00392072f, 0.00134353f, -0.04953702f, 
    0.03697053f, 0.00951117f, -0.04709155f, 0.01225028f, -0.00797188f, -0.03115749f, 0.03170920f, 0.03489186f, 
    0.00568564f, 0.00652562f, -0.02226325f, 0.01356879f, 0.02267624f, 0.01369675f, 0.01145864f, 0.00959814f, 
    0.03464425f, -0.04862417f, -0.04860096f, -0.01586357f, 0.01778685f, -0.05129557f, -0.03369403f, -0.03067402f, 
    0.03216181f, 0.01764844f, -0.01090480f, -0.00795058f, 0.00100475f, 0.02792792f, -0.02026548f, -0.06070230f, 
    -0.03563770f, -0.02634831f, 0.01291204f, 0.00329040f, 0.00969646f, -0.02193698f, -0.01747541f, -0.00863692f, 
    -0.02114190f, -0.03328312f, -0.05772763f, 0.02677895f, -0.01609752f, -0.04687286f, 0.01391642f, -0.03771725f, 
    0.03158266f, -0.00381782f, 0.02772503f, -0.02269052f, 0.01897672f, -0.03390554f, 0.03093085f, 0.02679098f, 
    -0.02207517f, -0.04266326f, 0.02847518f, 0.02362942f, -0.04588496f, 0.00261987f, 0.00278750f, 0.01405917f, 
    -0.03605288f, -0.04033045f, -0.03118876f, -0.02488915f, 0.01135456f, -0.03700699f, -0.05873044f, -0.00853822f, 
    -0.00676597f, 0.00777253f, 0.00305500f, -0.02989459f, 0.03382410f, -0.01849896f, 0.03696816f, 0.04194497f, 
    0.02900606f, -0.01584980f, -0.04554734f, 0.01495354f, -0.05630030f, -0.04429866f, -0.00544716f, 0.04416268f, 
    0.01911714f, -0.05631086f, -0.02217670f, -0.03016286f, -0.02596001f, -0.00707865f, 0.02924720f, -0.01699674f, 
    -0.04471501f, 0.03392865f, -0.00930460f, 0.03283354f, -0.02537830f, 0.04234264f, -0.03346888f, -0.05104921f, 
    -0.01257569f, 0.01647491f, -0.04016326f, 0.00172719f, 0.03034103f, -0.00428081f, -0.04326377f, 0.02381279f, 
    0.00136380f, -0.01112047f, -0.05125097f, 0.02488259f, -0.00793652f, -0.05755038f, 0.03186632f, -0.03926924f, 
    -0.02102163f, 0.01658206f, -0.04149667f, -0.04644024f, 0.01770080f, -0.00012776f, 0.01199198f, -0.01564653f, 
    -0.02691801f, 0.03630313f, 0.04383420f, 0.01283474f, 0.01901497f, -0.01491939f, 0.01544988f, 0.01031070f, 
    -0.01946334f, -0.02218258f, -0.02623902f, 0.02084339f, -0.00015558f, 0.01854923f, -0.03610892f, -0.04006674f, 
    -0.01074393f, -0.02856109f, 0.01206638f, -0.01625678f, 0.03947888f, 0.02056883f, 0.00443081f, -0.04352365f, 
    -0.05054780f, -0.00022831f, 0.03108265f, -0.02723728f, 0.01078299f, -0.01611172f, -0.00479774f, 0.01491035f, 
    -0.03833585f, -0.02715920f, 0.00337714f, -0.03659473f, -0.00125614f, -0.04635785f, -0.00654148f, -0.04087213f, 
    0.02567987f, -0.03961101f, 0.02315215f, 0.03566362f, -0.04434759f, 0.00469378f, 0.01227661f, 0.02861114f, 
    -0.00619502f, -0.03485992f, -0.03161387f, -0.00566058f, -0.03959180f, -0.00537426f, -0.03912533f, -0.05005608f, 
    -0.05109195f, -0.03081518f, -0.03128004f, 0.00311652f, -0.00119635f, -0.04413288f, -0.05800897f, 0.01834914f, 
    0.01884235f, 0.04543386f, -0.03304583f, -0.04461942f, -0.03134706f, 0.03999231f, -0.05073506f, -0.02558474f, 
    -0.01337083f, -0.02540515f, -0.00909907f, -0.03128642f, -0.00868984f, 0.01945641f, -0.04735110f, 0.02186557f, 
    -0.03430921f, -0.02647284f, 0.03589421f, 0.00509372f, 0.01275015f, -0.01470669f, 0.04030279f, -0.03465811f, 
    -0.04045616f, -0.01149843f, -0.02440322f, 0.02969326f, -0.02793721f, 0.04022659f, -0.04983353f, 0.00399598f, 
    0.03101631f, -0.03321244f, 0.02729480f, -0.05177070f, 0.02338291f, 0.00504220f, -0.01654377f, 0.01434263f, 
    0.03818399f, 0.04019034f, -0.05053284f, 0.02488978f, -0.00869936f, 0.02414555f, 0.02575896f, -0.00621948f, 
    -0.05010254f, -0.05544104f, -0.02795455f, -0.03746211f, -0.02703854f, -0.00334061f, -0.03359332f, -0.00075833f, 
    -0.05700088f, 0.01765753f, -0.05302120f, 0.02372839f, 0.01629234f, -0.05558661f, 0.01681930f, 0.04062955f, 
    0.03800958f, -0.01588588f, 0.00750613f, 0.03265189f, -0.04417650f, 0.00526719f, -0.05854287f, 0.01190224f, 
    0.00140723f, -0.02409188f, -0.05651984f, -0.05277815f, -0.02388944f, -0.05746513f, -0.03157428f, -0.04249654f, 
    0.01691375f, 0.00915774f, 0.02114071f, -0.03273367f, 0.03510438f, 0.00120464f, -0.03030625f, -0.04191639f, 
    0.00761526f, 0.01089305f, 0.03387036f, -0.03429286f, -0.04312399f, 0.00793141f, -0.02598979f, -0.02985864f, 
    0.04017491f, -0.00275069f, -0.05321556f, -0.03240666f, -0.02946410f, -0.01433789f, 0.03732322f, -0.04713657f, 
    -0.00113350f, 0.01689344f, 0.03315417f, -0.03198434f, -0.03818611f, -0.04433556f, -0.02530118f, 0.01159078f, 
    0.03768977f, -0.02379741f, 0.00297245f, -0.02421609f, -0.01440750f, -0.04149778f, 0.00810637f, -0.02591698f, 
    -0.02218011f, 0.04092639f, 0.03175002f, 0.02824106f, 0.00916662f, 0.01063960f, -0.00301176f, -0.03581443f, 
    -0.01819370f, 0.02377678f, 0.01247956f, 0.00805134f, -0.00195348f, 0.01028851f, -0.02179362f, 0.02745863f, 
    -0.02128231f, -0.02762773f, -0.02982501f, -0.04719976f, -0.04608367f, -0.01257480f, -0.02993297f, -0.03522255f, 
    0.03852341f, 0.01646815f, -0.01131028f, 0.04140633f, -0.01754075f, -0.01676914f, -0.00668315f, 0.02125146f, 
    -0.01002966f, 0.02448333f, 0.01580346f, 0.02875247f, -0.03819139f, 0.01986472f, -0.05142308f, 0.03356102f, 
    -0.02501168f, -0.03743155f, 0.00935061f, -0.05211369f, -0.01441211f, 0.02133620f, -0.01196675f, 0.01410356f, 
    0.07969727f, 0.18882558f, 0.37026095f, 0.31498724f, -0.07827058f, -0.07184878f, 0.01560690f, -0.04604278f, 
    0.13337886f, 0.11534193f, 0.19853546f, -0.03910303f, 0.05831291f, -0.55018908f, 0.31012401f, 0.02628850f, 
    -0.05087739f, -0.07480661f, 0.12743597f, 0.14708275f, 0.09085516f, 0.08980774f, 0.10533252f, 0.16627726f, 
    0.72910899f, -0.00731016f, 0.31487632f, -0.09237294f, -0.08243697f, -0.09429617f, 0.03893719f, -0.01179802f, 
    0.09803875f, 0.13175355f, 0.15107168f, 0.22767845f, 0.14943703f, -0.08908147f, 0.15442231f, -0.37865576f, 
    0.02721464f, -0.01977836f, 0.16957952f, -0.06964975f, 0.00372720f, -0.03424713f, -0.09652640f, 0.03539375f, 
    0.14973256f, -0.02212322f, 0.07593869f, 0.13239154f, 0.03999508f, -0.04896352f, -0.01330901f, -0.10180517f, 
    -0.06550805f, 0.01035899f, 0.04056416f, 0.00263230f, -0.21394518f, -0.07392516f, -0.15985000f, 0.09520959f, 
    -0.02415680f, -0.14797537f, 0.05320172f, 0.00160385f, 0.13415965f, 0.03704810f, 0.10319557f, -0.05426503f, 
    0.01800475f, 0.14051257f, 0.12184864f, -0.12306686f, -0.09764390f, -0.04968220f, -0.08840539f, 0.02707539f, 
    0.14509216f, 0.15108952f, 0.03854698f, 0.14468493f, -0.14629845f, 0.12160721f, 0.19420823f, -0.17366786f, 
    -0.01938392f, -0.09807323f, 0.18991558f, 0.17228392f, -0.10729515f, -0.08393012f, 0.03905987f, -0.24182095f, 
    -0.26919636f, -0.24706413f, -0.14252655f, 0.06896745f, -0.05353546f, 0.00611507f, -0.01856377f, 0.07964965f, 
    0.00266738f, -0.05234296f, 0.05033834f, -0.08982123f, 0.06566935f, -0.10883294f, -0.04325119f, 0.07623156f, 
    0.07697980f, 0.06327206f, -0.07841209f, 0.04327811f, 0.08125091f, 0.00739563f, -0.14314924f, 0.23741330f, 
    -0.14192900f, -0.25011599f, -0.08799779f, -0.15607269f, 0.10325358f, 0.01556125f, 0.19801490f, -0.02008684f, 
    -0.03945166f, -0.10844972f, 0.04285503f, 0.01641708f, 0.27950865f, 0.05267233f, 0.15550570f, -0.05471959f, 
    -0.02012253f, 0.04703426f, -0.00349393f, 0.04917154f, 0.04863190f, 0.01219211f, 0.21502955f, 0.12312161f, 
    0.09448808f, -0.04224066f, 0.05164349f, 0.00550869f, -0.09033715f, -0.08146884f, 0.01724684f, 0.01307157f, 
    -0.04513213f, -0.14518680f, -0.00271320f, -0.04982308f, -0.03054961f, 0.13470209f, -0.08618593f, 0.04343315f, 
    0.06168973f, 0.08346304f, 0.12010610f, -0.08427180f, 0.09452043f, 0.05881923f, -0.15726961f, 0.01181651f, 
    -0.18433191f, 0.24739283f, 0.12886767f, 0.26394215f, -0.09314135f, -0.07191177f, -0.00227529f, 0.04585635f, 
    -0.03815680f, 0.15769213f, -0.14741236f, 0.11036405f, -0.19551657f, 0.08118748f, -0.19853689f, 0.06409919f, 
    0.05750931f, -0.08283351f, 0.10201092f, -0.03381069f, -0.03112393f, -0.10033863f, -0.06960673f, 0.02114737f, 
    -0.22354829f, -0.07694128f, -0.03419689f, -0.07192756f, 0.09505076f, -0.07227682f, 0.12779975f, -0.06817751f, 
    -0.05281161f, -0.02565897f, -0.00577098f, -0.10257402f, -0.05722203f, 0.03290433f, 0.13746656f, -0.21952042f, 
    -0.01598507f, 0.05128309f, 0.15944578f, 0.01749316f, 0.06316847f, -0.14462902f, 0.10021490f, 0.01580691f, 
    0.28152028f, 0.42454460f, 0.25269997f, -0.13794507f, -0.03416753f, 0.03378282f, -0.01872939f, -0.04621515f, 
    0.01674913f, 0.15080430f, -0.05921473f, 0.09394328f, 0.04836108f, 0.19091454f, -0.16762711f, 0.05927107f, 
    0.02990013f, 0.07237699f, -0.02755052f, 0.08249635f, 0.05251775f, -0.04802538f, -0.04787709f, -0.00697022f, 
    -0.03952010f, -0.07372160f, 0.30959094f, -0.11452544f, -0.01447313f, 0.04458072f, -0.05331263f, 0.10087092f, 
    0.14369369f, 0.02358105f, 0.13490474f, 0.14798720f, -0.01699102f, -0.11739337f, 0.19580455f, 0.00611006f, 
    -0.06729210f, 0.08422603f, 0.04969940f, -0.00898894f, 0.09574788f, -0.00184609f, 0.07350619f, 0.05327542f, 
    0.17325480f, 0.14275874f, 0.10769237f, 0.19020052f, 0.06115950f, -0.01576484f, 0.05044807f, 0.10544587f, 
    -0.04499032f, 0.04409968f, 0.09555316f, 0.03652020f, -0.39475814f, -0.40340424f, -0.33850959f, -0.43804038f, 
    -0.08740254f, -0.10568989f, -0.08928244f, -0.13404645f, 0.02201437f, 0.02791070f, 0.01247812f, 0.03745348f, 
    -0.16916536f, 0.30213305f, 0.13036396f, 0.35826874f, 0.03188299f, -0.05200625f, -0.03625498f, -0.14238586f, 
    0.08900156f, 0.08582789f, 0.05963761f, 0.20036682f, -0.05023747f, 0.12534247f, -0.04809644f, 0.14480871f, 
    -0.10410213f, 0.00936849f, 0.13495137f, -0.04194358f, 0.14238173f, 0.07044285f, 0.05642392f, 0.01580981f, 
    -0.13004494f, -0.09511818f, 0.06272613f, 0.04808010f, -0.07846355f, -0.10320603f, -0.14672206f, 0.06220433f, 
    -0.30932486f, -0.02535760f, -0.02306880f, 0.03635054f, -0.46173969f, 0.06509483f, -0.10642128f, -0.39892399f, 
    0.03277349f, 0.01830932f, -0.12228592f, -0.00724368f, -0.01914213f, 0.05314782f, -0.20558278f, -0.04578752f, 
    -0.01716196f, -0.12581789f, -0.00514559f, -0.00720898f, 0.11204824f, 0.02153072f, 0.01879678f, -0.00485747f, 
    0.04165616f, -0.09809472f, 0.20444195f, -0.00930155f, 0.01841348f, -0.08840267f, -0.04083458f, -0.09112059f, 
    0.01820800f, 0.04410500f, -0.03615072f, 0.12186106f, -0.07014243f, 0.02240504f, 0.19738896f, -0.13315694f, 
    -0.05654440f, -0.10398383f, -0.22001752f, -0.19323508f, -0.05862388f, 0.16167100f, 0.12731378f, 0.17055500f, 
    0.16618326f, 0.01024300f, -0.27793732f, -0.01734758f, 0.14612718f, -0.09437519f, 0.01807432f, 0.16521849f, 
    0.00457014f, 0.12543061f, 0.01714836f, -0.02486907f, 0.07306500f, -0.06370036f, -0.02601597f, 0.02174432f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.21584481f, 0.06331427f, 0.03138294f, 0.16039878f, 0.04288716f, -0.02963465f, 0.01810011f, -0.12265974f, 
    -0.05696428f, 0.08130291f, 0.03235647f, 0.03961390f, 0.02883747f, -0.11126398f, -0.00834350f, 0.19500408f, 
    0.04270537f, 0.02836621f, 0.09285878f, 0.01040392f, -0.03811265f, -0.03619890f, 0.02859432f, 0.10403071f, 
    -0.00910603f, -0.01789863f, -0.05108162f, 0.01505591f, -0.03714282f, 0.04323808f, -0.02538053f, 0.00725603f, 
    -0.05093433f, 0.16989286f, -0.02203756f, -0.00333082f, 0.10607038f, 0.01901030f, -0.02942163f, -0.04816576f, 
    0.02107766f, -0.02912836f, 0.03507132f, 0.01206667f, 0.15148823f, 0.03017302f, 0.07083776f, 0.02533775f, 
    -0.00227190f, -0.03868977f, -0.05608457f, 0.01289127f, -0.09092617f, 0.02685876f, 0.08823864f, -0.05478095f, 
    0.14269702f, 0.12192895f, 0.02629081f, -0.02457795f, 0.10759625f, 0.06826365f, 0.04270300f, 0.17320518f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.56915271f, 0.37821692f, -0.07835773f, -0.15588044f, -0.07312118f, 0.03924182f, 0.08038551f, 0.22440414f, 
    -0.09639841f, -0.41313115f, -0.25187033f, 0.03516531f, -0.06449583f, 0.19815542f, 0.04736067f, -0.23427829f, 
    0.19249265f, -0.12338322f, -0.18904233f, 0.03076215f, -0.30462170f, 0.03943780f, 0.07576678f, 0.02271164f, 
    0.06573170f, -0.03448298f, -0.11702454f, 0.15389314f, 0.08659755f, 0.06860506f, 0.11661709f, -0.09189902f, 
    0.00262759f, -0.10744682f, 0.16855185f, -0.11816334f, -0.05612263f, -0.41543701f, 0.10316829f, -0.12449738f, 
    -0.07374495f, -0.00052663f, -0.12934801f, -0.07009055f, -0.06662118f, -0.05861569f, 0.15238620f, -0.60941130f, 
    0.02800789f, 0.13931432f, 0.12205237f, -0.04716150f, 0.07436504f, 0.09635253f, 0.11603111f, 0.03872241f, 
    -0.11674357f, -0.37243310f, 0.10236324f, -0.12302972f, -0.04959723f, 0.13365291f, -0.08204109f, -0.25382110f, 
    0.05869018f, 0.37766764f, 0.01549169f, 0.20321253f, -0.03988407f, -0.11898864f, -0.05478021f, -0.40892974f, 
    0.06906881f, -0.16216531f, 0.08012376f, 0.25763622f, 0.04075333f, -0.00912315f, -0.02238416f, -0.37442476f, 
    0.04195517f, 0.04336114f, 0.05116164f, 0.00207635f, -0.03441188f, -0.03154552f, 0.04642917f, -0.00568427f, 
    -0.04354588f, 0.07352857f, 0.06076950f, 0.05024488f, -0.72135490f, 0.00072286f, -0.11540849f, -0.06949332f, 
    0.00481116f, 0.04613295f, 0.13915542f, -0.08327567f, 0.26388246f, -0.12995303f, -0.14322025f, -0.00465796f, 
    0.00489922f, 0.02758133f, -0.19879076f, 0.00266203f, 0.28051642f, -0.11226018f, 0.19322914f, -0.42966807f, 
    -0.05902490f, 0.12148906f, 0.12142016f, 0.14226869f, -0.47359487f, -0.06502607f, 0.08980419f, -0.63154024f, 
    -0.22444688f, 0.21405387f, -0.03728138f, 0.00878609f, 0.10561647f, 0.12571667f, -0.00275868f, 0.19327962f, 
    0.22727931f, -0.69561136f, 0.10329659f, -0.10168714f, 0.02537191f, 0.04291242f, 0.00127541f, -0.13707453f, 
    0.04591597f, -0.04558476f, 0.22696844f, -0.18701462f, 0.06845890f, -0.02011935f, -0.01925974f, 0.37413016f, 
    0.08637285f, -0.10335840f, -0.17558812f, -0.01236572f, -0.41761783f, 0.09355593f, 0.05005942f, -0.03592068f, 
    0.02980865f, -0.01759596f, 0.03240557f, 0.22734573f, 0.19096917f, 0.15394384f, -0.00212065f, 0.08911820f, 
    0.03164427f, -0.25404456f, 0.03851113f, 0.08436641f, 0.18204650f, -0.17713711f, 0.24968541f, -0.12910846f, 
    0.00062021f, 0.05642406f, -0.21684873f, -0.01872611f, -0.60587537f, -0.01391031f, -0.06124974f, 0.29951766f, 
    0.01947956f, 0.00602229f, -0.57956225f, 0.11274770f, -0.33207783f, -0.07414891f, 0.11345495f, -0.15032837f, 
    0.01674457f, 0.06117636f, -0.03269449f, 0.08781547f, -0.17171352f, -0.10808926f, -0.09746072f, 0.26689923f, 
    -0.32354569f, -0.20345041f, 0.01116473f, -0.03373622f, 0.08425907f, 0.07464564f, 0.03784434f, -0.01459777f, 
    0.01185609f, 0.19362205f, 0.12140261f, 0.15981302f, -0.12273476f, 0.12452165f, 0.20562837f, -0.29524657f, 
    -0.11713055f, -0.04458944f, -0.27883658f, -0.10223455f, 0.27872983f, -0.02062248f, -0.08137425f, -0.50879794f, 
    -0.03508576f, -0.01492312f, -0.01163280f, 0.10874069f, 0.22623180f, 0.16367750f, -0.06156742f, 0.10053243f, 
    -0.06167708f, -0.38396373f, 0.07102302f, 0.03802975f, -0.17738040f, -0.17927876f, 0.22988003f, 0.07971426f, 
    0.07128666f, 0.06034774f, -0.60045254f, 0.05474566f, -0.33837608f, -0.07140256f, -0.08221517f, 0.00340919f, 
    -0.04860919f, -0.08708297f, -0.13652124f, 0.12555264f, 0.25314033f, -0.01297977f, -0.38579801f, -0.12495016f, 
    -0.37265638f, 0.18693170f, -0.03725615f, 0.05662216f, -0.38569045f, -0.01428046f, -0.09798222f, -0.23671919f, 
    0.12428831f, -0.11129672f, -0.02344144f, -0.03309267f, -0.04386084f, 0.00044704f, -0.00457760f, 0.12756462f, 
    -0.12847839f, -0.11529950f, -0.22515398f, -0.44422361f, 0.00760301f, -0.07123000f, -0.13951370f, -0.22025932f, 
    0.18191826f, 0.08586285f, -0.07087903f, -0.00784294f, 0.13529924f, -0.12403774f, 0.01982578f, 0.00115731f, 
    -0.06734797f, 0.07570013f, 0.03104302f, 0.12705523f, -0.07312790f, -0.14936958f, -0.06788973f, -0.01527405f, 
    -0.01940308f, -0.26800603f, 0.11917453f, 0.06310717f, -0.24360719f, 0.12087476f, 0.19069603f, 0.08106360f, 
    0.08779842f, -0.04099030f, 0.11110741f, 0.02392293f, -0.02594877f, 0.05922752f, -0.01836630f, 0.26335096f, 
    -0.05629550f, 0.06830733f, 0.31103545f, 0.13396727f, 0.17158252f, 0.07445306f, 0.18316156f, 0.15941513f, 
    -0.12311930f, -0.05712023f, -0.03296259f, -0.10939095f, -0.16327909f, 0.00805201f, 0.03675896f, -0.35851222f, 
    0.23132929f, 0.28803369f, 0.06732610f, 0.13136412f, -0.05250642f, -0.09924453f, -0.06112858f, 0.13261780f, 
    -0.10974529f, 0.03897944f, -0.35197875f, -0.00552466f, -0.11479127f, -0.08172793f, -0.00157724f, 0.38035554f, 
    -0.00231257f, -0.04487940f, 0.35273194f, -0.05912432f, -0.10686994f, 0.03850907f, -0.02575863f, -0.10781050f, 
    -0.10915283f, 0.03287027f, 0.03863145f, -0.04092066f, -0.28331327f, 0.18981706f, -0.10789448f, 0.08468407f, 
    0.08546344f, 0.34958619f, -0.13417912f, -0.05143092f, -0.19542141f, -0.25891063f, -0.17219920f, 0.04967336f, 
    0.06352498f, -0.10854451f, 0.12356147f, -0.06451102f, -0.17854601f, -0.02977039f, -0.01056935f, 0.13573486f, 
    0.02215390f, 0.05042454f, -0.26960382f, -0.13298504f, 0.09653536f, -0.08197685f, 0.18228553f, -0.17734720f, 
    -0.01027491f, -0.37200543f, -0.03981797f, -0.00849828f, 0.24654207f, 0.21737494f, -0.04863549f, -0.27325472f, 
    0.08297864f, -0.50001800f, -0.07615755f, -0.40209386f, -0.12529163f, -0.01511774f, -0.02002566f, -0.47462499f, 
    -0.01416689f, 0.21332254f, 0.08183220f, -0.26650533f, -0.05529588f, -0.12385764f, -0.12364826f, 0.08015662f, 
    -0.66576809f, -0.06445272f, -0.17959520f, 0.06502105f, -0.53031069f, -0.07661103f, -0.01648895f, 0.27362472f, 
    -0.00871233f, 0.04571535f, 0.00940849f, -0.23352657f, -0.43769118f, -0.18161426f, -0.05848343f, -0.09910688f, 
    0.03099247f, -0.28404090f, -0.54370683f, -0.04412251f, 0.04068287f, 0.25599220f, 0.35533759f, 0.10567322f, 
    0.04717680f, -0.02855915f, 0.17730762f, 0.07303774f, -0.09376933f, -0.01295828f, -0.37874791f, 0.12736985f, 
    -0.07945831f, -0.04984083f, 0.07107098f, -0.48228744f, -0.24895635f, -0.00611201f, 0.14788796f, 0.12573615f, 
    0.07977059f, 0.20070912f, 0.08434396f, 0.04380449f, 0.16210300f, 0.04464812f, -0.05150538f, 0.17783566f, 
    -0.17395511f, -0.43357697f, -0.04754785f, -0.21909881f, 0.05526349f, -0.05555913f, -0.02706186f, 0.15109923f, 
    -0.09712099f, 0.08323756f, 0.23352173f, 0.14571083f, -0.06247037f, -0.43492937f, -0.35940266f, -0.39788407f, 
    -0.18137071f, -0.12953240f, 0.05980700f, -0.07637130f, 0.14861359f, 0.00508294f, -0.08309737f, -0.35225636f, 
    0.03982894f, -0.02277799f, -0.07172799f, 0.15503748f, 0.29533681f, -0.32263607f, -0.02953883f, -0.12360703f, 
    0.11354869f, -0.02218702f, -0.15187420f, 0.05163674f, 0.14840268f, 0.00533548f, 0.42346194f, 0.02349105f, 
    -0.07880724f, -0.09135594f, 0.10609331f, -0.00870591f, -0.04142914f, 0.09273179f, 0.02755194f, 0.25827780f, 
    -0.08231983f, 0.22654715f, -0.31018564f, -0.49438769f, -0.18839300f, 0.08617778f, -0.14728418f, 0.06116493f, 
    0.04719883f, -0.32981706f, 0.09030948f, 0.02184708f, -0.25271201f, -0.49002174f, 0.07161631f, -0.15263757f, 
    0.15075932f, -0.53030407f, 0.07234816f, 0.06657497f, -0.07645773f, -0.07105738f, 0.07305158f, -0.54330426f, 
    -0.08210368f, 0.11913277f, -0.16962960f, 0.10825876f, -0.10304313f, -0.50327879f, -0.05496833f, 0.20216146f, 
    0.00516696f, -0.08049901f, 0.13474575f, -0.03537710f, 0.27946860f, 0.06055188f, -0.09360839f, -0.03822396f, 
    0.08956083f, 0.09505033f, -0.01783169f, -0.22539245f, 0.61779177f, 0.15540349f, -0.10153124f, -0.07842175f, 
    -0.02678385f, 0.27070928f, -0.32342777f, -0.12714420f, 0.19937380f, -0.19958282f, -0.39644438f, 0.00360593f, 
    -0.11330070f, 0.05483358f, -0.21872468f, 0.08569934f, -0.24281015f, -0.02508850f, 0.23227298f, -0.39105949f, 
    0.08840730f, -0.26730072f, -0.21160479f, -0.28441802f, 0.10887758f, -0.02706946f, -0.30731681f, -0.42742479f, 
    0.12056918f, -0.28781158f, 0.05364837f, -0.10352369f, 0.14656752f, -0.73643899f, -0.02790113f, -0.13323765f, 
    -0.14753497f, 0.01269513f, -0.00335490f, -0.32360557f, -0.04908971f, -0.04024310f, 0.05305924f, -0.29388356f, 
    0.02034077f, -0.06809622f, 0.03293505f, -0.04388573f, -0.10072516f, -0.24388565f, -0.41011354f, 0.26976964f, 
    0.33066693f, 0.09279475f, 0.27502868f, -0.03686494f, -0.01045333f, 0.05051378f, 0.06586264f, -0.06881745f, 
    -0.11438388f, -0.00046111f, -0.04735268f, 0.25466350f, -0.25682113f, -0.43616131f, -0.10701454f, 0.00017600f, 
    0.05653787f, -0.33692682f, -0.42605752f, 0.06604864f, -0.20703706f, 0.26123565f, -0.39598301f, 0.04097224f, 
    0.03636196f, 0.05272120f, 0.21858224f, -0.07119215f, -0.11608022f, 0.06131936f, -0.02286673f, 0.09612516f, 
    0.03082852f, 0.10399695f, 0.23723617f, 0.12819056f, -0.07838988f, 0.11146048f, -0.28622305f, 0.27113473f, 
    0.09800503f, 0.08447384f, -0.10992652f, -0.10676251f, -0.28547040f, 0.28374237f, -0.10013395f, 0.10686582f, 
    0.20594142f, -0.36286175f, -0.05634694f, 0.16198188f, 0.01557634f, -0.08293462f, 0.09567850f, 0.09715687f, 
    -0.07024241f, -0.06146216f, 0.30362162f, -0.01609344f, -0.02364083f, 0.14650823f, 0.15340678f, -0.03757288f, 
    -0.16453640f, -0.02100859f, -0.56052083f, 0.05082575f, 0.18062949f, 0.01273125f, 0.09551996f, 0.25314155f, 
    -0.04281401f, -0.11175897f, 0.06514321f, -0.22774065f, -0.02540942f, 0.12724410f, -0.10640185f, -0.08751488f, 
    -0.03481783f, 0.27540720f, 0.17295834f, 0.04442961f, 0.11762369f, 0.42104429f, -0.31368411f, 0.09823065f, 
    -0.05283750f, -0.08948277f, 0.18698539f, -0.09087203f, -0.22285923f, -0.07291966f, 0.16608201f, 0.04129277f, 
    0.10462099f, -0.62312055f, -0.00134443f, -0.31929764f, -0.50880021f, -0.06153750f, -0.35940054f, -0.26715958f, 
    -0.36424455f, -0.10757521f, 0.08250055f, 0.05600030f, -0.22220093f, -0.04829634f, 0.08656414f, -0.28154024f, 
    0.05122455f, -0.09484914f, 0.03543771f, 0.30333897f, 0.00769209f, -0.04118687f, 0.10626394f, 0.44389898f, 
    -0.05519478f, 0.11895312f, -0.12335432f, 0.04228679f, -0.01197482f, 0.16219267f, 0.39326844f, -0.34189320f, 
    -0.25281689f, -0.05642128f, -0.19854707f, -0.12343796f, 0.01126847f, -0.05748916f, 0.11423959f, 0.14478965f, 
    -0.07367439f, -0.00036682f, 0.05513594f, -0.70405561f, 0.04774609f, -0.34276834f, 0.08737987f, -0.02098870f, 
    -0.03631753f, -0.26801991f, -0.32315889f, -0.08099754f, 0.07476421f, -0.36122027f, -0.34602123f, 0.00187922f, 
    -0.12705411f, 0.06149722f, -0.15796073f, -0.12391590f, -0.08887560f, 0.04739815f, -0.45380500f, -0.35082662f, 
    -0.09075224f, -0.14066173f, -0.07679732f, -0.14354713f, -0.07247567f, -0.01111198f, 0.16899204f, 0.16582970f, 
    0.23165518f, 0.40865588f, 0.01570279f, 0.01387799f, 0.00565887f, -0.28882399f, 0.08979452f, -0.12458407f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09007312f, 0.15769489f, 0.12944914f, -0.03242742f, -0.10509448f, -0.01117851f, -0.06753308f, -0.06886134f, 
    0.10129106f, -0.09729137f, -0.02199428f, -0.05880815f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
