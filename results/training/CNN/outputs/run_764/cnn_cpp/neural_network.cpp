#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.90544248f, -0.57444203f, -0.44995630f, 0.75058442f, 1.04041731f, 0.27082461f, -0.12694722f, -0.49350151f, 
    0.07323162f, -1.06195736f, 0.11733026f, 0.21406883f, 0.17332728f, 0.60249043f, -0.62712640f, 0.04689552f, 
    0.09843477f, -0.37915754f, 0.56268138f, 0.15111399f, 0.51097238f, -0.56416696f, -0.77032036f, 0.71483737f, 
    0.01434859f, -0.04669043f, 0.32992956f, 0.68386483f, 0.16070233f, 0.52090126f, -0.65626401f, -0.53089356f, 
    -0.65656090f, -0.13735130f, -0.51966548f, -0.39645320f, 0.58652109f, 0.69320476f, 0.89330184f, -0.12878112f, 
    0.71411276f, -0.19483151f, -0.00926417f, 0.08195504f, 0.47294405f, 0.10383660f, -0.00280508f, 0.20805059f, 
    -0.72659463f, -0.66590708f, -0.53918284f, 0.34062761f, 0.63690692f, 0.00783692f, -0.67978001f, 0.41772482f, 
    0.78454411f, 0.45646673f, 0.80614030f, 0.54386741f, -0.01049071f, 0.58795363f, 0.14390844f, 0.82893962f, 
    -0.59905690f, -0.48345196f, -0.64563996f, -0.19415919f, 0.20236118f, -0.12766308f, -0.02375939f, 0.15271020f, 
    -0.08752347f, 0.12425156f, -0.59796387f, 0.81883180f, 0.48422986f, -0.76187497f, 0.05114316f, 0.43763849f, 
    0.16145834f, 0.87174344f, -0.49415523f, 0.03357133f, 0.69501227f, 0.51399535f, 0.64023268f, 0.24197678f, 
    0.03653532f, 0.01231049f, -0.78119874f, -1.05883527f, -0.63559580f, -0.26888809f, -0.46507215f, 0.37332934f, 
    0.35203049f, 0.06578794f, 0.20991944f, -0.15446106f, 0.64752561f, -0.52147353f, -0.14809735f, 0.52320689f, 
    0.18843140f, -0.45858023f, 0.00996093f, -0.29829657f, 0.37394062f, 0.78235662f, 0.04491568f, 0.19442940f, 
    -0.34671640f, 0.22538142f, 0.46152350f, -0.17951509f, 0.60985851f, -0.49935427f, -0.73332733f, -0.68260700f, 
    -0.18115951f, -0.02653295f, -0.38605955f, 0.04965594f, -0.02477434f, -0.12224265f, 1.02903092f, 0.66408128f, 
    0.24991646f, 0.38986054f, 0.26717898f, 0.00156153f, -0.13695927f, 0.23159668f, 0.02743011f, 0.72238541f, 
    0.63030785f, 0.32698917f, -0.22464080f, -0.39539361f, 0.13304709f, 0.32982627f, 0.19617030f, -0.69603360f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.18508439f, 0.11632524f, -0.09154811f, 0.15095988f, -0.08982961f, 0.09258419f, 0.06117775f, -0.09725305f, 
    -0.00899045f, 0.12741221f, 0.40790135f, 0.22172941f, -0.39166808f, -0.20402566f, 0.52886856f, 0.05202346f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.26439768f, -0.37751472f, -0.37412354f, 0.13661045f, 0.09272192f, 0.01441220f, 0.06453922f, -0.06901013f, 
    -0.22876334f, -0.32379588f, -0.08163530f, -0.21761034f, 0.15643239f, 0.11371582f, 0.01476649f, 0.08632632f, 
    -0.03546567f, -0.02850874f, -0.14623852f, 0.05855637f, 0.17101996f, -0.10571054f, 0.07771948f, 0.07895087f, 
    -0.10449853f, -0.07610010f, 0.13024856f, 0.05489371f, 0.20243718f, 0.10465482f, -0.23712553f, 0.10309769f, 
    0.13327484f, 0.03339982f, 0.03800549f, 0.10768957f, -0.11366917f, 0.17123820f, 0.26544994f, 0.02840181f, 
    0.25503105f, 0.22232278f, 0.03473168f, -0.06685764f, -0.02622351f, 0.30039451f, 0.11098137f, 0.05638119f, 
    -0.01612424f, 0.06975052f, 0.21270369f, 0.13819349f, 0.15573290f, 0.18417379f, -0.00497077f, -0.35865906f, 
    0.15900075f, 0.07327273f, 0.20832302f, 0.16397743f, -0.16313837f, 0.03430080f, -0.02883377f, 0.31727952f, 
    -0.09074023f, -0.29946122f, -0.28459060f, -0.23263273f, -0.02857407f, 0.05921723f, -0.02258343f, 0.19423972f, 
    -0.50981867f, -0.29166406f, 0.15066653f, 0.01311406f, 0.08508456f, -0.14286463f, 0.06358628f, -0.32642004f, 
    -0.25662276f, 0.10469508f, 0.17440809f, -0.07438143f, 0.12386896f, 0.13320738f, -0.10759097f, -0.02953296f, 
    0.16175196f, -0.01082749f, -0.38749421f, -0.11096707f, -0.31257451f, 0.36003426f, 0.13128428f, 0.13062474f, 
    0.07930598f, 0.02189577f, 0.04397282f, -0.30903146f, -0.19826074f, 0.35341141f, -0.21772775f, 0.18592618f, 
    -0.05239780f, -0.18452786f, 0.05342535f, 0.19439393f, -0.22666056f, 0.07414740f, -0.03544777f, 0.07652545f, 
    -0.09008743f, -0.26591548f, -0.04609806f, -0.14227307f, -0.13671617f, -0.37089536f, 0.19179195f, -0.26726317f, 
    0.21637209f, 0.02817092f, 0.04966941f, 0.10632959f, -0.03942215f, -0.04690657f, -0.18652612f, 0.40659955f, 
    0.17211270f, 0.12277942f, 0.07628475f, 0.13238919f, 0.00418284f, 0.00473802f, 0.12787180f, 0.10197557f, 
    0.13024062f, 0.16186854f, -0.15736572f, 0.14376561f, 0.01679479f, 0.06579609f, 0.01505299f, 0.06123113f, 
    -0.29139319f, 0.44667274f, 0.25242746f, 0.33428636f, 0.19164521f, 0.05702079f, -0.10378765f, -0.03970242f, 
    0.42472035f, 0.22856283f, 0.20333442f, -0.00366906f, 0.01968026f, -0.18894744f, -0.06072201f, -0.17989865f, 
    0.01793014f, 0.00824774f, -0.07478352f, -0.23458295f, -0.39296454f, -0.22912654f, -0.18732044f, -0.00576389f, 
    -0.04032483f, -0.07745859f, -0.03133623f, 0.36702821f, -0.30076593f, 0.05120282f, 0.14909242f, -0.22085071f, 
    0.10171544f, 0.09097556f, 0.11368328f, 0.09502508f, 0.34407800f, -0.10562190f, -0.06777348f, 0.00391462f, 
    0.05943632f, 0.08987777f, -0.05063549f, 0.00763375f, -0.27646732f, 0.00803507f, -0.13020268f, -0.13442011f, 
    0.06090006f, -0.11445963f, -0.03303100f, 0.11302196f, -0.10470956f, -0.09529469f, 0.24289379f, -0.01550400f, 
    0.11534019f, 0.03513315f, 0.01231670f, 0.18902208f, 0.04877336f, -0.03422740f, 0.20578150f, 0.38667002f, 
    0.16072831f, -0.16545470f, -0.29698461f, -0.01290213f, -0.08732132f, 0.03176201f, -0.01723139f, -0.08233029f, 
    -0.32914284f, 0.11630908f, 0.01048915f, 0.02734784f, 0.04279787f, 0.05968856f, 0.04825143f, 0.07655864f, 
    0.17338164f, -0.48688966f, -0.40015846f, 0.02064663f, -0.06589162f, 0.08655808f, -0.02194132f, -0.12380885f, 
    0.00086257f, -0.08096173f, 0.10530940f, -0.04995643f, 0.05590277f, -0.07533097f, 0.07962359f, -0.07378986f, 
    0.01532594f, 0.05535037f, -0.17229019f, -0.13196132f, -0.06816123f, -0.07633074f, 0.00002589f, 0.15144104f, 
    -0.03538857f, -0.11907768f, -0.15131231f, 0.11656525f, 0.11122421f, -0.25171009f, 0.26110739f, 0.14420822f, 
    0.00227851f, -0.04300422f, -0.01482476f, -0.11791346f, -0.29463357f, -0.06949276f, 0.18301661f, 0.31118608f, 
    -0.02777218f, 0.09852964f, 0.00699151f, -0.26906240f, 0.06908204f, -0.00396415f, 0.45511207f, -0.20749256f, 
    0.15813920f, 0.06762678f, -0.05291915f, 0.04074918f, 0.07427124f, 0.03388811f, 0.04775223f, 0.16190664f, 
    -0.02887554f, -0.26602471f, -0.07336067f, 0.09804802f, -0.02006214f, 0.10717366f, 0.01711005f, -0.08595876f, 
    0.25309262f, 0.44612595f, 0.29631281f, 0.11799311f, -0.05826027f, 0.02048496f, -0.03420861f, 0.17352037f, 
    -0.16603759f, 0.39928016f, 0.23287874f, 0.26297712f, -0.04379836f, -0.17262769f, -0.03184388f, -0.19816886f, 
    -0.12931012f, 0.01637108f, 0.09909782f, -0.25748596f, 0.01592642f, -0.19478327f, -0.03192903f, -0.20024645f, 
    0.00451774f, -0.09739850f, 0.20246366f, -0.01106655f, -0.18020271f, 0.09113865f, 0.07772017f, 0.08635060f, 
    0.23625933f, 0.04633544f, -0.11115714f, -0.07297342f, -0.05808342f, 0.03369636f, 0.07507405f, 0.14611228f, 
    0.12291422f, 0.10368076f, 0.02333692f, -0.04595594f, -0.00604617f, -0.01140004f, -0.00447676f, 0.08997880f, 
    -0.22962657f, -0.12681034f, 0.06305020f, 0.00323660f, -0.04709008f, -0.12361683f, -0.48145884f, 0.08616410f, 
    0.00452902f, 0.13806523f, 0.12089793f, -0.04743633f, 0.01173634f, 0.18276487f, 0.02573507f, 0.11344801f, 
    0.20470680f, -0.11081202f, 0.01715594f, -0.09960581f, -0.06019345f, 0.08421568f, -0.05328130f, -0.07966909f, 
    0.05475123f, 0.23346113f, -0.13793954f, -0.07157284f, 0.04356133f, -0.09348170f, 0.02935934f, 0.24015193f, 
    -0.03094277f, -0.09763822f, -0.33971661f, -0.08048684f, -0.06364791f, 0.08632810f, -0.18392500f, 0.02106579f, 
    0.01551558f, 0.36395174f, -0.04043417f, 0.26434633f, -0.07088814f, 0.07762277f, -0.15252797f, -0.01177299f, 
    -0.01774135f, 0.10276227f, -0.23367465f, -0.03925003f, -0.00358464f, 0.00100345f, 0.02111129f, 0.08279415f, 
    -0.00341855f, 0.00089300f, -0.15698196f, 0.00633443f, 0.11724246f, -0.16236086f, -0.02732150f, 0.12259352f, 
    0.01113520f, 0.12958707f, -0.07453167f, -0.00741724f, -0.24117845f, 0.03047575f, 0.42428091f, -0.06069556f, 
    0.21095343f, -0.07003239f, -0.01834276f, 0.00261757f, -0.02210395f, 0.05696023f, -0.29794851f, -0.28073698f, 
    -0.29819778f, -0.02918826f, -0.06830958f, -0.15465787f, 0.11472158f, -0.02913683f, 0.02212803f, -0.02609040f, 
    -0.67885554f, -0.29077128f, -0.11176083f, 0.04718856f, 0.05382626f, 0.10838616f, -0.23636508f, 0.06404848f, 
    0.66130424f, 0.33985382f, -0.11727730f, 0.10623432f, 0.19528572f, -0.03124195f, 0.12992054f, -0.08001171f, 
    -0.00006742f, -0.25792646f, 0.18454424f, 0.25175479f, 0.09997296f, 0.19543120f, 0.01662591f, -0.06445140f, 
    0.08502322f, -0.04863919f, -0.05969452f, -0.18505307f, -0.24723068f, -0.23558447f, -0.05733027f, -0.16612218f, 
    0.02312453f, 0.08426039f, 0.20097317f, 0.11793567f, -0.26747635f, 0.10200283f, -0.22514708f, 0.23688342f, 
    0.11578865f, 0.18583392f, 0.10439713f, 0.13945669f, 0.13265046f, 0.16286224f, -0.06901346f, 0.00119591f, 
    0.04633074f, 0.04574484f, 0.03750024f, 0.17038998f, 0.19071616f, -0.34527913f, -0.26223531f, 0.18367426f, 
    -0.30684343f, 0.04683967f, 0.03643285f, 0.00699384f, 0.15455411f, 0.11928364f, 0.21353926f, 0.41778484f, 
    0.33220041f, 0.03924429f, -0.10822681f, -0.18260609f, -0.03269355f, 0.07573803f, 0.19197525f, -0.46038663f, 
    -0.32315341f, -0.19906944f, -0.09735208f, 0.21608993f, -0.06254802f, -0.10189632f, 0.03836983f, 0.17209153f, 
    -0.27859849f, -0.36213318f, -0.26116249f, 0.12077336f, 0.02513256f, -0.01986157f, -0.01185619f, 0.10609511f, 
    0.04388282f, 0.06054510f, -0.24820432f, -0.18084094f, 0.02398889f, -0.26592559f, 0.12445867f, 0.04397938f, 
    0.08179580f, -0.13524763f, -0.13351563f, -0.26106530f, 0.14328712f, 0.21436445f, -0.06177263f, 0.13547815f, 
    -0.05038546f, -0.06851486f, 0.14445798f, 0.37605983f, 0.01264842f, -0.14555167f, 0.16247474f, -0.27025837f, 
    -0.14985228f, 0.00670186f, 0.01862294f, -0.00697958f, -0.22784983f, 0.12594911f, -0.11595869f, -0.29341692f, 
    -0.11915671f, -0.04346551f, 0.00990340f, -0.10050903f, -0.15321776f, -0.05900303f, -0.03837563f, 0.23244260f, 
    0.25374553f, 0.08757942f, 0.13821718f, -0.01045106f, 0.08285840f, -0.19749548f, 0.08991583f, 0.06595644f, 
    0.06107767f, -0.12874208f, -0.07021458f, 0.14190696f, -0.04384220f, 0.08945211f, 0.10369930f, 0.15099092f, 
    -0.06341430f, 0.11227538f, -0.39110607f, -0.23580432f, -0.02560156f, 0.20188123f, -0.01779815f, 0.03820630f, 
    0.17824170f, 0.03580788f, -0.05612203f, -0.25314888f, 0.08263994f, -0.12870473f, -0.08315246f, 0.10337623f, 
    -0.01532333f, -0.07359528f, 0.06851425f, -0.11845405f, -0.17239155f, -0.15758716f, 0.01509331f, 0.01054327f, 
    0.05764178f, -0.05861782f, 0.08510409f, 0.22327861f, -0.09177669f, -0.08828774f, -0.06859211f, 0.23391089f, 
    0.16736783f, 0.18744291f, 0.22481279f, 0.22811419f, 0.13727546f, -0.13208094f, 0.11625988f, 0.21225050f, 
    0.34373316f, -0.40864003f, -0.11503966f, -0.14539166f, 0.07737648f, -0.24338438f, -0.15164667f, -0.01333967f, 
    0.09690853f, 0.12686388f, -0.07626148f, -0.04026403f, 0.12715210f, 0.34297058f, 0.10944247f, 0.09059929f, 
    -0.01396644f, -0.20887649f, 0.24740648f, 0.08240942f, 0.00125640f, -0.10028942f, 0.01813840f, -0.11677199f, 
    -0.14950694f, 0.06804670f, -0.14118916f, 0.03629775f, 0.03068796f, 0.19716410f, 0.14816523f, -0.17845644f, 
    0.01496438f, 0.01813554f, 0.02319559f, -0.20056856f, 0.13060388f, 0.04292712f, -0.04456995f, -0.21452901f, 
    0.20837037f, -0.33992285f, -0.07824755f, -0.02726516f, -0.08497848f, 0.04730697f, -0.17037371f, 0.06071472f, 
    -0.08408782f, -0.38461193f, -0.22223544f, 0.03014759f, 0.16483796f, 0.20458078f, -0.08602438f, 0.19317400f, 
    0.00103773f, -0.06862775f, 0.15170072f, 0.31215170f, -0.34231782f, -0.07397507f, -0.00244155f, 0.09097058f, 
    0.11669106f, 0.14872651f, -0.08616571f, -0.15769242f, -0.05777081f, -0.01729343f, 0.08602494f, 0.02606792f, 
    -0.01080878f, 0.03031175f, 0.16959400f, -0.00944503f, 0.15472615f, -0.24151316f, 0.06912268f, 0.18213595f, 
    -0.15507820f, -0.08000578f, 0.23961022f, -0.26789659f, 0.08982596f, -0.34016517f, -0.18234348f, 0.04653769f, 
    -0.02621295f, 0.00420132f, -0.10774289f, 0.32094744f, -0.08857542f, -0.16051616f, -0.36002091f, -0.00353978f, 
    0.04444054f, 0.02089650f, 0.17016429f, -0.22451232f, 0.02034931f, -0.13412428f, 0.26245752f, 0.24765645f, 
    -0.31517777f, -0.09848792f, 0.20497712f, 0.04993686f, 0.10091998f, 0.04898252f, -0.08748214f, 0.03118938f, 
    0.38212714f, 0.07280555f, 0.03875021f, -0.06892665f, -0.42634594f, 0.06188788f, 0.13635065f, -0.17363219f, 
    -0.08450100f, 0.50195414f, -0.29116595f, -0.09742067f, -0.13462932f, -0.05497012f, -0.38457072f, -0.14500587f, 
    0.12943554f, -0.01703180f, -0.60294884f, 0.25902697f, -0.07438949f, -0.13208573f, -0.10466458f, 0.06097636f, 
    -0.13288841f, 0.18496127f, 0.02785528f, 0.07052588f, 0.27995354f, 0.01823460f, 0.18860903f, 0.14792098f, 
    0.04571255f, 0.04986534f, 0.02018867f, 0.12754239f, -0.28877738f, 0.24987718f, -0.03711458f, -0.06630913f, 
    0.34453297f, -0.01189834f, 0.11725961f, -0.12654153f, -0.06228309f, 0.04382081f, 0.24000977f, 0.01841001f, 
    0.13206692f, 0.16038370f, -0.23952642f, -0.15468228f, 0.02297626f, -0.15255713f, 0.54755175f, 0.01425612f, 
    0.12933005f, -0.16367318f, -0.13894647f, 0.27851528f, -0.04701992f, 0.19515805f, 0.13664059f, 0.55723178f, 
    -0.22996987f, -0.20776166f, 0.02969804f, 0.05211562f, 0.18395761f, -0.15360066f, 0.06205375f, 0.07375860f, 
    0.25484669f, -0.47755927f, 0.04250510f, 0.11964688f, -0.20630769f, -0.07241321f, -0.07519941f, -0.05496228f, 
    0.08152965f, -0.18359610f, 0.15960875f, -0.02319134f, 0.02793148f, -0.22142448f, -0.07348814f, -0.15505075f, 
    0.09264515f, 0.05045062f, 0.41019180f, -0.16498423f, 0.14466557f, -0.24895155f, -0.01494134f, -0.13764073f, 
    -0.03797862f, -0.12349047f, 0.01097694f, 0.08414277f, -0.05688751f, -0.18273796f, -0.23477837f, 0.15266915f, 
    0.23020622f, -0.01476922f, -0.04530565f, 0.08832785f, 0.15148889f, 0.20966917f, -0.22911665f, 0.06770982f, 
    0.35296959f, -0.04877873f, -0.20204747f, 0.01706352f, -0.34801596f, -0.03493090f, -0.34193903f, -0.02531080f, 
    -0.26127476f, 0.09343351f, -0.14888377f, 0.03299163f, 0.01135845f, 0.28643101f, 0.01284512f, 0.14182588f, 
    0.04306081f, -0.02709174f, -0.01896120f, 0.21593982f, -0.19010518f, 0.00439717f, 0.00261061f, -0.17316237f, 
    0.21714269f, 0.07601315f, -0.06068521f, 0.10125960f, 0.02704379f, 0.10384512f, -0.10615955f, 0.11901466f, 
    0.67906743f, -0.24183537f, -0.28628936f, 0.15194307f, 0.05332546f, 0.16715726f, -0.03179003f, -0.11051814f, 
    -0.02917601f, 0.16551131f, -0.15311550f, 0.01488193f, -0.04570735f, 0.11135685f, 0.02514836f, -0.07015116f, 
    0.22697252f, 0.10431759f, -0.03659311f, 0.20923243f, 0.06896982f, 0.01589734f, -0.21091226f, -0.11953027f, 
    -0.05669791f, 0.14017010f, 0.09297880f, -0.10832112f, 0.09546442f, 0.11974926f, 0.09750267f, 0.02866193f, 
    -0.00578388f, 0.00856084f, 0.02935449f, 0.03905327f, -0.01262159f, 0.27662119f, 0.10392784f, -0.30536005f, 
    -0.13418961f, 0.09861277f, 0.02695048f, -0.06390310f, -0.01544703f, 0.18700746f, 0.16010867f, -0.13586690f, 
    0.04829037f, -0.03541721f, -0.08308804f, -0.13654548f, 0.05881987f, 0.00542084f, 0.23846537f, -0.01999965f, 
    -0.04692085f, -0.17679325f, -0.09988406f, 0.01477752f, 0.09665900f, -0.08133163f, -0.16688177f, -0.09649602f, 
    -0.23098095f, 0.10433702f, 0.03184532f, 0.07078968f, -0.16189168f, -0.03382926f, 0.07151769f, 0.04524680f, 
    0.06576855f, -0.73649067f, -0.36091781f, 0.17523122f, -0.20464461f, -0.06845504f, 0.01874068f, 0.04131378f, 
    -0.00706279f, 0.09263579f, -0.33790484f, -0.20184788f, 0.02131986f, 0.27478528f, 0.25293607f, -0.11751062f, 
    -0.04362265f, 0.02972345f, 0.00787353f, 0.13911045f, -0.04765847f, -0.06681291f, -0.12627389f, -0.07639700f, 
    0.02109797f, 0.02749327f, -0.06220096f, -0.02189734f, 0.21028370f, -0.09122434f, 0.05928221f, -0.15766646f, 
    0.00402777f, 0.11564207f, 0.16601048f, 0.00826134f, -0.01141234f, -0.22028394f, 0.05905509f, -0.06479796f, 
    0.14472626f, -0.07070418f, -0.06499168f, 0.14623813f, -0.16403098f, -0.47713965f, -0.15518311f, -0.26792470f, 
    -0.13509172f, 0.18014009f, 0.13068531f, -0.13445587f, 0.01085543f, -0.07349171f, -0.10912523f, 0.45388064f, 
    0.29755384f, -0.25975418f, 0.04812057f, 0.04766766f, 0.02012792f, -0.08191482f, 0.03756109f, -0.10662756f, 
    0.46986112f, 0.07930636f, -0.38775685f, -0.34449801f, 0.04873968f, -0.03268012f, 0.17736244f, 0.10872001f, 
    -0.04636346f, -0.03845479f, 0.04255319f, 0.02650230f, -0.01821709f, -0.07720888f, 0.01308281f, -0.01187703f, 
    -0.02174004f, -0.01832216f, 0.00256869f, -0.02019916f, -0.01688307f, -0.05392233f, -0.07541663f, -0.06735403f, 
    0.04798472f, -0.00876935f, -0.06907154f, 0.03771369f, -0.03183684f, 0.06969970f, -0.02189960f, 0.07070053f, 
    -0.03646940f, -0.05495990f, -0.07754235f, -0.07983177f, 0.05614291f, -0.00909817f, 0.02609411f, -0.01552474f, 
    -0.03423722f, -0.04279034f, 0.03660740f, -0.06834213f, -0.05202635f, -0.06059947f, 0.04376193f, -0.02222365f, 
    -0.01166228f, 0.01514620f, 0.03611526f, 0.05155572f, -0.08990488f, 0.05619252f, 0.02925518f, 0.05877456f, 
    0.03059254f, 0.01219395f, 0.05002221f, -0.04037502f, -0.03178196f, 0.05427303f, -0.02372160f, 0.02723982f, 
    -0.05054623f, -0.00000398f, 0.00941689f, 0.01364778f, -0.03072936f, -0.00611232f, 0.00832913f, -0.07526739f, 
    0.02058475f, 0.06953850f, -0.02081451f, -0.02595283f, -0.04068889f, -0.08856876f, 0.01953907f, -0.07996792f, 
    -0.04990631f, -0.08246583f, -0.02331382f, -0.02754058f, 0.02091386f, -0.00939740f, 0.03718743f, 0.04530125f, 
    -0.06675419f, -0.07964434f, 0.00856922f, -0.02420756f, 0.04152212f, -0.06868722f, 0.01088839f, -0.03126106f, 
    -0.04011134f, -0.02628773f, -0.05882435f, -0.05685132f, -0.03761578f, -0.07815156f, -0.07883050f, -0.02354799f, 
    0.00649743f, -0.07484518f, -0.04820751f, -0.06637691f, 0.02250917f, -0.05659544f, 0.02855094f, -0.01807441f, 
    -0.07584243f, 0.06048071f, -0.01696412f, -0.04407362f, -0.04493154f, -0.05398002f, 0.05622890f, -0.01015021f, 
    -0.03657043f, -0.01398958f, -0.02445123f, 0.03978289f, 0.03797745f, -0.04943895f, -0.08268549f, -0.01864605f, 
    0.02328910f, 0.03376261f, -0.00616075f, -0.02165601f, -0.00179311f, -0.05626709f, -0.08246559f, 0.06083160f, 
    0.06489022f, 0.02652136f, 0.04413271f, -0.02511914f, 0.01711998f, 0.02606742f, -0.08862575f, 0.04914474f, 
    -0.03682313f, -0.00457713f, -0.00734654f, -0.05397771f, -0.08073921f, -0.06315507f, 0.00064460f, -0.08769754f, 
    0.00568773f, -0.13534850f, 0.15819642f, -0.12668200f, -0.30419517f, 0.01552421f, -0.09225640f, 0.06134909f, 
    -0.07401434f, -0.48308337f, -0.12373517f, -0.27916270f, -0.13744041f, 0.05256547f, -0.09847694f, 0.13411678f, 
    -0.17870189f, 0.00721141f, -0.03642577f, -0.21245243f, 0.04612975f, 0.37582040f, 0.06449413f, 0.04779109f, 
    0.10296219f, 0.15892614f, 0.12495364f, -0.28616995f, -0.24888654f, -0.32701281f, -0.02695693f, 0.08904544f, 
    0.18116811f, 0.06059996f, 0.04714796f, 0.23370498f, -0.15365577f, -0.25312045f, -0.35016567f, 0.01978566f, 
    -0.11408937f, -0.09565892f, -0.21527687f, -0.11153585f, 0.13016550f, 0.26382637f, 0.09297742f, -0.38529289f, 
    0.18452612f, 0.10113432f, -0.12180670f, 0.08538161f, 0.00390689f, -0.10806374f, 0.12321862f, 0.18025975f, 
    -0.04627356f, -0.21203540f, 0.07689180f, 0.06541254f, 0.11579792f, -0.03924910f, 0.24747720f, 0.11520573f, 
    0.03593458f, -0.18487245f, 0.14584208f, 0.00253842f, -0.07787415f, 0.02405518f, -0.02642997f, -0.16102253f, 
    0.01039724f, -0.19907871f, -0.23970623f, 0.01619617f, -0.29459909f, 0.00158736f, -0.04819104f, -0.06190500f, 
    0.31521234f, 0.03759919f, 0.03468072f, 0.04583324f, 0.03655625f, 0.02917230f, -0.07149319f, 0.11068551f, 
    0.09916773f, -0.04075470f, -0.25346330f, -0.12631838f, 0.44567156f, -0.16293208f, 0.01650969f, -0.19038741f, 
    -0.10923158f, -0.02803709f, 0.16432627f, -0.05784150f, 0.03483296f, -0.25343475f, 0.11795136f, -0.06923530f, 
    0.00553144f, 0.00016747f, 0.15569419f, -0.06806823f, 0.11734647f, 0.59613937f, 0.00156341f, 0.07869086f, 
    -0.15345302f, -0.11711197f, -0.10983165f, -0.07043242f, 0.12028868f, 0.06582306f, 0.01673233f, 0.22137780f, 
    0.11321065f, -0.05026026f, -0.05791085f, 0.25323501f, 0.18781303f, -0.02978202f, 0.32642534f, 0.29267588f, 
    0.03706538f, 0.01623157f, 0.12909816f, -0.19107890f, 0.02231034f, 0.06591786f, -0.04376980f, -0.00237282f, 
    0.21684060f, 0.14756565f, -0.13447490f, 0.08834838f, 0.00903359f, 0.11590769f, 0.12815580f, -0.06285633f, 
    -0.13242966f, 0.40917850f, -0.21675389f, -0.02702776f, 0.08013045f, 0.19016351f, 0.19955045f, 0.09320367f, 
    0.16083665f, 0.38464090f, 0.36786118f, -0.12485591f, 0.10615975f, 0.08643606f, 0.06817798f, -0.01680256f, 
    0.14997984f, 0.01410699f, 0.35495114f, -0.55423802f, -0.03372376f, -0.11497951f, -0.12946978f, -0.07266387f, 
    -0.15273812f, 0.03080222f, 0.02923336f, 0.17534178f, -0.01446472f, 0.26275712f, 0.01696550f, 0.02488591f, 
    -0.08811338f, 0.11161353f, 0.09555591f, 0.14268790f, -0.28337175f, 0.20427734f, 0.32919595f, 0.15842293f, 
    0.08611466f, 0.28877226f, -0.06286918f, -0.02295706f, -0.04024115f, 0.00463487f, -0.21294625f, 0.05785650f, 
    0.06568743f, -0.16464464f, -0.14466052f, -0.04774516f, -0.10678481f, -0.07087731f, -0.21574363f, 0.09517978f, 
    0.18811087f, -0.13652541f, 0.01022475f, -0.18589176f, 0.21767740f, -0.07842250f, 0.21530427f, 0.16082174f, 
    0.24748406f, 0.01410382f, 0.02240855f, 0.00210234f, -0.11802469f, -0.07525380f, 0.01812910f, 0.07954186f, 
    0.01308553f, 0.03663152f, -0.21314780f, -0.04981944f, -0.05865027f, 0.04638065f, -0.00114580f, 0.02673491f, 
    -0.00204064f, -0.18221633f, -0.17936602f, -0.13729587f, 0.01987923f, 0.03585730f, -0.07978061f, 0.05862521f, 
    0.02582192f, 0.16492356f, -0.02126473f, -0.31922445f, -0.04963925f, -0.06868137f, -0.14633028f, -0.07567964f, 
    -0.07023818f, 0.10276113f, -0.09059536f, -0.02640380f, 0.12923595f, -0.32445276f, -0.02769344f, 0.05590492f, 
    0.21668513f, 0.05826085f, -0.19604491f, 0.01425282f, 0.22849824f, 0.15581924f, 0.03674659f, 0.22574487f, 
    -0.02334379f, -0.35657182f, -0.11640397f, -0.18999107f, 0.03159943f, -0.11834206f, -0.00849038f, 0.21330424f, 
    0.13658822f, 0.01129270f, 0.11425597f, 0.18559566f, 0.05548003f, 0.04556521f, -0.05546510f, -0.01305044f, 
    0.00393440f, -0.22776277f, -0.00451189f, 0.00282112f, 0.10415406f, 0.07341529f, 0.05322866f, -0.33055037f, 
    -0.39017519f, 0.01337663f, -0.03495545f, 0.12513733f, 0.10865825f, -0.14198984f, -0.17709258f, -0.06307302f, 
    -0.05213457f, -0.06239874f, -0.06832416f, -0.06769207f, 0.03290591f, -0.07586382f, 0.05609639f, -0.02885732f, 
    -0.08348500f, -0.07255464f, 0.01022946f, -0.07318783f, 0.05974522f, 0.00370908f, -0.03971470f, -0.03800520f, 
    -0.06710569f, 0.02044266f, 0.07388769f, -0.00019306f, 0.06340848f, -0.07472783f, 0.06246928f, 0.03944407f, 
    0.06947193f, 0.06252693f, -0.08727606f, 0.02601153f, 0.01122561f, -0.06741954f, 0.00457137f, 0.00500977f, 
    0.03280048f, -0.04645168f, -0.07521641f, -0.04029839f, -0.00191927f, 0.04858118f, -0.08118942f, 0.01604380f, 
    -0.02695457f, 0.00218558f, -0.07294125f, 0.00167237f, -0.03468718f, 0.01501729f, -0.03815874f, -0.03765328f, 
    -0.06525883f, -0.00835162f, -0.01463248f, -0.03817594f, -0.04686682f, 0.05423619f, -0.00775356f, 0.05304627f, 
    -0.02899930f, -0.05066255f, -0.00406388f, -0.02201638f, -0.04664429f, -0.04618542f, 0.04755658f, 0.01611560f, 
    -0.03776496f, -0.06641594f, 0.07315661f, 0.06338939f, -0.00927725f, -0.05293348f, 0.06719112f, -0.00594991f, 
    0.01632643f, -0.00393519f, -0.07467160f, -0.02305275f, 0.03290029f, 0.04192980f, 0.01584016f, 0.01319531f, 
    -0.01955298f, -0.00356753f, 0.03102161f, -0.00322444f, 0.07497867f, -0.05631184f, -0.04928647f, 0.02418951f, 
    -0.08825178f, -0.05177245f, 0.00701837f, 0.00695681f, -0.06815085f, 0.07025773f, -0.01210368f, -0.08600071f, 
    -0.00423130f, 0.00193835f, -0.03666656f, 0.03949235f, 0.03759558f, -0.07732676f, -0.02753605f, -0.01647543f, 
    -0.07818519f, 0.02425925f, 0.02516708f, -0.03310004f, 0.00009936f, -0.05518136f, -0.00325067f, -0.01791022f, 
    -0.00375262f, -0.00151354f, 0.06731725f, 0.01038570f, -0.01989673f, 0.00318018f, -0.00062224f, 0.05150167f, 
    -0.00716864f, 0.00181802f, -0.00433225f, 0.06183414f, -0.05652735f, 0.00621538f, 0.04743147f, -0.02454705f, 
    -0.06823473f, -0.04224215f, -0.06843911f, -0.00662938f, 0.02065841f, -0.04440530f, -0.07839719f, -0.04069589f, 
    0.04782214f, 0.05725537f, -0.04414398f, 0.00225242f, -0.06585701f, 0.06894309f, 0.05191548f, -0.06134478f, 
    -0.16016178f, -0.17740065f, 0.27767625f, -0.03625968f, -0.05262167f, 0.12753591f, -0.20979150f, -0.08661131f, 
    0.19912219f, -0.07142444f, 0.22029382f, -0.12035776f, 0.06443230f, -0.02075752f, 0.10279522f, 0.27884784f, 
    0.01869655f, 0.04365320f, -0.06930648f, -0.18905255f, -0.12359883f, 0.00980625f, 0.08617587f, 0.10563020f, 
    0.17826451f, -0.07414349f, -0.29612976f, -0.07176405f, 0.32512087f, -0.04844451f, -0.02467352f, -0.19244747f, 
    -0.05690834f, -0.09515794f, 0.01332304f, 0.08254950f, -0.44648769f, 0.22913745f, -0.22317086f, 0.21637054f, 
    -0.18826194f, 0.05352755f, 0.05909337f, 0.07402163f, 0.12572467f, -0.08184125f, 0.04091454f, -0.49358991f, 
    -0.02968737f, -0.20449142f, -0.16003406f, 0.09197097f, 0.18207651f, 0.00890199f, -0.09036776f, 0.03271026f, 
    -0.12984423f, 0.07419366f, 0.01169340f, 0.16344558f, 0.20602076f, -0.07761268f, -0.25909525f, -0.05731800f, 
    0.04893098f, 0.07724437f, -0.12516183f, -0.10688803f, -0.10689104f, 0.13024043f, -0.02140069f, 0.06549456f, 
    0.20313795f, 0.01847105f, 0.06892014f, -0.00139478f, -0.02333825f, 0.12087709f, -0.00768784f, 0.04041776f, 
    0.07136044f, 0.13513023f, 0.11377361f, 0.19313315f, -0.13424622f, 0.08473372f, 0.17425001f, -0.10540118f, 
    0.10237262f, -0.06876744f, -0.09585110f, -0.20836341f, 0.46702990f, 0.34672520f, 0.09893341f, -0.12039290f, 
    -0.01859603f, 0.15175518f, -0.07436192f, -0.04253606f, 0.13806659f, 0.27737704f, -0.25817996f, 0.12849212f, 
    0.02662777f, 0.02606645f, 0.08607550f, 0.12638114f, -0.08889017f, -0.17124899f, -0.14953345f, -0.06534266f, 
    -0.09699059f, -0.06185444f, -0.19702129f, -0.14083369f, -0.20245385f, -0.05051585f, -0.13553774f, 0.46951747f, 
    0.15980706f, -0.10383516f, -0.07278619f, -0.08563926f, 0.03254434f, 0.10524277f, 0.42695037f, 0.06905571f, 
    -0.25003499f, 0.13422932f, -0.10475830f, -0.12744574f, -0.04663089f, -0.08253913f, -0.01803737f, -0.01853601f, 
    0.06723197f, 0.10435727f, -0.08782061f, 0.11100463f, -0.22026201f, -0.01978531f, 0.04288011f, -0.32065609f, 
    0.15141089f, 0.11940910f, -0.03665165f, -0.20738763f, -0.17434826f, 0.30756578f, -0.02256524f, 0.10545653f, 
    0.00244398f, 0.13527676f, 0.07243263f, -0.19659884f, -0.07301520f, 0.07839356f, 0.12680484f, 0.04399713f, 
    -0.05470784f, -0.03854717f, -0.18000779f, -0.08808480f, -0.09788990f, 0.03401184f, 0.12828515f, 0.07009389f, 
    0.08553419f, -0.02471699f, -0.36129683f, 0.03986128f, 0.27345720f, 0.33045036f, 0.11476070f, 0.28323540f, 
    -0.08042630f, 0.05876319f, 0.13456967f, 0.11806504f, -0.49713215f, -0.07486778f, 0.24186300f, 0.03809932f, 
    -0.02841614f, 0.05065447f, 0.02120248f, 0.07093927f, 0.10792209f, 0.25365424f, 0.17903672f, 0.12650062f, 
    0.11602207f, 0.07979235f, -0.19255060f, -0.13431785f, 0.23933861f, 0.11719006f, -0.14636374f, -0.03773009f, 
    -0.19249690f, 0.12530100f, 0.22664703f, 0.17959517f, 0.11749173f, 0.00387574f, -0.05080086f, -0.08625540f, 
    0.10606004f, -0.02943967f, -0.13739407f, 0.05126295f, -0.12922201f, 0.11082474f, -0.08474398f, 0.05750078f, 
    0.06406878f, -0.04881161f, -0.00433496f, -0.31960389f, -0.19482838f, -0.11466458f, 0.03550093f, 0.08502580f, 
    0.31605431f, 0.20264320f, -0.08693677f, -0.04642351f, 0.22990209f, 0.06358247f, 0.03572065f, 0.04529592f, 
    0.06759299f, 0.03751194f, 0.13607165f, 0.11524120f, 0.02977586f, -0.10587602f, -0.01618263f, -0.04570953f, 
    0.01241039f, 0.03440923f, 0.15260783f, -0.00487664f, 0.16816914f, 0.16633280f, -0.21739998f, 0.26570475f, 
    -0.07577308f, -0.02288658f, -0.03037000f, -0.00471825f, -0.26137289f, -0.21697330f, -0.23460928f, 0.03135599f, 
    0.05106739f, -0.10810401f, -0.15776427f, 0.31460524f, -0.04952476f, -0.24370189f, -0.10064842f, 0.03162240f, 
    -0.12903428f, -0.13526653f, 0.13761042f, 0.04764151f, -0.16918384f, 0.31073555f, -0.89959657f, -0.37552223f, 
    -0.08137506f, 0.21914153f, -0.04170500f, 0.10993813f, 0.04514695f, -0.04637244f, -0.02657918f, -0.32371935f, 
    -0.33428806f, -0.23945570f, 0.20973904f, 0.16904031f, -0.04532992f, -0.01970152f, -0.17012908f, -0.16821142f, 
    0.28961602f, 0.45990613f, 0.26782966f, 0.06705234f, 0.02503404f, -0.04908240f, 0.00007229f, 0.15823078f, 
    -0.14964619f, 0.01134508f, -0.20674527f, -0.31515616f, 0.04150296f, 0.14102376f, 0.06478015f, 0.22051121f, 
    -0.03942641f, -0.02409371f, -0.18817264f, -0.14938955f, -0.36771435f, 0.13682339f, -0.23128921f, -0.11937706f, 
    -0.05368962f, -0.17832355f, -0.04269908f, -0.27763835f, -0.07965662f, 0.21195997f, 0.03602693f, 0.07645893f, 
    -0.10209020f, -0.16704035f, -0.07198168f, 0.03392348f, -0.24543485f, -0.19033954f, -0.05579947f, 0.13462779f, 
    0.00025490f, 0.06266861f, -0.05492333f, 0.28046644f, 0.06227986f, -0.25461364f, -0.07164391f, -0.13170554f, 
    -0.11862040f, 0.09481290f, -0.03555160f, 0.10812087f, -0.10332359f, 0.04854919f, 0.11792060f, 0.33615339f, 
    0.12839094f, -0.10514493f, -0.11740914f, -0.16468742f, -0.00991937f, -0.00052384f, 0.07964617f, -0.33902511f, 
    -0.45011842f, -0.09807705f, -0.03128032f, 0.20076118f, 0.01321019f, -0.18442081f, -0.14373282f, 0.06829749f, 
    -0.19039938f, -0.14668208f, -0.16435501f, -0.06561380f, -0.03748394f, 0.09684215f, -0.03923870f, 0.14096051f, 
    0.01524415f, -0.12570243f, 0.17361349f, 0.37485823f, -0.03653288f, 0.00333257f, -0.03456667f, 0.08954275f, 
    -0.05665300f, 0.14307070f, 0.16636808f, 0.28121832f, 0.13134016f, 0.02935291f, -0.04942918f, 0.03116744f, 
    0.03031255f, 0.30135730f, -0.01525642f, 0.17617111f, -0.20563833f, 0.02806226f, -0.06318323f, 0.03952875f, 
    -0.03714023f, -0.07658327f, 0.11282463f, 0.10558984f, 0.10142537f, 0.01113732f, -0.00424919f, 0.15036404f, 
    -0.22018458f, 0.36653769f, -0.10835736f, -0.11176401f, -0.03085568f, 0.13278134f, 0.36261150f, 0.45303807f, 
    0.18720886f, -0.08137045f, 0.01151588f, 0.02149734f, 0.01645208f, 0.08612449f, -0.02263816f, -0.24180165f, 
    0.28200054f, 0.05368517f, -0.17292890f, 0.09781381f, 0.18659596f, -0.13791999f, 0.00698655f, -0.08826728f, 
    -0.12078921f, -0.05499993f, -0.12399519f, -0.12671652f, -0.05624430f, -0.03959177f, -0.03300246f, 0.09393448f, 
    0.03052010f, -0.08862403f, -0.09181012f, -0.08500685f, 0.00555366f, 0.03062473f, -0.10513179f, -0.06546959f, 
    0.01460731f, -0.00162138f, -0.09070870f, -0.02551766f, 0.03813073f, -0.07168491f, -0.09387124f, 0.01624878f, 
    0.01406745f, -0.01670798f, 0.03084809f, 0.03448980f, -0.05811010f, -0.00270905f, 0.04360408f, -0.09045509f, 
    -0.03998161f, -0.05186468f, -0.06108952f, -0.07980717f, -0.01364950f, -0.04166356f, 0.01990856f, -0.03358863f, 
    0.03607696f, 0.01710041f, -0.06712407f, -0.06271169f, -0.09918383f, 0.00090849f, -0.00843924f, 0.03698654f, 
    -0.06261732f, 0.00624114f, -0.07001051f, -0.10823166f, -0.06720308f, -0.07626738f, 0.01901172f, -0.01157550f, 
    -0.11285809f, -0.09378029f, -0.07620315f, -0.04999200f, 0.01763242f, 0.05194766f, -0.09226704f, -0.10213891f, 
    -0.09339032f, 0.00211958f, -0.07213233f, -0.02331715f, -0.06768721f, 0.00386919f, -0.07180917f, 0.01197029f, 
    -0.09136171f, -0.02122026f, 0.00968434f, 0.02078818f, -0.10327779f, 0.05384601f, -0.01587803f, -0.10716799f, 
    0.03572591f, -0.04756597f, -0.00984062f, -0.10548459f, -0.04785523f, 0.02869639f, 0.02862925f, -0.08002616f, 
    -0.11771148f, -0.04040623f, 0.01098256f, -0.10551138f, -0.00336029f, -0.00422872f, -0.06544553f, 0.03803261f, 
    -0.07165439f, -0.00369610f, -0.05449108f, -0.00846929f, -0.09444358f, 0.03226363f, 0.04658293f, 0.02188219f, 
    -0.00492076f, -0.01975530f, -0.04407547f, -0.08394617f, -0.00857081f, -0.02502005f, -0.07477500f, -0.08821596f, 
    0.03479958f, -0.06635717f, -0.05431882f, -0.07666908f, 0.03028967f, -0.02977259f, -0.07923930f, 0.03835265f, 
    -0.09039646f, -0.07192829f, -0.05414155f, 0.03211074f, 0.03057197f, 0.04004878f, -0.03185269f, -0.01708951f, 
    -0.09404772f, -0.01707963f, -0.09391131f, -0.09358326f, -0.08750568f, -0.04941299f, -0.07633176f, -0.00672597f, 
    0.00757113f, -0.06233388f, -0.10320114f, 0.02292631f, -0.01445784f, 0.01394335f, 0.05555173f, -0.06876919f, 
    -0.06827834f, -0.07400578f, 0.01206879f, -0.07285108f, -0.07270330f, -0.05674544f, -0.04423824f, -0.01146870f, 
    -0.33612758f, 0.01824943f, -0.37809673f, -0.14538708f, 0.17893656f, -0.21234366f, -0.28121421f, -0.01239124f, 
    -0.23838976f, -0.48145685f, -0.07441919f, -0.11871894f, 0.08086377f, 0.06304626f, 0.12532380f, -0.04850092f, 
    0.02983394f, -0.00962304f, -0.09976302f, 0.26743102f, -0.18180203f, 0.19683033f, -0.24722330f, 0.00726787f, 
    -0.03946462f, 0.01620833f, 0.01113940f, -0.02197829f, -0.02696578f, -0.17865372f, 0.14483526f, 0.24262328f, 
    0.02775734f, -0.13002631f, 0.06471469f, -0.12571502f, -0.02261436f, 0.15802683f, 0.07395503f, -0.09914050f, 
    -0.06364300f, -0.03263916f, 0.17812645f, 0.12813269f, -0.04256492f, -0.14519458f, -0.33206442f, 0.00249536f, 
    0.15423156f, 0.03727839f, 0.14099281f, 0.00161835f, 0.03889040f, 0.10982523f, 0.05561128f, 0.37236539f, 
    -0.00966990f, 0.01402412f, -0.04684608f, -0.12825142f, -0.08396524f, 0.14192778f, -0.04454724f, -0.12314977f, 
    -0.24519797f, -0.36532253f, 0.46586570f, -0.01110979f, 0.21686454f, 0.02708155f, 0.02623370f, -0.01083784f, 
    -0.28134733f, -0.39348304f, -0.05966051f, -0.05940969f, 0.13630936f, 0.29428872f, -0.09108894f, 0.06910713f, 
    0.13209777f, 0.10377167f, 0.17254981f, 0.14427990f, 0.10988425f, -0.23100878f, 0.19699480f, -0.07435941f, 
    -0.00954690f, -0.09369914f, -0.01602731f, 0.43876600f, -0.30178824f, 0.16375409f, -0.26097968f, 0.23860276f, 
    0.20819414f, -0.01670196f, 0.08580074f, 0.17462574f, 0.14831513f, -0.05520964f, -0.10203768f, -0.26612589f, 
    0.24102256f, -0.04861724f, 0.09089429f, -0.04175483f, 0.48463842f, -0.24563441f, -0.13582090f, 0.09443947f, 
    -0.15182595f, -0.26636815f, 0.01461171f, 0.15151289f, -0.10254804f, 0.27051622f, 0.25992358f, 0.05111227f, 
    -0.01701033f, -0.06789847f, 0.03214033f, 0.13893780f, -0.02316443f, -0.10565524f, 0.39924106f, -0.01953996f, 
    0.09600728f, 0.04361517f, -0.05031349f, -0.17178364f, -0.05251830f, -0.02079931f, 0.05177014f, 0.07231833f, 
    -0.04985499f, 0.02147844f, 0.11007486f, -0.23493752f, 0.15354255f, 0.35284719f, -0.02035143f, 0.07330836f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.21979873f, -0.15228610f, -0.08963386f, 0.08863030f, 0.11723010f, -0.08771851f, 0.18367103f, 0.00741197f, 
    0.04481715f, 0.15020272f, -0.03586930f, 0.09761439f, 0.18181925f, 0.06399475f, 0.02534101f, 0.26149675f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.33597344f, -0.23575597f, 0.17406078f, -0.48707607f, 0.37307221f, 0.12376100f, 0.32069653f, 0.17428231f, 
    -0.56699318f, 0.19605242f, 0.05830278f, 0.25872758f, 0.07644376f, -0.51978892f, -0.10095358f, 0.38838312f, 
    0.02666584f, 0.32498634f, -0.07972284f, 0.29225117f, 0.17618610f, -0.04876975f, -0.24352188f, 0.06481299f, 
    -0.04516564f, -0.24212629f, -0.13490477f, -0.07969282f, -0.18151203f, -0.29084945f, -0.01193038f, -0.12881608f, 
    -0.44998652f, 0.03802002f, -0.52128071f, 0.32198119f, -0.34375072f, 0.36784714f, 0.07058506f, -0.07043183f, 
    0.28483507f, 0.36134267f, -0.10508770f, -0.18184467f, -0.16798547f, 0.55947781f, 0.03052190f, 0.10061351f, 
    -0.43241096f, 0.61455327f, -0.00578979f, 0.17414416f, 0.36206472f, 0.11846466f, -0.17402039f, 0.04627331f, 
    0.05740563f, -0.16179359f, -0.18257771f, -0.13643576f, 0.06142558f, -0.01693281f, -0.01815465f, 0.18966074f, 
    -0.15918195f, -0.19254206f, 0.14537695f, -0.03806308f, -0.20683736f, 0.06672259f, 0.14515209f, -0.16545060f, 
    -0.18782806f, -0.02117643f, -0.19746181f, 0.05056840f, -0.23154216f, -0.13527194f, -0.03494802f, -0.02322942f, 
    0.17800438f, 0.51766521f, 0.29256022f, -0.04115219f, 0.32042584f, -0.10843768f, -0.13189526f, 0.15222716f, 
    0.20539185f, 0.08926424f, 0.01248169f, -0.24304101f, -0.00912044f, -0.53110003f, 0.02384520f, -0.15097743f, 
    0.06666493f, 0.22058056f, 0.59886134f, -0.44107324f, 0.10648585f, -0.24473244f, -0.01896224f, -0.22392285f, 
    -0.17876948f, 0.25001800f, 0.04585201f, 0.20894882f, 0.56335688f, 0.13867305f, -0.11797179f, -0.06498365f, 
    0.08103178f, 0.49249661f, 0.13898493f, 0.01551507f, 0.04854813f, 0.03820762f, -0.17447351f, -0.25638422f, 
    -0.12821221f, 0.42393339f, 0.24113865f, -0.14124157f, 0.30111188f, -0.35685068f, 0.22325200f, -0.17871192f, 
    -0.18275547f, -0.03411982f, 0.15668626f, -0.14817724f, -0.27592328f, -0.25865665f, -0.09928374f, 0.22493052f, 
    0.59915453f, 0.34232336f, -0.16931459f, 0.24319942f, -0.23342761f, 0.34604895f, -0.07142708f, 0.12716748f, 
    -0.06269619f, -0.39849159f, 0.02297891f, 0.36160114f, 0.08654202f, 0.09736175f, 0.28360945f, -0.11125316f, 
    -0.46495339f, 0.22798406f, 0.12082146f, -0.57168955f, -0.05096536f, 0.22252348f, 0.02433054f, 0.18343270f, 
    0.09631181f, -0.43716884f, 0.33005273f, 0.03590444f, 0.18694003f, 0.47835785f, 0.13486460f, -0.17468379f, 
    -0.03246558f, -0.15902479f, -0.10114422f, 0.28210950f, 0.13598615f, -0.44201478f, 0.25495452f, -0.27548930f, 
    -0.31966951f, 0.69937134f, 0.40212318f, -0.20038053f, -0.11866449f, -0.02712131f, -0.30123499f, -0.06978355f, 
    0.01961464f, -0.07208755f, 0.02677402f, 0.22034791f, -0.07785833f, 0.70305634f, -0.19132710f, -0.13387732f, 
    0.07024786f, 0.62107480f, -0.08090778f, -0.02582042f, 0.02557783f, -0.00225927f, 0.36237338f, -0.15003206f, 
    -0.67352557f, 0.09842805f, -0.05655733f, -0.25711846f, -0.07928856f, -0.16668732f, 0.02348890f, 0.20342918f, 
    0.32495800f, -0.04236909f, -0.39241022f, -0.27382320f, -0.01041145f, 0.32600218f, 0.41076139f, 0.04922509f, 
    -0.05799272f, -0.34957018f, -0.22908559f, 0.19543740f, 0.10604569f, 0.12524632f, 0.15032288f, 0.60370338f, 
    -0.09996777f, 0.28597736f, 0.10201713f, 0.17979233f, -0.04117031f, -0.13093132f, 0.38906404f, -0.04467211f, 
    -0.52601588f, 0.51349634f, 0.17023312f, -0.41165978f, -0.08142038f, -0.01858814f, -0.20932811f, 0.23816830f, 
    -0.01230630f, -0.15350711f, 0.04896696f, 0.10257911f, 0.01251207f, 0.00295319f, -0.11127970f, 0.07380027f, 
    -0.23457298f, -0.20700543f, 0.07285029f, 0.12859751f, -0.28017119f, 0.01313498f, 0.17573728f, -0.19003066f, 
    -0.06291901f, -0.11441656f, 0.03322567f, 0.17649692f, 0.07280722f, -0.36113974f, 0.57098222f, 0.15446740f, 
    -0.12083118f, -0.08257768f, 0.11937499f, 0.52275950f, 0.33184725f, -0.70841432f, -0.06890823f, 0.32661617f, 
    -0.26874200f, 0.09673124f, -0.20338620f, -0.21563645f, 0.39051649f, -0.10964709f, -0.37953621f, -0.14216691f, 
    0.35986060f, 0.28320777f, 0.23232168f, 0.08120375f, 0.40793648f, 0.36474165f, 0.07285914f, -0.31071064f, 
    0.16519016f, 0.82129014f, -0.10264493f, -0.48424941f, 0.26783884f, 0.43149191f, -0.41689640f, -0.05169457f, 
    0.69937491f, -0.25862736f, -0.01291291f, 0.55117047f, -0.26687393f, -0.69833416f, -0.23667708f, 0.19456042f, 
    -0.15882283f, 0.48799589f, -0.24747398f, -0.17546540f, -0.30315134f, 0.48308542f, -0.14041008f, 0.19501635f, 
    -0.28473827f, 0.47214437f, -0.10311030f, 0.51733917f, 0.57468098f, 0.12389692f, 0.08361923f, -0.10278374f, 
    0.19523348f, 0.19699281f, 0.51712686f, 0.20418511f, -0.39996737f, -0.14500692f, -0.07873205f, -0.12564960f, 
    -0.58169019f, 0.18519077f, -0.12298107f, -0.26101279f, -0.20009893f, 0.08169607f, 0.22435212f, -0.15957348f, 
    0.26101846f, 0.49617681f, -0.35779735f, 0.46665075f, -0.05455748f, -0.19702049f, 0.20741995f, 0.20831849f, 
    -0.06822811f, 0.00863885f, -0.14167240f, -0.30607358f, -0.45744771f, 0.22866982f, -0.09845925f, 0.56339675f, 
    -0.00367117f, 0.19925681f, -0.53351963f, -0.17172550f, 0.49344885f, 0.37041822f, -0.25076139f, -0.17460200f, 
    0.41325805f, -0.30707183f, 0.17294736f, -0.32137203f, -0.03342740f, 0.34488353f, -0.12903686f, 0.46090090f, 
    0.15371667f, -0.04974806f, 0.09754485f, 0.01795403f, 0.12951806f, -0.22224103f, -0.08289035f, 0.15643615f, 
    0.33013016f, -0.30136493f, 0.02277625f, -0.20255141f, -0.31458393f, -0.38407195f, 0.08922327f, -0.04754611f, 
    0.53504431f, 0.17420900f, -0.49114460f, 0.37988055f, -0.03003677f, 0.11354408f, 0.36466253f, -0.15283847f, 
    -0.47956479f, -0.00616654f, -0.19498888f, 0.11321891f, -0.26487923f, -0.66062248f, -0.15552083f, 0.11180636f, 
    0.44707379f, -0.28737774f, 0.11105124f, 0.25942683f, -0.06573350f, -0.36853674f, 0.61339378f, 0.05395055f, 
    0.43282947f, -0.28882238f, 0.15801620f, 0.14832984f, -0.48493794f, -0.24578828f, 0.04608652f, 0.03564638f, 
    0.07657876f, 0.29343775f, 0.03897544f, 0.01684461f, 0.17035757f, 0.47074509f, 0.22838275f, -0.14955601f, 
    0.48626956f, -0.35055369f, 0.16405684f, 0.21961164f, -0.24822415f, -0.27037910f, 0.19025812f, -0.06995784f, 
    0.33137849f, -0.21335445f, 0.51343042f, 0.54615283f, -0.35471395f, 0.10141459f, 0.10189329f, -0.18181476f, 
    0.18721314f, 0.14553726f, 0.24167855f, 0.62834764f, -0.01669119f, -0.50198388f, 0.05128748f, -0.48172301f, 
    0.27645025f, 0.04922120f, 0.66750485f, 0.01085301f, 0.21629240f, -0.33887783f, -0.23431423f, -0.15414460f, 
    0.27451190f, 0.47388342f, -0.22406134f, -0.23902012f, -0.30846411f, 0.22983800f, 0.01402673f, 0.41833177f, 
    0.27487206f, -0.24890788f, 0.56755221f, -0.34824440f, 0.20647094f, -0.09233259f, 0.32614341f, 0.03081927f, 
    -0.08316941f, 0.18332405f, 0.09752226f, -0.30084440f, 0.15715158f, 0.12194174f, -0.13257825f, -0.06371641f, 
    -0.24421936f, -0.12653466f, 0.03186153f, 0.03815772f, 0.00239632f, 0.00026231f, -0.15678018f, -0.24742594f, 
    -0.20694241f, 0.01601392f, -0.10639662f, -0.06132984f, -0.01846248f, -0.15636581f, -0.15185767f, 0.07117289f, 
    0.04066526f, 0.10833653f, 0.29465345f, -0.26597050f, -0.24812689f, -0.16464229f, 0.14153734f, -0.17207250f, 
    0.10271600f, -0.18216646f, 0.06262249f, 0.23794462f, -0.18610591f, 0.26957193f, 0.09620531f, -0.10802741f, 
    -0.08767949f, -0.20232163f, 0.42484641f, 0.00877049f, -0.25379285f, -0.42708436f, -0.10098848f, -0.08748624f, 
    0.34140033f, 0.24374853f, -0.20666605f, 0.43366802f, 0.50103307f, 0.37281349f, 0.11843028f, 0.16453324f, 
    0.07311071f, -0.67753625f, 0.22226787f, -0.17030737f, 0.66484147f, 0.06506791f, 0.11483503f, -0.20132369f, 
    -0.29465005f, 0.04863782f, 0.23045236f, -0.13621055f, 0.15297459f, -0.09420332f, -0.06961726f, 0.35966462f, 
    -0.16514754f, -0.01577962f, 0.11740024f, 0.42258391f, 0.54520917f, 0.08574678f, -0.02597343f, -0.00172264f, 
    0.29209986f, -0.24884018f, -0.19340518f, -0.43409050f, -0.31615347f, 0.12745504f, -0.24329364f, 0.49693888f, 
    0.21261673f, 0.41370344f, 0.31728157f, 0.60790497f, -0.20941383f, -0.00567995f, 0.05411433f, -0.23924524f, 
    0.28333625f, 0.12084424f, -0.03624171f, -0.10868376f, -0.40991834f, 0.09009927f, 0.15694506f, -0.09932534f, 
    0.33926845f, 0.09143928f, -0.38825503f, 0.04004472f, 0.24694447f, 0.20781648f, 0.36989853f, 0.03462400f, 
    -0.35412160f, -0.43058318f, 0.15938485f, -0.04944550f, 0.09953175f, -0.12119216f, 0.21583240f, 0.34379172f, 
    0.30658099f, -0.31073952f, -0.06999350f, 0.00462528f, 0.25450915f, -0.29794276f, 0.33752158f, -0.20590821f, 
    0.24627300f, -0.54691184f, -0.06376701f, 0.27920911f, 0.15021020f, 0.29833287f, 0.08493293f, 0.27161038f, 
    0.02135883f, 0.43453568f, -0.16195752f, 0.14173986f, -0.31362727f, 0.34785974f, -0.30170739f, 0.03226635f, 
    0.55043876f, 0.19196741f, -0.00822204f, 0.73010403f, 0.04258784f, -0.46279913f, -0.06056024f, -0.34238496f, 
    -0.50569838f, 0.12828566f, -0.18731526f, 0.21095593f, -0.42344490f, 0.44776511f, 0.15131998f, 0.05255972f, 
    -0.18742096f, 0.44187602f, -0.14789180f, 0.09416474f, 0.30763486f, 0.40086535f, 0.18378925f, -0.14049271f, 
    -0.32739046f, 0.44204509f, 0.34981689f, -0.18298392f, -0.31345263f, 0.05850700f, -0.39403078f, -0.11832994f, 
    0.08833973f, -0.03459652f, -0.03841600f, 0.09644312f, -0.07883763f, 0.53900361f, -0.19244397f, 0.11881825f, 
    0.00544172f, -0.31027478f, 0.06060275f, -0.47255665f, 0.35476163f, 0.36029243f, -0.56398398f, -0.05915804f, 
    0.47502843f, 0.51097578f, 0.04129790f, 0.02132630f, 0.48844945f, 0.44366831f, -0.17070194f, -0.31925064f, 
    -0.49993595f, -0.29569739f, 0.22275186f, -0.21540762f, 0.52187461f, 0.42100337f, 0.04207458f, -0.08723189f, 
    0.33873123f, 0.34125543f, 0.12911665f, -0.20236437f, 0.16364773f, 0.39146924f, 0.19957605f, 0.41199532f, 
    0.08337067f, 0.06801923f, 0.68651438f, -0.29160517f, 0.48459369f, -0.09886617f, 0.01221808f, 0.10987392f, 
    -0.32087538f, 0.25548363f, -0.02129900f, 0.25108966f, 0.29209897f, -0.33092234f, -0.06862313f, 0.19043557f, 
    0.40148669f, -0.10225382f, 0.20444274f, 0.14564939f, -0.12780641f, -0.03951045f, -0.42418870f, 0.23463450f, 
    0.10415751f, -0.28530875f, -0.20562479f, 0.02362235f, -0.23229679f, 0.29604754f, -0.03662336f, 0.33837885f, 
    -0.16939273f, 0.02714185f, 0.46367535f, 0.53709298f, -0.12080444f, -0.27868649f, -0.13194345f, -0.01782513f, 
    0.56722176f, 0.27899140f, 0.16880608f, 0.51022893f, -0.27974972f, -0.13614966f, -0.01161385f, 0.01164753f, 
    0.22765103f, -0.09646084f, 0.27382132f, 0.40602362f, -0.16901688f, -0.18959875f, 0.26015726f, -0.20198327f, 
    -0.43260685f, 0.43786141f, 0.24288890f, -0.20981720f, -0.29721457f, 0.22496873f, -0.09672913f, -0.00796911f, 
    0.17772938f, -0.12824760f, 0.07827868f, -0.21433571f, -0.29135102f, 0.16689715f, 0.35236627f, 0.08490172f, 
    -0.02942008f, 0.47747421f, -0.10070035f, 0.61465853f, 0.38450655f, -0.39317569f, -0.16556671f, -0.40595609f, 
    0.12318051f, -0.12948260f, -0.24633342f, 0.05519691f, -0.05676597f, -0.11453161f, -0.05032223f, -0.13449758f, 
    0.00471193f, -0.09513307f, 0.13692513f, -0.20272157f, -0.20815259f, -0.24214202f, 0.01804227f, -0.16013792f, 
    -0.11965076f, 0.28290051f, -0.61118490f, 0.14376737f, 0.00235512f, 0.29978985f, 0.17782035f, 0.02133636f, 
    0.08831158f, -0.52931803f, -0.07761958f, 0.21734717f, 0.02642478f, 0.23141010f, 0.22859620f, 0.36302617f, 
    0.11119674f, -0.53533751f, -0.87395698f, 0.20957732f, -0.26108763f, 0.30345204f, 0.09350249f, -0.15746802f, 
    0.12122086f, 0.17419273f, 0.17830926f, 0.53910935f, -0.33437619f, -0.32585114f, 0.22977157f, 0.46551323f, 
    0.44701418f, 0.06368649f, 0.14381875f, 0.46517071f, 0.04989111f, -0.30515251f, -0.21403134f, 0.01614829f, 
    0.30462748f, -0.31563354f, 0.20345730f, 0.19841534f, -0.34782228f, 0.10518450f, 0.11728717f, 0.13396612f, 
    -0.16543478f, -0.14990023f, -0.04661232f, -0.03267702f, -0.20991024f, -0.24103898f, 0.18069246f, 0.18404219f, 
    -0.14466691f, -0.01668283f, -0.21939388f, -0.19076687f, -0.15141845f, 0.01492324f, 0.11167002f, -0.24432108f, 
    0.10607605f, -0.48425689f, 0.46843347f, 0.11386947f, -0.12473493f, -0.00771828f, -0.17317508f, 0.09283007f, 
    0.34789288f, 0.35796189f, 0.17326021f, -0.20708792f, -0.01837173f, 0.66455626f, 0.08593466f, 0.25835308f, 
    -0.16231674f, -0.09601209f, -0.11324410f, -0.12087899f, 0.03837823f, 0.16642654f, -0.02561987f, -0.06434086f, 
    0.28267121f, -0.15844060f, 0.15513346f, -0.03747493f, -0.18486357f, -0.02998408f, -0.14967641f, -0.10646451f, 
    -0.36885911f, 0.38064688f, 0.18781796f, 0.06442279f, -0.11855565f, -0.08102623f, 0.57709038f, 0.17437431f, 
    0.21084683f, 0.26439133f, 0.18687117f, -0.04262352f, -0.25512761f, 0.20964725f, 0.06047424f, 0.44276688f, 
    -0.02160445f, 0.64594638f, 0.15696903f, -0.27465969f, 0.05706352f, -0.31314704f, -0.23518474f, -0.22358698f, 
    0.74419022f, -0.17840101f, -0.06573467f, 0.31123799f, -0.02490665f, 0.13472652f, 0.03323278f, 0.10616244f, 
    0.12591927f, 0.26946387f, -0.08011924f, -0.21286844f, 0.07173260f, 0.08406324f, -0.17538300f, -0.19097264f, 
    -0.71143556f, 0.30013883f, -0.13268185f, 0.21664643f, 0.22132568f, 0.04480128f, -0.06405853f, 0.13069957f, 
    0.45025313f, -0.30262744f, -0.15936227f, 0.37710547f, -0.37062022f, 0.13500763f, 0.44647616f, -0.14396420f, 
    0.41068196f, 0.16095433f, 0.24354553f, 0.17464952f, -0.43868396f, -0.52842391f, 0.19304502f, -0.06035092f, 
    -0.06495829f, -0.45126870f, -0.24083324f, 0.63105553f, 0.09557495f, -0.01787278f, 0.19284999f, -0.22666354f, 
    0.53704172f, -0.43482322f, 0.03479348f, 0.20686175f, 0.22420560f, 0.41120803f, -0.09673420f, -0.23333420f, 
    -0.07744692f, -0.06442798f, -0.20669493f, -0.35365963f, 0.49904656f, 0.40160525f, 0.39323297f, 0.01596631f, 
    -0.03255191f, -0.38964108f, -0.16893128f, -0.21677072f, 0.38175920f, -0.08097275f, -0.14402150f, 0.30460158f, 
    0.30973300f, -0.12309929f, -0.17683853f, -0.17355737f, -0.13983914f, 0.18472596f, 0.27701965f, -0.00942388f, 
    -0.18294284f, -0.18633938f, -0.00820727f, 0.67552805f, 0.33125311f, -0.36867979f, -0.14282896f, -0.15302528f, 
    0.58475840f, -0.03541262f, 0.02668354f, 0.18537585f, -0.45436040f, -0.16632389f, 0.16668066f, -0.08735888f, 
    -0.46234331f, 0.03920358f, -0.19366299f, 0.51077950f, -0.18865177f, -0.20053171f, 0.19186488f, -0.05556834f, 
    -0.38118577f, -0.66394085f, 0.24765696f, 0.43081620f, 0.25395623f, -0.37666959f, -0.03052904f, 0.11901058f, 
    0.62079966f, 0.20289047f, -0.04282770f, 0.13380696f, 0.10779187f, 0.33671781f, -0.18566969f, 0.30268109f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.26680890f, 0.22387251f, 0.03889694f, 0.26828924f, -0.15097122f, -0.12163708f, 0.47151843f, 0.49582046f, 
    -0.04705482f, 0.29297104f, 0.16656078f, -0.23252605f, 0.17937362f, 0.21888433f, 0.24820627f, -0.22511201f, 
    0.72920644f, 0.04729778f, 0.14425132f, -0.20250410f, 0.38552991f, 0.10710714f, 0.09184686f, -0.19049710f, 
    0.45613772f, -0.20863762f, -0.24866213f, -0.17470291f, 0.25697351f, 0.24086155f, -0.18233618f, 0.01075397f, 
    0.05741954f, 0.68825138f, 0.39754111f, -0.35150006f, 0.26339608f, 0.25868630f, -0.08902337f, -0.00177929f, 
    0.12013563f, 0.10903976f, -0.20558213f, 0.48052937f, -0.00086567f, -0.03468223f, 0.07812729f, 0.35120702f, 
    0.10698852f, 0.24240151f, 0.46190181f, 0.42733997f, 0.07147402f, -0.01920280f, 0.14061040f, -0.23363310f, 
    -0.30214855f, 0.50815254f, -0.13364361f, 0.40818676f, -0.38343278f, 0.14525375f, 0.41479918f, 0.49317062f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.31669182f, -0.18751422f, 0.28817645f, 0.20828262f, -0.06767299f, -0.70578456f, -0.21355928f, 0.05020117f, 
    -0.84760535f, 0.17226388f, -0.05439065f, -0.79371971f, 0.12262815f, -0.20801580f, 0.15004040f, 0.05213874f, 
    0.20132308f, 0.15451175f, -1.32194734f, -0.04401031f, 0.23482971f, 0.07731796f, -0.18473423f, -0.19667193f, 
    0.05281866f, -0.03027852f, -0.08874152f, 0.17022847f, -0.34089196f, -0.47938928f, 0.06158933f, -0.25408766f, 
    0.00628701f, -0.28911507f, 0.06727298f, 0.15103087f, -0.03165470f, -0.07773452f, 0.11639141f, 0.37249908f, 
    -1.27858508f, -0.23307014f, -0.15948121f, -0.28503206f, -0.36882657f, 0.40530026f, 0.20777322f, 0.08128087f, 
    -0.03162712f, 0.11851155f, -0.22676824f, -0.04597107f, -0.04229629f, -0.04729718f, -0.11013795f, 0.26263776f, 
    -0.68793470f, -0.07166765f, -0.10616706f, 0.31419182f, -0.27792954f, 0.05861362f, 0.09118503f, 0.39157182f, 
    -0.09866422f, -0.06269833f, 0.22733179f, -0.10332172f, 0.04786526f, 0.17186539f, -0.24292479f, -0.21988550f, 
    0.47413227f, 0.32226193f, -0.05626022f, 0.51521534f, 0.00751484f, 0.03078088f, 0.11143185f, -0.00322704f, 
    0.48152167f, 0.07244387f, -1.07112634f, -0.41406652f, -0.37638628f, 0.24474350f, 0.13607968f, -0.29663810f, 
    0.14708246f, 0.22543257f, -0.12662488f, -0.24467473f, -0.01076512f, 0.04386859f, 0.00133458f, -0.04092937f, 
    -0.06487477f, 0.02151483f, 0.31753638f, 0.09711228f, 0.06423485f, 0.07662120f, -0.88905424f, -0.11417748f, 
    0.78485900f, -0.02852544f, 0.02931194f, -0.29203087f, -0.09737965f, -0.15487586f, 0.17202789f, -0.37553790f, 
    0.03723188f, -0.03750892f, 0.37688622f, 0.07988931f, 0.01955569f, 0.10906372f, -0.09677990f, 0.26050532f, 
    0.11746924f, -0.24179225f, 0.29113498f, 0.06911672f, -0.05374102f, -0.22167481f, -0.14583169f, 0.16857244f, 
    -0.16785741f, -0.27334285f, 0.42915493f, 0.07470839f, 0.02856179f, -0.22355799f, -0.91692841f, -0.16192907f, 
    -0.89496189f, 0.01767057f, 0.43038478f, -1.61336493f, -0.21914887f, 0.18607721f, -0.38541490f, 0.05089106f, 
    -0.80901396f, 0.19521998f, 0.48774680f, 0.31662008f, -0.65674806f, -0.00565866f, 0.34637037f, -0.14868481f, 
    0.01914158f, -0.36167708f, 0.37365368f, 0.06671586f, -0.99089760f, -0.60337150f, -0.06183563f, -0.11436155f, 
    -1.41063607f, -0.37471029f, 0.00754048f, -0.02076548f, 0.10273320f, -0.16823263f, 0.41506776f, 0.44841066f, 
    -1.35330403f, 0.40159011f, 0.35757115f, -0.71070409f, -0.11950624f, -0.93006963f, -0.39757156f, 0.02501442f, 
    -0.05183209f, 0.39746401f, 0.10774261f, -0.35655263f, -0.07047392f, -0.13381034f, 0.12388548f, -0.28058568f, 
    -0.34051001f, -0.16173306f, 0.09593965f, 0.09280406f, 0.35990825f, 0.18176469f, -0.37684301f, -0.66171867f, 
    0.25795409f, 0.18121696f, -0.10148726f, -0.13866465f, -0.01264370f, -0.10562883f, 0.20065084f, 0.16285285f, 
    -0.10273274f, 0.26800632f, 0.40868530f, -0.09072307f, -0.21099848f, -0.28497908f, 0.01437029f, -0.06731576f, 
    -0.00685499f, -0.11847263f, 0.07665597f, 0.19954523f, -0.48049408f, -0.90363556f, -0.33081827f, -0.03872893f, 
    -0.42373675f, -0.44406885f, -0.09828363f, 0.22348653f, 0.12236608f, 0.17832415f, 0.07465357f, 0.18950747f, 
    0.14442040f, 0.39446443f, -0.33036667f, -0.53770012f, -0.21623436f, -0.49607834f, 0.04548599f, 0.17462008f, 
    -0.17178646f, 0.36251980f, 0.32648963f, 0.32599998f, -0.47059378f, 0.05716506f, -0.12538897f, 0.40773359f, 
    -0.12300648f, -0.77163219f, -1.13265681f, -0.60260576f, -0.11391975f, 0.08073680f, -0.11710735f, 0.07806978f, 
    -0.22861922f, 0.17234452f, -0.85662556f, -0.48618644f, 0.05289463f, 0.13902271f, -0.25666514f, 0.13952857f, 
    -0.07299241f, 0.14579490f, 0.00384107f, -0.13657890f, 0.02720395f, -0.27037606f, 0.15482011f, 0.05865962f, 
    -0.18578368f, -0.16272530f, -0.20287070f, -0.12319376f, 0.02319501f, 0.07958038f, -0.03798260f, -0.00882157f, 
    -0.08376810f, -0.28613627f, -0.01425224f, 0.33350426f, 0.18184969f, -0.03007371f, 0.12549917f, -0.21975777f, 
    0.10748660f, -0.60129833f, -0.17352112f, -0.00214818f, -0.07699031f, -0.11097365f, -0.04284822f, 0.06867864f, 
    0.24561965f, -0.48530141f, -0.35504895f, -0.09454679f, 0.03740844f, 0.02320182f, 0.27693808f, 0.15430769f, 
    -0.43123820f, 0.21219872f, -0.48371601f, -0.14290489f, 0.28986454f, -0.20143621f, 0.06470179f, 0.10301485f, 
    -0.04338114f, 0.00301637f, 0.49859828f, 0.11799840f, -0.07187369f, 0.09205151f, -0.15920348f, -0.48906887f, 
    0.05962151f, 0.21131977f, -0.14817880f, 0.00120546f, -0.26089993f, 0.19055267f, 0.27949136f, -0.10374802f, 
    0.03941599f, -0.15765829f, -0.45938912f, -0.08438185f, -0.14710644f, -0.06258919f, -0.15481758f, 0.00332061f, 
    -0.78508991f, 0.19166133f, -0.02949413f, 0.16437411f, -0.06044338f, -0.15204129f, -0.03749596f, -0.10585641f, 
    -0.16385204f, 0.50495273f, 0.15579030f, -0.48075894f, 0.51863414f, 0.17708150f, 0.05744350f, 0.31102312f, 
    0.20590240f, 0.37072629f, -0.20130184f, 0.14427045f, 0.38925278f, -0.06272315f, 0.04117126f, -0.62362570f, 
    -0.11857553f, 0.16684140f, 0.28431031f, 0.22897890f, -0.01663794f, 0.05104592f, -0.44354379f, -0.34576350f, 
    0.10066061f, -0.19502023f, -0.19065154f, 0.09726457f, 0.40535098f, 0.00506565f, 0.37592831f, -0.25652951f, 
    0.02742128f, -0.23599137f, -0.10381365f, 0.33548421f, -0.07382542f, 0.17134558f, -0.05887630f, -0.38088924f, 
    -0.70105791f, -0.01230332f, 0.12499235f, 0.01285983f, -0.43945634f, -0.07410302f, 0.12890694f, 0.05569816f, 
    0.39241236f, 0.14083053f, -0.56682736f, -0.12980387f, -0.02347541f, 0.23801807f, -0.05579885f, -0.10695255f, 
    -1.08118737f, -0.12370981f, 0.07680713f, -0.93412900f, 0.33900782f, 0.30233443f, 0.09005597f, -0.10245473f, 
    0.33157849f, -0.75400591f, -0.04601644f, 0.00833217f, -0.93425894f, 0.09986968f, -0.14304772f, 0.02393996f, 
    0.33579829f, 0.20122518f, -0.08385408f, -0.10167292f, -0.31649417f, 0.15050246f, -0.10610859f, 0.01057200f, 
    -0.25175112f, 0.08517031f, -0.36425480f, -0.22095977f, 0.18342815f, 0.24069478f, -0.46024555f, -0.14149134f, 
    -0.59697258f, -0.78047425f, -0.39961955f, 0.04366328f, -0.08750141f, -1.03768337f, 0.06536730f, 0.16899066f, 
    0.02453516f, 0.16596435f, 0.09731341f, -0.15340646f, -0.08990066f, -0.37694359f, -0.01603811f, 0.03330924f, 
    -0.04895815f, 0.20624237f, 0.02510123f, -0.23060292f, 0.12004934f, 0.36481473f, 0.28875005f, -0.66780311f, 
    -0.44555923f, -0.14713448f, 0.13340020f, 0.07255184f, -0.04226584f, 0.20183261f, 0.16365471f, 0.24718101f, 
    0.19299635f, -0.30083051f, -0.45485559f, 0.38154200f, 0.15632547f, -0.56924969f, 0.24098767f, -0.13113829f, 
    -1.44309437f, 0.10734572f, -0.03961206f, 0.25993410f, 0.02531187f, -0.28442085f, -0.61709392f, 0.05324757f, 
    -0.54060066f, 0.04831981f, -0.25437719f, 0.15870374f, 0.23859230f, -0.05473464f, 0.05455196f, 0.35702568f, 
    0.23063041f, -0.86847645f, -0.72126853f, 0.18422799f, -0.70992178f, -0.44240120f, 0.31376919f, 0.12447138f, 
    0.05519645f, 0.18386510f, -0.07608681f, 0.06326207f, -0.13182768f, 0.23939542f, 0.12529001f, 0.04367207f, 
    0.04848176f, -0.68987232f, -0.14696206f, -0.41926447f, -0.11701962f, 0.12969324f, 0.01735000f, 0.19238274f, 
    0.27466607f, 0.06745394f, 0.46242791f, -0.62466478f, -0.34269625f, -0.47779757f, -0.01014941f, -0.24808736f, 
    -0.38037607f, -0.13612452f, 0.18920887f, -0.07308553f, -0.04981846f, -0.55539632f, -0.20084783f, -0.61467874f, 
    0.06736926f, -0.05878741f, -0.66311210f, -0.10701555f, -0.42060205f, 0.15792647f, -0.27850559f, 0.11479116f, 
    -0.79825532f, -0.59991449f, 0.37607524f, -0.42644224f, -0.10549269f, 0.17730659f, 0.21505284f, -0.35780907f, 
    -0.99654615f, 0.49434161f, 0.08517804f, -0.30354086f, 0.35327983f, 0.10401928f, -0.04870957f, -0.39594406f, 
    0.30962953f, -0.10924594f, 0.33150917f, 0.05376657f, -0.17485614f, 0.30940941f, -0.21829586f, -0.16850249f, 
    -0.34771061f, -0.01432038f, 0.35779434f, -0.20463870f, 0.34108713f, 0.14015986f, -0.11184683f, -0.99838638f, 
    0.01245926f, 0.06776016f, 0.03055462f, 0.09094737f, -0.00461528f, 0.31026846f, -0.27120587f, 0.38742211f, 
    0.47726393f, -0.51845932f, -0.33356488f, 0.10673341f, 0.09642693f, -0.66381091f, -0.46337971f, 0.46732116f, 
    -0.09394596f, 0.16577747f, -0.44380862f, -0.19165212f, 0.04124580f, -0.27482602f, 0.08978123f, -0.01990686f, 
    -0.50856650f, -0.89437234f, 0.33449969f, 0.15934098f, -0.31010514f, -0.06589810f, -0.60571212f, 0.03421422f, 
    0.06807923f, -1.23788464f, 0.24937665f, -0.11202221f, 0.14740700f, -0.21514882f, -0.23202328f, -0.08642735f, 
    0.16277264f, 0.33272156f, 0.26209456f, 0.53768671f, -0.24185942f, 0.02292664f, -0.09293099f, -0.05754158f, 
    0.01755361f, -0.36906248f, -0.18264890f, 0.14308310f, -0.01918295f, 0.15950918f, 0.51294500f, -0.33942556f, 
    -0.06076568f, -0.16045748f, -0.59436834f, -0.01449092f, 0.05825106f, 0.24188861f, -0.28667223f, 0.14336817f, 
    -0.07285146f, -0.10121370f, 0.04743635f, 0.26802006f, -0.12187043f, -0.19951136f, -0.04082258f, -0.29769260f, 
    0.24528730f, -0.27186862f, 0.11638961f, 0.23816349f, -0.06297177f, 0.28520119f, 0.22218038f, -0.24018580f, 
    0.06369057f, -0.29284304f, -0.16995813f, 0.14206655f, -0.10679219f, -0.20408063f, 0.30687940f, 0.05195372f, 
    -0.14210090f, 0.12608625f, 0.03269053f, 0.01697398f, -0.05555982f, 0.07837545f, -0.20488384f, 0.04204416f, 
    -0.16614783f, 0.23031303f, -0.26196072f, 0.02717692f, -0.01631526f, -0.51451904f, 0.35340470f, -0.11343115f, 
    -0.94725299f, -0.59658128f, -0.32645020f, -0.59204298f, -0.09102123f, 0.20528904f, -0.05709630f, -0.23630109f, 
    0.20889591f, 0.54434460f, 0.03115998f, -1.03986466f, 0.04048458f, 0.30703983f, -0.41064471f, 0.02502524f, 
    -0.07884590f, 0.45689255f, 0.28450057f, 0.29765829f, -0.30814943f, -0.35563850f, -0.66105509f, -0.10603547f, 
    0.12140040f, 0.07426048f, -1.22124875f, -0.39845663f, 0.06795321f, 0.14093639f, -0.09335928f, -0.53735518f, 
    -0.08065912f, 0.05809204f, -0.94059485f, 0.29025254f, 0.32968509f, 0.02023608f, -0.96339840f, 0.41370255f, 
    0.27836558f, 0.16075821f, -0.03737622f, 0.37956971f, 0.03292179f, 0.26506186f, 0.07770672f, 0.14894331f, 
    -0.38920218f, -0.10861664f, -0.24712309f, 0.09074567f, 0.32417464f, 0.10281988f, 0.08059926f, -0.02795653f, 
    0.04937661f, -0.41787121f, 0.73862350f, 0.01384533f, 0.05752273f, 0.23411000f, 0.40929326f, -0.09609338f, 
    0.15082119f, -1.43192577f, 0.23284373f, -0.70858085f, 0.09384568f, -0.25265673f, 0.02364798f, 0.35186991f, 
    -0.29449275f, 0.07705322f, 0.28730711f, -0.08245564f, 0.16994423f, -0.11997920f, 0.02134933f, -0.19903989f, 
    -0.16708454f, -0.10408342f, 0.01550695f, 0.17728382f, -0.16750884f, -0.43620536f, -0.38828483f, -0.29235092f, 
    0.03951281f, 0.16428553f, -0.90651518f, -0.08997080f, 0.04681028f, -0.36656481f, -0.31816596f, 0.19198327f, 
    0.45278692f, 0.12598172f, -1.38067329f, -0.47717005f, 0.24957040f, -0.06256092f, -0.24191603f, -0.46717086f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.20895746f, 0.11896043f, -0.17994890f, 0.02070963f, 0.18832076f, 0.10118448f, -0.12472461f, -0.38643405f, 
    -0.64779449f, 0.01134433f, 0.23199922f, 0.08861770f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
