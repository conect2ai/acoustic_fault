#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.78908527f, 0.19244343f, -0.91807467f, -1.08121192f, -0.80999321f, 0.78883606f, 0.43882617f, 0.23083603f, 
    0.70698166f, 0.47459599f, -0.16080309f, -0.05697583f, 0.02593441f, 0.01728444f, -0.40331224f, 0.30484599f, 
    0.06611872f, 0.28928632f, 0.20864691f, 0.23657653f, 0.07192308f, -0.33056334f, -0.25146562f, -0.33191341f, 
    0.45548934f, 0.87317795f, 0.08882623f, 0.31434527f, 0.21979864f, -0.68677962f, -0.79005653f, -0.32016233f, 
    -0.42196354f, 0.48503897f, -0.52933860f, 0.03760824f, 0.32553837f, -0.22686844f, 0.03973375f, 0.34065497f, 
    0.31807342f, -0.63396519f, -0.35517317f, 0.00151595f, -0.20854287f, -0.17259865f, 0.33657140f, -0.02469358f, 
    0.11068989f, 0.02533543f, 0.38074949f, 0.91051596f, 0.49862829f, 0.24498159f, 0.32151118f, -0.30777961f, 
    0.09507805f, 0.78371412f, 0.59688032f, 0.55984992f, -0.66481340f, 0.07183909f, -0.18175434f, -0.37497985f, 
    -0.31918907f, 0.22849901f, -0.16948427f, -0.51061773f, -0.14273742f, -0.12887439f, -0.17337428f, -0.38449916f, 
    0.21591914f, 0.04008560f, -0.48161584f, 0.66682488f, -0.36762872f, -0.75382268f, -0.42179996f, 0.60538840f, 
    0.79988182f, 0.10747927f, -0.74356210f, 0.03707593f, 0.24045542f, -0.18890563f, 0.71566331f, 0.06025293f, 
    0.36903042f, 0.42034331f, 0.15946737f, -0.20592047f, 0.16153318f, -0.01582435f, 0.12344015f, 0.14780657f, 
    0.26498422f, 0.36773387f, -0.29936877f, -0.05407466f, -1.27280939f, -0.55434591f, 0.37624091f, -0.57144779f, 
    -0.87536991f, 0.17704350f, -0.37608066f, -0.25469071f, 0.05405743f, 0.12742829f, 0.01577122f, -0.25466317f, 
    0.15151115f, 0.29086176f, 0.39715192f, 0.08896489f, 0.03930486f, -0.04835549f, -0.24925506f, 0.13078274f, 
    0.01191537f, -0.12815988f, 0.10999428f, -0.19456518f, -0.01361772f, 0.54729837f, 0.43928078f, 0.57282573f, 
    1.18451023f, 0.71055824f, 0.03924574f, 0.02542402f, -0.32673094f, 0.20158321f, 0.06983894f, -0.56814444f, 
    -0.20585051f, -0.25617415f, 0.45596355f, -0.27796650f, -0.12267322f, -0.03186318f, -0.12183281f, -0.00764960f, 
    -0.18960638f, -0.08158315f, -0.21827334f, -0.49762142f, 0.30468670f, 0.23682207f, 0.98168695f, -0.14805748f, 
    -0.16757545f, 1.07023907f, 0.13247028f, -0.53988552f, -0.34960610f, -0.44560009f, 0.36580586f, -0.15897927f, 
    -0.59646308f, 0.03539873f, 0.03507872f, -0.27143377f, -0.37537926f, -0.03367471f, -0.13538747f, -0.21890391f, 
    -0.10516458f, 0.19968517f, -0.09589981f, 0.07715096f, -0.39595479f, -0.48667812f, -0.28548408f, -0.30471975f, 
    -1.00301766f, -0.57634461f, -0.23951153f, -0.60761905f, -0.37883803f, 0.65321130f, 0.70678931f, -0.29793078f, 
    0.20482613f, -0.14250337f, -0.22494847f, -0.04771436f, -0.26370794f, -0.29814062f, -0.26521221f, 0.24517773f, 
    0.09067675f, -0.23645033f, -0.00147501f, -0.10706101f, 0.25607625f, 0.23843098f, 0.04783008f, 0.38523626f, 
    -0.40127295f, -0.37919280f, 0.35774392f, -0.31069690f, 0.28766602f, -0.98432970f, -0.36359492f, -0.73432261f, 
    -0.61134154f, -0.03521978f, 0.39392203f, -0.02058266f, 0.19099222f, 0.39338738f, -0.13844176f, -0.29555508f, 
    -0.61527336f, -0.55374032f, -0.07465027f, 0.21826352f, -0.19344938f, 0.42186463f, -0.15175830f, 0.02500087f, 
    -0.05755546f, 0.26011759f, -0.68452168f, 0.76001745f, 0.82115394f, -0.32920575f, -0.56416571f, -0.62247682f, 
    0.39649191f, 0.45406321f, -0.37762171f, 0.19010487f, -0.47701383f, -0.37383565f, -0.25606331f, -0.22383079f, 
    -0.09476671f, 0.21462159f, 0.20669442f, -0.08413253f, 0.01535847f, 0.21904169f, 0.35104835f, -0.02748637f, 
    0.13035466f, -0.37770373f, 0.89751500f, -1.17510402f, 0.52482873f, -0.36448503f, 0.58972883f, 0.27996179f, 
    0.36450452f, 0.22753230f, -0.61473763f, -0.30623752f, 0.08920386f, 0.60410428f, -0.19011758f, 0.19412158f, 
    0.07950213f, -0.46938738f, -0.00229746f, -0.03144057f, 0.19499946f, -0.16863230f, -0.10706761f, -0.03881229f, 
    -0.12958838f, -0.16796584f, 0.37316626f, -0.94482416f, -0.19720380f, -0.09825364f, -0.35321888f, -0.43702194f, 
    -0.15030463f, 0.29115623f, -0.47795621f, 0.42277277f, 0.55532342f, 0.51365477f, 0.40884572f, -0.35984549f, 
    -0.16348985f, -0.25824636f, -0.15167315f, 0.42329273f, 0.35088578f, 0.02328786f, -0.41991997f, -0.13520469f, 
    0.24563736f, 0.22571018f, -0.24941912f, 0.09759087f, -1.11532962f, -1.40221405f, -0.68969393f, 0.06876420f, 
    -0.04636288f, -0.12294242f, 1.26770508f, 0.79115057f, -0.00765719f, 0.51849353f, 0.08731242f, -0.51194519f, 
    0.11173761f, -0.14436391f, 0.26677087f, -0.24263437f, -0.21195683f, -0.16672088f, -0.15294181f, -0.13990648f, 
    0.01685873f, -0.04279796f, -0.20644520f, 0.26859522f, -0.05111481f, 0.82761496f, -0.35995564f, -0.06639800f, 
    0.94436002f, 0.73477256f, -0.52021623f, -0.41310111f, -0.14106205f, -0.22472136f, 0.43678561f, -0.09653378f, 
    0.26549238f, -0.28182691f, -0.06497631f, -0.10610111f, -0.40840957f, -0.21901608f, -0.21192208f, 0.37628517f, 
    -0.43817133f, 0.29180524f, -0.05138496f, 0.13763997f, -0.26636505f, -0.17249334f, -0.49072358f, 1.08998692f, 
    1.20877814f, 0.09379675f, 0.76078278f, 1.11840808f, -0.01262987f, -0.52751911f, 0.18199034f, -0.56262714f, 
    0.08122211f, 0.16950323f, -0.02343195f, 0.15979487f, -0.37383509f, 0.08335091f, 0.18792865f, 0.17220297f, 
    -0.20460708f, 0.00057988f, -0.06155566f, 0.03471270f, -0.08890049f, -0.01652530f, -0.19188052f, -0.27300990f, 
    1.01681960f, 0.69192243f, 0.17108838f, 0.63148171f, -1.32235289f, 0.36636963f, -0.14674257f, -0.84953570f, 
    -0.76018119f, 0.16871659f, -0.31250352f, 0.04143508f, -0.08643533f, 0.39768967f, 0.15985548f, 0.08357369f, 
    0.10829826f, 0.00260202f, 0.02012539f, -0.01965254f, -0.16399695f, 0.16562833f, 0.16728757f, 0.22279036f, 
    -0.16692695f, 0.92090851f, -0.43855605f, 0.52866429f, -0.97328931f, 0.91639978f, -0.69927520f, -0.71845269f, 
    -0.70859212f, 0.05601750f, -0.30471447f, -0.41993386f, 0.02283462f, 0.17270094f, 0.08501797f, -0.28837928f, 
    -0.22467104f, 0.04683851f, 0.15765437f, -0.19588119f, 0.07738417f, 0.13122411f, 0.15982805f, -0.17569794f, 
    -0.06495547f, -0.11008289f, -0.79897445f, -0.58605379f, -0.66075987f, 0.87004185f, 0.54771447f, -0.48065609f, 
    -0.76524353f, -0.09411860f, -0.09280345f, 0.55294365f, -0.19916402f, -0.08476282f, -0.40460682f, -0.04070516f, 
    0.05936755f, 0.31168097f, -0.26532468f, 0.47666967f, 0.14692803f, -0.23243646f, 0.22136767f, 0.28129306f, 
    -0.07047074f, -0.44678849f, 1.33725297f, 0.31534973f, -1.00549626f, -0.66830176f, -0.34799263f, -0.65436083f, 
    -0.11061381f, 0.55879885f, 0.33390450f, -0.34843251f, -0.14009951f, -0.45974508f, 0.23392004f, -0.38820776f, 
    0.02556957f, -0.16797948f, -0.36721110f, -0.20421647f, -0.06286608f, 0.04081918f, 0.12148616f, -0.21834297f, 
    0.11396970f, -0.23509011f, -0.19908263f, -0.38991791f, -0.10849074f, -0.42854238f, 0.03236546f, 0.83908349f, 
    -0.13331731f, 0.57173038f, -0.34867871f, -0.80087495f, -0.13918787f, 0.31774968f, 0.53319854f, 0.29989764f, 
    0.41074374f, 0.29756653f, 0.32363731f, 0.02352619f, -0.00446757f, 0.14970861f, 0.23479031f, -0.16334809f, 
    0.36188003f, 0.17949252f, -0.01049032f, 0.14393239f, 0.67654669f, 0.23206717f, 0.84983426f, 1.15323400f, 
    0.38560444f, -0.35187274f, -0.03250070f, -0.55589074f, 0.52010876f, -0.29256603f, -0.14775269f, -0.13141844f, 
    0.00608609f, 0.33547741f, -0.09748945f, 0.19167291f, 0.31148997f, 0.39709052f, 0.17269239f, -0.03961534f, 
    -0.02190617f, 0.23609053f, 0.23164469f, -0.29336193f, -0.17316903f, -0.19280221f, -0.56611168f, 0.88116992f, 
    -0.33854425f, -1.00851405f, 0.44584906f, -0.82560879f, 0.14177538f, -0.75237155f, 0.30395198f, 0.25317997f, 
    0.30634490f, -0.21224685f, 0.06804685f, 0.30823210f, -0.01113705f, 0.12640734f, 0.01291903f, -0.01478281f, 
    0.10368981f, 0.01996356f, 0.35276574f, 0.18428357f, 0.12239751f, -0.05383352f, 0.77871120f, -0.07530674f, 
    -1.01760578f, 1.09005344f, 0.72872686f, 0.60618293f, 0.78988636f, 0.24293594f, 0.76698273f, 0.22966190f, 
    -0.21209782f, -0.10120423f, -0.22009139f, -0.27962092f, -0.20355910f, -0.03653252f, -0.21846800f, 0.06276973f, 
    -0.14224322f, 0.08379454f, 0.25420165f, -0.07965056f, -0.06512439f, 0.07425342f, -0.01190196f, -0.03850383f, 
    -0.55598545f, -0.26345482f, -0.29716566f, -0.10574329f, -0.67276931f, 0.10627553f, -0.66232944f, -0.63850868f, 
    -0.30177736f, -0.82530987f, 0.13524280f, 0.24421734f, 0.19112495f, -0.12189929f, -0.69791359f, -0.58723515f, 
    -0.25228500f, 0.09875896f, -0.06897515f, 0.27653795f, 0.00599725f, 0.27151874f, -0.28664389f, -0.08149052f, 
    1.03322232f, 0.53304482f, 1.27059531f, 0.43708497f, -0.01585680f, 0.71547544f, 0.29071853f, -0.07739717f, 
    -0.45497912f, 0.60285497f, 0.19759153f, 0.56411421f, 0.01740577f, 0.07273444f, -0.37447104f, -0.25602281f, 
    -0.16804127f, 0.29486915f, -0.21470492f, -0.26053676f, -0.07801738f, 0.13957055f, 0.14259911f, 0.03216636f, 
    0.11327174f, -0.11956020f, -0.61276442f, -0.96460652f, 0.51645011f, 0.56085408f, -0.72119665f, -0.04584667f, 
    0.34897232f, 0.26252946f, 0.46894169f, 0.28145397f, 0.02460969f, 0.08612768f, -0.24723528f, 0.49849188f, 
    0.16044059f, 0.14086102f, -0.43722573f, -0.51787412f, -0.36872184f, -0.09509886f, -0.50810260f, -0.36043042f, 
    0.01505514f, -0.02432854f, 1.23917282f, 0.67267638f, 0.02135690f, 0.48529741f, 0.51013720f, 0.64194536f, 
    0.33159307f, -0.61966723f, 0.43261796f, -0.39441797f, 0.03284486f, -0.13133486f, -0.19118521f, 0.14720559f, 
    -0.32987496f, 0.26689002f, 0.01952767f, -0.06632172f, 0.02147352f, 0.02437433f, 0.48615986f, 0.04205512f, 
    0.41383648f, 0.03621278f, 0.42126349f, 0.97701091f, -0.64157373f, -0.16821365f, -0.58059603f, -0.44761717f, 
    -0.05466523f, 0.40270045f, 0.36892700f, -0.36391440f, -0.71054816f, -0.38913450f, -0.23145910f, -0.41244376f, 
    -0.54134578f, -0.52463913f, -0.41174284f, 0.37327817f, 0.09447012f, 0.17014070f, -0.29921982f, 0.06111227f, 
    0.11893892f, -0.16383266f, -0.04297245f, -0.15909089f, 0.46381000f, 1.16427231f, 0.92254269f, 0.49615067f, 
    -0.44995725f, -0.72908199f, -0.40945014f, -0.70129222f, -0.53914917f, -0.12400673f, 0.42775983f, 0.38396537f, 
    0.04660845f, -0.04494197f, 0.24339700f, -0.28066221f, -0.19852929f, 0.17450608f, 0.03372102f, 0.22502540f, 
    0.27011311f, 0.00807150f, -0.09564273f, 0.23032904f, 0.28649312f, -0.45184425f, 0.17455722f, 0.71942204f, 
    0.69963771f, -0.43631053f, 0.35688457f, 0.28697515f, -0.29005212f, 0.27942002f, 0.64749640f, -0.08134013f, 
    0.14307998f, 0.33882913f, 0.25853151f, 0.00924566f, -0.07347976f, -0.17981638f, -0.38223308f, 0.05861608f, 
    0.56433147f, -0.50945574f, -0.19800687f, 0.16943766f, 0.06170247f, -0.28309426f, -1.69764233f, 0.36827651f, 
    0.98287845f, -0.22310691f, -0.84084702f, 0.71987921f, 0.56901288f, 0.20820022f, 0.39459991f, 0.04688463f, 
    -0.22389323f, 0.01101653f, 0.17445785f, 0.01002578f, -0.07738625f, -0.20005386f, 0.03385536f, -0.12253138f, 
    -0.15365489f, -0.27048773f, 0.31614280f, 0.18686946f, 0.24701026f, 0.24888732f, 0.15946549f, -1.15430808f, 
    -0.49942690f, -0.13485551f, 0.17713174f, 0.01265016f, -0.92350197f, -0.23131578f, 0.50619692f, -0.39476311f, 
    -0.47306946f, 0.45152932f, 0.55137008f, 0.08671467f, -0.30505270f, 0.28247529f, -0.02703725f, 0.20854521f, 
    -0.07961349f, 0.40246356f, -0.08914009f, -0.04411302f, -0.38273609f, -0.17465755f, 0.13404460f, -0.20418955f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25170350f, -0.00339929f, 0.30561456f, 0.24419783f, 0.04722911f, 0.00402694f, -0.07698128f, 0.16802639f, 
    0.26265168f, -0.01110644f, 0.20441996f, 0.03953080f, 0.27700812f, 0.24750015f, 0.13656645f, 0.19389607f, 
    0.02848975f, 0.30904514f, 0.06877401f, 0.19929665f, -0.07504697f, 0.32551482f, 0.13392888f, 0.38794222f, 
    0.39019176f, -0.01059282f, 0.29803011f, -0.00559396f, 0.26890293f, 0.15364267f, 0.05116588f, 0.25193396f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.60076511f, 0.17932747f, -0.20331891f, -0.53529370f, 0.17156728f, -0.02972477f, -0.01938625f, 0.05366194f, 
    -0.00668687f, -0.08585802f, -0.09682626f, 0.06406858f, 0.17758247f, -0.07483573f, 0.02097213f, 0.13630989f, 
    0.02786141f, 0.00573849f, -0.15340911f, 0.17648047f, 0.13886987f, -0.02648513f, -0.06740656f, -0.21275194f, 
    -0.05655968f, -0.02552873f, -0.05665455f, 0.05008002f, -0.24245104f, -0.11961988f, -0.14059839f, -0.03766319f, 
    0.03517472f, -0.14960843f, 0.01446034f, -0.12562756f, 0.07660821f, -0.26294845f, 0.28057018f, -0.26584849f, 
    -0.06095403f, -0.14094268f, 0.08518343f, -0.21887146f, -0.05748443f, -0.03247946f, 0.16333745f, -0.02710323f, 
    0.12975948f, -0.05841595f, -0.10332157f, 0.06823713f, 0.03626091f, 0.04559397f, -0.23794454f, 0.10335872f, 
    0.18081020f, 0.00334559f, -0.08676934f, -0.05859880f, 0.23825203f, -0.06187488f, -0.15054278f, 0.35714641f, 
    -0.03372819f, -0.12634790f, 0.12546697f, -0.02587661f, -0.05455947f, -0.10592744f, 0.09225225f, -0.02757210f, 
    0.23694654f, -0.13358025f, -0.29638076f, 0.33916691f, 0.06690067f, 0.12365532f, -0.20786068f, 0.06786402f, 
    0.08018816f, -0.12527047f, 0.06176780f, 0.15457252f, -0.31299141f, 0.23345882f, -0.00118308f, -0.30178532f, 
    0.08452795f, 0.07700332f, 0.05067262f, 0.04290563f, -0.03100423f, -0.00117676f, -0.06646014f, 0.06765590f, 
    -0.15980707f, -0.18491958f, -0.05332589f, 0.09345211f, 0.05956273f, 0.01832033f, -0.18505499f, 0.13481392f, 
    -0.10901032f, -0.06187719f, -0.11298693f, 0.03511297f, 0.31117395f, -0.05058320f, -0.22577290f, 0.50667572f, 
    -0.06244583f, -0.00789257f, 0.14192618f, -0.16419958f, 0.03730903f, -0.17474486f, 0.11159804f, -0.03104375f, 
    0.15152033f, -0.13015072f, 0.00170649f, -0.33844152f, -0.29162282f, -0.03449484f, 0.04577284f, 0.03222653f, 
    -0.04920743f, 0.08865136f, -0.08224970f, -0.00142163f, 0.25839356f, -0.16952036f, -0.20964561f, 0.09147034f, 
    -0.04553527f, 0.00513606f, 0.02510451f, 0.11307435f, 0.07772958f, 0.13549179f, -0.17658263f, -0.02312182f, 
    -0.26340139f, 0.31453997f, -0.05370831f, -0.27592111f, 0.08420181f, 0.00648634f, -0.02470911f, -0.03240241f, 
    0.02133465f, -0.10272351f, -0.07679015f, 0.10911949f, 0.37287655f, -0.26334670f, 0.09545831f, 0.31638551f, 
    -0.14991295f, 0.02050582f, -0.08849157f, 0.00318077f, -0.28598768f, -0.02436454f, -0.06256813f, -0.01783638f, 
    -0.39136481f, -0.11937337f, 0.10428681f, 0.05548400f, -0.26224592f, -0.06030641f, 0.15157978f, -0.08036745f, 
    0.07723729f, 0.05418105f, -0.14487444f, 0.08303317f, 0.03769721f, 0.22361408f, -0.21549992f, -0.09868074f, 
    -0.21938553f, -0.22578979f, 0.05204892f, -0.12451122f, -0.09343622f, 0.04660514f, 0.00282682f, -0.06380653f, 
    0.21853784f, 0.23544644f, -0.13750787f, 0.07981177f, -0.06150385f, 0.03466461f, 0.07385242f, -0.12587553f, 
    -0.07214187f, 0.10913233f, -0.14069599f, 0.05160640f, -0.12376867f, -0.37530848f, 0.33806401f, -0.16871120f, 
    -0.17141196f, 0.10081480f, -0.04730713f, -0.13701676f, 0.03031556f, -0.00388011f, 0.11263391f, -0.18944260f, 
    -0.38186920f, -0.05249017f, 0.00549735f, -0.19430880f, -0.17879021f, -0.00419999f, -0.05643224f, 0.05258920f, 
    -0.12301151f, 0.03875634f, 0.12490921f, 0.10307597f, -0.09221936f, -0.06501936f, 0.05949209f, 0.00753903f, 
    0.16156846f, 0.03889016f, 0.05869946f, -0.06120602f, 0.01257703f, 0.11227612f, 0.00594402f, -0.07341950f, 
    0.14867482f, 0.03361341f, -0.37367955f, 0.27413961f, -0.06776803f, -0.09430358f, 0.15166333f, 0.00171784f, 
    -0.01311097f, 0.09950738f, -0.21950780f, -0.03514813f, -0.56432176f, 0.07341139f, 0.04093308f, -0.00934835f, 
    -0.01369929f, 0.09494548f, -0.03536842f, -0.27669078f, -0.12057306f, -0.03240329f, 0.10133583f, 0.02078907f, 
    0.01612896f, 0.30336875f, 0.02366187f, 0.32641354f, 0.02014219f, 0.10002121f, 0.01182326f, 0.04792115f, 
    -0.10478057f, 0.12656534f, 0.01281844f, -0.01225609f, -0.13371959f, -0.25756523f, -0.05152365f, -0.01371239f, 
    -0.00632881f, 0.01261455f, 0.06418648f, -0.01183423f, -0.03948177f, 0.01797670f, -0.19302467f, -0.06663770f, 
    0.08179128f, 0.08540010f, -0.05736392f, 0.02911431f, -0.26826993f, -0.15626818f, 0.00479908f, 0.01287495f, 
    -0.18190123f, 0.14279477f, -0.11037769f, 0.05574680f, -0.34352750f, 0.10880237f, 0.06765097f, 0.37762353f, 
    0.05651857f, -0.02256233f, 0.03819473f, -0.26750302f, -0.08535728f, 0.07901100f, 0.07124228f, 0.03699607f, 
    0.14304695f, 0.00531206f, 0.06977531f, 0.06259888f, -0.09632015f, -0.15481080f, -0.06559022f, 0.12496286f, 
    -0.00751448f, 0.02672609f, -0.02213273f, -0.15793042f, -0.16174695f, 0.19028139f, 0.09674446f, -0.05628476f, 
    0.02587023f, 0.05375781f, -0.09001598f, -0.17107220f, -0.15725620f, 0.22496438f, 0.11365021f, -0.00178130f, 
    -0.07206257f, 0.29198214f, -0.01049362f, 0.07443336f, -0.13934447f, 0.04447713f, 0.10431294f, -0.07060692f, 
    -0.08315273f, 0.00649505f, -0.12293597f, 0.08567128f, -0.05047827f, 0.04235707f, -0.18449400f, 0.22427914f, 
    -0.03553309f, -0.09567062f, -0.09591437f, 0.01564270f, 0.04640739f, 0.03874100f, 0.06733622f, 0.05575724f, 
    0.35267523f, 0.19475475f, 0.19987699f, 0.16599311f, -0.02989013f, 0.05253268f, 0.03504864f, -0.07174332f, 
    0.07773265f, -0.06407060f, -0.00462765f, -0.10092833f, -0.61224782f, 0.13455020f, -0.20416826f, 0.23284507f, 
    0.00387818f, -0.03968201f, -0.06177812f, -0.08259271f, 0.19853415f, 0.13726044f, -0.08664507f, 0.00807444f, 
    -0.34384361f, -0.14779116f, 0.06246552f, -0.23952091f, 0.06484360f, -0.01773765f, 0.09065885f, 0.09066252f, 
    0.06632589f, 0.07220071f, 0.07007993f, 0.02799585f, 0.18122546f, -0.19512685f, -0.32347637f, -0.06189309f, 
    0.03089192f, -0.12060458f, -0.06485888f, 0.07914941f, -0.13020399f, 0.00936024f, -0.31384289f, 0.08873570f, 
    0.23158933f, 0.19149086f, 0.12061957f, 0.17137656f, 0.09762996f, 0.01065798f, 0.01558656f, 0.06865283f, 
    0.07186371f, -0.07510766f, -0.08875200f, -0.06120501f, 0.38090885f, -0.22973068f, 0.10487571f, -0.33187795f, 
    -0.01001073f, -0.03081525f, 0.03022598f, 0.08262102f, -0.20984258f, 0.10527273f, -0.05966698f, 0.04162726f, 
    -0.26602522f, 0.17979361f, 0.21876277f, 0.14490457f, -0.08062527f, 0.13869575f, 0.18770590f, 0.06984936f, 
    -0.07739940f, 0.02649729f, -0.06037648f, 0.10974134f, 0.29944813f, 0.06964044f, 0.01256278f, 0.31564730f, 
    -0.18932356f, 0.08791029f, 0.10147303f, 0.10543785f, 0.09581818f, -0.07047835f, 0.03377947f, -0.18071924f, 
    0.23810580f, -0.37523153f, -0.08282172f, 0.04062527f, 0.02632018f, -0.01070879f, -0.09148537f, 0.00621112f, 
    -0.10856889f, 0.03884833f, -0.07356249f, -0.26836872f, 0.15690023f, -0.17748863f, -0.23875323f, -0.07751691f, 
    -0.13488221f, -0.03694032f, -0.10430685f, -0.07474486f, 0.09397239f, -0.17768969f, -0.04513840f, -0.07228372f, 
    -0.18626031f, -0.06078295f, -0.00833511f, -0.15880029f, 0.15667467f, -0.05920653f, 0.12861265f, 0.00399169f, 
    -0.01177254f, 0.07667370f, 0.03866633f, -0.25040147f, -0.67300361f, 0.09215787f, -0.26536176f, 0.08002221f, 
    -0.10951404f, -0.10527308f, -0.02368700f, 0.00311994f, 0.18236366f, 0.00038388f, -0.21361418f, 0.03249712f, 
    0.33200577f, -0.08201147f, 0.05241993f, 0.03421356f, 0.02058767f, -0.02837189f, -0.07123876f, 0.05646840f, 
    0.03085711f, -0.02267597f, 0.10481288f, -0.05397623f, -0.23177242f, -0.02743720f, -0.32445967f, 0.00725254f, 
    -0.03087785f, -0.03704917f, 0.05085021f, 0.09852375f, 0.12852967f, -0.20096312f, 0.01667508f, -0.01443764f, 
    0.54441047f, 0.06398760f, -0.16581985f, 0.02297458f, -0.02061503f, 0.06030867f, -0.02363561f, -0.04168651f, 
    0.10699054f, -0.10919789f, -0.11634782f, 0.11092114f, -0.02568863f, -0.04128840f, 0.08354025f, 0.30570891f, 
    -0.04373121f, 0.01963338f, 0.01849670f, 0.14323370f, 0.04914851f, -0.00757398f, -0.09765267f, 0.05415617f, 
    0.29944056f, 0.07439514f, 0.14820716f, 0.03063295f, -0.11823816f, -0.00000885f, -0.00808264f, -0.03793548f, 
    -0.07041773f, 0.00001729f, 0.10576059f, 0.04109353f, -0.19140331f, 0.22222085f, -0.22499263f, -0.20599617f, 
    0.10040323f, 0.29135290f, 0.05434415f, -0.04855412f, 0.07501610f, 0.06304039f, -0.00353451f, 0.16527824f, 
    -0.16343755f, -0.10114660f, -0.20718078f, -0.11833675f, -0.08742148f, -0.08378529f, 0.09453632f, 0.01490337f, 
    0.00864321f, 0.02500226f, 0.05848402f, -0.03914064f, 0.10509817f, -0.00607397f, 0.05967028f, -0.35678557f, 
    0.15130973f, -0.07855669f, -0.07417437f, -0.15095359f, 0.00236375f, -0.08451179f, 0.02984505f, 0.06478871f, 
    0.33208880f, -0.44913590f, 0.09590611f, -0.39447832f, -0.09690830f, -0.30114725f, 0.12608974f, 0.13488546f, 
    -0.11792007f, 0.00573249f, -0.25308412f, -0.10453434f, 0.03761303f, -0.12361308f, -0.11424278f, -0.10857017f, 
    -0.16135252f, 0.01510703f, 0.03909294f, -0.00534656f, 0.20173158f, 0.13525894f, -0.05819467f, -0.04040652f, 
    0.36860111f, -0.09209603f, -0.15493308f, 0.27671233f, -0.13737084f, -0.11927728f, -0.04638882f, 0.02671904f, 
    0.12307389f, -0.16165665f, 0.18717863f, -0.05984963f, -0.41185167f, 0.23575744f, -0.09962945f, 0.13833970f, 
    -0.02404286f, -0.01257564f, -0.04253013f, -0.03671300f, 0.03377740f, 0.03674211f, 0.03788586f, 0.12002563f, 
    0.38747850f, -0.31362718f, -0.04560979f, 0.21157224f, 0.10779332f, 0.03142696f, -0.19934024f, 0.05606338f, 
    0.16409384f, 0.15345620f, -0.04428623f, 0.12142408f, -0.11021277f, -0.23334533f, -0.08910012f, -0.07577949f, 
    -0.00037058f, -0.14502855f, 0.00650348f, 0.03465534f, 0.01533359f, 0.01178230f, 0.01899912f, -0.03386446f, 
    0.26489079f, 0.29277456f, 0.21526709f, 0.06739207f, -0.10775805f, -0.03587164f, 0.03177635f, -0.01012116f, 
    -0.00662462f, -0.11132377f, 0.02733980f, -0.10993746f, 0.27189568f, -0.08881629f, -0.01007668f, 0.04128811f, 
    -0.14224738f, 0.11068790f, -0.39692712f, 0.19298318f, -0.15658835f, -0.12635018f, -0.06124321f, 0.00360101f, 
    0.32311445f, -0.33956793f, 0.20858829f, 0.20543487f, -0.17672935f, -0.01860572f, -0.00405496f, 0.02650925f, 
    -0.13971807f, 0.04329262f, -0.06364720f, 0.00824128f, 0.23250671f, -0.40531725f, -0.26574689f, -0.09742788f, 
    0.07517422f, 0.10151298f, -0.19160838f, -0.06576980f, 0.15545347f, -0.05001530f, -0.04482084f, -0.10390397f, 
    -0.06621452f, -0.04275021f, -0.08241381f, 0.01865944f, -0.10291843f, -0.00664140f, 0.01902345f, -0.00751229f, 
    0.03232351f, 0.15516546f, 0.25932536f, 0.02635927f, -0.11725150f, -0.00128101f, 0.08032911f, 0.13736461f, 
    0.00747556f, -0.11163743f, -0.04349047f, -0.34790757f, -0.08674263f, -0.04113737f, 0.17398928f, -0.01877887f, 
    -1.01140642f, -0.00671294f, -0.16063917f, -0.04941676f, -0.00869510f, -0.02518818f, 0.01354969f, 0.01206124f, 
    0.06680752f, 0.04879232f, -0.11816529f, -0.06018120f, 0.08926257f, -0.07561582f, -0.05972207f, 0.05890466f, 
    -0.06089587f, -0.01613302f, -0.16861464f, -0.01225060f, -0.18135852f, -0.00864596f, 0.02677467f, 0.00664791f, 
    0.17666876f, 0.22529119f, 0.08967385f, 0.36165383f, -0.00578560f, -0.19188872f, 0.06054163f, 0.00231191f, 
    -0.15024525f, -0.00986235f, -0.05270942f, -0.00558958f, -0.24048012f, 0.11444496f, 0.00974496f, -0.35754478f, 
    -0.11192246f, 0.03277901f, 0.01692812f, 0.11786016f, 0.19441456f, 0.01676661f, 0.11736637f, -0.10333426f, 
    0.14505535f, 0.07228845f, -0.23943052f, 0.03352240f, 0.07052968f, 0.04518403f, 0.07270271f, 0.06181028f, 
    -0.08968554f, -0.05749504f, 0.09328804f, -0.15043707f, -0.19149530f, -0.32537302f, 0.14811996f, -0.17303744f, 
    0.00801413f, 0.02641255f, 0.09214139f, 0.06436267f, -0.09041630f, -0.18942769f, -0.05269952f, 0.00517828f, 
    0.41214150f, 0.09502686f, -0.23270993f, -0.28616372f, 0.12855576f, -0.01723454f, -0.05886726f, -0.05286177f, 
    0.01454657f, 0.05787421f, -0.04467246f, -0.03813340f, -0.05313027f, -0.13931553f, -0.08572697f, 0.18288919f, 
    0.04907630f, 0.03772220f, -0.14659007f, -0.02094019f, 0.06762434f, 0.03234204f, -0.00963132f, -0.10135039f, 
    -0.17320377f, 0.09322525f, -0.10580733f, -0.09688111f, 0.08989064f, 0.06065087f, -0.03465424f, 0.10442296f, 
    -0.06228921f, 0.09592102f, -0.05292127f, -0.09036412f, 0.39684263f, -0.00934745f, 0.18309943f, 0.28290951f, 
    -0.20067045f, -0.16613658f, -0.05669655f, -0.07913218f, -0.03817926f, 0.11456926f, -0.02700091f, 0.05717607f, 
    0.23078626f, -0.11229350f, -0.18553536f, -0.03040211f, -0.07099915f, 0.14588818f, -0.01155513f, -0.08752312f, 
    0.00927923f, 0.00016982f, 0.07312366f, -0.05380677f, -0.59104031f, 0.08664610f, -0.25097892f, -0.05737325f, 
    -0.14646910f, -0.01065198f, -0.03975534f, 0.06977011f, -0.03761230f, 0.07619960f, 0.08059514f, 0.07104133f, 
    -0.13591816f, 0.05110155f, 0.09257649f, -0.19732720f, 0.08063924f, 0.00520499f, -0.00151560f, 0.04485771f, 
    -0.09173717f, -0.04760668f, -0.04105565f, -0.13234352f, 0.20401716f, -0.23135656f, 0.18657723f, 0.00579486f, 
    -0.04146665f, 0.06776112f, 0.01791398f, 0.16414435f, -0.14875218f, -0.01618101f, -0.01317203f, -0.08635578f, 
    0.36259869f, -0.00630308f, 0.14218797f, 0.32571566f, -0.22968590f, -0.23021334f, -0.13869399f, 0.05813416f, 
    0.08657326f, -0.01874160f, 0.02735468f, -0.07225793f, -0.05354674f, -0.05850275f, -0.06047469f, -0.12623142f, 
    0.01544957f, 0.16307749f, 0.00072921f, 0.01053341f, -0.10620731f, -0.00941959f, 0.14927964f, -0.12263913f, 
    0.28216359f, -0.18693072f, -0.03963354f, 0.23657693f, 0.04882884f, 0.06698170f, 0.04660577f, -0.15794325f, 
    -0.03519850f, 0.06273354f, -0.05718750f, 0.01719377f, 0.34060651f, 0.14456062f, -0.47974983f, -0.03062136f, 
    0.25486290f, 0.03094860f, -0.09148730f, -0.09559285f, -0.14251390f, -0.05985562f, -0.13673148f, 0.04722017f, 
    -0.35382998f, -0.21803708f, -0.10168174f, -0.50605142f, 0.02908079f, 0.07394113f, -0.03725404f, -0.06305725f, 
    -0.15575910f, 0.10560133f, -0.19611834f, 0.07372507f, -0.36387476f, -0.30075186f, 0.07994561f, 0.15137076f, 
    -0.13090058f, 0.07215461f, 0.01963390f, -0.11846270f, -0.14207140f, -0.05442210f, 0.01603156f, -0.06641842f, 
    -0.23303412f, 0.09237810f, -0.36880532f, 0.01378127f, -0.05203194f, -0.02441330f, 0.22445518f, 0.09602406f, 
    -0.01013365f, -0.00259606f, -0.01892420f, 0.02671510f, 0.35734791f, -0.30187601f, 0.13188018f, -0.24640448f, 
    -0.01007132f, 0.04025006f, -0.02682871f, -0.01795031f, 0.03334443f, -0.05119249f, -0.03319572f, -0.09906691f, 
    -0.15678012f, -0.00748824f, -0.27428213f, 0.03459581f, 0.07269677f, 0.00887015f, -0.06510049f, 0.03286396f, 
    -0.17480700f, 0.03736727f, -0.12715548f, -0.05651470f, -0.19593066f, 0.00015831f, 0.15894991f, -0.42822087f, 
    -0.15259255f, 0.13386865f, -0.13622664f, 0.02185632f, -0.07874003f, -0.20644198f, 0.00704532f, -0.09522901f, 
    0.14788777f, -0.21953247f, 0.06112177f, 0.01131372f, 0.01484428f, -0.06011636f, -0.10688355f, 0.07322302f, 
    -0.01420277f, -0.00883537f, -0.05738066f, 0.05279456f, -0.01830030f, -0.00758211f, -0.15765567f, -0.31118858f, 
    -0.14977096f, 0.06310099f, 0.05060371f, -0.07911078f, 0.12387989f, 0.12994118f, -0.09205765f, 0.09996349f, 
    -0.04954036f, 0.14145252f, 0.01369574f, -0.12211643f, -0.01099691f, 0.09613338f, -0.03929115f, 0.11459520f, 
    -0.08516509f, 0.12883681f, -0.08065743f, -0.02346148f, 0.60721505f, -0.38512337f, 0.02230843f, -0.06223400f, 
    0.08788024f, 0.00848539f, -0.04504819f, 0.05174742f, 0.01343603f, 0.08812663f, 0.16273554f, -0.03009620f, 
    0.27458706f, -0.06725958f, 0.01859814f, -0.00379637f, 0.15604147f, -0.17441067f, 0.04962284f, 0.01411631f, 
    0.00450587f, 0.15424508f, 0.06866694f, -0.02014803f, -0.34197873f, -0.06965587f, -0.10768253f, -0.22230253f, 
    0.01297284f, -0.11632712f, 0.05260554f, -0.01196752f, -0.14665093f, 0.16455986f, -0.02935516f, 0.06901705f, 
    -0.14581563f, 0.09267636f, -0.05803066f, -0.06146659f, -0.01754959f, 0.08473346f, -0.02778944f, 0.00991391f, 
    -0.06016546f, 0.00047558f, -0.07762872f, -0.03129879f, 0.29173526f, 0.01117918f, -0.11335916f, -0.04017892f, 
    -0.09005927f, 0.07234076f, -0.04844394f, 0.09561783f, -0.04888317f, 0.03328762f, -0.03685705f, -0.07238779f, 
    0.43171728f, 0.05121712f, -0.09073070f, -0.09286810f, -0.03285867f, 0.04129989f, 0.06250300f, 0.00180966f, 
    0.00283310f, 0.09065580f, 0.02618868f, -0.03340360f, 0.53836715f, -0.28663331f, -0.19115937f, -0.16508789f, 
    -0.02497788f, 0.05306306f, -0.03738893f, 0.02857642f, -0.07073998f, -0.05630889f, -0.06386307f, -0.23205371f, 
    -0.21748260f, 0.14516321f, -0.08977732f, -0.35165831f, -0.15782551f, -0.15893465f, 0.07164221f, -0.07759069f, 
    -0.10062301f, -0.10270977f, -0.09054323f, 0.03239382f, 0.02777614f, 0.00765075f, -0.09941144f, -0.09658615f, 
    0.06426003f, -0.05549549f, -0.01219436f, 0.01949707f, 0.08312850f, -0.10795599f, 0.11575008f, -0.09094724f, 
    -0.49623170f, -0.29363453f, -0.15996824f, -0.14319342f, -0.10123714f, -0.06495013f, -0.04192632f, -0.02100235f, 
    -0.06079110f, 0.03148393f, -0.05374755f, 0.08476088f, 0.07569441f, 0.06096509f, -0.13247758f, 0.09038893f, 
    -0.11190242f, 0.13350478f, -0.10181292f, 0.05788929f, -0.19453955f, -0.04234459f, -0.05460519f, -0.07812528f, 
    0.14400792f, 0.02668509f, 0.09465154f, -0.29235241f, 0.01684080f, 0.02105617f, 0.04636703f, 0.05706633f, 
    0.08674037f, 0.05469197f, -0.02107673f, 0.01544479f, -0.17821261f, -0.52512622f, -0.17855637f, 0.14276795f, 
    -0.11597752f, -0.12062683f, 0.05636941f, -0.04052995f, 0.03552742f, -0.08294041f, 0.12815790f, 0.14478870f, 
    0.33436319f, 0.07338817f, 0.10397705f, 0.08738702f, 0.01401507f, -0.03057208f, 0.10282455f, -0.08543719f, 
    0.08728194f, 0.04381314f, -0.05516966f, -0.00126966f, 0.21558577f, -0.15172319f, 0.06938563f, -0.04336805f, 
    -0.04147046f, 0.01918410f, 0.05054916f, 0.01982278f, -0.12296935f, -0.03648073f, -0.00088578f, 0.04604302f, 
    0.13302420f, 0.24734885f, 0.16698834f, 0.20521739f, -0.07478444f, -0.04453460f, -0.16165629f, -0.04060259f, 
    0.00415459f, 0.03194309f, 0.23272371f, 0.00879564f, -0.05601899f, -0.11973615f, 0.03308342f, 0.26684496f, 
    0.03578969f, 0.05007583f, 0.05348507f, 0.05632145f, -0.02467901f, 0.13637935f, -0.00270412f, -0.17130437f, 
    -0.08894522f, 0.14754032f, 0.14710940f, 0.15525883f, -0.07742813f, 0.08334975f, 0.12314133f, 0.06307221f, 
    0.08123971f, -0.01667090f, 0.01353526f, 0.15176821f, -0.29073089f, 0.21866322f, 0.06960560f, -0.04120193f, 
    -0.13943554f, 0.06920540f, -0.22615865f, 0.01396938f, 0.01821975f, 0.01943144f, 0.08345547f, 0.09969763f, 
    0.18675329f, -0.10521333f, 0.03769258f, -0.03133128f, -0.11203903f, -0.17369689f, -0.00376987f, -0.06071689f, 
    -0.11110902f, -0.09370531f, -0.03006779f, -0.02274176f, 0.08932632f, -0.19810438f, 0.13388929f, 0.15282659f, 
    -0.00584073f, 0.11702767f, -0.00529420f, -0.14436701f, 0.01616954f, 0.04302169f, 0.15651821f, -0.02142969f, 
    0.55938923f, -0.40224400f, -0.06328706f, 0.29244867f, -0.03595549f, -0.06638698f, -0.04893212f, 0.14804378f, 
    0.06536200f, 0.06042089f, -0.02170708f, -0.03809632f, -0.72931612f, 0.26836565f, 0.33660135f, -0.02275969f, 
    0.09494258f, 0.04161380f, 0.02294390f, 0.10135742f, -0.05306056f, 0.02441406f, -0.07042226f, -0.25716373f, 
    0.45066583f, -0.03999797f, -0.16347098f, 0.29986778f, 0.09228358f, 0.10315730f, 0.08982906f, 0.10622070f, 
    0.03447733f, -0.02146082f, -0.02564103f, 0.21240780f, 0.09041906f, 0.09228566f, -0.06086474f, 0.02903554f, 
    -0.19169831f, 0.05613173f, 0.07599752f, 0.05546897f, 0.05701219f, -0.09691763f, 0.02717445f, 0.02807353f, 
    0.14794131f, -0.23427035f, 0.19336408f, 0.01446321f, -0.01804503f, 0.00068265f, 0.04674121f, 0.03094894f, 
    -0.06165750f, 0.15223540f, -0.02559429f, -0.03610771f, -0.16632868f, 0.10062235f, 0.22519679f, 0.00613962f, 
    0.15486416f, 0.03283288f, -0.13704717f, 0.11814741f, -0.04970834f, -0.03024822f, -0.27588972f, -0.06602281f, 
    -0.02601499f, -0.31112796f, -0.11822146f, 0.21663731f, -0.05872728f, 0.18799140f, -0.06237255f, 0.00140337f, 
    0.12627959f, -0.07949205f, 0.00232242f, 0.08877608f, 0.28594884f, -0.12408069f, 0.04780274f, -0.11732444f, 
    0.12341207f, -0.01165838f, 0.01469712f, 0.03228629f, 0.07580393f, -0.01874545f, -0.02561215f, -0.04926547f, 
    0.02906555f, -0.18007502f, -0.28785315f, -0.20184542f, -0.03319890f, -0.08282236f, 0.09380241f, -0.13982669f, 
    0.02482912f, -0.02669485f, 0.14402843f, -0.14081073f, 0.08112226f, 0.26139843f, 0.15267678f, 0.08217143f, 
    -0.14218076f, -0.10957047f, -0.09215433f, -0.04135362f, 0.05118408f, 0.02062102f, 0.06848387f, 0.01779382f, 
    -0.69682670f, -0.82906216f, -0.30653742f, 0.15544380f, -0.01751609f, -0.06568860f, -0.08892988f, 0.03481390f, 
    0.06247587f, -0.02497598f, -0.09958357f, 0.06488444f, 0.35371602f, 0.06769433f, -0.14121681f, 0.00818615f, 
    -0.01076642f, -0.03568260f, 0.17888492f, -0.17369093f, -0.04720864f, -0.07013611f, 0.06539545f, -0.11041170f, 
    0.01435091f, -0.44929826f, -0.43698704f, -0.20134327f, -0.12225213f, -0.07954992f, -0.07592890f, -0.04912042f, 
    -0.08477486f, -0.06830098f, 0.03936635f, 0.03194436f, -0.03399630f, 0.05374922f, 0.32369101f, -0.02945498f, 
    -0.07852189f, 0.11673348f, -0.04399961f, 0.10222288f, -0.07357617f, 0.07429254f, -0.00663352f, 0.18313172f, 
    -0.39325723f, -0.25332037f, -0.24937239f, 0.17200975f, 0.08256175f, -0.03084872f, 0.00849955f, -0.00192637f, 
    -0.05770702f, 0.02012802f, -0.08566314f, -0.20527668f, -0.43278128f, 0.11136354f, 0.04267503f, -0.10396337f, 
    0.16443682f, -0.06308031f, 0.07185265f, 0.11897933f, 0.05198735f, 0.00572992f, 0.00843630f, 0.06612274f, 
    -0.24756709f, 0.14895323f, 0.14981365f, -0.28176439f, -0.01897132f, 0.04764626f, 0.03734561f, 0.07370108f, 
    0.02688719f, -0.07430770f, -0.01595091f, -0.11377379f, -0.21223457f, 0.30913237f, 0.09768401f, -0.02746474f, 
    -0.02172772f, -0.21085425f, 0.03805522f, -0.05214072f, -0.04831470f, 0.00287386f, -0.05735680f, -0.04652831f, 
    -0.02575650f, -0.10326973f, -0.01920876f, 0.41526166f, 0.06591732f, -0.07266676f, -0.03396541f, -0.00732191f, 
    0.03313337f, 0.07728917f, 0.14128035f, -0.02420106f, -0.11109878f, 0.00426759f, 0.13965262f, 0.20188187f, 
    -0.13005100f, 0.02392454f, 0.05964195f, -0.34971499f, -0.08676127f, 0.02109399f, 0.17221175f, -0.10486551f, 
    0.07873481f, -0.10648172f, 0.15784195f, 0.10266891f, -0.16228054f, 0.11231943f, 0.06595254f, 0.01879619f, 
    0.03370236f, 0.03266675f, 0.11871581f, -0.00424581f, -0.17093651f, -0.15331632f, -0.11203618f, 0.12193368f, 
    -0.07043570f, 0.04500783f, 0.04576286f, 0.01266920f, 0.02550962f, -0.05655355f, -0.06613308f, 0.10954811f, 
    0.42757803f, -0.16775103f, -0.03946374f, -0.01702938f, 0.06539600f, -0.15327315f, 0.00827189f, 0.09876714f, 
    0.12853396f, -0.12970327f, -0.10745756f, 0.13000777f, 0.13305999f, 0.32752949f, -0.12329356f, 0.09066670f, 
    0.00129761f, -0.00935998f, -0.00208959f, 0.10309289f, -0.04957275f, 0.09381106f, -0.02022738f, 0.10100462f, 
    0.14618804f, 0.05060038f, -0.02002969f, 0.21909124f, 0.03496413f, 0.09940851f, 0.07900212f, -0.05704082f, 
    -0.02657690f, -0.04773121f, -0.05087478f, -0.00197984f, -0.67058420f, -0.14059904f, 0.06353060f, 0.12241530f, 
    0.12441491f, -0.02830268f, 0.07182578f, 0.08879992f, -0.11022924f, -0.02950810f, 0.05471947f, -0.02059153f, 
    -0.22638461f, -0.11923113f, 0.14056952f, 0.00760198f, 0.03678769f, -0.17746542f, 0.07394876f, -0.04397834f, 
    0.02175005f, -0.09143668f, 0.00892598f, 0.07776034f, -0.14046033f, 0.08669730f, 0.20616356f, -0.05167241f, 
    -0.07185651f, 0.18197507f, 0.03201036f, -0.01763763f, 0.04380939f, -0.01381200f, 0.01512753f, 0.03490908f, 
    -0.48836070f, 0.04160268f, 0.10655492f, -0.39828980f, 0.15389921f, 0.09092353f, -0.18436252f, -0.12970546f, 
    0.02186317f, -0.06759824f, -0.01806124f, -0.20150326f, 0.23853800f, 0.22600445f, 0.09805078f, 0.01140496f, 
    0.11117546f, 0.12205588f, -0.00429506f, 0.04400511f, -0.02039524f, 0.10650258f, 0.17043282f, -0.13456693f, 
    -0.88347459f, -0.03215155f, -0.16204624f, 0.16131122f, -0.04711931f, 0.05828004f, 0.00004752f, 0.00166873f, 
    -0.00849175f, -0.13793039f, 0.07326294f, 0.05183772f, -0.21687581f, 0.01552634f, 0.05716576f, 0.12890600f, 
    0.04955156f, 0.02792258f, -0.09263770f, -0.11511422f, 0.06799609f, -0.05752456f, 0.01884437f, 0.03607725f, 
    0.03786818f, 0.36786315f, -0.31784847f, -0.29496095f, -0.06242483f, 0.14917032f, 0.04350065f, 0.21180607f, 
    -0.05977797f, -0.00075342f, 0.03416512f, 0.11615845f, -0.35088018f, 0.01633565f, 0.27245617f, 0.26408410f, 
    -0.04384028f, -0.14426227f, -0.03537204f, -0.06042308f, 0.00734618f, -0.02823493f, -0.04637097f, -0.13423266f, 
    -0.14135772f, -0.21915399f, 0.14832669f, -0.09780510f, 0.11030623f, 0.05482837f, -0.09942726f, -0.03264615f, 
    -0.01915314f, -0.11709314f, 0.14374135f, -0.00545751f, -0.03158623f, -0.06171443f, -0.35986638f, 0.11843962f, 
    0.05875269f, 0.05679582f, 0.06768973f, 0.16257586f, -0.00714268f, 0.06750622f, -0.08012412f, -0.06026873f, 
    0.35973719f, -0.11188493f, -0.08465382f, -0.05340196f, -0.04436300f, 0.00846097f, -0.11527750f, -0.12112874f, 
    -0.04212403f, 0.05060125f, 0.09141600f, -0.12261374f, -0.35393894f, 0.08152350f, 0.15053673f, 0.16618872f, 
    -0.05493074f, -0.12904787f, 0.00484126f, -0.08998182f, -0.00812082f, -0.06879079f, -0.06132354f, 0.06886596f, 
    -0.03051753f, 0.10597496f, 0.12375774f, 0.18900114f, -0.07971995f, 0.03842758f, 0.03985907f, 0.06103189f, 
    0.17025882f, 0.05305208f, -0.07602788f, 0.06783464f, 0.27777338f, -0.20282114f, 0.04474356f, -0.30949301f, 
    0.07732081f, 0.03576167f, -0.21594569f, -0.01613835f, -0.00536873f, 0.01424703f, -0.18963127f, -0.04097606f, 
    0.17559125f, -0.05168673f, -0.20902857f, 0.05562258f, -0.10522114f, 0.07076421f, 0.01710070f, -0.06775640f, 
    -0.08105383f, -0.05551677f, 0.14761168f, 0.00568813f, -0.01948071f, 0.00290255f, 0.15634158f, 0.11102120f, 
    0.05203542f, -0.07243761f, -0.07438619f, 0.08089641f, -0.06607109f, 0.03661162f, 0.05421358f, 0.15860385f, 
    -0.49335426f, -0.01523651f, -0.09482076f, -0.09025278f, 0.09952220f, 0.00657890f, -0.11756540f, 0.14054266f, 
    0.05601496f, -0.13538404f, -0.06649068f, 0.13897903f, 0.15215690f, 0.03183959f, -0.07325341f, 0.14347166f, 
    0.08258395f, -0.06108781f, -0.06485514f, 0.19962941f, 0.10577444f, 0.05299485f, 0.04201906f, 0.05047566f, 
    0.25708771f, 0.12500370f, 0.05828029f, -0.09300530f, -0.18315867f, -0.04571148f, 0.05157955f, 0.04422219f, 
    0.02927814f, 0.08858403f, 0.04529973f, -0.01956072f, -0.11079881f, 0.05800296f, 0.40143523f, -0.02209114f, 
    -0.17045616f, 0.07532563f, 0.00931066f, 0.04361790f, -0.13908972f, 0.00505346f, 0.25126466f, 0.11448856f, 
    -0.63973802f, -0.64296901f, 0.20189679f, 0.06972107f, -0.08730745f, 0.03298450f, -0.07131141f, -0.13812529f, 
    0.17621577f, 0.00167305f, -0.14370617f, -0.16257086f, -0.45601982f, 0.05046560f, -0.15859067f, -0.22528432f, 
    0.01218219f, 0.05368021f, -0.00987374f, 0.21251553f, -0.14147672f, -0.06411953f, -0.03136610f, -0.02472446f, 
    0.26902297f, 0.12549260f, -0.20894329f, -0.27739820f, 0.03441294f, -0.04641745f, -0.06695406f, 0.00125556f, 
    0.03850562f, -0.03474131f, -0.20495047f, -0.04666627f, -0.09707496f, -0.04007217f, 0.12101525f, 0.09241404f, 
    0.12688862f, -0.03251709f, -0.02840690f, 0.15484238f, 0.00596700f, 0.07150019f, -0.15459888f, -0.06153128f, 
    0.10468721f, -0.04787118f, -0.11469357f, -0.20201761f, 0.03013807f, 0.13960682f, -0.31198117f, -0.24798547f, 
    0.11283844f, 0.01330002f, 0.06744476f, 0.04975993f, -0.05907723f, 0.01056367f, -0.01557019f, 0.19499223f, 
    -0.08596682f, -0.02621557f, 0.14673543f, -0.00134542f, -0.26255643f, -0.12055905f, -0.01422168f, 0.00558283f, 
    0.16736108f, 0.06878024f, 0.11104216f, -0.20919031f, 0.03374393f, -0.07912917f, 0.07420240f, -0.15779376f, 
    -0.11559515f, 0.01760913f, -0.13904065f, -0.01127712f, -0.38321018f, 0.03593720f, -0.00377818f, -0.03783683f, 
    -0.08329660f, -0.01452188f, -0.03329649f, -0.04726963f, 0.31580436f, 0.15010980f, 0.18784012f, 0.04352581f, 
    -0.76595938f, -0.27262276f, -0.05326059f, 0.11495058f, -0.02228157f, 0.03766191f, -0.07137170f, -0.26931936f, 
    -0.09236617f, 0.04571245f, -0.00382985f, 0.03057412f, 0.04678804f, -0.02470620f, 0.17575353f, -0.28298372f, 
    0.12681279f, 0.08314617f, 0.01914437f, -0.17536631f, -0.07656638f, -0.00898347f, -0.12279560f, 0.08232073f, 
    0.02919969f, -0.06855293f, -0.02511470f, -0.08915237f, -0.03668484f, -0.28097913f, 0.09759930f, 0.02255249f, 
    -0.13375331f, 0.05809213f, -0.02890489f, -0.04610757f, -0.33418411f, 0.00632884f, -0.39540187f, -0.00120363f, 
    0.18327191f, 0.20120816f, 0.01971324f, 0.15366866f, 0.03501452f, -0.09084290f, 0.03388321f, -0.05200178f, 
    0.00629684f, -0.14671689f, 0.04009057f, 0.34372199f, 0.01974336f, -0.03081814f, -0.00114435f, 0.04349742f, 
    -0.21937926f, 0.09720552f, -0.09109449f, 0.29399243f, -0.16167870f, -0.13038324f, -0.11396574f, 0.02373474f, 
    0.12572899f, -0.01532483f, -0.18086916f, 0.19532733f, 0.10609102f, 0.09282499f, 0.12132663f, -0.14519612f, 
    -0.24510343f, 0.08103397f, 0.29772469f, 0.14528689f, 0.01509853f, 0.09002407f, 0.06324282f, 0.00891280f, 
    -0.13825899f, -0.12159593f, 0.05659804f, -0.02084797f, -0.06617495f, -0.15522726f, 0.00041300f, -0.10323567f, 
    0.12471657f, 0.08217202f, 0.05040468f, -0.10731259f, 0.00191886f, -0.24855965f, -0.03985566f, 0.05433951f, 
    -0.78678834f, 0.10180780f, -0.22207858f, -0.25017950f, 0.19182624f, 0.05308440f, 0.08379535f, -0.03135459f, 
    -0.10644422f, 0.08057407f, 0.01633891f, -0.22837511f, -0.04912018f, 0.00061359f, -0.10590750f, -0.39740482f, 
    -0.00219667f, -0.19689882f, -0.11070859f, 0.13102004f, 0.10850729f, -0.10831832f, -0.12154016f, -0.17529145f, 
    -0.12978773f, -0.14653982f, 0.44955906f, 0.26621211f, 0.02955738f, 0.00741502f, -0.04192595f, -0.00281711f, 
    -0.04095327f, 0.10464043f, -0.05446425f, 0.03909707f, 0.26127860f, -0.12724134f, -0.00729215f, 0.22181210f, 
    -0.16634192f, -0.06590892f, -0.03326740f, 0.04075297f, 0.03835852f, -0.07133025f, 0.11539219f, 0.14046833f, 
    -0.14411868f, 0.17921285f, 0.29382721f, -0.10543005f, -0.03966084f, 0.00496299f, 0.08561057f, 0.09506278f, 
    -0.03891322f, 0.00739561f, -0.10985647f, -0.36892569f, -0.03242189f, 0.07509528f, -0.38034889f, -0.04550594f, 
    0.13844201f, -0.00200760f, -0.12855992f, 0.02582087f, 0.03101314f, 0.12704790f, -0.17560291f, 0.16940913f, 
    0.22501022f, -0.00975720f, -0.01864591f, 0.05434604f, 0.19081905f, -0.07276123f, -0.04948004f, -0.17295516f, 
    -0.10059175f, -0.10274532f, -0.12120189f, -0.04188059f, -0.10341490f, -0.09168240f, 0.18833156f, -0.09984434f, 
    0.01045956f, 0.10325886f, -0.00114140f, -0.01147953f, -0.22795853f, 0.08881432f, 0.14254835f, 0.26309657f, 
    -0.01096789f, 0.04603013f, 0.03441039f, -0.02437028f, 0.14143237f, -0.04569253f, 0.04297190f, 0.03841768f, 
    0.00596143f, 0.11629362f, 0.19522589f, 0.30131224f, -0.18683070f, -0.17798398f, -0.13446870f, 0.16786543f, 
    -0.01490520f, -0.13432933f, 0.15594192f, 0.20460019f, 0.14684184f, 0.10521406f, -0.01389488f, 0.01954758f, 
    -0.02220942f, 0.36301553f, 0.28285351f, -0.52550989f, -0.09932600f, -0.02329077f, -0.12457354f, -0.06676552f, 
    0.05728935f, -0.07176778f, -0.07505438f, -0.07475130f, -0.00837115f, -0.01886459f, 0.04583979f, 0.24376455f, 
    0.25817445f, 0.11842736f, -0.16807862f, 0.09913936f, 0.01465827f, -0.04770941f, 0.30453399f, -0.31489816f, 
    0.06551477f, -0.10941228f, 0.22830409f, 0.20141421f, 0.00968877f, 0.11610451f, 0.13299225f, 0.04276777f, 
    0.02718067f, -0.01640876f, 0.14894328f, -0.13815846f, -0.46846363f, 0.00648965f, 0.01181615f, -0.40740085f, 
    0.07857026f, 0.10710407f, 0.07297663f, -0.05876828f, -0.00601001f, -0.04295570f, -0.25347853f, 0.06414369f, 
    -0.03293975f, -0.04163845f, 0.04972983f, 0.12543143f, 0.05091590f, 0.11199538f, 0.08442934f, -0.07312790f, 
    0.30934855f, -0.03732514f, -0.09618295f, 0.11497497f, 0.22244841f, -0.01508676f, -0.10150222f, 0.13034527f, 
    0.02736804f, 0.05669135f, 0.04439058f, 0.16498794f, 0.13557075f, -0.06030311f, -0.10211132f, -0.22831981f, 
    0.19822259f, 0.10669638f, -0.02233272f, 0.13418373f, -0.11285754f, 0.00283143f, 0.02258519f, 0.03289850f, 
    -0.24106619f, -0.01527161f, 0.13436082f, 0.13851136f, 0.13268301f, -0.03366796f, -0.08926426f, -0.30301526f, 
    0.05310062f, -0.03077409f, 0.09601764f, -0.04178807f, -0.03458348f, 0.10452190f, -0.08235505f, -0.06256330f, 
    -0.62856716f, -0.32270989f, 0.02443416f, 0.12610894f, 0.02057592f, -0.09081292f, 0.01674274f, -0.03793037f, 
    -0.00040601f, -0.00244758f, 0.02229273f, 0.00982706f, -0.09232673f, -0.18427861f, -0.27525523f, -0.15766917f, 
    0.01395664f, 0.00762532f, 0.02722446f, 0.05320010f, 0.02363915f, 0.03921158f, -0.03644179f, 0.25460535f, 
    -0.26867709f, -0.21129116f, -0.36845946f, 0.10239189f, -0.05239274f, 0.01294943f, 0.15213503f, 0.01162228f, 
    -0.11798292f, 0.05327110f, -0.03094425f, 0.11973485f, -0.56911963f, 0.09353870f, -0.03870599f, -0.01715184f, 
    0.12570618f, 0.09500171f, 0.02877527f, 0.05167858f, 0.13229649f, 0.15866427f, 0.08719678f, -0.07391368f, 
    -0.59624028f, 0.11599121f, 0.06600673f, 0.08453313f, 0.02807363f, -0.16876099f, 0.03390861f, 0.21065576f, 
    -0.07975617f, 0.15684079f, 0.11325371f, 0.15724874f, -0.20706873f, -0.25158843f, 0.09428332f, -0.01615937f, 
    0.04172182f, 0.10834951f, 0.03550747f, 0.16471262f, 0.10736164f, -0.06225909f, -0.16615126f, -0.13705592f, 
    0.08875936f, 0.07754655f, -0.12607770f, -0.30361250f, -0.05000202f, -0.00528580f, -0.17075583f, 0.01878144f, 
    -0.08477750f, 0.16911033f, 0.09834618f, -0.10638705f, 0.09238622f, 0.12293443f, 0.14395222f, -0.43378478f, 
    -0.02472416f, -0.12002546f, 0.06508557f, 0.05215874f, 0.07018019f, 0.10061131f, 0.03383032f, -0.06861838f, 
    -0.16846877f, 0.34218585f, 0.16610645f, -0.44539469f, -0.04080909f, 0.21277253f, 0.08072080f, -0.04876634f, 
    0.01369058f, -0.27634287f, 0.11377677f, -0.04567341f, 0.09130824f, -0.27719328f, 0.01899539f, -0.22432208f, 
    0.04939240f, -0.14197765f, 0.03013517f, -0.20605244f, 0.06009797f, -0.08731921f, 0.09996190f, 0.19797593f, 
    0.04663909f, 0.25584570f, 0.08492930f, -0.23514870f, -0.03744638f, 0.15991172f, -0.07261557f, -0.07958584f, 
    0.10810258f, -0.25134766f, -0.07274977f, 0.03985162f, 0.18382771f, -0.15325761f, 0.08729407f, -0.46863830f, 
    0.07952494f, -0.02363809f, 0.12050000f, -0.20224924f, -0.30850828f, -0.19983280f, -0.23262131f, 0.15801226f, 
    0.49610594f, -0.14391115f, -0.09091495f, 0.16335690f, -0.05919987f, -0.07121966f, 0.00744845f, 0.11470783f, 
    0.01226747f, 0.07266106f, -0.07582691f, 0.06269900f, 0.05155373f, -0.12390169f, -0.14200412f, -0.05211889f, 
    -0.03520802f, -0.21654348f, -0.14988574f, -0.08304352f, -0.19465134f, 0.14367297f, 0.01002270f, -0.00715708f, 
    -0.02526577f, -0.68068439f, 0.01124854f, -0.18406658f, 0.00926043f, 0.06993186f, 0.11837466f, -0.10644549f, 
    -0.04458142f, 0.02266269f, 0.18860377f, 0.15889733f, 0.51132631f, 0.13626541f, 0.12828371f, -0.37761697f, 
    -0.17928322f, 0.04313653f, 0.10934631f, -0.02349770f, 0.02655654f, 0.18358867f, 0.07459342f, 0.13276152f, 
    0.24096489f, 0.00399045f, -0.04505222f, -0.15080093f, -0.00382622f, 0.02157650f, 0.05030483f, 0.07295632f, 
    0.06924379f, -0.00216771f, 0.02672869f, -0.03476340f, 0.12476277f, 0.10320849f, 0.20279329f, -0.30519283f, 
    -0.00638273f, -0.08021390f, 0.01856439f, -0.03144361f, 0.04796170f, -0.02441899f, -0.19494642f, -0.11113726f, 
    0.36738679f, 0.29295325f, 0.19162266f, 0.48330727f, 0.03497191f, 0.09068476f, -0.08785647f, 0.12319776f, 
    -0.12804706f, 0.14617123f, 0.08923166f, 0.21230967f, 0.02821674f, 0.08345931f, 0.04191469f, -0.42335957f, 
    -0.16077545f, -0.05785441f, -0.00186862f, -0.05212388f, -0.20420796f, 0.03147427f, -0.14006852f, -0.01048662f, 
    -0.49457452f, -0.08961358f, -0.23015475f, 0.36655354f, 0.07525509f, 0.04101700f, 0.16289183f, -0.03587311f, 
    0.07611305f, -0.12059314f, 0.23370193f, 0.18773630f, -0.13685119f, -0.13538170f, -0.17719561f, 0.11953074f, 
    -0.16143882f, -0.03356578f, 0.00308523f, -0.01111670f, 0.04076007f, -0.13591799f, -0.06975672f, -0.39524978f, 
    0.08257242f, 0.37082955f, 0.22585349f, -0.43473744f, 0.08826655f, 0.10466470f, 0.01256434f, -0.04902351f, 
    -0.08562283f, 0.06933556f, 0.01677933f, -0.36347601f, -0.40503389f, 0.12819067f, -0.02836598f, 0.26643467f, 
    0.02466080f, -0.00449283f, -0.02292084f, -0.05387737f, -0.04647841f, -0.10534705f, -0.12784739f, -0.13607123f, 
    -0.24277560f, -0.35944515f, 0.04006738f, -0.10857097f, -0.11737464f, 0.03373311f, 0.00338486f, 0.09939265f, 
    -0.12033327f, -0.06496827f, -0.05717722f, 0.06803937f, -0.06311103f, -0.09106623f, -0.22345370f, -0.36277458f, 
    0.01607986f, -0.01659444f, -0.03636971f, -0.15221448f, -0.04111905f, -0.01594943f, -0.02894773f, 0.20365927f, 
    -0.06294115f, 0.20453590f, 0.06440858f, 0.16992818f, -0.13688698f, -0.15170632f, -0.06771682f, 0.01158383f, 
    -0.12081452f, 0.12115739f, -0.05127144f, 0.02656677f, -0.21792468f, -0.03424285f, 0.19252379f, -0.13146760f, 
    -0.06763405f, -0.01086066f, 0.06926076f, -0.02959727f, 0.19646710f, -0.05262777f, 0.23285185f, -0.15273753f, 
    -0.47994223f, 0.20829463f, 0.04439037f, -0.12326685f, 0.11117492f, -0.04313510f, -0.02093641f, 0.03958380f, 
    -0.02371095f, 0.03233167f, 0.15048523f, 0.03025840f, 0.07332511f, -0.35673064f, -0.15732422f, -0.01494191f, 
    -0.03427973f, -0.12441380f, 0.10666769f, 0.00466067f, -0.03835722f, 0.02551826f, -0.08559602f, 0.20970868f, 
    -0.08376089f, 0.13665681f, 0.03631989f, -0.17559317f, 0.20958084f, -0.12964328f, 0.02548426f, 0.12231813f, 
    0.12740870f, -0.07495502f, -0.25183579f, -0.03634163f, 0.32948300f, -0.15704876f, 0.25882322f, 0.18318996f, 
    -0.11985654f, 0.06143177f, 0.12427431f, -0.00804280f, 0.13357078f, -0.03445030f, -0.06153885f, -0.07542230f, 
    0.64359814f, -0.34862125f, 0.02092691f, 0.20569612f, -0.07902429f, 0.11091059f, 0.00522323f, 0.06536275f, 
    -0.12306840f, 0.06221072f, 0.06532672f, -0.04399162f, 0.05030375f, -0.03909576f, 0.03008889f, -0.14333962f, 
    -0.14017649f, 0.12281238f, 0.08395438f, -0.00706645f, 0.14611307f, -0.04374424f, -0.03951474f, -0.11067792f, 
    -0.00803181f, 0.22599837f, 0.10519250f, 0.24950212f, 0.18159483f, -0.02994313f, 0.08987106f, -0.06112124f, 
    0.00022450f, -0.04972246f, -0.00872785f, -0.11199722f, 0.08773666f, 0.13347358f, -0.30466682f, 0.16387270f, 
    -0.10747152f, 0.00711638f, 0.05108371f, -0.05274952f, -0.06557144f, -0.03499742f, 0.20556088f, -0.02016024f, 
    0.03839346f, -0.12274274f, -0.16608296f, -0.20559844f, -0.03026095f, 0.04421135f, -0.08198782f, -0.10133138f, 
    -0.13673915f, -0.01151916f, -0.05114469f, 0.00858081f, -0.18931122f, 0.09562064f, -0.17362182f, -0.02740107f, 
    -0.10687799f, 0.08212332f, -0.08273134f, -0.06455591f, 0.07032885f, 0.06789174f, -0.09177501f, -0.06061083f, 
    0.24094084f, 0.13855439f, 0.03655529f, 0.30147898f, 0.30403841f, 0.00251971f, -0.03353812f, -0.09391199f, 
    -0.04245052f, -0.13699239f, -0.06983649f, -0.06858596f, -0.35495487f, -0.04139803f, -0.05351358f, -0.23528583f, 
    0.09185798f, -0.03017297f, -0.00242631f, -0.13444857f, -0.13372071f, 0.02512416f, 0.00069153f, -0.08016468f, 
    0.00961998f, 0.23457411f, -0.06649850f, 0.06672896f, 0.00542057f, 0.00103310f, 0.10248165f, -0.08809394f, 
    -0.17316566f, 0.08473548f, 0.00801522f, -0.08378424f, 0.28165081f, 0.16760612f, 0.33881864f, 0.16520071f, 
    0.04505303f, -0.00350344f, 0.09154706f, 0.00683385f, -0.05040948f, 0.16443072f, 0.00669716f, -0.05682928f, 
    0.16185370f, -0.10937744f, 0.11289553f, 0.08010184f, -0.19625267f, 0.02161796f, -0.10563097f, -0.08427955f, 
    -0.04654207f, -0.04406289f, 0.01807009f, 0.07666435f, 0.42863381f, -0.04110876f, 0.09286091f, -0.07771476f, 
    -0.11077718f, 0.09763028f, -0.05405758f, -0.11839607f, -0.05014849f, 0.02721488f, 0.11026730f, 0.01155137f, 
    -0.00091346f, -0.25970572f, -0.12360407f, 0.12719646f, -0.13505760f, -0.15734878f, -0.00205524f, -0.07284801f, 
    0.00575436f, -0.05237939f, -0.18503664f, 0.05893008f, 0.07714886f, 0.34464368f, 0.21016143f, 0.07429598f, 
    0.09671603f, -0.01984998f, 0.08244558f, -0.15225860f, -0.09543660f, 0.03012191f, -0.01668705f, -0.08382868f, 
    0.04671789f, 0.12160999f, 0.21991791f, 0.11172258f, -0.02171958f, 0.08395056f, -0.01646291f, -0.01144012f, 
    -0.04948987f, 0.15361173f, -0.10536951f, -0.02891781f, 0.01696241f, 0.10717282f, -0.30013040f, -0.08855218f, 
    -0.06745086f, 0.03925070f, -0.00643246f, -0.09142607f, -0.15504056f, -0.11824201f, -0.11708283f, -0.13789026f, 
    -0.34581754f, 0.23062222f, -0.05375144f, -0.25760004f, -0.05477243f, 0.02730730f, 0.02431793f, -0.10859194f, 
    -0.11580206f, -0.01299316f, 0.12464742f, 0.02505744f, 0.17874366f, -0.68661338f, 0.25084600f, 0.12791076f, 
    -0.16229139f, -0.14507616f, -0.05662491f, -0.03813923f, -0.07508507f, 0.08373197f, -0.06507654f, -0.11219294f, 
    -0.08380483f, 0.10160418f, 0.01381384f, 0.30986953f, -0.11746355f, -0.10689801f, 0.01149020f, -0.04597982f, 
    -0.18973395f, 0.07825773f, 0.11305937f, 0.03760211f, -0.27137393f, 0.15465187f, -0.02926680f, 0.09277374f, 
    -0.05484047f, 0.00436088f, 0.05235576f, -0.08487108f, 0.02090177f, -0.00349541f, -0.02761297f, -0.17410505f, 
    0.14707385f, 0.18095322f, -0.12123183f, 0.13902764f, 0.11166415f, 0.10870515f, -0.16993472f, -0.07026796f, 
    0.01406366f, -0.03329825f, 0.06714645f, -0.01541175f, -0.03587679f, -0.17534618f, 0.06169114f, 0.01461983f, 
    -0.13957286f, -0.04676260f, -0.05711091f, -0.04053476f, -0.03075605f, -0.03591592f, -0.08335087f, -0.01454369f, 
    -0.07690620f, -0.06847789f, -0.16028723f, -0.21043037f, -0.04401429f, 0.02435645f, 0.09786964f, -0.08879425f, 
    -0.08285629f, 0.05309165f, -0.02705039f, -0.04267414f, 0.29705659f, -0.01383549f, -0.00488350f, 0.21455786f, 
    0.04267256f, -0.01842106f, 0.07458583f, -0.09969319f, -0.02142492f, -0.00097084f, -0.10819775f, -0.15117075f, 
    -0.18084915f, 0.25938025f, 0.07530606f, -0.12183703f, -0.04659553f, -0.04916179f, -0.07984325f, -0.03252043f, 
    -0.01408709f, 0.02013185f, -0.08499035f, -0.14847760f, 0.12443290f, -0.00687772f, 0.13793688f, 0.10068014f, 
    -0.08496641f, 0.03373071f, -0.04609484f, -0.04999253f, -0.11206981f, -0.03601117f, -0.17170453f, -0.01561127f, 
    -0.09247476f, -0.12861805f, -0.14857890f, -0.33581376f, 0.03595404f, -0.17306793f, 0.01422019f, -0.13123143f, 
    -0.10344145f, -0.01038826f, -0.14561886f, -0.02743340f, -0.09040891f, -0.05038372f, 0.02930221f, -0.24524161f, 
    -0.04692751f, -0.04317645f, -0.09900563f, 0.05143209f, 0.03657778f, -0.03717563f, -0.00752087f, 0.04472971f, 
    -0.61173254f, 0.16730216f, -0.14867429f, -0.10240670f, -0.22771810f, -0.03123637f, -0.01792596f, -0.11193785f, 
    -0.05149867f, -0.02284686f, -0.09023779f, 0.01509380f, 0.07086056f, 0.06848515f, 0.14866091f, 0.03413878f, 
    -0.08247912f, -0.08041465f, -0.00677070f, -0.04287952f, -0.01296878f, 0.12286046f, -0.06241811f, -0.05482538f, 
    -0.10719353f, -0.26887155f, -0.18311536f, 0.02601177f, 0.01489238f, -0.13685545f, -0.07540782f, 0.03343652f, 
    -0.04793210f, -0.10399564f, 0.09351890f, -0.03838170f, -0.01848479f, -0.03128836f, -0.21648437f, -0.13342844f, 
    0.03555725f, 0.08484433f, -0.00713235f, 0.08373103f, 0.04427961f, -0.04226919f, -0.04155560f, -0.00842295f, 
    0.17186941f, 0.06479220f, -0.01444192f, 0.24056180f, 0.16630949f, 0.08679353f, 0.03661424f, 0.06383438f, 
    0.03970283f, -0.08316623f, 0.02736278f, -0.11219414f, 0.27584469f, -0.16885878f, 0.23340562f, 0.08205414f, 
    0.04557309f, -0.01524601f, -0.02349257f, -0.14337096f, 0.03503222f, 0.06882406f, 0.00368515f, -0.13204747f, 
    -0.10772504f, 0.21008810f, 0.15719673f, 0.19448230f, -0.08842520f, -0.01344893f, -0.25395378f, 0.00606752f, 
    -0.06695908f, -0.07115444f, 0.07211326f, -0.00588887f, 0.07243381f, -0.30012420f, -0.01510174f, -0.25135070f, 
    0.12498115f, -0.06814775f, -0.06923643f, 0.04296459f, 0.00366127f, -0.07380670f, 0.00249921f, -0.02631520f, 
    0.26452252f, -0.06815498f, -0.01213815f, 0.12953843f, 0.13253452f, -0.16325881f, -0.07696796f, -0.07671988f, 
    -0.02176268f, 0.05706303f, -0.30323115f, 0.09357446f, 0.13147001f, 0.34111726f, -0.14326821f, -0.00812658f, 
    -0.06687192f, -0.09591814f, 0.02963344f, -0.10297083f, 0.04072086f, 0.03165399f, 0.13711299f, 0.03164611f, 
    0.06735978f, -0.26866972f, 0.27862960f, -0.23915659f, 0.05851517f, -0.06751499f, 0.09756215f, -0.16036704f, 
    -0.07667713f, 0.10254477f, 0.06403977f, -0.01347810f, 0.09089337f, -0.31375450f, 0.11122043f, 0.33269981f, 
    0.07522579f, 0.03195432f, -0.07872565f, -0.04289224f, 0.02273434f, -0.10445572f, 0.16414815f, -0.11526855f, 
    -0.17634742f, -0.18047068f, 0.18493058f, 0.07316157f, -0.00283492f, -0.18176460f, -0.11396255f, 0.08772231f, 
    -0.00068854f, 0.13195594f, 0.02439561f, -0.31290144f, -0.19130562f, -0.02346803f, 0.21323486f, -0.26126724f, 
    -0.08869156f, -0.01711924f, 0.05101253f, 0.07333338f, 0.12021479f, -0.09466943f, -0.27876315f, -0.00663316f, 
    -0.15285842f, -0.08435962f, -0.06159383f, -0.37039840f, 0.11673971f, 0.01233196f, -0.09402880f, -0.09415313f, 
    0.08409356f, 0.20435631f, 0.09517643f, -0.08218038f, -0.16049887f, -0.10971599f, 0.18341817f, -0.01365825f, 
    0.04879957f, -0.13304989f, 0.01351318f, 0.21607982f, 0.01957288f, 0.14288433f, -0.04998131f, 0.04049798f, 
    -0.13089581f, 0.12230913f, -0.29367018f, -0.09543417f, -0.09967435f, 0.04208370f, -0.13160229f, -0.13068840f, 
    0.19918562f, -0.08540752f, 0.07047267f, 0.08262704f, 0.14562133f, -0.10047205f, 0.12792283f, 0.06105664f, 
    -0.07186729f, 0.04553826f, -0.10741114f, -0.05009859f, 0.07337013f, -0.12191352f, 0.05812659f, 0.20051375f, 
    -0.00330420f, -0.18782862f, 0.36583212f, 0.11177543f, -0.01801261f, -0.06982619f, -0.02153257f, -0.14234759f, 
    -0.00302903f, 0.03865139f, -0.08689143f, -0.27726090f, -0.23602186f, -0.07192240f, 0.03025046f, 0.06886023f, 
    -0.04232349f, -0.09040394f, -0.01355778f, 0.12076761f, 0.01579965f, 0.03456546f, -0.07209548f, -0.24056710f, 
    0.14688954f, 0.01686905f, -0.02021218f, 0.19373424f, 0.10150781f, -0.14065716f, -0.15452458f, 0.07648633f, 
    0.20169359f, -0.00926170f, 0.10117897f, -0.17723523f, -0.09689257f, -0.34616965f, -0.07358595f, 0.08855310f, 
    0.03451043f, 0.00210588f, 0.00951530f, -0.05915757f, 0.10846820f, 0.13981313f, 0.13876088f, 0.13766335f, 
    -0.27941424f, -0.23122878f, -0.22634131f, -0.14128900f, -0.13956153f, -0.29677615f, -0.09580669f, 0.08781026f, 
    0.11453818f, 0.07235728f, -0.04598162f, -0.27387732f, -0.55427659f, -0.03390271f, 0.05169334f, 0.04879163f, 
    -0.00837596f, -0.14962012f, -0.12436418f, 0.25751144f, 0.12560940f, 0.02240931f, -0.05739089f, 0.12698258f, 
    -0.34572670f, 0.20553459f, -0.36315599f, -0.33622476f, 0.01036854f, 0.02379776f, -0.19353749f, 0.07989001f, 
    0.10108580f, 0.05640373f, -0.10025198f, -0.15650575f, -0.11924358f, 0.19956723f, -0.25246292f, -0.01180815f, 
    -0.12662543f, 0.02228402f, -0.17941980f, -0.11818074f, 0.03163015f, 0.01766908f, 0.12388638f, 0.18607639f, 
    -0.11343227f, -0.45736343f, 0.11666317f, 0.17586249f, -0.05464265f, -0.06380756f, 0.00585187f, -0.04036976f, 
    0.04415635f, -0.02751266f, 0.19619587f, 0.05270396f, 0.17557150f, -0.04583107f, -0.06818153f, -0.32497814f, 
    -0.07687748f, -0.17950451f, 0.17788783f, -0.11327945f, 0.02567565f, 0.09247989f, 0.05789143f, 0.19497883f, 
    0.50440460f, -0.14914408f, 0.19493207f, 0.14195165f, -0.19047779f, -0.15195015f, -0.04122925f, -0.05410863f, 
    0.07128660f, 0.00581255f, -0.03108981f, -0.11467621f, -0.24309200f, 0.16905546f, -0.15825227f, -0.29076594f, 
    0.00982567f, 0.07768020f, 0.08066183f, -0.07955090f, -0.02026738f, -0.12263527f, -0.10788336f, -0.36607090f, 
    0.18243027f, -0.09859599f, -0.25278059f, 0.11224503f, 0.18824981f, -0.00234140f, -0.03603271f, -0.08729348f, 
    -0.05015027f, -0.10298751f, 0.04484483f, -0.03770596f, -0.29714581f, 0.12849136f, 0.13786547f, 0.08188803f, 
    -0.05010751f, -0.08567020f, -0.01310408f, -0.01779511f, -0.05634120f, 0.14536901f, -0.24470693f, 0.09605367f, 
    0.23312578f, -0.06921691f, 0.14979132f, 0.19313931f, 0.09327825f, 0.21129711f, 0.01050409f, -0.12795095f, 
    -0.04978814f, -0.15665114f, 0.12496221f, 0.06961199f, -0.18016089f, 0.23533751f, -0.19014546f, -0.43116540f, 
    -0.13241205f, -0.00627300f, 0.08706894f, 0.16571790f, 0.13932255f, -0.08420485f, 0.08417168f, -0.05819426f, 
    0.11922787f, -0.21885034f, -0.32599863f, -0.02841956f, 0.21655804f, -0.11776262f, 0.01376296f, -0.06769901f, 
    0.10545845f, 0.05472853f, 0.11704777f, 0.06765626f, 0.08631840f, -0.17425062f, 0.05874146f, 0.04364827f, 
    0.05533364f, -0.04845604f, -0.03454992f, -0.04552053f, -0.02356172f, 0.07539082f, 0.00830643f, -0.07027078f, 
    0.26925007f, -0.08280514f, 0.05604666f, -0.04643252f, -0.08504418f, 0.06858590f, 0.10349781f, 0.10985190f, 
    0.01056480f, -0.21915871f, 0.05299728f, -0.04583049f, -0.26788774f, -0.31182817f, 0.17659861f, -0.21553691f, 
    -0.00683132f, -0.00615307f, 0.09446834f, -0.22290815f, -0.02115884f, 0.00238351f, 0.09200907f, 0.25144705f, 
    -0.39999428f, -0.40443245f, 0.38359296f, -0.07720035f, 0.08126018f, 0.04586909f, 0.00335436f, 0.19409122f, 
    0.00031552f, -0.12213863f, -0.09929963f, 0.00189800f, 0.18309410f, -0.05475718f, 0.11282858f, -0.07832878f, 
    -0.01572409f, 0.04155755f, -0.00769483f, -0.19146776f, 0.06702394f, -0.00243134f, 0.04235756f, 0.05547826f, 
    0.29864502f, -0.21043408f, 0.06700040f, 0.05011193f, 0.03504092f, 0.04798308f, -0.06462827f, -0.13604259f, 
    0.06042774f, -0.07228158f, 0.15534197f, 0.09562911f, -0.19944453f, 0.72172415f, -0.12943369f, 0.19893819f, 
    0.20507593f, 0.01792594f, -0.19859046f, 0.16403647f, -0.06827883f, -0.04348789f, -0.13865331f, -0.02313092f, 
    -0.27462417f, 0.02590992f, -0.26166719f, -0.06114375f, 0.03117330f, -0.09904744f, 0.11094601f, 0.00668511f, 
    -0.04811618f, -0.04393362f, 0.04656229f, -0.09901775f, -0.35396186f, 0.22181155f, -0.04375207f, -0.34968626f, 
    0.06951342f, -0.07165514f, -0.11508821f, -0.04148419f, -0.07496858f, -0.08347625f, 0.01610872f, 0.06853810f, 
    -0.57802576f, 0.09757230f, -0.07590039f, -0.13702458f, -0.00796427f, 0.01427567f, 0.25289139f, -0.06029717f, 
    -0.02629672f, 0.11527123f, -0.00439966f, 0.22665749f, 0.03531009f, -0.00905746f, -0.01134104f, 0.15453565f, 
    -0.02366270f, 0.05959874f, -0.03859001f, 0.08388320f, -0.15083244f, 0.09731998f, -0.00745682f, -0.00758745f, 
    -0.16127464f, -0.28914106f, -0.26381743f, -0.20777561f, -0.11320446f, -0.03294377f, 0.13768329f, -0.15868951f, 
    0.03597117f, 0.07452454f, -0.01229831f, 0.09120969f, 0.42526156f, 0.25310078f, 0.02151109f, 0.00636180f, 
    -0.03615388f, -0.02254471f, -0.05429623f, 0.02026464f, -0.02063970f, 0.05765042f, -0.06796593f, 0.11197212f, 
    0.24066432f, 0.21696632f, -0.53319800f, -0.03691365f, 0.02762461f, -0.02086913f, 0.16891842f, -0.07723847f, 
    -0.10916156f, -0.02346043f, -0.08487567f, 0.25958440f, -0.41793728f, -0.54919207f, -0.15663710f, 0.10743563f, 
    0.16224307f, -0.00580432f, 0.00851030f, -0.06642953f, -0.01678631f, 0.17440660f, 0.08740289f, -0.05267677f, 
    0.33792576f, -0.15899886f, 0.00928088f, 0.13784099f, 0.07504182f, -0.04486549f, -0.13151269f, 0.09730007f, 
    0.00425535f, 0.20673451f, 0.00908171f, -0.00120190f, -0.44643170f, 0.15791818f, 0.01612102f, -0.20795001f, 
    0.03707746f, 0.05939594f, 0.15174599f, -0.15896268f, -0.01861814f, 0.01307429f, 0.11993887f, 0.04909458f, 
    -0.27404445f, 0.25202987f, -0.12370431f, -0.41049689f, 0.10813215f, -0.08696043f, -0.06509008f, 0.03763359f, 
    -0.12666713f, -0.18947364f, 0.01820557f, -0.13085157f, 0.23903897f, -0.48586768f, -0.24797353f, -0.37449670f, 
    -0.11013648f, 0.02464909f, 0.05332477f, -0.00511542f, 0.03707537f, -0.10432383f, 0.09396599f, -0.08403195f, 
    -0.38877332f, -0.02679932f, 0.09653678f, -0.37206098f, -0.09750473f, 0.09402873f, 0.00558928f, -0.16455933f, 
    0.00940843f, -0.15273081f, 0.01542388f, 0.11638198f, -0.02794572f, 0.06757997f, 0.08401334f, 0.35260302f, 
    0.15149677f, 0.19643708f, -0.00375201f, 0.06013809f, 0.08707965f, -0.02940008f, 0.20563214f, -0.05231162f, 
    -0.11151882f, 0.19105364f, 0.20112163f, 0.21428142f, -0.05637468f, 0.02843514f, -0.12322093f, 0.08405519f, 
    0.10346699f, -0.03129764f, 0.12171052f, 0.02547027f, 0.16765288f, 0.18141922f, -0.25358382f, 0.10496491f, 
    0.00506792f, -0.11636755f, -0.01031298f, 0.02840087f, 0.07508155f, -0.04803003f, -0.08105367f, -0.20229241f, 
    -0.07988004f, 0.08959687f, 0.05276720f, -0.36020541f, -0.03305629f, 0.04085619f, -0.10242032f, 0.00681054f, 
    -0.08580405f, -0.08138424f, -0.16489394f, -0.00171663f, 0.32190713f, 0.12861083f, -0.10241963f, -0.26541632f, 
    0.00512173f, -0.07270162f, -0.02968621f, 0.15805876f, -0.07599249f, 0.02088959f, 0.10462056f, 0.00783003f, 
    -0.72584420f, 0.42924887f, -0.04947822f, 0.06733025f, 0.28041345f, 0.03230041f, 0.11998349f, -0.05445094f, 
    0.00581133f, 0.00587366f, 0.12819606f, -0.01812234f, -0.23295426f, -0.08693281f, -0.24868256f, 0.17358439f, 
    -0.07880949f, 0.01971384f, 0.15757352f, 0.01026964f, -0.08747589f, 0.05580840f, -0.06917928f, 0.21528573f, 
    0.06929950f, 0.19630185f, -0.00169587f, -0.36676109f, 0.09859615f, 0.17202871f, 0.05421748f, -0.07122545f, 
    -0.09564857f, -0.01921009f, -0.01956813f, 0.01578010f, -0.24750721f, -0.23652090f, -0.08983153f, -0.02594473f, 
    0.00934088f, 0.05194209f, 0.06979459f, -0.12821391f, 0.14675336f, -0.09751470f, 0.08263641f, 0.03243645f, 
    -0.50676173f, 0.40950930f, 0.00302811f, -0.34314802f, 0.07421066f, 0.17361756f, 0.01426097f, -0.09480292f, 
    -0.24315709f, -0.17403005f, -0.06600028f, -0.19364055f, 0.18998042f, 0.23953801f, -0.40503883f, 0.26793703f, 
    0.09804810f, -0.01528306f, -0.00534617f, 0.03734549f, -0.20965549f, -0.08772005f, -0.06811104f, 0.11496467f, 
    -0.04035734f, 0.25979137f, 0.21955357f, -0.25795642f, 0.02085529f, 0.07434336f, -0.05143957f, -0.06586768f, 
    -0.15078995f, -0.14782959f, -0.02930916f, -0.17200607f, -0.10411406f, 0.13802288f, 0.04351806f, -0.10713297f, 
    -0.03507770f, -0.02733341f, -0.01214907f, 0.06255890f, 0.25540504f, 0.08714511f, 0.03776302f, -0.09691147f, 
    0.03380285f, 0.09584871f, 0.03506889f, 0.04093067f, 0.16315177f, -0.05961031f, -0.09400727f, -0.12577985f, 
    0.01830659f, 0.06606757f, 0.18597403f, 0.23227412f, 0.14238666f, -0.16621748f, -0.18799168f, 0.24912241f, 
    -0.04652548f, -0.03412946f, 0.09723794f, -0.01212789f, 0.04671875f, -0.15031146f, 0.20808025f, -0.21388820f, 
    0.22368462f, 0.11724851f, 0.10194375f, -0.13152760f, -0.18591543f, -0.06003809f, 0.02127881f, 0.05450103f, 
    -0.10864002f, 0.05379728f, -0.00295158f, -0.00899036f, -0.40656686f, 0.06276976f, 0.33396599f, 0.01031502f, 
    0.21181458f, 0.09997255f, 0.10924004f, -0.00782438f, 0.03413764f, 0.04147726f, -0.19790609f, 0.24820538f, 
    -0.39813429f, -0.08279256f, -0.16366346f, -0.13051745f, 0.12871774f, 0.14285766f, -0.05871666f, -0.18551724f, 
    -0.03547547f, -0.21135768f, -0.08126342f, 0.04151098f, 0.10223458f, -0.03597308f, -0.08239010f, 0.10578387f, 
    0.05149966f, -0.07162119f, 0.15803419f, -0.01855733f, 0.04542891f, 0.18448025f, 0.12779804f, 0.02833557f, 
    -0.02915657f, 0.08885589f, -0.15186083f, 0.06530286f, -0.00073922f, -0.06648063f, 0.15770204f, -0.06735205f, 
    -0.16947025f, 0.00826996f, 0.05516989f, -0.11587612f, -0.55433041f, -0.19402400f, -0.24065410f, -0.31989029f, 
    0.01173715f, -0.07574508f, -0.18464638f, -0.00913212f, 0.00068756f, -0.00127863f, -0.15087205f, -0.08991732f, 
    -0.31936416f, -0.44079235f, 0.20942581f, -0.04979577f, 0.05524189f, -0.12738813f, -0.02999499f, 0.03320242f, 
    -0.01993621f, -0.05257916f, -0.12526649f, -0.13091926f, 0.32185483f, 0.07469591f, 0.04833017f, -0.01562811f, 
    -0.08465101f, -0.03012641f, -0.01105113f, -0.18986954f, 0.15680952f, 0.01095826f, 0.02576087f, -0.07705425f, 
    0.36748296f, 0.31459969f, 0.08291008f, -0.17266896f, 0.17959343f, 0.08139022f, 0.09895889f, 0.02971673f, 
    0.09078462f, 0.01343569f, -0.07244477f, -0.08597222f, -0.27114159f, 0.26372707f, 0.08851723f, -0.20310494f, 
    0.04002624f, -0.11327595f, -0.15668434f, -0.07199303f, -0.09254155f, 0.09630132f, 0.04570869f, 0.09685070f, 
    -0.03940130f, 0.02910341f, 0.15018836f, -0.03445209f, -0.01431436f, 0.06758700f, -0.08695590f, 0.02323783f, 
    0.06960763f, 0.10861035f, 0.08008713f, -0.10302509f, 0.11415985f, 0.16802450f, -0.08121071f, -0.08417762f, 
    -0.00954184f, -0.10178903f, 0.12202433f, 0.01566007f, -0.03893137f, 0.08387463f, 0.08679930f, -0.00307454f, 
    0.45174342f, 0.06249835f, -0.03877237f, -0.03736490f, -0.09778773f, -0.13036060f, 0.02954666f, 0.02248485f, 
    0.04221504f, 0.09557112f, -0.13210027f, -0.09925314f, 0.11218747f, -0.08681196f, 0.02817375f, 0.07035507f, 
    0.00308470f, -0.12049482f, 0.04857377f, 0.03133019f, 0.03974528f, 0.03230765f, -0.08831488f, 0.03312464f, 
    -0.83523679f, -0.16802002f, -0.28060180f, -0.64930832f, 0.24687739f, -0.05680203f, -0.24665724f, 0.00553915f, 
    0.08371999f, -0.07808321f, 0.08836146f, 0.11736563f, -0.41248393f, 0.29793414f, -0.16129786f, -0.26885164f, 
    0.04477122f, -0.02090166f, -0.06447745f, 0.06436000f, 0.08528885f, 0.02943230f, 0.09010250f, 0.14751312f, 
    -0.28624785f, 0.08636309f, -0.04338754f, 0.09114683f, 0.19456299f, -0.01586996f, -0.04727010f, -0.04106934f, 
    0.12702154f, 0.00674894f, -0.08662757f, -0.16973448f, 0.18321367f, 0.18133664f, 0.01425728f, 0.05690249f, 
    0.09460369f, -0.24319239f, 0.08622466f, -0.06949341f, 0.12070391f, 0.05926388f, -0.01295406f, 0.00535809f, 
    -0.50483108f, -0.27854350f, 0.27864856f, -0.12234427f, 0.03285953f, 0.12461486f, 0.07736114f, -0.08406150f, 
    -0.03586509f, -0.17994623f, -0.28547278f, 0.04822625f, 0.26135984f, 0.04984191f, -0.24503750f, 0.03419485f, 
    -0.08702078f, 0.09610251f, 0.13637038f, -0.12886685f, 0.06517359f, 0.20221025f, 0.14337103f, 0.07509729f, 
    -0.55868918f, -0.20358542f, 0.12349073f, -0.28253165f, 0.10240129f, -0.34685779f, 0.03895035f, 0.06451437f, 
    -0.01859783f, 0.00547373f, 0.07313029f, -0.01121940f, 0.05292426f, -0.02925317f, -0.00593048f, 0.30003971f, 
    0.00611473f, 0.10770978f, 0.18591227f, -0.11466722f, -0.02297590f, 0.10055390f, 0.09947799f, 0.15476775f, 
    0.03340849f, -0.36565062f, -0.28269804f, 0.10314920f, -0.02355949f, 0.05787848f, 0.04686556f, 0.07112154f, 
    -0.04952582f, -0.08358469f, -0.09073660f, 0.04703801f, 0.40118161f, -0.03254946f, -0.00387830f, -0.00606201f, 
    -0.06174589f, 0.09179894f, 0.12504032f, 0.06600469f, 0.01160992f, 0.14441474f, 0.00268331f, -0.19015478f, 
    -0.71328098f, -0.36266607f, -0.00723897f, -0.04680551f, 0.08745240f, -0.02124814f, -0.02861945f, -0.04275342f, 
    0.06883902f, -0.02203835f, 0.09631184f, 0.10941278f, 0.09602040f, -0.15049130f, 0.01717882f, 0.07179391f, 
    0.07959748f, -0.02268839f, -0.14149800f, 0.02386348f, -0.05802553f, -0.14106870f, -0.27643842f, 0.08080307f, 
    -0.72722965f, -0.42894375f, -0.07391489f, -0.11537835f, 0.00044807f, 0.12338974f, 0.14139715f, 0.04627636f, 
    0.18829070f, 0.08324521f, 0.05986680f, 0.12036079f, -0.17712833f, -0.31551796f, 0.12258299f, -0.07346341f, 
    -0.05527775f, -0.03820994f, -0.03258791f, -0.14444211f, 0.05529620f, -0.15994571f, -0.16337349f, -0.41724801f, 
    -0.13989763f, 0.23291092f, 0.24661832f, -0.09063073f, 0.05512810f, 0.01898792f, -0.09578879f, 0.11348647f, 
    0.01635567f, 0.14219540f, 0.05767046f, 0.17847522f, 0.02203211f, -0.12938496f, -0.01871749f, 0.13862084f, 
    -0.09973080f, -0.12510580f, -0.13371380f, -0.08402953f, 0.10441271f, 0.10070883f, 0.05442034f, 0.03171199f, 
    -0.02243022f, 0.10400091f, -0.23722656f, -0.00151520f, -0.18944162f, -0.05895389f, 0.07417048f, 0.08271116f, 
    0.11253994f, 0.05494706f, 0.07125699f, -0.02422890f, 0.24886844f, 0.15611067f, 0.02686654f, -0.06330911f, 
    0.08655243f, 0.19405325f, -0.00257408f, 0.03877956f, -0.13932589f, -0.11170811f, 0.05286002f, 0.19712774f, 
    0.08926199f, -0.19806883f, -0.03051668f, 0.07688753f, -0.19560018f, 0.09996615f, 0.04257530f, -0.07008166f, 
    -0.09188208f, 0.02176630f, -0.02748335f, -0.07066520f, 0.31989509f, 0.15704331f, 0.06775257f, -0.26753321f, 
    0.00516543f, -0.09318358f, -0.19876587f, 0.12220562f, 0.02822902f, 0.02603939f, -0.04142814f, 0.08716823f, 
    -0.26841557f, 0.16326702f, -0.21995032f, -0.36411083f, -0.04923864f, 0.07022768f, -0.10639880f, 0.16242112f, 
    0.09347579f, -0.03893286f, 0.04840216f, -0.15887706f, 0.29298958f, -0.06202319f, -0.09688954f, 0.29369479f, 
    0.14954005f, -0.02082641f, -0.07773052f, -0.00790368f, 0.00706295f, -0.06455611f, -0.00798201f, -0.04816271f, 
    -0.05482899f, 0.02219427f, -0.02099329f, 0.07432910f, -0.33922973f, 0.04929787f, 0.02301224f, 0.00898022f, 
    0.14988136f, -0.13282131f, 0.00318005f, 0.09834281f, -0.08255649f, -0.08934023f, 0.08137368f, -0.27860993f, 
    -0.04707357f, -0.03192176f, -0.05635519f, 0.02768457f, 0.01395697f, 0.00244474f, -0.20556392f, 0.01634562f, 
    -0.16211276f, 0.14420208f, -0.09242269f, -0.26838851f, 0.06730276f, -0.00104019f, -0.17890549f, 0.02076729f, 
    0.24843813f, 0.03003782f, 0.07403287f, 0.13023765f, -0.11313351f, 0.19676483f, 0.04218429f, 0.14623347f, 
    -0.05339263f, -0.16424355f, -0.01553618f, -0.11648494f, 0.01772578f, 0.12027771f, 0.04808098f, -0.12962221f, 
    0.02303142f, -0.04429559f, -0.28637519f, 0.02988737f, -0.13869570f, 0.05495207f, 0.05369878f, 0.20329240f, 
    0.11611864f, -0.02765176f, -0.00484672f, -0.06188991f, 0.04525121f, 0.08123244f, 0.11384577f, -0.59426618f, 
    0.17503060f, -0.05318046f, 0.00451544f, 0.00619930f, -0.02554192f, -0.17939629f, 0.04762369f, 0.00391068f, 
    -0.38374332f, -0.20290282f, -0.20699422f, 0.20820200f, -0.12120392f, -0.13790241f, -0.01268263f, -0.00858577f, 
    0.10182258f, 0.08477918f, -0.04465438f, 0.05405774f, 0.19041552f, 0.10711547f, 0.12191290f, -0.20697987f, 
    -0.12055611f, 0.00242483f, 0.13106906f, -0.00784616f, -0.02195889f, 0.06998970f, -0.19006893f, -0.17001444f, 
    -0.34924850f, 0.13943473f, 0.03905430f, 0.00048724f, 0.09059241f, 0.03711637f, 0.02457478f, -0.01541290f, 
    -0.06331919f, -0.04225945f, 0.10719758f, -0.09457216f, -0.09345768f, 0.09147011f, -0.22785440f, -0.11145018f, 
    0.21973138f, -0.02104981f, 0.00129724f, 0.05339177f, 0.02214673f, 0.02975060f, 0.09502665f, 0.16787037f, 
    0.00197447f, -0.21099116f, -0.08455587f, 0.17579032f, -0.02384166f, 0.05580698f, 0.05007543f, 0.03347000f, 
    -0.01861703f, -0.02810094f, -0.06952807f, -0.06821343f, 0.05450922f, -0.04987008f, -0.14062642f, 0.25703147f, 
    -0.02162010f, -0.05486326f, -0.02453409f, 0.04347714f, -0.07554130f, 0.05898103f, -0.11509012f, -0.04162946f, 
    0.31630120f, -0.34237069f, -0.15071845f, 0.10454062f, -0.11128499f, 0.02220746f, -0.11405967f, -0.19628280f, 
    0.11049908f, -0.08381563f, -0.00779220f, 0.03107660f, 0.32864279f, -0.17595649f, 0.10905591f, 0.26631501f, 
    -0.10500088f, -0.10692029f, 0.01033485f, 0.05014673f, -0.05189328f, -0.14154869f, -0.04528573f, -0.05530997f, 
    -0.27358311f, 0.54738289f, -0.07378460f, 0.00768066f, 0.07434490f, 0.08909816f, -0.15324046f, -0.07290734f, 
    0.11805049f, 0.04141440f, 0.10079939f, 0.07437045f, 0.05713044f, 0.12931252f, 0.04906297f, 0.06157778f, 
    0.16418259f, -0.10341696f, 0.03803819f, 0.08867923f, -0.25242609f, -0.18291064f, 0.12437601f, -0.00842289f, 
    0.13709912f, -0.09311103f, 0.04435252f, -0.38394046f, 0.02615017f, 0.00479523f, 0.06197792f, -0.02027846f, 
    0.00886192f, -0.18054546f, 0.04683103f, -0.13229877f, 0.10302682f, -0.07659590f, 0.14686282f, 0.10825256f, 
    -0.08834296f, 0.08606935f, 0.01814722f, 0.07228646f, 0.10387613f, -0.07031696f, -0.01193092f, -0.02759141f, 
    -0.31527975f, -0.52840090f, 0.05157362f, -0.16207154f, 0.09827234f, -0.03085068f, 0.18751712f, -0.05025389f, 
    0.04710284f, 0.04543735f, 0.03798541f, -0.00784336f, -0.03685578f, 0.15525024f, -0.02744252f, 0.04579768f, 
    0.09841584f, -0.01913994f, -0.08374335f, 0.02901898f, 0.02131980f, -0.00050516f, 0.03065565f, 0.12400737f, 
    0.49298039f, -0.36819813f, -0.16756551f, -0.16303135f, 0.12178177f, -0.01839484f, -0.04219850f, 0.00727671f, 
    0.11052836f, -0.00016697f, -0.08709837f, 0.00170072f, -0.00801366f, 0.17640895f, -0.07872052f, -0.02517577f, 
    0.01146795f, -0.13177824f, 0.15134270f, 0.01234207f, -0.04357225f, 0.02333350f, 0.03687247f, -0.00105718f, 
    0.32943329f, -0.19702964f, -0.11657261f, 0.08536831f, 0.12352007f, -0.03107666f, -0.08822614f, -0.02628181f, 
    -0.02957345f, 0.02247827f, -0.02563660f, -0.06768946f, -0.37107560f, 0.07294490f, -0.14881213f, -0.02007941f, 
    0.15743169f, 0.05702589f, 0.08762157f, -0.10648055f, -0.19650614f, -0.01419557f, -0.01568050f, 0.11672636f, 
    0.61809188f, 0.01092280f, -0.13994554f, 0.11988448f, -0.04233465f, -0.12022231f, -0.01277871f, 0.01698188f, 
    0.04611225f, -0.02083653f, 0.00522049f, 0.13654792f, 0.16223504f, 0.11185578f, 0.14409269f, 0.06280594f, 
    0.08390919f, 0.14628810f, 0.03719928f, -0.10316844f, 0.07549214f, -0.23901753f, -0.08988173f, 0.23003641f, 
    -0.62657714f, -0.13964029f, -0.04059924f, -0.15511334f, -0.12465099f, 0.21988386f, -0.12612243f, 0.01426493f, 
    0.01399641f, -0.00615494f, -0.02388669f, 0.06457057f, -0.24727426f, 0.31075871f, 0.01804297f, -0.22148289f, 
    -0.05380815f, 0.00547556f, 0.08385852f, -0.08770883f, -0.09334632f, 0.01872410f, -0.08123904f, -0.15451425f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06552659f, 0.00709157f, -0.10664489f, -0.04508802f, 0.04704186f, 0.03792935f, 0.02187764f, -0.12675580f, 
    -0.07709724f, 0.06397068f, 0.11142623f, -0.00066949f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
