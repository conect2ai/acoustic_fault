#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.12511337f, -0.27745897f, 0.18263456f, 0.74752986f, 0.45313832f, 0.79229808f, -0.50541323f, -0.32008937f, 
    0.41182768f, 0.20220067f, -0.08971046f, -0.22981618f, -0.20869155f, 0.64060283f, -0.49369767f, -0.15464750f, 
    0.02560323f, -0.19703515f, -0.00796432f, 0.23814726f, -0.14631489f, 0.02513078f, 0.01557936f, -0.02610954f, 
    -0.06457957f, -0.43773994f, 0.37949702f, 0.07807986f, 0.53103507f, 0.48531833f, 0.20309010f, 0.20119029f, 
    0.31982085f, 0.15885837f, 0.26832038f, 0.16646877f, 0.34366038f, 0.13221039f, -0.12505108f, 0.11792573f, 
    0.05782677f, 0.11028968f, 0.14606658f, -0.05998249f, 0.00117797f, -0.03677402f, -0.14656895f, -0.00352954f, 
    0.04030418f, -0.13045482f, 1.78613555f, -0.67756552f, -1.01290143f, -0.75109845f, -0.21673045f, 0.50059116f, 
    0.43380752f, 0.52863449f, 0.18484752f, -0.28931651f, 0.02077766f, 0.01968228f, 0.15968017f, -0.24721941f, 
    0.27629292f, -0.06296356f, -0.05953135f, 0.12737116f, -0.25087446f, -0.19428539f, 0.15781926f, -0.40283459f, 
    -0.39092994f, 0.13508856f, -0.28801447f, -0.78956443f, -0.47157124f, 0.08252326f, 0.24055324f, 0.22005129f, 
    -0.77022636f, -0.62670106f, 0.24403845f, 0.45182186f, 0.51231486f, 0.06303528f, 0.11585331f, 0.14350162f, 
    0.10807907f, -0.15468325f, 0.05809155f, -0.14716646f, -0.12817541f, 0.20764579f, -0.16989028f, -0.29956567f, 
    -0.33729437f, 0.07099457f, -0.50690287f, -0.40680492f, 0.81071782f, -0.10663247f, -0.69581264f, -0.45927411f, 
    -0.62365377f, 0.65478784f, -0.10220386f, 0.28002343f, 0.14458200f, 0.14420530f, -0.00097703f, 0.26226255f, 
    -0.30539545f, -0.14670090f, -0.11031876f, -0.31007704f, -0.32113343f, 0.76640546f, -0.26779011f, -0.36926702f, 
    -0.02959795f, -0.02272709f, 0.19894482f, 0.11161871f, 0.27138707f, -1.08164895f, 0.04460068f, -0.67809349f, 
    -0.52864581f, 0.31812379f, -0.20873493f, 0.19092050f, 0.58496767f, 0.61548042f, 0.60197169f, 0.11842918f, 
    -0.12900873f, 0.02958628f, -0.30533171f, 0.02415016f, -0.17380181f, -0.00715360f, 0.16475993f, -0.12400583f, 
    -0.11534014f, -0.01206776f, 0.11116745f, 0.03367978f, 0.00809841f, 0.03483724f, -1.28629327f, -0.43042165f, 
    0.19492905f, -0.14396012f, 0.37404662f, -0.58978075f, 0.33393967f, -0.20452258f, 0.07382400f, -0.18920571f, 
    0.07573269f, -0.22013818f, -0.36415234f, -0.26262379f, 0.09445570f, 0.15524545f, -0.10010333f, 0.19006118f, 
    0.15574762f, 0.13069855f, 0.18656343f, 0.22267462f, -0.06257850f, -0.15170288f, 0.27564403f, -1.45229626f, 
    0.57282513f, -0.31492424f, 0.56847644f, 0.32507944f, 0.23997667f, -0.34900102f, -0.14735007f, -0.05339549f, 
    0.09740369f, 0.56389886f, -0.64979666f, -0.37115067f, -0.01966390f, -0.01429787f, -0.26072779f, -0.38232496f, 
    -0.34551197f, 0.00810063f, -0.29824066f, -0.03037086f, -0.15220770f, -0.29008597f, -0.11005719f, -0.84683096f, 
    -0.35538030f, 0.10388902f, 0.26489836f, -0.17161916f, 0.06654731f, 0.40334916f, -0.06726492f, 0.26481000f, 
    -0.44790816f, 0.04455459f, 0.03269226f, 0.30231011f, 0.10979530f, -0.02351298f, -0.17212842f, -0.42225447f, 
    -0.01074914f, -0.67321366f, -0.01898646f, 0.87336737f, 0.24781001f, -0.04794783f, 0.22267024f, -0.00057983f, 
    -0.01853900f, -0.68786132f, -0.74042523f, -0.57313675f, -0.72531962f, -1.04277837f, 0.37236890f, -0.01293680f, 
    -0.04334889f, 0.15670660f, 0.52989429f, -0.34135276f, -0.23180597f, -0.21195285f, 0.25555879f, -0.32376406f, 
    -0.15059024f, 0.01311898f, 0.01535517f, -0.03467747f, -0.03350461f, -0.47765714f, -0.34007031f, -0.31371057f, 
    -0.36452958f, -0.36082420f, -0.17827103f, -0.82889330f, -0.94710833f, -0.86461610f, -0.03156846f, -0.01938836f, 
    -0.58661169f, -0.51457310f, -0.80355924f, -0.95612079f, 0.26405412f, 0.41878754f, -0.00661530f, 0.12660809f, 
    -0.38084182f, -0.12268227f, -0.71690315f, -0.07017348f, -0.39922407f, -0.27786601f, -0.48409581f, -0.17387933f, 
    0.01908023f, 0.21742937f, -0.30443579f, 0.63804412f, 0.13822545f, 0.39645755f, 0.23215042f, -0.65257782f, 
    0.10254037f, -0.21101370f, 0.26900643f, 0.22962932f, -0.08151061f, 0.23069224f, -0.23631661f, -0.16506241f, 
    0.05395964f, -0.24810258f, -0.18303826f, -0.23621355f, 0.02069924f, 0.03866753f, -0.00461351f, -0.31125313f, 
    -0.24988310f, -0.21515495f, -0.27448949f, -0.47229055f, -0.03151823f, -0.38372040f, 0.30054620f, 0.19502941f, 
    -0.46473590f, -0.77033567f, -0.58741575f, -0.44452688f, -0.07408459f, -0.53833646f, 0.00435520f, -0.07436237f, 
    0.17702119f, 0.37675264f, 0.36632425f, 0.12710543f, -0.09520070f, -0.39791492f, -0.19309650f, -0.40655196f, 
    -0.17305063f, -0.26821581f, 0.06033025f, -0.34609655f, -0.41309762f, 0.18657245f, -0.18973713f, 0.13310565f, 
    -0.07956684f, 0.32573548f, -0.08491199f, 0.29204881f, 0.60207200f, -0.10291023f, -0.32695246f, -0.32305491f, 
    -0.14322676f, 0.20476656f, -0.30280820f, -0.04617366f, 0.09403239f, -0.01832525f, -0.44997784f, -0.14232175f, 
    -0.22295797f, -0.16848157f, 0.20877720f, -0.13708094f, 0.11484016f, 0.18025182f, -0.19495691f, -0.68322259f, 
    -0.22350825f, 0.38623852f, 0.64054787f, 0.02427956f, -0.34524059f, -0.61508626f, 0.16084430f, 0.29122353f, 
    -0.12098434f, 0.30106899f, -0.22496215f, 0.27323818f, -0.22771922f, -0.01562104f, 0.22853631f, -0.22502436f, 
    0.11687473f, -0.45957586f, 0.24232250f, -0.00323953f, -0.11885304f, 0.40739787f, 0.38473684f, -0.37924117f, 
    -0.25477964f, -0.05383268f, -0.29038283f, -0.83575320f, -1.15801942f, -0.92156863f, -0.57302225f, -0.80622846f, 
    -0.49208638f, 0.44137743f, 0.15298082f, 0.57459182f, -0.02422377f, 0.16935100f, 0.04071157f, -0.06776019f, 
    0.06990889f, -0.02333662f, -0.03482606f, 0.14102079f, 0.42405245f, -0.12265582f, -0.10341843f, 0.19479088f, 
    -0.59212542f, -0.60031855f, -0.72439671f, -0.52154720f, -0.19504522f, 0.13331828f, 0.41889909f, 0.41581166f, 
    0.35271168f, -0.01323067f, 0.43529677f, 0.45921481f, 0.29502121f, -0.52956694f, 0.06918172f, -0.34677064f, 
    -0.30858395f, -0.09417898f, -0.44384870f, -0.43762255f, -0.22214057f, 0.53989202f, 0.33888876f, -0.09822470f, 
    0.58844137f, -0.69747835f, 0.20905288f, 0.05791437f, 0.27624905f, -0.22619399f, 0.34962463f, -0.12413619f, 
    0.01856265f, 0.17078483f, -0.16718711f, -0.28907588f, 0.03467540f, 0.54668736f, -0.72852623f, -0.12518999f, 
    0.17968743f, 0.37566048f, -0.03044043f, 0.16067626f, -0.29043493f, 0.18185276f, -0.04041260f, -0.55021846f, 
    0.09340794f, 0.32446763f, 0.16272199f, 0.25437611f, -0.09751913f, 0.12422694f, 0.50321364f, 0.26551470f, 
    0.10821003f, 0.25437295f, 0.04799965f, -0.22828570f, 0.30688342f, -0.11620535f, -0.30576682f, -0.14148891f, 
    0.48440823f, 0.02953270f, -0.35693544f, -0.33331797f, -0.13559747f, -0.18435755f, 0.00283474f, 0.32273677f, 
    0.01758705f, -0.31263000f, -0.06277402f, -0.75253683f, 0.45427325f, 1.05348861f, -0.68129551f, -0.58451688f, 
    0.62846428f, -0.31669828f, 0.07281985f, 0.23786265f, -0.21111995f, -0.17721222f, -0.04128544f, -0.14202191f, 
    0.26939750f, -0.17638476f, 0.21015932f, 0.06171208f, -0.00698747f, 0.31134447f, 0.06879013f, 0.05596361f, 
    0.02785734f, 0.14206725f, -0.12567285f, -0.04595862f, -1.12809348f, -0.45651215f, -0.78458881f, -1.14810610f, 
    -0.16872919f, 0.50432146f, -0.14654090f, -0.67743802f, -0.37075350f, 0.42269439f, -0.69037497f, -0.68243676f, 
    -0.23948932f, 0.10848348f, -0.45016521f, 0.18513069f, -0.10119087f, -0.05993578f, -0.09771325f, -0.46505639f, 
    0.10285441f, 0.42826420f, 0.32049137f, 0.13419975f, 0.01608387f, -0.01842713f, 0.20118017f, 0.33490610f, 
    -0.20615435f, -0.00977700f, 0.14667806f, 0.08650786f, 0.38118681f, -0.29244274f, -0.07387642f, 0.31484753f, 
    0.09575770f, 0.34798762f, -0.03311362f, -0.41538739f, 0.00183850f, -0.02857511f, 0.34259629f, 0.07368752f, 
    -0.27903113f, 0.34715316f, 0.00949600f, -0.41023535f, -0.24706453f, 0.43699318f, 0.25726965f, 0.57438576f, 
    0.09622800f, 0.11465683f, -0.41516528f, -0.30841619f, -0.35046071f, 0.15396367f, -0.21847723f, -0.15417568f, 
    0.31926608f, 0.37483445f, -0.29482040f, -0.18163362f, 0.43270671f, 0.21997243f, 0.04516223f, 0.18761672f, 
    -0.08866778f, -0.18107575f, 0.13678767f, -0.10921883f, -0.23255976f, 0.42485413f, 0.32321823f, -1.04174876f, 
    -0.96705860f, -0.42601383f, 0.21585828f, 0.65679562f, -0.50310123f, -0.57007641f, 0.03337595f, 0.26661146f, 
    0.34414965f, 0.14673251f, 0.03792658f, 0.36485267f, 0.42072344f, 0.34011626f, 0.28692105f, 0.14703228f, 
    0.00649155f, -0.35156724f, -0.12143280f, -0.01136299f, 0.10460625f, 0.13211977f, -0.20592172f, 0.03410438f, 
    -0.52372772f, -0.78060418f, 0.65580863f, 0.63232076f, 0.33549720f, 0.79343253f, -0.06055329f, -1.04351842f, 
    -1.03796542f, -0.72903156f, -0.19515455f, 0.33455926f, -0.57769948f, -0.53568441f, -0.52174276f, -0.43662834f, 
    -0.07963035f, 0.21994151f, 0.20449992f, 0.05960912f, 0.10318765f, -0.00843935f, 0.12839603f, -0.27316839f, 
    -0.26295784f, -0.47923332f, -0.63754821f, -0.00107823f, 0.31823665f, 0.42361510f, -0.63285249f, -0.63640904f, 
    -0.03316059f, 0.27765784f, -0.00016241f, -0.64527285f, -0.41134739f, 0.15192394f, -0.54410172f, 0.34899470f, 
    -0.17639644f, 0.08183759f, 0.27260566f, 0.01314592f, 0.11334261f, -0.46494940f, -0.30022117f, -0.37820822f, 
    -0.00944247f, 0.28451559f, 1.02028537f, 1.17194283f, 0.01125469f, 0.41148248f, 0.05099766f, -0.90141243f, 
    -0.65192622f, -0.27730972f, 0.24457288f, -0.06609748f, 0.23274212f, -0.04568456f, 0.12691993f, -0.23899011f, 
    -0.54748446f, -0.02167344f, 0.02615733f, 0.05591279f, 0.09472118f, -0.07898901f, 0.13192193f, -0.07762189f, 
    -0.07375601f, 0.13311140f, -0.16007264f, -0.37550294f, 0.19757751f, -0.93427664f, -0.27046287f, 0.56672657f, 
    0.53658795f, 0.62864661f, -0.02186872f, -0.51509798f, -0.27620959f, -0.03167592f, 0.35592830f, -0.31796429f, 
    -0.30372298f, -0.19540638f, 0.04333059f, -0.30388492f, 0.28639683f, 0.24549121f, -0.14040139f, -0.17427281f, 
    -0.40912148f, -0.61511093f, -0.20828706f, -0.32779509f, 0.47629309f, -0.45059994f, -0.06978924f, 0.01829938f, 
    -0.46943858f, 0.28152707f, 0.50801170f, 0.34079266f, -0.11183129f, -0.08644065f, -0.08032379f, -0.00843780f, 
    -0.15011065f, 0.31582588f, 0.06790423f, -0.05801148f, -0.12717965f, -0.27101484f, -0.57134253f, 0.19322501f, 
    0.07414247f, -0.34529662f, -0.11807821f, 0.24212001f, -0.21940197f, -0.35994908f, -0.37040785f, 0.23788770f, 
    0.00106679f, 0.18970850f, 0.19298466f, 0.10369821f, -0.32848340f, -0.34023720f, -0.16834836f, 0.67992127f, 
    0.38502938f, -0.25973567f, 0.68340087f, -0.68183810f, -0.18836138f, 0.25349343f, 0.11059990f, -0.17011124f, 
    -0.66806406f, -0.33611208f, 0.59296763f, 0.25421342f, -0.13786337f, 0.09546907f, -1.09834540f, -0.92221802f, 
    -0.53085554f, 0.17441046f, -0.33488739f, 0.65897751f, 0.25678474f, 0.12163834f, 0.41968301f, 0.58948386f, 
    0.23260903f, -0.09026338f, 0.13193098f, 0.14565063f, -0.01261619f, 0.10205000f, 0.07375003f, -0.18118396f, 
    -0.04103036f, 0.01357174f, -0.09015657f, -0.14785711f, 0.18737511f, 0.08552874f, -0.15438084f, -0.94557279f, 
    -0.32043174f, -0.37753302f, -0.49762687f, -0.05848271f, -0.32337233f, -0.81201959f, 0.04638643f, -0.23317572f, 
    -0.04927808f, -0.13301910f, -0.06582016f, 0.23356113f, -0.12671430f, -0.06915892f, 0.34843510f, -0.02500137f, 
    0.15303744f, 0.54677165f, 0.40123138f, 0.02567147f, -0.17551616f, -0.23917873f, -0.08883890f, 0.02863199f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.34309578f, -0.11742253f, 0.31291011f, 0.02726476f, 0.45008519f, 0.30112624f, 0.24763376f, -0.06815867f, 
    0.31554025f, 0.13726047f, -0.35704809f, 0.26466814f, 0.12207073f, 0.66074222f, 0.31973162f, 0.14820579f, 
    0.38054070f, 0.32232177f, -0.03494748f, 0.19839329f, -0.23340642f, 0.18072498f, 0.07287215f, 0.38108501f, 
    0.10060760f, 0.27948245f, 0.59018207f, -0.05241416f, 0.57663107f, 0.20318003f, 0.05118617f, -0.16298901f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.53791356f, -0.17276537f, 0.08216895f, -0.29195315f, -0.07062477f, -0.04620366f, 0.01801537f, -0.03774228f, 
    0.10949575f, 0.01752590f, -0.20699416f, -0.43758488f, 0.05432095f, -0.00778584f, 0.01481422f, 0.09873837f, 
    0.02030428f, 0.05152276f, 0.07034299f, 0.04830498f, -0.38454360f, -0.21299149f, -0.12220689f, -0.05438116f, 
    -0.12602068f, -0.56737870f, -0.70290136f, 0.10435338f, 0.02632889f, 0.01047081f, -0.04399292f, 0.01574510f, 
    0.05715450f, -0.03144245f, -0.14041662f, -0.00308681f, 0.20267753f, 0.20247675f, 0.16375324f, -0.04855398f, 
    -0.05582971f, 0.06242216f, 0.10776152f, 0.08958755f, -0.14009471f, -0.07800892f, 0.00940096f, 0.18835223f, 
    -0.22630534f, -0.69063091f, -0.61644959f, 0.00417794f, -0.00339938f, 0.03531133f, -0.18644594f, -0.00936698f, 
    -0.10364613f, -0.04746092f, -0.33834651f, 0.03604156f, -0.31178153f, 0.06311020f, 0.04638743f, -0.07353390f, 
    0.01736185f, 0.10032272f, 0.14357331f, 0.00693328f, 0.02756746f, 0.01506332f, -0.00520229f, -0.10383079f, 
    0.41471118f, 0.15660061f, 0.07727711f, -0.39444005f, -0.08554130f, 0.18044733f, 0.17491950f, 0.07219925f, 
    -0.02597460f, 0.04559926f, -0.01694952f, -0.00107086f, 0.09471171f, 0.15096134f, 0.25465885f, -0.09200314f, 
    -0.10220113f, -0.01347223f, -0.01551589f, 0.00599744f, -0.17126009f, -0.15594724f, 0.03434507f, 0.21590205f, 
    -0.09767255f, -0.11016679f, 0.08933515f, -0.05477226f, -0.05509435f, -0.15285580f, -0.00808292f, 0.06900370f, 
    -0.23230681f, -0.10518660f, -0.03166183f, -0.28584924f, 0.24586652f, 0.16128778f, 0.02065824f, -0.24262294f, 
    0.08000799f, 0.14039795f, 0.04264642f, 0.05953174f, -0.02571339f, 0.03652974f, 0.00072014f, 0.03575855f, 
    0.51180160f, 0.25219980f, -0.41698512f, -0.19062860f, 0.08054014f, 0.05771783f, 0.01589371f, 0.11033400f, 
    -0.15189180f, -0.18830085f, -0.18702863f, -0.01709652f, -0.48022258f, -0.30787829f, -0.08819821f, -0.00716963f, 
    -0.00414816f, 0.04273703f, 0.02405607f, 0.00954717f, -0.12338148f, -0.14164092f, 0.00160732f, 0.23319459f, 
    0.10441576f, -0.01292775f, 0.05512644f, -0.32478404f, -0.24565624f, -0.06271563f, -0.24952246f, 0.03082946f, 
    0.03130611f, -0.09892517f, -0.05294872f, -0.02943941f, -0.30340785f, -0.60464633f, -0.13255201f, 0.22057012f, 
    -0.09873641f, -0.01656858f, -0.03865568f, 0.04547429f, -0.02251077f, 0.00458951f, 0.06563232f, -0.06235242f, 
    0.01095412f, 0.21512967f, 0.05909599f, -0.12092433f, -0.10216462f, -0.19534878f, 0.19768839f, -0.18968976f, 
    -0.01981258f, -0.17107819f, -0.05904569f, -0.16372165f, 0.27663234f, 0.17665355f, -0.15890494f, -0.34454072f, 
    0.07871485f, -0.04421566f, 0.05154363f, -0.03886561f, 0.13114634f, -0.01520237f, -0.01061881f, -0.02654165f, 
    0.20841226f, -0.02218076f, -0.25740498f, -0.10192317f, 0.11233995f, 0.04418829f, 0.08790025f, -0.33826959f, 
    -0.21033591f, -0.24504699f, -0.18414417f, -0.00389248f, -0.13909912f, 0.27799112f, -0.17169715f, -0.08088424f, 
    -0.38044000f, -0.16925547f, -0.07839970f, 0.09049375f, 0.10161576f, 0.00531894f, 0.02076381f, -0.06963842f, 
    -0.01404255f, -0.79894465f, -0.18284385f, 0.19044927f, -0.00497506f, 0.03651897f, 0.03691090f, -0.03293296f, 
    0.05689279f, -0.00215764f, 0.11999588f, -0.08408415f, -0.07689244f, 0.01568812f, -0.08448960f, -0.12031292f, 
    -0.38785499f, 0.25048295f, -0.34597504f, -0.08348448f, 0.03616411f, -0.00082472f, -0.15592763f, -0.12638924f, 
    0.36258158f, 0.22424269f, -0.04237411f, -0.09798656f, 0.10583796f, 0.40127304f, 0.12308006f, 0.00248814f, 
    -0.04968101f, -0.02637466f, -0.01290558f, -0.00964435f, -0.01873270f, -0.00199331f, -0.05760042f, 0.03531029f, 
    -0.00409546f, 0.03038993f, -0.00760700f, 0.07021170f, -0.03800329f, -0.23938364f, -0.31874231f, -0.23065779f, 
    0.04781981f, -0.11176426f, 0.03262782f, -0.02340397f, -0.16118667f, 0.05761914f, -0.41422442f, -0.26656964f, 
    -0.03988268f, 0.02601228f, -0.03710157f, -0.00371125f, 0.14224653f, 0.30557910f, 0.20245618f, -0.33335638f, 
    -0.04146176f, 0.16376804f, 0.13972230f, -0.03319899f, -0.02150000f, -0.07238572f, -0.03129343f, -0.02707806f, 
    0.63109207f, 0.20904884f, -0.28273380f, -0.24887799f, -0.03275811f, -0.19614756f, -0.03070092f, -0.01662592f, 
    -0.09330727f, -0.09010216f, 0.02783201f, 0.02487188f, 0.11339545f, 0.25971246f, 0.23816755f, -0.21285801f, 
    0.01368059f, 0.08808786f, 0.18400806f, 0.04699095f, -0.07367857f, -0.08758792f, 0.02895831f, -0.12280303f, 
    -0.88680863f, -0.17985910f, -0.30567062f, -0.16473663f, 0.00008163f, -0.02295432f, -0.06443421f, -0.03355493f, 
    -0.08809981f, 0.01334581f, 0.02115867f, 0.06259523f, 0.15641336f, -0.00584901f, -0.59945405f, 0.15404135f, 
    -0.01340585f, -0.06608380f, 0.02826524f, -0.08406275f, -0.10077714f, -0.04926891f, 0.13055135f, 0.22294320f, 
    -0.10614678f, -0.52945340f, -0.26897940f, 0.01017825f, 0.00162633f, 0.00024015f, -0.04489024f, -0.02798296f, 
    0.06404815f, -0.16564490f, -0.00835451f, 0.05125242f, -0.03744089f, 0.16497585f, -0.00617435f, -0.06924455f, 
    -0.07172043f, 0.14105098f, 0.06816549f, -0.32540187f, 0.00880765f, -0.06585233f, -0.27188706f, -0.21902716f, 
    0.41418695f, 0.07523126f, -0.01065228f, -0.11541769f, 0.05438514f, 0.05362255f, 0.02684350f, 0.05389018f, 
    0.06490362f, 0.10981140f, -0.00592637f, 0.08377541f, 0.33002740f, 0.43374360f, 0.08810157f, -0.13239719f, 
    0.13043506f, 0.35009342f, 0.19256143f, -0.04082433f, 0.00725729f, 0.05521631f, 0.08106139f, 0.07024027f, 
    0.03945788f, 0.17113334f, -0.22789097f, 0.16873667f, -0.00547096f, -0.06653698f, 0.01318056f, 0.04933801f, 
    0.07437630f, 0.09357326f, 0.01251150f, 0.08500760f, 0.08829690f, 0.04771400f, 0.16786245f, 0.06729650f, 
    -0.06893029f, -0.04148849f, -0.00652268f, -0.01726321f, 0.07376583f, -0.03108157f, -0.02666924f, 0.03724395f, 
    0.97251195f, -0.34188133f, 0.15090291f, -0.06173906f, -0.07828036f, 0.06970178f, -0.04018967f, -0.11606348f, 
    0.05203388f, -0.07404093f, -0.07415602f, -0.07392313f, -0.40303123f, 0.02270960f, -0.15538207f, -0.08997156f, 
    -0.03568870f, 0.12688759f, 0.02355590f, 0.05955411f, -0.00553196f, -0.16584380f, -0.19362162f, -0.21382701f, 
    0.55452317f, 0.22129463f, 0.24728078f, -0.42835867f, -0.01212432f, 0.06514720f, 0.01065815f, 0.08505921f, 
    0.15714224f, 0.16532996f, 0.02582304f, -0.16527505f, -0.53020769f, -0.19571021f, -0.02939240f, -0.16222554f, 
    -0.03161209f, -0.02918713f, -0.07108142f, -0.06812136f, -0.03129288f, -0.02579438f, 0.06117481f, 0.21856686f, 
    -0.22933887f, 0.04210756f, 0.07595246f, -0.17054713f, 0.02327124f, -0.06604116f, 0.03061561f, 0.10843723f, 
    -0.01939271f, -0.02083591f, -0.00517025f, -0.08048882f, -0.12691267f, 0.01980188f, -0.39563814f, -0.25370854f, 
    0.07585623f, -0.07933419f, -0.07724546f, 0.00158341f, -0.17641358f, -0.06736112f, -0.06721825f, -0.37415048f, 
    0.06827742f, 0.03449855f, -0.20732297f, -0.05125349f, 0.11748999f, -0.05954737f, 0.23892573f, -0.03442994f, 
    -0.11165419f, 0.09675523f, -0.01876747f, 0.13151534f, 0.15550080f, 0.17568570f, 0.02271926f, 0.00717732f, 
    0.04319984f, 0.13698424f, -0.07700246f, -0.32241306f, 0.01815412f, -0.11143200f, 0.15304476f, -0.42556202f, 
    -0.02885262f, 0.04688006f, 0.08230914f, 0.36260176f, -0.22746351f, 0.23014651f, 0.14582963f, 0.12550940f, 
    0.01887848f, -0.00208471f, -0.09184609f, 0.13716087f, 0.20282826f, 0.04843611f, 0.12419289f, -0.04792117f, 
    -0.04505899f, 0.01122775f, -0.04415659f, -0.02127778f, 0.04204207f, -0.05917880f, 0.11388876f, -0.10554454f, 
    -0.07646728f, -0.07998148f, -0.00299384f, -0.38553676f, -0.00693532f, -0.11175952f, 0.16768512f, 0.12808126f, 
    -0.00913146f, 0.11150041f, 0.10479225f, -0.08374751f, 0.25577033f, 0.07386965f, 0.34816512f, 0.41469851f, 
    -0.06226673f, -0.04819502f, 0.03598598f, 0.02203891f, 0.02465972f, 0.00489980f, -0.14122367f, 0.06139629f, 
    -0.16544811f, 0.07239083f, -0.21021105f, 0.18429278f, -0.03259840f, 0.07290972f, 0.07257468f, -0.04294010f, 
    0.03550852f, -0.07724860f, 0.01385319f, 0.10274819f, -0.05420405f, 0.10596844f, -0.00979813f, -0.02124470f, 
    -0.22490127f, -0.05235116f, -0.34202835f, 0.02386663f, -0.05437227f, -0.02127451f, 0.03431858f, 0.08566044f, 
    -0.43701836f, -0.12540057f, -0.36782956f, -0.27341554f, -0.05161640f, 0.10745896f, 0.04101158f, 0.07290468f, 
    -0.05933419f, 0.16741389f, -0.12140756f, 0.03965136f, -0.20357586f, 0.08205294f, -0.02533069f, 0.00303258f, 
    0.04796560f, 0.12817945f, 0.08217791f, -0.08002862f, 0.19185026f, -0.04933693f, -0.07719831f, -0.00942136f, 
    0.41119266f, 0.05331684f, 0.25346395f, 0.45592183f, -0.03507166f, 0.04309553f, -0.09052997f, 0.02750519f, 
    0.00502148f, 0.05875865f, -0.07608337f, -0.08131661f, -0.17453372f, -0.04352398f, -0.03688488f, -0.19652674f, 
    0.03529239f, 0.06323066f, 0.01191368f, 0.18104994f, -0.09436722f, -0.04892037f, 0.04699039f, 0.00213992f, 
    0.42928723f, 0.34514856f, 0.34499097f, 0.36495915f, 0.19466740f, -0.09910966f, 0.20247899f, 0.16342393f, 
    -0.01934328f, -0.06071116f, -0.03554772f, -0.23172142f, 0.02911846f, 0.00836295f, 0.08696198f, -0.06029229f, 
    0.05105057f, 0.03081943f, -0.01153814f, -0.01982007f, 0.27458704f, 0.00917862f, 0.08241399f, 0.18755721f, 
    0.00716420f, 0.03440388f, 0.04546019f, -0.05889564f, 0.04118374f, 0.08475430f, 0.06478678f, -0.06434349f, 
    0.00711430f, -0.11309781f, 0.02321470f, 0.10557088f, -0.88997734f, 0.09970441f, -0.14331034f, 0.07566094f, 
    0.02384100f, 0.11549108f, 0.19042568f, -0.02756185f, -0.14522640f, -0.01997060f, 0.12769276f, 0.01760874f, 
    -0.08339589f, -0.38711703f, -0.56095284f, -0.57818663f, -0.20199598f, -0.23235649f, -0.08244928f, 0.25891846f, 
    0.15185487f, -0.05284410f, 0.02589970f, 0.01773477f, -0.21337464f, 0.21624035f, -0.28507349f, -0.00142924f, 
    0.11149770f, 0.09311079f, -0.20604455f, -0.25788617f, 0.18816365f, 0.01920089f, -0.00603073f, -0.04339836f, 
    0.05502216f, 0.09892083f, 0.27171269f, -0.00316188f, -0.00353988f, -0.06667008f, -0.09704214f, 0.01420096f, 
    -0.03931475f, -0.03036271f, 0.02680231f, 0.04504242f, 0.07437922f, -0.33890027f, -0.15594770f, 0.07334784f, 
    -0.01175632f, 0.09636346f, -0.15213327f, -0.12883349f, -0.09889733f, -0.27790904f, -0.32099953f, -0.17443572f, 
    0.48423928f, -0.23424292f, 0.31925672f, -0.09514595f, -0.00791544f, 0.01178244f, 0.04086651f, -0.10529420f, 
    0.03886262f, -0.32779858f, 0.04944080f, -0.22327965f, -0.12402825f, -0.31976643f, -0.49490681f, 0.02056333f, 
    -0.28321728f, -0.08879161f, 0.19834271f, 0.24259976f, -0.01420815f, 0.10710274f, 0.02262066f, 0.22176586f, 
    0.29212695f, 0.07326031f, -0.21440847f, -0.08328668f, 0.03846067f, -0.07017562f, 0.06881636f, -0.14585757f, 
    0.04151342f, -0.08915587f, 0.00904579f, -0.14258669f, -0.07005529f, 0.22606428f, 0.00793946f, 0.14017899f, 
    -0.32848984f, -0.04963770f, -0.17387079f, -0.32116279f, -0.00975678f, -0.10198919f, -0.04972940f, -0.01148652f, 
    -0.21412404f, 0.11275444f, -0.39595985f, 0.19427395f, -0.00728980f, 0.01917346f, 0.00182697f, 0.16992785f, 
    -0.05783993f, 0.05368917f, 0.06803381f, -0.06847958f, -0.16767816f, -0.14657450f, -0.04839835f, -0.06290472f, 
    -0.06790861f, 0.01921144f, 0.03408842f, 0.00025320f, -0.23515247f, 0.01076120f, 0.06250042f, 0.01044372f, 
    -0.31644580f, 0.58225435f, 0.29108840f, 0.01573590f, -0.02419638f, -0.03852365f, 0.07451241f, -0.12764764f, 
    -0.02003808f, 0.24092434f, 0.04344850f, 0.12568849f, 0.17002606f, 0.07945969f, -0.10793801f, 0.24264990f, 
    -0.07615913f, -0.03275626f, 0.04143564f, -0.15689015f, -0.01841989f, -0.01741114f, 0.25328496f, 0.05590837f, 
    -0.22251208f, 0.48878843f, 0.30950469f, -0.20303446f, 0.04144808f, 0.00773242f, 0.00368001f, -0.11313703f, 
    -0.13543428f, 0.03220411f, -0.00549801f, -0.14531408f, -0.19356889f, 0.50687122f, 0.18889394f, 0.19501692f, 
    0.02869238f, 0.06008107f, 0.05542205f, 0.02005984f, 0.00415532f, 0.03499077f, -0.08955846f, 0.01403705f, 
    -0.08485226f, -0.16620906f, -0.09492107f, 0.23015702f, 0.00793156f, 0.04254012f, -0.22821113f, 0.16293657f, 
    -0.01600782f, -0.00520580f, -0.01074893f, -0.01737766f, -0.08435471f, 0.15027666f, -0.15901935f, -0.07382557f, 
    -0.04513048f, -0.12009661f, -0.01145514f, -0.04125019f, -0.11765699f, 0.17344820f, -0.00357188f, 0.16913660f, 
    0.21700120f, -0.11423712f, -0.09586702f, -0.12517591f, 0.04651216f, -0.16342701f, 0.10453003f, 0.05604979f, 
    0.08803177f, 0.09232692f, -0.02856009f, -0.16793938f, -0.00250374f, 0.41234037f, 0.44911909f, 0.35949120f, 
    -0.07600822f, -0.06649683f, 0.16875610f, 0.04366672f, 0.04470254f, -0.05936123f, -0.08379428f, 0.03409157f, 
    -0.63320202f, -0.03579250f, 0.00058536f, -0.45307028f, -0.09131557f, -0.22632708f, 0.12892815f, -0.09537900f, 
    -0.05770240f, -0.05223568f, -0.00852307f, -0.01348528f, -0.19430777f, 0.13170357f, -0.10153177f, -0.08333194f, 
    -0.02430105f, 0.00410497f, 0.01257748f, -0.03973900f, 0.11502370f, -0.02346222f, 0.03851211f, 0.13998441f, 
    -0.21141310f, -0.16513562f, -0.16687000f, 0.05283086f, -0.02872448f, 0.01883005f, 0.00441474f, -0.39857021f, 
    0.02505262f, 0.01573097f, -0.01333256f, -0.00396048f, 0.18054393f, -0.07529572f, -0.23548603f, 0.13652013f, 
    -0.01255634f, -0.05317073f, 0.00558266f, -0.03376290f, -0.01698931f, -0.01627999f, 0.01779179f, -0.04082460f, 
    -0.08935376f, -0.03695548f, -0.11698063f, 0.09978760f, -0.01004119f, 0.05375337f, -0.02818566f, 0.02479367f, 
    -0.01836932f, -0.10533018f, -0.07704431f, -0.04045173f, -0.51417959f, -0.69713414f, -0.69757587f, -0.19170210f, 
    0.15206152f, 0.04239893f, -0.23776776f, -0.17439771f, 0.08302675f, -0.05174101f, 0.03115237f, 0.00961616f, 
    -0.00789758f, 0.36641362f, 0.10992426f, 0.03740110f, -0.06294806f, 0.16275716f, -0.02486961f, -0.10288888f, 
    -0.13032539f, -0.03482643f, -0.18260758f, 0.03828878f, 0.12334538f, -0.02568802f, -0.03046835f, -0.02115560f, 
    0.05380757f, 0.05550566f, -0.14297670f, 0.13113244f, -0.10392975f, 0.04992830f, 0.20305014f, -0.03983808f, 
    -0.03494981f, -0.32739758f, -0.57787806f, -0.02748411f, 0.02032655f, -0.00972928f, -0.03436067f, -0.00815872f, 
    -0.02966915f, 0.15862539f, -0.31919354f, 0.13953070f, 0.39063025f, 0.02486534f, -0.02314244f, 0.06299400f, 
    0.20706449f, -0.26581410f, -0.16290805f, 0.08501811f, -0.06017203f, 0.01622506f, 0.06828554f, 0.03666988f, 
    -0.67753059f, -0.42153981f, 0.62490183f, 0.50390363f, -0.03460509f, 0.13627040f, 0.02070291f, 0.04687480f, 
    0.03218833f, -0.13880251f, -0.01892840f, -0.04977408f, 0.01260976f, -0.05686405f, 0.03142601f, -0.08013643f, 
    0.10570461f, -0.00538668f, -0.12920168f, 0.08005998f, -0.09048647f, -0.19411564f, 0.21693894f, 0.02415459f, 
    -0.32381856f, -0.06756047f, 0.00172533f, -0.11176506f, -0.26204798f, -0.25833100f, -0.13868804f, -0.07095547f, 
    0.13322088f, 0.01127130f, 0.04793703f, 0.06229193f, 0.25853410f, -0.11300626f, 0.01236883f, 0.39342663f, 
    -0.09109984f, -0.01690288f, -0.05540281f, -0.09929892f, -0.04069810f, 0.03437314f, -0.06641582f, 0.02105607f, 
    0.20884454f, 0.54599440f, -0.25350305f, -0.52933711f, 0.00555520f, 0.05064218f, -0.00104294f, -0.02983082f, 
    -0.01102137f, -0.03161884f, -0.05398896f, -0.03034379f, -0.07555497f, -0.00343909f, -0.38601106f, 0.21108608f, 
    -0.07245591f, 0.06746867f, -0.01220552f, -0.17668052f, -0.07169413f, 0.04186971f, 0.03318062f, -0.02337967f, 
    -0.66206330f, -0.35877237f, 0.59411532f, -0.04570764f, -0.01397852f, 0.03613345f, 0.03663125f, 0.12341447f, 
    0.03330892f, -0.03250046f, 0.01616960f, 0.00973555f, -0.02104067f, -0.16426662f, 0.11742786f, -0.13267523f, 
    -0.04315197f, -0.13380452f, 0.03425983f, 0.01680855f, 0.09144385f, -0.02638080f, -0.00614595f, 0.06041173f, 
    -0.01504277f, 0.04588885f, 0.29177853f, -0.05240877f, -0.00120356f, 0.02883210f, 0.08155992f, 0.00632480f, 
    0.05107810f, 0.02010330f, 0.07994714f, 0.14623114f, -0.08432877f, -0.24047720f, -0.22545469f, -0.18238828f, 
    0.09889619f, -0.17669660f, -0.11039109f, 0.10248542f, 0.01897315f, -0.49818525f, 0.06401144f, 0.10557260f, 
    0.05903396f, 0.08655091f, 0.35572132f, 0.24580623f, -0.07190325f, -0.04398545f, 0.16706198f, 0.01810764f, 
    -0.12405842f, -0.10711303f, 0.05161195f, -0.00602176f, -0.33791772f, -0.14442480f, -0.30164886f, 0.38075411f, 
    0.08353487f, -0.14530391f, -0.02778490f, 0.01158746f, -0.04705444f, 0.04675218f, 0.04686829f, -0.06812061f, 
    -0.39961869f, 0.82444900f, -0.24339683f, -1.30055690f, -0.12100916f, 0.37583593f, -0.12201000f, 0.21542463f, 
    -0.28690997f, -0.04878394f, 0.07950664f, -0.25169241f, -0.43420017f, -0.04471104f, 0.00563663f, -0.15565249f, 
    -0.02028777f, -0.07058273f, 0.08890021f, -0.13681822f, -0.01052055f, 0.13648902f, -0.23734108f, -0.04128121f, 
    -0.48062003f, 0.42614517f, -0.05292340f, 0.42737791f, 0.00813986f, 0.06893001f, 0.25531223f, -0.21346538f, 
    -0.12467539f, -0.00367723f, -0.09804803f, 0.04253833f, 0.17629813f, 0.00116060f, -0.18771848f, -0.14158739f, 
    0.12528600f, 0.01123031f, 0.00685420f, -0.19838879f, -0.01265347f, 0.02820554f, -0.02766459f, -0.11137174f, 
    -0.35959479f, -0.12272335f, -0.01847409f, 0.31237733f, 0.16853066f, -0.07432098f, -0.00746957f, -0.09455095f, 
    -0.00533003f, 0.04883392f, 0.30414519f, -0.12269819f, 1.01151013f, -0.20274538f, -0.26256615f, 0.00160107f, 
    0.32054043f, -0.01386249f, 0.09283473f, -0.04175292f, -0.18377617f, 0.04381568f, -0.13732792f, 0.12040539f, 
    0.16714852f, 0.05170789f, -0.04103916f, -0.41000208f, 0.13462086f, 0.07767241f, -0.13056193f, 0.02154744f, 
    0.03718955f, 0.02068869f, 0.08215092f, -0.04213799f, 0.19257763f, 0.14649799f, -0.01122690f, -0.30051780f, 
    0.07024106f, -0.03180478f, -0.10349769f, -0.20441353f, -0.02158604f, -0.09097527f, 0.00133415f, -0.07593876f, 
    -0.16837800f, 0.12184634f, -0.10303655f, -0.36616191f, -0.07538052f, -0.16228925f, -0.07942342f, 0.02679830f, 
    -0.03934399f, -0.04326536f, 0.10018265f, 0.14250690f, -0.03571773f, -0.26939094f, 0.00404510f, 0.31738141f, 
    0.10480408f, 0.06693541f, 0.08994059f, -0.13785519f, -0.03627009f, -0.03144011f, 0.08791383f, 0.09616902f, 
    -0.24369395f, -0.18727283f, -0.11652266f, 0.25592086f, 0.20134823f, 0.00978926f, 0.12446270f, 0.05157635f, 
    0.01551789f, -0.01666709f, 0.12158693f, -0.00853602f, -0.51098830f, -0.25534922f, 0.17244364f, -0.16951725f, 
    -0.26364750f, 0.07022500f, -0.10747860f, 0.06807334f, 0.09964505f, 0.19023454f, 0.02472735f, -0.07408229f, 
    0.08207513f, -0.07304931f, -0.03112170f, 0.29186806f, -0.06625605f, -0.06420413f, 0.09321864f, 0.11490169f, 
    -0.03284595f, -0.00358426f, 0.06787901f, -0.10064927f, -0.09213638f, 0.50401688f, -0.26159787f, -0.26145306f, 
    0.06317945f, -0.05364408f, -0.22334711f, -0.05070563f, -0.25215462f, -0.13074687f, 0.02601784f, -0.04002205f, 
    0.07288812f, 0.02401857f, -0.37844962f, -0.17489977f, -0.04482667f, -0.35697192f, -0.07717270f, -0.30001315f, 
    -0.23383011f, 0.13644560f, -0.19413215f, 0.07880662f, 0.09523506f, -0.05031555f, -0.03915420f, 0.18186454f, 
    0.12391778f, 0.17098784f, 0.04906294f, 0.07066552f, 0.00673849f, -0.05506501f, -0.05825303f, -0.20434095f, 
    0.02322865f, 0.00334748f, 0.03007337f, 0.26730636f, 0.15550894f, -0.08986533f, -0.06971367f, 0.11366268f, 
    0.08849274f, 0.19425182f, 0.05885952f, 0.03292767f, 0.05026454f, -0.42649043f, -0.00036959f, -0.35566181f, 
    0.06685936f, -0.04930140f, -0.14744361f, -0.06806427f, -0.41095543f, -0.00400055f, -0.22486243f, 0.07369516f, 
    0.00645263f, -0.20238484f, 0.09355600f, -0.18695281f, 0.11894719f, 0.14663418f, -0.18938500f, -0.02446406f, 
    -0.13308312f, -0.13553357f, 0.08812434f, 0.14698015f, 0.90628093f, 0.46431765f, 0.56519073f, 0.35362777f, 
    -0.17085469f, 0.22453175f, -0.19474353f, -0.12169300f, -0.04824933f, 0.11587238f, 0.09855077f, -0.07946201f, 
    0.26916903f, -0.18135639f, -0.20708737f, 0.26188606f, 0.14050931f, 0.02507908f, -0.06961633f, -0.10230044f, 
    -0.02138120f, -0.01100450f, 0.03543038f, 0.12554629f, -0.13889800f, -0.38900861f, -0.27939093f, 0.15718769f, 
    -0.20116706f, -0.04590684f, -0.22884591f, -0.19390047f, 0.17669499f, 0.19502887f, 0.00634412f, -0.25817642f, 
    0.16283192f, -0.23921262f, 0.19942725f, 0.09631574f, -0.02535159f, -0.28800693f, -0.03163828f, 0.06095988f, 
    0.04634717f, 0.09037990f, -0.29834855f, -0.24593906f, 0.19878052f, -0.05674622f, -0.34695446f, -0.36629716f, 
    0.07404321f, 0.07882281f, -0.00395785f, 0.21193884f, 0.06553774f, 0.09738229f, -0.14140029f, -0.00060888f, 
    -0.61743861f, 0.42952538f, -0.11940427f, 0.55924582f, 0.08742812f, 0.06420906f, 0.08696462f, -0.02722345f, 
    -0.12692882f, -0.03500716f, -0.01790004f, 0.25714880f, -0.04564857f, -0.02983437f, -0.26620290f, -0.03819408f, 
    -0.07430369f, -0.05080201f, -0.10496465f, 0.11617774f, -0.07887064f, 0.03959954f, -0.18159242f, -0.17786528f, 
    -0.40001839f, -0.03131230f, 0.37221381f, -0.03456422f, -0.36955541f, -0.08076104f, -0.26808006f, -0.00249218f, 
    -0.06785384f, 0.28704816f, 0.00302764f, -0.04997965f, 0.43705338f, 0.24399747f, -0.20157000f, 0.19352627f, 
    0.26959205f, -0.03948086f, -0.01271536f, -0.08291880f, -0.05759597f, 0.01246830f, 0.04642839f, 0.16466217f, 
    -0.57615983f, 0.04186168f, -0.06647239f, -0.01814312f, -0.01744933f, -0.10602613f, 0.03810303f, 0.07086201f, 
    -0.23059542f, -0.00953325f, -0.15208712f, -0.14840649f, 0.15631469f, -0.20588715f, -0.30742615f, 0.06436073f, 
    0.04195139f, 0.06210908f, -0.15160860f, 0.01426383f, -0.04570365f, 0.14340544f, 0.02476438f, 0.15595089f, 
    -0.27990976f, -0.11120394f, -0.00898975f, -0.09249688f, 0.32482898f, 0.23064311f, 0.12974679f, -0.11420228f, 
    -0.15896840f, 0.03214116f, -0.01238185f, 0.04443867f, 0.19587775f, -0.19260889f, -0.21456552f, 0.03595984f, 
    0.17323238f, 0.01717125f, 0.00120853f, -0.14639162f, 0.05239825f, -0.07146860f, 0.08983653f, 0.06240937f, 
    0.35344076f, -0.81684017f, 0.35645872f, 0.00953291f, -0.06454655f, 0.00589631f, -0.02233574f, -0.06250589f, 
    -0.11713299f, -0.02783426f, -0.39417484f, 0.05449359f, 0.08409333f, 0.05992785f, 0.02840755f, 0.06605190f, 
    0.22703323f, 0.01241892f, 0.05884376f, 0.06418098f, -0.03098722f, -0.04364733f, -0.07239931f, 0.16110843f, 
    -0.12551111f, -0.29189211f, 0.05489396f, -0.13594608f, 0.04290874f, 0.01229046f, 0.03972351f, -0.07317051f, 
    0.06845333f, 0.03729434f, 0.09116369f, 0.28253764f, -0.19411176f, -0.04575511f, 0.04249234f, 0.09931985f, 
    -0.08166640f, -0.06391244f, 0.07902410f, -0.11020763f, -0.05056181f, 0.21097091f, 0.24313079f, 0.17998300f, 
    -0.31914926f, 0.00710201f, -0.19561514f, 0.17873973f, -0.08403882f, -0.05783889f, 0.04488388f, -0.03404368f, 
    -0.15026991f, -0.37933567f, -0.38470864f, 0.01818120f, -0.14398572f, -0.12504220f, -0.10033929f, -0.10282543f, 
    -0.10089093f, 0.02958570f, -0.03629038f, 0.22956817f, 0.16955222f, 0.03706202f, -0.08133364f, -0.19093904f, 
    -0.20412347f, -0.24659401f, -0.11376506f, 0.28905791f, -0.09405083f, -0.10150369f, -0.07338463f, -0.40163589f, 
    0.09763496f, 0.06416781f, 0.01859743f, -0.02092910f, 0.16421525f, -0.25371152f, -0.24718282f, 0.14828631f, 
    -0.03875323f, -0.23648819f, -0.03724519f, -0.04211715f, -0.08107062f, 0.22253090f, 0.00230203f, 0.34036306f, 
    0.10536465f, 0.08169190f, -0.10841937f, 0.03222339f, 0.03645461f, 0.02058500f, -0.07132891f, -0.11405743f, 
    -0.13133591f, -0.03789606f, -0.25943428f, 0.01771737f, -0.19212675f, 0.05636672f, 0.05308312f, 0.08213606f, 
    -0.08757375f, -0.15123965f, 0.02443374f, -0.05518759f, -0.10496039f, 0.06474786f, -0.12305974f, 0.32651436f, 
    0.18319492f, 0.19482768f, 0.29895830f, 0.17395459f, -0.03081416f, -0.16803610f, -0.16854756f, -0.04721359f, 
    0.14158614f, 0.04593631f, 0.14726706f, 0.03464842f, 0.11929115f, -0.01236587f, -0.13261944f, -0.00702300f, 
    0.02958278f, 0.00392856f, -0.03390012f, 0.03518171f, 0.08244481f, 0.14048193f, 0.00536325f, 0.12447558f, 
    0.03790199f, 0.28576112f, 0.18773182f, 0.24119230f, -0.02302681f, 0.08295744f, -0.06043025f, -0.00418654f, 
    -0.01115072f, 0.04303184f, -0.03773604f, 0.21189915f, -0.27466756f, -0.44766954f, -0.14523935f, -0.32896334f, 
    0.06394330f, 0.02447051f, -0.01648539f, 0.01098992f, -0.03476550f, -0.16252378f, -0.12565553f, -0.32310668f, 
    0.21271043f, -0.07120424f, 0.05983036f, 0.06141102f, -0.08095666f, 0.15444355f, -0.33854830f, -0.03457030f, 
    -0.27701259f, -0.02760845f, -0.14021908f, -0.14762934f, 0.09710609f, 0.36807448f, 0.39615732f, 0.26003695f, 
    -0.06805537f, 0.01968216f, 0.06615517f, 0.20035857f, 0.06536077f, -0.08441675f, 0.04292828f, 0.00437740f, 
    0.51623833f, 0.11395057f, 0.09382197f, 0.16755755f, 0.00203051f, -0.04907869f, -0.12662223f, -0.23962732f, 
    0.05478143f, -0.26077220f, -0.13944459f, -0.05907460f, 0.29746562f, -0.22663242f, -0.09796023f, -0.09045397f, 
    -0.23779789f, -0.22920716f, 0.16519746f, -0.07551648f, -0.01733054f, -0.05310876f, -0.11796583f, -0.44161370f, 
    -0.37659907f, -0.58602101f, -0.02237943f, -0.14794022f, 0.06522163f, -0.03761502f, 0.06516408f, 0.03718286f, 
    0.13331510f, -0.04723521f, -0.00868102f, -0.01987856f, 0.08906939f, -0.18001671f, -0.20611875f, 0.11628040f, 
    0.22081612f, -0.32041103f, 0.00068869f, -0.22955969f, -0.12080711f, 0.02406244f, -0.01014999f, -0.07959989f, 
    -0.19723488f, 0.06341772f, 0.02535645f, 0.02611175f, -0.08431268f, 0.04896009f, -0.05709844f, -0.01085170f, 
    0.09261059f, -0.04678278f, 0.12074891f, 0.06755399f, 0.05251988f, 0.08402348f, 0.01727490f, -0.02544594f, 
    0.04793228f, 0.12992696f, 0.04118603f, -0.01654435f, -0.05976256f, -0.16110590f, -0.20608507f, -0.17197487f, 
    0.06122085f, 0.09771573f, 0.09707227f, 0.18967062f, -0.02222834f, -0.04781150f, 0.05248950f, 0.08598099f, 
    -0.10411439f, -0.02522438f, -0.08777562f, -0.16046162f, -0.01309902f, 0.07033651f, 0.10734727f, 0.08112586f, 
    -0.15894578f, -0.07573050f, -0.11057239f, -0.02066079f, 0.00746498f, -0.04150118f, 0.06667365f, 0.01947162f, 
    0.14165387f, -0.31599277f, 0.43055198f, 0.31452954f, 0.26032206f, -0.12384758f, 0.04507189f, -0.24875678f, 
    -0.12716034f, -0.02568467f, -0.01662442f, 0.00417312f, -0.17461407f, 0.02717323f, 0.20367478f, -0.06642982f, 
    -0.21440314f, -0.00317373f, -0.05335878f, -0.16843115f, -0.20326649f, -0.09441661f, -0.05788136f, 0.03544594f, 
    -0.00273600f, 0.10749051f, 0.01824560f, 0.25799155f, -0.11870194f, 0.03719725f, 0.07801595f, 0.07007381f, 
    0.14677987f, 0.00073153f, 0.10371049f, -0.07137173f, -0.21201786f, -0.14068776f, 0.06989293f, -0.00295904f, 
    -0.04071272f, -0.05929050f, -0.08067784f, 0.08374333f, 0.09402861f, 0.28048196f, 0.01212037f, -0.15080950f, 
    -0.25452942f, -0.14794426f, -0.27764419f, -0.14254212f, -0.01089806f, -0.05989162f, -0.02547101f, 0.09068937f, 
    -0.06484934f, -0.06828012f, 0.02981173f, 0.10640165f, 0.24155486f, -0.01819889f, 0.07885908f, -0.01436053f, 
    0.25508419f, 0.16339755f, -0.05618782f, -0.37957489f, -0.09422000f, -0.48192888f, -0.15441120f, -0.32549125f, 
    0.13777988f, 0.07428771f, 0.00432551f, 0.13096558f, -0.12680122f, -0.09043423f, 0.01103822f, 0.06861766f, 
    0.08346588f, -0.08152731f, -0.10861854f, 0.05596162f, -0.10957497f, -0.08564005f, 0.23202068f, 0.16797337f, 
    -0.24144328f, -0.10510080f, -0.10062601f, 0.02006504f, 0.02475139f, 0.06524822f, -0.08165781f, 0.00067652f, 
    -0.38136709f, -0.52376759f, 0.40895703f, 0.23872283f, -0.09227132f, -0.09622268f, -0.03200454f, -0.02898638f, 
    0.05281827f, -0.07389032f, 0.12019766f, -0.10451297f, -0.05273694f, -0.06325316f, -0.06453481f, 0.03986580f, 
    0.01990621f, -0.12324733f, -0.17288090f, 0.01876939f, 0.05090506f, -0.07440796f, 0.32431501f, -0.09100282f, 
    -0.20335609f, -0.13922484f, -0.60827500f, -0.31013000f, 0.05034408f, -0.01052118f, -0.00310145f, 0.14814746f, 
    0.11939535f, -0.33985806f, -0.00965135f, -0.28569904f, 0.05045111f, -0.21010645f, 0.20699719f, 0.04685612f, 
    -0.07918596f, -0.12408385f, -0.04043580f, 0.09971164f, 0.03629613f, -0.09408585f, -0.14191289f, -0.15312886f, 
    0.02438654f, -0.24808145f, -0.58436549f, -0.35039517f, -0.07231207f, 0.03001526f, -0.04542543f, -0.03139450f, 
    0.12231714f, -0.07862058f, 0.14835373f, 0.18881007f, -0.45336691f, -0.07605909f, -0.14101401f, 0.01152669f, 
    -0.08874686f, -0.01901304f, -0.05856061f, -0.04253093f, -0.16708548f, -0.18689795f, 0.15393703f, 0.00192064f, 
    -0.11263629f, 0.14196098f, 0.13584392f, 0.14341065f, -0.00549520f, -0.01230079f, 0.16195561f, 0.16199459f, 
    0.01684333f, 0.01803264f, -0.01815852f, 0.16366172f, -0.50243384f, 0.43947363f, 0.48631537f, 0.21320425f, 
    0.00339602f, 0.11788858f, -0.00882190f, 0.05624464f, 0.18197148f, -0.19770479f, -0.43253180f, -0.26004857f, 
    -0.29828429f, -0.29101843f, 0.03295996f, 0.46842709f, -0.03368643f, 0.01067685f, -0.28976265f, 0.03725490f, 
    0.24445181f, -0.10133298f, 0.07338926f, -0.02490312f, -0.01696823f, -0.06244344f, 0.00976679f, -0.28311521f, 
    -0.07241599f, -0.13954437f, -0.09661002f, 0.16380961f, -0.09285757f, -0.14476876f, -0.10026815f, -0.07651005f, 
    0.05789578f, 0.27902442f, 0.02487006f, -0.49548566f, 0.23504061f, 0.15942940f, -0.04356894f, -0.29053235f, 
    0.00351892f, -0.05749294f, 0.02150732f, 0.01218609f, 0.14521700f, -0.15253116f, -0.24168843f, 0.09712371f, 
    0.14058723f, 0.09163780f, 0.00316724f, 0.01607024f, -0.21639059f, -0.32015708f, -0.29325190f, -0.20580715f, 
    0.06922065f, 0.12890412f, 0.08214051f, 0.10558723f, 0.10541037f, 0.01019273f, -0.13638532f, -0.07250617f, 
    -0.08912203f, -0.11550864f, -0.14958537f, -0.10536718f, 0.05684121f, -0.27843061f, -0.06368651f, -0.07249529f, 
    -0.10567109f, 0.05999072f, -0.08116525f, -0.03603761f, 0.03792903f, 0.08267172f, 0.08632087f, 0.25199860f, 
    0.05558440f, -0.18583138f, 0.46568182f, -0.37573385f, -0.02212583f, 0.14200269f, 0.04973735f, 0.05948669f, 
    0.21851151f, -0.04593273f, 0.18592441f, 0.10041113f, 0.19842549f, 0.06894404f, 0.01958140f, -0.02723378f, 
    0.24046913f, 0.12328131f, 0.07607901f, -0.00406797f, -0.07247980f, 0.03895474f, 0.01519138f, -0.01711363f, 
    -0.02467141f, -0.19522946f, -0.14155518f, -0.01790656f, -0.06310488f, 0.01125600f, 0.19832505f, 0.00157468f, 
    0.27114710f, -0.01951725f, 0.03406458f, -0.08021744f, -0.07773317f, -0.01981018f, -0.08066540f, 0.24174039f, 
    0.14706542f, 0.11485495f, -0.17075221f, 0.02273743f, -0.23690909f, -0.03398377f, 0.23519856f, 0.25352103f, 
    -0.19601093f, 0.26025373f, -0.04086143f, -0.26321033f, -0.01121172f, -0.05739626f, 0.04837328f, -0.00312689f, 
    -0.03542795f, -0.03157202f, -0.01963671f, 0.00686228f, -0.32109022f, 0.10124905f, -0.18979701f, -0.08301732f, 
    0.00200122f, -0.08570185f, 0.00675098f, 0.07474893f, 0.12212283f, 0.06071171f, -0.09736998f, 0.01128128f, 
    -0.38365582f, 0.04468591f, 0.08235647f, -0.40549898f, 0.06461623f, -0.12655215f, 0.04710368f, -0.02184119f, 
    0.03259778f, 0.07571860f, -0.04895711f, 0.14728095f, 0.08920870f, 0.00349691f, -0.30676937f, 0.10023129f, 
    0.00121516f, -0.03671027f, -0.06425800f, -0.02406903f, -0.21123844f, 0.01790174f, 0.11763254f, 0.19948135f, 
    -0.03261399f, -0.05416572f, -0.25019184f, -0.06163003f, 0.23661184f, 0.35974351f, -0.03851601f, 0.07634880f, 
    -0.13042255f, 0.16389491f, 0.04520071f, 0.09777619f, 0.19118634f, -0.22264169f, 0.28947034f, -0.02332049f, 
    0.00715802f, -0.15145361f, -0.04877736f, 0.14081934f, 0.19401048f, -0.14687446f, -0.03062575f, -0.02205682f, 
    0.23116955f, 0.05168541f, 0.14683843f, -0.19410232f, -0.10300869f, -0.00674875f, 0.21941732f, 0.18623240f, 
    -0.00910444f, 0.10730653f, -0.00714662f, -0.14685184f, 0.29367188f, -0.09728567f, 0.24447726f, 0.18795320f, 
    0.12981895f, -0.08657665f, -0.14470181f, 0.09887898f, 0.03506386f, 0.07272749f, 0.07489102f, 0.05112852f, 
    0.47239491f, -0.19874603f, -0.39501810f, -0.04943220f, 0.16359350f, -0.00416324f, 0.01846431f, -0.00946676f, 
    0.14131309f, -0.02621292f, -0.02145943f, -0.02573601f, -0.16965783f, 0.37562945f, -0.21311912f, -0.54379851f, 
    0.02269804f, 0.04256303f, 0.12646760f, 0.12465536f, -0.00761740f, -0.27345636f, -0.12005221f, -0.00844965f, 
    -0.09321326f, -0.05353838f, -0.47070503f, 0.16334717f, 0.15872736f, -0.00767444f, -0.03338037f, 0.10758598f, 
    0.03169857f, 0.38661182f, -0.07491063f, -0.03777634f, 0.31552267f, 0.18440275f, 0.13368790f, -0.10003129f, 
    0.04087634f, -0.15390792f, 0.16900231f, -0.08648379f, 0.26307151f, 0.02437206f, 0.25060359f, -0.04884067f, 
    -0.81929225f, -0.38993290f, -0.15474671f, -0.22570170f, 0.05518553f, -0.01192687f, -0.21883696f, 0.02914911f, 
    0.04209876f, 0.05789156f, -0.02023346f, -0.12093815f, -0.07545864f, 0.10323304f, 0.11855278f, -0.06589599f, 
    0.30053407f, 0.05546340f, 0.12371729f, 0.22282247f, -0.06465810f, 0.14092802f, 0.00666119f, 0.05843779f, 
    0.22402677f, -0.11549017f, 0.06513098f, -0.01422289f, 0.01516874f, 0.05693518f, -0.01757983f, 0.08954845f, 
    0.14787269f, 0.01541950f, 0.08608051f, 0.10872383f, -0.05813042f, -0.10265551f, -0.01288012f, -0.06630873f, 
    0.01888541f, 0.00353832f, 0.00209662f, 0.01847737f, 0.18490814f, -0.10799135f, -0.19772106f, -0.13497694f, 
    0.25806639f, 0.67100769f, -0.33955982f, -0.07395649f, -0.00119850f, -0.03059562f, 0.03795239f, 0.06716220f, 
    0.13515322f, 0.10568526f, 0.11721928f, 0.12186524f, -0.05880702f, 0.08655427f, -0.02844584f, -0.04425216f, 
    -0.11323511f, 0.07359095f, -0.03851343f, 0.16304114f, 0.07765446f, 0.10225502f, 0.10552327f, 0.06183618f, 
    0.03401702f, 0.30229053f, -0.11742519f, 0.38816637f, 0.02892874f, -0.10494243f, 0.05060242f, 0.17353228f, 
    0.09619898f, 0.19332071f, -0.16231617f, 0.04655241f, -0.13905129f, 0.35220808f, 0.29387572f, 0.30990544f, 
    -0.07637192f, -0.03650740f, -0.11705584f, 0.14976963f, 0.00235065f, 0.11310498f, 0.05842660f, 0.01389400f, 
    -0.26860055f, -0.10991767f, -0.05537548f, 0.25834677f, -0.33434433f, -0.18476982f, -0.02689318f, -0.42071441f, 
    0.00919626f, -0.00769684f, 0.06666900f, -0.00717187f, -0.04151901f, -0.15392634f, 0.04267194f, -0.17111699f, 
    -0.05371297f, 0.01213171f, 0.15868136f, 0.11160798f, 0.10168705f, -0.00223363f, 0.27204555f, 0.01313104f, 
    -0.11742704f, -0.08215708f, 0.28563800f, 0.07868589f, 0.04275320f, 0.16408075f, -0.05404878f, -0.01008090f, 
    0.09243655f, -0.12596442f, 0.20565991f, 0.11689696f, -0.31910619f, -0.09069057f, 0.36419284f, 0.29960674f, 
    -0.14345907f, 0.07433294f, 0.10343216f, 0.01783257f, -0.07267767f, 0.08996367f, -0.03685550f, 0.01775680f, 
    -1.24499214f, -0.03929681f, 0.13853945f, 0.04100224f, -0.21910505f, -0.27497846f, -0.31149241f, -0.21835229f, 
    -0.10544989f, 0.00858591f, -0.02697557f, -0.03939933f, 0.13826725f, 0.11116324f, 0.01214771f, -0.03116503f, 
    0.01144443f, 0.01539348f, -0.01997478f, 0.07436468f, 0.09685641f, 0.11387520f, 0.09355512f, 0.02130661f, 
    -0.38679531f, -0.50289476f, -0.62325144f, -0.27989683f, 0.04989469f, 0.17396295f, 0.04411368f, -0.20495182f, 
    0.04378680f, -0.12594897f, 0.06276312f, 0.10843315f, -0.10033121f, 0.08149970f, 0.05722540f, -0.35136294f, 
    0.00539384f, 0.00727525f, -0.05459731f, 0.06761646f, -0.02544441f, 0.13078725f, 0.01601821f, -0.10775442f, 
    -0.13451307f, -0.18727788f, -0.07781360f, 0.17929308f, 0.03818512f, -0.12394952f, -0.03679707f, 0.21899474f, 
    0.06317773f, 0.09888779f, -0.13849832f, -0.06321005f, -0.95237362f, -0.91903532f, -0.31347117f, -0.27778423f, 
    -0.15411156f, -0.32352054f, -0.09905826f, -0.62124401f, -0.00390312f, -0.04421156f, -0.10136065f, -0.07284817f, 
    -0.36939496f, 0.66948837f, 0.70451742f, 0.00824923f, -0.07791194f, -0.26143643f, -0.10940251f, 0.22465466f, 
    -0.17478940f, -0.05898172f, -0.03260257f, -0.00733439f, -0.05762140f, -0.03928193f, 0.09031014f, -0.14001325f, 
    0.08855138f, -0.00210134f, 0.18572317f, -0.10614857f, -0.04531419f, 0.22212893f, -0.12974611f, -0.02978517f, 
    -0.04520397f, -0.00985237f, -0.10812488f, 0.04274864f, 0.02731373f, -0.11831621f, 0.09670397f, 0.01378520f, 
    -0.03425125f, -0.23336765f, 0.19389865f, -0.33755866f, 0.01706373f, -0.13636245f, 0.09354822f, -0.08254186f, 
    0.23182829f, 0.14408699f, -0.22216514f, -0.11856834f, -0.01114993f, 0.04475476f, -0.07797591f, -0.06665001f, 
    -0.45093331f, -1.47787106f, -0.63183832f, -0.54844660f, 0.05586503f, -0.40841019f, -0.27225745f, -0.12634712f, 
    -0.10276078f, 0.06659978f, -0.03519414f, -0.08380646f, 0.05290697f, -0.06598581f, 0.08962158f, -0.14942335f, 
    0.06647756f, -0.07068187f, 0.03737850f, 0.01363134f, -0.15914765f, 0.09816362f, -0.27384269f, 0.08209215f, 
    0.35662889f, -0.24023151f, -0.16621724f, -0.10090807f, -0.22294948f, -0.17506841f, 0.26292831f, 0.00120142f, 
    0.13554797f, -0.19477229f, -0.08810265f, -0.18068750f, -0.30703980f, 0.22503519f, 0.00063776f, -0.36958015f, 
    -0.15393063f, -0.12502803f, -0.00397970f, 0.10729012f, -0.06471599f, 0.08557800f, 0.06338352f, -0.02800773f, 
    -0.65907121f, -0.80610257f, -0.20367420f, 0.34132358f, 0.23321483f, 0.28219676f, 0.01771687f, -0.48038715f, 
    0.07742189f, 0.05570294f, 0.08624183f, 0.02109099f, -0.14808761f, -0.16357602f, -0.63158321f, 0.19521372f, 
    -0.14720644f, -0.06113810f, 0.16495031f, 0.18310206f, -0.01333758f, -0.02814629f, 0.05164031f, 0.21898976f, 
    0.17944162f, -0.45799887f, -0.63956755f, -0.50809789f, 0.02205205f, 0.10596781f, 0.19112559f, -0.07624624f, 
    -0.04176706f, 0.05980144f, -0.04206803f, -0.10837656f, -0.33343929f, -0.13262470f, 0.16097084f, 0.15134473f, 
    0.03642691f, -0.04728693f, 0.14864485f, -0.06027865f, 0.04345515f, 0.28901225f, 0.07286549f, -0.00348202f, 
    0.14478898f, 0.20561454f, 0.14894466f, 0.05353804f, -0.02699738f, -0.00707321f, 0.01229546f, -0.02643066f, 
    0.09126134f, 0.03333714f, 0.17678875f, 0.22427273f, -0.01638909f, -0.24031109f, 0.66005015f, -0.37326261f, 
    0.00111729f, 0.02502538f, 0.01241260f, 0.05515744f, 0.01736156f, 0.13322401f, -0.07752986f, -0.14904788f, 
    -0.58537692f, 0.31757459f, 0.34718579f, 0.16938157f, -0.04855567f, 0.07385487f, -0.15517777f, 0.03825068f, 
    -0.03448925f, 0.08880059f, 0.13192071f, 0.03061051f, -0.63675296f, -0.25628692f, -0.42613110f, 0.11600725f, 
    -0.15262425f, -0.10044289f, 0.12155811f, -0.13824175f, 0.03272628f, 0.06380470f, -0.02780787f, 0.08333302f, 
    0.26293209f, 0.12497000f, 0.08454968f, -0.42744431f, -0.06473658f, 0.02656023f, -0.16168873f, 0.04901683f, 
    -0.18363522f, 0.15735170f, 0.01428563f, -0.05360750f, 0.20764974f, 0.07914472f, 0.05084716f, -0.05619226f, 
    -0.03515027f, 0.04009679f, 0.02072201f, 0.03526021f, -0.13640842f, -0.16434444f, -0.03573211f, -0.13501552f, 
    -0.17603512f, -0.14696488f, -0.05994604f, 0.11578443f, 0.00046537f, -0.03285245f, 0.13762216f, -0.11892521f, 
    -0.19217955f, 0.18682013f, 0.07586615f, -0.12623344f, 0.50156075f, -0.46572319f, -0.19708928f, 0.15451410f, 
    0.08594956f, 0.02962936f, -0.01889586f, -0.08050548f, -0.06541006f, -0.02149169f, -0.09022652f, -0.11280117f, 
    0.05553075f, -0.06786393f, 0.10997517f, -0.43550184f, 0.01138032f, 0.08037718f, 0.07350716f, -0.02121601f, 
    -0.01585438f, -0.05920334f, 0.01717055f, -0.09837464f, 0.63656181f, -0.45460311f, -0.24383692f, -0.30377400f, 
    0.02935581f, -0.12504300f, -0.00470418f, -0.15976879f, -0.00195807f, 0.08016806f, -0.12570636f, -0.11713190f, 
    0.47848955f, -0.54366159f, -0.42898852f, 0.16812083f, 0.04570540f, -0.05901637f, -0.15701328f, 0.00799814f, 
    -0.00224365f, 0.06881663f, -0.02486598f, -0.03658394f, 0.65236557f, -0.63438869f, 0.32867533f, -0.29027256f, 
    -0.05487940f, -0.09124214f, -0.06170462f, -0.03976435f, 0.03376589f, 0.02630884f, 0.13568126f, 0.09479958f, 
    0.04195403f, 0.10706909f, -0.05627024f, -0.11149722f, -0.04030555f, 0.09277318f, -0.02867772f, 0.07840548f, 
    -0.00230526f, -0.01131848f, 0.02217941f, 0.04168571f, 0.08677441f, -0.69972461f, -0.27444288f, -0.69050580f, 
    0.03398816f, -0.13276169f, -0.08919228f, 0.21761513f, 0.07141715f, -0.03351816f, -0.06449889f, 0.08260483f, 
    -0.74418563f, 0.27225497f, 0.28449729f, -0.05136928f, 0.03520600f, -0.09610295f, 0.05006867f, 0.18472655f, 
    -0.05216724f, -0.08423272f, -0.01794979f, -0.00394884f, 0.11582640f, 0.07240394f, 0.09754186f, 0.05395910f, 
    -0.02810171f, 0.06486293f, -0.00536288f, -0.00685226f, 0.02911260f, 0.08530375f, 0.01490461f, -0.03569361f, 
    -0.62778056f, -0.06459663f, -0.12945683f, 0.49671412f, 0.04815355f, 0.15915476f, 0.11844912f, 0.15648149f, 
    -0.02377078f, -0.11960932f, -0.04113121f, -0.22149561f, -0.02516957f, 0.09537556f, -0.23935026f, 0.08662499f, 
    0.05065469f, -0.06365420f, 0.08337006f, -0.07807218f, 0.00117719f, -0.02052597f, -0.11012758f, -0.24217860f, 
    0.14379005f, -0.12528463f, 0.31955847f, -0.04828824f, -0.19778474f, 0.12693079f, -0.11051189f, 0.12513968f, 
    -0.00546098f, 0.03860975f, -0.08577658f, -0.05632407f, -0.71386778f, -0.51045096f, -0.34618580f, 0.95716012f, 
    0.13539803f, -0.02090875f, 0.11096061f, 0.02076545f, 0.08702969f, -0.03779778f, 0.00009239f, 0.04294690f, 
    0.43046379f, -0.60867745f, -0.75219613f, -0.42877454f, 0.02719587f, -0.23954111f, 0.11151861f, -0.04780620f, 
    -0.02102274f, 0.09920362f, 0.16645150f, 0.02325717f, 0.13248861f, 0.18054265f, 0.12159396f, -0.23038958f, 
    -0.08400692f, 0.11326439f, -0.06875202f, -0.00276510f, 0.00312194f, -0.10058824f, -0.10089538f, -0.03363393f, 
    0.08392629f, 0.03956931f, 0.03031229f, -0.15807530f, -0.00547850f, 0.00003744f, 0.05904993f, -0.06037505f, 
    0.18001010f, -0.07740854f, -0.10386149f, -0.31941223f, -0.00373802f, 0.26178846f, -0.11548524f, -0.00104986f, 
    -0.33492783f, 0.30193362f, -0.23595724f, 0.09098905f, 0.05508522f, 0.09105254f, 0.03430495f, 0.06110791f, 
    -0.18577534f, -0.66917062f, -0.37099838f, -0.47668436f, -0.09888721f, -0.02216499f, -0.12609507f, 0.23361902f, 
    0.04703773f, 0.00840851f, -0.02094991f, -0.06862785f, 0.03372535f, 0.13014835f, -0.04138309f, -0.04425662f, 
    0.01993149f, 0.04278510f, 0.01139688f, -0.01234510f, -0.17072576f, -0.22177368f, -0.08444229f, 0.03903073f, 
    0.02495736f, 0.04168031f, 0.02783870f, 0.05617158f, -0.03057148f, -0.02898236f, -0.12167513f, -0.00147423f, 
    -0.05360526f, -0.04388006f, -0.00524223f, 0.06819201f, 0.83859175f, -0.61228931f, -0.07686459f, -0.13873017f, 
    0.11113078f, 0.17327183f, -0.07507654f, -0.15862824f, -0.04445828f, 0.17903168f, 0.04276646f, -0.03167067f, 
    0.08527392f, -0.22834656f, 0.28698102f, -0.50850207f, -0.14025460f, 0.03618681f, -0.11992951f, 0.26247895f, 
    -0.12917994f, -0.03202553f, 0.04939127f, -0.12109207f, -0.03787176f, -0.55505240f, -0.09113239f, -0.18376982f, 
    0.01657736f, -0.01757474f, 0.00787844f, 0.12886216f, -0.14737441f, -0.07425568f, -0.03775288f, -0.08600073f, 
    -0.19874334f, -0.15757723f, -0.03154880f, -0.05758153f, 0.04278502f, 0.00326368f, -0.12713425f, -0.12738785f, 
    0.08992376f, 0.08740588f, 0.03307584f, 0.02042584f, 0.03999369f, 0.19934838f, 0.17001610f, 0.14124064f, 
    -0.01402939f, -0.15903819f, 0.06276023f, 0.06585754f, 0.14790179f, -0.11402419f, 0.08422913f, -0.03952195f, 
    -0.08432365f, -0.00304611f, -0.08118783f, 0.09430742f, -0.00872384f, 0.04993520f, 0.01107936f, -0.02441200f, 
    -0.16990578f, -0.14075845f, -0.16369031f, 0.01989628f, -0.34200129f, -0.06024367f, 0.06712778f, 0.10837274f, 
    0.02829873f, 0.12155762f, -0.13037658f, 0.05584761f, -0.02185551f, -0.25675592f, 0.10584585f, 0.00505421f, 
    0.65532315f, -0.40542477f, -0.20461845f, -0.28310195f, -0.10363419f, -0.00105341f, -0.11275095f, 0.03937497f, 
    0.03366269f, 0.14528789f, 0.08037800f, -0.04154034f, 0.12814741f, -0.10414411f, -0.35041133f, 0.02208124f, 
    0.10820627f, 0.12888590f, 0.00338845f, 0.15327561f, 0.06406307f, -0.12811162f, -0.04672372f, 0.05031857f, 
    0.31644335f, 0.06340647f, -0.18731919f, -0.50098765f, 0.00958767f, -0.12939587f, 0.05726941f, -0.02585777f, 
    0.02354100f, 0.12175301f, 0.10133678f, 0.22162712f, 0.15429881f, -0.08623964f, -0.09437870f, -0.22674212f, 
    -0.17235723f, -0.09421516f, -0.02948674f, -0.07246709f, -0.00203520f, 0.06581462f, -0.02900354f, 0.06754812f, 
    -0.61306417f, -0.47047451f, 0.33513975f, -0.02260512f, 0.07105417f, 0.01295429f, -0.03298711f, -0.02008236f, 
    -0.01547898f, 0.04772547f, -0.08262952f, -0.00609489f, 0.27913877f, -0.01643487f, -0.24456307f, 0.03061409f, 
    0.22172299f, 0.10685655f, 0.07496040f, 0.07539071f, -0.09436505f, -0.32730588f, 0.01223683f, -0.30601963f, 
    -0.71223962f, -0.15104499f, 0.28898528f, 0.50070775f, -0.01816925f, -0.01454562f, 0.13782465f, 0.06916422f, 
    0.13622920f, -0.05855728f, -0.04493506f, 0.23309258f, -0.04621041f, -0.47098649f, -0.45726258f, -0.04516449f, 
    -0.02275866f, 0.16244237f, 0.10844939f, 0.02426814f, 0.13930231f, 0.00191049f, -0.01228764f, -0.06078511f, 
    0.33248362f, 0.25494576f, -0.22088386f, -0.31545022f, -0.05676831f, 0.00666705f, 0.07348686f, 0.05384320f, 
    -0.01459990f, 0.05132332f, -0.01424827f, 0.16450955f, 0.40431383f, -0.06435128f, -0.35815459f, -0.57567400f, 
    0.11526402f, 0.08420444f, 0.21307473f, -0.00417097f, 0.05547387f, 0.01145858f, -0.31144753f, -0.24478970f, 
    0.02760757f, -0.01317650f, -0.05547793f, -0.13328852f, -0.14046746f, -0.03836731f, 0.19144747f, 0.06779370f, 
    0.01824502f, 0.06171216f, 0.13646935f, 0.02125006f, -0.11593939f, -0.40090901f, -0.22038014f, 0.23494899f, 
    0.17202646f, 0.16133280f, 0.09940568f, -0.01877976f, -0.18994848f, -0.14242208f, -0.18859342f, -0.29975444f, 
    -0.39100385f, -0.95607042f, -0.93439835f, -0.51682663f, -0.30728465f, -0.19043721f, 0.09258455f, -0.12663981f, 
    0.07585394f, -0.08691160f, -0.07839272f, 0.00953201f, -0.41665334f, 0.12721202f, 0.03684070f, -0.07545980f, 
    0.03284865f, -0.10923228f, -0.14492601f, -0.08492830f, -0.14453058f, -0.05418621f, -0.21781428f, -0.39324179f, 
    0.41548020f, -0.27873895f, -0.18489163f, 0.03547388f, 0.22840136f, 0.12563236f, -0.10271148f, 0.08608229f, 
    0.07740291f, 0.06889848f, -0.00920017f, -0.16828457f, -0.13822743f, 0.16851534f, 0.02933424f, -0.08364066f, 
    -0.03431043f, -0.01784594f, -0.08339188f, -0.00517662f, 0.05331870f, 0.12040845f, 0.10917607f, 0.15936184f, 
    0.31151634f, -0.04211653f, -0.11704117f, -0.23576330f, 0.20749219f, -0.11260731f, 0.04329427f, -0.03883207f, 
    0.20633832f, 0.20111343f, 0.10317107f, 0.19846168f, 0.00679494f, -0.51693034f, -0.35972106f, -0.02532989f, 
    -0.12286289f, -0.12448219f, 0.04661018f, 0.25397772f, -0.09295353f, 0.08916637f, 0.01418811f, -0.00768760f, 
    -0.44637248f, -0.44174811f, -0.48365232f, 0.20181122f, 0.01438763f, 0.22341183f, 0.03087064f, 0.13834418f, 
    0.02693083f, -0.12123491f, 0.07157160f, 0.04156308f, 0.12515223f, 0.19810797f, -0.06598961f, 0.20366113f, 
    0.06336346f, -0.10027354f, 0.06882753f, 0.13120437f, -0.02307712f, -0.02065738f, -0.04937002f, 0.06130251f, 
    -0.50546545f, 0.00983341f, 0.05409803f, -0.50281107f, -0.07433409f, 0.03376188f, 0.15206440f, -0.01592709f, 
    -0.11564046f, 0.10021048f, 0.06898183f, 0.24010174f, -0.11140755f, -0.07772940f, 0.00974236f, 0.19711541f, 
    0.23841853f, -0.03444201f, -0.07261396f, 0.14215352f, -0.05787129f, 0.03805790f, 0.12963557f, 0.02555126f, 
    -0.23106620f, -0.70387316f, -0.34321344f, -0.06063260f, -0.18622065f, -0.02168933f, -0.00582663f, -0.02762678f, 
    -0.06792201f, -0.00369333f, -0.11428664f, 0.18162778f, -0.17415383f, -0.04941381f, -0.03437098f, 0.02047354f, 
    -0.02592227f, -0.09185134f, 0.00431722f, 0.09780806f, -0.10536369f, 0.07825490f, 0.03112857f, 0.04267323f, 
    -0.29833096f, 0.04275065f, 0.02440967f, 0.10008301f, 0.06744475f, -0.03752319f, -0.09068368f, 0.09537145f, 
    0.17195249f, 0.00472854f, 0.18569838f, 0.11164425f, 0.30446893f, -0.48263171f, -0.49210787f, -0.37678194f, 
    0.05465081f, 0.05932409f, 0.01515174f, -0.01319811f, 0.08670446f, -0.12537126f, -0.11174638f, 0.02640623f, 
    0.38730267f, 0.75889921f, -0.07815836f, -0.28041974f, -0.13760716f, -0.09531476f, -0.07016883f, -0.02861942f, 
    -0.02502779f, 0.03217342f, -0.06423068f, 0.14315537f, 0.43975848f, 0.18621127f, 0.04075625f, -0.02520939f, 
    0.33051583f, 0.07284569f, 0.18963245f, -0.03602623f, 0.21891637f, 0.01490013f, -0.01000054f, 0.10999492f, 
    -0.11417156f, 0.31888098f, 0.10814956f, 0.07459917f, 0.19683886f, -0.08601819f, 0.00509667f, -0.11532041f, 
    -0.11104127f, 0.04167005f, 0.04261904f, -0.01459544f, -0.00543298f, -0.01034023f, -0.02073821f, 0.13953528f, 
    -0.11212387f, 0.05015329f, 0.08504798f, 0.04836655f, -0.09419719f, -0.04453631f, -0.06187559f, -0.37637547f, 
    -0.22088073f, 0.06622070f, 0.25451615f, -0.03569704f, -0.08862890f, 0.02535948f, -0.00604318f, -0.00843702f, 
    0.20375548f, -0.00758745f, 0.11146283f, -0.04855487f, -0.16010182f, 0.10978519f, -0.26592690f, -0.17285514f, 
    -0.16968179f, -0.02617577f, -0.07722723f, 0.12764554f, 0.06163086f, 0.31946224f, -0.12627979f, 0.05221749f, 
    -0.01838830f, -0.30756655f, -0.49502510f, -0.07339041f, -0.05421472f, 0.00518278f, 0.11334115f, 0.08685893f, 
    0.15174803f, -0.01837090f, -0.00744490f, 0.02767094f, 0.13249937f, -0.20273262f, -0.34040064f, 0.03167324f, 
    -0.06707990f, 0.05015060f, 0.11405423f, 0.06965949f, 0.01506082f, -0.13579327f, -0.05120855f, -0.13618742f, 
    -0.32476091f, -0.22982050f, -0.04195438f, 0.22717936f, 0.05958839f, 0.09044652f, -0.00073128f, -0.31330353f, 
    -0.03412111f, -0.23580262f, -0.23462455f, 0.09077235f, -0.07949317f, -0.19999929f, 0.05864009f, 0.20538238f, 
    0.02160551f, 0.28595212f, -0.02946920f, -0.08224813f, 0.20964929f, 0.16061482f, 0.02598459f, -0.10357312f, 
    0.13479640f, -0.17859867f, 0.65443492f, -0.33655083f, 0.07386866f, -0.15068263f, 0.04583907f, -0.19060591f, 
    -0.09351729f, 0.08217086f, 0.12461868f, 0.06977591f, -0.04483889f, 0.06188007f, 0.20231225f, 0.31475526f, 
    -0.02087753f, -0.10829376f, -0.15287352f, -0.22138627f, 0.11637256f, 0.05158408f, 0.00177380f, 0.02282524f, 
    0.35170144f, -0.23448586f, 0.44626167f, -0.74509209f, -0.02941962f, -0.12153361f, 0.01975246f, -0.11021926f, 
    -0.10949292f, 0.03275469f, -0.07371882f, -0.04807405f, 0.24456562f, 0.06326898f, 0.49559334f, 0.26637793f, 
    0.24099633f, -0.33889091f, 0.02881856f, -0.32362875f, -0.04344178f, -0.08078303f, 0.00019127f, -0.02521316f, 
    -0.45202863f, -0.13272861f, 0.08978376f, 0.02970877f, 0.22534166f, -0.01201334f, -0.12022777f, 0.08899768f, 
    0.16780807f, -0.09906644f, 0.04390987f, -0.02137913f, -0.52665693f, -0.27647081f, 0.16131844f, 0.32297337f, 
    -0.02082106f, 0.12120016f, -0.05171765f, -0.25552917f, -0.09062644f, -0.00853875f, 0.02523091f, 0.08411706f, 
    -0.09364860f, 0.21675660f, -0.13135321f, -0.08710632f, 0.09171715f, 0.05026207f, -0.23374121f, -0.02575409f, 
    -0.04959330f, -0.11373732f, 0.03186921f, 0.00411651f, 0.00487506f, -0.09756809f, 0.00901766f, -0.14010751f, 
    -0.03964890f, -0.04369963f, -0.15450139f, -0.02910481f, 0.09802642f, 0.00813464f, 0.18977252f, 0.07752308f, 
    -0.42848545f, -0.24325314f, 0.50621033f, -0.69799244f, -0.16558680f, -0.05513535f, 0.03891277f, 0.28912497f, 
    0.05312490f, 0.08906423f, 0.07089656f, -0.03266391f, -0.04026673f, -0.10663229f, -0.15670796f, -0.02414807f, 
    -0.05740885f, 0.13929310f, 0.25026760f, 0.01084920f, -0.05895824f, 0.13381372f, 0.28383854f, 0.23863888f, 
    0.32617152f, 0.27360943f, -0.16258699f, -0.11837810f, -0.06236234f, -0.10876603f, -0.01860753f, 0.09722261f, 
    0.05592848f, 0.22071758f, 0.06138578f, -0.01377123f, -0.29872486f, 0.15235484f, 0.08191051f, 0.16557099f, 
    0.10132980f, -0.03049668f, -0.05846551f, -0.06554732f, -0.00497263f, -0.03153772f, 0.02813339f, -0.09821735f, 
    0.27642214f, -0.34965110f, 0.06842509f, 0.11137224f, 0.01993393f, 0.00645765f, 0.08433019f, 0.04581984f, 
    -0.20754446f, -0.21026781f, -0.11195737f, -0.14752673f, 0.18861544f, 0.52358884f, -0.30823427f, -0.03063150f, 
    -0.16563885f, -0.06841873f, 0.32067829f, 0.16393536f, -0.04704804f, 0.01889615f, -0.00410158f, 0.00119407f, 
    0.04841558f, 0.18161179f, 0.29393905f, -0.17628397f, 0.22194807f, -0.40079856f, -0.38539365f, 0.10997286f, 
    -0.11099990f, -0.04024440f, -0.03268070f, -0.03227962f, -0.06204389f, -0.06802437f, -0.45988101f, 0.06857592f, 
    -0.10457297f, -0.02621409f, 0.00942194f, -0.12964354f, 0.27897209f, -0.14418432f, -0.33371091f, -0.08459450f, 
    -0.23807675f, -0.26247779f, 0.31332201f, 0.01303709f, 0.04444078f, 0.00274368f, -0.03395537f, -0.19085513f, 
    -0.05392943f, 0.10754634f, 0.07591458f, 0.02093745f, -0.58860207f, 0.31039920f, -0.72028518f, -0.39777443f, 
    -0.31399235f, -0.04423828f, 0.13662393f, -0.15858681f, 0.11580585f, -0.21306868f, 0.03613922f, 0.05207624f, 
    0.09157116f, -0.24881636f, -0.18869922f, -0.12879968f, -0.51270998f, 0.18735057f, -0.07468051f, -0.09189294f, 
    0.15760633f, 0.02675366f, 0.04160528f, 0.02556033f, -0.16479714f, 0.00203458f, 0.07638358f, 0.18579029f, 
    -0.05354705f, 0.07405416f, 0.08251680f, -0.05478258f, 0.18664382f, 0.25824019f, -0.14914660f, -0.18013373f, 
    -0.23916863f, 0.08042035f, -0.20861009f, 0.02503170f, 0.04300081f, 0.06316885f, 0.14041139f, 0.00203555f, 
    0.06864233f, -0.02075270f, -0.21358390f, -0.06349050f, -0.08307542f, -0.06109695f, 0.35045400f, 0.54416043f, 
    0.09656717f, -0.31202161f, -0.09200223f, -0.16179180f, 0.02839243f, -0.04147854f, 0.04760261f, 0.01045695f, 
    -0.39584738f, -0.78423995f, 0.29156598f, -0.11446744f, -0.14251697f, 0.15103738f, -0.40729034f, 0.16088770f, 
    0.00452886f, 0.04914781f, 0.04964557f, 0.01300828f, -0.13105120f, -0.27411717f, -0.05558224f, -0.16379546f, 
    0.05607301f, -0.11594818f, 0.15069473f, -0.05228132f, 0.11703187f, 0.00047019f, 0.02543293f, 0.12244404f, 
    -0.27756020f, -0.07512702f, -0.77075231f, 0.34282124f, 0.06658886f, 0.24131209f, 0.21193413f, -0.09176172f, 
    -0.00665903f, -0.05143655f, -0.01988560f, -0.09178416f, 0.11057479f, -0.15951826f, 0.34062979f, -0.24156787f, 
    -0.00602278f, 0.10617824f, -0.21140529f, 0.00826704f, 0.20929803f, 0.12367699f, -0.00997150f, 0.14083329f, 
    0.10308297f, 0.20878085f, -0.06541278f, 0.15339904f, -0.10520041f, -0.06603388f, -0.11569848f, -0.08512109f, 
    0.00076227f, 0.08368152f, 0.07770848f, 0.10566337f, -0.10033621f, -0.31760043f, -0.25090057f, 0.18272735f, 
    0.14261302f, -0.04588787f, -0.40886804f, -0.01271639f, -0.05304088f, -0.06633309f, -0.10316949f, -0.14297421f, 
    0.20011440f, 0.23766740f, 0.28024542f, 0.23067318f, -0.09194242f, -0.08645254f, -0.31480440f, -0.07427546f, 
    0.11764296f, -0.02064441f, 0.04668339f, 0.07721569f, -0.38826016f, -0.21996605f, 0.13686195f, -0.07439850f, 
    -0.08616079f, -0.18728407f, -0.01704049f, 0.00098926f, 0.07842393f, 0.04584493f, 0.04063137f, 0.00410262f, 
    -0.45080262f, 0.84399903f, -0.46483561f, -0.10807784f, -0.06237303f, 0.08759336f, 0.15650462f, -0.05022050f, 
    -0.13517678f, 0.11659458f, 0.11915030f, 0.05906962f, -0.40884975f, -0.47525731f, -0.22446245f, -0.40568534f, 
    -0.14556363f, 0.03888321f, -0.03785148f, -0.09100180f, 0.00997928f, -0.05512360f, -0.05628924f, -0.04804661f, 
    -0.24115880f, 0.48468310f, -0.47591043f, 0.35417351f, 0.04992172f, 0.03273684f, -0.31435314f, 0.24434736f, 
    -0.09024836f, -0.18530588f, -0.21742795f, -0.27112877f, -0.38090056f, 0.29874718f, 0.20188111f, -0.48496047f, 
    -0.01847024f, -0.12213632f, 0.00366221f, 0.28179732f, -0.15609400f, -0.14055540f, -0.43149692f, -0.11874972f, 
    0.07615002f, 0.06892432f, 0.03658293f, 0.49947125f, 0.04038494f, -0.07136092f, 0.09824645f, 0.02865264f, 
    0.07126840f, 0.01078401f, 0.04540142f, 0.13482392f, 0.19246727f, 0.03472243f, 0.09876840f, -0.13913953f, 
    -0.28481385f, -0.02630552f, 0.07507285f, -0.06063469f, 0.11385766f, -0.05975715f, -0.00508607f, -0.17526707f, 
    0.00451072f, -0.13755009f, 0.04403815f, 0.22756815f, -0.15290950f, 0.21663435f, 0.23777193f, 0.21182624f, 
    -0.18240225f, -0.08542055f, 0.14644097f, 0.08463502f, 0.09431299f, -0.22124553f, -0.02082369f, 0.17518471f, 
    -0.07655737f, 0.36551866f, 0.25363627f, 0.06091091f, -0.00186845f, -0.07590940f, -0.40583405f, -0.44560578f, 
    -0.03799165f, -0.04918994f, 0.24032786f, 0.12612604f, -0.04031014f, 0.07896601f, 0.13336208f, 0.19185457f, 
    -0.04750116f, 0.09706208f, 0.11537480f, 0.07003514f, -0.07512096f, 0.10029902f, -0.20598996f, 0.01154874f, 
    0.14837903f, -0.20554684f, -0.15817825f, -0.02202250f, -0.06604181f, 0.16151980f, -0.32519084f, -0.70257294f, 
    -0.08997758f, -0.52882773f, -0.09535939f, 0.25547022f, 0.01498102f, -0.04661988f, -0.12648702f, -0.02115667f, 
    0.17814809f, 0.04965905f, 0.03341709f, -0.05543202f, -0.08547765f, -0.00848398f, -0.07851342f, 0.04782698f, 
    -0.01712256f, -0.10989638f, -0.11066230f, -0.10670891f, -0.17021197f, -0.10311180f, -0.40543509f, -0.35218155f, 
    -0.28884554f, 0.09748006f, -0.12079163f, -0.08188742f, 0.09809292f, -0.15042250f, 0.05998876f, 0.18218043f, 
    -0.06376818f, 0.00807555f, -0.25458452f, -0.09370696f, -0.10169172f, -0.09978138f, 0.17026849f, -0.05336345f, 
    -0.16778585f, 0.06298049f, 0.09904851f, 0.03979309f, 0.09444604f, -0.03372004f, -0.01705710f, 0.31541637f, 
    -0.38243979f, 0.23782440f, -0.33331686f, 0.12163662f, -0.09539254f, 0.20147851f, -0.06291460f, -0.08745271f, 
    0.19479218f, 0.24480097f, 0.28130254f, 0.12260199f, -0.29621118f, -0.71142763f, 0.38205686f, 0.12417728f, 
    0.00231963f, 0.23281367f, 0.03283442f, -0.10026947f, -0.04791740f, 0.06211155f, 0.10070953f, 0.16373861f, 
    0.24921121f, -0.04777252f, 0.25306386f, 0.00242102f, -0.30610135f, -0.07775471f, 0.02634872f, 0.03144086f, 
    -0.01299853f, -0.09750804f, 0.18828467f, 0.05782646f, 0.02647523f, -0.13714871f, 0.38252333f, 0.17107308f, 
    -0.00435191f, 0.14479105f, 0.16448799f, 0.00877116f, 0.04082282f, -0.16516435f, 0.15773349f, -0.13607146f, 
    0.03150924f, 0.01292637f, -0.18745264f, 0.33211666f, -0.17413761f, 0.05297580f, 0.09336080f, -0.09797104f, 
    0.05310409f, 0.05180601f, -0.07499015f, 0.06405038f, 0.72169888f, 0.14650108f, 0.18701714f, 0.52235150f, 
    -0.07753940f, -0.05676851f, 0.26135823f, 0.00037596f, -0.11526590f, 0.12904166f, 0.02875944f, 0.02879412f, 
    -0.09882639f, 0.12862605f, -0.60519266f, 0.19177772f, -0.12160151f, -0.12546566f, 0.11912851f, 0.07834839f, 
    -0.09359417f, 0.20895079f, -0.14944333f, -0.05490701f, -0.11638036f, -0.32177430f, 0.01112410f, 0.17076255f, 
    -0.11014572f, -0.16862519f, -0.06151187f, 0.07035859f, 0.04910062f, -0.20491140f, 0.04680700f, 0.02599252f, 
    -0.13424294f, -0.57240319f, 0.16243064f, -0.30029240f, -0.28897664f, 0.04215950f, 0.18334182f, 0.01579276f, 
    0.00292285f, 0.04389151f, 0.10335260f, -0.03252552f, -0.58391565f, 0.19654495f, -0.05067511f, 0.04074906f, 
    0.11480808f, 0.09107136f, -0.01906134f, 0.14223252f, -0.06805300f, -0.03292823f, -0.04058031f, 0.10002621f, 
    -0.47929180f, -0.39190674f, -0.17674309f, 0.23286627f, 0.16664892f, 0.01185461f, -0.18404548f, -0.03593872f, 
    -0.05920474f, -0.18272188f, -0.10776762f, -0.02178984f, -0.33043227f, 0.25765237f, 0.21106385f, 0.11190624f, 
    -0.04330665f, 0.11972603f, -0.05105013f, 0.05600349f, -0.01722623f, -0.01799788f, 0.05908147f, -0.01595115f, 
    -0.32219127f, -0.01199649f, -0.60244882f, -0.15301605f, -0.33505979f, -0.11391462f, 0.18018818f, -0.05524100f, 
    -0.12726416f, 0.12778327f, 0.03761583f, 0.02512333f, 0.25311890f, -0.25965577f, 0.19817251f, 0.03008942f, 
    0.03063031f, 0.10998010f, 0.05647186f, 0.00983660f, -0.13538045f, -0.32417300f, -0.20315945f, -0.35537231f, 
    -0.07028439f, 0.13689312f, 0.08744505f, -0.12648255f, 0.18071775f, 0.03547462f, -0.19945490f, 0.06380994f, 
    -0.03264554f, -0.06538248f, -0.18482631f, -0.25279436f, -0.05633314f, 0.81711817f, 0.08025405f, 0.05503954f, 
    -0.05089256f, -0.11507715f, -0.01808709f, -0.23061772f, -0.27051321f, 0.46204957f, 0.08254101f, 0.14915276f, 
    -0.30488005f, 0.09990424f, -0.18788382f, 0.01465227f, 0.24390872f, 0.04074948f, -0.09477165f, 0.04857818f, 
    -0.13249405f, 0.17978278f, -0.17452668f, -0.14600626f, -0.14485151f, -0.28370985f, -0.00792994f, -0.13346618f, 
    0.07063709f, 0.05264658f, -0.16137169f, 0.22686912f, -0.19559431f, 0.07652912f, 0.02320058f, -0.03421641f, 
    -0.38141769f, -0.42442432f, -0.09642458f, 0.50984597f, 0.41406789f, -0.07767384f, 0.04418596f, 0.01854465f, 
    0.09160521f, -0.11109150f, 0.20089546f, 0.18668258f, -0.19164696f, 0.05508975f, -0.34191090f, -0.08354817f, 
    -0.04676286f, 0.03131413f, 0.00776530f, 0.04310180f, 0.03299395f, 0.21598575f, -0.09770726f, -0.12247846f, 
    -0.61989951f, -0.44617578f, 0.09722663f, 0.29878986f, -0.16310546f, 0.16437423f, -0.05404758f, 0.32761303f, 
    -0.34890360f, 0.04419129f, -0.11309389f, 0.01897717f, 0.16090371f, -0.27013519f, -0.06848976f, -0.26742178f, 
    0.15268928f, 0.02139399f, 0.02646382f, -0.11937156f, 0.03422830f, 0.23255770f, 0.08094123f, 0.16714048f, 
    -0.33023369f, -0.02580699f, -0.17309549f, 0.35026050f, -0.04120716f, 0.03949127f, -0.02973695f, 0.07328568f, 
    -0.38119060f, -0.05320245f, 0.03887006f, -0.09582616f, -0.24252328f, -0.09479002f, -0.20090364f, -0.38461441f, 
    0.14326812f, 0.02178739f, -0.19522530f, 0.18710883f, -0.04127574f, 0.18278866f, 0.14893946f, -0.20502779f, 
    0.08057754f, -0.16462903f, 0.03633909f, 0.32037255f, -0.01316438f, 0.10099416f, 0.11351966f, -0.07735685f, 
    -0.12183672f, -0.03847004f, 0.10100431f, -0.00671918f, -0.45381153f, -0.24605611f, -0.38385198f, 0.14299017f, 
    0.11973762f, -0.04631765f, 0.00035979f, 0.18795742f, 0.15401749f, 0.02477322f, 0.31443372f, 0.13477677f, 
    0.06671437f, 0.07687540f, 0.13179639f, -0.35072666f, -0.06168890f, 0.12781541f, 0.00390561f, -0.00734260f, 
    -0.09727927f, 0.04686621f, -0.21412410f, -0.01852138f, 0.06846637f, 0.23407909f, -0.19377318f, -0.29717198f, 
    0.02246729f, -0.16590133f, 0.09570419f, 0.02785811f, 0.01698187f, 0.09808707f, 0.07438607f, 0.05505332f, 
    -0.72391444f, -0.58533311f, -0.12519914f, 0.25659940f, -0.15232866f, -0.28988427f, -0.20926732f, -0.05395386f, 
    -0.01353701f, 0.11538623f, -0.01363415f, -0.12375671f, 0.20770329f, -0.13702075f, 0.14546031f, 0.28940830f, 
    0.02192513f, -0.05244557f, 0.02816576f, 0.11246463f, 0.05556443f, -0.01837099f, 0.07297359f, 0.15939893f, 
    -0.24779478f, -0.24067795f, 0.19023696f, -0.14950585f, 0.01169130f, -0.20084000f, -0.14842188f, -0.02797156f, 
    0.05500127f, 0.02614493f, 0.11948489f, 0.21519646f, 0.17439842f, 0.00974265f, 0.07995306f, -0.35329518f, 
    -0.01683041f, 0.03391842f, -0.08997012f, 0.05047145f, -0.09271935f, -0.12814382f, 0.06840487f, -0.00647557f, 
    -0.28917345f, 0.20781642f, -0.25908029f, 0.32139659f, 0.39165553f, 0.09361769f, 0.14908449f, -0.01454946f, 
    -0.07431239f, -0.08308043f, -0.27920011f, -0.13790254f, -0.08272772f, -0.04805607f, 0.11136882f, -0.33610189f, 
    -0.20413180f, -0.13119145f, -0.04432969f, -0.24552667f, 0.00591774f, -0.09399976f, -0.08745522f, -0.13031408f, 
    -0.15195726f, -0.13989408f, -0.30938268f, 0.16847515f, -0.05518245f, 0.00489491f, 0.01715627f, 0.20726305f, 
    -0.20294769f, 0.08213703f, 0.08266271f, -0.35311267f, -0.21363729f, -0.01059531f, 0.19587676f, -0.00349260f, 
    0.04656653f, -0.00480175f, -0.04858651f, 0.07490751f, -0.01721743f, 0.14445183f, 0.00839249f, 0.03360674f, 
    0.10176766f, 0.43937987f, -0.28234759f, -0.08890204f, -0.10124983f, 0.22495674f, -0.18092875f, 0.09783201f, 
    0.17015518f, -0.10364547f, 0.26917112f, -0.00909936f, -0.11060410f, -0.58029222f, 0.61504215f, 0.14320241f, 
    0.14081722f, 0.06147873f, 0.50098777f, -0.20603940f, 0.02331909f, -0.15887089f, -0.02716346f, 0.06002896f, 
    -0.06537154f, 0.26029789f, -0.08205427f, -0.31641963f, -0.26533628f, 0.01406867f, -0.00528484f, -0.37111038f, 
    0.05737056f, 0.06471315f, 0.02481782f, -0.13776398f, -0.12801431f, -0.04806620f, 0.23586078f, -0.17923065f, 
    -0.04897462f, 0.02597445f, 0.02266594f, -0.02805043f, -0.09096955f, 0.16331582f, 0.22838959f, -0.27196637f, 
    0.23876321f, 0.41919112f, -0.00828728f, 0.18360837f, 0.16494869f, -0.03518740f, 0.12004735f, -0.07235105f, 
    -0.19611406f, 0.08034593f, -0.08583120f, -0.02267777f, -0.15511461f, -0.23062581f, -0.19546428f, 0.05360381f, 
    0.12025071f, -0.00163777f, -0.15153781f, -0.10336000f, 0.02566800f, 0.07690567f, 0.04634003f, -0.12096006f, 
    -0.55793732f, 0.39874247f, -0.26831138f, 0.12229031f, 0.04243208f, 0.03873000f, 0.19434346f, -0.43807754f, 
    0.08146408f, 0.13172102f, -0.10779724f, 0.10074724f, 0.28767329f, -0.34469542f, 0.31662178f, -0.11646985f, 
    -0.03597669f, -0.10894761f, 0.09297217f, 0.22371215f, -0.05094712f, 0.12808160f, 0.04985341f, 0.09960558f, 
    0.79123539f, 0.38332468f, 0.59923124f, 0.00756294f, -0.01915370f, 0.05249975f, -0.15256834f, 0.12950756f, 
    -0.25465089f, -0.01746008f, -0.12899788f, -0.06714434f, -0.33387405f, 0.24054846f, -0.12924629f, 0.17301051f, 
    0.00280810f, 0.23143965f, -0.01119431f, 0.04102330f, -0.01055013f, 0.01058321f, 0.23245662f, 0.17272831f, 
    -0.27552009f, -0.16611172f, -0.07243885f, 0.00658057f, 0.05431588f, -0.06635255f, 0.09144574f, 0.10712188f, 
    -0.07892641f, -0.09152970f, -0.22106935f, 0.19601315f, -0.47320837f, 0.14010708f, 0.06864645f, 0.51607645f, 
    0.01236217f, 0.00258767f, 0.07000620f, -0.02182839f, -0.03540729f, -0.10758382f, 0.21166828f, 0.00647442f, 
    -0.48306277f, 0.01945172f, -0.06155862f, 0.18100493f, 0.09011705f, -0.18675390f, 0.07823374f, -0.10786077f, 
    -0.07371179f, -0.08264850f, -0.05865101f, -0.05638696f, 0.34197721f, -0.04977649f, 0.30802029f, -0.78388596f, 
    -0.12973100f, -0.27900517f, -0.02407977f, -0.01739774f, -0.01309500f, -0.02546234f, -0.05821897f, 0.00539672f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.26707882f, 0.15393311f, 0.11934493f, -0.12753217f, -0.15335990f, 0.12639523f, 0.02501621f, -0.22247165f, 
    0.12293547f, -0.00947254f, 0.01504473f, -0.03604535f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
