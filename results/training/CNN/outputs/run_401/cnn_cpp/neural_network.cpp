#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.83295524f, 0.71039099f, -1.00685954f, -0.01479977f, -0.00000941f, 0.60352850f, 0.30160680f, 0.15826519f, 
    -0.21897350f, -0.26818973f, -0.94685447f, 0.75967503f, -0.73398376f, -0.01613519f, -0.62637866f, -0.03759218f, 
    -0.33055890f, -0.49710730f, -1.23346698f, 0.22783792f, -0.25627574f, 0.43286735f, 0.94256037f, -0.08002665f, 
    -0.03709157f, -0.11065949f, -0.29956353f, -0.23376578f, -0.40467876f, -0.35415903f, 0.66629201f, 0.65748107f, 
    0.04321635f, 0.29924712f, -0.41336098f, 0.41860336f, 0.51685381f, 0.96061373f, 0.49594572f, -1.07768798f, 
    -0.31776217f, -0.51401424f, -0.18955407f, 0.14903401f, -0.10386259f, -0.35102412f, 0.30751473f, -0.28622836f, 
    0.20864971f, 0.77101922f, -0.33930412f, -0.51555055f, -0.54673541f, 0.50325793f, -0.48411405f, -0.42219734f, 
    -1.09382021f, -0.89147455f, 0.31502643f, 0.76091462f, 0.59073538f, -0.15009603f, 0.27846137f, 0.27637637f, 
    0.82857656f, -0.10765582f, -0.31086245f, 0.77605027f, -0.23014185f, 0.35196844f, 0.69657427f, 0.17684013f, 
    0.33218119f, 0.11137538f, 0.20927310f, 0.66313744f, -0.84503287f, -0.98176086f, -0.05121165f, 0.70579922f, 
    0.38778993f, 0.89102131f, -0.49401221f, -0.72303110f, 0.84317803f, 0.17491731f, -0.66806650f, -0.43766135f, 
    0.45258930f, -0.04299961f, -0.46923855f, -1.02703691f, -0.27357745f, -0.78234404f, 0.78196120f, 0.97945529f, 
    0.21757534f, -0.23363100f, 0.00534048f, -0.56091696f, -1.60503590f, 0.43109047f, 0.27382967f, 0.76766354f, 
    0.40247563f, -0.10543425f, 0.06927822f, -0.03907711f, 0.99416566f, 0.21679939f, -0.73736084f, -0.54500502f, 
    -0.12540735f, -0.36947858f, 0.38985661f, 0.49094370f, 0.43551657f, -0.94161481f, -0.17175542f, -0.25867778f, 
    -0.79808170f, -0.40943781f, -0.91358048f, 0.31442434f, -0.10595760f, 0.33443007f, -0.28292942f, -0.94681817f, 
    -0.55610853f, 0.38607574f, 0.58313149f, -0.53919613f, -0.62544870f, -0.01816445f, 0.35049021f, -0.84890747f, 
    1.35203302f, -0.59130675f, 0.13203494f, -0.40858048f, 0.02010715f, -0.12333076f, -0.18538228f, -0.17612822f, 
    1.16027009f, -0.93060058f, -0.79035288f, 0.52401698f, -0.53872806f, 0.22047342f, -0.07219960f, -0.29628929f, 
    -0.09471360f, -0.18869130f, 0.04734162f, -0.75711077f, 0.52147669f, -0.79097319f, -0.64646584f, 0.39895859f, 
    -0.56952941f, -0.57000691f, 0.36699456f, 0.70352465f, 0.27737987f, 0.41125038f, 0.14547296f, -0.82268637f, 
    -0.01699303f, -0.08270267f, 0.50144416f, 0.19296180f, 0.70129824f, 0.18781541f, 0.56211227f, 0.67353994f, 
    0.88720620f, 0.05845021f, -0.78142798f, -0.07276020f, -0.73363692f, 0.74053884f, 0.80942041f, 0.12274534f, 
    -0.59615064f, 0.19763990f, -0.50451547f, -0.17995532f, -0.03944052f, -0.56711483f, 0.85144061f, -0.62750244f, 
    -0.90485477f, 0.43169692f, 0.59867090f, 0.25246203f, -0.40662730f, 0.31931221f, -0.97977072f, 0.63266313f, 
    0.84233260f, 0.27088353f, -0.13293338f, -0.03523607f, 0.37224409f, 0.34701928f, -0.32883999f, -1.04361224f, 
    0.20626897f, -0.45489335f, 0.68811083f, 0.72509962f, 0.48907498f, 0.31471074f, 0.21592063f, 0.11982566f, 
    -0.09103698f, -0.57687742f, -0.64033031f, -0.61078912f, -0.50361151f, 0.36934441f, -0.49475265f, -0.12470359f, 
    -0.50758660f, -0.00638021f, 0.92351460f, 0.08401308f, 0.69975299f, -0.60861158f, -0.98626906f, -0.36937192f, 
    0.31058124f, -0.07790306f, 0.82551181f, 0.16960137f, -1.04492891f, -0.35466155f, -0.49311352f, 0.37144646f, 
    -0.23337799f, -0.34910059f, 0.38942543f, -0.69066280f, -0.62473845f, -0.44183186f, 0.66360849f, 0.81254256f, 
    0.38795841f, -0.12876837f, -0.09047258f, 0.06296086f, 0.72071457f, -0.56094092f, 1.07193327f, 0.43443778f, 
    -0.19030583f, -0.05105431f, -0.33543161f, 0.16077343f, -0.70221817f, 1.14202893f, 0.00054847f, 0.27153921f, 
    -0.77452230f, -0.36025420f, -0.46945512f, -0.31949085f, -0.16128926f, 0.41139278f, 0.24238522f, 0.54192740f, 
    0.71335596f, -1.01372540f, 0.78108889f, 0.13033673f, -0.44412178f, -0.11580189f, -0.22495306f, -0.56124020f, 
    0.34715477f, -0.14504786f, -0.88515073f, 0.32652247f, -0.16719078f, 0.73586041f, 0.44214278f, -0.62686765f, 
    -0.01617280f, 1.04899132f, 0.87998718f, -0.59504527f, 0.47741792f, 0.30312005f, 0.10243831f, 0.14940189f, 
    -0.30776232f, 1.11457658f, 0.82992047f, 0.83546394f, -0.51415783f, -0.21590297f, -0.36654153f, 0.05425203f, 
    -0.31873509f, -0.41854674f, 0.95489937f, 0.70619112f, 0.83517116f, 0.52216375f, 0.38249359f, -0.08588064f, 
    0.32930371f, 0.53586638f, -0.02500873f, 0.23385848f, 0.19079378f, 0.25277302f, -0.91454148f, -1.05023694f, 
    -0.20253018f, 0.41294837f, 0.13071461f, -0.39453340f, 1.00671661f, -1.14527309f, 1.10081530f, 0.63178980f, 
    -0.13525157f, 0.05732244f, 0.13788190f, 0.06471521f, -0.44035873f, 0.77089500f, 0.81938457f, 0.74222070f, 
    -0.12030198f, -0.26489976f, 0.66251278f, 0.55950117f, 0.82267410f, -0.48090723f, 0.62736225f, -0.62392056f, 
    -0.40995914f, 0.58697832f, 0.53905457f, -0.54952794f, 0.33120111f, 0.02793901f, -0.40237680f, -0.39920419f, 
    -0.10881131f, -0.34392118f, -0.54573810f, 0.09801379f, -0.74094075f, -0.45094076f, 0.63290316f, -0.61975396f, 
    -0.47859022f, 0.98016834f, 0.43648341f, 0.29807547f, 0.92459351f, -0.36478785f, -0.27097785f, -0.23963596f, 
    0.11865348f, -0.75196105f, -0.72162205f, -0.56483155f, 0.15201621f, 0.72840196f, 0.24023414f, -0.10050753f, 
    -0.22969469f, 0.07533842f, -1.03087962f, -0.13668787f, 0.74887359f, 0.04782346f, 0.95624793f, -0.19980139f, 
    -0.59818530f, 0.25962198f, 0.48165837f, 0.88391745f, -0.73780900f, 0.64097518f, -0.55718857f, -0.62584823f, 
    0.26121604f, -0.09683511f, -0.18249023f, 0.01457581f, -0.67485040f, 0.42244926f, 0.92623442f, 0.67400336f, 
    0.53711808f, 0.27951109f, 0.46220258f, -0.04388030f, 0.22123393f, -0.69156909f, 0.79675788f, 0.80266577f, 
    0.74071550f, 0.39851764f, -0.38291731f, -0.07708781f, -0.28157267f, -0.10668867f, 0.63447779f, 0.64939147f, 
    -0.62528485f, 0.67138743f, 0.63719368f, 0.57431734f, -0.22311747f, -0.58830708f, 0.24874581f, 0.25272238f, 
    -0.92084575f, 0.77315652f, 0.55604410f, -0.96211535f, 0.58749592f, 0.13544396f, -0.55394864f, 0.16718771f, 
    0.10978030f, 0.17445879f, -0.33173576f, 0.84593505f, 0.44866985f, 0.04651230f, -0.49697432f, 0.39554942f, 
    -0.08006444f, -0.46858749f, -0.61691713f, -0.90394688f, -0.56810832f, -0.05175335f, -0.27924958f, 0.04163910f, 
    -0.24449190f, 0.39403707f, -0.61018807f, -1.02342355f, -0.19649102f, 0.40072137f, -0.25736067f, -0.47404778f, 
    0.43091685f, -0.17512077f, -0.33792421f, -0.89030987f, -0.02403438f, -0.67808652f, 0.49404216f, -0.22882342f, 
    -0.80152822f, 0.13489686f, 0.45396999f, 0.13223512f, -0.43767273f, -0.80129993f, -0.48902428f, 0.31073543f, 
    0.69180006f, -0.27992490f, -0.47246093f, -0.48123616f, -0.18542933f, 0.21143138f, -0.19919932f, -0.69226480f, 
    -0.60290062f, -0.06170144f, 0.39947891f, -0.40960118f, 0.76302809f, 0.62118965f, -0.64084381f, 0.48342106f, 
    1.00186372f, 0.50344712f, 0.03035628f, 0.16205259f, -0.41858801f, 0.49491721f, -0.39794526f, 0.21093951f, 
    -0.23546124f, 1.00087535f, -1.18999171f, -0.06327190f, -0.50348902f, 0.51572841f, -0.17288209f, 0.38956535f, 
    -1.34600222f, 0.97731507f, 0.12718865f, -0.09564520f, 0.41880205f, 0.02969250f, -0.27834460f, 0.37399784f, 
    -0.35477328f, 0.53369403f, 1.00444186f, 0.08607707f, -0.14546411f, -0.59900290f, -0.34288558f, 0.64891469f, 
    -0.40460810f, 0.29456961f, -0.56671065f, -0.80280793f, -0.54814494f, 0.40678746f, 0.09283758f, 0.66599786f, 
    -0.18578677f, -0.48751834f, -0.32100856f, -0.58184904f, -0.29613751f, 0.57870215f, -0.38184342f, -0.77772599f, 
    -0.52309138f, 0.54978621f, 0.52407724f, -0.24013159f, -0.09087313f, -0.48496827f, -0.71497798f, -0.50897461f, 
    -0.47992048f, 0.37307394f, 0.38770828f, 0.58431154f, -0.54550618f, 0.64380592f, 0.86973232f, 0.67429012f, 
    -0.06751902f, -0.53136855f, 0.59051996f, -0.00716939f, 0.05118748f, -0.34198815f, 0.15123844f, 0.61327678f, 
    -0.78734505f, -0.52716506f, -0.60554588f, -0.83267158f, 0.12396231f, 0.21007024f, -0.32426828f, -0.54317009f, 
    -0.98154044f, -0.55803925f, 0.29822516f, 0.41037366f, -0.37973806f, -0.29402369f, 0.42744184f, -0.34704247f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13090107f, 0.25716704f, 0.16031463f, 0.26238489f, 0.34355468f, -0.06547860f, 0.13297187f, -0.07155887f, 
    -0.00247955f, 0.10221011f, 0.31605947f, 0.12134138f, 0.05668104f, -0.02707017f, 0.15645614f, 0.00114543f, 
    0.02305951f, -0.18720452f, 0.02313385f, 0.00749200f, -0.02494548f, -0.00473948f, 0.13978542f, -0.14924130f, 
    0.12606160f, -0.17216688f, 0.14656693f, 0.14077790f, -0.03401271f, -0.16942717f, 0.16650520f, 0.04904229f, 
    0.26573300f, 0.12590627f, 0.38267374f, 0.27258763f, -0.00978839f, 0.00434966f, 0.17480311f, 0.25288805f, 
    -0.00917563f, 0.23681048f, 0.01915941f, 0.12885612f, 0.24484988f, 0.06266773f, 0.23477763f, 0.18339875f, 
    0.18746300f, 0.03198254f, 0.13094902f, 0.10195187f, 0.16865708f, 0.02818102f, -0.00507307f, 0.23852219f, 
    0.11473224f, 0.08283249f, -0.02815255f, 0.23490170f, 0.25250152f, 0.39112738f, 0.21319272f, 0.12725036f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00416911f, -0.07141144f, 0.10843118f, -0.16628890f, 0.26473030f, -0.11789205f, 0.00371292f, -0.10566220f, 
    0.03480422f, 0.00199320f, -0.10603505f, -0.02570350f, -0.03358558f, 0.04526795f, 0.08241966f, -0.05212871f, 
    -0.02648423f, -0.01833326f, -0.00723396f, -0.03266348f, 0.10456028f, -0.29798582f, -0.04244319f, 0.08927669f, 
    -0.23233624f, -0.05683914f, -0.05695691f, 0.06313881f, 0.09404062f, 0.01678559f, 0.01102089f, 0.06645439f, 
    -0.08611474f, 0.02711321f, 0.00714446f, -0.00762241f, -0.13045858f, 0.03716995f, -0.05778709f, 0.03642122f, 
    0.32259375f, 0.10715485f, 0.17740831f, -0.15408896f, -0.10326415f, 0.05191356f, 0.04300892f, -0.02013442f, 
    0.02547377f, 0.00687560f, 0.02351470f, -0.02914763f, -0.05268870f, 0.01143690f, -0.02583824f, 0.02168303f, 
    0.05269118f, -0.02838427f, 0.07256505f, 0.00136672f, 0.03295159f, 0.03685177f, 0.00957025f, -0.12774889f, 
    -0.07908499f, -0.01849179f, 0.10552627f, -0.06390025f, -0.02648868f, -0.00410520f, -0.00511313f, 0.02633066f, 
    -0.00478848f, 0.03726481f, 0.03422063f, 0.03558144f, 0.08500976f, -0.02260800f, -0.01338688f, -0.01213119f, 
    0.06656582f, 0.02391070f, 0.01243531f, -0.04910771f, 0.09624141f, -0.06770538f, -0.02315749f, -0.07827409f, 
    -0.00964941f, 0.02057268f, -0.04101297f, -0.02077295f, -0.06754337f, -0.03267667f, 0.02279372f, -0.02503316f, 
    0.02855736f, 0.01713413f, 0.02928313f, -0.04375963f, 0.30559057f, 0.03837219f, 0.05727560f, -0.07535308f, 
    0.09854002f, -0.04723271f, -0.02781721f, -0.03771380f, -0.09404652f, -0.01332291f, 0.06519280f, 0.04147334f, 
    0.00258824f, 0.07322381f, -0.00344015f, -0.07114094f, 0.00257334f, 0.00414854f, -0.10934452f, 0.04396337f, 
    -0.37572181f, 0.20955303f, -0.12873939f, -0.00296402f, -0.22243698f, -0.02131788f, -0.05580970f, -0.03069262f, 
    -0.00155110f, 0.01464777f, 0.02516704f, -0.02543741f, -0.05234298f, 0.09363241f, 0.02604159f, -0.02899505f, 
    -0.05898575f, 0.01975192f, 0.03627126f, -0.08572078f, -0.28617927f, -0.08678218f, -0.00495131f, 0.01348590f, 
    0.13977836f, 0.06718360f, 0.00117872f, -0.04134124f, 0.01679183f, 0.06350651f, 0.05180198f, 0.05213240f, 
    0.02068114f, 0.03390504f, 0.13582970f, -0.02945887f, -0.06764468f, -0.00546208f, -0.05741764f, -0.08143985f, 
    0.01954461f, -0.11628073f, 0.17334123f, -0.11116678f, -0.02973910f, -0.03883181f, -0.00403966f, -0.03687041f, 
    -0.10068419f, 0.06134637f, -0.15732890f, 0.01000839f, 0.03616348f, 0.01745813f, 0.00913537f, 0.06449213f, 
    0.05399904f, -0.02673709f, -0.01974409f, -0.06470067f, 0.15440273f, -0.20242161f, 0.07937680f, -0.01035761f, 
    0.16546221f, -0.01615694f, -0.11311339f, 0.05658052f, -0.00936386f, -0.03082884f, -0.06290290f, 0.10179805f, 
    0.11858767f, 0.06085159f, -0.03269487f, 0.01665479f, 0.11235345f, 0.01425738f, -0.05781854f, 0.06618715f, 
    -0.29044464f, 0.21542972f, -0.10749775f, -0.02623630f, -0.19244543f, -0.03654346f, 0.01319733f, -0.06993724f, 
    0.08477451f, -0.04349538f, 0.04656072f, -0.02587977f, -0.04898589f, 0.06879551f, 0.03436628f, -0.03825047f, 
    -0.06460544f, -0.08875822f, 0.09136261f, 0.02665639f, -0.34321314f, 0.12559517f, 0.06174496f, -0.08947669f, 
    -0.34897271f, 0.05690058f, -0.03852203f, 0.07525711f, 0.08524218f, -0.03636726f, -0.00914283f, 0.03859960f, 
    -0.07166964f, -0.05017045f, -0.02131714f, 0.00160238f, 0.03154728f, -0.02213048f, -0.02994717f, 0.04667279f, 
    -0.16717830f, -0.08153030f, 0.05887649f, 0.01041678f, 0.18579888f, -0.06087844f, 0.02066821f, -0.03635472f, 
    0.09160145f, 0.02716057f, 0.03586213f, -0.03204359f, 0.02480697f, 0.00601087f, 0.00970693f, 0.01026638f, 
    -0.04868788f, -0.04294281f, 0.09702425f, 0.00362176f, -0.32149708f, -0.50709945f, -0.14003322f, 0.08302814f, 
    -0.00590478f, 0.07090023f, -0.10596621f, -0.01293861f, 0.06000917f, 0.04501595f, 0.08357470f, 0.09347243f, 
    -0.09564646f, 0.01669604f, -0.00734218f, 0.04029707f, -0.02688350f, 0.05760982f, 0.01671488f, -0.09096967f, 
    -0.04783021f, -0.02472299f, 0.02054080f, -0.03312714f, -0.19790812f, 0.01305269f, -0.02116893f, 0.08439489f, 
    -0.02923550f, -0.02063932f, 0.02719213f, -0.03193615f, -0.03015245f, -0.01736122f, 0.03595684f, -0.07541770f, 
    -0.03773950f, 0.06128896f, -0.11142571f, 0.03429559f, 0.30081740f, 0.17531085f, 0.26044616f, -0.08247247f, 
    0.15305881f, -0.01570694f, -0.10688797f, 0.02475354f, -0.07506549f, -0.06107296f, 0.02557171f, -0.01612318f, 
    -0.03737380f, -0.09595784f, 0.06521067f, -0.04062413f, -0.00544324f, 0.09611013f, -0.08588172f, -0.06640361f, 
    0.25710565f, -0.42529470f, 0.15204267f, 0.14431436f, -0.06980833f, 0.07271896f, 0.11575101f, 0.02227164f, 
    0.04289255f, -0.08516011f, -0.22210650f, -0.00518682f, -0.01134086f, -0.03785194f, 0.01834609f, 0.03923583f, 
    0.10006793f, 0.09711538f, -0.01657985f, 0.03112224f, 0.05186132f, -0.33336598f, 0.15611511f, 0.14390834f, 
    0.10122898f, 0.00093187f, 0.01033541f, -0.04699883f, 0.02743147f, -0.03832166f, 0.08894870f, 0.03246500f, 
    -0.02907084f, 0.10853663f, -0.01472546f, 0.08067290f, 0.05557135f, 0.10091642f, -0.06028232f, -0.16006978f, 
    0.01893217f, 0.00549088f, 0.05229800f, -0.10853164f, 0.03516338f, -0.14352758f, -0.12856047f, 0.01985433f, 
    0.01875050f, -0.01450082f, -0.03360080f, -0.00132770f, -0.01219125f, -0.00183396f, -0.08426464f, -0.00910712f, 
    -0.00990761f, 0.08507620f, -0.08501092f, -0.05211037f, 0.03726084f, -0.07403320f, 0.05867920f, -0.10411816f, 
    0.17955172f, -0.00955679f, -0.03701128f, 0.01574840f, -0.03408680f, -0.03141762f, -0.00474036f, -0.00785663f, 
    -0.02905360f, -0.07539691f, 0.06724159f, 0.07485352f, 0.13231546f, -0.09877865f, -0.00205551f, 0.07699870f, 
    -0.30342880f, 0.15585753f, -0.02265476f, 0.21326014f, 0.14299725f, -0.00560259f, -0.08099093f, 0.00207023f, 
    0.05752003f, 0.03267669f, 0.04173243f, -0.06348135f, -0.06860106f, 0.05930871f, -0.05680172f, -0.02397774f, 
    -0.02011702f, -0.01022705f, 0.01271125f, 0.06027767f, 0.00723793f, 0.16627070f, 0.01648567f, -0.15189305f, 
    0.07348508f, -0.04436192f, -0.01223195f, -0.05274370f, 0.06289246f, -0.04916745f, -0.02562341f, 0.02031364f, 
    0.06295651f, 0.07909422f, 0.08824922f, -0.12649381f, -0.02784548f, -0.00103416f, -0.03287697f, -0.09629655f, 
    -0.29955488f, 0.13612111f, 0.03685175f, 0.04316669f, 0.03842787f, 0.00171324f, -0.09493257f, 0.05760727f, 
    -0.06176301f, -0.05563035f, 0.06124848f, -0.01281666f, 0.04969056f, 0.02419719f, -0.07034234f, -0.05376475f, 
    -0.02822182f, -0.07828479f, -0.05764256f, -0.07484952f, 0.32639387f, 0.07910280f, 0.05828582f, -0.12841623f, 
    -0.15064386f, 0.04756190f, 0.04361932f, -0.06165556f, 0.04821972f, -0.06297164f, 0.03267287f, -0.05014020f, 
    -0.05626425f, 0.01757720f, 0.06899443f, 0.06110779f, 0.03928447f, 0.01118039f, 0.09664101f, -0.02036655f, 
    0.07455005f, -0.15372744f, -0.00745889f, 0.07616585f, -0.06892271f, -0.04331332f, 0.00133605f, -0.04779238f, 
    0.00473299f, -0.02551812f, 0.01100534f, -0.04972169f, 0.06620575f, 0.03756981f, -0.04829224f, -0.00473245f, 
    -0.02353978f, -0.07439953f, 0.04782213f, -0.04544146f, -0.06647115f, 0.04833662f, 0.12857641f, -0.11987766f, 
    0.06114813f, -0.02014687f, -0.10176532f, 0.06980053f, -0.07642262f, 0.04008295f, -0.10607567f, 0.07240028f, 
    -0.08364782f, 0.06261710f, -0.08011647f, 0.01048473f, 0.03303913f, 0.07589900f, -0.07338346f, -0.01010619f, 
    -0.10892555f, -0.14426579f, 0.04465169f, 0.00234432f, 0.10613250f, -0.03933896f, 0.07764228f, -0.00161134f, 
    0.05369033f, -0.02786213f, -0.05110897f, 0.00476431f, 0.00108424f, 0.01451525f, -0.01387536f, 0.04052337f, 
    -0.07021918f, -0.07114652f, -0.02482021f, -0.02611918f, 0.12163756f, 0.16528681f, 0.13643573f, -0.16159116f, 
    -0.27530521f, 0.03207821f, 0.09271728f, -0.05080874f, 0.03869818f, -0.08610689f, 0.01789433f, -0.02887695f, 
    -0.03698554f, -0.01872817f, -0.02748149f, 0.09563258f, 0.04926588f, 0.03513950f, 0.03735442f, -0.03643194f, 
    0.25866449f, -0.09990592f, -0.06176746f, 0.16838828f, -0.31399432f, -0.03699454f, -0.16269951f, 0.04543018f, 
    0.01509898f, 0.02321205f, -0.01811693f, 0.08728653f, -0.01053329f, 0.03824095f, -0.04070310f, 0.05188882f, 
    -0.09722809f, 0.10839618f, -0.01282855f, 0.01106008f, 0.23032607f, 0.02031367f, 0.07430926f, 0.02338558f, 
    -0.08464298f, 0.00704371f, -0.08344948f, -0.10756557f, 0.09792906f, 0.03814396f, -0.10341715f, -0.00552876f, 
    0.00556368f, 0.07437685f, -0.00045750f, -0.05296353f, 0.01381339f, -0.08290939f, 0.12635761f, 0.02280411f, 
    0.02039789f, 0.04485966f, -0.05913460f, 0.01333857f, 0.17376080f, -0.16824345f, -0.01619145f, -0.05528166f, 
    -0.02905976f, -0.02729953f, 0.02748443f, -0.04064424f, 0.07764747f, -0.11357585f, -0.03948156f, 0.00406406f, 
    0.01362580f, -0.06810027f, -0.03565888f, 0.02692660f, -0.15268177f, -0.05340745f, 0.00655938f, 0.09850544f, 
    0.04394980f, 0.02176062f, -0.04121399f, 0.02531964f, 0.00581484f, 0.01127493f, 0.02513534f, -0.02704494f, 
    -0.02199627f, 0.05325533f, 0.01760340f, -0.00310008f, 0.07989498f, -0.02401842f, 0.00333322f, -0.15826534f, 
    -0.07440109f, 0.04813315f, -0.00399838f, 0.01438415f, 0.30638656f, -0.07783389f, -0.08816490f, -0.03195971f, 
    0.00255512f, 0.02362106f, -0.03401517f, -0.01121052f, 0.04612092f, -0.05820691f, -0.00303934f, -0.01627895f, 
    0.00298044f, -0.03737240f, 0.00069765f, -0.01434470f, 0.16693854f, 0.14219478f, -0.03448594f, -0.08401661f, 
    0.10405754f, -0.16400740f, -0.15757635f, -0.04513701f, 0.05979066f, 0.04083601f, -0.02860207f, 0.01001329f, 
    -0.04353011f, -0.03697886f, 0.01181538f, 0.03095088f, 0.04485147f, 0.03830240f, 0.02139175f, 0.07718456f, 
    0.04278360f, 0.02973371f, -0.02551022f, -0.14578763f, 0.06884414f, -0.09787232f, -0.08389381f, -0.02416879f, 
    0.04445079f, -0.03667877f, 0.02062637f, 0.06183757f, -0.05093317f, 0.01413844f, -0.06237456f, -0.03905586f, 
    -0.02172802f, 0.01557546f, -0.03437295f, -0.01579482f, 0.09370282f, -0.09242161f, 0.07581873f, 0.07477129f, 
    0.02813321f, -0.02504397f, -0.03575738f, -0.04477716f, -0.05872589f, -0.04530575f, -0.01501843f, -0.06278417f, 
    0.07482183f, -0.05199971f, -0.02185478f, -0.03617473f, 0.01729392f, -0.02080094f, 0.01826875f, -0.03130874f, 
    0.22766510f, -0.17713535f, -0.00773767f, -0.02540037f, -0.46089828f, -0.06243347f, -0.07586762f, 0.04308010f, 
    -0.01994634f, -0.05223310f, -0.12700853f, 0.12047342f, -0.08748139f, 0.03573037f, 0.05644336f, -0.06880942f, 
    -0.10659691f, 0.12173631f, 0.02557328f, 0.01827981f, 0.01328098f, 0.10761412f, -0.05405978f, -0.06648999f, 
    0.12752789f, -0.02798878f, 0.00841760f, -0.02558533f, -0.00420688f, 0.00785381f, -0.03366661f, -0.04799592f, 
    0.06856453f, 0.03652872f, -0.03572787f, -0.02596342f, -0.07029900f, -0.12161604f, 0.01245285f, 0.03397055f, 
    -0.03961555f, 0.02149431f, 0.01729006f, 0.02615857f, 0.12221377f, -0.07418150f, 0.00115200f, 0.04418386f, 
    0.00994985f, -0.04800135f, 0.01186226f, 0.06233970f, 0.01439617f, -0.00959175f, 0.01941186f, 0.00194596f, 
    0.04135179f, 0.06149266f, 0.00404023f, -0.00160073f, -0.11452097f, -0.21119517f, 0.02186511f, 0.01318658f, 
    0.01389942f, 0.00938052f, 0.00825188f, 0.00531767f, -0.03137555f, 0.10099591f, -0.03911046f, 0.04539375f, 
    -0.05253918f, -0.05619184f, 0.01840671f, -0.04267944f, -0.01462718f, -0.03912158f, 0.06012033f, -0.08032626f, 
    0.27388930f, -0.00760002f, 0.19166753f, -0.03926042f, 0.13382751f, -0.10416319f, -0.02963069f, 0.04826974f, 
    -0.05827692f, -0.05082083f, 0.03152591f, -0.00114978f, -0.06348803f, 0.03267851f, 0.00615203f, 0.02005092f, 
    -0.01954229f, 0.03221399f, -0.07196829f, 0.00661005f, 0.10395094f, 0.12058160f, 0.02660914f, -0.11759710f, 
    -0.23045555f, 0.02331161f, 0.01264700f, -0.03057729f, 0.03450776f, -0.02829675f, -0.00813842f, -0.00628926f, 
    0.00233370f, 0.02434065f, -0.03912937f, 0.00494353f, 0.00732905f, 0.03018600f, 0.00812312f, -0.01940430f, 
    -0.01213476f, 0.06472820f, 0.16300431f, 0.07666048f, -0.18890415f, -0.01767514f, 0.06241837f, 0.07058015f, 
    0.04525686f, -0.01640360f, 0.00494319f, 0.01955674f, 0.00088340f, 0.03286005f, 0.04073199f, 0.03636870f, 
    0.00867706f, -0.03161606f, -0.02616611f, 0.02277640f, 0.21487826f, -0.13045694f, 0.04669350f, 0.04040471f, 
    -0.22120573f, -0.02687172f, -0.00299255f, -0.00615313f, 0.00992959f, -0.01722389f, -0.10150664f, 0.01139868f, 
    -0.01777759f, -0.01172694f, 0.03870526f, -0.01331141f, -0.04115873f, 0.03526349f, 0.05042386f, 0.07203270f, 
    0.05809612f, -0.13076714f, 0.13768342f, -0.00617224f, 0.03843526f, -0.01448856f, -0.06053691f, 0.06643379f, 
    -0.07861327f, -0.02563628f, -0.00767349f, -0.02964921f, 0.09123278f, 0.01719424f, 0.05081502f, -0.01221477f, 
    -0.01768683f, -0.01745174f, 0.03061645f, -0.01528300f, 0.10099763f, -0.00139863f, 0.22315218f, 0.04880847f, 
    0.08540370f, -0.11549953f, -0.12425979f, 0.07273199f, -0.03788056f, -0.02952900f, 0.04623433f, 0.00349798f, 
    -0.00995255f, 0.03777967f, -0.05277079f, 0.05007684f, -0.05226785f, 0.01811627f, -0.05190405f, -0.02924264f, 
    -0.01333183f, 0.00120181f, 0.01564524f, -0.11453547f, 0.17594117f, -0.06681722f, 0.03699408f, 0.03434867f, 
    0.06031045f, -0.09142521f, -0.01642537f, 0.01662523f, -0.01797837f, 0.00553895f, -0.00780249f, 0.07691217f, 
    0.01136832f, -0.00648982f, -0.12301373f, 0.05616266f, 0.05244453f, -0.19938125f, 0.09518100f, 0.02018674f, 
    -0.28310236f, 0.01779828f, 0.06211143f, 0.01930508f, -0.00578729f, 0.04216003f, -0.11193720f, 0.05011453f, 
    -0.01650748f, -0.04047193f, 0.08783071f, -0.02730057f, 0.01921263f, 0.06895331f, 0.01051014f, -0.01204856f, 
    0.11520731f, 0.05730058f, 0.01169957f, -0.11058369f, 0.08711620f, 0.03353481f, -0.08411326f, 0.01980233f, 
    -0.02858176f, -0.05941695f, 0.10112891f, -0.02412102f, -0.00167074f, 0.04883727f, -0.00432829f, -0.06237648f, 
    0.03199810f, -0.01360059f, -0.03246264f, 0.10110664f, -0.17364497f, -0.09705370f, 0.00078756f, -0.04154037f, 
    -0.13483387f, 0.04516441f, -0.09962120f, 0.08034051f, 0.04919638f, 0.03503522f, -0.00286764f, -0.04330010f, 
    -0.05584003f, -0.01836316f, 0.01495289f, 0.00333401f, -0.08380444f, -0.03962105f, -0.02113323f, -0.03972418f, 
    -0.19832058f, -0.24954088f, 0.01213608f, -0.01604991f, -0.20949273f, 0.04210281f, -0.02415527f, -0.01443099f, 
    0.06202619f, -0.02303213f, -0.05462084f, -0.05031225f, -0.00344828f, -0.04458521f, 0.05636030f, 0.04403295f, 
    0.06453732f, 0.02198640f, -0.00581075f, 0.03040928f, 0.13647449f, -0.35765922f, -0.12431867f, -0.07555899f, 
    -0.02966708f, 0.00979658f, -0.10080072f, -0.01146340f, -0.08067486f, 0.04759708f, 0.04840557f, -0.00064651f, 
    -0.04890884f, 0.02349883f, 0.10331138f, -0.03311808f, 0.07106519f, 0.01419138f, 0.00277740f, -0.07618760f, 
    0.07564703f, 0.06183255f, 0.04867616f, 0.00151664f, -0.23016597f, 0.02224475f, 0.05704300f, 0.00256585f, 
    -0.00781587f, -0.02368401f, 0.03275073f, -0.02557319f, 0.00170733f, 0.02955243f, -0.02912581f, 0.00067606f, 
    -0.01965189f, 0.02308863f, -0.01645059f, 0.00595115f, -0.15729247f, -0.17747229f, -0.00045229f, -0.02706048f, 
    -0.06952082f, 0.00079268f, -0.02813885f, 0.04610714f, -0.02118338f, 0.00621160f, -0.01181502f, 0.01555545f, 
    0.03636839f, 0.02327264f, 0.04754616f, -0.06083991f, -0.06440713f, -0.02680508f, 0.02014685f, -0.03295342f, 
    -0.39094296f, 0.07328714f, 0.16678616f, 0.15753436f, 0.05319593f, -0.01370613f, -0.11607319f, 0.04023895f, 
    0.00860258f, -0.02801548f, -0.00031946f, 0.03161222f, 0.05915903f, 0.00664060f, -0.06189284f, 0.03284300f, 
    -0.06273045f, -0.03304375f, -0.06350067f, -0.09044575f, 0.18620625f, 0.03221833f, -0.06147912f, 0.04815576f, 
    -0.15258422f, -0.07894076f, -0.04442629f, -0.05419000f, -0.00250302f, 0.02595207f, -0.00055917f, -0.00505120f, 
    -0.00130021f, -0.03279245f, -0.03464613f, -0.08646071f, -0.00005220f, 0.07265805f, 0.02966132f, 0.03996403f, 
    0.09392513f, 0.08921836f, 0.17054951f, -0.02337970f, 0.15483961f, 0.05046359f, -0.06873350f, 0.04178202f, 
    -0.05773708f, -0.03047790f, -0.01280359f, -0.00968504f, -0.08678252f, -0.04439387f, 0.00671515f, 0.00177967f, 
    -0.03422909f, 0.03269914f, 0.05324918f, -0.04364686f, 0.11761665f, 0.11938235f, 0.08290210f, -0.12901656f, 
    0.08487090f, -0.18705118f, -0.04666181f, 0.01169611f, -0.00181495f, -0.04846102f, 0.04192946f, -0.04111603f, 
    0.08648743f, -0.02793329f, -0.00075128f, 0.11181948f, -0.04666987f, 0.06389997f, -0.10705025f, 0.00408434f, 
    0.06876522f, 0.03621637f, -0.01710226f, -0.11963977f, -0.38773626f, 0.10400212f, 0.11080240f, 0.01537244f, 
    0.08980138f, -0.01607651f, 0.07131356f, -0.04546880f, -0.00667806f, 0.02701036f, -0.02445508f, 0.10013954f, 
    -0.01058916f, -0.00059301f, 0.08962999f, -0.00338981f, -0.31663468f, -0.18412474f, -0.11225302f, 0.14269416f, 
    -0.09114349f, -0.02239809f, -0.01927614f, -0.00852908f, -0.03093840f, -0.02228701f, 0.01389938f, 0.03736635f, 
    0.04069809f, -0.07548248f, -0.07188538f, -0.00276113f, 0.03048177f, -0.01879737f, 0.02716904f, -0.03957680f, 
    0.04783930f, -0.24179310f, -0.04066073f, 0.07379644f, -0.04064615f, -0.11112503f, -0.01970905f, 0.01620666f, 
    -0.02829957f, 0.03920312f, -0.01242342f, -0.11540663f, 0.03487580f, -0.05063664f, 0.03656297f, -0.03568814f, 
    -0.07619832f, -0.05647847f, 0.00966823f, -0.00165128f, 0.01331251f, 0.08775771f, 0.02210581f, -0.05665740f, 
    0.14994949f, -0.12725730f, -0.11549909f, -0.05440987f, 0.01905510f, 0.01514554f, -0.02849407f, -0.04740468f, 
    0.02582401f, -0.02658156f, -0.03107216f, 0.05024221f, 0.01908277f, -0.13427100f, 0.00464789f, 0.07015727f, 
    -0.00149004f, -0.13654555f, 0.17988428f, 0.03757988f, 0.15341675f, -0.02588600f, 0.00660763f, 0.02432546f, 
    -0.05616191f, 0.02922532f, -0.00340931f, -0.04478794f, -0.06082654f, -0.02512465f, 0.02281432f, 0.00052558f, 
    0.03965188f, 0.00559383f, 0.11415239f, -0.06912409f, -0.26451373f, -0.05644680f, -0.02623126f, -0.12456676f, 
    -0.31631881f, 0.05010385f, -0.03788117f, 0.06746587f, 0.02577252f, 0.00687274f, -0.03015708f, -0.04401726f, 
    -0.02269499f, -0.05248040f, -0.00215380f, -0.04299733f, 0.02453127f, 0.02499436f, -0.03592004f, 0.02625388f, 
    0.19260694f, -0.28345445f, 0.08828071f, -0.01515231f, -0.01871587f, -0.03594327f, -0.05975573f, 0.02939587f, 
    -0.02840095f, -0.01536121f, 0.12554231f, -0.02781848f, -0.08454991f, 0.05648656f, -0.00636501f, -0.01603963f, 
    0.01558704f, 0.05515311f, 0.01322547f, -0.01891516f, -0.19569086f, -0.00413520f, -0.00042621f, 0.02831515f, 
    -0.25108156f, 0.03952397f, 0.02373911f, -0.02100265f, 0.00544813f, -0.05440494f, 0.02654016f, -0.05657257f, 
    0.00154206f, -0.04414961f, 0.06274973f, -0.05730115f, -0.00141929f, -0.07333808f, -0.05729803f, -0.02729243f, 
    -0.35688695f, -0.01877202f, -0.13642465f, -0.07400789f, 0.02716449f, 0.00852177f, -0.00222371f, -0.06064903f, 
    0.04277463f, 0.05714998f, 0.05147601f, 0.08261063f, -0.00285448f, -0.02491245f, 0.03302127f, 0.06436734f, 
    -0.00448585f, -0.00744882f, -0.02079823f, 0.00487459f, 0.03408119f, 0.03462780f, -0.01310059f, 0.02298873f, 
    -0.09867942f, 0.06697407f, 0.05311956f, 0.04027874f, -0.05487906f, -0.01759501f, -0.00285963f, 0.03453841f, 
    -0.00819144f, -0.00411813f, 0.01306156f, 0.01888687f, 0.05072568f, -0.04821282f, 0.06047997f, 0.00163186f, 
    0.11842711f, 0.04774203f, -0.16621451f, 0.03609983f, -0.01178494f, 0.05085592f, -0.05325318f, 0.05664485f, 
    0.02372436f, 0.00564369f, 0.01312307f, -0.02629973f, 0.05249479f, 0.05993802f, 0.02024165f, 0.04625319f, 
    0.01887119f, -0.06496749f, -0.05955903f, 0.02155813f, -0.22384395f, -0.07791769f, 0.00411091f, -0.00591101f, 
    -0.01213167f, 0.06162719f, 0.05042479f, -0.07761509f, 0.10540779f, -0.08156747f, -0.00948724f, 0.06054665f, 
    0.00267788f, -0.12235377f, 0.05180898f, -0.03477351f, 0.03987964f, -0.00787727f, 0.13768250f, -0.06854364f, 
    0.35376808f, -0.05333312f, -0.07659057f, 0.03074922f, -0.07711826f, 0.00250460f, 0.07254968f, -0.03826368f, 
    0.06416713f, 0.06950677f, 0.02087364f, -0.11345683f, 0.05731624f, -0.01366628f, 0.01826729f, 0.11125784f, 
    -0.06940919f, 0.04148740f, -0.09363551f, 0.11157946f, 0.22637108f, 0.18812589f, 0.10121445f, -0.10640642f, 
    0.00094094f, -0.16870503f, -0.06482245f, -0.00427072f, -0.03313009f, 0.06440732f, 0.09319144f, 0.01566177f, 
    -0.06271192f, 0.00504175f, 0.00980289f, 0.01169346f, 0.12061138f, 0.00449850f, -0.04678018f, 0.02741090f, 
    -0.15059027f, -0.02520154f, 0.10993108f, -0.12604806f, 0.18952155f, -0.00605600f, -0.03625264f, 0.08270308f, 
    -0.05206070f, -0.03929143f, 0.04567728f, 0.00900308f, 0.03531205f, -0.01264876f, 0.04762833f, -0.06753249f, 
    -0.00276796f, -0.11742044f, -0.01519891f, 0.08086180f, 0.22606671f, -0.39490688f, 0.07189106f, -0.19066903f, 
    -0.07279585f, -0.02208638f, 0.01395926f, -0.05319922f, -0.04282907f, -0.01549893f, -0.08539299f, -0.05636071f, 
    -0.05030965f, 0.00530437f, 0.00556512f, 0.02376452f, 0.05561734f, -0.14943954f, 0.06052212f, 0.01310826f, 
    0.19676304f, -0.04992423f, -0.00894848f, 0.06618554f, -0.12464166f, -0.08414058f, -0.02718651f, -0.03368343f, 
    0.04431880f, 0.01056415f, 0.04835054f, -0.04969246f, -0.00876761f, -0.01797456f, 0.02010557f, 0.04791544f, 
    -0.02414120f, 0.02507501f, -0.12948720f, 0.07276937f, 0.17235792f, -0.04419165f, -0.10754060f, 0.11909322f, 
    -0.22042529f, -0.07904088f, 0.06100276f, 0.04461778f, -0.04110892f, 0.04756935f, 0.02940754f, 0.00376833f, 
    -0.09287680f, 0.10865552f, -0.00180164f, 0.01991755f, 0.07577047f, 0.00292681f, -0.06602344f, -0.05526067f, 
    0.32148027f, -0.27082586f, 0.05527514f, -0.04374885f, -0.09266701f, 0.02927310f, -0.07849795f, -0.01453422f, 
    0.04818039f, 0.02539904f, -0.03535721f, 0.04774211f, -0.03514545f, 0.04629817f, 0.05694620f, 0.08658467f, 
    -0.08590446f, -0.02083723f, -0.09823360f, -0.03787199f, 0.01781690f, -0.02269042f, 0.05894224f, -0.01809464f, 
    -0.11568582f, 0.05020176f, 0.00760373f, 0.11103036f, 0.02362344f, 0.04205943f, -0.12908264f, -0.08913369f, 
    0.12109783f, 0.03615205f, 0.03925159f, -0.03119430f, 0.04246758f, -0.17582324f, -0.17261754f, -0.16397144f, 
    0.12017229f, -0.12487652f, -0.06165997f, 0.02352464f, -0.20420820f, -0.01333964f, 0.01487693f, -0.01444327f, 
    0.06730137f, 0.04656774f, 0.03111263f, -0.01794410f, 0.03914473f, 0.00929633f, -0.02490671f, 0.04255493f, 
    -0.01130726f, -0.02859452f, 0.02472499f, -0.04437927f, -0.23035188f, -0.25113741f, -0.30082110f, -0.29033411f, 
    0.34747666f, 0.04017689f, -0.04629469f, -0.01626320f, -0.02051610f, -0.04554155f, 0.13506080f, 0.01948259f, 
    -0.07109462f, -0.01416676f, 0.04272257f, -0.05673578f, 0.03142757f, -0.02572970f, 0.09130215f, -0.14047182f, 
    0.05381664f, -0.40951312f, 0.19988905f, -0.32912421f, 0.01255750f, -0.03496880f, 0.05633793f, -0.01265133f, 
    0.01722806f, 0.04319450f, 0.08881097f, -0.03717013f, -0.04573948f, 0.07247787f, -0.07915365f, -0.01795074f, 
    -0.02401081f, -0.13062257f, -0.01047452f, -0.10932007f, -0.25767398f, 0.05023988f, -0.39548990f, -0.28475061f, 
    0.05086435f, 0.13098410f, -0.06726099f, 0.05181496f, -0.13927422f, 0.06904718f, -0.06855878f, -0.05798510f, 
    0.07230394f, -0.12146828f, 0.00056955f, -0.05657829f, -0.03158128f, -0.13682149f, -0.00024597f, 0.04309228f, 
    0.09844726f, -0.00682921f, 0.11781644f, -0.05757251f, 0.10560744f, -0.05501057f, -0.06864309f, -0.02099540f, 
    -0.04051824f, 0.01816887f, -0.04286721f, -0.04484075f, 0.05822501f, -0.06418710f, 0.12957941f, -0.05428812f, 
    -0.03207242f, -0.05630398f, -0.01815031f, 0.01346072f, 0.08079298f, 0.18880446f, 0.06544758f, 0.07722541f, 
    0.05547120f, -0.02390630f, 0.04694882f, -0.05300386f, -0.01987551f, -0.04787932f, 0.01123939f, 0.02260200f, 
    0.04665241f, 0.04576754f, 0.03524880f, 0.04328024f, 0.01546585f, 0.08574905f, 0.01237462f, 0.03488913f, 
    0.21240409f, -0.02815702f, -0.21780422f, -0.09980556f, -0.08718952f, -0.05302829f, 0.01649535f, 0.05806793f, 
    -0.19466250f, -0.00893389f, -0.02438337f, -0.01815368f, 0.09356935f, -0.00531112f, 0.05288645f, 0.09300109f, 
    -0.09486198f, 0.06723644f, -0.05124648f, -0.10024816f, 0.30033836f, 0.00645052f, -0.11572658f, -0.12283742f, 
    0.00109888f, 0.07037660f, 0.10298647f, -0.05523248f, 0.05355009f, -0.07579538f, 0.02631890f, -0.10410856f, 
    -0.00387942f, 0.06393684f, 0.04742029f, -0.01348555f, -0.08310217f, 0.04104069f, -0.01962643f, 0.16693120f, 
    -0.16649134f, -0.08590265f, -0.07611472f, -0.01681340f, -0.03784952f, -0.04098997f, 0.05514574f, -0.04156050f, 
    -0.02036264f, 0.07120845f, -0.05905537f, 0.08198576f, -0.10575171f, -0.11598954f, 0.02996993f, -0.00405600f, 
    -0.04531387f, 0.07193442f, 0.04103988f, 0.12091427f, -0.19553423f, 0.08403815f, -0.09684066f, -0.03307787f, 
    -0.02672100f, -0.01427303f, -0.00251056f, 0.03605875f, -0.03292677f, 0.07348149f, 0.04861543f, -0.01648492f, 
    -0.02020948f, -0.01210599f, -0.01003796f, 0.10785980f, 0.07411250f, 0.01563560f, -0.03608667f, 0.04442818f, 
    -0.15580285f, -0.13414001f, 0.04079303f, -0.11366889f, 0.00129358f, -0.06313973f, 0.00473467f, -0.01961247f, 
    0.05537799f, 0.00604071f, -0.00685197f, -0.01360943f, 0.01719963f, 0.03492334f, -0.09798633f, -0.05917316f, 
    -0.02278451f, -0.02122897f, -0.02116610f, -0.09070735f, -0.02205822f, -0.19306754f, -0.00078197f, -0.07589210f, 
    0.27657628f, -0.01704893f, -0.00617992f, 0.03041339f, -0.01909661f, -0.03059436f, 0.06605639f, 0.05858035f, 
    0.10708474f, -0.07450315f, 0.05399752f, -0.03402125f, -0.07948892f, -0.16289598f, 0.06007266f, 0.02354872f, 
    0.07897528f, -0.39487168f, 0.01012746f, -0.16126060f, 0.00380528f, -0.09965494f, -0.11733006f, 0.03480118f, 
    0.10321533f, -0.01962814f, -0.07980608f, -0.01848578f, -0.09510340f, 0.04243556f, -0.01016315f, -0.11838935f, 
    -0.06277607f, 0.01362323f, -0.00679383f, -0.12552035f, 0.07014997f, 0.05018536f, -0.17233677f, 0.03790230f, 
    -0.18387547f, 0.02216599f, 0.01143479f, -0.03435056f, -0.05475096f, 0.04287975f, 0.01862195f, 0.07186680f, 
    -0.03681499f, 0.05125480f, 0.00892577f, 0.07673876f, 0.04294161f, -0.00639111f, -0.05289220f, 0.02711485f, 
    0.24428229f, 0.12931813f, 0.18164261f, 0.00243237f, -0.08759192f, -0.11833539f, -0.02634192f, 0.04544900f, 
    0.01340530f, 0.10906166f, 0.04234328f, -0.10516308f, 0.06665944f, -0.13028851f, 0.01752658f, -0.10001039f, 
    0.02750504f, -0.02603428f, 0.03934153f, 0.21212098f, 0.24648702f, -0.27304247f, -0.06864689f, 0.15076050f, 
    -0.02841779f, -0.02286498f, -0.03819011f, 0.07407387f, 0.01417305f, -0.06693774f, -0.02112586f, 0.02400351f, 
    -0.08285248f, -0.05040593f, -0.02782232f, 0.04238566f, -0.06100101f, -0.08603597f, -0.10267488f, -0.01844432f, 
    0.04502694f, 0.19164333f, -0.03953356f, 0.07138128f, 0.14487731f, 0.04719725f, -0.03204254f, -0.00449531f, 
    0.03245643f, 0.02905586f, -0.00925694f, 0.01468720f, -0.08480423f, 0.00017118f, -0.08138265f, 0.03710368f, 
    -0.05921808f, 0.10730110f, -0.04577519f, 0.05049581f, -0.06559546f, -0.03924058f, -0.31273147f, -0.01064868f, 
    -0.03610191f, -0.04922574f, 0.00081968f, -0.06038923f, 0.01867500f, 0.04325068f, 0.08105952f, -0.03866711f, 
    0.04121730f, 0.01673993f, -0.11013106f, 0.06354021f, -0.01879434f, 0.11569957f, -0.02296216f, 0.05359028f, 
    -0.07487296f, 0.19566511f, -0.07970059f, 0.00698292f, 0.05440462f, 0.04231274f, 0.06038486f, 0.03612159f, 
    0.04745460f, 0.02035012f, 0.03083428f, -0.00884714f, -0.02846229f, 0.02878884f, -0.04579015f, 0.00770281f, 
    -0.04394567f, 0.06598494f, -0.09094737f, 0.02503505f, 0.21819186f, 0.06408402f, -0.01777338f, 0.08817194f, 
    0.03783138f, 0.00244947f, -0.14284825f, 0.05978522f, 0.02672447f, 0.02394345f, -0.01545206f, -0.02384731f, 
    -0.02889639f, 0.05593796f, -0.02613581f, 0.04788041f, 0.02851489f, -0.02580415f, -0.04246452f, 0.00263490f, 
    0.14375059f, 0.13888550f, 0.13397567f, 0.02048318f, 0.12748693f, -0.09480724f, -0.09413344f, -0.01146970f, 
    -0.01229765f, 0.01544624f, -0.05432343f, -0.02141585f, 0.01800409f, 0.01322907f, 0.00254043f, -0.02515510f, 
    0.07496470f, 0.00632082f, -0.02733192f, 0.03889252f, -0.22646344f, -0.01576675f, -0.01513816f, 0.00319310f, 
    -0.16417122f, 0.01928659f, -0.01571457f, 0.01360353f, 0.09203282f, -0.04553689f, -0.02816351f, 0.04579517f, 
    -0.01775656f, 0.11924063f, -0.03837921f, 0.01079717f, -0.07710516f, -0.08381325f, -0.02945751f, -0.04118872f, 
    0.19985344f, 0.01419250f, 0.20366952f, -0.09274577f, -0.14365581f, -0.10876392f, -0.05993279f, 0.02461504f, 
    0.03258442f, 0.08599418f, 0.09480178f, -0.02583421f, 0.08272544f, -0.12281067f, 0.04340436f, -0.03935352f, 
    0.02031546f, -0.04611430f, 0.04392014f, 0.09776283f, -0.07377940f, 0.10059427f, 0.10539783f, 0.10052631f, 
    0.03108025f, -0.07337338f, -0.07496740f, -0.02356504f, 0.00254568f, 0.00052612f, -0.03367480f, 0.02041006f, 
    -0.04137451f, 0.00259985f, -0.10111181f, -0.05330279f, 0.01294228f, 0.02038280f, -0.00235346f, -0.00418253f, 
    0.27884248f, -0.35082123f, -0.03076515f, -0.10289823f, -0.04545556f, 0.07080872f, -0.07412864f, -0.06882367f, 
    0.07748108f, 0.00321940f, 0.01827843f, -0.00962300f, -0.02734455f, 0.02692475f, 0.00936586f, 0.01766261f, 
    0.06350622f, -0.09665485f, 0.04821621f, 0.05445207f, -0.01945514f, -0.05152182f, -0.10613012f, -0.05280193f, 
    -0.04686946f, -0.03114681f, 0.00843262f, 0.04856179f, 0.05576372f, 0.12443727f, 0.00466931f, -0.05545397f, 
    0.00507839f, -0.00020852f, -0.00260085f, -0.06014295f, 0.06062723f, 0.05399406f, -0.09093956f, 0.13710360f, 
    -0.19692992f, 0.13026276f, 0.02339356f, -0.04149666f, 0.23791306f, -0.08281374f, 0.04183397f, 0.01838535f, 
    -0.00956885f, -0.02582855f, -0.00796206f, -0.01061666f, 0.17384285f, -0.04597760f, 0.03004049f, 0.08150677f, 
    -0.04242415f, 0.02368205f, 0.03360375f, -0.04889140f, 0.11926052f, 0.03652797f, -0.10584909f, 0.00311963f, 
    -0.12965998f, -0.00878780f, 0.01996710f, -0.00972392f, -0.01263058f, 0.05759147f, 0.02746142f, 0.04194509f, 
    -0.04206771f, -0.03199566f, 0.05898827f, 0.02934933f, 0.03790651f, -0.03858722f, -0.02991050f, -0.00130424f, 
    -0.33288157f, 0.13970508f, -0.06008955f, 0.01154165f, 0.03566477f, -0.13127445f, 0.02107804f, -0.01111101f, 
    -0.12076660f, 0.03558803f, -0.01389573f, 0.01902667f, 0.01118328f, -0.04407707f, -0.11471411f, -0.08948921f, 
    -0.05175189f, 0.03280707f, -0.02315571f, 0.00914233f, -0.06048443f, 0.03139628f, -0.04145724f, 0.00342932f, 
    -0.05101490f, -0.01040601f, 0.01261792f, 0.03465218f, -0.03034346f, 0.01448525f, 0.02258475f, 0.04590777f, 
    -0.01519082f, 0.00561495f, -0.02988302f, 0.03767076f, -0.07077321f, -0.00438514f, -0.01769875f, -0.07648430f, 
    -0.17808186f, 0.12346058f, 0.04931766f, 0.00246815f, 0.09716637f, -0.07702446f, 0.06908751f, -0.00722091f, 
    -0.01189911f, 0.01091602f, -0.08000009f, 0.00262682f, 0.04232486f, -0.08145531f, -0.01573191f, 0.10044533f, 
    -0.02302062f, 0.02276779f, -0.02667095f, 0.05040519f, -0.19390519f, 0.02307939f, 0.03126743f, -0.01289344f, 
    0.17824273f, -0.03674996f, -0.01788777f, 0.01867675f, -0.08510491f, 0.04469801f, -0.02738505f, -0.00118749f, 
    0.05476315f, 0.01482154f, -0.08433609f, 0.09092180f, -0.08708642f, 0.02004052f, 0.08224245f, -0.01286432f, 
    0.11845602f, -0.06888776f, 0.09839987f, 0.02304484f, 0.08551344f, -0.04053487f, 0.00550161f, -0.08813672f, 
    0.04941887f, -0.01764664f, 0.05129455f, 0.01190969f, -0.02497946f, -0.02077424f, 0.00406220f, -0.02821273f, 
    0.06161429f, -0.00385569f, 0.01545958f, 0.02844184f, -0.27277085f, 0.22516204f, 0.09605201f, 0.01067976f, 
    -0.13265635f, 0.02787521f, 0.02189550f, 0.04303627f, -0.02948064f, 0.17955281f, 0.13674100f, 0.03379508f, 
    0.03923853f, -0.00627525f, -0.03205759f, 0.00632903f, -0.04863392f, -0.03697683f, 0.08582646f, 0.04978342f, 
    0.03916909f, 0.05584864f, -0.03047602f, -0.02007869f, 0.04881368f, -0.03138013f, 0.00285849f, -0.04884902f, 
    -0.03238822f, 0.03815812f, -0.02847688f, 0.07719088f, -0.01097876f, 0.09004132f, -0.06871568f, 0.00289789f, 
    -0.02647358f, 0.01533926f, 0.01982042f, -0.01709904f, 0.14120281f, 0.05988824f, 0.03251290f, 0.04632780f, 
    0.04266360f, 0.07534354f, -0.03547537f, 0.06631777f, 0.05168696f, 0.07008115f, -0.09527189f, -0.03085901f, 
    0.01983872f, 0.03068466f, 0.03842380f, -0.01268366f, 0.03064505f, -0.01045458f, -0.11724861f, -0.22153454f, 
    0.03413470f, 0.10502205f, -0.19641262f, 0.03473040f, -0.20523803f, 0.10659878f, 0.06861745f, -0.02719540f, 
    0.01378955f, -0.00502111f, -0.03609559f, -0.07260251f, -0.00515788f, 0.15707880f, 0.03188116f, 0.03558615f, 
    0.10576166f, -0.10682630f, 0.00004984f, -0.13464178f, -0.20462275f, 0.15387222f, -0.13900338f, -0.05011258f, 
    0.08862658f, 0.11696314f, -0.02530671f, 0.01848370f, 0.00858829f, 0.08803663f, -0.02816932f, -0.04742017f, 
    -0.01969569f, -0.00613709f, -0.04642236f, 0.02999692f, 0.04370207f, -0.12056035f, -0.02336081f, 0.00206416f, 
    0.05719589f, -0.06406442f, -0.15400776f, -0.03752419f, -0.17611171f, 0.04750851f, -0.03507063f, 0.00455287f, 
    0.06393756f, 0.00665973f, 0.04113556f, 0.08172978f, -0.03670367f, -0.09344888f, 0.01774832f, -0.02832534f, 
    0.04518927f, -0.06881618f, 0.01324937f, -0.00844513f, -0.00801688f, -0.10504749f, 0.06741999f, -0.13349836f, 
    -0.02639341f, 0.07336168f, -0.04188032f, -0.02074304f, 0.08257125f, -0.01599908f, -0.18316217f, -0.06028504f, 
    -0.00570009f, -0.09434167f, -0.02592389f, 0.07528844f, 0.04805608f, 0.09430355f, -0.00219653f, -0.08346561f, 
    0.06037184f, 0.08392254f, -0.10022198f, -0.02231400f, -0.00308710f, -0.02936039f, 0.05176847f, 0.00666229f, 
    -0.12482291f, 0.10837761f, -0.01598711f, 0.06067065f, -0.05438980f, -0.11804195f, 0.00202306f, -0.04797078f, 
    -0.03338734f, 0.05090473f, -0.03273891f, 0.14870209f, -0.18884885f, -0.09537098f, -0.08446365f, 0.00257990f, 
    -0.08471670f, 0.10759722f, -0.00661826f, -0.00680700f, 0.01860164f, -0.06778697f, 0.09954344f, 0.04547559f, 
    0.00738663f, 0.00757749f, 0.00715139f, -0.02729557f, 0.00789383f, -0.07624152f, -0.01231754f, -0.07351033f, 
    -0.41804931f, 0.02247320f, -0.27073780f, -0.18988910f, 0.06159254f, -0.00621861f, 0.03019198f, -0.01618762f, 
    -0.03854986f, 0.05050126f, 0.05020289f, 0.11647262f, 0.04877926f, -0.09725488f, -0.03388667f, -0.01553264f, 
    -0.00438413f, 0.03580413f, -0.05869541f, -0.01215443f, 0.00944054f, -0.06355836f, 0.05303442f, -0.07197814f, 
    0.11723634f, 0.07688657f, -0.08535262f, 0.04402919f, -0.02093244f, 0.00917389f, -0.07391322f, 0.01821546f, 
    0.01233270f, 0.04616229f, -0.02126902f, -0.04279123f, 0.00817719f, -0.05620397f, -0.02279439f, 0.05467481f, 
    0.08154733f, 0.16042311f, -0.08214017f, 0.00519613f, -0.23554736f, -0.04980970f, -0.05805304f, -0.12411505f, 
    -0.05242133f, 0.06535474f, 0.11693905f, 0.06549720f, 0.02408966f, -0.00600967f, 0.05516873f, -0.01060730f, 
    0.06393623f, -0.12335877f, -0.03090844f, 0.02619329f, -0.28726721f, -0.05531070f, -0.09930548f, -0.01069238f, 
    -0.15451187f, 0.05924240f, -0.00402592f, -0.00146940f, 0.10985472f, -0.00833723f, -0.08613117f, -0.00160565f, 
    0.03955866f, 0.00958115f, -0.02516391f, -0.05993084f, -0.03009458f, -0.02688018f, -0.11710919f, 0.02096087f, 
    0.01770182f, -0.00822474f, 0.05884052f, 0.03958313f, -0.03327581f, 0.03330135f, 0.02021031f, -0.00044616f, 
    0.06529924f, 0.01268167f, -0.05758649f, -0.01900892f, -0.00679210f, 0.07502843f, -0.04913710f, 0.04966481f, 
    0.09886406f, 0.03760386f, -0.01556184f, 0.01869330f, 0.04477218f, 0.11247005f, 0.03238155f, 0.14872536f, 
    0.12749554f, -0.01161687f, -0.02219424f, 0.03659906f, 0.00295942f, 0.05753871f, -0.02336260f, -0.04599676f, 
    0.00170515f, 0.04900180f, 0.03077020f, 0.02351646f, 0.02373640f, 0.02865982f, -0.03468250f, -0.04674974f, 
    -0.01793746f, -0.13501742f, -0.21049546f, -0.24156785f, -0.03200568f, 0.01652902f, -0.06731674f, 0.08195168f, 
    0.02117994f, 0.02668964f, 0.04181385f, -0.03033041f, 0.05829644f, -0.01053139f, 0.01429029f, -0.06291279f, 
    -0.05767628f, -0.15963852f, -0.02717862f, -0.01745754f, 0.23845333f, -0.05195609f, -0.21819372f, 0.03851181f, 
    -0.11380911f, 0.00881988f, 0.00373534f, -0.01285957f, 0.05443108f, 0.11592164f, -0.02791161f, 0.00664005f, 
    0.02368708f, 0.03849392f, -0.03808402f, 0.01507718f, 0.11785290f, -0.00209595f, -0.08490097f, 0.07360177f, 
    0.08553495f, -0.06499422f, 0.02828010f, -0.02744043f, -0.11923850f, -0.01377040f, -0.02790792f, 0.15115689f, 
    0.06981166f, -0.00167079f, -0.01691762f, 0.01700164f, 0.11532833f, -0.04416833f, 0.00224680f, 0.03221203f, 
    -0.01444860f, 0.02548114f, -0.01990802f, -0.11695829f, 0.09985149f, -0.09072398f, -0.19123456f, -0.05725195f, 
    -0.12120128f, -0.08653192f, 0.01360808f, -0.02369947f, 0.03730891f, -0.10206887f, 0.01288389f, -0.07815290f, 
    -0.00351024f, 0.04034622f, -0.03879851f, 0.05923807f, -0.01149110f, 0.03713340f, 0.06335396f, -0.06751275f, 
    0.21972314f, -0.00653240f, 0.04538813f, -0.01750166f, 0.12772356f, -0.02840019f, -0.03491139f, -0.06181732f, 
    -0.02190469f, 0.06109529f, -0.02799409f, -0.01397959f, 0.00344166f, -0.00511388f, 0.00128124f, -0.00494859f, 
    -0.05593253f, -0.03734495f, -0.00379499f, 0.00240105f, 0.08694896f, 0.06650332f, 0.10552187f, 0.02743443f, 
    0.08991877f, -0.00923929f, -0.14023146f, -0.04565522f, 0.05050566f, 0.03090658f, 0.01271600f, -0.00156369f, 
    -0.01700679f, -0.02461268f, -0.00441623f, -0.01741611f, -0.10385775f, -0.00692301f, -0.01532531f, 0.06176906f, 
    -0.11332038f, 0.11692753f, -0.10842081f, -0.09702228f, -0.02537110f, 0.06595536f, 0.04519029f, 0.02563513f, 
    -0.08230720f, -0.07706997f, -0.01277367f, 0.03465943f, -0.04505997f, -0.05146639f, -0.05654341f, -0.01057464f, 
    0.01121681f, 0.06708270f, -0.05552707f, -0.02133454f, 0.00948085f, 0.01953933f, 0.07662500f, -0.06303562f, 
    0.02595223f, 0.05851382f, -0.03269008f, 0.01924735f, 0.00503699f, 0.11848833f, 0.07524503f, 0.01788136f, 
    0.05515527f, 0.03931088f, -0.01460911f, -0.04843539f, -0.03096836f, -0.00876580f, -0.10945939f, -0.02047042f, 
    0.28954896f, -0.02728041f, 0.00924705f, 0.16519542f, -0.15806784f, -0.08325655f, 0.04783451f, -0.00236439f, 
    -0.04599408f, 0.09088838f, -0.03278551f, -0.02278045f, 0.03686442f, -0.01022856f, -0.00221206f, 0.00249207f, 
    -0.04984704f, -0.01345304f, 0.02254747f, 0.05111352f, 0.13028482f, 0.10537051f, 0.01969956f, -0.11758803f, 
    -0.07180743f, -0.01695419f, 0.06740570f, 0.05478697f, -0.20708038f, -0.10975426f, -0.03810880f, 0.01096796f, 
    0.14201786f, -0.08438360f, 0.01898430f, 0.01188286f, -0.09979197f, -0.00321418f, -0.01922829f, -0.02638289f, 
    -0.06743766f, -0.08444120f, 0.05389339f, -0.17578317f, -0.10417365f, 0.09014412f, 0.06827653f, -0.01444209f, 
    -0.01995580f, 0.04498057f, -0.02869474f, 0.03349925f, -0.02806082f, -0.10558844f, 0.02075289f, 0.06130406f, 
    -0.08238059f, 0.03210699f, -0.02769264f, -0.02193150f, -0.22686012f, -0.33770877f, 0.11666521f, -0.11784337f, 
    -0.06132900f, -0.02744182f, -0.06879354f, 0.01942466f, 0.03777138f, 0.06812014f, -0.00709134f, 0.04117070f, 
    -0.00962894f, 0.02041610f, -0.02546994f, 0.05680899f, -0.10941904f, -0.06997567f, -0.08140980f, -0.02480473f, 
    0.26399657f, 0.03116992f, -0.01743608f, 0.12085827f, -0.02263548f, -0.08952264f, 0.01536818f, 0.00830534f, 
    0.02524424f, 0.05457645f, 0.01452866f, 0.05284437f, 0.01419999f, -0.02728830f, -0.03516212f, 0.01863677f, 
    -0.09160631f, -0.08964176f, 0.07695927f, 0.01837105f, 0.18427862f, -0.15272416f, 0.08592187f, -0.04442402f, 
    0.15510583f, -0.21564454f, -0.05508627f, -0.05223710f, 0.00638406f, 0.01643290f, 0.06759211f, -0.03953094f, 
    -0.03611062f, -0.10801236f, 0.05573598f, -0.01510500f, -0.05168813f, 0.02263851f, 0.03987315f, 0.03419889f, 
    0.04274529f, 0.13043062f, 0.04571729f, -0.16714932f, -0.13580792f, 0.04346097f, -0.01524354f, 0.10332459f, 
    -0.06507212f, 0.01631680f, -0.04994484f, 0.02977877f, 0.03501219f, -0.13106517f, -0.02068412f, 0.05894157f, 
    -0.01274328f, 0.05886489f, 0.05721823f, 0.01254027f, 0.14656194f, -0.12026768f, -0.14577153f, -0.10571448f, 
    -0.25803760f, 0.04551001f, -0.02009111f, -0.19380897f, 0.04249410f, -0.00913666f, -0.05623565f, 0.00056929f, 
    -0.01567739f, -0.01445020f, -0.00726593f, -0.01568899f, 0.02689998f, 0.04300795f, 0.04169670f, -0.05979458f, 
    0.07308228f, -0.11887162f, 0.07525043f, -0.01757321f, 0.13249998f, -0.05128005f, -0.01466392f, -0.03739044f, 
    0.04974796f, 0.03547426f, 0.05332130f, -0.02154659f, -0.07246140f, 0.05294630f, 0.00509824f, -0.04292784f, 
    0.00737765f, 0.03313069f, -0.01589541f, 0.01790918f, 0.08757178f, 0.10353061f, -0.21632317f, -0.17014134f, 
    -0.07365224f, 0.00944324f, -0.02084789f, 0.08746420f, -0.09170652f, 0.00074713f, -0.08795332f, -0.00580069f, 
    -0.02286784f, 0.04652292f, -0.05739680f, -0.03869688f, -0.01390612f, 0.08495743f, -0.02452465f, -0.01488489f, 
    -0.14674041f, 0.06048580f, -0.10410065f, 0.01919031f, -0.20137893f, 0.01570502f, -0.09532670f, 0.01959883f, 
    0.01923906f, 0.08652537f, -0.07345908f, 0.01054384f, -0.06786559f, 0.04795016f, -0.00439270f, -0.02904632f, 
    0.06943306f, 0.02254816f, 0.01560738f, 0.02289707f, -0.24480689f, -0.30090344f, -0.05799318f, -0.05077174f, 
    -0.16489083f, -0.04099537f, -0.02024068f, -0.01291815f, -0.06341562f, -0.01218694f, -0.03440567f, -0.00286326f, 
    -0.03544282f, -0.00952467f, -0.04932209f, 0.03133800f, -0.00069485f, 0.03691013f, -0.13490263f, -0.03157349f, 
    0.08666276f, -0.04109641f, 0.05444718f, -0.07722437f, -0.06962103f, 0.09778595f, 0.05819616f, 0.03044541f, 
    -0.05234369f, -0.01597829f, -0.00315532f, 0.06741709f, 0.03087642f, -0.00760332f, -0.03026113f, 0.00003322f, 
    -0.12643267f, 0.01337633f, -0.03364790f, -0.04450926f, 0.00068277f, 0.05298453f, 0.06956495f, -0.04440295f, 
    0.05924486f, 0.07420332f, -0.05745003f, 0.04374290f, 0.06212876f, 0.07905598f, -0.00109939f, 0.01608724f, 
    0.04516616f, 0.00540240f, -0.00764484f, -0.12810738f, -0.06110480f, -0.11170357f, -0.12159616f, -0.03735220f, 
    0.20528138f, 0.09834163f, -0.19774140f, -0.03534732f, -0.09150735f, 0.01595514f, 0.03727777f, 0.02937547f, 
    -0.00851607f, 0.00155869f, -0.02894633f, 0.02432884f, -0.03152341f, -0.00184320f, -0.01063771f, -0.06304907f, 
    0.03794793f, -0.06930523f, -0.00639332f, 0.00056714f, -0.08165877f, -0.00320787f, -0.16339429f, 0.00648112f, 
    -0.04390492f, 0.03037057f, 0.09160413f, 0.03871138f, -0.06779749f, 0.01796554f, -0.03177660f, -0.01503137f, 
    0.10067648f, 0.00690732f, 0.02677563f, -0.01872041f, -0.08288521f, -0.03826379f, 0.02481609f, 0.00465287f, 
    0.20405546f, 0.00666427f, -0.11116555f, 0.00053419f, 0.00958493f, -0.09495415f, 0.01394310f, 0.04291164f, 
    -0.02950359f, -0.02854822f, -0.03507529f, -0.05112833f, 0.01449271f, 0.01394174f, -0.02473639f, 0.01279938f, 
    0.02023216f, -0.07715619f, 0.00795684f, 0.03464232f, 0.22552893f, 0.08808221f, 0.14456254f, 0.01195353f, 
    0.17315546f, -0.04950245f, -0.03149446f, -0.11325669f, 0.04236883f, -0.01999962f, 0.00847386f, -0.05460050f, 
    -0.02593866f, -0.04231683f, -0.02994065f, 0.01761504f, -0.03894286f, 0.00853669f, 0.04431206f, 0.00848562f, 
    0.20230880f, -0.17023006f, -0.14148566f, 0.14243372f, -0.19490951f, -0.05071127f, -0.00754327f, 0.01498489f, 
    0.01988361f, 0.00945694f, 0.02401817f, 0.04513060f, 0.02338979f, 0.02713969f, -0.00364243f, -0.01179961f, 
    -0.05508057f, 0.03015516f, -0.00975342f, -0.02452616f, 0.06585838f, -0.18828505f, 0.06647389f, -0.08525410f, 
    -0.15297101f, 0.09487007f, 0.03409662f, 0.05587219f, -0.04574403f, 0.00195870f, 0.01557673f, 0.06146867f, 
    -0.04449711f, -0.07372808f, -0.05759858f, -0.00134148f, -0.06311270f, 0.03638612f, -0.07907611f, 0.01040487f, 
    -0.07535359f, -0.22773388f, -0.08956470f, 0.02083600f, -0.32651517f, 0.03064617f, -0.07335227f, 0.02989052f, 
    0.01389751f, 0.04807189f, -0.04268087f, -0.02878123f, -0.02165458f, -0.02970737f, -0.03612283f, 0.00417996f, 
    -0.04728042f, 0.05799780f, 0.05266702f, -0.02065217f, 0.26068926f, 0.00395613f, 0.16073096f, 0.11018032f, 
    0.26223332f, -0.09225179f, -0.09833061f, -0.12585491f, 0.07466019f, 0.04163220f, 0.06738887f, -0.06230808f, 
    -0.06307746f, -0.04019525f, -0.03322851f, -0.02113546f, -0.02447923f, 0.02944503f, 0.01214126f, -0.00540877f, 
    -0.37044799f, -0.00170387f, -0.08394179f, -0.06336908f, 0.06046236f, 0.01891139f, 0.10317986f, 0.01217858f, 
    0.06796671f, -0.04999948f, 0.04588296f, -0.00698457f, 0.01114505f, -0.07362529f, 0.04362500f, -0.02758138f, 
    0.03186233f, -0.00426884f, -0.04859200f, -0.01884358f, -0.26754302f, 0.21209435f, -0.01820925f, -0.27700475f, 
    0.02114841f, 0.01155658f, 0.04796670f, 0.05809988f, 0.01000752f, -0.02698441f, -0.04837980f, 0.04609324f, 
    -0.05028006f, -0.07770421f, -0.03776834f, -0.03304757f, -0.00146672f, 0.02601559f, 0.03726212f, 0.01507281f, 
    0.00108165f, 0.08449072f, -0.17927656f, -0.12244297f, -0.06346893f, 0.00081584f, 0.03830732f, 0.05697132f, 
    0.00551582f, -0.05746326f, -0.03698047f, 0.01501858f, -0.05127299f, -0.01866673f, 0.01116450f, -0.05516373f, 
    0.00138168f, -0.06959498f, -0.09639870f, -0.05383329f, 0.16814086f, -0.01850019f, 0.03798925f, -0.00092791f, 
    -0.12171227f, 0.03237118f, 0.04195154f, 0.01272230f, -0.05139684f, 0.03204228f, -0.05683432f, -0.03377553f, 
    0.08471140f, 0.02565514f, -0.02967103f, 0.01276058f, -0.03926868f, -0.10268994f, 0.01245762f, -0.01376267f, 
    0.11235873f, 0.04539673f, -0.17992926f, -0.04149249f, -0.02399018f, 0.02040915f, 0.06233355f, 0.00770850f, 
    -0.00306723f, -0.04668806f, -0.03629467f, 0.00707910f, 0.01499235f, -0.03252723f, -0.00059665f, -0.04232542f, 
    -0.00149689f, -0.09591907f, -0.05856233f, -0.01769623f, -0.19949371f, 0.07150374f, -0.06594277f, -0.12440477f, 
    0.10813762f, 0.04651050f, 0.06200097f, 0.03515141f, 0.01755337f, -0.04203344f, -0.07874440f, 0.00142601f, 
    -0.03850171f, -0.07464236f, 0.00059034f, -0.03777560f, 0.05878802f, -0.00409533f, -0.02916206f, -0.00791211f, 
    -0.00154613f, 0.05528373f, 0.00821350f, -0.06561314f, 0.04461640f, 0.01434343f, 0.01353547f, 0.04166498f, 
    0.01242933f, -0.05431516f, -0.02966683f, 0.05986466f, 0.00709501f, 0.01944365f, -0.03554796f, -0.02126289f, 
    -0.06430292f, -0.02371179f, -0.00052385f, -0.04004301f, -0.20545748f, -0.00842896f, 0.01818414f, -0.07677877f, 
    -0.04503866f, -0.03005344f, 0.05330411f, 0.00047901f, -0.00304687f, 0.01329684f, -0.02336664f, 0.01542452f, 
    0.01940373f, -0.01947110f, -0.00960908f, 0.01842815f, -0.00191218f, -0.00605425f, -0.06215691f, -0.06567381f, 
    -0.34842968f, 0.13585623f, -0.00438275f, -0.07647528f, 0.03670409f, 0.01345431f, 0.08691728f, 0.02901299f, 
    0.06859413f, -0.02806837f, 0.04440530f, -0.04237650f, -0.00602292f, -0.04719007f, 0.02617380f, 0.03250770f, 
    -0.02272508f, -0.02998144f, -0.01394776f, 0.01640804f, -0.07476901f, 0.06755327f, 0.10623754f, -0.07416843f, 
    0.05648614f, -0.02403128f, 0.01915931f, 0.11297779f, 0.00339010f, -0.06690653f, -0.01609496f, -0.01394878f, 
    0.07631993f, 0.03053137f, -0.01036850f, 0.02787321f, -0.06572925f, -0.11267814f, 0.03272906f, -0.01632123f, 
    -0.00416803f, -0.28018764f, 0.12559043f, -0.08324078f, 0.00248282f, -0.06418789f, -0.02246749f, 0.04053176f, 
    0.03245256f, 0.07782562f, 0.00708037f, -0.08691902f, 0.07865523f, -0.00137901f, -0.04606216f, 0.04212861f, 
    -0.05324507f, 0.00342513f, -0.02807087f, 0.00657474f, 0.10144722f, -0.10222550f, -0.03865516f, -0.15783618f, 
    -0.15542856f, -0.05217075f, -0.04034818f, 0.00097619f, -0.00918558f, -0.02793383f, 0.01673277f, -0.00825167f, 
    0.04308708f, -0.01585275f, -0.01138620f, 0.01374216f, -0.02778774f, -0.02727709f, -0.00645115f, -0.04247810f, 
    0.16679855f, -0.03045917f, 0.00290674f, -0.10368132f, 0.00949595f, 0.06884514f, 0.00093842f, 0.01820570f, 
    0.00457104f, 0.08694646f, -0.01861653f, 0.06035370f, -0.00996961f, 0.00438954f, 0.04072158f, -0.04540348f, 
    -0.09809240f, -0.03208731f, -0.07471868f, -0.04886480f, 0.13774829f, 0.01693854f, 0.06487652f, 0.05165353f, 
    0.17278092f, -0.08350630f, -0.08152166f, -0.09032278f, 0.02790117f, 0.04386830f, 0.04812457f, -0.02089684f, 
    -0.02338697f, -0.01251457f, 0.00510857f, 0.00414886f, -0.00721416f, -0.01582779f, -0.01946255f, -0.00479393f, 
    0.32954034f, -0.05196796f, -0.01762893f, -0.05650203f, -0.01176298f, -0.04683823f, -0.04503652f, 0.07731637f, 
    0.06460303f, 0.02504762f, 0.07008811f, -0.00354841f, -0.02223333f, 0.00847167f, 0.05953543f, -0.00502754f, 
    -0.01057629f, -0.00727809f, 0.02333703f, -0.01227908f, -0.07182758f, 0.13170256f, -0.08660276f, -0.06061681f, 
    -0.04713546f, 0.02187360f, 0.04256121f, 0.04516883f, 0.05364250f, 0.00947179f, -0.01943046f, 0.01290874f, 
    -0.04654404f, -0.00771258f, -0.04768201f, -0.07058092f, 0.03022596f, -0.01343740f, 0.03750039f, -0.01854065f, 
    0.21266912f, 0.01303830f, -0.04357059f, 0.03963361f, -0.01013848f, -0.07724179f, -0.02085552f, 0.03059913f, 
    -0.00984872f, -0.03613992f, 0.01677988f, 0.05028568f, -0.02365021f, 0.00138046f, 0.03799581f, 0.02100851f, 
    -0.10302329f, -0.03043256f, -0.02318014f, -0.03824100f, 0.18949901f, -0.00436674f, -0.06838328f, -0.01164684f, 
    -0.02310253f, 0.01347678f, 0.02995793f, 0.00934311f, 0.03884219f, 0.05819938f, -0.00997206f, 0.04048134f, 
    -0.02301651f, 0.01848302f, -0.02059693f, -0.01045806f, -0.02424131f, -0.06501627f, -0.06550609f, -0.05890218f, 
    0.04646046f, 0.00091868f, 0.03105314f, 0.01695255f, -0.02248148f, 0.06444310f, -0.09383268f, 0.04090168f, 
    0.01125415f, 0.04177830f, 0.00476185f, -0.00423208f, 0.05062178f, 0.08248294f, -0.03081122f, -0.04331746f, 
    -0.04488609f, 0.00589996f, -0.05286040f, -0.06477456f, -0.28153789f, 0.09002217f, -0.00568661f, 0.01634771f, 
    -0.00060896f, -0.06243701f, 0.00665436f, -0.06686648f, -0.04235606f, -0.02836506f, 0.00840849f, -0.03349488f, 
    0.06435934f, -0.05434455f, 0.05088323f, -0.01058481f, 0.03231151f, -0.05533474f, -0.09157933f, 0.05360129f, 
    0.09360378f, 0.03053363f, 0.06209627f, 0.03042646f, 0.03286278f, -0.00599043f, -0.03413568f, -0.00672279f, 
    0.02293934f, 0.07649191f, -0.03032641f, 0.00679210f, 0.02959071f, 0.01920403f, -0.01089988f, 0.00179199f, 
    -0.01851782f, -0.06997791f, -0.03364231f, 0.00590542f, 0.18296404f, -0.25694707f, -0.09413348f, -0.05051321f, 
    -0.24920563f, -0.05369946f, -0.01709970f, -0.05571534f, -0.04931188f, 0.02485043f, 0.04319707f, 0.03447108f, 
    -0.01525552f, 0.00157255f, 0.03037646f, -0.04134734f, -0.02447742f, 0.05653641f, 0.01581568f, 0.01713141f, 
    0.09067780f, -0.23528379f, 0.02739406f, -0.02089482f, 0.04571475f, -0.11988073f, -0.02909866f, -0.10547956f, 
    0.02150405f, 0.00475379f, 0.03449024f, -0.01329245f, 0.04774499f, -0.05889942f, 0.05207130f, 0.05892499f, 
    -0.01503089f, -0.00605845f, 0.00192364f, 0.08781719f, 0.16985255f, -0.20810424f, 0.05403266f, -0.19876967f, 
    -0.10061322f, 0.04912956f, -0.04685925f, -0.08905474f, 0.06932566f, 0.04464320f, -0.06373117f, -0.00218153f, 
    -0.01194407f, -0.03374729f, -0.00956738f, -0.04927975f, -0.04848181f, 0.08764860f, 0.05637334f, -0.02288464f, 
    0.08199309f, -0.14721002f, 0.00928918f, -0.00241154f, 0.14408000f, -0.06513964f, -0.03464656f, -0.05489236f, 
    0.01790488f, 0.01773160f, 0.03156994f, -0.01234279f, -0.02871338f, 0.03926728f, 0.03887035f, -0.05025221f, 
    -0.03724156f, 0.00450803f, -0.01402725f, -0.03863860f, 0.22719920f, 0.12516154f, -0.02752481f, 0.01738819f, 
    -0.08061849f, -0.02070418f, 0.03372212f, 0.03303989f, -0.04517966f, -0.01025986f, 0.05163014f, -0.03730307f, 
    -0.02305901f, -0.06500162f, -0.03631270f, 0.05305096f, 0.06936207f, -0.00948952f, 0.01213223f, 0.01228467f, 
    0.23480487f, -0.10722284f, -0.13755757f, 0.07145721f, -0.00836686f, -0.14166141f, -0.02332023f, 0.03139993f, 
    0.04428681f, 0.02536447f, -0.00098195f, 0.00798402f, 0.04550539f, -0.02086067f, -0.01334458f, -0.01201755f, 
    -0.02760822f, -0.07363191f, 0.04634764f, 0.06506988f, 0.07625984f, 0.09540886f, -0.06901426f, 0.03781953f, 
    -0.07723091f, -0.03824444f, 0.07440935f, 0.02443487f, -0.02851102f, -0.04791810f, -0.02953197f, -0.01612294f, 
    -0.01647799f, -0.02855249f, -0.04905721f, 0.01635210f, 0.04352573f, 0.01517261f, 0.01337262f, -0.11349236f, 
    0.24218842f, -0.00335545f, -0.19889279f, -0.12945953f, -0.01322952f, -0.04217382f, 0.00784121f, 0.02503273f, 
    -0.03259571f, 0.03221733f, -0.06923147f, 0.02164953f, 0.03996297f, -0.04803139f, -0.02471354f, -0.01897796f, 
    0.00144398f, -0.07702674f, 0.03178904f, 0.02829657f, -0.02455317f, 0.05033239f, -0.01411984f, 0.02849194f, 
    0.06514944f, 0.05697564f, 0.02804141f, 0.08065800f, -0.04091107f, -0.06003928f, -0.05669284f, 0.08287882f, 
    0.00379718f, 0.00944713f, -0.04923476f, 0.00730541f, -0.01314557f, 0.05567600f, -0.06353559f, -0.02744506f, 
    0.04203771f, 0.05651219f, 0.06590041f, 0.17501287f, 0.20541647f, -0.09033908f, -0.08417306f, -0.09987327f, 
    0.01666262f, 0.02121502f, 0.10614359f, -0.00823873f, -0.04337029f, 0.02209423f, 0.08064487f, -0.02435317f, 
    -0.03326972f, 0.01091662f, -0.06198547f, -0.03381814f, 0.17664850f, -0.08588054f, -0.02473385f, 0.05812966f, 
    -0.12864739f, -0.04994244f, 0.09393153f, -0.05863701f, 0.03862114f, -0.03234537f, 0.02467730f, -0.03033691f, 
    0.03204812f, -0.01612039f, -0.02103938f, 0.03467103f, 0.03451153f, 0.00050715f, 0.08005720f, -0.02768232f, 
    0.07125624f, -0.12663428f, 0.06202492f, 0.03040712f, -0.11870359f, -0.03612195f, -0.02209136f, 0.06351434f, 
    0.01802722f, -0.01064966f, 0.03861647f, 0.03242032f, 0.05200381f, -0.03893998f, -0.00662849f, 0.02633606f, 
    -0.03997763f, 0.00834359f, 0.02717253f, -0.03248960f, -0.10860029f, 0.06271826f, 0.00133186f, -0.09677188f, 
    0.03003675f, 0.03362203f, 0.02136526f, 0.05389663f, 0.00902127f, -0.00609989f, 0.00767978f, -0.01327439f, 
    0.01825412f, -0.00856997f, -0.02478959f, -0.01170617f, -0.01980060f, -0.05582929f, -0.08361161f, -0.02222020f, 
    -0.10099724f, -0.17780334f, -0.06444602f, -0.19970681f, -0.18426156f, 0.04093560f, -0.02204367f, 0.05724695f, 
    -0.03411966f, -0.00409316f, -0.02286398f, 0.04461151f, -0.01824706f, -0.07807893f, -0.02874086f, 0.05181047f, 
    -0.02680527f, 0.11285435f, -0.00989260f, -0.04439794f, 0.23181283f, -0.21099937f, 0.08789942f, -0.02718332f, 
    0.09159122f, -0.12290863f, -0.04319844f, -0.03964118f, 0.00901753f, -0.00116219f, 0.05565779f, -0.04257190f, 
    -0.02471474f, 0.04621810f, 0.03179807f, -0.03764666f, -0.02638534f, 0.02354694f, 0.03118319f, -0.02811975f, 
    0.12033491f, -0.16259415f, -0.14754733f, 0.02481741f, 0.08594591f, -0.10254870f, -0.01379089f, 0.02234384f, 
    0.07597017f, 0.05590833f, -0.02422157f, 0.00933694f, 0.05297098f, -0.01234197f, 0.05300260f, -0.07162340f, 
    -0.01891714f, -0.12897086f, 0.02213376f, -0.04159783f, -0.08149971f, 0.14857540f, 0.07480430f, 0.13263488f, 
    0.03101213f, 0.01889189f, 0.00898416f, -0.01848416f, -0.00542037f, 0.00685809f, 0.00416718f, -0.01980118f, 
    -0.00196907f, -0.00611347f, -0.02539949f, -0.02882288f, -0.00350176f, 0.02030759f, 0.07021354f, -0.00038547f, 
    -0.14814590f, 0.19516635f, -0.03035536f, -0.02406169f, -0.02572781f, -0.00667522f, -0.02847569f, -0.02286889f, 
    0.02461248f, -0.02353022f, 0.00459713f, -0.07879335f, -0.01511658f, 0.02016109f, -0.04118000f, -0.03446570f, 
    -0.01774555f, -0.02121657f, 0.08498256f, 0.04968709f, -0.04356972f, -0.03963922f, -0.11259636f, -0.13131364f, 
    -0.07185769f, 0.00734042f, -0.04807886f, 0.01797070f, -0.04893257f, -0.07984006f, -0.06651548f, -0.00862166f, 
    -0.00965604f, 0.02831152f, -0.01594584f, 0.01027375f, 0.01604956f, 0.05030430f, -0.06254512f, 0.00898901f, 
    -0.13045396f, -0.01374176f, -0.11294028f, 0.05930343f, 0.18870910f, 0.04821622f, 0.08651812f, 0.00595632f, 
    0.00339638f, 0.03402815f, 0.01638979f, 0.01337945f, 0.01358803f, -0.02037354f, -0.03537137f, 0.03756446f, 
    0.03122655f, 0.00453309f, 0.04062742f, 0.04761611f, -0.13080657f, 0.04635594f, -0.14796597f, 0.05233581f, 
    -0.10505614f, 0.06796645f, -0.01821137f, 0.07258848f, -0.03190659f, 0.02565330f, -0.04047111f, -0.01508981f, 
    -0.09082554f, 0.03820249f, -0.03474142f, 0.00606457f, -0.06618053f, -0.03972566f, -0.02240753f, -0.00090255f, 
    -0.05016344f, -0.07601484f, 0.01777616f, -0.03327831f, -0.09766767f, -0.06637978f, -0.05689169f, 0.04961525f, 
    -0.09983030f, -0.03814528f, -0.03628178f, 0.02542893f, -0.07673976f, -0.00617395f, 0.07114002f, -0.00350215f, 
    0.02536985f, 0.07109177f, 0.04222938f, 0.01234191f, -0.14086509f, -0.05744794f, 0.06622194f, -0.01199974f, 
    0.00124015f, -0.11310650f, 0.01731813f, 0.03975879f, 0.07896652f, -0.02981153f, -0.03444200f, 0.09993839f, 
    -0.00334433f, 0.03203712f, 0.01811483f, -0.02915782f, 0.03481880f, -0.10792409f, 0.05931515f, -0.00601151f, 
    0.13335940f, -0.04566295f, -0.08765012f, 0.19454995f, 0.01006177f, 0.11540099f, 0.03731159f, -0.01434846f, 
    0.02600716f, -0.01393983f, -0.01536256f, 0.06003978f, -0.14368503f, -0.06976063f, -0.03172971f, -0.01119787f, 
    -0.01684557f, 0.06768897f, -0.05697278f, -0.02911747f, 0.02150569f, 0.14396632f, -0.00481913f, 0.12273721f, 
    -0.05983749f, -0.00508801f, 0.01976111f, -0.06748040f, 0.01026003f, -0.04110014f, -0.05868071f, 0.00257305f, 
    0.02736986f, 0.07388961f, 0.02320352f, 0.04997350f, -0.09449393f, 0.07122396f, -0.06733173f, -0.01844366f, 
    0.02500191f, -0.17908001f, 0.07314885f, 0.02357068f, -0.07458905f, -0.00498152f, -0.07958363f, -0.02686297f, 
    -0.04523967f, -0.04448871f, -0.08784606f, 0.06956550f, -0.05695763f, 0.00213231f, 0.05761168f, 0.07026818f, 
    0.02608647f, 0.02233632f, 0.01858149f, -0.00187161f, 0.22566977f, -0.08359563f, 0.09710697f, -0.01138122f, 
    -0.04780415f, -0.03847008f, -0.13108709f, -0.15734890f, -0.03500290f, -0.03267247f, 0.01504978f, -0.03450546f, 
    0.02791597f, -0.01291635f, 0.01711435f, -0.04314201f, -0.02656071f, -0.03829988f, 0.09535668f, 0.04808587f, 
    0.11940435f, -0.08113203f, -0.01037795f, 0.00942731f, 0.05046667f, -0.04725426f, -0.01486421f, 0.00083072f, 
    0.02004916f, 0.03028232f, 0.05773825f, -0.04250113f, 0.00864832f, -0.06784613f, 0.03730857f, -0.04266625f, 
    -0.01993723f, 0.01615754f, -0.00769054f, 0.01592796f, -0.12840419f, 0.25751558f, 0.05565469f, 0.08961612f, 
    -0.10962894f, -0.00498383f, -0.01018552f, 0.02097697f, -0.01969764f, -0.05322271f, -0.05937755f, -0.05821897f, 
    -0.00655118f, -0.06397924f, -0.04235176f, 0.04924800f, -0.00748973f, 0.07049046f, 0.02413536f, 0.05805702f, 
    0.07845852f, 0.03568525f, -0.08618306f, 0.01768614f, -0.08971103f, -0.01314451f, -0.07242327f, 0.00120609f, 
    -0.05212388f, 0.01281149f, 0.01032185f, 0.03285695f, -0.02956117f, 0.01432674f, -0.01132501f, 0.02475519f, 
    -0.03827781f, 0.05251824f, 0.01077621f, -0.02162627f, 0.33700937f, 0.28335702f, -0.04131774f, -0.08870818f, 
    0.01647952f, -0.04143756f, 0.06445187f, -0.03346630f, 0.08740830f, 0.05511792f, -0.02037213f, 0.00010212f, 
    -0.07829788f, 0.03231290f, -0.00907353f, 0.01525377f, -0.00270344f, 0.00717668f, 0.08264408f, 0.03885632f, 
    0.08270279f, 0.19590960f, 0.08789306f, 0.09044481f, -0.09690142f, -0.08436119f, 0.12626918f, -0.01465587f, 
    0.07773899f, -0.00441365f, 0.00404823f, 0.03290291f, -0.05531528f, -0.01261253f, -0.01304371f, -0.00878935f, 
    0.00998910f, -0.04198491f, -0.07427718f, -0.01593529f, 0.28711307f, 0.25864714f, -0.05248657f, 0.10729419f, 
    0.03622936f, 0.03789623f, 0.04159139f, 0.01712534f, -0.05671004f, 0.04566654f, -0.01543539f, -0.00032984f, 
    -0.05195484f, -0.08711384f, 0.10614424f, -0.05770595f, 0.06861224f, 0.09958000f, 0.00873478f, -0.10283118f, 
    0.24704236f, -0.29287860f, -0.04883952f, 0.12392788f, -0.00771032f, 0.01819473f, -0.06545615f, 0.04253919f, 
    0.05174045f, -0.09942497f, -0.01073722f, -0.02420441f, -0.10300601f, 0.05009215f, -0.05120570f, 0.04117333f, 
    0.05146557f, -0.02066317f, -0.11783590f, -0.04279855f, -0.38837191f, -0.19188280f, 0.02679224f, -0.14965688f, 
    -0.21379215f, -0.03019349f, -0.03185537f, 0.00227664f, 0.04844994f, -0.01816481f, -0.02757435f, -0.04520157f, 
    0.06420793f, 0.01959329f, 0.01771805f, 0.12150891f, 0.00725228f, -0.01576476f, 0.02574746f, 0.06368958f, 
    0.06214574f, -0.20143589f, -0.06573186f, 0.08170844f, 0.12789840f, 0.02659934f, -0.03563504f, 0.02235677f, 
    0.02181581f, -0.07163226f, 0.05048854f, 0.05066053f, -0.05930048f, 0.05200925f, -0.04124013f, 0.02602300f, 
    0.04341950f, -0.02021560f, 0.00491148f, 0.04600408f, -0.15796097f, 0.22399676f, -0.02271644f, 0.00726779f, 
    -0.06846388f, 0.01547975f, 0.05046049f, 0.02871326f, 0.01237192f, 0.02346412f, 0.02035577f, 0.02007245f, 
    -0.10044387f, -0.01810931f, -0.04849526f, -0.00764131f, -0.01545563f, 0.02130806f, 0.04992726f, -0.02824106f, 
    -0.02401729f, 0.00642187f, -0.00336682f, -0.03010536f, -0.02831985f, 0.02947511f, -0.02047852f, 0.01778243f, 
    0.05200885f, 0.00475757f, 0.05282989f, 0.04580611f, 0.00579986f, -0.02427723f, -0.06859493f, -0.03998924f, 
    -0.05244280f, -0.04439603f, 0.04751515f, -0.04387504f, -0.21210630f, 0.11322165f, -0.03096404f, -0.07695910f, 
    -0.04840988f, -0.04997010f, -0.06862912f, 0.00327118f, -0.04524800f, -0.05575949f, -0.03338810f, -0.02361753f, 
    0.02172150f, 0.02831243f, -0.00030135f, 0.01035952f, -0.03263136f, -0.06987686f, 0.07435846f, -0.02687659f, 
    0.07465824f, -0.01265032f, 0.11769485f, 0.08974711f, -0.01630023f, -0.03906220f, -0.01768167f, 0.07308926f, 
    -0.01818716f, -0.04057087f, -0.07310572f, -0.01116878f, -0.03387995f, 0.01153105f, 0.03756773f, -0.02921950f, 
    0.00957479f, 0.06536719f, 0.04710092f, 0.02188779f, 0.41814485f, -0.00817840f, -0.13163440f, 0.21458253f, 
    0.08077864f, 0.08167460f, 0.02096591f, -0.00627777f, 0.02278293f, -0.01087132f, -0.05378788f, 0.01609994f, 
    -0.12160013f, 0.00338695f, -0.05346545f, -0.00611800f, 0.04086016f, 0.05807174f, -0.02416416f, -0.04920536f, 
    0.25389689f, -0.01734192f, 0.07878789f, 0.07154942f, -0.03824143f, -0.03661814f, 0.03317515f, 0.02817111f, 
    -0.08146545f, 0.04684303f, 0.04298735f, 0.00529050f, -0.05267572f, -0.02111865f, -0.01662785f, -0.07693969f, 
    0.02731499f, -0.00221653f, -0.00031089f, 0.08335146f, -0.09565280f, -0.08826369f, -0.05866595f, -0.11498931f, 
    -0.11845592f, -0.06208252f, -0.15968828f, 0.04585165f, 0.03306151f, -0.00947790f, -0.07316936f, 0.00362746f, 
    0.02189052f, -0.03999113f, 0.03627264f, -0.00841394f, 0.00700910f, 0.00383836f, 0.08108774f, -0.01333709f, 
    -0.17457366f, -0.15830635f, -0.33860287f, 0.03692446f, -0.07289498f, -0.02306451f, 0.00285919f, 0.01188335f, 
    -0.01644870f, -0.07513253f, 0.05832982f, -0.06359977f, 0.00450758f, -0.02317606f, -0.04164248f, -0.00629362f, 
    -0.05439900f, 0.04964426f, 0.05602854f, -0.04890219f, -0.00437556f, -0.02022193f, 0.11098091f, 0.01923954f, 
    0.17286459f, 0.03316605f, 0.07032077f, 0.01016614f, 0.00266769f, -0.01701685f, 0.08356559f, 0.00577762f, 
    -0.03706070f, 0.00081560f, -0.11288773f, 0.07612705f, -0.05882164f, 0.06772990f, 0.04187326f, 0.04475030f, 
    -0.40921354f, 0.20224367f, -0.15987472f, 0.02193161f, 0.11869749f, 0.00228945f, 0.09543906f, 0.01918899f, 
    -0.01097268f, -0.05304329f, -0.04520887f, -0.02261965f, 0.08578696f, 0.06825810f, 0.05558753f, 0.02125682f, 
    -0.02690143f, -0.03955276f, 0.04046074f, 0.05120856f, -0.24807493f, 0.17770772f, 0.10220808f, 0.03530606f, 
    0.02542217f, 0.09026897f, 0.06026582f, 0.00621010f, 0.03331928f, -0.00485417f, 0.01677165f, -0.00951184f, 
    -0.03419199f, -0.00518408f, 0.01746695f, -0.03898371f, 0.05726109f, -0.08569227f, 0.11790822f, 0.00763661f, 
    -0.35554394f, -0.00316101f, -0.00663437f, -0.04600981f, 0.06984871f, -0.01312569f, 0.03252473f, 0.02744680f, 
    0.00016809f, -0.05530234f, -0.03995115f, -0.00301280f, -0.01661784f, 0.01541311f, 0.03422504f, -0.02774732f, 
    -0.00216152f, -0.11647839f, 0.02666629f, 0.00454216f, -0.23707421f, -0.24922581f, -0.32779428f, 0.07933913f, 
    0.14641790f, 0.00634290f, 0.03675448f, 0.01427393f, 0.00513211f, -0.02149433f, 0.00597874f, 0.00746814f, 
    0.00450719f, -0.03891865f, -0.00641356f, -0.00746379f, 0.02406418f, -0.00729334f, 0.01254971f, -0.02157138f, 
    -0.27665162f, -0.31053895f, -0.21086472f, -0.01422913f, -0.06411311f, -0.06338426f, -0.08785770f, -0.00245460f, 
    0.03685580f, -0.05581668f, -0.05682906f, -0.02086222f, -0.02465775f, -0.12418284f, -0.00410967f, -0.06566758f, 
    -0.00801919f, 0.03327984f, -0.04795808f, -0.02753245f, 0.04758748f, 0.02458289f, -0.00311090f, 0.17752166f, 
    0.11796301f, 0.05278449f, 0.05485876f, 0.00861238f, -0.05812261f, 0.04514916f, -0.01402360f, -0.03827682f, 
    -0.01757368f, -0.09377775f, -0.06040303f, -0.01433347f, -0.02739404f, 0.00047380f, 0.04821634f, -0.09318101f, 
    -0.11210910f, -0.28394115f, -0.40097973f, 0.03974646f, -0.09880765f, -0.03710265f, 0.08144648f, -0.06154002f, 
    0.01497193f, -0.07202438f, 0.03456188f, 0.01364223f, -0.02586878f, -0.01929503f, 0.01931680f, -0.03009215f, 
    -0.03256333f, 0.04425839f, 0.06636121f, -0.06179857f, -0.28884614f, -0.48044747f, -0.15244555f, 0.06376412f, 
    0.12041436f, -0.02903440f, -0.00584003f, 0.05770873f, -0.01223095f, -0.08368289f, -0.05113839f, 0.02483226f, 
    -0.06608666f, -0.06779668f, 0.06471715f, -0.04806351f, -0.09603304f, -0.03234593f, 0.00427231f, -0.11621326f, 
    0.01157817f, 0.01545345f, -0.02473433f, 0.05373063f, -0.04834403f, -0.11269011f, -0.04009585f, -0.02114341f, 
    0.01424678f, 0.04051285f, -0.08454065f, -0.03991996f, -0.03046126f, 0.06116964f, 0.00713967f, -0.01564440f, 
    0.04771512f, -0.00170678f, -0.05852639f, -0.02472094f, -0.01954426f, 0.18636855f, 0.07402418f, 0.09016529f, 
    0.04933413f, 0.00441804f, 0.01035664f, 0.00604477f, -0.01428545f, 0.01039595f, -0.03537123f, -0.02861927f, 
    0.03476768f, -0.01528285f, -0.04377988f, -0.01169562f, 0.02307955f, 0.03268599f, 0.01471272f, 0.06908379f, 
    0.10792432f, 0.04539284f, -0.07910182f, 0.09793303f, -0.10935485f, -0.02093087f, 0.00253653f, -0.06721821f, 
    0.03775396f, -0.02144966f, -0.02804753f, -0.02857675f, 0.03599464f, 0.02789445f, -0.07056453f, -0.02367436f, 
    0.02891449f, -0.10599142f, 0.09000635f, 0.06482428f, -0.05101516f, -0.00247400f, -0.03911724f, -0.01499901f, 
    -0.02025723f, -0.03451483f, -0.10208310f, 0.05742632f, 0.00859427f, 0.04704863f, -0.02340172f, 0.01332629f, 
    -0.00534054f, -0.03317272f, -0.01122850f, -0.01738779f, -0.01475015f, 0.02490643f, 0.05333878f, -0.00241667f, 
    -0.35684648f, 0.13600059f, 0.10239884f, 0.03696911f, -0.07706940f, -0.02637979f, -0.03399690f, 0.00364105f, 
    0.05551625f, -0.12067633f, -0.06813234f, -0.05303329f, -0.00740856f, -0.00089246f, -0.01085093f, -0.01311250f, 
    0.02247455f, -0.04365975f, 0.04204811f, 0.07796445f, 0.09573539f, 0.03773512f, 0.06503602f, 0.08657068f, 
    0.14349358f, 0.01036022f, 0.08819781f, 0.05264087f, 0.00965288f, -0.01143875f, -0.03391806f, -0.01208932f, 
    -0.06667916f, 0.01828088f, -0.04699531f, 0.00880176f, 0.01003320f, 0.01411542f, 0.03841997f, -0.02430137f, 
    -0.23515536f, -0.17849958f, -0.01265764f, -0.09736572f, -0.11115932f, -0.00471452f, -0.12042642f, -0.05177307f, 
    -0.00860381f, -0.07639842f, 0.08125264f, -0.01580483f, -0.02788108f, 0.02915862f, -0.02831395f, -0.00360619f, 
    0.05069404f, -0.02247894f, -0.00757230f, -0.01565130f, 0.16520774f, -0.10446723f, -0.08788194f, 0.04554405f, 
    -0.02092745f, -0.02859331f, -0.02648651f, -0.10680480f, 0.08723521f, -0.05629730f, 0.06809351f, -0.03548265f, 
    0.07643163f, 0.03588148f, -0.02031327f, 0.00892790f, 0.02929742f, -0.01925732f, 0.01751730f, 0.00691145f, 
    -0.14725938f, -0.07480759f, -0.10027080f, -0.06574162f, -0.17477715f, -0.02955946f, -0.00089333f, 0.02100422f, 
    -0.02561614f, 0.00446735f, -0.03485415f, -0.03219642f, 0.00784743f, 0.02597405f, -0.05230407f, -0.02377582f, 
    -0.02916388f, 0.01084655f, -0.00459993f, 0.10315501f, 0.14156097f, 0.03121767f, -0.03607341f, 0.08097547f, 
    0.05525295f, 0.02190111f, 0.04253313f, 0.04113583f, -0.02085396f, -0.03273178f, -0.02067162f, 0.08220457f, 
    -0.05091964f, -0.00397648f, 0.02296335f, 0.00384476f, 0.07812833f, -0.00891199f, -0.01082482f, -0.03142012f, 
    -0.05161810f, -0.01091373f, -0.11676209f, -0.02380563f, -0.06744380f, -0.01670109f, -0.07229641f, -0.02873585f, 
    0.02202222f, -0.00682426f, -0.10813881f, -0.08540212f, 0.03837278f, -0.00079393f, 0.05954798f, 0.08197767f, 
    -0.05293123f, 0.00576025f, -0.02485575f, 0.02690627f, 0.12715743f, 0.02094665f, -0.04391719f, 0.01621626f, 
    -0.03289354f, -0.12128399f, -0.07401799f, 0.05042312f, -0.06138305f, -0.00526863f, -0.10790215f, -0.01219168f, 
    -0.05466478f, -0.03844875f, 0.06243636f, 0.03550288f, -0.02899489f, 0.13243012f, -0.01467833f, 0.02297758f, 
    0.02081760f, 0.03058156f, -0.04159217f, -0.03655988f, 0.04742641f, -0.06272649f, -0.07460026f, -0.06678995f, 
    0.07014678f, -0.00073330f, 0.04801404f, -0.00116156f, 0.03103679f, -0.01757484f, 0.04152978f, -0.08872090f, 
    -0.01882809f, 0.03921459f, 0.01323932f, -0.02844978f, 0.25979653f, 0.16224566f, -0.02283234f, -0.03476091f, 
    0.07149433f, -0.00635739f, -0.01421061f, -0.05169094f, 0.05419015f, -0.00173350f, -0.08843222f, 0.00047856f, 
    -0.05283033f, 0.06292661f, 0.03022032f, 0.00160695f, -0.04669758f, 0.04380807f, -0.07251195f, 0.00406102f, 
    -0.04650300f, -0.02208308f, -0.05518962f, 0.06133370f, -0.08834293f, -0.01292064f, -0.12761571f, 0.06280903f, 
    0.00475960f, -0.01872543f, -0.01166251f, 0.00418385f, 0.03508266f, -0.01457181f, 0.03743158f, 0.03734651f, 
    0.01902477f, 0.05091081f, 0.05257048f, -0.01353546f, 0.11274698f, -0.00787119f, -0.00150972f, 0.06736460f, 
    -0.05365037f, -0.07213365f, 0.00358241f, -0.04318364f, -0.07467833f, 0.01313304f, 0.00335687f, 0.05247409f, 
    0.03593230f, 0.06760634f, 0.08736850f, 0.07939478f, -0.01102563f, 0.00984286f, 0.01293304f, 0.00250593f, 
    -0.15346731f, -0.14814658f, -0.02159657f, -0.02658983f, 0.01126026f, -0.00859280f, -0.06177113f, -0.02400060f, 
    0.07797150f, -0.09488933f, -0.03435484f, -0.01262627f, 0.00183050f, 0.01811410f, -0.06050887f, -0.04805388f, 
    -0.04729651f, 0.02488016f, 0.00226606f, -0.03626098f, -0.23049168f, 0.16084030f, -0.01646222f, 0.16287981f, 
    0.04645569f, 0.06065730f, 0.03493118f, 0.04630375f, -0.03465831f, 0.02872415f, -0.03176576f, 0.02015003f, 
    -0.00869572f, -0.08409898f, -0.02065689f, 0.03917623f, 0.03919916f, 0.01642095f, -0.01007739f, -0.02987092f, 
    0.05588052f, 0.26268995f, 0.09562935f, -0.06118426f, -0.00080017f, -0.06204263f, 0.02748713f, -0.09117141f, 
    0.11104546f, 0.02818304f, -0.02247449f, -0.00065353f, -0.05004954f, 0.00480297f, -0.09352866f, -0.07606074f, 
    0.01006832f, -0.08795013f, 0.09716914f, 0.04535994f, 0.10052558f, -0.03347479f, -0.21117823f, 0.02964385f, 
    0.08717228f, -0.02216849f, 0.09619328f, -0.03474189f, 0.01913640f, -0.01783044f, 0.00981490f, -0.01215341f, 
    0.00763608f, -0.04417664f, -0.09095543f, 0.01946079f, -0.00727884f, -0.00659521f, 0.02547126f, -0.06581566f, 
    0.05680026f, -0.12931055f, -0.03567658f, -0.06273683f, -0.10098048f, -0.12558003f, -0.04560342f, 0.09399116f, 
    -0.07038327f, -0.00968474f, -0.16016674f, -0.04245294f, 0.05972142f, -0.08940180f, 0.01369369f, -0.01554151f, 
    0.00304114f, 0.14549497f, -0.02715524f, 0.05014592f, -0.15884036f, 0.11561086f, 0.10233694f, 0.11774690f, 
    -0.00785167f, 0.08138648f, 0.04906313f, 0.02738231f, -0.00021704f, 0.01860949f, -0.09052782f, -0.01141277f, 
    0.00619820f, -0.07648698f, -0.10551050f, -0.01913173f, 0.00829620f, 0.03353435f, 0.04301541f, -0.10815741f, 
    0.01547403f, -0.02041113f, 0.06226412f, 0.05550843f, -0.05633789f, -0.04774399f, -0.00623006f, -0.02873436f, 
    -0.02820855f, -0.04200473f, -0.04665079f, 0.01961609f, -0.02197683f, 0.01217332f, 0.03209590f, -0.03400243f, 
    0.03649481f, -0.04758082f, -0.03500929f, -0.02395153f, -0.14296752f, -0.47519845f, -0.26744285f, 0.08862859f, 
    0.11713250f, -0.00470020f, 0.07230762f, 0.01792775f, -0.03084677f, -0.04612542f, -0.01461136f, 0.02319400f, 
    0.00041169f, -0.00982984f, 0.03491991f, -0.03717551f, -0.07602206f, -0.02154588f, -0.00879318f, 0.02510687f, 
    0.14716414f, 0.10675838f, 0.11459060f, 0.08892572f, 0.16786228f, 0.05044483f, 0.08954811f, -0.00110233f, 
    0.01715320f, 0.02692580f, -0.02009256f, -0.05970198f, 0.02588803f, -0.08503594f, 0.05160405f, 0.04479459f, 
    0.01037218f, 0.13575193f, 0.01509989f, 0.07927059f, -0.00264534f, 0.00643059f, -0.01820938f, 0.01285610f, 
    0.00455692f, -0.07133264f, -0.06644688f, -0.02353913f, 0.02070017f, 0.00387579f, -0.04052264f, -0.00541600f, 
    0.09455992f, -0.02132345f, -0.01698155f, -0.04034825f, -0.01058456f, 0.05467545f, 0.00699220f, 0.05562617f, 
    0.07978673f, -0.17146230f, -0.20149073f, -0.07331952f, -0.22352488f, -0.01093331f, -0.02345236f, 0.03367583f, 
    -0.10445541f, 0.07437994f, -0.01194066f, -0.03771076f, -0.01023177f, -0.03729434f, -0.06893179f, 0.09316262f, 
    -0.00328506f, 0.10318843f, -0.11251476f, -0.03848051f, -0.10998349f, 0.00012654f, 0.00541560f, -0.01913273f, 
    -0.02335814f, 0.04646226f, -0.04511780f, 0.00792021f, -0.02420397f, 0.05430326f, 0.00877902f, -0.00633838f, 
    -0.03221951f, 0.02885310f, -0.02191320f, 0.04844801f, -0.01864096f, 0.04012101f, 0.06733620f, -0.00547962f, 
    0.01980636f, -0.05696493f, 0.01000988f, 0.00703773f, -0.01664107f, 0.01080874f, -0.01270768f, 0.04515653f, 
    -0.01674336f, -0.00036626f, -0.00586232f, 0.02086185f, 0.00871787f, 0.05325286f, -0.01628339f, -0.06006002f, 
    0.02954842f, 0.00003736f, 0.03036658f, -0.04174828f, -0.18312550f, 0.01339894f, -0.11946312f, 0.03552287f, 
    0.04901299f, 0.03745828f, -0.04764206f, 0.07843255f, -0.06099736f, 0.02675335f, -0.00917339f, -0.03777186f, 
    0.01869759f, 0.02951405f, -0.01862281f, -0.01579965f, -0.00461726f, 0.08352515f, 0.07243803f, -0.00920513f, 
    -0.12477325f, -0.18713745f, 0.12990053f, 0.16825463f, -0.02040223f, -0.11780687f, -0.00871020f, 0.08255175f, 
    -0.06891585f, -0.04250620f, 0.04731221f, 0.03002265f, 0.02360263f, -0.07156111f, -0.00194048f, 0.05822220f, 
    -0.02589913f, -0.00980966f, 0.00505859f, 0.02649703f, -0.22605172f, 0.03050260f, -0.04356976f, 0.01620161f, 
    -0.12985754f, -0.00696322f, -0.10112152f, 0.07171194f, 0.00478188f, -0.05971255f, -0.00752753f, -0.05745746f, 
    -0.05489194f, -0.00769690f, 0.02448323f, -0.00013003f, 0.02063580f, 0.00857377f, -0.00853647f, 0.02164700f, 
    0.02758059f, 0.06422801f, -0.17450260f, 0.02703267f, 0.13410826f, 0.11074168f, 0.06691204f, 0.02542572f, 
    -0.01505288f, -0.00802493f, -0.03231237f, 0.02670099f, 0.01265849f, -0.05944221f, -0.06998298f, -0.02909320f, 
    -0.11443991f, 0.00552696f, -0.01613230f, -0.15732805f, -0.33511865f, -0.16873148f, 0.07814413f, 0.10902573f, 
    0.16824611f, 0.03704897f, -0.02844527f, 0.05075639f, -0.02326699f, -0.17883392f, 0.07144482f, -0.03608979f, 
    -0.04770176f, 0.01327985f, 0.00505465f, -0.02687781f, 0.05276060f, -0.00506973f, -0.02163589f, -0.05102740f, 
    -0.15074509f, -0.06606678f, 0.09185413f, -0.01022431f, -0.13159768f, -0.07600615f, 0.02979396f, -0.12402200f, 
    -0.00178692f, -0.11036739f, -0.02327256f, -0.17121528f, -0.07502221f, 0.15622349f, 0.03206182f, -0.07881261f, 
    0.00280896f, -0.07765415f, -0.08197343f, -0.00649582f, -0.03207278f, 0.21817912f, -0.03732352f, 0.21437138f, 
    -0.27989340f, 0.00706097f, -0.06070394f, 0.09234957f, 0.02093907f, -0.12896693f, 0.04082421f, -0.04421971f, 
    -0.03863445f, 0.07505999f, 0.06151041f, 0.00415620f, -0.07292880f, -0.03224750f, -0.10194974f, 0.06821720f, 
    -0.42836365f, -0.06987374f, -0.00818937f, -0.02669349f, 0.15135774f, 0.04617421f, 0.05871092f, 0.02007424f, 
    0.04439715f, 0.14334299f, -0.02242024f, -0.11899084f, 0.06434892f, 0.07646114f, -0.06199748f, -0.05214044f, 
    0.08211864f, 0.03637491f, 0.05621639f, -0.14631748f, -0.56931984f, 0.12192760f, -0.07921746f, -0.07654836f, 
    0.11383422f, 0.10459010f, -0.01977128f, -0.04807501f, 0.09872591f, 0.08074259f, 0.01936909f, -0.00707775f, 
    -0.01000785f, 0.04252259f, 0.03498787f, 0.03209398f, 0.08034673f, 0.00113163f, 0.08318461f, -0.09405751f, 
    -0.03512204f, -0.23079449f, -0.09263986f, 0.06829128f, -0.09098970f, -0.11129475f, -0.06017081f, 0.04583088f, 
    -0.08185340f, -0.12017583f, -0.07264603f, -0.02566236f, -0.01536280f, -0.04519997f, 0.01577311f, -0.15062949f, 
    0.02147540f, 0.08935172f, -0.00969841f, -0.03690957f, -0.12451481f, -0.03136432f, 0.15134457f, 0.03241440f, 
    -0.06156873f, 0.11096667f, 0.15830307f, 0.00583986f, -0.02521867f, 0.00823057f, 0.20308235f, 0.05386048f, 
    0.02263692f, 0.00028721f, 0.03903196f, -0.08306801f, -0.02112022f, 0.03329179f, 0.01842669f, 0.09458173f, 
    -0.33346620f, 0.10727446f, 0.02569162f, 0.10223971f, 0.02438328f, 0.01650957f, -0.04807283f, -0.02434170f, 
    0.12843670f, -0.01821430f, -0.01374242f, 0.07488167f, -0.06962827f, 0.00400405f, 0.05856152f, 0.02442151f, 
    -0.06950441f, 0.07548702f, 0.07308739f, 0.08645382f, 0.28885725f, -0.20634501f, -0.12094373f, -0.06899780f, 
    -0.19566186f, -0.00897974f, 0.03712074f, 0.09883505f, 0.05580775f, -0.02021576f, -0.01501575f, -0.05558761f, 
    0.04101308f, -0.05025474f, -0.04498974f, -0.02776704f, -0.00886868f, 0.03685975f, 0.00788179f, 0.09909921f, 
    -0.10886368f, 0.23567936f, -0.28759649f, 0.07894594f, -0.34279200f, -0.02532794f, -0.06954382f, -0.05320966f, 
    -0.11076207f, 0.03351491f, -0.06210464f, -0.04392771f, 0.03391943f, 0.02638079f, -0.00522898f, -0.02368981f, 
    -0.03229379f, 0.08517049f, -0.07728025f, 0.01111020f, -0.08251224f, -0.07916163f, 0.06358393f, 0.08830959f, 
    -0.07427853f, -0.10277516f, 0.00772288f, 0.05196022f, -0.00972570f, 0.04289996f, 0.02752464f, -0.06716754f, 
    0.11961306f, -0.01607193f, 0.04066712f, -0.03334527f, 0.03030479f, -0.02640687f, 0.02423471f, 0.08837648f, 
    -0.27946109f, 0.07511795f, -0.05683665f, -0.07112041f, -0.00080273f, -0.04859393f, 0.08127684f, -0.04308548f, 
    0.01257571f, 0.00072309f, -0.01124370f, -0.05183758f, -0.00581512f, 0.04370837f, 0.00498549f, -0.13949668f, 
    0.09536865f, -0.03895843f, 0.03131302f, 0.04549982f, 0.10592583f, -0.07532970f, -0.02686528f, 0.20043936f, 
    0.06290442f, -0.01835594f, -0.00268004f, -0.00271620f, 0.05512831f, 0.02238959f, -0.02993581f, -0.04964465f, 
    0.10769288f, 0.05385514f, 0.02144188f, -0.10865641f, 0.01637117f, -0.07645921f, 0.03499390f, -0.07568978f, 
    0.30957612f, 0.11556860f, 0.01717780f, -0.07809211f, 0.07646722f, -0.06673203f, -0.05354601f, -0.01936482f, 
    0.09802968f, -0.02563990f, -0.05515235f, 0.07905622f, 0.02768692f, 0.01839989f, 0.02370982f, -0.05561949f, 
    0.03683851f, 0.06515907f, -0.01352246f, 0.05550443f, -0.00203918f, -0.11168689f, -0.09457818f, -0.00534061f, 
    -0.03775433f, 0.10441070f, -0.09592412f, 0.06846055f, -0.06100247f, -0.07323329f, -0.00277550f, 0.05541940f, 
    -0.03992593f, -0.03008092f, -0.02071821f, -0.00541655f, -0.01229375f, -0.08877332f, -0.03378611f, -0.07200163f, 
    0.22938907f, 0.21241781f, -0.03660677f, -0.24966982f, -0.06780076f, -0.09825341f, 0.03333165f, 0.00269068f, 
    0.03768295f, 0.04707646f, -0.04710609f, -0.01633578f, -0.00518906f, 0.00380325f, 0.02882353f, 0.02340157f, 
    -0.04473381f, 0.01272983f, -0.01740520f, -0.00742432f, -0.05128497f, 0.10307252f, -0.02734472f, 0.07225511f, 
    0.11388335f, 0.05875706f, 0.05656341f, 0.08052478f, -0.05350035f, 0.00725922f, 0.02866803f, 0.03133316f, 
    0.05977742f, 0.04272187f, -0.02306339f, 0.03269970f, -0.03233499f, -0.07994241f, 0.08327194f, -0.09390608f, 
    -0.03803814f, -0.05358072f, -0.10901091f, 0.06935585f, 0.08877190f, 0.12543634f, -0.01312862f, 0.07142716f, 
    0.04427728f, 0.03145107f, 0.00242190f, 0.02899336f, -0.00893123f, 0.04194166f, 0.03553646f, 0.05545482f, 
    0.03842096f, 0.03003255f, 0.09252613f, -0.02687806f, -0.11514324f, 0.04645494f, 0.11257772f, -0.07608920f, 
    -0.15870151f, -0.06776658f, -0.02111578f, -0.07260461f, 0.09340770f, -0.02665176f, -0.05194315f, -0.15162691f, 
    -0.01325177f, 0.06718739f, -0.02681306f, -0.17442533f, 0.05105323f, 0.04095996f, -0.03873013f, 0.03043095f, 
    0.29311255f, -0.10662978f, -0.16803952f, 0.00741821f, -0.25500649f, -0.02074211f, -0.07956997f, -0.00505507f, 
    -0.09401696f, -0.07549600f, 0.00575522f, 0.08424759f, 0.07783344f, -0.03789711f, 0.07905108f, -0.04880173f, 
    -0.00734836f, 0.04122809f, -0.00874824f, 0.00408562f, -0.46848401f, -0.04372484f, -0.02755688f, 0.10327600f, 
    0.16066529f, 0.08909747f, -0.02031610f, 0.07147428f, -0.00858757f, 0.07175376f, 0.02443691f, -0.02687137f, 
    0.01151290f, 0.03369118f, 0.00373891f, -0.00483038f, 0.06363662f, 0.09545577f, 0.05064660f, -0.02708112f, 
    -0.12883754f, 0.15089224f, 0.09194626f, -0.11346182f, -0.00044555f, 0.19922896f, 0.05939364f, -0.05368572f, 
    0.01580895f, -0.03244149f, 0.10678463f, 0.02328863f, -0.00461643f, 0.04255535f, -0.13774520f, 0.05614808f, 
    -0.04240135f, -0.03749208f, -0.00836890f, 0.00792109f, -0.02728299f, -0.14980108f, 0.04869809f, 0.23345461f, 
    -0.04512084f, -0.10716739f, 0.02932663f, 0.01011461f, -0.04578396f, -0.02877455f, 0.12786470f, 0.09814104f, 
    -0.02861544f, -0.11391883f, 0.03730816f, -0.03667903f, 0.12043854f, 0.07491965f, 0.02360658f, 0.05739177f, 
    -0.21224846f, 0.14767808f, 0.17529532f, 0.05682461f, 0.01048149f, -0.03703343f, -0.05374584f, -0.01764730f, 
    -0.05110503f, 0.02214051f, 0.12301775f, -0.05643509f, 0.02169788f, -0.01987175f, 0.03697082f, 0.00392578f, 
    0.02620594f, -0.04202842f, -0.03811260f, -0.03342595f, -0.08559591f, -0.00509068f, -0.01403996f, 0.03368165f, 
    0.00563830f, -0.06439900f, 0.04439499f, 0.10278460f, -0.02530990f, -0.02205335f, 0.02077446f, 0.06122971f, 
    -0.04575057f, -0.00183483f, -0.01913347f, -0.08366746f, -0.02392889f, 0.08534820f, -0.04535675f, 0.00914735f, 
    -0.09471799f, 0.02529757f, 0.08788574f, 0.06893460f, 0.00064135f, -0.05179496f, -0.06961474f, 0.13375400f, 
    0.03297611f, 0.04797280f, 0.02096472f, 0.00258826f, -0.04292221f, -0.04698663f, 0.01174834f, 0.03819304f, 
    -0.00730040f, -0.07741842f, -0.04543997f, -0.01278854f, 0.00504787f, -0.13118668f, 0.14329021f, 0.11583377f, 
    -0.05692731f, -0.03362076f, 0.03099585f, -0.01273835f, -0.00464925f, 0.03488981f, 0.12136707f, 0.01783539f, 
    -0.00589330f, -0.01214451f, 0.03086713f, 0.04844747f, 0.03524638f, 0.03160053f, 0.03624384f, 0.07097989f, 
    -0.19740835f, -0.05463092f, -0.02975631f, -0.03011505f, 0.04208602f, 0.02322586f, -0.00697749f, -0.04131275f, 
    0.06463242f, 0.07239520f, 0.05419333f, -0.00278314f, 0.00056125f, -0.00466816f, 0.03121283f, 0.04138397f, 
    -0.00241028f, -0.08969872f, 0.01550278f, 0.02251093f, -0.07950153f, -0.19620314f, -0.00394658f, 0.13073072f, 
    0.02114328f, -0.07595676f, 0.00312576f, 0.03773394f, -0.12352366f, -0.07388783f, 0.06541608f, 0.03524199f, 
    -0.02972253f, -0.01550710f, 0.03360257f, 0.01370417f, -0.05493658f, 0.05881257f, -0.00006293f, 0.07667648f, 
    -0.28514424f, 0.22844608f, 0.11185396f, -0.26786807f, -0.06639809f, 0.14827801f, -0.00491198f, -0.01317089f, 
    -0.01026860f, -0.01115757f, 0.01409665f, -0.09665455f, -0.04735157f, -0.04368145f, -0.06664320f, 0.00927951f, 
    -0.01830778f, -0.04183226f, -0.05426951f, -0.00383861f, -0.10920259f, -0.38334143f, -0.00571451f, -0.07181303f, 
    0.11586044f, -0.06581625f, 0.03142032f, -0.05266575f, -0.06689920f, 0.02163677f, 0.09402235f, 0.01354961f, 
    0.01106138f, -0.02658559f, -0.06730378f, 0.10596311f, -0.06997337f, -0.11789676f, -0.04009756f, -0.03674140f, 
    -0.21905726f, 0.14535274f, 0.15126844f, 0.03668145f, -0.18597268f, 0.01101413f, -0.03143314f, 0.06617503f, 
    -0.06759809f, -0.11798245f, -0.06388941f, -0.06121781f, -0.04102609f, 0.01764816f, 0.05894700f, -0.01231922f, 
    -0.09763796f, 0.05358970f, -0.11062156f, -0.01495674f, 0.05785995f, 0.10787756f, 0.15868543f, 0.03024169f, 
    -0.08755494f, 0.05655837f, -0.00892810f, -0.05222895f, 0.03024469f, -0.04858690f, 0.00483512f, 0.05240999f, 
    -0.02974168f, 0.03821910f, 0.06752995f, -0.02971056f, -0.01545394f, -0.02627542f, 0.07650667f, 0.01061314f, 
    -0.19088334f, 0.23987083f, -0.07426098f, 0.05407503f, -0.04348410f, 0.03192317f, -0.01127609f, 0.12258892f, 
    0.01328791f, 0.05282206f, 0.04907544f, 0.02805128f, -0.10346664f, 0.00265844f, 0.05247170f, -0.04613176f, 
    0.11430033f, -0.02877097f, -0.02910427f, 0.00983147f, -0.38860816f, -0.06540374f, -0.03614764f, 0.04675770f, 
    0.08889865f, 0.03878280f, 0.01564158f, 0.00566316f, 0.05352973f, 0.08895417f, -0.03048061f, -0.01712492f, 
    0.02675440f, 0.04799798f, -0.01498673f, 0.03050120f, 0.02037451f, 0.07775483f, 0.11042505f, -0.03303067f, 
    -0.44141591f, 0.22803693f, -0.11143462f, -0.21032953f, -0.10818273f, 0.01018801f, -0.12795727f, -0.05308593f, 
    0.08005178f, -0.02050913f, -0.00203569f, 0.01905758f, -0.05628916f, 0.03050392f, 0.07235674f, 0.03334559f, 
    0.05794597f, 0.04509723f, -0.07719890f, -0.10504168f, -0.08377971f, -0.06611472f, 0.01249234f, 0.05664592f, 
    0.01193019f, -0.04388428f, -0.00262427f, 0.00186743f, -0.08908632f, 0.01492802f, 0.05341244f, 0.07126322f, 
    -0.01567344f, 0.00725924f, 0.03420378f, -0.00483549f, 0.06811836f, 0.03891076f, 0.04933991f, 0.01977430f, 
    0.07660212f, 0.32314900f, -0.25814748f, -0.05816207f, 0.05842377f, 0.06462095f, -0.07723725f, 0.09522229f, 
    0.07520795f, 0.01394509f, -0.06589265f, 0.00603397f, 0.05420854f, 0.01635730f, 0.02093948f, -0.00042900f, 
    0.02811451f, -0.12371396f, -0.03580976f, 0.00205072f, 0.13744536f, 0.32004014f, -0.26618361f, -0.15433589f, 
    0.00571983f, -0.02714166f, 0.06770346f, 0.06990951f, -0.00049591f, 0.03256337f, -0.02984360f, 0.05479353f, 
    -0.04153248f, -0.03061337f, 0.01699196f, -0.02509945f, 0.13038822f, 0.00205393f, -0.02858929f, -0.01505566f, 
    0.17576897f, -0.13595468f, -0.11501771f, 0.15396354f, -0.06186802f, 0.05588953f, -0.04434334f, 0.00389760f, 
    -0.02143432f, 0.07616312f, -0.06963002f, -0.02084888f, 0.04057081f, -0.02435291f, 0.01037019f, 0.01959650f, 
    -0.00793283f, -0.01563637f, 0.03478368f, -0.08100904f, 0.01970928f, -0.00652934f, -0.03569118f, -0.12854202f, 
    0.00759958f, 0.02533998f, -0.02826065f, -0.04693215f, -0.01026879f, -0.08893047f, -0.05282330f, -0.02299832f, 
    -0.06493106f, -0.01074741f, -0.08661762f, -0.06873603f, -0.06935877f, -0.08806498f, -0.07680436f, -0.02205039f, 
    -0.23378196f, -0.06587080f, -0.06561227f, 0.07939352f, 0.01169739f, 0.08702763f, -0.02125705f, 0.09595526f, 
    -0.02124522f, 0.00970744f, 0.03458580f, 0.00649821f, -0.04523737f, -0.05448290f, 0.05135925f, 0.00160553f, 
    0.01718276f, 0.03874451f, 0.00740389f, -0.03001890f, 0.07268257f, 0.03813073f, 0.02980821f, 0.12414650f, 
    0.03048690f, 0.10331780f, 0.00649845f, -0.05832882f, 0.11737137f, 0.00998081f, 0.10651334f, 0.00361063f, 
    0.05055821f, -0.01928122f, 0.04610099f, 0.05521248f, -0.10070440f, 0.03835189f, 0.11284228f, -0.00239471f, 
    -0.01698266f, 0.03096312f, -0.01543579f, -0.00693265f, 0.08832042f, -0.03571801f, -0.01420676f, 0.02990829f, 
    0.09865402f, 0.00549799f, -0.00364354f, -0.04009983f, -0.00552339f, -0.00537335f, -0.00645130f, 0.00295016f, 
    -0.05134349f, -0.01631556f, -0.02366017f, 0.05431484f, -0.02009879f, -0.02636439f, 0.17911486f, -0.15758115f, 
    -0.09968406f, 0.01621552f, 0.09865887f, -0.06449603f, 0.07633262f, 0.02095516f, 0.09835353f, -0.02161847f, 
    -0.02141921f, 0.00974705f, 0.02101516f, -0.00489476f, -0.03800152f, 0.02671333f, -0.06097877f, 0.06399204f, 
    -0.30802342f, -0.02849337f, 0.01691982f, 0.06527683f, 0.08105868f, -0.01823951f, 0.02281634f, -0.05529807f, 
    0.04855777f, -0.01518932f, -0.04762441f, -0.02539360f, 0.01442099f, 0.06550088f, 0.01155609f, -0.00723330f, 
    0.03028751f, 0.07369146f, 0.05506865f, -0.00837105f, 0.15075988f, 0.07971677f, -0.01206131f, 0.08937491f, 
    -0.04942302f, -0.00790182f, 0.06148113f, 0.01744182f, 0.07240262f, 0.01575878f, 0.02752083f, 0.09144232f, 
    0.01229361f, -0.02062080f, 0.00152553f, -0.04600543f, -0.08650423f, -0.15532711f, 0.00648090f, -0.05028445f, 
    0.36266217f, 0.21763216f, -0.09157484f, -0.24521883f, 0.04508078f, -0.07666522f, 0.01848681f, 0.04203525f, 
    0.04271224f, -0.03691519f, 0.03606443f, -0.00868753f, 0.08097993f, -0.01120032f, -0.00985369f, 0.00991771f, 
    0.04615943f, -0.02824456f, 0.01959805f, 0.00444030f, -0.26338825f, -0.20700839f, 0.04037498f, 0.10328088f, 
    0.06662922f, 0.02495922f, -0.02854260f, 0.02546343f, -0.06068489f, 0.04807585f, -0.01888531f, -0.05214592f, 
    -0.00799878f, -0.01828965f, 0.03139332f, -0.01589260f, -0.07238464f, -0.07711206f, 0.07722852f, -0.03056798f, 
    0.25310257f, 0.19114260f, 0.13317230f, -0.15529248f, -0.10716426f, -0.09874081f, -0.00511560f, 0.08153150f, 
    0.05758093f, -0.03857080f, 0.00797805f, -0.02793862f, -0.00811448f, 0.05555809f, 0.02043518f, -0.01695620f, 
    0.02712004f, 0.05351482f, -0.00952929f, -0.07923605f, -0.19067714f, -0.20213820f, 0.15129504f, 0.15079525f, 
    0.01485732f, -0.07881586f, -0.01650867f, -0.04352372f, -0.01319955f, 0.05965726f, -0.02295887f, 0.03678044f, 
    -0.06045979f, -0.05520079f, -0.01424153f, -0.12202898f, -0.06276691f, -0.04044214f, 0.02297764f, 0.02585574f, 
    -0.43276548f, -0.25038353f, -0.14792433f, 0.19540910f, 0.21905302f, 0.03404864f, 0.03459236f, -0.04592609f, 
    0.07573248f, 0.06279516f, -0.02700980f, -0.05231577f, 0.07745188f, 0.03446908f, 0.04233485f, -0.02266074f, 
    0.08588227f, 0.02331740f, 0.05206687f, -0.02072201f, -0.01421947f, -0.02516446f, 0.11818039f, 0.00595011f, 
    0.06026284f, -0.01463629f, 0.01186136f, -0.06578190f, -0.06175654f, 0.03287210f, 0.08173975f, 0.01984039f, 
    -0.13021055f, -0.00183556f, 0.03445210f, -0.05353640f, -0.03837555f, 0.03231938f, 0.00826940f, -0.00112956f, 
    -0.05491673f, 0.07695904f, -0.18575110f, 0.01668669f, 0.02251272f, 0.01054524f, 0.07364085f, 0.05353582f, 
    0.01128536f, 0.03708776f, 0.03530485f, 0.06791993f, 0.03413501f, -0.03187621f, -0.08693557f, -0.05024615f, 
    -0.03494540f, 0.09604239f, -0.00442631f, -0.00639309f, 0.08107561f, -0.12567605f, 0.09578969f, 0.00203710f, 
    0.01236428f, -0.09485282f, 0.03073669f, 0.01726587f, -0.06751169f, 0.00646169f, 0.06870631f, -0.00541292f, 
    -0.00816981f, -0.05359920f, -0.06073223f, 0.06159432f, -0.03061275f, 0.01020124f, -0.00471062f, 0.03036387f, 
    0.01822223f, -0.02316412f, 0.05413722f, 0.11050880f, -0.10056573f, -0.10622236f, -0.01712671f, 0.05077815f, 
    -0.02486935f, -0.03844238f, -0.03623600f, 0.00191906f, 0.03869384f, 0.01084390f, 0.09548131f, -0.01964763f, 
    0.01219993f, 0.02547440f, -0.00957905f, 0.09675533f, -0.26517987f, 0.06825581f, 0.03668422f, 0.09107095f, 
    0.03602748f, 0.03158663f, -0.06727160f, -0.05365507f, 0.07214374f, 0.02950292f, -0.03549349f, 0.06781349f, 
    -0.03516439f, 0.01098258f, -0.01108930f, -0.04375043f, 0.00584883f, -0.02415541f, 0.02475762f, -0.02452004f, 
    -0.02767591f, 0.24040510f, -0.02613765f, -0.04003052f, -0.08526655f, -0.03381886f, -0.04723860f, -0.10668280f, 
    -0.11305974f, -0.00069359f, -0.11402382f, 0.00933931f, -0.07804634f, 0.03207402f, -0.02096369f, 0.08662033f, 
    0.00395280f, 0.01322430f, 0.02730440f, 0.04052491f, -0.03296695f, 0.14864817f, -0.07570808f, 0.07488685f, 
    0.13218011f, -0.00189577f, 0.06532723f, 0.02983470f, -0.01416819f, -0.02061844f, -0.07011379f, 0.05571548f, 
    0.04252578f, -0.02360733f, -0.00336587f, -0.02598548f, 0.03300853f, -0.01342985f, -0.11724406f, -0.09270925f, 
    -0.19220713f, 0.07026564f, 0.06853640f, -0.09613797f, -0.07429580f, 0.02482691f, 0.02332459f, 0.15525585f, 
    -0.07956413f, -0.04192651f, 0.05868689f, -0.08329794f, 0.00426762f, -0.05668020f, -0.00584204f, -0.02365295f, 
    -0.05039842f, 0.02377800f, -0.00099684f, 0.04681195f, -0.15499213f, 0.03668880f, -0.07335654f, -0.03512589f, 
    -0.00723365f, 0.00267644f, 0.01063966f, -0.05682771f, 0.10005733f, -0.08716027f, 0.02464418f, 0.03357015f, 
    0.02261145f, -0.08911788f, 0.04511185f, 0.02498974f, 0.00946863f, -0.02756260f, -0.05103904f, 0.03068074f, 
    0.11691450f, 0.01189152f, 0.05491377f, 0.07916158f, 0.03612946f, -0.06683416f, -0.00015961f, -0.01556439f, 
    0.05597932f, 0.03421515f, -0.06813130f, -0.04707981f, 0.05706120f, 0.09175797f, 0.11110385f, -0.09422251f, 
    -0.05582937f, -0.02189228f, 0.04498277f, -0.06518383f, -0.04915402f, 0.10279053f, -0.00604223f, -0.01572664f, 
    -0.02371981f, -0.13933238f, 0.07539764f, 0.03682049f, -0.02650706f, -0.04889193f, 0.09698322f, -0.03144072f, 
    0.05386033f, -0.03064709f, -0.03716867f, 0.08431211f, -0.03688340f, -0.03707609f, 0.06652177f, 0.08814035f, 
    -0.44258246f, -0.15236126f, -0.05007551f, -0.08523682f, 0.05419048f, 0.09314624f, -0.05214467f, -0.09623427f, 
    0.05614407f, -0.11601438f, 0.06230818f, 0.08958922f, -0.12344583f, 0.03897646f, -0.03919609f, -0.01129581f, 
    0.10416887f, 0.01730717f, -0.14705540f, 0.00889927f, 0.02037423f, 0.01187357f, 0.01548008f, -0.00387016f, 
    -0.03709890f, -0.03170348f, 0.05704335f, 0.01389143f, 0.03736602f, 0.16772576f, 0.07982907f, -0.07509870f, 
    -0.09153444f, -0.00426448f, 0.00339928f, 0.08373871f, -0.09996425f, -0.14876841f, 0.00244225f, 0.10234555f, 
    0.06225560f, 0.02698251f, -0.05137768f, 0.12618381f, 0.10018284f, -0.03722127f, -0.01333929f, 0.06447029f, 
    0.06355625f, -0.01317459f, -0.00231175f, 0.04579464f, -0.01700092f, 0.01987432f, -0.00098236f, -0.00343432f, 
    0.01309533f, -0.03398794f, 0.10510400f, -0.13248631f, -0.10057814f, -0.06716835f, 0.00683970f, -0.00809170f, 
    0.07484425f, 0.05790460f, 0.01763373f, -0.02737258f, -0.05851851f, 0.13275184f, 0.08453275f, -0.00086003f, 
    0.05324184f, -0.06658337f, -0.01448129f, -0.05915925f, 0.00791912f, -0.06851675f, 0.11130931f, -0.07036065f, 
    -0.24947363f, -0.02001436f, -0.17189462f, -0.12195589f, -0.07432453f, 0.07300369f, 0.02888272f, 0.02200893f, 
    0.04198148f, -0.14481778f, 0.03639757f, 0.11309023f, -0.09823979f, -0.04982129f, -0.05847888f, 0.01898006f, 
    -0.06963425f, 0.03078636f, -0.08584668f, 0.03501699f, -0.47864988f, 0.16335358f, -0.23307990f, -0.05286733f, 
    -0.14050177f, 0.08403526f, 0.01364092f, 0.03869744f, -0.03595405f, -0.17110710f, -0.02498261f, -0.00845458f, 
    0.03086039f, -0.11871790f, -0.12573268f, 0.02718129f, -0.11265765f, 0.05280315f, 0.09983906f, 0.01715732f, 
    -0.01614423f, 0.05160721f, 0.07991606f, 0.08524118f, 0.15326607f, -0.10781962f, -0.12690812f, 0.10262568f, 
    -0.00801716f, 0.04398148f, -0.00748263f, -0.13502876f, -0.05013354f, 0.02024843f, 0.05042074f, 0.04655860f, 
    0.06963728f, -0.21680966f, -0.05752011f, -0.02721597f, 0.00475943f, 0.06897271f, -0.05099991f, 0.05693883f, 
    0.04172500f, 0.02093987f, -0.04440015f, -0.06610025f, -0.05559439f, 0.03610903f, -0.02669251f, 0.12736711f, 
    0.14996818f, 0.11711705f, -0.02754466f, 0.01655234f, -0.02857860f, -0.07128914f, -0.20399365f, 0.00572170f, 
    -0.27101335f, 0.01556729f, -0.25216612f, -0.18968557f, 0.09118222f, 0.01745271f, 0.08809171f, -0.01268123f, 
    -0.02711250f, 0.03527464f, 0.01676973f, 0.03375831f, 0.10349669f, -0.13903996f, 0.04787419f, -0.06708532f, 
    0.11167791f, -0.13527717f, 0.06294610f, -0.01988260f, -0.15317105f, 0.01711001f, 0.15346156f, 0.19769801f, 
    -0.32415161f, 0.01314499f, 0.08303006f, -0.02415268f, -0.01591063f, 0.17470671f, 0.00048970f, 0.04439938f, 
    0.04605151f, -0.00378874f, -0.10540083f, 0.00861195f, -0.06017010f, -0.13842951f, -0.01626137f, 0.02791809f, 
    -0.02270463f, -0.26725951f, -0.19022763f, -0.06445899f, 0.05523857f, 0.01288095f, -0.04939743f, -0.10104328f, 
    0.00449268f, 0.04220564f, 0.13050073f, 0.11706199f, 0.02719856f, -0.02889504f, 0.01792875f, 0.00922981f, 
    -0.09373850f, -0.04797990f, 0.00832210f, -0.05103237f, -0.04069510f, 0.07060202f, -0.02844503f, 0.07020990f, 
    0.00725365f, 0.06413154f, 0.02876851f, -0.06205661f, 0.09872215f, 0.03032503f, 0.09357334f, 0.04501600f, 
    0.04307082f, -0.00435947f, -0.16240937f, 0.00906736f, 0.01421028f, -0.10974903f, 0.09080446f, 0.06890198f, 
    0.00556081f, 0.07238432f, 0.02214974f, 0.06803364f, 0.07170791f, -0.02731949f, -0.00497829f, 0.09690395f, 
    0.00147950f, 0.04941692f, -0.03489133f, -0.04166824f, -0.06129945f, -0.02839719f, 0.00445813f, 0.09605353f, 
    0.10368522f, -0.05282945f, 0.13223185f, 0.05353627f, 0.17482947f, 0.21639171f, 0.07842152f, -0.02218188f, 
    -0.04528615f, 0.01813729f, -0.05350985f, 0.00884396f, -0.06300650f, 0.00534309f, 0.04219467f, -0.01740871f, 
    -0.07591406f, 0.01539736f, -0.14762740f, 0.09634099f, 0.00335390f, 0.11067834f, 0.03968986f, 0.05890383f, 
    -0.13735291f, -0.12745976f, 0.21329278f, 0.15547203f, -0.21532564f, 0.02885264f, -0.02397233f, -0.06827574f, 
    0.04273311f, -0.08663773f, -0.02084343f, -0.00112152f, -0.02580016f, -0.13454771f, 0.06017522f, -0.10259344f, 
    0.05015647f, 0.02532009f, 0.11202157f, 0.03801626f, -0.21296947f, 0.01109337f, -0.04947804f, 0.21255489f, 
    0.05630975f, -0.05095331f, -0.15332511f, -0.08622546f, -0.03028994f, 0.09244320f, 0.12715009f, -0.02432277f, 
    -0.03447913f, -0.00437037f, -0.06253607f, 0.02931797f, -0.02252750f, -0.06229340f, -0.04132459f, -0.05853052f, 
    -0.17105633f, -0.12374724f, -0.00067090f, 0.13892250f, -0.10339598f, 0.01301308f, -0.03462011f, -0.03763727f, 
    -0.00610756f, -0.04671971f, 0.01193985f, 0.02322176f, -0.01865756f, 0.08060893f, 0.10339759f, -0.06502067f, 
    0.08948001f, 0.04207413f, 0.01064352f, -0.02460323f, -0.49426627f, 0.01203646f, -0.01256127f, -0.11785721f, 
    -0.01745949f, 0.05514531f, -0.00418949f, 0.07073428f, -0.02180891f, -0.11830395f, 0.07882422f, 0.00786383f, 
    0.05883163f, -0.02441243f, 0.06723817f, 0.02670877f, -0.00649910f, 0.03910511f, -0.04058780f, 0.06598375f, 
    -0.04488144f, 0.06700031f, 0.03221776f, -0.08091630f, 0.01235943f, 0.04836415f, 0.07957952f, -0.02055782f, 
    -0.03330449f, 0.06449512f, -0.02346024f, 0.01026551f, -0.07337680f, -0.09446190f, 0.06034724f, -0.11878750f, 
    -0.01151865f, 0.05931377f, -0.14182255f, -0.01973890f, -0.06734565f, -0.02427192f, 0.05661783f, 0.08903767f, 
    -0.14458294f, -0.06125459f, -0.08546717f, 0.00591877f, -0.06315325f, 0.00999245f, -0.10755114f, 0.04271875f, 
    -0.01031002f, 0.01514166f, 0.03892804f, -0.00868054f, 0.01473407f, -0.08121837f, 0.08851524f, -0.08350681f, 
    -0.08336081f, -0.00581260f, 0.12400935f, -0.08652437f, 0.02746857f, 0.00443032f, -0.02545450f, -0.09469133f, 
    0.00436377f, 0.11135493f, -0.06525262f, -0.03028431f, -0.04588279f, -0.03767016f, -0.05057116f, 0.08402192f, 
    0.00811116f, -0.06641578f, -0.05754567f, 0.08283598f, -0.25906351f, 0.07872267f, -0.11122753f, -0.11183138f, 
    -0.09124378f, 0.05848028f, 0.03085466f, 0.08066387f, -0.07520976f, -0.13998266f, 0.04129596f, -0.03723430f, 
    0.03184218f, -0.07682803f, 0.01532194f, 0.01013401f, 0.02383456f, -0.04397991f, -0.01291954f, 0.00220146f, 
    -0.24378264f, 0.04984802f, 0.09999157f, 0.27086449f, 0.08726451f, 0.02730240f, -0.07568288f, -0.01865443f, 
    -0.01439501f, -0.00054959f, -0.09830474f, 0.01437845f, -0.01320336f, 0.02576691f, 0.05822752f, -0.05838583f, 
    0.06720684f, -0.06174360f, -0.05460942f, -0.28618652f, 0.03006106f, 0.01841618f, 0.06105557f, -0.04791122f, 
    0.21652369f, -0.00930734f, -0.17217612f, 0.00997641f, -0.04474965f, 0.05699594f, -0.02461302f, -0.09592367f, 
    0.06535720f, 0.11633383f, 0.00313010f, 0.01366883f, -0.19518754f, -0.07659017f, -0.06534553f, -0.00620739f, 
    0.15347199f, -0.02995372f, -0.04803411f, -0.03021771f, -0.14698797f, -0.06944436f, 0.05110244f, 0.05095198f, 
    0.02370155f, 0.03872896f, -0.00318756f, 0.08925816f, 0.08756943f, -0.01274748f, -0.00232165f, -0.09862688f, 
    -0.09704375f, 0.09959241f, 0.08768384f, 0.03394214f, 0.07366192f, -0.12488173f, 0.07270372f, -0.03506799f, 
    0.08957510f, -0.08779240f, -0.05979838f, 0.02577289f, 0.04529155f, -0.02930043f, -0.02915897f, 0.08049931f, 
    -0.07433829f, 0.10288839f, 0.05419493f, -0.02776679f, -0.12662502f, 0.03024097f, -0.16842353f, 0.08705027f, 
    0.03866337f, -0.04196480f, -0.06437008f, 0.07304353f, -0.34380266f, -0.15829475f, 0.05044264f, -0.05561525f, 
    0.02270085f, -0.01413989f, 0.05195564f, 0.09476759f, 0.02467222f, 0.07150687f, 0.05785362f, -0.07982757f, 
    0.00692401f, 0.05834487f, 0.06815924f, -0.05426912f, 0.03880718f, 0.00201004f, 0.07178045f, 0.08334525f, 
    0.14607616f, -0.11872657f, 0.07841376f, -0.04086584f, -0.01992419f, 0.01296120f, -0.07629024f, -0.03307326f, 
    0.10277119f, 0.06277528f, 0.05874104f, -0.04643102f, -0.00303206f, -0.00788876f, 0.02609072f, -0.00841252f, 
    0.08518195f, -0.02042472f, 0.08406574f, 0.18163556f, 0.03545376f, 0.09691231f, 0.11364157f, 0.06184999f, 
    -0.02295581f, -0.02634906f, -0.02470011f, -0.03509824f, -0.03087774f, 0.01362796f, 0.03641899f, 0.05065451f, 
    0.02283804f, 0.03066216f, 0.00983495f, 0.03273003f, 0.05707863f, 0.00451634f, -0.02706508f, 0.09212358f, 
    0.11428442f, -0.03839630f, -0.04345334f, -0.08040266f, 0.14664693f, 0.06329381f, -0.03022136f, -0.08612690f, 
    -0.04449628f, 0.08738141f, 0.12003580f, -0.00110053f, 0.06918500f, 0.01548065f, -0.02547048f, -0.03697883f, 
    -0.29220209f, 0.02564172f, 0.13027033f, 0.32551056f, -0.01890836f, -0.05650896f, 0.07034125f, -0.02430176f, 
    -0.03209349f, 0.05761670f, 0.06643390f, 0.01158041f, 0.00558976f, 0.02832383f, 0.01904914f, 0.01897396f, 
    0.08960336f, -0.02985164f, -0.01588185f, -0.15314358f, 0.09079492f, 0.13134283f, 0.06354055f, 0.05714906f, 
    -0.02108866f, -0.11763385f, 0.02246976f, -0.07658195f, 0.05638535f, 0.01609387f, -0.01074353f, -0.00656857f, 
    -0.06168770f, 0.00119288f, 0.08504635f, -0.00539004f, 0.08974326f, 0.15443924f, -0.02433418f, -0.00162838f, 
    -0.10717080f, -0.00225493f, -0.10948016f, 0.02354235f, 0.07951070f, 0.05044246f, 0.02761246f, 0.00782283f, 
    -0.03548333f, -0.01078024f, 0.01336616f, -0.03359229f, 0.03240338f, -0.02410642f, 0.02464193f, -0.07239939f, 
    0.07432121f, -0.06771756f, 0.08074950f, -0.00519634f, 0.02841919f, -0.01939260f, -0.04503761f, -0.00026965f, 
    0.08712096f, 0.10731703f, -0.06444149f, -0.01782107f, 0.05585096f, -0.09100560f, -0.05578458f, -0.03183444f, 
    -0.05151112f, -0.00137919f, 0.02401905f, -0.05990184f, -0.00390720f, -0.01039675f, -0.14733283f, -0.05418027f, 
    -0.10366517f, -0.05008675f, 0.13148499f, 0.08425555f, -0.22704154f, -0.04841577f, -0.01036628f, -0.00034243f, 
    -0.00405900f, 0.01900076f, 0.04112734f, -0.02397192f, 0.01681761f, -0.01185981f, -0.03264165f, 0.01860480f, 
    -0.11259905f, 0.02420441f, 0.07745609f, 0.03497640f, -0.25938258f, 0.04328750f, -0.17927966f, -0.09165008f, 
    -0.03803106f, 0.04192556f, 0.10343442f, 0.02682164f, -0.01800408f, -0.09295995f, 0.04126357f, 0.01293579f, 
    0.02641520f, -0.04537280f, -0.01531504f, 0.00697777f, -0.04518631f, -0.05273782f, -0.01606740f, 0.02783311f, 
    -0.28339329f, -0.03071458f, -0.10551409f, 0.00207955f, -0.07113481f, 0.13132837f, -0.03866166f, -0.05935492f, 
    0.00381937f, -0.06904761f, 0.01098918f, 0.00289002f, 0.08101542f, 0.00528278f, -0.08014033f, 0.05375788f, 
    -0.02920647f, -0.04895353f, 0.19141744f, -0.06026505f, 0.01851437f, -0.00817020f, 0.02653632f, 0.06245127f, 
    0.04558356f, 0.00241392f, -0.06523623f, -0.09471159f, -0.00994556f, 0.05054522f, 0.03404357f, -0.08899254f, 
    0.02045764f, 0.01744092f, -0.03241477f, 0.01193787f, -0.08245841f, -0.02004594f, -0.11389772f, 0.00819087f, 
    -0.21425617f, -0.03664535f, 0.07162160f, 0.07683350f, -0.17795514f, 0.08539432f, -0.00651793f, 0.02462306f, 
    0.02426839f, 0.00058065f, 0.04604603f, -0.02195079f, -0.02391069f, -0.03026484f, -0.06114670f, -0.13740550f, 
    0.09257840f, 0.16856620f, -0.01035633f, -0.00479759f, -0.13933356f, -0.06142456f, 0.25111958f, 0.10767612f, 
    -0.36914980f, 0.02239522f, -0.06174681f, 0.02343415f, -0.03464400f, -0.08135254f, 0.00214761f, -0.00426625f, 
    0.03763144f, -0.03575364f, 0.03886617f, -0.09699573f, -0.06667931f, 0.10337029f, 0.02504140f, 0.02667514f, 
    0.15575357f, 0.28079322f, 0.04853144f, -0.08296502f, 0.00885761f, -0.08667370f, 0.02432954f, 0.00548925f, 
    -0.06809744f, -0.00553855f, 0.05700758f, 0.05258412f, -0.01223232f, -0.00271476f, -0.00435815f, 0.04012318f, 
    -0.01673454f, 0.09208477f, 0.10340191f, -0.02562304f, -0.08014575f, -0.15691516f, -0.09459073f, 0.19115466f, 
    -0.01067729f, 0.05986307f, 0.00416269f, -0.00076864f, -0.00385645f, -0.02477141f, 0.06931486f, -0.00196535f, 
    -0.02539136f, 0.03623033f, -0.01076393f, 0.07463551f, -0.03305161f, 0.09125632f, -0.14107132f, 0.03649764f, 
    0.03074708f, -0.05973599f, 0.10987618f, -0.03196675f, -0.03582005f, -0.00926651f, 0.11367828f, -0.01887916f, 
    -0.01227889f, -0.07542241f, 0.00027272f, -0.03987605f, 0.02295427f, -0.08583751f, 0.06678177f, 0.07031173f, 
    0.02954183f, -0.06588611f, 0.01745600f, -0.04079541f, -0.39799717f, -0.12388612f, -0.15520740f, 0.00408012f, 
    0.01843591f, 0.04688392f, 0.12936434f, -0.09505422f, -0.01756493f, 0.00984487f, 0.00593818f, 0.03000249f, 
    0.09281923f, 0.08224849f, -0.04366779f, -0.04147804f, 0.07365755f, -0.12881801f, -0.14307502f, 0.07883179f, 
    -0.20993842f, -0.12529904f, -0.09998715f, 0.09074436f, 0.03655933f, 0.04027905f, 0.07919481f, 0.07036947f, 
    -0.08082616f, 0.09510298f, 0.04285674f, 0.07584894f, 0.06949203f, -0.06194391f, 0.02160073f, 0.06608947f, 
    0.03529034f, 0.00454841f, 0.00887312f, -0.00257835f, -0.28189370f, -0.16240266f, -0.06276944f, -0.11537238f, 
    -0.03615802f, -0.02279500f, 0.07177639f, 0.02600569f, -0.04065073f, 0.02953028f, -0.10579813f, 0.14498900f, 
    0.07121610f, 0.01081190f, -0.02019899f, -0.05998594f, 0.06849021f, -0.05489301f, 0.07584052f, -0.06121231f, 
    -0.10848976f, 0.14578977f, -0.14805831f, -0.09570536f, -0.00209755f, -0.00634985f, 0.08938891f, 0.01387370f, 
    -0.01172483f, -0.04341526f, 0.02574838f, -0.03244634f, -0.02480862f, -0.12717636f, 0.00590400f, -0.01245573f, 
    0.02240211f, -0.02043040f, 0.01388038f, -0.03144574f, -0.16011819f, -0.10253450f, -0.06126212f, -0.00374661f, 
    -0.05310806f, -0.06456059f, 0.03075690f, 0.02477963f, -0.05917133f, 0.05748952f, 0.07285193f, -0.04263872f, 
    -0.05559849f, 0.05843421f, -0.04303256f, 0.02350749f, 0.00578537f, 0.00668812f, -0.06136931f, 0.13813807f, 
    -0.16747427f, -0.02037805f, 0.18853383f, 0.06893433f, -0.09308147f, 0.00158393f, -0.08058178f, -0.07175630f, 
    -0.00860179f, -0.13617888f, -0.01848785f, 0.02459954f, -0.08287789f, 0.06321863f, 0.05880798f, -0.04902877f, 
    0.08862148f, 0.05915762f, 0.10380897f, -0.09758611f, 0.07101075f, 0.09141833f, 0.05429281f, -0.01353890f, 
    -0.05417026f, -0.10439825f, 0.00112946f, 0.00644189f, 0.10916511f, 0.05692683f, -0.02619656f, -0.06039165f, 
    0.07057773f, 0.07470833f, 0.08512628f, 0.06429762f, 0.03721796f, 0.02548654f, -0.15510073f, 0.04823343f, 
    -0.19480817f, -0.08019169f, 0.10546944f, 0.15865286f, -0.14807494f, 0.04305806f, 0.03162819f, -0.00898308f, 
    0.02605697f, -0.06980867f, 0.04565948f, -0.03819952f, -0.01530359f, 0.09794191f, 0.05094591f, -0.02867740f, 
    -0.05583991f, -0.00574904f, 0.01179164f, 0.02285530f, 0.05749081f, 0.00510865f, 0.01687519f, 0.13230598f, 
    -0.01298216f, -0.03889905f, -0.02417193f, 0.01112178f, -0.00238407f, 0.08442182f, -0.01614777f, -0.08925626f, 
    -0.07608214f, 0.02822306f, 0.00805896f, 0.04343548f, 0.06214956f, -0.05042220f, 0.06944927f, 0.05893200f, 
    -0.11365091f, 0.08962669f, -0.12783992f, -0.11824605f, -0.07963685f, 0.12129495f, 0.08242746f, 0.12188473f, 
    0.00779014f, -0.03236175f, -0.07547909f, 0.03047514f, -0.15884319f, -0.03556722f, -0.07469984f, 0.06230057f, 
    0.03224877f, 0.09576828f, 0.00242100f, -0.01849087f, 0.11782780f, -0.02335944f, -0.12666363f, -0.05168040f, 
    0.11280714f, -0.10890095f, -0.10517060f, 0.04097906f, 0.11121915f, 0.04538713f, 0.06912272f, -0.03444061f, 
    -0.01092021f, 0.17892769f, 0.19983557f, 0.09149293f, 0.11910429f, -0.03181377f, -0.22157528f, -0.00780300f, 
    -0.15610921f, -0.05117794f, -0.01991682f, -0.07485876f, 0.08110473f, 0.06781925f, -0.04770846f, -0.08608168f, 
    0.01780438f, 0.02430283f, 0.01325227f, 0.03293913f, -0.09279296f, 0.06665163f, -0.03997004f, 0.04297535f, 
    0.02849223f, -0.03448848f, -0.08961778f, -0.00185525f, 0.06421853f, 0.04959325f, 0.04790647f, 0.05915094f, 
    -0.07821890f, -0.09208562f, -0.01262919f, -0.05907229f, -0.01852102f, -0.01789033f, -0.03220525f, 0.01263335f, 
    0.01363486f, 0.06742719f, 0.02166813f, -0.01994785f, -0.03743278f, 0.14657634f, 0.02495529f, -0.03931232f, 
    0.07385644f, -0.03303103f, 0.09269417f, 0.11808614f, 0.02415630f, 0.00501365f, -0.01134289f, 0.00745248f, 
    0.04598250f, 0.00235307f, -0.06711508f, -0.01523276f, -0.02588479f, 0.11900251f, 0.02311420f, 0.01573235f, 
    0.05834329f, -0.19560367f, -0.09154484f, -0.03563740f, -0.32646435f, 0.08345252f, -0.26084915f, -0.09330833f, 
    0.03816617f, 0.13835990f, 0.12059697f, 0.02888575f, -0.08372391f, -0.03362041f, -0.02346953f, 0.03392096f, 
    -0.02756234f, -0.06202665f, 0.05249312f, 0.02805015f, -0.01618364f, -0.01309470f, -0.03313254f, -0.07263017f, 
    -0.13493180f, 0.07353055f, -0.08886251f, 0.25172678f, 0.05286711f, 0.04456478f, 0.03086783f, 0.07296237f, 
    0.03549537f, -0.01393681f, -0.00571028f, -0.02639875f, 0.10067187f, -0.01874986f, -0.07355115f, -0.04319789f, 
    0.02322887f, -0.12038138f, -0.02500087f, -0.03127770f, 0.17520781f, 0.01116813f, -0.03421858f, -0.17381923f, 
    -0.09864444f, -0.00349153f, -0.02038279f, -0.02941355f, -0.04731473f, 0.01161861f, -0.04002988f, 0.05604899f, 
    0.08750858f, -0.08880624f, -0.00641688f, 0.04523112f, -0.00947083f, 0.03904020f, 0.05967023f, 0.05146320f, 
    0.08628070f, -0.20717943f, -0.05367942f, 0.08926890f, -0.04149018f, -0.03239649f, 0.08949974f, -0.03958485f, 
    0.00163078f, 0.00882322f, -0.03677448f, 0.03895128f, -0.01468105f, -0.01294068f, 0.06988928f, 0.02440061f, 
    0.01752241f, 0.03635245f, -0.05344202f, 0.04807321f, 0.06149310f, -0.24354708f, -0.03993771f, -0.05285032f, 
    0.04528053f, -0.09670794f, 0.02463037f, -0.00038106f, -0.06912509f, 0.05761668f, 0.01116801f, 0.01424684f, 
    0.00668770f, 0.04277911f, -0.00480123f, -0.05741593f, -0.01956540f, 0.02943764f, -0.02934793f, 0.00294414f, 
    -0.12696922f, 0.18155570f, 0.07338767f, -0.09060080f, -0.24639304f, 0.06677697f, 0.02393386f, 0.04165286f, 
    0.03017865f, 0.04121239f, -0.03044505f, 0.00218437f, -0.12135760f, -0.00689037f, -0.09819797f, 0.02653357f, 
    0.00962375f, 0.01858665f, 0.07372408f, -0.01636628f, 0.04808401f, -0.03657151f, 0.07020248f, 0.08766118f, 
    0.08711632f, 0.02222292f, 0.03784374f, 0.00394910f, -0.04503285f, -0.06815676f, -0.11270308f, -0.03423684f, 
    0.01995322f, 0.06490844f, -0.01561320f, 0.01658137f, -0.00738131f, 0.07082131f, -0.15298893f, -0.02195676f, 
    -0.36156273f, 0.00599093f, 0.01344679f, -0.12885003f, 0.10252604f, -0.02510463f, 0.01204497f, 0.06912094f, 
    -0.10936885f, 0.01293792f, 0.03839113f, -0.09340198f, 0.03671245f, -0.01241560f, -0.00471763f, -0.01304607f, 
    -0.00040201f, -0.13093215f, 0.11813240f, 0.07683209f, -0.21908700f, 0.00372756f, 0.03840345f, 0.09957671f, 
    -0.03775321f, 0.05753564f, 0.04465075f, -0.01198565f, 0.01469750f, -0.08700697f, -0.15537599f, -0.01376365f, 
    0.08088893f, 0.00943943f, -0.07253877f, -0.09163375f, -0.01012204f, 0.08360896f, -0.06806171f, -0.31367657f, 
    0.00119797f, 0.00650036f, -0.09854491f, 0.10944457f, -0.07745509f, 0.03775202f, 0.06508175f, 0.00820277f, 
    -0.06827046f, -0.03511415f, 0.00351604f, -0.07548850f, -0.04204406f, -0.03203061f, -0.00169542f, 0.01423422f, 
    -0.04093020f, 0.11697645f, -0.06009258f, 0.10811738f, -0.08892732f, -0.29125294f, -0.11651555f, -0.13592348f, 
    0.17651515f, -0.11678945f, 0.05068372f, -0.00684162f, 0.08401164f, -0.03417796f, -0.01646616f, -0.04460325f, 
    -0.04923352f, -0.01486991f, 0.01665086f, -0.06259043f, 0.02134588f, 0.10801606f, -0.04479550f, 0.03512537f, 
    0.14750181f, -0.24093869f, 0.05686185f, -0.19430657f, 0.04961461f, -0.01240529f, -0.03678443f, 0.08645515f, 
    -0.08227297f, 0.00694666f, -0.01968035f, -0.08311331f, 0.10490326f, 0.06055218f, 0.04264287f, -0.01490185f, 
    0.01418402f, -0.03870766f, 0.01092051f, 0.01016175f, 0.30860278f, -0.46800560f, -0.02099665f, -0.02407452f, 
    -0.01306113f, 0.00246966f, 0.03081578f, -0.05319181f, -0.01435078f, 0.00885380f, -0.03576818f, -0.03024419f, 
    0.09689865f, 0.04573839f, 0.00135189f, -0.01539183f, -0.01055082f, -0.03174434f, -0.11421622f, 0.03212475f, 
    -0.11770382f, 0.05757537f, -0.10915259f, 0.04660112f, -0.05128150f, 0.09171036f, 0.11243195f, -0.10483283f, 
    -0.01912517f, 0.03353868f, -0.04734784f, 0.02313865f, -0.03276459f, 0.01892667f, -0.15520754f, 0.02417844f, 
    0.07070676f, 0.07432829f, -0.02184524f, 0.01888336f, 0.09501816f, -0.09717275f, -0.17073092f, -0.13431925f, 
    0.22278321f, -0.09313125f, -0.03960652f, -0.07324843f, -0.06143688f, -0.03845827f, -0.06325854f, -0.03809130f, 
    -0.18848664f, -0.03675650f, -0.03079008f, -0.01874346f, 0.09960631f, 0.03762106f, 0.09574218f, -0.00060096f, 
    0.06061837f, -0.12337921f, 0.00672049f, -0.24923879f, 0.15486526f, -0.04912980f, -0.00083038f, -0.05560201f, 
    -0.12808979f, -0.15897721f, 0.01308945f, -0.01274695f, -0.04891101f, 0.09025454f, 0.02081088f, 0.08229056f, 
    0.05333560f, -0.00554805f, 0.04898775f, 0.02509269f, -0.06842991f, 0.18069673f, 0.20605977f, 0.11232278f, 
    0.05447544f, -0.02698692f, -0.10391769f, 0.04707826f, -0.06072313f, -0.04924629f, -0.01116432f, 0.05206099f, 
    0.08684716f, 0.12445604f, -0.04436545f, 0.05894035f, -0.02553087f, 0.03014520f, 0.03275533f, 0.02275511f, 
    -0.11816285f, -0.32540774f, -0.06642754f, -0.23676957f, 0.39470339f, 0.06913103f, 0.05960415f, 0.07742417f, 
    -0.01436754f, -0.04538430f, -0.02486951f, -0.09053414f, 0.01530323f, 0.09199171f, -0.14047456f, 0.09990849f, 
    0.03996671f, 0.10162856f, 0.05497020f, 0.04495491f, 0.05325852f, -0.04509075f, -0.04303837f, -0.07957929f, 
    0.01955692f, -0.02704765f, 0.00905264f, 0.01447799f, -0.00039084f, -0.06277460f, -0.02812782f, 0.00995105f, 
    -0.12019875f, 0.00740846f, 0.14335720f, -0.09456882f, -0.04475672f, 0.07579261f, -0.06374552f, 0.08655219f, 
    0.10982639f, 0.13267653f, 0.02318531f, 0.10347984f, -0.16973501f, 0.01287079f, 0.06398216f, 0.01033012f, 
    0.00320326f, -0.04484994f, -0.03908763f, 0.05730751f, 0.03006605f, -0.03665189f, -0.00813925f, 0.02099566f, 
    -0.07567287f, 0.03879795f, -0.07454579f, -0.06768701f, -0.14150949f, -0.14261009f, -0.06856678f, 0.04648778f, 
    -0.07514022f, -0.00043361f, -0.01359983f, -0.00043233f, 0.04659140f, 0.01631188f, 0.00322643f, -0.01369666f, 
    0.04377557f, 0.02620553f, 0.12737614f, 0.00745264f, 0.00155151f, -0.11536434f, -0.04747756f, -0.10589240f, 
    0.06282102f, 0.17119789f, -0.02414519f, -0.17812340f, 0.06391513f, -0.02353458f, -0.08097753f, 0.04690144f, 
    0.02179192f, 0.15609312f, 0.02116244f, 0.04783819f, -0.05307919f, -0.03206690f, 0.02051300f, -0.02140481f, 
    -0.00982558f, -0.09131985f, 0.06181641f, 0.03037168f, -0.41167915f, 0.06027518f, 0.15016617f, 0.05567970f, 
    -0.01762125f, 0.06307849f, -0.05653871f, 0.12447330f, -0.05873168f, -0.07588589f, -0.01288623f, 0.03432992f, 
    -0.08970591f, -0.02443426f, 0.00500395f, 0.01469050f, -0.00127924f, 0.00690765f, 0.11690404f, 0.02212219f, 
    0.18171290f, -0.06697190f, 0.04490045f, -0.00131656f, 0.05767101f, 0.00243369f, -0.05829917f, 0.01569523f, 
    -0.02964096f, 0.00464909f, 0.02821139f, -0.03517018f, 0.03541273f, -0.00225741f, -0.07768765f, 0.00864994f, 
    -0.02986420f, -0.00021279f, -0.10651579f, -0.01817057f, 0.08687073f, -0.21435748f, -0.04597918f, 0.02287227f, 
    -0.07129972f, -0.11774074f, -0.02191974f, -0.03376826f, 0.05149153f, 0.02562476f, -0.04027085f, 0.03656196f, 
    -0.05533900f, 0.00909536f, 0.10365117f, -0.12765490f, -0.04228532f, -0.03164990f, -0.05509795f, -0.08495997f, 
    -0.04851164f, 0.03588784f, -0.09576893f, -0.26601928f, 0.11810716f, 0.01254908f, -0.05473281f, 0.02243975f, 
    -0.04349588f, -0.06071972f, 0.03344471f, -0.02865627f, -0.00616112f, -0.03507983f, -0.03064656f, 0.10920612f, 
    0.00873476f, -0.00759529f, 0.07148349f, 0.04225618f, 0.02156390f, 0.13022466f, -0.11962339f, 0.17503881f, 
    -0.04018786f, -0.05909841f, 0.19725575f, 0.06771845f, 0.06537915f, -0.06520148f, 0.05168825f, -0.00238303f, 
    0.00769971f, 0.00776269f, -0.06324683f, 0.02180577f, 0.02852938f, 0.08018091f, -0.08042207f, 0.05260760f, 
    -0.04966395f, -0.02423619f, -0.09830499f, 0.09018311f, 0.05799355f, 0.11039953f, 0.07475305f, 0.04258827f, 
    -0.02623607f, 0.06108656f, 0.03880113f, -0.04256060f, -0.00993952f, -0.02139381f, -0.15565705f, 0.03580720f, 
    0.04625176f, -0.09562616f, 0.01959318f, 0.00513408f, 0.12169932f, -0.37143406f, -0.05047996f, -0.17180271f, 
    -0.00613903f, -0.01129370f, 0.06857632f, -0.05449558f, 0.06705721f, 0.02544362f, -0.03383305f, 0.03689998f, 
    0.01313027f, 0.11185165f, 0.03228116f, -0.08253104f, 0.02808090f, -0.05824824f, -0.09359752f, 0.02226983f, 
    -0.06487552f, 0.08820912f, -0.03692976f, -0.00832712f, 0.22106974f, -0.05862993f, -0.03689025f, 0.00784449f, 
    0.03309032f, -0.00851187f, -0.08151424f, 0.03670161f, -0.01614491f, -0.01872252f, 0.13570304f, 0.00774710f, 
    -0.07865895f, -0.00725134f, 0.03882579f, 0.07107904f, -0.15284790f, 0.06949934f, 0.02929484f, -0.02822409f, 
    -0.20696434f, 0.02115394f, 0.13896863f, 0.01063006f, -0.00883757f, 0.08198728f, -0.11875482f, -0.09396416f, 
    0.08158243f, 0.07807867f, 0.00157774f, 0.06826663f, 0.04247193f, 0.03950742f, 0.02108280f, -0.07225581f, 
    -0.02372198f, 0.00574866f, 0.17570603f, 0.00170001f, -0.19337894f, 0.16035475f, 0.02089104f, 0.10449021f, 
    0.00095980f, -0.03915651f, -0.10572162f, -0.05027851f, -0.04375854f, 0.07425400f, 0.00267367f, 0.03224903f, 
    0.01960319f, -0.06263825f, 0.03694251f, -0.05157994f, -0.01881218f, 0.03093121f, 0.12089645f, 0.08028942f, 
    0.00153312f, 0.09164771f, 0.00557374f, 0.02355090f, -0.04282811f, -0.06823491f, -0.00498411f, -0.05503696f, 
    0.12756124f, -0.04974396f, -0.00320848f, -0.05836086f, 0.10859947f, 0.06668942f, 0.07782556f, -0.05891480f, 
    0.02608185f, 0.05724833f, 0.12572968f, -0.00761788f, -0.08083647f, 0.09684522f, -0.08662796f, 0.06870120f, 
    -0.05483436f, 0.00914684f, 0.02366551f, -0.00691526f, 0.01816318f, -0.00613570f, -0.07688317f, -0.01919903f, 
    -0.02992306f, -0.06525449f, 0.02374686f, -0.05333189f, -0.30234668f, 0.26545995f, 0.09101664f, 0.06401369f, 
    -0.33494273f, 0.04529364f, -0.04183359f, 0.02569253f, 0.01446761f, 0.02883074f, 0.05712024f, 0.06875998f, 
    -0.05074299f, -0.01437146f, -0.01954625f, 0.01240731f, -0.05144186f, -0.12095767f, -0.00355556f, 0.02348718f, 
    -0.30559483f, 0.16376624f, 0.01313272f, 0.14577326f, -0.13516311f, -0.09662437f, -0.10275857f, -0.00971972f, 
    0.01779499f, 0.04804897f, 0.02238568f, 0.03612298f, 0.02878663f, -0.02038506f, -0.01949449f, -0.06457508f, 
    -0.07948117f, -0.05840438f, -0.10760919f, -0.05536734f, -0.04078894f, 0.11717334f, -0.08005063f, -0.10648175f, 
    -0.09315176f, 0.01026309f, 0.06853923f, 0.00266907f, -0.07660138f, 0.07623901f, -0.01854616f, -0.01713247f, 
    -0.03470175f, -0.07517699f, -0.10467498f, 0.08348233f, -0.03653146f, 0.04020391f, 0.08867580f, 0.09940946f, 
    0.21663363f, -0.07634030f, -0.06902674f, 0.06565427f, 0.46305326f, -0.00923509f, -0.06502457f, 0.01839455f, 
    -0.01679819f, -0.04438299f, -0.13134217f, 0.04682333f, 0.00208050f, -0.01578486f, 0.05067199f, -0.01708662f, 
    -0.13561666f, 0.04876353f, -0.01215992f, 0.12129474f, -0.21291959f, 0.28086567f, 0.00594186f, 0.16806062f, 
    -0.01124710f, 0.00841961f, -0.06781311f, -0.01005363f, 0.04756206f, -0.05247127f, 0.02036425f, 0.00993243f, 
    0.07414721f, 0.01071349f, -0.05995027f, -0.00467869f, 0.05908149f, -0.05251820f, -0.04584589f, 0.00000319f, 
    0.05488004f, -0.06540272f, -0.23624018f, -0.15552284f, 0.19688767f, -0.03564533f, 0.01747968f, -0.00007221f, 
    0.06812974f, -0.04123910f, -0.01732579f, 0.01299957f, 0.01579191f, -0.05997514f, -0.02865907f, 0.00053569f, 
    -0.07340991f, 0.08161934f, -0.12117042f, 0.06269994f, -0.06187551f, -0.06271920f, -0.07765743f, -0.12336373f, 
    0.00014689f, -0.04781420f, 0.11747084f, 0.02659751f, -0.08917031f, 0.01673653f, -0.10185614f, -0.04073695f, 
    0.05891347f, 0.00573812f, -0.06181017f, 0.04540465f, -0.05149646f, 0.13396066f, 0.11582956f, -0.01240071f, 
    0.16491568f, -0.08832696f, 0.03464707f, 0.01249223f, -0.15397738f, 0.01817080f, 0.02008764f, 0.05350729f, 
    0.03027624f, 0.00928869f, -0.08025271f, 0.01217929f, -0.10082190f, 0.00918960f, -0.05037442f, 0.01787250f, 
    0.01907255f, 0.07189738f, -0.05199456f, 0.04277310f, 0.02830215f, -0.18045668f, -0.00988480f, -0.13120133f, 
    0.07324366f, -0.00786511f, 0.02426500f, -0.03221079f, 0.03972128f, -0.03119466f, -0.03818976f, 0.00850195f, 
    0.05109679f, 0.07622071f, 0.02268145f, -0.01690152f, 0.00499607f, 0.00530178f, -0.02419575f, 0.05504080f, 
    0.28743920f, -0.50174451f, -0.10603140f, 0.17230837f, 0.04235782f, 0.04507796f, 0.11295932f, 0.01621240f, 
    -0.13300334f, 0.04269068f, 0.01359762f, 0.06221649f, 0.00105156f, -0.00792472f, 0.04886178f, 0.00127020f, 
    0.03526732f, 0.03685500f, -0.09281278f, 0.03742422f, 0.14256078f, 0.00984402f, 0.11054847f, -0.02139947f, 
    0.07936917f, 0.02616206f, 0.02743314f, 0.01131864f, 0.03351177f, -0.04738732f, -0.04423570f, -0.01649857f, 
    0.00999885f, -0.01187700f, 0.01380923f, -0.01596836f, -0.03183310f, -0.06273714f, 0.07330597f, -0.09920678f, 
    0.28131768f, -0.30509865f, -0.10684095f, 0.15004174f, -0.00704094f, -0.10421063f, 0.01491611f, -0.00689474f, 
    0.02289995f, -0.01075636f, -0.02068405f, 0.03704944f, -0.01830908f, -0.04918449f, 0.07657146f, 0.02782875f, 
    -0.00369976f, -0.05555320f, -0.08041829f, -0.08110320f, 0.20063263f, -0.12040896f, -0.02645092f, 0.04442507f, 
    0.02206704f, -0.04568851f, 0.02318944f, -0.00625062f, 0.08096113f, 0.04420440f, 0.01556791f, -0.05438461f, 
    0.02431016f, 0.00445485f, -0.07697992f, 0.06988849f, 0.04728525f, -0.05859913f, -0.10684284f, 0.07438010f, 
    -0.21120103f, -0.03714119f, -0.08943561f, 0.18013877f, 0.00306755f, -0.02694860f, -0.03958268f, -0.00338823f, 
    -0.00074123f, 0.01818923f, -0.01391555f, -0.02119511f, 0.03865279f, 0.07489263f, -0.05476608f, -0.02225488f, 
    -0.06107435f, -0.07539283f, -0.09406372f, -0.02812423f, -0.14299995f, -0.16789229f, 0.06172235f, -0.00920983f, 
    0.12438746f, 0.01945009f, 0.07196892f, 0.08373884f, -0.07633752f, 0.02328486f, -0.06479997f, -0.03008382f, 
    -0.05615657f, 0.03490845f, 0.05536503f, -0.03872989f, -0.02236701f, 0.03122669f, 0.10638508f, -0.08863956f, 
    0.00340364f, -0.18728699f, -0.09019174f, 0.07535456f, 0.00041897f, -0.07651461f, 0.02184120f, -0.03802833f, 
    0.05769348f, 0.01499474f, -0.06791430f, 0.03724249f, -0.06100230f, 0.09176905f, 0.03435925f, -0.02264051f, 
    0.01729648f, 0.02586489f, -0.11427608f, 0.00152632f, -0.33863634f, 0.03270233f, -0.03326362f, -0.24623078f, 
    0.16718766f, -0.07657420f, -0.02910383f, 0.08085648f, -0.10336688f, 0.00863421f, -0.01301740f, -0.07947120f, 
    -0.00265338f, -0.00062694f, -0.07837978f, 0.03336444f, 0.03103526f, -0.01010260f, 0.13194574f, 0.02273053f, 
    -0.02034044f, 0.07458833f, -0.10629477f, -0.29902616f, 0.05352379f, -0.01938523f, -0.04320888f, -0.04284192f, 
    -0.03142544f, -0.04379516f, -0.02595015f, 0.02836647f, -0.03400764f, -0.05890225f, -0.04077411f, -0.06168301f, 
    -0.06477444f, 0.06644911f, -0.07344689f, 0.10960739f, 0.13168375f, -0.02492099f, 0.02596823f, 0.11471808f, 
    0.12824415f, -0.03186582f, 0.02491227f, -0.03489997f, -0.05212078f, -0.14359704f, 0.04656865f, 0.00195819f, 
    -0.05981553f, 0.02566357f, 0.05405517f, -0.01489907f, 0.00576439f, 0.00986999f, -0.07208052f, 0.08015098f, 
    0.14666335f, -0.18059933f, -0.06540858f, -0.23207745f, 0.08028312f, -0.06017016f, 0.04612093f, -0.12084338f, 
    -0.00803913f, -0.08501335f, -0.00716584f, 0.00322953f, 0.05281191f, 0.08327620f, -0.00921151f, 0.08130755f, 
    -0.00621988f, -0.04017782f, -0.03660670f, 0.10153809f, -0.04772310f, -0.09640782f, 0.14602534f, -0.09384385f, 
    0.16737576f, -0.02764916f, -0.09074634f, -0.02145199f, 0.01952369f, -0.06193571f, 0.02219289f, -0.01073105f, 
    0.03268379f, 0.00914015f, -0.06724584f, -0.04161584f, -0.00267546f, 0.05218216f, -0.01320945f, -0.08649860f, 
    0.07900213f, -0.06019836f, -0.13858016f, 0.07817601f, 0.00194385f, 0.03502578f, -0.02504657f, 0.02157327f, 
    0.00585421f, 0.10015465f, 0.06192126f, -0.02200960f, 0.00202663f, 0.03646097f, 0.05789501f, 0.07526016f, 
    -0.07472634f, 0.03184736f, -0.05722991f, -0.08500194f, 0.18507685f, 0.04252907f, 0.12844005f, -0.03273688f, 
    -0.07940403f, -0.00667651f, -0.01776343f, 0.02001082f, 0.00932108f, -0.02852575f, 0.04827242f, -0.02637284f, 
    -0.05563293f, 0.01306427f, 0.00197586f, 0.02252685f, -0.06949852f, 0.02196063f, 0.04866062f, -0.01563197f, 
    0.09749485f, -0.13870643f, 0.03190632f, 0.03369989f, 0.07391403f, -0.02452443f, -0.00796402f, 0.02684412f, 
    -0.00672720f, 0.02256441f, -0.04226188f, 0.01110727f, -0.00331738f, 0.01857396f, -0.11013300f, 0.09103845f, 
    -0.01378125f, 0.09544615f, 0.06650339f, -0.01940984f, -0.05323063f, 0.14840442f, -0.08815284f, -0.01027445f, 
    -0.21241643f, 0.05526110f, -0.07223317f, 0.03770583f, 0.06751742f, -0.01236464f, 0.03541635f, 0.10263430f, 
    -0.00328455f, -0.01899196f, -0.04195125f, 0.01531357f, -0.02115473f, 0.01936347f, -0.00979822f, -0.09979510f, 
    -0.14743245f, -0.33437270f, -0.03515046f, -0.32386586f, 0.02745607f, -0.01379018f, -0.04914283f, -0.03119782f, 
    -0.09298683f, -0.01780065f, -0.07421679f, 0.05399204f, 0.01171553f, 0.14352056f, -0.02470745f, 0.01509498f, 
    -0.00244769f, -0.06498190f, 0.03381540f, 0.00443682f, 0.03444539f, -0.01196375f, -0.09373015f, -0.07787952f, 
    0.02835336f, 0.04769612f, 0.05857415f, 0.01069083f, -0.09565305f, -0.06302079f, -0.05689818f, 0.02698902f, 
    0.02705066f, -0.02241707f, -0.13228132f, -0.03906419f, -0.08713302f, 0.09796100f, 0.03486338f, 0.00445898f, 
    -0.00174648f, 0.02109119f, -0.05549532f, -0.04921351f, 0.08804720f, 0.02052031f, 0.00093380f, 0.05826463f, 
    -0.02493681f, -0.04475730f, 0.02302102f, -0.08229264f, 0.06136995f, -0.07135704f, 0.03203821f, 0.00591593f, 
    0.01250669f, 0.05071866f, 0.09894539f, 0.03022854f, -0.17928530f, 0.21141934f, 0.03977462f, 0.11281463f, 
    -0.08568150f, 0.05295433f, -0.00852839f, 0.08207649f, 0.05080012f, -0.00089826f, 0.00454860f, 0.03259867f, 
    0.01664800f, -0.04609226f, -0.01957849f, -0.01596278f, 0.00281450f, -0.09065903f, -0.00775672f, 0.01803317f, 
    -0.10416505f, 0.00570476f, -0.15880275f, 0.12029945f, -0.11410008f, 0.07237614f, 0.05272182f, -0.04886753f, 
    -0.04224870f, 0.08704140f, -0.00582605f, -0.00758583f, -0.04789258f, 0.00341687f, -0.00613828f, 0.00229854f, 
    -0.02057169f, 0.21218693f, 0.03134460f, 0.05778651f, 0.07151393f, -0.09525890f, 0.01599225f, -0.22690643f, 
    0.03956613f, -0.05961428f, 0.05712491f, -0.07680744f, 0.02763012f, -0.06509815f, 0.06124199f, 0.00361529f, 
    0.01392770f, 0.04660832f, 0.04395846f, 0.03518585f, -0.06211071f, -0.01599716f, 0.01602205f, 0.07964398f, 
    -0.20916137f, 0.18476270f, -0.06965590f, -0.05722016f, -0.00781863f, 0.03684990f, 0.00198203f, -0.02872795f, 
    -0.00101575f, 0.00294970f, 0.00063761f, 0.05996767f, -0.00251428f, -0.02979391f, 0.01094804f, 0.01545404f, 
    -0.01541996f, 0.03731751f, -0.05200801f, -0.03691875f, 0.12400280f, -0.04092140f, 0.07181958f, 0.04372151f, 
    0.17007253f, -0.02492066f, 0.00146406f, -0.00270212f, -0.01007530f, -0.00388129f, -0.02881120f, 0.03847856f, 
    -0.01694177f, 0.01989711f, -0.00304112f, 0.00792116f, 0.01893158f, 0.01258041f, -0.01828591f, -0.01937175f, 
    -0.08566711f, 0.07223672f, 0.11606152f, 0.04723110f, -0.04622355f, 0.06470878f, -0.01300898f, -0.01546519f, 
    0.05383909f, 0.00226850f, -0.03218051f, -0.01477694f, 0.01933955f, -0.02132640f, -0.05702030f, -0.00285562f, 
    0.01318737f, -0.00466054f, -0.01521177f, -0.04542129f, -0.12066718f, -0.00062941f, 0.05294467f, -0.03771602f, 
    0.04658300f, -0.03301568f, -0.01421163f, -0.02448587f, 0.00910836f, -0.02281072f, -0.01147428f, 0.01162831f, 
    -0.02741420f, -0.02521862f, -0.00817411f, 0.02995124f, 0.00267218f, 0.01133584f, 0.01137987f, 0.02006131f, 
    -0.09257881f, -0.16328996f, -0.05147089f, -0.01840340f, 0.00590126f, 0.01243037f, -0.10866866f, -0.02947161f, 
    0.01334882f, -0.01812962f, -0.10485326f, 0.02340537f, -0.04798677f, -0.01577506f, -0.05699118f, -0.01438030f, 
    -0.02411906f, -0.01390910f, 0.02492472f, -0.03148090f, -0.07734562f, 0.05861885f, -0.01331382f, 0.01131254f, 
    -0.03828827f, 0.06192381f, -0.03603288f, -0.03721029f, -0.01448184f, -0.01818819f, -0.04751289f, 0.00076066f, 
    -0.01759529f, 0.02122404f, -0.07239471f, 0.01186067f, -0.01511922f, 0.00165255f, -0.05856491f, 0.07150616f, 
    0.17736489f, -0.09962782f, 0.19904964f, -0.01746132f, 0.04172922f, 0.03287078f, 0.00354102f, -0.01751155f, 
    -0.01727901f, -0.01052325f, -0.02105070f, 0.05989846f, -0.00962784f, -0.01092990f, -0.04573318f, -0.03802404f, 
    -0.02181774f, -0.03821403f, 0.02900047f, -0.01684521f, -0.01092131f, -0.13200103f, 0.06825335f, -0.00238782f, 
    -0.10574712f, 0.03742055f, 0.00150838f, -0.02904056f, 0.05699321f, -0.05677278f, 0.03044264f, 0.02406947f, 
    0.05230793f, -0.02000948f, -0.02556237f, -0.03919900f, 0.07738922f, 0.00877407f, -0.07015763f, -0.00008238f, 
    -0.06733393f, 0.08896595f, -0.16097809f, 0.00856987f, 0.07447883f, -0.03047840f, -0.06557029f, -0.09133060f, 
    0.05341912f, -0.01157386f, -0.09850813f, 0.04277487f, -0.00461728f, -0.05517920f, 0.01673336f, 0.02852243f, 
    0.00533120f, 0.01055571f, -0.00413829f, -0.00645313f, -0.04550940f, 0.10133597f, -0.11523685f, 0.00662038f, 
    0.10978597f, -0.11263146f, 0.03163179f, -0.02900797f, 0.00228506f, 0.03043876f, 0.00489030f, 0.06176792f, 
    -0.13133343f, -0.04557306f, -0.05001936f, -0.03183375f, 0.03818123f, 0.06140456f, -0.05606824f, -0.01142148f, 
    0.21869083f, -0.05793143f, 0.15649311f, -0.03511655f, 0.07972824f, -0.04844042f, 0.03058508f, -0.05321776f, 
    -0.03997487f, -0.02026817f, -0.02927333f, 0.04097593f, -0.03809765f, -0.02717605f, -0.04494317f, -0.06849530f, 
    -0.02948316f, -0.06540608f, 0.01822846f, -0.04673449f, 0.05234994f, 0.00191519f, 0.14926022f, 0.05182253f, 
    0.20711999f, 0.05365000f, 0.11436135f, 0.00420791f, -0.03290685f, -0.03006732f, -0.02435139f, 0.02659579f, 
    -0.04832295f, 0.00240840f, 0.01572269f, -0.05544142f, 0.05089899f, 0.02848898f, 0.01880384f, -0.01779657f, 
    -0.06701829f, 0.13178201f, -0.13793644f, -0.02532389f, 0.06064402f, -0.05970107f, -0.00265274f, -0.11832154f, 
    0.01119677f, -0.03150944f, -0.00360757f, 0.05756683f, 0.00519392f, 0.01176381f, -0.00882864f, -0.02584944f, 
    -0.02370141f, 0.05005112f, -0.04025740f, 0.00715763f, 0.05936012f, -0.02262259f, 0.11383399f, 0.01945265f, 
    0.08518066f, 0.04617116f, -0.06210054f, -0.02060259f, -0.00143208f, 0.00227391f, -0.00205402f, 0.00029848f, 
    0.02823000f, -0.05915894f, 0.02730975f, 0.02292231f, -0.05040743f, 0.03265049f, 0.09719139f, 0.01040543f, 
    -0.00472441f, 0.09541879f, 0.16251482f, -0.02486207f, 0.15943965f, -0.00504112f, 0.07528070f, 0.04266661f, 
    0.01391294f, 0.00737016f, -0.03340804f, 0.03013538f, -0.05845234f, -0.02476007f, -0.00276005f, -0.03004870f, 
    0.06294725f, 0.03486421f, 0.01150011f, -0.04154960f, -0.11719921f, 0.08937462f, 0.12089383f, 0.02790944f, 
    -0.00957268f, 0.11924358f, -0.07354978f, -0.00014232f, 0.01004334f, 0.03104598f, -0.00937702f, -0.00909824f, 
    0.01706248f, -0.02322332f, -0.04370526f, 0.02659721f, -0.01743335f, -0.02747767f, -0.04314002f, -0.01403979f, 
    -0.00029380f, 0.15018623f, 0.04935406f, 0.02912311f, 0.05657942f, -0.09469292f, 0.12585962f, -0.06271433f, 
    -0.00220831f, 0.05718944f, -0.12487572f, 0.02477578f, -0.05356571f, -0.03055777f, -0.01782645f, -0.00095686f, 
    0.01041089f, 0.07794736f, -0.03842272f, 0.01415108f, -0.04455290f, 0.12974465f, 0.03169854f, 0.12277696f, 
    0.11449575f, -0.00313133f, 0.00787024f, -0.10453678f, -0.01010639f, 0.03066771f, -0.00214463f, 0.04478804f, 
    0.01985369f, -0.05336956f, -0.04164011f, 0.08659811f, -0.06941920f, -0.00948532f, 0.04351380f, -0.02502267f, 
    -0.21785817f, 0.06135598f, -0.13985683f, -0.05732219f, -0.05355703f, -0.04325728f, -0.05743451f, -0.07728276f, 
    0.00581545f, -0.03007898f, -0.03658926f, 0.01560175f, 0.02024050f, -0.01136613f, -0.09202545f, 0.00090257f, 
    0.02435887f, 0.00366403f, -0.01716165f, 0.02315240f, -0.04935238f, -0.17517807f, -0.01317406f, -0.09988660f, 
    -0.15240788f, -0.04088787f, -0.03951097f, -0.03261983f, -0.04068559f, -0.02528702f, 0.04694922f, -0.00008428f, 
    -0.01819576f, -0.00740171f, -0.06485694f, -0.05359816f, -0.03865229f, 0.00293623f, -0.02597643f, -0.01273648f, 
    0.00958810f, 0.07046318f, -0.05594971f, 0.03614166f, -0.05572900f, 0.03106046f, -0.11231042f, -0.01781621f, 
    -0.02650309f, -0.04185326f, -0.00904523f, 0.06547605f, -0.06461404f, -0.02602619f, -0.07457176f, 0.02556214f, 
    0.04426761f, -0.01346990f, -0.00267637f, 0.00037814f, 0.11419926f, -0.14907034f, 0.08383352f, -0.00522982f, 
    -0.07811978f, 0.11517956f, -0.02447028f, -0.01841487f, -0.00409469f, 0.04674065f, -0.03530559f, -0.00124054f, 
    0.01939969f, 0.00043552f, -0.06314396f, -0.06361453f, -0.02569092f, -0.02402818f, 0.00915824f, -0.04139811f, 
    0.09177512f, -0.05429611f, -0.01462531f, 0.07141747f, -0.08931934f, 0.05857599f, 0.00295208f, 0.03494467f, 
    -0.04214701f, 0.01350284f, -0.00090900f, -0.07485070f, -0.06747636f, -0.04143536f, 0.01208603f, 0.02839242f, 
    0.03882932f, 0.00110756f, -0.00137578f, -0.00478095f, 0.03327966f, -0.10349786f, 0.07767040f, 0.01314794f, 
    -0.03124863f, 0.04699957f, -0.09188220f, 0.04541245f, 0.00852264f, -0.03483865f, 0.04579093f, 0.03292042f, 
    0.02816672f, 0.03369034f, -0.04832125f, -0.01722530f, 0.02843428f, 0.03739475f, 0.01095484f, -0.06482770f, 
    0.12899357f, 0.04858339f, 0.13219899f, 0.04361000f, 0.11116081f, 0.03826419f, 0.04157402f, -0.03419974f, 
    -0.00645375f, -0.03783553f, 0.00852143f, -0.04022248f, -0.02345692f, -0.02483583f, -0.01039028f, -0.01514539f, 
    0.01563295f, -0.00100719f, 0.03840801f, -0.01886627f, -0.08008619f, 0.15128809f, -0.13812916f, 0.09329780f, 
    0.13840467f, -0.03114618f, -0.15442677f, -0.00217365f, 0.06350795f, -0.02576947f, -0.07210031f, 0.04486408f, 
    0.03198623f, 0.00387776f, -0.06199056f, 0.03603755f, 0.01230091f, 0.03899212f, 0.04272252f, 0.00923209f, 
    0.00009894f, 0.18752100f, 0.04077834f, -0.01824955f, 0.11042538f, 0.03981098f, 0.14016666f, -0.06804748f, 
    0.01629467f, -0.01500130f, -0.06774148f, 0.00650446f, 0.01621082f, -0.00777097f, -0.03670322f, 0.02402608f, 
    -0.01998949f, 0.03091900f, -0.02351206f, 0.01210140f, -0.07379196f, 0.07521164f, 0.16269840f, 0.06105081f, 
    0.07676673f, 0.05080253f, 0.03557655f, 0.04530619f, 0.00915805f, -0.04409333f, -0.07147023f, 0.05217382f, 
    0.04433653f, -0.03199804f, -0.01729411f, -0.03410954f, 0.03557339f, 0.01856851f, 0.03257509f, -0.05154222f, 
    -0.00753604f, -0.11961377f, -0.15276802f, -0.02780005f, 0.06299241f, 0.01976739f, -0.02012478f, -0.05564714f, 
    0.01522072f, -0.07363984f, -0.04951917f, -0.01800695f, -0.05358221f, 0.01874007f, -0.03216163f, -0.02153022f, 
    -0.10002447f, -0.05329937f, -0.03803049f, 0.01614027f, 0.04177787f, 0.10346611f, -0.18699835f, 0.02579846f, 
    0.13035028f, -0.11228205f, -0.02534865f, 0.01144631f, 0.00967963f, 0.01425899f, -0.12391923f, -0.01672276f, 
    0.04053629f, 0.00694850f, 0.01588009f, -0.04082165f, 0.01853062f, -0.01405074f, -0.03117102f, 0.01842289f, 
    0.17065024f, -0.36812025f, 0.06311961f, -0.12770614f, -0.11805239f, -0.00408583f, -0.03939022f, -0.01540428f, 
    0.02141926f, -0.02537192f, -0.01994809f, 0.03716006f, -0.06604448f, 0.00853527f, 0.01156660f, -0.03764004f, 
    0.04771269f, -0.05227597f, 0.00757077f, -0.05179357f, 0.12894858f, 0.03781642f, 0.10478774f, -0.01743432f, 
    0.00221956f, -0.04088835f, -0.02532873f, -0.02303665f, -0.02019689f, 0.00172782f, 0.02200371f, -0.05206200f, 
    0.00340403f, -0.03494971f, -0.04468416f, -0.06538054f, 0.05529884f, -0.00707272f, 0.04119189f, -0.02199906f, 
    0.08362589f, -0.33880743f, 0.02348626f, -0.07060816f, -0.17021172f, 0.02782037f, -0.01757184f, -0.01930523f, 
    -0.05910122f, -0.03680745f, -0.02631564f, -0.06244431f, -0.09800849f, -0.00511141f, -0.08721127f, -0.06088642f, 
    0.06082045f, -0.00330389f, 0.02326480f, -0.02909434f, -0.09414998f, -0.24042656f, -0.14891824f, -0.11498575f, 
    -0.02701508f, -0.03626905f, -0.08914424f, -0.04032931f, -0.03082285f, -0.07229111f, -0.09344601f, 0.01883132f, 
    -0.01731909f, -0.01699587f, 0.02108011f, 0.00363151f, -0.03106904f, -0.04113667f, -0.02745799f, 0.03665992f, 
    -0.13041823f, -0.08994983f, -0.09109874f, -0.13977350f, -0.13136467f, -0.02584139f, -0.06448010f, -0.00505381f, 
    -0.02722096f, -0.06778893f, -0.04632559f, -0.02997212f, -0.03884016f, -0.02867329f, -0.02583537f, -0.01665750f, 
    -0.02440461f, -0.02522085f, -0.00906534f, -0.02530430f, 0.00310094f, 0.00662767f, -0.12853532f, -0.06559615f, 
    0.06703020f, -0.03285814f, -0.11620302f, -0.08559509f, -0.08077994f, -0.02526210f, -0.06265047f, 0.05071732f, 
    -0.02355722f, -0.04938563f, -0.04499358f, -0.03843271f, 0.01484434f, -0.02593102f, -0.03614170f, 0.02887793f, 
    -0.06399167f, -0.01124675f, -0.23170246f, -0.00548125f, 0.13507272f, -0.09372164f, -0.06621520f, -0.07559536f, 
    0.04411877f, -0.03328096f, -0.05937350f, 0.00708121f, -0.12041625f, 0.06326565f, -0.02224238f, -0.00111968f, 
    -0.09561432f, 0.02269871f, -0.06907706f, -0.00910283f, -0.20601892f, -0.02076376f, -0.15000752f, -0.14521177f, 
    -0.18791057f, 0.06961378f, -0.04306687f, -0.01076034f, -0.00121611f, -0.06458793f, -0.01373781f, -0.05859427f, 
    -0.02346882f, -0.02428778f, -0.02907004f, -0.01464899f, 0.07430238f, -0.03228467f, 0.02925876f, 0.04899844f, 
    -0.20373347f, 0.11167426f, 0.01276227f, 0.04370197f, 0.03258073f, -0.12997477f, 0.06765452f, -0.03374620f, 
    -0.04123693f, 0.01552042f, 0.02508346f, 0.05008188f, -0.08837824f, 0.00073816f, -0.03615904f, -0.03016382f, 
    -0.03404425f, -0.02724302f, -0.00196499f, 0.02287168f, 0.03272513f, -0.07442719f, 0.10929923f, 0.04268564f, 
    0.07591357f, 0.05104321f, -0.01653271f, -0.00726571f, 0.00854440f, -0.01505312f, -0.01425899f, -0.04253184f, 
    -0.05758652f, -0.01286746f, 0.00161839f, -0.01042028f, -0.02760659f, -0.01350121f, -0.01772791f, -0.05266302f, 
    -0.05929649f, 0.00150164f, -0.02735629f, 0.04211982f, -0.10289585f, 0.00290873f, -0.06817355f, -0.04534260f, 
    -0.01766768f, -0.00996354f, -0.01905372f, 0.05414411f, -0.04459713f, 0.04671501f, -0.09717543f, 0.03682226f, 
    0.03103999f, 0.00261205f, -0.07656457f, 0.02210153f, 0.02327295f, 0.07786971f, 0.12379109f, 0.02344325f, 
    0.09992933f, 0.05167076f, 0.05464595f, 0.01438698f, 0.00349620f, -0.00471341f, -0.05933199f, 0.01966213f, 
    0.01752746f, -0.01782358f, -0.00383184f, -0.02309889f, 0.00549318f, 0.00845143f, 0.04592576f, -0.02642673f, 
    0.20780341f, -0.07675821f, 0.06995188f, -0.01864850f, 0.00063424f, 0.08927345f, 0.02976997f, -0.00161848f, 
    -0.04507565f, -0.01771635f, 0.00788735f, 0.06594123f, -0.03126949f, 0.00668412f, -0.04212815f, -0.06572674f, 
    0.12789777f, 0.01288200f, -0.00216875f, 0.03242927f, 0.06050557f, 0.11905075f, -0.09489099f, -0.02130894f, 
    0.07070491f, -0.11559847f, -0.06569288f, -0.02203801f, 0.00226829f, -0.03742183f, -0.10341619f, -0.01999555f, 
    0.01781517f, 0.00919852f, 0.00955130f, -0.02928057f, 0.00898937f, -0.02582397f, -0.01522905f, 0.01024351f, 
    0.12003622f, 0.01011267f, 0.04789978f, -0.01682404f, -0.00056233f, 0.03164310f, 0.01843851f, -0.03306678f, 
    -0.02776671f, -0.02837919f, -0.05260213f, -0.05200393f, -0.03863419f, -0.02069008f, -0.00450350f, 0.01097210f, 
    -0.03453061f, -0.00724670f, -0.00132981f, -0.03862571f, -0.04804887f, 0.08434796f, -0.08200924f, 0.01452283f, 
    -0.08960163f, 0.01762344f, -0.00736029f, -0.02053453f, -0.02445712f, 0.00488328f, -0.06858644f, -0.01275150f, 
    0.03132393f, 0.01425547f, -0.02325354f, 0.03762725f, 0.02514016f, -0.00474484f, -0.02522908f, 0.00861363f, 
    -0.18064821f, 0.03072638f, 0.00776615f, -0.11913915f, -0.11361408f, -0.02212690f, 0.00352571f, -0.02920039f, 
    -0.06064341f, -0.01063721f, -0.01237269f, -0.02371937f, -0.01226617f, 0.02143545f, -0.00593395f, 0.01987484f, 
    0.00739595f, -0.03853382f, 0.00916268f, 0.01123782f, -0.01522669f, 0.05648527f, -0.21703051f, 0.04060955f, 
    0.06169398f, -0.04740191f, -0.04441535f, -0.06284451f, 0.00920990f, -0.08828790f, -0.06925008f, 0.00346260f, 
    0.00611094f, -0.06024144f, -0.03128085f, -0.01968853f, -0.08262932f, -0.01305160f, -0.00931618f, -0.02396704f, 
    0.02363320f, 0.03558169f, -0.03037259f, -0.08697806f, -0.03808787f, -0.03815644f, -0.05027801f, 0.00001809f, 
    -0.03519690f, -0.05273698f, 0.09412721f, 0.01502079f, -0.02091169f, 0.03965125f, -0.05011116f, -0.05239432f, 
    -0.02260306f, -0.01201143f, -0.03804048f, -0.03388900f, 0.01884983f, 0.11109287f, 0.17217480f, -0.01563723f, 
    0.09700951f, 0.06411952f, 0.05001608f, -0.04237430f, 0.04397821f, -0.02018568f, -0.03733674f, -0.01148689f, 
    -0.02082436f, -0.04061363f, -0.03978603f, 0.02549256f, 0.00605379f, -0.01512088f, 0.07888677f, -0.03401842f, 
    -0.06116342f, 0.13769840f, 0.14798433f, 0.11264144f, 0.15129323f, 0.04590852f, 0.11367211f, -0.02489334f, 
    -0.03481073f, -0.00105484f, -0.00234078f, 0.01159180f, 0.00921287f, -0.09859695f, -0.02260296f, 0.03676452f, 
    -0.04141351f, -0.00975323f, 0.04479856f, 0.03561698f, -0.09442607f, 0.11977378f, 0.13180818f, 0.12222864f, 
    0.06505023f, 0.07805308f, -0.05771487f, 0.05554484f, 0.02592787f, -0.00012356f, -0.01208045f, 0.04973156f, 
    0.05922730f, -0.05812441f, -0.01113790f, 0.00767306f, 0.00471912f, 0.07563695f, -0.01541907f, -0.04223001f, 
    -0.08947431f, 0.12876958f, 0.14144143f, 0.02587024f, 0.07556507f, 0.02659500f, 0.05426906f, 0.05133228f, 
    0.01020908f, -0.00286508f, -0.04175819f, 0.02486884f, 0.02896279f, -0.00517903f, -0.03521676f, -0.00217890f, 
    0.02265054f, 0.00020731f, -0.00935411f, 0.01746541f, 0.15361081f, 0.04562105f, 0.09619696f, -0.04351017f, 
    0.10011705f, -0.05958810f, 0.04229500f, -0.07520574f, 0.01343655f, -0.01855366f, -0.02672975f, 0.07483391f, 
    -0.00962621f, 0.01498691f, -0.02191019f, -0.08889256f, 0.00834347f, 0.00617702f, -0.01413423f, -0.00268267f, 
    0.02626454f, -0.05142266f, -0.02720731f, 0.00495969f, -0.02416878f, 0.11102076f, -0.01139272f, -0.01062559f, 
    -0.01454367f, -0.04783999f, 0.00856313f, 0.00594059f, -0.05016189f, -0.03115065f, -0.02717258f, 0.03929821f, 
    0.02819524f, -0.03642138f, -0.03024979f, -0.01227722f, 0.16263109f, -0.20828353f, -0.00527676f, -0.04251146f, 
    0.11331468f, -0.10272270f, -0.10072698f, -0.03174036f, -0.03936935f, -0.03159371f, -0.01926879f, -0.05396745f, 
    -0.00400400f, 0.00612058f, -0.05379432f, -0.02483016f, 0.01008835f, 0.02245513f, 0.00742775f, 0.01765765f, 
    0.05486018f, -0.18175007f, 0.06503130f, 0.03695390f, -0.16636793f, 0.13987570f, -0.03799477f, -0.01653765f, 
    -0.05216413f, -0.02742381f, -0.00526823f, -0.07406557f, -0.00846745f, -0.03031775f, -0.06113685f, 0.06360890f, 
    0.07694978f, -0.01912987f, 0.01815811f, -0.05473316f, -0.35173041f, -0.05573807f, 0.02252447f, -0.02926066f, 
    -0.07984513f, -0.00946079f, -0.06797265f, -0.09712140f, 0.05337005f, -0.04381691f, -0.00296427f, 0.01534862f, 
    0.04284679f, -0.02054048f, 0.03864137f, -0.08623855f, -0.04487450f, 0.06094737f, -0.02081181f, 0.07335666f, 
    0.05368734f, 0.11720911f, 0.14762761f, 0.17094572f, 0.08318648f, 0.08531504f, 0.07564337f, 0.05349918f, 
    0.08102701f, -0.05438520f, -0.04701557f, 0.06865422f, 0.02349416f, 0.02988112f, -0.02714452f, 0.00353351f, 
    -0.04404010f, -0.02924697f, 0.02592133f, -0.01180493f, 0.05048275f, -0.07371956f, 0.07479397f, 0.02776258f, 
    0.07867448f, -0.01611611f, 0.02331493f, -0.06709041f, -0.07014093f, 0.02385204f, -0.01126152f, 0.00471609f, 
    -0.00021130f, -0.05055984f, 0.00251283f, -0.05128944f, 0.00141225f, 0.04441178f, 0.05437104f, 0.05254454f, 
    0.13688567f, 0.03588128f, 0.07168357f, 0.04071906f, 0.05057220f, -0.00797368f, -0.00728625f, -0.02704978f, 
    0.00242639f, -0.03973286f, -0.03717314f, -0.00224804f, -0.04203172f, 0.00503928f, 0.00064903f, -0.03470395f, 
    -0.03347627f, -0.00509240f, -0.01911199f, -0.04546518f, -0.13136324f, -0.06104133f, -0.19845182f, -0.21777785f, 
    -0.16385798f, -0.00584593f, -0.09068021f, -0.05223347f, -0.00750635f, -0.07950526f, -0.03622162f, -0.02362244f, 
    -0.03738861f, -0.03247636f, -0.06338353f, -0.00586278f, 0.02697836f, -0.04073241f, -0.01697548f, 0.03380907f, 
    -0.14083821f, 0.07357270f, -0.07194791f, 0.04809852f, 0.15154609f, -0.02933066f, -0.09873102f, -0.10756573f, 
    -0.00346202f, -0.04538452f, 0.04441197f, 0.00873991f, 0.01261573f, -0.02385445f, -0.06832855f, -0.00779621f, 
    -0.03792416f, 0.01299388f, -0.00928283f, -0.02649920f, -0.01140402f, 0.08444259f, 0.22343850f, 0.04115944f, 
    0.10186528f, 0.03352110f, 0.12731151f, 0.04647329f, 0.04836173f, 0.00020917f, -0.00202467f, 0.01032526f, 
    -0.02855509f, 0.02479291f, -0.01707186f, -0.04936176f, -0.01707252f, 0.00913033f, 0.04476039f, -0.01655319f, 
    -0.01994254f, 0.10089424f, -0.09985350f, 0.04213429f, -0.04081036f, 0.03842184f, -0.02181344f, -0.08360439f, 
    -0.04053034f, -0.02082781f, 0.04443615f, 0.01173193f, -0.02416776f, 0.05975476f, 0.03260621f, -0.01579044f, 
    -0.02069806f, -0.04548976f, 0.07101035f, 0.00040282f, -0.14670475f, -0.12187330f, -0.06202514f, -0.15480377f, 
    -0.11216744f, 0.01043050f, -0.02270811f, -0.01514957f, -0.06817934f, 0.00432728f, 0.00144408f, 0.00876560f, 
    0.04663541f, 0.01189760f, -0.02442628f, -0.03601332f, -0.00868977f, 0.02597300f, -0.05296267f, -0.03266239f, 
    0.05162716f, -0.03279245f, -0.02884589f, 0.07934816f, 0.04282415f, -0.09060691f, -0.05763322f, -0.06158046f, 
    -0.01734139f, 0.04242719f, 0.03125475f, -0.04833202f, -0.04866706f, -0.00512990f, 0.04013130f, 0.03740469f, 
    0.04713354f, -0.02207148f, 0.06572340f, -0.00207137f, 0.04580163f, -0.00324717f, 0.01118587f, 0.06016225f, 
    0.08174216f, -0.02691738f, -0.02431755f, 0.03326780f, -0.02326092f, 0.01132999f, -0.01707909f, 0.00696508f, 
    -0.02999608f, -0.03528343f, 0.01535734f, -0.00652068f, 0.01579442f, -0.04444152f, 0.03470061f, 0.02143044f, 
    -0.10614178f, -0.12470897f, -0.11185496f, -0.01964277f, 0.08474163f, 0.03121125f, 0.02081922f, -0.03084071f, 
    -0.00166040f, -0.03148417f, 0.08165939f, 0.02494668f, 0.03669389f, 0.02589834f, 0.03482270f, -0.04718141f, 
    0.01799461f, 0.03074818f, 0.01823145f, -0.04761891f, 0.08187007f, -0.01374542f, -0.04825593f, 0.04491277f, 
    0.02409144f, -0.00495341f, -0.02164336f, -0.05054368f, -0.06749410f, 0.08272962f, -0.02068449f, -0.04273594f, 
    0.00511406f, -0.04157874f, -0.01042843f, -0.02767568f, -0.04104666f, -0.07064985f, 0.11484955f, -0.02539270f, 
    -0.07210639f, 0.03544981f, 0.11464417f, -0.05805812f, 0.00327863f, -0.01742089f, 0.00402180f, 0.04556376f, 
    0.01625602f, -0.02652511f, -0.03547322f, -0.02019143f, 0.05544399f, 0.08527000f, 0.04844219f, 0.00098227f, 
    -0.07312004f, 0.07289240f, -0.06950465f, 0.04240064f, 0.12821756f, 0.09498627f, -0.25434527f, 0.05958858f, 
    0.02584770f, -0.05471252f, -0.03561200f, -0.02198150f, -0.07022087f, 0.02699183f, -0.05278369f, 0.06432100f, 
    0.02755004f, 0.06343474f, -0.07299533f, 0.10760061f, -0.02216283f, -0.00939997f, 0.06402738f, 0.03049557f, 
    0.06705739f, -0.03456702f, -0.12131111f, -0.02635643f, -0.03593379f, -0.00968571f, 0.03064116f, -0.01614137f, 
    -0.04905881f, 0.01987753f, 0.06827048f, 0.04868876f, 0.04735452f, -0.03592974f, 0.05646884f, -0.01164944f, 
    -0.02127703f, 0.01204139f, 0.06607140f, 0.01260767f, 0.04952997f, 0.13958848f, 0.01274964f, 0.00148049f, 
    -0.10405808f, -0.12359111f, 0.00923283f, -0.00756484f, -0.08079260f, -0.02592534f, 0.05397028f, -0.00668018f, 
    0.03851509f, -0.01632951f, 0.03096737f, -0.09834331f, -0.03228838f, -0.14483742f, 0.07390308f, -0.02032825f, 
    -0.00211932f, -0.04997503f, 0.11303134f, -0.06499793f, 0.15304402f, 0.02031484f, -0.05087858f, 0.04434734f, 
    -0.05880584f, 0.02133843f, 0.00127358f, -0.04158208f, -0.01011578f, 0.03035847f, 0.07323364f, 0.00486049f, 
    -0.00508524f, 0.06222862f, -0.03689084f, 0.01681135f, -0.14222045f, -0.17165171f, 0.19956802f, 0.04147507f, 
    0.10044964f, -0.09447430f, -0.07974987f, 0.01998442f, -0.08798356f, -0.03455809f, 0.05914425f, -0.05456368f, 
    0.02307788f, -0.05472014f, 0.02347302f, -0.00833717f, -0.03526572f, -0.04649028f, 0.05203019f, 0.09300752f, 
    -0.01673290f, 0.12478092f, -0.14366850f, -0.11332743f, -0.08028086f, -0.04439500f, 0.02496017f, -0.03744571f, 
    -0.00644762f, -0.04334249f, 0.06063046f, 0.00023762f, 0.03956905f, 0.00944248f, 0.00203642f, 0.03430225f, 
    -0.04110294f, -0.09641875f, 0.03237933f, 0.04798977f, -0.18852150f, -0.07241290f, -0.02167089f, -0.20634089f, 
    -0.14521946f, 0.02093420f, -0.04981672f, -0.01003914f, -0.04820876f, -0.06975276f, 0.01171955f, 0.04209520f, 
    0.02382977f, 0.06162232f, 0.00687011f, 0.02855607f, -0.05174000f, -0.12185995f, -0.14013056f, 0.04491962f, 
    -0.05132653f, 0.01611840f, 0.09372226f, -0.04811241f, -0.09309604f, -0.01469867f, -0.03774714f, 0.01913849f, 
    0.00419456f, 0.01474992f, -0.01871917f, -0.01289448f, -0.02257716f, -0.03163237f, -0.03919977f, 0.01580744f, 
    -0.06439979f, -0.07714726f, 0.04603313f, -0.04763064f, -0.14972386f, 0.06859832f, -0.17436033f, -0.06207775f, 
    -0.11997382f, -0.02150034f, -0.01173422f, -0.17819092f, -0.06813226f, -0.01066928f, 0.01115097f, 0.01800635f, 
    0.06944335f, -0.12693323f, 0.01793586f, -0.02999164f, 0.00222382f, -0.07654858f, 0.09643877f, -0.02544263f, 
    -0.13587959f, 0.21253715f, 0.10896076f, -0.02563763f, -0.18562625f, -0.05090356f, 0.00849433f, -0.00377541f, 
    0.00448385f, -0.09653210f, 0.08926069f, -0.00490295f, 0.05164472f, 0.03243159f, 0.02032047f, -0.14138372f, 
    0.05144716f, -0.05466128f, 0.09735741f, -0.01323960f, -0.13381165f, -0.00687511f, 0.06279717f, -0.12012669f, 
    -0.21281524f, -0.00849378f, -0.00783199f, -0.05066094f, 0.07647157f, 0.01822915f, 0.04087201f, 0.07468779f, 
    -0.03645332f, -0.02423995f, 0.02580896f, -0.06368209f, 0.03240721f, -0.05678791f, 0.05330914f, -0.14126840f, 
    0.02448559f, -0.05735967f, -0.21760470f, 0.06206291f, 0.06189115f, 0.02050908f, 0.03296596f, -0.02563058f, 
    -0.06385221f, -0.03483198f, 0.10332886f, -0.00106339f, 0.03793922f, -0.05942098f, 0.08178224f, -0.05995723f, 
    0.02636541f, -0.00437060f, 0.11731295f, -0.01792365f, 0.17930083f, 0.15279022f, -0.08946212f, 0.05430924f, 
    0.15352610f, 0.00355593f, -0.00647862f, -0.07839982f, -0.03940096f, -0.06742536f, -0.04828688f, -0.00512739f, 
    -0.01702156f, -0.05822974f, 0.00908895f, -0.00298451f, -0.00690933f, 0.04302080f, 0.08023813f, -0.02721396f, 
    -0.09142365f, -0.11014163f, 0.14440101f, -0.16332251f, 0.07150840f, 0.05181824f, 0.00555300f, -0.10165504f, 
    0.05147446f, -0.06430128f, 0.05303001f, 0.03220947f, 0.02190462f, -0.06773626f, 0.07405198f, -0.07105614f, 
    -0.01415407f, 0.05335200f, -0.07056081f, -0.01151025f, 0.00159939f, 0.03387972f, 0.00529361f, -0.03164886f, 
    -0.00530616f, -0.05184796f, 0.01529053f, -0.02580645f, -0.09017461f, 0.06359427f, -0.08686667f, 0.05215535f, 
    0.08757797f, 0.01090286f, -0.04587595f, 0.04522073f, -0.08648022f, 0.00458248f, -0.02892869f, -0.01163906f, 
    0.07596098f, -0.00281640f, 0.00847336f, 0.00993417f, -0.02726617f, 0.04528888f, -0.03899353f, -0.02330205f, 
    0.02138370f, -0.00163983f, 0.04092895f, -0.05175787f, -0.03299774f, 0.03122375f, -0.02171250f, 0.04193941f, 
    -0.01200056f, -0.02206497f, -0.02752605f, -0.00571275f, -0.01676708f, -0.03176743f, 0.05834217f, 0.08413413f, 
    0.08860007f, -0.13773437f, -0.04717062f, -0.00453140f, -0.04559816f, 0.03663521f, -0.02537990f, -0.08717515f, 
    -0.01933165f, 0.04903464f, -0.02632327f, 0.05023788f, 0.02530867f, 0.02004225f, 0.04069439f, 0.07107162f, 
    -0.18150114f, 0.01398512f, 0.00281239f, -0.24181934f, -0.16572197f, 0.07569595f, 0.04645188f, 0.00615218f, 
    0.01605348f, -0.02292349f, 0.00692924f, -0.00309323f, -0.11360119f, 0.01279689f, 0.03117087f, -0.09286139f, 
    0.01098430f, 0.00760738f, -0.03790731f, -0.07080670f, -0.05276880f, -0.17185998f, -0.23626262f, -0.05024873f, 
    0.03219021f, 0.04575875f, -0.07150763f, -0.05835265f, -0.03270502f, 0.01596808f, 0.10830611f, -0.02478305f, 
    0.01761325f, -0.08519384f, 0.10416821f, 0.00484722f, -0.03476003f, 0.03962400f, 0.11570333f, 0.02194081f, 
    -0.25576180f, 0.14189421f, -0.11090180f, -0.15728146f, -0.29019460f, -0.03577435f, 0.00364726f, -0.01978264f, 
    0.08181916f, -0.05906726f, 0.11403704f, -0.01111288f, 0.01333082f, -0.02526508f, 0.06533841f, -0.05668616f, 
    0.01654352f, -0.13814312f, 0.04641607f, -0.00115908f, -0.05402210f, -0.09822723f, 0.15217364f, 0.06780996f, 
    0.12289684f, -0.08888748f, -0.04772088f, 0.03631871f, -0.02808870f, -0.00649555f, -0.00399134f, -0.06511979f, 
    -0.05246130f, -0.10475666f, 0.04446127f, 0.00876686f, -0.00780284f, 0.01371443f, 0.00757489f, 0.02417080f, 
    0.06241997f, 0.11257255f, 0.11659682f, 0.05306187f, 0.07641669f, -0.04064070f, 0.01733871f, -0.09116577f, 
    -0.09356291f, -0.03006642f, -0.00520448f, 0.02163091f, 0.06039517f, 0.02931994f, -0.06489854f, -0.09025760f, 
    -0.05150490f, 0.05543011f, -0.00187278f, -0.10967790f, -0.08796851f, -0.12254678f, -0.07292015f, -0.12856042f, 
    -0.04163296f, -0.02771572f, 0.00832280f, -0.06704891f, -0.03737223f, -0.05911523f, 0.10144721f, 0.02000544f, 
    0.07095963f, 0.02629911f, 0.02355499f, -0.02284571f, 0.09736966f, 0.05923257f, 0.02294123f, -0.02743767f, 
    0.04393237f, -0.14383557f, -0.07478688f, 0.06261055f, 0.11352482f, 0.03134845f, 0.01366872f, 0.00036098f, 
    -0.08558448f, 0.00708195f, 0.01539718f, 0.05427057f, -0.03847788f, 0.00946791f, 0.04386451f, -0.01687563f, 
    -0.03161472f, -0.00549477f, 0.04737585f, -0.01303139f, -0.08146665f, -0.00594180f, -0.15890159f, -0.05991524f, 
    -0.06373122f, 0.09032585f, -0.01260045f, 0.01441325f, -0.05021236f, -0.02957745f, 0.01172352f, -0.00052820f, 
    0.00510245f, 0.08204090f, 0.04135831f, 0.03312369f, -0.02946975f, -0.06307877f, -0.10922466f, 0.04481649f, 
    0.10283013f, 0.00117216f, 0.01151919f, 0.03754108f, 0.12273015f, 0.09550091f, 0.01079409f, -0.04745465f, 
    -0.01369558f, 0.00040545f, -0.00433760f, 0.01147133f, -0.01286739f, -0.00666032f, 0.00236236f, 0.03835945f, 
    0.00955750f, 0.02578036f, 0.04839549f, -0.01018218f, -0.08824664f, -0.15451442f, -0.05488218f, 0.12006875f, 
    0.12322135f, 0.07766015f, 0.05876428f, -0.04366180f, -0.04499847f, -0.06862568f, 0.03435811f, 0.00818506f, 
    0.04715293f, 0.03837454f, 0.03128189f, -0.05088928f, 0.01846705f, 0.05064585f, 0.01466112f, -0.06368546f, 
    0.09629466f, 0.05326391f, -0.10303488f, 0.08635070f, 0.11877734f, 0.06888648f, 0.06970819f, -0.01640286f, 
    -0.03173663f, -0.00018361f, -0.04849418f, 0.01103924f, -0.04136797f, 0.02264875f, -0.05603604f, -0.03319151f, 
    0.00446538f, 0.05944643f, 0.07195555f, 0.00932625f, -0.09314540f, -0.05138082f, -0.03466962f, -0.24091558f, 
    -0.04067833f, 0.03371402f, -0.02652417f, 0.02102844f, 0.04908691f, -0.07998905f, 0.02784174f, 0.01891412f, 
    -0.03702824f, -0.01137811f, -0.02917243f, 0.01126846f, 0.00416312f, 0.04493112f, -0.02526959f, -0.00559477f, 
    0.10587296f, 0.21142326f, 0.08751327f, 0.02228552f, -0.04853577f, -0.01004439f, -0.02280756f, -0.06244333f, 
    -0.13849041f, -0.07700545f, 0.08224057f, -0.02429227f, 0.01895734f, 0.04083468f, -0.16136722f, -0.10361990f, 
    0.02464151f, -0.02792632f, -0.00393394f, -0.06057380f, 0.08895497f, 0.07882816f, -0.08939396f, 0.02134121f, 
    0.04939658f, 0.12785096f, 0.04398157f, -0.00078867f, -0.03745956f, 0.04128520f, 0.05511101f, 0.03922617f, 
    -0.11011230f, 0.09302670f, -0.05636381f, 0.00705497f, -0.00884978f, 0.05596058f, 0.03202020f, -0.04878701f, 
    0.06107489f, 0.13169658f, 0.06719110f, 0.06304062f, -0.09504703f, -0.02318880f, 0.03403673f, -0.02966481f, 
    -0.05373833f, 0.04107050f, 0.04657905f, -0.01845565f, 0.06259545f, 0.00089759f, 0.04134659f, 0.00909592f, 
    -0.00084990f, -0.05655566f, 0.08663445f, -0.01256782f, -0.05326806f, 0.04076190f, -0.18752804f, -0.11290029f, 
    -0.13601284f, -0.01821877f, 0.01371805f, -0.06112322f, -0.04070391f, -0.00127064f, 0.03184750f, 0.01631067f, 
    -0.03310735f, 0.04674893f, -0.00460561f, -0.02253651f, 0.02077030f, -0.09830798f, -0.10677548f, -0.05903336f, 
    0.09797275f, 0.09687607f, -0.19201981f, 0.09384868f, 0.08220785f, 0.03924857f, -0.05741217f, -0.08660402f, 
    -0.01327682f, 0.05092065f, -0.00608309f, 0.01450910f, 0.01809901f, -0.06237196f, 0.03708124f, -0.01364923f, 
    0.00881085f, -0.01656353f, 0.09066322f, -0.00007120f, -0.10795684f, -0.07144929f, 0.10713400f, 0.04073190f, 
    0.07826932f, -0.06316537f, -0.04515215f, 0.00550562f, -0.02827399f, 0.04678407f, 0.02198640f, -0.00870526f, 
    -0.00831875f, -0.04663731f, 0.00743490f, 0.01973793f, -0.01687347f, 0.00158305f, -0.01272432f, -0.01161621f, 
    0.05325177f, -0.15171336f, 0.07048473f, -0.00805476f, 0.07874683f, -0.03484320f, -0.00637489f, 0.00341599f, 
    -0.04854659f, 0.02001584f, -0.06610100f, -0.05393665f, -0.01050247f, -0.08525941f, 0.02237265f, 0.04048747f, 
    -0.03411418f, -0.01364914f, 0.07677074f, 0.04469305f, -0.12732935f, -0.06487665f, 0.02443906f, -0.13021043f, 
    0.00754067f, -0.00999658f, 0.01079682f, -0.07876959f, -0.03448980f, -0.09109316f, 0.08431581f, 0.02969165f, 
    0.02458064f, 0.03146847f, -0.00666262f, -0.05346129f, 0.06694105f, 0.02993861f, -0.01576590f, -0.01807194f, 
    0.08503614f, 0.04949518f, 0.01194429f, 0.05265771f, 0.09792960f, 0.04929891f, -0.02415696f, -0.02983854f, 
    -0.01392524f, -0.03490737f, 0.00601372f, 0.03591293f, 0.00987638f, 0.00242723f, -0.04902527f, 0.01455686f, 
    -0.00030290f, 0.01177845f, 0.07412915f, 0.04885080f, 0.07175594f, 0.11531413f, -0.05692465f, 0.02538848f, 
    0.03933737f, 0.01002198f, -0.09866873f, -0.05220115f, 0.04686723f, 0.01776224f, 0.06977334f, 0.01118759f, 
    -0.00371077f, -0.04004835f, 0.05716329f, 0.00623596f, 0.02293108f, 0.01528591f, 0.03675418f, -0.01111451f, 
    0.11511136f, 0.05855188f, -0.04200732f, 0.05764993f, 0.01617537f, -0.04249499f, -0.00563342f, -0.06377994f, 
    -0.05564141f, -0.03699103f, 0.03206659f, 0.04720366f, 0.04974683f, -0.07969345f, 0.01531507f, -0.04822781f, 
    -0.01592345f, 0.02161835f, 0.09712671f, -0.02537622f, -0.05153055f, 0.09417856f, 0.04793306f, -0.08693482f, 
    -0.02480669f, -0.04136989f, -0.01360131f, -0.02746552f, -0.01624058f, -0.12914033f, 0.08498225f, 0.05489386f, 
    0.01432958f, -0.03180752f, -0.01165365f, -0.05565435f, 0.00688363f, 0.06722847f, -0.03746910f, -0.03470521f, 
    0.12997632f, 0.00152721f, -0.02804381f, 0.02422441f, 0.05907734f, -0.02730134f, -0.01861968f, -0.03384944f, 
    -0.02644847f, -0.00122543f, 0.00683005f, -0.02390795f, -0.00125989f, -0.04332002f, 0.01290725f, -0.02287744f, 
    -0.03578535f, -0.00998497f, 0.02873788f, -0.04208392f, -0.16196446f, 0.07542554f, 0.08927181f, -0.14533310f, 
    -0.14262205f, 0.04452115f, 0.02091769f, 0.07017724f, -0.03055189f, -0.01568059f, -0.00554986f, -0.00941977f, 
    0.00005243f, -0.01076539f, -0.07338312f, -0.01194858f, 0.00225285f, -0.06686907f, -0.15590847f, -0.06619103f, 
    -0.16503261f, -0.11031571f, 0.21761076f, -0.03121379f, -0.07303063f, 0.01711132f, -0.01603218f, 0.03403171f, 
    -0.04420487f, 0.00654721f, -0.00332663f, 0.06351615f, -0.02273121f, 0.07912459f, -0.01886849f, -0.03711272f, 
    -0.01002860f, -0.05019531f, -0.04070261f, -0.04650281f, -0.12213673f, -0.08281408f, 0.03651948f, -0.07448753f, 
    -0.22948575f, -0.01008520f, 0.03077855f, 0.01552639f, 0.06466725f, -0.02226264f, 0.07226212f, 0.02884383f, 
    0.01321726f, 0.03737303f, -0.00486457f, -0.00875742f, -0.01432476f, -0.08651775f, 0.02124980f, 0.05527497f, 
    -0.05752868f, -0.02588954f, 0.14339249f, -0.07364021f, -0.01722613f, 0.04321782f, -0.02033580f, 0.03277328f, 
    -0.04413629f, 0.05918800f, -0.00802540f, 0.01801548f, -0.03386625f, -0.02986053f, 0.01877750f, -0.01130670f, 
    -0.02491020f, -0.00859929f, -0.01902996f, -0.01269682f, -0.02950310f, 0.08210925f, -0.04422471f, -0.01195344f, 
    -0.09752862f, -0.02109625f, -0.02632064f, -0.02779488f, -0.02889222f, -0.02941213f, 0.03494043f, 0.01057466f, 
    0.01358903f, 0.09287375f, 0.00941653f, 0.04222284f, 0.03596684f, -0.03978318f, -0.00629478f, 0.07448213f, 
    0.07149404f, -0.03876344f, 0.01369002f, 0.00024836f, 0.05916013f, -0.04048931f, -0.00694916f, -0.00918140f, 
    0.00379659f, -0.04878395f, 0.06311799f, -0.03809773f, -0.05532219f, -0.01595984f, 0.03532939f, 0.01261514f, 
    -0.02627314f, 0.06700186f, -0.02347956f, -0.00601414f, -0.03085885f, -0.11913406f, -0.07960091f, -0.07433452f, 
    0.02104847f, 0.04261502f, 0.01430347f, -0.00737152f, -0.03999358f, -0.07031674f, 0.01028577f, 0.02137892f, 
    0.00762602f, -0.05095093f, 0.01406167f, 0.02733825f, 0.06611577f, 0.01873616f, -0.11593093f, -0.00501133f, 
    -0.04295107f, 0.02849837f, -0.06660403f, 0.06311351f, -0.01142131f, -0.03621819f, -0.03131310f, -0.08594218f, 
    -0.09889889f, -0.00200172f, 0.01834767f, -0.06468320f, -0.05698586f, -0.02490285f, 0.02379704f, -0.00360303f, 
    0.03468442f, -0.03978740f, 0.03584935f, 0.04575898f, -0.02284163f, 0.02272824f, -0.14317760f, -0.03377950f, 
    0.03921512f, 0.07041039f, 0.00419841f, -0.01686654f, -0.00985175f, -0.09120984f, 0.04591643f, 0.04388968f, 
    0.02251841f, -0.02314820f, -0.02390968f, 0.01044847f, 0.02852183f, 0.00840038f, 0.04192142f, -0.05623730f, 
    -0.14114550f, -0.07296395f, 0.21123257f, 0.00910310f, 0.16673921f, -0.00073012f, -0.01644416f, -0.01503401f, 
    -0.08091298f, 0.00916037f, -0.04354258f, -0.00312193f, -0.06668062f, -0.10489020f, 0.04347410f, -0.01430742f, 
    0.06609273f, 0.05134671f, -0.07825635f, 0.00338164f, -0.04866196f, -0.12141553f, 0.04152664f, -0.18491744f, 
    -0.11939547f, 0.02413186f, -0.01029071f, 0.03298046f, -0.03645610f, 0.00609039f, -0.00151617f, 0.02531658f, 
    0.01415182f, 0.03887339f, -0.06062899f, 0.04954201f, 0.00638110f, -0.00132158f, -0.23991412f, -0.00413851f, 
    -0.13709724f, 0.08382972f, 0.00818988f, -0.07158673f, -0.05683076f, -0.00294888f, -0.00366287f, 0.01075433f, 
    -0.02984577f, -0.02446249f, 0.02379135f, 0.01794438f, -0.04595628f, 0.09750222f, 0.00146893f, 0.01856867f, 
    0.02882188f, -0.05894674f, -0.01300025f, 0.03331512f, 0.03906543f, 0.03614111f, 0.00819992f, -0.00466496f, 
    0.08644228f, 0.08517101f, 0.01777615f, -0.05430467f, -0.02500658f, -0.00762300f, 0.04975435f, 0.03670917f, 
    -0.02974655f, 0.00085555f, -0.04491066f, -0.05820230f, 0.00793214f, 0.04463018f, 0.04308649f, -0.02547483f, 
    -0.10814264f, 0.11205205f, -0.27008662f, -0.19156612f, -0.12627876f, 0.02289443f, -0.01255715f, -0.16120774f, 
    0.06121235f, -0.04150163f, 0.05940126f, 0.03131030f, -0.01760962f, -0.03027802f, 0.02494331f, 0.00335653f, 
    -0.03523292f, -0.14554268f, -0.01377536f, 0.03939429f, -0.11603551f, -0.05448030f, 0.13259026f, -0.03635941f, 
    -0.04696146f, -0.05761830f, 0.03861926f, 0.02094580f, -0.03711310f, -0.07982101f, 0.02560432f, -0.01601379f, 
    -0.04756485f, 0.01966649f, 0.03798856f, 0.00435251f, 0.03261746f, -0.06668767f, -0.03549143f, -0.01154260f, 
    -0.06854864f, -0.02131851f, 0.29443431f, -0.04283952f, 0.03337111f, 0.06456028f, 0.02484022f, -0.01691526f, 
    0.14176941f, -0.05662729f, 0.08563126f, -0.00499106f, 0.09379642f, -0.01263259f, 0.01644640f, 0.01325156f, 
    -0.01346206f, 0.05208527f, -0.08440640f, 0.03859594f, 0.08083140f, -0.15929723f, 0.00425920f, -0.06529988f, 
    0.03088328f, -0.06493928f, 0.03250188f, 0.00883958f, 0.00590077f, -0.04049093f, 0.03190494f, -0.05057984f, 
    0.00543287f, 0.07345590f, -0.00387270f, -0.01698906f, 0.05626632f, 0.03958842f, 0.03133565f, 0.09223094f, 
    -0.00499467f, -0.25108817f, -0.04558542f, 0.05292391f, 0.05922942f, 0.04788319f, 0.03559493f, 0.02662444f, 
    -0.00955701f, 0.02987668f, -0.02976177f, -0.01864473f, 0.06155378f, 0.06832691f, -0.03670099f, -0.00435453f, 
    0.05263097f, -0.01625519f, -0.01100255f, 0.08211808f, -0.05068719f, 0.00435488f, 0.06812223f, 0.02331505f, 
    -0.05019075f, 0.04007733f, -0.01516606f, -0.08143783f, 0.04706023f, 0.08240526f, -0.01199871f, -0.00177296f, 
    -0.03876120f, 0.04358875f, -0.01687521f, -0.05488778f, -0.03021645f, -0.03794117f, 0.01679371f, -0.01334977f, 
    0.02625524f, -0.17541932f, 0.10634384f, -0.20243056f, -0.14444873f, -0.07713876f, 0.00218535f, -0.08839298f, 
    0.02339453f, 0.00542654f, -0.00557592f, 0.04110184f, 0.04757614f, -0.09063889f, -0.08795118f, -0.03790122f, 
    0.03358483f, 0.04928001f, -0.00639626f, -0.01821609f, 0.21836010f, -0.10682043f, 0.09758048f, -0.03456516f, 
    0.14964266f, 0.00133686f, -0.06010312f, 0.03055103f, 0.08284871f, 0.08480287f, 0.10592265f, 0.06022635f, 
    -0.06408923f, 0.10849436f, -0.05164449f, 0.00788869f, -0.02660808f, 0.07191294f, -0.03930704f, 0.02085183f, 
    0.04221519f, -0.24925879f, 0.01176845f, 0.05735992f, -0.14416470f, -0.12475767f, -0.01308859f, -0.02439949f, 
    0.08108813f, -0.00472052f, -0.04513136f, 0.04919087f, 0.01088139f, -0.06311868f, 0.05869853f, -0.02126205f, 
    0.10434689f, -0.00251786f, 0.04525489f, -0.04357154f, 0.04513891f, -0.01068718f, -0.00537630f, -0.12845288f, 
    -0.07832339f, 0.01945922f, 0.02743291f, -0.06991653f, 0.01712456f, -0.10219543f, -0.04546002f, 0.05306810f, 
    0.00154889f, -0.02757610f, -0.04741743f, 0.00429733f, -0.11339005f, 0.05601340f, -0.01176091f, 0.16684972f, 
    0.03000030f, 0.27939788f, -0.11535289f, -0.28796700f, -0.08120782f, -0.10756450f, -0.00358542f, -0.00221210f, 
    0.08429279f, 0.08956648f, -0.00278266f, -0.00573978f, 0.09374509f, -0.06957931f, -0.01732104f, -0.00393112f, 
    -0.02292094f, 0.05170738f, 0.01070281f, -0.03134952f, -0.40755200f, 0.38188693f, -0.02220044f, 0.13305588f, 
    -0.03261651f, 0.15160598f, 0.03082995f, -0.00321574f, 0.03858111f, 0.07035033f, -0.04090419f, 0.05089509f, 
    0.08049861f, -0.02062432f, 0.05946082f, 0.10365253f, -0.05028802f, 0.09713662f, -0.04185072f, 0.01230248f, 
    0.15878996f, -0.00560140f, -0.12521876f, 0.15130484f, -0.08037762f, -0.00092930f, 0.02253369f, -0.00456487f, 
    -0.00028749f, 0.00803865f, -0.04690190f, 0.07404952f, -0.01799791f, -0.10252777f, 0.04913200f, 0.02869334f, 
    0.01546673f, -0.05674954f, 0.05551272f, -0.02116985f, 0.41950855f, -0.21822372f, -0.05311857f, -0.03124322f, 
    0.08063293f, 0.04316472f, -0.06966023f, -0.02886637f, -0.15208410f, 0.11987661f, -0.07217462f, 0.03953740f, 
    -0.01600509f, 0.02494389f, -0.03054501f, -0.01765550f, -0.01171409f, -0.09000113f, -0.01262594f, -0.03793958f, 
    -0.28115273f, 0.13864937f, 0.09230830f, -0.07133033f, -0.12419475f, 0.05522855f, 0.06745241f, 0.02663260f, 
    -0.04635152f, -0.03742338f, -0.02154926f, -0.01473603f, -0.00413138f, -0.01380682f, -0.05574460f, -0.01084856f, 
    -0.01547686f, 0.03211603f, 0.04544488f, -0.00348524f, 0.01114025f, -0.11111922f, -0.10731957f, 0.03576681f, 
    0.15456717f, -0.15261388f, 0.06471919f, 0.08178303f, 0.02807867f, -0.03477741f, -0.02552657f, 0.06120316f, 
    -0.04567822f, -0.11249257f, -0.02474182f, -0.00025118f, -0.04690593f, 0.09120906f, 0.07042976f, 0.11767041f, 
    -0.11756981f, -0.12061609f, 0.00352447f, 0.12138481f, 0.06775381f, 0.05622976f, -0.02627435f, 0.01081778f, 
    0.02323755f, 0.13707197f, -0.02943273f, -0.01647073f, -0.03716393f, 0.00800009f, -0.04767974f, 0.04037910f, 
    -0.10596150f, 0.04557636f, -0.03878726f, -0.01495760f, -0.05159534f, -0.65391612f, -0.07220889f, -0.05842403f, 
    -0.04786349f, -0.15180609f, 0.03770301f, -0.01183640f, 0.06148091f, -0.04102500f, -0.15923540f, -0.08483310f, 
    -0.02336625f, 0.00216258f, 0.08840446f, 0.02977420f, 0.05746299f, 0.11494819f, -0.01750601f, 0.08503012f, 
    0.12838055f, 0.19127254f, 0.05913189f, 0.26732400f, -0.02675832f, 0.03165773f, -0.02033788f, 0.07885004f, 
    -0.00469290f, -0.05768694f, -0.11140931f, -0.05025093f, 0.12922408f, 0.01207341f, 0.14420058f, 0.05256191f, 
    0.03642984f, 0.00661074f, -0.15298061f, 0.01519114f, -0.07889827f, -0.06512872f, 0.08996351f, -0.20377064f, 
    -0.08103880f, -0.10868019f, 0.05010238f, 0.03946282f, 0.07572491f, 0.04245456f, -0.09569152f, -0.04082641f, 
    -0.00045796f, -0.04590502f, 0.04140333f, 0.04026316f, 0.01203866f, 0.03467293f, 0.00710373f, -0.00205128f, 
    -0.21511976f, 0.05194063f, 0.13268700f, -0.26104555f, 0.03847718f, 0.04500699f, 0.02826899f, -0.08902212f, 
    0.09578557f, -0.03992012f, 0.06799164f, -0.04232350f, -0.02064578f, 0.00078284f, -0.03384989f, 0.06024260f, 
    -0.01834928f, 0.13326107f, -0.13822845f, 0.03656387f, -0.09107881f, -0.03626427f, -0.06630369f, -0.08606480f, 
    -0.03836547f, 0.04064619f, 0.05614701f, 0.05289965f, 0.00315134f, -0.08167694f, 0.09015457f, 0.03287352f, 
    -0.04266807f, -0.03037961f, -0.06154166f, 0.05314508f, -0.02973463f, -0.06793100f, -0.12074295f, 0.02578736f, 
    -0.07084167f, -0.26196289f, -0.02618356f, -0.06201664f, -0.12536947f, 0.04270994f, 0.08912387f, -0.05903285f, 
    -0.05094659f, 0.04461557f, -0.04791551f, -0.02020353f, 0.05389725f, 0.06779122f, -0.13596272f, 0.11193773f, 
    -0.01727890f, -0.06014393f, -0.13302167f, -0.16692455f, 0.37231243f, -0.37706402f, 0.02683518f, -0.01486217f, 
    -0.11661393f, -0.20498763f, -0.07342102f, 0.07670791f, 0.18614875f, -0.02526190f, -0.07957211f, -0.02643345f, 
    0.02574232f, -0.10805652f, -0.02980107f, 0.10442572f, 0.15129898f, 0.09343615f, 0.02436267f, -0.04060422f, 
    -0.16703692f, -0.10156816f, 0.05034582f, -0.01373716f, 0.05418103f, 0.04160470f, -0.01677456f, -0.06746610f, 
    0.00646630f, 0.03255183f, -0.06891272f, -0.03007795f, 0.06346194f, 0.03871722f, -0.00420941f, 0.03566341f, 
    -0.05944168f, -0.11935090f, -0.00279196f, -0.01103948f, -0.02637513f, -0.26522404f, -0.09750730f, 0.12474885f, 
    -0.07631746f, 0.00111668f, 0.06613430f, -0.09115773f, -0.02994928f, -0.01870388f, -0.07187407f, -0.00036141f, 
    0.04591954f, -0.02135862f, -0.03820061f, -0.15497717f, -0.07201315f, -0.04219956f, -0.01592598f, 0.07880371f, 
    0.02466768f, 0.07621385f, -0.04614433f, 0.07554607f, -0.11224043f, -0.15637662f, 0.02833186f, -0.06817507f, 
    -0.03114736f, 0.04704480f, 0.01704348f, 0.01948350f, 0.11613371f, 0.02760239f, 0.08112321f, 0.00929616f, 
    0.04046524f, 0.03545870f, -0.01447349f, 0.07981412f, -0.29238588f, 0.14165761f, 0.08377264f, -0.38710210f, 
    -0.06140568f, -0.09307279f, 0.03871910f, -0.12784173f, 0.02271619f, 0.13270190f, -0.05367730f, -0.03866958f, 
    -0.03442262f, 0.00413423f, 0.05189320f, 0.10996138f, 0.01469271f, -0.01700032f, -0.04406699f, -0.01757038f, 
    -0.34687248f, 0.04503777f, 0.13103198f, 0.05673408f, 0.06183216f, -0.05584938f, 0.06516760f, -0.02132549f, 
    -0.00082632f, -0.00481522f, 0.01598710f, 0.01228643f, 0.07691495f, 0.08642285f, 0.09681857f, 0.00929855f, 
    0.05263557f, 0.09579239f, 0.03751623f, 0.01032881f, -0.02608099f, -0.11213117f, -0.11895039f, 0.11501236f, 
    0.00843337f, 0.07830976f, 0.00125007f, -0.02235134f, -0.06925604f, 0.10614208f, -0.01190410f, -0.05334690f, 
    -0.01730496f, 0.02324901f, -0.04371050f, -0.07806889f, -0.13163620f, 0.03383900f, 0.00664182f, -0.01254842f, 
    0.31697437f, -0.07965298f, -0.04748729f, -0.21099082f, -0.15488189f, -0.01597074f, 0.05253827f, 0.00248143f, 
    0.09645665f, -0.10660910f, -0.06151742f, 0.01685223f, 0.00235113f, 0.04483613f, -0.11835135f, 0.05133465f, 
    0.06261028f, 0.02363449f, 0.06198914f, 0.06667041f, -0.31221658f, -0.07511788f, -0.10415124f, -0.07079996f, 
    -0.21340357f, 0.03627829f, 0.05760454f, -0.06231382f, -0.09859671f, -0.06742181f, -0.07547761f, -0.07699995f, 
    -0.05323643f, -0.07262398f, 0.00348348f, -0.05096510f, 0.00481760f, 0.06297784f, 0.05059134f, 0.05294466f, 
    0.15893911f, -0.33765844f, 0.10228669f, 0.02554482f, -0.10193217f, 0.00493927f, 0.02034303f, -0.01965375f, 
    -0.01190104f, -0.02900914f, 0.01471211f, -0.02049092f, 0.00781017f, -0.03790747f, -0.05546895f, 0.04498737f, 
    0.03929554f, 0.00091017f, 0.04373189f, 0.05055969f, -0.03173042f, -0.20108427f, 0.05626091f, 0.00162724f, 
    -0.02980744f, -0.07998331f, 0.02352790f, -0.07148790f, 0.02889483f, 0.04483677f, 0.07747151f, 0.00211021f, 
    0.05468261f, -0.18283255f, 0.01106838f, 0.00320677f, 0.03344888f, -0.15178323f, 0.08544062f, 0.05772747f, 
    0.14748816f, -0.27063453f, 0.22930548f, -0.02273444f, -0.04038250f, 0.04407910f, 0.02839393f, -0.09471770f, 
    0.01453018f, -0.00234452f, -0.03968123f, 0.02341208f, 0.03984081f, -0.10778388f, -0.00292602f, 0.01641812f, 
    -0.02340302f, -0.01308623f, 0.00073685f, 0.02878206f, -0.03432370f, -0.12296755f, 0.13102591f, -0.10071592f, 
    -0.15202597f, -0.00694167f, 0.10399182f, -0.06116287f, -0.03987034f, -0.00982250f, -0.07891250f, -0.01044074f, 
    -0.04665901f, -0.04339512f, -0.05081176f, -0.05665749f, -0.03947818f, 0.01761205f, 0.03399507f, -0.05526293f, 
    0.05890456f, 0.06156890f, 0.11771368f, -0.11471196f, -0.13595749f, 0.04971555f, 0.08841971f, -0.05469973f, 
    -0.03259609f, -0.06340076f, -0.06185726f, 0.08698586f, -0.02002946f, -0.01318419f, 0.00813841f, -0.03397425f, 
    0.01141255f, 0.04510736f, 0.07247566f, 0.00752003f, 0.10133423f, -0.00856706f, 0.16081437f, -0.20711997f, 
    -0.24505816f, -0.06589610f, -0.07100504f, 0.09358048f, -0.04015194f, 0.08475054f, 0.05437793f, 0.08480950f, 
    0.10913279f, -0.08888717f, -0.00594973f, -0.02774484f, 0.07660389f, -0.02627514f, 0.01082719f, -0.04743311f, 
    0.42838988f, -0.02327929f, -0.25977355f, -0.23801391f, -0.28722799f, -0.00019683f, 0.04476191f, 0.07544971f, 
    0.09562089f, -0.08413250f, -0.11410617f, -0.02237731f, 0.06311033f, 0.17629865f, -0.11483824f, 0.03995685f, 
    0.08618742f, -0.00691744f, -0.01825484f, 0.06648543f, 0.19669570f, -0.06969728f, 0.18181807f, -0.11788663f, 
    -0.24074137f, 0.01793316f, 0.05304983f, 0.12524734f, -0.04917978f, 0.01417288f, -0.05564900f, 0.03058623f, 
    0.02145751f, -0.14212769f, 0.03132391f, -0.08660073f, 0.02222835f, -0.09479661f, 0.08053353f, -0.03109858f, 
    -0.06748609f, 0.20615862f, -0.11237402f, 0.11185987f, -0.04394307f, 0.09278934f, 0.03209176f, -0.01368688f, 
    -0.03143273f, 0.08114395f, -0.01592358f, 0.03819026f, 0.03754761f, 0.04926429f, 0.00936554f, 0.07104644f, 
    -0.01290054f, 0.00953414f, -0.08511522f, -0.07348001f, -0.12300836f, -0.09848890f, 0.06561356f, 0.06653497f, 
    0.05714153f, -0.07734737f, -0.01924252f, 0.01673877f, -0.02372086f, -0.04240861f, 0.10989705f, 0.05115644f, 
    -0.01622534f, 0.00879525f, 0.01278041f, 0.01353550f, 0.05560302f, -0.04339032f, 0.03692552f, 0.06527174f, 
    0.17207690f, -0.23776241f, 0.09513813f, -0.12900352f, 0.19033220f, 0.09675353f, 0.00925156f, -0.03523011f, 
    0.00579043f, -0.16226017f, 0.10889649f, -0.02412283f, -0.05939203f, 0.10900887f, 0.00967380f, -0.03379042f, 
    0.03327780f, -0.08363911f, -0.03867709f, 0.02002054f, 0.10499217f, -0.12186153f, -0.00526926f, 0.12231175f, 
    -0.04903264f, 0.02021464f, -0.00685518f, -0.02416290f, 0.02527440f, 0.07110739f, -0.01814070f, 0.02036138f, 
    -0.05661025f, 0.00177775f, 0.03875642f, -0.03537438f, -0.04373243f, 0.02856773f, -0.01159224f, 0.00327853f, 
    0.34814867f, -0.22219604f, 0.23459958f, -0.07018383f, 0.22067471f, 0.07240225f, -0.04910560f, -0.04918167f, 
    0.01843431f, 0.00771420f, 0.00883467f, -0.08380166f, -0.03081467f, 0.08229632f, -0.01994940f, -0.02589329f, 
    -0.00321627f, -0.08018883f, -0.13138694f, -0.06995486f, 0.15730385f, -0.07614221f, -0.05950940f, 0.00768623f, 
    -0.23091248f, -0.02107022f, 0.02806145f, 0.07438849f, 0.02768218f, -0.05264939f, -0.03733566f, -0.04250100f, 
    -0.01493813f, -0.01281608f, 0.02598789f, 0.02293922f, 0.08755604f, 0.05545618f, 0.04170991f, 0.10395049f, 
    -0.10125313f, -0.04032353f, 0.03519865f, -0.16203992f, -0.04442234f, 0.05754920f, 0.02283036f, -0.07158574f, 
    -0.12370753f, -0.00280874f, 0.01904193f, -0.01429088f, -0.03243323f, 0.09891310f, -0.04655850f, -0.01386109f, 
    -0.06026641f, -0.06303752f, 0.00831990f, -0.01882564f, -0.18546209f, -0.07081305f, 0.06101651f, -0.18020536f, 
    0.13297781f, 0.03830107f, -0.01132314f, -0.10063208f, -0.05184880f, -0.01468246f, 0.02698832f, -0.08884626f, 
    -0.04810660f, 0.02375047f, 0.07130458f, -0.02577386f, 0.01983449f, -0.12421549f, -0.02493760f, -0.06022893f, 
    -0.23692212f, 0.04621796f, 0.13817754f, -0.09978835f, -0.00902027f, 0.09820685f, 0.02154089f, 0.09323454f, 
    0.01687214f, -0.03334136f, -0.00484021f, 0.05841614f, 0.01381368f, 0.02587443f, 0.02642558f, -0.01266881f, 
    -0.02446709f, -0.00709900f, -0.12760083f, 0.06124402f, 0.45231399f, 0.07826738f, -0.09704170f, -0.22417873f, 
    -0.00922302f, 0.00542834f, -0.08272626f, -0.01756452f, 0.04459447f, -0.07064596f, -0.03459927f, -0.06064149f, 
    0.08451524f, 0.04924222f, -0.02969408f, 0.01273176f, 0.09312737f, -0.06749097f, -0.04064357f, 0.10921011f, 
    -0.25550738f, 0.14697635f, 0.07721748f, 0.04547204f, 0.07103775f, 0.07428784f, 0.02417720f, -0.03081835f, 
    0.06771404f, -0.04623846f, -0.01854157f, 0.02322166f, 0.03958655f, -0.00558346f, -0.02154735f, -0.00737674f, 
    -0.08683855f, -0.00224494f, 0.04499065f, 0.04900627f, 0.05026243f, -0.15773103f, -0.04111698f, 0.09816924f, 
    -0.04069097f, -0.04646746f, 0.01409495f, -0.10547142f, 0.00110908f, -0.03159225f, -0.05950518f, 0.07283075f, 
    -0.20572919f, -0.00912273f, 0.00020978f, 0.00432463f, 0.10086434f, 0.10505565f, 0.04383342f, 0.10787854f, 
    0.11713395f, -0.19131631f, -0.12857351f, 0.07453086f, 0.08057286f, -0.01940996f, 0.05454871f, 0.08803588f, 
    -0.05436913f, 0.11015248f, 0.01004910f, 0.06757589f, 0.00564758f, 0.01586501f, 0.00756099f, 0.00500538f, 
    0.00978058f, 0.04054259f, 0.06024944f, -0.10449834f, -0.33801112f, -0.28072438f, -0.10807865f, 0.21793391f, 
    0.11384949f, -0.05079267f, 0.00467497f, 0.09202296f, -0.02232613f, 0.00234166f, -0.04112281f, -0.01311244f, 
    -0.01282797f, -0.00685166f, -0.16937476f, 0.09294726f, -0.05982940f, 0.05485914f, 0.01802408f, 0.09898591f, 
    -0.05114979f, -0.09009735f, -0.05268342f, 0.04635455f, 0.04150400f, 0.06036806f, -0.01863077f, 0.01491254f, 
    -0.03045015f, 0.12974523f, -0.04014077f, -0.07118922f, -0.01535450f, 0.06579437f, -0.01047551f, 0.02588068f, 
    -0.01388415f, -0.00737124f, 0.04226586f, -0.02004812f, -0.20697010f, -0.09515911f, -0.17571229f, 0.10022864f, 
    -0.02852237f, 0.01103491f, -0.00189506f, 0.00895260f, -0.02767310f, 0.02842182f, 0.07744236f, -0.02960802f, 
    -0.06930139f, -0.01938638f, 0.03460149f, -0.03905294f, -0.06739668f, 0.02367423f, 0.05486214f, 0.09503246f, 
    -0.13055938f, -0.09688344f, 0.09370879f, -0.00394227f, 0.02819748f, 0.11904436f, 0.01851214f, -0.02923954f, 
    -0.03708411f, 0.00141441f, -0.11415302f, -0.00782731f, 0.07901093f, 0.02704516f, -0.02711069f, -0.08551714f, 
    0.02854472f, -0.18497293f, -0.06089437f, -0.03214058f, -0.01908142f, 0.01161404f, 0.05962550f, -0.21445520f, 
    -0.12416313f, 0.01484113f, 0.04713914f, -0.03253129f, 0.02214438f, 0.04946204f, -0.02063582f, 0.05110464f, 
    0.03139710f, 0.03890216f, -0.05787998f, 0.00421607f, -0.05190021f, 0.04352895f, 0.03128866f, 0.05720559f, 
    0.07952685f, -0.42062244f, 0.03621184f, 0.13808882f, 0.12690213f, 0.01001560f, -0.00560820f, -0.03044154f, 
    -0.00906983f, -0.05534430f, -0.05748458f, -0.02647433f, 0.01006438f, 0.02508372f, 0.08335197f, 0.01698651f, 
    0.02469468f, -0.13895701f, -0.09941615f, 0.10235193f, -0.07417394f, -0.00900673f, 0.11923503f, -0.09612075f, 
    -0.15049392f, -0.09701528f, 0.05985725f, -0.00567687f, -0.08435985f, 0.00708556f, 0.03138786f, -0.07158321f, 
    0.00623633f, -0.05564610f, 0.05483671f, -0.01512549f, -0.02912565f, 0.09254061f, -0.06036407f, -0.02741753f, 
    0.17561135f, -0.02803260f, -0.14618163f, -0.00417948f, -0.03356631f, -0.00329741f, 0.04172369f, 0.03039187f, 
    0.02192219f, 0.05903140f, -0.06481240f, -0.04717737f, 0.02329296f, 0.00915431f, 0.07997392f, 0.01947203f, 
    -0.06337781f, 0.05369396f, 0.01551195f, 0.04298298f, 0.04270296f, -0.00866379f, -0.07032099f, 0.00874952f, 
    0.06564836f, -0.04524789f, -0.01285674f, 0.03853175f, -0.07560941f, 0.04822908f, 0.00067965f, 0.03245623f, 
    0.05478867f, -0.19119905f, -0.00218523f, 0.07403888f, -0.05812409f, -0.02118897f, 0.12019814f, 0.01697116f, 
    -0.00573878f, -0.04387654f, 0.03205280f, 0.07568225f, -0.07818153f, -0.06872709f, 0.04641707f, -0.01548730f, 
    0.03062137f, -0.02999864f, 0.08898395f, 0.00420571f, 0.03309945f, 0.00654177f, 0.06130667f, -0.07268760f, 
    0.03603127f, -0.08555994f, -0.02115832f, -0.02722304f, 0.17200753f, -0.06711348f, 0.10086593f, -0.07259057f, 
    -0.17299554f, 0.04524555f, 0.04973817f, 0.02326427f, -0.02023385f, 0.01534522f, -0.01501735f, 0.08504156f, 
    0.00938410f, -0.06866611f, 0.02652418f, -0.01329175f, 0.03914006f, -0.09100846f, 0.01171527f, -0.04752427f, 
    -0.19424671f, 0.02321404f, 0.12698671f, -0.14972986f, 0.01232569f, -0.02378601f, 0.06502432f, -0.01392720f, 
    0.03388629f, -0.01507355f, -0.01569779f, -0.00458746f, -0.00199083f, 0.02721289f, -0.02880477f, -0.01760204f, 
    0.00089928f, 0.04438158f, 0.03550081f, 0.00662634f, -0.21407664f, -0.19097996f, -0.09741855f, 0.14346291f, 
    0.06320595f, -0.01160061f, -0.00408268f, 0.03301516f, -0.04140837f, 0.06156018f, 0.06656481f, -0.01332961f, 
    -0.00878665f, 0.02434151f, 0.00590701f, 0.07029441f, -0.06974540f, -0.00374491f, 0.10208866f, 0.00321967f, 
    -0.21221077f, -0.21001117f, -0.06321558f, 0.01701383f, 0.09867688f, 0.04095603f, -0.03105620f, -0.06007394f, 
    -0.02699766f, -0.05570642f, 0.00663789f, -0.02743141f, -0.11412044f, 0.01639946f, -0.01135713f, 0.03788689f, 
    0.10543045f, 0.09348215f, 0.07549045f, 0.09092555f, 0.04563404f, 0.08592783f, 0.06653421f, 0.00635335f, 
    -0.01180929f, 0.01089736f, 0.02210481f, 0.00543113f, 0.02516012f, 0.01717893f, -0.02009612f, -0.00188782f, 
    -0.00926930f, -0.04876905f, -0.01389938f, 0.06580677f, -0.02646209f, -0.12958097f, -0.07838386f, 0.00467160f, 
    0.10072571f, 0.02184648f, -0.08802205f, 0.07676129f, -0.00629704f, -0.04162961f, -0.01486239f, -0.04411045f, 
    0.02402305f, 0.02413127f, 0.02244244f, 0.04646477f, -0.00023548f, -0.01490480f, 0.03965344f, -0.01650784f, 
    -0.00219595f, 0.01820765f, -0.01704209f, -0.06112623f, 0.12496032f, 0.11683684f, -0.03668531f, 0.07900960f, 
    -0.00353485f, -0.03002630f, -0.00761649f, 0.07446259f, -0.00820727f, 0.02294958f, 0.00867631f, 0.00582171f, 
    -0.00297128f, -0.04179069f, 0.03223043f, 0.02464478f, 0.00716847f, 0.02406224f, 0.05393320f, -0.00353584f, 
    -0.03471083f, -0.02449756f, 0.20221518f, 0.00609039f, -0.07140224f, 0.04835016f, -0.05210114f, -0.03005659f, 
    0.02195340f, 0.02522603f, 0.01097729f, 0.06101020f, -0.00538068f, 0.09025597f, 0.01045396f, 0.05084540f, 
    -0.01166545f, -0.02553895f, -0.09490131f, -0.08918400f, 0.02130771f, 0.00540024f, -0.11130222f, 0.04573141f, 
    -0.03126836f, -0.05157080f, -0.01396402f, -0.00808121f, -0.01367430f, -0.05858975f, 0.03032163f, -0.00902479f, 
    -0.00589632f, -0.12491791f, 0.04311224f, 0.04600929f, 0.06128711f, 0.05599809f, 0.04743587f, -0.02451716f, 
    0.05489388f, 0.04279860f, 0.06185656f, -0.02812664f, 0.01995129f, 0.02607848f, 0.07130922f, -0.00555341f, 
    0.04360750f, 0.00138217f, -0.02882112f, 0.06961349f, 0.05458599f, 0.01304962f, -0.01290344f, -0.06530196f, 
    0.07932815f, 0.08039595f, -0.05584066f, 0.04639208f, -0.28187108f, -0.23111519f, -0.19541769f, 0.01092472f, 
    0.00430226f, -0.01886618f, -0.06603426f, -0.11164102f, 0.02195985f, 0.04677782f, 0.03164311f, -0.05658884f, 
    -0.08524962f, -0.01705870f, -0.00003461f, 0.10781565f, 0.11221941f, 0.06339620f, 0.10970790f, 0.09925914f, 
    0.05390899f, 0.01342809f, 0.01394539f, -0.05539652f, 0.03514615f, 0.06048080f, 0.01416661f, 0.08864249f, 
    -0.09248046f, 0.06173782f, -0.00061961f, -0.02719746f, 0.03224488f, -0.01211676f, -0.02937213f, 0.02926595f, 
    0.05267493f, -0.02231220f, 0.07092585f, 0.05704254f, -0.12749900f, 0.00663054f, -0.09524968f, 0.02891135f, 
    -0.02970258f, 0.04141430f, -0.00737594f, 0.04959735f, -0.00134050f, 0.02257889f, 0.04242584f, -0.01978976f, 
    0.03722010f, -0.02926252f, -0.03970525f, -0.00877728f, 0.01220764f, -0.05928965f, 0.08824176f, 0.00127298f, 
    0.13798852f, 0.01176119f, 0.00464763f, -0.00378603f, 0.06563236f, -0.03229767f, 0.03150852f, -0.01991534f, 
    -0.01656683f, -0.02838323f, 0.02346277f, 0.05311706f, -0.01209916f, 0.00118163f, -0.03038601f, -0.08494563f, 
    0.09241825f, 0.04745273f, -0.05569389f, 0.09460030f, 0.17506590f, 0.08515222f, -0.13331185f, 0.04085087f, 
    -0.03984965f, -0.05593105f, -0.04831120f, -0.01805764f, 0.06042600f, -0.04835065f, 0.03318377f, -0.02275833f, 
    0.00233634f, -0.03687152f, -0.01401165f, -0.02193622f, -0.02899591f, 0.06193592f, -0.05685750f, 0.08706640f, 
    -0.08091985f, -0.18555877f, 0.02369147f, -0.00032143f, 0.09921055f, 0.06915119f, 0.06599916f, -0.03860005f, 
    0.05135654f, -0.04196501f, 0.04889492f, -0.00132069f, -0.00083868f, 0.03527723f, -0.00583634f, 0.09246464f, 
    0.08585861f, 0.01920513f, 0.01379269f, -0.00710859f, 0.31561136f, 0.17427884f, -0.06366884f, -0.01217200f, 
    0.05580163f, 0.03914731f, -0.04661072f, 0.03118676f, 0.02718004f, 0.05927094f, -0.11107665f, -0.01107371f, 
    0.04933778f, 0.00344484f, -0.00270584f, 0.02552573f, 0.05811514f, -0.07606918f, -0.14121409f, -0.02244356f, 
    0.18188532f, 0.10304422f, -0.10941618f, 0.08529504f, -0.09076333f, -0.06283992f, -0.05861484f, 0.07867906f, 
    0.03459304f, -0.05914440f, -0.02757242f, -0.04827845f, 0.05031032f, -0.03955327f, -0.05522566f, -0.01209045f, 
    0.00497193f, -0.03285539f, -0.02790793f, -0.06736881f, -0.31952557f, -0.01670455f, -0.07961219f, 0.17206050f, 
    0.08254813f, 0.04280261f, 0.03057495f, -0.02216551f, 0.03044233f, -0.06464518f, 0.03070181f, 0.09597066f, 
    -0.03118854f, -0.08029915f, 0.08355252f, 0.05076206f, -0.05726393f, -0.08181896f, -0.03555035f, -0.01109085f, 
    -0.21366079f, -0.20101133f, 0.02246967f, 0.02763030f, 0.13943286f, 0.02796298f, -0.05062350f, 0.09812435f, 
    -0.01254706f, 0.09421275f, 0.04115884f, -0.01617967f, -0.04060929f, -0.04844826f, 0.06124790f, -0.06943415f, 
    -0.04946852f, -0.14024489f, 0.05602266f, 0.00948862f, 0.02846899f, -0.05616769f, -0.03073289f, -0.04358695f, 
    0.05746770f, 0.03207630f, 0.00948327f, 0.00791138f, 0.03602275f, -0.03153246f, -0.02450082f, -0.00471072f, 
    -0.08403096f, 0.01671367f, -0.03226554f, -0.05093031f, -0.08788428f, -0.18303660f, 0.03855724f, 0.06632429f, 
    -0.35588136f, -0.17539077f, -0.07581828f, -0.04190529f, -0.04376492f, 0.09434601f, -0.01226190f, -0.07260323f, 
    -0.02413963f, 0.04847415f, 0.05977776f, 0.02011300f, 0.06599417f, -0.00763629f, -0.00258165f, 0.04895772f, 
    -0.05311029f, 0.06448334f, 0.04072010f, 0.02809405f, -0.07669495f, -0.12575704f, -0.18540978f, -0.13130964f, 
    -0.01169377f, -0.00714447f, 0.01689862f, -0.07504996f, -0.10377606f, -0.09654928f, -0.06643622f, -0.06080681f, 
    -0.08972486f, -0.04032780f, -0.00472841f, -0.11027173f, 0.00849059f, 0.11894061f, 0.04403140f, 0.03549278f, 
    -0.41428101f, 0.12404931f, -0.06634831f, -0.08333985f, 0.02092232f, 0.09271695f, 0.00987105f, -0.03858953f, 
    -0.03780970f, 0.02644316f, 0.04599844f, -0.04433763f, -0.00113198f, -0.11505010f, 0.01815784f, -0.03282905f, 
    -0.01709380f, 0.02353115f, -0.06620207f, 0.03189499f, 0.02974543f, 0.05117496f, 0.03582568f, 0.05578847f, 
    0.16172011f, -0.02936590f, 0.06518203f, -0.06718329f, 0.02440649f, 0.00778177f, 0.03186581f, 0.03107483f, 
    0.04588575f, 0.02215153f, 0.09685735f, -0.03056835f, 0.09289404f, 0.05857246f, -0.05996548f, 0.04148021f, 
    -0.27152726f, 0.03819621f, -0.03361714f, 0.02895009f, -0.00588832f, 0.05038504f, -0.01610227f, -0.04662383f, 
    0.01006147f, -0.00164468f, 0.06379037f, 0.04146762f, 0.03504810f, -0.01309161f, 0.01357276f, -0.00193316f, 
    0.04709049f, 0.06505337f, -0.01173030f, 0.07062839f, 0.13534974f, -0.01609075f, -0.02361721f, -0.01402391f, 
    -0.07934241f, -0.08813494f, -0.07348117f, -0.02310565f, 0.06870679f, -0.00311408f, -0.07081014f, -0.01209003f, 
    -0.06390441f, -0.04659019f, 0.03428974f, 0.01372498f, 0.04373430f, 0.08798777f, 0.01825380f, -0.01635198f, 
    0.04316474f, -0.06205732f, 0.00707222f, -0.01034501f, 0.05843175f, 0.06473386f, 0.06201920f, 0.00395360f, 
    -0.02496640f, -0.00989624f, 0.02826044f, 0.03669680f, -0.05751804f, -0.01740148f, -0.00799775f, -0.02727506f, 
    -0.01463098f, -0.14604858f, -0.10448864f, 0.01057313f, -0.15037666f, -0.05725875f, -0.06756749f, -0.09752211f, 
    -0.02296213f, 0.04087396f, 0.05290728f, -0.02241070f, -0.06720968f, 0.06258853f, -0.03267540f, 0.00897737f, 
    0.06086910f, -0.02089804f, -0.01007340f, -0.03060745f, -0.04399523f, -0.07601398f, 0.02304704f, 0.03329773f, 
    -0.18631470f, -0.22745149f, 0.05373738f, 0.05153261f, 0.24324933f, 0.01458014f, 0.06635080f, 0.08629382f, 
    -0.01123837f, -0.08834738f, 0.02694117f, 0.02108856f, -0.00134117f, 0.01376569f, 0.01882983f, -0.02455695f, 
    -0.00676426f, -0.03613111f, 0.00862691f, 0.02672082f, 0.22263913f, 0.12617671f, -0.04068317f, 0.05267092f, 
    -0.06918950f, -0.16182572f, -0.11916617f, -0.01651517f, -0.00383131f, -0.08626591f, -0.02704556f, 0.00273487f, 
    -0.04369205f, -0.03039003f, -0.07606206f, -0.02466271f, -0.04712426f, 0.04316029f, -0.02327992f, -0.07091202f, 
    -0.41268998f, -0.11098512f, 0.12391298f, -0.08822156f, -0.27035484f, 0.01348550f, 0.07265952f, -0.05764866f, 
    -0.08147667f, 0.05612924f, -0.00323327f, 0.00401830f, 0.02689546f, -0.04690140f, 0.02492448f, -0.05662071f, 
    0.04251636f, -0.01630859f, -0.01727064f, 0.03251893f, -0.47104010f, -0.28589272f, 0.18165043f, -0.02557920f, 
    -0.24929617f, 0.02295105f, 0.02381929f, 0.05506410f, -0.01631048f, 0.01124195f, 0.01530334f, 0.06567606f, 
    0.02896456f, 0.03579368f, 0.02084797f, -0.03918918f, 0.00830552f, -0.14613283f, -0.18767089f, -0.13651688f, 
    -0.28146088f, -0.12513176f, -0.10199624f, -0.03016771f, -0.03048707f, 0.00098195f, 0.03662287f, 0.01387505f, 
    0.00296965f, 0.02671363f, 0.00993496f, 0.00969258f, -0.06839924f, -0.02003887f, 0.00290810f, 0.08963196f, 
    -0.03780800f, 0.04537182f, -0.04991432f, 0.07216984f, 0.10742300f, 0.09455866f, 0.02239199f, -0.00205831f, 
    0.00292069f, 0.07812756f, -0.03353460f, 0.01422822f, 0.00098711f, 0.03756259f, -0.03964017f, 0.02857923f, 
    0.01260930f, 0.01684283f, 0.01261486f, 0.07508826f, 0.00987762f, 0.06863406f, -0.02774535f, -0.01806728f, 
    -0.33570856f, 0.02084700f, -0.18672165f, -0.09369082f, -0.01806876f, 0.07385708f, -0.00113099f, -0.06641596f, 
    -0.04911040f, 0.03171341f, -0.00426691f, -0.00600176f, -0.08623579f, 0.02858197f, 0.04645563f, 0.05392860f, 
    -0.00350047f, 0.07273967f, -0.00136989f, 0.04923408f, -0.39559472f, -0.14828829f, 0.05664284f, -0.19894955f, 
    -0.28585085f, 0.01988921f, -0.03828267f, 0.01679318f, -0.10154323f, 0.03299552f, -0.00319665f, 0.01175187f, 
    -0.02607774f, 0.13955627f, -0.02522494f, -0.02640990f, -0.05494617f, -0.01668702f, -0.09506723f, -0.05111343f, 
    -0.37926453f, -0.27158728f, -0.13108142f, -0.13789731f, -0.16337040f, 0.01259435f, 0.03122319f, -0.01763006f, 
    -0.03081954f, 0.04444471f, 0.05210437f, 0.01367316f, -0.00656071f, 0.08133812f, -0.01608005f, 0.04438506f, 
    0.02473002f, 0.02527522f, 0.07853843f, 0.04151524f, 0.17928119f, 0.17985003f, 0.15155226f, 0.00851572f, 
    0.00966698f, 0.11859404f, -0.03075009f, 0.02837832f, 0.01821711f, -0.03970709f, -0.08822583f, 0.01759849f, 
    0.02846559f, 0.03609603f, 0.01143483f, 0.02577630f, 0.02818148f, -0.04677885f, -0.00539645f, -0.02774766f, 
    -0.40758500f, -0.17247276f, 0.14631009f, 0.05319377f, -0.15347907f, 0.04082910f, -0.03009364f, -0.05896617f, 
    -0.06871806f, 0.03244628f, 0.02022552f, 0.01953943f, 0.08854643f, -0.07198197f, 0.10177357f, -0.03561496f, 
    0.01323297f, 0.02081223f, -0.00714417f, 0.09368795f, -0.32128766f, -0.12975611f, -0.12217375f, -0.09970204f, 
    -0.15128309f, 0.06165127f, -0.00897618f, -0.09283193f, -0.01914669f, -0.01665136f, -0.07640337f, 0.06675103f, 
    -0.06858519f, 0.14379258f, -0.00454661f, 0.00996874f, 0.07019968f, 0.11785173f, 0.03774761f, 0.06307387f, 
    -0.00752230f, 0.03102240f, -0.02296965f, 0.03022799f, -0.13271132f, 0.02995468f, -0.01208979f, 0.00059379f, 
    0.05876252f, 0.03919692f, 0.12011047f, -0.03183557f, 0.00450516f, 0.00584150f, 0.02237895f, 0.00333797f, 
    -0.00046636f, -0.02579319f, 0.12256562f, 0.04425737f, 0.12556247f, 0.00446877f, -0.00091328f, 0.06272986f, 
    -0.01389033f, 0.01083187f, 0.03654514f, 0.05096081f, -0.00969631f, 0.07770050f, -0.00764290f, 0.02061648f, 
    0.00262262f, 0.01433091f, -0.04039699f, 0.06011092f, 0.03861474f, -0.07761742f, -0.02665682f, -0.00268412f, 
    -0.34771034f, -0.09633567f, -0.31806815f, -0.11220933f, -0.01537119f, -0.00072396f, 0.01324199f, -0.10194711f, 
    0.00365215f, 0.00797028f, 0.05946240f, -0.01460343f, -0.00570548f, -0.09111331f, 0.07436877f, -0.07780345f, 
    0.01197488f, 0.07000733f, 0.06370220f, -0.03735043f, 0.13761826f, 0.02486670f, -0.04450482f, 0.04312723f, 
    -0.03508532f, -0.09829238f, -0.04480344f, -0.03730735f, -0.03230400f, -0.05172950f, -0.01075198f, 0.02513027f, 
    -0.01643080f, -0.03928941f, -0.04941826f, -0.06040279f, -0.01020229f, 0.01089773f, -0.07029349f, -0.02749970f, 
    0.00392245f, 0.06096448f, -0.22371632f, 0.04692971f, -0.01566488f, -0.07831447f, 0.04104588f, 0.02041349f, 
    0.03574605f, -0.01706656f, 0.06975450f, 0.06359059f, 0.06693361f, -0.06240812f, 0.03318303f, 0.01925374f, 
    0.02662333f, 0.00574390f, -0.03456252f, 0.04762612f, -0.24475521f, -0.06085083f, 0.07468184f, 0.00272465f, 
    -0.08559131f, 0.02488206f, -0.00738725f, -0.02742901f, -0.04249708f, 0.01107899f, 0.01048886f, 0.04222671f, 
    0.05297248f, 0.03368058f, 0.07644525f, -0.00041479f, -0.00470888f, -0.04358556f, -0.03585400f, 0.00206926f, 
    -0.19692571f, 0.00736125f, -0.14084564f, -0.08699757f, -0.00040170f, 0.06479834f, 0.04227073f, -0.10269296f, 
    -0.00105671f, 0.05927859f, 0.03057795f, 0.01081781f, 0.04971661f, -0.04043565f, -0.00583854f, -0.05123804f, 
    -0.00467038f, 0.10993536f, 0.08129732f, 0.07263851f, -0.38394383f, 0.02667101f, -0.26813850f, -0.08765137f, 
    0.02082670f, 0.09988621f, -0.00294876f, -0.10374285f, -0.02381237f, 0.02125552f, 0.02545614f, 0.00702008f, 
    -0.04707082f, -0.04921633f, -0.00021347f, -0.12353099f, -0.06744834f, 0.07192745f, 0.07891168f, -0.00000516f, 
    -0.01250315f, -0.05049725f, -0.09653606f, -0.05428258f, 0.01396808f, -0.01807340f, -0.00848650f, 0.00504009f, 
    -0.03920302f, -0.07402039f, 0.03446318f, 0.00695386f, -0.06668209f, -0.04987673f, 0.06951450f, -0.01060037f, 
    -0.02579531f, 0.01068721f, 0.11907907f, 0.01324396f, -0.15991868f, 0.01069247f, 0.13705903f, 0.03235177f, 
    0.07073193f, -0.01906140f, 0.00091512f, 0.03006957f, -0.01099518f, 0.08091433f, -0.05708435f, 0.02685948f, 
    0.04713206f, 0.00889834f, 0.00916699f, -0.08111805f, -0.01592971f, 0.01732583f, 0.07467747f, 0.01708970f, 
    -0.00770101f, 0.02266005f, -0.08269557f, -0.00086538f, -0.02955675f, 0.00459651f, -0.00161956f, 0.01177840f, 
    -0.02831743f, -0.01398544f, -0.02019192f, -0.01912505f, 0.06002812f, -0.06840135f, 0.02012051f, -0.00262491f, 
    0.00479378f, 0.02926953f, 0.10033931f, 0.04034830f, 0.14833367f, -0.02068813f, -0.02031422f, 0.02956527f, 
    -0.08609181f, 0.02780254f, 0.12203692f, -0.00908425f, -0.00290642f, 0.00292783f, 0.00952939f, 0.10191157f, 
    0.03551668f, -0.04415259f, -0.03689846f, -0.01526635f, 0.01593473f, -0.07594264f, -0.16235945f, -0.07318220f, 
    0.09523965f, 0.04433414f, 0.01134388f, 0.03382268f, -0.08328293f, 0.01624227f, -0.11868292f, 0.03154164f, 
    -0.03136573f, 0.02320581f, 0.04849508f, -0.04286016f, 0.00350668f, 0.03219133f, -0.02477453f, -0.01736201f, 
    -0.02707987f, 0.01924425f, 0.02446330f, -0.04675677f, 0.11371179f, 0.05446688f, -0.10026610f, 0.03265027f, 
    -0.02267194f, -0.04285476f, -0.07989851f, 0.05000557f, -0.06062426f, 0.01107321f, -0.04602930f, -0.03421411f, 
    0.07319921f, -0.05233512f, -0.00733476f, 0.01917521f, 0.03640272f, -0.09343281f, 0.03890524f, 0.05601725f, 
    0.17695685f, 0.06588464f, -0.10482383f, 0.04580063f, -0.04178807f, -0.11233696f, -0.05927186f, -0.02480706f, 
    0.00239406f, -0.02275187f, 0.01586008f, 0.04597380f, -0.02910000f, -0.08778173f, -0.08165428f, -0.06119874f, 
    -0.00556728f, -0.04590005f, -0.06850835f, -0.06701229f, 0.05138503f, -0.03544543f, -0.03433859f, 0.00586719f, 
    0.07109710f, 0.02769992f, 0.04056085f, -0.02194672f, 0.04528445f, -0.03335634f, -0.03634311f, -0.04943949f, 
    -0.02483736f, -0.05574791f, -0.01886124f, 0.04469313f, 0.10408320f, 0.01196101f, -0.00016466f, 0.07629269f, 
    -0.28177741f, 0.08664578f, -0.05370248f, -0.07009373f, -0.03554840f, 0.04523942f, 0.04583127f, -0.05083926f, 
    -0.04109716f, 0.05235857f, 0.01926672f, 0.02697825f, 0.00205237f, -0.04980069f, 0.01513947f, -0.04198461f, 
    0.06060406f, 0.08319886f, 0.04216495f, 0.09146339f, 0.00531582f, 0.12977953f, 0.07291027f, -0.09053548f, 
    -0.07006447f, 0.02037160f, 0.06263584f, 0.01058198f, 0.06633758f, 0.05346514f, -0.02872504f, 0.05779945f, 
    0.01560731f, 0.03355098f, 0.04757132f, 0.09159885f, 0.09137670f, 0.03208910f, 0.00316417f, 0.02641297f, 
    -0.29296857f, -0.00553576f, -0.13811478f, 0.02851546f, 0.08261310f, 0.01858920f, 0.00439637f, -0.10347499f, 
    -0.03012313f, 0.08208111f, 0.03425518f, 0.08577880f, -0.02402968f, -0.08319971f, 0.09890498f, 0.04204322f, 
    -0.01754794f, 0.02679549f, -0.07836409f, 0.03303392f, -0.20155376f, -0.04492342f, -0.03209469f, -0.04648825f, 
    -0.03823962f, 0.10848662f, -0.02246414f, 0.02254869f, -0.02194640f, -0.03941600f, -0.01385277f, 0.02066139f, 
    0.02735260f, 0.09651075f, 0.02341858f, 0.01736918f, 0.04841939f, 0.02054417f, -0.01336729f, 0.00199236f, 
    0.16983289f, 0.00636214f, -0.00564298f, -0.00893976f, 0.00595076f, -0.17147680f, -0.16445456f, -0.01097518f, 
    0.03152804f, -0.07412493f, -0.02005196f, 0.05674518f, -0.06187066f, -0.05411122f, -0.14926052f, -0.04776643f, 
    0.00100116f, -0.08592200f, -0.07459850f, -0.10170401f, 0.22065462f, 0.23135433f, 0.06213106f, -0.05240785f, 
    -0.03794957f, 0.04746181f, -0.05834426f, 0.03166695f, 0.06321617f, -0.05124142f, -0.04228877f, -0.03376023f, 
    0.08272831f, -0.01469633f, 0.00482826f, 0.05834039f, 0.11000159f, -0.04151207f, -0.02110866f, 0.09184168f, 
    0.06503945f, 0.03723080f, 0.01591216f, -0.07316366f, 0.00950389f, 0.11123481f, 0.01258394f, -0.02773472f, 
    0.02484298f, -0.00735837f, 0.00373772f, -0.01491673f, -0.02413619f, 0.05251394f, -0.00568985f, 0.01742872f, 
    0.02263181f, -0.01348715f, 0.02104945f, 0.09943802f, -0.34409776f, -0.02846084f, -0.05331554f, -0.06071986f, 
    -0.07397368f, 0.06856656f, -0.01870908f, -0.05333928f, -0.05320714f, 0.00063592f, -0.01862853f, 0.03662083f, 
    -0.03934564f, 0.09160486f, -0.01189890f, 0.00559321f, -0.02225178f, 0.08111687f, 0.00477230f, -0.02390795f, 
    0.13234992f, -0.01180838f, 0.05752862f, 0.10364441f, 0.01398358f, 0.04093166f, 0.00811459f, -0.00391559f, 
    0.05816569f, 0.00338192f, 0.00809553f, 0.05860070f, -0.00291171f, 0.02132741f, -0.00640313f, -0.02368520f, 
    -0.00382899f, -0.20203437f, -0.01115971f, -0.04508252f, 0.18572417f, 0.05042698f, -0.04098741f, 0.05551591f, 
    -0.11835577f, -0.05409959f, -0.08230774f, 0.03777594f, 0.02282738f, 0.02699106f, 0.03272589f, -0.00491021f, 
    -0.01707907f, -0.06283595f, -0.05681193f, -0.02495806f, -0.02549648f, -0.08154018f, -0.03567762f, -0.06511123f, 
    -0.11144907f, 0.19770074f, 0.02823354f, 0.08705052f, 0.01579218f, 0.19999748f, 0.09808959f, 0.03864083f, 
    -0.04686203f, 0.05912968f, 0.01789422f, 0.04834187f, 0.02178113f, 0.00816193f, -0.00528316f, -0.08150613f, 
    -0.01957671f, -0.04790960f, -0.00462996f, 0.06665049f, -0.07483898f, 0.06258883f, -0.03364450f, -0.01588095f, 
    0.33088523f, 0.11344055f, -0.04893314f, 0.01344391f, 0.00207448f, -0.03920015f, -0.00717800f, -0.07199565f, 
    -0.00722942f, 0.05861580f, 0.01983371f, 0.01244376f, 0.02575158f, 0.00766188f, 0.03019982f, -0.03690196f, 
    -0.11764249f, -0.01849151f, -0.00053806f, 0.01668545f, -0.06397232f, -0.01694045f, 0.01021215f, -0.01469345f, 
    0.04941153f, -0.04608728f, -0.09122909f, 0.04651193f, 0.06214523f, 0.04583971f, -0.01112314f, -0.02134627f, 
    -0.00531934f, 0.01259466f, -0.12451147f, -0.02444078f, 0.08822026f, -0.18097173f, 0.06503322f, -0.01250481f, 
    -0.00105990f, 0.03808975f, 0.01309319f, 0.03144756f, 0.01967375f, 0.01792255f, -0.05178904f, -0.05606809f, 
    -0.00310884f, 0.01240429f, -0.05813855f, -0.05822811f, -0.02823984f, -0.07420985f, -0.02376569f, -0.02433144f, 
    0.29382864f, 0.10895310f, -0.15225382f, -0.04599432f, -0.05036472f, -0.05045088f, 0.01740125f, -0.05658346f, 
    0.03685140f, -0.04622995f, 0.12765092f, 0.01173454f, 0.01049447f, 0.02849070f, 0.02379242f, 0.06842428f, 
    0.03181245f, 0.01942342f, 0.00076254f, 0.07818973f, -0.01412435f, -0.12318239f, 0.00427898f, -0.02095095f, 
    -0.10981906f, 0.04771621f, 0.04098462f, -0.00207544f, 0.06604436f, 0.05958786f, -0.14137395f, -0.02739723f, 
    -0.01547056f, 0.02243142f, 0.00761715f, -0.10511412f, 0.05843246f, 0.03096133f, -0.06896343f, -0.02240667f, 
    -0.17682569f, 0.20357110f, 0.04598692f, -0.04014235f, -0.02199601f, -0.04472660f, -0.00268088f, 0.03399939f, 
    -0.15939674f, -0.00163265f, -0.04162857f, -0.03760548f, -0.01669984f, -0.11483794f, -0.03571786f, 0.02523093f, 
    0.05662685f, -0.03030405f, 0.00882681f, -0.00803501f, 0.25957817f, -0.10606068f, -0.13932507f, 0.04472708f, 
    -0.11348771f, 0.05366997f, -0.04038641f, 0.05944825f, -0.00251265f, 0.04420854f, -0.08533289f, -0.09371831f, 
    0.04055558f, -0.03417197f, 0.02071124f, -0.06938663f, -0.07556114f, 0.02949908f, -0.05918567f, -0.05378350f, 
    0.09065515f, -0.12718853f, -0.12405319f, 0.16007341f, -0.00887182f, 0.10895512f, 0.01778901f, -0.02208828f, 
    0.07520161f, 0.01867904f, 0.09403747f, 0.04630206f, 0.00611848f, 0.04960042f, -0.00974093f, 0.03274995f, 
    0.01016259f, 0.00562280f, -0.00051366f, -0.01863552f, 0.06454305f, -0.22312079f, -0.02613132f, 0.08872766f, 
    -0.04900566f, 0.04986380f, 0.04541891f, -0.01918854f, -0.06323741f, 0.02238335f, -0.01904334f, 0.00445542f, 
    -0.06677281f, -0.02498253f, -0.03250938f, -0.04480170f, 0.09273904f, 0.02345369f, -0.09233140f, -0.08266431f, 
    -0.34629050f, 0.25352713f, 0.01960860f, 0.03057619f, 0.03430140f, 0.03505119f, -0.05661155f, 0.01448477f, 
    -0.05936086f, 0.01070353f, -0.02942787f, -0.01145400f, 0.02336987f, -0.05769514f, -0.05526327f, -0.02034326f, 
    0.02244990f, -0.02128964f, 0.02804760f, -0.05731766f, -0.44008636f, 0.15440276f, -0.04170375f, -0.03961087f, 
    0.06274584f, -0.01000102f, 0.02442822f, 0.03497425f, 0.03872261f, 0.02049227f, -0.01511819f, -0.00238877f, 
    0.06068550f, -0.01512104f, 0.03024238f, -0.04175095f, -0.13420987f, 0.05457929f, -0.13423300f, -0.01656819f, 
    0.01842757f, 0.13996123f, -0.07208504f, 0.03805361f, 0.11684743f, 0.07206401f, 0.02792824f, -0.02833713f, 
    -0.04604072f, -0.00355737f, 0.05015207f, 0.08203946f, 0.00159439f, -0.00470826f, 0.05510838f, -0.03826167f, 
    -0.01110189f, 0.05350376f, -0.11138070f, 0.05312728f, -0.17523487f, -0.02720369f, -0.06016654f, -0.12706968f, 
    -0.05408197f, -0.16654915f, -0.01773561f, 0.09503332f, 0.03990917f, -0.06837763f, 0.10076957f, -0.15134326f, 
    -0.11351406f, 0.02777148f, -0.03486786f, 0.01595368f, -0.05515220f, 0.00962980f, 0.16328585f, 0.02108621f, 
    0.15095864f, -0.03873274f, -0.00557022f, 0.04431540f, -0.02815541f, 0.00960646f, 0.01383240f, 0.04642460f, 
    -0.03136384f, -0.03819092f, 0.01310509f, -0.06129018f, -0.02123838f, 0.04486987f, -0.02379067f, 0.00122841f, 
    -0.01866628f, 0.03154284f, -0.08782561f, -0.02704628f, -0.23730552f, -0.01154777f, -0.07568348f, 0.06846736f, 
    0.06262125f, -0.03819602f, 0.09359791f, -0.10740809f, 0.00124394f, -0.10328566f, 0.07979853f, -0.06378329f, 
    0.00036833f, 0.03974580f, 0.04410884f, 0.07629991f, 0.05788570f, -0.04374193f, -0.07737233f, 0.00433851f, 
    -0.00788429f, 0.01084942f, 0.02310318f, 0.08182900f, 0.01188518f, 0.01023346f, -0.15978278f, 0.03012926f, 
    0.00914071f, 0.00608274f, -0.03404371f, 0.07140191f, -0.01799912f, -0.06550976f, 0.05546342f, -0.08780170f, 
    0.07176892f, -0.05612731f, -0.00108486f, 0.01265985f, 0.18265621f, -0.31928509f, -0.01074819f, 0.00634633f, 
    0.06468856f, -0.07110743f, -0.05279903f, -0.01072611f, 0.03857574f, -0.07079206f, 0.00325472f, 0.02664487f, 
    -0.02620242f, 0.05338179f, -0.16932929f, 0.06214171f, -0.05070961f, 0.00201995f, 0.08977140f, -0.02221060f, 
    0.24635430f, -0.11292391f, -0.21850291f, 0.11313371f, -0.11840753f, -0.00974205f, 0.00709210f, -0.04946963f, 
    -0.02478602f, 0.02059064f, 0.01295479f, 0.00674482f, -0.01401831f, 0.07225017f, 0.03380765f, 0.01948596f, 
    0.00241891f, -0.05546409f, -0.02106744f, 0.01233938f, -0.27981922f, -0.49104887f, -0.06011319f, -0.07677261f, 
    -0.18693101f, 0.00742895f, 0.08127391f, 0.05229789f, 0.02468321f, 0.12645748f, -0.05347479f, 0.05135498f, 
    -0.04569157f, -0.04043659f, -0.03261770f, -0.05554899f, -0.07837503f, -0.08861411f, -0.09484871f, -0.05151753f, 
    -0.17850085f, -0.09876418f, 0.05314252f, 0.00713927f, 0.06616931f, -0.13526137f, 0.16225290f, 0.05503215f, 
    0.01267834f, -0.02598366f, 0.04006581f, -0.09491789f, -0.00954225f, 0.04442099f, -0.00391415f, -0.02755983f, 
    -0.03392969f, -0.05585396f, 0.03021734f, 0.07546186f, -0.21356264f, 0.07071518f, 0.04396723f, -0.02368875f, 
    -0.00991273f, -0.10644885f, 0.10563795f, -0.03010140f, 0.00422440f, 0.03104246f, -0.08156041f, -0.01544033f, 
    -0.09117936f, -0.06830186f, -0.01600124f, -0.01399742f, 0.10326159f, 0.05180355f, -0.03706784f, 0.01952348f, 
    0.08222857f, -0.05186294f, 0.08116914f, 0.09469368f, 0.10334511f, -0.00593361f, 0.06371935f, -0.02543587f, 
    0.03098584f, -0.00992042f, 0.00885013f, -0.06558575f, 0.01253039f, 0.03641455f, 0.07889067f, 0.00650201f, 
    0.02217718f, 0.00938969f, 0.04580786f, 0.00213113f, -0.08052724f, -0.11968478f, 0.00498854f, -0.03288443f, 
    0.03008128f, 0.03300681f, 0.05129533f, -0.01207512f, -0.03055526f, 0.00048813f, -0.08439516f, 0.02356942f, 
    0.01442548f, -0.04093492f, -0.11072820f, 0.00185333f, -0.02057291f, 0.03263027f, -0.16967100f, -0.07654031f, 
    -0.00291695f, 0.13313909f, -0.06397521f, -0.06917164f, 0.00591505f, 0.04512786f, -0.11003705f, -0.02375222f, 
    -0.06361488f, -0.06860027f, 0.00679992f, -0.02144375f, 0.04804824f, 0.01281876f, -0.01610048f, 0.07874494f, 
    0.00794716f, -0.05196895f, 0.03449170f, 0.02755413f, 0.17524637f, -0.11751706f, -0.14201866f, 0.18468645f, 
    -0.12279646f, 0.09641335f, 0.01633986f, -0.01206565f, -0.00803653f, -0.07408350f, 0.12214991f, -0.02871651f, 
    0.00219534f, 0.02775826f, -0.01811469f, 0.04329699f, -0.00801498f, 0.01685918f, -0.04054987f, 0.04856225f, 
    -0.10684472f, 0.33491871f, -0.10730744f, 0.11780263f, 0.16077548f, 0.07938381f, -0.06092240f, 0.04490326f, 
    -0.05763184f, -0.02429433f, 0.02416028f, 0.07340039f, 0.03608663f, 0.00798051f, 0.01601895f, -0.04438321f, 
    0.07435454f, 0.01150299f, -0.03075993f, 0.05185246f, -0.08221617f, -0.07687536f, 0.03541070f, -0.03629789f, 
    0.00160079f, -0.03743748f, 0.08179077f, 0.04570326f, 0.00867347f, -0.06496807f, -0.08231368f, -0.07519894f, 
    0.02121617f, 0.05054465f, -0.05210824f, -0.04636421f, -0.03771476f, -0.01663215f, -0.13365509f, 0.01001919f, 
    0.11508375f, -0.29791012f, -0.11166789f, -0.15340909f, 0.18412445f, -0.04802490f, -0.02769217f, -0.02625790f, 
    0.03819575f, 0.07355057f, 0.01145092f, -0.06524309f, -0.01837580f, 0.01928139f, -0.00344161f, 0.06333257f, 
    0.05893949f, 0.01538471f, 0.04282108f, -0.07900877f, 0.01532633f, 0.28620651f, -0.09400603f, -0.16882759f, 
    0.18123506f, 0.11270086f, -0.14114451f, -0.06477033f, 0.06105808f, -0.00904444f, 0.04985145f, 0.05313694f, 
    -0.07025121f, -0.07828251f, -0.00164257f, 0.03159383f, 0.05271267f, 0.11105891f, -0.00744064f, 0.01539355f, 
    0.10772780f, 0.10268613f, -0.10833693f, -0.12192777f, -0.09787821f, 0.02049383f, -0.07075401f, -0.04174086f, 
    0.06261034f, 0.06984118f, 0.05220517f, -0.00998479f, -0.08177689f, 0.00142019f, 0.00141280f, 0.06298467f, 
    -0.00980118f, 0.00071312f, -0.03058437f, 0.00780608f, 0.15880744f, 0.12322043f, -0.03332897f, -0.06618359f, 
    -0.05696110f, -0.05095308f, -0.00124810f, 0.04776854f, 0.01322624f, 0.03950540f, -0.07294583f, -0.00740388f, 
    -0.01047312f, -0.03354008f, 0.08748461f, 0.05748466f, -0.03581527f, -0.02735912f, 0.03695468f, -0.04748478f, 
    0.24671876f, -0.00874906f, -0.12445009f, -0.07494006f, -0.10083540f, -0.05453161f, 0.03043881f, -0.04211969f, 
    0.05754929f, 0.04759025f, 0.02769008f, -0.03471538f, 0.00416742f, -0.00594269f, 0.04656016f, -0.00621967f, 
    -0.00982091f, -0.03037015f, -0.01264579f, 0.01156321f, 0.38834926f, 0.17325799f, -0.19838333f, -0.19469555f, 
    -0.00023852f, -0.05013161f, -0.03758196f, -0.00177824f, 0.01174688f, 0.01195164f, 0.08131463f, -0.02518565f, 
    -0.00122186f, -0.02619036f, 0.02130665f, -0.02949224f, -0.07482412f, -0.00285645f, -0.00768699f, 0.02767990f, 
    0.36856186f, -0.08992868f, -0.14302619f, -0.03216774f, -0.12274573f, 0.01694954f, -0.00944591f, 0.00825910f, 
    -0.01889968f, 0.01802309f, 0.07412112f, 0.02572880f, 0.00031160f, 0.02630228f, -0.02386571f, 0.00373282f, 
    -0.04408741f, -0.02577828f, -0.03508511f, -0.02432769f, 0.15052764f, 0.03755470f, -0.06464854f, -0.10977865f, 
    0.14372422f, 0.03222119f, 0.06691889f, -0.02038326f, 0.10880264f, -0.06217532f, 0.01638496f, -0.00890211f, 
    -0.06249804f, 0.02348538f, 0.02437146f, 0.02235612f, -0.03050187f, 0.01702718f, -0.02298078f, 0.04512831f, 
    -0.04405103f, -0.24922027f, -0.05700434f, -0.05054356f, 0.17471589f, 0.09476484f, -0.11095268f, 0.01687534f, 
    0.03244181f, 0.07388902f, -0.00716944f, 0.00737484f, -0.02226641f, 0.07846651f, 0.01924544f, 0.04533735f, 
    0.09296221f, -0.01524481f, -0.01768163f, -0.13514633f, 0.34784093f, -0.10177739f, -0.08475327f, -0.11662109f, 
    -0.12848705f, 0.03157414f, 0.05483488f, -0.01439361f, 0.07008638f, 0.05211217f, 0.10258623f, -0.03739600f, 
    0.01016063f, -0.05730351f, 0.05503042f, 0.03095742f, -0.09960863f, -0.00561636f, 0.00743899f, 0.04516894f, 
    0.00354507f, -0.22522675f, 0.07978509f, 0.01984932f, -0.02423190f, 0.02107527f, 0.02952754f, 0.01173946f, 
    -0.02494328f, -0.02114576f, -0.02290208f, -0.01526289f, -0.03543773f, -0.05778158f, -0.08280145f, -0.08808965f, 
    -0.02000403f, -0.02033206f, -0.01149986f, -0.01811991f, 0.04542456f, 0.07218898f, -0.09149113f, -0.06743198f, 
    -0.06266300f, -0.11986842f, -0.10494604f, 0.00357585f, -0.00960485f, -0.08512371f, 0.03671306f, 0.04876959f, 
    0.01053868f, -0.03203762f, -0.03385435f, 0.07884926f, -0.01674234f, 0.00396013f, 0.08621720f, -0.05529010f, 
    -0.14026478f, -0.12041069f, -0.15014806f, -0.02408409f, -0.28106010f, -0.05917552f, 0.03103225f, -0.00996096f, 
    0.00796311f, 0.06614918f, -0.07951726f, 0.03451827f, 0.01383526f, -0.00289824f, 0.01135810f, 0.04976704f, 
    -0.00709912f, -0.08776225f, -0.04733324f, -0.05786715f, -0.00788832f, 0.02089719f, 0.06231416f, -0.03463847f, 
    -0.02278004f, -0.01273878f, -0.01553866f, -0.00542598f, -0.02637845f, -0.06931093f, -0.01155861f, -0.04738780f, 
    0.04442573f, 0.00477936f, -0.00051138f, -0.00436533f, 0.05082617f, -0.03863415f, -0.03182683f, 0.01203539f, 
    -0.28767979f, 0.07691511f, 0.05256653f, -0.01892683f, 0.05815579f, -0.07683314f, -0.00228925f, 0.00454031f, 
    0.08142480f, 0.07678092f, -0.02431606f, -0.00119804f, 0.04411929f, 0.00774985f, -0.02114443f, 0.04306374f, 
    -0.11336422f, -0.02282003f, -0.05846354f, 0.03554303f, -0.16513331f, 0.20346271f, -0.02673629f, -0.19815944f, 
    0.18849459f, 0.03902648f, -0.09339429f, 0.01441796f, 0.05686929f, 0.05524150f, 0.02378494f, 0.01708029f, 
    0.04806005f, -0.00523557f, 0.01943223f, 0.01569648f, 0.06204261f, 0.01658138f, -0.03224610f, -0.00614406f, 
    -0.06041184f, -0.08887049f, -0.03300969f, -0.03848429f, 0.02807516f, 0.01085395f, 0.08761117f, -0.04811418f, 
    0.03185322f, -0.00398929f, -0.02073922f, 0.02525890f, 0.00956739f, 0.07198927f, 0.00064028f, 0.04067233f, 
    0.00332893f, -0.03057731f, -0.05554634f, -0.03743778f, -0.08893403f, -0.17577863f, -0.11894235f, 0.03804744f, 
    -0.11510082f, -0.08237676f, 0.09836790f, -0.00673921f, -0.00857048f, -0.03563742f, 0.02724540f, -0.01425415f, 
    -0.01096538f, 0.03617842f, 0.01494086f, 0.02731856f, 0.02714540f, -0.08296861f, -0.05811529f, -0.01124648f, 
    -0.08237974f, -0.30697662f, -0.01393048f, 0.00250774f, -0.18284458f, 0.08441395f, 0.08400434f, 0.03004617f, 
    0.05978525f, 0.09137498f, -0.01182925f, -0.02653678f, 0.01341463f, -0.00367476f, -0.00598153f, -0.05224558f, 
    -0.00353383f, -0.02533236f, -0.06860443f, -0.05619489f, 0.01256211f, -0.17264244f, 0.01016224f, -0.07476567f, 
    0.01889648f, -0.01766367f, -0.07495093f, 0.03268641f, 0.15439880f, 0.05732797f, 0.02393151f, -0.02604352f, 
    0.08293526f, 0.02024109f, -0.01021576f, 0.05173294f, 0.02412985f, -0.05435195f, 0.03617746f, -0.06669118f, 
    0.00576949f, -0.13589002f, 0.02929280f, 0.04118862f, -0.11108568f, 0.01990164f, 0.03363126f, 0.03009812f, 
    -0.00022313f, 0.04191037f, -0.01463714f, -0.01804606f, -0.01056270f, -0.00584916f, -0.09079319f, -0.04000452f, 
    -0.00711651f, -0.02737375f, -0.11611404f, -0.04575016f, 0.12573789f, 0.05490137f, -0.05701825f, -0.14574170f, 
    -0.01958801f, -0.13332617f, -0.11671714f, -0.01930353f, -0.10650878f, -0.13168809f, 0.11437880f, -0.04968559f, 
    0.07088195f, -0.03752876f, -0.05423694f, 0.04889363f, -0.00166375f, 0.01965851f, 0.03262788f, -0.00990141f, 
    0.10124451f, -0.08541487f, 0.01736753f, -0.01845060f, 0.06045354f, -0.10975259f, -0.04643894f, 0.02355927f, 
    -0.02048700f, -0.18219468f, -0.08922463f, -0.07630412f, -0.02590221f, -0.02473184f, -0.01530651f, 0.00149027f, 
    -0.04535511f, -0.02678180f, 0.03921166f, 0.05541804f, 0.09438669f, 0.05680790f, 0.02829048f, 0.06737895f, 
    -0.05602710f, -0.15086758f, 0.02630473f, -0.00515874f, -0.07015480f, -0.08985795f, 0.01649628f, -0.07653135f, 
    -0.03047624f, 0.02871748f, -0.04454538f, -0.00404548f, -0.00406141f, 0.07439830f, 0.01155554f, -0.08226302f, 
    0.03282224f, -0.03972557f, 0.07060926f, 0.03261026f, -0.01285688f, -0.01127088f, -0.02911713f, 0.05865132f, 
    -0.06542803f, -0.06494543f, -0.03345975f, 0.00049601f, 0.01256736f, -0.00664941f, 0.02702623f, -0.04378775f, 
    -0.04400867f, 0.00533579f, -0.05947098f, 0.04619132f, -0.19371100f, 0.18262027f, -0.06792160f, 0.00474233f, 
    0.01890112f, 0.04959727f, -0.07145192f, 0.03169160f, -0.06772975f, -0.04806980f, 0.01496919f, 0.11005981f, 
    0.02232729f, 0.03151561f, 0.03538794f, -0.03944436f, 0.03257109f, 0.01068827f, -0.12427492f, -0.12920074f, 
    -0.04533108f, -0.08673842f, 0.10127441f, -0.06239407f, 0.01869304f, -0.03610248f, 0.07704078f, -0.00292481f, 
    0.00843814f, -0.04451834f, 0.02597473f, -0.04665201f, 0.04499390f, -0.03236911f, -0.05495012f, 0.01846095f, 
    -0.03723506f, -0.08432314f, -0.00606821f, 0.03402881f, 0.14184709f, 0.06738279f, -0.04983293f, 0.00187977f, 
    0.30952057f, 0.04169464f, -0.04904030f, -0.01614096f, -0.00302902f, 0.02057505f, 0.05471886f, 0.03958101f, 
    0.07225563f, 0.04416642f, -0.03078606f, -0.06051758f, 0.02824785f, 0.03386792f, 0.04961985f, 0.01809319f, 
    -0.18986875f, 0.11973378f, -0.00039442f, 0.03940890f, -0.12282410f, -0.00438667f, -0.01367826f, 0.00378903f, 
    0.03420877f, -0.04157928f, 0.01278389f, -0.02974886f, 0.10147192f, 0.05746152f, 0.00916950f, 0.00886334f, 
    0.04801298f, -0.04721830f, -0.00886592f, -0.04264765f, 0.32201967f, -0.07419983f, -0.14878912f, -0.04151247f, 
    0.01031971f, -0.05069346f, 0.11703454f, -0.09174042f, 0.02906418f, -0.05049678f, 0.05537188f, 0.04433333f, 
    0.02620783f, 0.06692126f, -0.01161641f, -0.00604891f, 0.00847048f, -0.00874898f, 0.00761616f, 0.04478390f, 
    -0.01703818f, -0.05636173f, 0.07418495f, -0.04104960f, -0.02634347f, -0.09954321f, -0.07416707f, -0.03242824f, 
    -0.12979633f, -0.11735434f, -0.00523415f, -0.06810129f, 0.06941769f, 0.00653565f, -0.05821072f, -0.07307286f, 
    -0.12906268f, -0.06327637f, -0.05337901f, 0.05400604f, 0.03522421f, 0.07566881f, -0.00814961f, 0.01272826f, 
    0.13910785f, 0.04080318f, 0.02675234f, 0.02160929f, 0.05169196f, 0.01207699f, -0.02097266f, -0.07085280f, 
    -0.07142803f, 0.00009068f, 0.16183558f, 0.04248746f, 0.00230176f, 0.00095224f, 0.08738973f, -0.03913455f, 
    -0.02957743f, 0.13199876f, -0.03612844f, -0.06321532f, 0.07071388f, 0.02638683f, -0.03546293f, 0.05953962f, 
    -0.07801053f, -0.03597172f, -0.03073873f, 0.06518879f, 0.00249969f, -0.06360041f, 0.03346330f, 0.01824919f, 
    -0.00853684f, -0.06407277f, 0.06742808f, -0.06292360f, 0.22728081f, -0.01890174f, -0.05700568f, -0.15659395f, 
    -0.16229728f, 0.07175356f, 0.02401043f, -0.03886658f, 0.02939913f, 0.02609290f, 0.05547460f, -0.05709135f, 
    0.01786800f, -0.01384899f, 0.02252155f, -0.03443888f, 0.03886467f, -0.01658734f, -0.00413341f, 0.06060284f, 
    0.15309975f, 0.14118274f, -0.09878036f, -0.02094891f, 0.10194434f, 0.00407055f, 0.00355963f, -0.00158830f, 
    -0.05302318f, -0.06155432f, 0.05925429f, 0.06029093f, 0.04331017f, -0.01384304f, -0.07645354f, 0.06342011f, 
    -0.01262457f, 0.01229896f, 0.00162408f, -0.01314615f, 0.07280074f, 0.03747946f, -0.00959751f, -0.04675276f, 
    0.00243932f, -0.15814348f, -0.08465198f, 0.02913078f, -0.08691809f, -0.19313832f, -0.07800350f, 0.02631037f, 
    0.02883307f, 0.04198638f, -0.01980843f, -0.05482444f, -0.02894181f, 0.03071450f, 0.02121197f, -0.05401563f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03931313f, 0.04943625f, -0.01141840f, -0.01793027f, -0.00273324f, 0.00736238f, -0.03230920f, -0.01556489f, 
    -0.03206190f, -0.00459501f, 0.03642484f, 0.01774388f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
