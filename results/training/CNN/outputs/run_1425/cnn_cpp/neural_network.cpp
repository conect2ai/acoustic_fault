#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.30425406f, -0.95763725f, -0.20843603f, -0.05399396f, -1.16366708f, 0.23200482f, -0.84849542f, -1.11874592f, 
    -0.80641907f, -0.82734895f, -0.24276416f, -0.19915372f, 0.03151353f, -0.17003930f, -0.24213229f, 0.19551896f, 
    -0.12347209f, 0.00099663f, -0.12888739f, -0.27910259f, -0.04646654f, 0.42456633f, 0.06111965f, 0.06163890f, 
    0.56834269f, 0.39137039f, 0.67059940f, 0.72860211f, -0.04195038f, 0.29655507f, -0.69072306f, -0.20544846f, 
    0.44292721f, 0.49669120f, -0.14159973f, -0.19128031f, 0.15601605f, 0.12369740f, 0.15625416f, -0.06472360f, 
    -0.15212625f, -0.23764330f, -0.36626002f, -0.32379243f, -0.31099844f, -0.04426704f, -0.00656310f, 0.00779588f, 
    -0.14990155f, 0.27366263f, 0.60174227f, 0.00445634f, 0.11838119f, 0.00180985f, -0.83052433f, -0.18127668f, 
    -0.13158605f, 0.51099688f, 0.29975307f, 0.52747875f, -0.57191777f, -0.34880099f, 0.51114899f, 0.15239599f, 
    -0.64485902f, 0.24279466f, -0.31018105f, -0.09882689f, -0.32280907f, 0.21422707f, -0.34023488f, -0.13256389f, 
    0.19995020f, -0.06397408f, 0.31195542f, 0.66006738f, 0.16910458f, -0.77664703f, -0.98144776f, -0.84198809f, 
    0.53060484f, 0.94645721f, -0.30971062f, -0.89828330f, 0.39948723f, 0.23554587f, 0.52121460f, 0.32548180f, 
    -0.08850189f, 0.46284309f, 0.01309943f, -0.22708589f, 0.15782331f, -0.05153602f, -0.42358798f, 0.14395377f, 
    -0.06518208f, -0.09950753f, -0.08129793f, -0.02932549f, 1.02142489f, -0.31289420f, 0.37893832f, 0.30716351f, 
    -1.05335379f, 0.29788837f, -0.14110224f, -0.08982000f, 0.07169288f, 0.12595977f, -0.08208942f, -0.46991983f, 
    -0.14869651f, 0.07029491f, -0.13012573f, -0.37996584f, -0.15655287f, -0.06097112f, -0.00839597f, -0.36555162f, 
    -0.49944896f, -0.19405755f, -0.59070361f, -0.85384393f, -1.06376493f, -1.53366792f, -1.15612221f, -1.14462686f, 
    -0.45627007f, -0.67636573f, 1.23151195f, 0.33194396f, -0.11430907f, 0.51860088f, 1.29222846f, 0.19578695f, 
    0.15764333f, -0.09879710f, 0.24016075f, -0.23444347f, -0.27716678f, 0.04295836f, -0.01134502f, 0.02471258f, 
    -0.23627645f, -0.01353665f, -0.03880996f, 0.12962732f, 0.24278471f, 0.01637925f, -0.28717360f, -0.35171914f, 
    -0.24017893f, -0.33476043f, 0.47050309f, -0.79693097f, -0.42337462f, 1.31892860f, -0.42976654f, -0.20392035f, 
    -0.79112107f, -0.32253760f, 0.57375056f, 0.07722506f, -0.00944798f, 0.21695437f, 0.24006332f, 0.03455145f, 
    0.01397630f, 0.13124143f, 0.21227528f, -0.37519726f, 0.12944417f, 0.21392241f, 0.07182454f, 0.68290573f, 
    0.05933856f, -0.80413020f, -0.62435585f, 0.51057756f, 0.08259770f, -0.22851305f, 0.15303239f, -0.21362339f, 
    -0.31716967f, 0.10913909f, 0.02882160f, 0.36766806f, -0.28509244f, -0.35748413f, 0.10412925f, 0.09448176f, 
    -0.20981827f, 0.00121781f, -0.82995135f, 0.13236940f, 0.38390866f, 0.62597233f, 0.23854604f, 0.52972025f, 
    0.91163576f, 1.95516801f, 0.37521026f, -0.22397691f, -1.04589510f, -0.98329347f, -0.61628693f, -0.76524633f, 
    -0.94185716f, -1.52332294f, 0.13169082f, -0.10104667f, 0.04896896f, -0.04384892f, -0.12865527f, 0.12945493f, 
    -0.04394935f, 0.33495605f, 0.13385491f, 0.16832873f, -0.05350811f, 0.20542122f, -0.22346307f, 0.03947441f, 
    -0.04205096f, 0.92166525f, -0.32325783f, -0.05860463f, 0.45190698f, 0.12234157f, -0.05436396f, 0.42807156f, 
    -0.26171386f, -0.42069185f, -0.49109504f, 0.05907428f, -0.17749855f, 0.24264960f, 0.41187319f, 0.36473399f, 
    0.44519758f, -0.25524458f, -0.01700320f, 0.14827091f, 0.31554466f, 0.06665537f, 0.72561216f, 0.42325330f, 
    -0.13075180f, -0.08044174f, 1.49507642f, -0.13623732f, 0.18673509f, -0.19978034f, -0.28879616f, -0.10211756f, 
    -0.23571023f, 0.81675881f, -0.49525583f, -0.66552502f, -0.23580374f, 0.26293641f, -0.36813164f, -0.53004360f, 
    0.61230797f, -0.10691114f, 0.30008963f, -0.20059729f, -0.25958332f, 0.07090227f, -0.10036752f, -0.24801886f, 
    -0.26197341f, 0.13025828f, 0.09745756f, 0.90748507f, 0.59785360f, -0.10336339f, -0.51640534f, -0.71236116f, 
    0.88844532f, -0.02214566f, -0.02678744f, 0.10019409f, 0.08561214f, -0.21788092f, -0.34373251f, -0.33186930f, 
    0.10322566f, 0.35818294f, 0.24826103f, -0.01104647f, -0.10730048f, -0.08888526f, 0.18551938f, -0.21512614f, 
    -0.03205042f, -0.27484554f, 0.24789324f, 0.21842179f, -1.38037050f, -1.27941859f, -0.55123466f, -0.04902888f, 
    0.05996927f, 0.36096758f, -0.68327534f, -1.54014850f, -1.50028777f, -0.57667047f, -0.37554437f, -0.10142121f, 
    0.00107217f, -0.64561921f, -0.52161151f, -0.17630836f, -0.31342709f, -0.19339734f, -0.17803277f, -0.01171656f, 
    0.07919303f, -0.45596322f, -0.59279042f, -0.04323776f, -0.61757660f, 0.09068069f, 1.13958251f, 1.14491904f, 
    -0.13520789f, -0.07519334f, -0.75224203f, -0.81943107f, -0.31771639f, 0.26459956f, -0.04483797f, -0.54031235f, 
    -0.62092268f, -0.48707303f, 0.36954579f, 0.14068475f, 0.49829799f, 0.37168056f, 0.09839728f, 0.25988519f, 
    0.11699310f, -0.14044690f, -0.09851702f, -0.10977362f, -0.13413110f, -0.24366571f, 0.84198284f, -0.13506913f, 
    0.15308659f, 0.47516868f, 0.09837354f, 0.56414270f, 0.63374597f, 0.48057723f, -0.46370301f, -0.48524421f, 
    -0.19261461f, -0.11834053f, 0.14172491f, -0.24347030f, -0.28289840f, -0.29453516f, -0.22764719f, 0.01616086f, 
    -0.32672450f, -0.02764682f, 0.32862738f, -0.14120813f, -0.36684993f, -0.05433268f, -0.00521207f, 0.37973231f, 
    0.28074774f, -0.03725287f, 0.25777826f, -0.37014875f, -1.05732524f, -0.49161011f, 0.42901838f, 0.69551080f, 
    0.05872920f, 0.39900094f, -0.34622335f, -0.41493747f, 0.54070222f, -0.35236874f, -0.13242851f, 0.01879133f, 
    0.38826260f, 0.11085526f, -0.42471451f, 0.19993217f, 0.33408663f, -0.20604843f, -0.00930216f, -0.07404073f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03945437f, -0.16744637f, 0.84338272f, 0.76760554f, 0.32369441f, 0.29821801f, 0.65516877f, 0.48929429f, 
    0.51664460f, 0.25320759f, 0.45721105f, 0.28802595f, -0.00384142f, 0.39089540f, 0.21303685f, 0.45430276f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.71984571f, 0.45680112f, -0.40110448f, -0.45788884f, 0.08071694f, 0.10087162f, 0.18601590f, 0.14044955f, 
    -0.03230479f, -0.09161424f, 0.01098297f, 0.03877430f, 0.11165774f, -0.56987345f, -0.20192653f, 0.31416109f, 
    0.01953974f, 0.06762693f, -0.03617013f, 0.12449005f, 0.03778239f, 0.14034909f, 0.05909518f, -0.03740428f, 
    -1.11511958f, -0.79062879f, -0.20495097f, -0.33494401f, 0.01922421f, 0.01802789f, -0.01502186f, -0.00113139f, 
    -0.08067809f, -0.21561331f, -0.00091475f, 0.12801985f, 0.17969586f, 0.07342784f, -0.64619786f, 0.29323044f, 
    0.16846405f, -0.02946391f, -0.17812033f, -0.23805298f, -0.28473121f, -0.11257845f, -0.17244789f, 0.05588894f, 
    -0.55162233f, -0.57573658f, 0.02915462f, -0.01504874f, 0.07450494f, -0.05542179f, 0.01690173f, -0.00835391f, 
    -0.12265904f, -0.16123886f, 0.05508452f, 0.43124133f, 0.25772232f, 0.13569078f, -0.01125386f, -0.09909374f, 
    0.25358588f, 0.22174601f, 0.13977879f, -0.03115011f, 0.01004644f, 0.14028494f, 0.10920484f, 0.14840095f, 
    0.09839217f, 0.11458072f, 0.30899185f, 0.08600798f, 0.02443191f, -0.01608863f, -0.08144456f, -0.25874752f, 
    -0.07009884f, 0.11198315f, 0.00446990f, -0.03048476f, 0.03233772f, 0.05347428f, -0.37501657f, 0.05360550f, 
    -0.01564422f, 0.18567528f, -0.08576222f, -0.09188065f, -0.06450408f, -0.23944546f, -0.09275928f, -0.06105168f, 
    0.28438413f, 0.06877481f, -0.38066649f, -0.12039652f, 0.03222355f, 0.02856736f, -0.05184774f, -0.04170462f, 
    0.07867163f, 0.06853609f, -0.06551431f, 0.00313247f, -0.06509411f, 0.05547083f, 0.02768389f, 0.04849453f, 
    -0.19033396f, -0.35566896f, 0.12110691f, -0.17265145f, -0.13614471f, 0.05943602f, -0.09697987f, -0.14977351f, 
    -0.34241596f, -0.91892862f, 0.15973513f, -0.27322194f, -0.09360997f, 0.00380319f, -0.05817524f, 0.00494586f, 
    -0.00093823f, 0.11214662f, 0.03325751f, -0.29797280f, -0.33359072f, -0.10701051f, -0.13517673f, 0.13004674f, 
    -0.13036835f, 0.07328898f, -0.01186575f, -0.06708619f, -0.17462876f, -0.29863819f, -0.21672329f, -0.40728721f, 
    0.80777037f, 0.40954393f, -0.29768708f, -0.20237944f, 0.28437248f, 0.16214454f, 0.14973763f, -0.04669393f, 
    -0.10531396f, -0.01499233f, -0.13213177f, -0.24013278f, -0.61009246f, 0.53660512f, 0.21767652f, -0.42704529f, 
    -0.04401410f, -0.05219970f, -0.24602804f, -0.20036055f, 0.09034917f, -0.07692437f, -0.07412352f, -0.01331210f, 
    0.02888825f, -0.21253476f, -0.81424922f, 0.24946502f, 0.00059588f, 0.09315608f, 0.07714809f, 0.11250442f, 
    0.15075020f, 0.05458867f, 0.03913415f, 0.02920583f, -0.32693043f, -0.27319732f, 0.15944056f, -0.28303856f, 
    -0.08783361f, 0.13761073f, -0.38772407f, -0.15808190f, 0.06680789f, -0.20324351f, -0.25178972f, -0.01979489f, 
    0.02913023f, 0.20836221f, 0.31728300f, 0.22774190f, -0.09267104f, -0.04358422f, -0.18143289f, 0.27377376f, 
    0.04827108f, 0.10439600f, 0.03255716f, -0.02450979f, 0.24471389f, 0.53951544f, 0.29582870f, 0.10704424f, 
    -0.03445698f, -0.04115102f, -0.01089134f, 0.00362610f, 0.04535045f, 0.01769416f, -0.02538608f, 0.13497221f, 
    0.52670640f, 0.30878210f, 0.28883326f, -0.33079171f, 0.02123044f, 0.07829884f, 0.01392445f, -0.04033425f, 
    0.03374298f, -0.08660874f, -0.07899132f, -0.08270935f, 0.20303746f, -0.56810141f, -0.22160953f, -0.21794476f, 
    0.06992790f, 0.19030464f, -0.25101712f, -0.05997257f, 0.21860309f, 0.03361037f, -0.07946336f, 0.08198748f, 
    0.23644865f, 0.17978351f, -0.02565512f, -0.09875687f, -0.08684102f, 0.01018705f, -0.21638013f, 0.01190947f, 
    -0.35574812f, -0.15902475f, 0.06287251f, -0.67567253f, 0.40459532f, -0.04851730f, -0.38883376f, -0.24102475f, 
    -0.04907870f, 0.15556109f, 0.10386547f, -0.13342284f, -0.07579426f, -0.24606922f, -0.05299952f, -0.25796488f, 
    -0.24057244f, 0.06344842f, -0.01429123f, 0.28809357f, -0.36245653f, -0.16145918f, 0.27320570f, -0.27944478f, 
    -0.08130208f, -0.00352505f, 0.07665145f, 0.06101824f, 0.22577977f, 0.06766843f, -0.10488677f, 0.01277728f, 
    -0.08831590f, 0.21309938f, 0.23152755f, 0.04769070f, -0.19181909f, 0.00998800f, -0.02462400f, 0.02883387f, 
    0.22132458f, -0.38371378f, -0.32451943f, -0.70676708f, -0.35745025f, -0.38882202f, -0.35831684f, -0.04963148f, 
    -0.11897738f, -0.03057749f, 0.06983938f, 0.05471939f, 0.18953535f, -0.13299778f, 0.06903982f, -0.03236047f, 
    -0.12511896f, 0.26129279f, -0.02882810f, -0.03120296f, -0.23868023f, -0.03397207f, 0.18137893f, 0.07327976f, 
    0.90237617f, -0.28216612f, 0.00127639f, -0.04821600f, -0.03436343f, -0.03886335f, 0.16327596f, -0.33096686f, 
    0.06695687f, 0.03733258f, -0.18047911f, 0.10582711f, 0.45408991f, 0.11894814f, -0.00873498f, 0.01052480f, 
    0.00762076f, -0.17039803f, 0.09754203f, -0.10291343f, 0.15639600f, 0.31050435f, -0.10345686f, -0.18761317f, 
    0.26952925f, -0.04508238f, 0.07226750f, 0.17383929f, -0.06676085f, -0.03063118f, -0.16899109f, -0.09577461f, 
    0.10592217f, -0.07839951f, -0.16815183f, 0.07749209f, -0.12451266f, -0.12080842f, 0.16983822f, -0.20136847f, 
    0.02090468f, -0.18651100f, -0.05052451f, 0.12629615f, -0.00999116f, 0.02516021f, 0.03396747f, 0.00131417f, 
    1.03839338f, 0.10024960f, 0.33179006f, 0.41803172f, -0.10615698f, -0.00303537f, -0.06051530f, -0.00298271f, 
    0.01147513f, -0.08855449f, 0.02811079f, 0.20749769f, -0.40103939f, 0.05631747f, 0.35737780f, -0.02901128f, 
    0.00503161f, 0.03647802f, -0.06911562f, 0.14760722f, 0.12149636f, -0.19250707f, -0.04977597f, -0.04480800f, 
    -0.94624406f, -0.50732476f, 0.09297570f, 0.27189970f, -0.05454237f, 0.05726741f, -0.11479539f, 0.25629786f, 
    -0.01411847f, -0.01623332f, -0.06092706f, -0.04446416f, -0.30804047f, -0.70667666f, 0.16634098f, -0.01017495f, 
    -0.12910236f, 0.00488773f, 0.01700362f, -0.02219025f, -0.07202224f, -0.03176635f, -0.00574262f, -0.03233849f, 
    -0.31051719f, 0.80046606f, -0.11712696f, 0.09426018f, -0.04074129f, 0.14779496f, 0.04289283f, -0.03944241f, 
    -0.01500520f, -0.13555120f, 0.00936090f, -0.06439767f, 0.15899998f, -0.17444345f, 0.47863567f, -0.19703922f, 
    -0.04228874f, -0.00687769f, -0.07445981f, -0.27176517f, 0.04493757f, 0.26214078f, 0.07004696f, 0.06420978f, 
    -0.24225967f, 0.31689686f, -0.06213424f, -0.08307977f, -0.06805198f, 0.03466162f, -0.02155973f, -0.04198803f, 
    0.18999702f, 0.27571648f, 0.26034600f, 0.19808011f, -0.00688493f, 0.38049555f, 0.72139633f, 0.54577327f, 
    -0.12049194f, -0.05506326f, 0.06968848f, 0.12484396f, 0.04463905f, -0.11267739f, 0.02302443f, 0.22953218f, 
    0.24851848f, 0.04642629f, -0.22561494f, 0.18736334f, -0.15998034f, 0.04285877f, 0.36871943f, -0.23528273f, 
    0.03051633f, 0.10892590f, 0.10664873f, -0.15430163f, -0.12723279f, -0.10908421f, 0.12064764f, -0.04331312f, 
    -0.20741443f, 0.19854107f, 0.11139442f, -0.07215393f, 0.05298848f, -0.10349680f, -0.05048814f, -0.09777660f, 
    -0.79987633f, -0.61897695f, 0.78828323f, -1.13730741f, 0.09589271f, -0.12134567f, -0.51123250f, -0.16020918f, 
    0.16131701f, -0.01760090f, 0.03967225f, -0.00663332f, -0.12006787f, -0.00795328f, -0.00315248f, 0.17496499f, 
    -0.32720032f, -0.36140558f, -0.04476242f, -0.01509060f, 0.23639929f, -0.06361722f, -0.07758535f, 0.05095552f, 
    -0.69311130f, 0.28079054f, -0.49977455f, 0.35219267f, -0.22228786f, -0.10823714f, -0.04855616f, -0.22282447f, 
    0.15085860f, 0.12489559f, -0.27442414f, 0.20728090f, 0.03157168f, 0.26943111f, -0.07849069f, -0.26850995f, 
    0.05805567f, 0.00598207f, -0.21218953f, 0.15602361f, -0.13735914f, 0.15684196f, -0.24571039f, 0.13295697f, 
    -0.53734845f, -0.69281632f, 0.16993071f, 0.18382734f, 0.12795861f, -0.06055049f, -0.04471796f, 0.17794581f, 
    -0.03386796f, -0.01130929f, -0.08090332f, -0.00915489f, -0.26070100f, -0.10642260f, 0.16355748f, -0.18751635f, 
    -0.13285805f, 0.07156006f, 0.07992762f, 0.04972028f, -0.02213355f, -0.04230225f, -0.00946714f, 0.02906773f, 
    0.04026037f, 0.20565251f, -0.86755878f, -0.41386953f, 0.01139484f, -0.04071222f, 0.04472637f, 0.02498039f, 
    0.01474205f, -0.05504518f, 0.04971745f, -0.16363214f, -0.51013643f, 0.07599793f, -0.20409298f, 0.09913616f, 
    0.14263640f, 0.21155533f, -0.03879945f, 0.01571593f, 0.14975791f, 0.00576862f, 0.28915757f, 0.13334090f, 
    -0.10699189f, -0.04053724f, 0.00827807f, 0.37042767f, 0.12565081f, -0.13364759f, -0.03087042f, 0.14081714f, 
    -0.11835481f, 0.15787674f, -0.17461090f, 0.03160162f, 0.01900885f, -0.04055728f, 0.44448492f, -0.29600409f, 
    -0.04043054f, 0.07444935f, -0.21301268f, -0.00211226f, 0.22751591f, 0.01844490f, 0.29054576f, -0.12784319f, 
    -0.06684306f, -0.29807177f, 0.08874713f, 0.06077276f, -0.32787371f, -0.02587410f, -0.07196993f, 0.01201528f, 
    -0.08159934f, -0.05456389f, 0.25289014f, -0.00348874f, -0.27029720f, -0.32885131f, -0.23629764f, 0.54998779f, 
    0.11521403f, -0.10576563f, -0.14307176f, -0.10494439f, 0.14486040f, -0.14625323f, 0.08348921f, -0.02864676f, 
    -0.47944638f, -0.21046251f, 0.28002137f, 0.28820729f, -0.32080159f, 0.32940012f, -0.41785282f, 0.09881668f, 
    0.18845001f, -0.00497795f, -0.14254563f, -0.00067650f, 0.22538714f, -0.37143865f, -0.07199702f, 0.09526590f, 
    0.45668650f, 0.14418180f, 0.05093315f, -0.17661795f, 0.05928513f, 0.28001311f, -0.00460989f, -0.01406009f, 
    0.41531217f, 0.17560583f, -0.48427773f, -0.10451403f, -0.23094143f, 0.09879584f, -0.18531410f, -0.20793897f, 
    0.23792934f, 0.01004355f, -0.18695623f, -0.32143044f, 0.06705106f, 0.42585766f, -0.05592830f, 0.54836595f, 
    0.02378693f, -0.05671697f, -0.12491801f, -0.46280256f, -0.22723378f, 0.20306657f, 0.01884294f, -0.09815198f, 
    -0.04698312f, -0.30156171f, 0.49794969f, 0.27744624f, 0.16132107f, 0.17855804f, -0.07271796f, 0.11039066f, 
    0.06680672f, -0.11171322f, -0.03676387f, 0.01758606f, -0.13753729f, -0.00119698f, -0.43784466f, 0.32424653f, 
    -0.02995078f, -0.07437401f, -0.50606221f, 0.07225935f, -0.01679518f, -0.62574315f, 0.04890361f, -0.34534854f, 
    -1.25933731f, -0.36387756f, 0.46950227f, 0.30236384f, -0.31560269f, 0.00343156f, -0.30954897f, 0.04688982f, 
    0.02398786f, 0.21625631f, -0.21782945f, -0.02066155f, -0.64748979f, -0.23830383f, -0.51861614f, 0.11528238f, 
    -0.03315714f, 0.19224747f, 0.22320692f, 0.08532532f, 0.01985866f, -0.02565666f, 0.14453280f, -0.08257603f, 
    -0.42923760f, 0.22520231f, -0.16713549f, 0.26255462f, 0.17336331f, 0.11757068f, -0.01469514f, 0.10215055f, 
    -0.08548986f, 0.11757340f, -0.12445617f, 0.21537840f, 0.52679038f, -0.19962965f, 0.53756541f, -0.08743797f, 
    -0.72329354f, -0.19242303f, 0.11984705f, -0.05595879f, 0.04219422f, 0.11340079f, 0.30709082f, 0.08422752f, 
    -0.48247793f, 0.36333460f, -0.30854717f, 0.02547191f, 0.09513745f, 0.14994627f, 0.09170716f, 0.16634701f, 
    -0.19041753f, -0.15763329f, 0.23704474f, -0.22858819f, -0.08214797f, -0.29448491f, 0.15276974f, -0.58716762f, 
    -0.27577296f, 0.05623591f, -0.15954240f, 0.15194544f, -0.11127985f, -0.00344669f, 0.09138854f, -0.17177671f, 
    0.22585219f, 0.02211067f, 0.08376561f, 0.14595044f, -0.07003608f, -0.03405070f, 0.17717192f, -0.28090814f, 
    0.01784874f, -0.06703462f, 0.08526220f, 0.00008800f, -0.89065886f, -1.01142168f, -0.42132708f, 0.15284880f, 
    0.08677747f, 0.09468555f, 0.06873692f, 0.07733800f, 0.08275466f, -0.02451097f, 0.03593497f, 0.16346364f, 
    -0.57466215f, -0.47166303f, -0.52360404f, -0.22259678f, 0.01235818f, -0.10640770f, -0.03385419f, 0.07515475f, 
    -0.43824533f, -0.20758626f, -0.32611606f, -0.41563755f, 0.01163980f, 0.09840163f, 0.07843961f, 0.24109651f, 
    0.09743775f, -0.25555199f, 0.04757048f, -0.05643436f, 0.10549535f, -0.14658380f, 0.17697254f, -0.03982072f, 
    -0.09777146f, -0.07287461f, -0.16153567f, -0.12912393f, 0.10505009f, -0.14325731f, 0.09096034f, -0.16611503f, 
    0.10176519f, 0.08645016f, -0.02311480f, 0.46044195f, 0.23964745f, 0.46086681f, 0.02544382f, 0.28296739f, 
    -0.27505708f, -0.20486894f, -0.07264779f, -0.00774548f, 0.04667894f, -0.10994224f, -0.08659469f, 0.23798086f, 
    -0.38952011f, -0.29382873f, 0.07139312f, -0.36364266f, -0.41458040f, -0.06870688f, -0.19272445f, -0.01562249f, 
    0.11042462f, -0.06069939f, -0.05737668f, -0.16456293f, 0.07510822f, -0.00838558f, 0.10434122f, 0.01226328f, 
    0.09915236f, -0.15447813f, -0.21244390f, 0.00732732f, 0.07169224f, -0.16672932f, -0.16884166f, -0.29044190f, 
    0.13525656f, 0.70872861f, 0.19893628f, 0.40259993f, 0.28496099f, 0.20415443f, 0.19410847f, 0.19186246f, 
    0.12684070f, -0.05573241f, 0.01357529f, -0.16624258f, 0.20815860f, 0.04383999f, 0.10048713f, 0.11772104f, 
    0.10544698f, 0.04689600f, -0.05482278f, 0.07885175f, 0.17238273f, -0.12928098f, -0.06263538f, -0.04950542f, 
    0.11938932f, 0.17299965f, -0.56536412f, -0.46421418f, 0.05822220f, 0.11594311f, 0.07142421f, 0.06993502f, 
    -0.10886589f, 0.01301116f, 0.10722552f, -0.29239678f, -0.15349428f, 0.16561739f, 0.04273161f, 0.02381607f, 
    0.13448249f, 0.12788893f, -0.13316295f, 0.08957679f, -0.18010774f, 0.06323268f, -0.02421563f, 0.09361494f, 
    -0.00677642f, -0.20813023f, 0.23765627f, 0.04801188f, -0.01474471f, 0.01887164f, -0.03368558f, 0.15237904f, 
    -0.09473440f, 0.03167430f, 0.04981801f, 0.17272069f, 0.39610451f, 0.21118526f, -0.49366215f, 0.53784615f, 
    0.02282071f, -0.00717387f, -0.08025029f, -0.30176109f, 0.14186256f, -0.05476741f, -0.09285543f, 0.00656730f, 
    -0.28144288f, -0.89645249f, -0.52666575f, -0.32663506f, 0.23500936f, 0.07150149f, 0.01204120f, 0.01351270f, 
    0.08474523f, 0.06032662f, -0.10542505f, 0.00079811f, -0.48217896f, -0.29856217f, -0.23489375f, -0.27914611f, 
    0.04979908f, -0.20145638f, 0.13756484f, -0.07331144f, -0.00980008f, -0.07974888f, -0.03279822f, 0.00695985f, 
    -0.05103653f, 0.17159486f, 0.17592083f, -0.33733281f, 0.21734683f, 0.19776481f, 0.21698514f, -0.20611989f, 
    0.13920356f, -0.13972144f, 0.01590732f, 0.11275965f, -0.51033092f, -0.39953238f, 0.06450345f, 0.48665771f, 
    0.11880863f, 0.06278996f, -0.02522692f, 0.01824316f, 0.00677236f, 0.03080562f, -0.00207447f, 0.04188506f, 
    0.52940589f, -0.28716299f, -0.19974786f, 0.38681835f, 0.07374100f, 0.00585266f, -0.11721937f, 0.09528238f, 
    0.30773535f, -0.00226308f, 0.16259098f, 0.24071741f, -0.00175711f, 0.15310091f, -0.27812353f, -0.46573848f, 
    0.05254476f, 0.03987740f, 0.16659221f, 0.15829189f, -0.00988064f, 0.02319069f, -0.04738697f, -0.12230006f, 
    0.14634241f, -0.31139895f, -0.18310300f, -0.02785187f, 0.15043361f, 0.14578864f, 0.11208480f, 0.06403592f, 
    -0.12307596f, -0.29999381f, -0.30175424f, -0.79812562f, -1.11712098f, -0.60820711f, 0.09114660f, -0.49337971f, 
    -0.02649819f, -0.10800805f, -0.12036514f, 0.05210022f, -0.00223355f, -0.09959863f, 0.07900607f, -0.16492856f, 
    0.23077156f, 0.00124185f, 0.12746319f, -0.04842124f, 0.52168804f, 0.07489751f, -0.07682458f, 0.23226000f, 
    -0.05985231f, -0.06031375f, 0.06540842f, 0.17661200f, 0.00021747f, -0.07591792f, 0.05391880f, -0.33409032f, 
    -0.08885342f, 0.11039407f, -0.17201217f, -0.12392627f, 0.11230262f, -0.11969315f, 0.10701877f, 0.14526530f, 
    0.19817600f, 0.35794988f, -0.45115387f, 0.01786586f, 0.02877573f, 0.15773878f, 0.15306729f, 0.11347074f, 
    0.02000485f, -0.03898070f, 0.04317746f, -0.01195503f, -0.09537610f, -0.09266604f, -0.19476469f, -0.06685780f, 
    0.17368113f, -0.14015335f, 0.51355326f, 0.01666378f, 0.05000806f, -0.00847855f, -0.14521754f, 0.04695011f, 
    -0.22995016f, -0.38880274f, -0.18278734f, 0.33454406f, 0.25360769f, 0.04029432f, -0.28110003f, 0.27555028f, 
    -0.03260506f, -0.09636395f, 0.10561780f, 0.06212844f, -0.03648592f, -0.30616906f, -0.29377365f, -0.29687375f, 
    -0.03141029f, -0.06884429f, -0.17849027f, 0.13168027f, 0.28478238f, -0.28377897f, -0.07784502f, 0.25029522f, 
    -0.00933786f, 0.37571755f, 0.38674805f, -0.23815131f, 0.08720717f, -0.01156370f, -0.11649463f, -0.15333320f, 
    -0.00884254f, -0.07201497f, 0.10818420f, -0.06994150f, -0.36110416f, -0.26485237f, -0.00221213f, 0.31416777f, 
    0.14961924f, -0.01383556f, -0.43850094f, 0.21998253f, -0.05090515f, 0.10883065f, 0.04013839f, -0.09848417f, 
    -0.34699565f, -0.47721788f, -0.24406123f, 0.13025239f, 0.01028043f, 0.00281548f, 0.00250316f, 0.03352406f, 
    -0.00517453f, 0.08831829f, 0.04956125f, -0.09575518f, 0.58111018f, -0.15500498f, -0.18690655f, 0.21274073f, 
    0.10191492f, -0.32572952f, -0.31938985f, -0.09175266f, -0.19057757f, 0.25416350f, -0.06115859f, 0.04031995f, 
    -1.84614587f, -2.11994290f, -0.79922706f, -0.07188839f, 0.01384814f, -0.87431979f, -0.24666032f, -0.81428361f, 
    -0.11918863f, 0.02453741f, 0.00629408f, -0.08548471f, 0.09138605f, 0.09308628f, -0.21066709f, -0.51726907f, 
    0.07380878f, -0.00131890f, 0.14508842f, 0.03325182f, -0.23004168f, -0.05352703f, -0.13977379f, -0.23685779f, 
    0.28906870f, 0.23894139f, -0.07659253f, 0.15616535f, -0.07770807f, 0.04134099f, -0.00142070f, 0.15041023f, 
    0.04354463f, 0.04878344f, 0.03475071f, 0.27893379f, 0.65446752f, 0.33582568f, -0.01330140f, -0.03376152f, 
    -0.13280660f, -0.22215992f, 0.07938350f, -0.12560225f, -0.08536952f, 0.08568314f, 0.11338061f, 0.07774763f, 
    0.13892530f, 0.16943885f, 0.03435086f, -0.16482402f, -0.03880708f, 0.03987972f, 0.12043086f, 0.03348605f, 
    0.18668780f, 0.21394955f, 0.30077505f, 0.18935318f, -0.90955561f, 0.31987560f, 0.58090758f, 0.19443436f, 
    -0.21525821f, -0.08121579f, -0.05585658f, 0.11213332f, -0.25958788f, 0.31529796f, 0.03325411f, 0.07228652f, 
    -0.03505635f, 0.06775212f, -0.16155347f, -0.18107960f, -0.05973055f, -0.24817060f, 0.05400617f, 0.21058692f, 
    0.05470190f, -0.08273661f, -0.14724417f, 0.09178402f, -0.18669881f, 0.01205331f, -0.11807409f, -0.34123054f, 
    0.10964715f, -0.40147007f, 0.01517678f, 0.14416936f, 0.04472472f, 0.19262664f, -0.26016408f, -0.27887613f, 
    0.23324157f, -1.28133178f, -0.21020946f, -0.50783384f, -0.08862738f, -0.02385537f, 0.29835746f, -0.21971677f, 
    0.02898826f, 0.00868261f, 0.02504999f, 0.14506574f, -0.05754326f, -0.02111890f, -0.03140043f, 0.17854786f, 
    0.16598397f, 0.03439490f, -0.22090620f, -0.06183351f, 0.08009846f, -0.27213255f, -0.06413960f, -0.13767080f, 
    0.29291371f, 0.25582206f, 0.47684416f, -0.53210175f, 0.09865893f, 0.11181290f, 0.30085707f, -0.05023428f, 
    -0.01267302f, -0.14791647f, 0.24202649f, 0.06649273f, 0.39650658f, 0.17499493f, 0.28442815f, 0.01218905f, 
    0.12550996f, -0.03411060f, 0.03266160f, 0.06088346f, 0.10244460f, -0.44820860f, 0.23229754f, -0.29588774f, 
    -1.26701736f, -1.54435527f, -0.35766283f, 0.47414017f, -0.14771560f, 0.06482051f, 0.23144785f, -0.28742421f, 
    -0.14107876f, 0.00964372f, 0.05740793f, -0.00859726f, -0.02692075f, -0.35129505f, -0.39057815f, 0.07233282f, 
    -0.29004750f, 0.21210961f, 0.12431543f, -0.06088699f, -0.11290306f, -0.07109407f, 0.03051181f, 0.11280566f, 
    -0.55730158f, 0.12694985f, 0.06778192f, -0.27293146f, 0.07667647f, 0.03144112f, -0.05938321f, -0.16483033f, 
    -0.06312574f, 0.01595105f, -0.19533701f, -0.01933516f, 0.60157776f, 0.48209932f, -0.51885206f, -0.19498114f, 
    -0.09405571f, 0.02405252f, 0.38267216f, 0.03963062f, 0.21569592f, 0.41768977f, 0.05869044f, -0.03763511f, 
    -0.32592714f, -1.25873137f, 0.66919357f, 0.22421126f, 0.08438875f, -0.05647312f, -0.31562725f, 0.16358039f, 
    0.02771924f, 0.01078817f, -0.02151838f, -0.04433651f, -0.00064600f, 0.02172034f, 0.01692180f, -0.19393568f, 
    0.04567669f, -0.06749697f, -0.03929134f, 0.01434132f, 0.13766851f, 0.00652836f, -0.12832043f, -0.16392650f, 
    0.03166217f, -0.14977454f, -0.23293377f, 0.09275880f, 0.10112558f, 0.22859846f, 0.02528773f, -0.00275884f, 
    -0.26163310f, -0.14310859f, 0.02446561f, -0.13889754f, -0.87480742f, -0.26090688f, 0.39454392f, 0.11643318f, 
    0.02450449f, 0.04383975f, -0.02339136f, 0.00263423f, -0.24841057f, -0.19350012f, 0.06551014f, 0.04255717f, 
    0.11934324f, -0.15943155f, -0.04386595f, -0.11546900f, -0.06367584f, -0.03676897f, -0.07482024f, -0.01010422f, 
    0.09761407f, 0.00537400f, 0.10036948f, 0.05362906f, 1.39788830f, -1.60182345f, -0.85686284f, -0.93947536f, 
    -0.20731254f, -0.05586617f, -0.25364053f, 0.16650695f, 0.10780376f, 0.11254523f, 0.00598494f, 0.00818808f, 
    -0.02556806f, 0.12259201f, -0.25960937f, -0.06007132f, 0.23248880f, -0.08890715f, -0.02700516f, -0.19573615f, 
    -0.05238823f, 0.09786136f, -0.01342640f, -0.05686092f, -0.07109310f, 0.10231096f, 0.21408822f, 0.11845284f, 
    0.01039369f, -0.24010533f, 0.26623204f, 0.01125775f, 0.00744695f, -0.13832866f, 0.00229132f, -0.01846728f, 
    -1.55862427f, 0.95985907f, -0.48813161f, 0.28456396f, 0.01017880f, -0.11472482f, 0.05772141f, 0.19108553f, 
    0.06966208f, -0.05808779f, 0.06690316f, 0.05765207f, -0.07696959f, 0.11486776f, 0.04958189f, -0.00991097f, 
    -0.17731115f, -0.12317846f, 0.00620615f, -0.10022395f, 0.04479788f, 0.04737837f, -0.02942213f, -0.00521157f, 
    0.07906788f, 0.48268524f, -0.37289891f, 0.13195413f, -0.07143064f, -0.02891017f, -0.02411907f, 0.06072245f, 
    0.11459445f, -0.03544202f, -0.05200455f, -0.23181465f, -0.07599150f, 0.16065903f, 0.19831981f, 0.18753000f, 
    -0.07616216f, 0.18595803f, 0.02576860f, -0.01082911f, -0.06333263f, 0.01780313f, -0.19016230f, -0.07505559f, 
    -0.00809085f, -1.19248295f, 0.63693517f, -0.20359132f, -0.07626621f, 0.11698559f, -0.11935874f, 0.24557556f, 
    -0.04851233f, -0.16196015f, 0.00510147f, -0.04965119f, -0.02109694f, 0.22352491f, -0.06294341f, -0.09435937f, 
    -0.03892371f, 0.19941421f, -0.08780494f, -0.12768768f, -0.10296187f, 0.04165687f, 0.06279164f, 0.14694671f, 
    0.08722140f, 0.30549964f, -0.16446887f, 0.15916099f, 0.00138521f, -0.04715319f, 0.00519510f, -0.09172854f, 
    -0.01660511f, 0.15224281f, -0.06327086f, -0.17343511f, 0.02441444f, -0.26705596f, 0.34918591f, -0.21719924f, 
    -0.32155168f, 0.10663066f, -0.02672123f, -0.14609402f, -0.09058921f, 0.00982609f, -0.04598539f, 0.01688698f, 
    -0.44269595f, -1.08851671f, -0.69836611f, 0.08451384f, 0.04737223f, -0.16674998f, 0.06456815f, -0.02753459f, 
    0.03902373f, -0.03489242f, 0.00866634f, 0.12247946f, -0.13466983f, 0.46189484f, -0.04936980f, -0.16488068f, 
    0.09173604f, -0.01186818f, -0.05054939f, 0.03768723f, 0.02075160f, -0.11167981f, 0.08152415f, 0.15945050f, 
    -0.22571945f, 0.36230069f, 0.12946236f, 0.35681731f, -0.06426024f, -0.14899200f, -0.15890072f, -0.18619092f, 
    0.23608702f, 0.52158797f, 0.02061798f, 0.18927304f, -0.80785745f, -0.78684080f, 0.17446838f, 0.20508839f, 
    -0.14661518f, 0.28620559f, 0.00399289f, 0.19932462f, -0.25794616f, -0.28386348f, -0.13967434f, -0.06065586f, 
    -0.48876897f, 0.23688479f, 0.09048204f, 0.06943750f, 0.11068383f, -0.00935769f, -0.08273714f, -0.07266948f, 
    -0.00243088f, 0.13249829f, -0.31476256f, -0.42899641f, -0.37680137f, -0.51958692f, -0.82279748f, -0.16724515f, 
    0.04730988f, 0.02753925f, 0.38182765f, 0.06433182f, 0.11955770f, -0.08055250f, -0.28616247f, -0.10736194f, 
    0.28721008f, -0.04735009f, -0.21579082f, 0.17512399f, 0.33602929f, 0.31312820f, 0.06423891f, 0.15683474f, 
    0.11174875f, -0.08972912f, 0.13688345f, 0.13782568f, -0.37827289f, -0.01639564f, -0.00068940f, 0.12789510f, 
    0.20841843f, -0.20611243f, -0.09409938f, -0.06700652f, 0.09030510f, 0.38870305f, 0.20980540f, 0.29545224f, 
    -0.61762124f, 0.36254582f, 0.41605601f, 0.48533905f, 0.02409559f, 0.24537398f, -0.21908306f, -0.14174077f, 
    -0.06532848f, 0.03400147f, 0.06212842f, -0.01345175f, -0.23905535f, -0.15481217f, 0.00960642f, -0.10097848f, 
    0.01218110f, 0.16076829f, 0.04069519f, -0.23127890f, -0.05701705f, 0.21374121f, 0.18309540f, 0.27396882f, 
    -0.75348407f, 0.20039710f, 0.22699174f, 0.11980242f, 0.13288969f, -0.11522094f, -0.16245796f, -0.00022151f, 
    0.10874455f, -0.21326715f, -0.06904555f, 0.04241572f, -0.90889156f, -0.08887857f, 0.27778548f, 0.17375222f, 
    -0.14528203f, -0.22285415f, -0.02440175f, 0.10631496f, -0.06573316f, 0.16028127f, 0.29954189f, 0.10085894f, 
    0.47198209f, -0.02292223f, -0.86212462f, -0.52348834f, -0.13230583f, -0.25244373f, 0.12121227f, -0.34615189f, 
    0.07090348f, -0.03412460f, 0.04413926f, 0.01330699f, -0.39118382f, 0.11664114f, 0.43653339f, -0.13645321f, 
    0.20904543f, -0.15194982f, 0.05750223f, 0.03275014f, -0.10151823f, -0.01225703f, -0.00026028f, -0.13778852f, 
    -0.80857819f, -0.13257942f, 0.35997227f, -0.19444333f, -0.25124165f, -0.09888658f, -0.03038577f, -0.21924359f, 
    -0.23005770f, -0.13818800f, 0.05112765f, -0.03246332f, -0.23063679f, 0.66619760f, -0.04546154f, -0.14410633f, 
    0.25860509f, 0.06643529f, -0.11812497f, 0.15733245f, -0.21133177f, 0.01431694f, 0.16626237f, 0.03995610f, 
    -0.27922225f, -0.01544805f, -0.13444132f, -0.61929268f, -0.45639786f, 0.17515858f, -0.11439671f, 0.36152413f, 
    0.05185197f, -0.01252661f, 0.10587219f, -0.10719202f, -0.30874982f, 0.00767744f, -0.51002800f, 0.44664887f, 
    0.09473298f, 0.02666726f, 0.05051714f, -0.02965951f, 0.14414066f, -0.08857980f, 0.12060169f, -0.02373116f, 
    -0.09748618f, -0.00706659f, -0.18826692f, -0.20462225f, 0.15977958f, -0.25958058f, 0.04817978f, -0.06477711f, 
    0.03301569f, 0.30219170f, 0.00396980f, -0.06840465f, -0.05359025f, 0.57760060f, 0.48177835f, -1.00324059f, 
    -0.27747157f, -0.07474606f, -0.14313792f, -0.13722175f, 0.09651221f, 0.17798619f, 0.00237587f, 0.17553179f, 
    0.26928049f, -0.24099819f, 0.13084091f, -0.00861345f, 0.01921752f, 0.06191012f, 0.27936262f, 0.02513341f, 
    -0.02332557f, 0.02216323f, 0.22454047f, 0.46920681f, 0.40858054f, -0.07559573f, 0.42134643f, 0.24632356f, 
    -0.08055410f, -0.05059707f, -0.38457784f, -0.50380015f, 0.01972641f, -0.20720275f, 0.03491193f, 0.24719808f, 
    -0.61895710f, 0.09496087f, -0.26515964f, 0.11117671f, 0.09245966f, -0.35149479f, -0.03181851f, -0.19326352f, 
    -0.10640825f, -0.00130821f, -0.23190209f, -0.09363529f, 0.12372405f, -0.12978807f, 0.04202232f, 0.00754726f, 
    0.23911738f, -0.49075347f, 0.26958472f, 0.04431926f, 0.01744395f, -0.05007961f, -0.29907775f, -0.21700723f, 
    -0.13463525f, 0.61069065f, -0.82451618f, 0.11372662f, -0.26458022f, -0.00727785f, 0.09745836f, 0.11789735f, 
    -0.02560793f, 0.07959399f, -0.09177370f, -0.04103693f, 0.25123248f, -0.34988761f, 0.24437137f, -0.22828740f, 
    0.17243168f, 0.04725903f, -0.00316680f, 0.22826517f, 0.20650055f, 0.06785402f, -0.10636082f, -0.04464585f, 
    -0.16776548f, -0.25545147f, -0.48270160f, -0.09247513f, 0.24810360f, 0.07327120f, 0.01423884f, 0.04236963f, 
    0.02041619f, -0.44446152f, -0.05262882f, -0.16217311f, -0.06028261f, -0.38148978f, -0.37131763f, -0.29008073f, 
    -0.25702643f, -0.18129610f, 0.39990944f, -0.07330342f, -0.17144720f, 0.23154306f, 0.26095736f, 0.10419526f, 
    -0.28232720f, -0.16862431f, 0.36959061f, -0.15177761f, -0.19907808f, 0.08127022f, 0.00980545f, 0.09323895f, 
    0.12630792f, 0.13754563f, -0.04111439f, -0.02060064f, -0.09578897f, 0.28943202f, -1.10122406f, 0.02140575f, 
    0.33128282f, 0.00849067f, 0.31713608f, 0.01802492f, 0.13698865f, -0.17959930f, 0.00445571f, 0.20056100f, 
    -0.01847577f, -0.36713150f, 0.56958413f, -0.09048247f, 0.07660799f, 0.23763865f, -0.10687642f, 0.22191672f, 
    -0.02699243f, 0.04917514f, -0.15506376f, 0.23651960f, -0.02479878f, 0.17892732f, -1.27050328f, 0.17379288f, 
    -0.10164102f, 0.12111312f, 0.38130754f, -0.19701761f, 0.15875193f, -0.32675222f, -0.25937530f, -0.06638637f, 
    -0.06714338f, -0.02126187f, 0.02017863f, 0.25904202f, -0.29860905f, 0.27564380f, -0.12422521f, 0.17224135f, 
    -0.09006979f, 0.15293543f, 0.18708104f, 0.05459575f, -0.53917152f, -0.67543691f, -0.48676533f, -0.71788788f, 
    -0.30357331f, -0.25917560f, -0.03665298f, -0.08569846f, -0.08269569f, 0.01644620f, 0.17628935f, -0.05312652f, 
    -0.06237255f, 0.34038717f, 0.49190065f, 0.27021968f, -0.14711596f, -0.02933759f, 0.10562839f, 0.20794663f, 
    0.03790139f, 0.13981450f, -0.16642819f, 0.07221059f, 0.35494080f, 0.51868623f, 0.41812968f, 0.18763179f, 
    0.01914109f, 0.05880193f, 0.24177945f, 0.00218138f, -0.51451164f, 0.04738273f, -0.16479373f, -0.11403806f, 
    0.05260026f, 0.24351855f, -0.01335565f, 0.13529930f, 0.00833905f, -0.06996639f, -0.03460768f, -0.08501284f, 
    -0.04794964f, -0.22508121f, -0.48873931f, -0.54429799f, -0.41155264f, 0.66647464f, -0.54029870f, -0.25612426f, 
    0.16364236f, -0.10977247f, -0.15820417f, -0.03051780f, -0.08479479f, 0.31656957f, 0.06474023f, -0.52748394f, 
    -0.37788278f, -0.54006034f, 0.60484165f, 0.20277910f, -0.25429413f, 0.22465508f, -0.08880918f, 0.41625974f, 
    -0.11500709f, -0.04038116f, 0.09893539f, 0.12372614f, 0.10597280f, 0.07361730f, -0.19398367f, 0.52212691f, 
    -0.09986641f, 0.07946749f, 0.11369618f, 0.08078752f, -0.04336982f, -0.02735679f, 0.54311919f, 0.75253969f, 
    0.29260707f, -1.06181037f, 0.20048107f, 0.14676447f, -0.08186697f, 0.02184912f, 0.42382112f, -0.40181431f, 
    0.15095748f, 0.10071009f, -0.03141751f, -0.26217458f, -0.37630141f, 0.06093999f, -0.03645119f, -0.07613334f, 
    -0.20439343f, -0.12246028f, -0.43893659f, 0.28962591f, -0.22256546f, 0.06194523f, 0.00879071f, 0.18362303f, 
    -0.51049614f, 0.30548581f, 0.40337574f, -0.31932840f, 0.18243539f, -0.11442975f, -0.31117684f, 0.65755677f, 
    -0.20465085f, 0.16054499f, 0.35685506f, -0.06924172f, 0.34294733f, -0.33510405f, -0.44796827f, 0.59993142f, 
    -0.06872731f, -0.03821306f, 0.04812395f, -0.41608283f, 0.07110863f, 0.11687239f, -0.01846387f, -0.15708704f, 
    -0.38671052f, -0.32917160f, -0.65242022f, 0.07542555f, 0.00816572f, -0.05133327f, -0.44140300f, 0.02268543f, 
    0.09279142f, 0.01209936f, 0.00514260f, -0.10732559f, 0.24758686f, -0.35321552f, -0.15316756f, 0.01745851f, 
    -0.37290844f, -0.12371191f, -0.02298402f, -0.26124954f, -0.21388800f, 0.08730479f, -0.35544232f, -0.09511182f, 
    -0.13304242f, -0.43790460f, -0.37616929f, 0.36519682f, -0.36576486f, -0.37296817f, -0.32196757f, 0.05285819f, 
    0.34999737f, -0.18690424f, -0.11679298f, 0.20193967f, -0.07073288f, 0.52041066f, -0.40263817f, -0.01218632f, 
    -0.32103381f, 0.04140021f, 0.31949174f, -0.12690416f, -0.17709549f, 0.10406530f, 0.13468389f, 0.17277998f, 
    -0.36113027f, -0.48751622f, 0.09173000f, 0.18040811f, -0.10519923f, -0.18850531f, 0.11807895f, -0.23760141f, 
    0.16993065f, -0.06394301f, -0.06938842f, -0.24188514f, 0.77930605f, 0.02227802f, 0.29885402f, -0.36042774f, 
    0.15672123f, 0.15130034f, -0.13235514f, -0.00776591f, -0.20340271f, 0.02510804f, -0.01019999f, -0.03209838f, 
    -0.08176072f, -0.32293117f, 0.54319614f, -0.18265286f, 0.15059988f, -0.23637374f, -0.03103844f, 0.05449439f, 
    -0.09476161f, 0.11776283f, 0.10143290f, -0.04739340f, -0.90729040f, 0.41946635f, -0.33883280f, 0.22937499f, 
    -0.30205259f, -0.13460623f, 0.23028947f, 0.18233758f, -0.12990528f, 0.15534647f, -0.12865707f, -0.06796657f, 
    0.11969392f, 0.01913858f, 0.07168742f, 0.21538670f, 0.10843676f, -0.00490355f, 0.01271351f, 0.32845372f, 
    0.17126420f, 0.10141367f, 0.18070854f, 0.02263318f, -0.62542254f, 0.25737548f, -0.66009158f, 0.10192188f, 
    0.18916115f, -0.27690595f, 0.07964415f, 0.15605487f, -0.22234493f, 0.08208434f, -0.07835088f, -0.11838118f, 
    0.24774188f, 0.18185258f, 0.60807866f, -0.20729838f, 0.06715351f, 0.04752387f, -0.07637672f, 0.24195608f, 
    -0.02224237f, -0.18104957f, -0.13602860f, -0.15256238f, 0.03110841f, -0.12749004f, 0.24954490f, -0.32685894f, 
    -0.16321413f, 0.32735246f, -0.41616806f, 0.41424781f, -0.27775446f, -0.05950300f, 0.02523309f, -0.54417843f, 
    0.14420560f, -0.43671227f, 0.81349528f, -0.47744370f, -0.25815105f, -0.17491059f, -0.54564214f, -0.12095664f, 
    -0.09052605f, 0.07048845f, 0.07383973f, 0.01715623f, -0.02187653f, 0.18959093f, -0.16239499f, 0.00395076f, 
    0.01267347f, 0.28015351f, -0.06216977f, 0.23359106f, 0.02700700f, -0.20364401f, -0.20255063f, -0.33277220f, 
    0.37485227f, 0.08773584f, 0.19652653f, 0.07951981f, -0.02743669f, -0.01092300f, 0.04148005f, 0.14379644f, 
    -0.24302736f, -0.04475824f, -0.14162304f, 0.27498341f, -0.00076024f, -0.39898258f, 0.34836531f, -0.06742247f, 
    0.06794546f, 0.35512546f, -0.05771198f, 0.15655707f, -0.13056527f, -0.12118610f, -0.00539899f, 0.18424565f, 
    -0.55256265f, -0.72489810f, -0.00174201f, 0.28581387f, -0.36171961f, -0.16461439f, 0.13863811f, -0.27477214f, 
    0.03838143f, 0.13560764f, 0.07149582f, -0.10972055f, 0.69696110f, -0.30284551f, 0.49914542f, -0.11768477f, 
    0.15844129f, -0.12584166f, 0.28988057f, 0.14381786f, -0.13360704f, -0.05151793f, -0.08716766f, -0.11603797f, 
    -0.13958213f, 0.27650961f, -0.19361317f, -0.30571008f, -0.06619868f, -0.02192127f, 0.21314181f, -0.00618113f, 
    -0.22502956f, 0.04916497f, -0.00767332f, -0.10731885f, 0.68137515f, -0.69079697f, 0.71745992f, 0.62082833f, 
    0.12203664f, -0.12623526f, -0.02911911f, 0.07913680f, -0.13796003f, 0.04908661f, 0.05307880f, -0.05968310f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.35615680f, 0.05506294f, 0.29802510f, -0.08346416f, -0.27202284f, 0.17384705f, 0.05402283f, -0.21928410f, 
    0.23287462f, -0.04282506f, 0.02713480f, -0.01704745f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
