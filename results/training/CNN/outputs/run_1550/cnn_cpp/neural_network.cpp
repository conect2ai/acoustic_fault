#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.02177846f, 0.23893087f, 0.05885287f, -0.33860335f, -0.89386159f, -0.70028448f, 0.91157609f, -0.28591561f, 
    0.53320825f, 0.26711866f, -0.54478109f, 0.36142111f, -0.63658500f, -1.30205941f, -1.16884828f, -0.56561452f, 
    0.63899529f, -0.87598860f, 0.94222975f, 0.18362413f, -0.31617281f, 0.29286215f, 0.77764231f, 0.40486783f, 
    0.14522730f, 0.27380243f, 0.43264106f, -0.65654123f, 0.69442093f, -0.07355174f, 0.58024287f, -0.21191072f, 
    0.50332767f, 0.11030757f, -0.42309070f, -0.26755035f, -0.49223685f, -0.47939938f, 1.00225317f, 0.26584616f, 
    -0.16005385f, 0.26867667f, -0.14544739f, -0.98691964f, -0.32369646f, 0.66413802f, -0.30339861f, 0.36945418f, 
    -0.53510594f, 0.01287021f, -0.80347139f, -0.52186996f, -0.41731209f, -0.20837073f, 0.18956546f, 0.28612882f, 
    0.61765116f, 0.99677515f, -0.80879337f, -0.77146602f, -0.16368391f, -0.23226611f, -0.16893554f, -0.01610113f, 
    0.05608751f, 0.08880368f, 0.71148545f, 0.59500974f, -0.57769454f, -0.03701711f, 0.62131423f, -0.44556582f, 
    -0.52297586f, 0.62414753f, -0.17421135f, 0.36867693f, 0.65908879f, 0.23315573f, 0.37162572f, 0.12029626f, 
    0.31057829f, -1.25989258f, 0.66315591f, 0.20733768f, -0.57043362f, -0.13424499f, -0.30843425f, -0.11950252f, 
    1.03305304f, -0.90900660f, 0.46519235f, 0.93921101f, 1.10987246f, -0.91159397f, -0.87746876f, -0.40026379f, 
    0.32558119f, 0.38604882f, 0.60371244f, 0.78231329f, 1.53686309f, -1.19564462f, -0.78356564f, -0.26973408f, 
    0.14459935f, -0.37002465f, 0.27631611f, 0.39487284f, 0.27324623f, -0.09425917f, -0.88967222f, 0.75038886f, 
    -0.12585557f, -0.41353178f, 0.05038094f, 0.71262521f, 0.72985941f, -0.00920258f, -0.20841898f, -0.92515993f, 
    -0.75953364f, -0.41966698f, -0.23998174f, 0.13898054f, -0.59949261f, -0.25975826f, -0.35555115f, 1.39186406f, 
    -0.92014688f, 0.71341878f, -0.72232932f, -0.22579990f, 0.30085939f, -0.12091459f, 0.28666183f, 0.26633874f, 
    -0.33851203f, 0.30476385f, -0.63652760f, -0.05819948f, 1.01410341f, -0.51517755f, 0.05023777f, 0.71086353f, 
    0.38023084f, 0.70145619f, 0.58322912f, 0.19821225f, 0.64309734f, 0.20087507f, 0.05725636f, -0.08623391f, 
    0.29110211f, 1.12544167f, 0.02317748f, 0.41753367f, -0.58316833f, 0.05147391f, -0.31101725f, 0.19086474f, 
    0.30831322f, 0.43380919f, 0.04564102f, 0.18013550f, 0.56129581f, 0.69912356f, -0.18549514f, 0.60487109f, 
    0.05904737f, -0.43417978f, 0.25340280f, -1.52552438f, 0.16175888f, -0.76599199f, -0.27963257f, 0.66524184f, 
    1.00296760f, 0.13378344f, 0.54410470f, 0.39163381f, 0.26599881f, 0.69058818f, 0.17439273f, 0.57284576f, 
    0.42955309f, 0.69274068f, 0.22470227f, -0.62559998f, -0.06807742f, -0.09344597f, 0.63145661f, -0.19626288f, 
    -0.29193649f, 0.66279906f, 0.19348724f, 1.00948727f, -1.01995611f, -0.54057556f, 0.32989812f, -0.90484858f, 
    -0.91332573f, -0.17742030f, 1.25205660f, -0.23274475f, -0.50731862f, -0.41777891f, -0.48701513f, -0.02887625f, 
    -0.58420730f, -0.42144591f, -1.39349806f, -0.67431939f, -0.95340967f, 0.44394961f, 0.54183686f, 0.36888093f, 
    0.78812820f, 0.52117807f, -0.16990052f, -0.01246491f, -0.09776929f, 0.18051355f, 0.15862459f, -0.69834036f, 
    0.16362485f, 1.14814520f, 0.69426030f, -0.85262066f, 0.40435022f, -0.04308822f, 0.07103000f, 0.03854948f, 
    0.19229271f, -0.65654856f, -0.79868436f, -0.99934608f, -0.48202184f, -0.37325189f, -0.37663642f, -0.55936301f, 
    0.05000933f, -0.04495944f, 0.28679094f, -0.82263315f, 0.17955659f, 0.38898823f, -0.08405788f, -0.58213854f, 
    -1.15494442f, -0.19680417f, -0.63602030f, -0.73318022f, -0.52738160f, -0.43201637f, -0.80198067f, 0.32072100f, 
    -1.24539530f, -0.49718893f, -0.38384849f, -0.18176070f, 0.15639828f, -0.27132204f, 0.53250068f, -0.35447785f, 
    -0.26023036f, 0.62219125f, -1.07598317f, 0.19619280f, 0.54916632f, 0.60382921f, -1.08492053f, -0.88865525f, 
    -0.72469300f, 1.66059029f, 0.22071750f, -0.07469767f, -0.11233059f, -0.52268004f, -0.46931618f, -1.23313344f, 
    -0.72411907f, -0.45286712f, -0.03276224f, 0.95350784f, -1.18197441f, -0.37342840f, -0.49895465f, -0.24412332f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.17874134f, 0.21961108f, -0.09696791f, 0.31384784f, 0.30418140f, 0.35012767f, 0.24319521f, 0.60543674f, 
    -0.50893819f, 0.33575767f, 0.17939962f, -0.01842409f, 0.44956458f, 0.74510646f, -0.23837079f, 0.70829242f, 
    0.01121197f, 0.75016820f, 0.46857664f, 0.48680288f, -0.22206472f, 0.33623609f, -0.17355722f, -0.13373215f, 
    -0.07826415f, 0.25094646f, -0.22749750f, 0.32512131f, -0.41579005f, 0.12087010f, -0.10912517f, 0.07448628f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04103743f, 0.00551032f, 0.00896564f, -0.03045114f, 0.04577404f, -0.04101213f, 0.04601731f, -0.05898988f, 
    -0.00987112f, 0.02520871f, -0.06590398f, 0.00977498f, -0.06502824f, -0.05743787f, 0.01772626f, 0.02628807f, 
    -0.01650071f, 0.03565343f, -0.01226227f, -0.00156457f, -0.05230335f, 0.03222862f, 0.01175698f, -0.04014510f, 
    -0.04509234f, 0.01576682f, 0.03894661f, -0.06342414f, 0.04501019f, 0.04778524f, 0.01169487f, 0.02745828f, 
    0.02296710f, -0.02740608f, -0.04555773f, -0.04241321f, 0.01708002f, -0.00402624f, -0.03957177f, -0.03413403f, 
    0.03053464f, -0.03373187f, 0.01423092f, -0.05944811f, -0.04543535f, -0.02712773f, 0.04277423f, -0.05042235f, 
    -0.01004757f, 0.01535859f, -0.05564292f, -0.06426633f, -0.00281464f, -0.02397849f, -0.05795732f, -0.04168596f, 
    -0.03857816f, -0.02764602f, 0.04615662f, -0.00689293f, -0.00888986f, 0.00063972f, -0.02046678f, 0.00310392f, 
    -0.02664925f, -0.02315619f, -0.04010003f, -0.02141267f, -0.05159597f, -0.01467904f, -0.03008194f, -0.05851087f, 
    -0.05018558f, -0.06464386f, -0.04623251f, -0.04704326f, -0.01098138f, -0.00464222f, -0.03229782f, -0.05142646f, 
    -0.00282451f, 0.01166616f, 0.00024690f, -0.04925436f, -0.03388976f, 0.01776651f, 0.00581733f, -0.03326941f, 
    -0.01770539f, -0.01215974f, -0.02700166f, 0.02430174f, -0.02157463f, -0.05561376f, 0.04375308f, -0.03745274f, 
    -0.03474894f, 0.03102473f, 0.01186853f, 0.01142973f, 0.03829671f, 0.02958950f, -0.04338640f, -0.03391766f, 
    -0.02144912f, -0.05625892f, -0.06395283f, -0.02643305f, -0.03491865f, -0.03927569f, 0.04564476f, -0.00167049f, 
    0.00048915f, -0.05542940f, 0.00949918f, -0.02229904f, 0.03493048f, -0.01679103f, 0.04793973f, -0.02976746f, 
    -0.01006861f, 0.02196973f, -0.02508427f, 0.01468260f, 0.01751480f, -0.06044263f, -0.05016629f, -0.01057806f, 
    -0.03940305f, 0.05021301f, -0.01799801f, -0.04905538f, -0.03105429f, -0.04183466f, 0.03223138f, 0.01794108f, 
    -0.03332669f, -0.03069409f, -0.01182323f, 0.04687116f, -0.01883218f, 0.01036024f, -0.03242119f, 0.03042535f, 
    0.03379389f, -0.03812107f, -0.00461713f, 0.04777955f, -0.01473682f, -0.01628025f, -0.03695567f, -0.05296870f, 
    0.03341921f, 0.00069646f, 0.04786998f, -0.01016466f, 0.01154318f, -0.03963228f, 0.03749319f, -0.00434747f, 
    -0.02505092f, 0.03827719f, 0.05046955f, -0.04228655f, -0.01163681f, 0.03830380f, -0.03223586f, -0.05763097f, 
    -0.03865960f, 0.03344656f, 0.00194947f, 0.03477594f, 0.03053851f, -0.05810592f, -0.01463628f, -0.02331073f, 
    -0.02524341f, 0.04871793f, -0.02733780f, -0.00305326f, -0.02859168f, -0.01726448f, 0.00947960f, -0.03966627f, 
    0.01934855f, 0.03535106f, 0.04892804f, 0.00219900f, 0.01567278f, -0.01764164f, -0.03409390f, -0.01900494f, 
    0.02808770f, 0.02253571f, 0.01615913f, 0.04391027f, -0.00976825f, -0.02235681f, -0.01987496f, 0.03861988f, 
    0.00355791f, 0.00662403f, 0.00997244f, 0.03847050f, -0.06604341f, -0.04801002f, -0.02619980f, -0.01785022f, 
    -0.01518750f, -0.03365882f, 0.01782663f, -0.00686393f, 0.03128656f, -0.01074467f, 0.01415152f, -0.00641694f, 
    0.02909059f, 0.05159592f, 0.01501311f, -0.06004868f, 0.03869647f, -0.02830680f, 0.02883373f, -0.01143794f, 
    -0.01605614f, 0.02271276f, -0.06586951f, 0.01280695f, 0.01777084f, 0.04955787f, 0.03804462f, -0.05057469f, 
    0.01910757f, -0.05817986f, 0.05034203f, -0.05860351f, -0.04635335f, -0.03335283f, 0.03059856f, 0.01471340f, 
    -0.00651326f, -0.03547047f, 0.00303974f, 0.00896378f, 0.00615737f, -0.02915354f, 0.03901627f, -0.05601108f, 
    0.02673582f, -0.03456677f, 0.04011991f, -0.03842178f, -0.03753262f, 0.04333825f, -0.02968642f, 0.01178651f, 
    -0.06675487f, 0.00164218f, 0.01695726f, -0.05849892f, 0.04392675f, -0.02460580f, 0.01438977f, 0.02878552f, 
    -0.06348316f, -0.01553498f, -0.00640176f, -0.03416798f, -0.03224626f, 0.04622887f, 0.01121124f, -0.06599168f, 
    -0.05239994f, -0.00714237f, 0.03370946f, -0.01448231f, 0.01213118f, -0.02803408f, -0.01133558f, 0.02102625f, 
    -0.05667846f, 0.02691754f, 0.02760327f, 0.04300855f, 0.02580709f, -0.03516661f, 0.00157767f, -0.04013396f, 
    0.17183332f, -0.03124290f, -0.02205958f, -0.16403595f, 0.04562757f, 0.17876552f, 0.11418740f, 0.28832215f, 
    -0.06945915f, -0.16255075f, -0.36354980f, -0.40029609f, 0.27168941f, 0.05529955f, 0.06901307f, 0.16757461f, 
    0.00488239f, -0.12760535f, 0.21608879f, -0.04122255f, 0.01444806f, 0.41949126f, 0.36004883f, 0.05491286f, 
    -0.11286841f, -0.10843245f, 0.00807742f, 0.09325108f, -0.04913406f, -0.00351665f, 0.01282856f, -0.02084283f, 
    -0.14219059f, -0.01111422f, 0.01979972f, -0.37537369f, 0.00668155f, 0.11581384f, 0.09924638f, -0.00823040f, 
    -0.17502564f, 0.12498989f, -0.53391826f, 0.04089877f, -0.83161736f, -0.05938023f, 0.08173709f, -0.10249815f, 
    0.15924989f, -0.07887610f, 0.00441710f, -0.04274417f, 0.02581137f, -0.19104125f, -0.03527598f, -0.20493473f, 
    0.14446767f, 0.06699064f, 0.06352576f, -0.00414527f, 0.21253829f, -0.14430791f, -0.13982964f, -0.12084409f, 
    0.34206739f, -0.20560642f, 0.39999717f, 0.15126616f, 0.11485353f, -0.11287477f, 0.04804952f, 0.16628703f, 
    0.02299638f, -0.00374134f, -0.04164182f, 0.33787602f, 0.19291556f, 0.04626811f, -0.03738717f, -0.03143537f, 
    0.00331386f, -0.14498256f, -0.08873118f, -0.01117470f, 0.04181218f, -0.09543238f, 0.10190081f, 0.11254791f, 
    0.05231813f, -0.16582401f, 0.13421105f, -0.30893853f, 0.34884182f, 0.14959720f, 0.18434848f, 0.19446053f, 
    0.13438848f, 0.23317054f, -0.03378207f, 0.02391253f, -0.03462451f, 0.44734323f, -0.06226982f, 0.51586622f, 
    0.02823577f, 0.10770321f, 0.01138120f, 0.16785066f, -0.12008421f, 0.09567644f, 0.02919023f, 0.01296730f, 
    0.13447981f, -0.23972130f, 0.04157997f, 0.07239257f, 0.17273526f, 0.17413470f, 0.10004313f, 0.03282176f, 
    0.02611792f, -0.02946617f, 0.06086076f, -0.11070792f, 0.00311227f, 0.05563853f, -0.20275174f, 0.28319606f, 
    0.39410508f, 0.22556950f, -0.25102019f, -0.06772467f, 0.07456369f, 0.53147131f, -0.00432505f, 0.48811260f, 
    -0.10756952f, 0.21859054f, 0.48623177f, 0.05540515f, -0.26380536f, 0.07852580f, -0.01630437f, 0.02719849f, 
    0.08992315f, -0.06231417f, 0.01593648f, 0.03502600f, -0.10057371f, -0.05135738f, 0.04683059f, -0.12841560f, 
    -0.18981467f, 0.06239732f, -0.07225105f, 0.12587434f, 0.11438212f, 0.20583732f, 0.13573080f, 0.04133408f, 
    0.31743553f, 0.29421189f, -0.02945750f, -0.08466078f, -0.04170015f, 0.04630091f, -0.01493661f, -0.02929602f, 
    -0.03735427f, -0.07879613f, -0.27487206f, 0.06394810f, -0.23540619f, 0.02671736f, -0.11403123f, -0.14602688f, 
    -0.19287339f, 0.15461852f, 0.00503732f, 0.07873131f, -0.00562074f, -0.15118252f, 0.04872099f, 0.01493796f, 
    -0.18940116f, -0.09131406f, 0.03881584f, -0.25807145f, -0.40975660f, 0.38024232f, 0.14841715f, -0.07710631f, 
    -0.32707271f, -0.19020423f, 0.18929607f, -0.21229157f, -0.25360847f, -0.34325638f, 0.06340542f, -0.03959212f, 
    -0.03391603f, 0.07270394f, -0.05443019f, -0.10544194f, -0.13722944f, -0.43583325f, -0.19700226f, 0.18436034f, 
    0.18127742f, -0.11394709f, 0.06357588f, 0.02366946f, 0.18085732f, 0.12902308f, 0.25280398f, 0.10043407f, 
    0.18837422f, -0.02502457f, 0.07819211f, -0.05749833f, -0.01413267f, -0.03404471f, -0.01332130f, -0.18081522f, 
    0.02120024f, -0.03260199f, -0.01723788f, -0.00315631f, 0.08547169f, 0.02834104f, -0.00918949f, 0.09223478f, 
    -0.16882278f, -0.24617700f, 0.08724343f, -0.48704928f, -0.15929615f, 0.06261929f, 0.02350761f, -0.02803236f, 
    0.14867561f, 0.06395528f, 0.14464776f, -0.02412737f, -0.21057470f, 0.15003955f, 0.12216587f, -0.02225737f, 
    -0.00999864f, -0.06270412f, -0.35988852f, -0.42970055f, 0.38279060f, -0.21312912f, -0.06166317f, 0.21852262f, 
    0.06266525f, 0.00524612f, 0.02675670f, 0.12345317f, 0.23326556f, -0.16661049f, 0.19406998f, -0.02408639f, 
    -0.05721480f, -0.00750559f, 0.03845808f, 0.31354603f, 0.34978405f, 0.10867168f, 0.09859439f, 0.16091512f, 
    -0.43273109f, 0.16682257f, -0.02814291f, 0.22114670f, -0.30961394f, -0.43610686f, -0.12280624f, 0.13022077f, 
    0.07045052f, 0.36092457f, 0.02416366f, -0.07057277f, -0.08608292f, -0.10088062f, -0.29312512f, 0.16081445f, 
    -0.05942865f, 0.00390949f, 0.00452838f, 0.03268815f, -0.00922078f, 0.00574216f, -0.03846641f, -0.00933892f, 
    0.02974571f, -0.03419801f, -0.03378435f, -0.01064687f, -0.02610769f, -0.04197578f, -0.06367353f, -0.05332310f, 
    -0.02932763f, -0.04993389f, 0.01920799f, 0.03585527f, -0.04947716f, 0.00929799f, 0.00386791f, -0.05114091f, 
    0.01975328f, 0.04788589f, 0.03962946f, -0.06543603f, 0.00925500f, -0.05914187f, -0.03100795f, -0.01605516f, 
    0.04016797f, -0.03669052f, -0.05705581f, -0.03728291f, -0.02183311f, 0.02328478f, -0.02339981f, -0.02503288f, 
    -0.01483338f, 0.04388911f, -0.04825576f, -0.02732509f, -0.05046509f, -0.02390005f, -0.06278123f, 0.02127099f, 
    0.00039661f, -0.01133237f, -0.05814558f, -0.03230366f, 0.02540880f, 0.00871164f, 0.04698436f, -0.00966819f, 
    0.03428340f, -0.01789243f, -0.02955026f, 0.01498762f, 0.05146180f, -0.02974100f, -0.00687418f, -0.03285692f, 
    0.01706691f, -0.05022734f, 0.02387327f, 0.01911806f, -0.05732096f, -0.00991782f, 0.04526435f, 0.02282606f, 
    0.00285096f, -0.03890365f, 0.04948365f, -0.06181764f, -0.00229139f, -0.05597350f, -0.00506200f, -0.00735711f, 
    -0.06087842f, -0.00082114f, -0.02258369f, 0.02172516f, -0.06439678f, -0.00209494f, -0.00352995f, 0.04045419f, 
    -0.03153565f, 0.00336220f, -0.00729955f, 0.02347712f, -0.02085333f, -0.05831390f, -0.02698559f, 0.02140871f, 
    -0.03693479f, 0.00266003f, -0.05749177f, -0.03053565f, -0.01110551f, -0.01005573f, -0.02851286f, -0.03226173f, 
    -0.00849561f, -0.06134386f, 0.02332130f, -0.06395185f, -0.02937246f, 0.02933831f, 0.02686934f, 0.02729731f, 
    -0.05912007f, 0.00090512f, -0.03681456f, 0.04857638f, 0.02319110f, -0.00963481f, 0.04531037f, -0.03651760f, 
    0.05204104f, -0.03559177f, -0.05346393f, -0.02180072f, 0.04562353f, 0.02067056f, 0.04271882f, -0.01819743f, 
    -0.00199034f, -0.02781035f, 0.04799543f, -0.04284968f, 0.01080675f, 0.02545068f, 0.04466002f, -0.04618011f, 
    -0.05200390f, -0.03747966f, -0.02700540f, -0.01895371f, 0.02792708f, 0.01889552f, -0.05961062f, 0.02830118f, 
    -0.00289914f, 0.01392533f, -0.02897498f, -0.00243988f, -0.00015158f, -0.01785297f, 0.01845519f, -0.04608099f, 
    0.01310865f, 0.04599978f, 0.03350019f, -0.00380387f, -0.05157315f, 0.00338332f, 0.03887173f, -0.04376724f, 
    0.05038626f, -0.01418320f, -0.04231225f, -0.04583590f, -0.01686332f, 0.02330938f, -0.04116063f, -0.01182875f, 
    -0.04876276f, -0.05811921f, -0.04078784f, -0.02073901f, 0.03052547f, -0.02609894f, -0.04055772f, 0.01755063f, 
    0.00013262f, -0.05194388f, 0.01460661f, 0.00902662f, 0.02901897f, -0.04131805f, 0.03901802f, 0.00284994f, 
    0.04242906f, 0.04943470f, 0.02428635f, -0.05236829f, -0.00917227f, -0.05601203f, 0.04682869f, -0.05564271f, 
    0.00718852f, -0.03841626f, -0.00686949f, -0.06470671f, -0.06007910f, 0.04802521f, -0.06445261f, 0.01075049f, 
    -0.05873048f, -0.03012568f, 0.01406075f, 0.00866493f, -0.04871123f, -0.03875007f, -0.05418133f, -0.02417115f, 
    0.01873944f, 0.03865925f, -0.05871215f, -0.05370978f, -0.01815969f, 0.00514873f, -0.01196704f, -0.04941199f, 
    0.03264664f, -0.01502593f, 0.01251429f, -0.02804664f, -0.01278822f, 0.02144246f, 0.02227792f, 0.01239428f, 
    -0.06484469f, 0.03058705f, -0.06449661f, 0.03052882f, -0.02135495f, 0.01606944f, -0.06675008f, 0.00329436f, 
    0.03162618f, -0.02076640f, 0.04959059f, 0.02275728f, 0.03565660f, -0.02610258f, -0.02754046f, 0.05421523f, 
    0.02657169f, -0.01406077f, 0.04441538f, -0.04436093f, 0.04579452f, -0.02771505f, 0.01643697f, -0.03968876f, 
    -0.03233132f, -0.01288141f, 0.03663544f, 0.00909092f, 0.02934047f, -0.00521087f, 0.00503127f, -0.01416336f, 
    -0.03078439f, 0.01266971f, 0.01410445f, -0.01131905f, 0.00713353f, -0.04388360f, -0.05460156f, 0.03437034f, 
    0.03509102f, -0.00020946f, 0.00962297f, -0.00979381f, 0.03028890f, -0.02849292f, -0.00350255f, -0.05135891f, 
    -0.04111981f, -0.04788185f, 0.05363282f, -0.06075303f, 0.04382433f, 0.02517687f, 0.02786396f, -0.00035801f, 
    -0.05523547f, -0.03739621f, -0.05654820f, -0.03661479f, -0.03895132f, -0.01475648f, -0.05099287f, 0.03352936f, 
    0.03982507f, 0.03723624f, -0.00345814f, 0.04432182f, -0.00503877f, -0.03240689f, 0.01764716f, 0.04585364f, 
    -0.03080670f, 0.01728651f, 0.01599107f, -0.05975555f, 0.01343207f, 0.04491151f, -0.01100547f, -0.04543274f, 
    0.03048972f, -0.00946031f, -0.03915454f, -0.04300096f, -0.03372293f, -0.02458996f, 0.04631235f, -0.00325882f, 
    0.02488269f, -0.05227354f, -0.01123235f, -0.00673014f, -0.04617585f, -0.04299693f, -0.06438564f, 0.04124039f, 
    -0.06567818f, -0.00726741f, -0.02823029f, 0.02402710f, -0.04467187f, -0.05887489f, -0.04503975f, -0.00710048f, 
    0.04372940f, -0.06498466f, -0.03912213f, 0.02414483f, 0.02385706f, 0.05035952f, 0.01607934f, -0.02109896f, 
    0.00328184f, -0.00639382f, -0.01490664f, -0.04915492f, -0.02214884f, 0.02435962f, 0.05552690f, -0.04996360f, 
    -0.02174997f, -0.02836729f, 0.00036030f, 0.03698164f, 0.04041961f, 0.00497520f, -0.05587434f, 0.04960325f, 
    -0.06293108f, -0.03483367f, 0.05135808f, 0.04566333f, 0.04312718f, 0.03602188f, -0.00858407f, 0.00966760f, 
    0.00668977f, -0.02897521f, 0.00837599f, -0.02217111f, -0.00431481f, -0.04498296f, -0.06449457f, -0.05033802f, 
    -0.01990471f, -0.02706814f, 0.03143359f, -0.04800480f, 0.00235751f, -0.05500978f, -0.05361385f, 0.02440322f, 
    0.05073655f, -0.06214226f, 0.02460168f, -0.04320741f, 0.00486757f, 0.00882640f, 0.04991816f, -0.05188604f, 
    0.01526909f, -0.06193811f, 0.01996338f, 0.03743792f, -0.02933550f, 0.01034610f, -0.04851178f, -0.02405400f, 
    -0.06098540f, -0.00512272f, -0.05451510f, 0.00110031f, -0.02795407f, 0.01182986f, 0.03666575f, 0.02723980f, 
    -0.03159064f, -0.04394729f, 0.02622925f, -0.01606393f, 0.03531112f, -0.02857314f, 0.02437605f, -0.01848883f, 
    0.01567872f, 0.04818643f, -0.00304142f, -0.03701485f, 0.04758789f, 0.02033886f, -0.05227508f, -0.04481042f, 
    0.01899683f, 0.02220860f, 0.02504388f, 0.05157506f, 0.02616897f, 0.04029055f, -0.01808118f, -0.06161494f, 
    -0.03213441f, 0.01747677f, -0.01896149f, 0.04283096f, 0.02804676f, -0.00726036f, 0.04128971f, 0.03460588f, 
    0.03816199f, -0.01306509f, -0.05188914f, -0.04150852f, 0.04563142f, 0.00375504f, -0.02896946f, -0.02817262f, 
    -0.00031744f, -0.04705788f, -0.00400472f, -0.04158131f, -0.05344604f, -0.02146848f, 0.02412038f, 0.03005512f, 
    -0.06456520f, -0.01898184f, 0.01596279f, -0.01692022f, 0.04598120f, -0.03481694f, 0.01602306f, -0.06647009f, 
    -0.01699720f, -0.05900417f, 0.02068395f, -0.02114604f, 0.00897974f, 0.03614414f, -0.00862630f, -0.01447571f, 
    -0.05374852f, 0.01453548f, 0.04230271f, -0.01913604f, 0.05426122f, 0.01334848f, 0.02991871f, -0.04217891f, 
    -0.01404360f, 0.03790414f, 0.02445642f, 0.02866000f, 0.00258169f, -0.04697398f, -0.05185803f, 0.03529098f, 
    0.01903937f, 0.00141955f, -0.06083427f, 0.03435936f, -0.06663049f, 0.00406689f, 0.00192790f, -0.04645300f, 
    -0.02790583f, -0.01837000f, -0.00239875f, 0.03136357f, 0.03170037f, -0.04667818f, -0.02381997f, 0.01136594f, 
    -0.05061746f, 0.00915873f, 0.03982833f, -0.02246924f, 0.03927596f, 0.02300564f, -0.02007132f, 0.01348301f, 
    -0.02095856f, -0.05099379f, 0.05818048f, 0.04782245f, -0.04218593f, -0.04440707f, -0.01838261f, 0.04581376f, 
    0.02216101f, -0.00845213f, -0.04880035f, 0.00368738f, 0.01845217f, 0.04705145f, -0.02890112f, -0.01148349f, 
    -0.02899908f, -0.03791025f, -0.07011536f, 0.01495883f, -0.02023208f, -0.02522870f, 0.01209116f, -0.05561858f, 
    -0.02282870f, -0.02283759f, 0.00118054f, -0.06686349f, -0.02625747f, 0.03529911f, -0.02191564f, -0.06257182f, 
    0.02615989f, -0.03713239f, 0.05025983f, -0.04608731f, -0.05939715f, -0.03182375f, 0.04737848f, -0.03020035f, 
    0.01875192f, 0.00576597f, -0.05725098f, -0.04958449f, -0.04788670f, 0.00871926f, -0.04878572f, -0.00377349f, 
    -0.01854874f, -0.05399767f, -0.04950674f, -0.02292806f, 0.01079619f, 0.00442578f, -0.00416615f, -0.04107700f, 
    -0.05802397f, 0.03806059f, -0.01668548f, -0.03416528f, -0.04966314f, 0.05564026f, -0.00277541f, -0.05881888f, 
    0.03122633f, -0.01621309f, 0.03439291f, 0.00760599f, -0.05887868f, -0.03288861f, 0.04121488f, -0.04683779f, 
    0.04104008f, 0.49060884f, 0.34548017f, -0.07825113f, -0.11977568f, 0.38034645f, -0.11839281f, 0.05601303f, 
    0.20557228f, -0.16469800f, 0.06688217f, -0.28211662f, -0.11892623f, 0.07815790f, -0.16283122f, 0.09315118f, 
    -0.12765716f, 0.22017458f, 0.07057253f, -0.59871399f, -0.57543421f, -0.31702134f, 0.02692884f, -0.03079666f, 
    0.18822879f, 0.27043635f, 0.24334976f, -0.60789520f, 0.45062616f, 0.12617216f, 0.11551612f, -0.00924692f, 
    -0.08300179f, -0.15456624f, 0.21048924f, -0.11460031f, 0.38100576f, 0.23060405f, 0.02494385f, 0.04237786f, 
    -0.03037693f, 0.07787029f, 0.11423311f, -0.11612149f, -0.30279526f, -0.16886914f, -0.14658643f, -0.03396231f, 
    0.03697176f, -0.07434589f, 0.05720372f, 0.03452601f, -0.12762690f, -0.17267559f, -0.51531571f, -0.28101221f, 
    -0.35358396f, -0.03815262f, -0.14415078f, -0.07595704f, 0.02184987f, -0.19034155f, -0.01907704f, -0.25479454f, 
    -0.01609036f, -0.15263793f, 0.09687702f, 0.10539373f, 0.00795038f, -0.04440138f, 0.24945679f, -0.12741870f, 
    -0.43915507f, -0.64315885f, -0.45146191f, -0.57876909f, -0.40589130f, 0.15097234f, -0.00770570f, 0.35417047f, 
    -0.12488020f, -0.47560039f, 0.05212889f, 0.21378808f, -0.19239186f, 0.11457631f, 0.05422843f, 0.06295593f, 
    0.24126981f, -0.01796936f, -0.31554493f, -0.60664558f, -0.22243802f, -0.18356651f, -0.32287705f, -0.15132126f, 
    -0.08798681f, -0.10282584f, 0.27822116f, 0.27369836f, -0.78516531f, -0.49397817f, -0.35004559f, 0.02299881f, 
    0.34662080f, -0.09257015f, 0.02022102f, 0.06980034f, -0.08179710f, -0.17819037f, -0.23218572f, 0.22271919f, 
    0.16931182f, 0.26593134f, -0.18644804f, -0.07305074f, 0.08515874f, 0.04206811f, 0.18438238f, 0.30653507f, 
    0.05400364f, 0.00330362f, -0.00212383f, 0.09917018f, -0.02191137f, -0.04114509f, 0.50023675f, -0.07591996f, 
    -0.06958804f, 0.16738054f, 0.17282076f, 0.26958346f, -0.05558430f, 0.15636420f, -0.17726263f, 0.13665207f, 
    -0.10040508f, 0.01405846f, 0.17747536f, 0.20770600f, -0.06185300f, 0.41132265f, 0.14451338f, 0.23798567f, 
    -0.12756707f, -0.31399295f, -0.16830148f, -0.20105658f, 0.06568844f, -0.03222496f, 0.08487725f, 0.16356130f, 
    0.13513535f, -0.00362806f, -0.29482722f, -0.08750454f, -0.16914491f, 0.04284484f, 0.05923305f, 0.05314336f, 
    -0.06749906f, 0.14954987f, -0.64086479f, -0.06149114f, -0.02548890f, 0.13996565f, -0.11691930f, -0.20042832f, 
    -0.00581901f, 0.30648324f, 0.13368970f, -1.06783152f, -0.55084211f, -0.30739397f, 0.13045754f, 0.06928325f, 
    0.28094813f, -0.02557680f, -0.01803497f, 0.17380579f, -0.16342071f, -0.33319828f, -0.10065403f, -0.22072366f, 
    -0.24869126f, -0.37248230f, -0.03073032f, 0.12849170f, 0.01661516f, -0.31718218f, -0.09127555f, 0.14933826f, 
    0.16233675f, -0.14175010f, -0.20688617f, 0.01866855f, 0.13744608f, -0.00437362f, 0.40154821f, -0.32114288f, 
    -0.27379400f, 0.10140322f, -0.06325620f, -0.14784414f, 0.42211661f, 0.41288710f, -0.12749739f, -0.03445669f, 
    0.28899592f, 0.29753304f, -0.24884024f, -0.00289418f, -0.12000708f, -0.03840647f, -0.02597555f, 0.11110917f, 
    0.06971439f, -0.48542351f, -0.34348679f, 0.09660965f, 0.13407874f, 0.19687949f, -0.37881529f, -0.27568561f, 
    0.11666261f, 0.48870859f, -0.18170407f, -0.25651175f, 0.26425627f, -0.35315543f, 0.02360629f, 0.02186836f, 
    0.05529097f, -0.22631085f, 0.25400239f, 0.16242307f, 0.12369553f, -0.09548890f, 0.21790221f, 0.23069060f, 
    0.04488092f, -0.09021655f, 0.20324869f, 0.05007202f, 0.12357074f, -0.01436782f, -0.07377324f, -0.02040525f, 
    0.17915134f, 0.03145510f, -0.12392864f, 0.05897273f, 0.31101397f, 0.19473186f, 0.05262070f, -0.08483154f, 
    0.24426714f, -0.01438763f, 0.02142607f, 0.07737359f, 0.04159573f, -0.23595707f, 0.49496213f, -0.05438143f, 
    -0.15595669f, -0.09143338f, 0.18871677f, 0.01574463f, 0.25621444f, 0.20510696f, 0.60903573f, 0.23615913f, 
    -0.28472388f, 0.25198066f, 0.11460855f, -0.01018139f, -0.01340726f, -0.06783693f, -0.14558724f, 0.53179258f, 
    0.07052558f, -0.02012245f, 0.08228269f, 0.07062624f, 0.20187154f, 0.29454327f, 0.13032386f, -0.08767815f, 
    0.31432500f, 0.14192261f, 0.42454517f, 0.02368373f, 0.04059985f, 0.13261463f, 0.06522389f, 0.16781324f, 
    -0.02552276f, 0.16590001f, 0.04069788f, 0.37308836f, 0.06455035f, 0.04797528f, 0.03789498f, 0.01940565f, 
    0.09883324f, -0.06744901f, -0.00379716f, -0.14792439f, 0.04456158f, 0.01119873f, -0.02221838f, -0.06303547f, 
    0.05488707f, -0.05482268f, 0.04285416f, -0.05677900f, 0.05317669f, 0.08148719f, 0.03486822f, -0.17618163f, 
    -0.04309693f, 0.07027862f, -0.02614522f, 0.12628946f, -0.10249857f, -0.05396020f, -0.01834181f, 0.15651415f, 
    0.17660166f, -0.26046973f, 0.23654287f, -0.19999552f, -0.25597343f, 0.07239526f, 0.08957350f, 0.20797369f, 
    -0.07774340f, 0.00509732f, 0.11114898f, 0.30037710f, -0.32912099f, -0.24371631f, -0.05457846f, -0.17290233f, 
    -0.01943286f, 0.00366503f, -0.10608684f, 0.00412144f, -0.04857336f, 0.39470935f, -0.18646039f, -0.10325084f, 
    -0.07726532f, 0.11367476f, -0.13092753f, 0.12515019f, 0.08249845f, -0.29651213f, 0.22854698f, 0.02728413f, 
    0.01686543f, 0.00547318f, -0.02555791f, 0.30718619f, -0.16141047f, 0.11895972f, -0.07372427f, -0.12791131f, 
    -0.01298668f, 0.35172051f, 0.13202338f, 0.36481142f, 0.14802504f, 0.12334030f, 0.07412490f, -0.13682710f, 
    -0.04386343f, -0.21529911f, -1.03962290f, -0.31779298f, 0.05389423f, -0.03002217f, 0.01589520f, -0.03887992f, 
    -0.01502940f, 0.04921879f, 0.13161038f, -0.69203031f, -0.42987478f, -0.09422801f, -0.23988226f, 0.15941240f, 
    0.02029223f, 0.00866660f, 0.11741301f, 0.11167504f, 0.13855642f, -0.02962506f, 0.15823036f, 0.17141843f, 
    0.03651441f, -0.02374242f, 0.07161821f, -0.06642038f, 0.23232548f, 0.07362824f, 0.02950555f, 0.03055763f, 
    0.05267846f, 0.12410429f, 0.15344670f, -0.07259327f, -0.06565960f, 0.14283872f, 0.19248419f, 0.09103920f, 
    -0.01909246f, 0.13720839f, -0.22727691f, -0.13806136f, -0.13335569f, 0.15811813f, -0.06601661f, -0.04194521f, 
    0.01214517f, -0.23398042f, -0.32749242f, 0.10033654f, 0.00696638f, 0.29103813f, 0.15329260f, -0.03087384f, 
    -0.15983312f, -0.19282638f, 0.00865271f, 0.10106660f, -0.01182744f, 0.19603215f, 0.21648873f, -0.06274806f, 
    -0.02783557f, -0.60255712f, -0.23676306f, 0.06958005f, 0.01281428f, 0.11049096f, 0.18300454f, 0.06307787f, 
    -0.11476301f, 0.25245744f, -0.10487343f, -0.05931040f, 0.04505234f, 0.13004400f, 0.12401571f, 0.08520196f, 
    0.18276161f, 0.14047179f, 0.12396317f, 0.01274035f, 0.24477884f, 0.18272236f, 0.05073338f, -0.09303849f, 
    0.11739963f, 0.15683439f, 0.05102489f, -0.02083870f, -0.03556171f, -0.06708045f, -0.00833091f, 0.18740593f, 
    -0.15282880f, 0.10144432f, 0.14568046f, -0.20254874f, -0.04815287f, -0.21499963f, -0.06863844f, 0.09533153f, 
    -0.08277040f, -0.06569041f, 0.20083605f, -0.01614960f, -0.07520541f, -0.00684278f, -0.29304302f, 0.25413874f, 
    0.24410123f, -0.03604900f, -0.02335577f, -0.35529971f, 0.08445254f, -0.25571561f, 0.01334646f, 0.14054900f, 
    -0.11022933f, 0.28062958f, 0.12033463f, 0.06540989f, 0.13154790f, -0.02149003f, -0.07445899f, -0.37775445f, 
    -0.21788141f, -0.14030302f, 0.19312416f, -0.11932780f, -0.14254256f, 0.02608806f, 0.14244190f, 0.16396761f, 
    0.01719021f, -0.08467515f, -0.02257670f, 0.12790707f, -0.09845880f, -0.04320380f, -0.09958546f, -0.10449220f, 
    0.10999031f, -0.00099335f, 0.22142182f, 0.01740057f, 0.27108723f, -0.03179065f, 0.00774100f, 0.05431866f, 
    0.15715946f, 0.06112241f, -0.09965835f, 0.26171482f, 0.07280459f, -0.05063850f, 0.11430757f, 0.08715128f, 
    -0.03283261f, -0.00660016f, -0.16154180f, -0.12985954f, 0.06900825f, -0.20690665f, 0.19701192f, -0.06721065f, 
    0.12599270f, 0.00162304f, 0.03689624f, -0.04326024f, -0.43200606f, -0.08805119f, -0.11495583f, 0.09568708f, 
    0.14771348f, 0.13611826f, 0.02129702f, -0.00903037f, -0.16896896f, 0.14622399f, -0.14494707f, -0.01925247f, 
    0.49179292f, 0.06744435f, -0.01610892f, -0.36180115f, 0.02553665f, 0.11342116f, 0.01529245f, -0.04773725f, 
    -0.05053082f, 0.29306883f, 0.18361633f, 0.04862829f, -0.09566594f, 0.01337465f, -0.14407769f, 0.02786365f, 
    -0.80162412f, -0.36653692f, -0.06933549f, -0.10489932f, 0.00370100f, -0.06795751f, 0.02260979f, 0.04479546f, 
    -0.22823474f, -0.02210198f, -0.34797129f, -1.24115217f, 0.10316312f, 0.19553819f, 0.13698566f, 0.05725810f, 
    -0.07146291f, 0.00730311f, 0.03690896f, 0.05882274f, -0.13877797f, 0.17709741f, -0.19685186f, -0.09214421f, 
    -0.14223118f, -0.06004550f, -0.00666076f, -0.04645024f, 0.03295599f, 0.11770537f, 0.04316178f, -0.02640008f, 
    0.07165790f, 0.23179242f, -0.07321484f, 0.08650459f, -0.07836872f, 0.07994908f, -0.10159271f, 0.01592804f, 
    -0.05631928f, -0.06512070f, 0.15989509f, 0.14154173f, 0.39160037f, 0.11316335f, 0.05518459f, -0.04015076f, 
    -0.05696080f, 0.04339301f, 0.00863957f, 0.11798769f, 0.09895717f, 0.16090138f, -0.04234684f, -0.30046415f, 
    -0.18220268f, 0.09970142f, 0.20300093f, 0.00645736f, 0.27356976f, -0.02000272f, 0.06370448f, 0.02202374f, 
    -0.08722150f, 0.27095479f, 0.34199458f, 0.12431178f, 0.12623839f, 0.11519809f, 0.05928205f, 0.18112925f, 
    -0.20508189f, -0.17532609f, -0.05820528f, 0.00609728f, 0.04632614f, -0.14133571f, 0.04707135f, -0.04604192f, 
    -0.06043832f, -0.16733795f, 0.37094429f, 0.66998577f, 0.00392604f, 0.05192912f, 0.10238992f, 0.08780599f, 
    -0.12690882f, 0.31099746f, 0.42881188f, -0.96493542f, -0.31898668f, -0.06837531f, 0.03838782f, 0.05547754f, 
    -0.10596986f, -0.05918994f, 0.10119779f, 0.37152085f, 0.05157679f, -0.38596192f, 0.06287745f, -0.01149387f, 
    0.42642340f, 0.09221656f, -0.03701502f, -0.00277280f, -0.15727434f, 0.07372753f, -0.18612435f, 0.16939686f, 
    -0.11169979f, 0.03906043f, -0.02103964f, 0.28027979f, 0.18865874f, -0.44168448f, -0.16242671f, -0.87887836f, 
    0.05071937f, 0.12840578f, 0.10668269f, 0.15792938f, 0.20531288f, 0.05853568f, -0.37156793f, 0.05613819f, 
    0.17979679f, -0.13029432f, 0.06475371f, 0.21159367f, 0.37397468f, -0.24668968f, 0.05942301f, 0.05618668f, 
    0.17999841f, -0.13495468f, -0.00372510f, 0.03148783f, 0.25760430f, 0.24774593f, 0.09631582f, -0.00749059f, 
    -0.04066410f, 0.02775637f, 0.07180975f, -0.19585209f, -0.03360549f, 0.06428185f, -0.04655224f, -0.00414514f, 
    -0.08574736f, 0.56725770f, -0.12648177f, -0.04078757f, 0.12633312f, 0.08224698f, 0.14849465f, -0.06305050f, 
    0.08783495f, 0.05866800f, -0.12011353f, 0.07700416f, 0.11368790f, 0.16535629f, 0.06779518f, -0.28221965f, 
    0.00974635f, 0.06940252f, 0.08070686f, -0.41891420f, 0.20002298f, 0.22393280f, -0.02820527f, 0.18550897f, 
    -0.06944203f, 0.04144410f, 0.00302552f, 0.04102903f, -0.13072616f, 0.10018849f, 0.04554828f, -0.09733878f, 
    -0.06713262f, -0.31056538f, -0.12791815f, -0.09321892f, 0.12381565f, -0.08948868f, 0.13069579f, -0.02679548f, 
    0.09564604f, -0.02708180f, -0.09644200f, 0.17424837f, 0.19021232f, 0.21414764f, -0.31184795f, 0.04375159f, 
    -0.08084426f, -0.14773993f, 0.20272791f, -0.07050892f, 0.08182006f, -0.08924907f, -0.11157755f, -0.35065821f, 
    -0.35795978f, -0.86621934f, -0.05567373f, -0.00714379f, -0.06195463f, 0.06069428f, -0.05855322f, -0.17237569f, 
    0.09516840f, -0.03793238f, -0.07168988f, -0.03801346f, -0.13571422f, 0.05609721f, 0.02505066f, -0.02058275f, 
    0.16763407f, 0.07840522f, 0.10667602f, 0.12418069f, 0.23825189f, -0.24751508f, -0.09492362f, 0.27028418f, 
    0.21443017f, 0.09551155f, -0.43153599f, 0.26526922f, -0.35412973f, -0.11971172f, 0.04840568f, -0.04001497f, 
    -0.03919405f, 0.00262081f, -0.05449940f, 0.41301569f, 0.06531976f, -0.65608019f, -0.08012226f, 0.09766518f, 
    0.16354699f, -0.01303301f, -0.03804845f, 0.10806857f, -0.00097575f, 0.29036602f, -0.69882011f, -0.11391350f, 
    -0.15062213f, -0.19090703f, 0.03191382f, -0.06479351f, 0.15713486f, -0.36114001f, -0.36890587f, 0.12597536f, 
    -0.09243783f, -0.04453832f, 0.11980526f, 0.11971559f, 0.01276991f, -0.01186229f, -0.21076255f, -0.54643446f, 
    -0.23242927f, 0.03779006f, -0.17250894f, -0.23522812f, 0.05144343f, -0.01894834f, 0.14472491f, 0.13325855f, 
    -0.00374607f, -0.42960963f, 0.05354986f, 0.04353328f, -0.16706449f, -0.04028752f, -0.23761114f, -0.08010024f, 
    -0.32583681f, -0.54211766f, 0.06550811f, -0.19985262f, -0.30631241f, -0.03837864f, -0.07294855f, -0.00159764f, 
    0.04590880f, -0.02713725f, -0.39498782f, 0.38400501f, -0.15732336f, 0.12987590f, 0.01038972f, -0.07298972f, 
    0.00767227f, 0.21646771f, -0.09583923f, 0.01228349f, -0.00567351f, -0.11142524f, 0.15116315f, -0.04980278f, 
    0.02767518f, 0.13986415f, 0.14467689f, 0.03532449f, -0.06555572f, -0.11333060f, 0.10263481f, -0.08109438f, 
    -0.10705806f, -0.04924828f, 0.10023139f, 0.09168466f, 0.01417724f, 0.12681793f, 0.09137427f, -0.05293424f, 
    -0.00808792f, 0.14630674f, 0.06512111f, -0.13681084f, 0.13323109f, 0.18797930f, 0.08340414f, 0.35955584f, 
    -0.00048687f, 0.14257938f, 0.13303776f, 0.28592855f, -0.04127981f, 0.03989106f, -0.06659040f, -0.09911074f, 
    0.17833035f, -0.04659256f, 0.12424176f, -0.23653547f, 0.22685546f, 0.19832933f, -0.01232952f, -0.03855750f, 
    -0.05382243f, 0.20517853f, 0.11352853f, 0.11540978f, 0.15982880f, 0.18565108f, 0.21378617f, 0.34353176f, 
    -0.09108190f, -0.02455130f, -0.00266682f, -0.42301741f, -0.21741891f, 0.02991926f, -0.02769805f, 0.09661736f, 
    0.11038655f, 0.30124938f, 0.03896253f, 0.48514190f, 0.15488221f, 0.02179341f, 0.10809556f, 0.10030458f, 
    -0.07114113f, 0.36169007f, -0.18460038f, -0.71727443f, -0.36920974f, -0.15284459f, 0.05894297f, -0.15219384f, 
    -0.14959864f, 0.00403494f, -0.07106762f, 0.82058340f, -0.45925120f, -0.13755462f, -0.33845869f, 0.01064074f, 
    -0.07068575f, 0.09375947f, 0.33287078f, 0.03350294f, -0.09580029f, 0.09648536f, -0.05156282f, -0.30866247f, 
    -0.01911631f, 0.00118247f, 0.28527924f, 0.07824893f, 0.23795699f, 0.14745452f, 0.21167734f, 0.25223029f, 
    0.00699588f, 0.15695025f, 0.22220133f, 0.10345111f, 0.08653817f, 0.23389290f, 0.40092975f, -0.73161370f, 
    -0.35681853f, 0.08844779f, -0.76943672f, 0.20385240f, 0.10775496f, -0.01886878f, 0.33101326f, 0.27063769f, 
    0.24005966f, -0.13994169f, 0.24168836f, 0.19312273f, 0.40457454f, 0.29545343f, 0.34093580f, 0.16686368f, 
    0.06470854f, 0.02195137f, 0.01523154f, -0.16863951f, -0.14409693f, -0.12606435f, -0.04081407f, 0.24503285f, 
    -0.01963094f, 0.09597037f, 0.02502353f, -0.07231487f, -0.07930015f, 0.15132686f, -0.02099695f, 0.05362068f, 
    0.25013465f, 0.26967400f, 0.12830551f, 0.07003987f, 0.02879336f, 0.04705890f, -0.29702801f, -0.03507993f, 
    -0.03667662f, 0.08321850f, 0.11037258f, -0.09009162f, 0.39661372f, 0.34006688f, -0.05457356f, 0.10904724f, 
    0.13188717f, 0.17316550f, 0.13314699f, 0.13702142f, -0.00792271f, -0.02310864f, -0.12678494f, -0.39360112f, 
    -0.33087844f, -0.33517161f, 0.03393346f, 0.23708329f, 0.02967678f, 0.14484480f, -0.02182303f, -0.04057020f, 
    -0.08682432f, 0.08975375f, -0.02842114f, 0.32846665f, -0.11004899f, 0.17912857f, -0.31777474f, 0.01493832f, 
    0.56614566f, -0.08265973f, 0.00766556f, 0.01548889f, 0.12129369f, -0.00253182f, -0.15613830f, -0.64008415f, 
    -0.34090513f, -0.09044646f, -0.19771723f, -0.09486881f, -0.22746220f, 0.03122524f, 0.19163063f, -0.15365425f, 
    0.09629717f, -0.00717563f, 0.04348210f, -0.30108210f, -0.12038885f, -0.18874432f, -0.32820132f, -0.27990487f, 
    0.07312866f, 0.26319957f, 0.11485445f, 0.03166211f, -0.04249404f, -0.09775342f, -0.32382214f, 0.10781978f, 
    -0.03251066f, 0.05250457f, -0.40502432f, -0.16811085f, 0.35860464f, -0.11644585f, -0.09862152f, -0.12942243f, 
    -0.20549104f, -0.02411971f, -0.04261500f, -0.28831446f, -0.19046339f, 0.33037385f, -0.01730723f, -0.00053675f, 
    -0.07376803f, 0.34864935f, 0.10371128f, 0.10132417f, -0.35710892f, -0.33623090f, 0.30051887f, -0.12082519f, 
    -0.14317189f, -0.04037982f, 0.01763116f, -0.01500786f, 0.24990468f, -0.14810516f, -0.57325220f, -0.08397649f, 
    -0.11117086f, -0.16974415f, -0.17550753f, 0.17438471f, 0.13175991f, 0.08822020f, -0.77868301f, -0.16001365f, 
    0.76224965f, -0.00630211f, -0.01272483f, 0.07039524f, 0.07272925f, -0.00324089f, 0.11381377f, -0.59696096f, 
    -0.16321714f, 0.67489243f, -0.06114894f, 0.01937436f, 0.05446985f, 0.07061399f, 0.16547343f, 0.30899405f, 
    0.02392862f, 0.04541121f, -0.00404571f, 0.02104079f, 0.04042898f, -0.00535722f, -0.03535252f, -0.05354766f, 
    -0.00648117f, -0.00378066f, -0.06445047f, 0.03446718f, -0.01916493f, -0.02812026f, 0.03493504f, -0.00407641f, 
    0.01626835f, 0.02908938f, -0.04628092f, -0.01090159f, -0.02259870f, -0.00578138f, 0.04625339f, -0.05541437f, 
    0.00508187f, -0.01962025f, -0.06005852f, 0.01314989f, -0.06039754f, 0.01870959f, -0.00189724f, 0.03473465f, 
    0.05016064f, 0.04306247f, -0.04643639f, 0.01851818f, 0.00833290f, -0.05635365f, 0.05007258f, -0.04194177f, 
    -0.00005570f, -0.04614943f, -0.05306407f, -0.00439690f, 0.01010788f, -0.02494961f, 0.02887068f, 0.04970164f, 
    -0.05398672f, -0.06527959f, -0.03303108f, 0.04237913f, 0.04748814f, 0.01701208f, -0.05708810f, 0.01330189f, 
    -0.02406255f, -0.02355311f, 0.01901495f, -0.02505472f, -0.02879020f, 0.02339853f, -0.01062321f, 0.01137583f, 
    -0.01843662f, -0.01633351f, -0.03778630f, 0.04165271f, -0.02385991f, -0.05941132f, -0.03186699f, -0.01103633f, 
    0.02661369f, 0.02398160f, -0.04653876f, 0.00847358f, -0.02730505f, -0.03451926f, 0.01282392f, 0.01794512f, 
    0.03694192f, -0.00930217f, 0.04766240f, -0.06306872f, -0.02667026f, -0.03301854f, -0.03159577f, -0.04100548f, 
    0.04557825f, -0.03553343f, -0.02717918f, -0.06272964f, 0.01781094f, -0.02859545f, 0.03060940f, 0.00677621f, 
    -0.01366105f, 0.01365314f, -0.04909541f, -0.02994029f, -0.02980362f, 0.04445530f, 0.05127347f, -0.04819155f, 
    0.00961996f, -0.05539559f, -0.01743932f, 0.04620150f, -0.06698421f, 0.02220027f, 0.04160791f, 0.01211002f, 
    -0.03341824f, -0.05401135f, 0.04809452f, -0.04815760f, -0.05556678f, -0.06486371f, 0.03360633f, -0.06618974f, 
    -0.01105759f, 0.04798052f, 0.01625801f, -0.02970325f, -0.02275526f, -0.06426495f, -0.00919246f, 0.01685055f, 
    0.05013749f, -0.00172498f, -0.05082878f, 0.00558868f, -0.02292261f, -0.06495991f, 0.03647255f, 0.02586147f, 
    -0.05575596f, 0.03131532f, 0.05010700f, -0.04381733f, -0.04429435f, -0.03457798f, 0.01540049f, -0.02594588f, 
    -0.05015686f, -0.00762900f, -0.02300043f, 0.00292522f, 0.00259734f, 0.00336485f, 0.02290790f, -0.05128597f, 
    -0.03328176f, -0.02480822f, 0.01080718f, 0.01758555f, -0.00277270f, -0.04026644f, -0.05660211f, 0.02165929f, 
    0.00863868f, -0.04403731f, -0.05431635f, 0.02772871f, -0.02637652f, -0.04089628f, 0.01997241f, 0.00603128f, 
    -0.00863623f, -0.01381051f, -0.05854077f, 0.03529453f, -0.01202588f, -0.05121771f, -0.02007755f, 0.02229130f, 
    0.00684325f, -0.01368608f, 0.04521229f, -0.01724422f, 0.03811820f, -0.01317912f, 0.02917642f, -0.01823323f, 
    -0.01810920f, -0.03931020f, 0.03008228f, -0.01266678f, 0.03118313f, 0.02359160f, 0.04817295f, 0.04335981f, 
    0.03134488f, -0.02626543f, -0.05292240f, -0.01369077f, -0.05559568f, -0.02608499f, 0.02346098f, -0.03840082f, 
    0.03701353f, -0.02323797f, 0.00123950f, 0.02709954f, -0.05859562f, -0.05752473f, -0.05301699f, -0.00838522f, 
    0.00330325f, -0.05416499f, 0.03616281f, 0.00073681f, -0.04193780f, 0.00950057f, 0.00049386f, -0.06168226f, 
    0.03907739f, -0.06241063f, -0.04288122f, 0.01740888f, 0.04313748f, 0.04052978f, -0.02355295f, -0.00779778f, 
    0.02171538f, 0.00122470f, -0.00128559f, -0.02781108f, -0.06452866f, -0.01110849f, 0.05593015f, -0.02824192f, 
    -0.01068725f, -0.00294279f, 0.00826797f, 0.04554832f, 0.01692166f, 0.02297055f, 0.00769884f, 0.02602112f, 
    0.00863659f, 0.01701600f, -0.03402903f, 0.02392235f, 0.04286223f, -0.02821423f, -0.02310220f, -0.00428558f, 
    0.04915105f, 0.03591140f, -0.04959975f, 0.00487325f, 0.01517916f, -0.00513433f, 0.03697896f, 0.01365257f, 
    0.01274046f, -0.00359907f, 0.02873042f, 0.03799773f, -0.04548554f, -0.01179419f, 0.01806842f, 0.01860843f, 
    -0.02954654f, 0.04017895f, -0.02095626f, 0.00607058f, -0.01832292f, -0.05669481f, 0.03888290f, 0.01967074f, 
    -0.01906991f, -0.01566430f, 0.02043797f, -0.04676843f, -0.01450509f, -0.04413319f, 0.02248494f, -0.05034349f, 
    0.03186751f, -0.06016926f, 0.02198727f, -0.05221267f, -0.04605692f, 0.04279936f, 0.04584043f, 0.00070623f, 
    -0.01973207f, 0.00193662f, -0.00858322f, -0.01812269f, -0.06129861f, -0.03270913f, 0.03969281f, -0.00183153f, 
    -0.00542125f, -0.03637308f, -0.03100851f, -0.04308892f, -0.03236256f, -0.05261729f, -0.00679707f, 0.00617811f, 
    0.01616041f, 0.00551647f, 0.00210914f, 0.01178223f, -0.02142384f, -0.03872672f, 0.00902457f, -0.01307578f, 
    -0.03438476f, 0.04541059f, -0.01945488f, -0.05733290f, 0.04142996f, -0.06105022f, 0.01026697f, 0.04246711f, 
    -0.03516598f, 0.01352613f, 0.02421239f, 0.01539866f, -0.06357159f, -0.02296745f, -0.05108024f, -0.03242224f, 
    -0.02807280f, 0.02925682f, 0.03832562f, -0.01814522f, -0.03790091f, 0.03997067f, 0.04212263f, 0.02301577f, 
    0.01327124f, -0.04578389f, 0.02632682f, -0.05467660f, 0.00275723f, 0.02530138f, -0.00943661f, -0.03526986f, 
    -0.04809934f, -0.03646800f, 0.02120233f, -0.04606068f, 0.01711433f, 0.01248068f, -0.04751587f, -0.00068016f, 
    0.03171836f, -0.00908806f, 0.04235138f, -0.03058807f, -0.05774190f, 0.05005991f, -0.02400139f, 0.04081534f, 
    -0.03053798f, -0.01038358f, -0.02833505f, 0.04861446f, -0.06361936f, -0.02907781f, 0.02873725f, -0.02635460f, 
    0.03874390f, 0.01030389f, 0.00314510f, -0.04693622f, -0.06171202f, -0.06571735f, -0.06427425f, 0.00502437f, 
    -0.01170128f, 0.03348620f, 0.01911985f, 0.04637643f, -0.02528618f, 0.02427431f, -0.02294179f, 0.03643870f, 
    -0.00224974f, 0.03749183f, -0.00727439f, -0.01136614f, -0.03417362f, -0.02929600f, 0.00139860f, -0.04592003f, 
    0.04346307f, 0.01138286f, -0.03578925f, -0.01695474f, -0.03514817f, -0.03649812f, -0.06268770f, -0.04524273f, 
    0.00947965f, -0.01839094f, -0.01160753f, -0.01756509f, 0.03391264f, 0.03683330f, -0.01313890f, -0.06415945f, 
    -0.00731268f, -0.02501587f, -0.06154422f, -0.04420702f, 0.03718551f, -0.02463864f, -0.00955192f, 0.06005424f, 
    0.05056017f, 0.04879479f, 0.01610184f, -0.01566091f, 0.02201891f, -0.00375974f, -0.01300360f, 0.01737809f, 
    0.04896654f, 0.01753237f, -0.01243117f, 0.04352636f, -0.04439075f, -0.03638720f, -0.04682545f, -0.05633188f, 
    -0.06189484f, -0.05427914f, -0.06163354f, -0.04225859f, 0.03966954f, -0.01469770f, -0.03884585f, -0.05038777f, 
    0.04988563f, -0.00956769f, 0.03347673f, -0.00557103f, 0.01461788f, 0.00888204f, -0.01586529f, 0.01590367f, 
    -0.03395857f, -0.00152651f, 0.04925252f, -0.04423027f, -0.03556762f, -0.01623163f, 0.03219337f, 0.04564939f, 
    0.01409629f, 0.04756487f, -0.05899287f, -0.04980547f, 0.03529374f, 0.00154386f, -0.05951291f, 0.03512075f, 
    0.00840626f, -0.05650679f, 0.02109605f, 0.00112469f, -0.00729165f, -0.00518741f, 0.00753219f, 0.00531618f, 
    -0.03603242f, 0.02665248f, -0.05424957f, -0.03158126f, -0.00386378f, 0.03385159f, -0.03606194f, -0.02959473f, 
    0.01055488f, 0.04035625f, 0.00072454f, -0.04626074f, 0.00846222f, 0.04384748f, -0.01924970f, 0.04820831f, 
    0.00644189f, 0.04233835f, -0.03964045f, 0.03568024f, 0.03951960f, -0.03288288f, -0.04292364f, -0.06402276f, 
    -0.04013274f, -0.00110251f, 0.02405453f, -0.01389967f, 0.00938830f, -0.02277474f, -0.06220951f, -0.02277027f, 
    0.00177101f, -0.02594461f, -0.04110964f, -0.00828383f, -0.05493752f, -0.04634297f, -0.02543340f, 0.03407238f, 
    0.02246130f, -0.01626207f, -0.01792536f, 0.01474801f, -0.05707949f, -0.06113028f, 0.03536093f, -0.02561513f, 
    0.00391419f, 0.05165011f, 0.03588509f, 0.03672953f, -0.04442496f, 0.01251432f, 0.02567658f, -0.00142922f, 
    -0.03727815f, 0.03155326f, -0.02460047f, 0.01704741f, 0.00113330f, -0.00199989f, 0.00032619f, 0.04540023f, 
    0.03682408f, 0.04184854f, -0.04385234f, 0.02000237f, 0.00837724f, -0.05856329f, 0.00141585f, -0.04520699f, 
    0.03538468f, 0.04299306f, -0.05471280f, -0.03549549f, -0.00762556f, 0.02060818f, -0.06109112f, 0.00198928f, 
    -0.04900263f, 0.03696560f, -0.05064685f, -0.05251038f, -0.00573053f, -0.05105258f, 0.02679808f, -0.03418316f, 
    -0.04975570f, -0.03496794f, 0.02937670f, -0.00265800f, 0.04062625f, -0.04278572f, -0.02107792f, -0.00346432f, 
    0.01351030f, 0.00924069f, -0.03920566f, -0.03477055f, -0.03411414f, -0.01765878f, 0.04270142f, -0.05607253f, 
    -0.18092276f, -0.71785271f, 0.05998057f, 0.01253646f, -0.33522105f, -0.10303178f, -0.05200996f, 0.02399039f, 
    0.07039916f, -0.15349855f, 0.14175935f, 0.03431332f, 0.05940238f, -0.08495434f, -0.09014639f, 0.08607039f, 
    -0.01741592f, 0.10863373f, 0.01810154f, -0.10931715f, 0.03861503f, -0.26232207f, -0.01158967f, -0.09050041f, 
    0.08875003f, 0.17284253f, 0.06669906f, -0.14862522f, -0.06181906f, -0.13925672f, 0.01175398f, 0.00585026f, 
    -0.01683573f, -0.01103845f, 0.21609606f, -0.04393126f, 0.01201869f, -0.15365008f, 0.11493932f, -0.00043532f, 
    0.04889043f, 0.15318710f, 0.07401328f, -0.08148550f, 0.25833136f, 0.08837292f, 0.02675286f, 0.01005191f, 
    0.07893230f, 0.06626095f, 0.07120559f, -0.03181453f, -0.09619579f, 0.04559693f, 0.23328316f, -0.14095373f, 
    -0.17078018f, -0.17577036f, -0.02566286f, -0.00643152f, 0.05388623f, 0.03050085f, 0.07923856f, -0.08610385f, 
    0.22605020f, -0.03752274f, -0.09839494f, 0.22520199f, 0.18119180f, -0.02848730f, -0.01138864f, 0.12311470f, 
    0.05571661f, -0.09681288f, -0.08171919f, -0.16725621f, -0.01738793f, -0.03105864f, 0.05205029f, 0.11853797f, 
    0.08231862f, -0.12459604f, -0.16640398f, 0.49439210f, 0.05852011f, -0.18876655f, 0.03666919f, 0.06678542f, 
    0.25948963f, 0.30163294f, 0.32632396f, -0.21283375f, 0.29847941f, 0.05147081f, -0.16099840f, -0.10739610f, 
    0.04334205f, 0.25341776f, 0.06417701f, 0.72540325f, -0.30315122f, 0.08014032f, -0.15806654f, 0.07628969f, 
    -0.03741504f, 0.05067476f, 0.13424939f, -0.03509676f, -0.28742522f, -0.07168372f, 0.08276966f, -0.04026522f, 
    0.12153646f, 0.03699766f, 0.09231189f, -0.15951867f, -0.16578873f, 0.26357552f, -0.20074823f, 0.16307202f, 
    0.14297199f, 0.11612481f, 0.06825881f, 0.01042455f, -0.00325771f, 0.02288861f, 0.09178858f, -0.46875715f, 
    0.13910569f, -0.39859366f, -0.44085443f, -0.01893788f, -0.02540646f, 0.15263034f, 0.09482344f, 0.13777983f, 
    -0.23481302f, 0.27486682f, 0.11013222f, 0.28328297f, 0.22293673f, 0.23275152f, 0.06829403f, 0.20210598f, 
    0.35746828f, 0.10693943f, 0.02486577f, -0.03832535f, -0.06855970f, -0.14137705f, -0.11915341f, -0.00001251f, 
    -0.07163522f, 0.15126039f, 0.24850719f, 0.05885883f, -0.05153381f, -0.06255248f, -0.07092497f, 0.12384328f, 
    0.09673126f, 0.00165318f, 0.13447164f, -0.02300590f, 0.07887064f, -0.06879890f, -0.00977761f, -0.03517517f, 
    0.14926241f, -0.04819567f, -0.05828805f, 0.14172582f, 0.00153416f, 0.05931967f, -0.02156136f, 0.21005793f, 
    0.03101683f, 0.08815284f, 0.12211473f, 0.04509258f, 0.14647253f, 0.05493034f, -0.03563644f, -0.09585435f, 
    -0.15287241f, -0.21091074f, 0.12412185f, 0.04838486f, -0.04199266f, 0.01156754f, 0.04676670f, -0.02438771f, 
    -0.07485822f, -0.17891894f, 0.04689807f, 0.07278402f, -0.09068922f, 0.29970515f, -0.68002439f, 0.06319985f, 
    -0.18014315f, -0.02583537f, 0.31247953f, -0.38934615f, 0.03219037f, -0.36075768f, -0.15296820f, -0.78527504f, 
    -0.73261791f, -0.46653536f, 0.24584170f, -0.04026572f, -0.10455855f, 0.00469742f, 0.06946181f, -0.08159912f, 
    0.45734793f, 0.13827312f, 0.15614098f, 0.07558696f, -0.18163943f, -0.04311385f, -0.20366375f, 0.11137639f, 
    -0.12783593f, 0.42597410f, 0.10864628f, -0.04101045f, -0.11511946f, -0.02861388f, -0.18861926f, -0.10833061f, 
    0.18170904f, 0.10370034f, 0.09113719f, 0.21446250f, -0.23052342f, 0.07139120f, -0.15054454f, -0.02352174f, 
    -0.01187084f, 0.03407874f, 0.14573576f, -0.13503684f, -0.09421875f, 0.06832479f, -0.05775108f, -0.08229284f, 
    0.05188915f, 0.30677226f, -0.15009758f, 0.15153266f, 0.05688240f, 0.23587389f, 0.24705322f, -0.12611313f, 
    -0.06821331f, -0.01937512f, 0.10757588f, 0.07099669f, -0.03600401f, -0.13005345f, -0.12921561f, 0.22009045f, 
    -0.20773900f, -0.02706752f, -0.19666456f, 0.14249454f, -0.07079460f, 0.07456998f, -0.52294940f, -0.02188245f, 
    -0.32298452f, -0.29786867f, -0.08453246f, 0.22048157f, -0.07653860f, -0.02543002f, -0.17030926f, -0.49663073f, 
    0.32033482f, 0.36120173f, -0.23824750f, 0.17380573f, -0.21761388f, -0.03231465f, -0.14598799f, 0.00441362f, 
    -0.10984218f, -0.24909039f, -0.35684818f, 0.41304791f, -0.02677338f, 0.02388189f, -0.11588228f, -0.05151188f, 
    -0.06164777f, -0.15042952f, 0.26569813f, 0.19551840f, 0.13461651f, 0.06809916f, -0.05746534f, -0.02454971f, 
    0.06561466f, -0.00466123f, 0.11982266f, -0.02102201f, 0.11330070f, 0.05864414f, 0.04775210f, 0.10442597f, 
    -0.01167053f, -0.10665590f, -0.16777526f, -0.09395637f, 0.04896794f, 0.00972777f, -0.01199933f, 0.27702487f, 
    0.02070442f, 0.18754902f, 0.20495389f, -0.06896663f, 0.10722656f, -0.04422671f, -0.43940821f, 0.18696263f, 
    0.22029722f, 0.13039961f, 0.31489709f, 0.32491598f, -0.06501433f, 0.28173983f, 0.31573531f, 0.24000330f, 
    0.21134195f, -0.07798051f, 0.05183648f, 0.20879573f, 0.10995858f, 0.09587470f, 0.26428649f, 0.52282846f, 
    0.27012250f, -0.11708347f, 0.01574656f, 0.25263262f, -0.07831699f, 0.14146961f, -0.02756388f, 0.02855459f, 
    0.09368870f, -0.11269811f, -0.14611895f, 0.01139205f, 0.05500307f, -0.23701739f, -0.21476619f, 0.03182551f, 
    -0.14869331f, -0.10577738f, 0.15614131f, 0.03335115f, -0.08110617f, 0.09497971f, 0.12197500f, -0.60796356f, 
    -0.03923614f, 0.21570727f, 0.03712533f, -0.36564431f, -0.10599153f, -0.10120462f, -0.10104302f, -0.04282065f, 
    -0.03190756f, 0.05736491f, 0.38479471f, 0.24177217f, -0.01881321f, 0.07980456f, -0.09054884f, 0.09934403f, 
    0.10780629f, -0.09316958f, -0.26421586f, -0.09381871f, -0.10491536f, 0.42048165f, 0.22099924f, -0.22276591f, 
    -0.15420415f, 0.22584820f, -0.00462809f, -0.11244639f, -0.00031267f, 0.00582914f, 0.18156981f, 0.17626755f, 
    0.04452105f, -0.18418929f, -0.50927913f, -0.06342772f, -0.11158184f, -0.06753235f, -0.08710874f, 0.06316076f, 
    0.13419047f, -0.10865539f, 0.05721895f, 0.07366502f, 0.08013490f, 0.06856447f, -0.14040011f, -0.14134760f, 
    0.07937193f, 0.37829819f, -0.02159892f, -0.01637272f, -0.09169345f, -0.10488775f, -0.11596116f, 0.07420822f, 
    0.03981699f, 0.01282472f, -0.02574220f, 0.14517961f, 0.06618626f, -0.16480391f, -0.11743309f, -0.30123425f, 
    0.15848744f, 0.15272160f, 0.06936008f, 0.07808370f, 0.13835049f, 0.05497629f, 0.11639031f, 0.02535429f, 
    -0.08793536f, 0.09902152f, 0.25473061f, 0.15356721f, 0.09750307f, -0.06035645f, -0.00348316f, 0.03952323f, 
    -0.05273563f, -0.17308296f, 0.12498051f, 0.10934211f, -0.11057083f, 0.10734014f, 0.24721828f, 0.04031628f, 
    0.08916369f, 0.27531010f, -0.35064429f, 0.10486650f, -0.21658370f, 0.06406610f, 0.07966343f, 0.19326375f, 
    -0.18664168f, 0.06608362f, -0.49986115f, 0.10473077f, 0.00317784f, 0.09427815f, 0.09674077f, -0.04688954f, 
    0.28209844f, 0.00995345f, -0.25335303f, 0.07531038f, -0.40300235f, -0.15329929f, 0.14694354f, 0.08227234f, 
    -0.06784368f, 0.33404955f, -0.03740435f, -0.25020361f, -0.25478986f, -0.07198333f, 0.11462469f, -0.31126311f, 
    0.28454688f, 0.05489137f, 0.15259349f, 0.19003402f, 0.17378639f, 0.15892206f, 0.20546922f, -0.21691062f, 
    -0.20260997f, 0.16593683f, -0.08204004f, 0.15492117f, 0.18335804f, -0.08816192f, -0.03143253f, -0.08088550f, 
    -0.15064996f, 0.19880021f, 0.31089661f, 0.06050649f, 0.10938432f, 0.02420885f, 0.15600757f, 0.25845522f, 
    -0.11533203f, -0.41531730f, 0.29455030f, 0.13675101f, 0.04157852f, 0.06840567f, 0.25511330f, 0.13062567f, 
    0.14783175f, -0.07718964f, 0.02268976f, -0.13213506f, 0.09555920f, 0.22795270f, 0.04688609f, -0.00810199f, 
    0.13929501f, 0.11070047f, -0.12913598f, 0.11640939f, 0.09335951f, 0.11509120f, 0.27701584f, -0.03304544f, 
    0.14892480f, -0.03929767f, 0.06517196f, 0.17831114f, -0.11159290f, -0.09772001f, 0.13173923f, 0.05700989f, 
    -0.08652930f, 0.21258438f, -0.01854775f, 0.04301676f, -0.04254196f, 0.00001056f, -0.20810720f, 0.08698475f, 
    0.42417756f, 0.13134962f, -0.35021979f, -0.43101820f, -0.26425463f, -0.13603963f, 0.25900069f, -0.23119234f, 
    -0.05446638f, 0.08373573f, -0.11961623f, 0.41040283f, 0.27545664f, 0.19078922f, 0.28349769f, 0.34227455f, 
    -0.14452277f, -0.22442646f, 0.02006970f, 0.07977803f, 0.25913703f, 0.12679179f, 0.12731145f, 0.11080261f, 
    -0.03677891f, 0.04368320f, -0.03942281f, -0.05071991f, -0.01178001f, -0.00955500f, -0.05888427f, 0.03805551f, 
    -0.00174852f, -0.03430061f, 0.00946767f, 0.00369614f, 0.01813224f, -0.04649186f, 0.04423708f, 0.00046333f, 
    0.00436010f, -0.04364497f, 0.03235637f, -0.00892375f, 0.04100763f, 0.00601663f, 0.02622581f, 0.00405922f, 
    0.04504414f, -0.01076650f, 0.04468777f, -0.00151885f, -0.00126745f, -0.04207120f, 0.03972657f, -0.04832998f, 
    -0.04339596f, 0.02966191f, -0.00438690f, -0.05265564f, 0.00610278f, 0.04065910f, -0.01312352f, 0.02749204f, 
    -0.00770873f, 0.04372735f, 0.02238349f, 0.03831922f, -0.02946305f, 0.03506536f, 0.03283937f, -0.05963601f, 
    0.00170867f, 0.00621808f, -0.05371619f, 0.04202896f, -0.03726364f, -0.04693034f, 0.04610406f, -0.06326166f, 
    -0.06217752f, -0.04064143f, 0.00542614f, 0.02287215f, 0.02444088f, -0.02238917f, 0.02453741f, 0.01802403f, 
    -0.05971973f, 0.01408277f, -0.04352432f, -0.05707216f, -0.05443273f, 0.01506482f, 0.01851900f, 0.01457043f, 
    0.03062491f, -0.02755012f, -0.02301560f, -0.05236682f, -0.06160952f, 0.01682000f, -0.05549960f, -0.04533567f, 
    -0.01899700f, -0.04143038f, 0.00858599f, 0.04483509f, 0.03551133f, -0.05129571f, -0.01762184f, 0.04714397f, 
    0.04900758f, 0.00103197f, -0.04577607f, -0.02250744f, 0.03565314f, 0.02757386f, 0.03791523f, -0.03295444f, 
    -0.02599321f, -0.00592813f, -0.00587608f, -0.01901805f, -0.05976345f, -0.02389426f, 0.01788647f, 0.04387229f, 
    -0.02987956f, 0.01965199f, -0.05828364f, 0.02804417f, -0.01914763f, -0.02196148f, 0.03159142f, -0.02660877f, 
    -0.00748074f, -0.06525873f, -0.04503248f, -0.00238296f, 0.04694949f, 0.02901122f, -0.01542101f, -0.01032978f, 
    -0.06560148f, 0.02055598f, -0.03577946f, 0.04034432f, 0.00651682f, 0.00968113f, 0.03504558f, 0.03659793f, 
    -0.03202168f, 0.00376998f, -0.03142826f, -0.04791841f, 0.04166834f, -0.00112943f, 0.00307342f, -0.00051876f, 
    -0.03094872f, -0.00105518f, -0.05150643f, 0.01294484f, -0.02775699f, 0.02882596f, -0.03544216f, 0.01671862f, 
    -0.05240708f, 0.01414123f, -0.03547348f, 0.00437456f, -0.04916997f, 0.02019740f, -0.02948044f, 0.00939902f, 
    -0.05238242f, -0.00881514f, -0.05028152f, -0.05354428f, -0.06917896f, -0.04845676f, -0.06479755f, 0.03930926f, 
    -0.05275397f, 0.01214309f, 0.04336080f, -0.04251485f, 0.01757611f, 0.04090215f, 0.00424907f, 0.03042897f, 
    0.03067843f, -0.03971421f, -0.05387446f, -0.05415450f, 0.01392969f, -0.03783627f, -0.05856057f, -0.02385471f, 
    -0.00287648f, -0.05919797f, -0.02253266f, -0.07008632f, 0.02398697f, -0.04346208f, 0.04131210f, -0.05818769f, 
    -0.06058259f, 0.01366937f, 0.01957738f, -0.00694775f, 0.01959954f, -0.05529600f, -0.06067938f, 0.02035007f, 
    0.02760691f, -0.03615800f, 0.04535261f, -0.03913970f, 0.01393704f, -0.03533623f, -0.05174313f, 0.02646702f, 
    -0.04840744f, 0.04930587f, -0.06580823f, -0.03888493f, -0.05115146f, -0.01764829f, 0.02386697f, -0.04329267f, 
    0.03926022f, -0.05458592f, -0.02964559f, 0.02342960f, 0.02198141f, 0.00891413f, -0.06307378f, -0.03037065f, 
    -0.01133035f, -0.03453832f, -0.02632637f, 0.01020484f, -0.00549211f, 0.00054013f, -0.02536817f, -0.01840664f, 
    -0.03313784f, -0.00730611f, 0.02663018f, -0.04168629f, 0.03310799f, -0.04835684f, -0.03535603f, 0.02075212f, 
    0.00731278f, -0.03466003f, -0.06526214f, 0.00150510f, -0.00395168f, -0.00879617f, 0.02308965f, 0.00394983f, 
    -0.05245156f, -0.06601749f, 0.01470344f, 0.01350797f, 0.00737605f, -0.01552491f, 0.04194702f, 0.00099957f, 
    0.04631013f, -0.06025105f, -0.03280170f, 0.00436194f, 0.03866718f, -0.04979559f, -0.05225460f, -0.02308807f, 
    0.04866366f, -0.02384086f, -0.04686736f, -0.01979320f, -0.06093355f, -0.04814854f, -0.03480679f, 0.03894296f, 
    0.01476426f, 0.04593118f, -0.04454124f, 0.05980317f, -0.05388699f, 0.00229779f, -0.02642388f, 0.00820385f, 
    -0.06645773f, -0.05144739f, -0.05853187f, -0.04502124f, -0.05128887f, 0.02381398f, 0.03588697f, 0.00068948f, 
    -0.06588782f, -0.01314258f, -0.04752648f, -0.02143594f, 0.01222179f, -0.02017415f, -0.03154119f, 0.00472002f, 
    0.43647027f, 0.48487511f, 0.30786017f, 0.00454344f, 0.04618181f, 0.04220622f, 0.15161811f, 0.00072543f, 
    -0.19411287f, 0.23118903f, 0.60505438f, 0.36876899f, -0.17747556f, 0.12403218f, 0.02037753f, -0.14701901f, 
    -0.32730204f, -0.00852463f, 0.08623698f, -0.00830328f, 0.11634123f, -0.34362963f, -0.12942176f, -0.10210841f, 
    0.14409050f, 0.15012789f, 0.15521014f, -0.01418762f, -0.10234223f, 0.05278661f, -0.31680498f, -0.26227993f, 
    -0.04103949f, -0.07319295f, 0.09789572f, -0.01348094f, -0.14867930f, -0.11074572f, -0.14086644f, -0.12997302f, 
    -0.05367198f, -0.02021163f, -0.05754566f, 0.10261659f, -0.17637379f, 0.23536935f, 0.35391700f, 0.14530630f, 
    0.02476022f, -0.07439914f, 0.09549115f, -0.05486585f, -0.03593566f, -0.05686935f, -0.00551541f, 0.05687713f, 
    -0.17876017f, -0.03520596f, -0.09631365f, -0.07177240f, -0.08407581f, -0.06481649f, 0.10605712f, -0.09749893f, 
    -0.12721619f, 0.06950407f, -0.20237663f, -0.29396072f, -0.36407730f, 0.01905597f, 0.04268218f, 0.10944394f, 
    0.17628564f, 0.02251766f, 0.12578861f, -0.49484149f, -0.22809593f, 0.36192682f, 0.30143291f, 0.15783550f, 
    0.02831493f, -0.12945364f, 0.05242368f, 0.55056632f, -0.09124939f, 0.11577184f, -0.03151853f, -0.02766041f, 
    -0.11297670f, 0.25380936f, -0.27552605f, -0.39570656f, 0.06623373f, 0.09278343f, 0.07741734f, 0.06973597f, 
    0.07692802f, -0.10049499f, -0.11594487f, 0.06900328f, -0.42721918f, -0.95851481f, 0.17265061f, -0.00810143f, 
    -0.04866641f, -0.09568603f, 0.09199985f, -0.04382913f, 0.28332514f, 0.00769379f, -0.13535342f, -0.24070713f, 
    -0.00342775f, -0.00074910f, 0.04563602f, -0.02017698f, -0.13100639f, 0.14002739f, 0.07260805f, 0.01638584f, 
    -0.02084806f, -0.08281492f, 0.02840956f, 0.02177469f, -0.11892596f, -0.07041547f, 0.14482012f, -0.14196159f, 
    -0.24842283f, -0.17546612f, 0.07664966f, 0.25188249f, 0.20568480f, 0.25222781f, -0.10882986f, -0.31362948f, 
    -0.03295409f, -0.00361198f, 0.01530103f, -0.23645046f, -0.34006682f, -0.10646591f, -0.11117510f, 0.06679790f, 
    0.15028971f, 0.04028386f, 0.11814701f, 0.00401961f, -0.03601332f, -0.05039651f, -0.02143820f, 0.07451729f, 
    0.09405784f, -0.39603621f, -0.27126884f, -0.03223040f, -0.00684753f, -0.01044171f, -0.00331105f, -0.02205824f, 
    -0.03753011f, -0.11268815f, 0.07449272f, 0.04641138f, -0.01938902f, -0.02788751f, -0.14566359f, -0.19021693f, 
    -0.21316454f, 0.03429455f, 0.00623504f, 0.15987290f, 0.14092152f, 0.21835597f, -0.34133372f, 0.06487630f, 
    0.13636859f, -0.01304183f, -0.06415732f, -0.01736015f, 0.10017202f, 0.01412119f, 0.05435152f, -0.02503216f, 
    -0.09449752f, -0.00140018f, 0.34158078f, 0.15627860f, 0.02330474f, 0.12666030f, 0.01190999f, 0.12095921f, 
    0.04533809f, -0.18131222f, 0.08633234f, 0.32918212f, 0.18649986f, -0.23013915f, -0.22771363f, -0.31126702f, 
    -0.43594921f, 0.09887809f, -0.02122804f, -0.32592964f, 0.06853671f, 0.12220493f, 0.16905135f, 0.33602861f, 
    0.45705098f, 0.24159165f, -0.04343116f, 0.03453682f, -0.07673106f, 0.09630584f, -0.12152367f, 0.01277195f, 
    0.29607567f, 0.03828497f, 0.16707353f, 0.14483806f, 0.04241312f, -0.06021449f, -0.24152063f, -0.32470304f, 
    0.02327718f, 0.04348635f, 0.02560580f, 0.01695492f, 0.17121887f, 0.02445121f, -0.02515719f, -0.11108616f, 
    0.13503253f, -0.25305557f, 0.57958746f, 0.30007318f, -0.01969268f, -0.08779058f, -0.03029928f, -0.06190323f, 
    0.01869110f, -0.10202348f, 0.10500637f, -0.05066179f, 0.18423550f, 0.02016413f, -0.07077466f, -0.14488980f, 
    -0.00077747f, 0.25194195f, -0.19525909f, -0.00253626f, 0.22630331f, 0.37663254f, 0.26155517f, -0.05053641f, 
    -0.03210207f, 0.00259251f, 0.10818052f, -0.06796180f, 0.36818719f, -0.08655864f, -0.08650576f, 0.13439433f, 
    -0.29519227f, 0.08360328f, -0.11512699f, 0.10852332f, 0.21833789f, -0.19661467f, -0.22552224f, -0.32503787f, 
    -0.24652515f, -0.04807129f, 0.00880283f, -0.08569454f, 0.06182263f, -0.09437469f, 0.03233278f, -0.24861655f, 
    -0.05309226f, -0.04245377f, 0.05718933f, -0.01870774f, -0.13676341f, 0.08377224f, 0.16130421f, 0.30078641f, 
    0.11404187f, -0.12507230f, -0.20889868f, 0.04487453f, -0.36319739f, -0.24814457f, 0.01788997f, 0.04746072f, 
    0.05787636f, 0.40308630f, -0.18319722f, 0.26655203f, -0.06102835f, -0.13438857f, 0.01288060f, 0.05510711f, 
    0.00035863f, 0.12937060f, -0.18906397f, 0.14199041f, 0.20144482f, -0.15838329f, 0.07966278f, -0.14659749f, 
    0.12859376f, 0.15968083f, 0.09879902f, -0.07111035f, 0.14268087f, -0.08368676f, 0.02790671f, 0.01121078f, 
    -0.08037601f, 0.01623222f, 0.16741697f, 0.07932731f, -0.00650347f, 0.05146252f, -0.23390737f, 0.03048478f, 
    -0.23639177f, 0.24635430f, 0.21334843f, 0.10270669f, 0.13426006f, 0.37039509f, -0.06314836f, 0.30453974f, 
    0.26703903f, -0.00249934f, 0.02086306f, -0.11090741f, 0.00651649f, 0.09154505f, -0.34530422f, -0.15108463f, 
    0.09224127f, 0.06997845f, -0.06247950f, 0.05563653f, 0.01768060f, -0.02002534f, 0.08326750f, -0.29025710f, 
    0.15666716f, -0.10259266f, -0.01044465f, 0.15582873f, 0.13047351f, 0.29360831f, 0.10996050f, 0.05002578f, 
    -0.02361221f, -0.12453437f, -0.33102137f, -0.13574484f, -0.08457455f, 0.03995141f, 0.06641205f, 0.01478717f, 
    0.05033901f, 0.36528116f, -0.03906557f, -0.28736457f, 0.01697805f, 0.24657993f, 0.12736969f, 0.10278380f, 
    0.04333171f, 0.09167390f, 0.52525628f, 0.15107931f, 0.43104047f, -0.14092617f, -0.03935714f, -0.09834782f, 
    0.08273737f, 0.13368651f, 0.21774201f, -0.17135097f, -0.60666436f, -0.26079655f, -0.01267745f, -0.06917082f, 
    0.15774532f, -0.02187569f, 0.15197277f, 0.02746327f, -0.40450561f, -0.05368352f, -0.29750943f, 0.15537623f, 
    -0.04724767f, 0.09343597f, 0.23847869f, 0.21925141f, -0.05954688f, 0.02385912f, -0.25231084f, -0.31819996f, 
    0.09825877f, 0.02668172f, 0.41542169f, 0.11278902f, -0.00485077f, -0.10751237f, -0.35739741f, -0.56487638f, 
    -0.78473711f, 0.17137185f, -0.40546766f, -0.06450430f, 0.21296874f, 0.16307986f, -0.55506074f, 0.15877080f, 
    -0.02379760f, 0.28517863f, 0.27986524f, 0.16968362f, -0.09931993f, 0.35516000f, 0.05245224f, 0.13349378f, 
    -0.05569186f, 0.29790801f, 0.21767125f, -0.13873607f, 0.00787022f, -0.32873568f, -0.12617791f, 0.03857553f, 
    0.11842518f, 0.50967711f, 0.33328059f, 0.12015594f, 0.00125277f, 0.11168366f, -0.09221623f, 0.10466392f, 
    0.14732166f, 0.01144802f, -0.25867885f, 0.02275352f, 0.18032812f, -0.03457414f, -0.09720526f, -0.05302770f, 
    0.00250834f, -0.06418364f, -0.05117462f, 0.15240015f, -0.79934412f, -0.55894667f, -0.09141874f, 0.09645551f, 
    -0.02308742f, 0.09475871f, -0.01323085f, 0.00853411f, -0.23519455f, 0.18003479f, 0.28367215f, -0.15589884f, 
    0.08653939f, -0.28473404f, -0.23366292f, -0.18974453f, 0.17653909f, -0.10906406f, 0.10547268f, 0.03442288f, 
    -0.01527639f, 0.18980990f, -0.28697485f, 0.18247542f, 0.02748433f, 0.10456696f, 0.13016444f, -0.46182650f, 
    -0.40771246f, -0.27588624f, -0.00393372f, 0.09542635f, 0.01551358f, -0.25473380f, -0.01767123f, 0.02262232f, 
    -0.29902092f, -0.02509311f, -0.29665112f, -0.04659899f, -0.02859544f, -0.13879107f, -0.06450762f, 0.10717629f, 
    -0.39017993f, 0.16665468f, 0.24384077f, 0.10939717f, -0.04059593f, -0.14864551f, -0.13914733f, -0.05302377f, 
    -0.04752813f, -0.71515548f, 0.03029780f, 0.12932666f, -0.07082559f, 0.05920725f, 0.02390979f, 0.07431829f, 
    0.06196101f, 0.03654683f, -0.09601802f, 0.08353622f, -0.01030713f, -0.01539233f, 0.02597815f, 0.15374644f, 
    -0.12631819f, -0.14373447f, 0.11880779f, 0.01332486f, 0.19735952f, 0.26983970f, 0.07364870f, -0.27099195f, 
    0.10435012f, 0.18213683f, 0.13056991f, 0.11776631f, -0.34323934f, 0.70223004f, -0.18768840f, -0.05636195f, 
    -0.27113262f, -0.46137208f, 0.08065405f, -0.01190405f, 0.14689089f, -0.17384560f, -0.09052905f, -0.14371459f, 
    -0.13416201f, 0.01097919f, -0.03929628f, 0.17257059f, 0.19411296f, -0.04114519f, -0.29478580f, -0.29353648f, 
    -1.32208216f, -0.28522941f, -0.21483220f, 0.05014216f, -0.05731011f, -0.14560869f, -0.00050153f, 0.06065736f, 
    0.29790953f, -0.52312487f, 0.02356921f, 0.09204311f, 0.12041216f, 0.15333004f, -0.01890283f, -0.23636498f, 
    0.52964449f, 0.14128236f, -0.06688613f, 0.15941702f, 0.20779744f, -0.12912965f, -0.06434514f, 0.10144931f, 
    -0.03306488f, 0.05574532f, 0.26979667f, 0.14447103f, -0.02524385f, -0.02878961f, -0.11870997f, -0.07777746f, 
    -0.02700976f, 0.02095062f, 0.09056922f, 0.06690126f, 0.16665640f, -0.17515732f, -0.31842038f, -0.34144118f, 
    0.03684323f, 0.17095914f, -0.13001485f, 0.09417488f, 0.11322715f, -0.05268391f, 0.04934817f, 0.08771598f, 
    0.26702684f, 0.10936087f, -0.09617458f, 0.08773378f, 0.29344052f, 0.37591207f, 0.07914387f, -0.09502991f, 
    -0.14818956f, -0.09655102f, 0.08891983f, -0.02267396f, -0.08692809f, -0.45707765f, 0.07607849f, 0.20420915f, 
    0.03176980f, 0.08800182f, 0.00912228f, -0.18856381f, 0.22531992f, 0.16614859f, -0.08603578f, 0.26661298f, 
    0.05639326f, -0.10541465f, 0.05343030f, 0.06650367f, 0.24370249f, 0.10107097f, 0.25589785f, -0.15427804f, 
    0.05601190f, -0.14022741f, -0.10218514f, -0.04157226f, 0.08436493f, -0.01888650f, 0.03828372f, 0.08732477f, 
    0.08410677f, 0.09298461f, 0.22368723f, 0.00013909f, 0.06345127f, 0.10284910f, 0.01135250f, 0.10570638f, 
    0.06686095f, 0.49857384f, 0.24470080f, 0.10166291f, 0.07994781f, 0.09073801f, 0.02491844f, 0.19662698f, 
    -0.15196680f, 0.20013057f, -0.21215566f, -0.16160502f, 0.09232675f, -0.04915075f, 0.05353328f, -0.07770507f, 
    0.07925537f, 0.17728396f, -0.20337960f, 0.12020864f, -0.14896810f, 0.31963703f, -0.13701239f, -0.00760219f, 
    -0.32733744f, 0.17860225f, 0.09334868f, 0.08743909f, -0.07435472f, 0.11121321f, -0.26302427f, 0.05780916f, 
    -0.06661976f, 0.03118213f, 0.02082912f, -0.11426000f, -0.22813468f, 0.21378537f, 0.02959073f, 0.04955624f, 
    0.04895440f, 0.00093816f, -0.03946029f, -0.01551889f, -0.02564495f, 0.17214753f, -0.44629195f, -0.35066712f, 
    -0.42752877f, -0.07622975f, 0.08063949f, 0.03107917f, 0.22149351f, -0.01011241f, 0.03779423f, -0.16575339f, 
    -0.11261201f, -0.10405450f, -0.00800637f, 0.10100514f, -0.36230299f, 0.20765448f, 0.16690622f, -0.21016686f, 
    0.14265406f, 0.04223849f, 0.05483633f, -0.00141924f, -0.07697866f, -0.02282107f, -0.08940729f, 0.09049168f, 
    0.10422877f, -0.42658448f, -0.19311729f, -0.08767386f, -0.03200883f, 0.05312674f, -0.01647941f, -0.04939488f, 
    0.18642043f, -0.11317182f, 0.18648887f, 0.05185645f, -0.03968285f, 0.19494566f, 0.19618459f, -0.10153488f, 
    0.17637420f, -0.00695429f, 0.02674693f, 0.16389017f, 0.06246350f, 0.21257554f, 0.24997264f, 0.09817952f, 
    0.02184177f, -0.09304006f, 0.08499546f, -0.05938972f, 0.11787562f, 0.03621846f, 0.08416452f, 0.25745061f, 
    0.12407797f, 0.15762074f, 0.25897077f, 0.03669594f, 0.05961934f, -0.03652012f, -0.29556760f, 0.02285726f, 
    0.17065716f, 0.02398654f, 0.05882039f, 0.13948052f, 0.09395749f, 0.28433502f, 0.18913834f, 0.20508184f, 
    -0.23899810f, 0.08817288f, 0.18448509f, 0.21736774f, -0.28829953f, 0.09321565f, 0.11536977f, 0.35954919f, 
    0.32540226f, -0.31582195f, 0.27829766f, -0.01800993f, -0.02691257f, 0.02998410f, 0.11805479f, 0.08292543f, 
    0.16113722f, -0.03295701f, -0.02988456f, 0.02595835f, -0.00870496f, 0.13595770f, 0.07473643f, 0.08579128f, 
    0.00987117f, 0.18948981f, -0.04383818f, 0.00153902f, -0.04214817f, -0.05574199f, 0.10157183f, 0.14703113f, 
    -0.08485561f, 0.07576846f, 0.30915436f, 0.18736653f, -0.12948593f, 0.29504612f, 0.05176515f, 0.11737261f, 
    0.05505654f, 0.14623322f, -0.05684950f, 0.14195736f, 0.53026259f, 0.30949810f, -0.10539254f, 0.04936564f, 
    -0.20170464f, -0.10167515f, 0.00572259f, 0.16393451f, 0.33214512f, 0.06942360f, -0.28519911f, 0.08505378f, 
    0.15697445f, 0.05995984f, -0.05202361f, 0.24491201f, 0.08710136f, -0.08310436f, -0.10514887f, -0.07970791f, 
    -0.16452771f, -0.24732392f, 0.02349862f, 0.04413873f, -0.25517830f, -0.10509997f, -0.22085375f, 0.25137207f, 
    -0.56289309f, 0.17970230f, 0.41054797f, 0.38090387f, -0.17568317f, 0.26174191f, 0.20085602f, 0.21159734f, 
    0.21092734f, -0.20030378f, -0.01708643f, 0.06069032f, 0.17790532f, -0.13850340f, 0.16113096f, 0.01780061f, 
    -0.01571083f, -0.00565837f, 0.01945067f, 0.01150853f, -0.04079404f, 0.04968186f, -0.01865311f, 0.01619873f, 
    0.02437571f, 0.01942017f, -0.02304350f, -0.00627881f, -0.03035231f, -0.03257557f, 0.01000282f, 0.01203883f, 
    0.00064574f, -0.04417117f, 0.04644493f, -0.04055016f, -0.02052463f, 0.00454823f, -0.01190090f, -0.05289774f, 
    0.02700360f, 0.03811136f, -0.00681356f, -0.00197310f, -0.02001076f, -0.02861404f, 0.00660764f, -0.03155460f, 
    0.04356980f, -0.01021856f, 0.02805722f, -0.05688364f, 0.03650811f, 0.00139183f, 0.02931018f, -0.05817815f, 
    -0.03859056f, 0.02617368f, -0.02728268f, 0.04411487f, 0.03162433f, 0.03811625f, -0.05539923f, -0.05428083f, 
    -0.01232577f, 0.01809135f, -0.04828835f, -0.03889129f, -0.05059798f, -0.02178974f, -0.05227865f, -0.04091400f, 
    0.01324928f, 0.02439787f, 0.00940204f, 0.01576049f, -0.03809333f, 0.01156097f, -0.04398024f, -0.02218592f, 
    -0.02108333f, -0.06281313f, -0.02177767f, -0.02769374f, -0.04764745f, -0.03412101f, -0.02581620f, -0.05040430f, 
    -0.01355447f, -0.05149718f, -0.01733498f, 0.03796828f, 0.04627404f, -0.05131813f, -0.02976633f, -0.03826728f, 
    0.02003298f, 0.02263777f, -0.01551624f, 0.02796468f, 0.00897302f, -0.01378244f, -0.03924749f, -0.02584868f, 
    -0.04603513f, 0.04059700f, 0.00846576f, -0.05739447f, -0.06465732f, -0.05706336f, -0.02287522f, -0.02829906f, 
    -0.05497497f, -0.01419669f, -0.00215529f, 0.05888292f, -0.00254894f, 0.03672329f, 0.03026505f, -0.05556824f, 
    -0.01051817f, -0.00008140f, 0.00499957f, -0.01872657f, -0.05293334f, -0.00176808f, -0.05417329f, 0.03697083f, 
    0.00004670f, -0.04299420f, -0.05367441f, 0.00597355f, 0.03029788f, -0.04912318f, -0.04307536f, 0.03764538f, 
    -0.04443708f, -0.01569521f, 0.04318072f, -0.03602511f, 0.04026532f, -0.00342655f, 0.03977807f, 0.01816137f, 
    0.01976920f, 0.02377007f, 0.00331898f, -0.00928748f, -0.00428107f, 0.03028933f, -0.03718651f, -0.03437565f, 
    -0.05309516f, -0.02572026f, -0.01294724f, -0.05015288f, 0.00950272f, -0.00306805f, 0.04088276f, -0.00308493f, 
    0.01585367f, -0.04536007f, -0.03294461f, -0.01615011f, 0.04832889f, 0.03296429f, -0.03305915f, -0.04249555f, 
    0.00330359f, -0.05649496f, 0.05127802f, 0.01967256f, -0.00067226f, 0.04264948f, -0.00035252f, 0.04196299f, 
    -0.05860120f, -0.01179235f, 0.03874739f, -0.01266730f, 0.03167232f, -0.05379600f, 0.04305825f, -0.03050812f, 
    -0.04836282f, -0.02992423f, 0.00856629f, -0.05980976f, -0.00444129f, -0.00303218f, 0.03044532f, -0.00878181f, 
    0.03265768f, -0.03367821f, -0.00373589f, -0.05315029f, -0.00038401f, 0.04216211f, 0.00806407f, -0.04949635f, 
    0.00155965f, -0.03585180f, 0.02537092f, -0.05641717f, 0.02643288f, -0.04135661f, 0.02486392f, -0.01233920f, 
    -0.03610487f, 0.00609922f, -0.03619296f, 0.00404821f, -0.05116400f, -0.00601131f, -0.05848508f, -0.02938867f, 
    -0.03718697f, 0.01700475f, 0.03909762f, -0.00870644f, -0.02179109f, 0.03911600f, 0.03312586f, 0.00270460f, 
    -0.00052428f, 0.05880810f, -0.04129623f, -0.04760816f, 0.05123392f, -0.05003342f, -0.01397679f, -0.06209777f, 
    0.01047638f, 0.04461695f, 0.04554928f, 0.03521048f, -0.04343815f, 0.03224695f, 0.04821493f, -0.00345786f, 
    0.04832379f, -0.00586464f, 0.03391131f, 0.01606598f, -0.05410381f, 0.00186742f, -0.00438347f, -0.03852214f, 
    -0.01068020f, -0.02352707f, -0.00607127f, -0.03884687f, 0.00200201f, -0.03281733f, 0.01627198f, -0.01433979f, 
    -0.05058806f, 0.00789873f, 0.03851370f, 0.03298159f, 0.05053778f, -0.03337353f, 0.02888368f, 0.04355919f, 
    -0.01174321f, 0.05239226f, -0.02007891f, -0.03419952f, 0.03699128f, -0.05565326f, 0.03641263f, -0.01048312f, 
    0.01096666f, -0.05910556f, 0.03754225f, 0.00750064f, 0.05078803f, 0.02066319f, 0.04399025f, 0.04339053f, 
    -0.01108559f, 0.00501655f, 0.02460701f, -0.04674224f, 0.02031842f, -0.03129125f, 0.04399307f, -0.05313917f, 
    -0.04884594f, -0.01964263f, -0.02745163f, 0.02086647f, -0.00745170f, -0.02530851f, -0.00425447f, -0.01829802f, 
    -0.05727244f, 0.02392642f, -0.02246365f, 0.05191691f, 0.03191124f, -0.03330708f, -0.01327263f, -0.04126971f, 
    0.02562225f, -0.04506823f, 0.03118650f, 0.02742738f, -0.06010888f, -0.04970059f, 0.02216219f, 0.02639095f, 
    0.03381595f, 0.00965278f, 0.02169572f, -0.06030617f, -0.02912995f, 0.01538842f, 0.04309106f, 0.02947832f, 
    0.01650402f, 0.01879662f, 0.00185641f, 0.03566952f, 0.01497711f, -0.06979372f, 0.05200897f, -0.00548329f, 
    0.00936461f, 0.05281124f, -0.04120340f, 0.02485301f, -0.04398730f, 0.01815060f, 0.03888196f, -0.04118173f, 
    -0.01669237f, 0.01819193f, 0.04688887f, -0.01204373f, 0.04532974f, -0.02007628f, -0.05463268f, -0.01210740f, 
    -0.01938412f, -0.06007930f, 0.02048330f, -0.03368646f, -0.02237742f, -0.04597441f, -0.03485121f, -0.03632158f, 
    0.02950307f, 0.03417422f, -0.03369853f, -0.04862000f, 0.00717686f, 0.02066888f, 0.02219542f, 0.01644467f, 
    0.04780599f, -0.02936796f, 0.00941846f, 0.00089995f, -0.05772615f, 0.01050324f, -0.05623688f, -0.04043470f, 
    -0.03296220f, -0.04756817f, -0.05550441f, 0.04523922f, -0.02971071f, 0.02426961f, -0.00161477f, -0.06037711f, 
    0.01898425f, 0.02601043f, -0.02557612f, 0.01708053f, 0.05305332f, -0.05420013f, -0.01299099f, -0.05254371f, 
    -0.00704924f, 0.04744488f, 0.01629699f, 0.01002667f, 0.04736373f, 0.04706546f, 0.03347500f, -0.03960666f, 
    -0.01145209f, -0.02936742f, 0.01907076f, -0.02326612f, -0.00990760f, -0.02358101f, -0.01888507f, -0.00522096f, 
    -0.03300766f, -0.06174977f, 0.02079616f, 0.05027071f, 0.01252858f, -0.04773745f, -0.02429278f, -0.01527424f, 
    -0.00206762f, 0.02792974f, -0.06131056f, -0.03280710f, -0.05119687f, -0.05363863f, 0.04936827f, -0.02039792f, 
    -0.05192086f, 0.02943446f, -0.04664432f, 0.02322820f, -0.03238930f, 0.04423943f, -0.05857352f, 0.04733619f, 
    0.04170692f, 0.00774997f, -0.00444996f, 0.04023973f, -0.05868676f, 0.00859624f, -0.02551071f, -0.04001995f, 
    0.02034641f, -0.01722326f, -0.02105925f, -0.00168235f, -0.04995690f, 0.01837667f, -0.01931293f, -0.02182840f, 
    0.01439424f, -0.05536554f, 0.01103630f, -0.02883532f, 0.01725671f, -0.03626944f, 0.04311684f, 0.02711680f, 
    -0.01767052f, 0.00430132f, 0.02564368f, -0.00022029f, -0.04587476f, -0.03521914f, 0.00024034f, -0.04297954f, 
    -0.01428068f, 0.02886784f, -0.05367832f, -0.06097640f, -0.05995245f, -0.05148555f, -0.05958984f, -0.05106653f, 
    -0.02667856f, 0.04466446f, -0.02215071f, -0.05435098f, 0.00434732f, 0.03650041f, 0.00972590f, 0.01266388f, 
    -0.03855435f, 0.03955820f, 0.01498148f, -0.06253604f, -0.03931511f, -0.05064330f, 0.01937563f, 0.03661638f, 
    0.00599973f, -0.00265278f, -0.01338299f, -0.02962084f, -0.03661914f, -0.02798244f, 0.00958407f, -0.00745005f, 
    0.04379045f, -0.03987432f, -0.00792843f, -0.06536157f, -0.00102729f, -0.05343944f, 0.01285769f, -0.04164349f, 
    -0.05392651f, 0.02184336f, -0.02159775f, 0.01410111f, 0.04320288f, 0.05231509f, -0.01522199f, 0.01433805f, 
    -0.04792194f, -0.04110617f, -0.03507482f, -0.00614011f, 0.02943409f, 0.00919123f, 0.00642425f, -0.00988147f, 
    -0.04959150f, -0.00634887f, 0.00145051f, -0.02326562f, -0.04553865f, 0.04135900f, 0.01756319f, -0.04011102f, 
    -0.06303505f, 0.02790832f, 0.03961756f, 0.01693281f, 0.04572679f, 0.03291783f, -0.00653021f, -0.02592839f, 
    0.02599383f, 0.02819294f, -0.06160634f, -0.01436605f, -0.00470380f, 0.05286320f, -0.00114504f, -0.04958624f, 
    -0.02414435f, 0.05045010f, -0.05861018f, 0.02393994f, -0.01086361f, -0.05937693f, 0.02271545f, -0.03423520f, 
    -0.00868405f, 0.05266896f, 0.01534452f, -0.04270980f, -0.05660039f, -0.05736868f, -0.02731465f, 0.00215650f, 
    0.03256981f, -0.06007251f, -0.05734845f, -0.02879274f, 0.05339427f, 0.02412065f, -0.02415418f, -0.03494835f, 
    -0.02051726f, -0.04542355f, -0.03224434f, 0.00034492f, 0.04166204f, 0.04549145f, 0.03027873f, 0.04227027f, 
    0.02214694f, -0.05871562f, -0.02369017f, -0.05065035f, 0.05060181f, -0.01439142f, -0.00359735f, 0.05317923f, 
    -0.04936957f, 0.03388090f, -0.02732804f, -0.02119350f, 0.02806226f, -0.05014498f, 0.04624695f, -0.04818855f, 
    -0.03513440f, -0.04131353f, 0.02477095f, 0.03037103f, 0.00013046f, 0.05115834f, 0.00453028f, -0.05515508f, 
    -0.01309796f, 0.04825892f, 0.22098683f, -0.09526629f, 0.07895808f, -0.08707978f, -0.08200567f, 0.09321928f, 
    0.14699632f, -0.36704123f, -0.08453082f, -0.34155324f, -0.14359091f, -0.08491938f, 0.04900819f, 0.07301991f, 
    -0.01599004f, 0.25163493f, 0.16281779f, 0.12931563f, 0.14402364f, -0.15520087f, -0.05672972f, -0.09735671f, 
    -0.22351868f, -0.05058411f, 0.04017736f, -0.00001567f, 0.12862062f, 0.28244540f, -0.07385530f, 0.07912352f, 
    -0.07460853f, -0.04354141f, 0.06203611f, 0.01566518f, -0.09205252f, 0.28324357f, 0.01015062f, -0.17247303f, 
    0.23432277f, -0.18036324f, 0.33575335f, -0.01557995f, -0.22787881f, -0.69554943f, 0.11065789f, -0.02968987f, 
    -0.09734595f, -0.05446860f, 0.13829744f, 0.02541179f, 0.03510968f, -0.01966945f, -0.32701415f, -0.03675390f, 
    0.26507190f, 0.01285816f, 0.00695755f, -0.04713773f, 0.07094146f, 0.32213327f, 0.16186868f, 0.36465135f, 
    0.13610990f, 0.09560948f, -0.11611975f, 0.04520182f, -0.07570489f, -0.11803927f, 0.01087930f, 0.18781586f, 
    0.13097133f, 0.06844481f, 0.04216166f, -0.22779800f, -0.07950232f, -0.21792160f, -0.18225184f, -0.10471495f, 
    -0.07505215f, 0.31232417f, 0.22275682f, -0.33402422f, -0.06276884f, -0.22726165f, 0.34076786f, -0.03881505f, 
    0.03208749f, 0.32186478f, -0.53306079f, 0.21370123f, -0.05174583f, -0.00938765f, -0.08730007f, -0.16059425f, 
    0.01206287f, 0.15122931f, 0.02370155f, -0.24700806f, -0.08919293f, 0.03624497f, 0.09029716f, 0.13761552f, 
    -0.15643676f, -0.12883721f, 0.11304919f, 0.22915837f, 0.08116542f, -0.10436097f, -0.15987238f, 0.01424134f, 
    0.14776145f, 0.04999722f, 0.00897423f, -0.00941625f, 0.25073397f, 0.05786013f, -0.14303906f, 0.05076675f, 
    -0.15978269f, 0.13940229f, -0.04270479f, -0.19389203f, -0.06420320f, -0.05615383f, 0.02864884f, -0.05098614f, 
    0.10075366f, -0.10663255f, 0.29397976f, 0.02308953f, -0.01982181f, 0.11689804f, 0.09804866f, -0.01129158f, 
    0.18858606f, -0.04140829f, 0.23573934f, -0.10402130f, -0.28674394f, 0.12454912f, 0.29871911f, 0.09820206f, 
    0.08923075f, 0.04066901f, 0.24616693f, 0.00394813f, -0.03816275f, -0.10081077f, -0.19273496f, 0.06629251f, 
    -0.13096140f, -0.26638526f, 0.08842138f, 0.08438013f, -0.03683365f, 0.02515754f, 0.08906967f, -0.10474735f, 
    0.20392647f, 0.05316177f, 0.05896776f, 0.12081976f, 0.26775324f, 0.03970031f, 0.11462368f, -0.04047387f, 
    0.03074069f, 0.24383375f, -0.00742932f, -0.22403513f, -0.22197206f, -0.23059173f, -0.18427244f, -0.07744287f, 
    -0.11321498f, -0.09600750f, -0.00425187f, -0.00945913f, 0.10521506f, 0.09358378f, 0.18010856f, 0.00219230f, 
    -0.04101500f, -0.04016764f, -0.13753635f, -0.08611241f, -0.11249005f, -0.26373786f, 0.25493661f, 0.38710228f, 
    0.18314993f, -0.10432307f, -0.12827928f, -0.04649564f, -0.14231598f, 0.48740342f, 0.33823866f, 0.14197823f, 
    0.24805006f, -0.27222371f, 0.09014137f, -0.25695997f, 0.04635413f, -0.31459603f, -0.42113099f, 0.08579345f, 
    -0.29068422f, -0.00068582f, 0.08109011f, 0.02601228f, 0.00633065f, 0.02173528f, 0.06515100f, 0.12366766f, 
    0.08777130f, 0.05527363f, 0.16881515f, -0.01923795f, 0.04350334f, 0.02794256f, -0.11197123f, -0.01013772f, 
    0.10506122f, 0.04783900f, 0.04618208f, 0.24842703f, -0.17751089f, 0.01865466f, -0.02769897f, -0.02164851f, 
    -0.08794200f, 0.24742356f, 0.48681757f, 0.19161800f, 0.41451618f, -0.01197244f, 0.16522282f, 0.05277897f, 
    -0.05394681f, -0.01469404f, -0.16861618f, 0.17458101f, 0.28410426f, -0.31241947f, -0.07336572f, -0.05291348f, 
    -0.08020990f, 0.06069151f, -0.08753772f, -0.00672079f, 0.40966755f, 0.03462224f, 0.23184182f, -0.11695961f, 
    0.05215130f, -0.20415458f, 0.03944791f, 0.08205294f, -0.27809742f, -0.01651762f, 0.05314554f, -0.14718106f, 
    -0.09406486f, 0.01095716f, 0.02232087f, -0.05877437f, 0.04160161f, 0.30973884f, -0.02873706f, -0.07914202f, 
    -0.11910991f, -0.30016664f, -0.06300874f, -0.15533167f, -0.00293084f, -0.02800366f, -0.26728085f, 0.30425796f, 
    0.32014754f, 0.24071239f, -0.10672504f, 0.08416259f, -0.02233366f, 0.12502491f, -0.28101915f, -0.16792056f, 
    0.04091722f, -0.02290903f, 0.02441698f, -0.02337128f, -0.01713888f, 0.04169897f, -0.02693381f, -0.02076308f, 
    -0.01932583f, -0.06523856f, -0.06769691f, -0.03020717f, 0.01525941f, 0.02594388f, 0.01329790f, 0.02720259f, 
    -0.01690974f, 0.03255759f, 0.02440193f, -0.04527062f, -0.02880854f, -0.02973009f, -0.03524936f, 0.05170751f, 
    0.01690642f, -0.05318982f, -0.05202212f, -0.01798114f, 0.02942760f, 0.03935041f, -0.04083832f, -0.01865531f, 
    -0.04649962f, -0.03749410f, -0.02717365f, 0.00279643f, -0.06825662f, -0.06395677f, -0.02436729f, -0.04655877f, 
    -0.05964985f, 0.04619716f, -0.02686903f, 0.01975179f, -0.04475372f, 0.02442842f, 0.01682792f, -0.01231130f, 
    0.03228801f, -0.00484981f, 0.04510549f, 0.01041185f, -0.05236007f, 0.04140637f, -0.03415961f, 0.00258215f, 
    -0.06290701f, -0.05411315f, -0.04277623f, 0.02828477f, 0.02146114f, 0.04502102f, 0.04128099f, -0.02441622f, 
    0.00703971f, 0.04410371f, -0.03625987f, 0.04371214f, -0.02772786f, 0.04805905f, 0.03730979f, -0.04988952f, 
    0.00237604f, 0.02862750f, -0.01060204f, 0.02142237f, 0.01765024f, -0.02873697f, -0.04149146f, -0.00873419f, 
    -0.02581838f, 0.04885692f, 0.03345237f, -0.00220142f, -0.05337764f, -0.06779968f, -0.04433877f, -0.00664751f, 
    -0.03718257f, 0.04195968f, -0.02721758f, 0.05092620f, 0.01205109f, -0.00576383f, 0.03331603f, -0.01194704f, 
    0.03924069f, 0.00255281f, -0.00513928f, 0.01512688f, -0.03281710f, 0.01887940f, 0.05118715f, -0.04231521f, 
    -0.05799398f, 0.05054885f, -0.01594691f, -0.04405371f, 0.00597277f, -0.01230741f, -0.05466387f, -0.05043600f, 
    -0.03744932f, 0.04760599f, -0.03181387f, 0.00642309f, 0.01614573f, 0.03157851f, -0.06168988f, 0.02381414f, 
    -0.04133775f, 0.03632665f, -0.01789606f, -0.00128289f, -0.03236124f, -0.00546901f, -0.05909636f, -0.06137867f, 
    -0.01187867f, -0.02944176f, -0.01099301f, -0.05341229f, -0.02754785f, 0.02928888f, -0.04193084f, -0.03619486f, 
    -0.06043725f, 0.02633450f, -0.06247076f, -0.02208236f, -0.06430850f, -0.03900872f, -0.06031248f, -0.04959433f, 
    -0.04313828f, 0.01989261f, -0.00826626f, 0.04642225f, -0.00773066f, 0.02816362f, -0.03996562f, 0.02772618f, 
    -0.06303118f, -0.04690520f, 0.02088986f, -0.05146924f, -0.06644257f, -0.03156132f, -0.05798014f, -0.04946422f, 
    -0.03041105f, 0.04308980f, -0.02327915f, 0.03516197f, 0.03056732f, -0.02232234f, -0.05451272f, -0.06029308f, 
    0.03964180f, -0.05234978f, -0.00176255f, -0.02951748f, 0.00230540f, 0.01546609f, 0.02286774f, -0.02850671f, 
    0.00331837f, 0.04998758f, 0.03750453f, -0.01578048f, 0.01519947f, -0.01131029f, 0.00202974f, -0.04546173f, 
    0.02981214f, 0.02545990f, -0.01608421f, 0.01249256f, -0.04592463f, -0.01181758f, -0.01633897f, -0.01244066f, 
    0.02218843f, -0.03633503f, 0.01545134f, 0.04039112f, -0.05808735f, -0.05932575f, -0.06310989f, 0.04221977f, 
    0.00031626f, 0.04824830f, 0.00564044f, -0.02331771f, -0.00624617f, 0.02334425f, -0.01163035f, -0.04791700f, 
    0.03937555f, 0.02026823f, 0.00303854f, 0.01042188f, -0.00490555f, -0.02789710f, 0.02863446f, -0.02112303f, 
    -0.01017712f, -0.03521170f, -0.05667064f, -0.04751868f, -0.04708817f, -0.04326117f, -0.03899467f, -0.00021413f, 
    -0.05476793f, 0.00542651f, -0.06711044f, 0.03771950f, -0.03734744f, -0.04015350f, -0.00291338f, -0.04852806f, 
    0.04671160f, -0.01670037f, 0.00744434f, -0.00487806f, -0.05542015f, 0.03113299f, -0.04341247f, -0.00187042f, 
    0.04413899f, -0.03702622f, 0.01690639f, 0.01088409f, -0.05857469f, 0.04146643f, 0.04210753f, 0.00248934f, 
    0.02031476f, 0.01246022f, -0.01821733f, -0.05658882f, 0.02295695f, 0.01879889f, 0.02240372f, 0.03158491f, 
    -0.06665604f, 0.04869240f, -0.02451450f, -0.02280242f, -0.05615537f, 0.03633843f, -0.00151608f, -0.06429623f, 
    -0.01984009f, 0.02158925f, -0.03929884f, 0.04910106f, -0.00940359f, -0.05077565f, 0.02018935f, 0.03126946f, 
    0.02279973f, -0.06222342f, 0.02206634f, -0.06425931f, 0.01612374f, 0.00388544f, -0.05093729f, 0.01321251f, 
    -0.05030359f, -0.04714419f, -0.03623274f, -0.02463767f, 0.01420006f, 0.04268302f, -0.01008682f, -0.04333818f, 
    0.59511000f, 0.17954473f, 0.09254874f, 0.03638776f, -0.13066015f, 0.06114249f, 0.03630227f, -0.37625286f, 
    -0.17633918f, 0.25655577f, 0.06037980f, 0.19470789f, -0.00920759f, 0.31239566f, -0.16547337f, -0.06203613f, 
    -0.09114413f, -0.11304162f, -0.24711008f, 0.02271940f, -0.20034534f, -0.04423799f, -0.01104919f, 0.19707699f, 
    0.13328479f, 0.23464802f, -0.12067284f, -0.08034181f, 0.14555739f, -0.29195610f, -0.10411428f, 0.05240490f, 
    0.00347103f, -0.12777478f, -0.06964461f, 0.23553240f, -0.09751634f, 0.08265533f, -0.12549190f, -0.03346297f, 
    0.02195919f, -0.16428533f, -0.01098957f, 0.08939102f, 0.11540920f, 0.25135925f, -0.01867492f, 0.02000264f, 
    0.23277698f, 0.02332524f, -0.17430680f, 0.15288304f, -0.01224228f, 0.14530441f, -0.13953064f, -0.02006037f, 
    -0.16760245f, -0.02178783f, 0.07298525f, 0.18893933f, -0.01200659f, 0.11376047f, -0.01025457f, -0.18354551f, 
    -0.32369873f, -0.15785442f, 0.22536214f, 0.05516174f, -0.18341042f, 0.01491895f, -0.08653443f, 0.04546400f, 
    -0.14385904f, -0.00583119f, -0.18852372f, -0.09098707f, -0.05301237f, 0.09519526f, -0.11237196f, -0.06225797f, 
    -0.08251964f, -0.12531725f, -0.27700853f, -0.10599113f, -0.18156753f, 0.08470800f, 0.02790464f, 0.00403030f, 
    -0.00227925f, -0.01803646f, 0.11595694f, -0.35412067f, -0.07735633f, -0.11274181f, 0.02733275f, -0.17133856f, 
    0.06662092f, -0.00586149f, 0.07808959f, 0.45885530f, -0.00754575f, -1.04765725f, 0.05885758f, -0.07755908f, 
    -0.31233892f, 0.26595917f, 0.00237774f, -0.26110947f, 0.04917324f, 0.08427857f, 0.18551874f, -0.01370880f, 
    0.02447624f, 0.15919979f, -0.08269383f, -0.17599575f, -0.30258486f, -0.04464519f, 0.20808499f, 0.12259013f, 
    0.14364929f, 0.09156279f, 0.15237950f, 0.11927839f, -0.09261584f, -0.00807429f, 0.65142483f, -0.14408945f, 
    -0.98015445f, -0.19255932f, -0.26328230f, -0.14010268f, 0.16621497f, -0.25882584f, -0.28034550f, -0.03891959f, 
    0.04332363f, -0.37495080f, 0.07737058f, 0.11147840f, 0.12488716f, 0.04310803f, 0.13931902f, -0.23758258f, 
    0.14321962f, -0.04491445f, 0.01607982f, 0.19363587f, 0.26581520f, 0.15886573f, 0.06553072f, -0.12396307f, 
    0.01946816f, 0.08197323f, -0.23072958f, -0.30506319f, -0.02406450f, 0.10179942f, -0.06900406f, 0.12123574f, 
    -0.15430261f, 0.09403873f, -0.12264947f, 0.06921896f, -0.27106756f, 0.05575262f, -0.01815566f, 0.06357517f, 
    -0.18229328f, 0.13710076f, 0.06107496f, -0.05210106f, 0.05732549f, -0.08581941f, -0.37729606f, -0.00959487f, 
    0.18181558f, 0.23678701f, -0.05553472f, 0.10364710f, 0.02528749f, 0.07686447f, -0.07187174f, 0.16771720f, 
    0.02709650f, 0.01656241f, -0.08057841f, 0.08120052f, 0.11479149f, 0.19131134f, 0.03905691f, -0.32584524f, 
    0.12030144f, -0.22862962f, 0.01582044f, -0.07130072f, -0.07620133f, -0.07799184f, -0.07325383f, -0.28168613f, 
    -0.02438530f, 0.00948612f, 0.19381633f, -0.01984910f, -0.01515387f, 0.01458650f, 0.12525876f, 0.47734895f, 
    0.26547369f, 0.51990527f, 0.01880959f, -0.01983445f, -0.26013848f, -0.00898314f, -0.26702577f, -0.38436100f, 
    0.46628395f, 0.15654312f, 0.15245268f, 0.38738370f, 0.13165733f, 0.09199844f, 0.17758945f, 0.09209411f, 
    0.10327801f, 0.37659499f, 0.05461549f, -0.25253794f, 0.33847541f, -0.05585340f, 0.00511416f, 0.27175829f, 
    0.03474820f, 0.22099464f, 0.36455241f, -0.08103112f, 0.07776926f, 0.03875084f, -0.01865344f, 0.10072667f, 
    0.05173123f, -0.09098037f, -0.19414815f, -0.08305787f, 0.02347160f, 0.35970068f, -0.02452165f, 0.12946858f, 
    0.21345641f, -0.00278737f, 0.06979932f, 0.00455085f, 0.16685867f, 0.14639631f, 0.29251328f, -0.07600870f, 
    0.11488966f, 0.10314324f, -0.00609025f, -0.13133636f, -0.05369337f, -0.03510427f, -0.16988091f, -0.25852677f, 
    -0.23031034f, -0.11643311f, -0.12248037f, -0.34260470f, -0.05931623f, -0.62584299f, -0.17268705f, -0.05629839f, 
    0.29980859f, -0.08725108f, 0.22297430f, 0.17505378f, -0.03521443f, 0.05776976f, 0.22550945f, -0.36643648f, 
    -0.28456500f, -0.02328670f, 0.08302672f, 0.13691776f, 0.21420862f, 0.15833066f, 0.05192662f, 0.08218177f, 
    -0.52873492f, 0.34473950f, -0.09960681f, -0.16847432f, -0.16719344f, -0.00796294f, -0.05597621f, -0.09938663f, 
    0.01633328f, 0.05411499f, -0.32002157f, 0.06746273f, -0.03413981f, 0.08534784f, -0.21359754f, 0.10565328f, 
    0.11263060f, -0.05520473f, 0.05175485f, -0.01416649f, -0.10291856f, -0.38500929f, -0.25387165f, -0.07601790f, 
    -0.00623883f, -0.05307015f, 0.03632173f, -0.08298418f, 0.16617976f, 0.12586612f, -0.29252118f, 0.20072262f, 
    -0.13370325f, 0.02177226f, 0.00600851f, -0.07168957f, 0.06999854f, 0.06586986f, 0.13308907f, -0.04429794f, 
    0.17369558f, 0.04465027f, -0.11861029f, -0.21475331f, -0.07762010f, 0.06619716f, -0.00887532f, -0.05978290f, 
    0.09019842f, 0.17313693f, -0.16625585f, 0.15153924f, -0.01605010f, 0.22311558f, -0.38951969f, 0.11507199f, 
    0.07389472f, -0.03365628f, -0.19070095f, -0.28134397f, 0.23582755f, 0.25738254f, 0.11417038f, -0.18763629f, 
    0.27834153f, 0.34550375f, 0.15716225f, 0.00271728f, -0.08672265f, 0.17245728f, 0.28214929f, 0.09331527f, 
    -0.05918204f, -0.03495793f, -0.23494248f, -0.23254037f, 0.01144070f, -0.39559579f, 0.12397468f, 0.07839113f, 
    0.03264669f, -0.68541145f, -0.26631886f, 0.55203837f, -0.18609898f, -0.00643858f, 0.08263893f, -0.04233700f, 
    0.20372571f, -0.17276563f, -0.35669866f, -1.01675248f, 0.14655945f, 0.04277769f, 0.10076772f, -0.18369184f, 
    0.14687434f, 0.08841512f, -0.01046889f, 0.58159924f, -0.57993913f, -0.79140586f, -0.41387635f, 0.32483944f, 
    -0.01202817f, 0.13546216f, -0.18574575f, -0.09966601f, 0.27141806f, 0.15182765f, -0.27994153f, -0.04513276f, 
    0.07219377f, 0.07472228f, 0.19530575f, 0.21393508f, 0.15429690f, -0.14588460f, 0.24540740f, -0.11805503f, 
    0.06526908f, 0.17059445f, 0.06799638f, 0.16043091f, 0.14496410f, 0.00293169f, 0.09612829f, -0.17185940f, 
    -0.57765067f, 0.11162354f, 0.09669833f, -0.12367889f, -0.33795905f, -0.05849906f, -0.05758988f, 0.14670710f, 
    -0.08145362f, 0.28394338f, -0.20721409f, 0.23741417f, 0.16135035f, 0.13037159f, 0.21643880f, 0.08597215f, 
    0.00472266f, 0.06594568f, 0.06003866f, -0.06225157f, 0.09450696f, -0.33457500f, 0.12945934f, 0.14689092f, 
    0.09242504f, 0.04064815f, -0.42221215f, 0.00337598f, 0.18698309f, 0.08865847f, -0.13071465f, 0.15133940f, 
    0.13780496f, 0.22532065f, -0.07492605f, 0.23826407f, 0.12726013f, -0.13863231f, -0.05212434f, -0.13641335f, 
    0.01270681f, -0.11674505f, -0.03474632f, -0.08543377f, 0.19318472f, 0.19226107f, -0.12113804f, 0.07385727f, 
    -0.06764240f, 0.10710083f, 0.05912420f, 0.12343299f, 0.01844917f, 0.04244615f, -0.01408764f, -0.37660000f, 
    0.12499342f, -0.31096298f, -0.03766251f, -0.06126721f, 0.03514778f, -0.07948759f, 0.16877554f, -0.02157895f, 
    -0.21101621f, 0.31663793f, -0.07752227f, 0.02421625f, 0.02222803f, 0.01747473f, -0.18974188f, -0.09603523f, 
    -0.22903234f, -0.01128386f, 0.30218184f, 0.02829611f, 0.12956737f, 0.07808764f, 0.05084626f, 0.13016143f, 
    0.18180507f, 0.01369213f, -0.23040958f, -0.09783506f, -0.19001451f, 0.07915898f, -0.07695474f, -0.04520756f, 
    0.02044478f, -0.18782419f, -0.10140312f, -0.35541114f, 0.22875409f, -0.06765895f, 0.19448157f, 0.00710338f, 
    0.12110726f, 0.10224707f, -0.09812780f, -0.28261667f, -0.21494859f, 0.42902201f, 0.07129774f, -0.12215789f, 
    -0.00150873f, -0.04462514f, -0.34850210f, 0.31827033f, 0.14730905f, -0.10507195f, 0.00414939f, -0.03197832f, 
    -0.10510220f, 0.00037671f, -0.03682071f, -0.46198568f, -0.18929932f, 0.05870242f, 0.13458303f, 0.04356242f, 
    0.04461130f, 0.01051257f, -0.01938545f, -0.00993398f, -0.20958868f, 0.46324223f, -0.09207473f, -0.01942547f, 
    -0.00503953f, -0.14218217f, 0.07199901f, -0.03244815f, -0.03667650f, -0.18375112f, 0.14250703f, -0.11110859f, 
    0.26309988f, -0.04593594f, 0.02759069f, -0.06044237f, 0.07924301f, 0.20885183f, -0.37602150f, 0.11836755f, 
    0.17220165f, -0.11654168f, -0.11951361f, -0.11008955f, 0.35071871f, 0.03861224f, -0.08004859f, -0.25852206f, 
    -0.03137286f, 0.18939668f, 0.02470382f, -0.10636180f, 0.06742239f, -0.03104175f, 0.00133639f, 0.00477931f, 
    0.34160021f, 0.38228273f, -0.38687578f, -0.19276413f, 0.01508257f, 0.07072184f, -0.07843532f, 0.08026404f, 
    -0.04223261f, 0.49038181f, 0.07998133f, -0.36353579f, 0.14524795f, 0.07248980f, -0.19120061f, -0.02362502f, 
    0.07540448f, -0.01918674f, -0.06363570f, 0.10923532f, 0.29766801f, -0.03772666f, -0.01434015f, -0.05960360f, 
    0.19158383f, 0.06706969f, 0.08654818f, 0.04210413f, 0.02785290f, 0.02291459f, -0.05967123f, 0.15267162f, 
    0.18113062f, 0.21755981f, -0.09439814f, -0.19301087f, -0.17951477f, 0.19969116f, -0.11602008f, -0.18527599f, 
    0.07958527f, 0.09705768f, 0.08119601f, 0.18936262f, -0.16039476f, -0.18295434f, -0.46942970f, 0.11283412f, 
    0.22211906f, -0.00407432f, -0.13295114f, 0.05168690f, 0.16230071f, -0.09071723f, -0.06266215f, -0.44938850f, 
    0.01417404f, 0.26135668f, -0.02518576f, -0.03855594f, 0.04387796f, -0.11202239f, -0.18327492f, 0.08912447f, 
    -0.00227079f, 0.26974836f, 0.01394944f, 0.03690224f, -0.06941000f, -0.05480129f, 0.18100241f, 0.12061024f, 
    0.23215185f, 0.09006237f, 0.09012510f, -0.19851400f, -0.14289530f, -0.05705665f, -0.07649948f, 0.14702077f, 
    0.06008435f, -0.17588831f, 0.17722771f, -0.17415346f, 0.16000868f, -0.21032873f, -0.03993111f, 0.18517461f, 
    -0.17065240f, -0.06935231f, -0.12037980f, 0.17783724f, -0.16900577f, 0.24372169f, 0.04266591f, 0.03799261f, 
    -0.07056804f, 0.01098240f, 0.12992865f, -0.59636801f, 0.35947853f, -0.51128334f, -0.22438395f, -0.03685875f, 
    0.11327261f, -0.11313309f, -0.17208087f, 0.04001072f, 0.19468954f, -0.18912253f, 0.15136641f, -0.06150291f, 
    -0.04538284f, 0.17555253f, 0.23160158f, 0.18387803f, 0.27759686f, 0.23289500f, 0.81443352f, -0.01257587f, 
    0.02892587f, -0.19764562f, 0.24506128f, 0.13318501f, 0.16671418f, -0.05997915f, -0.17416689f, 0.05165152f, 
    -1.07533824f, 0.02659669f, 0.32353607f, -0.01793251f, -0.17129524f, 0.13177744f, -0.50887978f, -0.16923931f, 
    -0.14097701f, 0.14700213f, 0.21023591f, 0.19540150f, -0.36202076f, 0.10799647f, -0.12078927f, 0.39783531f, 
    -0.16618620f, 0.05082012f, 0.22336067f, -0.08462038f, -0.12357888f, 0.07867289f, 0.17334713f, 0.02532022f, 
    0.08495944f, -0.14859511f, -0.02912026f, 0.02275436f, 0.31639874f, 0.08379218f, 0.11824182f, 0.18650179f, 
    0.11384448f, 0.20367101f, -0.01995887f, 0.16405880f, 0.11412652f, -0.17996438f, 0.09452188f, 0.08673888f, 
    -0.02172625f, -0.13658410f, -0.16130941f, 0.15823209f, -0.00144240f, 0.24756782f, 0.23086099f, -0.12195707f, 
    -0.35613605f, 0.09031500f, 0.19898640f, 0.09789544f, 0.03055086f, -0.00216407f, 0.30439338f, -0.12438983f, 
    -0.08554555f, 0.02025623f, 0.02452818f, -0.03411753f, 0.04988373f, 0.08215644f, -0.01477135f, 0.00320634f, 
    -0.07751060f, 0.06449383f, -0.05815444f, 0.14828765f, 0.14355506f, -0.21834986f, 0.07056031f, -0.43599141f, 
    -0.01888052f, -0.21102123f, -0.24690504f, -0.08627976f, 0.06949289f, -0.11307410f, -0.21261871f, 0.44325420f, 
    0.00758928f, -0.14318934f, -0.08914713f, -0.24389207f, 0.13309243f, 0.05657681f, 0.06194286f, 0.00475422f, 
    -0.22035509f, -0.11855508f, -0.17765360f, 0.02722225f, -0.14670746f, -0.06475662f, -0.11983076f, -0.06356718f, 
    0.18197303f, -0.23121956f, -0.26680341f, -0.02466292f, -0.18531814f, -0.16026790f, 0.14837655f, 0.02102110f, 
    0.02794438f, 0.06322040f, -0.25350562f, 0.42161280f, 0.71627796f, -0.16822638f, -0.30395719f, -0.12215585f, 
    -0.07837670f, -0.01566122f, 0.10641302f, -0.02568400f, -0.00850878f, -0.39329520f, 0.11010797f, 0.01682851f, 
    -0.08381111f, 0.16032289f, 0.05573365f, -0.03485297f, -0.28024846f, -0.11889143f, -0.15890656f, -0.39028642f, 
    0.00726660f, -0.07155408f, 0.14917882f, 0.06123325f, -0.02767221f, 0.20211019f, -0.04708119f, -0.12025068f, 
    -0.05588840f, -0.08274860f, 0.17809024f, 0.24547569f, 0.29909530f, 0.16796637f, 0.05184507f, 0.24022585f, 
    0.23365682f, -0.30401090f, -0.07994267f, -0.26884493f, 0.03533172f, -0.23031506f, -0.02724104f, -0.06702704f, 
    -0.10780251f, -0.17962241f, -0.20933245f, -0.13366361f, -0.02642132f, 0.11082426f, -0.11374070f, -0.10559981f, 
    0.01806174f, 0.02173940f, -0.00007204f, 0.00184575f, -0.05087775f, -0.05391428f, 0.01415415f, -0.06469420f, 
    0.00432096f, 0.00044898f, 0.03993290f, 0.04843281f, 0.00358447f, 0.00023263f, -0.04699827f, -0.03427158f, 
    -0.06602868f, -0.02986734f, 0.05305737f, 0.00845570f, -0.02570123f, 0.02005805f, 0.02634056f, 0.05488433f, 
    -0.04627549f, -0.02581098f, 0.02388584f, -0.05249889f, 0.03845249f, -0.04438673f, -0.02214754f, 0.00037071f, 
    0.04859045f, -0.04828230f, 0.01121900f, 0.04565431f, -0.03428860f, 0.03605955f, -0.01914085f, 0.03260577f, 
    -0.01553495f, 0.04882751f, 0.03157917f, 0.00093312f, -0.05637801f, -0.05848019f, 0.04428978f, 0.03851509f, 
    0.05055357f, 0.04141947f, -0.06400319f, -0.00219746f, 0.01194469f, 0.04399361f, -0.03193432f, -0.06180489f, 
    -0.00468077f, 0.04041499f, -0.03085771f, -0.01803589f, 0.04504259f, 0.01046617f, -0.06270293f, -0.06189261f, 
    0.02320699f, 0.02058601f, -0.00577454f, 0.05015736f, -0.03412403f, -0.05798467f, 0.04119954f, -0.00285466f, 
    0.05726617f, 0.05125408f, 0.00017569f, 0.02743443f, -0.02272057f, -0.04901728f, -0.00919548f, 0.03740069f, 
    -0.02479212f, 0.03780520f, -0.01424478f, -0.03393148f, -0.01940175f, -0.02888785f, 0.02522571f, -0.05308519f, 
    -0.01072429f, -0.06098809f, 0.02973016f, -0.03422251f, -0.04656920f, 0.01381852f, 0.01480152f, -0.01833741f, 
    -0.05023736f, -0.01418995f, -0.03088809f, 0.03177528f, 0.01662218f, 0.01913740f, 0.03276598f, 0.03055656f, 
    -0.04930703f, -0.01907597f, 0.02603691f, 0.01971082f, 0.02462267f, -0.04283782f, 0.02927928f, -0.05862439f, 
    0.00018034f, -0.03234665f, -0.02491178f, -0.04932360f, -0.02851500f, 0.04824053f, -0.01162555f, 0.02181659f, 
    -0.06416911f, -0.01448204f, -0.02998995f, -0.04531674f, 0.00362879f, -0.00011822f, -0.03689053f, -0.02278046f, 
    -0.01856829f, -0.02718911f, -0.03668607f, 0.03277031f, 0.02892465f, -0.04707913f, 0.01075502f, -0.05345504f, 
    -0.00999640f, -0.06606427f, -0.06072010f, 0.01142930f, 0.01206284f, 0.04949537f, -0.00410862f, -0.00796518f, 
    -0.06392701f, -0.05682158f, 0.02897289f, -0.00754995f, -0.05377696f, 0.01880633f, 0.03246633f, -0.01957191f, 
    0.01492163f, -0.04370791f, -0.06619366f, -0.06385830f, 0.04292566f, -0.01674822f, -0.03488724f, 0.02925790f, 
    -0.06708954f, 0.00103758f, -0.00374513f, 0.01943569f, -0.04716295f, 0.02845291f, -0.05069141f, 0.04490107f, 
    -0.03742396f, 0.01092207f, 0.02103096f, -0.06373996f, -0.03727649f, -0.02957996f, 0.02372121f, -0.01167275f, 
    0.00621345f, 0.00849661f, 0.01413187f, 0.03287369f, 0.03840965f, 0.01577537f, -0.05024841f, -0.00588984f, 
    -0.02853674f, -0.03647446f, -0.04879034f, -0.02144462f, -0.01244480f, -0.03302670f, -0.05642935f, 0.02517330f, 
    -0.02234350f, -0.04554235f, -0.03931282f, 0.01706585f, -0.05395231f, -0.02793641f, -0.02249820f, 0.03458190f, 
    -0.00709623f, -0.02334440f, 0.05078952f, -0.02054645f, -0.01135909f, -0.02007043f, -0.06708526f, -0.05335542f, 
    -0.04832501f, 0.02220062f, 0.03230852f, -0.00644642f, -0.01589647f, 0.03341831f, -0.05995711f, -0.04205106f, 
    0.01569204f, -0.03796034f, -0.01740559f, -0.05878488f, 0.04939253f, 0.01841742f, 0.00015868f, -0.02822190f, 
    -0.03131368f, -0.05335632f, 0.01445276f, 0.04987257f, -0.06576983f, 0.03361227f, -0.00925371f, -0.04766304f, 
    0.03288445f, 0.01808234f, 0.03623460f, -0.01426816f, -0.03043517f, -0.06603851f, 0.01430925f, -0.01056431f, 
    0.03270067f, 0.05306144f, -0.06255658f, -0.01221839f, 0.03909807f, -0.01598795f, 0.01924698f, 0.04376400f, 
    -0.02308010f, -0.00792488f, -0.04341417f, 0.01125897f, 0.00241797f, -0.02920947f, -0.02162723f, -0.05029120f, 
    0.03880517f, 0.01447961f, 0.02632092f, -0.04583065f, -0.04531444f, 0.02825110f, -0.03570567f, -0.06237312f, 
    -0.00446047f, -0.05657857f, -0.03567879f, -0.01401002f, 0.05542202f, 0.04561032f, -0.03995946f, 0.02288042f, 
    -0.06054011f, 0.03241082f, 0.02255552f, 0.03743725f, -0.01911093f, 0.01856804f, -0.04735808f, 0.01026739f, 
    -0.03672836f, 0.02059835f, -0.03460899f, -0.00430019f, -0.05844360f, 0.01243156f, -0.04804192f, -0.00332984f, 
    0.28813809f, 0.30861202f, 0.44627678f, -0.11219031f, 0.23148069f, -0.14641868f, 0.13811675f, -0.01845436f, 
    0.13988633f, 0.05552484f, 0.42504689f, 0.21592119f, 0.03996298f, 0.12389658f, 0.00866301f, 0.08546803f, 
    0.17241357f, -0.08267134f, -0.12860873f, 0.13931929f, -0.02398007f, 0.03605271f, -0.11495470f, -0.05345593f, 
    0.01494974f, 0.13169406f, 0.24771747f, -0.26578090f, 0.03996815f, 0.04186069f, -0.09785015f, 0.07908184f, 
    0.05183707f, -0.19192453f, -0.33733204f, -0.04007386f, -0.28650254f, -0.21104193f, -0.09953281f, 0.07683147f, 
    0.30702832f, -0.08366542f, -0.34849140f, -0.14373074f, 0.06717464f, 0.15298000f, 0.05870346f, -0.01366674f, 
    0.04846034f, -0.02274765f, 0.16065085f, -0.06649492f, -0.30818617f, -0.29600933f, -0.39134789f, -0.28915706f, 
    0.06101359f, -0.17830583f, -0.08987958f, -0.22207695f, 0.03512296f, -0.00040009f, -0.22867465f, -0.21105608f, 
    0.07805382f, 0.31102142f, -0.23155345f, -0.27055374f, -0.21404473f, -0.03162834f, -0.09604859f, -0.27773988f, 
    -0.07613523f, 0.21304357f, -0.07043143f, 0.18745190f, 0.10824469f, 0.04659355f, 0.01949132f, 0.01061483f, 
    0.15589276f, 0.27851090f, 0.20005833f, 0.54633218f, -0.19932708f, 0.03830399f, -0.05906729f, -0.00159867f, 
    0.18194641f, -0.33936557f, -0.30008546f, 0.25715050f, 0.05537410f, 0.06033047f, -0.00918596f, -0.09934594f, 
    0.07304688f, 0.16127573f, 0.03466034f, -0.07529333f, -0.06333582f, -0.39341700f, 0.18306719f, 0.34317482f, 
    -0.01952777f, -0.10406268f, 0.15320346f, 0.04661723f, -0.13756813f, -0.05461392f, 0.00020790f, -0.03118108f, 
    -0.02274761f, -0.06425194f, 0.21997295f, 0.12481391f, 0.01932516f, -0.06904078f, -0.27120602f, 0.02175418f, 
    0.01081571f, -0.00082561f, 0.03779558f, 0.04693796f, -0.13975565f, 0.08386534f, -0.24445033f, 0.19409475f, 
    0.58767772f, -0.15514436f, 0.67651141f, 0.26790833f, -0.08594590f, 0.43385851f, 0.13256295f, -0.23447643f, 
    0.35869235f, -0.42432809f, -0.02694331f, -0.37361801f, -0.32151970f, -0.21159777f, -0.14245096f, 0.07660351f, 
    -0.15273079f, 0.12028161f, -0.02924156f, -0.11243556f, -0.08067211f, -0.08023676f, 0.21429572f, 0.09336383f, 
    0.04209684f, -0.29956791f, 0.03415557f, -0.00667186f, -0.02417388f, -0.04315333f, 0.14788638f, -0.12204298f, 
    0.06089539f, -0.02967361f, -0.19879991f, 0.03160540f, 0.28748292f, -0.16400291f, -0.01930292f, -0.16467671f, 
    -0.01293295f, -0.27599511f, -0.21904401f, 0.18501180f, 0.30338153f, -0.43709430f, 0.01874013f, -0.12550986f, 
    0.06745752f, 0.29288337f, -0.04970716f, -0.11988931f, -0.16132484f, 0.12565592f, 0.07108719f, 0.13190827f, 
    0.03479569f, -0.11102302f, 0.09015541f, -0.14950584f, 0.05836224f, -0.27023563f, 0.24080741f, 0.43605497f, 
    -0.25256938f, 0.11685863f, -0.07922203f, -0.28601289f, 0.00793312f, 0.30016643f, 0.09879195f, 0.08474501f, 
    -0.15637469f, 0.16536269f, -0.11540680f, -0.03272946f, -0.03679745f, 0.05603752f, 0.21756923f, -0.04466674f, 
    0.54274535f, 0.29616964f, -0.03317836f, -0.13550913f, 0.03061081f, -0.01164778f, -0.06672423f, 0.15370889f, 
    -0.28660432f, 0.04022272f, 0.19614029f, 0.11959641f, 0.08891426f, 0.07864358f, 0.36027101f, -0.20385365f, 
    -0.00180271f, -0.31323642f, 0.03186916f, 0.15805042f, 0.15437406f, 0.14122416f, -0.10473777f, -0.06192514f, 
    0.10205439f, -0.24328886f, 0.48724172f, 0.17271380f, 0.03623799f, 0.06024703f, -0.18205130f, -0.08240451f, 
    0.15705815f, -0.00264955f, 0.09441174f, -0.23386434f, -0.19037275f, -0.10716888f, 0.03776575f, 0.16343439f, 
    -0.01111432f, 0.09290162f, -0.09898309f, -0.03940578f, 0.14060135f, 0.66790390f, 0.23407406f, -0.04340746f, 
    -0.08406010f, 0.06963526f, 0.14264119f, -0.01746409f, 0.15110864f, 0.00740285f, 0.25192401f, 0.34878835f, 
    0.24369301f, 0.16676453f, -0.17460549f, -0.03935667f, 0.16373396f, 0.20649549f, 0.41005194f, -0.69946051f, 
    0.02007721f, -0.02501678f, -0.00593910f, -0.35788465f, 0.08303574f, -0.18766144f, -0.03027530f, 0.26940054f, 
    0.16607600f, -0.03324901f, 0.05191269f, -0.12299353f, -0.17672464f, 0.17954063f, 0.25471842f, 0.01650604f, 
    -0.32094908f, -0.37922576f, 0.18373244f, 0.06968717f, 0.08303958f, 0.07529624f, -0.05205685f, -0.08636691f, 
    -0.04846711f, -0.19317998f, 0.50557292f, 0.26337025f, -0.02368346f, -0.12707879f, -0.06567706f, 0.08027615f, 
    0.22145449f, -0.12707390f, 0.23742846f, 0.01310974f, -0.02672696f, -0.16557176f, -0.52197033f, -0.32626760f, 
    -0.01971647f, 0.04459672f, -0.02580534f, 0.19281641f, 0.18643229f, 0.11892115f, 0.00746812f, 0.08814820f, 
    -0.26797640f, 0.23182330f, -0.07604299f, -0.09823085f, -0.01136973f, 0.09383058f, -0.17278895f, 0.30158028f, 
    -0.24020815f, -0.19578245f, 0.35777169f, 0.12831895f, 0.05077990f, 0.35067767f, 0.13827348f, -0.00968443f, 
    0.14317857f, 0.06504612f, -0.10969467f, -0.05477199f, -0.15554716f, 0.12497923f, 0.14481537f, 0.21675965f, 
    -0.05655015f, 0.10064449f, -0.07835370f, 0.06573412f, 0.10177020f, 0.15659527f, -0.27015689f, 0.38300335f, 
    0.42506069f, 0.04392084f, 0.10929606f, 0.09922275f, 0.06026870f, 0.05120033f, 0.05474787f, -0.00789052f, 
    0.29089072f, -0.03800037f, -0.24260706f, -0.18513206f, -0.47801343f, -0.36163476f, -0.02822031f, 0.02835761f, 
    0.06278814f, -0.78667760f, -0.23369226f, 0.49117488f, -0.15435590f, 0.06174566f, -0.00790511f, 0.01383369f, 
    -0.05459234f, 0.09915818f, -0.16754942f, 0.12118831f, 0.16306724f, 0.05015291f, -0.04358472f, 0.01909743f, 
    0.08403109f, -0.08654893f, 0.01495373f, -0.05265700f, 0.47986442f, -0.45624509f, -0.24376084f, 0.19364190f, 
    0.07376239f, 0.31923029f, -0.04268714f, -0.17346135f, 0.01509742f, 0.13131511f, -0.20159513f, 0.11005432f, 
    -0.12399155f, 0.27625808f, 0.05729800f, 0.16122319f, 0.07893912f, -0.95494694f, -0.74112487f, 0.03179937f, 
    0.01152350f, 0.10206393f, -0.03188889f, 0.09949236f, 0.11176749f, 0.01686920f, 0.06932903f, 0.53559160f, 
    -0.54777724f, 0.18141606f, 0.38014922f, -0.00615448f, -0.16355237f, 0.27776575f, -0.07953884f, 0.02131587f, 
    -0.26367626f, 0.12454194f, -0.12561977f, -0.01402828f, -0.32949713f, 0.13048123f, -0.06300040f, -0.04971546f, 
    0.14068119f, 0.03061061f, 0.16706294f, -0.08268404f, -0.12584373f, 0.02007570f, -0.03276511f, -0.13204719f, 
    0.07514638f, -0.08709636f, 0.29545587f, -0.06355432f, 0.07492048f, -0.00655483f, -0.06986146f, 0.05253421f, 
    0.10112215f, 0.02041898f, 0.15242466f, 0.15620427f, 0.13877635f, -0.02367765f, -0.24261846f, -0.38522103f, 
    -0.03151827f, -0.09741812f, -0.02592756f, 0.25798529f, -0.39188647f, -0.41147998f, -0.40316480f, 0.01585665f, 
    0.00807253f, 0.22361089f, -0.00903387f, 0.09556833f, 0.23529667f, 0.23573805f, 0.25228447f, 0.00238975f, 
    -0.12181142f, -0.29400703f, -0.10680376f, -0.08722080f, -0.02099895f, 0.20258412f, 0.41873056f, 0.17135292f, 
    0.17386092f, 0.06366034f, -0.13137117f, 0.17222019f, 0.18463221f, -0.10171005f, -0.58621401f, 0.33847815f, 
    -0.43072814f, -0.07561573f, 0.09057063f, 0.09664530f, -0.26583296f, 0.22280215f, 0.10441457f, -0.82972461f, 
    -0.57565957f, 0.22314733f, -0.01146832f, -0.09879126f, 0.01518233f, 0.03199485f, -0.12608786f, -0.13281237f, 
    0.06043775f, 0.14804874f, 0.11672130f, -0.07845446f, 0.01970032f, -0.00038273f, 0.15103661f, 0.16969705f, 
    -0.13248527f, 0.16632523f, 0.32007340f, 0.00696010f, -0.07830781f, 0.02522998f, -0.02564370f, 0.26085231f, 
    0.06525393f, 0.07043497f, -0.19446728f, -0.01251508f, -0.82067871f, -0.20267290f, -0.06286922f, 0.05121936f, 
    0.02753389f, -0.15198584f, -0.16361779f, -0.24789940f, 0.09310079f, 0.14978656f, 0.06532178f, -0.03032791f, 
    -0.03217849f, -0.06499524f, -0.04778456f, 0.20114432f, -0.08401278f, 1.22418904f, -0.61027706f, 0.05083525f, 
    -0.14531037f, 0.02839435f, -0.08759382f, -0.00641697f, -0.08621810f, 0.13417958f, 0.49383602f, -0.11665267f, 
    -0.12214627f, -0.20847538f, 0.18356314f, -0.01666814f, 0.00070802f, 0.27442116f, -0.08840119f, -0.34884056f, 
    -0.49880561f, -0.09427255f, -0.18849558f, 0.13219565f, 0.18044420f, 0.01662507f, -0.17949398f, -0.52285534f, 
    -0.13846548f, -1.29320240f, -0.14102894f, -0.26851544f, 0.20845993f, 0.20188393f, 0.01631968f, -0.10386639f, 
    0.27634355f, -0.03655829f, 0.16750309f, 0.22727007f, -0.21535620f, -0.00543426f, 0.09609485f, -0.09017113f, 
    -0.05295299f, 0.05042277f, -0.11137725f, 0.60787416f, -0.07446086f, -0.06990536f, -0.06252073f, 0.18709014f, 
    0.01486562f, -0.02224345f, 0.03852604f, -0.00555157f, -0.05056281f, 0.07674660f, 0.09623191f, 0.13922478f, 
    0.06501205f, 0.38746679f, 0.10097807f, 0.05605526f, -0.04242688f, -0.26420617f, -0.07531152f, 0.11427071f, 
    -0.03640378f, -0.02035478f, -0.04052540f, -0.05384494f, -0.23095076f, 0.20001772f, -0.02059717f, -0.00014370f, 
    -0.01758829f, 0.01786211f, -0.10822774f, 0.24548824f, 0.15139177f, 0.11733452f, -0.05083978f, 0.35271966f, 
    0.10319245f, 0.10895824f, 0.08047806f, -0.04026492f, -0.03841985f, -0.00741504f, -0.06762295f, -0.00530360f, 
    0.38549131f, -0.17770787f, 0.07703576f, -0.03439229f, -0.16884068f, -0.05659933f, 0.03067741f, -0.11216605f, 
    0.07194348f, -0.29823446f, -0.12198891f, 0.23415047f, -0.31365779f, 0.30254096f, 0.05429855f, 0.11365126f, 
    -0.03188850f, -0.02674859f, -0.12582935f, -0.31793189f, -0.13944380f, -0.07705173f, 0.13235794f, 0.16309626f, 
    0.07826234f, 0.16426767f, -0.00673589f, -0.19729821f, 0.00605181f, 0.02437048f, -0.06944760f, 0.05706537f, 
    -0.29576117f, 0.16501164f, 0.05429377f, 0.35508412f, -0.07819057f, -0.02736063f, -0.15814912f, -0.15636489f, 
    0.03954789f, -0.03943774f, -0.03769558f, 0.44528234f, 0.19287939f, 0.25410733f, 0.11476377f, 0.05860798f, 
    -0.24167220f, 0.07321490f, 0.10072590f, 0.02763409f, -0.16665097f, 0.02510695f, 0.31871411f, -0.11613286f, 
    0.15177211f, -0.07958694f, -0.02834284f, -0.03971142f, 0.09601709f, -0.04214616f, -0.08039041f, 0.33523467f, 
    -0.02754276f, -0.09659389f, -0.00456411f, 0.00630826f, 0.14823923f, -0.19006231f, -0.39178005f, 0.39852566f, 
    -0.20367137f, 0.20049670f, 0.27933297f, -0.31018764f, -0.03199093f, -0.00190169f, -0.00776142f, 0.11366675f, 
    -0.29766902f, -0.34898669f, 0.10578085f, -0.07613655f, -0.12986197f, 0.16678901f, 0.22612949f, -0.15527378f, 
    0.02132452f, 0.04273634f, 0.09474318f, -0.12542702f, -0.08120213f, -0.05955705f, 0.16561566f, 0.21331398f, 
    0.14228196f, -0.00977365f, 0.09017266f, -0.04755641f, -0.03722046f, 0.01172687f, -0.02427422f, 0.18547192f, 
    -0.10371397f, 0.02645552f, -0.12071311f, -0.02865604f, 0.01991351f, -0.11797535f, 0.04153008f, -0.03748133f, 
    -0.03842338f, 0.06108869f, 0.10888059f, 0.09471397f, -0.26060009f, 0.01992480f, -0.23869102f, 0.06062939f, 
    -0.11752727f, 0.00367109f, -0.00627047f, 0.09104613f, -0.06599930f, 0.03185488f, 0.09539124f, -0.23237723f, 
    0.12847413f, -0.22095710f, -0.04490692f, 0.20250507f, 0.08182828f, -0.12816769f, 0.16573441f, -0.05643269f, 
    -0.22656202f, -0.08238839f, -0.22247854f, -0.26922959f, 0.25800550f, 0.03584571f, -0.08157861f, 0.27741116f, 
    0.48983037f, -0.25993836f, -0.15273669f, 0.00646565f, 0.05782026f, 0.19310308f, -0.27808693f, 0.09993114f, 
    0.05702077f, 0.64446324f, 0.05489903f, 0.03374965f, -0.04201150f, 0.17323606f, -0.17776863f, 0.13753566f, 
    -0.01150267f, -0.08330962f, 0.07352524f, -0.06648431f, 0.03038333f, -0.06426402f, -0.01934950f, 0.07483517f, 
    0.00661184f, 0.03855234f, -0.02481157f, 0.08976328f, -0.19957229f, 0.18129592f, -0.11369643f, 0.09261616f, 
    -0.02404743f, -0.03845398f, -0.02715222f, -0.20456620f, 0.55755609f, 0.12924565f, 0.04393508f, -0.19506918f, 
    -0.02242610f, -0.02107897f, 0.12946557f, 0.02677760f, 0.03947778f, 0.71612024f, 0.07172886f, -0.11431836f, 
    0.02313119f, 0.06849048f, 0.24964957f, -0.12231553f, -0.09350967f, 0.18961856f, 0.48546568f, 0.25072065f, 
    -0.15658405f, -0.23917852f, 0.09518185f, -0.12320042f, 0.05258765f, -0.07598510f, 0.08999696f, 0.20994872f, 
    -0.07395594f, 0.17551020f, -0.16534829f, 0.04733202f, 0.25126761f, 0.04663057f, -0.66173953f, -0.04203092f, 
    -0.19074376f, 0.13145214f, -0.19215681f, 0.02550380f, 0.03024571f, -0.26935539f, 0.10844222f, -0.34853470f, 
    0.06132805f, 0.19574097f, 0.10531384f, -0.13292740f, -0.06727362f, -0.06796264f, 0.07687835f, 0.25448295f, 
    -0.03456292f, -0.00679748f, -0.03881206f, -0.01749099f, -0.02902522f, 0.00551242f, -0.04036006f, 0.04443428f, 
    0.05013203f, -0.00129816f, 0.01142451f, 0.05132142f, -0.05982187f, -0.02673504f, 0.00455739f, -0.03258883f, 
    -0.01849535f, -0.00991539f, 0.03546686f, -0.05519053f, -0.03454576f, 0.02456605f, -0.05125266f, 0.01624584f, 
    -0.02990309f, 0.03962195f, -0.01438794f, -0.02951150f, 0.01022304f, -0.06494623f, -0.05170323f, 0.04331761f, 
    0.01251633f, -0.01209792f, -0.05774229f, -0.05001341f, 0.03965202f, -0.01261027f, -0.02806930f, -0.06181936f, 
    -0.04761109f, -0.06034182f, 0.01074736f, 0.03263848f, -0.05427272f, -0.04457923f, 0.00995686f, 0.02693863f, 
    -0.02182595f, -0.00177501f, 0.00266856f, -0.04521977f, -0.04010882f, -0.01225208f, -0.01131390f, 0.02992796f, 
    0.05136867f, -0.00077374f, -0.03861235f, -0.05575702f, -0.00567938f, -0.01450733f, 0.01421845f, 0.04850675f, 
    -0.02904449f, 0.00660628f, 0.04028451f, -0.01012140f, -0.03184783f, -0.05900732f, -0.03278322f, -0.01665453f, 
    0.04718936f, -0.02434433f, -0.03429242f, -0.00397375f, 0.00740040f, -0.00695484f, 0.01046354f, 0.02760133f, 
    -0.01647765f, 0.00819054f, -0.05749252f, 0.04350199f, 0.00463261f, -0.01818524f, -0.03909636f, 0.01901195f, 
    -0.02084563f, -0.06141935f, 0.00838175f, -0.02324442f, -0.03134289f, 0.04419380f, 0.03532220f, -0.00576763f, 
    -0.00136346f, -0.03108872f, 0.01741815f, 0.02354003f, 0.01726799f, 0.02787406f, -0.02362159f, -0.03316471f, 
    -0.00091143f, -0.00303664f, 0.04532531f, 0.01881761f, 0.04600542f, -0.01337180f, -0.03065021f, -0.04331868f, 
    0.02379942f, -0.04883263f, -0.03278265f, 0.02349549f, -0.00497024f, -0.01554414f, 0.02147940f, -0.03289146f, 
    0.03269055f, -0.01679968f, 0.03445572f, -0.02640215f, -0.00294074f, -0.06501976f, -0.06337771f, -0.01063034f, 
    -0.04624736f, -0.04433294f, 0.02254461f, -0.03936223f, -0.04887529f, -0.04045336f, -0.02442872f, -0.05427326f, 
    0.02150810f, -0.05587457f, -0.05804729f, -0.03060485f, -0.00290108f, -0.01893654f, -0.01451989f, -0.00922947f, 
    0.00712936f, 0.03418894f, 0.03299101f, -0.06633221f, -0.05696942f, 0.04203998f, 0.04966663f, -0.04873106f, 
    0.02576927f, -0.01032666f, 0.02422458f, 0.05023654f, -0.04419441f, 0.01329780f, -0.02294566f, 0.02157472f, 
    0.04620873f, -0.02733928f, 0.01026829f, -0.04046603f, -0.02655035f, 0.02203332f, 0.03133013f, -0.01883915f, 
    -0.02700789f, 0.03980086f, -0.04879557f, 0.02251361f, -0.02695718f, -0.01861515f, -0.05279138f, -0.05784169f, 
    0.02235680f, 0.02768411f, -0.04981172f, -0.00279556f, -0.05483777f, -0.05090604f, 0.03191069f, 0.02119072f, 
    -0.01365665f, -0.03269016f, -0.02020259f, -0.00714941f, -0.03315675f, -0.05838829f, 0.00936990f, -0.05354019f, 
    0.01762735f, 0.00037550f, -0.00503109f, 0.02419323f, 0.04388901f, -0.00283538f, 0.03168710f, -0.05980102f, 
    0.03226701f, 0.04657193f, 0.03651099f, 0.05070657f, 0.04900952f, 0.02839769f, -0.04351709f, -0.00075046f, 
    -0.03220979f, -0.02950835f, -0.00744400f, -0.01685757f, -0.01171895f, -0.05967729f, 0.01992216f, -0.03068180f, 
    -0.05120298f, 0.04967970f, 0.00635048f, -0.01964710f, -0.00768704f, -0.04197727f, -0.04077624f, 0.05148256f, 
    0.00076986f, 0.02801771f, -0.04806266f, 0.00828173f, 0.00175247f, -0.03601988f, -0.03925645f, -0.02827278f, 
    -0.03154514f, -0.03377587f, -0.05473574f, 0.02257786f, 0.01062689f, -0.05468400f, 0.02269449f, -0.04649976f, 
    0.01601862f, -0.03967116f, -0.00997032f, 0.01219139f, 0.02328558f, 0.03294208f, -0.03275776f, -0.02700854f, 
    -0.03900950f, -0.00835103f, 0.05202568f, 0.02586369f, 0.02504337f, 0.00189935f, -0.00654349f, -0.02417896f, 
    -0.06335124f, 0.01751366f, -0.00095154f, -0.02459057f, 0.02437967f, -0.02191228f, -0.04797958f, 0.00730101f, 
    0.03396907f, -0.03556557f, 0.00618955f, -0.02735516f, 0.05009178f, -0.06140400f, -0.01278919f, -0.01707153f, 
    0.02205128f, 0.02868691f, -0.01746756f, 0.03830494f, -0.02044320f, -0.00898420f, 0.03496427f, -0.03769166f, 
    -0.05207822f, -0.03265648f, -0.05444705f, -0.05373676f, 0.04423910f, 0.04599891f, 0.00157156f, 0.02090519f, 
    -0.11762794f, 0.36302853f, 0.31656796f, -0.11613224f, -0.06818223f, -0.33806825f, 0.07083523f, 0.05951578f, 
    0.07940610f, -0.02005695f, 0.10552087f, -0.24375309f, 0.08489311f, 0.01917157f, -0.21209194f, -0.03006511f, 
    -0.04042703f, 0.01037458f, 0.08360589f, -0.02529960f, -0.31955299f, 0.09761924f, -0.08914281f, 0.01197782f, 
    -0.00413019f, 0.00633244f, -0.20521928f, -0.80387574f, -0.15416853f, 0.30523235f, -0.02434010f, 0.06020613f, 
    0.03663276f, -0.19116539f, -0.02530411f, -0.07545099f, 0.16484323f, -0.30441251f, -0.07038819f, 0.00169030f, 
    -0.09775972f, 0.13979182f, 0.30365023f, 0.02074523f, -0.23882598f, -0.07156566f, -0.13295755f, -0.53477085f, 
    -0.06425648f, -0.15078272f, -0.12543762f, 0.01040116f, -0.08673496f, -0.05686413f, -0.03816146f, 0.31900457f, 
    -0.40771180f, -0.01993191f, -0.10733661f, -0.06664621f, -0.05663871f, -0.04283837f, 0.09523194f, 0.34724346f, 
    -0.52116102f, -0.44758716f, -0.04805589f, -0.13295509f, -0.13582078f, -0.24629182f, -0.15175574f, -0.29966807f, 
    0.18015341f, -0.08670574f, -0.25761044f, 0.09495821f, -0.08148283f, 0.01092939f, -0.05478200f, -0.06791924f, 
    0.24353826f, -0.25218916f, -0.26377299f, 0.02813505f, -0.10109305f, -0.15526247f, -0.26153898f, -0.09160170f, 
    -0.04432486f, -0.17520209f, 0.18661289f, -0.02689206f, 0.01986731f, -0.10885963f, -0.10565379f, -0.12517436f, 
    0.08131676f, 0.10400321f, 0.23425138f, -0.51178479f, -0.25495103f, -0.16963218f, 0.23513712f, -0.16348790f, 
    -0.22660534f, -0.03149277f, 0.04279478f, 0.01362456f, 0.12273789f, -0.00557836f, -0.24808525f, 0.28704920f, 
    -0.03882307f, 0.13504086f, 0.00251296f, -0.04663890f, 0.01555475f, -0.10854752f, 0.16164702f, 0.26508057f, 
    0.04188915f, 0.04036205f, 0.20345551f, -0.03951988f, -0.07790697f, -0.11998640f, -0.00641847f, -0.16319759f, 
    -0.38844562f, 0.06269464f, -0.45960832f, -0.31281421f, -0.33978140f, 0.31156841f, 0.19205606f, -0.01715334f, 
    -0.29120865f, -0.11847623f, 0.03012224f, 0.18658322f, -0.07020416f, 0.00536175f, -0.13582850f, -0.12793134f, 
    0.01192665f, -0.13809389f, -0.42865396f, 0.11803598f, -0.01465109f, -0.01871240f, 0.14349447f, 0.03240600f, 
    0.02263463f, 0.02655424f, 0.01103198f, -0.14516544f, -0.15068993f, -0.00068340f, -0.13958243f, -0.00596279f, 
    0.17903733f, 0.01439392f, 0.06875856f, -0.31078377f, -0.11768971f, -0.04768935f, 0.06054252f, 0.08266911f, 
    0.12957425f, 0.03810088f, -0.22287917f, -0.65357196f, -0.51186305f, -0.15477413f, 0.09406182f, 0.17314452f, 
    0.05047483f, -0.09376383f, 0.27943808f, -0.02259223f, 0.05765411f, -0.07900244f, -0.25667915f, -0.02424827f, 
    0.04383624f, 0.09229735f, 0.00735786f, -0.12439041f, 0.21640670f, -0.44796816f, -0.75987697f, 0.01115777f, 
    0.00489663f, 0.14978909f, -0.25899467f, -0.12276917f, -0.36633247f, 0.03970867f, 0.52500933f, -0.34646100f, 
    0.62068343f, -0.09960385f, -0.09818206f, 0.52902174f, 0.19076730f, 0.09078389f, 0.11225240f, 0.16040863f, 
    0.27474141f, 0.05978186f, -0.33618560f, -0.09369981f, -0.04239834f, 0.00786740f, -0.06280319f, 0.05618470f, 
    -0.08277681f, 0.31323850f, 0.26394218f, 0.03425485f, -0.01420336f, 0.11009664f, -0.04213310f, 0.20696184f, 
    0.05034234f, 0.15781884f, 0.01016587f, 0.03145780f, -0.00035277f, -0.00026644f, 0.12274185f, -0.12378741f, 
    0.15066569f, 0.00401348f, 0.59533155f, 0.37813610f, 0.23423029f, -0.16204077f, 0.15305021f, 0.39485508f, 
    -0.03733246f, 0.03304174f, 0.00552041f, 0.00314869f, 0.17404847f, -0.09562900f, 0.22105706f, -0.00101298f, 
    -0.35972533f, 0.01204571f, -0.06928418f, 0.10725087f, 0.18552436f, 0.37332615f, 0.16557817f, -0.22127253f, 
    0.14699690f, 0.28606141f, -0.07493720f, -0.01454220f, 0.04136192f, 0.34967452f, -0.26788533f, 0.03316514f, 
    0.37106723f, -0.00746052f, -0.11532582f, -0.10949998f, 0.06020972f, -0.02097288f, 0.58361328f, 0.30788308f, 
    0.55347109f, -0.08947112f, 0.07859935f, 0.38813871f, 0.08618044f, 0.07419585f, -0.07865916f, 0.62685585f, 
    0.01786426f, 0.27646920f, 0.14011057f, 0.09261252f, 0.28521326f, 0.09959815f, -0.00672117f, 0.08804291f, 
    0.03951675f, 0.00766954f, -0.02437167f, 0.04201695f, 0.05312009f, -0.04881668f, -0.00126490f, -0.01084381f, 
    0.01134381f, 0.00362652f, -0.01010313f, 0.01052171f, -0.03455481f, -0.04210458f, -0.00734566f, -0.06410132f, 
    -0.02594604f, 0.02646181f, -0.00414711f, -0.05394246f, -0.02796218f, 0.03532779f, -0.01882276f, -0.05872636f, 
    0.04510570f, -0.05364578f, 0.04616331f, -0.01747802f, -0.03802333f, -0.02736706f, -0.01985208f, -0.02835652f, 
    -0.03591155f, -0.04219688f, -0.03984190f, -0.05975905f, -0.01507932f, 0.05244238f, -0.00166497f, -0.00770611f, 
    0.01034881f, -0.05214566f, 0.01225766f, 0.04632467f, -0.05495200f, -0.05679247f, -0.00544856f, 0.05300913f, 
    -0.06146931f, -0.04479402f, -0.06004228f, -0.05236994f, -0.00969931f, -0.03902841f, -0.05628431f, 0.04564669f, 
    -0.01403445f, -0.05196474f, -0.01331697f, -0.01705479f, 0.03955255f, 0.02069096f, -0.02458141f, -0.04024832f, 
    -0.04125972f, 0.02114779f, -0.00415471f, 0.04696149f, -0.00232785f, 0.02371177f, -0.00620935f, -0.02963716f, 
    0.05002631f, 0.02177863f, -0.05185031f, -0.06388918f, -0.02839660f, -0.05262364f, 0.00144324f, -0.04200399f, 
    0.05130175f, -0.02941898f, 0.05280369f, -0.04636966f, 0.04929622f, 0.04508621f, -0.06094627f, -0.04064074f, 
    -0.05587912f, 0.01131755f, -0.00048658f, 0.01719266f, 0.01576794f, -0.02403690f, -0.05133529f, 0.03035164f, 
    -0.04148812f, 0.00736288f, -0.04420136f, -0.05692649f, -0.05289431f, 0.01110925f, 0.04024503f, 0.01388064f, 
    0.00377990f, -0.03251511f, -0.04331338f, -0.05268027f, -0.00301310f, 0.04483330f, 0.02370194f, -0.00342687f, 
    -0.01475555f, -0.03526766f, -0.02046034f, 0.01053267f, 0.01090186f, -0.03826902f, 0.05227969f, 0.00236498f, 
    -0.03454341f, 0.03120576f, 0.00056713f, 0.00071749f, -0.02520874f, -0.04207660f, 0.01322269f, -0.01191338f, 
    -0.05099949f, 0.01575009f, 0.02461097f, -0.04629361f, 0.03945588f, -0.06044118f, 0.04220413f, -0.02091922f, 
    0.03495270f, -0.03979916f, 0.03372797f, -0.05865027f, -0.04752992f, -0.04094789f, 0.03772344f, 0.01625910f, 
    0.03368065f, 0.00959579f, -0.03150674f, -0.00223198f, 0.04638886f, -0.01287755f, 0.03086769f, -0.02847248f, 
    0.04662736f, 0.04074774f, -0.03973995f, -0.04101801f, 0.03525821f, -0.03647644f, 0.02203782f, 0.03077437f, 
    -0.04400878f, 0.01976709f, -0.04201744f, -0.05079187f, 0.03861303f, -0.06217957f, -0.01177955f, 0.00224712f, 
    -0.05743041f, 0.03938203f, -0.04223610f, -0.01162131f, -0.01868460f, 0.02814718f, 0.03640278f, -0.00763845f, 
    0.01620629f, 0.05293493f, 0.00881545f, 0.04993381f, 0.02686985f, -0.04710823f, -0.05066778f, 0.02920382f, 
    0.03469917f, 0.04544302f, -0.00567447f, 0.00256724f, 0.03565190f, -0.00038315f, 0.01068564f, -0.01086625f, 
    -0.00475065f, -0.01288772f, 0.04729981f, -0.04611834f, -0.04635619f, -0.00374254f, -0.06285488f, -0.04919210f, 
    0.01755764f, 0.03708669f, -0.02370991f, -0.01010452f, 0.04164610f, 0.00683709f, 0.02518390f, 0.00281302f, 
    0.01971996f, -0.05744573f, -0.05984437f, -0.04421823f, -0.05067363f, 0.03006173f, 0.00773611f, -0.01277187f, 
    -0.00476863f, -0.06331432f, 0.01387160f, -0.03422218f, 0.02254609f, -0.03065854f, -0.02873908f, 0.02905652f, 
    -0.03845220f, -0.06046703f, -0.04036303f, -0.04724777f, 0.02027776f, -0.05426916f, -0.02203944f, 0.00645428f, 
    -0.01687519f, -0.04743430f, -0.02208767f, 0.01560472f, -0.04854777f, -0.04796606f, 0.05005928f, -0.02770294f, 
    -0.05569039f, 0.03605358f, 0.01475095f, 0.01742023f, -0.02868083f, -0.04331757f, -0.04558516f, 0.01408515f, 
    -0.02096618f, -0.01539636f, -0.01457227f, -0.04521924f, 0.05185372f, 0.01159712f, -0.06175442f, -0.02452400f, 
    0.04911631f, -0.03073803f, -0.02008163f, 0.03620261f, 0.04265581f, 0.04564865f, 0.05110557f, -0.06152551f, 
    0.02318234f, -0.00662274f, 0.04647683f, 0.02263379f, -0.03100524f, -0.06072710f, 0.00370658f, 0.05230642f, 
    -0.03956179f, 0.01948496f, 0.02893654f, 0.05297408f, 0.01592038f, -0.05192203f, -0.01485022f, -0.01125240f, 
    -0.04292923f, 0.05256849f, -0.04813796f, -0.02264449f, -0.01701422f, 0.04725861f, -0.05259096f, -0.03417942f, 
    -0.39690551f, -0.28533357f, -0.20456615f, -0.06658544f, -0.32598814f, -0.15645228f, -0.03976708f, -0.33311030f, 
    -0.12870432f, -0.20056632f, -0.29900536f, -0.98631591f, 0.05336748f, 0.06197439f, 0.12804480f, 0.08386927f, 
    -0.05366015f, 0.01380676f, 0.20118763f, 0.10327291f, 0.03555416f, 0.08374246f, -0.01649861f, -0.01909341f, 
    -0.13674691f, 0.17321762f, -0.09913373f, -0.17893085f, 0.15302865f, 0.21012980f, 0.02319151f, 0.04398602f, 
    -0.15967289f, 0.22649148f, 0.04230519f, 0.22972369f, -0.26329276f, 0.07606002f, 0.07366343f, -0.06541352f, 
    0.06157969f, 0.04094141f, -0.18873741f, 0.11145368f, 0.44526830f, 0.24283454f, -0.46554291f, -0.38684928f, 
    0.04164983f, 0.24050523f, 0.16682945f, 0.11152334f, 0.07799543f, 0.04906264f, 0.39811710f, -0.23285799f, 
    0.19673817f, 0.20230806f, 0.15021524f, 0.21911445f, 0.12868968f, 0.27475047f, 0.10016847f, -0.15555067f, 
    -0.00974936f, 0.07484737f, -0.06642991f, 0.10663827f, 0.06707379f, 0.13649186f, 0.18122500f, 0.18635236f, 
    -0.16979873f, -0.00039167f, 0.16258572f, 0.00301061f, -0.08352672f, -0.04133305f, -0.06766373f, 0.01741789f, 
    -0.05426872f, -0.82258326f, -0.15115145f, -0.16004008f, -0.31197345f, -0.08073173f, -0.21185827f, -0.08417186f, 
    0.03696405f, 0.04414938f, 0.77906340f, -0.36515671f, -0.14140242f, -0.05043864f, 0.17407417f, -0.09687210f, 
    0.06850023f, -0.06598540f, -0.17093855f, 0.70652241f, -0.17365067f, -0.13459618f, 0.17703368f, 0.06302533f, 
    0.09279988f, 0.00487081f, 0.07661191f, -0.09414051f, 0.09496845f, 0.20601599f, -0.12890472f, 0.03340703f, 
    -0.05227863f, 0.09388110f, -0.14357154f, -0.17644094f, -0.13160649f, 0.09660891f, -0.27023420f, -0.42119777f, 
    0.09013433f, -0.14031491f, 0.03395572f, -0.02529849f, 0.02233548f, -0.00316227f, -0.43483844f, -0.00920496f, 
    0.05579319f, -0.03858577f, -0.01348023f, 0.00434380f, 0.23211056f, -0.04959137f, -0.25096563f, 0.05614045f, 
    0.22682343f, 0.35972437f, -0.08427192f, 0.16754760f, 0.13945732f, 0.05626101f, 0.16948923f, 0.07148966f, 
    0.07985485f, 0.00119955f, 0.19523576f, 0.08357055f, 0.14658006f, -0.04803034f, 0.00923143f, 0.06111402f, 
    -0.01573951f, 0.48004192f, 0.23898275f, -0.11540505f, 0.13384289f, 0.24828362f, 0.07004373f, 0.10724759f, 
    -0.01829449f, -0.16560182f, -0.00842750f, 0.03486070f, 0.22727744f, 0.09203263f, 0.17134383f, -0.01004366f, 
    0.05928379f, 0.10135759f, 0.10164461f, -0.44004026f, 0.28911424f, 0.16940582f, 0.06864233f, 0.05817059f, 
    -0.24562284f, 0.08308400f, 0.02638237f, 0.00764444f, -0.05066652f, -0.03693483f, 0.17564665f, -0.02234231f, 
    0.03363285f, -0.14394911f, -0.00276874f, -0.05335655f, 0.07564453f, 0.02916938f, -0.12297715f, 0.11758962f, 
    0.00753455f, 0.01472500f, -0.06656732f, 0.22204152f, 0.30876282f, 0.33995637f, -0.16158527f, -0.38626984f, 
    -0.49115539f, -0.03391636f, -0.06637248f, 0.00555786f, 0.04300742f, -0.11798585f, 0.11434124f, -0.16934356f, 
    0.06694470f, -0.53272665f, -0.12606759f, 0.00114074f, -0.12651555f, -0.08566054f, -0.07257416f, -0.19307181f, 
    0.40976393f, -0.10049035f, 0.28062183f, 0.08344793f, 0.03562132f, -0.01757478f, 0.02295396f, -0.00114962f, 
    0.07471874f, 0.27086791f, -0.13923702f, -0.00155366f, 0.06829461f, -0.01330631f, 0.06096257f, 0.08939230f, 
    0.05429966f, 0.15455733f, -0.02749658f, 0.29262963f, 0.09430821f, 0.03569989f, 0.03345644f, -0.20184667f, 
    -0.03096367f, -0.01152449f, -0.00980907f, 0.11169972f, -0.19751748f, -0.39220527f, 0.12933862f, 0.02480005f, 
    0.24999619f, 0.02044841f, 0.07690091f, 0.15562862f, 0.19363198f, 0.27288604f, -0.07536521f, -0.02795412f, 
    -0.33682275f, -0.50037897f, -0.00495310f, -0.07830630f, 0.18690114f, -0.07109398f, -0.15865831f, -0.18782479f, 
    0.00384181f, 0.15832549f, -0.10510340f, -0.01115058f, -0.22997670f, -0.24858323f, -0.52220261f, 0.11432462f, 
    0.22302479f, -0.03109309f, -0.17598072f, -0.27200130f, -0.09533621f, 0.05745450f, 0.19144139f, 0.08994585f, 
    -0.00980171f, -0.36356470f, 0.06695040f, 0.03665711f, 0.01221889f, -0.05890120f, -0.00420123f, -0.00553049f, 
    0.01107856f, -0.04898509f, -0.02136304f, 0.00967039f, 0.00150872f, -0.04428353f, -0.05583241f, -0.01691130f, 
    -0.05752363f, 0.02621937f, -0.01127236f, 0.00067533f, -0.03633430f, 0.02667287f, 0.03803283f, -0.04949459f, 
    -0.02372092f, -0.05567158f, -0.02765173f, 0.00145546f, -0.06190292f, -0.00425982f, 0.04548011f, 0.01992119f, 
    -0.00907166f, -0.06021753f, 0.02129224f, 0.05008701f, -0.00141280f, 0.02915270f, -0.05505735f, -0.01166731f, 
    -0.00952681f, -0.05422270f, 0.04015252f, -0.01469062f, 0.03907334f, 0.01125992f, 0.00059310f, 0.03146799f, 
    -0.03030003f, 0.01525306f, 0.02959707f, -0.01007319f, -0.05674418f, 0.02718449f, -0.04094115f, 0.00476999f, 
    -0.04041468f, -0.04538155f, -0.00184396f, -0.06096959f, -0.05202253f, 0.03377211f, 0.01350818f, -0.04711573f, 
    0.02810433f, 0.03985461f, 0.05225502f, -0.03932064f, 0.00079268f, -0.05236992f, -0.01333800f, -0.03316931f, 
    -0.04015110f, 0.03364077f, -0.01431580f, 0.04952520f, -0.04100440f, -0.00882595f, -0.02576281f, 0.00992452f, 
    0.01092701f, -0.01670162f, -0.03312064f, -0.01020801f, -0.03618757f, -0.03824328f, 0.05178437f, -0.03126356f, 
    -0.02560348f, 0.00864797f, -0.00803566f, 0.04209147f, -0.02261673f, -0.03483298f, -0.02577826f, -0.05016426f, 
    -0.01868586f, -0.06235936f, -0.04690459f, 0.00174237f, -0.02703136f, 0.00278919f, 0.00837230f, -0.01851067f, 
    0.03344956f, -0.04945667f, -0.03117753f, -0.00875551f, 0.02481792f, -0.04095798f, -0.04362710f, -0.03191604f, 
    0.00959201f, 0.03248772f, 0.04813540f, 0.00380457f, -0.02724010f, -0.05278573f, -0.04730597f, -0.02037417f, 
    0.02597306f, 0.03181380f, -0.05556163f, 0.02919053f, 0.02325187f, 0.04891681f, -0.02910729f, -0.00261277f, 
    0.04653818f, -0.00266264f, -0.03176181f, -0.00710485f, -0.02993249f, 0.01622671f, -0.03150790f, -0.01255619f, 
    -0.01270654f, 0.03380428f, -0.01840187f, 0.03559159f, -0.04271016f, -0.03809217f, -0.05635805f, 0.01521643f, 
    -0.04762108f, -0.04282524f, 0.03181802f, -0.05924053f, -0.00683025f, -0.06398311f, -0.02729675f, -0.00078626f, 
    0.02753670f, 0.01679154f, 0.02900579f, 0.01433268f, 0.02527706f, -0.02886619f, 0.00419035f, -0.00393445f, 
    -0.01572532f, 0.04012119f, -0.05947632f, 0.01817044f, -0.06045820f, -0.00068204f, -0.05995318f, -0.04481286f, 
    -0.05975316f, -0.03151344f, -0.02508679f, 0.00069680f, -0.06365693f, 0.01602612f, 0.04776565f, -0.02051422f, 
    -0.03277682f, 0.02536171f, -0.01964678f, -0.05248686f, -0.04442948f, 0.03470091f, 0.01437091f, 0.00512904f, 
    -0.02958884f, -0.01803555f, -0.04555617f, 0.00696860f, -0.01505955f, 0.01621507f, 0.02958896f, -0.03222085f, 
    -0.03004814f, 0.00869341f, -0.01141263f, 0.00954240f, 0.00319230f, -0.01717054f, -0.06107887f, 0.00194928f, 
    0.03669014f, -0.01536721f, -0.02773730f, 0.03868896f, 0.04155098f, 0.00392884f, -0.00904960f, -0.04805798f, 
    -0.01515662f, -0.03083456f, 0.05064639f, -0.01121607f, 0.05032190f, 0.01795778f, 0.03182243f, 0.00187874f, 
    0.00787309f, -0.04379048f, -0.05203287f, -0.05313092f, 0.05153722f, -0.04894766f, 0.04638632f, -0.05104040f, 
    0.00494371f, 0.01315778f, -0.01285041f, 0.02422557f, 0.00182502f, -0.04831588f, -0.00566286f, -0.03086067f, 
    0.01023824f, -0.01071104f, 0.04081954f, -0.05332504f, -0.03694716f, 0.03484262f, 0.04967984f, 0.00183255f, 
    0.01736107f, -0.01494991f, 0.02530979f, -0.00696077f, -0.02851711f, 0.02342650f, -0.05986260f, -0.00070944f, 
    0.04871808f, 0.03160610f, 0.02632938f, 0.02185771f, -0.01064102f, 0.01568264f, 0.01959518f, -0.01749788f, 
    -0.01263997f, -0.05376653f, -0.00613988f, -0.01933038f, 0.05050050f, -0.04077186f, -0.01851866f, -0.00759578f, 
    -0.05606621f, -0.00233218f, 0.04053541f, -0.06228698f, 0.01551765f, 0.04948173f, -0.04356458f, 0.01587644f, 
    0.00533297f, -0.00925388f, -0.05946916f, -0.01433577f, -0.05282041f, -0.06311224f, 0.04529129f, 0.02591165f, 
    0.02088982f, 0.02107721f, -0.05868340f, -0.03741704f, -0.06304337f, -0.00987849f, 0.01826882f, 0.00684869f, 
    0.04579921f, -0.05490999f, -0.00466528f, -0.03315922f, 0.00899534f, -0.01096102f, 0.01145833f, 0.03630731f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.06171710f, 0.08516604f, -0.05790333f, -0.00648839f, 0.09928068f, 0.17196637f, 0.19060114f, 0.40730953f, 
    -0.05889506f, -0.00219603f, 0.05519016f, -0.01090128f, 0.04113782f, -0.12599470f, 0.31243744f, -0.20387764f, 
    -0.05014585f, 0.01417781f, 0.13950513f, 0.01028680f, 0.07028555f, 0.30836329f, 0.18452579f, -0.05711193f, 
    -0.11600496f, 0.12696670f, 0.05698983f, -0.04042964f, -0.12129667f, -0.00355184f, 0.23764445f, -0.01478497f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.06304143f, -0.28944007f, -0.06142710f, -0.00308845f, 0.27655840f, 0.06235613f, 0.02874929f, -0.48758218f, 
    -0.12984914f, -0.11617611f, 0.12660857f, -0.14297609f, 0.06428804f, 0.43105561f, -0.17016761f, 0.31641552f, 
    -0.12334315f, -0.09617320f, 0.15986633f, 0.02764311f, 0.10396602f, -0.11589000f, 0.17400153f, 0.00076884f, 
    0.05957137f, 0.00451051f, -0.86624390f, -0.14902408f, 0.54911673f, -0.05307272f, -0.01785564f, 0.04926254f, 
    -0.11754529f, 0.18800086f, -0.03304515f, -0.11524508f, 0.61022687f, 0.37287796f, 0.26771218f, -0.10545055f, 
    -0.02741810f, 0.13580818f, -0.20194678f, -0.15427276f, -0.03129477f, -0.41276845f, 0.06185256f, -0.30729425f, 
    -0.11011757f, 0.09075253f, 0.27764729f, -0.06629924f, -0.09917506f, 0.08194330f, 0.03048727f, 0.00461962f, 
    -0.28129232f, 0.27372047f, -0.16278075f, 0.13407080f, 0.56347626f, -0.14212234f, 0.17422743f, 0.00583574f, 
    0.04538422f, -0.16424231f, 0.01926769f, 0.04244203f, -0.47106263f, 0.21765065f, -0.15117359f, 0.59363419f, 
    0.00381503f, 0.12735613f, 0.15588346f, 0.03079620f, 0.02468177f, 0.03122304f, -1.24851859f, 0.20848887f, 
    0.14280206f, 0.10232082f, 0.18498410f, 0.02138514f, 0.16761415f, -0.13009021f, 0.01372872f, -0.01085421f, 
    -0.84231287f, -0.22600450f, -0.24597368f, 0.04850481f, -0.59541559f, -0.04864159f, -0.16126032f, -0.11006789f, 
    0.15478398f, -0.06860950f, 0.03789304f, -0.13794346f, -0.12381378f, 0.18893887f, -0.47265095f, -0.24735561f, 
    0.15280315f, -0.07981730f, -0.94672328f, 0.27709448f, 0.10421576f, -0.34286469f, -0.06475843f, 0.48563418f, 
    -0.11861425f, -0.01093114f, 0.33443806f, 0.08539069f, -0.11171126f, -1.34956193f, 0.04011908f, -0.16036169f, 
    -0.30538672f, -0.43914273f, 0.46710694f, 0.12217177f, -0.18520387f, -0.11216480f, -0.57065570f, 0.01915656f, 
    0.14278461f, -0.29358453f, 0.05564303f, 0.04745101f, -0.12457544f, 0.17290653f, -0.26048812f, -0.04751954f, 
    0.10739328f, 0.12376357f, -0.18323742f, 0.14117910f, 0.02011314f, 0.49819133f, -0.42435783f, -0.22625643f, 
    -0.06048116f, 0.08488657f, -0.32348770f, -0.07196102f, 0.35890752f, -0.26394629f, 0.03766286f, 0.12405784f, 
    0.52366751f, 0.05073698f, -0.02461499f, 0.00523674f, -0.00773577f, -0.16804898f, 0.28752929f, 0.01314116f, 
    0.15483600f, 0.49373278f, 0.09128392f, -0.02117831f, 0.44545501f, -0.20281351f, -0.46294188f, 0.09311520f, 
    0.08893275f, 0.01049343f, 0.05409292f, -0.44237682f, 0.00688113f, 0.28316694f, 0.22358613f, 0.12427387f, 
    -0.12371352f, -0.08777703f, -0.08285039f, -0.11453848f, 0.37973896f, 0.11459283f, -0.10684092f, 0.10162348f, 
    -0.03910003f, 0.00943457f, 0.13009782f, -0.11005059f, -0.49045718f, -0.12640731f, -0.11810437f, 0.12572213f, 
    0.02664984f, -0.29195568f, 0.11842173f, 0.13214315f, -0.94525492f, -0.35778597f, 0.71983701f, 0.21878569f, 
    0.03983770f, 0.12982982f, -0.13715692f, 0.11682138f, 0.13821581f, -0.03308100f, -0.70524269f, 0.15493295f, 
    -0.17079175f, -0.14679891f, -0.60265195f, 0.07306543f, -0.41004446f, 0.45848823f, -0.32010466f, 0.12493716f, 
    -0.53855616f, -0.09867629f, -0.07440171f, -0.04038246f, -0.02021307f, -0.00405695f, 0.43973127f, 0.13227578f, 
    0.10671327f, -0.22263432f, 0.06106984f, 0.03336830f, -0.20879187f, -0.28663880f, -0.11061826f, -0.24830170f, 
    0.06619574f, -0.15176721f, 0.27923945f, 0.08884394f, 0.11895974f, 0.07393129f, 0.18354103f, -0.19244851f, 
    0.04475096f, 0.11911912f, -0.12256718f, 0.02430904f, -0.08660720f, -0.03362142f, -0.04810639f, 0.01706885f, 
    0.52708435f, 0.56701398f, 0.16495255f, -0.17033406f, 0.08586993f, 0.02130598f, -0.28203765f, 0.02093786f, 
    -0.07852169f, 0.38726994f, -0.15810436f, -0.14267938f, -0.22884820f, -0.11856618f, 0.09850049f, 0.12995090f, 
    0.09932059f, -0.01008058f, 0.06201323f, -0.09356843f, 0.13232547f, -0.09276900f, 1.32641923f, -0.27806568f, 
    0.01342570f, 0.15987277f, -0.33552414f, 0.10831623f, -0.73571187f, -0.19877841f, 0.30457389f, 0.07044704f, 
    0.14130907f, -0.09220803f, -0.14510752f, 0.15487209f, 0.10885848f, 0.15463790f, -0.52243078f, 0.02036354f, 
    0.16229828f, -0.29754251f, 0.03143068f, 0.04782152f, -0.02320821f, -0.51217210f, -0.19415504f, 0.01110424f, 
    -0.02098836f, 0.08383637f, -0.75027949f, 0.45434242f, 0.04634952f, -0.31321463f, -0.25055754f, -0.05917611f, 
    -0.11738455f, -0.15125868f, -0.51111501f, -0.16360942f, 0.10351156f, 0.65848553f, 0.60161245f, -0.11047406f, 
    -0.34887505f, 0.02593189f, 0.36451659f, -0.14849189f, -0.31383592f, -0.09268418f, 0.12180334f, 0.03934699f, 
    0.01285522f, 0.15983871f, -0.16819431f, -0.10578001f, 0.10501163f, 0.29969820f, 0.24150634f, 0.24900030f, 
    0.13330470f, -0.17669462f, 0.02562401f, -0.41133478f, 0.02839197f, 0.13832137f, -0.68508595f, -0.10088028f, 
    0.13128248f, 0.16326942f, 0.38473231f, 0.00517059f, -1.19655824f, -0.05431472f, -0.04513957f, 0.03263388f, 
    0.72874779f, -0.25687504f, -0.12514284f, -0.15422896f, -1.11736703f, 0.00115828f, -0.25331274f, 0.13095401f, 
    0.02382359f, 0.01285077f, 0.09811059f, 0.04914201f, -0.77475375f, -0.25899884f, -0.30575931f, 0.19235575f, 
    0.05831889f, -0.03777454f, 0.68200159f, 0.15533519f, 0.10018628f, -0.15306935f, 0.38129398f, 0.06523873f, 
    0.12286065f, -0.13717341f, 0.13855739f, 0.04541510f, -0.44482261f, -0.55685896f, -0.75282657f, 0.13268544f, 
    -0.28336579f, -0.84614807f, 0.32187510f, 0.13182306f, 0.33522543f, 0.03805664f, 0.31989834f, 0.08860227f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.33705136f, 0.11108862f, 0.48676738f, 0.07486610f, 0.05679633f, -0.19329797f, -0.00701767f, -0.13580899f, 
    0.00143935f, 0.35214460f, 0.30164447f, -0.10075442f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
