#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.16757441f, 0.05093303f, -0.36558893f, 0.19827512f, -0.02639529f, 0.12582748f, -0.01538995f, -0.28337827f, 
    0.09573218f, 0.16060992f, -0.09052730f, 0.03246223f, 0.25424111f, -0.14806429f, 0.05427006f, -0.06744252f, 
    -0.04676457f, 0.10477521f, 0.03986472f, 0.09490223f, 0.20191304f, -0.30363411f, 0.45322797f, -0.19078846f, 
    -0.34691405f, 0.66592586f, -0.44750926f, -0.45565400f, -0.63173401f, -0.48788080f, -0.14902113f, 0.01535205f, 
    0.21250761f, 0.38842604f, 0.08332340f, 0.18155009f, 0.13725424f, 0.34193498f, -0.21078213f, 0.31879076f, 
    -0.01199834f, 0.06898533f, 0.04289971f, -0.14067434f, -0.11059953f, -0.19793114f, -0.28056952f, -0.12362463f, 
    0.11440915f, -0.32681572f, 0.68226874f, 0.49870571f, 0.36147970f, 0.06818891f, -0.77349985f, -0.14733107f, 
    -0.33313468f, 0.08185624f, -0.00676748f, -0.52277946f, 0.36758509f, -0.19854107f, -0.09247690f, 0.04775858f, 
    -0.38066405f, -0.01940969f, 0.09579660f, 0.39184913f, -0.19642599f, -0.06331480f, -0.05677699f, -0.15911135f, 
    -0.25724527f, 0.03313901f, 0.15287873f, -1.27580607f, 0.66265637f, 0.12303865f, -0.34150887f, 0.61530793f, 
    0.10658081f, -0.26928067f, -0.15484391f, 0.09266106f, 0.21775170f, 0.24889897f, -0.27510306f, -0.03587697f, 
    -0.01912904f, -0.30060843f, 0.01719379f, -0.33883822f, -0.29932654f, -0.14543593f, -0.18623091f, -0.00605937f, 
    -0.17634872f, -0.37323481f, -0.19645220f, -0.60263926f, -0.49074098f, -0.39881364f, -0.54144341f, -0.37581351f, 
    -0.34071073f, -0.61313426f, -0.48804045f, -0.21383348f, -0.59409022f, -0.80998135f, 0.43630832f, 0.02408152f, 
    0.16291243f, 0.25864372f, 0.04840764f, 0.06828259f, 0.06566068f, -0.03074073f, 0.15692213f, 0.06485637f, 
    0.03320695f, 0.17077897f, -0.14635047f, -0.12471676f, 0.30180386f, 0.42321116f, 0.38944837f, -0.30032855f, 
    -0.15883932f, -0.10548834f, -0.13178428f, 0.38413057f, 0.23916379f, -0.09326521f, -0.18303794f, 0.23192759f, 
    -0.18706554f, 0.04537646f, 0.04587578f, -0.26892167f, 0.02054093f, -0.21570446f, -0.23206069f, 0.06458159f, 
    -0.00039844f, 0.10768757f, 0.32330227f, -0.24363720f, -0.43500373f, 0.31826285f, 0.11587758f, 0.34980226f, 
    0.16358112f, -0.48374140f, -0.14720583f, 0.33308932f, 0.20848764f, 0.21620885f, -0.67979437f, -0.22768942f, 
    -0.58176363f, -0.19926976f, -0.07102724f, -0.17743322f, 0.20104235f, 0.05056016f, -0.12612623f, -0.05607952f, 
    -0.07838523f, 0.05577986f, 0.20219478f, -0.15982358f, -0.24732564f, -0.12749206f, -0.14941226f, 0.57686394f, 
    -0.12778766f, -0.39143860f, -0.49905759f, -0.79079485f, 0.57605875f, 0.35256264f, -0.21026461f, -0.47576091f, 
    0.08184943f, -0.04995501f, 0.26896408f, -0.23410182f, -0.09442467f, -0.21437955f, 0.17310429f, 0.39643216f, 
    0.58463079f, -0.20484266f, -0.18130864f, 0.00886977f, 0.05670599f, 0.16699539f, -0.20804560f, -0.02629475f, 
    0.75957119f, -0.62892598f, -0.51917768f, 0.26793081f, -0.27879393f, 0.43222824f, 0.31123853f, -0.00483785f, 
    -0.24337916f, 0.23705490f, -0.10617518f, 0.26429921f, -0.29727021f, -0.24801178f, 0.50751597f, -0.15778954f, 
    -0.15790766f, 0.17782328f, -0.06576076f, -0.40274218f, 0.13115312f, -0.05332230f, 0.18941772f, 0.12569505f, 
    0.14670648f, 0.98911107f, 0.07209469f, -0.48915398f, -0.00675067f, -0.58401400f, 0.50845492f, 0.44136170f, 
    -0.07745176f, -0.50594497f, -0.38909718f, 0.04423594f, 0.49734247f, -0.03935716f, -0.06351966f, 0.01559621f, 
    -0.05334030f, -0.13515633f, -0.05928474f, -0.09034225f, -0.08680218f, -0.02459729f, 0.01867764f, 0.12521127f, 
    0.11172158f, 0.21556002f, -0.75374836f, -0.34300017f, -0.14333090f, 0.11570696f, 0.09734637f, 0.21165805f, 
    0.15492393f, 0.21213731f, 0.22225156f, 0.11190353f, 0.13499124f, 0.02147313f, 0.07762440f, 0.15594323f, 
    -0.15864211f, -0.24069899f, 0.12635602f, -0.18785580f, -0.01598835f, 0.31557256f, 0.13360776f, -0.09900855f, 
    0.05194873f, -0.00156260f, -0.08861854f, -0.34736890f, -0.84171563f, 0.30732650f, 0.16933443f, 0.72212404f, 
    0.22299920f, 0.56243730f, -0.57718116f, -0.68419212f, -0.14442492f, -0.12054488f, -0.36070964f, -0.08046888f, 
    -0.29030359f, -0.09179839f, -0.00501246f, -0.25790387f, 0.22319214f, 0.13621062f, 0.10540026f, -0.00232901f, 
    -0.13177805f, 0.01278166f, 0.12649369f, 0.18386036f, -0.38031703f, 0.16635235f, -0.36676884f, -0.48691452f, 
    -0.31800607f, 0.01760090f, -0.06210520f, 0.04938988f, -0.02909561f, 0.02297823f, 0.13379692f, -0.06039443f, 
    -0.21346295f, -0.28686562f, -0.24172391f, -0.35571727f, -0.03240383f, -0.37030679f, 0.13531350f, 0.07400121f, 
    0.22924846f, 0.23679702f, 0.24314956f, 0.25018451f, 0.18280080f, -0.69193679f, -0.38479975f, -0.08773331f, 
    0.25789610f, -0.03963017f, 0.53296191f, -0.15061352f, -0.06538719f, 0.47975156f, 0.38030410f, 0.08042814f, 
    0.06577720f, -0.11141688f, -0.04383557f, -0.21684419f, -0.08477591f, 0.19341297f, -0.22004266f, -0.08048262f, 
    -0.14109686f, -0.04682012f, -0.10205504f, 0.18997385f, -0.18040106f, -0.00743755f, 0.06423270f, -0.05179470f, 
    0.22403312f, 0.13102101f, 0.17613761f, 0.22952999f, 0.33326101f, 0.29894572f, 0.35810968f, 0.22768767f, 
    0.09098235f, 0.04053303f, 0.01985358f, 0.09914596f, 0.04216332f, 0.10756910f, -0.08408567f, -0.07201067f, 
    -0.01073400f, 0.12275635f, -0.20422176f, -0.07147660f, 0.08452005f, 0.04517548f, 0.18435518f, 0.06865621f, 
    0.76498693f, 0.27777427f, -0.21498676f, 0.26703408f, -0.09815026f, -0.23956867f, 0.00448257f, -0.04372457f, 
    -0.08488493f, -0.05052556f, 0.05144412f, 0.09448444f, 0.01016840f, -0.42483401f, -0.25643477f, -0.00108527f, 
    0.23292859f, 0.13696189f, -0.20541751f, -0.20860079f, 0.37235075f, 0.10716992f, -0.29906845f, -0.30237326f, 
    -0.87441546f, -0.46524978f, 0.06030078f, 0.28406516f, 0.39278898f, 0.61981148f, 0.10115448f, -0.90300667f, 
    -0.90765893f, -0.43096668f, -0.26113358f, -0.20897381f, -0.24026187f, -0.36382106f, -0.39379865f, -0.30526018f, 
    -0.14471288f, -0.19548602f, -0.10384167f, -0.10544499f, 0.22434637f, -0.08296422f, -0.32242981f, -0.08146638f, 
    -0.27549332f, 0.81783855f, -0.97162837f, -0.80098927f, 0.18351176f, 0.30478576f, 0.42408672f, 0.33558273f, 
    0.17047785f, -0.10575232f, -0.09173609f, 0.10423809f, 0.09499434f, -0.10948461f, -0.07890389f, 0.12298279f, 
    0.27487186f, -0.04877348f, -0.10264378f, -0.07654069f, -0.24269167f, -0.00582387f, -0.03602551f, -0.04978376f, 
    0.07742067f, 0.12113366f, -0.27080750f, 0.66233212f, 0.20195293f, 0.09983484f, -0.35195860f, 0.19952609f, 
    -0.24631552f, -0.13836473f, -0.16685976f, 0.25572056f, -0.20014755f, -0.15663083f, 0.47682586f, -0.56517231f, 
    0.05655917f, 0.03669519f, -0.22582650f, 0.16847843f, 0.25857544f, -0.08248014f, 0.13826171f, -0.09876006f, 
    -0.08719668f, -0.07663468f, -0.19067046f, -0.07443561f, -0.05465366f, -0.16156617f, -0.10409825f, 0.08165270f, 
    -0.23093669f, -0.00000813f, 0.29083636f, 0.12908195f, 0.23294471f, -0.02447693f, 0.15477185f, 0.09721772f, 
    0.09736019f, 0.02096417f, -0.22591768f, -0.07064419f, 0.02912071f, -0.28585422f, 0.25745863f, 0.07727210f, 
    0.20929760f, -0.11953352f, 0.21341510f, -0.28639308f, 0.61653644f, -0.25418824f, 0.07975440f, 0.59053499f, 
    0.10470851f, 0.29121998f, 0.39247444f, -0.09279778f, -0.54238045f, -0.54099548f, -0.04855740f, -0.01307563f, 
    -0.02822351f, -0.15703076f, -0.02528318f, -0.23786047f, 0.11857458f, 0.04905660f, 0.16880174f, -0.21937677f, 
    0.09131984f, -0.26910138f, -0.04070833f, -0.09891777f, 0.09064779f, 0.19226642f, -0.04667022f, -0.05052120f, 
    -0.01921657f, 0.26443371f, -0.13534185f, -0.15540968f, -0.03470694f, 0.13191344f, -0.17055812f, -0.00132260f, 
    0.33335707f, 0.28335789f, -0.08262336f, -0.26626644f, -0.25839674f, 0.27199301f, -0.24355960f, 0.08681139f, 
    -0.16791838f, 0.02390025f, 0.16186705f, 0.16007064f, 0.15401432f, 0.10560379f, 0.66824275f, 0.22563891f, 
    0.07309262f, 0.18730991f, 0.44092751f, -0.36527318f, 0.08753732f, -0.33278188f, -0.25971407f, -0.44701064f, 
    -0.17810026f, 0.26247272f, -0.01213908f, 0.09295642f, -0.20837967f, 0.16792385f, 0.30200222f, -0.08549644f, 
    -0.25968984f, 0.14035815f, -0.00502276f, -0.03671340f, 0.11425152f, 0.22826973f, -0.31133938f, -0.12329978f, 
    -1.00394535f, 0.23001371f, 0.81039679f, 0.37383139f, -0.64164513f, -0.58634979f, -0.60630065f, 0.73845690f, 
    -0.15046340f, -0.38933611f, 0.56912845f, -0.14389662f, 0.03455114f, -0.12835155f, -0.13250545f, 0.21119437f, 
    -0.08482374f, -0.36569703f, -0.28914815f, 0.05527536f, 0.00855463f, -0.18314311f, -0.26316455f, 0.15993632f, 
    1.03431487f, -0.21402076f, -0.66314816f, -0.30152309f, -0.68701589f, 0.18599883f, 0.03808291f, 0.36951244f, 
    0.21074380f, 0.00612168f, -0.08692549f, 0.26890355f, -0.23466201f, -0.07511494f, 0.04903482f, -0.02892092f, 
    0.01263065f, 0.11568090f, -0.09349868f, -0.03261645f, 0.17813236f, -0.12895642f, -0.06694062f, 0.08549547f, 
    0.04343950f, 0.16354114f, -0.12335208f, -0.12616731f, 0.25412536f, -0.13940999f, 0.22595794f, -0.38782668f, 
    -0.32268119f, 0.11460764f, 0.30188733f, 0.13053004f, -0.11252074f, -0.16863662f, 0.09319445f, 0.26119092f, 
    -0.24380535f, -0.19752830f, 0.04914446f, 0.09055027f, 0.19711117f, 0.17114383f, 0.09172133f, 0.17587414f, 
    0.05606933f, -0.41199830f, 0.30740827f, 0.19584429f, -0.00101985f, -0.15558915f, 0.25877309f, -0.52044636f, 
    -0.56311214f, -0.48033264f, -0.37728068f, -0.50321376f, 0.17648336f, 0.01651105f, -0.04711520f, 0.43670401f, 
    0.24811237f, 0.19247246f, -0.03987668f, 0.03908564f, 0.11749569f, -0.07926100f, -0.24864879f, 0.05658384f, 
    0.05272740f, -0.19522110f, -0.05078537f, -0.40055847f, 0.31193665f, 0.59327328f, -0.18903208f, -0.39446718f, 
    -0.54687816f, 0.07983158f, 0.13364860f, 0.31375441f, 0.16738120f, -0.51187652f, -0.02552900f, 0.29479891f, 
    -0.16626848f, -0.06732432f, 0.00820392f, 0.23131134f, -0.17187753f, -0.21368660f, 0.29527920f, -0.18032826f, 
    -0.12358448f, -0.12560865f, -0.00791331f, 0.26122108f, 0.39908406f, 0.22771078f, 0.23042959f, -0.09778700f, 
    -0.45374420f, -0.16304582f, -0.27011678f, -0.23354702f, -0.11209860f, -0.17510933f, -0.09619693f, 0.05690376f, 
    0.14486100f, 0.42139453f, 0.19338877f, 0.06206874f, 0.00289241f, 0.27641073f, -0.27974045f, -0.00526130f, 
    -0.16370869f, -0.24807368f, -0.21658139f, 0.09760127f, -0.27780294f, 0.44799811f, 0.41245708f, -0.53808337f, 
    0.46569338f, -0.30724403f, -0.40598747f, -0.31366515f, 0.04095730f, 0.15893500f, 0.48744437f, 0.00098630f, 
    -0.17565449f, 0.01117319f, -0.08434067f, -0.22630684f, -0.10441364f, -0.06109672f, 0.20904826f, 0.14121641f, 
    -0.11395176f, -0.09067935f, -0.18987902f, 0.16148379f, -0.00583769f, -0.05337383f, 0.42174369f, -0.14907075f, 
    0.24039364f, 0.24004005f, -0.16165026f, -0.60940737f, -0.31190223f, 0.00924306f, 0.50909966f, -0.28588492f, 
    0.04661663f, -0.36093655f, 0.05420234f, 0.19406706f, 0.35580036f, 0.08411232f, 0.22387043f, -0.35653087f, 
    -0.31969413f, 0.09553526f, -0.06384274f, -0.15645412f, 0.20368853f, 0.08228724f, 0.13517515f, -0.26345533f, 
    -0.32996985f, -0.39709416f, 0.49974552f, 0.49402693f, -0.02774883f, 0.32229927f, -0.13214529f, -0.05889888f, 
    -0.17119950f, -0.03020224f, 0.19543701f, 0.24755281f, -0.50904995f, -0.14452410f, 0.35897613f, 0.00081286f, 
    -0.24621300f, 0.11855754f, 0.06119337f, 0.16948688f, -0.27701655f, -0.03407196f, -0.16444960f, 0.09761550f, 
    -0.19419497f, 0.46939990f, 0.27677172f, -0.62486207f, 0.05056154f, -0.00669638f, 0.07113186f, 0.10033431f, 
    -0.27539858f, 0.06432900f, -0.40790501f, 0.41871703f, -0.31326631f, -0.19280393f, 0.29552644f, -0.21516347f, 
    -0.09564294f, 0.23377699f, 0.10644174f, -0.16116925f, -0.03067991f, -0.05649164f, 0.00112086f, -0.29466215f, 
    -0.50438756f, 0.21147598f, 0.30895478f, -0.20367044f, -0.11524355f, 0.03261713f, -0.01302219f, 0.10924528f, 
    0.20432755f, -0.00710701f, -0.43176642f, -0.48517716f, 0.53202736f, -0.06521696f, 0.12124952f, -0.33331260f, 
    0.18517806f, 0.07647806f, -0.30572695f, -0.27750483f, -0.17264906f, -0.19011509f, 0.40789053f, 0.11165231f, 
    -0.14845143f, 0.18773623f, 0.24152185f, -0.30623251f, -0.03605870f, 0.01717080f, 0.26127580f, -0.01795062f, 
    -0.15054083f, 0.11459081f, -0.27936760f, -0.23050150f, 0.17153817f, -0.37104738f, 0.31325647f, -0.27468494f, 
    0.13879137f, 0.07632498f, 0.18751736f, -0.10406870f, 0.08381039f, -0.09575310f, -0.31335488f, 0.12773743f, 
    0.12956846f, 0.16349560f, 0.30252835f, 0.77919364f, -0.08670963f, 0.21162170f, -0.27485386f, -0.57177621f, 
    -0.05766040f, 0.18608637f, 0.13365480f, 0.02568893f, -0.09580395f, -0.02144097f, -0.04665264f, 0.07533949f, 
    -0.08596022f, -0.15957136f, 0.20183863f, -0.03247152f, 0.00774590f, -0.18723534f, -0.41694453f, -0.22878517f, 
    -0.27533457f, -0.31577098f, -0.32502109f, -0.35896242f, 0.47377232f, -0.31595314f, 0.28328133f, 0.05129553f, 
    0.04130017f, -0.29741755f, 0.12117518f, 0.10502533f, -0.19431084f, -0.32877630f, 0.26232108f, -0.12261774f, 
    0.08329088f, -0.06579102f, 0.02794428f, -0.32303146f, -0.15037167f, -0.10043857f, 0.00095071f, -0.01478497f, 
    -0.49701181f, -0.24784368f, -0.41758808f, -0.49514979f, -0.45444584f, -0.66938865f, 0.32068935f, 0.36531687f, 
    -0.65201050f, -0.28003120f, -0.52316380f, -0.43181819f, -0.31141418f, 0.05972676f, -0.21536112f, 0.37136397f, 
    0.30313674f, 0.21114755f, -0.04352398f, -0.41051373f, 0.21599680f, -0.11151246f, -0.14080743f, 0.02843268f, 
    -0.19477746f, 0.26124200f, -0.10306325f, -0.36017039f, -0.05252915f, -0.07859887f, 0.82844567f, -0.23359056f, 
    -0.75888938f, -0.75923467f, -0.82342046f, -0.13354182f, -0.17310537f, 0.52513874f, 0.18599829f, 0.14741902f, 
    0.09695593f, 0.19601148f, 0.37477371f, 0.09224675f, -0.11734316f, 0.04486419f, -0.02751296f, -0.07757559f, 
    -0.04970971f, 0.05401460f, -0.10215370f, 0.13666457f, -0.32012364f, -0.37536070f, 0.09170759f, 0.07887068f, 
    -0.37478399f, -0.34347036f, -0.10301452f, -0.37682277f, -0.19771105f, -0.53083068f, -0.70391303f, -0.59715670f, 
    -0.44107646f, 0.47154969f, 0.14452364f, 0.21165609f, -0.06455239f, 0.45636556f, -0.33654359f, 0.11500635f, 
    -0.41041005f, -0.37234980f, -0.49717161f, -0.06375284f, -0.37689608f, 0.16634926f, -0.05700423f, -0.35838029f, 
    -0.77781188f, 0.02194279f, 0.06737033f, -0.45960775f, -0.41114575f, -0.44802806f, -0.49591357f, -0.44577429f, 
    -0.36867914f, -0.32448778f, -0.16822483f, -0.17767011f, -0.30934241f, -0.52100092f, -0.19329004f, 0.00972160f, 
    0.09092259f, -0.01539183f, 0.04191751f, -0.08889993f, 0.11187623f, 0.05023589f, -0.19908951f, -0.19586216f, 
    0.00185601f, 0.02626325f, 0.29241630f, 0.29467374f, 0.26156661f, 0.19949096f, 0.02198404f, -0.20906502f, 
    -0.15413372f, 0.10283242f, 0.09805299f, 0.33466846f, -0.43675160f, -0.18007687f, -0.12180748f, -0.16105188f, 
    0.14358209f, 0.28328392f, -0.18644589f, -0.09432076f, -0.01385962f, -0.18580909f, 0.10396096f, -0.25980628f, 
    -0.20975536f, -0.37815839f, -0.37793875f, -0.23084734f, -0.04624552f, -0.52551907f, -0.46073997f, -0.07416850f, 
    -0.41645634f, 0.00321991f, -0.33827099f, 0.08030324f, -0.35275030f, 0.28946695f, 0.52066755f, -0.10696232f, 
    -0.27464941f, 0.00683877f, 0.08410200f, 0.03857455f, -0.10505956f, -0.11529402f, 0.26032162f, 0.22738460f, 
    -0.31146678f, -0.03298538f, 0.30766159f, 0.38104594f, -0.51792383f, -0.63795233f, -0.45684436f, -0.47205183f, 
    0.16859199f, 0.22419727f, -0.23443072f, -0.55169022f, -0.57845938f, 0.13546990f, -0.15518248f, -0.05648808f, 
    -0.02118318f, -0.25245833f, -0.14516477f, -0.62586170f, -0.16668995f, 0.02097571f, 0.01527166f, -0.20599836f, 
    -0.11899620f, -0.29494822f, 0.31048480f, 0.01289041f, -0.67014873f, -0.54644805f, -0.23679140f, -0.10904651f, 
    -0.50191879f, -0.17238495f, 0.16730814f, 0.10390694f, 0.41820532f, 0.15450309f, 0.19240232f, 0.22401400f, 
    0.00703108f, -0.12498442f, -0.02366295f, -0.37911138f, -0.10965884f, -0.38019529f, -0.29436123f, -0.34295785f, 
    0.11164189f, -0.03135835f, 0.25961423f, -0.03974031f, 0.52004588f, -1.01512611f, -0.25599387f, 0.14313211f, 
    -0.81069303f, -0.46312842f, -0.23150600f, -0.14178516f, 0.33443931f, 0.43578050f, 0.32140708f, -0.23936443f, 
    -0.04081839f, -0.21615034f, 0.18823107f, 0.00726964f, 0.11030029f, -0.05257162f, -0.13948490f, -0.02882193f, 
    -0.20514946f, -0.22234735f, -0.26268181f, 0.01804184f, -0.44473669f, -0.39353883f, -0.27979088f, 0.46766055f, 
    -0.14021368f, -0.12299684f, 0.06673915f, -0.22704549f, -0.28916374f, 0.21365876f, 0.29080796f, -0.33852232f, 
    0.01974576f, -0.06363878f, -0.07080695f, 0.26904115f, 0.10181624f, -0.16436659f, 0.08933423f, -0.23975596f, 
    0.03134932f, -0.01401686f, 0.05753648f, 0.02729391f, 0.26219121f, 0.23604530f, -0.00787031f, -0.04590352f, 
    -0.18730488f, 0.10926153f, -0.11731680f, 0.03755106f, -0.12462672f, 0.46600661f, -0.16372728f, 0.15416013f, 
    0.30945846f, 0.05625207f, 0.40746084f, -0.16583051f, -0.35785514f, -0.23848429f, -0.02858012f, -0.18562256f, 
    -0.11755623f, 0.00239693f, 0.04807340f, -0.12908131f, 0.04783863f, 0.08762783f, -0.42960739f, 0.03375791f, 
    -0.08823398f, -0.71728534f, -0.68553448f, -0.60618794f, -0.85931784f, 0.12636715f, 0.27910784f, 0.32198262f, 
    0.07040945f, -0.05838535f, -0.41588616f, -0.34528911f, -0.19973274f, 0.17280135f, 0.12424516f, 0.17972563f, 
    0.17141016f, 0.03826724f, 0.07729870f, -0.16321447f, -0.31346935f, 0.09129318f, 0.09255206f, -0.29097068f, 
    -0.34886473f, -0.77399278f, -0.38944045f, -0.51046067f, -0.68726462f, -0.67179650f, 0.64829451f, 0.08689617f, 
    -0.18338186f, -0.06106652f, 0.88087779f, -0.25061667f, -0.02906564f, -0.28496435f, 0.03498039f, -0.06907953f, 
    0.03494483f, 0.17163852f, 0.05750438f, -0.10177148f, 0.14911266f, -0.03632950f, -0.15597020f, 0.07635829f, 
    0.20135050f, 0.17537989f, -0.33029124f, -0.73718709f, -0.61539036f, 0.16512676f, 0.39885390f, -0.36517000f, 
    -0.20189124f, -0.13544503f, -0.08638563f, -0.33801863f, -0.26469073f, -0.48118180f, -0.12129232f, 0.18187085f, 
    0.00410506f, 0.10501914f, 0.06197489f, 0.23289020f, -0.33781976f, 0.18501629f, -0.33864731f, -0.20529361f, 
    -0.25748089f, -0.17997707f, -0.00809960f, -0.52519047f, -0.36559901f, -0.04975445f, 0.33014336f, 0.41847953f, 
    0.35779837f, 0.28549081f, 0.04217201f, 0.37122831f, 0.12394583f, -0.04519934f, -0.24592672f, 0.15833311f, 
    0.24850541f, -0.35739616f, -0.07466103f, 0.08086546f, -0.04806955f, -0.02742747f, -0.36757839f, 0.03275699f, 
    0.23661572f, -0.14030208f, 0.22377343f, 0.21282707f, -0.41438705f, -0.29759648f, 0.04424052f, -0.09638969f, 
    0.12210009f, -0.06566618f, -0.44502118f, -0.12752213f, 0.05614844f, -0.25900978f, 0.21419801f, 0.33646676f, 
    0.24253339f, 0.34592623f, -0.12583227f, 0.06102781f, 0.12258363f, 0.13052839f, 0.06084614f, -0.13914238f, 
    0.07319943f, 0.11549955f, -0.01714476f, -0.10655022f, -0.10831044f, -0.65789282f, -0.25429070f, 0.08555916f, 
    0.18813774f, 0.35160011f, -0.67660272f, -0.44848940f, 0.04230238f, 0.58511072f, 0.76518911f, -0.20025513f, 
    -0.02952476f, 0.04515903f, -0.25754482f, 0.32768697f, 0.06076499f, -0.23133495f, -0.24934858f, 0.13788188f, 
    -0.05684701f, -0.11997861f, 0.07473734f, 0.29790437f, -0.06052322f, 0.22073190f, -0.03942074f, 0.13333780f, 
    -0.30828783f, -0.08019758f, 0.16161984f, -0.27185965f, -0.32747972f, 0.12586135f, -0.22907560f, -0.25918430f, 
    0.22073512f, -0.02160342f, 0.13576725f, 0.22930439f, -0.13215820f, 0.03117710f, 0.07868189f, 0.12460982f, 
    0.10664105f, -0.25636959f, 0.05262238f, -0.17047450f, 0.14097419f, 0.27287725f, 0.19134645f, 0.20103143f, 
    -1.06922925f, 0.11872825f, 0.57622999f, 0.48027575f, -0.10756322f, -0.06455725f, -0.65955973f, -0.21274160f, 
    -0.10763817f, -0.07587516f, 0.16884214f, -0.43927771f, 0.17095946f, -0.48430872f, -0.20799196f, -0.17625687f, 
    -0.09896141f, 0.24705189f, 0.20974232f, 0.09745034f, -0.30376589f, 0.01890051f, 0.07705220f, 0.25559264f, 
    -1.10532856f, -0.32989973f, -0.54384643f, 0.20254916f, 0.33818427f, -0.39733621f, -0.22976366f, -0.35594159f, 
    0.08410994f, 0.18442944f, 0.56833303f, 0.17036843f, 0.32761085f, 0.08768619f, 0.18741143f, 0.18750980f, 
    -0.20025177f, -0.33003929f, -0.21814521f, -0.35450879f, -0.08237381f, 0.04335924f, 0.03644772f, 0.09936235f, 
    0.08700544f, 0.00858348f, -0.57387924f, -0.13528644f, 0.31784087f, -0.07375954f, 0.61479938f, 0.34657779f, 
    -0.01013607f, -0.30341893f, 0.09714868f, -0.20821641f, -0.18867192f, 0.02258929f, 0.29600564f, 0.10761853f, 
    0.19709043f, -0.22743835f, -0.21287082f, 0.18291384f, -0.30432579f, -0.04225755f, 0.09133026f, -0.09264230f, 
    -0.11487837f, 0.09327417f, 0.77922654f, -0.29062381f, -0.61618435f, -0.23151511f, -0.41109014f, -0.16539429f, 
    0.00580956f, 0.20919164f, 0.26313773f, 0.34847611f, -0.19174580f, -0.02077647f, 0.11404807f, -0.13201107f, 
    0.20038974f, 0.24589829f, -0.02729070f, -0.07786319f, 0.09969661f, -0.24181667f, 0.00297097f, -0.26453227f, 
    0.25076756f, -0.04839011f, 0.10689313f, -0.75512511f, -0.26241899f, -0.43874574f, -0.02212200f, -0.13738479f, 
    0.19232698f, 0.09025695f, 0.23257092f, 0.56567258f, 0.29953262f, 0.11614493f, -0.02955654f, 0.35575935f, 
    -0.52722049f, 0.06045543f, -0.48219526f, -0.21369934f, 0.22021934f, -0.07229180f, -0.13043006f, 0.17237121f, 
    0.45178851f, -0.13203263f, -0.23749961f, 0.52131230f, -0.40176934f, -0.51688737f, -0.03395208f, -0.68101043f, 
    -0.84368837f, 0.45412126f, -0.25493988f, -0.64970803f, -0.48017207f, -0.39349088f, -0.46912503f, -0.14329337f, 
    -0.12022135f, -0.35986033f, -0.00418349f, 0.03752836f, 0.04172532f, 0.07054504f, -0.23143782f, -0.30920368f, 
    -0.06546264f, 0.23020832f, 0.12596995f, -0.05408531f, 0.34913084f, 0.39965972f, 0.14849076f, 0.34851459f, 
    -0.10487597f, -0.28659290f, -0.24061631f, -0.16945203f, -0.10143889f, 0.30829349f, -0.22377868f, 0.17859557f, 
    0.23257168f, -0.16406552f, -0.30350098f, 0.39668939f, -0.21581239f, 0.05660147f, -0.20159113f, -0.01103262f, 
    0.09383549f, 0.19504705f, 0.05906324f, -0.03306926f, 0.08882663f, -0.20778245f, -1.27910197f, 0.20599698f, 
    -0.62150472f, -1.09966719f, -0.10390639f, 0.40200558f, 0.56950706f, 0.52644968f, 0.40982902f, 0.47994828f, 
    -0.05117109f, -0.03193003f, -0.28637981f, -0.46889588f, -0.15793376f, 0.06576676f, 0.03972104f, -0.18214332f, 
    0.06105801f, -0.21854600f, 0.03250251f, 0.01041702f, 0.04657954f, 0.02811368f, -0.01043050f, -0.32453769f, 
    -0.22990704f, -0.15813823f, 0.44817877f, 0.49294740f, 0.71875578f, -0.35563156f, -0.23266426f, -0.33055148f, 
    0.22558881f, 0.04718111f, -0.27493137f, -0.07723681f, 0.02581683f, -0.02077170f, 0.03936116f, -0.33296025f, 
    0.27772462f, -0.20996647f, 0.19395974f, -0.34254238f, -0.20147538f, 0.41738957f, 0.20753561f, -0.21116143f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13139704f, 0.07297067f, 0.37379324f, 0.00465238f, -0.17391704f, 0.28483650f, -0.14125073f, 0.26713514f, 
    0.21182947f, 0.31740993f, -0.11908130f, 0.26154464f, 0.00881094f, 0.24595162f, 0.14502609f, 0.17246702f, 
    -0.21371330f, 0.31487492f, -0.03239575f, 0.11870187f, 0.08241604f, -0.00027538f, 0.16017745f, 0.30822602f, 
    0.22431985f, 0.29691625f, -0.06693611f, 0.35550493f, 0.06915982f, 0.40226740f, 0.10245903f, 0.20151176f, 
    0.09971132f, 0.33713412f, 0.33060130f, 0.06921785f, -0.16697043f, 0.18462293f, 0.21268055f, -0.09573734f, 
    -0.40878811f, 0.12304803f, 0.22826804f, 0.06977525f, 0.43054083f, 0.04061253f, 0.10362302f, 0.12194468f, 
    -0.19028087f, -0.11196669f, -0.30509144f, 0.03678863f, 0.01673087f, 0.26020542f, 0.09182563f, 0.07234659f, 
    0.41122150f, 0.24655075f, 0.18824485f, 0.23855421f, -0.40102777f, 0.02873397f, 0.12188813f, 0.24797072f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00401637f, 0.02726335f, -0.00323410f, 0.05813369f, -0.06853420f, 0.04335696f, 0.04074278f, -0.04367279f, 
    -0.07903489f, -0.10038926f, -0.03824099f, 0.06504874f, 0.11792943f, -0.06398006f, -0.06291129f, 0.06012123f, 
    0.08529038f, 0.07015401f, 0.02684393f, -0.00452970f, -0.07321863f, 0.01684940f, 0.01530722f, 0.10390794f, 
    -0.05059223f, -0.30240479f, -0.06465699f, -0.17808442f, -0.04362041f, 0.07236914f, -0.14084275f, -0.08430499f, 
    -0.02105627f, 0.02391661f, -0.05226634f, -0.00328967f, -0.20133235f, 0.24520162f, 0.04724238f, -0.00269735f, 
    -0.09673550f, 0.11838575f, 0.01167898f, 0.08384828f, -0.05656822f, 0.06138656f, 0.06117642f, 0.11197624f, 
    0.34866938f, 0.20100908f, -0.15703274f, -0.14874619f, 0.13053988f, 0.03203376f, -0.00376106f, 0.09608036f, 
    0.02895690f, 0.02298814f, 0.02350056f, -0.01800492f, -0.36692175f, -0.18048310f, -0.39175296f, 0.10965582f, 
    0.02070251f, 0.01728395f, 0.03684784f, -0.00129226f, -0.00159533f, 0.00353042f, -0.09365692f, -0.07187062f, 
    0.00322258f, 0.15699178f, -0.15650097f, 0.17642497f, 0.06144764f, -0.01579061f, -0.13742450f, -0.11321098f, 
    -0.00403444f, -0.03480876f, 0.05626262f, -0.00056216f, 0.16127732f, -0.06736044f, -0.22336012f, -0.05077806f, 
    0.09309850f, 0.13442665f, -0.11358880f, 0.01967914f, 0.01692943f, 0.00046807f, 0.04306911f, 0.07110358f, 
    0.07910179f, 0.06346858f, -0.23732378f, 0.08096713f, 0.02102630f, 0.05788520f, 0.00546704f, -0.06928136f, 
    -0.00612963f, -0.08789897f, -0.15608811f, -0.02653086f, 0.01089154f, -0.12152697f, -0.22698867f, 0.10922968f, 
    -0.00459790f, -0.01305389f, -0.06194570f, -0.05922395f, -0.10217043f, -0.01330535f, -0.08660786f, -0.16791500f, 
    0.10846503f, 0.04526923f, 0.05525045f, 0.05540820f, 0.04105072f, 0.08828647f, 0.05386340f, 0.06554017f, 
    -0.15163040f, -0.10242431f, 0.02970372f, -0.11835497f, 0.36832061f, 0.12200000f, -0.20654836f, -0.16613996f, 
    0.02644319f, -0.17576723f, 0.02373892f, -0.09944616f, -0.05211326f, -0.05358016f, -0.01527502f, 0.05415419f, 
    0.08089805f, 0.06687762f, -0.05200724f, -0.12715933f, 0.03165470f, 0.09922465f, -0.00036181f, 0.02217669f, 
    -0.01038339f, -0.08271918f, -0.07734928f, -0.08425196f, 0.22642399f, 0.00828586f, 0.07126726f, -0.04290060f, 
    -0.03761056f, 0.01601711f, 0.00652486f, 0.01382524f, -0.07522500f, 0.12645599f, 0.04395255f, -0.07699633f, 
    -0.00951989f, -0.00598282f, 0.00862390f, 0.01623378f, -0.06211057f, -0.00944743f, 0.04617230f, -0.00305806f, 
    -0.18091422f, -0.19086415f, -0.12135106f, -0.19383626f, -0.49039114f, -0.07899947f, -0.33233809f, 0.14587538f, 
    0.05930410f, 0.00018161f, 0.01734632f, 0.05596757f, -0.03715440f, 0.01078354f, 0.02730940f, 0.04099421f, 
    0.45992839f, 0.23679990f, -0.13770781f, -0.10971817f, -0.16261533f, -0.07396742f, 0.10858501f, 0.01123141f, 
    -0.11447433f, -0.13450222f, -0.09855072f, -0.05200228f, -0.03474521f, -0.07158244f, -0.76036745f, 0.03476161f, 
    -0.04916191f, -0.03360277f, 0.07908694f, -0.10794614f, -0.06726046f, -0.04285050f, -0.19799668f, -0.16281018f, 
    -0.53989488f, 0.41968787f, -0.23306803f, 0.15930797f, 0.11413443f, -0.10565380f, 0.02489140f, -0.06868634f, 
    -0.00729564f, -0.00532227f, -0.01125626f, 0.10522605f, -0.04523503f, -0.04850136f, 0.01215116f, 0.05943730f, 
    -0.00982990f, 0.05752812f, 0.00570512f, 0.03601570f, -0.22341815f, -0.12152354f, 0.02803935f, -0.00791070f, 
    0.00699798f, -0.60590070f, 0.04301196f, -0.07766497f, -0.05762195f, -0.07104807f, 0.08699737f, 0.03183751f, 
    -0.02068804f, -0.01518677f, 0.06027456f, 0.04255028f, -0.02257317f, 0.02310085f, 0.00794439f, -0.00064544f, 
    -0.11638707f, -0.07418248f, -0.00663056f, -0.02420235f, -0.03216660f, -0.00566911f, -0.03572450f, -0.04407226f, 
    -0.15834275f, -0.12130629f, -0.14622216f, 0.06655016f, -0.11022777f, -0.12456448f, -0.07415630f, -0.00601354f, 
    0.00998051f, 0.02070920f, -0.02201532f, 0.00772357f, 0.05320267f, 0.21525544f, 0.11820551f, -0.38675725f, 
    -0.07225017f, -0.02138531f, 0.08853027f, -0.05596108f, 0.00803348f, -0.11307628f, -0.02341196f, -0.18165056f, 
    -0.05847469f, -0.29927889f, -0.25079143f, 0.07339878f, 0.07484920f, 0.03458703f, -0.07906667f, -0.08001511f, 
    -0.01798486f, 0.05270196f, 0.03982742f, 0.00312521f, -0.11241027f, 0.01409148f, 0.02075673f, -0.03702501f, 
    -0.29162711f, -0.10796327f, 0.04517498f, 0.05912933f, -0.07320361f, -0.01979550f, 0.00163344f, -0.04265885f, 
    0.21619235f, 0.12908213f, -0.10329545f, -0.11255194f, -0.02679955f, 0.00308129f, 0.05671747f, 0.07352383f, 
    0.03775853f, 0.11622040f, -0.02421105f, 0.00855066f, -0.52295935f, -0.19845407f, 0.21536312f, -0.12487026f, 
    -0.01872903f, -0.00814622f, -0.03749416f, 0.06662933f, -0.11612882f, -0.16433518f, 0.00669442f, -0.16529106f, 
    0.08706247f, -0.04242241f, 0.00556561f, -0.03940730f, -0.06839603f, -0.05388223f, -0.17374194f, -0.02356071f, 
    0.12672749f, -0.02269334f, 0.02509128f, 0.07408679f, -0.58557427f, -0.03181608f, -0.03282378f, -0.07409342f, 
    -0.04631143f, 0.05952704f, -0.05396096f, -0.01426415f, -0.02116123f, -0.06271191f, -0.01426560f, 0.08092091f, 
    -0.11134884f, 0.01981453f, 0.18879828f, -0.29230174f, -0.19050708f, 0.01993592f, -0.12032308f, -0.06811929f, 
    0.01987361f, -0.01478645f, -0.16981837f, 0.01986459f, 0.12257340f, 0.13372028f, -0.16536868f, -0.01343160f, 
    0.00987500f, -0.12141199f, 0.00982362f, -0.21685314f, -0.15979835f, -0.02303635f, 0.09502754f, -0.13319011f, 
    -0.32507849f, -0.10067557f, -0.07875564f, -0.01351123f, -0.02385404f, 0.03739333f, -0.01340493f, -0.01489548f, 
    -0.10496669f, 0.12925474f, -0.08738321f, -0.08197745f, -0.25388956f, -0.34073281f, -0.27036557f, 0.11820447f, 
    -0.07350271f, -0.03196119f, 0.02226579f, -0.00669574f, -0.03133245f, 0.04650814f, -0.16339085f, -0.16048963f, 
    -0.01730150f, 0.01505869f, -0.03270261f, -0.06893544f, -0.07004069f, -0.06666503f, -0.02313479f, -0.07893468f, 
    -0.04076840f, 0.03231080f, -0.06509343f, -0.07246160f, -0.33129993f, -0.32295427f, -0.01205205f, 0.03907831f, 
    -0.02630856f, 0.00710355f, -0.03365094f, 0.06956779f, -0.15393408f, 0.02500995f, 0.08618142f, 0.10263555f, 
    -0.00041940f, -0.08241449f, -0.01613186f, -0.07482304f, -0.03510144f, -0.02796249f, 0.02889667f, -0.02716409f, 
    0.00020672f, 0.06275833f, 0.08050820f, 0.11814819f, 0.10180537f, 0.14846770f, -0.06043506f, -0.06824827f, 
    -0.06139737f, 0.05055129f, -0.08900759f, 0.14490761f, 0.14021985f, -0.07614122f, 0.00306488f, -0.05218158f, 
    0.12857448f, -0.06838498f, -0.10793051f, 0.08507942f, 0.08454933f, -0.00134438f, -0.06831314f, -0.06897675f, 
    -0.11471268f, 0.02002272f, 0.02624596f, 0.08076209f, 0.24686538f, 0.12500305f, -0.16144605f, -0.21346715f, 
    -0.04978898f, -0.00712913f, -0.03299860f, -0.00936527f, -0.11451571f, -0.05597099f, -0.11046059f, -0.07614476f, 
    0.14594822f, 0.33290085f, -0.00344103f, -0.09302645f, 0.07198288f, 0.18329206f, -0.02630491f, 0.04930992f, 
    0.00811760f, -0.01113793f, -0.01542612f, -0.05574368f, -0.35359657f, -0.02678849f, 0.14268436f, -0.03936220f, 
    0.06169066f, 0.02043461f, -0.02362167f, -0.03126942f, -0.01823300f, 0.01084149f, 0.04032536f, -0.00639593f, 
    0.19211483f, 0.02915153f, -0.10728535f, -0.13517043f, -0.00838196f, 0.02564139f, 0.09354115f, -0.05303127f, 
    0.04410345f, -0.05116503f, 0.03301314f, 0.03061732f, 0.28236160f, 0.01110179f, -0.26135886f, -0.09979653f, 
    0.10894365f, -0.08327720f, -0.03339399f, -0.00849266f, -0.11415829f, -0.09628588f, -0.16064395f, -0.08207560f, 
    0.06198046f, 0.07387076f, 0.05983939f, -0.07067746f, 0.11722032f, 0.03950870f, 0.06089633f, -0.14565530f, 
    -0.10489809f, -0.11449213f, 0.00369734f, -0.05938410f, 0.03313688f, 0.03230948f, 0.13573350f, -0.08726085f, 
    0.00321706f, 0.17870666f, 0.00751106f, 0.05791484f, 0.03459862f, 0.02626685f, 0.02347885f, 0.01881970f, 
    0.10268990f, -0.02169897f, 0.14104769f, 0.00886696f, -0.01932657f, 0.08067594f, -0.04455528f, -0.02200569f, 
    0.00258293f, 0.01140870f, -0.04273296f, -0.06599656f, -0.15377590f, -0.14885190f, 0.03675748f, -0.07978394f, 
    0.00721946f, 0.00648404f, 0.06570238f, 0.04550071f, -0.02733855f, 0.09010980f, 0.04929908f, -0.00846351f, 
    0.29373094f, 0.00412689f, -0.02056617f, -0.07107353f, 0.10973512f, 0.15643060f, 0.15540519f, 0.06966332f, 
    -0.00566070f, 0.08350100f, 0.00236752f, 0.06267808f, 0.26047871f, 0.05704139f, -0.05574407f, -0.12351281f, 
    0.00373298f, 0.13942352f, -0.00827378f, 0.05515836f, 0.01573306f, 0.02662491f, 0.08382923f, 0.01602182f, 
    0.32033342f, 0.05641532f, 0.14468990f, -0.10209787f, 0.17037116f, 0.11879113f, 0.27796617f, 0.05295277f, 
    -0.04425653f, 0.00209476f, 0.05053506f, -0.03904824f, 0.07523673f, 0.17720445f, -0.03200895f, -0.03023337f, 
    -0.04359380f, -0.00956443f, 0.10883729f, -0.00220361f, 0.04961391f, 0.04585243f, -0.12728129f, -0.19221821f, 
    0.22138925f, 0.21838486f, 0.02881229f, -0.01930896f, -0.14998452f, -0.06195730f, -0.02021835f, 0.05512140f, 
    0.04985321f, -0.03507015f, 0.01988694f, 0.04007346f, -0.25936228f, 0.27719161f, 0.19604385f, -0.39060649f, 
    -0.09220059f, -0.03448991f, -0.01361168f, -0.07537667f, -0.07787836f, -0.21080899f, -0.15075913f, -0.04479331f, 
    0.16318135f, 0.14469381f, 0.03115920f, 0.00350578f, -0.06595226f, -0.09820841f, -0.08658865f, -0.04601808f, 
    0.04665393f, 0.05659727f, -0.00569249f, 0.01657557f, 0.28175423f, 0.01635320f, -0.13258487f, -0.29837111f, 
    0.02178724f, -0.24823594f, 0.07204078f, -0.09216619f, -0.01845525f, 0.00435348f, -0.01070881f, 0.02036849f, 
    0.15939589f, 0.21992692f, 0.11966343f, -0.24704885f, -0.00230782f, 0.07625767f, 0.08836752f, -0.08210048f, 
    0.02802969f, -0.04005643f, -0.18032995f, -0.00712886f, 0.10875214f, -0.14325148f, -0.43136203f, -0.03108879f, 
    0.04207613f, 0.01822647f, 0.06576189f, -0.00794895f, -0.00575945f, -0.06099260f, 0.03754971f, 0.07927996f, 
    -0.27729583f, -0.06786745f, -0.09533294f, 0.11543586f, 0.01355777f, 0.01102167f, -0.01205763f, -0.03167512f, 
    -0.09058961f, -0.08534421f, -0.11359417f, 0.07866715f, 0.02850495f, 0.06735261f, 0.03378196f, -0.12973417f, 
    0.05779674f, 0.04193996f, 0.09751979f, -0.16471510f, 0.08293140f, 0.00633934f, 0.00984966f, -0.10787933f, 
    0.24907407f, 0.12727286f, -0.15264590f, -0.15768334f, 0.06730622f, 0.19075361f, 0.05415689f, 0.00524226f, 
    -0.02601607f, -0.00540234f, -0.00111435f, 0.02689605f, -0.03979325f, -0.06942319f, 0.02054399f, -0.06985357f, 
    -0.16343179f, -0.05634737f, 0.09217270f, 0.05680916f, -0.01616486f, -0.06290662f, 0.04816749f, -0.00316483f, 
    -0.03325495f, -0.08143282f, -0.04015408f, -0.08532513f, 0.03231966f, 0.13650750f, 0.02032688f, 0.06382843f, 
    0.00620997f, 0.03072079f, 0.01104532f, -0.03266511f, 0.21885133f, 0.06624101f, -0.14377914f, -0.09151225f, 
    -0.05961806f, -0.01250315f, 0.04181565f, -0.05059198f, 0.06441210f, -0.12965617f, -0.02673542f, 0.04955316f, 
    -0.08130237f, 0.01857547f, 0.05377320f, -0.01390360f, -0.01283184f, 0.02333468f, -0.02477396f, -0.03457687f, 
    -0.07149738f, 0.00737545f, -0.01832330f, -0.00551695f, 0.04066030f, -0.26505581f, -0.04889128f, -0.06523920f, 
    0.01699605f, 0.07062174f, 0.01526323f, -0.11642771f, 0.18461573f, 0.12902017f, 0.00601233f, 0.02673198f, 
    0.25640637f, -0.10253581f, 0.33323479f, -0.29944396f, -0.03021790f, -0.08239609f, -0.02987521f, -0.00553978f, 
    -0.00295410f, -0.05522998f, -0.04284201f, 0.05163797f, -0.06257969f, -0.15852641f, -0.35965616f, 0.14302428f, 
    0.06243484f, -0.04566088f, -0.07524803f, 0.05698101f, -0.21350774f, 0.02238779f, -0.32606944f, -0.25434464f, 
    -0.17436364f, 0.13598643f, 0.20310508f, 0.08641660f, -0.10539047f, -0.02156784f, 0.06984928f, -0.22374797f, 
    -0.10557576f, -0.02788840f, -0.02562864f, 0.04538083f, 0.21749960f, 0.13332069f, 0.30834231f, 0.10847899f, 
    0.00186019f, 0.01968521f, -0.02780581f, -0.01777691f, -0.02686187f, -0.02806987f, -0.00353322f, 0.02297314f, 
    0.40766749f, -0.48336026f, 0.07743442f, -0.13488041f, 0.04754471f, -0.06323487f, -0.09687804f, -0.10442981f, 
    -0.00140313f, 0.01448279f, 0.03261202f, -0.08069606f, 0.40447333f, -0.06944931f, -0.03554190f, -0.31411234f, 
    0.16054459f, -0.11513209f, -0.15672535f, -0.14645377f, -0.01406322f, 0.02431540f, -0.10906319f, 0.02700991f, 
    0.42706615f, 0.01228760f, 0.04510419f, 0.06801659f, -0.14762834f, 0.06363698f, 0.02546107f, 0.04028876f, 
    0.02514707f, 0.00438252f, -0.04320861f, -0.05646960f, 0.56619591f, -0.17438085f, -0.07933614f, -0.03483399f, 
    -0.09139518f, -0.04497700f, 0.02535542f, 0.10338946f, -0.05011962f, -0.00180512f, -0.02827187f, 0.10887891f, 
    0.03116051f, 0.00284017f, -0.03972175f, -0.07189996f, -0.00541657f, -0.03275022f, 0.03095354f, -0.05166009f, 
    -0.01731073f, -0.06475457f, 0.00415818f, 0.03322038f, 0.04075887f, -0.24917419f, -0.08843705f, -0.06313450f, 
    -0.07839129f, -0.17031102f, 0.12218880f, -0.01891105f, 0.05871937f, 0.01089746f, 0.04994394f, -0.00530978f, 
    0.10793419f, 0.11626703f, -0.00822231f, -0.03782452f, 0.29070312f, 0.11888308f, 0.00660749f, 0.12491798f, 
    -0.07014241f, 0.03231236f, -0.06559805f, -0.00091956f, 0.15499707f, 0.31978509f, -0.00081517f, -0.07245992f, 
    -0.03634087f, -0.01227410f, -0.03887481f, 0.03393415f, -0.04694268f, -0.11777725f, -0.06115830f, 0.01943276f, 
    0.09379863f, 0.04776562f, 0.11184045f, 0.11164076f, -0.02302764f, 0.00080169f, 0.04356590f, -0.05670466f, 
    0.11954351f, 0.13421917f, 0.15363811f, 0.07569120f, 0.35510105f, 0.10779563f, 0.18461154f, 0.07267371f, 
    0.01508932f, -0.04949747f, -0.00782834f, 0.05787099f, -0.05268147f, 0.05063157f, 0.00852571f, 0.08625174f, 
    0.13213016f, -0.28374410f, -0.03004638f, -0.06872001f, 0.02892617f, -0.30788475f, 0.16644673f, 0.07733987f, 
    0.07274379f, -0.02000407f, 0.00815300f, -0.03736008f, 0.67550653f, -0.06027023f, -0.04759826f, 0.08555750f, 
    -0.10309078f, 0.01631233f, 0.01492611f, -0.02936329f, 0.06058099f, 0.00812302f, 0.15851799f, 0.19999176f, 
    -0.00701488f, 0.01361837f, -0.01114779f, 0.02463507f, -0.01713535f, 0.06702064f, 0.02385519f, -0.14288619f, 
    0.01336364f, -0.01256735f, 0.09508812f, -0.09006096f, -0.03683947f, 0.00850660f, 0.05331594f, -0.09082211f, 
    0.03008173f, -0.02820691f, 0.02347229f, 0.01649710f, 0.05487665f, 0.02645970f, -0.00125991f, 0.00285941f, 
    0.49112612f, 0.02910830f, 0.17584085f, 0.22273013f, -0.16291934f, -0.09439447f, -0.13327309f, -0.16323367f, 
    0.09098522f, -0.04710607f, 0.07628395f, 0.06378379f, -0.02002339f, 0.02390604f, -0.05646741f, 0.05432675f, 
    0.08846970f, -0.00701085f, 0.00825631f, -0.02351653f, -0.02759000f, -0.03283392f, -0.05080883f, 0.06554514f, 
    0.10961764f, 0.14305587f, -0.06811675f, -0.01208558f, -0.10666714f, -0.08151859f, 0.05496643f, -0.11739754f, 
    -0.06650870f, 0.03235073f, -0.00989884f, 0.07301315f, -0.89354223f, 0.33778933f, -0.50770015f, -0.25905615f, 
    0.06341786f, -0.01657802f, 0.04513947f, -0.01837581f, -0.03758641f, 0.05762561f, -0.20156394f, 0.13211887f, 
    0.57007653f, -0.07081831f, 0.00746127f, -0.11416643f, 0.02520246f, 0.01062467f, 0.06543967f, -0.12293598f, 
    0.04722258f, -0.03176825f, -0.13499208f, -0.05595715f, 0.03065844f, 0.11735117f, -0.08246152f, -0.03099469f, 
    0.05900478f, -0.01483571f, 0.04644791f, 0.13181499f, -0.03033363f, -0.03646537f, 0.05138730f, -0.05156233f, 
    0.07387152f, -0.00333953f, -0.23047988f, -0.12451826f, -0.20623481f, -0.07103160f, -0.00372561f, 0.11856221f, 
    -0.08525879f, 0.03874373f, 0.00469692f, 0.07764770f, 0.09091763f, 0.10079525f, 0.10335979f, -0.16706128f, 
    0.10159823f, 0.08973200f, 0.02072345f, -0.07544621f, 0.18529186f, 0.11606966f, -0.15133935f, -0.10604794f, 
    -0.09817925f, -0.11611074f, 0.03686659f, -0.09665637f, 0.04385353f, 0.03086735f, -0.03136960f, 0.06631865f, 
    0.17031147f, 0.11610212f, -0.09631620f, 0.15397966f, -0.22781149f, 0.18840812f, 0.20557056f, 0.04268311f, 
    -0.00439946f, -0.03860466f, -0.03115934f, -0.06812223f, 0.04113496f, -0.04775996f, 0.06997008f, -0.01582062f, 
    -0.01749334f, 0.12599598f, -0.07578929f, 0.06915884f, -0.05684418f, -0.07360992f, 0.25626591f, -0.22902019f, 
    0.00647018f, -0.00461124f, -0.00381176f, 0.03415191f, -0.01572637f, -0.07570158f, -0.14880264f, 0.10508014f, 
    -0.14611822f, -0.07117338f, 0.12753883f, 0.01362641f, 0.14402322f, -0.13605699f, 0.05935168f, 0.22243069f, 
    0.00591161f, -0.07175501f, 0.14193851f, -0.24002457f, -0.00577266f, -0.03454361f, -0.08794334f, 0.08879959f, 
    -0.23987319f, -0.21219987f, -0.13502087f, -0.32049403f, 0.29370826f, -0.10455827f, 0.00571208f, 0.12175606f, 
    -0.04140875f, -0.06991617f, 0.02933251f, 0.02188073f, -0.14846809f, 0.03621396f, -0.07905100f, 0.23420388f, 
    -0.04410181f, -0.01646305f, -0.03872716f, -0.00440299f, -0.11967258f, 0.11169087f, 0.17672062f, -0.06142005f, 
    0.02630685f, 0.01454710f, 0.00329930f, 0.01454709f, 0.19023490f, -0.08894426f, 0.13348661f, -0.09638386f, 
    -0.00798246f, 0.02055607f, -0.03090009f, -0.02864968f, -0.07152908f, -0.15948123f, -0.23767117f, 0.00147737f, 
    -0.02809964f, 0.04670619f, 0.05298328f, -0.10023431f, 0.01119990f, 0.00807278f, -0.00699724f, 0.00867784f, 
    -0.33655822f, -0.39881992f, 0.05675156f, -0.22422165f, -0.13749714f, -0.24412256f, 0.13155717f, 0.08962954f, 
    -0.05505558f, 0.07830045f, -0.12201075f, 0.08800603f, 0.00457235f, 0.01878994f, 0.01425896f, 0.08304204f, 
    0.11714813f, -0.13864140f, -0.00500131f, -0.10821531f, -0.01231915f, 0.09011023f, 0.00609729f, -0.27005863f, 
    0.11510751f, -0.02729770f, -0.08045560f, 0.05128195f, -0.16512316f, -0.11920326f, 0.15957074f, -0.09041021f, 
    -0.09604421f, -0.05723019f, 0.10108149f, 0.26155987f, 0.03604483f, -0.01646057f, 0.02131455f, -0.00599719f, 
    0.01795531f, 0.16640164f, 0.04320991f, 0.04840147f, -0.04843034f, -0.05058463f, -0.29420611f, -0.03490876f, 
    -0.02747370f, -0.00208449f, 0.01549487f, 0.00049324f, 0.02584582f, 0.11178073f, 0.08238924f, 0.08152831f, 
    0.01902721f, 0.01180796f, -0.04206774f, 0.07638842f, 0.00681817f, 0.08722178f, -0.08838718f, -0.00145710f, 
    -0.04336307f, -0.07561428f, -0.04073888f, 0.12088589f, -0.01936429f, 0.16950022f, -0.09719785f, 0.05859834f, 
    -0.01804125f, -0.03302855f, 0.02408408f, 0.03511876f, 0.20699334f, -0.08527128f, 0.23669846f, -0.00637766f, 
    0.01820314f, 0.13170829f, 0.10659492f, 0.08928352f, 0.03005285f, -0.03017114f, -0.04703503f, 0.01801595f, 
    -0.30044279f, -0.01986887f, -0.26351279f, -0.30257383f, 0.03638926f, 0.11450962f, 0.05004957f, 0.13372891f, 
    0.01111875f, 0.06033780f, 0.03152415f, -0.04417528f, -0.31518510f, 0.05426674f, -0.02343621f, -0.05707899f, 
    0.09055994f, 0.06879734f, -0.16072743f, 0.00347710f, -0.02147292f, 0.06370850f, 0.01418697f, -0.15653019f, 
    -0.03913433f, -0.04729457f, 0.00313638f, 0.02534629f, 0.13424832f, -0.06784530f, 0.13606770f, -0.06622708f, 
    -0.02590747f, -0.00218738f, 0.03532197f, -0.00195182f, 0.19107300f, 0.16034770f, 0.08780695f, -0.00783086f, 
    -0.06784336f, 0.03715939f, -0.08545260f, -0.02031734f, 0.05196501f, 0.08945789f, -0.37632093f, -0.23665480f, 
    0.14623280f, 0.20705324f, 0.25341305f, 0.18056710f, 0.00935921f, -0.08298841f, -0.14257744f, -0.32496881f, 
    -0.07139043f, 0.01211501f, 0.00333855f, -0.14100195f, 0.37252778f, 0.13883790f, 0.04148071f, -0.19092599f, 
    -0.04997199f, 0.08484384f, 0.00281230f, -0.16076741f, 0.00823921f, -0.03164146f, 0.04832222f, -0.06927992f, 
    -0.23888420f, 0.12673880f, 0.17227682f, -0.00605636f, 0.14553261f, -0.06631777f, 0.14807650f, -0.13434079f, 
    0.08249474f, -0.04107377f, -0.00982027f, -0.03757842f, -0.05636381f, 0.01528353f, 0.04114847f, 0.14617372f, 
    -0.07519427f, -0.04871050f, 0.01763138f, -0.00963171f, 0.03723529f, -0.14002831f, -0.08686577f, 0.02007565f, 
    -0.17118087f, -0.09552396f, -0.03113539f, 0.01217406f, 0.07930369f, -0.00253787f, 0.11653388f, 0.26693273f, 
    -0.16450210f, -0.10921218f, 0.04402973f, 0.03792874f, -0.56215650f, 0.08867986f, -0.08612324f, -0.08617718f, 
    0.07351720f, 0.15048434f, 0.00363061f, -0.02299978f, 0.02314306f, 0.13003929f, 0.04285435f, 0.07393374f, 
    -0.08240077f, 0.00751675f, -0.04020843f, -0.03063839f, 0.02083169f, 0.04632367f, 0.13806713f, -0.06750796f, 
    -0.02962880f, 0.02810142f, 0.00555156f, 0.04270632f, -0.20165035f, -0.03357881f, -0.52359682f, -0.39289793f, 
    -0.11676367f, 0.01674799f, -0.09057287f, -0.22398868f, -0.02015165f, -0.04832324f, -0.01993415f, 0.06253626f, 
    -0.57786977f, -0.18380708f, -0.31832731f, 0.01122295f, 0.05232708f, 0.07139962f, 0.03721249f, 0.04466698f, 
    -0.07186128f, 0.05103311f, 0.14687268f, 0.04053060f, 0.39223662f, -0.16865179f, 0.19959174f, 0.34457773f, 
    0.00353229f, 0.02370993f, -0.04553608f, -0.01237593f, -0.07836980f, -0.09263814f, 0.16519992f, -0.09016741f, 
    0.32640663f, -0.06590080f, -0.01888442f, 0.01524319f, -0.02373422f, 0.07420749f, 0.01864245f, -0.13253993f, 
    0.04805619f, -0.08871025f, 0.11565360f, -0.06801283f, -0.42701191f, 0.18469034f, -0.32661724f, -0.20606576f, 
    -0.07396694f, 0.05852817f, -0.07888438f, 0.07183845f, -0.03371016f, 0.10559715f, -0.00717901f, -0.12097498f, 
    0.22900090f, 0.33089632f, 0.34321129f, 0.14121981f, 0.07078531f, 0.02094099f, -0.20534246f, 0.16738866f, 
    0.02253763f, 0.02786520f, 0.00180572f, 0.04218911f, 0.13214464f, -0.02743229f, 0.03597499f, -0.01920956f, 
    0.09861886f, -0.02566212f, 0.01476453f, -0.00852225f, -0.00480228f, 0.02308248f, -0.09474780f, 0.02824827f, 
    -0.02616349f, 0.05568793f, -0.20485406f, -0.19555980f, -0.06589291f, -0.04683124f, -0.02993185f, -0.14284410f, 
    -0.05049518f, -0.07776760f, -0.19490053f, 0.03725938f, 0.06043451f, 0.06119572f, -0.16248479f, 0.27093136f, 
    -0.10279388f, -0.07430870f, 0.03903855f, 0.05392902f, 0.01577924f, 0.24120121f, -0.02214657f, -0.15634122f, 
    -0.00990308f, -0.00727349f, -0.03189909f, 0.04472525f, 0.08257178f, -0.06029899f, 0.08779453f, 0.05760330f, 
    0.02578939f, 0.09893604f, 0.14939533f, -0.07952657f, -0.04544489f, 0.25176278f, 0.09633802f, 0.07984696f, 
    -0.04764409f, -0.01495753f, 0.10461082f, -0.29785332f, -0.01555433f, 0.15003537f, -0.00882146f, 0.12990852f, 
    -0.53246093f, 0.09293705f, 0.11223058f, -0.63030094f, 0.02317758f, -0.00390994f, 0.04472248f, -0.01862561f, 
    0.00550992f, -0.02538387f, -0.00022405f, 0.05082120f, 0.21347418f, -0.22707948f, -0.07246305f, 0.08631927f, 
    -0.02500474f, -0.05164928f, 0.03471106f, -0.01062105f, -0.11677335f, 0.06442206f, 0.14972398f, 0.11825578f, 
    -0.66817629f, -0.37650549f, -0.28115994f, -0.28588298f, -0.07842703f, -0.03191525f, -0.04753250f, -0.01085247f, 
    0.02616895f, -0.00308708f, -0.01032161f, 0.01628034f, -0.01003144f, 0.01545960f, -0.11930000f, -0.15984909f, 
    0.03799882f, 0.03247775f, -0.03161604f, 0.05653835f, 0.04043739f, -0.05713511f, -0.00493308f, 0.00211578f, 
    0.29152885f, -0.14920290f, -0.08403836f, -0.27432966f, 0.04747062f, -0.05576905f, -0.00082209f, -0.02775230f, 
    -0.04678536f, 0.09674995f, -0.06265659f, -0.08631316f, -0.09289020f, 0.16590543f, 0.33078721f, -0.28031021f, 
    -0.03718157f, 0.02514435f, -0.00828410f, -0.06495415f, 0.02009958f, 0.03444321f, 0.00942879f, 0.03186188f, 
    -0.32672825f, -0.09860402f, 0.17874354f, -0.04497233f, -0.01349468f, 0.08423011f, -0.04352890f, -0.04705105f, 
    -0.03994137f, -0.07037743f, -0.14571217f, 0.01236420f, -0.39788282f, -0.05319701f, -0.01036187f, -0.20411997f, 
    -0.02668990f, -0.20090398f, -0.14255388f, -0.01600851f, 0.00639344f, -0.02446465f, -0.04723795f, -0.06411587f, 
    0.04185898f, -0.05048901f, -0.01215694f, 0.11379489f, 0.01385532f, -0.03093866f, 0.00837704f, 0.08141829f, 
    -0.00539647f, -0.02946346f, -0.02135641f, -0.02776229f, -0.01993781f, 0.04990492f, -0.07477325f, 0.02864608f, 
    -0.14347823f, 0.03508948f, -0.00467873f, 0.03842246f, 0.00255999f, -0.00692973f, 0.07296694f, -0.06300745f, 
    -0.07762781f, 0.08547188f, 0.09696805f, 0.08587850f, 0.13618800f, 0.05025176f, -0.01462770f, 0.04452611f, 
    -0.00363400f, -0.05293402f, -0.10442035f, -0.07887468f, -0.07725871f, -0.00289195f, 0.01104191f, 0.10944976f, 
    -0.02247077f, 0.00246078f, 0.06548002f, 0.08233359f, 0.04473017f, -0.08930503f, -0.09388391f, 0.12659281f, 
    -0.06949484f, -0.01054990f, -0.02031424f, 0.00115471f, 0.00882956f, 0.01186587f, 0.00345603f, 0.06380826f, 
    -0.12833352f, 0.06534988f, 0.01886896f, -0.00652937f, -0.12514137f, -0.19127256f, 0.34725365f, -0.28681445f, 
    -0.02368158f, -0.01816022f, 0.09419626f, -0.02525906f, 0.02081636f, -0.09641565f, 0.08546007f, 0.00371932f, 
    -0.17951149f, 0.17801139f, -0.20385456f, -0.11674019f, 0.11357106f, 0.02378722f, -0.11606535f, 0.01568674f, 
    -0.03780300f, 0.04083633f, -0.00430427f, -0.09595767f, -0.10214346f, 0.05433514f, 0.34746042f, -0.00811971f, 
    -0.03738135f, 0.05494487f, 0.01766042f, -0.01250404f, -0.00083612f, -0.04796243f, -0.02964228f, 0.06780335f, 
    -0.00301594f, -0.15181759f, 0.07993217f, -0.23861498f, -0.01099242f, -0.03219180f, -0.06886048f, 0.08502859f, 
    0.04932152f, -0.08618137f, 0.17378446f, -0.17763589f, -0.04871247f, -0.00552895f, 0.00289015f, 0.13119712f, 
    -0.01839688f, -0.01045462f, 0.05117946f, 0.04021090f, -0.08954899f, 0.10123665f, 0.03159234f, -0.06593319f, 
    -0.21792045f, 0.24800946f, -0.33620402f, -0.02479950f, 0.01156813f, -0.07881162f, -0.01284943f, 0.12879930f, 
    -0.02785182f, -0.02813709f, 0.02004777f, -0.04173203f, -0.02769418f, -0.10181326f, -0.01170653f, -0.05852875f, 
    -0.19230039f, 0.08050566f, 0.02238793f, -0.02490116f, -0.00873060f, -0.00541351f, -0.03437362f, 0.00159625f, 
    -0.16329148f, -0.01375933f, -0.00021411f, -0.05663182f, -0.03580159f, -0.10081896f, 0.12774713f, 0.03448005f, 
    0.00616757f, -0.06735671f, -0.05182805f, 0.02580468f, -0.11481989f, 0.14632452f, -0.47205293f, 0.26350093f, 
    -0.22161783f, 0.05095610f, -0.17418309f, 0.10383520f, -0.01016852f, -0.01323619f, 0.01018174f, 0.00624157f, 
    -0.29405856f, 0.45085409f, 0.14477649f, -0.00475647f, -0.04364792f, 0.07412376f, -0.10135532f, -0.07385712f, 
    0.01649124f, 0.05635590f, -0.14511825f, 0.06702805f, -0.12900627f, 0.11664942f, -0.02968681f, 0.00039773f, 
    0.10292900f, -0.05542733f, 0.02924439f, 0.01502692f, -0.04589093f, 0.05177442f, -0.03790478f, -0.05268447f, 
    -0.26337007f, -0.17867285f, 0.05194842f, -0.01851950f, 0.02318856f, -0.09214228f, -0.11598945f, -0.23492981f, 
    0.08560877f, -0.04699221f, -0.01794613f, -0.00274572f, 0.37415981f, 0.21488267f, -0.04047941f, -0.01893581f, 
    -0.01034348f, 0.05975498f, -0.00582918f, 0.10643356f, -0.14236794f, 0.09964059f, -0.04269962f, -0.00833346f, 
    -0.12024044f, -0.02237226f, 0.07445160f, -0.12467103f, 0.00930753f, -0.05024167f, -0.01503065f, -0.14404416f, 
    0.10318308f, 0.03969280f, 0.04511768f, -0.01264773f, -0.35315582f, 0.02930856f, 0.13440457f, -0.00852183f, 
    0.00384841f, 0.05529592f, -0.03430322f, 0.00568421f, 0.05025504f, -0.06100407f, 0.07900725f, -0.04233645f, 
    -0.37331757f, -0.01999445f, -0.03049738f, 0.12346885f, -0.15412009f, 0.04460324f, 0.02343101f, -0.25467581f, 
    -0.00376591f, 0.07989085f, -0.05772054f, 0.04083312f, 0.08237056f, -0.11024594f, -0.09052311f, 0.11743676f, 
    0.11239818f, 0.13521576f, -0.01942813f, 0.27001411f, 0.13768612f, 0.00299982f, 0.05754908f, 0.00363991f, 
    0.17926414f, -0.05266089f, 0.08840679f, -0.13162026f, -0.07076421f, -0.02577316f, -0.05117305f, -0.08446485f, 
    0.12024260f, 0.30360129f, -0.03623854f, 0.11725689f, 0.22131094f, -0.14446560f, -0.23766947f, -0.23631477f, 
    -0.05273675f, 0.04780607f, 0.05776111f, -0.00912374f, 0.07541133f, -0.04347033f, -0.12382393f, 0.24792227f, 
    -0.05175773f, 0.04626790f, -0.03354230f, 0.07181084f, -0.09476054f, 0.01099084f, 0.10419247f, -0.04744576f, 
    0.03603150f, -0.04242457f, 0.04659325f, 0.00378924f, -0.05462161f, 0.07901834f, -0.03934406f, -0.04464788f, 
    0.02492375f, -0.00366605f, -0.02177519f, -0.05216318f, 0.11926354f, 0.11380529f, 0.10252848f, 0.12852927f, 
    -0.05509551f, 0.01147914f, -0.06450805f, -0.02494668f, -0.03393757f, -0.03218386f, -0.06430400f, -0.00241637f, 
    0.10118714f, 0.16302605f, 0.02659497f, 0.12581427f, 0.24635479f, 0.08692908f, -0.36059275f, 0.13153443f, 
    0.19897789f, 0.01223177f, -0.09762110f, -0.05425159f, 0.06255926f, -0.03047081f, 0.01547035f, 0.08544095f, 
    -0.08706550f, 0.33000350f, -0.01623180f, 0.12490495f, -0.05476005f, 0.03739129f, 0.12573113f, -0.05430014f, 
    0.06219444f, 0.10185920f, -0.00855347f, -0.01303175f, -0.61897969f, -0.39889628f, 0.03094783f, -0.15843140f, 
    -0.07097880f, 0.00955463f, 0.04285616f, -0.15839964f, 0.00694021f, -0.01412788f, -0.08280888f, -0.03224565f, 
    -0.63564134f, -0.45858017f, -0.19596428f, -0.26535100f, -0.00518090f, 0.00674505f, -0.13357922f, -0.04792430f, 
    -0.01785717f, -0.05536952f, -0.00524238f, 0.01748783f, -0.08851990f, -0.06972513f, -0.16372417f, -0.07565633f, 
    0.02003022f, -0.02071708f, -0.03793344f, 0.05208196f, 0.01702314f, -0.04755460f, -0.14782602f, 0.16015752f, 
    0.30796036f, -0.02497747f, -0.14133625f, 0.11931581f, -0.03814714f, 0.13439867f, 0.01040818f, 0.08568996f, 
    0.00964009f, -0.01888846f, 0.02043370f, -0.00357556f, -0.20067091f, 0.12494262f, 0.36897767f, -0.12545931f, 
    -0.02979315f, -0.03992580f, 0.10870627f, 0.05826243f, -0.04201940f, -0.02015871f, 0.01185744f, -0.03567421f, 
    0.14701058f, 0.29426682f, 0.08307400f, 0.04418248f, 0.01766480f, 0.10232973f, -0.00340342f, -0.01477578f, 
    -0.09984443f, -0.05829227f, -0.11772989f, 0.05578081f, 0.29530534f, 0.36563677f, 0.04134548f, 0.22512999f, 
    0.00416229f, -0.00948577f, 0.11422820f, -0.04637426f, -0.12483609f, -0.01273165f, -0.03142866f, 0.05148880f, 
    -0.02768963f, -0.00361556f, 0.01076335f, 0.04655838f, -0.13882375f, 0.02432469f, 0.09309993f, -0.15650353f, 
    0.00357201f, -0.02833616f, -0.06859455f, -0.00303946f, 0.03023147f, -0.11314399f, -0.07251239f, 0.04056403f, 
    -0.00835356f, -0.00277695f, 0.03900786f, 0.01790931f, 0.06597900f, 0.02519651f, 0.00369803f, 0.07308040f, 
    -0.33745819f, 0.44557449f, 0.56688917f, 0.04538213f, -0.04755768f, 0.04264113f, 0.08369429f, -0.03817539f, 
    0.02760383f, -0.03120450f, 0.04178502f, 0.00749909f, 0.11160791f, 0.15933904f, 0.37650952f, 0.27457532f, 
    -0.13778032f, 0.09834467f, -0.10430973f, 0.16861184f, -0.01663290f, 0.03623172f, 0.00493123f, 0.02509729f, 
    -0.40164703f, -0.30558699f, -0.14012170f, 0.02522524f, 0.09542464f, -0.01806066f, 0.00630687f, 0.06424441f, 
    -0.06010158f, 0.00755311f, 0.03093901f, -0.01314228f, -0.09691110f, -0.14270949f, -0.06653461f, 0.07952271f, 
    -0.03083100f, 0.00057248f, -0.04887007f, 0.04731101f, 0.09679762f, -0.15253448f, -0.03948249f, -0.17342603f, 
    0.00669731f, -0.10857457f, 0.00061144f, 0.05420802f, -0.05723465f, -0.09555490f, -0.07253325f, 0.00421879f, 
    0.08188087f, 0.01550670f, 0.03058281f, -0.01125169f, 0.09505433f, -0.14728355f, -0.23949639f, 0.17473689f, 
    0.13738552f, 0.12505016f, -0.05928645f, -0.01704056f, 0.04601043f, 0.07406811f, -0.04043326f, -0.01118284f, 
    -0.11550198f, -0.02796564f, -0.00008753f, 0.03386658f, -0.07207969f, -0.08763602f, 0.11088569f, -0.22468479f, 
    -0.01770669f, -0.05394858f, 0.05220657f, 0.00008829f, -0.22484761f, 0.32818750f, -0.12500331f, 0.01145568f, 
    -0.10111438f, 0.05087527f, 0.03812383f, 0.11887915f, -0.03075670f, 0.03206085f, -0.01756090f, -0.03649228f, 
    0.20083514f, -0.31821308f, -0.16830523f, 0.08963966f, 0.05478954f, -0.06324248f, 0.01194203f, -0.03905781f, 
    -0.09520350f, -0.11254340f, -0.09925627f, 0.12276620f, -0.01528265f, -0.02914118f, 0.27079520f, 0.01517036f, 
    0.07250720f, -0.02208104f, -0.01448600f, 0.09643840f, 0.03446847f, -0.07543787f, 0.13943265f, -0.03435376f, 
    -0.25830606f, 0.31052992f, 0.11115960f, 0.02467499f, -0.01165683f, 0.19301830f, -0.04243090f, -0.15730321f, 
    -0.01432777f, 0.08107009f, 0.00183068f, 0.13573821f, -0.27700561f, 0.08125401f, -0.13566987f, 0.21581975f, 
    0.11529504f, 0.14343640f, -0.08006404f, -0.01740250f, -0.00958273f, -0.00374260f, -0.03331654f, -0.04274588f, 
    -0.70635575f, -0.52086651f, 0.01135762f, -0.12266404f, -0.24970423f, 0.10602827f, -0.06691615f, -0.03280403f, 
    -0.01066602f, 0.03037980f, -0.05400925f, -0.02425553f, -0.15556757f, -0.12081368f, 0.07935812f, -0.06347159f, 
    -0.03289801f, -0.05199587f, -0.11738579f, -0.02746077f, 0.06911368f, -0.01120721f, -0.20020017f, 0.14505446f, 
    0.06869882f, 0.57177216f, 0.45603675f, 0.19218607f, -0.00060300f, 0.04272428f, 0.01277366f, -0.08592624f, 
    0.07756445f, -0.05840898f, -0.13326551f, 0.06813499f, -0.19506478f, 0.05426524f, -0.15371881f, -0.10380702f, 
    0.06895718f, -0.10669995f, 0.04804020f, 0.03298692f, -0.00770803f, 0.04544818f, 0.02141999f, -0.04698962f, 
    -0.03402862f, -0.03903537f, -0.22582401f, -0.18080780f, 0.23522916f, 0.09117462f, 0.07703605f, -0.24596193f, 
    -0.09531451f, -0.00245849f, -0.07747939f, 0.02112057f, -0.35891885f, -0.08986491f, -0.05001000f, 0.28306091f, 
    0.01910076f, 0.00173068f, 0.17327362f, -0.06376509f, -0.03883543f, 0.01401540f, -0.06678137f, 0.08871693f, 
    -0.12077653f, -0.21772785f, 0.30545846f, 0.14881486f, -0.06840049f, -0.03422830f, -0.04414606f, 0.04825065f, 
    0.01107306f, 0.15569064f, -0.17072673f, 0.04619761f, 0.29185909f, 0.04334145f, 0.01358756f, -0.38855931f, 
    -0.06533396f, -0.07911238f, -0.01177490f, -0.15532877f, -0.09652966f, -0.00194353f, 0.01811400f, -0.09707586f, 
    0.00344517f, -0.24234106f, -0.10425812f, 0.10053597f, 0.10896765f, 0.13516764f, 0.01521544f, 0.05428346f, 
    0.09069479f, -0.01640945f, 0.07248454f, -0.08581798f, -0.08421244f, 0.03573398f, 0.01179406f, 0.11808462f, 
    0.16130614f, 0.08064298f, -0.02641876f, 0.03539597f, -0.12263202f, -0.06899041f, 0.06376106f, -0.20709892f, 
    0.12984103f, -0.10384520f, 0.23370443f, 0.15455285f, -0.12317057f, 0.01807602f, 0.00668103f, 0.09569238f, 
    -0.00164778f, -0.03542151f, 0.06659670f, 0.07902000f, -0.10281898f, -0.08325984f, -0.06697591f, 0.21284936f, 
    -0.09148936f, -0.07707259f, 0.00059555f, -0.03325824f, -0.06101231f, 0.09556022f, 0.00475823f, -0.01427388f, 
    -0.32555196f, 0.08235025f, 0.11928471f, 0.13068192f, 0.12250198f, -0.15464917f, 0.03480256f, -0.21487807f, 
    -0.01850619f, 0.10460211f, 0.10879957f, -0.06687791f, -0.32681292f, -0.06902409f, 0.06188455f, 0.37293157f, 
    0.04847442f, -0.07296428f, -0.01215944f, -0.07784961f, 0.02065630f, -0.10646430f, 0.09931666f, -0.12219073f, 
    -0.19187608f, 0.19781163f, 0.04237498f, -0.20730300f, 0.30159900f, 0.18968125f, 0.07622448f, 0.06169938f, 
    -0.17750005f, -0.02916986f, -0.03769914f, -0.06416022f, -0.33263871f, 0.41225943f, -0.15556186f, 0.11045578f, 
    -0.00496306f, 0.03766420f, -0.03270596f, -0.15544544f, -0.04014809f, -0.03884696f, -0.03429067f, -0.00416789f, 
    0.25612023f, -0.00434174f, -0.00271778f, 0.23290992f, -0.02070593f, -0.02510255f, -0.03527867f, -0.11688602f, 
    0.05532593f, 0.06639986f, 0.11144890f, 0.05978997f, -0.19751960f, -0.09429414f, -0.06750476f, -0.29423308f, 
    0.16386186f, 0.20100932f, 0.07984321f, -0.01212447f, -0.16464548f, 0.01712528f, -0.05796793f, -0.05513512f, 
    -0.32302076f, -0.18439737f, -0.25987822f, -0.14871499f, 0.13176100f, 0.01017690f, 0.05456591f, 0.04944900f, 
    -0.07997003f, -0.11787104f, -0.00348887f, -0.12770699f, -0.20255187f, -0.25901538f, 0.32555583f, -0.16790733f, 
    -0.28573191f, -0.05742696f, -0.26870504f, 0.07683478f, 0.08455542f, 0.03727172f, -0.04206533f, -0.04585318f, 
    -0.26406753f, 0.24708712f, -0.07779048f, 0.16782178f, 0.06760470f, 0.17976314f, 0.07211848f, 0.03173266f, 
    -0.19762111f, 0.03897470f, -0.04085733f, 0.12946719f, -0.31699082f, 0.74220699f, -0.08717619f, -0.04565600f, 
    0.22163901f, -0.04822197f, -0.05453717f, -0.16592459f, -0.30773875f, 0.09753314f, 0.07047199f, -0.01696238f, 
    -0.00386280f, -0.03977173f, 0.05385805f, -0.26822942f, -0.06971330f, 0.19433323f, -0.16655350f, -0.05319981f, 
    0.02533726f, 0.04632531f, -0.00989338f, 0.06999457f, 0.02765216f, -0.09857719f, -0.08278843f, -0.06742059f, 
    0.01677605f, 0.00386847f, 0.02084653f, 0.02857143f, 0.02603479f, 0.08188244f, -0.13966599f, 0.00230273f, 
    -0.21952753f, 0.57179421f, -0.12399711f, 0.67567772f, 0.07256651f, -0.00687016f, 0.13092884f, -0.05749411f, 
    0.11313672f, 0.01123072f, -0.03119363f, 0.04196560f, 0.04612175f, -0.09246228f, 0.04323459f, 0.00377717f, 
    0.01673558f, -0.10724796f, 0.08982074f, -0.08516375f, -0.06177434f, 0.06275944f, -0.04537515f, -0.12638220f, 
    -0.01908722f, -0.03372017f, 0.35042417f, 0.22042158f, -0.04003736f, -0.25334775f, 0.08965912f, 0.04011978f, 
    0.06192176f, 0.03805001f, 0.06946191f, 0.07311314f, -0.01789182f, 0.03361865f, -0.26781207f, -0.05649618f, 
    -0.07862399f, -0.16220395f, 0.06503084f, 0.05850957f, -0.05620000f, 0.10709778f, -0.09428973f, -0.01854380f, 
    -0.34599242f, 0.01871531f, 0.03950642f, 0.33418530f, -0.01214857f, -0.03771814f, -0.01128435f, -0.09397131f, 
    -0.01118806f, -0.02874666f, 0.22635384f, 0.01631231f, -0.15369862f, -0.29098281f, 0.01672333f, -0.23345710f, 
    -0.07644715f, 0.00144693f, -0.18926395f, -0.15447934f, 0.01713513f, -0.17697440f, -0.11208263f, 0.09985186f, 
    0.04270917f, -0.24065495f, 0.07342874f, 0.11651871f, 0.04876621f, 0.14971183f, -0.07300208f, 0.10890359f, 
    0.07431747f, -0.05255514f, 0.12827991f, 0.03316195f, 0.48687798f, -0.00756658f, 0.08172408f, -0.22497140f, 
    -0.25951061f, -0.22441576f, -0.11751886f, -0.10782443f, -0.04866154f, 0.04886030f, -0.02657556f, 0.14239891f, 
    -0.14668879f, -0.07175182f, 0.07635596f, 0.23239394f, -0.13685459f, -0.09262927f, 0.15048383f, 0.06789817f, 
    0.04018571f, 0.15016261f, -0.16338418f, -0.03682181f, -0.39309984f, -0.08475912f, -0.21378656f, -0.15487017f, 
    -0.18705788f, 0.03875085f, -0.20221874f, -0.17802587f, 0.03034509f, 0.08943908f, -0.12606633f, -0.06716947f, 
    0.17675364f, -0.26862600f, 0.01966010f, -0.16779336f, -0.04848065f, -0.12956475f, -0.10504515f, -0.00801586f, 
    0.01840212f, 0.00453987f, 0.04782457f, -0.27216598f, 0.02648230f, 0.41292253f, -0.21552747f, -0.06472518f, 
    0.07897634f, 0.03714417f, -0.07109157f, -0.10562082f, 0.04738885f, -0.10835494f, -0.12619627f, -0.05283076f, 
    0.27298260f, -0.14306720f, 0.09744391f, -0.07026642f, -0.05015117f, -0.04544739f, -0.03699629f, -0.00954018f, 
    0.03999929f, -0.20065096f, -0.08479773f, 0.07170121f, 0.06494009f, -0.00170745f, 0.12093446f, -0.15986624f, 
    -0.16101180f, -0.11990929f, -0.19166489f, 0.00860874f, -0.17661834f, 0.00980535f, 0.06111022f, -0.03445886f, 
    -0.18838382f, 0.12892927f, -0.07279726f, 0.14770523f, 0.00858895f, -0.01639105f, -0.10419974f, -0.05936373f, 
    -0.09849674f, -0.07714035f, -0.02382777f, -0.17562507f, -0.23952408f, -0.03439670f, 0.11563752f, 0.03187782f, 
    -0.04136788f, 0.05811794f, 0.01640546f, 0.00108633f, 0.12064184f, 0.08145891f, 0.13777676f, -0.09851363f, 
    -0.23343314f, 0.11189937f, 0.08361395f, 0.21080275f, -0.01995568f, -0.04627101f, -0.03168623f, 0.02397120f, 
    -0.00789295f, -0.02444747f, 0.00416897f, 0.01687447f, 0.09407362f, -0.08493908f, -0.01265097f, -0.07953514f, 
    0.07063222f, 0.02885727f, -0.05121009f, 0.00908538f, -0.03346822f, -0.03270876f, 0.05588687f, 0.01356203f, 
    -0.21150473f, -0.05243913f, -0.05002024f, 0.37137407f, -0.02544819f, 0.06951471f, -0.17259124f, -0.09037510f, 
    -0.02892478f, -0.07601561f, -0.04324265f, 0.12637451f, 0.00164256f, -0.09828957f, -0.06507936f, 0.18381552f, 
    -0.01315539f, 0.10654282f, 0.15956479f, 0.08418164f, 0.01237176f, 0.08663339f, -0.07153625f, 0.10115522f, 
    0.15038723f, -0.22398058f, 0.05371904f, 0.03917739f, -0.00289502f, 0.03599222f, 0.03458752f, 0.05995994f, 
    -0.10319375f, 0.02708071f, -0.13780949f, -0.00939417f, -0.06246494f, 0.04499525f, 0.27079684f, -0.16687927f, 
    -0.21366125f, 0.15745562f, 0.07889836f, 0.02454997f, 0.15002123f, 0.12515606f, 0.05611740f, 0.02186673f, 
    0.00126916f, -0.05537877f, -0.13153119f, 0.13475804f, 0.04498143f, -0.08063808f, -0.11563893f, 0.02162927f, 
    0.02185769f, 0.06900237f, -0.00843932f, 0.07884449f, -0.19208521f, -0.00567030f, -0.02175584f, 0.24487816f, 
    -0.02530859f, 0.01991891f, 0.10586849f, 0.05979125f, 0.05882041f, 0.03634446f, 0.10104806f, -0.03988732f, 
    0.02298455f, 0.01728845f, 0.05184324f, 0.17458886f, 0.00420668f, -0.06722108f, -0.01526125f, -0.08379152f, 
    -0.02871980f, 0.16308273f, -0.10505787f, -0.01010012f, 0.41427791f, -0.03053458f, 0.01028031f, 0.10616197f, 
    0.09705683f, 0.11754037f, -0.01652005f, -0.20844147f, -0.06094130f, -0.02455597f, -0.01898239f, 0.08441222f, 
    0.21198690f, -0.10591078f, 0.10818449f, -0.01548010f, 0.04491536f, -0.04333797f, 0.01520508f, 0.04518530f, 
    0.08360534f, -0.14718466f, 0.12286059f, -0.05657431f, -0.07634128f, 0.10219419f, -0.27666166f, -0.12298519f, 
    0.04617964f, 0.09091683f, -0.02766104f, 0.02744996f, -0.02578484f, -0.03512139f, -0.06050661f, -0.07844648f, 
    -0.04014846f, -0.11051757f, 0.02764733f, 0.23436040f, 0.06584572f, 0.00033858f, 0.01635741f, -0.09757937f, 
    0.07521052f, 0.05032353f, 0.00947975f, 0.14848819f, 0.08926254f, -0.19384675f, -0.00116894f, 0.17237744f, 
    0.08777457f, -0.01323824f, 0.05033740f, -0.20099787f, -0.06386141f, -0.01969836f, -0.07869177f, 0.15206739f, 
    -0.01099196f, 0.15253548f, -0.29969016f, 0.09823054f, -0.02263928f, 0.00561736f, -0.08317870f, 0.14369708f, 
    0.04138178f, 0.08937768f, 0.04342489f, -0.07222446f, -0.10290606f, 0.25065050f, -0.16574839f, -0.45692649f, 
    0.33198103f, 0.12154748f, -0.02550149f, 0.03494383f, -0.27004653f, -0.04437962f, 0.03669451f, -0.02336207f, 
    0.00961526f, -0.12431658f, -0.20369534f, 0.01238344f, 0.17756790f, 0.04717426f, -0.02646698f, 0.08054861f, 
    0.02269174f, -0.01745111f, -0.00077696f, -0.03060321f, 0.53184497f, 0.05148530f, -0.15308282f, -0.35207093f, 
    -0.06704945f, -0.05384579f, 0.00617574f, -0.16727494f, 0.10737187f, -0.05248557f, -0.02926570f, -0.05400141f, 
    0.09943678f, -0.14869587f, -0.02856707f, 0.15495721f, -0.01626124f, 0.05309024f, -0.00357758f, -0.04416071f, 
    0.07581189f, 0.03072390f, 0.11952380f, -0.11113016f, -0.35820702f, 0.41366667f, -0.42214227f, 0.31895518f, 
    -0.00082815f, -0.18864329f, 0.07748642f, -0.12223875f, -0.09373445f, 0.00093592f, 0.01934251f, 0.02456918f, 
    0.13250105f, -0.00573421f, -0.10364656f, -0.14324053f, -0.02742374f, 0.00335349f, -0.04327841f, -0.03030662f, 
    -0.05365657f, -0.00537994f, 0.00873460f, -0.10564137f, -0.48278007f, 0.39643797f, -0.12188477f, -0.01014854f, 
    0.28208214f, 0.03640866f, -0.16379459f, 0.03763404f, -0.25948733f, -0.12887539f, -0.03006595f, -0.18480198f, 
    -0.31662434f, 0.05616433f, -0.06528084f, 0.10574675f, -0.06095812f, 0.04275489f, 0.07460494f, -0.20008908f, 
    -0.05338281f, 0.08108994f, 0.06034483f, 0.04954063f, 0.21226096f, 0.02524104f, -0.04705670f, 0.09184701f, 
    0.23411012f, 0.04014937f, -0.02968673f, 0.00823639f, 0.07355494f, 0.04301501f, -0.04957157f, -0.02107242f, 
    -0.08887186f, -0.19399123f, 0.06052824f, 0.21600394f, -0.07468489f, -0.04385655f, -0.05236375f, 0.09407999f, 
    -0.01674589f, 0.07122243f, -0.19281974f, -0.00821916f, -0.22014077f, -0.20341359f, -0.00110900f, -0.05726413f, 
    -0.26382595f, -0.00415871f, -0.07816409f, -0.05513821f, -0.02263917f, 0.00051012f, -0.24081744f, -0.03947199f, 
    0.77019644f, -0.10932390f, -0.13852318f, 0.17785837f, 0.18958840f, -0.00381567f, 0.05587554f, -0.09504469f, 
    -0.13283218f, 0.01019588f, 0.03712152f, 0.10833602f, -0.39296150f, 0.53539908f, -0.18060037f, -0.58810669f, 
    0.10122630f, 0.14590888f, -0.10698991f, -0.03435932f, -0.24386887f, 0.05461716f, -0.01202297f, 0.09000771f, 
    -0.04991223f, 0.04060463f, 0.00569541f, -0.05539336f, 0.01023552f, -0.17720051f, -0.05327779f, -0.00863509f, 
    0.16110143f, -0.12373703f, -0.15247144f, 0.01065052f, 0.09693462f, 0.09409975f, 0.08359115f, 0.03765332f, 
    0.05904549f, -0.01489750f, 0.00392176f, -0.00023708f, -0.04034294f, -0.00351671f, 0.07879354f, 0.06159665f, 
    0.06423336f, 0.13000004f, -0.02626346f, 0.03579847f, 0.00150212f, -0.08294612f, -0.10382117f, 0.14720105f, 
    0.02961795f, -0.03402916f, 0.01937325f, -0.08078738f, 0.12335055f, -0.08586488f, -0.20944503f, 0.26060408f, 
    0.00062937f, -0.07752701f, -0.11349270f, -0.06825990f, 0.19311890f, 0.14672799f, 0.15341842f, 0.31480521f, 
    0.16807711f, 0.16553646f, 0.34126380f, 0.23992020f, -0.27538368f, -0.14177972f, -0.01704446f, 0.14212233f, 
    0.10951625f, 0.03083415f, 0.03457371f, 0.03141366f, -0.23023771f, -0.23158629f, -0.21265389f, -0.41332731f, 
    0.04217120f, 0.05073475f, -0.00596878f, 0.00070450f, 0.10648818f, -0.04148507f, -0.00495058f, 0.00814250f, 
    -0.01765984f, 0.05299898f, -0.17417133f, 0.01088045f, 0.05421824f, -0.01027906f, 0.03486783f, 0.02016728f, 
    0.02317805f, 0.06574289f, -0.04987577f, 0.04823837f, -0.12848236f, 0.07136659f, -0.01831855f, 0.04705788f, 
    -0.02078656f, -0.18269065f, -0.04335787f, -0.13494547f, 0.06174380f, -0.01085211f, 0.06614758f, -0.03008678f, 
    0.04739889f, 0.00200723f, -0.10796417f, -0.03419422f, 0.02661664f, -0.06729598f, 0.00576840f, 0.05194326f, 
    -0.09299863f, -0.05823434f, -0.16649769f, 0.06450308f, 0.10674021f, -0.02340686f, -0.15511020f, -0.04299647f, 
    0.12194680f, -0.02501276f, -0.01409773f, -0.11264993f, -0.01868900f, 0.00047191f, 0.10339832f, -0.07709267f, 
    0.08481745f, 0.01766300f, 0.02945989f, 0.07691240f, -0.02466573f, -0.06195244f, 0.01412174f, 0.02236062f, 
    0.06079300f, 0.10009187f, -0.20246537f, 0.07205780f, -0.17094529f, -0.20280094f, 0.16978282f, 0.05641871f, 
    0.02331753f, 0.06005202f, -0.07382965f, -0.05405416f, -0.12431810f, -0.03870643f, -0.04542153f, -0.02125562f, 
    -0.03161130f, 0.06260533f, 0.02487488f, 0.04020743f, 0.08175239f, 0.02412725f, -0.14889872f, -0.04577304f, 
    0.01216659f, -0.07666923f, -0.06477242f, 0.02967698f, 0.14946523f, 0.04145632f, -0.19624214f, -0.00544527f, 
    0.01465318f, -0.02321260f, 0.03882916f, 0.06018903f, 0.09666933f, -0.05297422f, -0.15224527f, -0.04446922f, 
    0.09535152f, 0.00974124f, -0.01065554f, -0.00118673f, 0.08315636f, 0.06302361f, 0.00955299f, 0.05582426f, 
    -0.09078504f, -0.04922773f, -0.03097658f, 0.00765920f, 0.45033500f, -0.36333728f, -0.15386863f, 0.17274915f, 
    -0.00455729f, 0.04092925f, 0.08545975f, -0.09180773f, 0.09826447f, -0.01473666f, -0.01289564f, 0.01077923f, 
    -0.09715164f, -0.21827877f, 0.16363078f, 0.09858675f, 0.14519596f, 0.03996586f, 0.01324312f, -0.07524607f, 
    0.03836723f, 0.05265208f, -0.03890616f, 0.04273171f, -0.00948176f, -0.58517957f, 0.00244849f, -0.03907926f, 
    -0.06086479f, 0.03723289f, -0.08931082f, 0.02911939f, 0.02587555f, -0.16882907f, -0.11186031f, 0.08102801f, 
    0.44263929f, -0.18862870f, -0.04124919f, -0.12858965f, 0.05445057f, -0.17204012f, 0.11386858f, -0.09463524f, 
    0.10913164f, -0.05555730f, -0.00457399f, 0.01930117f, -0.02155100f, 0.00390218f, 0.00495937f, -0.06815808f, 
    0.02412948f, -0.03210696f, 0.03537821f, 0.03422684f, -0.01382508f, -0.14177446f, -0.19858222f, -0.02656162f, 
    0.15109167f, -0.16761050f, -0.07225601f, -0.07220057f, 0.20529930f, 0.06536052f, -0.00180290f, 0.12051605f, 
    0.00688729f, 0.00538805f, -0.03019784f, -0.08175039f, 0.01876043f, 0.04996136f, 0.01638047f, 0.03684207f, 
    0.03770606f, -0.02757858f, 0.01328235f, 0.05696642f, -0.02439998f, -0.01366693f, -0.07936222f, -0.11472397f, 
    0.13703352f, 0.10876537f, 0.06329137f, 0.11891630f, -0.07336138f, 0.05855926f, -0.07218575f, 0.01400943f, 
    0.07753255f, -0.00067581f, 0.05288141f, -0.03736480f, 0.16087684f, -0.17041403f, 0.29801142f, 0.13363850f, 
    -0.09953158f, 0.10399352f, -0.26429158f, -0.17911234f, -0.17519854f, -0.06198434f, -0.00090195f, 0.01710180f, 
    -0.14499478f, 0.02724939f, 0.05505010f, -0.08622869f, -0.01730662f, -0.03937029f, -0.12270851f, -0.12563002f, 
    -0.03181079f, -0.01597507f, -0.06415245f, 0.07611129f, -0.03514764f, 0.07631722f, -0.08459827f, -0.03797784f, 
    0.09246653f, 0.02534873f, 0.04586970f, -0.04393322f, -0.02952141f, -0.06499028f, -0.11197947f, 0.04031039f, 
    -0.02706806f, 0.19741450f, 0.26905066f, 0.20048502f, 0.03427111f, 0.11254061f, 0.13458155f, 0.09605714f, 
    0.04830505f, -0.05637854f, -0.02798995f, 0.01672487f, -0.29265007f, -0.18624425f, -0.30747706f, -0.04615722f, 
    -0.06665248f, -0.08776739f, 0.03391490f, 0.00717485f, -0.02594282f, -0.06989925f, -0.10971519f, -0.14195551f, 
    0.02859144f, 0.19046815f, 0.04263822f, 0.11418157f, 0.08119391f, 0.01310122f, -0.13247468f, -0.02644754f, 
    -0.08184198f, 0.17944504f, 0.02681005f, -0.02994573f, -0.32322514f, -0.30417147f, -0.13771558f, 0.03330980f, 
    -0.03033456f, -0.09472314f, 0.11719779f, 0.10333104f, 0.05814685f, 0.03441813f, -0.02337725f, -0.04730010f, 
    -0.10392004f, -0.04952427f, 0.11400162f, 0.13641275f, -0.27785259f, 0.02175144f, -0.07534478f, 0.11758506f, 
    -0.04997848f, -0.03811651f, -0.04200959f, 0.04195262f, 0.00211835f, -0.26305768f, 0.24584046f, -0.00142407f, 
    -0.24412209f, 0.03181084f, -0.19956814f, -0.01468730f, -0.16634405f, 0.02129977f, 0.01211321f, -0.10709034f, 
    0.06814068f, -0.02811894f, -0.44623613f, 0.20704453f, 0.03567597f, -0.09541163f, -0.04029325f, -0.11265167f, 
    -0.00280033f, -0.21773759f, 0.20817620f, 0.11830214f, 0.02150014f, -0.26758465f, -0.15463461f, -0.05114146f, 
    0.03369598f, 0.07786522f, -0.05178387f, -0.02019613f, 0.01456577f, -0.10913930f, 0.09972780f, -0.32991618f, 
    0.06072267f, -0.07172630f, 0.11717866f, 0.01816613f, -0.00007360f, -0.05484660f, -0.04131567f, 0.19428293f, 
    0.01805722f, -0.03996647f, 0.00029219f, -0.12437204f, -0.02866320f, 0.00572930f, -0.07075180f, -0.03589636f, 
    -0.00685757f, -0.03328345f, 0.01638012f, -0.08236381f, -0.03283033f, 0.02290532f, -0.01051770f, 0.20003854f, 
    0.03667251f, 0.01320348f, 0.04946629f, 0.05760021f, 0.00547124f, -0.02765623f, 0.02490936f, -0.07549147f, 
    0.21266794f, 0.06800352f, 0.14981423f, 0.33044305f, 0.13958420f, 0.15463175f, -0.00437858f, 0.19422384f, 
    -0.09658023f, -0.03981670f, 0.08252895f, -0.27822441f, -0.00330322f, -0.04436389f, 0.06392013f, 0.00086753f, 
    -0.11785277f, -0.03198368f, 0.18688162f, -0.01653782f, 0.00655903f, 0.00365931f, -0.06740691f, -0.09469952f, 
    0.03397415f, -0.04675946f, -0.01668355f, -0.07148839f, 0.12180775f, 0.19988613f, 0.22648554f, 0.12899058f, 
    0.00943429f, -0.08096721f, -0.04107300f, 0.06993632f, -0.00474954f, -0.05556931f, 0.11370181f, 0.03406423f, 
    -0.02314989f, -0.04379420f, 0.05651733f, 0.17016864f, 0.01060853f, -0.01419047f, 0.14309964f, -0.02269599f, 
    0.02451495f, -0.02160409f, 0.02661953f, 0.01086059f, 0.33981407f, -0.10688999f, -0.13552423f, 0.21033713f, 
    0.02327061f, -0.02999062f, 0.04465197f, -0.01557867f, 0.15820932f, -0.02616897f, 0.02441529f, 0.05934822f, 
    -0.00117036f, 0.08435637f, 0.14574382f, -0.03023452f, -0.15187867f, -0.20321165f, 0.04288058f, -0.14695156f, 
    0.00133135f, -0.04082999f, -0.02685787f, -0.07772153f, -0.06304700f, 0.04247481f, 0.08285710f, 0.03932733f, 
    -0.01527979f, -0.04376062f, -0.14174114f, -0.10158090f, -0.01521534f, -0.00259001f, -0.06775072f, -0.01634884f, 
    0.21275443f, 0.09453440f, 0.12030524f, 0.11127053f, -0.08567694f, -0.10516784f, -0.06275243f, -0.13442861f, 
    -0.04046696f, -0.17347592f, -0.05599447f, 0.01344345f, -0.15666132f, 0.00269875f, -0.00605057f, 0.06655148f, 
    -0.10290089f, -0.14134546f, 0.01628907f, -0.12562998f, 0.07424631f, 0.01626684f, 0.08986514f, 0.20296657f, 
    -0.02815923f, 0.00351728f, -0.02566720f, 0.10017686f, -0.09589219f, 0.02375515f, -0.14024469f, 0.09609917f, 
    0.00921304f, -0.07073710f, -0.00462952f, 0.00892051f, -0.02156517f, -0.24871194f, -0.15277739f, 0.01427925f, 
    0.00637622f, -0.01283009f, 0.10241444f, 0.03834853f, 0.09827078f, -0.06335653f, 0.02029850f, 0.02062318f, 
    -0.32092255f, 0.07970855f, 0.05009991f, 0.04116729f, -0.06533273f, -0.03169862f, -0.06889572f, -0.05760413f, 
    -0.03934396f, -0.01735115f, 0.02899326f, 0.12199725f, -0.05327955f, 0.18922746f, 0.08737312f, 0.17178130f, 
    -0.08019672f, -0.11224049f, 0.00091260f, 0.04520342f, 0.01267935f, 0.04182916f, 0.05670085f, 0.05183479f, 
    -0.07680998f, 0.00283518f, 0.16566049f, -0.07736593f, -0.07605563f, 0.11534329f, -0.08347745f, 0.01618620f, 
    -0.11637060f, 0.01443596f, 0.01814413f, 0.09910134f, 0.18117727f, -0.05103828f, 0.08485101f, 0.04840436f, 
    0.05095059f, 0.11674923f, 0.02747612f, 0.05637843f, -0.09502919f, 0.01630651f, -0.17020497f, -0.14800069f, 
    0.07696004f, 0.02747084f, 0.15775456f, 0.04801976f, -0.06275306f, -0.08528675f, -0.05045309f, -0.08911032f, 
    0.07003553f, 0.03961019f, 0.00565278f, 0.02735480f, -0.32020935f, -0.07452570f, -0.17781535f, -0.12402528f, 
    -0.21015412f, -0.11155149f, 0.15028396f, 0.08462156f, -0.08141696f, -0.10131114f, -0.10354586f, -0.15604578f, 
    0.03757937f, -0.02590536f, 0.06447467f, 0.08903535f, -0.15629679f, 0.03601592f, -0.09804405f, 0.09634327f, 
    0.05060850f, 0.00593899f, -0.01913495f, -0.00295614f, 0.02828190f, -0.28948548f, 0.54429495f, 0.00600736f, 
    -0.05799934f, 0.12836562f, -0.25123516f, 0.10180154f, -0.14268272f, 0.02940984f, -0.05292182f, 0.02364435f, 
    0.13060357f, 0.14415933f, 0.13318180f, 0.25871122f, -0.03028833f, -0.07533382f, -0.11021798f, -0.04404830f, 
    -0.04492539f, -0.06307322f, 0.03223798f, -0.01300673f, 0.05716264f, -0.37774715f, -0.20887099f, -0.06648988f, 
    -0.11243880f, -0.03568656f, 0.01157022f, 0.02185534f, 0.11615035f, -0.00791819f, -0.11593210f, 0.04075208f, 
    -0.12386554f, -0.15698402f, -0.07573048f, -0.08899902f, -0.00953309f, -0.00884202f, -0.05768962f, 0.06822834f, 
    -0.10979515f, -0.08256974f, 0.01215227f, -0.01066093f, 0.21304819f, 0.05336089f, 0.00300839f, -0.06449061f, 
    -0.12421004f, -0.04987165f, -0.06787293f, -0.03471959f, -0.00975202f, -0.11811479f, -0.24092036f, -0.01946183f, 
    -0.01857765f, 0.03299409f, -0.02386923f, 0.09169517f, 0.02903093f, -0.11277485f, -0.00941291f, -0.08591908f, 
    -0.04648252f, 0.00730106f, 0.02240105f, -0.03452567f, -0.02901333f, 0.03202186f, 0.04924930f, 0.00784000f, 
    0.07500692f, 0.14134488f, -0.01258693f, -0.02477808f, 0.05881363f, -0.01059393f, 0.01484592f, 0.00478918f, 
    -0.18852107f, -0.02286497f, 0.06928274f, 0.09608435f, -0.15259141f, -0.04588609f, -0.06344879f, 0.19267298f, 
    0.01627782f, 0.01935057f, -0.01617093f, -0.02920292f, -0.07004437f, -0.19670431f, 0.22206609f, -0.11878357f, 
    0.04649864f, 0.01702892f, 0.00513719f, -0.06430464f, -0.26525724f, -0.03355397f, -0.06100014f, -0.04383412f, 
    0.11545125f, -0.15668073f, 0.00643786f, -0.02121033f, -0.07504635f, 0.01060642f, 0.09276900f, 0.09754637f, 
    -0.00491176f, 0.06840350f, 0.14099339f, -0.02171057f, 0.09421628f, -0.08343098f, -0.12551764f, -0.10331038f, 
    -0.00860012f, -0.00940782f, -0.05297561f, 0.13864614f, -0.04762747f, -0.21022567f, 0.04068504f, -0.30955595f, 
    0.14956437f, 0.06122476f, -0.60939711f, 0.28619218f, 0.12820138f, 0.08821004f, 0.00162128f, -0.01407532f, 
    0.02122567f, -0.02753449f, 0.02477936f, 0.03232837f, -0.70616442f, 0.26095048f, 0.49023053f, -0.07749568f, 
    0.05314302f, -0.00252065f, 0.06686882f, -0.03062036f, 0.11792105f, -0.40834531f, -0.20051208f, -0.24450517f, 
    0.13797644f, 0.11885539f, -0.14301728f, -0.00863035f, 0.23336160f, 0.21504056f, 0.06717332f, -0.03698313f, 
    0.07851307f, 0.02174404f, -0.01858960f, 0.06777195f, 0.22799613f, -0.12201632f, -0.35853264f, 0.08313372f, 
    -0.02802209f, -0.05493907f, 0.05661882f, -0.01946296f, 0.04436794f, 0.09281635f, 0.00582286f, 0.24299529f, 
    -0.17585757f, 0.32035923f, -0.15189955f, -0.09354569f, -0.01050793f, 0.02627035f, -0.01286858f, 0.07832471f, 
    0.04746751f, -0.04817821f, -0.00616964f, -0.09702347f, -0.05410826f, 0.16816717f, -0.15006770f, -0.18152732f, 
    0.04599045f, 0.10670938f, 0.18358368f, 0.20645782f, -0.02464396f, -0.04446366f, 0.13407928f, 0.01600374f, 
    -0.09366000f, -0.12745467f, 0.07428528f, -0.28192967f, 0.05371108f, 0.03200021f, -0.04315532f, 0.00754980f, 
    0.10206643f, 0.08286983f, 0.05669252f, -0.10941431f, -0.14918481f, 0.13703467f, -0.19073352f, -0.06716198f, 
    0.12033914f, 0.11020974f, -0.01285960f, -0.10686202f, 0.10652500f, -0.02594974f, -0.04584092f, -0.03760057f, 
    -0.08823119f, -0.11795706f, -0.12002582f, 0.07959045f, 0.02436684f, -0.00732972f, -0.09974658f, 0.01523261f, 
    0.06036631f, 0.06949956f, 0.03910980f, -0.05273862f, 0.15597190f, 0.15649202f, 0.13640411f, -0.12149374f, 
    0.03261900f, -0.00877800f, 0.00522342f, 0.10128699f, 0.04674558f, 0.08181944f, -0.07784031f, 0.01589797f, 
    -0.17306355f, -0.02330187f, -0.00773360f, -0.03396723f, -0.24852505f, 0.01014020f, 0.00306378f, -0.10205977f, 
    0.10277630f, 0.11878499f, 0.12413701f, 0.02787616f, -0.42142984f, -0.58102810f, 0.03475841f, 0.00590969f, 
    0.00192275f, -0.01182724f, -0.01825283f, 0.00251906f, 0.04832419f, -0.10556170f, 0.22642316f, 0.10657553f, 
    -0.10877235f, -0.12896635f, -0.05132766f, 0.05181377f, -0.03259931f, -0.07756317f, -0.05740957f, 0.04449554f, 
    0.09072662f, -0.03037055f, -0.07428611f, 0.15561979f, -0.35759917f, 0.04618578f, -0.16356869f, 0.09554068f, 
    0.00594079f, 0.03040024f, -0.01267508f, 0.06527565f, 0.01555007f, 0.03409131f, -0.03170527f, -0.08342567f, 
    -0.21457350f, 0.25352952f, 0.20814770f, -0.10366466f, -0.20010033f, -0.02781477f, -0.11628831f, 0.12329081f, 
    0.04732183f, 0.02048381f, 0.03254216f, -0.08024131f, -0.35221422f, -0.04574921f, 0.12385806f, -0.30499071f, 
    0.02911634f, 0.02583726f, 0.00738666f, 0.00519007f, 0.14071986f, -0.07116627f, -0.09745461f, -0.15967698f, 
    -0.07472527f, -0.19698365f, -0.12805539f, 0.20030455f, -0.03917878f, -0.01446746f, -0.12290253f, 0.17974037f, 
    -0.13994719f, 0.06660149f, 0.03347718f, -0.05467405f, -0.03814281f, -0.15531567f, -0.09166244f, 0.12676795f, 
    -0.04251950f, -0.01383139f, -0.02841905f, -0.02393981f, -0.06809620f, 0.03582802f, 0.15282503f, -0.04533670f, 
    -0.16711818f, -0.16210425f, -0.39471343f, -0.27098298f, 0.01814890f, 0.04143440f, 0.03593986f, 0.02367643f, 
    -0.03353390f, 0.06161811f, -0.08937443f, -0.07676610f, 0.01984711f, -0.06241634f, 0.02859463f, -0.04297335f, 
    -0.08800007f, 0.13232701f, -0.00372676f, -0.06778783f, 0.02546176f, 0.02906788f, 0.04350212f, 0.04539288f, 
    -0.10108725f, -0.19107056f, -0.04236515f, -0.05860053f, 0.13311942f, 0.15823461f, -0.07986379f, 0.04735336f, 
    -0.02087310f, -0.08727214f, 0.11148944f, -0.05153118f, 0.52121317f, -0.29737112f, 0.43025759f, 0.15304510f, 
    0.03444421f, 0.01361388f, 0.08475786f, -0.00602944f, 0.19448531f, -0.06805068f, 0.20289721f, -0.05611351f, 
    -0.11051124f, -0.20797953f, -0.31597126f, -0.18684630f, -0.05690698f, 0.06017661f, -0.07849149f, 0.14488311f, 
    0.10225386f, -0.05707474f, 0.06607693f, -0.03680087f, 0.01151182f, -0.22945639f, 0.07928498f, 0.03009855f, 
    0.01249185f, 0.04163013f, -0.08641555f, 0.05362109f, 0.04407082f, 0.17082542f, 0.05258029f, -0.05918986f, 
    -0.14142230f, 0.07357236f, 0.04942788f, -0.18752240f, -0.01948368f, -0.20584054f, 0.03263003f, -0.22940767f, 
    -0.03037264f, -0.03932352f, -0.00359672f, -0.04647403f, -0.13916674f, -0.17018679f, -0.03577937f, 0.37732372f, 
    0.12586017f, -0.09346992f, -0.03286378f, 0.10910169f, -0.03620372f, -0.12659177f, 0.07836805f, 0.12757538f, 
    0.00786078f, -0.04585025f, -0.08648979f, 0.04091120f, -0.06588639f, 0.01628219f, 0.07569606f, -0.11602943f, 
    -0.18232216f, -0.21994829f, 0.13586384f, -0.24451344f, 0.74215549f, -0.12524158f, -0.13066548f, 0.07103555f, 
    0.04629911f, -0.04059780f, -0.01100047f, 0.13467579f, -0.04703965f, 0.03780992f, -0.04106871f, 0.00141524f, 
    -0.13330987f, -0.14793846f, -0.06579914f, 0.05264347f, 0.16402449f, 0.11449216f, -0.16339381f, 0.06500412f, 
    -0.01349228f, 0.02798257f, -0.00832835f, -0.03121762f, -0.03609259f, 0.08105882f, 0.20517759f, -0.07552101f, 
    0.19687556f, -0.10298213f, 0.06015487f, 0.04781941f, -0.09659111f, 0.02626999f, -0.01919463f, 0.03476231f, 
    -0.30198497f, 0.21035688f, -0.07755373f, 0.06291660f, -0.05536153f, 0.05170374f, 0.06605795f, 0.01022621f, 
    0.12793019f, 0.02269207f, 0.10575062f, -0.08337575f, 0.09383837f, 0.19207738f, -0.13553226f, 0.04755214f, 
    0.17715487f, 0.05931881f, 0.05925838f, -0.05571094f, 0.20428327f, -0.01994292f, 0.08678246f, 0.03202844f, 
    0.06819862f, -0.08852076f, -0.02723512f, -0.04990047f, 0.14978839f, 0.13888341f, -0.01399952f, -0.10401495f, 
    -0.06015874f, 0.02492150f, 0.08291046f, 0.11854948f, 0.11057892f, -0.08042473f, -0.22322018f, 0.06008449f, 
    -0.04103947f, 0.04593094f, 0.04177183f, 0.00340873f, 0.08436412f, -0.24776933f, -0.09580731f, -0.35053793f, 
    0.12690988f, -0.05950435f, -0.13080421f, 0.02641138f, 0.09031015f, 0.09810120f, -0.01042576f, -0.02095708f, 
    -0.22605985f, 0.06647472f, -0.32738826f, -0.43405995f, -0.08177128f, 0.08961251f, 0.06328241f, -0.07191882f, 
    0.16161539f, 0.03517975f, 0.06475400f, 0.07856221f, -0.12343368f, -0.04923743f, -0.06575217f, -0.02970162f, 
    0.14459281f, -0.08872581f, -0.18478900f, -0.00304999f, -0.00355687f, -0.00700674f, -0.02494483f, 0.23610108f, 
    -0.01517298f, -0.00764020f, -0.03050161f, 0.02694704f, 0.08918174f, 0.08569483f, 0.06418161f, -0.11376254f, 
    0.16450651f, 0.05180774f, -0.09692632f, -0.28664634f, -0.08179577f, 0.02837860f, -0.03520733f, -0.06082417f, 
    -0.02738239f, 0.08790070f, 0.13093488f, 0.07827494f, 0.07331666f, -0.01653007f, 0.05362172f, 0.17146745f, 
    -0.01116840f, 0.03806022f, 0.10371019f, 0.04241087f, -0.17303999f, -0.15244320f, -0.02953823f, 0.00036868f, 
    0.08159291f, 0.02732589f, 0.11467910f, -0.01747210f, -0.04144926f, -0.14253011f, 0.02583377f, -0.06221838f, 
    0.00880368f, 0.07254579f, 0.06587920f, -0.04097577f, 0.29526344f, 0.07676371f, -0.05774638f, 0.08777414f, 
    -0.00858884f, 0.01547980f, 0.01990362f, 0.03051004f, 0.12237122f, 0.10609401f, -0.05682335f, -0.18340583f, 
    0.11376309f, 0.15169661f, -0.03087750f, -0.14246891f, 0.05351203f, 0.04069580f, 0.03047920f, 0.00084456f, 
    -0.09675384f, -0.28396180f, -0.00995187f, 0.07590609f, -0.06457305f, -0.04388004f, -0.09426627f, 0.01512048f, 
    0.16285123f, 0.00619364f, -0.03078623f, 0.04579867f, -0.27634004f, -0.15755443f, 0.01700802f, -0.08302902f, 
    -0.03473895f, -0.09703481f, 0.07970948f, 0.09021802f, 0.01824346f, -0.08715133f, -0.14386864f, -0.32327831f, 
    -0.07155988f, 0.05227752f, -0.03857955f, 0.04170738f, -0.09557152f, 0.13546258f, 0.05845994f, -0.11214992f, 
    0.04676219f, 0.14619826f, -0.03782970f, 0.03034356f, -0.02278819f, -0.15862681f, -0.11567082f, 0.05330986f, 
    0.06573172f, -0.03326756f, 0.03220736f, 0.10744181f, -0.20703340f, -0.22129510f, 0.14910321f, 0.21646711f, 
    0.12225019f, -0.03150464f, -0.29880470f, -0.27965507f, 0.05626359f, -0.03664591f, -0.01808465f, 0.22838400f, 
    0.04232231f, -0.08060125f, -0.04299877f, -0.09171075f, -0.41429734f, -0.16584085f, -0.13622293f, -0.11836375f, 
    0.14070551f, 0.03976981f, -0.06532382f, 0.07541442f, 0.01696971f, -0.01141278f, -0.05208290f, 0.03990735f, 
    0.13891231f, -0.03781561f, 0.03696316f, 0.02882830f, -0.04227521f, -0.22366118f, -0.19419424f, -0.10349707f, 
    0.01893860f, -0.03407313f, -0.04129927f, 0.01982355f, -0.08278111f, -0.13606147f, 0.01979301f, -0.07493971f, 
    -0.08045575f, -0.03724200f, -0.10216327f, -0.02359615f, 0.03837203f, 0.02307510f, 0.20246568f, 0.15883777f, 
    0.14257421f, 0.02503388f, 0.01953870f, -0.07797907f, 0.09725935f, 0.03677802f, -0.07176895f, -0.15275811f, 
    0.09711940f, 0.10463483f, -0.00857537f, -0.00142029f, -0.32750466f, -0.11913927f, 0.32676527f, 0.32339138f, 
    -0.13504587f, -0.13090865f, -0.10428497f, 0.10484549f, 0.01812340f, 0.02608505f, -0.13574915f, 0.06451153f, 
    0.01218916f, 0.00967538f, -0.03236882f, -0.13523316f, 0.18489610f, 0.19329596f, 0.00112512f, -0.03517514f, 
    0.00618745f, -0.00518640f, 0.01859556f, 0.07154230f, 0.26736853f, 0.08759858f, 0.22226010f, -0.01190289f, 
    -0.01809311f, 0.05697516f, 0.15148440f, 0.06548827f, 0.13687381f, 0.00384566f, -0.01750838f, 0.01635415f, 
    -0.17483822f, 0.02143841f, 0.26096925f, -0.13048626f, -0.05376718f, -0.04164025f, 0.09643405f, 0.05196146f, 
    0.10458033f, -0.10093012f, -0.17604841f, -0.01611142f, -0.25483394f, 0.19713010f, -0.00340860f, -0.48708668f, 
    0.03790279f, 0.00306519f, -0.03996728f, 0.00446243f, 0.05268340f, 0.11817966f, -0.11870153f, 0.03549835f, 
    0.18241283f, -0.11450841f, 0.04635869f, -0.10926931f, 0.01018334f, -0.17510624f, -0.04336733f, 0.15899321f, 
    0.18471296f, -0.04233363f, -0.14930037f, 0.03098628f, -0.22801435f, -0.33822894f, -0.05189711f, 0.04803703f, 
    -0.09764089f, 0.03795256f, 0.04352230f, 0.00597387f, -0.01328569f, 0.01432253f, 0.18318705f, 0.22226012f, 
    0.08749112f, 0.06222580f, 0.00596282f, -0.19627076f, 0.21681096f, -0.04687632f, 0.10664664f, -0.04620282f, 
    -0.02960464f, 0.00850610f, 0.09537925f, 0.04774012f, -0.01995004f, -0.02774330f, -0.14513807f, 0.06843520f, 
    -0.04636607f, -0.03755224f, -0.10943630f, 0.14763455f, -0.10000734f, -0.05125865f, 0.14673465f, -0.16018493f, 
    -0.71956283f, 0.09486637f, -0.18564995f, -0.14036798f, 0.00029855f, -0.01730021f, 0.02284554f, -0.01683697f, 
    0.07987540f, -0.11720472f, -0.04724523f, 0.10553234f, 0.18050501f, -0.15864839f, 0.20543225f, 0.09634581f, 
    -0.06462040f, 0.04828637f, -0.12692063f, 0.06868149f, 0.22690661f, -0.24583422f, -0.04116250f, 0.18406659f, 
    -0.01388051f, 0.02483479f, 0.01565523f, 0.07814444f, -0.01731734f, 0.13670535f, -0.08083018f, -0.02685515f, 
    0.10446821f, 0.09266176f, -0.07841081f, 0.12095333f, 0.22398265f, 0.34619004f, -0.09173663f, 0.01411721f, 
    -0.06752589f, 0.02350185f, -0.03548871f, 0.03040664f, -0.06218732f, 0.02459297f, 0.00785816f, 0.04088629f, 
    0.17800197f, -0.14575325f, -0.03396461f, -0.58243543f, 0.11474756f, 0.01845783f, 0.21359929f, -0.05611923f, 
    0.03152652f, 0.09879377f, -0.01717371f, 0.08583482f, 0.04619864f, -0.13916075f, 0.11394913f, -0.23796424f, 
    0.03625864f, 0.03676834f, 0.01034118f, 0.01191537f, 0.21367961f, 0.23016533f, 0.22392674f, 0.05419630f, 
    -0.56450552f, -0.71501392f, -0.42094886f, -0.43039399f, -0.27724680f, -0.28083548f, -0.10707097f, -0.57644361f, 
    -0.02059949f, -0.01295780f, 0.01440111f, -0.02561262f, 0.04145556f, 0.06529109f, -0.06767327f, -0.15105014f, 
    0.04204936f, -0.04916641f, 0.08919413f, -0.01077007f, 0.04952516f, 0.01473087f, 0.06690034f, -0.23499171f, 
    -0.60592979f, -0.09608467f, 0.33233225f, -0.00324327f, 0.00277626f, 0.04615191f, 0.15784132f, -0.16147730f, 
    -0.00078691f, 0.03893919f, -0.00024232f, 0.12666707f, -0.01465954f, -0.09811791f, 0.02142168f, 0.12179750f, 
    -0.07061626f, 0.02456344f, 0.05017863f, -0.00652041f, 0.02332030f, 0.00720348f, -0.01669893f, -0.04663838f, 
    -0.08038639f, -0.01993895f, -0.00585272f, 0.09609149f, 0.06508058f, -0.06416878f, 0.03142505f, 0.04091538f, 
    0.02771292f, 0.04281233f, 0.19176237f, 0.04360201f, 0.18363570f, 0.08967751f, 0.22414039f, -0.11379176f, 
    0.12645285f, -0.13779013f, 0.16893819f, -0.04247647f, -0.02246495f, 0.05394162f, -0.01107811f, 0.04906443f, 
    -0.23653857f, 0.07696241f, 0.21900463f, -0.02669608f, -0.05950483f, 0.01479111f, -0.02756657f, -0.09040246f, 
    -0.11095890f, -0.05411342f, 0.05461273f, 0.02761575f, -0.09675331f, -0.30919629f, -0.12708974f, 0.24544998f, 
    0.21193951f, -0.00655986f, -0.05662795f, 0.10050423f, -0.04505168f, -0.02292323f, 0.00149469f, 0.08960751f, 
    -0.14994726f, -0.21945199f, -0.01072499f, 0.08410978f, -0.23240450f, -0.31667745f, -0.18022478f, 0.01553621f, 
    -0.05911123f, -0.05598453f, -0.02903747f, -0.09391785f, -0.04718508f, -0.07089254f, 0.11457496f, 0.09855217f, 
    0.04215358f, 0.02260581f, -0.00991823f, 0.00743307f, 0.08245237f, 0.17390040f, 0.05174693f, -0.01822938f, 
    -0.01890728f, -0.02548706f, -0.02271943f, 0.05385466f, 0.04560076f, -0.01269694f, -0.05889085f, 0.07650986f, 
    -0.00071385f, -0.11716363f, 0.01100179f, -0.00746758f, -0.03854827f, -0.20459172f, -0.15508735f, -0.18034828f, 
    0.02928646f, 0.06223141f, 0.00447601f, 0.06775273f, -0.02036642f, 0.02055450f, -0.07353161f, 0.02166242f, 
    -0.19255237f, -0.71575755f, -0.18040085f, 0.31564036f, 0.10278789f, 0.06391095f, 0.02209295f, -0.22803378f, 
    -0.03871430f, 0.06298582f, 0.09477071f, 0.12252289f, -0.28532544f, 0.29389656f, 0.09772994f, -0.10429894f, 
    0.07232849f, -0.00557629f, -0.01277905f, 0.13157393f, 0.09901435f, 0.01012735f, 0.17247714f, -0.19416180f, 
    0.11801319f, -0.11902384f, -0.07426084f, 0.00881632f, -0.08951720f, 0.07045829f, 0.21193610f, -0.01643065f, 
    0.09292877f, 0.12979020f, -0.16169903f, 0.11141443f, 0.04811634f, 0.12126972f, 0.00567776f, 0.01184397f, 
    -0.00903607f, -0.04979764f, -0.05845933f, 0.00074792f, 0.02555584f, -0.00440166f, 0.01144733f, 0.05596039f, 
    -0.34967524f, -0.35530767f, -0.02854051f, 0.01929739f, 0.16318831f, 0.10035982f, 0.01727906f, -0.18348742f, 
    -0.00565834f, -0.00380613f, -0.05221117f, 0.06426299f, -0.04805633f, -0.13607872f, -0.10036996f, -0.03841055f, 
    -0.05679177f, -0.01980215f, -0.02962132f, -0.00122190f, -0.04219433f, -0.03430632f, -0.08791380f, -0.04631395f, 
    -0.25070688f, -0.21019302f, -0.05135195f, 0.02246495f, 0.09043056f, 0.14947540f, -0.00293150f, -0.14600210f, 
    -0.01882310f, -0.05110400f, -0.07783607f, -0.01437107f, -0.40224412f, -0.09545963f, -0.43326834f, -0.12894842f, 
    -0.15073490f, 0.09582252f, 0.04222021f, 0.05008921f, 0.02519786f, 0.02486202f, 0.05044330f, -0.06044762f, 
    0.37268135f, 0.36491519f, -0.18107343f, 0.12776469f, -0.00725164f, 0.00135802f, 0.08065157f, 0.02274334f, 
    0.13964826f, 0.02799520f, 0.06211369f, -0.04849716f, -0.00931304f, -0.02865225f, -0.12508099f, 0.16236097f, 
    0.05551546f, 0.13342942f, -0.03133493f, -0.09702148f, -0.04323408f, -0.07523397f, 0.04844537f, 0.05977769f, 
    -0.09540118f, -0.20254523f, -0.45317435f, -0.03769616f, 0.06793853f, 0.11636191f, 0.12706511f, -0.18519762f, 
    0.05574979f, -0.08743842f, 0.05146492f, 0.03146400f, 0.03285180f, -0.00149054f, -0.06981467f, 0.06087806f, 
    -0.23693599f, 0.06519397f, 0.11974289f, -0.01636340f, 0.01945185f, -0.01359082f, -0.01383434f, -0.00320545f, 
    0.27763209f, -0.00973391f, -0.12630011f, -0.02409143f, -0.02822408f, -0.05973958f, 0.00254561f, 0.00082096f, 
    0.12058934f, -0.15024874f, -0.00104395f, 0.12804085f, 0.14541791f, -0.01295315f, -0.20013405f, -0.01269984f, 
    -0.08917982f, 0.03854783f, 0.04747713f, 0.08675852f, -0.06047747f, 0.07252742f, -0.08775003f, 0.04566758f, 
    0.21111104f, 0.14199783f, -0.13603799f, -0.07143882f, -0.02569074f, 0.08972331f, 0.13909985f, -0.00842230f, 
    -0.02554394f, -0.03413767f, -0.02980915f, -0.07558353f, -0.03806939f, -0.02170518f, 0.05218865f, 0.16023687f, 
    0.09461733f, -0.05811731f, 0.17680646f, -0.02794085f, 0.07358220f, 0.20248340f, 0.08541057f, -0.21438898f, 
    0.10526287f, -0.07725232f, -0.00537683f, 0.14338334f, 0.01050188f, 0.09143432f, 0.08873595f, -0.03794157f, 
    0.10344730f, 0.07385819f, 0.04731905f, 0.12644553f, -0.03448044f, 0.06759057f, 0.21695825f, -0.24387564f, 
    0.07286742f, -0.01953124f, -0.02951270f, 0.03021476f, -0.01804731f, 0.10166750f, 0.01789585f, -0.11224712f, 
    -0.09762052f, -0.04034157f, 0.03531913f, 0.00279314f, 0.03915936f, -0.06109216f, 0.01505608f, 0.15512659f, 
    -0.02197516f, -0.02388467f, -0.05587795f, -0.05712844f, 0.16266292f, 0.13450970f, -0.01201631f, -0.05718247f, 
    0.01448623f, 0.01544338f, 0.03897950f, 0.04682473f, 0.11086413f, 0.15680477f, 0.19383356f, 0.07233678f, 
    -0.03382541f, 0.03972694f, 0.01965967f, -0.01507640f, 0.04032892f, 0.05919724f, 0.04284148f, 0.02212827f, 
    0.09475251f, -0.05784768f, 0.14178623f, 0.12058077f, -0.48669314f, -0.68792152f, -0.13171776f, -0.37100118f, 
    0.02327514f, 0.16538107f, -0.03528715f, -0.23512976f, 0.03276428f, 0.08322345f, 0.00453273f, -0.00482936f, 
    0.28528249f, 0.36491060f, -0.07186160f, -0.03615820f, -0.05355930f, -0.01528059f, -0.05754491f, 0.04608203f, 
    0.13017856f, 0.02892260f, -0.00651186f, 0.02820900f, -0.61109811f, -0.53983182f, -0.16470721f, -0.05250199f, 
    0.07057351f, -0.03495102f, -0.17953868f, -0.14931265f, -0.02988204f, -0.07020298f, 0.12657760f, 0.02061205f, 
    -0.26132247f, -0.37533632f, -0.43308330f, -0.26717418f, -0.19708689f, 0.05480527f, 0.04389086f, -0.24971561f, 
    -0.04955329f, -0.01379267f, 0.00834424f, 0.02971242f, 0.03070018f, -0.03529718f, -0.05295673f, -0.04430856f, 
    0.01859749f, 0.05078112f, 0.00334466f, 0.06485096f, -0.04497526f, -0.00805970f, 0.08746807f, -0.14036229f, 
    -0.67490095f, -0.30093527f, -0.20563373f, -0.19304487f, 0.11014505f, -0.14504302f, 0.01921923f, -0.21726882f, 
    -0.03114214f, 0.03152271f, -0.11837628f, 0.00916944f, -0.53498131f, 0.07338974f, 0.13382621f, 0.01924779f, 
    0.06036260f, -0.18926661f, -0.18833809f, -0.22238716f, -0.02049526f, -0.00290690f, -0.00837712f, 0.01351185f, 
    -0.37109601f, 0.08122180f, 0.35365707f, 0.27862212f, -0.05903579f, -0.05774764f, -0.05736340f, 0.07363728f, 
    -0.03912746f, 0.05240479f, 0.07180404f, -0.02887318f, -0.11512600f, -0.04489012f, 0.07245506f, 0.06104788f, 
    -0.10684127f, 0.06010170f, 0.03118946f, 0.02623905f, -0.03656722f, 0.03293866f, 0.06819310f, 0.02351338f, 
    -0.04512971f, -0.00336379f, -0.06205987f, -0.04382419f, -0.00912683f, -0.07226241f, -0.14501199f, 0.06593122f, 
    -0.02365558f, -0.07026810f, 0.01318922f, -0.07218958f, 0.01999418f, 0.05885725f, 0.04881436f, 0.08237999f, 
    0.03244637f, -0.05319475f, -0.03679537f, 0.02521002f, 0.00396948f, 0.15442391f, 0.26105890f, 0.10515816f, 
    -0.42038053f, -0.03521590f, -0.23400235f, -0.25690797f, -0.02108373f, 0.12852241f, 0.05017359f, -0.09330434f, 
    0.10342082f, -0.00235600f, 0.01432323f, 0.04661392f, -0.35983780f, -0.12592188f, 0.10984630f, 0.43252838f, 
    -0.00404334f, -0.14440939f, -0.02741394f, 0.16558151f, -0.03474585f, -0.04490541f, -0.03500727f, 0.00380975f, 
    -0.27999613f, -0.13665320f, -0.81477821f, -0.05646116f, -0.37749401f, -0.09642911f, 0.16666520f, -0.23418429f, 
    0.02142667f, 0.00556928f, 0.00459702f, 0.08453419f, -0.10184380f, 0.00083822f, 0.07785936f, -0.15136281f, 
    -0.06584275f, -0.16402325f, -0.04047112f, 0.00514628f, -0.05393618f, 0.10922700f, -0.07958487f, 0.08038761f, 
    -0.16832297f, -0.04057829f, 0.02160747f, -0.03396297f, -0.13949092f, -0.02086173f, -0.06949347f, -0.30177617f, 
    -0.01496596f, 0.02853104f, -0.02927672f, -0.00776359f, 0.17582715f, -0.26229849f, -0.25000265f, 0.24431032f, 
    -0.12190732f, -0.19065644f, 0.06128499f, 0.21349718f, -0.15177453f, -0.01661403f, -0.00390762f, 0.05370684f, 
    -0.06149077f, -0.06007426f, -0.05013308f, -0.07759759f, -0.15437593f, -0.16010900f, -0.18976504f, -0.17962630f, 
    0.02714126f, 0.00030063f, -0.09864692f, -0.08578740f, -0.20159474f, -0.48055512f, -0.19860294f, 0.38319013f, 
    0.17732069f, -0.04960538f, 0.03514766f, -0.04420979f, 0.01791891f, 0.00841515f, -0.04243095f, 0.04498799f, 
    -0.85156429f, 0.19735600f, 0.36571416f, -0.26286510f, -0.09086484f, -0.15515208f, -0.11532564f, 0.16933644f, 
    -0.08546842f, 0.09052686f, 0.08323409f, -0.06661222f, -0.09875691f, 0.15310848f, 0.07052930f, -0.07743969f, 
    0.03176866f, -0.02043031f, 0.09667211f, -0.02528397f, 0.07594793f, 0.03044310f, 0.02234200f, 0.01179823f, 
    0.27636632f, 0.23158155f, -0.21314089f, 0.12375021f, -0.01861423f, 0.00239486f, 0.03403544f, 0.30035412f, 
    0.12288091f, 0.00832992f, 0.04963683f, 0.05050173f, -0.31037140f, 0.21145311f, 0.56599778f, 0.22426364f, 
    -0.09583682f, -0.11577456f, 0.01878523f, -0.03311644f, -0.16782695f, 0.01176768f, -0.17672880f, 0.15098824f, 
    -0.50556356f, -0.63250381f, -0.36611784f, -0.49482331f, 0.15955360f, -0.49416381f, -0.04755549f, -0.35689235f, 
    -0.03856573f, -0.04102675f, -0.01375238f, -0.04207327f, 0.23429820f, -0.19272962f, -0.07614786f, -0.06007324f, 
    -0.04457802f, -0.06623862f, 0.07257199f, -0.07834519f, -0.02028467f, -0.12784103f, 0.08771500f, -0.10445728f, 
    -0.24684703f, -0.11074685f, 0.19076125f, 0.19404778f, -0.01847834f, -0.03508798f, -0.06930251f, 0.17891736f, 
    -0.01600702f, 0.12105819f, 0.11746726f, -0.04333009f, -0.13117972f, -0.19862923f, 0.07530241f, 0.37119353f, 
    0.09091891f, 0.06768589f, -0.12713103f, 0.16193439f, -0.00415127f, 0.08405785f, -0.11027247f, -0.03152062f, 
    0.13147119f, -0.00371764f, -0.00626651f, -0.12035160f, -0.06466148f, 0.00958806f, -0.06522606f, -0.03502714f, 
    -0.10469101f, -0.04584324f, 0.10376653f, -0.07194210f, -0.08467659f, -0.07813919f, -0.13267061f, -0.04751616f, 
    -0.00721671f, -0.02681923f, 0.00562982f, 0.01472905f, -0.01783274f, 0.06041044f, -0.00294634f, 0.05135853f, 
    -0.11674719f, 0.14524817f, 0.01778053f, -0.01538376f, -0.14367560f, 0.01723002f, -0.04820087f, 0.04933826f, 
    0.00553328f, -0.04871959f, 0.07299108f, -0.01274681f, 0.59823436f, 0.03593726f, -0.04321844f, -0.11998712f, 
    -0.04997717f, -0.03330372f, -0.00541654f, -0.03525391f, 0.09140208f, 0.00718723f, 0.04899926f, 0.01292639f, 
    -0.29775852f, -0.14593557f, -0.36888781f, 0.03372887f, 0.23949888f, -0.05668921f, 0.04927902f, 0.10118158f, 
    0.05197118f, 0.01241695f, 0.01567079f, 0.02308334f, -0.00915004f, 0.10769817f, -0.07440910f, 0.06570764f, 
    0.02689855f, 0.00688520f, 0.01633642f, -0.08048589f, 0.02318848f, 0.00489472f, -0.03826319f, -0.04934077f, 
    -0.10088699f, 0.38531333f, -0.14213590f, 0.29001716f, -0.00423839f, 0.01004928f, -0.01218000f, 0.02671092f, 
    -0.11308780f, -0.00286235f, -0.00110514f, 0.00576085f, -0.30191612f, -0.01773475f, 0.12341093f, -0.01207697f, 
    -0.01049769f, -0.01931499f, 0.07256991f, 0.02240185f, 0.05777920f, -0.04395064f, 0.01162539f, -0.04777163f, 
    0.12294212f, -0.05773359f, 0.13733304f, -0.29307765f, -0.03159523f, 0.04503034f, 0.10789064f, 0.02917284f, 
    -0.02126511f, -0.01376820f, 0.12445401f, 0.02267245f, -0.19881135f, 0.25959769f, 0.23854111f, 0.00365137f, 
    -0.07316172f, -0.05164410f, 0.04307226f, -0.00525643f, -0.00702452f, -0.10135625f, 0.03937603f, -0.03624728f, 
    0.20756824f, 0.07884873f, -0.08890910f, -0.07927922f, 0.03098786f, 0.02234433f, -0.02301815f, 0.01108063f, 
    -0.04937003f, 0.10503379f, -0.07499830f, -0.03053538f, -0.01675224f, -0.23139279f, 0.17742111f, -0.24209411f, 
    0.01431790f, -0.09299124f, -0.09372236f, 0.06299737f, -0.02389741f, -0.05039065f, 0.00398529f, -0.00062450f, 
    -0.10223971f, -0.09706740f, -0.15979318f, 0.09115954f, -0.05117533f, -0.08108041f, 0.14901423f, 0.00959130f, 
    0.03663148f, -0.04217591f, 0.00565868f, 0.03466794f, 0.26382661f, -0.03197039f, 0.06495935f, -0.23326735f, 
    0.04675359f, 0.04374277f, -0.03117114f, -0.03151581f, 0.10112031f, 0.06291891f, -0.10743099f, -0.11844642f, 
    0.03171616f, 0.03705005f, -0.02760893f, -0.09553973f, 0.01546420f, 0.05004392f, 0.02501309f, -0.04865482f, 
    -0.00930136f, -0.09171832f, -0.18956187f, -0.12140508f, -0.02607201f, 0.02317005f, -0.06686970f, -0.04790944f, 
    0.00245763f, 0.01639386f, -0.03160796f, -0.02993570f, 0.07679576f, 0.02312722f, 0.05889479f, -0.03860795f, 
    0.06635835f, -0.34645122f, 0.27912349f, -0.19452906f, -0.17071728f, -0.04815986f, -0.11430865f, 0.17689602f, 
    -0.10430719f, -0.02482854f, 0.03381312f, -0.08473848f, -0.03900886f, -0.07890226f, 0.05719648f, -0.10781128f, 
    -0.02880628f, -0.00355697f, 0.06382441f, -0.04942401f, 0.00610337f, 0.15483706f, -0.05535227f, 0.10687761f, 
    0.04852929f, 0.23134299f, -0.12972951f, 0.02128342f, -0.03206819f, 0.04243258f, -0.05447496f, 0.09433755f, 
    -0.00963022f, 0.05254249f, 0.04300021f, -0.01285981f, 0.09523743f, 0.01732438f, -0.09139584f, -0.08823432f, 
    0.01051623f, -0.04975124f, -0.00979644f, -0.04822312f, -0.14408119f, -0.07605492f, 0.07061352f, 0.03921129f, 
    0.15560499f, 0.12404878f, 0.09807645f, -0.30319235f, -0.02804152f, -0.00590547f, 0.04830661f, 0.04582766f, 
    -0.00502835f, 0.06594781f, -0.00640583f, -0.01473973f, -0.00583446f, 0.02609940f, 0.08745327f, -0.01070991f, 
    0.04277880f, -0.06102636f, 0.05317964f, -0.01669684f, 0.02027063f, 0.00394368f, -0.00027777f, -0.01478953f, 
    -0.04024820f, 0.01111898f, 0.03398613f, -0.04089783f, -0.06195518f, -0.17040959f, 0.00986367f, 0.03000966f, 
    0.06315159f, 0.03658460f, 0.03225825f, -0.00537936f, -0.02280232f, -0.76192832f, 0.31069073f, -0.12647024f, 
    -0.29552683f, -0.02922365f, 0.06068226f, -0.06757799f, -0.08538990f, 0.03306349f, 0.02439152f, 0.01070643f, 
    -0.09992161f, -0.04644536f, -0.05545095f, 0.00853655f, -0.11477029f, -0.08500776f, 0.14315921f, -0.11523549f, 
    -0.04791785f, 0.02338807f, 0.01311245f, -0.02572028f, 0.04341022f, -0.09408090f, 0.13774411f, -0.09402087f, 
    -0.03615155f, -0.03759086f, -0.05000415f, 0.02178010f, 0.04437839f, 0.03274251f, 0.01327653f, -0.01951736f, 
    -0.25709963f, -0.10255597f, -0.08595734f, 0.13781695f, -0.02304090f, 0.05312905f, 0.03274134f, -0.03269025f, 
    0.06163473f, -0.02731751f, -0.02354732f, -0.08267511f, 0.07379134f, 0.17039485f, -0.16336787f, 0.03584448f, 
    -0.00997810f, 0.13118488f, -0.08682844f, -0.07515333f, -0.06744563f, 0.07072832f, 0.06527230f, 0.02045455f, 
    -0.09273832f, -0.02864966f, -0.00859793f, -0.04602791f, -0.07401025f, 0.03675464f, 0.01728177f, 0.06472671f, 
    0.06997134f, 0.09255386f, -0.04328964f, -0.12626994f, 0.04715960f, -0.03665131f, 0.06998663f, -0.10235835f, 
    -0.03188538f, 0.08063228f, -0.06379565f, -0.07004511f, 0.04487560f, 0.05701866f, 0.04836959f, 0.00535803f, 
    -0.00211624f, 0.10860343f, 0.08297275f, 0.00187118f, 0.03060244f, 0.01862216f, -0.04775527f, -0.06993407f, 
    0.00387790f, 0.05161162f, -0.02125557f, -0.01235037f, 0.08987248f, 0.07164706f, -0.04463505f, -0.08848324f, 
    0.05509423f, -0.15833585f, -0.01748678f, -0.09940274f, -0.18116871f, -0.07404283f, -0.12590940f, -0.00208750f, 
    -0.01468656f, 0.07432192f, 0.04969149f, 0.09680253f, -0.04910602f, 0.04692700f, 0.00743031f, -0.04547125f, 
    0.02359178f, -0.11068189f, 0.05217907f, -0.10061810f, -0.11356385f, 0.02465988f, -0.00872268f, 0.07734898f, 
    -0.07387933f, -0.03701402f, 0.12152504f, -0.06715365f, 0.04797990f, -0.04737394f, 0.01297342f, -0.19297771f, 
    -0.07997789f, 0.04732736f, -0.00330813f, -0.03845679f, -0.07766369f, -0.08671025f, 0.02042453f, -0.07768228f, 
    -0.03580604f, -0.00084781f, 0.01328413f, -0.00990613f, -0.04095923f, 0.06673229f, -0.03036136f, 0.13858926f, 
    -0.05096611f, -0.03344385f, -0.00003083f, 0.01417190f, -0.02139549f, 0.04342331f, 0.00539565f, -0.07644919f, 
    0.11162039f, 0.03132212f, -0.07161177f, 0.03485222f, -0.01748119f, 0.00978266f, 0.06138463f, 0.04761124f, 
    0.13000029f, 0.07053986f, 0.05831833f, 0.04507695f, -0.40556067f, -0.20690858f, -0.24208857f, 0.46810669f, 
    0.02517348f, 0.02447136f, -0.02754405f, 0.02891641f, 0.07660937f, -0.09048759f, 0.00156585f, 0.04591135f, 
    -0.11312503f, -0.08318818f, -0.11370836f, 0.00310697f, -0.06223165f, -0.05661149f, 0.15366407f, -0.01576108f, 
    -0.16405311f, 0.03760250f, 0.07966070f, 0.04023135f, -0.40004542f, -0.35608852f, 0.29069400f, 0.21633489f, 
    0.05879935f, 0.05177136f, -0.00435430f, 0.03416682f, 0.01170023f, -0.05956755f, -0.00109762f, -0.01826233f, 
    -0.23263744f, -0.12454113f, -0.10282681f, 0.38498774f, 0.11560766f, 0.03379786f, -0.00254709f, 0.13547131f, 
    -0.01263278f, -0.02156979f, -0.06499460f, 0.00697396f, 0.07351602f, 0.01061888f, 0.12966177f, -0.10945950f, 
    0.01710210f, -0.01050157f, 0.00519320f, -0.04592087f, 0.06243226f, -0.03671059f, 0.00132877f, 0.02666657f, 
    -0.40860674f, -0.26015818f, -0.14109392f, -0.08733816f, 0.04278237f, 0.03635845f, -0.05852147f, 0.05912750f, 
    0.03669656f, -0.02468793f, 0.03098197f, -0.00166743f, -0.27341983f, 0.22271863f, 0.18802911f, -0.20260188f, 
    -0.10587207f, -0.28931391f, 0.06918101f, 0.11189616f, -0.04972681f, 0.01210566f, -0.05131768f, 0.08013760f, 
    0.29919928f, -0.47974500f, -0.57162672f, -0.09768839f, -0.06628931f, -0.08359253f, -0.01017271f, -0.06081970f, 
    0.06972186f, 0.11993776f, 0.05726968f, 0.06077239f, 0.22920053f, -0.43363822f, -0.21145245f, -0.14648958f, 
    -0.15007691f, -0.05762570f, -0.07576226f, -0.08141921f, 0.15193708f, -0.10991710f, -0.05793731f, 0.09933615f, 
    -0.04139979f, 0.15994568f, -0.01873311f, 0.08226854f, -0.00525676f, -0.11996243f, 0.02062300f, -0.02533183f, 
    0.03767217f, 0.03528499f, 0.01090212f, 0.04165629f, -0.03052861f, 0.11598095f, 0.10035273f, -0.06252489f, 
    0.02890738f, -0.04715846f, 0.00866464f, -0.05131251f, 0.08198926f, -0.07380282f, 0.09360982f, -0.18690936f, 
    -0.54434204f, -0.35125807f, -0.28996092f, -0.27785110f, 0.03310157f, 0.01502827f, 0.22306708f, -0.04020283f, 
    -0.01593766f, -0.01031851f, -0.00828551f, -0.03546044f, 0.08141117f, -0.27024809f, -0.14945771f, -0.27260071f, 
    -0.06189019f, 0.03438319f, -0.11920515f, 0.04726082f, 0.05811398f, 0.07798404f, 0.00850798f, -0.01530861f, 
    0.02887816f, -0.30371708f, -0.20655864f, -0.22988945f, 0.07440045f, 0.07258490f, 0.12423256f, 0.04351998f, 
    -0.02753136f, -0.01938550f, -0.05285072f, -0.10495056f, 0.18108536f, 0.04305390f, -0.07534772f, -0.17393132f, 
    0.05452559f, 0.05097825f, 0.06273821f, 0.01260770f, -0.06265418f, 0.09143151f, -0.14097840f, -0.20835446f, 
    0.02691082f, -0.06701814f, 0.03065310f, 0.02936282f, 0.12731935f, 0.06055359f, -0.02185483f, -0.07286962f, 
    0.09179710f, 0.07980192f, 0.04097535f, -0.00446253f, 0.55720675f, -0.46315667f, -0.09407564f, -0.05233211f, 
    0.08914611f, 0.00263322f, -0.06053826f, -0.13963729f, -0.08628332f, 0.06098002f, 0.03463203f, -0.24808076f, 
    0.04218140f, -0.00788224f, -0.01941179f, 0.02859911f, -0.02071877f, -0.08167002f, -0.08525071f, 0.03300085f, 
    0.00326274f, 0.00208671f, 0.01721754f, -0.01198583f, -0.28967693f, -0.32965162f, 0.47609857f, -0.18661246f, 
    0.06158659f, -0.02118508f, 0.14496174f, -0.01129360f, -0.00884960f, 0.04677510f, 0.00980786f, -0.03338330f, 
    0.63250995f, -0.70399183f, -0.09401332f, 0.07813714f, -0.01817642f, -0.01643436f, -0.01491312f, -0.10565115f, 
    0.03144391f, 0.13342088f, 0.07735952f, -0.04075416f, 0.11863832f, -0.05630370f, 0.05692929f, -0.05249821f, 
    0.02953813f, 0.02648711f, 0.02004930f, -0.02636627f, -0.06200761f, 0.09967086f, -0.09078985f, 0.07682950f, 
    -0.12799683f, -0.09927344f, -0.01056954f, -0.05382679f, -0.03540666f, -0.03250641f, 0.06246831f, -0.08715099f, 
    -0.09840328f, 0.08798320f, -0.00526310f, -0.06096673f, 0.51405156f, -0.35173348f, -0.19988836f, -0.59182954f, 
    0.01240719f, 0.00350995f, 0.01800957f, 0.01983465f, 0.02155145f, -0.05486301f, 0.02477523f, -0.03332344f, 
    -0.31514797f, -0.17497371f, 0.07985651f, -0.25303373f, -0.08279585f, 0.12679887f, -0.11763256f, 0.11338967f, 
    0.08048034f, 0.01251015f, -0.01738828f, -0.04449276f, -0.09312730f, 0.08116798f, -0.00335470f, -0.02946824f, 
    0.04714479f, -0.07509798f, 0.12088321f, -0.02325148f, 0.07638807f, 0.02760639f, 0.04659318f, 0.03059615f, 
    0.35112196f, -0.58770084f, -0.46869406f, -0.11635958f, 0.11160164f, -0.01533701f, 0.10865932f, 0.01707777f, 
    0.11541685f, -0.06770521f, -0.02855348f, -0.06480630f, 0.22546168f, -0.14935958f, 0.11816476f, -0.34298790f, 
    0.02344599f, -0.02516782f, -0.00834636f, -0.01901349f, 0.07089262f, 0.04353100f, 0.04707740f, -0.20791902f, 
    -0.04247924f, -0.00565589f, -0.07925741f, -0.01583931f, -0.03727916f, -0.01244000f, -0.04115164f, 0.00361950f, 
    0.12053015f, 0.01047792f, -0.03818991f, -0.01073165f, -0.17660847f, -0.20142896f, -0.07691864f, -0.06385581f, 
    0.06249113f, -0.01019959f, 0.00450430f, 0.06456534f, -0.08720365f, -0.28213763f, -0.21914312f, -0.15843888f, 
    -0.67691696f, 0.27111685f, 0.13999179f, 0.28656736f, 0.24011776f, 0.08479094f, -0.04741233f, 0.00562598f, 
    0.03420819f, -0.08369890f, 0.05001506f, 0.02089970f, 0.34820217f, -0.06546159f, -0.11858850f, -0.28499100f, 
    0.00508994f, -0.02536373f, 0.09399973f, -0.03458516f, -0.03578454f, 0.12912183f, -0.05200275f, -0.24637912f, 
    -0.14521904f, -0.36539879f, -0.22595175f, -0.12333399f, -0.28711671f, -0.00053393f, -0.04066750f, 0.15263161f, 
    -0.04684067f, 0.01887667f, -0.02414989f, 0.03138145f, -0.38430506f, 0.10485072f, 0.12977134f, 0.07143562f, 
    -0.08080787f, 0.06509826f, -0.05450400f, -0.01344629f, -0.13890845f, -0.01514851f, 0.04210648f, 0.02697718f, 
    -0.35810968f, -0.23773715f, 0.01861726f, 0.04432011f, -0.02419116f, -0.01003687f, -0.11388043f, 0.09948526f, 
    0.00006573f, 0.00840963f, 0.06194667f, -0.01020373f, -0.35168627f, -0.23498757f, 0.18244363f, 0.45798191f, 
    0.04185517f, 0.14408645f, -0.05032462f, -0.01929610f, -0.00412496f, 0.08388853f, -0.11267262f, 0.05840791f, 
    -0.24533230f, -0.21180166f, 0.06383196f, -0.01300209f, -0.00498187f, 0.00866727f, 0.00733536f, -0.01172511f, 
    0.05140941f, -0.00945609f, 0.11145715f, 0.16071589f, -0.47867027f, -0.17851190f, 0.09968149f, 0.04471325f, 
    -0.08256988f, 0.05250002f, -0.00255193f, -0.05646754f, 0.05014799f, 0.12270237f, 0.08768525f, 0.10689335f, 
    -0.07036015f, -0.08727574f, -0.16092764f, -0.16649519f, -0.07592392f, 0.01009854f, 0.04827744f, 0.01056807f, 
    0.10562566f, -0.00721899f, 0.11039679f, 0.00427108f, 0.42674685f, 0.29456046f, 0.17259149f, 0.02130016f, 
    -0.12058667f, -0.03645165f, -0.05703356f, 0.08243176f, 0.01959917f, 0.03943601f, 0.07735958f, 0.05751428f, 
    -0.05739589f, -0.21292600f, -0.19582215f, 0.07397139f, -0.15437546f, 0.06143477f, 0.14193828f, -0.01856089f, 
    0.00136366f, 0.00840786f, 0.13969636f, 0.07443067f, -0.13897838f, -0.00440967f, -0.15075803f, -0.13323122f, 
    0.01723581f, -0.04202593f, 0.06065514f, -0.01206904f, 0.09348866f, 0.07252264f, 0.01721489f, -0.01768569f, 
    -0.05866951f, 0.02593961f, -0.06458046f, -0.07305964f, -0.03836169f, -0.03311511f, -0.04196838f, -0.04412669f, 
    0.06095143f, 0.04631267f, 0.09695897f, 0.09300667f, -0.07871639f, 0.23564145f, 0.05533787f, -0.03189987f, 
    -0.04456780f, -0.06167321f, -0.05139033f, -0.01555225f, -0.02764417f, -0.00629706f, -0.02642991f, -0.00456785f, 
    0.24839929f, 0.21010886f, -0.30868545f, -0.68875492f, -0.05654092f, -0.04340890f, -0.01500948f, -0.09102730f, 
    0.06912464f, 0.04208999f, 0.01449328f, 0.10430447f, 0.03246776f, -0.23632421f, -0.09954494f, -0.15505543f, 
    -0.04111420f, 0.04424871f, 0.01686798f, 0.01260356f, 0.06579839f, 0.04691489f, 0.04720346f, 0.07237446f, 
    0.03452199f, -0.02064078f, 0.07138043f, 0.15685154f, -0.02525287f, -0.01746984f, -0.03485733f, 0.04502545f, 
    -0.13929603f, -0.00074007f, -0.14896932f, -0.06363059f, -0.08151148f, -0.04328209f, -0.04556495f, -0.04607511f, 
    -0.02798490f, -0.00126315f, 0.05050128f, -0.00864414f, 0.11325710f, -0.00320907f, -0.00125080f, 0.01752757f, 
    -0.23655941f, 0.13388437f, 0.03749864f, 0.08087090f, -0.12181776f, 0.00940944f, -0.00120520f, -0.21292849f, 
    -0.05376161f, -0.03171313f, -0.06426554f, -0.02995771f, 0.00307901f, 0.00346219f, -0.00475458f, -0.05583095f, 
    0.06264763f, -0.05926194f, -0.01676893f, -0.02277961f, 0.03052531f, 0.12222429f, 0.01814932f, 0.09328760f, 
    -0.25091022f, 0.08152179f, 0.10506655f, 0.00158974f, 0.04317621f, 0.00176641f, 0.05292180f, -0.08860485f, 
    0.05714660f, 0.02134695f, -0.03363860f, -0.01398083f, 0.74842954f, 0.01693215f, -0.00227625f, -0.40475580f, 
    0.21788357f, 0.06418473f, 0.00195695f, -0.02785674f, -0.00889485f, 0.16783604f, -0.00763116f, 0.10437436f, 
    -0.31377631f, -0.08552171f, 0.06111536f, 0.09531859f, 0.02526665f, 0.06174659f, 0.06142359f, 0.00971449f, 
    0.00116598f, 0.04126089f, 0.03518863f, 0.05755740f, 0.02952903f, -0.01223726f, 0.00230494f, -0.09066293f, 
    0.05001143f, 0.01139026f, 0.04770894f, -0.02337494f, -0.02671965f, 0.05254938f, 0.05067752f, 0.07213384f, 
    -0.04202056f, -0.12397356f, 0.12062982f, -0.01969722f, 0.04736207f, -0.08142802f, -0.00980516f, -0.01135451f, 
    -0.04284402f, -0.03073920f, -0.01734679f, -0.04352455f, 0.13612936f, 0.12217178f, -0.11062180f, 0.00029113f, 
    0.13516098f, -0.07034104f, -0.04080621f, 0.12203568f, 0.11543117f, -0.08641278f, 0.18644619f, 0.02521058f, 
    -0.15889370f, -0.11812123f, 0.04405709f, 0.02271399f, 0.14328404f, -0.07406881f, -0.10440734f, 0.06548212f, 
    -0.12155034f, -0.17019536f, 0.00133097f, -0.11233031f, 0.11326249f, 0.15191166f, 0.05281175f, -0.06163222f, 
    -0.02591901f, -0.01349086f, -0.07742420f, -0.02304836f, -0.00532191f, -0.03477963f, 0.04307828f, 0.07440355f, 
    0.19369642f, 0.10975317f, 0.06066671f, -0.03278359f, 0.15582332f, -0.08405363f, 0.01480003f, -0.01705080f, 
    0.06723870f, -0.03699003f, 0.09077597f, 0.03875899f, 0.22757134f, -0.11041987f, -0.12152617f, -0.09213506f, 
    -0.08754841f, 0.15031044f, 0.06744372f, -0.17575206f, -0.06264824f, 0.12893817f, 0.04493397f, -0.02791773f, 
    -0.17274909f, 0.03479081f, 0.25359118f, 0.02907061f, 0.09614683f, -0.06884913f, -0.05014325f, 0.12052131f, 
    0.04329037f, 0.08342972f, -0.20325661f, -0.18807051f, -0.29700974f, -0.05296677f, 0.09646098f, -0.01207940f, 
    0.01597110f, 0.06954925f, -0.11510892f, -0.00003921f, 0.00494057f, 0.10333531f, 0.00396495f, 0.13296333f, 
    0.02467748f, 0.04087926f, -0.05711941f, 0.03192401f, 0.05258430f, -0.10717698f, -0.05316798f, 0.02009051f, 
    0.11966553f, 0.14794299f, 0.05270480f, 0.07474762f, -0.20231786f, 0.04829416f, 0.07765124f, 0.04824226f, 
    0.00195941f, 0.02920246f, -0.04403056f, 0.00710629f, -0.11638178f, -0.04478692f, -0.11146156f, -0.29495841f, 
    -0.04731910f, 0.00908106f, -0.01593705f, -0.02334355f, 0.00116047f, 0.00976741f, -0.01727165f, -0.02140075f, 
    -0.19093226f, -0.10771340f, -0.19431201f, -0.33059868f, 0.10143099f, -0.08505554f, 0.00052078f, 0.01983725f, 
    -0.04152088f, 0.08067817f, -0.01154689f, 0.09330443f, -0.12411747f, 0.04290084f, -0.00310925f, -0.13862967f, 
    -0.18174517f, -0.20062283f, -0.11377842f, 0.00204202f, 0.09797943f, 0.17969428f, 0.03177827f, 0.16858272f, 
    -0.13625896f, -0.02448302f, 0.01723250f, 0.03641742f, -0.07152644f, -0.27158770f, -0.36210424f, -0.44459087f, 
    -0.03224932f, 0.06048805f, 0.04309301f, 0.02329665f, 0.08387001f, -0.01662341f, 0.00424652f, -0.07814845f, 
    -0.08411513f, -0.04235416f, -0.11505582f, -0.17587668f, -0.14181459f, -0.10578241f, -0.06885187f, -0.20016545f, 
    0.01934171f, 0.06149847f, 0.00180971f, -0.01766594f, -0.09795537f, 0.16286895f, -0.04476379f, -0.21166858f, 
    -0.02401562f, -0.08404744f, -0.02743955f, -0.07254658f, -0.16180871f, -0.06397260f, -0.22886357f, -0.20865034f, 
    0.02043417f, -0.41828400f, -0.33664301f, 0.22643025f, 0.10506614f, -0.04250375f, 0.06855302f, 0.10977758f, 
    -0.07656282f, -0.05809858f, 0.01263990f, 0.01796894f, -0.17090923f, -0.37265706f, -0.15403865f, 0.01408963f, 
    -0.13537405f, 0.01281102f, 0.13216755f, -0.23079726f, 0.05131603f, 0.04072696f, 0.14404243f, 0.12299041f, 
    -0.16752401f, -0.13479245f, -0.33029836f, 0.00676308f, 0.11561339f, 0.12977003f, 0.12336536f, 0.11886594f, 
    0.11734843f, 0.03511836f, 0.14987634f, 0.11298265f, -0.20857483f, -0.19260274f, -0.10717493f, 0.03588828f, 
    0.19210972f, 0.08935110f, 0.12923989f, 0.19101642f, -0.20596899f, -0.05883607f, -0.10249183f, -0.30490631f, 
    0.03789937f, -0.07632081f, -0.02962184f, -0.07296754f, 0.12179040f, 0.05433031f, 0.04742450f, -0.01142925f, 
    0.04622373f, 0.03693680f, 0.16719425f, 0.07344675f, -0.02083521f, 0.06283065f, -0.04537206f, -0.05200773f, 
    -0.08097607f, -0.07896852f, -0.02942428f, -0.08740229f, 0.03353851f, 0.04224097f, -0.10341664f, -0.05256573f, 
    -0.02787136f, -0.42737892f, -0.24661867f, -0.05363769f, 0.05688112f, 0.11563646f, -0.01515104f, -0.03895939f, 
    -0.12259436f, -0.00039675f, -0.04275381f, 0.04039894f, -0.32380313f, -0.32941306f, -0.21954347f, 0.29768801f, 
    0.05541197f, 0.09643696f, 0.10386745f, -0.03274260f, 0.00239673f, -0.01665855f, -0.00471751f, 0.04112061f, 
    0.13329650f, -0.04631178f, -0.13788484f, -0.07002346f, -0.05367841f, -0.19899341f, 0.02044421f, -0.10516953f, 
    0.07487076f, -0.12504977f, -0.05435178f, 0.00019555f, -0.01480626f, -0.07927473f, -0.11060107f, -0.15396038f, 
    -0.02808518f, -0.05172136f, -0.02453697f, -0.00991127f, 0.10909540f, 0.08116601f, 0.10754380f, 0.14740376f, 
    0.02133260f, -0.02090978f, -0.09202760f, -0.04465069f, -0.07173089f, -0.07359091f, -0.02360083f, 0.07564713f, 
    -0.05366567f, -0.03434349f, -0.04516685f, 0.04535441f, 0.39238906f, 0.05848752f, -0.25063252f, -0.12415010f, 
    0.19837888f, -0.07138571f, -0.04623518f, 0.03275384f, 0.12472881f, -0.02551113f, 0.12084520f, 0.12826297f, 
    -0.05627061f, -0.02641142f, -0.00070128f, 0.01456005f, -0.02950676f, -0.04687243f, -0.04061815f, -0.01887318f, 
    0.07196528f, 0.01507883f, 0.00159718f, 0.04213610f, 0.63810855f, 0.20305729f, -0.03258361f, -0.05407710f, 
    -0.19804485f, 0.01946384f, 0.03993504f, -0.19468291f, 0.01217649f, -0.03105160f, 0.10760091f, -0.00130026f, 
    0.23998897f, -0.47456837f, -0.57814330f, -0.48307747f, 0.07194043f, 0.06406529f, 0.08414034f, 0.01551899f, 
    0.02671082f, 0.11593513f, 0.00583404f, 0.00211286f, -0.03100310f, -0.26537889f, 0.02088736f, -0.18887810f, 
    -0.05429223f, 0.06643632f, 0.01923396f, 0.03904850f, 0.05918404f, 0.01043614f, -0.04061833f, -0.06510617f, 
    -0.15769944f, -0.15212230f, -0.03452230f, 0.02859909f, 0.07627642f, 0.11322984f, -0.02734456f, -0.02491075f, 
    0.04411304f, 0.00066948f, -0.00138348f, 0.04068350f, -0.08134678f, -0.12573496f, -0.24963225f, 0.15928970f, 
    0.09089701f, -0.08939328f, 0.14024086f, 0.00649826f, 0.02233737f, 0.08538353f, -0.11160869f, 0.10520262f, 
    -0.44208232f, -0.61777008f, -0.32770848f, -0.03246011f, -0.08568170f, -0.05648598f, -0.09847743f, -0.12809043f, 
    -0.05924139f, -0.00069889f, -0.03847088f, 0.08139089f, -0.09899805f, -0.07127568f, 0.11777371f, -0.06328268f, 
    0.04056571f, 0.04766492f, -0.11425925f, 0.01971442f, -0.01929489f, -0.00312855f, 0.07017582f, -0.01179324f, 
    -0.23200861f, -0.21171317f, -0.13542302f, 0.16716634f, -0.05227952f, 0.12998343f, 0.06474291f, 0.06560490f, 
    -0.06345825f, 0.14506049f, 0.07699165f, -0.04495862f, 0.18131974f, 0.17550457f, -0.01142444f, -0.18947066f, 
    -0.06912601f, -0.11849035f, -0.00129662f, -0.03119700f, 0.09565090f, -0.08466902f, 0.00160091f, 0.12388878f, 
    -0.03041759f, -0.05612724f, 0.13033779f, 0.05393619f, -0.00014498f, -0.04951092f, -0.20771855f, -0.13129120f, 
    -0.00151923f, -0.09248601f, -0.06471550f, -0.01389009f, 0.06392072f, 0.02876175f, 0.44076794f, -0.17930567f, 
    0.00212806f, -0.16906467f, -0.06423270f, -0.17552003f, 0.00283881f, 0.01931284f, 0.05860568f, 0.10589983f, 
    -0.25152171f, 0.11611813f, -0.47876099f, 0.31458014f, -0.08455539f, 0.09926363f, 0.11644670f, 0.07600537f, 
    -0.02805615f, -0.02177959f, -0.04190750f, -0.12722185f, -0.42353916f, -0.12585317f, 0.10032781f, 0.36765352f, 
    -0.00487012f, 0.08384609f, -0.05225712f, -0.16648516f, -0.07238182f, 0.04033490f, 0.04452806f, 0.08590835f, 
    -0.44871548f, 0.19333790f, 0.00632537f, -0.11293325f, 0.04030316f, -0.12954313f, 0.15337224f, 0.19671832f, 
    -0.04571063f, -0.01334237f, 0.03449306f, -0.01209711f, -0.27237311f, -0.11784041f, -0.00892205f, -0.05377971f, 
    -0.01245631f, 0.04837253f, 0.06873672f, -0.00338402f, 0.06177143f, 0.08182222f, -0.05212458f, 0.00871142f, 
    -0.28470638f, -0.30386460f, -0.08099966f, -0.26505825f, 0.06916940f, 0.04043525f, 0.03711096f, 0.15342976f, 
    0.04830318f, 0.01214803f, 0.03396167f, 0.17267863f, 0.02382714f, 0.01387865f, 0.13633893f, -0.33465719f, 
    -0.00661212f, 0.15496987f, 0.07371116f, 0.16852219f, 0.05911629f, 0.06497907f, -0.07962450f, -0.04622583f, 
    0.31481779f, -0.36124632f, 0.12321197f, -0.40568379f, 0.08268525f, -0.17428392f, -0.10436936f, 0.01454620f, 
    -0.11809633f, -0.09823991f, -0.05813925f, 0.01072243f, 0.06398908f, 0.08541396f, 0.08254132f, -0.25760898f, 
    0.04014377f, -0.09762916f, -0.16579443f, 0.08069062f, 0.08076489f, -0.03503258f, -0.05328067f, 0.01426774f, 
    -0.03903541f, 0.14435428f, 0.13446373f, 0.21450713f, 0.03788103f, 0.01587760f, -0.06349526f, -0.04150604f, 
    0.08737144f, -0.13056234f, 0.08528992f, 0.14738667f, -0.53156859f, -0.65952033f, 0.14450638f, -0.24083242f, 
    -0.06307723f, 0.21173491f, -0.00429572f, 0.15615445f, 0.09869123f, -0.00210489f, 0.00233623f, -0.04734489f, 
    -0.17134950f, -0.02844317f, 0.03509057f, -0.31733692f, 0.11446077f, -0.18956825f, 0.12553260f, -0.04101100f, 
    -0.03749582f, 0.02512290f, 0.01265427f, -0.00685238f, 0.14321695f, 0.18027541f, 0.15504964f, 0.21729454f, 
    -0.06373857f, -0.01789520f, -0.10901196f, -0.08003844f, 0.04096601f, 0.05213414f, 0.00693752f, -0.00995153f, 
    -0.02197268f, 0.06179830f, 0.06676803f, 0.07295313f, 0.09293500f, 0.03942407f, -0.03655082f, -0.02828413f, 
    0.02535038f, 0.10066389f, 0.08232685f, -0.06661765f, -0.14868182f, -0.10293185f, -0.29641247f, 0.10404976f, 
    0.07730631f, 0.01390770f, 0.13054517f, -0.07871169f, 0.06221041f, -0.09738962f, 0.00725615f, -0.02740408f, 
    -0.47059336f, -0.34644169f, 0.24672592f, -0.01861184f, 0.02611580f, 0.22162639f, -0.09685139f, -0.00214304f, 
    0.09390316f, 0.07732524f, 0.05298513f, 0.04634907f, 0.21756910f, -0.25216788f, 0.20419815f, 0.14000346f, 
    0.05018932f, -0.17678782f, -0.03580742f, -0.02266399f, -0.16605799f, 0.18567204f, -0.04505280f, -0.04802894f, 
    -0.15290554f, -0.10362938f, -0.42408994f, -0.04870567f, -0.02062116f, -0.08982013f, -0.00638470f, -0.05249259f, 
    -0.00471727f, -0.15291436f, -0.11137334f, 0.04161928f, 0.06142622f, 0.13819964f, 0.18308511f, 0.06083862f, 
    0.07693895f, -0.12695526f, -0.00705533f, -0.11902121f, 0.14744022f, -0.04406520f, -0.02083141f, 0.09023061f, 
    -0.01466851f, -0.56599456f, 0.28152436f, -0.14975819f, 0.04819902f, 0.06612811f, -0.01746610f, 0.13252938f, 
    -0.07917623f, -0.01094458f, -0.06315883f, 0.00337504f, -0.05909742f, -0.11700030f, -0.07294325f, 0.06711757f, 
    0.11735737f, -0.02979262f, 0.07612906f, 0.04564401f, 0.04506990f, -0.13224265f, -0.11587969f, -0.10703507f, 
    0.13162017f, -0.20831746f, -0.18066853f, -0.16707839f, 0.27567831f, 0.02152058f, 0.13094409f, 0.15093318f, 
    0.04440002f, -0.08757755f, -0.03879155f, -0.05219878f, -0.19945584f, -0.41166338f, -0.28503019f, 0.16087078f, 
    0.13776508f, -0.07347959f, 0.12638919f, -0.06521922f, -0.00339647f, -0.00120460f, 0.06035035f, 0.07664274f, 
    -0.04603137f, -0.05121545f, 0.48495641f, -0.56213182f, 0.12253473f, -0.10187488f, -0.01402794f, -0.00914477f, 
    -0.08153977f, 0.04844875f, 0.03203722f, -0.11428541f, 0.24435744f, -0.19411919f, 0.12786043f, -0.11590294f, 
    0.00364090f, 0.06333126f, -0.07392986f, -0.02728659f, 0.09498511f, -0.12500331f, -0.10896052f, 0.05325724f, 
    0.29598230f, 0.23112139f, -0.16148566f, -0.20378336f, 0.04359220f, 0.01116250f, 0.07892375f, 0.13995385f, 
    -0.00204689f, 0.03592700f, -0.05914254f, -0.09309661f, -0.49116433f, 0.28183809f, -0.52913129f, 0.05734482f, 
    0.09810369f, -0.13584231f, -0.01776163f, -0.05351800f, -0.01295287f, -0.07136303f, 0.05308747f, 0.02069056f, 
    0.08322456f, 0.24712136f, -0.04745760f, -0.10877716f, -0.12655120f, 0.06269835f, 0.08557731f, 0.04480288f, 
    -0.11733676f, 0.09553646f, -0.02468836f, 0.10308497f, -0.11002040f, -0.07896194f, -0.13198948f, 0.03372943f, 
    0.01633719f, 0.09479667f, -0.01001875f, -0.17211291f, -0.03583447f, -0.01683962f, 0.02226515f, 0.04883587f, 
    -0.03771849f, 0.05972452f, -0.30449641f, -0.07876310f, 0.08319675f, -0.07274728f, -0.05430083f, 0.11774860f, 
    0.04320091f, -0.09453308f, 0.12106227f, -0.04538999f, -0.31874993f, -0.20205610f, 0.18335305f, -0.06282547f, 
    0.08545842f, -0.01481592f, -0.21049888f, 0.13471922f, 0.07902163f, 0.13235860f, -0.10449846f, 0.02820858f, 
    -0.05859012f, -0.02612487f, 0.03391343f, -0.30278447f, -0.06124562f, -0.04290293f, -0.06742996f, 0.01141683f, 
    -0.04303917f, -0.02957837f, -0.02183911f, 0.11704475f, -0.34033230f, 0.04202056f, -0.01169365f, 0.02062457f, 
    0.15644847f, -0.08069696f, 0.01362130f, -0.03095387f, 0.11201074f, -0.03581594f, -0.01990889f, -0.14840302f, 
    0.02925092f, -0.17600973f, -0.11965989f, -0.09223073f, 0.17083555f, 0.01918159f, -0.00191319f, 0.10409959f, 
    -0.05431631f, -0.12057284f, -0.11247913f, -0.08519229f, -0.03244523f, 0.13111494f, 0.10353112f, 0.03260325f, 
    0.00596705f, -0.04428843f, 0.07526373f, 0.02408136f, 0.08389094f, 0.16907088f, 0.13098495f, 0.10867506f, 
    0.03258622f, -0.00633740f, 0.01193715f, -0.04582738f, 0.02323079f, 0.01504893f, 0.08945762f, 0.06683986f, 
    0.18852633f, 0.10424355f, 0.11124045f, 0.20241520f, -0.65037394f, 0.40495250f, -0.16329022f, 0.06086684f, 
    -0.17457820f, -0.18598627f, 0.13573900f, 0.06966964f, 0.05623903f, 0.01375410f, 0.00435042f, -0.13012777f, 
    -0.25870374f, 0.26755145f, 0.39845851f, -0.42220679f, 0.07476109f, -0.34131697f, 0.06952972f, -0.09079213f, 
    -0.13193454f, 0.04535875f, 0.06462252f, 0.02771037f, 0.29928768f, 0.05433066f, 0.04993339f, -0.23189978f, 
    -0.06704650f, 0.06214986f, 0.09608585f, 0.08940753f, 0.10624506f, 0.11335556f, -0.02183572f, -0.02968784f, 
    -0.22529662f, 0.14375091f, 0.08155950f, 0.09163750f, -0.06322468f, -0.08295409f, 0.02059215f, -0.03202872f, 
    0.08823086f, 0.06765408f, 0.03808383f, 0.05501436f, -0.01603532f, -0.15341900f, -0.14408013f, 0.07269770f, 
    0.04229375f, 0.08901571f, 0.08603109f, -0.01102639f, -0.03384375f, 0.17985412f, 0.01339881f, 0.07286283f, 
    -0.18748620f, 0.25144878f, -0.01463642f, -0.30443993f, -0.25347388f, -0.07618017f, 0.01654152f, 0.09161099f, 
    0.04534357f, 0.00273950f, -0.02201051f, 0.01613058f, -0.00078221f, -0.05468658f, 0.00196098f, -0.41572869f, 
    -0.21134777f, 0.00241887f, 0.06399658f, 0.20732956f, -0.00301810f, -0.02102178f, 0.02193882f, 0.00005617f, 
    0.07950816f, 0.21105593f, 0.11702978f, -0.14556506f, -0.02257069f, -0.21647352f, -0.13644977f, 0.06465738f, 
    -0.09302336f, 0.02486528f, -0.00788317f, 0.00744328f, -0.04742884f, 0.13021664f, 0.04539715f, 0.17550753f, 
    0.00220704f, -0.14597888f, -0.15911342f, -0.09018338f, 0.09393354f, 0.01948409f, 0.15695557f, 0.10840557f, 
    -0.10812894f, 0.12121191f, -0.21446416f, 0.04005395f, 0.14029957f, -0.25089538f, 0.07299556f, -0.00259896f, 
    0.10675621f, -0.07012310f, -0.03797401f, -0.02803661f, -0.08529105f, -0.21255137f, 0.13409685f, -0.00259311f, 
    -0.00389427f, 0.04325982f, -0.11762591f, 0.00731981f, 0.18892081f, 0.11276044f, -0.04859407f, -0.04924450f, 
    0.16649444f, -0.22431675f, -0.21701248f, 0.08229586f, -0.09427072f, -0.05910143f, -0.04954669f, 0.11220243f, 
    0.04416087f, 0.02360700f, 0.09566137f, 0.00551265f, 0.15227629f, -0.14713494f, -0.06062099f, -0.61056405f, 
    -0.18874894f, -0.12443330f, 0.09427997f, -0.17792590f, 0.04607909f, -0.06472427f, -0.02957618f, -0.01466627f, 
    -0.15960743f, -0.05270234f, 0.08493808f, 0.28846425f, 0.12572287f, -0.07858554f, 0.04135862f, 0.12993394f, 
    0.09736519f, 0.02588360f, 0.03729521f, 0.10579264f, 0.11273828f, 0.00910217f, 0.10258627f, 0.41546091f, 
    0.07713648f, 0.05298260f, -0.14464080f, 0.02874572f, -0.06878619f, -0.02847767f, -0.02715353f, -0.11665921f, 
    -0.01542493f, 0.15591262f, -0.09160382f, 0.12623200f, 0.13347903f, -0.01446453f, 0.09562642f, -0.00665972f, 
    0.07637081f, -0.02807566f, -0.03379932f, -0.07628251f, -0.36762562f, -0.05650599f, 0.19609684f, 0.19340071f, 
    0.06087732f, 0.00385344f, 0.00565767f, -0.18827377f, 0.15644078f, -0.12807633f, 0.02530623f, 0.00534053f, 
    0.02450694f, 0.18909684f, 0.04040112f, -0.02405773f, 0.21333893f, -0.13987848f, 0.06994219f, 0.14104727f, 
    -0.07943898f, -0.03781619f, -0.01405440f, -0.04335408f, -0.33482218f, -0.96429908f, -0.02835062f, -0.25307414f, 
    0.01204666f, 0.10567483f, -0.03719812f, 0.07382514f, -0.12087289f, 0.00444421f, 0.04109613f, -0.07902674f, 
    -0.02942588f, -0.15638289f, 0.13057418f, 0.33455202f, 0.00760517f, -0.08777928f, -0.12638921f, -0.11793859f, 
    -0.01723472f, -0.00217259f, -0.03156293f, 0.00268968f, 0.07300524f, -0.13843778f, 0.08463336f, 0.22146210f, 
    -0.13545434f, 0.03275935f, -0.09888390f, 0.08508280f, -0.03406311f, 0.03027150f, 0.04260566f, 0.02826011f, 
    0.02306004f, -0.02190724f, 0.44510674f, -0.28125951f, -0.02948412f, -0.26772389f, -0.18350187f, -0.26383108f, 
    -0.18556912f, 0.08120306f, 0.05421141f, -0.08602793f, 0.24352753f, 0.10375795f, 0.23411970f, 0.06407966f, 
    0.12629609f, -0.19318400f, -0.15004158f, -0.11467952f, 0.08638325f, 0.01761498f, -0.22739789f, 0.12635943f, 
    -0.16777717f, 0.00436251f, -0.01799390f, -0.53113091f, -0.26223814f, 0.16561665f, -0.12994859f, 0.25221935f, 
    0.04819470f, 0.00809318f, 0.01493573f, -0.02618627f, -0.04025897f, 0.01758157f, -0.46956646f, -0.00375691f, 
    0.05714223f, 0.19670643f, 0.01868839f, 0.00735387f, 0.12482695f, -0.16433953f, -0.05409801f, -0.10842238f, 
    0.09713382f, 0.08503816f, 0.19677070f, 0.08621211f, 0.05529892f, -0.14659837f, 0.03552475f, -0.23946483f, 
    -0.01858900f, 0.05039638f, 0.04399202f, -0.06805158f, 0.06389566f, -0.35199821f, 0.18298453f, -0.15491389f, 
    0.03245094f, 0.15309738f, -0.09882060f, -0.04425596f, -0.13645223f, -0.08793638f, 0.08194913f, -0.04564606f, 
    -0.18972106f, 0.05800050f, 0.01485358f, -0.03792382f, -0.04417878f, 0.02703996f, 0.07574027f, 0.17494237f, 
    -0.06528961f, 0.01003765f, -0.03705530f, 0.04589529f, -0.38880447f, 0.19741511f, -0.09667872f, 0.17890178f, 
    0.00751096f, -0.02371162f, -0.22836830f, 0.20343159f, -0.15444829f, -0.08778279f, -0.13541548f, -0.09915016f, 
    0.05923168f, 0.07965664f, -0.20394519f, 0.07142819f, -0.04975600f, 0.04272405f, -0.05425287f, -0.15054508f, 
    0.01613841f, -0.01564620f, -0.11026566f, 0.00126839f, 0.26419416f, 0.17427659f, -0.12662908f, 0.02910468f, 
    -0.06361046f, 0.13408928f, 0.15006879f, 0.03778797f, -0.02346065f, -0.13669747f, -0.50885630f, -0.36600423f, 
    -0.19589768f, -0.30079728f, -0.14448383f, 0.13039890f, -0.11872031f, 0.19216371f, -0.03350284f, 0.06350024f, 
    0.01380908f, 0.13023692f, 0.12636571f, 0.05579387f, 0.07335925f, -0.27620968f, 0.16608031f, 0.09377526f, 
    -0.11700948f, -0.11328795f, 0.22497328f, -0.01132553f, -0.03517982f, -0.04449925f, -0.09505843f, 0.03634898f, 
    0.15145440f, -0.29297289f, 0.20636153f, 0.23554651f, -0.08738610f, -0.01010764f, 0.12420576f, -0.11569558f, 
    -0.01317961f, -0.20726763f, -0.05960476f, 0.06673371f, -0.02781531f, -0.18723111f, 0.13949926f, 0.28159148f, 
    0.04373589f, -0.14849164f, 0.00209443f, -0.02944601f, -0.14830442f, -0.12093525f, -0.07996512f, 0.02094316f, 
    -0.08178192f, 0.47129682f, -0.12894805f, 0.24891171f, 0.08280307f, 0.09901688f, -0.03034414f, -0.05957798f, 
    -0.09457099f, 0.12708932f, 0.10227989f, 0.19705765f, 0.13633935f, -0.17599221f, 0.14607431f, 0.09265715f, 
    -0.07110906f, 0.16102052f, -0.00419370f, -0.07242204f, -0.03538968f, -0.03511607f, 0.08163352f, 0.12096081f, 
    -0.14302279f, 0.13938218f, 0.06758934f, -0.22880228f, 0.02615838f, -0.03309772f, -0.16417284f, -0.01085094f, 
    -0.14179027f, 0.04764630f, -0.06777028f, -0.08760241f, -0.25148809f, -0.11926712f, 0.08227400f, 0.12782507f, 
    0.04929107f, 0.18104494f, 0.12447653f, 0.02840057f, -0.00611728f, -0.12984495f, 0.03727196f, 0.05744267f, 
    0.10104553f, -0.08932710f, 0.11128221f, -0.02039738f, -0.13511710f, -0.05255720f, 0.08605774f, 0.13437189f, 
    0.04938667f, 0.02302186f, 0.03399351f, 0.05428531f, -0.04281884f, 0.22080271f, -0.17480972f, -0.03570778f, 
    0.07002153f, 0.04110270f, 0.06017911f, -0.03437839f, -0.16477743f, -0.03074841f, -0.08558651f, -0.02594016f, 
    -0.13652794f, -0.13440777f, -0.10751057f, -0.29101187f, -0.05933319f, -0.12325339f, -0.01662969f, -0.15014651f, 
    0.02151060f, 0.00760324f, 0.01225976f, 0.07487516f, -0.09528509f, 0.04761995f, -0.28390139f, 0.10362543f, 
    -0.25841397f, -0.03544749f, -0.01342188f, -0.03486510f, -0.06853029f, 0.14085187f, -0.07768290f, 0.06524879f, 
    -0.05528560f, -0.41625732f, -0.48457485f, -0.09792358f, 0.03027353f, 0.03858276f, -0.23414719f, -0.12025689f, 
    0.07931726f, 0.00808358f, -0.02429711f, -0.03724282f, -0.22198108f, 0.31657892f, -0.25535536f, 0.21290757f, 
    0.01612041f, -0.05234310f, -0.07466085f, 0.04143224f, -0.06754988f, -0.02336843f, 0.05795360f, 0.10244284f, 
    -0.03919832f, -0.02681638f, 0.43062693f, 0.13653792f, -0.06226105f, 0.02389708f, -0.00179944f, 0.12163895f, 
    0.12964614f, -0.08882714f, -0.04846096f, 0.16751397f, -0.08034465f, 0.01628048f, 0.08948029f, -0.02453219f, 
    -0.09270205f, 0.04887955f, 0.04319369f, -0.05234760f, -0.01928118f, -0.02686483f, 0.06778815f, -0.00700429f, 
    -0.20869708f, -0.07337655f, 0.01234453f, -0.16621438f, -0.16593538f, 0.02280023f, -0.33282742f, 0.09016129f, 
    0.07408021f, -0.12732510f, 0.05509330f, -0.11509386f, -0.12260456f, -0.01781331f, -0.04798751f, -0.06654978f, 
    -0.11027598f, 0.05945546f, -0.00669817f, 0.04415554f, 0.04966794f, 0.06413000f, 0.10846929f, 0.10491721f, 
    -0.11967373f, -0.15943575f, 0.14425208f, -0.00010488f, -0.09221183f, 0.10646003f, -0.20757961f, 0.00244816f, 
    -0.04855059f, 0.06117583f, -0.06644633f, -0.07251159f, -0.70998460f, 0.45814070f, -0.07415816f, 0.38355348f, 
    0.01649567f, 0.05352484f, -0.07750022f, -0.05972157f, -0.11214029f, -0.01106130f, 0.06486344f, -0.17628743f, 
    -0.12164543f, 0.12842482f, 0.09644402f, 0.06232836f, -0.02039577f, 0.05538690f, -0.07973205f, 0.09094428f, 
    0.05921522f, -0.01613741f, 0.03503661f, -0.11345979f, -0.07105335f, 0.15030397f, -0.14761926f, 0.06799666f, 
    -0.07168656f, 0.11041043f, 0.01749295f, -0.06893255f, 0.04890651f, 0.12919863f, -0.07800514f, 0.07995124f, 
    -0.24756160f, -0.18135230f, -0.23083857f, 0.01544828f, 0.07037202f, -0.02117873f, -0.05310168f, -0.06807378f, 
    -0.07400218f, 0.02145085f, -0.12402847f, -0.03803940f, 0.09452573f, -0.11726584f, 0.28487533f, 0.21379325f, 
    -0.28915587f, 0.10176938f, 0.12892355f, -0.06883506f, 0.13553999f, 0.03124994f, 0.06480549f, 0.01400483f, 
    -0.18955798f, 0.02742409f, -0.04619041f, -0.06736993f, 0.02368540f, -0.04835491f, -0.00401686f, -0.00797331f, 
    -0.20218328f, -0.21765597f, -0.06540300f, -0.01529301f, -0.19554022f, 0.24072573f, -0.18728694f, 0.04697704f, 
    0.02377366f, 0.05543311f, 0.21539132f, 0.00584270f, 0.07729197f, 0.03464903f, 0.01320986f, 0.06856709f, 
    -0.19958584f, 0.16435815f, -0.24973425f, -0.07196701f, -0.00247643f, 0.00071453f, -0.06693565f, 0.12391925f, 
    -0.15597211f, 0.02313768f, 0.00427862f, -0.00205188f, -0.09968660f, -0.10755865f, 0.11453467f, -0.19617228f, 
    -0.09186459f, 0.12128967f, -0.25475961f, 0.02015174f, -0.08121282f, -0.19717549f, 0.04762832f, -0.10531022f, 
    0.19019239f, 0.07834593f, 0.34129512f, 0.08450492f, -0.05621990f, -0.09776746f, 0.08812219f, -0.02257953f, 
    -0.28557986f, 0.02045757f, -0.17754734f, -0.16972266f, -0.09078556f, 0.15988289f, 0.27102417f, 0.13246112f, 
    0.02885994f, 0.01902373f, 0.06074254f, -0.01529932f, -0.02597526f, 0.02682406f, 0.01298175f, 0.14515272f, 
    -0.02984178f, -0.00011021f, 0.04908650f, 0.19633985f, -0.02033196f, 0.01836272f, -0.01056897f, 0.20180432f, 
    0.10863339f, 0.05799971f, 0.17284741f, 0.19188289f, -0.13959719f, -0.02455554f, -0.05693364f, -0.06627104f, 
    0.00870813f, -0.10669499f, -0.07242977f, 0.12815765f, -0.39679334f, -0.21282855f, -0.29918662f, -0.13771117f, 
    -0.11399192f, -0.01796123f, 0.00316163f, 0.04080132f, 0.00499213f, 0.00053417f, 0.02907226f, 0.10678960f, 
    -0.17840414f, -0.12873334f, -0.33492240f, -0.64832264f, 0.23114604f, -0.06228726f, 0.19597252f, -0.15012255f, 
    -0.10384156f, -0.06938015f, 0.04713828f, -0.02404844f, -0.01604486f, 0.08173507f, -0.13833268f, 0.06666404f, 
    -0.05971299f, -0.11067830f, 0.05935547f, 0.15911359f, 0.10261829f, -0.19593434f, 0.04691235f, 0.06287723f, 
    0.03397361f, 0.06485970f, -0.07358594f, -0.18999358f, -0.27480304f, 0.24491391f, -0.33908367f, 0.26025262f, 
    0.11723080f, 0.02178565f, -0.03660666f, 0.05117859f, 0.03207518f, 0.01648967f, 0.07187168f, -0.04515483f, 
    0.03151891f, -0.50554341f, -0.26619044f, -0.13372439f, -0.03923197f, 0.06098687f, -0.12369651f, 0.00674574f, 
    0.00734204f, 0.05973262f, 0.01441033f, 0.01735039f, 0.03482198f, -0.15131097f, -0.26722097f, -0.02452173f, 
    -0.17051315f, -0.03377288f, -0.04421267f, -0.15284497f, -0.21644743f, -0.09505907f, -0.16417007f, -0.07257838f, 
    -0.05346208f, -0.19000955f, 0.23661643f, 0.17885251f, -0.03049035f, 0.03378591f, -0.00824657f, -0.03540616f, 
    0.00340855f, -0.03970236f, 0.09393759f, 0.07016031f, 0.08359768f, -0.18527026f, -0.11807447f, 0.17024912f, 
    0.05862007f, 0.03203059f, -0.19501056f, 0.04784563f, 0.09307726f, 0.02980674f, -0.01637662f, -0.06394541f, 
    0.20121446f, 0.11951850f, 0.10589670f, -0.15632164f, -0.12113311f, 0.03188840f, 0.06478781f, 0.07380749f, 
    0.11041167f, -0.22084635f, -0.02064539f, 0.00737308f, 0.17822787f, 0.06868019f, 0.11745534f, -0.17361414f, 
    0.03360479f, -0.13406740f, 0.05398067f, 0.18613951f, -0.08818385f, -0.02420899f, -0.32082573f, -0.21600968f, 
    -0.01460044f, 0.11157460f, -0.02486496f, -0.10500402f, -0.07440397f, 0.01907266f, 0.18694408f, 0.08394556f, 
    0.06019123f, 0.12910029f, -0.01248432f, 0.08638620f, -0.04946550f, 0.06094011f, 0.26013559f, -0.10894646f, 
    -0.00212338f, -0.09940786f, 0.10812987f, -0.00260227f, -0.18407503f, -0.31300187f, -0.23199573f, 0.03743376f, 
    -0.20737335f, -0.09214216f, -0.13718177f, 0.03536639f, 0.02917405f, -0.08483294f, 0.02309722f, 0.06770667f, 
    0.06887916f, 0.09402329f, -0.13545725f, -0.18954860f, -0.10405216f, 0.02987303f, 0.11522699f, 0.19503132f, 
    0.11046636f, -0.05054973f, 0.08961534f, -0.07233709f, -0.03312817f, 0.08817482f, 0.09701826f, -0.14659779f, 
    -0.42379037f, 0.16417061f, -0.40344423f, 0.05585248f, -0.06864128f, 0.13429667f, -0.23045583f, 0.02370350f, 
    -0.10884208f, 0.04225263f, -0.01831747f, -0.08289850f, -0.16785756f, 0.21015666f, -0.08601195f, -0.15463738f, 
    -0.02350343f, 0.00123483f, 0.08625847f, -0.20548896f, 0.08127759f, 0.10829254f, 0.12105885f, 0.18564875f, 
    -0.25460786f, 0.16734855f, -0.02301521f, -0.04942368f, 0.02657884f, 0.08219545f, -0.02882000f, -0.03049307f, 
    -0.14877006f, 0.00109908f, 0.01783475f, 0.05840179f, -0.39888009f, 0.18162970f, 0.20341381f, -0.30518275f, 
    -0.16714486f, 0.01985643f, 0.09552975f, 0.07315435f, -0.00989143f, -0.00877503f, 0.15686415f, 0.00647916f, 
    -0.07418058f, -0.09016308f, -0.02345997f, 0.02654328f, -0.07483477f, 0.01953682f, 0.06727435f, 0.06887877f, 
    -0.01198107f, 0.15335713f, 0.03873327f, 0.10417610f, -0.57288623f, 0.13607658f, -0.01509264f, 0.30683213f, 
    0.14451171f, -0.09613311f, -0.21936885f, 0.12255779f, 0.03078871f, -0.02885908f, 0.04073985f, -0.16752510f, 
    -0.17319107f, 0.04933145f, -0.05441211f, 0.06828618f, -0.02259134f, 0.17157803f, 0.03743968f, 0.00869626f, 
    0.00134030f, 0.02480852f, -0.03506523f, -0.00419300f, -0.00188999f, 0.23226584f, -0.10985148f, -0.03730294f, 
    0.02863032f, -0.03373674f, -0.04623739f, -0.03969166f, 0.01532067f, 0.12444649f, -0.18689235f, -0.04308518f, 
    -0.30831996f, 0.22477657f, -0.08112462f, 0.00911856f, 0.00206370f, -0.06659774f, 0.05624807f, 0.05026605f, 
    0.00022339f, -0.01664722f, 0.01688257f, -0.07223767f, -0.03438441f, 0.06603857f, 0.41716340f, -0.01469058f, 
    -0.14723800f, 0.05456195f, 0.12459018f, -0.01667869f, 0.05692994f, -0.07165346f, 0.24299127f, 0.05857407f, 
    -0.06487898f, -0.10723224f, -0.15677227f, 0.22312902f, -0.13689606f, 0.04453772f, 0.18497583f, 0.01112403f, 
    0.05354756f, 0.04734561f, 0.07939416f, 0.12232318f, -0.05016678f, 0.19093966f, -0.02129125f, -0.16856304f, 
    -0.09791785f, 0.04193822f, 0.14312086f, -0.08319890f, -0.14574122f, 0.06753758f, 0.22370820f, 0.12110654f, 
    0.43484578f, -0.15740696f, 0.23612784f, -0.16789354f, -0.09851232f, 0.08756566f, 0.03598329f, -0.01285797f, 
    0.04976409f, -0.00906567f, -0.10857431f, -0.20257393f, -0.30808774f, 0.16602077f, -0.16837916f, 0.30182955f, 
    -0.01314728f, 0.11237652f, -0.00821251f, -0.05118203f, -0.04456112f, 0.00869760f, 0.09216365f, 0.16677679f, 
    -0.06415132f, -0.04144102f, -0.12846109f, 0.11869455f, 0.05712152f, 0.08140017f, 0.11611236f, 0.04331582f, 
    0.03954608f, 0.08170962f, -0.09207349f, -0.02617523f, -0.15337034f, -0.31069297f, 0.13800797f, -0.00145296f, 
    -0.10395192f, -0.03844418f, -0.01615786f, 0.06229983f, 0.01106615f, 0.08361863f, -0.04120334f, 0.01434620f, 
    0.15202047f, -0.16143468f, 0.41604874f, 0.29663536f, -0.03784485f, -0.17432298f, -0.00479333f, -0.11327303f, 
    -0.14358236f, -0.01086179f, -0.01443572f, -0.07602352f, -0.32901520f, -0.22056845f, -0.15203764f, -0.15920615f, 
    0.07573799f, 0.03236551f, 0.03491145f, 0.16698866f, 0.06009874f, -0.00824139f, 0.17407386f, 0.09404232f, 
    0.12840562f, -0.08428609f, 0.09828488f, -0.02180543f, -0.04275152f, -0.18274777f, -0.25260547f, -0.22083054f, 
    -0.02349066f, -0.08900134f, -0.16654734f, -0.11202507f, 0.10186040f, -0.04646011f, 0.11602834f, -0.02751656f, 
    -0.12906255f, 0.10433154f, -0.20328696f, 0.07870542f, -0.06359106f, -0.12948631f, 0.09680522f, 0.03569249f, 
    -0.14292476f, 0.18653481f, 0.18648551f, -0.31525293f, -0.11739358f, 0.10258938f, 0.00765545f, -0.07260434f, 
    0.04893275f, 0.01856557f, 0.07630959f, 0.06510484f, -0.36570433f, 0.37231734f, -0.08232614f, 0.20094904f, 
    -0.22012281f, 0.13645452f, 0.03607823f, -0.08612301f, 0.02736565f, 0.07787116f, 0.05183907f, -0.09247235f, 
    -0.48631665f, 0.19995001f, -0.59882271f, 0.36285031f, 0.09317020f, -0.10982401f, 0.09485883f, 0.06988695f, 
    -0.21701935f, -0.15597980f, -0.04208490f, -0.01858886f, -0.11517438f, 0.07092233f, -0.13639154f, 0.11101915f, 
    -0.19371746f, 0.07527784f, 0.18748626f, 0.17952925f, -0.13517125f, 0.03124398f, -0.03930188f, -0.00307664f, 
    -0.24149601f, -0.11519965f, -0.10280889f, 0.00521057f, 0.00171707f, -0.02275089f, 0.02642769f, -0.04771173f, 
    0.02015490f, -0.00560946f, -0.06446639f, -0.03203076f, -0.50772053f, 0.17110808f, -0.30932635f, 0.27826980f, 
    -0.01547888f, 0.07052596f, 0.00038107f, -0.32688630f, -0.03370833f, -0.01986508f, -0.06256364f, 0.02726160f, 
    -0.01467920f, -0.04756743f, 0.02494192f, -0.19776638f, 0.08271342f, -0.03647067f, -0.15370704f, 0.06407209f, 
    -0.04821225f, 0.01136282f, -0.12330218f, -0.13432920f, -0.21780889f, -0.03280770f, -0.15043093f, 0.18628117f, 
    0.11182216f, -0.07603205f, 0.04252988f, -0.08631437f, -0.06168269f, -0.01617409f, 0.06409015f, 0.00559925f, 
    -0.07138449f, -0.04112944f, -0.08228015f, -0.01133242f, 0.02441732f, -0.02651957f, -0.03712505f, -0.02111976f, 
    0.03840989f, 0.07298216f, -0.02495858f, -0.01223228f, 0.28011757f, 0.13420735f, 0.26662549f, -0.10549518f, 
    0.02878037f, 0.11605582f, -0.04927041f, 0.10658710f, -0.09182157f, 0.00753514f, 0.07177953f, -0.04720113f, 
    -0.45920685f, -0.12430265f, -0.18536061f, 0.32620189f, -0.12579271f, 0.12643400f, 0.14505892f, -0.24815324f, 
    0.00446032f, 0.04321506f, -0.04486288f, 0.07785147f, -0.67513478f, -0.04621423f, -0.33049202f, 0.30291992f, 
    0.03462930f, -0.03956759f, -0.00223793f, 0.19212812f, -0.16196243f, 0.01908631f, 0.05195634f, -0.07594172f, 
    -0.07648283f, 0.14721712f, 0.34677872f, -0.39242190f, 0.14372285f, 0.07070163f, 0.06701883f, 0.03049963f, 
    0.07105441f, -0.01941476f, -0.10191291f, 0.05680708f, 0.04544042f, -0.09212137f, 0.02238976f, -0.04817801f, 
    -0.01669222f, 0.10715294f, 0.03956031f, 0.01156937f, 0.02578080f, 0.16590621f, -0.08044922f, -0.07958909f, 
    -0.15245984f, 0.43262100f, -0.12529743f, -0.14070086f, -0.02083487f, -0.02204204f, 0.20566010f, 0.08536913f, 
    -0.04880369f, 0.02497953f, 0.03347494f, 0.02445582f, 0.19381292f, 0.17448010f, 0.09481692f, -0.06312279f, 
    -0.06759225f, 0.16317964f, -0.09936338f, 0.16228874f, -0.08759720f, -0.02545233f, 0.08113471f, -0.07110514f, 
    0.47658119f, 0.21454845f, 0.06203895f, -0.07729296f, -0.08170321f, 0.12725633f, -0.01730962f, 0.11244258f, 
    -0.01667252f, 0.07204454f, 0.02534722f, -0.02503304f, 0.01509206f, -0.29380274f, 0.00815713f, 0.35432300f, 
    0.18649186f, -0.09147258f, 0.00376285f, 0.17744946f, 0.16294779f, 0.03819105f, 0.08736949f, 0.03565188f, 
    -0.11656230f, -0.25253761f, 0.05155995f, 0.36531168f, 0.04766506f, 0.03606111f, 0.02677741f, 0.22111702f, 
    -0.17155339f, -0.09328145f, -0.06400972f, 0.03042596f, 0.00291163f, 0.13644050f, 0.03159132f, 0.16219448f, 
    0.04589584f, -0.05430925f, 0.11025483f, 0.00167409f, 0.03272462f, -0.00221826f, 0.01872958f, -0.04096940f, 
    0.21509339f, -0.08422443f, 0.25534424f, -0.00340218f, -0.04074103f, 0.06632830f, -0.40729997f, -0.08984242f, 
    -0.03469083f, -0.03234938f, 0.08425467f, 0.04613139f, 0.13199592f, -0.23725484f, 0.28882322f, -0.26581335f, 
    0.18793467f, -0.06937309f, 0.06233716f, -0.04386395f, -0.03444625f, 0.25366583f, 0.05920519f, 0.05642223f, 
    0.24174286f, -0.12033211f, 0.29349083f, 0.08151371f, 0.16595723f, 0.02568276f, 0.03013020f, -0.06510857f, 
    0.04501897f, 0.07779230f, 0.03323137f, 0.19155739f, 0.31045628f, -0.12829594f, 0.15075429f, 0.12635694f, 
    0.09111521f, -0.09983262f, 0.09954689f, 0.07999303f, -0.23774724f, -0.05860928f, -0.04152745f, -0.09316784f, 
    0.40611112f, -0.19192353f, 0.10707102f, 0.09345724f, 0.15765037f, -0.09761414f, 0.02509416f, 0.12340759f, 
    -0.02305976f, -0.18624997f, 0.04699295f, 0.09235851f, -0.24366492f, 0.00896694f, -0.26770824f, 0.09505976f, 
    -0.03914243f, 0.12939908f, 0.20241092f, -0.03964445f, 0.19860750f, 0.11369415f, 0.01393607f, 0.01113242f, 
    0.10311947f, 0.16298468f, -0.08147150f, 0.08874634f, 0.01845820f, 0.25888237f, 0.09455717f, 0.09525029f, 
    0.08794681f, 0.19999163f, 0.07615408f, 0.12313403f, 0.11915383f, 0.02504057f, -0.04213797f, -0.07269493f, 
    -0.11070582f, 0.12299699f, -0.09305078f, 0.08774563f, 0.01759106f, -0.05596009f, 0.13437626f, 0.01388797f, 
    0.12195142f, 0.05916445f, 0.20818108f, -0.05595327f, -0.08914544f, 0.08552911f, -0.22259814f, -0.01559227f, 
    -0.03303890f, -0.11376536f, -0.01385940f, -0.22536460f, 0.01260766f, 0.02284466f, 0.03538591f, -0.01878330f, 
    0.05815831f, 0.05797142f, 0.01168568f, 0.09566396f, 0.00852868f, 0.13924707f, 0.10910445f, -0.03800350f, 
    0.04860155f, -0.01774273f, 0.05861924f, -0.04975467f, -0.04049545f, 0.02254555f, -0.05573349f, 0.04088244f, 
    0.14671069f, 0.09951506f, 0.09144092f, 0.09635667f, -0.02424875f, -0.74661469f, 0.11255647f, -0.30176243f, 
    0.00667849f, -0.16470411f, 0.13728356f, -0.01126584f, 0.05953321f, 0.09045337f, 0.03906757f, -0.00042365f, 
    -0.06661604f, -0.29417333f, 0.27650565f, -0.25605127f, -0.06426808f, 0.06371403f, -0.04583379f, 0.09068138f, 
    -0.04454739f, 0.06207080f, 0.08517762f, -0.13019003f, -0.53312653f, -0.31315643f, -0.30849391f, 0.14763494f, 
    -0.23819794f, -0.21718758f, -0.02182521f, -0.23872960f, 0.01686705f, 0.01596103f, -0.03980651f, 0.05232647f, 
    -0.04519747f, -0.24463472f, -0.08992025f, -0.20006388f, -0.14392237f, -0.17804699f, 0.06689376f, -0.16011918f, 
    0.05896330f, 0.02030474f, -0.08798067f, -0.02997068f, 0.15494050f, 0.16855192f, 0.00791957f, 0.06113274f, 
    -0.08964610f, -0.00564119f, 0.02094939f, 0.06305315f, 0.01090129f, 0.06815474f, 0.15788363f, -0.02143608f, 
    0.07316777f, 0.06863713f, 0.22298954f, -0.14545767f, -0.07477280f, 0.04918651f, 0.07956325f, -0.05764387f, 
    0.05351410f, 0.07443208f, 0.01179722f, -0.13719699f, -0.13937114f, -0.19795457f, -0.15649517f, 0.04204894f, 
    -0.12275259f, -0.05234189f, -0.00663737f, 0.14747907f, -0.02294462f, 0.06668619f, -0.04174214f, 0.04415137f, 
    -0.15371975f, -0.24168243f, -0.22884429f, -0.13320072f, 0.05032809f, -0.13781394f, 0.05738324f, -0.10997775f, 
    -0.10866330f, 0.09202725f, -0.05094401f, -0.05650642f, 0.09975476f, -0.07340375f, -0.08110677f, -0.42083174f, 
    -0.03104706f, -0.09156402f, 0.10721681f, -0.05412905f, -0.05728287f, 0.10674772f, 0.05730098f, 0.10695018f, 
    0.23434198f, -0.11468345f, 0.16176488f, -0.08187202f, 0.10040835f, 0.07135659f, -0.22544336f, 0.17942375f, 
    -0.14040135f, -0.03394486f, -0.20691676f, -0.05630446f, -0.00326546f, 0.04785023f, -0.26713258f, 0.11003900f, 
    0.02114790f, 0.09470145f, -0.04459185f, -0.10597347f, -0.02664518f, 0.11507845f, 0.20933470f, 0.05917769f, 
    0.14062861f, 0.16336246f, 0.10183235f, -0.15248957f, -0.16780099f, -0.02738909f, 0.01358283f, 0.16825663f, 
    -0.06171490f, -0.02738256f, 0.00286549f, 0.10879982f, -0.18131165f, 0.55458099f, -0.06339481f, -0.25809571f, 
    0.04168245f, -0.07976969f, 0.04882008f, -0.00445284f, -0.02914054f, 0.01224900f, -0.14202656f, -0.01887067f, 
    -0.09865090f, -0.14153121f, 0.18119128f, 0.04421423f, -0.00112698f, -0.01769068f, -0.01461474f, 0.10954338f, 
    -0.01285529f, 0.07821170f, 0.18104112f, -0.02914595f, -0.26260582f, -0.21093687f, -0.22601528f, 0.16150759f, 
    0.11108201f, -0.10739078f, -0.03115245f, -0.01929223f, -0.05388528f, 0.01227150f, 0.02522359f, -0.06810275f, 
    0.00640777f, -0.13741234f, 0.11599945f, 0.02257074f, 0.01738529f, 0.02481931f, 0.03477189f, -0.09154081f, 
    0.06061588f, 0.03107519f, -0.02050695f, -0.15962659f, 0.08115655f, 0.03085537f, -0.08597346f, 0.04829231f, 
    0.12397716f, 0.11827280f, 0.03130144f, -0.15115836f, -0.12441711f, 0.07487386f, 0.05156091f, -0.04086542f, 
    0.19491151f, -0.02483219f, 0.12795755f, -0.06813264f, 0.12418510f, -0.02249295f, -0.10438374f, 0.14986302f, 
    -0.05665042f, -0.06294236f, -0.19134936f, -0.17375289f, -0.23338372f, 0.09628826f, -0.21295688f, 0.11182661f, 
    0.04826593f, -0.12438443f, 0.00158507f, 0.11701857f, 0.04969499f, -0.00425521f, -0.05547122f, 0.02224739f, 
    -0.27807423f, -0.34935972f, -0.23687367f, 0.12087626f, 0.03053417f, -0.07918353f, 0.07913272f, 0.04792849f, 
    0.07278873f, 0.09400395f, 0.22703363f, -0.00257863f, -0.37376902f, 0.17667742f, -0.33510515f, 0.16562261f, 
    0.02675442f, -0.07700589f, 0.07875042f, 0.02290559f, 0.01158384f, -0.12607142f, 0.05348419f, 0.10739076f, 
    -0.03319258f, -0.12940681f, -0.07813042f, 0.07830110f, 0.01097236f, -0.01319063f, 0.07953937f, 0.09950382f, 
    -0.15639967f, -0.11030579f, 0.04077480f, 0.03577277f, -0.07819988f, -0.15535203f, -0.18643799f, 0.14110292f, 
    -0.00065070f, -0.01535671f, -0.00225528f, 0.05097137f, -0.07097619f, -0.02967147f, 0.17720334f, -0.42263708f, 
    -0.39551339f, -0.00207543f, -0.10687567f, 0.05766300f, -0.30112359f, 0.08907757f, 0.11468410f, -0.32903761f, 
    0.02795592f, 0.02765345f, -0.09112836f, -0.05840949f, 0.14263816f, 0.30824494f, 0.10335089f, 0.19438009f, 
    0.09313220f, -0.03354147f, 0.07261474f, -0.02008569f, -0.05645546f, -0.04177780f, -0.10086898f, 0.14210629f, 
    -0.27574506f, 0.12747777f, -0.09852003f, -0.43390325f, 0.14876615f, 0.01828769f, -0.11997513f, 0.03747286f, 
    -0.10269679f, 0.03284948f, 0.10839850f, 0.00092018f, -0.36717090f, 0.11100298f, -0.26220778f, -0.04881946f, 
    0.08894730f, -0.05940641f, 0.11410180f, -0.03894822f, -0.11606586f, -0.05738376f, 0.16801655f, 0.04630385f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09052703f, 0.05456892f, 0.05630137f, -0.08882792f, -0.08030742f, 0.07333490f, 0.03734170f, -0.07675725f, 
    0.03205069f, 0.02072101f, 0.02605333f, -0.03963000f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
