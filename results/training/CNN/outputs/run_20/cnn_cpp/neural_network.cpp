#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.12334022f, -0.01277422f, 0.60367018f, 1.80242252f, 0.14123705f, 0.26993024f, -0.59933984f, 0.00998588f, 
    0.64424706f, -0.06390999f, 0.04572790f, -0.31784764f, -0.85140574f, -0.15932229f, -0.56781739f, 0.28052199f, 
    0.47693673f, 0.35390455f, 0.14428385f, -0.13799281f, 0.34976086f, 0.40033168f, -0.37691790f, -0.18810029f, 
    0.22945128f, -0.72627169f, 1.02717817f, -0.64136016f, -1.06392443f, 0.13456325f, -0.88321024f, -0.58864236f, 
    0.59761363f, 0.42851233f, -1.19925141f, -0.05407409f, -0.15613355f, -0.23227599f, 0.55362958f, -0.37972191f, 
    0.42602119f, 0.00199396f, -0.40076119f, -0.33625814f, 0.04584262f, -0.12414742f, -0.41484174f, 0.22262135f, 
    -0.01484514f, 0.10397062f, 1.21481812f, 1.17919123f, 1.15028524f, -0.40039182f, -0.36416596f, -0.47534776f, 
    -1.30851114f, -0.45180842f, -0.15315378f, 0.08997828f, 0.33981866f, 0.73179567f, 0.21464188f, 0.16002399f, 
    0.06806130f, -0.52571654f, 0.29767334f, -0.14597137f, -0.22663984f, 0.25126624f, 0.31756648f, 0.31582370f, 
    -0.20459369f, 0.04381714f, 0.38854760f, 0.30982608f, 1.40572238f, 1.57407939f, 0.05337276f, 0.52116078f, 
    -0.59639257f, 0.43686822f, 0.10467477f, -0.38981119f, 0.32663614f, -0.34119630f, 0.17344640f, 0.14275092f, 
    0.48046705f, 0.66590112f, 0.39112097f, 0.37768003f, 0.27230242f, 0.11522138f, 0.49300760f, -0.50458157f, 
    0.04361011f, 0.14346007f, -0.12826858f, 0.46277535f, -0.25141770f, -1.14865339f, 0.92182493f, 0.81844127f, 
    -0.31589624f, -0.26689965f, 1.00736356f, 0.69324434f, 0.73596108f, -0.34018993f, -0.17746437f, -0.27011257f, 
    -0.07000609f, -0.05254463f, -0.43268722f, -0.12330778f, -0.25545156f, -0.37340206f, 0.03375842f, 0.15307452f, 
    0.11472421f, 0.12450625f, -0.31067479f, -0.45598790f, -0.08833463f, 1.42885256f, -0.54127425f, -1.52838147f, 
    -1.34645367f, -0.43960866f, 0.70661271f, 0.03705028f, 0.43147260f, 0.19463000f, 0.26481563f, -0.54599446f, 
    0.25904465f, 0.00598786f, 0.20523065f, -0.47928590f, -0.17459375f, -0.17437162f, 0.09006493f, 0.25091884f, 
    -0.23184200f, -0.02709792f, 0.25847977f, 0.08227614f, 0.07952203f, 0.16032785f, 1.68956971f, 0.96281463f, 
    -0.70215124f, 0.92314821f, 0.16049874f, 0.49875331f, 0.78632754f, 0.92523181f, 1.27681470f, 0.23150493f, 
    -0.37667587f, -0.08114674f, 0.07367223f, -0.54329515f, -0.05149530f, 0.08186013f, -0.38717127f, -0.46504614f, 
    -0.33237815f, 0.16637816f, -0.12379428f, -0.32845908f, 0.07005499f, -0.14115897f, -0.11427179f, 1.04179156f, 
    1.00733209f, 0.94435453f, 1.13866043f, 1.02728462f, 0.34207669f, -0.86438507f, -0.34796602f, -0.95246917f, 
    -0.60148853f, 0.24452236f, 0.12591112f, -0.33781543f, 0.26010099f, -0.25431120f, 0.15003511f, -0.19638258f, 
    -0.15680544f, 0.06040210f, 0.17576972f, 0.01489235f, -0.11033461f, 0.23963556f, 0.36725101f, 0.63645983f, 
    -1.32698274f, 1.49914908f, 0.98202223f, 0.10376788f, 0.13295011f, 1.00886452f, 0.10684404f, -1.08034003f, 
    0.44421205f, -0.86875391f, -0.16074178f, 0.09105105f, 0.30427676f, 0.20736760f, -0.27623868f, 0.15333885f, 
    -0.00303584f, 0.13170426f, -0.11613907f, -0.21909611f, -0.38835511f, -0.35863727f, -0.36050257f, 0.00928199f, 
    -0.14723006f, -0.81904221f, -0.12234154f, -0.28634816f, -0.04825875f, -0.35668841f, -0.16755192f, -0.61805046f, 
    -0.63755226f, -1.16763198f, -0.70611405f, 0.47807267f, 0.28729007f, 0.37736398f, 0.69898087f, 0.55382901f, 
    -0.26123145f, -0.28603294f, -0.06117591f, -0.05517143f, 0.93556708f, 0.17849171f, 0.27340597f, 0.04180988f, 
    0.39422923f, 0.12786911f, -0.84584498f, -1.10329032f, -0.75761640f, -0.85956687f, -0.80261141f, -0.20040521f, 
    -0.06109584f, -0.16230153f, -0.39713994f, 0.35300648f, 0.16553292f, 0.43357337f, -0.17510292f, 0.08240845f, 
    -0.53666657f, 0.27117440f, 0.21663205f, 0.53947634f, -0.11994018f, 0.15418629f, -0.04120658f, 0.41934788f, 
    -0.53343141f, -0.23451783f, 0.42785260f, -0.67875671f, 0.43743300f, -1.17888951f, -0.71012878f, -0.11807004f, 
    1.20124602f, -0.96744311f, 0.31580698f, 0.70545995f, 0.61359698f, -0.25812289f, -0.59227937f, -0.40747577f, 
    -0.01369692f, -0.00842724f, -0.07471008f, 0.07364056f, -0.18061966f, -0.17097569f, -0.00753175f, -0.18462473f, 
    -0.08056451f, -0.39635912f, 0.09370948f, -0.56366265f, 1.02354717f, 0.40563902f, -0.41417533f, -0.72725910f, 
    0.38059479f, 0.34036279f, 0.70115471f, 1.02647400f, -0.00248357f, 0.39389816f, 0.32333246f, -0.24466558f, 
    0.15304044f, 0.29194966f, 0.58712029f, -0.16065393f, 0.20769969f, -0.38991797f, 0.67568469f, 0.43415025f, 
    0.63287485f, 0.57881844f, -0.05901274f, -0.30487478f, -0.33814725f, 0.44451275f, 0.24080767f, -0.79681081f, 
    -0.79105532f, 0.95666677f, 1.31816435f, -0.49765295f, -1.14468682f, -0.65832275f, -0.77528769f, -0.01870239f, 
    0.51355749f, -0.03218133f, 0.40980473f, -0.56883526f, -0.11176593f, -0.51337922f, -0.13100268f, -0.02131722f, 
    0.39778146f, 0.04771478f, 0.08798935f, -0.32227570f, -0.41474414f, 0.03469321f, -0.18454848f, -0.98059702f, 
    0.47499120f, 1.07049108f, -0.43328178f, -1.60774052f, -0.57065099f, 0.57212168f, -0.68391091f, -0.71144342f, 
    0.35368022f, 0.36734480f, 0.20661061f, 0.10927954f, 0.51324242f, -0.34793925f, 0.50066108f, 0.22061503f, 
    0.13792782f, -0.16973947f, 0.38211539f, -0.06635334f, -0.16052479f, 0.04351387f, 0.32701659f, -0.68949550f, 
    -1.90327084f, -1.41492569f, -0.53003156f, 0.10758288f, -0.44234687f, 1.32987559f, 0.98759085f, 0.22398154f, 
    0.77128977f, 0.18404335f, -0.15989695f, -0.24585943f, -0.43277493f, -0.14586684f, -0.04914707f, 0.14245190f, 
    -0.09567824f, -0.09322126f, -0.14938456f, -0.21056131f, -0.18548483f, 0.10194939f, 0.21546763f, 0.34059632f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08882737f, 0.61692655f, -0.08169615f, 0.41542932f, 0.05446615f, 0.59940279f, 0.39072788f, 0.15554820f, 
    -0.07332260f, 0.38100010f, -0.12641184f, -0.14735268f, 0.31371585f, 0.63133174f, 0.19864210f, 0.46623525f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04026499f, -0.07023217f, -0.42510939f, 0.72138292f, 0.08927696f, 0.12259009f, 0.12000755f, -0.14968117f, 
    0.09737266f, -0.01690310f, 0.07675220f, 0.07929239f, -0.67207271f, 0.24705844f, 0.09631132f, -0.29763505f, 
    -0.20679884f, -0.05440732f, -0.05120091f, 0.08234213f, 0.01705680f, 0.08317861f, -0.04943898f, -0.24992584f, 
    0.07103781f, 0.14395039f, 0.24331141f, -0.27371201f, -0.07478468f, -0.07498562f, 0.17574635f, -0.00551089f, 
    0.03823434f, -0.27600658f, -0.01036129f, 0.18795696f, -0.13875149f, -0.01238904f, -0.22135346f, -0.22090814f, 
    -0.24503022f, -0.12475713f, 0.08775660f, 0.12967107f, 0.17289491f, -0.02721964f, -0.10613719f, -0.04794232f, 
    -0.05187591f, 0.23335722f, -0.06816956f, 0.52077019f, 0.00827119f, 0.10736512f, 0.18694888f, 0.00850363f, 
    0.32392824f, -0.19756493f, -0.13558935f, 0.14054310f, 0.40202975f, -0.38389191f, -0.04623010f, -0.61615491f, 
    0.06611203f, -0.22158797f, 0.15288141f, -0.31596425f, -0.17088304f, -0.01692178f, -0.02831411f, -0.01999584f, 
    -0.08468456f, 0.18049231f, -0.24803390f, 0.14363104f, -0.35929185f, 0.16947265f, -0.12451321f, 0.08959821f, 
    -0.08357472f, 0.14445302f, 0.21789421f, -0.06673715f, 0.45196062f, -0.00904672f, 0.17263837f, 0.04633979f, 
    -0.15363012f, -0.13302691f, -0.07835862f, 0.10874454f, -0.01122767f, -0.05867472f, -0.09110027f, -0.01437494f, 
    -0.06198142f, -0.00975974f, 0.43854079f, 0.21961218f, -0.28332454f, -0.37797248f, 0.10164391f, -0.08564616f, 
    -0.03240937f, 0.04906129f, -0.17836300f, -0.02081778f, -0.93073016f, -0.21035466f, -0.22258081f, 0.22356699f, 
    0.01260810f, 0.10309481f, 0.12933910f, 0.02297684f, 0.18578549f, -0.19087619f, 0.02589785f, 0.21267930f, 
    -0.31141204f, -0.48584870f, 0.09689979f, -0.42272398f, -0.00471136f, 0.00844794f, 0.26745626f, -0.00128590f, 
    -0.13763225f, -0.06591038f, -0.08346612f, 0.00112395f, 0.76770830f, -0.45142126f, 0.15105480f, 0.01587369f, 
    0.04622140f, -0.06044316f, 0.10860884f, -0.11657558f, -0.09454679f, 0.01530255f, 0.08760224f, -0.03054003f, 
    -0.15903579f, -0.16597313f, 0.04429587f, -0.54634744f, 0.22310054f, 0.17093028f, 0.11711090f, -0.25562125f, 
    -0.04343721f, -0.12522297f, -0.01512220f, 0.21965617f, -0.21136698f, -0.31927755f, 0.53272313f, -0.51915854f, 
    -0.08844160f, -0.00730886f, 0.23065633f, -0.17381097f, 0.08286928f, -0.14016959f, -0.01055302f, -0.03797680f, 
    0.05023383f, -0.03531609f, -0.28655791f, 0.40736419f, 0.08858503f, -0.01882991f, -0.11230305f, -0.21763255f, 
    0.04275614f, 0.12086128f, 0.11701066f, -0.03040855f, -0.35381252f, 0.61918324f, -0.07246988f, -0.34645784f, 
    0.25875238f, 0.12060346f, -0.11138488f, -0.07051373f, 0.05081920f, 0.09904909f, -0.07399806f, 0.18002675f, 
    0.17615485f, 0.05278589f, -0.10648508f, 0.25257888f, 0.02074689f, -0.05352771f, -0.11258225f, 0.13305785f, 
    -0.04460550f, 0.12741135f, -0.11820054f, -0.15118012f, -0.22019124f, 0.10203803f, -0.01126489f, -0.53146666f, 
    0.04372981f, 0.03461633f, 0.04506367f, 0.30145678f, -0.14957030f, -0.00245741f, 0.08410045f, 0.04730347f, 
    -0.17313623f, -0.03618884f, 0.09034318f, -0.02312717f, -0.21039382f, -0.03996095f, 0.09956732f, 0.08806049f, 
    0.01826932f, 0.05850680f, 0.05532527f, -0.06534930f, 0.22541180f, 0.42399257f, -0.04715814f, 0.01628978f, 
    0.02347882f, 0.16574509f, 0.08799681f, -0.16044609f, 0.17538038f, 0.11722991f, -0.07510474f, 0.11440774f, 
    -0.05437170f, -0.24517365f, -0.05590884f, 0.05330003f, -0.05210318f, -0.13301168f, -0.10774820f, 0.01122107f, 
    -0.17691270f, -0.08391260f, -0.07863971f, -0.17715874f, 0.30789208f, -1.00240314f, 0.40754169f, -0.81481743f, 
    0.16611505f, -0.05492491f, -0.13791564f, -0.04143173f, -0.09791113f, -0.10029714f, 0.15742847f, 0.01112884f, 
    0.56955147f, -0.08422100f, 0.31148669f, 0.41390994f, -0.06641940f, -0.11581504f, -0.05479069f, 0.08882827f, 
    0.04419433f, -0.02132968f, -0.17413032f, 0.10639907f, 0.16702068f, -0.03585755f, 0.20115763f, 0.56498188f, 
    -0.03905848f, 0.16623035f, 0.10790894f, 0.02071101f, -0.10584079f, 0.07332690f, -0.08495501f, 0.10521582f, 
    -0.17298506f, -0.18388782f, -0.25249690f, -0.08958389f, -0.00828137f, 0.37277618f, 0.01475980f, -0.22902782f, 
    0.03089732f, -0.02494820f, 0.28466326f, 0.14722455f, -0.21409670f, 0.08696676f, -0.17044081f, 0.01662509f, 
    0.12655571f, 0.04242397f, -0.06177688f, -0.13530552f, 0.02738380f, 0.16464227f, 0.09780240f, -0.17611007f, 
    -0.00477356f, 0.11696443f, 0.00197851f, -0.12812710f, -0.05398946f, -0.06179621f, -0.00242265f, 0.11459910f, 
    0.20892160f, 0.20920151f, 0.11685229f, -0.04185652f, -0.44475454f, -0.00490586f, -0.01744547f, -0.34915039f, 
    0.15943614f, -0.10864718f, -0.27946332f, -0.17062174f, 0.30545041f, 0.27644858f, -0.10089163f, -0.13945062f, 
    0.39663848f, -0.16584781f, 0.07755910f, -0.05674762f, -0.12662318f, -0.17635337f, -0.29392764f, -0.06528552f, 
    0.09080924f, 0.05782394f, -0.11244290f, 0.07580829f, 0.25892651f, -0.47641861f, -0.11892334f, -0.47662202f, 
    -0.02421211f, -0.10807739f, -0.07901675f, 0.01397292f, -0.36841485f, 0.09543608f, -0.05892409f, -0.23596764f, 
    -0.79386109f, -0.15754513f, -0.04456262f, 0.13537627f, 0.02366816f, -0.08950252f, -0.35815451f, 0.07464918f, 
    -0.10104144f, 0.02878134f, 0.23016597f, 0.24577855f, 0.64123559f, -0.57493818f, -0.08194403f, -0.09326315f, 
    -0.04860068f, -0.22181131f, -0.13793677f, 0.13172385f, 0.10406034f, -0.27867734f, -0.10833330f, 0.09012782f, 
    -0.47289991f, -0.13877457f, -0.16008756f, 0.08998320f, 0.10945186f, 0.08964250f, -0.18259576f, -0.09192683f, 
    0.15092990f, 0.03125974f, -0.22025499f, -0.09375036f, -0.64917850f, -0.02016544f, -0.66243356f, -0.16851716f, 
    0.01522515f, 0.16342178f, -0.09096064f, -0.01866048f, 0.00695885f, 0.17127872f, 0.03695939f, 0.02569348f, 
    -0.44509342f, 0.26774451f, 0.02628311f, -0.29716802f, 0.08467333f, 0.27242693f, 0.05799226f, -0.02133271f, 
    0.11111190f, 0.02394829f, -0.08599243f, -0.06585845f, -0.01925707f, 0.13506801f, -0.33155373f, 0.13152502f, 
    0.09121696f, 0.12423803f, -0.09695463f, 0.04487701f, -0.04017356f, -0.07881096f, -0.21585453f, -0.08964896f, 
    -0.08356740f, 0.10252210f, -0.45875859f, -0.02409321f, -0.26907638f, 0.06981179f, 0.29410002f, 0.24930215f, 
    0.12346099f, -0.03311421f, 0.09079104f, -0.04039724f, -0.36248365f, -0.08561223f, 0.02547214f, -0.02457359f, 
    -0.00847773f, -0.34938917f, 0.15923089f, 0.01102212f, -0.18774457f, -0.00124509f, -0.27378058f, 0.14116412f, 
    0.63227749f, -0.06140630f, -0.13918178f, 0.01539319f, 0.09417993f, -0.26695439f, 0.15439597f, 0.26224154f, 
    -0.11991333f, 0.07400204f, 0.11432100f, -0.00767305f, 0.08213874f, 0.13866642f, -0.28978372f, -0.00650059f, 
    0.29256958f, -0.01400241f, 0.09917945f, -0.19685833f, -0.07475986f, 0.03520622f, -0.03405162f, -0.21668442f, 
    0.63951427f, 0.02307197f, -0.40294543f, 0.12751448f, 0.11914137f, -0.08906504f, 0.02454518f, -0.05098534f, 
    -0.33452734f, -0.02315052f, 0.00172229f, 0.01160742f, -0.13498181f, 0.20542431f, -0.22754623f, -0.32591546f, 
    -0.25260857f, -0.07878418f, -0.07447619f, -0.04757584f, -0.13547654f, -0.15546837f, -0.07538916f, -0.16197641f, 
    -0.02728558f, -0.32094738f, -0.07013538f, 0.09426230f, -0.15019134f, -0.39646798f, 0.12643626f, -0.36546180f, 
    -0.10177378f, -0.09976166f, 0.03219465f, -0.04828247f, -0.04582874f, 0.42448211f, 0.11698943f, 0.19882956f, 
    0.02051214f, -0.07353292f, 0.10207438f, 0.14064512f, -0.09665062f, -0.03649656f, -0.10512473f, 0.01671758f, 
    0.00707011f, 0.22408572f, 0.14821438f, -0.03114448f, -0.12059938f, -0.19469136f, 0.13291356f, 0.07645260f, 
    -0.21526635f, -0.15237059f, 0.13429672f, 0.16397089f, -0.69106448f, -0.67048818f, 0.16884813f, -0.30934003f, 
    0.03166287f, -0.25023973f, 0.10354149f, -0.11711692f, -0.04609703f, 0.25520819f, 0.03721708f, -0.16380461f, 
    0.88794976f, -0.05123351f, -0.63626790f, -0.19029760f, -0.02080459f, 0.09130016f, 0.17370577f, -0.08541594f, 
    0.07419412f, 0.11728452f, 0.01563380f, -0.15236907f, 0.63798225f, -0.13898417f, 0.37898320f, 0.48949853f, 
    -0.30806607f, -0.13895185f, -0.03775139f, 0.11525892f, 0.08650316f, 0.05670796f, 0.17658697f, 0.06263060f, 
    0.16383785f, -0.29285014f, -0.23343772f, 0.42374882f, -0.06943569f, -0.04296682f, 0.27869937f, 0.07876819f, 
    -0.12661667f, 0.08970480f, 0.20594136f, -0.08121999f, 0.18089230f, 0.43028694f, 0.21053639f, -0.05548372f, 
    -0.16212742f, -0.00685817f, 0.10907194f, 0.04061799f, 0.06905591f, 0.16767399f, 0.06828524f, -0.13830590f, 
    -0.26488242f, -0.69596970f, -0.40261385f, 0.29368797f, 0.13933890f, 0.13192125f, 0.34010538f, 0.03594801f, 
    0.04325348f, 0.20580298f, -0.19405133f, -0.18331926f, -0.76108581f, -0.53247839f, 0.15373024f, -0.17338450f, 
    -0.17007920f, -0.04884130f, 0.07731543f, -0.00635145f, 0.18632455f, -0.22760399f, 0.06017393f, 0.02560848f, 
    -0.29246512f, 0.27034295f, 0.12235952f, -0.11331206f, 0.14432508f, -0.15163070f, -0.01535995f, 0.06662142f, 
    -0.14168745f, 0.04232275f, 0.34459928f, -0.02765064f, 0.00749923f, -0.01030688f, -0.12564941f, 0.24856465f, 
    -0.04891087f, 0.01766984f, 0.16722971f, -0.06473731f, -0.14139570f, 0.18068561f, -0.14011607f, 0.19672947f, 
    -0.29335719f, -0.50443333f, -0.41255650f, -0.32699549f, -0.23082426f, -0.14330900f, 0.07885696f, -0.00715363f, 
    -0.04288546f, -0.00179823f, 0.15126769f, -0.13577364f, -0.13730469f, -0.85323799f, -0.10920292f, 0.18630931f, 
    -0.01529883f, 0.04682333f, -0.02270874f, 0.02026589f, -0.00755835f, -0.12044073f, 0.13711885f, -0.26572004f, 
    0.87900299f, 0.28111842f, -0.12978949f, 0.14507473f, 0.32302427f, 0.05338508f, 0.01401240f, 0.21728055f, 
    -0.01218157f, 0.19264963f, -0.10219946f, -0.00681613f, 0.21360460f, 0.23049612f, 0.26517242f, -0.04891536f, 
    0.04752201f, -0.11341653f, -0.00925282f, 0.23452830f, 0.08982798f, 0.04137950f, 0.06389660f, -0.08913083f, 
    0.00658186f, 0.01705642f, -0.06185282f, -0.37357631f, -0.29394251f, -0.40598661f, -0.08515515f, 0.17684616f, 
    -0.00506377f, -0.26833534f, -0.07136285f, 0.22330001f, -0.10268036f, 0.40334821f, -0.19850115f, -0.07109311f, 
    -0.20443363f, -0.02804607f, 0.04887855f, 0.00490535f, -0.03497659f, -0.10380202f, -0.04893480f, 0.01587620f, 
    -0.44182813f, -0.22913860f, -0.09580037f, -0.27599445f, -0.25527972f, -0.06403402f, -0.28550038f, -0.07310781f, 
    -0.27655312f, -0.35765541f, 0.08465801f, -0.05319457f, 0.64236963f, 0.24599880f, 0.00898732f, 0.38999662f, 
    -0.09025579f, -0.08612433f, -0.04678275f, 0.08715089f, -0.08363387f, -0.01590457f, -0.00142990f, -0.13519432f, 
    0.00059071f, 0.33389616f, 0.33774012f, 0.16092482f, 0.04477078f, -0.03389446f, -0.08511474f, -0.18667509f, 
    -0.20580715f, 0.04629789f, 0.06886484f, 0.06180788f, 0.13253966f, -0.01795344f, -0.00377891f, -0.14971298f, 
    -0.16228063f, -0.22155276f, 0.00145829f, -0.04184560f, -0.23228487f, -0.00902398f, -0.19835532f, -0.17579181f, 
    -0.01343623f, 0.21676311f, 0.05023503f, -0.11100372f, -0.05044543f, 0.20543763f, 0.03070269f, 0.17284285f, 
    0.31216991f, -0.11539498f, -0.05917786f, 0.16516316f, 0.63741547f, 0.13215870f, -0.24847780f, -0.10234679f, 
    -0.10857097f, -0.26450312f, 0.15026233f, -0.08147542f, 0.07256801f, -0.21241635f, 0.11850735f, 0.01824758f, 
    -0.64266074f, -0.85875559f, 0.10521337f, 0.01081138f, -0.21765265f, 0.16563234f, -0.28203049f, -0.21287525f, 
    0.11823956f, 0.05011914f, 0.01041778f, -0.06713289f, -0.12147605f, 0.14662459f, -0.00915334f, 0.01215217f, 
    -0.14594904f, -0.11202407f, 0.05605732f, 0.01707712f, -0.04705020f, 0.00415717f, 0.24456879f, -0.10257659f, 
    -0.41194850f, 0.23791839f, -0.04387192f, -0.06783062f, -0.03428129f, 0.16264783f, 0.10629336f, 0.14260200f, 
    -0.19997501f, 0.19482802f, 0.14432155f, -0.00398365f, -0.36286640f, -0.05550794f, -0.13965751f, 0.20233171f, 
    -0.02601255f, 0.12787241f, 0.07202281f, -0.05654071f, -0.01400219f, -0.04476556f, 0.01334696f, 0.02231989f, 
    0.22351396f, -0.18271270f, -0.00750957f, 0.08814049f, 0.01323975f, 0.17037594f, 0.04974649f, 0.15738097f, 
    0.08462796f, 0.01889767f, 0.11969324f, 0.01716575f, -0.11189023f, 0.20112370f, 0.36661920f, 0.09300137f, 
    -0.05283431f, 0.02032606f, -0.14874433f, -0.05657415f, 0.21120818f, -0.07699300f, 0.03548123f, -0.09627634f, 
    0.10639597f, 0.73944521f, -0.22189663f, -0.64486688f, 0.09733310f, 0.24449353f, 0.07610297f, 0.11701936f, 
    0.05165724f, 0.04304720f, -0.16076927f, -0.01699805f, -0.35712856f, -0.03321065f, 0.21314105f, -0.22785871f, 
    0.07783815f, -0.09623013f, 0.12737367f, -0.05459725f, -0.13328965f, -0.14170797f, 0.08953426f, -0.10794871f, 
    0.07388663f, 0.09918825f, 0.16826545f, 0.23145401f, 0.26730019f, 0.05919049f, -0.07383116f, 0.40794948f, 
    -0.08134640f, 0.06232610f, 0.26863635f, 0.19822474f, 0.46217147f, -0.39175051f, -0.16551268f, 0.40518057f, 
    0.14056404f, -0.07155978f, 0.05978606f, 0.02829155f, 0.14010999f, -0.15900198f, 0.05076849f, 0.07658716f, 
    0.03702433f, -0.48357901f, -0.12928021f, -0.00058843f, -0.06587078f, 0.08524225f, -0.18149558f, -0.45624790f, 
    0.06320826f, -0.06081887f, -0.02723924f, 0.00798642f, -0.17641973f, 0.21817513f, -0.14630479f, 0.01899060f, 
    -0.22072777f, -0.21856850f, 0.02384027f, 0.11952841f, -0.11931111f, -0.09738608f, 0.15697363f, 0.04036777f, 
    -0.56039232f, -0.28087267f, -0.02444666f, 0.06993482f, -0.11250558f, -0.07614678f, -0.10514971f, 0.02136552f, 
    -0.00140438f, -0.00515471f, -0.22117722f, -0.19094552f, -1.00037515f, 0.17094299f, -0.06053858f, 0.27238193f, 
    0.05647124f, -0.04509992f, 0.07797510f, 0.06709799f, -0.16449651f, -0.10361373f, 0.25048363f, -0.00861814f, 
    -0.04422376f, -0.12545073f, 0.11332079f, -0.45122600f, 0.03622174f, 0.06784506f, -0.08640514f, -0.00633633f, 
    0.36959526f, 0.11915977f, -0.08452955f, 0.23982628f, 0.03708303f, -0.44725701f, 0.12706462f, 0.50501746f, 
    0.02861244f, 0.15026878f, 0.06025500f, -0.29933849f, -0.13040365f, -0.07488318f, -0.24559475f, 0.21573170f, 
    0.15737486f, 0.23134921f, -0.07799038f, 0.39062726f, 0.01237191f, -0.12564051f, 0.01252207f, 0.04231031f, 
    -0.15289047f, -0.23472849f, 0.01232223f, 0.08301828f, 0.15430351f, 0.02976647f, 0.13102388f, -0.00104905f, 
    -0.12509978f, -0.02787125f, 0.12359957f, -0.11889970f, -0.12093828f, 0.13257754f, 0.26254886f, 0.18751645f, 
    -0.36172247f, 0.23035048f, 0.02029249f, 0.10626490f, 0.11201732f, -0.08874665f, -0.22362423f, -0.19255768f, 
    0.06488039f, 0.06685355f, 0.04580453f, -0.14539169f, 0.06010116f, -0.30413216f, -0.36941922f, -0.09460795f, 
    -0.07358400f, 0.10578973f, -0.12422881f, 0.14445812f, 0.18279456f, -0.11138458f, 0.00357374f, -0.12471586f, 
    0.33337235f, 0.19748706f, 0.14850928f, -0.33268607f, -0.04309132f, -0.03889438f, -0.14821443f, -0.47649896f, 
    -0.28555775f, -0.15746486f, -0.32893896f, 0.08248220f, -0.03730777f, -0.05105861f, 0.01984960f, 0.26346007f, 
    -0.38749290f, -0.09510530f, 0.18784352f, 0.03107829f, -0.16642895f, -0.02066075f, 0.00196161f, 0.27402294f, 
    -0.49318233f, -0.37573433f, 0.47973406f, 0.20693414f, -0.27859253f, -0.13456337f, 0.03260961f, 0.06130618f, 
    0.03955535f, -0.07862770f, 0.07286499f, 0.16721925f, 0.02350908f, -0.24215755f, 0.20884228f, 0.16702367f, 
    -0.00174855f, -0.13758671f, -0.05238827f, 0.13533235f, -0.18510619f, 0.29143083f, 0.06156449f, 0.36971107f, 
    -0.13311981f, -0.07197158f, -0.57166207f, 0.24614803f, 0.19955844f, 0.19138578f, 0.07138082f, 0.03311843f, 
    0.33699879f, -0.01462933f, 0.06617159f, 0.05130595f, -0.12648624f, -0.07860317f, 0.16820984f, -0.23791762f, 
    0.15975034f, 0.15627660f, -0.11230779f, -0.28997824f, 0.00316458f, -0.09989420f, -0.18584798f, -0.16791624f, 
    0.24919358f, 0.23263256f, 0.13610259f, -0.12075251f, 0.08793113f, 0.01596886f, -0.13127759f, 0.12380031f, 
    0.29433927f, 0.25153431f, 0.03119181f, -0.05977201f, -0.12421755f, -0.20727997f, 0.01608387f, 0.07583848f, 
    -0.04085249f, 0.18112877f, -0.00548522f, -0.05592603f, 0.08006930f, 0.02167928f, 0.01895892f, 0.23306347f, 
    0.15424612f, -0.07995088f, 0.02743441f, -0.13303098f, -0.06714711f, -0.00160181f, -0.00091628f, 0.27600697f, 
    -0.06985950f, -0.06286591f, 0.04918598f, -0.06904373f, -0.68087494f, -0.00402980f, -0.30839598f, -0.51157486f, 
    0.24976435f, 0.18581542f, -0.05136743f, -0.19641806f, -0.00475189f, -0.00283257f, -0.29001069f, 0.08790666f, 
    0.19513629f, 0.10582180f, 0.27396971f, -0.92586100f, -0.15831853f, 0.01645850f, 0.05330735f, -0.26333725f, 
    -0.21453589f, -0.18301262f, 0.18438675f, 0.01523872f, -0.01698721f, 0.01934568f, -0.14086595f, 0.23564291f, 
    0.10089546f, -0.08316661f, -0.10340201f, -0.21043335f, -0.03459393f, 0.25478271f, -0.01560539f, 0.05587914f, 
    -0.40630856f, 0.29578674f, -0.21998388f, 0.04312191f, 0.03591361f, 0.00623684f, -0.12653293f, 0.22009881f, 
    -0.11052731f, -0.03557189f, -0.05814593f, -0.05777279f, -0.01649304f, 0.37362239f, 0.17522636f, 0.20450103f, 
    0.03889465f, 0.04180066f, 0.04289936f, 0.07310894f, 0.07898714f, -0.08167230f, -0.23326659f, -0.57060885f, 
    0.53489053f, -0.64231670f, 0.20436503f, -0.11481256f, 0.01044438f, 0.10939860f, 0.17314227f, -0.05793795f, 
    0.03254354f, -0.14168599f, 0.29083943f, 0.11790654f, -0.10082458f, 0.06357002f, -0.33564451f, 0.07445930f, 
    0.06930063f, 0.04327977f, 0.12094550f, -0.01725084f, 0.08567788f, 0.08913752f, -0.00364938f, 0.03217788f, 
    -0.86561519f, 0.07789858f, 0.11256059f, 0.09790992f, -0.21269700f, -0.02723578f, 0.06352543f, 0.10755433f, 
    -0.00499420f, 0.12389600f, 0.12309416f, 0.14331226f, 0.16123469f, 0.31846294f, 0.18527523f, -0.88282615f, 
    -0.00830717f, 0.01709319f, 0.07142622f, 0.14340124f, 0.07914782f, 0.06990301f, 0.13892320f, 0.02847773f, 
    0.75277793f, 0.05318826f, 0.26438254f, 0.11022364f, 0.00393565f, 0.04349128f, -0.01061845f, 0.15778893f, 
    0.10746213f, 0.11687295f, -0.24289460f, -0.06421988f, -0.18684630f, -0.07132024f, -0.18945898f, -0.08125021f, 
    -0.02653372f, 0.14118364f, 0.02195959f, 0.05829599f, 0.04625892f, -0.51218194f, -0.02559981f, -0.12982124f, 
    -0.38244623f, -0.07946287f, -0.66313714f, -0.21108174f, -0.27707136f, -0.34927890f, 0.14032535f, -0.34457079f, 
    -0.34278652f, 0.09667408f, -0.18918745f, 0.03142270f, -0.36654177f, -0.09846207f, -0.16210853f, -0.19125871f, 
    -0.28668231f, 0.11588278f, -0.13958475f, 0.06152093f, -0.04712635f, 0.12134071f, 0.28884748f, 0.19078074f, 
    -0.55585027f, -0.07841589f, -0.13467465f, 0.16360986f, -0.00844250f, -0.07177465f, 0.10407518f, 0.30093655f, 
    0.05635860f, -0.17400074f, 0.02532235f, -0.18735999f, 0.36685666f, -0.47049424f, -0.32490346f, 0.05079339f, 
    0.05421870f, 0.05377555f, 0.04107429f, 0.04016746f, 0.16463338f, -0.11490878f, -0.05858513f, 0.10097127f, 
    0.28098628f, -0.21928144f, 0.18578747f, -0.25431171f, 0.24877083f, 0.04016621f, 0.19724898f, -0.06125788f, 
    0.18395124f, -0.02578854f, -0.12846215f, -0.00428679f, -0.01865802f, -0.44974598f, 0.01308237f, -0.40797433f, 
    -0.07782778f, 0.06818397f, -0.02693221f, -0.05205943f, 0.14126928f, -0.07248617f, 0.26240668f, 0.15581505f, 
    0.02516400f, 0.45143557f, -0.06723114f, -0.31606740f, -0.19455375f, 0.07732537f, 0.03312042f, -0.27480868f, 
    -0.16599719f, -0.04878534f, 0.12639523f, -0.15606929f, 0.03252776f, 0.18245482f, 0.02683182f, 0.40268046f, 
    0.21891381f, -0.15588291f, -0.14896254f, -0.05548088f, -0.17434743f, -0.24548388f, -0.09580102f, -0.09102395f, 
    -0.33780280f, 0.04635879f, -0.62263721f, -0.11056682f, -0.04196090f, -0.17343894f, -0.01935607f, -0.04032401f, 
    -0.26273400f, 0.15435089f, 0.14337207f, -0.09243130f, 0.16864471f, -0.78244334f, -0.09182524f, -0.19460395f, 
    -0.02447822f, 0.01144154f, -0.11593557f, 0.04615454f, -0.24660121f, -0.01064715f, 0.00517058f, -0.03059854f, 
    0.41695568f, -0.58579129f, -0.04082281f, -0.45819932f, -0.05618521f, 0.00208590f, -0.10043120f, -0.12962557f, 
    -0.06674800f, -0.14294827f, -0.13537945f, 0.04256895f, 0.07809360f, 0.17232521f, -0.21401428f, 0.22276178f, 
    -0.08303060f, 0.18356931f, -0.09105776f, -0.05375551f, -0.05704444f, 0.19029000f, -0.04264627f, -0.11841162f, 
    -0.25207448f, 0.30060875f, 0.02736521f, -0.15078984f, -0.19718592f, 0.09571122f, -0.06841858f, -0.10824824f, 
    0.08433343f, 0.03606310f, -0.07018811f, -0.22164257f, -0.85225016f, 0.16579063f, -0.37100729f, -0.02689807f, 
    0.00535122f, -0.19277683f, -0.01617135f, -0.14990680f, -0.03297334f, 0.09411296f, 0.03038730f, -0.05324187f, 
    -0.51967436f, 0.14060076f, -0.08314460f, 0.11398715f, 0.09783099f, -0.16273092f, 0.03550779f, -0.00396487f, 
    -0.09985117f, 0.06954892f, 0.11030608f, -0.12212809f, 0.29027250f, -0.11923555f, 0.03048988f, 0.22006741f, 
    -0.10475440f, -0.28741658f, -0.06574516f, -0.12223762f, -0.03440634f, -0.04165849f, -0.25552675f, -0.05115849f, 
    0.13654244f, 0.29102814f, 0.34828967f, 0.43737784f, 0.16291410f, 0.21253785f, 0.01812537f, -0.09545824f, 
    -0.02494998f, 0.07830528f, -0.24636686f, -0.09233489f, 0.40717632f, 0.51461315f, 0.00054449f, 0.35029384f, 
    0.13955897f, 0.07338750f, 0.00769151f, 0.09536206f, -0.21559116f, -0.19782959f, 0.05785582f, 0.00897668f, 
    -0.50000054f, 0.10306107f, 0.06409305f, -0.08263229f, -0.08890256f, -0.02219493f, 0.34132990f, -0.06459095f, 
    0.04989890f, -0.04006426f, -0.00487900f, -0.06674828f, -0.22691904f, 0.22816052f, -0.26009127f, 0.40314054f, 
    0.12481062f, -0.10189585f, -0.14918824f, -0.05619819f, -0.01647544f, -0.18177812f, -0.01800588f, -0.05937330f, 
    0.81276995f, 0.16214254f, 0.07727840f, -0.00460151f, -0.17514022f, -0.23770522f, 0.09399524f, -0.22991352f, 
    -0.06481634f, 0.05280076f, 0.00125505f, -0.18571132f, 0.12037989f, 0.04730881f, 0.34022334f, 0.03380826f, 
    -0.03524339f, 0.19158269f, 0.08529042f, -0.12192959f, 0.03297289f, 0.19876550f, -0.04617730f, -0.10854115f, 
    -0.22760049f, -0.33937135f, 0.34406352f, 0.36715245f, -0.17543001f, -0.46606013f, -0.11134183f, 0.12705116f, 
    0.14496617f, -0.02117496f, 0.01861474f, 0.01918197f, -0.54552394f, -0.21701473f, -0.39625573f, -0.49606884f, 
    0.18913792f, 0.05574089f, -0.35034126f, 0.13854252f, -0.19169609f, -0.06163795f, 0.02298794f, 0.24240027f, 
    0.43158758f, 0.06129763f, -0.38892686f, -0.26416254f, 0.12465683f, -0.05453848f, 0.02026249f, 0.03366770f, 
    0.08001015f, 0.08001614f, 0.03586579f, 0.15690088f, 0.24863596f, -0.05521281f, -0.14528523f, 0.18911698f, 
    0.22784375f, 0.07609415f, -0.12237366f, 0.02218234f, -0.31437275f, 0.16694033f, 0.12422634f, 0.01312250f, 
    0.10648835f, -0.13015848f, 0.34659430f, 0.19037622f, 0.09933580f, -0.13489608f, -0.12233112f, -0.31543127f, 
    -0.08144392f, -0.22444169f, -0.05990520f, -0.28281128f, -0.18692544f, 0.57404691f, -0.18200266f, 0.07002614f, 
    -0.28055891f, 0.15097679f, -0.26249319f, 0.05327549f, 0.20036452f, 0.04131679f, 0.15441008f, 0.05089441f, 
    0.54610783f, -0.00223620f, 0.09377008f, 0.17516121f, 0.07363127f, -0.15493184f, 0.01067041f, -0.24052531f, 
    -0.20569248f, -0.05637477f, 0.01414882f, -0.10571163f, -0.46758854f, -0.02342007f, -0.17536306f, 0.40763634f, 
    0.12031237f, 0.25743455f, -0.03370300f, -0.05395937f, 0.19354577f, 0.10502365f, -0.01406650f, -0.14210650f, 
    0.00642919f, -0.56692541f, -0.48773277f, -0.10917445f, 0.21636333f, -0.27784598f, -0.17339668f, -0.06494257f, 
    0.27890608f, 0.16468969f, 0.22917776f, -0.16627404f, 0.01936757f, 0.02832216f, -0.22824791f, -0.41495371f, 
    -0.15434717f, -0.23400290f, 0.22688265f, -0.28406909f, 0.01585434f, 0.20045593f, 0.04535748f, 0.16809838f, 
    -0.32139531f, -0.20572741f, 0.44641531f, -0.15578660f, -0.12310731f, 0.20193107f, -0.53057611f, -0.11078188f, 
    0.13418058f, -0.15224198f, -0.00841524f, -0.03371428f, -0.52767926f, 0.11834826f, 0.15211360f, -0.24619605f, 
    0.05560310f, -0.26451084f, -0.16756228f, 0.15486592f, 0.00075918f, 0.11550025f, -0.25380957f, -0.13506879f, 
    0.33480251f, 0.35896870f, -0.32905003f, 0.23091546f, -0.24324243f, 0.12612389f, 0.02597852f, 0.05727401f, 
    0.13479583f, 0.16410649f, 0.11684179f, -0.12454624f, -0.31656823f, 0.08856204f, -0.17839292f, -0.28769711f, 
    -0.14631997f, 0.11158864f, -0.42918038f, -0.14206903f, 0.14674506f, 0.07391352f, -0.04678660f, 0.06487442f, 
    0.01222050f, -0.42591453f, 0.16038777f, -0.38270366f, -0.11420605f, -0.19980799f, 0.05891246f, 0.16054620f, 
    0.09304891f, 0.11687032f, 0.11005815f, 0.32370254f, -0.26281407f, 0.36152580f, 0.32125118f, 0.14128147f, 
    -0.34150308f, -0.10633899f, -0.17002285f, -0.19404010f, -0.01581310f, 0.00301870f, -0.25786799f, -0.03633838f, 
    -0.06569014f, 0.22462104f, -0.11426952f, 0.13018064f, 0.21462375f, 0.03755753f, 0.11723410f, -0.09570397f, 
    -0.36574903f, 0.03649848f, 0.12258460f, -0.20946155f, 0.01422441f, -0.77199453f, 0.02095287f, 0.16694057f, 
    -0.03457333f, -0.00638884f, -0.04411326f, 0.17716041f, 0.02810582f, 0.06885065f, 0.10040880f, -0.11685842f, 
    0.23427647f, 0.19556823f, 0.36065435f, -0.43549868f, -0.21074872f, 0.00403361f, 0.16858740f, -0.31753066f, 
    -0.16882031f, -0.05888682f, -0.11694239f, -0.00204233f, 0.19232319f, -0.68142968f, 0.46588147f, -0.50845182f, 
    0.19241597f, 0.07234792f, -0.35281953f, -0.15157832f, -0.04708120f, -0.08618249f, -0.05099587f, -0.10719115f, 
    0.32799307f, 0.13630183f, 0.06575841f, 0.09447353f, 0.12098919f, -0.06526249f, 0.05252180f, -0.08358762f, 
    0.04446298f, 0.07611318f, -0.25535297f, 0.28904772f, 0.03606877f, 0.73330587f, 0.41584420f, 0.52182490f, 
    -0.06113110f, -0.00999301f, -0.09380855f, 0.17734072f, 0.04789791f, 0.09302556f, -0.00816890f, 0.07067747f, 
    -0.96749049f, 0.31721371f, -0.01084257f, -0.16219178f, 0.29885745f, -0.04734584f, 0.00637251f, 0.08516749f, 
    0.17082135f, 0.07973320f, 0.27658904f, 0.22379737f, -0.37917611f, 0.30570513f, -0.40476438f, -0.80355769f, 
    0.16218413f, -0.07454678f, -0.11424041f, 0.06664553f, -0.17924488f, -0.24496883f, 0.03767243f, -0.24746650f, 
    -0.21543446f, -0.14895730f, 0.01332746f, -0.43294656f, -0.20847754f, 0.09362477f, -0.00123058f, 0.09361956f, 
    -0.09969349f, 0.05135395f, -0.03514302f, -0.14829731f, -0.02760295f, -0.06296584f, -0.04666544f, 0.08167882f, 
    0.14665785f, 0.12863664f, -0.22937277f, 0.13900733f, 0.05055631f, 0.08130626f, -0.17071062f, -0.24587017f, 
    -0.14186464f, -0.62269664f, 0.05158199f, -0.10797887f, 0.17028928f, 0.09111033f, 0.06155215f, -0.05784720f, 
    -0.12089581f, 0.14131360f, -0.18645583f, 0.05072105f, -0.61320132f, -0.22314043f, 0.20991479f, -0.28754884f, 
    -0.09951692f, 0.10700161f, 0.33689624f, 0.31242236f, -0.20040728f, -0.06123755f, 0.07367124f, 0.06919787f, 
    0.22331376f, 0.16706428f, 0.02665816f, 0.35555938f, 0.18472871f, 0.14005992f, -0.00122230f, 0.08136073f, 
    -0.36300567f, 0.00109172f, 0.03810710f, -0.16354287f, -0.62220013f, 0.73863393f, -0.20559242f, 0.07952964f, 
    0.21889018f, -0.10436919f, 0.07704324f, 0.00662811f, 0.07344918f, 0.18401679f, 0.05018800f, -0.06562703f, 
    0.01950070f, -0.00841553f, -0.32325095f, 0.14646704f, -0.00841788f, -0.02432440f, 0.14386772f, -0.04363152f, 
    0.13106677f, -0.15831009f, -0.15939939f, -0.08132435f, -0.26237369f, -0.41803387f, -0.23741417f, 0.23503828f, 
    0.04004719f, -0.02608905f, -0.12450720f, 0.08202905f, 0.01796655f, 0.12458162f, 0.09239038f, -0.04374060f, 
    -0.35020235f, -0.09786091f, 0.03578632f, -0.23961738f, 0.05815628f, -0.30708954f, -0.14805976f, 0.01071983f, 
    -0.21989205f, 0.01604000f, -0.16463043f, 0.19343217f, 0.34795207f, -0.07984459f, 0.16209415f, -0.37418431f, 
    0.13609047f, 0.31214648f, 0.12545356f, -0.05250352f, -0.03353341f, -0.25277051f, -0.16559766f, 0.17544381f, 
    -0.52899647f, 0.07094850f, 0.17096572f, 0.05819713f, 0.15155703f, 0.03569009f, -0.18309233f, -0.07189012f, 
    0.01057775f, 0.14836045f, -0.01604614f, 0.05246872f, -1.20242620f, 0.21265544f, -0.25796407f, -0.18544528f, 
    0.35750356f, -0.04035804f, -0.08362453f, 0.04157883f, 0.11351955f, 0.03317102f, 0.08914112f, 0.28049764f, 
    0.33154923f, -0.02008378f, -0.31995162f, -0.44906381f, -0.10964299f, 0.00376095f, -0.47128913f, -0.01205113f, 
    0.01620596f, 0.04803970f, -0.26947367f, 0.04991364f, -0.34505475f, -0.21482614f, 0.11269090f, 0.17153342f, 
    -0.15648483f, 0.12292413f, 0.06954929f, 0.08972441f, 0.15138432f, -0.26871979f, 0.23035908f, -0.20912693f, 
    -0.78819454f, -0.68449807f, -0.28972685f, -0.34707612f, -0.04843825f, 0.04347980f, -0.02474414f, -0.17579570f, 
    0.21556933f, -0.37831104f, -0.25459659f, 0.03792084f, -0.25082460f, -0.20383918f, -0.08192779f, -0.62211943f, 
    0.06733143f, 0.10010299f, -0.04095950f, 0.03465054f, 0.12879388f, 0.13491988f, 0.08216716f, 0.02906719f, 
    -0.84951800f, -0.12682168f, -0.25825003f, 0.06028572f, 0.25344884f, -0.11211349f, -0.22485414f, -0.15244512f, 
    0.06201503f, -0.05609063f, 0.15905558f, -0.17696917f, 0.76820213f, 0.15396284f, -0.08555031f, -0.00100573f, 
    -0.11561701f, 0.08269994f, 0.00453944f, -0.16421707f, 0.27979830f, 0.49614844f, -0.03272825f, 0.15917137f, 
    0.25569704f, 0.03510316f, -0.10847681f, -0.31011397f, -0.38316351f, 0.04437641f, -0.01423078f, 0.01411796f, 
    0.15331410f, 0.02880980f, 0.16386126f, -0.18994126f, -0.00529084f, -0.19806539f, -0.04445432f, -0.09513514f, 
    -0.28175870f, -0.23695816f, 0.07890679f, -0.10259599f, -0.07133292f, 0.06522338f, -0.30733591f, -0.17260501f, 
    0.27743733f, -0.15536392f, -0.03552496f, 0.29568124f, -0.00488506f, -0.09923605f, 0.13154653f, 0.15332176f, 
    -0.09109054f, 0.39739516f, -0.14126007f, 0.28820178f, 0.25069389f, -0.08889854f, 0.31214631f, -0.02666554f, 
    0.24364401f, 0.19218999f, 0.18594624f, 0.11038984f, 0.15470123f, -0.01098585f, 0.05116697f, 0.06869573f, 
    0.18009627f, 0.47319034f, 0.05826956f, 0.00806623f, 0.01099108f, 0.27963895f, 0.16941200f, 0.13504358f, 
    0.01699774f, 0.21133931f, 0.18389143f, 0.16834620f, 0.52950490f, -0.19830628f, 0.04214177f, 0.01362630f, 
    -0.43765241f, -0.02588287f, 0.11210602f, -0.11790817f, 0.05974966f, -0.06605109f, -0.07142480f, -0.10466912f, 
    0.31894732f, -0.12690118f, 0.07272326f, -0.94326293f, -0.02305808f, -0.07334430f, 0.11792696f, -0.04719461f, 
    -0.23932847f, -0.09285117f, -0.03594256f, -0.16356938f, -0.27554089f, -0.07546601f, 0.21478835f, 0.11886884f, 
    -0.05346936f, 0.10549482f, 0.11837116f, 0.06809369f, 0.06044609f, 0.08133949f, 0.02899800f, -0.08886673f, 
    1.01748681f, 0.24784842f, -0.35335946f, -0.03747455f, 0.08696044f, 0.00367939f, -0.04170684f, 0.05922095f, 
    0.20754734f, 0.19384141f, 0.07265188f, -0.00406961f, 0.32949182f, 0.00089258f, -0.24233073f, 0.13247845f, 
    -0.17481636f, -0.01815312f, -0.02478812f, 0.02198788f, -0.22393166f, -0.17085133f, -0.09742314f, -0.00507477f, 
    -0.85640621f, 0.20092754f, 0.08358156f, -0.35337356f, 0.05447128f, 0.03868676f, -0.05397886f, 0.31026036f, 
    0.30377275f, 0.05864709f, -0.10295123f, -0.15821485f, 0.04830056f, 0.38507417f, -0.34573588f, -0.00987553f, 
    0.06560913f, -0.21807970f, -0.25021204f, -0.23152797f, -0.05951652f, 0.16587514f, -0.06739165f, -0.03833246f, 
    -0.72181243f, -0.39087448f, -0.21484375f, -0.29156935f, 0.23741974f, 0.09002234f, 0.19600752f, 0.15857758f, 
    0.18284942f, -0.05439688f, 0.07547572f, -0.01419616f, 0.57126927f, -0.52146155f, -0.46357712f, 0.13143636f, 
    0.22022706f, -0.28680554f, -0.07230580f, 0.11473218f, -0.13573593f, 0.15555933f, -0.04738299f, 0.04336890f, 
    -0.16313982f, -0.14139125f, -0.13593812f, 0.08982962f, -0.07256326f, -0.01644389f, -0.18788572f, -0.01961816f, 
    -0.01471640f, -0.23811881f, 0.16295104f, 0.21852978f, -0.14134514f, -0.06609065f, -0.05537858f, 0.17484528f, 
    -0.25557929f, 0.14833671f, -0.01775177f, 0.08434335f, 0.12869562f, -0.23836158f, -0.08712088f, -0.17244941f, 
    0.11246587f, 0.14746514f, -0.28405875f, -0.03954970f, -0.36500382f, 0.08583892f, 0.00003042f, -0.20497835f, 
    -0.03001502f, 0.03310155f, -0.16407989f, -0.32559595f, 0.46394339f, -0.31849885f, -0.15444063f, 0.11586861f, 
    0.17416015f, 0.12434348f, -0.14716083f, 0.01839360f, -0.22193271f, -0.03177871f, 0.27410844f, 0.23905449f, 
    -0.29816666f, 0.06051966f, -0.18043549f, 0.20867299f, 0.29660934f, 0.09190165f, 0.23718913f, -0.17519063f, 
    -0.03356032f, -0.18592267f, -0.10305075f, -0.03869358f, 0.27126437f, -0.26487079f, 0.03969515f, 0.54936785f, 
    0.16224383f, 0.10243678f, -0.03787201f, -0.13259503f, 0.11284192f, 0.04461859f, -0.05527701f, -0.03361327f, 
    -0.96721679f, 0.40613368f, 0.12906750f, -0.11613692f, 0.02115534f, -0.09168211f, 0.12159495f, -0.15073349f, 
    -0.08711449f, -0.05848634f, -0.10523539f, 0.08450419f, -0.37071514f, 0.26885372f, 0.06121945f, 0.14875868f, 
    -0.08811691f, -0.09665392f, 0.33208835f, 0.10519125f, 0.01874791f, 0.04240138f, 0.01680388f, -0.19718377f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19041488f, 0.07311191f, -0.03137759f, -0.02492829f, -0.01313032f, -0.06502777f, 0.07519581f, -0.14246383f, 
    -0.14187227f, 0.02272105f, 0.16074474f, 0.10773538f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
