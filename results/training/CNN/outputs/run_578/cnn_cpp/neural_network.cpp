#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.87717766f, -0.73857474f, 0.17672685f, -0.60667962f, -1.00047183f, 1.01558709f, -0.31757855f, -0.13859631f, 
    -0.02778874f, -0.51555467f, 0.13112904f, -0.47382224f, 1.45589411f, -0.62682670f, 0.91494441f, -0.10452317f, 
    -0.23671575f, -0.51558781f, -0.63739657f, 0.94135714f, -0.25118572f, -0.67904431f, -0.18935874f, -1.41662288f, 
    0.09706339f, -0.09900115f, 0.48354101f, 0.75122327f, 1.40964079f, -1.68216836f, -0.12037478f, -0.14416669f, 
    -0.03501456f, 0.71563727f, -0.07753862f, 0.19991153f, 1.07314038f, -0.77447051f, 0.15690029f, -0.08892724f, 
    -1.36734307f, -0.27523118f, -0.73413688f, -0.54534543f, 0.50723749f, -0.02450298f, -1.53433466f, -0.05770578f, 
    0.90914440f, -0.68027282f, 0.86931211f, -0.00336693f, -0.30323055f, 0.10413957f, -0.97483790f, -0.30616224f, 
    0.73060262f, 0.46978438f, -0.26152620f, 0.64497131f, -0.09404314f, -0.86273640f, 0.65530658f, 0.67421579f, 
    0.91260397f, -0.79457593f, 1.39576674f, -0.58615971f, -0.80060887f, -0.55598629f, -0.49897060f, -0.37748680f, 
    0.87709910f, -0.25045431f, 1.24093425f, 1.05249035f, -0.26408732f, 0.19771862f, -0.24779642f, 0.28978345f, 
    0.21805856f, -0.48619351f, -0.14747362f, 0.95792985f, -0.10814042f, 1.22711289f, 0.43855360f, -0.67319721f, 
    0.62177283f, -0.30833861f, 0.39898515f, 0.77823323f, 0.65283436f, -1.25307989f, -0.84120673f, -0.86218172f, 
    -0.60372794f, 0.39388537f, 0.25780621f, 0.99129069f, 1.11739683f, 0.77390981f, -0.52390248f, 1.16135848f, 
    -0.47569719f, 0.28045964f, 0.17026396f, 0.01036545f, -1.21671903f, 0.27635762f, -0.43605486f, 0.79706568f, 
    0.99476349f, 0.33044028f, 0.32261676f, 0.09364428f, 0.84482986f, -0.85800421f, -0.68635684f, -1.03699207f, 
    -0.07338916f, -1.03608012f, 0.44644788f, -0.48154840f, 0.17477901f, -0.09721047f, 1.09308064f, 0.51442921f, 
    0.66345197f, 0.73172116f, -0.32698134f, -0.34553590f, 0.47887084f, 1.12718785f, 0.34722143f, 0.80399752f, 
    0.92582357f, 0.35499564f, -0.66902715f, -0.39344013f, 0.73721439f, 0.51732796f, 0.53477424f, -0.50271368f, 
    -1.07670307f, -1.07155538f, -1.04505074f, 0.55385876f, 0.68441558f, 0.73105323f, -0.22434865f, -0.07789030f, 
    -0.21638173f, -0.28237808f, -0.18539056f, 0.20997262f, -0.67549634f, 0.76023847f, 1.22521102f, 0.59001976f, 
    -0.37642455f, 0.25370800f, 0.96326530f, 0.99235559f, 0.89109552f, 0.41473910f, 0.27819282f, 0.61759031f, 
    -0.66250277f, -0.23724937f, -0.52182788f, 0.87249285f, 0.57089120f, 0.52674949f, 0.78730178f, 0.79015356f, 
    0.96036077f, 0.22725946f, -0.03585185f, 0.36089736f, -0.14255098f, -0.87383163f, -0.56054574f, -0.28010872f, 
    0.11872920f, 0.58382213f, -0.34483731f, -0.30321717f, -0.87755692f, 1.09798956f, -0.95571953f, 0.24066098f, 
    0.92538327f, 0.63572443f, 0.49790284f, -0.57357502f, -0.19306189f, -0.36826304f, -1.08077157f, -0.65958923f, 
    -0.42767176f, -0.40301445f, -0.47389528f, -0.75646013f, 0.73320717f, 0.12129293f, 0.56021965f, -0.63227981f, 
    1.10601282f, 0.39209539f, -0.29709086f, 0.84167266f, 0.62091660f, -0.54148960f, -0.30644715f, -0.02305724f, 
    0.08172233f, -0.56081837f, -0.06156672f, -0.64916271f, 0.24406865f, 0.53886151f, -0.03150444f, -0.77878737f, 
    -0.52419966f, 0.85999942f, -0.63700110f, -0.68121171f, -0.87232262f, -0.91320068f, -1.35691142f, 0.35860315f, 
    0.55523497f, -0.31046343f, 1.01334906f, 0.68359381f, 1.09250140f, -0.71769536f, -0.55133265f, -0.84847426f, 
    0.62311959f, -0.03962973f, -0.23690702f, -0.72091824f, -1.07840776f, -0.72193140f, -0.45242545f, 1.10964763f, 
    -0.76444495f, -0.24567443f, 0.49654573f, -0.37616688f, 0.98584503f, 0.61662084f, 1.37560666f, 0.68833566f, 
    -0.51277035f, 0.05408325f, -0.27352637f, -0.32099608f, -0.28019631f, -0.45427459f, -0.52960742f, -0.85588348f, 
    0.18292466f, -0.08601017f, -0.95440257f, -0.97359568f, -0.35459122f, 0.17149861f, -0.80909723f, -0.44707015f, 
    -0.15453450f, 0.74453306f, 1.31353462f, 0.45976683f, 0.05843994f, -0.52402633f, -0.62739617f, -1.01478350f, 
    -0.66110021f, -0.95099926f, -1.07483864f, 0.70911169f, 1.09332919f, 0.03624856f, 0.09387826f, 0.48600417f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.18673070f, -0.42186105f, 0.34382111f, -0.27379546f, 0.19976486f, 0.06750963f, -0.15307751f, -0.03837403f, 
    0.41709656f, -0.36477795f, 0.33119315f, 0.42753503f, 0.42931974f, -0.36393431f, -0.32804057f, -0.05119101f, 
    0.16641380f, 0.29762962f, 0.00160559f, 0.08936726f, -0.10130133f, 0.12697360f, 0.09736644f, 0.20380785f, 
    0.05054667f, 0.03384311f, -0.21058327f, 0.13265939f, -0.00972267f, 0.14419188f, -0.03603877f, 0.00997813f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.05880591f, 0.03416519f, 0.01509822f, -0.00191216f, -0.04893275f, -0.00557494f, -0.05262189f, -0.05974444f, 
    -0.03005464f, -0.02076840f, 0.00101246f, 0.03505559f, -0.05219149f, 0.01457569f, -0.04396069f, -0.05375925f, 
    0.03276469f, -0.02310786f, -0.00777596f, 0.01887889f, 0.01851506f, 0.01363251f, -0.04959068f, 0.02217443f, 
    0.02395478f, 0.02533592f, 0.00785965f, 0.02268801f, -0.05980523f, 0.02580409f, 0.02530924f, 0.03630628f, 
    0.01751510f, 0.02628387f, -0.05379320f, -0.00673469f, -0.04315579f, -0.03872943f, -0.05515564f, 0.03749392f, 
    -0.06108790f, -0.02081643f, -0.05290646f, 0.00106541f, -0.00123024f, -0.00470480f, -0.00171511f, -0.06534707f, 
    -0.06062783f, 0.03933333f, -0.04974961f, -0.02735113f, 0.04500859f, 0.01294093f, -0.05324921f, 0.02400386f, 
    -0.06357742f, -0.04810131f, -0.00441574f, 0.03172437f, 0.01082371f, 0.00382230f, -0.04906930f, -0.05274756f, 
    0.03913186f, 0.03300282f, 0.01722785f, 0.01618068f, 0.01924740f, -0.00436836f, -0.00685682f, 0.03565297f, 
    0.05451893f, -0.01490060f, 0.02315387f, 0.00399400f, -0.02633897f, -0.05708966f, -0.00539310f, 0.03912832f, 
    -0.05516353f, -0.00670435f, 0.01005639f, 0.02909462f, -0.02144672f, 0.04387382f, -0.05154140f, -0.01493145f, 
    0.00869528f, -0.00318802f, 0.02783298f, 0.01579809f, -0.04896519f, 0.04629496f, 0.01855795f, -0.06742655f, 
    0.01509435f, -0.04311632f, 0.00189157f, 0.01123996f, -0.00308385f, -0.04959757f, 0.05299084f, -0.00852463f, 
    -0.05936827f, -0.06793679f, -0.03332466f, -0.03419178f, -0.05906023f, -0.05711181f, 0.03669960f, -0.02503881f, 
    -0.01143337f, -0.00019559f, -0.06608873f, 0.02837016f, -0.06740595f, -0.00425682f, -0.05921092f, 0.02938105f, 
    -0.03727397f, 0.02978040f, -0.04992371f, -0.04156253f, -0.00759602f, -0.00253886f, -0.02153355f, 0.00139796f, 
    -0.04613809f, -0.05009701f, 0.05023530f, -0.03541372f, -0.06765772f, 0.04742645f, -0.01639589f, -0.00850841f, 
    -0.03462617f, -0.06476109f, -0.01775448f, 0.03640535f, -0.00141586f, -0.02258144f, -0.00584983f, 0.00216815f, 
    0.03036642f, -0.03322474f, 0.04159226f, 0.02873319f, 0.01930725f, -0.00958092f, 0.02863795f, -0.03366788f, 
    0.04393563f, 0.03616200f, 0.01818895f, -0.00014693f, 0.00730975f, -0.01954441f, 0.00337826f, 0.04071394f, 
    -0.02572796f, 0.05056231f, -0.00455467f, -0.03377591f, -0.01201799f, 0.02895185f, -0.06174284f, -0.04884352f, 
    -0.05002371f, -0.04075186f, 0.02842379f, 0.00098401f, 0.00114410f, 0.01069323f, 0.01803447f, -0.01640151f, 
    -0.06220511f, -0.05276598f, 0.01612836f, -0.02424196f, 0.01891320f, -0.05900357f, -0.00663022f, -0.05913075f, 
    0.01561938f, -0.04439205f, 0.03552917f, 0.01476816f, -0.03263320f, 0.02498303f, 0.03540910f, -0.05945690f, 
    -0.06366297f, -0.04556441f, 0.00759910f, 0.00752033f, -0.04573588f, -0.06561086f, -0.02698760f, -0.03212653f, 
    -0.03329009f, 0.04167963f, 0.02151688f, 0.00637090f, 0.03159192f, -0.01791086f, -0.02545175f, -0.00495260f, 
    -0.00708122f, -0.02478047f, 0.04023663f, -0.00051765f, 0.00189187f, -0.06034824f, 0.04985337f, -0.02784814f, 
    0.00349116f, -0.04892672f, -0.01548578f, 0.00144475f, -0.03236990f, -0.04553714f, 0.02743688f, 0.02345375f, 
    0.01070044f, -0.02545363f, -0.05183938f, -0.02537953f, 0.02407806f, 0.03239154f, -0.02105466f, 0.05338153f, 
    0.05106985f, -0.03123754f, 0.02112388f, -0.00262200f, -0.00786992f, 0.00633190f, -0.00750867f, 0.03803837f, 
    -0.04587374f, 0.02168307f, -0.04787567f, 0.03947897f, -0.01965365f, -0.03309086f, 0.01242685f, 0.02755093f, 
    -0.00782175f, -0.03761822f, 0.04495011f, 0.00045721f, -0.02439803f, 0.04744707f, -0.04793619f, -0.00526646f, 
    0.03321864f, 0.01982639f, 0.01776064f, 0.02534045f, -0.04016907f, -0.02371740f, -0.00545836f, -0.00088516f, 
    -0.02425810f, -0.05324690f, -0.01123034f, 0.04532372f, -0.06204892f, 0.02326991f, -0.03201418f, -0.03829461f, 
    -0.00060137f, 0.02580830f, -0.01359063f, -0.01431915f, -0.00939928f, 0.00731289f, 0.00405479f, -0.03038026f, 
    -0.04454754f, 0.02367858f, 0.02917435f, 0.05121758f, -0.00568505f, -0.04016690f, 0.00678750f, 0.05050014f, 
    -0.23106095f, 0.25616845f, -0.19167201f, -0.00553628f, -0.27982697f, 0.32415542f, -0.02221289f, 0.08988674f, 
    -0.01801984f, -0.12457120f, -0.12451053f, -0.09468560f, 0.28006738f, 0.21019644f, -0.16927537f, -0.20411704f, 
    -0.04313279f, 0.01086095f, -0.01569978f, -0.18895958f, -0.07677939f, 0.08647673f, 0.08638626f, 0.22775564f, 
    0.14096865f, -0.22337365f, -0.15093625f, 0.28095591f, 0.10756595f, 0.07827213f, 0.31521466f, -0.08937722f, 
    -0.00824605f, -0.12263588f, 0.13036686f, -0.16524266f, 0.09517868f, 0.00535392f, 0.00004728f, 0.13585995f, 
    0.04823336f, 0.29704535f, -0.08134145f, -0.12468378f, 0.03646446f, 0.09746484f, 0.13892965f, 0.08375862f, 
    0.16055922f, 0.20005769f, 0.01404205f, 0.08323120f, 0.15070899f, -0.07624253f, -0.30182964f, 0.25851107f, 
    -0.19985564f, 0.03324174f, -0.03126616f, 0.08736178f, -0.16473433f, 0.13583897f, 0.07870936f, 0.22940536f, 
    -0.04690645f, -0.03651251f, 0.01916925f, 0.11335650f, -0.01425987f, -0.22316873f, -0.09066001f, -0.02035055f, 
    -0.10965525f, -0.10609521f, -0.07470011f, -0.08084427f, 0.09638303f, 0.10175713f, 0.31772947f, -0.19852030f, 
    0.12180662f, -0.10393608f, -0.04687937f, -0.07029829f, -0.21380162f, -0.24212626f, 0.00449392f, -0.01140374f, 
    0.06175566f, -0.12434074f, 0.11373706f, -0.01306330f, -0.19965097f, 0.08753926f, 0.03889838f, 0.18870860f, 
    -0.18838210f, -0.18153223f, 0.08245067f, 0.33280319f, -0.38284901f, -0.14428268f, 0.17162919f, -0.00255108f, 
    0.18974121f, 0.08617425f, 0.03779931f, 0.15143315f, -0.19633970f, 0.04202723f, 0.07674530f, 0.03019946f, 
    -0.07608002f, 0.04825983f, 0.21608151f, 0.05466513f, 0.09586473f, 0.51918888f, 0.43387496f, -0.19122294f, 
    0.06930479f, -0.11508343f, 0.04018389f, -0.07415098f, 0.19369917f, 0.02113974f, 0.10937861f, -0.37106508f, 
    0.04827977f, 0.02158349f, 0.03726101f, -0.02807839f, 0.49305984f, -0.14957426f, 0.22600016f, 0.28337908f, 
    -0.10624687f, -0.02070586f, 0.20826694f, -0.11626239f, 0.02462680f, -0.12399489f, -0.00236195f, 0.07056884f, 
    0.21986674f, 0.20700438f, 0.03881147f, -0.09871115f, -0.02543926f, -0.17061834f, 0.14685263f, 0.09958962f, 
    0.02030207f, -0.35071626f, 0.19682492f, -0.08756053f, 0.27025378f, 0.03518321f, -0.20434575f, -0.05339089f, 
    0.09806175f, -0.06321967f, 0.11137678f, -0.22273140f, -0.15446240f, 0.02662762f, -0.01558880f, -0.14723647f, 
    -0.08487216f, -0.00897943f, 0.19351172f, -0.25231424f, -0.16653070f, -0.01236936f, -0.07002936f, 0.11881992f, 
    -0.06342850f, 0.20231757f, 0.02605351f, 0.15023875f, -0.08109946f, 0.03639946f, 0.01244993f, 0.01180571f, 
    -0.11752091f, -0.27730438f, 0.04475067f, 0.25612938f, -0.06946412f, -0.22047880f, -0.37283489f, -0.16514836f, 
    0.18724488f, 0.06674996f, -0.14818943f, 0.17557323f, 0.03050024f, -0.09847185f, -0.02147078f, 0.11111417f, 
    -0.12193603f, -0.15034506f, 0.02645927f, 0.20444256f, 0.12639426f, -0.10510094f, 0.09473671f, -0.52164501f, 
    -0.29261026f, -0.15730162f, 0.15971579f, 0.08531778f, 0.10418689f, -0.17716858f, 0.08744372f, 0.10458571f, 
    -0.11991086f, 0.07741251f, -0.10955662f, 0.08860160f, -0.06227376f, -0.27762321f, -0.04407202f, 0.09066216f, 
    -0.03165780f, 0.16532925f, -0.00472920f, -0.06532935f, 0.04909606f, -0.06829591f, 0.15349473f, -0.10770563f, 
    -0.12837164f, -0.34300062f, 0.52591181f, -0.14908081f, 0.00914432f, 0.12218270f, -0.04002193f, 0.34811223f, 
    -0.15519467f, 0.16609199f, -0.04329103f, 0.06336998f, 0.11325116f, -0.06588775f, 0.01264898f, 0.10177331f, 
    -0.06707935f, -0.12355186f, -0.09325494f, -0.22005352f, 0.22137022f, -0.26794708f, -0.10947001f, -0.08496718f, 
    0.18330692f, 0.11283008f, -0.09176840f, -0.10980815f, 0.14914115f, 0.13610756f, -0.11270419f, 0.00107752f, 
    -0.32862392f, 0.13134977f, 0.07486562f, -0.20866929f, -0.01986316f, 0.09961642f, -0.01535130f, 0.09350601f, 
    -0.11459666f, 0.02977088f, 0.09097322f, -0.26852745f, -0.07703393f, 0.12894158f, 0.06197193f, -0.26285917f, 
    -0.00492276f, 0.01411522f, 0.14389060f, -0.16480593f, -0.01506849f, 0.00194311f, 0.15432617f, -0.01544013f, 
    -0.59006929f, -0.19386776f, -0.31843412f, 0.18003197f, 0.09011855f, 0.21218888f, 0.21433435f, -0.01090974f, 
    0.02744528f, -0.10097556f, 0.06852002f, -0.25890428f, -0.09286790f, -0.06487063f, 0.21423554f, -0.06325035f, 
    -0.05210979f, -0.05231842f, -0.49572930f, 0.07037022f, -0.38770661f, 0.01517488f, 0.09436614f, 0.00939664f, 
    -0.10248847f, -0.06567217f, 0.08930270f, 0.30940357f, -0.35998419f, -0.10158874f, 0.09439947f, -0.19136041f, 
    -0.11485057f, -0.00663908f, 0.12157433f, 0.04012179f, -0.45921162f, 0.01795426f, -0.31147084f, 0.10280848f, 
    0.25000927f, 0.10110454f, 0.03931437f, 0.13359109f, 0.19352429f, 0.16368505f, -0.11351639f, -0.04815483f, 
    0.13503025f, 0.02167992f, 0.12668981f, 0.31597766f, -0.12600106f, -0.23694168f, -0.08883886f, 0.44549811f, 
    -0.27756810f, 0.07922480f, 0.04382413f, -0.03629624f, 0.07820122f, -0.06482690f, 0.10478767f, -0.23202886f, 
    -0.70638663f, -0.01773327f, -0.17418227f, -0.16283968f, 0.00081919f, -0.17494319f, 0.22411270f, 0.11616148f, 
    0.12380648f, 0.07981215f, 0.03968143f, -0.27026764f, 0.00606914f, -0.00069492f, 0.12744755f, -0.05885744f, 
    0.16612773f, -0.06833592f, 0.42713487f, -0.17407028f, -0.03955659f, -0.12956837f, 0.10831889f, -0.06553183f, 
    -0.06796648f, 0.09193435f, -0.41275716f, 0.01838155f, -0.21383156f, -0.09537848f, 0.01289733f, 0.00099039f, 
    -0.26910618f, 0.00606162f, 0.01961226f, 0.29564333f, 0.16264130f, 0.11838043f, -0.08371048f, -0.00309157f, 
    -0.03876480f, 0.04113059f, 0.11408646f, 0.11317929f, 0.38010570f, 0.37247136f, -0.02100015f, 0.14671060f, 
    0.01230948f, -0.20777968f, -0.17739028f, -0.05183132f, -0.06039380f, 0.03611705f, 0.08573650f, 0.12883240f, 
    0.16174023f, 0.11235814f, 0.09012216f, -0.07296757f, 0.16883397f, 0.17843460f, -0.05020330f, 0.13567132f, 
    0.31584299f, 0.16481762f, -0.09646541f, -0.11981092f, 0.04652768f, -0.02677438f, -0.00836993f, -0.00585989f, 
    0.19688345f, 0.08022490f, -0.07207317f, -0.11081612f, 0.15390673f, 0.05002812f, 0.05151918f, 0.20962152f, 
    0.22189756f, 0.13280633f, -0.14473042f, 0.05600018f, -0.19404674f, -0.02872745f, 0.08597820f, -0.12392868f, 
    0.03572596f, 0.09984683f, 0.15466784f, -0.08911024f, -0.05882956f, -0.09270023f, 0.01740855f, 0.01225047f, 
    0.02323174f, 0.00982638f, 0.23316422f, 0.24141991f, 0.00164240f, -0.13377614f, -0.06191102f, -0.00634179f, 
    0.04890040f, 0.28952053f, 0.03457908f, 0.12254897f, 0.19351034f, 0.14807163f, -0.01678270f, -0.04874964f, 
    -0.09251632f, 0.05736747f, 0.11413956f, 0.06846321f, -0.07053803f, 0.12729247f, 0.07903673f, 0.05891230f, 
    -0.24610159f, -0.05930766f, 0.32095468f, 0.15105002f, 0.10244960f, 0.09663624f, -0.21997440f, 0.02621651f, 
    -0.03408131f, -0.17013651f, -0.14223385f, 0.18078257f, 0.10894020f, 0.15047596f, -0.02872698f, 0.00964992f, 
    0.12044738f, 0.07487799f, 0.16870889f, -0.08224846f, -0.11394510f, -0.08848620f, -0.00374747f, 0.35704124f, 
    0.32951862f, -0.38101777f, 0.00220094f, -0.05311355f, 0.03511052f, -0.06236979f, 0.24946266f, 0.09595762f, 
    -0.12298436f, 0.19189462f, 0.08129011f, 0.01128846f, -0.00227899f, -0.09023818f, 0.40147114f, 0.10319774f, 
    0.20463146f, -0.32189083f, -0.31052461f, 0.16409083f, 0.10318585f, 0.17367271f, -0.05335953f, 0.01598631f, 
    0.42280623f, -0.12050296f, -0.18648259f, -0.03230021f, 0.06412040f, -0.13977644f, -0.14430840f, -0.06095644f, 
    -0.08141562f, -0.09634764f, 0.11106080f, 0.02484164f, -0.45868385f, 0.10622939f, 0.00660035f, 0.15822050f, 
    0.06236659f, -0.02675571f, -0.04589248f, 0.15194261f, 0.11111539f, 0.02767959f, 0.11204655f, -0.15778869f, 
    -0.00828089f, 0.07923540f, -0.05479398f, 0.10144471f, 0.04441445f, -0.06679204f, -0.07056598f, -0.23512441f, 
    0.14678152f, 0.01583632f, -0.04169230f, -0.18810563f, 0.19436336f, 0.11439785f, 0.08411320f, 0.16353664f, 
    -0.00417291f, -0.00738535f, -0.13858621f, -0.09577525f, 0.11115476f, -0.04333631f, -0.07185012f, 0.46054295f, 
    0.08624856f, 0.06658193f, 0.13079298f, -0.03062625f, -0.05669463f, -0.21222566f, -0.09092391f, 0.08032219f, 
    0.01886884f, -0.03392608f, -0.01940919f, 0.01581152f, 0.00840787f, -0.02013204f, -0.05694205f, 0.03526575f, 
    0.03987771f, 0.04626356f, -0.03175135f, -0.04065500f, 0.04544220f, -0.06244679f, 0.03006218f, 0.04786126f, 
    0.02140429f, -0.07197285f, -0.00456475f, 0.03443246f, 0.01554884f, 0.02311026f, -0.03882691f, -0.03057687f, 
    -0.04860992f, 0.02614922f, 0.01363896f, -0.01675675f, -0.05691410f, -0.06454268f, -0.00651614f, 0.01765644f, 
    -0.05875078f, -0.01138188f, -0.01283210f, -0.03453191f, 0.04326994f, 0.02077547f, 0.03590022f, 0.05723340f, 
    -0.05754510f, -0.00407625f, 0.03544652f, 0.01674649f, 0.00710173f, 0.04703450f, -0.03661209f, 0.03430366f, 
    0.04176057f, -0.00628370f, -0.01278968f, -0.05362141f, -0.02450032f, -0.05043839f, 0.03008824f, -0.06535259f, 
    -0.04028725f, -0.03417188f, -0.05519995f, -0.03400144f, -0.05861421f, -0.00178788f, -0.02623496f, -0.04074687f, 
    -0.00755797f, 0.05169100f, -0.07521639f, 0.02665424f, -0.00290370f, -0.05582528f, 0.02130884f, 0.00024566f, 
    -0.01943083f, 0.04175035f, 0.04164028f, -0.04248863f, 0.01579334f, 0.01901261f, 0.02374099f, -0.05784029f, 
    0.00724140f, 0.02781090f, -0.03930559f, -0.05997828f, -0.00858036f, -0.06154385f, -0.05268079f, -0.02912544f, 
    -0.05373172f, 0.03350795f, -0.05310698f, -0.05838671f, 0.02603891f, 0.04522380f, -0.04141591f, -0.01384093f, 
    -0.04187431f, 0.01076994f, 0.01417748f, -0.05864543f, -0.03411121f, 0.02558404f, 0.02270798f, 0.04109792f, 
    -0.00213480f, 0.04058190f, -0.01106099f, -0.01472392f, 0.00755594f, 0.04872073f, -0.04879103f, 0.00861179f, 
    -0.06662909f, -0.02944628f, -0.02868287f, 0.02380372f, -0.05163476f, -0.00763722f, 0.03433058f, 0.01436276f, 
    0.00655340f, -0.01290114f, 0.01770420f, 0.02596895f, -0.01534880f, -0.07173547f, 0.05782005f, -0.05365555f, 
    -0.02812586f, -0.01225927f, 0.02523743f, 0.02528505f, 0.00049580f, -0.02963563f, -0.00293592f, 0.01048252f, 
    -0.03517501f, 0.01038186f, -0.01253163f, -0.00273059f, -0.05183940f, -0.04051053f, -0.01964187f, 0.01692634f, 
    -0.05804857f, -0.02764946f, -0.02545402f, -0.06720097f, -0.07454459f, -0.04544582f, -0.00969805f, -0.05575098f, 
    0.03040005f, -0.06313056f, -0.02282308f, -0.03558460f, 0.03621911f, -0.07248294f, 0.02857216f, 0.04662077f, 
    0.01392222f, -0.02811085f, -0.02124987f, 0.03784236f, -0.02127198f, 0.01811766f, -0.02696053f, -0.04817412f, 
    0.03601216f, -0.00290644f, -0.00330456f, -0.02968975f, -0.04079377f, -0.06562304f, 0.03190989f, 0.01688583f, 
    0.05374120f, -0.03212172f, -0.04760147f, -0.01001028f, -0.00281625f, 0.02920339f, 0.00776168f, -0.01155847f, 
    -0.03919316f, 0.00671996f, -0.05063704f, -0.03298686f, 0.03732458f, -0.03507275f, -0.03717254f, -0.05184064f, 
    -0.05148258f, 0.03391853f, 0.00841904f, 0.03988741f, -0.06456151f, -0.02428333f, -0.04784402f, 0.01789321f, 
    0.02482708f, 0.02256696f, -0.05313060f, 0.03876372f, -0.04842113f, 0.01884516f, -0.05712861f, 0.03541782f, 
    0.02160279f, 0.01200854f, 0.04909109f, 0.04736250f, 0.01673769f, 0.04796163f, 0.00183031f, 0.03602947f, 
    -0.01922215f, 0.01107084f, -0.05828965f, 0.00141473f, 0.03820394f, 0.00092455f, 0.04631757f, 0.00314324f, 
    0.04235381f, -0.03474611f, -0.03509699f, -0.00782096f, 0.03673458f, 0.04245476f, 0.01932786f, 0.03796164f, 
    0.01483298f, 0.03831355f, -0.03272750f, 0.00757492f, -0.03109878f, 0.04945506f, -0.02855563f, -0.00920464f, 
    0.01922479f, 0.04344830f, -0.04609075f, -0.01816258f, -0.06528831f, 0.00547210f, 0.04686350f, -0.04256580f, 
    -0.00883439f, -0.03839200f, 0.02839858f, -0.05358273f, -0.01060227f, 0.02535227f, 0.02930329f, -0.03937271f, 
    0.03278485f, 0.02617632f, 0.02397853f, -0.02138245f, 0.01001576f, 0.03985357f, -0.04202015f, -0.03716728f, 
    -0.01275548f, 0.03517865f, 0.00978235f, -0.06285530f, -0.00251761f, 0.04309500f, -0.01558511f, -0.03789013f, 
    -0.01780554f, 0.02478086f, 0.03988940f, -0.04003311f, 0.01303709f, -0.01231272f, -0.00531482f, -0.01251843f, 
    -0.02298107f, 0.04665963f, 0.04534143f, 0.00244073f, -0.03780324f, -0.06180065f, 0.04299041f, -0.02704698f, 
    -0.05759766f, -0.26037997f, -0.01450875f, 0.06980302f, -0.12089116f, -0.06784644f, -0.03719899f, 0.00322979f, 
    -0.12866931f, -0.19736844f, -0.34208265f, -0.09789026f, 0.00071800f, 0.27582142f, 0.08105603f, -0.27585608f, 
    -0.15313716f, 0.06742170f, 0.20883001f, 0.16053531f, -0.00370487f, 0.07923616f, 0.11819799f, -0.18772957f, 
    0.12804112f, 0.05495433f, 0.01688800f, 0.02376650f, -0.09421784f, -0.11715677f, 0.07927129f, 0.02827868f, 
    -0.22980767f, -0.09617378f, 0.06708368f, -0.19534393f, -0.07907484f, 0.31984210f, 0.23864688f, 0.12898430f, 
    0.07157815f, -0.20089595f, 0.03667367f, 0.39474064f, -0.01378983f, 0.21505465f, -0.27342373f, 0.04385441f, 
    -0.06488275f, 0.19683574f, 0.07338239f, -0.02124709f, -0.07812115f, -0.03148599f, 0.28260279f, -0.09845993f, 
    -0.15125673f, 0.05140069f, -0.44981122f, -0.02568896f, -0.09616118f, 0.12762295f, -0.11192714f, -0.29060349f, 
    0.05206231f, 0.02597099f, -0.08056317f, 0.13008773f, -0.03387604f, 0.03425675f, -0.00842677f, 0.16740149f, 
    0.27220902f, 0.03898688f, 0.06332324f, -0.11522720f, 0.03232836f, 0.12206012f, 0.03639129f, 0.13698059f, 
    -0.10008986f, 0.03414348f, 0.10691845f, 0.05339269f, 0.17815743f, 0.13170743f, 0.11046427f, 0.02081290f, 
    0.12343900f, 0.04306096f, -0.10859384f, 0.00819205f, 0.31845552f, 0.10583263f, 0.08046528f, -0.33157927f, 
    -0.00835792f, 0.12281358f, 0.00595899f, -0.23156422f, 0.36105162f, 0.24359196f, 0.10396582f, -0.13844278f, 
    -0.24223888f, 0.07348167f, -0.01680652f, 0.04817804f, 0.36935428f, 0.15670852f, -0.36717346f, 0.01637264f, 
    0.03181364f, 0.18345621f, 0.10398640f, -0.05970580f, -0.18116857f, -0.06367872f, -0.34226131f, 0.22821409f, 
    -0.13265119f, 0.04361010f, 0.10414276f, 0.00429999f, -0.27008486f, 0.20064391f, -0.10049830f, -0.29462454f, 
    -0.04217900f, -0.26913846f, -0.28290492f, 0.07379427f, -0.09266485f, -0.06535568f, -0.28983703f, -0.31262580f, 
    0.07974237f, 0.15475424f, 0.09684952f, 0.00699205f, -0.15762399f, 0.05481800f, -0.05880722f, -0.01430889f, 
    -0.05298962f, -0.28984332f, -0.08706893f, 0.02917759f, 0.02957617f, 0.14259130f, 0.04493995f, 0.01470596f, 
    0.12151840f, -0.21894531f, -0.21602771f, -0.26559874f, 0.06641586f, 0.07851821f, 0.16877261f, -0.01732333f, 
    0.00687101f, 0.06009061f, -0.16080341f, 0.05352031f, 0.28612074f, -0.10223722f, -0.06065580f, -0.01499463f, 
    0.15662012f, -0.18554898f, 0.03226241f, -0.09833657f, -0.46372148f, 0.04128809f, 0.07963902f, -0.00099067f, 
    0.10919586f, 0.01881188f, -0.00955115f, -0.02739157f, -0.06132758f, -0.36299744f, 0.13150740f, 0.00547754f, 
    0.01813709f, 0.10975726f, -0.03890672f, 0.14635554f, 0.11946300f, 0.34688058f, -0.05871498f, -0.10680428f, 
    0.15317887f, 0.07585839f, -0.05005703f, 0.01296532f, 0.06600390f, 0.00114048f, 0.16399854f, 0.12044244f, 
    0.25773987f, 0.07427780f, -0.07939734f, 0.01172634f, -0.06536342f, -0.07247402f, -0.24654528f, 0.20230520f, 
    0.24146739f, -0.12847613f, 0.05151634f, 0.10705698f, 0.10467566f, 0.18261309f, 0.15477869f, 0.05368808f, 
    -0.06833421f, -0.05964255f, 0.05761793f, -0.00124081f, -0.05485701f, 0.03068055f, -0.08805255f, 0.12474761f, 
    0.04020879f, 0.01321224f, 0.00976636f, 0.27720204f, 0.08076894f, -0.08702733f, 0.02227735f, -0.07933182f, 
    -0.02147587f, -0.15652856f, -0.43025783f, 0.17288376f, 0.17630742f, -0.09387578f, -0.05031565f, -0.19711897f, 
    0.00921442f, -0.06969983f, 0.14265862f, 0.22768660f, 0.10814109f, -0.13436013f, 0.17480221f, -0.05423308f, 
    0.14025016f, -0.14649364f, 0.00507303f, 0.13939136f, -0.02065031f, 0.06702765f, 0.26262265f, -0.24557135f, 
    -0.09479838f, 0.02824390f, 0.01068159f, 0.10113591f, 0.02005162f, -0.02017901f, -0.23828828f, 0.31219548f, 
    -0.19863863f, 0.13558786f, 0.09421218f, -0.06745528f, -0.07812081f, 0.17885177f, -0.02431366f, -0.42702276f, 
    -0.32818037f, 0.01107459f, 0.03723520f, 0.13788314f, 0.10399421f, 0.02064964f, 0.16022803f, 0.14509836f, 
    0.09623528f, -0.06584956f, 0.04524327f, 0.12895229f, -0.02182002f, -0.14188829f, -0.17128007f, -0.05195497f, 
    -0.09714998f, 0.12488514f, -0.19321632f, -0.09163874f, 0.12464850f, 0.33148855f, 0.25413018f, 0.00612286f, 
    -0.10783451f, 0.35808122f, 0.06556140f, 0.07612899f, -0.11201371f, -0.05453486f, -0.00533002f, -0.14704700f, 
    -0.04352994f, 0.05663314f, 0.49105126f, -0.11970663f, 0.03156850f, -0.06946453f, -0.12039374f, -0.17220475f, 
    0.11017576f, 0.04513400f, -0.02476244f, 0.08934630f, 0.04066063f, -0.06149026f, 0.06694623f, 0.03973515f, 
    -0.16261737f, -0.10184275f, 0.13502972f, 0.06963974f, -0.15307765f, -0.09443457f, 0.06175259f, 0.01506168f, 
    0.08859015f, 0.14044838f, 0.22952205f, -0.03529981f, -0.05216613f, 0.27746159f, 0.07631108f, 0.15739746f, 
    -0.10524990f, -0.07996365f, -0.01397521f, 0.03054898f, -0.08715712f, -0.10200573f, -0.06420466f, 0.05435842f, 
    0.05959383f, -0.04246720f, -0.16279629f, -0.02745489f, -0.03461178f, -0.01355903f, -0.12494081f, 0.19921748f, 
    -0.20237567f, 0.13398732f, 0.20891115f, 0.21058401f, -0.01893180f, -0.07515054f, 0.06603366f, 0.04788432f, 
    -0.21642257f, -0.23540290f, -0.07808132f, 0.07809166f, 0.07707486f, 0.06544530f, 0.04903693f, 0.13992806f, 
    -0.02750935f, -0.01664169f, -0.15277956f, -0.19083606f, -0.09760907f, 0.02547847f, -0.04257314f, -0.16430600f, 
    0.04829333f, 0.08359463f, 0.44582388f, -0.03123711f, 0.22896510f, 0.05805252f, 0.18676168f, -0.17510438f, 
    -0.10524904f, -0.00956986f, 0.09246892f, -0.08706779f, -0.04358684f, -0.21517827f, 0.34248361f, 0.24973452f, 
    0.03770124f, 0.00354870f, -0.02269198f, 0.13712704f, 0.33293018f, 0.13503169f, 0.18349180f, -0.15832819f, 
    -0.19107109f, 0.11275818f, 0.10877787f, -0.09842530f, 0.08964689f, 0.16355640f, -0.18175434f, -0.26222867f, 
    0.04641104f, 0.19114771f, -0.10426031f, -0.08223652f, 0.03226568f, 0.09566089f, 0.11435834f, -0.13832220f, 
    -0.00185847f, 0.09137513f, 0.13785949f, -0.03200809f, 0.12219374f, 0.11786815f, -0.22084601f, 0.04513128f, 
    -0.17291388f, -0.34364286f, 0.13916753f, 0.10243557f, -0.10832052f, 0.22211015f, 0.10784893f, -0.29560983f, 
    0.08628871f, 0.10425872f, 0.32298139f, -0.24062882f, -0.16275299f, -0.14685284f, -0.11467982f, -0.00968378f, 
    0.09090509f, -0.08425532f, 0.21666996f, -0.11476342f, 0.02396602f, 0.04467126f, -0.01273107f, 0.00700775f, 
    0.15218307f, -0.03182944f, -0.23577201f, -0.17443040f, -0.32738280f, 0.30278006f, 0.18205217f, 0.10543325f, 
    0.04436573f, -0.04480026f, -0.17717046f, -0.09692770f, -0.15972234f, -0.09083564f, 0.14653827f, -0.02576055f, 
    0.08694682f, -0.06026571f, -0.04036392f, -0.10464251f, 0.12387855f, 0.24318844f, -0.03351902f, -0.26889712f, 
    -0.09268056f, -0.12217227f, 0.02219157f, 0.13673322f, 0.07090486f, -0.17612123f, 0.22390401f, -0.13578807f, 
    -0.25396755f, 0.18065064f, 0.14013539f, 0.05276419f, 0.04718709f, -0.14205858f, 0.05851685f, -0.05865276f, 
    -0.02162688f, -0.26514733f, -0.08002673f, -0.08344846f, 0.08152065f, -0.01005135f, 0.05761665f, -0.12013340f, 
    -0.06790381f, -0.09314661f, -0.14038989f, -0.02354585f, 0.16793433f, 0.11392933f, 0.03508674f, -0.06491289f, 
    -0.03810406f, 0.31467599f, -0.08015871f, -0.13855742f, -0.01312985f, 0.00308830f, 0.13226141f, 0.12929948f, 
    -0.05997676f, 0.35912269f, -0.08940031f, 0.05014527f, 0.08381194f, 0.09375919f, -0.28944758f, -0.06648664f, 
    -0.02498060f, -0.18601276f, 0.39239943f, -0.20243034f, 0.06352874f, 0.15791751f, 0.27936727f, -0.14664809f, 
    -0.00187088f, 0.00584311f, -0.20758735f, -0.10010799f, -0.05164976f, -0.11669360f, -0.16488042f, -0.17387742f, 
    -0.07193605f, -0.24853362f, 0.16722906f, 0.16262858f, 0.01879284f, -0.33884302f, -0.17573871f, 0.26343662f, 
    0.14062904f, 0.09097601f, -0.12453182f, 0.08657619f, -0.15052485f, -0.49753749f, -0.10060234f, 0.04384224f, 
    0.12470891f, -0.00950885f, -0.08192352f, -0.10112093f, 0.06151582f, 0.02727019f, 0.32544446f, 0.14744481f, 
    0.08502684f, -0.17873813f, -0.17110775f, -0.03650328f, 0.02349588f, -0.04732040f, -0.01287713f, 0.12548809f, 
    0.01428213f, -0.10648414f, -0.26452896f, 0.13608801f, -0.03720412f, -0.11180663f, 0.07243787f, 0.16289300f, 
    -0.31355521f, -0.09986016f, -0.15305857f, 0.18924710f, 0.01383008f, -0.06806292f, -0.23475336f, 0.09466718f, 
    0.18373987f, 0.07021215f, -0.18256794f, 0.01937825f, -0.24626304f, -0.03475657f, -0.16368063f, 0.10079159f, 
    -0.10366667f, 0.08967777f, -0.15517665f, -0.15358861f, -0.30675876f, 0.00303556f, -0.10192545f, -0.12925991f, 
    0.01995508f, 0.20278050f, -0.03259435f, -0.12877767f, 0.29181078f, -0.49596521f, 0.00536779f, 0.00509241f, 
    0.02432813f, -0.01717053f, -0.10871580f, -0.07322086f, 0.12288336f, 0.04372446f, -0.22113845f, 0.07029349f, 
    0.30886039f, 0.12277660f, -0.13227278f, 0.15268430f, -0.32907766f, 0.02030751f, 0.06629811f, 0.18272045f, 
    -0.08698513f, -0.02967522f, -0.31813341f, 0.11970110f, 0.04823267f, -0.02907365f, 0.23237306f, -0.14621195f, 
    0.36058766f, -0.15633492f, 0.09831171f, -0.02880507f, 0.08119608f, -0.10966953f, -0.10669596f, -0.11579479f, 
    0.06016217f, -0.47201312f, -0.13698931f, 0.02082870f, -0.08525229f, -0.04956225f, 0.01247754f, -0.00226749f, 
    0.24190919f, 0.03789188f, 0.15936276f, -0.02188863f, -0.01085177f, 0.02914141f, 0.01913471f, 0.16401558f, 
    0.04046464f, 0.37643048f, 0.09388710f, 0.26463935f, 0.11335519f, -0.06692338f, -0.12586559f, 0.31316394f, 
    -0.04054618f, -0.21623743f, -0.15828641f, -0.49138755f, -0.27077067f, 0.13722187f, 0.08576994f, 0.06095663f, 
    0.06826306f, -0.04627728f, -0.21259034f, -0.16889410f, 0.02777710f, 0.00675772f, 0.16304773f, 0.11344201f, 
    -0.01136633f, 0.25021738f, -0.17826998f, 0.00335123f, 0.09146883f, -0.00320158f, 0.14883925f, 0.03830075f, 
    -0.09900412f, 0.12574083f, 0.08640027f, 0.08789510f, 0.10676924f, 0.14081742f, 0.14320044f, 0.27722201f, 
    0.05739275f, -0.15288302f, -0.06419054f, 0.19582151f, 0.02228445f, 0.06516948f, 0.12754183f, -0.10160847f, 
    -0.20042489f, 0.22471096f, -0.13513945f, 0.02474164f, -0.08826686f, -0.05543721f, 0.30271965f, -0.12153740f, 
    -0.24880970f, -0.07400240f, 0.19395496f, 0.00185637f, -0.11307272f, 0.02195728f, -0.31319821f, 0.00492169f, 
    0.18520220f, 0.17579313f, 0.20190735f, 0.10096037f, 0.02857169f, -0.12629887f, 0.02533333f, 0.10633068f, 
    -0.03665154f, 0.06503265f, -0.05650754f, 0.18248859f, -0.15817364f, 0.00238497f, 0.17449443f, -0.07833636f, 
    -0.16649723f, 0.07619226f, 0.02080281f, -0.15550199f, 0.28049690f, 0.17378125f, -0.05549402f, -0.00153858f, 
    -0.22826011f, 0.16545196f, -0.14049572f, 0.36100101f, 0.06411080f, 0.27744684f, -0.00082787f, -0.04469043f, 
    0.08252694f, -0.14329608f, 0.09132425f, -0.14308996f, -0.10033990f, -0.01450737f, 0.03617219f, 0.08647947f, 
    -0.02777789f, -0.00504673f, -0.00924267f, 0.22497475f, 0.16235228f, 0.06562815f, 0.10363711f, 0.11372998f, 
    0.06151745f, -0.13298830f, -0.15754189f, 0.12466905f, -0.06630034f, -0.02835182f, -0.05997866f, 0.00123073f, 
    0.22526622f, 0.15978189f, -0.15108004f, -0.33850601f, -0.10072480f, 0.07298276f, 0.18288398f, 0.39922148f, 
    -0.00782641f, 0.08300359f, 0.10057136f, 0.04307262f, 0.14411151f, -0.05006785f, -0.01939961f, -0.29889148f, 
    -0.14279489f, -0.19677867f, -0.05561010f, 0.01957603f, -0.07327913f, -0.02036639f, -0.13171656f, 0.08781746f, 
    0.16116259f, -0.09839476f, 0.08309421f, -0.08361987f, -0.01808583f, -0.10438707f, -0.04304143f, -0.33399180f, 
    -0.22194700f, 0.02653024f, -0.27687442f, -0.26056933f, -0.36595282f, 0.01517885f, 0.07766574f, -0.02688733f, 
    0.12905635f, -0.06851555f, 0.10235792f, -0.15622410f, 0.19798727f, 0.10956153f, 0.00807320f, -0.09814189f, 
    -0.17813434f, 0.16294217f, 0.05427583f, 0.01803606f, 0.01534073f, 0.26522255f, 0.04405321f, 0.08378311f, 
    0.10000931f, 0.08792603f, -0.06278569f, 0.05629539f, 0.01355799f, -0.04383419f, 0.08009202f, -0.22334445f, 
    -0.03643786f, -0.22483532f, 0.09667475f, 0.09814721f, -0.13672018f, 0.11042076f, 0.23458481f, -0.11299444f, 
    0.12974407f, 0.02248268f, 0.17288199f, 0.03480576f, 0.12228932f, -0.20570947f, -0.05593891f, -0.05500237f, 
    0.23983687f, 0.18024279f, -0.20396294f, -0.22864787f, 0.21697593f, -0.05781291f, 0.18994795f, 0.02825586f, 
    0.04478990f, 0.12498236f, -0.07213216f, -0.29057220f, -0.16740716f, 0.16806063f, 0.14801748f, -0.12382349f, 
    0.14338723f, -0.20870480f, -0.14507404f, 0.13343792f, -0.07945374f, 0.25382954f, 0.19248164f, -0.22534567f, 
    -0.19255294f, -0.20201936f, 0.04283456f, -0.13585281f, -0.09139981f, -0.04627618f, -0.06399428f, -0.39142516f, 
    0.14961541f, -0.04843048f, -0.05412675f, 0.17301306f, 0.17025450f, 0.17414285f, 0.10323197f, 0.03853178f, 
    -0.10440193f, 0.14540276f, -0.25338599f, -0.18672414f, 0.47238487f, 0.10571919f, -0.24950638f, -0.17947313f, 
    -0.16622771f, 0.13154535f, 0.03812777f, -0.02823479f, -0.04859483f, 0.08351105f, -0.13400055f, 0.03496310f, 
    -0.10505249f, -0.03586846f, -0.15537077f, -0.06773403f, -0.33059916f, 0.04293218f, -0.10664956f, -0.08888610f, 
    -0.11880413f, -0.12806021f, 0.03608356f, 0.14548531f, -0.02721441f, -0.34469059f, -0.20836696f, 0.33976561f, 
    -0.00519710f, -0.00509164f, 0.13067405f, -0.15878549f, 0.12975083f, -0.36551613f, -0.09621022f, 0.00797181f, 
    -0.12203398f, 0.09784812f, -0.25627959f, -0.07551988f, 0.07687577f, 0.11045223f, 0.12415956f, -0.01778225f, 
    -0.22693338f, -0.39907560f, 0.07492921f, -0.04203358f, 0.19317126f, -0.01322208f, 0.48008594f, 0.19438422f, 
    -0.05308253f, 0.08071481f, 0.16389650f, -0.02406076f, 0.11134591f, 0.05530507f, 0.06977803f, -0.13828006f, 
    -0.00559703f, 0.08795182f, -0.11814234f, 0.48253927f, 0.04061014f, 0.06055990f, 0.01296215f, 0.03512660f, 
    0.15390003f, -0.10551000f, -0.06806327f, -0.18832935f, 0.02037401f, -0.03133044f, 0.10119970f, 0.24508426f, 
    0.18909517f, -0.01221667f, -0.04627556f, 0.04436466f, -0.06043682f, 0.22687340f, -0.10166049f, 0.12397630f, 
    -0.04973914f, -0.24004474f, 0.14868122f, 0.32585368f, -0.05495092f, 0.08459622f, -0.29635927f, -0.19139785f, 
    0.14874145f, 0.07321917f, -0.00313152f, 0.15120721f, 0.06226982f, 0.05973284f, -0.34983835f, 0.30284709f, 
    -0.01122629f, 0.06221720f, 0.01374576f, 0.20924187f, 0.04204164f, -0.04168573f, 0.13479826f, -0.06610432f, 
    -0.04447234f, -0.07577054f, 0.35787630f, 0.08889425f, 0.16649801f, 0.04297726f, -0.11888451f, -0.03785195f, 
    0.17213562f, -0.31862426f, 0.06916729f, 0.05346255f, -0.07563638f, 0.15869512f, -0.12963486f, 0.10069480f, 
    -0.02744929f, -0.26245055f, -0.08374969f, 0.16570289f, -0.17699541f, 0.26969522f, 0.19182421f, 0.12840708f, 
    -0.00718406f, -0.01023427f, -0.17821679f, -0.72479892f, -0.25061098f, -0.12122921f, 0.23059016f, 0.08915941f, 
    0.24030542f, -0.01363632f, -0.02948146f, -0.27711657f, -0.11928320f, 0.04895698f, 0.24549161f, 0.11945150f, 
    0.08516643f, 0.05763227f, 0.10814328f, 0.11606245f, 0.23217984f, -0.33975309f, -0.19517955f, -0.15841253f, 
    0.00295377f, 0.00335567f, 0.12806518f, -0.03253375f, 0.01295137f, -0.21368261f, -0.03734282f, -0.07708371f, 
    -0.09178197f, -0.21681096f, 0.07583337f, -0.15596481f, 0.14484261f, -0.12245610f, 0.08936442f, -0.21205220f, 
    0.17861448f, 0.17207217f, -0.03568731f, -0.02196463f, 0.08129779f, -0.05686098f, 0.00379503f, -0.00689310f, 
    -0.04233766f, 0.08239878f, 0.16968521f, 0.10573472f, 0.30219647f, -0.09412628f, 0.11001243f, -0.13617969f, 
    0.00868185f, 0.00237175f, -0.06005892f, 0.04258242f, -0.06203634f, -0.10382876f, -0.26570255f, 0.08908611f, 
    0.22214313f, 0.02586938f, 0.40105462f, -0.03890587f, 0.12068219f, -0.20517854f, -0.06290260f, -0.05774852f, 
    0.06128214f, 0.02267044f, -0.02472855f, -0.11712771f, 0.26125151f, 0.20272972f, -0.08742286f, -0.17311922f, 
    0.12800322f, -0.10788921f, 0.12875046f, 0.21025530f, 0.39720154f, 0.18099122f, -0.32878214f, 0.09182728f, 
    -0.07636449f, 0.15810061f, -0.11703925f, 0.02154449f, -0.11031072f, -0.00895939f, -0.25717199f, 0.17357941f, 
    0.15708791f, 0.14927897f, -0.02059803f, 0.08002856f, -0.09170181f, 0.30269513f, -0.36668819f, 0.02130926f, 
    0.02631478f, 0.09527067f, 0.25983632f, 0.34766003f, -0.11789042f, 0.06754470f, 0.16910429f, -0.14143963f, 
    0.01689213f, 0.28268218f, -0.01925238f, -0.04598098f, -0.08308557f, -0.02661856f, -0.02694866f, -0.09252776f, 
    -0.07666582f, -0.31857878f, -0.03916827f, -0.24166781f, -0.05270479f, 0.04232384f, 0.13585499f, 0.09419604f, 
    -0.10593009f, -0.01649252f, -0.02260111f, -0.05357439f, 0.20734856f, 0.11414561f, 0.12698066f, -0.06988309f, 
    -0.26771030f, -0.11384770f, 0.24403039f, 0.39845479f, 0.28574637f, 0.12624140f, -0.08864472f, -0.09501743f, 
    0.27923363f, 0.03246564f, 0.34567091f, -0.27031702f, -0.43190756f, 0.20459089f, 0.11198688f, 0.00564177f, 
    -0.26744989f, 0.03078762f, 0.08515724f, -0.05271100f, 0.13127628f, -0.17318943f, 0.05783641f, -0.19041552f, 
    0.05468360f, 0.14092506f, 0.28931814f, 0.34116402f, 0.04154180f, -0.13406101f, -0.16400225f, -0.09441864f, 
    0.12442483f, -0.03453597f, 0.29571104f, -0.17729287f, 0.08282556f, 0.10729400f, -0.02666957f, -0.03170490f, 
    -0.04350152f, 0.12071550f, 0.13250905f, 0.22965845f, -0.08036956f, -0.22984324f, -0.05283240f, -0.04346610f, 
    0.21287945f, -0.20550366f, -0.06705159f, -0.08459611f, -0.07857555f, 0.01894591f, 0.04807901f, 0.07080012f, 
    -0.68552470f, 0.06617764f, 0.01403592f, 0.11777902f, 0.00925036f, 0.17322838f, 0.25856313f, 0.19290851f, 
    0.12614624f, -0.42041469f, 0.01041395f, -0.15264152f, 0.05424559f, -0.19949281f, 0.11065414f, 0.28232312f, 
    -0.02828122f, -0.13977298f, 0.56652278f, 0.24051869f, 0.17424344f, 0.08965752f, -0.07005948f, 0.04104649f, 
    0.06381329f, 0.17283753f, 0.19311073f, -0.54559600f, -0.04343490f, 0.13147572f, 0.16749156f, 0.07293358f, 
    -0.03676650f, 0.17617685f, 0.06074186f, 0.17695870f, 0.08996153f, 0.10713546f, -0.03332815f, 0.21079151f, 
    0.06990688f, 0.07946843f, 0.17102070f, 0.14759612f, -0.10539748f, -0.03346760f, -0.18940307f, -0.11582832f, 
    0.18106847f, -0.15104353f, 0.17761341f, 0.14059088f, 0.07762180f, 0.05062356f, -0.73979837f, -0.59270936f, 
    -0.21238236f, -0.05438211f, -0.07917796f, -0.09618317f, 0.14953858f, 0.01435772f, -0.08102489f, -0.28236717f, 
    -0.15417533f, -0.17086659f, 0.07754082f, 0.03916119f, -0.09906506f, 0.19810840f, 0.03314682f, 0.02070440f, 
    0.22600321f, -0.04751074f, -0.12626173f, 0.02214561f, -0.01600441f, -0.09727461f, -0.09184470f, 0.00022465f, 
    -0.03713408f, 0.16424574f, -0.09150545f, 0.10019446f, 0.05024711f, -0.22564116f, 0.07476176f, 0.03679812f, 
    0.22461087f, -0.00966808f, -0.29025429f, -0.03659117f, -0.01275298f, 0.15035340f, 0.20582509f, 0.04381323f, 
    -0.08250473f, -0.12791018f, -0.12327183f, -0.08190005f, -0.08625953f, 0.20200102f, 0.07176966f, 0.15009743f, 
    0.05744655f, 0.10524914f, -0.01045433f, -0.02707245f, 0.06335416f, -0.26176107f, -0.19880208f, -0.13389425f, 
    -0.00922338f, 0.01824350f, -0.11044864f, 0.02682055f, 0.02844755f, -0.13799903f, 0.05356130f, -0.10027752f, 
    0.21535999f, 0.05812292f, 0.19168860f, 0.00202653f, 0.02531232f, -0.03844760f, 0.37611502f, 0.34457624f, 
    -0.15216592f, 0.14018762f, -0.10637736f, 0.22236571f, 0.07231742f, 0.07520570f, -0.01601817f, -0.09533530f, 
    -0.08459480f, -0.06881242f, 0.00154080f, 0.20168930f, 0.17276527f, -0.09618794f, -0.03470534f, 0.03155413f, 
    0.15848581f, -0.15953703f, -0.16544972f, -0.12766752f, -0.06044693f, 0.05826325f, -0.07525005f, 0.06469474f, 
    0.17715846f, 0.33721808f, -0.19369493f, 0.21147509f, -0.25050420f, -0.21827173f, 0.16678032f, 0.08049836f, 
    0.04068787f, 0.04040778f, 0.08875325f, -0.14008003f, 0.14056051f, 0.10809484f, 0.05168214f, -0.23256072f, 
    -0.05051104f, -0.03453389f, 0.06432667f, 0.02783377f, -0.03293210f, -0.16278645f, 0.01875031f, 0.02193619f, 
    0.01482074f, 0.18596821f, 0.00118503f, 0.07488864f, -0.88425052f, -0.14868332f, -0.02949829f, 0.22985320f, 
    0.04013581f, -0.00246268f, -0.00240133f, 0.00900551f, 0.02855850f, 0.05172173f, -0.19528347f, -0.03630017f, 
    -0.00412611f, 0.03511113f, 0.19043535f, 0.22708599f, 0.03142271f, 0.28697270f, 0.07738093f, -0.20135237f, 
    -0.14578351f, 0.02692266f, 0.13545555f, -0.02594809f, -0.04170215f, 0.14861611f, -0.00913499f, 0.07804283f, 
    -0.04332031f, -0.24710743f, 0.06236688f, -0.22628151f, -0.09059263f, 0.23479833f, 0.30886161f, -0.10139035f, 
    -0.00569801f, -0.00093802f, -0.05341464f, -0.06611577f, 0.03006896f, -0.02070247f, -0.00133484f, -0.01288247f, 
    0.02521554f, 0.05770160f, -0.00111589f, -0.03254813f, 0.01950846f, 0.01426363f, -0.06558852f, 0.02329956f, 
    -0.00751106f, -0.04702297f, 0.00612665f, -0.05056959f, -0.03925578f, -0.05734375f, 0.03578234f, -0.02500149f, 
    -0.06599842f, -0.00518093f, 0.00204118f, 0.04923172f, -0.01230028f, -0.02902635f, -0.02837929f, -0.03392898f, 
    0.03098618f, 0.04260674f, -0.00431924f, 0.02380800f, -0.01210057f, 0.01611663f, -0.01664482f, 0.01653080f, 
    -0.05553753f, -0.00322200f, -0.02551754f, -0.01641817f, -0.05584133f, -0.02672558f, 0.02542575f, 0.03028284f, 
    0.01184474f, -0.01608771f, 0.01430735f, 0.02708378f, -0.04152405f, 0.02971119f, 0.03879316f, 0.00188650f, 
    -0.06343785f, 0.03035796f, 0.00186026f, 0.04230627f, -0.01196836f, -0.01571988f, -0.02804560f, -0.04769611f, 
    0.01141669f, -0.02997090f, -0.03540137f, -0.05813076f, 0.04644108f, -0.03646030f, -0.01217580f, 0.04824195f, 
    -0.02799361f, -0.03703406f, 0.01910001f, 0.01609435f, 0.00826033f, -0.00689537f, -0.00995278f, 0.01531670f, 
    -0.02538845f, 0.04771047f, -0.04336229f, -0.05036122f, -0.04782267f, -0.06737927f, 0.04144189f, -0.03811926f, 
    -0.00933013f, -0.04198049f, 0.03382241f, 0.04922768f, 0.04572143f, -0.00383743f, -0.03813789f, -0.03516399f, 
    -0.04517392f, 0.03599710f, 0.01592719f, 0.04502867f, 0.01972708f, -0.02896005f, -0.02329975f, 0.03011391f, 
    0.00892435f, -0.00306992f, -0.04433816f, -0.01830980f, -0.03945392f, -0.02751451f, 0.01583290f, 0.03162654f, 
    0.01467740f, -0.03379765f, -0.00589761f, -0.02529839f, 0.01925946f, -0.05052108f, -0.03671260f, -0.02825253f, 
    0.00064430f, 0.04395057f, 0.04230586f, 0.03312437f, -0.02435308f, 0.00014009f, 0.06141970f, -0.00825252f, 
    -0.02132786f, 0.02750695f, -0.00340357f, -0.04244637f, -0.02209871f, -0.05204996f, -0.01849579f, 0.01197214f, 
    -0.01834866f, -0.04703837f, -0.00645977f, 0.00533299f, -0.04238313f, 0.02566446f, -0.02423141f, -0.03531200f, 
    -0.05241119f, 0.02331191f, -0.03369672f, -0.03272690f, 0.01344317f, -0.02794729f, -0.02637259f, -0.00080260f, 
    0.00123586f, 0.03151216f, 0.02726860f, 0.03997847f, -0.02861948f, -0.03337849f, -0.06145925f, 0.00615509f, 
    -0.03960630f, -0.03097776f, -0.04994180f, 0.04063255f, 0.02365926f, -0.03833207f, 0.05831880f, 0.03042751f, 
    0.00343476f, 0.03046341f, -0.03027894f, 0.05644102f, -0.00676538f, 0.00096914f, -0.00065714f, -0.00812936f, 
    0.03087187f, 0.02885228f, 0.00024346f, 0.05498799f, 0.04632738f, -0.06234463f, 0.04308958f, 0.00173727f, 
    0.04712712f, 0.04827028f, -0.02469569f, -0.03277427f, -0.01422289f, 0.01017834f, 0.01456121f, -0.03448440f, 
    -0.00579573f, -0.04805442f, -0.05507562f, 0.00325428f, -0.05013691f, 0.05016897f, -0.02207538f, -0.00398970f, 
    -0.04677670f, 0.02835097f, -0.03059298f, -0.00161167f, -0.02098490f, -0.03504574f, -0.01170724f, -0.05279897f, 
    -0.05838994f, -0.06362812f, -0.01155651f, 0.00935964f, -0.00351946f, -0.00370297f, 0.01330068f, 0.02915453f, 
    0.01401898f, -0.00792040f, -0.00412231f, 0.03469584f, 0.03091203f, -0.00041090f, 0.00130123f, -0.01902647f, 
    -0.04031588f, -0.04834820f, -0.04162138f, 0.04738802f, -0.04692867f, 0.03286980f, -0.05460024f, 0.00887162f, 
    -0.02027987f, -0.05734305f, 0.01105362f, 0.03228989f, 0.00864050f, 0.03630558f, -0.01362515f, -0.03243414f, 
    0.01143578f, -0.05099252f, 0.00041732f, 0.04803994f, -0.02081687f, 0.02046898f, 0.01082255f, 0.00443863f, 
    0.02128190f, -0.00949757f, -0.04223031f, 0.01041224f, -0.03064689f, -0.04160441f, -0.05702729f, -0.04827064f, 
    -0.00852621f, 0.04649847f, -0.03833483f, 0.03441710f, -0.04148700f, -0.01458315f, -0.06343821f, -0.05441115f, 
    -0.01007271f, -0.00439479f, -0.06597359f, 0.00427029f, -0.05234541f, -0.03515144f, 0.04518625f, 0.03912404f, 
    -0.06399453f, 0.04220980f, 0.01921155f, 0.00696364f, 0.02500853f, 0.02315036f, -0.04968379f, -0.04912627f, 
    0.03514897f, 0.00203600f, -0.00909957f, 0.01292061f, 0.01553066f, -0.03352498f, -0.01131468f, -0.04696560f, 
    0.06438877f, 0.32467639f, -0.00466197f, 0.02257548f, 0.16140389f, 0.11656021f, -0.02939929f, -0.05307911f, 
    0.02222784f, -0.48983094f, 0.23383208f, 0.22960348f, -0.03724311f, 0.16878285f, -0.05740603f, 0.12970288f, 
    -0.28461835f, -0.05750896f, 0.32191369f, -0.11826950f, 0.24220839f, -0.18251611f, -0.09671031f, -0.00931944f, 
    -0.06350746f, 0.02055223f, 0.21427947f, 0.07387823f, -0.23952332f, 0.56098390f, 0.10959481f, -0.13070336f, 
    -0.10082190f, 0.07132596f, -0.03122907f, 0.03143404f, -0.06059775f, -0.04989650f, -0.05125323f, 0.11658738f, 
    0.07441065f, 0.00627205f, -0.12924071f, -0.02707659f, 0.08590633f, -0.59195280f, -0.04321663f, -0.36595416f, 
    0.03003508f, 0.03519678f, -0.03867675f, 0.07440628f, -0.13476299f, 0.07780434f, -0.80620027f, -0.27025813f, 
    0.31469801f, -0.03838194f, 0.08107737f, 0.02140331f, 0.10370682f, -0.06395992f, -0.01784605f, -0.07555183f, 
    0.16219260f, -0.08467367f, -0.07924568f, 0.30422688f, -0.00281496f, 0.00418630f, 0.10334045f, 0.10928851f, 
    0.15197167f, 0.04774908f, 0.21691538f, 0.13796411f, -0.01246057f, 0.03156054f, -0.00237221f, 0.03323678f, 
    0.04584446f, -0.22641958f, -0.32209450f, -0.11972329f, -0.15053716f, 0.05076160f, -0.13921240f, -0.05356643f, 
    0.01751501f, 0.05264126f, 0.44158447f, -0.08829566f, 0.01674777f, -0.00789101f, 0.06885995f, 0.07136016f, 
    -0.01159185f, 0.11293509f, 0.18388940f, 0.42473915f, 0.25939602f, 0.09172582f, 0.05547360f, 0.09467904f, 
    -0.00325114f, -0.03803279f, 0.16769727f, -0.07265031f, -0.91871339f, -0.09180397f, 0.32141212f, -0.12315615f, 
    -0.16783614f, -0.01479611f, 0.02647754f, -0.15475021f, -0.01881945f, -0.12728158f, -0.00641148f, -0.25353989f, 
    0.00778780f, 0.00955416f, -0.02489580f, 0.04311017f, 0.12856834f, -0.07275173f, 0.29511377f, 0.15117322f, 
    0.12662993f, -0.00203217f, 0.16427281f, 0.09028463f, 0.04871748f, 0.16938399f, 0.00278900f, 0.35483491f, 
    0.06315619f, 0.00674343f, 0.14984366f, -0.03568527f, 0.12842968f, 0.22430199f, 0.01360557f, 0.09046023f, 
    -0.09680457f, -0.20291616f, -0.13691092f, -0.17075481f, -0.01434582f, -0.08373047f, -0.09971660f, 0.02981960f, 
    -0.05865075f, -0.20364924f, 0.15694863f, -0.01038244f, 0.02622496f, -0.18680891f, -0.18958169f, -0.02628264f, 
    0.04358612f, -0.01118102f, 0.30753461f, 0.13930245f, 0.15279453f, 0.00017779f, 0.21047056f, 0.13731933f, 
    0.03189557f, 0.12853189f, 0.00894024f, 0.43375641f, 0.13174243f, 0.22565007f, -0.05558811f, 0.10064005f, 
    0.07932552f, -0.12785079f, -0.00714100f, 0.14413515f, 0.09632047f, 0.03576211f, -0.34169668f, -0.13095964f, 
    0.01756129f, -0.06227795f, -0.01730675f, 0.16340849f, -0.12634781f, -0.28272796f, -0.09781054f, -0.27761534f, 
    -0.15838373f, 0.02351628f, -0.00109992f, -0.07397986f, -0.04745008f, 0.07656007f, -0.06448300f, -0.12140897f, 
    -0.21382740f, 0.03700564f, 0.10692965f, -0.11205050f, 0.10746331f, -0.13632055f, 0.01374112f, -0.29313931f, 
    0.06376441f, 0.01314189f, -0.01240410f, 0.02724333f, -0.09397329f, -0.00312820f, 0.14250258f, 0.13941243f, 
    -0.05450875f, -0.06906670f, -0.36360800f, 0.01279459f, 0.03146676f, 0.01985526f, -0.14341964f, 0.12703972f, 
    -0.03524530f, -0.16203322f, -0.06109592f, -0.37871936f, 0.06218076f, -0.07342912f, 0.01048734f, 0.03376367f, 
    -0.25938651f, 0.11655524f, 0.39943236f, 0.40786999f, -0.06978897f, 0.20675859f, 0.22786209f, 0.16242450f, 
    0.12448548f, -0.12255872f, -0.02729111f, 0.00220797f, -0.23172674f, -0.34178424f, -0.02378825f, 0.13902156f, 
    0.16053009f, -0.03616695f, -0.15507881f, -0.03384783f, 0.44620207f, 0.20321809f, 0.26691568f, 0.03518490f, 
    0.02578755f, 0.13959578f, 0.09885466f, 0.00073195f, -0.04547299f, -0.15688843f, -0.04087921f, -0.29849496f, 
    -0.00244735f, -0.04899101f, -0.07001965f, 0.07875517f, 0.09192829f, -0.00900488f, -0.41250771f, -0.20233802f, 
    -0.12406369f, -0.16327554f, -0.04065165f, -0.08623058f, -0.21885717f, 0.16666837f, -0.00452055f, -0.27641952f, 
    -0.13519773f, -0.17387527f, 0.01916154f, 0.07826520f, -0.04036958f, 0.01280929f, -0.00782679f, -0.09052832f, 
    0.01840584f, 0.02514793f, -0.03241637f, 0.04234453f, -0.05408603f, 0.00155285f, -0.05068321f, 0.01113517f, 
    -0.05226845f, 0.03694187f, -0.03347081f, 0.04346353f, 0.00608001f, 0.00056306f, -0.03947742f, 0.00040174f, 
    -0.00188752f, 0.03636891f, 0.00036750f, -0.04526810f, -0.02960947f, -0.06007811f, 0.02725984f, 0.05237327f, 
    0.02921868f, -0.06753593f, -0.02703415f, 0.00395690f, -0.02514376f, -0.03154704f, -0.06136409f, 0.01765895f, 
    -0.04389168f, 0.04347274f, -0.03703362f, 0.02827150f, -0.02304117f, -0.04026819f, -0.01848703f, -0.00499708f, 
    0.02305994f, -0.05540350f, -0.02239214f, 0.00989665f, 0.04850669f, -0.03872257f, -0.05985847f, -0.03729716f, 
    -0.06526074f, 0.00724510f, -0.06141063f, -0.02425484f, -0.04995183f, -0.06102056f, 0.00343766f, -0.00420926f, 
    -0.01141705f, -0.02411875f, -0.05274041f, -0.01796836f, -0.03153955f, -0.05468173f, -0.02002690f, 0.03136688f, 
    -0.01481003f, -0.01887008f, 0.00284613f, -0.05273331f, 0.02390706f, 0.02045028f, -0.04630506f, -0.00616452f, 
    -0.05462268f, 0.01238780f, -0.05705687f, 0.02169102f, -0.00293343f, -0.02139281f, -0.00010081f, -0.04264844f, 
    -0.04355622f, 0.01478683f, -0.00890769f, -0.00912027f, 0.00326825f, 0.02835745f, -0.00221092f, 0.00775290f, 
    -0.04974110f, 0.04304644f, -0.01233197f, 0.03006466f, -0.07033241f, -0.02534480f, -0.01879288f, -0.01903789f, 
    0.04439238f, -0.01267097f, 0.00590795f, 0.00334451f, -0.00828388f, -0.03807388f, 0.03868725f, -0.04118092f, 
    0.05214750f, -0.00354752f, 0.04709353f, -0.03401483f, -0.04583059f, 0.04145333f, -0.03723682f, -0.06337843f, 
    0.00431090f, -0.04491599f, 0.02489061f, -0.05469684f, -0.01533774f, -0.01522751f, -0.01453496f, -0.06762413f, 
    -0.05828940f, -0.01976107f, 0.00097225f, -0.00190068f, -0.05902528f, 0.04271078f, -0.03866230f, -0.05028244f, 
    0.02915609f, -0.02564511f, 0.03371095f, 0.03583067f, -0.06230592f, -0.02851685f, 0.02738352f, 0.02236854f, 
    0.02601674f, 0.01235631f, -0.01351682f, 0.04466179f, 0.02275889f, -0.05799221f, 0.01384610f, -0.05199796f, 
    -0.01680513f, -0.02341622f, 0.01296414f, -0.00328855f, 0.00809124f, -0.01627414f, 0.00082066f, -0.01910804f, 
    -0.03850344f, 0.05782550f, -0.00985483f, -0.02698460f, 0.02267907f, 0.02568436f, -0.04113282f, 0.03356795f, 
    -0.00554853f, 0.00519435f, 0.02417614f, -0.01193476f, -0.00843477f, 0.02200206f, -0.00904727f, -0.00351560f, 
    -0.04146072f, -0.01875951f, -0.01488444f, 0.06753761f, 0.02284724f, -0.00333726f, 0.04009985f, -0.00691031f, 
    -0.00533678f, 0.02479569f, -0.00905882f, 0.04529458f, 0.04688278f, 0.04843339f, 0.04049838f, -0.04581471f, 
    0.01703094f, 0.00106257f, -0.03993074f, -0.05616929f, -0.00374266f, 0.04537579f, 0.00870036f, -0.04534595f, 
    0.01345566f, 0.05512724f, 0.02095959f, -0.03387695f, 0.04580306f, 0.02696121f, 0.03208712f, -0.05506045f, 
    -0.01857010f, -0.03518777f, -0.06267155f, 0.02606882f, -0.00128494f, -0.04894175f, -0.05526795f, -0.01853105f, 
    -0.01034252f, -0.05180429f, 0.05500067f, 0.04196722f, -0.00800385f, -0.03898873f, 0.02528073f, -0.06791755f, 
    -0.05636643f, 0.02459726f, 0.01038744f, -0.00431194f, -0.04637882f, 0.00701432f, 0.01938500f, 0.03115427f, 
    -0.01635539f, 0.02107559f, 0.02053062f, -0.03494082f, -0.05943965f, 0.00732661f, -0.06128551f, -0.06486575f, 
    0.00783662f, 0.00835786f, -0.03856517f, 0.01514369f, 0.02994288f, 0.04218843f, -0.03779499f, -0.05369721f, 
    -0.03457852f, -0.02372117f, 0.02232713f, 0.04312145f, 0.02392468f, 0.00780466f, 0.05277836f, 0.02872904f, 
    -0.05384042f, 0.02813104f, -0.01524782f, 0.00720994f, -0.05632435f, -0.03349042f, -0.01632731f, -0.01597046f, 
    0.01021752f, 0.01090264f, -0.07043699f, 0.01824082f, -0.01695716f, 0.03103488f, -0.01364650f, -0.06022652f, 
    -0.01716811f, 0.02190734f, -0.05088406f, -0.01847950f, 0.00670624f, 0.02270903f, 0.01143248f, -0.04861930f, 
    0.04880335f, -0.02274803f, -0.01131714f, 0.04379971f, -0.04713235f, -0.02171228f, 0.03790564f, -0.03777215f, 
    -0.01674348f, 0.02141466f, 0.03628324f, -0.00874361f, 0.00922973f, 0.03063895f, 0.04031168f, -0.04359017f, 
    0.08228736f, 0.21699530f, 0.31904885f, -0.31003681f, -0.04182735f, -0.18239191f, 0.12946969f, 0.07641128f, 
    -0.17632638f, 0.37639275f, 0.01713177f, 0.12570983f, -0.25275105f, 0.15676321f, 0.03407196f, 0.01290045f, 
    -0.36941239f, -0.20298028f, 0.21906850f, 0.03943319f, -0.12258141f, 0.17633612f, 0.12712885f, -0.11393765f, 
    -0.08239503f, 0.02583451f, -0.01993803f, 0.04369720f, -0.09068525f, -0.23177920f, 0.04064739f, 0.06637979f, 
    0.09055032f, 0.11627014f, 0.17910513f, -0.00312502f, 0.23074095f, 0.21851510f, 0.17285864f, -0.08453286f, 
    0.07629305f, -0.24867937f, -0.07023308f, -0.07990522f, -0.00750283f, 0.02480670f, 0.14928336f, 0.26133084f, 
    -0.17378756f, -0.08481994f, -0.28053597f, 0.19635721f, -0.10260119f, -0.28524172f, 0.08370638f, -0.18332951f, 
    -0.00013013f, -0.25174424f, -0.03580356f, 0.10253200f, 0.19255066f, 0.10960128f, -0.48328000f, 0.15264121f, 
    0.04388898f, -0.06055155f, 0.12693730f, -0.10344736f, 0.24715672f, -0.11585177f, 0.06123311f, -0.10079796f, 
    0.05867379f, -0.08620071f, -0.09055599f, 0.04114760f, 0.14601782f, -0.15402013f, -0.00866026f, 0.14488286f, 
    0.11171711f, 0.05648086f, 0.27376246f, -0.05726502f, 0.14586417f, -0.04984940f, 0.35063747f, -0.04422357f, 
    -0.02719008f, -0.08946835f, -0.05233803f, 0.36421776f, 0.10038874f, 0.14565349f, 0.22823133f, -0.39326140f, 
    -0.16188988f, -0.04635185f, -0.08631348f, -0.55476052f, 0.46970505f, 0.05801810f, 0.16166493f, -0.09989608f, 
    0.16286105f, 0.07105269f, -0.09508051f, 0.11707573f, 0.25958964f, -0.04226421f, -0.00281531f, -0.02691389f, 
    -0.05738949f, 0.02640739f, 0.19474864f, 0.33011135f, -0.08272958f, -0.12618811f, -0.17086069f, 0.34143105f, 
    -0.09526327f, 0.02654294f, -0.01394256f, -0.09666188f, -0.24458674f, 0.21639915f, -0.49011466f, 0.16009751f, 
    0.04139571f, 0.18033086f, -0.00815940f, -0.21745500f, -0.05135184f, 0.11923886f, 0.07112424f, -0.51045990f, 
    0.16636787f, -0.02170826f, 0.00948441f, 0.27305752f, 0.15553202f, 0.09802163f, 0.14307906f, -0.13862096f, 
    0.06471409f, -0.02721734f, 0.04212863f, -0.11882197f, 0.10239898f, -0.04079282f, 0.20519225f, -0.06502411f, 
    0.01251788f, -0.03811858f, -0.09436523f, 0.03390531f, -0.12508303f, -0.37042275f, -0.00789306f, -0.07975147f, 
    0.01007388f, -0.04290862f, -0.53109181f, -0.10017829f, -0.21225272f, -0.16827340f, 0.25773862f, 0.26560467f, 
    0.20985213f, -0.03592366f, -0.06748971f, -0.35353854f, 0.02819576f, -0.01092233f, -0.14116612f, -0.14027449f, 
    0.11794815f, 0.05333325f, 0.02195871f, 0.02436629f, -0.18912758f, -0.08261639f, 0.19646552f, 0.01583214f, 
    0.02281710f, -0.07138734f, 0.02809356f, 0.00731749f, 0.06997953f, -0.12691666f, 0.07513262f, -0.09856725f, 
    0.00205772f, -0.07626554f, -0.07642867f, 0.10543920f, -0.09031180f, -0.22222658f, 0.08317721f, -0.07884727f, 
    -0.01622471f, 0.15810911f, 0.05503280f, 0.11744422f, -0.17241350f, 0.08989007f, 0.04078005f, -0.00524912f, 
    0.25778577f, -0.24310379f, -0.37050658f, 0.13766308f, 0.18650627f, 0.04115121f, -0.07274633f, -0.09865547f, 
    -0.15902111f, -0.20668450f, 0.03012434f, 0.11606524f, -0.06460805f, -0.02579932f, -0.04590680f, 0.07534344f, 
    -0.12950961f, 0.07458386f, 0.14156300f, 0.19223362f, -0.02085106f, -0.02783096f, -0.04838406f, -0.36312327f, 
    0.20600069f, 0.04526688f, -0.41395885f, 0.31219956f, 0.23614685f, 0.32841849f, 0.09494951f, -0.01163880f, 
    -0.02776971f, 0.00385131f, 0.15953206f, 0.02122022f, 0.04722957f, 0.27717173f, 0.01745616f, -0.00496522f, 
    -0.04198815f, 0.05179608f, -0.14517526f, 0.07691144f, -0.17092636f, 0.06514093f, -0.04041869f, -0.01022432f, 
    0.19095162f, 0.03507721f, 0.09556212f, 0.07333237f, 0.02629301f, 0.04792518f, -0.16399048f, 0.13822290f, 
    -0.04804591f, 0.11490888f, 0.03359784f, 0.00024817f, 0.03432297f, 0.11363562f, 0.13595431f, -0.01625891f, 
    -0.05159968f, -0.02831960f, -0.12414630f, -0.00611083f, 0.14917296f, 0.01858192f, -0.26750830f, 0.04992253f, 
    -0.11435445f, 0.12842859f, -0.06356449f, -0.08637761f, -0.04688635f, 0.01364022f, -0.09698995f, -0.08692196f, 
    0.35781160f, -0.05886977f, 0.19334650f, 0.02590186f, 0.03876838f, 0.03965079f, -0.14261575f, 0.05331032f, 
    0.00121173f, 0.10742038f, 0.28121847f, 0.20751576f, 0.04288892f, 0.13754423f, -0.02751466f, -0.10384156f, 
    -0.08163843f, 0.33270219f, 0.20964296f, -0.04802122f, 0.18214841f, 0.13399090f, 0.08210780f, -0.04954420f, 
    -0.10314520f, -0.10162598f, 0.13825269f, 0.63692576f, -0.32547876f, -0.19812647f, -0.00544512f, 0.10322965f, 
    -0.05279353f, -0.12333886f, -0.01899674f, 0.00062567f, 0.53588533f, -0.03862501f, -0.01607495f, -0.06502243f, 
    0.17133188f, -0.17294273f, 0.20199974f, -0.03644899f, -0.04272963f, 0.54509830f, 0.03279686f, -0.29157639f, 
    -0.04171649f, 0.05661444f, -0.14106254f, 0.08408996f, 0.08831395f, 0.05952657f, 0.22962348f, -0.27264249f, 
    -0.16223338f, -0.10770150f, -0.02726412f, -0.02919300f, -0.08629779f, -0.10501548f, 0.11285946f, 0.77342170f, 
    -0.03939916f, -0.32766277f, -0.11823662f, 0.04306889f, -0.08848467f, 0.00937239f, 0.16959926f, -0.00044024f, 
    -0.01513061f, -0.60851449f, 0.06410245f, 0.09850390f, 0.03703377f, 0.09866131f, -0.14706200f, 0.13710345f, 
    -0.08589553f, -0.05341601f, 0.18583006f, 0.20063546f, 0.15111908f, -0.18999311f, 0.25245759f, -0.18214113f, 
    -0.08853942f, 0.09298286f, 0.10734377f, -0.06496368f, -0.08765958f, 0.28849539f, 0.05202542f, -0.05755379f, 
    0.01881766f, -0.10044227f, 0.04330860f, -0.58966684f, -0.70927173f, 0.02169300f, 0.00453532f, 0.07169321f, 
    0.00574630f, 0.04343536f, -0.04908673f, -0.12624091f, -0.13213533f, 0.13033928f, 0.11220761f, -0.06895994f, 
    0.06031607f, -0.25917068f, -0.06293941f, 0.10753282f, -0.09001831f, -0.01786253f, 0.05377759f, 0.04576596f, 
    -0.12238085f, -0.11773396f, -0.14961286f, -0.14565778f, 0.02287829f, 0.08907147f, -0.42041856f, -0.39477751f, 
    -0.03612254f, -0.07997940f, 0.05923867f, 0.12655666f, -0.19227821f, 0.05069314f, 0.00509854f, -0.66951138f, 
    -0.61660916f, 0.08003907f, -0.08107426f, 0.16139863f, 0.09397294f, -0.01965274f, -0.12397140f, -0.19459754f, 
    0.08446074f, 0.14918278f, -0.10207996f, -0.00461809f, 0.01382549f, 0.00754315f, 0.07112244f, 0.13976258f, 
    0.03331655f, 0.29960465f, -0.18039556f, 0.01095477f, -0.06749141f, -0.20010500f, -0.13057166f, 0.27521467f, 
    0.00712026f, 0.12956984f, -0.73283362f, -0.05123489f, -0.02957908f, 0.01820447f, 0.13222100f, 0.15002733f, 
    -0.00676511f, 0.05492369f, -0.01768676f, -0.34698144f, 0.16529699f, -0.03731693f, -0.14290795f, 0.02584941f, 
    0.08439413f, 0.08690339f, 0.03300640f, -0.10770583f, -0.03739661f, 0.09912455f, -0.06102157f, -0.14391774f, 
    0.14681838f, 0.00624223f, 0.03322032f, 0.00351837f, -0.04334602f, -0.16325878f, -0.17123747f, -0.30847216f, 
    0.07589012f, 0.05374072f, -0.07921940f, 0.03046589f, 0.21839163f, 0.10466775f, -0.20721485f, 0.20410970f, 
    -0.19446544f, -0.12647350f, 0.06096704f, -0.04415572f, -0.08622099f, -0.02553203f, -0.04898694f, -0.03079676f, 
    -0.11524608f, 0.23411050f, -0.13535911f, -0.25889069f, 0.01093651f, -0.04896718f, -0.11922006f, 0.12176314f, 
    0.04571664f, 0.08103900f, 0.00105275f, -0.15104954f, 0.04446626f, 0.08695658f, 0.10840948f, -0.01646994f, 
    0.01448724f, 0.21398877f, 0.52932298f, -0.32940024f, -0.19223347f, -0.06837617f, -0.04470675f, 0.05969363f, 
    0.01817814f, 0.07540748f, -0.21240650f, -0.57935071f, 0.14839615f, 0.16460595f, 0.25946462f, 0.15167180f, 
    0.13943501f, 0.09295820f, -0.05239534f, -0.04275552f, 0.20137028f, 0.24238710f, 0.08493022f, 0.00397432f, 
    0.10832953f, 0.02225659f, 0.07152668f, -0.07862390f, -0.61091113f, -0.69495195f, -0.16300942f, 0.12099385f, 
    0.15781707f, 0.05387948f, -0.01623082f, 0.03738432f, 0.10271594f, -0.08002318f, 0.22784995f, 0.03273717f, 
    -0.21009499f, -0.02960190f, 0.09793895f, 0.09567850f, -0.03639701f, -0.06062663f, -0.18064597f, 0.20894055f, 
    0.19158889f, -0.07093165f, -0.17253949f, 0.02267571f, 0.21992892f, 0.10137013f, 0.27110937f, -0.08319741f, 
    0.22823194f, -0.11111347f, 0.00978662f, -0.23888373f, -0.00158395f, 0.02717861f, 0.08005655f, -0.07438630f, 
    0.01627718f, -0.53603065f, -0.13116097f, -0.08571852f, 0.06439734f, -0.00270574f, 0.07731701f, -0.12363870f, 
    0.04704577f, 0.11068141f, 0.15757142f, -0.00932790f, 0.13070823f, -0.07814497f, 0.14127511f, -0.07256259f, 
    0.04151753f, -0.12146324f, 0.04567324f, 0.08182000f, 0.12389401f, -0.17071153f, -0.00477324f, 0.21397296f, 
    -0.00763240f, -0.02828908f, -0.01388808f, -0.26081499f, -0.04322015f, -0.12430035f, -0.12196694f, -0.34880891f, 
    0.01784323f, -0.41975030f, -0.25446528f, -0.22371876f, 0.06404071f, -0.38425830f, 0.20007046f, -0.24304157f, 
    -0.01106049f, -0.06140626f, 0.08230449f, 0.07876469f, 0.19030014f, -0.20285974f, -0.04604311f, -0.19330190f, 
    0.17426305f, 0.12403819f, 0.13410650f, 0.04319096f, -0.01659924f, 0.05286777f, -0.25560549f, -0.15374145f, 
    0.17206493f, -0.11490142f, 0.20405869f, -0.13856183f, -0.05115775f, 0.06640325f, -0.03503289f, -0.18415998f, 
    -0.10981829f, 0.05186201f, -0.17362371f, -0.06914885f, 0.08360671f, 0.16062941f, -0.07630116f, -0.18362819f, 
    -0.15469754f, -0.07258669f, 0.18462344f, 0.05378757f, 0.18607680f, -0.05993940f, -0.04284662f, -0.12446017f, 
    -0.10391761f, -0.25618747f, 0.48718596f, 0.05385755f, 0.12744659f, -0.18666743f, -0.13272716f, 0.10580968f, 
    -0.04000980f, -0.01439335f, 0.08812883f, -0.06396079f, 0.24942133f, -0.31818929f, -0.15249966f, -0.00425221f, 
    -0.14870198f, 0.20120153f, 0.31130224f, -0.42583331f, 0.07662304f, -0.00000549f, 0.03215040f, 0.19435236f, 
    0.08556997f, 0.03656281f, 0.06173708f, 0.05324075f, 0.12870713f, 0.11718856f, -0.00090224f, 0.13051832f, 
    0.07713648f, -0.05225037f, 0.12575328f, 0.00081391f, 0.11085432f, -0.49785364f, 0.06665704f, -0.13535386f, 
    0.35683367f, 0.31143633f, 0.10397403f, 0.12940919f, 0.02553288f, 0.16523886f, -0.15697649f, 0.16820784f, 
    0.14083590f, -0.20177713f, -0.02283522f, 0.01088258f, -0.12229560f, -0.09420379f, 0.10285162f, -0.02367226f, 
    -0.22707690f, -0.07258109f, -0.27552605f, -0.18609190f, -0.12907992f, -0.27474082f, 0.05744503f, 0.01399675f, 
    -0.11200453f, 0.09142219f, -0.53233373f, 0.23113783f, 0.11158308f, 0.12281231f, 0.17611519f, 0.15972830f, 
    0.19108474f, -0.38051304f, -0.00054975f, -0.30273139f, 0.02669263f, 0.11305980f, 0.01897475f, 0.09868482f, 
    0.06695312f, 0.06775614f, 0.18861762f, 0.09580404f, 0.23232991f, -0.03209565f, 0.01704996f, -0.09371036f, 
    0.32632533f, 0.21017414f, 0.05785067f, 0.05655090f, 0.17881779f, -0.14857028f, 0.01945207f, -0.17059903f, 
    -0.01714420f, 0.22782592f, -0.04783440f, 0.11249984f, -0.12765028f, 0.34509772f, -0.14583637f, 0.19632037f, 
    -0.02977961f, -0.18569508f, 0.12294887f, 0.05814455f, -0.12916268f, 0.11093134f, 0.32872921f, -0.21057284f, 
    -0.27822348f, -0.17551832f, -0.11580332f, 0.09158596f, 0.25576496f, 0.13802800f, -0.41283095f, -0.24077575f, 
    0.07718151f, 0.14160919f, 0.00398358f, 0.01180194f, 0.19086337f, 0.10596298f, -0.27175519f, 0.07381008f, 
    0.23762700f, 0.00266863f, 0.03600065f, 0.18744349f, -0.06086486f, 0.17783424f, 0.10277831f, 0.13699672f, 
    -0.13689530f, 0.08925907f, -0.30747709f, 0.18951876f, 0.15211058f, -0.11074226f, 0.18590005f, 0.14207381f, 
    0.04243799f, -0.03861661f, 0.05900618f, 0.40077871f, -0.21906790f, -0.20284633f, -0.00476128f, 0.09132943f, 
    0.07203169f, 0.16058746f, -0.09963288f, -0.11077090f, 0.17108364f, -0.26759812f, -0.14357360f, 0.04310041f, 
    -0.08416783f, 0.00959990f, 0.15736470f, -0.61552542f, 0.19588321f, 0.10080099f, 0.28578892f, 0.14080423f, 
    -0.03265348f, -0.02947121f, -0.07925109f, -0.16495648f, -0.18359944f, -0.07315899f, 0.27518901f, -0.01616552f, 
    0.11440650f, 0.03640288f, 0.16460410f, 0.07499947f, 0.04280853f, -0.08409641f, -0.02932819f, -0.09507495f, 
    0.11467195f, 0.10837290f, -0.00114612f, 0.10032645f, 0.13705963f, 0.21333390f, 0.43312764f, 0.36889929f, 
    -0.11724272f, 0.05487461f, 0.05326838f, 0.10704216f, 0.15360646f, 0.02219023f, 0.00905473f, -0.66454470f, 
    -0.05187416f, -0.40382034f, 0.14005427f, 0.04673380f, 0.12415449f, 0.02776303f, -0.00891000f, 0.05141092f, 
    -0.05679053f, 0.00759143f, 0.00585353f, 0.03359880f, -0.04697024f, -0.04879065f, 0.00289035f, 0.03996813f, 
    -0.02044784f, 0.04536523f, -0.03837721f, -0.00900689f, -0.06215376f, -0.01924132f, -0.04699240f, -0.05617610f, 
    -0.06329902f, 0.00218424f, -0.01795430f, 0.01639477f, 0.04180321f, -0.01551255f, 0.02265120f, 0.01829209f, 
    -0.00533955f, -0.03196436f, 0.04417557f, 0.03451362f, -0.01557143f, -0.05301027f, -0.02769308f, -0.04599665f, 
    -0.05453244f, -0.02107526f, 0.01720832f, 0.04036193f, 0.01847474f, 0.03560134f, -0.01848746f, -0.02720136f, 
    -0.06305557f, -0.03069101f, -0.04699219f, -0.04685074f, 0.01010700f, -0.05337866f, -0.03691622f, 0.03867031f, 
    0.01984102f, -0.04371975f, -0.05329186f, 0.01751354f, 0.01532253f, -0.04884648f, 0.00969146f, 0.02975357f, 
    -0.02102199f, -0.01275042f, -0.05922286f, -0.02170629f, 0.01039913f, 0.02688155f, -0.00463355f, -0.02138533f, 
    0.03997337f, 0.01999513f, 0.04565470f, -0.04531351f, -0.02967260f, 0.03967203f, -0.06531560f, -0.00959022f, 
    -0.03797333f, 0.02699929f, -0.02810138f, -0.06820171f, -0.02957200f, 0.03543525f, -0.05164017f, 0.04563800f, 
    -0.03257899f, 0.02980145f, 0.04039118f, -0.02822427f, 0.04454164f, 0.04042299f, 0.01819356f, 0.00450256f, 
    -0.06681107f, -0.06277525f, -0.00857814f, 0.00235186f, 0.03900455f, 0.00935380f, -0.05841681f, 0.01484418f, 
    0.03481008f, 0.00968273f, -0.01489141f, 0.04581359f, -0.00242567f, -0.02225321f, -0.00023910f, -0.03475377f, 
    0.00741504f, -0.06832598f, 0.00219788f, -0.01814472f, -0.02072652f, -0.01992567f, -0.06122834f, -0.06481582f, 
    -0.01414214f, -0.04850647f, 0.02805503f, -0.00336373f, -0.04609626f, 0.03400708f, 0.01633065f, -0.05586829f, 
    -0.05023174f, -0.02528679f, 0.04871287f, 0.00507765f, -0.03413690f, -0.06249348f, 0.01315766f, 0.03160011f, 
    0.00932550f, -0.05898841f, -0.00496491f, -0.00459467f, -0.04404128f, -0.03628930f, -0.02447907f, -0.00204968f, 
    -0.04750568f, 0.02875531f, 0.01611692f, 0.04565751f, 0.03213084f, -0.04719554f, 0.01210164f, -0.06204547f, 
    -0.01356261f, 0.03099605f, 0.02183802f, -0.04424723f, 0.01417815f, -0.06038493f, 0.04419497f, 0.03412143f, 
    -0.02661096f, -0.03224634f, -0.06341701f, -0.03293111f, 0.02005694f, -0.04335828f, 0.00371834f, -0.03648564f, 
    0.03766190f, 0.00471617f, 0.00599015f, 0.00686325f, 0.02478466f, -0.05993415f, -0.03308866f, -0.06348971f, 
    0.01512236f, -0.02168246f, 0.04017805f, -0.02457722f, -0.02229920f, 0.04046726f, 0.00998652f, -0.05215849f, 
    0.03200018f, -0.05681652f, -0.04813273f, -0.05480061f, 0.04618776f, -0.03014380f, -0.05522103f, 0.02781756f, 
    0.02003030f, 0.01172990f, 0.02929952f, -0.02408108f, -0.03411474f, -0.05370196f, 0.03828651f, 0.00740557f, 
    -0.04439330f, -0.00058913f, -0.06301901f, 0.02673398f, -0.06302247f, 0.04693205f, -0.00245614f, 0.03686040f, 
    0.04418515f, 0.02433426f, -0.05173211f, -0.04613398f, 0.01761693f, -0.01383211f, 0.01128702f, 0.00417820f, 
    -0.00883066f, -0.00219429f, -0.02146616f, -0.02418956f, -0.05446490f, 0.03867325f, -0.05684880f, -0.00121923f, 
    0.01907329f, 0.04430572f, 0.02518947f, 0.04562047f, 0.02429171f, -0.05277221f, 0.01587777f, -0.04640495f, 
    -0.00179449f, 0.01740565f, -0.04544372f, -0.02391636f, -0.06105324f, -0.05010144f, -0.01583712f, 0.03862314f, 
    0.03762904f, -0.00752226f, 0.02936330f, 0.01273853f, -0.03042032f, -0.01519893f, -0.01420064f, 0.01448621f, 
    -0.06303549f, 0.03398284f, -0.00079355f, 0.02730703f, -0.02300343f, 0.01313471f, 0.01563229f, 0.00646410f, 
    0.03294713f, 0.03419040f, -0.05335557f, -0.06236530f, -0.05759325f, 0.00719352f, -0.05141086f, -0.02756673f, 
    0.03541483f, -0.00722933f, -0.05486203f, 0.03428599f, -0.01903076f, 0.04893393f, -0.00470269f, 0.00208167f, 
    -0.04208958f, -0.03683991f, 0.05178496f, -0.06394702f, 0.01320990f, 0.03789087f, 0.02115540f, 0.03523320f, 
    -0.02580411f, 0.01257983f, -0.04550365f, 0.02167928f, -0.06092080f, 0.01317270f, 0.02144413f, -0.00749825f, 
    -0.04158099f, -0.03471295f, 0.03897779f, 0.00967718f, -0.04560215f, -0.01304217f, -0.02133447f, -0.04013027f, 
    0.04925297f, -0.00466312f, -0.03829195f, 0.03103446f, -0.04796280f, 0.19347844f, -0.11829662f, -0.02413715f, 
    0.05592642f, -0.01106627f, -0.45952961f, 0.26143008f, 0.11357453f, -0.02447091f, -0.12308650f, 0.04218025f, 
    0.08517803f, 0.10945274f, -0.14135870f, 0.09811022f, -0.32401615f, 0.07918260f, 0.06205809f, 0.24125028f, 
    0.02188875f, -0.03595211f, -0.02481027f, -0.44903484f, 0.21326467f, -0.39011502f, 0.03789782f, -0.14697550f, 
    0.11289757f, 0.03340436f, -0.10165820f, 0.16940762f, 0.13803282f, 0.02738822f, -0.09320888f, -0.05520325f, 
    0.13365343f, -0.17700307f, -0.02469866f, -0.17717391f, 0.11613815f, -0.12092892f, -0.47830290f, 0.19477636f, 
    -0.04251716f, 0.04384792f, -0.08833525f, -0.20630234f, -0.02337713f, 0.08463482f, 0.24875505f, 0.10008162f, 
    -0.22617400f, 0.02695084f, 0.20232303f, -0.03664302f, 0.03723291f, -0.11761020f, 0.17762737f, 0.31158888f, 
    0.21268523f, -0.19361730f, -0.13136622f, -0.02911628f, -0.26214787f, -0.05340049f, -0.01772604f, -0.07309210f, 
    0.22396213f, 0.03774533f, -0.32879916f, -0.12136794f, 0.05147974f, 0.05729864f, -0.01821415f, -0.03916188f, 
    0.17259599f, -0.19165024f, 0.02829255f, -0.31226158f, -0.10003070f, 0.13811739f, -0.20444418f, 0.14793713f, 
    -0.06729139f, -0.15263030f, -0.14325440f, 0.15514484f, -0.20015009f, 0.16045703f, 0.02755882f, -0.05452354f, 
    0.08842074f, 0.21184942f, 0.02574848f, -0.04781153f, 0.22532761f, 0.02684338f, 0.05120058f, -0.02747917f, 
    -0.16257319f, 0.14352810f, -0.06220399f, -0.10812585f, -0.21309783f, -0.35585147f, 0.31290108f, -0.02881258f, 
    0.03342367f, 0.25278312f, -0.15911964f, -0.00925267f, 0.10289977f, -0.07668144f, -0.22028297f, 0.31721362f, 
    0.18117519f, -0.07359372f, -0.08483754f, 0.07149018f, -0.11822425f, -0.00574670f, 0.30365101f, 0.05555678f, 
    -0.17465211f, -0.13780852f, 0.13448046f, -0.46742362f, -0.06845000f, 0.04705044f, -0.22939484f, -0.37921524f, 
    0.20168130f, 0.10903747f, 0.00626366f, -0.12565893f, -0.16480865f, -0.03958510f, 0.17655462f, -0.23388419f, 
    -0.30487394f, -0.30746314f, 0.55352628f, 0.00675020f, -0.02326866f, 0.10596404f, -0.05401907f, 0.03650457f, 
    0.02837749f, -0.02939923f, -0.13571683f, 0.04827069f, -0.01062889f, 0.00718607f, 0.04927881f, 0.01809520f, 
    0.12541242f, 0.01247440f, 0.12821352f, 0.22061493f, 0.02251855f, 0.04983110f, -0.07046091f, 0.13089009f, 
    -0.19352911f, 0.00816611f, 0.01668331f, 0.04428891f, 0.19780190f, 0.10600904f, 0.10587113f, 0.02879855f, 
    0.16851096f, 0.16128343f, -0.03334447f, 0.02770804f, -0.17737292f, -0.25976792f, 0.29121897f, 0.08108753f, 
    0.04878312f, 0.04695727f, 0.02081345f, 0.05608242f, 0.15877332f, 0.49892840f, -0.11088633f, 0.14405471f, 
    0.09298944f, 0.05728921f, 0.16003712f, -0.13262323f, 0.14919573f, 0.18066834f, -0.02178437f, 0.02399077f, 
    -0.06848127f, 0.15365064f, -0.01369161f, -0.07198694f, 0.14401785f, -0.09857891f, 0.10928445f, -0.11091533f, 
    0.08754530f, -0.07985901f, 0.13751821f, 0.21025489f, 0.09290919f, 0.00362839f, 0.12554720f, 0.01333848f, 
    -0.10029627f, -0.05469740f, 0.22463301f, -0.22170852f, 0.07564012f, -0.05345172f, 0.04913708f, 0.05611571f, 
    0.07559069f, 0.41500276f, -0.24626271f, -0.30299133f, 0.14039552f, 0.04821131f, -0.00551698f, -0.25734651f, 
    0.04382411f, -0.07822483f, -0.11947024f, 0.27981034f, -0.07422066f, 0.02304721f, -0.14680184f, -0.22458710f, 
    0.04351721f, 0.08288628f, -0.21830179f, -0.08262620f, -0.32357094f, 0.44994923f, 0.04236831f, 0.14717966f, 
    -0.09543309f, 0.00175872f, 0.01117559f, 0.08271814f, 0.21028863f, 0.17546438f, -0.15264434f, 0.01044142f, 
    0.11305100f, 0.03959236f, -0.11111504f, -0.07438503f, 0.07311156f, 0.11062372f, -0.12497339f, 0.09964815f, 
    -0.15309295f, 0.10977302f, -0.02670976f, 0.21881485f, 0.07849835f, 0.20772995f, -0.24207026f, -0.14332932f, 
    0.06454237f, 0.08246551f, -0.13715863f, -0.14160801f, 0.00371650f, 0.13876708f, 0.14544176f, -0.27019885f, 
    -0.23483333f, 0.15782210f, -0.09178086f, -0.01524196f, 0.04830913f, -0.08459884f, -0.05161778f, -0.10385054f, 
    0.23210303f, -0.21007301f, -0.05164642f, -0.27587932f, -0.03274428f, 0.12903704f, 0.12210638f, -0.03943255f, 
    -0.06753364f, 0.45477691f, -0.18023151f, 0.29578751f, -0.03141809f, -0.08204076f, 0.11372379f, 0.12300085f, 
    0.14503968f, -0.02374773f, -0.13928618f, -0.32857645f, -0.02534833f, -0.00326321f, -0.17214790f, 0.11330565f, 
    0.00665251f, -0.05285700f, 0.10851040f, -0.34043202f, 0.33949164f, 0.09586305f, -0.09858865f, -0.12473474f, 
    0.06529755f, -0.16286716f, -0.10220343f, 0.00411431f, 0.09677015f, -0.29166430f, 0.29367074f, -0.21690622f, 
    -0.12870845f, 0.07467003f, 0.00856297f, -0.04549383f, 0.00174040f, 0.44115177f, 0.15550411f, 0.14435467f, 
    0.17462561f, 0.02206375f, 0.14644529f, -0.07856599f, -0.10778994f, 0.06318228f, 0.20879170f, -0.31077904f, 
    0.02407378f, -0.10917101f, 0.24722995f, -0.00529734f, -0.15181699f, -0.05512625f, 0.11436916f, 0.45274898f, 
    -0.00868493f, 0.07057186f, -0.04415543f, -0.01527675f, 0.09209860f, 0.09058530f, -0.07002565f, -0.08166814f, 
    0.13594531f, -0.24769999f, -0.03910280f, -0.01436749f, 0.12340117f, -0.13980089f, -0.05677753f, -0.00941088f, 
    -0.11177096f, -0.26767126f, 0.02962794f, 0.14891036f, 0.05392637f, -0.18211421f, 0.06791585f, 0.01712759f, 
    0.00112334f, 0.09704553f, 0.05627846f, -0.44854462f, -0.11227847f, -0.50031769f, -0.17476065f, -0.04632839f, 
    -0.08397342f, 0.06726413f, 0.04170069f, -0.20633775f, -0.32786801f, 0.04213234f, -0.18559866f, -0.04460772f, 
    0.15318121f, 0.04611479f, -0.05577593f, 0.05619031f, -0.00287763f, -0.06312699f, 0.10491717f, -0.12391376f, 
    0.08947735f, -0.08877951f, 0.10563494f, 0.11237661f, -0.04143897f, 0.31986985f, 0.25128838f, 0.21017350f, 
    0.26442710f, 0.07036393f, 0.22703320f, 0.12061776f, -0.12389239f, -0.15957664f, 0.17436346f, -0.18189242f, 
    0.27302009f, -0.00816066f, 0.05017117f, -0.27608135f, 0.00328548f, -0.21134481f, 0.19400944f, -0.18425368f, 
    -0.15046735f, -0.03193401f, -0.32845601f, 0.00182118f, -0.12683976f, -0.06129989f, -0.03793751f, 0.01892968f, 
    0.03155230f, 0.18925492f, 0.04027950f, 0.22679925f, 0.01003340f, 0.09458209f, 0.05875175f, 0.17312679f, 
    0.09766216f, -0.06112949f, -0.19982733f, -0.12250359f, 0.02831159f, -0.10697346f, -0.32676163f, 0.10055044f, 
    0.15828601f, -0.26531091f, 0.33591455f, -0.01424968f, -0.07846376f, 0.10474794f, 0.05825525f, 0.02989620f, 
    0.25849390f, 0.15946798f, -0.09221074f, -0.34227374f, -0.12933508f, -0.01258181f, -0.06499895f, 0.05459045f, 
    -0.12086934f, -0.01260478f, 0.18241118f, 0.14984035f, 0.01346863f, 0.32830846f, -0.04346514f, 0.21993822f, 
    0.06304879f, -0.10762627f, -0.06065159f, 0.05574095f, 0.05477524f, -0.23061453f, -0.13586412f, 0.03126652f, 
    -0.20154271f, 0.07790779f, -0.01130741f, -0.07128911f, 0.06384303f, 0.03134881f, 0.00631683f, -0.09123196f, 
    0.08803844f, -0.09325802f, 0.04634640f, -0.01534543f, 0.09704698f, -0.09879126f, 0.01994637f, -0.07953846f, 
    -0.28810278f, 0.06859615f, -0.17343454f, -0.09036284f, -0.02115623f, -0.06207871f, 0.09002156f, 0.08591241f, 
    0.03127439f, -0.09006198f, -0.03515662f, 0.00916967f, 0.13528164f, -0.15434143f, 0.06974877f, 0.02742965f, 
    0.01212311f, 0.04770433f, -0.23693365f, -0.03614334f, -0.33451629f, -0.02731795f, -0.06775640f, 0.18584487f, 
    -0.11174786f, -0.14131542f, 0.00097300f, -0.20957720f, -0.23488721f, -0.27156657f, -0.16883376f, -0.02898659f, 
    0.06390573f, 0.18194027f, 0.05818984f, 0.12647991f, 0.25898781f, 0.05523155f, 0.16022949f, 0.04592979f, 
    -0.01209992f, -0.13022713f, 0.04269657f, -0.17737019f, 0.31671831f, 0.17539847f, -0.10627447f, -0.11220068f, 
    -0.05956867f, -0.01369370f, 0.08096719f, 0.14242016f, -0.26941371f, 0.19406828f, 0.19411175f, -0.02680666f, 
    0.22929277f, 0.06611694f, 0.02873676f, -0.11171471f, -0.18689157f, -0.00355537f, 0.37200433f, 0.27550855f, 
    0.15563944f, 0.16491598f, 0.17473464f, -0.20951566f, 0.13537447f, 0.03586011f, 0.22345990f, 0.25498948f, 
    0.09627879f, 0.14972058f, 0.14910455f, -0.06109345f, 0.03248437f, 0.07014648f, 0.15879905f, -0.13176264f, 
    -0.10584024f, 0.01437844f, -0.16805373f, 0.08561504f, 0.09892427f, 0.09091013f, -0.09127550f, -0.06027669f, 
    0.04869271f, -0.38176155f, 0.01843731f, -0.00281934f, 0.28122959f, 0.18801892f, -0.14428174f, -0.14233890f, 
    -0.32431266f, -0.04362996f, 0.29408580f, -0.06776288f, 0.06157220f, 0.05524993f, -0.07579102f, 0.24471712f, 
    -0.14886513f, 0.09630208f, 0.10548916f, -0.79632026f, 0.13907284f, 0.55577028f, -0.12029617f, -0.06196064f, 
    0.02239989f, 0.04507796f, 0.07979475f, -0.06588347f, -0.19772963f, 0.00362975f, -0.01424910f, 0.01942393f, 
    -0.15041728f, 0.03362248f, -0.13549972f, 0.23024581f, 0.19862752f, 0.72326821f, 0.10512337f, -0.14970651f, 
    0.07464673f, 0.15923636f, 0.09298252f, 0.02201904f, 0.03664428f, 0.17259769f, -0.18762028f, -0.20660795f, 
    0.09667690f, -0.06977534f, 0.10070977f, 0.08349493f, 0.00104391f, 0.18733495f, -0.05830470f, -0.67533559f, 
    0.17364234f, 0.32169366f, 0.04304749f, 0.15310214f, -0.06442892f, -0.14546572f, 0.26250309f, -0.08884867f, 
    0.13013242f, 0.12479136f, 0.24610408f, -0.02910558f, 0.10461088f, 0.12655291f, -0.04143790f, 0.07166509f, 
    -0.00715884f, 0.04442836f, -0.34291580f, 0.08694278f, 0.16163689f, -0.22076674f, -0.18458591f, 0.18421519f, 
    0.12986903f, -0.16281120f, 0.10471893f, -0.01993439f, -0.09493225f, 0.04844219f, -0.03406668f, 0.14841470f, 
    -0.22074364f, 0.15662065f, 0.04023404f, -0.11913396f, -0.10334188f, 0.01913326f, 0.17702141f, 0.01560512f, 
    -0.10971711f, -0.17166631f, 0.15733708f, 0.13074160f, 0.13859275f, -0.13725898f, 0.15176804f, 0.06097823f, 
    -0.19326255f, -0.01397239f, 0.10746844f, -0.09838659f, -0.04694076f, -0.50930697f, 0.10634892f, -0.26620713f, 
    0.05728740f, 0.07414057f, -0.12059205f, -0.20361125f, 0.29009724f, 0.00518523f, 0.22052848f, 0.18687747f, 
    -0.11943302f, -0.31015956f, -0.08734477f, -0.07925007f, -0.04509120f, 0.16130476f, 0.09621225f, 0.05150121f, 
    0.07789309f, 0.08541594f, -0.01709380f, -0.14599890f, 0.02863519f, 0.04535275f, 0.26957762f, -0.00452624f, 
    0.03011495f, -0.09600627f, -0.24394187f, 0.12084994f, 0.00721936f, -0.05543641f, 0.01793483f, -0.08157901f, 
    -0.08828450f, -0.02170766f, -0.11015052f, -0.06358918f, -0.12438323f, 0.03202756f, 0.04304565f, 0.14697185f, 
    0.03695109f, 0.03647065f, -0.14610852f, 0.16537592f, 0.13953254f, 0.17070575f, 0.32240528f, -0.18695813f, 
    -0.07083736f, 0.08044013f, -0.01450887f, -0.18977571f, -0.00360998f, -0.10082340f, -0.07994535f, 0.23847303f, 
    0.24176463f, -0.00589665f, 0.06932849f, 0.08366966f, 0.06417198f, 0.29031467f, -0.40216693f, -0.04883822f, 
    -0.00291556f, -0.19322282f, -0.04255744f, -0.11650177f, 0.02075257f, 0.43240842f, 0.05917316f, -0.02541116f, 
    0.02287261f, 0.02765463f, 0.07669362f, -0.06611953f, -0.07397278f, 0.22268417f, -0.15262309f, -0.21113561f, 
    -0.12575856f, 0.10854501f, 0.13931493f, 0.06826820f, 0.10892087f, 0.05016625f, -0.11143913f, 0.36221033f, 
    -0.21104087f, -0.01955573f, -0.09273700f, 0.06779478f, -0.07483451f, 0.05287182f, 0.07801158f, 0.00327548f, 
    0.13393593f, 0.23265995f, -0.33767977f, -0.18365464f, 0.05405115f, -0.00851799f, -0.13500080f, 0.04781239f, 
    0.09650285f, -0.05160053f, 0.12034065f, -0.04443442f, 0.11635499f, 0.04994845f, 0.06503487f, -0.14515266f, 
    0.11151400f, -0.12987113f, 0.27958581f, 0.18678924f, -0.04538099f, -0.03181076f, -0.03781231f, -0.13566110f, 
    -0.09368896f, 0.05226746f, 0.00630886f, -0.37408566f, -0.28340143f, -0.28011331f, 0.12909435f, -0.02215395f, 
    0.09706607f, 0.06167914f, -0.10125380f, -0.34941614f, -0.08954615f, -0.02651072f, 0.11913542f, -0.02210537f, 
    -0.04888090f, 0.00134509f, -0.06305966f, 0.02933343f, 0.03944514f, -0.26129830f, 0.05433764f, -0.20615794f, 
    0.18658485f, 0.01104048f, -0.14095846f, -0.05337068f, 0.35312742f, -0.17731494f, 0.28275388f, -0.12259144f, 
    -0.25126833f, 0.12455858f, 0.07152252f, -0.19864815f, 0.12155385f, -0.10235567f, -0.07692885f, -0.25542280f, 
    -0.48286089f, -0.33873892f, -0.00843290f, 0.01727031f, 0.37041241f, 0.00538418f, -0.06398043f, -0.01461035f, 
    -0.04807093f, 0.00232466f, 0.00807916f, -0.02545664f, 0.03349961f, -0.00248683f, -0.04767123f, 0.01970085f, 
    -0.05467402f, 0.03238508f, -0.05391207f, -0.02813380f, -0.01433712f, 0.03960184f, -0.03832886f, 0.04466113f, 
    0.01941719f, -0.01184384f, -0.05488518f, -0.06020681f, 0.03675691f, 0.04438972f, -0.03453907f, 0.00796732f, 
    -0.05719609f, 0.01217195f, -0.02716011f, -0.01733055f, 0.03953447f, 0.00635814f, -0.02746350f, 0.04218034f, 
    0.01795509f, -0.04568550f, -0.03263758f, -0.04004243f, -0.00525722f, 0.01805208f, 0.02760456f, -0.04836440f, 
    -0.05809925f, -0.02217342f, -0.00872461f, -0.00694384f, -0.01237559f, -0.01490023f, -0.03575115f, -0.05747896f, 
    -0.06978864f, 0.04969011f, 0.01999568f, 0.01666957f, -0.05184244f, -0.03222149f, -0.04316712f, 0.01727516f, 
    -0.02890922f, -0.03156829f, 0.01866435f, -0.03960000f, 0.03883262f, -0.00371256f, -0.01523913f, -0.00197549f, 
    0.00352123f, -0.03123030f, -0.01182048f, -0.01920831f, -0.02995562f, -0.03257386f, 0.04156598f, -0.05503232f, 
    -0.03298920f, -0.01967237f, -0.04455565f, 0.03711710f, -0.06741884f, -0.00827877f, 0.02006207f, -0.03835364f, 
    0.02510003f, 0.04437580f, -0.03682830f, -0.02086053f, -0.05996198f, 0.04139505f, 0.02770130f, -0.02599230f, 
    0.00531892f, -0.03578139f, 0.03086838f, 0.05167222f, -0.04207705f, -0.05703852f, 0.02543642f, 0.05387932f, 
    -0.00436432f, -0.00225832f, -0.00684507f, -0.01108503f, 0.04154639f, -0.06120116f, 0.03987486f, 0.03572799f, 
    0.01439924f, -0.05780141f, -0.05463063f, -0.03493899f, 0.01515967f, 0.03199869f, -0.00490284f, -0.02902051f, 
    0.03082287f, -0.04539042f, 0.00874706f, -0.06463987f, 0.01105177f, -0.01644061f, 0.03045328f, -0.02105859f, 
    0.01159999f, 0.02949312f, -0.05474569f, -0.00894007f, 0.02170622f, 0.00127227f, -0.01074550f, -0.02312844f, 
    0.01112352f, 0.00302760f, 0.01342132f, -0.01549298f, 0.00476684f, 0.00945832f, 0.00045124f, -0.05388748f, 
    0.04909249f, -0.00291444f, -0.02870290f, -0.03351392f, -0.04918081f, 0.01315516f, 0.02110321f, -0.01811283f, 
    0.04977238f, -0.00564400f, 0.04123167f, 0.00827886f, -0.05331470f, -0.00679112f, -0.04440698f, 0.00628946f, 
    -0.06244348f, -0.06444207f, -0.06520513f, 0.03659585f, -0.04647240f, -0.04307965f, 0.04098310f, -0.04838543f, 
    -0.00005293f, 0.00781531f, 0.04172892f, 0.02132837f, 0.01927352f, -0.05273158f, -0.01706319f, 0.01991157f, 
    -0.01452506f, -0.05775826f, -0.06956197f, -0.03870028f, -0.06647412f, -0.02518968f, 0.01288991f, -0.06654203f, 
    0.04058919f, -0.04725363f, 0.03495871f, -0.02190285f, -0.03924211f, 0.02304751f, 0.01715023f, -0.03265198f, 
    -0.03517102f, -0.01452701f, -0.05976370f, -0.01503639f, 0.00355661f, 0.03475672f, -0.00872283f, 0.01610790f, 
    -0.01002014f, -0.06072444f, 0.00167355f, 0.03876502f, -0.04298389f, 0.00315065f, -0.04109698f, -0.05481050f, 
    -0.00339889f, -0.00477228f, 0.00675009f, -0.04395246f, -0.00134177f, 0.05786306f, 0.01329605f, 0.02075271f, 
    -0.00374229f, 0.03021904f, 0.03438317f, 0.03071241f, -0.03472731f, 0.00915601f, -0.03082081f, -0.04643495f, 
    -0.01981634f, -0.04559211f, 0.04145994f, 0.02377001f, 0.03108786f, 0.01166169f, 0.02596677f, -0.06334902f, 
    0.03965942f, -0.04405592f, 0.04218205f, 0.01102612f, 0.00484529f, -0.02755282f, -0.03631441f, -0.00456906f, 
    -0.05882401f, -0.00771868f, 0.05184387f, 0.03098353f, 0.04709642f, 0.03588283f, -0.03586905f, -0.03442777f, 
    -0.02116522f, -0.04923438f, -0.03666515f, 0.04919128f, 0.01938086f, -0.02718550f, 0.04382965f, -0.01674223f, 
    0.02477209f, -0.01086512f, -0.05006649f, -0.03891247f, 0.02315319f, 0.02622569f, 0.03969036f, 0.03527837f, 
    -0.02007238f, 0.00741766f, -0.06445363f, 0.01389251f, 0.00530699f, -0.02152823f, -0.00601261f, 0.01416350f, 
    -0.01603038f, 0.00949931f, 0.00634192f, 0.01563808f, 0.01855356f, 0.00123686f, -0.02830837f, 0.01847919f, 
    0.04392615f, 0.01504428f, 0.05347470f, 0.02777265f, 0.00786311f, 0.00133887f, 0.02610152f, -0.03669241f, 
    0.03675541f, 0.00833082f, 0.00312075f, -0.06504823f, 0.00642930f, -0.02958973f, 0.01379155f, -0.01989956f, 
    -0.54327327f, 0.14205420f, -0.47470388f, 0.15864755f, -0.04571276f, 0.21241294f, 0.00256186f, -0.28078291f, 
    -0.04253254f, 0.28462926f, 0.24809623f, -0.13364872f, 0.16653220f, 0.11208186f, -0.12606017f, -0.15721302f, 
    -0.06459939f, -0.17899661f, 0.08253084f, -0.02627562f, -0.56331766f, 0.12663974f, 0.01895877f, 0.10402538f, 
    -0.08312023f, 0.24143399f, 0.08475073f, -0.03671250f, -0.70784396f, -0.30627838f, 0.00775145f, -0.02436629f, 
    -0.09882777f, 0.11619113f, -0.16501431f, -0.01109644f, -0.94783586f, 0.31717992f, 0.17486748f, 0.11558466f, 
    0.17092589f, -0.08276387f, -0.21196339f, 0.00539750f, 0.15279655f, -0.36783049f, 0.29858735f, 0.17366561f, 
    -0.01837534f, 0.16462111f, -0.13149065f, 0.01346198f, 0.22296792f, 0.04351491f, 0.09765176f, 0.30944282f, 
    -0.11925428f, 0.00700474f, 0.06276850f, 0.04402887f, 0.08152199f, 0.15710977f, 0.05829497f, -0.10847336f, 
    -0.83272874f, 0.05354935f, -0.02145839f, 0.20474249f, -0.22810422f, -0.38599795f, -0.09281426f, -0.00401121f, 
    -0.64556217f, -0.13970095f, 0.07821436f, -0.02807090f, 0.29271704f, -0.08498026f, -0.03592734f, -0.03841458f, 
    0.11192656f, 0.20054844f, 0.19671133f, -0.17299742f, 0.06868418f, 0.08974802f, 0.03141568f, -0.05634590f, 
    0.12477469f, 0.07044949f, 0.20106827f, 0.29408717f, -0.25387937f, 0.09559169f, 0.09169865f, 0.05024936f, 
    -0.24568972f, 0.07756301f, 0.00071129f, 0.04710772f, 0.08633943f, -0.15101992f, -0.03447960f, -0.02598447f, 
    0.16872019f, 0.01388158f, 0.03316135f, -0.12369896f, 0.68060333f, 0.27966559f, 0.04638633f, -0.04986117f, 
    0.01294692f, -0.08135229f, 0.13304773f, -0.00484262f, 0.06121516f, -0.56134844f, -0.41646883f, 0.06343933f, 
    0.07900425f, -0.03434696f, 0.10559180f, -0.14356314f, 0.12814666f, 0.24870674f, -0.55978161f, 0.11862202f, 
    0.08009442f, -0.17886181f, 0.20604071f, -0.06001006f, -0.06510277f, -0.08542328f, 0.00981526f, -0.39949363f, 
    0.12031455f, -0.15809305f, -0.04600688f, -0.21315345f, 0.18947050f, 0.06494238f, -0.04770999f, 0.25590020f, 
    0.45396185f, -0.06317580f, 0.11399484f, -0.14788386f, 0.07270327f, -0.17210263f, 0.14978190f, -0.00419711f, 
    0.17579885f, 0.29368696f, 0.12265336f, -0.29301125f, 0.02180203f, -0.11128347f, -0.05105306f, -0.04925834f, 
    -0.07643579f, 0.19151901f, -0.18657361f, -0.16361320f, -0.11617295f, -0.02486676f, 0.09359572f, 0.02912235f, 
    -0.22446983f, 0.04166782f, -0.05125192f, -0.51084584f, 0.03589552f, 0.00388135f, -0.19149362f, 0.03796655f, 
    -0.10574775f, -0.04281443f, -0.03508694f, 0.34861407f, -0.03091373f, -0.09388196f, -0.21902105f, 0.08137705f, 
    -0.04859926f, 0.03741214f, 0.01080051f, 0.07599604f, -0.00952683f, -0.11300290f, -0.08792683f, 0.07652075f, 
    0.18445809f, -0.00558429f, -0.02320990f, 0.15459879f, -0.04904551f, 0.19479856f, 0.25895321f, 0.02653874f, 
    -0.00675779f, 0.03198400f, -0.09480093f, 0.06456248f, -0.05502265f, 0.06101916f, -0.23497716f, -0.24558744f, 
    0.11364315f, -0.21884845f, -0.02479565f, 0.10643458f, 0.07272789f, -0.00815461f, 0.04206247f, -0.04591026f, 
    0.04230518f, 0.01554350f, -0.24386427f, 0.11857830f, -0.16192727f, 0.04714645f, 0.15173183f, 0.07917430f, 
    -0.16100459f, -0.14346194f, 0.14259110f, -0.08294790f, 0.12319646f, 0.19333661f, 0.11322805f, -0.15606104f, 
    -0.01891491f, -0.03093207f, -0.12264879f, 0.28623313f, 0.04313732f, 0.13893624f, 0.07487138f, -0.01364060f, 
    0.00249459f, -0.01903027f, 0.00727214f, 0.13216969f, -0.44149676f, 0.06937226f, 0.08264101f, 0.19308302f, 
    0.15576980f, 0.15275259f, -0.08088100f, -0.18858820f, -0.52349788f, -0.13508862f, 0.06971128f, -0.01997070f, 
    0.21744509f, 0.15654284f, -0.22159819f, -0.08235644f, 0.06961443f, -0.19155155f, -0.27478081f, -0.39749172f, 
    -0.10488208f, 0.08268142f, 0.11880174f, 0.25861874f, 0.16926095f, 0.12780181f, 0.45731792f, 0.04256841f, 
    0.00506295f, 0.17913015f, -0.00002734f, -0.13019641f, 0.19134809f, 0.03215790f, -0.03485883f, 0.69138473f, 
    -0.03305203f, 0.03828140f, -0.00312954f, 0.08010859f, 0.20059228f, 0.05868223f, 0.00325106f, 0.12085079f, 
    -0.17265467f, -0.12260468f, 0.13166140f, 0.02236160f, -0.08818404f, 0.01972383f, 0.21818760f, 0.18528846f, 
    -0.11919186f, -0.29942071f, 0.05146227f, -0.12162457f, -0.10019246f, 0.02358216f, 0.17439304f, -0.12089064f, 
    -0.04470603f, -0.05509308f, 0.07785605f, -0.12117086f, -0.63215256f, -0.01300563f, 0.06287546f, 0.03300926f, 
    0.04353850f, 0.01055514f, -0.02385742f, 0.14074418f, 0.49278325f, -0.41331169f, 0.07462927f, -0.29626521f, 
    -0.03816161f, -0.19951837f, 0.28288823f, 0.01282813f, -0.18576466f, -0.03503763f, -0.09227316f, 0.11437998f, 
    0.08034220f, 0.02418293f, 0.09154823f, -0.01693472f, -0.03810644f, -0.10655975f, 0.25929210f, 0.09148355f, 
    -0.09589767f, 0.22380604f, -0.07792394f, -0.20771477f, 0.13492294f, 0.09488667f, 0.10769449f, -0.05039565f, 
    0.05893246f, -0.14353149f, 0.10013738f, -0.14138021f, 0.03381342f, 0.09967496f, 0.25730947f, 0.27200821f, 
    0.23360826f, -0.13690251f, -0.20431638f, -0.11677566f, 0.09264952f, 0.30625296f, 0.04368310f, 0.10256669f, 
    -0.13260771f, 0.03337480f, 0.03774547f, 0.14466797f, -0.06517105f, -0.03789511f, 0.16410661f, 0.16526437f, 
    -0.01891730f, -0.25957516f, 0.07968084f, -0.10883448f, -0.13904089f, -0.33256361f, 0.12374862f, -0.00149610f, 
    0.00255641f, 0.11169646f, 0.02884079f, -0.07049481f, -0.33739993f, 0.29107094f, 0.09297942f, 0.00525037f, 
    0.22550629f, -0.01138918f, -0.10570768f, -0.01958649f, -0.23206988f, -0.11635586f, 0.11431123f, -0.04609288f, 
    -0.07544272f, -0.23147018f, -0.09281446f, 0.15036280f, -0.09079580f, 0.15470676f, 0.09651664f, -0.27560714f, 
    -0.25354275f, 0.27803311f, -0.00945036f, -0.13906749f, 0.09733998f, -0.36031291f, -0.01484617f, 0.14575882f, 
    0.07908639f, -0.08403026f, -0.00369200f, -0.05148178f, -0.07624783f, 0.16746895f, 0.56970358f, 0.00737965f, 
    -0.32376966f, 0.00716208f, 0.15529256f, 0.15916531f, 0.24958092f, 0.31694302f, -0.26294017f, -0.07427609f, 
    -0.19292983f, -0.02650686f, 0.22226247f, -0.01278700f, 0.07384277f, -0.17767118f, 0.17818600f, -0.31098834f, 
    -0.15647370f, -0.07453594f, 0.45093569f, -0.11062483f, -0.04209561f, -0.11312259f, -0.03369217f, -0.01454821f, 
    -0.16989988f, -0.15978976f, -0.09896456f, 0.16909263f, -0.09267341f, 0.15320408f, -0.00049314f, 0.06510723f, 
    0.02938873f, -0.00379647f, -0.19417679f, -0.00112493f, 0.12036974f, 0.17521770f, -0.05882709f, -0.22367957f, 
    -0.14134435f, 0.17505886f, 0.15457648f, -0.05634958f, -0.04992349f, 0.07167688f, 0.10762061f, -0.08424278f, 
    -0.11025122f, 0.15757966f, 0.11640137f, -0.08544882f, -0.14366452f, 0.00081598f, 0.09172205f, 0.09969909f, 
    0.07105649f, -0.06470922f, -0.08462722f, 0.03914697f, 0.06436490f, 0.20392789f, -0.02807137f, 0.05970103f, 
    -0.31428656f, 0.07230507f, -0.00537629f, 0.26652116f, 0.24749446f, 0.06488303f, -0.60357714f, -0.20686069f, 
    0.24815126f, 0.10459571f, -0.14194742f, -0.02176234f, 0.10997932f, 0.08329902f, 0.19798058f, -0.19108546f, 
    0.11008955f, -0.35354978f, 0.13187093f, 0.06221484f, -0.09130017f, 0.11143804f, 0.06572828f, 0.09067688f, 
    -0.16919692f, -0.01852898f, 0.09728978f, 0.04064958f, 0.17577732f, 0.04306516f, 0.18445002f, 0.01675845f, 
    -0.04464641f, 0.33802867f, 0.26096374f, -0.17101873f, 0.10685091f, 0.02093366f, -0.28729695f, 0.17524889f, 
    0.01802450f, -0.03888101f, 0.19681758f, 0.15813003f, -0.26303378f, 0.48225081f, 0.23387307f, 0.13025080f, 
    -0.15297984f, -0.00415299f, -0.25758544f, -0.28927031f, 0.07390562f, -0.16028331f, -0.10356750f, -0.31594783f, 
    -0.00458645f, -0.04301174f, -0.02342192f, 0.12824808f, -0.22915050f, 0.07296094f, 0.08379140f, 0.21622130f, 
    0.09999602f, 0.00070348f, -0.15935840f, 0.13528267f, 0.01797190f, -0.22142088f, -0.07871795f, -0.06713731f, 
    0.02153052f, -0.17131016f, 0.17703831f, 0.06272390f, -0.16796818f, 0.02293454f, -0.03593124f, -0.24254198f, 
    -0.03811679f, -0.11804762f, -0.29921243f, 0.01760244f, 0.04115450f, -0.01834289f, -0.08201979f, -0.20393752f, 
    -0.10456557f, 0.38059661f, -0.10466675f, 0.02903987f, 0.13967259f, 0.00614268f, -0.18063931f, 0.04327893f, 
    -0.03071327f, -0.03830299f, 0.04713510f, -0.04882475f, -0.03101072f, -0.03854356f, -0.02345765f, -0.03518362f, 
    -0.05611143f, -0.02227874f, -0.05860077f, -0.01349772f, -0.03845640f, -0.05911917f, 0.01600340f, -0.05266933f, 
    -0.05584269f, -0.01104421f, 0.01347922f, 0.00545974f, 0.03564256f, -0.05579805f, -0.02666578f, 0.00746158f, 
    0.03945793f, -0.05736752f, -0.03122238f, 0.01089518f, 0.04137866f, -0.05502965f, -0.03751554f, 0.03856003f, 
    -0.03081677f, 0.02689693f, -0.05277826f, 0.01819484f, 0.02138396f, 0.03469229f, 0.01243966f, -0.03975451f, 
    -0.03922131f, -0.00206840f, 0.04026295f, 0.02877613f, 0.04650134f, -0.04544439f, 0.04894854f, 0.05008738f, 
    -0.04922185f, -0.03934074f, -0.01777331f, 0.04085729f, 0.02254612f, -0.01231157f, 0.00715430f, 0.01631599f, 
    -0.04487688f, -0.04389427f, -0.03274233f, 0.02294360f, -0.03336692f, -0.06011356f, 0.04428995f, 0.04592482f, 
    -0.00129536f, -0.01192509f, 0.05343802f, -0.05552804f, -0.03328824f, -0.04199781f, -0.01702401f, -0.03984428f, 
    -0.00139384f, -0.05079046f, 0.04396233f, -0.03294158f, -0.05667160f, 0.02947561f, 0.03863958f, -0.06149813f, 
    -0.00489707f, -0.05845749f, -0.01447637f, -0.02237199f, -0.00541861f, 0.02776157f, -0.04357239f, 0.03849736f, 
    0.03970480f, 0.02808584f, -0.04896625f, -0.05204789f, -0.01083416f, 0.02809687f, -0.03089942f, -0.03367848f, 
    -0.03114511f, 0.02063547f, -0.01456367f, -0.03868671f, 0.04049155f, -0.04203027f, 0.03563033f, -0.00215774f, 
    -0.04042741f, 0.03786169f, -0.04274017f, 0.00251974f, -0.01275130f, 0.02963693f, -0.04236192f, 0.03394527f, 
    0.03021001f, 0.03139279f, 0.02663022f, 0.04041870f, -0.03299094f, 0.03139398f, 0.04827800f, 0.05265096f, 
    -0.03776078f, -0.00277757f, -0.05107017f, 0.01237719f, 0.02749879f, 0.03624560f, 0.00958016f, -0.05695977f, 
    0.03701157f, -0.01664785f, 0.02328741f, -0.04890477f, -0.03051283f, -0.05849252f, 0.00938420f, -0.01962449f, 
    0.04038466f, -0.03136655f, 0.04170784f, 0.01159398f, -0.05503471f, 0.04258097f, 0.01912212f, 0.03918456f, 
    -0.00173064f, -0.03327062f, -0.00392660f, -0.04719246f, -0.04551040f, 0.02797366f, 0.03144154f, -0.05257061f, 
    -0.00358422f, 0.00694260f, -0.01876699f, -0.05029016f, -0.02221819f, 0.02229190f, -0.04544491f, -0.04674513f, 
    -0.01479640f, -0.00105037f, 0.05037539f, -0.03936647f, -0.03872823f, -0.01936655f, -0.03868471f, -0.01423823f, 
    -0.00556379f, 0.04178875f, -0.03890428f, -0.03372363f, 0.02235768f, 0.03170744f, -0.00017160f, 0.00027778f, 
    0.02365006f, 0.01143498f, -0.04889424f, -0.02780772f, 0.03472967f, 0.05077307f, 0.04378464f, -0.06245612f, 
    -0.01835638f, -0.00996761f, -0.01980668f, 0.03040050f, 0.03572633f, -0.02436378f, 0.02495052f, -0.04141334f, 
    -0.03294500f, 0.01011168f, -0.02330839f, -0.02535999f, -0.04378478f, 0.04675940f, 0.03568417f, -0.02153245f, 
    0.01412090f, 0.01374731f, 0.04125802f, -0.04467747f, 0.03189107f, -0.04310521f, 0.02087295f, -0.04882357f, 
    0.04962484f, -0.06487795f, -0.04002387f, 0.00327573f, 0.01211930f, -0.00389810f, 0.01837480f, -0.03195465f, 
    -0.05216601f, 0.02181542f, 0.00644036f, -0.01599702f, -0.04292832f, -0.04254568f, -0.06229321f, -0.03621839f, 
    0.00608051f, -0.00397075f, 0.03258904f, -0.04577544f, 0.05531425f, -0.04775104f, -0.00780595f, -0.03612336f, 
    0.02245357f, -0.00254782f, 0.03147688f, -0.02513970f, 0.01744823f, -0.03482248f, 0.01716950f, 0.02409748f, 
    -0.00787812f, 0.02049609f, -0.00666631f, -0.02298537f, -0.02055957f, -0.05784633f, 0.02402401f, 0.03225798f, 
    -0.04142566f, 0.03881536f, 0.03397188f, -0.01762116f, -0.00332067f, -0.00115265f, -0.01837051f, -0.05079615f, 
    -0.00018983f, -0.01842335f, -0.02597044f, 0.02176498f, 0.00825475f, -0.05248478f, 0.04069395f, -0.05336564f, 
    -0.00506375f, -0.00192073f, -0.03127650f, -0.05811966f, -0.05320931f, 0.00217522f, -0.00524001f, 0.04264436f, 
    -0.00923079f, 0.01515444f, 0.00213626f, 0.02994222f, 0.03500681f, 0.00098325f, 0.00492411f, 0.02459242f, 
    0.02414688f, -0.01734237f, -0.01492577f, 0.00401459f, -0.02440776f, 0.00265102f, -0.01572341f, -0.04401074f, 
    -0.20296319f, -0.01908123f, -0.06836841f, -0.35265750f, 0.01188907f, -0.00859454f, -0.07046618f, 0.13148248f, 
    0.25377694f, -0.33013093f, -0.06893170f, 0.00647871f, 0.31012794f, 0.37568882f, 0.20845683f, -0.12281932f, 
    -0.30679390f, -0.27920434f, 0.09495741f, 0.15725051f, -0.12684883f, 0.19198585f, 0.01529477f, -0.06134118f, 
    -0.20933518f, 0.10684267f, 0.25771224f, -0.15540874f, -0.14414573f, 0.15543453f, -0.19187018f, -0.04917623f, 
    -0.16930674f, 0.08873611f, -0.03036878f, -0.06761856f, 0.10269520f, 0.03797429f, -0.18567739f, 0.03952504f, 
    0.00508894f, -0.23654984f, -0.13594303f, 0.12216883f, 0.29525372f, -0.28278065f, 0.09239098f, -0.54018003f, 
    -0.05005678f, 0.15531014f, 0.19984475f, 0.07229402f, 0.04583765f, -0.01511049f, -0.19685724f, -0.14059646f, 
    -0.20128796f, 0.06560764f, 0.18483253f, 0.16452667f, 0.08079330f, -0.08358196f, -0.16714893f, -0.10785864f, 
    -0.02790052f, -0.17018521f, -0.02726913f, 0.14359316f, -0.17360117f, 0.05113798f, -0.05306596f, 0.06481581f, 
    0.00135684f, 0.06646185f, 0.14674431f, 0.17414327f, -0.17127459f, -0.10408782f, 0.13709828f, 0.12099931f, 
    -0.07840096f, -0.04687861f, -0.12870936f, -0.21332546f, 0.13015853f, 0.05045017f, 0.05798008f, -0.12630719f, 
    -0.00761053f, -0.22872883f, 0.35171375f, 0.18789549f, -0.02442118f, -0.06295305f, 0.04887464f, 0.07728717f, 
    -0.03574670f, 0.04136652f, 0.09685118f, 0.33522812f, 0.30662781f, 0.22664894f, -0.11533792f, -0.05994720f, 
    0.05257515f, -0.08145672f, 0.11902595f, -0.09805755f, -0.51430917f, -0.08057716f, 0.04283516f, 0.11775383f, 
    -0.00915377f, 0.07147462f, 0.10797094f, -0.25062156f, -0.17741184f, 0.04255623f, -0.03410211f, -0.27094492f, 
    0.12286323f, 0.07414376f, -0.00770693f, -0.13855106f, 0.09013058f, -0.03936987f, 0.42509395f, 0.21074642f, 
    -0.02758977f, -0.10645143f, -0.07853815f, -0.10788090f, 0.01850754f, -0.06240705f, -0.19289720f, 0.07502422f, 
    0.24058633f, 0.13114512f, -0.21660051f, 0.05923074f, 0.10773042f, 0.23435342f, 0.04383515f, -0.04421042f, 
    0.07658765f, -0.03678159f, -0.30980062f, 0.20794998f, 0.16959894f, 0.08394369f, 0.09005932f, -0.09650011f, 
    -0.10981389f, -0.13808157f, -0.19520915f, -0.06110457f, 0.09508058f, -0.01090478f, 0.16290858f, -0.03697644f, 
    -0.26672268f, 0.10451037f, 0.30916998f, 0.14515497f, 0.29085970f, 0.26880267f, -0.00442309f, -0.17833339f, 
    0.15646091f, 0.21594183f, -0.04844105f, -0.00920694f, -0.00084220f, 0.25540116f, 0.36343113f, 0.20549893f, 
    -0.04608172f, -0.11135197f, -0.01123711f, -0.19392183f, 0.32742777f, 0.08012196f, -0.19962268f, -0.00530949f, 
    0.20420006f, 0.17351824f, 0.01789784f, -0.07655259f, 0.04208680f, -0.04660543f, -0.22851740f, -0.18654238f, 
    0.03345137f, 0.01949867f, -0.07368356f, -0.04681949f, 0.02646746f, -0.09707090f, -0.10922246f, -0.12606870f, 
    -0.33686954f, 0.49291739f, 0.16045929f, 0.03396762f, -0.11164013f, -0.11950172f, -0.00326353f, -0.03815395f, 
    0.16779855f, 0.01144974f, 0.05055052f, 0.13715144f, -0.06202431f, 0.09507703f, 0.06865592f, -0.00809149f, 
    0.27484018f, 0.02450153f, -0.19900054f, -0.06222953f, 0.16933990f, 0.15776268f, 0.03247657f, -0.16564314f, 
    0.16331001f, 0.09510608f, -0.10716410f, -0.39242712f, -0.08789261f, 0.08434824f, -0.02400139f, -0.01707736f, 
    0.09483127f, 0.01650887f, 0.39841726f, 0.36132169f, 0.24748939f, 0.03056441f, -0.19890535f, 0.03085676f, 
    0.09226595f, -0.12500793f, -0.05503551f, -0.09814413f, -0.01381733f, -0.43597415f, -0.01022398f, 0.23878181f, 
    0.13026525f, -0.17127620f, 0.11078553f, -0.17399624f, 0.39997101f, 0.25620818f, 0.29548481f, 0.13841894f, 
    -0.03187105f, -0.14110398f, 0.23103143f, 0.15206014f, -0.01423876f, 0.00339242f, 0.06259647f, -0.38916776f, 
    0.24145517f, 0.06550932f, 0.09094805f, 0.05776858f, 0.07128832f, 0.04637969f, 0.05134918f, 0.00330874f, 
    -0.25823346f, 0.20255990f, 0.29566556f, 0.22983898f, 0.06537876f, -0.17813963f, -0.09317051f, -0.15638170f, 
    -0.25936797f, -0.15306960f, 0.17723450f, 0.31137228f, 0.10755445f, -0.37644318f, -0.25797898f, 0.01535531f, 
    -0.00994489f, 0.00607264f, -0.05449144f, 0.02766514f, -0.06728993f, -0.00540489f, -0.04607454f, -0.05259976f, 
    -0.04943127f, -0.03478945f, -0.04314229f, 0.00700141f, -0.06223619f, -0.05849837f, -0.06045974f, -0.03209152f, 
    -0.03654537f, 0.04558762f, -0.03207517f, 0.04862532f, -0.05683973f, 0.01548675f, -0.04366574f, -0.03987291f, 
    -0.03862289f, 0.02967141f, -0.00411038f, -0.03396009f, -0.01710135f, 0.02956996f, -0.03597381f, -0.04497448f, 
    0.04618799f, 0.04675214f, 0.00136677f, -0.04727321f, 0.02757520f, -0.05186711f, 0.04261482f, -0.04355391f, 
    -0.05817444f, 0.02142694f, -0.02320058f, -0.04284332f, -0.02994752f, -0.01063597f, 0.01651289f, 0.04406755f, 
    -0.05762582f, -0.00797320f, -0.05129265f, 0.03065651f, 0.00151436f, -0.02961042f, -0.03479424f, 0.02564352f, 
    -0.05383426f, -0.02741947f, 0.04278925f, 0.01256542f, 0.01282263f, 0.04135162f, -0.04415599f, -0.03600630f, 
    0.03794074f, 0.02305583f, -0.05896211f, -0.04577412f, -0.04536423f, -0.00127480f, 0.01448372f, -0.04793714f, 
    0.02033773f, 0.02922711f, -0.01922607f, -0.05390166f, -0.04623969f, -0.02827820f, -0.06249038f, -0.00671993f, 
    0.03982603f, 0.00159454f, 0.04635620f, -0.01047442f, -0.00951382f, -0.01704773f, -0.03111049f, -0.05260959f, 
    0.03120272f, -0.04757438f, 0.02409989f, 0.01193017f, 0.00758486f, -0.05168484f, -0.04985654f, 0.04711397f, 
    0.02157206f, 0.03053916f, -0.02665995f, -0.01708967f, 0.03273519f, 0.03241661f, -0.04384237f, -0.05947764f, 
    0.04121850f, -0.02829026f, -0.01565269f, -0.01797830f, -0.05811512f, -0.01074244f, 0.04994297f, 0.02200914f, 
    -0.02094482f, -0.04500098f, -0.04574950f, -0.05711917f, 0.04031383f, -0.05472655f, -0.01452491f, 0.02298712f, 
    -0.05464318f, 0.00151304f, -0.00311073f, -0.02743633f, 0.04263672f, 0.03615808f, -0.02548140f, -0.04017568f, 
    -0.06515823f, -0.02100329f, 0.04677041f, 0.03217901f, -0.00056309f, 0.05177487f, 0.01620118f, 0.00840188f, 
    0.04627578f, 0.02088350f, 0.04361701f, 0.04956114f, 0.02448032f, 0.04082844f, -0.04186446f, 0.01004265f, 
    0.04769834f, -0.00768249f, -0.04803522f, 0.04398009f, -0.00674508f, 0.00351095f, -0.00371980f, -0.00766188f, 
    -0.04890469f, -0.06144319f, 0.01469757f, 0.04843175f, 0.01167991f, -0.06322129f, -0.00135691f, -0.00960828f, 
    0.00300182f, 0.01864266f, -0.06222466f, -0.05637427f, -0.03802214f, -0.04911398f, 0.00727796f, 0.01593723f, 
    -0.01962273f, -0.03510547f, 0.03226900f, -0.05698992f, 0.00692456f, 0.04292333f, -0.04244161f, -0.00003863f, 
    0.03868946f, -0.03486715f, -0.03481213f, -0.04165902f, 0.03951345f, 0.00554189f, 0.00615023f, -0.00264312f, 
    -0.01732067f, -0.02649089f, -0.02116994f, 0.01449885f, -0.00365723f, -0.05714349f, 0.01414907f, -0.02183374f, 
    0.05307397f, -0.05315800f, -0.03076691f, -0.00930341f, -0.06047456f, -0.02672318f, -0.00717316f, 0.01191892f, 
    -0.03772531f, -0.02392050f, 0.03286887f, 0.02974669f, -0.03025017f, -0.00931109f, 0.00521608f, 0.02148895f, 
    -0.00395663f, 0.00930761f, 0.02688087f, 0.03348942f, -0.04133672f, -0.00326819f, 0.02024209f, 0.00739923f, 
    -0.02319908f, -0.00481628f, -0.04518674f, 0.01206800f, 0.03686818f, 0.04225993f, 0.02406172f, 0.04469216f, 
    -0.02067196f, -0.00356355f, 0.03945532f, -0.00772315f, 0.02920460f, 0.02114614f, -0.00990168f, 0.05303005f, 
    -0.06001442f, 0.01708846f, 0.04813791f, 0.00472873f, -0.01688630f, -0.04662563f, 0.05363911f, -0.03355134f, 
    -0.06056524f, 0.03126765f, 0.04548723f, 0.00380168f, -0.04001851f, 0.00561328f, -0.05242033f, -0.06016748f, 
    0.02941331f, -0.00276066f, -0.01549712f, -0.06135907f, 0.04974452f, -0.06287929f, 0.04980435f, 0.00624535f, 
    -0.02407553f, -0.01569021f, -0.03647389f, 0.00317428f, 0.03664325f, -0.02605649f, -0.00982480f, -0.01924818f, 
    -0.04402254f, -0.03417550f, 0.00056032f, -0.04563773f, -0.02876307f, -0.02657964f, 0.01007745f, -0.02125458f, 
    -0.01500631f, 0.00034771f, -0.05032076f, -0.00832994f, -0.03025746f, 0.04485202f, -0.01945450f, 0.02576024f, 
    -0.00235323f, 0.04227439f, 0.00285423f, -0.05642648f, 0.03613859f, -0.01965737f, -0.01647108f, -0.01855554f, 
    -0.20295709f, -0.44627824f, 0.21399289f, -0.07962778f, -0.06833044f, -0.04638567f, -0.03099965f, 0.04986309f, 
    0.02924257f, -0.04372040f, 0.07084171f, -0.47069153f, 0.14303893f, 0.03027383f, 0.10173111f, -0.17464057f, 
    -0.12261569f, -0.23103140f, -0.43291983f, 0.04236164f, -0.32475343f, -0.18510041f, 0.03637521f, 0.00522331f, 
    0.11249842f, 0.06500702f, 0.11451244f, -0.09056836f, 0.08708614f, -0.11253019f, -0.14588417f, 0.14818324f, 
    -0.01256583f, -0.13416584f, -0.02184382f, 0.09454697f, -0.03136263f, 0.17435069f, 0.04753340f, -0.02370718f, 
    -0.21525487f, 0.00634024f, 0.11864344f, 0.18806170f, 0.09192100f, 0.73498631f, 0.05790671f, -0.15489048f, 
    0.14508313f, 0.08908510f, 0.09854575f, -0.01901605f, -0.28652668f, -0.00308535f, -0.14593396f, 0.27521911f, 
    0.39703000f, -0.01355319f, -0.13745575f, 0.07557984f, 0.10360248f, -0.13778351f, -0.07132308f, -0.42404565f, 
    0.12169018f, -0.11404804f, -0.21052785f, -0.27998027f, 0.07281454f, 0.11470884f, -0.12055951f, 0.02063231f, 
    0.18997100f, 0.07364071f, -0.03311851f, -0.00947912f, -0.01399918f, -0.10199361f, 0.06873643f, 0.02985297f, 
    0.01485659f, 0.09085200f, 0.01675035f, 0.44334319f, 0.04424779f, -0.03531086f, -0.07669903f, -0.08303351f, 
    0.09386180f, -0.16698849f, -0.12511522f, -0.12657557f, 0.13131443f, -0.05694653f, -0.04867223f, -0.10364150f, 
    -0.12743180f, 0.13679561f, 0.09190739f, 0.28263465f, 0.02613433f, -0.19337712f, -0.11487032f, -0.06448317f, 
    0.06791463f, -0.00654203f, -0.07850997f, 0.07851513f, 0.38505456f, 0.29414177f, -0.27715850f, 0.13936172f, 
    0.00920670f, 0.00536564f, 0.13047257f, -0.07228882f, 0.02584708f, -0.20744164f, -0.05026705f, -0.48783779f, 
    -0.23641819f, 0.02886837f, 0.13029400f, 0.05865951f, 0.12943526f, 0.03655633f, 0.14554566f, 0.15066089f, 
    -0.19204687f, -0.05269096f, -0.14194985f, -0.11219959f, -0.09653063f, -0.07279690f, -0.06296465f, 0.23622330f, 
    -0.00271040f, 0.14316666f, -0.04118629f, -0.01157971f, 0.14550191f, 0.05725283f, -0.05977330f, 0.18676442f, 
    0.30349872f, 0.08626064f, -0.31851715f, -0.08944198f, 0.03010685f, 0.18394534f, 0.03051374f, 0.17585860f, 
    0.09044160f, 0.14020272f, -0.02413780f, 0.01217749f, -0.16516946f, 0.02900469f, 0.02737968f, -0.08888494f, 
    -0.00525940f, -0.28468913f, 0.11162515f, 0.04084772f, 0.08349314f, -0.11788096f, -0.11472534f, -0.13307796f, 
    -0.01617863f, 0.05235325f, 0.06178510f, 0.08822068f, -0.12791480f, -0.03721712f, -0.07275836f, 0.16556691f, 
    -0.00079546f, 0.14633223f, 0.05563064f, -0.03746981f, 0.00973023f, 0.02216013f, 0.11354387f, -0.15861665f, 
    -0.11128551f, -0.13608465f, 0.13183582f, 0.20629740f, -0.00068482f, 0.41644967f, -0.28870413f, -0.10607927f, 
    0.12401983f, 0.01086624f, 0.13068134f, 0.09215739f, -0.00494648f, -0.13793150f, -0.44864771f, -0.47933164f, 
    -0.02006172f, -0.08647494f, 0.03591310f, -0.02249220f, 0.05202559f, -0.23356920f, 0.04238011f, 0.24325456f, 
    -0.02756845f, 0.00950627f, 0.03476045f, 0.04141515f, 0.05945660f, 0.04887354f, 0.09142695f, -0.19350928f, 
    0.04189089f, 0.08667286f, 0.11740851f, -0.08441103f, -0.01792155f, -0.12063847f, 0.14794213f, 0.06661893f, 
    0.06720481f, -0.51247036f, 0.01305368f, 0.17248482f, 0.16560715f, -0.03952270f, -0.05747091f, 0.00092740f, 
    0.01407849f, 0.05744626f, 0.08624320f, 0.04709592f, 0.01302699f, -0.19919477f, 0.10056790f, 0.15504315f, 
    0.16596138f, -0.10166445f, 0.01846530f, -0.22745948f, -0.11633935f, -0.01508306f, 0.07643066f, -0.05959840f, 
    -0.01895858f, 0.16523480f, -0.14824380f, -0.14881346f, 0.09866147f, 0.14895299f, -0.14967690f, -0.29254675f, 
    -0.12621181f, -0.15997224f, 0.02990028f, 0.07148495f, 0.16502002f, -0.48352608f, -0.07480177f, 0.08803804f, 
    0.06928424f, 0.00216689f, -0.01761520f, 0.09408282f, -0.09429749f, 0.26999602f, 0.27916738f, 0.16283834f, 
    -0.02558750f, -0.06358902f, -0.01342759f, 0.07145606f, -0.08291451f, 0.09285395f, 0.03121053f, 0.34569445f, 
    0.15136801f, -0.72748762f, 0.12260545f, -0.09602083f, -0.12440740f, -0.13665324f, 0.13915849f, -0.08151461f, 
    -0.02458858f, 0.02523207f, -0.00545475f, -0.01274075f, 0.05196055f, -0.04498888f, 0.04400828f, -0.00941625f, 
    0.02828898f, -0.06189031f, 0.00144645f, -0.02443869f, 0.00420766f, 0.01824744f, 0.01827630f, 0.03764104f, 
    -0.02115425f, 0.05165403f, -0.00194908f, -0.00767366f, -0.00558158f, -0.02374688f, -0.06587083f, -0.05052095f, 
    0.02069107f, -0.01456559f, -0.00247415f, -0.00968794f, -0.04359026f, 0.02737154f, -0.00348527f, 0.05038963f, 
    -0.01977480f, -0.02853916f, -0.05175278f, -0.05635138f, -0.04516588f, -0.02678478f, -0.02144438f, 0.04851096f, 
    0.02225673f, -0.02938446f, -0.00076878f, 0.06084523f, 0.02812559f, -0.04490159f, 0.00760580f, -0.03758065f, 
    -0.01208731f, 0.02511884f, -0.03944566f, 0.01330620f, 0.03394930f, 0.03305794f, -0.03279538f, 0.01237370f, 
    -0.05612800f, -0.03542541f, -0.00036161f, -0.05189495f, 0.01921131f, -0.01906448f, -0.03549661f, -0.05556516f, 
    0.03386004f, 0.03357530f, 0.04305582f, 0.03890274f, 0.04823426f, 0.02159555f, 0.01882652f, -0.04969819f, 
    0.00898325f, 0.02733647f, -0.00545345f, -0.06365468f, 0.01213277f, -0.05851297f, 0.04339848f, -0.00494246f, 
    0.01135119f, -0.02072894f, -0.04542867f, 0.05344409f, 0.02551111f, -0.03631216f, -0.01422333f, -0.01292203f, 
    0.02085196f, 0.00802036f, -0.05193774f, 0.03521220f, 0.05193231f, -0.02097751f, -0.04488992f, 0.00258859f, 
    -0.00249962f, 0.03108256f, -0.04691849f, 0.04239330f, -0.00787741f, -0.01128417f, -0.06181788f, -0.04671929f, 
    -0.06364455f, -0.04375355f, -0.05867516f, 0.04338089f, 0.00550951f, -0.03966170f, 0.01566124f, 0.03515089f, 
    -0.00294777f, -0.03945265f, -0.02623129f, 0.03602771f, -0.02076377f, -0.06296450f, 0.03097853f, 0.02804843f, 
    0.02493913f, 0.00361412f, -0.03379519f, -0.00465194f, -0.02557498f, 0.04848304f, 0.05540954f, 0.03551305f, 
    0.04934900f, 0.00606868f, -0.03217762f, 0.02265566f, -0.02035693f, 0.01062665f, 0.01304425f, 0.04139698f, 
    -0.05162925f, 0.00859957f, 0.00360071f, -0.01523547f, 0.01034363f, -0.01086385f, 0.04139168f, 0.01687616f, 
    -0.04644848f, 0.05461287f, -0.06605392f, -0.00043384f, -0.02915211f, -0.00714680f, 0.02589614f, 0.00598091f, 
    0.04884272f, -0.02659081f, -0.02822979f, 0.01970807f, -0.05085222f, -0.00291965f, -0.04014877f, 0.00998466f, 
    -0.03567972f, -0.02818425f, -0.00921897f, 0.01398912f, -0.02773363f, -0.05946845f, -0.02856022f, 0.05135963f, 
    -0.02337322f, 0.01269182f, -0.04581224f, -0.03362072f, -0.03708259f, -0.01341598f, -0.02340000f, -0.01178803f, 
    0.04367153f, 0.03543962f, -0.01993438f, 0.03254803f, -0.01109863f, -0.05739000f, -0.03177382f, 0.00360234f, 
    0.02940244f, 0.02372062f, 0.01029105f, 0.01693177f, -0.02271098f, -0.00066645f, -0.04284763f, 0.04158222f, 
    0.04098843f, 0.03433796f, -0.01619648f, -0.02819189f, -0.05398000f, 0.03004840f, -0.05202963f, 0.01760589f, 
    -0.01374659f, -0.02716991f, 0.03412394f, -0.04572936f, -0.06068609f, 0.05276854f, -0.01136963f, 0.00649234f, 
    -0.03377009f, 0.00723816f, 0.02724708f, -0.02189722f, -0.04415306f, -0.05761058f, -0.03826726f, -0.02108214f, 
    -0.02738141f, -0.02188900f, 0.01722850f, -0.03307727f, 0.03764883f, 0.03394908f, -0.05529109f, 0.02309785f, 
    0.02702777f, 0.03153156f, 0.03588643f, -0.02872233f, -0.04532015f, -0.06745511f, -0.00639727f, 0.03243163f, 
    -0.03094269f, -0.03748782f, -0.01902250f, -0.04239338f, -0.06068853f, -0.06678218f, 0.02825082f, -0.03639419f, 
    -0.05094470f, -0.02683121f, -0.01163100f, 0.01915748f, -0.01934040f, -0.03997446f, -0.03068447f, -0.04703629f, 
    -0.00277825f, 0.04193287f, -0.06198615f, -0.01118253f, -0.03125222f, 0.04766403f, 0.02115379f, -0.00262999f, 
    -0.04480587f, -0.02187045f, -0.02804601f, 0.01518527f, 0.00204265f, 0.01358076f, -0.05248226f, 0.03526105f, 
    0.03649295f, 0.02015016f, -0.03628350f, 0.01937533f, -0.02784582f, -0.02059384f, 0.00916577f, 0.04668823f, 
    0.00160011f, 0.04786062f, 0.05018309f, -0.03621446f, -0.06350252f, 0.03908239f, -0.04078817f, -0.01545513f, 
    0.03141396f, -0.04205211f, -0.04513804f, -0.00177482f, -0.04049002f, 0.00352436f, 0.01686760f, -0.05797823f, 
    0.17830564f, -0.10617935f, 0.22292045f, -0.20061696f, -0.03797235f, -0.05111559f, 0.04173087f, -0.03180058f, 
    -0.11517750f, 0.36849511f, 0.36361101f, 0.08370610f, -0.11608809f, 0.36030746f, 0.22912671f, -0.12347475f, 
    0.09219877f, 0.06491847f, -0.22774501f, 0.05092439f, -0.20884389f, 0.12281617f, -0.27207291f, -0.25914338f, 
    -0.10133650f, 0.01295035f, 0.07276443f, -0.35511196f, 0.44209486f, -0.13145055f, -0.06488304f, -0.23260137f, 
    -0.01211177f, 0.19012968f, 0.02292480f, 0.00616211f, 0.11299498f, 0.06864022f, -0.00717641f, -0.12782881f, 
    -0.13412496f, -0.28661114f, -0.13213865f, 0.06039191f, 0.07376369f, 0.19181447f, 0.04977544f, 0.15040177f, 
    -0.16645807f, 0.12092257f, -0.05013949f, 0.10584849f, -0.14801951f, -0.09449102f, 0.22151470f, -0.05242509f, 
    -0.12507710f, -0.12363452f, 0.01198979f, -0.02044991f, 0.09524244f, 0.05621930f, -0.09336829f, 0.29723254f, 
    0.51013136f, -0.07124314f, -0.14961165f, 0.01668864f, 0.11381516f, -0.16630891f, 0.11261839f, 0.17807384f, 
    0.17964822f, -0.05450999f, -0.16013575f, 0.03227042f, 0.06191640f, -0.00804115f, -0.17743862f, 0.02286078f, 
    -0.12165930f, 0.12048535f, 0.10393196f, 0.16727862f, 0.32029575f, -0.04665450f, 0.10644560f, -0.03965399f, 
    -0.14505261f, 0.27591416f, -0.08921448f, -0.12833919f, -0.34684631f, 0.06548621f, -0.09421668f, -0.07683945f, 
    -0.04350697f, -0.07708546f, 0.00592494f, -0.08188651f, -0.31314632f, 0.01429307f, -0.04702226f, -0.03027334f, 
    0.02507018f, 0.04965334f, -0.19885196f, -0.15266259f, 0.05315841f, -0.09260262f, -0.09317018f, -0.06192836f, 
    -0.06331599f, -0.05673068f, -0.06334919f, -0.05611866f, -0.03139900f, -0.02445698f, -0.05871620f, 0.43045974f, 
    0.13100524f, -0.06593557f, 0.16227500f, -0.15377904f, -0.02218107f, -0.18778732f, -0.35255456f, 0.00578755f, 
    0.07380690f, -0.09841715f, -0.08265929f, -0.16250624f, -0.10767438f, 0.04386394f, -0.05421916f, -0.26502195f, 
    -0.07289683f, -0.18640316f, 0.05905068f, -0.19005452f, -0.11793077f, 0.13403070f, -0.06814981f, -0.21210486f, 
    -0.06983235f, -0.02275912f, 0.16901496f, 0.15126698f, 0.04322244f, 0.24286196f, -0.03427390f, 0.06771623f, 
    0.05938470f, 0.10306474f, 0.09811627f, -0.03961112f, 0.02366769f, -0.08482406f, -0.06482012f, -0.00563388f, 
    0.04855499f, -0.01995996f, 0.26757291f, 0.04327480f, -0.08019990f, 0.10527901f, 0.16124074f, 0.08344628f, 
    0.10110830f, -0.06972106f, -0.44455367f, -0.14424908f, -0.20489317f, 0.02406104f, -0.03980089f, 0.05566780f, 
    -0.21310481f, -0.03039234f, 0.03306108f, 0.12357647f, 0.27556390f, -0.18500876f, 0.19911018f, 0.06987047f, 
    0.09096909f, 0.04912481f, 0.01418353f, 0.12505272f, 0.10767303f, -0.02594666f, 0.04583424f, -0.20041685f, 
    -0.24216574f, 0.01284489f, 0.11255373f, -0.10392302f, 0.14118230f, 0.03693993f, -0.38651216f, -0.16146091f, 
    0.01776976f, 0.23784390f, -0.27247211f, 0.04150325f, 0.10662732f, 0.07774313f, -0.10133675f, 0.13811998f, 
    0.01805290f, 0.26200116f, -0.18917938f, -0.14372274f, -0.01082223f, 0.12443587f, 0.09392917f, -0.24920496f, 
    0.28354165f, -0.16694549f, 0.04886696f, 0.12703307f, -0.10417606f, 0.01281458f, 0.13699289f, 0.23922141f, 
    0.13796723f, -0.04730389f, 0.26034799f, -0.38061386f, -0.32688800f, -0.14585678f, -0.01515739f, 0.21997531f, 
    0.02417256f, 0.17444392f, -0.22980693f, -0.18178232f, -0.21179831f, -0.03817970f, -0.09099878f, -0.07552257f, 
    0.19352783f, -0.02577340f, 0.03193080f, -0.19318448f, 0.20563896f, 0.35595813f, 0.06470411f, 0.10952159f, 
    -0.05272771f, -0.07035790f, -0.07015426f, -0.09481822f, 0.26793280f, 0.01163147f, -0.18125129f, 0.16172792f, 
    0.09693064f, 0.10683549f, -0.07570408f, 0.11023577f, -0.33151630f, -0.11121419f, 0.10053638f, -0.11291612f, 
    0.43041232f, -0.02719814f, -0.14633337f, -0.05724201f, -0.07176518f, 0.07528917f, 0.13649353f, 0.33506805f, 
    0.22001648f, 0.15282947f, -0.00892865f, 0.19131303f, -0.01178036f, 0.08772323f, 0.35616967f, 0.11973272f, 
    -0.08382368f, 0.22764786f, 0.05000115f, 0.20116365f, 0.29521775f, -0.04565742f, 0.10800300f, -0.10244665f, 
    0.26623282f, 0.12173588f, 0.15322454f, -0.07298481f, 0.04696037f, -0.27251357f, -0.27788135f, -0.02737276f, 
    0.10069515f, 0.24905072f, -0.17753561f, -0.24241109f, 0.25418910f, 0.02898594f, 0.11139684f, 0.19516397f, 
    -0.11877456f, 0.13966264f, 0.02769010f, -0.04062497f, -0.04902622f, -0.04014308f, -0.14262004f, 0.24964052f, 
    -0.31873026f, -0.06999777f, -0.25244501f, -0.43803334f, 0.11587937f, -0.08096181f, -0.17970526f, -0.01023266f, 
    -0.00682124f, 0.12442958f, -0.09272742f, 0.14179157f, 0.04956646f, -0.02717851f, -0.02009239f, -0.11957327f, 
    -0.26408821f, -0.00145262f, -0.36764839f, -0.17021342f, 0.04699400f, 0.13322455f, 0.29359350f, 0.04698153f, 
    -0.07836393f, 0.03323958f, 0.06874190f, -0.07488021f, 0.03827310f, 0.07545890f, 0.17494503f, 0.16171217f, 
    -0.21591483f, -0.05288578f, -0.29760733f, 0.18616743f, 0.10358957f, 0.01178631f, 0.15394035f, 0.27464095f, 
    0.26727825f, 0.01298640f, -0.17202999f, -0.25345841f, -0.02179238f, 0.07247925f, -0.02454937f, -0.22354731f, 
    -0.38501111f, -0.11941981f, -0.17199919f, 0.08857596f, -0.13537665f, -0.09078938f, -0.04890327f, 0.02731848f, 
    -0.08203368f, 0.02206409f, 0.23810023f, -0.22296026f, -0.14902525f, -0.20820665f, -0.18013065f, 0.14689495f, 
    -0.08242524f, -0.10332523f, -0.20892389f, -0.13847235f, -0.07780191f, -0.02842744f, -0.09018889f, 0.15780954f, 
    -0.21033479f, -0.03349303f, 0.03401215f, -0.65617192f, -0.21236822f, 0.00710587f, 0.05698039f, 0.15402591f, 
    -0.12671070f, -0.05343818f, 0.01340931f, 0.09654052f, 0.15403646f, -0.06118553f, 0.11178745f, -0.07550714f, 
    0.09075012f, 0.05841881f, 0.19692734f, 0.11446562f, 0.08393152f, 0.25934467f, 0.34209591f, 0.41760060f, 
    -0.01115151f, 0.03687652f, 0.21715976f, -0.12870865f, 0.06703321f, 0.01238162f, -0.07439861f, -0.16354269f, 
    -0.03612011f, -0.13811862f, -0.14810106f, -0.02696216f, 0.06149965f, 0.20544855f, -0.17475066f, -0.06683405f, 
    -0.23280305f, -0.01467311f, -0.00062238f, -0.06645561f, -0.06771676f, -0.00818824f, -0.10744533f, 0.04129357f, 
    0.33942050f, 0.20805056f, 0.28082246f, -0.05863765f, 0.10045963f, -0.02693116f, 0.14062142f, 0.24855639f, 
    0.18293142f, 0.01809421f, -0.09530675f, -0.00824911f, 0.09716202f, 0.12546264f, -0.11534019f, -0.01005714f, 
    0.04687617f, -0.10515463f, -0.01665365f, -0.23561761f, 0.12552154f, 0.04195904f, -0.01976435f, 0.03979038f, 
    -0.13070467f, -0.10837042f, 0.06482457f, -0.12271525f, -0.14247914f, 0.25366354f, 0.05441541f, -0.08760428f, 
    -0.28823850f, 0.23791231f, 0.01520336f, 0.16017979f, 0.22607501f, 0.02186412f, 0.10102313f, -0.01426670f, 
    -0.03220082f, -0.14414847f, -0.03500247f, 0.04696748f, -0.09247944f, 0.21838644f, 0.13515146f, -0.16832651f, 
    0.11468451f, -0.04617060f, -0.17374480f, -0.04341057f, 0.05535265f, 0.05242436f, 0.32991332f, 0.30833301f, 
    0.36222595f, 0.08755495f, -0.31810692f, 0.24620467f, -0.11277955f, 0.04974053f, -0.14972538f, -0.01949082f, 
    -0.21466744f, -0.10494079f, 0.01438160f, 0.07940604f, -0.03493268f, -0.04954755f, -0.03086134f, 0.06774842f, 
    0.22397354f, -0.24941762f, -0.16215903f, 0.08960563f, 0.07122465f, -0.17575541f, -0.12240478f, 0.02790176f, 
    0.00487580f, 0.27441809f, -0.03271232f, 0.16647401f, 0.12477982f, -0.07101617f, 0.18898404f, -0.19900283f, 
    0.13028149f, -0.49589849f, -0.04333826f, -0.18706100f, -0.10671961f, -0.08862792f, 0.10000121f, 0.12752654f, 
    -0.22139212f, 0.11728184f, 0.07717051f, 0.05434175f, 0.24069174f, 0.24940857f, -0.05270349f, -0.08094514f, 
    -0.01041566f, -0.00396074f, 0.01152317f, -0.27339700f, -0.20617095f, -0.08796108f, -0.10574160f, -0.07715090f, 
    0.05253375f, 0.00874004f, -0.21729730f, 0.10516272f, -0.12889276f, 0.13531527f, 0.16576850f, 0.07052555f, 
    -0.16300808f, -0.02269584f, 0.14173201f, -0.10568773f, -0.04597970f, -0.10141335f, 0.36870852f, 0.15856896f, 
    0.03561943f, 0.12305447f, 0.01486846f, -0.17266358f, 0.17392695f, -0.02630785f, 0.00389672f, 0.08343340f, 
    -0.02558273f, 0.29614618f, 0.16213468f, 0.10426696f, -0.09457848f, -0.04644731f, 0.18396746f, 0.03537583f, 
    -0.38967702f, -0.40583563f, -0.31487414f, 0.11556014f, 0.22576638f, -0.15889655f, -0.09230463f, -0.04464420f, 
    -0.04034067f, -0.16808060f, 0.08747697f, -0.03241780f, 0.08473212f, -0.10693213f, -0.18988286f, 0.10744157f, 
    -0.10276352f, -0.27108338f, -0.00760275f, -0.09362897f, 0.12215307f, -0.01195066f, 0.11193392f, 0.11476722f, 
    0.07014390f, -0.14809987f, -0.10740608f, -0.25506455f, -0.07719211f, -0.20825553f, 0.01011170f, 0.08432320f, 
    0.10634927f, -0.02663130f, -0.11528006f, 0.05704988f, -0.46409261f, -0.35754421f, -0.03067758f, 0.25690508f, 
    0.20999387f, 0.02459778f, -0.03345696f, 0.10361524f, 0.02371145f, -0.55696553f, 0.09182218f, 0.00499136f, 
    0.25106707f, 0.00497136f, -0.08591762f, 0.15820347f, -0.00146444f, -0.15457268f, 0.05006911f, 0.13491921f, 
    -0.11868486f, -0.13787012f, -0.05593352f, -0.11562715f, -0.22991906f, -0.20131071f, -0.04621452f, -0.22351947f, 
    -0.10431755f, 0.04982546f, 0.34815606f, 0.07042904f, 0.11747763f, -0.12039692f, 0.10000241f, 0.06624289f, 
    0.00378169f, 0.00862557f, 0.07729339f, 0.26689848f, 0.03197459f, -0.10563839f, -0.12289340f, -0.00701862f, 
    0.19153358f, 0.08447096f, 0.23905693f, -0.01662335f, -0.23448680f, 0.08390947f, 0.02635281f, 0.05526606f, 
    0.03888283f, -0.05715356f, -0.39897653f, -0.21573968f, 0.13731892f, 0.05219581f, -0.04828686f, 0.26579610f, 
    0.16158481f, 0.08920404f, -0.04330287f, -0.09364456f, -0.02723241f, 0.19234471f, 0.21321304f, 0.01381035f, 
    -0.09308223f, 0.04190147f, -0.05824471f, 0.06724161f, -0.19025680f, -0.03487210f, 0.06404804f, 0.16077743f, 
    -0.03080317f, 0.15028216f, -0.06842464f, 0.18358785f, 0.11590878f, 0.10002004f, 0.30489790f, 0.15748872f, 
    0.04898250f, 0.07585840f, -0.16438559f, -0.33287412f, 0.09707739f, -0.45992318f, -0.02092747f, -0.09409036f, 
    0.10316671f, 0.20224141f, -0.06129341f, 0.05719889f, 0.02728115f, 0.04388621f, 0.36281562f, -0.19429986f, 
    -0.13652873f, -0.15764238f, 0.08461076f, -0.32206815f, -0.10100728f, 0.03748814f, -0.02866371f, 0.11899491f, 
    -0.31840819f, 0.10055283f, 0.24477553f, 0.08260214f, -0.06355178f, -0.06936786f, 0.05987718f, -0.08697120f, 
    0.10013646f, 0.17798324f, 0.19593441f, -0.15404531f, -0.01789922f, 0.09241410f, -0.02641276f, -0.06793717f, 
    0.20644173f, 0.14243318f, 0.16012515f, -0.03304436f, 0.02157087f, -0.03514535f, -0.06658446f, -0.50661242f, 
    0.17080221f, 0.11123984f, -0.03630968f, 0.51511824f, 0.30108011f, -0.00072820f, 0.05195243f, -0.24807057f, 
    -0.39923924f, 0.02353091f, 0.15411739f, 0.13057189f, 0.18227445f, 0.02343895f, 0.04901279f, 0.10576740f, 
    -0.09265252f, 0.03777086f, 0.13014854f, -0.14182481f, -0.11001214f, -0.13566929f, 0.14551577f, 0.05791225f, 
    -0.04143320f, 0.15888485f, -0.10149264f, 0.14173704f, 0.01392713f, 0.28998324f, 0.15158843f, 0.04376250f, 
    -0.19083291f, 0.09517004f, 0.00794882f, 0.06505411f, -0.00295087f, 0.16783649f, 0.13389422f, 0.00439787f, 
    -0.01034895f, -0.04621973f, -0.03937577f, -0.07364568f, -0.03423476f, 0.08821715f, 0.10358936f, 0.21523884f, 
    0.07247329f, -0.00601572f, -0.17413476f, 0.16000031f, 0.10178985f, -0.09686338f, 0.07206286f, 0.03311863f, 
    0.06741083f, -0.00702949f, -0.00441577f, 0.06964646f, -0.24177215f, -0.05555471f, -0.01662159f, 0.01082519f, 
    -0.09301572f, 0.18454869f, -0.52296120f, -0.14403419f, 0.15788406f, 0.16748568f, -0.01668246f, -0.10601684f, 
    -0.05596737f, -0.16500670f, 0.09224463f, 0.21269928f, 0.09495875f, 0.12044231f, 0.02393349f, 0.00218114f, 
    0.10874257f, -0.06203107f, -0.06750727f, -0.01070824f, 0.16959658f, -0.05148159f, 0.29157662f, 0.12662724f, 
    -0.07809891f, -0.27866173f, -0.09328858f, -0.00972477f, 0.07011105f, 0.11748514f, -0.00433445f, 0.05256831f, 
    0.00049126f, -0.18833879f, 0.12635157f, 0.01991535f, 0.21285930f, 0.06159294f, -0.02278304f, 0.12008419f, 
    -0.00739122f, -0.23047909f, -0.14161415f, -0.02115129f, 0.19017246f, -0.07098559f, 0.04435355f, -0.23428249f, 
    0.07274384f, 0.04777560f, -0.02545514f, -0.04932253f, 0.11371472f, -0.05904291f, -0.09164788f, -0.10904272f, 
    -0.02815849f, -0.00747900f, -0.05213819f, 0.02083790f, -0.00588763f, -0.02076676f, -0.04842572f, 0.03222689f, 
    -0.01480847f, 0.02621700f, 0.03877488f, 0.03258678f, -0.00638233f, 0.03519746f, -0.00199651f, -0.03789989f, 
    0.00693326f, -0.00147696f, 0.05302505f, -0.02896900f, 0.01176710f, -0.01547206f, -0.03743553f, 0.03791786f, 
    -0.03473383f, 0.02229678f, 0.03022152f, -0.00973867f, 0.01570824f, -0.04649347f, -0.02172800f, -0.06150459f, 
    0.01547153f, 0.05126188f, -0.01091839f, 0.04913718f, -0.01495683f, -0.06291749f, -0.03687567f, -0.00047034f, 
    -0.02697531f, -0.03969789f, 0.03206668f, 0.00437039f, -0.06105053f, -0.00527760f, 0.02630757f, -0.05597013f, 
    -0.01058842f, -0.04629920f, -0.05307863f, -0.00549397f, -0.01547289f, 0.04212561f, 0.02114348f, -0.04736778f, 
    -0.02809208f, 0.02241690f, 0.01540481f, 0.02294269f, 0.00970817f, -0.04292683f, 0.01815361f, -0.04811239f, 
    0.03556831f, -0.01870878f, 0.03269335f, -0.02664743f, 0.02866376f, 0.04165639f, -0.03865510f, 0.02014635f, 
    -0.04568189f, 0.01377834f, -0.05106695f, 0.02834119f, 0.03836718f, -0.03816960f, -0.01104679f, -0.04082861f, 
    -0.05802841f, -0.01020988f, 0.03334370f, -0.01148642f, -0.04253193f, -0.04420552f, 0.01773595f, -0.02378961f, 
    -0.05289209f, -0.03482201f, -0.02408917f, -0.06446176f, 0.05276115f, 0.03316888f, -0.04093220f, -0.00307125f, 
    0.02806755f, -0.05067421f, -0.03580154f, -0.05330889f, 0.04537052f, 0.03454224f, -0.00051765f, 0.02091586f, 
    -0.03863203f, 0.01384526f, -0.01709611f, -0.05104681f, 0.00166278f, -0.02480178f, 0.02983416f, 0.01419622f, 
    -0.00495318f, -0.01152083f, 0.03704851f, 0.05293028f, -0.05020343f, 0.02617966f, 0.01907382f, -0.01858079f, 
    -0.01045721f, -0.04574447f, 0.04421241f, 0.04036606f, 0.02926281f, -0.02044496f, 0.00463561f, -0.00022249f, 
    -0.01660854f, -0.01302304f, -0.05259610f, 0.00456639f, 0.02625998f, 0.01422583f, -0.02793733f, -0.00299635f, 
    -0.02003262f, 0.01134647f, -0.04622466f, -0.03924853f, 0.02668342f, -0.02798300f, 0.04929559f, 0.01012796f, 
    -0.05666418f, 0.01286038f, 0.00083388f, 0.03821678f, -0.01379397f, 0.00526498f, -0.00531956f, 0.03007552f, 
    0.03114918f, 0.01377135f, -0.03530033f, -0.03717509f, -0.04167274f, -0.00902657f, -0.05191569f, 0.01236798f, 
    0.03283130f, 0.04610742f, -0.03587976f, 0.03682861f, 0.02340382f, -0.04830535f, 0.04687664f, -0.05793856f, 
    -0.02804832f, -0.01597810f, 0.00133456f, 0.04926274f, -0.05005408f, -0.06291625f, -0.05318069f, 0.01932603f, 
    -0.01977575f, -0.05440652f, -0.05224275f, -0.01732098f, 0.02772082f, 0.01507682f, -0.04438925f, -0.00740559f, 
    0.01519269f, 0.04351442f, -0.05797480f, 0.04969498f, -0.04657465f, -0.01620551f, 0.01025544f, 0.05155998f, 
    0.01108955f, 0.03023167f, 0.01001000f, 0.00755101f, -0.01801282f, 0.02925921f, 0.04278746f, -0.01130104f, 
    0.04460386f, 0.00793268f, 0.02617923f, -0.01945646f, -0.02847421f, -0.05714497f, 0.04158726f, -0.05342675f, 
    -0.06021198f, -0.00632815f, -0.05075557f, -0.04327699f, -0.05402741f, 0.03311465f, -0.04288195f, 0.01864490f, 
    -0.01667494f, 0.02651959f, -0.02911221f, -0.06316311f, -0.03106719f, -0.01967896f, -0.06016171f, -0.05034748f, 
    -0.03959105f, 0.02631821f, -0.00763784f, 0.04430587f, 0.00830436f, 0.03356694f, 0.04442396f, 0.00113417f, 
    0.02519022f, 0.03094108f, -0.05281006f, -0.04511517f, -0.00520480f, 0.01269554f, 0.03144573f, -0.04012804f, 
    0.02051818f, -0.00796813f, -0.00824549f, -0.05012314f, -0.04690489f, -0.02732273f, 0.01307540f, -0.00469294f, 
    -0.05835489f, -0.06076273f, -0.03191958f, 0.03754409f, -0.01907254f, -0.04989551f, 0.03683749f, -0.01072794f, 
    0.04804427f, 0.01541876f, 0.01099084f, 0.01255408f, 0.00798869f, -0.04855376f, -0.03851254f, -0.04266433f, 
    -0.03972968f, 0.02320801f, -0.02500322f, 0.02018154f, 0.00716148f, -0.04612983f, 0.01121577f, 0.03292382f, 
    -0.06364487f, 0.03776616f, -0.03001861f, -0.04245458f, 0.01669725f, 0.00456438f, -0.03864188f, -0.04901705f, 
    0.05120153f, -0.01720889f, 0.03316361f, -0.00133318f, -0.05642876f, 0.00056891f, -0.00672385f, -0.06123398f, 
    -0.05370315f, 0.01956782f, 0.02037995f, 0.04296695f, 0.02335935f, -0.05771489f, -0.02846536f, -0.04697637f, 
    -0.01429489f, 0.02289990f, -0.04866253f, -0.03134467f, -0.04016634f, -0.03124518f, -0.00275579f, -0.03997284f, 
    -0.01210642f, -0.03023616f, -0.02861105f, 0.02420369f, -0.00212511f, -0.04869614f, 0.01257884f, 0.04580214f, 
    0.02764166f, -0.03646900f, 0.02419916f, 0.03054362f, -0.01019586f, -0.06413072f, 0.03806484f, 0.01924349f, 
    -0.06317578f, -0.01155959f, -0.00011320f, -0.01064625f, -0.02359046f, -0.01998701f, 0.01161089f, 0.00617626f, 
    0.00773975f, -0.03427681f, 0.01621681f, -0.03878031f, 0.03587877f, 0.04349867f, -0.00965236f, -0.02579687f, 
    -0.05484632f, -0.02236683f, -0.02465012f, -0.06367754f, -0.04536433f, -0.03752824f, -0.01243512f, 0.03161445f, 
    -0.00520349f, 0.01615927f, -0.00751148f, -0.05047652f, -0.00325085f, 0.04290657f, -0.05690781f, 0.02896792f, 
    -0.04697216f, -0.01931030f, -0.02997198f, -0.03968249f, -0.05211210f, -0.01539096f, 0.02619147f, -0.05861669f, 
    -0.02500284f, -0.01478025f, 0.00408124f, -0.00249157f, 0.03533528f, -0.05988692f, 0.02465859f, 0.01633890f, 
    0.04140191f, -0.01911768f, 0.02330686f, -0.03608779f, -0.02687276f, 0.03628544f, 0.03446897f, 0.01178303f, 
    0.04630486f, -0.04871199f, 0.03994297f, -0.02320967f, -0.01788848f, -0.00987116f, 0.03841002f, -0.00973077f, 
    0.03920799f, -0.01250876f, 0.01324274f, -0.03819120f, -0.00780902f, -0.01778994f, 0.03352041f, -0.04806375f, 
    -0.00671520f, 0.00433817f, 0.04531294f, 0.00574343f, -0.01888968f, 0.01637742f, -0.02577785f, -0.02956242f, 
    0.00942069f, -0.01430894f, -0.02872696f, -0.05863095f, -0.06198419f, -0.00880689f, 0.01374122f, 0.00142541f, 
    -0.03425624f, -0.00105379f, 0.04594332f, -0.00811090f, 0.01038673f, 0.03570775f, 0.00712041f, 0.03436267f, 
    -0.00394641f, -0.05763222f, -0.05151753f, -0.03675534f, 0.02681048f, -0.06437726f, -0.03705649f, -0.04981877f, 
    0.01045770f, -0.00362857f, -0.00414003f, -0.01838573f, -0.01404060f, -0.02192198f, 0.02833477f, 0.02846052f, 
    -0.01528208f, -0.02532628f, 0.01161812f, 0.04259298f, 0.02698285f, -0.05383273f, 0.01751913f, 0.01272415f, 
    -0.02559534f, -0.03913289f, -0.01007287f, 0.00847564f, 0.04423498f, 0.03302041f, 0.02537584f, 0.02025987f, 
    -0.05949320f, -0.03187132f, 0.04204247f, 0.04389446f, 0.02934856f, 0.00538388f, 0.03366611f, 0.00238047f, 
    -0.02800717f, -0.04210707f, 0.01745141f, -0.04136142f, -0.01600222f, -0.03122356f, 0.02463630f, -0.00579867f, 
    -0.06116724f, 0.04769010f, 0.05181865f, 0.03419011f, 0.00805318f, -0.00477574f, -0.02656643f, -0.04497707f, 
    -0.01791138f, -0.04376312f, 0.02742849f, 0.01888625f, -0.05792071f, 0.04635041f, -0.03038467f, 0.04745223f, 
    -0.05107028f, 0.04189492f, 0.02875785f, -0.03684108f, -0.05139207f, 0.03339683f, -0.01751912f, -0.01399743f, 
    0.01358226f, 0.04743857f, -0.01048034f, 0.02708535f, -0.00564608f, -0.07024637f, -0.04273912f, -0.01304500f, 
    -0.04925950f, 0.00848205f, -0.03500885f, 0.00146157f, 0.01285585f, 0.00580064f, -0.06256686f, -0.06155303f, 
    -0.01435178f, -0.01621654f, 0.02495532f, 0.04472254f, -0.01476824f, -0.02319969f, 0.04454218f, 0.04952295f, 
    -0.02995239f, -0.02702555f, -0.04742761f, 0.04441033f, -0.02782952f, 0.00645546f, -0.04630465f, 0.04936648f, 
    0.02480902f, 0.01723122f, 0.01237638f, -0.04083708f, -0.00323464f, -0.00533020f, -0.03402097f, -0.02265313f, 
    0.02407785f, -0.04178986f, 0.02729719f, -0.01510845f, -0.03342017f, 0.01733672f, -0.06477068f, 0.04162571f, 
    -0.00174366f, -0.06656004f, -0.01373609f, 0.03230237f, -0.02256426f, -0.05027770f, -0.00452501f, 0.02081820f, 
    -0.01819945f, -0.01014695f, -0.04601733f, 0.04104740f, 0.02977035f, -0.03084908f, 0.03444296f, 0.02475290f, 
    0.00284606f, -0.04836393f, -0.06365168f, 0.01450043f, 0.01994132f, 0.01191176f, -0.02588966f, 0.03913477f, 
    -0.04142945f, -0.04065808f, -0.00161418f, -0.06413399f, 0.05047659f, -0.04720865f, 0.03272735f, 0.01520315f, 
    0.02622837f, -0.01250658f, 0.01919036f, 0.04489107f, 0.02534816f, -0.05181500f, 0.01998253f, -0.02359623f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.00503515f, 0.09514732f, 0.03610323f, -0.04792248f, 0.10414002f, 0.05465056f, 0.10502234f, -0.01386268f, 
    0.34218517f, -0.03115928f, -0.02728682f, -0.00706704f, -0.03511364f, -0.08325022f, 0.05713762f, 0.03275078f, 
    0.06836338f, -0.16724730f, 0.09662247f, 0.02662825f, 0.05472212f, 0.02934531f, -0.02821967f, 0.10038788f, 
    -0.05746248f, 0.16637997f, 0.00065703f, -0.19964465f, -0.07290708f, 0.14756264f, -0.00712507f, 0.01687583f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05665967f, -0.40282291f, 0.15279180f, 0.10916487f, 0.26375622f, -0.04657587f, -0.19029805f, -0.24626851f, 
    -0.19415316f, 0.03162304f, -0.75619972f, 0.14693014f, 0.30780891f, 0.31157890f, 0.53816080f, -0.12330139f, 
    -0.64159036f, 0.59678435f, 0.20292823f, -0.13185383f, -0.24152721f, -0.31913731f, -0.17710231f, -0.09985925f, 
    0.00619735f, 0.91115940f, 0.08975622f, 0.32039186f, -0.64110589f, -0.24000961f, -0.09906752f, -0.17084502f, 
    -0.13458614f, 0.13981029f, 0.46541563f, -0.02086491f, 0.12369784f, -0.61514550f, 0.26713058f, -0.37771016f, 
    -0.10231863f, 0.04032335f, -0.22676931f, -0.03820583f, -0.05648410f, -0.20926274f, -0.08808365f, -0.14537814f, 
    -0.07578674f, -0.09061483f, 0.03817900f, -0.15725555f, 0.46638829f, -0.22863266f, -0.04045141f, 0.10154293f, 
    -0.09190562f, 0.45706782f, 0.00689341f, -0.68442154f, 0.38792253f, -0.12064854f, 0.16430351f, 0.08506422f, 
    0.09089751f, -0.49827698f, 0.41170967f, -0.05008595f, -0.38576150f, 0.35082197f, -0.13625999f, 0.06713433f, 
    -0.36350763f, 0.18032244f, 0.05996418f, 0.12768306f, 0.36596164f, -0.39559680f, -0.64694095f, 0.15821354f, 
    0.23070575f, -0.50540328f, -0.47684437f, -0.12784919f, 0.95356643f, 0.39753586f, -0.12166505f, 0.05559708f, 
    -0.17824115f, -0.03359350f, 0.08598737f, 0.13749474f, -0.62412947f, -0.54764616f, 0.10504819f, 0.12116922f, 
    -0.09310348f, 0.01376348f, -0.33415118f, -0.14824332f, 0.35279062f, 0.03312508f, -0.55594414f, 0.20571983f, 
    0.16527048f, -0.00126716f, 0.12943181f, -0.12471215f, 0.37283635f, 0.93399924f, -0.17114308f, 0.16812021f, 
    -0.23868312f, -0.64159870f, -0.53359973f, -0.02995217f, 0.06938209f, 0.34366736f, 0.14979020f, -0.58533311f, 
    0.07137338f, -0.07673611f, 0.12910341f, 0.00775678f, 0.08654386f, -0.40452766f, 0.12116490f, 0.09141056f, 
    0.13580054f, -0.35609490f, -0.01417686f, 0.00938724f, 0.44904271f, -0.00356996f, 0.27722973f, 0.08419517f, 
    0.15012966f, 0.08193851f, -0.49472702f, -0.02358522f, 0.37707701f, -0.12617829f, 0.31460744f, -0.13840105f, 
    0.42529115f, -0.30295283f, -0.59131324f, -0.00254624f, -0.45871836f, -0.67057621f, 0.01904911f, 0.00814214f, 
    -0.03164646f, -0.26742083f, -0.14570631f, -0.02784603f, -0.25359902f, 0.43832263f, 0.15630221f, 0.07386444f, 
    -0.15866689f, 0.20604743f, 0.22226481f, -0.14875367f, -0.62096363f, -0.21374474f, -0.51138735f, -0.44430718f, 
    0.02905269f, -0.01976944f, 0.35108566f, 0.03843682f, -0.30717412f, -0.27925828f, 0.65702558f, 0.06689860f, 
    -0.64811546f, 0.09295223f, 0.38117188f, 0.02115259f, -0.45831871f, -0.25096241f, 0.06884429f, 0.26752773f, 
    0.04571246f, -0.38327160f, 0.03972862f, -0.24154863f, 0.49217874f, 0.38573405f, -0.00159158f, -0.04191745f, 
    0.16967727f, -0.34764031f, -0.49209365f, -0.04567438f, 0.27547324f, -0.29357263f, -0.36748847f, 0.03731983f, 
    0.22779888f, -0.08127366f, 0.83709449f, 0.14058526f, 0.13818295f, 0.22368258f, -0.28916621f, 0.13190909f, 
    -0.06510557f, -0.31581357f, 0.27892706f, -0.14073126f, -0.32837304f, -0.42885438f, -0.05644976f, 0.53644431f, 
    0.02034357f, -0.40239081f, -0.10131270f, 0.24755742f, -0.93190140f, -0.51081288f, 0.07609363f, 0.05782805f, 
    0.00179079f, 0.09749383f, -0.22626704f, 0.03097646f, -0.23913093f, -0.11308812f, 0.28482801f, -0.07789695f, 
    -0.40638241f, -0.07475454f, 0.05178983f, -0.16840626f, 0.10428267f, 0.17013198f, -0.12895568f, 0.18074544f, 
    -0.05590189f, 0.57838815f, -0.48178890f, -0.11565962f, -0.20930062f, -0.48194790f, 0.01354724f, -0.18180610f, 
    0.06755400f, -0.12606096f, -0.09350321f, 0.81203693f, 0.28020224f, -0.03458752f, -0.01343298f, -0.05991540f, 
    0.03717185f, 0.38420978f, 0.10798758f, 0.17019437f, -0.33276683f, 0.14984445f, 0.53755826f, -0.53742033f, 
    -0.47648451f, 0.02175430f, -0.04297969f, -0.00706487f, -0.70457780f, 0.02041432f, 0.02618149f, -0.03847156f, 
    0.09561425f, 0.03841960f, -0.10037460f, -0.15961386f, -0.27170825f, 0.90201712f, -0.15070356f, -0.01963288f, 
    -0.00116979f, -0.67989457f, -0.06645138f, 0.07009808f, -0.12810326f, 0.57346272f, -0.01322520f, 0.08492641f, 
    0.16818213f, -0.31796136f, -0.03713622f, 0.16020922f, 0.11812232f, 0.18773040f, -0.40121767f, 0.02774215f, 
    -0.12942460f, -0.11493615f, -0.28419167f, 0.03514796f, -0.12298522f, -0.26726291f, -0.25461546f, 0.07698214f, 
    0.84426737f, 0.09798007f, 0.77736562f, -0.15565687f, -0.66525471f, 0.61061746f, -0.02882184f, 0.04414163f, 
    0.10280836f, 0.23046006f, -0.02848977f, 0.10952186f, 0.05710619f, -0.46447361f, -0.13064399f, 0.10065934f, 
    0.06956126f, 0.21137014f, -0.55058903f, 0.07382467f, -0.16273747f, 0.33912414f, 0.17858195f, -0.36148733f, 
    0.59245563f, 0.09413046f, 0.15634336f, -0.10336148f, 0.08523282f, -0.23334561f, -0.54430348f, 0.13501979f, 
    -0.06467044f, -0.35134685f, 0.09659159f, 0.10782374f, 0.48658049f, -0.13763206f, -0.14736851f, -0.58850402f, 
    0.02120399f, -0.59119391f, 0.00119761f, -0.50484812f, 0.56881422f, 0.45507291f, -0.17988113f, 0.01463185f, 
    -0.07037830f, 0.70618105f, -0.14520593f, -0.15746342f, -0.29605633f, 0.40238163f, 0.21399717f, 0.56404811f, 
    0.36029807f, 0.03366395f, 0.01681709f, -0.05281662f, -0.49340954f, -0.18985546f, -0.59832168f, 0.03897300f, 
    -0.32126948f, 0.16569431f, -0.30022758f, -0.13307215f, -0.32253543f, -0.04103798f, 0.11878181f, 0.17204055f, 
    0.07583074f, -0.42995402f, 0.06050737f, -0.43027642f, -0.51282775f, -0.33509064f, -0.01609680f, -0.16790915f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09130442f, -0.11249790f, -0.08194170f, -0.03331352f, -0.01487453f, 0.13957658f, 0.15609282f, -0.48981148f, 
    -0.20272657f, -0.04249933f, 0.23433511f, 0.26478562f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
