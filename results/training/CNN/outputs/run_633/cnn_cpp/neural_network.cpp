#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.28806648f, -0.87805915f, -0.72999269f, -0.11982861f, -0.32251447f, -0.86121446f, 0.71221775f, 0.50321722f, 
    -0.46956858f, 0.59508258f, 0.05856925f, 0.31923553f, 0.10169408f, -0.28112584f, 0.16080670f, -0.10162862f, 
    0.01651478f, 0.06733098f, 0.16228284f, -0.25619134f, 0.04154139f, -0.17871810f, 0.04928899f, -0.17138115f, 
    -0.02500113f, -0.83882785f, 0.15189505f, 0.84840101f, -0.59000075f, 0.54692113f, 0.73119152f, -0.06324200f, 
    0.10306334f, -0.38399068f, -0.92168558f, 0.31119815f, 0.05958501f, -0.00432604f, -0.07732239f, -0.37353644f, 
    -0.05177721f, -0.03381866f, -0.12563255f, -0.32256833f, -0.05418576f, -0.22308989f, 0.04821130f, -0.09986881f, 
    0.00568933f, 0.23291148f, -0.25466430f, -0.64026171f, -0.88009858f, -0.57522541f, -0.12773348f, -0.53044081f, 
    0.07434846f, 0.01393431f, 0.30419773f, 0.57621413f, 0.47825208f, -0.42910552f, 0.33276159f, -0.29785302f, 
    -0.20206499f, -0.06126156f, 0.10315775f, 0.09254069f, -0.21038021f, 0.16252427f, 0.04698418f, 0.02786028f, 
    -0.23077627f, 0.32586205f, -0.01367863f, -0.90505564f, -0.26316318f, -0.12293419f, 0.44642413f, 0.29104272f, 
    0.51683718f, 0.85187936f, 0.33386108f, 0.01636805f, 0.39674288f, -0.03468651f, -0.34996238f, 0.39811900f, 
    0.15449393f, 0.06505591f, 0.09627043f, -0.07325409f, -0.20940994f, -0.00858939f, -0.12591167f, 0.03330978f, 
    0.15390874f, 0.01369316f, 0.32154191f, -0.22504513f, 0.96485031f, 0.20899700f, 0.33736366f, 1.03122115f, 
    0.60352260f, -0.24184270f, 0.43229851f, 0.12931089f, 0.14801550f, -0.00549193f, -0.23164608f, -0.11379855f, 
    -0.20588444f, 0.20264126f, 0.05721329f, -0.25881428f, -0.08702986f, 0.01452483f, -0.08271009f, 0.08996549f, 
    0.01211788f, 0.26984027f, -0.37291232f, 0.13653348f, -0.19410427f, 0.15005691f, -0.38444263f, -0.27732190f, 
    -0.44593704f, 0.25999343f, 0.78307605f, 0.36536098f, 0.21504538f, 0.54202944f, 0.20784730f, -0.45186892f, 
    -0.11049104f, 0.05896735f, -0.62213677f, -0.38660768f, -0.12651363f, 0.03093810f, -0.06572244f, 0.14174768f, 
    -0.14724711f, 0.04190611f, -0.28871602f, -0.49741212f, 0.23945691f, 0.01303444f, -0.64183724f, 0.19165604f, 
    -0.37313649f, -0.92032945f, -0.20698236f, 0.24992539f, 0.24141894f, 0.42512903f, 0.09857388f, 0.05575718f, 
    -0.40697891f, -0.02726225f, -0.02342383f, -0.01414548f, -0.35842279f, 0.34984931f, -0.15287076f, -0.19165073f, 
    0.27710456f, 0.40881473f, -0.14206111f, 0.03560932f, -0.01110234f, 0.05030178f, 0.34077531f, -0.16929530f, 
    -0.37574548f, -0.40554667f, -0.25738490f, -0.24715655f, 0.44786716f, 0.71054846f, -0.46003255f, 0.31555602f, 
    0.55755043f, -0.04179064f, -0.17497554f, -0.22576956f, -0.01453349f, -0.30369341f, -0.19535333f, 0.28141597f, 
    -0.07910257f, -0.22834705f, -0.18781281f, 0.01004624f, -0.21162078f, -0.22288908f, 0.00435717f, -0.08830108f, 
    0.56751829f, 0.36265913f, 0.06360946f, 0.79186505f, 0.71945292f, 0.68377900f, 0.31837603f, 0.21536864f, 
    -0.24294510f, 0.19501035f, -0.34383810f, -0.43482921f, -0.03040028f, 0.01109993f, 0.08620987f, -0.12909676f, 
    0.00367370f, -0.08429150f, -0.08551493f, -0.11676660f, -0.28128165f, -0.22013153f, -0.15455356f, -0.27961153f, 
    -0.33207336f, 0.16145682f, -1.00711977f, 0.51564336f, 0.65723538f, 0.72222316f, 0.07273977f, 0.58497709f, 
    -0.22150829f, -0.17056300f, 0.37314591f, 0.18279132f, 0.28877226f, -0.19100569f, 0.09692958f, 0.14214434f, 
    -0.17549385f, -0.29591909f, -0.28684619f, -0.19988483f, 0.07890322f, 0.16105188f, 0.23698495f, 0.25383520f, 
    0.23890220f, -0.13536817f, 1.15083444f, -0.28957155f, 0.61801249f, -0.03459086f, -0.42600262f, -0.24246933f, 
    -0.30764437f, -0.10125389f, 0.77021092f, 0.04058198f, 0.03762682f, 0.05745297f, -0.12703854f, -0.23450984f, 
    -0.00542652f, 0.20831898f, 0.13343595f, 0.27501827f, -0.08787090f, -0.09455957f, -0.12180109f, -0.04415352f, 
    -0.09243035f, -0.08013074f, 0.13567273f, -0.57058847f, -0.80444431f, 0.59991878f, 0.18364473f, -0.48148409f, 
    0.34884331f, -0.22317004f, 0.15166885f, 0.31291875f, -0.26606771f, 0.34091398f, -0.30427828f, 0.09419551f, 
    0.41513786f, -0.43725619f, 0.21371990f, 0.20147714f, -0.14315742f, 0.03601513f, 0.29303440f, -0.07234235f, 
    -0.01839017f, 0.24719501f, -0.04696354f, 0.24957098f, 0.98522276f, 0.38300043f, -0.60963243f, -0.62500495f, 
    -0.37077382f, -0.34345478f, -0.05879982f, 0.04668276f, 0.06908107f, -0.16583210f, -0.32131147f, 0.28863803f, 
    -0.16960412f, 0.13827080f, -0.26900417f, 0.25641555f, -0.16661575f, -0.23734075f, -0.38619009f, 0.36772665f, 
    -0.28597292f, 0.03310265f, 0.01731513f, 0.14169133f, -0.30850106f, 0.11411023f, -0.30291218f, -0.46043611f, 
    -0.23817249f, -0.12574708f, 0.04722285f, -0.55215478f, -0.55553240f, -0.21213914f, -0.49444821f, -0.60421050f, 
    0.12525102f, 0.20699231f, -0.17996506f, -0.04069694f, -0.47043765f, -0.18993197f, -0.48034936f, -0.35005891f, 
    -0.06845318f, 0.22479790f, 0.07486942f, 0.18747778f, -0.38410038f, -0.26947194f, 0.13057518f, 0.97183371f, 
    0.53967714f, 0.42847294f, 0.51567703f, 0.00551399f, -0.16958962f, 0.13962995f, -0.79329813f, -0.33444074f, 
    -0.01820379f, -0.38784865f, 0.02897851f, -0.17014533f, -0.41200703f, -0.28540155f, -0.06599800f, 0.08445219f, 
    -0.05428750f, -0.23887286f, 0.10059332f, -0.12608767f, 0.13865957f, -0.17688316f, 0.30218616f, 0.60679430f, 
    -0.18674845f, -0.88142687f, 0.12410722f, -0.31711844f, -0.33796269f, 0.21627137f, -0.42003295f, 0.31083536f, 
    -0.38657889f, -0.32282481f, -0.22673622f, -0.00817037f, 0.42170051f, -0.18822026f, 0.05079336f, 0.10689227f, 
    -0.10047296f, 0.22138657f, 0.08953666f, 0.37045982f, -0.09941985f, -0.25833642f, 0.13279368f, 0.01417833f, 
    -0.83121741f, 0.37894562f, -0.12567797f, -0.35455853f, -0.21538804f, 0.09904265f, 0.74947041f, -0.20270725f, 
    -0.17376749f, -0.15346536f, -0.04259077f, -0.18933141f, -0.04821141f, -0.31560263f, 0.18002032f, -0.00431294f, 
    -0.56050056f, 0.05915033f, -0.04691049f, -0.50607383f, 0.04002262f, -0.14868285f, 0.24779862f, 0.38355950f, 
    0.35313392f, -0.99239451f, -0.26129287f, 0.14545444f, -0.04502121f, 0.68871331f, 0.87460297f, -0.03072564f, 
    -0.47602710f, 0.05355580f, -0.57097954f, 0.26722097f, 0.18017957f, -0.15494812f, 0.52816600f, -0.26738605f, 
    -0.16268396f, -0.18605231f, -0.24316999f, -0.24210162f, 0.18514284f, 0.02931077f, -0.05192068f, 0.04877844f, 
    -0.09241892f, -0.18372120f, 0.52439278f, 0.36985534f, 0.46512935f, 0.57604653f, 0.79326224f, 0.00345525f, 
    -0.74976039f, -0.40565419f, -0.54552084f, -0.08360327f, 0.31743038f, 0.24268815f, -0.05301008f, -0.02656337f, 
    0.10162367f, -0.16424897f, 0.32502365f, 0.14434120f, 0.00508330f, 0.43464804f, 0.37364677f, 0.06975799f, 
    0.01626733f, 0.16661167f, 0.34247005f, 0.54559410f, -0.63891965f, -0.64446002f, 0.37762165f, 0.20330934f, 
    0.23850267f, 0.62205547f, -0.04618635f, 0.67484349f, 0.10585933f, -0.08901802f, -0.04017973f, -0.49546903f, 
    0.11534186f, -0.31557029f, 0.18386939f, 0.03510143f, -0.46984011f, 0.27125490f, -0.13759430f, -0.30874237f, 
    -0.34924814f, 0.07712862f, -0.06482606f, 0.04533955f, -0.57415980f, 0.12455148f, -0.37532035f, -0.67863005f, 
    -0.67286128f, 0.04739385f, -0.16464902f, 0.11605563f, -0.10769345f, -0.25929916f, 0.50383812f, 0.17275266f, 
    0.22307673f, 0.31981513f, 0.10199717f, -0.00339994f, 0.19914463f, 0.15084508f, -0.21402563f, 0.50625515f, 
    0.11664881f, 0.03522576f, -0.42821029f, 0.29545552f, -0.07310238f, -0.27472287f, -0.95243442f, 0.19861075f, 
    0.57885087f, -0.64381522f, 0.30455816f, -0.15342011f, 0.53025854f, -0.40591899f, 0.01806805f, -0.11925101f, 
    -0.42579603f, -0.40015823f, -0.06311755f, 0.14194803f, 0.18236339f, 0.41429108f, 0.08270647f, -0.30053395f, 
    0.14247829f, 0.09734015f, 0.06990157f, 0.33849987f, -0.22196293f, -0.08276986f, -0.58122486f, -0.41253641f, 
    0.31851631f, 0.24979268f, -0.56938869f, -0.61430877f, -0.36985099f, 0.28585184f, -0.14888948f, 0.32287776f, 
    -0.05831099f, 0.55611074f, 0.04794266f, 0.13989544f, -0.42836064f, 0.13846572f, 0.14149709f, 0.25912949f, 
    -0.29763019f, -0.62614936f, -0.15985532f, -0.32910892f, 0.00751115f, -0.29468086f, -0.20579056f, -0.68670553f, 
    -0.20326985f, -0.06819717f, 0.09456940f, 0.48660964f, -0.15249731f, 0.53316265f, 0.46558088f, -0.70033610f, 
    -0.08433676f, 0.49425966f, 0.06212050f, -0.05956984f, -0.46756756f, 0.02481575f, -0.43706459f, 0.20982444f, 
    0.22070001f, 0.34804374f, 0.21010293f, -0.06354695f, -0.13283578f, 0.01937266f, 0.11101643f, 0.32656500f, 
    0.13154361f, -0.01617425f, 0.63165182f, 0.49349010f, 0.42632711f, -0.68448621f, -0.34998515f, -0.41505560f, 
    0.03995818f, -0.54901874f, 0.09632088f, -0.04882758f, -0.06924447f, 0.50516039f, -0.09613714f, 0.25227940f, 
    -0.05767011f, 0.17236644f, -0.15786527f, 0.20910928f, -0.38106531f, -0.24703982f, 0.09878362f, -0.23916662f, 
    -0.15210481f, -0.41421464f, 0.06464878f, -0.71689540f, 0.61755919f, -0.00195319f, 0.25680125f, -0.00765410f, 
    -0.19622768f, -0.33759445f, -0.65939903f, -0.20696972f, 0.06218213f, 0.05188958f, -0.01687927f, 0.33521393f, 
    0.33944768f, -0.01450501f, 0.08844315f, -0.07131416f, 0.28040254f, 0.32870972f, 0.23304865f, -0.00949086f, 
    0.49773425f, -0.14341433f, 0.50127721f, 1.02704573f, 0.18920366f, 0.28005335f, -0.33838886f, 0.04260018f, 
    0.31115860f, 0.15686433f, -0.17096332f, 0.59794790f, -0.18752484f, 0.40060163f, 0.18924427f, -0.13090619f, 
    -0.18098168f, -0.14013596f, -0.28723630f, -0.13656238f, -0.08639022f, -0.25427625f, -0.25039238f, 0.11124275f, 
    -0.12548998f, -0.07835588f, -0.15235040f, -0.10291904f, 0.59156877f, 1.19703054f, 0.16976671f, -0.19306588f, 
    0.24806871f, 0.51474184f, -0.38734522f, -0.44835222f, -0.15797636f, 0.20868464f, 0.40852347f, -0.09135992f, 
    -0.05916763f, -0.08868600f, 0.35676062f, 0.15202713f, 0.19996734f, -0.13399282f, 0.13262022f, 0.07272334f, 
    0.02294432f, 0.20415105f, -0.17937249f, 0.04275196f, 0.74603665f, 0.15160665f, 0.29010668f, 0.84917516f, 
    -0.35358670f, 0.52717650f, 0.26320639f, 0.04947624f, 0.57124406f, -0.25403076f, -0.37438884f, -0.22953476f, 
    0.15749004f, 0.01077290f, 0.11866631f, -0.21720064f, -0.30989164f, -0.18919900f, 0.35146913f, 0.24623276f, 
    -0.24010693f, -0.21365076f, 0.16516064f, 0.07195717f, -0.11352067f, -0.09904032f, -0.83457375f, 0.43181351f, 
    0.61576939f, -0.41395989f, -0.60422403f, 0.08647034f, 0.25811064f, -0.47311351f, -0.11139490f, 0.22468211f, 
    0.33132729f, 0.04581158f, 0.09634983f, 0.08939789f, 0.44233233f, 0.17655061f, -0.12877958f, -0.00299377f, 
    -0.22207065f, -0.00690451f, -0.09691002f, 0.05287668f, 0.31373227f, 0.24982417f, -1.06282389f, -0.27134252f, 
    -0.12787718f, 1.08750916f, -0.27670878f, 0.60579091f, 0.58577865f, -0.05503579f, 0.10052513f, -0.59288877f, 
    0.10684652f, 0.16671424f, -0.17126365f, 0.13292697f, 0.33434004f, -0.19140431f, 0.19808507f, 0.14922397f, 
    -0.17693129f, 0.02110035f, -0.10123376f, 0.01621692f, 0.05198761f, -0.02737334f, -0.08347511f, -1.05244112f, 
    0.63787085f, 0.20993699f, -0.68449050f, -0.53987223f, 0.62661707f, 0.04767838f, -0.48570961f, 0.00102906f, 
    -0.45536649f, -0.19072857f, 0.26635450f, 0.01549101f, 0.25340286f, -0.06567132f, -0.37397492f, 0.05552618f, 
    -0.29986539f, -0.32152313f, -0.15744156f, 0.25948134f, 0.22195859f, 0.13311800f, 0.20626424f, 0.06333280f, 
    0.76110542f, 0.79786462f, -0.77369589f, -0.39226052f, -0.67081308f, 0.24052563f, 0.33734214f, -0.39260906f, 
    -0.14934938f, -0.51131165f, 0.41189387f, 0.31509387f, 0.36156428f, 0.03420677f, -0.29532248f, 0.15501858f, 
    -0.08009878f, 0.05872434f, 0.25298586f, -0.22407623f, -0.01405045f, -0.19215474f, 0.28956556f, 0.00047801f, 
    0.08328264f, 0.92499733f, 0.22514859f, 0.40879878f, 0.64934456f, 0.58087623f, -0.28676924f, 0.32808214f, 
    -0.37007585f, 0.37302661f, 0.33934161f, -0.17353076f, -0.13854896f, 0.37401688f, 0.11031437f, 0.05196491f, 
    0.22658123f, 0.34712189f, 0.16159618f, -0.17821752f, -0.17927051f, -0.12900403f, -0.15852495f, -0.28332561f, 
    0.01326657f, 0.16957191f, 0.64078027f, 0.88915169f, 0.62446117f, -0.06605227f, 0.65561962f, -0.40239584f, 
    -0.40030292f, -0.53598326f, 0.12465170f, -0.31957823f, -0.21335553f, 0.04496982f, 0.25500125f, 0.09552090f, 
    0.24819785f, 0.02537068f, 0.12283833f, 0.15426266f, -0.03617693f, 0.18905382f, 0.31535876f, 0.24095146f, 
    -0.04515697f, 0.11310147f, -0.06352270f, 0.19544953f, -0.39809561f, 0.06561871f, 0.27994728f, -0.45057082f, 
    0.36008039f, 0.64627588f, 0.18917316f, 0.24157999f, 0.61124533f, -0.15238656f, -0.38590991f, -0.42476994f, 
    -0.41121221f, 0.01788287f, -0.39658993f, 0.11240672f, -0.09622826f, 0.12299277f, -0.21007068f, 0.17933911f, 
    0.12429432f, -0.04114533f, -0.22412829f, 0.28048179f, 0.06709377f, 0.03954849f, 0.46492997f, 0.36101374f, 
    -0.08219185f, -0.06144915f, -0.18881050f, -0.47356579f, 0.42474189f, 0.73484319f, -0.50836533f, 0.22643143f, 
    -0.46183363f, 0.39618716f, -0.47151664f, 0.25255707f, 0.18056473f, 0.38591748f, -0.22984254f, -0.11370266f, 
    -0.13255292f, 0.13536365f, 0.07241841f, -0.28430653f, 0.19983298f, -0.20999528f, 0.35855243f, 0.09586993f, 
    -0.88264680f, -0.58078206f, 0.06104755f, -0.18744361f, -0.69547409f, -0.68916619f, -0.09665945f, -0.02190040f, 
    0.11833408f, 0.41362655f, -0.00709081f, 0.41007212f, 0.28046015f, -0.05156755f, 0.24046186f, 0.05339712f, 
    0.11828613f, 0.39643264f, 0.15405780f, -0.12582362f, -0.18723890f, 0.28270558f, 0.36378670f, -0.02382804f, 
    -0.30147150f, -0.04355842f, -0.40443802f, 0.65354693f, 0.49087125f, 0.25302419f, 0.59185207f, 0.43657050f, 
    0.20805168f, 0.32046217f, 0.17920920f, 0.11807694f, 0.25558770f, -0.15619464f, 0.15007192f, 0.05563869f, 
    0.28608429f, -0.14006397f, 0.00872802f, 0.13815247f, -0.22626480f, 0.22170450f, 0.25659323f, -0.24777715f, 
    -0.63939589f, -0.06372928f, 0.52532977f, 0.16843414f, 0.09843823f, -0.10468324f, 0.25210604f, -0.61731195f, 
    -0.28426367f, -0.29463106f, -0.08279122f, -0.01257874f, 0.41045213f, 0.24010184f, 0.01036756f, -0.10277417f, 
    -0.04283411f, -0.51278645f, 0.40703276f, -0.41382927f, -0.10430593f, -0.40813980f, -0.13292676f, -0.09643576f, 
    0.61156267f, 0.39515278f, -0.57770807f, -0.21399662f, -0.46424475f, -0.30164406f, -0.68298596f, -0.06431875f, 
    -0.27009234f, -0.29062834f, 0.45451394f, -0.34970534f, 0.41162625f, 0.34594771f, -0.12775917f, 0.34283200f, 
    0.27823210f, -0.53314620f, -0.31379935f, 0.25262478f, -0.14634329f, 0.46123460f, 0.50835162f, 0.11668628f, 
    -0.11878730f, -0.79318100f, -0.32506323f, 0.57545400f, 0.57801896f, 0.29553592f, 0.32679439f, 0.47386670f, 
    0.67068118f, -0.17529994f, -0.13416323f, -0.46835056f, -0.40778229f, 0.24486439f, 0.34682441f, 0.15662046f, 
    0.07684832f, 0.23227726f, -0.14211936f, 0.09820908f, 0.18029560f, 0.05164205f, 0.14019027f, 0.16617616f, 
    0.05974688f, -0.39239493f, -0.07047550f, -0.40677470f, -0.48443821f, -0.49496287f, -0.19780466f, 0.70299929f, 
    0.05484730f, -0.53887391f, -0.17308328f, -0.20953223f, -0.42054474f, -0.36742863f, 0.25033724f, -0.30191562f, 
    -0.10686358f, -0.35078898f, 0.00282638f, 0.16620548f, -0.02385972f, -0.36407644f, 0.15242119f, -0.35555473f, 
    0.26314816f, 0.34666300f, -0.06597963f, 0.48713890f, -0.74050826f, -0.17332286f, 0.31165841f, 0.69585073f, 
    -0.62668633f, -0.70307660f, -0.53497982f, -0.64580578f, 0.10113967f, -0.20238255f, 0.44476217f, 0.12935606f, 
    0.18584102f, -0.30038977f, -0.37279931f, -0.04953058f, 0.01176883f, 0.13597214f, -0.39663798f, -0.10606128f, 
    0.08450820f, 0.08719026f, -0.15162177f, 0.09967288f, -0.33209327f, 0.59366727f, -0.34884718f, -0.84661818f, 
    -0.35487315f, 0.41777158f, -0.36756852f, -0.06051511f, 0.25253630f, 0.27988493f, 0.17526007f, 0.31941527f, 
    0.10845008f, -0.08050719f, -0.19956198f, 0.10215341f, 0.42083716f, 0.15234664f, 0.07479602f, 0.18090804f, 
    -0.19165559f, -0.19875695f, 0.19469807f, -0.17266394f, 0.36901924f, 1.10507524f, 0.33227235f, -0.57423121f, 
    1.02497208f, 0.42752078f, 0.20756502f, -0.12828451f, -0.04919837f, 0.17526515f, 0.20407276f, -0.25043091f, 
    0.19775620f, 0.24827896f, 0.01295121f, -0.11434336f, 0.11337721f, -0.37813953f, 0.35135236f, 0.06263161f, 
    -0.05815612f, 0.04261152f, -0.15412481f, 0.02011214f, 0.21402185f, 0.02236307f, 0.99448800f, 0.33455190f, 
    -0.14493176f, -0.16498250f, -0.25663722f, -0.52686137f, -0.21268994f, 0.62723023f, -0.06841920f, -0.02668664f, 
    -0.19473545f, 0.05445804f, 0.01515160f, -0.13520233f, -0.06928333f, -0.15476140f, -0.15974787f, -0.13538787f, 
    0.36726269f, 0.03545240f, 0.23923026f, -0.30346519f, -0.03211692f, -0.55180126f, 0.01956112f, -0.87548596f, 
    0.31315088f, -0.00144890f, -0.65263844f, -0.68290418f, 0.70924693f, 0.12165581f, -0.40963179f, 0.41556197f, 
    0.48745343f, 0.19797303f, -0.38168120f, -0.24874182f, -0.04653835f, 0.03894902f, -0.13524170f, -0.16326874f, 
    -0.17139474f, 0.04398974f, -0.11623913f, -0.04019864f, -0.01944015f, 0.24021566f, 0.16927874f, 0.12545142f, 
    0.45246905f, -0.51003712f, 0.00687718f, 0.86703408f, 0.41372907f, -0.51338440f, -0.60534436f, -0.06833829f, 
    -0.18010533f, 0.28472903f, 0.50325954f, -0.27143034f, -0.15094103f, -0.17645124f, 0.08183970f, 0.40283060f, 
    0.01959476f, 0.39535111f, -0.33706972f, 0.57884175f, -0.11216088f, -0.24891241f, 0.24975818f, -0.34703434f, 
    -0.08645470f, 0.65833801f, 0.37700862f, -0.34326297f, -0.55061859f, -0.33317378f, 0.59196210f, -0.08301146f, 
    -0.41211891f, 0.46681491f, 0.34811836f, -0.50509053f, 0.26030207f, 0.08763575f, 0.11283308f, -0.16272932f, 
    -0.05095814f, -0.08699606f, -0.30703235f, 0.05212639f, 0.35646862f, 0.13273409f, 0.02106462f, 0.12732801f, 
    0.18913527f, 0.29722813f, 0.48612404f, 0.58896691f, 0.80560589f, -0.02193269f, 0.07062658f, -0.24326210f, 
    -0.39518940f, 0.34087858f, -0.32343245f, -0.37514848f, 0.37276995f, -0.07152321f, -0.31588364f, 0.42141661f, 
    -0.17547363f, 0.20941974f, -0.04670361f, 0.07035864f, 0.17070307f, -0.47532088f, 0.16344866f, 0.08986571f, 
    0.22167097f, 0.33563158f, 0.02162245f, -0.61996448f, 0.54866248f, 0.80243731f, -0.18424028f, 0.41328904f, 
    0.78800398f, 0.33171409f, 0.33790651f, 0.25146267f, 0.14194961f, -0.42320213f, -0.24008010f, -0.58483374f, 
    -0.05921470f, -0.19957435f, -0.01565875f, -0.07338341f, -0.12419561f, 0.25432336f, 0.05784351f, 0.05521205f, 
    0.34115338f, 0.26026791f, 0.05742737f, -0.20078041f, 0.78054523f, 0.19820121f, 0.25575963f, -0.63550013f, 
    -0.61660206f, 0.53463262f, 0.22367769f, 0.63328773f, 0.54790604f, 0.54793996f, 0.24615231f, -0.49601281f, 
    -0.34556916f, -0.26184407f, -0.22466266f, -0.09079062f, 0.03551025f, -0.13493627f, -0.11012620f, -0.03849578f, 
    0.00152422f, 0.00985112f, -0.07791351f, -0.39197499f, -0.34092239f, -1.16111207f, 0.80478656f, 1.00101030f, 
    -0.49031067f, -0.01224570f, 0.31301138f, 0.57492214f, 0.31253621f, 0.52381128f, -0.19340710f, -0.24679962f, 
    -0.15048668f, 0.13337544f, 0.11052117f, 0.08675861f, -0.15680969f, -0.29306638f, -0.24567404f, -0.08727614f, 
    0.01944469f, 0.03331387f, 0.28918704f, -0.08976416f, 0.23630361f, -0.01042296f, -0.75541794f, -0.30398288f, 
    0.29997683f, -0.27657920f, -0.58830541f, -0.23262282f, 0.03045800f, 0.08891558f, -0.33137193f, -0.02281844f, 
    -0.18863489f, 0.36523187f, -0.28990054f, 0.17379899f, -0.06868859f, -0.05916885f, 0.07245261f, 0.18568097f, 
    0.33662739f, 0.03254420f, 0.38233596f, -0.15138638f, 0.23059900f, 0.30278847f, -0.28947887f, 0.99181896f, 
    1.06054771f, -0.33995858f, -0.50275755f, -0.04487957f, -0.01852523f, 0.39714378f, -0.61512423f, 0.50017804f, 
    0.32502016f, 0.24872939f, -0.15493751f, -0.19487038f, -0.35950199f, -0.15897274f, -0.12452923f, -0.37574431f, 
    -0.14821160f, 0.21514869f, 0.12985271f, -0.38152942f, 0.12655380f, -0.09629267f, 0.01171373f, -0.11978602f, 
    -0.82018965f, 0.04578880f, -0.31244636f, 0.01820551f, 0.19076027f, -0.70199192f, -0.41621664f, -0.06586954f, 
    -0.23702472f, -0.78864241f, -0.20201598f, 0.34548408f, 0.13282120f, 0.31856722f, 0.37533420f, -0.25196540f, 
    -0.31346571f, -0.22143503f, -0.12890022f, 0.21838766f, 0.42886305f, 0.09299156f, 0.22360091f, -0.01729032f, 
    0.26269802f, 0.77612215f, -0.71134758f, 0.36987683f, 0.41203070f, 0.29075843f, 0.44630927f, -0.51664442f, 
    0.05596504f, -0.07186578f, 0.09818903f, -0.24488452f, 0.03274162f, -0.66671282f, 0.06213647f, 0.26613539f, 
    0.36162260f, -0.39325774f, -0.34690085f, 0.19731928f, -0.12404935f, -0.13896987f, -0.18659903f, -0.30676687f, 
    -0.32623339f, 0.10257277f, -0.18880217f, -1.21948373f, -0.14822507f, -0.06392016f, -0.38745540f, 0.45733735f, 
    0.69497353f, 0.66081971f, -0.58535337f, 0.09000608f, 0.04845291f, -0.41421536f, -0.31405857f, -0.15768197f, 
    0.04534238f, -0.32288897f, -0.00930635f, -0.25130960f, 0.04747466f, -0.06084104f, -0.11288601f, 0.16091797f, 
    0.11754782f, -0.04300029f, 0.12521273f, -0.64324617f, -1.15064275f, -0.43558955f, -0.20024228f, -0.00786945f, 
    -0.68593287f, 0.32056162f, 0.60621935f, -0.35305843f, -0.25989747f, 0.23947290f, -0.16426811f, -0.00321274f, 
    0.44062936f, 0.26591879f, 0.12223104f, 0.07991766f, -0.10854907f, -0.08543157f, -0.21174893f, -0.10523347f, 
    -0.20638874f, 0.10083758f, -0.00349023f, -0.12760413f, 0.65998310f, -0.04419083f, -1.07363653f, 0.13618317f, 
    -0.37092876f, -0.15558812f, 0.56063759f, -0.31214383f, 0.38234797f, 0.19752625f, 0.25846344f, 0.15233047f, 
    -0.27973396f, 0.17398770f, 0.14320984f, 0.03970530f, -0.00486840f, 0.22560126f, -0.21201436f, 0.25379249f, 
    -0.00754974f, 0.28666884f, 0.33735308f, 0.24893795f, -0.07291509f, -0.15920030f, 0.26557371f, 0.16499518f, 
    -0.25181603f, 0.61483824f, -0.21377255f, -0.45506299f, -0.00057348f, -0.29118434f, -0.69698566f, 0.15398894f, 
    -0.09166384f, 0.34037694f, 0.29462010f, 0.25792584f, 0.27333146f, 0.26301497f, -0.44140190f, 0.44485182f, 
    0.32876429f, -0.28687254f, 0.03198931f, -0.20971708f, 0.35634014f, -0.02472951f, -0.60071945f, 0.02526858f, 
    -0.76954722f, -0.56444347f, 0.02498983f, 0.25606632f, 0.58637035f, 0.31852436f, -0.18639438f, 0.65221655f, 
    0.32171607f, -0.41422817f, -0.02516490f, -0.51209909f, 0.61849737f, -0.02619098f, 0.09456179f, 0.03193720f, 
    0.23713639f, 0.04879854f, -0.20240071f, -0.09141283f, 0.01709065f, -0.05221111f, -0.04151094f, 0.23090035f, 
    0.51927948f, 0.71409327f, 0.41773379f, 0.35955411f, -0.69473237f, -0.30554637f, -0.62208623f, -0.73841131f, 
    0.12286157f, 0.18075512f, 0.59186310f, -0.11898282f, -0.18007967f, -0.11613936f, -0.19829039f, -0.32334656f, 
    0.03196237f, -0.12750188f, -0.09904801f, 0.09009847f, 0.12862043f, 0.01298837f, 0.13592428f, 0.02086536f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02001534f, 0.21078230f, 0.18422772f, 0.14416747f, 0.07913671f, -0.00697057f, -0.04342934f, -0.02138105f, 
    0.09831923f, 0.13124987f, 0.20849086f, 0.28436929f, -0.07818261f, 0.25085548f, -0.11922088f, 0.34165248f, 
    0.08367977f, 0.14383258f, 0.10449700f, -0.00884693f, 0.06782827f, -0.02945679f, 0.22281590f, -0.02975641f, 
    0.07891300f, 0.06181244f, 0.14962545f, 0.14617345f, 0.18912145f, 0.29932204f, 0.18960819f, 0.18633927f, 
    0.05407216f, 0.25335470f, 0.06869145f, -0.04632827f, -0.00541298f, 0.30824089f, -0.00683087f, 0.09263031f, 
    0.02982882f, 0.09896913f, 0.26462239f, 0.23173656f, 0.26958570f, 0.24274828f, -0.01381595f, -0.00554718f, 
    -0.03193425f, 0.15969673f, 0.01629094f, -0.06706572f, -0.11526591f, 0.09530608f, 0.11788545f, 0.06209305f, 
    0.11774959f, 0.03419317f, 0.22916389f, 0.19389610f, 0.29695114f, 0.23828036f, -0.03480847f, 0.20029683f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.56427264f, -0.15641640f, -0.01681296f, -0.05419038f, 0.03865173f, -0.07278601f, -0.07696111f, -0.07674394f, 
    0.03506504f, -0.01534744f, 0.09388275f, -0.00222604f, -0.39274722f, 0.00156327f, 0.19071828f, -0.15782812f, 
    0.01628129f, 0.04601619f, -0.01304438f, -0.14957517f, -0.00403625f, -0.03524625f, 0.05689916f, -0.06575850f, 
    -0.13710792f, 0.07437443f, -0.15240605f, -0.25572410f, -0.02399168f, 0.09379473f, 0.03310480f, 0.02698112f, 
    -0.07425070f, -0.04472402f, 0.05630895f, 0.02876356f, 0.12137130f, 0.13653477f, 0.07566632f, -0.02620145f, 
    -0.00935086f, 0.09249510f, -0.12011798f, -0.09111387f, 0.05847134f, -0.02942700f, -0.01115390f, -0.11890054f, 
    0.25616169f, -0.03406407f, -0.20506647f, 0.29772258f, -0.15250361f, 0.00651008f, -0.03933321f, 0.01873693f, 
    -0.04879794f, -0.08545253f, 0.00957990f, -0.04484627f, 0.14132322f, 0.11375913f, -0.02577433f, -0.10352492f, 
    0.05888420f, 0.12697937f, 0.01465865f, 0.03116027f, -0.01976448f, -0.02213188f, -0.11364021f, 0.06411166f, 
    0.19087870f, 0.01085281f, -0.07573915f, -0.30971399f, -0.04823007f, 0.00195279f, 0.14206000f, 0.06176926f, 
    -0.01743399f, 0.03329740f, -0.04266358f, -0.06027254f, 0.18782875f, 0.08532315f, 0.02408395f, -0.11047688f, 
    0.00716509f, 0.07172813f, -0.00626486f, 0.08550368f, -0.05797534f, 0.16373535f, -0.03168481f, 0.06921551f, 
    0.05075689f, -0.06120680f, 0.11209400f, 0.19408280f, -0.19785425f, 0.04569158f, 0.02895976f, 0.02931076f, 
    -0.00182761f, -0.00073384f, 0.00889759f, -0.06197092f, 0.09353012f, 0.02579681f, 0.02259397f, 0.15576807f, 
    -0.10955774f, -0.08123657f, -0.03159871f, -0.14188889f, -0.05404528f, 0.03279501f, 0.07464920f, 0.03729600f, 
    0.16615181f, -0.04598392f, -0.03016592f, 0.03936771f, 0.07235342f, -0.00707383f, -0.04794389f, -0.02346264f, 
    0.02920908f, 0.01448006f, -0.04210892f, -0.02461247f, -0.18670288f, -0.04796115f, -0.00954966f, 0.13590811f, 
    -0.05385831f, -0.04726400f, 0.01404558f, -0.00034871f, 0.05472555f, -0.01890870f, -0.09945865f, -0.06630056f, 
    -0.05660232f, -0.05385822f, 0.09769648f, -0.33408269f, -0.07721027f, -0.01887664f, -0.11839812f, 0.15779729f, 
    -0.03732532f, -0.05407195f, 0.00472674f, -0.01670523f, -0.13676170f, -0.12002353f, -0.05842455f, -0.03708652f, 
    -0.02538680f, 0.06585082f, 0.03585231f, -0.00682092f, -0.04562432f, -0.00444674f, -0.07235029f, 0.01586059f, 
    0.05307278f, 0.11927864f, 0.06879777f, -0.08321521f, -0.15885021f, 0.02092396f, 0.08326136f, 0.00857971f, 
    -0.05605832f, -0.09922690f, -0.01213280f, 0.01600545f, -0.10485858f, 0.04187118f, 0.10494827f, 0.00137496f, 
    -0.03825245f, -0.06448704f, -0.07205614f, -0.08657318f, 0.00320557f, -0.04335400f, 0.03843430f, 0.06027957f, 
    0.29249361f, 0.09321776f, 0.15376730f, -0.20996684f, 0.03567250f, 0.00149103f, -0.04180581f, -0.05878451f, 
    0.03539171f, -0.00629024f, -0.05978904f, -0.04646861f, -0.42759678f, -0.11979280f, 0.09640504f, -0.00839989f, 
    0.01436239f, 0.04560262f, -0.01589681f, -0.07387246f, 0.04799605f, -0.04941999f, 0.05217573f, -0.12725899f, 
    0.17374158f, -0.02974558f, 0.15986300f, -0.08206870f, -0.15193020f, -0.04136154f, 0.07165385f, -0.00947720f, 
    0.04072095f, -0.08328983f, -0.08322324f, 0.00130468f, 0.08793241f, 0.05733810f, 0.02903027f, 0.12018794f, 
    -0.07329907f, 0.02821974f, 0.00644103f, 0.05883836f, -0.08404209f, 0.00745338f, 0.00285540f, -0.10898702f, 
    -0.06042955f, -0.15067638f, -0.09381630f, -0.02967433f, -0.20040058f, 0.13700876f, 0.02519799f, -0.05490019f, 
    -0.04235271f, -0.07374029f, -0.04989255f, 0.06500854f, 0.00203720f, 0.00775018f, -0.04173044f, 0.09629470f, 
    0.00932370f, 0.19349138f, -0.12724206f, 0.04129005f, -0.05417448f, -0.08183743f, 0.08585178f, 0.05928136f, 
    -0.26779914f, -0.12995115f, -0.11606949f, 0.17489390f, -0.11307076f, 0.00825688f, 0.10020474f, -0.02277470f, 
    0.06279084f, 0.11064544f, -0.10253387f, -0.09098401f, -0.27667856f, 0.08046079f, 0.11280715f, -0.12496450f, 
    0.03861673f, -0.08058970f, 0.02165508f, 0.13302512f, 0.03707131f, -0.01752120f, -0.01962004f, 0.11412037f, 
    0.10557882f, 0.06034716f, -0.07125793f, 0.07662240f, -0.11931387f, -0.06272787f, 0.02562025f, 0.04165749f, 
    0.07980942f, 0.03112035f, -0.09078806f, -0.11384317f, -0.12473805f, 0.04532191f, -0.05972237f, -0.01153030f, 
    0.06079780f, -0.02565562f, 0.01072982f, -0.02392123f, 0.16815411f, -0.01469635f, -0.05712876f, -0.06597854f, 
    0.08010872f, 0.15163298f, -0.01458942f, -0.12471594f, -0.16016079f, 0.01220145f, -0.05765788f, 0.04957134f, 
    0.08140685f, 0.05424875f, 0.00279460f, 0.01836833f, -0.20030098f, 0.11148897f, 0.10798365f, 0.07453720f, 
    0.02646882f, -0.08586960f, 0.07962517f, -0.05604503f, 0.04636760f, 0.00793554f, 0.00928447f, -0.03066550f, 
    0.10298722f, 0.01179530f, -0.17848536f, 0.25361076f, -0.07621400f, -0.05627609f, -0.02955757f, 0.01870795f, 
    0.05492112f, -0.03533130f, 0.02683439f, 0.08208951f, -0.00269907f, -0.14655723f, -0.01902502f, 0.22078250f, 
    0.02622605f, 0.04340792f, -0.00580474f, -0.04759919f, -0.02301005f, 0.10656223f, 0.01039722f, -0.00250114f, 
    -0.02312368f, 0.16856886f, -0.06525701f, 0.06725181f, -0.01500457f, 0.02698865f, -0.07856688f, 0.08115241f, 
    0.07463250f, -0.00630856f, 0.07359286f, 0.03931948f, 0.05518217f, 0.11135332f, 0.10268265f, -0.01311134f, 
    0.01911348f, 0.06442985f, 0.01164563f, 0.03832668f, -0.01696633f, 0.02550011f, -0.05352320f, -0.00374392f, 
    -0.27694228f, 0.03895608f, 0.09394966f, -0.15078282f, -0.13002504f, 0.00144692f, -0.00871234f, 0.11416144f, 
    -0.06846829f, -0.05428912f, 0.02921788f, 0.02991617f, 0.06639251f, -0.06694580f, -0.08444710f, 0.14733210f, 
    -0.10796642f, -0.11000641f, 0.07715215f, 0.07715555f, 0.02376188f, 0.07012667f, -0.01524820f, -0.03819821f, 
    0.10041257f, 0.16906570f, 0.07683744f, -0.25433791f, -0.11699794f, -0.03232792f, 0.04115662f, 0.00743622f, 
    -0.06453656f, -0.07617374f, -0.10373712f, -0.02007612f, 0.05228411f, 0.08957873f, 0.09680044f, 0.08770488f, 
    0.07500232f, -0.02253507f, 0.00031589f, -0.10754298f, 0.05099705f, 0.06257294f, -0.09060854f, 0.22537494f, 
    -0.02655746f, -0.14800139f, -0.18520062f, 0.16905867f, 0.03970149f, -0.12304375f, -0.05781176f, -0.00745128f, 
    0.02836292f, 0.15857758f, -0.07615868f, 0.06281134f, -0.21259144f, 0.12061141f, 0.01295178f, -0.22460073f, 
    -0.01768030f, 0.10674251f, 0.02943150f, 0.02057905f, -0.05741413f, -0.01631316f, -0.05489588f, 0.06837816f, 
    0.17076850f, 0.04688563f, -0.15451734f, -0.07660475f, 0.01338001f, -0.00532574f, -0.01104083f, -0.13643998f, 
    0.02865036f, 0.01832855f, 0.00645629f, 0.09243816f, -0.02849734f, 0.02426103f, -0.14015341f, 0.17313327f, 
    0.05778955f, -0.05308342f, -0.06115059f, -0.04377942f, 0.01546717f, -0.14271908f, -0.03688719f, -0.07530662f, 
    -0.21466362f, -0.19093993f, 0.09311209f, -0.00171092f, -0.11672693f, 0.12698022f, -0.01194695f, 0.06065493f, 
    -0.12481177f, -0.01715911f, 0.04150097f, -0.07073230f, -0.41450757f, 0.10280944f, 0.03000350f, 0.19526267f, 
    -0.04134549f, 0.10463722f, -0.03278498f, -0.01414487f, -0.02482291f, -0.14867461f, -0.04199602f, -0.02379573f, 
    0.01774340f, -0.11051967f, 0.06928209f, -0.15549286f, 0.02204304f, 0.02321250f, -0.06255488f, 0.06089834f, 
    -0.08889747f, 0.06135489f, -0.00090612f, 0.00703480f, 0.21611717f, -0.28936324f, 0.09744760f, 0.02845307f, 
    -0.17107481f, -0.00073779f, 0.09501804f, 0.03332711f, -0.20470913f, 0.08869527f, -0.01383673f, 0.00827045f, 
    0.21395649f, -0.01252624f, 0.00892141f, -0.22921525f, -0.01034001f, -0.02312031f, 0.05575828f, -0.01415004f, 
    -0.03699482f, -0.03587430f, -0.05771134f, -0.06845994f, 0.25266278f, -0.08912861f, -0.05279743f, 0.27858275f, 
    -0.14283417f, 0.08507863f, -0.13377407f, 0.05083124f, -0.09258968f, 0.02469841f, -0.00456165f, -0.02311763f, 
    -0.01103888f, 0.01218010f, -0.05278834f, -0.32585382f, -0.08067439f, -0.02111993f, -0.12883689f, 0.02976084f, 
    -0.04014204f, -0.09586909f, 0.03599225f, -0.03028194f, 0.55930406f, -0.04203245f, -0.03155838f, -0.25442019f, 
    0.00198787f, 0.07682592f, 0.03480724f, 0.08778569f, -0.00624266f, 0.02123542f, 0.06400585f, 0.02587898f, 
    0.20293637f, -0.16332436f, -0.13301593f, 0.38587335f, -0.14240724f, 0.12141252f, -0.10069511f, 0.02001152f, 
    0.01597211f, 0.02998050f, -0.06894899f, -0.02338575f, 0.10359240f, -0.08377595f, 0.00949280f, -0.22627720f, 
    0.02877570f, -0.08477145f, 0.04767125f, 0.05804008f, -0.07689290f, -0.00213598f, 0.03028596f, 0.09125616f, 
    -0.18586639f, 0.10685824f, -0.07644299f, -0.08684406f, -0.10505059f, -0.10785116f, -0.11400871f, -0.01682182f, 
    0.06540395f, 0.00219026f, 0.00710733f, -0.13117731f, -0.07780660f, -0.07134005f, 0.22470997f, 0.08783702f, 
    -0.09955710f, -0.00115281f, 0.11312372f, -0.17883885f, 0.00230337f, 0.00630820f, 0.00354196f, -0.01242543f, 
    0.08710736f, -0.09099636f, -0.04896305f, -0.14299063f, 0.12331556f, 0.05964338f, 0.02657671f, -0.13959356f, 
    -0.11638809f, 0.12021833f, 0.00768807f, -0.02443859f, 0.04896779f, -0.03275823f, 0.17144080f, 0.15948243f, 
    -0.20253538f, -0.01893727f, 0.10422279f, 0.00379072f, 0.04425112f, -0.06535509f, -0.00512385f, 0.04519537f, 
    -0.38232651f, -0.03944744f, 0.05001555f, 0.12396742f, 0.08062527f, 0.08457930f, -0.06789299f, 0.15153328f, 
    0.00696317f, 0.01215880f, 0.05058832f, -0.21379885f, -0.03714414f, 0.07449334f, 0.04580072f, -0.24484299f, 
    -0.07033253f, 0.08315838f, 0.10271183f, 0.13481537f, 0.01944886f, 0.03253776f, 0.02011161f, -0.05326144f, 
    -0.22865984f, 0.04647084f, -0.04459748f, 0.00287538f, -0.02310769f, -0.02623489f, 0.06788421f, 0.02796638f, 
    0.02106882f, -0.18701106f, 0.05597380f, -0.08324839f, 0.17187700f, -0.33491600f, -0.01526425f, 0.08357014f, 
    -0.00585905f, -0.01791259f, 0.04545991f, 0.11392771f, -0.01225618f, -0.02487865f, 0.09927441f, -0.05203977f, 
    -0.13660946f, 0.10370026f, 0.17818488f, -0.14437401f, 0.02117700f, -0.02679943f, 0.03307121f, 0.04212986f, 
    0.01888447f, -0.01896584f, 0.08244441f, 0.02026686f, -0.28445980f, 0.13538241f, -0.21058536f, 0.03820556f, 
    -0.01364731f, -0.01143989f, -0.04952598f, 0.05833489f, 0.09736965f, 0.06525096f, -0.07657076f, 0.03737825f, 
    -0.09945256f, 0.04408377f, 0.00444526f, -0.05815216f, -0.16176364f, -0.02799354f, 0.06733005f, -0.13693693f, 
    -0.05249325f, 0.02019060f, 0.09441814f, -0.11706999f, -0.03901022f, 0.00024374f, 0.09552545f, 0.02345332f, 
    -0.04007655f, 0.06954452f, -0.10244484f, 0.05262915f, 0.12130276f, -0.05195758f, 0.00708489f, -0.10300007f, 
    0.15074901f, 0.09474745f, 0.16807355f, -0.30031273f, 0.12457917f, 0.04705402f, 0.01272387f, -0.00555223f, 
    0.06628631f, -0.08581486f, 0.01903902f, 0.02623462f, 0.08354236f, 0.08824070f, -0.00480714f, 0.10436157f, 
    -0.09719907f, -0.14166714f, -0.05983718f, 0.02752624f, -0.04709910f, -0.01598020f, -0.04924316f, 0.02647495f, 
    0.34558445f, -0.14921442f, -0.03033284f, -0.02350836f, -0.09026296f, 0.04143582f, 0.11238718f, 0.11535797f, 
    -0.03343186f, -0.09544390f, 0.00439470f, -0.00776614f, -0.02772541f, -0.00578337f, -0.24602011f, -0.14656582f, 
    -0.19503105f, 0.14311992f, 0.00808316f, -0.06341189f, -0.00634843f, 0.03471370f, -0.16136517f, -0.03848585f, 
    0.35225195f, -0.12361719f, -0.13240625f, -0.16333762f, 0.07805281f, -0.02286047f, 0.05195114f, 0.05748314f, 
    0.09583130f, -0.01762141f, -0.03198419f, 0.07358403f, -0.05981253f, 0.11297526f, -0.04279148f, 0.02389940f, 
    0.11028882f, 0.00037797f, 0.02712308f, -0.07813429f, -0.04452861f, 0.10486371f, 0.01610398f, 0.02856326f, 
    0.28643313f, 0.00678252f, 0.13878502f, 0.26344609f, -0.08486959f, 0.01685404f, -0.01468873f, 0.03480512f, 
    0.03068030f, 0.10951079f, -0.03361752f, 0.10431405f, -0.06877162f, -0.06583211f, 0.09274857f, 0.02264407f, 
    0.10444663f, -0.02574008f, -0.08578184f, -0.04392739f, 0.11556848f, -0.02284778f, -0.01249318f, 0.09471464f, 
    -0.25534722f, -0.12465822f, -0.00539728f, -0.27169567f, 0.04871783f, 0.00706801f, 0.00635394f, 0.00079844f, 
    -0.00294801f, 0.09041709f, 0.05521673f, 0.00649949f, 0.01948103f, -0.15789418f, -0.06942128f, -0.01482662f, 
    0.10715690f, -0.12073556f, -0.08039664f, -0.11012593f, -0.03326492f, -0.04502815f, 0.00618612f, -0.14917122f, 
    0.18027936f, -0.00455299f, 0.03305486f, 0.08823480f, -0.04368100f, 0.04783884f, -0.09201984f, 0.04873468f, 
    -0.01287589f, 0.05074554f, -0.01167564f, 0.01876497f, 0.09120315f, -0.11757710f, 0.08168778f, 0.03929922f, 
    -0.04792984f, 0.12935627f, 0.02591178f, 0.03953346f, -0.01841765f, -0.07993643f, -0.03901932f, -0.02274704f, 
    0.16394289f, -0.07281826f, -0.14858118f, -0.05003623f, -0.03143588f, -0.01326696f, -0.11623537f, -0.10132753f, 
    0.03725862f, 0.03385868f, 0.10736948f, -0.05464821f, -0.26772991f, 0.12980215f, -0.01734650f, 0.01240217f, 
    0.08273145f, 0.00368400f, 0.10797957f, 0.16602360f, -0.02716377f, 0.03920697f, 0.04011227f, 0.10061035f, 
    0.23439081f, -0.14957602f, 0.03042728f, -0.32566759f, 0.02937069f, -0.08644141f, 0.08725645f, -0.06758836f, 
    -0.12916757f, -0.02807527f, -0.01289335f, 0.11892417f, -0.09219060f, -0.12766996f, 0.05091470f, -0.20804086f, 
    -0.06247566f, -0.14823617f, 0.01255473f, -0.05583161f, -0.06998391f, -0.06680617f, -0.01284602f, -0.19669099f, 
    0.20420782f, 0.08919411f, -0.15453351f, 0.06235003f, 0.09480598f, 0.08948158f, 0.01092799f, -0.04230900f, 
    -0.06591787f, 0.07069873f, 0.01493705f, -0.03857253f, 0.19116403f, -0.34265369f, -0.07340071f, -0.13098350f, 
    -0.05966162f, 0.06024670f, -0.00629690f, 0.17035793f, 0.00586119f, 0.05265662f, -0.04414907f, -0.04362147f, 
    -0.28814679f, -0.02341034f, -0.27229252f, -0.27374631f, -0.13591327f, 0.07734490f, -0.05218461f, 0.01163389f, 
    -0.00080617f, -0.13763921f, -0.07957608f, 0.03604321f, 0.05254215f, 0.02913131f, -0.24972413f, -0.00548903f, 
    -0.01395951f, -0.00237928f, 0.03214948f, -0.00254038f, -0.15193528f, -0.02823370f, -0.08274421f, -0.06996174f, 
    -0.03641034f, -0.04087919f, 0.12732917f, 0.20486401f, 0.00696101f, 0.04786610f, -0.02931536f, 0.06729218f, 
    -0.04239306f, 0.08106012f, 0.17308587f, 0.03607963f, 0.31601691f, -0.26374409f, -0.01553685f, 0.04929009f, 
    0.12389746f, 0.02077265f, -0.10330512f, -0.02268212f, -0.02665658f, 0.08610721f, -0.04730076f, 0.00772108f, 
    -0.07399591f, -0.06759065f, 0.05302025f, -0.03775341f, -0.00133599f, -0.04296644f, 0.00951981f, 0.06913614f, 
    -0.02760018f, 0.02742750f, 0.10178364f, -0.01674039f, -0.24945246f, 0.08355086f, -0.11031377f, 0.26182339f, 
    -0.05243003f, -0.09296514f, -0.04905000f, -0.05042862f, 0.19199683f, 0.18532731f, -0.05316882f, 0.00908630f, 
    -0.20554364f, 0.07685038f, -0.10551352f, 0.07240190f, -0.01668781f, -0.09135862f, -0.05096933f, 0.00552583f, 
    0.02305207f, -0.22602424f, 0.01720115f, 0.04010355f, 0.25881279f, 0.08941686f, -0.12013317f, 0.06455767f, 
    -0.00178567f, 0.09386636f, -0.13158599f, 0.02862759f, -0.10552429f, -0.03511851f, 0.04257095f, -0.02638398f, 
    -0.05941644f, -0.04221014f, -0.11010754f, 0.01928088f, 0.10698436f, -0.00008809f, 0.02338335f, -0.03914725f, 
    -0.04322160f, -0.12844801f, 0.05462430f, 0.11505770f, -0.15074113f, 0.02979523f, -0.27952355f, 0.18136905f, 
    -0.09858420f, 0.04233838f, 0.02375055f, 0.01896514f, -0.01885755f, 0.11104076f, 0.06036915f, 0.10745125f, 
    0.16768642f, 0.25478393f, 0.10694744f, 0.09890520f, 0.03014417f, 0.02174188f, 0.05650643f, -0.05530614f, 
    0.02595116f, -0.02930291f, -0.00397644f, 0.03994134f, -0.05088400f, 0.03238885f, 0.05631592f, -0.07811613f, 
    -0.01033137f, 0.02185043f, 0.02305573f, -0.06268043f, 0.08095767f, -0.06431409f, 0.02883798f, 0.05713603f, 
    0.08185870f, -0.04198118f, 0.01542383f, 0.14050326f, -0.07582641f, -0.08256999f, 0.00884848f, -0.01936702f, 
    0.03539913f, 0.10284217f, -0.04031911f, 0.05766963f, -0.43960199f, 0.00428638f, -0.18259463f, 0.04173269f, 
    -0.05114511f, 0.00463962f, -0.00736515f, 0.03798710f, 0.02613025f, -0.08652003f, -0.05853805f, 0.05293225f, 
    -0.16137040f, 0.10278415f, -0.29299071f, 0.18623549f, 0.11755784f, 0.04534409f, -0.01006809f, -0.01813766f, 
    -0.03534467f, 0.02557960f, 0.03985108f, 0.11307691f, -0.49036038f, -0.14441405f, -0.11319189f, -0.09526137f, 
    0.03655449f, -0.02811335f, 0.04457611f, 0.04804514f, 0.04288957f, -0.02929638f, -0.07959555f, -0.11125036f, 
    0.27170214f, -0.29207122f, 0.03468047f, -0.13807987f, -0.05097630f, -0.01050656f, -0.02539041f, 0.09328396f, 
    -0.00226168f, -0.02920317f, 0.00880220f, -0.01144692f, 0.32100564f, 0.00763243f, 0.01660816f, 0.13839620f, 
    -0.08503184f, 0.05830134f, -0.00244400f, -0.01575056f, 0.07508270f, -0.11391819f, -0.04012753f, -0.11818159f, 
    0.08415674f, -0.05148071f, 0.02709254f, 0.19622689f, -0.11157778f, -0.01660591f, 0.04227306f, -0.00451154f, 
    0.06654581f, 0.01868759f, -0.01718638f, 0.11712860f, 0.14624599f, -0.04405927f, 0.01856471f, 0.07970330f, 
    0.06342154f, -0.05520458f, 0.03153069f, 0.02907926f, 0.09701724f, 0.13135000f, -0.06299303f, -0.17768528f, 
    0.21512662f, 0.04895170f, -0.04004564f, 0.01092392f, -0.05508472f, -0.02449821f, -0.01537843f, -0.10452541f, 
    0.02002331f, -0.28137308f, 0.06991240f, -0.25782076f, -0.15345815f, -0.02000262f, -0.05661593f, -0.03501108f, 
    -0.01148591f, 0.00884020f, 0.09225632f, 0.00312523f, 0.10112113f, 0.06703923f, 0.08819748f, -0.02882461f, 
    0.21677212f, -0.19696976f, 0.06936844f, -0.02149024f, 0.14129061f, -0.05553498f, -0.15583897f, 0.08705743f, 
    -0.05896091f, -0.00071542f, -0.02283517f, 0.05691551f, -0.06621557f, 0.06916358f, -0.09835690f, 0.12464894f, 
    -0.08797593f, 0.04526716f, -0.14639042f, 0.03566233f, 0.00610789f, 0.07427318f, 0.09371849f, -0.01143950f, 
    0.05567377f, -0.10814482f, -0.10545498f, -0.23051664f, 0.07356583f, -0.11103990f, 0.01994098f, 0.02918658f, 
    -0.13301238f, 0.09315910f, 0.00529986f, 0.10307243f, 0.10702030f, 0.14283140f, -0.09632651f, 0.09794502f, 
    -0.06786450f, -0.05468431f, -0.05322215f, -0.16642788f, 0.02184867f, 0.18346119f, -0.06401527f, -0.04399348f, 
    -0.03096089f, -0.08763691f, 0.03246790f, -0.15594420f, 0.10748646f, -0.09204745f, 0.00359732f, -0.02868608f, 
    0.05415611f, -0.04127159f, -0.01433712f, 0.00533121f, -0.06603584f, -0.21808392f, 0.05068877f, -0.01692770f, 
    0.03816624f, -0.03030846f, 0.02396047f, 0.15413710f, 0.12344413f, -0.11484995f, 0.05843403f, -0.07985667f, 
    -0.18993770f, -0.18661973f, 0.06085731f, -0.25613281f, -0.05845461f, -0.01490167f, 0.01276732f, 0.10141312f, 
    0.11546506f, 0.05973753f, 0.11221717f, 0.02579083f, 0.14810443f, -0.12759493f, 0.04233829f, 0.15768787f, 
    -0.03182133f, -0.06253260f, -0.10371204f, -0.01649347f, 0.06544874f, 0.00502069f, -0.12482107f, 0.11649379f, 
    0.18040106f, -0.15455611f, -0.02956332f, -0.06473517f, 0.02331211f, -0.06239913f, 0.03444734f, 0.08725180f, 
    -0.02563208f, 0.01817749f, -0.04990414f, -0.01539589f, -0.60842204f, -0.05049380f, -0.07555502f, -0.17323495f, 
    -0.00440398f, -0.13667700f, -0.09617347f, 0.02842261f, 0.02490890f, -0.00470696f, -0.18612669f, -0.06372965f, 
    -0.11060470f, -0.08396777f, 0.03102623f, 0.02398198f, 0.07153209f, -0.08350064f, -0.02295025f, 0.06581960f, 
    -0.00550316f, 0.05197849f, 0.04197530f, 0.14245427f, 0.06537719f, -0.04036807f, 0.12932333f, -0.08369286f, 
    -0.01622779f, -0.05193086f, 0.01776369f, 0.07000289f, -0.04220357f, 0.07883684f, 0.09192356f, -0.08854874f, 
    -0.05057080f, 0.17969693f, -0.05153219f, 0.16664931f, 0.08354855f, 0.07715821f, 0.08727649f, 0.01238374f, 
    0.00420010f, 0.07526182f, 0.02294093f, 0.10433872f, 0.03096802f, 0.01499775f, -0.02352089f, -0.00282241f, 
    0.04286304f, -0.03776130f, -0.01449971f, -0.01918877f, 0.15196402f, 0.17748775f, -0.02835422f, 0.02122407f, 
    0.01740571f, 0.01314955f, 0.06944361f, -0.03803094f, -0.05163570f, -0.23680757f, 0.03119631f, -0.01474603f, 
    0.05803876f, -0.04636127f, -0.02279549f, -0.11341034f, -0.29072440f, 0.11021112f, -0.08894102f, -0.08953198f, 
    -0.04495851f, 0.00348296f, 0.08739195f, -0.07128005f, -0.00083002f, 0.06884613f, 0.06550037f, -0.10368389f, 
    -0.00885501f, 0.06808116f, -0.17160316f, 0.05840432f, 0.05764769f, -0.07072408f, -0.05967398f, -0.09251184f, 
    0.01038700f, 0.09365276f, 0.01598294f, 0.12264864f, 0.28690621f, -0.05049932f, 0.04330585f, -0.02925808f, 
    -0.13715489f, -0.13107254f, -0.04289545f, -0.04361152f, -0.09204537f, -0.09227943f, -0.14820014f, 0.08282805f, 
    -0.19306907f, -0.07185800f, -0.07167105f, -0.19828410f, 0.07074907f, 0.04790855f, -0.03921144f, 0.03053751f, 
    -0.02219389f, 0.07815482f, -0.00002586f, -0.04966622f, 0.20037781f, 0.04960404f, 0.10859267f, -0.10292695f, 
    -0.06064446f, 0.13874045f, -0.04014083f, -0.03255685f, -0.01690467f, -0.09310895f, -0.14237873f, 0.06441280f, 
    0.14167084f, -0.02664990f, -0.13930352f, 0.10412361f, -0.12068743f, 0.13874146f, -0.06526953f, -0.05259868f, 
    0.11782306f, -0.05468984f, -0.17918123f, -0.08204786f, 0.16491179f, -0.02698745f, 0.05242008f, 0.11348671f, 
    -0.10747413f, 0.02328046f, -0.02768223f, 0.00631534f, -0.01375251f, -0.04386550f, -0.02570805f, 0.00814861f, 
    0.32930806f, -0.37100962f, -0.22604576f, -0.01156270f, 0.04876840f, -0.09278788f, 0.00502849f, 0.01165091f, 
    -0.04475199f, -0.01542141f, -0.10281607f, 0.16715454f, -0.10970183f, 0.05480392f, -0.05427881f, -0.15645795f, 
    0.00360010f, 0.02514932f, 0.10845116f, 0.01236924f, -0.01623682f, 0.15329219f, 0.00455525f, 0.09687630f, 
    0.30401629f, -0.01658162f, -0.12861387f, -0.23350897f, 0.00866052f, 0.01499956f, -0.00838028f, -0.00662017f, 
    0.09371240f, -0.03192864f, -0.01245694f, 0.04118136f, -0.03813089f, -0.05028585f, 0.02027770f, 0.02751304f, 
    -0.00494486f, 0.06395428f, 0.07618088f, 0.04805269f, 0.06206920f, 0.01733600f, 0.08744520f, -0.07216163f, 
    0.54265374f, 0.01551515f, 0.08498595f, 0.24197398f, -0.13676937f, -0.04185740f, 0.09417374f, -0.03597330f, 
    -0.10239168f, 0.01603723f, -0.03224985f, -0.01797754f, 0.04062949f, -0.14746106f, -0.07499809f, 0.05954966f, 
    0.03306678f, -0.10583252f, 0.03303741f, -0.10563739f, 0.03485188f, 0.01285294f, -0.02944546f, -0.03653556f, 
    0.06159522f, -0.07712808f, 0.25114998f, 0.18349530f, -0.18003422f, 0.02953039f, 0.05321125f, -0.00009440f, 
    -0.04949712f, 0.03180998f, -0.01159473f, -0.05677482f, 0.21820548f, 0.06519385f, 0.11953573f, 0.07768375f, 
    -0.07570475f, -0.11468676f, -0.04008704f, -0.04737431f, 0.09748054f, 0.01039393f, 0.00748480f, -0.04362232f, 
    -0.08908246f, 0.08384458f, -0.02602340f, -0.15423355f, 0.12683731f, 0.01746563f, 0.00204034f, 0.00218895f, 
    0.06972029f, 0.03864785f, 0.03846846f, 0.00067231f, -0.01344249f, 0.12393805f, 0.09280935f, 0.09688406f, 
    -0.04946379f, 0.04421983f, 0.03793603f, 0.03865423f, 0.05206036f, -0.01608117f, -0.07472547f, 0.04252136f, 
    0.20260039f, 0.10319690f, -0.03933784f, 0.19748420f, -0.03403845f, 0.01852685f, -0.10826533f, 0.02321625f, 
    -0.10889779f, -0.00655120f, 0.05130320f, 0.07871065f, 0.28023544f, -0.14812686f, 0.20720878f, 0.07459126f, 
    0.03068009f, -0.01145136f, 0.04588002f, 0.06613285f, -0.04925482f, 0.05191051f, 0.05219556f, -0.04802521f, 
    -0.05890886f, -0.10620241f, 0.09408811f, -0.14271846f, 0.08164656f, 0.02087391f, 0.00997717f, -0.00025203f, 
    0.06011342f, 0.00161512f, 0.00990689f, 0.05522440f, 0.11152136f, -0.14964843f, -0.01188640f, -0.03807705f, 
    -0.01244338f, 0.04920591f, -0.03995845f, -0.10089608f, 0.06582365f, -0.00243750f, 0.06590554f, -0.01647177f, 
    -0.34133279f, 0.10219072f, -0.01222365f, -0.01213960f, -0.00027968f, 0.00793127f, 0.02901927f, 0.13865329f, 
    0.02226506f, 0.03965147f, -0.03311561f, -0.03738046f, 0.14221023f, -0.09912551f, -0.16671441f, -0.05249669f, 
    -0.05033797f, -0.00504672f, -0.09317723f, -0.03666082f, 0.00202509f, -0.02054736f, -0.00634613f, -0.14145322f, 
    -0.28697932f, 0.10604737f, -0.06272971f, -0.12458299f, -0.06793851f, -0.03665020f, 0.10922527f, 0.02620850f, 
    0.01175606f, 0.01295200f, -0.02491803f, -0.02235611f, -0.26030591f, -0.13749763f, -0.04255993f, -0.26956275f, 
    0.00146597f, -0.03396258f, -0.00863240f, -0.01662232f, 0.01799043f, 0.14988953f, -0.07440893f, -0.00915888f, 
    -0.16053493f, 0.07393526f, -0.11300471f, 0.05776190f, 0.15072742f, 0.02748344f, -0.02898224f, -0.07016040f, 
    -0.07600633f, 0.08725782f, -0.01044188f, 0.04162013f, -0.10374272f, -0.16228810f, -0.23763599f, -0.07869376f, 
    -0.08704234f, -0.10275027f, -0.01705309f, -0.01643597f, 0.05605323f, 0.00806131f, 0.01802938f, 0.00808381f, 
    0.17501372f, 0.03638706f, -0.10464787f, -0.02391890f, 0.07717306f, -0.08241772f, -0.00052175f, 0.07461547f, 
    0.06190612f, 0.11064279f, 0.07379545f, -0.09004876f, 0.28355917f, -0.04633132f, 0.00833618f, 0.05989502f, 
    0.02038884f, -0.03890306f, -0.08508082f, -0.01528107f, -0.01182643f, -0.01951355f, -0.11445821f, -0.01837905f, 
    -0.03283405f, 0.04553460f, -0.02240373f, 0.05727404f, 0.04906531f, 0.00234782f, 0.00696738f, -0.08890828f, 
    0.02050787f, -0.05200894f, 0.01216893f, -0.02640116f, -0.05854751f, -0.12090432f, 0.03279744f, 0.05558230f, 
    -0.04136534f, -0.08596199f, 0.01415863f, 0.13833183f, -0.00026013f, -0.01585132f, -0.00663067f, -0.03008104f, 
    -0.05077128f, 0.09121485f, 0.03992284f, -0.07126997f, -0.10691287f, -0.07947659f, -0.04515747f, 0.03119595f, 
    -0.00711971f, -0.03724056f, -0.08978481f, -0.05182134f, 0.00651534f, -0.21302408f, -0.07948387f, -0.16480356f, 
    -0.13498889f, 0.07953834f, -0.14156720f, -0.00849436f, 0.04733041f, -0.08907267f, 0.03958936f, -0.00330242f, 
    0.15906620f, -0.04657628f, -0.23258300f, 0.01115297f, -0.13581398f, 0.09612775f, 0.03397269f, 0.06460848f, 
    -0.02986020f, 0.03575627f, -0.07584141f, -0.03664635f, 0.20261563f, -0.04725291f, -0.03322479f, 0.15897790f, 
    0.02169430f, 0.05591404f, -0.08218122f, -0.06608163f, -0.03659814f, 0.03140103f, -0.01181375f, 0.01698367f, 
    0.04963614f, 0.03062499f, -0.26105917f, 0.12754178f, 0.01608359f, 0.04356207f, -0.05154750f, 0.00145706f, 
    -0.09974048f, 0.08581586f, -0.17131960f, -0.04376815f, -0.13500263f, -0.16396356f, -0.14700922f, -0.14701596f, 
    -0.11224241f, -0.05561564f, -0.19443406f, 0.02752499f, 0.04109022f, -0.13158603f, -0.00792344f, -0.02353919f, 
    0.12132322f, -0.03042000f, -0.02673879f, -0.18196304f, -0.03546423f, 0.06657530f, 0.05067785f, 0.05601277f, 
    -0.05899340f, 0.05589402f, 0.09690618f, 0.02371978f, 0.13271016f, 0.03675117f, -0.11606111f, 0.01028932f, 
    0.05259312f, 0.00746746f, 0.07497417f, 0.10011524f, -0.03379301f, -0.11828247f, -0.06689908f, -0.08104898f, 
    -0.10546748f, -0.01202652f, -0.02318762f, -0.09231310f, 0.00245648f, 0.04346299f, -0.02783775f, 0.04390749f, 
    -0.14762740f, -0.00010858f, 0.04705637f, -0.00834196f, 0.30409303f, -0.15748872f, -0.09554625f, -0.13446087f, 
    -0.08442817f, 0.04964004f, -0.05352074f, 0.06213989f, -0.04300912f, -0.03099101f, 0.01252507f, -0.09085485f, 
    0.28417680f, -0.10334292f, -0.03482919f, -0.13402674f, 0.01620063f, 0.01189606f, -0.06170281f, -0.02509741f, 
    -0.04031471f, -0.08362994f, -0.12675501f, -0.05585452f, 0.16205069f, 0.14156643f, -0.18918955f, -0.28555429f, 
    -0.06094266f, -0.01716639f, -0.10199825f, -0.02798404f, -0.00391466f, 0.07454518f, 0.00606167f, 0.02247237f, 
    -0.02736870f, 0.03704068f, -0.00244680f, -0.26904860f, -0.02016058f, -0.09501570f, 0.10312659f, -0.06106237f, 
    -0.04086732f, 0.07810291f, 0.01295884f, -0.09868088f, 0.03214889f, 0.02004580f, 0.01219910f, -0.06648674f, 
    0.10444367f, -0.01281503f, 0.00432513f, -0.04526949f, -0.08150706f, -0.02236283f, -0.05354492f, 0.01823676f, 
    -0.07467156f, 0.04581557f, -0.08753140f, -0.02050230f, 0.10816531f, -0.00836614f, -0.00074764f, -0.16209775f, 
    0.03398285f, -0.06042960f, -0.03155860f, -0.05011564f, 0.07322284f, 0.01662086f, 0.10213210f, 0.07381163f, 
    0.02683028f, 0.07506813f, 0.09135430f, 0.05372552f, -0.00220856f, 0.06139993f, 0.06600122f, -0.00572855f, 
    0.06855294f, -0.16006413f, -0.00366173f, 0.03222740f, -0.08911794f, 0.03079457f, 0.03096450f, -0.01552131f, 
    -0.02822762f, 0.08651870f, -0.04899970f, 0.01217636f, -0.35105354f, -0.09834760f, -0.05011759f, -0.43664032f, 
    0.01233811f, -0.01761990f, -0.09575249f, 0.06530528f, 0.07557499f, -0.02649777f, -0.15453678f, 0.00942533f, 
    0.09442395f, 0.11139524f, 0.11739481f, 0.06744012f, -0.03036316f, -0.07731492f, 0.10499393f, 0.00018578f, 
    -0.06289060f, -0.05337224f, -0.01089191f, -0.01217084f, 0.10013177f, -0.08533783f, 0.03689898f, -0.03854869f, 
    -0.06343105f, 0.04651465f, -0.08273032f, 0.04096295f, 0.02824654f, -0.01232524f, -0.00753543f, -0.11569130f, 
    -0.48603868f, 0.07629099f, -0.15232258f, -0.12855749f, 0.00987613f, -0.09136731f, 0.04379788f, -0.01651389f, 
    -0.02324148f, -0.02544350f, 0.01148124f, -0.08694904f, 0.04575561f, -0.02727830f, -0.07140312f, 0.00602769f, 
    -0.09796137f, 0.06765704f, -0.00161777f, 0.09177113f, 0.03822285f, -0.04656931f, 0.04819448f, -0.03567063f, 
    -0.23221983f, -0.13819668f, 0.15020092f, -0.08198901f, -0.01937959f, -0.05762080f, -0.07622111f, 0.01712318f, 
    -0.01124045f, 0.02539475f, -0.05504187f, 0.08703165f, -0.07713737f, 0.01718209f, -0.07190181f, -0.17111830f, 
    0.04926514f, 0.07862491f, -0.00517851f, 0.00433491f, -0.10981446f, 0.09008166f, 0.00377628f, -0.10456502f, 
    -0.08447169f, -0.03856361f, 0.08895200f, -0.01752984f, 0.00769437f, -0.09326831f, 0.09964016f, 0.00423471f, 
    -0.03651489f, 0.05977390f, 0.02922554f, -0.05674473f, 0.13283457f, -0.02090072f, 0.02118482f, -0.07730109f, 
    0.05387826f, -0.01257366f, 0.05363986f, 0.03872753f, -0.05390239f, 0.05143771f, -0.01794459f, -0.06320644f, 
    -0.10190341f, 0.10576935f, 0.02528386f, -0.08359651f, -0.01401662f, -0.01885126f, 0.11255030f, 0.00759521f, 
    -0.10867747f, -0.02190243f, 0.03883596f, -0.03734919f, 0.31066775f, 0.05101287f, 0.18920250f, 0.00531441f, 
    0.13010468f, -0.07716153f, -0.04220879f, 0.01542370f, -0.09536705f, 0.07167874f, 0.14726356f, -0.00064646f, 
    0.14608857f, -0.11593491f, -0.19674234f, 0.04718764f, -0.04613806f, 0.07626139f, -0.13269284f, 0.06834945f, 
    -0.12378058f, -0.03927724f, -0.06574527f, -0.04497908f, 0.09648278f, -0.02700703f, 0.05862077f, -0.00749501f, 
    -0.02319328f, 0.03557700f, 0.02931929f, 0.00887752f, -0.04993428f, 0.05590308f, 0.05186613f, -0.03215691f, 
    -0.09141080f, 0.16205014f, -0.19508585f, -0.05401553f, -0.00881638f, 0.05485348f, -0.03508663f, 0.00154005f, 
    -0.10621180f, -0.05232493f, -0.07857928f, -0.02850208f, 0.33043057f, -0.05525333f, -0.08610546f, 0.05051567f, 
    -0.00626667f, -0.01160911f, 0.01433223f, 0.04302217f, -0.06042147f, 0.10748339f, 0.08406293f, 0.04272787f, 
    -0.03231950f, 0.15523431f, 0.15491608f, 0.03729219f, -0.03682568f, 0.02273370f, 0.12818517f, 0.09298668f, 
    -0.16293101f, 0.03185246f, 0.13164414f, -0.00331042f, 0.25771248f, 0.10263561f, -0.16278990f, -0.00508667f, 
    -0.06254455f, -0.02064179f, 0.05987864f, -0.04295794f, -0.00702240f, 0.06337800f, 0.01797146f, 0.09803373f, 
    0.18309532f, -0.05574153f, -0.13732097f, -0.27370602f, -0.22005273f, 0.00024206f, -0.07639136f, 0.01189807f, 
    -0.05549806f, -0.10398415f, 0.05596656f, -0.04377767f, 0.28025225f, -0.04744361f, 0.10708071f, -0.15884167f, 
    0.06667279f, -0.04584286f, 0.07253429f, 0.02257299f, 0.00194472f, -0.01226434f, 0.13053863f, -0.05179014f, 
    0.13877288f, 0.08004117f, -0.11852292f, -0.25062880f, -0.04484057f, -0.00101514f, -0.03633660f, 0.00198462f, 
    -0.07518367f, 0.03278589f, -0.11741214f, -0.10393270f, -0.22840969f, 0.05144013f, -0.00873549f, -0.17302853f, 
    0.03983976f, 0.01797332f, -0.02929562f, 0.08994161f, 0.00884889f, -0.07294087f, 0.09829867f, -0.15360656f, 
    0.03975500f, 0.01145892f, 0.12041122f, 0.01871150f, -0.07321833f, -0.14801532f, -0.03684801f, -0.00566798f, 
    0.05588302f, -0.00410752f, 0.02420663f, -0.07182705f, 0.43927050f, -0.02143713f, -0.25831461f, 0.00540668f, 
    -0.14483835f, -0.00561589f, -0.10756837f, 0.06479049f, 0.02704647f, 0.00790546f, -0.02031737f, -0.00943223f, 
    0.03966252f, -0.23525834f, 0.15518180f, 0.04485875f, 0.03343423f, -0.02495402f, 0.04627779f, -0.01663566f, 
    -0.00882400f, -0.09612969f, -0.03657067f, -0.03551384f, 0.02315128f, 0.09188896f, -0.09041288f, 0.02280786f, 
    0.11212297f, 0.08062269f, -0.03697313f, -0.07686795f, -0.07244618f, -0.10118429f, -0.00552736f, -0.08777144f, 
    0.14956051f, 0.08175747f, 0.08524202f, 0.09952962f, 0.01082563f, -0.00943154f, -0.06287806f, 0.12502638f, 
    -0.08473883f, -0.00653978f, -0.01039800f, 0.09531315f, 0.08639075f, 0.21087362f, -0.09454070f, 0.04589504f, 
    0.03099209f, 0.04049553f, -0.01195529f, -0.09281548f, -0.02395183f, 0.04629349f, 0.03548309f, -0.11152646f, 
    -0.01055371f, -0.08615011f, -0.03198213f, 0.01832266f, 0.05047704f, 0.05811528f, -0.02401523f, -0.09974273f, 
    0.00231920f, 0.11647885f, -0.04097933f, 0.07054542f, 0.16802566f, -0.02623708f, 0.09979583f, 0.14564596f, 
    0.08436997f, -0.09474020f, 0.03931302f, 0.06783336f, 0.02767878f, -0.05868508f, -0.03239831f, -0.06586523f, 
    0.05079376f, 0.04448597f, -0.10730945f, -0.00662135f, -0.14313161f, -0.08678060f, 0.00323614f, -0.05387247f, 
    -0.06712694f, -0.10800593f, -0.00237806f, 0.05667295f, -0.14134264f, 0.11212435f, -0.04385842f, 0.01268220f, 
    -0.03611866f, -0.06438518f, -0.03490532f, 0.06292622f, 0.02258214f, 0.01731752f, -0.03347762f, -0.07102639f, 
    -0.38494802f, -0.53484869f, -0.08807264f, -0.03142082f, -0.11970182f, -0.03423981f, 0.01139841f, -0.06888231f, 
    0.03641934f, -0.10178372f, 0.07898658f, -0.04039072f, -0.18769641f, -0.01732630f, 0.00293969f, -0.06368544f, 
    -0.05122760f, -0.01427176f, 0.02574171f, -0.03321151f, -0.12524135f, 0.10442481f, 0.02717268f, 0.03449334f, 
    -0.17154028f, 0.04694103f, -0.02223468f, -0.03342232f, -0.04848155f, -0.02822992f, 0.04853354f, 0.06168485f, 
    -0.03090381f, -0.08368655f, 0.00858053f, 0.01474155f, -0.08963040f, -0.01404214f, -0.06053302f, -0.00203901f, 
    -0.06332750f, -0.06482705f, -0.03286597f, -0.01733115f, 0.08910826f, -0.01165134f, 0.04023225f, -0.00561781f, 
    -0.23686123f, -0.37236315f, -0.15544148f, 0.11663029f, -0.08133867f, 0.00076709f, 0.02563987f, -0.09783360f, 
    0.06052108f, -0.11340348f, 0.02339160f, 0.01544613f, -0.37805998f, -0.04589923f, 0.09717388f, 0.14550330f, 
    0.04866468f, 0.11224569f, -0.10788211f, -0.06311172f, 0.03662433f, 0.02638068f, 0.12314317f, -0.02297387f, 
    -0.05200665f, -0.07268990f, 0.05173915f, -0.03730831f, -0.00949105f, 0.04362526f, 0.08201898f, 0.12703100f, 
    -0.00139647f, 0.08407353f, -0.06624430f, 0.02425288f, -0.05902988f, -0.03939086f, 0.02322124f, -0.09694570f, 
    -0.00027110f, -0.04339600f, -0.05032128f, 0.01662469f, -0.02235472f, 0.08633742f, 0.12243038f, -0.11060904f, 
    0.08948085f, -0.04917078f, 0.03450485f, 0.01029726f, -0.10807688f, 0.04972776f, 0.04678051f, 0.17083758f, 
    0.01545557f, 0.06040509f, 0.01113099f, -0.02136548f, 0.17554553f, 0.04093483f, 0.06689626f, 0.04984854f, 
    -0.10131458f, -0.00099493f, -0.03917831f, 0.04781276f, 0.00876715f, 0.06856339f, 0.05112440f, -0.04370498f, 
    0.05256168f, -0.29887262f, 0.03335319f, 0.08110838f, -0.04276377f, 0.01428603f, -0.03863525f, 0.02810283f, 
    0.07790197f, -0.05688395f, 0.04281977f, -0.03216647f, 0.15989172f, -0.08415002f, 0.22044045f, -0.05216620f, 
    0.06894940f, 0.02070370f, 0.04311044f, -0.08900843f, 0.04404527f, 0.00713579f, 0.02392922f, 0.05441220f, 
    -0.06648610f, 0.20400676f, 0.04950725f, -0.00199952f, -0.01747398f, -0.10490686f, 0.04547932f, 0.09709349f, 
    -0.00781802f, 0.00934044f, -0.02429656f, 0.02282332f, 0.34159783f, 0.03056050f, 0.06418049f, 0.16754666f, 
    0.07234281f, -0.03796054f, -0.04549173f, 0.11950620f, 0.00884452f, -0.07674526f, 0.01734130f, -0.16043334f, 
    -0.03946991f, -0.17206857f, -0.15121670f, 0.28640664f, 0.01687804f, 0.03759411f, -0.05133807f, -0.09835282f, 
    -0.00810754f, -0.05363149f, -0.06010787f, -0.09129871f, 0.10211269f, -0.03167543f, 0.04001058f, 0.00587126f, 
    -0.06874233f, -0.09112310f, -0.02085039f, -0.08221097f, 0.02286251f, 0.04402427f, 0.17105751f, 0.01832286f, 
    -0.09737345f, 0.04303485f, -0.05976683f, -0.27791095f, -0.04545747f, -0.11764837f, 0.09652986f, -0.03536613f, 
    -0.04512305f, -0.03121530f, -0.08751847f, -0.03372769f, 0.26631254f, -0.11724950f, 0.02161531f, -0.04454671f, 
    0.06638466f, -0.00373517f, 0.13242240f, 0.06177431f, -0.11341481f, 0.02596100f, 0.12204253f, -0.03003007f, 
    -0.04896671f, 0.11591308f, 0.08893896f, -0.07278372f, -0.04573893f, 0.05305520f, 0.08139937f, 0.04231268f, 
    -0.02445277f, 0.07790946f, -0.00449264f, 0.05471473f, -0.11638203f, 0.01684465f, 0.32050958f, -0.01504693f, 
    0.05310206f, -0.10301633f, 0.11141474f, 0.06050140f, 0.00919777f, -0.03379649f, -0.09176583f, 0.09799591f, 
    -0.01167558f, 0.01872456f, 0.13796555f, 0.18640904f, 0.04924282f, 0.08270594f, 0.11879164f, 0.00485744f, 
    -0.03841658f, -0.02259713f, 0.01960611f, -0.13563475f, 0.20695156f, 0.07866091f, 0.00457481f, 0.03657783f, 
    0.05481685f, -0.07572094f, 0.05823399f, -0.00261752f, -0.09299521f, 0.01811203f, -0.03865315f, -0.05593606f, 
    -0.26269373f, -0.39490682f, -0.15522474f, 0.03042151f, -0.18288220f, -0.05263967f, -0.13165361f, 0.00610714f, 
    -0.01226209f, 0.06468797f, -0.04161119f, 0.03444328f, -0.25146237f, 0.03336947f, -0.01543008f, 0.17570283f, 
    -0.06807251f, -0.09836007f, -0.03431004f, 0.07192487f, 0.01720887f, 0.01966395f, 0.00283379f, -0.06723502f, 
    -0.08484992f, -0.27923879f, -0.06509940f, 0.00057810f, -0.00932812f, -0.08186406f, -0.08613818f, 0.08768205f, 
    0.01556158f, -0.00185725f, 0.09274835f, 0.03872190f, -0.00224220f, 0.06554981f, 0.16864400f, -0.02029425f, 
    0.04039785f, -0.06813338f, -0.06638718f, -0.02102190f, -0.04958700f, -0.03521648f, -0.06346552f, -0.01534802f, 
    -0.04079914f, 0.09869392f, -0.07876660f, -0.05015802f, 0.03205453f, -0.09142808f, -0.02188819f, 0.05948922f, 
    -0.02776388f, 0.00857752f, -0.00604402f, -0.00230524f, 0.35874143f, 0.19967288f, 0.11837967f, 0.06227296f, 
    0.02253152f, 0.03476538f, -0.00093441f, 0.00058099f, 0.00794047f, 0.05831720f, -0.11192834f, -0.07291912f, 
    0.13291423f, -0.07606815f, -0.06689098f, 0.08903436f, -0.08523314f, -0.08826458f, 0.02187668f, 0.04530884f, 
    -0.10147358f, 0.06840982f, -0.06431857f, 0.05704677f, -0.26599762f, -0.25429845f, -0.16115075f, 0.04411672f, 
    -0.13807373f, 0.02942907f, -0.02143492f, -0.06328949f, -0.05216134f, -0.02193879f, -0.03629772f, 0.06807073f, 
    0.09340838f, -0.28600469f, -0.11535161f, -0.09292468f, 0.03358338f, -0.00898556f, 0.01646734f, -0.04483330f, 
    -0.13372324f, -0.04304582f, 0.00060733f, -0.08138110f, -0.25399375f, -0.16611187f, -0.10633203f, -0.15594353f, 
    -0.04554463f, 0.03142720f, -0.07582932f, 0.02070737f, -0.04485516f, 0.00188229f, -0.00771051f, -0.09211233f, 
    0.04264821f, 0.03088855f, 0.02685461f, 0.06074736f, -0.03163312f, 0.05516488f, 0.04338327f, -0.01308443f, 
    -0.03670713f, 0.01545233f, -0.15261187f, 0.10814679f, 0.12261695f, 0.03534686f, 0.12075406f, -0.05241306f, 
    -0.02929772f, 0.03558591f, -0.06641220f, 0.00731562f, 0.03090695f, 0.01896107f, -0.09803423f, 0.08921330f, 
    -0.11586906f, -0.17587757f, -0.04440911f, -0.16421343f, -0.07370649f, -0.09842769f, -0.01322510f, -0.02483052f, 
    -0.08710255f, -0.09373578f, -0.04067172f, -0.02020433f, 0.13529293f, -0.12148707f, 0.13095024f, 0.11906384f, 
    0.05189306f, 0.01800467f, 0.11278716f, 0.09229998f, 0.05456651f, -0.08425010f, -0.00664669f, 0.00275062f, 
    0.34841904f, -0.02342566f, -0.13438413f, -0.03263310f, -0.00661108f, 0.09227043f, -0.14011748f, 0.08445714f, 
    0.19373180f, -0.07701673f, 0.02675023f, -0.07721327f, -0.18669842f, -0.05383896f, 0.10708443f, -0.05244413f, 
    -0.06081394f, -0.05849703f, 0.02415833f, -0.00666104f, -0.04501828f, -0.11183421f, -0.10504252f, 0.05376477f, 
    0.05542729f, -0.04364581f, -0.04564497f, -0.01707643f, -0.04578575f, -0.00806441f, 0.03500199f, 0.09523395f, 
    -0.01558734f, 0.03720130f, 0.01412628f, -0.00916097f, 0.07617416f, 0.18950510f, 0.18853925f, 0.21212904f, 
    0.00022507f, 0.15013410f, -0.05734556f, -0.04928147f, 0.08341961f, 0.02322279f, -0.03658910f, -0.01501689f, 
    0.00816602f, 0.10884459f, -0.00836873f, -0.06517282f, -0.07064375f, 0.10236619f, 0.03139156f, 0.05618530f, 
    0.08449379f, -0.03679690f, -0.20718831f, -0.00258253f, 0.27392080f, -0.14706604f, -0.29568025f, -0.04396497f, 
    -0.03696317f, -0.05445749f, 0.01780565f, -0.00359449f, 0.02514743f, -0.11407476f, 0.03834252f, 0.04667581f, 
    0.14224008f, -0.20958541f, 0.01702781f, 0.01071588f, 0.00150252f, 0.07335486f, 0.04915275f, 0.05321182f, 
    0.01939109f, 0.05954086f, 0.01819638f, 0.10288936f, -0.10004668f, 0.13747124f, 0.09517697f, -0.19866318f, 
    0.01117939f, 0.06600873f, -0.03244623f, 0.05094507f, 0.06477143f, -0.12934384f, -0.01831841f, -0.00983796f, 
    0.27877215f, 0.00930418f, 0.08884617f, 0.22315003f, 0.04851778f, 0.15209788f, 0.13821219f, -0.06837640f, 
    0.04823473f, 0.05015668f, 0.02535900f, -0.20180114f, -0.04797519f, -0.12735772f, 0.07093219f, -0.05362160f, 
    0.01071859f, 0.00571815f, 0.06734334f, 0.05543938f, -0.04814817f, -0.03372523f, -0.00602267f, -0.01212645f, 
    -0.26635799f, -0.55403769f, -0.06087943f, 0.14598125f, -0.05950169f, -0.01137363f, 0.04737694f, -0.11489119f, 
    -0.05754789f, -0.04095625f, -0.04195656f, -0.16332290f, -0.12334076f, -0.09744232f, -0.05911523f, -0.03256588f, 
    -0.13155995f, -0.13793586f, 0.00756124f, 0.11749543f, 0.03966064f, -0.17407362f, 0.11868566f, -0.07319544f, 
    -0.37222457f, -0.16031729f, -0.09804841f, -0.21614608f, -0.03782067f, 0.07154345f, -0.19440597f, 0.10696822f, 
    -0.04268010f, 0.06932457f, -0.03303933f, -0.06492632f, -0.26387584f, 0.18755430f, 0.18494812f, -0.19532524f, 
    -0.00252068f, -0.06426569f, 0.03488574f, 0.09718700f, -0.04263352f, 0.00179659f, 0.04166513f, 0.02612976f, 
    0.00891696f, 0.22055303f, 0.16343932f, -0.15956241f, -0.08960086f, 0.04072463f, -0.00980092f, 0.03908341f, 
    -0.01763576f, -0.08484387f, 0.09029973f, 0.13013151f, -0.01641443f, -0.00644268f, -0.01419022f, -0.12684980f, 
    -0.11010122f, 0.07745009f, -0.06399661f, 0.04756436f, -0.04292779f, -0.05272862f, 0.03366904f, 0.05581955f, 
    0.05414141f, 0.24577898f, 0.14156215f, 0.10039100f, -0.10369989f, -0.01164446f, 0.00813578f, -0.06234825f, 
    0.04342470f, -0.04282249f, 0.09062739f, 0.01792059f, 0.05278615f, -0.11462644f, -0.04606564f, 0.13195026f, 
    -0.01631668f, 0.09426048f, 0.03623900f, -0.03547767f, 0.01436531f, -0.11440118f, 0.07589418f, -0.00057998f, 
    0.26244146f, -0.17683527f, -0.02168467f, -0.06490309f, -0.08559963f, -0.01140980f, 0.01905038f, -0.02976305f, 
    -0.03709530f, -0.09939203f, 0.05700644f, -0.06024802f, 0.08420417f, -0.01360843f, 0.03230765f, 0.04896056f, 
    0.01958874f, -0.07271884f, -0.03414357f, 0.02158574f, -0.01960602f, 0.03108393f, 0.00152968f, -0.01606003f, 
    0.24337830f, -0.19750026f, -0.13023610f, 0.05659543f, -0.13942443f, 0.01763815f, -0.00652763f, 0.08961606f, 
    -0.04513379f, -0.04165725f, -0.01679640f, 0.04617475f, 0.08066315f, -0.01168820f, 0.08223969f, 0.04964165f, 
    0.01390949f, 0.07423064f, 0.00153363f, 0.02375992f, 0.06883460f, -0.10783526f, 0.04031924f, -0.04845079f, 
    -0.12660486f, 0.03126029f, 0.03575680f, -0.28864846f, -0.06952956f, -0.11944869f, -0.09244221f, -0.05355897f, 
    0.05838431f, -0.17809816f, 0.02303156f, -0.00609759f, -0.25125492f, 0.03082446f, -0.03459097f, 0.30429581f, 
    0.10833751f, 0.02252568f, 0.00761918f, -0.00821987f, -0.04114312f, 0.06824160f, 0.00050879f, -0.09464032f, 
    -0.34825796f, 0.13238701f, 0.09154157f, 0.07410032f, 0.04389305f, 0.07844175f, -0.07852323f, 0.07693779f, 
    0.01033489f, 0.08136329f, 0.08511025f, -0.01389296f, 0.23641759f, 0.35357115f, -0.16894472f, -0.38788632f, 
    0.03454544f, -0.09386101f, -0.01739089f, -0.02381408f, -0.04233404f, -0.01607847f, 0.09753760f, 0.03130028f, 
    0.05020778f, -0.04536905f, -0.05927939f, 0.22484255f, 0.16179919f, 0.12053107f, 0.01173939f, 0.19493626f, 
    0.02541052f, 0.06919191f, 0.03849114f, -0.07256516f, -0.32470390f, -0.01227425f, -0.20676130f, 0.00579194f, 
    0.06956206f, 0.05347132f, -0.03149389f, 0.01249400f, 0.00356537f, -0.07674918f, -0.00822490f, 0.04947321f, 
    0.19386944f, 0.17035213f, -0.00339294f, 0.06009867f, -0.08513094f, 0.05716992f, 0.07791357f, 0.08463059f, 
    -0.05057776f, 0.06133861f, 0.00254833f, 0.05394156f, -0.25890362f, -0.10641360f, -0.00748353f, 0.08737388f, 
    0.06338020f, -0.11662459f, 0.07174352f, -0.03896635f, -0.07035296f, -0.07679959f, 0.05132547f, 0.04055864f, 
    0.02909311f, -0.14354640f, -0.03148938f, 0.19372550f, 0.05562792f, -0.09150536f, -0.01469294f, 0.10798856f, 
    -0.07390619f, -0.04284017f, -0.03266076f, 0.00328247f, -0.33830613f, 0.10037243f, 0.09129881f, 0.22409810f, 
    0.06578182f, -0.02856231f, 0.06012556f, 0.12558013f, -0.02569174f, -0.00102069f, 0.02822199f, 0.03003489f, 
    0.12122513f, 0.07618534f, -0.20345096f, 0.04173528f, 0.06076565f, -0.03945461f, 0.06770866f, 0.08827730f, 
    -0.04024070f, 0.05193175f, 0.03072670f, 0.07232799f, -0.47379547f, 0.21808633f, 0.00343538f, -0.16424409f, 
    0.04386386f, -0.08321016f, 0.02278744f, 0.05290200f, -0.04198568f, -0.00961129f, -0.08496023f, 0.00473656f, 
    -0.02958867f, -0.10548561f, 0.06114506f, -0.03671202f, -0.14221036f, 0.03219600f, 0.07656346f, -0.04315139f, 
    -0.04990740f, 0.10581119f, -0.05492275f, 0.08241671f, 0.07933980f, 0.14452580f, -0.05407314f, -0.08953894f, 
    0.02200116f, -0.00603052f, -0.16112915f, -0.00644644f, 0.06564926f, -0.08991756f, -0.01961818f, -0.03961972f, 
    0.12848528f, -0.06699388f, 0.05464198f, 0.00676227f, -0.11916809f, 0.00421675f, 0.06306993f, -0.05486051f, 
    -0.00525166f, 0.14845097f, 0.02915741f, -0.03600588f, -0.01805617f, 0.00605797f, -0.00489940f, -0.00778920f, 
    0.09557852f, 0.05580011f, 0.01876076f, 0.09172042f, 0.00894079f, 0.07429615f, -0.03795065f, 0.09746546f, 
    0.00872116f, 0.17971337f, 0.12957264f, 0.15129738f, 0.02351170f, 0.01129030f, 0.05940637f, 0.07687996f, 
    -0.01951770f, -0.02986889f, 0.00854034f, 0.00308444f, 0.06524707f, 0.18916206f, -0.00671656f, 0.05782145f, 
    0.05527500f, -0.04701947f, -0.04320988f, -0.04046100f, 0.02071481f, 0.02332858f, -0.02137307f, -0.03765152f, 
    -0.17806239f, -0.11562699f, 0.04317772f, -0.16379273f, 0.05606071f, -0.01877563f, 0.03106995f, -0.03225069f, 
    -0.04348074f, -0.13162093f, -0.10698368f, 0.06667830f, -0.02597502f, 0.31014985f, -0.10326680f, -0.38404509f, 
    -0.01112186f, -0.09366184f, 0.03328149f, -0.01512213f, 0.10966183f, 0.02750378f, 0.04557874f, 0.01212669f, 
    -0.18555799f, -0.03455438f, 0.12857778f, 0.15086579f, -0.03241595f, 0.03779653f, -0.07883987f, -0.06551772f, 
    0.06858921f, 0.02314650f, -0.10755248f, -0.06583922f, -0.19997674f, 0.17780520f, -0.08128452f, 0.06798320f, 
    -0.02330451f, -0.02988087f, 0.01017772f, 0.03902036f, -0.10140538f, -0.03308961f, 0.10677750f, 0.06496064f, 
    0.16271557f, 0.06649248f, 0.04201833f, 0.05629862f, 0.16475099f, 0.05098048f, 0.03501729f, 0.09838192f, 
    -0.03922934f, 0.01745138f, 0.00029911f, -0.07040012f, -0.19107121f, -0.18243900f, -0.08489409f, -0.07396949f, 
    -0.05344572f, 0.12517790f, -0.07663997f, -0.00431318f, -0.01277391f, 0.02490010f, -0.03567911f, 0.13059296f, 
    0.21159260f, -0.08129710f, 0.11734559f, -0.00790012f, 0.02595397f, 0.11034968f, -0.07371586f, 0.10961067f, 
    -0.10865275f, 0.08620020f, -0.06368811f, 0.15419139f, -0.37041473f, 0.06705937f, -0.05704476f, -0.15333401f, 
    0.06714798f, -0.11108714f, 0.02534820f, 0.02028235f, -0.03198285f, 0.06517685f, 0.05557607f, -0.14090402f, 
    -0.12723160f, 0.07383697f, 0.09206377f, 0.09278393f, 0.01395560f, 0.04339672f, -0.02262990f, -0.01570117f, 
    0.00659863f, 0.05830995f, -0.06205687f, -0.04965159f, 0.00113921f, -0.07606493f, 0.02645908f, -0.24793841f, 
    0.10455942f, 0.03465082f, -0.05296153f, -0.02528846f, -0.12236676f, -0.04141435f, 0.06156817f, -0.03619731f, 
    -0.37268153f, -0.18029000f, 0.05172673f, 0.02212393f, 0.02323715f, -0.03304729f, 0.08909781f, 0.11078936f, 
    0.00714345f, -0.01120521f, -0.00325183f, 0.02825655f, -0.17312142f, 0.07452077f, -0.01520983f, -0.25228408f, 
    -0.08122353f, 0.03984809f, -0.06071448f, 0.11394452f, -0.03987509f, 0.04181408f, -0.00104509f, 0.01099280f, 
    -0.07986879f, 0.26495290f, -0.04758207f, -0.10737976f, 0.06195644f, -0.04955889f, -0.00313600f, -0.01204634f, 
    -0.04859874f, -0.09089716f, 0.05233620f, -0.00023726f, -0.23849988f, -0.05991631f, 0.04569232f, -0.11120729f, 
    -0.03888884f, -0.01877622f, -0.04088042f, 0.02482014f, -0.06135553f, 0.01039630f, -0.05946323f, -0.02605704f, 
    -0.36167914f, -0.18434063f, -0.08697277f, -0.40914354f, -0.00404242f, 0.03252838f, 0.08798499f, -0.09067588f, 
    -0.00283474f, -0.05280022f, -0.08348056f, 0.01425836f, 0.21162865f, 0.03437964f, -0.09651985f, -0.29443324f, 
    0.05403523f, 0.03645115f, 0.01686828f, -0.02150453f, 0.01445937f, -0.00103269f, -0.06059837f, -0.02408521f, 
    -0.05397273f, -0.05957924f, -0.10801082f, -0.09503955f, -0.05618164f, 0.06473655f, 0.02186630f, -0.06311294f, 
    0.01805728f, 0.05368940f, -0.06241021f, -0.04770934f, -0.01733718f, 0.03350553f, -0.04196437f, -0.03133114f, 
    -0.08458213f, 0.00466421f, 0.08102388f, 0.08433499f, 0.04382126f, 0.06030385f, 0.00160437f, -0.03389442f, 
    -0.16042654f, -0.07580609f, 0.09232506f, 0.21074697f, -0.02843110f, -0.02412082f, -0.05954596f, -0.02900833f, 
    0.09196858f, 0.04438594f, -0.05553960f, -0.08571368f, -0.54995662f, 0.13152783f, 0.08713335f, 0.14370857f, 
    -0.06871523f, -0.08281904f, -0.01188580f, -0.04332770f, -0.12223840f, 0.04268757f, 0.05683432f, 0.01782961f, 
    -0.00333494f, 0.13361430f, 0.04763658f, 0.01169580f, 0.02276097f, 0.15265295f, -0.08111631f, -0.01024374f, 
    -0.01524065f, -0.03868277f, 0.05113003f, 0.17601758f, -0.02551676f, -0.10667007f, 0.23498237f, 0.00469264f, 
    -0.05638654f, -0.02236896f, 0.02801505f, 0.00622948f, 0.08546752f, -0.06777490f, -0.07778317f, 0.00042180f, 
    -0.22438045f, 0.11221219f, 0.02044655f, 0.10610176f, 0.04594149f, 0.03382806f, 0.00003973f, -0.05931712f, 
    -0.01677182f, -0.05148483f, -0.02453459f, 0.01922795f, -0.25435773f, 0.01093863f, -0.07535897f, -0.00747700f, 
    0.02906822f, 0.01662955f, 0.07388125f, 0.03145737f, 0.00676809f, 0.09351876f, -0.02424506f, 0.01205344f, 
    0.10717941f, -0.11467065f, -0.08880575f, 0.10638075f, -0.09069566f, 0.01758915f, 0.10271004f, 0.01000285f, 
    -0.03284774f, 0.05776989f, -0.00950583f, 0.01019063f, -0.12235926f, 0.07376946f, -0.16794717f, -0.10066733f, 
    0.04260931f, 0.05801618f, 0.02567373f, 0.11589650f, 0.02029039f, -0.05156823f, -0.00685095f, -0.03013541f, 
    -0.16509002f, 0.00236784f, -0.01181186f, 0.10135004f, 0.03959004f, -0.06641659f, 0.12213778f, 0.01771354f, 
    -0.10708905f, 0.02800003f, -0.04607734f, 0.06896367f, -0.20584306f, -0.09547126f, 0.08428445f, 0.13248669f, 
    -0.00450784f, -0.04615750f, -0.08102751f, -0.08395693f, 0.06629670f, 0.02814712f, -0.04586807f, 0.09590648f, 
    0.17619826f, -0.04400416f, 0.01429435f, 0.15395388f, -0.00027737f, 0.02019310f, 0.00540094f, 0.07553490f, 
    0.00775696f, 0.06077779f, 0.10656325f, 0.03205137f, 0.15102737f, -0.00241109f, -0.16786231f, 0.03668463f, 
    -0.13245225f, -0.03746060f, 0.03029889f, -0.06814767f, -0.08144041f, -0.08841315f, -0.00733280f, -0.03043170f, 
    0.05531067f, -0.24894974f, 0.20538524f, -0.04450746f, -0.12036810f, 0.06270500f, 0.01211807f, -0.11762601f, 
    0.06368216f, -0.10647900f, 0.03637836f, -0.03433881f, 0.24324693f, -0.00682523f, 0.03685094f, 0.05170029f, 
    0.05240520f, -0.00298928f, 0.05339934f, 0.05404768f, -0.03875078f, -0.04799963f, -0.00487410f, 0.03455404f, 
    -0.07195935f, -0.16641550f, -0.08569767f, 0.04659294f, 0.07352265f, 0.00966361f, 0.05375598f, -0.02797733f, 
    0.10489137f, -0.15379690f, -0.04523752f, -0.17663468f, -0.13640068f, -0.04938807f, -0.15044780f, 0.17502585f, 
    0.06285219f, 0.02933672f, -0.06356656f, -0.00229228f, 0.07763514f, -0.06402042f, -0.04527346f, -0.09194981f, 
    -0.04241582f, -0.04639374f, 0.15862942f, -0.06418560f, -0.01264880f, -0.13507544f, -0.03656143f, 0.02905710f, 
    -0.00698610f, -0.00259438f, 0.01535323f, -0.11213265f, 0.33357045f, 0.22916302f, -0.21358308f, -0.02863049f, 
    -0.04220039f, 0.12117734f, 0.02586349f, 0.06506637f, -0.02639948f, -0.04048562f, -0.00356228f, 0.05598098f, 
    -0.19685125f, -0.05543654f, 0.23161168f, 0.03653739f, -0.01946451f, 0.12039637f, -0.02946681f, 0.19274385f, 
    0.08140837f, 0.07892629f, 0.09840582f, 0.14749254f, 0.24127312f, 0.30538920f, -0.27520740f, -0.10354586f, 
    0.03480856f, -0.04847253f, 0.03797190f, -0.01136652f, -0.02926023f, -0.03383020f, -0.03166450f, 0.04856148f, 
    0.19318248f, -0.02933165f, 0.14336802f, -0.06394339f, 0.01588911f, 0.01594439f, 0.01511798f, 0.06837848f, 
    0.00558677f, 0.00398021f, -0.15079948f, 0.07235152f, -0.14525177f, -0.15321542f, 0.08234654f, 0.04955336f, 
    -0.04988327f, -0.11700315f, 0.04847361f, 0.02533945f, -0.00580091f, -0.01742988f, -0.01373334f, -0.00204125f, 
    -0.17764188f, -0.03401079f, 0.01922005f, -0.04435546f, 0.08065424f, -0.01442784f, 0.02734600f, 0.05135739f, 
    -0.03544907f, -0.10756757f, 0.05209881f, -0.05452053f, -0.15613335f, 0.21848045f, 0.09324788f, 0.03808987f, 
    0.07191733f, 0.02510033f, 0.03980138f, 0.02033745f, 0.15917180f, 0.00162700f, -0.00091275f, -0.11277255f, 
    -0.66358626f, -0.01481312f, -0.02400831f, 0.01619026f, 0.02620040f, 0.07072710f, -0.01689049f, 0.00798431f, 
    -0.05345218f, 0.00952981f, 0.07614594f, 0.04944012f, -0.37903669f, 0.02440028f, 0.03980657f, 0.13198423f, 
    0.07775235f, 0.03548186f, 0.00491919f, 0.12676914f, -0.07267194f, -0.09304899f, -0.02475252f, 0.03340816f, 
    -0.01843174f, 0.13189882f, 0.00338808f, -0.04382000f, 0.04620099f, 0.06124601f, -0.04336511f, -0.03689416f, 
    -0.02273219f, -0.06979372f, -0.10577647f, -0.11096122f, -0.08337653f, 0.01868199f, -0.02937447f, 0.06657750f, 
    -0.05497372f, -0.10721251f, -0.06788132f, -0.08507784f, -0.07319757f, -0.05610967f, -0.00346208f, -0.10334042f, 
    -0.17068560f, -0.05182645f, -0.03680078f, 0.26524481f, -0.01196492f, -0.01457191f, 0.11533800f, 0.00290114f, 
    0.03499516f, -0.07250145f, 0.00386124f, 0.08654124f, -0.39749107f, -0.14949510f, 0.24065167f, 0.10870334f, 
    -0.09978361f, -0.04036554f, -0.03782357f, -0.01509362f, 0.06606276f, -0.04632505f, -0.02274343f, 0.00140465f, 
    -0.27431956f, -0.07084026f, -0.16078793f, -0.07322992f, 0.07781488f, -0.09507157f, -0.06155276f, 0.04389978f, 
    0.10555736f, -0.06334897f, -0.12536830f, -0.05692963f, -0.17751075f, -0.39933527f, 0.36743045f, 0.22307497f, 
    0.05838169f, 0.05001748f, 0.08733399f, 0.01503339f, -0.01945996f, -0.00423767f, -0.03632563f, 0.06787772f, 
    -0.41253641f, -0.24210389f, -0.13493797f, 0.08803372f, 0.03951836f, 0.01836625f, -0.04186206f, -0.11528565f, 
    -0.07038140f, -0.04600022f, -0.08999535f, 0.03672999f, -0.34532595f, 0.11361502f, 0.02801898f, -0.15239908f, 
    -0.04340069f, -0.03114659f, 0.11544585f, -0.02032881f, -0.00709428f, -0.04160074f, 0.08427518f, -0.03212778f, 
    -0.19744304f, 0.00599818f, 0.16057195f, -0.20204870f, 0.09015293f, -0.04023365f, 0.03029921f, -0.01640760f, 
    0.01734004f, 0.05994419f, -0.00006702f, -0.11416721f, 0.16887446f, 0.02722516f, 0.09739235f, -0.10475266f, 
    0.07273832f, 0.08488578f, -0.24795134f, -0.01444891f, 0.08336335f, -0.06324346f, 0.02273142f, -0.17331654f, 
    0.16442172f, -0.09112053f, 0.00731105f, -0.07731143f, 0.06046141f, 0.11769214f, -0.07357290f, -0.11075786f, 
    -0.02098606f, 0.05544414f, 0.04929739f, 0.00002382f, -0.07102601f, 0.02713411f, -0.21191263f, -0.19286150f, 
    -0.04521141f, 0.07585017f, -0.04932389f, -0.11630431f, 0.00376760f, -0.22787622f, -0.07840115f, -0.10378800f, 
    0.02336658f, 0.14897418f, 0.26952508f, -0.03228542f, 0.05750584f, -0.07833527f, -0.04240793f, -0.18169624f, 
    -0.03795858f, 0.02072655f, -0.10041945f, -0.00851377f, -0.15314142f, 0.13177805f, 0.12947235f, -0.08836856f, 
    -0.01734005f, 0.00614340f, 0.03473959f, 0.14015226f, 0.04395766f, 0.11908852f, -0.02038240f, -0.07145684f, 
    -0.01418430f, 0.02023012f, 0.03687981f, 0.18619031f, 0.00793196f, -0.07353733f, 0.03120260f, 0.02724201f, 
    -0.01404339f, -0.10140543f, 0.09384979f, 0.13407251f, -0.32097438f, -0.22554135f, -0.09730399f, 0.04979479f, 
    0.03788085f, -0.04270285f, 0.07344038f, -0.13817450f, 0.07047102f, -0.02407120f, 0.05464247f, 0.06139730f, 
    0.02080683f, -0.00394249f, 0.02001148f, 0.05925801f, 0.02065450f, 0.01691237f, 0.01352531f, -0.12668037f, 
    0.00839700f, -0.12891997f, -0.10503286f, -0.12859458f, 0.03437399f, -0.08746237f, 0.01237193f, 0.14503476f, 
    0.00195435f, 0.06872634f, 0.03898885f, 0.13378657f, -0.02938847f, 0.04476549f, 0.09977309f, -0.07157509f, 
    -0.07331736f, -0.07126360f, 0.07649827f, 0.28565857f, -0.18420906f, -0.08139160f, 0.04538238f, -0.01736223f, 
    0.07642999f, 0.01032067f, 0.05079160f, 0.07016548f, -0.04392273f, -0.08928142f, -0.14848398f, 0.01307688f, 
    0.09268570f, -0.02007448f, 0.08104304f, 0.02807275f, 0.03698320f, 0.08468424f, 0.13696381f, 0.08438239f, 
    -0.30508968f, -0.04392262f, 0.01237439f, 0.17888138f, 0.00504880f, -0.04669401f, 0.20039167f, 0.02241050f, 
    0.09686170f, -0.06999592f, 0.11605699f, -0.20600943f, -0.18931101f, -0.40327933f, 0.09585035f, -0.01994793f, 
    -0.05477562f, 0.06785380f, 0.07895152f, -0.01729087f, -0.09278481f, 0.06032250f, -0.04699543f, 0.12381534f, 
    0.08943251f, -0.04640208f, -0.07572912f, -0.01158736f, -0.11690164f, 0.11630128f, 0.03918194f, -0.02271391f, 
    -0.10825144f, 0.08785449f, -0.02272985f, 0.22003016f, -0.15085906f, 0.12535289f, -0.05592504f, -0.17610684f, 
    0.05154524f, 0.02587982f, 0.01713803f, -0.26791179f, -0.02853665f, -0.04953848f, -0.25773585f, -0.00989645f, 
    -0.22582603f, -0.14707221f, -0.11540582f, 0.11841286f, 0.11085516f, -0.01129750f, -0.01128149f, 0.00636718f, 
    0.19830333f, 0.17645951f, -0.01829028f, 0.18294045f, -0.19824430f, 0.14460684f, -0.16042487f, -0.01016681f, 
    0.12916368f, -0.13907668f, 0.15015638f, -0.03601379f, 0.05078393f, -0.03356977f, -0.02673811f, -0.07565983f, 
    0.16133080f, -0.01960099f, -0.16387920f, 0.01067252f, 0.10132074f, -0.08827274f, -0.05894086f, -0.04600821f, 
    0.08194982f, -0.15471599f, 0.07588109f, 0.02502348f, -0.14002591f, -0.00646403f, 0.02549818f, -0.16278711f, 
    0.04232354f, 0.04437679f, 0.05952791f, -0.08472016f, 0.07220057f, -0.04919325f, 0.07096665f, 0.02787533f, 
    0.06342805f, -0.03620626f, -0.04615706f, 0.08934564f, -0.02725254f, 0.05652400f, 0.00864568f, -0.01165070f, 
    -0.05677707f, 0.01475767f, 0.14633751f, 0.15748620f, -0.00313534f, 0.06783108f, 0.29444662f, -0.17824224f, 
    -0.04263441f, 0.07509901f, -0.02203895f, 0.04574720f, -0.02126963f, 0.05298286f, 0.07238664f, 0.02825288f, 
    0.05193854f, -0.10998142f, -0.03525098f, 0.01672591f, 0.01819607f, -0.03738276f, 0.02575306f, 0.03427953f, 
    -0.01355226f, -0.12713547f, 0.02036771f, -0.10494650f, -0.02248642f, -0.06945192f, 0.01942034f, 0.24170946f, 
    0.03397911f, 0.02990850f, -0.06440434f, -0.08401971f, 0.02650568f, 0.10500365f, 0.03298579f, 0.12695473f, 
    0.18420814f, 0.19111808f, 0.04836074f, 0.05055107f, 0.00995757f, 0.02932882f, 0.01815890f, -0.04785443f, 
    -0.08905034f, 0.04244439f, 0.03309958f, -0.17249762f, 0.11330803f, 0.14036150f, 0.07201057f, 0.01978679f, 
    -0.05125747f, -0.03860494f, -0.01016585f, 0.08223259f, 0.04606519f, -0.09546205f, 0.02540595f, 0.08577375f, 
    -0.60274607f, 0.07157174f, 0.21306765f, -0.19208832f, 0.01088617f, 0.06970683f, 0.00630993f, -0.05154743f, 
    -0.00431455f, 0.01231914f, -0.00387943f, -0.06010047f, -0.40191072f, -0.19541231f, 0.14747398f, 0.23007961f, 
    -0.10265185f, 0.00258659f, 0.00220553f, 0.03083267f, -0.06697382f, -0.00920939f, -0.02123923f, -0.07240196f, 
    -0.12870489f, 0.28913361f, 0.00439738f, 0.20959808f, 0.04278396f, 0.00768512f, -0.03977871f, -0.07750667f, 
    0.10415270f, -0.03294630f, -0.00087757f, 0.03434087f, 0.03060570f, 0.06599058f, 0.17187704f, -0.14373170f, 
    0.05671678f, 0.00922707f, -0.08172562f, -0.08367754f, -0.00518186f, -0.02113716f, 0.04770982f, 0.14040340f, 
    0.14715783f, 0.04222938f, 0.07989305f, 0.09028438f, -0.01954456f, -0.01400723f, 0.03800829f, 0.06564003f, 
    -0.00400385f, 0.09100417f, 0.09634531f, 0.12435725f, 0.06258743f, 0.13854295f, -0.19637457f, -0.10292064f, 
    -0.09018003f, 0.08115698f, -0.15131518f, 0.05648961f, -0.03877734f, -0.12857963f, -0.02974693f, -0.13298665f, 
    0.08871959f, 0.13657403f, -0.01960246f, 0.00677229f, 0.18954730f, -0.11698177f, -0.08506972f, -0.03884896f, 
    0.06649771f, -0.03212787f, 0.01286189f, -0.04148702f, -0.24811986f, -0.00351984f, 0.05573666f, 0.10628532f, 
    0.10121424f, -0.06762502f, -0.09147091f, -0.06912945f, -0.07950338f, 0.12187134f, 0.23973820f, -0.01891851f, 
    0.04953323f, 0.12784712f, -0.09169757f, -0.07659325f, -0.08088738f, 0.07540791f, 0.09950161f, -0.00218069f, 
    0.05007726f, -0.04492747f, 0.06876911f, -0.01127402f, -0.13819359f, -0.04887076f, 0.08857878f, -0.13418330f, 
    0.04882992f, 0.04496108f, -0.04509845f, -0.13018386f, -0.07098400f, 0.08243475f, 0.01248009f, 0.14951390f, 
    0.01895385f, 0.06679063f, 0.17676701f, 0.22848944f, 0.05341048f, -0.11657110f, 0.07922205f, 0.02657031f, 
    0.17305337f, -0.03108612f, -0.12243775f, 0.09034406f, -0.21950851f, 0.06485762f, 0.08885974f, -0.07738109f, 
    0.07315062f, 0.02559005f, 0.12803048f, -0.01554752f, 0.01297517f, 0.00298610f, 0.11348321f, -0.05034281f, 
    -0.01428849f, 0.05347995f, 0.00063764f, 0.00107569f, 0.04858413f, 0.11270154f, 0.08177021f, 0.05655926f, 
    0.09167055f, -0.05416790f, 0.13245435f, -0.18656042f, 0.03601075f, -0.00513445f, 0.01961716f, 0.06790784f, 
    0.00732825f, -0.03254294f, -0.00348576f, 0.02927691f, -0.04876858f, -0.07898752f, 0.12127525f, 0.05177353f, 
    -0.07153145f, -0.02065084f, -0.04481684f, 0.04703569f, 0.01970472f, 0.01404805f, -0.05057109f, -0.08621152f, 
    -0.11097732f, -0.12633191f, 0.02781199f, 0.14826171f, -0.06728900f, -0.02760872f, 0.14407167f, -0.39974949f, 
    0.04946458f, -0.02903766f, 0.03561253f, -0.03206664f, -0.02809362f, -0.00150599f, 0.11372021f, 0.00428485f, 
    0.23208663f, 0.09436896f, 0.04345866f, 0.20648909f, -0.18829025f, -0.09547610f, -0.06811453f, -0.08348677f, 
    0.04418034f, 0.05474650f, -0.09122528f, -0.09856795f, -0.16012806f, -0.25059307f, -0.19580674f, 0.06297012f, 
    0.08514903f, -0.01534418f, 0.14703079f, -0.04725194f, 0.04801530f, -0.04117110f, -0.03840427f, -0.08376814f, 
    -0.07992099f, 0.00196755f, -0.17435050f, -0.16411521f, 0.09307421f, -0.00802525f, -0.05819232f, 0.04590064f, 
    0.15468167f, 0.08946171f, 0.05076309f, 0.12937644f, 0.06061768f, -0.03174094f, -0.07849909f, -0.02632485f, 
    -0.07721213f, -0.03123030f, -0.01840855f, -0.05884144f, 0.05424824f, -0.07028773f, -0.06399252f, 0.01706079f, 
    0.11736087f, 0.08298942f, 0.14545512f, 0.19669603f, -0.22055189f, 0.01731276f, -0.08061203f, 0.05666498f, 
    0.06757219f, -0.08792732f, 0.02357027f, 0.11492320f, -0.07665386f, 0.06568722f, 0.23493016f, -0.03204432f, 
    -0.00200292f, -0.00901271f, 0.10468981f, 0.02879220f, -0.03443608f, 0.00771712f, 0.01868800f, -0.09982272f, 
    0.39342570f, -0.03480989f, -0.16336130f, -0.02633486f, -0.01237471f, -0.08637773f, -0.08785382f, -0.12934674f, 
    -0.01907627f, -0.03524518f, -0.04058896f, 0.03428671f, -0.19371724f, -0.04011691f, 0.12519665f, 0.17496105f, 
    -0.04339891f, 0.02797163f, -0.04174436f, 0.07034478f, 0.07667878f, 0.05331702f, -0.04174110f, -0.05482896f, 
    -0.10069222f, -0.15168305f, -0.23343351f, 0.02197664f, 0.04809726f, -0.10473706f, 0.11807084f, 0.09551884f, 
    0.12144148f, 0.06473188f, -0.01169237f, -0.03267251f, 0.13031501f, -0.19199687f, -0.11295133f, -0.07476101f, 
    0.06624224f, -0.16904809f, -0.06960300f, -0.11396206f, -0.12111610f, -0.08134311f, -0.00828497f, -0.06934272f, 
    0.10855058f, -0.06755733f, -0.00569689f, 0.14920460f, 0.04423240f, -0.05816611f, -0.11027251f, 0.08088528f, 
    -0.03875911f, 0.17232876f, -0.00385527f, 0.17047784f, -0.18466988f, 0.03981566f, -0.06767684f, 0.19432394f, 
    0.06360702f, -0.00318602f, -0.05320990f, -0.05619131f, -0.01528971f, 0.09944630f, -0.11315303f, 0.10284059f, 
    -0.29010066f, 0.09640402f, -0.30446172f, -0.01618605f, 0.11565081f, -0.01335368f, -0.04964738f, -0.03459022f, 
    -0.08337150f, -0.01738609f, -0.03607723f, -0.17205611f, -0.37975809f, -0.30888221f, -0.21458314f, -0.23982473f, 
    0.16519150f, -0.02686733f, 0.05995026f, -0.04266735f, -0.06260102f, 0.09417768f, 0.02380255f, 0.07847413f, 
    -0.16606857f, -0.00890425f, -0.00321141f, -0.07493890f, 0.12872364f, -0.02824538f, 0.09731398f, 0.01559747f, 
    0.04771246f, 0.06758074f, -0.01656444f, 0.04116432f, 0.11512944f, -0.08048643f, 0.04887134f, 0.12726331f, 
    0.04271650f, -0.00184777f, 0.03707964f, -0.04622265f, -0.20258909f, -0.07699565f, 0.10445950f, 0.23315418f, 
    -0.51467210f, 0.09952457f, -0.06940202f, -0.07015392f, 0.11299259f, -0.05759125f, -0.03178614f, -0.15522572f, 
    0.00157075f, 0.07671461f, -0.06294013f, 0.03743007f, 0.14974123f, -0.00641276f, -0.03750028f, 0.08780780f, 
    -0.05430749f, -0.02938245f, 0.05894355f, 0.04284924f, -0.09270337f, -0.03988580f, -0.05982794f, 0.09975757f, 
    -0.01979342f, -0.21403754f, 0.03229817f, -0.19043462f, 0.00911676f, 0.05344100f, -0.04098577f, -0.01517954f, 
    0.05008557f, -0.02332989f, 0.06079559f, 0.02994562f, 0.11744273f, -0.14959903f, -0.08389597f, 0.21700238f, 
    -0.12432951f, -0.04746917f, 0.01931532f, 0.03466011f, 0.09322722f, 0.03733925f, -0.08990934f, -0.00492130f, 
    -0.39506313f, 0.03800629f, -0.09562081f, -0.33343989f, -0.10133416f, -0.01986974f, -0.03218835f, -0.13618961f, 
    -0.02288816f, -0.05214490f, 0.10383724f, 0.04968657f, 0.13428728f, -0.46253037f, 0.08834191f, 0.01412732f, 
    -0.07516790f, 0.04691151f, 0.11420715f, -0.09058399f, 0.01490708f, -0.01273770f, -0.05487576f, 0.10519896f, 
    0.16105010f, 0.20746768f, 0.14888912f, -0.29466766f, -0.05071073f, 0.07956378f, -0.01443368f, 0.05704797f, 
    -0.09016698f, -0.01072373f, 0.04306291f, 0.06217441f, -0.02171971f, -0.15254048f, -0.19170386f, -0.06736892f, 
    -0.15582991f, -0.05989069f, 0.06575795f, 0.00880665f, -0.08385473f, 0.12337381f, -0.00117944f, 0.16795062f, 
    -0.12189543f, -0.13443714f, -0.26713920f, 0.04156435f, -0.11678374f, 0.00022007f, 0.15976784f, -0.05304827f, 
    0.14699940f, -0.11178244f, -0.15207952f, 0.00271550f, -0.02320607f, -0.10915778f, -0.04156891f, 0.05798489f, 
    -0.03533622f, 0.03847838f, -0.08337227f, 0.02475540f, 0.03056458f, 0.03996176f, 0.13584343f, 0.19393109f, 
    -0.06424544f, -0.02456742f, 0.03359294f, -0.09064940f, -0.20815788f, 0.00744599f, 0.06470029f, 0.10257954f, 
    0.04958439f, 0.02246280f, -0.00305658f, 0.03600861f, 0.47037372f, -0.13298795f, 0.04054869f, 0.05066980f, 
    -0.03365726f, -0.14193302f, -0.07192788f, -0.02354942f, 0.03849759f, -0.01172199f, 0.07488919f, -0.04380956f, 
    -0.18558562f, 0.11592447f, 0.04759998f, 0.15086304f, 0.01675442f, 0.02462096f, 0.05990263f, -0.06342506f, 
    -0.02974761f, 0.02125858f, -0.07675453f, -0.15009478f, -0.02396843f, -0.05851119f, -0.08412445f, -0.14535382f, 
    -0.08494612f, 0.10854046f, 0.01169317f, -0.01627667f, -0.08663684f, -0.05454136f, -0.06319987f, -0.05257940f, 
    -0.08320598f, -0.07828618f, -0.16165286f, 0.24756639f, 0.10183735f, 0.10909983f, 0.01691712f, 0.08981374f, 
    0.06462544f, 0.06701607f, 0.02203721f, 0.03550725f, 0.01766140f, -0.00605801f, -0.05821115f, -0.19787465f, 
    -0.02833795f, -0.02551168f, 0.00791932f, -0.11122091f, 0.01885678f, 0.00712426f, 0.00671087f, 0.17850278f, 
    -0.00109463f, 0.06845388f, 0.11986702f, -0.39052954f, 0.07092069f, 0.01430651f, 0.01544865f, 0.04926438f, 
    0.09207611f, -0.04457304f, -0.09081651f, 0.01899042f, -0.05987059f, -0.05609376f, 0.01405957f, 0.11644861f, 
    0.08361501f, 0.08338810f, 0.04974704f, -0.07487977f, -0.01457860f, 0.00377341f, 0.08517911f, -0.02567693f, 
    0.18747966f, -0.00629099f, -0.16710328f, 0.04365369f, 0.04180910f, -0.04885176f, -0.03252880f, -0.00364706f, 
    -0.05433194f, 0.04779794f, -0.10783964f, 0.04723348f, 0.15000442f, -0.17240968f, -0.04308477f, 0.02690557f, 
    -0.05165641f, 0.08493136f, 0.00208649f, 0.08532655f, 0.09055357f, -0.02804894f, -0.01086666f, 0.01019010f, 
    0.09726931f, 0.16711290f, 0.06694973f, -0.36587951f, -0.02952361f, 0.01955779f, 0.00811050f, 0.00362244f, 
    0.11512681f, -0.13691871f, -0.02652892f, -0.08453745f, 0.00421275f, -0.09328447f, -0.02850499f, -0.17322175f, 
    0.03181176f, 0.02339907f, -0.04707682f, 0.04094462f, 0.12355953f, 0.02997281f, 0.18645498f, 0.06297461f, 
    0.04564506f, -0.11198742f, -0.26270393f, 0.10285003f, -0.08312975f, -0.00510974f, 0.00181967f, 0.00116301f, 
    -0.04434803f, -0.05091177f, -0.00373478f, -0.11735683f, -0.12013961f, -0.05369276f, 0.07611009f, -0.26713902f, 
    -0.01860687f, 0.09978221f, -0.07177016f, 0.11505118f, -0.04300880f, -0.06082619f, -0.00478461f, 0.10280436f, 
    -0.16605972f, 0.00442009f, -0.06482440f, -0.07730900f, 0.02801467f, -0.10179646f, -0.00596469f, 0.04432455f, 
    0.08833381f, 0.12989604f, -0.06479908f, -0.06210882f, 0.14557186f, -0.25218880f, -0.07576799f, 0.16751748f, 
    -0.00810302f, 0.00074180f, 0.07226886f, 0.12807731f, 0.09293409f, 0.03662562f, -0.15176439f, -0.04476577f, 
    0.12850122f, 0.23850638f, 0.04284826f, -0.37685782f, -0.02569108f, 0.02007112f, 0.05819006f, 0.05886485f, 
    -0.05253978f, 0.00307680f, -0.05911814f, -0.12611933f, 0.01886805f, 0.09483974f, 0.05964303f, 0.21391928f, 
    0.01728716f, -0.02869987f, -0.02991646f, -0.02842031f, 0.07555429f, -0.07041523f, -0.02571087f, -0.10261784f, 
    -0.23214556f, 0.30523473f, 0.10335638f, 0.12084000f, -0.06998672f, 0.01420093f, -0.00873350f, 0.07106212f, 
    0.00448107f, 0.09142944f, 0.04715273f, 0.08916745f, 0.11419535f, -0.06407248f, -0.00428014f, 0.02082825f, 
    0.08195966f, -0.04791176f, 0.13248804f, -0.01456760f, -0.07677571f, -0.00270539f, 0.03243837f, -0.22550184f, 
    -0.08639476f, -0.00440429f, 0.16575588f, -0.10659852f, -0.07722007f, 0.02862430f, 0.00378812f, -0.03855380f, 
    0.01773288f, 0.03952729f, -0.07981906f, 0.07742725f, 0.10679261f, -0.10745211f, -0.08895347f, -0.02139540f, 
    0.00713105f, -0.03768084f, 0.10823450f, -0.02390887f, 0.01966893f, 0.07922323f, 0.03919698f, -0.22187853f, 
    0.45473018f, -0.21961914f, 0.22024709f, 0.04922800f, 0.00842669f, 0.00824235f, -0.03617204f, 0.01702047f, 
    0.12065268f, 0.01460163f, 0.00803965f, -0.11655718f, 0.28237015f, -0.12252393f, 0.07707736f, -0.00093551f, 
    -0.02735823f, 0.06714800f, -0.00299624f, -0.00312750f, -0.11976787f, 0.02726707f, 0.03225625f, 0.06045721f, 
    0.13895209f, -0.30769709f, -0.04772047f, 0.31611803f, 0.14720184f, 0.04635862f, -0.00077012f, 0.08285592f, 
    0.03191075f, 0.08910878f, 0.00448026f, -0.03290090f, -0.00387723f, 0.23810600f, 0.12212085f, 0.01754730f, 
    -0.01869520f, 0.08652513f, 0.08539435f, 0.08799937f, 0.02956598f, 0.03721959f, 0.10663994f, -0.05443459f, 
    -0.22136499f, 0.18319404f, 0.10808763f, -0.08022363f, 0.10885460f, 0.06009660f, 0.01362669f, -0.02396565f, 
    -0.07149319f, -0.06360437f, 0.02074990f, -0.00156007f, 0.13709821f, -0.11759067f, 0.02255698f, -0.08269181f, 
    -0.05179895f, 0.05235704f, -0.01762855f, -0.07348036f, -0.09442646f, -0.08965725f, 0.08507929f, 0.12407830f, 
    -0.22581610f, 0.05627725f, -0.01118201f, 0.07307880f, -0.11554158f, 0.11711302f, 0.15284616f, 0.00932194f, 
    -0.04230545f, 0.23177956f, 0.05896110f, -0.10907156f, 0.07459947f, -0.15246865f, -0.19553412f, 0.19054593f, 
    0.02150626f, 0.02168218f, -0.00794514f, 0.10523403f, -0.06147889f, -0.02049739f, 0.00876194f, -0.08248513f, 
    -0.16935770f, -0.03370714f, -0.02325097f, 0.04785758f, -0.10255834f, 0.03675470f, -0.09937851f, -0.01003842f, 
    -0.08446927f, 0.07304145f, -0.07309884f, -0.11972954f, 0.03430017f, 0.06975988f, 0.06099861f, -0.10620612f, 
    -0.06832700f, 0.02333472f, 0.02485505f, 0.01412259f, 0.13964280f, -0.10447804f, 0.07972886f, -0.11012461f, 
    -0.22399645f, -0.09201466f, -0.17880642f, 0.04510386f, 0.02723591f, 0.01232979f, -0.18827593f, -0.12749298f, 
    -0.00368280f, -0.04458271f, 0.02292828f, -0.07844257f, 0.17237386f, -0.42250460f, 0.03123169f, -0.02697413f, 
    0.00376233f, -0.01666374f, -0.05765158f, 0.01495935f, -0.05113283f, 0.06921819f, -0.10433830f, -0.01406855f, 
    0.08403838f, -0.05975836f, -0.19173616f, -0.08288543f, -0.11423161f, 0.03106823f, -0.06699669f, -0.02090308f, 
    -0.04553747f, 0.09125418f, -0.02009786f, 0.11896107f, 0.26514152f, -0.03951744f, -0.12493557f, -0.22080031f, 
    0.04925545f, 0.03873283f, 0.00740125f, -0.10212164f, -0.02596141f, 0.04653287f, -0.08252367f, 0.02637301f, 
    -0.02835317f, -0.11421765f, -0.19613662f, 0.29625741f, -0.02953172f, 0.01476293f, 0.06511081f, -0.10283744f, 
    0.00946837f, 0.01208047f, -0.04473295f, -0.06331080f, -0.05338908f, 0.12585670f, 0.13474682f, -0.04234362f, 
    -0.10344797f, 0.09548873f, -0.06427031f, 0.05441657f, 0.05330016f, 0.09222071f, -0.06171381f, -0.02230279f, 
    -0.09084561f, 0.02636424f, 0.02796349f, -0.01949883f, 0.04143342f, 0.03223099f, 0.07397807f, 0.11565145f, 
    -0.05926783f, -0.05518897f, 0.10179584f, 0.11484887f, 0.09994522f, 0.04484081f, -0.15546486f, 0.12086794f, 
    -0.18242145f, 0.11045031f, -0.07549375f, -0.01818786f, -0.15891106f, 0.03248129f, 0.01872963f, 0.07837413f, 
    0.20029587f, 0.26393661f, 0.09245224f, -0.34398156f, -0.19047932f, 0.07894069f, 0.02806713f, 0.07571650f, 
    -0.08382314f, -0.00714932f, 0.02058920f, -0.00752599f, -0.11229119f, 0.08859116f, -0.05326270f, 0.16668333f, 
    -0.05254210f, 0.10790289f, -0.00151789f, -0.05978521f, -0.02212625f, 0.05014620f, 0.00407558f, -0.07070392f, 
    -0.11822303f, 0.02964051f, -0.11769672f, -0.06396235f, 0.09334445f, -0.10161442f, 0.04157639f, 0.00949356f, 
    -0.10058068f, 0.06625218f, -0.12255026f, 0.07966688f, 0.07315048f, -0.06579555f, -0.06476046f, 0.12580955f, 
    0.02777352f, 0.05031831f, -0.08013365f, 0.17745824f, -0.06389158f, -0.10712024f, -0.11601117f, 0.06786925f, 
    -0.48595190f, -0.00134558f, -0.26137316f, 0.27063850f, 0.04458968f, 0.01512482f, 0.01906795f, -0.02998974f, 
    0.04501751f, -0.05972752f, 0.07264488f, 0.00224652f, 0.24172422f, -0.15893045f, -0.04383547f, 0.17943504f, 
    0.00338899f, -0.03770463f, 0.00544857f, -0.00137728f, -0.08927439f, 0.02590222f, -0.09673480f, -0.08119526f, 
    -0.07950402f, 0.00321930f, -0.16011199f, -0.03895860f, 0.00418545f, 0.02756493f, -0.00403235f, -0.09646256f, 
    -0.15189385f, -0.03369240f, 0.08984459f, -0.04525731f, -0.53045183f, 0.16151355f, -0.12129323f, 0.17252675f, 
    0.16821425f, 0.18343437f, 0.08173214f, 0.12172102f, 0.02553223f, 0.00193669f, 0.01190748f, 0.06765177f, 
    -0.08447908f, -0.04837758f, -0.06778987f, 0.06461199f, -0.00988195f, 0.04038048f, -0.03990478f, -0.13927719f, 
    -0.04366353f, -0.15106243f, 0.07164080f, -0.01330379f, 0.07149471f, 0.03957793f, 0.09865519f, -0.15476146f, 
    -0.04276688f, -0.07376941f, 0.02003783f, 0.07335235f, -0.10128827f, 0.05459840f, -0.01992328f, 0.04760361f, 
    0.19369365f, -0.25483307f, -0.00740203f, -0.04526234f, 0.00736832f, 0.05675130f, 0.04313595f, -0.05163648f, 
    -0.07682751f, 0.01540701f, 0.06165050f, 0.13376386f, -0.11518853f, 0.06330145f, -0.08112088f, -0.22567597f, 
    -0.05884190f, 0.01674922f, 0.04898514f, -0.03493444f, 0.04264083f, -0.06827322f, 0.08204545f, -0.04038293f, 
    -0.22216383f, 0.00244653f, -0.05086558f, 0.19216484f, -0.00431665f, 0.09273525f, -0.06663993f, -0.01025217f, 
    -0.09817897f, -0.00569023f, 0.03097447f, -0.04137673f, -0.03775691f, 0.05654938f, 0.05511485f, -0.07457577f, 
    -0.08492877f, -0.07829285f, 0.01361360f, -0.05053400f, 0.09411035f, 0.00272439f, -0.09211760f, -0.15481862f, 
    -0.29503584f, -0.08480692f, -0.07099279f, 0.01899286f, 0.03084213f, -0.01293337f, -0.01908359f, 0.03244271f, 
    -0.00759821f, -0.01895287f, 0.02756213f, -0.00558023f, -0.01635475f, 0.13802721f, -0.11501171f, -0.18347752f, 
    0.03883443f, 0.06030794f, 0.04260747f, -0.02161357f, -0.05230584f, -0.01483429f, -0.06289230f, 0.11328351f, 
    0.27431181f, 0.08799316f, 0.26546416f, -0.02364490f, -0.04740371f, 0.05247518f, -0.02502780f, -0.01586141f, 
    -0.04171358f, 0.03350110f, -0.12136113f, 0.01439080f, 0.00241691f, -0.03257844f, 0.00021760f, 0.03216556f, 
    -0.01655155f, 0.00765495f, -0.05060381f, -0.03228682f, -0.08794355f, -0.03861887f, -0.04360362f, -0.00617560f, 
    -0.01302224f, 0.24839242f, 0.14894502f, 0.14686573f, 0.04901991f, -0.03710841f, 0.07089993f, -0.00969509f, 
    0.01192929f, 0.05140923f, -0.00682773f, -0.06693143f, -0.13072160f, -0.03208857f, 0.06074474f, -0.07558402f, 
    0.04969826f, -0.01029221f, -0.06359025f, 0.08703001f, -0.04128703f, 0.02084730f, -0.04911732f, 0.00208670f, 
    -0.07666034f, 0.03293364f, -0.09744619f, -0.10207622f, 0.01094520f, 0.04825960f, -0.00168008f, -0.05276646f, 
    -0.01920570f, -0.02242192f, -0.01652965f, -0.08213228f, 0.27646375f, 0.10512065f, -0.07131690f, -0.10460211f, 
    -0.02118925f, -0.06634001f, 0.00253082f, -0.05370041f, 0.00067463f, 0.01892688f, 0.03402803f, -0.03837003f, 
    0.14362538f, 0.11349103f, 0.14220229f, 0.25989461f, 0.14869134f, 0.08358834f, 0.05921115f, -0.00763911f, 
    0.03156972f, -0.01569561f, -0.02418882f, -0.05844693f, -0.17896792f, 0.20227957f, 0.10258660f, 0.01524242f, 
    -0.02153951f, -0.02615944f, 0.03161203f, 0.02338060f, -0.00425641f, 0.10663174f, -0.01725229f, 0.02725238f, 
    -0.15385051f, 0.07970577f, 0.02254286f, -0.15480612f, -0.07732528f, -0.00216454f, 0.03197263f, -0.08801472f, 
    0.01991194f, -0.03614849f, -0.02497195f, -0.03026240f, -0.01568153f, -0.12240002f, -0.17558436f, -0.13936001f, 
    -0.09901757f, 0.02196327f, -0.04405869f, -0.03084625f, -0.00590280f, 0.01207846f, -0.07717609f, 0.02038264f, 
    0.04411803f, 0.18490154f, -0.30064133f, 0.00272522f, -0.10281615f, -0.04692784f, 0.00842059f, -0.04138860f, 
    -0.13665056f, -0.01347571f, 0.03672950f, -0.02742606f, 0.01236691f, 0.08420195f, 0.02403657f, 0.13220723f, 
    0.01136563f, -0.02333212f, -0.02652279f, -0.06197441f, -0.01084625f, 0.00119248f, -0.03499342f, -0.06056805f, 
    0.03638278f, 0.04361603f, -0.11768133f, 0.09191253f, -0.05424052f, 0.08594942f, -0.10398463f, 0.01163604f, 
    -0.01536193f, 0.01939741f, -0.01146568f, -0.09623244f, 0.07241343f, 0.09465911f, 0.01026662f, 0.16212858f, 
    -0.03218375f, -0.00386254f, -0.02397590f, -0.07240576f, -0.05012751f, -0.03466609f, -0.02403063f, 0.05173622f, 
    -0.07985440f, -0.07531253f, 0.12658514f, 0.15709677f, 0.01788655f, -0.05228009f, -0.00821062f, -0.07443304f, 
    -0.03281356f, -0.06277718f, 0.00981310f, -0.03047908f, 0.01668580f, 0.17051426f, -0.05664191f, -0.01657120f, 
    -0.07453775f, 0.05968057f, 0.03382175f, -0.07645553f, -0.07017801f, -0.07331388f, -0.05799792f, -0.06406287f, 
    0.15118083f, 0.10056508f, 0.14061999f, 0.16354316f, 0.09212627f, -0.00507090f, 0.00338527f, 0.06567921f, 
    -0.06295775f, -0.05908399f, 0.03805631f, 0.04227747f, -0.18565616f, 0.06212528f, 0.04129950f, -0.03065094f, 
    -0.04557813f, 0.00232888f, 0.02216998f, -0.11405504f, 0.00018108f, 0.01793752f, 0.01790587f, -0.01048536f, 
    -0.28779644f, -0.00688807f, -0.22399984f, -0.08409656f, 0.01176898f, -0.06520243f, -0.02225966f, -0.05915093f, 
    -0.03861222f, -0.03200911f, -0.04452068f, -0.00400713f, -0.01118340f, 0.06133273f, -0.00355035f, -0.10119814f, 
    -0.16078252f, 0.08592249f, 0.01010203f, -0.03204228f, -0.08342889f, 0.01673469f, -0.11718112f, -0.03385817f, 
    0.15118253f, 0.12962693f, 0.06154525f, 0.19840136f, 0.14002322f, 0.02598197f, 0.03256279f, -0.06797285f, 
    -0.05675187f, -0.02425673f, -0.08893432f, -0.08883778f, 0.12041986f, 0.07757704f, 0.07731216f, 0.14163511f, 
    0.02733311f, 0.07724748f, 0.00856862f, 0.07322362f, -0.03824788f, 0.03475801f, 0.07586104f, -0.05269518f, 
    0.11845845f, -0.05444740f, 0.10994017f, 0.09871858f, 0.02216645f, 0.04372452f, 0.06715053f, -0.05106182f, 
    -0.02712734f, 0.01671280f, 0.00925137f, -0.11692887f, 0.21819931f, -0.08803100f, 0.08972292f, -0.01298895f, 
    0.01404532f, -0.01782397f, -0.01965436f, -0.01804399f, 0.05031423f, 0.05915938f, 0.02344201f, -0.11406243f, 
    0.00922763f, -0.17036480f, 0.00514613f, 0.08122319f, -0.07599817f, -0.03063324f, 0.03259373f, -0.01202060f, 
    -0.07570468f, 0.07206919f, 0.01229213f, -0.00345211f, -0.05803544f, -0.09045947f, 0.13423353f, -0.03142810f, 
    0.02859345f, -0.07504313f, 0.03550766f, 0.00884961f, -0.01231989f, 0.05386109f, -0.06421982f, -0.01459610f, 
    -0.28820962f, -0.08494828f, 0.07345514f, -0.15853067f, -0.02346011f, 0.07390940f, 0.00365544f, -0.03399926f, 
    -0.07766825f, -0.07447336f, -0.04916448f, 0.02741463f, 0.14302510f, -0.28011727f, -0.05891094f, 0.06322636f, 
    0.02929471f, -0.04536858f, 0.00724285f, -0.03321125f, -0.00582006f, -0.01365202f, 0.01530411f, 0.01537736f, 
    0.04086110f, 0.11802199f, -0.05714276f, -0.13590847f, -0.01511964f, -0.07116100f, 0.01341199f, -0.04125680f, 
    0.05115847f, -0.04717003f, -0.06990606f, -0.09340770f, 0.24007757f, 0.05061606f, 0.04043588f, -0.05147963f, 
    -0.08095485f, 0.05159764f, -0.05071787f, 0.00333939f, 0.00750872f, 0.02508559f, 0.00637346f, -0.01886971f, 
    0.07911379f, -0.01726436f, 0.15233134f, -0.01465359f, 0.01028727f, -0.05392857f, 0.01949447f, 0.01159408f, 
    0.00607245f, -0.03888943f, 0.02951643f, -0.12892756f, 0.08378022f, 0.06309997f, 0.05336302f, 0.21731769f, 
    0.07815709f, -0.07846749f, 0.04781953f, -0.00026074f, -0.07926634f, -0.00236244f, -0.01238623f, -0.01231149f, 
    -0.27938512f, 0.09677456f, 0.04635413f, 0.04103958f, -0.02970332f, -0.07057963f, -0.08496344f, 0.03085996f, 
    0.00747264f, -0.02094311f, -0.04398199f, -0.00165003f, -0.18997355f, 0.02902830f, -0.17816551f, -0.07837155f, 
    0.00570505f, -0.01615591f, 0.01311339f, -0.00961507f, -0.04330964f, -0.00998283f, -0.03740124f, -0.13546227f, 
    -0.21138611f, -0.07167467f, -0.09678368f, -0.00414268f, 0.01222672f, -0.04816241f, -0.07444545f, -0.02108101f, 
    -0.10134406f, -0.03721020f, 0.03148690f, 0.01482127f, -0.10976198f, 0.07398324f, -0.01650131f, -0.06340650f, 
    -0.14508106f, 0.02563102f, 0.00337304f, -0.07017647f, -0.02755325f, 0.08236838f, -0.01556740f, -0.00937876f, 
    -0.18429492f, -0.08660407f, -0.07351273f, -0.06943052f, 0.03069239f, 0.01117413f, -0.03140657f, -0.00768588f, 
    -0.08180547f, 0.04496301f, -0.05593780f, -0.03106647f, 0.24756619f, 0.07534032f, -0.04973360f, 0.17693464f, 
    0.05708643f, -0.09710795f, -0.07749885f, -0.04492032f, 0.03230381f, -0.03516698f, -0.03997354f, -0.07856186f, 
    -0.12451191f, 0.15122566f, 0.00997340f, -0.06165712f, -0.13218015f, 0.02592126f, -0.05106681f, -0.02151147f, 
    -0.01145547f, -0.02727832f, -0.00644718f, -0.06672135f, 0.06090066f, -0.02230447f, 0.03271531f, -0.00634819f, 
    -0.07349899f, -0.04409919f, 0.04773250f, -0.01959762f, 0.03149395f, -0.01852963f, -0.09245738f, -0.06181902f, 
    -0.09798986f, 0.11762162f, 0.07309000f, 0.07749055f, -0.08026583f, -0.07073466f, -0.10938772f, -0.01452968f, 
    -0.13086443f, -0.01284606f, 0.01027312f, -0.06453710f, 0.00357041f, -0.27685598f, -0.06587079f, -0.08110944f, 
    -0.01186883f, -0.00699119f, -0.01018999f, -0.04855619f, -0.03765355f, 0.06250843f, 0.04777458f, -0.04698861f, 
    0.06909321f, 0.17138201f, 0.01953061f, 0.14262141f, -0.01826369f, 0.05126481f, -0.06932379f, 0.01956559f, 
    -0.09136967f, 0.02585947f, -0.05103737f, 0.06558196f, 0.07399270f, 0.01587667f, -0.04020311f, -0.00106229f, 
    -0.09042843f, -0.04693783f, -0.06091600f, -0.07981914f, -0.12777121f, 0.04075592f, -0.07167393f, -0.05876517f, 
    0.02435155f, 0.16898674f, -0.01463041f, 0.10725151f, 0.10056587f, -0.10662784f, -0.04175997f, 0.04135753f, 
    0.06685446f, 0.01285044f, -0.05389622f, -0.09517326f, -0.35401356f, 0.20822963f, -0.01657059f, -0.11152697f, 
    -0.03633539f, 0.01820382f, -0.04574456f, -0.00460707f, -0.15811163f, -0.03964989f, -0.08413894f, -0.09876049f, 
    -0.00524881f, -0.02145551f, -0.16267328f, 0.01030084f, -0.11061718f, -0.06769127f, 0.03447074f, -0.03337092f, 
    -0.07149497f, -0.05178531f, 0.05559919f, -0.10223480f, 0.05369355f, 0.21504286f, 0.00986342f, 0.26441014f, 
    0.12852314f, 0.00134756f, 0.10801057f, 0.07475363f, 0.06908304f, 0.03502141f, 0.04083471f, 0.10780256f, 
    0.05010393f, 0.04987531f, -0.18271847f, -0.19637567f, -0.17788570f, -0.01828083f, -0.02267438f, -0.10668544f, 
    -0.04839705f, -0.01133776f, 0.00734778f, -0.10143352f, 0.08074618f, 0.04886851f, -0.16373871f, -0.00724215f, 
    -0.04947663f, -0.05742270f, -0.06354367f, -0.07088513f, 0.03772530f, 0.05662541f, -0.00003199f, -0.05131193f, 
    -0.00376009f, -0.16213416f, -0.01155698f, 0.01781263f, 0.06591337f, -0.08032937f, 0.01928102f, -0.06093714f, 
    -0.00393465f, 0.05007290f, -0.03399958f, -0.09396538f, -0.05699221f, 0.05766754f, 0.00703285f, -0.11964262f, 
    -0.06227328f, 0.05240485f, 0.00599431f, -0.13392611f, -0.01082054f, -0.00065739f, 0.10424577f, 0.09351613f, 
    -0.12142050f, 0.10550182f, -0.12765732f, -0.06121345f, -0.06659796f, 0.01311054f, -0.05501771f, -0.05885396f, 
    0.01195143f, -0.03386008f, 0.00042908f, -0.06946868f, -0.02337524f, -0.08620800f, 0.00495388f, -0.00031881f, 
    0.08144595f, 0.03024079f, -0.05043926f, -0.14302637f, -0.05993081f, -0.01511441f, -0.03134961f, -0.04571628f, 
    0.17531371f, 0.04841901f, 0.13339490f, 0.18825668f, 0.22908518f, 0.06576788f, 0.08693288f, -0.04460939f, 
    0.01171505f, -0.04253680f, 0.00829889f, -0.08751418f, -0.18651330f, 0.08487712f, -0.10090227f, 0.03177180f, 
    0.00777160f, -0.03681445f, 0.01173928f, 0.00162791f, -0.00757247f, 0.01529906f, -0.06057695f, -0.06318569f, 
    0.20614572f, -0.06570137f, 0.09865396f, 0.02166079f, 0.01805230f, -0.04378167f, -0.00501991f, -0.00280732f, 
    -0.03020980f, -0.02343531f, -0.04461561f, 0.03845615f, -0.08294167f, 0.12405768f, -0.19072556f, -0.02831759f, 
    -0.09921952f, -0.02813127f, 0.00866742f, -0.01174792f, -0.12337646f, -0.05582961f, -0.04306800f, -0.08990904f, 
    0.03279470f, 0.09015027f, 0.06910923f, 0.11154310f, 0.00542895f, 0.02322584f, 0.00152291f, 0.08533414f, 
    0.03038956f, 0.08416522f, -0.03217009f, 0.01979827f, 0.19346544f, 0.01641308f, 0.14125617f, 0.00982348f, 
    0.06439313f, 0.05166879f, -0.05530172f, -0.07882233f, -0.05187178f, 0.04234098f, -0.05267340f, 0.03408581f, 
    -0.20503293f, 0.17057706f, -0.05574061f, 0.02024002f, -0.09012125f, -0.05420312f, -0.04546250f, -0.03822858f, 
    0.00919761f, 0.05188806f, -0.01490125f, -0.11446436f, -0.07491248f, -0.10678513f, 0.00207568f, 0.07829475f, 
    -0.03476875f, -0.06229777f, -0.12982865f, 0.06688115f, 0.02977067f, -0.04432503f, -0.01286704f, -0.13010801f, 
    -0.03857841f, 0.08708008f, 0.13579907f, 0.12850150f, 0.09269908f, 0.08008821f, 0.08071616f, -0.01095867f, 
    -0.01493769f, 0.01262207f, 0.04486677f, -0.06472670f, -0.02581165f, -0.17979138f, -0.11316844f, 0.01508106f, 
    -0.04774695f, -0.13032179f, 0.00397986f, -0.07860004f, -0.08748917f, -0.00930285f, -0.02794038f, -0.08268253f, 
    -0.16007394f, 0.23413600f, -0.13127275f, -0.00342436f, -0.07570303f, -0.03903124f, -0.04852920f, -0.00142529f, 
    0.07198097f, 0.01599741f, 0.03382081f, 0.13554016f, 0.02584458f, 0.04665571f, -0.03599193f, -0.06294122f, 
    0.00930322f, -0.00355078f, -0.14338176f, -0.02396910f, -0.00636592f, 0.03405769f, -0.04403518f, -0.01139763f, 
    -0.25420567f, 0.15679118f, 0.21038091f, 0.02022256f, 0.10390268f, -0.03042783f, 0.00158648f, -0.00877257f, 
    0.02844649f, -0.01975355f, -0.11903445f, 0.03422946f, 0.11369020f, -0.07650412f, 0.12339382f, 0.11971501f, 
    -0.09536561f, -0.03857893f, 0.01990966f, -0.01432666f, -0.03915669f, -0.04917372f, -0.00112991f, -0.15372059f, 
    0.10189482f, -0.07102978f, 0.02180991f, 0.22091655f, 0.02304140f, -0.06398470f, -0.00524887f, -0.02989335f, 
    0.04806471f, -0.04058049f, -0.01924644f, -0.14902526f, 0.05922442f, 0.02830966f, 0.01286528f, 0.06181098f, 
    -0.14627856f, -0.00176540f, 0.01905489f, -0.02706477f, -0.00833481f, -0.01659918f, 0.00213126f, 0.00308980f, 
    -0.08955999f, 0.07614259f, 0.03843794f, 0.02861706f, 0.03372166f, -0.03964115f, -0.02379999f, 0.02491666f, 
    0.03777740f, -0.03586656f, 0.02457574f, -0.06980473f, 0.11221270f, 0.01809997f, 0.03994198f, 0.06465546f, 
    -0.08048697f, 0.05430402f, -0.09695361f, -0.04670043f, 0.00655218f, -0.16578791f, -0.11616788f, 0.05468260f, 
    0.10140751f, 0.06159545f, 0.02311495f, 0.08969834f, 0.06579076f, -0.03609075f, -0.02705888f, -0.04210026f, 
    0.05338648f, -0.04041139f, -0.02379502f, -0.09545343f, -0.08465047f, -0.04971848f, -0.02668480f, 0.14296101f, 
    0.02558058f, -0.03257003f, 0.04788068f, 0.01130780f, 0.05292169f, 0.03445359f, -0.09405717f, 0.00283068f, 
    -0.02820764f, 0.03605911f, 0.06265042f, -0.00613736f, -0.02866268f, 0.05211890f, -0.08858516f, -0.01276990f, 
    0.05831818f, -0.01652039f, -0.03188957f, 0.01697183f, -0.05925624f, -0.17513013f, 0.15836868f, -0.03964045f, 
    -0.05196040f, 0.03246197f, -0.01751903f, -0.14711860f, -0.13440691f, 0.04801017f, 0.01206398f, 0.08306818f, 
    -0.10014510f, 0.17861110f, -0.25202411f, -0.11018414f, 0.07709885f, -0.10980021f, -0.03566436f, -0.05511640f, 
    0.10551637f, 0.00530718f, -0.09023205f, 0.11401058f, -0.16054291f, -0.01329824f, -0.03307201f, -0.12432849f, 
    -0.01552911f, -0.09280991f, -0.06058291f, -0.03588784f, 0.07051876f, -0.03826030f, -0.03998305f, -0.17016211f, 
    -0.12213995f, -0.13047454f, 0.10040770f, 0.15825367f, 0.05111543f, 0.00882440f, -0.07736988f, -0.05611814f, 
    0.05355098f, -0.07297798f, 0.09994289f, -0.09177653f, -0.09915762f, -0.00220899f, -0.13753073f, -0.11373176f, 
    0.01121208f, -0.03164713f, -0.08545420f, 0.07917168f, 0.02524807f, -0.03712409f, -0.00109906f, 0.00223815f, 
    0.04193865f, -0.09207078f, -0.09812123f, -0.05307278f, -0.07585571f, 0.06367786f, 0.00014880f, -0.14469905f, 
    -0.09655417f, -0.02793379f, 0.01723841f, 0.00216636f, -0.14072978f, -0.21549563f, 0.06851496f, 0.04613810f, 
    -0.06044590f, 0.00902550f, -0.05467324f, -0.10060135f, 0.07669701f, 0.01854156f, 0.00932386f, 0.02679606f, 
    -0.17977583f, -0.00358916f, -0.07589823f, 0.08456602f, 0.11686704f, 0.03328984f, 0.00595480f, -0.04440518f, 
    0.11400861f, 0.10172351f, 0.03048109f, 0.04514365f, 0.07159597f, 0.02357326f, 0.04011657f, 0.02529586f, 
    -0.03426937f, -0.11981726f, 0.01859175f, -0.05949393f, -0.07711060f, -0.12378586f, -0.01416573f, 0.01656439f, 
    0.05918463f, 0.17844677f, -0.00169241f, -0.12602349f, 0.03106645f, -0.13606167f, 0.01464403f, -0.03719126f, 
    -0.04197641f, 0.01973138f, 0.02379238f, 0.11018543f, -0.27459759f, -0.17410272f, 0.06370223f, -0.26586050f, 
    -0.02485494f, -0.27237082f, 0.08599429f, -0.04498763f, 0.03050565f, 0.07801157f, -0.24225180f, 0.14520922f, 
    -0.09985585f, -0.15787952f, 0.06608149f, -0.08878401f, -0.04695312f, -0.03070283f, 0.08479250f, -0.06969503f, 
    0.03866164f, -0.15342419f, 0.06275801f, 0.08822111f, 0.12376080f, -0.00642751f, -0.00276380f, -0.00110248f, 
    -0.01706484f, 0.01583848f, -0.00614883f, -0.17539726f, -0.03242853f, -0.06076024f, 0.05582146f, 0.15492821f, 
    -0.17061600f, -0.36599454f, -0.04675169f, 0.04717706f, -0.04376852f, 0.03928016f, -0.01815760f, -0.01951878f, 
    -0.03934425f, 0.08486869f, 0.05349270f, 0.06260866f, -0.14062366f, -0.12233210f, -0.16080716f, -0.23717967f, 
    -0.01465661f, -0.08907601f, 0.10366824f, -0.05287568f, 0.02073240f, 0.07002757f, -0.01174859f, 0.05520435f, 
    0.22246839f, 0.01533187f, -0.24676374f, 0.04795748f, 0.11885498f, -0.12064162f, -0.11743607f, -0.11480347f, 
    -0.07235021f, 0.05499744f, 0.00052068f, -0.05500695f, 0.17819910f, -0.02727900f, -0.14400226f, -0.00393408f, 
    -0.02057792f, 0.01221009f, 0.01521532f, -0.02895138f, -0.01335193f, -0.01555259f, -0.02676041f, 0.11102086f, 
    0.16528143f, -0.12515937f, -0.01879184f, 0.09732433f, 0.06547178f, 0.02472443f, -0.00817989f, -0.04271144f, 
    -0.03196746f, 0.05482389f, 0.07198709f, -0.10974383f, 0.01090194f, -0.07625216f, 0.01351383f, -0.08506456f, 
    0.08089536f, -0.07401510f, 0.06099430f, 0.02804955f, -0.00844766f, -0.03453583f, 0.01764215f, 0.14380679f, 
    0.00264804f, -0.23233469f, -0.01655511f, -0.01912785f, -0.17965114f, -0.12360783f, -0.00661020f, -0.02385637f, 
    -0.05721363f, 0.12360160f, -0.10658637f, 0.09143437f, 0.10360983f, 0.01476757f, -0.12620892f, -0.22267735f, 
    0.08512133f, -0.01102480f, 0.10237613f, 0.03440111f, 0.09054984f, -0.03343795f, -0.02319482f, -0.02114394f, 
    0.15940486f, 0.24192402f, -0.26958850f, 0.00269568f, 0.08976640f, -0.07375848f, -0.08527505f, -0.05950700f, 
    -0.00273326f, -0.07549594f, 0.08780743f, 0.06160121f, 0.02868845f, -0.06440575f, 0.03542389f, 0.15378448f, 
    0.08342096f, 0.01545613f, -0.03397471f, -0.07957628f, 0.01819751f, -0.06749383f, 0.04869619f, 0.03460897f, 
    -0.13052441f, -0.22029422f, -0.10057300f, 0.00949199f, 0.07464021f, 0.00050007f, -0.04664060f, 0.04043932f, 
    0.12131485f, 0.08142898f, 0.12861477f, -0.00712982f, 0.13789546f, 0.01937721f, -0.03961712f, 0.06477867f, 
    -0.02726194f, -0.00413068f, -0.00781465f, 0.12357950f, 0.06109900f, -0.03125185f, -0.08935492f, -0.11196125f, 
    -0.02035419f, -0.09893817f, 0.05742804f, -0.01849848f, -0.01138957f, 0.00778594f, -0.11607450f, 0.05577691f, 
    0.17686020f, -0.18062268f, 0.15671870f, 0.00870883f, 0.11270945f, 0.08153499f, -0.18394133f, -0.24389763f, 
    -0.02911630f, -0.12561558f, -0.01134505f, -0.02799330f, 0.02941767f, 0.03067498f, 0.04401807f, 0.00678683f, 
    0.10308602f, 0.15407071f, 0.01528189f, 0.17817672f, -0.07289904f, 0.04243385f, 0.10199118f, 0.07826579f, 
    -0.00739774f, 0.03244914f, 0.10081067f, 0.05864863f, -0.10915832f, -0.19363898f, 0.01071334f, -0.09900258f, 
    -0.06426194f, -0.09294782f, 0.05013547f, -0.01185257f, -0.09390186f, 0.01966775f, 0.03004707f, -0.14060327f, 
    -0.06492783f, 0.21248472f, -0.13368189f, -0.18496598f, 0.02627639f, -0.00535170f, 0.12913631f, -0.00588994f, 
    0.09265704f, -0.02006389f, 0.04646475f, 0.05556806f, 0.10092849f, -0.01849356f, 0.14148620f, 0.02789357f, 
    -0.06607176f, -0.06216780f, 0.04190292f, -0.09148728f, -0.02578952f, 0.01925914f, 0.07021759f, 0.03150605f, 
    -0.15769143f, 0.03008285f, 0.01497967f, -0.20866831f, -0.08284173f, 0.02525483f, 0.06889070f, -0.04747012f, 
    0.00029807f, -0.05975717f, -0.06626957f, -0.14369184f, -0.16382088f, 0.00098716f, -0.15578917f, -0.21835378f, 
    -0.11626195f, -0.04684084f, -0.02025199f, -0.02197790f, 0.05116112f, -0.10361774f, 0.09403531f, -0.06232606f, 
    -0.01666483f, 0.25401533f, -0.08917267f, 0.02729386f, -0.04155458f, 0.01429484f, -0.12661335f, -0.01257115f, 
    0.01794196f, -0.07831999f, 0.02930978f, 0.11944745f, 0.06754173f, 0.02629136f, 0.04446115f, 0.05617452f, 
    0.00061819f, -0.00942908f, -0.01265394f, -0.01954663f, 0.02169741f, 0.00945967f, 0.08585075f, -0.13355820f, 
    -0.04635329f, 0.14657627f, -0.25798908f, -0.12338807f, 0.00859637f, 0.06708465f, -0.12255161f, 0.04444202f, 
    0.10483839f, 0.09569101f, -0.03609380f, 0.09386272f, 0.01515348f, 0.02551697f, 0.07105982f, 0.03469848f, 
    0.04283257f, 0.01282958f, 0.15098493f, -0.00683962f, 0.01402264f, -0.00332239f, -0.04387175f, -0.00465112f, 
    -0.27581513f, -0.16694276f, 0.01574588f, -0.08618695f, 0.05247476f, -0.01912456f, -0.01341545f, -0.06700158f, 
    0.01785810f, 0.11866846f, -0.04024022f, 0.05649291f, 0.14811631f, 0.04425631f, -0.07501788f, 0.08208565f, 
    0.01903301f, 0.03105117f, 0.02282993f, -0.00971887f, 0.00580046f, -0.02097066f, 0.02892173f, 0.12504570f, 
    0.07298897f, 0.03806643f, -0.00648177f, 0.03613579f, 0.02864307f, 0.10934090f, -0.04532788f, 0.00818931f, 
    0.09164161f, 0.02058745f, 0.05597864f, 0.13442460f, 0.20432763f, 0.06145960f, -0.08737313f, 0.06749002f, 
    0.02498987f, -0.13067918f, -0.03630817f, -0.00796410f, 0.09132249f, -0.03154591f, 0.00920711f, -0.11044817f, 
    0.18309766f, 0.15845545f, -0.08154330f, 0.09749912f, 0.02198276f, 0.04431434f, -0.07245616f, -0.01023380f, 
    0.04183122f, 0.02304740f, -0.17137650f, -0.04346083f, 0.14072931f, -0.06243251f, 0.00593654f, 0.02456984f, 
    0.06968709f, -0.00739240f, -0.10854629f, 0.02185137f, 0.08291462f, 0.07615714f, -0.00452714f, -0.12643138f, 
    -0.15801775f, -0.09862999f, 0.06690212f, -0.12517534f, -0.01768735f, -0.04503113f, 0.16376030f, -0.07357275f, 
    0.08298533f, -0.06998714f, 0.06418730f, -0.00063459f, 0.05267635f, 0.18310873f, -0.39062911f, 0.14677487f, 
    0.08392742f, 0.02421001f, -0.09580597f, -0.06311829f, -0.03876594f, 0.07311198f, -0.10780671f, 0.04044132f, 
    -0.14163701f, -0.13549888f, 0.00986611f, -0.23421419f, 0.01425527f, -0.02317954f, -0.17553928f, -0.06281964f, 
    0.13609193f, 0.06985757f, 0.02078174f, 0.05608677f, -0.13867980f, 0.09490526f, 0.03265171f, 0.05114819f, 
    -0.05003742f, 0.02597468f, 0.01089528f, -0.05558244f, 0.07757689f, 0.08843612f, 0.01960330f, 0.00626939f, 
    -0.01561487f, 0.04563996f, 0.01923604f, -0.06860059f, 0.00866368f, -0.05652747f, 0.02069821f, 0.04645271f, 
    0.02004587f, -0.00185183f, -0.13267364f, 0.01808060f, -0.25873581f, -0.14412710f, 0.16142955f, -0.18381742f, 
    0.02451079f, -0.00923489f, 0.14076310f, -0.17453615f, 0.03643044f, 0.06917050f, 0.08400379f, 0.01513926f, 
    0.04247480f, 0.24298988f, -0.04445809f, 0.06917028f, -0.02840487f, -0.00424927f, 0.01420597f, 0.00438640f, 
    0.07612206f, -0.03500525f, 0.03782938f, 0.03305420f, -0.13775335f, -0.04891743f, -0.12107629f, -0.13419476f, 
    0.04034982f, -0.05987366f, 0.05205454f, -0.00321822f, 0.00475882f, 0.07466676f, 0.03825105f, 0.00914997f, 
    -0.05662253f, 0.06154420f, 0.02076119f, 0.12373072f, -0.07021537f, -0.11232425f, -0.08345816f, -0.08809765f, 
    -0.09301863f, 0.07201250f, -0.05469793f, -0.12529504f, -0.14727184f, -0.10747346f, -0.17275873f, -0.06575517f, 
    0.06341677f, -0.01085279f, 0.03671874f, -0.02581592f, 0.04510731f, -0.07299674f, 0.03931070f, 0.01810368f, 
    -0.32736969f, -0.25546798f, -0.20395052f, 0.09736469f, -0.00226269f, 0.01814526f, 0.05623487f, -0.04526382f, 
    -0.14263090f, 0.03782040f, -0.00922735f, -0.01427474f, -0.04240821f, -0.00682542f, -0.33736581f, -0.05114625f, 
    0.09376332f, -0.02207809f, -0.06556129f, 0.13490179f, -0.01949287f, -0.00228049f, 0.09140456f, 0.12821132f, 
    -0.10726397f, -0.15044230f, 0.14031376f, 0.07476174f, 0.01284306f, -0.06609760f, -0.01343485f, 0.06680284f, 
    -0.05063488f, 0.11919153f, -0.02521506f, 0.04436475f, 0.24174537f, -0.02057759f, -0.03905163f, -0.01541588f, 
    0.01443556f, -0.00957532f, -0.12120137f, 0.08448625f, 0.00572131f, 0.01812333f, -0.05150516f, 0.01169709f, 
    -0.39451900f, 0.08530571f, -0.19705909f, -0.05268867f, 0.13388671f, -0.06560995f, 0.06436113f, -0.01734744f, 
    -0.04661073f, -0.08965204f, -0.05907079f, 0.05096804f, -0.12149715f, 0.09460310f, 0.04263692f, 0.06361955f, 
    0.07615990f, -0.02230401f, 0.01213491f, 0.04053196f, 0.01724551f, 0.12526335f, 0.03908854f, 0.04544586f, 
    -0.09175924f, -0.32133511f, 0.12026412f, -0.00456231f, 0.01961354f, -0.07891285f, -0.05438431f, 0.04806140f, 
    0.02669135f, -0.07783559f, 0.05793103f, -0.03219586f, -0.35682574f, -0.04920621f, 0.02218358f, 0.00533081f, 
    0.09354918f, 0.01060802f, -0.02135880f, 0.08787595f, 0.13944760f, 0.09863672f, 0.05634834f, 0.05529180f, 
    -0.10706134f, 0.12030322f, -0.21522842f, -0.10362671f, 0.04885637f, 0.05959726f, 0.00503162f, 0.03100770f, 
    0.08096616f, -0.00701850f, 0.03355073f, -0.04372063f, -0.12428832f, 0.06535468f, -0.15532576f, -0.25030178f, 
    0.01377462f, 0.04344646f, -0.03083150f, -0.15184081f, 0.02037629f, 0.00006280f, -0.04980661f, 0.00863286f, 
    0.28983203f, -0.02334466f, 0.05276553f, -0.02144282f, 0.03983934f, -0.07338417f, -0.02510803f, 0.08761490f, 
    -0.01430350f, 0.01814189f, -0.00881088f, -0.01745061f, 0.44094750f, -0.03012370f, 0.00377649f, 0.00797572f, 
    0.03720909f, -0.14252883f, 0.02371500f, 0.05175418f, -0.09082124f, 0.05836954f, -0.02154169f, -0.03630973f, 
    -0.14225015f, 0.08777890f, 0.07793427f, 0.17583829f, 0.05616207f, 0.01205688f, -0.05567406f, 0.06832088f, 
    -0.03118512f, -0.08326547f, 0.08286937f, 0.03253702f, -0.14048523f, 0.10999606f, 0.02615865f, 0.18818513f, 
    -0.01776321f, 0.04297765f, -0.02815975f, -0.05390714f, 0.05363072f, -0.06316298f, 0.09509276f, 0.05449212f, 
    -0.00990145f, -0.12188260f, -0.19236542f, -0.21809353f, -0.02383227f, -0.08690690f, -0.11443783f, 0.09172761f, 
    -0.03852836f, 0.07272735f, -0.13099989f, 0.03731909f, -0.33140525f, 0.13064305f, 0.02094265f, -0.02087615f, 
    0.02168254f, -0.03526415f, -0.02005335f, -0.02861432f, -0.07499466f, 0.07091811f, -0.14585787f, 0.08734504f, 
    0.19294550f, -0.23585282f, 0.14672212f, 0.17414811f, 0.08814327f, 0.04961045f, -0.11059223f, -0.06156001f, 
    -0.00434489f, 0.09927106f, 0.02818273f, 0.07858881f, -0.14101696f, 0.06331292f, -0.21498531f, 0.14908651f, 
    0.00939344f, -0.10030413f, -0.02529714f, 0.03525700f, 0.05610212f, 0.04686522f, 0.01490558f, -0.03392169f, 
    -0.14715764f, 0.16919935f, -0.17703089f, -0.38613522f, 0.05389732f, -0.17392018f, -0.07494841f, 0.01435775f, 
    -0.10050324f, -0.13658114f, -0.00351350f, -0.19581711f, -0.16563457f, 0.14757432f, -0.03413685f, 0.09333256f, 
    0.07770597f, 0.08219059f, -0.00233926f, 0.04010464f, 0.11231973f, 0.06915329f, 0.08685111f, 0.10946988f, 
    -0.26305598f, -0.11582477f, 0.15785989f, 0.00181610f, 0.06019713f, -0.04140446f, -0.09646324f, -0.02106796f, 
    0.00992955f, -0.11882512f, -0.01087492f, -0.05826583f, 0.39389184f, 0.17360672f, -0.13893679f, -0.12896684f, 
    0.04058266f, 0.01432762f, 0.03590719f, -0.05227691f, -0.13743469f, -0.11534576f, 0.01497172f, -0.10731038f, 
    -0.01791860f, -0.11967865f, 0.03295335f, 0.05775782f, 0.02029366f, 0.04058800f, 0.02797375f, 0.00674379f, 
    0.01293583f, -0.01835165f, 0.02307733f, -0.07070068f, 0.16354078f, -0.01805130f, -0.16037254f, -0.00168172f, 
    -0.01994436f, -0.07823785f, -0.07266761f, -0.03921784f, -0.03009929f, -0.04861777f, -0.00322334f, -0.03232723f, 
    -0.05283630f, 0.00429872f, 0.07611339f, -0.17516541f, -0.06063180f, -0.05274720f, -0.09198782f, -0.08224908f, 
    0.15685755f, 0.03859301f, -0.01178424f, 0.01782568f, -0.03251790f, 0.08890609f, -0.11738538f, 0.08346913f, 
    -0.02954937f, 0.04012814f, 0.07051193f, 0.03633428f, -0.09343902f, -0.05638013f, -0.09503414f, -0.02418573f, 
    0.27197370f, -0.15008654f, 0.09674249f, 0.06572571f, -0.00375383f, 0.07717416f, 0.15190144f, -0.11910350f, 
    0.07372381f, 0.15938033f, -0.07997709f, 0.04144023f, 0.00538294f, 0.04713956f, 0.19890049f, -0.22679076f, 
    0.06920171f, 0.12092604f, -0.04417064f, 0.07688004f, 0.02930496f, 0.03909326f, 0.01990979f, 0.03066674f, 
    -0.07218840f, 0.03684900f, -0.06827141f, -0.01247654f, 0.07385363f, 0.07967526f, 0.06533609f, -0.02170796f, 
    0.08340648f, -0.00916667f, 0.03033524f, 0.04765175f, 0.07928984f, 0.08361381f, 0.00758280f, -0.03868248f, 
    0.04045670f, -0.02395608f, -0.07227234f, -0.00621287f, -0.06235671f, 0.03274981f, 0.02814410f, -0.03071115f, 
    0.00789830f, 0.12716398f, -0.23377492f, 0.33095750f, -0.01732032f, 0.07995947f, -0.02084411f, -0.00510919f, 
    -0.00011377f, -0.08779109f, -0.02438706f, -0.04937700f, -0.24339040f, -0.08696156f, 0.01010933f, -0.02253582f, 
    0.02456183f, -0.10290617f, -0.06223305f, -0.02479953f, 0.03823762f, -0.07741734f, 0.09056137f, 0.14317872f, 
    -0.16745402f, 0.19077671f, 0.24447852f, -0.03796493f, -0.00038141f, 0.05412941f, -0.08397084f, -0.06252167f, 
    0.00309775f, 0.02868146f, 0.03532365f, -0.13415682f, -0.22154224f, 0.05736441f, 0.05957769f, -0.12048549f, 
    0.09740896f, -0.08470532f, -0.18072213f, -0.01975892f, -0.01071896f, 0.05361381f, -0.07783702f, 0.07086811f, 
    -0.04432929f, -0.14783548f, -0.00683002f, -0.26696259f, -0.01670783f, 0.08476833f, -0.02905351f, -0.08057670f, 
    -0.15004247f, -0.08126390f, -0.04419859f, -0.17035452f, -0.08069345f, -0.02132979f, -0.00814961f, -0.05518910f, 
    0.22603151f, 0.01008163f, 0.05209724f, -0.11202567f, 0.01184705f, 0.07835831f, -0.06648081f, 0.12494649f, 
    -0.05638670f, -0.14554408f, 0.28937298f, -0.09105966f, -0.11424339f, 0.04239645f, 0.00615028f, 0.13205469f, 
    -0.09897634f, 0.05081892f, -0.03252083f, 0.06451863f, -0.11329877f, 0.03357901f, 0.12404076f, -0.13821220f, 
    0.05033340f, 0.00543642f, 0.05814702f, -0.04712373f, -0.04173921f, -0.01860028f, -0.06361410f, 0.03691897f, 
    -0.10109815f, -0.01363314f, 0.16812466f, 0.00595925f, 0.10438558f, 0.03649404f, 0.02788001f, -0.02304954f, 
    0.11867604f, 0.00987458f, -0.08635405f, -0.03789018f, 0.17016745f, 0.12815972f, -0.14690652f, -0.14740451f, 
    0.01339340f, -0.03803492f, 0.05500568f, 0.11463740f, 0.07105982f, -0.06890240f, -0.15711729f, 0.12041420f, 
    -0.14742953f, 0.05916531f, 0.20073539f, 0.04130078f, -0.02146269f, 0.08589545f, 0.09061460f, 0.04051936f, 
    -0.02213918f, -0.18451838f, 0.06781828f, -0.08543098f, 0.40951630f, 0.09129900f, -0.05498409f, -0.05001640f, 
    0.08806083f, -0.02779813f, -0.09809861f, 0.07873621f, 0.00333670f, -0.05366197f, -0.11743420f, 0.14144406f, 
    -0.33910757f, -0.01771704f, 0.11130360f, 0.08194984f, 0.10417217f, 0.04206870f, -0.11768446f, 0.03719694f, 
    0.04934172f, -0.00838456f, 0.02501536f, 0.05633936f, -0.32682329f, 0.18143758f, -0.08552539f, -0.09298307f, 
    -0.04635093f, 0.07130721f, 0.09611566f, -0.13267668f, -0.00190856f, 0.01002050f, 0.01054861f, 0.07741462f, 
    -0.02534194f, -0.16959743f, 0.15588616f, -0.23811278f, -0.03807232f, 0.00306299f, -0.07858132f, 0.09793320f, 
    0.00120914f, -0.00370813f, -0.10267811f, -0.07782031f, -0.60562319f, 0.27713090f, -0.04748468f, -0.06747568f, 
    0.08101100f, 0.02248660f, 0.05877649f, -0.02433717f, -0.02765740f, 0.04455529f, 0.01476728f, 0.03462150f, 
    -0.14060162f, -0.04466433f, 0.01903031f, 0.22198497f, 0.04857438f, 0.00610481f, 0.07965696f, 0.01242771f, 
    0.00052539f, -0.00049757f, -0.01692542f, -0.00679229f, -0.46524689f, -0.16671431f, 0.13168192f, -0.17624660f, 
    -0.00435998f, -0.10924242f, -0.00516914f, -0.04499613f, 0.10351076f, -0.07761421f, 0.14402579f, -0.00534742f, 
    -0.16135314f, 0.17361289f, 0.18453456f, -0.13232441f, -0.07364081f, 0.02338031f, 0.10091322f, -0.03621010f, 
    0.06746550f, -0.01119883f, -0.03556857f, -0.09528875f, -0.14396806f, 0.32462463f, 0.22862056f, -0.08332340f, 
    -0.02391466f, -0.03727374f, -0.05711198f, -0.01390698f, 0.06129058f, -0.02208799f, 0.03254769f, 0.05637217f, 
    0.24455088f, -0.16699381f, 0.16829960f, -0.21561716f, -0.00406457f, 0.10753622f, -0.03904616f, 0.02807496f, 
    0.01367928f, -0.02462501f, 0.04586514f, -0.06768220f, -0.15728568f, -0.14901710f, 0.08930687f, -0.17096511f, 
    0.13527988f, 0.03997541f, -0.08844119f, -0.12506871f, -0.09416508f, -0.08643732f, -0.00305738f, 0.01341979f, 
    0.29800686f, 0.05792006f, 0.17355002f, 0.07231823f, -0.01879688f, 0.08996665f, 0.09207317f, 0.06848461f, 
    0.06556636f, -0.02246078f, -0.01608599f, 0.02197098f, 0.06838471f, -0.35354450f, 0.15926477f, -0.10720001f, 
    0.04890878f, -0.06369245f, 0.04931079f, 0.00473783f, 0.05257860f, -0.15960287f, 0.14654648f, 0.10869015f, 
    -0.03708424f, -0.30250266f, -0.05085013f, -0.01883614f, 0.05910134f, -0.01583825f, -0.10182075f, -0.09705070f, 
    -0.08793496f, -0.10060225f, -0.11833985f, -0.00944503f, -0.00874955f, 0.18805005f, 0.25638148f, -0.01094224f, 
    -0.00110168f, 0.06046139f, -0.10866775f, -0.00756691f, 0.01909494f, 0.13359950f, 0.04569177f, -0.11341029f, 
    0.11590295f, -0.38671270f, -0.13708761f, 0.14007959f, -0.16406882f, -0.00089185f, 0.13704519f, 0.03337185f, 
    0.08901061f, 0.07796995f, -0.11589018f, 0.01927902f, 0.22412507f, 0.09967582f, -0.12022103f, -0.22050695f, 
    -0.06200662f, -0.06826700f, 0.08795470f, -0.01285578f, -0.06618279f, 0.05705733f, 0.16344215f, 0.01707343f, 
    0.38966259f, 0.16335455f, -0.03186923f, -0.04865337f, 0.11220821f, -0.06178221f, -0.04337521f, 0.04049316f, 
    0.00343969f, -0.01628920f, 0.02332225f, 0.08680080f, 0.26661921f, -0.13536805f, -0.10784291f, 0.16346101f, 
    -0.08998078f, 0.01530110f, -0.01073495f, 0.00870131f, 0.02814748f, -0.05638508f, 0.09601589f, -0.09349547f, 
    -0.31316850f, 0.21555987f, 0.18588303f, -0.05193526f, -0.04099465f, 0.11975777f, -0.04821672f, 0.06801574f, 
    0.00855782f, -0.03895236f, 0.05654628f, 0.01311344f, 0.09176061f, -0.04194978f, -0.21197706f, -0.09890574f, 
    -0.06077424f, 0.01647080f, 0.00660773f, 0.07410002f, 0.07945694f, -0.08233169f, 0.10684481f, -0.04027567f, 
    0.04516650f, -0.26516962f, -0.12765737f, -0.17155764f, -0.01961747f, -0.00572473f, 0.07333557f, 0.09578571f, 
    0.03258399f, 0.00210201f, 0.09128618f, -0.02703938f, -0.12556536f, -0.02253241f, 0.10849813f, -0.30837333f, 
    0.03235756f, 0.00182139f, -0.08048002f, -0.06894138f, -0.06284736f, 0.02447351f, 0.01945124f, -0.10489379f, 
    0.15603372f, 0.02324634f, -0.09016312f, -0.12823781f, -0.07083233f, 0.09875553f, 0.04845833f, 0.06105141f, 
    0.02910082f, -0.10110358f, 0.01098675f, -0.07011565f, -0.02380632f, 0.23331417f, 0.01662038f, -0.17633761f, 
    0.06534004f, 0.08767815f, -0.03777907f, 0.06729057f, 0.07999813f, -0.06084751f, -0.02272703f, -0.01926258f, 
    0.23118390f, 0.01176896f, 0.01489344f, -0.03652315f, 0.01836935f, -0.00174417f, 0.08900592f, -0.09425751f, 
    0.15475976f, 0.02322648f, -0.05918787f, -0.06275755f, 0.22130206f, 0.11371005f, -0.13836934f, 0.04061991f, 
    -0.01674092f, -0.10925916f, 0.03545053f, -0.05012080f, 0.01280717f, 0.02195906f, 0.06428313f, -0.04070878f, 
    -0.47007412f, -0.34719047f, -0.14234903f, -0.14708956f, -0.05219777f, -0.08719029f, -0.02880631f, 0.01357973f, 
    0.01441441f, 0.06052634f, -0.07052220f, 0.04241571f, 0.03548028f, 0.01451422f, -0.05870919f, 0.03253512f, 
    -0.02690407f, -0.01343184f, -0.04018176f, -0.03602313f, -0.00275199f, -0.16994704f, -0.07776061f, -0.11642585f, 
    0.06760555f, 0.02866638f, 0.04459433f, -0.07827097f, -0.14335401f, 0.01317664f, -0.08198549f, -0.04463632f, 
    -0.01296429f, 0.05906470f, 0.02836899f, -0.04508353f, 0.18092236f, 0.05327366f, -0.13656421f, -0.00862672f, 
    -0.09441577f, -0.06583829f, -0.00479177f, -0.07235164f, -0.02508122f, -0.17379457f, -0.06098236f, -0.10971541f, 
    -0.25152555f, -0.08386692f, -0.20655200f, -0.15445891f, 0.05469324f, -0.09869041f, -0.15443863f, -0.02088568f, 
    -0.08340979f, -0.07783145f, -0.12135089f, -0.10057232f, 0.12549588f, 0.02119600f, 0.00470699f, 0.10789178f, 
    -0.01625587f, -0.18492197f, 0.02063286f, 0.04467369f, 0.10958737f, 0.02649127f, -0.00704665f, 0.08302087f, 
    -0.45409441f, -0.23741595f, 0.10203390f, 0.03539148f, 0.15073396f, 0.11674247f, -0.01547202f, -0.15182357f, 
    0.12620156f, 0.01041890f, -0.02063863f, 0.11397902f, 0.04884944f, 0.05260238f, 0.08385883f, 0.08055148f, 
    -0.03937018f, -0.01972574f, 0.09591617f, 0.11973348f, 0.07017233f, 0.05576091f, 0.04815195f, 0.05398325f, 
    -0.21041255f, -0.23023558f, 0.08514725f, 0.02274762f, -0.00283801f, 0.07182331f, 0.00737363f, -0.11344294f, 
    0.09797056f, -0.17010109f, -0.10035438f, 0.03233780f, 0.14989500f, 0.00803014f, 0.02810460f, -0.01496400f, 
    0.05783401f, 0.04422150f, 0.03631496f, -0.02451398f, 0.02508284f, -0.03748233f, -0.06486041f, -0.03982003f, 
    -0.16490756f, 0.11627264f, -0.11342265f, -0.31088975f, -0.01437653f, -0.00012684f, 0.00197011f, 0.02655699f, 
    0.08143857f, -0.06371111f, 0.02987900f, -0.07132812f, -0.07465025f, -0.13315548f, 0.05013621f, 0.15163989f, 
    0.00106817f, 0.10339378f, -0.01177130f, 0.15247183f, 0.03754275f, -0.03602798f, 0.07534272f, -0.03116206f, 
    0.05848850f, 0.03668255f, -0.09279998f, 0.07639930f, -0.11746959f, 0.10560124f, -0.10244808f, -0.17634261f, 
    0.09129730f, -0.01726541f, 0.02523115f, -0.03944415f, 0.07052007f, 0.12483501f, -0.01366635f, -0.03837342f, 
    0.08352256f, -0.04681786f, -0.02105510f, 0.05605207f, 0.09705842f, -0.04632210f, -0.08482378f, -0.00614566f, 
    0.00780056f, -0.00105991f, 0.02287033f, -0.26119724f, 0.03886585f, 0.09183609f, 0.12330009f, 0.06614389f, 
    0.01299053f, 0.09883692f, 0.11708929f, 0.11643521f, -0.09764903f, -0.13502499f, -0.06923490f, -0.01485809f, 
    0.04316865f, 0.03904511f, 0.04821867f, 0.08663189f, 0.01511474f, -0.14923441f, -0.11538590f, -0.03962629f, 
    0.10562867f, -0.01577174f, 0.04707073f, -0.04943699f, -0.12518403f, 0.05231157f, 0.03389111f, 0.04823288f, 
    0.00293054f, 0.12780677f, 0.08801027f, 0.05946019f, -0.06970836f, -0.10478697f, 0.01652697f, 0.24946697f, 
    0.00180693f, -0.18715549f, -0.04203159f, -0.05660293f, -0.01934741f, -0.02923895f, -0.01044098f, -0.01574897f, 
    0.08984989f, 0.12262147f, -0.05140135f, 0.01215202f, 0.01953714f, -0.00587391f, 0.01833011f, -0.05006220f, 
    -0.07268791f, -0.12601513f, 0.06300558f, -0.00311882f, 0.07997945f, 0.20160761f, -0.12467474f, 0.01834016f, 
    -0.09012058f, 0.12166325f, -0.13136333f, 0.02744256f, 0.05011171f, 0.03307226f, -0.01596693f, 0.06773844f, 
    -0.07618172f, 0.05070471f, -0.01311538f, -0.13029787f, 0.05973179f, -0.08647642f, -0.04973332f, 0.08096378f, 
    -0.03196808f, 0.00617045f, 0.03582598f, 0.06789153f, 0.24840568f, -0.03888433f, 0.04914847f, 0.12212839f, 
    0.01157584f, -0.00648905f, 0.04830934f, 0.03143495f, 0.01857800f, 0.09490868f, 0.06843167f, 0.20933913f, 
    -0.56414169f, -0.18254603f, -0.16062082f, -0.06348055f, 0.05750321f, -0.01584952f, -0.09014269f, -0.14094487f, 
    0.01484618f, -0.16541830f, -0.01426902f, -0.03808536f, -0.53699392f, -0.08798312f, -0.27141345f, -0.16788034f, 
    0.06552380f, 0.05759848f, -0.07829405f, -0.02476747f, 0.05726351f, -0.05434110f, 0.08255053f, 0.07230983f, 
    -0.30453235f, -0.20854326f, 0.05128275f, -0.10034195f, 0.02200965f, 0.02628691f, 0.07762025f, -0.07139421f, 
    0.12924461f, 0.15094328f, -0.04068820f, 0.06937988f, -0.03405654f, 0.02785180f, -0.01461320f, 0.11251294f, 
    0.06671444f, 0.09181447f, 0.10636047f, -0.03146602f, 0.02821041f, 0.03348887f, 0.08652028f, 0.14125161f, 
    0.16698927f, 0.00054716f, 0.03192493f, 0.17430644f, -0.02259646f, -0.03034292f, 0.07084995f, 0.02095322f, 
    -0.00883738f, 0.05288684f, 0.00108922f, 0.08547685f, -0.22768739f, 0.01330785f, -0.12299170f, 0.06228986f, 
    -0.00172106f, -0.02209840f, 0.02180795f, -0.03045608f, 0.01852732f, 0.04081426f, 0.06630556f, -0.07584148f, 
    -0.18717030f, -0.15645602f, 0.01795937f, -0.07991592f, 0.05976050f, -0.05789619f, -0.02513479f, -0.02467835f, 
    0.05648995f, -0.04435043f, 0.05524942f, -0.01910986f, -0.44329727f, -0.39696705f, -0.09660521f, 0.01986021f, 
    0.02685873f, -0.01349630f, -0.02301901f, 0.05240135f, -0.02881313f, 0.03309071f, 0.11271966f, -0.01217286f, 
    -0.22458220f, -0.16372301f, 0.12006707f, -0.22203383f, 0.08890250f, 0.00353781f, 0.02127030f, 0.11880949f, 
    0.03024192f, 0.04411860f, 0.02557046f, 0.09119219f, 0.23602875f, -0.08406303f, -0.09505402f, 0.02758956f, 
    0.00123634f, 0.03108925f, 0.05686694f, -0.01450853f, 0.08194368f, -0.06074843f, -0.05277172f, 0.00171557f, 
    -0.12966448f, -0.08353207f, -0.04392115f, 0.05711625f, 0.14517012f, -0.12230547f, -0.05808715f, 0.00173674f, 
    0.02783044f, -0.14424676f, 0.07855976f, 0.05569115f, 0.15407746f, 0.06383163f, -0.14040273f, 0.05090205f, 
    0.13096412f, 0.03882090f, 0.00546207f, 0.02035830f, -0.01841958f, 0.09608353f, -0.00334879f, -0.06041419f, 
    0.04877609f, -0.01717784f, -0.05780992f, -0.04144574f, -0.06909681f, -0.00080741f, 0.02831479f, 0.05672837f, 
    0.05025508f, 0.02355114f, 0.09338148f, 0.06195476f, 0.14970879f, 0.07250407f, 0.00015304f, 0.02259292f, 
    0.02450270f, -0.07481962f, -0.08094871f, -0.01924731f, -0.02024078f, 0.00220569f, -0.08648392f, 0.01935911f, 
    -0.11834411f, -0.06517166f, 0.10258938f, 0.03554697f, 0.08086026f, 0.14163746f, 0.07822763f, -0.08675817f, 
    0.04267686f, 0.07730128f, 0.06514960f, 0.11860577f, -0.01788431f, 0.06116921f, -0.20314270f, 0.04557114f, 
    -0.07938226f, -0.12926693f, 0.00347009f, 0.06199363f, 0.00872545f, 0.06906292f, 0.13856350f, -0.03823531f, 
    0.09682868f, 0.08836302f, -0.01271720f, 0.05585833f, -0.00781321f, 0.00639681f, 0.04195479f, -0.07282384f, 
    0.04143059f, 0.01796861f, 0.01241950f, -0.12403923f, 0.26349518f, -0.01955433f, 0.08770034f, -0.04744747f, 
    0.01001857f, 0.04506786f, 0.01573650f, 0.08992396f, 0.00299822f, -0.00201725f, 0.04045081f, -0.04955902f, 
    -0.09671343f, 0.01319138f, -0.03100950f, -0.00967002f, 0.01939819f, -0.04039806f, 0.05414674f, -0.07569481f, 
    -0.04142109f, 0.02026275f, 0.06732684f, 0.06592412f, -0.40254441f, -0.54303271f, -0.07421934f, -0.00527259f, 
    0.04534762f, -0.01644154f, -0.03773208f, 0.00854611f, 0.04620197f, 0.07256357f, 0.02266103f, 0.04277353f, 
    -0.45969471f, -0.09766971f, 0.07467090f, -0.10176793f, 0.05049887f, 0.03069965f, -0.09000940f, 0.00757247f, 
    0.07444023f, -0.04598158f, -0.09833365f, 0.08297335f, 0.01772371f, 0.01130542f, -0.09022065f, 0.12819694f, 
    -0.02780155f, -0.04176330f, -0.03167007f, -0.10804354f, 0.05883682f, 0.10756975f, -0.02013335f, -0.06778131f, 
    -0.10100698f, -0.01239508f, 0.00134952f, -0.03160945f, 0.06771736f, -0.18818983f, 0.02541412f, -0.05291366f, 
    -0.12839136f, -0.02078504f, -0.00643867f, 0.14383224f, -0.37027127f, -0.13593601f, -0.09884888f, 0.08207563f, 
    0.00857141f, 0.03333946f, 0.06630167f, 0.00382368f, 0.01835096f, -0.05391499f, 0.00980589f, 0.02875392f, 
    -0.38257244f, 0.05951025f, -0.01989806f, -0.13294309f, 0.09094664f, 0.04643394f, -0.05105914f, 0.07742316f, 
    0.02671187f, -0.08213347f, 0.11445681f, 0.09775803f, -0.41236103f, -0.02580960f, -0.17454553f, -0.21868783f, 
    0.08419979f, -0.01983500f, -0.05741938f, -0.07593384f, -0.04615556f, 0.10157971f, -0.09036675f, 0.01091122f, 
    0.06145524f, -0.23397133f, -0.04376451f, -0.05078167f, 0.00088105f, -0.04067704f, 0.08957880f, -0.22499834f, 
    -0.05841444f, -0.12972027f, -0.24881363f, -0.00032856f, -0.12453031f, 0.09033626f, -0.12705286f, -0.19268730f, 
    0.01683872f, -0.03700223f, -0.06383815f, 0.00567830f, 0.11508013f, 0.09334181f, -0.00013967f, -0.04432730f, 
    0.10969128f, 0.00071269f, -0.11513422f, 0.09552953f, -0.07294235f, 0.01856697f, 0.17466079f, 0.01739166f, 
    -0.00920957f, 0.05988108f, 0.00781972f, -0.06004889f, -0.41092905f, -0.46362787f, -0.02078310f, 0.09261342f, 
    0.06455354f, -0.01167641f, 0.00648553f, -0.11199179f, 0.09105352f, 0.00815311f, -0.17526737f, -0.09362037f, 
    0.30071804f, 0.05969387f, -0.02492135f, -0.01843387f, 0.10325535f, 0.12012131f, 0.07469676f, 0.03247686f, 
    0.06424572f, 0.22341467f, -0.07193041f, 0.07193293f, -0.27813154f, -0.23898299f, 0.05221294f, 0.01401385f, 
    0.10464522f, -0.01213661f, -0.02791787f, -0.02498325f, 0.03809860f, 0.05589806f, -0.18398587f, 0.03514969f, 
    0.23482624f, 0.04363461f, 0.01218620f, 0.08381160f, -0.08641893f, -0.04934617f, 0.01722396f, -0.02431555f, 
    0.04080511f, 0.04049452f, -0.09818600f, -0.06355234f, 0.10461380f, 0.02061179f, -0.01541565f, -0.06484418f, 
    -0.04349463f, 0.09382406f, -0.00190233f, -0.06456108f, 0.02588741f, -0.01859515f, 0.01153055f, 0.04464421f, 
    -0.13387533f, -0.03479524f, 0.02653804f, 0.02185266f, 0.04313816f, -0.00892082f, 0.00905880f, 0.02738729f, 
    0.22430675f, 0.05272019f, -0.00601252f, 0.04040298f, 0.13404673f, 0.09209764f, -0.02602988f, -0.08556128f, 
    0.08310563f, 0.06491999f, 0.03432483f, 0.02600425f, 0.00428120f, 0.11182161f, 0.05072286f, 0.14401212f, 
    0.18504700f, 0.02488187f, -0.04996450f, 0.11365588f, -0.09265103f, -0.06837629f, 0.05468462f, 0.02336163f, 
    -0.03518702f, 0.12897740f, -0.18610394f, 0.05645387f, 0.06614001f, 0.09159490f, 0.08129734f, -0.17636441f, 
    0.01538517f, 0.10917769f, 0.00191111f, 0.08350274f, 0.05225891f, 0.00748675f, 0.00246703f, -0.00090084f, 
    -0.20029302f, 0.31779936f, -0.06639360f, 0.06468625f, 0.17427061f, -0.10800287f, 0.09251117f, -0.03190220f, 
    -0.03780199f, -0.01959739f, 0.04418297f, 0.03274699f, -0.12601398f, -0.15135114f, 0.18495567f, 0.17238863f, 
    -0.03986560f, 0.05848298f, -0.08479785f, 0.03192423f, -0.12500383f, 0.15329275f, 0.14779386f, 0.02557350f, 
    0.20996934f, 0.08243575f, -0.00914319f, 0.06729325f, -0.06818685f, -0.05498525f, -0.02907159f, -0.13575466f, 
    0.09545083f, 0.03725453f, -0.05511603f, -0.10282417f, -0.12876160f, -0.05602204f, 0.02289027f, -0.04225507f, 
    0.01678757f, 0.05039261f, -0.01723468f, 0.05336921f, -0.07883826f, -0.03466668f, -0.06572150f, 0.12312038f, 
    -0.06910536f, -0.10324515f, -0.01918655f, -0.36417788f, 0.05749742f, -0.01426199f, -0.04330994f, 0.01707417f, 
    0.06764543f, -0.02707957f, -0.04053020f, -0.00935056f, -0.04608026f, -0.19477472f, -0.03758487f, 0.01441102f, 
    -0.02840907f, 0.02154505f, 0.02734595f, 0.10507550f, 0.04063170f, -0.00168110f, -0.01606591f, -0.03766982f, 
    -0.08244329f, 0.13350254f, -0.00971242f, 0.17739917f, -0.01772103f, -0.04325631f, -0.08361468f, -0.03654855f, 
    -0.08006556f, -0.00634326f, -0.05380652f, -0.04032038f, 0.19302200f, -0.11784518f, -0.02846204f, -0.00787508f, 
    -0.05660174f, 0.00323013f, 0.13841102f, 0.03744025f, -0.05616422f, -0.07245177f, -0.06384213f, 0.02512860f, 
    -0.04314633f, -0.32798001f, -0.07847805f, -0.23064734f, 0.07514187f, -0.06637971f, 0.02072784f, -0.02522953f, 
    0.02292563f, 0.05798949f, 0.08831530f, 0.01722083f, 0.04815049f, -0.02741146f, -0.13495977f, 0.05180559f, 
    0.06310087f, 0.05226263f, 0.08264881f, 0.04212239f, -0.12819234f, -0.04577570f, 0.01625132f, 0.03916950f, 
    0.02206247f, 0.12046117f, 0.08295809f, -0.28373879f, 0.06457558f, -0.09502380f, 0.00255377f, 0.12358508f, 
    -0.14566056f, -0.05201517f, 0.07141159f, -0.03997107f, -0.02428044f, 0.08546066f, 0.07825384f, -0.00418311f, 
    0.06629751f, 0.05379336f, -0.07399972f, 0.02614424f, -0.03305682f, -0.07923129f, -0.06780257f, -0.10579742f, 
    0.00931605f, 0.17481820f, -0.03616454f, -0.02626972f, 0.09404764f, -0.03192315f, -0.12509628f, -0.05145412f, 
    0.06478482f, 0.06829671f, 0.06437639f, 0.07405630f, -0.02713932f, 0.05696930f, -0.10025270f, 0.00381261f, 
    0.03761823f, 0.01740362f, -0.05589765f, -0.03852075f, 0.08233896f, 0.01238607f, -0.01274451f, 0.13445847f, 
    0.15643948f, -0.09283832f, -0.11746007f, -0.13205877f, -0.02893993f, 0.01726057f, -0.01318179f, -0.08434950f, 
    -0.00084012f, 0.04431614f, 0.04281322f, -0.04816390f, 0.06602019f, 0.12594581f, -0.07247179f, -0.08118264f, 
    -0.03772920f, 0.06608488f, 0.00195804f, -0.00574569f, 0.00329071f, 0.02170631f, -0.12687400f, -0.05409095f, 
    -0.14875749f, -0.11270225f, -0.03018148f, 0.11154029f, -0.13799559f, -0.02549424f, -0.12557691f, 0.05150253f, 
    -0.06054751f, 0.14379284f, 0.02690025f, 0.04122923f, 0.04990686f, 0.06462800f, 0.17712642f, 0.15123251f, 
    0.00317850f, -0.00348799f, 0.03924023f, -0.03386009f, -0.07962099f, 0.06821591f, 0.06200671f, 0.14310627f, 
    0.22505181f, -0.01197477f, -0.12251113f, 0.22649626f, 0.08126215f, -0.07776193f, -0.04359307f, 0.04605114f, 
    -0.02111544f, -0.00229078f, 0.03720821f, -0.02241404f, -0.11397339f, -0.17403391f, 0.10473759f, -0.06030038f, 
    0.01446802f, -0.09146337f, 0.10759653f, 0.09084542f, 0.06819182f, 0.01091823f, 0.01235733f, -0.11304794f, 
    0.04957462f, -0.04663312f, -0.04782367f, 0.03778059f, -0.04075583f, 0.14979880f, -0.11583745f, -0.16551058f, 
    0.03514602f, -0.07013410f, -0.13026993f, -0.02337377f, -0.03432962f, 0.03157265f, 0.17146118f, -0.05522556f, 
    -0.15451303f, -0.02481943f, -0.13453262f, 0.03315260f, 0.13713785f, -0.03632714f, 0.06574988f, 0.02053269f, 
    -0.16633919f, 0.25386047f, -0.00449649f, -0.07448255f, -0.03608879f, 0.09190304f, 0.00316230f, -0.06708100f, 
    -0.05813563f, 0.09514193f, -0.04252802f, -0.07836641f, -0.29159653f, -0.10922501f, 0.01510060f, 0.04408883f, 
    -0.12976700f, 0.07635905f, 0.07242041f, -0.00885667f, -0.06982712f, 0.07113233f, -0.01049548f, -0.10956632f, 
    -0.08829615f, -0.13423105f, -0.04518725f, -0.05019209f, -0.00373576f, -0.06796951f, -0.10831191f, -0.03398796f, 
    0.02791039f, -0.10908432f, 0.00274692f, -0.05778225f, 0.05787535f, -0.04779122f, 0.04552605f, 0.11943653f, 
    -0.08198503f, -0.00882559f, -0.04658417f, 0.04457063f, -0.08833078f, -0.05508814f, 0.04434904f, -0.09372149f, 
    0.32697940f, -0.05628255f, 0.05611916f, -0.09089929f, 0.10558056f, -0.00915223f, -0.08074347f, -0.01822661f, 
    0.08468905f, -0.02881003f, 0.03350890f, -0.06358430f, 0.38952184f, -0.05695957f, -0.05539469f, 0.10371146f, 
    -0.01124542f, -0.03028889f, 0.02531729f, 0.01649060f, -0.04416466f, -0.00594382f, 0.00883243f, 0.05277803f, 
    0.01487271f, -0.21569808f, 0.04750824f, -0.16809566f, 0.07336853f, 0.00460228f, -0.01881188f, 0.07063130f, 
    0.02206907f, -0.05940541f, -0.04091801f, 0.00716822f, -0.21222539f, 0.11154893f, 0.02168052f, 0.05347469f, 
    0.02600578f, 0.06519111f, 0.00188201f, 0.00231002f, -0.01739959f, 0.02228131f, 0.02171740f, -0.02442975f, 
    0.08635278f, -0.08027776f, 0.13231282f, -0.12345074f, 0.02612140f, -0.03638742f, 0.02030383f, -0.09185392f, 
    -0.08214343f, 0.04485162f, 0.11936897f, 0.06148399f, -0.09399759f, -0.11560173f, -0.11205989f, 0.12326159f, 
    -0.14478761f, 0.09969032f, -0.04746314f, -0.02713137f, 0.04846812f, -0.03970688f, 0.04961169f, 0.06978285f, 
    0.13985047f, -0.26468152f, -0.21407762f, 0.03511069f, 0.05939848f, 0.07080348f, -0.04460624f, -0.05072672f, 
    -0.01469877f, -0.00197268f, -0.11610515f, 0.06378654f, 0.02632673f, 0.07470809f, -0.10544211f, -0.13834117f, 
    0.10914117f, -0.03698299f, 0.02276342f, 0.02923033f, -0.01376816f, 0.06840196f, -0.10636538f, -0.05488865f, 
    0.35252076f, 0.25034222f, -0.18200552f, 0.23746063f, -0.07378611f, -0.04643910f, -0.06046596f, -0.02025558f, 
    0.08512422f, -0.03146381f, -0.05838547f, 0.06630481f, -0.18440673f, -0.14516363f, -0.00474406f, -0.09894554f, 
    0.01061236f, -0.10569126f, 0.04563891f, 0.10837959f, -0.01306804f, -0.02286576f, 0.01024413f, -0.01340260f, 
    0.11392305f, -0.08173445f, -0.04532615f, -0.32410273f, -0.05046566f, 0.08891497f, 0.21301441f, 0.06115955f, 
    -0.01336003f, 0.01903775f, -0.08959733f, -0.07372021f, 0.14992364f, -0.03511163f, -0.09731417f, 0.16783665f, 
    -0.11149467f, 0.15765914f, 0.02338544f, -0.01398352f, 0.05447460f, -0.06921772f, -0.01752328f, -0.09124750f, 
    -0.22215347f, -0.19163211f, -0.00013085f, -0.00429478f, 0.06739824f, -0.04869777f, -0.02130129f, 0.09758427f, 
    -0.08686715f, -0.02027382f, -0.06874251f, -0.12374602f, 0.01812661f, -0.00682565f, 0.08413992f, -0.04989586f, 
    0.06057125f, 0.08451881f, -0.03364525f, -0.01517539f, 0.00695917f, 0.01795235f, 0.08968436f, 0.16185993f, 
    0.24975821f, 0.01357972f, -0.07232396f, -0.05711174f, 0.14490269f, -0.05181228f, -0.18933634f, 0.03803315f, 
    0.02803130f, 0.03844731f, -0.02319203f, -0.00269891f, -0.36948466f, 0.00593780f, 0.09675175f, -0.19333029f, 
    0.01896594f, -0.02460413f, -0.05406804f, 0.05178751f, -0.06243078f, -0.01856462f, -0.03448955f, 0.04739435f, 
    0.18649578f, -0.25369412f, -0.10806580f, 0.10297934f, -0.06838143f, 0.03513236f, -0.04420218f, -0.11668632f, 
    0.02031110f, 0.00897568f, -0.02605408f, 0.02889277f, -0.20481297f, 0.07773492f, -0.33997020f, 0.04113480f, 
    0.26431787f, -0.14759652f, -0.00596396f, 0.11559243f, 0.06066397f, 0.04426915f, -0.04819919f, -0.06072908f, 
    0.07963919f, -0.03927128f, 0.02654796f, 0.13876612f, 0.03880645f, 0.13888091f, 0.00035617f, -0.05882924f, 
    0.01236098f, -0.01029898f, -0.13418613f, -0.04708400f, -0.02531475f, 0.04435817f, -0.04919855f, 0.08272969f, 
    0.15259686f, -0.00422466f, 0.04012307f, -0.00904025f, 0.08357418f, 0.00152470f, -0.06228522f, -0.01935886f, 
    -0.22727396f, 0.49060377f, -0.06992308f, -0.04909489f, 0.14719167f, 0.00950350f, 0.01704450f, -0.02777778f, 
    0.04376616f, 0.02266827f, 0.03837043f, -0.16466230f, 0.01741661f, -0.26374298f, -0.03437393f, 0.13508610f, 
    -0.15787509f, 0.09272479f, -0.16900718f, -0.06930971f, -0.01351723f, 0.13598134f, -0.04259929f, -0.04869384f, 
    -0.07442274f, 0.01587921f, 0.03768881f, -0.19789015f, 0.04691909f, -0.03450117f, -0.05580334f, 0.10917743f, 
    -0.04484740f, -0.11004954f, -0.03641902f, -0.04798563f, 0.05024994f, -0.03730505f, -0.09773450f, 0.09351002f, 
    0.10664769f, 0.01889480f, -0.14789833f, 0.00094596f, -0.04121691f, 0.08328976f, -0.02963860f, 0.03541638f, 
    0.35831189f, -0.08844087f, -0.12303722f, -0.16315292f, 0.00039577f, 0.01028156f, 0.03872469f, -0.02584806f, 
    0.02480333f, -0.04577734f, 0.01090220f, -0.14886110f, -0.43808770f, -0.06683286f, -0.04662755f, -0.10972015f, 
    -0.05138119f, 0.10467534f, -0.02713590f, 0.08849170f, -0.02552354f, -0.03033719f, 0.01673669f, -0.08641415f, 
    -0.21922112f, -0.14754783f, 0.02486695f, -0.04247767f, 0.07472754f, -0.03485489f, -0.01744825f, 0.07238536f, 
    -0.03550715f, 0.07514366f, 0.08023113f, 0.01851997f, -0.45037249f, -0.08945231f, 0.06229093f, 0.06521584f, 
    -0.00220148f, 0.04884399f, -0.15354717f, 0.10729256f, 0.00805794f, 0.01822127f, 0.10916162f, 0.11191742f, 
    -0.17905340f, 0.11657828f, 0.07551378f, 0.01308573f, -0.20133874f, 0.09100719f, -0.26341021f, -0.02556917f, 
    0.07166629f, 0.02661523f, 0.04083180f, -0.09063235f, 0.25317097f, 0.02789906f, -0.05708726f, 0.16465248f, 
    -0.01635012f, 0.11490053f, -0.07923511f, -0.05088352f, 0.11781323f, 0.07422197f, 0.10596231f, 0.09513523f, 
    -0.24640588f, 0.12446664f, 0.05898215f, -0.01018440f, -0.02302898f, 0.02013949f, -0.00176472f, -0.09969018f, 
    0.00821444f, -0.12916334f, -0.06511102f, 0.02454159f, 0.07129128f, -0.20600906f, -0.05549838f, -0.02239745f, 
    0.02590345f, -0.12396324f, 0.00478503f, 0.02661942f, -0.07904308f, -0.01727270f, 0.05067525f, 0.11955152f, 
    -0.20811510f, -0.27211946f, 0.14299174f, 0.06155396f, 0.01261737f, 0.05876982f, 0.07477432f, 0.02970421f, 
    0.09234629f, 0.01052664f, 0.00425147f, 0.05297825f, -0.23597175f, 0.29937354f, 0.04795894f, -0.12813047f, 
    0.09819336f, -0.01587465f, 0.01469778f, -0.09658968f, 0.01699180f, -0.07963213f, 0.02668099f, -0.03794803f, 
    0.09201033f, 0.02721666f, 0.04428648f, -0.06891598f, 0.08719862f, -0.08507545f, -0.00365051f, 0.03762957f, 
    0.01514026f, 0.04007335f, -0.00188462f, -0.07491647f, -0.06709298f, -0.05083263f, 0.08287024f, 0.17182845f, 
    -0.05463318f, -0.02954781f, -0.11829505f, 0.08768640f, -0.05077989f, -0.08306372f, -0.11087774f, -0.11300879f, 
    0.05071350f, -0.19147044f, 0.04811683f, 0.14984240f, -0.08760629f, 0.15355663f, 0.03391983f, -0.02320649f, 
    -0.11057513f, 0.11559018f, -0.02242366f, -0.14905271f, 0.45116571f, 0.07239895f, -0.35911980f, 0.00330159f, 
    0.04781872f, -0.08997934f, 0.02092431f, 0.07109120f, 0.08383467f, 0.05282757f, 0.09585508f, -0.00662401f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07414569f, 0.02376510f, -0.00782484f, 0.01457064f, 0.00431182f, 0.03993480f, -0.01766876f, -0.08082967f, 
    -0.03760752f, -0.01226975f, 0.07282955f, -0.01376171f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
