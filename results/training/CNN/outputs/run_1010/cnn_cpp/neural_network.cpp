#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.53157401f, 0.04742834f, -0.33529252f, -0.30843335f, -0.78263390f, -0.68605006f, 0.30844370f, 0.69553441f, 
    0.35835534f, 1.47163570f, -1.41463256f, -0.73131847f, -0.06462519f, -0.21395372f, 0.77127314f, -0.18666561f, 
    0.16433357f, -0.18102421f, -0.39874938f, 0.52546734f, -0.06522273f, 0.46581012f, 0.04768896f, -0.04417927f, 
    -0.51342434f, 0.22202559f, 0.28334981f, -0.88148731f, 0.88324362f, -0.60014331f, 0.04623939f, 0.59251195f, 
    -0.33024362f, 0.13699338f, 0.53660452f, -0.26442215f, 1.15564466f, 0.44328874f, -1.11522627f, -0.24415256f, 
    -0.39823103f, -0.02233307f, -0.42613927f, -0.25908601f, -0.70039189f, -0.31123349f, 0.67494041f, 0.39365900f, 
    0.22370735f, -0.40686303f, -0.37284136f, 0.41899532f, -0.04008755f, -0.30686221f, -0.78216332f, -1.49979007f, 
    0.23084323f, 0.92512578f, 0.98169059f, -0.07916598f, 0.19998530f, -0.59462911f, -0.30097634f, 0.21420805f, 
    0.33739421f, 0.34216267f, -0.02066768f, 0.22410111f, 0.12806685f, 0.41075388f, -0.41794798f, -0.39059782f, 
    -1.15055895f, -0.83584398f, -0.24809839f, 0.44986284f, -0.42523399f, -0.36250809f, -0.42286253f, -0.40113991f, 
    -0.42016703f, 0.22374567f, -0.58141249f, -0.64683264f, -1.02100873f, -0.70744425f, -0.67090863f, 0.47673815f, 
    -0.73589259f, -0.35253939f, 0.64896637f, 0.95511156f, 0.21318507f, -0.53964198f, -0.74021322f, -0.59000885f, 
    -0.06979305f, -0.26969910f, 0.31426299f, -0.17239814f, 0.04189498f, 0.19558945f, -0.43330932f, 0.47337791f, 
    -0.58635229f, 0.32440707f, -0.00037336f, 0.32978651f, 0.51830989f, 0.61913389f, -0.78938979f, -0.25565621f, 
    0.39740843f, -0.62718529f, 0.01760456f, 0.51626915f, -0.00485599f, -0.81930399f, 0.25402084f, -0.51427221f, 
    -0.05708698f, -0.85156041f, -0.77098316f, -0.15167901f, 0.06297661f, 0.63227397f, -0.87705612f, -0.63264525f, 
    -0.34263977f, -0.38601097f, 0.01848289f, -0.60460901f, 0.39264098f, -0.15059540f, -0.64836204f, 0.39766967f, 
    0.09457026f, -0.57054520f, -0.50665355f, 0.36891174f, 0.30590719f, 0.52468562f, -0.71547037f, 0.46066347f, 
    -0.64042711f, -0.55993152f, -0.76757175f, 0.52722096f, -0.28581312f, 0.24304591f, 0.20029680f, -0.12154994f, 
    0.57730377f, 0.80831861f, 0.50376630f, 0.43394208f, -0.13356221f, 0.24305633f, 0.10859991f, -0.24680941f, 
    -0.38144195f, -0.31045750f, -0.29851279f, 0.25538790f, 0.16346927f, -0.04002372f, 0.63914287f, 0.44102135f, 
    -0.28006291f, 0.66931307f, -0.20133263f, 0.08752047f, 0.26649180f, 0.29258367f, -0.03534039f, -0.14418578f, 
    -0.13906536f, -0.69737548f, 0.85988289f, -0.63736933f, 0.20542824f, -0.04321409f, 0.34316814f, 0.20789823f, 
    0.10885782f, 0.15246648f, 0.13742915f, 0.43083841f, -0.55231911f, -0.06879959f, 0.67847615f, -1.19249487f, 
    -0.45659506f, 0.26916999f, -0.37330991f, -0.38995689f, -0.37185320f, 0.15337119f, -1.24169326f, -0.44494271f, 
    1.40198517f, -0.28823858f, -1.29360175f, -0.15114664f, -0.08547702f, 0.48407644f, 0.02289519f, 0.01296525f, 
    -0.37595457f, 0.47211757f, -0.09037539f, -0.61727107f, 0.66560698f, 0.26991954f, -0.23206271f, -0.13908528f, 
    -0.11593743f, 0.02466828f, 0.29174310f, -0.04686455f, -0.33900160f, 0.38147247f, 0.13466412f, -0.65222526f, 
    0.51736414f, 0.86310279f, -0.73063457f, -0.04063597f, 0.17794389f, 0.41329780f, -0.21415205f, 0.16745718f, 
    -0.45099545f, 0.30308729f, -0.95444041f, -0.85379088f, -1.10071826f, 0.65178406f, 0.78353351f, 0.10435441f, 
    0.09780114f, 0.42759699f, 0.15752937f, -0.82771927f, 0.51485592f, 0.87279749f, -0.23886980f, -0.58984679f, 
    0.24441466f, -0.03210289f, -0.48764122f, 0.03880160f, -0.96890378f, 0.43358320f, -0.40195310f, -1.10065627f, 
    -0.15292555f, -0.19716781f, 0.01816011f, 0.49715093f, -0.06330154f, 0.52372122f, 0.35733005f, 0.26134574f, 
    -0.59464508f, -0.36077440f, 0.33526489f, 0.26528677f, 0.31839883f, 0.08821849f, -1.31263602f, 1.41325140f, 
    0.60484713f, -0.56989491f, 0.10453118f, -0.00899697f, -0.41456643f, 0.30013451f, -0.16838935f, -0.41581619f, 
    -0.76355159f, -0.32473743f, -0.49530205f, -0.74282938f, -0.72006720f, -0.67973578f, -0.46823075f, -0.64241207f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06022919f, 0.15142895f, 0.45970729f, 0.06917094f, 0.01449901f, 0.12811761f, -0.01546687f, -0.18965958f, 
    0.00505588f, -0.19903561f, 0.25977513f, 0.03059219f, 0.20133761f, 0.12657368f, -0.25727978f, -0.09654596f, 
    0.52446276f, -0.25418159f, -0.09806130f, -0.01910631f, -0.19566242f, -0.08026998f, 0.12374268f, 0.30825281f, 
    0.35950094f, 0.38665703f, 0.18482184f, 0.18270227f, 0.48182899f, 0.18784054f, 0.32741830f, -0.40360042f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.36280721f, 0.25354102f, -0.16140816f, -0.03232577f, -0.01362973f, -0.02623105f, -0.03167273f, -0.20232350f, 
    -0.02050404f, -0.05144774f, 0.04466173f, 0.02457476f, 0.03968867f, -0.01958828f, -0.00634499f, -0.05606381f, 
    -0.03021737f, -0.04382721f, -0.15815908f, -0.12392158f, 0.07074860f, 0.15912889f, -0.33294281f, -0.14122993f, 
    0.06676154f, -0.04175026f, -0.15578286f, 0.02219017f, -0.07513789f, -0.02694470f, -0.11272877f, 0.01538176f, 
    -0.28665191f, 0.03960001f, -0.15004131f, 0.16820836f, 0.03815344f, -0.00944154f, 0.00386419f, 0.11172523f, 
    -0.36245987f, -0.35242698f, -0.17647044f, 0.02314190f, -0.02666688f, -0.00587648f, -0.05771314f, -0.05952734f, 
    -0.00791686f, -0.06930976f, -0.18896505f, -0.09096579f, 0.00356386f, -0.24022397f, 0.00040122f, -0.09955259f, 
    -0.01146025f, -0.03390829f, 0.04311257f, -0.12514292f, 0.04946809f, -0.03503295f, -0.14183050f, 0.08254349f, 
    0.07087386f, 0.03258258f, 0.03949578f, -0.01984370f, 0.01414012f, 0.06021241f, -0.15846530f, -0.00319742f, 
    -0.15548208f, 0.02619793f, -0.07077727f, -0.04382272f, 0.09949379f, 0.01008945f, -0.09150104f, -0.01259339f, 
    -0.15711278f, 0.35310647f, 0.14012262f, -0.16326202f, -0.48898292f, -0.23242386f, -0.07078097f, -0.22916907f, 
    0.06032752f, 0.08343079f, -0.00999834f, -0.02429773f, -0.08865225f, 0.03044924f, 0.05163551f, 0.02519489f, 
    0.05375689f, 0.16782741f, 0.19407608f, 0.14035618f, -0.36496428f, -0.03675658f, -0.21588953f, 0.19688198f, 
    0.01727401f, 0.02515523f, -0.04121023f, 0.04309487f, 0.00939777f, -0.05857004f, -0.03408980f, 0.03076762f, 
    -0.00604744f, 0.00236132f, 0.06631274f, 0.08604636f, 0.20719652f, 0.02633680f, -0.11099692f, 0.09519789f, 
    0.70813841f, -0.36162263f, -0.56631172f, -0.15140656f, -0.09448830f, 0.12941386f, 0.04637159f, 0.15931071f, 
    -0.16399758f, 0.09544274f, -0.03094997f, 0.05906776f, -0.08810134f, 0.08597243f, 0.00101197f, -0.03013867f, 
    0.09052379f, 0.08524291f, -0.00576616f, 0.03213932f, -0.08109498f, -0.15830821f, -0.15162049f, -0.06052680f, 
    -0.09404446f, 0.06671995f, 0.02586631f, -0.01671804f, 0.06648818f, 0.03644570f, 0.04467637f, 0.02077567f, 
    0.00080999f, 0.10523541f, 0.06972954f, -0.07402556f, -0.09036571f, 0.00812580f, 0.00180335f, 0.05502459f, 
    0.41375500f, 0.23212561f, 0.12378496f, -0.29008311f, 0.01268908f, 0.04557887f, 0.14252627f, 0.12725277f, 
    -0.03203254f, 0.10833094f, -0.02402965f, -0.04073881f, -0.03460881f, -0.04656121f, -0.02150429f, 0.01514823f, 
    -0.12146099f, 0.00506129f, -0.14602658f, -0.04483123f, 0.30821508f, 0.27802056f, 0.24307631f, -0.44766393f, 
    -0.07546619f, 0.16299379f, 0.13789980f, 0.02654584f, -0.00752515f, 0.03994735f, 0.02495203f, 0.00390268f, 
    0.02956327f, -0.09482030f, 0.02089642f, -0.05318446f, -0.07867373f, 0.04602519f, 0.06167175f, 0.17233792f, 
    -0.25159189f, 0.12415620f, -0.03409281f, -0.18552238f, -0.20811670f, -0.05934661f, -0.16655299f, -0.22595516f, 
    -0.04967457f, -0.14066219f, 0.04217794f, -0.02491428f, -0.00357654f, 0.06111031f, 0.00659951f, -0.05393540f, 
    0.10739121f, -0.06337871f, -0.08412562f, -0.05389656f, 0.03493276f, 0.01884494f, 0.09073211f, -0.00980277f, 
    0.01305967f, 0.01658180f, 0.00999448f, 0.07101279f, -0.00207799f, 0.05037270f, -0.03810319f, 0.13174945f, 
    -0.07080933f, -0.03583578f, -0.03851750f, -0.03567614f, -0.09603303f, -0.08149213f, -0.06803459f, -0.06456645f, 
    0.02792111f, -0.07446277f, -0.34763181f, 0.03989533f, -0.14479485f, -0.01602947f, -0.05124894f, -0.03013792f, 
    -0.03880430f, 0.06137146f, -0.08490903f, 0.00443734f, -0.04441616f, -0.12479968f, -0.08532602f, -0.10181794f, 
    -0.04750903f, -0.18270004f, -0.16326664f, -0.02987393f, 0.26267353f, 0.33760917f, -0.03049641f, -0.31706595f, 
    -0.09731491f, 0.05620892f, -0.04152643f, -0.02952666f, -0.05479370f, 0.03321312f, 0.02005775f, -0.07965402f, 
    -0.00517805f, 0.03128931f, 0.01082518f, -0.03518674f, -0.05983662f, -0.00727177f, -0.03188318f, -0.00552909f, 
    0.43621746f, 0.28723153f, 0.05879833f, -0.38194615f, -0.09426623f, 0.17928019f, 0.12846942f, 0.08586575f, 
    -0.03113507f, 0.06709194f, 0.01698916f, 0.02749532f, -0.04798195f, -0.00120852f, 0.00832278f, 0.04097325f, 
    -0.03364798f, -0.14038068f, -0.11720866f, 0.13564864f, -0.08462402f, -0.02597870f, 0.02172116f, 0.07783730f, 
    0.07921678f, 0.00158030f, -0.05289038f, -0.01406127f, 0.07138976f, 0.04578582f, -0.09631161f, -0.00158902f, 
    -0.10806541f, -0.11276384f, 0.02078859f, -0.05902194f, 0.00904783f, -0.02863274f, -0.04543390f, -0.13097176f, 
    0.28477743f, 0.15461905f, -0.01329564f, -0.17909969f, 0.16194494f, 0.12829898f, 0.17764057f, 0.08392719f, 
    -0.11054645f, -0.23633763f, -0.14001244f, -0.10481640f, -0.05477235f, -0.00113569f, 0.06544068f, -0.01372900f, 
    0.04573379f, -0.03965572f, -0.04436255f, -0.02875646f, -0.10288879f, -0.13708854f, -0.13816777f, -0.00499015f, 
    0.18329605f, 0.05651822f, 0.04088844f, -0.01646513f, 0.06622675f, 0.03961481f, 0.04182915f, 0.06683144f, 
    0.02373558f, 0.09724496f, 0.04644731f, 0.10926294f, -0.00542044f, -0.13208215f, 0.06864959f, -0.01525983f, 
    -0.02447013f, -0.01587950f, 0.04134040f, 0.00353974f, 0.08403697f, 0.02308828f, 0.03373140f, 0.03919031f, 
    0.03066964f, 0.06768314f, -0.19570272f, -0.14717554f, -0.00157138f, -0.22971354f, -0.36999711f, -0.01181785f, 
    0.03863118f, 0.02321376f, -0.04196718f, 0.02483575f, -0.46860334f, 0.16521628f, 0.00861579f, -0.08079354f, 
    0.03780282f, 0.00157463f, -0.01984947f, 0.00873215f, 0.08443627f, 0.09921493f, -0.04756507f, -0.00764056f, 
    -0.03169742f, -0.07645261f, -0.01694462f, -0.07327567f, -0.05908802f, -0.07927200f, -0.18194002f, 0.01285299f, 
    -0.12706318f, -0.15368734f, -0.11822968f, 0.03809460f, 0.04901360f, 0.02064649f, 0.06989829f, 0.07549876f, 
    0.03937256f, 0.04500914f, -0.00801199f, 0.03422959f, 0.05567196f, 0.01922721f, 0.02357140f, 0.01695717f, 
    -0.26798436f, -0.02322464f, -0.06978674f, 0.09669892f, 0.02622525f, 0.27254152f, 0.13119720f, 0.04699941f, 
    -0.26241273f, 0.07368555f, 0.04857619f, 0.10038690f, -0.11315739f, -0.00863916f, -0.07269822f, -0.06669940f, 
    0.05343643f, 0.01325514f, 0.13588095f, -0.01820857f, 0.06347489f, -0.08120611f, -0.18473308f, -0.09099605f, 
    0.38654131f, 0.35753766f, 0.34025252f, -0.65170437f, 0.01783270f, -0.06614493f, 0.04743515f, -0.02019412f, 
    0.05778518f, -0.09371352f, 0.19400960f, -0.18321007f, -0.06177771f, -0.09662047f, -0.09074029f, -0.01631408f, 
    0.02207698f, -0.03413555f, 0.11950634f, -0.16110644f, -0.48679635f, -0.23414482f, 0.20801021f, -0.27482864f, 
    -0.00219453f, -0.01191204f, 0.01683447f, -0.07713469f, 0.01157566f, 0.02856353f, -0.11162436f, -0.11676428f, 
    -0.22923610f, -0.03143826f, -0.13261734f, -0.08548243f, -0.22343974f, 0.00530958f, -0.11397765f, -0.05526729f, 
    -0.31980795f, -0.51970214f, 0.10974265f, -0.22327255f, 0.06665520f, 0.01267735f, -0.09343122f, -0.02515708f, 
    0.01448298f, -0.05058326f, 0.04762222f, -0.00454407f, -0.08061989f, -0.16638292f, -0.14446995f, -0.31263033f, 
    -0.24743916f, -0.12190594f, 0.00800701f, -0.13065085f, -0.23393686f, -0.17274714f, -0.15779242f, 0.03198065f, 
    -0.07155371f, -0.15854561f, -0.08660234f, -0.00533032f, -0.04330714f, -0.01741295f, -0.09628397f, 0.01314848f, 
    -0.35292289f, -0.20458189f, -0.10894246f, -0.14648645f, 0.13475162f, -0.20982961f, -0.14063497f, 0.05507903f, 
    0.27934858f, 0.16154172f, -0.37341186f, 0.08738929f, 0.15351805f, 0.18448962f, 0.15023346f, 0.16766830f, 
    -0.15777117f, -0.20065615f, -0.05473131f, -0.04428347f, -0.07747842f, 0.06812549f, 0.02637372f, 0.03918650f, 
    0.09985584f, 0.03144933f, 0.01084896f, 0.01677916f, -0.53083235f, 0.18682471f, 0.29275855f, -0.28599620f, 
    0.36060202f, -0.09496199f, -0.26824740f, 0.00487061f, 0.09519499f, 0.05948379f, 0.05764830f, -0.09860692f, 
    -0.03196044f, -0.02495053f, 0.01707584f, -0.01756798f, -0.04173323f, -0.07456230f, -0.08289701f, 0.04193896f, 
    0.18869521f, 0.21173511f, 0.05084396f, -0.26821199f, -0.31770128f, -0.08079261f, -0.07333040f, -0.04805033f, 
    0.01884948f, -0.13540535f, 0.02067659f, -0.05256496f, -0.00748958f, 0.01882681f, 0.07824787f, -0.08136709f, 
    -0.02619257f, -0.01002780f, -0.19692589f, 0.14112064f, -0.04906686f, -0.06660013f, -0.02428045f, -0.01912029f, 
    -0.04555200f, -0.12642358f, -0.00080492f, 0.03676796f, 0.06146902f, 0.00291555f, -0.02082946f, 0.07086571f, 
    -0.01870604f, 0.05821594f, 0.05536487f, -0.01221757f, -0.06981343f, -0.07153536f, -0.08270484f, -0.01519584f, 
    -0.88065851f, 0.16088204f, 0.10093453f, 0.03818806f, -0.19471598f, -0.02127008f, -0.17891638f, 0.03908579f, 
    0.11379381f, -0.06123031f, 0.02156743f, 0.02998285f, 0.00861606f, -0.04607035f, 0.02951119f, -0.02893684f, 
    0.07407370f, 0.04210200f, -0.25461161f, -0.06343392f, 0.35499734f, 0.28397721f, 0.12401523f, -0.33784643f, 
    0.00111264f, 0.15234873f, 0.15998094f, 0.18232372f, -0.14150344f, 0.09236579f, -0.02134292f, -0.04112805f, 
    0.02062294f, -0.09801696f, -0.14913078f, -0.03587768f, -0.22585829f, -0.01565620f, 0.07925458f, 0.05070503f, 
    -0.16565044f, -0.07900335f, -0.16530536f, -0.02807768f, -0.10754076f, 0.26249865f, -0.02887128f, -0.10444914f, 
    0.04167670f, -0.05856460f, -0.07681760f, -0.12835260f, 0.02922955f, 0.10484914f, 0.10993893f, -0.00284706f, 
    -0.00559608f, -0.02231192f, 0.18087463f, 0.14225452f, 1.09600961f, 0.64927810f, -0.33735129f, 0.30050611f, 
    0.01818769f, -0.16869657f, 0.24553825f, -0.01222909f, -0.27602315f, 0.16081069f, 0.11687475f, -0.12423987f, 
    -0.11661922f, -0.01560665f, 0.00171164f, -0.08646445f, 0.09486895f, -0.07672372f, -0.10551819f, 0.17850211f, 
    -0.05780248f, 0.02110766f, 0.15900549f, 0.10038196f, 0.16041397f, 0.07878436f, -0.02368723f, 0.09235075f, 
    -0.05679230f, 0.01032456f, -0.03704415f, 0.01196801f, 0.05016847f, -0.00328091f, 0.07167625f, 0.05179294f, 
    0.12692259f, -0.03864921f, -0.01350439f, -0.05656610f, -0.11688145f, -0.28620961f, -0.01302250f, -0.05496252f, 
    -0.10053858f, -0.07377828f, 0.06315576f, -0.10985533f, 0.09307148f, 0.04107720f, -0.03272352f, -0.01051983f, 
    -0.27017552f, 0.17132431f, -0.04256295f, -0.09709702f, -0.03086215f, -0.13548528f, 0.08806654f, 0.02392459f, 
    0.39726642f, 0.24546368f, -0.12476858f, -0.11523799f, -0.72659725f, 0.07963187f, -0.05155237f, -0.03590157f, 
    -0.19739982f, -0.02994072f, -0.05591590f, 0.01152582f, -0.03976944f, 0.04598793f, 0.03643563f, -0.11923263f, 
    -0.26642421f, -0.17304106f, -0.10526743f, -0.31910923f, 0.14651512f, -0.01735201f, 0.06048171f, 0.12707023f, 
    0.01183635f, 0.04785819f, 0.01958690f, -0.04271858f, 0.00976858f, -0.07497609f, -0.02240013f, -0.03154023f, 
    -0.00592077f, 0.05428790f, 0.05456805f, 0.08688805f, 0.03507156f, 0.04557747f, 0.07873572f, -0.22468781f, 
    0.48266116f, -0.51867521f, 0.07961462f, 0.08844732f, -0.08909985f, -0.05375443f, 0.03995133f, 0.01165636f, 
    0.10271970f, -0.12418943f, 0.21583235f, -0.14905256f, 0.00615937f, -0.14166443f, -0.12843797f, 0.06195091f, 
    -0.07375055f, -0.08023699f, -0.05624720f, -0.10675459f, 0.29689848f, 0.09568793f, 0.11154485f, 0.07810789f, 
    0.10766959f, -0.02322095f, -0.06889382f, 0.01595870f, -0.02508629f, 0.01721618f, -0.08391263f, -0.02321463f, 
    0.00023164f, 0.00138808f, 0.09894849f, 0.15128574f, 0.00137079f, -0.11958785f, 0.05326287f, -0.13168401f, 
    0.15108581f, 0.31212759f, 0.06003898f, 0.18537213f, 0.06024145f, 0.10371819f, -0.02437155f, -0.02367901f, 
    0.13608560f, -0.03809009f, 0.08991781f, -0.02131296f, 0.05797216f, -0.06492594f, 0.03519572f, -0.06458412f, 
    0.04357170f, -0.12306752f, -0.20464517f, -0.01743319f, -0.14298512f, 0.32862350f, -0.06001219f, -0.04415305f, 
    -0.01718425f, 0.13286078f, -0.36150134f, -0.04192827f, -0.26988855f, -0.17656974f, -0.00126742f, 0.01095059f, 
    0.04839605f, -0.01700947f, 0.17078018f, -0.00617260f, -0.01396801f, 0.07989359f, -0.35738903f, -0.25998765f, 
    0.20522314f, 0.05696506f, -0.03934079f, -0.17200254f, -0.25599247f, 0.19595964f, -0.28093439f, -0.23798069f, 
    -0.17125978f, -0.04975217f, -0.05148790f, -0.01977694f, 0.04344162f, 0.08324187f, -0.02222978f, 0.14549829f, 
    0.03149505f, -0.31263977f, 0.06116845f, 0.13904297f, 0.05884046f, -0.00654657f, -0.06787569f, -0.02208062f, 
    0.03962347f, -0.14084977f, 0.07339951f, 0.01993335f, 0.12325767f, 0.02472440f, 0.09186545f, -0.02791250f, 
    0.21260288f, 0.03446733f, 0.01787106f, -0.05265516f, -0.04523531f, 0.07335354f, 0.10051922f, -0.18131967f, 
    -0.05284451f, -0.06282203f, -0.09427031f, -0.05001321f, -0.21099214f, -0.06026829f, -0.04376599f, -0.13908090f, 
    0.14143395f, -0.05192848f, 0.08319069f, 0.04376747f, 0.00578661f, 0.11845208f, 0.12895921f, -0.02183390f, 
    0.03914674f, -0.06739755f, 0.12296896f, 0.08355941f, -0.23665930f, 0.07567139f, -0.12749025f, 0.35166907f, 
    -0.12267027f, -0.03312539f, 0.00434136f, -0.27335614f, -0.13869749f, -0.07742091f, -0.07713153f, 0.02752496f, 
    -0.00766264f, -0.01441976f, 0.01469494f, -0.07122536f, 0.04906414f, -0.02345551f, -0.33614153f, 0.01068813f, 
    0.10419820f, 0.26777375f, 0.09990809f, 0.03994742f, 0.16377841f, -0.03740677f, -0.13887535f, -0.24823964f, 
    -0.07726420f, -0.02936767f, 0.02953699f, -0.01847173f, 0.02432216f, 0.00745430f, 0.03311630f, 0.05774590f, 
    0.01766772f, 0.05395518f, -0.21527942f, -0.09256401f, -0.04310313f, -0.02820680f, 0.19434576f, 0.04498237f, 
    -0.09611173f, -0.09400166f, 0.11110993f, 0.13692153f, -0.01153513f, -0.05455538f, 0.16490474f, -0.18614033f, 
    0.10657985f, -0.04829868f, -0.20999253f, -0.10646555f, -0.11264803f, 0.04663655f, 0.01530336f, -0.05770827f, 
    -0.35059649f, -0.06086463f, -0.12906381f, -0.06529796f, -0.18140312f, 0.10635609f, 0.17226112f, 0.25383449f, 
    0.03341911f, -0.10489181f, -0.04343705f, -0.06974233f, 0.06298696f, -0.02416730f, -0.03033153f, 0.04198693f, 
    0.07116760f, -0.01229632f, -0.07127305f, 0.10090689f, 0.43053359f, 0.17346887f, 0.11031513f, 0.16585045f, 
    0.32804847f, -0.03201154f, -0.08706942f, -0.02611626f, -0.05289092f, -0.02620609f, -0.07626376f, -0.00002237f, 
    -0.02167591f, -0.01238365f, 0.03348619f, 0.09307618f, -0.04507107f, -0.01439053f, 0.11052585f, -0.02486723f, 
    0.06070208f, -0.11493954f, 0.16758971f, 0.06548175f, 0.01598163f, -0.09466693f, -0.10933048f, -0.01738667f, 
    -0.02886516f, -0.05385582f, 0.20935863f, 0.09414025f, -0.01806768f, -0.18280976f, 0.06995523f, -0.14854568f, 
    -0.05009430f, -0.07895866f, 0.03832170f, 0.02864791f, 0.44867685f, 0.09112207f, -0.03940547f, -0.13306038f, 
    0.18674651f, 0.04215655f, -0.00453406f, -0.07124452f, 0.04001010f, -0.10833334f, 0.00123210f, 0.00052245f, 
    0.04073748f, -0.04570302f, 0.04937531f, -0.29362950f, 0.19423464f, -0.15223391f, -0.00963718f, -0.19863169f, 
    0.22503217f, -0.00258327f, 0.07711181f, 0.13969532f, 0.12825128f, -0.04327360f, -0.06870160f, -0.03290490f, 
    -0.03845576f, -0.12021507f, 0.03015811f, -0.04866710f, 0.03143052f, 0.01978227f, -0.03177202f, -0.18728554f, 
    -0.12495293f, -0.03678853f, 0.00640671f, -0.07643795f, -0.43919805f, -0.17438622f, 0.13047437f, -0.15556462f, 
    -0.42772940f, 0.01345590f, 0.00542572f, -0.23319349f, -0.09601156f, 0.04939086f, 0.02866628f, 0.00794747f, 
    0.00652767f, -0.02304564f, -0.09139231f, -0.10267704f, -0.14156984f, -0.20469771f, -0.23829740f, 0.04252569f, 
    -1.23512995f, 0.21610643f, -0.49034384f, 0.03391321f, 0.13652809f, 0.14121903f, -0.23340145f, -0.08419971f, 
    0.39770028f, 0.20034525f, -0.02870427f, 0.11277863f, 0.09199191f, 0.08437762f, 0.00142312f, -0.11550791f, 
    0.01411598f, -0.03985129f, -0.12313770f, 0.16724537f, -0.35967281f, 0.19878641f, 0.05402985f, -0.06159864f, 
    0.08132413f, -0.07618456f, 0.06715963f, 0.05627661f, 0.13126630f, -0.01334921f, 0.11986741f, 0.06850579f, 
    -0.13357396f, 0.12838937f, -0.08946124f, 0.03742044f, 0.08527460f, 0.09949693f, 0.05125944f, -0.12325921f, 
    -0.11810297f, 0.11274847f, 0.03808312f, 0.01760009f, 0.13060640f, -0.04458609f, -0.05317649f, 0.01646187f, 
    -0.03713431f, -0.06532738f, 0.03186661f, 0.12812351f, -0.01884377f, 0.00511017f, -0.02153992f, 0.19332491f, 
    0.20623574f, 0.10818963f, 0.01580847f, 0.09622901f, 0.34374034f, 0.10349002f, 0.08774233f, 0.15721449f, 
    -0.00149082f, -0.04950439f, 0.05809123f, -0.02237750f, 0.05136655f, -0.04951397f, -0.00010049f, 0.07737757f, 
    0.31917027f, 0.05559378f, -0.11630394f, -0.03328341f, 0.02157724f, 0.05247215f, 0.00527937f, -0.07737090f, 
    0.12982774f, -0.30038255f, -0.21941096f, 0.05336028f, -0.10398706f, -0.01348046f, 0.07831618f, 0.07935324f, 
    0.01931455f, -0.16477141f, 0.02481356f, -0.01793962f, 0.03001017f, -0.04118304f, -0.01421050f, 0.02840179f, 
    -0.01261839f, -0.08403480f, 0.00703064f, 0.02783404f, -0.38186225f, -0.21750556f, -0.08996461f, -0.18998806f, 
    0.28023127f, 0.06716921f, -0.09688718f, -0.02313293f, -0.13198599f, -0.10724130f, 0.03759316f, 0.04620467f, 
    0.04021965f, -0.05823225f, 0.08573940f, 0.09497879f, 0.09911259f, 0.16227886f, 0.03282934f, 0.00636244f, 
    -0.31041145f, -0.16730349f, -0.12685500f, -0.09057280f, 0.07726301f, 0.02394496f, 0.14983197f, -0.32675382f, 
    -0.04029771f, -0.00098439f, 0.02075640f, 0.03119268f, 0.02437093f, 0.05646455f, 0.03279915f, 0.00933413f, 
    -0.01862774f, -0.03807000f, 0.17855334f, 0.02666958f, 0.03109823f, -0.02136486f, 0.12480797f, -0.03405596f, 
    0.07006697f, 0.03936826f, -0.05478722f, -0.02659414f, -0.01585362f, -0.02630453f, -0.00794046f, -0.05599539f, 
    0.00982339f, 0.13329171f, -0.04978484f, -0.02529592f, 0.02311068f, -0.08846975f, 0.10319246f, -0.02546924f, 
    -0.22082551f, -0.61723715f, 0.22803622f, -0.12919265f, 0.06516734f, 0.03049410f, -0.05489910f, -0.08313599f, 
    0.00547903f, -0.07556093f, 0.08894072f, -0.02792505f, 0.05219433f, 0.00538598f, 0.04951094f, 0.00542883f, 
    0.20884979f, -0.05450686f, 0.14597778f, 0.01696857f, 0.07843016f, 0.26626942f, -0.01042282f, 0.12278242f, 
    0.00764435f, 0.15513173f, -0.12883841f, -0.19846359f, 0.04908587f, -0.12036930f, 0.05251720f, 0.02850526f, 
    0.03611970f, 0.00668912f, 0.03071520f, -0.15519963f, -0.00609518f, 0.12529337f, -0.09226071f, 0.09563595f, 
    -0.34694391f, -0.09133673f, 0.01771049f, -0.05379069f, -0.05258299f, 0.06671436f, -0.05030286f, -0.29966384f, 
    -0.13394077f, -0.37725043f, 0.14568126f, 0.04418473f, -0.03037642f, -0.03918327f, -0.09385250f, 0.02777223f, 
    -0.02001104f, -0.03355745f, -0.32162666f, -0.06684721f, -0.35950813f, 0.70254904f, 0.02148557f, 0.23246598f, 
    0.07098807f, -0.25390348f, 0.19142663f, -0.17409377f, -0.24186553f, 0.34993696f, 0.06501337f, 0.18856694f, 
    0.01173988f, -0.10670231f, 0.02480106f, -0.00706781f, -0.07617834f, -0.08493861f, 0.08665351f, -0.07306226f, 
    0.15164864f, 0.03297659f, -0.04811587f, 0.00737045f, 0.08074514f, 0.01642083f, -0.04022979f, -0.01822812f, 
    0.03053221f, -0.01005324f, 0.12569855f, 0.01404494f, 0.10658423f, 0.09241658f, 0.13052298f, 0.04092963f, 
    0.00948203f, 0.00739782f, 0.04374985f, 0.02458356f, 0.36666769f, -0.09989281f, 0.07714838f, -0.01983757f, 
    0.12206203f, 0.03432346f, -0.05947631f, -0.03838713f, 0.00041178f, -0.00849832f, -0.10128520f, -0.18226959f, 
    -0.11390390f, -0.00936113f, 0.01294516f, 0.00509440f, -0.09671162f, -0.15363684f, 0.09731514f, -0.07913718f, 
    -0.40378445f, 0.25630444f, 0.45707425f, 0.45425063f, -0.74387062f, -0.01456441f, 0.02985025f, 0.01713479f, 
    -0.09314540f, 0.22572821f, -0.05694343f, -0.02463916f, -0.05695257f, 0.04408116f, -0.04743855f, 0.06920516f, 
    0.10071680f, 0.12194122f, 0.17095716f, 0.09955496f, -0.00828194f, -0.11885867f, 0.14566949f, -0.46766284f, 
    -0.02777839f, 0.10814891f, 0.05114707f, -0.06669886f, 0.04591021f, 0.11201461f, -0.02701527f, -0.00585553f, 
    0.04824381f, 0.06536931f, -0.10605765f, -0.05147284f, -0.13000353f, -0.10510606f, 0.07484444f, 0.11922392f, 
    -0.05990732f, -0.30312183f, 0.84570014f, 0.03794401f, 0.34610957f, -0.07052074f, -0.06488313f, -0.06227496f, 
    0.14365779f, -0.17672673f, 0.05978385f, -0.02691515f, 0.09889709f, -0.20059073f, 0.12341557f, 0.09060769f, 
    -0.00103221f, 0.02537176f, -0.01733128f, -0.05304151f, -0.09819287f, -0.22233726f, -0.15132339f, -0.14919615f, 
    0.19607165f, 0.05372006f, -0.02358493f, 0.06223472f, 0.04495774f, 0.06123841f, -0.01628342f, -0.01177178f, 
    -0.05352453f, 0.13431567f, -0.08387162f, -0.12954989f, -0.09481291f, 0.01948929f, 0.03359003f, -0.12069259f, 
    -0.15043737f, -0.13503839f, 0.52347392f, 0.61539865f, -0.00430227f, -0.00133735f, 0.07684693f, -0.10861720f, 
    0.12187482f, 0.06625191f, -0.04809241f, -0.00255586f, -0.03250549f, 0.02983326f, -0.03995930f, -0.01506510f, 
    0.09041788f, 0.04262739f, -0.08509611f, 0.06634271f, -0.88589716f, -0.48178291f, -0.54452968f, 0.05279451f, 
    -0.73269767f, 0.06003417f, 0.07631098f, 0.04142562f, 0.12230384f, -0.06852665f, -0.03084296f, 0.04826588f, 
    0.02240770f, 0.07430267f, -0.12541285f, -0.05792159f, -0.07045136f, -0.08447073f, 0.11590743f, 0.11095844f, 
    -0.70758033f, -0.36319664f, 0.42708635f, -0.36593288f, -0.06148925f, -0.07729154f, 0.11755017f, -0.01132172f, 
    -0.04452575f, 0.08670445f, 0.03058236f, 0.01197842f, -0.00033369f, 0.01204022f, -0.00921690f, -0.01540648f, 
    -0.16777243f, -0.15172951f, -0.06490097f, 0.05556999f, 0.01762818f, -0.06185488f, 0.01478504f, -0.02600636f, 
    0.07754630f, 0.00906922f, -0.14222133f, -0.04146282f, 0.00591825f, 0.07858994f, -0.11698266f, -0.21908805f, 
    0.06168107f, 0.03681114f, -0.01878269f, 0.05689831f, -0.09182948f, -0.12336685f, -0.08055769f, 0.02273473f, 
    -0.01640642f, -0.15403649f, 0.12451836f, -0.15334475f, 0.09234241f, -0.02854241f, -0.30253753f, -0.46361449f, 
    -0.09698657f, 0.06436403f, 0.08364632f, -0.06483844f, 0.01433340f, -0.03949539f, 0.01440352f, 0.08635244f, 
    -0.04486134f, -0.16907564f, 0.06530291f, 0.05121011f, 0.03601725f, -0.69518524f, -0.26677310f, 0.12710935f, 
    -0.29397628f, 0.10742076f, -0.09548898f, 0.01341997f, 0.03391564f, -0.15020457f, -0.00535717f, 0.06934270f, 
    -0.00060386f, -0.02663235f, -0.00871297f, -0.00403927f, 0.03446367f, 0.00593714f, 0.05416348f, 0.01267664f, 
    -0.25608236f, -0.38553396f, 0.20840223f, 0.10324883f, -0.22683100f, -0.00082818f, 0.09431095f, -0.13058491f, 
    0.25393867f, 0.10406696f, -0.00525819f, -0.00297810f, 0.04117937f, 0.05286889f, -0.09007917f, -0.04093847f, 
    -0.04764125f, -0.02365353f, -0.09151109f, 0.06982141f, -0.04381221f, 0.04925960f, -0.00974487f, -0.04167306f, 
    0.05284399f, -0.00711205f, -0.00295328f, 0.07049074f, 0.01309935f, -0.07817342f, -0.12960495f, -0.17805475f, 
    0.15805939f, -0.07619237f, 0.14674617f, -0.00346281f, -0.07080253f, -0.02766478f, 0.06629491f, -0.10468689f, 
    -0.05294259f, 0.04328097f, 0.16516623f, 0.29775158f, 0.05831834f, 0.00461162f, -0.12859568f, 0.06623521f, 
    0.10824985f, -0.12149070f, 0.03030522f, 0.17266123f, 0.10149159f, 0.00543873f, 0.03634928f, -0.01659955f, 
    -0.04603076f, 0.06396266f, 0.01694083f, 0.01609131f, -0.34373227f, -0.39061895f, -0.16723582f, -0.74260163f, 
    -0.42919737f, 0.01061022f, -0.01103202f, 0.01619689f, 0.04732628f, 0.05176027f, 0.00786383f, -0.01622612f, 
    -0.04313956f, 0.01479776f, -0.01866365f, -0.02470259f, -0.11372174f, 0.07686870f, 0.03267895f, -0.08413935f, 
    0.05387314f, -0.10155877f, -0.01503787f, -0.00040944f, 0.14541382f, 0.00323927f, 0.01798090f, 0.08456010f, 
    -0.00181497f, 0.02034102f, -0.23364282f, -0.06023943f, -0.20241736f, 0.16473652f, -0.05606003f, 0.07618066f, 
    -0.08264729f, -0.02549721f, 0.03612373f, -0.05205908f, 0.12587237f, 0.10245537f, -0.10748914f, -0.34616718f, 
    -0.16977732f, -0.03296091f, 0.01421973f, -0.03383409f, 0.11037137f, 0.07524582f, 0.01398207f, -0.00974139f, 
    -0.02828006f, 0.06034156f, 0.04172756f, 0.15337345f, -0.02093234f, -0.03995568f, 0.05099077f, 0.10479227f, 
    0.00874285f, -0.06547469f, -0.10838535f, -0.11496581f, 0.05150623f, -0.07655595f, -0.04640720f, -0.01015608f, 
    0.08121007f, 0.07422113f, -0.04814881f, -0.00812562f, -0.06907586f, 0.09851696f, -0.10338099f, 0.06885274f, 
    0.03563150f, 0.02872954f, 0.03942953f, 0.01973069f, 0.33843553f, -0.67068672f, -0.06340613f, -0.13327375f, 
    -0.25255808f, 0.07178761f, -0.18812737f, -0.00910832f, -0.16871227f, -0.27739725f, -0.01360851f, -0.07741030f, 
    0.03427831f, -0.21652612f, 0.03949685f, -0.00389666f, 0.03456321f, -0.18519695f, 0.27395436f, 0.10316843f, 
    0.78029001f, 0.09450478f, -0.79124135f, 0.05483564f, -0.11241805f, -0.01068311f, 0.09257919f, -0.02053932f, 
    0.01641501f, 0.09334016f, -0.05827650f, -0.00122067f, -0.06760536f, -0.04445953f, -0.14869115f, 0.04495071f, 
    0.00723197f, 0.14167456f, -0.24414466f, -0.11452126f, 0.08568014f, -0.00022240f, -0.24462989f, 0.00106507f, 
    0.10861582f, -0.05176984f, -0.03815449f, -0.00624202f, 0.04081070f, -0.06039593f, 0.05934614f, 0.07429397f, 
    0.05783917f, 0.03089316f, -0.20173597f, -0.14622107f, 0.05075161f, 0.17646360f, -0.03020511f, -0.07004978f, 
    -0.05782019f, 0.02111075f, -0.17101569f, 0.00591579f, 0.05358602f, -0.03308777f, -0.00517336f, 0.05571908f, 
    0.01581997f, -0.00398854f, -0.00312181f, 0.01364135f, 0.02452255f, 0.06666233f, -0.03239876f, -0.03024446f, 
    0.04716558f, 0.04825157f, -0.04508962f, -0.00337475f, -0.10335014f, 0.15347010f, 0.06270324f, -0.09035981f, 
    -0.03402172f, 0.02876069f, -0.04631457f, 0.01158806f, 0.03314768f, -0.02757899f, 0.16877374f, -0.21469896f, 
    0.02580434f, -0.02629348f, 0.10189666f, -0.05492330f, 0.01072089f, 0.02084165f, 0.16066702f, -0.01415531f, 
    -0.05567069f, -0.01891368f, 0.47532371f, 0.17436567f, 0.22446527f, -0.08454058f, -0.05114852f, 0.06939162f, 
    0.18749431f, -0.19460516f, 0.06638286f, -0.00828952f, -0.01311334f, -0.00980072f, 0.07709006f, 0.03599049f, 
    -0.06888822f, 0.01769576f, -0.00270212f, -0.08857658f, 0.08538150f, 0.14357924f, -0.08642378f, -0.17341962f, 
    0.23725815f, 0.00042059f, 0.09454778f, -0.02830341f, 0.02246382f, -0.05195932f, 0.03309730f, 0.05871596f, 
    0.03964911f, -0.01718254f, -0.02472003f, -0.05511670f, 0.07912764f, 0.12884931f, 0.05380684f, 0.05246648f, 
    0.09123619f, -0.24837695f, -0.42307591f, 0.11217976f, -0.21402067f, 0.09793223f, 0.11254892f, 0.01111262f, 
    0.00373702f, 0.00993990f, -0.02433923f, 0.02348473f, 0.00556353f, 0.07280561f, -0.01493548f, 0.03562313f, 
    -0.02893032f, -0.01759620f, 0.02602310f, 0.14190385f, -0.17588064f, 0.00503680f, 0.05014491f, 0.00411906f, 
    0.03976005f, -0.03712895f, -0.03603610f, -0.14449245f, -0.01606520f, 0.03209879f, 0.03689974f, -0.06569580f, 
    -0.01138808f, 0.09325275f, -0.07179213f, -0.04000514f, -0.14495192f, -0.01714093f, -0.08474892f, -0.00804835f, 
    0.41195723f, -0.00633405f, 0.29578170f, -0.31955546f, 0.36117652f, -0.02940427f, 0.12924041f, -0.02897128f, 
    0.00573518f, 0.00503126f, -0.05857011f, -0.06017961f, 0.03729220f, 0.01918731f, -0.00427733f, 0.10715962f, 
    0.05143849f, -0.02563651f, 0.19701003f, -0.01077339f, -0.54990840f, -0.58571279f, -0.30823416f, 0.20692021f, 
    -0.46967921f, -0.20409380f, 0.03814556f, -0.07236329f, 0.01216622f, -0.11456024f, -0.01179758f, -0.03971263f, 
    0.01303745f, -0.03844497f, -0.04603714f, -0.09805003f, 0.03218808f, -0.03960448f, -0.13100971f, 0.04745832f, 
    -0.17111860f, -0.15199707f, -0.13661817f, 0.08734628f, 0.31826657f, 0.22816944f, 0.12341136f, 0.26372042f, 
    0.08359588f, 0.14408503f, 0.15928832f, 0.01909448f, -0.08951145f, 0.00895267f, -0.00680375f, -0.00458712f, 
    -0.11129320f, 0.18487351f, -0.06289478f, 0.03856494f, -0.55382735f, 0.34582275f, 0.13783959f, 0.01923377f, 
    0.50311095f, -0.05831423f, -0.05659484f, 0.05655640f, -0.06266025f, -0.08942761f, -0.13523547f, 0.15777472f, 
    -0.08671285f, 0.03190680f, -0.00563708f, -0.01168403f, 0.05044793f, 0.22742142f, -0.03430087f, -0.13204730f, 
    0.00450046f, 0.30579835f, 0.18367577f, -0.17255589f, -0.51413405f, -0.03916236f, 0.12842780f, -0.10594445f, 
    -0.00680362f, -0.03485772f, -0.08901589f, -0.08222002f, -0.15017317f, 0.07409044f, -0.13600856f, -0.13665205f, 
    -0.06191823f, -0.00098389f, -0.11513684f, -0.07290352f, 0.26637995f, -0.02101632f, -0.52622175f, 0.16893299f, 
    -0.04438800f, 0.10746723f, -0.04290814f, -0.01315902f, -0.27260062f, -0.02515208f, -0.25457862f, -0.26044714f, 
    0.12841885f, -0.19010107f, -0.02673557f, 0.04624621f, -0.00019280f, -0.22466941f, 0.05597014f, -0.07606035f, 
    -0.09563382f, -0.34046793f, 0.14049523f, 0.40192980f, 0.59481287f, -0.09252559f, 0.02991103f, -0.10548215f, 
    0.03365440f, -0.05443937f, 0.00981540f, 0.07027669f, -0.05133504f, -0.07759110f, -0.06861661f, -0.12815996f, 
    0.11632880f, -0.02136150f, 0.07301936f, 0.03177071f, -0.07940123f, -0.05883286f, 0.58475083f, -0.30061719f, 
    0.40466106f, -0.32408512f, 0.20622562f, 0.00870918f, 0.01631847f, -0.10126697f, 0.19085082f, -0.02980820f, 
    0.03587019f, -0.11879049f, 0.06013205f, -0.12914225f, -0.20877269f, -0.04429368f, -0.13870895f, -0.04195209f, 
    -0.82011861f, 1.18663371f, -0.04816340f, -0.28720161f, 0.26684374f, 0.48405659f, 0.18921521f, 0.03010595f, 
    -0.05594461f, 0.04549860f, -0.33697328f, -0.09439950f, -0.02942020f, 0.02219995f, 0.11705431f, -0.05537696f, 
    0.04119737f, -0.08997494f, 0.15048386f, 0.01551675f, -0.50928104f, -0.15569279f, -0.28932524f, 0.30177721f, 
    -0.24621418f, 0.12114865f, 0.02517628f, 0.08324919f, 0.05478457f, 0.00011191f, 0.06858172f, 0.03378692f, 
    0.10040107f, -0.08737059f, -0.15807772f, -0.28637138f, -0.07991024f, -0.02931735f, -0.07735030f, 0.00350692f, 
    -0.03623375f, 0.07821077f, -0.13861953f, -0.11734296f, 0.26131663f, 0.08773538f, 0.07253207f, -0.04916426f, 
    -0.04535906f, 0.02961424f, -0.06829972f, 0.11999455f, -0.01292980f, 0.09495716f, 0.10159992f, -0.07503735f, 
    -0.02801231f, 0.15880889f, -0.03192005f, 0.02576453f, -0.11352806f, -0.17578660f, -0.24634992f, 0.11500829f, 
    0.21930084f, -0.11458390f, 0.05277438f, -0.02081622f, 0.08258080f, 0.05200558f, 0.00435251f, -0.03681071f, 
    -0.03533199f, -0.12210738f, 0.03984749f, -0.03592936f, -0.05237627f, -0.08321383f, -0.03936378f, 0.00786086f, 
    -0.27299479f, -0.29205370f, 0.22536659f, 0.01459432f, 0.41880837f, -0.25934774f, 0.06797334f, 0.06075810f, 
    0.12777650f, 0.10816793f, 0.15142222f, 0.10479011f, -0.00604944f, 0.01042229f, 0.13908641f, -0.06974653f, 
    0.05902070f, -0.01557587f, -0.01554428f, 0.02737959f, 0.04922439f, -0.18240261f, -0.08713273f, -0.30131042f, 
    -0.20701490f, 0.17614058f, 0.00619494f, 0.16899195f, 0.10922644f, 0.10368736f, 0.06391782f, -0.09012806f, 
    0.22117831f, -0.14531915f, -0.20464519f, 0.02725298f, 0.11467160f, -0.04210667f, 0.12393405f, 0.10193724f, 
    -0.48444471f, 0.31135643f, 0.21277027f, 0.26046982f, 0.24288824f, 0.07188576f, -0.04708663f, -0.06729624f, 
    0.12466181f, -0.09578257f, -0.13788435f, -0.16324307f, 0.03755429f, 0.01486205f, -0.05780322f, 0.05093655f, 
    0.04139089f, 0.04572638f, 0.05551009f, -0.15686873f, 0.06493612f, -0.16491848f, -0.19378670f, -0.13368461f, 
    0.19151539f, 0.07458465f, 0.04673313f, -0.04999175f, -0.00764564f, 0.04742475f, 0.01244337f, -0.01629057f, 
    -0.14562359f, 0.08885523f, -0.09683421f, -0.10200238f, -0.00977449f, 0.07042606f, 0.01267719f, 0.03549466f, 
    0.06361277f, -0.11439973f, -0.20640585f, -0.13176279f, 0.20796256f, 0.06640096f, 0.08699337f, 0.01011339f, 
    0.07521421f, -0.03153599f, 0.03067661f, -0.01308789f, 0.19140399f, 0.07713903f, 0.01796703f, 0.02849017f, 
    -0.09999752f, 0.01748680f, 0.03637885f, 0.05336324f, -0.16173336f, 0.28112608f, -0.07013851f, 0.00323008f, 
    -0.46851528f, -0.07517586f, -0.02999484f, 0.00765879f, -0.09583931f, -0.07379472f, 0.00015006f, 0.10456950f, 
    0.06310482f, -0.29660413f, -0.17710058f, -0.05091970f, -0.06306150f, -0.00484582f, 0.25726479f, 0.08598387f, 
    -0.13786052f, -0.04085881f, -0.32330158f, -0.14371563f, 0.37078649f, 0.13324611f, 0.04284185f, -0.06585509f, 
    -0.05247240f, -0.13583741f, -0.03733414f, 0.14999101f, -0.00055220f, 0.04565901f, 0.07590225f, -0.09010100f, 
    -0.00710385f, 0.17843546f, 0.04398670f, -0.13946582f, -1.10637450f, -0.40637392f, -0.24539845f, 0.15859090f, 
    -0.22085439f, -0.05046999f, -0.01851630f, 0.08959681f, 0.22345489f, 0.00275094f, 0.10325652f, 0.09970652f, 
    0.16347598f, -0.06262932f, 0.01062216f, -0.01624712f, -0.01280699f, -0.10721067f, -0.03254939f, -0.03778943f, 
    0.02028688f, 0.07861448f, -0.30141535f, -0.08442475f, -0.53737229f, 0.33038193f, -0.06269965f, 0.18950082f, 
    -0.08337207f, -0.02242114f, -0.50026596f, -0.29260966f, -0.10583229f, -0.06605496f, -0.04334908f, 0.00025623f, 
    0.21141505f, -0.20858586f, -0.00898807f, 0.09174559f, 0.10907722f, 0.36682588f, 0.27834678f, -0.22323275f, 
    -0.38491234f, -0.29427841f, -0.06979777f, 0.10681885f, 0.03048945f, 0.10498063f, 0.10577302f, -0.03006168f, 
    0.07311455f, 0.12305447f, -0.00583473f, -0.02965827f, -0.09653027f, 0.13811579f, -0.02985917f, 0.16508667f, 
    -0.26167661f, -0.03202822f, 0.15211838f, -0.10254605f, -0.42635763f, 0.01338693f, -0.08089430f, 0.05954057f, 
    -0.08232976f, -0.03679606f, -0.10037006f, -0.03291883f, 0.15387605f, 0.04150756f, -0.23498626f, -0.11359178f, 
    -0.00189764f, -0.14382458f, 0.02289717f, -0.14908206f, 0.25059962f, -0.23417069f, -0.28451973f, 0.21750250f, 
    0.28555354f, -0.12228990f, 0.09579711f, 0.02091400f, -0.01179737f, 0.07137939f, -0.00978614f, -0.02179063f, 
    -0.07892241f, -0.01499300f, -0.12956345f, -0.00397241f, -0.01003914f, 0.12170950f, 0.16844061f, -0.22505346f, 
    0.17912309f, 0.48333326f, -0.21783254f, -0.25195101f, 0.42940235f, -0.00456133f, 0.05931680f, -0.14823776f, 
    0.07543354f, -0.12821548f, -0.03008153f, 0.06224531f, -0.37293482f, -0.07471385f, 0.01946165f, 0.04918704f, 
    -0.14771268f, 0.08570725f, -0.24142386f, 0.05788942f, -0.15905371f, -0.12553705f, -0.07787646f, -0.47252339f, 
    -0.39403486f, 0.00956831f, 0.09370059f, -0.12041182f, -0.01096991f, -0.10612860f, -0.08330718f, 0.06370546f, 
    -0.20347154f, -0.06244551f, 0.00735677f, 0.06077726f, 0.07832073f, 0.03250752f, -0.27204946f, -0.19383749f, 
    0.22156240f, -0.14688514f, 0.12205098f, -0.37108073f, -0.30279320f, -0.30605552f, -0.03881888f, -0.17537497f, 
    -0.06048351f, -0.24555233f, 0.13367417f, 0.02333016f, 0.21878052f, -0.20559458f, -0.11772347f, 0.17283286f, 
    0.17593497f, -0.01149750f, -0.17775021f, -0.36536023f, -1.40481627f, 0.52894354f, -0.41162717f, 0.17377289f, 
    -0.16962130f, 0.26063299f, -0.21987930f, 0.04632678f, -0.14276806f, -0.07191259f, -0.02362693f, -0.14899074f, 
    0.06595072f, -0.17500347f, -0.14446737f, 0.04078583f, 0.13068841f, 0.11133812f, -0.03727200f, -0.30829597f, 
    -0.11380966f, 0.16238074f, -0.17357178f, 0.00242314f, 0.28296238f, 0.29889908f, 0.03731991f, 0.02009920f, 
    -0.17154287f, -0.07509541f, -0.17496087f, 0.04602559f, 0.07215977f, 0.06274697f, 0.07707997f, -0.00077101f, 
    -0.11567172f, -0.07699492f, -0.02867261f, 0.03018455f, 0.48037115f, 0.11531533f, 0.52128154f, -0.44097093f, 
    0.24603799f, -0.32654169f, 0.09303152f, -0.14728306f, -0.05169314f, 0.00174609f, 0.06800292f, 0.01085976f, 
    0.04919723f, -0.04081487f, -0.04257211f, 0.02035599f, -0.11684008f, -0.03042359f, 0.04983312f, -0.08646096f, 
    0.18996871f, -0.07120092f, -0.20779242f, -0.20357990f, 0.16009076f, 0.13105559f, 0.05896899f, 0.07290585f, 
    0.01864705f, -0.00716187f, 0.02935019f, -0.07054882f, -0.00111856f, 0.04146030f, 0.02904117f, -0.03407817f, 
    0.02388065f, -0.04633069f, -0.03484478f, -0.01378785f, -0.24948584f, -0.15490842f, -0.03524036f, 0.01866379f, 
    -0.09394859f, -0.02281895f, -0.09499837f, -0.13851820f, -0.05016066f, -0.03770319f, -0.01034394f, 0.07958248f, 
    -0.06513042f, -0.00596258f, 0.07200633f, -0.00438043f, 0.08820948f, 0.06479110f, -0.03930301f, -0.18967253f, 
    0.72259855f, 0.68681645f, 0.38236350f, -0.88722789f, 0.24553390f, -0.28305584f, -0.08763873f, -0.04249704f, 
    -0.23999470f, 0.05948680f, -0.12749210f, -0.08813553f, 0.11003913f, 0.12344375f, 0.11006117f, -0.08085144f, 
    0.01134599f, -0.12865584f, 0.19568904f, 0.05329626f, -0.08896675f, -0.05510320f, -0.17621171f, -0.07762172f, 
    0.16721287f, 0.03822225f, 0.07148766f, 0.03766598f, -0.04692354f, 0.11111472f, -0.14854403f, 0.03198295f, 
    0.00939176f, -0.10197389f, 0.00380587f, 0.04569249f, 0.02150796f, 0.04552147f, -0.19924977f, -0.04618823f, 
    0.02273215f, 0.11174285f, 0.24085175f, -0.03410026f, 0.10900103f, -0.15451348f, -0.13293931f, 0.04601489f, 
    -0.11329064f, 0.30669874f, 0.01382539f, 0.06002097f, 0.07212960f, -0.09209267f, -0.06560194f, 0.05734674f, 
    -0.08792171f, -0.12683089f, -0.16720411f, -0.44981009f, -0.12057643f, -0.56465840f, 0.19184844f, -0.38510203f, 
    -0.05561681f, -0.23066333f, 0.00302266f, -0.02260929f, -0.12774774f, -0.51287055f, 0.00932529f, -0.15390825f, 
    0.00462359f, 0.09833492f, -0.07733040f, -0.07642712f, -0.03700513f, -0.11420881f, -0.05534505f, -0.17081103f, 
    0.27364373f, -0.25271305f, -0.19758682f, -0.17349294f, -0.25975329f, 0.01261835f, -0.07234835f, -0.00534953f, 
    0.01514357f, -0.01927778f, -0.09066568f, -0.01981119f, -0.00268575f, -0.17975189f, 0.00810095f, -0.05489361f, 
    -0.04877834f, 0.08569498f, -0.08255238f, -0.08758420f, -0.00970624f, 0.02368087f, 0.02326655f, 0.06631281f, 
    0.00287933f, 0.02766405f, -0.06270726f, 0.11318534f, -0.03545016f, -0.04375805f, 0.19780084f, -0.18146542f, 
    0.14463717f, -0.05094680f, 0.00114480f, 0.10659920f, -0.01586331f, -0.01248250f, -0.23484722f, -0.06576058f, 
    -0.32429832f, 0.14794834f, -0.20968397f, -0.26767319f, -0.01661586f, -0.03857080f, -0.03249677f, 0.01096748f, 
    0.00400473f, -0.02279409f, -0.01310297f, 0.02305655f, 0.05918484f, 0.04227799f, -0.05423453f, 0.10155218f, 
    0.16613251f, 0.10142629f, 0.07811974f, 0.37191555f, 0.12944330f, -0.10580436f, -0.24327327f, 0.18345250f, 
    0.03204747f, 0.06073749f, -0.01855403f, 0.07570676f, -0.02625977f, -0.00223195f, 0.00301596f, 0.02161857f, 
    0.03763475f, 0.04060432f, 0.01519890f, -0.01632420f, 0.08395384f, -0.01996270f, -0.06970399f, 0.00271289f, 
    -0.23514956f, -0.45923448f, 0.20723467f, -0.03767350f, -0.08708764f, -0.26374584f, -0.25701788f, 0.01400009f, 
    -0.14206596f, 0.15543257f, -0.20566773f, 0.13883767f, -0.11440856f, -0.11342759f, -0.19710189f, 0.01116589f, 
    0.05054031f, 0.05216878f, -0.06865546f, 0.06911352f, -0.02678590f, 0.05845797f, -0.00874904f, -0.03518823f, 
    -0.08776369f, 0.10219861f, 0.06823669f, -0.01277952f, 0.10368855f, 0.06626048f, 0.10327042f, 0.04396464f, 
    0.01669843f, 0.04644427f, 0.00606833f, 0.09629518f, -0.00710322f, -0.10334865f, -0.04426054f, 0.17872049f, 
    -0.13928145f, -0.21284825f, 0.07352869f, 0.14574119f, 0.08111966f, -0.16159737f, 0.05190744f, 0.11075143f, 
    -0.24870083f, -0.16217385f, -0.03747461f, -0.01105007f, 0.01870597f, -0.02397745f, -0.00046228f, 0.03401624f, 
    0.09462791f, 0.00642897f, 0.10572152f, 0.09714740f, 0.13694502f, 0.08756012f, 0.34674597f, 0.13739261f, 
    0.09489518f, -0.11155182f, 0.09472401f, -0.07519933f, 0.15005745f, 0.26161072f, 0.02573070f, -0.03808505f, 
    -0.00305209f, 0.07914784f, -0.00483375f, 0.06544740f, 0.08863840f, -0.22078300f, 0.05146479f, -0.02240100f, 
    0.06530421f, 0.06676637f, 0.15272117f, 0.33318990f, 0.39225486f, 0.01585539f, 0.07152314f, -0.06449238f, 
    0.11623166f, 0.18549548f, 0.05400945f, 0.00073139f, -0.04168944f, -0.07521957f, 0.00050980f, -0.17011198f, 
    -0.03383892f, -0.02712049f, 0.12042461f, -0.07714412f, 0.00044002f, 0.07454924f, -0.03466108f, 0.04901251f, 
    -0.02914555f, 0.05483055f, 0.07272523f, -0.06197284f, -0.08464575f, 0.08112470f, 0.07448310f, 0.05987428f, 
    -0.19868861f, 0.03949930f, 0.09560141f, 0.03075571f, -0.09972665f, -0.05726566f, -0.16275844f, -0.19182718f, 
    -0.00935176f, -0.02815244f, -0.08385331f, -0.07681320f, -0.06358064f, 0.15805075f, 0.08891781f, 0.23355338f, 
    -0.13440678f, 0.03448603f, -0.06419365f, 0.07746536f, 0.10106979f, -0.10799162f, -0.05389186f, -0.04492102f, 
    -0.06716752f, -0.06553829f, -0.09320387f, -0.07379241f, 0.13262849f, 0.25314069f, 0.26877674f, 0.22621052f, 
    0.22405626f, -0.17279740f, -0.00072838f, 0.05545083f, 0.04278882f, 0.12962382f, 0.04751153f, 0.02716540f, 
    -0.02039660f, -0.00945335f, 0.02134791f, -0.04371761f, -0.03938801f, -0.11036626f, -0.03409259f, -0.23817015f, 
    -0.02945263f, 0.01215310f, 0.15183307f, 0.25278988f, 0.16096166f, -0.12287837f, 0.00008587f, -0.10036696f, 
    -0.16797508f, 0.05608977f, -0.00555274f, 0.07917899f, -0.05446555f, 0.05590256f, -0.06737895f, -0.02407675f, 
    -0.01685590f, -0.05207931f, 0.02410130f, 0.05079292f, 0.03508843f, -0.09649377f, -0.03708751f, -0.10440840f, 
    -0.07571513f, 0.00201374f, 0.06677596f, 0.03600188f, -0.06372607f, 0.01782041f, -0.00022079f, -0.16538739f, 
    -0.18634623f, -0.08701192f, -0.09076217f, -0.03224503f, 0.02403356f, -0.08501153f, -0.10700070f, -0.13891365f, 
    0.27170464f, 0.00141368f, 0.15991601f, 0.17588213f, 0.01334297f, -0.21960869f, -0.12839794f, -0.16733241f, 
    -0.05844367f, -0.09441393f, 0.08244586f, -0.05279459f, 0.02190377f, 0.01893003f, 0.02232625f, 0.02355531f, 
    0.01745278f, -0.05119216f, -0.06189045f, -0.10632288f, -0.01632808f, -0.01153863f, 0.00662395f, 0.15111496f, 
    0.07938031f, 0.09694894f, 0.08049609f, 0.06415993f, 0.11747445f, 0.10704758f, 0.10276904f, 0.07578666f, 
    0.06846613f, 0.00938362f, 0.06900033f, 0.00633638f, 0.06925517f, 0.02148293f, -0.14724480f, 0.20490052f, 
    0.08366908f, 0.05560649f, -0.11634011f, -0.04363606f, -0.03071304f, 0.08610921f, -0.00813460f, 0.01678609f, 
    0.10538170f, 0.08540601f, 0.01184864f, -0.22878791f, -0.00995683f, -0.24826571f, 0.06127068f, 0.08124206f, 
    -0.03794709f, -0.00061795f, -0.09682567f, 0.00363535f, 0.08492129f, -0.63793218f, -0.29584011f, 0.35406652f, 
    0.11491285f, 0.08727983f, 0.00838502f, 0.09457984f, -0.01485236f, 0.10562837f, 0.03283160f, 0.03491933f, 
    -0.06263410f, -0.05776802f, 0.02466783f, 0.11102255f, 0.03658963f, 0.09582721f, -0.06798300f, -0.04447626f, 
    0.01050129f, 0.00483354f, -0.08802704f, -0.05343767f, -0.07575276f, 0.11163605f, 0.06204519f, 0.04763310f, 
    0.05144671f, 0.05599854f, 0.03285574f, 0.15836281f, -0.08025712f, -0.02568862f, 0.01777144f, 0.21158719f, 
    0.01284715f, -0.08474431f, -0.00623472f, 0.09416577f, -0.22497471f, 0.05295499f, 0.22734833f, -0.00571329f, 
    0.09039404f, -0.06228541f, 0.14146191f, -0.35106406f, 0.18846150f, -0.01655584f, -0.10527926f, -0.00451507f, 
    0.05378576f, -0.00605516f, -0.06652229f, -0.08417986f, 0.11758627f, 0.13823080f, -0.12039355f, 0.06033396f, 
    -0.09299127f, 0.00844196f, 0.08677381f, 0.34447637f, 0.01902321f, -0.07145818f, -0.09416850f, 0.17911415f, 
    -0.17860806f, -0.03605109f, -0.22304447f, -0.13290304f, 0.12108772f, -0.02039106f, -0.00010509f, 0.00407562f, 
    -0.14379041f, -0.18791422f, -0.12923987f, -0.25218779f, -0.05996299f, -0.28116119f, -0.07092242f, -0.08319499f, 
    -0.14175756f, -0.02785312f, -0.10855748f, 0.01518880f, 0.02874129f, -0.02178775f, -0.11882240f, 0.00854750f, 
    0.07555892f, -0.05944955f, -0.00981777f, 0.01989113f, -0.12989621f, -0.09321420f, 0.02971822f, 0.24305227f, 
    -0.19653739f, -0.01498946f, -0.17845233f, -0.00960243f, -0.16190311f, -0.09743226f, 0.09049656f, -0.04762219f, 
    -0.00032216f, 0.02582531f, -0.07382722f, -0.16017213f, -0.08017530f, -0.03910430f, 0.07872937f, -0.14945157f, 
    -0.25500467f, -0.02317827f, 0.01106067f, 0.00706660f, 0.09135558f, -0.28566787f, 0.03168981f, -0.17823678f, 
    -0.11627571f, 0.11357037f, -0.04235241f, 0.02216934f, 0.04743352f, -0.05817217f, -0.07801083f, -0.08476119f, 
    -0.13132136f, 0.01937813f, 0.06201845f, -0.11808895f, -0.09183086f, -0.07375921f, -0.07940125f, -0.17791875f, 
    0.18197338f, -0.15125699f, 0.29151350f, 0.07920692f, 0.07695296f, -0.18558139f, -0.05319738f, -0.12435713f, 
    -0.01914568f, 0.08217142f, 0.15355691f, -0.07004776f, 0.04745501f, -0.01570011f, 0.08905286f, 0.05200568f, 
    0.00529263f, 0.09163111f, -0.03055600f, -0.05946027f, 0.16016501f, -0.26769075f, -0.52139693f, 0.31015778f, 
    -0.32954362f, -0.06640535f, 0.03017359f, -0.00435680f, -0.00312362f, -0.02746707f, 0.04261440f, -0.09709520f, 
    -0.04746030f, 0.05636844f, -0.00125821f, -0.10999689f, 0.07806162f, 0.07942801f, -0.08348874f, 0.09380667f, 
    0.13347007f, 0.28192866f, 0.28778893f, 0.28423363f, 0.22810027f, -0.10455339f, -0.03017435f, -0.00857651f, 
    -0.09410650f, 0.07418203f, 0.06600365f, -0.04118160f, 0.05875160f, -0.06736254f, 0.02807070f, -0.09789951f, 
    -0.03315305f, -0.00283014f, -0.19029304f, -0.13273019f, 0.00204786f, -0.03784022f, -0.05454733f, -0.01680454f, 
    0.10917608f, 0.02895307f, 0.12737708f, 0.02139436f, -0.03286790f, 0.00930278f, 0.06715994f, 0.05278823f, 
    0.04948908f, -0.06200967f, 0.06708711f, -0.11766508f, -0.00627345f, -0.11017556f, -0.05637360f, 0.05740663f, 
    0.48197171f, -0.63607651f, -0.60419744f, 0.70004040f, 0.01491164f, 0.19555403f, -0.03364156f, 0.05601960f, 
    -0.04403818f, -0.00216946f, 0.14710049f, -0.11605768f, -0.04629010f, -0.02192247f, 0.03283367f, -0.12245297f, 
    -0.08927101f, -0.00171364f, -0.33529383f, -0.02102510f, -0.10714070f, -0.05091462f, 0.17583065f, 0.17529689f, 
    0.14263876f, -0.09015893f, 0.18318945f, -0.01157406f, -0.00318363f, 0.00599632f, 0.03328758f, -0.01753934f, 
    -0.01559882f, 0.02673918f, 0.06914466f, 0.09883836f, 0.13789213f, -0.13302951f, 0.04832820f, 0.22878474f, 
    0.24854903f, 0.04377622f, 0.11976349f, -0.19159110f, -0.02300877f, -0.14716476f, 0.12153957f, 0.08270457f, 
    -0.09739091f, -0.06389730f, -0.15024444f, -0.03817389f, 0.02207825f, -0.06754527f, -0.01015955f, 0.02013843f, 
    0.09738149f, -0.05013127f, 0.01152618f, 0.08331148f, -0.08728632f, -0.48423269f, 0.16160899f, -0.25645405f, 
    -0.25801253f, 0.26280716f, -0.09018850f, -0.10823617f, 0.09475202f, 0.11684936f, 0.05480460f, 0.02096878f, 
    0.06590716f, -0.20592308f, -0.10873658f, -0.01997208f, -0.12492103f, 0.05074669f, 0.14801873f, -0.01956753f, 
    -0.04900653f, 0.07027669f, -0.29350045f, 0.09137508f, 0.00426036f, -0.08223601f, -0.02466169f, -0.18548556f, 
    -0.01503016f, 0.04053680f, 0.21809225f, -0.00264775f, 0.02906086f, 0.04795101f, -0.13794063f, 0.06705655f, 
    -0.25223601f, -0.03447309f, 0.21816817f, 0.26822123f, -0.30522585f, 0.53599459f, -0.19426414f, -0.18058796f, 
    0.06658477f, 0.04528099f, -0.08047270f, 0.04448584f, -0.04184814f, -0.05615303f, 0.17996268f, 0.07060561f, 
    0.10833555f, -0.15883169f, 0.01335039f, -0.00188107f, 0.00263345f, 0.17344418f, 0.05687292f, -0.03903688f, 
    0.46802384f, 0.02989688f, 0.02843986f, -0.26743647f, 0.27655098f, -0.01119369f, 0.19432458f, -0.13012776f, 
    -0.01161728f, -0.00468338f, 0.09788998f, 0.06465799f, 0.06369466f, -0.07946110f, 0.02722483f, -0.16693531f, 
    -0.09412345f, -0.33260539f, -0.08667148f, -0.26189968f, -0.55307460f, 0.17017519f, -0.10354714f, -0.24196321f, 
    0.03457121f, 0.06551687f, -0.14414221f, -0.14397055f, 0.12437348f, 0.08541838f, 0.05428006f, 0.05634830f, 
    -0.05230441f, -0.01195758f, -0.05318673f, 0.12385765f, -0.10195346f, -0.03701810f, -0.03891413f, 0.09080447f, 
    -0.44771865f, 0.14698210f, -0.49211034f, -0.40626183f, -0.16956398f, -0.02385839f, -0.05006826f, 0.06115506f, 
    -0.10024232f, -0.16109188f, 0.05958901f, 0.03218000f, -0.20890376f, 0.19629893f, 0.18894820f, -0.17548676f, 
    -0.12822610f, 0.02662203f, 0.04759216f, -0.04140019f, -0.24798550f, -0.17466857f, -0.03093330f, 0.00540359f, 
    0.07921425f, 0.12247095f, 0.00849152f, -0.07107598f, -0.04785003f, -0.01913998f, 0.04958687f, -0.01190467f, 
    -0.05602628f, 0.05191194f, 0.02480934f, -0.11297639f, 0.10987063f, 0.11285245f, -0.08895360f, -0.01835998f, 
    -0.20314515f, -0.08291788f, 0.20746550f, -0.12398286f, -0.22006468f, 0.06267673f, -0.09724695f, -0.05261112f, 
    -0.08002207f, -0.09106760f, -0.00441077f, -0.03491882f, -0.05238914f, 0.01191549f, 0.02072479f, -0.00440428f, 
    0.00624804f, -0.07196574f, -0.04719106f, -0.02950964f, 0.10455719f, -0.10249617f, 0.22553429f, 0.13216215f, 
    -0.18453474f, -0.03970572f, 0.11579805f, 0.03219182f, -0.06612761f, -0.13699205f, 0.06151836f, 0.01289606f, 
    0.00118418f, 0.08680033f, 0.01828085f, -0.00506217f, -0.00164790f, -0.06038151f, -0.03907873f, 0.04903033f, 
    0.12742543f, 0.13587934f, -0.36223772f, -0.00118262f, 0.02417654f, -0.15641023f, 0.16513695f, 0.05370739f, 
    -0.07245596f, -0.02167133f, 0.02337569f, 0.00717934f, -0.03096389f, -0.06390288f, 0.01388614f, 0.02727249f, 
    0.02197632f, 0.41160086f, -0.17406197f, -0.10563298f, -0.04277040f, -0.04140167f, 0.00760535f, -0.03276796f, 
    0.07307576f, 0.18637010f, -0.22096160f, -0.04387497f, 0.02740297f, -0.16047461f, -0.09184080f, 0.01553657f, 
    -0.03985671f, -0.03345346f, 0.03233923f, 0.10012910f, 0.12391075f, 0.09234443f, -0.00085853f, 0.27160010f, 
    0.31970221f, 0.15316908f, -0.03521937f, -0.19451922f, 0.34222552f, -0.02898219f, -0.08993339f, 0.11204515f, 
    -0.11906607f, -0.11716425f, -0.03662814f, -0.11625091f, -0.07147590f, -0.07136041f, -0.08035456f, 0.09466122f, 
    -0.04801254f, 0.06184476f, -0.08551645f, -0.16653934f, 0.02715307f, 0.04476972f, 0.37263232f, -0.08638782f, 
    -0.04302712f, 0.12559234f, 0.03120687f, 0.11826788f, 0.04936988f, -0.11508124f, -0.00346047f, -0.03999963f, 
    0.02739649f, 0.04320874f, 0.04996818f, 0.03929054f, 0.07054678f, -0.04884844f, 0.02152348f, 0.28966829f, 
    -0.19381139f, -0.03016562f, 0.13495305f, 0.15373610f, -0.20473737f, -0.00510739f, 0.08358295f, 0.21703030f, 
    0.01066488f, -0.20221740f, 0.00403778f, -0.05491060f, 0.01623682f, 0.04107560f, -0.00378846f, -0.11223154f, 
    -0.00360899f, -0.02419498f, 0.10517235f, -0.17669967f, 0.26963848f, -0.08658768f, -0.23381132f, -0.15066333f, 
    0.12159741f, 0.13953070f, -0.19356751f, -0.30713814f, -0.21181233f, 0.20847256f, -0.04457199f, 0.23255147f, 
    0.05820764f, 0.29541084f, 0.09087158f, 0.12422252f, 0.19445805f, -0.02810199f, -0.09053858f, 0.37702906f, 
    -0.22887374f, -0.02052170f, 0.01853498f, -0.15464459f, -0.17181398f, -0.01750687f, 0.03278600f, -0.00489465f, 
    -0.05285985f, 0.27436844f, 0.08282653f, 0.02911231f, -0.11410239f, -0.00947987f, -0.07976390f, -0.04014345f, 
    -0.08562708f, 0.02668706f, 0.08550250f, 0.13904656f, -0.04054287f, -0.21616611f, -0.11994468f, 0.17545168f, 
    -0.05177168f, 0.11415407f, 0.09256109f, -0.01387903f, 0.00855949f, -0.04680999f, 0.02741047f, -0.02254318f, 
    -0.06053790f, 0.01203291f, 0.02172835f, -0.29918867f, -0.07961802f, 0.21182726f, -0.07429089f, -0.14746575f, 
    0.00200161f, -0.11167055f, -0.46208912f, 0.02739341f, 0.09030362f, 0.07491694f, -0.04408396f, -0.17232873f, 
    0.01674443f, -0.02819379f, 0.08885019f, -0.02683855f, 0.03465010f, 0.27882147f, 0.00615274f, 0.00201083f, 
    0.09560390f, 0.20372908f, 0.02735122f, -0.07127032f, -0.34648129f, -0.01114380f, 0.22348540f, 0.19940430f, 
    0.00874193f, -0.01822135f, -0.11234751f, -0.07804142f, 0.05786156f, -0.04966936f, 0.03232181f, 0.07960373f, 
    0.07265288f, 0.04795466f, -0.00307418f, 0.07483330f, -0.25054723f, -0.00488727f, 0.28032640f, 0.03178389f, 
    -0.11077425f, -0.08719326f, -0.14471480f, 0.02998770f, 0.17989977f, 0.09673336f, 0.00976964f, -0.10725808f, 
    -0.03701558f, 0.08147011f, 0.19267833f, -0.01881947f, -0.03068978f, 0.07097887f, 0.16512735f, -0.19133765f, 
    0.25301108f, 0.07487721f, 0.17369901f, -0.09335773f, 0.50722468f, 0.37183982f, -0.01841805f, -0.00326737f, 
    0.03799300f, 0.05843186f, -0.16183271f, 0.15050003f, -0.06646352f, 0.19640671f, 0.06635018f, -0.05119864f, 
    0.06984577f, 0.03177010f, 0.00568630f, 0.22509752f, -0.06143963f, -0.02906901f, -0.02733700f, -0.17689370f, 
    0.17849617f, -0.74396020f, 0.61579162f, 0.05619889f, -0.66560888f, -0.08454379f, 0.15183012f, -0.11932164f, 
    -0.11331972f, 0.04460222f, 0.14788367f, -0.01512679f, -0.11513555f, -0.07202577f, 0.24279532f, -0.01653056f, 
    0.05254454f, -0.00316623f, 0.11461084f, 0.17468347f, 0.46856266f, -0.23776153f, -0.17511772f, 0.22412618f, 
    -0.00086785f, 0.10630529f, -0.18413925f, -0.06617051f, -0.16069105f, 0.17933217f, -0.05688463f, -0.08583380f, 
    0.19611339f, -0.01140765f, 0.15425086f, -0.04765775f, -0.06979900f, 0.03080181f, 0.04771885f, 0.05117990f, 
    0.19630899f, -0.21154468f, 0.00933873f, 0.09848925f, 0.10170851f, 0.16390818f, 0.04928033f, -0.08303425f, 
    -0.12608387f, 0.22561419f, 0.02003181f, -0.05003584f, -0.00683034f, 0.19180751f, 0.14202641f, -0.01891399f, 
    -0.07631196f, 0.01758321f, -0.01068936f, 0.09585990f, 0.04130093f, -0.10322196f, -0.24308097f, -0.30964887f, 
    0.12776886f, -0.03133712f, -0.08526549f, -0.06238491f, -0.16255969f, 0.19895896f, 0.02740664f, 0.12481183f, 
    -0.03355119f, -0.05805787f, 0.08867469f, 0.18078643f, -0.16044737f, 0.14645307f, 0.08673266f, 0.24736470f, 
    -0.65063351f, 0.07812955f, -0.30422786f, -0.39661020f, -0.17924078f, 0.03932571f, -0.02340142f, -0.00267957f, 
    -0.01475231f, 0.22530070f, -0.00402829f, 0.04018012f, -0.10463683f, -0.02554148f, -0.16468817f, -0.03321796f, 
    -0.00375368f, 0.04723904f, -0.04607653f, 0.07504755f, -0.35407498f, -0.03197644f, 0.28262484f, 0.27926090f, 
    -0.47760281f, 0.14248194f, -0.08854909f, -0.07288254f, 0.07026365f, 0.18396792f, -0.06848639f, 0.05165922f, 
    -0.05744516f, -0.01148100f, -0.04470441f, 0.04169145f, -0.10706312f, -0.04723373f, -0.15350820f, -0.08569383f, 
    -0.05163297f, 0.16446002f, 0.26965106f, 0.26643974f, -0.14799629f, 0.03358268f, -0.00061635f, 0.26474893f, 
    -0.05390410f, -0.02382674f, -0.08965254f, 0.00295097f, -0.07481443f, -0.00990506f, -0.06113024f, 0.02697971f, 
    0.02958464f, 0.09160741f, -0.11886946f, 0.12154585f, -0.07861382f, -0.09023757f, -0.17645313f, 0.12484242f, 
    0.00858097f, 0.11176693f, -0.14621276f, -0.04918150f, -0.09540743f, 0.10700978f, -0.08511264f, 0.01331057f, 
    -0.01120795f, -0.11251682f, 0.09260564f, 0.08980559f, -0.04192961f, 0.17370054f, -0.16708316f, -0.02135950f, 
    -1.18622100f, 0.30431339f, 0.09947728f, 0.47431764f, -0.31036413f, 0.10014958f, -0.16355570f, -0.08920576f, 
    0.24389504f, 0.00546883f, -0.10213537f, 0.08802961f, -0.12119429f, 0.01407378f, -0.14606422f, 0.03549651f, 
    -0.20618173f, 0.13070342f, -0.04642723f, -0.08477377f, -0.03116365f, -0.05139894f, 0.33063167f, 0.04115589f, 
    -0.23716040f, 0.06276967f, -0.13144672f, 0.04812434f, 0.04410466f, -0.02109402f, 0.06286245f, 0.00897610f, 
    -0.04628569f, 0.06551414f, -0.02362317f, 0.07039079f, 0.07142087f, -0.33536720f, -0.21637696f, -0.32381138f, 
    0.09440235f, -0.16712146f, -0.39466196f, -0.11498553f, 0.04898085f, -0.11648267f, 0.13442494f, -0.09990820f, 
    0.00141329f, -0.44565731f, 0.08166120f, 0.03964595f, -0.10322964f, -0.04288844f, 0.04860413f, -0.03711693f, 
    -0.02715181f, 0.15154383f, -0.10996782f, -0.19696917f, -0.37263983f, 0.99949825f, -0.37516287f, -0.25781849f, 
    0.32600427f, -0.07072290f, 0.03877548f, 0.13970922f, 0.25295588f, 0.06063441f, 0.11247600f, 0.00637753f, 
    0.17861257f, -0.07603077f, -0.08030800f, 0.07922529f, 0.07812030f, 0.10691319f, 0.07924978f, -0.01232632f, 
    0.03000731f, 0.03381465f, 0.11175916f, -0.08758784f, 0.02066962f, 0.06756081f, -0.00881094f, 0.00931348f, 
    -0.02037885f, 0.10697278f, 0.11692413f, 0.14661336f, -0.06366439f, 0.04340205f, -0.04028241f, -0.05245047f, 
    -0.00885997f, 0.01588568f, -0.06668853f, 0.06644505f, -0.27334821f, -0.08403493f, 0.37993488f, 0.08927187f, 
    -0.09428672f, -0.02471322f, -0.12943399f, 0.03228277f, 0.03379842f, 0.01786213f, 0.07125838f, 0.07033548f, 
    -0.09352075f, 0.02388971f, 0.14066854f, 0.03751645f, -0.02244304f, -0.01862534f, -0.09586890f, -0.06479663f, 
    -0.01512155f, -0.17624867f, 0.02099437f, -0.60559267f, -0.48285311f, -0.00574709f, 0.05047982f, 0.07180055f, 
    0.17360634f, -0.21071897f, 0.02272275f, -0.03128831f, 0.05227074f, 0.00062129f, 0.05354835f, 0.24025002f, 
    0.02593570f, 0.10836314f, 0.08753290f, 0.06351604f, -0.02519631f, -0.18788339f, -0.08160323f, 0.03157323f, 
    0.06073361f, 0.02707365f, 0.14230052f, -0.08895103f, -0.05990877f, 0.07956401f, -0.04115554f, -0.07021596f, 
    -0.01258707f, -0.11091585f, -0.03957878f, 0.03130633f, -0.07862297f, -0.04985208f, 0.03145214f, -0.02044275f, 
    -0.36290574f, 0.20661733f, 0.46857116f, -0.07990777f, 0.23959947f, -0.01538555f, -0.08368069f, -0.15960227f, 
    -0.04840127f, 0.33714214f, -0.10932732f, 0.07027856f, 0.15960540f, 0.01970804f, -0.10235533f, 0.00028852f, 
    0.06407928f, -0.08239311f, 0.05075322f, 0.06139761f, 0.07957822f, 0.15414122f, -0.09390765f, 0.05597972f, 
    -0.03879944f, -0.01066398f, -0.04919074f, -0.06045096f, -0.04637419f, -0.01450951f, -0.06344504f, -0.07657428f, 
    0.00220902f, -0.17313179f, -0.10415348f, -0.12839282f, -0.17099580f, -0.16726163f, -0.02932153f, 0.12062582f, 
    -0.26090553f, -0.62235904f, -0.50254810f, 0.00730021f, 0.06793208f, -0.02115009f, -0.13609868f, -0.00806185f, 
    -0.17771128f, -0.01661781f, -0.08306879f, -0.02943945f, -0.00634477f, -0.02688239f, -0.12507224f, -0.07289357f, 
    -0.06762981f, 0.03165546f, 0.16009623f, -0.03039259f, -0.74292201f, -0.64828527f, -0.93307585f, -0.08508554f, 
    -0.17132588f, -0.02027845f, 0.21039642f, -0.13576835f, -0.10947199f, -0.47064844f, 0.06194875f, -0.02108124f, 
    -0.05801491f, -0.11740770f, -0.01010513f, 0.05103795f, -0.01718596f, 0.07042535f, 0.12070989f, 0.12140452f, 
    0.34068894f, -0.64183760f, -0.67036849f, -0.19357097f, 0.15489805f, -0.09953059f, 0.20038225f, 0.47608769f, 
    0.18574767f, -0.32224590f, 0.01705791f, -0.00789491f, -0.08840613f, 0.03571203f, 0.08428729f, 0.04539700f, 
    0.03561337f, 0.14825603f, 0.17281450f, 0.02530814f, -0.00942686f, -0.03349281f, 0.11563009f, 0.01637809f, 
    0.10505689f, -0.07921047f, -0.08752170f, -0.06799830f, -0.05942291f, -0.00775695f, 0.11175308f, 0.04086065f, 
    -0.18245800f, -0.04455992f, 0.08468481f, 0.00346300f, -0.08152687f, -0.00324313f, -0.05060082f, -0.13947247f, 
    0.20650357f, -0.04905358f, 0.02389998f, 0.14626738f, 0.01574295f, 0.08776288f, 0.02487734f, 0.12422326f, 
    0.09597612f, -0.16501983f, 0.04920615f, 0.04776302f, -0.09414645f, -0.02150140f, 0.03436500f, -0.01128939f, 
    -0.09614681f, 0.20617983f, -0.13202271f, -0.03809332f, -0.67995346f, -0.57452172f, -0.32254672f, -0.27570507f, 
    -0.18129745f, -0.12810750f, -0.04936225f, -0.13064034f, 0.04910133f, -0.23350261f, -0.00389574f, -0.01612549f, 
    -0.03248744f, 0.05166886f, 0.04079408f, -0.00476189f, 0.00490222f, 0.09643503f, 0.13559276f, 0.09883440f, 
    -0.58234978f, -0.54921639f, -0.72339392f, 0.13327636f, -0.05365595f, -0.25548613f, -0.04551197f, -0.01684121f, 
    -0.04194325f, -0.24005586f, -0.05726891f, 0.02526783f, 0.05216521f, -0.06456520f, 0.02115687f, 0.00364620f, 
    -0.01223854f, 0.00908376f, 0.08223454f, -0.10321134f, 0.11698378f, 0.24213767f, -0.12469297f, 0.01655252f, 
    0.10241750f, -0.04410521f, -0.10167636f, -0.04448593f, 0.05574547f, 0.13351262f, 0.28338942f, -0.00809647f, 
    0.05665435f, -0.10756849f, 0.08916062f, 0.10287984f, -0.05600023f, -0.08895060f, -0.03287960f, -0.11318532f, 
    -0.62091696f, 0.54085696f, 0.34812087f, -0.06757806f, 0.15070705f, -0.13464902f, -0.17345853f, -0.09547013f, 
    0.12310354f, 0.12982614f, -0.07700740f, 0.07846412f, 0.01441603f, 0.15188868f, 0.08320682f, -0.00625323f, 
    0.05092916f, -0.03075603f, -0.01880240f, 0.00405451f, -0.05462005f, 0.06164924f, -0.04839597f, -0.34055993f, 
    -0.18407208f, -0.03010843f, 0.00492574f, 0.05737189f, -0.10025457f, -0.06171584f, -0.01797619f, -0.06394005f, 
    -0.07305109f, -0.04544154f, -0.12303333f, -0.07692881f, -0.06514125f, -0.27598327f, 0.01299133f, 0.13926435f, 
    -0.05623683f, 0.00094813f, 0.16418301f, 0.03559743f, 0.04005310f, -0.03395152f, -0.04651266f, -0.02701768f, 
    -0.07887990f, 0.04626463f, -0.02793415f, 0.10953248f, 0.15961322f, 0.08815885f, 0.05841929f, 0.00982803f, 
    -0.02742264f, -0.09603068f, -0.05733982f, -0.01475952f, -0.22031206f, -0.22447053f, -0.15037653f, -0.00529586f, 
    -0.10216692f, 0.03895414f, 0.13727300f, 0.07974179f, -0.05299426f, 0.07300168f, -0.08253253f, -0.04250142f, 
    -0.01444415f, -0.01953008f, 0.01370570f, 0.09154999f, 0.10240077f, 0.01345386f, -0.06710314f, 0.07298478f, 
    0.08347587f, 0.05410553f, -0.13041905f, 0.03789353f, -0.18934050f, 0.03813732f, 0.06585880f, -0.06594147f, 
    -0.14860696f, 0.05120674f, 0.01624030f, -0.24702702f, -0.04446997f, -0.26085240f, -0.27016228f, 0.14034072f, 
    -0.07054559f, -0.09342533f, -0.00914032f, 0.03509261f, -0.98493510f, -0.91844624f, -0.46930203f, 0.09056234f, 
    -0.01732504f, -0.12774406f, 0.23939350f, -0.19711486f, 0.22690411f, -0.34687033f, -0.00320957f, -0.00453542f, 
    -0.00903160f, 0.08005253f, 0.04724054f, -0.13997473f, -0.03984233f, 0.13717498f, 0.07922711f, 0.02651160f, 
    -0.73732573f, -0.88730311f, -0.80697960f, 0.31443805f, 0.23426472f, 0.01096202f, 0.27597722f, -0.12804507f, 
    -0.26272449f, -0.02103877f, 0.00108021f, -0.07612137f, 0.03265421f, -0.00220779f, 0.03266284f, 0.03928061f, 
    0.05576396f, -0.01278360f, 0.28286192f, 0.01040203f, 0.06446967f, 0.27287656f, -0.00181266f, 0.16406663f, 
    0.04155578f, 0.05307517f, 0.08343050f, -0.07935173f, 0.02223753f, 0.19533147f, -0.16176161f, 0.02816129f, 
    0.19747639f, -0.03284592f, -0.02444704f, -0.13608027f, 0.12892038f, -0.24220718f, 0.05377198f, -0.01501828f, 
    0.08321283f, 0.21217324f, -0.02571177f, 0.14838080f, 0.13921586f, -0.09258778f, 0.06880548f, -0.02033389f, 
    0.08175211f, 0.07153890f, -0.15174776f, 0.00858829f, -0.02039227f, 0.01322518f, 0.00787481f, -0.11467943f, 
    0.03390691f, -0.18026553f, 0.05583802f, 0.02637533f, -0.02047477f, 0.20401798f, 0.03515825f, 0.00203640f, 
    0.08976159f, 0.02771939f, -0.04191747f, 0.01976926f, 0.13508283f, 0.07273640f, 0.17356820f, -0.06185326f, 
    0.02722536f, -0.00905293f, 0.07599966f, 0.16491063f, 0.01441690f, -0.04738320f, -0.15742652f, 0.05189660f, 
    -0.64430290f, 0.39759871f, 0.53712922f, 0.08480545f, 0.22098474f, -0.06922030f, -0.16983530f, -0.07434057f, 
    -0.20445716f, 0.19185784f, -0.15138224f, 0.14714967f, 0.02398459f, 0.10794073f, 0.10432594f, 0.04633779f, 
    0.00417768f, -0.02907113f, -0.02882757f, 0.00255216f, -0.15503959f, 0.05073894f, -0.42366475f, 0.04071830f, 
    0.26096848f, -0.05610355f, 0.23358978f, -0.02511286f, -0.06468699f, 0.04115110f, -0.04727492f, 0.02576754f, 
    0.04486813f, 0.09399506f, 0.02623786f, -0.00799601f, -0.16998056f, -0.18535046f, 0.18710376f, -0.06374902f, 
    -0.89973634f, -0.37131804f, -0.10692713f, -0.06177638f, 0.26403832f, -0.17382774f, 0.03749073f, -0.11060436f, 
    0.00151889f, -0.08656733f, 0.01172145f, 0.04667829f, 0.01791780f, -0.02628150f, 0.00538099f, 0.00531845f, 
    -0.00213259f, 0.11924773f, 0.13219455f, -0.12118185f, 0.22242549f, -0.05274270f, -0.17444618f, -0.12773080f, 
    0.09558072f, -0.02295649f, 0.07099160f, 0.06860141f, 0.02282795f, 0.01249122f, -0.01781674f, -0.00531513f, 
    -0.06363355f, -0.17823143f, 0.01607525f, -0.08922376f, -0.02153002f, -0.11370494f, 0.06131626f, -0.01212414f, 
    -0.43659651f, -0.29016814f, -0.20113695f, -0.18163744f, 0.40766171f, -0.08496683f, 0.21786726f, 0.07686570f, 
    -0.19592220f, 0.12891050f, 0.03283573f, -0.00873972f, -0.00931131f, -0.02892049f, 0.00415648f, -0.05699386f, 
    0.04625265f, -0.12481881f, 0.21282658f, -0.05708104f, -0.22032338f, -0.32888162f, -0.72697103f, -0.15362053f, 
    0.01703891f, -0.23070328f, -0.16793382f, -0.04726103f, -0.13774233f, -0.27558705f, -0.00501032f, -0.04649780f, 
    -0.02576985f, -0.00631451f, 0.08362176f, -0.11274186f, -0.06083768f, 0.19131610f, 0.19854084f, 0.03672913f, 
    -0.49639767f, -0.32928652f, 0.18016115f, 0.24137758f, -0.05566898f, 0.12738085f, 0.07960381f, 0.05521172f, 
    0.03224313f, 0.26704851f, 0.01372801f, -0.08988044f, 0.11437906f, -0.01113881f, -0.02447363f, 0.05362328f, 
    -0.01549312f, -0.09963679f, 0.03694037f, 0.11537495f, -0.46660495f, -0.62343842f, -0.17406398f, -0.30684304f, 
    0.20409130f, 0.11766626f, -0.06197041f, 0.30203310f, -0.34414449f, 0.17014968f, -0.15358020f, 0.05392313f, 
    0.19582543f, 0.08319547f, -0.10699118f, 0.03368703f, -0.05988353f, 0.13675138f, -0.02669080f, -0.02727346f, 
    0.15718749f, 0.08530966f, 0.02193221f, -0.09690843f, -0.10288482f, -0.05999799f, 0.00593752f, 0.05754410f, 
    0.00942301f, -0.13248312f, -0.26032600f, -0.04211899f, 0.04276310f, -0.06795099f, -0.15261918f, -0.12823126f, 
    -0.04991266f, 0.04902206f, -0.09191090f, -0.08037443f, 0.37073731f, 0.14565822f, -0.08222711f, -0.08464772f, 
    -0.11497854f, 0.06780046f, 0.04573423f, -0.02320326f, -0.08998644f, -0.00328436f, -0.05340337f, -0.21611905f, 
    0.19386604f, 0.03401263f, 0.01273214f, -0.00520408f, -0.02497060f, 0.08529615f, -0.02814981f, -0.06400389f, 
    -0.85247350f, 0.24119587f, 0.33518520f, 0.02764830f, 0.40574738f, 0.00086808f, 0.05005747f, 0.20412834f, 
    -0.17729965f, 0.04492406f, 0.04317640f, 0.00665380f, 0.08906373f, 0.05387117f, 0.01636111f, 0.25650293f, 
    0.03197000f, 0.10680418f, -0.07263826f, -0.04839735f, 0.00468876f, 0.07459818f, 0.07516119f, -0.01351352f, 
    -0.12257423f, -0.02990890f, -0.00315794f, -0.10858349f, 0.02365750f, -0.11034855f, 0.00670259f, 0.01553581f, 
    0.05934631f, -0.00962885f, -0.05231331f, -0.41902417f, 0.07037960f, 0.07687967f, 0.08018609f, 0.01465134f, 
    0.55478042f, -0.40381283f, -0.46840364f, -0.35554874f, 0.01265147f, 0.14363255f, -0.01931757f, -0.10288642f, 
    0.17241187f, 0.09067030f, -0.00720041f, 0.10715192f, -0.03530400f, -0.13780262f, 0.05764153f, 0.00721678f, 
    0.08961207f, -0.08346021f, 0.09458437f, 0.10726048f, 0.01008748f, 0.01629297f, 0.07366491f, 0.03214529f, 
    -0.16969095f, -0.03948396f, 0.09742109f, -0.00969854f, 0.02769082f, -0.05086627f, 0.11035875f, 0.06552180f, 
    0.03072418f, -0.03348173f, 0.01289211f, -0.06515215f, -0.09443510f, 0.07914098f, 0.08378161f, -0.00380332f, 
    0.36202270f, -0.51604730f, 0.16728146f, -0.47817841f, -0.14620192f, -0.03192412f, 0.01851132f, -0.25130051f, 
    0.27399737f, 0.05285637f, -0.00397074f, 0.01556074f, -0.07959738f, -0.08060273f, -0.00701236f, -0.01538241f, 
    -0.05285428f, -0.11324964f, 0.11509477f, -0.04250943f, -0.92786413f, -0.70698881f, -0.46144739f, 0.44823584f, 
    0.15537411f, -0.02598753f, 0.02281654f, 0.08953845f, 0.11944961f, 0.14811179f, 0.03693271f, -0.00264327f, 
    -0.07025579f, -0.16458309f, -0.03966353f, -0.08656674f, 0.06331894f, -0.05862123f, 0.18016300f, -0.21264088f, 
    -0.45368400f, 0.01767635f, -0.00230993f, 0.05968470f, -0.25833458f, 0.04375179f, -0.10162856f, -0.24372314f, 
    0.11248153f, 0.12293029f, 0.04889350f, 0.01075658f, 0.07827611f, 0.00897329f, -0.01147466f, 0.05710391f, 
    -0.00971177f, -0.15280393f, 0.00482014f, 0.12356679f, 0.01686834f, 0.04337449f, -0.02053894f, 0.01250502f, 
    -0.10051411f, 0.00957162f, 0.01226384f, 0.14029072f, 0.02109705f, -0.04295702f, -0.09918661f, -0.19219503f, 
    0.05569947f, 0.04418585f, 0.02413015f, 0.02788555f, -0.01091950f, -0.03910869f, 0.02118579f, 0.01778071f, 
    -0.12228576f, 0.04250645f, 0.10368356f, -0.00482828f, -0.01725006f, -0.08598859f, 0.04228985f, -0.05748858f, 
    0.04065582f, 0.04328580f, 0.08130503f, -0.01928931f, 0.05979523f, -0.02085083f, -0.03620740f, -0.03020570f, 
    -0.04333580f, -0.03659367f, -0.05456815f, 0.04038313f, 0.04365465f, -0.46685818f, 0.29775375f, 0.09396331f, 
    -0.09592851f, -0.12465356f, 0.10369106f, -0.02014952f, 0.10187835f, 0.04964541f, -0.03562864f, -0.04212003f, 
    0.00376997f, -0.05890528f, -0.02253352f, -0.00135181f, -0.00694207f, -0.12981720f, 0.05898295f, 0.05626294f, 
    0.43797055f, -0.46291125f, -0.39723998f, -0.18693271f, -0.12636970f, -0.02255991f, -0.04521916f, -0.08768635f, 
    0.27943268f, 0.17251796f, 0.00714981f, 0.01396318f, -0.10744225f, -0.08475277f, 0.05181895f, -0.06943378f, 
    0.06893810f, -0.13897184f, 0.12672593f, -0.13281576f, -0.06520965f, 0.14879993f, -0.11688214f, -0.05540633f, 
    -0.07982595f, 0.14881152f, -0.02249903f, 0.03255496f, -0.01259750f, -0.07235815f, -0.26798925f, 0.17688684f, 
    0.04143055f, 0.08212005f, -0.08908958f, 0.02074059f, -0.01801810f, 0.01369189f, -0.06905605f, 0.02640917f, 
    0.67756009f, -0.90719336f, -0.32837236f, -0.43880343f, -0.11333452f, -0.00337989f, -0.10753499f, -0.11533310f, 
    0.15038501f, -0.37958854f, 0.00454860f, -0.00099149f, 0.03341721f, 0.03265449f, 0.01836730f, -0.03642316f, 
    -0.01454346f, -0.01877707f, -0.00532409f, -0.02679778f, -0.06018350f, 0.05697656f, 0.00393464f, 0.04941774f, 
    -0.17110150f, 0.01665461f, 0.03812680f, 0.01888411f, 0.00503391f, 0.00671594f, 0.03040591f, 0.06199775f, 
    0.03412071f, 0.03789218f, -0.01165555f, 0.13471314f, 0.06324683f, -0.11715849f, 0.14568363f, 0.03579189f, 
    0.16399390f, 0.25610119f, 0.03794058f, -0.01138126f, -0.23845455f, 0.05215273f, 0.06944127f, 0.04211778f, 
    -0.08244549f, -0.10243010f, -0.29845515f, -0.19477715f, -0.33614239f, -0.15672825f, -0.30814022f, 0.02169817f, 
    0.00106841f, 0.08117058f, 0.02143346f, -0.01246324f, -0.06504285f, 0.06481312f, -0.01741029f, -0.13027805f, 
    -0.23642296f, 0.05598141f, 0.03330953f, -0.03936236f, 0.01808894f, -0.06017735f, 0.01069354f, 0.05285173f, 
    -0.00786562f, -0.00181292f, -0.03914728f, 0.06242376f, -0.01732784f, 0.03487223f, -0.11143318f, -0.05768098f, 
    0.01014503f, 0.05744146f, 0.10560165f, -0.11364996f, -0.11780027f, 0.02283693f, 0.05996216f, 0.01572894f, 
    0.00530288f, -0.02585397f, 0.04339040f, 0.00439331f, -0.01995077f, -0.11232494f, -0.00996931f, 0.00754431f, 
    -0.07449020f, 0.02018851f, 0.06315032f, -0.03090886f, -1.11112273f, -0.49140191f, 0.10868631f, 0.13206027f, 
    0.44736442f, 0.21746393f, -0.27966502f, 0.32860738f, -0.02793710f, 0.00431356f, 0.02114493f, -0.02642813f, 
    -0.01668350f, -0.02827495f, -0.06116091f, 0.01564386f, -0.00374221f, -0.01282898f, -0.10136912f, 0.06884747f, 
    0.22340162f, -0.63367283f, 0.45804068f, 0.67543417f, 0.11558440f, 0.14379281f, 0.17048056f, -0.03150947f, 
    0.08659562f, -0.22520550f, 0.08285554f, 0.04279310f, 0.11273843f, -0.08930364f, 0.01921971f, 0.02136615f, 
    0.01714819f, 0.06990214f, 0.01216742f, -0.07610840f, 0.14046575f, -0.02623275f, 0.01291467f, -0.04076738f, 
    -0.02494549f, 0.04411883f, 0.06365270f, -0.10679933f, -0.08320697f, -0.05653304f, 0.09475148f, -0.02769414f, 
    -0.01137748f, -0.06681950f, 0.06557396f, 0.05423885f, -0.04743259f, -0.00889540f, -0.04033924f, 0.01875145f, 
    0.08187414f, 0.02616005f, -0.06552876f, 0.03141169f, -0.03254727f, 0.01757766f, -0.01127514f, -0.03450587f, 
    -0.01363938f, -0.03291403f, -0.01944618f, -0.01595948f, -0.02437496f, -0.04137842f, -0.10085247f, -0.13960956f, 
    -0.09143162f, -0.04101979f, -0.03697088f, -0.09075811f, -0.04258653f, 0.00814094f, 0.08375926f, -0.05087703f, 
    0.04877478f, -0.03617733f, 0.02616035f, 0.04216295f, -0.12691377f, -0.08072870f, 0.12418236f, -0.10797399f, 
    -0.19061860f, -0.01930803f, -0.11385661f, -0.08047680f, -0.00179918f, -0.13593747f, 0.00825303f, -0.03918941f, 
    0.60239089f, -0.17967401f, -0.33580804f, -0.22186723f, -0.27086735f, -0.06100532f, -0.04314782f, -0.05047810f, 
    -0.00792712f, -0.05348811f, 0.04156798f, 0.03791250f, 0.12886298f, 0.05903650f, 0.05775876f, -0.04061692f, 
    -0.01029890f, 0.03267146f, 0.03578607f, 0.03045861f, -0.02799070f, 0.28157988f, -0.13741472f, 0.02993977f, 
    -0.35402662f, 0.03007495f, 0.13303266f, -0.24014236f, -0.05668085f, -0.01083978f, 0.00112118f, 0.03468840f, 
    0.03706703f, -0.01623475f, -0.04264283f, -0.11565657f, 0.00973250f, -0.05474708f, -0.10651845f, 0.00895054f, 
    0.24033342f, -0.49757075f, -0.63198781f, 0.26024258f, -0.25033501f, 0.05233536f, -0.05980368f, -0.03940490f, 
    -0.13584092f, 0.09304808f, -0.00966152f, 0.01199719f, 0.10813899f, 0.01038766f, 0.00331487f, 0.07088263f, 
    -0.04221987f, 0.00276014f, -0.25549400f, -0.11153536f, -0.00137435f, 0.04434834f, -0.05950085f, -0.04456728f, 
    -0.10776947f, 0.03275798f, 0.00243226f, 0.05243143f, -0.00582825f, 0.02249883f, 0.05869787f, 0.03626642f, 
    -0.02352470f, 0.00457459f, -0.01689620f, -0.08882996f, 0.03101289f, 0.05576383f, 0.01227631f, 0.01411527f, 
    0.26457226f, 0.38472503f, -0.65800375f, 0.06265722f, -0.78234869f, -0.02048383f, 0.13472086f, -0.10933607f, 
    -0.06635598f, -0.08955586f, -0.12951620f, 0.08890872f, 0.02935772f, -0.06474687f, -0.02127808f, -0.06593893f, 
    -0.07697277f, 0.24048106f, -0.18265013f, 0.06489202f, -0.59014803f, -0.33379194f, 0.25335094f, -0.00751671f, 
    0.12250572f, 0.09384173f, -0.01415114f, -0.08291538f, 0.20989005f, 0.14410754f, 0.01988267f, -0.03558088f, 
    -0.11410473f, -0.12396033f, -0.01754881f, 0.08897310f, 0.00358191f, 0.02210696f, 0.21175133f, -0.08393441f, 
    0.09734254f, -0.26162192f, -0.06910191f, 0.08181714f, -0.12515792f, -0.18584591f, -0.15987958f, -0.25566164f, 
    -0.02873109f, -0.14872661f, -0.00648930f, 0.12228622f, 0.07611533f, -0.01574157f, -0.02298649f, -0.07406223f, 
    0.13860229f, 0.23739570f, 0.27358583f, 0.27070248f, 0.36833966f, -0.85194325f, -0.33730564f, 0.14595068f, 
    0.43113676f, 0.17109112f, 0.06525152f, 0.19352436f, -0.05160577f, 0.26506114f, 0.18576410f, 0.08648773f, 
    0.06566098f, 0.23444666f, 0.00682473f, -0.10618378f, 0.07396595f, -0.09002471f, -0.00592956f, -0.09017376f, 
    0.02168311f, -0.06555109f, 0.04829596f, -0.02850047f, -0.16512494f, -0.00047640f, -0.04725152f, 0.02073536f, 
    0.09509469f, 0.00470050f, 0.09553216f, 0.02782118f, 0.00649986f, 0.10889384f, 0.10172014f, 0.02689569f, 
    0.13275386f, 0.01072027f, 0.02811784f, 0.06928218f, -0.07479987f, -0.16084607f, -0.13921225f, 0.00427618f, 
    -0.15252843f, -0.10247381f, 0.08081757f, 0.11976719f, 0.10493971f, 0.05095071f, 0.01411375f, 0.21818684f, 
    0.01014016f, 0.01954958f, 0.06482691f, -0.09393138f, 0.04951074f, 0.05771519f, 0.09666933f, 0.13430016f, 
    -0.78063720f, -0.52228320f, 0.31604561f, 0.26743981f, 0.25350943f, 0.04956299f, -0.06383204f, -0.05794251f, 
    -0.19522487f, -0.05835651f, 0.03311664f, -0.07227047f, 0.05496899f, -0.06172739f, -0.01805403f, -0.30733687f, 
    -0.21750122f, -0.16986899f, -0.22124143f, -0.15566674f, 0.17471276f, 0.13446836f, 0.00463933f, -0.15184829f, 
    -0.10255627f, -0.05320894f, -0.14665417f, 0.02014767f, 0.03919529f, -0.13757642f, -0.09604868f, 0.02615646f, 
    -0.03552934f, 0.00435618f, 0.08455850f, -0.06448507f, 0.05247618f, -0.02937048f, 0.02790459f, 0.02448891f, 
    -0.06643844f, -0.39034566f, -0.44438997f, 0.01835291f, 0.00005378f, -0.19028622f, -0.02944052f, 0.11199395f, 
    0.24061985f, 0.05900282f, 0.19145289f, -0.19712476f, 0.01964669f, -0.03141040f, 0.02335196f, -0.11842873f, 
    -0.05784940f, 0.07991973f, -0.02659273f, -0.11272738f, -0.28082180f, 0.19316784f, 0.08805055f, -0.09786578f, 
    -0.12759909f, -0.06586255f, -0.09130224f, -0.09379987f, 0.03353906f, -0.04387454f, -0.16980031f, -0.02361995f, 
    0.03710547f, -0.04187228f, -0.01502287f, 0.04643448f, 0.03350615f, -0.04566302f, 0.01915019f, 0.00466308f, 
    -0.05673456f, -0.00717462f, -0.69718772f, -0.37829742f, -0.03306847f, 0.09405774f, -0.17022881f, 0.20192091f, 
    -0.05347751f, -0.19933793f, 0.01415349f, -0.05350665f, -0.06141742f, 0.05759532f, 0.07465009f, 0.09569642f, 
    -0.02945569f, 0.06046197f, -0.06807899f, -0.17793831f, 0.33998758f, -0.42684707f, -0.35309574f, -0.28224242f, 
    0.22407484f, -0.08703713f, -0.16161472f, 0.13263610f, -0.23114130f, -0.31046313f, -0.05630421f, 0.01568377f, 
    -0.01230908f, 0.06685129f, 0.00346682f, 0.01432846f, -0.00920622f, 0.18556872f, -0.19769736f, -0.05788915f, 
    -0.49321720f, 0.11081289f, 0.20266843f, 0.20380081f, -0.31946141f, 0.21336080f, -0.10224877f, 0.04177483f, 
    -0.08425842f, -0.37409317f, -0.05068571f, 0.05677309f, -0.00934634f, -0.06527790f, -0.05149407f, -0.14124937f, 
    0.00435961f, 0.00573332f, -0.12102646f, -0.19617920f, -0.00036065f, -0.01685758f, -0.12657300f, 0.06478472f, 
    -0.03490241f, -0.13416022f, -0.05258569f, -0.05414763f, -0.03794942f, 0.02258464f, 0.05704675f, 0.05580354f, 
    0.06061117f, -0.09539896f, -0.00534533f, -0.01563666f, 0.15467784f, 0.16848257f, 0.17389998f, 0.20142505f, 
    -0.35990974f, -0.09511574f, 0.07764213f, 0.07822768f, -0.05025050f, -0.00309339f, -0.00982598f, -0.03565300f, 
    -0.01546371f, -0.01063404f, -0.06193847f, 0.09833865f, 0.08906873f, 0.05516874f, 0.00250486f, -0.05556950f, 
    0.13584654f, 0.01605882f, 0.17736845f, 0.10926528f, -0.03461589f, -0.27807859f, -0.28781626f, -0.13316666f, 
    -0.13488945f, 0.07545518f, -0.09929170f, 0.15023534f, 0.07544781f, -0.03770603f, -0.04516309f, 0.01004853f, 
    0.00774260f, -0.00119168f, 0.06559297f, 0.05894849f, 0.11378473f, 0.05025485f, 0.08441794f, 0.09986303f, 
    -0.21026713f, -0.28663221f, -0.65516323f, -0.37027925f, -0.06906430f, 0.04229196f, 0.08663800f, 0.21048655f, 
    -0.09673556f, -0.20645653f, -0.04766092f, -0.05640548f, -0.07079531f, 0.14086355f, 0.07535604f, 0.04918447f, 
    0.03045214f, 0.09993742f, -0.05276395f, 0.07219836f, -0.14580427f, -0.16117387f, -0.12407521f, -0.13092642f, 
    0.28075704f, 0.07942662f, 0.18939948f, 0.01055003f, 0.10873333f, 0.01861362f, -0.08540636f, 0.06035125f, 
    -0.06891974f, 0.00225081f, 0.06802644f, 0.03382013f, -0.04453187f, 0.00928269f, 0.15384559f, -0.00020824f, 
    -0.08437226f, -0.58600670f, -0.65383750f, -0.02057809f, 0.20123856f, 0.13576284f, 0.08506714f, 0.19869398f, 
    0.15983573f, 0.19093506f, 0.01793127f, -0.10255773f, -0.15213840f, -0.01017542f, -0.12101120f, -0.00455008f, 
    -0.01084051f, 0.01222969f, -0.01709154f, 0.01733620f, -0.70518470f, 0.20069584f, 0.24709529f, -0.02371662f, 
    -0.28915602f, -0.06710049f, -0.10016852f, -0.11097471f, -0.03253001f, -0.08204246f, -0.17643125f, -0.08190684f, 
    -0.03105438f, -0.04782940f, -0.08091019f, 0.00361926f, -0.02288970f, -0.07504980f, -0.08491596f, -0.04474757f, 
    -0.20131539f, -0.11245813f, -0.07968814f, -0.16323999f, -0.24927939f, -0.10549892f, 0.11846322f, 0.03423363f, 
    0.01405575f, -0.05119097f, 0.13167252f, 0.12974954f, 0.15652385f, 0.11147185f, 0.10174786f, -0.01363547f, 
    0.08265363f, -0.05854526f, 0.16347277f, 0.01905222f, -0.13956685f, 0.24617714f, 0.17956290f, 0.05600583f, 
    -0.21858537f, 0.10288876f, -0.03426109f, -0.19622834f, -0.06591005f, -0.04581280f, -0.02082599f, -0.00774973f, 
    -0.11722992f, -0.08721721f, -0.03294357f, -0.18603654f, -0.04821428f, -0.20393999f, -0.27932763f, -0.26082239f, 
    -0.20471466f, 0.02495099f, 0.08295225f, -0.04225563f, -0.16873486f, -0.08223783f, -0.09213150f, -0.06113642f, 
    0.05514433f, -0.04973475f, -0.10178157f, -0.00559115f, -0.08778050f, 0.05673608f, 0.04586518f, 0.02435418f, 
    0.04767925f, 0.00372720f, -0.01129253f, 0.04032242f, -0.05355558f, -0.86180133f, -0.22690906f, -0.22112361f, 
    0.56351548f, 0.01796342f, 0.19978942f, 0.08976856f, 0.00816202f, -0.06926603f, -0.01063650f, -0.00441195f, 
    0.04452043f, 0.00896808f, 0.14090902f, 0.07618608f, 0.05992540f, -0.10220402f, -0.07386573f, -0.21580943f, 
    0.68515682f, 0.09728297f, -0.27868971f, -0.56063819f, -0.17275782f, 0.25370008f, -0.10994152f, -0.09156143f, 
    0.14029436f, 0.01034404f, 0.01520027f, 0.10410716f, 0.16731676f, 0.02542073f, 0.07559726f, 0.01939585f, 
    0.10038156f, -0.00642162f, 0.28143635f, -0.07563314f, 0.12224921f, 0.10437316f, -0.13476735f, -0.00181081f, 
    -0.04227284f, 0.00951455f, -0.02243441f, 0.01479712f, 0.04132280f, -0.12453733f, 0.10563597f, 0.01388229f, 
    0.07970004f, 0.00004190f, 0.03942322f, -0.05978825f, -0.03227523f, -0.02818414f, 0.04505798f, -0.02019248f, 
    0.02842808f, 0.08059409f, -0.08428583f, -0.03945483f, -0.03282158f, 0.09120270f, 0.00520222f, 0.04409312f, 
    -0.00188269f, -0.02265536f, -0.07426896f, 0.04495125f, 0.04680642f, -0.01180191f, 0.07846461f, 0.08488061f, 
    -0.01013585f, 0.07357535f, 0.04631257f, 0.04106112f, -0.13183944f, -0.07693245f, 0.02865957f, 0.06007934f, 
    0.07085902f, 0.01289024f, 0.05551062f, -0.05945492f, -0.05212462f, 0.01378828f, 0.01816352f, 0.08803899f, 
    -0.03768975f, 0.17866920f, 0.14861627f, 0.06832416f, 0.02025355f, 0.09693050f, -0.11547009f, 0.09106514f, 
    -0.18808839f, -0.44667238f, -0.56159794f, -0.13821566f, 0.01887754f, -0.14189650f, 0.07928113f, 0.13259891f, 
    0.12523195f, 0.13862583f, 0.11919155f, -0.07630972f, -0.00694026f, -0.09166907f, -0.09529367f, -0.00711643f, 
    0.02632720f, 0.02380827f, 0.02301754f, -0.00496742f, 0.55608982f, 0.24519083f, 0.07604282f, 0.02315888f, 
    -0.00881444f, 0.06007681f, -0.26738924f, 0.00899163f, -0.03617315f, -0.14241163f, -0.03879792f, -0.03228166f, 
    0.10249935f, -0.03058464f, 0.05941752f, 0.07447407f, -0.05700900f, -0.17093390f, 0.08074249f, -0.04145985f, 
    0.30364382f, -0.26126015f, -0.39486161f, -0.20236723f, 0.06466070f, 0.04867616f, 0.08988023f, 0.04576954f, 
    0.14266077f, -0.00976962f, 0.00818593f, 0.03614761f, -0.02076916f, -0.02348921f, 0.04603552f, 0.03605699f, 
    0.05118105f, 0.05883060f, 0.19051127f, 0.14712533f, -0.12712775f, 0.11577815f, 0.07212986f, 0.05436403f, 
    -0.10981645f, -0.01725264f, -0.02913180f, -0.05635851f, -0.04872909f, -0.09852784f, -0.04054197f, -0.00712593f, 
    0.04518566f, 0.06608231f, 0.05176023f, 0.02099212f, 0.12946135f, 0.13639396f, 0.15936621f, 0.06608818f, 
    0.91401458f, 0.21947053f, 0.17204849f, -0.23225814f, -0.30216563f, 0.05063391f, -0.00466177f, -0.07973725f, 
    0.01285952f, -0.30708358f, 0.04603080f, -0.01295259f, -0.01427542f, -0.00620284f, -0.01712002f, 0.04097950f, 
    -0.07433569f, -0.14434174f, -0.03425376f, -0.09186261f, 0.40012521f, -0.10273745f, -0.24785417f, -0.45532170f, 
    -0.19024034f, -0.22007529f, -0.39872149f, 0.04054686f, -0.21984728f, -0.42117763f, 0.02366195f, -0.00234362f, 
    -0.04638660f, 0.05244352f, 0.11871697f, 0.07698894f, 0.05077719f, 0.13624056f, -0.23411706f, -0.41673902f, 
    0.20863798f, 0.21178344f, 0.12078920f, -0.06644339f, -0.24278434f, -0.04387512f, -0.00146932f, 0.21092208f, 
    0.14601234f, 0.19735730f, -0.01978258f, -0.00943146f, -0.02624020f, -0.06236340f, -0.08199183f, -0.00487902f, 
    -0.06130069f, -0.10970831f, -0.08225736f, -0.31428140f, -0.47900492f, -0.76157850f, 0.55314720f, -0.14103548f, 
    -0.80923378f, 0.26353791f, -0.51760727f, 0.00358756f, -0.04189249f, -0.21660830f, -0.19729203f, 0.05613903f, 
    -0.09489103f, -0.02014952f, 0.14205416f, 0.07892115f, -0.04789088f, -0.05076989f, -0.05735839f, 0.05415354f, 
    -0.10788777f, 0.11873222f, 0.02768100f, 0.08898197f, 0.24045771f, 0.02136308f, -0.07786870f, -0.02990731f, 
    -0.02562167f, 0.00979123f, -0.02445365f, -0.12540552f, 0.06266156f, 0.11883134f, -0.05768830f, 0.15785877f, 
    0.02624226f, -0.00912207f, -0.13891636f, -0.04680743f, -0.11524788f, 0.10906786f, 0.22397867f, -0.15932092f, 
    0.14879555f, 0.02375299f, 0.08885112f, -0.20326230f, -0.29379958f, 0.00394074f, 0.08962545f, 0.05886006f, 
    0.06868154f, -0.00266235f, 0.10374517f, 0.08868798f, 0.02279427f, -0.06336194f, -0.08939598f, 0.01304749f, 
    0.17964584f, -0.63977128f, -0.71899337f, -0.26564619f, 0.14264937f, 0.04371801f, -0.19364978f, 0.27687514f, 
    0.03254068f, 0.16060929f, -0.04638870f, -0.00329135f, 0.02483695f, -0.13233195f, 0.03109205f, 0.15718825f, 
    0.25999513f, 0.15344854f, -0.14127551f, 0.12275829f, -0.13278750f, -0.21696545f, -0.48727182f, 0.23519313f, 
    0.00604590f, -0.18090726f, 0.23978178f, 0.18571888f, -0.19427893f, 0.07566996f, -0.01646312f, -0.01941935f, 
    -0.04070043f, -0.09068489f, -0.03539369f, 0.01287854f, 0.02991712f, -0.01643585f, -0.03622295f, -0.00162294f, 
    -0.23777775f, 0.07760173f, 0.14760165f, 0.76415551f, -0.26126015f, -0.15580480f, 0.08459666f, -0.50631064f, 
    0.14536390f, -0.37247595f, 0.10945124f, -0.17781688f, 0.13525012f, 0.03707727f, 0.03296570f, 0.13339022f, 
    0.07670922f, -0.03489124f, 0.03414952f, 0.11841979f, -0.20349985f, -0.16040784f, -0.37701789f, -0.17529941f, 
    0.28071150f, -0.13889615f, 0.16264319f, 0.16715199f, 0.04250060f, -0.07107924f, -0.00589603f, 0.06192642f, 
    -0.00544691f, -0.15020750f, -0.14360304f, -0.03232446f, 0.14281555f, 0.09444296f, 0.03149006f, 0.03013389f, 
    0.01273227f, 0.07645246f, -0.09884045f, 0.24664338f, -0.53858966f, -0.09915766f, 0.01717004f, 0.03882317f, 
    0.12166154f, 0.18577352f, 0.11164204f, -0.01670206f, 0.04949124f, 0.04331742f, 0.09005478f, -0.10787143f, 
    0.06908891f, 0.11082967f, 0.09416955f, -0.02551875f, 0.04169568f, -0.48345572f, 0.26161569f, -0.05587335f, 
    -0.09915644f, -0.07856493f, -0.43445104f, 0.07515702f, 0.15863076f, 0.37001193f, -0.03118401f, 0.07636026f, 
    0.04039896f, -0.07173954f, -0.08833497f, -0.03006089f, 0.05845654f, 0.07053203f, 0.09449580f, 0.05823592f, 
    -0.00153772f, 0.54350257f, -0.77262902f, 0.22269352f, -0.04412557f, 0.22759704f, 0.07224571f, 0.23519032f, 
    -0.07863639f, 0.29629421f, -0.01191629f, -0.02274783f, -0.13114586f, -0.04365319f, -0.02600702f, -0.01967361f, 
    0.01170380f, -0.02342046f, 0.02978833f, -0.04411262f, -0.00724100f, 0.10031144f, -0.03091816f, -0.09066543f, 
    0.06966596f, 0.07624380f, 0.11716523f, -0.00916144f, -0.00022923f, -0.13224228f, -0.06290697f, 0.02662676f, 
    -0.00827166f, -0.01557865f, -0.02547861f, 0.03324595f, -0.05090658f, -0.16018939f, -0.15482116f, -0.09434576f, 
    0.06738119f, 0.26642707f, 0.01279212f, -0.39338452f, 0.01170682f, -0.02207890f, 0.10516889f, 0.09448048f, 
    0.12314892f, 0.07808681f, 0.05655515f, 0.05000551f, -0.05125726f, 0.00690962f, -0.01630007f, 0.04325962f, 
    0.12909019f, -0.06473523f, 0.01119720f, -0.02466314f, -0.38836446f, -0.12716049f, -0.10525563f, 0.07039218f, 
    -0.15926571f, -0.25317580f, 0.02464515f, 0.17384449f, 0.05272818f, 0.18023521f, 0.03312021f, -0.03872788f, 
    0.02670528f, -0.07170592f, -0.06119893f, 0.02570189f, -0.01554635f, 0.07547298f, 0.11663252f, -0.29416576f, 
    -0.45884696f, -0.27219191f, 0.46226984f, 0.26321602f, -0.65719354f, 0.21956527f, -0.23146947f, 0.12331986f, 
    0.09038113f, 0.33740339f, 0.06519195f, -0.03249958f, 0.00605080f, -0.01514610f, -0.07450639f, 0.01990516f, 
    0.02895973f, 0.00665761f, 0.01315854f, 0.07132043f, 0.00558811f, 0.27131972f, 0.06072817f, -0.31031927f, 
    -0.09734230f, 0.16548054f, -0.35966054f, 0.06756634f, -0.06219725f, -0.21447074f, -0.02294905f, 0.18637933f, 
    -0.17527290f, -0.01175986f, 0.18068087f, -0.05321560f, -0.01975885f, -0.08409026f, 0.01257904f, 0.02823411f, 
    0.37198746f, 0.12260995f, 0.21947210f, 0.11442675f, -0.49175400f, -0.03030503f, -0.07052675f, -0.28309369f, 
    0.03804526f, 0.00613261f, 0.06434625f, -0.01956950f, 0.09301114f, 0.00100416f, 0.02765295f, 0.02376846f, 
    0.02088646f, 0.06225625f, -0.00614821f, -0.01838805f, -0.35373884f, -0.20242546f, -0.47606096f, -0.20287049f, 
    0.24902131f, 0.04768011f, 0.06095030f, 0.21344474f, 0.03277430f, 0.06450971f, -0.09768999f, -0.03438111f, 
    0.03341012f, -0.01503591f, -0.14213395f, 0.03809045f, 0.07721248f, -0.04034124f, 0.04665152f, 0.02680791f, 
    -0.21290866f, 0.28487545f, 0.00656473f, 0.00611635f, 0.26686186f, -0.01292992f, -0.11764604f, -0.16021250f, 
    -0.07730795f, -0.16687350f, 0.01003969f, 0.18449114f, -0.18210810f, -0.00388686f, -0.14968635f, 0.19248959f, 
    -0.03619694f, -0.10687654f, -0.02963018f, 0.08107825f, -0.15744300f, -0.14209767f, -0.35151443f, -0.17429376f, 
    0.07523683f, 0.09235852f, 0.03674631f, 0.08426283f, -0.00035955f, 0.08591531f, 0.08348773f, -0.10417636f, 
    0.00134280f, 0.00279221f, -0.10888356f, 0.07091948f, 0.05213531f, 0.09336172f, 0.09459654f, 0.06191552f, 
    -0.21625218f, -0.06993429f, -0.13445011f, -0.20717025f, 0.30010179f, -0.25861123f, 0.11246303f, -0.15444651f, 
    0.01805494f, -0.13663948f, -0.12129913f, 0.08488289f, 0.04934253f, -0.18232392f, 0.02657934f, 0.12378305f, 
    -0.07090731f, -0.03271855f, -0.00258473f, 0.07246137f, -0.20706657f, 0.43219915f, -0.25770211f, -0.54973710f, 
    -0.36143926f, -0.08331826f, -0.27731490f, -0.06099944f, -0.16702835f, 0.11093511f, -0.07556046f, 0.05130386f, 
    -0.01584945f, 0.11472455f, 0.13114509f, -0.10395163f, -0.01963502f, 0.12647389f, 0.03213711f, 0.17223516f, 
    -0.09538525f, -0.22482343f, -0.62998152f, -0.08799282f, -0.36653310f, -0.29497874f, 0.02696737f, -0.05672019f, 
    -0.11396394f, -0.02275674f, -0.06079569f, -0.05898131f, -0.08090149f, -0.10202516f, -0.14289235f, 0.14634949f, 
    -0.02084932f, -0.12315635f, 0.15471113f, -0.11414226f, 0.01469981f, -0.08159696f, -0.26862985f, 0.04133784f, 
    0.04501894f, -0.08054718f, 0.12620674f, 0.09135069f, 0.00528787f, -0.28504187f, 0.04219203f, 0.02635976f, 
    0.06262123f, -0.03461629f, 0.01175338f, 0.07435825f, 0.19617118f, -0.09699587f, -0.00428107f, 0.13179006f, 
    0.00930918f, 0.10645886f, -0.21967871f, 0.00262873f, -0.17070028f, 0.07682458f, -0.06983857f, 0.20066819f, 
    0.04348935f, -0.12455987f, 0.03375977f, 0.06033467f, -0.08934612f, -0.00644764f, 0.03540944f, -0.09255461f, 
    0.12197718f, 0.12990867f, 0.01962948f, -0.09039497f, 0.18399793f, -0.20914820f, 0.11835664f, -0.29044661f, 
    0.04958121f, -0.00566847f, 0.08255540f, 0.00288375f, -0.11285790f, -0.07032841f, 0.13577178f, 0.01300972f, 
    -0.03270185f, 0.12929355f, -0.04796956f, -0.03136909f, 0.12717880f, -0.02687704f, -0.07771458f, 0.00342689f, 
    0.18574731f, 0.17795411f, 0.24551596f, 0.27126685f, -0.23343150f, -0.00547681f, -0.11930023f, -0.39618495f, 
    -0.05777672f, -0.15643206f, 0.06077548f, 0.02322044f, 0.00602996f, 0.16868904f, 0.03679138f, 0.01426873f, 
    0.04507441f, 0.01866347f, -0.02115492f, -0.00771034f, -0.16525544f, 0.02374639f, -0.74686897f, 0.25746599f, 
    -0.28774866f, -0.00663658f, 0.07003985f, 0.17552184f, 0.02911608f, 0.09038060f, 0.03005870f, 0.01051243f, 
    -0.01411035f, 0.01958781f, -0.07863235f, -0.12802495f, 0.11229678f, 0.05552950f, 0.14351109f, 0.07904403f, 
    -0.48765397f, 0.16201526f, 0.03455194f, -0.06192015f, -0.33259818f, 0.14635536f, -0.27811238f, 0.10897552f, 
    0.06458547f, 0.14341301f, -0.00006002f, -0.07290196f, 0.06557929f, 0.00085571f, -0.08531986f, 0.04794966f, 
    -0.04341006f, 0.04700567f, -0.00534929f, -0.21490321f, -0.03294754f, 0.08731768f, -0.34340805f, 0.04177177f, 
    0.03050526f, 0.07519356f, 0.19672969f, 0.23645809f, 0.07092126f, -0.08246823f, 0.07322720f, -0.10232990f, 
    0.01498520f, -0.08216629f, -0.03706222f, 0.15767223f, 0.14871632f, -0.21698850f, -0.00157499f, -0.06640649f, 
    -0.74581224f, 0.18158939f, -0.96959537f, -0.02117991f, -0.13586339f, -0.02457306f, -0.10292570f, 0.06632685f, 
    -0.13406220f, 0.17457180f, 0.02612986f, -0.08165981f, -0.05655110f, -0.08411643f, -0.08282755f, 0.19266939f, 
    -0.06771804f, -0.01205877f, 0.10354750f, 0.01184777f, -0.07706695f, -0.35673189f, -0.07355028f, 0.27317971f, 
    -0.26803005f, -0.12876672f, -0.06148461f, 0.03800808f, 0.05382022f, 0.14084528f, 0.03125116f, 0.04244275f, 
    0.07489997f, 0.10377296f, -0.02371953f, -0.05814603f, 0.00780918f, 0.05467363f, 0.26291788f, 0.23283859f, 
    -0.59742993f, -0.25090215f, -0.07477805f, -0.14936993f, 0.01099073f, 0.02097647f, -0.07876657f, 0.09118532f, 
    0.05240739f, -0.06403641f, -0.13485649f, -0.09611773f, 0.12065267f, 0.03644151f, -0.05543716f, 0.10556186f, 
    0.10101064f, 0.08026040f, 0.12506570f, 0.32970542f, -1.01760089f, 0.20044693f, 0.04473225f, 0.20055649f, 
    0.08540878f, 0.03405026f, -0.02109110f, -0.25927088f, 0.23701316f, 0.11226609f, -0.06982200f, -0.05838305f, 
    -0.03936516f, -0.08462792f, 0.15249370f, 0.03314490f, -0.01800907f, -0.07008421f, -0.01971986f, -0.00253755f, 
    0.27544820f, -0.16879441f, 0.05068615f, 0.14424142f, -0.12147603f, 0.01541094f, 0.03638574f, 0.14064904f, 
    -0.02174309f, 0.14000013f, -0.10049506f, 0.08217617f, 0.00182549f, 0.02975632f, 0.03949381f, -0.08651569f, 
    0.07059763f, 0.14453208f, 0.13845401f, -0.11991699f, 0.42850515f, -0.23382153f, 0.38637677f, -0.07061920f, 
    -0.24835585f, -0.09893517f, 0.06961249f, 0.23949422f, 0.19012234f, 0.06861395f, -0.05536848f, 0.01979529f, 
    0.01997650f, -0.07080515f, -0.22155616f, -0.06429529f, 0.11908384f, 0.19999801f, 0.01616389f, 0.12169018f, 
    -0.16197146f, 0.04752060f, -0.23241161f, -0.08733483f, -0.09013002f, -0.06696545f, 0.04348595f, 0.03559430f, 
    -0.18691120f, -0.10125133f, 0.00369358f, 0.09362179f, -0.10118978f, 0.10658854f, -0.03031444f, -0.16255288f, 
    -0.20085774f, -0.24597351f, -0.54954892f, -0.10517346f, 0.06303618f, -0.34005079f, -0.32579860f, 0.12081720f, 
    0.04251215f, -0.21533492f, -0.14147542f, 0.14708091f, -0.33042553f, 0.02993029f, 0.01981367f, 0.14441600f, 
    -0.18619809f, 0.12601897f, 0.14253904f, -0.08116768f, -0.14802614f, 0.09602599f, -0.07003966f, 0.10403719f, 
    0.00877024f, 0.32305530f, 0.10149582f, 0.05441264f, 0.07101577f, 0.12700428f, -0.26086414f, 0.09569779f, 
    -0.07296849f, -0.07468393f, -0.29060230f, 0.14858671f, -0.18624592f, -0.09324727f, -0.09732036f, -0.08721249f, 
    -0.17431578f, -0.02393639f, -0.11885611f, -0.06350883f, 0.15316449f, -0.42239088f, -0.17878447f, -0.13767430f, 
    -0.21768136f, -0.10080507f, -0.17715697f, -0.14751862f, -0.13058695f, 0.01094702f, -0.04658303f, 0.02895274f, 
    -0.20688640f, 0.19026268f, 0.08739604f, 0.04417961f, -0.13413481f, 0.03123771f, 0.00272783f, 0.05339255f, 
    -0.22282122f, 0.14756225f, -0.57140917f, 0.03092095f, 0.10692626f, -0.07333481f, -0.12882110f, -0.05905621f, 
    -0.16237001f, 0.01098981f, -0.09548614f, 0.10649572f, 0.03911991f, -0.12650871f, 0.04280072f, 0.04491347f, 
    -0.05612223f, -0.20230904f, 0.01369655f, -0.14966020f, -0.22541554f, 0.00411756f, -0.84096885f, 0.14146277f, 
    0.04836467f, 0.12402721f, -0.14643683f, 0.09080307f, -0.10370039f, 0.05047729f, -0.02794923f, 0.09121779f, 
    -0.07368808f, 0.09394078f, -0.00057863f, 0.12745047f, -0.07591423f, -0.08593374f, -0.21980189f, -0.14549974f, 
    -0.10667767f, -0.36187616f, -0.11544713f, -0.03629296f, -0.15503480f, -0.11254236f, -0.16007785f, 0.21877888f, 
    -0.17667007f, -0.01383367f, -0.05314054f, 0.02758997f, -0.02260207f, -0.03527663f, 0.00616466f, 0.10285967f, 
    -0.15976250f, 0.00528467f, 0.01216894f, -0.01059218f, -0.17396390f, -0.23600414f, 0.18066852f, 0.09716225f, 
    -0.16445450f, -0.11275990f, 0.09324092f, -0.05038896f, -0.03971866f, -0.04036612f, 0.03619743f, 0.05166829f, 
    -0.01983649f, 0.13590780f, -0.03665869f, -0.00548974f, 0.21723102f, 0.14255013f, 0.15359861f, 0.20047140f, 
    -0.01757037f, -0.15317945f, 0.15996762f, 0.12229307f, -0.19004256f, -0.00013395f, 0.13142128f, 0.07289103f, 
    -0.02558515f, -0.10415517f, -0.00188425f, -0.14719228f, 0.06027832f, -0.01454988f, 0.06049520f, -0.01001032f, 
    0.06765198f, 0.21337542f, 0.13285732f, 0.17442335f, -0.21503957f, -0.02467234f, -0.09964948f, -0.18446870f, 
    0.17835219f, -0.07866610f, -0.00799362f, 0.19167104f, -0.08726080f, -0.03025731f, -0.02903206f, 0.09749946f, 
    0.08419169f, 0.00601796f, 0.03611615f, 0.13324235f, -0.06244208f, -0.05964556f, 0.08685795f, -0.00903046f, 
    -0.48929080f, 0.05515292f, -0.25022027f, -0.01906601f, 0.07010403f, -0.06421330f, -0.20208882f, -0.11073756f, 
    -0.04484714f, -0.00762016f, -0.07438532f, 0.03555923f, -0.01857719f, 0.02563653f, -0.01389418f, 0.02061859f, 
    -0.02006564f, 0.05087714f, -0.11991210f, -0.00757101f, 0.03677437f, -0.10679819f, 0.07374576f, 0.52316040f, 
    0.06491489f, -0.21011652f, -0.01784961f, -0.02322336f, -0.09554426f, -0.17546509f, 0.06302731f, -0.13808239f, 
    -0.00493625f, 0.26378283f, 0.27823651f, -0.10007263f, 0.11856610f, -0.00476312f, -0.04638100f, 0.30943757f, 
    -0.05912800f, 0.05383009f, 0.04538449f, 0.16497299f, 0.21885458f, 0.12278283f, 0.04942403f, 0.05397413f, 
    -0.07558972f, 0.10769537f, -0.13953607f, 0.05474409f, 0.04511711f, -0.10162362f, -0.11033686f, 0.13440926f, 
    0.06909000f, -0.15477329f, 0.07665262f, 0.12082165f, -0.01289793f, -0.41314086f, -0.34883714f, -0.40914130f, 
    -0.24730033f, -0.27147672f, -0.06496932f, -0.14817730f, 0.00178894f, -0.13772382f, -0.13935068f, -0.01722473f, 
    -0.14666717f, 0.05242657f, -0.01952935f, 0.12885496f, -0.07753646f, -0.09762260f, -0.04818318f, -0.16739653f, 
    0.46107465f, -0.48605663f, 0.43370301f, -0.24795914f, -0.26743525f, -0.00096072f, -0.02028180f, -0.25957683f, 
    0.05534644f, -0.03195531f, 0.13048044f, 0.06728431f, -0.05503384f, 0.08987104f, -0.10483664f, -0.03740208f, 
    -0.03669789f, 0.04309856f, 0.16357635f, -0.31170318f, 0.01008948f, -0.06120021f, 0.41957054f, 0.14094017f, 
    0.18433861f, -0.12650277f, -0.01326103f, 0.02639152f, -0.23299815f, -0.16318731f, 0.00049240f, -0.11483604f, 
    0.23664747f, 0.05925332f, 0.15858847f, -0.05212190f, -0.01851485f, -0.11781982f, -0.07433455f, -0.05226545f, 
    0.07882385f, -0.29234028f, 0.20313504f, 0.08966357f, -0.48066306f, -0.02066854f, -0.21488541f, 0.16339090f, 
    -0.06535035f, -0.10075523f, -0.08671901f, -0.04128617f, 0.28791797f, -0.09629747f, 0.12373730f, 0.05631132f, 
    0.08256651f, 0.13817124f, 0.10692759f, 0.11843543f, 0.12345115f, -0.16378617f, 0.10002151f, 0.13111602f, 
    0.02468747f, -0.15981902f, 0.17464270f, 0.31830660f, 0.02586600f, -0.32801756f, 0.08708210f, 0.16092832f, 
    -0.11962372f, 0.10049557f, -0.06236367f, -0.09913497f, -0.14488086f, 0.01605147f, -0.13666882f, -0.03814644f, 
    -0.28139856f, 0.18035862f, 0.00816925f, 0.09362449f, 0.20099506f, -0.08049441f, -0.06724316f, 0.28329715f, 
    -0.11395525f, -0.03118361f, -0.13845976f, 0.06415377f, 0.05378362f, 0.20478584f, 0.06859996f, 0.13408428f, 
    -0.04236701f, 0.10912728f, -0.05128035f, 0.03462405f, -0.21746629f, -0.08626261f, 0.26592371f, 0.16186762f, 
    0.10796731f, -0.04736856f, -0.07010794f, 0.10337348f, 0.09517618f, 0.00267177f, -0.04778955f, -0.09169959f, 
    -0.08657719f, 0.07934135f, 0.03178741f, 0.11989987f, -0.23296690f, -0.00252515f, 0.01983010f, 0.10300125f, 
    0.08369192f, -0.16699395f, 0.22507209f, 0.23556376f, 0.05857503f, -0.11760100f, -0.05947540f, -0.06934984f, 
    0.06964033f, 0.00740005f, -0.11020290f, -0.12267492f, -0.08032191f, 0.16556869f, 0.12619282f, 0.05620755f, 
    -0.05632933f, -0.00843264f, 0.12742016f, 0.12399241f, -0.17048506f, 0.11076915f, -0.02504277f, 0.33805066f, 
    -0.02795024f, 0.02468186f, -0.04503909f, -0.01094627f, 0.27825940f, 0.14557856f, -0.14049554f, -0.02460939f, 
    0.08831061f, -0.00105075f, 0.09184290f, -0.11855070f, -0.05425666f, -0.15533322f, 0.27590615f, 0.08060868f, 
    0.16238740f, 0.12427043f, -0.01662893f, -0.13715954f, -0.00054456f, 0.07274541f, -0.02797911f, -0.15190263f, 
    0.07764810f, 0.04344130f, -0.04846104f, 0.11468390f, -0.05205552f, -0.16392635f, -0.16232114f, -0.03127712f, 
    0.00416022f, -0.01374719f, 0.01696885f, -0.02500716f, -0.02250327f, -0.10569842f, 0.05335717f, 0.07189584f, 
    0.04908058f, -0.18527415f, 0.13954730f, -0.02829165f, -0.03437768f, -0.03749912f, -0.06903723f, 0.06429891f, 
    -0.19428387f, 0.10027530f, 0.04949865f, 0.07683045f, -0.26406896f, -0.03154296f, -0.05786460f, -0.03169752f, 
    -0.17995353f, -0.01018608f, 0.18273869f, -0.06627268f, 0.19044214f, -0.13669057f, 0.03269637f, 0.13738264f, 
    0.16771683f, -0.13355488f, -0.14188203f, 0.13995934f, -0.00012881f, -0.03750347f, 0.00953843f, 0.05638753f, 
    0.06964373f, 0.02827423f, 0.08626998f, 0.06112167f, -0.23588267f, -0.48998991f, -0.11443896f, -0.17784669f, 
    -0.19262761f, -0.08302764f, -0.04981221f, 0.03897802f, 0.08348299f, 0.02613277f, -0.12274757f, 0.04514325f, 
    0.07800093f, -0.02668904f, 0.02233997f, 0.15718210f, -0.03524902f, 0.17422274f, 0.18663107f, 0.05189047f, 
    0.37719148f, -0.45673600f, 0.44805548f, -0.10740676f, 0.23011488f, -0.33292377f, -0.01825354f, 0.14335045f, 
    0.03804344f, 0.02212970f, 0.07313958f, 0.02984118f, -0.05298075f, -0.04137706f, 0.13589662f, -0.01241490f, 
    -0.13484451f, 0.02471539f, -0.04612944f, -0.21959232f, -0.44164163f, 0.08026881f, -0.80683488f, 0.11238798f, 
    -0.00409144f, -0.01935223f, 0.00106081f, -0.08349036f, -0.07845163f, -0.06291150f, -0.00166601f, 0.09741931f, 
    -0.00843383f, 0.03572257f, -0.04285537f, 0.00754235f, -0.04711632f, -0.19237331f, -0.10743488f, -0.19433619f, 
    0.14248031f, -0.03297040f, 0.02358522f, 0.39686468f, 0.02073617f, -0.29008946f, -0.14307389f, 0.04075511f, 
    -0.03504539f, -0.23085183f, -0.03815976f, 0.12680626f, -0.05744990f, 0.05633119f, 0.08906140f, -0.02633730f, 
    -0.16245578f, 0.10396991f, -0.10375068f, -0.08175943f, -0.74445331f, -0.63556659f, 0.21490110f, 0.69635874f, 
    -0.41023996f, 0.07627816f, 0.10676878f, -0.17043203f, 0.33941665f, -0.32497817f, -0.25280046f, -0.02634240f, 
    -0.10231102f, 0.16838983f, 0.27523297f, 0.02575814f, -0.07855789f, 0.23541813f, 0.11877288f, 0.03299299f, 
    -0.16871783f, -0.11007742f, 0.06454603f, -0.11492980f, 0.14126581f, 0.01652592f, 0.12390022f, -0.04497868f, 
    0.06156953f, 0.06599905f, -0.08033819f, 0.08930509f, -0.07789700f, 0.09823503f, 0.00273086f, -0.04599117f, 
    -0.09277143f, -0.02963099f, -0.04618777f, -0.12526716f, -0.50052959f, 0.11859541f, -0.42178828f, 0.26703358f, 
    0.39881828f, -0.05074909f, 0.13057669f, -0.15848024f, 0.03778278f, 0.27301246f, 0.07626472f, 0.14837478f, 
    0.05913791f, -0.00456690f, 0.00238784f, 0.09657257f, -0.22283892f, -0.04333441f, -0.02462444f, -0.05155272f, 
    0.32833782f, -0.71762335f, -0.11147508f, 0.56057417f, 0.08347225f, 0.05571347f, -0.03387886f, -0.05672431f, 
    0.16047405f, -0.20585138f, -0.15294105f, -0.01861122f, 0.08385908f, 0.05723941f, -0.07287527f, 0.11682132f, 
    -0.14757164f, 0.18713772f, 0.21623345f, -0.06083048f, 0.19636610f, 0.17497328f, 0.28848279f, 0.04950640f, 
    -0.21672162f, -0.10289859f, -0.00757737f, 0.12685077f, 0.09435931f, 0.09885474f, -0.04614506f, 0.11299376f, 
    -0.04673978f, -0.08775941f, -0.06447740f, 0.06062169f, 0.08509456f, 0.07216843f, -0.00063601f, 0.11194876f, 
    -0.92948794f, 0.10463152f, -0.53649259f, 0.23009871f, -0.67976511f, 0.21402495f, 0.21979068f, 0.17135508f, 
    -0.28024623f, 0.17959584f, -0.07826532f, -0.05831750f, 0.16198599f, 0.18977267f, -0.07270239f, 0.05982405f, 
    -0.03480996f, 0.16103141f, 0.05537654f, 0.02738094f, 0.17169996f, -0.14674352f, 0.04861789f, 0.09027635f, 
    -0.08158319f, -0.09455828f, -0.03982531f, -0.07473028f, 0.00255140f, -0.00028230f, -0.09979885f, -0.13625117f, 
    0.10516544f, -0.09548603f, -0.12389023f, 0.09251019f, 0.05840508f, 0.05590523f, 0.03433661f, -0.09855105f, 
    -0.07485163f, -0.36331183f, -0.01539764f, -0.10658268f, -0.20318489f, -0.03513663f, -0.04596170f, 0.04841214f, 
    -0.06458665f, 0.04353568f, 0.01265224f, 0.01044973f, 0.15776518f, 0.07769053f, -0.05331571f, 0.06960511f, 
    0.04519476f, 0.07582778f, 0.08014452f, 0.08471897f, 0.05972127f, -0.41746691f, -0.29155082f, -0.12271798f, 
    0.08772323f, -0.19734694f, -0.36105976f, -0.20550357f, -0.01166241f, -0.06788960f, -0.05368125f, 0.03240672f, 
    0.14651823f, -0.09702675f, 0.00908064f, 0.04178220f, -0.07444688f, 0.10186281f, 0.18586878f, -0.04773916f, 
    0.66864568f, 0.03060173f, 0.63856518f, -0.00141061f, -0.28289381f, -0.03563669f, -0.04287607f, -0.33823222f, 
    0.14864509f, -0.08476297f, -0.11143146f, 0.05701827f, 0.04822380f, 0.05757937f, -0.08029981f, -0.07794636f, 
    0.11145034f, -0.05562272f, 0.11752326f, 0.17305627f, -0.08630258f, 0.06644528f, -0.10765500f, 0.19871105f, 
    -0.04051913f, -0.01277984f, 0.04475936f, -0.03380033f, -0.18201718f, -0.02275282f, 0.01218378f, 0.06004144f, 
    -0.06318917f, -0.09368771f, -0.03474833f, 0.03171400f, -0.11054335f, -0.09637761f, -0.13429271f, -0.06993177f, 
    0.22931515f, -0.00475567f, -0.04463406f, 0.37089190f, 0.21522716f, -0.04527214f, 0.24163774f, -0.06788549f, 
    0.05137563f, 0.14963798f, -0.09757736f, 0.17384630f, 0.01637668f, 0.16367348f, 0.15233746f, -0.01657149f, 
    -0.05789709f, -0.04695365f, -0.10922825f, -0.01980527f, -0.11476935f, -0.23951362f, -0.08585521f, -0.19366230f, 
    -0.04221012f, 0.03662888f, -0.26681435f, -0.18474019f, -0.08744013f, 0.03320125f, 0.06366595f, -0.03886546f, 
    -0.06068699f, -0.01125896f, -0.09805457f, 0.06127318f, -0.01161193f, 0.03181052f, 0.02727981f, -0.07513670f, 
    0.13841826f, -0.15398118f, -0.19320299f, -0.09125823f, -0.08786125f, -0.26575813f, -0.12354770f, 0.00247395f, 
    -0.21481548f, 0.05418551f, 0.04059004f, 0.09200714f, 0.15343186f, -0.13442557f, -0.08632530f, 0.01207226f, 
    -0.01307260f, -0.03240141f, 0.12514132f, 0.05050922f, -0.04065644f, -0.12915415f, 0.25373316f, 0.08479316f, 
    0.02135338f, -0.10888336f, 0.21161696f, -0.02840118f, 0.21045911f, -0.19067788f, -0.07259104f, -0.01836856f, 
    -0.09114244f, -0.02591720f, 0.05451066f, -0.11256262f, 0.03142098f, 0.01250676f, -0.03128881f, -0.11905541f, 
    -0.00287451f, -0.09124101f, 0.08423353f, 0.21622236f, -0.24564263f, -0.12508774f, -0.26471499f, -0.12397925f, 
    -0.06181019f, 0.12469900f, 0.00890154f, -0.10597432f, -0.11163361f, -0.30643442f, -0.07603310f, -0.01373506f, 
    -0.07378237f, -0.04633063f, -0.05860532f, -0.13422629f, 0.38765070f, -0.14338611f, 0.03527059f, -0.15760627f, 
    -0.11168823f, -0.02698808f, -0.09926959f, -0.10544126f, 0.00969066f, -0.03788522f, -0.18169485f, 0.00218351f, 
    0.01459983f, -0.09939229f, -0.12861288f, 0.10670150f, 0.10521828f, -0.05549978f, -0.06612614f, -0.05186577f, 
    -0.27576926f, -0.04269817f, -0.38644302f, 0.07387363f, 0.09128422f, -0.03052457f, 0.28626648f, 0.05198161f, 
    0.08916213f, 0.03825480f, -0.02282123f, 0.06364856f, 0.13331205f, 0.16611415f, 0.09272957f, -0.01344238f, 
    -0.05638617f, 0.00403587f, -0.25996381f, -0.07805938f, 0.13470247f, -0.18132348f, -0.35842568f, 0.09349222f, 
    0.06165594f, 0.03570224f, 0.05224825f, -0.05710921f, -0.04188920f, 0.01274416f, 0.03136696f, 0.02512415f, 
    -0.19060591f, -0.00454055f, -0.01048609f, -0.10907923f, 0.03480710f, 0.28057882f, -0.10721103f, 0.19697042f, 
    -0.20362929f, 0.07544009f, -0.27367467f, 0.20199887f, -0.18481301f, -0.12317303f, 0.03684402f, 0.24455243f, 
    0.08168414f, 0.11454560f, -0.24073687f, -0.03092374f, -0.10015654f, 0.11043075f, -0.10417840f, 0.09240951f, 
    0.11622608f, 0.12785321f, -0.29698518f, -0.10453557f, -0.27675653f, -0.15326431f, -0.24057312f, 0.47198823f, 
    0.43560201f, -0.18764850f, -0.08384778f, -0.25944754f, 0.11173859f, -0.15225576f, 0.02023780f, 0.18825877f, 
    0.03118824f, -0.02057733f, -0.00211360f, 0.20327882f, -0.00790296f, -0.09400047f, 0.21576580f, 0.11417421f, 
    -0.07955723f, -0.44089058f, 0.07515395f, 0.15133309f, 0.26771018f, 0.15134540f, -0.41526055f, 0.21709315f, 
    -0.11006491f, -0.08788918f, -0.08057851f, 0.02114736f, -0.07355849f, 0.14779489f, -0.14010291f, 0.05177754f, 
    -0.11917692f, 0.06859294f, -0.05269948f, 0.06515693f, 0.22178891f, -0.17962849f, 0.24810404f, 0.28873608f, 
    -0.04648635f, 0.05666091f, 0.00994134f, 0.17877617f, 0.07567322f, -0.02603777f, 0.08509319f, -0.14415655f, 
    -0.00833347f, -0.01712701f, 0.01203901f, -0.00486345f, 0.07406049f, 0.03033871f, -0.09121258f, -0.12855968f, 
    0.25496289f, -0.16252625f, 0.22293833f, -0.12772256f, -0.08862986f, 0.11166611f, 0.10014131f, 0.00034441f, 
    0.15893415f, -0.00553876f, 0.15611553f, -0.03929660f, 0.03651017f, 0.06200755f, 0.00942674f, -0.05577539f, 
    0.07840988f, -0.01632418f, 0.03289470f, -0.21844259f, -0.37535658f, 0.02028525f, -0.11939600f, 0.22020213f, 
    -0.23945162f, -0.01907231f, 0.09821054f, -0.00069671f, 0.11122315f, -0.06402227f, -0.23313719f, -0.05078379f, 
    -0.02236536f, -0.05258131f, 0.00594011f, 0.10234851f, -0.06095896f, -0.01446795f, -0.08609594f, -0.09259455f, 
    -0.53303975f, 0.07719766f, -0.36325830f, 0.24433902f, -0.32714334f, -0.00961672f, 0.00832442f, -0.01752524f, 
    0.03186053f, 0.05174527f, -0.06326319f, -0.16711649f, -0.06130844f, -0.11023884f, 0.00207671f, -0.01844528f, 
    -0.02560079f, -0.09728820f, -0.11113888f, -0.01193779f, 0.30034056f, -0.25799331f, 0.38380674f, -0.20316690f, 
    0.09196673f, 0.07336209f, -0.13164024f, 0.14790066f, 0.18053234f, -0.03975167f, 0.04212765f, 0.00372245f, 
    0.02086129f, -0.00627531f, -0.06657635f, -0.00423287f, 0.22760439f, 0.01084976f, 0.00355857f, 0.11296732f, 
    0.02674993f, -0.49432781f, -0.09877504f, -0.14932919f, 0.21104574f, -0.00543890f, -0.05026129f, -0.14380407f, 
    0.02159945f, -0.11407793f, 0.02661872f, 0.04548995f, -0.09711865f, -0.00189339f, -0.05205299f, 0.06831600f, 
    0.02812431f, -0.05951077f, 0.00218378f, -0.00874186f, 0.29984045f, 0.14750972f, 0.28119025f, 0.03621239f, 
    -0.16085580f, -0.03175217f, 0.15023094f, -0.01574632f, 0.06373011f, -0.06912998f, -0.14219598f, -0.02402205f, 
    0.02227901f, 0.05628077f, 0.01204532f, -0.02678696f, 0.00884701f, -0.00756879f, -0.21635774f, 0.07428553f, 
    0.11582126f, -0.30525342f, 0.17548873f, -0.41886315f, 0.30400774f, 0.03465541f, 0.15091984f, 0.15647551f, 
    0.16421355f, 0.15794849f, -0.09965850f, 0.18544504f, -0.03157368f, 0.13587065f, -0.06871370f, -0.05609739f, 
    0.15477584f, 0.07039113f, -0.18801177f, 0.15057454f, 0.01304905f, -0.36620143f, -0.30655655f, -0.22297949f, 
    -0.08754200f, -0.01215438f, -0.15205163f, 0.07505980f, -0.03890454f, -0.04219451f, -0.01177163f, 0.02987222f, 
    0.15178145f, -0.05881978f, -0.13011242f, 0.10471644f, -0.05292136f, 0.09298801f, -0.03513886f, 0.02209615f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17605558f, 0.09836202f, 0.06199687f, -0.11587123f, -0.05437281f, 0.05807798f, 0.05190686f, -0.11591254f, 
    0.03600768f, 0.06776100f, -0.02145391f, -0.02300321f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
