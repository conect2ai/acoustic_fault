#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.78516102f, 1.33357525f, 1.07365835f, -1.04729497f, 0.40991968f, -0.12765972f, 0.17583001f, -0.02561876f, 
    -0.07637351f, -0.17853960f, -0.51342708f, 0.68594736f, -1.11513078f, -1.32774007f, -0.81994802f, -0.06903377f, 
    0.11876132f, -0.24746692f, 0.07582672f, -0.97985220f, -0.92851496f, 1.19884253f, 0.66852254f, -0.46110788f, 
    -0.76118416f, 0.23110208f, -0.20011501f, -0.47633258f, -1.10229599f, -0.20068659f, 0.59501821f, -0.38447386f, 
    -0.58451402f, 0.32164943f, -0.37955585f, -0.49195886f, -1.00716746f, -0.76001751f, 0.80061066f, 0.13498570f, 
    -0.56040442f, 0.84913194f, -0.29117155f, -0.15878002f, 0.08775862f, 1.18286169f, 0.49523082f, -0.64515781f, 
    -0.17972039f, 0.98755759f, 0.42517865f, 0.10793593f, 0.24007791f, 0.13634197f, 0.91907895f, 0.56972569f, 
    1.12125432f, 0.78311974f, 0.58673656f, 0.36656120f, 0.23832762f, 0.71828312f, -0.23486024f, 0.56343883f, 
    -1.47102368f, 0.19198665f, 0.96746701f, -0.87929839f, 0.94668543f, -0.03258437f, -0.19070716f, -0.03303596f, 
    0.75075078f, -0.78602588f, -1.02475965f, -0.49706346f, -0.30763352f, -0.33270681f, -0.47594213f, 0.16064247f, 
    0.70398331f, 1.36883163f, 0.81881499f, 0.04911026f, 0.56404042f, 0.04117671f, -1.08040631f, -0.41467503f, 
    -0.16732736f, -0.45006484f, -0.77274549f, -0.44033587f, -0.50505060f, -0.89437360f, -0.43400052f, 0.70596755f, 
    0.23267722f, 0.69546348f, 0.43649536f, -1.62034118f, 0.71213460f, 1.07933688f, 0.20997487f, 0.79331613f, 
    0.01184262f, -0.17575356f, -0.02934984f, 0.10591001f, -0.97399288f, -0.55204695f, -0.52826029f, 0.90923953f, 
    1.33917475f, 0.71354902f, 0.00252274f, -0.23477173f, -0.38847682f, -0.38400707f, 1.34991443f, -0.95145464f, 
    0.61097407f, -0.30689621f, -1.17174160f, 0.20232159f, 0.31139362f, 0.28025198f, -0.50997794f, -1.48803067f, 
    -0.89857727f, -0.82910961f, 0.11332744f, 0.06753621f, -0.08861848f, 0.11378736f, -0.21043372f, -0.91270655f, 
    1.13039219f, -0.67207718f, 0.71848494f, -0.74723935f, 0.47272256f, -0.46801150f, -0.47011691f, -0.67570418f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.31603822f, 0.33197382f, 0.26031151f, 0.41821021f, 0.12618309f, 0.25051796f, 0.33252412f, 0.11158721f, 
    0.40437013f, 0.08974277f, 0.13582639f, 0.11145539f, 0.05999774f, 0.11236548f, 0.29818660f, -0.09652470f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.50391060f, 1.02591932f, -0.41897824f, 0.18585274f, 0.44112933f, 0.00176427f, -0.09953775f, 0.10714167f, 
    0.12746826f, 0.08682910f, 0.06139855f, 0.06154389f, 0.05295432f, 0.00063951f, 0.09281044f, 0.02575301f, 
    0.04931086f, -0.03955938f, -0.05844569f, 0.02701992f, -0.02816234f, -0.01257099f, -0.21492712f, 0.09075533f, 
    0.14011280f, 0.07798424f, -0.04985862f, 0.05895073f, 0.11070173f, -0.04100905f, 0.03001560f, -0.15435797f, 
    -0.09343556f, 0.04153587f, 0.13081679f, -0.00608544f, -0.02682219f, 0.05842760f, 0.11465288f, -0.03853402f, 
    0.40995315f, -0.52363664f, 0.06970088f, -0.19157654f, 0.02679924f, 0.02590098f, 0.04070976f, -0.04290969f, 
    -0.00145958f, -0.03197203f, 0.10400590f, -0.00230948f, 0.01643976f, 0.07345153f, 0.04636997f, 0.01803249f, 
    0.20808379f, -0.04429526f, -0.16497983f, 0.02838664f, 0.04037981f, -0.17571068f, -0.08184816f, -0.07631732f, 
    -0.04324724f, 0.00804346f, 0.05594322f, -0.11158474f, -0.04443931f, -0.18860625f, -0.00345690f, 0.00647871f, 
    -0.02880980f, 0.04415855f, 0.12757948f, 0.10898865f, 0.07978141f, -0.01838755f, 0.01656051f, 0.21026927f, 
    -0.66298836f, 0.11169922f, 0.04413628f, -0.00508720f, -0.34705666f, -0.25497976f, 0.10160378f, 0.11389006f, 
    0.06931601f, 0.07320036f, 0.12561630f, -0.04916308f, -0.08568311f, 0.00211068f, 0.06620005f, -0.00443510f, 
    -0.07291167f, 0.00120440f, 0.05795449f, 0.07768133f, 0.19063625f, 0.16699813f, 0.10912667f, -0.15833007f, 
    0.18489031f, 0.05379796f, -0.00834928f, 0.03915111f, 0.17480899f, 0.19305755f, -0.13575561f, 0.02567174f, 
    0.05179084f, -0.01162172f, 0.01674203f, -0.08813857f, -0.00316126f, -0.13299352f, -0.07676198f, -0.03901323f, 
    0.25796872f, 0.02938954f, 0.04695686f, 0.06930640f, -0.00489020f, -0.11329108f, 0.00725429f, 0.20331363f, 
    0.16839842f, 0.24680732f, 0.03165172f, 0.07262070f, 0.06391527f, -0.06862155f, -0.00796183f, -0.06778361f, 
    -0.14500321f, -0.06519908f, -0.09754755f, -0.00027752f, -0.09230020f, -0.09282756f, 0.13497140f, -0.09696855f, 
    -0.18501203f, 0.08017185f, 0.20176794f, -0.00213798f, 0.09413709f, 0.13184805f, 0.01418543f, -0.09624624f, 
    -0.03071144f, 0.09264899f, 0.10532634f, 0.00445584f, 0.09735321f, 0.01366767f, -0.01751442f, -0.13324444f, 
    0.04554545f, -0.40426734f, 0.07758978f, -0.19602735f, -0.04302412f, 0.12647517f, -0.13589050f, 0.13077642f, 
    0.01315654f, 0.14208557f, 0.11250786f, 0.13661978f, -0.04451935f, 0.03198139f, -0.09693743f, -0.01081094f, 
    0.07360409f, -0.01664194f, -0.11447769f, -0.06255247f, 0.74500453f, -0.32649943f, -0.04133689f, -0.04830913f, 
    0.28790268f, 0.05794189f, -0.20960200f, 0.24229085f, 0.15369652f, -0.01381941f, -0.01439287f, 0.01315734f, 
    0.07263458f, 0.06434353f, -0.01209785f, 0.02821672f, 0.04860296f, 0.10998834f, -0.12022106f, 0.08710188f, 
    -0.13235207f, 0.18151888f, -0.28126192f, -0.16418196f, -0.23207574f, -0.04089217f, 0.00483681f, 0.12181753f, 
    -0.14480579f, 0.00393672f, 0.06243778f, -0.03734850f, 0.02722165f, -0.08905505f, -0.08406878f, 0.09738331f, 
    -0.00297628f, 0.06472033f, 0.07400360f, -0.05536759f, -0.27863193f, 0.00307962f, 0.04191117f, 0.10984264f, 
    -0.12280035f, -0.36597425f, 0.16461840f, 0.13193665f, 0.01182414f, -0.04085328f, -0.04738125f, 0.10254665f, 
    0.10421134f, 0.06594083f, 0.00838783f, 0.03897006f, -0.13570271f, -0.07004212f, 0.10959978f, 0.03906786f, 
    0.09714312f, 0.12988922f, 0.09453356f, -0.27835160f, -0.10344690f, 0.07359656f, 0.09721589f, 0.00875724f, 
    0.14922325f, 0.08619298f, -0.03724785f, -0.00976564f, -0.07091250f, 0.07461221f, 0.12780176f, 0.09209771f, 
    -0.04715767f, -0.09197311f, -0.05392800f, 0.04040878f, 0.68531185f, -0.08849366f, -0.03440781f, 0.22390947f, 
    0.10958783f, 0.14226787f, -0.04603729f, 0.09561370f, -0.17780781f, 0.07166091f, 0.03072339f, -0.00475451f, 
    -0.08048675f, 0.14458083f, -0.02270680f, 0.06785206f, -0.01648781f, 0.18425827f, -0.08162600f, -0.01951074f, 
    0.16767727f, -0.15428375f, -0.36190382f, -0.15776977f, -0.20281155f, -0.02102499f, -0.22435391f, 0.14806022f, 
    -0.01549906f, -0.14820848f, 0.17196622f, -0.03184274f, 0.21584240f, -0.02943318f, -0.05698145f, 0.05998008f, 
    0.07461938f, 0.11995114f, 0.07086968f, 0.18804434f, 0.13470733f, 0.05066150f, 0.16412425f, -0.08846316f, 
    0.13477796f, 0.00624856f, 0.06978819f, 0.02580040f, -0.10617021f, -0.00633431f, 0.11001525f, -0.08917830f, 
    0.05437232f, 0.03719625f, 0.02941308f, -0.12445792f, 0.01353094f, 0.22877252f, -0.08319801f, -0.06508896f, 
    -0.04344087f, -0.03787158f, -0.03854682f, -0.01526664f, -0.00652440f, -0.05783994f, -0.03526787f, 0.01522609f, 
    -0.06206005f, 0.01095977f, -0.04839537f, 0.01329200f, -0.02581682f, -0.06377818f, 0.01015040f, 0.03952461f, 
    -0.05436430f, -0.03365041f, -0.03663711f, 0.02664067f, 0.00002937f, 0.00321194f, 0.03576370f, 0.02392662f, 
    0.00676107f, 0.04999705f, 0.00611404f, -0.04878916f, 0.02812385f, -0.04086113f, -0.00679355f, -0.04537393f, 
    0.04193186f, -0.01701197f, -0.04828659f, -0.02082795f, -0.02591188f, 0.00884166f, -0.00050482f, -0.05107820f, 
    0.01917903f, -0.02720719f, -0.03254027f, -0.02145228f, -0.02416341f, -0.01912750f, -0.02785535f, -0.05500913f, 
    0.00181062f, -0.04803907f, 0.00058482f, -0.00528886f, 0.00986782f, 0.01928877f, 0.04273307f, -0.06050730f, 
    -0.01201168f, -0.06178748f, -0.06162986f, 0.00492518f, 0.02267725f, -0.03301115f, -0.03652397f, 0.03945226f, 
    0.02972681f, -0.02626358f, -0.00148474f, 0.00075270f, -0.05652113f, 0.00577468f, 0.03216695f, -0.02107510f, 
    0.00348988f, -0.04896433f, 0.03152478f, -0.05906042f, 0.01400048f, -0.00949237f, -0.02420087f, -0.04769575f, 
    0.03340134f, -0.00383832f, -0.01701893f, -0.04304426f, -0.04877146f, 0.03580746f, 0.01592625f, 0.00998767f, 
    -0.04610844f, 0.04826706f, -0.00613360f, 0.01980645f, 0.04775306f, -0.06189305f, 0.00520702f, -0.04718522f, 
    -0.05940738f, 0.04222087f, 0.04206305f, -0.03271948f, -0.01469300f, 0.04522949f, 0.03485809f, -0.01029306f, 
    -0.02053814f, 0.01689040f, -0.00848068f, -0.03878664f, 0.04462407f, -0.00486201f, -0.00569558f, 0.02771872f, 
    -0.05493462f, 0.03852530f, 0.02402757f, -0.02609830f, 0.00827486f, 0.04181559f, -0.04451036f, -0.02463264f, 
    -0.05442159f, 0.01458874f, 0.00281891f, 0.03959800f, -0.01019277f, 0.04308520f, -0.02111187f, -0.00214038f, 
    0.03562856f, -0.05117906f, 0.00425888f, 0.00798020f, 0.01736250f, 0.01217638f, -0.01136219f, -0.03587034f, 
    -0.05588589f, -0.04271986f, 0.01842172f, 0.01518591f, -0.03816571f, 0.00297727f, -0.05442643f, 0.03350783f, 
    -0.04693287f, 0.00816421f, 0.01666455f, 0.01069946f, -0.00898900f, 0.03164756f, -0.03748132f, -0.02605776f, 
    0.04638460f, -0.04428343f, -0.04884034f, -0.00368204f, -0.05298541f, -0.04026239f, -0.06204199f, 0.02160963f, 
    0.04691868f, -0.05285135f, 0.02198180f, -0.01562587f, -0.03793757f, 0.00631354f, 0.01649379f, -0.06063762f, 
    -0.03026469f, 0.04764823f, 0.03556336f, -0.05791796f, -0.00257514f, 0.04087664f, 0.00243348f, 0.01877164f, 
    -0.05385865f, -0.04049539f, -0.04599278f, 0.04518986f, -0.01227689f, -0.00604929f, -0.00314462f, 0.01100221f, 
    -0.00773411f, -0.02622227f, -0.01072603f, 0.00225011f, -0.02496592f, 0.03529398f, 0.01307700f, -0.01277266f, 
    -0.06075952f, 0.04565945f, 0.01692916f, 0.02441945f, 0.03589584f, -0.01084063f, 0.04652009f, -0.01438839f, 
    0.00295748f, 0.03905173f, 0.04115514f, -0.02976784f, 0.02268818f, 0.00537376f, -0.01404915f, -0.02503084f, 
    0.03818648f, 0.01767313f, -0.05301954f, -0.02815942f, -0.05892399f, -0.03795917f, 0.02034145f, -0.02561587f, 
    0.03250621f, 0.01966362f, -0.05494350f, -0.04975636f, -0.01893120f, 0.02100785f, -0.01138746f, -0.00559997f, 
    0.02117825f, 0.00595499f, 0.02201823f, -0.01432786f, -0.02699698f, 0.04502339f, -0.03512760f, 0.00973717f, 
    -0.05888293f, -0.04803519f, -0.02734446f, -0.01268903f, 0.02701685f, -0.02967799f, 0.04127324f, 0.04919153f, 
    -0.01777734f, -0.03376562f, -0.02924310f, 0.04476780f, 0.04231646f, 0.00189660f, 0.00166202f, -0.05834218f, 
    -0.02057732f, 0.03300970f, 0.00200947f, 0.03447792f, -0.02056324f, 0.03037118f, 0.01724021f, -0.00991297f, 
    0.01501010f, -0.01938427f, 0.01072149f, 0.03862586f, 0.01758039f, 0.00051699f, 0.02384176f, -0.06179921f, 
    -0.00951928f, -0.02543245f, 0.03666173f, -0.03169277f, -0.04202384f, 0.00052159f, -0.00373989f, 0.03581772f, 
    -0.03905467f, 0.04812139f, -0.04449426f, -0.05358338f, 0.00454849f, -0.00195286f, -0.02963555f, 0.04027957f, 
    -0.03294364f, -0.05335541f, 0.01627499f, -0.02829797f, -0.04473461f, -0.05435770f, 0.01858697f, 0.01050851f, 
    -0.04384747f, -0.05326772f, 0.03441964f, 0.00810276f, 0.01160418f, 0.04899501f, 0.01788810f, -0.00913831f, 
    -0.05981977f, -0.00338251f, -0.01468537f, 0.03923367f, -0.05036233f, -0.05293559f, -0.03118820f, 0.00690891f, 
    0.02013737f, 0.03054444f, -0.05510914f, -0.04045441f, 0.04238793f, -0.06165023f, 0.02500008f, -0.02998968f, 
    -0.03506519f, -0.05518882f, 0.03004257f, -0.03247757f, -0.03324682f, -0.03313533f, 0.00679049f, -0.01176199f, 
    -0.50069368f, 0.21998756f, -0.18404679f, 0.04943993f, 0.25354195f, -0.05312109f, 0.02044390f, 0.07926540f, 
    0.00127986f, -0.02899801f, 0.03090544f, 0.08403223f, -0.06560455f, 0.04276027f, -0.07298000f, 0.12044244f, 
    0.11424011f, 0.04836059f, -0.18623039f, 0.14146928f, -0.03173216f, -0.01210155f, 0.30172789f, 0.13397662f, 
    -0.37974262f, 0.02815532f, 0.07701743f, 0.00594863f, -0.06889027f, 0.00053280f, -0.09155568f, 0.12294586f, 
    0.08723739f, 0.01316547f, -0.18181852f, -0.06326026f, 0.00697970f, -0.09545301f, -0.05751887f, -0.05812047f, 
    0.14322756f, -0.04798997f, -0.02172635f, 0.06527174f, -0.16242009f, -0.06773049f, -0.18371746f, -0.08184431f, 
    0.15017188f, 0.01994411f, -0.05671437f, -0.04147562f, 0.08233825f, 0.14042750f, -0.00561065f, 0.06205167f, 
    0.04277140f, 0.07207917f, -0.02724099f, 0.04785237f, 0.00507492f, 0.02077658f, -0.05549535f, 0.11780912f, 
    -0.32398206f, 0.09665781f, 0.02901736f, -0.06671219f, 0.02364277f, 0.06846455f, 0.04686908f, -0.12321134f, 
    0.07726536f, 0.16581112f, 0.04211519f, 0.05783759f, 0.08134001f, -0.10411651f, 0.00953388f, -0.13450976f, 
    0.20592350f, 0.10140199f, -0.03282313f, -0.04617285f, -0.22191149f, -0.14154460f, -0.06260487f, 0.04936278f, 
    -0.03941273f, 0.04615907f, 0.06816427f, 0.18741658f, -0.06110226f, -0.09126823f, 0.01934946f, 0.02787473f, 
    -0.06898367f, -0.09112366f, 0.19351475f, 0.11638375f, 0.57094562f, -0.19351915f, 0.09147273f, -0.25067791f, 
    0.11793536f, -0.21499319f, -0.09807397f, -0.01917367f, 0.06589254f, -0.02357837f, 0.09758572f, 0.08459856f, 
    -0.05466351f, 0.04041949f, -0.00330486f, 0.01977011f, 0.03287814f, 0.01494610f, 0.11628992f, -0.02360507f, 
    -0.26368564f, 0.15344332f, 0.16407624f, -0.14856762f, 0.17186899f, -0.04802326f, 0.07219523f, -0.07969899f, 
    0.11839114f, 0.04615979f, 0.01969795f, -0.07869927f, 0.09112263f, 0.02814808f, -0.00426149f, 0.09796471f, 
    0.00033346f, 0.01873763f, 0.02180911f, 0.14311214f, -0.31582877f, 0.16952634f, 0.18609835f, -0.03266343f, 
    -0.10399327f, -0.00693341f, 0.09876686f, 0.03299953f, -0.03439753f, 0.27543485f, 0.03878198f, -0.02211207f, 
    -0.02204829f, 0.02462992f, 0.05557649f, 0.00962914f, -0.01597436f, -0.00618777f, 0.08297516f, 0.04744940f, 
    0.23404090f, -0.41776061f, 0.04351367f, 0.02934237f, -0.13998738f, 0.05807523f, 0.11888242f, 0.04697555f, 
    0.07734817f, 0.15329060f, -0.14370632f, -0.00618454f, -0.03719671f, -0.01382860f, 0.03143167f, 0.04562564f, 
    0.04426074f, -0.16148221f, 0.01361734f, -0.16502620f, -0.07678169f, -0.42001122f, 0.30296078f, -0.05917003f, 
    0.13931268f, 0.10218470f, -0.08760995f, -0.04436566f, 0.01269970f, 0.00990287f, 0.01334334f, -0.08879468f, 
    0.02496677f, 0.06774476f, -0.00839470f, -0.10718605f, 0.01707277f, -0.15032791f, 0.02156404f, -0.11947938f, 
    0.59982353f, -0.02971433f, 0.09836810f, -0.02640183f, -0.19999388f, 0.20338410f, -0.00237137f, 0.03964037f, 
    0.13565212f, 0.13079448f, -0.15899861f, -0.06573615f, -0.05351593f, -0.13657825f, -0.09867810f, 0.11419196f, 
    0.08223253f, 0.01158195f, 0.17029098f, 0.00355044f, -0.03273631f, 0.35068655f, -0.40631837f, -0.27239606f, 
    0.07383180f, -0.13744560f, 0.19170085f, 0.08044203f, -0.01878262f, 0.12833762f, 0.05731879f, 0.11055490f, 
    0.09646666f, -0.18150523f, 0.03489441f, 0.05950296f, -0.13422818f, 0.08348493f, 0.05537125f, -0.04065765f, 
    0.38317567f, 0.29684806f, -0.02685625f, 0.13859695f, 0.06792823f, -0.06158080f, -0.01060295f, -0.13283373f, 
    0.04179401f, 0.03413678f, 0.10431835f, -0.00435192f, -0.01322739f, -0.00398211f, 0.06057261f, 0.06386977f, 
    0.12458755f, -0.01652007f, -0.00031940f, -0.03023975f, -0.15482007f, -0.34747648f, -0.19101712f, -0.39260554f, 
    -0.02822042f, 0.06197108f, -0.08248451f, 0.14354298f, 0.04010562f, 0.05630084f, -0.00617520f, 0.14603822f, 
    0.11682322f, -0.11683650f, 0.14557907f, 0.10924736f, -0.04779913f, -0.00282182f, 0.05752151f, -0.01879611f, 
    0.42249393f, -0.42236236f, -0.08637520f, 0.30800062f, -0.01652316f, -0.12356695f, 0.01552071f, 0.07738125f, 
    0.21194769f, 0.14269461f, -0.02019807f, -0.01299254f, 0.04996556f, 0.15593892f, -0.11663981f, 0.11600710f, 
    -0.00427814f, -0.00692713f, -0.11284101f, 0.03609024f, 0.10143591f, 0.02528661f, -0.21635704f, 0.04080425f, 
    0.22819827f, 0.06097020f, -0.04769812f, 0.03487872f, -0.02185930f, -0.02232007f, 0.09836531f, -0.03930904f, 
    -0.18835714f, -0.03959212f, 0.12410582f, -0.03291139f, -0.02749622f, 0.11190791f, 0.06388470f, -0.00663914f, 
    0.30765867f, -0.20334385f, -0.14149509f, -0.05787382f, -0.11555145f, 0.08883372f, 0.09537851f, 0.18372743f, 
    -0.09981450f, -0.05753986f, 0.10260727f, 0.13383447f, -0.08773308f, -0.01211784f, -0.06495590f, 0.07178324f, 
    0.06546324f, 0.01599960f, -0.12904176f, -0.05321366f, -0.06404387f, -0.06759629f, 0.05822688f, -0.13772650f, 
    0.18666628f, 0.02719097f, -0.02621978f, 0.02021860f, -0.04383810f, -0.13146695f, 0.17769475f, 0.07524254f, 
    0.07087596f, 0.09155864f, -0.00539282f, 0.03209959f, 0.01329701f, 0.00973023f, -0.08894983f, -0.11058788f, 
    0.24408436f, -0.03380521f, 0.36831519f, 0.20869386f, 0.18612126f, -0.07653845f, 0.11756273f, 0.09797293f, 
    0.06629341f, 0.06172097f, -0.11372968f, 0.07308779f, -0.11519498f, -0.06705189f, -0.01119941f, -0.06220063f, 
    -0.11130144f, 0.03452842f, 0.08932976f, -0.00306325f, 0.04045758f, 0.08672295f, 0.12501670f, 0.14177814f, 
    0.12448796f, -0.05312420f, 0.13237919f, 0.00355386f, -0.08178326f, -0.10037004f, -0.02807627f, -0.14391275f, 
    0.07207755f, 0.08749066f, -0.03380940f, 0.14227034f, 0.04393008f, -0.07880567f, 0.13801239f, -0.03447371f, 
    0.11826286f, 0.18676817f, 0.07806838f, -0.04511121f, 0.33391416f, -0.03188813f, -0.13918620f, -0.07758119f, 
    0.11207808f, -0.08949851f, -0.01313653f, 0.03380973f, -0.03768308f, 0.04440113f, -0.03252271f, -0.13950439f, 
    -0.09123330f, -0.06333283f, -0.04930015f, 0.01923610f, 0.34485227f, -0.02156279f, 0.01334769f, -0.15679732f, 
    -0.35698679f, 0.17314380f, 0.17831919f, 0.06167519f, -0.04806590f, -0.04181222f, 0.03667270f, -0.01248257f, 
    -0.10390390f, 0.09079247f, -0.04730427f, -0.01099635f, 0.03449660f, 0.04347207f, 0.02431603f, 0.12372015f, 
    0.21978746f, -0.12351292f, -0.03284030f, -0.24595059f, 0.06129454f, 0.05920120f, 0.13441773f, 0.03530905f, 
    -0.08731925f, 0.06491576f, 0.06914274f, -0.10072837f, -0.01114989f, 0.00784680f, -0.14551285f, 0.19461524f, 
    -0.01682596f, -0.07210599f, 0.01016741f, 0.08079156f, -0.49968338f, 0.12456608f, 0.06170666f, 0.09824737f, 
    0.21806535f, -0.06360035f, -0.21377413f, -0.18896624f, 0.11917203f, 0.06781580f, -0.00631568f, -0.14119455f, 
    -0.03844621f, 0.09026009f, -0.07610904f, -0.02763271f, -0.04395378f, -0.12115205f, 0.04386368f, 0.03768310f, 
    0.24721138f, 0.30884108f, -0.08103322f, -0.03824728f, 0.15476112f, 0.06823029f, 0.03384744f, -0.08263730f, 
    0.11969118f, -0.03246261f, 0.01245700f, 0.03807341f, -0.03518573f, -0.04682230f, 0.04321029f, 0.05978181f, 
    0.14142747f, 0.08129144f, 0.02878542f, -0.06013723f, 0.09733533f, -0.15908819f, -0.14458834f, 0.02745089f, 
    -0.17065285f, 0.09824989f, 0.08271364f, 0.06488140f, -0.11764700f, -0.04203384f, 0.04672138f, -0.05158833f, 
    0.10230042f, 0.02400876f, -0.11689303f, -0.10483236f, -0.08812294f, -0.11784325f, -0.05014325f, -0.12172096f, 
    0.54874474f, 0.29949158f, 0.33387762f, -0.08919357f, 0.00875416f, 0.03077683f, 0.08785187f, 0.02840912f, 
    -0.07483598f, 0.10786592f, -0.08392657f, 0.08488125f, -0.05315711f, -0.05704986f, -0.01258504f, 0.03638434f, 
    -0.06989924f, 0.04872229f, 0.11942134f, -0.04618037f, -0.01398377f, 0.30996606f, -0.43900129f, -0.14031921f, 
    -0.02551610f, 0.00805186f, 0.13943900f, -0.02614823f, 0.07506588f, 0.00521483f, -0.05576336f, 0.09427804f, 
    0.08858612f, 0.10661336f, 0.01688383f, -0.06065464f, -0.05482196f, -0.04357926f, -0.13513298f, -0.09927784f, 
    -0.03406251f, 0.08527990f, 0.12016346f, 0.30877936f, 0.46672866f, -0.03530646f, -0.10923601f, -0.02939369f, 
    0.02260914f, -0.03868475f, 0.06559299f, -0.01032581f, 0.13200247f, -0.14768960f, -0.05081158f, -0.14735493f, 
    -0.04163940f, 0.07702404f, -0.12822443f, -0.12375089f, -0.46566993f, -0.04328256f, -0.20578420f, -0.26005173f, 
    -0.23592518f, 0.13380991f, -0.12621067f, -0.14581050f, 0.07767026f, -0.07397486f, -0.04100194f, -0.00139050f, 
    0.23030160f, -0.03636045f, -0.02564324f, -0.08153249f, 0.07479340f, -0.04082822f, 0.00913533f, 0.06696124f, 
    0.37105346f, 0.16361524f, 0.25474864f, 0.10952991f, 0.21379416f, -0.00751685f, 0.05116973f, 0.02877746f, 
    0.05488934f, 0.02617754f, 0.08133251f, 0.11304704f, -0.02586007f, 0.04683024f, -0.03037815f, 0.10191292f, 
    0.02774222f, 0.05569139f, 0.00885583f, -0.10724600f, 0.08733072f, 0.12099628f, -0.36044872f, 0.04356173f, 
    0.22205175f, 0.27006438f, 0.03840849f, -0.03983675f, -0.02896835f, 0.01607091f, -0.03155207f, 0.06927107f, 
    0.02744928f, 0.06382507f, -0.05729993f, 0.08754041f, -0.04186162f, -0.08835045f, 0.00705711f, 0.00586895f, 
    0.00238025f, -0.03367234f, 0.01815935f, -0.02415069f, -0.04696242f, -0.00185923f, 0.04261823f, 0.03119168f, 
    0.03912476f, -0.03991383f, 0.03773453f, -0.00415720f, -0.00736784f, 0.03416775f, -0.05172948f, -0.02589316f, 
    0.01477401f, -0.03572793f, -0.02650045f, -0.03696712f, 0.01653536f, 0.02593363f, -0.03101155f, 0.04154615f, 
    -0.00308655f, 0.04206854f, 0.02719291f, -0.00576585f, 0.01754320f, 0.01569322f, -0.05796044f, -0.04499030f, 
    -0.04161378f, -0.03671690f, 0.00659309f, -0.03428205f, 0.02065890f, -0.04383434f, -0.06029796f, -0.05825556f, 
    -0.01799343f, -0.03665502f, -0.05532717f, -0.00969414f, -0.05481900f, 0.04594076f, 0.02539215f, 0.03716134f, 
    0.04262645f, -0.02909912f, 0.04468050f, 0.00696376f, -0.04029543f, -0.00781211f, -0.03079167f, -0.05787814f, 
    -0.01035822f, -0.00207647f, -0.00115473f, 0.02283656f, 0.00069582f, -0.04989940f, -0.03032550f, 0.00232443f, 
    0.03010271f, 0.00230171f, -0.03152451f, -0.02895169f, 0.04242389f, 0.04166210f, 0.01464076f, 0.00233650f, 
    0.04498236f, -0.01079128f, 0.02736653f, -0.02148844f, -0.04732411f, 0.02662824f, 0.03807931f, -0.02607700f, 
    0.02542298f, 0.01546756f, 0.00517439f, -0.05478672f, -0.03235433f, -0.04842148f, -0.06030698f, -0.03140681f, 
    -0.01068742f, -0.04828734f, -0.01207539f, -0.01818170f, 0.00476066f, 0.02543286f, 0.02275652f, -0.01692222f, 
    -0.02184798f, -0.03815768f, 0.01091459f, -0.00452348f, 0.02395596f, 0.04774290f, -0.05841609f, -0.03788511f, 
    -0.02083182f, -0.04176800f, -0.04203983f, 0.00702956f, 0.04108221f, -0.00395195f, -0.04549500f, -0.06072309f, 
    -0.00372305f, 0.00320928f, -0.02918806f, -0.05345051f, 0.00582292f, -0.05060523f, -0.03480186f, -0.03868884f, 
    -0.02712524f, -0.04454466f, 0.00111553f, 0.01878114f, 0.04929445f, -0.05764461f, 0.03055232f, 0.02355147f, 
    0.02631667f, -0.03269227f, -0.03688946f, 0.00137257f, 0.03788472f, -0.00340536f, 0.00907359f, 0.00888883f, 
    -0.05983671f, 0.04500343f, -0.03432759f, 0.03188128f, -0.03262397f, -0.01499666f, -0.03640801f, -0.01668211f, 
    0.00145697f, 0.02856996f, -0.05282703f, 0.04746855f, 0.02574629f, 0.03215865f, -0.04673811f, -0.02457561f, 
    0.01901978f, -0.04550884f, -0.03099350f, 0.03847065f, -0.04613305f, -0.02320005f, 0.01325080f, -0.04267142f, 
    0.00456380f, -0.02601693f, -0.05429107f, -0.05136590f, 0.03503783f, 0.00704614f, -0.01571637f, -0.05481734f, 
    0.04462115f, -0.02342374f, -0.05609615f, -0.05797150f, 0.01151704f, -0.01164020f, -0.04731153f, 0.02332574f, 
    -0.01168420f, -0.05842502f, -0.04084587f, -0.04323808f, 0.01812028f, -0.01856907f, -0.04781057f, -0.02965501f, 
    0.03567803f, 0.02452957f, -0.02377460f, -0.04020241f, 0.00532482f, 0.00469222f, 0.01329383f, -0.01625944f, 
    -0.04165782f, -0.05230835f, -0.01542348f, -0.02242563f, 0.02661525f, -0.00770061f, 0.02456297f, -0.05013122f, 
    -0.01772956f, -0.00825878f, 0.01256130f, 0.03945700f, -0.04123100f, -0.03138595f, 0.00617993f, 0.01828733f, 
    -0.03777597f, -0.03043104f, -0.02645287f, 0.00054726f, 0.05116693f, -0.05209817f, -0.02665560f, -0.03201590f, 
    0.00773926f, 0.01937654f, 0.03414220f, -0.04791914f, -0.00186280f, -0.04662457f, 0.00293557f, -0.02649985f, 
    0.03787806f, 0.01242565f, -0.05787588f, -0.05376076f, 0.01262397f, 0.00321981f, 0.03257154f, 0.00396570f, 
    -0.03900396f, -0.04824697f, 0.00610532f, 0.04747942f, 0.03435690f, -0.02419191f, 0.04718973f, 0.04332107f, 
    -0.00013645f, 0.00073371f, -0.05165675f, -0.02690491f, -0.05942670f, -0.03652718f, -0.06164526f, -0.00080911f, 
    0.00441197f, 0.03087187f, 0.04371212f, -0.00673719f, -0.00016516f, -0.04935590f, 0.04637308f, 0.03951794f, 
    -0.00783727f, -0.04678291f, 0.04797840f, 0.00832000f, -0.02170430f, 0.03003608f, 0.03732425f, -0.00245246f, 
    -0.05467060f, 0.01339274f, -0.00019394f, -0.01495812f, -0.01622727f, 0.04399582f, -0.01461963f, -0.03166660f, 
    -0.04388274f, -0.04292332f, -0.01899204f, -0.03849859f, 0.02190196f, 0.04723958f, 0.01626028f, -0.05707248f, 
    0.01745971f, 0.03668104f, -0.01117034f, 0.01189849f, 0.00263147f, 0.03533796f, -0.05147230f, -0.03508625f, 
    0.02956625f, -0.00570108f, -0.02362625f, 0.02378324f, -0.03869863f, 0.04112532f, -0.05510707f, -0.03752340f, 
    0.03586740f, 0.04777925f, -0.04447087f, -0.06038041f, -0.04340775f, -0.00332108f, -0.03555833f, 0.02235225f, 
    0.04187123f, -0.06153996f, -0.00970285f, -0.04699262f, -0.04767265f, 0.02671000f, -0.03327296f, -0.04741903f, 
    -0.01868968f, 0.01766747f, -0.04648876f, 0.02690502f, -0.00907517f, -0.03855280f, -0.02408478f, 0.03385806f, 
    0.43983874f, 0.18872753f, -0.14262809f, 0.13662715f, 0.11170035f, 0.31247130f, 0.05810418f, 0.05537762f, 
    0.10670495f, 0.06552435f, 0.13877155f, 0.08638114f, 0.00862068f, 0.10554266f, -0.07384558f, 0.16383098f, 
    0.00886209f, -0.03087668f, -0.07116760f, -0.17772169f, -0.33715391f, 0.06476317f, -0.01199649f, -0.11323369f, 
    -0.03535734f, 0.01887282f, 0.01958257f, 0.10644528f, 0.09240258f, 0.07553868f, 0.02239629f, -0.08841927f, 
    0.00311402f, 0.00774820f, -0.07582447f, 0.00990526f, 0.00092308f, -0.06542575f, -0.03390575f, 0.14120853f, 
    0.46652260f, -0.48086888f, -0.11691936f, -0.09221670f, -0.08288552f, -0.03047589f, 0.12122875f, -0.04773116f, 
    0.06475004f, 0.04985610f, -0.15265904f, 0.02120808f, -0.04825472f, -0.11465367f, -0.19447437f, 0.08713673f, 
    -0.12025341f, -0.05582104f, 0.01422524f, 0.06306735f, 0.24396464f, 0.20503277f, -0.12571456f, -0.08415528f, 
    0.01224380f, 0.13024822f, 0.09018897f, -0.07059763f, 0.03565490f, -0.04133372f, -0.09223901f, -0.04153435f, 
    0.10896145f, 0.10726403f, -0.13832550f, -0.02115508f, 0.10685596f, -0.05081609f, -0.07753843f, -0.01156081f, 
    0.17089103f, -0.03874098f, 0.13230532f, -0.09739138f, -0.32489178f, 0.04670971f, -0.00645718f, 0.01377730f, 
    -0.02125645f, -0.10020726f, -0.10904387f, 0.03074193f, -0.12890410f, 0.03950522f, 0.11145069f, 0.13130261f, 
    -0.02837987f, 0.04510112f, -0.04386434f, -0.05034052f, 0.36973003f, 0.05371108f, 0.01500899f, 0.16268742f, 
    -0.21140103f, 0.00891281f, 0.00545790f, -0.10382383f, 0.05963849f, -0.10494164f, 0.02057166f, 0.17505111f, 
    -0.17615992f, 0.13964741f, -0.13000003f, 0.11224383f, 0.06056439f, -0.11628414f, -0.03764549f, 0.01387088f, 
    0.30088285f, 0.32407352f, 0.12363006f, 0.21930972f, 0.04053542f, -0.04620097f, -0.11874519f, 0.01238803f, 
    -0.05016012f, 0.02781698f, -0.02150742f, -0.02994006f, 0.00415398f, 0.00234402f, -0.10522497f, -0.01789442f, 
    -0.00336687f, 0.00852407f, 0.03678482f, 0.00697919f, 0.26071683f, 0.10406596f, 0.09810445f, -0.03369140f, 
    0.23763840f, -0.01754832f, 0.20601706f, -0.03858490f, 0.07705127f, 0.06699779f, 0.21084942f, -0.11733198f, 
    0.09964625f, 0.17145245f, -0.02526193f, -0.00086769f, 0.15151401f, -0.01546417f, 0.03876286f, -0.00797336f, 
    0.18107098f, 0.23777831f, 0.15338893f, -0.18100485f, 0.27707139f, -0.02041136f, -0.02730621f, -0.01779201f, 
    0.07387058f, 0.07300360f, -0.06874783f, -0.04339693f, 0.00773819f, -0.04286063f, 0.09501217f, 0.09028393f, 
    0.03117368f, 0.12454124f, -0.07664491f, -0.01687704f, 0.34630546f, 0.24172637f, -0.16069271f, 0.07692364f, 
    -0.04452766f, -0.16220778f, 0.11506391f, -0.07160388f, 0.02449688f, -0.05958266f, -0.12436353f, -0.16153832f, 
    -0.00248977f, 0.03821949f, 0.14435710f, -0.12020268f, 0.11955382f, -0.00233654f, 0.02422682f, 0.04630213f, 
    -0.02224458f, 0.17344131f, 0.29878995f, -0.07250020f, 0.03226314f, -0.03191256f, -0.08343290f, 0.06022250f, 
    -0.02443913f, 0.05691347f, -0.10037865f, 0.01923540f, -0.00335716f, -0.00259058f, 0.00111464f, 0.13370869f, 
    0.06205440f, 0.00848216f, 0.12798926f, -0.10246056f, -0.47708917f, -0.19841409f, -0.03242936f, -0.10258216f, 
    0.20001471f, 0.02487889f, 0.21296299f, -0.14870451f, 0.01763886f, 0.02280415f, -0.04553988f, 0.04591744f, 
    0.12085468f, -0.03829198f, -0.16404834f, 0.11811139f, -0.11031968f, 0.03337948f, -0.01551976f, 0.14005895f, 
    -0.11985599f, -0.21337575f, -0.23402998f, 0.19654530f, -0.09349558f, -0.07532863f, 0.06843124f, -0.08882496f, 
    -0.18634038f, 0.07758205f, -0.12445688f, 0.14293472f, 0.03890667f, -0.04082363f, 0.04462203f, 0.06224773f, 
    -0.08660002f, 0.01451643f, -0.10636591f, 0.01355076f, 0.12596756f, 0.11854543f, -0.27814382f, 0.16223936f, 
    0.37491792f, 0.24935924f, -0.04331553f, -0.15803945f, 0.10069414f, 0.08067581f, 0.09432689f, 0.05677773f, 
    0.07801199f, 0.02158839f, 0.03296760f, 0.00875946f, -0.14738517f, -0.10585158f, 0.02024642f, 0.04179704f, 
    0.40512648f, 0.06292802f, 0.33212307f, -0.11004581f, 0.18174873f, -0.11017806f, -0.02179262f, 0.20277926f, 
    -0.06785063f, -0.09236746f, 0.08506384f, -0.02772329f, 0.09352277f, 0.01504665f, 0.07994357f, 0.03887262f, 
    0.10156550f, 0.05386120f, -0.16084349f, 0.04856722f, -0.39465532f, 0.15623625f, -0.33595726f, -0.16550472f, 
    0.33547887f, -0.03904570f, -0.02740362f, -0.15765257f, -0.04864214f, -0.12955283f, 0.02568839f, 0.12154697f, 
    -0.04455776f, -0.11890253f, 0.03818403f, 0.04747080f, 0.03376479f, 0.06583443f, 0.09656807f, -0.00399368f, 
    -0.42275503f, -0.30918139f, 0.20447668f, -0.15995154f, -0.07763305f, 0.03834293f, -0.12436333f, 0.02017559f, 
    0.08052547f, -0.09200643f, -0.07823003f, -0.00669452f, -0.13655542f, -0.21337256f, -0.08134805f, -0.02327366f, 
    0.07350612f, -0.17125399f, 0.12197635f, 0.01389561f, -0.01361727f, 0.12101676f, -0.13354601f, 0.19051158f, 
    0.22719653f, 0.15166026f, 0.03360781f, 0.04973383f, -0.13962153f, 0.07727558f, 0.07180431f, 0.06167061f, 
    -0.07640758f, -0.22001745f, -0.23268054f, 0.11889867f, -0.02332654f, 0.17880405f, 0.26109165f, 0.07880776f, 
    -0.07531539f, 0.12121636f, 0.17018147f, 0.05851930f, 0.25924170f, -0.09854278f, -0.02589874f, -0.07952173f, 
    -0.05817221f, -0.05779023f, 0.03728186f, 0.05638716f, 0.04395877f, 0.16922934f, 0.02719778f, -0.03975698f, 
    -0.06055458f, 0.12346042f, -0.06716783f, 0.15877186f, 0.03568259f, 0.07560753f, 0.18795127f, -0.05334175f, 
    0.27289420f, -0.15650719f, -0.05781744f, -0.06092383f, 0.12991305f, 0.02833385f, 0.05822586f, -0.01021282f, 
    -0.03453591f, -0.12249032f, -0.18150038f, 0.03393321f, -0.13821170f, 0.15930408f, -0.03811467f, 0.12923743f, 
    0.04919125f, -0.23464844f, 0.16293541f, 0.20960920f, 0.28024581f, 0.10098588f, 0.05295203f, 0.10454833f, 
    0.05297290f, -0.12190599f, 0.03174707f, -0.09607091f, -0.02978973f, -0.01219290f, -0.00955340f, -0.11550998f, 
    0.02924785f, -0.07079482f, 0.12438208f, -0.05584580f, -0.57856137f, -0.17148881f, -0.06684370f, 0.13841397f, 
    0.07873698f, -0.04834690f, 0.08414205f, -0.13518530f, 0.07254034f, 0.03315419f, -0.03780317f, 0.10963465f, 
    0.26257536f, -0.02766434f, -0.09661102f, -0.00812185f, -0.00340305f, 0.00515050f, -0.02428609f, -0.10015561f, 
    -0.50039142f, -0.33649415f, -0.28496328f, 0.03066962f, -0.12915465f, -0.09415258f, -0.19818367f, 0.04805452f, 
    0.07970239f, -0.09160867f, 0.05620196f, 0.16807459f, 0.00497184f, 0.00807196f, 0.06130397f, -0.08366499f, 
    -0.07668073f, -0.07944571f, -0.10700479f, -0.14890435f, 0.33156529f, 0.01065310f, -0.11903780f, 0.01015586f, 
    0.05859419f, -0.04959541f, 0.24859577f, 0.05061217f, 0.00509127f, -0.08474489f, -0.19152747f, 0.00248171f, 
    -0.04739509f, 0.02561408f, 0.04301678f, 0.05006139f, -0.08616257f, 0.19527331f, 0.02264031f, 0.08270039f, 
    0.20584287f, 0.26065505f, 0.17858350f, 0.03887543f, 0.15857171f, -0.04088165f, 0.16331509f, -0.12149853f, 
    -0.06002149f, -0.04450459f, 0.06116344f, 0.00458713f, 0.01399383f, 0.02524795f, -0.07673374f, 0.00943846f, 
    0.04451828f, 0.10521008f, 0.04987304f, -0.01555781f, -0.32428595f, 0.40444455f, -0.21599300f, 0.11713547f, 
    -0.16247179f, -0.10827838f, -0.04833759f, 0.05808063f, 0.19419573f, 0.05691992f, 0.01753073f, 0.05026571f, 
    -0.08860912f, -0.10142961f, -0.07679098f, 0.19271885f, 0.02563227f, 0.20021945f, -0.04184749f, 0.11904979f, 
    -0.10581951f, -0.05547071f, 0.09013825f, 0.19809301f, 0.09910788f, -0.06139419f, 0.02749993f, 0.02835249f, 
    -0.16723913f, -0.11289680f, 0.11309936f, 0.01096250f, 0.11147167f, 0.09666575f, 0.22037287f, -0.20943861f, 
    0.00586652f, 0.06013720f, 0.07903645f, -0.21122915f, 0.93230003f, 0.02934513f, 0.32088545f, 0.33384979f, 
    0.14308250f, 0.35550585f, -0.09856014f, 0.08866891f, 0.08730540f, 0.04865246f, 0.05532707f, 0.02375250f, 
    -0.04667551f, 0.10098182f, -0.01754408f, -0.01001840f, 0.17296684f, -0.10421415f, 0.02198960f, 0.15739036f, 
    0.03115374f, -0.11200887f, 0.28482780f, -0.07265536f, -0.16724229f, -0.00906587f, 0.00663301f, 0.01481000f, 
    0.10815064f, -0.03161075f, -0.10849392f, 0.07788230f, 0.22648659f, 0.08446125f, -0.03109319f, -0.10809024f, 
    0.03343772f, -0.02349944f, 0.11263108f, -0.04308852f, 0.41700071f, 0.30517650f, 0.23120019f, 0.25375846f, 
    0.16148409f, -0.04589267f, 0.05884409f, 0.04163162f, 0.20527831f, -0.13532782f, 0.01521939f, 0.04255898f, 
    -0.06083778f, 0.02231378f, -0.00603578f, -0.01695325f, -0.02086665f, 0.32668751f, 0.07424252f, -0.01667135f, 
    0.17860605f, 0.30599648f, 0.15990987f, -0.18853232f, 0.18657443f, -0.10047111f, -0.01380470f, -0.05662923f, 
    -0.11854487f, 0.04527047f, -0.00320122f, -0.11520872f, 0.04425209f, -0.12307768f, -0.00400847f, 0.01081853f, 
    -0.00523266f, -0.03980097f, 0.14297652f, 0.05083682f, 0.36023748f, 0.31138536f, -0.04170763f, 0.15746745f, 
    -0.18850325f, -0.02357667f, -0.10550322f, 0.17139770f, 0.11738915f, 0.00944101f, -0.07265347f, -0.00830195f, 
    0.15949988f, 0.11405921f, -0.07134424f, 0.00292588f, -0.03967819f, -0.00659237f, 0.01448832f, 0.01745477f, 
    -0.26041171f, 0.24697606f, 0.18640561f, 0.31767163f, 0.06697432f, -0.13753727f, -0.11586772f, 0.06011960f, 
    0.00069979f, -0.17830618f, -0.00697355f, -0.09451304f, 0.07607033f, 0.02201935f, 0.11789659f, 0.04580523f, 
    0.04301612f, -0.06569591f, -0.00618629f, -0.08841412f, 0.00697071f, 0.16299893f, -0.02793351f, 0.46531916f, 
    0.32740754f, 0.10686723f, 0.03692802f, -0.00467380f, -0.16186275f, 0.06453771f, -0.13817294f, -0.00758268f, 
    -0.06255323f, 0.03941795f, 0.17690113f, -0.14815050f, -0.00805670f, 0.07631686f, 0.04609440f, -0.00440116f, 
    -0.05680904f, -0.20073551f, -0.42062071f, -0.42578930f, 0.07780915f, 0.02123060f, 0.13680983f, -0.04172593f, 
    0.07187936f, -0.01112118f, 0.07758252f, 0.09155854f, 0.07580174f, 0.03034290f, 0.07973258f, 0.11252679f, 
    0.17886774f, 0.01587856f, -0.04055986f, 0.05787898f, -0.23475739f, 0.12079451f, -0.16657761f, 0.11613881f, 
    0.18121569f, 0.06240228f, 0.08467961f, -0.01857150f, 0.01844641f, 0.12417550f, 0.03667734f, 0.09813683f, 
    0.04752538f, 0.02336375f, 0.16240492f, -0.08469418f, -0.02008217f, 0.13264601f, -0.04698783f, 0.15182674f, 
    -0.10792624f, -0.54203898f, -0.01861629f, 0.24932297f, -0.19808654f, 0.19972222f, 0.13642624f, 0.03887046f, 
    0.06570853f, -0.05655967f, -0.05784435f, 0.01935287f, -0.06456874f, -0.00164415f, 0.08827499f, -0.03722300f, 
    0.00853443f, 0.03638792f, 0.12058835f, 0.09944297f, 0.22883525f, -0.26414669f, 0.07282834f, -0.08169742f, 
    0.13019130f, -0.23089744f, -0.09468112f, -0.00841684f, 0.02615574f, 0.04602559f, -0.03532558f, 0.10245388f, 
    -0.07873458f, -0.04956902f, -0.02696731f, 0.01567986f, 0.06799092f, -0.13649657f, 0.04279257f, -0.08952209f, 
    -0.42924953f, 0.15275246f, 0.18833049f, 0.37210307f, -0.01784832f, -0.12446383f, -0.16067159f, -0.07902408f, 
    0.12626785f, -0.17225957f, 0.05221860f, -0.06975776f, -0.05735259f, -0.26334023f, 0.03497584f, -0.03813491f, 
    0.02792588f, -0.05996354f, -0.18017061f, -0.03082168f, -0.35915923f, -0.11056100f, -0.24900092f, 0.06293523f, 
    -0.03312447f, -0.00379571f, 0.29586604f, 0.01643017f, 0.04934749f, 0.04907404f, 0.04533949f, 0.01270946f, 
    -0.08455242f, 0.05300894f, -0.09512606f, -0.03363232f, -0.10498728f, -0.04833612f, -0.03933709f, 0.04033188f, 
    0.48292741f, -0.10599266f, 0.19372445f, -0.07339139f, 0.15247278f, -0.04775163f, -0.00497082f, -0.07400531f, 
    -0.01632661f, 0.10842816f, 0.01040647f, -0.01252701f, 0.05895987f, -0.05556249f, -0.19176592f, 0.04528033f, 
    -0.15652746f, -0.06262108f, 0.14027758f, 0.17736357f, 0.16929436f, -0.03843089f, -0.02650100f, 0.22668564f, 
    0.19829364f, -0.12558682f, -0.07073110f, 0.04829423f, 0.04700270f, -0.09002504f, 0.00032630f, -0.09030499f, 
    0.05615863f, 0.07291902f, -0.03769211f, 0.03654401f, 0.00184331f, -0.06702946f, -0.06080009f, -0.00271592f, 
    -0.11454695f, -0.04887901f, -0.04062002f, 0.02041559f, 0.26558670f, 0.03151953f, 0.04687145f, -0.01912035f, 
    -0.10813779f, -0.05104920f, 0.07798704f, -0.02526507f, 0.10570159f, 0.17936625f, -0.09615009f, -0.08366138f, 
    -0.05909433f, -0.03278182f, 0.04753454f, 0.00628299f, -0.07038838f, 0.06801035f, 0.29904941f, 0.08342624f, 
    -0.57444918f, 0.19340792f, -0.07654548f, 0.02194646f, 0.00156860f, -0.07174506f, -0.10705112f, 0.00571226f, 
    -0.12172747f, -0.09539464f, -0.14775495f, -0.03939033f, 0.15252566f, 0.08820122f, 0.04535349f, -0.00940096f, 
    -0.42486870f, 0.03988905f, -0.02608829f, -0.35041818f, -0.34478003f, 0.10711376f, 0.04373513f, 0.24847832f, 
    0.02506435f, -0.15784773f, 0.00591324f, 0.02181215f, 0.11004639f, 0.08977370f, 0.08410880f, 0.11071859f, 
    0.06092263f, -0.14941268f, 0.10578806f, -0.14063314f, 0.33864018f, 0.33225653f, 0.17472076f, 0.38425595f, 
    -0.04610698f, -0.12982740f, 0.10864557f, -0.06965028f, 0.06409197f, 0.08575346f, -0.13006842f, 0.09276351f, 
    -0.19600821f, -0.00567609f, -0.08240632f, -0.05977365f, -0.00699431f, -0.17025803f, -0.00186464f, 0.04144467f, 
    -0.41361815f, 0.10022268f, -0.08425380f, -0.03939766f, 0.29732448f, 0.28506932f, -0.03151210f, 0.01287124f, 
    0.11895626f, 0.06319317f, -0.06709552f, 0.05874012f, 0.09019859f, -0.13534947f, -0.12253347f, -0.03683894f, 
    0.13760975f, 0.13210024f, 0.05600817f, 0.07590231f, 0.27396065f, 0.49483517f, 0.16216527f, 0.16394359f, 
    -0.04380163f, -0.07556194f, 0.01219104f, 0.17486481f, 0.01624370f, 0.22580610f, 0.12818934f, -0.08321109f, 
    0.16972473f, -0.00644174f, -0.11653095f, -0.07974304f, -0.14242578f, 0.06151626f, 0.08881477f, 0.07136738f, 
    -0.05141497f, -0.02463517f, -0.04803949f, -0.00920897f, -0.03050604f, -0.00928265f, 0.02061696f, 0.00370493f, 
    -0.02923682f, -0.03081489f, -0.03838384f, 0.01991273f, 0.04530010f, 0.03422352f, -0.02579533f, 0.01449906f, 
    -0.03087240f, 0.00389598f, 0.04501742f, 0.00115242f, -0.04857725f, -0.01706429f, 0.00158934f, -0.03868204f, 
    -0.04436695f, -0.02564271f, -0.02524657f, -0.04743153f, 0.01274840f, -0.04211642f, 0.01196736f, -0.02501792f, 
    -0.00228024f, -0.01165200f, 0.02418425f, 0.05431377f, -0.05423527f, -0.04669543f, -0.03320910f, -0.01468857f, 
    0.05730051f, -0.05857230f, 0.00899696f, 0.05362114f, -0.01815033f, 0.00977917f, -0.04099921f, -0.05218824f, 
    0.04633644f, -0.01309595f, 0.02478033f, -0.00821090f, 0.03408271f, 0.04929382f, -0.01711822f, -0.01094871f, 
    -0.00177180f, 0.02776432f, 0.01019624f, -0.04922746f, -0.01771485f, 0.05698308f, -0.04148322f, 0.02542733f, 
    0.04889416f, -0.04341782f, -0.02101001f, -0.04521497f, 0.00816739f, -0.02222629f, -0.01597054f, 0.02518702f, 
    0.03875662f, -0.00459802f, -0.04850227f, -0.02496418f, -0.03871634f, -0.04532519f, -0.04497693f, 0.01331892f, 
    0.03207191f, 0.03510563f, -0.03611557f, -0.02303972f, -0.02001332f, -0.05452355f, -0.02233437f, -0.05352713f, 
    0.00623946f, -0.00359731f, -0.01783042f, -0.01640076f, -0.06665746f, 0.01054207f, -0.01320281f, -0.04810929f, 
    0.04929445f, 0.03907272f, -0.03238818f, -0.03823021f, -0.04720793f, 0.01846228f, -0.01303064f, 0.03372606f, 
    -0.05605810f, -0.01298043f, -0.05345063f, -0.03167532f, -0.04296447f, 0.00491593f, -0.05101651f, 0.02667917f, 
    0.02532615f, 0.01909850f, -0.04587169f, -0.03098099f, -0.00593610f, -0.02205580f, -0.02352393f, -0.06441119f, 
    -0.04143883f, -0.04606758f, 0.01266651f, -0.02930865f, -0.04655807f, 0.02520603f, 0.04798213f, -0.00512355f, 
    0.01204764f, 0.03833927f, 0.00816079f, -0.00398639f, 0.00499776f, -0.02086462f, 0.00594080f, -0.03488091f, 
    -0.00353778f, -0.03883623f, -0.02992659f, -0.06689342f, 0.00921583f, 0.00808690f, -0.04960096f, 0.02811471f, 
    -0.01709106f, 0.02900787f, 0.01733353f, -0.01524547f, -0.01756731f, -0.00963531f, 0.02387342f, -0.01220586f, 
    -0.02086698f, 0.03210262f, -0.04792958f, 0.01256317f, -0.05100819f, -0.01345760f, 0.00200145f, -0.00448050f, 
    -0.03324080f, -0.03237306f, -0.05390362f, 0.05283727f, -0.01208964f, 0.03138131f, 0.01251274f, 0.01984819f, 
    0.01868392f, 0.00921535f, -0.01527493f, 0.02341186f, 0.03545781f, -0.00556646f, -0.03877958f, 0.02454982f, 
    -0.00500152f, -0.02967492f, -0.00256694f, -0.04055418f, -0.00882103f, 0.00503509f, 0.03088098f, 0.05214803f, 
    0.01657546f, -0.01051241f, -0.00506155f, -0.03292149f, 0.05148674f, -0.05701746f, 0.01144000f, 0.02378503f, 
    0.04965514f, 0.01223459f, -0.04460840f, -0.00920224f, -0.04035457f, -0.04545016f, -0.01797349f, -0.04100813f, 
    0.01857987f, 0.04634647f, 0.00164813f, -0.04800819f, 0.05280362f, -0.02544971f, -0.01728863f, -0.00676957f, 
    0.02099247f, 0.04016168f, -0.01661892f, -0.03307590f, 0.03634705f, -0.00046500f, -0.05689422f, 0.00296611f, 
    -0.03755282f, 0.00503911f, 0.04825003f, 0.05311656f, -0.01182441f, 0.02694322f, 0.01453712f, -0.03946488f, 
    -0.03469354f, 0.04286656f, -0.04329289f, -0.03446164f, -0.04249243f, -0.04376792f, 0.02437167f, 0.03560342f, 
    0.05149579f, 0.03735293f, 0.01607570f, -0.04889897f, -0.01493891f, -0.04373176f, -0.01920847f, -0.05215155f, 
    0.00539337f, 0.02811615f, -0.00345290f, 0.03897959f, 0.01463865f, -0.02076524f, -0.04552281f, 0.03973827f, 
    -0.02416393f, -0.01773162f, -0.02588770f, -0.03799025f, -0.05077118f, 0.02579164f, -0.01155045f, -0.05260274f, 
    -0.00119582f, -0.05067866f, -0.05570186f, 0.00354285f, -0.00904404f, 0.02290766f, -0.05005147f, 0.05132806f, 
    -0.02542982f, -0.03953112f, 0.00982020f, 0.02366948f, 0.04439149f, 0.03820837f, -0.01274369f, 0.00079410f, 
    0.02677977f, -0.04403402f, 0.01341146f, 0.01467253f, -0.01199934f, 0.02393969f, 0.05288704f, 0.02739011f, 
    0.03558374f, 0.03646139f, 0.03386382f, -0.03607341f, 0.03589861f, 0.03765178f, -0.05967763f, -0.04543076f, 
    0.04080485f, -0.05496957f, -0.00398154f, 0.00490131f, -0.05358745f, 0.00583340f, 0.03111976f, 0.03197490f, 
    0.01033851f, 0.02133039f, -0.00580937f, -0.05059045f, -0.03121925f, -0.02600090f, -0.03216825f, 0.01977054f, 
    -0.03930793f, 0.04383925f, -0.04115640f, -0.03305956f, 0.04490681f, -0.04957904f, -0.00035009f, -0.04210348f, 
    0.03432558f, 0.02742846f, -0.04915752f, 0.05100856f, 0.02696645f, -0.03976522f, 0.04416717f, -0.01759953f, 
    -0.02251689f, -0.03908723f, -0.05472422f, 0.04606876f, -0.02585062f, -0.02156496f, -0.00463600f, -0.04436053f, 
    -0.05938635f, 0.02994833f, -0.01670926f, -0.04790555f, -0.03592306f, 0.01834324f, -0.02878274f, -0.04595656f, 
    -0.04724874f, -0.00093867f, 0.04712754f, 0.00304404f, -0.02818645f, 0.00644950f, 0.00983736f, 0.00473054f, 
    0.00223874f, -0.03722046f, -0.04796283f, -0.02448687f, -0.00887248f, 0.03647596f, 0.00168955f, -0.03787709f, 
    -0.01018222f, -0.01259428f, -0.03997359f, 0.04077824f, 0.04291790f, 0.04695279f, 0.02875731f, -0.03804756f, 
    0.01547317f, -0.00259283f, 0.03530322f, -0.02663521f, 0.02222271f, -0.05467967f, 0.02365370f, -0.00312908f, 
    0.01684626f, -0.02209979f, 0.03194774f, -0.04695561f, 0.03376013f, 0.00285937f, -0.03882130f, -0.01159005f, 
    0.03247470f, -0.02437135f, 0.02763205f, 0.02030061f, 0.01693412f, -0.02756494f, -0.03580970f, 0.03056601f, 
    -0.06143378f, -0.01323251f, 0.03692303f, 0.00865648f, 0.01631706f, -0.05640527f, 0.00889485f, -0.05485843f, 
    0.01379915f, 0.01729507f, -0.04937463f, -0.01469299f, -0.05866444f, -0.04668028f, -0.03604032f, -0.00611570f, 
    -0.06167801f, -0.04368315f, -0.05483376f, -0.03731350f, -0.01380697f, -0.06096861f, -0.04658246f, 0.01843223f, 
    0.03449224f, -0.04892498f, -0.00758530f, 0.00041208f, -0.03161667f, -0.04389130f, -0.03622407f, -0.00533001f, 
    -0.01775557f, 0.00181244f, -0.00620719f, -0.03494037f, -0.05318298f, -0.00196104f, -0.04104767f, 0.00402378f, 
    -0.02735555f, -0.03604090f, -0.00414216f, 0.02945126f, 0.04982563f, 0.01628582f, -0.03526384f, -0.01546622f, 
    -0.04860951f, 0.02127957f, -0.03834193f, 0.01647216f, -0.05137222f, -0.05257985f, 0.03753120f, -0.03874137f, 
    0.02223480f, -0.04094100f, -0.06186484f, 0.03720906f, -0.00967918f, -0.04145007f, -0.03905988f, -0.02880015f, 
    -0.00795899f, 0.01302695f, 0.00224324f, 0.01991030f, 0.02901996f, 0.04819382f, 0.01092859f, -0.02756554f, 
    -0.04532410f, -0.02264653f, -0.05806008f, 0.03410567f, 0.03321074f, 0.01716436f, 0.03400801f, -0.01497382f, 
    -0.02459622f, -0.00551811f, 0.04483193f, 0.03050311f, -0.05839147f, -0.00960894f, -0.02846211f, -0.01234913f, 
    -0.02203546f, 0.03579442f, -0.04700909f, -0.05058237f, -0.00332892f, -0.01140685f, 0.04396267f, 0.02996760f, 
    0.00021364f, 0.04514262f, -0.01076415f, 0.01970871f, -0.05249181f, -0.05736002f, -0.02182517f, -0.02088075f, 
    -0.04688048f, -0.03192040f, -0.04186895f, 0.03091740f, -0.01568433f, -0.00392930f, 0.03977306f, -0.03879598f, 
    0.04949623f, 0.02202097f, -0.01360118f, -0.02093526f, -0.01743725f, -0.01094683f, 0.03098742f, 0.01036091f, 
    -0.02208891f, 0.01543495f, -0.03038043f, -0.04034056f, -0.03704356f, 0.02617021f, -0.05984181f, -0.00905623f, 
    -0.04381185f, 0.03206502f, -0.03182707f, -0.01945707f, 0.01608352f, -0.04281705f, -0.02239599f, -0.05150206f, 
    -0.02819518f, -0.03358357f, -0.05461982f, 0.02990459f, 0.03357170f, -0.02622347f, -0.03640647f, 0.01704259f, 
    0.03033826f, -0.02014196f, -0.01680747f, -0.03593421f, 0.03389974f, 0.00162235f, 0.04097791f, -0.04938720f, 
    -0.03676195f, -0.00977619f, -0.05790804f, -0.04465824f, 0.03873132f, -0.05647298f, 0.00743287f, -0.04933402f, 
    0.04678322f, -0.04830730f, 0.02669644f, -0.02709043f, 0.02220051f, -0.03026960f, -0.04540872f, -0.02526344f, 
    -0.01183432f, 0.04243584f, -0.04141235f, -0.02340697f, -0.00422850f, 0.04060500f, 0.02084890f, 0.00723361f, 
    0.00423855f, 0.04985370f, -0.03111786f, 0.04836432f, -0.04859712f, -0.01563108f, -0.06159143f, -0.02253533f, 
    -0.01541068f, 0.01870200f, -0.01128913f, -0.01600631f, 0.02109232f, -0.02823656f, -0.02637244f, 0.03709882f, 
    -0.00284272f, 0.02194681f, 0.01900382f, -0.02643038f, 0.02314379f, -0.03320067f, 0.03309979f, -0.04029465f, 
    0.02569918f, 0.03914915f, -0.04407525f, 0.04219078f, 0.01957145f, -0.03149843f, -0.00043888f, 0.00053536f, 
    0.02856316f, -0.05635796f, 0.02350149f, 0.00991904f, -0.02542724f, -0.03462205f, -0.02491803f, 0.03583322f, 
    -0.03883684f, -0.03816688f, -0.01852638f, -0.00264590f, 0.02761603f, -0.04926913f, -0.06013404f, 0.04167344f, 
    0.02880177f, 0.02312589f, 0.02980286f, -0.03537640f, -0.00181017f, -0.01467347f, -0.01718740f, 0.03736927f, 
    0.04862164f, -0.05308054f, -0.01750135f, 0.01510214f, 0.00336608f, 0.00311732f, 0.04382952f, -0.03494924f, 
    0.02068729f, -0.01411038f, 0.03171583f, -0.05457573f, 0.00973567f, 0.02323949f, -0.00436113f, -0.05045718f, 
    -0.06180473f, 0.04183776f, 0.01140327f, -0.01506355f, -0.04376069f, 0.01026750f, -0.02079440f, -0.03250408f, 
    -0.92806381f, 0.13044718f, 0.07659432f, 0.19709091f, 0.01417164f, 0.07641091f, 0.12924094f, 0.14438306f, 
    -0.01053284f, -0.02146942f, 0.12064832f, 0.05220338f, -0.05015485f, 0.14147025f, 0.01680676f, 0.15701403f, 
    0.08002970f, -0.00322076f, -0.01360087f, 0.03487922f, 0.00296264f, 0.18530452f, 0.29073954f, 0.14469369f, 
    -0.24941958f, 0.08135530f, 0.11820813f, 0.02319398f, -0.06504075f, 0.06525141f, 0.04586697f, 0.01628437f, 
    0.05897233f, -0.04012565f, -0.09702056f, 0.02970298f, -0.06975105f, 0.01275210f, -0.05118157f, -0.06669785f, 
    -0.07509668f, 0.04908011f, -0.08097982f, -0.02137424f, -0.02940705f, -0.10607783f, -0.06893948f, -0.00954428f, 
    0.09717599f, -0.02659342f, -0.07526882f, 0.00931415f, -0.04777429f, 0.08644566f, 0.16333525f, 0.09498451f, 
    -0.08233605f, 0.03095710f, 0.03836282f, 0.05245136f, -0.06294182f, 0.20214042f, 0.04323780f, -0.12045559f, 
    -0.10187253f, -0.02733070f, -0.04998390f, -0.10637546f, 0.03390235f, 0.10006603f, 0.13805754f, -0.02339442f, 
    0.03951966f, 0.15333831f, 0.01149026f, -0.03372521f, -0.02378467f, 0.00428889f, -0.06595601f, 0.12104526f, 
    0.37739760f, -0.26487768f, 0.00180958f, -0.25208899f, -0.04415435f, -0.04268445f, -0.01659982f, 0.04268234f, 
    0.04430420f, -0.05885099f, -0.05970234f, 0.11609630f, 0.02047588f, -0.05813183f, -0.01284213f, -0.06767492f, 
    0.05637467f, -0.09710311f, 0.03833865f, 0.09461810f, 0.53933614f, -0.32041156f, -0.06915361f, -0.12707175f, 
    0.05424994f, -0.12629604f, -0.00489227f, 0.05756276f, 0.03360242f, 0.06253236f, 0.14857608f, -0.04665574f, 
    -0.09502190f, -0.02057227f, -0.07992605f, -0.02949475f, 0.05393744f, 0.04305578f, 0.10891040f, -0.05945431f, 
    -0.58468890f, 0.02320632f, -0.00742381f, 0.04956617f, 0.13410828f, -0.06041399f, 0.03192575f, -0.14908381f, 
    0.09710950f, 0.09305702f, 0.02759712f, -0.10074116f, 0.08601186f, -0.05866373f, 0.06383550f, 0.11282586f, 
    -0.05552436f, 0.02090974f, 0.06936339f, 0.12675889f, -0.78651595f, 0.36422855f, 0.12105987f, 0.05978016f, 
    0.21548061f, 0.02031163f, 0.08406703f, 0.00317605f, -0.03433549f, 0.11105636f, 0.02875392f, 0.00644365f, 
    -0.09154574f, -0.08415205f, 0.08411229f, -0.05061943f, -0.00914151f, -0.02829387f, 0.11396737f, 0.06462800f, 
    0.35067996f, 0.09663875f, -0.11656828f, 0.05847795f, -0.11475509f, -0.04160982f, 0.05381337f, -0.00322890f, 
    0.00038064f, 0.01297288f, 0.04579594f, -0.15269853f, 0.05509935f, -0.03663599f, -0.04316005f, 0.09062968f, 
    0.01423305f, -0.11106531f, 0.13340273f, 0.11896247f, -0.32244489f, -0.31568748f, 0.16974145f, 0.05129064f, 
    -0.20812632f, 0.11434709f, 0.05448234f, 0.04185685f, -0.03061291f, 0.06468362f, 0.08049272f, -0.13593085f, 
    0.03620188f, 0.01457497f, 0.00253740f, -0.23310652f, -0.00393293f, -0.10591391f, -0.09555183f, -0.03382646f, 
    0.30489048f, 0.12828507f, 0.08706515f, -0.02552542f, 0.08494971f, 0.08638800f, 0.15614794f, 0.07938518f, 
    0.18269247f, 0.05162390f, -0.08114015f, 0.03066695f, 0.02775900f, 0.04008812f, -0.04560529f, 0.03112904f, 
    0.02972000f, 0.02353476f, 0.17005062f, -0.01612046f, 0.08987672f, 0.42390528f, -0.72822428f, -0.35513493f, 
    -0.05238406f, -0.11910059f, 0.04036885f, 0.13204511f, 0.16725428f, 0.15674293f, 0.06513812f, -0.00767312f, 
    -0.03779414f, -0.07652111f, 0.00965384f, 0.02751153f, -0.06083010f, 0.12168889f, -0.02561687f, -0.08942182f, 
    0.03661996f, -0.05895128f, -0.19209409f, 0.11155283f, 0.25844294f, -0.19653998f, -0.19582139f, 0.01595130f, 
    -0.02859429f, 0.06049531f, 0.04231669f, 0.00989550f, 0.05877781f, 0.02329612f, 0.09072353f, 0.01158740f, 
    0.14934994f, 0.11041137f, -0.00681520f, -0.05518013f, -0.04672209f, -0.19073179f, -0.09943612f, -0.12712006f, 
    -0.21009456f, 0.18204556f, 0.09507131f, 0.01153518f, 0.09053515f, -0.03949637f, 0.05217656f, 0.10651931f, 
    0.13783790f, -0.07430257f, 0.07453727f, 0.03583070f, 0.14025323f, -0.06482774f, 0.11048848f, 0.10917409f, 
    -0.00222756f, 0.02059778f, -0.01649990f, 0.04730492f, 0.07139791f, 0.14281651f, 0.02871586f, -0.01632608f, 
    0.19086930f, 0.11444286f, -0.03627002f, -0.01905706f, 0.00544296f, 0.00317254f, -0.13510804f, 0.02468957f, 
    0.12067006f, 0.03495893f, 0.00563232f, 0.03811301f, 0.18381259f, 0.06709199f, -0.31770501f, 0.06146349f, 
    0.14342226f, 0.01123403f, 0.06780549f, 0.04521273f, 0.04573793f, 0.00896465f, 0.06317602f, 0.00538867f, 
    0.03041678f, -0.04585858f, 0.02754332f, 0.06813335f, -0.10602446f, 0.04925919f, 0.04883016f, 0.08621553f, 
    -0.02632423f, 0.02871172f, -0.05191101f, -0.05245484f, -0.04336736f, 0.01047431f, 0.01411143f, -0.04120132f, 
    0.04850722f, -0.04611890f, -0.05430688f, -0.01459609f, 0.02793552f, 0.04921960f, 0.03019416f, 0.01616763f, 
    0.03993081f, 0.04267458f, -0.04198045f, -0.02112475f, -0.04336348f, 0.04816073f, -0.02563745f, 0.02125347f, 
    -0.02219907f, -0.04412256f, 0.01022874f, -0.02517225f, 0.02196469f, -0.01408176f, -0.03058962f, 0.03397700f, 
    0.01814724f, -0.04935857f, -0.01241981f, -0.02639515f, -0.00440175f, -0.01925891f, -0.02433839f, 0.03137150f, 
    -0.01860728f, -0.03704239f, 0.04470337f, -0.01737154f, -0.03650344f, -0.04196836f, -0.04675620f, 0.00567056f, 
    -0.02939131f, -0.04282523f, -0.00873562f, 0.00030441f, -0.00790456f, -0.02775102f, 0.03223865f, -0.03045187f, 
    0.02371539f, -0.03330913f, -0.03460054f, -0.02214258f, -0.00535035f, -0.05025624f, -0.00252203f, 0.00790808f, 
    0.02530561f, -0.00104272f, -0.00924365f, 0.00817299f, -0.05605241f, -0.02776320f, -0.05482517f, -0.00212893f, 
    0.03260377f, 0.01642178f, 0.02604340f, -0.00692683f, -0.01375621f, -0.02414933f, 0.03388724f, 0.00724001f, 
    -0.00749711f, -0.03570634f, -0.04588406f, -0.05399379f, -0.03754845f, -0.02608879f, -0.00941760f, 0.00569930f, 
    -0.01531345f, -0.01415441f, -0.01606393f, -0.00452464f, -0.04365442f, -0.01701722f, -0.03795042f, -0.02124639f, 
    0.04021528f, 0.02861982f, -0.01925356f, -0.02023763f, -0.02602334f, -0.06187321f, 0.03968813f, -0.03456094f, 
    0.00226223f, -0.03696768f, -0.04535921f, 0.04156465f, -0.04594604f, -0.01613135f, 0.04686122f, -0.01247478f, 
    -0.01367488f, 0.00391843f, -0.03292747f, 0.02478988f, -0.00748272f, -0.01455895f, -0.02178143f, 0.02092194f, 
    0.01951951f, 0.03790241f, -0.05712256f, 0.02119944f, -0.01018884f, -0.03447955f, 0.03536262f, -0.04130096f, 
    0.05202313f, 0.04334164f, -0.03426214f, 0.01353621f, -0.05830762f, 0.02550527f, -0.02214707f, -0.01091304f, 
    -0.05558047f, -0.00283670f, -0.01122454f, -0.01804858f, 0.00340023f, -0.04896818f, -0.03912463f, -0.00413907f, 
    0.04043543f, 0.01356310f, 0.03406325f, 0.04859259f, 0.02719078f, -0.02502724f, 0.03491520f, 0.02957875f, 
    0.04056272f, -0.02366245f, -0.05415227f, -0.01233793f, 0.04491525f, -0.04287682f, 0.03518648f, 0.03071557f, 
    -0.05048982f, -0.03091287f, -0.05074959f, -0.05374258f, -0.02778599f, 0.05002997f, -0.04613434f, 0.03360623f, 
    0.01141722f, -0.00665190f, -0.01340042f, -0.01863013f, -0.02559764f, -0.01182507f, 0.03491393f, -0.00311816f, 
    0.00508620f, 0.00250198f, 0.00491131f, 0.03810707f, 0.02608168f, -0.01684225f, -0.02673728f, -0.01033040f, 
    -0.01574482f, 0.01446808f, 0.04562464f, -0.06301472f, -0.04352511f, -0.04261382f, -0.06903785f, 0.00750473f, 
    -0.01226970f, -0.02830758f, 0.01383227f, -0.03693420f, -0.03011182f, -0.05629173f, 0.04521300f, 0.00924020f, 
    -0.03464109f, 0.01424971f, 0.01751110f, 0.01321661f, -0.00229577f, 0.00124670f, -0.01686960f, -0.02916456f, 
    0.02216878f, -0.01044168f, 0.02062748f, 0.03994931f, 0.01677997f, -0.01403951f, 0.02741612f, -0.03922990f, 
    0.01656528f, 0.01172060f, 0.04611637f, -0.03976133f, 0.05285331f, -0.00222921f, 0.02767307f, 0.03314659f, 
    0.04581127f, -0.01535546f, -0.05703173f, 0.00978308f, -0.00126055f, -0.04795200f, -0.03898010f, 0.00949643f, 
    -0.05206957f, -0.03393549f, -0.00048347f, -0.05817105f, -0.02995676f, -0.05608123f, 0.00871488f, 0.00447633f, 
    -0.05696265f, 0.02828448f, 0.04475149f, 0.00542347f, -0.04551678f, -0.03738271f, -0.04721309f, -0.03284949f, 
    -0.04609277f, 0.01412269f, -0.01452674f, -0.03250735f, 0.04718176f, -0.00825898f, -0.05397924f, 0.01029942f, 
    0.01451742f, -0.03515617f, -0.00751641f, -0.04926749f, 0.02125502f, -0.05013819f, 0.00819352f, 0.01924918f, 
    -0.01121005f, -0.02299678f, -0.02667699f, 0.02789179f, 0.00898748f, 0.00356298f, -0.03229496f, -0.00790510f, 
    -0.01126401f, -0.05952619f, -0.05114833f, -0.03169705f, -0.01519388f, 0.00543430f, -0.05181845f, -0.03971632f, 
    -0.01851462f, -0.02864305f, 0.00508081f, 0.02116341f, -0.01021665f, -0.01947230f, -0.05166637f, -0.01722375f, 
    -0.04872052f, 0.03159560f, -0.05371248f, 0.04122248f, -0.03000708f, -0.01237311f, -0.03909858f, -0.02172376f, 
    0.00519015f, -0.00005441f, -0.03729700f, -0.05534396f, -0.01086035f, 0.00389630f, -0.00208806f, 0.04302324f, 
    -0.05917517f, 0.03741457f, -0.04582550f, 0.01778075f, -0.03244618f, -0.02141641f, -0.00157302f, 0.01914618f, 
    0.03725622f, -0.06129166f, 0.00594582f, 0.04764537f, -0.00310588f, 0.04197583f, -0.00334181f, 0.01064831f, 
    0.02035992f, -0.00906635f, -0.03537688f, 0.00722083f, -0.04286876f, 0.01959475f, 0.03316797f, -0.05388150f, 
    0.04151431f, 0.00835223f, 0.03511179f, -0.03298969f, -0.02312470f, 0.02858111f, -0.01341525f, -0.00504432f, 
    -0.02481646f, 0.01817378f, -0.02136640f, -0.04118143f, -0.02831421f, 0.01875196f, 0.02650852f, -0.00252847f, 
    0.02298363f, -0.05754017f, 0.02876493f, 0.04767084f, -0.00742644f, -0.06094698f, -0.02046341f, -0.03970725f, 
    0.00705659f, 0.03943571f, -0.00897472f, -0.03428185f, 0.04515471f, -0.06032502f, -0.03697122f, 0.03024772f, 
    -0.04346506f, -0.04125265f, -0.00120210f, -0.04843993f, 0.02536463f, 0.00749772f, 0.02292123f, -0.04319533f, 
    0.03923437f, -0.06341898f, 0.04006964f, -0.06667422f, 0.04499020f, -0.00788733f, -0.05536641f, -0.05122034f, 
    0.01858063f, -0.03691653f, 0.00662709f, 0.02940682f, -0.02807544f, -0.04740346f, 0.01197562f, 0.02743323f, 
    -0.04665792f, 0.01084614f, 0.01339884f, -0.02727561f, 0.03434253f, 0.01369272f, 0.04593509f, -0.06155793f, 
    0.02080754f, -0.02035293f, 0.00129011f, -0.03420434f, -0.05071246f, 0.03507620f, 0.04119599f, 0.01239200f, 
    -0.05878105f, 0.00279796f, 0.01842091f, -0.04260117f, 0.04451804f, -0.05046494f, 0.00108451f, -0.02001116f, 
    0.03152026f, 0.04547076f, 0.03943802f, 0.01652183f, -0.01035237f, -0.00474348f, -0.00906883f, 0.02395869f, 
    -0.01063448f, 0.00312444f, 0.02437330f, -0.03524242f, -0.04707524f, -0.06338787f, -0.04805522f, 0.00877601f, 
    -0.02682980f, -0.01016822f, -0.06023330f, -0.00485311f, -0.03300672f, 0.03367777f, 0.02904161f, -0.03447829f, 
    0.04945451f, -0.02397615f, -0.05003134f, 0.00063842f, -0.06332516f, 0.03812914f, -0.03746557f, 0.00021776f, 
    -0.00110597f, -0.01642311f, -0.00226104f, 0.01925866f, 0.02974283f, -0.03624268f, -0.05528313f, 0.01047094f, 
    -0.01986711f, 0.01216329f, -0.05011095f, -0.03902383f, -0.03281181f, -0.01867415f, -0.00735164f, -0.04866190f, 
    -0.01332681f, -0.05527406f, 0.03382379f, -0.04580567f, 0.04176769f, 0.02688644f, 0.00446657f, 0.01272433f, 
    -0.03809536f, -0.05407229f, -0.05678123f, -0.05773509f, -0.03575369f, 0.03424777f, 0.02642124f, -0.02206261f, 
    -0.00293258f, 0.02796556f, -0.01551498f, -0.04285653f, -0.05601390f, 0.04519366f, 0.02682384f, 0.00156761f, 
    -0.00112956f, -0.04640366f, 0.00588667f, 0.03471683f, 0.01182317f, 0.00683747f, -0.02969509f, 0.04008569f, 
    0.00614409f, -0.05087959f, -0.02725193f, -0.05266998f, 0.00323481f, -0.01014240f, -0.06401663f, -0.02015857f, 
    -0.01986796f, -0.02986867f, 0.01873770f, -0.01539647f, -0.04792288f, -0.01607861f, 0.02420422f, -0.04413133f, 
    -0.00850117f, -0.00914702f, -0.01685238f, 0.00243071f, -0.04275373f, -0.01160158f, -0.00941359f, -0.00633015f, 
    -0.03550133f, -0.03755428f, 0.01250312f, -0.05117380f, 0.02905349f, -0.03655064f, 0.03065997f, 0.01243920f, 
    0.00248901f, -0.00783317f, 0.02411349f, 0.04761805f, 0.01661708f, 0.03274536f, 0.02734898f, -0.04725138f, 
    -0.01617307f, -0.00224326f, -0.05497223f, -0.02756012f, -0.02126987f, -0.02119357f, -0.05933825f, -0.02378501f, 
    0.02454440f, -0.04085920f, 0.02648426f, -0.02242483f, -0.00406059f, -0.03919676f, 0.01961528f, -0.03374011f, 
    -0.04194796f, 0.00760523f, 0.02400559f, -0.04321462f, 0.01567724f, -0.03673956f, 0.04654133f, -0.05918246f, 
    0.00829914f, 0.01155466f, -0.05934006f, -0.03432232f, -0.04316666f, 0.00149932f, -0.04844686f, -0.03046597f, 
    0.00181320f, -0.04561455f, -0.01818826f, -0.04458475f, 0.02574470f, 0.02133168f, 0.02267505f, -0.02321330f, 
    0.02930987f, 0.03732648f, -0.04981371f, 0.00758846f, -0.02388379f, 0.03358745f, 0.04555219f, -0.00847639f, 
    0.00089589f, -0.01968795f, -0.02344184f, -0.01302958f, 0.03603115f, -0.01538319f, -0.05194508f, -0.04347120f, 
    0.04811644f, -0.03207463f, -0.02250798f, 0.04484525f, 0.00777265f, 0.04576269f, 0.01711027f, -0.05254453f, 
    -0.00342237f, 0.01976803f, 0.02309231f, 0.02035295f, -0.03100516f, 0.02565163f, -0.06301776f, -0.01318828f, 
    0.03140554f, 0.00295232f, -0.03601949f, 0.01181049f, -0.05245383f, 0.01930378f, 0.00204140f, 0.02810534f, 
    0.02119600f, 0.04077401f, -0.02691342f, -0.04248760f, 0.01610937f, -0.02769088f, 0.00752627f, 0.02900586f, 
    0.01579302f, 0.03064812f, 0.04601523f, -0.01705794f, 0.01321449f, -0.05144195f, 0.03349532f, 0.00180503f, 
    -0.00645750f, -0.03764337f, 0.01845985f, -0.06162143f, -0.06002937f, -0.00092774f, -0.03934241f, 0.01430098f, 
    -0.05806182f, 0.01979482f, -0.05880851f, -0.04725126f, -0.02841675f, 0.00201581f, 0.03994739f, 0.03906487f, 
    0.04723141f, -0.04503057f, -0.00758760f, -0.04258106f, -0.00091529f, -0.03409601f, -0.05818838f, 0.00943938f, 
    -0.02125180f, -0.02787584f, -0.02980281f, -0.00487891f, 0.02827814f, 0.00830001f, 0.02418747f, -0.01289025f, 
    -0.06405699f, -0.02421398f, -0.05201409f, 0.03153516f, -0.02342555f, -0.04020943f, 0.03542581f, 0.04211983f, 
    0.03724856f, -0.02701482f, -0.00025872f, 0.00309631f, 0.04264521f, 0.03911272f, 0.00384291f, -0.03525726f, 
    0.01626319f, -0.05975246f, -0.01931819f, -0.05978624f, -0.02293439f, -0.02645605f, 0.04450833f, -0.04871580f, 
    0.01410221f, 0.03065639f, -0.06465819f, 0.04580738f, -0.01279884f, -0.05207441f, 0.01928828f, 0.00779798f, 
    0.04521767f, 0.04707883f, -0.06026644f, -0.03079790f, -0.00859672f, 0.04455443f, -0.04515472f, -0.04364041f, 
    -0.06123812f, -0.04355715f, -0.05139564f, 0.00072250f, -0.05871487f, 0.00124992f, -0.00580121f, -0.01844922f, 
    -0.03421237f, -0.03604395f, -0.01667046f, 0.03804729f, -0.00398992f, 0.00200226f, 0.01952797f, -0.00880236f, 
    0.03526213f, -0.00163512f, -0.03496951f, -0.00045047f, -0.05909237f, 0.04133876f, 0.03329472f, 0.01663468f, 
    0.00854952f, 0.03538297f, 0.01505267f, 0.01280395f, -0.05709162f, 0.00296945f, 0.01570959f, 0.01901561f, 
    -0.03744621f, -0.05580443f, -0.06031323f, 0.00602771f, 0.03196114f, 0.04634218f, -0.05071729f, 0.00650006f, 
    0.03422533f, 0.01071464f, -0.04955044f, 0.05086982f, -0.02654030f, 0.01627411f, -0.06032994f, 0.04731983f, 
    -0.02541201f, -0.04080060f, -0.00146446f, 0.00228627f, -0.02183153f, 0.04987329f, 0.01918362f, -0.02198680f, 
    -0.04004437f, 0.00846809f, 0.00318500f, -0.04436640f, -0.02596624f, -0.06067302f, -0.00298183f, -0.02636557f, 
    0.01657383f, -0.01291188f, -0.00771301f, 0.00082898f, -0.05420893f, 0.03221633f, 0.01362345f, -0.00663494f, 
    -0.05101927f, -0.04761085f, -0.01425123f, 0.01099292f, -0.00074917f, 0.00260316f, -0.02449122f, 0.04042284f, 
    -0.04848625f, -0.01737299f, -0.00600619f, -0.00211988f, -0.03475267f, 0.01498190f, -0.05702720f, -0.01417814f, 
    0.00719864f, -0.01780519f, 0.03052305f, -0.06021839f, -0.05530265f, -0.00913287f, 0.01588916f, -0.00728338f, 
    0.02248945f, 0.02990178f, 0.03616709f, -0.00895224f, 0.02328513f, 0.04237777f, 0.00645216f, 0.00645130f, 
    -0.01718689f, 0.02746879f, 0.01484007f, 0.03457610f, -0.03158494f, -0.02856198f, 0.00466291f, -0.03441214f, 
    0.00884946f, 0.03329784f, 0.01874180f, 0.03307971f, -0.04956695f, -0.02943723f, 0.03826507f, -0.00658613f, 
    0.02271385f, -0.01268234f, 0.00208267f, -0.04545552f, -0.00705652f, -0.05327809f, -0.05092430f, 0.04107264f, 
    0.03760237f, 0.03495596f, -0.05304861f, -0.00990867f, -0.01595743f, -0.06126779f, -0.05146549f, -0.01002411f, 
    0.01419025f, 0.03404093f, 0.02475135f, 0.01946277f, 0.03555859f, 0.02857304f, -0.02159979f, 0.02309807f, 
    0.04272244f, 0.02265395f, -0.03549543f, 0.01215756f, -0.01580103f, 0.03691078f, -0.04154807f, -0.01570937f, 
    -0.00624469f, -0.00107518f, 0.01483551f, -0.02690926f, -0.02299347f, -0.04717784f, -0.00370371f, 0.01236527f, 
    -0.00683340f, -0.02501870f, -0.01455342f, -0.01879849f, 0.04628167f, 0.02011739f, 0.02738582f, 0.03901294f, 
    0.04459610f, -0.01373904f, 0.03986008f, -0.04943267f, -0.00607622f, -0.00906685f, 0.03050576f, -0.02000664f, 
    0.01493088f, 0.01449389f, 0.04583934f, -0.01390487f, -0.04116489f, -0.01889291f, -0.03745948f, -0.01503339f, 
    -0.01942139f, 0.00790807f, 0.02979919f, -0.05446145f, 0.01598858f, 0.01706537f, -0.01176019f, -0.00077487f, 
    -0.06183303f, 0.03104909f, 0.01925102f, 0.01684627f, 0.03417421f, 0.03843273f, 0.02480191f, -0.05167427f, 
    0.00125724f, 0.02869501f, -0.01632348f, -0.01419689f, 0.03791275f, -0.04488777f, -0.00459253f, 0.01959877f, 
    0.02323762f, 0.04059439f, 0.03186630f, -0.05180321f, -0.05563821f, -0.06078352f, 0.01386400f, -0.01003089f, 
    -0.01577227f, -0.05059436f, -0.01424360f, 0.00117876f, 0.01291449f, 0.02677089f, -0.01685874f, -0.01082103f, 
    -0.02120468f, -0.05823552f, -0.00238507f, -0.03741195f, 0.03726745f, -0.03073082f, -0.04189341f, 0.00136743f, 
    -0.01081081f, 0.04339575f, 0.03116247f, -0.04300580f, -0.04124129f, -0.01041264f, -0.02366129f, -0.00343723f, 
    -0.02248761f, -0.05167822f, -0.02939274f, 0.03550623f, -0.04069068f, -0.04883003f, 0.02268854f, -0.01104955f, 
    -0.00271038f, -0.02413306f, 0.00650424f, 0.00391427f, -0.03514977f, 0.00194045f, -0.05777767f, -0.02269198f, 
    0.00647151f, -0.05736075f, -0.03865595f, -0.01221234f, 0.05214211f, 0.02560497f, -0.05875037f, 0.04411435f, 
    -0.03485447f, -0.03899214f, 0.03886724f, -0.00536969f, -0.03369334f, -0.04249447f, 0.04160764f, 0.04348045f, 
    -0.02244561f, -0.01219296f, -0.02062435f, 0.02920195f, -0.00015745f, 0.01584116f, -0.04680079f, 0.01429156f, 
    -0.06303629f, -0.02786035f, -0.04064879f, 0.04157482f, -0.00940475f, -0.01439006f, -0.03004214f, -0.03606232f, 
    -0.01575565f, 0.02597364f, -0.02908548f, 0.00544575f, 0.03981884f, 0.02620721f, -0.03157089f, -0.04524708f, 
    -0.04443446f, -0.04800078f, 0.03784513f, -0.03030659f, 0.02924483f, -0.00668050f, 0.03293404f, 0.04116816f, 
    -0.04232745f, -0.01360186f, 0.01250821f, 0.00605862f, -0.06029524f, -0.04495058f, 0.03845911f, -0.01904526f, 
    -0.03447480f, -0.00212110f, 0.00315316f, 0.01196683f, -0.01212463f, 0.03373912f, -0.05183676f, 0.02069353f, 
    -0.02624270f, 0.00017261f, 0.03652924f, -0.02657811f, 0.02741341f, -0.01083764f, 0.04333931f, 0.02498568f, 
    0.00948775f, 0.01979132f, 0.03086396f, -0.01083746f, 0.03466560f, 0.04006788f, 0.03010411f, -0.03529833f, 
    0.03982523f, -0.05303985f, 0.00412788f, -0.03127588f, 0.01017806f, -0.04563066f, -0.00142091f, -0.00918438f, 
    -0.04493598f, 0.03458294f, 0.05319729f, 0.02624812f, 0.00082989f, -0.00535999f, -0.00947315f, -0.01974742f, 
    0.04573258f, 0.02307363f, -0.04835163f, -0.03775417f, -0.04617546f, -0.02702835f, 0.03587222f, 0.04947278f, 
    -0.04650279f, -0.02767631f, 0.00458815f, 0.02085143f, -0.04650039f, -0.01213635f, 0.00216855f, -0.02810520f, 
    0.04564689f, -0.00814653f, 0.04201207f, -0.05593220f, -0.02694487f, 0.02144109f, 0.03431635f, -0.00622452f, 
    0.01150996f, 0.01662209f, 0.04280500f, 0.04127146f, -0.02457689f, -0.02532158f, 0.02168601f, -0.03089319f, 
    0.03410469f, 0.01871728f, -0.04097046f, 0.01840068f, 0.00170886f, -0.06097363f, -0.03181098f, -0.01005625f, 
    -0.00147330f, -0.00377124f, 0.00459276f, -0.03139862f, -0.04098561f, 0.05436323f, -0.03952438f, 0.01621235f, 
    -0.02953695f, 0.02904006f, -0.03576466f, -0.00612915f, -0.05566505f, -0.06359962f, -0.04233892f, -0.03954267f, 
    0.02812615f, -0.03866747f, -0.03405005f, 0.02272903f, -0.04405549f, -0.03452370f, -0.04931470f, 0.03583373f, 
    -0.01257722f, 0.04401363f, -0.03161305f, -0.05671191f, -0.06429511f, -0.05886511f, 0.00250578f, -0.05369960f, 
    -0.03932275f, -0.05588002f, -0.02535029f, -0.06169038f, 0.02940648f, -0.05369841f, -0.01046984f, -0.05483748f, 
    0.04378300f, -0.04427873f, -0.03768756f, 0.03323858f, -0.00066632f, -0.03138412f, -0.05114577f, -0.01921200f, 
    0.04585652f, 0.04408593f, -0.04154814f, -0.02379689f, 0.03483839f, -0.03970795f, 0.02021212f, -0.04214003f, 
    -0.00234353f, -0.02300736f, -0.04962501f, -0.00120836f, 0.02903093f, -0.00032672f, 0.02627443f, -0.04932927f, 
    -0.04176372f, -0.04594592f, 0.00277890f, -0.06307131f, -0.01142618f, 0.03018834f, 0.02376392f, -0.01338290f, 
    0.04384469f, -0.00055394f, -0.01810335f, -0.00525131f, -0.02962755f, 0.04344249f, 0.02639787f, -0.03924249f, 
    -0.04113267f, 0.03490081f, -0.05498722f, 0.00680388f, 0.03756163f, 0.00713047f, 0.01372880f, 0.01589094f, 
    -0.05060463f, 0.01594256f, -0.01551367f, 0.02088885f, -0.00821818f, 0.02286793f, 0.05532710f, 0.01888117f, 
    0.01741552f, 0.00920662f, -0.02493860f, 0.02979959f, 0.04360750f, 0.00430000f, 0.05090493f, 0.03694481f, 
    -0.02835454f, 0.01325083f, 0.00968087f, 0.01150103f, 0.03036721f, -0.03892626f, -0.03317413f, -0.01952734f, 
    0.01126079f, -0.01595723f, 0.03143282f, -0.04161093f, -0.01415085f, 0.01820444f, 0.02733589f, -0.02988772f, 
    -0.05642410f, 0.04689382f, -0.01480541f, -0.03097206f, -0.06243547f, -0.02512973f, -0.06013390f, 0.04134573f, 
    -0.03009146f, 0.00535590f, 0.02777163f, 0.04783997f, 0.01512722f, -0.01040978f, -0.06295788f, -0.06019871f, 
    0.01424092f, -0.00557457f, -0.05611745f, -0.03866063f, -0.01498619f, 0.04665665f, -0.05127120f, -0.00012522f, 
    -0.03906061f, -0.04210755f, 0.00459308f, 0.01271474f, -0.03683471f, 0.02345322f, 0.00142060f, 0.04338552f, 
    -0.05160511f, 0.00561482f, 0.02282165f, -0.02993748f, 0.00144255f, 0.01702642f, 0.01124469f, -0.05129035f, 
    -0.01824073f, 0.03084436f, 0.00726830f, -0.01431619f, 0.01998618f, 0.01871154f, -0.05287709f, -0.02456285f, 
    0.03403335f, -0.01161099f, 0.00686513f, 0.01402251f, -0.01414846f, -0.05714896f, -0.01031754f, 0.03683666f, 
    0.03458324f, -0.01166775f, 0.02606502f, 0.00806462f, -0.04186214f, -0.03261544f, 0.00800181f, -0.05224677f, 
    -0.02813953f, 0.00493147f, 0.01407826f, -0.02009184f, 0.02010420f, 0.02864410f, -0.00960328f, 0.02132987f, 
    0.42307812f, -0.03437626f, 0.14111286f, 0.14255376f, 0.36923805f, -0.38939533f, -0.05813164f, 0.09095452f, 
    0.03414863f, 0.02720542f, 0.06613575f, -0.02478746f, 0.02953003f, -0.15085728f, 0.06205455f, -0.06917646f, 
    0.09320902f, 0.01444970f, 0.03532762f, 0.08958492f, -0.08080739f, -0.50308466f, -0.07336178f, 0.19941670f, 
    0.02427992f, -0.06403980f, -0.01311303f, -0.15491785f, -0.04159565f, -0.04038685f, -0.06912093f, 0.02084823f, 
    -0.02527917f, 0.16414061f, 0.07606093f, -0.18451060f, -0.05202256f, -0.00426303f, -0.12659217f, 0.05439914f, 
    -0.13812977f, 0.16544969f, 0.00947887f, 0.11409954f, -0.07422516f, 0.11136261f, 0.03747510f, 0.00140768f, 
    -0.04486493f, -0.01394548f, 0.05766528f, 0.07057706f, -0.13256106f, -0.00914214f, -0.02236799f, -0.00607462f, 
    0.09383520f, 0.08939833f, 0.05001258f, 0.07767097f, -0.21358180f, 0.03472728f, -0.02748482f, 0.24108861f, 
    -0.15841062f, 0.07575329f, 0.18053499f, -0.04168794f, -0.00732715f, 0.01405725f, -0.13282046f, -0.11989009f, 
    0.01575702f, -0.01286901f, 0.16368140f, 0.07663259f, 0.12109119f, -0.03518769f, -0.04007516f, -0.02066494f, 
    0.12001342f, 0.26966104f, -0.02239343f, 0.04354494f, 0.03518226f, 0.02295893f, -0.00479811f, 0.02337616f, 
    0.02836376f, -0.04508735f, 0.04587343f, 0.11237554f, -0.05633747f, -0.04609486f, -0.16339704f, -0.01529305f, 
    -0.01661064f, -0.02065422f, 0.06233980f, 0.10204221f, 0.66971958f, 0.00590477f, 0.28296864f, -0.38343775f, 
    -0.02489393f, -0.13274379f, -0.11571499f, -0.13093770f, 0.03977099f, 0.02832224f, 0.02485510f, 0.17710917f, 
    -0.17533806f, 0.17517802f, 0.13425082f, 0.02563676f, -0.00271132f, -0.06327692f, 0.06625033f, -0.02613537f, 
    0.40651345f, 0.20716411f, 0.42455229f, -0.16085404f, 0.33316538f, -0.06496503f, 0.01353615f, -0.00661888f, 
    0.12053097f, 0.07769315f, 0.10552378f, -0.05304181f, -0.07598600f, 0.01872845f, -0.12909988f, 0.08389848f, 
    0.07428865f, -0.05424142f, 0.04162095f, 0.10950968f, -0.07439078f, -0.10533281f, -0.14760116f, -0.02138912f, 
    -0.37607595f, -0.08734094f, -0.10073050f, -0.14746994f, 0.05931462f, -0.01613689f, 0.05521594f, -0.04483486f, 
    -0.10796476f, -0.05096477f, -0.02270250f, -0.06704647f, -0.10308752f, -0.11173920f, -0.03515738f, 0.07286765f, 
    0.13255122f, -0.04162541f, -0.00010934f, 0.03988488f, -0.08266190f, 0.09763555f, 0.02152109f, -0.00814097f, 
    0.09304376f, -0.04327715f, -0.18452393f, 0.05113759f, -0.02010624f, -0.06548597f, 0.00230690f, -0.14810523f, 
    0.03347683f, -0.07075675f, 0.05474389f, -0.19308536f, 0.72200465f, 0.21584016f, 0.20402771f, 0.09162724f, 
    0.53057337f, -0.03695514f, -0.23344520f, -0.07642871f, 0.10709734f, -0.04702523f, 0.00672680f, 0.02858646f, 
    0.06269462f, 0.08185361f, -0.03948428f, -0.11057690f, 0.09433261f, -0.19554174f, 0.08060417f, -0.00614533f, 
    0.13386735f, -0.09566227f, 0.04159710f, 0.10859890f, 0.08397493f, 0.08104836f, 0.04236161f, -0.11860947f, 
    0.13478006f, 0.14495052f, 0.05153772f, 0.11276949f, -0.01576257f, 0.00776227f, -0.07153212f, -0.02110038f, 
    -0.12527741f, 0.01385429f, -0.01972395f, -0.02515245f, -0.16806883f, 0.39407149f, 0.23719902f, -0.10033257f, 
    -0.25680476f, 0.04504891f, 0.06484535f, 0.21553005f, -0.03501994f, 0.02649525f, -0.12471925f, -0.00702026f, 
    -0.06324767f, 0.03807180f, -0.02730658f, 0.05275795f, 0.09395003f, 0.02213013f, 0.01065282f, -0.11288176f, 
    -0.44011900f, 0.58512688f, 0.20747496f, 0.06425199f, 0.09701833f, 0.24486186f, 0.26064485f, 0.05613646f, 
    -0.03033389f, -0.04722916f, 0.05967232f, -0.09853376f, 0.02774542f, 0.03424952f, 0.04896960f, 0.17827980f, 
    0.13804111f, 0.04040216f, 0.14098082f, -0.05437271f, -0.53679639f, -0.13830690f, 0.17184222f, -0.42223841f, 
    -0.01503005f, -0.29866803f, -0.15135162f, 0.07357413f, -0.19567284f, 0.04047388f, -0.12007795f, -0.00498563f, 
    0.09031577f, -0.01360229f, 0.05230252f, -0.10011377f, -0.01434628f, -0.09282321f, -0.13597810f, -0.01807775f, 
    -0.29029164f, 0.01107108f, 0.00599920f, 0.24019435f, -0.06150553f, 0.22178619f, 0.18371204f, -0.04331598f, 
    0.27695397f, 0.10733296f, -0.04092854f, 0.09855378f, -0.12288519f, 0.07460004f, 0.02788605f, 0.05242270f, 
    -0.05382577f, 0.02798986f, 0.00149479f, -0.13388374f, 0.55261588f, 0.04085105f, 0.06901931f, 0.00219179f, 
    0.10971721f, 0.15958658f, 0.06475168f, 0.15051292f, -0.05429074f, -0.03527082f, 0.12012406f, -0.01212546f, 
    0.01844685f, 0.01012244f, -0.00363486f, -0.07691317f, -0.05589347f, 0.06670843f, -0.01075519f, -0.09415637f, 
    -0.05373308f, 0.04258709f, -0.06199061f, -0.02270791f, -0.00797199f, 0.00476623f, 0.03285166f, 0.05020113f, 
    -0.05438976f, -0.03286744f, -0.06234159f, -0.03411788f, 0.03563363f, -0.05044637f, 0.01511935f, -0.02377135f, 
    -0.05476471f, -0.01359348f, 0.01653065f, -0.01205305f, 0.00961102f, -0.03376896f, 0.02093410f, -0.05311746f, 
    -0.05707821f, 0.04736372f, -0.06043655f, -0.01834721f, -0.05302900f, 0.03569528f, -0.04064513f, 0.01889770f, 
    -0.03562735f, 0.02448404f, -0.05249456f, -0.01812225f, -0.05174525f, 0.02113516f, 0.02310687f, 0.01513742f, 
    -0.02831564f, -0.00426954f, -0.01956013f, -0.00208340f, -0.00836490f, 0.01556638f, 0.00818500f, -0.05114214f, 
    -0.00560909f, -0.00021675f, 0.03516696f, -0.04024923f, 0.03757435f, -0.06282376f, -0.00170550f, -0.06119168f, 
    0.02049990f, -0.00652687f, -0.05597978f, 0.04521776f, -0.05688661f, -0.01958910f, -0.05258616f, -0.04170731f, 
    0.02576130f, -0.04038114f, 0.01265862f, 0.02671855f, -0.05918816f, -0.01193624f, 0.00824403f, 0.00242236f, 
    0.00024485f, -0.05720659f, 0.04795370f, -0.04729220f, 0.01812893f, -0.02367106f, -0.06028922f, 0.03024391f, 
    -0.04039437f, 0.03975911f, 0.01215561f, -0.01649829f, 0.01543611f, -0.05863264f, 0.01290449f, 0.02199754f, 
    -0.03271496f, 0.01915481f, 0.02121051f, -0.03289133f, -0.04845394f, 0.03766873f, 0.04431575f, 0.00139626f, 
    -0.06291302f, -0.05891524f, -0.02324431f, 0.00438921f, 0.02826211f, -0.00755940f, -0.05371806f, -0.05924916f, 
    -0.01626472f, 0.03151341f, 0.03058404f, 0.03844010f, -0.03178392f, -0.06055965f, 0.02314220f, -0.02985683f, 
    0.01213787f, -0.01572091f, 0.03663526f, -0.02850454f, 0.01271449f, 0.02123211f, 0.04821376f, -0.01024296f, 
    -0.00114702f, 0.03338188f, 0.02274957f, -0.05814390f, -0.04955265f, -0.05050510f, -0.05433749f, 0.04790704f, 
    0.02362732f, -0.00803597f, -0.06055795f, -0.02802997f, -0.00721704f, -0.02998455f, 0.03212411f, 0.03990746f, 
    0.04414130f, -0.00224276f, -0.00288676f, -0.01766230f, 0.01822808f, -0.04583277f, 0.00769269f, -0.01820455f, 
    0.02365392f, -0.00001436f, -0.03299095f, -0.05408072f, -0.02168085f, 0.01994161f, -0.01096640f, 0.01536183f, 
    0.05076380f, 0.02973137f, -0.03782013f, -0.04453791f, 0.01499343f, 0.01964342f, 0.03685888f, -0.03123523f, 
    -0.00288971f, -0.00336653f, -0.05381391f, -0.01930746f, -0.00101623f, 0.02473169f, -0.05454168f, -0.04795402f, 
    0.01231121f, 0.02831912f, -0.02439342f, -0.00347224f, 0.02398619f, 0.00960566f, -0.03299730f, 0.03806225f, 
    -0.05012447f, -0.03979240f, 0.00398373f, -0.00677918f, 0.02825036f, -0.00581716f, 0.02350434f, -0.04583024f, 
    -0.06100759f, -0.06222784f, 0.00977034f, -0.03067206f, 0.01831198f, -0.00597471f, -0.01590555f, -0.01456202f, 
    -0.02537522f, -0.05229997f, 0.01046065f, -0.00941877f, 0.01901527f, -0.04065366f, -0.01350356f, -0.02274874f, 
    -0.04312489f, -0.06138052f, -0.03577532f, 0.00806693f, 0.04362787f, 0.04782965f, 0.02783196f, 0.00747615f, 
    0.04126666f, -0.01364846f, -0.05428551f, 0.00501991f, 0.01195826f, -0.05049172f, -0.04160336f, 0.02708625f, 
    -0.00635327f, 0.03423361f, -0.05163683f, -0.04941494f, 0.02744094f, 0.00224809f, -0.03153127f, -0.01826424f, 
    -0.05133486f, 0.02941514f, -0.03109003f, -0.02905800f, 0.04232979f, -0.02835157f, -0.00239139f, -0.00992010f, 
    0.02421940f, -0.02782346f, 0.04152497f, -0.05088713f, 0.00851871f, -0.03539393f, -0.05282669f, 0.03641434f, 
    0.01046147f, -0.03075069f, -0.00696317f, -0.05897674f, -0.03921495f, -0.05718476f, -0.01333309f, -0.02073635f, 
    0.02119451f, 0.03011852f, -0.01485900f, 0.00654200f, 0.00298821f, 0.02034819f, -0.01586907f, 0.04172765f, 
    0.02792433f, -0.01509823f, -0.06139132f, -0.04030161f, -0.03030023f, -0.01565003f, -0.04020423f, -0.00802184f, 
    -0.06088996f, -0.02777109f, 0.01961197f, 0.02197478f, 0.03475372f, -0.01792293f, 0.01423909f, -0.02463748f, 
    0.02197889f, 0.04118551f, -0.03037765f, -0.00380618f, -0.02923816f, -0.01594694f, -0.02978913f, -0.02798047f, 
    0.00091464f, -0.04582771f, -0.00243338f, -0.06143180f, -0.03244914f, 0.03693474f, 0.04504667f, -0.01693696f, 
    -0.05494661f, -0.01301551f, 0.01237135f, -0.05071880f, -0.05740831f, 0.01794467f, -0.00758773f, 0.03511934f, 
    -0.03449484f, 0.01131275f, 0.02304626f, -0.00423680f, -0.05081340f, 0.02207568f, 0.04247656f, 0.03242652f, 
    0.01324692f, 0.03477386f, 0.04813354f, 0.01176311f, 0.03998005f, 0.00124314f, -0.05192661f, 0.03326572f, 
    0.02314374f, 0.02778705f, 0.04130170f, -0.05856670f, 0.03650260f, 0.04182512f, -0.05444058f, -0.01353605f, 
    -0.01064470f, -0.20193048f, -0.06176936f, -0.23459873f, 0.05885559f, -0.11154354f, -0.04274755f, -0.21194026f, 
    -0.09970171f, -0.07507167f, 0.02640178f, -0.03925581f, -0.06622785f, -0.17708158f, 0.00315467f, 0.15417379f, 
    0.07970561f, -0.35579130f, -0.01199379f, -0.01218907f, -0.00061319f, -0.18058123f, -0.11769124f, 0.16515972f, 
    0.06964434f, -0.03493101f, 0.18295690f, -0.13348551f, -0.03893874f, 0.02959487f, -0.00130282f, 0.23215446f, 
    -0.06075194f, -0.16216832f, -0.16956918f, 0.16749316f, 0.06793583f, 0.03927217f, 0.36890733f, 0.13671476f, 
    -0.10509663f, 0.15620346f, 0.07491033f, 0.31081867f, -0.04273924f, -0.09553571f, -0.21414825f, 0.09489910f, 
    0.06909471f, 0.00537038f, 0.08011524f, -0.07382172f, -0.01812179f, 0.12980998f, 0.06519243f, 0.05217315f, 
    0.00512265f, 0.21400927f, -0.21962740f, 0.02301921f, 0.19578050f, -0.05003620f, 0.32118571f, -0.04512718f, 
    0.07344883f, -0.14331789f, -0.08466853f, -0.08630925f, 0.09268242f, 0.04590672f, -0.04896218f, -0.05482480f, 
    -0.03554421f, -0.01654001f, -0.01907475f, 0.03161006f, 0.07458388f, 0.20973416f, 0.10544626f, 0.04496805f, 
    0.28791797f, 0.19271205f, -0.09886625f, 0.00084985f, 0.53492087f, -0.12069776f, 0.13060802f, -0.18507840f, 
    0.23661460f, 0.00629812f, 0.02274705f, 0.01954805f, 0.12799148f, 0.03138483f, -0.01628382f, 0.07772981f, 
    0.05557279f, -0.22349475f, 0.11203153f, -0.00010989f, -0.51197207f, -0.01391847f, -0.12104739f, -0.17325582f, 
    -0.09339458f, 0.16796722f, 0.15102276f, 0.04229083f, -0.03090077f, -0.05579380f, 0.04418666f, -0.02489829f, 
    0.07210422f, -0.02886184f, 0.02017441f, 0.04160549f, 0.02423831f, -0.30873403f, -0.20365678f, -0.11098396f, 
    -0.19876532f, -0.22048511f, -0.37260133f, -0.42400685f, -0.15461852f, 0.09281510f, -0.00384760f, 0.05084268f, 
    -0.08782817f, 0.00518113f, 0.04483800f, 0.09715894f, -0.10586718f, 0.14869276f, -0.04528194f, 0.09579621f, 
    -0.14637014f, -0.24428585f, -0.22124282f, -0.12871149f, 0.54324466f, 0.14299425f, -0.21699089f, -0.17038175f, 
    -0.16846055f, 0.03149803f, 0.10352825f, 0.12517880f, 0.13269076f, 0.04439614f, -0.19467491f, 0.03776982f, 
    -0.08018472f, -0.00287094f, 0.09495738f, 0.10957187f, 0.11000816f, -0.01905952f, -0.16908313f, -0.09065001f, 
    0.11098635f, 0.29992294f, -0.18396439f, 0.18023343f, 0.07782897f, 0.14120923f, 0.07369392f, 0.02949371f, 
    -0.00493687f, -0.14822152f, -0.05489821f, 0.16951974f, -0.05140508f, -0.05454579f, 0.10075694f, 0.01648532f, 
    0.18624510f, 0.23590152f, -0.01439232f, 0.12879276f, -0.04208161f, 0.43339345f, -0.00146851f, -0.16742511f, 
    -0.08962443f, -0.00878281f, 0.03666173f, -0.18525027f, -0.01372030f, 0.05291108f, 0.10213874f, 0.20590524f, 
    -0.01032465f, 0.06648667f, 0.05473125f, 0.24601164f, 0.14017080f, 0.04707238f, -0.32184935f, 0.05493288f, 
    -0.02432859f, 0.28009292f, -0.28036216f, 0.12299807f, 0.04042980f, -0.03279230f, -0.03378253f, 0.16564052f, 
    -0.02930831f, -0.02135484f, -0.08931500f, -0.00637794f, 0.09198260f, -0.20767792f, 0.09043045f, 0.01177902f, 
    0.00837806f, 0.09672365f, 0.07948555f, -0.06915935f, 0.67093790f, 0.30646309f, 0.07001358f, 0.10514186f, 
    0.49847606f, 0.05854499f, -0.01108277f, -0.00258309f, 0.05424372f, -0.01187524f, -0.02636656f, -0.03687114f, 
    0.03988817f, 0.17023617f, 0.09527946f, 0.03421087f, 0.10728028f, -0.42632180f, -0.11474033f, 0.16003086f, 
    0.06467988f, -0.17550108f, 0.18320514f, -0.05304963f, 0.01583767f, 0.02581265f, 0.07492623f, 0.06668008f, 
    0.13951166f, 0.20317157f, -0.20475437f, -0.10980488f, 0.18076129f, 0.08322598f, -0.06110387f, -0.10719899f, 
    0.14384240f, 0.00634044f, 0.01571172f, -0.18633933f, 0.27502644f, 0.04273171f, 0.22253831f, -0.27027255f, 
    0.02066541f, -0.05205113f, 0.10455045f, -0.04890661f, 0.16814077f, -0.15550306f, 0.12449368f, 0.02457294f, 
    0.06813119f, 0.19030853f, 0.01631740f, 0.06286173f, 0.07284564f, 0.23990180f, 0.06782327f, 0.09385279f, 
    0.27988550f, 0.21653168f, -0.00303083f, 0.05623451f, -0.00282081f, -0.15126261f, -0.08476967f, -0.06577943f, 
    -0.04526502f, 0.00916023f, -0.06909607f, -0.00743619f, 0.11241847f, -0.08589964f, -0.05086604f, 0.11992224f, 
    -0.03088656f, 0.01620552f, 0.19651753f, 0.13051291f, 0.29162139f, -0.25392601f, -0.38120160f, 0.00470137f, 
    -0.03282388f, -0.04339542f, -0.11653438f, -0.04648995f, 0.06660149f, -0.08220010f, -0.15543741f, -0.02228298f, 
    0.17118008f, 0.06790216f, 0.23776031f, 0.18503475f, 0.08256522f, -0.20598179f, -0.12481520f, 0.05714858f, 
    0.07200069f, -0.14464134f, -0.11603744f, 0.31840754f, 0.49205440f, -0.13611916f, -0.03424010f, 0.00537233f, 
    0.02083576f, 0.05139277f, 0.14289154f, 0.08985821f, 0.08434897f, -0.07755312f, 0.11225238f, 0.04735450f, 
    0.08232623f, 0.11975563f, 0.20045723f, 0.09348970f, -0.11627265f, -0.16873010f, 0.23837575f, 0.24117793f, 
    0.18590464f, -0.05691034f, 0.08545429f, 0.02742700f, 0.00996450f, -0.07336718f, 0.18403611f, 0.01737438f, 
    -0.03291271f, 0.02671233f, 0.16205947f, 0.06711363f, -0.02720756f, 0.05505100f, 0.02778914f, 0.05476847f, 
    -0.20240027f, 0.22193302f, -0.04154247f, 0.19002454f, -0.20846529f, 0.00042102f, -0.05563368f, 0.29791659f, 
    -0.17932037f, -0.13585320f, -0.03356641f, 0.01377988f, 0.07570673f, 0.05181309f, 0.03094364f, 0.04888818f, 
    -0.06611446f, 0.06352752f, 0.09907949f, 0.01873395f, -0.17856605f, -0.11858330f, 0.30975562f, -0.07815618f, 
    0.04025767f, -0.15006806f, -0.06211973f, 0.04542406f, 0.05253198f, -0.12340846f, 0.12647188f, -0.00437506f, 
    -0.01537229f, 0.12705705f, 0.12234585f, -0.03251549f, 0.06520972f, -0.02502370f, 0.14303048f, 0.07682266f, 
    0.04988541f, -0.06092709f, 0.35570160f, -0.34425494f, 0.38298529f, -0.24593893f, 0.00012164f, -0.03399628f, 
    0.23690905f, -0.12047277f, -0.00708439f, -0.16585489f, 0.17323714f, -0.00172052f, -0.07365537f, -0.16840456f, 
    0.06945983f, 0.03283304f, -0.21755745f, 0.06787903f, 0.02346785f, 0.05932534f, -0.15062936f, -0.06798015f, 
    -0.16015373f, 0.08678121f, 0.09067447f, -0.10462120f, -0.09467306f, 0.15614110f, 0.07535595f, 0.12821700f, 
    -0.04382281f, 0.09845100f, 0.01630550f, -0.07937018f, -0.03429684f, -0.10928859f, 0.04570943f, 0.00152255f, 
    0.14235832f, -0.18318954f, -0.29281557f, -0.06420056f, 0.07885844f, 0.06097597f, 0.04399962f, -0.14919510f, 
    0.03463410f, 0.18359037f, 0.20233123f, -0.05266347f, -0.00564425f, -0.00297888f, -0.08768032f, 0.13101529f, 
    -0.01654702f, 0.12144728f, 0.10224096f, 0.03801278f, -0.31207371f, 0.31906113f, -0.18774626f, -0.02565875f, 
    -0.10574345f, 0.04517709f, -0.19623597f, -0.10763331f, 0.00471502f, -0.12590832f, 0.01875548f, 0.04878297f, 
    -0.00066388f, -0.05962608f, -0.09067699f, 0.00225076f, -0.02195385f, -0.05932453f, -0.10283837f, -0.05982131f, 
    0.09702951f, 0.44557610f, -0.17382939f, 0.11259993f, -0.26312378f, -0.00957881f, -0.16695778f, 0.04803562f, 
    -0.02472564f, -0.25300092f, 0.29402488f, 0.12111802f, 0.14748143f, -0.05022904f, 0.04193990f, 0.04639351f, 
    0.14575392f, -0.03993347f, -0.01499461f, 0.15133958f, 0.41915625f, -0.11479367f, -0.09441256f, 0.25899801f, 
    0.02694196f, -0.02140141f, 0.06374259f, -0.08540048f, -0.12530592f, -0.03783685f, 0.23973712f, 0.00232639f, 
    0.08509013f, 0.05828677f, 0.01206969f, -0.15655403f, 0.15223649f, -0.05485837f, 0.06015585f, -0.06465404f, 
    -0.44117525f, 0.38444009f, 0.01087989f, -0.12647676f, 0.03752377f, 0.01732232f, 0.06382632f, 0.18249932f, 
    -0.19365808f, -0.04424160f, 0.08880101f, 0.05781764f, -0.02812873f, 0.09365053f, 0.10860470f, 0.22001612f, 
    -0.08671308f, -0.11491650f, -0.19544666f, -0.11710123f, -0.68301600f, 0.71253598f, -0.09010816f, -0.15826653f, 
    -0.12680371f, -0.08896895f, -0.01367358f, 0.08273836f, 0.15852201f, -0.14747281f, 0.03705779f, 0.01519042f, 
    -0.03616924f, 0.10613314f, -0.00306297f, -0.06231400f, 0.15025166f, -0.12782951f, 0.01613364f, -0.00075052f, 
    -0.62881935f, -0.16867438f, 0.10359275f, 0.01188987f, 0.28333172f, -0.14243482f, -0.20453341f, 0.22595246f, 
    -0.01720033f, -0.06248542f, -0.16441804f, -0.14484622f, 0.04451812f, -0.02547351f, 0.07508191f, -0.01886058f, 
    0.09388194f, 0.11890259f, 0.14802977f, -0.00185426f, 0.33272675f, 0.08312821f, -0.08628754f, 0.17841925f, 
    -0.33331621f, -0.09945872f, 0.23908044f, -0.14395712f, 0.02554465f, -0.11565660f, 0.15438221f, -0.00507914f, 
    0.04798859f, 0.12328648f, 0.10218721f, -0.05746406f, 0.12947614f, -0.14383040f, 0.16659532f, 0.13494575f, 
    -0.58216405f, 0.29136148f, -0.00198264f, 0.05949152f, -0.21745971f, 0.15736896f, -0.20543811f, 0.02603317f, 
    0.16702700f, -0.00790992f, 0.02817207f, 0.10191269f, -0.06513143f, -0.11671197f, 0.00177559f, 0.05829091f, 
    0.15982021f, 0.01493124f, 0.04894198f, -0.11243892f, 0.36658821f, -0.22924858f, -0.27034917f, 0.05225485f, 
    -0.07850698f, 0.15159805f, 0.13939953f, 0.06105844f, 0.08979377f, -0.05859921f, 0.02203875f, -0.07031381f, 
    -0.09105196f, -0.00788116f, -0.05454208f, -0.09368052f, 0.12335312f, -0.02940593f, 0.03498165f, 0.08822894f, 
    -0.03002897f, -0.03382073f, -0.04906441f, -0.03937214f, -0.05533789f, 0.01533083f, 0.04076827f, 0.02856532f, 
    0.02275411f, 0.02122679f, 0.03739813f, -0.01844217f, -0.01091741f, -0.04550894f, -0.01272914f, -0.05755072f, 
    -0.02209064f, 0.03205157f, -0.02155895f, 0.04465378f, -0.01525360f, -0.03472206f, 0.00001932f, 0.00953858f, 
    -0.04455439f, -0.01020059f, -0.03884080f, -0.00924541f, -0.04046281f, 0.00338139f, -0.01657788f, -0.05074228f, 
    0.04145566f, -0.04171937f, 0.00808812f, 0.00502702f, 0.01332196f, -0.04181192f, 0.00416036f, -0.04718658f, 
    0.04340274f, 0.00128590f, 0.01665523f, -0.04309984f, 0.03036955f, -0.03465127f, -0.03547262f, -0.01371164f, 
    0.00912851f, 0.03458679f, -0.03140640f, -0.04055335f, -0.02725195f, 0.04292237f, -0.00550755f, 0.02049037f, 
    -0.00625894f, -0.02486816f, 0.02447935f, -0.01145177f, -0.03517086f, 0.02845559f, 0.04830189f, 0.04328165f, 
    -0.01512530f, 0.00004572f, -0.05712575f, -0.05831002f, -0.00753629f, -0.04044245f, 0.05054856f, 0.04526224f, 
    0.04332358f, -0.04228732f, -0.04313665f, -0.03544430f, 0.00692874f, -0.00737847f, -0.05542122f, -0.03843900f, 
    0.02471666f, -0.03541360f, 0.03123902f, 0.00636917f, 0.00215157f, -0.03546914f, -0.05404074f, 0.00294301f, 
    0.03854869f, -0.03878805f, -0.05989703f, 0.01814232f, 0.02258241f, 0.01404398f, -0.00231341f, 0.02964340f, 
    -0.04132824f, -0.03528000f, -0.05851668f, -0.00971773f, 0.03938406f, 0.01398868f, -0.00491058f, -0.01361220f, 
    -0.03494293f, -0.01882933f, 0.02239140f, -0.01753051f, -0.03588840f, -0.03630171f, -0.04153478f, -0.01458200f, 
    0.02002092f, 0.02354493f, 0.00949654f, -0.02880618f, -0.03248025f, -0.06095548f, -0.02380998f, -0.00468962f, 
    -0.01505663f, 0.00530529f, -0.04271819f, -0.03920546f, 0.04468277f, 0.02256997f, -0.00471407f, -0.01195432f, 
    -0.03515543f, 0.00004123f, -0.01745373f, 0.04333532f, 0.02630354f, -0.00428789f, 0.01936601f, 0.01780503f, 
    0.04727100f, 0.03369739f, 0.04988136f, 0.04138802f, 0.03792677f, -0.02350627f, 0.04347505f, 0.04321365f, 
    -0.04448352f, 0.00891958f, -0.00861021f, -0.02462101f, 0.04728763f, 0.00274655f, -0.03254681f, 0.03443649f, 
    -0.04205457f, -0.02381569f, -0.02569292f, 0.02752216f, -0.03440754f, 0.01912973f, 0.00754045f, 0.00298378f, 
    0.03092297f, -0.00245065f, -0.01834706f, 0.02021758f, -0.05102038f, -0.00641297f, -0.05864202f, -0.04552652f, 
    0.00995088f, -0.01299981f, 0.01832607f, -0.05605245f, 0.00880838f, -0.05621108f, 0.03553610f, -0.00181950f, 
    0.01970567f, 0.04303619f, -0.01561064f, -0.01158646f, 0.04430997f, 0.03462818f, -0.06141595f, -0.05698823f, 
    -0.03774565f, 0.00307222f, 0.04671123f, 0.02014125f, 0.02826628f, -0.06134480f, 0.01494284f, 0.00283789f, 
    0.02862012f, 0.04329373f, -0.04040639f, 0.03594197f, -0.03040939f, 0.01221302f, -0.04596619f, 0.02029888f, 
    -0.00068097f, -0.05643207f, -0.05016162f, 0.01211583f, 0.02073149f, -0.05601139f, -0.05508152f, -0.01010997f, 
    0.02024711f, -0.04578393f, -0.04115965f, -0.05019701f, -0.00695685f, 0.03021414f, 0.02333695f, -0.02754632f, 
    -0.02757416f, 0.02838759f, -0.00264430f, 0.00046419f, 0.01769805f, -0.03501780f, -0.03623913f, -0.00467686f, 
    -0.05619235f, -0.03419471f, -0.03537174f, 0.03485674f, 0.01224864f, 0.04350335f, 0.02631772f, 0.00336955f, 
    -0.06047790f, 0.00798819f, -0.01926567f, -0.00549930f, 0.03619385f, -0.04013667f, -0.02357144f, 0.03650411f, 
    -0.04975840f, -0.06134574f, -0.03454500f, -0.02252905f, -0.03407043f, -0.00192352f, -0.03504946f, -0.04770053f, 
    0.01089455f, -0.05556013f, 0.02980217f, -0.03516254f, -0.02254014f, -0.02553207f, -0.05415655f, -0.05409313f, 
    -0.03768321f, -0.05876342f, 0.00268824f, -0.03695373f, -0.03553962f, 0.00023646f, 0.03997377f, -0.03364635f, 
    0.00012082f, -0.04090279f, -0.03475654f, -0.00569280f, 0.04806650f, 0.04279381f, -0.00086735f, -0.06014322f, 
    -0.02546994f, -0.04443403f, 0.02427312f, 0.00530948f, -0.01276602f, 0.00888348f, -0.02497173f, -0.02820050f, 
    -0.03856473f, -0.05604025f, -0.02645541f, 0.00720692f, -0.02151551f, 0.01219174f, -0.03524157f, -0.01681880f, 
    0.00647861f, 0.02162564f, -0.00463234f, -0.06359328f, -0.05191277f, -0.02146445f, -0.02336564f, -0.02936767f, 
    0.02753287f, -0.03931893f, -0.03465113f, 0.00653858f, -0.02181072f, 0.00314327f, 0.00229914f, -0.03236054f, 
    -0.00183785f, 0.04865760f, 0.03946218f, -0.03080525f, 0.02256757f, -0.04613115f, -0.03063181f, 0.02059572f, 
    0.03117572f, -0.03724510f, -0.04371620f, -0.00949076f, -0.05827606f, 0.00948204f, -0.00928950f, -0.03819149f, 
    0.02656532f, 0.00681638f, -0.05722313f, -0.00571624f, 0.00311270f, -0.04956355f, -0.01078927f, -0.00954254f, 
    -0.00779073f, -0.05058565f, 0.04146529f, -0.03846145f, -0.00847095f, -0.05028060f, -0.06456818f, 0.00994197f, 
    -0.04628976f, 0.01222045f, 0.01113410f, -0.01656711f, -0.00957864f, -0.02662753f, 0.01270643f, -0.01623729f, 
    0.01861589f, -0.01633950f, -0.00903024f, -0.01242777f, 0.02354918f, -0.01538245f, 0.03024147f, 0.01824585f, 
    0.00771606f, 0.02387095f, -0.01445797f, 0.02848654f, -0.04992023f, -0.00724573f, -0.02406677f, -0.00679396f, 
    -0.02642026f, 0.01605254f, 0.03496738f, 0.00313077f, -0.02633463f, -0.00176597f, -0.05157112f, -0.00416995f, 
    0.02543710f, -0.03062236f, 0.04251768f, -0.02756446f, 0.01986569f, -0.01568340f, -0.05031298f, -0.00286056f, 
    0.00497031f, 0.00391239f, 0.03522104f, -0.03956783f, -0.03154957f, 0.04073920f, 0.03815075f, -0.03547308f, 
    0.02882156f, -0.02402313f, 0.03800789f, 0.00944409f, -0.01574177f, -0.01465951f, 0.01119580f, 0.04341711f, 
    -0.01930264f, 0.01553375f, -0.03467607f, -0.03923346f, 0.04243307f, -0.06051154f, -0.04410048f, 0.01062566f, 
    0.02612894f, 0.05032082f, -0.00691063f, -0.00604829f, 0.03196499f, -0.01506268f, 0.05346157f, 0.03333920f, 
    -0.03572165f, -0.02554654f, 0.02153629f, 0.00225493f, -0.05670501f, -0.05621960f, -0.05624380f, -0.03096748f, 
    -0.05433174f, 0.03528310f, 0.03147564f, -0.01467235f, 0.02021156f, -0.04226578f, -0.01246976f, -0.04034973f, 
    -0.02228273f, 0.02169557f, -0.02469405f, 0.03441216f, -0.03844403f, -0.04866288f, -0.01851071f, -0.00126400f, 
    -0.03885659f, 0.03517397f, -0.02976764f, 0.01779261f, 0.02084367f, -0.05575114f, -0.02140517f, 0.00101496f, 
    0.01491680f, -0.02783643f, 0.00943307f, 0.02384072f, -0.04912407f, -0.02905797f, -0.03482250f, -0.03336253f, 
    -0.05131659f, -0.03225692f, -0.01010740f, 0.01694699f, 0.01020071f, -0.03350270f, 0.01432674f, 0.04185138f, 
    -0.06543600f, 0.03682242f, -0.04820260f, -0.01643393f, -0.02883962f, -0.03170101f, 0.01266947f, -0.03343915f, 
    -0.01938034f, -0.04396303f, -0.03217743f, 0.02477791f, 0.04801121f, 0.04628323f, 0.05602341f, 0.00496376f, 
    -0.00735283f, 0.00043086f, -0.00564130f, -0.00238987f, -0.06579579f, 0.03309705f, 0.01973478f, -0.03148009f, 
    0.02927015f, 0.00493758f, 0.01472167f, -0.01642209f, -0.03490015f, 0.05085120f, 0.04652571f, -0.02454453f, 
    -0.02349120f, -0.01359524f, -0.00632622f, 0.03710299f, -0.04389244f, -0.00887656f, 0.01413914f, -0.05620635f, 
    -0.05217654f, 0.02174736f, 0.02849943f, -0.04865104f, 0.02829107f, -0.00812306f, -0.02993099f, 0.03042695f, 
    0.04437263f, 0.01081201f, -0.01606927f, -0.03452468f, 0.04190000f, -0.05121354f, 0.02016424f, -0.04309791f, 
    -0.05718321f, 0.04417020f, -0.00216558f, -0.05407532f, -0.03280756f, -0.03149041f, -0.05676850f, -0.02012466f, 
    0.01737102f, -0.02624132f, -0.04771790f, -0.01003724f, -0.01854173f, 0.04617549f, -0.01287476f, 0.02655681f, 
    0.01381478f, 0.00832519f, 0.01604579f, -0.02469260f, 0.02618895f, -0.02682619f, -0.00349187f, 0.02214204f, 
    -0.04578569f, 0.02840191f, 0.01170306f, -0.04201458f, 0.02510737f, -0.03650711f, -0.04613589f, -0.01832895f, 
    0.01589330f, -0.04426190f, 0.01842171f, 0.03712272f, 0.01175232f, -0.00890300f, 0.01238031f, -0.04922930f, 
    0.01591562f, -0.00248370f, -0.05691837f, 0.00487204f, -0.01223454f, -0.02893698f, 0.03836857f, -0.04786668f, 
    0.05914865f, 0.02231304f, -0.01707741f, -0.04943823f, 0.04763967f, 0.00968626f, -0.01271623f, -0.02388304f, 
    -0.04493465f, -0.04405256f, 0.01930310f, -0.01281616f, 0.02417190f, -0.02749413f, 0.00018371f, 0.03375255f, 
    0.00163229f, -0.04218034f, -0.01849409f, -0.05001565f, -0.05497108f, -0.06367951f, -0.01091462f, -0.01244280f, 
    -0.03084845f, -0.01190113f, -0.06278118f, 0.00454756f, 0.00591392f, 0.00680278f, 0.04317345f, -0.03170466f, 
    -0.03784410f, 0.04412336f, -0.03429261f, 0.02584446f, 0.01076951f, -0.03814805f, 0.01923782f, -0.02258881f, 
    0.02510893f, -0.03885161f, 0.01040137f, 0.00946539f, 0.01399030f, -0.05242723f, 0.02488491f, 0.03992803f, 
    -0.04816567f, -0.01945415f, -0.01572899f, -0.02964427f, 0.03270900f, -0.05159015f, -0.00116810f, 0.04942351f, 
    0.01842177f, -0.01744698f, 0.03369303f, 0.03886165f, 0.01805898f, 0.03286823f, -0.04964950f, -0.05475088f, 
    -0.02617226f, 0.03650587f, 0.04386638f, 0.04776003f, -0.05431029f, 0.02823445f, 0.01056086f, 0.02470511f, 
    -0.04341162f, 0.02131239f, -0.04846323f, 0.01623893f, -0.02846466f, -0.05655767f, 0.04429700f, 0.00487634f, 
    0.25031257f, 0.37092230f, 0.27269697f, -0.02062614f, -0.07515176f, 0.35261056f, 0.19658427f, -0.12741269f, 
    -0.06466982f, 0.03725217f, -0.09473982f, 0.00767458f, 0.06673628f, 0.02704429f, 0.00386173f, 0.08069751f, 
    0.04768635f, 0.07537021f, 0.00140725f, -0.15467244f, 0.08915310f, -0.12363416f, -0.16255297f, -0.55200523f, 
    -0.37935370f, 0.01034629f, -0.05598207f, 0.06818388f, 0.14355028f, 0.00728029f, 0.12388796f, 0.08427247f, 
    0.17468046f, 0.11624853f, 0.12761538f, 0.14139892f, 0.09395869f, 0.07687759f, -0.00813990f, 0.07365043f, 
    -0.00626970f, -0.07523215f, 0.22407143f, -0.18028505f, 0.08309003f, 0.08036859f, 0.05657909f, -0.00847453f, 
    0.20495635f, 0.18342090f, 0.23232180f, 0.04772538f, 0.00716929f, 0.01059545f, 0.09811476f, 0.07376993f, 
    0.15185156f, -0.07699317f, 0.02374035f, 0.02013386f, -0.06041921f, -0.28555864f, -0.04783689f, -0.16834937f, 
    -0.18435897f, 0.09980589f, 0.05147194f, 0.11401470f, -0.00509506f, 0.22508986f, 0.07632359f, 0.14292684f, 
    -0.01118605f, 0.05780410f, 0.04908612f, 0.04447475f, 0.06612322f, 0.19329922f, -0.01672534f, 0.03556867f, 
    -0.11615600f, 0.03038228f, -0.26163557f, 0.06634074f, -0.33025959f, 0.25725853f, 0.10352828f, -0.04060485f, 
    -0.11678816f, 0.31251472f, 0.07968275f, 0.09168762f, 0.13559832f, 0.04465436f, 0.28006071f, 0.25760892f, 
    -0.03794574f, 0.13486537f, 0.05185073f, 0.15197469f, 0.05382294f, 0.46511692f, 0.01046272f, 0.25003481f, 
    0.33713838f, 0.15847009f, -0.02392173f, 0.26769578f, -0.02568612f, 0.02290157f, 0.06749459f, -0.11580598f, 
    0.08881996f, -0.05475204f, 0.06834915f, 0.13413401f, 0.10282211f, 0.20564207f, 0.06953131f, 0.06187702f, 
    0.28548360f, 0.34185767f, 0.14764956f, 0.18105277f, 0.14896359f, 0.19341078f, 0.18012840f, 0.09887122f, 
    -0.02440251f, -0.02980244f, -0.16753018f, 0.12821838f, -0.01088052f, 0.11393323f, 0.06721034f, -0.08434086f, 
    0.10040067f, 0.04665812f, 0.06375986f, -0.04828490f, 0.13907304f, -0.02260336f, 0.33193511f, -0.22603038f, 
    0.19987044f, 0.09198005f, 0.04175925f, 0.18821138f, 0.06642853f, -0.05096421f, 0.12675604f, 0.06515770f, 
    0.11752200f, 0.08402017f, 0.18421128f, 0.08287371f, 0.25270745f, 0.10949674f, 0.06952334f, 0.01203977f, 
    -0.46204254f, -0.39468029f, -0.05649571f, -0.17965509f, -0.23338063f, 0.06878715f, 0.04786843f, 0.10986205f, 
    0.06569166f, 0.14858368f, 0.02408351f, 0.02354296f, -0.02276868f, 0.19464616f, 0.04254264f, 0.04671887f, 
    -0.05113951f, -0.04761332f, 0.04098983f, 0.05708014f, -0.14736350f, 0.10992957f, 0.40455061f, -0.01730729f, 
    0.14110257f, 0.11196740f, 0.28517121f, 0.11393588f, 0.00543594f, -0.00400393f, 0.01369304f, 0.09895483f, 
    0.07114659f, -0.05691546f, 0.24038373f, 0.14925802f, -0.03347398f, 0.20472772f, 0.13350601f, -0.04132817f, 
    -0.13944152f, -0.27686933f, -0.25785699f, -0.05199588f, -0.04079749f, 0.15008323f, 0.04153346f, 0.01973690f, 
    0.13873735f, 0.02674756f, 0.18684709f, 0.01762705f, 0.11418674f, 0.11077624f, 0.00348905f, -0.02827017f, 
    0.06129372f, 0.00704212f, -0.02659191f, 0.42273787f, 0.68258959f, -0.59679496f, 0.07273994f, 0.16259708f, 
    0.20476191f, -0.04783516f, 0.01208997f, 0.05968321f, -0.10486564f, 0.17819771f, 0.11698756f, 0.04528474f, 
    0.08736182f, 0.04022986f, 0.16424367f, 0.09754562f, -0.09749130f, 0.24440092f, -0.05956276f, 0.08194487f, 
    0.52804112f, -0.05739005f, -0.06038714f, -0.02526994f, 0.04956072f, 0.06206561f, 0.26509205f, -0.12013745f, 
    0.07468686f, 0.24026342f, 0.16958024f, 0.03604626f, -0.18572000f, 0.01302734f, 0.09232500f, 0.12061009f, 
    -0.02425196f, -0.05941674f, -0.05730605f, 0.05760036f, -0.23791128f, -0.06509039f, 0.04311414f, 0.00522819f, 
    0.08297960f, 0.06721369f, 0.06723645f, 0.06118988f, -0.14917143f, 0.02104455f, 0.12775563f, 0.04004236f, 
    0.02296564f, 0.03183933f, 0.08247289f, 0.15045388f, 0.00361826f, 0.13227518f, 0.12588194f, 0.04482773f, 
    0.01682472f, -0.26874715f, -0.08209518f, -0.15837963f, -0.11768162f, 0.08148731f, 0.18402508f, 0.00244597f, 
    -0.00384934f, 0.02025974f, 0.10203132f, 0.04441644f, 0.08599011f, 0.09891261f, 0.15647362f, 0.04155048f, 
    -0.01814250f, 0.04978175f, -0.06643154f, 0.19941652f, -0.24704929f, -0.15106390f, 0.37089109f, -0.03482195f, 
    -0.10281992f, -0.07006083f, -0.00100627f, -0.12170786f, 0.02764278f, 0.05585457f, 0.00860901f, -0.02153620f, 
    0.15002020f, -0.01728931f, 0.13931811f, 0.03050350f, 0.11770650f, 0.08973248f, -0.01182615f, -0.14140393f, 
    -0.02215710f, 0.03076639f, -0.05362717f, -0.02530159f, -0.05458633f, 0.00888364f, 0.02993197f, 0.00258383f, 
    -0.05050554f, -0.00176374f, -0.04342400f, -0.04932867f, 0.03758429f, -0.03423911f, -0.02192358f, 0.05025848f, 
    0.01062429f, 0.02336210f, -0.04516586f, -0.02635106f, -0.00088938f, -0.04222603f, 0.02237682f, -0.00640291f, 
    -0.00383227f, 0.03476844f, 0.02982143f, 0.01376445f, 0.02314166f, -0.01689872f, 0.01820761f, -0.00848490f, 
    -0.01061653f, -0.05222038f, -0.03773465f, -0.03869830f, -0.05704512f, -0.04177441f, -0.01287017f, 0.04536795f, 
    0.00783550f, -0.04453783f, -0.00504762f, 0.05173228f, -0.03634407f, 0.00021773f, 0.01767083f, 0.01719126f, 
    -0.03966267f, -0.00324158f, -0.05850236f, 0.03649974f, -0.06482401f, -0.01095503f, -0.05784283f, 0.00718903f, 
    0.03549901f, -0.05761218f, 0.03428259f, -0.05594403f, -0.00088902f, -0.04841870f, -0.06505188f, 0.02190087f, 
    0.03644643f, -0.05365002f, 0.02082255f, -0.04280417f, 0.02222025f, -0.04778912f, 0.00535795f, -0.04779876f, 
    0.00577315f, -0.01078759f, 0.03795232f, -0.05753310f, -0.01617715f, -0.05447054f, 0.02374310f, 0.05136893f, 
    -0.00593413f, 0.00887059f, -0.03797286f, 0.00030201f, 0.03230317f, 0.04106192f, -0.04223102f, -0.04299516f, 
    -0.03465297f, -0.02042248f, -0.05144583f, 0.03743137f, -0.02208317f, 0.00852850f, -0.02101663f, 0.01263750f, 
    -0.00803466f, -0.02548806f, -0.00583089f, -0.02581479f, 0.01136697f, -0.05041462f, 0.00307209f, 0.01134277f, 
    -0.05182948f, 0.00179872f, -0.00082009f, -0.00934352f, 0.05800210f, -0.05518721f, -0.03173929f, -0.00507279f, 
    0.03503032f, -0.01624569f, -0.03075305f, 0.02115919f, -0.03439064f, 0.05765340f, -0.00058203f, 0.00037151f, 
    -0.00087373f, -0.03560573f, 0.02967318f, 0.03314460f, 0.02931478f, 0.04513460f, 0.03498507f, 0.04457356f, 
    0.02261498f, -0.01796532f, 0.04321851f, -0.05238736f, 0.04233949f, -0.00779301f, -0.03830281f, -0.02108347f, 
    -0.05870722f, -0.05433241f, -0.03371676f, -0.03117992f, -0.04655162f, -0.04743781f, 0.03061458f, 0.03109490f, 
    -0.00144671f, 0.04300264f, 0.01586041f, -0.02554891f, -0.01182049f, -0.01460822f, -0.01952991f, -0.01340305f, 
    0.01562956f, 0.05028781f, -0.01041462f, 0.05286080f, -0.04060880f, -0.00813609f, 0.02036008f, 0.01523274f, 
    0.00497503f, -0.02121732f, -0.02683720f, 0.03432528f, -0.00397147f, -0.00068828f, 0.00945410f, -0.00833099f, 
    0.03039862f, -0.01481553f, 0.00256732f, 0.01254283f, 0.00608732f, -0.04882509f, -0.04642883f, 0.00098608f, 
    -0.04968826f, 0.03365451f, -0.03441107f, 0.02225816f, -0.02801319f, -0.05532443f, 0.02920647f, -0.01023651f, 
    -0.05861405f, -0.00535106f, -0.06220885f, -0.05415839f, -0.04051349f, -0.02282934f, -0.04439143f, 0.02107524f, 
    -0.00884936f, 0.04742988f, 0.02908786f, -0.01839894f, -0.01368699f, 0.03681332f, -0.02867045f, 0.00448701f, 
    -0.01076784f, 0.05218688f, -0.01708000f, 0.03605410f, 0.04396557f, 0.02447874f, -0.03537165f, 0.03489662f, 
    -0.00609891f, 0.00855303f, 0.04892527f, -0.01622198f, 0.05265331f, -0.00309398f, 0.00771483f, -0.05772246f, 
    0.00407883f, 0.00665557f, -0.05113531f, -0.05120526f, 0.01642821f, 0.03642495f, 0.01755334f, -0.04696745f, 
    0.01698585f, 0.01105003f, 0.05321836f, 0.00901997f, 0.00303894f, 0.04259849f, 0.00202867f, -0.02524225f, 
    -0.05037275f, 0.02214548f, 0.05015724f, -0.03360300f, 0.01698390f, -0.00124433f, 0.01779478f, 0.04238681f, 
    0.01308857f, -0.01194607f, 0.05553754f, -0.03859764f, 0.03567810f, 0.01098116f, -0.04987715f, 0.02345075f, 
    -0.05703900f, 0.04576814f, 0.01151874f, 0.00767896f, 0.03035946f, 0.04566564f, -0.01857011f, -0.04873955f, 
    0.04023933f, -0.04286451f, -0.04919152f, 0.03920746f, -0.03954808f, 0.01239964f, -0.05732492f, 0.01749632f, 
    -0.00752669f, -0.01289372f, -0.01109396f, -0.01612235f, -0.03885201f, 0.02348454f, 0.02398490f, 0.00387952f, 
    -0.02040874f, -0.04323804f, -0.01119517f, -0.04298897f, -0.01408769f, -0.02743566f, -0.02682373f, -0.01788964f, 
    0.00356750f, -0.02029437f, -0.03506026f, -0.03708847f, 0.03661093f, 0.03135580f, 0.01982702f, 0.00482909f, 
    -0.06141677f, -0.05004489f, -0.02286349f, -0.04456201f, -0.02910334f, -0.04268317f, -0.03702440f, -0.05575776f, 
    0.00786048f, 0.02927515f, -0.05023176f, -0.04486083f, -0.02879307f, -0.01614133f, -0.02268241f, -0.04693451f, 
    -0.05036895f, 0.02478203f, -0.00083049f, -0.05849183f, -0.00961846f, 0.02725453f, 0.02305347f, -0.00924420f, 
    -0.03793285f, -0.05614003f, 0.00694276f, 0.04486100f, -0.05030872f, -0.01751013f, 0.03183826f, 0.02074973f, 
    0.11308596f, -0.42518565f, 0.03107051f, -0.01068362f, 0.08969411f, -0.30874375f, 0.14032185f, -0.09308844f, 
    0.03403678f, 0.05554510f, -0.12750831f, -0.04983754f, 0.23075375f, -0.04869305f, -0.01015343f, -0.10902081f, 
    -0.06259891f, 0.03512420f, 0.04767019f, 0.14148206f, 0.05437181f, -0.03146590f, 0.25537276f, 0.27545950f, 
    -0.14186873f, -0.16416454f, 0.06029347f, -0.03745059f, 0.04630259f, 0.03844228f, 0.01343375f, 0.03789498f, 
    0.08096107f, 0.08096193f, 0.06326898f, -0.05698826f, 0.10507903f, 0.00317203f, -0.04150026f, 0.01663455f, 
    -0.61322272f, 0.52953649f, -0.17433093f, 0.30570358f, -0.23081978f, 0.29837984f, -0.09453831f, 0.10469498f, 
    -0.04316943f, 0.17683560f, -0.02663890f, 0.08667782f, 0.16930524f, -0.08242716f, -0.03073666f, 0.08701506f, 
    -0.03946558f, 0.01679333f, 0.00882895f, 0.00801186f, 0.10655650f, -0.07887018f, -0.37066132f, 0.33927688f, 
    -0.14874652f, 0.26861835f, -0.01611253f, 0.19595370f, 0.07369189f, 0.17954125f, 0.05323966f, -0.06100505f, 
    0.09760664f, 0.07308009f, 0.14649986f, 0.00728546f, 0.10280862f, -0.03147258f, 0.13159151f, -0.25473309f, 
    0.41653192f, 0.29467025f, -0.21846023f, 0.14304592f, -0.21650085f, 0.06885917f, -0.06535697f, -0.01279087f, 
    -0.02287009f, 0.11068033f, -0.08044302f, 0.10621858f, 0.14591053f, 0.11868981f, -0.13948587f, 0.06140824f, 
    0.07728019f, -0.01459915f, 0.04092640f, -0.00627539f, 0.33174932f, -0.09650462f, 0.18885913f, -0.15127955f, 
    -0.09453847f, -0.02879907f, -0.10342468f, 0.05497819f, -0.05606356f, -0.08381725f, 0.10590343f, 0.01033415f, 
    -0.06983294f, 0.12185095f, 0.18709724f, 0.01609432f, -0.06846343f, 0.11035436f, -0.01170084f, 0.03987086f, 
    0.15102723f, -0.04111726f, 0.33729199f, -0.19551414f, 0.03653158f, 0.06018208f, 0.20636764f, -0.04940316f, 
    -0.00622522f, -0.20100749f, -0.04528207f, 0.08744531f, -0.11742949f, -0.01993616f, 0.04034412f, 0.04415891f, 
    0.12160282f, 0.08896127f, 0.11597844f, 0.09493870f, 0.71384162f, 0.06081133f, -0.18668570f, 0.04502819f, 
    -0.35177976f, 0.00375865f, -0.12759683f, 0.02948182f, -0.07947429f, 0.04364668f, 0.11932916f, 0.03043438f, 
    0.13165860f, -0.02805578f, -0.07242610f, 0.18592763f, 0.03081159f, -0.05307224f, -0.13144690f, 0.27629295f, 
    -0.27492908f, -0.25451714f, -0.01148803f, 0.37837362f, -0.14570446f, -0.01433383f, 0.01373223f, 0.00880837f, 
    -0.03998168f, 0.14645852f, -0.15813300f, 0.01707420f, 0.06159816f, -0.02939279f, 0.18620975f, -0.00241705f, 
    -0.17794055f, 0.04899902f, -0.09705698f, -0.02286467f, 0.04359100f, 0.16361353f, 0.21269917f, -0.11108430f, 
    0.48422652f, -0.04541185f, -0.05948198f, -0.21913780f, 0.01407545f, 0.01558148f, -0.13111134f, 0.01844990f, 
    0.00829016f, 0.08017082f, 0.08161925f, 0.10251056f, 0.11975608f, 0.03939046f, 0.08741612f, -0.02514960f, 
    -0.12718612f, -0.41801867f, -0.11868703f, 0.41148284f, 0.02962864f, 0.06103075f, -0.10753471f, -0.27062756f, 
    0.18049282f, 0.21773781f, -0.05328923f, -0.00816533f, -0.06949919f, -0.10362557f, 0.06320564f, 0.00849936f, 
    -0.05832414f, -0.10720778f, 0.06398674f, 0.14482927f, -0.27742228f, 0.08504548f, 0.15564474f, -0.12416332f, 
    -0.02824818f, 0.23601875f, 0.03263301f, 0.09467797f, -0.06019210f, -0.05136709f, -0.08286738f, -0.13324758f, 
    0.10525109f, 0.11673082f, -0.02917749f, -0.01056136f, 0.02142217f, -0.08517427f, 0.08677221f, -0.08095030f, 
    -0.21753944f, 0.37873492f, -0.36074421f, 0.03048713f, -0.19876051f, 0.21478963f, 0.14662582f, 0.09378601f, 
    -0.11605905f, 0.06010917f, 0.08352454f, -0.12359724f, -0.05373079f, -0.10180642f, 0.00584726f, 0.11880652f, 
    -0.03838608f, -0.01877919f, 0.08181515f, 0.12213806f, -0.30375814f, -0.08087981f, 0.28363797f, -0.39603758f, 
    0.04224271f, -0.34883434f, 0.08953469f, 0.20744975f, -0.03868545f, 0.15893240f, -0.18212539f, -0.03424217f, 
    -0.04245413f, -0.14664452f, 0.00688257f, -0.15278195f, -0.01318281f, -0.09094630f, -0.04991661f, -0.01118741f, 
    -0.37039906f, -0.34340873f, -0.10399862f, 0.57905155f, -0.07036356f, 0.02758223f, 0.14297768f, 0.03820278f, 
    0.19441473f, 0.12636676f, -0.10597286f, 0.11879188f, -0.13386476f, 0.14376155f, 0.18704729f, 0.00657862f, 
    -0.06444741f, 0.09516189f, -0.01443746f, -0.13247678f, -0.07421198f, -0.34291476f, 0.12426833f, -0.08293537f, 
    -0.04991405f, 0.04556961f, 0.09789214f, 0.11797045f, 0.03898287f, 0.06213730f, -0.08923639f, -0.03731441f, 
    -0.13149703f, 0.07050765f, 0.02941191f, 0.00293098f, 0.13242057f, 0.05189061f, 0.09387878f, 0.00766334f, 
    -0.03258123f, 0.03476898f, 0.00947308f, 0.03644411f, 0.03191776f, -0.01830743f, -0.02699214f, 0.02411293f, 
    -0.02819446f, 0.04343715f, 0.02441023f, -0.03930956f, 0.02396464f, 0.03011198f, 0.04493859f, -0.04310972f, 
    0.02732396f, -0.00734878f, -0.00489563f, 0.00464544f, -0.01732047f, -0.00004594f, -0.00868482f, -0.05075149f, 
    -0.02952406f, -0.05445287f, 0.01216003f, 0.00554338f, 0.02876895f, -0.02492482f, 0.03025017f, 0.03999365f, 
    -0.00780665f, -0.01498054f, 0.04504124f, -0.03666387f, -0.01166651f, 0.01216983f, -0.02947218f, -0.02616609f, 
    0.02710874f, 0.02982728f, -0.01086454f, 0.00946094f, 0.01184272f, -0.04314470f, -0.01027430f, -0.02628326f, 
    0.02930032f, -0.03050194f, 0.03618146f, 0.00347734f, -0.02480739f, 0.02987566f, -0.00458523f, 0.04399368f, 
    -0.01002979f, -0.04423348f, -0.00598207f, -0.02747081f, -0.01605049f, 0.04315633f, -0.02510528f, -0.04144900f, 
    0.00272590f, -0.00603149f, -0.01747621f, -0.02432892f, 0.00422746f, -0.02258535f, 0.01273658f, 0.00734838f, 
    0.01962063f, 0.01132261f, 0.03391209f, 0.04808884f, -0.01625400f, -0.03710522f, 0.01754715f, 0.03996474f, 
    -0.00660670f, -0.05099732f, 0.02265417f, 0.01264513f, -0.04740300f, -0.04806707f, -0.03662919f, -0.04210060f, 
    0.02188145f, 0.04077285f, -0.05747832f, -0.02207571f, -0.06070203f, -0.02395827f, 0.04169451f, 0.01341499f, 
    0.04879000f, -0.01630696f, 0.01947987f, 0.04481196f, 0.02664044f, 0.02287703f, 0.02177229f, 0.03984554f, 
    -0.00520272f, 0.03302943f, 0.04512026f, -0.04706085f, 0.02979751f, 0.04618810f, -0.04638937f, 0.01543210f, 
    -0.05521277f, 0.02260181f, -0.01504385f, -0.04252303f, -0.00949125f, -0.05535770f, -0.03277994f, -0.03354685f, 
    -0.02375868f, -0.05105251f, -0.01424064f, -0.01355269f, -0.05683287f, -0.05335568f, -0.03145214f, -0.03535831f, 
    -0.05342905f, -0.04257389f, -0.00896603f, -0.04280628f, 0.00029324f, -0.00970278f, -0.02956858f, -0.01576073f, 
    0.02042179f, 0.01757365f, -0.05145709f, -0.03602838f, -0.04742409f, -0.01355077f, -0.02340179f, 0.00073392f, 
    -0.05200038f, 0.03229094f, -0.05073482f, 0.01916250f, -0.04889299f, -0.06139277f, -0.04500424f, 0.01859163f, 
    0.00212230f, -0.00972747f, -0.04702115f, 0.04215687f, -0.05456646f, -0.01454784f, 0.02180409f, 0.00585174f, 
    -0.02620562f, 0.04016558f, -0.03487750f, 0.00188956f, 0.00482527f, 0.04331814f, 0.02809324f, 0.00220957f, 
    -0.05264118f, -0.03810389f, 0.00669828f, -0.00843096f, 0.04843399f, -0.03881548f, 0.02806907f, 0.01458518f, 
    0.02049229f, 0.02662539f, 0.00382512f, -0.01801978f, 0.03862350f, -0.05809793f, -0.04423765f, -0.06125890f, 
    -0.04603590f, 0.04558327f, -0.01328030f, 0.04544835f, 0.00426028f, 0.01226313f, -0.05272485f, -0.03750385f, 
    -0.05855318f, 0.02672321f, -0.02415937f, -0.03724834f, -0.00788991f, -0.02573587f, -0.00422865f, 0.02521702f, 
    0.02822921f, -0.00946106f, 0.03173020f, -0.03236546f, 0.02574880f, -0.00876466f, -0.04506624f, 0.01857609f, 
    0.02430323f, -0.02560491f, -0.03097814f, 0.00418858f, -0.00862200f, -0.01272208f, 0.04577739f, -0.00044473f, 
    0.01667744f, 0.01887970f, 0.01231016f, -0.00738377f, -0.02788793f, -0.04953980f, -0.00237642f, -0.05761945f, 
    -0.03369587f, -0.02141674f, -0.01335812f, 0.02526040f, -0.05099241f, 0.04965863f, 0.02756303f, 0.03144580f, 
    -0.01245251f, 0.02575029f, -0.04693070f, -0.01924436f, 0.00780929f, -0.01026417f, -0.01951721f, 0.01516158f, 
    0.03395456f, -0.05956707f, 0.01263676f, -0.02744215f, -0.02650213f, 0.03438173f, 0.02676201f, -0.01457636f, 
    0.00665819f, 0.00780874f, 0.03948347f, 0.02245999f, -0.02786713f, 0.02892624f, -0.01256001f, -0.01999178f, 
    -0.01989804f, -0.03593315f, -0.03462891f, 0.03224904f, 0.03732512f, 0.04513070f, -0.01018163f, 0.04723418f, 
    0.04320064f, 0.00322904f, -0.03861156f, -0.06016719f, -0.04982254f, 0.01557636f, -0.00606974f, 0.00878154f, 
    -0.02991208f, -0.04070723f, -0.05435343f, -0.05231671f, 0.04883531f, -0.03541542f, -0.02335525f, -0.02145253f, 
    -0.04819616f, -0.00122952f, 0.03219523f, -0.02123321f, -0.01779861f, -0.00970005f, -0.02268638f, 0.02825079f, 
    0.03205560f, -0.04228187f, 0.01638652f, 0.00040101f, -0.05288257f, -0.02104678f, -0.03583335f, -0.01454939f, 
    0.00378278f, -0.04677807f, 0.04868961f, 0.00336545f, -0.01966685f, 0.01754841f, 0.00377203f, 0.00316061f, 
    -0.05411651f, -0.04009652f, -0.01694074f, -0.03364921f, -0.02392690f, -0.01558411f, -0.03629709f, -0.06069954f, 
    -0.05173732f, -0.02184429f, -0.05348676f, -0.05844661f, 0.00859108f, -0.03191074f, -0.03881197f, -0.04082145f, 
    0.23524956f, 0.35711864f, 0.57500285f, 0.12425409f, -0.57725340f, 0.05448636f, -0.23129641f, 0.00856381f, 
    0.09753995f, 0.20766051f, 0.22746980f, 0.04239842f, 0.01050806f, 0.13359772f, 0.10412907f, 0.15881771f, 
    -0.15540467f, -0.13374999f, 0.07011543f, -0.06845683f, 0.02323366f, -0.01017012f, 0.07162178f, -0.11871150f, 
    0.09445848f, -0.09682538f, -0.00751218f, 0.01953148f, 0.03220012f, 0.10697436f, 0.06862121f, -0.03022685f, 
    -0.02026899f, 0.07286350f, 0.19542770f, 0.09342046f, -0.00759281f, -0.05256965f, -0.00084408f, 0.21825336f, 
    -0.07858490f, -0.05822180f, -0.11994071f, 0.01187871f, 0.01789700f, 0.12128866f, 0.13987075f, -0.02624867f, 
    -0.03494228f, -0.11189725f, -0.01944379f, 0.11299583f, -0.06950193f, 0.13065003f, 0.07314390f, 0.00537162f, 
    0.14938344f, 0.05645657f, -0.02798339f, 0.03701866f, 0.17688407f, 0.31157795f, -0.18041937f, -0.16637526f, 
    0.04119397f, -0.03125444f, -0.05481007f, 0.19736217f, 0.07795860f, 0.03374378f, 0.00732164f, 0.05079197f, 
    -0.01397972f, 0.13942005f, 0.00040562f, 0.15974241f, -0.06848316f, 0.00289782f, -0.14440413f, 0.22465497f, 
    -0.11647931f, 0.00561237f, -0.18579929f, -0.12813558f, -0.14033046f, 0.33857578f, 0.10371095f, -0.12404022f, 
    0.00498845f, 0.12814978f, -0.06845314f, 0.02435387f, -0.11808208f, 0.06635465f, 0.14526601f, 0.04877266f, 
    0.01684612f, -0.03737338f, 0.06567418f, -0.01673003f, -0.15944846f, -0.22090793f, 0.07264986f, 0.13373567f, 
    0.07576884f, 0.27944547f, 0.25713021f, -0.06032342f, 0.02514102f, -0.00857501f, 0.11590607f, -0.05131590f, 
    -0.00640600f, -0.11450535f, -0.17742521f, -0.03712106f, 0.17891194f, 0.10554995f, -0.13571657f, -0.06598850f, 
    -0.07411924f, 0.09591346f, 0.01364035f, 0.27760571f, 0.12578002f, 0.10220246f, 0.03164842f, -0.04752817f, 
    0.08862146f, 0.28856266f, 0.11611513f, -0.03169203f, 0.07264412f, -0.00040884f, 0.02573873f, 0.02927329f, 
    0.09377558f, -0.01793265f, 0.02686784f, 0.05153039f, -0.31072441f, -0.48006943f, -0.04076833f, -0.13360025f, 
    0.26280853f, 0.18853477f, -0.05140472f, 0.18720211f, -0.03392856f, 0.03502473f, 0.00018811f, -0.06896558f, 
    -0.09330066f, 0.03108121f, -0.12064456f, -0.00699260f, -0.14873391f, -0.01542375f, 0.03769586f, -0.05621451f, 
    -0.09439146f, -0.02502950f, -0.18672220f, 0.05500951f, 0.47192699f, 0.02674827f, 0.05210025f, 0.04635619f, 
    0.01418875f, -0.12089555f, -0.07691129f, -0.06875648f, -0.00386766f, 0.07397700f, -0.13067992f, 0.11558209f, 
    0.11686429f, -0.01672389f, 0.06008118f, -0.04829712f, -0.18997765f, 0.54812646f, 0.13372956f, 0.06314981f, 
    -0.48796552f, -0.07077917f, 0.04008492f, 0.04688441f, 0.07987902f, 0.06651828f, 0.11356135f, 0.00354863f, 
    -0.00619956f, 0.03052211f, 0.04693712f, -0.07983141f, -0.02087133f, 0.02387910f, -0.05906396f, 0.21443628f, 
    -0.33286983f, 0.23836336f, -0.20671424f, -0.18538128f, 0.41743305f, 0.10562412f, 0.22187330f, 0.20421508f, 
    0.25105947f, -0.01877431f, 0.14400886f, 0.03795025f, -0.02649178f, -0.05651648f, -0.03442425f, -0.11857048f, 
    -0.15143830f, 0.01241665f, 0.04431674f, -0.09940824f, -0.12842138f, -0.16655572f, -0.24822450f, -0.10004025f, 
    0.05688796f, -0.04154282f, 0.06985360f, 0.10745622f, -0.01211488f, -0.05720291f, -0.10593157f, 0.00482219f, 
    -0.09772803f, -0.07640794f, 0.03734885f, 0.14000495f, 0.15419143f, 0.14928360f, -0.15240285f, -0.02515463f, 
    -0.43143129f, -0.39365813f, -0.33967713f, 0.02393614f, -0.08902847f, 0.19778322f, 0.22409210f, 0.04824538f, 
    -0.01777403f, -0.04896731f, 0.02604922f, 0.17163461f, 0.21793729f, 0.24288094f, 0.12000091f, -0.02451207f, 
    0.04715720f, -0.03471965f, -0.21657635f, -0.07108881f, -0.64662576f, -0.28690431f, 0.21054308f, 0.22415632f, 
    0.01833802f, -0.04360777f, 0.07954671f, 0.01322916f, -0.02352316f, -0.07173747f, 0.02927605f, 0.03247324f, 
    0.11033025f, 0.07838403f, 0.05583938f, 0.04693975f, 0.13433243f, -0.07091349f, -0.19120941f, -0.04716326f, 
    -0.42270246f, 0.21393134f, -0.16381000f, -0.11911406f, 0.26123300f, 0.25269556f, 0.04631184f, 0.04385515f, 
    0.15888678f, 0.07292555f, -0.01976187f, -0.00214654f, 0.05708095f, -0.00710526f, -0.08093940f, 0.05974941f, 
    0.07252446f, -0.09543134f, 0.09411084f, -0.00259020f, 0.18021458f, -0.42604315f, 0.15567490f, -0.03069041f, 
    0.21417503f, -0.05552293f, 0.01956280f, -0.02658483f, -0.01016784f, -0.06939647f, 0.18737361f, 0.07401945f, 
    0.05763252f, -0.04731568f, 0.08258567f, 0.15264484f, -0.13352641f, -0.05375436f, -0.06816185f, 0.03578310f, 
    -0.04290792f, -0.04238972f, -0.04355823f, 0.00547960f, -0.03075980f, 0.02997616f, 0.03746734f, 0.00020355f, 
    -0.06208832f, -0.04167641f, -0.00254501f, 0.02041555f, -0.00221736f, -0.04485691f, 0.00557961f, -0.01420215f, 
    0.03164224f, 0.01489641f, -0.02223595f, -0.04987554f, -0.00280426f, 0.02694509f, -0.02986879f, -0.02277132f, 
    -0.04134942f, -0.04499317f, -0.01807813f, 0.02447673f, 0.00311025f, 0.03816425f, -0.00479976f, -0.06213384f, 
    -0.02921185f, -0.00466304f, 0.04745790f, -0.02488270f, -0.02156063f, 0.01875236f, -0.00916969f, 0.00194731f, 
    0.01993519f, -0.04733774f, -0.04000592f, -0.03797038f, 0.01599441f, -0.05443791f, -0.03997812f, -0.00714161f, 
    -0.06139198f, 0.03835009f, -0.04205387f, 0.01822823f, 0.00950262f, -0.00718446f, -0.01974919f, 0.02532538f, 
    -0.02729294f, -0.02551213f, -0.01886014f, -0.00551815f, 0.02631284f, 0.02653811f, 0.01700507f, -0.06364813f, 
    -0.00565994f, -0.05829035f, 0.03532190f, -0.03274381f, 0.01225278f, -0.02493647f, -0.00536451f, -0.04079625f, 
    0.00248623f, -0.05927097f, 0.01774994f, 0.01423750f, 0.01174703f, -0.05724146f, -0.03443308f, 0.04097481f, 
    0.03495387f, -0.02852022f, -0.03793437f, -0.02470310f, -0.05007866f, -0.00972741f, 0.04271830f, -0.02089999f, 
    0.01148945f, 0.04423599f, -0.05330450f, 0.00467637f, -0.03606132f, -0.04507894f, 0.00982531f, 0.00931841f, 
    -0.03518536f, -0.04419903f, -0.06249238f, 0.00312867f, -0.04343679f, -0.03398652f, 0.02392887f, -0.01178741f, 
    -0.00374172f, 0.02393948f, -0.02281875f, -0.04575805f, 0.04176203f, -0.00283328f, 0.05184902f, -0.03027642f, 
    -0.03512701f, -0.05723780f, -0.02969955f, 0.00185913f, 0.04184537f, 0.03089855f, 0.01279794f, -0.00559973f, 
    -0.02286664f, 0.01381047f, 0.03980486f, -0.02439250f, 0.02554887f, 0.02952136f, -0.05638917f, -0.01387798f, 
    0.00548168f, -0.04231510f, -0.00333805f, -0.06016118f, -0.01188302f, 0.04761257f, -0.05915972f, 0.05351283f, 
    0.02160924f, -0.03859835f, 0.00903474f, 0.03310486f, -0.05119848f, -0.03062920f, -0.04282113f, 0.04103238f, 
    -0.03424216f, 0.02319710f, 0.00215016f, -0.00727971f, -0.03429880f, -0.01406154f, 0.03742700f, -0.00889234f, 
    0.02367791f, -0.01871043f, -0.04776239f, -0.01763893f, 0.04492544f, -0.02469611f, 0.01784594f, -0.05778791f, 
    -0.03802065f, -0.01073566f, -0.06407074f, 0.02279058f, -0.03519604f, -0.02387267f, -0.01000531f, -0.03750587f, 
    0.01539595f, -0.02062154f, -0.05053933f, 0.04038917f, -0.02645330f, 0.01435702f, 0.03349459f, 0.00365121f, 
    -0.01698318f, -0.00968606f, 0.02548373f, 0.00394981f, 0.03638043f, -0.00147482f, 0.04504667f, 0.04483762f, 
    -0.02245627f, -0.05139448f, -0.05683014f, -0.05403996f, 0.01201268f, -0.04969469f, 0.01461555f, -0.04217141f, 
    0.02494465f, -0.05095008f, -0.05182704f, 0.04448668f, -0.00435498f, 0.01354470f, -0.00577525f, 0.04170394f, 
    -0.03591735f, -0.01808780f, 0.00568911f, -0.03066527f, 0.04197535f, 0.03660653f, -0.05765541f, 0.02015402f, 
    0.01669662f, 0.00591831f, 0.01331016f, 0.01663362f, 0.04415284f, -0.05117998f, -0.00854995f, -0.05597480f, 
    -0.02757379f, 0.00501542f, -0.05143506f, -0.02766173f, 0.00002829f, -0.05508604f, -0.01219373f, 0.03307907f, 
    -0.00547940f, -0.02839396f, -0.02016851f, 0.02359007f, 0.02352880f, 0.01218100f, -0.06340475f, -0.05039874f, 
    0.02721798f, -0.02067691f, -0.03982686f, 0.01211837f, -0.05024452f, 0.00585158f, 0.04118427f, 0.01362349f, 
    0.03648899f, 0.04403381f, -0.00216439f, 0.03023109f, 0.00129476f, 0.03830050f, 0.01472658f, -0.01135615f, 
    0.03113326f, 0.01736326f, 0.04381593f, 0.00824315f, 0.01332151f, -0.02151537f, 0.03295914f, -0.03739728f, 
    -0.04680654f, 0.00128776f, -0.05626134f, -0.04317740f, -0.00239349f, 0.01724312f, 0.02029211f, 0.01017929f, 
    0.03296617f, 0.01920576f, 0.01613316f, -0.02792265f, 0.02975489f, -0.05618107f, -0.02043448f, -0.00006677f, 
    0.02183103f, -0.04758923f, -0.01189939f, 0.04256954f, -0.02696509f, -0.00620728f, -0.05344817f, -0.03621619f, 
    -0.00067168f, 0.01026078f, 0.03729371f, -0.04631051f, 0.00714642f, -0.02833151f, 0.03022919f, -0.00303495f, 
    -0.00984088f, 0.00857480f, 0.00702589f, -0.04395268f, 0.03662211f, -0.04214871f, 0.04611257f, -0.02556283f, 
    0.01066524f, -0.00495576f, -0.02083018f, 0.00261311f, -0.03336004f, 0.01213973f, -0.03336390f, 0.03440296f, 
    0.02108217f, 0.00510029f, 0.04256161f, 0.03508712f, -0.02820530f, -0.01810065f, -0.05814208f, -0.02983892f, 
    -0.04770983f, -0.04963302f, -0.02186579f, -0.02125315f, 0.01437058f, -0.01084851f, -0.04179606f, -0.03689280f, 
    -0.29924744f, -0.23351081f, -0.14150161f, 0.08306850f, 0.12616175f, -0.06667436f, 0.05806962f, -0.08375013f, 
    -0.06329674f, 0.09156474f, -0.01888592f, -0.02343041f, 0.09942915f, 0.11806471f, 0.09442798f, 0.03375258f, 
    -0.00891763f, 0.16152258f, 0.09504753f, 0.08968824f, 0.20148611f, 0.12751918f, 0.15276596f, 0.11090112f, 
    0.18139395f, 0.02490122f, -0.17509302f, -0.05914718f, -0.09018993f, -0.03368390f, -0.14199340f, 0.00906189f, 
    0.05037353f, 0.12163422f, 0.18275490f, -0.07554328f, 0.16388381f, -0.03392519f, -0.28939620f, -0.10058237f, 
    0.23044865f, 0.28302184f, -0.23929840f, -0.21831480f, -0.00202353f, -0.07865810f, 0.07498933f, 0.16263573f, 
    0.06321066f, -0.05188784f, 0.08548553f, -0.04130032f, 0.07458793f, -0.12160008f, 0.06390376f, 0.13828036f, 
    0.15907340f, -0.09864408f, 0.19474141f, -0.12719905f, -0.18835959f, 0.14371279f, 0.15964459f, 0.26538602f, 
    0.07549918f, 0.13734752f, 0.03480253f, -0.06454661f, -0.09265638f, 0.16499481f, -0.03206702f, 0.23295619f, 
    -0.03770625f, 0.02332425f, -0.02022908f, 0.00008540f, 0.01496791f, -0.00653030f, -0.10675699f, -0.08065215f, 
    0.01391229f, -0.22911867f, 0.09995413f, 0.25718188f, 0.03852974f, 0.09512048f, -0.02218061f, -0.04054904f, 
    -0.03946926f, -0.01680628f, -0.02411373f, 0.04265619f, 0.02077699f, -0.09174234f, -0.06590729f, 0.04300886f, 
    0.14008804f, 0.13011725f, -0.15469348f, 0.08587929f, 0.20007651f, 0.03797637f, -0.26703599f, 0.02327947f, 
    0.22440553f, -0.20006189f, -0.04830142f, -0.01942112f, -0.13854392f, -0.04346571f, 0.11164849f, 0.04476606f, 
    -0.22076094f, 0.10583390f, 0.07733665f, -0.07567413f, 0.16579530f, 0.05841826f, 0.12647520f, 0.00825677f, 
    0.03780682f, 0.24277656f, 0.07972883f, 0.14769813f, -0.07486536f, -0.02322119f, 0.09338926f, -0.03518626f, 
    -0.12867898f, 0.03636098f, 0.10856063f, -0.08196074f, -0.14642943f, 0.02752423f, -0.00992845f, -0.05451721f, 
    0.08867025f, 0.13519315f, 0.09453490f, 0.08406349f, -0.27456143f, 0.05724206f, 0.06049000f, 0.02189562f, 
    0.04921931f, -0.12892729f, 0.01471080f, 0.18532872f, 0.02603453f, -0.05339220f, 0.08633641f, 0.23636127f, 
    -0.08037382f, 0.01470685f, 0.00857674f, -0.02195889f, -0.12928414f, -0.02032394f, 0.03258765f, -0.01246882f, 
    0.12798873f, 0.10430355f, 0.14808400f, -0.03564078f, 0.13221048f, -0.08905178f, -0.04847864f, 0.03054889f, 
    0.08054939f, 0.06685675f, 0.05349302f, -0.09764133f, 0.09962592f, -0.01794711f, 0.01146958f, 0.05020628f, 
    0.03667809f, -0.21186076f, -0.08526114f, 0.09065741f, -0.29441717f, -0.29794398f, -0.02686251f, 0.10008082f, 
    0.06147614f, -0.04287350f, -0.05713243f, -0.11166871f, -0.21279189f, -0.10048828f, 0.08440276f, -0.07702891f, 
    0.15032685f, 0.21790996f, 0.10952754f, -0.06021677f, -0.01268899f, -0.14179620f, 0.15749058f, -0.16078793f, 
    0.11939432f, 0.04301748f, 0.17553110f, 0.00095614f, 0.07919046f, 0.07935266f, -0.10900836f, -0.08136342f, 
    0.04246981f, -0.01621597f, 0.03369628f, 0.06741317f, -0.12444867f, 0.33472997f, 0.02567627f, 0.06237332f, 
    0.19655916f, -0.06513790f, -0.09776665f, 0.18259509f, -0.44346419f, -0.09078863f, 0.11297834f, 0.05344628f, 
    -0.15986928f, 0.05153439f, 0.03400454f, -0.27115101f, -0.10110891f, 0.05171080f, 0.02555138f, 0.05094291f, 
    0.01149447f, -0.23656893f, -0.01271327f, 0.02960893f, 0.06109807f, 0.19449760f, 0.19432898f, 0.01769152f, 
    0.01688767f, 0.21444397f, 0.05534276f, 0.02272059f, -0.11500204f, -0.05685157f, -0.05678494f, 0.12766103f, 
    0.01786675f, -0.17271052f, -0.05072668f, -0.05052695f, -0.17990755f, -0.08919559f, 0.02064701f, 0.13138095f, 
    0.09286515f, 0.10085347f, 0.16978709f, 0.02936401f, -0.09567939f, 0.29297107f, -0.18695718f, 0.24138094f, 
    0.08991168f, -0.11041634f, -0.03815990f, -0.21762916f, 0.07250706f, 0.12721717f, 0.07344629f, 0.10451490f, 
    0.11715438f, 0.04428567f, 0.08914647f, 0.05459408f, 0.05534203f, -0.32891750f, 0.07669611f, 0.01747414f, 
    -0.24514146f, -0.05192851f, 0.26053566f, -0.04924402f, 0.02957035f, 0.23509695f, 0.05131808f, 0.02382337f, 
    0.09263816f, -0.13248771f, -0.06309783f, 0.07647796f, -0.19351186f, -0.07847968f, -0.00410180f, -0.07097413f, 
    0.03498246f, 0.07674414f, -0.12003183f, 0.02071734f, -0.11407825f, 0.41765502f, 0.18581355f, 0.00876163f, 
    -0.14409481f, -0.02483190f, -0.02513598f, -0.08117490f, -0.06474798f, 0.01789035f, 0.17923391f, 0.15504502f, 
    -0.06126856f, -0.15833844f, -0.00403530f, -0.03708297f, -0.04640584f, -0.11351287f, 0.07591197f, -0.01187448f, 
    0.05746420f, -0.37779287f, 0.30640832f, 0.09261087f, -0.46956488f, 0.01276030f, 0.23945032f, 0.03563699f, 
    -0.04613573f, -0.12467275f, -0.07535567f, -0.03729322f, 0.11670095f, 0.15146148f, 0.06013769f, -0.08061774f, 
    0.00441036f, -0.08679914f, 0.02569857f, 0.09358259f, 0.10136233f, 0.14531803f, 0.01574354f, -0.09057966f, 
    0.19231147f, -0.04644796f, 0.14590973f, 0.00116304f, -0.07744471f, -0.09814423f, 0.09046093f, -0.07713550f, 
    0.03102547f, -0.02959562f, 0.10814971f, 0.12364876f, 0.14603603f, 0.18346298f, 0.08116411f, 0.02188189f, 
    -0.65002221f, 0.27163854f, 0.12250552f, 0.11391832f, 0.24145781f, 0.20424049f, 0.16046605f, -0.01383993f, 
    0.07721903f, 0.16619094f, 0.01924530f, 0.14251849f, -0.04789587f, -0.05651357f, 0.15276885f, 0.01545052f, 
    -0.11980616f, 0.03478906f, 0.07453161f, -0.07828255f, 0.05448907f, 0.04088514f, -0.17343284f, -0.06834070f, 
    0.38858235f, -0.11520901f, 0.06763202f, 0.07359155f, -0.01533981f, 0.10761116f, 0.05667434f, 0.10516714f, 
    0.01488253f, -0.13984506f, 0.05118367f, 0.10254249f, 0.10363826f, 0.06422781f, 0.11448571f, -0.02262683f, 
    0.56987375f, -0.17003129f, -0.23245235f, -0.22310343f, 0.37145454f, 0.17842729f, -0.09692802f, -0.06145051f, 
    -0.00108545f, 0.02782770f, -0.07572810f, -0.01980984f, 0.23066112f, 0.03397764f, 0.06769669f, -0.03320459f, 
    0.12003165f, -0.03485534f, -0.09108528f, -0.16733247f, -0.27340466f, 0.00025651f, 0.10274404f, 0.20973243f, 
    -0.33627662f, 0.20981944f, 0.08092914f, 0.24629979f, 0.01352762f, 0.06045346f, 0.07830311f, -0.06110596f, 
    0.10225073f, -0.01647625f, 0.13397732f, 0.06783459f, -0.14991121f, 0.03576880f, -0.05092036f, 0.07572061f, 
    -0.15981631f, -0.21880622f, -0.04855047f, 0.03179391f, -0.19380441f, 0.17587607f, 0.16182837f, 0.02977890f, 
    0.06124933f, -0.15831111f, 0.05987635f, 0.04241484f, 0.06989350f, 0.02716209f, 0.12827156f, 0.09390496f, 
    0.10375647f, -0.10283121f, -0.00021844f, -0.08619634f, -0.08351047f, 0.21706438f, -0.21630861f, 0.07230471f, 
    0.25123206f, -0.05230306f, -0.10863085f, -0.04919604f, 0.02989882f, -0.09758786f, -0.05927201f, 0.04306423f, 
    0.12898590f, -0.01959515f, -0.03763075f, 0.05670987f, -0.00716146f, -0.05773776f, -0.05030991f, 0.10038578f, 
    -0.16052920f, 0.47969100f, -0.31482381f, 0.11303592f, -0.00061290f, -0.02696856f, -0.00705929f, -0.20987478f, 
    -0.12879497f, -0.04217822f, 0.19098000f, 0.04544454f, 0.00951149f, 0.05563114f, 0.07901015f, 0.01830761f, 
    -0.02175528f, 0.29912201f, 0.06262053f, 0.25665584f, -0.29556006f, 0.19561750f, -0.09271997f, 0.00790935f, 
    -0.26672152f, 0.21010581f, 0.19485459f, 0.04117271f, -0.09853202f, 0.14539802f, 0.05831888f, 0.03219231f, 
    -0.00763019f, -0.01352966f, -0.06105114f, 0.05553272f, 0.06287078f, 0.10005811f, -0.17852178f, 0.06657308f, 
    0.03454755f, -0.25198999f, -0.13094243f, 0.13081674f, 0.16555828f, -0.15317048f, 0.03084314f, -0.05303136f, 
    -0.15265736f, 0.09992880f, 0.12925416f, 0.01783173f, -0.02581918f, -0.11085652f, 0.00411928f, 0.00276253f, 
    -0.07706694f, 0.02774281f, 0.16089208f, 0.09555586f, 0.40510291f, -0.09157697f, -0.24806538f, -0.00403449f, 
    -0.38521272f, 0.21778813f, -0.17532949f, 0.08208645f, 0.09680896f, -0.05658085f, 0.01988196f, -0.15298480f, 
    -0.05449054f, 0.21965578f, 0.08181486f, -0.10403246f, 0.10194854f, -0.14387855f, 0.02088196f, -0.15623838f, 
    -0.32694978f, -0.24621598f, -0.17570478f, 0.12657915f, 0.35427606f, 0.07275331f, -0.14090614f, 0.08419470f, 
    -0.11502985f, 0.08519355f, 0.00977585f, -0.10951838f, 0.13965015f, -0.04287799f, -0.10034262f, -0.05651321f, 
    -0.05766266f, 0.10092414f, 0.02496727f, 0.04459719f, -0.00754777f, 0.11670675f, 0.32010341f, 0.18427467f, 
    -0.35575461f, -0.00101855f, 0.21800664f, 0.07363020f, 0.19321722f, -0.01762750f, -0.07833435f, -0.22475715f, 
    -0.11583491f, -0.05292791f, -0.24944967f, 0.00171172f, 0.12031822f, 0.00459283f, 0.10682452f, 0.17333013f, 
    -0.30325097f, 0.16529186f, -0.06943173f, 0.08310608f, 0.21145591f, 0.08411181f, 0.09922861f, -0.12663268f, 
    -0.12039983f, -0.05925184f, -0.02267698f, 0.05647055f, -0.07465072f, -0.07954718f, 0.05458164f, -0.03481999f, 
    0.10793239f, 0.07863626f, 0.15997273f, -0.12964216f, -0.12234683f, -0.04671133f, 0.02843192f, 0.18919630f, 
    -0.24050723f, -0.11881464f, 0.11784641f, -0.00822989f, 0.21301727f, 0.31046703f, -0.13355343f, -0.01185677f, 
    0.13079268f, 0.21353699f, -0.15830877f, 0.14310531f, 0.06634164f, -0.05756196f, 0.06831058f, 0.08950663f, 
    -0.05665316f, 0.00945867f, -0.05326623f, -0.02421303f, 0.02260559f, 0.01222413f, 0.00030042f, -0.03641249f, 
    0.04316613f, 0.01865870f, -0.06046241f, 0.04080387f, 0.00809225f, -0.05203188f, 0.04752198f, -0.00748612f, 
    0.05087325f, 0.04984308f, 0.02024348f, 0.00801748f, -0.04332168f, -0.04834318f, 0.04221986f, -0.01549595f, 
    -0.04435690f, 0.00134786f, 0.01807586f, 0.00885971f, -0.05239486f, -0.02256640f, 0.00255462f, 0.01417663f, 
    0.04206136f, 0.03884000f, 0.00722250f, 0.03444226f, 0.00108608f, 0.00795735f, -0.01245214f, -0.02446944f, 
    -0.04085251f, -0.04844343f, 0.01163073f, -0.02269037f, -0.03215161f, -0.03139579f, 0.01311578f, -0.01982277f, 
    -0.03248564f, 0.02978229f, -0.03108048f, -0.01102182f, -0.02339107f, 0.03430989f, 0.04850568f, -0.04041561f, 
    -0.02826585f, -0.03296392f, -0.03837767f, -0.01494308f, 0.04526260f, 0.03395509f, -0.01240067f, -0.02527886f, 
    -0.04233535f, 0.01836594f, 0.02602398f, 0.03814083f, 0.03320060f, 0.01782242f, -0.02649307f, -0.06013133f, 
    -0.05818615f, -0.01082253f, 0.03676644f, -0.00780947f, 0.02282542f, -0.04962738f, -0.02618554f, -0.02220070f, 
    -0.01701312f, -0.05132443f, 0.00516391f, -0.00804492f, -0.02078187f, -0.03016408f, 0.04937712f, -0.03687458f, 
    -0.03830754f, 0.00672128f, -0.05920042f, 0.04527014f, -0.04507148f, 0.03637871f, -0.02054013f, 0.03502481f, 
    -0.01598309f, 0.01496305f, -0.04336361f, -0.02345984f, -0.00300695f, 0.05238832f, -0.00324649f, -0.02205972f, 
    0.03503366f, 0.04127333f, 0.00827155f, 0.04956165f, -0.01053231f, 0.00050152f, -0.04877349f, -0.00942047f, 
    -0.04907642f, -0.01781438f, -0.06014721f, -0.01756749f, -0.05701850f, 0.01921260f, -0.05589905f, 0.00301075f, 
    0.01496026f, 0.00951007f, -0.03941864f, -0.05391086f, -0.02875235f, 0.05311754f, 0.05282628f, 0.02274622f, 
    0.03766304f, -0.00326049f, 0.04272936f, -0.00930248f, 0.01341643f, 0.04660039f, 0.01437086f, 0.00894868f, 
    0.01220953f, -0.01144162f, 0.00497777f, -0.06062015f, -0.04479256f, -0.03951710f, 0.04891263f, -0.01684509f, 
    0.04415389f, 0.01627354f, 0.03426800f, -0.05875441f, -0.04226376f, 0.02148245f, -0.03137906f, -0.03777317f, 
    0.01295114f, -0.02636749f, -0.05924332f, -0.05772814f, 0.02209002f, -0.01574730f, -0.01687825f, 0.00833080f, 
    -0.03028678f, -0.05360586f, -0.00995030f, -0.04282976f, 0.01342500f, -0.04477384f, 0.00099798f, -0.04147861f, 
    -0.01250214f, 0.03860905f, 0.01752658f, -0.02089451f, 0.00882885f, -0.05495192f, -0.02785987f, -0.02224516f, 
    -0.03460907f, 0.01579554f, 0.03620464f, -0.00821677f, -0.00844357f, 0.01934611f, -0.01796245f, 0.04037584f, 
    -0.04145109f, 0.01472700f, 0.02466122f, -0.01363430f, 0.00027737f, 0.01962932f, 0.04515649f, 0.02050023f, 
    -0.03610594f, 0.02050316f, 0.03504416f, -0.02459144f, -0.01948722f, -0.01834432f, -0.00438701f, 0.04155998f, 
    0.01703476f, -0.02552214f, 0.02060589f, 0.04458820f, -0.01109255f, 0.03633068f, -0.04146792f, 0.02737131f, 
    -0.04972572f, -0.04796375f, -0.03068528f, 0.03081406f, 0.02263329f, -0.00340166f, -0.03019842f, -0.03180274f, 
    -0.00286926f, 0.04618062f, 0.04144388f, 0.03899846f, -0.00545727f, 0.01090733f, -0.00534966f, -0.03641425f, 
    0.01184045f, 0.04329884f, -0.02026091f, 0.03629557f, -0.04916995f, 0.01655973f, 0.00150389f, -0.00769342f, 
    -0.01650164f, -0.03685783f, -0.03279624f, -0.03681347f, -0.04862249f, 0.00126186f, -0.00479260f, -0.02980244f, 
    0.01650131f, -0.00860694f, -0.01658305f, -0.05701584f, 0.01407450f, -0.01570779f, -0.03119276f, 0.01338261f, 
    -0.02554244f, 0.01200263f, 0.01943030f, -0.04138007f, -0.00297439f, 0.00879434f, 0.02812279f, 0.00715781f, 
    0.02106639f, -0.01817910f, -0.03947414f, -0.04814269f, -0.02650803f, -0.03158581f, -0.00715653f, -0.05421964f, 
    0.00384648f, 0.04754870f, -0.03557773f, 0.00538855f, -0.03821231f, 0.01821962f, -0.05837359f, -0.02108264f, 
    0.03611587f, 0.04343157f, -0.05402721f, -0.01604060f, 0.02250930f, 0.05236644f, -0.05441979f, 0.01466272f, 
    -0.04820464f, -0.02962955f, -0.04574778f, -0.05247821f, 0.01376023f, -0.04876261f, -0.04465758f, -0.05329483f, 
    -0.01908648f, -0.04437493f, -0.03070682f, 0.04906518f, -0.03312951f, -0.02667891f, 0.00326119f, -0.05532986f, 
    0.04224366f, 0.01642630f, -0.05475567f, -0.00933060f, -0.02617589f, 0.00592003f, -0.00889700f, -0.02424739f, 
    -0.01810118f, 0.04333509f, -0.05406925f, -0.01625344f, 0.00704818f, 0.01218254f, -0.04191807f, -0.01016344f, 
    -0.04870089f, 0.06154741f, 0.01490075f, -0.00131213f, -0.00303077f, -0.02115054f, 0.03018896f, 0.04136670f, 
    0.07982483f, 0.37813097f, -0.40666655f, 0.09883913f, 0.20757738f, -0.07831508f, 0.02980060f, 0.08605865f, 
    0.12296014f, 0.09495483f, 0.14259298f, 0.00036216f, -0.01106218f, 0.23849297f, 0.14747868f, 0.12503059f, 
    -0.04558635f, 0.03262704f, -0.05438980f, 0.10114589f, 0.14883420f, 0.34060737f, 0.21959658f, 0.33651087f, 
    0.15617855f, 0.08135607f, -0.07917248f, 0.08153696f, 0.12693571f, 0.08519495f, -0.12784676f, -0.11536651f, 
    0.00086150f, 0.09968001f, 0.05086177f, -0.00475746f, 0.02437038f, -0.14230710f, -0.02593539f, 0.03284607f, 
    0.38365978f, -0.16736102f, -0.32971618f, 0.06603032f, -0.28572437f, 0.09754252f, -0.07057113f, 0.10210347f, 
    -0.04185617f, -0.11537603f, -0.07615110f, -0.03333357f, 0.10600168f, -0.03229907f, -0.09744146f, 0.02557781f, 
    0.13854793f, 0.05887233f, -0.11577358f, -0.03989574f, 0.25839067f, 0.12055894f, -0.19519639f, 0.15552710f, 
    -0.06644980f, 0.13917623f, -0.04362545f, -0.08875661f, 0.09072143f, -0.18090436f, 0.06759011f, 0.04709306f, 
    0.05614764f, 0.02838708f, 0.10637844f, -0.01583560f, 0.06499341f, -0.07392072f, 0.11452527f, 0.03657411f, 
    -0.23979577f, 0.16978091f, 0.15563676f, 0.00095688f, -0.27231276f, -0.14036264f, -0.02139022f, 0.07262892f, 
    0.02762212f, 0.07632429f, 0.07085476f, 0.06920474f, -0.02590949f, 0.01202193f, 0.02893440f, -0.03990281f, 
    0.02143528f, -0.03357235f, -0.01209010f, 0.01711246f, 0.08742245f, -0.24028066f, 0.00093854f, -0.09073621f, 
    0.04524169f, -0.08564488f, 0.07281438f, -0.00416529f, 0.11099184f, 0.00611209f, -0.04335729f, -0.00161385f, 
    -0.19187631f, 0.06330261f, 0.07977667f, -0.01643520f, 0.09725354f, -0.02243092f, -0.04710780f, 0.03970820f, 
    -0.17338307f, -0.16949990f, 0.01882446f, -0.08608165f, -0.19238958f, -0.04051536f, 0.06367555f, 0.03059655f, 
    0.05012504f, 0.16486944f, 0.04056505f, -0.03410568f, -0.02335506f, -0.00312050f, 0.07058141f, -0.07495716f, 
    0.02578477f, 0.09984969f, -0.04242383f, 0.11682706f, 0.09100512f, 0.00089487f, -0.01112393f, 0.18881863f, 
    -0.10920268f, 0.10022612f, 0.05340573f, 0.03527800f, 0.04671854f, 0.23295979f, 0.04183631f, -0.02668302f, 
    0.09241446f, 0.09470984f, -0.03566676f, 0.13169886f, 0.02313394f, -0.01425415f, -0.01289608f, -0.03196615f, 
    0.33335224f, -0.18506458f, 0.08111221f, 0.09003495f, 0.07259618f, 0.02248046f, -0.17426595f, 0.13491237f, 
    0.03793825f, 0.09147677f, 0.00593549f, 0.09073081f, -0.01892830f, -0.08312301f, 0.11535759f, 0.10662086f, 
    0.03545106f, -0.09942845f, -0.14520499f, -0.04642186f, 0.23981370f, -0.47743285f, -0.23151460f, -0.03463279f, 
    0.04567868f, -0.01400730f, -0.11681460f, 0.02525816f, 0.04911665f, -0.01809258f, 0.05047018f, -0.10536964f, 
    0.00255867f, 0.16182671f, -0.00417039f, 0.02047955f, 0.08787927f, -0.04387630f, 0.01480728f, 0.00462972f, 
    0.05294138f, 0.35028774f, 0.00487523f, -0.11085842f, -0.07993478f, -0.01918642f, -0.09548758f, -0.00012657f, 
    -0.07785866f, 0.10302131f, -0.16034012f, -0.00749744f, 0.01740024f, -0.04725804f, -0.00879959f, 0.29172337f, 
    0.07499863f, 0.02941276f, -0.04858910f, -0.01045936f, -1.10155988f, 0.26163349f, -0.05845465f, -0.11323091f, 
    0.00475392f, -0.15759017f, 0.19823223f, -0.12832759f, 0.11310183f, -0.00152593f, -0.04904803f, 0.01693208f, 
    0.13387914f, 0.02624116f, -0.08611523f, -0.01425108f, -0.23443025f, 0.03146493f, 0.04897175f, 0.09551900f, 
    -0.04077246f, 0.23003463f, -0.13878341f, -0.16732672f, -0.33743387f, -0.05620507f, -0.06338746f, 0.08892562f, 
    0.02725144f, -0.10366744f, 0.00926121f, 0.06879029f, -0.05088275f, -0.05635702f, 0.04395553f, 0.03532319f, 
    0.00309116f, 0.08227394f, 0.00127062f, -0.01101377f, 0.59198773f, -0.10443173f, -0.13542074f, 0.30812028f, 
    0.20681535f, 0.11402860f, 0.08407885f, 0.13028696f, 0.04808069f, 0.18012403f, -0.01607393f, 0.03406462f, 
    -0.06539610f, 0.10938030f, 0.02467100f, 0.02711221f, 0.00933333f, -0.19588917f, -0.10351875f, 0.03230780f, 
    0.27331546f, -0.12389562f, -0.20599666f, 0.03255171f, -0.15004742f, -0.18116693f, -0.32286122f, 0.23209293f, 
    0.07620573f, -0.12430834f, 0.09735740f, 0.02257821f, 0.14548454f, 0.04248443f, 0.00459975f, -0.00558566f, 
    0.10464027f, 0.01718490f, -0.08930693f, 0.05175835f, -0.34543791f, -0.09422130f, -0.04147254f, -0.01318328f, 
    0.20648773f, -0.00997644f, 0.13679056f, 0.08532173f, -0.03515860f, -0.10467609f, 0.00960882f, 0.08880816f, 
    -0.15487860f, -0.03750279f, 0.10874628f, -0.01781051f, 0.01692815f, 0.15258315f, 0.06478444f, 0.11263860f, 
    0.17402478f, -0.26292330f, -0.26421574f, -0.28303868f, -0.29976404f, -0.21195552f, 0.01000168f, -0.21829355f, 
    -0.06145007f, 0.04085636f, -0.00235810f, 0.02020968f, 0.06555714f, 0.09433164f, 0.22705543f, -0.14449991f, 
    -0.06857210f, 0.13259120f, -0.01449146f, 0.18153432f, 0.54040974f, 0.29133111f, 0.03033291f, 0.11188745f, 
    0.46799502f, 0.01448681f, -0.18005586f, -0.00518744f, 0.04160974f, -0.07083920f, -0.13286109f, -0.04785349f, 
    -0.00754741f, 0.08907337f, 0.14109638f, 0.06824007f, 0.13967735f, -0.18275756f, -0.17727309f, -0.04326618f, 
    0.11296871f, 0.39575294f, -0.01948167f, 0.06591831f, 0.20311752f, 0.05562844f, 0.13624950f, 0.10487995f, 
    -0.10757641f, 0.02982439f, 0.05611979f, 0.04200790f, 0.05224000f, -0.13764893f, 0.03655709f, -0.04048460f, 
    0.19879167f, -0.06218204f, 0.08134439f, -0.06180649f, 0.04955290f, -0.00292143f, 0.00730838f, 0.33297849f, 
    0.18615092f, 0.07418028f, -0.00316962f, 0.09081381f, -0.10151895f, 0.05362871f, -0.00941847f, 0.09678266f, 
    -0.01280724f, -0.02570106f, -0.01299662f, 0.06650978f, 0.04210994f, -0.12007891f, 0.11467580f, -0.00384146f, 
    -0.39875105f, 0.33906236f, -0.03179534f, 0.35219333f, 0.28756616f, -0.06896871f, 0.02164426f, 0.09772672f, 
    0.08694091f, 0.11092065f, 0.10529672f, -0.09056959f, 0.08711971f, -0.04170953f, -0.05179683f, -0.07974133f, 
    0.04806164f, 0.17720687f, -0.20240277f, 0.04646162f, -0.68409836f, -0.10099632f, -0.12462595f, -0.09237354f, 
    0.15805098f, 0.12359688f, 0.15644090f, 0.14122166f, -0.07191218f, 0.02350510f, 0.12200119f, -0.00023809f, 
    -0.03646567f, 0.00572019f, 0.21130103f, 0.02615999f, 0.11120583f, 0.14360628f, 0.03263145f, 0.12332546f, 
    0.05539999f, -0.33720785f, 0.00965038f, -0.14158741f, -0.36092144f, 0.13175054f, 0.15385272f, 0.06889921f, 
    -0.02252077f, 0.04531110f, 0.16284078f, 0.02172638f, -0.13217279f, 0.11448305f, 0.14535590f, 0.04568347f, 
    0.13055533f, 0.08771081f, 0.08653957f, 0.04642522f, 0.01617832f, -0.14354813f, -0.10968273f, 0.00073256f, 
    -0.11469645f, 0.05281168f, -0.17510454f, 0.08590331f, 0.09520871f, -0.01655611f, -0.07667254f, 0.13471696f, 
    0.04843296f, -0.05964821f, -0.03300688f, 0.11457489f, -0.06653099f, 0.03146718f, -0.05003208f, -0.05222904f, 
    -0.02964354f, -0.09608252f, 0.18706439f, 0.00637132f, 0.23550688f, 0.05626072f, -0.11273002f, 0.00590423f, 
    -0.01334262f, 0.00829483f, 0.16670956f, 0.15230532f, 0.03334106f, 0.11107985f, 0.13795362f, -0.02133189f, 
    0.07469095f, -0.13859870f, -0.07652830f, 0.03263784f, -0.41228449f, -0.37165761f, -0.14970237f, -0.12306906f, 
    -0.01755704f, 0.11245910f, -0.08158802f, 0.07159148f, -0.14982229f, -0.10028445f, 0.11294461f, 0.12000203f, 
    0.07512744f, 0.00653576f, -0.13783063f, 0.08717798f, -0.09554051f, -0.09271244f, 0.07662370f, -0.10603949f, 
    0.07235261f, 0.13026586f, -0.13002430f, -0.15953477f, -0.06673561f, -0.00864094f, 0.04766626f, 0.01825593f, 
    0.00709887f, -0.01472926f, -0.00075301f, -0.02198739f, -0.09875255f, 0.01272861f, -0.01608811f, 0.02803970f, 
    0.16442391f, 0.04023866f, -0.17255178f, 0.17904560f, -0.58588320f, 0.02026068f, 0.22991408f, 0.31331480f, 
    -0.03939577f, 0.06026410f, -0.00864889f, -0.08263063f, -0.06074104f, -0.05807756f, 0.07167353f, -0.05795504f, 
    0.14639246f, 0.03915916f, 0.04529995f, -0.06321686f, 0.03843418f, 0.05752088f, 0.06715385f, -0.03537161f, 
    0.10833993f, 0.45932209f, 0.19051065f, -0.18795003f, -0.16084421f, 0.09162378f, -0.01264026f, 0.10860132f, 
    0.19004300f, -0.15926485f, 0.03895367f, -0.07393601f, -0.09999525f, -0.00555839f, -0.18826696f, -0.01065639f, 
    -0.04040180f, -0.01463984f, 0.02263418f, 0.10399688f, -0.07759289f, 0.09718236f, 0.05668372f, 0.22856031f, 
    0.04142675f, -0.08637450f, -0.09425874f, 0.07991335f, 0.06548221f, 0.14018556f, -0.01288106f, -0.02416052f, 
    0.00024858f, 0.00262655f, -0.06061751f, -0.01793758f, 0.06233990f, -0.17219025f, -0.07602030f, 0.04270973f, 
    0.00621250f, 0.03492390f, 0.03158530f, 0.02479407f, 0.00587657f, 0.15503798f, 0.13183330f, 0.02848082f, 
    -0.20303997f, -0.16882063f, -0.05442717f, 0.23943193f, -0.10898171f, 0.04043477f, 0.04080419f, -0.06886296f, 
    -0.11673599f, -0.07840509f, 0.09433666f, -0.01650202f, -0.09176714f, 0.13653414f, 0.37592414f, 0.04699784f, 
    -0.27989158f, 0.21809049f, 0.08301811f, 0.03267322f, -0.02487829f, 0.05103454f, -0.00162902f, 0.05637962f, 
    -0.13422628f, 0.01008993f, -0.01885539f, 0.04152967f, -0.02582748f, -0.07491855f, 0.03956327f, 0.06367444f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03445598f, 0.03118727f, 0.02103220f, 0.06128823f, -0.00860803f, 0.04598149f, -0.14205761f, 0.06520346f, 
    0.00471185f, 0.01074792f, 0.16693465f, -0.01165770f, 0.01262949f, 0.04198615f, 0.00562072f, -0.08861016f, 
    0.01525592f, -0.01014764f, 0.12584455f, 0.04530914f, -0.05394967f, 0.08367402f, -0.02731762f, -0.05245920f, 
    0.01061399f, 0.11657602f, 0.03316823f, 0.01226186f, 0.03112712f, 0.02763213f, 0.16024019f, -0.00867098f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.21656160f, -0.07025231f, 0.02311584f, -1.03872967f, -0.03193316f, -0.34763959f, 0.22606361f, 0.02707301f, 
    0.00205636f, -0.07460277f, -0.69151127f, -0.05861106f, 0.08314124f, 0.12118474f, 0.11649887f, 0.32341787f, 
    0.11615615f, 0.35123402f, -0.20011063f, -0.02871526f, -0.02725352f, 0.13249204f, -0.00894741f, 0.19109692f, 
    -0.07503516f, -0.17347409f, 0.12216674f, -0.15646090f, -0.90225136f, 0.15116838f, -0.02213209f, 0.11447057f, 
    0.08971227f, -0.05567106f, 0.43665960f, 0.08657609f, 0.05330635f, 0.39850983f, -0.55080503f, -0.08049391f, 
    0.13791938f, -0.05614992f, 0.00236766f, -0.09341250f, 0.11568846f, -0.11238848f, 0.08365059f, 0.33791229f, 
    -0.00910898f, -0.72002459f, -0.41603476f, -0.02384452f, -0.02833875f, 0.00826408f, -0.10515150f, 0.21192896f, 
    0.14976601f, 0.10611900f, -0.02827855f, 0.01297260f, -0.70394272f, 0.09142367f, 0.31590080f, -0.42235646f, 
    0.20348635f, -0.13033354f, 0.48851353f, 0.40123188f, -0.15336704f, -0.40795690f, -0.21415295f, -0.63420141f, 
    -0.07911247f, -0.07459693f, 0.24045108f, -0.07779218f, -0.04400906f, -0.06102912f, -0.10644849f, -0.00206054f, 
    -0.04028346f, 0.07473978f, -0.45720637f, -0.01693453f, 0.14779964f, 0.21819083f, 0.01425652f, -0.23861042f, 
    -0.06169270f, -0.60693181f, 0.09648834f, -0.57510459f, 0.06414469f, -0.00750822f, -0.33273387f, -0.29124483f, 
    -0.10667181f, -0.00018025f, -0.05496579f, -0.34956327f, 0.13944064f, 0.11368252f, 0.32775360f, 0.40751323f, 
    0.15587243f, -0.15493070f, 0.15132722f, 0.00940845f, -0.01130114f, -0.02613868f, -0.04846299f, -0.41610432f, 
    0.15370183f, 0.13655151f, 0.34104499f, 0.06840333f, -0.06185006f, -0.41967586f, 0.06401770f, 0.07255851f, 
    -0.12599008f, -0.85097402f, 0.04542163f, 0.18694489f, 0.12000751f, -0.09735256f, 0.43166813f, -0.10047332f, 
    -0.32310918f, -0.09030923f, -0.00865316f, 0.13481356f, -0.01111941f, -0.30926421f, -0.02555002f, 0.08485582f, 
    -0.14701518f, -0.12103575f, 0.34370384f, 0.04167869f, 0.00354917f, -0.08032922f, 0.06137818f, 0.34249437f, 
    -0.16651337f, 0.14900619f, 0.49793154f, 0.09395877f, -0.06741972f, -0.19980992f, -0.08652314f, 0.06925525f, 
    -0.00261733f, 0.30055332f, 0.11483911f, -0.25800571f, 0.14874183f, 0.15368327f, -0.35825995f, -0.43181705f, 
    -0.02235849f, -0.16872162f, -0.28947246f, -0.32936466f, -0.01925024f, -0.23472959f, -0.28024194f, 0.44096979f, 
    -0.08375108f, 0.00994593f, -0.22846195f, 0.04689348f, -0.02733653f, 0.07178726f, 0.11655357f, 0.17588636f, 
    0.09373629f, -0.90272689f, -0.12562810f, -0.09590743f, 0.10393587f, 0.07872808f, 0.06831292f, 0.19441709f, 
    0.14076522f, 0.15293628f, -0.16874830f, 0.29388395f, 0.12395519f, 0.15976633f, -0.05829061f, 0.39086947f, 
    0.00220307f, -0.09897447f, -0.41623107f, -0.43096641f, -0.05809078f, 0.09303731f, 0.38040593f, 0.17921272f, 
    0.03189454f, -0.15048134f, -0.01855122f, 0.15919136f, -0.06380679f, 0.02289702f, 0.05014348f, -0.54215556f, 
    0.04857558f, -0.00350800f, -0.58133775f, -0.13165179f, 0.04198530f, 0.21873437f, 0.10290772f, -0.61746985f, 
    -0.04379057f, 0.40953794f, 0.07903744f, -0.22740468f, 0.05853443f, -0.06579243f, -0.28542647f, -0.41397542f, 
    -0.65861887f, -0.04021151f, -0.20518294f, 0.44257745f, -0.14070925f, 0.02100459f, 0.40425843f, 0.13364729f, 
    0.07178561f, -0.13321567f, -0.32106426f, -0.03895689f, 0.02882197f, -0.06902739f, 0.02996202f, 0.23021582f, 
    -0.08372966f, 0.23871826f, -0.44536772f, 0.11676324f, 0.00520076f, -0.30729952f, 0.06975690f, -0.25189251f, 
    -0.11281004f, -0.24643445f, 0.15278083f, 0.29850173f, 0.03296936f, 0.15435295f, -0.49156240f, 0.35852483f, 
    -0.12278251f, 0.02601880f, -0.23698483f, 0.06437844f, -0.05379279f, 0.29496148f, -0.33270317f, -0.52389812f, 
    0.03655003f, 0.02743073f, -0.08891626f, -0.06478296f, -0.11401506f, 0.07115665f, 0.15148412f, -0.05562428f, 
    -0.02953489f, -0.37710324f, 0.51235753f, -0.08745850f, 0.05590955f, 0.33504069f, 0.00074961f, -0.36324170f, 
    -0.17396638f, -0.48000771f, 0.14052068f, 0.49796972f, -0.32879645f, -0.05927645f, -0.62078416f, -0.46433374f, 
    -0.46564755f, -0.00549968f, -0.27917463f, -0.14662792f, 0.07909032f, -0.06022712f, 0.07581342f, -0.58748984f, 
    -0.04599223f, 0.11829691f, -0.38871077f, 0.14908193f, -0.12881321f, -0.10807642f, -0.14099400f, -0.11910892f, 
    -0.18336925f, 0.31668842f, -0.40534273f, 0.00155825f, -0.13930532f, 0.18812516f, -0.17411239f, 0.56385809f, 
    0.11877175f, 0.10412788f, 0.00442061f, -0.47702837f, 0.39712027f, 0.09769967f, -0.47762448f, -0.01939832f, 
    -0.44401494f, 0.11858272f, 0.37211025f, 0.03228817f, -0.08170315f, -0.31338710f, -0.12875663f, -0.39719439f, 
    0.03416914f, -0.13276356f, 0.42146140f, -0.00870182f, 0.00230434f, -0.16358663f, 0.03267857f, -0.87052184f, 
    0.03884961f, -0.11263486f, -0.11101556f, 0.06798261f, -0.05789083f, -0.03252951f, -0.07225759f, -0.15548533f, 
    0.14586230f, 0.06615774f, -0.01255144f, 0.39089528f, -0.22891851f, -0.03628648f, 0.27264637f, 0.61168718f, 
    0.27491319f, -0.00981998f, -0.62340206f, 0.26404685f, -0.12216222f, 0.15669228f, -0.10767181f, -0.35215244f, 
    -0.01485361f, 0.11856490f, -0.60987842f, -0.15878397f, 0.01435133f, 0.08902878f, 0.12246219f, -0.16028804f, 
    -0.01381110f, 0.23580016f, 0.39445460f, -0.02276954f, 0.06821078f, -0.17467618f, 0.03466516f, -0.39141259f, 
    -0.11597878f, 0.16866605f, 0.00507040f, -0.35252860f, -0.01934155f, -0.15857553f, 0.31072855f, 0.31707615f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.07525016f, 0.07688048f, -0.08474585f, 0.01451706f, 0.07839497f, -0.15294978f, 0.17941281f, -0.20963371f, 
    0.05852555f, 0.15090472f, 0.08581204f, -0.10544071f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
