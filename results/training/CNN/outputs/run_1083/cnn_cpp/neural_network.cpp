#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.80789709f, -1.30469787f, -0.74197841f, 0.27035603f, 0.11577924f, -0.26188213f, -0.01300575f, -0.72328973f, 
    -0.65722048f, 1.20658553f, -1.37467515f, 0.38692319f, 0.14897412f, -0.13969260f, -0.12291610f, -0.11364917f, 
    0.29712245f, -0.53775352f, -0.15796658f, -0.52345651f, -1.41512883f, 0.53400964f, -0.14083011f, -0.43223098f, 
    -0.75325054f, -0.58606166f, -0.59218532f, -0.43785897f, 0.04626852f, -0.21289583f, -0.26584867f, -0.10144760f, 
    -0.97607529f, 0.75239211f, 0.81299269f, 0.99056566f, -0.09888764f, 1.05553603f, 0.97870713f, -0.68579125f, 
    -0.59874731f, -0.63446939f, 0.47528955f, -0.16057535f, -0.23531497f, -0.28108981f, 0.78209049f, -0.30085984f, 
    -0.54692346f, 0.55379081f, 0.25183511f, 0.88903421f, 0.38229939f, 0.72860122f, -0.94531071f, 1.62233818f, 
    -1.76323688f, 0.18146773f, -0.08208872f, -0.31524533f, 0.20074087f, 0.09583258f, -0.02807828f, 0.61856872f, 
    0.83736891f, -0.15484919f, 0.51421022f, 1.04439151f, 1.01973248f, -0.18764289f, 0.30903098f, -0.00875461f, 
    -1.02556336f, -1.10245740f, 0.11291637f, 0.43997908f, -0.77328736f, 0.95998979f, -0.01155548f, 0.00982319f, 
    0.49380681f, 0.62927800f, 0.40502715f, -0.26133215f, -0.17707188f, -0.00444627f, 0.52891487f, 0.07096655f, 
    -0.34274989f, 0.93162388f, -0.11938905f, -0.78574961f, -1.45638776f, -0.19201353f, 1.46847379f, -0.04025782f, 
    0.04273660f, 0.33114392f, 0.15067734f, 0.63487625f, 0.65788013f, 0.93783295f, 0.16475305f, -0.93842876f, 
    -0.27519315f, -0.00003169f, 0.18267392f, 0.66975874f, -0.48189673f, -0.11004967f, 0.56681693f, 0.95868260f, 
    0.41645175f, 0.68812138f, -0.42986506f, -0.88252681f, -0.16970950f, -0.74374324f, -0.09889468f, 0.14156163f, 
    -0.98067045f, -1.33124661f, -1.41205823f, 0.17441677f, -0.27502459f, 0.47165343f, 0.50564307f, -0.60792172f, 
    0.34336394f, -1.15285194f, 0.75274271f, 0.93768728f, -0.11566643f, 0.20193517f, 0.56991845f, -2.02589035f, 
    -0.24714075f, 0.01234593f, -1.10281742f, -0.81458282f, 0.15949138f, 0.30636272f, -0.17966223f, -0.56559372f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04929443f, 0.56739837f, 0.11148118f, -0.08486195f, 0.40713468f, 0.52915567f, 0.56794477f, 0.69233263f, 
    0.57415384f, 0.37894320f, 0.28766066f, 0.95647442f, 0.42594773f, 1.16145587f, 0.82992810f, 0.27517921f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.63318759f, 0.08191023f, 0.06197646f, 0.23058118f, -0.05910377f, 0.06949992f, 0.05303766f, -0.00301259f, 
    0.04145875f, -0.20017312f, -0.80748451f, -0.68765330f, 0.04226282f, 0.30934480f, -0.05502935f, 0.04496769f, 
    -0.23847970f, 0.00738472f, 0.31713980f, 0.21525717f, 0.39539766f, 0.20410526f, 0.09121963f, 0.31535962f, 
    0.22494021f, 0.01123872f, 0.14188166f, 0.67764002f, 0.51162356f, 0.55375993f, 0.03080805f, -0.07167628f, 
    -0.00098465f, 0.16328703f, 0.09174086f, 0.13665633f, -0.21785092f, -0.26567677f, 0.10717896f, 0.00100702f, 
    -0.02731026f, -0.24046637f, 0.06171227f, -0.15037888f, 0.17526650f, 0.28166407f, -0.08052204f, -0.66156721f, 
    0.05446872f, -0.02844829f, -0.05777659f, 0.28427675f, 0.20421034f, 0.21750993f, 0.02531504f, -0.15100585f, 
    -0.47208977f, -0.17724904f, -0.40156353f, 0.14564566f, 0.02409029f, -0.02200213f, -0.24792995f, 0.51406246f, 
    0.14768450f, -0.87015939f, -0.23008598f, -0.05452893f, 0.10375046f, 0.13742717f, 0.13231860f, 0.00803627f, 
    0.10655653f, 0.09619693f, 0.09483227f, 0.17313440f, 0.22341235f, 0.27535805f, 0.00957129f, -0.36652634f, 
    -0.10130507f, 0.60219353f, -0.24964635f, 0.02080002f, -0.15034726f, 0.08253618f, -0.20145996f, -0.06059513f, 
    0.07542086f, -0.10771256f, 0.31882522f, -0.35894027f, -0.29653174f, -0.07829633f, -0.04972546f, 0.28619456f, 
    0.01550950f, -0.04786798f, -0.16059628f, -0.47213337f, -1.06433141f, -0.44142270f, -0.06375646f, 0.02311892f, 
    0.00427971f, 0.08101442f, -0.29290444f, -0.14277045f, -0.13736190f, -0.78254586f, -0.34810412f, -0.27741536f, 
    -0.08681475f, -0.12444333f, 0.15894060f, 0.23034385f, 0.10006557f, 0.54018658f, 0.37133020f, 0.19170532f, 
    -0.29943079f, -0.06465522f, -0.11762597f, -0.13362870f, -0.00375656f, 0.01922798f, -0.56414717f, -0.25123426f, 
    -0.88021946f, -0.26702458f, -0.21583995f, 0.02867184f, 0.15690857f, -0.06728385f, 0.16349462f, 0.30568835f, 
    0.30637562f, 0.20540023f, 0.08448277f, -0.01758409f, -0.27944979f, 0.12118983f, 0.30864719f, -0.11562174f, 
    -0.10499976f, -0.06156315f, 0.04920273f, -0.05407377f, -0.07895303f, -0.02808618f, 0.04953718f, -0.02037169f, 
    -0.08813696f, 0.08159528f, -0.02551133f, -0.05380503f, -0.02512030f, 0.01477044f, 0.04853870f, -0.03944010f, 
    -0.07851066f, -0.07373003f, -0.01796313f, -0.06322031f, -0.01341202f, -0.04315719f, 0.01078818f, -0.00791982f, 
    0.00001585f, -0.07227337f, -0.07377575f, 0.03589182f, -0.02741814f, 0.02104942f, -0.08929651f, -0.01096396f, 
    -0.06136113f, 0.01696501f, -0.04946483f, -0.08624385f, -0.03481606f, -0.03928934f, -0.02813380f, -0.01980696f, 
    -0.07352088f, 0.05869413f, 0.03514794f, 0.06187083f, 0.04754618f, -0.00705758f, -0.06265149f, 0.04934223f, 
    -0.05078585f, 0.06837676f, -0.08195326f, 0.02057218f, 0.02899215f, -0.08272868f, -0.03213157f, -0.01566854f, 
    0.01700648f, 0.01127199f, -0.00590918f, -0.06493845f, -0.08758493f, 0.06277035f, -0.08841614f, 0.05292560f, 
    0.07527457f, -0.02251280f, 0.00203616f, -0.09240062f, 0.04279789f, -0.04479651f, 0.03841310f, -0.10231309f, 
    0.03069003f, 0.03546341f, -0.01181667f, -0.01710511f, -0.05969136f, -0.02490957f, -0.03957460f, -0.05078165f, 
    -0.06104282f, -0.07142001f, 0.05369189f, -0.04291158f, -0.05273322f, 0.06511536f, -0.08259023f, 0.00356885f, 
    -0.06930733f, 0.03587127f, -0.08042911f, -0.09309188f, -0.00264991f, -0.01872506f, -0.04298513f, -0.09551088f, 
    0.04962256f, -0.03648568f, -0.07270938f, -0.08340786f, 0.02935001f, -0.08988002f, 0.02945994f, -0.00111098f, 
    0.02095701f, -0.09335461f, 0.01873515f, -0.08437411f, 0.06827131f, 0.04922254f, -0.00749112f, -0.07352562f, 
    0.00332823f, -0.05936739f, 0.04373089f, -0.07862568f, 0.05780982f, -0.01555306f, 0.04395055f, -0.02452515f, 
    0.04832312f, -0.02337985f, 0.07734750f, -0.06707286f, -0.04035510f, -0.07139179f, 0.03857178f, -0.04443400f, 
    -0.01300748f, -0.09134331f, -0.01625004f, -0.05643508f, -0.00899898f, -0.03434907f, 0.02321878f, -0.01019646f, 
    -0.05461597f, -0.07283574f, 0.01392755f, -0.06963090f, 0.02017489f, 0.02955746f, 0.03578573f, 0.02283074f, 
    0.26029605f, 0.15645240f, -0.63387448f, -0.32604647f, -0.00531356f, 0.30291104f, 0.06774554f, 0.03447125f, 
    0.06042987f, 0.32699308f, 0.23206158f, -0.59403050f, -0.13056117f, 0.16863085f, 0.29494119f, -0.21034248f, 
    -0.18731004f, 0.02987798f, -0.18730342f, -0.28237551f, -0.43857926f, -0.24409756f, 0.05050501f, 0.22912420f, 
    0.10251504f, -0.14174762f, 0.03013478f, -0.18159501f, -0.22272936f, -0.14993352f, -0.19288103f, 0.02427026f, 
    -0.09407447f, 0.22801293f, 0.11810249f, -0.12068564f, 0.75051999f, 0.38660374f, 0.62658197f, -0.00878352f, 
    -0.29512170f, 0.08557178f, -0.13792759f, 0.05154923f, 0.18326233f, -0.03785367f, -0.28263006f, -0.12837480f, 
    0.13561210f, 0.04377055f, 0.07119494f, 0.16149206f, 0.19480453f, 0.07584712f, -0.88719273f, -1.22299433f, 
    -0.76624697f, 0.12401498f, 0.09355818f, -0.04012604f, 0.25256106f, 0.30700937f, -0.33737865f, 0.17121355f, 
    -0.14521596f, -0.06757209f, -0.47029826f, 0.29419860f, -0.28034431f, -0.03270284f, 0.05341535f, -0.03103932f, 
    0.09151682f, -0.64975828f, 0.45830312f, 0.36724585f, 0.02077011f, -0.19536278f, -0.16429308f, -0.06460746f, 
    -0.35310847f, 0.05250180f, 0.16134459f, 0.53848815f, -0.13561223f, 0.11691372f, -0.00282624f, -0.15308800f, 
    0.23360375f, 0.18248327f, -0.60794872f, -1.17503297f, -0.53818178f, -0.20700569f, 0.15445243f, 0.03581008f, 
    -0.06947025f, -0.08735617f, -0.09058901f, 0.66261077f, 0.29774675f, 0.35054833f, 0.12981284f, 0.16593356f, 
    0.00426903f, 0.00781554f, 0.24141994f, 0.13267550f, -0.29747835f, -0.32547963f, -0.35589120f, -0.10191340f, 
    -0.17813677f, -0.13075304f, 0.01816213f, -0.13905697f, 0.07645122f, -0.20444334f, 0.18625821f, 0.53701723f, 
    -0.12223496f, -0.12266315f, 0.02381569f, 0.13779323f, 0.04446557f, 0.19300684f, 0.22154909f, -0.40241063f, 
    0.05008370f, -0.21208870f, 0.35812524f, -0.05017336f, 0.02346897f, 0.34475192f, 0.13311633f, 0.13476677f, 
    -0.22482117f, -0.06253431f, -0.18498610f, -0.36706966f, 0.18321413f, 0.02010612f, 0.00836569f, 0.17264530f, 
    -0.31650126f, -0.30161753f, -0.18099022f, -0.01947067f, -0.14501639f, -0.22501835f, -0.11979390f, -0.01283085f, 
    0.31210211f, 0.13320607f, -0.59310496f, 0.73579592f, -0.14844508f, 0.03083075f, -0.07340130f, -0.05708780f, 
    -0.49122152f, -0.26917741f, 0.22070871f, -0.05313135f, -0.46430638f, -0.17710932f, -0.00807047f, -0.13894898f, 
    -0.02494822f, -0.08926543f, 0.18057024f, -0.20356824f, -0.11598019f, -0.12728737f, 0.21496621f, -0.00009923f, 
    -0.36454624f, 0.22847283f, 0.09680349f, 0.15205775f, -0.19955304f, 0.12782456f, -0.82624310f, 0.09166883f, 
    0.14467168f, -0.08877876f, 0.31155705f, 0.10557362f, 0.06282056f, -0.30908331f, 0.45090526f, 0.12181155f, 
    0.09823136f, 0.12274660f, -0.04321694f, 0.21393010f, 0.10322651f, -0.03851214f, -0.48671028f, 1.12189543f, 
    0.30832174f, 0.38543612f, 0.19015948f, 0.30254120f, 0.24214014f, 0.30269396f, 0.00527146f, -0.23981194f, 
    0.08757056f, 0.03701617f, -0.06131609f, 0.10973652f, 0.08494208f, -0.00089765f, 0.12069045f, 0.03900967f, 
    -0.40779606f, -0.18090492f, 0.25501359f, 0.20851465f, -0.19427221f, 0.03664092f, 0.00376109f, -0.02280376f, 
    0.05458661f, -0.39779302f, 0.22117580f, 0.01760054f, 0.01117539f, 0.03659081f, -0.08398044f, 0.06725189f, 
    0.02430697f, 0.17508689f, 0.23505767f, -0.23320533f, 0.25675538f, 0.22889845f, -0.12350349f, -0.16179051f, 
    -0.05618376f, 0.01313668f, 0.06750219f, -0.25151810f, 0.09353539f, 0.02671817f, 0.19906184f, 0.33933121f, 
    -0.03411021f, 0.09841996f, 0.17317867f, 0.17563760f, -0.26733118f, 0.12504934f, 0.13995594f, -0.21928903f, 
    -0.22886296f, 0.01993109f, -0.23904586f, -0.07582912f, -0.01656944f, 0.38658479f, 0.23072204f, -0.47972646f, 
    0.12318803f, 0.12866111f, 0.28556532f, 0.23164301f, 0.11996673f, 0.23616907f, -0.20879030f, 0.06840326f, 
    0.20817654f, 0.31551415f, 0.19040370f, 0.20513800f, 0.21223338f, 0.22547925f, 0.20964371f, -0.93192023f, 
    -0.56963331f, -0.02555480f, 0.05341231f, -0.30132613f, 0.27238595f, -0.02538445f, 0.20120710f, 0.13329472f, 
    0.52001637f, 0.02380266f, -0.39032280f, -0.11139428f, -0.04127806f, -0.01264705f, -0.15836373f, -0.01086793f, 
    -0.08766075f, 0.03968944f, -0.29890943f, -0.14549062f, 0.05055746f, 0.18383555f, 0.04729116f, -0.01663717f, 
    -0.63897073f, -0.40059721f, 0.15544277f, 0.22952411f, -0.36938831f, 0.05068690f, -0.00840202f, -0.13106784f, 
    -0.10910378f, -0.17082125f, -0.03028993f, 0.00716053f, 0.00446719f, 0.19860022f, 0.22580165f, -0.08432342f, 
    0.13825615f, 0.27203813f, 0.28095880f, 0.28742394f, -0.44262105f, 0.15746461f, 0.16743608f, -0.09240216f, 
    0.00417503f, 0.16418082f, 0.12935118f, 0.42361218f, 0.11345057f, 0.01013260f, 0.18283214f, 0.17092885f, 
    -0.04248805f, 0.04396005f, -0.00434651f, 0.16235866f, 0.21291044f, 0.29373890f, 0.34366971f, 0.12723634f, 
    -0.05709880f, -0.05540766f, 0.20257594f, 0.29098871f, -0.08884710f, 0.22893049f, -0.24059902f, 0.06545313f, 
    0.14495774f, 0.21094403f, 0.12818208f, 0.08050897f, -0.30475482f, -0.21673597f, -0.20919925f, -0.12718651f, 
    0.50394726f, 0.29482123f, -0.56369424f, 0.29124212f, -0.01551198f, -0.25162306f, 0.01282070f, -0.06401186f, 
    -0.04814097f, -0.11169839f, 0.39875779f, 0.11833064f, -0.02861237f, 0.15922813f, -0.25183097f, -0.25410444f, 
    0.02907349f, 0.23387414f, 0.63700259f, -0.26318863f, -0.36053994f, -0.26770708f, 0.08685376f, -0.12940325f, 
    0.22002023f, -0.04414906f, 0.05552445f, -0.69545436f, -0.18058594f, 0.09232253f, 0.03160172f, 0.16404057f, 
    0.04149419f, 0.09858653f, -0.04520329f, 0.03965095f, -0.26507044f, -0.14138617f, 0.06854694f, 0.26639852f, 
    0.25089446f, -0.00595745f, -0.31822115f, -0.34793574f, -0.56768864f, 0.17534812f, 0.13823204f, -0.17807542f, 
    0.07205203f, 0.15658550f, 0.07888817f, -0.08586391f, 0.01859987f, 0.04700946f, -0.06319890f, 0.03095608f, 
    0.30054393f, -0.30081075f, -0.22095388f, -0.49697718f, 0.22469345f, 0.06547192f, 0.10448416f, 0.88169163f, 
    0.45934731f, -0.42084029f, 0.20685935f, 0.00362919f, 0.06968150f, -0.14279191f, -0.06445561f, -0.18589920f, 
    -0.02410864f, -0.02427157f, 0.07253432f, -0.03879070f, 0.04775731f, -0.08170564f, -0.07644376f, 0.00515864f, 
    -0.09104286f, -0.06409753f, 0.03211900f, -0.05604859f, -0.06229556f, 0.02685529f, 0.01003006f, -0.06500977f, 
    0.02636406f, -0.01679173f, -0.05822669f, -0.02473490f, -0.03603796f, 0.06033971f, -0.04209161f, -0.04974588f, 
    0.00598704f, -0.07799269f, 0.01358967f, 0.04158183f, 0.02038389f, 0.01862851f, -0.04434403f, 0.01097406f, 
    -0.05903561f, -0.08720025f, -0.00442395f, 0.05606025f, -0.01802642f, -0.10366315f, -0.09529823f, -0.01082038f, 
    -0.06333642f, 0.02945679f, 0.01765217f, -0.06866838f, -0.02055626f, -0.03566127f, 0.03167647f, 0.02499282f, 
    -0.07372752f, -0.07218266f, -0.07396303f, -0.06645465f, -0.04550774f, -0.01548984f, -0.02922526f, -0.01161503f, 
    0.04104620f, -0.02720707f, -0.05726399f, -0.03430035f, -0.05141073f, 0.05376881f, 0.01502865f, -0.03096297f, 
    0.04424190f, -0.02766313f, -0.00490751f, 0.00897287f, -0.10108189f, 0.03366638f, -0.05670940f, -0.09734645f, 
    0.02746694f, 0.03463293f, 0.04965720f, -0.04086019f, -0.04827331f, -0.01861444f, 0.02544086f, -0.08082343f, 
    -0.03872488f, 0.03395176f, -0.08209918f, -0.01078442f, -0.07490659f, -0.00693458f, -0.09645559f, 0.03033344f, 
    -0.06174465f, 0.04372805f, -0.01064514f, -0.01851017f, -0.04611026f, -0.04898336f, -0.02962985f, -0.03729695f, 
    -0.05062615f, -0.03365817f, 0.00039956f, -0.01005389f, -0.01817186f, -0.00896000f, 0.05130266f, 0.03598421f, 
    -0.04484918f, 0.02242394f, 0.04819033f, -0.06681064f, -0.05542538f, 0.05125782f, 0.02221691f, 0.01024870f, 
    0.00790631f, 0.00533661f, -0.01619488f, 0.06467730f, 0.01150812f, 0.04699193f, 0.04667237f, -0.03657787f, 
    -0.09105273f, -0.07791275f, 0.07047664f, -0.08889890f, 0.04875445f, -0.06673265f, -0.01718535f, -0.08742537f, 
    0.01032351f, -0.05447046f, 0.00069993f, 0.04419187f, -0.05290416f, -0.01567594f, 0.04975887f, 0.06612272f, 
    0.04306947f, 0.01707051f, 0.06967363f, -0.01494848f, -0.07194727f, -0.04825206f, -0.03800270f, 0.02190214f, 
    -0.02986657f, -0.06863353f, 0.04101774f, -0.03569504f, 0.05940343f, -0.06962247f, -0.09201220f, -0.03519538f, 
    -0.05746356f, -0.01942047f, -0.06374391f, 0.00799188f, 0.06801254f, 0.01640065f, 0.03520188f, -0.02597023f, 
    -0.00441724f, -0.01350137f, -0.00060287f, 0.03721926f, -0.06295577f, 0.03372964f, -0.05983399f, -0.06205473f, 
    -0.01063452f, -0.02952640f, 0.06015159f, 0.06606583f, -0.03014411f, -0.01691033f, 0.04204082f, -0.05921655f, 
    -0.00396681f, 0.02603397f, -0.08308527f, -0.05387239f, 0.04108262f, 0.05943861f, 0.00705917f, -0.06619241f, 
    -0.08732386f, -0.04522885f, -0.00591635f, -0.04756434f, -0.00065179f, -0.03259678f, -0.05172291f, -0.00429595f, 
    -0.00779382f, 0.06115594f, 0.05334865f, 0.02102763f, -0.09284669f, 0.03127692f, -0.01227786f, 0.06335567f, 
    -0.00402011f, 0.06002475f, -0.02876412f, 0.06124364f, -0.02165115f, -0.08266374f, 0.06306932f, 0.04951913f, 
    0.04435554f, -0.08454794f, -0.02156425f, 0.06361784f, 0.02302143f, -0.09779986f, 0.03244708f, 0.01335759f, 
    0.01592060f, -0.09289297f, -0.05994724f, -0.01325198f, -0.09444273f, 0.03745834f, 0.02643837f, -0.09324349f, 
    -0.08293345f, -0.00192801f, -0.01651356f, -0.09243350f, -0.03693241f, -0.00673124f, -0.07862442f, 0.01327019f, 
    -0.04193316f, -0.03211542f, 0.00919333f, 0.03978534f, -0.06455175f, 0.03648065f, -0.04526040f, 0.03655164f, 
    -0.02954134f, -0.00784966f, -0.04704504f, -0.05965684f, 0.06838652f, -0.02862088f, -0.05905489f, -0.03951630f, 
    -0.08088709f, -0.05990300f, 0.02010384f, 0.05126885f, -0.02269125f, 0.00091352f, 0.01324225f, -0.08336417f, 
    0.04377564f, -0.07015217f, 0.04938699f, -0.07690019f, 0.05505712f, -0.05672564f, -0.02541161f, 0.05092695f, 
    -0.05597335f, -0.05753345f, -0.04003108f, -0.03910461f, 0.00565420f, 0.03807627f, -0.08053858f, -0.05186870f, 
    0.06484496f, -0.06908485f, 0.06048930f, 0.06600779f, 0.01839840f, -0.09254813f, 0.03864276f, 0.05473739f, 
    0.05255582f, 0.03647253f, 0.00722698f, 0.00558299f, 0.05469282f, -0.03721915f, -0.00464364f, -0.05976632f, 
    0.27398136f, -0.20789379f, 0.29394203f, 0.30662876f, 0.17602214f, -0.16676696f, 0.02309492f, -0.10432317f, 
    0.10233071f, -0.53800529f, 0.00915971f, 0.16192125f, -0.20172399f, 0.17988293f, 0.45505869f, 0.19919546f, 
    0.26315776f, -0.15960328f, 0.09147851f, -0.38266480f, -0.09546752f, 0.30789068f, -0.06350375f, -0.15385629f, 
    0.10310803f, -0.06199820f, 0.19137470f, 0.47158566f, 0.26191509f, 0.02802361f, 0.08733169f, 0.19924824f, 
    0.40923607f, 0.02893750f, -0.33413699f, -0.03742502f, -0.21929459f, 0.32672843f, 0.19222842f, -0.01435292f, 
    0.10640163f, -0.21021770f, 0.01434981f, -0.25028172f, 0.14987813f, -0.12499674f, 0.20537148f, 0.15966442f, 
    -0.00641002f, 0.16387939f, 0.09481177f, -0.06098982f, -0.36552155f, -0.22498903f, -0.02000592f, -0.09961340f, 
    -0.25982833f, -0.14216273f, 0.60046858f, 0.23094131f, 0.01667812f, 0.10877775f, -0.14098418f, 0.29752207f, 
    0.07567795f, 0.18101022f, 0.07328578f, -0.08797427f, 0.10704263f, 0.06192737f, -0.03074968f, 0.05634651f, 
    0.10122129f, 0.93611026f, -0.08697338f, -0.39609766f, -0.16899802f, -0.20636179f, 0.14499205f, 0.27387100f, 
    -0.11614741f, -0.17471316f, 0.00788639f, -0.05174292f, 0.15012668f, -0.09712440f, 0.01573882f, 0.21096672f, 
    0.02408947f, 0.04510227f, 0.19844595f, 0.00731166f, -0.15885977f, -0.10861345f, -0.68671447f, -0.14090024f, 
    0.08304815f, 0.22179845f, 0.08013231f, -0.35629871f, 0.05278601f, 0.08523222f, -0.05705646f, 0.06806332f, 
    0.00337795f, 0.01861967f, 0.02689177f, -0.04527773f, 0.29640982f, 0.38720381f, 0.70040566f, 0.09880955f, 
    0.12443004f, -0.20983998f, -0.31379771f, -0.09664185f, 0.09635235f, -0.07361976f, 0.31534097f, -0.14683500f, 
    -0.29999620f, -0.11391316f, -0.31199855f, -0.20666862f, -0.17172004f, 0.14057936f, -0.38210097f, 0.07052959f, 
    -0.05822919f, -0.08432859f, -0.11068860f, -0.05683149f, -0.17814679f, -0.14493412f, -0.25425500f, 0.11413413f, 
    0.20674685f, 0.17739525f, -0.04498045f, -0.24029085f, -0.08332370f, 0.04714564f, -0.09115332f, -0.07978828f, 
    -0.45574972f, -0.26943991f, -0.32537919f, -0.08541502f, 0.05621395f, -0.05133449f, 0.22341196f, -0.17303391f, 
    -0.03129064f, 0.83330625f, 0.09423146f, 0.03825438f, 0.15170169f, 0.37033090f, 0.21855894f, 0.27333412f, 
    -0.29067066f, 0.10367727f, -0.28046754f, 0.10911496f, -0.03380647f, 0.02502597f, 0.19720511f, -0.09534419f, 
    0.18613504f, -0.03920740f, -0.21616088f, 0.05989170f, 0.12333929f, 0.40409213f, -0.23750162f, -0.21917593f, 
    0.07286996f, 0.05867841f, 0.00073562f, 0.17963015f, -0.34085187f, -0.69909787f, -0.44792986f, 0.08188978f, 
    -0.20096959f, -0.14170325f, -0.23278062f, -0.14560445f, -0.05474587f, -0.17140111f, -0.32710242f, 0.10904896f, 
    -0.02370322f, 0.26120555f, 0.27369517f, 0.10027105f, -0.02650928f, -0.05295553f, 0.27153832f, 0.11323697f, 
    -0.32210979f, 0.03100084f, 0.24783020f, 0.85289943f, 0.13482220f, -0.00001436f, -0.23931016f, -0.09389362f, 
    -1.20434093f, -0.29683766f, -0.04668276f, -0.25744510f, -0.27643928f, 0.30410212f, 0.25164738f, -0.12133113f, 
    0.18897346f, 0.21834189f, 0.24993637f, 0.24320956f, 0.16768146f, 0.17550813f, -0.03788504f, 0.21818717f, 
    0.11904821f, 0.00413895f, -0.56386977f, 0.13440436f, -0.17641671f, 0.19087857f, 0.15391019f, -0.17316802f, 
    -0.07907361f, 0.25624681f, -0.73083878f, -0.06480409f, 0.49168089f, 0.24236150f, 0.27760395f, -0.22401401f, 
    0.01806566f, 0.12879060f, 0.10569996f, -0.23698758f, -0.81496251f, -0.14224491f, -0.09402370f, 0.06759156f, 
    0.06362360f, 0.07114089f, 0.24856065f, 0.05533386f, -0.84351921f, -0.36333135f, -0.03215413f, 0.03039356f, 
    -0.11581643f, -0.29632843f, 0.40078911f, -0.16688573f, -0.23171264f, -0.30114082f, 0.23887807f, 0.74074399f, 
    0.03107196f, 0.11267956f, -0.04490608f, -0.03243275f, 0.21525156f, 0.13809100f, -0.50491714f, -0.65591884f, 
    0.15543355f, 0.18018052f, -0.18422604f, 0.03668713f, -0.02250055f, 0.15267238f, -0.31723073f, -0.31723067f, 
    0.01772421f, -0.02655723f, -0.22519541f, -0.11930555f, -0.08161229f, 0.16255656f, 0.16138777f, -0.06078090f, 
    0.35032469f, 0.01409660f, -0.05545340f, -0.16624410f, -0.33045897f, 0.11864963f, 0.09017148f, -0.01593247f, 
    -0.32926726f, 0.22788684f, -0.04688091f, -0.61072963f, -0.22543523f, 0.58988690f, -0.11163581f, 0.33742237f, 
    0.32133618f, -0.12144003f, -0.31542334f, -0.42631090f, -0.80301809f, -0.12126580f, 0.11820854f, 0.12356757f, 
    0.19813059f, 0.06312881f, -0.08491157f, 0.13834088f, 0.28676799f, -0.05644415f, 0.26264665f, -0.04587231f, 
    0.25491485f, -0.10701022f, -0.01888856f, 0.12539349f, -0.07627359f, -0.67050928f, 0.28555343f, 0.18455774f, 
    -0.03206283f, -0.07712714f, -0.13107233f, 0.11520789f, 0.31707472f, 0.29315686f, -0.23247881f, -0.22646651f, 
    -0.09301677f, -0.05704256f, -0.07723679f, 0.22270955f, 0.01346799f, 0.31066677f, -0.08338400f, 0.33218533f, 
    -1.54315281f, 0.14591715f, 0.25761718f, -0.19079728f, -0.02543395f, -0.00671697f, 0.09456574f, 0.37232974f, 
    0.18824877f, 0.27545866f, -0.11204296f, 0.11857010f, -0.32933217f, 0.15551461f, 0.01836281f, 0.02842682f, 
    -0.19515365f, -0.01890603f, -0.35920343f, 0.00643177f, -0.04979863f, -0.11274675f, 0.04861987f, 0.02281744f, 
    -0.05076369f, 0.36051106f, -0.15776968f, -0.11049460f, -0.13662454f, -0.18520880f, -0.10181223f, 0.08319528f, 
    -0.00243480f, -0.26087973f, -0.63883507f, 0.06845883f, -0.74939889f, -0.41705424f, -0.21980298f, 0.08993453f, 
    0.02265167f, 0.20545833f, 0.15962148f, 0.13756406f, -0.47872362f, -0.08232427f, -0.05889985f, -0.01912142f, 
    -0.15749891f, 0.10151756f, -0.01337413f, 0.08364265f, 0.18332098f, 0.24159074f, 0.19075643f, -0.03459009f, 
    -0.06095527f, 0.05911802f, 0.00381675f, -0.00976728f, -0.03482824f, 0.26459864f, 0.38592520f, 0.26473829f, 
    -0.00373338f, 0.13999526f, -0.13127695f, 0.10810418f, 0.11306161f, -0.08048851f, -0.00038734f, -0.37583980f, 
    0.17267853f, -0.16947177f, 0.22473681f, -0.33811387f, 0.22623686f, 0.03700973f, -0.05222683f, -0.35894907f, 
    0.47822943f, 0.86038709f, -0.16394348f, 0.02206747f, -0.00118224f, 0.11945665f, -0.03762237f, 0.02753025f, 
    -0.31840003f, 0.12141991f, 0.56218058f, -0.12809397f, -0.31550521f, -0.34146437f, -0.23997870f, -0.06293201f, 
    0.14885816f, 0.55207753f, 0.10487740f, -0.44445220f, -0.15039086f, 0.06992053f, 0.35456648f, 0.26619491f, 
    0.15089506f, 0.39650685f, -0.13331980f, 0.01521447f, 0.42080981f, -0.15990755f, -0.04611504f, -0.03879274f, 
    -0.17643765f, 0.18569998f, 0.04860868f, -0.17677978f, 0.02158826f, -0.30204773f, -0.09720121f, 0.03802826f, 
    -0.03794228f, 0.03492760f, 0.06773459f, -0.05522225f, -0.35792693f, -0.64852262f, 0.47452611f, 0.09127434f, 
    0.17458694f, 0.14029062f, 0.16321158f, 0.11152542f, 0.19934227f, 0.10615935f, -0.07683436f, 0.04640404f, 
    0.16585323f, 0.22987138f, 0.26485056f, 0.13451985f, 0.27025574f, 0.22971965f, -0.12542248f, -0.09636035f, 
    -0.41711834f, -0.06901832f, -0.10860766f, 0.29355612f, 0.12886585f, 0.07093104f, 0.30101320f, 0.34300339f, 
    -0.11960460f, -0.00233767f, 0.12916675f, -0.10147443f, -0.08588372f, -0.10731320f, -0.33072951f, 0.12291911f, 
    -0.35803002f, 0.26432058f, -0.28269598f, 0.21738349f, 0.15566909f, 0.20083594f, -0.01718943f, 0.34378043f, 
    -0.01064689f, 0.22888625f, 0.21600866f, 0.25679678f, 0.16748388f, 0.26843682f, 0.09068317f, 0.06097072f, 
    0.24581094f, 0.14864677f, -0.19281767f, -0.10384740f, 0.35398346f, -0.00702671f, -0.03103927f, -0.01641971f, 
    -0.03507765f, -0.15937623f, 0.05312550f, 0.05637607f, -0.05701964f, 0.32978702f, 0.08314624f, 0.28290322f, 
    0.16827689f, 0.38306072f, 0.52516985f, 0.19486511f, -0.22113685f, 0.04474952f, -0.17009538f, 0.23100211f, 
    -0.03051692f, -0.27675906f, 0.04359583f, -0.39301249f, -0.36910740f, -0.57797080f, -0.41486770f, -0.21905485f, 
    0.40083218f, 0.22808605f, 0.26274133f, 0.30415890f, 0.42686197f, 0.13617678f, 0.38846013f, 0.18774366f, 
    0.09628335f, 0.00861301f, 0.30984253f, 0.18508622f, 0.38641232f, 0.48834965f, 0.40524501f, -0.20557207f, 
    0.03938123f, -0.37765142f, -0.06098838f, 0.09690497f, -0.11969251f, 0.01339932f, 0.21646023f, -0.06654106f, 
    0.04896072f, 0.04403847f, -0.02893938f, -0.08606014f, -0.05668668f, 0.06523874f, 0.07408836f, -0.00701900f, 
    -0.00184457f, -0.00935361f, -0.05204456f, 0.00156734f, 0.05049893f, 0.00746611f, -0.06107260f, 0.05445283f, 
    0.00616197f, -0.05029289f, -0.00394329f, -0.04820304f, -0.01304060f, -0.06675325f, 0.06861588f, -0.04269917f, 
    -0.06578575f, -0.04645133f, 0.00825301f, -0.07099891f, -0.04696183f, 0.07350996f, -0.07777508f, -0.02322151f, 
    -0.03220883f, -0.07694162f, -0.02405323f, -0.06492719f, 0.04480994f, -0.07492194f, -0.04217905f, 0.01336364f, 
    0.06564621f, -0.01028259f, 0.06017403f, 0.01262901f, 0.00126738f, 0.00142487f, -0.03068428f, 0.02914424f, 
    0.04002513f, -0.08599516f, -0.03561509f, 0.04149467f, -0.01426440f, -0.06083415f, 0.00493655f, 0.07118531f, 
    0.02557763f, -0.04965991f, -0.00362195f, -0.04065779f, -0.07421955f, -0.05248477f, 0.02703246f, -0.00298658f, 
    -0.01973637f, 0.05744571f, 0.03392460f, 0.04787561f, 0.00107262f, -0.04202560f, 0.00768536f, 0.01552607f, 
    -0.07479536f, -0.08761182f, -0.02646822f, 0.04557806f, -0.02133948f, 0.05582502f, 0.01286560f, 0.06966459f, 
    -0.05210570f, -0.05589520f, 0.03176532f, -0.02075521f, 0.00659185f, -0.00788403f, -0.03531912f, -0.05125852f, 
    -0.07941914f, 0.00273535f, -0.03219007f, 0.01172161f, -0.07913688f, -0.07028647f, -0.06796265f, -0.03495748f, 
    -0.03611074f, 0.01889081f, 0.07273030f, 0.03508766f, -0.09130370f, -0.00107057f, -0.02717354f, 0.07014707f, 
    -0.08890441f, -0.01624888f, 0.01203316f, -0.03463047f, -0.02990695f, -0.09050391f, -0.05429857f, -0.05323309f, 
    -0.02574125f, -0.04381537f, -0.06351405f, 0.02930539f, -0.06271386f, 0.00979717f, -0.05172521f, -0.03959048f, 
    -0.02421159f, -0.01314994f, 0.04661020f, 0.03649388f, 0.05209688f, -0.01538063f, -0.03837776f, -0.03837349f, 
    -0.02279738f, -0.03717179f, 0.04688975f, 0.05816911f, 0.06207486f, 0.05658762f, -0.02476154f, 0.02646591f, 
    -0.01942551f, -0.01268957f, 0.03698425f, -0.06132268f, -0.03965414f, -0.08996610f, -0.08714858f, -0.06189387f, 
    0.18699887f, -0.23856217f, -0.73583144f, -0.21844579f, 0.00435030f, -0.07599343f, 0.12533455f, 0.00674650f, 
    -0.10028759f, 0.19733720f, 0.08166097f, -0.14534740f, 0.27318719f, 0.83872211f, 0.13322185f, 0.35813469f, 
    0.27316403f, 0.26438698f, -0.07159801f, -0.76626855f, -0.49414408f, -0.08640343f, 0.01053117f, -0.11462539f, 
    -0.03706686f, 0.10434809f, 0.10580437f, -0.28187391f, 0.25769076f, 0.13900577f, -0.13940549f, 0.09149832f, 
    -0.06255666f, -0.01480223f, 0.01359389f, -0.20462315f, -0.19468792f, -0.51493901f, -0.16392265f, 0.16176011f, 
    -0.01546613f, 0.02861946f, 0.18569502f, 0.22594132f, 0.11560211f, -0.00764518f, -0.03556972f, -0.24873663f, 
    -0.20268521f, -0.07084683f, 0.02317935f, -0.05706652f, -0.07561331f, -0.05662081f, -0.60316342f, 0.34740627f, 
    -0.00330551f, -0.09625946f, 0.29217246f, 0.19013411f, 0.23089214f, 0.06300810f, -0.14907624f, 0.12570620f, 
    -0.07676695f, -0.07702596f, -0.31157961f, -0.05414224f, -0.11697453f, 0.19320244f, 0.07043616f, -0.03531067f, 
    0.36284074f, 0.58221525f, -0.34772831f, -0.02030334f, 0.06033597f, -0.04961067f, 0.10801087f, 0.01293495f, 
    -0.06555182f, 0.32678041f, -0.19337834f, 0.02829738f, -0.23630403f, 0.01275361f, 0.09107324f, -0.14417447f, 
    0.01450970f, -0.06730192f, -0.39933601f, 0.39475274f, 0.19226703f, 0.00518493f, 0.06249740f, -0.09761415f, 
    0.12975313f, 0.14677726f, 0.06432815f, 0.21031745f, -0.13032246f, 0.10372092f, 0.12738921f, 0.05794978f, 
    0.06529140f, 0.04459466f, -0.04072201f, 0.10352855f, -0.08233107f, 0.15023799f, -0.12500638f, 0.21110739f, 
    0.06746468f, -0.16417195f, 0.07184008f, 0.09094435f, 0.49442908f, -1.79821730f, -0.84702367f, 0.24138875f, 
    0.17624253f, -0.02042554f, 0.02914944f, 0.13044921f, -0.14241147f, 0.16211599f, 0.25522846f, -0.13070489f, 
    -0.32840252f, -0.26428637f, -0.01540537f, 0.04710648f, 0.20286117f, 0.15144250f, -0.16085623f, -1.36091149f, 
    0.15424715f, 0.00331963f, -0.25999296f, -0.07748156f, -0.12412432f, -0.01064479f, -0.08120938f, -0.02247487f, 
    0.12686644f, -0.18691120f, -0.30460355f, -0.05091630f, 0.04145868f, 0.45306861f, 0.14846829f, 0.02785694f, 
    0.01800142f, -1.00343072f, 0.44719079f, 0.08430412f, 0.23279585f, -0.13844760f, 0.07453590f, 0.30990121f, 
    0.38722727f, 0.46510467f, 0.07388866f, -0.18143772f, 0.19343215f, 0.02760999f, -0.13077839f, -0.15274253f, 
    -0.10719208f, 0.14385282f, 0.30848378f, -0.11864305f, -0.06046553f, 0.11134990f, 0.27089772f, 0.21543615f, 
    -0.00552876f, -0.38912037f, -0.49860540f, -0.44069955f, 0.16159651f, 0.16734849f, 0.06713597f, -0.20292853f, 
    -0.07722083f, 0.26509118f, 0.13389909f, 0.14480463f, -0.04047300f, -0.01630141f, 0.06450682f, 0.10193319f, 
    0.21661539f, 0.10773625f, 0.03525459f, -0.25781056f, -0.69381243f, -0.67369014f, 0.20737980f, -0.32160470f, 
    -0.01679376f, 0.19077812f, 0.00919403f, -0.39337704f, 0.24004094f, 0.09377148f, -0.11872881f, -0.05567841f, 
    -0.15016876f, 0.11193363f, 0.22810633f, 0.24250732f, 0.26181731f, -0.23149340f, -0.07533196f, 0.01244417f, 
    0.38343945f, 0.03197026f, 0.18941456f, -0.10431564f, 0.03457991f, -0.00191359f, 0.07072606f, 0.00673957f, 
    0.09990194f, -0.14967972f, -0.00900093f, -0.14017317f, 0.02534250f, 0.08321919f, -0.00679169f, 0.31398690f, 
    0.13312925f, -0.02887245f, -0.16123354f, -0.06039693f, 0.23686324f, -0.05773805f, -0.11198649f, -0.06982301f, 
    0.23645824f, -0.10831969f, 0.14752023f, 0.28180316f, 0.13167775f, -0.19215558f, -0.12387606f, 0.15102187f, 
    0.11549437f, 0.13026433f, 0.11883631f, -0.08782149f, 0.05230963f, 0.00389574f, -0.44937441f, 0.38325793f, 
    0.36480951f, 0.18260971f, -0.05439393f, -0.03981017f, 0.24877509f, -0.21406038f, -0.06086275f, 0.02329548f, 
    0.36948735f, 0.10732738f, 0.12018771f, -0.23355198f, -0.07105704f, -0.22264349f, -0.19302426f, 0.08641407f, 
    0.06936361f, 0.10815170f, 0.14904702f, 0.08296761f, -0.08548000f, -0.32365581f, 0.03207120f, 0.17884377f, 
    -0.10525417f, -0.38985154f, 0.15625717f, 0.22843853f, 0.23579706f, -0.03906921f, -0.04561678f, 0.09921837f, 
    -0.06252931f, -0.06270333f, 0.01912893f, 0.04118020f, -0.03619049f, 0.02777143f, -0.01769479f, 0.01843204f, 
    0.02270030f, -0.03229118f, 0.04043422f, -0.08675100f, 0.06639322f, 0.05613798f, -0.09394924f, -0.06297240f, 
    -0.00296724f, -0.01028188f, -0.07582293f, 0.04857684f, 0.05324648f, -0.05787278f, -0.03772176f, -0.07948425f, 
    0.01991543f, -0.05986967f, -0.03067172f, -0.05929482f, -0.02702059f, -0.07901131f, 0.00175983f, -0.00404796f, 
    0.04801077f, 0.01846287f, 0.00145272f, 0.06280038f, -0.06959420f, -0.02258399f, 0.01082646f, -0.03843927f, 
    -0.07362030f, -0.01495828f, -0.07419236f, -0.04268615f, -0.00327345f, 0.01771241f, -0.08250483f, 0.03126219f, 
    0.06786807f, -0.06005465f, 0.05441090f, -0.06005693f, 0.02927327f, 0.02029533f, 0.04706317f, 0.03536852f, 
    -0.03792812f, 0.00972789f, 0.04333729f, 0.05917104f, -0.02697762f, -0.02458428f, -0.03462457f, -0.02066717f, 
    0.03327621f, -0.02622188f, 0.02816095f, 0.02437084f, -0.07867960f, -0.06468962f, 0.05589999f, 0.01447801f, 
    0.00663222f, -0.00569583f, -0.07804137f, -0.04503746f, 0.02990440f, 0.03212845f, -0.09447411f, 0.00783883f, 
    0.06136795f, 0.02454716f, -0.03526152f, 0.00810741f, 0.06286799f, 0.05402900f, 0.04923575f, -0.01917633f, 
    -0.07392116f, -0.00894434f, -0.05723294f, -0.01221466f, 0.01677585f, 0.06295141f, -0.00876294f, 0.02775219f, 
    0.03106658f, -0.04112612f, -0.07847817f, -0.06425509f, 0.04583463f, -0.07408313f, 0.04272443f, 0.06801006f, 
    -0.09357937f, -0.08775094f, -0.09438635f, 0.04250756f, -0.06883350f, -0.08272445f, -0.02517079f, -0.07837953f, 
    -0.05486219f, 0.06775810f, -0.07050175f, -0.08441751f, -0.09531401f, -0.02404757f, -0.01215860f, 0.05793637f, 
    0.03802256f, 0.06701750f, -0.02052364f, 0.02870985f, 0.03666673f, -0.00104377f, 0.03810489f, -0.06556123f, 
    0.03213263f, -0.00753814f, -0.01538051f, 0.06099026f, 0.02858020f, -0.02964861f, -0.05299494f, 0.04062794f, 
    -0.00412597f, -0.05989438f, -0.09285188f, 0.06749476f, -0.09369467f, 0.04473595f, -0.01120859f, -0.06435630f, 
    -0.71381348f, -0.08510479f, 0.15559022f, 0.03817679f, -0.04719935f, 0.09494524f, -0.04871755f, -0.01206172f, 
    0.16520238f, -0.33316767f, 0.50077748f, -0.06648021f, -0.03371379f, 0.04938900f, -0.06311880f, 0.01491080f, 
    -0.06118400f, 0.15641102f, -0.18752506f, -0.08852374f, 0.12280602f, 0.17162089f, -0.08508728f, 0.23405477f, 
    -0.02787868f, 0.16666065f, 0.12716749f, -0.11390611f, -0.16525123f, 0.03479254f, -0.11807867f, -0.19227058f, 
    0.03720204f, 0.09150323f, -0.16354553f, -0.43106699f, 0.24572396f, 0.30680186f, 0.13047466f, -0.03373294f, 
    0.04965507f, -0.13195239f, -0.10774425f, -0.01875449f, -0.07102834f, 0.25271478f, 0.02607373f, -0.25253138f, 
    -0.05363591f, -0.29879916f, -0.01818715f, 0.08898115f, -0.03707892f, -0.20890783f, 0.28133497f, -0.22162306f, 
    0.02056932f, 0.30942520f, -0.02007841f, -0.16635540f, 0.07485808f, -0.21946763f, -0.01133121f, 0.03208617f, 
    0.14030726f, -0.09293504f, 0.10708130f, -0.13169882f, -0.05288409f, 0.09135865f, 0.18340901f, 0.37159625f, 
    0.11935118f, -0.58402193f, -0.10947417f, 0.24940763f, -0.31481290f, 0.29948536f, 0.00400900f, 0.06146689f, 
    -0.24831800f, 0.01710501f, 0.01217798f, -0.40501973f, 0.08467020f, -0.00349445f, -0.23824015f, 0.09854268f, 
    0.22465250f, -0.05729777f, -0.23077874f, -0.27775931f, 0.70802170f, -0.16605379f, 0.26551446f, 0.00657740f, 
    -0.16139835f, -0.09383909f, 0.26945859f, -0.01719879f, 0.36983630f, -0.13551809f, -0.05828091f, -0.08549481f, 
    0.17201932f, 0.14099595f, -0.24283509f, -0.30371180f, 0.14435907f, 0.12352628f, -0.55951631f, 0.09470400f, 
    0.11222932f, 0.27478066f, 0.11147583f, 0.18850347f, 0.22806272f, 0.44304770f, 0.07175351f, 0.59280205f, 
    0.25856185f, -0.13079475f, -0.28282875f, -0.12970045f, -0.02058389f, -0.15322691f, 0.30041730f, -0.25303906f, 
    -0.37020907f, 0.18487860f, -0.07738549f, 0.03252662f, 0.00205774f, 0.09212867f, -0.24847333f, 0.24761033f, 
    0.11365876f, 0.15398218f, 0.22262718f, 0.15702356f, -0.00851412f, 0.01318062f, -0.03252646f, 0.06045743f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.19218282f, -0.05731044f, 0.42825857f, 0.44085872f, -0.12519635f, -0.06494974f, 0.05281264f, -0.14958526f, 
    0.33495176f, 0.26659691f, 0.68081212f, 0.05757417f, 0.27024841f, -0.15356795f, -0.09403127f, 0.26192415f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.61258340f, 0.13786185f, -0.68833297f, -0.29657361f, 0.61659718f, -0.22624613f, -0.11691572f, 0.55229002f, 
    -0.15842223f, -0.02110924f, -0.39427415f, 0.11254430f, 0.46731865f, 0.05114591f, -0.09505012f, -0.94617087f, 
    0.13745530f, 0.10033363f, 0.11920477f, -0.15476760f, 0.12194299f, -0.10864922f, -0.21381836f, -0.06673428f, 
    0.29365718f, 0.07431953f, 0.40716383f, 0.11584896f, 0.02313012f, -0.49906477f, 0.22834677f, -0.45411605f, 
    -1.15220988f, -0.12509839f, -1.25566876f, -0.25514817f, -0.33206210f, 0.11884151f, -0.25417802f, -0.30269510f, 
    0.03207363f, -0.52747077f, 0.44505444f, -0.21035117f, -0.84306669f, 0.40915716f, -0.09539149f, 0.30333686f, 
    -0.12851371f, 0.12742241f, -0.50813460f, -0.37731740f, 0.32612395f, 0.16806512f, 0.05011438f, 0.32458326f, 
    -0.31321147f, -0.54425097f, -0.04694327f, 0.07383645f, -0.96416378f, 0.47711927f, -0.19851875f, 0.40534484f, 
    0.28579384f, 0.04161597f, -0.14125679f, -0.10802133f, -0.30930603f, -0.03815749f, 0.09890639f, 0.52046978f, 
    0.46337196f, -0.07096472f, -0.19891870f, 0.00321635f, 0.22190097f, 0.30409136f, -0.24830483f, -0.29046467f, 
    -0.05246622f, -0.05543220f, -0.17658392f, 0.06775255f, 0.06417055f, -0.16053630f, -0.06235688f, -0.16457346f, 
    0.52962530f, 0.33830985f, 0.22349671f, -0.20992957f, -0.26903576f, -0.38548690f, -0.23649466f, 0.11057298f, 
    -1.99074852f, 0.04710123f, -0.92434371f, -0.20402378f, -0.55840200f, -0.16829960f, 0.17788586f, -0.26946551f, 
    -1.36882830f, -0.36453727f, 0.19122021f, -0.13219418f, 1.00146782f, 0.27053741f, -0.03722947f, 0.09057184f, 
    -0.17775847f, 0.07051168f, 0.46336451f, -0.50358731f, 0.26950338f, 0.18882640f, 0.23292741f, -0.01435558f, 
    -0.41383040f, 0.54498988f, -0.16494580f, 0.08722381f, 0.47224885f, 0.08553796f, 0.11103143f, 0.08219900f, 
    -0.41420570f, 0.13372149f, 0.50805521f, 0.40408999f, 0.58328503f, -0.02447760f, -0.13784669f, -1.07569766f, 
    -0.65603977f, -0.36183697f, 0.22228456f, -0.22930118f, -0.41466379f, -0.45050451f, 0.18585403f, -0.25702137f, 
    -0.35601109f, 0.19758162f, -0.71212369f, 0.39414203f, -0.84798610f, 0.14421055f, 0.10288096f, 0.25683671f, 
    -0.80829728f, 0.46838248f, -0.16777053f, -0.08798224f, -0.46459886f, 0.20515116f, 0.23213601f, 0.48798469f, 
    -1.14665532f, 0.22192827f, -0.98483551f, 0.76268947f, 0.03131358f, 0.10806892f, -0.04098748f, 0.41131738f, 
    0.87254626f, -0.47445887f, -0.02338288f, -0.19865026f, -0.17143424f, -0.69294989f, -0.17120957f, -0.37206113f, 
    -0.70500344f, 0.01792929f, 0.77267438f, -0.00927747f, -0.71336430f, -0.20836563f, 0.23653075f, 0.08492339f, 
    -0.57414740f, -1.26265180f, 0.22721025f, -0.09165136f, -0.33651149f, 0.10626529f, 0.22486736f, 0.12998463f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.73784655f, 0.52266520f, 0.33744818f, 0.14147599f, -0.34312460f, -0.49358708f, 0.49871325f, -0.27307367f, 
    0.33376583f, 0.39942157f, -0.00606715f, -0.34241319f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
