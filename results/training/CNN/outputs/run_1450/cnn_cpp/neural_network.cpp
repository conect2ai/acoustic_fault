#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.35535860f, -0.75232923f, -0.27824438f, -0.07900633f, -0.13005294f, 0.18814738f, 0.15019783f, 0.14742962f, 
    -0.69941831f, -0.40922564f, -0.52204829f, -0.62614751f, -0.11353686f, 0.78149104f, 0.35618946f, 0.00029072f, 
    -0.09397633f, -0.36365560f, -0.33276570f, -0.49145871f, -0.31200477f, 0.44695410f, -0.15381537f, -0.08011732f, 
    -0.51266438f, -0.41786575f, -0.46986175f, -0.65555978f, -0.66424441f, -0.37880692f, 0.67403555f, 0.27064645f, 
    -0.02678555f, 0.06421187f, 0.10880478f, 0.26031163f, 0.02603054f, -0.30983052f, 0.48812473f, 0.06333940f, 
    -0.11734278f, 0.49515447f, -0.16426855f, -0.28704509f, -0.01156267f, 0.60433382f, -0.63967413f, 0.66720659f, 
    -0.28457171f, -0.36040583f, 0.33151105f, -0.04271584f, -0.04812590f, 0.23825034f, 0.73715490f, -0.44540900f, 
    0.39341718f, -0.37027580f, 0.22061248f, -0.22053461f, -0.06685614f, -0.07251348f, 0.31826040f, -0.08537307f, 
    0.30009776f, 0.30440167f, -0.42556193f, -0.49366769f, -0.06296775f, 0.27193975f, 0.16731957f, 0.58054173f, 
    0.71783221f, 0.03756954f, 0.18057829f, 0.00019321f, -0.15230623f, 0.02746249f, 0.38770843f, 0.20851289f, 
    0.00264093f, -0.52687764f, 0.02484794f, 0.60586780f, 0.84596574f, -0.00723375f, -0.08391467f, -0.19452919f, 
    -0.41116488f, -0.10808439f, -0.52014512f, -0.80917782f, 0.91283906f, 0.23043251f, -0.41733450f, 0.08146801f, 
    0.29037181f, -0.22872370f, -0.27941200f, -0.55326480f, 0.34399486f, -0.61753416f, 0.39241284f, 0.34864458f, 
    0.39156270f, 0.34284297f, 0.07916441f, 0.21354420f, -1.03517234f, 1.00780618f, -0.45222080f, 0.45933160f, 
    -0.52236289f, -0.34589192f, -0.06451995f, 0.08896486f, 0.07487147f, 0.16572249f, 0.84483409f, -0.26305827f, 
    -0.34158251f, -0.34980556f, -0.10827506f, -0.01967629f, 0.35416472f, 0.48894867f, 0.46214694f, -0.15194017f, 
    -0.59828877f, -0.14687224f, -0.17845541f, -0.43511403f, -0.16872549f, 0.53039962f, 0.61218822f, 1.00201166f, 
    -0.34243640f, -0.47086036f, 0.04164022f, -0.03877927f, 0.24931698f, -0.31369394f, 0.36060745f, 0.09940696f, 
    -0.00079315f, 0.34427536f, 0.12157575f, -0.52284384f, 0.22433119f, 0.26701969f, -0.27962649f, -0.47960797f, 
    0.13868791f, -0.41189605f, 0.16294561f, -0.67313814f, -0.14993410f, 0.14313340f, 0.24248657f, 0.22193974f, 
    0.21844016f, 0.25123379f, -1.26540542f, 0.70984530f, 0.25022614f, -0.56246686f, 0.17926987f, 0.23746301f, 
    0.00316935f, 0.22462361f, 0.00927635f, -0.27663058f, 0.72418082f, -0.08254398f, 0.36155790f, 0.34929496f, 
    0.44954458f, 0.25428391f, -0.47446316f, 0.14800750f, -0.69726270f, 0.01973748f, 0.44518372f, 0.31047058f, 
    0.51109064f, -0.63106591f, 0.35254300f, 0.01073136f, 0.17390208f, 0.47539097f, -0.12131086f, -0.06896964f, 
    0.56274116f, 0.06860138f, 0.46283653f, -0.14760605f, -0.44029850f, -0.17011826f, 0.44252470f, -0.53081745f, 
    0.54651737f, 0.10765512f, 0.00328154f, -0.09167622f, 0.08644066f, 0.35999650f, 0.21804595f, -0.05739791f, 
    -0.35405031f, 0.46401498f, -0.70134747f, 0.21714360f, 0.54988509f, -0.17533696f, 0.01533157f, 0.51106477f, 
    0.15883633f, -0.33215311f, -0.21242656f, -0.69453508f, -0.49472371f, -0.76553643f, 0.46668842f, 0.06232139f, 
    0.23531541f, -0.04918338f, 0.00225964f, 0.04018386f, -0.30179036f, -0.28993365f, 0.66914707f, 0.17098257f, 
    0.23122640f, -0.37564880f, 0.31575492f, 0.53579402f, 0.66096658f, -0.09054475f, -0.10377301f, -0.23114701f, 
    0.07735080f, -0.41076511f, 0.01409138f, -0.34884933f, -0.38874504f, 0.24659246f, -0.32319942f, -0.68269581f, 
    -0.70397812f, 0.30352110f, -0.04020033f, 0.34924644f, -0.04300806f, -0.51171291f, -0.38986233f, 0.69929910f, 
    -0.46030432f, 0.65100598f, -0.13500977f, -0.12195496f, -0.08434340f, 0.70337719f, -0.59807968f, -0.16891755f, 
    -0.31214193f, -0.07798389f, -0.67833978f, -0.43176448f, -0.41081721f, 0.11994328f, -0.50819522f, 0.76313466f, 
    -0.46293312f, -0.54361910f, -0.38145715f, -0.11366547f, -0.05886868f, -0.33395007f, -0.17303608f, 0.23606922f, 
    -0.21366765f, 0.01010396f, 0.40446985f, -0.48911190f, -0.06253026f, 0.36796939f, 0.42906323f, -0.18588695f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.37446603f, -0.37983859f, -0.32176608f, 0.00253903f, 0.24812976f, 0.04940064f, 0.17392017f, 0.00149611f, 
    0.08918837f, 0.39821562f, 0.16187342f, -0.07600886f, 0.07015312f, 0.06615969f, 0.16789977f, 0.30176792f, 
    0.42866606f, 0.47360140f, -0.10186712f, -0.17947407f, -0.11944289f, 0.07996873f, -0.12687370f, -0.01623279f, 
    -0.04412962f, 0.11536442f, -0.14587611f, -0.23131907f, -0.04155461f, 0.08662720f, 0.10086301f, 0.24933261f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04156169f, 0.20488216f, 0.55299073f, 0.04923549f, 0.13225998f, 0.00529854f, 0.03138754f, 0.14359288f, 
    0.09493110f, -0.46562701f, -0.10476251f, 0.47076640f, -0.05641016f, 0.05976782f, -0.06265950f, -0.01413135f, 
    0.01860058f, 0.13023829f, -0.12782079f, 0.06160812f, 0.16245155f, -0.11099344f, 0.01432705f, -0.04578054f, 
    -0.04985759f, -0.08901498f, -0.04419659f, -0.28589734f, 0.35029945f, 0.35756591f, -0.16239464f, 0.02886693f, 
    -0.04781837f, -0.06938770f, 0.04008547f, 0.08119410f, 0.06353730f, 0.04629333f, -0.04985919f, 0.02988826f, 
    0.02479714f, 0.09158007f, 0.02226440f, -0.05760559f, 0.12245239f, 0.05746184f, 0.05594584f, -0.10624325f, 
    -0.03791375f, -0.11837243f, 0.17370936f, -0.03206818f, -0.05657551f, -0.10177556f, 0.31358534f, -0.12485975f, 
    -0.15740542f, 0.02320702f, 0.01994188f, 0.08064101f, 0.00988890f, 0.08407472f, -0.09523121f, -0.05763728f, 
    -0.38151953f, -0.22651739f, 0.02406058f, 0.13223079f, 0.08031517f, 0.10817534f, -0.00711683f, -0.03972016f, 
    0.03840822f, 0.03122802f, -0.16667071f, 0.06766357f, -0.02223840f, -0.03702648f, 0.04761404f, 0.06979153f, 
    0.10244029f, 0.00352485f, 0.16516295f, 0.03854113f, 0.00772124f, -0.07220282f, 0.03819405f, 0.19924527f, 
    0.20320934f, 0.23324193f, 0.24812001f, 0.04410252f, 0.14938048f, 0.00861737f, 0.00421453f, 0.06668471f, 
    -0.11732771f, 0.00080338f, 0.05823970f, -0.12356453f, 0.07646996f, 0.01833103f, -0.05814984f, -0.16281186f, 
    0.04798955f, -0.00394824f, -0.03883486f, -0.01156422f, -0.15430608f, -0.18416050f, -0.21987477f, 0.07232573f, 
    -0.08374480f, -0.03143513f, 0.21292186f, -0.01990192f, -0.07357194f, 0.05280161f, -0.24964035f, -0.27316201f, 
    0.12301752f, 0.04848465f, 0.10093795f, 0.06254020f, 0.03076702f, -0.03478738f, 0.10182095f, 0.25817966f, 
    -0.24790202f, 0.07234480f, 0.06749348f, -0.08838272f, 0.04619151f, -0.05395195f, 0.00186027f, 0.33012533f, 
    0.12547244f, -0.25098878f, 0.04924751f, -0.02890921f, -0.07976087f, 0.09094500f, 0.11117513f, 0.09442944f, 
    0.01795107f, -0.10604963f, -0.04581941f, -0.07896446f, 0.08906664f, 0.02520504f, 0.10589170f, 0.18693620f, 
    0.25015259f, 0.02276817f, 0.33211696f, 0.20143610f, 0.07242890f, 0.02179100f, 0.13112004f, -0.02151465f, 
    0.00407907f, 0.04770796f, -0.85261482f, -0.34881794f, -0.34598035f, 0.07620205f, -0.17891295f, -0.17309660f, 
    0.01142390f, -0.01928508f, 0.11151613f, -0.15628910f, -0.12476414f, -0.15674178f, -0.06066827f, -0.13379890f, 
    -0.08905223f, 0.09267791f, 0.04312372f, 0.09110008f, -0.15049587f, -0.19398955f, 0.10991416f, 0.07370874f, 
    -0.13650754f, -0.23184741f, 0.01657282f, -0.03906201f, 0.14453681f, 0.03073340f, 0.07096224f, -0.08886710f, 
    -0.19525991f, -0.04993961f, -0.00249196f, 0.11867652f, 0.00695290f, 0.15454291f, 0.08628300f, -0.01155395f, 
    -0.22412705f, -0.10850173f, 0.07892475f, 0.14626554f, 0.09039861f, -0.10194495f, -0.09725894f, 0.00139157f, 
    -0.06756146f, -0.21181655f, -0.06169625f, 0.07151412f, 0.16352381f, 0.07005822f, 0.06561463f, -0.04342835f, 
    -0.21671405f, -0.29912555f, -0.46843591f, -0.18363544f, -0.09905259f, -0.16246079f, 0.05913051f, 0.04310204f, 
    -0.07256367f, 0.01508643f, -0.04708127f, -0.08356006f, 0.08944358f, 0.13973375f, 0.08031660f, 0.12546812f, 
    0.14535739f, 0.15456823f, -0.12214481f, -0.17576796f, -0.09364520f, -0.01954586f, 0.03890027f, -0.03994783f, 
    -0.10490599f, 0.20345145f, 0.03331514f, -0.21757951f, -0.52665216f, -0.43889084f, -0.24110229f, -0.12842587f, 
    -0.17086850f, 0.01847437f, 0.03439939f, -0.03395749f, -0.02062581f, -0.01280975f, 0.03402425f, -0.11283363f, 
    -0.03459610f, 0.11367503f, -0.01649985f, 0.10485558f, 0.02150694f, -0.27438423f, -0.35891172f, -0.18711351f, 
    0.09512174f, 0.03326552f, -0.04149004f, -0.02849174f, -0.00280184f, 0.03431136f, -0.29572070f, -0.23728211f, 
    -0.31717035f, 0.09248478f, -0.06362693f, 0.05910508f, 0.03232428f, -0.03132172f, 0.00504832f, 0.06903292f, 
    0.11972009f, -0.08370438f, -0.01825456f, 0.11929453f, 0.01489185f, 0.07280874f, 0.03132749f, 0.09563729f, 
    0.05675653f, 0.05469752f, 0.03916405f, -0.02756360f, 0.05356840f, -0.05058714f, 0.04728751f, -0.03284923f, 
    -0.05490794f, 0.01816663f, 0.04984127f, -0.02255609f, 0.04332849f, 0.00791278f, 0.00093949f, 0.03861882f, 
    0.01644928f, -0.00732200f, -0.02143332f, -0.05816111f, -0.03480029f, 0.05032829f, 0.03142272f, -0.02984012f, 
    0.02111842f, 0.04146441f, 0.02468343f, -0.01346220f, -0.02130470f, -0.00046579f, 0.00161309f, -0.05293441f, 
    -0.02831446f, -0.02638504f, -0.00885997f, -0.00099699f, 0.01172970f, -0.02175206f, 0.03305282f, -0.00189409f, 
    -0.05442796f, 0.00603594f, 0.03277331f, -0.04469914f, -0.01612194f, 0.01552280f, -0.00682531f, -0.00273839f, 
    -0.00587550f, 0.01685677f, 0.01462276f, -0.00272119f, -0.01157350f, 0.04050651f, -0.05376750f, 0.03960619f, 
    -0.00180936f, -0.02871881f, 0.03979275f, 0.01505748f, -0.01869081f, 0.01504121f, -0.02815062f, -0.04257369f, 
    -0.02251911f, -0.00083364f, -0.03449433f, -0.05504239f, -0.04362008f, -0.03894398f, 0.03603140f, 0.02430078f, 
    0.05422231f, -0.05880938f, -0.00128315f, -0.00463874f, -0.04734093f, -0.04068438f, -0.00758369f, 0.04417829f, 
    -0.03756941f, -0.02946389f, 0.00732816f, 0.01493832f, -0.02188205f, -0.04702600f, 0.05521047f, -0.01824380f, 
    -0.04565959f, -0.04085626f, -0.03501205f, 0.04292701f, 0.01414953f, -0.04695844f, 0.01831147f, -0.02901840f, 
    -0.05625053f, -0.03678190f, -0.00806734f, 0.02451180f, 0.01493752f, -0.05380963f, 0.00725127f, 0.04021779f, 
    -0.01532987f, -0.04300077f, 0.02511840f, -0.05276796f, 0.00718897f, -0.04611469f, -0.00166884f, -0.04021882f, 
    -0.01486538f, -0.02657514f, 0.05137922f, 0.03209649f, 0.04412356f, 0.01369265f, 0.04479795f, 0.01878595f, 
    0.03530272f, -0.02526220f, -0.04170065f, 0.01862764f, 0.04449803f, 0.02975419f, -0.01483651f, 0.00227951f, 
    0.03028094f, -0.02056306f, 0.02433218f, 0.01137255f, 0.00897422f, -0.01937540f, 0.02200721f, 0.01530603f, 
    -0.01254214f, 0.02858326f, -0.03336819f, -0.04664027f, -0.02869086f, 0.03336974f, -0.01973587f, -0.04718921f, 
    0.00731362f, 0.04465774f, -0.01366856f, 0.04445025f, -0.00935456f, -0.03750396f, -0.02936693f, -0.03532306f, 
    0.05883556f, -0.05176404f, -0.05889482f, -0.04795619f, 0.04090001f, 0.04886247f, -0.04620144f, -0.01220139f, 
    -0.03867785f, -0.04177664f, -0.00581526f, 0.02649513f, 0.01921910f, -0.04185719f, -0.01112218f, -0.01320338f, 
    -0.01979932f, 0.00472313f, -0.00330943f, -0.00097349f, -0.03840664f, -0.04424617f, -0.02506343f, -0.05610357f, 
    0.03286473f, 0.05094849f, -0.03744835f, -0.02104798f, -0.00463318f, 0.03437731f, -0.03533852f, 0.04590434f, 
    -0.05073910f, 0.02153884f, 0.00552791f, 0.01475391f, 0.01299835f, 0.02238213f, -0.01209774f, 0.01412859f, 
    -0.01547777f, 0.02956223f, 0.00181592f, 0.00225767f, 0.03347255f, 0.01114644f, -0.05399941f, 0.00430153f, 
    0.03590645f, -0.05797700f, -0.00889999f, -0.01581589f, -0.01714294f, -0.03548291f, -0.03082005f, 0.01117338f, 
    0.00041298f, -0.04983872f, -0.03304410f, -0.04295412f, -0.04462446f, -0.04239989f, -0.01397412f, -0.05830626f, 
    0.04046337f, 0.00912885f, 0.04073260f, -0.01622770f, -0.04941633f, -0.00770049f, 0.01296638f, -0.04238738f, 
    -0.03187719f, 0.05158666f, 0.01107561f, -0.04385911f, -0.04097411f, 0.00684733f, -0.04234365f, 0.04265403f, 
    -0.03342629f, 0.00158121f, 0.00132314f, 0.00426959f, 0.00414174f, -0.02773043f, -0.05877778f, 0.02475538f, 
    -0.03197496f, 0.00266223f, -0.00796078f, 0.00584143f, 0.01104712f, -0.03726768f, -0.04880524f, 0.05497172f, 
    -0.01289362f, -0.05660753f, -0.04105670f, -0.02733881f, -0.00683326f, -0.03251426f, 0.04581542f, -0.01597727f, 
    0.02621558f, 0.00983264f, -0.00876727f, -0.01780320f, 0.03774948f, 0.03604225f, -0.00055203f, -0.05069492f, 
    -0.03354553f, -0.03939378f, -0.05538665f, 0.02528329f, -0.05358028f, -0.01950795f, -0.02403196f, 0.02669677f, 
    -0.03760770f, 0.03319869f, 0.02621712f, 0.02043262f, -0.02767339f, -0.01823107f, 0.05174488f, 0.01136675f, 
    -0.04576709f, 0.02374963f, -0.02929884f, -0.01592096f, -0.05778807f, 0.04617555f, 0.00273190f, -0.01206881f, 
    0.24023791f, 0.19506237f, -0.10974939f, 0.05857639f, -0.00662171f, 0.13773976f, -0.00897993f, -0.12046335f, 
    0.07562295f, 0.27895454f, 0.38266551f, -0.06650370f, -0.06666807f, -0.11053293f, 0.08630300f, 0.02661891f, 
    -0.19673139f, -0.10595518f, 0.30319902f, 0.31323087f, 0.14983396f, -0.03000198f, -0.04894435f, -0.03293718f, 
    0.02247998f, -0.04314273f, -0.28863582f, 0.23180377f, 0.29663479f, 0.12752217f, -0.07857019f, 0.06479026f, 
    -0.01569958f, -0.02537992f, 0.12860894f, 0.02171093f, -0.00416644f, 0.06023540f, -0.03012931f, 0.00886291f, 
    0.02648908f, -0.18273123f, -0.01096708f, -0.03266088f, -0.07379498f, 0.26459014f, 0.15323684f, -0.17009531f, 
    0.01472298f, -0.04055025f, -0.23924595f, 0.13913399f, 0.05098893f, 0.07092345f, 0.20300566f, 0.16981032f, 
    -0.02141172f, -0.04487941f, 0.06507830f, -0.07322316f, -0.07877348f, -0.02815727f, 0.20124513f, 0.02389182f, 
    -0.23733360f, 0.06706796f, 0.02929590f, -0.04038185f, -0.05882001f, 0.02096576f, 0.07119525f, 0.14037636f, 
    -0.20541558f, 0.00507642f, -0.04972572f, -0.09511974f, -0.05625832f, -0.07485285f, 0.16154610f, -0.01437031f, 
    0.02745949f, -0.00043353f, 0.06623039f, 0.15795402f, 0.03694981f, -0.09127534f, -0.10051340f, 0.13241012f, 
    -0.09595744f, 0.03146878f, 0.37905341f, -0.12510732f, -0.19266458f, 0.07896014f, -0.02572829f, 0.10257728f, 
    -0.06970972f, 0.10180236f, 0.11320464f, -0.36224714f, 0.07986906f, -0.39236438f, -0.00711871f, 0.14460856f, 
    0.07470220f, 0.10845030f, 0.13453633f, 0.07177371f, -0.06619412f, 0.18169205f, 0.04655274f, 0.04571986f, 
    -0.10293675f, 0.05160853f, -0.03230793f, 0.02628512f, -0.23158740f, -0.33975148f, -0.17548779f, 0.07607653f, 
    -0.03358803f, -0.22404025f, 0.08957401f, -0.02749221f, 0.05948258f, -0.03112903f, -0.06833920f, -0.35060751f, 
    -0.03042945f, 0.17274186f, -0.00505081f, -0.15612169f, 0.07878119f, 0.03273740f, 0.08081885f, 0.48720121f, 
    -0.13133349f, 0.10592011f, 0.08667325f, 0.13607268f, 0.09461912f, -0.01083239f, 0.10865369f, 0.07212606f, 
    0.05753257f, 0.05499996f, 0.14183669f, -0.12455936f, 0.06227989f, -0.05050738f, -0.08678720f, -0.03598185f, 
    0.05086033f, -0.03127884f, 0.05763022f, -0.17804185f, 0.02311237f, 0.14879826f, 0.02383917f, 0.10287245f, 
    0.03575884f, 0.08376473f, 0.22141936f, -0.43948153f, -0.17909025f, -0.09362724f, -0.09099400f, -0.02944310f, 
    -0.15945554f, -0.02704254f, 0.03860582f, -0.12697412f, -0.05877742f, -0.32429999f, -0.06136463f, -0.38583645f, 
    -0.15947412f, -0.03569565f, 0.00001526f, -0.06888706f, 0.14983152f, -0.33428335f, -0.24688783f, 0.02959435f, 
    -0.16422532f, 0.16920923f, -0.02851550f, 0.10250092f, 0.07871297f, 0.11139422f, -0.11875641f, -0.02693100f, 
    -0.06125509f, -0.03165721f, -0.17864543f, -0.12101317f, -0.17679349f, -0.16031460f, 0.25598881f, -0.16265267f, 
    -0.10132673f, 0.01228166f, -0.15226527f, -0.12339304f, -0.08317787f, 0.07320445f, 0.08593760f, 0.12701921f, 
    0.18429261f, -0.18040618f, -0.03003879f, 0.05593106f, -0.01162496f, 0.21855675f, -0.02509137f, 0.14954554f, 
    -0.09815623f, -0.01202853f, -0.09897549f, -0.10953718f, -0.27309078f, -0.18450530f, 0.03348876f, 0.10104338f, 
    0.14118636f, -0.06955550f, -0.16411601f, 0.21503797f, 0.23465879f, -0.02407483f, -0.17680159f, 0.13954778f, 
    0.01484989f, 0.04641595f, -0.24930535f, 0.01829658f, -0.13738857f, -0.18380068f, -0.18725646f, 0.17212498f, 
    -0.01145639f, 0.17742111f, 0.18713586f, -0.06772655f, -0.05210810f, 0.03238139f, -0.07354701f, -0.19022280f, 
    -0.07929923f, -0.07058657f, 0.08988290f, 0.02830399f, 0.30884203f, 0.06057226f, -0.22290385f, -0.04908498f, 
    0.12478857f, 0.08051471f, 0.02820209f, 0.02531021f, -0.04624601f, 0.17367822f, -0.18465982f, -0.14571595f, 
    -0.01934768f, -0.03675789f, -0.07258549f, 0.22477195f, 0.11164230f, 0.17466670f, -0.12057677f, 0.00205620f, 
    -0.09953771f, 0.09177540f, -0.04425592f, -0.03164810f, 0.12520474f, 0.01581920f, -0.13632573f, -0.07859948f, 
    -0.16209929f, 0.01209119f, 0.07606519f, 0.11071540f, -0.01477409f, 0.03699403f, 0.05612028f, -0.03784648f, 
    0.00726326f, -0.00396307f, -0.04993723f, -0.05740862f, -0.06710429f, 0.03184681f, -0.04740377f, 0.04632793f, 
    -0.04092261f, -0.02574753f, -0.03772050f, -0.05711104f, 0.04944489f, 0.03698833f, 0.00819853f, -0.06195777f, 
    -0.03002702f, 0.01747224f, -0.01959144f, 0.03530535f, -0.00648953f, -0.04991803f, -0.01080695f, 0.04385833f, 
    -0.03166824f, -0.03497026f, 0.04856205f, 0.05665703f, 0.01362429f, -0.04750851f, -0.01757470f, -0.00370989f, 
    0.01664311f, -0.02160828f, 0.03373766f, -0.02550001f, 0.04720092f, -0.02698093f, -0.03896666f, 0.02286645f, 
    -0.00238519f, -0.00978271f, -0.02300621f, -0.06303042f, -0.03105900f, -0.02797143f, 0.02442877f, 0.01907791f, 
    0.01919653f, 0.01339864f, 0.01999279f, 0.05166909f, -0.03010474f, 0.03867711f, -0.06784067f, 0.04554929f, 
    -0.05887299f, -0.03059274f, 0.04086548f, 0.03229649f, -0.01399984f, 0.03276059f, 0.01905528f, -0.06604830f, 
    -0.00887112f, 0.01673417f, -0.05240746f, -0.03011724f, -0.02349465f, 0.02905034f, -0.02873851f, 0.05138232f, 
    -0.04916555f, -0.06189853f, 0.02585935f, -0.01451036f, 0.02162143f, -0.06306284f, -0.04888048f, 0.03641179f, 
    -0.05232228f, -0.00092239f, 0.00263767f, -0.01786657f, 0.01441893f, 0.00591240f, -0.01743413f, -0.04616530f, 
    -0.04155493f, -0.01997035f, 0.00197184f, 0.01285949f, -0.05876537f, -0.00757083f, -0.07011318f, -0.05843992f, 
    0.03072452f, 0.02036365f, -0.04000900f, 0.01936290f, 0.00451055f, 0.01288714f, -0.03413773f, 0.00033330f, 
    -0.03675491f, -0.03862044f, 0.02879519f, -0.00183771f, -0.01700491f, -0.03668563f, 0.00682268f, 0.03359976f, 
    -0.06448839f, -0.00344831f, 0.01618792f, -0.02045324f, 0.02573253f, 0.03976244f, -0.04696676f, -0.01979107f, 
    -0.02120641f, 0.02177891f, 0.05182008f, -0.05188072f, -0.01715657f, 0.00039091f, 0.02081434f, -0.00204342f, 
    -0.06521124f, 0.00114733f, -0.02799348f, 0.00917435f, -0.06538478f, -0.02783923f, -0.04158014f, 0.03702964f, 
    0.02936951f, -0.03376205f, -0.00227933f, 0.03034097f, 0.04671663f, -0.02676363f, -0.01572534f, 0.01053158f, 
    -0.01962919f, 0.03637732f, -0.04187206f, 0.04528050f, -0.03296034f, 0.01313237f, -0.05656185f, -0.05951703f, 
    0.02277524f, 0.00277517f, 0.03956763f, 0.02411265f, -0.02904983f, 0.03001115f, 0.02128933f, -0.04759049f, 
    -0.03070356f, 0.04773682f, -0.00566848f, 0.04609035f, -0.05952291f, -0.00077391f, -0.01173740f, -0.04364359f, 
    -0.01764758f, 0.02553390f, -0.06148898f, 0.04459935f, 0.02541813f, 0.02381479f, 0.03719516f, 0.02094023f, 
    0.00191981f, -0.03725836f, -0.05364788f, -0.04422118f, 0.02751605f, 0.01087554f, -0.01976868f, -0.05953639f, 
    0.05140492f, -0.02827828f, -0.03674472f, -0.04380649f, -0.00075207f, 0.03283337f, -0.05697781f, 0.00530851f, 
    -0.01515226f, -0.04097320f, 0.04718878f, -0.04339838f, -0.04971600f, -0.04550497f, -0.00084040f, -0.05375442f, 
    -0.00336994f, 0.03455573f, -0.02992669f, -0.06417239f, 0.00588189f, 0.03034743f, -0.00441976f, 0.02640045f, 
    -0.01532121f, 0.02900751f, -0.04934001f, 0.03360293f, 0.03650713f, -0.06461276f, -0.04886787f, 0.03515177f, 
    0.03800453f, -0.01449262f, -0.05037364f, 0.04860171f, 0.01930682f, -0.05233345f, -0.04004211f, -0.03754449f, 
    0.03746862f, 0.02644823f, -0.03652840f, 0.04786943f, 0.01212404f, -0.03454916f, 0.01496232f, -0.04016045f, 
    -0.03035339f, 0.04157510f, 0.01499275f, -0.02153693f, 0.05538324f, -0.06511321f, 0.04964640f, -0.01584545f, 
    0.05157368f, -0.01615298f, 0.04934516f, -0.00302037f, 0.02025275f, -0.05375433f, 0.01729369f, 0.04566930f, 
    -0.03462877f, 0.02858937f, 0.01957020f, -0.06387496f, -0.03944714f, -0.04703797f, 0.04125208f, -0.02191928f, 
    0.02141054f, 0.05277023f, 0.01658865f, -0.02564168f, -0.02064016f, 0.03165967f, -0.01234860f, -0.04347026f, 
    0.02543135f, -0.05350108f, -0.03857729f, -0.04031929f, 0.03168770f, 0.01183449f, 0.03195323f, -0.01345961f, 
    0.05666828f, 0.02276505f, -0.01888016f, -0.01409073f, -0.03266801f, -0.00846524f, -0.06651444f, -0.01110009f, 
    -0.03620359f, -0.04712509f, 0.03403738f, -0.05374845f, 0.04178073f, -0.00187013f, -0.06273336f, -0.00586262f, 
    0.07226343f, 0.16869888f, 0.10665940f, 0.17295185f, 0.00565532f, 0.13263728f, 0.12860902f, 0.19815075f, 
    0.12508138f, 0.00689911f, 0.11912894f, 0.27853835f, -0.12047294f, -0.08086063f, -0.18368585f, 0.10139924f, 
    0.06913319f, -0.15176700f, 0.03907099f, -0.01073689f, 0.06114228f, -0.04897604f, -0.04173978f, 0.08498871f, 
    0.22599047f, -0.05775533f, -0.05832918f, -0.32049412f, -0.10521062f, 0.27004763f, -0.06951702f, -0.04064166f, 
    -0.00697589f, 0.11495554f, -0.02930349f, 0.02570101f, -0.08393434f, -0.10493189f, -0.32211670f, 0.11853798f, 
    0.05722528f, -0.14785050f, 0.14771046f, 0.17548542f, 0.07823241f, -0.19861721f, -0.16591676f, -0.32102534f, 
    0.01701455f, -0.06768382f, -0.14770141f, 0.24786070f, -0.01144869f, -0.06468795f, 0.00408731f, -0.11625633f, 
    0.08813448f, 0.03986083f, 0.33028683f, 0.08785416f, 0.24561477f, 0.07313193f, -0.03356461f, 0.04368421f, 
    0.07307476f, -0.22760934f, -0.04808465f, -0.02358193f, -0.02627151f, -0.05049898f, -0.02230193f, -0.03319535f, 
    -0.28286865f, -0.13541567f, -0.00296761f, 0.14108330f, -0.09300753f, 0.09037271f, 0.22310293f, -0.07149941f, 
    0.03036006f, 0.22351559f, 0.25580925f, 0.07040056f, 0.27913800f, 0.14463086f, -0.11735432f, 0.25822273f, 
    0.07947063f, 0.07309120f, 0.14425153f, 0.23736325f, 0.18239276f, 0.12286843f, 0.02842476f, -0.06875771f, 
    0.09660263f, 0.05643608f, 0.22626124f, -0.13898720f, -0.29032168f, 0.00707204f, -0.06074956f, -0.05155711f, 
    0.06464349f, 0.02991267f, 0.11324777f, -0.00872457f, 0.19121869f, 0.15445910f, 0.19172998f, 0.09453227f, 
    0.02512373f, 0.04551017f, 0.16238023f, -0.12527500f, 0.07354290f, 0.01115360f, 0.13639516f, -0.18842892f, 
    -0.07861921f, -0.00668870f, 0.04465992f, 0.19456542f, -0.01139204f, -0.02943023f, 0.08063729f, 0.19271560f, 
    0.47683406f, 0.02502243f, 0.01277223f, 0.19042349f, 0.10733498f, -0.00540312f, 0.10336217f, -0.13880041f, 
    0.07659607f, 0.21950343f, -0.00117064f, -0.06434995f, 0.15706766f, 0.13465284f, 0.11273882f, 0.03362770f, 
    0.11302929f, -0.00029180f, -0.28248861f, 0.03074653f, 0.02227573f, 0.07737413f, 0.08398269f, 0.24237341f, 
    0.14864837f, 0.00610398f, 0.08003072f, 0.36354202f, 0.01470740f, 0.15782778f, 0.13732398f, 0.16241498f, 
    0.13634726f, 0.08196361f, 0.63621628f, -0.18587671f, -0.36859742f, -0.35132399f, 0.00924229f, -0.16674079f, 
    -0.05488445f, -0.17094825f, 0.04981752f, -0.36083439f, -0.32930672f, -0.18523985f, 0.11626155f, -0.07071137f, 
    -0.12853535f, 0.09219422f, 0.15985614f, -0.05065448f, 0.08007649f, -0.19017217f, -0.26942417f, 0.00953765f, 
    -0.20342512f, -0.16325690f, 0.20080753f, 0.03220856f, 0.09218319f, -0.34016606f, -0.31164101f, -0.16036297f, 
    0.08235080f, -0.09558894f, -0.09456206f, 0.13565913f, 0.11926165f, 0.07789797f, -0.28958571f, -0.28429818f, 
    -0.10185590f, -0.04232663f, 0.03969712f, -0.09745598f, 0.09223792f, -0.02250348f, 0.02374342f, -0.11303829f, 
    -0.08898281f, -0.31600901f, -0.11034930f, -0.05941418f, -0.04160738f, 0.22665265f, 0.10775021f, -0.04269203f, 
    0.12009194f, -0.10635553f, 0.50588375f, -0.08421884f, 0.11012845f, 0.09809094f, 0.00161010f, -0.26161927f, 
    0.01005177f, -0.16707747f, 0.13241573f, -0.28381017f, 0.02960619f, -0.11101037f, 0.07883994f, 0.04404644f, 
    0.07722498f, 0.32236713f, -0.44200239f, 0.09657196f, 0.02215259f, -0.10476619f, -0.14063710f, -0.01040288f, 
    -0.06829391f, 0.06681729f, -0.11726881f, -0.07898953f, -0.02724460f, 0.39332271f, -0.06390455f, -0.12858538f, 
    0.02880624f, 0.05210166f, -0.14716451f, -0.07189678f, -0.14695042f, 0.22590196f, -0.05262816f, 0.09567630f, 
    -0.09257977f, 0.14759086f, 0.06418995f, 0.03753234f, 0.06449136f, 0.11011047f, 0.07601095f, 0.36504766f, 
    -0.00275258f, 0.13899486f, 0.15864822f, 0.08143692f, -0.05065352f, -0.06196491f, 0.03441437f, 0.05927178f, 
    0.11131828f, 0.10865992f, -0.00453389f, 0.11530064f, 0.12308480f, 0.03857355f, -0.08324999f, -0.13135445f, 
    0.04838043f, -0.00201584f, 0.00114098f, 0.07589205f, 0.04256376f, 0.29019901f, 0.14670187f, 0.19950275f, 
    0.44896337f, 0.04974397f, -0.05762114f, 0.11190724f, 0.03748466f, 0.10158527f, 0.02778782f, 0.11046141f, 
    0.23077886f, -0.33304700f, -0.31974241f, -0.30392697f, 0.09717810f, 0.02505662f, -0.20176455f, -0.15624554f, 
    -0.06227121f, 0.10175376f, -0.14007850f, -0.27975798f, -0.10835455f, -0.21924882f, -0.13456093f, 0.02620392f, 
    0.02918227f, 0.00762348f, 0.07462012f, -0.46036193f, -0.18813764f, -0.21106161f, -0.00544719f, 0.11119404f, 
    0.12240399f, -0.00340516f, -0.04423610f, 0.03782639f, 0.13108493f, 0.02212453f, 0.08325121f, 0.04964417f, 
    0.02301693f, 0.07181326f, 0.09963880f, 0.06028148f, 0.15775082f, 0.42424831f, -0.12541381f, -0.06882013f, 
    0.11879507f, -0.03206564f, 0.09252823f, 0.08914788f, 0.10646898f, -0.03934466f, 0.28677386f, 0.06272490f, 
    0.14066111f, 0.09896509f, 0.00900267f, -0.06528603f, 0.17450565f, 0.06741599f, -0.10758218f, 0.27541453f, 
    -0.12573256f, -0.07164561f, -0.11186725f, -0.02204475f, 0.00665047f, 0.13682689f, 0.19503719f, 0.10445087f, 
    0.22889207f, 0.17821364f, -0.09594367f, -0.02181565f, -0.04740170f, 0.01502584f, -0.07242092f, -0.07176333f, 
    0.11892486f, -0.10170963f, -0.08346357f, 0.01636401f, 0.03826052f, 0.01979113f, 0.03397211f, 0.05051080f, 
    0.07580498f, 0.13017835f, 0.04938827f, -0.25234881f, -0.32148418f, 0.12627475f, -0.02370603f, 0.13408121f, 
    0.03866933f, 0.11238777f, 0.08302090f, -0.23666999f, -0.21679898f, -0.28623879f, -0.09612989f, 0.05667119f, 
    0.03142958f, 0.14177679f, 0.04151433f, 0.05829459f, -0.47944629f, -0.36598292f, -0.38880616f, -0.04970797f, 
    -0.09770788f, 0.05134036f, 0.08037035f, -0.06237137f, -0.13955580f, 0.22919649f, -0.03739638f, 0.02177190f, 
    -0.09110478f, -0.10187822f, -0.01026416f, 0.12263718f, 0.09427024f, 0.02810350f, -0.04710929f, -0.15821680f, 
    -0.04517305f, 0.09037749f, -0.00543741f, 0.06030802f, 0.00656395f, 0.11632210f, -0.04334610f, -0.05641194f, 
    -0.02203022f, 0.02045493f, 0.14391141f, 0.09940128f, -0.03091840f, 0.05602794f, 0.08252409f, 0.09257597f, 
    0.25095615f, 0.05280860f, 0.25104570f, 0.18073989f, 0.01107652f, -0.02648750f, 0.00231554f, 0.09907938f, 
    0.11757317f, -0.03283489f, -0.07878891f, -0.16195430f, 0.12546605f, 0.12954903f, 0.11782651f, 0.08290797f, 
    -0.00612842f, -0.09313176f, 0.17743763f, -0.47079200f, -0.63129693f, -0.00708077f, -0.12419048f, 0.05639275f, 
    0.06015409f, -0.13029639f, -0.03218680f, 0.05907050f, -0.08421093f, -0.29534602f, -0.02770617f, -0.03699168f, 
    -0.09570803f, -0.14328042f, 0.06145573f, -0.06943410f, -0.37091348f, -0.29294905f, -0.25895837f, -0.27348521f, 
    -0.15715577f, -0.04396759f, 0.14023411f, 0.06063505f, -0.00329616f, -0.38844103f, 0.01168017f, 0.01580114f, 
    -0.07514565f, -0.00794115f, -0.02950136f, -0.01930815f, 0.00777622f, 0.16771255f, 0.04636100f, -0.01538922f, 
    -0.23638640f, -0.19997680f, -0.00450094f, -0.01469181f, 0.10851748f, -0.06244021f, -0.03530650f, 0.22719736f, 
    -0.19747648f, -0.08703634f, -0.01384970f, -0.02973929f, 0.03843821f, 0.10895992f, 0.19782974f, 0.07398916f, 
    -0.10802283f, -0.21153191f, -0.17815366f, -0.11354109f, 0.05140556f, -0.10113039f, 0.00766680f, 0.12475757f, 
    0.05363880f, 0.19631097f, 0.10350217f, 0.14233819f, -0.08506346f, -0.17043406f, -0.11913760f, 0.11864040f, 
    0.08696459f, 0.29187685f, 0.27430505f, 0.03274334f, 0.02512886f, -0.01576643f, -0.12591255f, -0.06924314f, 
    -0.05147574f, 0.05238136f, 0.08169762f, -0.08766765f, -0.29169145f, 0.15447213f, -0.06643684f, -0.05859886f, 
    -0.25786200f, 0.02919709f, -0.02381304f, 0.06531790f, -0.55954593f, -0.46785155f, 0.22402728f, -0.03608911f, 
    0.11330263f, 0.12069966f, -0.04563040f, -0.11622558f, -0.03805959f, -0.07191436f, -0.08748613f, -0.10903303f, 
    -0.07161297f, -0.04981775f, -0.16596276f, 0.03374591f, 0.03962318f, 0.04019476f, -0.02699470f, -0.04827106f, 
    -0.15376645f, -0.20564187f, -0.23815791f, 0.00092964f, 0.13029729f, -0.07676131f, 0.00746354f, -0.14287329f, 
    -0.03821911f, -0.05130957f, 0.02840250f, -0.02800791f, 0.15230553f, 0.14453122f, -0.04483747f, 0.12120821f, 
    0.05005048f, -0.04647961f, 0.00610214f, -0.03926992f, -0.03610864f, 0.02025641f, -0.02775859f, -0.02290804f, 
    -0.00456993f, -0.01939329f, -0.05528187f, 0.04495874f, -0.03948618f, 0.01295126f, -0.03927947f, 0.04639854f, 
    0.00925693f, -0.01356257f, -0.05048107f, 0.00464898f, -0.05413792f, -0.04783709f, 0.02310954f, 0.01247269f, 
    0.01649442f, -0.01052466f, 0.05538258f, -0.02924013f, 0.05111849f, 0.03320271f, -0.02455120f, -0.00859743f, 
    0.01860780f, -0.00312213f, -0.04919578f, -0.01039896f, -0.02735446f, -0.03115132f, -0.04023520f, -0.04982598f, 
    0.04127032f, -0.00331894f, -0.03924553f, -0.03025892f, -0.04315889f, 0.01841783f, -0.05523732f, -0.02808680f, 
    -0.02140671f, 0.01349867f, 0.03680938f, -0.02090940f, -0.03418039f, -0.01308555f, 0.00864765f, -0.01738470f, 
    -0.03644400f, 0.04057711f, 0.03299964f, 0.04151214f, 0.04527765f, -0.05509452f, -0.01741967f, -0.01589669f, 
    -0.01815120f, -0.01356651f, 0.03419391f, -0.04433180f, 0.03803532f, 0.02849012f, -0.02710911f, 0.01321631f, 
    -0.03459836f, -0.02315461f, -0.05031855f, -0.04393269f, -0.06473955f, -0.04996372f, -0.03466287f, -0.02062351f, 
    -0.05000616f, -0.03025270f, -0.04017795f, -0.06170076f, 0.00473269f, -0.00767122f, -0.02401957f, -0.06056266f, 
    -0.02963986f, 0.04842922f, 0.05132539f, 0.00848622f, -0.06050991f, 0.05270339f, -0.02507626f, 0.01121258f, 
    0.04971105f, 0.01179755f, -0.02029084f, 0.03918016f, 0.04336946f, -0.05810700f, 0.04055380f, -0.05233144f, 
    0.03353000f, -0.02562613f, 0.02132051f, 0.00798607f, -0.00357654f, 0.01323427f, 0.05481900f, -0.04550679f, 
    -0.04077616f, -0.06109942f, -0.00711633f, 0.03117472f, 0.04001059f, 0.03529769f, -0.01078316f, -0.00942068f, 
    -0.00132252f, -0.00961721f, -0.03616189f, 0.01745195f, -0.02548516f, -0.05671347f, 0.03601786f, 0.00724179f, 
    -0.04753925f, 0.04097772f, 0.02928794f, -0.04358795f, 0.04414210f, -0.01352034f, 0.00461544f, 0.04010673f, 
    -0.05691965f, -0.03925338f, -0.06061395f, 0.02786504f, -0.00147818f, 0.01309745f, -0.03352646f, -0.05122717f, 
    0.04813331f, 0.01732281f, 0.01416447f, -0.00850289f, -0.02296234f, 0.02805275f, -0.03111086f, 0.01655484f, 
    -0.03159360f, -0.03273376f, 0.03978835f, -0.04627448f, -0.01486224f, 0.05071108f, 0.02448012f, -0.04814949f, 
    0.02370458f, -0.05799080f, -0.02943802f, -0.02000960f, 0.03602029f, 0.02956647f, -0.03691709f, 0.01610071f, 
    -0.01561268f, -0.02555830f, 0.03756165f, 0.01945187f, -0.05182301f, -0.04633377f, -0.04424679f, -0.04706790f, 
    -0.05854022f, 0.05045431f, 0.01621500f, -0.01664572f, 0.03936812f, 0.05703073f, 0.05606974f, -0.05305802f, 
    -0.05774242f, 0.05609231f, 0.00824030f, 0.05095651f, -0.00131512f, -0.03406968f, -0.03966378f, 0.03588267f, 
    -0.03491925f, -0.01914663f, -0.00524340f, -0.01429715f, -0.03148517f, -0.01339451f, 0.04576927f, 0.04097804f, 
    0.04382510f, 0.04384591f, -0.03787600f, -0.04985417f, -0.04123716f, 0.03022446f, 0.02235596f, -0.06014127f, 
    -0.01848140f, 0.03382437f, -0.06239452f, 0.03082676f, -0.01769953f, -0.05543348f, 0.02630062f, 0.02904047f, 
    0.01683923f, 0.03919291f, -0.02381283f, -0.03382377f, -0.06080385f, -0.02191255f, 0.03646803f, -0.05724292f, 
    0.01305845f, 0.02615542f, -0.01643210f, 0.04781454f, -0.02092208f, 0.01118578f, 0.01121777f, 0.04900712f, 
    0.04336527f, -0.00498259f, 0.04510755f, 0.00246490f, 0.01595138f, -0.00286584f, 0.00943742f, 0.04626053f, 
    0.04730341f, -0.05313550f, 0.02478297f, -0.04957563f, 0.05503280f, -0.00734863f, -0.03591041f, 0.00366287f, 
    -0.05544723f, 0.05515627f, 0.01215624f, 0.04394613f, 0.03840734f, -0.03481264f, -0.00598997f, -0.03131372f, 
    -0.03025616f, -0.06191599f, -0.02532576f, 0.00390486f, 0.01089105f, 0.01359170f, 0.00511644f, 0.01358436f, 
    0.02935517f, -0.01905465f, -0.01821133f, -0.05639862f, -0.02050684f, 0.01955631f, 0.01317419f, 0.04121342f, 
    0.01331045f, 0.02484674f, 0.02404567f, 0.02238544f, -0.03353150f, -0.01963896f, -0.01501181f, -0.05798319f, 
    -0.06318329f, -0.00263105f, -0.04452423f, 0.02992856f, -0.03493292f, -0.06212057f, 0.02590029f, 0.03708169f, 
    -0.01386577f, 0.08726130f, 0.01103582f, -0.02551569f, -0.02323064f, -0.08180349f, 0.00636870f, -0.09979539f, 
    0.07419471f, -0.11504792f, 0.12976956f, 0.04154442f, -0.02156799f, -0.19185229f, -0.09893974f, -0.05263935f, 
    -0.04761676f, -0.04556939f, -0.26796469f, 0.02053784f, -0.12116366f, -0.00780925f, -0.12673846f, -0.25481352f, 
    0.02489156f, -0.13548899f, -0.13321978f, 0.07402920f, 0.11327463f, -0.11098886f, 0.25246799f, -0.00624053f, 
    -0.15672684f, -0.01698572f, -0.00976430f, 0.06766508f, 0.00326583f, -0.04986695f, 0.11373557f, 0.06848547f, 
    -0.04339667f, 0.01963733f, 0.11835507f, 0.03943739f, -0.12433581f, -0.12953606f, 0.00047109f, 0.09910318f, 
    0.06787924f, -0.18886806f, -0.05053780f, -0.00071412f, 0.05340173f, 0.20136413f, 0.08931537f, -0.00975548f, 
    0.29494008f, 0.06749695f, -0.00228301f, -0.12674935f, -0.04185978f, 0.09313687f, 0.17488748f, -0.28654316f, 
    -0.03949142f, -0.04234024f, 0.09750392f, -0.06783404f, -0.13913701f, -0.01665709f, 0.10363672f, 0.08014097f, 
    -0.07957414f, 0.00594740f, -0.11590115f, 0.08778668f, -0.04578346f, -0.17902252f, -0.00592596f, 0.08289163f, 
    0.13482936f, 0.03986690f, 0.02812397f, 0.06677723f, 0.14653657f, -0.04568364f, -0.10191960f, -0.01959468f, 
    -0.12171609f, -0.13114333f, 0.15505761f, 0.11886831f, -0.01629247f, -0.11736288f, -0.03162469f, 0.01022275f, 
    -0.07096605f, 0.02818324f, -0.04104256f, 0.06387375f, 0.20355789f, -0.04392208f, -0.45875624f, -0.08125077f, 
    0.09780588f, -0.02494286f, 0.18379089f, 0.03571363f, 0.24542259f, 0.23300800f, 0.02256319f, 0.00280688f, 
    0.12840152f, 0.15293124f, 0.03480610f, 0.06976687f, 0.10856780f, -0.20479016f, 0.06089975f, -0.07280883f, 
    0.03387527f, -0.05658938f, -0.05494694f, -0.10250821f, 0.16583595f, 0.10134626f, -0.03970128f, -0.11723716f, 
    -0.09504283f, 0.09401038f, 0.05328508f, -0.03201423f, 0.14963624f, -0.11824289f, 0.03163470f, -0.03163910f, 
    -0.13696575f, -0.03154874f, 0.03863170f, 0.07143126f, -0.04088480f, 0.01204690f, 0.02970710f, 0.24246371f, 
    0.00259147f, -0.10478617f, -0.04262720f, 0.07057651f, -0.02323860f, 0.09784818f, 0.14135754f, 0.06348796f, 
    -0.05151304f, 0.11334633f, 0.27027261f, 0.13600791f, -0.07079580f, -0.02969646f, 0.07501980f, 0.09604254f, 
    0.15369643f, -0.00337410f, 0.26347855f, 0.34594065f, 0.19609407f, -0.07957919f, -0.12954055f, 0.02902805f, 
    0.08223410f, 0.09501837f, 0.04535972f, 0.03139308f, 0.11515713f, -0.05411960f, -0.61671519f, -0.38922203f, 
    0.02370213f, -0.02492289f, 0.08920064f, -0.11404861f, 0.19343796f, -0.05449777f, 0.07642935f, -0.06696548f, 
    -0.15210371f, 0.09844046f, -0.00102231f, 0.01404152f, 0.02999791f, 0.03827464f, -0.03900290f, 0.13766152f, 
    0.16129369f, -0.12422259f, -0.11014850f, 0.22004633f, 0.04274569f, -0.11549070f, -0.01351685f, -0.07982544f, 
    -0.00678832f, -0.16236268f, -0.11152554f, -0.09557246f, 0.06965718f, 0.09283438f, 0.10925603f, -0.21503298f, 
    -0.17731962f, 0.20675592f, -0.01233018f, -0.11706156f, -0.13414876f, 0.05821002f, 0.18463407f, 0.05927604f, 
    -0.22633050f, -0.23216929f, -0.10331899f, 0.11963569f, -0.09253988f, 0.01603576f, 0.07003587f, -0.07971953f, 
    -0.05679741f, -0.12028437f, -0.09045915f, 0.06066203f, 0.06216926f, -0.07348990f, -0.11543322f, -0.20984115f, 
    0.05527927f, 0.12358981f, -0.09564823f, -0.02187837f, -0.14475629f, -0.05864482f, -0.15079057f, 0.04466111f, 
    -0.18284243f, -0.09057663f, -0.18675290f, -0.28597450f, -0.24036929f, -0.30616340f, 0.01520623f, -0.18278927f, 
    0.00940837f, 0.06554492f, -0.06929963f, -0.01169665f, -0.05813318f, 0.06541209f, 0.08242753f, 0.18366803f, 
    -0.03640333f, -0.15674879f, 0.02850668f, -0.05906572f, 0.04930205f, 0.19653206f, 0.13717473f, 0.30787194f, 
    -0.05605472f, -0.00467783f, -0.14004478f, 0.02116985f, 0.02141771f, -0.27631971f, 0.13546246f, 0.33819300f, 
    -0.09291900f, 0.07975390f, -0.04591543f, 0.21877815f, 0.02502927f, 0.09397366f, -0.08800387f, -0.06966691f, 
    0.04784248f, -0.11347567f, -0.15986955f, 0.23651589f, 0.01583645f, -0.10654229f, 0.04604682f, 0.12573646f, 
    0.28491455f, -0.10916618f, 0.11577823f, 0.01334154f, 0.02348978f, 0.01211640f, -0.03088873f, 0.02829917f, 
    -0.01667267f, 0.40993956f, -0.33643159f, -0.03378669f, 0.03174575f, -0.00853206f, 0.13558899f, -0.01857347f, 
    -0.03300187f, 0.03873476f, 0.18019088f, 0.06855214f, 0.05055664f, -0.02203665f, 0.05960307f, 0.04362489f, 
    0.01286405f, -0.09959849f, 0.08833718f, 0.38171685f, 0.19557226f, -0.39627412f, 0.04805148f, -0.08821365f, 
    0.05068927f, 0.03660448f, 0.05633496f, -0.05159674f, -0.11589169f, -0.39680299f, 0.08271055f, 0.00358937f, 
    -0.04093882f, 0.03821235f, -0.02977485f, 0.04759847f, -0.10822387f, -0.13218126f, -0.32684529f, 0.32350731f, 
    -0.07272926f, 0.07083103f, 0.08181387f, -0.02154336f, 0.15644933f, 0.05044162f, -0.54833394f, -0.21405816f, 
    0.12883887f, 0.00780317f, -0.10083364f, -0.12192693f, 0.06110677f, 0.19390099f, -0.06886984f, -0.13482259f, 
    -0.15922059f, 0.16272041f, -0.17934741f, -0.05231846f, -0.04047507f, 0.04309474f, 0.09147234f, -0.03081800f, 
    -0.19641064f, -0.13564332f, -0.00610682f, 0.03844411f, 0.12484607f, -0.06974545f, -0.04404123f, 0.00309578f, 
    0.08615859f, 0.00041053f, 0.08526327f, -0.39562449f, -0.16202694f, -0.19949837f, 0.04797525f, 0.01828124f, 
    -0.00676059f, -0.10119427f, 0.34812567f, 0.11434075f, 0.13401037f, 0.09523471f, -0.03346597f, 0.08519682f, 
    0.09597772f, 0.02506571f, -0.05784419f, 0.15654960f, 0.06875559f, -0.26181179f, 0.00313591f, -0.15679646f, 
    -0.04041092f, 0.00238679f, 0.03120814f, -0.00822161f, -0.17732263f, 0.27321389f, -0.29399553f, -0.19036333f, 
    0.08993209f, -0.05502391f, 0.20507750f, 0.03592878f, -0.07315974f, 0.09316714f, -0.40365860f, -0.18119024f, 
    -0.11763105f, -0.06489752f, -0.07982308f, 0.07419381f, 0.08806605f, -0.08392132f, 0.17578578f, 0.18265148f, 
    -0.19972199f, 0.00283934f, -0.10289966f, 0.01439406f, 0.01643735f, 0.07176400f, 0.02586593f, -0.43939677f, 
    0.07153498f, -0.10271499f, -0.15867580f, 0.06115774f, -0.02211619f, 0.00352567f, -0.03054002f, -0.20068839f, 
    -0.54102004f, -0.21063370f, 0.19035159f, 0.01079580f, -0.11887582f, 0.00228518f, 0.18015996f, 0.00856423f, 
    -0.02588442f, 0.17071374f, 0.05561450f, -0.07913297f, -0.00284299f, -0.11256632f, 0.06966092f, 0.01982430f, 
    -0.00089519f, -0.04788126f, -0.47122064f, 0.09470439f, 0.25971371f, -0.08407868f, 0.07953146f, -0.09587781f, 
    0.17109229f, 0.17406695f, 0.03042679f, 0.02629310f, 0.21828385f, -0.14024447f, -0.03525382f, -0.01996881f, 
    -0.25733605f, 0.05939085f, -0.07402059f, -0.11755225f, -0.01912887f, 0.13954474f, 0.30206856f, -0.06293248f, 
    -0.16319950f, 0.14295392f, 0.09603811f, 0.03877503f, -0.18803492f, -0.12249593f, -0.16284208f, -0.23310407f, 
    -0.10961556f, -0.22073171f, -0.00291879f, 0.13271990f, 0.05331863f, -0.02589586f, -0.15983689f, -0.33938739f, 
    -0.05664772f, -0.00838331f, 0.19216190f, 0.07887427f, 0.06165655f, 0.02552968f, 0.12989344f, -0.08482286f, 
    -0.06165840f, 0.01020668f, -0.02042920f, 0.06868127f, 0.00555200f, -0.05235425f, 0.02894155f, -0.14087284f, 
    0.24069512f, 0.20400873f, 0.10753960f, -0.14872515f, 0.12702221f, -0.15999603f, 0.04353885f, 0.16623896f, 
    -0.03380521f, -0.01724366f, -0.27747187f, 0.13812505f, -0.09371520f, 0.14400904f, -0.20825408f, -0.02674815f, 
    0.03770854f, 0.09079153f, 0.10914365f, -0.11757063f, 0.27095634f, 0.04298193f, -0.05850321f, -0.13411669f, 
    0.11213299f, -0.06983415f, -0.20796652f, 0.38816494f, 0.35146111f, 0.06851989f, 0.00042595f, 0.04933634f, 
    -0.23332004f, 0.04928029f, 0.02047155f, -0.01269666f, 0.27725899f, -0.21565470f, 0.06887876f, -0.15537520f, 
    0.01368547f, -0.00763899f, 0.03536573f, 0.00832921f, 0.06265685f, 0.08078483f, 0.11145283f, 0.10478898f, 
    0.03804593f, 0.00569212f, -0.03567364f, -0.01337482f, 0.00274579f, -0.06683761f, -0.09461638f, 0.15179570f, 
    0.09583208f, -0.19992739f, -0.00409461f, 0.08805965f, -0.03800587f, 0.05054286f, -0.03040524f, 0.11734428f, 
    -0.11057395f, -0.15647995f, -0.04962405f, 0.13684303f, -0.05915466f, 0.05698321f, -0.07532857f, 0.11188886f, 
    -0.09173140f, 0.00406634f, 0.08651791f, -0.06722435f, -0.08049931f, -0.13225062f, -0.02015917f, -0.09271978f, 
    -0.00991082f, -0.03644991f, -0.22933145f, 0.09752797f, -0.14014046f, 0.04165258f, -0.10370896f, -0.14348266f, 
    -0.09715593f, -0.04705864f, -0.26005229f, -0.10191618f, 0.04861320f, 0.00649213f, 0.01638926f, 0.00679879f, 
    -0.12623577f, -0.20987840f, -0.26339427f, -0.02227767f, -0.17226678f, -0.33794299f, -0.04015813f, 0.01813428f, 
    0.07756347f, -0.01959931f, -0.11131237f, -0.00081049f, 0.01387123f, 0.03893282f, -0.11866901f, 0.05619660f, 
    -0.08476907f, 0.04656084f, -0.14347874f, -0.15103027f, -0.24372590f, 0.03735450f, 0.18899477f, 0.10445333f, 
    0.26451507f, 0.07924409f, 0.08538700f, -0.06008648f, -0.03016931f, -0.04039625f, 0.14184357f, 0.15070753f, 
    0.22473501f, 0.08610812f, 0.04702049f, -0.01728148f, -0.00227588f, -0.09111640f, 0.13688663f, 0.09859163f, 
    0.13096900f, 0.09000837f, 0.21137980f, 0.10182294f, -0.12629342f, 0.08983988f, 0.11396527f, 0.02803691f, 
    0.12327149f, 0.00604193f, 0.08966931f, 0.11759855f, 0.15872404f, 0.00216686f, -0.01603155f, -0.02889482f, 
    0.10475650f, -0.10275251f, -0.05797691f, -0.04602142f, 0.05460392f, 0.05586299f, 0.03199730f, -0.04347095f, 
    -0.10406746f, -0.17356215f, -0.19134727f, 0.19661704f, -0.00132568f, -0.08088498f, 0.03948642f, 0.21525368f, 
    -0.02735971f, 0.02717511f, -0.04621131f, 0.03655669f, -0.13774206f, -0.07622050f, 0.06273890f, -0.00718139f, 
    0.06171983f, 0.09803941f, 0.19688079f, 0.06720035f, -0.22593211f, 0.00519627f, 0.18755749f, 0.01228117f, 
    0.06580274f, -0.02298090f, 0.03968192f, -0.04795716f, 0.05401264f, 0.07686212f, 0.17618993f, 0.12124135f, 
    0.12250016f, 0.17443068f, -0.08555419f, 0.16337392f, 0.02832585f, 0.02910508f, 0.01133262f, -0.07963313f, 
    0.25316164f, -0.02273869f, -0.04894168f, -0.03600530f, 0.13828909f, 0.13259536f, 0.10487679f, 0.03704602f, 
    -0.10340485f, 0.22326158f, 0.11499546f, 0.08015095f, 0.06042910f, 0.06759681f, -0.07544310f, 0.00858003f, 
    0.04643094f, -0.01508878f, 0.05050378f, -0.00299005f, -0.00450337f, -0.06353173f, -0.00666195f, -0.03515593f, 
    -0.08689162f, -0.03100906f, -0.13800481f, 0.12071865f, -0.04230985f, -0.06605117f, 0.04124039f, 0.12658782f, 
    0.10814887f, -0.01162042f, 0.03229323f, -0.12061140f, -0.05777973f, 0.03059172f, 0.00332535f, 0.09145541f, 
    -0.02205531f, 0.02695017f, 0.07570750f, 0.06591049f, -0.06092096f, -0.23991810f, 0.05700075f, -0.02123925f, 
    -0.02915304f, 0.00064442f, 0.04007274f, -0.03962115f, -0.08853355f, 0.02419459f, -0.13422321f, 0.13078672f, 
    -0.05773192f, 0.01183294f, -0.01793109f, 0.07511342f, -0.02632759f, -0.12915790f, -0.05261454f, -0.08591519f, 
    0.08202563f, -0.00563954f, -0.03328089f, -0.13732471f, -0.14474727f, -0.14899747f, 0.11917295f, 0.02522689f, 
    -0.09832893f, 0.20704842f, 0.02124501f, 0.05255623f, 0.03872754f, -0.06137035f, 0.06730779f, 0.14594200f, 
    0.14045389f, 0.09123921f, 0.16182415f, 0.04976068f, 0.11923228f, -0.19089650f, 0.02185964f, -0.03706486f, 
    0.00422617f, 0.01169839f, -0.18046507f, -0.11247608f, -0.01994104f, 0.02316725f, 0.14501721f, 0.20383221f, 
    0.04484294f, 0.08175173f, 0.02055117f, 0.15181182f, 0.07531338f, -0.00921803f, 0.06278808f, -0.08890065f, 
    0.08280561f, 0.14700668f, 0.06112048f, 0.00351346f, 0.17820469f, -0.06846300f, 0.00142709f, -0.11638296f, 
    -0.04598051f, 0.01095866f, -0.09800023f, -0.13309199f, 0.14138296f, -0.21308112f, -0.04263438f, 0.09525210f, 
    -0.00754128f, 0.08274131f, 0.23556659f, 0.04459155f, -0.16020109f, 0.10998327f, 0.04636756f, -0.06343455f, 
    0.01027367f, -0.07776506f, -0.09520268f, -0.18103717f, -0.01427779f, 0.05317546f, -0.19467448f, 0.08724231f, 
    0.01388004f, 0.06308154f, -0.08681949f, 0.03616029f, 0.18408878f, 0.08831588f, -0.24491081f, -0.04584825f, 
    0.00877247f, -0.07278630f, -0.00882977f, 0.00441918f, 0.06232042f, 0.01966282f, 0.04270505f, 0.02411740f, 
    0.04159615f, 0.01073694f, -0.09922656f, 0.11860417f, -0.01487398f, 0.14881025f, 0.11944227f, -0.03857583f, 
    0.08693381f, 0.06962447f, 0.04410946f, 0.06842556f, -0.07858448f, -0.02043587f, 0.04031625f, -0.06856110f, 
    -0.02679735f, -0.18825875f, 0.34304333f, 0.17380576f, -0.04322335f, -0.29648244f, 0.09325108f, 0.00390298f, 
    -0.02667923f, -0.01776033f, -0.02596657f, -0.03584697f, 0.12145624f, 0.06150558f, -0.01004515f, -0.03689013f, 
    0.08086205f, 0.01801525f, -0.11144497f, 0.12576659f, 0.10479163f, 0.33338249f, 0.00095079f, -0.06757967f, 
    0.00401238f, 0.06144977f, 0.03558034f, 0.18131180f, -0.35205549f, -0.07290708f, -0.15775304f, -0.05026594f, 
    0.10867316f, 0.10748323f, -0.04614273f, 0.15913525f, -0.00221543f, -0.29658854f, -0.12480070f, -0.25604394f, 
    0.07204323f, 0.01125195f, 0.07888483f, -0.02544599f, 0.12421605f, -0.05137422f, -0.32470417f, -0.02475266f, 
    -0.21423960f, 0.00967058f, 0.00449270f, -0.02170607f, -0.11752567f, 0.08214523f, 0.03626532f, 0.06676606f, 
    -0.06760762f, 0.08499947f, -0.00097275f, -0.03159602f, 0.00572695f, -0.08793472f, 0.08279657f, 0.17434135f, 
    -0.15867850f, -0.02751832f, -0.12518628f, -0.08996980f, 0.03321779f, -0.02677708f, 0.05414009f, -0.02896480f, 
    0.01437145f, -0.35858712f, -0.23351093f, 0.09314455f, -0.07560302f, 0.13107888f, 0.06491002f, -0.01807175f, 
    -0.00055223f, -0.00594372f, -0.17159858f, -0.28761348f, -0.08073101f, -0.05611797f, 0.13802251f, -0.03386259f, 
    0.05226545f, 0.08012589f, -0.07622187f, -0.08667195f, 0.02990573f, 0.05023779f, 0.05067505f, 0.01345227f, 
    -0.03865661f, 0.00284873f, 0.04333235f, 0.05229577f, 0.10663913f, -0.15813063f, 0.11123867f, -0.01404600f, 
    -0.00269754f, -0.06990661f, -0.25342438f, 0.02483536f, -0.06985808f, -0.03207523f, -0.18860252f, 0.08417048f, 
    0.05226057f, -0.06293736f, -0.01086125f, -0.14043884f, 0.06522948f, -0.07119405f, 0.03827807f, 0.05979130f, 
    0.03047558f, -0.02566792f, -0.03322034f, -0.00911395f, 0.08149455f, 0.13349517f, 0.06686720f, -0.29609922f, 
    -0.17989919f, -0.28172055f, 0.10405544f, 0.00965236f, -0.05517659f, 0.06752318f, 0.13242713f, -0.01835919f, 
    -0.02088951f, -0.11924811f, 0.10702851f, 0.00473272f, -0.00222772f, -0.01820328f, -0.02567128f, 0.05306300f, 
    0.10446955f, 0.09509248f, 0.11119191f, 0.03648911f, 0.10366742f, 0.03765066f, 0.07099072f, 0.03768305f, 
    0.08844905f, 0.01458677f, -0.12316306f, -0.06701282f, 0.00246510f, -0.10763708f, 0.08675992f, -0.15237328f, 
    -0.21331196f, 0.01065279f, 0.11777601f, 0.03904913f, -0.01516845f, -0.00395913f, 0.00955552f, -0.03887259f, 
    0.02796527f, -0.03541156f, -0.06016767f, 0.08096354f, 0.14026606f, 0.06459315f, 0.12541555f, -0.05055910f, 
    0.11510742f, -0.25472057f, -0.00317137f, -0.10588977f, 0.03583608f, -0.19397302f, -0.15006202f, 0.00114471f, 
    0.09383351f, -0.00972637f, 0.15356542f, 0.07642756f, 0.02443294f, 0.07620734f, -0.04574098f, -0.03737663f, 
    -0.16726388f, -0.00808493f, -0.02082469f, -0.04401699f, 0.19961643f, 0.19299746f, -0.12589693f, -0.11553393f, 
    0.07644710f, -0.18900488f, -0.05527794f, -0.07396442f, -0.09995792f, -0.07505685f, 0.08722031f, 0.21022804f, 
    0.18578681f, 0.15574966f, 0.28126583f, -0.08813442f, 0.07272364f, 0.08282817f, -0.02076869f, -0.04729778f, 
    -0.04262882f, -0.13735226f, 0.17281246f, -0.10608687f, -0.06316754f, 0.12021296f, -0.07768725f, -0.03209553f, 
    0.21342729f, -0.06258129f, -0.46039054f, -0.33585858f, 0.15346709f, 0.09543732f, -0.07578265f, 0.04325186f, 
    0.01860781f, -0.09630246f, -0.09070873f, 0.22335489f, 0.22672850f, 0.31052738f, -0.01657590f, 0.15152219f, 
    0.00713350f, 0.02165403f, -0.01162289f, 0.04317987f, -0.20567113f, 0.15864955f, 0.41450179f, -0.02377632f, 
    -0.02837892f, -0.01350232f, -0.03097415f, -0.06842493f, -0.09795182f, 0.09460731f, 0.21620418f, -0.16127801f, 
    0.12692547f, 0.07798735f, -0.01782292f, -0.07194534f, 0.02116837f, -0.05185982f, 0.14879034f, -0.07398546f, 
    0.09456421f, 0.10057738f, 0.04733519f, 0.00818668f, -0.03713606f, -0.04942331f, 0.01270052f, -0.02163193f, 
    -0.12363440f, 0.02698519f, 0.02401947f, -0.02883190f, 0.16584189f, 0.24513306f, 0.17912266f, 0.10129359f, 
    0.12365322f, -0.12963550f, -0.06601293f, 0.02758297f, 0.01776203f, 0.06727871f, -0.02663122f, -0.10254479f, 
    -0.03419106f, 0.10561102f, -0.06756268f, -0.19524403f, 0.05280203f, 0.03871287f, 0.18207157f, -0.03355621f, 
    0.05600231f, -0.04878036f, -0.08832985f, -0.04696092f, -0.10180013f, 0.00412737f, 0.05149825f, 0.05144820f, 
    0.06882902f, -0.11360847f, -0.18606418f, 0.06473909f, -0.05055949f, -0.13305783f, 0.17333558f, -0.04261625f, 
    -0.18039812f, 0.00835727f, 0.06665019f, 0.04169090f, -0.08748545f, 0.02618755f, -0.01947401f, 0.02279489f, 
    0.04504448f, -0.02336101f, -0.31698626f, -0.16732927f, -0.05224916f, -0.18123946f, 0.00436718f, -0.00345276f, 
    -0.00756865f, 0.02638388f, 0.03228391f, -0.00603678f, -0.03726552f, 0.10243852f, -0.07117491f, 0.02310671f, 
    0.24043396f, 0.02011467f, 0.11753494f, 0.04522578f, 0.06538835f, -0.05388381f, 0.21565884f, 0.04252249f, 
    0.12853833f, 0.02898409f, 0.00440839f, -0.02264988f, -0.04254712f, -0.01703141f, 0.10282284f, 0.02477169f, 
    -0.24253534f, -0.03174703f, 0.09017936f, -0.11154722f, 0.00288807f, -0.00558401f, 0.12029418f, 0.12137423f, 
    0.08779574f, -0.12590703f, -0.01813203f, -0.16524754f, 0.07721455f, 0.08378821f, 0.10800049f, -0.25886479f, 
    -0.39002800f, -0.17877352f, 0.13208161f, 0.12885594f, 0.00572977f, 0.01355567f, 0.02399471f, -0.03530254f, 
    -0.12540059f, 0.02182055f, -0.10340150f, 0.00471016f, 0.07720160f, 0.10178687f, 0.06677526f, 0.10308076f, 
    -0.06904008f, 0.00970965f, 0.18707338f, 0.05927508f, 0.13513891f, 0.34792256f, 0.03987023f, 0.05622526f, 
    0.03260619f, -0.02329781f, -0.10771956f, 0.15759675f, -0.06057023f, -0.18390985f, 0.06327908f, 0.00949195f, 
    0.04420434f, 0.11873434f, -0.03057811f, -0.04127046f, 0.05887971f, 0.11232115f, 0.06492593f, 0.13422701f, 
    0.02988521f, -0.08878137f, 0.08342879f, -0.02252958f, 0.13253535f, -0.10415801f, 0.10651157f, -0.24491432f, 
    -0.11528245f, -0.12904856f, 0.11146963f, 0.04409615f, -0.01956347f, 0.07947361f, -0.07349867f, -0.00121789f, 
    0.06526740f, -0.05697861f, -0.12095058f, 0.05858072f, 0.08378839f, -0.08745486f, -0.23836778f, 0.09106749f, 
    -0.18840382f, -0.05056147f, 0.16840984f, 0.18304850f, -0.10609803f, -0.10234706f, -0.19188596f, -0.00472655f, 
    0.12096838f, 0.11456562f, 0.41454560f, 0.17637514f, 0.26704082f, 0.06360517f, -0.03713928f, -0.00386921f, 
    0.02452273f, -0.01343017f, -0.06590928f, 0.04087846f, 0.08889426f, -0.04562828f, 0.05117175f, -0.01315833f, 
    0.00056419f, 0.04516415f, 0.04927838f, -0.05042082f, 0.13378417f, 0.08517319f, -0.04540625f, 0.18411598f, 
    0.00782993f, -0.10777503f, 0.01110697f, 0.11586123f, -0.11540558f, -0.10896884f, -0.14647661f, 0.00244358f, 
    0.15183888f, 0.04770444f, 0.10271841f, -0.14726499f, -0.26250815f, -0.12968035f, -0.03857265f, 0.01608515f, 
    -0.03654544f, -0.01615752f, 0.07090721f, -0.22122833f, 0.06204819f, 0.14088798f, 0.03610696f, -0.01614158f, 
    -0.04417973f, 0.14391345f, -0.06014751f, -0.21715616f, -0.14927895f, 0.08061852f, -0.07753488f, 0.12247137f, 
    0.09117393f, 0.09605618f, 0.11944951f, -0.05278534f, 0.03425790f, 0.10244403f, 0.02211992f, -0.04559750f, 
    -0.05429903f, -0.05113061f, -0.07161100f, -0.03733445f, -0.16130148f, 0.05214973f, 0.09212822f, 0.05346541f, 
    0.00296204f, -0.07948698f, -0.21956533f, -0.05959746f, 0.05720422f, 0.12108087f, 0.07550015f, 0.11574931f, 
    -0.16420808f, -0.10254204f, -0.28629181f, 0.23953483f, 0.22366399f, 0.10875580f, 0.11615046f, 0.08633824f, 
    0.18661468f, 0.13588853f, 0.01937849f, -0.08660097f, 0.03147579f, 0.09882125f, 0.01690169f, 0.13000265f, 
    -0.07429140f, 0.00908955f, -0.11985685f, -0.10407427f, 0.02499959f, 0.12089372f, 0.16418004f, 0.15953724f, 
    0.03617717f, 0.11695766f, 0.14482874f, 0.00632362f, -0.21708232f, -0.22752456f, 0.04799994f, 0.25431037f, 
    0.17504066f, 0.12138950f, 0.12712237f, 0.04165331f, -0.01019494f, 0.01351964f, -0.32263705f, -0.02134495f, 
    0.07883998f, -0.01125068f, -0.19121513f, 0.14828944f, -0.06950050f, 0.14853173f, 0.13719201f, 0.00149917f, 
    -0.00239965f, -0.06716207f, -0.07334442f, -0.00982594f, -0.05058430f, -0.05353058f, -0.00849235f, -0.05857281f, 
    -0.01216766f, -0.03121902f, -0.06897835f, -0.01311949f, -0.00469962f, -0.03806752f, 0.03945963f, 0.02529902f, 
    -0.04947582f, 0.01134555f, -0.00527170f, 0.03900822f, -0.03473397f, -0.02017828f, 0.00197516f, -0.02650674f, 
    -0.03016265f, -0.00140232f, 0.03424861f, 0.03221478f, -0.00185728f, -0.04015416f, -0.02064192f, -0.01740342f, 
    -0.02313912f, 0.01405760f, 0.04021826f, -0.00136325f, -0.02376011f, 0.02324119f, 0.03154229f, -0.00956907f, 
    0.02862314f, -0.06004207f, 0.01081034f, 0.03851931f, 0.00533865f, 0.00755774f, 0.04409555f, -0.05865962f, 
    -0.06267286f, -0.04215728f, 0.00754024f, 0.00594896f, -0.04673836f, -0.03215642f, -0.05391706f, -0.00385511f, 
    -0.00450158f, -0.06223200f, 0.03822061f, -0.04330574f, 0.00620309f, 0.01975747f, -0.03086849f, 0.02333900f, 
    -0.05425208f, 0.02951288f, -0.01018920f, -0.04866329f, -0.04809754f, -0.03248428f, -0.05556961f, 0.02329408f, 
    0.05428895f, 0.01974249f, -0.04229534f, 0.00468784f, -0.00287477f, 0.00783323f, 0.04682193f, 0.02499987f, 
    -0.01365471f, 0.02391900f, 0.03098859f, -0.02387025f, 0.04852572f, -0.00593355f, 0.01891733f, 0.00207072f, 
    -0.04155700f, 0.04391908f, -0.03213789f, 0.02404925f, -0.05557426f, 0.01521914f, -0.02625782f, 0.02781057f, 
    -0.05174316f, 0.00013542f, -0.00387191f, 0.00912347f, -0.01514551f, -0.07662081f, -0.02739143f, 0.04162809f, 
    0.03607667f, 0.02623495f, 0.01487613f, -0.00780414f, -0.00398178f, 0.03639433f, -0.07159016f, 0.00484116f, 
    0.02812292f, -0.01920455f, -0.04748987f, -0.01997715f, -0.06768440f, 0.01517422f, -0.03042551f, -0.06520993f, 
    -0.03267060f, -0.02634616f, -0.05179261f, -0.02557174f, -0.00669825f, 0.03904369f, -0.06209593f, 0.02401880f, 
    0.03098373f, 0.04916329f, 0.01990697f, -0.06246171f, 0.02606263f, 0.02511987f, -0.02818301f, -0.00776671f, 
    -0.05289627f, -0.02985226f, 0.02981934f, 0.02212752f, -0.01452037f, -0.00691158f, -0.05503135f, -0.04652841f, 
    0.02124890f, 0.01604308f, -0.04192561f, 0.00164801f, -0.03274500f, -0.05973956f, 0.00153829f, -0.01662916f, 
    0.04174497f, 0.02551459f, -0.06821925f, -0.04998156f, 0.01673583f, -0.03547223f, -0.04700564f, -0.06182478f, 
    -0.03112931f, -0.05520001f, 0.02955557f, 0.02872542f, -0.01868233f, 0.03018893f, -0.04556670f, -0.07063282f, 
    -0.01122453f, -0.06491796f, 0.00951945f, 0.04709430f, 0.00342866f, 0.02091408f, 0.03937821f, -0.05395329f, 
    0.01145856f, -0.06729683f, 0.03832309f, -0.07028911f, -0.04628835f, 0.02004774f, 0.01397547f, 0.01758629f, 
    -0.01982771f, -0.04200358f, 0.04005715f, -0.02202035f, -0.00342655f, 0.03667456f, -0.02152786f, 0.02118193f, 
    -0.03547946f, -0.02551010f, -0.07146034f, 0.01801204f, -0.06759622f, 0.00340774f, -0.04283471f, -0.01977889f, 
    -0.00900016f, 0.00580558f, -0.03733419f, -0.03804629f, 0.04481803f, -0.01000874f, -0.03702793f, 0.00959202f, 
    -0.03128414f, 0.01173176f, -0.04015227f, -0.04386790f, -0.01879992f, 0.00702201f, -0.03622844f, 0.03759756f, 
    -0.00127065f, 0.02417016f, -0.00335354f, -0.03674591f, -0.02089314f, -0.05543078f, -0.04033695f, -0.06101459f, 
    -0.04847324f, 0.01460164f, 0.03415878f, -0.05281175f, 0.02440346f, -0.04364176f, -0.06419802f, 0.01488214f, 
    0.02107374f, 0.02955312f, -0.02307628f, 0.08062980f, -0.04163932f, -0.06065107f, 0.01666192f, -0.02770451f, 
    -0.04312169f, 0.05518114f, 0.03118545f, -0.03736279f, -0.00992359f, 0.05167985f, -0.05964871f, 0.04777602f, 
    0.02150445f, 0.01003029f, 0.01548524f, 0.01709952f, 0.00497364f, 0.00755892f, -0.06559084f, -0.05925709f, 
    0.05289951f, -0.05111101f, -0.03790530f, -0.04102430f, 0.03210873f, 0.02937550f, -0.03937915f, 0.02652923f, 
    0.02256831f, 0.00509021f, 0.03716077f, 0.02785045f, -0.03746162f, 0.03420970f, 0.03475015f, 0.00812304f, 
    -0.00871321f, -0.03795972f, -0.03314484f, -0.00201887f, 0.01384222f, 0.02812169f, 0.00917190f, 0.00381844f, 
    0.04763875f, -0.00143129f, 0.04197905f, 0.04671232f, 0.00204168f, 0.02488438f, -0.01200397f, -0.04330073f, 
    -0.02035296f, -0.06043370f, -0.02722024f, 0.01868694f, 0.03701318f, 0.02315684f, 0.04985783f, -0.03984420f, 
    -0.01553940f, -0.01729180f, -0.01137922f, -0.01686772f, 0.00872599f, -0.04417358f, -0.05564641f, 0.05690951f, 
    -0.04554239f, -0.05034759f, 0.04087850f, -0.00649519f, -0.05121066f, 0.03886286f, -0.02942617f, -0.00669899f, 
    0.00901487f, 0.00632412f, -0.02662728f, 0.00344645f, -0.06031797f, 0.02627527f, -0.02855070f, 0.03527219f, 
    0.01075742f, -0.05114487f, -0.06014310f, 0.04759556f, -0.02752563f, -0.04124913f, 0.02432591f, -0.02101169f, 
    0.05119223f, -0.02200479f, -0.01670953f, -0.05293028f, 0.00485535f, 0.03983611f, 0.04879948f, -0.06039194f, 
    0.00232549f, -0.02148895f, -0.05444622f, -0.01766664f, 0.03850100f, -0.06168334f, -0.02108009f, 0.00459852f, 
    0.02003707f, -0.02739185f, 0.02203885f, -0.06331792f, -0.04754252f, 0.01105770f, -0.00536142f, -0.02990936f, 
    -0.00271027f, -0.06260337f, -0.03208961f, -0.03730254f, 0.04987118f, 0.02790045f, 0.01810711f, 0.00995737f, 
    0.00401860f, 0.03556027f, 0.00644615f, 0.04734545f, -0.03457117f, -0.03290723f, -0.00365441f, -0.03162397f, 
    -0.02797300f, -0.02780577f, -0.06315616f, -0.04988069f, 0.01066725f, 0.00009617f, -0.01037307f, 0.02176135f, 
    0.03633375f, 0.04774804f, -0.05586933f, -0.06345481f, -0.01541176f, -0.03079284f, -0.00974922f, -0.04840856f, 
    -0.05159464f, -0.00718264f, -0.05479289f, 0.01611126f, -0.00196474f, 0.04132089f, 0.00373741f, 0.04199241f, 
    -0.04470453f, -0.01055341f, -0.04498806f, -0.04546149f, -0.00561438f, 0.02719154f, -0.05355145f, 0.00669863f, 
    0.01749516f, -0.02487692f, -0.05927325f, -0.06262387f, -0.02702766f, -0.02698714f, 0.01328529f, -0.03927889f, 
    0.00543253f, -0.04306037f, -0.01037001f, 0.05266833f, 0.00604428f, 0.04204310f, 0.03241036f, -0.04829030f, 
    -0.06315537f, 0.04377425f, -0.03084948f, 0.04134671f, -0.04920769f, 0.03985290f, -0.05064569f, 0.02885677f, 
    -0.01049122f, 0.03320656f, -0.00453107f, 0.00534608f, -0.01047719f, 0.01962941f, -0.05627204f, -0.02638624f, 
    -0.00858867f, 0.04064514f, -0.01529048f, -0.05930832f, -0.04509304f, -0.02543261f, -0.05367365f, 0.04977466f, 
    -0.01305337f, -0.01989106f, -0.03878425f, 0.03535724f, -0.00239953f, -0.00004897f, -0.00590906f, 0.03498785f, 
    0.01561539f, 0.00358158f, -0.03423783f, -0.00012827f, 0.02686575f, 0.05454083f, 0.01584955f, -0.00477813f, 
    -0.05887536f, -0.02638674f, -0.01031165f, 0.04117194f, 0.00222674f, -0.05982761f, -0.04364756f, 0.04460380f, 
    -0.04962316f, -0.01056294f, -0.05887846f, -0.04507431f, 0.03171205f, 0.02715089f, -0.01818700f, 0.04607548f, 
    -0.01446662f, 0.02386701f, 0.02692063f, -0.01189679f, -0.03723586f, -0.05118673f, -0.00219840f, -0.01154189f, 
    -0.01271172f, -0.01329437f, -0.04976358f, -0.02484661f, 0.03647064f, 0.05177812f, -0.05895489f, -0.03550239f, 
    -0.05543463f, 0.01630175f, -0.03645919f, -0.00017617f, 0.01036324f, 0.04830451f, 0.01560182f, 0.03312056f, 
    0.01383533f, 0.03427401f, -0.03000535f, 0.02477932f, -0.06210218f, 0.00730309f, 0.03589451f, 0.00414092f, 
    0.02939242f, 0.01323760f, -0.04276220f, 0.03523969f, -0.05982743f, -0.06160468f, 0.01033380f, -0.02624341f, 
    -0.05014155f, 0.02170633f, 0.01177474f, -0.04196135f, -0.01934300f, -0.02245781f, 0.00509549f, 0.04234379f, 
    -0.04924987f, -0.05204759f, 0.04868415f, 0.03134679f, -0.02348830f, -0.05360948f, -0.04498792f, -0.04323725f, 
    -0.04644015f, 0.02846260f, 0.04446210f, 0.01055961f, 0.03500047f, -0.00864316f, -0.05095466f, 0.04532062f, 
    0.01834268f, 0.03572108f, -0.04473794f, -0.00264773f, 0.02719861f, -0.01812713f, -0.00148273f, -0.02243185f, 
    0.00473307f, -0.03853925f, -0.04496485f, -0.00034414f, 0.02022931f, -0.03062853f, 0.00894862f, 0.03433947f, 
    -0.00909699f, -0.05370601f, -0.04598613f, 0.03165339f, -0.02517088f, 0.02023235f, -0.06293556f, -0.00275749f, 
    -0.05384056f, 0.01244407f, -0.04327983f, 0.01696328f, 0.00816999f, 0.03168581f, 0.03306872f, -0.05729216f, 
    -0.00533827f, -0.00023653f, 0.04781721f, 0.03610108f, -0.03306898f, -0.04680093f, 0.02590379f, 0.00253554f, 
    -0.01683778f, -0.06355159f, 0.01167347f, -0.02053324f, -0.06941928f, 0.01608207f, 0.04221918f, -0.06728876f, 
    -0.04378379f, -0.07308100f, -0.01284490f, 0.00884624f, -0.02777863f, -0.00245743f, 0.03623177f, -0.05580758f, 
    -0.01492084f, 0.03804690f, -0.01827601f, -0.03936540f, -0.01812664f, 0.01307477f, 0.04627465f, -0.06091246f, 
    -0.04601041f, -0.01405763f, -0.03188504f, 0.02905259f, 0.01878028f, 0.03249506f, -0.02810906f, -0.06261779f, 
    -0.01907751f, -0.04759324f, 0.03360761f, 0.04003173f, 0.04178351f, 0.00775712f, -0.03365989f, -0.05509479f, 
    -0.05542774f, -0.04951168f, -0.02133868f, -0.00943062f, -0.05762142f, -0.01102390f, 0.02019200f, 0.03857729f, 
    -0.04612415f, 0.01063454f, -0.07192853f, 0.00433056f, -0.02862183f, 0.00460152f, -0.00381241f, -0.01636350f, 
    0.01146945f, 0.03093593f, 0.01222702f, 0.03334013f, 0.00190945f, 0.01903027f, 0.03063865f, 0.01794866f, 
    0.01613710f, -0.04770601f, -0.01988624f, -0.02541230f, -0.02280930f, -0.04364728f, -0.00578489f, -0.01951546f, 
    -0.06482651f, 0.04562993f, 0.04565676f, -0.01532975f, 0.00300251f, -0.05691519f, -0.00602186f, -0.01627150f, 
    -0.03404275f, 0.00334768f, -0.06607811f, 0.00988179f, -0.00143833f, -0.04358787f, -0.04913178f, -0.00961537f, 
    0.02848969f, 0.06520833f, -0.00729148f, 0.04194864f, -0.06210170f, -0.00655496f, 0.00918761f, -0.02568220f, 
    0.00183635f, -0.02041432f, 0.02164937f, -0.00529525f, 0.04722174f, 0.00025621f, -0.06350940f, 0.01267638f, 
    -0.00165130f, 0.03142025f, 0.00470857f, 0.01186395f, 0.04735896f, -0.05828378f, -0.00509499f, -0.03923171f, 
    -0.02755934f, -0.04795307f, -0.06246769f, -0.03918144f, -0.01738749f, 0.01134227f, -0.05276836f, -0.06352959f, 
    0.01764735f, -0.00653135f, -0.03471633f, 0.02761753f, 0.02471037f, 0.01697110f, -0.02185160f, -0.04182452f, 
    -0.02278719f, 0.02627329f, -0.06613592f, -0.06326264f, 0.03778598f, -0.04849368f, -0.03168254f, 0.02579726f, 
    -0.04505872f, 0.00876282f, -0.03918906f, -0.04748756f, 0.01946521f, -0.04227516f, -0.00298600f, -0.02969887f, 
    -0.03999980f, 0.00258783f, -0.06507389f, -0.06309846f, -0.00260626f, -0.04669431f, 0.04991007f, -0.01223105f, 
    -0.01799809f, -0.00249998f, 0.00017750f, 0.03648562f, -0.04376812f, -0.07403526f, 0.01780328f, -0.03385781f, 
    -0.00816312f, -0.01578768f, -0.04924785f, 0.01401990f, 0.02267472f, 0.01727384f, -0.01410110f, 0.00026499f, 
    -0.05292788f, 0.04679052f, -0.03434570f, -0.03469253f, -0.04267618f, -0.03798948f, 0.02895792f, 0.06634722f, 
    0.02777153f, -0.02270458f, 0.04615983f, 0.02591470f, -0.02291260f, 0.00584266f, -0.00831177f, 0.02987553f, 
    -0.04729531f, 0.03605038f, 0.02366515f, 0.04822500f, 0.00325212f, 0.03316475f, 0.00043185f, -0.00059515f, 
    -0.04041618f, 0.00553435f, 0.03592300f, -0.02219014f, -0.02494088f, -0.04891028f, 0.05068194f, 0.00101717f, 
    -0.03522395f, -0.00067483f, 0.02144306f, 0.02416183f, -0.04475880f, -0.05693701f, -0.01694982f, -0.01709658f, 
    0.04530284f, 0.02849011f, 0.06248412f, 0.02629339f, -0.00257486f, 0.01841085f, -0.04673124f, -0.02433536f, 
    0.03068513f, -0.01989488f, -0.01022778f, -0.04171314f, -0.05263163f, -0.01814854f, -0.03501772f, 0.01792051f, 
    -0.05806688f, -0.05530272f, -0.01890707f, -0.05618457f, -0.01040095f, -0.03441186f, -0.05554589f, 0.00275011f, 
    -0.02099893f, 0.01972218f, -0.01494703f, 0.00741233f, 0.02724566f, -0.06188084f, -0.02009703f, -0.04919166f, 
    -0.05146380f, -0.03243579f, -0.04458091f, -0.02019504f, 0.02870650f, -0.00444376f, -0.02303454f, 0.03756002f, 
    -0.02362862f, 0.00049712f, -0.00890410f, -0.02936375f, -0.01315775f, 0.02404572f, 0.03923128f, -0.02995124f, 
    -0.02960345f, 0.01189013f, 0.01997614f, -0.04993817f, 0.04154160f, 0.00831417f, 0.00734194f, -0.05809923f, 
    0.02161149f, 0.02536397f, -0.02573681f, 0.05205933f, -0.01858634f, -0.06498805f, -0.05079587f, -0.01172335f, 
    0.01590446f, 0.04792448f, -0.04849319f, -0.01472883f, 0.05143474f, -0.03980487f, -0.01182095f, -0.01191636f, 
    -0.04569187f, 0.04179889f, -0.01093028f, -0.04658733f, -0.00625990f, 0.01525572f, 0.01666253f, -0.04833827f, 
    -0.03202398f, 0.20490344f, 0.26689646f, 0.08339673f, -0.00523164f, -0.04735266f, 0.03358283f, 0.11096784f, 
    0.14889506f, -0.33377329f, -0.01677814f, 0.00296287f, -0.03512618f, -0.14387703f, -0.15981355f, 0.11406100f, 
    0.13499354f, 0.11862876f, -0.12736484f, -0.02699548f, 0.09152939f, -0.03528622f, 0.08304393f, -0.02415691f, 
    0.03286312f, 0.13609906f, 0.10336416f, -0.46143642f, 0.22430876f, 0.32596135f, -0.00217124f, -0.13787754f, 
    -0.21613939f, -0.04030249f, 0.06604618f, 0.04715999f, -0.00509682f, 0.13156328f, 0.01592100f, 0.02414432f, 
    0.10771764f, 0.03214865f, 0.15748540f, 0.01645068f, -0.09678175f, -0.03702619f, 0.13608462f, 0.09869718f, 
    0.00603625f, 0.15008889f, 0.08189166f, -0.13518043f, 0.01100843f, -0.12848543f, 0.04509624f, 0.02448436f, 
    -0.18390474f, 0.02714176f, 0.06630857f, 0.23163207f, 0.00103692f, -0.07707364f, 0.03850377f, 0.15199743f, 
    0.08140214f, -0.02114070f, -0.04095738f, -0.04944349f, -0.02382934f, -0.28981066f, -0.16509628f, -0.21977910f, 
    0.07511985f, 0.11959447f, -0.01558605f, 0.08773459f, 0.03456682f, 0.11193183f, -0.04873744f, -0.00321727f, 
    -0.07760610f, -0.17259480f, 0.18432580f, 0.00796167f, 0.01429322f, 0.10035755f, -0.07735912f, 0.12580054f, 
    0.26034874f, 0.06337933f, -0.04089146f, 0.18867877f, 0.23241799f, -0.08270786f, 0.05145754f, -0.04385819f, 
    -0.10110627f, 0.05351624f, -0.00345861f, -0.12477383f, 0.10493845f, 0.19003360f, -0.03942775f, 0.01662915f, 
    -0.00798264f, -0.19732447f, -0.11494674f, -0.09232715f, -0.41996458f, -0.16010521f, -0.03798616f, 0.05315835f, 
    0.00554999f, 0.07444298f, 0.17757054f, -0.01362398f, 0.10854171f, 0.12900966f, 0.13455769f, 0.01540896f, 
    0.07572734f, 0.02736806f, 0.02702191f, -0.07542812f, -0.09186128f, -0.13755161f, 0.20216604f, 0.06901105f, 
    -0.14299832f, 0.22163014f, -0.04244676f, -0.01088696f, -0.14608794f, -0.09571929f, -0.09463211f, 0.16547367f, 
    0.03334106f, 0.12292100f, 0.08914484f, 0.02086251f, 0.12049029f, -0.21693578f, 0.03112203f, 0.06658036f, 
    -0.06829317f, -0.14513399f, 0.01347572f, -0.02426887f, 0.17617571f, -0.01262202f, 0.08399142f, 0.17228541f, 
    0.13419388f, -0.14490440f, 0.24467692f, 0.24539469f, 0.00498400f, 0.03115261f, -0.08351696f, 0.00592179f, 
    -0.00065921f, 0.03326913f, -0.65521836f, 0.00688191f, -0.05495062f, -0.07070638f, 0.01011432f, -0.05314394f, 
    -0.12478427f, 0.13018398f, 0.02575480f, -0.20710801f, -0.01546376f, 0.10804901f, 0.00361412f, 0.01955048f, 
    0.08799635f, 0.03505144f, 0.16166368f, 0.08305503f, -0.25611973f, -0.02382902f, 0.13298768f, 0.03584947f, 
    0.05136093f, 0.03171215f, 0.06934439f, -0.27939528f, -0.04448174f, 0.09628707f, -0.06783500f, -0.04359490f, 
    0.01960109f, 0.04637058f, 0.02535587f, 0.14687678f, -0.06138702f, 0.07197336f, 0.10430544f, -0.01784201f, 
    0.03769577f, -0.01536527f, 0.05754386f, 0.13456865f, -0.25524896f, -0.19856377f, -0.16093506f, -0.02362954f, 
    0.03454418f, 0.08214214f, -0.04037957f, 0.18999211f, 0.11138994f, 0.12043630f, 0.04900075f, -0.21620522f, 
    -0.22271749f, -0.16659278f, -0.44587657f, -0.00063996f, -0.03106221f, -0.05357210f, -0.07495282f, -0.09667328f, 
    -0.02160775f, 0.02010750f, 0.11811510f, 0.14175534f, 0.04545643f, 0.06389327f, -0.00201617f, 0.21080516f, 
    0.16154487f, 0.01099461f, 0.00062465f, -0.17820196f, -0.03525608f, 0.05499701f, 0.10403035f, 0.13488336f, 
    -0.04108188f, 0.02334543f, -0.00487036f, -0.56051236f, -0.26904145f, -0.57078820f, -0.15927179f, -0.16619296f, 
    -0.27754962f, -0.12058952f, -0.11691360f, -0.06991245f, -0.04565998f, 0.10328158f, 0.21808051f, -0.26212999f, 
    -0.14296687f, -0.38918498f, -0.02042544f, 0.17150238f, 0.19312534f, -0.01042345f, -0.16884851f, -0.26074234f, 
    -0.17840333f, -0.01401723f, 0.08175391f, -0.03848647f, 0.05675940f, 0.04929508f, -0.28978276f, -0.17918052f, 
    -0.15309471f, -0.03603510f, -0.05745174f, 0.11435278f, -0.00896384f, 0.10470051f, 0.10378837f, 0.13436164f, 
    0.12330323f, -0.00892611f, 0.10113645f, 0.02385568f, 0.11754525f, -0.04335537f, -0.36918789f, -0.00300508f, 
    0.02236331f, -0.00868389f, 0.02906109f, 0.11806903f, -0.01549359f, 0.01912606f, 0.00462477f, -0.14040156f, 
    0.06611412f, 0.16906917f, -0.08985844f, -0.03828925f, 0.04391958f, -0.16849136f, -0.11348993f, 0.05123311f, 
    -0.02937221f, 0.07515691f, 0.19412139f, 0.08851019f, -0.17696406f, -0.03979320f, -0.01232408f, 0.08507650f, 
    0.06243093f, -0.02825451f, 0.02254084f, 0.29089680f, -0.09265112f, -0.05380473f, -0.06687293f, -0.02914398f, 
    -0.20277870f, 0.13552293f, 0.14132641f, 0.09904926f, -0.01582207f, 0.03145436f, 0.05590628f, 0.03450638f, 
    -0.00169251f, 0.03713889f, 0.07475492f, 0.03720456f, 0.06369820f, -0.06586894f, -0.12760979f, -0.25242329f, 
    0.08961299f, -0.08102139f, 0.11865319f, 0.04827642f, 0.09299324f, -0.07425694f, -0.21915030f, -0.08023860f, 
    -0.20646338f, 0.15545486f, 0.03720306f, 0.11625104f, 0.05725092f, 0.03623951f, -0.03560600f, -0.05909975f, 
    0.16780691f, -0.03899912f, 0.05861668f, 0.11000483f, 0.07472507f, 0.07455391f, -0.07899056f, -0.08834382f, 
    0.05444742f, -0.09275940f, -0.00976058f, 0.04972923f, 0.07842895f, 0.10707201f, 0.05119107f, -0.06709485f, 
    -0.01447290f, -0.06892375f, 0.00365661f, 0.08795884f, -0.22594126f, 0.10909001f, -0.09634942f, 0.13352296f, 
    -0.04007642f, 0.09655251f, -0.14363165f, -0.03443173f, -0.23354346f, 0.08254327f, -0.09333783f, -0.12870106f, 
    0.09288856f, -0.05681130f, 0.06439601f, 0.23466940f, 0.15884924f, 0.05019766f, 0.05800760f, -0.02131060f, 
    -0.07553148f, 0.19116345f, -0.05035161f, -0.18663748f, -0.16832408f, -0.15288921f, -0.46427196f, -0.20700823f, 
    0.05181362f, -0.17528574f, 0.01545560f, 0.00126153f, 0.04262204f, -0.25466847f, 0.17532471f, -0.04831598f, 
    0.09530997f, 0.02174513f, 0.18516856f, 0.07018657f, -0.14960235f, -0.11612768f, -0.02281657f, 0.17397557f, 
    0.17485303f, 0.05462860f, -0.01064598f, -0.02032070f, 0.00232968f, 0.13608459f, -0.19553310f, -0.16521555f, 
    -0.03283148f, 0.10941944f, 0.11178134f, -0.21793692f, -0.01009329f, 0.14377719f, 0.08379302f, -0.07282679f, 
    -0.13576235f, -0.05757287f, -0.10910885f, 0.13936521f, -0.01575687f, 0.10762974f, 0.13960004f, 0.06714270f, 
    0.01714281f, 0.15252872f, 0.05640920f, 0.00924981f, 0.14890447f, -0.04828845f, -0.07608194f, -0.00915333f, 
    0.04100612f, -0.14822835f, -0.38344905f, 0.34505990f, -0.25808927f, 0.13622771f, -0.18814731f, -0.25520271f, 
    -0.03191226f, -0.14665723f, -0.09578705f, 0.01546927f, 0.19526206f, 0.14099048f, -0.11815991f, -0.04467413f, 
    -0.00081282f, 0.07755619f, -0.06917889f, -0.27970710f, -0.02101677f, -0.08351923f, -0.08768404f, -0.08857220f, 
    0.05544764f, -0.11329300f, 0.07934391f, -0.14024411f, -0.06867337f, 0.28955743f, 0.15394472f, 0.18453318f, 
    -0.04859661f, -0.06793441f, 0.02578947f, 0.11225805f, 0.17643602f, 0.03924152f, 0.00153718f, -0.05935964f, 
    0.04403436f, 0.14384085f, 0.06319679f, 0.04053387f, 0.12254877f, -0.04170769f, -0.16699895f, -0.15452129f, 
    -0.01538915f, -0.04855537f, 0.04840936f, 0.07844935f, -0.02816826f, -0.05681299f, -0.14802797f, -0.18334267f, 
    0.24138866f, 0.17722911f, 0.03490874f, 0.00661238f, -0.31199849f, -0.02519565f, 0.04889235f, 0.01651119f, 
    0.02230146f, -0.17558688f, -0.16942111f, 0.02500733f, -0.01212310f, -0.00851499f, 0.04748029f, 0.02552406f, 
    0.07156885f, -0.01705559f, -0.07915735f, -0.18286073f, -0.25580475f, 0.01365175f, 0.12429574f, 0.10511358f, 
    0.11372738f, 0.07699804f, 0.06953112f, 0.29509541f, 0.06691305f, -0.04602516f, -0.02479031f, -0.36827299f, 
    -0.27361482f, 0.09548783f, 0.00155404f, 0.07930577f, 0.18886012f, -0.11593522f, -0.20219946f, -0.10996304f, 
    -0.04648786f, -0.16356136f, 0.06921908f, -0.00200291f, 0.02767601f, -0.05099522f, 0.04327945f, -0.17893805f, 
    0.10658648f, -0.09349988f, 0.04620836f, -0.00551594f, -0.00489192f, -0.02598737f, -0.07664469f, 0.17997803f, 
    -0.30354387f, 0.14394088f, -0.25700241f, 0.06569586f, -0.01731933f, 0.08580430f, 0.03507373f, 0.01952930f, 
    -0.06623144f, 0.14310643f, 0.06454182f, 0.17956552f, 0.14117548f, 0.03803935f, -0.10125104f, 0.00308515f, 
    0.02604355f, 0.02056993f, -0.00725236f, -0.05627614f, 0.04501262f, -0.06651323f, -0.00208897f, 0.00894111f, 
    -0.00105824f, -0.03408673f, -0.04358092f, -0.04130995f, -0.05770329f, -0.03146998f, -0.06475869f, -0.03569210f, 
    -0.01222291f, 0.04891825f, 0.00546889f, 0.03513802f, 0.00761014f, -0.03635598f, 0.02499102f, 0.00321730f, 
    0.01022341f, 0.03527774f, 0.01008430f, -0.04543250f, -0.05168280f, 0.02749044f, 0.04906622f, -0.03627559f, 
    0.03900029f, 0.04330379f, -0.01826330f, -0.01077826f, 0.01006293f, -0.00552041f, 0.03750145f, -0.05011723f, 
    -0.00109262f, -0.03123986f, 0.02218705f, 0.02609798f, -0.02631166f, -0.00652639f, 0.04651439f, -0.05035945f, 
    -0.01367264f, -0.06793801f, 0.05166283f, -0.05088239f, 0.04527984f, 0.02158658f, -0.03128122f, 0.02308712f, 
    -0.04707813f, -0.04806015f, 0.03538186f, -0.02530398f, 0.02371317f, 0.03540315f, 0.02804736f, -0.00390822f, 
    -0.04604897f, -0.01417575f, -0.02827466f, -0.04394934f, -0.01902471f, 0.00292551f, 0.00054643f, -0.02096308f, 
    -0.01903381f, -0.04898985f, 0.00531991f, 0.02345269f, -0.03779581f, 0.00899307f, 0.00386885f, -0.01162427f, 
    -0.01670823f, 0.04809802f, -0.02293983f, 0.02132115f, -0.04341602f, -0.05410005f, 0.01140230f, -0.02481561f, 
    -0.04069288f, -0.06410860f, 0.02538007f, 0.02485544f, -0.00693509f, 0.04587136f, -0.01000395f, -0.06569295f, 
    0.02695217f, -0.04443014f, 0.00034705f, 0.00145151f, 0.03757142f, -0.01003957f, 0.04961892f, 0.04597933f, 
    -0.05904048f, -0.06013105f, -0.01201111f, -0.02018907f, 0.03362817f, -0.04074337f, 0.02606455f, 0.01460083f, 
    -0.06480914f, -0.02310389f, -0.05133614f, -0.00247356f, 0.01046581f, 0.03734988f, 0.04176040f, 0.01567548f, 
    0.04615384f, -0.03239404f, -0.03969885f, 0.03587849f, -0.01698130f, -0.03471231f, 0.01328364f, 0.00112506f, 
    -0.00448439f, 0.03486834f, -0.04973571f, 0.03273281f, 0.01157134f, -0.05129972f, -0.02783168f, 0.00928702f, 
    -0.01030408f, -0.04306458f, -0.00351303f, -0.05432907f, -0.01958300f, -0.03490448f, -0.04235293f, 0.00107757f, 
    0.03547411f, 0.01625351f, 0.00874003f, 0.03596566f, 0.01050716f, -0.03222910f, -0.02794527f, -0.01308024f, 
    -0.01538308f, -0.01082452f, -0.01124893f, 0.01869585f, 0.01674737f, 0.00588571f, 0.04581064f, -0.05450441f, 
    0.02082575f, -0.02082091f, -0.02008572f, 0.05077420f, 0.04272228f, 0.04916468f, 0.04861086f, 0.02219905f, 
    -0.06529639f, 0.03842387f, 0.04135630f, -0.04273332f, 0.03199356f, -0.06141549f, -0.04210432f, -0.00294229f, 
    -0.05609973f, -0.01442603f, -0.06207184f, -0.00522991f, 0.04220219f, -0.03479493f, 0.02252526f, -0.03029334f, 
    -0.05462253f, -0.06369060f, 0.02206242f, -0.02917072f, 0.00488364f, -0.01433152f, -0.02372017f, 0.01561686f, 
    -0.06111166f, 0.00664788f, 0.04609806f, 0.03155275f, -0.04486244f, 0.04198868f, -0.04025816f, -0.05744816f, 
    0.03066987f, 0.03162003f, 0.00965570f, -0.06566524f, -0.02422087f, -0.05488480f, -0.06454892f, -0.06498904f, 
    0.00985952f, 0.00929013f, -0.05898470f, -0.01147897f, 0.02038465f, 0.03206251f, -0.01583833f, -0.03482020f, 
    0.04843893f, -0.00040660f, -0.02821928f, 0.01817233f, -0.04371861f, 0.04508145f, 0.04362779f, -0.02319162f, 
    -0.05916708f, -0.01840038f, -0.01788966f, -0.04384565f, -0.04299789f, 0.00675225f, 0.01729729f, -0.04847651f, 
    -0.01832457f, 0.04868706f, 0.05322802f, 0.02853083f, -0.03213954f, -0.00797635f, -0.02947301f, -0.03236339f, 
    -0.03542757f, -0.06113503f, -0.05720468f, 0.01924413f, 0.01497828f, 0.03159479f, 0.00390915f, -0.04754030f, 
    0.00649215f, 0.02741530f, -0.05635126f, 0.02793710f, -0.00671357f, -0.01981058f, -0.01011573f, -0.06528658f, 
    -0.02278516f, 0.03094077f, 0.02067211f, 0.01728356f, -0.00242292f, 0.01036892f, -0.03842745f, -0.05630796f, 
    0.02118925f, -0.02416237f, -0.04720340f, 0.02603580f, 0.03433857f, -0.05397556f, -0.02860673f, -0.00798723f, 
    -0.01928021f, -0.01031312f, -0.02154433f, -0.01394718f, -0.01867465f, -0.04872467f, 0.01090294f, -0.04682060f, 
    0.01501146f, 0.02252930f, 0.03225365f, -0.00657909f, -0.03371480f, 0.03574334f, 0.00789696f, -0.05664697f, 
    -0.03395563f, -0.05872692f, 0.01660127f, 0.00104934f, -0.00654439f, 0.05038580f, -0.04140651f, -0.05642588f, 
    0.02469086f, 0.04607915f, 0.03189936f, -0.01395755f, -0.04943055f, 0.01848192f, -0.00323770f, -0.04544366f, 
    -0.04515590f, -0.00220272f, -0.00330460f, 0.03208620f, 0.03304685f, 0.04664686f, -0.02713761f, 0.04407676f, 
    -0.06277090f, 0.02456479f, 0.04574744f, 0.01953924f, -0.04163169f, 0.03702885f, -0.05762298f, -0.03632863f, 
    -0.01440512f, -0.04923991f, -0.05066876f, 0.04039206f, -0.05967371f, -0.03288502f, -0.05164977f, 0.01205113f, 
    0.04130898f, -0.06325130f, 0.03435199f, -0.04686535f, -0.03123941f, -0.03143066f, 0.01887637f, -0.01121685f, 
    0.05205376f, 0.03785853f, 0.04401270f, -0.05415792f, 0.04967079f, -0.01904056f, -0.02811876f, 0.04745584f, 
    0.03392944f, 0.04252148f, -0.05239506f, 0.02234706f, -0.04763325f, -0.04358021f, -0.00940556f, -0.04477203f, 
    -0.04794692f, 0.05551576f, -0.01805986f, 0.00095290f, -0.01429430f, -0.05941539f, -0.04005002f, -0.05593468f, 
    -0.01615612f, -0.05298244f, 0.00111282f, 0.00266193f, -0.04641895f, -0.00592387f, -0.05133206f, 0.04511185f, 
    -0.00570331f, -0.03413290f, -0.03007834f, -0.00060379f, 0.03500530f, -0.05707367f, -0.00213503f, 0.02938957f, 
    -0.05669735f, -0.06183413f, -0.01928702f, -0.01154582f, 0.03960036f, 0.03996311f, -0.00397976f, -0.05014115f, 
    -0.06188480f, 0.03794077f, -0.04063397f, -0.02187060f, -0.00956038f, 0.00260390f, -0.03781139f, -0.01664523f, 
    0.05167147f, 0.04041898f, 0.04452974f, 0.03387611f, 0.04563706f, -0.02773242f, -0.00305380f, 0.02278611f, 
    0.01320624f, -0.03806105f, 0.03668499f, 0.04343028f, 0.01217007f, -0.05826844f, 0.03963906f, -0.00146610f, 
    -0.03322818f, -0.03810465f, -0.03138233f, 0.01870780f, -0.05203904f, -0.03826314f, 0.01528747f, -0.03963298f, 
    -0.06669772f, -0.06410362f, 0.01238115f, -0.00376617f, 0.04864991f, -0.01959662f, 0.01162063f, 0.00849076f, 
    -0.06200844f, -0.01179157f, 0.04841873f, -0.06609893f, -0.01366546f, -0.00052344f, -0.03648491f, -0.04932110f, 
    -0.01046314f, -0.01780520f, -0.01790491f, 0.04131854f, -0.03390586f, -0.06091281f, -0.05250294f, 0.00087947f, 
    -0.02609901f, -0.04974439f, -0.05759072f, -0.04606187f, 0.04803629f, 0.02627770f, 0.03315872f, 0.00771341f, 
    -0.05227019f, -0.01219201f, 0.03934421f, 0.01520715f, -0.00554020f, 0.00187854f, -0.02859964f, -0.00304017f, 
    -0.04641412f, 0.00441836f, 0.03410402f, 0.04351234f, -0.02039513f, 0.03822596f, 0.03367389f, 0.05614903f, 
    -0.01849973f, -0.00553904f, 0.01957608f, -0.00949935f, 0.00414133f, -0.04256863f, -0.01452590f, -0.02676262f, 
    -0.00782965f, 0.02123421f, 0.02664350f, 0.00347718f, -0.05913158f, 0.03663625f, -0.04537211f, 0.03184794f, 
    -0.02709348f, 0.00109538f, -0.00139488f, 0.04088202f, -0.02195598f, 0.04827827f, 0.04538534f, -0.00083107f, 
    -0.03089287f, -0.01662599f, -0.03579452f, -0.05256211f, -0.06026613f, -0.02290456f, -0.03994578f, -0.04927808f, 
    0.06182775f, -0.02736351f, -0.04950278f, 0.03182828f, 0.04689225f, -0.03821043f, -0.01427789f, 0.02079641f, 
    -0.03177607f, 0.00526439f, 0.00109140f, 0.01403828f, 0.03564638f, -0.01766245f, 0.03565368f, -0.06538429f, 
    0.02537632f, -0.01309338f, -0.05030957f, -0.01813370f, -0.02892791f, 0.02611132f, -0.05919856f, 0.02235105f, 
    0.00047553f, 0.04838367f, 0.05196501f, 0.03537343f, 0.04421476f, -0.03964295f, 0.01681051f, -0.01782903f, 
    -0.06421904f, 0.03272152f, -0.03943114f, -0.05376622f, 0.04497592f, 0.00516655f, -0.00523969f, -0.02664529f, 
    0.04490327f, -0.04785019f, 0.02692067f, 0.04916427f, 0.03808810f, -0.01033506f, -0.02907725f, 0.02672085f, 
    -0.05431981f, -0.02604702f, -0.02958315f, -0.02458375f, -0.04688697f, -0.03731602f, 0.01760885f, 0.02032336f, 
    -0.01905887f, -0.01652524f, -0.01558775f, 0.02060492f, -0.02121369f, -0.02213121f, -0.03895693f, 0.01973019f, 
    0.02959158f, 0.00358107f, 0.01037123f, 0.01070485f, 0.02548382f, 0.01930391f, -0.04155872f, -0.06286646f, 
    -0.01074161f, -0.04386969f, 0.03587750f, 0.01021193f, 0.02386017f, 0.00447584f, 0.01559225f, -0.04892496f, 
    0.04493371f, -0.01681233f, -0.06608684f, 0.03005915f, -0.03206656f, -0.13195711f, 0.02556192f, 0.04113126f, 
    0.02879407f, 0.03206165f, -0.31907156f, -0.15739818f, 0.09053387f, 0.03923836f, -0.16311643f, 0.06704645f, 
    -0.09454713f, 0.05453462f, 0.23838949f, 0.07292807f, -0.13326661f, -0.04589765f, -0.02878579f, 0.03273846f, 
    -0.00816925f, -0.09004728f, -0.18930830f, 0.07179542f, -0.03017849f, -0.58234358f, 0.12100109f, 0.00804625f, 
    0.11400641f, 0.04993540f, 0.09548421f, 0.04171303f, -0.23503490f, -0.13108459f, 0.25907186f, 0.00610608f, 
    0.03132432f, -0.01271314f, 0.09488201f, -0.12673892f, -0.05276649f, -0.42769504f, -0.14282767f, 0.08232272f, 
    -0.14033413f, 0.05252763f, 0.08794688f, 0.08073011f, -0.03026799f, 0.17044200f, -0.32557547f, -0.10946266f, 
    0.19486953f, -0.00405951f, -0.05179368f, 0.01347634f, 0.06484713f, 0.12609866f, 0.06568723f, -0.10461269f, 
    -0.16318120f, 0.29527879f, -0.08421092f, -0.07154416f, 0.05901983f, -0.03286997f, 0.00423721f, 0.08546501f, 
    -0.03587447f, -0.39600027f, 0.11107393f, -0.06013415f, 0.09257982f, 0.11512072f, -0.10943536f, 0.07950971f, 
    0.08568110f, -0.06571425f, 0.08152904f, -0.11675436f, -0.07127693f, 0.10520940f, -0.01101345f, -0.02846799f, 
    -0.00033594f, -0.17269541f, 0.14326668f, 0.14002818f, 0.20173858f, 0.24609312f, 0.04838728f, 0.09975830f, 
    -0.02235535f, -0.08966868f, 0.01901451f, 0.09916071f, -0.37085322f, -0.16291064f, 0.07742930f, -0.01146345f, 
    0.09214076f, -0.04853692f, 0.05642781f, 0.01137535f, -0.08524743f, 0.34121588f, -0.35373747f, -0.19124216f, 
    0.12055529f, 0.19025175f, -0.08776822f, 0.08206973f, 0.11939706f, -0.10067972f, -0.07703119f, -0.01577099f, 
    -0.14340398f, 0.01116623f, 0.04272467f, 0.05616773f, 0.09489956f, 0.04003169f, 0.02762420f, 0.32098746f, 
    -0.07760171f, -0.10274514f, -0.01969591f, 0.04219756f, -0.03526082f, -0.02656483f, -0.17714603f, -0.13406384f, 
    -0.01797039f, -0.12191814f, 0.04462006f, 0.04882533f, -0.05104795f, 0.08373750f, 0.07144516f, -0.14862522f, 
    -0.27543217f, -0.13444909f, 0.29553559f, 0.02839083f, -0.23640697f, -0.02409471f, 0.11191456f, 0.10248661f, 
    0.10428126f, 0.00823441f, -0.04089844f, -0.15384430f, 0.09255001f, 0.03619653f, -0.00939738f, -0.09517915f, 
    -0.04153684f, 0.08459053f, -0.49718526f, -0.06705988f, 0.47799459f, -0.04951381f, -0.07024466f, 0.23737508f, 
    -0.16728656f, 0.10714237f, 0.01195038f, -0.17310151f, 0.28902879f, 0.33039412f, -0.04439446f, -0.15343811f, 
    -0.12969227f, 0.02322652f, 0.09039849f, 0.00276039f, 0.08732357f, -0.07921245f, 0.23576492f, -0.02910121f, 
    -0.11036870f, 0.15451993f, 0.01959374f, -0.00720261f, 0.01532812f, -0.06384490f, -0.12519459f, 0.15799214f, 
    0.00784337f, -0.11045775f, -0.17077075f, 0.15463787f, -0.10205579f, -0.08185361f, -0.22716862f, -0.13665323f, 
    -0.06476106f, -0.00166180f, 0.18175839f, 0.07136690f, -0.00449799f, 0.04620406f, 0.12291834f, -0.36585724f, 
    -0.14890082f, 0.12744951f, -0.09653537f, -0.13852987f, -0.08104245f, 0.06066241f, 0.02470877f, -0.01592062f, 
    0.14883170f, 0.29142681f, 0.02737693f, 0.03578140f, -0.10112526f, -0.08304472f, -0.16022697f, 0.02054111f, 
    0.04275487f, -0.19651380f, 0.05909097f, 0.29127386f, 0.07443023f, -0.13254429f, -0.39623624f, -0.07257242f, 
    0.07065669f, 0.12615877f, -0.02855241f, -0.05383720f, 0.12810236f, -0.00083056f, 0.13938913f, -0.05785197f, 
    0.09350798f, 0.03671365f, 0.07902876f, 0.23634380f, 0.28661785f, 0.18367058f, 0.11127402f, -0.21645562f, 
    -0.11496057f, -0.10073651f, 0.04774126f, 0.17349717f, -0.01332631f, -0.15752496f, 0.03248253f, 0.03231977f, 
    0.10895700f, -0.28415579f, 0.06162987f, -0.01596371f, 0.10983521f, 0.16020142f, 0.16062073f, -0.09773304f, 
    0.02718068f, -0.12830807f, -0.02585868f, -0.03010739f, -0.02689742f, 0.02553258f, -0.14778437f, 0.20439215f, 
    0.10406469f, -0.00923085f, 0.09355792f, 0.05479310f, -0.09315986f, -0.07322329f, 0.02476790f, 0.02756580f, 
    -0.08974796f, -0.00335242f, -0.05229107f, -0.01496653f, -0.06907012f, -0.01001506f, 0.05835286f, 0.20066395f, 
    -0.05697700f, 0.01431386f, 0.01640343f, 0.00660550f, 0.04131558f, 0.04988263f, -0.02741353f, 0.04645665f, 
    -0.05639303f, 0.04473980f, -0.00754344f, 0.03447030f, 0.04856316f, -0.02887836f, 0.03056965f, -0.03736601f, 
    -0.02530540f, -0.01207477f, -0.03854493f, -0.04263886f, -0.01587269f, -0.02644334f, 0.04209949f, -0.00994645f, 
    -0.01078512f, -0.03664435f, 0.05772216f, 0.04905191f, 0.00905852f, -0.03403575f, -0.02414097f, 0.03033268f, 
    -0.04648887f, 0.02875763f, -0.01140244f, 0.02830278f, 0.04220037f, -0.06398783f, 0.02331209f, 0.05119631f, 
    -0.03642670f, 0.02845221f, -0.03846389f, 0.04662476f, -0.04655022f, 0.02187164f, -0.01332299f, 0.02040967f, 
    -0.05109737f, -0.05520482f, -0.01614902f, 0.05110057f, -0.02857856f, -0.05764555f, -0.02859838f, -0.03984003f, 
    0.00452824f, -0.00070576f, 0.04925084f, -0.03486469f, 0.04433740f, -0.04367258f, -0.02927650f, -0.00584434f, 
    -0.01300998f, 0.02783220f, -0.02351682f, -0.00858419f, -0.00348862f, 0.04211152f, 0.01481972f, -0.05862364f, 
    -0.03524850f, -0.00002167f, 0.00123557f, 0.00258762f, 0.02294297f, -0.03487888f, -0.04243271f, -0.03883863f, 
    0.03740607f, -0.02405844f, 0.02705157f, -0.00811326f, -0.05046053f, 0.03703749f, -0.04198038f, -0.06084907f, 
    0.02582329f, -0.03695943f, 0.00596133f, -0.02506860f, -0.00526296f, 0.00249533f, -0.05956089f, -0.00871560f, 
    -0.02906309f, -0.04506777f, 0.01632464f, -0.01035827f, -0.05032422f, 0.00955763f, 0.03581432f, -0.05770267f, 
    -0.03424652f, 0.02148210f, 0.05220458f, 0.01631240f, -0.01617944f, -0.03668184f, -0.00242337f, 0.04037691f, 
    0.00495043f, 0.00563631f, -0.00590607f, -0.02071690f, -0.06189785f, 0.04866949f, -0.05830023f, 0.01570140f, 
    -0.00544734f, -0.04715720f, 0.04807701f, 0.01402833f, -0.01919916f, -0.04293111f, -0.02302662f, -0.05816602f, 
    -0.01906052f, 0.00804223f, -0.02801845f, -0.06425357f, 0.00720381f, 0.01233737f, -0.03676977f, -0.05168300f, 
    -0.02311487f, -0.03127329f, 0.00739971f, 0.03561441f, -0.02936339f, 0.00561375f, -0.01392865f, 0.01735570f, 
    -0.06429365f, 0.01655341f, -0.05524508f, -0.01810325f, -0.01367065f, -0.05319284f, -0.01597909f, 0.01910614f, 
    -0.03839877f, -0.02229559f, -0.00041764f, -0.03256616f, -0.02115675f, -0.04157734f, 0.01273996f, -0.00687378f, 
    -0.05257324f, 0.00865305f, 0.03025119f, 0.02315143f, 0.04302945f, -0.04691495f, -0.03873875f, 0.01297251f, 
    0.01037094f, 0.02872688f, 0.03539965f, -0.02683864f, 0.01482204f, -0.00513593f, -0.01807097f, 0.02020835f, 
    -0.03227666f, -0.01746618f, 0.04564914f, 0.01856528f, 0.00225534f, -0.05512718f, -0.05103017f, 0.01090708f, 
    0.05277875f, -0.05217543f, 0.03348669f, -0.04278467f, -0.00240503f, -0.03945183f, -0.04178725f, 0.00833362f, 
    -0.02753215f, -0.03512847f, -0.01486618f, 0.03591279f, -0.00085557f, 0.00047098f, 0.03112523f, 0.01260978f, 
    -0.03424364f, 0.03284932f, 0.00470194f, 0.01754430f, -0.00523074f, 0.02056495f, 0.02944848f, 0.04178807f, 
    -0.05615096f, 0.05680080f, 0.04544225f, -0.00218209f, -0.05757518f, -0.00443184f, -0.00479000f, -0.05065316f, 
    0.00931368f, -0.05933948f, -0.04989326f, -0.00285706f, -0.01284884f, -0.03575339f, -0.01947509f, 0.01602650f, 
    -0.03360904f, 0.03638301f, -0.01552152f, 0.01282796f, -0.03080562f, 0.01878956f, 0.02630212f, -0.04223963f, 
    0.04273961f, -0.04824957f, 0.03914442f, 0.04440247f, 0.00868937f, 0.02925824f, 0.00580721f, -0.03610507f, 
    0.00364527f, 0.04089800f, -0.02643035f, -0.05594287f, -0.04476443f, -0.05051297f, 0.02548141f, -0.00903949f, 
    -0.02164838f, 0.02138044f, 0.03640204f, -0.02321808f, -0.02203092f, -0.04713651f, -0.03072217f, -0.00874131f, 
    0.02208056f, -0.06387895f, -0.01532674f, -0.05967208f, -0.04378276f, -0.06070285f, -0.04403603f, 0.02204308f, 
    -0.02232093f, -0.03197982f, 0.05097982f, 0.04736133f, 0.00963167f, 0.00291962f, -0.04109792f, -0.04160760f, 
    -0.02755424f, 0.01935300f, 0.02108427f, 0.03032552f, -0.03931664f, -0.03093919f, -0.05809553f, 0.02090271f, 
    -0.05266207f, -0.04653506f, -0.03099074f, -0.03115760f, -0.01411342f, -0.00097018f, 0.03672148f, -0.03437131f, 
    0.03588836f, -0.00852358f, -0.05884076f, 0.05033454f, 0.02245426f, 0.01701764f, -0.05367334f, 0.01593495f, 
    0.01713352f, 0.04639289f, -0.00455992f, 0.02637488f, 0.02620912f, -0.02292325f, -0.02953224f, -0.01660762f, 
    -0.05411397f, -0.00664567f, 0.05218505f, -0.05439688f, -0.08424366f, -0.01138382f, -0.02800649f, 0.04840844f, 
    -0.06241904f, 0.02118968f, -0.06492126f, -0.04137248f, -0.03171075f, -0.04541513f, -0.02830387f, -0.08308192f, 
    -0.04458357f, 0.00555552f, 0.01867001f, -0.02964424f, -0.02085788f, -0.00123498f, 0.00022702f, 0.00230159f, 
    -0.05535709f, -0.06115997f, -0.02199015f, -0.01673556f, -0.04291259f, -0.03181490f, -0.03330261f, -0.04698173f, 
    0.02184488f, 0.00216378f, -0.06990153f, -0.08951875f, 0.00493360f, -0.04402706f, -0.05522905f, -0.05339558f, 
    0.01290055f, 0.00377741f, -0.04297369f, -0.00929417f, 0.01207051f, -0.07573524f, -0.08407476f, -0.01604088f, 
    0.01262173f, -0.06214479f, -0.07834467f, 0.01088733f, -0.09638754f, -0.02052738f, 0.01708071f, 0.02196904f, 
    0.03338259f, 0.04470411f, -0.00574446f, 0.01072624f, -0.02366584f, -0.05574621f, -0.00938911f, -0.07482795f, 
    0.00702004f, -0.03191025f, 0.02514629f, -0.07052138f, 0.02032624f, -0.02129141f, 0.02250559f, -0.06411668f, 
    -0.04743031f, -0.01261638f, -0.01040316f, 0.00800569f, 0.02177131f, -0.05130292f, -0.07009424f, -0.05020444f, 
    0.00845134f, -0.00071712f, -0.03831945f, -0.02916022f, 0.00627083f, -0.03833401f, -0.06716056f, -0.02145574f, 
    -0.06323821f, 0.03048453f, 0.02572520f, -0.03621909f, -0.06333232f, -0.05341788f, -0.00194702f, 0.03130477f, 
    0.01689469f, -0.06620446f, -0.03191457f, -0.06918532f, 0.02833552f, -0.03511192f, -0.04762140f, -0.01516498f, 
    0.02266665f, -0.04896104f, -0.07598295f, 0.04352707f, -0.06393407f, -0.02508429f, -0.00119946f, -0.00864574f, 
    -0.09894432f, -0.05192272f, -0.07903260f, -0.03920368f, -0.04901833f, -0.06630068f, -0.01791445f, -0.02173185f, 
    0.00263093f, -0.04352898f, 0.01781973f, -0.05598466f, 0.02360696f, 0.03924254f, 0.02065394f, -0.08306541f, 
    -0.03556807f, -0.02075493f, -0.06578327f, -0.00477082f, -0.05859100f, 0.02435378f, 0.00266980f, -0.08998723f, 
    -0.03945190f, 0.00295774f, -0.00689612f, 0.01624246f, 0.01143549f, -0.02641778f, -0.07054472f, -0.01884794f, 
    0.02272995f, 0.02683416f, 0.02317153f, 0.02625448f, -0.01342148f, 0.04032649f, -0.04672730f, -0.00714820f, 
    0.02345813f, -0.09772938f, -0.00958266f, 0.01084139f, -0.01500255f, -0.01685099f, 0.01803615f, -0.00199548f, 
    -0.02993467f, -0.03003280f, -0.00242059f, -0.00350223f, 0.06520785f, 0.04465463f, -0.05284759f, -0.02229090f, 
    -0.09243008f, -0.04354612f, 0.01952426f, 0.02835334f, -0.05977422f, 0.03716716f, 0.03150834f, 0.00641828f, 
    -0.01293321f, -0.03991396f, -0.04079248f, -0.05017274f, -0.06010866f, -0.00022332f, -0.05693094f, -0.06199237f, 
    -0.02584649f, 0.04157200f, -0.05667640f, -0.07115549f, -0.07516047f, 0.00720912f, -0.07054321f, -0.01448372f, 
    -0.04813175f, -0.05624909f, -0.02024428f, -0.06400008f, 0.00811722f, -0.06502587f, -0.06141924f, -0.07893338f, 
    -0.02726761f, -0.02352693f, -0.05769891f, -0.02350549f, 0.00310156f, -0.05971817f, -0.00593632f, 0.01058090f, 
    -0.02218106f, 0.03103317f, 0.03803774f, 0.01116930f, -0.07538220f, -0.00863365f, -0.06020126f, -0.04277746f, 
    -0.06468087f, 0.01430010f, 0.02244615f, 0.05303427f, 0.00333062f, 0.04777716f, -0.04182651f, -0.06277566f, 
    -0.00515016f, -0.07829995f, -0.04058294f, 0.00825599f, 0.01253823f, -0.05807218f, 0.04425424f, -0.00521382f, 
    0.00882895f, 0.05701248f, 0.05318897f, 0.02611368f, 0.05179039f, -0.03251305f, -0.06155435f, 0.04553219f, 
    -0.02924936f, 0.02260092f, -0.05828451f, 0.00303374f, 0.04128765f, -0.04193810f, -0.02075216f, -0.09165440f, 
    -0.04289813f, -0.04016963f, -0.00499790f, -0.06232042f, 0.02583615f, -0.02834962f, -0.04642696f, 0.03963482f, 
    0.01515860f, -0.01925323f, 0.02012545f, 0.03650699f, -0.00970373f, 0.00516131f, 0.03193962f, 0.03143858f, 
    0.00842718f, 0.00094669f, -0.05205021f, -0.02274281f, -0.09550818f, -0.04299292f, -0.00421433f, 0.01078382f, 
    -0.24668367f, -0.54262525f, -0.37794945f, -0.20424600f, 0.19544785f, 0.15818396f, 0.19412392f, 0.04225060f, 
    0.00381987f, -0.88154739f, -0.46999741f, -0.29569528f, -0.26763427f, -0.33802700f, 0.01202716f, -0.15311347f, 
    -0.12902348f, -0.14031696f, 0.13908085f, -0.82770836f, -0.39088580f, -0.19033103f, -0.17525569f, -0.00813072f, 
    0.18360333f, 0.02884908f, -0.03388331f, -0.30147162f, -0.36341062f, -0.07724630f, -0.19550885f, 0.13084431f, 
    -0.05800048f, 0.10466954f, -0.11410515f, -0.00729013f, 0.06698957f, 0.24812683f, 0.02838071f, 0.12647708f, 
    0.00284789f, 0.05351358f, -0.03379894f, 0.16813163f, 0.15749903f, 0.24454370f, -0.05811416f, -0.12502782f, 
    -0.20669535f, 0.03003452f, -0.03897155f, -0.05421751f, -0.07129791f, -0.14786127f, 0.33014962f, 0.07128823f, 
    0.02632848f, -0.06227767f, 0.03335935f, -0.04878021f, 0.09472595f, 0.08964796f, -0.18449156f, -0.12683596f, 
    -0.16822220f, -0.06947925f, 0.01393877f, -0.04672792f, 0.04431832f, -0.07555848f, 0.00393674f, 0.13100798f, 
    0.18866527f, 0.04562615f, -0.11353184f, 0.06361915f, -0.10221751f, 0.00513211f, 0.04801223f, 0.02172870f, 
    -0.06680153f, 0.27278185f, 0.03027101f, 0.24275221f, -0.04764083f, 0.20413649f, 0.00433908f, 0.12001427f, 
    0.04044924f, 0.20657535f, 0.02300402f, -0.21491854f, -0.62086141f, 0.00318593f, 0.05464052f, 0.15768316f, 
    0.17904772f, 0.04373142f, 0.08635770f, -0.01757514f, -0.10021737f, -0.09015167f, -0.05635044f, -0.03538591f, 
    -0.00582846f, 0.10007412f, -0.04422548f, -0.07224255f, -0.00442103f, -0.11577954f, -0.35575113f, 0.08315713f, 
    0.24211606f, 0.08588672f, 0.05492309f, 0.12328145f, -0.05189564f, 0.10324571f, -0.05205975f, -0.18466528f, 
    -0.03331343f, 0.02039385f, 0.17297515f, -0.08322953f, -0.03119624f, 0.01856074f, -0.19919698f, 0.07857668f, 
    -0.27380159f, 0.08292677f, -0.13160111f, 0.08731907f, -0.03464189f, 0.06196402f, 0.14567252f, 0.22143634f, 
    0.26567978f, -0.13523133f, -0.10042523f, -0.09735890f, 0.17602658f, 0.17428467f, 0.07962301f, 0.15377200f, 
    0.11456203f, 0.19650188f, 0.13109842f, 0.04520824f, 0.02963162f, 0.11236836f, 0.09075103f, 0.12807758f, 
    0.07867069f, -0.26494613f, -0.17868550f, -0.18574417f, 0.12028431f, 0.17260589f, 0.11300177f, 0.08938069f, 
    0.10764550f, 0.04556879f, -0.18738003f, -0.12071151f, -0.10668253f, -0.03333233f, 0.09134638f, 0.11036618f, 
    -0.04660535f, -0.11901926f, -0.12994325f, 0.14070287f, 0.23403436f, 0.13972282f, -0.10910044f, -0.01050808f, 
    -0.07953385f, -0.07775816f, 0.08529410f, -0.12604463f, 0.17938827f, -0.28241169f, 0.12937406f, -0.24760982f, 
    0.01768632f, 0.15290518f, 0.15722696f, -0.02455896f, -0.24107246f, 0.10430017f, 0.23384078f, 0.23258917f, 
    0.11894401f, -0.02585919f, -0.03992222f, 0.00160122f, 0.14051129f, -0.00195322f, 0.03324867f, 0.00252257f, 
    -0.07465158f, 0.02846461f, -0.11280645f, -0.00106820f, 0.08642572f, 0.08365806f, -0.07730567f, -0.02402001f, 
    0.09805992f, -0.11423041f, -0.08418615f, -0.23480925f, 0.12393276f, 0.06753529f, -0.05422466f, -0.09986293f, 
    -0.17377330f, -0.09806754f, -0.16427182f, 0.05983519f, -0.04514730f, -0.15660389f, 0.00470022f, -0.06649188f, 
    0.06992817f, -0.01568888f, 0.18623921f, 0.08714407f, -0.00423749f, 0.00410685f, 0.08172217f, 0.07855266f, 
    0.15947306f, 0.17212789f, 0.14318545f, -0.02653446f, -0.01605692f, -0.14799245f, -0.06953636f, -0.14295901f, 
    -0.03689322f, 0.00300879f, 0.09453046f, -0.18941095f, 0.25114360f, -0.03336338f, -0.11421491f, -0.15944397f, 
    -0.18979642f, -0.10805242f, -0.06115079f, 0.03592174f, -0.28109506f, -0.97384709f, -0.50025111f, -0.05867958f, 
    0.00993126f, -0.01635601f, 0.06255814f, 0.07307926f, -0.02605994f, -0.21819694f, -0.12063767f, -0.16092691f, 
    -0.07136003f, 0.08857941f, -0.04576569f, 0.07476803f, -0.02688699f, 0.05164888f, -0.52668566f, -0.31108215f, 
    -0.40359917f, 0.09591752f, 0.20742446f, 0.06301030f, 0.07488003f, 0.05514611f, 0.13243872f, -0.04431752f, 
    -0.05502641f, 0.11917837f, 0.20041578f, -0.00012200f, 0.03932977f, 0.15748869f, 0.10947060f, 0.03894432f, 
    0.17262159f, 0.03001716f, 0.17234805f, -0.10489313f, -0.00678842f, 0.02182230f, 0.06824926f, 0.08303819f, 
    -0.05805474f, 0.07152080f, -0.51904607f, 0.07885668f, 0.14639898f, 0.03421997f, -0.00293053f, 0.12105381f, 
    0.16589342f, -0.18684666f, 0.15289699f, 0.07572640f, 0.33325300f, 0.00383755f, 0.10820485f, 0.07052636f, 
    0.21703371f, 0.03445444f, -0.02414855f, 0.12591520f, -0.31388810f, -0.01893066f, 0.07044261f, 0.03739226f, 
    0.12337314f, 0.02574155f, -0.11630178f, 0.16153774f, 0.02335414f, -0.24384935f, -0.35632181f, -0.11185844f, 
    -0.09133544f, -0.00257669f, 0.07213999f, 0.10315736f, -0.08703955f, 0.21720943f, -0.35744601f, -0.61993927f, 
    -0.06956780f, 0.18140611f, 0.03414508f, 0.01008110f, 0.01161102f, 0.02926712f, 0.10823588f, -0.08852902f, 
    -0.31298143f, -0.26142889f, 0.08478478f, -0.08960246f, -0.17120615f, -0.13622883f, 0.11113962f, -0.03280468f, 
    -0.17570347f, -0.23993835f, -0.03415643f, 0.06299113f, -0.07122324f, -0.10623164f, 0.04302118f, 0.09180775f, 
    -0.10977913f, -0.18029244f, -0.11033985f, 0.08418263f, 0.03014939f, -0.02981937f, 0.03358444f, 0.05817672f, 
    0.12192054f, -0.33895323f, -0.15022480f, -0.08821918f, -0.03562262f, -0.10990041f, 0.07417980f, 0.17306362f, 
    0.09103446f, 0.01778528f, 0.21617505f, -0.20198359f, -0.14170003f, -0.16284409f, -0.03841846f, 0.24883780f, 
    0.12710907f, 0.10070450f, 0.00892222f, -0.36187738f, -0.39494503f, -0.49806103f, -0.13612035f, -0.16804568f, 
    0.12738653f, 0.00561828f, 0.07746981f, 0.08572282f, -0.11290210f, 0.28168088f, -0.02201430f, -0.06958218f, 
    0.03473166f, -0.02833917f, 0.05451661f, 0.14623068f, 0.01305807f, 0.13283400f, -0.22308773f, -0.51300001f, 
    -0.05263873f, 0.00745122f, -0.02107606f, 0.05448313f, -0.08884753f, 0.06345922f, 0.24393342f, 0.16692425f, 
    0.16343430f, -0.01623824f, 0.12376233f, -0.02663623f, 0.13746861f, -0.04415818f, 0.10060903f, 0.50386375f, 
    0.12358879f, -0.18886022f, 0.00390026f, 0.11559460f, -0.05793218f, 0.09790591f, 0.15802281f, 0.06563886f, 
    -0.17570435f, -0.05686255f, -0.00272191f, 0.14935696f, -0.05361951f, 0.16465189f, 0.19059403f, 0.02141981f, 
    0.00741817f, -0.03016972f, -0.05521422f, -0.07527576f, -0.04612774f, -0.10039587f, 0.07852801f, -0.09873452f, 
    0.07242236f, 0.02280669f, -0.96495396f, -0.34537181f, -0.06339046f, -0.12061866f, -0.12351518f, -0.17522360f, 
    0.12924685f, 0.20841718f, 0.08510748f, -0.19515446f, -0.34711269f, -0.39217111f, -0.10249522f, -0.22567125f, 
    -0.10975110f, 0.09225217f, -0.02569751f, 0.08144679f, -0.48796546f, -0.30104244f, 0.13851054f, 0.00465826f, 
    -0.06032173f, -0.07243820f, 0.01250674f, 0.04987903f, -0.07833462f, 0.50492764f, -0.00049576f, -0.43462205f, 
    -0.10594222f, -0.00088358f, -0.07450201f, -0.02599477f, -0.04367625f, 0.04866804f, 0.01111686f, 0.11186673f, 
    -0.16204174f, 0.10526036f, 0.05373754f, 0.04083536f, 0.07596166f, 0.14121275f, -0.01877985f, 0.16228288f, 
    -0.22007228f, -0.21390569f, -0.00028170f, 0.00694429f, 0.02540435f, 0.16842622f, 0.06601725f, 0.04062755f, 
    0.08007894f, 0.22710200f, 0.16155058f, -0.06058536f, -0.00597224f, -0.08476468f, -0.00947944f, -0.06461546f, 
    -0.02379625f, -0.27107048f, -0.24735010f, 0.10564440f, 0.03702663f, -0.01807485f, 0.02447493f, 0.13560502f, 
    0.08082589f, 0.09488668f, 0.32960299f, -0.41400456f, -0.47466776f, 0.08985206f, 0.16985583f, 0.09316842f, 
    0.02256670f, -0.03447382f, -0.01921867f, 0.09931539f, 0.25509340f, 0.03678018f, -0.14438654f, 0.08878385f, 
    0.00142302f, -0.06667196f, 0.10279486f, 0.14108619f, 0.21775329f, -0.14464669f, -0.26420707f, -0.10986562f, 
    0.06480475f, 0.02955074f, 0.08745638f, 0.07361434f, -0.00703994f, 0.26249033f, 0.09213081f, 0.12640965f, 
    0.06660655f, -0.01617440f, -0.06907203f, 0.14519800f, -0.11081906f, 0.06995472f, -0.07532640f, 0.22460309f, 
    -0.02743343f, 0.09588258f, -0.11186937f, -0.00261740f, 0.03699391f, 0.09263790f, -0.09462900f, 0.16591038f, 
    -0.19417390f, -0.07608246f, -0.02605175f, 0.06453399f, -0.03851087f, 0.04315640f, -0.00222619f, 0.09511974f, 
    0.34648579f, 0.02488789f, -0.12015669f, -0.03676135f, 0.04216682f, -0.15011881f, 0.01467905f, 0.08651657f, 
    -0.08320563f, 0.26837924f, 0.01393474f, -0.20028208f, 0.00820876f, -0.09273152f, -0.00692013f, 0.07611419f, 
    -0.01876706f, -0.04804208f, 0.09510723f, 0.17695723f, -0.08152479f, -0.09798940f, -0.09749624f, -0.04264969f, 
    0.04289231f, 0.06144915f, 0.15479530f, 0.51333553f, 0.06790569f, -0.28656244f, -0.19363591f, -0.02575741f, 
    -0.04928165f, 0.05941103f, -0.05814922f, -0.05938582f, 0.03494623f, 0.07005859f, -0.08154046f, 0.04635205f, 
    0.01700723f, -0.03668628f, 0.12455691f, 0.07863478f, 0.06624843f, -0.03788249f, 0.02210671f, -0.23919015f, 
    -0.12945434f, 0.07731729f, 0.17244337f, -0.04027911f, 0.14887019f, -0.03537812f, -0.14700167f, -0.13303517f, 
    0.28676188f, -0.12322840f, 0.22026549f, 0.24897157f, -0.01411887f, 0.04538560f, 0.01277564f, -0.16246137f, 
    -0.08719528f, 0.08419517f, 0.21224990f, 0.15076607f, 0.17638002f, -0.03444295f, -0.09926015f, 0.03600840f, 
    -0.01733238f, -0.05446728f, 0.11672074f, 0.01521828f, 0.05560424f, 0.00695297f, -0.08250707f, -0.09339815f, 
    0.08448171f, 0.02358827f, 0.02535379f, -0.08224504f, -0.01559963f, 0.27394700f, -0.22667778f, 0.10118823f, 
    0.07594745f, -0.01107825f, 0.03029915f, 0.14026283f, -0.03402049f, 0.07461945f, 0.01479336f, -0.13248599f, 
    0.06869437f, 0.15059994f, -0.02731413f, 0.21294111f, 0.07508374f, -0.19863176f, -0.11119881f, -0.11906313f, 
    0.09552297f, 0.06232710f, -0.23871964f, -0.05585573f, 0.31006145f, -0.21795113f, 0.15341304f, -0.08037194f, 
    -0.19925345f, 0.28415745f, 0.09382867f, 0.03705960f, 0.03948700f, -0.13074706f, -0.04494052f, 0.08002394f, 
    0.06666751f, 0.18863682f, 0.13357235f, 0.06918637f, -0.10955556f, 0.04071636f, -0.02876830f, -0.37603357f, 
    -0.01655970f, -0.05648506f, -0.02482149f, 0.00634613f, -0.02639986f, -0.10744023f, 0.07120217f, 0.08582436f, 
    -0.00621732f, -0.05226677f, -0.02473321f, -0.08303595f, 0.25946406f, -0.02288991f, 0.03750904f, 0.05053799f, 
    0.01176823f, -0.09642188f, -0.10293198f, 0.05017825f, -0.06631058f, 0.01580714f, 0.02780013f, -0.08620330f, 
    0.09726093f, 0.33556959f, 0.04609738f, -0.28186479f, 0.07506273f, -0.02997251f, 0.03949949f, 0.10051389f, 
    -0.00118079f, -0.08404262f, 0.59282410f, 0.53510022f, 0.17184725f, 0.09751634f, -0.01099200f, 0.16448237f, 
    0.03470685f, 0.01688046f, 0.02817654f, 0.07670078f, 0.13577114f, 0.05630799f, -0.37385818f, -0.01951034f, 
    -0.06256772f, -0.05361012f, -0.19414070f, -0.15378582f, 0.20060921f, 0.19483328f, 0.13488036f, -0.26086766f, 
    0.08762803f, 0.12501849f, 0.02189018f, 0.12107897f, -0.03887243f, 0.13318855f, 0.06467506f, 0.00734800f, 
    -0.04160979f, 0.07360075f, -0.17494363f, 0.03410979f, -0.03238779f, 0.03462829f, -0.05322357f, 0.00554919f, 
    0.11809588f, 0.00474214f, 0.04268911f, 0.02191516f, -0.08100382f, 0.01678109f, 0.03245531f, 0.08328653f, 
    0.07353021f, -0.35645017f, -0.04030527f, -0.04266267f, 0.03184240f, -0.07253875f, 0.15901904f, -0.09727704f, 
    -0.63535792f, -0.31576028f, -0.18555029f, 0.00336175f, -0.04236147f, 0.01170464f, 0.00390482f, -0.17691766f, 
    0.05443592f, -0.08622594f, 0.15223089f, 0.11350350f, 0.04707630f, -0.06598466f, -0.03673018f, -0.04842128f, 
    0.13789478f, -0.17879254f, -0.12668006f, -0.06226338f, 0.02066104f, -0.00398795f, 0.10542544f, -0.05530305f, 
    0.06502143f, 0.03024733f, 0.01721472f, -0.29433665f, 0.27663481f, 0.46513057f, -0.11606547f, -0.08722722f, 
    -0.17295831f, -0.04018857f, -0.08513478f, -0.02295267f, 0.15031560f, -0.10911602f, 0.02869520f, 0.01374329f, 
    0.11702548f, -0.20388719f, 0.02987379f, 0.07367805f, -0.01307891f, -0.45556048f, -0.06142171f, 0.19036382f, 
    -0.02179526f, 0.00824255f, 0.03277271f, -0.04099561f, -0.02191257f, -0.13320439f, -0.08185994f, -0.32560486f, 
    -0.38930604f, -0.01511265f, -0.03265706f, 0.09967292f, -0.01116922f, -0.00353385f, -0.04509867f, -0.13223042f, 
    -0.13443026f, 0.20352089f, 0.06047574f, 0.02925344f, 0.03603268f, -0.08362361f, -0.00137748f, -0.09492190f, 
    -0.01487903f, -0.06550387f, -0.03768154f, -0.03709324f, 0.02862333f, -0.02943606f, 0.15798442f, -0.09283116f, 
    0.05589429f, 0.18126445f, -0.00645644f, -0.00287571f, -0.05368175f, 0.07053965f, 0.10956904f, 0.07694235f, 
    0.00492523f, 0.24064042f, 0.05371708f, 0.13303767f, 0.10079689f, 0.03580511f, -0.04400144f, 0.00989133f, 
    -0.18777452f, -0.00581707f, 0.08651900f, 0.18529828f, -0.10663950f, 0.13783503f, 0.12677321f, -0.01905245f, 
    0.06146680f, 0.04672054f, -0.05822393f, 0.15209009f, -0.06528924f, -0.00544560f, -0.27086177f, 0.07619046f, 
    0.07897189f, -0.03607173f, 0.04353542f, 0.03959779f, -0.02637833f, 0.04293134f, 0.00709785f, -0.16394956f, 
    -0.04279899f, 0.03071255f, 0.00045269f, 0.08894841f, 0.03911016f, -0.05973237f, -0.16264790f, -0.02466812f, 
    -0.07152908f, -0.01394913f, 0.01182665f, -0.02989032f, 0.11652268f, -0.01354707f, -0.07456381f, -0.10476308f, 
    0.07454439f, -0.05763308f, -0.06859818f, -0.02545501f, -0.00943226f, -0.20676994f, -0.17673190f, -0.20887561f, 
    0.05994673f, 0.03838225f, -0.06905692f, 0.04117995f, 0.02477835f, 0.03262356f, 0.02818860f, -0.03368444f, 
    -0.01798270f, 0.25769061f, 0.05161930f, 0.01216436f, 0.07913150f, 0.03940690f, 0.00310954f, 0.00518959f, 
    0.13618770f, 0.01748752f, 0.12374440f, 0.03713473f, 0.02108757f, 0.03838931f, 0.09523449f, 0.10444424f, 
    0.07990487f, -0.00521980f, -0.09084196f, -0.01155818f, -0.01877907f, -0.01087928f, 0.01599233f, 0.12005150f, 
    0.04586685f, -0.13332851f, -0.23592319f, -0.37522018f, 0.20103699f, 0.09914277f, -0.13339542f, 0.09701444f, 
    -0.11218929f, 0.00836066f, -0.02227992f, -0.11435142f, 0.12051141f, -0.06230281f, 0.08374821f, -0.17952596f, 
    0.05539476f, -0.01896152f, -0.02078545f, -0.00909004f, -0.09004349f, -0.14233996f, -0.03172480f, -0.03832071f, 
    0.02394437f, 0.04983760f, 0.13104340f, 0.07631156f, -0.06508463f, -0.12969595f, -0.17085634f, -0.17449909f, 
    -0.01142268f, -0.20093292f, -0.03270974f, 0.08243628f, -0.05394302f, 0.17338830f, 0.09691859f, 0.07632706f, 
    -0.00324673f, 0.02584215f, -0.05557923f, 0.14966094f, 0.05494856f, 0.10478379f, 0.07203036f, 0.02557998f, 
    0.02281709f, -0.01659271f, -0.02449151f, 0.01024863f, 0.06430911f, 0.13460633f, -0.11209843f, -0.01209298f, 
    -0.03972864f, -0.10288543f, 0.01401093f, 0.05075907f, -0.14548057f, 0.10584345f, -0.05660506f, 0.24756877f, 
    0.03776157f, -0.23309711f, 0.30568647f, -0.06489833f, -0.00057046f, -0.35426965f, 0.12553243f, 0.19173299f, 
    0.10226492f, -0.18465489f, -0.12931466f, -0.06451315f, 0.18064542f, -0.01578524f, -0.04760510f, 0.17798270f, 
    0.02368799f, 0.03928300f, -0.18258390f, -0.03407392f, -0.23867562f, -0.06941264f, 0.04270056f, -0.18217155f, 
    0.17928861f, 0.14670613f, 0.07581315f, 0.12114047f, 0.09146047f, 0.01790651f, 0.15579723f, -0.04413012f, 
    -0.07136515f, 0.07879306f, 0.06647988f, -0.05769122f, -0.18694833f, -0.12221425f, -0.22229651f, 0.00627004f, 
    -0.03695244f, -0.20907760f, -0.05568540f, 0.07661014f, 0.09366211f, -0.11722299f, -0.15648586f, -0.01096220f, 
    -0.03065407f, 0.16745873f, 0.10091086f, 0.16295770f, 0.01565399f, 0.09933183f, -0.12124328f, -0.11783864f, 
    -0.18137240f, 0.13554481f, 0.02009439f, -0.25162771f, 0.05217495f, 0.17349939f, -0.01810062f, 0.09125355f, 
    -0.08390353f, -0.07720926f, 0.30228290f, 0.21280342f, -0.08598454f, 0.05627907f, 0.00202928f, 0.01982194f, 
    0.13414514f, 0.09486728f, 0.02719354f, 0.12333582f, 0.04524464f, -0.06931297f, 0.10647205f, -0.02951002f, 
    0.06234282f, -0.15074669f, -0.04352197f, -0.17768887f, 0.16909908f, 0.02052578f, -0.09811875f, -0.07946390f, 
    -0.00082860f, -0.04488329f, -0.05223987f, 0.09933908f, 0.14363562f, -0.21724431f, 0.15089156f, 0.15806445f, 
    0.19077972f, 0.09893338f, 0.00191602f, -0.10516328f, -0.03328048f, 0.01118242f, -0.01794981f, 0.08498328f, 
    -0.00357448f, -0.01566959f, -0.11488358f, 0.11877161f, 0.02667046f, 0.01756904f, 0.08832367f, 0.04783914f, 
    -0.04622421f, -0.02146303f, 0.04098013f, 0.04998337f, 0.06840585f, -0.15506156f, -0.24278294f, -0.20824631f, 
    -0.03070434f, -0.01870457f, -0.03193202f, -0.05716578f, -0.12106343f, -0.09014336f, -0.04868779f, 0.04508227f, 
    -0.07577521f, -0.09530579f, -0.09328003f, -0.05933240f, -0.02039289f, 0.04390961f, -0.20487875f, -0.05052862f, 
    -0.21700740f, -0.06246518f, 0.08284400f, 0.33267167f, -0.03106643f, 0.05070102f, -0.08476770f, -0.14357036f, 
    -0.17521732f, -0.11578165f, 0.27290910f, -0.02480168f, 0.14300235f, -0.09793559f, 0.04773714f, -0.07584080f, 
    -0.04974772f, -0.10811986f, 0.04586530f, -0.03427795f, -0.02425123f, 0.06481393f, 0.03699418f, 0.03371227f, 
    0.02175085f, 0.06831225f, 0.02287304f, -0.01994403f, -0.00758518f, 0.10958219f, 0.21938176f, -0.23894508f, 
    0.01584478f, -0.03124890f, 0.23254196f, 0.14062914f, 0.08677255f, 0.04592990f, 0.20551771f, -0.04491867f, 
    -0.11779375f, -0.11172400f, -0.01044817f, 0.10587290f, 0.05877807f, -0.04956511f, 0.12457358f, 0.04861189f, 
    0.08171277f, 0.06171618f, 0.12519839f, 0.08770125f, 0.16642532f, 0.04477405f, -0.07129549f, 0.11578636f, 
    0.05919409f, -0.01218771f, 0.12283245f, 0.01874870f, 0.08451995f, 0.09199435f, -0.08964158f, 0.05379229f, 
    0.16617429f, -0.01303571f, 0.00610003f, 0.15309560f, -0.03711400f, 0.22731279f, -0.03004908f, 0.06652957f, 
    -0.04723277f, -0.10534188f, -0.11073939f, 0.36365128f, -0.18870896f, 0.09912264f, -0.02943511f, -0.03127130f, 
    -0.11505146f, -0.06381564f, -0.00353941f, -0.14504769f, -0.01526983f, 0.04120250f, 0.05856676f, -0.04530416f, 
    0.00055748f, -0.00070821f, -0.00256366f, -0.14395146f, -0.30655581f, -0.03553841f, -0.19203557f, 0.11100473f, 
    0.00076213f, 0.18205111f, -0.01562443f, -0.04774485f, -0.15008491f, 0.05258995f, -0.10902719f, 0.04099568f, 
    -0.00632796f, 0.03752162f, 0.18472737f, 0.09227868f, -0.18185230f, 0.01388823f, 0.12650259f, 0.02598152f, 
    -0.35658234f, 0.02017833f, -0.04138459f, 0.03244626f, 0.11904424f, 0.06370651f, 0.18105373f, 0.20255274f, 
    0.16729482f, 0.01567800f, 0.04814661f, -0.11914780f, -0.09675804f, -0.02086226f, -0.02337712f, 0.04304756f, 
    0.08826378f, -0.13169645f, 0.05088775f, 0.02071860f, 0.00460143f, 0.12985055f, -0.03386914f, -0.11440476f, 
    0.17521614f, -0.07375936f, 0.02459315f, 0.03725820f, -0.00668944f, 0.04286074f, -0.00677487f, 0.12156162f, 
    0.03848923f, -0.05827232f, -0.21022543f, -0.18431035f, 0.59866339f, 0.08271677f, 0.07276081f, -0.08953680f, 
    0.10137650f, -0.19034952f, 0.06272458f, -0.06976775f, 0.10305342f, 0.17000313f, 0.03393013f, 0.03460904f, 
    -0.04292877f, -0.03400799f, -0.23299380f, -0.19591376f, -0.00038736f, 0.02092230f, 0.14968900f, -0.08214004f, 
    -0.13811153f, 0.20657116f, -0.10876299f, 0.06420948f, -0.10366188f, 0.00597286f, 0.08333011f, 0.15276220f, 
    -0.18664494f, 0.08837729f, -0.06591961f, -0.05160213f, -0.25287774f, -0.02540087f, 0.08146483f, 0.01429111f, 
    0.03905179f, 0.07237417f, -0.02012843f, 0.07906023f, -0.11222946f, 0.07093555f, 0.03115970f, 0.06462758f, 
    0.20568871f, -0.08008481f, -0.04021138f, -0.05882470f, -0.05313062f, -0.00919061f, 0.12995517f, 0.07387456f, 
    -0.00099023f, 0.08395988f, -0.15700378f, 0.01200931f, 0.11956389f, 0.15510140f, 0.10477030f, 0.00864598f, 
    0.06887640f, -0.02986396f, 0.06729665f, -0.02231277f, 0.06588432f, -0.08828299f, -0.09899879f, -0.04682645f, 
    0.09000319f, 0.05402717f, 0.02375840f, -0.20517442f, -0.05227153f, 0.01564292f, 0.05855307f, 0.04671813f, 
    -0.20620850f, 0.05669551f, 0.03933236f, -0.09495112f, 0.49304211f, -0.06650699f, -0.07892596f, 0.11070015f, 
    0.10165641f, -0.02944968f, 0.04639902f, 0.10323555f, -0.07610543f, -0.07527034f, -0.15445048f, 0.06481269f, 
    -0.04371477f, -0.24229150f, 0.02109314f, 0.05745818f, -0.08017435f, 0.18453710f, -0.11659306f, -0.39526534f, 
    0.05822243f, 0.08603202f, -0.06309143f, 0.03359603f, -0.11780724f, -0.18541317f, 0.01335021f, -0.17665040f, 
    -0.26040515f, 0.07410738f, 0.01432564f, 0.17543791f, -0.02937947f, 0.13525353f, -0.13103750f, 0.05594253f, 
    -0.01613875f, 0.00453811f, -0.04009122f, 0.03819229f, 0.09772366f, 0.07352376f, 0.07359517f, 0.06496333f, 
    -0.01986920f, -0.03439221f, 0.01259720f, -0.05681382f, -0.04971514f, -0.06407253f, -0.06993990f, -0.07500600f, 
    0.04642900f, -0.04033652f, -0.02734932f, -0.02139124f, -0.05528338f, -0.05879737f, 0.00463769f, 0.02793720f, 
    -0.08621638f, -0.04807660f, -0.08794808f, -0.01837229f, -0.03830967f, 0.01135720f, -0.06505936f, -0.02139468f, 
    0.03269773f, -0.01531594f, -0.00889542f, -0.03199733f, -0.07605438f, 0.03081769f, -0.07239112f, -0.08448487f, 
    -0.01055346f, -0.00097209f, -0.01491129f, -0.01120482f, -0.02396616f, -0.03241944f, -0.06140400f, 0.00767273f, 
    -0.03462356f, -0.01289618f, -0.01172635f, -0.04599000f, -0.04730742f, -0.05249008f, -0.04443256f, -0.06103763f, 
    -0.00052988f, 0.01135816f, -0.06790987f, 0.05754682f, 0.01392293f, -0.07094774f, -0.05900684f, 0.00793097f, 
    -0.02237679f, -0.01634013f, -0.06453742f, -0.05900170f, -0.00394884f, -0.08867929f, -0.04085742f, 0.01444642f, 
    -0.05630623f, -0.04203143f, -0.04657309f, -0.06301516f, 0.00655290f, 0.01277832f, -0.08244490f, -0.05362981f, 
    -0.04573669f, 0.02178372f, -0.01193299f, -0.03803026f, 0.00970244f, -0.07482231f, -0.03288921f, 0.05939634f, 
    -0.02761967f, -0.02375032f, -0.03913277f, -0.05814983f, -0.03118617f, -0.06479365f, -0.02297351f, -0.06576192f, 
    -0.09409983f, -0.06614399f, 0.03696461f, -0.00170788f, 0.00358193f, -0.07507434f, 0.02905290f, 0.03431464f, 
    -0.06571974f, -0.05643206f, 0.04871863f, -0.05554475f, -0.05331981f, -0.06020394f, -0.07355978f, -0.02357070f, 
    0.01721964f, 0.03310240f, -0.04496990f, -0.03154775f, -0.05606020f, 0.02110101f, -0.01532568f, 0.00841397f, 
    -0.02658179f, 0.02024980f, -0.04971050f, 0.01079233f, -0.04031983f, -0.02329076f, -0.07111505f, -0.06139660f, 
    -0.04131990f, -0.04973033f, -0.04144168f, 0.02023801f, -0.02206282f, -0.04772870f, -0.07699550f, -0.06523765f, 
    0.02748344f, -0.00008464f, -0.02730725f, -0.03234779f, 0.01297833f, -0.04645461f, -0.00643840f, -0.07911000f, 
    -0.04810041f, -0.02790324f, -0.01701713f, 0.01386729f, 0.03163081f, -0.03775944f, -0.08607825f, 0.03164196f, 
    -0.08749760f, -0.06168112f, -0.10780282f, -0.08729459f, -0.06769879f, 0.01731114f, 0.01088272f, -0.06375715f, 
    -0.03095646f, -0.02327574f, 0.04362857f, 0.01894761f, -0.02470220f, -0.05705123f, -0.09410237f, 0.00754846f, 
    -0.08157608f, 0.00759236f, 0.05438012f, 0.03708653f, -0.01862313f, -0.00442870f, -0.03228842f, 0.04721750f, 
    -0.08323907f, 0.02792039f, 0.01733582f, -0.05089812f, -0.02837169f, -0.04071630f, 0.02583054f, -0.01471587f, 
    -0.03476977f, -0.06142801f, -0.08188310f, -0.06628028f, -0.04756446f, -0.10567931f, 0.01059439f, 0.03257705f, 
    0.01424567f, -0.05581269f, -0.06792226f, 0.02092553f, -0.01441752f, -0.04698860f, -0.03697092f, -0.08264151f, 
    0.03585183f, 0.00084921f, 0.04378368f, 0.00785625f, -0.00724501f, -0.05550871f, -0.07040260f, -0.00137866f, 
    -0.00346342f, -0.06995469f, 0.01479770f, -0.04422659f, -0.07328002f, 0.03357473f, -0.05454066f, -0.00893110f, 
    -0.03924357f, -0.08172291f, -0.03796142f, -0.07074282f, -0.06362616f, 0.05189589f, -0.04474890f, -0.00171888f, 
    -0.02984130f, 0.03299992f, -0.01247734f, 0.03702613f, -0.03161034f, -0.07060146f, -0.00923585f, 0.03214252f, 
    0.02638557f, -0.02439348f, -0.06329677f, 0.05543466f, 0.00667453f, -0.02782359f, 0.03296025f, -0.03648019f, 
    -0.03149058f, -0.04767835f, -0.01116538f, -0.08841353f, -0.01917388f, -0.05039868f, -0.00440431f, -0.09944014f, 
    -0.03431518f, -0.05941761f, -0.03791286f, -0.04044724f, -0.07375729f, 0.02676517f, 0.01169912f, -0.05727035f, 
    -0.01957527f, 0.03201528f, -0.00398988f, 0.06188895f, -0.01263150f, -0.02620441f, 0.00400341f, -0.05316735f, 
    -0.07252320f, -0.08162527f, -0.01876007f, -0.02155525f, -0.02435484f, -0.01198905f, 0.01920008f, -0.01541276f, 
    -0.03588332f, 0.01195258f, -0.04260787f, -0.03544256f, -0.07161020f, -0.00764596f, -0.08903574f, 0.02886835f, 
    0.02553154f, 0.00365600f, -0.04079948f, -0.01474215f, -0.07911626f, 0.02547466f, -0.01693703f, -0.06139920f, 
    -0.03418272f, -0.05766602f, -0.03931306f, -0.00427984f, -0.10369759f, 0.02078110f, -0.00440539f, -0.02659637f, 
    0.09298484f, 0.07185725f, 0.02438167f, 0.03199993f, -0.10355293f, -0.05046255f, 0.04238915f, -0.13683951f, 
    -0.19904499f, -0.27396527f, 0.20636179f, -0.08131950f, -0.09645215f, -0.18520923f, 0.01263361f, 0.00433461f, 
    0.05197121f, -0.08912197f, -0.27406281f, -0.07649755f, 0.09825961f, 0.02981173f, 0.03603019f, 0.01670443f, 
    -0.06833050f, -0.23508996f, -0.02930360f, 0.20905332f, -0.04660912f, 0.07646685f, -0.07540076f, -0.08433716f, 
    -0.15489896f, 0.05327642f, 0.01783122f, -0.12417658f, -0.27087143f, 0.09779971f, 0.02645727f, -0.11225009f, 
    0.14206819f, 0.08010596f, -0.05537513f, -0.05790652f, 0.04452996f, -0.03784633f, 0.09481675f, -0.03774520f, 
    -0.07667013f, 0.18895829f, 0.07102619f, 0.03241963f, 0.08202085f, 0.10744838f, -0.11831062f, 0.11642921f, 
    -0.00751929f, -0.00631239f, -0.01520961f, 0.11281477f, -0.05368263f, -0.00338022f, 0.07074723f, -0.15388145f, 
    0.06042964f, -0.09217184f, 0.06849042f, 0.15928319f, -0.06460077f, 0.09144381f, 0.22027744f, 0.04262567f, 
    -0.18654546f, -0.09705865f, -0.05664779f, 0.12353504f, 0.04646147f, 0.10552561f, -0.04922957f, 0.13623016f, 
    0.11573710f, -0.56988174f, -0.30652937f, 0.10670079f, -0.06271254f, 0.10735053f, -0.02520070f, -0.03610611f, 
    -0.06984518f, 0.00296576f, -0.10358204f, -0.20546615f, 0.28102213f, -0.17889595f, 0.18483075f, 0.12956066f, 
    -0.03897970f, -0.02405974f, 0.05915716f, -0.09916950f, 0.04514934f, -0.09306524f, 0.02013902f, -0.01334220f, 
    0.01711293f, 0.00151712f, 0.06009408f, 0.07662106f, -0.00303213f, -0.10709019f, 0.31403205f, 0.02914175f, 
    0.13441430f, 0.13230494f, -0.03315931f, 0.04372920f, 0.01976165f, -0.04118862f, -0.11383045f, 0.09510515f, 
    0.10576705f, 0.24875171f, -0.06909836f, -0.02388828f, 0.04134796f, -0.11497840f, 0.08455447f, -0.05833972f, 
    -0.04189966f, -0.05295561f, -0.01547522f, 0.07075522f, 0.05810934f, 0.06311468f, -0.00784097f, -0.05315240f, 
    -0.13334744f, -0.15808652f, 0.04800319f, 0.00550420f, 0.11350603f, -0.11766864f, -0.04942920f, 0.04411029f, 
    -0.00930089f, -0.08732395f, 0.06163174f, -0.04122254f, -0.02939107f, -0.20841809f, -0.04635127f, 0.00674766f, 
    0.03862766f, 0.09755244f, 0.12748143f, -0.02963835f, 0.00754204f, 0.00127339f, -0.03450390f, 0.06396808f, 
    0.08361340f, -0.12813565f, -0.38784239f, -0.10737571f, 0.07961575f, 0.38743064f, -0.03876393f, 0.04441089f, 
    -0.10149521f, -0.04820285f, -0.05423362f, -0.23671797f, 0.02651320f, -0.02411884f, 0.04263787f, 0.00626402f, 
    -0.01857148f, -0.03158025f, -0.16871840f, 0.08462888f, -0.13796434f, 0.10756343f, 0.12954696f, -0.12639621f, 
    0.05875557f, -0.03604231f, 0.04590239f, -0.20586219f, 0.07474127f, -0.27216679f, -0.01129639f, 0.02327245f, 
    0.00828165f, -0.05230471f, 0.02399248f, 0.03788431f, -0.08774651f, -0.00683477f, -0.06726865f, -0.07477465f, 
    -0.13928697f, 0.03225372f, 0.08435580f, 0.04180034f, -0.02486008f, 0.03543299f, -0.05638908f, -0.15758111f, 
    0.17891572f, -0.20436633f, -0.03889778f, 0.07218689f, -0.07345445f, -0.10884699f, -0.10444371f, 0.18916357f, 
    -0.09512167f, 0.00632235f, 0.17343926f, -0.05007583f, -0.14085101f, 0.07650692f, 0.16399787f, 0.05270406f, 
    0.17631081f, 0.04341392f, 0.06961113f, 0.02887790f, -0.17794658f, 0.01359808f, 0.16764224f, 0.11247553f, 
    0.20445383f, 0.06177764f, -0.11723889f, -0.11086787f, 0.02056555f, -0.02483244f, -0.03621562f, -0.14612779f, 
    -0.02995567f, 0.00414998f, -0.04835226f, -0.03782207f, 0.18690644f, 0.17930040f, -0.01340503f, 0.17525050f, 
    -0.06438664f, 0.14724375f, 0.05792395f, 0.12772936f, -0.24211903f, 0.19034736f, 0.28625631f, 0.00271106f, 
    -0.08251823f, -0.07572278f, -0.06218385f, -0.13778254f, -0.06372222f, 0.31981626f, 0.24194059f, 0.02811378f, 
    0.14207843f, -0.09750759f, 0.19271545f, 0.08696150f, -0.00038660f, 0.05311893f, 0.06041166f, -0.04926600f, 
    0.16977262f, 0.11392765f, 0.23503821f, 0.11008593f, 0.06616628f, 0.00612196f, 0.01178358f, 0.04480124f, 
    -0.06220433f, 0.11265266f, 0.07675145f, -0.02812442f, 0.03564957f, 0.00973254f, 0.21616454f, 0.00142359f, 
    0.24469256f, -0.13776031f, -0.06516904f, 0.15308189f, -0.09307740f, 0.03398431f, 0.10489705f, -0.08684915f, 
    -0.03643246f, 0.16111906f, -0.42808074f, -0.51524073f, -0.03034415f, -0.07447927f, 0.06249698f, 0.03349009f, 
    -0.02443101f, 0.10750867f, 0.07733786f, -0.11758906f, -0.24222644f, 0.00812193f, 0.02942755f, 0.04995686f, 
    0.05129531f, 0.00486163f, -0.07761755f, -0.27410290f, -0.31898892f, -0.37563214f, -0.02900909f, -0.08144926f, 
    0.07187727f, 0.02324172f, -0.04690356f, -0.08677112f, 0.02351743f, -0.03086980f, 0.20374084f, 0.05215264f, 
    0.05883763f, 0.05086102f, -0.10871721f, 0.02735835f, -0.01879911f, 0.29949260f, 0.10033067f, -0.00962214f, 
    0.08216082f, -0.04378020f, 0.03928679f, 0.11432377f, -0.03117327f, -0.03862912f, 0.35551026f, 0.16086575f, 
    0.19499885f, 0.10399583f, -0.02176387f, 0.04414491f, 0.12268566f, 0.00281838f, -0.09424648f, 0.09173269f, 
    -0.05693578f, 0.03573157f, -0.04094775f, 0.11125093f, -0.19323736f, 0.05871752f, 0.14172816f, 0.00675625f, 
    0.15161054f, 0.22086462f, 0.02609983f, -0.15629998f, 0.00132537f, -0.05479454f, 0.03268163f, -0.03480107f, 
    -0.04114608f, -0.32066482f, -0.04097095f, -0.04308460f, 0.03170684f, -0.08889949f, 0.12626107f, -0.08832823f, 
    0.00312726f, 0.02693123f, -0.11497630f, -0.22376132f, 0.28073335f, 0.07200437f, 0.25762150f, 0.17646211f, 
    0.03189827f, -0.14113620f, 0.02989355f, 0.04935350f, -0.11511447f, -0.16813374f, -0.02378055f, -0.06021526f, 
    0.13053539f, 0.04300573f, -0.15857582f, 0.03533978f, -0.30385011f, 0.22896670f, -0.06207027f, 0.03367726f, 
    -0.02185679f, -0.02858237f, 0.08631498f, 0.13370290f, -0.09729806f, 0.18195899f, -0.01661361f, 0.08533398f, 
    -0.10509348f, 0.12979898f, -0.12821992f, 0.12249837f, 0.14389177f, -0.01875728f, -0.28589889f, 0.11042287f, 
    0.15989709f, -0.12690036f, 0.09954942f, 0.00712091f, 0.01078426f, 0.16703124f, -0.05216762f, 0.07989856f, 
    -0.09689613f, 0.12042591f, 0.04210100f, 0.08539219f, -0.07552233f, -0.07579121f, -0.03635817f, 0.04146384f, 
    0.20993908f, 0.04666187f, 0.27657542f, 0.06589688f, 0.03196653f, -0.07132860f, 0.01641898f, -0.00779814f, 
    0.05240142f, 0.13449505f, -0.35485980f, -0.17204922f, 0.06085403f, 0.05814084f, 0.08247507f, -0.00781129f, 
    0.02684470f, 0.08683211f, 0.13220650f, -0.29039595f, -0.04031944f, 0.01582260f, 0.07793234f, -0.02774565f, 
    -0.01609755f, 0.01455891f, 0.00278061f, 0.04400148f, 0.05222621f, -0.11374622f, 0.09723049f, -0.00960519f, 
    -0.12637269f, -0.05588873f, -0.16341016f, 0.01643322f, -0.21485305f, -0.12035336f, -0.19458874f, 0.02432527f, 
    0.12946340f, -0.07312997f, 0.22139932f, -0.12613457f, -0.09629366f, -0.22055764f, -0.13864565f, 0.04574710f, 
    -0.03925312f, -0.02277224f, -0.00233914f, -0.07854157f, -0.01095376f, 0.15942784f, 0.04671478f, 0.05713776f, 
    -0.23548812f, -0.05111220f, 0.07757147f, 0.07517140f, 0.00602117f, 0.05195942f, -0.13134912f, 0.18388169f, 
    -0.16170841f, 0.03804958f, 0.06174320f, 0.01261017f, 0.02404412f, -0.04833245f, -0.03102721f, -0.21827535f, 
    0.09457070f, -0.34726280f, 0.26896611f, -0.13484795f, -0.02356789f, -0.06210452f, 0.04276738f, 0.04353683f, 
    0.06092408f, 0.22191595f, 0.09931213f, 0.08059748f, -0.06223617f, 0.02725040f, -0.03029141f, -0.13946809f, 
    -0.09925566f, 0.12798224f, 0.45993903f, 0.44739583f, 0.37773716f, -0.05512431f, -0.15433772f, -0.05355181f, 
    0.03797689f, -0.06210758f, 0.11527719f, 0.08553325f, 0.16887759f, 0.36420727f, -0.04407372f, -0.02924153f, 
    -0.07509221f, 0.08124517f, -0.06694224f, 0.04477215f, -0.22340663f, -0.17106088f, -0.03918452f, -0.02431551f, 
    -0.18365857f, -0.02539391f, -0.03733005f, -0.23051307f, -0.08447058f, 0.23285253f, 0.17531538f, -0.04843387f, 
    0.12457322f, -0.01649089f, 0.12075773f, -0.05616217f, -0.02726176f, -0.19456162f, 0.20460410f, -0.04380853f, 
    0.02712415f, 0.07085304f, -0.02289655f, 0.01309752f, 0.07920660f, 0.01310484f, 0.02810736f, -0.13129584f, 
    0.07105748f, -0.13559762f, -0.04529103f, 0.10798973f, -0.09906573f, 0.06908552f, 0.06916169f, 0.02473043f, 
    0.13807303f, 0.03422778f, 0.07428528f, -0.04830793f, -0.09546299f, 0.10226558f, 0.14570330f, 0.01655682f, 
    0.29442662f, 0.03734307f, -0.14751215f, 0.09199831f, -0.19210926f, 0.10403827f, 0.12615874f, 0.02903664f, 
    0.00757007f, 0.28774363f, -0.01828754f, -0.08510030f, -0.07723092f, -0.16020271f, 0.02739450f, 0.20339285f, 
    0.08263314f, 0.17637849f, 0.32988715f, -0.36749738f, 0.07204662f, 0.29503295f, -0.05025769f, -0.00702268f, 
    0.11423015f, -0.10860269f, -0.00308360f, -0.01592769f, 0.15775311f, 0.19904655f, 0.12358149f, 0.05507569f, 
    -0.06956355f, 0.05984984f, 0.00673612f, 0.10979021f, 0.09565498f, 0.20807970f, 0.17630953f, 0.04758350f, 
    -0.13778453f, 0.07178983f, -0.07784312f, 0.04575280f, -0.11707180f, -0.20315492f, 0.20854844f, 0.16018620f, 
    0.11287434f, 0.05239661f, -0.04847117f, -0.10803688f, 0.14953762f, -0.03838298f, -0.14128560f, 0.07686912f, 
    -0.17142841f, -0.09171661f, 0.06140254f, -0.10350928f, -0.09536488f, -0.16351204f, -0.10989655f, -0.43074167f, 
    0.28403589f, 0.10852917f, -0.04488735f, -0.00028773f, -0.03400281f, 0.04127303f, -0.00334978f, -0.00383314f, 
    -0.21756871f, 0.16990681f, 0.14587240f, 0.01425764f, 0.00178026f, 0.03469038f, -0.06230764f, 0.06810982f, 
    0.11228549f, 0.07712113f, 0.00788205f, 0.03499774f, 0.24672803f, 0.05649719f, 0.11771304f, 0.20742272f, 
    -0.03879635f, 0.13675176f, 0.14850096f, -0.01995820f, 0.07689968f, -0.08483835f, -0.01464527f, 0.04350409f, 
    -0.12462004f, -0.05057395f, -0.15436558f, -0.19544064f, -0.12753385f, -0.29787380f, 0.02310983f, 0.19536202f, 
    0.06130670f, -0.09205972f, -0.01624920f, -0.00789620f, 0.05693558f, 0.16774695f, 0.03192344f, -0.05852128f, 
    0.01436253f, 0.01878778f, 0.04963318f, -0.06639753f, -0.10124277f, -0.25778311f, -0.11924956f, 0.15024424f, 
    -0.05073050f, -0.06415619f, 0.18657619f, -0.05214230f, -0.04935869f, -0.25908226f, -0.23041117f, -0.00513994f, 
    0.15984979f, 0.17922726f, -0.08030819f, 0.00124804f, 0.00007693f, 0.06657240f, -0.02127588f, -0.09260914f, 
    0.06478959f, 0.13274227f, 0.15997148f, 0.00587651f, -0.03177669f, -0.02988087f, 0.06016056f, 0.11544719f, 
    0.03508817f, 0.03700669f, 0.05717861f, 0.00664144f, 0.09416786f, 0.10898969f, -0.15771596f, -0.03947556f, 
    -0.04371461f, -0.12009887f, -0.00418738f, -0.05254162f, -0.08318924f, -0.04895136f, 0.11405481f, -0.00953784f, 
    -0.09429563f, 0.07345711f, -0.24075958f, 0.08872336f, 0.06360391f, 0.12577528f, -0.04256344f, -0.07995086f, 
    -0.08945315f, 0.16925323f, 0.09677742f, 0.11141062f, -0.25951940f, -0.14560980f, -0.02285888f, 0.15321147f, 
    0.00311867f, 0.06697237f, -0.21761273f, 0.10572740f, -0.00359777f, -0.11817124f, 0.09520990f, 0.18744692f, 
    0.09273516f, -0.02379181f, 0.02093459f, -0.06441218f, 0.21180254f, 0.21501665f, 0.06972965f, 0.12475149f, 
    -0.12903528f, -0.07968607f, 0.00199765f, 0.02873883f, 0.11171471f, -0.19933976f, -0.27086249f, 0.23550011f, 
    0.08939510f, -0.16640720f, -0.06062584f, 0.01368732f, -0.08759260f, -0.02560558f, 0.04298118f, -0.33425224f, 
    -0.23011318f, -0.27696741f, -0.10677838f, 0.06625310f, 0.11730657f, -0.15610045f, -0.06520504f, -0.01968699f, 
    -0.09485232f, 0.32901421f, 0.24844511f, -0.02024765f, 0.20708095f, 0.06278297f, 0.12879679f, 0.14287473f, 
    -0.06044871f, 0.02140996f, 0.30044171f, 0.24905592f, 0.00369076f, 0.01316254f, -0.10022778f, -0.05794936f, 
    -0.02712411f, 0.07753266f, -0.01937079f, -0.27243039f, -0.15788040f, -0.03706233f, 0.10701198f, -0.07340964f, 
    -0.11105248f, -0.08284777f, -0.05797546f, -0.07666288f, -0.15901734f, 0.09586804f, -0.00115355f, -0.07841282f, 
    -0.07131618f, 0.16103807f, 0.02809980f, 0.08165473f, 0.18863721f, -0.14442295f, 0.10098822f, -0.00438726f, 
    -0.01562137f, 0.04661728f, -0.14443289f, 0.07259257f, 0.01871560f, 0.13891786f, -0.05068292f, -0.23487976f, 
    -0.00264088f, -0.03382914f, -0.03513794f, -0.08264530f, 0.02184615f, -0.03123117f, 0.20797448f, 0.05919662f, 
    0.06022406f, 0.01266750f, -0.00303667f, 0.03914275f, 0.10791630f, 0.07288255f, -0.10884545f, -0.04063796f, 
    -0.10579654f, 0.00009047f, -0.00754419f, 0.11858028f, 0.07740909f, 0.15776563f, -0.05423642f, 0.11030270f, 
    0.20560212f, -0.23781160f, -0.15592664f, 0.12205433f, 0.07866324f, 0.12112240f, 0.18284176f, -0.15049720f, 
    -0.07675771f, 0.34029716f, -0.03769166f, 0.03022550f, -0.11698552f, -0.05830140f, -0.04990701f, 0.02510568f, 
    -0.04472862f, 0.02662327f, 0.05081056f, -0.47600585f, -0.12269387f, -0.08218393f, 0.15348752f, 0.12835950f, 
    -0.04048381f, -0.18786848f, -0.03204311f, -0.06816847f, -0.09287603f, 0.02264705f, -0.07803917f, -0.03815172f, 
    0.04342308f, 0.05849012f, -0.06134656f, 0.12914449f, -0.03951079f, -0.25995493f, -0.08662020f, 0.02045323f, 
    -0.12593257f, -0.02616466f, -0.05103657f, -0.17068815f, 0.03865752f, 0.08159401f, -0.21710794f, 0.04185611f, 
    0.10636995f, 0.17498969f, 0.10672052f, -0.04413017f, 0.12306923f, 0.02250585f, 0.18983787f, -0.00598592f, 
    -0.03956258f, -0.01234337f, -0.08074177f, 0.03019026f, 0.02760786f, -0.05566020f, 0.05152582f, -0.15515040f, 
    -0.07790219f, -0.02354507f, -0.13744019f, -0.07758466f, -0.16548795f, 0.01682353f, -0.05455325f, -0.02345610f, 
    -0.00204334f, 0.18479306f, 0.07958833f, -0.07518583f, -0.07347102f, 0.05690786f, 0.00237946f, 0.15156934f, 
    -0.04881756f, -0.01975287f, 0.04628893f, 0.30831912f, -0.03255249f, -0.01690771f, -0.04882974f, 0.04176413f, 
    0.11143535f, 0.14758430f, -0.00792913f, -0.04626168f, -0.03560172f, 0.07635332f, 0.03643655f, -0.02192994f, 
    -0.01543185f, -0.18247072f, -0.19890918f, 0.03084516f, 0.16732962f, 0.01864623f, 0.01802214f, 0.12957174f, 
    0.15031767f, -0.02214812f, 0.02538135f, 0.06536093f, 0.12216729f, -0.10776931f, -0.19799350f, -0.03835356f, 
    -0.15700006f, -0.02008292f, -0.06904285f, 0.10183260f, 0.05696239f, -0.03241729f, -0.03689322f, 0.05185378f, 
    -0.08030979f, 0.03020798f, 0.13313457f, 0.01143490f, 0.09996801f, -0.02848771f, -0.05954161f, -0.08972929f, 
    0.06441789f, -0.11652812f, -0.01380452f, -0.01576823f, -0.08624609f, 0.07840026f, -0.04242538f, 0.04058654f, 
    0.25504363f, 0.00338898f, -0.06241300f, -0.01231489f, 0.06851438f, -0.11558323f, 0.08274607f, 0.15092483f, 
    0.11745013f, -0.06205294f, 0.02883304f, 0.06915942f, 0.08251182f, 0.07658671f, -0.01263649f, -0.07773668f, 
    -0.18615848f, 0.01040710f, 0.43110707f, 0.32269192f, 0.07212713f, 0.00969848f, -0.04571700f, 0.10054976f, 
    0.17156145f, 0.03823388f, 0.03144740f, 0.01865927f, -0.09692225f, -0.08935159f, -0.04185438f, 0.01061499f, 
    0.05840328f, 0.14882380f, 0.09738293f, 0.02590271f, -0.01604382f, -0.31494221f, 0.01933757f, 0.04465740f, 
    0.07759655f, 0.18108198f, 0.12196627f, -0.18039273f, -0.10022251f, -0.06777460f, -0.15841469f, 0.02453232f, 
    0.01123615f, 0.10972569f, 0.07231800f, 0.08558200f, 0.05305299f, -0.02355580f, -0.07001445f, -0.04360688f, 
    0.00587320f, -0.18913536f, -0.02047917f, -0.07093376f, -0.09392024f, 0.06751195f, 0.14883237f, -0.13645284f, 
    0.03903019f, 0.05951285f, -0.01859673f, -0.06486282f, -0.08571187f, 0.20937072f, 0.13595937f, -0.05806940f, 
    0.11524913f, -0.05100802f, -0.21377888f, 0.10087205f, 0.13309088f, 0.05035170f, -0.09856527f, 0.08261797f, 
    -0.18066892f, 0.00392143f, -0.11411615f, -0.01618279f, 0.09036843f, 0.14647852f, 0.07773791f, -0.00322680f, 
    0.12162054f, -0.14201581f, 0.02665723f, -0.36448452f, -0.22626427f, -0.08817022f, -0.03847397f, 0.03329292f, 
    -0.10899880f, 0.07596715f, -0.06029873f, 0.16645132f, -0.17372771f, -0.06504393f, 0.09099188f, 0.23199016f, 
    0.09475469f, 0.06666507f, 0.00062704f, -0.23219566f, -0.12130322f, -0.06409382f, 0.15425497f, 0.08452073f, 
    0.17590563f, 0.27816287f, -0.07724997f, 0.25381443f, 0.23083682f, 0.06321594f, 0.18748932f, 0.10959540f, 
    -0.02854748f, -0.01570346f, -0.04341234f, 0.06242817f, 0.05963217f, 0.00998505f, 0.33200896f, 0.11680350f, 
    0.17734177f, -0.00833376f, 0.08340573f, -0.05713367f, 0.02440115f, 0.09247838f, 0.16149721f, -0.11028969f, 
    -0.09993871f, -0.17641193f, -0.12157237f, 0.07388690f, 0.00238770f, 0.05544167f, 0.03193914f, -0.07705013f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.26276308f, -0.03661966f, 0.23866394f, 0.03437304f, 0.26964915f, 0.26242810f, 0.03377046f, 0.08772960f, 
    -0.11659483f, 0.13191989f, 0.06354244f, -0.05498823f, 0.00163874f, -0.00161599f, -0.00559693f, 0.12176466f, 
    -0.03316993f, -0.06614966f, 0.03559417f, 0.02131849f, 0.01046325f, 0.02093733f, 0.23584409f, 0.06110721f, 
    -0.06678691f, -0.06323424f, 0.07890221f, -0.02772732f, 0.11044372f, 0.04092832f, 0.04735758f, 0.09890991f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16415738f, 0.15236598f, 0.06131408f, 0.13083968f, -0.11183105f, -0.11955537f, 0.02153299f, 0.19165131f, 
    0.34620813f, -0.21443787f, 0.20221815f, 0.00898718f, -0.00159826f, 0.13157955f, -0.05479489f, -0.11157077f, 
    0.20165172f, 0.02449934f, -0.04733780f, -0.13046956f, 0.09434848f, 0.00254836f, 0.14215702f, 0.19001749f, 
    0.35999143f, 0.40073156f, -0.01363423f, -0.06833230f, -0.26870400f, 0.11988913f, -0.08904371f, 0.04260682f, 
    -0.11974488f, 0.10986704f, -0.45285663f, 0.04496978f, 0.13258679f, -0.17076211f, 0.05276872f, 0.12828088f, 
    -0.02783738f, 0.16883253f, 0.34189850f, 0.00552164f, 0.19054967f, -0.02469245f, 0.02043935f, 0.09292310f, 
    0.16930227f, 0.15398282f, -0.16139176f, -0.15898976f, 0.01056152f, -0.07620294f, -0.04811436f, -0.21043427f, 
    -0.02252060f, 0.11565428f, -0.19312195f, 0.07117833f, 0.31951833f, 0.24445960f, -0.04879109f, -0.08239361f, 
    0.36774120f, -0.09445534f, -0.27089125f, 0.04951184f, 0.05915407f, -0.20921324f, 0.00032235f, 0.06390364f, 
    0.46663648f, -0.27289844f, -0.14399514f, -0.15817207f, -0.16676207f, 0.03284580f, -0.09776095f, 0.02715581f, 
    0.18580933f, 0.03206613f, 0.05402577f, 0.21613266f, 0.09920548f, -0.15151328f, 0.05669958f, 0.39114362f, 
    -0.08161439f, 0.33936843f, -0.08989451f, -0.17015727f, -0.20709595f, -0.21102014f, 0.27183494f, 0.17750682f, 
    0.19303614f, -0.05166949f, -0.02340256f, 0.09020948f, 0.04669501f, 0.04671009f, -0.15528081f, 0.03627620f, 
    -0.19294707f, 0.00510028f, 0.10330831f, 0.16847228f, -0.00019758f, -0.08996161f, 0.14420900f, 0.07379522f, 
    -0.07730541f, 0.08734488f, 0.12083019f, -0.00232257f, 0.12306233f, -0.04198554f, -0.01782904f, -0.25783166f, 
    -0.06964895f, -0.25797540f, 0.12765481f, -0.04086852f, 0.37855324f, -0.25049201f, 0.13954198f, 0.04064360f, 
    -0.11198315f, -0.09547509f, 0.28766912f, -0.10027459f, 0.22081807f, 0.51603985f, 0.11457244f, 0.13597420f, 
    -0.30093068f, 0.37140763f, -0.19342983f, 0.09220314f, -0.06868961f, -0.08088090f, -0.10092343f, -0.27649486f, 
    -0.24815825f, 0.04178802f, 0.16531181f, 0.09935531f, -0.04875550f, -0.12824345f, -0.21684405f, -0.23386911f, 
    0.16845101f, -0.16078265f, -0.16157550f, -0.05407102f, 0.10828228f, 0.07930217f, 0.12265860f, 0.02914664f, 
    -0.12552238f, 0.00146663f, 0.05641914f, -0.02506236f, 0.01934380f, -0.13824396f, 0.00729444f, -0.25213516f, 
    -0.02495779f, 0.19682761f, -0.00726053f, -0.01010538f, 0.01289348f, 0.05097352f, -0.16014907f, 0.03276688f, 
    -0.06413169f, 0.05028799f, -0.03241543f, 0.17644371f, -0.15809278f, -0.08119635f, -0.00619138f, -0.03354796f, 
    -0.04004136f, -0.15497522f, -0.10113931f, 0.15182477f, -0.05728063f, 0.17488287f, -0.06618255f, -0.05146565f, 
    -0.05360208f, -0.03793713f, -0.16065793f, 0.14555521f, 0.17457403f, -0.23631941f, 0.01189688f, -0.23884849f, 
    0.25542334f, -0.12321908f, 0.00127292f, -0.25806117f, -0.14958277f, 0.10570680f, -0.09592663f, -0.20880368f, 
    0.50162220f, -0.00655929f, 0.10103884f, 0.16906171f, -0.15632480f, -0.05804057f, 0.18772651f, 0.39636022f, 
    -0.21430686f, 0.30740681f, -0.07151080f, -0.06433653f, -0.23746808f, 0.09278189f, 0.02892363f, 0.25846612f, 
    -0.45665953f, 0.11502098f, -0.06474323f, 0.09428268f, 0.17747197f, -0.53750008f, 0.17556052f, -0.15461883f, 
    0.43465289f, -0.03337193f, 0.35966223f, 0.34112754f, 0.09246363f, 0.06232937f, 0.00455479f, -0.08395066f, 
    0.07170833f, 0.05085865f, 0.03141819f, 0.20637378f, -0.00787266f, -0.08361764f, -0.43162248f, 0.33657920f, 
    0.19201292f, 0.08317184f, 0.14404485f, 0.01845182f, 0.05677343f, -0.19227776f, -0.21588789f, 0.07218465f, 
    0.23694935f, -0.02211666f, 0.03249802f, 0.15156959f, 0.01994488f, 0.08096599f, 0.05755479f, 0.09404494f, 
    0.48593819f, 0.05426885f, -0.18935974f, -0.05230793f, 0.06349955f, -0.10359770f, 0.00754875f, 0.30327553f, 
    -0.14918166f, 0.13503151f, 0.11229024f, 0.11102024f, 0.12678725f, -0.21090993f, -0.15802632f, -0.27916074f, 
    0.29025856f, -0.09898532f, -0.04606934f, -0.08039082f, -0.05262262f, -0.06092406f, -0.00860969f, -0.02553390f, 
    0.01165106f, -0.07690999f, -0.36574200f, 0.11877267f, 0.17784414f, 0.21176724f, 0.07967355f, 0.15939084f, 
    -0.39140832f, 0.05926902f, 0.37488168f, 0.19033353f, 0.12840602f, 0.12010936f, -0.15811332f, -0.14985438f, 
    -0.08063836f, 0.00239835f, -0.17703339f, -0.07874648f, 0.12938756f, 0.03994663f, -0.42737719f, -0.31986800f, 
    -0.10961885f, 0.00332662f, -0.09332184f, -0.19373697f, 0.27584624f, 0.03552272f, 0.15216596f, 0.10383669f, 
    -0.10870036f, -0.13488694f, 0.17469151f, -0.13324623f, 0.07141370f, 0.39721254f, -0.07560098f, 0.20161782f, 
    -0.15570211f, 0.28466821f, -0.16549075f, 0.22501010f, -0.05310839f, 0.10346091f, -0.12296962f, -0.18488924f, 
    -0.37831086f, -0.15473293f, -0.16072935f, -0.00391557f, -0.13793059f, 0.12059698f, -0.08841931f, 0.16081154f, 
    -0.37244529f, -0.28424665f, -0.22971176f, 0.00244145f, 0.35473123f, 0.35290819f, -0.13854410f, 0.07535248f, 
    -0.14849091f, 0.14453211f, 0.36876729f, 0.04789682f, 0.09715138f, 0.37708902f, -0.01835712f, -0.15952659f, 
    -0.09986525f, 0.23217985f, -0.23593073f, 0.17203934f, -0.03816205f, 0.08714162f, -0.04767213f, 0.03652776f, 
    -0.27783838f, 0.06317145f, -0.16356024f, 0.11479881f, -0.09152314f, 0.08285640f, 0.11201750f, 0.15690945f, 
    -0.20765004f, -0.22417779f, -0.14947616f, 0.17535904f, -0.03729588f, 0.37152293f, -0.11387667f, 0.11765343f, 
    0.36367926f, 0.08108526f, 0.21191309f, -0.12983671f, 0.10555551f, 0.41641140f, 0.06107738f, -0.02719771f, 
    0.25384727f, -0.02161421f, -0.22767656f, -0.08982385f, 0.17500329f, -0.11315034f, -0.16164272f, -0.08502618f, 
    0.12899134f, 0.16625834f, 0.01132150f, -0.07567379f, 0.10400365f, 0.03532437f, 0.02449839f, 0.16912740f, 
    -0.37157312f, 0.11791793f, 0.06473200f, -0.01366776f, -0.13381781f, -0.22084326f, 0.24769114f, 0.05823759f, 
    0.29147989f, -0.14680748f, -0.11801617f, -0.06187348f, 0.16560917f, -0.12792692f, -0.08775916f, 0.03635643f, 
    0.01004765f, -0.13657083f, -0.16489865f, -0.05192276f, -0.11120027f, -0.03342834f, -0.00048407f, 0.30029058f, 
    0.09573239f, -0.05817281f, -0.17643593f, -0.16462016f, 0.02596676f, -0.05133120f, -0.20132273f, -0.36315930f, 
    -0.16249742f, 0.19462679f, 0.12071258f, 0.12557307f, -0.08816135f, -0.34214523f, 0.19094785f, 0.34502667f, 
    0.13813624f, -0.12514040f, -0.20754382f, -0.12197850f, -0.35403493f, -0.04125187f, 0.00947430f, -0.04505691f, 
    0.06448300f, 0.01945510f, -0.35525155f, -0.04189915f, -0.14265636f, 0.05553212f, -0.14820366f, -0.07795898f, 
    -0.00493624f, 0.13248803f, -0.03167113f, 0.04930438f, -0.07410811f, 0.06687799f, 0.05658120f, -0.12313925f, 
    -0.10805731f, -0.19789675f, 0.17504154f, -0.16587286f, -0.13959229f, 0.13430588f, -0.39771330f, -0.30410114f, 
    -0.15419406f, 0.13393965f, 0.20794028f, 0.09274040f, 0.35249317f, 0.00755060f, 0.05177927f, 0.04605247f, 
    -0.17770477f, 0.06187336f, 0.17978655f, 0.18177909f, 0.16259995f, 0.15625270f, -0.06205748f, -0.14012541f, 
    0.06007341f, 0.11836236f, 0.05998310f, 0.35701260f, -0.04712872f, -0.15285398f, -0.02147241f, 0.41071451f, 
    -0.17461072f, -0.08910342f, -0.07734772f, -0.02432531f, 0.19438508f, -0.08494965f, -0.25678807f, -0.00923637f, 
    -0.29959673f, -0.09995703f, -0.03789702f, 0.02258757f, -0.12492126f, -0.35724962f, 0.03666970f, 0.04583203f, 
    0.17629763f, -0.38550168f, 0.31916165f, 0.06800548f, 0.05290097f, 0.10359111f, -0.11771555f, -0.08663310f, 
    -0.26490140f, 0.02493721f, 0.06049234f, 0.23558593f, -0.05602174f, 0.16764405f, -0.22683163f, 0.08859448f, 
    -0.17537275f, 0.28441575f, -0.19940677f, -0.03056186f, 0.21652035f, 0.21626773f, 0.12033241f, -0.17177945f, 
    -0.20418157f, 0.08974230f, -0.09512924f, -0.11873416f, 0.02007615f, -0.18900564f, 0.17299625f, 0.37847102f, 
    0.15751739f, -0.09355602f, 0.15183045f, -0.05116265f, -0.04400013f, -0.06043057f, 0.12544696f, 0.00128774f, 
    0.10053595f, 0.03909466f, -0.08533578f, 0.38361579f, 0.01789391f, -0.10596811f, 0.29854351f, 0.36850452f, 
    0.21117160f, 0.07329668f, 0.07845274f, 0.12041692f, 0.13986129f, 0.06661994f, -0.16799831f, -0.05154030f, 
    -0.18982863f, 0.14938942f, -0.29617807f, 0.13411203f, -0.12440668f, 0.25131699f, 0.16682504f, -0.18413289f, 
    0.61677307f, 0.10328148f, -0.11755019f, 0.15164994f, -0.13078383f, -0.14500767f, 0.08868391f, -0.18346095f, 
    -0.04754372f, 0.12986092f, -0.13612792f, 0.30524215f, -0.12971437f, 0.12655745f, 0.06141286f, 0.23969845f, 
    0.24065691f, 0.26787627f, -0.06949945f, -0.00492478f, -0.06434425f, 0.27486512f, 0.15253899f, 0.16620529f, 
    -0.00813759f, 0.14474313f, -0.35886288f, 0.08071096f, 0.26797172f, -0.03615655f, 0.12321597f, -0.25230542f, 
    -0.29967809f, -0.09163673f, 0.14976974f, -0.42286819f, -0.14995116f, 0.02906891f, -0.10117012f, 0.34086004f, 
    -0.00783940f, 0.06329643f, -0.15842833f, -0.12407887f, -0.17608161f, -0.00106969f, -0.30933097f, -0.12605220f, 
    -0.13570842f, 0.24772896f, -0.38271934f, -0.14104919f, 0.13918814f, 0.15354724f, 0.37921706f, 0.09314025f, 
    -0.13151489f, -0.07211136f, -0.08878864f, 0.02049150f, -0.00120723f, 0.01578235f, 0.12200855f, -0.14327109f, 
    0.05624253f, -0.16388765f, -0.04794056f, -0.04389710f, -0.18123947f, -0.02399968f, 0.08740054f, 0.07662365f, 
    -0.01089080f, 0.15625800f, -0.10249902f, -0.03786101f, 0.14853127f, 0.15332231f, -0.05433910f, -0.05954964f, 
    -0.18672340f, -0.19475128f, 0.01245234f, -0.08253372f, 0.14233194f, -0.12186066f, 0.11941628f, -0.06577719f, 
    0.43881136f, 0.01841345f, 0.69949555f, -0.10907400f, 0.18125126f, 0.29376751f, 0.06331696f, 0.04053395f, 
    -0.47890723f, 0.07045255f, -0.21952493f, -0.12098031f, -0.02448876f, -0.16636278f, -0.04263230f, -0.02348330f, 
    -0.57877582f, -0.09162680f, 0.12238483f, 0.01311129f, 0.05198691f, -0.13330998f, 0.15644895f, 0.23671684f, 
    0.14044902f, -0.18828839f, -0.15433249f, -0.00446716f, 0.12268077f, -0.41177371f, -0.06339826f, 0.10343191f, 
    -0.17279066f, 0.12993711f, 0.02033436f, 0.14030348f, 0.26663181f, -0.28968507f, -0.08772850f, 0.26888439f, 
    -0.28802872f, -0.11373883f, 0.26046294f, 0.07301222f, 0.00027980f, -0.11531367f, 0.14695702f, 0.16665362f, 
    -0.10725991f, -0.12316811f, -0.09455976f, 0.21584061f, -0.01781935f, -0.09073768f, -0.39592850f, 0.22481695f, 
    0.20553629f, 0.28638157f, 0.02921277f, -0.09842139f, 0.08006983f, -0.34677544f, -0.31554407f, -0.03694256f, 
    -0.27034822f, 0.09773125f, 0.34425190f, 0.07482839f, 0.14837034f, -0.80888903f, -0.12927388f, -0.20146281f, 
    0.27547458f, -0.20783396f, 0.03836199f, 0.07735406f, -0.13859400f, -0.08955333f, -0.07510293f, 0.02148548f, 
    0.07032672f, -0.06145340f, -0.10377017f, 0.17746073f, -0.17738135f, -0.07925337f, -0.26235139f, 0.51916873f, 
    -0.01755213f, 0.05293638f, 0.19252369f, 0.09491291f, 0.08406139f, -0.48209032f, -0.11032003f, -0.19338776f, 
    0.22264899f, -0.09736407f, -0.23964797f, 0.15093467f, -0.12120265f, -0.12852344f, 0.16625628f, 0.21840876f, 
    0.36266610f, 0.19714250f, 0.09031188f, -0.11948623f, 0.05730508f, 0.04059638f, 0.17589220f, 0.17142496f, 
    -0.00892233f, -0.05237018f, 0.12380211f, 0.14263333f, -0.02733094f, -0.17758512f, -0.17489877f, 0.28766483f, 
    -0.32642874f, 0.01543128f, 0.01765318f, 0.03753120f, 0.37763527f, 0.43648180f, 0.14248939f, -0.17398122f, 
    0.31884176f, -0.10701948f, 0.34747982f, 0.12978716f, 0.06829595f, -0.01219142f, -0.09834554f, 0.15100226f, 
    -0.22792976f, 0.09488134f, -0.00209163f, 0.22733496f, -0.08974036f, -0.16571398f, -0.08356866f, 0.23460194f, 
    -0.22525266f, -0.04816884f, 0.17012514f, 0.02788061f, 0.08706449f, -0.03667604f, -0.06476007f, -0.28611219f, 
    -0.01100118f, -0.19455922f, -0.10444129f, -0.00747209f, 0.08276320f, -0.38374817f, 0.04001154f, 0.19181007f, 
    0.12045375f, 0.12937178f, -0.22013851f, 0.07296952f, 0.05810893f, -0.06442648f, 0.04928268f, -0.07165463f, 
    0.17614080f, -0.22819392f, -0.11936184f, 0.05025449f, 0.15288340f, -0.03627931f, 0.03097997f, 0.13318561f, 
    0.13955073f, 0.12872756f, -0.06012818f, 0.32453722f, -0.13465263f, 0.06374305f, -0.30442080f, -0.13110718f, 
    0.08533097f, 0.26139241f, -0.08425735f, 0.09217576f, -0.22359513f, 0.14563864f, 0.01876655f, 0.30451873f, 
    -0.01591401f, 0.13972582f, 0.56184030f, 0.05802659f, 0.04143529f, 0.14411791f, 0.00065332f, 0.04688779f, 
    -0.09395566f, -0.16003045f, 0.04278617f, -0.13311143f, -0.13462050f, 0.06058523f, 0.06142250f, 0.14802222f, 
    0.11206076f, -0.15349331f, 0.10951264f, -0.07440662f, -0.05084651f, 0.13083629f, 0.12972185f, -0.14300714f, 
    0.24627845f, -0.04814921f, 0.08786800f, -0.01778653f, 0.01001633f, -0.40737191f, -0.02382861f, 0.26702747f, 
    0.12526743f, -0.17184231f, 0.37834194f, 0.10311521f, -0.06585548f, -0.02891465f, -0.15037365f, 0.00044908f, 
    0.03129390f, 0.06964225f, 0.00774036f, 0.06006231f, -0.16212484f, 0.06846929f, 0.03376444f, 0.01537383f, 
    -0.03199887f, -0.10806055f, 0.12378945f, 0.07633056f, 0.01456663f, -0.03218504f, 0.26992089f, 0.26713178f, 
    -0.08002876f, -0.21713327f, 0.01481924f, -0.07756738f, 0.22792940f, -0.05057128f, -0.09228108f, -0.06884862f, 
    -0.15778737f, 0.14451283f, 0.36621609f, 0.12403138f, 0.03244995f, 0.08957437f, 0.11452532f, -0.17487328f, 
    0.28822204f, -0.02343071f, 0.10936920f, -0.17199361f, -0.12481318f, -0.11839729f, -0.15033314f, 0.01066376f, 
    0.18764292f, 0.15595929f, 0.09361464f, 0.01907748f, 0.08392278f, 0.17138959f, 0.22858468f, 0.22216877f, 
    0.05425030f, 0.18605773f, 0.21612427f, -0.07322321f, -0.09977670f, 0.09576730f, -0.15988758f, -0.09399677f, 
    -0.15748985f, -0.07710741f, 0.09075192f, 0.15900166f, -0.10453768f, 0.28470173f, 0.15521601f, -0.20637137f, 
    0.13277519f, 0.17247266f, 0.23983102f, -0.05116770f, -0.06163711f, 0.13939317f, -0.11506427f, -0.16192698f, 
    0.14224373f, -0.08641829f, 0.11450730f, -0.25440198f, -0.06588163f, -0.12150587f, 0.20465487f, 0.23669280f, 
    0.23823027f, -0.01830078f, -0.11792271f, -0.14539096f, 0.23619367f, 0.29153177f, -0.08834599f, -0.08193362f, 
    0.09446443f, 0.12907286f, -0.08231992f, -0.16616178f, -0.06780656f, -0.36441675f, 0.10829584f, 0.05657537f, 
    -0.06387773f, -0.00224868f, 0.13341224f, -0.20145510f, 0.16619129f, 0.00446805f, -0.18381572f, 0.11500095f, 
    0.03302765f, 0.00555932f, -0.11290158f, -0.03707079f, -0.08965606f, 0.09915414f, 0.36582106f, 0.30325460f, 
    -0.06242412f, 0.22502732f, 0.11983658f, 0.11970430f, 0.09476933f, -0.01837135f, 0.15250030f, -0.03033802f, 
    -0.11932997f, 0.13394357f, -0.06240599f, -0.07822271f, 0.07970312f, 0.09252929f, -0.09937461f, 0.01346246f, 
    -0.21208616f, 0.13519827f, -0.05662336f, -0.08420649f, -0.10745008f, 0.12857321f, 0.08645699f, 0.14501692f, 
    -0.03259519f, 0.06136677f, -0.03266405f, 0.15424772f, 0.12170799f, -0.01010321f, -0.17961667f, 0.18762171f, 
    -0.29798770f, -0.01505697f, 0.10642725f, -0.10573674f, 0.12559809f, 0.15533084f, 0.01503684f, -0.14471342f, 
    0.12907822f, 0.04611954f, 0.19297279f, 0.17602214f, 0.15590425f, 0.22428855f, -0.03785770f, 0.07836401f, 
    -0.27359414f, 0.15232050f, -0.09869879f, -0.21399364f, 0.15978278f, 0.12077495f, -0.01758488f, -0.12755498f, 
    -0.15241817f, 0.11437041f, -0.00660010f, -0.11054666f, 0.11728276f, 0.02410273f, 0.25396013f, 0.10578477f, 
    0.08756869f, -0.21381301f, 0.20976873f, 0.04173395f, 0.33539999f, 0.05895338f, 0.10452328f, -0.11643462f, 
    -0.15975818f, 0.06628064f, 0.08697262f, 0.14265221f, 0.14891759f, 0.52202910f, 0.06625173f, -0.28324604f, 
    -0.18993370f, -0.02039373f, 0.22728057f, -0.16874014f, 0.17190112f, -0.07136854f, 0.14919303f, 0.06636909f, 
    -0.22767489f, -0.13653062f, -0.15368211f, -0.38466254f, -0.12193012f, -0.15584958f, -0.38086364f, -0.11130100f, 
    0.08387613f, 0.16345336f, -0.14304745f, -0.10909370f, -0.01215520f, 0.25994053f, 0.17702371f, 0.09577861f, 
    0.19201939f, 0.13614830f, -0.11918413f, 0.06158419f, 0.13185705f, -0.13669425f, 0.03166946f, 0.37654057f, 
    0.11813840f, -0.05668953f, -0.15543403f, 0.13301429f, 0.15925542f, 0.02090553f, -0.16416347f, -0.17234768f, 
    0.03388585f, 0.02189355f, 0.07417016f, 0.46274498f, -0.13053451f, -0.04934137f, -0.31101879f, -0.35647351f, 
    0.08476924f, -0.26375803f, -0.00488362f, 0.12415604f, 0.12166971f, -0.16017658f, 0.05347023f, 0.11902381f, 
    -0.03055588f, -0.15439416f, 0.12422118f, -0.15790296f, -0.08848049f, -0.00193347f, -0.16701902f, -0.11729760f, 
    -0.14565067f, -0.04090854f, 0.12487508f, -0.05331119f, -0.09940383f, -0.14564419f, -0.04511213f, -0.03016579f, 
    0.08916707f, -0.10665928f, -0.09626353f, 0.08214240f, -0.07855155f, -0.01964389f, -0.05385472f, 0.02223971f, 
    -0.07973758f, -0.15295723f, -0.10268902f, 0.01358247f, -0.17654565f, -0.17319931f, -0.01506368f, -0.06783921f, 
    -0.31521735f, 0.11330472f, -0.13861862f, 0.06553071f, -0.17341353f, 0.23228064f, 0.09946512f, -0.12059443f, 
    -0.23487616f, 0.01631574f, 0.02622464f, 0.17876491f, 0.12730674f, 0.10027616f, 0.15355675f, 0.01127809f, 
    0.16296056f, -0.17377037f, 0.10073956f, 0.08431582f, -0.01408362f, -0.16962686f, 0.19553217f, 0.45956737f, 
    0.15914801f, 0.03328022f, 0.20138659f, -0.01520691f, -0.04821620f, 0.21938220f, 0.12393951f, -0.08971579f, 
    -0.06372007f, -0.14416245f, 0.14092602f, 0.13288487f, 0.21631522f, 0.14880876f, 0.14888938f, -0.15541255f, 
    -0.15838948f, -0.43301901f, 0.03586093f, -0.28173828f, -0.03806679f, -0.09913597f, 0.08741830f, -0.17429316f, 
    -0.09296647f, -0.01243243f, -0.13507535f, -0.06824981f, -0.15451156f, 0.15855619f, -0.22754996f, -0.20053962f, 
    0.44393736f, 0.22676396f, -0.77212816f, 0.15303835f, -0.06265467f, 0.19519497f, 0.23585860f, 0.15949421f, 
    -0.03185596f, -0.04573148f, -0.31295580f, 0.15435503f, -0.25708100f, 0.10507556f, -0.14183852f, -0.58136207f, 
    -0.15833789f, 0.01514997f, -0.06205106f, -0.14698952f, 0.04872660f, 0.14821757f, 0.04810853f, -0.08915540f, 
    0.17345749f, -0.16027485f, 0.04602632f, 0.14600284f, 0.17908503f, -0.02466430f, 0.00601381f, -0.18572535f, 
    0.11032808f, -0.19519691f, 0.11148667f, 0.19543217f, -0.18726966f, 0.01333890f, 0.37187120f, -0.30983955f, 
    -0.18853784f, 0.05333871f, -0.11434954f, 0.14770715f, 0.08446071f, 0.33695543f, -0.01649320f, -0.12534374f, 
    0.11592615f, 0.10813734f, 0.11375272f, 0.07136651f, 0.04911699f, -0.14226177f, -0.15345412f, -0.17331381f, 
    -0.01606585f, 0.11621616f, -0.08820846f, -0.11521486f, -0.15712920f, 0.04450991f, -0.18657464f, -0.01106587f, 
    -0.19622087f, -0.16451778f, -0.15601091f, -0.09902263f, 0.04499614f, 0.17344137f, 0.08853482f, 0.04276331f, 
    0.49607995f, 0.00747852f, -0.31754306f, 0.05076245f, 0.35298941f, -0.14798655f, 0.13111565f, 0.15657887f, 
    -0.05186814f, -0.35316342f, -0.08170599f, -0.13644734f, -0.16422078f, -0.06496663f, 0.03425605f, 0.42135572f, 
    -0.14323764f, -0.06323954f, -0.01203912f, -0.09615099f, 0.07889109f, -0.10245652f, -0.17553818f, -0.13997015f, 
    -0.21214454f, 0.12731069f, -0.31232217f, 0.11283421f, -0.16431822f, -0.21516035f, 0.12072260f, 0.34605366f, 
    0.02290841f, -0.16647711f, 0.20425007f, -0.16527160f, 0.06239612f, 0.14447130f, -0.09882169f, 0.43047544f, 
    0.18135361f, 0.01579886f, 0.06449432f, 0.30644402f, 0.01255354f, 0.01526996f, 0.05376047f, -0.15132244f, 
    -0.09644528f, -0.01957548f, 0.11129039f, 0.46499148f, -0.06368901f, 0.02004824f, -0.07590452f, -0.21305341f, 
    -0.17579460f, -0.09503774f, 0.01470826f, 0.01339025f, 0.13206482f, -0.30568239f, -0.28679347f, 0.11083567f, 
    -0.44732365f, -0.10332190f, -0.07377082f, -0.04511145f, 0.21301740f, 0.51694328f, 0.10792535f, -0.14063375f, 
    -0.09566976f, -0.16386338f, 0.31038538f, 0.09289648f, -0.07182611f, 0.08095334f, 0.10161456f, -0.16333698f, 
    0.12050893f, 0.14354445f, 0.13956256f, -0.24416971f, 0.08731288f, 0.11290623f, -0.22887301f, -0.31316456f, 
    0.34038743f, 0.23508456f, -0.06530645f, -0.01194053f, 0.19008061f, 0.11572047f, 0.04888342f, 0.05173734f, 
    -0.16900204f, -0.09575073f, -0.06502034f, 0.10494298f, -0.01789610f, 0.04255920f, 0.04374306f, -0.06032320f, 
    -0.10810704f, 0.06738005f, -0.12828456f, -0.02460093f, -0.16984466f, 0.08470549f, -0.09812863f, -0.02372012f, 
    -0.18409804f, -0.14141479f, 0.02800578f, -0.16211201f, 0.04299667f, 0.03946406f, 0.06479402f, -0.15091579f, 
    0.07225700f, 0.06060980f, -0.06419475f, 0.07977206f, 0.09540317f, -0.03540983f, -0.21857134f, -0.11812866f, 
    -0.01284171f, -0.10494108f, 0.08098900f, 0.13948005f, -0.02213869f, -0.14298500f, 0.01320258f, 0.10550059f, 
    0.16115630f, 0.07246000f, -0.05383312f, -0.06685866f, -0.05035107f, -0.00114452f, 0.15584266f, -0.16361982f, 
    -0.12716724f, -0.17042407f, -0.12786877f, 0.31236210f, -0.09129764f, -0.06419479f, -0.14537658f, -0.01092334f, 
    -0.11099485f, 0.10433868f, 0.16617398f, 0.06079059f, -0.11164681f, 0.11023708f, 0.23931587f, -0.02755461f, 
    -0.12202866f, 0.12268275f, -0.19988145f, -0.07484356f, -0.53958219f, 0.13240120f, -0.12859851f, 0.05980980f, 
    -0.15875636f, -0.14822854f, -0.07241901f, 0.00220298f, -0.13916600f, -0.03587370f, -0.15923449f, 0.11734006f, 
    0.11830818f, 0.02931617f, 0.04812387f, -0.12955612f, 0.12508942f, -0.14797550f, 0.04516550f, 0.05264899f, 
    0.01595343f, 0.06182877f, 0.12489716f, 0.09155232f, 0.05748331f, 0.09872904f, 0.20900898f, -0.06421018f, 
    0.24618295f, 0.06513678f, 0.40920618f, -0.15710901f, 0.12206493f, -0.08266933f, -0.09756315f, -0.28492048f, 
    -0.22963525f, -0.07379056f, 0.16985962f, -0.16947818f, -0.06896774f, 0.04364125f, -0.09151811f, -0.10855781f, 
    0.07925838f, -0.08102532f, 0.02483357f, -0.32395017f, 0.02663442f, 0.14990510f, 0.16883013f, 0.53030884f, 
    0.01361737f, 0.18674016f, 0.24214984f, -0.06328187f, -0.28094926f, -0.08122817f, 0.07651608f, -0.11574784f, 
    0.48752823f, 0.06275221f, -0.49545202f, 0.14872406f, 0.22113720f, 0.07064967f, 0.06830589f, -0.04539023f, 
    -0.17481835f, -0.18339813f, 0.00269862f, -0.11631798f, -0.08128723f, 0.07013066f, -0.09463511f, 0.27175385f, 
    0.19641358f, 0.14314809f, -0.14377183f, -0.12906477f, 0.04055694f, -0.11293311f, -0.68621027f, -0.03413082f, 
    -0.51157534f, 0.21237583f, -0.27100590f, -0.19132175f, 0.13610731f, 0.14131960f, 0.38879174f, 0.29320768f, 
    0.11589763f, -0.06403653f, 0.08993489f, -0.01567552f, 0.00347559f, -0.42199671f, 0.07785925f, -0.08649319f, 
    -0.24391618f, -0.20146038f, 0.30200514f, 0.05690672f, -0.17659706f, -0.07333111f, 0.03474075f, 0.04707465f, 
    0.10607124f, 0.00406126f, -0.03258592f, -0.36999473f, -0.13856408f, -0.06672672f, -0.33101022f, 0.36335808f, 
    -0.24360195f, 0.31538826f, 0.06426651f, -0.09636526f, -0.03468022f, -0.33748510f, 0.10345285f, 0.11977307f, 
    0.06707028f, -0.14462265f, 0.39491048f, -0.05197443f, 0.30884030f, 0.02537142f, 0.12969355f, 0.54108840f, 
    -0.21720885f, 0.08949528f, 0.20864037f, 0.23884323f, -0.01110404f, 0.07263017f, -0.00043980f, -0.18665008f, 
    -0.36881030f, 0.06273117f, 0.12979013f, 0.27706197f, 0.01050535f, -0.07496472f, -0.08321888f, -0.25390375f, 
    -0.30862856f, -0.26727667f, -0.39972046f, -0.04945471f, 0.00987757f, -0.33233947f, -0.35013905f, 0.24492656f, 
    0.05093135f, 0.04402432f, 0.46584803f, 0.09152785f, -0.13309172f, 0.23215096f, -0.15991145f, 0.07568407f, 
    -0.07799464f, 0.01476185f, 0.15111603f, -0.05720399f, 0.11211476f, 0.14880510f, -0.02782514f, -0.13296369f, 
    -0.09953171f, 0.05601426f, 0.04961297f, 0.09393629f, -0.11527731f, 0.15763839f, 0.18036923f, 0.10390513f, 
    0.16530611f, -0.02928510f, 0.06958666f, 0.14230520f, 0.34773183f, 0.04652971f, 0.10788375f, -0.13467593f, 
    0.13059738f, -0.13676979f, -0.07605114f, -0.06313372f, -0.03226496f, 0.40549222f, 0.07831375f, -0.01150872f, 
    0.46474248f, 0.07292140f, -0.13215068f, 0.24433269f, -0.15667766f, -0.06024017f, 0.12870225f, 0.04460748f, 
    -0.10613013f, -0.13942793f, -0.06375150f, 0.16106823f, 0.18125781f, -0.06651271f, -0.17466655f, -0.21124096f, 
    -0.16449262f, 0.02665822f, -0.10353953f, 0.09649076f, 0.24111885f, 0.11303637f, 0.10286291f, 0.10710779f, 
    0.19676535f, 0.01688913f, 0.04234035f, 0.11557814f, 0.30202481f, 0.07382408f, -0.03188297f, 0.04056463f, 
    -0.00999398f, -0.01620631f, 0.07501211f, 0.07951981f, -0.00586936f, -0.17024833f, -0.14844698f, 0.04046587f, 
    -0.18643564f, 0.09833466f, 0.12573090f, 0.03487585f, -0.04009761f, 0.12151073f, -0.70544034f, 0.03387860f, 
    -0.39098319f, 0.08185848f, -0.30245420f, 0.05899274f, -0.17697236f, 0.06497622f, -0.02118274f, -0.00288865f, 
    0.11313890f, 0.15431055f, -0.08357830f, 0.01668890f, 0.24830952f, 0.19044033f, -0.09726498f, 0.00649531f, 
    0.35567617f, -0.08911433f, -0.53864920f, -0.31632632f, -0.09891236f, -0.05438996f, 0.01570906f, 0.26529703f, 
    -0.32434073f, -0.15904665f, -0.11625974f, 0.29793262f, -0.08959267f, 0.06678501f, 0.00718846f, -0.45523140f, 
    0.13325328f, -0.07470772f, -0.10263287f, -0.08776448f, 0.11873046f, 0.00997748f, 0.09648225f, -0.02912591f, 
    -0.05618878f, 0.04281328f, -0.07939593f, 0.03775911f, -0.02811148f, -0.12178068f, -0.09243198f, 0.46568477f, 
    -0.17628339f, -0.06656361f, 0.07161967f, 0.18392704f, -0.07124352f, 0.15040810f, 0.12570783f, 0.03439182f, 
    -0.01544754f, -0.13504608f, 0.01568130f, 0.24696933f, -0.08227497f, -0.15583256f, 0.23407808f, -0.28227434f, 
    0.39408666f, -0.10839408f, -0.18901956f, -0.05023108f, 0.33373097f, -0.19205803f, -0.10581549f, 0.25898638f, 
    0.23202625f, -0.02556712f, -0.04652391f, -0.08402771f, 0.35009253f, -0.03796888f, 0.04683469f, 0.01547646f, 
    -0.36559415f, -0.01813013f, 0.09229416f, -0.21070431f, -0.13430034f, 0.06681348f, -0.03311934f, 0.27458021f, 
    0.02477345f, 0.05322838f, 0.17433380f, -0.27381510f, -0.07260130f, -0.04735014f, -0.16948244f, -0.19616821f, 
    -0.24820675f, -0.09011039f, -0.16338815f, -0.01560180f, 0.06221181f, 0.05192767f, 0.20655799f, 0.13233930f, 
    -0.26702034f, 0.16033287f, 0.29042742f, 0.09696610f, -0.00338228f, 0.25975019f, 0.11987536f, 0.00902445f, 
    -0.28469983f, 0.14168106f, 0.28360969f, 0.02752619f, 0.06946335f, -0.01917341f, -0.16399850f, -0.07258117f, 
    0.00720217f, 0.05522818f, -0.06892670f, -0.11240196f, -0.02777012f, 0.13235153f, 0.13773331f, -0.08591747f, 
    0.07617900f, -0.12127109f, 0.09537271f, -0.10519493f, 0.25982249f, 0.17305277f, -0.15930964f, 0.02847325f, 
    -0.28233618f, 0.05160768f, 0.14050917f, 0.03062119f, 0.22835499f, 0.26354733f, 0.09809852f, -0.14904028f, 
    -0.11077720f, 0.20380116f, -0.24850747f, -0.03374676f, 0.06075836f, -0.05381494f, 0.07723438f, 0.17828450f, 
    -0.38585386f, -0.11451346f, -0.11204735f, 0.12636861f, -0.09401351f, -0.00953885f, -0.12272654f, 0.03931869f, 
    -0.06392825f, 0.01454557f, -0.16587064f, -0.13138966f, -0.25468493f, 0.15938370f, -0.05249749f, 0.10180336f, 
    -0.27004665f, 0.14073622f, -0.38545793f, 0.01305000f, 0.20714290f, 0.15004872f, 0.03672476f, -0.21687132f, 
    0.54628825f, -0.21745776f, 0.04162959f, 0.09572887f, -0.05522554f, 0.18030794f, 0.05721989f, -0.08153408f, 
    0.16340822f, 0.03586613f, 0.10489779f, 0.22096831f, -0.12981652f, -0.17237945f, -0.34957597f, -0.09437130f, 
    -0.03911443f, 0.12281024f, -0.36232221f, -0.09218649f, -0.01545202f, 0.41984022f, 0.38679469f, -0.00202658f, 
    0.33748659f, -0.00105725f, -0.21752226f, 0.09348448f, -0.16226417f, -0.06506292f, 0.15315948f, -0.21458992f, 
    0.34439516f, 0.14168499f, -0.29446542f, 0.05360664f, 0.03010728f, -0.13572992f, -0.13460104f, 0.08196671f, 
    -0.10732593f, -0.05395264f, 0.06917529f, 0.47031662f, -0.07431182f, 0.15358613f, -0.10623293f, 0.28873110f, 
    0.08276432f, -0.00764745f, 0.06550620f, 0.08527950f, -0.15782477f, 0.40997335f, 0.39830634f, -0.07109015f, 
    -0.06093372f, 0.00240907f, -0.13674131f, 0.14880349f, 0.14555781f, -0.11096667f, 0.08793069f, 0.04045988f, 
    -0.21557367f, 0.08767861f, -0.19223708f, -0.08181787f, -0.13626745f, -0.04394340f, -0.02520757f, -0.01760094f, 
    -0.22722903f, -0.03170006f, 0.03830598f, 0.13183592f, -0.01553897f, 0.11358752f, 0.24700652f, 0.18303747f, 
    0.22174852f, 0.07265473f, -0.18928483f, 0.02497958f, -0.28264251f, 0.22569291f, 0.03037926f, 0.14644311f, 
    -0.23987788f, 0.15328714f, -0.30945393f, 0.05248540f, 0.27364889f, -0.05903924f, -0.16297849f, -0.07088532f, 
    -0.16380998f, -0.14950034f, 0.18109299f, -0.24620815f, 0.09992487f, 0.08976804f, 0.14901952f, -0.07107975f, 
    0.00503011f, 0.11687170f, -0.13898654f, -0.21760379f, -0.16565771f, 0.00636533f, -0.12789260f, -0.06495090f, 
    0.09067922f, 0.19746803f, -0.42219740f, 0.10067870f, -0.06540658f, 0.36069947f, 0.25685787f, -0.04577323f, 
    0.02635038f, -0.03434150f, 0.60990196f, -0.16341913f, -0.02548039f, 0.40715641f, -0.16105404f, -0.04144148f, 
    -0.57272118f, 0.18300258f, -0.00441813f, 0.09757303f, 0.16628014f, 0.09338129f, -0.05700283f, 0.12448314f, 
    -0.04501981f, -0.14065395f, -0.05441628f, -0.44609258f, -0.07770473f, -0.04342988f, -0.09759343f, -0.31614643f, 
    0.08844651f, -0.08174495f, -0.20717742f, 0.11954805f, 0.00331334f, -0.16478005f, 0.10918138f, 0.08933624f, 
    -0.08209526f, 0.17447318f, -0.15759009f, 0.12737548f, 0.09500659f, -0.12509131f, 0.08682809f, -0.01553973f, 
    -0.12743576f, -0.09654260f, -0.04564732f, -0.05201312f, 0.04836867f, -0.06570995f, -0.14575145f, -0.11926317f, 
    -0.14138308f, 0.10648088f, -0.12914424f, -0.16758089f, -0.01256695f, -0.05646253f, -0.02377868f, -0.03754777f, 
    -0.16656154f, 0.04001812f, -0.02572429f, -0.05482257f, 0.07627255f, -0.01737139f, -0.17180324f, -0.07948665f, 
    0.00029584f, -0.05719528f, 0.08112712f, 0.08336015f, -0.28558776f, 0.01157445f, 0.12740701f, -0.18630077f, 
    -0.10931592f, 0.07022762f, -0.06914423f, -0.31175151f, 0.04399925f, -0.13128763f, 0.16369841f, 0.12187479f, 
    -0.03193107f, 0.15382349f, -0.14587732f, 0.00154168f, -0.02363153f, -0.05580139f, 0.03694834f, 0.00086490f, 
    -0.04314661f, -0.22553228f, -0.15914285f, -0.12077992f, -0.11085914f, 0.19439168f, -0.02571432f, -0.20719784f, 
    -0.17842294f, 0.09908054f, 0.05478182f, 0.08519190f, -0.06005062f, 0.27577186f, 0.11286129f, 0.19023755f, 
    -0.28443861f, 0.09267487f, -0.08315995f, 0.17744219f, 0.02934733f, 0.17314130f, -0.14386867f, -0.19860597f, 
    -0.17373705f, 0.03414698f, 0.06477524f, 0.27173471f, -0.08444511f, 0.13310669f, 0.35596937f, 0.15456866f, 
    0.30973923f, 0.04717000f, -0.01135938f, -0.13500454f, -0.22425592f, -0.23504333f, 0.21097419f, 0.18296741f, 
    -0.15583958f, 0.04255685f, -0.07091449f, 0.13082373f, -0.11360521f, 0.05865267f, -0.04814976f, -0.07566752f, 
    -0.17308158f, -0.08509335f, -0.11271563f, -0.02248692f, -0.01396479f, -0.16203865f, 0.10621261f, 0.15333985f, 
    -0.12374295f, -0.05106976f, 0.15455894f, 0.17584643f, 0.01831993f, -0.17031132f, 0.02977890f, -0.05223444f, 
    -0.08455292f, -0.11522097f, -0.03587917f, -0.03148949f, -0.13739495f, -0.09591327f, -0.17238824f, -0.03957716f, 
    0.08660018f, 0.11138360f, 0.06892464f, -0.09876508f, -0.02714472f, 0.28271902f, -0.12745881f, 0.01827521f, 
    0.09981724f, -0.10473213f, 0.22424588f, 0.02283240f, -0.17549086f, 0.07674178f, 0.15432262f, -0.31972548f, 
    -0.09843918f, 0.13787603f, -0.17524548f, 0.10380419f, -0.07074755f, 0.19555600f, -0.17232670f, -0.09468687f, 
    0.06280567f, 0.10536087f, -0.28450572f, -0.21109430f, 0.09415565f, 0.30580416f, 0.25755206f, -0.05256069f, 
    0.12358909f, 0.12667102f, -0.04831877f, -0.08352847f, 0.21391627f, -0.44674128f, -0.04453858f, 0.06292242f, 
    0.05271189f, 0.15493813f, 0.06462897f, 0.18360129f, 0.09440257f, 0.13273153f, 0.08446621f, 0.04475020f, 
    -0.06295563f, -0.15099001f, -0.04738852f, 0.19007015f, 0.03937519f, 0.10207801f, -0.55657727f, 0.53837937f, 
    0.13319148f, 0.12420193f, -0.11743192f, -0.04016255f, -0.07554743f, 0.01323492f, -0.33574477f, 0.07499935f, 
    0.05675726f, -0.08292553f, 0.09390746f, -0.07136679f, -0.17100139f, -0.01737389f, -0.13909161f, -0.01875274f, 
    0.05408415f, -0.19087128f, 0.00792689f, -0.15322448f, 0.02393958f, 0.00531946f, -0.04956039f, 0.03072605f, 
    -0.17745544f, -0.07400620f, -0.13123378f, -0.12009839f, -0.11094195f, -0.17479172f, -0.03978395f, 0.07089709f, 
    -0.15553887f, 0.12840198f, -0.06052639f, 0.16515112f, -0.11602423f, 0.04497281f, 0.05652992f, -0.17334780f, 
    -0.18079618f, 0.16539985f, -0.04245309f, 0.14271785f, 0.15050970f, -0.08658468f, -0.07209495f, 0.16289590f, 
    0.39300519f, -0.21053876f, -0.21554896f, 0.18837366f, -0.17874235f, 0.11362503f, -0.08356077f, -0.40907237f, 
    0.03794198f, -0.08765509f, 0.01626992f, 0.38356340f, -0.15189847f, 0.02828734f, -0.09652395f, -0.02961801f, 
    0.25000361f, 0.16669875f, -0.47940788f, 0.09157553f, -0.27708817f, 0.22353227f, 0.05433474f, 0.15409264f, 
    0.37260693f, -0.07365432f, -0.21051742f, 0.00776954f, 0.14750794f, -0.25485632f, 0.00306986f, 0.21654767f, 
    0.03866651f, -0.35756144f, -0.00710754f, -0.19862525f, 0.09107534f, 0.15714221f, -0.00224578f, 0.01895920f, 
    0.14704804f, -0.11452458f, -0.06599742f, -0.13305074f, -0.09318175f, -0.06154571f, -0.28326693f, -0.16891997f, 
    0.11685325f, 0.27204248f, -0.54852474f, -0.18965487f, -0.01305563f, -0.02140434f, 0.41228929f, 0.29695731f, 
    -0.07648882f, -0.04654652f, -0.16771396f, 0.13021715f, -0.09990018f, 0.11804812f, -0.14908394f, 0.01109559f, 
    -0.04522668f, 0.05619274f, 0.06521492f, -0.07027041f, 0.07266205f, 0.00212920f, 0.06766038f, -0.18061644f, 
    -0.16628809f, -0.14312665f, 0.15603313f, 0.07626343f, -0.13559842f, 0.11357448f, -0.03658900f, -0.03861475f, 
    -0.11808603f, -0.15007122f, -0.14112209f, -0.00712760f, 0.00558196f, 0.00834964f, 0.03939684f, 0.11846493f, 
    -0.07990718f, -0.04365427f, -0.29872888f, -0.00261259f, 0.21619879f, 0.23462875f, 0.01701201f, 0.05724833f, 
    -0.25093031f, 0.19271600f, -0.24007849f, 0.08819541f, -0.18304344f, -0.03970939f, -0.05198842f, -0.00022489f, 
    -0.14609960f, 0.15117079f, -0.04208198f, 0.13846354f, 0.01221035f, -0.12157927f, -0.24588118f, -0.06746789f, 
    0.12212057f, -0.21125878f, -0.09625389f, 0.04774031f, -0.09507927f, 0.20867720f, 0.13953096f, 0.17914669f, 
    0.34883022f, -0.08566785f, 0.34824526f, 0.13909270f, 0.30190352f, 0.10786418f, 0.08544742f, -0.38952318f, 
    -0.30071893f, -0.03925910f, -0.04871497f, -0.36334756f, 0.10622406f, -0.15406378f, -0.00479784f, 0.11934175f, 
    0.11008388f, -0.01898112f, -0.07152922f, -0.09150110f, 0.03854385f, -0.11104570f, 0.22732317f, 0.29976150f, 
    -0.14331579f, -0.18144821f, 0.03328276f, -0.10625269f, -0.15061150f, 0.07872424f, 0.22468625f, -0.10098340f, 
    0.13824387f, 0.07954090f, 0.08641885f, -0.11241578f, 0.23292744f, -0.56428427f, 0.04703470f, -0.10411654f, 
    -0.28412473f, -0.07449020f, 0.23189108f, 0.23770855f, 0.00022717f, 0.01391307f, 0.12487335f, -0.02839899f, 
    0.04651365f, 0.10837524f, 0.08698823f, -0.14237651f, -0.16822428f, -0.01001918f, -0.39443251f, 0.51771057f, 
    -0.00971999f, 0.25654408f, 0.26896384f, -0.09242202f, -0.05651226f, -0.31884238f, -0.22188526f, 0.04233270f, 
    0.22199768f, 0.08258616f, 0.33560988f, -0.04246908f, -0.08530660f, 0.35358125f, -0.02785770f, 0.15112047f, 
    -0.08306623f, 0.14828596f, 0.21974584f, 0.01640316f, -0.17945744f, 0.05629662f, 0.18517041f, -0.20813017f, 
    -0.57125551f, -0.10468516f, 0.07043181f, -0.04210905f, 0.11300623f, -0.10082013f, 0.39522451f, 0.19400305f, 
    0.06708646f, -0.22377270f, -0.10455319f, 0.10900617f, 0.40113965f, 0.10697351f, 0.09290680f, -0.09365522f, 
    -0.17146409f, -0.09920146f, 0.04051912f, 0.00344972f, 0.31254005f, -0.16124827f, -0.15048580f, 0.24580368f, 
    0.15525109f, 0.05893541f, 0.02328763f, 0.13523497f, 0.17041086f, -0.10477041f, -0.11709996f, 0.00058239f, 
    0.08129255f, 0.14420295f, 0.16325466f, 0.29615730f, 0.15652320f, -0.02624767f, -0.29821002f, 0.26337141f, 
    -0.11125095f, 0.15873308f, -0.08280154f, 0.06541685f, 0.13808541f, -0.04544262f, -0.30790713f, -0.02277714f, 
    0.08760203f, 0.00203675f, -0.04563574f, -0.10249214f, -0.08047225f, -0.07102381f, 0.05128974f, 0.02053555f, 
    -0.19375084f, -0.21405612f, 0.06260414f, 0.00865026f, 0.07008751f, -0.05730292f, -0.14470024f, -0.14753868f, 
    -0.08205762f, 0.07744402f, 0.14667340f, 0.08122280f, 0.11247147f, 0.10735834f, -0.11258852f, 0.06042973f, 
    -0.11541300f, -0.20553277f, -0.04173352f, -0.12505436f, 0.02011455f, 0.11285146f, -0.21721606f, -0.21514927f, 
    0.00429842f, 0.03203689f, 0.02328135f, -0.09511551f, -0.22803105f, -0.03478051f, 0.06353053f, -0.08864319f, 
    0.01573328f, 0.03164973f, -0.17515102f, -0.10279692f, 0.17227709f, -0.15915543f, -0.05675752f, 0.18970641f, 
    0.07589645f, 0.13258567f, -0.14243057f, 0.11058968f, -0.16725849f, 0.02232614f, 0.10689722f, 0.04080674f, 
    0.17041618f, -0.26722750f, -0.10306324f, -0.07823019f, -0.21286003f, -0.11135311f, 0.33625343f, -0.06055384f, 
    0.23570140f, 0.16357689f, 0.43703565f, 0.16218244f, 0.21218354f, 0.17166613f, 0.12018960f, 0.36779374f, 
    -0.53102988f, -0.19291364f, 0.03018827f, 0.08902400f, 0.00946382f, -0.11396810f, -0.02648573f, -0.12779385f, 
    -0.52344066f, 0.01031890f, 0.01237260f, 0.00965992f, -0.15286778f, 0.08239426f, 0.35370687f, -0.30781442f, 
    0.30641368f, -0.10834213f, -0.25828767f, 0.00411018f, 0.15652986f, -0.43264785f, -0.03433625f, 0.17278120f, 
    -0.01028019f, 0.16920653f, 0.07907858f, 0.05480228f, 0.20541033f, 0.54637337f, -0.05651537f, -0.17027152f, 
    -0.26796949f, 0.26682663f, -0.07414047f, -0.03698568f, 0.14500119f, 0.07318787f, 0.08760073f, 0.12685338f, 
    -0.33461025f, 0.03299486f, -0.14493056f, 0.05378464f, -0.12112822f, -0.19425938f, 0.00774725f, 0.01866684f, 
    0.14466374f, -0.03397350f, -0.10265076f, -0.01299516f, 0.03910138f, 0.06734619f, 0.06650197f, -0.12266260f, 
    -0.05761929f, -0.08580443f, -0.11665027f, -0.11526345f, 0.09816389f, 0.01851991f, -0.09244483f, -0.07422338f, 
    0.39097616f, 0.08425830f, -0.05563703f, -0.32564229f, 0.02881307f, -0.12863784f, -0.15675190f, 0.26360652f, 
    0.16384146f, -0.06802346f, 0.07821997f, -0.12625095f, -0.17410575f, -0.15992552f, -0.19353808f, 0.06838371f, 
    0.22110918f, 0.15946032f, -0.19327843f, 0.15025359f, -0.11847573f, 0.23517938f, 0.06030632f, 0.05589959f, 
    -0.01757577f, -0.01728900f, 0.08403533f, 0.11972631f, -0.12036335f, -0.04966096f, 0.03685657f, 0.03331493f, 
    0.54070431f, 0.06810151f, -0.02387336f, -0.04941153f, 0.12440068f, 0.09479646f, -0.01585053f, 0.03749835f, 
    0.02634048f, 0.08675078f, -0.13623320f, 0.34275001f, -0.12681201f, 0.09937519f, -0.20859945f, 0.20940594f, 
    0.23358762f, 0.17167939f, 0.04314946f, 0.03671899f, -0.06979609f, -0.36303860f, -0.24122693f, -0.17211898f, 
    -0.11453105f, -0.12657104f, -0.63742489f, -0.06098143f, 0.15427732f, 0.24100144f, 0.11438473f, -0.05985523f, 
    -0.12109283f, 0.19441786f, 0.21791521f, 0.08655142f, -0.12551625f, -0.03932178f, -0.06613915f, 0.06511131f, 
    -0.20282455f, 0.06477889f, -0.15731579f, -0.12982273f, 0.00805579f, 0.13087244f, -0.48009273f, -0.02576186f, 
    0.02449462f, 0.15044762f, -0.23610128f, -0.12265540f, 0.29851887f, 0.36263990f, -0.00938909f, 0.10490217f, 
    0.03358801f, 0.07407440f, 0.48013148f, 0.04959969f, 0.10735816f, 0.07889786f, -0.11805614f, -0.35493428f, 
    -0.19035184f, 0.12717271f, 0.25096950f, -0.27658653f, -0.11038812f, -0.00038050f, 0.05827405f, -0.29073408f, 
    -0.04298161f, -0.03773501f, -0.15454765f, -0.18709767f, -0.17427245f, 0.17020014f, 0.43068212f, 0.50801837f, 
    -0.11044565f, -0.01359166f, 0.12265885f, 0.12708047f, 0.01952438f, 0.12086456f, 0.08926531f, -0.23546089f, 
    -0.19238251f, -0.07843665f, -0.13619405f, 0.03585317f, -0.43966112f, 0.04073382f, 0.16818555f, 0.01503338f, 
    -0.10804418f, -0.04227766f, -0.13554987f, -0.00644318f, 0.11129507f, 0.04691317f, -0.13378885f, 0.14236623f, 
    0.19365954f, -0.12541130f, 0.00536639f, -0.24789374f, 0.02894930f, 0.12954228f, 0.00953023f, -0.17097230f, 
    0.09616979f, -0.10818221f, 0.08460366f, 0.15548521f, 0.00325967f, -0.04314864f, 0.34543931f, 0.07615815f, 
    -0.01024989f, -0.12335736f, -0.49505731f, -0.07829586f, 0.10622462f, 0.47879741f, -0.09076260f, -0.26022726f, 
    -0.01812374f, -0.04846246f, -0.22723971f, -0.21627234f, -0.04732497f, 0.05575964f, -0.17858624f, -0.06083544f, 
    -0.20267637f, -0.03186000f, 0.10262887f, 0.40296528f, -0.10327253f, 0.04266890f, 0.30958721f, -0.11322928f, 
    -0.08967287f, 0.20027296f, 0.06202841f, -0.19564131f, -0.01787668f, 0.30964130f, 0.35369852f, -0.02414998f, 
    0.26529697f, 0.00012960f, 0.23470633f, -0.04672015f, 0.05858583f, 0.30024329f, 0.03211990f, -0.07635908f, 
    -0.23804837f, 0.02841678f, -0.14680599f, 0.07645406f, 0.07832084f, -0.02724978f, -0.17192030f, 0.11696123f, 
    -0.15644290f, -0.15774660f, 0.09711207f, -0.31531671f, -0.12828919f, 0.02584998f, -0.08634169f, -0.38077930f, 
    -0.31597486f, -0.05714511f, -0.01727263f, -0.16367881f, 0.07850726f, -0.08014159f, 0.31490999f, 0.40891322f, 
    -0.10713921f, -0.01990572f, 0.48740008f, 0.16449431f, 0.05055821f, 0.29687071f, 0.06157800f, -0.23730847f, 
    -0.26045412f, 0.07027005f, 0.14921494f, 0.09116079f, 0.03447610f, -0.06286409f, 0.08085718f, -0.08658480f, 
    0.14918168f, 0.06758416f, -0.14424331f, -0.13887705f, 0.06700548f, 0.00008055f, -0.11458646f, -0.24501993f, 
    -0.03714713f, 0.18999790f, 0.07489857f, -0.11811461f, -0.05636709f, 0.11561074f, -0.06664460f, -0.02463943f, 
    0.47790146f, 0.10015097f, 0.38692528f, -0.17026359f, -0.02796059f, -0.26276544f, -0.15707821f, 0.04746842f, 
    -0.23032370f, -0.12492483f, 0.02453395f, -0.11812644f, -0.12289681f, -0.15542296f, 0.15808588f, 0.27853110f, 
    0.05981347f, 0.13626114f, 0.10116403f, -0.36778873f, 0.15018730f, -0.03670504f, -0.08002176f, 0.10295251f, 
    -0.03054376f, 0.16859628f, 0.02311174f, -0.06686375f, 0.04733944f, -0.34057552f, 0.08551556f, 0.00963962f, 
    -0.30538282f, 0.03133022f, 0.14534733f, 0.11464885f, 0.11527802f, 0.28323579f, 0.06000691f, -0.12658671f, 
    0.34303162f, 0.13113360f, 0.36870697f, 0.28468761f, 0.10387419f, -0.00916549f, 0.15704307f, -0.29386199f, 
    0.21110994f, 0.13574365f, 0.05078436f, 0.18514296f, -0.13297029f, 0.07552188f, 0.30113330f, 0.43941298f, 
    -0.07182683f, 0.04445895f, 0.05269859f, 0.09883653f, 0.16362873f, 0.39375731f, -0.14889486f, -0.13430190f, 
    -0.25775918f, 0.09223720f, 0.01623970f, -0.13819329f, -0.03596064f, 0.04188236f, 0.02621540f, 0.13720416f, 
    -0.09136464f, 0.02880277f, 0.05500976f, 0.06123099f, -0.15011331f, -0.17464545f, 0.11951088f, -0.01590456f, 
    -0.03168761f, -0.03794386f, 0.05950752f, 0.28305572f, -0.11084480f, 0.10429610f, 0.01339893f, -0.21533942f, 
    0.05045034f, 0.09502909f, 0.06694533f, 0.07538381f, -0.21847923f, -0.10115434f, 0.12909941f, -0.18744840f, 
    0.03550705f, 0.11481000f, -0.69486696f, 0.11964843f, 0.18246627f, -0.11025551f, 0.16259889f, -0.19113298f, 
    -0.01673722f, 0.06180219f, 0.16967762f, -0.09651373f, 0.00866675f, 0.06502697f, 0.07798526f, 0.15757936f, 
    -0.03688088f, -0.09330745f, 0.08394187f, -0.21494253f, 0.14271475f, 0.07170781f, -0.23108266f, 0.09818115f, 
    -0.33478233f, 0.07075234f, 0.13435656f, 0.06241812f, 0.10245670f, 0.47427687f, 0.17577130f, -0.01349612f, 
    0.25715336f, -0.06171671f, 0.15636863f, -0.03954194f, 0.02293253f, 0.20889433f, 0.06815586f, -0.02917150f, 
    -0.19709185f, 0.21383196f, 0.05724440f, -0.14671382f, 0.18662117f, 0.06880870f, 0.11130089f, 0.12751332f, 
    -0.33434361f, 0.08965662f, 0.08323237f, -0.06323721f, -0.07123946f, -0.14394289f, 0.28427568f, 0.27388555f, 
    0.05481237f, -0.03995726f, 0.01189977f, 0.00668403f, 0.26508200f, 0.09548364f, 0.15220167f, -0.13238378f, 
    0.01712869f, 0.01109063f, 0.01861068f, 0.00410190f, 0.26870915f, 0.07539555f, -0.00526989f, 0.01708971f, 
    0.04419675f, -0.06694052f, 0.16615812f, 0.16481911f, 0.11916023f, 0.02786988f, 0.01502638f, -0.09819686f, 
    0.16592090f, -0.05004936f, 0.12105399f, 0.04767750f, 0.10383233f, -0.10394599f, -0.47119632f, 0.34779802f, 
    -0.53191739f, 0.18458921f, -0.34312171f, 0.02512686f, -0.10162344f, 0.00741403f, -0.06988948f, 0.19331978f, 
    -0.02592726f, -0.07719227f, 0.06468829f, 0.05526182f, 0.17218438f, -0.06674451f, -0.15199879f, 0.00190053f, 
    0.10243088f, -0.02917910f, -0.15740623f, 0.08351419f, -0.02664850f, 0.05082283f, -0.09100655f, 0.19161980f, 
    -0.05925648f, -0.02682125f, -0.01229295f, -0.03215520f, 0.09577800f, 0.14717171f, -0.28391999f, -0.38418013f, 
    0.06326523f, -0.02918061f, 0.01077283f, 0.03407140f, -0.01388961f, -0.12110376f, -0.15159772f, 0.23960322f, 
    0.23025978f, -0.08419760f, 0.03606723f, 0.03882422f, -0.18487512f, 0.14214885f, -0.08844668f, -0.01918231f, 
    -0.13157974f, 0.18174852f, 0.27516577f, -0.10302487f, -0.12818560f, 0.15634133f, 0.02985373f, 0.14109808f, 
    -0.07644677f, 0.01648516f, 0.13049245f, 0.04982432f, 0.07790811f, 0.01664995f, -0.02310177f, 0.46475118f, 
    -0.12588711f, -0.00156302f, 0.01971469f, 0.09199180f, 0.22398040f, -0.16694859f, 0.29914403f, -0.10586977f, 
    0.09105446f, -0.16136397f, 0.07345846f, 0.13429636f, -0.16948317f, 0.07626407f, 0.14911717f, 0.17997870f, 
    -0.11746614f, 0.03521790f, 0.35789993f, -0.04612706f, 0.11924104f, 0.07394575f, -0.12971020f, 0.13882248f, 
    0.00277386f, 0.00252806f, 0.08275270f, 0.19294226f, 0.11154185f, 0.14623414f, -0.06187075f, -0.23979719f, 
    -0.10249999f, -0.09070814f, 0.16217610f, -0.01816382f, 0.04483991f, 0.04806554f, -0.12686664f, -0.22667108f, 
    -0.11502790f, -0.13858336f, -0.15586165f, -0.12832971f, -0.03819826f, 0.21676509f, 0.15384242f, -0.25816986f, 
    0.41350225f, 0.22698076f, 0.30922502f, -0.10756529f, 0.05691410f, -0.11019458f, 0.00939466f, 0.06153264f, 
    0.03649648f, -0.09569947f, -0.04032695f, 0.02911090f, -0.07868869f, 0.12106847f, 0.05840063f, 0.16634996f, 
    -0.14312625f, 0.02568827f, -0.07127869f, -0.00699684f, 0.25972039f, 0.51916397f, 0.24050538f, -0.24144061f, 
    0.45811197f, 0.07273640f, 0.03051598f, 0.08466249f, -0.01138103f, 0.12970698f, 0.15126599f, -0.20421749f, 
    0.12122227f, -0.15656216f, -0.15731679f, -0.33380705f, -0.05781623f, 0.07985330f, -0.00258842f, 0.39458153f, 
    0.04433126f, 0.13963975f, -0.06490445f, -0.16984838f, 0.06729604f, -0.03954728f, -0.33505017f, -0.27970758f, 
    0.15177178f, -0.02665723f, 0.05546594f, -0.16196355f, 0.08227923f, 0.10032561f, 0.25192222f, 0.16851382f, 
    -0.09197646f, 0.03768086f, 0.03259868f, 0.03056151f, 0.32367274f, -0.18661723f, 0.02610131f, 0.16711564f, 
    -0.02204518f, 0.12573299f, 0.38603964f, 0.14021856f, -0.06618266f, 0.05417236f, -0.14989810f, -0.12863424f, 
    0.35840866f, -0.08982509f, 0.01832188f, -0.00753633f, 0.06659735f, 0.17340228f, -0.23383538f, -0.12212960f, 
    -0.16558576f, 0.20523909f, -0.15825783f, 0.17798553f, -0.02770428f, 0.28767025f, -0.19039041f, -0.10726744f, 
    0.04339080f, -0.04601433f, 0.01853647f, 0.01218776f, 0.09468751f, 0.32178479f, -0.04526617f, 0.25670785f, 
    0.37608102f, -0.24429597f, -0.05866555f, 0.40213194f, 0.06799715f, -0.09568641f, 0.10949122f, -0.04459771f, 
    -0.10019314f, 0.03601828f, 0.16353600f, 0.55374980f, -0.04868985f, 0.13399151f, -0.28316012f, 0.20723714f, 
    -0.56824553f, -0.23319693f, -0.23724632f, -0.13908534f, 0.00180913f, 0.09939384f, -0.13960645f, -0.06813257f, 
    -0.35891107f, -0.07064733f, 0.15611698f, -0.12067959f, -0.06316692f, 0.38053766f, -0.07180603f, -0.05919207f, 
    0.44671237f, -0.21010278f, 0.08365034f, -0.03569828f, -0.04087853f, -0.08800970f, -0.14794514f, 0.00984317f, 
    0.17314392f, -0.13828751f, -0.13291420f, 0.40200245f, 0.07255799f, 0.02791752f, -0.17008621f, -0.17010897f, 
    0.12890147f, 0.07337222f, 0.19821990f, 0.00406397f, -0.25030506f, -0.21860205f, -0.31213295f, 0.18576595f, 
    -0.22634453f, -0.01783092f, 0.03834075f, -0.11955229f, 0.15676665f, 0.14144997f, -0.05599455f, -0.03893923f, 
    -0.10670551f, -0.30647966f, 0.42603070f, -0.17539914f, 0.07144406f, -0.09831332f, -0.05543192f, -0.04180513f, 
    0.17133775f, -0.17675225f, 0.10407409f, -0.37321755f, 0.14047863f, 0.10120676f, -0.12657894f, -0.13883385f, 
    0.05192324f, 0.25655463f, -0.51102060f, 0.13553549f, -0.03297450f, 0.21082938f, 0.26300278f, 0.01662333f, 
    0.11714074f, -0.07408778f, 0.02578602f, 0.11336082f, 0.32488313f, -0.09570715f, 0.12624125f, -0.21513441f, 
    -0.41226742f, 0.07323798f, -0.10058916f, -0.21385399f, -0.16133407f, 0.13090441f, 0.08570484f, -0.09814227f, 
    -0.07667962f, 0.11774653f, -0.04424094f, -0.19332901f, -0.03993816f, -0.03102614f, 0.02626332f, 0.21903475f, 
    -0.01068771f, -0.10402245f, 0.13960336f, -0.03275931f, -0.05847452f, 0.13665889f, 0.00479351f, 0.06337436f, 
    0.01829565f, 0.08751079f, -0.52430618f, 0.14505251f, 0.00507924f, -0.12097941f, 0.01737011f, 0.05165956f, 
    0.24502572f, -0.15276058f, -0.07415542f, -0.09353853f, 0.06262134f, 0.16372028f, 0.18805426f, 0.04776881f, 
    0.20056352f, -0.00835447f, -0.06280555f, 0.02892485f, -0.12639455f, -0.13407204f, -0.01192163f, 0.29713401f, 
    -0.24238229f, 0.01864823f, 0.12039537f, -0.03208875f, 0.16235575f, 0.37261480f, 0.18356733f, 0.00565332f, 
    0.09893542f, 0.12950753f, -0.09941632f, 0.12913293f, 0.26767030f, 0.16379882f, -0.12489469f, -0.03579009f, 
    0.03248664f, 0.19141465f, -0.13463512f, 0.13919923f, 0.11154363f, 0.08690941f, -0.09119802f, -0.24013592f, 
    -0.04666267f, 0.00478872f, -0.11591737f, 0.32531396f, 0.00718115f, -0.11117426f, -0.11728579f, 0.02231848f, 
    -0.21543904f, -0.30752087f, -0.05958869f, 0.10879795f, -0.19028710f, -0.27531886f, -0.17946045f, -0.04382780f, 
    0.01828953f, -0.07672330f, -0.00801750f, 0.14723815f, -0.06769472f, -0.06818233f, -0.14239965f, 0.02640735f, 
    -0.12741451f, 0.03539460f, -0.16036929f, -0.13586015f, 0.08587710f, -0.13163832f, 0.16757102f, -0.05897207f, 
    0.10676418f, 0.00225814f, -0.05648118f, -0.03186750f, -0.17046519f, -0.16643164f, 0.00634120f, -0.12804385f, 
    -0.04785765f, -0.17508335f, 0.02445100f, -0.15982671f, 0.01474880f, -0.13692507f, -0.08310045f, 0.10712996f, 
    0.00762708f, 0.16664831f, -0.09890395f, -0.12167223f, 0.19539757f, 0.18411541f, 0.12702027f, 0.13789302f, 
    -0.12022968f, 0.16466422f, -0.14210580f, 0.20722675f, -0.03432749f, 0.08273318f, 0.14667925f, 0.05246386f, 
    0.06469276f, 0.00519759f, 0.04200871f, -0.23068346f, -0.10111704f, 0.15462346f, -0.34244645f, -0.23758151f, 
    -0.24412088f, -0.06432608f, -0.17434977f, 0.04310247f, -0.16987778f, -0.02457708f, 0.20059152f, 0.31611350f, 
    -0.29550496f, -0.05346374f, -0.11853983f, -0.05525973f, 0.07922827f, 0.07120466f, 0.04485240f, -0.12941574f, 
    0.00788655f, -0.19420704f, 0.23995504f, -0.12051297f, -0.13941856f, 0.12337574f, 0.02565991f, 0.02049175f, 
    0.08574981f, 0.11089797f, -0.13489795f, -0.16176209f, -0.07068661f, -0.14573248f, -0.01719852f, 0.03853269f, 
    -0.08346732f, 0.15399931f, -0.10727752f, 0.06287713f, 0.14218070f, 0.18704700f, 0.15051422f, -0.16992281f, 
    0.37260109f, -0.02339502f, 0.25453269f, -0.00101015f, 0.21879469f, -0.11006303f, -0.07124221f, -0.24654922f, 
    -0.43232062f, 0.03648341f, -0.17057072f, -0.01563661f, 0.11431342f, 0.05599809f, 0.08070727f, -0.00562939f, 
    -0.01494347f, -0.14791618f, 0.13581805f, 0.01579227f, -0.01061092f, -0.07986331f, -0.02796360f, -0.13082826f, 
    0.07918180f, 0.08120994f, -0.10381366f, -0.08707133f, -0.18903512f, -0.24537963f, 0.14828418f, 0.21228440f, 
    -0.05148131f, 0.06961209f, 0.03116393f, -0.05756664f, -0.02639112f, 0.24453099f, -0.00099361f, -0.26872656f, 
    -0.24643171f, -0.11034770f, 0.03089096f, -0.11847933f, -0.11022481f, -0.01049629f, -0.06105110f, -0.22870614f, 
    0.23635855f, 0.01726659f, 0.09814606f, -0.02684793f, -0.02372149f, -0.16067913f, 0.19092883f, -0.14570978f, 
    0.02121095f, -0.11508156f, 0.14322682f, -0.05121134f, -0.22566108f, 0.19814393f, 0.09830845f, -0.17978029f, 
    -0.09514906f, 0.11291766f, -0.22973110f, 0.07657488f, 0.28799763f, -0.34165621f, -0.12711695f, -0.03650980f, 
    -0.42242938f, 0.13762186f, 0.16614185f, 0.09433264f, 0.02217297f, -0.11664977f, 0.08091607f, -0.08423404f, 
    0.08627913f, 0.02029089f, 0.05178901f, -0.11053861f, -0.06834193f, -0.05171681f, -0.11891203f, -0.08560117f, 
    -0.32014549f, -0.00088037f, 0.18081774f, 0.06080401f, 0.12401011f, 0.04132687f, 0.13464575f, -0.06607040f, 
    -0.14816216f, 0.14977902f, -0.03199409f, 0.11518168f, -0.02653684f, -0.14718674f, 0.12887530f, -0.20749049f, 
    0.05996978f, -0.00003877f, 0.14027536f, 0.04217002f, 0.12769714f, 0.17510800f, 0.06038944f, -0.01816727f, 
    0.10661134f, -0.07249382f, -0.10836934f, -0.15323249f, -0.09436083f, 0.09886169f, 0.06387145f, -0.17399457f, 
    -0.14523929f, -0.03156615f, -0.17911117f, -0.03037627f, 0.02297031f, -0.25282612f, -0.20692629f, -0.19409348f, 
    -0.37172949f, 0.07437127f, -0.02043165f, 0.16132924f, 0.17052779f, 0.46519437f, 0.09617183f, -0.28506851f, 
    0.21916878f, 0.05952920f, 0.27085543f, -0.00564990f, -0.00498821f, -0.15497133f, -0.04320402f, 0.10529523f, 
    -0.27203807f, -0.10522504f, -0.09639711f, 0.00735769f, 0.15988852f, -0.02872666f, -0.09062573f, -0.21866426f, 
    -0.07511915f, 0.02838435f, -0.21329203f, -0.09338884f, 0.02373193f, 0.18342656f, 0.16053577f, -0.06994879f, 
    0.21818916f, -0.12702723f, 0.09097334f, 0.05749194f, -0.03800834f, -0.08596583f, -0.04725916f, 0.07276047f, 
    0.03289339f, 0.03057821f, 0.03788286f, 0.13095213f, -0.10478417f, 0.02411455f, 0.02527852f, 0.02222436f, 
    -0.06421127f, -0.07517172f, -0.09882283f, -0.09385879f, 0.13695076f, -0.10112102f, 0.10344319f, 0.19803236f, 
    -0.32035509f, -0.15015371f, 0.09176315f, 0.07085773f, 0.20612738f, 0.06782676f, -0.03767634f, -0.01910063f, 
    -0.02991917f, 0.15298526f, -0.41418210f, 0.07017069f, 0.12042315f, -0.47731143f, -0.15367498f, 0.05462604f, 
    0.35063183f, -0.29954001f, 0.12972809f, -0.00299405f, 0.10160558f, 0.04771794f, -0.12255111f, -0.24136604f, 
    0.52347773f, -0.11513992f, 0.09998698f, 0.07626479f, 0.06422614f, -0.10533828f, -0.03339074f, 0.01844984f, 
    0.06200978f, 0.24699563f, -0.42755580f, -0.02363472f, -0.15026064f, 0.47378761f, 0.24829601f, 0.04277658f, 
    -0.11664874f, -0.07884339f, 0.27823353f, -0.05995133f, 0.24668694f, 0.28251261f, -0.02600490f, -0.25214607f, 
    -0.27604508f, 0.07893556f, -0.19691002f, -0.09600693f, -0.15902349f, 0.02764042f, 0.11454234f, 0.17063926f, 
    -0.01060645f, 0.04010744f, -0.09296753f, -0.32304230f, -0.06915794f, -0.07320277f, -0.00889210f, -0.34246403f, 
    0.02737555f, -0.11109699f, 0.08906090f, -0.06065480f, 0.26441696f, 0.09236740f, 0.14058529f, 0.19632062f, 
    0.12083101f, 0.03519059f, -0.30749384f, -0.06455490f, 0.08695872f, -0.11624889f, -0.13565616f, -0.00722895f, 
    0.41912150f, 0.07991567f, -0.23182553f, -0.20736891f, -0.14954889f, -0.11105449f, -0.00393859f, 0.30966339f, 
    0.12320986f, -0.00035166f, -0.04327423f, 0.27836359f, 0.07647984f, 0.06662932f, -0.26236472f, 0.17633441f, 
    -0.18300055f, 0.23334326f, -0.01697624f, -0.14873934f, -0.29632822f, -0.01877577f, 0.27777505f, 0.26782787f, 
    0.05170578f, -0.11731609f, -0.33805829f, 0.05596664f, -0.02304200f, -0.32960847f, 0.01109103f, 0.26155713f, 
    0.31886226f, 0.01409973f, 0.33284080f, -0.08562542f, -0.08099878f, 0.15157798f, 0.01736282f, -0.03301746f, 
    0.16763799f, -0.06789212f, 0.07551884f, 0.05089387f, -0.00525206f, -0.16684772f, 0.20405759f, 0.25372642f, 
    0.12100464f, 0.18734576f, 0.00672395f, -0.21494386f, 0.13083474f, 0.20472243f, -0.13746534f, -0.01188456f, 
    -0.02994569f, -0.01369593f, 0.02863343f, -0.13709989f, 0.15799573f, -0.19460166f, 0.16530724f, 0.18816094f, 
    0.30792540f, -0.28160965f, 0.19790396f, -0.24584454f, -0.14594814f, 0.10318235f, 0.12844034f, 0.16736108f, 
    0.13265122f, -0.07229742f, -0.06880346f, 0.15711220f, 0.16754335f, -0.05156241f, 0.13681367f, 0.09485238f, 
    0.35753727f, 0.33544353f, -0.14435163f, 0.07429655f, -0.29149181f, -0.19853145f, 0.09190910f, 0.04169687f, 
    -0.01769075f, -0.17645344f, -0.31199211f, 0.00887346f, 0.17729038f, -0.40771818f, -0.11210451f, 0.06875227f, 
    0.33566329f, -0.22648638f, 0.05517658f, 0.07243603f, 0.12391201f, -0.08977163f, 0.02570185f, -0.04401355f, 
    0.23498632f, -0.16781925f, 0.00709000f, 0.41742313f, -0.07778063f, 0.07638273f, 0.11575848f, 0.32755229f, 
    -0.07430462f, 0.24190848f, -0.18900654f, -0.03877369f, -0.30707991f, 0.32674959f, 0.03955177f, 0.14443809f, 
    -0.30003104f, -0.01154994f, 0.24271852f, 0.01271497f, 0.22151621f, 0.56806034f, -0.05690011f, -0.20663695f, 
    -0.30372709f, 0.26387042f, 0.02516293f, 0.03057359f, -0.13480909f, 0.03181984f, -0.08066133f, -0.20256732f, 
    -0.22448955f, 0.01378316f, -0.02685032f, -0.26601547f, -0.13802941f, 0.11778659f, -0.32692009f, -0.02335724f, 
    -0.13949889f, 0.10163788f, -0.21950409f, 0.06128430f, -0.11434120f, 0.33431593f, 0.09488576f, 0.04432217f, 
    -0.23841530f, 0.01613327f, 0.37167275f, 0.04089781f, 0.30928218f, 0.03330984f, 0.02641958f, 0.33339924f, 
    -0.44197646f, 0.09951869f, -0.06847294f, 0.29680812f, -0.19785286f, 0.04792864f, -0.20350498f, -0.30754638f, 
    -0.34913021f, 0.04151814f, 0.05358807f, 0.21225494f, 0.15060194f, -0.09603383f, 0.20152919f, 0.03220636f, 
    0.18496226f, -0.18169755f, 0.04622790f, 0.09520641f, 0.18731317f, -0.00526789f, -0.28792566f, 0.05031291f, 
    -0.11462177f, -0.05391400f, 0.24179353f, -0.14917278f, 0.20001791f, 0.16058683f, 0.17757632f, -0.04232628f, 
    -0.51002610f, 0.05519471f, 0.29194885f, 0.06784850f, -0.11738480f, 0.14951621f, -0.00754567f, -0.02513922f, 
    -0.02846955f, 0.12699701f, -0.09623355f, -0.32028455f, 0.12555309f, -0.16398594f, 0.23568356f, 0.01966625f, 
    -0.09862453f, -0.17309551f, 0.10553040f, -0.05867428f, 0.24838099f, -0.01182406f, -0.01366847f, -0.11235350f, 
    0.29301116f, -0.08174592f, 0.23243286f, -0.12343945f, -0.10137170f, -0.38524875f, -0.08481058f, -0.16070943f, 
    0.05757830f, -0.11657248f, 0.31992957f, -0.17618479f, -0.00633021f, 0.00631416f, 0.06532306f, 0.05558369f, 
    0.12304616f, -0.02906372f, -0.15272300f, -0.03341854f, 0.00422253f, -0.16560729f, 0.36042196f, 0.28112298f, 
    0.07936063f, 0.13322212f, 0.06857944f, 0.04837239f, 0.08620908f, 0.01703403f, 0.05208720f, -0.07074773f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.06952669f, -0.09812942f, 0.24821174f, 0.25401846f, 0.23996824f, 0.10951953f, -0.01349171f, 0.03057437f, 
    -0.20948938f, 0.10260598f, 0.25124168f, 0.07436903f, 0.16080740f, 0.17518635f, -0.32403162f, 0.09803632f, 
    -0.06395204f, -0.09459044f, -0.28928530f, 0.09051263f, -0.15369484f, 0.32897371f, 0.08732875f, 0.00850447f, 
    0.24858917f, 0.14485481f, 0.01579321f, -0.01391118f, 0.07902012f, 0.01722865f, -0.19587246f, -0.03750743f, 
    0.30665985f, 0.06545891f, 0.17836498f, -0.05326669f, -0.04988378f, -0.09371500f, 0.12406588f, 0.07558329f, 
    -0.12629606f, 0.34330428f, -0.11693557f, -0.16286457f, -0.20988350f, -0.10919145f, 0.23488373f, 0.20574459f, 
    0.31847271f, 0.18225893f, 0.13987222f, -0.12226909f, -0.24590826f, 0.07086809f, -0.06944080f, 0.06449959f, 
    0.16053674f, 0.08428174f, 0.02148605f, 0.10447996f, 0.10971564f, -0.12634337f, -0.06840719f, 0.11785827f, 
    -0.01403106f, 0.01932047f, -0.15670829f, -0.08367761f, 0.04681671f, -0.05766061f, -0.09749610f, -0.27107123f, 
    0.15501325f, 0.05045808f, -0.12339333f, 0.17160606f, -0.05968070f, 0.15449446f, 0.03074735f, -0.20497501f, 
    0.05489912f, 0.07340863f, 0.21911919f, -0.16029544f, -0.09236881f, -0.02945210f, 0.00984445f, -0.10582440f, 
    0.15428308f, 0.43113530f, -0.03242647f, 0.04004828f, -0.08455093f, -0.03922168f, 0.15129900f, 0.19441286f, 
    0.02186104f, 0.05817455f, 0.02506079f, -0.00411025f, -0.17875169f, 0.05974095f, -0.04612983f, 0.04687477f, 
    -0.20839694f, -0.12853688f, 0.18302760f, 0.11358033f, 0.05240619f, -0.07619508f, -0.05157052f, -0.06777815f, 
    0.29502821f, 0.16707708f, 0.21901868f, -0.11001717f, -0.07605975f, 0.01786973f, -0.13429336f, 0.10927182f, 
    0.05382168f, -0.19280575f, -0.07857978f, -0.11603049f, 0.14536524f, 0.18208395f, 0.23321344f, 0.21165432f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.17177491f, -0.15257089f, 0.13335679f, -0.12897748f, -0.47247350f, -0.11421348f, 0.14355998f, 0.20258594f, 
    0.09932224f, -0.35530019f, -0.20678465f, -0.15466507f, 0.02348793f, -0.06715371f, -0.13794632f, -0.00972784f, 
    0.25097877f, 0.13609605f, 0.11776372f, -0.38348836f, -0.01787096f, -0.62385350f, 0.11285686f, 0.26780483f, 
    0.08655338f, -0.15998602f, 0.16100664f, -0.03212742f, 0.01314770f, 0.09750188f, 0.03179782f, -0.05727592f, 
    -0.12087478f, -0.13693596f, -0.44418439f, 0.03101080f, 0.00695678f, -0.07331353f, -0.03627978f, -0.01808104f, 
    -0.06930269f, -0.07243208f, 0.09991407f, -0.14541811f, -0.04897224f, 0.05830869f, -0.00721314f, -0.14687046f, 
    -0.41761008f, -0.02797796f, -0.09515668f, 0.00922663f, 0.10506508f, -0.01923749f, 0.17483886f, 0.07789312f, 
    -0.62872267f, -0.08923097f, -0.01570925f, 0.21962680f, 0.00135577f, -0.07768632f, -0.34624702f, 0.01449239f, 
    -0.05769766f, -0.15397303f, -0.02853752f, 0.00822967f, 0.07926496f, 0.09661419f, -0.00101813f, 0.26286480f, 
    -0.09873206f, -0.02866423f, -0.20181184f, -0.39271873f, 0.05357758f, -0.28346422f, 0.08199196f, 0.02685870f, 
    0.00813023f, -0.29825306f, -0.32507145f, 0.05714582f, 0.16320373f, -0.24179408f, -0.20816596f, -0.03894953f, 
    -0.11388968f, -0.05142069f, -0.14506683f, 0.13964164f, 0.07036672f, -0.11148404f, -0.21342117f, -0.20259948f, 
    0.11186009f, 0.06556816f, -0.09346322f, -0.01715347f, 0.24402003f, 0.07423210f, 0.05984026f, 0.15496565f, 
    0.57695818f, -0.18790017f, -0.52814305f, 0.09970423f, -0.20543154f, 0.00275226f, -0.18397719f, -0.02681361f, 
    -0.33530644f, -0.08110140f, -0.22307520f, -0.08556183f, 0.03162166f, -0.01992000f, 0.14606170f, -0.25414419f, 
    0.13589482f, 0.10812958f, 0.19236071f, 0.16377948f, -0.47073492f, -0.18247472f, -0.48309943f, 0.09239154f, 
    0.03530555f, -0.26270431f, -0.09057264f, -0.00206524f, -0.05346447f, 0.11455313f, 0.03917229f, 0.20833255f, 
    -0.02010229f, -0.27188200f, -0.01707370f, 0.09911092f, 0.01854804f, -0.20470296f, -0.18054731f, 0.16355921f, 
    -0.39725730f, 0.04920129f, -0.08216934f, -0.18536349f, 0.01950527f, 0.29828787f, 0.14545076f, 0.45231164f, 
    -0.05904719f, 0.00948242f, -0.34861562f, 0.12575677f, 0.14805782f, 0.10410436f, -0.00455823f, 0.12567380f, 
    0.02384201f, 0.13144454f, -0.38904151f, -0.27843961f, -0.07677603f, 0.04398057f, -0.42686093f, 0.21702144f, 
    -0.25331452f, -0.24626075f, -0.01428236f, -0.35811299f, -0.07693554f, -0.12135375f, 0.18461603f, 0.25292894f, 
    -0.81851947f, 0.26544037f, -0.01426358f, 0.11600068f, -0.21188629f, -0.16514392f, 0.12875602f, -0.03810142f, 
    -0.16061813f, 0.07248183f, 0.00754192f, -0.92608243f, -0.01813700f, 0.09678195f, -0.13564175f, -0.02170849f, 
    -0.13466972f, 0.08923654f, 0.13012196f, -0.01780933f, -0.34843808f, 0.09651727f, 0.00175804f, -0.39003292f, 
    -0.69014871f, -0.05818909f, -0.12794572f, 0.29763195f, 0.27909827f, 0.21619855f, 0.04830215f, 0.00978877f, 
    0.01723023f, 0.10687055f, 0.02502161f, -0.18277204f, 0.02788825f, -0.47724187f, 0.46648714f, 0.09605852f, 
    0.31923145f, -0.13677610f, -0.08259797f, 0.08429443f, 0.07439575f, -0.02650801f, -0.15962312f, 0.11293074f, 
    -0.05436212f, -0.10715258f, 0.12868401f, -0.03707559f, -0.06753222f, -0.10958478f, -0.08930298f, -0.17737278f, 
    -0.11204685f, -0.39894080f, 0.17191136f, 0.00135812f, 0.05930992f, 0.06979478f, -0.32032764f, -0.01287365f, 
    0.03783485f, 0.23887640f, -0.02199487f, 0.04115576f, -0.46896616f, 0.07371169f, -0.56913233f, -0.08133102f, 
    -0.14739339f, -0.02084587f, 0.00289503f, -0.05061180f, -0.14993677f, 0.21740115f, 0.18164364f, 0.26041731f, 
    -0.01281011f, -0.10214939f, 0.04302851f, -0.00677207f, -0.09287201f, -0.10746404f, -0.13732962f, -0.55790913f, 
    0.17525399f, 0.04829883f, -0.07045624f, -0.03529272f, 0.13438010f, 0.23643889f, -0.00863688f, -0.17469938f, 
    -0.09430187f, -0.16715911f, -0.30433160f, 0.14664485f, 0.03798230f, 0.17309193f, 0.06259227f, -0.72940934f, 
    -0.15343583f, 0.22474287f, 0.06857265f, 0.15432638f, -0.04398299f, -0.05110519f, -0.04766522f, -0.00238714f, 
    -0.01937247f, -0.12279238f, 0.09545217f, 0.00506433f, -0.05551728f, 0.18675768f, 0.41133940f, -0.04115725f, 
    -0.10582321f, 0.32531798f, -0.04406567f, -0.41081476f, 0.04584735f, -0.06683327f, 0.18252590f, 0.05762183f, 
    0.18117554f, 0.12720381f, 0.29842082f, 0.01466725f, -0.11334943f, 0.35218725f, -0.09874816f, 0.10687096f, 
    0.18740532f, -0.08555377f, 0.10023231f, -0.39664137f, -0.21181010f, -0.06811291f, -0.00800871f, 0.19398764f, 
    -0.11949784f, 0.09459822f, -0.08450136f, 0.02866856f, -0.02296310f, -0.00459568f, 0.00286228f, 0.04654443f, 
    0.25065947f, -0.05633277f, -0.04404633f, 0.03185471f, 0.00050955f, -0.08193204f, -0.12562586f, -0.00630677f, 
    0.14752601f, 0.36952677f, -0.01195941f, 0.11183213f, 0.12391189f, -0.27254409f, -0.18084745f, 0.12882276f, 
    -0.75948876f, 0.09516804f, -0.07776842f, 0.28744581f, -0.48642150f, -0.01984262f, -0.21808334f, -0.02078100f, 
    0.10754603f, 0.10616434f, 0.00442761f, 0.12697716f, -0.65909010f, 0.11891473f, -0.07493072f, -0.27640498f, 
    -0.11720200f, 0.29843375f, -0.01573122f, -0.28782159f, -0.09548526f, -0.01673839f, 0.13389899f, -0.36766714f, 
    0.10727619f, -0.02296020f, -0.09560338f, -0.05593965f, -0.23142736f, -0.00713528f, -0.21411328f, -0.04405230f, 
    0.09976213f, 0.00011614f, 0.13711765f, -0.21231042f, 0.08963744f, -0.11635972f, -0.01170036f, 0.07585442f, 
    0.10371877f, -0.09861294f, 0.00312464f, -0.08485732f, 0.10771142f, -0.15452057f, 0.11221001f, 0.12905800f, 
    -0.71784925f, 0.06211636f, -0.14727585f, -0.12579411f, -0.03064544f, 0.17266443f, -0.03129925f, 0.03019578f, 
    -0.32704738f, -0.12811033f, 0.03037362f, 0.08712640f, -0.00383555f, -0.22207159f, 0.10187594f, -0.07128710f, 
    -0.83651823f, 0.01428902f, 0.24608491f, 0.20538646f, -0.26747176f, 0.00225333f, -0.22921546f, -0.37134993f, 
    -0.22120470f, -0.36882865f, 0.17679404f, 0.12406501f, 0.05156912f, -0.00031110f, 0.29801926f, -0.09278410f, 
    0.00661805f, 0.09711336f, 0.02157221f, 0.29286626f, 0.05082469f, -0.11085057f, -0.12559976f, -0.07290577f, 
    0.10440382f, 0.04376872f, 0.11414162f, -0.32588702f, -0.12133464f, 0.11568885f, -0.57062316f, 0.05195540f, 
    0.03746070f, -0.03107873f, 0.22851881f, 0.12247796f, -0.69579566f, 0.20763221f, 0.28655389f, -0.32353547f, 
    -0.01845697f, -0.07170659f, 0.28994694f, 0.03424904f, -0.06558612f, 0.02336705f, -0.03828767f, 0.26900119f, 
    0.11651117f, 0.00032240f, 0.09691992f, -0.16162609f, 0.09790683f, -0.56491590f, 0.06334783f, -0.02706669f, 
    -0.58912742f, 0.05917338f, -0.04981975f, 0.00363106f, -0.13237110f, 0.02203486f, -0.26286352f, -0.10158043f, 
    -0.13842556f, 0.06950114f, 0.10071825f, -0.49947298f, -0.03364900f, -0.23013581f, -0.08696310f, -0.43795365f, 
    0.11858924f, 0.27661091f, -0.62253177f, -0.16547665f, -0.49191272f, -0.72319984f, 0.11012425f, 0.00991865f, 
    0.27990744f, 0.22474341f, 0.02089150f, -0.22035359f, 0.15215021f, -0.08547509f, 0.24217562f, -0.03476953f, 
    0.12243012f, -0.38037881f, -0.00835620f, 0.00073180f, 0.12514009f, -0.37468183f, 0.18568373f, -0.02583792f, 
    0.02171374f, -0.12534398f, 0.13362569f, 0.11767097f, 0.23198418f, 0.08106872f, -0.05307129f, -0.25714156f, 
    0.11970775f, 0.28611982f, 0.05256113f, -0.03052854f, -0.33758324f, -0.03653676f, -0.00903997f, 0.06984819f, 
    0.05904827f, 0.15463941f, -0.10817347f, -0.48398721f, -0.12585886f, -0.19146448f, 0.12758076f, 0.03023898f, 
    0.30975151f, 0.00030810f, 0.01632789f, 0.13368677f, 0.05159737f, -0.49780050f, 0.10350220f, 0.04454770f, 
    0.03133668f, -0.13874006f, -0.12082675f, -0.24728468f, -0.03934581f, 0.00817343f, 0.16559243f, 0.17260438f, 
    -0.01160968f, -0.22453010f, 0.07260367f, -0.14110477f, -0.01406600f, 0.10673378f, 0.02617516f, -0.27698290f, 
    -0.02907321f, -0.03498071f, -0.10237096f, 0.17712422f, -0.09330773f, -0.09926963f, 0.01566252f, 0.02826627f, 
    0.11697832f, 0.23626582f, -0.12519361f, -0.01472197f, -0.07442602f, -0.00239957f, 0.04042581f, 0.00745187f, 
    -0.09004116f, 0.00083786f, -0.33654726f, 0.09323640f, 0.02870458f, -0.21279478f, 0.18497939f, 0.01155631f, 
    0.00109439f, -0.11485372f, 0.04698911f, 0.00812825f, 0.02884034f, -0.00710148f, -0.01781413f, -0.16263787f, 
    0.02185992f, -0.07636382f, -0.09977157f, -0.23946041f, 0.10594217f, -0.02553962f, 0.04068708f, -0.02681605f, 
    0.07210275f, -0.19336572f, -0.06034591f, -0.01364923f, -0.13404450f, 0.27590293f, 0.09715410f, -0.04037901f, 
    -0.50447154f, -0.43048128f, -0.06401870f, -0.10472396f, 0.10485896f, -0.07850553f, 0.13064846f, -0.02354363f, 
    0.07688558f, -0.22235394f, 0.16339871f, -0.14325453f, 0.28231019f, -0.09092400f, 0.08891878f, 0.02130101f, 
    -0.65587050f, 0.37159067f, -0.16041596f, 0.18525280f, -0.40673706f, 0.04299222f, -0.12814659f, 0.26705635f, 
    -0.21988520f, 0.10789970f, 0.01737741f, 0.00371589f, 0.11926398f, 0.03619740f, 0.17218447f, -0.17312331f, 
    -0.05968903f, 0.16755781f, 0.09459384f, 0.01253098f, -0.12838152f, -0.18559620f, 0.08839657f, 0.16020574f, 
    -0.14901817f, -0.21443225f, 0.01704340f, -0.02059572f, 0.14365786f, -0.04203185f, 0.01081839f, -0.08406740f, 
    -0.08265228f, -0.00202288f, 0.27825895f, 0.18739095f, 0.09097761f, -0.13239400f, -0.20327564f, 0.11827540f, 
    -0.21927859f, -0.09954245f, 0.11172461f, -0.28350863f, 0.02363933f, 0.03665547f, 0.09703369f, -0.08822857f, 
    0.14667596f, 0.01513804f, -0.02078149f, -0.21688350f, -0.01373655f, -0.08303261f, -0.10172728f, -0.03276647f, 
    0.12123280f, -0.05071742f, -0.22004832f, 0.16380356f, -0.00439204f, 0.07007959f, -0.57956254f, -0.41900563f, 
    0.04066638f, -0.03461654f, 0.12415189f, -0.41521043f, -0.10170700f, 0.10908373f, 0.00127754f, -0.04560497f, 
    -0.00714855f, -0.11678472f, 0.14441793f, -0.01090707f, 0.06831621f, 0.20519398f, -0.53519726f, -0.11970224f, 
    -0.08033105f, -0.07959432f, 0.13872360f, -0.11533105f, 0.20801547f, 0.09504487f, -0.45681754f, -0.16674849f, 
    -0.12307621f, -0.20549224f, 0.16055638f, 0.05708934f, -0.02763899f, 0.13001072f, 0.01051170f, 0.05000569f, 
    -0.41473880f, -0.04261853f, 0.09984218f, -0.07402096f, 0.04661706f, 0.07288375f, 0.10516208f, -0.00960728f, 
    0.05418792f, -0.09000044f, 0.06731115f, -0.08615535f, 0.01482374f, 0.06555080f, 0.02570687f, 0.04527678f, 
    0.02558034f, 0.02442869f, -0.09627286f, -0.47163332f, 0.05917177f, 0.08538012f, 0.01825509f, 0.03190026f, 
    0.18262772f, -0.11334506f, 0.10820086f, -0.07691843f, 0.10275762f, -0.09533653f, -0.00357722f, 0.31615183f, 
    -0.29233748f, -0.47668186f, -0.00659727f, 0.11843473f, 0.30749908f, 0.06824904f, 0.09078230f, -0.25431898f, 
    -0.06250878f, -0.27322936f, 0.01374673f, -0.05989495f, -0.12482800f, 0.04870689f, -0.12091798f, -0.10210367f, 
    0.13570386f, -0.02476993f, -0.11955579f, 0.06992322f, 0.14938757f, 0.10800415f, -0.10250202f, -0.17323534f, 
    0.06285863f, -0.25983024f, 0.37323400f, 0.15361576f, -0.09930835f, -0.22007716f, -0.16176185f, -0.31978431f, 
    0.09536643f, -0.14238706f, -0.56702644f, -0.23800559f, 0.26305172f, 0.34692428f, -0.15875526f, -0.76051879f, 
    -0.05243798f, -0.33777678f, -0.04906777f, 0.17940342f, -0.01752763f, 0.33318698f, -0.57057893f, -0.05354916f, 
    -0.02157760f, 0.27663064f, 0.12280066f, 0.13498791f, 0.04464848f, -0.05738972f, -0.27549204f, 0.12265535f, 
    -0.08093498f, 0.03815782f, -0.08911752f, -0.02639662f, 0.01611159f, -0.18725564f, 0.04390853f, 0.18917517f, 
    -0.17341945f, 0.36809480f, -0.07261820f, -0.61151445f, -0.03757441f, -0.11561901f, 0.05056850f, 0.01688385f, 
    0.33309561f, -0.56255716f, -0.72039181f, 0.00380300f, 0.16121775f, -0.61137038f, 0.21389894f, -0.04587099f, 
    0.10310362f, -0.21441351f, -0.19753380f, -0.34509668f, 0.21261092f, -0.00122464f, -0.17267385f, 0.05765310f, 
    0.05733765f, -0.01296756f, 0.01911582f, -0.07302473f, -0.06811456f, -0.51453960f, 0.03619137f, -0.13513926f, 
    0.30753696f, -0.02457484f, -0.00205782f, 0.17014402f, -0.64843863f, 0.05700168f, -0.64739496f, 0.01240678f, 
    -0.00693283f, 0.25063360f, 0.08753274f, -0.00405404f, -0.07949627f, -0.33144617f, -0.29639807f, 0.00848390f, 
    -0.01202956f, 0.30747342f, -0.25421602f, 0.24768552f, -0.50272304f, 0.05552440f, 0.00049179f, 0.14139751f, 
    -0.84669769f, 0.07114467f, 0.14047436f, -0.01802847f, -0.30651030f, 0.18454832f, -0.87242174f, -0.20874158f, 
    -0.09085222f, -0.43140399f, -0.01150481f, 0.04783143f, -0.09766402f, 0.05334630f, 0.11424130f, -0.49257115f, 
    0.25440407f, -0.34055108f, -0.22531305f, -0.03604636f, -0.36975455f, 0.00518146f, -0.35013178f, 0.03589720f, 
    0.19666967f, -0.16225177f, 0.12066374f, -0.07352483f, -0.55647087f, -0.52068400f, -0.14645216f, 0.13076092f, 
    0.21462248f, 0.05789779f, -0.13290671f, -0.19606651f, 0.16203214f, 0.00139117f, -0.19420250f, -0.58455801f, 
    0.03202488f, -0.04944561f, -0.19967982f, 0.00827667f, -0.80367398f, -0.38657182f, -0.08051983f, -0.28999764f, 
    0.07946841f, 0.06360912f, 0.17350581f, -0.02030476f, 0.06527174f, -0.05939883f, -0.55468297f, -0.12838523f, 
    -0.08146656f, -0.26525262f, -0.02302305f, 0.08546946f, -0.01541675f, 0.11504823f, 0.21550816f, 0.05945197f, 
    -0.11604728f, 0.09464999f, 0.12191202f, -0.08647943f, -0.06575672f, 0.04819996f, 0.60465336f, -0.43542746f, 
    -0.13072717f, -0.58969337f, -0.04644916f, 0.27561566f, 0.03601676f, -0.18654554f, -0.04579974f, -0.03503731f, 
    -0.42863509f, -0.29193193f, -0.68856716f, 0.17027172f, -0.03213968f, -0.37946901f, -0.06395125f, 0.16963327f, 
    -0.26078448f, 0.12760286f, -0.14410639f, 0.21296348f, 0.08164982f, 0.15632451f, 0.15854315f, 0.00361612f, 
    0.06040239f, -0.08502849f, 0.14017698f, 0.03271956f, 0.33126724f, -0.35175076f, 0.06772899f, 0.48197314f, 
    0.28100702f, -0.02043662f, 0.06086205f, -0.21738350f, -0.76100332f, 0.17198668f, -0.39022613f, 0.07283591f, 
    -0.09584132f, 0.01064229f, 0.11946590f, 0.15699540f, 0.04181898f, 0.12122105f, -0.16797313f, -0.12923108f, 
    0.02005726f, -0.24487878f, 0.02085207f, 0.03202291f, 0.13766290f, -0.02050609f, -0.09541188f, 0.10639979f, 
    -0.15236139f, -0.12760484f, -0.05345393f, 0.11425633f, 0.06764781f, 0.04051282f, -0.01311481f, -0.19031832f, 
    0.02019885f, 0.41004127f, 0.00711631f, -0.07163431f, -0.35211667f, 0.02491847f, -0.24056351f, 0.06733917f, 
    0.01940555f, -0.26060063f, -0.30891266f, -0.02639084f, -0.34873933f, -0.11236510f, 0.39922675f, -0.04458337f, 
    -0.22220486f, 0.12751995f, 0.20050165f, -0.04970081f, -0.08860669f, 0.27525672f, -0.06261099f, 0.08999258f, 
    -0.18434714f, -0.02041171f, -0.57137191f, 0.15475121f, 0.22856276f, 0.04193298f, -0.59575200f, -0.62553042f, 
    -0.05619019f, 0.13299394f, 0.30342761f, 0.18020092f, 0.19105776f, -0.17902000f, 0.20038603f, 0.00593579f, 
    -0.10171396f, -0.34850135f, -0.10783894f, -0.36704066f, -0.04342144f, 0.06334951f, -0.32104579f, -0.27917692f, 
    -0.11688767f, 0.14049764f, -0.34589270f, 0.09090040f, 0.09005401f, 0.05652038f, 0.16473164f, -0.28770268f, 
    0.00019144f, 0.10834786f, 0.17881037f, -0.14288703f, 0.01526220f, -0.01696576f, -0.10073785f, 0.11754689f, 
    -0.03603088f, -0.76006359f, 0.22719769f, 0.22290465f, 0.02099306f, -0.13797705f, -0.14080387f, 0.00390506f, 
    -0.57413995f, -0.34702495f, 0.09401320f, 0.20260611f, 0.20168111f, -0.49107209f, -0.25442922f, -0.07407141f, 
    -0.05154295f, 0.20213816f, -0.05612522f, -0.12010317f, -0.18473123f, -0.31897512f, -0.32300818f, 0.35014212f, 
    -0.10700484f, 0.07618132f, 0.00061633f, -0.04992147f, 0.28136748f, -0.81611532f, -0.07695732f, 0.01941369f, 
    -0.42977482f, 0.02005824f, -0.06129059f, -0.07109848f, -0.43991461f, 0.24738467f, -0.05115324f, 0.04529337f, 
    -0.18609855f, 0.19195531f, 0.12050989f, -0.28229991f, -0.05601722f, -0.25212649f, 0.11786108f, -0.28140917f, 
    -0.13941891f, 0.21880451f, 0.30729365f, 0.11143699f, 0.24816135f, -0.13288222f, -0.09319048f, 0.09007426f, 
    -0.18221630f, -0.07049006f, 0.05783555f, -0.07151136f, 0.09144162f, -0.05002903f, 0.10987677f, -0.09623419f, 
    -0.13903147f, 0.00023578f, -0.06479228f, -0.24606350f, -0.25533977f, 0.04720288f, 0.10108478f, -0.05916101f, 
    0.03939631f, 0.01512207f, 0.03678519f, -0.09235515f, 0.21794523f, 0.11943849f, -0.13312969f, 0.12278713f, 
    -0.57485139f, -0.22480345f, -0.59564805f, -0.51280600f, 0.43645778f, 0.11171052f, 0.21322010f, -0.10969036f, 
    0.01517182f, 0.10585469f, 0.15384227f, -0.08979727f, -0.15417716f, -0.02234050f, 0.22634389f, -0.41094756f, 
    -0.17937225f, 0.03598363f, -0.29648039f, -0.28035897f, 0.07902849f, 0.17824304f, -0.25092989f, -0.11814384f, 
    -0.17852336f, -0.19375612f, -0.21105745f, 0.18671229f, 0.04033456f, -0.31993625f, -0.27126172f, -0.22277839f, 
    0.27083281f, -0.21694219f, 0.12312376f, -0.16849831f, -0.07634383f, 0.11476931f, -0.18550774f, 0.16218852f, 
    0.14582257f, 0.02794885f, 0.06240425f, -0.35572699f, -0.06486312f, -0.23296040f, -0.27487966f, -0.15584640f, 
    -0.31354564f, 0.11939151f, -0.24762231f, -0.25063789f, 0.02350752f, -0.08442893f, -0.37856883f, 0.18380269f, 
    0.41825578f, 0.22358787f, -0.31798291f, -0.12372015f, -0.13334174f, 0.12072437f, -0.15271576f, -0.45279807f, 
    0.19666441f, -0.10958634f, -0.22717553f, 0.18334787f, 0.01572103f, -0.10445953f, 0.08410488f, -0.37943232f, 
    -0.07583994f, -0.17329060f, -0.53258097f, 0.00177419f, 0.00640505f, 0.02243856f, -0.02473234f, -0.33554533f, 
    0.11317382f, -0.01394221f, -0.07034305f, 0.24871273f, 0.10641657f, -0.41905650f, -0.14180410f, 0.05573824f, 
    -0.46093595f, -0.51782697f, -0.10555083f, 0.06453287f, -0.26038364f, -0.01872974f, 0.08578212f, -0.66732907f, 
    0.01501703f, 0.09993783f, -0.05604082f, -0.02992364f, -0.12567525f, -0.23137332f, 0.27205604f, -0.01577520f, 
    0.07818576f, -0.08149108f, -0.06575765f, 0.08811878f, 0.07632098f, 0.15118213f, 0.13614751f, -0.30360717f, 
    -0.52222013f, 0.04128446f, 0.20750716f, 0.35972893f, -0.18185195f, -0.07000177f, 0.03874468f, -0.24768044f, 
    0.11644232f, 0.27543467f, 0.21857375f, 0.02780837f, -0.40422505f, 0.10329737f, 0.30559447f, -0.03146240f, 
    0.23980707f, 0.09230602f, -0.09843636f, 0.16007659f, -0.05026068f, -0.58720160f, -0.02499306f, 0.22986859f, 
    -0.68457156f, 0.40189540f, -0.41882861f, 0.26820353f, 0.09995454f, 0.08098563f, -0.36439466f, -0.04498537f, 
    -0.34992003f, 0.25734583f, 0.28952575f, -0.02975636f, -0.38079807f, 0.00950348f, 0.02947368f, 0.19407582f, 
    -0.21114153f, 0.04167006f, -0.35362694f, -0.09963360f, 0.03150638f, -0.00911545f, 0.13518231f, -0.21283114f, 
    0.17578954f, 0.23556466f, -0.16782415f, -0.04078541f, 0.03479799f, -0.50216448f, -0.37418061f, -0.26385343f, 
    0.05672371f, 0.14762940f, -0.52832890f, 0.36970475f, 0.02190708f, -0.47556719f, -0.28761390f, 0.00267213f, 
    -0.19724630f, -0.01253788f, 0.28911024f, 0.02573534f, -0.07918541f, -0.08720130f, -0.26476094f, -0.59925801f, 
    -0.15794598f, -0.33391872f, 0.27553251f, 0.00463850f, 0.12141990f, -0.37687570f, 0.05579654f, 0.49896798f, 
    0.03268017f, 0.12581103f, -0.16148263f, -0.41813740f, -0.51987845f, -0.01146891f, -0.21877602f, -0.13620937f, 
    0.01316756f, -0.00761016f, -0.13229446f, 0.03169150f, -0.25770131f, -0.06097763f, -0.01615280f, -0.07124818f, 
    0.00574689f, 0.05114629f, 0.13759612f, -0.42848751f, -0.13111036f, 0.10676136f, 0.14876010f, -0.04382955f, 
    -0.19209550f, 0.26737604f, 0.01373275f, -0.19522116f, -0.27187237f, 0.22505590f, -0.87218058f, -0.34662265f, 
    -0.24063538f, 0.08422445f, -0.30213627f, -0.43609080f, -0.08974959f, -0.26737773f, 0.01140384f, 0.01551474f, 
    -0.17041183f, 0.21987385f, -0.23300223f, -0.08712295f, -0.28908604f, -0.13741413f, 0.14823087f, -0.04423181f, 
    -0.22847305f, -0.63581711f, -0.04497286f, 0.04707207f, 0.10870186f, -0.05163758f, 0.09709949f, -0.36407921f, 
    -0.01596045f, -0.23642173f, 0.17989755f, -0.00338378f, -0.24857453f, 0.06493957f, -0.20537682f, -0.00646769f, 
    -0.26565683f, 0.06651003f, -0.23924282f, -0.07409724f, -0.31273520f, 0.37346166f, 0.16952255f, -0.43231642f, 
    -0.51866490f, -0.04160856f, -0.39966056f, -0.02441839f, 0.15603293f, 0.04073782f, -0.33565092f, 0.23583627f, 
    0.32355985f, 0.03749325f, 0.12841494f, 0.22072147f, -0.15722299f, -0.02558841f, -0.34843522f, -0.19766594f, 
    -0.23151486f, -0.45002627f, -0.04373611f, 0.22364463f, 0.04639417f, 0.06719859f, -0.04728937f, -0.15193251f, 
    0.06015372f, -0.04240784f, -0.11057708f, 0.00936224f, -0.09068136f, -0.09119006f, 0.05535106f, -0.23597890f, 
    0.17219873f, 0.03398640f, 0.37669373f, -0.19787383f, 0.06276245f, -0.05072049f, 0.06247170f, 0.01380441f, 
    0.19036651f, -0.16744730f, -0.51569629f, 0.18908836f, -0.09409603f, -0.10497686f, -0.19301163f, -0.15980402f, 
    0.15136501f, -0.23811908f, -0.44775617f, -0.06332728f, 0.07604049f, 0.06774403f, 0.37265432f, -0.35496104f, 
    0.17691256f, 0.02171573f, 0.38159952f, 0.26344857f, 0.09368313f, -0.00796419f, 0.11368261f, 0.20978236f, 
    -0.04434946f, -0.14514557f, -0.21346258f, 0.06147840f, -0.04463087f, -0.06467703f, -0.05041370f, -0.42567322f, 
    -0.37831002f, 0.01706568f, 0.14161119f, 0.14546067f, -0.23881696f, -0.01553296f, -0.04186332f, 0.01777919f, 
    0.08410159f, -0.34030148f, 0.22165762f, 0.18727660f, 0.05027539f, 0.49737328f, -0.14204143f, -0.01961753f, 
    0.14130449f, 0.11309291f, -0.00770452f, -0.68051243f, -0.23611863f, -0.15455115f, 0.10034303f, 0.07860296f, 
    0.02995316f, 0.12743308f, 0.02697726f, -0.11814465f, 0.21072979f, 0.26180947f, -0.23640525f, -0.41122991f, 
    -0.06763482f, 0.16850084f, 0.09857047f, -0.10475290f, -0.26473698f, -0.04813763f, 0.07106745f, 0.14153934f, 
    -0.02101316f, -0.51951885f, -0.14208761f, -0.06153406f, 0.40351874f, -0.06567980f, -0.73110479f, 0.13855372f, 
    0.07716542f, -0.42143103f, -0.34585297f, -0.45492911f, 0.34772068f, -0.29443201f, 0.06184119f, -0.37075874f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.23666824f, 0.10358384f, -0.01227066f, -0.09222410f, -0.09013075f, -0.01965847f, -0.01794635f, -0.16079822f, 
    0.14760146f, 0.02615376f, 0.09138343f, -0.02763993f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
