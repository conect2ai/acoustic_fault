#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.16924931f, 0.79199481f, 0.21844561f, -0.86719644f, 0.49705473f, 0.47228584f, 0.21984081f, 0.08776372f, 
    -0.47182792f, -0.81870943f, 0.26630515f, 0.19640818f, 0.80460846f, 0.02501460f, 0.17015868f, 0.24688254f, 
    -0.28641272f, -0.19342890f, 0.81448370f, 0.24508815f, 0.41930687f, 0.07348461f, 0.52043658f, 0.53600562f, 
    -0.50719965f, -0.38415542f, -0.41398275f, 0.39121091f, 0.02976032f, -0.51390529f, -1.00818932f, -0.54746842f, 
    -0.84754914f, 0.21791348f, 0.38317388f, 0.14121746f, 0.59669226f, -0.11212897f, 0.10408816f, 0.33782330f, 
    -0.22398894f, 0.54884219f, 0.49886218f, -0.50500268f, 0.47834265f, 0.77164304f, -0.56862754f, -0.37715825f, 
    -0.48916650f, -0.50919265f, -0.53288609f, -0.31336802f, -0.15684196f, 0.04601010f, 0.83488905f, 0.17074500f, 
    -0.43655938f, 0.61328083f, 0.65843302f, 0.15063736f, -0.48024714f, -0.12239874f, -0.03618122f, -0.65110880f, 
    -0.77862656f, 0.00056540f, 0.39347452f, -0.24152045f, -0.02563311f, -0.01827074f, -0.03389314f, -0.21915066f, 
    -0.19623154f, -0.02377367f, -0.53648186f, 0.89261085f, -0.64667779f, -0.52330166f, -0.12400115f, -0.39371738f, 
    0.46396396f, 0.12598690f, 0.21765195f, 0.92543906f, 0.54302794f, -0.25359836f, 0.26678306f, 0.46964318f, 
    0.55922151f, 0.05384698f, 0.84985989f, 0.58923918f, -0.58350015f, 0.35725892f, 0.56660348f, -0.03822276f, 
    0.49086013f, 0.11997196f, -0.12141725f, 0.33556229f, -0.77750438f, -0.01404892f, -0.73748428f, 0.93853712f, 
    0.09199054f, 0.23517649f, 0.27386630f, -0.19747926f, -0.28332576f, -0.90938437f, -0.62134802f, -0.59008551f, 
    -0.42179725f, 0.18370865f, 0.25517944f, 0.41542876f, 0.23154533f, -0.89862245f, -0.08034643f, -0.35981432f, 
    0.33217254f, 0.54834235f, 0.68667996f, 0.04562603f, 0.47710019f, 0.42394453f, -0.96945798f, 0.71385056f, 
    0.77098191f, 0.20804909f, 0.25336808f, -0.56140262f, 0.05308794f, 0.22970261f, -0.06643429f, -0.72731227f, 
    -0.66897947f, 0.32147732f, -0.67661917f, -0.33032587f, -0.11404739f, 0.44052541f, 0.19709498f, 0.24058908f, 
    -0.48368907f, 0.24533261f, -0.58849466f, -0.09093190f, 0.81708127f, -0.76461983f, 0.01904468f, 0.15129332f, 
    -0.34900519f, 0.56591094f, 1.13233328f, 0.05947124f, -0.27168471f, -0.38562870f, 0.39372510f, 0.32780975f, 
    0.09340478f, 0.03707150f, -0.55332303f, 0.88206255f, 0.68013400f, -0.09316015f, -0.34118751f, 0.58009851f, 
    -0.34301040f, -0.16284393f, 0.47892961f, -0.69980448f, -0.44351786f, -0.39423493f, 0.63243932f, 0.83629316f, 
    0.48439723f, 0.26856232f, -0.51571667f, 0.09687405f, 0.92517108f, 0.96423864f, -0.40450516f, 0.36895555f, 
    0.44874698f, -0.61447006f, 0.04851826f, -0.16325520f, 0.00819205f, 0.90069318f, 0.08085744f, 0.87212604f, 
    0.24604374f, -1.03036058f, -0.12879172f, 0.11600769f, 0.05000415f, -0.13973141f, 0.29282019f, 1.00773668f, 
    1.06619322f, -1.16518998f, 0.38660741f, -0.54108101f, 0.15665820f, 0.14905822f, 0.00480066f, -0.48275140f, 
    -0.57409376f, -0.09685417f, -0.60979784f, -0.33522409f, 0.55008405f, -0.35008878f, -0.36326629f, -0.14703454f, 
    -0.55531812f, -0.91717285f, -0.54468143f, 0.48639339f, 0.64991045f, -0.54268324f, -0.54571009f, 0.34041935f, 
    0.32365167f, -1.14427149f, 0.54995173f, -0.26738214f, 0.09820647f, 0.62267435f, -0.30795196f, -0.24977498f, 
    -0.10929249f, 0.21825175f, -0.11458676f, -0.95877993f, 0.81489646f, 0.29528433f, -0.48274291f, -0.26331758f, 
    0.06822218f, -0.22432013f, 0.11853217f, -0.45400614f, -0.59535503f, -0.68421972f, 0.46874890f, -0.14805551f, 
    -0.29997674f, -0.46832454f, -0.38762322f, -0.10457413f, -0.89797050f, 0.47654647f, -0.58469975f, -0.57895768f, 
    0.27431425f, -0.38104868f, 0.02531974f, -0.39649782f, 0.24371462f, 0.10220609f, -0.54830372f, -0.17841819f, 
    0.37654656f, 0.74084067f, 0.71474338f, 0.22406018f, 0.51313692f, 0.32146493f, 0.67760623f, 0.23102811f, 
    -0.78915966f, 0.23710831f, -0.67514753f, -0.11649553f, -0.51629555f, 0.25454146f, 0.14021781f, 0.45777139f, 
    -1.05832112f, -0.63831282f, 0.39126402f, 0.41922942f, 0.56749684f, -0.40285653f, -0.35037926f, -0.23683414f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.30746132f, -0.00142152f, -0.01034067f, 0.10225368f, 0.02249795f, 0.09517263f, 0.03900894f, 0.13556990f, 
    0.24400821f, 0.23941022f, 0.05775314f, -0.07619103f, -0.03163366f, 0.36229008f, -0.07045085f, 0.31737617f, 
    -0.03696422f, 0.08838810f, 0.11586981f, -0.04820761f, 0.16438754f, 0.20156103f, 0.26193231f, -0.11030404f, 
    -0.03419375f, 0.07323945f, -0.00631125f, 0.09724157f, 0.18279077f, -0.15410931f, -0.01692445f, 0.07189010f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04569321f, 0.03311609f, -0.00715212f, 0.02894133f, -0.03975695f, 0.02399385f, -0.03792801f, -0.02853082f, 
    -0.01227595f, -0.02494466f, 0.00764722f, 0.00017548f, -0.02483491f, -0.04576685f, -0.00019821f, 0.02036073f, 
    0.00229998f, 0.02063524f, -0.01637934f, 0.01622710f, 0.02910129f, 0.00831297f, -0.02380937f, 0.00421262f, 
    0.02896803f, -0.02045110f, 0.00767677f, 0.02342628f, -0.01379899f, 0.01592448f, -0.01584687f, -0.03087663f, 
    0.00826465f, -0.03181073f, -0.03664855f, 0.02231042f, -0.02018038f, 0.00404493f, 0.00200113f, -0.01248051f, 
    -0.02614772f, -0.00166496f, 0.02446186f, 0.02120783f, 0.00874842f, -0.03273666f, -0.01457976f, 0.03701188f, 
    -0.00497695f, -0.04242312f, -0.01491197f, -0.02154139f, 0.01133917f, 0.02542731f, -0.02009476f, 0.01393085f, 
    -0.03524138f, -0.03355571f, -0.02307832f, 0.01424939f, 0.03263412f, -0.01485235f, 0.02226673f, -0.04158300f, 
    -0.04043562f, 0.00168771f, 0.00379887f, 0.00661045f, 0.00688242f, 0.02316704f, -0.00136219f, -0.01238860f, 
    -0.04130362f, 0.02139914f, 0.03166039f, 0.01079614f, 0.02464736f, 0.02066273f, 0.00011227f, -0.00807005f, 
    -0.02093031f, 0.00491843f, -0.02857931f, -0.00813869f, 0.02558967f, -0.04140455f, -0.03518682f, 0.01600138f, 
    -0.02855073f, -0.03218621f, -0.01201262f, 0.01466883f, -0.01101873f, 0.01848288f, 0.00766890f, -0.00297871f, 
    0.03335016f, -0.02796716f, 0.03205936f, -0.01513677f, -0.03367122f, -0.01182563f, 0.03475301f, -0.04277282f, 
    -0.02513661f, -0.01584317f, 0.00740479f, -0.03224174f, 0.00975436f, -0.04211308f, 0.02149426f, 0.01479003f, 
    0.02877118f, -0.03722336f, -0.00991410f, -0.03327730f, 0.01034681f, -0.02670139f, -0.03295862f, -0.01376447f, 
    0.03408189f, 0.02444577f, 0.00054851f, -0.02496296f, 0.02294780f, -0.01316783f, 0.02254887f, 0.02097637f, 
    -0.02668909f, 0.01066170f, -0.01965941f, -0.02266440f, -0.02951504f, 0.00565108f, -0.03515989f, 0.01976020f, 
    -0.00811340f, -0.00709457f, -0.00055927f, -0.00518115f, 0.02022355f, -0.03682365f, -0.02295315f, -0.02946954f, 
    0.02578069f, 0.01546533f, -0.03888810f, -0.00733391f, -0.01990539f, -0.03029352f, -0.00012054f, 0.00885439f, 
    -0.02884320f, -0.02723120f, 0.00403652f, 0.03386689f, -0.02251553f, -0.03581873f, 0.02194089f, -0.00950682f, 
    -0.00611586f, -0.01211894f, -0.04221150f, -0.04300910f, -0.02491941f, 0.02131785f, -0.03031520f, -0.02384281f, 
    -0.02669340f, -0.00463433f, -0.00797842f, -0.02327236f, -0.03893719f, -0.04389513f, 0.01408343f, -0.02034463f, 
    0.02084711f, -0.03662499f, 0.02130569f, -0.00167702f, -0.00236597f, -0.04330939f, -0.01342016f, 0.02281518f, 
    0.00242752f, -0.03698812f, -0.00734583f, -0.00167962f, 0.02841683f, -0.03639133f, 0.00247969f, -0.02347202f, 
    0.03015067f, 0.01360897f, 0.02287273f, 0.02526224f, 0.02926229f, -0.02197930f, -0.00515688f, 0.02382993f, 
    0.01213342f, -0.04252227f, 0.03129648f, 0.01122899f, -0.00659025f, 0.02279056f, -0.00191248f, -0.00438383f, 
    0.03150712f, -0.02714008f, -0.01484483f, -0.03581932f, 0.03205753f, 0.02817193f, 0.02926334f, -0.02160970f, 
    -0.03935065f, 0.01531461f, -0.03136161f, -0.01142263f, 0.02484211f, 0.00884187f, -0.03851207f, -0.04301770f, 
    0.00751091f, -0.01290486f, -0.00607638f, -0.00559346f, -0.01757527f, -0.00320631f, 0.01152448f, -0.00366107f, 
    0.02014519f, -0.03699271f, -0.02323617f, -0.00748189f, -0.01013588f, -0.03440221f, 0.02288743f, 0.02181083f, 
    0.02316074f, -0.01155463f, -0.01998616f, -0.00224322f, -0.01859135f, -0.00009398f, 0.03794086f, 0.00148285f, 
    -0.03592397f, -0.03347716f, 0.00346381f, -0.00253957f, -0.02685763f, -0.01392769f, 0.02764994f, -0.04278002f, 
    0.00833733f, -0.03092270f, 0.02675162f, 0.01314636f, -0.00503574f, -0.00091421f, -0.01493195f, -0.04174873f, 
    -0.04238367f, 0.01289237f, -0.02234326f, -0.03831766f, 0.02696950f, -0.00668617f, -0.04246955f, -0.03601969f, 
    -0.01977324f, -0.02253258f, 0.00636726f, -0.04013734f, 0.01008455f, 0.02713337f, -0.00505696f, 0.00804729f, 
    0.01839293f, 0.01223902f, -0.03481871f, -0.01878073f, -0.01050958f, 0.01383273f, -0.02058917f, -0.03954566f, 
    0.01412659f, -0.03860496f, 0.00902886f, -0.01880171f, -0.01826217f, -0.04236367f, 0.03188379f, -0.01758878f, 
    0.02168584f, -0.01788943f, -0.00699107f, -0.00902631f, 0.02937912f, -0.03852549f, -0.03531560f, 0.00252000f, 
    0.00644002f, 0.03044276f, -0.03967129f, -0.02666201f, -0.01953313f, 0.00193494f, 0.02897703f, -0.04551686f, 
    -0.02774612f, -0.00937849f, 0.03008553f, -0.01175298f, 0.00742913f, -0.03951520f, 0.00367990f, -0.03225818f, 
    0.03287961f, -0.04092803f, -0.00703656f, -0.03257043f, -0.04137287f, 0.01191931f, 0.01470140f, 0.02206396f, 
    -0.03051655f, -0.03847581f, 0.00043102f, 0.03267589f, -0.02269820f, 0.01203426f, -0.02456443f, 0.02593507f, 
    -0.03181214f, 0.02472169f, -0.02349618f, 0.00474871f, -0.00971222f, 0.02005831f, 0.02548605f, -0.04284431f, 
    -0.03265721f, 0.00678303f, -0.01173682f, 0.03326981f, 0.00753277f, -0.03673497f, -0.00310843f, 0.03132947f, 
    0.01985429f, -0.03963299f, 0.02893048f, 0.02543054f, -0.02472844f, 0.03435324f, -0.03465230f, 0.02011612f, 
    0.01155085f, -0.03845837f, -0.01090089f, -0.03512909f, -0.01232743f, -0.02548800f, 0.03186371f, -0.02301510f, 
    0.02553811f, -0.01710226f, -0.03675639f, -0.01105605f, -0.04407200f, -0.04029144f, -0.04573726f, -0.00038705f, 
    0.01704359f, 0.01876043f, 0.02883491f, -0.00066541f, -0.00980731f, -0.02486432f, -0.02574044f, -0.01515054f, 
    0.02418184f, -0.03448481f, -0.00597144f, -0.01188123f, -0.03545257f, -0.03766711f, -0.01872394f, -0.03201349f, 
    0.01201274f, -0.03136315f, -0.03200556f, -0.01009717f, 0.00257145f, 0.02536914f, -0.04036545f, 0.03087922f, 
    0.02434563f, -0.04565965f, -0.04064194f, 0.00104313f, -0.03790125f, 0.03357998f, 0.02322563f, 0.03520485f, 
    -0.03814455f, 0.00018075f, 0.01518700f, 0.01710390f, -0.00418235f, -0.00515161f, -0.03471485f, -0.03781543f, 
    -0.02143923f, -0.03918334f, -0.00577914f, 0.00668759f, -0.00014876f, -0.02658064f, -0.00885653f, 0.00181777f, 
    -0.02148910f, 0.01525777f, 0.01670055f, -0.00083071f, -0.01201425f, -0.04476720f, 0.03006458f, 0.02246320f, 
    0.02827351f, -0.02376169f, 0.02117733f, 0.00923172f, 0.03470381f, -0.02331564f, -0.04470377f, 0.02859496f, 
    -0.03480083f, -0.02399010f, 0.02593482f, -0.03814803f, 0.01986714f, -0.03575627f, -0.00128904f, 0.01596651f, 
    -0.02981890f, -0.01303767f, 0.01121965f, -0.00809836f, -0.00691423f, 0.03240482f, -0.00435659f, -0.01866535f, 
    -0.01018489f, 0.02318266f, 0.00046615f, 0.02219070f, -0.01216953f, 0.01046026f, 0.00482515f, 0.03233506f, 
    0.02149933f, -0.00723731f, 0.01683126f, -0.00849759f, -0.04200031f, 0.00813093f, -0.04308686f, -0.01889462f, 
    0.02291635f, -0.02058771f, 0.01661217f, -0.01114453f, -0.00690281f, 0.00399986f, -0.02334583f, -0.02980352f, 
    -0.03879062f, -0.01421854f, -0.03082372f, -0.00041121f, 0.00856664f, 0.01596125f, 0.02856588f, -0.03602625f, 
    0.00283503f, 0.01652920f, 0.03389741f, 0.01599421f, -0.00333843f, -0.03198609f, -0.00943021f, -0.00214900f, 
    -0.00259978f, 0.01067653f, -0.03460184f, 0.01288971f, 0.01065214f, -0.01765374f, -0.00393024f, -0.02101887f, 
    -0.02634246f, 0.02064612f, -0.02046276f, -0.02044968f, 0.02211861f, 0.01218252f, -0.04635726f, -0.02167912f, 
    -0.02957855f, 0.00420652f, 0.00015524f, -0.00887075f, 0.02836875f, -0.04135619f, -0.03971421f, -0.03290071f, 
    0.02118611f, 0.03333475f, -0.00343960f, -0.00433809f, 0.00635044f, -0.01742295f, -0.02634095f, 0.02213286f, 
    -0.03418542f, 0.03223770f, 0.02887555f, -0.01766613f, -0.01088876f, -0.02885654f, -0.00932571f, 0.01580645f, 
    0.00202977f, -0.03131245f, -0.02641426f, -0.01878402f, -0.01275633f, 0.00919912f, 0.01507021f, 0.03648210f, 
    -0.02572767f, -0.01482057f, -0.00427578f, -0.01955321f, -0.01683774f, 0.01466809f, -0.02088978f, -0.01917216f, 
    -0.03218051f, 0.00167698f, -0.04038211f, -0.04082283f, 0.01464349f, -0.02924697f, 0.03114643f, 0.02062541f, 
    -0.02373964f, 0.00103961f, -0.02418821f, -0.02922026f, -0.03603487f, 0.00633572f, -0.00843865f, -0.01819722f, 
    -0.00603107f, -0.02779450f, -0.01441221f, -0.01167311f, 0.00492757f, -0.03891662f, -0.01349527f, -0.01952189f, 
    -0.00557887f, 0.03389432f, 0.00989279f, 0.01343086f, 0.03278646f, 0.02463390f, -0.02024080f, 0.02638131f, 
    -0.03834231f, -0.01045489f, 0.02276769f, -0.00689104f, -0.03997092f, 0.01183755f, -0.01217239f, 0.02585199f, 
    -0.03285982f, -0.02518763f, -0.01770766f, -0.04370121f, 0.00444205f, -0.02233996f, -0.00494205f, 0.00556152f, 
    0.02570765f, -0.01552684f, 0.02824779f, -0.02739144f, -0.03003978f, -0.02208732f, 0.00811465f, 0.02848176f, 
    0.00621782f, 0.02249684f, 0.02877108f, -0.00492853f, 0.00554717f, 0.00026977f, -0.02193715f, 0.00343088f, 
    0.02142240f, -0.02470988f, -0.01937400f, 0.02502954f, -0.02832093f, 0.02085681f, -0.01143990f, 0.02869432f, 
    0.00511983f, -0.00993559f, -0.03323025f, 0.01110038f, -0.04162560f, 0.03284879f, -0.04176813f, -0.02794126f, 
    -0.01065600f, -0.02637312f, 0.03250542f, -0.02362413f, 0.00461110f, -0.03015585f, -0.02295947f, -0.01967445f, 
    -0.03449481f, -0.18049636f, 0.14917140f, 0.06343746f, -0.10327861f, 0.05850591f, 0.03231594f, 0.07725739f, 
    -0.09064143f, 0.08352416f, 0.05127158f, 0.00923353f, -0.01054887f, -0.09582267f, 0.04036459f, 0.04155093f, 
    0.14073348f, -0.11866235f, 0.04328499f, 0.05022283f, 0.20964193f, 0.10100656f, -0.21533756f, 0.00728663f, 
    0.04640945f, -0.02586924f, -0.05621453f, 0.02256492f, 0.09348750f, 0.07061515f, -0.11459137f, -0.07457420f, 
    0.10950669f, -0.00907650f, 0.06236286f, -0.02612226f, 0.01763126f, -0.07734197f, -0.04691872f, -0.01822575f, 
    -0.15158661f, -0.03644515f, 0.05900379f, 0.03983397f, -0.08075532f, 0.06066932f, 0.08612799f, -0.04816115f, 
    -0.02383880f, -0.02151632f, 0.03644739f, -0.02137750f, -0.01047087f, 0.06352206f, 0.11763383f, 0.10126267f, 
    0.06279610f, -0.09855106f, -0.04000228f, -0.01506420f, -0.13863572f, 0.04675471f, -0.08808603f, 0.06596622f, 
    -0.04809375f, -0.00665741f, 0.07652915f, -0.00743943f, -0.06046941f, 0.02809112f, 0.05792009f, -0.00422660f, 
    -0.01427354f, -0.01267458f, 0.02058738f, -0.05354449f, -0.00109158f, 0.09034254f, 0.10566451f, 0.10097072f, 
    0.05686303f, 0.00290866f, -0.15958068f, -0.06581750f, -0.10216620f, -0.07254257f, 0.14572385f, 0.01837190f, 
    0.02510138f, -0.00368668f, 0.05448681f, -0.01397086f, 0.08084566f, 0.08068592f, 0.10987883f, -0.08696438f, 
    0.02512384f, -0.06089988f, -0.03943300f, -0.08860629f, 0.06630471f, 0.31475505f, -0.12667432f, 0.00951273f, 
    -0.05823416f, -0.00959833f, 0.01785444f, 0.03063572f, -0.00315384f, -0.07728436f, -0.03906418f, -0.06578756f, 
    0.01589233f, 0.00603249f, 0.04339954f, 0.18560840f, 0.13316433f, 0.11065963f, 0.06579699f, 0.13474508f, 
    -0.16531208f, 0.08511247f, -0.12795880f, 0.13364384f, 0.01599944f, 0.04176372f, 0.00726120f, 0.02892488f, 
    -0.07183287f, 0.05525545f, -0.01182499f, -0.06631824f, 0.01809042f, 0.02452742f, 0.02104113f, 0.08236545f, 
    0.03551097f, 0.03092796f, -0.11176677f, -0.04206189f, 0.09062731f, 0.04434073f, 0.03386993f, -0.09124991f, 
    0.18992068f, 0.03233392f, -0.00822459f, 0.03170452f, 0.01160717f, 0.03727206f, -0.00770973f, 0.04359044f, 
    -0.01624339f, -0.03207330f, 0.02121366f, 0.12384945f, 0.00060575f, -0.05701939f, 0.04404724f, 0.01401965f, 
    0.08541278f, 0.00324568f, -0.01549181f, -0.00796848f, -0.05893115f, -0.05027873f, 0.03687334f, 0.05107726f, 
    0.12860717f, -0.04766935f, -0.01014768f, 0.08053365f, 0.00008533f, 0.03972380f, 0.10398839f, -0.03198029f, 
    0.03460901f, 0.13468802f, -0.01867601f, -0.03890149f, 0.16025691f, -0.00153628f, -0.14884046f, -0.08981370f, 
    0.03519915f, 0.14628643f, -0.04273776f, 0.06237226f, -0.00037688f, -0.02354795f, -0.06971520f, 0.00270014f, 
    0.03489082f, 0.16041620f, -0.00323227f, 0.08737426f, 0.03309103f, -0.06536759f, -0.02305334f, -0.08675630f, 
    -0.33857945f, 0.19448626f, -0.01590113f, 0.13354340f, -0.03304655f, 0.14555405f, 0.16616911f, -0.10775975f, 
    -0.00095726f, -0.08908524f, 0.00499194f, 0.06777319f, 0.02511731f, -0.02315529f, -0.00152181f, 0.03142775f, 
    0.01965985f, -0.01957384f, -0.12095250f, 0.02924468f, -0.21889904f, 0.07562550f, 0.11191726f, -0.10753611f, 
    -0.01248371f, 0.10661822f, 0.14795895f, -0.02690421f, -0.01341349f, -0.00018161f, -0.12723212f, 0.01337713f, 
    0.14495482f, 0.07846098f, 0.06093719f, 0.02474273f, 0.19436201f, -0.04953923f, -0.05834515f, -0.08278455f, 
    -0.09690551f, 0.23448867f, 0.06283560f, 0.06648536f, 0.22252181f, 0.03552714f, 0.10177045f, 0.00861567f, 
    0.03504270f, 0.03248993f, 0.04230195f, 0.08012541f, -0.04192457f, 0.00067590f, 0.01697375f, -0.11361484f, 
    -0.01972920f, -0.10744625f, 0.00605977f, -0.01634039f, 0.11059092f, -0.13601501f, 0.05330976f, 0.05988349f, 
    0.10728509f, -0.01284301f, 0.06087244f, 0.06056786f, -0.00583943f, -0.02984981f, -0.02868290f, 0.00464779f, 
    0.05671387f, 0.12849264f, 0.00508591f, -0.03068254f, -0.03559866f, -0.08286333f, -0.01246871f, -0.04473901f, 
    0.28231660f, 0.16751176f, 0.06965052f, -0.03481972f, 0.13878010f, 0.05371053f, -0.00122286f, 0.02195176f, 
    0.07747492f, 0.03692644f, 0.05898359f, 0.07160439f, -0.08361822f, 0.07333682f, 0.12876338f, 0.01287214f, 
    0.03333528f, -0.00198280f, -0.03522088f, 0.02301111f, 0.07246165f, 0.02485357f, 0.05461674f, 0.00620339f, 
    0.19167127f, 0.04072868f, -0.00213874f, 0.08802981f, -0.15051322f, 0.12988213f, 0.01636635f, 0.03054823f, 
    0.03060855f, 0.02295787f, 0.01562934f, -0.05399136f, -0.00142134f, 0.05219765f, 0.05462870f, 0.09035738f, 
    -0.10791931f, 0.16584440f, 0.29810426f, 0.15100062f, 0.02108421f, 0.10045271f, 0.08391280f, 0.04474368f, 
    0.03152150f, -0.05988579f, -0.08481787f, 0.05572883f, 0.02408311f, 0.08389250f, -0.09370324f, -0.01587621f, 
    -0.01671520f, 0.07017179f, 0.09686729f, 0.06723505f, -0.08957426f, -0.14544345f, -0.00466775f, 0.08001821f, 
    -0.17868525f, 0.04048368f, 0.05851652f, -0.00669929f, 0.03159484f, 0.06281888f, 0.05412322f, 0.03127069f, 
    0.01057827f, -0.08784306f, -0.03642283f, -0.09890960f, -0.02442530f, -0.07565752f, 0.09326771f, -0.00583205f, 
    0.19802494f, -0.07922057f, 0.06331835f, 0.02442974f, 0.02438715f, 0.02194750f, -0.07346297f, -0.00165422f, 
    0.11475176f, 0.04278018f, 0.03953099f, 0.00911146f, -0.05651402f, -0.00261422f, -0.10329284f, 0.04229831f, 
    -0.00313574f, -0.15364383f, -0.02495047f, -0.02973120f, -0.21739377f, -0.22257781f, 0.00068625f, 0.07432673f, 
    0.11066686f, -0.03377529f, -0.00593633f, 0.08716521f, 0.04679136f, 0.06247474f, -0.06303878f, -0.01606693f, 
    0.18076158f, 0.04014246f, -0.04682987f, -0.13582224f, 0.05931575f, 0.05709405f, 0.12611084f, 0.05647204f, 
    -0.30522260f, 0.32089999f, 0.03324964f, 0.11698993f, -0.17426001f, 0.09294688f, 0.07046673f, -0.12334450f, 
    0.10648865f, 0.01764881f, -0.03629261f, 0.05429218f, 0.04063932f, 0.07837197f, 0.08855133f, 0.09579662f, 
    0.05862869f, 0.00757526f, -0.08504231f, 0.04078059f, 0.09513237f, 0.10782114f, -0.13475613f, 0.00202806f, 
    -0.08540569f, 0.08433222f, 0.16088966f, -0.01499116f, -0.00519593f, 0.02469355f, 0.10050945f, 0.14005563f, 
    -0.02725626f, -0.08654556f, -0.01853000f, 0.03342807f, 0.02556597f, 0.14713354f, 0.04030448f, -0.00732468f, 
    -0.16545337f, -0.14306273f, 0.25318614f, -0.00278759f, -0.01195047f, 0.06110895f, -0.06584846f, -0.02204660f, 
    0.03322453f, 0.01431262f, -0.01551102f, 0.06608891f, -0.05151199f, -0.04000727f, -0.08085125f, -0.01910169f, 
    -0.04704471f, -0.07861226f, 0.13549541f, -0.00072794f, 0.09629840f, 0.03619043f, 0.05613074f, 0.06462945f, 
    0.18654220f, 0.12140872f, -0.03750833f, 0.15098155f, 0.01829167f, -0.00071926f, -0.01382424f, 0.05952205f, 
    -0.01755179f, -0.04004747f, 0.06792083f, 0.12796991f, 0.05303685f, 0.04908975f, 0.05696242f, 0.00094329f, 
    -0.31030110f, 0.09653694f, 0.20525390f, 0.07191083f, 0.19013171f, 0.08975228f, 0.00930542f, -0.01613137f, 
    0.02832022f, 0.04714511f, 0.06983420f, 0.08820938f, -0.11912982f, 0.13822785f, -0.01216657f, 0.03659051f, 
    -0.01449473f, 0.07021568f, 0.09907268f, 0.10104054f, 0.23731351f, -0.12542057f, 0.07660803f, 0.07043241f, 
    0.00433362f, 0.02649028f, 0.00526704f, 0.10889305f, 0.02620508f, 0.09179208f, -0.06452881f, 0.00203792f, 
    -0.08281124f, 0.09844273f, 0.00329122f, 0.06516149f, 0.11573026f, 0.06378785f, 0.06641205f, 0.16034339f, 
    0.29085937f, -0.02053215f, -0.07023397f, -0.11421726f, 0.30115983f, 0.09267740f, 0.00513919f, -0.01578926f, 
    -0.03182840f, -0.00000249f, 0.03728522f, -0.04859381f, 0.02381580f, 0.03375357f, -0.12152186f, 0.04359938f, 
    -0.00932306f, 0.06445358f, 0.01853438f, -0.00298528f, -0.10552488f, 0.06225631f, 0.12957022f, -0.02676837f, 
    0.16076005f, 0.01730404f, 0.05891820f, 0.05472908f, -0.00517563f, 0.02355059f, 0.03046483f, 0.03289687f, 
    0.00790201f, 0.10384926f, 0.09487940f, 0.12576397f, -0.01064640f, 0.17830330f, 0.09575047f, 0.11255729f, 
    -0.02789942f, -0.02555062f, 0.17525662f, 0.01183662f, -0.04563438f, 0.05144684f, -0.03950591f, 0.05267629f, 
    0.00741882f, 0.10568491f, -0.04010084f, -0.01940190f, -0.03666409f, 0.01389194f, -0.00851105f, 0.11807039f, 
    0.01042757f, 0.04839171f, 0.25524741f, 0.09051768f, -0.06597723f, -0.02575863f, 0.05099275f, 0.10886990f, 
    0.06118903f, 0.04816980f, 0.08009032f, -0.05874057f, -0.07908262f, 0.02821070f, 0.02242509f, 0.13403730f, 
    0.02312336f, 0.07096601f, 0.08720488f, 0.04139319f, 0.02194647f, 0.01444357f, -0.04588741f, -0.00388511f, 
    0.14532845f, 0.27538288f, -0.09108292f, 0.23033781f, -0.14112641f, -0.13767315f, 0.13613462f, -0.08126616f, 
    0.05263736f, 0.08049648f, 0.03606744f, 0.02567502f, 0.00512380f, 0.03709675f, 0.15706721f, 0.04534197f, 
    0.12988502f, 0.02201104f, 0.01924851f, 0.09872920f, -0.06434166f, 0.12462590f, 0.03053538f, -0.01163281f, 
    0.13540792f, 0.09585700f, 0.01689426f, 0.11605291f, -0.00859535f, -0.01339526f, -0.03898227f, -0.01754994f, 
    0.08021963f, 0.10074130f, 0.07166274f, 0.11038402f, -0.00588101f, 0.09204651f, -0.04015381f, 0.04850591f, 
    -0.01134879f, 0.01593455f, 0.02406787f, -0.04159554f, 0.00100169f, 0.01665074f, 0.00874371f, -0.03449612f, 
    -0.04344169f, -0.00627472f, 0.02900542f, -0.00440399f, -0.03119611f, -0.01305861f, -0.03276648f, 0.02958952f, 
    0.02388988f, 0.00107822f, -0.01564791f, -0.00389485f, -0.04545707f, 0.02824675f, 0.01803517f, -0.02893285f, 
    -0.02687434f, -0.00731336f, 0.01520990f, 0.03347904f, -0.00145013f, 0.00673112f, 0.02727779f, -0.00378953f, 
    0.01278728f, -0.02283273f, 0.00296365f, 0.03303577f, -0.00272719f, -0.03607425f, 0.02454918f, -0.03458440f, 
    0.01190589f, -0.04459159f, 0.00198411f, -0.02001998f, -0.02926422f, 0.03374293f, -0.00845542f, -0.03059505f, 
    0.01062445f, 0.01411315f, -0.00043167f, 0.00421077f, 0.02585380f, 0.00353155f, 0.01749701f, -0.01310351f, 
    0.02817162f, -0.00175724f, 0.01630784f, 0.01697353f, -0.01486398f, 0.00581970f, 0.00197272f, -0.01375860f, 
    -0.01044010f, -0.04379363f, -0.01401501f, 0.00717676f, -0.03833515f, 0.03314074f, -0.03484979f, -0.03848292f, 
    -0.01250225f, -0.03202136f, -0.03656618f, 0.00431891f, -0.03002633f, -0.04290871f, -0.04061734f, 0.00156999f, 
    0.02585824f, -0.03021271f, -0.02474291f, -0.01903659f, 0.01589637f, 0.00149436f, -0.02141416f, -0.02061745f, 
    -0.02647074f, 0.02955125f, 0.00098961f, 0.01463994f, 0.00656616f, -0.03285450f, 0.01830816f, 0.00065778f, 
    -0.03563556f, -0.02827868f, 0.00163041f, 0.03121983f, -0.03516228f, -0.02911896f, 0.01383703f, -0.03087850f, 
    0.02727632f, 0.02047773f, -0.00631164f, 0.00417173f, 0.01418355f, -0.01101609f, 0.01758879f, -0.02192353f, 
    0.03010870f, -0.02957608f, -0.03420540f, -0.02720592f, 0.03179878f, -0.01701118f, -0.00416534f, -0.03411897f, 
    -0.02552692f, 0.00638274f, -0.01840803f, -0.00017075f, 0.02125428f, 0.02564486f, -0.04531433f, -0.02062714f, 
    0.00196987f, -0.00414729f, 0.02040597f, -0.00629940f, -0.02449334f, 0.00935655f, -0.03749881f, 0.01392187f, 
    -0.02531267f, -0.00136505f, -0.02669122f, 0.00054546f, -0.02652877f, -0.02463072f, -0.01914855f, 0.01097701f, 
    0.00441146f, -0.03466206f, 0.02329615f, -0.00968985f, 0.01118326f, -0.00264190f, 0.00784930f, -0.01966131f, 
    0.03268291f, -0.01268783f, -0.00594094f, -0.00151099f, 0.02613553f, 0.00591627f, 0.03221618f, -0.03051082f, 
    -0.01203429f, 0.00148922f, -0.02185416f, 0.01415586f, -0.00118086f, -0.01076858f, -0.02565693f, 0.00376111f, 
    0.01888881f, -0.02333107f, 0.01535193f, 0.01871482f, -0.04188029f, 0.00334013f, 0.03240015f, -0.03452213f, 
    -0.01289977f, -0.02437605f, -0.02065645f, -0.01857990f, 0.01834111f, 0.03030516f, 0.00864106f, 0.02377847f, 
    -0.01078309f, -0.01721700f, -0.00232896f, -0.00355611f, 0.01538483f, -0.02153208f, 0.00289309f, -0.03968018f, 
    -0.02209044f, -0.02875774f, -0.01764152f, -0.01123757f, 0.02964383f, -0.00891197f, -0.04270231f, -0.00853311f, 
    0.02584508f, 0.00338358f, -0.00498352f, -0.00757950f, -0.02740064f, -0.01411181f, -0.01941504f, -0.01088319f, 
    -0.02480344f, -0.02335716f, 0.01407501f, 0.00844709f, 0.00300533f, -0.01950688f, 0.02344383f, -0.03741732f, 
    -0.03866872f, -0.01897823f, -0.02949681f, -0.02417986f, -0.02438213f, -0.02467667f, -0.00334416f, 0.01822956f, 
    -0.03779504f, -0.04431332f, 0.00078579f, 0.00868267f, 0.00980783f, -0.02550570f, 0.02312590f, -0.04262545f, 
    -0.01346651f, -0.01400826f, 0.00846125f, -0.01938346f, -0.03933648f, -0.01200694f, -0.03670428f, 0.00079090f, 
    0.00763448f, 0.03164897f, 0.02391385f, -0.03818579f, -0.01604552f, 0.00511522f, -0.02948959f, 0.02590821f, 
    -0.00117900f, 0.01592143f, -0.01152012f, 0.02506834f, 0.03065344f, 0.03212719f, -0.00609916f, -0.01658272f, 
    0.00697793f, -0.00212689f, 0.00101486f, -0.03621370f, -0.01776018f, -0.04307395f, -0.03014440f, -0.04050212f, 
    -0.03251087f, -0.01086319f, 0.02611169f, 0.01409111f, -0.00752718f, -0.00960578f, -0.03177429f, -0.02570855f, 
    -0.01298378f, -0.02574902f, -0.01572591f, 0.03038799f, -0.00166793f, -0.03575874f, 0.00733972f, 0.01631800f, 
    0.01280428f, 0.01394113f, 0.01467173f, 0.02964479f, 0.03805025f, -0.04547874f, 0.00156980f, -0.00176377f, 
    -0.03584378f, 0.02708766f, 0.02008632f, 0.01378980f, 0.01317130f, 0.01883418f, -0.01819120f, 0.01817995f, 
    0.00701206f, -0.03700611f, -0.02120162f, -0.00476613f, -0.01480884f, -0.01878784f, -0.00873498f, -0.01055846f, 
    0.01869236f, 0.00748325f, 0.02615136f, 0.02322250f, 0.03333266f, -0.02450239f, -0.03720741f, 0.00429307f, 
    0.02851293f, -0.03275124f, -0.03249416f, -0.02289473f, -0.01717041f, -0.01116578f, -0.04318592f, 0.00767695f, 
    -0.02776261f, -0.00565393f, 0.01997574f, -0.02254283f, 0.01559206f, 0.00694231f, 0.02756534f, -0.03280519f, 
    0.01710707f, -0.02263885f, -0.01892821f, 0.03487436f, -0.00207694f, -0.02690846f, -0.01453986f, -0.03313546f, 
    0.02727651f, 0.01741455f, 0.00449933f, -0.03567741f, 0.00373381f, -0.03016137f, -0.01816980f, -0.03115373f, 
    -0.03468232f, -0.02095581f, -0.00497763f, -0.00540389f, -0.02338472f, -0.00789294f, -0.02513142f, -0.02504588f, 
    0.02793089f, -0.02320585f, -0.00630469f, 0.01565254f, -0.03571406f, -0.03635899f, -0.03912064f, 0.01364726f, 
    -0.00801735f, 0.03248259f, -0.01644996f, -0.03653227f, 0.02681970f, -0.00656556f, -0.03386964f, -0.01321475f, 
    -0.04256210f, 0.01221777f, -0.03915663f, -0.00068244f, 0.03282562f, 0.00805985f, -0.04419073f, -0.01803223f, 
    -0.01057647f, -0.00148911f, 0.01583613f, 0.01035494f, 0.03726621f, -0.03686710f, -0.02384716f, 0.02350213f, 
    -0.00632209f, 0.00885812f, 0.02417883f, -0.02991967f, -0.00184277f, 0.01658028f, 0.00345060f, 0.01487108f, 
    0.02007079f, -0.04260257f, -0.01341195f, 0.01726637f, 0.01743363f, 0.00096984f, 0.01255245f, -0.01532995f, 
    -0.01140211f, -0.00022484f, -0.00496743f, -0.01231184f, 0.00848314f, -0.03145913f, 0.03051843f, 0.02104551f, 
    -0.02835815f, -0.00522991f, 0.01753513f, 0.01963660f, 0.00708722f, -0.01290955f, -0.03809472f, -0.03090557f, 
    0.01859273f, 0.01633208f, -0.04449277f, 0.02632266f, 0.01415927f, -0.01334976f, -0.02350922f, -0.04035257f, 
    0.01404806f, -0.01205603f, 0.02305516f, -0.02080911f, 0.01457458f, -0.04005375f, -0.00299927f, -0.00821964f, 
    -0.03717355f, -0.01896891f, 0.00559594f, -0.03484290f, 0.02517287f, -0.01904268f, -0.01021445f, 0.00554940f, 
    -0.02171292f, -0.00695164f, -0.02761552f, -0.02655076f, -0.00494945f, 0.00620225f, -0.01936394f, -0.04431259f, 
    0.02646969f, -0.00705916f, 0.02025760f, -0.04014461f, -0.02022428f, -0.02640831f, -0.01847306f, -0.00728095f, 
    -0.02519666f, 0.02533557f, 0.00353682f, -0.03805222f, -0.04091707f, 0.02064669f, -0.03917252f, 0.01910157f, 
    0.03188367f, -0.03797810f, -0.02171845f, -0.03616146f, -0.04330719f, -0.02437859f, 0.00605092f, 0.00371189f, 
    0.01895152f, -0.01818878f, -0.03508822f, -0.02291185f, -0.02299506f, 0.01350602f, -0.02879564f, -0.04391659f, 
    -0.03170741f, -0.01015989f, -0.02038415f, -0.00221755f, -0.02126144f, 0.01487244f, 0.02485844f, 0.02717594f, 
    0.03346639f, 0.01412689f, -0.03536226f, -0.00570568f, -0.00535370f, -0.02917431f, 0.01229263f, -0.00226670f, 
    -0.03618433f, -0.01421916f, -0.00058950f, -0.01089187f, -0.00127532f, -0.03002098f, 0.00698491f, -0.00842455f, 
    -0.04484207f, -0.02645621f, -0.00405946f, -0.02812320f, 0.00866099f, 0.02447448f, 0.02580798f, 0.02520936f, 
    -0.03291445f, -0.03453982f, -0.04337930f, 0.01361275f, 0.02842371f, 0.00565796f, 0.00280343f, -0.00524911f, 
    -0.00306077f, -0.04553100f, -0.04130646f, 0.02499567f, 0.01748721f, 0.00644167f, -0.02661542f, 0.01618603f, 
    -0.02325007f, -0.03252229f, -0.01338650f, -0.01562734f, -0.00710313f, -0.01195462f, 0.01830600f, 0.01267802f, 
    0.02916277f, -0.02910220f, -0.01054254f, -0.03907012f, -0.00244535f, -0.00643612f, 0.03154710f, 0.01009606f, 
    0.01913173f, -0.04360497f, 0.00289960f, -0.03837738f, -0.02152988f, -0.02272642f, -0.01821430f, -0.00996552f, 
    -0.00440039f, -0.03652359f, 0.02671966f, 0.00011944f, -0.03341654f, -0.03989721f, 0.01985186f, -0.02850524f, 
    0.02462921f, -0.02795199f, -0.02518177f, 0.01983460f, -0.03964922f, 0.02092777f, -0.00203191f, 0.02361583f, 
    -0.04175567f, 0.00297084f, -0.02506701f, -0.04101814f, 0.01023424f, 0.02276067f, 0.02692844f, -0.00787150f, 
    -0.03937255f, 0.02887525f, -0.01050342f, -0.04027826f, 0.02354675f, 0.03117341f, -0.01693198f, -0.01798734f, 
    0.02946399f, 0.00395393f, -0.03522592f, 0.01921195f, -0.03128449f, -0.02900861f, 0.00932015f, 0.00096930f, 
    -0.03478977f, -0.03912048f, 0.01024654f, -0.03085158f, -0.02987182f, 0.00628364f, -0.02198123f, -0.03591919f, 
    0.01158241f, 0.00503152f, -0.02098333f, 0.02337393f, 0.00631256f, 0.01995739f, -0.00273509f, 0.00542258f, 
    -0.03446690f, -0.03304622f, 0.00993970f, 0.01069776f, -0.02981867f, -0.04552101f, 0.00858289f, -0.00328995f, 
    -0.00848319f, -0.03616982f, 0.01809425f, -0.00313875f, -0.01741109f, 0.03300059f, 0.00915375f, 0.02758384f, 
    -0.01205340f, 0.02713010f, -0.00288024f, -0.00409480f, -0.03585654f, 0.00694777f, 0.00668582f, -0.01764823f, 
    -0.00588716f, -0.01420099f, 0.02580692f, -0.01346513f, -0.03942781f, -0.04329484f, -0.03436697f, 0.00526273f, 
    -0.03968054f, -0.01351962f, 0.01643381f, -0.04456418f, -0.00592183f, 0.00406176f, 0.02865430f, -0.03242563f, 
    -0.01730186f, 0.00029582f, 0.02864363f, -0.00997885f, -0.02167927f, 0.02817824f, 0.00458345f, 0.01727391f, 
    0.00935650f, -0.00267166f, -0.04239074f, -0.01030654f, -0.04364526f, -0.01244849f, -0.02858340f, -0.01664371f, 
    0.01985665f, 0.02523100f, -0.00505547f, -0.00138454f, 0.02509116f, -0.03275379f, -0.00857550f, -0.01846612f, 
    -0.04007901f, 0.02445229f, 0.01777442f, 0.00801983f, -0.02957237f, -0.02954509f, -0.01773898f, -0.00959317f, 
    0.01237346f, -0.00996761f, -0.01775869f, 0.00277122f, -0.03516041f, 0.01959287f, -0.04247736f, -0.03135936f, 
    -0.02291985f, 0.00406331f, 0.00470561f, 0.02882499f, 0.01212161f, -0.00764856f, -0.03832719f, -0.02901051f, 
    -0.03739394f, 0.01515145f, -0.03650642f, -0.00200697f, 0.00132760f, 0.03178199f, -0.03310598f, 0.01516450f, 
    -0.04045179f, -0.02645821f, 0.03759010f, -0.01695067f, -0.04000846f, -0.01707821f, -0.01621371f, 0.02781928f, 
    -0.04116335f, -0.04023803f, -0.01050721f, 0.02378083f, -0.03227477f, -0.00675327f, -0.04534068f, -0.01730687f, 
    -0.02795163f, 0.01303550f, -0.03350187f, -0.02566122f, -0.03133441f, 0.01940544f, -0.01998564f, 0.02841531f, 
    -0.03407810f, 0.01834173f, -0.04135889f, -0.02445173f, -0.01112114f, -0.00599333f, -0.04004149f, -0.01481343f, 
    -0.00106892f, 0.02789529f, -0.03611338f, -0.02640882f, 0.00913015f, -0.01397082f, 0.01653955f, -0.00939713f, 
    -0.04320179f, -0.00024757f, 0.00281471f, -0.01820418f, 0.00241168f, -0.00446952f, -0.02811272f, 0.01359588f, 
    -0.01675818f, -0.02973020f, 0.02703477f, -0.00082662f, -0.04083759f, -0.02646895f, -0.01180335f, -0.00276388f, 
    0.02834596f, -0.02710596f, 0.00806101f, 0.01371698f, 0.00139918f, -0.03950629f, 0.03674507f, -0.00975576f, 
    0.02236703f, 0.01984197f, -0.00229453f, -0.00831091f, 0.02741092f, -0.00324178f, 0.01850810f, 0.02064264f, 
    -0.00111148f, -0.01979244f, -0.04379722f, -0.02174557f, -0.00545640f, -0.01394292f, 0.01786359f, 0.00917483f, 
    0.00776010f, 0.01395973f, -0.04110853f, -0.01707071f, 0.00931212f, -0.03328924f, -0.01535251f, 0.01238529f, 
    0.01713805f, 0.02456378f, -0.03110348f, 0.01585950f, -0.01550156f, 0.00489851f, -0.01846263f, -0.01628159f, 
    -0.00102771f, -0.04056732f, -0.00060042f, -0.04096603f, -0.03396128f, -0.04446754f, -0.02444833f, -0.01072709f, 
    -0.04530560f, -0.04186958f, 0.02723487f, -0.02778747f, 0.00052635f, -0.00319632f, -0.02359478f, -0.02065628f, 
    0.00797824f, 0.02020990f, 0.01343049f, -0.03748479f, -0.01532837f, -0.03036861f, 0.02179886f, 0.01873675f, 
    0.02208731f, -0.01439265f, -0.01707204f, 0.02953642f, -0.03760233f, -0.04016170f, 0.02729626f, -0.02890433f, 
    -0.00312301f, 0.02934143f, -0.04080977f, 0.01184966f, -0.02756358f, -0.00347160f, -0.03567218f, -0.03485292f, 
    -0.04022753f, -0.00231327f, 0.03862727f, 0.01630457f, -0.01790809f, -0.01920075f, -0.02792788f, -0.00497771f, 
    -0.03836702f, -0.03303876f, -0.00593567f, 0.00961884f, -0.03923705f, 0.01610962f, 0.01823681f, 0.01639906f, 
    -0.01654800f, 0.03260094f, -0.03561259f, 0.02978935f, -0.04291034f, -0.04463789f, -0.02372415f, -0.00502871f, 
    -0.00259293f, -0.00555887f, 0.02590814f, 0.00970079f, 0.02945707f, -0.02415119f, 0.00034088f, 0.01806283f, 
    0.02080423f, -0.04100832f, -0.02637783f, 0.02673136f, -0.03336200f, 0.00889125f, -0.02044616f, 0.01369835f, 
    -0.02261220f, -0.03125547f, -0.04041921f, 0.02637829f, -0.00459469f, -0.00905853f, -0.03458259f, 0.01499101f, 
    -0.03503825f, -0.02981069f, 0.02184033f, -0.01977648f, -0.03620243f, 0.01817263f, 0.03412372f, -0.01668917f, 
    -0.00176870f, 0.02863239f, -0.00745510f, -0.02145971f, 0.00156392f, 0.01233452f, -0.04039964f, 0.02281593f, 
    0.01484372f, 0.02046153f, 0.01974034f, 0.01707406f, -0.01514212f, 0.00003140f, -0.03703732f, -0.00940599f, 
    0.03055972f, -0.00052725f, 0.01197103f, 0.02054511f, 0.01677941f, -0.01543781f, -0.00150570f, 0.03076868f, 
    -0.02993665f, 0.00382417f, -0.01786889f, 0.00282070f, -0.01168985f, -0.00280429f, -0.01085422f, -0.02955029f, 
    -0.00778382f, 0.02622975f, 0.03690475f, -0.03315188f, -0.03755557f, 0.03219084f, 0.00615673f, 0.02461550f, 
    0.02816069f, -0.00698214f, -0.03748252f, 0.01248924f, -0.03181372f, -0.00535390f, 0.00223567f, -0.03761939f, 
    -0.00529646f, -0.00847626f, -0.04316285f, -0.03836237f, -0.01360549f, 0.01217990f, -0.00338973f, 0.01518824f, 
    -0.03821142f, -0.03540408f, 0.01504088f, 0.01984025f, -0.01439621f, 0.01114754f, -0.02308432f, -0.02423207f, 
    -0.01923696f, -0.00293328f, -0.03505288f, -0.00918237f, 0.01803181f, -0.03360163f, 0.02123334f, -0.02737876f, 
    -0.02204580f, 0.02012507f, -0.00943168f, 0.02903567f, -0.00957931f, -0.02020720f, -0.02711896f, 0.00128633f, 
    -0.04276685f, -0.00210055f, -0.04064684f, 0.03765167f, -0.00952246f, 0.01628395f, -0.00805669f, -0.00970019f, 
    -0.02378370f, -0.00781109f, 0.03274825f, -0.02603498f, 0.01358603f, -0.02556305f, -0.03696817f, 0.03126559f, 
    -0.04198636f, -0.03996039f, -0.02077483f, -0.04363478f, 0.02158310f, -0.01929981f, -0.00622730f, 0.03348036f, 
    -0.00442749f, -0.01630599f, -0.02558848f, 0.01906447f, -0.02590743f, 0.02203287f, -0.00280752f, 0.01374735f, 
    0.00755698f, 0.01650740f, -0.00391803f, -0.01039012f, -0.00213670f, -0.01729152f, -0.02567249f, -0.03852355f, 
    0.02112471f, -0.00703160f, -0.01901626f, 0.01442450f, 0.00654073f, -0.01510827f, -0.02895281f, -0.02510560f, 
    0.01264766f, 0.00117603f, 0.02337098f, -0.02708804f, -0.00956388f, -0.01133813f, -0.03212553f, -0.04017030f, 
    -0.00646829f, -0.02924746f, -0.01581839f, 0.00349168f, -0.00642954f, 0.00637880f, -0.00679263f, -0.02530486f, 
    -0.02239341f, -0.04375445f, 0.00965893f, -0.03825225f, -0.02634843f, 0.00684101f, 0.02510535f, 0.01415294f, 
    0.02828908f, -0.04101610f, 0.02100569f, 0.00069674f, -0.03787588f, 0.02141450f, -0.00062186f, -0.03507198f, 
    0.02123690f, -0.03170576f, -0.00738791f, 0.03162022f, 0.02819172f, 0.00838009f, 0.00546185f, 0.01469068f, 
    -0.03452379f, -0.03111895f, 0.02722050f, 0.01535271f, 0.01761918f, -0.02455786f, -0.00783109f, 0.03075601f, 
    -0.02675597f, -0.03706124f, 0.00079019f, 0.01288801f, 0.03173785f, -0.02141807f, -0.00251522f, -0.00515218f, 
    -0.04164111f, 0.00127779f, -0.02839366f, 0.03171369f, 0.02768651f, 0.01133098f, -0.02053676f, -0.00787211f, 
    0.01719474f, -0.00926505f, 0.01507463f, -0.02938687f, -0.03035239f, -0.03277902f, -0.01426019f, -0.02485845f, 
    0.01006164f, -0.04014876f, 0.01589514f, 0.00861248f, -0.03019281f, 0.02963674f, -0.04290602f, -0.00289063f, 
    -0.00764438f, -0.01214489f, 0.03059438f, 0.01716167f, -0.02141599f, -0.01689886f, -0.00405808f, 0.03169804f, 
    0.01186664f, -0.01026840f, 0.03116009f, 0.03009881f, 0.01403728f, 0.00807707f, 0.00976080f, 0.01461630f, 
    -0.03523739f, 0.00873811f, -0.01439899f, -0.01179104f, -0.04304134f, -0.02952955f, 0.02579001f, 0.02099229f, 
    0.02385856f, 0.02218316f, -0.04409213f, -0.04269828f, -0.00359927f, 0.02595449f, 0.02427925f, -0.02138554f, 
    -0.01292610f, -0.01804490f, -0.02255312f, 0.01010936f, 0.02812966f, -0.02076029f, 0.02200289f, 0.00958920f, 
    0.01176510f, 0.00074927f, 0.01709743f, 0.03073563f, 0.00959813f, -0.01895282f, -0.02918123f, 0.01104780f, 
    0.01235786f, -0.02770292f, -0.00599264f, 0.01296186f, -0.03932990f, -0.03850549f, -0.03391057f, -0.01424651f, 
    -0.02290067f, -0.01563992f, -0.02666091f, -0.00420604f, -0.04360135f, 0.00532426f, 0.01900287f, -0.00584635f, 
    0.01799588f, -0.02610491f, 0.02721994f, 0.01349947f, 0.00764630f, -0.03319614f, 0.03068286f, 0.00147786f, 
    0.02552566f, -0.01614398f, -0.02781881f, -0.01232983f, -0.01275148f, 0.00389982f, 0.01711284f, -0.01932335f, 
    0.02074352f, -0.01909748f, -0.02934034f, 0.02482881f, -0.04388748f, 0.00050667f, 0.02655572f, -0.02546603f, 
    0.01323184f, -0.04366323f, 0.00044624f, 0.03285225f, 0.02688237f, -0.03594243f, -0.02473968f, -0.01275308f, 
    -0.00009364f, -0.01866809f, -0.02843706f, -0.02789712f, 0.02641817f, -0.01355715f, -0.01812907f, -0.02692443f, 
    0.01546745f, -0.01820973f, -0.00213739f, -0.02824142f, 0.00917468f, -0.03394384f, -0.04047842f, 0.02502943f, 
    0.00415218f, -0.02506259f, -0.02478366f, 0.01234187f, -0.03445853f, 0.02733633f, -0.01395434f, -0.01147464f, 
    -0.04346892f, 0.00591325f, 0.03600379f, 0.02266693f, 0.02042082f, -0.00381459f, 0.00816877f, 0.00067222f, 
    0.01287423f, 0.00009927f, -0.02643428f, -0.01375658f, -0.02786331f, 0.03114679f, -0.01564942f, -0.01617420f, 
    0.01232701f, -0.01524363f, -0.00716594f, -0.03507352f, -0.02460060f, -0.03055215f, 0.02680425f, -0.01922254f, 
    -0.01727534f, 0.00042458f, -0.00394925f, -0.00005586f, 0.00708070f, -0.04415087f, 0.02692512f, -0.01978745f, 
    -0.01958571f, -0.03343130f, -0.02285834f, -0.01826078f, -0.03321374f, 0.03000068f, -0.03878473f, -0.03156218f, 
    -0.02411296f, -0.04515007f, -0.03706588f, -0.02038606f, 0.02055800f, -0.01701439f, -0.02620002f, -0.03169046f, 
    0.00586155f, -0.04494553f, 0.02622636f, -0.00009514f, 0.00785991f, 0.00550103f, -0.01235104f, 0.03324798f, 
    0.01973993f, 0.01628952f, 0.00499251f, -0.01031687f, 0.02845506f, 0.00860031f, -0.03374144f, -0.02965806f, 
    -0.02143954f, -0.03003467f, 0.00730479f, -0.02785731f, -0.00392688f, 0.02092310f, -0.02007523f, 0.02589948f, 
    0.01616180f, -0.02965531f, -0.01582615f, -0.03840419f, -0.03242502f, 0.02856317f, -0.00221560f, 0.01887056f, 
    -0.02395915f, 0.02951149f, -0.02022968f, -0.03664902f, 0.00519755f, -0.00084532f, -0.01531346f, 0.00046622f, 
    -0.02910436f, -0.00276847f, 0.01212871f, 0.01854584f, 0.00523759f, -0.01040884f, -0.02771015f, -0.00300460f, 
    0.01712208f, -0.04026053f, 0.00968811f, -0.02271696f, -0.00472417f, 0.00984637f, 0.02080364f, 0.01765744f, 
    -0.00148459f, -0.02733849f, -0.01326931f, 0.03272179f, 0.02513755f, 0.02934351f, -0.04031303f, -0.00599900f, 
    0.03023247f, 0.03311068f, 0.00512672f, -0.01248683f, 0.02006926f, 0.01615949f, -0.03506948f, -0.02689216f, 
    0.01282576f, 0.03361222f, -0.01662557f, 0.01462007f, -0.01330133f, -0.02692042f, -0.01236761f, -0.01556853f, 
    -0.03577258f, 0.02163168f, -0.00417332f, 0.02042702f, -0.00194138f, 0.01727103f, -0.00870502f, -0.02207495f, 
    -0.01296249f, 0.01818952f, -0.01514893f, 0.00045557f, -0.00164772f, -0.04276721f, 0.02633969f, -0.02252584f, 
    0.00113825f, 0.00892224f, -0.03144845f, 0.00342985f, -0.02894934f, -0.04008953f, 0.00305734f, -0.01234159f, 
    -0.01710318f, -0.00426887f, 0.01578295f, -0.03575838f, -0.02001164f, -0.03487461f, 0.01215321f, 0.00548896f, 
    -0.00016641f, 0.01569098f, 0.02605687f, -0.01699820f, 0.01585020f, -0.00851073f, -0.00428071f, 0.03036632f, 
    -0.01977194f, 0.01703475f, 0.03184484f, -0.04130154f, 0.00443629f, 0.01315809f, 0.00586463f, 0.02979331f, 
    -0.03377160f, 0.00466756f, -0.03140571f, -0.01777183f, 0.03057993f, -0.03386337f, -0.02544051f, -0.04015399f, 
    0.01268524f, 0.03109289f, -0.00641686f, 0.00555053f, 0.00077258f, 0.01466429f, 0.02487367f, -0.03574228f, 
    -0.01507793f, 0.04405407f, 0.00823510f, 0.01697060f, -0.00226116f, -0.00348672f, 0.01795392f, -0.02920221f, 
    0.01929254f, 0.01567516f, -0.01142579f, -0.00410334f, -0.03377614f, -0.01532232f, -0.03153814f, -0.03906265f, 
    0.01756173f, -0.02078696f, 0.03845102f, 0.01099609f, -0.00663544f, 0.00338226f, -0.02240635f, -0.03732995f, 
    0.01713295f, 0.01041957f, 0.02192902f, 0.02779817f, 0.00729178f, -0.03385045f, 0.00422264f, 0.01070961f, 
    -0.03759028f, 0.03653860f, -0.01359340f, -0.01920382f, 0.01960320f, 0.00208534f, -0.03807183f, -0.00895769f, 
    -0.03372463f, -0.00181945f, 0.01056757f, 0.02285620f, -0.02366142f, -0.00186747f, -0.02303756f, 0.02340694f, 
    -0.02437120f, 0.00439464f, 0.03281074f, -0.04323592f, -0.04154251f, -0.00586920f, -0.01857326f, -0.00790156f, 
    0.00342158f, -0.03646097f, 0.01779633f, 0.03152630f, 0.02500380f, -0.02856635f, -0.01648741f, 0.00383933f, 
    -0.00735007f, -0.01104238f, -0.00101958f, -0.03679115f, 0.00538530f, 0.00981848f, -0.00934457f, -0.00114489f, 
    0.01978038f, -0.02100307f, 0.00550572f, 0.00518820f, 0.01198278f, -0.03990574f, -0.02866117f, -0.03971723f, 
    -0.02168678f, 0.01603733f, -0.01330259f, -0.03879233f, 0.03083752f, 0.02663576f, -0.01451464f, -0.01195345f, 
    -0.03429855f, 0.01412069f, 0.00969966f, 0.03293677f, 0.02415458f, 0.01853384f, -0.00676746f, 0.00405941f, 
    0.02074833f, 0.03112467f, -0.01297166f, 0.01075405f, -0.00311486f, -0.00007667f, -0.00536633f, 0.00284020f, 
    -0.02565242f, -0.03447790f, -0.04474594f, 0.00563679f, -0.02429787f, -0.02317925f, -0.04078523f, 0.03473430f, 
    0.00039657f, 0.02171271f, 0.00626580f, 0.04272134f, 0.03238061f, -0.03704544f, 0.02640762f, 0.03026810f, 
    -0.00682394f, 0.01783307f, -0.02502905f, 0.02836431f, 0.00464247f, 0.00696891f, 0.00328956f, -0.01655483f, 
    0.02918917f, -0.04038378f, 0.00437800f, 0.02103993f, 0.02273596f, 0.00560492f, -0.01552506f, 0.02170204f, 
    -0.04011983f, -0.02919943f, -0.02970176f, -0.00892317f, -0.00343394f, -0.01647594f, 0.03340799f, -0.00319375f, 
    0.00603211f, 0.04206487f, 0.01204666f, -0.00052965f, -0.02612671f, -0.02463943f, -0.03678109f, -0.02101587f, 
    -0.03194548f, -0.01546390f, -0.01341306f, -0.01917202f, -0.00710467f, 0.03413824f, 0.02896103f, -0.03912902f, 
    -0.03647283f, -0.01229391f, 0.01385530f, -0.01160068f, -0.03223504f, 0.02039333f, -0.01817291f, -0.00920220f, 
    -0.03258165f, -0.01226139f, 0.01686984f, -0.03136393f, -0.00392050f, -0.01172798f, -0.00055742f, -0.01132927f, 
    0.01285438f, 0.01017275f, 0.01838259f, 0.01868692f, 0.01650389f, 0.02004370f, -0.02769485f, -0.02230583f, 
    0.00123518f, -0.03315570f, -0.00229458f, -0.00072080f, 0.00583701f, -0.01859383f, 0.00742883f, -0.03599441f, 
    -0.02959720f, 0.00019068f, -0.02662507f, 0.02872539f, -0.01636899f, 0.01239376f, -0.01162395f, -0.04125438f, 
    -0.01846205f, 0.02320545f, -0.03917596f, -0.03480730f, -0.01612735f, -0.01633988f, -0.01010129f, 0.00579466f, 
    -0.00488152f, -0.04545394f, 0.00152741f, 0.01611034f, -0.03622342f, -0.00265956f, 0.01052591f, -0.02924867f, 
    0.01938838f, -0.01591015f, -0.03371583f, 0.02848999f, -0.01739365f, 0.00659414f, -0.00424809f, -0.01863246f, 
    0.02771042f, 0.00621033f, -0.02013989f, -0.03896146f, -0.01479869f, -0.02838162f, 0.01670007f, -0.04069942f, 
    0.01071072f, 0.01331155f, -0.02684799f, 0.03398915f, -0.04085558f, -0.00926609f, 0.00315456f, 0.01102198f, 
    -0.00328712f, -0.00406161f, -0.00921530f, 0.02454625f, -0.02513953f, -0.03770129f, -0.00506605f, -0.04141979f, 
    -0.02299752f, -0.02473678f, 0.01869719f, 0.00210896f, -0.02109640f, 0.02280567f, 0.00017931f, -0.03421628f, 
    -0.01749043f, -0.01138377f, 0.01391490f, 0.01367611f, 0.01163677f, 0.03372380f, 0.00674015f, -0.00305233f, 
    -0.04150195f, -0.00342803f, -0.03730296f, -0.02641303f, -0.04413762f, -0.02576467f, -0.01724313f, 0.02830736f, 
    0.01385336f, -0.00066886f, 0.02527776f, -0.04770325f, -0.01127440f, -0.03582761f, -0.03484532f, 0.02045568f, 
    -0.03316401f, -0.03733214f, 0.02267747f, -0.04281436f, -0.03714720f, -0.01099163f, -0.01769579f, 0.01559269f, 
    0.02913537f, -0.02557465f, -0.02799052f, -0.02792440f, -0.03649699f, 0.00020560f, -0.03602221f, 0.03008233f, 
    -0.00005621f, -0.02206338f, 0.01653305f, 0.00881698f, -0.00681463f, -0.01387452f, -0.01922292f, -0.02908214f, 
    -0.03667383f, -0.00567149f, -0.01448360f, 0.00429370f, -0.01790109f, -0.02018304f, -0.00532500f, -0.00817378f, 
    0.03430481f, 0.02628689f, -0.02089103f, -0.03993113f, -0.01255718f, -0.02832954f, 0.03547370f, 0.03469402f, 
    0.02937286f, 0.01826300f, -0.00651877f, 0.01457533f, -0.01332138f, 0.01106222f, -0.02413535f, 0.02532067f, 
    0.02868799f, -0.00716529f, 0.02536793f, 0.01389587f, 0.01179853f, -0.02637832f, -0.03344298f, -0.00678696f, 
    -0.02431867f, 0.00193188f, 0.01843932f, 0.01108209f, 0.02919791f, -0.01380577f, -0.01631871f, -0.00401104f, 
    -0.01466123f, -0.01783584f, -0.02677771f, -0.01302374f, -0.03667335f, 0.00147820f, 0.01918812f, -0.00069026f, 
    -0.02851763f, 0.02323512f, 0.02849344f, 0.01874564f, 0.04120958f, -0.02136543f, 0.01715437f, -0.04339859f, 
    -0.02779597f, 0.00572058f, 0.03171500f, -0.00913854f, 0.01805104f, 0.00496443f, 0.01088473f, -0.01930274f, 
    -0.01243813f, -0.03418604f, -0.03065832f, 0.02286944f, 0.03456551f, -0.04193151f, -0.03554081f, 0.00367816f, 
    -0.00678538f, -0.03438418f, -0.03632658f, -0.00781280f, 0.00820612f, 0.02013701f, 0.00710466f, 0.01325187f, 
    -0.03086017f, -0.01164072f, 0.02175941f, -0.00120783f, -0.00617941f, -0.00057256f, -0.04831837f, -0.03015899f, 
    -0.01374870f, 0.01170977f, -0.00226476f, 0.02848184f, -0.01190017f, 0.01905568f, -0.00898636f, -0.02593333f, 
    -0.02823273f, 0.00890458f, -0.00781827f, 0.01127628f, -0.02795112f, -0.01149259f, -0.04044559f, 0.01378763f, 
    -0.03721429f, -0.00391340f, -0.00285120f, -0.01397529f, -0.00360118f, -0.01409202f, -0.00211588f, -0.00130252f, 
    -0.03266611f, 0.01746192f, -0.01200492f, -0.01840649f, -0.01309479f, 0.00018265f, -0.02662588f, -0.02103844f, 
    0.03379069f, 0.00328454f, -0.04687012f, -0.01564323f, -0.03048586f, -0.01009143f, -0.01678473f, 0.01360996f, 
    0.01376451f, -0.00279689f, -0.04193128f, 0.01153499f, -0.01623148f, 0.00650605f, -0.00586253f, 0.00562474f, 
    -0.00230264f, -0.00725926f, 0.00683883f, -0.01272240f, -0.01995008f, -0.01285885f, -0.00055509f, -0.03521589f, 
    -0.01318857f, -0.03253635f, -0.01499647f, -0.03176872f, 0.03104364f, -0.03373882f, -0.03264635f, 0.00925339f, 
    0.02086570f, 0.00662562f, -0.03800815f, 0.01887438f, -0.00183640f, -0.00762718f, -0.02196567f, -0.03245348f, 
    -0.04110005f, -0.03954155f, -0.01537340f, -0.04500679f, -0.03208002f, 0.01238357f, -0.03382935f, 0.00748645f, 
    -0.01703985f, -0.00567475f, -0.03471625f, 0.02727157f, -0.01857813f, -0.03343477f, 0.00085871f, -0.02599208f, 
    0.02262672f, -0.03689845f, -0.02170326f, -0.04286983f, -0.01388876f, -0.00465296f, 0.00180780f, 0.01147823f, 
    0.02136385f, -0.03487972f, 0.00671684f, -0.01995578f, -0.03907999f, 0.02910900f, 0.03662427f, -0.02908860f, 
    -0.01270998f, 0.00883271f, 0.03222800f, 0.02415026f, -0.03684923f, 0.04127426f, -0.02749797f, 0.01791056f, 
    -0.19238801f, 0.35052234f, -0.09464363f, -0.02598390f, 0.28734511f, 0.01290165f, 0.09485254f, 0.01477966f, 
    0.10029419f, -0.04614337f, -0.00485330f, 0.02477720f, -0.00056189f, 0.12527470f, 0.01522650f, 0.07782196f, 
    0.01177188f, -0.08197107f, -0.00040790f, -0.03830294f, 0.30273888f, -0.03921655f, 0.19463760f, -0.04249220f, 
    -0.06699479f, -0.00280352f, 0.12677552f, -0.03719481f, 0.11954189f, -0.13193226f, 0.00477032f, 0.08245130f, 
    0.00224089f, 0.08292031f, -0.05737921f, 0.08686432f, -0.02147005f, -0.00320685f, -0.18977922f, 0.05869123f, 
    0.24270402f, 0.15203321f, -0.04756826f, -0.04163776f, 0.22688374f, -0.07741787f, -0.16381383f, -0.02921928f, 
    0.03727882f, 0.10428235f, 0.02143653f, 0.06202023f, 0.09881972f, 0.04629338f, 0.02699653f, 0.05743819f, 
    0.14625150f, -0.09306230f, -0.08264911f, -0.01314049f, 0.13025257f, -0.03818742f, 0.10350420f, 0.09385115f, 
    0.06449571f, 0.04869304f, 0.00953511f, -0.00674326f, -0.00503881f, 0.01608319f, -0.12917711f, 0.05783175f, 
    0.02980511f, 0.04485491f, 0.05038278f, 0.07459263f, 0.10251322f, 0.19894902f, 0.11453118f, 0.03376649f, 
    0.08702012f, -0.11948390f, 0.04799274f, -0.03869064f, 0.21116109f, 0.12144364f, 0.03287013f, -0.01140873f, 
    -0.07800426f, 0.05680295f, -0.03554720f, 0.03603452f, -0.01648108f, -0.00937728f, -0.03777304f, -0.00720728f, 
    0.11388714f, 0.00172025f, -0.02482616f, -0.04741154f, 0.24773337f, -0.02622306f, 0.18350857f, 0.04522294f, 
    0.16488849f, 0.00910396f, -0.03311588f, 0.00485406f, -0.04893665f, 0.03542060f, 0.09045842f, 0.02094775f, 
    0.08277111f, 0.07957640f, -0.06923450f, 0.01226090f, -0.05304797f, 0.03867855f, 0.10182890f, 0.12792543f, 
    0.34225503f, -0.20886239f, -0.06120104f, -0.11342552f, -0.03719782f, 0.05914119f, 0.08936333f, -0.03103689f, 
    0.00354915f, 0.06417110f, 0.02765930f, 0.00394261f, -0.03157008f, 0.09047691f, 0.00095854f, 0.05154334f, 
    0.01425724f, -0.09403063f, -0.07719176f, -0.00302741f, 0.00595643f, 0.01589371f, 0.11766221f, -0.13998269f, 
    -0.09214807f, -0.03460464f, 0.08275094f, -0.04577339f, 0.11589316f, -0.06420858f, -0.04469108f, 0.03665813f, 
    0.04999071f, 0.11380033f, 0.07500605f, -0.04034322f, 0.01401496f, 0.07709357f, -0.04179256f, 0.20238155f, 
    0.33658683f, -0.01401311f, -0.05523257f, 0.09554456f, 0.09599680f, 0.06869022f, 0.06322106f, 0.02042238f, 
    0.03850638f, -0.07177226f, -0.01532870f, 0.08777486f, -0.02988980f, 0.06017801f, -0.03839420f, -0.02441408f, 
    0.05791411f, 0.00052757f, -0.13419217f, -0.00090234f, -0.06645668f, -0.06292824f, 0.01079449f, 0.22053753f, 
    0.00316829f, -0.07397571f, 0.00593314f, 0.05114868f, -0.02882252f, 0.09410168f, 0.11688555f, 0.04530161f, 
    -0.09649699f, -0.09563693f, -0.04977640f, 0.00611797f, -0.05029838f, -0.01370741f, -0.03170661f, -0.01155953f, 
    0.50450110f, -0.16432759f, -0.24063963f, -0.05983290f, 0.04318884f, -0.07084949f, -0.05198087f, 0.05947712f, 
    0.03463832f, 0.10993355f, -0.01494353f, 0.00200227f, 0.01597850f, -0.02143432f, 0.02313271f, -0.06692126f, 
    0.00097739f, -0.15170801f, 0.01825270f, -0.07166497f, 0.10450358f, 0.23779850f, -0.15880084f, 0.13043289f, 
    0.08254794f, -0.02732737f, 0.00206751f, 0.10078759f, -0.02482061f, -0.04641937f, 0.06572066f, 0.00810670f, 
    0.04735686f, -0.06134412f, -0.04536628f, 0.04676173f, -0.01548763f, -0.15058795f, -0.03802743f, 0.05947930f, 
    -0.04741291f, 0.06713987f, -0.05240110f, -0.00154926f, -0.15036036f, 0.04049315f, -0.06298941f, 0.04431134f, 
    0.08556592f, 0.02725927f, -0.06455986f, -0.01557354f, 0.13034375f, -0.05760127f, -0.01408427f, 0.04683693f, 
    0.01017709f, 0.09960763f, 0.08183216f, -0.07344874f, -0.03092396f, 0.36520156f, 0.04891939f, -0.16316162f, 
    -0.09119356f, 0.04735295f, -0.00030860f, -0.01563897f, 0.01858455f, 0.08459031f, 0.02659340f, -0.02529211f, 
    0.04161366f, -0.04329002f, 0.01022749f, 0.04175435f, 0.09956782f, -0.10187152f, -0.02364594f, -0.04994655f, 
    0.22566496f, 0.08742926f, 0.16320802f, 0.07753885f, -0.03586020f, -0.07018371f, 0.05128340f, 0.05787774f, 
    0.07607830f, -0.06793207f, 0.04243623f, 0.10241805f, -0.04492108f, -0.07403941f, -0.18318747f, -0.02998937f, 
    -0.00674628f, -0.09110059f, 0.04266229f, -0.00714114f, -0.11597510f, 0.01718234f, 0.07160515f, 0.07503886f, 
    -0.13993976f, 0.02656816f, -0.02494479f, 0.00985736f, 0.05020125f, -0.06653547f, 0.00193496f, -0.05238361f, 
    0.00695767f, 0.01974434f, 0.04056813f, 0.02496186f, 0.02828413f, 0.05757166f, 0.04392613f, -0.02275894f, 
    0.45965236f, 0.11241607f, -0.20714667f, -0.09675945f, -0.13428967f, 0.03060511f, 0.06466776f, 0.00741414f, 
    0.09887319f, 0.14423265f, -0.11480955f, 0.02771512f, 0.04867871f, 0.00573715f, 0.16179845f, 0.03784253f, 
    0.02701657f, -0.02644383f, 0.10527053f, -0.13675849f, 0.26792148f, 0.11982917f, -0.07057679f, -0.03515688f, 
    0.43655083f, -0.19022359f, -0.05101250f, -0.05176860f, 0.05755282f, 0.02279053f, 0.07666493f, 0.12557335f, 
    -0.01659443f, -0.10620034f, 0.05025940f, 0.09594856f, 0.05591971f, -0.11053386f, -0.00453503f, -0.07220148f, 
    0.00357763f, 0.39409384f, 0.05707672f, 0.11631207f, 0.31098068f, -0.09023470f, 0.00062033f, 0.02311426f, 
    0.00958178f, 0.03700256f, 0.05675304f, 0.05991815f, -0.10475360f, 0.00355654f, 0.10121282f, 0.05761531f, 
    -0.01917677f, -0.06313252f, 0.16083476f, 0.04200480f, 0.26728010f, 0.13802812f, 0.00445194f, -0.11085129f, 
    -0.11671147f, 0.03283257f, 0.06852986f, 0.07424258f, 0.02652176f, -0.01462282f, 0.01249419f, -0.06720290f, 
    0.06487125f, 0.07925177f, 0.06941362f, 0.09822485f, 0.10999174f, -0.05516316f, -0.08313043f, 0.00050213f, 
    0.62121981f, -0.06928501f, -0.19900373f, 0.00046208f, 0.17123356f, -0.12804753f, -0.04713785f, 0.02169498f, 
    0.05097009f, 0.03973603f, -0.00367921f, 0.07472395f, 0.05910538f, 0.05744707f, 0.01244850f, -0.10381063f, 
    0.07087925f, -0.06778912f, -0.06624895f, -0.05611471f, 0.19026305f, -0.02589550f, 0.06109386f, 0.25164303f, 
    0.19409274f, -0.07153717f, -0.01468889f, 0.05805634f, 0.00432131f, -0.05972772f, 0.05593126f, 0.06129603f, 
    0.02512004f, 0.16191006f, 0.04657132f, 0.07357656f, 0.02495239f, 0.05408828f, -0.00805371f, 0.08407617f, 
    -0.00343765f, 0.50312644f, -0.21110997f, 0.30504653f, 0.27925086f, -0.00788257f, 0.01957165f, -0.02143442f, 
    0.01312219f, -0.00343668f, 0.04603193f, 0.01749482f, -0.06944952f, 0.00567085f, 0.06606043f, 0.08644038f, 
    0.16725324f, -0.00681175f, -0.07964987f, -0.02968522f, -0.17168391f, 0.02385008f, -0.01138612f, 0.07024342f, 
    -0.03109723f, -0.14008060f, -0.02947477f, -0.03702729f, -0.00799961f, 0.10676455f, 0.00843687f, -0.04241696f, 
    0.03708040f, 0.02848016f, 0.05257352f, 0.02323847f, 0.00385691f, -0.02641847f, 0.17178062f, -0.07403242f, 
    0.21220471f, 0.18796958f, -0.19694215f, -0.09666742f, -0.18033862f, -0.05335330f, -0.00681112f, -0.00362551f, 
    0.03503800f, 0.03295768f, -0.00356245f, -0.06178477f, 0.09498194f, 0.12233563f, 0.06928720f, 0.13539331f, 
    -0.03426597f, 0.03197751f, 0.12785105f, 0.18087921f, 0.15899356f, 0.46275982f, -0.03016653f, -0.09048983f, 
    -0.04656577f, 0.01982677f, 0.05699334f, -0.04898710f, 0.03570237f, 0.00097550f, -0.00582449f, -0.02738622f, 
    -0.04149891f, 0.02695452f, 0.07506339f, -0.02845592f, 0.01749687f, -0.00203557f, 0.11110484f, -0.10414041f, 
    -0.24150717f, -0.06712186f, 0.22881001f, 0.04180775f, -0.30723283f, 0.09355218f, 0.06817025f, 0.00362202f, 
    0.01358862f, -0.00228199f, -0.01028328f, 0.04534684f, -0.07496915f, 0.02600282f, 0.18463005f, -0.04772243f, 
    -0.07908799f, 0.04483322f, 0.11176880f, 0.09367692f, 0.15647848f, -0.03871648f, -0.12994920f, -0.12328442f, 
    -0.03730951f, -0.07072009f, -0.06196712f, 0.01812898f, 0.20865993f, -0.08416417f, 0.07162711f, 0.00864324f, 
    0.04852883f, 0.08097448f, 0.06966118f, -0.04653200f, 0.12087544f, 0.10339385f, -0.04149780f, 0.15064205f, 
    0.09972430f, 0.44417661f, -0.08833703f, -0.02909612f, 0.07014623f, 0.07274380f, 0.01381353f, -0.04779486f, 
    -0.04747513f, -0.05526274f, 0.00218879f, 0.04106402f, 0.03875014f, 0.13214153f, 0.09569042f, 0.03379868f, 
    -0.03189109f, 0.06559800f, 0.09784785f, -0.03441479f, 0.06931114f, 0.20937784f, -0.11712124f, -0.12860981f, 
    -0.10392688f, 0.03238185f, 0.10298577f, 0.08291430f, 0.10155714f, 0.14539202f, 0.10964746f, -0.05808673f, 
    0.02677478f, 0.07670847f, -0.07121388f, 0.11593901f, 0.06163257f, -0.15118316f, -0.08638152f, -0.09547915f, 
    0.25458956f, -0.25189474f, -0.00777131f, 0.02453094f, 0.03375267f, -0.05363642f, -0.10185257f, 0.07334358f, 
    0.04742561f, -0.06973322f, 0.16031045f, -0.02417624f, -0.00648961f, 0.01396004f, 0.05807496f, 0.03957902f, 
    0.04874491f, 0.06425583f, -0.13221394f, 0.03502621f, 0.08946741f, -0.05919991f, -0.07792622f, -0.02234199f, 
    -0.14711055f, 0.08829483f, 0.04996494f, 0.06460688f, -0.05531546f, 0.02684267f, 0.14277419f, 0.07802305f, 
    0.08859970f, 0.05268895f, -0.05541797f, 0.09501591f, 0.07687640f, -0.09657553f, 0.00645025f, 0.03859255f, 
    -0.09720332f, 0.25153092f, -0.04983785f, 0.12233885f, 0.12113200f, 0.10851488f, -0.03303954f, 0.05982782f, 
    0.06008589f, -0.04959403f, 0.09947022f, 0.07404206f, -0.03856920f, 0.19245109f, -0.03193746f, 0.03020925f, 
    -0.01119444f, 0.14295723f, -0.03874157f, 0.01303604f, -0.04776159f, 0.04672064f, -0.02906785f, -0.03081634f, 
    0.04856637f, 0.10366175f, 0.08227286f, 0.01407935f, -0.03894065f, -0.03059839f, 0.03688942f, 0.13204651f, 
    -0.09375912f, 0.04637920f, 0.05808202f, 0.05167914f, 0.07742668f, 0.07724717f, 0.03066680f, 0.13371912f, 
    0.23141821f, 0.16368887f, 0.12414759f, 0.12061654f, 0.15552013f, 0.04365798f, -0.00767276f, -0.05018827f, 
    0.04546589f, 0.03502657f, 0.06978395f, 0.00895946f, -0.01773476f, -0.02946111f, 0.02013304f, -0.06080571f, 
    0.10952207f, 0.12641686f, 0.11199074f, 0.00887972f, 0.20630661f, -0.06479324f, -0.01823018f, -0.01421041f, 
    -0.07448214f, -0.00269991f, 0.02527015f, 0.05969073f, 0.04761621f, -0.01931561f, -0.00576178f, 0.06342997f, 
    0.04698257f, 0.11099411f, 0.10009113f, 0.06584133f, -0.02924372f, -0.12765290f, -0.09331542f, -0.01298638f, 
    0.06254248f, 0.03026715f, 0.15917365f, 0.16248818f, 0.18179007f, 0.08887896f, -0.02483830f, -0.04086055f, 
    -0.03028928f, 0.02173822f, 0.02361533f, 0.03099667f, 0.02461747f, 0.03728216f, -0.00114752f, -0.01398256f, 
    0.15468806f, 0.10991543f, 0.11067072f, 0.08884404f, 0.00527197f, -0.17977823f, 0.09275118f, -0.02989119f, 
    -0.04228733f, 0.01380056f, 0.02818841f, 0.05802065f, 0.03713520f, 0.04357353f, 0.08858757f, 0.05804866f, 
    0.04090150f, 0.03239068f, -0.02617368f, -0.10581607f, -0.00946791f, -0.08064292f, 0.02401163f, 0.04982483f, 
    0.24386159f, -0.05592977f, -0.04283835f, 0.02011190f, -0.04025527f, 0.01529734f, 0.12166630f, -0.07136758f, 
    -0.00189370f, -0.03128218f, -0.05331948f, 0.01653574f, 0.00465055f, 0.00147099f, -0.01184533f, -0.03528845f, 
    -0.05350998f, 0.00434811f, 0.16742644f, 0.03205175f, -0.13766831f, -0.00609532f, 0.14380784f, -0.11093912f, 
    -0.16493535f, 0.02131129f, 0.03391672f, 0.02010881f, 0.02446930f, -0.10031167f, 0.03139800f, 0.06473199f, 
    -0.06948277f, 0.12998891f, -0.01553000f, 0.03904644f, 0.02913531f, 0.03627576f, -0.02854010f, 0.06567816f, 
    -0.01637516f, -0.05287081f, -0.04225312f, 0.01377236f, 0.03089067f, 0.02367282f, 0.02084106f, 0.04078777f, 
    -0.07117086f, 0.00679861f, 0.09646955f, 0.02304874f, -0.03857438f, 0.01218793f, 0.00965773f, 0.04807927f, 
    0.06899667f, -0.05598671f, 0.09245433f, 0.08257706f, -0.01121698f, 0.13974150f, 0.11026388f, 0.06124466f, 
    0.10938205f, 0.01122945f, -0.06791276f, -0.03551511f, 0.03259123f, 0.06000010f, 0.10439344f, 0.07177205f, 
    -0.00229422f, -0.06243616f, 0.00314054f, 0.02359211f, 0.01694028f, 0.08781174f, 0.02004382f, 0.13442439f, 
    0.35114533f, -0.10034819f, -0.13306606f, 0.02872936f, -0.04301128f, -0.00343027f, 0.10054673f, -0.06122571f, 
    0.01764012f, 0.10465496f, -0.03855267f, -0.02664495f, -0.01016831f, 0.04992416f, 0.04008476f, 0.03743422f, 
    0.07140697f, -0.01845023f, 0.07897389f, 0.03593083f, 0.09430774f, -0.04505536f, -0.14937373f, 0.17578757f, 
    0.11364967f, 0.01094060f, -0.00772428f, -0.01925286f, 0.01643471f, 0.04393670f, 0.04081359f, 0.02393167f, 
    -0.01718688f, -0.03919823f, -0.04234663f, 0.02099847f, -0.00544392f, 0.00018010f, 0.06594700f, 0.13191971f, 
    -0.11622140f, 0.08789715f, 0.04384237f, -0.04780261f, -0.10079550f, 0.05888371f, 0.00721367f, 0.13167325f, 
    0.15295990f, 0.04633710f, -0.02681212f, 0.00039895f, 0.08852870f, 0.05320113f, -0.02644822f, 0.07282344f, 
    0.00320661f, -0.00377438f, -0.04830789f, -0.01939417f, -0.06362756f, 0.11389732f, 0.02120755f, 0.07938851f, 
    0.02089582f, 0.03556769f, 0.01942145f, 0.06133958f, -0.00903018f, 0.06771773f, 0.02514833f, -0.02771027f, 
    0.04044680f, 0.01343338f, 0.06165105f, 0.08914845f, 0.04049167f, 0.03708348f, -0.03419282f, 0.10115056f, 
    -0.32342929f, 0.02569336f, -0.19582754f, -0.16941006f, 0.11099569f, -0.11963787f, -0.02694130f, 0.06036332f, 
    0.02970962f, -0.02241742f, 0.13872570f, 0.03907796f, 0.09680844f, -0.08285680f, -0.00663429f, -0.00702687f, 
    0.04633456f, -0.01549987f, 0.00483366f, 0.02438153f, -0.10620362f, 0.08475354f, 0.13398905f, -0.05959845f, 
    -0.15595916f, 0.06291641f, -0.02916918f, 0.03702353f, 0.14683725f, -0.06407641f, 0.06346789f, 0.01586277f, 
    0.02813877f, 0.05393553f, 0.00424605f, 0.06654916f, 0.08576393f, -0.04264919f, -0.07898089f, -0.02957398f, 
    0.00903052f, -0.10018300f, -0.40235519f, 0.00780674f, -0.07622385f, -0.06995049f, -0.01620810f, -0.04139437f, 
    -0.02228817f, 0.10818943f, 0.06216963f, -0.01220047f, -0.02489299f, -0.10204895f, 0.12881497f, 0.00057659f, 
    0.16857551f, -0.08054454f, -0.06013820f, -0.02042295f, 0.05631022f, 0.04450328f, -0.02091741f, 0.14001751f, 
    0.28224280f, 0.02751993f, -0.12394471f, -0.10662006f, 0.06406069f, -0.07364186f, 0.07652813f, 0.14854281f, 
    -0.03532888f, 0.16573797f, 0.02619431f, 0.09137329f, 0.08536820f, 0.03041862f, 0.01521777f, -0.07271925f, 
    -0.01227246f, 0.22432841f, 0.04076974f, -0.20858298f, 0.23443277f, 0.09834086f, 0.01428050f, -0.02963075f, 
    -0.03124314f, 0.10978282f, 0.07594909f, 0.09146827f, 0.06769712f, -0.01540977f, 0.13558139f, 0.01704441f, 
    0.04991834f, 0.12978284f, 0.11242633f, -0.00113478f, 0.13465998f, 0.09080306f, -0.12597357f, 0.05222599f, 
    0.00224865f, -0.03317925f, -0.01168647f, -0.05779819f, -0.15715033f, 0.01088346f, -0.03485959f, -0.00124394f, 
    -0.06475864f, 0.00520072f, 0.05556383f, 0.06553021f, 0.08486380f, -0.03559137f, -0.03471496f, 0.01249594f, 
    0.23453224f, -0.17637560f, -0.03914552f, 0.16522963f, -0.00425669f, -0.02455755f, 0.08560082f, -0.02258380f, 
    0.00128160f, -0.00899682f, 0.06132202f, 0.01555143f, 0.03074700f, -0.03961136f, 0.03391058f, -0.06099018f, 
    -0.00649218f, -0.02539362f, 0.14157549f, -0.02005938f, -0.11676304f, 0.06544961f, 0.36030301f, 0.09888096f, 
    0.02747620f, -0.01644623f, -0.02007792f, 0.03726909f, 0.00066180f, 0.02504653f, 0.10141400f, 0.00697750f, 
    0.11037495f, 0.10150715f, -0.05308241f, 0.00404014f, 0.02166169f, -0.03839187f, 0.05276131f, 0.05130217f, 
    -0.11188219f, 0.25486240f, -0.11889192f, 0.13721159f, 0.10669237f, 0.07476489f, 0.01010286f, 0.07020231f, 
    0.04304438f, 0.03695729f, 0.13209075f, 0.06959444f, 0.03153719f, 0.05076342f, 0.14349890f, 0.06981369f, 
    0.07575664f, 0.03059037f, -0.04044638f, 0.13285744f, -0.21234380f, -0.08755717f, 0.04135032f, -0.16883437f, 
    -0.06327672f, -0.14369418f, -0.04250091f, -0.07082837f, 0.07194661f, 0.04608436f, 0.01132468f, 0.00557155f, 
    -0.01603709f, 0.10341743f, -0.00308279f, 0.01831108f, -0.02317208f, -0.03606177f, 0.01176492f, -0.12876558f, 
    0.15661682f, -0.00567621f, -0.22948582f, 0.01767760f, -0.25712335f, 0.00912493f, -0.04320670f, 0.04918050f, 
    -0.02517257f, -0.00253497f, -0.06249501f, -0.05290666f, 0.07299352f, -0.01895123f, -0.02641012f, 0.11376504f, 
    0.00621156f, -0.07408813f, -0.06392480f, 0.03131966f, -0.33359942f, 0.05286435f, -0.15632492f, -0.06393003f, 
    0.01239524f, 0.00340837f, 0.01304934f, -0.05861894f, -0.07610531f, 0.03185301f, 0.05138763f, -0.01778971f, 
    -0.01284529f, -0.06740289f, 0.05973444f, -0.04884936f, 0.00752710f, -0.01701162f, 0.06520436f, -0.15343770f, 
    -0.29241177f, 0.08347900f, 0.20787387f, -0.09084703f, -0.35221967f, -0.04848968f, -0.02383519f, 0.07245794f, 
    0.01436193f, -0.01657594f, 0.14237390f, -0.05049625f, -0.00886597f, -0.00045838f, 0.09302627f, -0.04818963f, 
    -0.06479543f, -0.07930595f, 0.14825216f, 0.04625445f, 0.09086075f, -0.13243020f, -0.02573090f, -0.13408892f, 
    -0.15814692f, -0.00153766f, -0.04679532f, 0.00571239f, 0.03986070f, 0.00045427f, 0.09072406f, 0.06824075f, 
    -0.03257532f, -0.02518768f, -0.04707388f, -0.04795372f, 0.01041089f, -0.08585115f, -0.07169638f, 0.03490688f, 
    -0.02068729f, 0.10951185f, -0.01838460f, -0.04192846f, 0.08342931f, 0.00561220f, 0.02901090f, 0.01389761f, 
    0.03144393f, -0.00579688f, 0.02812103f, 0.02573768f, 0.12614262f, 0.03202375f, 0.02214470f, -0.00658469f, 
    0.03099739f, -0.06038595f, -0.06494901f, -0.09413720f, 0.04386470f, 0.09918736f, -0.03787839f, 0.06866663f, 
    0.03177384f, -0.03455017f, 0.11290979f, 0.10051084f, 0.07925848f, 0.12922448f, 0.01114061f, -0.06460762f, 
    0.05447129f, 0.06039244f, -0.03608632f, 0.13858519f, 0.01994199f, -0.07386265f, -0.00892802f, -0.04443049f, 
    -0.16926898f, -0.29943016f, -0.05241140f, -0.12062971f, 0.05405307f, 0.02085829f, -0.01820446f, 0.05264933f, 
    0.01658467f, -0.07979927f, 0.10920869f, -0.06130567f, 0.00425826f, -0.05515845f, -0.06291259f, -0.01885426f, 
    -0.05455064f, -0.02812104f, 0.03772510f, 0.02689568f, -0.03273490f, -0.14749728f, -0.01314862f, -0.03162457f, 
    -0.07877018f, 0.00240482f, -0.03863723f, -0.03546164f, -0.02641109f, 0.01657129f, 0.10395075f, 0.01506953f, 
    -0.00398777f, -0.02745140f, -0.00910170f, -0.05653472f, 0.04424430f, -0.05663129f, 0.07761738f, -0.01805517f, 
    -0.00156844f, 0.00622537f, 0.00002944f, 0.02943080f, 0.02611900f, -0.00442663f, -0.02889083f, -0.00169009f, 
    0.01801367f, -0.04100014f, -0.01345713f, -0.04474194f, -0.00574827f, -0.03439397f, -0.02393919f, 0.02818428f, 
    -0.03365319f, -0.01985827f, 0.01357464f, -0.01464681f, 0.02830100f, 0.01116729f, 0.00996053f, 0.00908289f, 
    0.00709831f, -0.00273775f, 0.02032195f, -0.04011188f, -0.02756278f, -0.01241281f, -0.01727884f, -0.02011845f, 
    -0.01131048f, 0.03947972f, 0.03610831f, 0.00013044f, 0.02974009f, 0.01147976f, -0.02981344f, 0.02303433f, 
    -0.03960017f, -0.04446420f, -0.00616812f, -0.01878132f, -0.01594548f, -0.03938953f, -0.00139774f, 0.04344004f, 
    0.01991353f, -0.00254100f, 0.01467763f, -0.00584575f, -0.01606241f, -0.03226813f, -0.00988739f, 0.02965616f, 
    -0.03527222f, -0.02639130f, -0.01663164f, 0.01784004f, -0.03670609f, -0.00269241f, -0.04427725f, -0.02231497f, 
    -0.02856534f, -0.03916072f, 0.01828221f, -0.01565946f, 0.03154811f, -0.01953022f, -0.02612038f, -0.00243681f, 
    -0.00735724f, -0.02920230f, 0.00387863f, 0.02768797f, 0.01396844f, 0.01359693f, 0.02964401f, -0.01623691f, 
    0.03074214f, 0.03114225f, 0.01558786f, -0.02054123f, 0.02512333f, -0.01611168f, -0.03120420f, -0.00931077f, 
    0.02086825f, 0.02606410f, 0.00008945f, 0.00644497f, 0.02392377f, -0.02013829f, -0.00179570f, 0.00956196f, 
    0.01470178f, 0.02659738f, -0.03198477f, -0.00731953f, 0.00053998f, -0.00475078f, 0.00173967f, -0.02418542f, 
    0.02862835f, -0.04134523f, -0.03732583f, 0.00337264f, 0.02100247f, -0.00210387f, -0.03378867f, 0.03370706f, 
    0.02478287f, 0.02623404f, -0.03170141f, -0.02540780f, 0.02694345f, -0.00598540f, 0.01174408f, -0.03338446f, 
    -0.04206587f, 0.03287175f, 0.00321772f, 0.03125292f, -0.03464948f, 0.02598114f, 0.00313454f, 0.01783237f, 
    0.03037529f, 0.01202351f, -0.03113400f, 0.03109117f, -0.01084224f, 0.01831694f, 0.03141674f, 0.01190251f, 
    0.01135366f, -0.03283779f, -0.03889815f, -0.01489646f, -0.01698264f, 0.00584404f, -0.00328575f, 0.02949302f, 
    -0.00601355f, -0.01778578f, -0.01335912f, -0.04111799f, -0.02832025f, -0.03782280f, 0.01682232f, -0.01383799f, 
    0.03300973f, -0.02439104f, 0.00931643f, -0.00199791f, -0.01802078f, -0.01132779f, 0.01629891f, 0.00612755f, 
    -0.00897106f, 0.02863858f, 0.01962394f, -0.04250659f, -0.03530994f, -0.00123348f, -0.00637642f, 0.01860126f, 
    -0.00152783f, 0.00776824f, -0.01987893f, -0.03034602f, 0.02391303f, 0.02271513f, -0.03579494f, 0.02067398f, 
    -0.03530791f, 0.00566990f, -0.02168127f, 0.00987885f, -0.01975055f, 0.02677594f, 0.02583596f, 0.01499398f, 
    -0.01542695f, 0.01580210f, 0.02616641f, -0.01157167f, -0.00435428f, -0.02128033f, 0.03117886f, -0.03400494f, 
    0.03815193f, -0.01956192f, 0.00958850f, -0.03620632f, 0.00942232f, -0.04449426f, 0.01388069f, 0.00004224f, 
    -0.02932201f, 0.01451663f, 0.02124671f, 0.01404272f, -0.00823162f, 0.02788233f, -0.01306989f, -0.02680505f, 
    -0.01142042f, 0.03235676f, -0.00639483f, -0.04536507f, 0.02172272f, 0.01695858f, -0.03007001f, -0.00918071f, 
    -0.03078165f, -0.02901848f, 0.02075760f, -0.03536684f, -0.02758986f, -0.03457401f, 0.01064704f, -0.01822059f, 
    0.02216791f, -0.04625830f, -0.03318520f, 0.03243271f, 0.02981068f, 0.00475154f, -0.01926308f, 0.01270135f, 
    -0.02022020f, -0.01276614f, -0.00792889f, -0.01894771f, -0.01217591f, -0.02627419f, -0.03412303f, -0.03658612f, 
    -0.03816764f, 0.00224933f, 0.02416963f, 0.03299086f, -0.03190100f, -0.00021776f, -0.03823292f, -0.01723456f, 
    -0.00414648f, -0.01742390f, -0.01190123f, -0.00891336f, 0.00651607f, 0.00313118f, -0.01260747f, -0.01108390f, 
    -0.01185491f, -0.01210357f, 0.02557733f, 0.02205095f, -0.02769583f, 0.02644102f, -0.00516341f, 0.02128827f, 
    -0.03251343f, -0.00549988f, -0.02476852f, 0.00328151f, -0.03294608f, -0.04124274f, 0.01219247f, -0.00596538f, 
    -0.04289095f, 0.01048234f, 0.03690786f, -0.00835413f, -0.03234588f, -0.02392616f, -0.02196854f, 0.01488917f, 
    -0.02487832f, -0.01155531f, 0.03830431f, -0.04536932f, 0.02678896f, 0.00325939f, 0.03595789f, -0.03452081f, 
    0.02667062f, -0.00021031f, -0.02221587f, 0.01577055f, -0.01583025f, -0.01287755f, -0.02159097f, -0.02677718f, 
    -0.03715324f, 0.01904183f, 0.00308532f, -0.02824237f, -0.04176113f, -0.01010779f, 0.01035646f, -0.02767080f, 
    0.00394978f, -0.02519085f, 0.02394642f, 0.01547861f, 0.02656358f, 0.00806656f, -0.03907622f, -0.04273596f, 
    0.04219038f, -0.03513697f, -0.01074325f, 0.00221879f, -0.00469607f, 0.01102274f, -0.04001679f, -0.03575451f, 
    0.00119236f, 0.00054574f, -0.00897316f, -0.01021175f, -0.03135027f, 0.00178906f, 0.04381380f, -0.03928494f, 
    0.03291794f, 0.00535135f, 0.03119972f, -0.02950224f, -0.03738554f, -0.00413534f, -0.03239017f, 0.03062911f, 
    -0.02744221f, -0.00342826f, 0.02890848f, -0.01737349f, 0.04094043f, -0.02282450f, -0.00541085f, -0.01456013f, 
    -0.01704121f, 0.01203339f, 0.00211683f, 0.02186723f, 0.02406476f, -0.01709841f, -0.00071311f, -0.03382013f, 
    0.01480267f, 0.01885025f, -0.00336103f, -0.00698722f, -0.02013061f, -0.02464765f, -0.03651997f, 0.00328453f, 
    0.01312496f, -0.01670076f, 0.02601934f, 0.01937620f, -0.03475256f, -0.04532786f, 0.03266785f, -0.01808963f, 
    -0.01183514f, 0.02810051f, -0.00464607f, -0.00678913f, -0.02430981f, -0.02794365f, -0.03300984f, -0.01013685f, 
    0.03037588f, -0.01055361f, -0.01437370f, -0.01023358f, 0.00361908f, 0.01342556f, -0.02370753f, 0.01631949f, 
    -0.00112629f, -0.02592042f, -0.02095852f, -0.04484619f, 0.01447516f, 0.03037692f, 0.03636691f, -0.00174418f, 
    -0.00839824f, 0.01133098f, 0.01595194f, -0.01219835f, 0.00077435f, -0.03584158f, 0.00275585f, -0.00860851f, 
    0.00130333f, -0.01897227f, 0.03762401f, 0.02367944f, -0.03098307f, -0.02148511f, 0.01384616f, -0.00774838f, 
    -0.00916240f, -0.00239729f, 0.02284373f, -0.02769284f, -0.01411688f, 0.02685786f, -0.03471690f, 0.00466596f, 
    0.00825772f, 0.03137160f, -0.02415968f, -0.03226443f, -0.00782822f, -0.01754652f, 0.02966196f, 0.02380535f, 
    -0.02603232f, 0.01607973f, -0.01849788f, -0.04324698f, -0.00208551f, -0.01429125f, -0.02477079f, -0.02017697f, 
    0.02900422f, -0.00324782f, -0.00866301f, 0.02275118f, 0.00113692f, -0.00620170f, -0.02259799f, 0.00566811f, 
    -0.00241713f, -0.01261076f, 0.03704074f, -0.01707374f, 0.00511002f, 0.00668969f, -0.03471563f, -0.03146125f, 
    -0.01579911f, 0.01383962f, 0.00360422f, -0.00074348f, -0.02055561f, -0.00683402f, -0.04735069f, -0.03160098f, 
    -0.02058887f, -0.01071445f, 0.02840639f, -0.01969849f, 0.00314888f, -0.01674516f, -0.01283929f, -0.01946598f, 
    -0.01793133f, -0.02128917f, -0.00040061f, 0.00789205f, 0.01314346f, -0.00199491f, -0.00940314f, 0.02846812f, 
    0.02014806f, 0.01798529f, 0.02056122f, -0.00711708f, -0.02047035f, -0.03364497f, 0.03658387f, -0.01263110f, 
    -0.02423227f, -0.01025513f, 0.00407941f, 0.01658722f, 0.00859232f, -0.00501587f, -0.03523664f, 0.03096405f, 
    -0.01792647f, 0.01755016f, -0.02457977f, -0.01436247f, 0.00846471f, -0.01181987f, 0.02081592f, -0.01952524f, 
    -0.03160527f, 0.01244374f, 0.02228634f, -0.01893822f, 0.02682639f, -0.01770711f, -0.01964865f, 0.01597003f, 
    0.01746841f, -0.04061485f, -0.03927318f, -0.03026948f, -0.03611304f, 0.03403177f, 0.00077583f, 0.01750056f, 
    -0.02823357f, 0.00913586f, -0.00048093f, -0.04059979f, 0.01502161f, -0.02797816f, 0.01201583f, 0.02745762f, 
    -0.00050453f, 0.02285525f, -0.03646570f, 0.02408161f, -0.00161877f, 0.03049224f, -0.03228608f, -0.02653340f, 
    0.01786626f, -0.02102437f, 0.00966527f, -0.04148068f, 0.02197100f, 0.01434268f, -0.01863998f, 0.01167004f, 
    -0.00441221f, 0.02960792f, -0.03718621f, -0.04278492f, -0.00906908f, -0.00121771f, -0.02556351f, 0.00671168f, 
    -0.00804641f, -0.01679534f, -0.01679691f, 0.02421476f, 0.00858928f, 0.02815910f, 0.00797257f, 0.01160260f, 
    -0.02762236f, -0.02928187f, -0.02295260f, -0.04013031f, 0.00028977f, 0.02025013f, 0.00173945f, 0.00487079f, 
    -0.01599918f, -0.01261122f, -0.02354207f, 0.02310677f, 0.00381765f, 0.03148187f, -0.03178857f, 0.00600568f, 
    0.02834826f, 0.01025782f, 0.01176182f, -0.00223251f, 0.03110817f, -0.01432469f, 0.00552502f, -0.00444592f, 
    -0.00734033f, 0.02962043f, 0.03253623f, -0.04321954f, 0.01031559f, 0.02852536f, -0.00356919f, -0.02753016f, 
    0.00244149f, -0.03060306f, 0.03440252f, -0.01876819f, 0.00430869f, -0.03301962f, 0.03680680f, -0.02143486f, 
    0.00737120f, 0.04326468f, -0.02137271f, 0.00825698f, 0.03509064f, -0.00204142f, -0.02990782f, -0.01324089f, 
    0.00119612f, -0.00526972f, 0.04241160f, -0.02788850f, -0.02927590f, -0.03671562f, 0.03122875f, 0.01831041f, 
    0.00110698f, -0.00190854f, -0.02397873f, -0.03553981f, 0.02318736f, 0.01025679f, 0.02189338f, -0.01303694f, 
    -0.00898443f, -0.00687227f, -0.04314579f, 0.00070532f, -0.01648343f, 0.02836620f, -0.02963642f, -0.02331759f, 
    -0.03649176f, 0.01839471f, -0.03991577f, -0.01916599f, -0.01009249f, -0.00195101f, -0.02444357f, -0.04611982f, 
    0.02368317f, 0.01656156f, 0.03014944f, -0.01842366f, -0.02143599f, -0.03825041f, 0.01331858f, -0.00353544f, 
    -0.04591626f, -0.14693590f, 0.05935954f, -0.15608677f, 0.07495610f, 0.10607277f, 0.09352937f, 0.08421236f, 
    -0.07365666f, -0.04063894f, -0.07948162f, -0.05512032f, -0.00768015f, -0.07088971f, -0.00486709f, 0.08092273f, 
    0.03600782f, -0.09994107f, -0.03641586f, 0.05196818f, 0.28931826f, 0.27008590f, -0.09907834f, 0.12632269f, 
    0.22643815f, 0.07018260f, -0.12385779f, -0.16103068f, 0.13940214f, 0.06368278f, -0.12434162f, -0.08752904f, 
    0.04445875f, 0.04381678f, 0.03755226f, -0.01114796f, 0.10071591f, -0.09806407f, 0.05966651f, -0.00765432f, 
    -0.08122285f, -0.12217049f, -0.26551482f, -0.18593755f, -0.09358662f, 0.04306212f, -0.00148273f, 0.09483103f, 
    0.06925853f, -0.06803767f, -0.01652187f, -0.00620277f, -0.01915492f, -0.03953112f, -0.02108780f, 0.04712496f, 
    -0.03144106f, -0.02504187f, -0.07424600f, 0.04793235f, 0.12781879f, 0.17405033f, -0.14786910f, -0.18706647f, 
    -0.04922494f, 0.08762699f, 0.06326747f, -0.00085995f, -0.03196077f, 0.10292741f, 0.07237925f, 0.12609217f, 
    0.04802885f, -0.16696939f, -0.07918249f, 0.03991671f, -0.12123039f, 0.17249948f, 0.07088719f, 0.08050691f, 
    0.03859134f, 0.13918141f, -0.07339247f, -0.03550692f, -0.01835752f, -0.06672107f, -0.01159119f, 0.02591408f, 
    0.09383179f, -0.07002936f, 0.02708747f, 0.00197076f, 0.13029368f, 0.04442851f, 0.14887102f, -0.04633025f, 
    0.09620477f, 0.07457090f, 0.00311227f, 0.04744121f, 0.00533985f, 0.27354530f, 0.03708076f, -0.01208933f, 
    -0.11206473f, 0.09515052f, 0.06426081f, 0.02508679f, 0.06027719f, -0.01947521f, 0.03224960f, 0.01228288f, 
    -0.00004300f, -0.09055061f, -0.01829144f, 0.09943861f, 0.03983249f, 0.17500909f, 0.11400052f, 0.08331110f, 
    -0.08976616f, 0.05511589f, 0.03277803f, 0.02567184f, -0.12514327f, -0.01340680f, -0.09091276f, 0.01529063f, 
    0.08529723f, 0.02628591f, -0.01161534f, 0.01155459f, 0.03428291f, -0.00185938f, -0.09585664f, 0.01387233f, 
    -0.01230583f, -0.03369768f, -0.03419533f, 0.01124413f, 0.15956916f, -0.03125235f, 0.23732851f, 0.05827881f, 
    0.28549904f, -0.05372322f, -0.08025056f, -0.06826156f, 0.09435950f, 0.00453162f, -0.02852999f, -0.02218485f, 
    0.09197679f, 0.04290272f, 0.04437198f, -0.05480012f, -0.00832363f, -0.09931986f, 0.10520569f, -0.06947654f, 
    0.07969431f, 0.22715235f, 0.05510645f, 0.19340914f, 0.01889890f, 0.09416912f, -0.04756884f, -0.06777142f, 
    0.19314212f, 0.01933893f, -0.01020826f, 0.04849416f, 0.09742460f, 0.09636410f, 0.13280320f, -0.09617729f, 
    -0.09326901f, -0.00747025f, 0.03763815f, -0.06929705f, 0.09439152f, -0.11249841f, -0.13877828f, -0.24208991f, 
    0.08684366f, 0.02935482f, -0.02191046f, 0.08892705f, -0.06440343f, -0.08793218f, -0.02608562f, -0.03237720f, 
    -0.01667749f, -0.05591153f, -0.03869222f, 0.10498647f, -0.09056104f, -0.03424437f, 0.04617269f, -0.00682804f, 
    -0.02134888f, 0.00323014f, 0.08504245f, -0.08068640f, -0.08963715f, -0.09742594f, -0.05372902f, -0.00069268f, 
    0.09899139f, -0.13141546f, 0.00062411f, -0.01423266f, 0.03901982f, 0.03841145f, 0.05147861f, 0.02660065f, 
    -0.08603793f, 0.00960035f, -0.02327303f, -0.00589727f, 0.12257410f, 0.22514580f, 0.10481232f, -0.02308118f, 
    0.00727563f, -0.00784904f, 0.13686576f, 0.03512136f, -0.05757995f, 0.02603639f, -0.02963224f, 0.13983612f, 
    0.01273020f, 0.16604057f, 0.06069353f, 0.04234183f, 0.04137986f, -0.09051131f, 0.06369746f, 0.00303431f, 
    0.37659803f, 0.21423844f, 0.20992178f, 0.04343771f, -0.06563637f, -0.01775693f, -0.04310929f, -0.12182149f, 
    -0.05860429f, 0.00836431f, 0.00907247f, -0.06102715f, 0.00712547f, 0.03162001f, 0.02538240f, 0.09018712f, 
    0.01443018f, 0.00045036f, 0.07288592f, -0.01287261f, 0.24988894f, -0.00706499f, 0.24373533f, 0.11693992f, 
    0.13359863f, -0.06917202f, -0.12282140f, -0.12921010f, -0.05910187f, -0.01920589f, -0.04438804f, 0.02853316f, 
    -0.01600937f, 0.02835421f, -0.02371898f, -0.01144205f, -0.00811710f, -0.06938780f, 0.02794684f, -0.11475902f, 
    0.45131797f, 0.17909706f, -0.11453518f, -0.03082925f, 0.03861677f, 0.08454135f, 0.10732597f, 0.04562854f, 
    0.17233567f, 0.06389490f, 0.15135805f, -0.01081876f, 0.01643902f, 0.02262511f, -0.02162752f, 0.00506007f, 
    0.02027005f, -0.12524374f, 0.11980851f, 0.11733393f, 0.14225544f, 0.07601298f, 0.17352855f, 0.10847464f, 
    0.03951569f, 0.00765044f, 0.02541968f, 0.00611100f, -0.04846074f, 0.09019454f, -0.01200020f, -0.05849642f, 
    -0.04663078f, -0.03130908f, -0.07613309f, -0.02290347f, 0.00172373f, 0.01288616f, 0.12286799f, -0.04334447f, 
    0.31271425f, 0.39327413f, 0.12413848f, 0.20445988f, 0.04303285f, 0.04674845f, -0.00319931f, -0.12284660f, 
    0.03659241f, 0.08037744f, -0.10822157f, 0.02889807f, 0.16532861f, 0.20904958f, 0.05218221f, 0.12329398f, 
    -0.00074710f, 0.03952703f, 0.17607638f, -0.00038403f, 0.16773473f, -0.15736315f, -0.11093229f, -0.22172064f, 
    0.00862909f, 0.06090480f, 0.12354904f, 0.11585655f, 0.04923623f, -0.03475608f, 0.01220293f, 0.08506726f, 
    0.05037105f, -0.10800025f, -0.06785035f, -0.00276242f, 0.00945998f, 0.11447656f, 0.02398702f, 0.05357048f, 
    0.26843879f, -0.10467102f, -0.11042513f, -0.02669784f, 0.09768420f, -0.01477217f, 0.12912199f, -0.02080068f, 
    0.06286500f, -0.09382782f, -0.00008002f, 0.02898180f, -0.03169549f, 0.16283663f, -0.10438763f, 0.08284783f, 
    -0.03314039f, -0.03139857f, -0.02689865f, 0.09799603f, 0.03648406f, -0.10553095f, 0.22631058f, 0.12932245f, 
    0.28998616f, -0.03967071f, -0.10270005f, -0.02021351f, 0.03660956f, 0.12053522f, 0.01450534f, -0.01506690f, 
    0.07285172f, 0.03681876f, 0.03555973f, -0.09390125f, -0.03838883f, 0.02006237f, 0.07999812f, 0.03044640f, 
    0.11386802f, 0.05443758f, -0.07591502f, -0.09937226f, -0.10429691f, 0.02375883f, -0.03509483f, -0.00331369f, 
    0.04475617f, -0.00519566f, -0.09388027f, 0.07949290f, -0.03059473f, 0.05714170f, 0.00002092f, -0.03482080f, 
    0.01158449f, 0.02594008f, -0.01959374f, -0.08399640f, -0.08800871f, -0.14888206f, -0.33475620f, -0.09723718f, 
    0.13880722f, 0.10877726f, 0.09253187f, -0.01739271f, 0.00678959f, 0.02774701f, 0.11734940f, 0.09901326f, 
    -0.08382646f, -0.11849622f, -0.03850787f, 0.00009492f, 0.05941452f, 0.02696030f, -0.06489955f, 0.07690477f, 
    -0.17045139f, -0.14502303f, -0.22737329f, -0.01885411f, 0.25776243f, 0.05222325f, 0.08709782f, 0.00171930f, 
    -0.06487281f, -0.03985253f, 0.05680412f, 0.01645621f, -0.09476852f, -0.11358774f, -0.14092672f, 0.06255452f, 
    0.11575534f, -0.08003969f, 0.03998755f, 0.02534640f, 0.29164717f, 0.01357922f, 0.29617906f, 0.24575406f, 
    0.00546643f, -0.12013437f, -0.05885118f, 0.02987411f, -0.00787631f, -0.03859732f, -0.04299562f, 0.04077015f, 
    0.09479501f, 0.07668925f, 0.04171288f, -0.00949675f, -0.00153121f, 0.08318226f, 0.03977084f, 0.00997991f, 
    0.18869296f, 0.02715312f, 0.39516836f, 0.24425405f, 0.13040306f, -0.00354979f, -0.10341430f, 0.01103679f, 
    0.11108281f, 0.10150038f, 0.01331437f, 0.06934345f, -0.10373904f, 0.07149085f, 0.05133794f, 0.04257974f, 
    -0.08855609f, 0.20844314f, 0.04521777f, 0.08035619f, 0.28412229f, 0.11256968f, -0.08228118f, 0.07711434f, 
    0.06627193f, 0.10330025f, -0.11589750f, -0.03532621f, 0.09193037f, 0.11800116f, -0.04370538f, 0.10665466f, 
    -0.00098491f, 0.03937456f, 0.05792749f, 0.05464154f, 0.07242356f, -0.05834485f, 0.01288845f, 0.00518400f, 
    0.19461769f, -0.00308640f, 0.09759349f, -0.08438626f, 0.20792647f, 0.09383012f, 0.01261856f, 0.03242400f, 
    0.02049492f, -0.13159777f, -0.00824333f, -0.08587947f, -0.01027034f, 0.01526896f, -0.13071743f, -0.07274947f, 
    0.01036967f, 0.03947451f, 0.05512177f, 0.02390018f, -0.01466256f, 0.04878506f, 0.15740766f, 0.27976364f, 
    0.14806020f, 0.00726463f, -0.04835540f, -0.03883666f, 0.05019384f, 0.03382568f, -0.05938428f, -0.02948716f, 
    0.07179668f, 0.17041609f, 0.03656097f, 0.02406289f, -0.07041706f, 0.11972984f, 0.07823020f, 0.02978078f, 
    -0.03019896f, 0.19345991f, -0.03185964f, -0.11551721f, -0.11229881f, 0.09432411f, 0.02016729f, -0.03979609f, 
    0.07463270f, 0.03613442f, -0.05588069f, 0.06640618f, 0.02542095f, 0.07212929f, 0.02889043f, 0.04061734f, 
    -0.01935237f, 0.10350245f, 0.14038901f, -0.01406896f, 0.16111173f, 0.07403903f, 0.25300512f, 0.07014621f, 
    -0.04154612f, -0.02763526f, -0.01499401f, -0.09925731f, -0.13119306f, -0.00369706f, 0.01748302f, 0.02182659f, 
    0.00070778f, 0.09263133f, 0.01785347f, 0.14234319f, 0.04642821f, 0.11634216f, -0.04863867f, 0.01397011f, 
    0.05263744f, 0.09932883f, -0.05453692f, 0.20896675f, -0.05880969f, 0.05265209f, 0.09072784f, 0.02286105f, 
    0.07168966f, 0.04021613f, 0.01734620f, 0.10224938f, 0.03343720f, -0.00996902f, 0.15425393f, 0.13734555f, 
    0.07667927f, -0.01430871f, -0.00987590f, -0.06519975f, 0.02070496f, 0.13187033f, 0.28468442f, 0.24989344f, 
    -0.09977052f, -0.06487586f, -0.03342061f, 0.05718303f, 0.00878380f, 0.18663406f, 0.01226060f, 0.01826512f, 
    0.09052611f, -0.01083348f, 0.10436790f, 0.02057420f, 0.03217193f, 0.05095599f, -0.04026675f, 0.10605344f, 
    -0.04040704f, 0.03226370f, 0.03167506f, 0.02054165f, -0.02775081f, -0.02232464f, 0.02927972f, 0.01945445f, 
    -0.00599252f, -0.00312756f, -0.03600460f, -0.01889785f, 0.01233383f, -0.03976922f, 0.00506522f, -0.01167595f, 
    -0.00909005f, -0.02125808f, -0.03436970f, 0.00236719f, 0.00407365f, 0.02649189f, -0.01802260f, 0.01090968f, 
    -0.04552866f, -0.03360303f, -0.03284782f, 0.01676216f, -0.00537212f, -0.04149435f, -0.01831144f, -0.04336996f, 
    -0.01655295f, 0.01578434f, 0.02041638f, 0.03748453f, 0.01777877f, 0.03833989f, -0.04063658f, -0.00340024f, 
    -0.02204185f, 0.00399154f, -0.00358405f, 0.00652665f, -0.01354120f, 0.01568198f, -0.02525498f, 0.00110723f, 
    -0.01725361f, -0.02598076f, -0.02108406f, 0.03337254f, -0.02868189f, -0.00250758f, -0.00202062f, 0.02705656f, 
    0.00154273f, -0.01959618f, -0.02160164f, -0.02428993f, 0.01243321f, -0.01979122f, -0.02498373f, -0.02529584f, 
    0.01319166f, 0.00520084f, 0.00418358f, -0.02506545f, -0.00915944f, -0.03982905f, 0.01057736f, -0.03268097f, 
    -0.02628892f, 0.01802268f, -0.01478445f, 0.02368016f, 0.01289154f, -0.04507409f, -0.01913949f, -0.03988210f, 
    0.02422823f, -0.03344620f, -0.01504136f, -0.00943909f, -0.03041987f, 0.00805833f, -0.03438697f, 0.00285169f, 
    0.02333196f, -0.02280330f, 0.01193572f, 0.02555283f, -0.01918102f, -0.03671738f, 0.02271533f, -0.01246274f, 
    0.02801726f, 0.02818621f, 0.00653680f, 0.01357848f, -0.02353821f, -0.02877998f, -0.02633201f, 0.02498653f, 
    0.00287532f, 0.02754950f, 0.02944035f, -0.00408716f, 0.02700839f, -0.02839358f, -0.02647072f, 0.00551202f, 
    0.02149803f, 0.00959116f, -0.02682186f, -0.00698817f, -0.01855880f, 0.01114008f, -0.01427370f, -0.01469554f, 
    0.00021117f, 0.02289493f, -0.00186462f, -0.00747080f, -0.02256913f, 0.01756424f, -0.01387423f, -0.02296718f, 
    0.01039099f, -0.04011105f, -0.03924225f, 0.03257720f, 0.02911405f, -0.00422735f, -0.03286714f, -0.03582976f, 
    0.00153353f, 0.01658574f, 0.01999032f, 0.01271001f, 0.02793474f, -0.03938180f, 0.01962094f, -0.02984960f, 
    0.00643536f, 0.02320785f, 0.01966610f, 0.01015867f, -0.02916783f, -0.00387433f, 0.03251900f, 0.01869038f, 
    -0.01819042f, 0.02588566f, -0.02303481f, 0.00709172f, 0.02640714f, -0.03616437f, 0.01428884f, -0.04302459f, 
    0.01343368f, -0.02412873f, 0.01403814f, -0.03302490f, -0.04003836f, -0.04014010f, 0.01785663f, 0.02172598f, 
    -0.03006274f, -0.02384186f, 0.01854611f, -0.00424444f, -0.01940893f, -0.04288438f, 0.02004901f, 0.02169145f, 
    0.02150328f, -0.00343936f, 0.02899623f, -0.00430018f, -0.04312614f, -0.01439036f, -0.01524236f, -0.00675687f, 
    0.02951555f, 0.01340784f, 0.02529624f, 0.02305416f, -0.01957971f, -0.02501748f, 0.00992741f, 0.03340230f, 
    0.01907070f, 0.02969408f, -0.02882076f, 0.03054565f, -0.03203576f, -0.03836145f, -0.03235362f, -0.01314170f, 
    0.00154632f, -0.02198824f, -0.04088815f, -0.03072656f, -0.00628137f, -0.02778602f, 0.02047187f, -0.01274537f, 
    -0.04344146f, 0.02034851f, 0.01982720f, -0.00646999f, -0.03815898f, -0.02858385f, 0.00382205f, -0.00853898f, 
    -0.00680703f, 0.02688834f, -0.00903948f, -0.03263459f, -0.00866324f, -0.04525016f, -0.00491901f, 0.01021369f, 
    0.01443651f, 0.02622685f, 0.02193921f, -0.01076353f, -0.03323087f, 0.02548026f, -0.04358945f, 0.00441651f, 
    -0.01957276f, 0.01008939f, -0.00386400f, 0.01601540f, -0.01440307f, -0.01365927f, -0.00790482f, 0.00781998f, 
    -0.03296768f, 0.00281812f, 0.02154449f, -0.03239638f, 0.02124340f, 0.01120564f, -0.00413692f, -0.01907167f, 
    0.03264355f, 0.00447622f, 0.04167997f, 0.02861380f, 0.03199302f, 0.02163304f, 0.01241368f, 0.03154879f, 
    0.00300932f, 0.00921503f, 0.03281095f, 0.01040121f, 0.00166565f, -0.00353854f, -0.01951503f, 0.02685373f, 
    -0.00141466f, 0.02225750f, 0.03322773f, -0.01138910f, -0.00345456f, -0.04428579f, -0.04168683f, -0.00968263f, 
    -0.00120654f, 0.03216181f, 0.02376409f, 0.00871551f, -0.03769025f, -0.00540114f, -0.02250377f, -0.04035572f, 
    -0.00819655f, 0.02340912f, 0.00628419f, 0.00682426f, -0.01221866f, -0.01594948f, -0.01262674f, 0.02702220f, 
    0.01316492f, -0.01826402f, 0.02476975f, -0.03784299f, 0.01103145f, -0.04521672f, -0.03875550f, -0.04302584f, 
    0.00888977f, 0.00598451f, 0.01180167f, -0.04070138f, 0.01695753f, -0.01593608f, 0.01303501f, -0.03868244f, 
    0.02919535f, -0.00494789f, 0.00235386f, -0.03037237f, -0.03324922f, -0.03739029f, -0.01821426f, 0.01985203f, 
    -0.03070290f, 0.01076699f, -0.00494882f, -0.00485339f, -0.00591834f, -0.01833047f, 0.00520126f, 0.00668512f, 
    -0.00953569f, -0.00265186f, -0.00642425f, 0.02473287f, -0.03681173f, -0.01303029f, -0.00763929f, -0.02486849f, 
    0.02239007f, 0.03096880f, -0.01384713f, -0.01449532f, -0.02992380f, 0.00600070f, -0.02705651f, 0.02100363f, 
    -0.04300791f, -0.03930561f, -0.02328204f, -0.04534075f, -0.00202403f, -0.02745813f, -0.00063695f, -0.02034724f, 
    -0.01110471f, -0.00835398f, 0.03053300f, -0.02389182f, -0.00553486f, -0.04278951f, 0.04291116f, -0.00385177f, 
    0.01798452f, 0.00049461f, 0.03141967f, 0.00901573f, -0.04123189f, -0.00843591f, -0.03468701f, 0.00794184f, 
    -0.01760166f, 0.02975676f, -0.03083255f, 0.01271033f, -0.04246833f, 0.00523343f, 0.00105636f, -0.01255023f, 
    -0.01690015f, 0.02797772f, -0.01762070f, -0.03432182f, 0.02888522f, 0.00404467f, -0.00523145f, -0.03648256f, 
    0.01072953f, 0.00319760f, 0.02898862f, 0.03184438f, -0.04096749f, -0.03607923f, 0.00959840f, -0.01808720f, 
    -0.00668347f, 0.01917196f, -0.03560024f, -0.00778119f, -0.02649060f, -0.00100690f, -0.02528569f, -0.04362018f, 
    -0.00908287f, 0.00188705f, 0.02842147f, -0.02460898f, 0.02078902f, -0.02478324f, 0.00046265f, 0.03341296f, 
    0.02374923f, -0.02522953f, 0.01859917f, -0.01198522f, -0.04342330f, 0.01073371f, 0.00121348f, 0.02753413f, 
    -0.00989139f, -0.03204660f, -0.01153067f, 0.01248586f, -0.00468285f, -0.01432108f, -0.00542698f, 0.03155680f, 
    0.01698733f, 0.00510943f, -0.03543228f, -0.02353095f, 0.00021720f, -0.04107786f, -0.00276972f, 0.01834309f, 
    -0.00534492f, 0.01234447f, -0.00950325f, 0.01377869f, -0.00901118f, -0.00192183f, -0.03622206f, 0.00996495f, 
    -0.04003006f, -0.02194045f, 0.01888990f, 0.02024217f, -0.01253765f, 0.00174434f, -0.02484555f, 0.02209354f, 
    0.03295118f, -0.00392352f, -0.01386300f, -0.03216197f, -0.03976080f, -0.02229788f, 0.02279270f, -0.03596823f, 
    -0.04434630f, -0.02889420f, 0.02345329f, -0.00307252f, -0.00501493f, -0.01827786f, 0.02984820f, -0.00855423f, 
    -0.04152273f, -0.00056346f, -0.02346149f, 0.00732178f, 0.02815599f, -0.04370197f, 0.01027754f, -0.02265163f, 
    -0.00440292f, 0.00894185f, 0.02781431f, -0.04293489f, 0.03610010f, -0.02653773f, 0.02718715f, -0.02698180f, 
    0.01246969f, -0.03772154f, 0.01797840f, -0.00625471f, -0.01699300f, 0.01482165f, 0.02724143f, 0.00270944f, 
    -0.02793643f, -0.04217076f, -0.02705610f, 0.01774832f, -0.01845386f, -0.03729029f, -0.03208189f, -0.00745731f, 
    0.03106160f, -0.02938351f, -0.04003989f, 0.00791125f, 0.02699550f, -0.01514078f, 0.01761177f, 0.01724255f, 
    0.01738669f, 0.00545224f, 0.04020680f, 0.00290776f, 0.01664352f, -0.00706327f, -0.04417092f, -0.03840340f, 
    0.00677073f, -0.03038891f, -0.02382834f, 0.03333171f, 0.00600121f, -0.02555430f, 0.00455717f, -0.04211592f, 
    0.02981269f, -0.02370739f, -0.00907497f, 0.01257188f, 0.00757659f, -0.01297957f, -0.02609274f, 0.03119968f, 
    0.01072313f, -0.00924370f, -0.00389037f, 0.02241633f, 0.01232187f, -0.00653659f, -0.00653847f, 0.01079096f, 
    0.00473580f, -0.01774395f, -0.03592568f, -0.00065964f, 0.01192038f, -0.04112129f, 0.02348946f, 0.01986731f, 
    -0.00454089f, -0.01243464f, -0.00673725f, 0.01818233f, -0.04500342f, -0.00643469f, 0.00531206f, -0.00939280f, 
    -0.02392834f, -0.03634660f, -0.00691964f, 0.02160143f, -0.03292604f, 0.00941086f, 0.00301847f, -0.04450626f, 
    0.00056531f, 0.01226803f, -0.03632104f, -0.00207011f, -0.01559737f, -0.02827764f, -0.04302454f, -0.01083632f, 
    0.00070398f, -0.01563187f, 0.01587610f, -0.02539441f, -0.04204750f, 0.02105382f, -0.02976757f, -0.03976755f, 
    -0.04448576f, -0.04340314f, -0.03433204f, -0.02514604f, 0.00344809f, -0.03028036f, -0.03892587f, 0.01733152f, 
    0.01498515f, -0.02569559f, 0.01302337f, 0.00243193f, 0.00172630f, -0.01236995f, -0.02690527f, -0.02145551f, 
    0.00580820f, 0.00103849f, -0.04548837f, 0.00916330f, 0.01060448f, 0.02004346f, -0.00344662f, -0.00770816f, 
    0.00638097f, -0.04287988f, 0.02354711f, -0.00938604f, -0.04448737f, 0.00933645f, -0.03734438f, 0.01941643f, 
    -0.03513000f, 0.00197186f, 0.00954693f, 0.00307411f, 0.00872171f, 0.00433725f, -0.04160472f, 0.00773983f, 
    -0.02788530f, 0.02765368f, -0.01337294f, 0.02116899f, -0.00336389f, 0.00115491f, -0.00391752f, 0.02177889f, 
    0.00997709f, 0.03350104f, 0.00282514f, 0.02367766f, -0.01167947f, -0.03961333f, -0.03343784f, 0.01090193f, 
    -0.03651568f, -0.01180556f, 0.03143071f, -0.01781000f, -0.02005485f, 0.00574288f, -0.04202836f, 0.02309885f, 
    -0.03111612f, -0.03286198f, -0.00466707f, -0.00530607f, -0.01866383f, -0.02726603f, -0.02989097f, 0.02204252f, 
    0.00928617f, 0.02468314f, -0.01441890f, -0.01388101f, 0.01130592f, -0.00727214f, -0.03230156f, 0.01318998f, 
    0.03226793f, -0.00615009f, -0.01683853f, 0.02763732f, 0.01507165f, -0.00803852f, 0.00365582f, -0.04343642f, 
    -0.04221224f, 0.03136229f, -0.01106145f, -0.02136529f, 0.00291477f, 0.01216516f, 0.00584883f, -0.02963621f, 
    -0.03315099f, 0.03640658f, -0.03885194f, -0.02170504f, 0.00089442f, -0.03555331f, 0.02750853f, 0.00573044f, 
    0.03271711f, -0.01851388f, 0.01094641f, -0.03553911f, -0.04545231f, -0.00607983f, 0.01119748f, 0.03125034f, 
    -0.02570751f, -0.01437403f, -0.02320418f, -0.03386082f, -0.02825517f, -0.03317673f, 0.03093182f, 0.01381776f, 
    0.00479003f, 0.00941241f, 0.01646294f, 0.00619295f, 0.00623045f, -0.00084862f, -0.01466177f, -0.03686021f, 
    0.01893135f, 0.02050452f, 0.00395799f, -0.01284424f, -0.00126664f, 0.02561755f, 0.01979716f, 0.01129258f, 
    -0.00814661f, -0.03490667f, -0.03682877f, 0.01277085f, -0.00072744f, -0.02947030f, 0.02563745f, -0.03955754f, 
    0.02534368f, 0.01990772f, 0.04029198f, -0.02951317f, -0.00437815f, -0.03947067f, -0.00573459f, -0.01745377f, 
    0.01539493f, -0.04213285f, 0.01544742f, -0.00408754f, -0.00670698f, 0.02667763f, -0.00029524f, -0.00519107f, 
    0.00856775f, -0.02378820f, 0.04216578f, -0.04370399f, 0.00943697f, 0.02596227f, -0.02094731f, -0.02818415f, 
    -0.00920401f, 0.02975013f, -0.02982319f, -0.04244294f, 0.01085919f, 0.01030991f, 0.01671922f, 0.00686928f, 
    -0.04124397f, -0.01128654f, 0.01806734f, 0.02609494f, -0.02070544f, -0.02388283f, 0.01433837f, -0.00612631f, 
    -0.01846299f, -0.02022856f, -0.01931250f, -0.00813590f, 0.03145995f, 0.02409171f, -0.03793527f, -0.02712248f, 
    0.02391104f, -0.02132955f, 0.02979569f, -0.01651627f, -0.01676023f, -0.02031973f, 0.00307198f, -0.03975258f, 
    -0.03176186f, -0.03843359f, 0.00321368f, -0.03116781f, -0.00792729f, -0.00966720f, -0.03508804f, -0.00480560f, 
    -0.02312708f, 0.00127010f, -0.03058266f, -0.01782491f, -0.04551949f, -0.00184227f, 0.01256543f, 0.01869568f, 
    -0.01656042f, 0.03033106f, -0.01694936f, 0.00503624f, 0.03114448f, -0.00217747f, -0.00208548f, -0.03395771f, 
    -0.01386829f, -0.00063430f, -0.02877839f, 0.02940153f, 0.03156107f, 0.01360824f, 0.02680849f, 0.02471547f, 
    0.00842594f, 0.01812852f, -0.03634675f, 0.00994330f, -0.00799095f, -0.02014851f, 0.01030838f, 0.00984503f, 
    -0.03713530f, -0.01650836f, -0.00122276f, 0.01039840f, 0.00149840f, -0.00241163f, -0.04532171f, -0.02461220f, 
    -0.02212584f, -0.01496488f, 0.02289105f, -0.01206408f, 0.02758859f, -0.00753946f, -0.03912372f, -0.03636105f, 
    -0.00237473f, -0.01437735f, 0.00419104f, 0.01527058f, -0.04047224f, -0.01961965f, -0.04523648f, -0.04228565f, 
    0.01273465f, -0.02365969f, 0.00858961f, 0.01184462f, -0.00674871f, -0.03814080f, -0.02891117f, 0.00764972f, 
    -0.03839377f, 0.02553820f, -0.03679585f, -0.03841422f, 0.00330101f, 0.03183952f, -0.02978118f, -0.03914529f, 
    0.02543849f, 0.00351888f, 0.00655586f, -0.03339946f, -0.02157755f, 0.02014924f, -0.02606285f, -0.02854979f, 
    0.00475978f, 0.03190875f, 0.03030468f, 0.00396590f, 0.00624866f, -0.00090891f, -0.02805039f, -0.03297681f, 
    -0.04494815f, 0.01876666f, -0.01454497f, -0.04452216f, -0.02922089f, -0.02754921f, 0.00680536f, 0.01469830f, 
    -0.01576285f, 0.00780278f, 0.02918462f, 0.03321882f, 0.00927005f, -0.03136953f, 0.01070993f, -0.01470204f, 
    0.03004663f, -0.01694775f, -0.00179966f, -0.01058183f, 0.02915275f, -0.03771591f, -0.00311122f, 0.01503166f, 
    0.00231301f, -0.04078406f, -0.01082795f, 0.02668432f, 0.01867849f, 0.01223252f, 0.02052220f, -0.02498860f, 
    0.02509580f, 0.03278574f, -0.00443526f, -0.02378628f, -0.01043624f, 0.01355363f, -0.04496504f, -0.02978800f, 
    -0.03089112f, 0.02393492f, -0.00902219f, -0.03875514f, -0.03369446f, 0.00340336f, 0.01235257f, 0.00057252f, 
    -0.03319206f, 0.01063401f, -0.02307241f, 0.00276864f, 0.03022515f, 0.02888348f, 0.01840487f, -0.03132056f, 
    -0.02518852f, -0.03330854f, -0.02527538f, -0.03581376f, 0.01921465f, -0.04095176f, -0.00298185f, -0.04123355f, 
    0.03208560f, -0.03152686f, -0.04081945f, 0.00160363f, 0.03254813f, -0.00537782f, -0.04291081f, 0.01754643f, 
    0.00510708f, 0.00190686f, -0.00383140f, 0.02874367f, -0.01612781f, -0.02452724f, -0.03688218f, 0.02471477f, 
    0.00507282f, 0.01419035f, 0.01466690f, -0.04371081f, 0.02670374f, -0.00636740f, 0.02686559f, 0.02976756f, 
    -0.00792589f, -0.01411933f, 0.00243782f, -0.01031042f, 0.01076541f, -0.03564671f, 0.00129945f, 0.00543968f, 
    0.01670841f, -0.03942158f, -0.01279614f, -0.01817260f, -0.01165304f, 0.01140640f, -0.03720181f, 0.00680561f, 
    -0.02684236f, 0.03160758f, 0.01952064f, 0.01034979f, -0.04331204f, 0.00154525f, -0.03838414f, 0.02168544f, 
    0.00272098f, -0.02161752f, -0.04422139f, -0.00235255f, -0.01134390f, -0.03155780f, -0.00187687f, -0.03496441f, 
    -0.02487409f, -0.01680012f, -0.01361589f, 0.01681665f, -0.01375606f, 0.00609100f, 0.02938610f, -0.00682903f, 
    -0.01276958f, 0.00373498f, -0.02031401f, 0.00715395f, 0.01061063f, 0.02648866f, 0.01261197f, 0.01616134f, 
    -0.03213304f, -0.04383277f, 0.00370285f, -0.01569944f, 0.01154994f, 0.01499152f, -0.01018710f, -0.00126393f, 
    -0.00833835f, -0.02127362f, -0.02843641f, -0.02782794f, -0.02727745f, 0.00630253f, -0.01826858f, 0.03046958f, 
    -0.01571517f, 0.00940044f, -0.00123982f, -0.02567923f, 0.02555213f, -0.03379525f, -0.02494514f, 0.02517863f, 
    -0.04441284f, -0.00541378f, 0.00422850f, 0.04366598f, -0.03243769f, -0.00159244f, 0.03049349f, 0.02095862f, 
    -0.01691539f, 0.01593543f, 0.02866238f, -0.03075692f, -0.00701072f, -0.00927550f, 0.00904144f, -0.03270864f, 
    0.02517720f, -0.02647869f, 0.01142868f, -0.04495994f, -0.02544792f, -0.03853972f, -0.02822245f, 0.02078158f, 
    -0.04253715f, 0.02075014f, -0.03088067f, -0.02251183f, -0.00095572f, -0.03918609f, -0.03342710f, -0.03546336f, 
    -0.04341368f, -0.00990484f, -0.03368205f, -0.01745466f, -0.01334740f, 0.00997434f, -0.02028381f, -0.03895897f, 
    0.03004809f, 0.01526291f, -0.01828305f, -0.03760829f, -0.01411155f, 0.01849544f, -0.04228960f, 0.03042833f, 
    0.02432955f, -0.01023250f, 0.01359340f, -0.02021489f, 0.01772450f, -0.03285537f, 0.01427494f, 0.01245057f, 
    -0.01033429f, -0.01464075f, -0.02156238f, 0.01064756f, -0.02065230f, -0.03017466f, -0.01144855f, 0.00191271f, 
    -0.01382290f, -0.02594762f, 0.02096544f, -0.02528868f, -0.04176321f, 0.00498735f, -0.02655749f, 0.01393577f, 
    -0.02495074f, -0.03252201f, -0.01287539f, 0.03314744f, -0.04039136f, -0.03689878f, -0.04055681f, 0.02904668f, 
    0.02037025f, 0.02782391f, 0.01956047f, -0.03146750f, -0.03189281f, -0.03050209f, -0.02826276f, -0.01070313f, 
    -0.03194149f, 0.00109892f, 0.02766956f, -0.03083737f, -0.03353505f, 0.02598419f, 0.00159632f, -0.02574124f, 
    0.02506598f, 0.03956234f, -0.01545659f, 0.00606629f, 0.00011876f, -0.01742684f, -0.04229758f, -0.04049836f, 
    0.01860248f, -0.01886269f, 0.03295554f, 0.02609728f, -0.02317670f, -0.00642692f, 0.01771051f, 0.01336640f, 
    -0.03200959f, -0.00719788f, -0.01703742f, -0.01840945f, 0.00166687f, 0.02147483f, 0.02480984f, -0.03928583f, 
    0.02259361f, -0.01158739f, -0.03609574f, 0.00418698f, -0.00223515f, 0.01529354f, 0.00888551f, 0.01061789f, 
    0.00614092f, -0.02933877f, -0.03890691f, 0.02823967f, 0.00079238f, -0.01912443f, -0.01674462f, 0.00654325f, 
    0.01283196f, -0.02084724f, -0.03143996f, -0.00294997f, 0.02668093f, -0.02512280f, 0.02610073f, 0.01579921f, 
    -0.01508206f, 0.01006227f, -0.02237483f, -0.04549491f, 0.00474576f, 0.00240488f, -0.03055811f, 0.02766862f, 
    0.00353316f, -0.00241174f, -0.01374789f, -0.04276053f, -0.03549771f, -0.04456300f, 0.02684207f, -0.03555816f, 
    -0.02072695f, -0.04463685f, -0.04004458f, -0.01161537f, 0.02961351f, 0.02439846f, -0.01181694f, 0.03039867f, 
    -0.02389540f, 0.01938674f, 0.01873646f, -0.00956459f, 0.02959925f, 0.02906688f, 0.00214882f, 0.01885588f, 
    -0.03396526f, -0.03817755f, -0.01348703f, -0.03078962f, -0.04539552f, 0.00181559f, -0.02672499f, 0.00373074f, 
    -0.04030933f, -0.03410542f, -0.01791638f, -0.03320485f, 0.01025986f, 0.02089302f, 0.00234738f, 0.00810960f, 
    0.00686451f, 0.00976323f, -0.04152842f, 0.02272064f, -0.02516869f, -0.02488857f, -0.01730719f, -0.01857735f, 
    -0.02759144f, -0.01923779f, -0.03119651f, 0.03297464f, 0.02885045f, 0.00811068f, 0.02995422f, -0.02897696f, 
    -0.04317281f, 0.00638901f, -0.01598353f, -0.01281472f, 0.01247669f, -0.00216159f, -0.02748363f, -0.02753515f, 
    0.02752008f, 0.00430559f, -0.04420650f, 0.00530536f, -0.00937955f, -0.01653337f, -0.02893943f, 0.01362238f, 
    -0.03607510f, -0.01741601f, -0.01350353f, 0.01208069f, -0.00310801f, 0.01282674f, -0.02241127f, 0.00130910f, 
    -0.00166427f, -0.00012163f, 0.03228281f, 0.02672690f, -0.02474021f, -0.01977560f, -0.00142222f, -0.03001682f, 
    -0.02311436f, -0.04169417f, 0.03116398f, -0.00830521f, -0.00085698f, 0.00605884f, -0.00884757f, 0.02146979f, 
    -0.01589377f, -0.01616783f, 0.03099448f, -0.02342968f, -0.02666604f, 0.01975322f, -0.04320267f, 0.01620899f, 
    0.01919705f, 0.02791843f, 0.02034670f, -0.02484410f, 0.00878209f, 0.02101780f, 0.00773444f, 0.02736971f, 
    -0.00224771f, -0.04060863f, -0.01207186f, -0.04446732f, -0.03967080f, 0.01570070f, -0.04097411f, -0.03395046f, 
    0.02715429f, 0.02224989f, -0.01624517f, 0.01505449f, -0.03642739f, 0.02961391f, -0.03389505f, -0.03354826f, 
    0.01890482f, 0.00157180f, -0.02574456f, 0.02178880f, 0.00286395f, -0.04142568f, -0.04094286f, -0.02061306f, 
    -0.02502084f, 0.01803665f, -0.02888172f, 0.02382140f, 0.02929336f, 0.01950448f, -0.00942570f, 0.00178088f, 
    -0.03636746f, -0.03822028f, -0.01262735f, -0.04674382f, 0.02258071f, -0.00326999f, -0.02777971f, 0.00429977f, 
    -0.00637971f, -0.04386923f, -0.01210833f, 0.00284032f, -0.03713591f, 0.02082492f, 0.01523736f, -0.04255110f, 
    -0.01192638f, -0.01294984f, 0.02796269f, 0.01021222f, 0.02503035f, -0.02629040f, -0.01036859f, 0.01432434f, 
    0.01414053f, 0.01261721f, -0.01557122f, -0.01707681f, 0.02864156f, -0.03631285f, -0.02513471f, 0.00991456f, 
    0.01601610f, -0.01803679f, -0.03527255f, 0.00921245f, 0.00809335f, 0.01976187f, -0.01113931f, -0.01433086f, 
    0.02859662f, -0.04344231f, -0.01581602f, 0.02373724f, -0.00512514f, -0.04617253f, 0.00725086f, -0.04584162f, 
    0.00120031f, 0.00369084f, 0.00521945f, -0.00838075f, 0.00029634f, 0.02374458f, -0.02783964f, -0.02588039f, 
    0.01809724f, -0.03859820f, -0.02135311f, 0.02506538f, -0.00097906f, -0.02116746f, -0.01880796f, -0.01031812f, 
    -0.02016354f, 0.02242268f, 0.00703960f, -0.00012932f, 0.00154465f, -0.00952947f, 0.01713596f, -0.02541509f, 
    -0.01295691f, -0.01800963f, -0.04570948f, -0.03789997f, 0.00211776f, 0.01645809f, -0.00795608f, 0.00608204f, 
    0.00999187f, -0.03500605f, -0.02612470f, -0.03503139f, -0.00589508f, -0.03235019f, -0.03046562f, 0.01774770f, 
    -0.02786421f, 0.00201173f, -0.02449486f, 0.01517427f, -0.00849087f, -0.04261320f, -0.00309450f, -0.00667292f, 
    -0.03000571f, -0.04784996f, -0.04111263f, -0.03693607f, 0.02077263f, -0.03264174f, 0.01840975f, -0.04722241f, 
    0.01380013f, -0.04323913f, -0.02392564f, -0.03369591f, -0.04659079f, -0.03592635f, -0.03119689f, 0.00490060f, 
    -0.01844817f, -0.01095193f, -0.00848316f, 0.00470354f, -0.00976736f, 0.01404521f, 0.02634781f, -0.03550445f, 
    -0.03490680f, -0.01944966f, -0.04736710f, 0.02351356f, -0.00661906f, -0.01007662f, 0.00668047f, 0.00288669f, 
    -0.02680564f, -0.02542875f, -0.04555942f, -0.02596590f, -0.03939376f, -0.02581849f, 0.01820637f, 0.02786977f, 
    -0.02142786f, -0.04470825f, -0.00794712f, 0.00061706f, -0.00920510f, 0.01535811f, -0.02356634f, -0.02279119f, 
    -0.03823776f, 0.00953131f, -0.00079205f, 0.00754826f, -0.03138925f, 0.02658303f, -0.02702626f, 0.00558145f, 
    -0.00854787f, -0.04587192f, -0.01896518f, -0.04708447f, 0.00876374f, 0.02650547f, 0.01100515f, -0.03915262f, 
    -0.03552825f, 0.02745385f, -0.03236136f, -0.02937629f, 0.02049852f, 0.03984018f, 0.02617041f, 0.00658279f, 
    -0.03311980f, -0.01791604f, 0.03128092f, -0.00837651f, -0.03090232f, -0.01114338f, 0.02312437f, -0.01901514f, 
    0.02418522f, 0.02429648f, 0.01039197f, 0.01791049f, -0.02428786f, -0.02559466f, -0.04502549f, -0.00835774f, 
    -0.03828984f, 0.00235717f, 0.00522568f, -0.01872176f, 0.01386978f, -0.02317185f, -0.03214210f, -0.02120470f, 
    -0.03613248f, 0.02521246f, -0.03433827f, 0.00360862f, -0.01849405f, 0.01803555f, -0.01405767f, 0.01906274f, 
    0.00845920f, 0.02250315f, 0.00055016f, 0.01335580f, -0.00926602f, -0.02574521f, -0.00153895f, -0.03541024f, 
    -0.01050607f, 0.00641759f, 0.02745853f, 0.02425571f, 0.02702140f, 0.02226450f, 0.00478722f, 0.01560500f, 
    -0.01943940f, -0.00479737f, -0.00581033f, 0.01650578f, -0.03446997f, 0.00257029f, -0.03877326f, 0.01390003f, 
    -0.00530887f, 0.01426814f, -0.04476340f, -0.00419082f, -0.04548633f, -0.03821835f, 0.00540809f, 0.00958831f, 
    -0.02165104f, -0.00144977f, -0.03489439f, -0.01888188f, 0.01658713f, -0.02309002f, 0.00414416f, 0.02618028f, 
    -0.03864583f, -0.01342523f, -0.01080397f, -0.03576175f, -0.04117365f, -0.00063251f, -0.04764374f, -0.02956885f, 
    -0.02927752f, 0.01865369f, 0.00901753f, -0.03973790f, -0.04032720f, -0.00824204f, -0.03485133f, 0.02152581f, 
    -0.00949541f, -0.04180921f, -0.01265477f, -0.02217772f, -0.04109432f, 0.03060080f, -0.00807830f, 0.01246135f, 
    0.01355665f, -0.02103809f, -0.04394839f, 0.00443100f, 0.02597427f, -0.04472606f, -0.03623920f, 0.01201227f, 
    0.01852413f, 0.01197956f, -0.01388934f, -0.02143752f, -0.02184981f, 0.02296042f, 0.01189417f, -0.02512463f, 
    0.01462772f, -0.03547915f, 0.00694375f, -0.03793074f, -0.04301497f, -0.03886492f, 0.01955364f, 0.01588435f, 
    -0.03991672f, 0.00211305f, -0.00069581f, 0.00159781f, 0.02098013f, 0.03084251f, -0.02954278f, -0.02615467f, 
    0.02187660f, -0.02021690f, 0.00268816f, 0.00334504f, -0.02209898f, -0.04139373f, 0.01460279f, 0.01734261f, 
    0.00693564f, 0.02351186f, 0.01500830f, 0.00047719f, -0.03064186f, 0.02861889f, -0.01513807f, 0.02030432f, 
    -0.01083771f, -0.02432055f, -0.03203239f, -0.03249500f, -0.00132977f, -0.03510290f, -0.03650162f, -0.02728657f, 
    0.02873689f, 0.00304794f, -0.04313660f, 0.00470773f, -0.00779973f, -0.01036873f, -0.00152711f, 0.02209022f, 
    0.01646257f, 0.02187770f, 0.02750571f, 0.03075201f, -0.00942383f, -0.01920025f, -0.03722738f, 0.01460219f, 
    -0.00281237f, -0.02014005f, 0.00241367f, -0.00759676f, -0.00620351f, 0.03083783f, 0.01935774f, 0.03064357f, 
    0.00962899f, -0.01064577f, -0.02189054f, -0.02935652f, 0.02704708f, 0.01311863f, -0.00893660f, -0.01494762f, 
    0.01186599f, -0.04066183f, 0.00894029f, -0.00656034f, 0.00591305f, -0.04329827f, -0.04340248f, -0.01028633f, 
    0.01103460f, -0.04233983f, -0.01923312f, -0.00889270f, -0.00799437f, 0.00414747f, -0.00045326f, -0.02643675f, 
    0.00292008f, 0.01066987f, 0.01541011f, 0.02264260f, 0.02354677f, 0.01206382f, 0.01786059f, -0.01008924f, 
    -0.01361919f, -0.00396412f, 0.00728763f, -0.02129097f, 0.01097557f, -0.00040907f, -0.02368037f, 0.02298059f, 
    -0.00440500f, 0.00522860f, -0.01563619f, -0.04717665f, 0.02821699f, -0.04747412f, 0.01529091f, -0.01192260f, 
    -0.00159933f, -0.04287462f, 0.00650638f, -0.02792335f, -0.01031579f, -0.02952622f, -0.00330304f, 0.00812515f, 
    -0.03441290f, 0.02432965f, -0.00621941f, 0.02367085f, -0.02891692f, 0.02840507f, -0.03561428f, 0.00488239f, 
    -0.01516488f, 0.01651725f, 0.00352456f, 0.02431950f, 0.02738133f, -0.04273028f, 0.02194187f, 0.00075272f, 
    0.00616316f, 0.00052518f, -0.03295522f, -0.03681673f, 0.02575930f, -0.00009889f, 0.01485357f, 0.01963704f, 
    -0.02991852f, -0.03707581f, -0.00764794f, -0.02744805f, 0.01379348f, -0.00039113f, -0.00622236f, -0.00789940f, 
    0.00904084f, 0.02966844f, -0.01357081f, -0.02592968f, -0.00771942f, 0.01685230f, 0.01401593f, -0.04774519f, 
    -0.02385151f, 0.01608098f, -0.00505308f, -0.03127017f, 0.00289768f, 0.02794714f, 0.02459604f, -0.03417194f, 
    -0.02953662f, -0.04148215f, -0.02203406f, 0.01699121f, -0.00594010f, -0.01446688f, 0.02019266f, -0.00260453f, 
    -0.00684754f, -0.04284965f, -0.02062356f, -0.01331891f, -0.04051267f, 0.02686921f, -0.03770062f, -0.02712136f, 
    0.01048773f, 0.00759176f, -0.02583231f, 0.00070512f, 0.01728863f, -0.03866791f, 0.02439756f, 0.02088655f, 
    0.02001934f, 0.00379822f, -0.03071398f, 0.00358615f, -0.00120039f, 0.01370744f, 0.02587105f, -0.00010931f, 
    -0.04562528f, -0.01176155f, -0.04278183f, 0.01039151f, -0.02559857f, 0.01294231f, -0.01088339f, -0.01573703f, 
    0.01971227f, -0.01130779f, -0.01377435f, -0.01252077f, 0.00993930f, -0.04507488f, 0.01909014f, -0.00499259f, 
    0.01893761f, -0.02488648f, -0.02869979f, 0.02790274f, -0.04679385f, 0.03080376f, -0.01434037f, 0.00838421f, 
    -0.03105909f, -0.03919681f, -0.03645312f, -0.04469822f, -0.00427615f, -0.00230683f, -0.03088477f, -0.02435332f, 
    -0.03557681f, 0.01695243f, 0.00047746f, 0.01084381f, -0.00317815f, -0.02773316f, -0.02504293f, -0.04717177f, 
    -0.00274642f, -0.01804889f, -0.04245427f, -0.00374832f, -0.02556916f, -0.02520959f, 0.02094989f, -0.00704390f, 
    -0.03516467f, 0.01143148f, 0.00971656f, -0.03691058f, -0.03494804f, -0.00685505f, 0.03027506f, -0.01211118f, 
    -0.03716014f, 0.00286110f, -0.01443764f, 0.01168705f, 0.02820457f, 0.02677977f, -0.00961831f, 0.02868723f, 
    -0.02692591f, -0.03634277f, -0.03804747f, -0.00286606f, 0.00907290f, 0.02988408f, -0.01664380f, 0.00520222f, 
    -0.03378478f, 0.01145286f, -0.03133113f, -0.02805144f, -0.02615538f, 0.00243532f, 0.00427131f, 0.01373290f, 
    0.01636896f, -0.03809354f, 0.00118351f, -0.02710862f, -0.02859504f, -0.03853356f, 0.02505578f, 0.01614892f, 
    0.00140517f, -0.00411355f, 0.00677190f, 0.01302475f, 0.02125839f, -0.04333251f, -0.01315322f, 0.00726305f, 
    0.02986887f, -0.04186303f, -0.03073116f, -0.02719426f, -0.01694790f, -0.04456670f, -0.03182299f, 0.00558139f, 
    -0.01958854f, -0.03356390f, 0.00881340f, -0.00863543f, -0.04010571f, -0.01561351f, -0.03021427f, -0.00221516f, 
    0.01666823f, 0.00803811f, -0.02744941f, -0.03424680f, -0.00424987f, 0.02786604f, -0.00995502f, 0.02261079f, 
    0.12861684f, -0.03928612f, 0.05349206f, 0.04996166f, -0.03313975f, 0.11790779f, -0.05702526f, 0.05994590f, 
    0.07783073f, -0.05589519f, 0.04041325f, 0.05103187f, -0.00108107f, 0.16437849f, -0.22725998f, -0.03766356f, 
    -0.04132852f, 0.07910289f, 0.07501396f, -0.06621584f, 0.01199957f, 0.06347995f, 0.07406792f, 0.12546262f, 
    -0.00254889f, -0.14493112f, -0.12634343f, -0.02637923f, -0.00531261f, 0.03911015f, 0.06476710f, -0.00083945f, 
    0.09795522f, -0.00115950f, 0.05778250f, 0.05243319f, 0.03877210f, 0.06634238f, 0.09552873f, 0.08145168f, 
    0.30640939f, 0.28569430f, 0.25478873f, 0.24695516f, 0.28065145f, 0.02556086f, -0.00314141f, 0.00962995f, 
    -0.03382757f, 0.03486926f, -0.01478601f, 0.02702272f, -0.03856909f, 0.07039541f, 0.00801195f, 0.01383947f, 
    -0.03670086f, 0.06157861f, 0.03876097f, -0.09553496f, 0.05370341f, 0.04598366f, -0.15519863f, -0.04061629f, 
    -0.14728062f, -0.10428309f, -0.06775921f, -0.01003189f, 0.03902395f, 0.11225506f, -0.04367233f, -0.07797223f, 
    0.00215908f, 0.10241911f, 0.05410020f, 0.02887022f, -0.03111672f, -0.04687348f, -0.09745041f, 0.03051622f, 
    0.04925659f, 0.32550132f, 0.03993268f, 0.06792285f, -0.05705469f, -0.04568598f, -0.00247785f, -0.03598867f, 
    0.00301341f, 0.00479969f, 0.12564325f, 0.03204847f, 0.05527610f, 0.04845411f, -0.10997707f, 0.08034746f, 
    -0.00333635f, 0.05398869f, 0.04541882f, -0.01907448f, 0.15404513f, -0.01262687f, -0.24155825f, -0.17598842f, 
    0.01136189f, -0.08142348f, 0.02861196f, 0.00602102f, -0.03577217f, 0.01224696f, -0.04283714f, -0.09221265f, 
    0.07250886f, 0.07758937f, -0.00147874f, -0.03452059f, -0.09034637f, 0.03455817f, 0.00403314f, -0.01747241f, 
    0.25013623f, 0.17416422f, 0.15156010f, -0.12101955f, 0.09267952f, -0.18965037f, -0.04192933f, 0.06459420f, 
    -0.08613838f, 0.00275069f, -0.02914608f, 0.05601339f, -0.03305784f, 0.02694559f, 0.00751432f, -0.01432485f, 
    -0.11474625f, 0.02142019f, 0.09350562f, -0.02062084f, -0.10674730f, -0.09853382f, 0.05360978f, 0.05572778f, 
    -0.04778940f, 0.09360550f, 0.02139161f, 0.01563664f, -0.02551193f, 0.05235503f, -0.04021829f, 0.09274426f, 
    -0.00834268f, 0.02417097f, 0.06819859f, 0.03686176f, -0.02091347f, -0.04419096f, -0.05450755f, 0.02256559f, 
    -0.26549429f, 0.10546572f, 0.04831076f, -0.12971313f, -0.13632128f, -0.10151708f, -0.01498868f, -0.02607680f, 
    0.01536333f, -0.00687014f, 0.00115470f, 0.04241036f, 0.01174299f, -0.11627406f, 0.01492238f, -0.03500699f, 
    0.08064531f, -0.00105156f, 0.10547545f, 0.00870296f, 0.16073819f, 0.24594809f, 0.05838367f, 0.20992713f, 
    0.04527520f, -0.04598674f, -0.20677881f, 0.05344542f, 0.00020972f, -0.01429202f, -0.00593646f, 0.02084952f, 
    -0.12212104f, 0.04893445f, -0.00983169f, -0.03942807f, -0.05925695f, 0.05772082f, -0.09471988f, 0.00776802f, 
    0.19617678f, 0.28125128f, 0.02974576f, 0.06492779f, 0.01880581f, -0.03495349f, -0.06061577f, -0.05261153f, 
    -0.10512619f, 0.02086652f, 0.00474744f, 0.02006260f, 0.04800002f, 0.04149427f, 0.08047079f, -0.05433408f, 
    -0.00981746f, 0.02396223f, 0.04843375f, -0.04591958f, 0.58211416f, -0.10795372f, 0.08930299f, -0.01357948f, 
    0.07863191f, 0.01379975f, -0.04487955f, -0.05027897f, 0.02734978f, -0.07677399f, 0.06270764f, -0.02379377f, 
    0.04343330f, 0.06162136f, -0.05505672f, 0.08411449f, -0.05950736f, -0.00092705f, 0.06032725f, 0.02202694f, 
    0.00665866f, -0.08826534f, 0.29846659f, 0.06746922f, 0.08634627f, -0.03613629f, 0.05958318f, 0.05553039f, 
    0.08800595f, 0.04237230f, 0.02272536f, 0.03441956f, 0.01982578f, 0.10961250f, 0.00906577f, -0.03194092f, 
    0.06409993f, 0.04272949f, -0.03860708f, 0.00366685f, 0.03560522f, -0.16359329f, 0.03142264f, 0.15188080f, 
    0.11961531f, -0.10746930f, -0.07594647f, 0.06103526f, -0.03548815f, -0.02673056f, 0.01049909f, -0.04248572f, 
    0.06268588f, 0.08144376f, -0.03052730f, -0.03644843f, 0.05539329f, -0.03680246f, 0.02373928f, 0.12218008f, 
    0.19602983f, -0.29656142f, -0.04969321f, -0.03826762f, -0.04176260f, 0.03680211f, 0.01918728f, 0.00076050f, 
    0.03812931f, -0.04959041f, 0.05185257f, -0.08244567f, 0.05640066f, -0.09884576f, -0.01883342f, -0.00389177f, 
    0.04314663f, 0.02813587f, 0.00165718f, -0.00760524f, 0.14817663f, -0.29890922f, 0.10251809f, 0.01794917f, 
    -0.07802672f, -0.03414105f, 0.02673667f, -0.04214507f, -0.00199229f, -0.09253446f, 0.03077467f, 0.04258618f, 
    0.04098864f, 0.05861518f, -0.02263122f, -0.05373209f, -0.05862760f, 0.02631220f, -0.13269821f, -0.02677100f, 
    -0.28850025f, -0.19688371f, -0.19628130f, -0.02518683f, 0.16211995f, 0.15450402f, 0.05594754f, 0.01696018f, 
    0.07643798f, 0.05907607f, 0.14091872f, -0.06900981f, -0.04837111f, 0.04073714f, 0.02280025f, 0.02021808f, 
    -0.00150016f, 0.07991059f, 0.02152473f, 0.06019916f, -0.30825210f, 0.22869655f, 0.10586046f, 0.11506087f, 
    -0.14641012f, 0.07319465f, -0.04579937f, 0.00830792f, 0.03228033f, 0.01870069f, -0.04524786f, -0.06548384f, 
    -0.02758385f, 0.08938992f, -0.10640200f, 0.01691733f, -0.10057898f, -0.03726751f, 0.01510992f, -0.07544660f, 
    0.31505826f, 0.06853367f, 0.04265986f, -0.01078812f, -0.11599813f, 0.06619596f, -0.07988878f, -0.00991340f, 
    -0.02458532f, 0.01568818f, -0.05887620f, 0.08141227f, -0.00067316f, 0.02950791f, -0.01738924f, -0.00702803f, 
    0.00612710f, -0.01349626f, 0.07799399f, -0.07572310f, -0.14970461f, 0.00095333f, -0.04355114f, 0.06522603f, 
    0.06165010f, -0.04062475f, -0.07415711f, 0.00466952f, -0.09960938f, 0.11404300f, 0.01203671f, 0.01746084f, 
    0.06943841f, -0.01958970f, 0.12543191f, 0.06115240f, 0.01870009f, 0.05538061f, -0.02906110f, 0.08519316f, 
    0.02203013f, 0.15051828f, 0.05181569f, 0.14071360f, 0.10683901f, 0.02988952f, 0.01896063f, -0.03604157f, 
    -0.01476285f, 0.07088476f, -0.10413669f, -0.00069200f, -0.00740316f, 0.00980992f, 0.09698226f, -0.03049874f, 
    -0.00390215f, -0.04036631f, 0.08925845f, -0.03449312f, -0.15052059f, 0.33343974f, -0.01368753f, 0.21917433f, 
    0.11379348f, 0.03034101f, 0.02374036f, 0.03305448f, -0.00677194f, -0.04342557f, -0.05150669f, 0.00482995f, 
    0.02805278f, -0.03925498f, -0.01933066f, -0.06071084f, -0.00667509f, -0.01044530f, 0.03977352f, 0.02489184f, 
    0.00729079f, -0.00017469f, 0.04734504f, 0.04724321f, -0.06118286f, 0.12638314f, 0.15134658f, 0.06107442f, 
    0.05794897f, -0.07473852f, -0.06353068f, -0.04936370f, 0.02254531f, 0.05859736f, 0.02365402f, -0.08623540f, 
    -0.01603509f, -0.05900175f, 0.00076818f, -0.03417617f, 0.09473252f, -0.15649201f, 0.15516508f, -0.06742772f, 
    -0.05479595f, 0.19835891f, 0.06390149f, 0.07359549f, 0.00558500f, 0.14124854f, 0.01287146f, -0.04267658f, 
    -0.05929469f, 0.07659280f, -0.02545218f, -0.03303379f, 0.05723582f, 0.12448207f, 0.01920468f, -0.06054050f, 
    -0.11613651f, -0.20495360f, 0.13146693f, -0.13520265f, 0.04804856f, 0.05324412f, 0.15844370f, -0.06308869f, 
    -0.01495537f, 0.05090719f, 0.04064357f, 0.00081959f, 0.02534335f, 0.00928115f, 0.00998647f, -0.02368980f, 
    0.05855682f, -0.05609751f, 0.06728946f, -0.05293386f, -0.23740718f, -0.16943465f, 0.12327277f, 0.09467650f, 
    0.06179666f, 0.09874371f, 0.01116482f, -0.03080541f, 0.03649138f, 0.08267139f, -0.00302736f, 0.01614624f, 
    0.00383113f, -0.00587935f, -0.04978113f, -0.02938248f, 0.04063170f, 0.04142836f, 0.14458594f, 0.02040477f, 
    0.00355056f, -0.07776675f, 0.00409912f, -0.09375868f, 0.00394471f, -0.01990530f, -0.01494410f, 0.02732679f, 
    -0.01457159f, 0.08944460f, 0.05822868f, 0.00666094f, 0.04881833f, -0.06471618f, 0.05232333f, 0.00953668f, 
    -0.09166121f, 0.04753765f, 0.10437091f, 0.08710814f, -0.20406608f, 0.05277928f, 0.19717851f, -0.19598399f, 
    0.07650863f, 0.09217849f, 0.05225885f, -0.04317960f, 0.00669913f, 0.12546854f, 0.00124274f, 0.12538083f, 
    0.01058755f, -0.09617733f, 0.05461635f, -0.02661522f, 0.11745442f, 0.01530079f, -0.06068945f, -0.05985582f, 
    -0.12745231f, -0.12436392f, 0.09827963f, 0.09380440f, 0.16327362f, 0.14869481f, -0.06440528f, -0.04989156f, 
    0.03393079f, 0.07890853f, -0.01265012f, 0.02457445f, 0.00077991f, 0.00126537f, 0.02477271f, -0.02018588f, 
    -0.04545015f, -0.08105869f, 0.05502173f, 0.07678194f, 0.08010401f, -0.19142295f, 0.14747155f, 0.06577405f, 
    0.08191883f, -0.12696257f, -0.01220330f, 0.04020355f, 0.07810658f, -0.05826261f, 0.04277036f, 0.05995649f, 
    0.00464137f, 0.01746267f, 0.00793528f, -0.01187288f, -0.03614340f, 0.02727395f, 0.02460888f, -0.02619965f, 
    0.06350523f, -0.03183907f, 0.11018585f, -0.15679593f, -0.18661748f, -0.14872676f, -0.04261907f, 0.04726450f, 
    0.08285096f, 0.07773523f, 0.07046858f, -0.07955437f, -0.04611087f, -0.04681973f, 0.05912492f, 0.04351743f, 
    -0.06230074f, 0.10734843f, 0.01761698f, -0.06645271f, 0.01462098f, -0.05659164f, 0.01338541f, -0.19290702f, 
    0.17294569f, -0.00372316f, -0.04061779f, -0.07462585f, 0.06216595f, -0.01044371f, 0.10355976f, 0.05308872f, 
    -0.05477590f, 0.04545943f, 0.00527670f, 0.02150417f, -0.03743302f, 0.03196654f, 0.12632206f, -0.02685259f, 
    -0.10300671f, 0.19190925f, -0.04125531f, -0.13852474f, 0.11222225f, -0.08293384f, 0.03018219f, -0.02622698f, 
    0.05498789f, 0.00355583f, -0.01097882f, -0.02252361f, 0.02744438f, 0.12414785f, 0.05002850f, -0.03022499f, 
    -0.01875210f, 0.10910777f, -0.05640978f, -0.01913518f, -0.13905901f, -0.06531929f, 0.06826949f, 0.00399721f, 
    -0.01605208f, 0.08243088f, 0.10696066f, -0.00506865f, 0.02543703f, -0.06981046f, 0.09368583f, 0.09106394f, 
    -0.04464726f, -0.02632139f, 0.07289746f, 0.05184906f, -0.04223360f, 0.04617148f, 0.03725817f, -0.02063969f, 
    -0.14911367f, -0.16121073f, -0.07858776f, -0.10622171f, -0.06206820f, -0.08907400f, -0.09412996f, 0.05706640f, 
    0.11431245f, 0.04584856f, -0.04068541f, -0.01122382f, -0.05835649f, -0.03866775f, -0.08032704f, 0.01900847f, 
    -0.02724377f, 0.02296344f, -0.03211671f, 0.06221331f, 0.26865080f, -0.12425120f, 0.19159681f, 0.06497692f, 
    0.19857761f, 0.13922784f, 0.05124160f, 0.02583751f, 0.10153734f, 0.03312191f, -0.00627828f, 0.07891628f, 
    0.06597072f, -0.02759541f, -0.10670643f, 0.05000621f, -0.00373454f, -0.06678940f, -0.01357670f, -0.10449003f, 
    -0.16944808f, -0.29019088f, 0.14414585f, 0.04447099f, 0.16165301f, 0.02090638f, -0.10575052f, 0.04390825f, 
    0.04356765f, 0.06902134f, -0.08045456f, 0.00055729f, -0.05308803f, 0.03394473f, 0.00899669f, 0.07374754f, 
    -0.04381651f, 0.08280952f, 0.01995061f, 0.15761901f, 0.05706474f, -0.29002979f, 0.27141890f, 0.00117012f, 
    0.20035483f, 0.10162747f, 0.09566252f, 0.08300901f, 0.03587500f, 0.16583754f, 0.00761553f, 0.03029685f, 
    0.00182212f, -0.00757405f, 0.01160200f, -0.06899328f, -0.08919524f, -0.12196303f, 0.01344914f, -0.12383255f, 
    -0.05621013f, -0.19172552f, 0.11625154f, 0.00487423f, 0.00697460f, 0.05306809f, 0.11812179f, -0.04201295f, 
    0.10854223f, -0.02870288f, -0.00022944f, -0.00270756f, -0.00307802f, 0.03779843f, -0.03331050f, 0.00568653f, 
    0.03803325f, -0.01929957f, 0.01557403f, 0.10301136f, 0.16997653f, 0.15991342f, -0.05694756f, 0.15758130f, 
    -0.14085612f, -0.01480587f, 0.04477395f, 0.02811692f, 0.08136927f, -0.02383299f, 0.02532292f, -0.01118502f, 
    0.05732648f, 0.06005028f, -0.00871820f, -0.04523802f, 0.03645332f, 0.05021387f, 0.03342817f, -0.00417658f, 
    0.14131370f, 0.18594278f, 0.01199663f, 0.24088369f, 0.27927053f, 0.17542486f, 0.04993478f, 0.01761492f, 
    -0.08460315f, -0.00775841f, -0.01917956f, -0.04263622f, 0.04539024f, 0.06451419f, -0.00244396f, 0.11187848f, 
    -0.04630868f, -0.03153027f, -0.05365930f, -0.01164542f, -0.30790395f, -0.17146386f, 0.07472159f, 0.00972657f, 
    -0.05689394f, -0.09982581f, 0.05134196f, 0.03023709f, 0.01360474f, 0.09477510f, 0.03340959f, -0.00818581f, 
    0.04208086f, -0.09005795f, 0.10553180f, -0.03998956f, 0.05140349f, 0.14009598f, 0.10519879f, 0.11143218f, 
    0.13243176f, -0.38238096f, 0.06144337f, -0.04729788f, 0.04805105f, -0.13353629f, -0.08996880f, 0.08175954f, 
    0.07896353f, 0.13875076f, 0.02855326f, -0.02711823f, -0.06131222f, 0.05628057f, -0.02826847f, 0.01708889f, 
    -0.00446772f, 0.01098101f, 0.08251444f, 0.07033689f, 0.22705741f, -0.08443865f, -0.05981506f, 0.13426542f, 
    0.00862866f, -0.18847670f, -0.00008269f, 0.03643605f, -0.03278209f, -0.01856815f, 0.05244505f, 0.01187348f, 
    -0.10556415f, -0.06192054f, 0.00344634f, 0.02395296f, -0.08187243f, 0.07228428f, -0.00886796f, 0.06108623f, 
    0.24610674f, -0.10341110f, -0.03549891f, 0.02056229f, -0.07663444f, 0.00674815f, -0.03301295f, 0.11228887f, 
    0.03597049f, 0.03580527f, -0.03639878f, -0.12012598f, 0.09245188f, -0.03852474f, -0.00332116f, 0.02907819f, 
    -0.02658989f, 0.09197137f, 0.06669060f, 0.02885697f, 0.03856226f, 0.12755162f, -0.05424548f, -0.01866599f, 
    -0.13564436f, 0.01704909f, -0.02185624f, -0.06642156f, 0.00520008f, 0.04797466f, 0.03785244f, 0.03772295f, 
    -0.06111455f, -0.06807724f, 0.07680125f, 0.03854460f, 0.00417144f, 0.10979116f, -0.00478900f, 0.01158908f, 
    -0.21940742f, -0.04423728f, -0.10505641f, 0.15129544f, 0.12877674f, -0.01434384f, 0.01078657f, 0.11458337f, 
    -0.09483127f, 0.09758884f, 0.04653675f, 0.00179740f, 0.10391156f, -0.03848258f, -0.15424226f, 0.03310933f, 
    -0.08028189f, 0.12116173f, 0.02126608f, 0.05928701f, 0.02355846f, 0.21562174f, -0.06273068f, 0.10091192f, 
    -0.11237949f, -0.01725153f, 0.08365999f, 0.02935074f, 0.15733461f, 0.06152339f, -0.01165074f, 0.00426094f, 
    -0.02088503f, -0.01961743f, -0.00256139f, 0.08198305f, 0.09797493f, 0.03162224f, 0.01104047f, -0.05638329f, 
    0.21701354f, 0.17107567f, -0.17092852f, 0.02969136f, -0.06931013f, 0.01455971f, -0.03759385f, -0.02585928f, 
    0.02161016f, 0.04532013f, 0.03751891f, 0.04603158f, 0.02630243f, -0.04232514f, 0.11906637f, 0.04297325f, 
    0.01172541f, -0.01057718f, -0.06138220f, -0.03798266f, 0.00089664f, -0.04622716f, 0.03629344f, -0.15230630f, 
    0.21967445f, 0.00378788f, -0.02877034f, 0.09462024f, 0.04471402f, -0.05022522f, 0.02007968f, 0.09743145f, 
    0.05349337f, 0.14154989f, 0.14573763f, 0.06968004f, 0.13587181f, 0.04325522f, -0.08892582f, 0.09137366f, 
    -0.43032604f, 0.12969251f, -0.15275641f, -0.06003431f, 0.05632607f, -0.01741465f, 0.08660541f, 0.10220739f, 
    -0.05841626f, 0.03865546f, 0.09307137f, 0.01107509f, 0.05909529f, 0.02357983f, 0.06804752f, -0.00598185f, 
    0.00664158f, 0.15127248f, 0.01872030f, 0.00428005f, 0.45917729f, 0.21430260f, 0.01439946f, -0.00539800f, 
    -0.17265980f, 0.02742764f, -0.02497489f, -0.14834681f, 0.01266516f, -0.08763280f, 0.06182951f, 0.07193878f, 
    -0.08854114f, -0.04384555f, 0.02655808f, 0.07607274f, -0.12449203f, -0.04066713f, 0.02505521f, -0.05201941f, 
    -0.02350050f, -0.28851759f, -0.05060618f, -0.12531599f, 0.03501468f, -0.15260713f, -0.08217428f, 0.11994912f, 
    0.01953575f, -0.00002200f, 0.07359963f, -0.01210950f, 0.00067235f, -0.01925250f, -0.02413019f, -0.07484321f, 
    -0.04016221f, 0.04313382f, -0.02686255f, -0.05324032f, -0.07349405f, -0.19749956f, 0.02029893f, -0.12165762f, 
    -0.03402563f, 0.00155793f, -0.15865375f, 0.07770793f, 0.09168829f, 0.00921671f, -0.09066535f, -0.07926215f, 
    0.00626702f, 0.08350214f, 0.02278012f, 0.10160643f, -0.07222304f, -0.05219633f, 0.00941756f, 0.06937668f, 
    0.14636412f, 0.15553366f, -0.19819365f, -0.14429075f, -0.00371734f, -0.03724039f, 0.00947394f, 0.02538536f, 
    0.08116397f, 0.05061229f, 0.03884985f, 0.00669970f, -0.02461469f, 0.03548730f, 0.03778546f, 0.07580721f, 
    0.04925884f, 0.13005710f, -0.14411429f, 0.08161181f, -0.04013675f, 0.12505044f, -0.06101418f, 0.04713225f, 
    -0.12229496f, -0.14561775f, 0.07023159f, -0.04762744f, -0.02195431f, -0.06252097f, -0.00723533f, 0.03334974f, 
    0.07905519f, -0.03832629f, 0.01457917f, -0.05363336f, -0.06701022f, -0.14326805f, 0.07001854f, 0.06209740f, 
    0.53330380f, 0.12686583f, -0.12158518f, -0.01232556f, -0.08990479f, -0.05357118f, -0.02897147f, 0.08515266f, 
    -0.00375630f, -0.00950768f, -0.01434027f, -0.02529895f, 0.07060144f, -0.07503764f, 0.00405493f, -0.01209526f, 
    0.04434905f, -0.00362132f, -0.04951372f, 0.03273414f, 0.01521409f, 0.22831677f, -0.07452024f, 0.06522658f, 
    0.13339132f, -0.01847890f, 0.01262669f, -0.11303648f, 0.02889031f, -0.07566002f, 0.01904874f, 0.02872042f, 
    0.09888420f, -0.05617019f, 0.02832472f, 0.01451766f, -0.04835491f, 0.03109204f, -0.12997767f, -0.12484004f, 
    -0.11228465f, 0.05337682f, 0.11113012f, 0.26013026f, -0.09843290f, -0.07186338f, 0.04734123f, 0.05597218f, 
    0.03460135f, 0.09273944f, -0.05221722f, -0.02647435f, -0.02547170f, 0.01333762f, 0.07027289f, 0.00925825f, 
    -0.00742566f, 0.01605051f, 0.11064679f, 0.02543344f, 0.32691768f, 0.12468483f, -0.08492642f, 0.16985737f, 
    -0.03404883f, 0.00133638f, -0.04470303f, 0.05773462f, 0.00087094f, -0.09707885f, -0.01721422f, -0.06871614f, 
    0.05292155f, 0.03602869f, -0.05494989f, -0.08484586f, -0.03460367f, -0.13074720f, 0.01009265f, -0.05742913f, 
    0.20278707f, 0.15382098f, -0.13618104f, -0.01663372f, 0.10418187f, 0.01035066f, 0.16727006f, 0.00138378f, 
    0.07187037f, -0.06999930f, -0.03020949f, 0.08481298f, 0.05240516f, 0.04020776f, 0.13590945f, 0.01245805f, 
    0.01110387f, 0.06637996f, -0.18901300f, -0.08669049f, 0.20036840f, -0.02784230f, 0.04152123f, -0.07516886f, 
    -0.08396584f, -0.03117098f, -0.01535930f, -0.00217406f, 0.05134225f, 0.00748848f, 0.02508375f, -0.08276208f, 
    -0.08944157f, -0.03118671f, -0.06004370f, -0.06192065f, -0.04303110f, -0.00131040f, -0.05464769f, -0.06730303f, 
    0.09419543f, -0.30610716f, 0.11346602f, -0.09154557f, 0.42302340f, 0.19626069f, -0.02521451f, 0.05037075f, 
    -0.00407205f, -0.05177104f, -0.04504762f, -0.07806520f, 0.08614877f, 0.05163563f, -0.08981902f, 0.03288994f, 
    -0.06361118f, -0.00128543f, -0.00750124f, -0.05884506f, 0.21116830f, -0.19849274f, 0.07424671f, 0.08489095f, 
    -0.06342205f, -0.00803358f, 0.11083393f, -0.00607025f, -0.02311220f, 0.01435128f, 0.05429519f, 0.07659306f, 
    0.03046226f, 0.01755792f, -0.05230351f, -0.10259998f, 0.04509737f, -0.08746663f, 0.01945130f, 0.06184995f, 
    0.13051181f, 0.00418171f, -0.00813865f, 0.04892803f, -0.20031776f, -0.01522698f, 0.06714448f, 0.15798913f, 
    -0.01174306f, 0.02525966f, 0.09596309f, 0.07519517f, -0.05015249f, 0.03808363f, -0.04182026f, 0.06857152f, 
    0.05889028f, 0.10570943f, -0.01373336f, 0.05480043f, -0.09826422f, 0.11423797f, -0.09477644f, 0.01560638f, 
    -0.01348995f, -0.04487495f, 0.00041912f, -0.04411878f, 0.09972153f, -0.08544758f, -0.03907156f, 0.08931509f, 
    0.06046801f, -0.09422474f, 0.05170552f, 0.05897054f, -0.15681840f, 0.07463171f, -0.05232923f, 0.06847958f, 
    -0.05905518f, 0.08847523f, 0.20719017f, 0.05012923f, -0.09807705f, -0.08773786f, 0.01179147f, 0.05049337f, 
    -0.04609451f, 0.03038032f, -0.01114617f, -0.07950905f, -0.01225402f, 0.13080639f, 0.02903777f, -0.00694764f, 
    0.02908224f, -0.12621328f, -0.04507069f, -0.07335562f, 0.08792791f, -0.15157798f, -0.18384892f, 0.07885481f, 
    0.11919910f, 0.06098815f, -0.09883140f, -0.06080632f, 0.00740168f, 0.06389087f, -0.05199979f, -0.02226561f, 
    0.01174073f, 0.12361667f, 0.06072587f, -0.06054477f, 0.02756871f, -0.00598809f, -0.00895598f, 0.06150920f, 
    -0.05684111f, 0.07284048f, -0.02550872f, -0.06939723f, -0.08395831f, -0.13491176f, 0.05870893f, 0.02379104f, 
    -0.07089218f, 0.15821208f, 0.04637031f, -0.01481708f, 0.03279722f, -0.05004805f, -0.10503595f, -0.08847529f, 
    -0.01716907f, -0.08700164f, 0.06164916f, -0.10838950f, 0.18116184f, 0.15806329f, -0.22170302f, 0.02481327f, 
    0.13760552f, -0.01748504f, -0.02437626f, -0.00077635f, -0.04170729f, -0.02796485f, -0.05667999f, -0.03681612f, 
    0.02495068f, 0.00015567f, 0.02247062f, 0.14903380f, 0.11105570f, -0.03112375f, -0.02217310f, 0.10393441f, 
    0.07028476f, -0.11468095f, 0.00080257f, -0.07187333f, -0.10213494f, -0.03050556f, -0.01045994f, 0.06154858f, 
    -0.12671550f, 0.07627272f, -0.03812058f, -0.09350470f, -0.00863533f, -0.03095292f, 0.01252636f, -0.01501071f, 
    -0.03335408f, -0.01956475f, -0.07313908f, -0.05798821f, 0.16638127f, 0.18797411f, 0.01225669f, 0.06618941f, 
    0.22258821f, 0.05940586f, 0.08795866f, -0.03798555f, -0.04414631f, 0.01007688f, 0.02287326f, 0.00570143f, 
    -0.04410367f, 0.11943106f, 0.04768926f, 0.11087141f, -0.02840905f, 0.01045009f, 0.00205075f, 0.13510156f, 
    0.05557650f, -0.00569905f, -0.05582081f, -0.00086976f, 0.11980721f, -0.03800038f, 0.03817567f, 0.03549962f, 
    0.08608308f, 0.02048902f, -0.01334874f, 0.03772892f, -0.00737908f, -0.05904497f, 0.02650398f, -0.02168905f, 
    0.10070358f, 0.05379298f, 0.07537629f, -0.01160121f, 0.15955848f, 0.03228743f, -0.08179085f, 0.02129740f, 
    0.05133783f, -0.01944938f, -0.02891726f, -0.05597556f, 0.08359938f, 0.07569359f, 0.02069700f, 0.05731066f, 
    -0.08013315f, -0.05208170f, -0.00721916f, 0.02637707f, 0.06490649f, -0.03312381f, -0.08140744f, 0.02676297f, 
    -0.19468586f, -0.10645855f, 0.06566352f, 0.06514571f, -0.18624772f, 0.01093854f, 0.02364087f, -0.10206231f, 
    -0.09343499f, 0.00231357f, 0.10969510f, 0.00159106f, -0.03894484f, -0.03813370f, -0.04915654f, -0.06039711f, 
    0.04876231f, -0.02939986f, -0.03313749f, 0.01183727f, 0.07564929f, -0.05956440f, -0.00894752f, -0.15650614f, 
    0.16887867f, 0.13943271f, 0.03363952f, 0.03810414f, 0.06818592f, -0.02115354f, -0.09010436f, -0.00260855f, 
    0.05296033f, -0.09692181f, -0.05106528f, -0.02071834f, 0.17035027f, 0.05664830f, -0.08675506f, -0.03349726f, 
    -0.08618210f, 0.29101044f, 0.03395992f, 0.03047708f, 0.19838166f, 0.12748435f, 0.04022742f, 0.00820275f, 
    0.04107185f, 0.08511440f, -0.04587749f, 0.12243693f, 0.08196247f, 0.03166457f, -0.02219342f, -0.11922255f, 
    -0.01880970f, 0.01694014f, 0.02540936f, -0.10999909f, -0.12298121f, -0.04731308f, -0.02926099f, 0.03087101f, 
    0.12662993f, -0.00866410f, 0.07105824f, 0.18792798f, 0.00366612f, -0.02472016f, -0.00484180f, 0.05445738f, 
    0.02637613f, 0.00313827f, -0.00839740f, -0.07876769f, 0.04978466f, 0.01769758f, -0.00646793f, -0.09288061f, 
    0.08317188f, 0.09886597f, -0.07098182f, 0.09938488f, -0.07023390f, -0.06605440f, 0.12209991f, -0.02658073f, 
    0.01670368f, 0.09110443f, 0.00322612f, -0.00137296f, 0.10919655f, -0.01300623f, 0.11258150f, 0.09006272f, 
    0.00490663f, 0.01001856f, -0.06470630f, 0.04668340f, 0.07016253f, 0.15803535f, -0.00269329f, -0.06732181f, 
    0.21439534f, 0.09996106f, 0.04200117f, -0.00300312f, -0.00239846f, 0.03303818f, 0.02642304f, 0.05084591f, 
    0.04410633f, 0.09352490f, 0.05385879f, -0.08412652f, -0.02755848f, 0.04872903f, 0.05129634f, 0.01519767f, 
    -0.37354943f, -0.12980288f, 0.00451012f, 0.06004208f, 0.04661569f, 0.06163245f, 0.00688033f, 0.14643039f, 
    0.09632566f, 0.06135085f, -0.02350231f, -0.00677281f, 0.07797092f, -0.05673916f, -0.04041460f, -0.02206589f, 
    0.00390899f, 0.01387424f, -0.08514787f, 0.04555858f, -0.28034937f, 0.02201770f, -0.03643896f, 0.21994963f, 
    -0.20752510f, -0.04670554f, 0.02368097f, -0.07864065f, 0.01171715f, 0.05358027f, 0.05856841f, -0.01293931f, 
    -0.11341326f, 0.06717766f, -0.05449974f, -0.01365556f, -0.07638028f, -0.07466324f, -0.05190599f, -0.00506233f, 
    0.12908782f, 0.08564499f, -0.12996091f, -0.00568434f, -0.15323168f, -0.08753499f, 0.02579197f, -0.00478637f, 
    0.04966804f, 0.09779168f, -0.05382817f, 0.09150257f, -0.13683416f, -0.03535077f, 0.03595285f, -0.00077314f, 
    -0.03479937f, -0.02270027f, -0.02994170f, -0.04860366f, -0.35878667f, -0.07166503f, -0.09241561f, 0.06980478f, 
    0.04149548f, -0.05038107f, -0.00556910f, 0.07685512f, 0.01657514f, -0.00900027f, -0.03206830f, 0.00527920f, 
    0.04871312f, -0.07399861f, -0.03029365f, -0.09262312f, 0.01441362f, 0.04250693f, -0.02136589f, 0.00443959f, 
    -0.24761510f, 0.04497392f, -0.01249987f, 0.09049465f, -0.35143447f, 0.06868732f, -0.05045335f, -0.06364872f, 
    -0.03575915f, 0.07813483f, -0.00740392f, -0.05211593f, 0.03336857f, 0.02347897f, -0.00515147f, -0.03278683f, 
    0.12959921f, -0.03418322f, -0.00337976f, 0.03270905f, 0.00596174f, 0.12439082f, -0.01951011f, 0.04764441f, 
    0.09720923f, -0.00973048f, 0.02682476f, 0.00855184f, -0.03547784f, 0.01226418f, 0.00171517f, 0.04815482f, 
    0.09309146f, 0.07574396f, -0.01319464f, 0.03248306f, 0.03149731f, 0.01907692f, -0.07477809f, -0.03106589f, 
    0.02085257f, -0.15597035f, 0.15092847f, 0.13276118f, -0.08180436f, 0.03527943f, -0.05996697f, 0.04196900f, 
    0.05200589f, 0.06952430f, -0.00687335f, -0.02669722f, 0.03580053f, 0.06657806f, -0.01493290f, 0.07731764f, 
    -0.01832327f, -0.04927930f, -0.04609306f, 0.02343789f, 0.04298748f, 0.09742591f, 0.01190986f, 0.04913805f, 
    0.23928091f, 0.16177037f, -0.02740467f, 0.03657100f, 0.03042434f, 0.08478902f, 0.02035112f, 0.03755310f, 
    -0.14980280f, -0.02000582f, -0.01228736f, -0.01626402f, 0.08226772f, -0.00939044f, 0.12811942f, -0.00935413f, 
    -0.02885645f, 0.06897173f, 0.08507468f, -0.00008286f, 0.11039318f, 0.10371929f, 0.08190592f, -0.07638631f, 
    0.08235116f, -0.02293571f, -0.04124286f, 0.05564035f, 0.00966976f, 0.06561840f, -0.00644112f, 0.04874928f, 
    0.02055947f, -0.03610951f, 0.10786952f, 0.03871867f, -0.50300050f, -0.06260309f, -0.01965894f, 0.10192755f, 
    0.00571746f, 0.00036197f, 0.07871047f, 0.01909005f, 0.03639525f, 0.07122249f, -0.06166657f, 0.07038187f, 
    0.09369256f, 0.01522934f, 0.00279521f, 0.09831163f, 0.09568002f, 0.03694640f, 0.04502538f, 0.10203306f, 
    0.00703762f, 0.09919962f, -0.12051191f, 0.10546146f, 0.38026810f, 0.00151105f, -0.04224651f, -0.07334381f, 
    -0.00982205f, 0.08519600f, 0.04807985f, -0.10862342f, 0.01288683f, 0.11294996f, -0.04868956f, 0.09312823f, 
    -0.10526800f, -0.06692647f, 0.13834485f, 0.06756414f, 0.09090634f, 0.13627926f, 0.13683474f, 0.05507363f, 
    0.25265649f, -0.01877233f, 0.06523184f, 0.01426471f, 0.05001868f, 0.06221484f, 0.04435458f, 0.04637431f, 
    0.05634918f, -0.02017759f, 0.02614284f, -0.00157493f, 0.08673090f, 0.02434655f, 0.14021745f, 0.13787292f, 
    -0.22199790f, -0.08054257f, 0.11884587f, 0.11121649f, 0.15727267f, 0.14499521f, 0.00811354f, 0.03240311f, 
    0.06545616f, 0.17356318f, -0.02857352f, -0.00595534f, 0.03991989f, -0.01708771f, -0.01426172f, 0.03528171f, 
    0.05814550f, -0.07360619f, 0.11365204f, 0.11451659f, -0.11861672f, -0.20442390f, 0.10773327f, -0.01547401f, 
    0.09835912f, 0.00669141f, 0.03724991f, 0.08099122f, 0.02583419f, 0.05044283f, -0.03201985f, 0.01228203f, 
    -0.03501320f, -0.09094071f, 0.00608195f, -0.04120792f, -0.00015715f, 0.02004075f, -0.08937287f, -0.12295726f, 
    0.16051765f, 0.12512806f, -0.09351898f, 0.09393556f, -0.01062190f, -0.06888665f, 0.02438276f, 0.03287242f, 
    0.13741493f, 0.08342714f, 0.04031503f, -0.00909209f, 0.02576705f, -0.10546131f, 0.00638848f, -0.03873042f, 
    0.04177494f, 0.03151973f, 0.00088990f, 0.01096278f, -0.04580307f, -0.16148992f, 0.08675390f, -0.10089006f, 
    0.16965915f, 0.04829127f, -0.04687320f, -0.00214130f, -0.00391342f, 0.05322311f, -0.03461327f, 0.01998927f, 
    0.02529017f, 0.03449216f, 0.04801586f, 0.00509872f, -0.08719103f, -0.02647493f, 0.07813379f, -0.00915968f, 
    -0.02315034f, -0.00879388f, -0.00159792f, 0.00680041f, 0.00440663f, -0.00051520f, 0.00946307f, -0.04312096f, 
    0.00306930f, 0.00650079f, 0.02286202f, 0.01105371f, -0.00302019f, 0.00352180f, -0.01667819f, -0.03530646f, 
    -0.00397659f, -0.01350971f, 0.00998247f, -0.01126275f, -0.04081808f, -0.01956888f, 0.00931748f, 0.01276744f, 
    -0.01167275f, 0.00738019f, -0.04175756f, -0.02405733f, 0.00278532f, 0.01281439f, 0.01679656f, -0.03395662f, 
    -0.01872608f, 0.00421263f, -0.02926681f, -0.00506099f, -0.00534582f, 0.03408313f, 0.03063845f, -0.00936528f, 
    -0.01652851f, -0.02370489f, -0.00828915f, 0.01872168f, -0.00856285f, -0.00245095f, 0.01973825f, -0.02032780f, 
    -0.02644588f, -0.03435661f, 0.00960216f, 0.02948792f, -0.03768751f, 0.03192794f, 0.00718189f, -0.00770542f, 
    0.02926609f, 0.01732484f, -0.00497883f, 0.02508742f, 0.00367272f, -0.02916893f, -0.01967135f, 0.01717392f, 
    -0.02425755f, -0.02737695f, 0.02676240f, 0.00782562f, 0.02677279f, 0.02416187f, 0.02952718f, -0.04032607f, 
    0.00038478f, -0.02907798f, -0.02940308f, -0.00528487f, 0.00487668f, 0.02043634f, -0.03898625f, -0.00771232f, 
    0.01211775f, 0.02994395f, -0.00856764f, 0.03142773f, -0.00647157f, -0.02462667f, -0.01686192f, 0.03340665f, 
    0.03363096f, -0.03444466f, -0.03253691f, -0.02686400f, -0.00301519f, 0.03343783f, 0.00429075f, -0.03319949f, 
    -0.01136258f, -0.02938180f, -0.03704569f, -0.00325165f, 0.02096893f, -0.03247321f, -0.02927117f, 0.03216383f, 
    -0.04309399f, 0.00949174f, 0.02816104f, 0.02439937f, -0.03012389f, -0.00856790f, -0.00269023f, 0.01768025f, 
    -0.00039734f, -0.01334544f, -0.03940656f, 0.01356860f, 0.03333594f, 0.01696903f, -0.00379669f, -0.02938662f, 
    0.01264906f, -0.03746865f, 0.00613289f, -0.00700378f, -0.03805646f, 0.00304707f, 0.00489701f, -0.01198539f, 
    -0.01555627f, 0.00152616f, 0.00000278f, -0.01901923f, -0.01264016f, 0.00162199f, -0.01873648f, -0.00973642f, 
    0.01838870f, 0.00090885f, -0.02840919f, -0.02730141f, 0.00827825f, 0.00262191f, -0.03819474f, -0.03094313f, 
    -0.03650330f, -0.02048999f, -0.01784037f, -0.01564208f, -0.02613157f, 0.02801120f, -0.03072631f, -0.00970265f, 
    -0.01183775f, 0.03180275f, 0.00707559f, -0.02080771f, -0.00438906f, -0.00341863f, -0.01090364f, -0.01840861f, 
    -0.03779513f, 0.00827858f, 0.02996707f, 0.02973626f, -0.01159869f, -0.00424448f, -0.02956310f, -0.01923869f, 
    -0.01340190f, -0.03887955f, -0.04193388f, -0.03104091f, -0.01753199f, 0.01419497f, -0.02318465f, -0.01538463f, 
    0.02709575f, 0.00556254f, -0.02934034f, -0.03184243f, -0.01690441f, -0.01377589f, 0.02347018f, 0.02103997f, 
    0.02779898f, -0.02678351f, -0.01276031f, -0.03354531f, -0.02789418f, 0.01260462f, -0.00499558f, 0.03128570f, 
    -0.02947135f, -0.03473688f, 0.02858321f, 0.00790603f, -0.00323313f, 0.02062120f, 0.00788891f, 0.01633686f, 
    -0.04269641f, 0.01721214f, 0.02700304f, -0.03372546f, -0.04152933f, -0.02586726f, -0.01629483f, 0.02209304f, 
    0.00862132f, 0.01295338f, 0.02178786f, -0.03725645f, 0.03149857f, 0.00916139f, 0.02314777f, -0.03534827f, 
    -0.01470479f, -0.00403130f, 0.00938389f, -0.03899986f, 0.00903980f, 0.03063488f, 0.02539621f, -0.02811595f, 
    0.01979561f, -0.00551803f, -0.03607475f, 0.00261045f, -0.00047916f, -0.01155318f, -0.03240477f, 0.01224892f, 
    0.00441796f, -0.03169852f, -0.00560285f, -0.00515060f, 0.00283442f, -0.02637231f, -0.02168651f, 0.02905374f, 
    -0.02313372f, 0.03067889f, -0.02355968f, -0.04264153f, 0.00788091f, 0.02354613f, -0.00754124f, -0.02379640f, 
    -0.01041479f, -0.02251542f, -0.01760222f, -0.01541934f, -0.00321837f, 0.00487328f, 0.00865782f, -0.01932953f, 
    -0.01098065f, 0.02787998f, 0.02214469f, -0.01916185f, 0.01326218f, -0.00412256f, 0.02791616f, -0.03150875f, 
    -0.03374300f, -0.03128686f, 0.01906883f, 0.03134647f, 0.01216502f, -0.01045251f, -0.03596241f, -0.01647935f, 
    0.01020435f, 0.02667961f, -0.03451275f, -0.00850745f, -0.04011480f, -0.01658184f, -0.04470209f, -0.00251398f, 
    -0.00372131f, 0.01176172f, -0.00253526f, -0.00262908f, -0.03593761f, -0.00211515f, -0.02085477f, -0.00332664f, 
    -0.01633375f, -0.03162686f, 0.00304620f, 0.00626415f, -0.01158723f, -0.00997581f, -0.03056413f, -0.02691527f, 
    0.02623873f, 0.00037748f, 0.00188402f, 0.02736812f, 0.03137195f, -0.02531157f, -0.01663603f, -0.00707328f, 
    0.02153420f, 0.02939677f, -0.00311114f, -0.03211700f, 0.01469047f, -0.00794111f, -0.00311952f, -0.04324956f, 
    -0.00247422f, 0.01303803f, -0.04191065f, 0.01043911f, -0.00864905f, 0.02467798f, 0.01444245f, 0.03160996f, 
    0.00590268f, -0.00618256f, -0.00976402f, 0.01680059f, 0.00137632f, 0.00763179f, -0.00386392f, -0.03729822f, 
    0.01573004f, 0.03071827f, -0.04384330f, -0.00141961f, -0.00791456f, 0.00497060f, -0.03575602f, 0.00684873f, 
    -0.00645446f, -0.02319779f, -0.02025864f, 0.03238194f, 0.02491139f, -0.00358201f, 0.02390322f, 0.00149677f, 
    -0.01839011f, -0.03167840f, 0.01451990f, -0.01901792f, -0.04452135f, -0.03156533f, 0.00952530f, 0.00688615f, 
    -0.03437416f, -0.00225130f, -0.01025071f, -0.02360798f, -0.01202871f, -0.03050278f, 0.00100904f, -0.04439694f, 
    -0.02408082f, -0.02100937f, -0.03109363f, -0.02398498f, -0.00477145f, -0.04279882f, 0.02079700f, -0.00669677f, 
    0.01985567f, 0.02492310f, 0.02345281f, 0.00713352f, -0.01306626f, 0.00319815f, 0.01874861f, 0.01912280f, 
    0.01053375f, -0.04421374f, -0.02521571f, -0.03039723f, 0.02472217f, 0.00888223f, 0.03285785f, 0.02451282f, 
    0.02182957f, -0.02860726f, 0.02113158f, 0.01960932f, -0.03497165f, -0.02540092f, 0.03107505f, 0.02974504f, 
    -0.02757100f, -0.02847350f, -0.01793054f, -0.02740207f, 0.02037143f, -0.00966809f, 0.01952178f, -0.01445729f, 
    -0.01988619f, -0.01803686f, 0.00379020f, -0.04150316f, 0.02376512f, -0.03623713f, 0.02840595f, -0.04307868f, 
    0.01123453f, -0.03484080f, -0.00376634f, -0.00455060f, 0.03309120f, -0.02334408f, 0.02171457f, -0.02803220f, 
    0.02057718f, -0.04054198f, 0.02670455f, -0.00056237f, 0.02864267f, -0.03473951f, 0.02317701f, -0.03515277f, 
    -0.03926757f, -0.04448864f, -0.03689811f, -0.01856110f, -0.00524822f, -0.01875163f, -0.00202267f, -0.04217060f, 
    -0.02401772f, -0.03902526f, -0.04100383f, -0.02193241f, -0.02300425f, -0.01287724f, -0.03919228f, -0.02846420f, 
    -0.01454588f, 0.02618479f, -0.01229410f, 0.02024482f, 0.01728730f, 0.00716947f, -0.00958274f, -0.00041224f, 
    -0.00676234f, -0.00898824f, -0.03591708f, -0.03778735f, -0.02971974f, -0.00810600f, -0.02977316f, -0.02580481f, 
    -0.04319768f, 0.01285035f, -0.04166733f, -0.03607870f, 0.00068847f, 0.00211101f, -0.00712640f, -0.00944439f, 
    -0.02912497f, 0.01919917f, 0.03341177f, 0.01424942f, -0.02845530f, -0.04202281f, 0.00869407f, 0.02060521f, 
    -0.01782909f, -0.02753292f, -0.04144382f, 0.00972065f, -0.03824709f, -0.01694334f, -0.03865494f, -0.03236433f, 
    0.02113093f, 0.02440180f, -0.01246712f, -0.02761599f, -0.02306238f, -0.00409796f, -0.01217665f, -0.01545896f, 
    -0.02704604f, -0.01758028f, 0.00593349f, 0.02496086f, -0.01497454f, -0.01400522f, -0.03864476f, -0.03405895f, 
    -0.01412702f, 0.00338941f, -0.00914484f, 0.01483994f, -0.03741571f, -0.00602993f, -0.04048421f, 0.01896669f, 
    -0.00140878f, 0.03107884f, 0.00809997f, -0.01712081f, -0.01278138f, -0.04392025f, 0.00826543f, 0.00068564f, 
    0.02676227f, 0.01750498f, -0.00579613f, -0.01119029f, -0.02976914f, -0.04307421f, 0.02945127f, 0.01321431f, 
    -0.03861516f, 0.02585900f, 0.00834710f, -0.03343670f, -0.04067369f, 0.02517574f, -0.03472554f, -0.01160417f, 
    -0.04361720f, -0.04260873f, -0.03452542f, 0.00466407f, -0.02942421f, -0.03691621f, 0.01217439f, 0.01379601f, 
    -0.03654064f, -0.00041792f, -0.02719708f, -0.02034018f, 0.02369484f, 0.00337856f, -0.00650032f, -0.04267606f, 
    0.01988440f, 0.03266275f, -0.02606974f, 0.01126642f, -0.02792565f, 0.03044125f, 0.01861833f, -0.04133742f, 
    0.01214292f, -0.02343233f, -0.00536581f, 0.01379010f, -0.04101694f, 0.01741875f, 0.02818362f, 0.03208015f, 
    -0.03767556f, -0.02667002f, 0.00056494f, -0.03632466f, 0.00173599f, 0.00363676f, -0.00116281f, -0.02498854f, 
    -0.01702459f, -0.00900439f, 0.00014664f, 0.02799611f, 0.02398185f, -0.01258984f, -0.01209287f, 0.02619977f, 
    -0.01021781f, -0.03955908f, -0.02585723f, -0.03581635f, -0.01453288f, 0.00164150f, 0.01830025f, -0.02921835f, 
    -0.03129066f, -0.00795016f, -0.03113310f, 0.00183148f, -0.04278841f, -0.01990601f, 0.02298092f, 0.02942951f, 
    -0.00332335f, -0.00875547f, 0.02621715f, -0.02267215f, 0.03315002f, 0.02088876f, 0.01958445f, 0.02545877f, 
    0.00621211f, 0.01762415f, -0.00054278f, 0.00903239f, -0.01117305f, 0.01553190f, -0.02485489f, -0.02093323f, 
    0.00277496f, -0.01008901f, -0.01895717f, -0.00546474f, -0.03689785f, -0.02189608f, 0.02607935f, 0.03309085f, 
    0.02240412f, -0.03553937f, -0.03728282f, -0.02324066f, -0.00917094f, -0.02691058f, -0.03929825f, -0.04040308f, 
    -0.00937471f, -0.04111858f, -0.03969726f, -0.02785009f, -0.00891728f, -0.01831717f, 0.02360344f, -0.00182323f, 
    0.02238581f, 0.00713416f, 0.00939822f, 0.01399504f, -0.03190303f, 0.02248309f, 0.02699082f, 0.01844416f, 
    -0.03267487f, -0.00587028f, -0.04292155f, 0.01683792f, -0.01177671f, 0.01665835f, -0.01517790f, -0.01023029f, 
    -0.01196626f, -0.01322915f, -0.03177220f, -0.00855459f, -0.03085707f, 0.03258396f, 0.01886131f, 0.01275012f, 
    0.00655463f, 0.03369136f, -0.02637725f, -0.04248717f, 0.01839375f, -0.02584829f, 0.02349563f, 0.01660188f, 
    -0.03391513f, 0.01968878f, 0.01613555f, 0.00998905f, 0.00175205f, 0.01110234f, 0.00699605f, 0.00588399f, 
    0.03140635f, 0.00791931f, -0.02521510f, -0.00372108f, 0.00021604f, -0.01865876f, -0.00376062f, -0.03782496f, 
    -0.00661616f, 0.00738509f, 0.00696388f, -0.01730589f, -0.01589083f, -0.04404070f, 0.02880721f, -0.02763756f, 
    -0.00267150f, 0.02489788f, -0.02345293f, 0.03604875f, -0.03530084f, 0.02863876f, -0.02187571f, -0.03912982f, 
    0.01802482f, -0.00017600f, -0.00260926f, -0.03204793f, 0.01942298f, -0.01216543f, 0.02998883f, 0.00733501f, 
    0.00037581f, 0.02795213f, 0.02500866f, -0.00746635f, 0.01335953f, 0.03298287f, 0.01245573f, -0.03096295f, 
    0.00037050f, -0.01392706f, 0.01308779f, -0.01745654f, -0.02007365f, -0.01726426f, -0.00975368f, 0.02706680f, 
    -0.01160564f, 0.00972980f, 0.01287203f, -0.03140052f, -0.02215720f, 0.00735601f, 0.02103074f, -0.01664476f, 
    0.02221586f, -0.01528303f, -0.04099066f, -0.02047809f, -0.01631275f, -0.02691482f, -0.01499852f, -0.00636009f, 
    -0.03001095f, 0.01302659f, 0.01159409f, 0.01786686f, -0.04133556f, -0.00320513f, -0.01294281f, -0.01583273f, 
    0.01369968f, -0.00996853f, 0.00145521f, -0.00015258f, 0.02892631f, 0.02575815f, -0.00275182f, -0.01340394f, 
    -0.02035608f, 0.00033545f, -0.02154120f, 0.02365037f, -0.02645626f, -0.02153904f, -0.04199486f, 0.02806099f, 
    -0.00693475f, 0.02237702f, -0.03357585f, -0.02334373f, -0.00943383f, 0.00573335f, -0.02372892f, -0.00251162f, 
    -0.01734998f, -0.02264781f, 0.02050062f, -0.04217182f, 0.01743227f, -0.00242865f, -0.03161713f, -0.01620082f, 
    0.02711371f, -0.00111849f, -0.00717787f, -0.00667514f, 0.02707005f, 0.02220435f, -0.00255634f, -0.00031265f, 
    -0.00799660f, 0.01993066f, 0.02695478f, 0.00072568f, 0.03026010f, 0.00876886f, -0.02821626f, -0.00268983f, 
    -0.03713215f, 0.02857650f, -0.01207751f, -0.00513781f, -0.03113837f, -0.00736319f, 0.01713089f, 0.01977408f, 
    -0.01601763f, 0.02654525f, -0.02808480f, -0.02620148f, -0.03968015f, 0.00237976f, 0.02800474f, 0.02143797f, 
    -0.02309663f, -0.03050777f, -0.00782589f, -0.02108438f, -0.03354593f, 0.02202063f, 0.01111845f, 0.01894194f, 
    -0.00677622f, 0.01621458f, -0.02075290f, -0.00342004f, 0.00354027f, -0.01525429f, 0.01901121f, -0.03510723f, 
    -0.00180278f, -0.01983662f, -0.01725129f, 0.01351693f, 0.02080984f, 0.01365066f, -0.01915576f, 0.01138707f, 
    -0.02155299f, 0.03355704f, 0.00124530f, -0.03237288f, -0.02356008f, -0.01039028f, -0.04127075f, -0.03074220f, 
    0.02612733f, -0.01617432f, 0.02110016f, -0.03307483f, 0.01757499f, 0.00300453f, -0.03853215f, -0.02595364f, 
    0.03911519f, -0.01036806f, 0.00520765f, 0.01691561f, -0.02709157f, 0.00643337f, -0.04421152f, 0.01858422f, 
    0.00251965f, -0.00260970f, -0.00446361f, -0.02063032f, 0.00755621f, 0.00474704f, -0.01817836f, 0.01193872f, 
    -0.01360516f, 0.00392422f, -0.00969963f, -0.01828355f, -0.01875233f, 0.00739461f, -0.02644966f, 0.01994417f, 
    0.01875933f, 0.01111805f, 0.00790985f, -0.01438942f, 0.02063514f, 0.00999769f, -0.02990810f, 0.02435038f, 
    -0.01791929f, -0.00591281f, 0.00520928f, -0.00357441f, 0.01325681f, -0.00203271f, 0.02997597f, -0.03307221f, 
    -0.00366587f, 0.02205985f, -0.03893533f, 0.00508336f, -0.02789855f, -0.03142868f, 0.00904415f, -0.01667920f, 
    0.00256938f, 0.02489840f, -0.01941653f, -0.03663808f, -0.00579486f, 0.02042020f, -0.00100013f, -0.01398085f, 
    0.02950192f, -0.00139053f, 0.01006188f, -0.00199859f, -0.03573987f, -0.04028599f, -0.03668150f, -0.01488119f, 
    0.01037752f, -0.02280305f, 0.02477571f, -0.03778153f, -0.01352720f, -0.03855871f, -0.00812484f, -0.04305277f, 
    -0.04355310f, -0.00607025f, -0.02176405f, -0.00858089f, -0.00912423f, 0.02890399f, 0.01482218f, -0.02092282f, 
    0.01645846f, 0.00249297f, -0.01103431f, -0.00517135f, -0.04047141f, -0.02515334f, 0.01029644f, -0.00620393f, 
    -0.02988999f, -0.01380750f, -0.02471851f, 0.03324004f, 0.02484116f, -0.01777034f, -0.03448367f, -0.01203353f, 
    0.00715290f, 0.01259602f, 0.01777335f, -0.03512701f, 0.03092722f, -0.02604756f, -0.03288492f, 0.02369767f, 
    0.00841600f, -0.01010027f, 0.02177483f, 0.02486053f, 0.01156711f, -0.01522111f, 0.00435539f, -0.00528793f, 
    0.00521858f, -0.04407332f, 0.02850348f, 0.02226569f, -0.00797568f, -0.04070799f, 0.01593365f, -0.00212318f, 
    0.01442279f, -0.04317423f, 0.02628059f, -0.02110596f, -0.02006016f, -0.00246526f, 0.01496682f, -0.03638572f, 
    -0.01768468f, -0.04267791f, 0.01210906f, 0.00812151f, 0.02244109f, 0.01117053f, -0.03453156f, -0.03377451f, 
    -0.03085838f, -0.02358527f, -0.00008482f, 0.02590486f, 0.02364014f, -0.00909035f, -0.01181679f, 0.01026119f, 
    0.00910368f, 0.03193152f, 0.00662305f, 0.00550380f, -0.03150734f, -0.02913028f, 0.01741419f, 0.02007929f, 
    -0.03366978f, -0.03177350f, -0.02656702f, 0.00047494f, -0.01355598f, -0.02166690f, -0.00462639f, -0.01097452f, 
    -0.01801139f, 0.00813507f, -0.01147989f, -0.02367750f, -0.00541701f, -0.03932775f, -0.01253310f, -0.01796070f, 
    -0.03476258f, -0.02044461f, -0.02404726f, 0.02561089f, 0.00668637f, -0.02373484f, -0.03182955f, -0.03498811f, 
    -0.02622486f, -0.04486929f, -0.01580848f, -0.01289222f, 0.02862919f, 0.02231008f, -0.01627653f, -0.03053698f, 
    0.00077742f, 0.01413044f, -0.02699493f, 0.00938069f, -0.02396588f, 0.01298300f, -0.00619358f, 0.03276163f, 
    -0.02581447f, 0.01505107f, 0.00040821f, -0.03615615f, -0.00706371f, -0.01481242f, -0.02223015f, 0.01957070f, 
    -0.03946292f, -0.01436763f, -0.01073893f, -0.03592360f, -0.02429387f, -0.02637357f, -0.01732313f, 0.00002128f, 
    0.01956207f, -0.04483351f, -0.00858172f, 0.00591782f, -0.01901811f, -0.01947996f, -0.02434286f, 0.00430782f, 
    0.00472895f, -0.02721419f, 0.01415708f, -0.00823131f, -0.04382725f, -0.01340591f, -0.03606947f, 0.00571191f, 
    -0.03792828f, -0.01275638f, -0.00100482f, -0.02901826f, 0.02093115f, 0.02060840f, -0.01181453f, 0.03286475f, 
    -0.04465826f, -0.00375483f, -0.01996588f, 0.01785065f, -0.03373250f, -0.02654435f, -0.01996258f, -0.04189330f, 
    -0.01517070f, 0.00028746f, 0.02546474f, -0.03945462f, -0.02119142f, -0.02614490f, -0.03484831f, -0.03119018f, 
    -0.00006569f, 0.00254448f, 0.02331891f, 0.03023616f, 0.00133019f, 0.01887701f, -0.02188905f, -0.01012572f, 
    -0.02271103f, -0.03316164f, -0.01717337f, 0.00223382f, -0.04482758f, -0.03689301f, -0.01606372f, -0.04470306f, 
    0.02299966f, 0.00831309f, 0.00164219f, -0.02357575f, -0.00697859f, 0.02184727f, -0.00134239f, -0.01874812f, 
    -0.02502554f, -0.01260185f, 0.02901579f, -0.01945074f, 0.03103438f, -0.04081970f, 0.01532385f, 0.02836642f, 
    -0.00186363f, 0.00902828f, -0.02966629f, -0.02613606f, 0.01593251f, -0.02843143f, 0.02221817f, -0.01920057f, 
    -0.01005570f, 0.01535863f, 0.02372716f, 0.02757790f, 0.01577258f, -0.03447533f, 0.00457929f, -0.01854936f, 
    0.02602531f, 0.01642699f, 0.01727538f, 0.01559844f, 0.01147999f, 0.01700791f, 0.01862496f, 0.01282626f, 
    0.02351306f, -0.01824911f, 0.02946344f, -0.03958613f, 0.02162182f, -0.02335285f, 0.03336612f, -0.01247869f, 
    -0.00481425f, -0.02798637f, 0.01936045f, -0.02110515f, 0.00849320f, -0.02680443f, 0.00794398f, -0.03754862f, 
    0.02259700f, -0.00240600f, -0.00447004f, -0.03936489f, -0.00292531f, -0.01400011f, 0.00043280f, 0.02045878f, 
    0.02189384f, 0.01897071f, -0.04078793f, -0.02961002f, 0.01696702f, -0.01761439f, 0.00959334f, 0.02811196f, 
    0.01491796f, -0.03923741f, -0.00040902f, -0.04153205f, 0.00741738f, -0.01650766f, 0.02776562f, -0.04381874f, 
    -0.01689216f, 0.00411050f, 0.01307168f, -0.00953005f, 0.00082990f, -0.04453139f, -0.03580714f, 0.01300665f, 
    0.01324474f, 0.03146319f, 0.03307758f, -0.03359360f, 0.01444202f, -0.04504078f, -0.03754112f, 0.01674262f, 
    -0.02489326f, 0.00010535f, -0.02996546f, -0.02081083f, -0.02895034f, 0.00400714f, -0.02893953f, 0.02003247f, 
    0.03325410f, -0.03563812f, -0.03715374f, -0.00267118f, -0.01940540f, 0.00360043f, -0.01454985f, 0.00207406f, 
    0.02550902f, -0.01820785f, 0.00200730f, -0.01960249f, 0.01815542f, -0.03914660f, 0.00738840f, -0.00962345f, 
    -0.03947718f, -0.02796193f, 0.00779470f, 0.02139661f, -0.03382371f, 0.00488614f, -0.03618816f, 0.01934837f, 
    -0.00578685f, 0.01170320f, -0.01661130f, -0.01663853f, -0.02981814f, -0.02325655f, -0.00414734f, -0.00291648f, 
    -0.00237652f, -0.00076266f, 0.02697718f, -0.01109391f, -0.03902859f, 0.01001635f, -0.02807477f, 0.02647801f, 
    -0.02530033f, -0.03242020f, -0.02107100f, -0.03928634f, -0.00039994f, 0.02175267f, -0.02554110f, 0.01888916f, 
    0.00932168f, 0.00369913f, -0.02829975f, 0.00046238f, -0.04506202f, -0.00757237f, -0.03323602f, -0.00317173f, 
    -0.02540629f, 0.00397448f, 0.01999638f, 0.03178059f, -0.01761989f, 0.01351020f, 0.01821224f, 0.01112653f, 
    -0.00563772f, 0.01061230f, -0.00334108f, -0.03240716f, 0.03058118f, 0.00369208f, -0.01133940f, -0.02309901f, 
    -0.03632398f, -0.01949912f, 0.01546212f, 0.01195166f, 0.02263731f, -0.02627655f, 0.02108657f, -0.02649607f, 
    -0.02760980f, 0.02108842f, 0.02461231f, -0.04512866f, -0.01864919f, -0.04364828f, 0.01296220f, 0.00529283f, 
    0.03348864f, 0.01437647f, 0.01207767f, -0.03791503f, -0.02871394f, 0.02069484f, -0.01335746f, -0.02555671f, 
    -0.03289718f, 0.02760108f, -0.00907541f, 0.01088567f, 0.02795766f, 0.01232879f, -0.03860353f, -0.04036258f, 
    -0.03471889f, 0.00069041f, -0.03257004f, -0.03911736f, -0.01772733f, -0.00355693f, 0.02524660f, 0.02899415f, 
    -0.03551475f, -0.02756941f, -0.03410973f, -0.04362446f, -0.00219922f, -0.02029836f, -0.01179233f, 0.01618991f, 
    -0.00842336f, -0.00603571f, -0.01679304f, -0.03883955f, -0.03830265f, 0.00416592f, -0.00365877f, 0.03001622f, 
    -0.02775305f, -0.02501793f, 0.00550417f, -0.02779107f, -0.00255964f, 0.03087845f, -0.02345741f, -0.02965949f, 
    0.00464297f, -0.01157046f, 0.03168287f, -0.04449418f, 0.02152145f, 0.02145825f, 0.01588274f, -0.01703046f, 
    0.02770411f, -0.02981667f, 0.02043060f, -0.02574562f, -0.01450482f, -0.02517280f, 0.03146443f, 0.01141160f, 
    -0.03315620f, -0.02927746f, -0.00757220f, -0.00289373f, 0.01939674f, -0.02839736f, 0.00767190f, 0.00175934f, 
    -0.01567414f, 0.02710518f, 0.02157855f, -0.01311683f, 0.01662310f, -0.01526386f, 0.01661447f, -0.02728646f, 
    0.02558490f, 0.01055241f, 0.02621066f, -0.00959132f, 0.00897870f, 0.01719996f, -0.03686761f, 0.01674029f, 
    -0.03099433f, -0.02732481f, 0.02628098f, -0.03273432f, 0.01284602f, -0.01471402f, -0.02716233f, -0.00403624f, 
    -0.02786164f, 0.03108863f, -0.02405538f, 0.02641981f, -0.03997415f, -0.03015038f, -0.02528372f, -0.00574027f, 
    -0.02307856f, 0.00604471f, -0.03833646f, 0.03276571f, 0.00939372f, 0.01910179f, 0.02816140f, -0.02902114f, 
    0.01115680f, -0.02952973f, -0.02060683f, 0.01431800f, -0.02243372f, 0.02567309f, -0.03130515f, -0.03477093f, 
    0.02540641f, 0.03260987f, 0.01416391f, -0.01530883f, 0.00746936f, -0.00244650f, 0.03477223f, -0.04518007f, 
    -0.04402826f, -0.03121991f, -0.03009395f, -0.00219377f, 0.01527042f, 0.02479795f, 0.00189881f, -0.00262141f, 
    0.02753474f, -0.01295768f, -0.01755527f, -0.03679023f, -0.03492087f, -0.02664966f, 0.02170714f, -0.03647270f, 
    -0.00500985f, -0.02299109f, -0.03113147f, -0.02897725f, 0.00802089f, -0.04419259f, -0.00080252f, -0.01410847f, 
    -0.02736599f, -0.04419343f, -0.00643245f, 0.01684887f, -0.02433372f, 0.00890889f, 0.01048337f, 0.02177517f, 
    -0.00237826f, -0.00130993f, -0.04445760f, -0.04101640f, -0.04183836f, -0.01306302f, 0.01788890f, 0.02847222f, 
    0.01525046f, -0.02141434f, 0.03810684f, -0.00459029f, -0.02214057f, -0.00259128f, 0.02385548f, -0.01388691f, 
    0.00275365f, -0.00087778f, 0.01344709f, 0.02436359f, 0.02758713f, 0.03030279f, -0.00840117f, 0.01558251f, 
    0.01250348f, 0.02611202f, -0.04474719f, 0.03681976f, 0.01989040f, 0.02133163f, 0.00778478f, -0.03186593f, 
    0.00106730f, -0.02965564f, -0.02291110f, -0.03000275f, -0.01102009f, 0.01570428f, 0.02592957f, -0.00899910f, 
    -0.03591222f, -0.03374058f, -0.04146567f, 0.00741469f, -0.03964609f, 0.00236340f, -0.00864168f, 0.02414322f, 
    0.01766887f, -0.02652879f, 0.01249998f, -0.04131846f, 0.00354173f, -0.02501179f, -0.02862024f, 0.00030158f, 
    -0.01807790f, -0.00969133f, 0.00967762f, -0.00943012f, -0.00594033f, 0.00927525f, 0.00342202f, 0.01337711f, 
    -0.03984389f, -0.02918403f, -0.00920698f, -0.01005128f, 0.01174893f, 0.02848770f, 0.01980946f, 0.03073054f, 
    -0.00110792f, 0.03174325f, -0.03935716f, -0.00444432f, -0.02003137f, 0.01937253f, 0.02895451f, 0.00139334f, 
    -0.03885120f, -0.03999100f, -0.01540416f, 0.00114603f, -0.02327318f, 0.00302761f, -0.00748899f, 0.01702224f, 
    -0.04353527f, -0.01538207f, 0.00966403f, -0.00517553f, -0.03531489f, 0.00357477f, -0.03281124f, 0.02819129f, 
    0.00818206f, 0.01244384f, -0.03441476f, 0.01020635f, -0.02832049f, 0.02381033f, -0.02249454f, 0.00770131f, 
    -0.02479843f, -0.01473850f, -0.03442377f, -0.02950276f, -0.02198078f, -0.02407857f, -0.01997559f, -0.02693270f, 
    -0.00869465f, 0.02172924f, -0.00437752f, -0.03247470f, -0.03773294f, -0.03381125f, -0.01421876f, -0.02311047f, 
    -0.03396663f, -0.02169310f, -0.01066649f, -0.03719195f, -0.01985503f, -0.03726893f, -0.02913080f, 0.02536308f, 
    -0.00774541f, -0.02661979f, 0.01910162f, -0.03623237f, -0.03281954f, -0.02359130f, -0.00619224f, 0.01436150f, 
    -0.01062743f, -0.02687387f, 0.00067539f, -0.00012353f, -0.04048882f, 0.01480677f, 0.00372552f, -0.04468726f, 
    -0.01892681f, 0.01299193f, -0.02072375f, -0.02283010f, -0.01968073f, -0.02308159f, 0.00023717f, 0.02895994f, 
    -0.00083961f, 0.00861918f, -0.00275826f, 0.02663664f, -0.02950276f, -0.00132180f, -0.02156238f, 0.02456370f, 
    0.03012593f, -0.01966961f, 0.03119350f, -0.03745224f, 0.02696541f, -0.02878925f, -0.04077123f, -0.00379964f, 
    0.01480279f, 0.02861109f, -0.02734656f, -0.00661566f, -0.02588927f, -0.03997140f, -0.00497817f, 0.02862990f, 
    -0.01775232f, -0.02650819f, 0.02243649f, 0.02130179f, 0.02565568f, 0.01365652f, 0.01463937f, -0.03049053f, 
    0.00071897f, 0.00427801f, -0.01070596f, 0.02378729f, 0.01834732f, -0.02466703f, -0.04268381f, 0.01171471f, 
    0.02293762f, -0.03218814f, 0.01578981f, -0.03371715f, -0.02949251f, 0.00477349f, 0.01471633f, 0.02261839f, 
    0.02071358f, -0.00484762f, -0.02790506f, -0.02242506f, -0.01077568f, -0.01655884f, -0.02644618f, -0.03264581f, 
    -0.01168811f, 0.00209100f, -0.03083949f, -0.01988202f, 0.02452530f, 0.02658268f, 0.01922718f, 0.01818370f, 
    0.01849384f, 0.00927457f, 0.01943979f, -0.02626285f, 0.02882054f, -0.00069398f, 0.00907305f, -0.01649086f, 
    -0.01969097f, 0.02004383f, 0.00351506f, 0.00342570f, -0.00666890f, -0.03457309f, -0.03897224f, -0.02640133f, 
    -0.01033771f, -0.03249536f, 0.00163111f, -0.00902385f, -0.00450426f, -0.01063035f, 0.00491816f, -0.00237309f, 
    -0.02853534f, 0.01837934f, -0.03327527f, 0.00622018f, 0.00384220f, 0.01110322f, 0.02937060f, -0.01333739f, 
    0.02580597f, 0.03313290f, -0.01823904f, -0.01688163f, 0.01542751f, 0.01731349f, 0.02103699f, -0.04523330f, 
    -0.00920002f, 0.01939159f, -0.03889060f, 0.00922596f, -0.03635582f, 0.00943271f, 0.01264138f, 0.03020071f, 
    -0.00659383f, 0.02658890f, -0.04135257f, 0.00136810f, -0.00460130f, 0.01379549f, -0.02757506f, -0.00965748f, 
    -0.04356910f, -0.03725350f, -0.03953766f, 0.00437502f, 0.02733364f, -0.04327035f, 0.02123289f, -0.01442693f, 
    0.01626788f, 0.00531806f, -0.01528859f, -0.03783046f, -0.01460378f, 0.02691847f, 0.00098241f, -0.03826865f, 
    -0.02289879f, 0.00545319f, 0.02550339f, -0.03417326f, -0.03085006f, -0.03652982f, 0.01632712f, 0.02001932f, 
    0.03041417f, -0.03175474f, -0.00194634f, -0.03117473f, 0.00931230f, -0.02158953f, 0.00237533f, 0.01728069f, 
    -0.02263056f, -0.03348684f, -0.02259427f, -0.01828817f, 0.00071895f, 0.03163883f, 0.02901562f, 0.00903024f, 
    0.01968121f, 0.00034833f, -0.00586926f, -0.03525900f, 0.01964498f, 0.02911082f, -0.03293298f, -0.00687939f, 
    -0.04318622f, -0.03575517f, -0.02984077f, 0.01966902f, 0.00299939f, 0.03327645f, 0.02124353f, -0.03728928f, 
    -0.02907205f, 0.00558959f, -0.02762409f, -0.03423240f, 0.02827493f, -0.02322908f, -0.02738177f, -0.04422970f, 
    -0.03961864f, -0.01375517f, 0.00629815f, 0.02621035f, 0.00796478f, 0.02622416f, -0.03494638f, 0.00262737f, 
    0.02053727f, -0.03355378f, -0.03403368f, 0.02635450f, -0.02321251f, 0.02721713f, -0.03897583f, -0.02269754f, 
    -0.02373372f, -0.00245308f, 0.02852960f, -0.01952725f, -0.00403621f, 0.02181494f, -0.03187773f, 0.00559546f, 
    0.00540876f, -0.03885427f, -0.00486174f, 0.03115250f, -0.00163153f, 0.01695026f, -0.03344571f, -0.00435425f, 
    -0.02996218f, -0.03299367f, -0.01583515f, 0.03264381f, 0.00034236f, -0.01033300f, 0.00356758f, -0.04211736f, 
    0.02009122f, -0.00999922f, 0.00782628f, 0.02022408f, -0.00652834f, 0.01105409f, 0.01933279f, 0.01414802f, 
    -0.02292676f, -0.03271129f, 0.02969385f, -0.03085798f, -0.01129234f, -0.01620582f, 0.00436285f, 0.02720747f, 
    0.02740734f, 0.02252221f, 0.03140800f, -0.04266419f, -0.02377849f, 0.01631828f, 0.01559018f, -0.01572588f, 
    -0.03471424f, -0.00415098f, -0.01704489f, 0.00695546f, -0.01556138f, -0.02418130f, -0.04114512f, -0.03340788f, 
    -0.01860457f, -0.03545354f, -0.04424804f, -0.00580284f, -0.01806179f, -0.02544949f, 0.02741584f, -0.04259701f, 
    -0.01814329f, 0.01945401f, -0.04292448f, -0.00386509f, -0.02259983f, -0.03793219f, -0.03205359f, 0.01940019f, 
    0.03265612f, -0.00869828f, -0.01663414f, -0.01593990f, 0.02496677f, 0.02455410f, 0.02265905f, 0.01546433f, 
    -0.02532338f, -0.02023050f, 0.01582911f, -0.00278848f, -0.01592793f, 0.00997627f, -0.03405885f, -0.04221677f, 
    -0.02042642f, -0.01033645f, 0.00956215f, -0.02158080f, 0.01787581f, -0.02313589f, 0.02110920f, -0.02735349f, 
    0.03085044f, -0.00022826f, -0.00105186f, -0.01464980f, 0.02965187f, 0.01223367f, 0.00929724f, -0.01436075f, 
    0.02103984f, -0.00753343f, 0.10958816f, 0.04006603f, -0.19916420f, 0.07120173f, 0.02369176f, 0.03565079f, 
    -0.04358016f, 0.13708642f, 0.06361251f, -0.03260764f, 0.15541334f, -0.17339852f, 0.15466534f, 0.01946954f, 
    0.06657942f, -0.04462078f, 0.01400054f, 0.04537560f, 0.11222795f, -0.29358631f, -0.10252245f, -0.09580076f, 
    -0.07218707f, -0.07755715f, 0.07478103f, 0.07165163f, 0.00991921f, 0.09575067f, -0.01853708f, -0.06830087f, 
    0.11933415f, 0.06176025f, 0.07173243f, 0.02135776f, -0.02260827f, -0.03043238f, -0.13462481f, -0.08787732f, 
    -0.37302944f, -0.02070198f, -0.01181136f, 0.01731823f, -0.12218364f, 0.12851137f, 0.07205962f, 0.04186859f, 
    0.03603904f, -0.02048802f, -0.01375673f, -0.07517876f, -0.00697792f, 0.03767580f, 0.11078817f, 0.07279156f, 
    0.08714928f, -0.19793689f, -0.10767756f, 0.01019776f, -0.29610521f, 0.07510805f, -0.03730981f, -0.01549488f, 
    -0.03963600f, -0.00163162f, 0.09225589f, -0.04086792f, -0.06580109f, 0.05192637f, 0.04011232f, 0.03007494f, 
    -0.09013214f, -0.02538918f, -0.04498874f, -0.04985162f, 0.05396130f, 0.11058866f, 0.16217482f, 0.05712404f, 
    -0.11961535f, -0.20118931f, 0.00653092f, 0.04045015f, -0.04297278f, 0.00933840f, 0.13647042f, 0.12225811f, 
    0.08365393f, 0.09185005f, 0.00125448f, -0.00545837f, 0.03221313f, -0.02590858f, 0.04527344f, -0.00039775f, 
    -0.04932879f, -0.06717152f, 0.00429766f, -0.05453956f, -0.11337079f, 0.05023741f, -0.09398651f, -0.03396788f, 
    0.01244945f, 0.08297161f, 0.03175833f, -0.00439410f, 0.01219410f, -0.03383404f, 0.00505893f, 0.01287638f, 
    -0.00422470f, 0.03664278f, 0.06361507f, 0.19976933f, 0.17060158f, 0.10665866f, 0.04281132f, 0.07216362f, 
    -0.41196108f, -0.06357773f, -0.11383863f, 0.10485391f, 0.15118976f, 0.11498147f, 0.06221376f, 0.07629038f, 
    0.07547776f, 0.00308146f, 0.04897054f, 0.02316682f, 0.00694591f, -0.06428514f, 0.01403926f, 0.09607124f, 
    0.13285345f, 0.00946561f, -0.13824704f, 0.00514815f, 0.14543164f, 0.01433667f, -0.21423747f, -0.15245561f, 
    0.06516170f, -0.00698327f, -0.09390309f, 0.03542153f, -0.07413466f, 0.03528471f, -0.01915418f, -0.04790734f, 
    -0.02446344f, 0.02819721f, -0.04951550f, 0.10481393f, -0.03435168f, 0.02479993f, 0.02119010f, 0.02768163f, 
    0.20132835f, -0.16639464f, 0.02904406f, -0.08165133f, 0.07124021f, -0.09066048f, 0.10211669f, -0.03123241f, 
    0.00606870f, -0.06563377f, 0.02531953f, -0.00627004f, -0.05741844f, 0.11831676f, 0.02965569f, -0.01276634f, 
    0.06231661f, 0.16269785f, -0.03026203f, -0.01068950f, 0.10295393f, 0.09751052f, -0.00812619f, -0.02956547f, 
    -0.14021549f, 0.03855282f, 0.09710652f, 0.05409102f, 0.01917823f, 0.05540941f, 0.05327922f, -0.00797219f, 
    0.16472106f, 0.17165977f, 0.05099774f, 0.03319061f, 0.07304386f, -0.08070810f, 0.07211395f, -0.07567168f, 
    -0.35711303f, 0.00326733f, 0.05521978f, 0.15410021f, 0.10505084f, 0.23058470f, 0.20146154f, 0.09847672f, 
    0.06816762f, -0.05291032f, 0.05139743f, 0.00648587f, 0.06362960f, -0.07308044f, -0.08503728f, 0.05757998f, 
    -0.01295469f, 0.13420349f, -0.21024066f, 0.02248549f, -0.20483981f, 0.02116318f, 0.02028209f, -0.08861792f, 
    -0.07100938f, 0.08845022f, 0.05279296f, -0.01855141f, 0.02149326f, 0.14001381f, -0.13837691f, -0.12978889f, 
    0.23726866f, 0.03755725f, 0.09245393f, 0.01355301f, 0.14402714f, 0.02632071f, -0.04744487f, -0.05771337f, 
    -0.16056716f, 0.07130878f, -0.26717868f, -0.05641973f, 0.11786865f, -0.03888903f, 0.04556920f, 0.09011669f, 
    -0.10726316f, -0.01067273f, 0.13536006f, 0.00134869f, -0.11515703f, -0.09112272f, 0.09475353f, -0.11800244f, 
    -0.02927089f, -0.02932469f, 0.12615481f, -0.00780496f, 0.14346233f, -0.09317504f, -0.06859963f, -0.09921674f, 
    -0.05329823f, 0.07146209f, 0.05156451f, 0.01680766f, 0.04691580f, -0.03760095f, 0.05067775f, -0.00067601f, 
    0.05032878f, 0.08413395f, -0.00509661f, -0.13671084f, -0.01178516f, -0.01985428f, -0.05254177f, -0.09936444f, 
    0.24696049f, -0.06214458f, 0.15804057f, 0.08077566f, 0.21180432f, -0.04995163f, -0.02110029f, -0.00434559f, 
    0.01371315f, 0.03295715f, -0.03679072f, 0.02721564f, -0.05914568f, 0.13764995f, 0.00428320f, 0.14618032f, 
    0.00252512f, -0.01838578f, -0.03284823f, -0.01318774f, -0.09074707f, 0.13167395f, -0.25164279f, 0.03589782f, 
    0.07946142f, 0.01726059f, 0.03464681f, 0.08238219f, -0.07666367f, 0.16434008f, 0.08519401f, 0.01268785f, 
    -0.04603630f, -0.07081942f, 0.08142895f, -0.03005723f, 0.00822210f, 0.08230738f, 0.17432445f, 0.03766979f, 
    0.00158947f, -0.19424151f, 0.32367212f, 0.10834228f, -0.02316285f, 0.03427651f, 0.07400898f, 0.00875341f, 
    -0.01002580f, -0.07273352f, -0.06953441f, 0.01153205f, -0.05969340f, 0.01102738f, -0.06713786f, 0.02453806f, 
    -0.04150352f, 0.16990720f, -0.01851869f, 0.06215534f, -0.01160099f, 0.09134319f, 0.16150190f, -0.01116881f, 
    -0.19682883f, 0.04028017f, 0.14005542f, 0.02668474f, -0.01794961f, 0.02870415f, 0.07394412f, 0.01114233f, 
    0.07199047f, -0.13506904f, 0.00885041f, -0.02324187f, -0.00342231f, -0.05045292f, 0.00493631f, 0.04932470f, 
    -0.05127117f, -0.06010003f, 0.07652786f, 0.03191061f, -0.05523745f, -0.08423074f, 0.04815445f, 0.03658793f, 
    0.09481798f, 0.00606468f, 0.03250672f, -0.02785101f, 0.05878803f, 0.02894815f, -0.02823857f, -0.03481428f, 
    0.05217861f, -0.14956875f, -0.05141585f, -0.07824337f, 0.03780410f, -0.22448620f, -0.01609772f, -0.10015197f, 
    -0.15776652f, 0.03976245f, 0.10866747f, 0.00954452f, 0.10722720f, 0.06565681f, 0.02085790f, 0.06127369f, 
    0.11115684f, 0.13034107f, -0.08791030f, -0.10823545f, -0.00994978f, -0.02330885f, 0.00572556f, -0.01278447f, 
    -0.26149425f, 0.26320261f, 0.15132624f, 0.10885888f, -0.20147339f, 0.05920522f, 0.09808110f, 0.06158153f, 
    0.12214427f, -0.03242898f, 0.03677866f, 0.13017845f, -0.00168254f, 0.02608173f, 0.01466420f, 0.16089280f, 
    0.05597939f, 0.11690351f, -0.16385216f, 0.05871143f, 0.31521055f, 0.20943697f, 0.05038856f, -0.23642504f, 
    -0.23536450f, -0.00303618f, 0.01368557f, 0.07287973f, 0.07630089f, 0.05568143f, 0.05545374f, -0.01087176f, 
    -0.04589141f, -0.03713699f, 0.12651475f, 0.11722809f, 0.11549726f, 0.06246842f, 0.10042856f, 0.08089592f, 
    0.31479263f, 0.03916126f, 0.33592737f, -0.19761045f, -0.18441150f, 0.02759916f, -0.08533427f, -0.08639576f, 
    -0.00378676f, 0.02525842f, 0.00391579f, 0.11617013f, 0.00243751f, -0.05217094f, -0.03078738f, -0.03631537f, 
    -0.05401349f, 0.04824324f, 0.07768606f, -0.03341686f, -0.04658011f, 0.15869147f, -0.28203416f, -0.02818190f, 
    0.04147587f, 0.04976443f, -0.16650458f, 0.05007831f, 0.02828889f, -0.08972442f, 0.04607042f, 0.03877087f, 
    0.04103307f, -0.02420440f, 0.09048922f, 0.23655622f, 0.01778300f, -0.01856867f, 0.13832861f, 0.12359625f, 
    -0.01956730f, 0.01116492f, 0.03148180f, -0.00091084f, 0.18502006f, -0.03075144f, -0.02964823f, -0.02365103f, 
    -0.08891302f, -0.08506432f, 0.09853926f, 0.00115404f, -0.10412702f, 0.12061163f, 0.03670279f, 0.05135546f, 
    0.07573085f, 0.08704159f, 0.02654687f, 0.09115352f, 0.52662104f, -0.27391285f, 0.08380327f, 0.05634938f, 
    0.06460450f, -0.03859115f, 0.03106305f, 0.12763454f, 0.00359423f, -0.04833180f, -0.02587092f, 0.02803470f, 
    -0.05025865f, 0.17311989f, -0.00034538f, 0.07602983f, 0.04966458f, 0.10461535f, -0.10002400f, 0.13535249f, 
    0.34682220f, -0.04256807f, -0.22391826f, -0.11207111f, 0.26831621f, 0.09774291f, 0.01563970f, 0.09766587f, 
    0.04377067f, 0.03331576f, -0.06726538f, 0.02360296f, 0.04774122f, 0.03481051f, -0.07764382f, 0.04962590f, 
    0.06398501f, 0.13140376f, 0.00451068f, 0.02377659f, 0.08129111f, -0.11457080f, -0.05799496f, -0.05883112f, 
    0.08870449f, -0.00350005f, 0.01859885f, -0.00411580f, -0.12522309f, 0.00820735f, 0.06746094f, -0.03278404f, 
    0.01259930f, 0.09804347f, 0.00266580f, 0.13747028f, -0.00823828f, 0.11535466f, 0.09569059f, 0.08789821f, 
    0.10697541f, -0.22947808f, 0.10426252f, 0.07114305f, 0.01220340f, -0.13052730f, -0.02904104f, 0.09655717f, 
    -0.03799245f, -0.09503562f, -0.03389334f, -0.06491828f, -0.07772230f, -0.05057419f, 0.01832943f, 0.09407997f, 
    0.08967693f, 0.16272946f, 0.21129872f, 0.16641477f, -0.18380159f, -0.12465163f, -0.14068408f, -0.02821545f, 
    0.01408756f, 0.22769599f, 0.08769934f, 0.00890151f, -0.01306354f, -0.01875804f, -0.02702513f, -0.00109320f, 
    0.01941513f, -0.00250321f, 0.09156636f, -0.08080217f, -0.04138699f, -0.01426344f, -0.01047087f, -0.03155234f, 
    0.09124373f, 0.30180824f, -0.00139877f, 0.15139033f, 0.04924443f, 0.05175825f, 0.03169509f, -0.02276336f, 
    -0.06639805f, 0.06356578f, -0.03778844f, 0.03550267f, 0.03280029f, 0.06627905f, 0.09849055f, 0.02893795f, 
    0.12639417f, 0.01967057f, -0.01461060f, 0.19422531f, 0.04783270f, -0.03367499f, -0.04653581f, 0.00866808f, 
    0.11757644f, 0.17921330f, -0.01484020f, 0.09706059f, 0.04016349f, -0.01280803f, -0.04520659f, -0.06042285f, 
    0.11759989f, 0.12677024f, 0.04052679f, 0.15535738f, 0.01572335f, -0.03735197f, -0.12199008f, -0.02395468f, 
    0.33763304f, 0.12984483f, -0.10979830f, 0.05609994f, -0.35871443f, -0.00497478f, 0.06544621f, -0.05461868f, 
    0.11617545f, 0.02663490f, 0.02461601f, 0.06843279f, 0.04677318f, 0.01283936f, -0.00897135f, 0.02492860f, 
    -0.01473667f, 0.12474661f, 0.06039558f, 0.04092751f, -0.38734081f, -0.30117834f, 0.18528458f, 0.12156984f, 
    0.01886287f, -0.11447270f, -0.02737138f, 0.02070405f, -0.04196396f, 0.01131115f, 0.06451462f, 0.05603239f, 
    0.03865254f, 0.04957089f, 0.11542899f, 0.06219302f, 0.02309692f, 0.15548639f, -0.00926622f, 0.03861872f, 
    -0.17694104f, 0.03979603f, -0.12961793f, 0.00978940f, -0.16888024f, 0.13479403f, 0.08408214f, 0.06805617f, 
    -0.06359152f, -0.00361258f, 0.01496684f, 0.00275435f, -0.11039876f, 0.02171922f, 0.02794564f, -0.06248696f, 
    -0.07938048f, -0.02336418f, 0.01063053f, -0.07135614f, -0.02678871f, 0.28156322f, -0.26848570f, -0.35255647f, 
    0.14458524f, 0.08853528f, -0.13602433f, -0.05773939f, 0.09377863f, 0.12074929f, -0.04656097f, -0.07970321f, 
    -0.00685575f, 0.02161359f, 0.00733315f, 0.06190122f, 0.00139853f, -0.08223584f, -0.08385902f, 0.10419323f, 
    -0.14027347f, 0.07295635f, 0.01472279f, 0.11429963f, -0.10524950f, 0.10840631f, -0.03572157f, 0.14306566f, 
    0.09682122f, 0.05331464f, 0.15967570f, 0.07416289f, 0.02551074f, -0.17527892f, -0.10953078f, 0.07627913f, 
    -0.02876472f, 0.00305508f, 0.01783218f, -0.01158937f, 0.00376700f, 0.05783446f, -0.28301430f, -0.25532779f, 
    0.26656386f, 0.04263572f, -0.02662639f, 0.03804600f, 0.00324437f, 0.03996090f, 0.02772688f, -0.04823411f, 
    0.01004405f, 0.00876159f, 0.02834320f, 0.02784329f, 0.05474091f, -0.03011602f, -0.15309450f, -0.00217829f, 
    -0.07659411f, 0.00448740f, 0.09126970f, -0.16745102f, -0.12825699f, -0.05200586f, 0.17677289f, 0.12968360f, 
    -0.06443519f, 0.08207353f, 0.06181572f, -0.03573360f, -0.07252304f, -0.03448877f, -0.03256553f, -0.06233553f, 
    0.06053999f, 0.02631889f, 0.10104681f, 0.00866505f, -0.03410469f, 0.17681329f, 0.06508265f, 0.11673336f, 
    -0.00672559f, -0.04730318f, -0.02922590f, 0.17496604f, -0.09158302f, -0.08112675f, -0.09422678f, 0.03101383f, 
    0.01151472f, -0.00348903f, 0.02338449f, 0.08117408f, -0.05161608f, 0.13282645f, -0.11514261f, -0.02241593f, 
    0.01056933f, 0.03959337f, 0.05529149f, -0.14358151f, 0.02046065f, -0.05046066f, 0.07489748f, -0.01888872f, 
    0.03263563f, 0.04324653f, 0.10005737f, 0.00172783f, 0.03405361f, -0.06527644f, -0.02002644f, -0.00858314f, 
    0.04611943f, -0.00817031f, 0.06874144f, -0.03170822f, 0.41390547f, 0.03415587f, 0.06650241f, 0.17008665f, 
    0.02391735f, 0.01274493f, 0.09670659f, -0.00594899f, 0.03787356f, 0.06069186f, 0.05889006f, 0.01914668f, 
    -0.06956182f, 0.08735738f, -0.00510231f, 0.12853497f, 0.13471812f, 0.12426165f, 0.04366120f, 0.05956701f, 
    0.01900801f, 0.19443585f, 0.04196757f, 0.18294349f, -0.07481839f, 0.07729439f, 0.10112462f, -0.01562712f, 
    -0.16762359f, 0.11985995f, 0.10775399f, 0.06880836f, 0.05533974f, -0.00010694f, -0.10069047f, -0.06936377f, 
    0.05376307f, 0.00506451f, 0.12975553f, -0.01932386f, 0.44960979f, 0.03036777f, -0.03361362f, -0.01100700f, 
    0.07897123f, 0.15415813f, 0.01659275f, 0.05624046f, 0.13802880f, 0.11756254f, -0.04378609f, -0.02271292f, 
    0.06020843f, -0.04006405f, -0.01734975f, 0.13078167f, 0.01936607f, 0.01087277f, -0.01674291f, 0.08314312f, 
    -0.12663029f, 0.21580194f, 0.13665079f, -0.26662886f, -0.01499783f, 0.02980141f, -0.03020868f, 0.13830459f, 
    -0.16214575f, -0.02339771f, 0.03896615f, -0.02000108f, 0.01558526f, 0.08985309f, 0.01430377f, 0.06765273f, 
    -0.00654625f, -0.02823211f, -0.04372310f, -0.06190749f, -0.11595864f, -0.13217731f, 0.06234046f, 0.11818816f, 
    -0.01961156f, 0.01722322f, 0.02511835f, 0.07270654f, -0.02852020f, -0.05963005f, 0.01231191f, -0.05605319f, 
    0.10468572f, 0.02647642f, -0.05931118f, -0.09415178f, 0.04643130f, 0.05624068f, -0.14169690f, 0.07508074f, 
    0.12638877f, -0.51074743f, -0.03794152f, 0.34628150f, -0.03277753f, 0.01855800f, 0.07664398f, -0.07224444f, 
    0.01354583f, -0.01246443f, 0.01780409f, -0.14273722f, 0.17776322f, 0.08450904f, 0.12540257f, 0.06589098f, 
    0.02719557f, 0.02433208f, 0.01690454f, 0.07353558f, -0.06395606f, 0.14139807f, 0.05380040f, -0.20533128f, 
    0.15464409f, 0.08904494f, 0.12419648f, 0.06281784f, 0.01244819f, 0.01283071f, -0.03330624f, 0.02751920f, 
    0.08271120f, 0.02303264f, 0.09351839f, 0.04265362f, 0.00680315f, 0.01309110f, -0.11186768f, 0.01363623f, 
    -0.11504082f, -0.22125530f, -0.20273620f, 0.15853746f, 0.05217531f, -0.11164352f, -0.10434829f, -0.00121757f, 
    -0.01183860f, -0.01978434f, 0.14270227f, -0.08113471f, 0.03222416f, -0.03182226f, -0.09379428f, 0.01882997f, 
    -0.04938371f, -0.02412420f, -0.15343265f, -0.04200874f, 0.02615409f, 0.45718965f, -0.08916748f, 0.13817513f, 
    -0.25172773f, 0.26518399f, 0.21239556f, -0.12902230f, -0.02817698f, -0.03721153f, 0.04874663f, -0.09594341f, 
    -0.01346302f, 0.09454408f, 0.00634997f, 0.12018341f, -0.00236621f, 0.03406787f, 0.01082974f, 0.06658342f, 
    -0.16928498f, -0.20829669f, 0.07695303f, -0.03440540f, -0.11559644f, -0.04318444f, 0.14307548f, -0.12883052f, 
    0.12456731f, -0.00882916f, -0.02731334f, -0.00573152f, 0.06998046f, -0.07045610f, 0.01071719f, -0.06889312f, 
    -0.01762652f, 0.09987287f, 0.01054038f, -0.00400811f, -0.01448386f, -0.14016618f, 0.05882134f, 0.02054570f, 
    -0.07598756f, -0.00071303f, 0.01591701f, -0.01513130f, 0.01740511f, 0.05669731f, -0.00509499f, 0.06851874f, 
    -0.04131015f, -0.07000315f, -0.00044278f, -0.07375752f, -0.02307972f, 0.05512982f, -0.10504043f, -0.05389265f, 
    0.05695013f, 0.06269294f, -0.19559211f, 0.20860519f, -0.25928408f, 0.10386868f, 0.15176266f, 0.03191725f, 
    -0.17818734f, 0.04921169f, -0.02891600f, 0.04714931f, 0.02697927f, -0.00904395f, -0.02309153f, 0.04098542f, 
    -0.01234552f, -0.02903896f, 0.12785821f, -0.04120645f, 0.16018103f, 0.25151500f, -0.22455886f, -0.13079199f, 
    0.04722749f, 0.11319106f, -0.03719479f, -0.02182944f, 0.01292397f, 0.00110900f, -0.03840156f, -0.05778774f, 
    0.07042968f, 0.01943998f, 0.06541733f, 0.07123560f, 0.05124625f, 0.02646301f, -0.00684837f, -0.00791123f, 
    0.71382236f, -0.15049095f, -0.09497846f, -0.15454103f, -0.08577113f, 0.08251740f, 0.06088522f, -0.06579343f, 
    0.04935554f, -0.03597708f, -0.05246956f, 0.01883588f, 0.04822276f, 0.09272887f, 0.10310955f, -0.01160026f, 
    -0.08591795f, 0.01016362f, 0.04141036f, -0.01383399f, 0.00304044f, 0.26943010f, -0.02238755f, -0.23917845f, 
    -0.07667253f, 0.13988350f, -0.02023724f, 0.04953926f, -0.04872461f, 0.04257114f, 0.03601449f, -0.03265580f, 
    0.05909885f, 0.05664488f, -0.01575913f, 0.01450307f, -0.04581381f, 0.05813663f, -0.13397609f, 0.14230733f, 
    0.24677625f, -0.03289234f, 0.01938816f, -0.09265225f, 0.11355241f, -0.04226611f, 0.16643897f, 0.06110269f, 
    -0.15921676f, -0.12143161f, 0.03511808f, -0.04690948f, 0.08791517f, -0.00262535f, -0.00605920f, -0.08141463f, 
    0.13380796f, -0.07421785f, -0.06048846f, -0.11989314f, -0.42855650f, -0.26900983f, 0.08757669f, 0.11885171f, 
    -0.05764883f, -0.04981574f, 0.02011149f, -0.05449097f, 0.05035371f, -0.00282703f, -0.06137173f, 0.09451196f, 
    0.13285272f, 0.01806910f, -0.05106496f, 0.06140828f, -0.04122030f, -0.01115113f, -0.17449494f, 0.02104774f, 
    -0.00179016f, 0.06128263f, -0.06396981f, 0.17742056f, 0.46383715f, -0.08005353f, -0.12747148f, 0.12421366f, 
    0.02173433f, 0.04421666f, 0.03685870f, -0.02286511f, 0.21475005f, 0.04144222f, 0.07207211f, 0.10485567f, 
    0.02410325f, -0.11559866f, -0.00807079f, 0.02609571f, 0.31520265f, 0.18020283f, 0.21625279f, -0.19641171f, 
    0.05649104f, -0.00225148f, -0.03318958f, -0.01063817f, -0.18347651f, -0.00934841f, 0.00673824f, 0.03166786f, 
    0.01453721f, -0.05017697f, -0.04811346f, -0.08598284f, 0.07311020f, -0.04679065f, -0.02992583f, -0.08275758f, 
    -0.24380808f, -0.12435567f, -0.00104077f, 0.04412073f, 0.08047864f, -0.05877876f, -0.07725176f, -0.08019868f, 
    0.04007992f, -0.00583755f, -0.00547046f, -0.00027582f, -0.02561958f, 0.00092972f, -0.02325982f, 0.03261291f, 
    -0.00324654f, -0.01871426f, -0.07008621f, 0.08495644f, -0.14707260f, -0.39353797f, 0.04619476f, 0.00018061f, 
    0.06701624f, 0.04266302f, -0.00088662f, 0.04069947f, 0.07973064f, -0.02440627f, -0.01801714f, -0.08100440f, 
    -0.06282149f, -0.07260647f, -0.06327616f, -0.09041381f, -0.01170020f, 0.04264478f, 0.05845829f, 0.04589665f, 
    0.06361499f, 0.43697694f, -0.08415177f, -0.08298883f, 0.10034139f, 0.13744904f, 0.01491321f, 0.01880832f, 
    0.00802186f, 0.03024599f, 0.07977092f, 0.07159574f, 0.01063957f, -0.05228285f, -0.05429717f, 0.02246569f, 
    -0.02650150f, 0.03627589f, 0.03186287f, 0.04066688f, 0.06195100f, -0.08906589f, 0.13353327f, -0.18953738f, 
    0.08996085f, 0.03293592f, -0.05308949f, -0.02338418f, 0.12512465f, -0.06866738f, 0.02087604f, 0.01104343f, 
    -0.06890753f, -0.04217368f, -0.00366971f, -0.04348955f, -0.05336756f, -0.01131361f, 0.05793205f, 0.01872935f, 
    -0.03791014f, 0.02725475f, 0.01022021f, -0.04198681f, -0.01286668f, 0.01739950f, -0.02825685f, -0.00512337f, 
    -0.02087839f, -0.02530942f, -0.03622505f, -0.01986859f, -0.00020300f, -0.00771783f, 0.01529856f, -0.01717372f, 
    -0.00171428f, 0.03340837f, 0.02156765f, -0.02802123f, -0.00685182f, 0.03095512f, -0.03685801f, -0.01300596f, 
    -0.04205573f, -0.00390264f, -0.03353474f, 0.00527855f, 0.01175549f, 0.01016900f, 0.03103730f, -0.02833700f, 
    -0.00025974f, -0.01224977f, -0.01724822f, -0.03404474f, -0.02226440f, -0.03620135f, -0.01443393f, -0.00299921f, 
    -0.02288456f, 0.01229725f, -0.00714290f, -0.01077108f, -0.03135672f, 0.03936080f, -0.03525862f, 0.02453034f, 
    -0.01461582f, 0.02078359f, -0.01340895f, -0.03130478f, 0.02230882f, -0.00101062f, 0.02677898f, 0.00150294f, 
    0.02885300f, -0.02310522f, -0.02764896f, 0.00941942f, 0.02417761f, 0.01004086f, 0.00059971f, 0.03419983f, 
    0.03299429f, -0.01845677f, 0.00396736f, 0.03024451f, -0.02749879f, -0.01264111f, -0.03917132f, 0.01924274f, 
    0.02683383f, 0.02859353f, 0.00877037f, -0.04460240f, -0.03234338f, -0.01177580f, -0.02348451f, -0.00536081f, 
    0.00894496f, -0.02148650f, -0.03522597f, 0.03186638f, -0.04096252f, -0.02145133f, 0.01772051f, 0.02365101f, 
    0.02915289f, -0.03832881f, 0.01674501f, 0.01770996f, -0.02508408f, -0.02585468f, 0.00653592f, 0.01838951f, 
    -0.02311102f, -0.03596763f, 0.01306506f, 0.01209223f, 0.01072439f, -0.04208346f, 0.00035205f, 0.01383039f, 
    -0.03010347f, 0.03431273f, -0.03757036f, 0.02145721f, 0.02261443f, 0.01452770f, -0.03112245f, 0.00133235f, 
    0.00233954f, -0.00652394f, 0.00762805f, 0.00959812f, 0.02309340f, -0.01448622f, 0.01359360f, -0.02585275f, 
    -0.01712499f, -0.01756823f, -0.02055363f, -0.01082876f, -0.00562539f, -0.03129879f, -0.03361210f, 0.02443383f, 
    -0.03885006f, 0.03107185f, -0.02232191f, -0.02924901f, 0.02365442f, -0.00702264f, 0.01942610f, -0.01883801f, 
    0.01160706f, 0.03585410f, 0.00312532f, 0.02553828f, -0.02960059f, -0.00034007f, 0.00170371f, -0.01139965f, 
    0.02499032f, -0.01892648f, -0.01699383f, 0.00987870f, -0.02337960f, -0.00840913f, -0.01781482f, 0.02892203f, 
    -0.03417027f, 0.03889356f, 0.01547132f, 0.02673990f, -0.03812298f, -0.01334987f, -0.00834176f, 0.00097869f, 
    0.01418021f, 0.00531719f, -0.02518339f, -0.01891848f, -0.03956663f, 0.03165819f, -0.02814911f, 0.00747217f, 
    -0.02844273f, -0.03034496f, -0.00453573f, -0.03078133f, 0.01904774f, 0.03382077f, -0.03869617f, 0.02155815f, 
    -0.01295158f, -0.03925700f, -0.00274407f, -0.04525233f, 0.01822374f, -0.04397821f, -0.04265494f, -0.04145937f, 
    -0.03218063f, -0.02693315f, 0.01162856f, -0.03400099f, -0.00977932f, -0.01542125f, -0.01554372f, 0.02550616f, 
    0.03298942f, 0.01493208f, -0.02845874f, 0.01914721f, -0.00643432f, 0.00850937f, -0.03236048f, 0.02457027f, 
    0.04329627f, -0.00001972f, 0.00508368f, 0.01776760f, 0.02446621f, 0.02779698f, 0.02445826f, -0.04150538f, 
    -0.03752786f, 0.02993149f, -0.02639296f, -0.01595312f, -0.03090724f, -0.00932831f, 0.02567013f, -0.00085415f, 
    -0.02702964f, 0.01590819f, 0.02261904f, -0.03399224f, 0.01703005f, 0.00645833f, -0.02374541f, -0.03586881f, 
    0.01553247f, 0.02236288f, 0.00544550f, 0.03043137f, -0.01172306f, -0.04481253f, -0.02581086f, 0.02384541f, 
    0.00911897f, -0.02880846f, 0.00842804f, -0.02450938f, 0.03226386f, 0.02853426f, 0.01925889f, 0.01833562f, 
    0.01402873f, -0.01246410f, 0.02259660f, 0.04092626f, -0.03295952f, -0.04493937f, 0.00683397f, 0.04251599f, 
    -0.00236334f, 0.02758059f, -0.02612146f, 0.00354092f, -0.03958712f, 0.02129692f, -0.00073753f, 0.01495411f, 
    0.01692943f, -0.02152354f, -0.01961199f, 0.01297071f, 0.02553291f, -0.02084128f, 0.00748314f, 0.01499526f, 
    -0.03252297f, -0.03029900f, 0.02805818f, 0.03013914f, -0.02977648f, 0.00893939f, 0.01863146f, 0.00740568f, 
    -0.01243378f, 0.04051922f, 0.00695622f, 0.02412627f, -0.02134278f, -0.04367312f, 0.02677925f, 0.02361034f, 
    -0.00301389f, -0.04551189f, -0.04090673f, 0.01128550f, 0.02002909f, -0.02919876f, -0.01726636f, 0.01402356f, 
    -0.00228927f, 0.00891160f, -0.00613180f, -0.00314701f, 0.03065953f, -0.02347522f, -0.01357911f, 0.02984861f, 
    0.01489071f, 0.02240284f, -0.02801629f, -0.02320337f, 0.00515397f, 0.02161979f, -0.03395265f, 0.02681536f, 
    -0.03893825f, -0.02379328f, -0.03061948f, -0.01401507f, 0.00271895f, 0.01526460f, 0.01802845f, -0.00028477f, 
    0.02245391f, 0.03788528f, -0.01883264f, -0.00296590f, -0.01881727f, -0.03391155f, -0.03275079f, -0.03589109f, 
    0.00498695f, 0.00043819f, 0.01079025f, -0.02638809f, 0.00065842f, -0.02597938f, 0.02995857f, 0.03733357f, 
    -0.00222426f, 0.01704420f, 0.02355994f, 0.01890145f, -0.00192051f, 0.02972723f, 0.02542578f, -0.04060529f, 
    -0.02198193f, -0.01656781f, 0.02209168f, 0.00813055f, 0.01730133f, -0.00696173f, 0.00859269f, -0.01466297f, 
    -0.00839240f, -0.04085781f, 0.03181653f, 0.01772468f, -0.02701455f, -0.00950139f, 0.01218986f, -0.00510296f, 
    -0.02954117f, 0.00049614f, -0.04241077f, -0.00224414f, 0.00939650f, 0.01516829f, 0.03123414f, -0.03987118f, 
    -0.00217602f, -0.04249885f, 0.03397647f, -0.00572516f, -0.03039185f, -0.02045361f, -0.03927901f, 0.01437147f, 
    0.01280345f, 0.02906994f, 0.02315287f, 0.00124448f, 0.03483281f, 0.01937011f, -0.00465478f, -0.02943312f, 
    -0.00149559f, -0.03337333f, -0.02298157f, -0.03875295f, -0.00202559f, -0.01520594f, 0.01990868f, 0.02835613f, 
    0.01051576f, -0.04666585f, -0.00635722f, -0.02609232f, 0.00028545f, -0.01455747f, -0.03269964f, -0.03042384f, 
    0.03326790f, 0.03776367f, -0.01773398f, -0.00843427f, -0.00256260f, -0.02568116f, 0.01438049f, -0.03792044f, 
    -0.00905069f, -0.04258021f, 0.01772476f, 0.00850062f, -0.01176263f, -0.01126914f, -0.01218121f, -0.04249502f, 
    0.02517201f, -0.00120368f, 0.01588581f, -0.00295898f, 0.02708473f, -0.01153334f, -0.00890354f, -0.01716331f, 
    -0.01357964f, -0.01320342f, 0.02712942f, 0.02994615f, 0.00431920f, -0.00726944f, -0.00046822f, 0.01090952f, 
    -0.00981476f, -0.00252550f, -0.02606812f, 0.03335524f, 0.03724783f, -0.01005664f, -0.00052289f, -0.00693055f, 
    0.01366867f, -0.04231400f, 0.02954420f, -0.00470001f, -0.04615542f, -0.03899519f, 0.01057791f, 0.02601896f, 
    -0.02579371f, -0.03515255f, 0.02876933f, 0.03284210f, -0.02114748f, -0.00511969f, 0.01441212f, 0.03069976f, 
    -0.02814258f, -0.01358016f, 0.00531310f, 0.03164448f, 0.00221098f, 0.02319256f, 0.03027734f, 0.02726216f, 
    0.03079838f, -0.00593687f, -0.01866263f, -0.01147994f, 0.01395755f, -0.01065384f, 0.01069753f, 0.01706399f, 
    -0.00490839f, 0.04031620f, 0.01720482f, -0.01984922f, 0.02118877f, -0.01564686f, -0.01457159f, -0.03694083f, 
    -0.02307869f, -0.02335574f, -0.02927757f, 0.01063580f, -0.01787973f, -0.03520854f, -0.00465819f, -0.04553360f, 
    -0.01905547f, 0.03195005f, -0.00243518f, 0.01786976f, 0.00071457f, -0.00278886f, -0.02060700f, 0.03030797f, 
    0.00725964f, -0.03828593f, -0.00128532f, 0.01810344f, -0.02127152f, -0.02363878f, -0.00049242f, -0.00836654f, 
    -0.00360968f, 0.00652292f, -0.00792634f, 0.02024885f, 0.01978915f, -0.01596926f, -0.03453429f, -0.00098197f, 
    0.02275071f, 0.02890552f, 0.01634235f, 0.01026105f, -0.04374798f, 0.02902440f, -0.03709660f, -0.02725573f, 
    -0.02240249f, 0.02936048f, 0.01437204f, 0.00950631f, -0.03916794f, -0.03344242f, -0.03867228f, -0.02674341f, 
    -0.02265918f, -0.02150696f, 0.01197998f, -0.03295182f, -0.03939942f, 0.03383543f, -0.04401306f, -0.01510478f, 
    -0.01455219f, -0.03047329f, 0.01744040f, -0.03051435f, 0.00159326f, -0.02972069f, 0.03214796f, -0.02741641f, 
    0.02101628f, -0.00152562f, -0.02972029f, -0.00959656f, 0.03037657f, -0.02944952f, -0.03611665f, 0.01486935f, 
    0.03157772f, -0.03463122f, -0.00513838f, 0.02544209f, -0.01121044f, -0.04524537f, 0.00393030f, -0.00979084f, 
    -0.02739828f, 0.03677344f, 0.00889321f, -0.03396152f, 0.00466280f, 0.01627453f, 0.02529049f, 0.02034447f, 
    -0.03549983f, -0.04575081f, 0.02941280f, -0.04322125f, 0.01121568f, -0.03159444f, -0.02913022f, 0.02470059f, 
    0.00779356f, -0.03637933f, -0.03305382f, -0.01999319f, -0.04238547f, -0.03974888f, -0.02059310f, -0.03998557f, 
    -0.00233950f, -0.03395166f, 0.02772935f, -0.01795650f, -0.03079095f, 0.01467919f, 0.03069601f, 0.01690157f, 
    -0.03950025f, 0.00827057f, 0.02139507f, -0.01064797f, 0.00224438f, -0.01764838f, 0.02655490f, 0.00210470f, 
    -0.00474456f, 0.03226124f, -0.03403334f, 0.03089583f, 0.00771336f, 0.02376537f, 0.03077155f, -0.04504092f, 
    -0.03867709f, 0.01512937f, -0.02338671f, -0.01788486f, 0.02041538f, -0.01982390f, 0.02679073f, 0.01489775f, 
    -0.03271871f, -0.01019585f, -0.00724703f, -0.02406049f, -0.00129632f, 0.00627499f, -0.03449719f, -0.03173481f, 
    -0.04273332f, 0.02154393f, -0.02886317f, 0.02858821f, -0.00249066f, -0.01192966f, -0.00135657f, -0.02591672f, 
    -0.02429151f, 0.01130092f, -0.03416340f, -0.04448836f, -0.04031753f, -0.03986634f, 0.00352285f, -0.03749862f, 
    0.02422888f, -0.01537854f, -0.01952749f, -0.00152487f, 0.02610281f, 0.01916839f, -0.00312528f, 0.03038358f, 
    -0.13610391f, 0.10400476f, 0.02213879f, 0.04773082f, 0.02198982f, -0.01915963f, 0.03687963f, 0.02675062f, 
    0.00484390f, -0.03778010f, 0.01731154f, 0.06228041f, -0.11091457f, 0.23971738f, -0.09440691f, 0.02137369f, 
    0.04804527f, 0.14582525f, -0.05067797f, 0.08117000f, -0.05465934f, 0.11299905f, -0.03056174f, 0.05985229f, 
    -0.13196337f, 0.03965373f, 0.07023575f, 0.01028984f, 0.01154956f, -0.06129383f, 0.07559837f, 0.12919159f, 
    -0.04166447f, -0.08579414f, 0.04575976f, -0.00391095f, -0.02647761f, 0.11867032f, -0.00903470f, 0.08979186f, 
    0.12379433f, 0.03368825f, 0.17868176f, 0.10539468f, 0.04329877f, -0.06099254f, 0.04165637f, -0.07935320f, 
    -0.08649385f, 0.02335604f, 0.07619805f, 0.01108274f, -0.01003520f, 0.03700929f, -0.00178017f, -0.00949789f, 
    0.06666199f, 0.11295703f, 0.07429774f, -0.02615259f, 0.27766564f, -0.26547402f, 0.00845307f, 0.17702593f, 
    0.06941626f, 0.01246847f, -0.03549038f, 0.05526879f, 0.12182733f, -0.05129590f, -0.10913561f, 0.00061938f, 
    0.12516050f, 0.14074625f, 0.12334672f, 0.05535114f, 0.02785819f, -0.18775111f, -0.10450730f, 0.01102344f, 
    -0.02854060f, 0.00064053f, 0.13080132f, 0.01938427f, 0.11400951f, -0.03637437f, 0.01723328f, -0.02234487f, 
    -0.13029291f, 0.05516737f, 0.04164747f, 0.04794417f, -0.02033702f, 0.05843365f, -0.07840067f, -0.01957232f, 
    0.05849400f, 0.17059004f, 0.05936425f, 0.04335213f, 0.15102804f, -0.19157010f, -0.01101136f, 0.06178271f, 
    0.07467905f, -0.08606302f, 0.03292398f, 0.05539622f, 0.00694933f, -0.01497281f, -0.00107124f, -0.02474746f, 
    0.00957108f, 0.04739659f, 0.02213997f, -0.02958658f, -0.03993609f, -0.18476686f, -0.04172707f, -0.04534776f, 
    0.19496717f, -0.08129337f, -0.12330394f, -0.06604498f, -0.01517410f, -0.02057414f, 0.08913245f, -0.09163480f, 
    -0.09243252f, -0.03883900f, -0.04504605f, -0.02711657f, 0.08109673f, 0.05810063f, -0.01754488f, 0.04350802f, 
    -0.07480204f, 0.07365695f, 0.16431293f, -0.04708716f, -0.01685222f, 0.13500276f, 0.14768790f, 0.13101071f, 
    -0.10620809f, 0.03121100f, 0.05827260f, -0.00372190f, 0.03028500f, -0.01390016f, 0.03531197f, 0.05716332f, 
    -0.08706839f, 0.10212762f, -0.04788462f, 0.06231034f, 0.00494025f, -0.00896852f, -0.02058406f, 0.05662337f, 
    0.00868675f, 0.09939976f, -0.10983177f, 0.04089122f, 0.02156788f, 0.07202101f, -0.04755661f, 0.12187215f, 
    -0.10174797f, 0.06482662f, 0.02460936f, 0.01666239f, -0.05954611f, -0.08623569f, 0.06684410f, 0.05960198f, 
    0.04376537f, -0.04347994f, 0.08021029f, 0.04827852f, -0.14420803f, 0.06940840f, 0.07871088f, 0.10966446f, 
    0.11582506f, 0.09913702f, -0.07710359f, -0.10518558f, 0.02470283f, 0.11513376f, 0.04361589f, 0.08151743f, 
    -0.07141785f, -0.12112668f, -0.03582322f, -0.07953185f, 0.02537418f, 0.15697673f, 0.01466827f, 0.09020496f, 
    -0.01681578f, -0.08771933f, -0.18940587f, 0.10480347f, -0.11568497f, -0.09932299f, -0.00086379f, -0.12930737f, 
    -0.05570688f, 0.06084228f, 0.00701805f, 0.01315118f, -0.14777713f, 0.00230200f, 0.05946635f, 0.02146522f, 
    0.13023995f, 0.02272620f, 0.10471474f, -0.02501016f, 0.12029619f, -0.19647267f, -0.05086122f, 0.08706763f, 
    0.15490232f, -0.05173910f, 0.01832677f, -0.04723811f, 0.00727229f, 0.00824733f, -0.01696015f, 0.03632289f, 
    -0.07083689f, -0.15601544f, -0.05935044f, -0.03479577f, 0.09067605f, 0.09559761f, -0.05880307f, 0.08105459f, 
    -0.10746567f, 0.08477286f, 0.10523774f, -0.06949972f, 0.10761005f, 0.07584661f, 0.00947102f, 0.06565081f, 
    0.19405897f, 0.03219991f, -0.05760369f, -0.03897244f, 0.09044764f, 0.09818623f, -0.03846893f, 0.02067767f, 
    0.08952145f, 0.02225065f, -0.11676293f, -0.03337052f, -0.05780372f, 0.08009256f, -0.06195926f, 0.06238377f, 
    -0.02063946f, -0.10667861f, 0.01314589f, 0.15434891f, -0.02255536f, 0.05126254f, -0.04818847f, -0.00318041f, 
    -0.04157235f, 0.02916841f, 0.07828715f, 0.08020511f, 0.05624312f, 0.07868838f, -0.01480808f, 0.06585274f, 
    -0.38131905f, 0.11008707f, -0.12620895f, -0.10139451f, 0.13594116f, 0.02645545f, 0.03974839f, 0.03995331f, 
    -0.02234586f, 0.11302232f, 0.03340566f, 0.07091678f, 0.10640926f, -0.06129904f, -0.01411094f, 0.01330503f, 
    -0.00320026f, 0.10575418f, -0.03851829f, -0.05602656f, 0.06391417f, 0.07579257f, 0.21024261f, -0.09413670f, 
    -0.07515257f, 0.03835947f, -0.01821237f, 0.00370458f, 0.15062909f, -0.09249459f, -0.01383464f, 0.01973276f, 
    0.06078843f, 0.05777499f, 0.01913929f, 0.02139564f, 0.04486712f, 0.00701300f, -0.10576215f, 0.02221232f, 
    -0.32983524f, -0.00294797f, -0.29290116f, 0.04155041f, -0.02902878f, 0.07353344f, 0.06579074f, 0.05411081f, 
    0.09301183f, 0.02449659f, 0.16724969f, -0.00834189f, -0.04879562f, -0.06845225f, 0.13079187f, -0.00035335f, 
    0.13534056f, -0.10905515f, -0.09210495f, -0.01656264f, -0.31583592f, 0.00232986f, -0.05297380f, 0.13438480f, 
    0.17828183f, 0.06080502f, -0.05715733f, -0.10738795f, 0.04246876f, -0.00960662f, 0.05279672f, 0.11802801f, 
    -0.06602383f, 0.18235712f, 0.03867297f, 0.06100230f, 0.04744429f, -0.04476994f, -0.01006729f, -0.01179000f, 
    -0.08689608f, 0.15667218f, -0.02833622f, -0.19888881f, 0.04964168f, 0.12241498f, -0.07282048f, -0.01605363f, 
    -0.15450194f, 0.12528422f, -0.03764314f, 0.06250822f, -0.08480503f, -0.03483940f, 0.13382979f, 0.00205233f, 
    -0.00166836f, 0.12929036f, 0.06916876f, -0.01181342f, 0.05996233f, 0.10026318f, -0.21160035f, 0.10286556f, 
    -0.00600430f, -0.07832208f, -0.03219928f, 0.02377130f, -0.09336216f, -0.08556998f, -0.06702963f, 0.05521382f, 
    -0.03253696f, -0.06275995f, 0.01761131f, 0.08104930f, 0.06976730f, 0.04332224f, -0.01042109f, -0.03409467f, 
    -0.37305656f, -0.08749922f, -0.12872772f, 0.10867957f, -0.14002027f, -0.04932238f, 0.07396914f, -0.06381284f, 
    -0.00123160f, -0.01350695f, 0.05806919f, -0.03104559f, 0.01451423f, -0.01266190f, 0.05677503f, -0.02145451f, 
    0.05313284f, -0.10362336f, 0.15896375f, 0.00403671f, -0.38563791f, 0.03361931f, 0.22661546f, 0.17493786f, 
    0.01404358f, 0.01710773f, -0.06742817f, 0.08839735f, -0.03926973f, 0.01555616f, 0.03060182f, 0.02125177f, 
    0.03817528f, 0.15582660f, -0.06019142f, 0.00508068f, -0.14784998f, -0.01534421f, 0.05386622f, -0.01701964f, 
    -0.35563239f, -0.05106068f, 0.13434143f, 0.10091485f, -0.03987829f, 0.09868290f, 0.00619654f, 0.09046604f, 
    0.05407672f, 0.14922695f, 0.02355368f, -0.01095715f, 0.04758523f, 0.17756449f, 0.11040889f, 0.12472449f, 
    -0.01837893f, -0.00221375f, -0.08136383f, 0.02884888f, -0.14500813f, -0.20279455f, 0.25139934f, -0.10904806f, 
    0.13737139f, -0.01739245f, 0.06855421f, -0.08116017f, 0.06806292f, 0.02036872f, -0.05815667f, 0.10113496f, 
    -0.18249866f, 0.00522420f, -0.02065250f, -0.10787787f, 0.07555813f, -0.14618325f, 0.02533138f, -0.05208620f, 
    0.16984847f, 0.05861305f, -0.09951081f, -0.06567112f, -0.17655091f, -0.02969358f, 0.01131088f, 0.07721601f, 
    0.02489344f, -0.05514794f, -0.08133045f, 0.02129274f, 0.11951675f, -0.11460790f, 0.00484907f, 0.07713945f, 
    0.08032224f, -0.16499858f, 0.03322735f, -0.04457892f, -0.52527374f, 0.10587403f, -0.07705574f, 0.10576761f, 
    0.05208036f, -0.03653555f, 0.04418930f, -0.06138170f, -0.00760649f, 0.03092741f, -0.04027251f, 0.03279243f, 
    0.01999285f, -0.11844575f, 0.01989517f, -0.02000563f, 0.03778420f, 0.04898899f, 0.12282072f, -0.09407694f, 
    -0.22951405f, 0.13266064f, 0.14297396f, 0.15968567f, -0.13191406f, -0.04543865f, -0.03861283f, -0.09211278f, 
    0.00324230f, 0.02998688f, 0.17144464f, 0.03969777f, -0.04882893f, -0.02780306f, 0.09977011f, 0.07043531f, 
    -0.12594196f, -0.14059861f, 0.15058997f, 0.03600733f, 0.06655968f, 0.22538671f, 0.10014489f, -0.00221100f, 
    -0.01234772f, -0.02792827f, -0.09803292f, 0.06879824f, 0.08722560f, -0.00438302f, 0.03940574f, 0.09644844f, 
    0.00244105f, -0.15291058f, -0.10509609f, 0.03532668f, 0.08252303f, -0.15768318f, -0.00574155f, -0.03307940f, 
    -0.02200836f, 0.09015102f, 0.14569861f, 0.17657918f, 0.18195228f, 0.12043904f, 0.09066083f, 0.03564775f, 
    0.04510394f, 0.06920438f, 0.01673374f, 0.08472265f, 0.10043925f, 0.03795989f, 0.02256949f, -0.02348758f, 
    -0.00185570f, -0.12679166f, -0.07906138f, -0.00273455f, 0.12226052f, -0.00506222f, -0.04760629f, -0.03136819f, 
    0.06488725f, -0.10305089f, 0.03259824f, 0.06982367f, 0.06880300f, 0.04156937f, -0.03129968f, -0.04630712f, 
    -0.01329565f, 0.04580890f, -0.11220969f, 0.01071054f, 0.09006839f, 0.00612546f, 0.00274951f, -0.05916379f, 
    -0.01598939f, -0.31607828f, -0.03102752f, -0.10167296f, 0.11471105f, -0.09261105f, 0.02920494f, 0.08286422f, 
    0.11401926f, -0.07305146f, 0.14468120f, -0.06496666f, 0.02212442f, -0.02646989f, -0.07964844f, -0.04234878f, 
    -0.08763060f, -0.01930778f, 0.06336866f, -0.03314135f, -0.11545704f, -0.21998356f, 0.02864988f, -0.09704480f, 
    0.05685486f, 0.00633579f, 0.08846754f, -0.00704914f, -0.02030231f, -0.06272882f, 0.07845957f, 0.00034392f, 
    -0.03483302f, -0.00847221f, 0.00281811f, -0.09287550f, -0.00633885f, -0.04783897f, 0.06207032f, -0.07010274f, 
    0.15369575f, -0.10320346f, -0.00049164f, 0.02929443f, 0.01575818f, 0.04123227f, -0.07401140f, -0.17505763f, 
    0.01921356f, 0.04917465f, -0.03455907f, -0.01270275f, 0.07299914f, 0.07945424f, -0.02441178f, 0.01035771f, 
    0.01214742f, 0.01216917f, -0.02013189f, -0.06714322f, -0.12161936f, -0.00522244f, -0.03544648f, -0.07241883f, 
    0.05375439f, 0.02288405f, 0.06454799f, 0.04020645f, -0.10052322f, 0.23482171f, -0.01877359f, 0.03386973f, 
    0.04156686f, 0.03180189f, 0.07191038f, 0.08134864f, 0.00670900f, 0.00564735f, 0.07475132f, -0.16554806f, 
    0.03435772f, -0.12949955f, -0.23639773f, 0.08525804f, 0.03559783f, 0.04481367f, 0.00219681f, -0.04962241f, 
    -0.03621935f, -0.16666162f, 0.03290794f, 0.01806837f, -0.02143561f, -0.09649441f, -0.02381711f, 0.06880984f, 
    -0.05716494f, 0.13856445f, -0.05505041f, 0.03181171f, 0.05042717f, 0.02999493f, 0.07928598f, -0.09920763f, 
    -0.17419794f, -0.10549575f, -0.02768579f, 0.04257431f, 0.21010737f, 0.05564571f, -0.01715801f, 0.07850489f, 
    0.00575887f, -0.01818446f, -0.06716453f, -0.01180908f, 0.03210303f, -0.06643036f, 0.06181719f, -0.00273285f, 
    0.04763851f, 0.04692532f, 0.05003205f, 0.08107052f, 0.10240144f, -0.00621879f, -0.09563496f, 0.16991839f, 
    -0.02246367f, -0.11341177f, 0.10317804f, 0.05541702f, -0.08852482f, -0.04390829f, 0.08137690f, 0.06419528f, 
    -0.04191444f, -0.00719277f, -0.04136198f, 0.10309707f, -0.16404746f, -0.22308753f, 0.14924444f, 0.00676087f, 
    -0.20971034f, -0.00462333f, 0.08735233f, 0.05329167f, -0.00022303f, 0.09961427f, -0.09057042f, 0.05137124f, 
    0.03355618f, 0.04998032f, 0.16573489f, -0.02523763f, -0.12324958f, -0.01651657f, -0.13293950f, -0.08364832f, 
    -0.19852723f, 0.34533152f, 0.11700343f, 0.03172353f, 0.15014255f, -0.00296491f, 0.07498980f, -0.04560189f, 
    0.10865726f, -0.15081362f, 0.09728997f, 0.10059290f, -0.01730704f, -0.02915714f, -0.02774862f, 0.02706515f, 
    0.01546776f, 0.03944005f, -0.00745052f, 0.10994460f, 0.09151238f, 0.02202488f, -0.06505311f, 0.31785983f, 
    -0.13559131f, 0.15911119f, -0.05858314f, 0.11932875f, 0.00216057f, 0.19727013f, -0.04865442f, -0.01993364f, 
    0.10348163f, 0.02357476f, 0.01543652f, 0.06295466f, 0.11132096f, 0.03329334f, 0.08055437f, -0.13385855f, 
    -0.31118575f, 0.24484266f, 0.00653440f, -0.07429713f, 0.02192005f, 0.13447028f, -0.01303992f, 0.01703720f, 
    -0.04128543f, 0.03887437f, 0.07988936f, -0.02975081f, 0.05389528f, -0.03778445f, 0.13978493f, 0.05884499f, 
    -0.02168955f, 0.04722864f, -0.02426997f, 0.05856952f, -0.19001156f, 0.10700575f, 0.03829771f, -0.25891417f, 
    -0.08384174f, 0.01750061f, -0.03369230f, -0.08156066f, 0.02523129f, 0.01366614f, -0.05894043f, 0.05928474f, 
    0.09149874f, -0.09149548f, 0.02090935f, -0.05964973f, 0.09290556f, -0.00990541f, 0.11779830f, 0.04781271f, 
    -0.00443274f, 0.17935975f, 0.11888043f, -0.07230008f, 0.11115159f, -0.01896823f, 0.03533504f, 0.03899342f, 
    -0.03709043f, -0.06898604f, 0.03459826f, -0.02493968f, 0.06073852f, 0.02837281f, 0.04441991f, 0.00298812f, 
    -0.02484071f, 0.05961565f, -0.08843853f, -0.00747264f, 0.30818424f, -0.26001707f, -0.13342914f, 0.20031914f, 
    -0.20833752f, -0.07981785f, 0.00415349f, -0.09422481f, -0.09605264f, 0.13724469f, 0.01079136f, -0.01055480f, 
    -0.12950748f, 0.09434706f, 0.00675989f, -0.03656293f, -0.09626375f, 0.00492337f, 0.03403662f, 0.06247586f, 
    0.37522277f, -0.19029246f, 0.01469426f, 0.11637786f, -0.03467052f, -0.07935037f, 0.06723328f, -0.05682197f, 
    0.03700710f, 0.00323094f, -0.15193236f, -0.03575779f, -0.11379892f, -0.00294234f, 0.01150697f, 0.03195829f, 
    0.06962278f, 0.04847155f, 0.07123952f, 0.18326086f, 0.33726749f, -0.06779613f, -0.08589055f, 0.13886695f, 
    -0.11207205f, 0.05223696f, -0.01220663f, -0.11892202f, 0.00625961f, 0.06160353f, -0.07488655f, 0.06808639f, 
    -0.03048423f, -0.06912775f, 0.01086025f, 0.05722561f, -0.02254916f, 0.03900338f, -0.00915870f, 0.09764601f, 
    -0.39268404f, -0.24739933f, 0.01504115f, -0.27632925f, 0.33180121f, 0.05023544f, -0.01958649f, -0.07621717f, 
    -0.04222627f, 0.20186377f, -0.08959944f, -0.07828519f, 0.07653549f, -0.05812597f, -0.05366608f, 0.06991292f, 
    -0.06743453f, 0.02339451f, -0.00680574f, 0.08431368f, 0.14997773f, -0.10270229f, 0.01219136f, 0.05654781f, 
    -0.08851781f, -0.01696787f, 0.05425416f, -0.02992975f, 0.07045074f, 0.05387293f, -0.08580842f, 0.07109911f, 
    -0.01062766f, -0.02508942f, -0.06540491f, 0.11745130f, 0.04850055f, 0.02886154f, 0.08382890f, 0.10381824f, 
    -0.07763542f, -0.00823392f, -0.09391984f, 0.13916227f, 0.22914781f, 0.09347454f, -0.00401387f, -0.05719364f, 
    -0.07317292f, 0.09305641f, 0.16689941f, 0.01482963f, -0.01587212f, 0.01237926f, 0.16113889f, 0.02950875f, 
    0.05392250f, -0.05905820f, 0.06882617f, 0.07731893f, 0.08247932f, -0.11021784f, 0.22833468f, -0.30473369f, 
    0.00871355f, 0.05824221f, -0.00364376f, -0.02367239f, -0.01213834f, -0.05880194f, -0.02902009f, 0.01090570f, 
    0.05583279f, 0.08188042f, -0.02658610f, -0.02084048f, 0.11418115f, 0.00703435f, -0.11842056f, -0.08783995f, 
    -0.01409948f, -0.12125679f, -0.10421770f, -0.11871615f, -0.09235849f, 0.18558358f, 0.08468040f, 0.00185186f, 
    -0.11034217f, -0.09487896f, 0.04594139f, -0.09084775f, 0.07740974f, 0.05416990f, 0.03700147f, 0.05526635f, 
    0.01634574f, 0.07801553f, -0.12789737f, -0.09134360f, 0.51550567f, 0.21931075f, 0.02222344f, 0.02234011f, 
    -0.15638563f, -0.01761522f, 0.02890866f, -0.10630173f, 0.02527211f, 0.05757429f, 0.03986717f, 0.10335446f, 
    -0.08268807f, 0.01143272f, -0.06019882f, 0.05886054f, -0.04044182f, -0.04957661f, 0.00788826f, -0.04014438f, 
    -0.38686797f, 0.06704824f, 0.22763358f, -0.13530089f, 0.26346096f, 0.03059974f, 0.05401161f, 0.03621735f, 
    -0.03287305f, -0.10688448f, 0.04498034f, 0.04034205f, -0.02657481f, -0.05981787f, 0.04607733f, 0.04694844f, 
    -0.03471328f, 0.08853186f, -0.02507567f, -0.01421954f, -0.03521443f, 0.06298062f, 0.05736658f, -0.30974194f, 
    -0.24608079f, -0.03632966f, -0.03871926f, 0.04234866f, -0.00013898f, 0.09953064f, -0.14491843f, -0.08225065f, 
    -0.02029429f, -0.01803743f, 0.05886495f, 0.05532353f, -0.01289080f, -0.18555966f, -0.03978493f, -0.00232957f, 
    0.08399753f, -0.23658666f, 0.03949220f, -0.38764137f, -0.16591430f, 0.02856458f, 0.07204913f, -0.10995431f, 
    -0.01144257f, 0.06849107f, 0.04274783f, 0.07813978f, 0.02201391f, 0.03970000f, -0.03829091f, -0.05282627f, 
    0.06639647f, 0.09916794f, -0.03440186f, 0.03752436f, 0.22838904f, -0.07353298f, -0.17730187f, 0.12172699f, 
    -0.15106401f, -0.01354480f, 0.04894352f, -0.01479943f, 0.09877973f, -0.12726632f, -0.09878795f, 0.05256705f, 
    0.10107867f, 0.08115527f, 0.05056138f, 0.04523783f, -0.06202520f, -0.03709979f, -0.03178499f, 0.12054792f, 
    0.36431992f, -0.11664079f, 0.01076064f, 0.19350556f, -0.05892885f, 0.01366406f, -0.02372224f, 0.05799280f, 
    0.00982425f, 0.19776557f, 0.01717315f, 0.00510346f, 0.01334328f, -0.09466577f, -0.16812658f, -0.04696782f, 
    0.02032899f, -0.06345873f, -0.06012356f, 0.02279754f, 0.43216604f, -0.20350011f, 0.00027641f, 0.11082703f, 
    0.25233707f, 0.00841489f, 0.03100105f, -0.02469219f, 0.07572139f, -0.00523256f, 0.01117307f, 0.06448950f, 
    0.03046744f, -0.00541704f, 0.00210713f, 0.09240516f, -0.06588984f, 0.01704002f, -0.02559462f, -0.11665712f, 
    0.21848297f, 0.22404721f, -0.09288841f, -0.08642526f, -0.21406819f, 0.02848820f, 0.00959896f, 0.01180719f, 
    0.03981264f, 0.07326862f, 0.01140043f, 0.00446879f, 0.10770759f, -0.05809586f, 0.05754388f, 0.04136936f, 
    0.07629821f, -0.01910803f, 0.00187077f, 0.02680821f, -0.00657416f, 0.13552302f, 0.07683787f, 0.21831740f, 
    -0.09252784f, 0.10654508f, -0.07011992f, -0.00832884f, -0.05739441f, 0.15950149f, -0.08186099f, -0.13082878f, 
    0.00270536f, 0.00196114f, 0.10361231f, 0.05710119f, -0.04131014f, -0.07472885f, -0.01517419f, -0.14862314f, 
    0.34666869f, -0.30101874f, -0.08344889f, 0.06858502f, 0.11635858f, -0.04546171f, 0.11987125f, -0.02805315f, 
    0.19275175f, -0.02070473f, -0.04340111f, 0.00427674f, 0.03566794f, 0.04767225f, 0.03358547f, 0.09958757f, 
    0.03598756f, 0.04694171f, -0.07167820f, 0.00660766f, 0.37433827f, 0.04573586f, -0.10148244f, -0.04836995f, 
    -0.13756786f, 0.01611986f, 0.07814533f, -0.05456690f, 0.02247262f, -0.05830606f, -0.03029860f, 0.05372490f, 
    -0.10544528f, -0.07284723f, -0.02440968f, -0.10157515f, 0.03280882f, -0.06349803f, 0.00878628f, 0.02566366f, 
    -0.26581034f, -0.00656658f, 0.24858557f, -0.22553957f, 0.27302307f, 0.02036800f, 0.04850863f, 0.01748179f, 
    -0.01750351f, -0.01515760f, -0.14077239f, 0.01939030f, 0.02552071f, 0.12205952f, 0.02490970f, 0.02747512f, 
    0.00631783f, -0.06683262f, 0.05091923f, -0.02763052f, 0.36728776f, 0.13436514f, 0.00449121f, 0.11036463f, 
    0.01635895f, -0.06195183f, 0.09493554f, -0.04202025f, 0.05778452f, 0.01835860f, 0.06283416f, 0.01786896f, 
    0.06079225f, -0.00413240f, 0.01750358f, -0.02216918f, 0.03774335f, -0.01738849f, -0.06902875f, 0.00618353f, 
    -0.17894490f, 0.14759691f, -0.04830652f, 0.00235046f, 0.04365738f, 0.07162064f, 0.04624071f, 0.13775523f, 
    -0.05761849f, 0.07131242f, 0.02484487f, -0.05535161f, -0.04389868f, 0.00743858f, 0.08378538f, 0.06693315f, 
    0.09591119f, -0.10205971f, -0.10160633f, 0.01203962f, 0.34477195f, 0.06517485f, -0.17967845f, -0.02721707f, 
    0.21622485f, -0.05643845f, -0.06472317f, -0.12150556f, 0.13614601f, 0.05179843f, -0.09187037f, -0.01289768f, 
    0.08434019f, 0.10467733f, 0.07552662f, 0.01817810f, -0.00725488f, -0.10326871f, -0.10741960f, 0.10005894f, 
    -0.36905605f, -0.08029204f, -0.21243459f, -0.05108622f, -0.11905774f, 0.12637196f, -0.06269766f, 0.05886872f, 
    -0.06917752f, -0.03839809f, -0.08770320f, -0.01123238f, -0.03925293f, 0.08171140f, 0.07601635f, 0.02630450f, 
    0.08213737f, -0.11277663f, -0.11923702f, 0.03209117f, 0.15131378f, 0.17243791f, -0.22201622f, -0.21117307f, 
    -0.10998248f, 0.17760180f, 0.17608646f, -0.13011386f, -0.02926668f, -0.06708514f, 0.07951353f, 0.15736450f, 
    0.02909376f, -0.08229077f, -0.14131404f, 0.07601137f, 0.03837683f, 0.24175222f, 0.11842545f, 0.05849931f, 
    -0.26945105f, -0.05880804f, -0.03347139f, -0.02422297f, 0.13238794f, -0.04659776f, -0.00002182f, 0.11966614f, 
    0.00159059f, 0.04296466f, 0.01686032f, 0.06408559f, 0.15202676f, 0.03085468f, 0.09040315f, -0.11848463f, 
    0.10110850f, -0.04526218f, 0.05268402f, -0.06041040f, -0.22168842f, 0.13199088f, -0.02872512f, -0.06627882f, 
    -0.08282305f, 0.08033691f, 0.12698956f, 0.00162606f, 0.02324174f, -0.03584230f, 0.02177937f, 0.03700344f, 
    -0.07609733f, -0.10062767f, -0.04703098f, 0.16288753f, 0.22150148f, 0.15890302f, 0.11340754f, 0.08459044f, 
    -0.31031802f, -0.18105610f, 0.00584762f, 0.04597866f, 0.01335374f, -0.00220739f, -0.03264447f, -0.01503727f, 
    -0.04038246f, 0.05609564f, -0.04263592f, -0.07267779f, -0.00418832f, 0.00582042f, -0.03380801f, 0.00521099f, 
    -0.04982895f, -0.07177659f, -0.05663640f, -0.00750550f, 0.04613820f, -0.12055033f, 0.19874015f, -0.22899218f, 
    0.17053123f, -0.13639486f, -0.08758191f, -0.10786779f, 0.10518784f, -0.06198699f, -0.02413762f, -0.03565219f, 
    0.02177804f, 0.04668749f, -0.00973760f, -0.01222746f, 0.02419493f, -0.00410183f, -0.01152175f, 0.14957507f, 
    0.19891566f, 0.15096390f, -0.05554282f, 0.11157196f, 0.08652225f, 0.09328178f, 0.02310470f, -0.06778561f, 
    0.06742680f, -0.06640923f, -0.04267481f, 0.00253462f, -0.01079463f, 0.07831097f, 0.05099697f, -0.08425067f, 
    0.05033255f, 0.10281868f, 0.01936196f, -0.05524866f, 0.00767239f, 0.06508142f, -0.09853178f, -0.09058496f, 
    0.01337687f, -0.02887535f, 0.02825577f, 0.04036248f, -0.01514110f, -0.00382612f, 0.04447429f, 0.04589498f, 
    0.00645838f, -0.00674497f, -0.04444056f, 0.09638782f, -0.02001284f, 0.09876584f, 0.07061984f, 0.03581774f, 
    -0.11320009f, -0.18808736f, -0.04971668f, 0.02520108f, -0.11211106f, -0.03805890f, -0.00380126f, 0.02859388f, 
    0.04918366f, 0.03557431f, 0.01811654f, -0.04732369f, 0.04494152f, 0.01625404f, -0.00682347f, -0.00951907f, 
    -0.02627682f, 0.11363239f, -0.06521893f, 0.02091121f, 0.37257603f, 0.14865671f, -0.00993420f, -0.09674963f, 
    0.08037069f, -0.02990429f, 0.18795452f, 0.09064158f, -0.03037499f, 0.08138079f, -0.08893256f, -0.01881966f, 
    0.17004077f, -0.01419031f, 0.05000154f, -0.01824794f, 0.13374400f, -0.05739047f, 0.04101929f, -0.04131882f, 
    0.38717967f, 0.19904394f, 0.01306565f, -0.20743811f, -0.07800660f, 0.04085963f, -0.00018655f, 0.03124334f, 
    0.02853808f, -0.02548044f, -0.01294312f, -0.05058555f, -0.06860965f, -0.09031191f, -0.02083110f, -0.07358738f, 
    -0.00068120f, -0.01296067f, 0.15799573f, -0.08314622f, 0.30995798f, 0.00622676f, 0.12691398f, -0.03195694f, 
    0.08175149f, -0.12591255f, -0.11875723f, 0.00820572f, 0.03953961f, 0.05648071f, -0.06382164f, -0.10048532f, 
    -0.04093554f, 0.00391855f, -0.03768005f, -0.09215079f, 0.04325804f, -0.06651682f, 0.00981015f, -0.03239110f, 
    0.47087783f, 0.23933175f, -0.28437570f, -0.00951436f, 0.22543116f, -0.04233314f, -0.03807741f, 0.02048592f, 
    0.05977929f, 0.09699490f, 0.15971091f, 0.00089633f, -0.04407708f, 0.02958632f, -0.11407393f, 0.08875376f, 
    -0.02461419f, -0.03343381f, -0.05927346f, 0.08767827f, 0.10042901f, 0.12568466f, 0.01410508f, -0.08204757f, 
    -0.20007952f, 0.01277769f, 0.09026910f, 0.08569256f, -0.03290882f, 0.05875047f, -0.00028330f, -0.02930744f, 
    -0.07955890f, -0.11334529f, -0.02168473f, -0.01930760f, 0.03415827f, 0.04499559f, 0.17409994f, 0.02759813f, 
    0.28663877f, 0.15502091f, -0.01306412f, 0.26841396f, -0.19831420f, -0.03787843f, 0.07314982f, -0.15807267f, 
    0.02021523f, 0.06490118f, -0.15678811f, -0.06827544f, 0.03796649f, 0.08978058f, -0.00158282f, 0.07798944f, 
    0.00170893f, -0.02157526f, 0.05116626f, 0.03941901f, -0.22857334f, -0.06487921f, -0.13006037f, -0.09460359f, 
    0.09271724f, 0.10149830f, 0.10506637f, 0.05140262f, -0.03348357f, -0.04407708f, 0.10422505f, 0.14094163f, 
    0.10510550f, -0.06665552f, -0.05106382f, -0.02182174f, 0.03008655f, 0.03952305f, -0.02721647f, -0.06778570f, 
    0.05800669f, 0.25984281f, -0.12582515f, -0.04021636f, 0.16868633f, -0.04089421f, 0.06211187f, -0.06572590f, 
    0.11060752f, 0.09016741f, 0.07611573f, 0.02691025f, 0.02215120f, 0.09347837f, 0.00826723f, 0.04107857f, 
    0.04531716f, -0.10896621f, 0.06383971f, -0.01559995f, 0.27175364f, -0.29839933f, 0.10714542f, 0.00330481f, 
    0.20217000f, -0.15671891f, -0.07003392f, -0.04985914f, 0.08775044f, 0.12230348f, -0.06050789f, 0.01497580f, 
    0.08547260f, 0.07413565f, -0.00611550f, -0.13896763f, -0.04468504f, -0.03227175f, 0.07563888f, 0.01883487f, 
    -0.08290694f, -0.07209182f, -0.05254393f, 0.01051167f, -0.35461575f, 0.01746863f, 0.02843770f, 0.08170195f, 
    0.03479384f, -0.01323814f, 0.03183199f, 0.09099101f, -0.01322850f, 0.06658190f, 0.00037428f, -0.02078510f, 
    -0.01911440f, 0.09420799f, -0.12159344f, -0.07110874f, -0.35959324f, -0.01244298f, -0.01617240f, -0.13844612f, 
    -0.01851103f, 0.08406539f, 0.14512521f, -0.00007633f, 0.04899815f, 0.04426417f, 0.07330136f, 0.09556074f, 
    -0.04820541f, -0.09908661f, -0.03773692f, 0.04973907f, 0.02888703f, 0.01046428f, -0.02581273f, 0.10268813f, 
    -0.05561063f, 0.14303924f, -0.02104049f, 0.00952688f, 0.13558266f, 0.15891358f, 0.03836480f, 0.00661954f, 
    -0.03054626f, -0.00102236f, 0.06195313f, 0.06913100f, -0.17838664f, -0.07734554f, -0.09749247f, 0.13921578f, 
    0.09842501f, -0.00354698f, 0.05569888f, 0.08376016f, 0.04404277f, -0.14602274f, 0.01324687f, 0.10082763f, 
    -0.10167107f, -0.17468190f, -0.04483577f, 0.01303637f, -0.04574413f, -0.07928075f, -0.07694384f, 0.05303149f, 
    0.03627426f, -0.00740054f, -0.00348712f, 0.07272976f, 0.02908712f, -0.03486970f, 0.13092446f, 0.00233933f, 
    0.32110685f, -0.08142428f, 0.22131132f, -0.06627068f, 0.07528193f, -0.10532188f, -0.10367989f, 0.01921993f, 
    0.06790005f, -0.11405735f, 0.07155649f, -0.05719728f, -0.13400616f, 0.11331292f, -0.00475843f, 0.04735187f, 
    0.01973988f, 0.06092672f, -0.00865777f, 0.19802102f, 0.33774263f, 0.05623439f, -0.16911000f, 0.01084466f, 
    0.15626375f, -0.03509227f, -0.05454109f, -0.06573036f, 0.00944740f, 0.07546443f, -0.03960481f, 0.02728858f, 
    -0.01684774f, 0.03896961f, 0.10117065f, 0.05357223f, 0.04630315f, 0.00436061f, -0.10859890f, 0.00232719f, 
    0.08244304f, -0.12998886f, 0.19621518f, -0.30266318f, 0.12948728f, 0.03992263f, 0.03305753f, 0.02123750f, 
    0.00923868f, -0.10302987f, -0.05819798f, -0.08945820f, -0.05802605f, -0.08359049f, -0.10485549f, -0.00807959f, 
    -0.06811399f, 0.05552002f, 0.03901173f, 0.05714973f, -0.05423988f, -0.20289284f, 0.05411587f, 0.01001157f, 
    0.09006366f, -0.01096367f, -0.08401061f, -0.09657548f, 0.07399292f, -0.02303886f, -0.03252552f, -0.05218019f, 
    -0.07019018f, 0.09447818f, -0.06104356f, 0.08183093f, -0.05656596f, 0.05828111f, 0.02371093f, 0.07613802f, 
    -0.09024042f, 0.17948490f, -0.16701330f, -0.13142768f, -0.06503347f, 0.02808543f, 0.02495090f, -0.02140854f, 
    -0.03894933f, -0.09041681f, -0.07801516f, -0.00422843f, 0.01176798f, -0.00162562f, 0.04524251f, 0.11769231f, 
    0.00000787f, 0.12343813f, 0.23094381f, 0.05662281f, 0.04416348f, -0.07010284f, 0.09291188f, -0.02809972f, 
    0.04511642f, -0.10711868f, 0.03679675f, -0.00990140f, -0.01099084f, 0.08838801f, -0.01382676f, -0.11853134f, 
    0.00144446f, 0.06102262f, -0.01078444f, -0.05523154f, 0.03074061f, -0.04272502f, -0.00787129f, -0.02872013f, 
    -0.17313839f, -0.13806573f, -0.14108066f, 0.10621306f, 0.03240287f, 0.08181527f, 0.03835055f, 0.06071920f, 
    -0.04288375f, -0.06600565f, -0.00166980f, 0.00981316f, -0.00705627f, -0.00584579f, 0.12815079f, 0.05402292f, 
    0.09505852f, 0.03384896f, -0.14714198f, 0.05399873f, -0.05651735f, -0.12452664f, 0.20151533f, 0.11638604f, 
    0.11189695f, -0.00032806f, -0.06771358f, 0.15787208f, 0.06053842f, 0.18226996f, -0.03028703f, -0.01862339f, 
    0.03863663f, 0.05436445f, 0.10044063f, 0.00606119f, 0.10165131f, -0.13323072f, -0.06016418f, 0.01501456f, 
    -0.02846622f, -0.02204310f, -0.01359470f, -0.02598057f, -0.02330191f, -0.03585222f, 0.02799601f, 0.00924106f, 
    0.01535758f, -0.00500757f, -0.00963897f, -0.02786878f, -0.00222042f, -0.02441623f, -0.02957502f, -0.00468693f, 
    0.02671121f, -0.01357243f, -0.00450951f, -0.04194604f, -0.03757014f, 0.01230805f, 0.00059747f, -0.04108691f, 
    -0.02482195f, 0.00287956f, -0.04048349f, -0.02290617f, -0.02489435f, 0.02128259f, -0.02742059f, -0.02221335f, 
    0.00475234f, -0.02837749f, 0.03600257f, 0.01778918f, -0.02243607f, 0.01417290f, 0.00037574f, -0.01287717f, 
    0.01704607f, -0.02564592f, -0.02445469f, -0.04039423f, 0.02629910f, -0.02197580f, -0.00389203f, 0.00653210f, 
    -0.04267527f, 0.00735693f, -0.04072138f, 0.02329348f, -0.03392865f, -0.02104869f, 0.03210926f, 0.01006204f, 
    -0.03656994f, -0.03312383f, 0.02682937f, 0.00486491f, -0.04513618f, -0.03466607f, -0.01945706f, -0.01254976f, 
    -0.04383353f, -0.00000321f, 0.00629576f, 0.03016508f, -0.04374773f, -0.01166705f, -0.02104666f, -0.01754305f, 
    0.00543019f, 0.00604740f, -0.00810078f, 0.00718615f, -0.00350629f, -0.00560339f, -0.01028585f, -0.04240549f, 
    -0.00281736f, 0.00784607f, -0.01575223f, -0.01361886f, 0.00971616f, 0.03177566f, -0.01257756f, -0.04481300f, 
    -0.00385487f, -0.04215669f, 0.02109869f, 0.02677785f, 0.00847701f, 0.00111457f, -0.04016146f, 0.00660458f, 
    -0.04162133f, 0.03188377f, 0.01221156f, -0.02514585f, 0.02094552f, -0.02647358f, 0.00240693f, 0.00108185f, 
    0.02881865f, -0.03355154f, -0.00470773f, 0.01231034f, -0.03860689f, 0.02724373f, 0.00443740f, 0.03063854f, 
    0.02110719f, 0.01085543f, -0.03141817f, 0.00268737f, 0.00164601f, 0.02043586f, -0.03421639f, -0.02365416f, 
    0.01697920f, -0.04469797f, 0.01627840f, -0.03078604f, 0.01529303f, 0.00766700f, 0.00413127f, -0.01979562f, 
    -0.03132740f, 0.02435290f, -0.00148426f, -0.01358468f, 0.02788990f, -0.03686647f, 0.01852389f, 0.01946930f, 
    0.03109776f, -0.02528935f, -0.03730468f, 0.02534726f, 0.00693813f, 0.01371724f, -0.01433548f, -0.00838296f, 
    -0.03221143f, 0.01654371f, -0.02811784f, -0.02213508f, -0.02728885f, 0.01585284f, 0.01495192f, -0.04397232f, 
    -0.01274300f, 0.02534453f, -0.02518988f, -0.03986660f, -0.02734489f, -0.00393678f, -0.01322579f, 0.02528092f, 
    -0.04031221f, -0.02723790f, -0.01222807f, 0.00033040f, -0.02483088f, 0.01347574f, 0.03091396f, -0.02033581f, 
    0.02179602f, -0.02784129f, -0.01716593f, -0.01700096f, -0.00672170f, 0.00126416f, 0.00539716f, -0.04009755f, 
    0.01964765f, -0.01771826f, -0.02481174f, -0.00893387f, -0.03164296f, 0.00503809f, 0.01147960f, 0.02467684f, 
    -0.02641684f, -0.04536328f, 0.01030145f, -0.00935166f, 0.01136582f, 0.00468929f, -0.03930188f, -0.00643326f, 
    -0.04077042f, -0.00237860f, -0.03344087f, 0.00202147f, 0.00196519f, 0.02657973f, -0.00934363f, 0.01069129f, 
    -0.03359674f, -0.01447242f, -0.02474244f, 0.02020795f, 0.00523047f, 0.03079758f, -0.00922487f, 0.03192959f, 
    0.02186401f, -0.01557997f, -0.04486414f, -0.02781660f, 0.00661788f, -0.00608975f, -0.04293751f, 0.02408857f, 
    0.02738287f, -0.02965903f, -0.01980088f, 0.01776335f, -0.03249294f, 0.00811854f, 0.02801752f, 0.01018921f, 
    -0.01478223f, -0.01990763f, 0.02016891f, 0.00205365f, -0.01443005f, -0.00901881f, -0.00533154f, -0.01003064f, 
    -0.00430744f, 0.02514612f, -0.02202956f, -0.00201083f, -0.04091441f, -0.01171081f, 0.03079715f, -0.03665766f, 
    -0.03714607f, 0.02159554f, -0.00523998f, 0.02587065f, -0.03485120f, 0.02397993f, -0.00826200f, 0.02611350f, 
    0.00681860f, -0.04083140f, -0.01198431f, 0.01115392f, 0.01982204f, -0.01829141f, 0.01577281f, 0.02079512f, 
    0.02526897f, 0.00015801f, -0.01391265f, 0.01045898f, -0.02991590f, -0.01541438f, -0.01051549f, -0.01469009f, 
    -0.00887938f, 0.01211378f, 0.00821802f, -0.01049575f, 0.01306592f, -0.01858324f, -0.03621156f, -0.02398792f, 
    -0.02037265f, -0.01224680f, -0.03037916f, 0.03025747f, 0.02457909f, -0.01166377f, 0.02857073f, -0.01018666f, 
    0.02675021f, -0.03854913f, 0.02684945f, -0.03549186f, 0.02512028f, -0.00795312f, 0.02571070f, -0.04130537f, 
    -0.04096281f, -0.03173681f, 0.01509775f, 0.01035608f, -0.04283701f, 0.01639382f, 0.01852398f, 0.02995430f, 
    -0.00784199f, -0.04537199f, 0.02779174f, -0.04470036f, -0.02655028f, -0.04272170f, 0.02602892f, 0.01849616f, 
    0.02452529f, 0.00849158f, 0.03346178f, -0.02863221f, -0.01371180f, -0.01588764f, -0.00143423f, 0.00067821f, 
    -0.00882360f, -0.04082129f, -0.00158711f, -0.04387731f, -0.02881504f, -0.01037620f, -0.00078780f, 0.00521917f, 
    -0.00232803f, 0.02665085f, 0.00309368f, -0.04152708f, 0.03324815f, -0.02630625f, -0.04102037f, -0.01407366f, 
    -0.03751944f, -0.00607074f, 0.02682851f, -0.01423378f, -0.03785335f, 0.00842591f, 0.02596793f, -0.03512793f, 
    0.00297487f, 0.02150927f, -0.00846149f, 0.00323735f, 0.01383159f, -0.03046320f, -0.02550255f, -0.01475149f, 
    0.03228189f, 0.02252226f, 0.03168480f, 0.02165176f, -0.03539834f, 0.02887112f, 0.03082670f, 0.00301702f, 
    -0.01772418f, 0.03179793f, -0.00271064f, 0.00997385f, 0.00853590f, 0.00044401f, -0.00530120f, -0.01773992f, 
    -0.02793840f, -0.00848183f, -0.03432938f, -0.03521214f, -0.02716845f, -0.00107751f, -0.02513586f, -0.01827812f, 
    0.02700209f, -0.02483105f, -0.01790892f, -0.03193270f, -0.03470488f, 0.01121113f, 0.03181028f, -0.00854048f, 
    -0.03954571f, 0.01479003f, -0.03668291f, 0.02110507f, 0.00765325f, 0.03142261f, -0.04031624f, -0.01170952f, 
    -0.00243357f, 0.02316325f, -0.03422145f, 0.02348215f, -0.04528455f, -0.03325235f, -0.04447517f, -0.03711806f, 
    0.02243212f, -0.03079475f, 0.01086236f, -0.04267596f, 0.00545309f, -0.02020527f, 0.02894980f, 0.00762404f, 
    0.03260647f, -0.03375841f, 0.03287176f, 0.01295974f, -0.01513235f, -0.00076007f, -0.03947207f, 0.02946568f, 
    -0.01901349f, -0.03492185f, 0.02775251f, 0.02678892f, -0.03857283f, 0.02471409f, 0.00419277f, 0.02941521f, 
    -0.01151762f, -0.02821587f, 0.03138383f, -0.04460575f, -0.04327583f, 0.00001616f, 0.03193733f, -0.03270706f, 
    -0.00668682f, 0.01026524f, 0.00857462f, -0.01415831f, 0.01030033f, 0.00498982f, 0.00471328f, -0.00392578f, 
    -0.02222031f, 0.02958341f, -0.02210190f, -0.03386200f, 0.03328729f, -0.04352021f, -0.00837944f, -0.01208623f, 
    0.01812668f, 0.02099435f, -0.02515586f, -0.03230783f, 0.01661741f, -0.00161582f, 0.00130592f, -0.00816207f, 
    -0.03163129f, -0.04326005f, 0.02513130f, -0.04464860f, -0.01463490f, 0.02709197f, -0.02633877f, -0.01210440f, 
    0.01221551f, -0.04518392f, 0.01106313f, 0.01163378f, -0.01090614f, 0.02588779f, -0.02108412f, -0.04247884f, 
    -0.00237740f, -0.00741093f, 0.00439576f, 0.00716174f, 0.01750429f, 0.00090397f, -0.03865163f, 0.02201334f, 
    -0.03157616f, 0.02419393f, -0.03995357f, -0.00312403f, -0.02872401f, -0.01168806f, -0.03437191f, 0.02535943f, 
    -0.01954378f, -0.02370030f, 0.00513589f, -0.02650910f, 0.01791906f, -0.01338253f, -0.01452282f, 0.01727576f, 
    0.02433848f, -0.00095853f, -0.02250735f, 0.03078799f, 0.02783643f, -0.01842804f, 0.01233288f, -0.01035724f, 
    0.02231476f, -0.02000966f, -0.00756816f, 0.02658960f, -0.02432372f, -0.04210138f, 0.01201191f, 0.00564531f, 
    0.02994555f, -0.02348643f, -0.03101960f, 0.01802486f, 0.00162246f, -0.00153586f, -0.01659715f, -0.00291779f, 
    0.01962788f, -0.00466451f, -0.04275834f, -0.00467307f, -0.02128184f, -0.01424891f, 0.03069034f, 0.03078752f, 
    -0.04547437f, -0.04062072f, -0.03598377f, -0.00162506f, 0.01946114f, 0.01932018f, -0.02572037f, -0.04441854f, 
    0.03143177f, -0.00249362f, -0.04270217f, -0.02411125f, -0.01577324f, -0.00026861f, 0.02113679f, -0.01531890f, 
    0.00954964f, -0.01791736f, 0.01266256f, -0.01692834f, -0.03591136f, 0.03274219f, -0.02984045f, -0.03438525f, 
    -0.01440736f, -0.00447849f, 0.02578133f, -0.02985048f, -0.03441219f, 0.00317573f, -0.01146255f, -0.04427229f, 
    0.03051426f, 0.01382794f, -0.04381151f, -0.03141787f, 0.01463354f, 0.02466645f, -0.00674480f, -0.04245967f, 
    0.01396408f, -0.02900985f, -0.02358389f, -0.01657627f, -0.02313272f, 0.00585718f, -0.00196121f, -0.03667925f, 
    -0.03007349f, -0.00932796f, 0.00743617f, 0.02182080f, -0.00883358f, -0.02384582f, -0.00856013f, 0.01827327f, 
    -0.02292347f, -0.00270051f, -0.04495761f, -0.02676925f, -0.01988805f, 0.00040642f, -0.02830850f, 0.01912452f, 
    -0.00672694f, 0.03128688f, 0.01459764f, 0.00413809f, -0.03017671f, -0.04322405f, -0.03402834f, -0.01257493f, 
    -0.01919133f, 0.01551524f, 0.02488765f, 0.01163566f, 0.01850420f, 0.01387367f, -0.01603004f, 0.00412505f, 
    0.01879995f, 0.00445505f, 0.02008031f, 0.01107771f, -0.00666471f, -0.01787199f, 0.01639050f, 0.01286187f, 
    -0.01473857f, -0.03426101f, 0.00809446f, 0.00950100f, 0.02489047f, 0.00696309f, -0.00900435f, -0.03812278f, 
    0.00909814f, 0.00214428f, 0.02976081f, -0.04349391f, 0.00232882f, 0.01523758f, 0.02523945f, -0.02995310f, 
    0.00032743f, 0.00207266f, -0.00089845f, -0.02260016f, -0.03331064f, 0.03148793f, -0.00475321f, 0.01348549f, 
    -0.02479307f, 0.02052935f, -0.04237057f, -0.02815129f, -0.02415648f, -0.02012511f, -0.00893008f, -0.02855077f, 
    0.03994271f, -0.02586543f, 0.20980033f, 0.08463649f, 0.13659270f, -0.08426788f, -0.10886946f, 0.00833779f, 
    -0.01077337f, 0.04773932f, 0.05756827f, 0.05290722f, 0.08249021f, -0.02156824f, 0.06539406f, -0.03913444f, 
    -0.00536379f, 0.00828620f, 0.02514814f, -0.00940798f, -0.01399368f, 0.01607187f, 0.01384465f, -0.13554367f, 
    -0.22879805f, 0.09261372f, 0.13829343f, 0.19629842f, -0.04315257f, 0.06513017f, 0.00903184f, 0.05579830f, 
    -0.01562117f, -0.10042639f, -0.08500204f, 0.03394005f, 0.06798027f, 0.04776544f, 0.02126751f, 0.00017592f, 
    0.37571391f, 0.15313073f, 0.30664411f, 0.14240500f, 0.15733676f, -0.16138446f, 0.06852585f, -0.03825340f, 
    0.08390696f, 0.08288205f, 0.08609645f, 0.01794704f, 0.09342039f, -0.02191457f, 0.02790544f, 0.13069347f, 
    0.08761283f, 0.05322424f, 0.05155865f, 0.04149820f, -0.18776162f, -0.34140414f, 0.27242437f, 0.35881501f, 
    0.04054982f, -0.14744930f, -0.00588092f, 0.13217954f, 0.07197767f, -0.03731292f, -0.05257274f, -0.07554138f, 
    -0.01264835f, 0.09269882f, 0.19804958f, -0.13158208f, 0.06642332f, -0.14282168f, 0.01554338f, -0.02384431f, 
    0.26121429f, -0.09219790f, 0.11678679f, -0.01010161f, -0.01793206f, -0.03918060f, 0.01949573f, -0.03934688f, 
    -0.04538051f, 0.01649824f, -0.04306179f, -0.00334810f, -0.07128780f, 0.05462601f, -0.01580103f, 0.11264958f, 
    -0.05090319f, -0.00426371f, 0.03114295f, 0.04509985f, 0.13207759f, -0.19723140f, 0.13357525f, 0.19288000f, 
    -0.02654880f, -0.05166228f, -0.03437514f, 0.02152346f, 0.07189918f, 0.01142165f, -0.05939541f, 0.01898869f, 
    0.09994092f, 0.11092797f, 0.08809191f, -0.07823421f, -0.08526446f, -0.04948109f, 0.05943732f, -0.00221311f, 
    0.12046545f, 0.09396283f, 0.01966128f, 0.06871294f, 0.13802558f, 0.03912955f, -0.01800784f, -0.05980683f, 
    0.09760439f, -0.05507108f, 0.05962695f, 0.08587886f, 0.06346905f, 0.02966532f, 0.08587444f, 0.09685294f, 
    0.08339614f, 0.07142176f, 0.00940422f, 0.02387486f, -0.02615927f, -0.01051355f, -0.32692823f, 0.05161278f, 
    -0.13065422f, 0.08894170f, 0.14823271f, 0.08747777f, 0.03516692f, 0.15898007f, 0.10371994f, 0.03772841f, 
    0.03795012f, -0.02239287f, -0.02326774f, 0.07166670f, 0.07334145f, 0.02006471f, 0.01164263f, -0.00107758f, 
    -0.12501551f, -0.23436862f, 0.05838862f, -0.06959746f, 0.02375548f, -0.01169584f, 0.03612608f, 0.12386188f, 
    -0.09197853f, 0.06631314f, -0.00275251f, 0.05620731f, -0.03824186f, 0.03898492f, 0.00419348f, 0.13220651f, 
    -0.01052610f, 0.04338061f, -0.06108792f, 0.08570951f, -0.16699873f, 0.00308292f, 0.15181649f, 0.07887934f, 
    -0.04362898f, 0.01101297f, 0.02512897f, 0.00506226f, 0.05029671f, 0.05920586f, 0.01554458f, 0.01954119f, 
    0.05163319f, -0.00729635f, 0.01949885f, -0.09889296f, -0.00297442f, -0.06359111f, -0.00094675f, -0.05494561f, 
    -0.00281723f, 0.00103691f, 0.08031774f, -0.00848055f, 0.14420673f, 0.05861940f, 0.05081991f, -0.00757683f, 
    0.04212378f, -0.06810967f, -0.00676943f, -0.01497307f, -0.03499616f, -0.02457790f, 0.04159836f, 0.15632068f, 
    0.06467626f, -0.00009227f, -0.02186037f, -0.00821530f, -0.50400108f, -0.20008595f, 0.07811132f, 0.10594168f, 
    -0.14834067f, -0.01406790f, -0.09131067f, -0.09047122f, 0.02625176f, -0.00271703f, 0.07238269f, 0.01131431f, 
    -0.04245769f, 0.02049460f, 0.05871160f, -0.07220273f, -0.05614752f, 0.09242181f, -0.02493783f, -0.03181263f, 
    -0.33243594f, -0.24138212f, -0.23610359f, 0.22840030f, 0.15260532f, 0.01423494f, 0.07085609f, -0.00161021f, 
    0.11777858f, 0.07732590f, 0.02526363f, 0.04326612f, 0.03567772f, 0.01569354f, 0.00256440f, 0.02349399f, 
    0.04506169f, -0.03020320f, -0.00976223f, 0.12720238f, -0.17567807f, 0.10846991f, -0.18327864f, -0.13115230f, 
    -0.09400726f, 0.09633829f, 0.18534057f, 0.03699023f, 0.03184825f, 0.06588791f, 0.13099423f, 0.07942640f, 
    0.04690283f, -0.02355676f, 0.09536295f, 0.12032403f, 0.00054817f, 0.01702037f, 0.06636193f, 0.03139002f, 
    -0.42612961f, 0.11987250f, 0.26408496f, -0.15792862f, -0.03807840f, 0.02378302f, -0.00230063f, 0.03273683f, 
    -0.13094074f, 0.03380911f, -0.15008107f, 0.05616545f, -0.11887160f, 0.07922815f, 0.01604811f, -0.06174651f, 
    0.04275649f, 0.08698662f, -0.02376481f, -0.07218504f, -0.04286200f, -0.16686372f, -0.17465742f, 0.09361770f, 
    0.11081954f, 0.07476878f, -0.02844487f, 0.00121814f, 0.05686765f, 0.07716942f, 0.05120036f, 0.06048337f, 
    0.02398732f, 0.07607081f, 0.07136369f, 0.00489029f, -0.05931585f, -0.00473467f, 0.01267735f, 0.00636817f, 
    -0.17762090f, -0.11815351f, 0.21759130f, -0.29805639f, 0.14714640f, 0.09440184f, 0.11492605f, 0.12569001f, 
    -0.00701227f, -0.05816819f, 0.03999528f, 0.05004148f, -0.08892711f, -0.07580430f, 0.03936608f, -0.13656168f, 
    0.07010809f, -0.00694818f, 0.06096806f, 0.06504098f, 0.18385516f, -0.08255971f, 0.31468052f, 0.10522678f, 
    0.01745105f, -0.27402338f, -0.13924132f, 0.04028234f, -0.03539896f, 0.09547116f, -0.01369441f, -0.00989976f, 
    -0.03893835f, -0.00695390f, 0.04843774f, 0.04475591f, 0.02690286f, -0.04945302f, -0.00506790f, 0.04973265f, 
    0.06910740f, 0.01548930f, 0.11517186f, 0.11462630f, -0.02007494f, 0.11282282f, -0.11237606f, 0.11590560f, 
    -0.06033888f, 0.05527362f, 0.02565879f, -0.05184538f, 0.00322699f, -0.08369628f, 0.03577706f, 0.02336633f, 
    0.03723894f, 0.05544363f, 0.04358769f, -0.00860081f, -0.22111510f, 0.21046542f, -0.21555708f, -0.05057294f, 
    -0.16505799f, 0.13649797f, 0.19203633f, 0.13008051f, -0.00477245f, -0.03357906f, 0.05864828f, -0.00860623f, 
    -0.04139403f, 0.01193743f, -0.04797443f, 0.17731553f, 0.06287355f, -0.04962925f, 0.01937677f, -0.01708398f, 
    0.03461052f, 0.14194581f, 0.22051047f, -0.03701397f, 0.35864019f, -0.04113279f, 0.00269259f, 0.01393039f, 
    0.12039392f, 0.01792340f, 0.05994630f, 0.01080797f, 0.02666663f, 0.00598089f, -0.03297365f, 0.03555432f, 
    0.07455482f, 0.02144247f, -0.01620795f, 0.14347832f, 0.23939642f, 0.01981755f, 0.25474170f, 0.12117723f, 
    -0.03058204f, -0.12729703f, -0.05994807f, 0.07369600f, 0.02442924f, -0.00368915f, -0.04839103f, -0.02172864f, 
    -0.00396835f, 0.11269865f, 0.09502184f, 0.02355603f, -0.00292484f, 0.01200231f, 0.04811226f, -0.03560885f, 
    -0.21973546f, 0.11359756f, 0.25671467f, 0.05778364f, -0.06456231f, -0.12770137f, -0.07246470f, 0.04993642f, 
    0.02765492f, 0.06986779f, -0.02501079f, 0.03796991f, 0.08544763f, 0.05345138f, 0.09940121f, -0.07013420f, 
    -0.03224168f, 0.07664791f, -0.00401450f, -0.02049743f, -0.00363826f, -0.06534530f, -0.24095787f, 0.08122290f, 
    0.16262262f, 0.08734919f, 0.07327569f, 0.07283478f, 0.08344839f, 0.13861337f, 0.03956043f, 0.00185112f, 
    -0.04809050f, -0.00257784f, 0.04932979f, 0.07243891f, 0.02592467f, -0.00699320f, -0.02124180f, -0.01299395f, 
    -0.44647938f, 0.01152120f, -0.20904429f, 0.04860605f, -0.04012005f, 0.10581072f, 0.10568644f, -0.10723565f, 
    0.05495640f, 0.16829219f, -0.03095027f, 0.08446215f, 0.09873255f, -0.04448231f, 0.02793369f, -0.02101364f, 
    -0.05667493f, -0.02376874f, 0.03436375f, -0.00518266f, 0.15758863f, -0.01170937f, 0.13075674f, -0.11986557f, 
    -0.04345899f, 0.07213958f, 0.16713545f, 0.13947301f, -0.05992573f, -0.00921484f, 0.10060716f, -0.10189649f, 
    -0.03070433f, 0.03189600f, 0.02289885f, 0.02628973f, 0.02068750f, 0.01721390f, 0.11356672f, 0.04740051f, 
    0.00570364f, 0.08790929f, -0.20785901f, 0.10409520f, -0.42860636f, 0.13853262f, 0.03615448f, -0.03996629f, 
    -0.00099405f, 0.09462579f, 0.00741196f, 0.06187294f, -0.01276901f, 0.09658299f, 0.11947262f, 0.04541298f, 
    0.06195145f, 0.07257099f, -0.03761249f, -0.07932460f, -0.12889901f, -0.07289662f, -0.19397508f, 0.07570850f, 
    -0.04925612f, 0.00897799f, 0.16608281f, 0.07029814f, 0.05834134f, 0.03869023f, 0.07503119f, 0.02576870f, 
    0.04968025f, -0.00370461f, 0.10866801f, 0.14357574f, 0.07669813f, 0.07116301f, -0.01316829f, 0.07523812f, 
    0.20555943f, -0.16043736f, 0.08550534f, 0.09404568f, 0.02576017f, 0.00988973f, 0.08514235f, 0.14666435f, 
    0.06021849f, 0.11411819f, 0.07415653f, 0.01481837f, -0.01524757f, 0.06460541f, -0.03880357f, -0.04681413f, 
    0.02763599f, -0.01114881f, -0.05653121f, -0.02286168f, -0.06558382f, 0.28580147f, -0.10637676f, -0.02965564f, 
    -0.06809454f, 0.13075460f, 0.05289749f, 0.05773763f, 0.03480525f, -0.05602091f, -0.01463860f, 0.17249800f, 
    0.05119058f, -0.05230904f, 0.03004635f, 0.06944252f, -0.05872976f, -0.01898177f, 0.04167929f, 0.03290430f, 
    0.09837185f, -0.15083410f, 0.18490243f, -0.06028016f, -0.02215404f, -0.07251139f, -0.04899890f, -0.02692035f, 
    0.08073740f, 0.07142228f, -0.05785628f, 0.01708941f, 0.05296338f, 0.03289671f, -0.04902752f, -0.07843306f, 
    0.05194792f, -0.01616186f, 0.07066011f, 0.03313260f, -0.02800240f, 0.17132400f, -0.27654830f, 0.00742458f, 
    -0.02014581f, 0.12936582f, 0.14653477f, -0.09637156f, -0.07869461f, -0.14165141f, 0.00448434f, 0.02802510f, 
    0.04079080f, 0.05649442f, -0.04428894f, 0.08810931f, 0.03132827f, 0.05726114f, 0.03277292f, -0.05042876f, 
    -0.02666504f, -0.03596625f, -0.00804233f, 0.01675920f, 0.02973026f, -0.02992536f, 0.00734100f, 0.00051421f, 
    0.00105515f, -0.03433647f, -0.00576885f, -0.03917043f, -0.00888734f, -0.01795708f, -0.01347076f, -0.02940642f, 
    -0.00971177f, -0.04274651f, -0.02923763f, 0.02272035f, -0.00815731f, -0.02550842f, 0.03122124f, -0.02711926f, 
    -0.00997933f, 0.00525043f, -0.04543278f, -0.01796607f, -0.01511715f, -0.03461755f, 0.01020451f, 0.00198453f, 
    -0.01824754f, -0.03435054f, -0.04314391f, 0.02424237f, -0.03580700f, 0.02304779f, 0.00603955f, -0.02998248f, 
    -0.01995412f, 0.03008438f, 0.01507689f, -0.00554079f, 0.02740529f, 0.02285695f, -0.04240377f, 0.01507540f, 
    -0.02156525f, 0.00615942f, 0.00741056f, -0.04307587f, 0.02780548f, -0.01498878f, -0.01739395f, -0.02933433f, 
    0.03355113f, -0.02455043f, 0.01535533f, 0.00082406f, 0.02484205f, -0.02506641f, -0.01587700f, -0.04467855f, 
    -0.02736473f, 0.01429169f, 0.01891382f, -0.04419607f, 0.01957236f, 0.00870307f, -0.01879740f, -0.02130582f, 
    0.01151374f, -0.00219153f, -0.02310923f, -0.02665830f, 0.00640142f, 0.00944999f, -0.00142735f, 0.02991783f, 
    0.02825998f, -0.02962264f, 0.01016934f, 0.02823896f, 0.01582572f, 0.03147822f, -0.00405079f, -0.03449170f, 
    -0.01684978f, -0.01496171f, 0.01670958f, 0.01762136f, -0.02368146f, 0.01031639f, -0.03196445f, 0.03024604f, 
    -0.00575132f, 0.00135732f, 0.03137143f, 0.02823018f, -0.02292441f, 0.00010903f, -0.02186499f, 0.02446268f, 
    -0.01796996f, 0.02819517f, -0.04191150f, 0.00552312f, 0.00461173f, 0.02745162f, 0.02856523f, 0.00145117f, 
    -0.01693137f, -0.02639852f, -0.03645179f, -0.04554380f, 0.00550571f, -0.00284201f, 0.01999909f, 0.02257344f, 
    -0.03569284f, -0.00870590f, 0.01664968f, -0.02646989f, -0.04673518f, -0.04230935f, 0.00493023f, -0.02502565f, 
    0.01287349f, 0.01772438f, -0.02485965f, -0.00576829f, 0.00109304f, -0.04159036f, 0.02266760f, 0.00742073f, 
    0.02875377f, 0.00386649f, 0.00731301f, 0.01845446f, -0.03410215f, -0.01783887f, 0.03409245f, -0.04393109f, 
    0.03916215f, -0.04120880f, -0.03662900f, 0.00530752f, 0.01342266f, 0.02325891f, 0.00699214f, -0.03669583f, 
    0.02673919f, 0.02780706f, -0.02675500f, -0.02731468f, 0.02892611f, -0.01901592f, -0.03579647f, 0.00379788f, 
    0.02839748f, -0.03077176f, -0.04796484f, -0.03499575f, -0.03946732f, 0.02550475f, -0.04399860f, -0.00538527f, 
    -0.02200881f, -0.02042329f, -0.02622598f, -0.01393407f, 0.01778507f, -0.00827444f, -0.01292045f, 0.01736966f, 
    -0.04305816f, 0.02220705f, -0.04260562f, 0.01774064f, 0.02402297f, -0.04552728f, -0.00234552f, -0.01141114f, 
    -0.01220683f, -0.00660185f, 0.00657891f, 0.02497093f, 0.01279222f, -0.02851772f, -0.04734035f, -0.01810777f, 
    -0.02913473f, 0.03013160f, 0.00469699f, 0.02377979f, -0.00873190f, -0.02770943f, -0.01628240f, -0.01667913f, 
    0.01653409f, -0.02500719f, -0.01746936f, 0.02403759f, -0.00541015f, 0.00051972f, -0.01213710f, -0.01161383f, 
    0.02193080f, 0.01869255f, 0.01372702f, -0.00944395f, -0.01746508f, -0.00418073f, -0.04057113f, -0.03295042f, 
    -0.00705466f, -0.01765598f, -0.00527203f, 0.01764766f, 0.02617316f, -0.03087924f, 0.03059663f, -0.02892336f, 
    -0.00999228f, 0.03566522f, -0.01522330f, -0.01642159f, -0.03494628f, 0.01335866f, -0.04551172f, 0.03103412f, 
    0.03837486f, -0.04130885f, -0.01099195f, -0.00235359f, -0.03421718f, -0.01404261f, -0.00313824f, 0.00064523f, 
    0.03981017f, -0.01603286f, -0.02646611f, 0.01807935f, 0.00144257f, -0.02486616f, -0.04787604f, 0.02574723f, 
    -0.00359722f, 0.01683146f, -0.02599445f, 0.01250389f, -0.02232048f, -0.01489235f, -0.02671914f, -0.02724213f, 
    -0.00103290f, -0.03385814f, -0.00855222f, -0.03208664f, -0.04439690f, -0.03961712f, -0.00917276f, -0.01104687f, 
    -0.03637938f, 0.01651306f, -0.00513470f, 0.01212631f, -0.04287448f, -0.00967816f, 0.00568327f, 0.02225737f, 
    0.02510947f, 0.00605430f, 0.01558018f, 0.03067374f, -0.02402790f, -0.02595671f, -0.04720869f, -0.00259683f, 
    0.00497958f, -0.00960287f, 0.02668156f, -0.02897220f, 0.00406178f, -0.04039427f, -0.02626736f, -0.01756978f, 
    -0.00743589f, 0.00775587f, -0.01867431f, 0.00897492f, 0.00473152f, -0.02927187f, -0.04140103f, 0.02379262f, 
    0.00721092f, -0.02198001f, 0.01395535f, -0.00609370f, -0.02643056f, -0.02288231f, 0.02714602f, -0.02954521f, 
    0.02787707f, 0.02628339f, -0.03212707f, 0.01662113f, -0.04173476f, -0.02033290f, -0.02212827f, -0.00650675f, 
    0.02829806f, -0.01690706f, -0.00209911f, -0.00130394f, -0.03234890f, 0.02032225f, -0.00393560f, 0.01484801f, 
    0.01765474f, 0.02439483f, 0.01627395f, -0.02348341f, 0.01707784f, 0.01313663f, -0.02020906f, -0.04368320f, 
    0.00928461f, 0.00096830f, -0.00557860f, -0.04352672f, -0.02767022f, 0.01315308f, 0.01124884f, -0.01187828f, 
    0.02767966f, 0.00278008f, -0.01464357f, -0.04070150f, 0.02571953f, -0.03374774f, -0.03999412f, 0.02634519f, 
    -0.01620036f, 0.02346139f, -0.04239522f, 0.01185754f, 0.02476175f, -0.02457292f, -0.01049634f, 0.00030392f, 
    -0.04116663f, 0.01305098f, -0.00968576f, -0.01597423f, 0.00428951f, 0.01971609f, -0.01819773f, 0.01395327f, 
    -0.02292902f, 0.01812213f, 0.02645486f, 0.00008620f, 0.02212931f, 0.01345917f, -0.01205254f, -0.03764087f, 
    0.02245480f, 0.02091671f, 0.00593011f, -0.01191564f, 0.01175547f, -0.03672022f, 0.02340661f, 0.03191255f, 
    0.03285561f, 0.01709315f, -0.04269315f, -0.00223868f, 0.00165327f, -0.01694456f, 0.02066229f, 0.00145689f, 
    0.00029405f, -0.00970140f, 0.02377667f, 0.00046683f, -0.03422669f, -0.02705274f, 0.00582962f, -0.01036171f, 
    0.00372201f, -0.00741226f, 0.02591397f, 0.01412391f, -0.00054239f, 0.00200991f, -0.04124467f, 0.02533744f, 
    0.02890408f, 0.00721918f, -0.01389642f, 0.01122143f, 0.02939415f, 0.02673995f, -0.00583385f, 0.01797933f, 
    0.02982747f, 0.01407335f, 0.00995268f, 0.00617831f, -0.02480066f, -0.02457621f, 0.01651331f, -0.03729674f, 
    -0.03658754f, -0.02317315f, -0.02798588f, -0.04338194f, 0.01066456f, 0.01051214f, 0.00880182f, -0.02082642f, 
    -0.00724096f, -0.01104463f, -0.02968768f, -0.03584749f, -0.01926777f, 0.01377153f, 0.02446127f, 0.01896912f, 
    -0.03218194f, -0.04472334f, -0.04632720f, -0.01450577f, 0.01869915f, -0.00073163f, -0.03020892f, -0.03979035f, 
    0.02848012f, -0.04297676f, 0.02989791f, -0.03064227f, -0.02595956f, -0.00144550f, -0.02532694f, -0.01114426f, 
    -0.01103515f, 0.03050984f, -0.00674192f, 0.02075500f, -0.00292506f, -0.01601334f, -0.02843060f, -0.03756446f, 
    -0.01978730f, -0.00186444f, -0.04159475f, -0.00537670f, 0.02896197f, 0.01401096f, 0.02850948f, 0.00011376f, 
    0.04022390f, -0.04656548f, -0.02421753f, 0.02230823f, -0.00883449f, 0.00128409f, 0.00320142f, -0.01194154f, 
    0.01726175f, -0.02562584f, 0.01986418f, 0.02453711f, 0.00374060f, -0.00009608f, -0.02500027f, -0.02939783f, 
    -0.03814405f, -0.01066921f, 0.01825720f, 0.03050975f, 0.02041583f, 0.00790195f, -0.02269986f, -0.02649056f, 
    -0.00476408f, 0.02269296f, 0.02013534f, 0.01957076f, 0.00573020f, -0.02313954f, 0.00584647f, 0.01110840f, 
    -0.00296745f, 0.01426713f, -0.01944803f, -0.04264896f, -0.04473726f, -0.01756141f, -0.02521214f, -0.00019607f, 
    -0.02989114f, 0.00700461f, 0.03026479f, -0.04680102f, -0.01782364f, 0.03153945f, 0.01300133f, 0.01894503f, 
    -0.00349417f, -0.02608657f, -0.01869882f, -0.04571861f, -0.03538008f, -0.03489259f, 0.02604764f, 0.01034932f, 
    -0.02523907f, -0.00654994f, 0.00105479f, -0.02866802f, -0.01963309f, 0.04158000f, -0.01205407f, -0.03124240f, 
    -0.01955045f, -0.00494947f, -0.04340977f, -0.04525533f, -0.00329920f, -0.02803325f, 0.02868041f, 0.02720689f, 
    0.01305801f, -0.01261362f, -0.02483124f, -0.02376262f, -0.04600202f, -0.00175281f, 0.00741711f, -0.02933067f, 
    0.00496388f, -0.04082579f, -0.03183109f, -0.03317496f, -0.02022893f, -0.01638908f, -0.01806091f, 0.02685497f, 
    -0.01271756f, -0.03997890f, -0.04360772f, -0.00693373f, -0.04570252f, -0.04348353f, 0.00022672f, -0.02198610f, 
    -0.02491870f, 0.00503581f, 0.02092837f, 0.03013529f, -0.00222912f, 0.02251613f, 0.00450690f, -0.00006891f, 
    -0.03814138f, -0.01396470f, 0.02330478f, -0.01864161f, 0.00280546f, -0.01714692f, -0.00173648f, -0.03515714f, 
    0.01230650f, 0.01617720f, -0.02788808f, -0.02744175f, -0.03634318f, 0.01327259f, 0.03170506f, -0.00885163f, 
    0.00180059f, -0.03116038f, -0.02433756f, -0.02958790f, -0.00185467f, -0.00096536f, 0.02352565f, 0.00375506f, 
    -0.03240523f, -0.02286687f, 0.00013002f, 0.02054575f, 0.01843535f, -0.01662006f, -0.01767952f, -0.03333814f, 
    -0.01615120f, -0.02300390f, 0.02973362f, 0.01137445f, 0.00390177f, -0.01732945f, -0.03003205f, -0.01927912f, 
    -0.02211452f, -0.03419030f, -0.01049415f, -0.03871042f, -0.04555376f, 0.00299034f, 0.00418778f, -0.00624335f, 
    -0.02106473f, 0.02545177f, 0.00771439f, 0.02854014f, 0.02226405f, 0.03502972f, -0.02516504f, -0.01215741f, 
    0.02940749f, 0.00825003f, -0.03528449f, 0.00656934f, -0.02034240f, 0.02799637f, -0.00716215f, 0.01632470f, 
    -0.02802057f, -0.03446760f, -0.02065368f, -0.01558086f, -0.02161997f, 0.02479048f, -0.04548303f, -0.04526784f, 
    -0.01079602f, -0.01645415f, -0.01953645f, 0.01123360f, -0.00939139f, 0.00562141f, -0.02004269f, -0.01690707f, 
    -0.00102939f, -0.00910680f, 0.00739814f, -0.02871813f, -0.01141308f, -0.00426265f, 0.02852913f, 0.02262162f, 
    -0.01842564f, -0.02259105f, -0.01084633f, 0.02856872f, 0.00853857f, -0.02907037f, -0.00290600f, 0.02642244f, 
    0.02212282f, 0.00042549f, 0.02599866f, -0.03940630f, 0.03069553f, -0.00844652f, -0.02183057f, 0.03177759f, 
    0.01495200f, 0.00367514f, -0.00208353f, 0.00946297f, 0.02155111f, -0.00549847f, 0.00891106f, -0.02780991f, 
    -0.00955787f, -0.04082091f, 0.01523254f, 0.00536333f, -0.02479062f, 0.02091129f, 0.02706941f, -0.01015395f, 
    -0.01706602f, -0.00231224f, -0.00538530f, -0.00129979f, 0.00448258f, -0.02716557f, 0.00738058f, -0.02217791f, 
    0.02453601f, -0.03248923f, 0.02508115f, 0.01610669f, 0.01083011f, -0.03197203f, -0.04470685f, -0.01934439f, 
    0.02096356f, -0.01219068f, -0.02359811f, 0.02796112f, -0.00892540f, -0.02438288f, 0.02653643f, -0.02930772f, 
    0.03450659f, -0.00580645f, 0.00794340f, -0.01290379f, -0.00866028f, 0.00700986f, -0.02468141f, 0.02541821f, 
    -0.02580967f, 0.02463055f, -0.03583615f, 0.00995880f, 0.01254468f, -0.02345403f, 0.02155885f, 0.00375287f, 
    -0.03040123f, -0.02911228f, -0.00090144f, -0.01062567f, 0.02643847f, -0.02498578f, 0.02034398f, -0.00464525f, 
    0.01950696f, -0.01468111f, 0.03216141f, 0.01996097f, -0.02977316f, 0.00066244f, -0.04285846f, 0.01419242f, 
    0.00496009f, 0.01669210f, -0.02478602f, 0.03073358f, -0.00471516f, 0.03039359f, 0.02742853f, -0.03442701f, 
    0.01897937f, -0.01206068f, -0.04084306f, 0.02753580f, 0.01588925f, -0.01965008f, -0.04646304f, 0.03285616f, 
    -0.02954694f, -0.02595944f, -0.00006883f, 0.01401872f, -0.02965653f, 0.01146131f, 0.00540474f, 0.00398997f, 
    -0.01585486f, -0.02987349f, -0.00818608f, -0.00655487f, -0.01705980f, 0.01129201f, -0.00543061f, 0.01013128f, 
    0.02342856f, -0.00366443f, -0.03414638f, -0.03335287f, 0.00508859f, -0.00489741f, -0.02171881f, 0.03319925f, 
    -0.03190652f, 0.01300959f, -0.04268904f, -0.03142707f, 0.03232167f, -0.00226650f, -0.04690198f, -0.01575125f, 
    -0.03089361f, -0.01192749f, -0.03928222f, -0.02654272f, -0.02032029f, -0.02937105f, 0.01953748f, -0.03615108f, 
    -0.01716018f, 0.01664290f, 0.02488735f, -0.02802001f, -0.00412785f, 0.03176291f, -0.01864902f, -0.02432840f, 
    0.01231933f, 0.00359957f, -0.01670699f, 0.00621129f, 0.02670503f, -0.00764030f, 0.03003374f, -0.01871141f, 
    0.00720941f, 0.01514292f, -0.02315908f, 0.00818441f, 0.03777287f, 0.01178097f, -0.00896367f, -0.03245903f, 
    0.02727861f, -0.01017838f, -0.03437109f, 0.00505161f, 0.02547746f, 0.03184839f, -0.00160517f, 0.02288576f, 
    -0.03907249f, -0.01883141f, -0.00863434f, 0.00862946f, 0.01945277f, 0.03267359f, 0.03527181f, -0.00047676f, 
    -0.03774137f, -0.00763122f, -0.00942650f, -0.01967088f, 0.01548892f, -0.01996559f, -0.02579956f, 0.03465468f, 
    -0.02472496f, -0.02017639f, 0.03102654f, 0.00468150f, -0.03434609f, -0.01595824f, -0.00136884f, 0.01174050f, 
    0.02105080f, 0.03569198f, 0.00637553f, 0.00751402f, 0.02772588f, -0.02792847f, -0.00530338f, 0.00723624f, 
    -0.02159750f, -0.01221384f, -0.01954805f, 0.03253236f, 0.00185178f, -0.03731760f, -0.02214452f, 0.00091842f, 
    -0.02622810f, 0.00606932f, 0.00771620f, -0.01744453f, -0.02747449f, -0.03442948f, -0.03939127f, -0.00426173f, 
    -0.02460429f, 0.00782684f, -0.03479384f, 0.01615726f, -0.03573754f, 0.00546721f, 0.00524431f, 0.02966294f, 
    -0.01653386f, 0.01920336f, 0.01249758f, 0.00032660f, -0.02665135f, -0.03404175f, -0.02913269f, 0.03160005f, 
    0.02207542f, 0.00484994f, -0.02743767f, 0.02442632f, 0.02489542f, -0.03940095f, -0.00169405f, -0.03439042f, 
    -0.03152175f, 0.01867519f, 0.03017602f, -0.04064077f, 0.00823511f, 0.02109637f, -0.02867737f, 0.02348985f, 
    0.00400133f, -0.00610515f, -0.02177328f, -0.04000827f, -0.02973392f, 0.03404954f, 0.03265628f, -0.03740719f, 
    -0.03474765f, -0.00510176f, -0.00211140f, 0.01023633f, 0.02762214f, 0.01079037f, -0.02814777f, -0.03092825f, 
    0.02271612f, 0.02238832f, 0.02155499f, 0.02687603f, -0.02502513f, -0.04625167f, -0.03759262f, 0.03274547f, 
    0.01605505f, -0.03829611f, -0.03471161f, -0.00310265f, 0.01411109f, -0.01537144f, -0.02395609f, -0.00739333f, 
    0.02480833f, -0.04586952f, -0.00386140f, -0.04001088f, 0.00516101f, -0.02642681f, -0.03324657f, -0.00700969f, 
    0.00425381f, 0.02390468f, -0.00546145f, -0.00712648f, -0.01659274f, 0.00804498f, -0.04354237f, -0.03305960f, 
    0.00451459f, 0.01637044f, -0.00188605f, -0.01365362f, -0.02780198f, 0.02559922f, -0.03416692f, 0.01365966f, 
    0.03065562f, -0.03709596f, -0.00405787f, 0.01305152f, -0.02599349f, 0.02927480f, -0.02029783f, -0.02516362f, 
    -0.03544398f, 0.02669626f, -0.04526031f, -0.03209425f, -0.02029798f, 0.00551690f, -0.00963414f, -0.03101744f, 
    -0.00424558f, -0.02884818f, -0.03906864f, 0.02049829f, 0.01225757f, 0.02039269f, 0.03199478f, 0.00098758f, 
    0.00460363f, -0.00840055f, 0.00764882f, -0.02968820f, -0.04216021f, -0.02126443f, -0.03467447f, -0.00262141f, 
    -0.02244429f, -0.00202703f, -0.02102963f, -0.03646102f, -0.00898126f, -0.03309557f, -0.03128668f, -0.03876872f, 
    -0.00884149f, -0.02793732f, -0.03142590f, -0.02572864f, 0.02394882f, -0.00894643f, 0.01111568f, 0.03304780f, 
    0.02286825f, -0.03339373f, -0.03640390f, -0.01942648f, -0.01489550f, -0.03090978f, 0.01586470f, 0.00492892f, 
    0.02980202f, -0.03299546f, -0.03994412f, -0.00399006f, 0.02059193f, -0.01710622f, -0.00307569f, -0.03127587f, 
    -0.00860903f, 0.00065739f, -0.00242999f, 0.02866204f, -0.02909336f, -0.01158667f, -0.03939312f, 0.03022529f, 
    0.00371833f, 0.01031622f, 0.03180381f, 0.02629172f, -0.00040423f, 0.01651617f, -0.04714717f, -0.02587963f, 
    -0.00190892f, -0.00147439f, 0.02365399f, 0.03184840f, 0.01841505f, -0.01509432f, 0.02924794f, 0.02961771f, 
    -0.02577333f, 0.00692787f, -0.02432788f, 0.01156106f, -0.01407541f, -0.02952766f, 0.00929704f, -0.01725481f, 
    0.02870448f, 0.02765473f, -0.02435947f, 0.02752446f, 0.01852004f, 0.00256382f, 0.02611889f, -0.02534578f, 
    -0.01302977f, 0.03117149f, 0.02474434f, 0.00175687f, -0.04316525f, 0.00996969f, -0.01054355f, 0.01425074f, 
    -0.04257938f, 0.02856290f, 0.01007838f, -0.01038630f, 0.01363077f, 0.01607813f, -0.04749260f, 0.00839090f, 
    -0.03933719f, 0.02696136f, 0.00106129f, -0.01655024f, -0.03071294f, -0.04033761f, -0.03235113f, -0.01996806f, 
    -0.04100068f, -0.01384946f, -0.02816681f, -0.02346864f, 0.01340431f, 0.00987612f, 0.00836180f, -0.03573481f, 
    0.02659507f, 0.02404647f, -0.03597509f, -0.01504343f, -0.00081387f, 0.00346693f, 0.01978942f, 0.03012116f, 
    0.00393474f, -0.04021077f, -0.01771553f, 0.00807138f, 0.02513161f, -0.02374933f, 0.03344345f, 0.00203219f, 
    -0.03599761f, -0.01650476f, -0.03603963f, -0.00749994f, -0.04134262f, 0.01423010f, -0.02112534f, 0.01323460f, 
    0.01149360f, 0.02510614f, -0.00290304f, 0.03214971f, 0.02754810f, -0.00360956f, 0.03909493f, 0.03074159f, 
    -0.01821749f, -0.01372782f, -0.00104548f, -0.01804294f, -0.03072527f, 0.00724754f, -0.00544370f, -0.03660563f, 
    0.00755440f, 0.00327734f, -0.03492685f, -0.03095008f, -0.02042362f, -0.02781521f, 0.02472694f, -0.02871057f, 
    0.01828431f, -0.02639297f, 0.02928809f, -0.03288909f, -0.01212377f, -0.01757465f, -0.01442382f, -0.03665232f, 
    0.01075802f, -0.02600528f, -0.02708026f, 0.04318126f, 0.00340437f, -0.03290058f, -0.01071029f, -0.02500928f, 
    0.00616704f, -0.00610197f, -0.04025638f, -0.03460833f, -0.03486903f, -0.02701047f, 0.01299475f, 0.03539223f, 
    -0.00011084f, 0.01329326f, -0.01193728f, 0.00373620f, 0.00122685f, -0.01867116f, -0.00433003f, -0.01832065f, 
    -0.02965437f, -0.04420888f, -0.01520385f, -0.01831327f, -0.00840679f, -0.02658885f, -0.00152898f, -0.03230249f, 
    -0.03801803f, -0.01329294f, -0.00951028f, -0.03429438f, 0.01094831f, -0.03255796f, 0.02243540f, -0.03193173f, 
    0.01482354f, 0.00363709f, -0.04405710f, 0.00889560f, 0.02992316f, 0.00090211f, -0.03381757f, -0.02299756f, 
    -0.00071116f, -0.03680852f, -0.00325015f, -0.01076398f, -0.02565339f, -0.04027401f, -0.00644053f, 0.02588796f, 
    -0.02096701f, -0.01544110f, 0.00164571f, 0.02252571f, -0.00154865f, 0.02468628f, 0.00540434f, 0.02438368f, 
    0.02283061f, 0.03071923f, -0.02307930f, 0.02259036f, 0.00715091f, -0.02475365f, -0.02422517f, -0.01553270f, 
    -0.03844598f, 0.01647220f, -0.03434083f, -0.03234203f, -0.02681857f, -0.02286056f, 0.01243048f, -0.03166780f, 
    0.00101333f, -0.01199860f, -0.01277183f, -0.02638140f, 0.03382120f, 0.01912591f, -0.00960189f, 0.02698396f, 
    -0.04334885f, 0.01950351f, 0.02769154f, 0.00306490f, -0.04018351f, 0.01652504f, 0.01248468f, -0.00292765f, 
    -0.02223894f, -0.00319584f, -0.03237196f, -0.00543635f, -0.01250291f, 0.03485274f, -0.00714837f, 0.01911692f, 
    -0.00867538f, -0.03313467f, -0.01708792f, 0.02315130f, -0.04462693f, 0.02863755f, 0.02099102f, 0.03503989f, 
    -0.02797333f, -0.03354871f, -0.04162446f, -0.00041877f, -0.03742331f, -0.00442212f, -0.04008368f, 0.02089774f, 
    0.16205774f, -0.16620132f, -0.04564736f, 0.00547076f, -0.04310835f, -0.05037663f, 0.06353881f, -0.06759256f, 
    -0.10150186f, 0.06202566f, 0.02990320f, 0.05168423f, 0.01459963f, -0.09492657f, 0.14351858f, 0.03853281f, 
    -0.06419055f, -0.00324650f, -0.01924955f, 0.03275289f, -0.11943035f, 0.24157482f, 0.08048352f, -0.11826909f, 
    0.15711848f, 0.20026314f, -0.04537177f, 0.06094946f, 0.10116529f, 0.04549194f, -0.01171730f, 0.00253426f, 
    -0.07539698f, -0.05281129f, -0.21478960f, -0.08373585f, -0.01294305f, 0.02143748f, -0.00186849f, -0.05875677f, 
    -0.08777808f, -0.21452935f, -0.16658980f, -0.26859272f, -0.37428808f, 0.06991550f, 0.15766016f, 0.00111510f, 
    -0.01960883f, 0.04207108f, 0.13061814f, -0.06400258f, 0.09874851f, -0.06763067f, 0.08396195f, -0.09190466f, 
    -0.00303636f, 0.06988563f, 0.05954485f, 0.02552528f, -0.04752469f, 0.01289292f, 0.06036415f, 0.04299257f, 
    0.06375822f, 0.00379005f, -0.02129955f, -0.01911793f, -0.02084831f, -0.04262253f, 0.13441122f, 0.11170990f, 
    -0.00058069f, -0.08753972f, 0.07136115f, 0.01756466f, 0.03153861f, -0.07132573f, 0.01807974f, 0.04274006f, 
    0.08475952f, 0.01122177f, -0.14815606f, -0.09587517f, -0.16388883f, -0.00823753f, -0.00781447f, -0.06144155f, 
    -0.01703962f, 0.00349782f, -0.07199498f, 0.02649620f, 0.01923908f, -0.03435414f, 0.07724568f, -0.05260649f, 
    -0.06262397f, -0.07809708f, -0.03896115f, 0.02634113f, -0.16004974f, 0.12549314f, 0.11836834f, 0.26142123f, 
    -0.04942419f, 0.01159079f, -0.09553374f, -0.02903850f, 0.02856360f, -0.08141533f, 0.05291611f, 0.16369979f, 
    -0.00028247f, -0.01540275f, 0.04553082f, -0.01883235f, 0.12833919f, 0.03469474f, -0.01643418f, 0.05438008f, 
    -0.07834264f, 0.10506094f, -0.07606503f, 0.10882731f, -0.21818458f, 0.13366380f, -0.02304460f, 0.09355766f, 
    -0.01664480f, 0.03536327f, -0.01399207f, -0.00758756f, 0.03260260f, -0.01070645f, 0.09687769f, 0.04681247f, 
    0.04461650f, -0.03426177f, 0.05380591f, -0.08803990f, 0.03929624f, 0.04490422f, -0.04069734f, 0.06386194f, 
    0.26388973f, -0.10484792f, 0.00729185f, 0.00932567f, 0.07598269f, 0.00339510f, 0.11140572f, -0.02510332f, 
    0.04584778f, -0.04658252f, 0.00158442f, 0.01972231f, 0.06939957f, -0.00334096f, 0.10940348f, -0.01492270f, 
    -0.05071633f, -0.05117101f, 0.07197703f, 0.07984224f, 0.08454277f, 0.04654174f, -0.08235573f, 0.03257530f, 
    0.09943511f, 0.11337721f, 0.08836082f, -0.00522856f, 0.09922634f, 0.06192767f, 0.04940072f, 0.00735239f, 
    -0.03656276f, 0.02460846f, 0.05182439f, 0.12083673f, 0.09163417f, -0.24534829f, -0.04439867f, -0.22636163f, 
    0.09773511f, 0.11571622f, 0.18141358f, -0.12466526f, 0.00059049f, 0.07638820f, 0.00500047f, -0.04528157f, 
    0.12054253f, 0.05033588f, 0.11697067f, 0.08395987f, 0.02093078f, -0.04783125f, 0.00345203f, -0.00300455f, 
    -0.19472928f, -0.03629894f, 0.04719243f, -0.18004417f, -0.11742966f, 0.14595698f, 0.07258916f, 0.02124954f, 
    -0.09118785f, -0.03540365f, 0.12208775f, 0.02111755f, 0.00987158f, 0.02198970f, -0.00544634f, 0.08004355f, 
    0.06307653f, -0.01626863f, 0.09453940f, 0.07348493f, -0.84700716f, 0.26930922f, -0.03298604f, -0.07161628f, 
    -0.06391006f, 0.12875262f, 0.01812792f, 0.08848115f, 0.09624328f, 0.06278925f, 0.05766866f, 0.15030463f, 
    -0.07787064f, -0.03330915f, 0.04418442f, -0.04408535f, 0.07864419f, 0.01184015f, 0.11334654f, -0.05797951f, 
    -0.02141301f, 0.22874525f, -0.14764215f, -0.09150893f, -0.00305388f, 0.17168021f, 0.03519651f, -0.11084832f, 
    -0.03391850f, -0.03568093f, 0.00044020f, 0.15320170f, -0.05732211f, 0.02062278f, -0.08035749f, 0.08964776f, 
    0.01821282f, -0.05525152f, -0.04317949f, 0.06155334f, -0.18927553f, 0.16747551f, 0.07163317f, -0.03515264f, 
    0.10675721f, 0.03727027f, 0.16352537f, 0.04437492f, 0.06165606f, 0.06575523f, -0.03473946f, 0.08592210f, 
    0.03349087f, -0.03752531f, 0.00926722f, 0.09956393f, -0.05294805f, 0.07422847f, 0.07902727f, -0.03593550f, 
    -0.21004079f, 0.42697397f, -0.06168669f, 0.04906664f, -0.24590573f, 0.01949855f, 0.02086256f, -0.13270171f, 
    0.00442496f, 0.00435214f, -0.05777650f, 0.08623024f, 0.01684555f, 0.13673277f, 0.15192769f, 0.07188154f, 
    0.06568700f, -0.07576220f, 0.10559553f, -0.03498424f, -0.05028796f, 0.23116629f, -0.03466132f, -0.03093470f, 
    0.16864187f, 0.08327638f, -0.00393226f, 0.08178435f, 0.02200740f, 0.13820161f, 0.01280844f, 0.08041313f, 
    0.09370115f, 0.09111197f, 0.08456548f, 0.02974197f, 0.07417350f, -0.01803908f, 0.05008453f, 0.09764246f, 
    0.04023064f, 0.17306465f, 0.34081015f, -0.06996267f, -0.07177694f, -0.09495348f, -0.10961059f, 0.03699453f, 
    -0.03144863f, -0.05938802f, -0.01040440f, 0.08410493f, 0.02533905f, 0.01096525f, -0.12798700f, 0.02591385f, 
    0.06841116f, -0.13532291f, 0.07778452f, -0.04594710f, 0.38262671f, -0.27113298f, -0.11773010f, 0.01723709f, 
    0.02262153f, 0.02707537f, 0.12339416f, 0.01101871f, -0.03333092f, 0.04069933f, 0.00577847f, -0.02720019f, 
    -0.02686290f, -0.02204784f, 0.10811816f, 0.00139614f, 0.03880451f, 0.11744771f, 0.04227585f, 0.18283305f, 
    -0.07591083f, -0.25867224f, -0.03428870f, 0.05701561f, 0.06465003f, 0.00820125f, 0.13367522f, -0.10380834f, 
    0.08176457f, -0.08486681f, 0.02889266f, -0.04388955f, -0.01752461f, 0.00802348f, -0.12109113f, 0.03675313f, 
    -0.04869125f, 0.07413805f, -0.09800023f, 0.15045577f, -0.28837556f, 0.09783900f, 0.08487637f, 0.08672100f, 
    0.26309752f, 0.07414392f, -0.02460376f, 0.08595805f, 0.13181345f, -0.02483697f, 0.06100988f, -0.11428732f, 
    -0.05026696f, -0.10127813f, -0.14040838f, -0.01908776f, -0.03591452f, 0.02624985f, -0.01996664f, -0.01128494f, 
    -0.02491139f, -0.14785336f, 0.02100068f, -0.18648188f, -0.03687307f, 0.11822178f, -0.00094322f, 0.05013308f, 
    -0.06917822f, -0.03111886f, 0.14596249f, -0.03462451f, 0.00814281f, 0.09151079f, -0.03516342f, 0.00774120f, 
    0.12220606f, -0.02476345f, -0.01595599f, 0.03949438f, 0.08125439f, -0.23767304f, -0.01580287f, -0.09844913f, 
    0.06002565f, 0.08729386f, 0.03233107f, -0.13706376f, -0.15033551f, 0.03929075f, 0.09520640f, 0.04182303f, 
    0.04033431f, 0.07084538f, 0.10335497f, -0.10740572f, 0.05512302f, 0.03529466f, -0.11376970f, -0.07980981f, 
    -0.12675861f, -0.14858544f, -0.11200788f, 0.06545538f, 0.16608192f, -0.13526879f, -0.07762282f, -0.00834213f, 
    0.00321163f, 0.05324467f, 0.04703977f, 0.03963730f, 0.04093215f, -0.04273109f, 0.09823841f, 0.05195633f, 
    -0.02262609f, -0.01971746f, 0.09144831f, 0.09339330f, -0.00686010f, 0.25187603f, -0.02511931f, 0.17885938f, 
    0.29576230f, -0.02020286f, 0.08779137f, -0.03494491f, 0.06989389f, -0.04272493f, 0.03716436f, 0.06784314f, 
    0.02692835f, -0.04332093f, 0.04405739f, -0.02518551f, 0.02492860f, 0.05483183f, -0.13003559f, 0.08177508f, 
    -0.18977712f, 0.12946479f, 0.05801300f, 0.23723452f, 0.04550292f, 0.10167300f, -0.07216591f, 0.06641732f, 
    0.05995080f, 0.06026509f, -0.03957865f, 0.01906735f, -0.00124115f, -0.08793916f, -0.00243083f, -0.01989405f, 
    -0.06371352f, 0.03245610f, -0.04198586f, -0.08430064f, -0.13269961f, 0.03779066f, -0.03460829f, -0.04909748f, 
    -0.13848618f, 0.01595669f, -0.06324584f, 0.06008112f, -0.03159868f, 0.11535159f, 0.08091815f, 0.05675352f, 
    0.05786759f, 0.02581014f, 0.02130699f, -0.02621472f, 0.02758102f, -0.08543642f, -0.06500190f, 0.07320678f, 
    0.08127499f, 0.21600085f, 0.00508034f, 0.06504554f, 0.17224291f, 0.04467203f, 0.00718141f, -0.08676256f, 
    0.10526320f, -0.07727104f, 0.02827077f, -0.05303022f, 0.00080008f, 0.14812861f, -0.12014398f, -0.04201528f, 
    0.20895086f, -0.08756036f, -0.12643410f, -0.01789762f, 0.04280666f, -0.03903792f, -0.02391727f, 0.35825667f, 
    0.07530817f, -0.04057916f, 0.06552223f, 0.04678819f, 0.02043310f, -0.02705002f, 0.04507480f, -0.02343380f, 
    0.09708179f, 0.01595275f, -0.01055671f, 0.00079044f, -0.12402501f, 0.05519735f, 0.07577968f, 0.09600625f, 
    -0.09254967f, -0.01057363f, 0.00655525f, 0.00936320f, -0.33654663f, -0.00253372f, 0.00248686f, 0.00654534f, 
    -0.03039418f, 0.10313210f, 0.20296538f, 0.05766194f, 0.07954530f, 0.05890841f, -0.05614454f, -0.08177868f, 
    0.12587218f, -0.08810871f, -0.10912108f, -0.05119872f, -0.19325756f, 0.39182740f, 0.01478402f, 0.07014014f, 
    0.03773317f, 0.06110416f, -0.07529658f, 0.04966964f, -0.06671768f, 0.07474055f, -0.03215192f, 0.01062889f, 
    0.04048555f, -0.02794130f, 0.01849265f, 0.08544163f, 0.03873264f, 0.05664154f, 0.10908206f, 0.05732495f, 
    -0.23358195f, 0.17316093f, -0.11624322f, 0.12910038f, -0.06770260f, 0.21461333f, 0.08029503f, 0.06011208f, 
    -0.05021292f, -0.01102303f, -0.01791482f, 0.07339253f, 0.03689250f, -0.03841802f, -0.02016592f, 0.07736856f, 
    0.04876734f, -0.08564428f, 0.04246353f, 0.03203290f, -0.18676263f, 0.36198321f, 0.05466110f, 0.29383668f, 
    -0.06770979f, 0.00595565f, -0.01562357f, 0.02427272f, 0.03050211f, 0.03455935f, -0.04784544f, 0.01167964f, 
    0.00871554f, -0.09491834f, 0.08359331f, -0.06081966f, 0.08079907f, 0.11435306f, 0.01140122f, -0.02803590f, 
    -0.16518454f, -0.11887642f, 0.04082394f, -0.12192365f, 0.09796703f, -0.04020317f, 0.08352553f, -0.04853547f, 
    0.04192341f, -0.02353720f, -0.09941616f, 0.02747149f, 0.04792170f, 0.00021172f, 0.08739150f, -0.00648105f, 
    0.06504538f, -0.12453766f, 0.17200756f, 0.03235522f, 0.06652264f, 0.20505133f, 0.05912418f, -0.02983268f, 
    -0.26588032f, 0.07792699f, -0.01298378f, 0.06234828f, 0.03213213f, 0.00130693f, 0.03396670f, -0.11068431f, 
    0.06768088f, -0.08866189f, -0.05788841f, -0.00229314f, 0.00813122f, 0.07856853f, -0.01566815f, -0.07572237f, 
    -0.25387427f, -0.32897067f, -0.03634986f, -0.13996786f, -0.15249640f, -0.16035205f, 0.10519489f, 0.00097792f, 
    -0.05702362f, -0.10055579f, -0.05295824f, -0.01075912f, 0.10783964f, 0.02085530f, 0.02350132f, 0.13789223f, 
    -0.04025944f, -0.12067374f, -0.03341247f, 0.10313363f, 0.14883132f, -0.04393962f, 0.13812657f, 0.19046646f, 
    0.31809005f, 0.00597674f, 0.02241318f, 0.03408142f, -0.02533317f, 0.03055095f, -0.13074486f, -0.08629803f, 
    0.01196400f, -0.06036241f, 0.01993323f, -0.00761009f, 0.11711311f, 0.00374477f, 0.05489572f, -0.06069643f, 
    0.05646205f, -0.14110982f, -0.15485355f, -0.05104087f, 0.02310457f, -0.03324626f, 0.08997215f, 0.03852446f, 
    -0.02066442f, -0.04580322f, -0.10629102f, -0.00402297f, -0.08912458f, 0.04383803f, 0.01496933f, 0.08746637f, 
    0.01728328f, -0.06144490f, -0.07555499f, 0.01845030f, 0.22200409f, 0.07646865f, 0.22546506f, 0.16661617f, 
    0.28655395f, -0.00938592f, 0.03661243f, -0.04471032f, 0.00310497f, 0.04303358f, -0.02563697f, -0.02633370f, 
    -0.03245247f, 0.01782218f, 0.03739814f, 0.10559189f, -0.08784029f, -0.08675461f, -0.04171053f, -0.09869829f, 
    -0.11096340f, 0.05792245f, -0.10999984f, -0.06486666f, 0.01050134f, -0.01458418f, -0.00807605f, 0.06386552f, 
    -0.00861540f, -0.02859325f, 0.04508966f, 0.03859346f, 0.02382814f, 0.07031062f, 0.07196479f, 0.19209692f, 
    0.09221114f, 0.02957190f, -0.05752236f, 0.08071673f, 0.15803577f, 0.15814580f, -0.19386610f, 0.02553534f, 
    0.14390305f, 0.02810409f, 0.06376786f, -0.00193289f, 0.05258060f, 0.09864619f, 0.09751901f, 0.02672520f, 
    0.12321077f, -0.10423186f, 0.00067509f, 0.00140349f, 0.07298631f, 0.07038826f, -0.01769100f, 0.00368618f, 
    0.25344160f, 0.19366774f, -0.17787753f, 0.09616295f, 0.06553148f, 0.10908922f, -0.02548535f, 0.04618265f, 
    0.04170729f, 0.00733422f, -0.04466125f, 0.11625189f, -0.03007188f, 0.05807773f, 0.02495539f, 0.14743920f, 
    0.00021461f, 0.03117079f, -0.11470117f, -0.01259372f, -0.26414934f, -0.21994363f, -0.04219890f, 0.13137351f, 
    -0.01670180f, 0.12240039f, 0.02996376f, 0.05928677f, 0.05114601f, 0.00717889f, -0.08259848f, 0.01904634f, 
    -0.04722906f, -0.00349858f, -0.03031518f, -0.04422553f, 0.07782231f, -0.01388532f, 0.00757309f, -0.07469894f, 
    -0.35544479f, -0.02350138f, -0.08799418f, 0.02480318f, 0.08501910f, -0.08089623f, -0.08990867f, -0.09994888f, 
    0.04756031f, -0.01155172f, 0.04837732f, 0.04486890f, -0.15698664f, -0.05052465f, 0.03745982f, 0.04428759f, 
    0.10933883f, -0.07310907f, -0.00628252f, 0.02413488f, -0.33833432f, -0.01256340f, 0.01742137f, -0.02237923f, 
    -0.14893238f, -0.06651281f, -0.06920508f, -0.00606555f, 0.12536536f, -0.09187414f, -0.02327075f, 0.07256437f, 
    -0.15056132f, 0.08609736f, 0.01851186f, 0.04535915f, 0.10428380f, 0.01238927f, -0.01344609f, 0.02896426f, 
    0.01469339f, -0.01258170f, -0.10897516f, 0.03474656f, -0.00609307f, -0.06801243f, -0.03707209f, -0.18094847f, 
    -0.12439574f, 0.02766071f, -0.04993297f, -0.04032890f, -0.01310205f, -0.08172135f, -0.00652455f, 0.02707140f, 
    0.07210965f, -0.05913645f, -0.01978580f, 0.13241126f, 0.07947608f, 0.02703389f, -0.06176657f, -0.17848654f, 
    -0.22972371f, -0.06275529f, -0.03611081f, 0.02424713f, 0.03495895f, -0.04251552f, 0.10067029f, 0.06846783f, 
    0.08718738f, 0.02113781f, 0.02313431f, 0.06513427f, 0.03829356f, -0.01122044f, 0.09931134f, -0.07115622f, 
    0.08888379f, 0.19073753f, 0.38619497f, 0.30055809f, -0.08962918f, 0.30717912f, -0.02133713f, -0.05611409f, 
    0.08692082f, 0.00790420f, -0.12724200f, 0.10635865f, -0.03796106f, 0.09011248f, 0.03094842f, -0.13631581f, 
    0.00220990f, 0.07728072f, 0.08295167f, -0.04253530f, 0.12284659f, 0.17547022f, 0.01438433f, 0.03903565f, 
    0.15937501f, -0.03992841f, -0.07581627f, -0.00407075f, -0.14384730f, 0.02130749f, -0.02456238f, -0.01382933f, 
    0.07380720f, 0.04446016f, -0.02020496f, 0.05477310f, 0.08425415f, 0.02265722f, 0.01207049f, 0.06694844f, 
    0.12425524f, 0.43281174f, 0.21572272f, 0.07823940f, 0.10293657f, 0.07027742f, 0.07303961f, 0.15093678f, 
    0.17359447f, -0.00356180f, 0.00386121f, 0.03385183f, 0.00428831f, 0.12288322f, -0.11586754f, -0.02627417f, 
    -0.01770334f, -0.06226125f, 0.17723227f, 0.03695672f, -0.16107015f, -0.23205039f, -0.10771304f, -0.00800961f, 
    -0.02029971f, -0.16617060f, 0.13411485f, -0.04073480f, 0.01481923f, 0.03799172f, 0.00701620f, -0.12559904f, 
    -0.01121382f, 0.00201369f, 0.05764302f, 0.04800972f, 0.11003640f, -0.03959351f, 0.10746364f, 0.11479537f, 
    -0.21859001f, -0.21419306f, 0.03607180f, 0.22888480f, -0.16567430f, 0.14895037f, -0.11289871f, 0.02448023f, 
    0.02509837f, -0.04241141f, 0.02083568f, -0.01045197f, -0.09358492f, 0.00813082f, -0.06113820f, 0.13223155f, 
    0.02340025f, -0.02030723f, -0.03328131f, 0.05169849f, -0.10991064f, 0.11342960f, -0.06339891f, -0.14461355f, 
    -0.26284838f, 0.05517524f, 0.01247920f, 0.15599059f, 0.03453248f, -0.19728042f, 0.06267570f, -0.05046392f, 
    0.02893386f, -0.10293674f, -0.11571185f, 0.09187690f, 0.09922232f, 0.08592226f, 0.05840714f, -0.05556374f, 
    -0.41698867f, 0.05355416f, -0.21281235f, -0.12620562f, 0.12270340f, -0.04335422f, -0.05032979f, -0.09116346f, 
    0.01870711f, 0.02947048f, 0.03807053f, -0.01579076f, -0.03187090f, 0.12348787f, 0.01159284f, -0.01503519f, 
    0.03061235f, -0.14940952f, -0.05418450f, 0.12055642f, 0.04875012f, -0.26885217f, -0.36767998f, 0.23415986f, 
    0.16053879f, 0.03352602f, -0.00300837f, 0.04052548f, -0.04102717f, -0.04297544f, -0.08861887f, 0.02645783f, 
    -0.08932445f, 0.03811109f, 0.04213787f, 0.01584426f, -0.12419460f, 0.09932446f, -0.00760605f, -0.07929320f, 
    -0.32311559f, -0.01440250f, 0.06883240f, 0.09385896f, -0.02498343f, -0.07789330f, 0.11393645f, -0.02220071f, 
    0.07461893f, -0.01663046f, -0.15442127f, -0.00837210f, -0.00661285f, 0.08166020f, -0.01714757f, 0.04206036f, 
    -0.01716267f, -0.01057873f, 0.09662630f, -0.05648009f, 0.20197795f, 0.01076316f, 0.03680554f, 0.10074671f, 
    0.11332460f, 0.11523397f, 0.07437293f, 0.17230397f, -0.07722883f, 0.00345853f, -0.07146651f, 0.04547326f, 
    -0.08722701f, -0.14704403f, 0.00504494f, -0.02898130f, 0.12899676f, -0.02095694f, 0.03560705f, 0.04944922f, 
    -0.03744918f, 0.28455064f, -0.10428956f, -0.01717143f, 0.07406923f, -0.04864926f, 0.09908420f, -0.05547072f, 
    0.07591356f, 0.09135927f, 0.00163985f, 0.05331425f, 0.11602452f, -0.07563639f, 0.07160968f, -0.03496599f, 
    0.11333724f, 0.03899534f, 0.15105017f, 0.02838145f, 0.25001532f, 0.31099775f, 0.08690336f, 0.04932727f, 
    -0.06709008f, -0.00874644f, 0.03743014f, 0.05980237f, 0.09836249f, -0.04125617f, 0.00767768f, -0.02870460f, 
    0.00135495f, 0.09772439f, -0.03157172f, 0.01548571f, 0.03620109f, -0.02157484f, 0.11636429f, 0.08874808f, 
    0.21024117f, 0.07350420f, -0.12332928f, 0.31464684f, 0.25466588f, 0.06474575f, 0.08797586f, -0.15250906f, 
    0.00431314f, 0.10215606f, 0.00443042f, 0.14097871f, -0.04792270f, 0.03812550f, 0.07432795f, 0.10650918f, 
    0.11425257f, 0.01286227f, -0.01674023f, -0.02737668f, 0.11639942f, 0.22768645f, -0.17865393f, 0.08308433f, 
    0.10026599f, -0.09817360f, 0.07397340f, 0.17875908f, 0.03233921f, 0.03650123f, 0.01544941f, -0.01622647f, 
    0.00652764f, -0.08021564f, -0.01522450f, 0.12822001f, 0.04367657f, 0.08970181f, 0.04161208f, -0.01282698f, 
    0.08708769f, 0.21196339f, 0.04098793f, 0.04670847f, -0.05536374f, 0.06011209f, 0.00958842f, -0.05147611f, 
    0.07305637f, 0.11245108f, 0.04591723f, 0.02284738f, -0.04672429f, 0.06830897f, 0.02066805f, 0.07370701f, 
    -0.07874590f, 0.02118057f, 0.03170004f, 0.06949860f, 0.05691529f, 0.01264343f, -0.09302000f, -0.06887952f, 
    -0.21545266f, -0.05029198f, -0.11274200f, -0.13555248f, -0.05703919f, -0.09423438f, 0.01351876f, 0.11941807f, 
    0.03818178f, -0.01310180f, 0.05154847f, 0.02927293f, 0.06237776f, 0.06982061f, 0.03906495f, 0.04203210f, 
    0.29881269f, 0.15144813f, -0.00687613f, 0.22557338f, 0.25679454f, -0.03968580f, 0.07756672f, -0.10746485f, 
    0.03722787f, 0.08674888f, -0.06758132f, 0.10175516f, 0.04225247f, 0.06914040f, 0.03948256f, 0.08946417f, 
    0.03517194f, 0.04414657f, 0.07680004f, 0.03675796f, 0.09413256f, 0.11628585f, -0.07865013f, -0.02012493f, 
    -0.09803908f, -0.04115205f, 0.17673729f, 0.08165234f, -0.03614835f, -0.04119839f, -0.02146651f, 0.14848746f, 
    0.05645975f, -0.07547724f, 0.05460774f, 0.04873625f, 0.00242894f, 0.17240706f, -0.02498856f, 0.12342151f, 
    0.22914828f, 0.28816372f, -0.08026021f, 0.18877274f, 0.05406110f, 0.05887345f, 0.00963234f, -0.01086088f, 
    0.03850049f, 0.02151820f, 0.09497880f, 0.02146933f, 0.07770307f, 0.14573467f, 0.01111057f, 0.04768075f, 
    -0.09083208f, 0.09071522f, -0.00068810f, -0.02257532f, -0.00010177f, -0.08570224f, 0.25241411f, -0.08488762f, 
    0.16108152f, 0.00967777f, 0.04493598f, 0.05554364f, 0.02892071f, 0.16760257f, 0.01379772f, 0.01839313f, 
    -0.03141459f, 0.06055285f, -0.08779871f, 0.15262713f, 0.02275233f, 0.04910373f, -0.03114708f, 0.10106440f, 
    0.34547558f, 0.37806857f, 0.07005464f, 0.08800475f, 0.16472358f, 0.14637491f, 0.01049299f, 0.00428922f, 
    -0.07951342f, 0.00676775f, 0.06614373f, 0.07979892f, 0.03173052f, 0.03842433f, 0.09643970f, -0.04829308f, 
    0.02913316f, 0.12757231f, 0.03469869f, -0.02915470f, -0.00939929f, 0.08961607f, 0.04621165f, -0.05317095f, 
    -0.08600767f, -0.03687804f, -0.04685909f, 0.00332950f, 0.02235053f, 0.03830282f, 0.03182233f, 0.05301452f, 
    -0.00607523f, 0.07776031f, 0.14713641f, 0.05450743f, 0.11242419f, 0.05849863f, -0.06010865f, 0.04671147f, 
    0.09370916f, 0.27288461f, 0.12143961f, 0.09789617f, 0.01034231f, 0.05880599f, -0.15355252f, 0.05090393f, 
    0.03779848f, 0.05201236f, -0.01349433f, 0.07768500f, -0.08573531f, -0.09633910f, -0.05739892f, 0.09110299f, 
    0.01332854f, -0.06186643f, -0.02971924f, 0.02347353f, -0.11522068f, -0.23455583f, -0.01452405f, 0.00311307f, 
    -0.01556799f, 0.07180899f, -0.02190526f, 0.04960871f, -0.03658981f, 0.00348564f, 0.07954731f, 0.06683807f, 
    0.09934752f, 0.11021583f, 0.05223063f, -0.06605785f, 0.00005098f, 0.12655516f, -0.06066974f, 0.08282294f, 
    0.19649336f, 0.08523114f, 0.25505644f, -0.08177186f, 0.00611933f, -0.04208791f, -0.03762905f, 0.07576674f, 
    -0.00467676f, -0.02457261f, 0.06705647f, 0.07611492f, 0.04212580f, 0.07916491f, 0.08779561f, -0.03839879f, 
    0.00156516f, 0.01750535f, 0.06696846f, -0.07367466f, -0.16239785f, -0.16058598f, -0.07847005f, -0.02420401f, 
    -0.07467807f, 0.08446820f, 0.05688729f, 0.01752381f, 0.04476823f, 0.05197871f, -0.00187659f, 0.05525574f, 
    -0.00731306f, 0.08187460f, 0.14922929f, -0.00945293f, 0.12647188f, 0.09432620f, -0.01654896f, 0.11048248f, 
    -0.20304695f, -0.14950061f, 0.10811188f, -0.22141586f, -0.00093733f, 0.03501390f, 0.06042046f, -0.01313563f, 
    0.00913328f, 0.12187797f, 0.03952262f, 0.03055634f, 0.05301591f, -0.02417627f, -0.01268346f, 0.08181848f, 
    0.10457873f, 0.00018287f, 0.04249045f, 0.16702400f, 0.20474756f, 0.28137049f, 0.25007251f, 0.03031448f, 
    0.02271967f, -0.08489814f, 0.05900102f, -0.02975328f, 0.02806977f, 0.01943948f, 0.09366421f, 0.01679751f, 
    0.03365200f, 0.03757953f, 0.06242793f, 0.04438972f, -0.05141637f, -0.07852916f, -0.00121668f, 0.01817830f, 
    0.42014360f, 0.06828463f, 0.22872920f, -0.15588160f, -0.00671845f, 0.02779110f, -0.03017718f, 0.23588093f, 
    -0.07790501f, 0.10223217f, -0.00322656f, -0.04678591f, 0.10416444f, 0.00831582f, 0.00083236f, 0.13854134f, 
    -0.03633010f, -0.02412097f, 0.06899995f, -0.02555062f, 0.27884087f, 0.11271750f, -0.13145554f, 0.01228291f, 
    0.02592929f, 0.03432931f, -0.08862008f, 0.08760191f, 0.09586012f, 0.10997213f, 0.08665948f, -0.08086535f, 
    0.04001874f, -0.08965465f, -0.02371564f, 0.08357076f, -0.13602261f, -0.05013479f, 0.15825143f, 0.05070299f, 
    0.11280979f, -0.13989325f, -0.06775124f, -0.07367782f, -0.08730957f, 0.07222144f, 0.03694327f, 0.02151290f, 
    0.11595260f, 0.01428784f, 0.01626276f, 0.07479739f, 0.05808146f, -0.01635986f, 0.02310309f, 0.04643276f, 
    0.03466908f, 0.14110824f, 0.04329701f, 0.08744343f, -0.05969237f, 0.15291944f, -0.04647715f, 0.02533585f, 
    0.16103362f, 0.10446103f, 0.11857816f, 0.03639089f, 0.11029664f, 0.10556733f, 0.03858342f, -0.07620198f, 
    -0.03350744f, -0.06107771f, 0.01683406f, 0.07728163f, 0.03022048f, 0.03893862f, 0.04581189f, 0.19306836f, 
    -0.01568253f, -0.14795136f, -0.07588013f, -0.09320496f, -0.20924200f, -0.08597530f, 0.12371839f, -0.05376620f, 
    -0.08207070f, 0.03485844f, -0.08244130f, -0.09846993f, 0.05845175f, -0.00420314f, -0.01464966f, 0.13285066f, 
    0.09541152f, -0.08824940f, 0.04691855f, 0.07204257f, 0.14209083f, -0.18700600f, -0.13041718f, -0.04179246f, 
    -0.12798065f, 0.08442270f, 0.06990700f, -0.01298020f, 0.12886441f, 0.00729833f, 0.04760394f, 0.06778200f, 
    0.04928878f, 0.07142302f, 0.03500605f, 0.05572514f, 0.00774082f, 0.06541020f, 0.06095733f, 0.01691790f, 
    0.11424183f, -0.42766085f, -0.22754353f, -0.32323697f, 0.03715118f, -0.06534551f, -0.06613778f, -0.00650334f, 
    -0.03577745f, 0.09712584f, 0.14013258f, -0.04737540f, -0.01512217f, -0.04367583f, 0.08139753f, 0.03717711f, 
    0.02200541f, -0.00895812f, -0.02417508f, 0.00305560f, 0.19275102f, 0.28974581f, 0.14953314f, 0.05491949f, 
    0.12000564f, 0.00118627f, -0.05789360f, 0.09406136f, -0.09582602f, -0.00264766f, -0.03414840f, -0.08113179f, 
    0.00617859f, 0.03424899f, 0.00707128f, 0.09695794f, -0.03485458f, 0.04802029f, -0.08189952f, -0.05403820f, 
    0.20421523f, 0.31651288f, -0.04162448f, 0.02933337f, 0.11191462f, 0.00742624f, 0.24673484f, -0.08191523f, 
    -0.01253262f, 0.02482814f, -0.00439142f, -0.03151534f, 0.08821258f, 0.08928839f, 0.11253152f, -0.01461419f, 
    0.04977426f, 0.00012865f, 0.11727503f, 0.07820441f, 0.08069663f, 0.14932828f, 0.00915802f, -0.04595007f, 
    0.17809959f, 0.04086841f, 0.05162876f, -0.07717865f, 0.06092127f, 0.18907028f, -0.00833656f, -0.07472321f, 
    -0.14685865f, 0.01104137f, 0.08930650f, 0.13802390f, 0.00948812f, -0.06830073f, -0.13264517f, 0.03618826f, 
    0.45852262f, -0.22644739f, 0.35729071f, -0.05993957f, 0.21990170f, 0.06370459f, -0.00427408f, 0.15262426f, 
    -0.09824522f, 0.05072260f, 0.01750252f, -0.01102765f, 0.11493646f, 0.03201822f, 0.06693921f, 0.10922781f, 
    -0.01229370f, -0.00861371f, 0.02595199f, -0.01704643f, 0.04534474f, 0.22341515f, 0.39411351f, 0.08399039f, 
    0.09943007f, 0.01368198f, 0.02092256f, -0.07464166f, -0.03145651f, -0.03845806f, -0.01146442f, -0.04995716f, 
    0.12868416f, 0.10054251f, 0.16399443f, 0.06405464f, 0.17624666f, -0.10074383f, -0.06484940f, -0.01673472f, 
    0.28639653f, 0.32792991f, -0.10862214f, 0.10202586f, 0.11758602f, 0.03270285f, 0.08147509f, 0.02847785f, 
    -0.05782279f, 0.02242355f, 0.08620113f, -0.06371751f, 0.07186569f, 0.02659404f, 0.15582129f, 0.08542279f, 
    0.03952953f, 0.03874058f, -0.07593615f, 0.10560152f, -0.01839541f, -0.00106692f, -0.24697863f, -0.01510305f, 
    0.00710820f, -0.04436478f, 0.13089909f, -0.03245705f, 0.08429562f, 0.16137095f, -0.00433665f, 0.02001513f, 
    0.12244079f, 0.10810784f, -0.04811258f, 0.00109385f, 0.01679884f, 0.01915058f, -0.05254222f, 0.02198797f, 
    -0.06427015f, -0.19608045f, -0.22365318f, 0.00032996f, -0.04606353f, 0.01134709f, 0.00233951f, 0.01395950f, 
    0.09036839f, 0.07879463f, 0.04721799f, -0.03678465f, 0.00100043f, -0.01711380f, 0.05235177f, -0.04726816f, 
    0.01509237f, -0.05927760f, 0.05915111f, -0.04514578f, -0.01412381f, -0.11059074f, -0.02115862f, -0.16603740f, 
    -0.01009186f, 0.00828972f, -0.01172335f, -0.05352304f, 0.00193156f, 0.02639640f, 0.08609404f, -0.00150275f, 
    0.07209115f, 0.00184042f, 0.09213676f, 0.02391544f, 0.02056851f, -0.01490364f, 0.00908158f, -0.04843519f, 
    -0.18554214f, -0.03932199f, 0.01251888f, -0.07098106f, -0.26806796f, -0.04176024f, -0.01517760f, -0.05019398f, 
    0.01687239f, 0.03878393f, -0.01092741f, 0.11419690f, 0.06321417f, 0.04687038f, 0.21487236f, -0.04052703f, 
    0.09635966f, -0.01353710f, 0.00815274f, 0.14076540f, -0.08352903f, -0.16964182f, 0.00066878f, -0.03490879f, 
    -0.04940937f, 0.07041432f, -0.00222133f, -0.06264770f, 0.11357554f, 0.09625475f, 0.01673865f, 0.08135629f, 
    0.05905383f, -0.00435189f, 0.10122648f, -0.04953789f, 0.13598768f, -0.00391347f, 0.01148004f, 0.05816059f, 
    0.02460339f, -0.15469524f, -0.16833189f, -0.01096848f, 0.05530345f, -0.02422447f, 0.09608371f, 0.01941686f, 
    -0.06724295f, 0.01450063f, 0.07631138f, 0.03726093f, 0.09852811f, 0.05410229f, 0.06315088f, -0.05205138f, 
    0.12929018f, -0.01851630f, -0.09602799f, 0.03083546f, -0.02909734f, 0.17170948f, 0.00045841f, 0.04661090f, 
    0.04715015f, 0.04403239f, -0.00244892f, 0.17909212f, 0.18558441f, 0.05900868f, 0.01771680f, -0.09547085f, 
    -0.00413043f, -0.11261606f, 0.00462972f, 0.04938043f, -0.00910603f, -0.04294482f, 0.00311449f, -0.00422359f, 
    -0.20478976f, -0.17181030f, 0.11263019f, -0.20468970f, -0.09154991f, 0.04379392f, -0.13695815f, 0.13820514f, 
    -0.13232502f, -0.02827335f, 0.10136852f, 0.04777537f, 0.01089282f, 0.04782974f, -0.01192071f, 0.06609099f, 
    0.02710781f, 0.02050016f, -0.05844910f, 0.02612757f, 0.02946403f, 0.01381821f, -0.06297091f, 0.04883892f, 
    0.09219243f, 0.03364606f, -0.07691794f, -0.06944708f, 0.13532513f, 0.01135626f, 0.07975858f, -0.06453148f, 
    -0.01228653f, 0.01534791f, 0.01461587f, 0.04266502f, 0.08085728f, -0.02438039f, 0.06457214f, -0.09064490f, 
    0.01804397f, -0.00366198f, -0.00035595f, 0.00240527f, -0.02590344f, -0.02922510f, 0.02398315f, 0.02820336f, 
    0.01819952f, -0.02924485f, -0.02291279f, 0.03341472f, -0.02447422f, 0.02276324f, -0.00866120f, -0.00809057f, 
    -0.00724673f, -0.00517942f, -0.01605473f, -0.02231484f, -0.01658361f, 0.00770147f, -0.00433091f, -0.02004435f, 
    0.00083424f, -0.00899700f, -0.03508412f, -0.01995358f, -0.03588127f, -0.01035339f, 0.00409735f, 0.01331432f, 
    -0.01492177f, 0.00653890f, -0.00704869f, 0.01502639f, -0.02600160f, 0.03022368f, -0.02124025f, 0.00299419f, 
    0.00049415f, -0.02069172f, -0.02218085f, -0.01103555f, -0.02270619f, -0.03021377f, -0.00832296f, 0.01387982f, 
    0.03077331f, -0.00525706f, -0.04199319f, -0.01729399f, -0.01739712f, 0.03883991f, -0.01634682f, -0.01046685f, 
    0.02933885f, -0.04182689f, -0.02554778f, 0.00902428f, -0.01972311f, -0.00067366f, 0.02238140f, -0.04348340f, 
    -0.02168480f, -0.00315666f, -0.02702042f, -0.02022663f, 0.02398622f, -0.01209231f, 0.02221087f, 0.02951246f, 
    0.00769187f, 0.01100173f, -0.00974561f, -0.00864061f, -0.02501970f, -0.03002555f, -0.00028955f, 0.02823316f, 
    -0.01036808f, 0.04611446f, 0.00406171f, -0.03472114f, -0.03457308f, 0.03267394f, -0.01606292f, 0.00327704f, 
    -0.01176300f, -0.04220694f, 0.02089060f, 0.01637002f, -0.02517571f, 0.01331771f, -0.01990198f, 0.01708881f, 
    -0.02804783f, -0.02950945f, -0.00809560f, 0.01783258f, 0.01410894f, -0.02576230f, -0.02109923f, -0.00417644f, 
    0.00944941f, -0.01265505f, 0.02753105f, -0.03749567f, -0.03484708f, 0.03432973f, -0.00203727f, 0.01683663f, 
    0.00282742f, 0.00105631f, 0.01964753f, 0.01565401f, -0.02136823f, -0.00386624f, -0.02006537f, 0.03127140f, 
    -0.01561144f, -0.02507198f, 0.02336227f, -0.02425267f, -0.01877490f, -0.00928408f, 0.03616305f, 0.00932757f, 
    0.03272465f, -0.01113888f, -0.01001739f, 0.01252445f, -0.00257576f, -0.02345191f, 0.00668709f, -0.04339635f, 
    -0.01181944f, 0.02052059f, -0.04260466f, 0.01932015f, 0.01563605f, -0.02164897f, -0.00192680f, -0.02879133f, 
    -0.04304080f, 0.00582996f, -0.02560151f, -0.04389376f, -0.01510854f, 0.02710765f, -0.02512587f, -0.03819836f, 
    0.02278836f, 0.02944606f, -0.02332211f, 0.00842279f, 0.03097360f, -0.03811311f, 0.02169134f, 0.00682033f, 
    -0.02621463f, -0.00644615f, 0.01302361f, -0.04007358f, 0.00720595f, 0.01210366f, 0.00087498f, -0.03690160f, 
    -0.02743792f, -0.02816900f, -0.02166793f, -0.01533424f, -0.02591549f, 0.03044076f, -0.01061328f, 0.03203232f, 
    -0.03047128f, 0.02016523f, -0.02807304f, -0.00596529f, 0.01971225f, -0.00173891f, -0.04151124f, 0.00190543f, 
    0.00454107f, 0.02031862f, -0.00516051f, -0.01909574f, -0.04197236f, -0.01011926f, -0.01167008f, -0.02493275f, 
    -0.00121746f, -0.03419758f, -0.02300325f, 0.02739487f, -0.02084890f, -0.04175032f, 0.03852420f, -0.00499227f, 
    -0.00773974f, -0.01354608f, 0.00943824f, 0.00340447f, 0.00881798f, -0.02993311f, 0.03343198f, -0.03822159f, 
    0.00744575f, 0.01227151f, -0.02306246f, 0.03567344f, 0.02835435f, -0.02188313f, -0.04255392f, -0.00701917f, 
    -0.00080342f, 0.02122001f, 0.00009913f, -0.03255238f, 0.01501299f, 0.01057669f, 0.02697088f, 0.00598181f, 
    -0.03355055f, -0.03086817f, 0.02191366f, -0.02573877f, 0.02529086f, -0.03393226f, 0.02226877f, -0.01628147f, 
    0.00272252f, -0.03922131f, 0.01614380f, -0.03331072f, -0.03008927f, -0.02008972f, 0.02801889f, 0.03344562f, 
    0.04085362f, -0.01184295f, -0.01915155f, -0.02880117f, -0.01859563f, 0.00867189f, 0.00792060f, 0.02507064f, 
    -0.03178608f, -0.01008613f, -0.01362636f, -0.02169202f, 0.01153280f, -0.00841265f, 0.00803589f, 0.02231486f, 
    -0.00514009f, -0.03146477f, 0.02532260f, -0.04326706f, 0.01502113f, 0.03780560f, -0.02761620f, 0.01848037f, 
    0.00048866f, -0.03606650f, 0.03829049f, 0.03255249f, -0.03958312f, -0.00511030f, -0.00418739f, 0.04623102f, 
    -0.02373428f, -0.02787280f, -0.01221065f, -0.02508214f, 0.00119143f, 0.02145402f, -0.02972360f, -0.00001565f, 
    -0.03557115f, 0.01993804f, 0.04224874f, 0.02402598f, -0.03663837f, 0.03879422f, 0.03260245f, -0.00201913f, 
    0.00041133f, 0.02030388f, 0.01782485f, -0.02165747f, -0.02154590f, -0.00577342f, -0.03933290f, -0.00532411f, 
    0.00000818f, -0.02289453f, 0.00328869f, 0.01543430f, 0.00905559f, -0.01949327f, -0.01724104f, 0.03465565f, 
    0.01346600f, 0.02139777f, 0.01908585f, 0.01659690f, 0.00140787f, 0.02696924f, -0.01717625f, 0.01338366f, 
    -0.02526526f, 0.01530752f, 0.01010619f, 0.00127299f, -0.03232836f, -0.02790680f, -0.02736785f, -0.03394528f, 
    -0.03738394f, 0.04316280f, 0.02191415f, -0.04064165f, 0.00754416f, -0.02815680f, 0.02541586f, 0.02789421f, 
    -0.02738800f, -0.01034884f, -0.02537859f, -0.02472305f, -0.00634528f, 0.02085014f, 0.01824979f, 0.02517045f, 
    0.02588963f, -0.00136426f, 0.02805918f, 0.02991001f, -0.00846313f, 0.01749260f, -0.02349542f, 0.01229325f, 
    0.01357032f, 0.04077516f, -0.00533038f, 0.03741786f, 0.00270611f, -0.00197522f, -0.02355849f, 0.01163074f, 
    -0.03776002f, 0.00530711f, 0.00037177f, 0.03807269f, 0.00188493f, -0.01884665f, 0.00565056f, 0.02712719f, 
    -0.01401809f, -0.00164384f, -0.04294515f, -0.01255292f, -0.01686321f, 0.03535443f, 0.03060544f, -0.01052914f, 
    -0.02250293f, 0.02421218f, -0.04026317f, -0.00953895f, -0.00478303f, -0.03999066f, -0.01951315f, -0.03401075f, 
    0.00137462f, -0.03556818f, 0.02984584f, 0.00776938f, 0.00768817f, -0.03023783f, 0.01495444f, -0.02112467f, 
    0.01858489f, -0.02777932f, -0.00198791f, -0.01091174f, 0.02240312f, -0.02265442f, 0.01407369f, 0.01825475f, 
    0.02525591f, -0.02560476f, 0.01785306f, -0.02219230f, -0.02973711f, -0.01155092f, 0.02025178f, 0.01340482f, 
    -0.03943867f, 0.03947188f, 0.00493197f, 0.02899618f, 0.01485537f, 0.01850863f, 0.02191667f, 0.03017351f, 
    -0.02139590f, 0.03058573f, -0.02087366f, 0.00393934f, -0.02290496f, 0.01003498f, -0.04390985f, -0.00031791f, 
    0.00028210f, 0.01606806f, 0.01188358f, -0.04147141f, -0.01073170f, -0.03035671f, 0.00989992f, -0.01287845f, 
    -0.00553800f, 0.02950235f, -0.00376007f, 0.01901025f, -0.04101418f, -0.04038309f, 0.01356483f, -0.00967873f, 
    0.03263396f, 0.00839145f, -0.02169035f, -0.02767085f, -0.00969826f, -0.01506516f, -0.00401443f, 0.02047247f, 
    -0.02226990f, 0.02023679f, 0.03455412f, -0.03221956f, 0.01568419f, -0.02410687f, -0.02185741f, 0.00343804f, 
    0.01600564f, 0.02855443f, -0.02912632f, -0.00689586f, 0.02683014f, -0.02082479f, -0.04069861f, -0.02916833f, 
    -0.02283504f, -0.02715682f, -0.00563287f, 0.01274247f, 0.03715254f, -0.02062802f, -0.03705729f, 0.01737970f, 
    0.01441630f, 0.00979012f, -0.02786613f, -0.02633127f, 0.03070009f, -0.01136123f, 0.02374708f, 0.03007065f, 
    0.01953294f, -0.01197251f, 0.01739541f, 0.02894948f, -0.04490186f, -0.01104074f, -0.00258470f, -0.01470138f, 
    -0.02806478f, 0.00999657f, 0.03933392f, -0.02084073f, 0.03018479f, -0.03036400f, 0.00034812f, 0.00048528f, 
    0.01686886f, -0.00107568f, -0.03650159f, -0.00303497f, -0.02071637f, 0.01005109f, -0.02371852f, 0.01647776f, 
    -0.00053500f, 0.01192754f, -0.01716609f, 0.03126961f, 0.01093241f, -0.03214048f, -0.04047005f, -0.00902815f, 
    0.03253149f, 0.02172099f, -0.02922780f, -0.03156519f, 0.00172310f, -0.03539835f, -0.02826212f, 0.02393157f, 
    -0.01427236f, 0.02121814f, 0.02077074f, 0.00369931f, 0.03095429f, 0.02524948f, 0.02161417f, -0.00443205f, 
    0.01852998f, 0.01596247f, 0.03344345f, -0.03312213f, 0.00275661f, 0.02545092f, 0.02288927f, 0.02548748f, 
    0.03338293f, -0.00408980f, 0.00222769f, 0.02509085f, -0.01963904f, -0.01477665f, 0.00054284f, -0.01784302f, 
    0.01953709f, -0.00689291f, 0.01703051f, 0.01132001f, 0.02997672f, -0.01589638f, -0.02530540f, -0.02566105f, 
    -0.00738271f, -0.01810220f, 0.02242834f, 0.02825901f, -0.01927993f, 0.00049543f, 0.01529983f, -0.03585834f, 
    -0.00782631f, 0.01901579f, -0.02843440f, -0.02858444f, 0.00491015f, 0.00437116f, -0.03205739f, 0.02859603f, 
    -0.02218482f, -0.02703255f, 0.03735972f, -0.01597673f, -0.01396617f, -0.01432054f, -0.03011671f, -0.02764147f, 
    -0.04187036f, 0.00775350f, 0.02275502f, 0.00804654f, -0.01879387f, -0.01495156f, 0.01043226f, -0.03000694f, 
    0.00595851f, -0.02500281f, 0.02672573f, -0.00396474f, 0.02774656f, 0.03220548f, -0.01136949f, 0.00058065f, 
    0.03262110f, -0.00653644f, 0.04300168f, -0.00511909f, 0.01184690f, 0.01430091f, -0.00989375f, 0.03014796f, 
    0.02028391f, 0.00957265f, -0.03869635f, -0.02893521f, -0.00577035f, 0.01913472f, -0.03837734f, -0.02250944f, 
    0.02130331f, -0.03594368f, 0.00074360f, 0.02254814f, 0.00882282f, -0.03811222f, -0.03043985f, -0.00934961f, 
    -0.01775994f, -0.01342151f, -0.02401532f, -0.00428550f, -0.00728458f, -0.01404445f, 0.02271642f, 0.02120562f, 
    0.02820441f, 0.01567436f, -0.00829041f, 0.02882899f, -0.01709596f, 0.03738150f, -0.00622325f, -0.03345281f, 
    0.02322241f, -0.03621889f, -0.03966574f, 0.00171586f, 0.01033894f, 0.00993951f, 0.02423287f, -0.00432286f, 
    0.00283645f, 0.01189633f, 0.00624731f, -0.01595397f, 0.00854877f, -0.00955329f, -0.00862141f, -0.02788161f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02628746f, 0.02466565f, -0.03761973f, 0.02495269f, 0.01100785f, 0.03437182f, 0.08735741f, -0.00422235f, 
    -0.06290097f, -0.03097974f, -0.00968077f, -0.02607617f, -0.03017562f, 0.06806012f, 0.06002912f, -0.00458586f, 
    -0.01053015f, 0.01935907f, 0.01544038f, 0.03878699f, -0.03189531f, 0.06519531f, 0.00055062f, -0.04182120f, 
    -0.02356663f, 0.07119113f, -0.04645868f, 0.00298958f, 0.05394134f, 0.02507022f, 0.05227577f, -0.01906323f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.13154589f, -0.18590407f, 0.14566924f, 0.00008643f, 0.03862005f, 0.32537240f, 0.23920184f, -0.12522021f, 
    -0.23327614f, 0.07664980f, 0.15553111f, 0.13431737f, -0.35018474f, 0.32545161f, 0.23013020f, -0.01234254f, 
    -0.02628239f, -0.08341841f, -0.01012913f, 0.00959077f, -0.07547201f, 0.03512242f, 0.11664028f, -0.25034925f, 
    -0.15478811f, 0.32815197f, 0.03666659f, -0.15400694f, 0.27218744f, -0.17159356f, 0.22182268f, 0.16817974f, 
    0.10346114f, -0.01171394f, 0.08350091f, -0.02899334f, 0.13306147f, -0.16669083f, 0.12488245f, 0.05827228f, 
    0.28082898f, -0.11170622f, 0.08936864f, 0.09441841f, -0.13031216f, -0.06292647f, -0.19827022f, -0.14012171f, 
    0.05553650f, -0.11899199f, -0.22730069f, 0.10972411f, -0.00305117f, -0.09743951f, 0.28422070f, 0.19282666f, 
    0.06586444f, -0.16283672f, 0.08158521f, 0.06425010f, 0.47688004f, 0.12555343f, 0.20399378f, 0.06734131f, 
    0.01613598f, 0.02977184f, -0.02176796f, 0.16606876f, 0.16257504f, 0.11568584f, 0.03242390f, -0.11625283f, 
    -0.07319713f, -0.02594596f, -0.15990140f, 0.01314291f, -0.11160938f, -0.02621420f, -0.14972550f, 0.14471051f, 
    -0.13355768f, -0.01274995f, -0.02134681f, -0.10071357f, -0.04029734f, 0.10437655f, -0.04128758f, -0.15823483f, 
    0.06906924f, 0.15859386f, -0.08425592f, 0.17021047f, -0.09859070f, -0.16023122f, -0.16229621f, -0.13296610f, 
    0.14532413f, -0.09030456f, -0.09892396f, -0.13036087f, 0.10028066f, 0.30029401f, -0.22282827f, -0.17119959f, 
    0.03283710f, 0.03037186f, 0.02039794f, -0.17086644f, -0.06004533f, 0.04303863f, -0.22379246f, 0.02546662f, 
    0.14450091f, -0.11624533f, 0.18967305f, -0.52742571f, 0.00417884f, -0.61215693f, 0.00053795f, 0.12041098f, 
    0.10710823f, 0.27227136f, -0.10720639f, 0.01858663f, 0.13785505f, 0.00710409f, 0.22453025f, -0.01317352f, 
    0.03738568f, 0.25049266f, 0.14643674f, 0.01913430f, -0.10917312f, 0.07494007f, -0.18121855f, 0.10551374f, 
    0.08026732f, 0.07281803f, -0.13110973f, 0.14778040f, -0.23744829f, -0.35464567f, -0.19731347f, -0.15933923f, 
    0.14928544f, -0.14847925f, 0.45508388f, 0.01405748f, -0.04820998f, -0.35152334f, 0.19808388f, 0.11297093f, 
    0.17066596f, 0.09842975f, -0.11311563f, 0.17986813f, 0.22496948f, 0.39345813f, -0.11540909f, 0.15811259f, 
    -0.14542538f, 0.03240764f, -0.01282524f, 0.15726243f, -0.06679989f, 0.22552948f, 0.11693294f, 0.07984242f, 
    0.26785561f, -0.11195979f, 0.00600327f, 0.14631972f, 0.36409789f, 0.35931599f, -0.29597500f, 0.00253241f, 
    0.16107267f, -0.09703921f, -0.17957006f, 0.14514174f, 0.07875021f, -0.33312681f, 0.04773100f, 0.29691911f, 
    -0.04424040f, -0.14343280f, -0.10852538f, 0.01425756f, -0.33957484f, -0.25351560f, 0.16975585f, -0.07989126f, 
    0.11243602f, -0.06536648f, -0.12305412f, -0.07909162f, 0.15892456f, -0.21374510f, -0.25298411f, 0.12677518f, 
    0.24474700f, 0.01072943f, 0.04131326f, 0.01293719f, -0.18829888f, 0.46529320f, 0.35488400f, -0.03118408f, 
    0.01402939f, 0.10013543f, -0.14512841f, 0.18396038f, 0.00763226f, 0.00648047f, 0.24727841f, 0.35354647f, 
    -0.04591581f, -0.33992133f, -0.16619770f, 0.05348665f, 0.40109092f, 0.12091706f, 0.04911060f, 0.10947481f, 
    0.02001084f, 0.33204013f, -0.03393551f, 0.12345524f, -0.15129319f, -0.31785792f, -0.04655762f, -0.09228985f, 
    0.10380873f, -0.13015063f, 0.16323820f, 0.10395696f, 0.07146133f, -0.27987507f, 0.26696336f, -0.07082354f, 
    -0.14451352f, 0.08986007f, 0.24360114f, -0.07363643f, -0.09179157f, -0.07053482f, 0.02194171f, 0.06928879f, 
    -0.11453726f, 0.10406575f, -0.16486697f, -0.10907443f, 0.43099892f, 0.09973659f, -0.12963207f, 0.02902257f, 
    0.03958372f, 0.20823717f, 0.14120422f, -0.06569841f, 0.08674644f, -0.19654480f, -0.14500807f, 0.09603592f, 
    0.09814801f, 0.11040927f, 0.06646269f, -0.09348082f, 0.35735387f, 0.05846943f, 0.28215232f, -0.05082871f, 
    0.06442663f, 0.10610323f, 0.26750633f, 0.08985900f, 0.07201038f, 0.21718596f, 0.51353872f, 0.26568383f, 
    -0.12735866f, 0.12833448f, -0.15098260f, 0.06335091f, -0.48970285f, -0.13110462f, -0.14398815f, -0.06120205f, 
    -0.02165255f, 0.30274740f, 0.07083175f, 0.01263849f, 0.12366152f, -0.04215120f, -0.24538819f, -0.04464064f, 
    0.30753523f, 0.11723550f, -0.06951032f, 0.12774388f, -0.00736975f, -0.06204005f, 0.32698503f, -0.03746797f, 
    0.14861745f, -0.08858296f, -0.14542921f, -0.09092546f, 0.13666248f, -0.01973203f, 0.15954585f, -0.02714678f, 
    0.17011669f, -0.13274656f, -0.06903329f, -0.00354191f, 0.29357836f, 0.23623927f, -0.33444959f, 0.01429289f, 
    -0.02692724f, -0.07193266f, -0.03653951f, 0.00009702f, -0.12867807f, 0.23058169f, -0.02832664f, 0.00917927f, 
    -0.10711059f, -0.12570783f, 0.04794826f, -0.17606932f, 0.12601303f, 0.10377187f, 0.35621107f, 0.04218678f, 
    -0.15358512f, 0.03967989f, 0.03613973f, 0.11373717f, -0.07464980f, 0.01128317f, -0.60529470f, -0.30642235f, 
    -0.02363235f, 0.24412245f, -0.01127869f, -0.11939041f, -0.02877339f, 0.31713450f, 0.00427685f, 0.06621394f, 
    -0.02543095f, 0.32931361f, -0.02814491f, 0.13447244f, -0.16334523f, 0.04002844f, -0.00727098f, 0.15440112f, 
    -0.03403329f, 0.01765688f, -0.07291844f, 0.15026616f, -0.22100006f, -0.16035876f, 0.38693464f, -0.14285989f, 
    -0.06154410f, -0.05803062f, 0.25909701f, 0.38746744f, 0.10984973f, 0.14688519f, -0.68331462f, 0.15416491f, 
    0.04792396f, -0.07023244f, -0.08123156f, -0.09727819f, 0.25957453f, 0.02456092f, -0.15031864f, 0.17063648f, 
    0.04269557f, 0.16566536f, -0.16616447f, 0.15438397f, -0.09782438f, -0.17012300f, -0.21757264f, -0.14155282f, 
    0.00070736f, 0.10143941f, -0.16692252f, -0.07292277f, -0.00513365f, 0.03331527f, -0.20782255f, -0.14179310f, 
    -0.01814074f, 0.00290350f, 0.33860907f, 0.20144840f, -0.01435908f, -0.49032396f, 0.22882077f, -0.33074421f, 
    0.09107074f, 0.32279262f, -0.13861707f, -0.09611728f, 0.25052112f, 0.11207381f, 0.09927226f, -0.04102547f, 
    -0.01354835f, -0.16963710f, 0.07388326f, 0.08119088f, -0.07515907f, 0.10109425f, -0.04378741f, -0.00285690f, 
    -0.16264018f, 0.10368874f, 0.07393910f, 0.12306171f, 0.16046178f, 0.00766968f, 0.08176301f, -0.04695304f, 
    0.14962821f, 0.11176860f, -0.04559622f, 0.04804794f, -0.09140698f, -0.08582431f, 0.16152349f, 0.00759253f, 
    -0.14112754f, -0.14193778f, 0.01674869f, -0.13678461f, 0.03630624f, 0.00526161f, -0.08992510f, -0.04354997f, 
    0.09588470f, 0.09071417f, 0.07388389f, -0.15008621f, 0.04274677f, 0.30481622f, -0.08226527f, -0.12478354f, 
    -0.10265860f, 0.17041054f, 0.15594314f, 0.14806379f, 0.36161953f, -0.09003174f, 0.28721648f, -0.18025464f, 
    0.05730686f, 0.15302251f, -0.15033318f, 0.28938499f, -0.11447319f, 0.27192801f, -0.58346355f, 0.02705556f, 
    -0.08683860f, -0.21010998f, -0.13700180f, -0.06707060f, -0.18814005f, 0.37234035f, 0.16474628f, -0.15971346f, 
    0.09281044f, 0.01492093f, -0.13316017f, -0.04219887f, 0.15006173f, 0.17365019f, 0.16759780f, 0.02791088f, 
    0.01117264f, 0.11055328f, 0.09246818f, -0.00095855f, -0.06091969f, -0.00721286f, -0.16748305f, -0.11435881f, 
    0.05540446f, 0.12662019f, -0.24104233f, -0.21571203f, 0.15245759f, -0.00667743f, -0.57276118f, 0.00567060f, 
    -0.06145569f, 0.30267841f, 0.08227694f, -0.05606953f, 0.39802143f, -0.08912084f, 0.22152670f, 0.15372062f, 
    0.03654777f, -0.12125310f, -0.16477042f, 0.04571578f, 0.16380236f, -0.19708233f, 0.03215073f, -0.01468776f, 
    -0.11163107f, -0.12443569f, 0.16752189f, 0.12486612f, 0.07334550f, 0.10756006f, -0.10840531f, -0.09573239f, 
    0.09559036f, -0.00310983f, -0.00128828f, -0.01809443f, -0.12290664f, -0.03413569f, -0.04895417f, -0.12389570f, 
    -0.08387136f, 0.04512985f, -0.01300306f, -0.14688532f, -0.19106048f, -0.03424775f, -0.07955728f, 0.11180160f, 
    -0.12561786f, 0.11044700f, 0.00239109f, -0.01860436f, 0.07762225f, 0.10746945f, 0.11609698f, -0.02736845f, 
    0.03259071f, -0.05399216f, 0.04802203f, 0.14107014f, -0.25003943f, 0.46983883f, 0.02662252f, -0.13207418f, 
    -0.13405545f, 0.15939668f, 0.30666819f, -0.16957299f, 0.11884888f, 0.10166357f, 0.12459952f, 0.27825245f, 
    0.02566435f, 0.06701913f, -0.12462612f, 0.07172214f, -0.31713447f, 0.41414481f, -0.19565013f, 0.06989437f, 
    -0.01196591f, 0.04574727f, -0.10907766f, -0.12832136f, 0.00993542f, 0.05080106f, 0.12030375f, -0.01943593f, 
    0.03190755f, 0.05391423f, 0.10526957f, 0.11357022f, 0.09997484f, -0.50614142f, 0.26475149f, -0.14799280f, 
    -0.06197888f, 0.00005454f, 0.30645862f, 0.21196580f, -0.15823069f, -0.05634207f, -0.34956464f, 0.33768806f, 
    -0.06750191f, -0.14051919f, -0.09905078f, -0.14156336f, 0.01457437f, -0.52389938f, 0.35292616f, 0.05204229f, 
    0.04629770f, -0.16648160f, 0.00492874f, -0.07909948f, 0.08640686f, -0.03877720f, -0.06743591f, 0.03479127f, 
    -0.13374412f, -0.00703525f, -0.04371644f, 0.16012828f, -0.11382939f, 0.11769603f, -0.14325392f, -0.01152354f, 
    -0.07113317f, -0.05115687f, 0.07187556f, -0.12707596f, 0.10314552f, 0.01670566f, 0.08733969f, 0.16019244f, 
    -0.02799746f, 0.08499563f, 0.03590025f, 0.07780686f, 0.16478179f, -0.10638242f, -0.14588420f, -0.06764386f, 
    -0.09876826f, -0.05826537f, -0.00351909f, -0.01872460f, -0.08556379f, 0.23597710f, 0.33912954f, -0.07667370f, 
    0.02047042f, 0.11802959f, 0.06312212f, -0.04444093f, 0.30511618f, -0.06155045f, -0.10836440f, -0.05241477f, 
    0.09279300f, -0.17148441f, -0.09094462f, 0.19306560f, 0.15037867f, 0.20448130f, 0.07359869f, 0.16899815f, 
    0.00777253f, 0.03084860f, -0.05945615f, -0.12665267f, -0.28396544f, -0.21056142f, 0.21665503f, -0.11256716f, 
    -0.08360769f, -0.27099192f, -0.16518593f, -0.15032586f, 0.06413884f, 0.27275705f, 0.25522652f, 0.12050822f, 
    0.02845251f, -0.09679414f, -0.10591324f, 0.10795041f, -0.33329427f, 0.53120548f, -0.20653859f, -0.16074544f, 
    0.08137370f, 0.16037951f, 0.02740171f, 0.36965477f, -0.05207145f, 0.21917516f, 0.38130191f, 0.05666150f, 
    -0.10795277f, -0.32623944f, -0.12462805f, 0.03700922f, 0.07495847f, -0.07480627f, 0.08572966f, -0.15498276f, 
    -0.15751857f, 0.06919734f, -0.14047863f, 0.13792707f, -0.06896447f, -0.05930344f, 0.10781848f, 0.06498548f, 
    -0.02800775f, 0.04091499f, -0.13822025f, -0.14031771f, 0.14267258f, -0.05823529f, 0.11779376f, 0.09815481f, 
    0.06133892f, -0.00298202f, 0.11590704f, 0.47674724f, -0.01759286f, -0.17007785f, 0.42482764f, -0.28584117f, 
    -0.11675406f, 0.10405304f, -0.00343252f, 0.15235242f, -0.07351946f, -0.13404113f, 0.25210622f, 0.17381611f, 
    -0.13698286f, -0.01262450f, 0.10500636f, -0.14952740f, -0.00421059f, 0.27239376f, 0.23771624f, -0.01111161f, 
    0.27983731f, 0.06349221f, -0.13288866f, 0.03699629f, 0.14896715f, -0.23303285f, 0.01447404f, -0.15736084f, 
    0.14875962f, -0.02237665f, -0.40130499f, -0.45923325f, 0.14699639f, 0.18216966f, -0.04843193f, 0.00078235f, 
    0.14076869f, 0.08972869f, 0.00824004f, 0.16339445f, -0.10642051f, -0.07930815f, 0.10162849f, -0.15293552f, 
    0.15427637f, 0.17882752f, -0.11638045f, 0.10785105f, -0.06577348f, 0.12209463f, 0.14951150f, -0.15248773f, 
    -0.07144813f, -0.10246496f, 0.06004076f, -0.04416602f, -0.32134026f, 0.21085297f, -0.10161044f, 0.10357818f, 
    0.03396651f, 0.08002450f, 0.23793145f, -0.45093757f, -0.01733190f, 0.08180463f, 0.20551834f, 0.61173648f, 
    -0.06699178f, -0.33019537f, 0.07875935f, -0.12115522f, 0.03034543f, -0.07087557f, 0.12722485f, 0.15016443f, 
    -0.01559831f, 0.13414641f, -0.15730272f, 0.09448583f, -0.17482787f, -0.17695673f, -0.18200447f, -0.15448521f, 
    0.00515432f, -0.09737745f, -0.16602279f, -0.09759545f, -0.06247710f, 0.00709163f, -0.19471535f, 0.15904969f, 
    0.06920028f, -0.01807253f, -0.16956952f, 0.10355376f, -0.04806815f, -0.02555545f, -0.01138650f, 0.04987626f, 
    -0.15447144f, 0.11115351f, 0.15704714f, 0.08111281f, -0.12357242f, -0.07717181f, 0.00529281f, 0.00156207f, 
    -0.02265172f, 0.16974348f, -0.00023221f, 0.04521351f, -0.14535116f, 0.24122036f, -0.30970573f, 0.17368214f, 
    0.26455492f, 0.13756365f, -0.04399113f, 0.05809619f, -0.31508946f, -0.14994909f, -0.12793587f, 0.08798700f, 
    -0.09543659f, -0.15193497f, 0.31377086f, -0.10140917f, 0.07443894f, -0.52061415f, -0.15978396f, 0.24001215f, 
    -0.07935058f, -0.05422034f, 0.09036446f, 0.01562309f, -0.11258475f, 0.13951941f, 0.07301613f, 0.00422543f, 
    -0.13422640f, 0.07095506f, 0.14129232f, -0.05675773f, 0.02439504f, 0.06824579f, 0.16949613f, -0.14604999f, 
    0.22290868f, -0.08820149f, 0.06822968f, 0.13965374f, -0.30618617f, 0.16696571f, -0.13756160f, 0.05712455f, 
    0.12210172f, -0.14011480f, -0.04078297f, -0.47580713f, -0.14909844f, 0.16424797f, -0.26556143f, 0.02327885f, 
    -0.04533458f, 0.27419460f, 0.10581901f, -0.07224007f, 0.31120485f, 0.05228756f, -0.20351776f, 0.06089680f, 
    0.13417745f, -0.00721523f, -0.13818033f, -0.02511166f, -0.02055970f, -0.14854181f, 0.14735790f, -0.15879180f, 
    -0.07022943f, -0.04442678f, 0.04206571f, -0.03903833f, -0.11476304f, 0.04771341f, 0.06699304f, -0.09610095f, 
    0.15976928f, -0.01462654f, -0.03639753f, -0.04894553f, -0.10507700f, 0.10247546f, -0.09061137f, -0.14171009f, 
    -0.12609774f, -0.18165682f, 0.11419494f, 0.06446573f, -0.15989920f, 0.03661193f, 0.09018771f, 0.10211490f, 
    -0.09568504f, 0.19870985f, -0.10237922f, -0.09721362f, 0.08314005f, -0.03430768f, -0.04039336f, -0.11959574f, 
    -0.16572681f, 0.02009575f, -0.03086896f, -0.14857991f, 0.17711864f, -0.27351439f, 0.09208517f, -0.15244411f, 
    -0.14121658f, 0.07743892f, -0.15541391f, -0.21015163f, 0.12253027f, 0.29663187f, 0.41981578f, -0.34056965f, 
    0.13209920f, 0.42058879f, -0.11039589f, -0.12440521f, 0.03020305f, 0.16950166f, 0.20602648f, 0.03327829f, 
    -0.13225466f, 0.27445981f, 0.12886031f, -0.08256790f, 0.11746004f, -0.09891402f, 0.17948577f, 0.09557170f, 
    0.22033274f, 0.06233002f, -0.00609217f, 0.09333238f, 0.29446155f, -0.16405886f, 0.32746947f, -0.02805287f, 
    -0.07515147f, 0.04977467f, 0.11093365f, 0.14163394f, 0.14694695f, -0.22000517f, -0.30946586f, 0.18713069f, 
    0.06172819f, -0.21933588f, 0.10582023f, -0.00109384f, 0.03973151f, -0.20540483f, -0.03634031f, 0.17542866f, 
    0.00554282f, -0.05274493f, -0.03241284f, -0.14810316f, -0.04704392f, -0.11693361f, 0.21123573f, 0.14890750f, 
    -0.14034268f, -0.11893108f, -0.06639690f, 0.11760096f, 0.10255013f, 0.27085716f, -0.10246784f, -0.06995761f, 
    0.11465624f, -0.04816759f, 0.15588786f, -0.32118079f, -0.15265812f, 0.13049966f, 0.25648814f, -0.03604383f, 
    0.04467901f, 0.44544640f, 0.06149301f, -0.09259814f, -0.21888578f, -0.02693884f, 0.34486997f, -0.07922200f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.06188169f, -0.04345474f, -0.03782905f, -0.14533806f, 0.06539959f, -0.20023058f, 0.11062241f, -0.06677528f, 
    -0.06333036f, 0.14037378f, -0.07296729f, 0.11776075f, -0.10735127f, -0.04612043f, -0.12893765f, 0.14609359f, 
    0.00974804f, 0.04017122f, -0.01081770f, -0.11986796f, 0.22905341f, 0.02570817f, -0.01028005f, 0.07154766f, 
    -0.16081737f, -0.03260010f, -0.13755621f, 0.07611068f, -0.17160578f, 0.19836727f, 0.09468181f, 0.00309253f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.07532697f, -0.28667957f, 0.02795703f, 0.45394775f, 0.07562988f, 0.12063028f, -0.50991827f, -0.29302290f, 
    -0.11361534f, -0.41021979f, -0.02428393f, -0.38792691f, 0.13692024f, 0.01576457f, -0.20770340f, 0.06635159f, 
    -0.00977097f, 0.06994776f, -0.61871767f, -0.06110841f, -0.06615199f, 0.05089625f, 0.02243935f, 0.19359538f, 
    0.09476043f, -0.10060199f, 0.11204785f, 0.41074094f, -0.11645307f, 0.10220856f, -0.46778855f, 0.22732979f, 
    0.30984360f, -0.21471877f, -0.12931222f, 0.03214476f, -0.78615785f, 0.04713225f, -0.09916479f, -0.63676000f, 
    0.01548316f, 0.24321236f, 0.03194701f, -0.52104092f, -0.30598336f, -0.02243131f, 0.06557164f, -0.00416391f, 
    0.13441874f, 0.08935732f, 0.05179861f, 0.16244590f, 0.16932213f, 0.18442830f, 0.11936475f, 0.25820145f, 
    -0.06475437f, -0.04837760f, -0.79082566f, -0.25842255f, 0.01354893f, 0.23953187f, -0.06984172f, 0.06736523f, 
    -0.29118860f, 0.21441163f, 0.02802877f, 0.29143462f, -0.21847545f, 0.38527361f, 0.30939630f, -0.26183948f, 
    -0.08523979f, -0.35340738f, -0.34027275f, -0.48322532f, -0.04824624f, -0.15253118f, -0.00002531f, 0.03689506f, 
    -0.14908640f, -0.31644246f, 0.23985220f, -0.09584597f, 0.00131560f, 0.02369240f, 0.01646648f, 0.05913338f, 
    0.22653939f, 0.02052585f, 0.17457087f, -0.23344351f, -0.07883359f, -0.40197992f, 0.16332968f, 0.08578995f, 
    -0.29488850f, 0.11687147f, -0.04817375f, 0.10742489f, 0.15454690f, -0.00429478f, -0.02274587f, -0.04856805f, 
    -0.31017897f, 0.24024181f, 0.16373201f, -0.05320120f, -0.27797335f, -0.15996283f, 0.25939056f, 0.12197764f, 
    0.02068744f, 0.32617363f, -0.76299244f, 0.11247671f, -0.17223194f, -0.04928611f, -0.48995060f, 0.23833674f, 
    0.14190593f, 0.05184628f, 0.28988415f, 0.30910665f, -0.18852380f, -0.22513285f, 0.07535379f, -0.38118842f, 
    -0.01589475f, -0.17364579f, -0.01736071f, 0.21363699f, 0.03614961f, -0.35113966f, -0.13320178f, 0.25248194f, 
    -0.18860517f, 0.13015841f, 0.04449597f, 0.12159704f, -0.06701432f, -0.17060412f, -0.06282009f, 0.30235577f, 
    0.01816604f, -0.22733106f, 0.20370989f, -0.04911808f, -0.20091733f, -0.50459099f, -0.26511565f, 0.24822949f, 
    0.08135915f, 0.09594714f, -0.03602589f, 0.33152992f, -0.05218954f, 0.20328607f, 0.18971495f, 0.00667425f, 
    0.12752546f, -0.17435032f, -0.02922696f, -0.16638151f, 0.01122030f, -0.30664116f, -0.23016781f, -0.11072003f, 
    -0.21251395f, -0.36910844f, 0.44995877f, -0.02465148f, 0.22076330f, -0.09903061f, 0.37473285f, 0.24069726f, 
    -0.10144185f, -0.24919540f, -0.07429466f, 0.16303152f, -0.02002755f, -0.12024917f, 0.25153515f, -0.22981183f, 
    -0.67950177f, 0.14650388f, -0.53603834f, -0.22868553f, 0.08392926f, 0.28116283f, -0.10861386f, 0.14799275f, 
    -0.27388558f, -0.68638033f, 0.05652053f, -0.23323447f, 0.02013969f, 0.03419128f, -0.41023967f, -0.12390773f, 
    0.36246189f, -0.49416783f, 0.06061305f, 0.20077078f, -0.14142787f, 0.04132459f, 0.25607544f, -0.32431388f, 
    -0.11802693f, 0.27867281f, 0.26671657f, -0.16380404f, 0.11111899f, -0.26030692f, 0.01609624f, -0.25720996f, 
    0.18617083f, 0.02877317f, 0.10579038f, -0.35668585f, -0.15792805f, -0.13584061f, 0.27500522f, 0.01878647f, 
    -0.59140235f, -0.02432955f, -0.18104801f, -0.37057829f, 0.04381904f, -0.08903082f, 0.42807192f, 0.26865926f, 
    0.26799387f, 0.37468171f, -0.02194822f, 0.01427201f, -0.05767021f, 0.14574605f, 0.26940250f, -0.58428001f, 
    0.02205556f, 0.00961530f, -0.29389817f, 0.05342365f, -0.31458610f, -0.07717686f, 0.05543131f, -0.12784633f, 
    -0.18785504f, 0.05225369f, 0.11353205f, -0.16495551f, -0.09640629f, -0.10381924f, 0.26540780f, -0.40490389f, 
    -0.22467138f, 0.18681540f, -0.17102982f, -0.83538651f, -0.28421581f, 0.24361818f, -0.20565708f, -0.03503752f, 
    -0.14294644f, -0.06463145f, -0.32949278f, -0.09346651f, -0.40440017f, 0.01632348f, 0.32731700f, 0.12804241f, 
    0.03186776f, -0.65825719f, 0.36548728f, -0.15015922f, 0.26803887f, 0.16054600f, 0.10839764f, 0.34205663f, 
    0.05848711f, 0.16570532f, -0.63270986f, -0.41340882f, -0.03970491f, -0.03340968f, 0.28265989f, -0.24982075f, 
    -0.15159711f, 0.09329959f, 0.06794413f, 0.19109955f, 0.33615747f, -0.17123896f, -0.11619142f, 0.28009719f, 
    0.12961259f, 0.02057814f, -0.40715498f, -0.20793131f, 0.36595017f, 0.14072321f, -0.62423605f, -0.25016645f, 
    -0.08359143f, -0.07399470f, 0.02552674f, 0.14786871f, -0.16779111f, -0.05928646f, 0.24844263f, -0.39435229f, 
    0.00278593f, 0.11265486f, 0.17375049f, -0.35005605f, -0.08302399f, 0.25085074f, 0.08609766f, -0.02876675f, 
    0.28101078f, 0.24135213f, -0.07230421f, -0.67610496f, -0.09653191f, -0.28931487f, 0.38340962f, -0.07705029f, 
    -0.05595365f, 0.00910840f, -0.25471088f, -0.09426001f, -0.21233842f, -0.13242760f, -0.14651972f, -0.02209978f, 
    -0.14137812f, 0.26333436f, -0.47620100f, -0.15780871f, -0.02599626f, 0.37248337f, -0.11708904f, -0.28996292f, 
    0.34332752f, -0.03418343f, -0.54304826f, 0.19427986f, 0.08029991f, -0.01012351f, -0.31537989f, 0.02137314f, 
    0.11896447f, -0.01315657f, -0.09867761f, -0.12694289f, 0.04488080f, -0.01570514f, 0.13829418f, -0.05273827f, 
    -0.33509490f, -0.13297161f, 0.05421430f, 0.39661154f, 0.12685467f, 0.13996805f, 0.03859942f, -0.00123977f, 
    -0.02682829f, -0.09295142f, 0.18536954f, -0.15017290f, -0.19469996f, 0.28485346f, 0.11156766f, -0.56101495f, 
    -0.01191413f, -0.00295896f, 0.29273805f, -0.10785297f, 0.06518302f, -0.65881824f, 0.21681593f, -0.36622679f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.03637455f, -0.13454841f, 0.09121767f, -0.07516332f, -0.06199221f, 0.13997066f, 0.12888180f, -0.17513423f, 
    0.06462215f, -0.03532341f, 0.23654009f, -0.08010804f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
