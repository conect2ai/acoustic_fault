#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.25891706f, 0.26284835f, 0.03764876f, 0.37749007f, -0.12649992f, -0.08278921f, -0.33955604f, -0.08603087f, 
    0.15363739f, 0.12541775f, 0.02014664f, 0.04476855f, 0.12533899f, 0.16275842f, -0.30348679f, -0.26446420f, 
    0.08549114f, 0.35950401f, -0.01575135f, 0.04919526f, -0.05960985f, -0.27758259f, -0.40662140f, -0.08823346f, 
    -0.23791708f, 0.39256203f, 0.16140300f, -0.02194589f, 0.43059996f, 0.19775610f, -0.10027360f, 0.15946503f, 
    0.01082641f, 0.18611626f, 0.28271851f, 0.04056654f, -0.17458306f, -0.32805237f, -0.29717413f, 0.29914978f, 
    0.05057426f, 0.28682068f, 0.05305026f, 0.08945101f, -0.09492544f, -0.02105960f, -0.31359044f, -0.23509847f, 
    -0.34673989f, -0.53184986f, 0.77588880f, 0.37183177f, -0.15294765f, -0.54855520f, -0.71635741f, 0.31649837f, 
    -0.19006395f, 0.19563048f, 0.35773689f, 0.01096788f, 0.10878944f, 0.25412336f, -0.03982348f, -0.14810215f, 
    -0.21780220f, -0.01974153f, -0.12793382f, -0.33264089f, 0.00953691f, 0.26018688f, -0.21755221f, 0.35165885f, 
    0.01090035f, -0.24878509f, -0.33054098f, -0.94548923f, -0.59066588f, -0.19042458f, -0.31787002f, -0.20802431f, 
    0.14353508f, -0.31964296f, -0.42361328f, 0.01543642f, 0.02391233f, -0.20766230f, -0.39857432f, 0.02861497f, 
    -0.34604087f, -0.27917457f, -0.12955113f, -0.29643515f, -0.43285066f, -0.05552372f, -0.07344285f, -0.24174413f, 
    -0.00956674f, -0.09387805f, -0.00528936f, -0.16171734f, 0.30583134f, -0.07904384f, -0.57243454f, -0.62060946f, 
    -1.06191576f, 0.11369756f, -0.64560223f, -0.24517989f, 0.36191499f, -0.16657297f, 0.67042875f, 0.16643034f, 
    0.19390783f, 0.56057566f, 0.20367463f, -0.27786547f, 0.31722838f, -0.13086124f, -0.42414984f, -0.05849230f, 
    -0.31344128f, 0.22153886f, 0.16265017f, -0.30560538f, 0.02985054f, -0.34075549f, 0.22136292f, 0.07360906f, 
    0.01615595f, 0.03005170f, -0.08182758f, 0.13584286f, 0.30327809f, -0.28706437f, 0.08008032f, 0.12865464f, 
    0.01257206f, 0.04737662f, 0.05030704f, -0.25579593f, -0.01326939f, 0.04491875f, -0.57349318f, 0.04210440f, 
    0.42753744f, 0.29901379f, -0.27029198f, -0.41203409f, 0.44315434f, 0.16358541f, -0.90121901f, -0.62555569f, 
    -0.47754666f, 0.12513509f, 0.08401413f, -0.35688177f, -0.39306524f, -0.01007973f, 0.47009227f, 0.48672977f, 
    0.46172994f, 0.01326843f, -0.03883775f, 0.12318572f, 0.04034894f, -0.04480190f, -0.03995974f, -0.07281606f, 
    0.15786481f, -0.20047258f, -0.24348097f, -0.06579467f, -0.12302253f, -0.12789057f, -0.35830590f, 1.07954204f, 
    -0.65172523f, -0.19226630f, 0.20855778f, -0.19593528f, 0.09446637f, -0.00602241f, 0.10659257f, -0.20873639f, 
    0.04030092f, 0.31854224f, -0.01335551f, -0.36930719f, 0.24030717f, -0.20330575f, -0.47624695f, 0.21618615f, 
    0.17356376f, 0.28704867f, -0.19326888f, 0.23219459f, -0.02614721f, 0.33180338f, -0.08532411f, -0.31539643f, 
    -0.48129436f, -0.10006951f, -0.43355906f, -0.11174779f, -0.22634137f, 0.24686521f, 0.03987942f, 0.08162269f, 
    0.13372953f, -0.10049612f, 0.25468937f, -0.46021527f, 0.07224167f, -0.09818345f, -0.24137241f, -0.10773287f, 
    -0.03102777f, 0.18898238f, -0.16757105f, -0.20244253f, -0.08062873f, 0.32467553f, 0.30990976f, 0.17020614f, 
    0.48401505f, 0.88074785f, 1.05608523f, -0.27335790f, -0.42866901f, -0.37019765f, -0.30099913f, -0.32338211f, 
    -0.05270943f, -0.21502928f, -0.22718243f, -0.14355038f, -0.48371562f, -0.05414088f, 0.57107884f, 0.01129116f, 
    -0.11004856f, 0.29603314f, 0.31299594f, 0.16437627f, -0.46033141f, -0.18350367f, -0.19154130f, 0.02102168f, 
    0.19621733f, 0.07490376f, -0.51680100f, -0.03653545f, -0.35992518f, 0.57401180f, -0.77001059f, -0.24357191f, 
    -0.29592353f, -0.75868833f, -0.27870399f, 0.68170774f, 0.02740237f, -0.11663881f, -0.15474309f, 0.29359853f, 
    0.20305006f, -0.47387633f, -0.25794464f, -0.13803692f, -0.28239667f, -0.48438177f, 0.26567766f, -0.53801030f, 
    0.11059962f, 0.19170091f, 0.11991255f, -0.25293300f, -1.00029945f, 0.05616628f, 0.62352949f, 0.80929488f, 
    0.51711684f, 0.45792738f, 0.41676906f, -0.31175911f, -0.23084877f, -0.05897741f, -0.38527870f, 0.01586080f, 
    -0.33832183f, 0.07718235f, -0.18270715f, 0.09686531f, -0.23443818f, -0.11831385f, -0.34035978f, 0.18598549f, 
    0.12402962f, -0.24791956f, 0.18115871f, 0.02804438f, -1.18761575f, -0.05388928f, 0.14359407f, 0.76662594f, 
    -0.05195606f, -0.32195407f, -1.03328049f, -0.40251076f, 0.32812834f, 0.80508471f, 0.45336470f, 0.13578723f, 
    -0.06594567f, -0.04208244f, 0.47981858f, -0.04599148f, 0.11980022f, 0.09437696f, -0.17982388f, -0.24965543f, 
    0.14526299f, -0.02922673f, 0.25482890f, 0.08764391f, -0.23462315f, -1.11778331f, 0.21227339f, -0.11256469f, 
    -0.63835096f, -0.41857785f, 0.38836884f, 0.69531524f, 0.28251413f, -0.19857609f, -0.09522995f, 0.22589637f, 
    0.60316783f, -0.16494474f, 0.17248999f, -0.57916003f, -0.23235616f, -0.44998351f, -0.25604093f, 0.07311039f, 
    -0.26283896f, 0.19687574f, 0.45349136f, 0.34904119f, 0.15094742f, 0.02197971f, -0.20228204f, 0.32540807f, 
    0.34039927f, -0.03757555f, -0.26418415f, 0.03616549f, -0.50979179f, -0.37716034f, -0.06166102f, -0.40615413f, 
    -0.14703751f, 0.19201237f, -0.27868605f, -0.37176552f, 0.06248449f, 0.21591453f, 0.26644936f, 0.17343758f, 
    -0.27447286f, -0.44533214f, 0.20481010f, 0.11546414f, 0.08438202f, 0.22121383f, 0.32827121f, 0.50132316f, 
    -0.70003617f, -0.05953827f, 0.22904682f, 0.41610971f, 0.01145262f, -0.25598300f, 0.36466420f, -0.04515045f, 
    0.25346139f, 0.28160948f, -0.15406419f, -0.09275611f, -0.35241592f, -0.07478495f, -0.10245890f, -0.27719650f, 
    0.15378666f, 0.27147189f, -0.34556702f, 0.22693354f, -0.28733301f, 0.03152990f, -0.02732732f, 0.20844984f, 
    -0.73894268f, 0.28841197f, -0.25702968f, 0.20597324f, 0.67213488f, 0.38048539f, 0.19284315f, -0.40359446f, 
    -0.14405292f, 0.31720623f, 0.03225665f, 0.05062715f, -0.00828374f, -0.31553352f, 0.36586633f, -0.21698795f, 
    -0.30548322f, 0.01933322f, -0.24309240f, 0.03088650f, -0.29797727f, -0.47562423f, 0.07981152f, 0.11791763f, 
    -0.18288130f, -0.49824131f, -0.55785280f, -0.11485629f, -0.23520076f, -0.60460484f, 1.07712948f, -0.30983183f, 
    -0.74086535f, -0.54602516f, 0.12531219f, -0.16414934f, -0.31783068f, -0.44649717f, -0.37331176f, -0.39908361f, 
    0.16073237f, 0.18275684f, 0.01717117f, -0.08870574f, -0.00719105f, -0.14071587f, -0.11094400f, -0.05013976f, 
    -0.00267673f, -0.05807701f, -0.62800324f, 0.25915879f, -0.93586236f, -0.60998344f, -0.08694086f, 0.25414434f, 
    -0.02059060f, 0.29189149f, -0.46566808f, -0.52499533f, 0.03497858f, -0.14020096f, -0.29809839f, -0.06363902f, 
    0.29559925f, 0.16795734f, -0.16607130f, -0.03741223f, -0.26735681f, -0.07150482f, 0.07039349f, 0.16386294f, 
    0.23323727f, 0.47517666f, 0.03401478f, -0.39782116f, -0.01477664f, 0.54275650f, 0.94649869f, 0.46931109f, 
    -0.04228659f, -0.19469975f, -0.55431718f, -0.60816050f, -0.46204776f, 0.25115922f, -0.55077803f, 0.17176452f, 
    0.03206921f, -0.17489097f, -0.25663194f, 0.16626410f, 0.30161008f, -0.09680487f, 0.02556057f, 0.06494310f, 
    -0.24645893f, -0.01863008f, 0.18457708f, 0.14095385f, 0.60995370f, -0.96216005f, -0.96072400f, -0.89633632f, 
    -1.08380115f, 0.81150085f, 0.53858000f, 0.81699461f, -0.16383259f, -0.05434500f, 0.23369513f, -0.04496837f, 
    0.44737902f, -0.33361867f, -0.22200944f, 0.08163034f, -0.14195594f, -0.03765738f, 0.09705335f, -0.06721343f, 
    -0.15671638f, -0.13236041f, -0.18378755f, 0.10701810f, -0.16149813f, 0.11733063f, -0.16039450f, -0.33941847f, 
    0.03043090f, -0.77807868f, -0.67838508f, -0.33869326f, -0.24219608f, -0.13156283f, -0.23201999f, 0.19836983f, 
    0.00910685f, -0.32169589f, -0.21944328f, -0.30891275f, -0.28431189f, 0.21268351f, 0.18727171f, 0.11680596f, 
    0.09997932f, -0.14102529f, -0.20292269f, -0.20740610f, -0.39612830f, -0.09628755f, 0.60031855f, -0.47513521f, 
    -0.09799167f, 0.51172292f, -0.45142001f, 0.04229007f, 0.49421248f, -0.35465452f, -0.26651332f, -0.25107166f, 
    -0.12233251f, -0.14428329f, 0.09314679f, -0.33619934f, -0.28888407f, 0.30583373f, 0.23787796f, 0.27598789f, 
    -0.07431490f, 0.12140710f, -0.29484701f, 0.19563890f, 0.19133921f, -0.13620253f, 0.06908988f, 0.53995186f, 
    0.39686376f, 0.47241285f, -0.23101443f, 0.21107042f, -0.18532179f, 0.00025511f, 0.15917459f, -0.11464886f, 
    0.35935137f, 0.18894547f, -0.10764696f, 0.16114716f, 0.18093903f, -0.17149749f, 0.17205644f, -0.24488312f, 
    -0.32723749f, 0.06617522f, -0.05740608f, -0.18201305f, 0.32560742f, -0.04652431f, 0.11258419f, -0.15826780f, 
    0.26232883f, 0.34594089f, 0.36558446f, 0.01455182f, 0.29120508f, -0.09498458f, -0.05344800f, 0.08551862f, 
    -0.25672099f, -0.21270642f, -0.06107958f, -0.02267122f, 0.49198171f, 0.17743143f, -0.16319978f, 0.28824350f, 
    -0.18849586f, 0.07966296f, 0.11961748f, -0.04605446f, 0.11747090f, -0.03754511f, 0.02225281f, 0.14656620f, 
    0.18809018f, 0.78287148f, -0.91535693f, -0.40389490f, 0.31010529f, 0.18469250f, 0.35201731f, 0.57761902f, 
    -0.51950216f, 0.38162082f, 0.30936852f, -0.04806517f, 0.48295724f, -0.17316575f, -0.38315004f, -0.37819248f, 
    0.25132552f, -0.20853814f, -0.10194439f, -0.03820723f, 0.01071591f, -0.33345935f, 0.17488807f, -0.10614030f, 
    0.24661799f, 0.06853061f, 0.29450774f, 0.03063867f, 0.03774407f, -0.03783305f, -0.60040462f, -0.19451955f, 
    0.41661683f, -0.20736824f, -0.07956120f, 0.37485716f, -0.23033622f, 0.69356054f, -0.48139673f, -0.22710548f, 
    0.26543102f, -0.02167094f, -0.10390384f, -0.19744009f, 0.09679708f, 0.02795882f, 0.02995892f, 0.12895232f, 
    0.00622621f, 0.07041200f, 0.43362212f, 0.39753905f, -1.05372632f, -0.33976573f, 0.09172200f, 0.64614058f, 
    -0.40478173f, -0.54979992f, -0.12937281f, -0.29263848f, -0.41027248f, -0.03408913f, 0.11254045f, 0.37209296f, 
    -0.30857855f, 0.32646337f, -0.14509228f, 0.03755064f, 0.10055020f, 0.09182485f, -0.21764730f, 0.05895085f, 
    -0.46600449f, -0.32350376f, 0.45479584f, 0.20439184f, -0.93915844f, -0.26136413f, -0.46011919f, -0.54711008f, 
    0.26564205f, 0.55012482f, -0.07598566f, 0.02000109f, -0.19746472f, 0.16109452f, -0.46170148f, -0.07377293f, 
    0.02725451f, 0.40570673f, -0.66849667f, 0.27409253f, 0.03579303f, -0.31081301f, 0.26703507f, 0.26569778f, 
    -0.09523501f, 0.09276831f, -0.23371263f, -0.37737080f, -0.40297121f, -0.45690063f, -0.24531613f, -0.40822002f, 
    -0.33060780f, -0.35800883f, -0.34678036f, -0.33846563f, -0.39941537f, -0.24586433f, -0.59639931f, 0.24335983f, 
    -0.09325083f, 0.34466669f, 0.52719903f, 0.40233722f, -0.13605234f, -0.46918407f, 0.00309253f, -0.09926151f, 
    -0.06420865f, 0.08242252f, -0.09167144f, -0.39450818f, -0.10620641f, 0.57255602f, 0.24973960f, 0.63089824f, 
    0.48772031f, 0.00713903f, -0.35812062f, -0.70699757f, -0.42357972f, 0.20664398f, 0.15432414f, -0.12198469f, 
    -0.06980660f, -0.04324889f, 0.39917368f, -0.36112329f, -0.15418395f, 0.20417778f, -0.16543327f, -0.07645500f, 
    0.40912083f, -0.24988391f, -0.25885350f, 0.51146895f, 0.11615935f, -0.30622053f, -0.08463901f, 0.27599251f, 
    0.61440068f, 0.58573490f, -0.27670258f, -0.00320172f, -0.16587628f, -0.20716074f, 0.30086240f, -0.03709522f, 
    -0.38066903f, -0.17007503f, -0.14713243f, 0.14392006f, 0.22335349f, -0.40576658f, 0.00143025f, 0.16231644f, 
    0.11418848f, -0.08541283f, 0.11168415f, 0.39281741f, -0.35975328f, -0.58327025f, -0.44019127f, -0.39940932f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06833323f, 0.01679148f, 0.35876322f, -0.06731762f, 0.43450952f, 0.08642944f, 0.24976176f, 0.01383716f, 
    0.11701341f, 0.22522682f, 0.17290014f, 0.44727045f, 0.30870062f, 0.28639466f, -0.04951447f, 0.31564102f, 
    0.38415119f, -0.22912596f, -0.20653236f, 0.18650061f, 0.53669411f, 0.06754768f, -0.07182006f, 0.03273887f, 
    -0.17742403f, 0.37202623f, 0.23982780f, 0.32436991f, -0.29502037f, 0.03884577f, 0.18955126f, -0.07738331f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00939290f, -0.00791766f, -0.02903421f, 0.02818572f, 0.00260042f, -0.04536716f, -0.03132112f, -0.05162425f, 
    0.02993129f, 0.02092238f, -0.03009444f, -0.00505939f, 0.00093579f, -0.01305120f, -0.03785919f, -0.01982046f, 
    -0.04565965f, -0.03317653f, 0.02911132f, -0.00781791f, -0.01119241f, 0.01952248f, 0.02211355f, 0.03507319f, 
    0.02606216f, 0.05222018f, -0.04488086f, 0.04150910f, 0.04210222f, -0.05416984f, 0.01119509f, 0.03266173f, 
    -0.03495853f, 0.04032302f, 0.03026801f, -0.04006060f, -0.02670689f, -0.03852271f, 0.00088347f, 0.03742338f, 
    0.02574144f, 0.03006723f, 0.00712504f, -0.03667912f, -0.01421252f, -0.04099033f, -0.02637095f, -0.03794532f, 
    0.02616520f, -0.00119693f, 0.02618692f, 0.02737680f, -0.04569779f, -0.01226928f, -0.04308623f, 0.01208210f, 
    -0.05234637f, -0.01494590f, -0.01262952f, -0.00074994f, -0.03363201f, -0.00274752f, -0.03349352f, 0.02557704f, 
    -0.03599017f, -0.03737238f, -0.04932545f, 0.02298420f, -0.04952264f, -0.03989555f, -0.00215487f, -0.01330610f, 
    -0.00954693f, 0.00654911f, 0.02406027f, 0.04386211f, -0.03769597f, -0.04948451f, 0.01807663f, -0.03059934f, 
    0.01418189f, 0.00094816f, -0.02785259f, 0.01507038f, 0.01220210f, -0.02138007f, 0.02596971f, 0.01491265f, 
    0.01628375f, 0.01561307f, -0.05333854f, 0.00581084f, -0.00144849f, 0.00426054f, 0.02547350f, 0.00881869f, 
    -0.04390229f, -0.05630686f, -0.03531509f, -0.04547159f, -0.03008946f, 0.00782788f, 0.03871151f, -0.04614651f, 
    0.01636116f, -0.00810232f, -0.01629923f, 0.02906650f, 0.00383772f, 0.02811242f, -0.01932467f, -0.05811640f, 
    -0.04398318f, -0.04126644f, 0.02160218f, -0.00815544f, -0.00699667f, -0.03406308f, 0.02292110f, 0.00953780f, 
    0.03742741f, -0.01025192f, -0.05505935f, -0.03782447f, -0.04767816f, 0.03768894f, -0.00173741f, 0.00050100f, 
    0.01103329f, -0.01799915f, -0.05656061f, -0.01157491f, -0.03256378f, 0.01856798f, -0.01598491f, -0.04596017f, 
    0.00674640f, 0.01482479f, 0.00839797f, -0.05232815f, 0.04006561f, -0.05251653f, -0.01576553f, -0.04547207f, 
    -0.03689948f, 0.03299426f, -0.05897901f, 0.04580544f, 0.03944900f, -0.01493629f, 0.01357635f, 0.00264983f, 
    -0.00082881f, -0.03795958f, -0.02053300f, -0.02176315f, 0.02180688f, -0.02305298f, -0.04789710f, 0.00398845f, 
    -0.02666344f, 0.02030685f, 0.01024769f, -0.02206506f, -0.04269740f, 0.03452307f, 0.03572036f, -0.04139147f, 
    0.03431160f, 0.00069264f, -0.03373549f, -0.03612835f, -0.03598671f, 0.01418926f, 0.04120008f, -0.03098859f, 
    0.00420054f, -0.04183960f, -0.00518065f, -0.01378760f, -0.04554114f, -0.00654818f, -0.01225118f, 0.02688428f, 
    -0.04554843f, 0.02431008f, -0.00146583f, 0.01019615f, -0.03015823f, -0.00907000f, -0.00514315f, 0.03524359f, 
    -0.01052883f, -0.03471848f, 0.05532564f, 0.02163858f, -0.01302261f, -0.02716771f, -0.04387965f, 0.00924960f, 
    0.00757151f, 0.02375854f, -0.04190055f, -0.04464664f, 0.04068181f, 0.00794548f, 0.01275888f, -0.03107028f, 
    -0.04971362f, -0.01133026f, -0.00184774f, -0.02371266f, -0.01918418f, -0.04581341f, 0.04402978f, -0.00680808f, 
    0.01846957f, -0.00557588f, 0.01108152f, -0.03202194f, 0.01972451f, 0.02773205f, -0.02939097f, 0.04301696f, 
    -0.03838723f, -0.03153580f, -0.00324711f, -0.01059947f, -0.02296632f, -0.03735987f, 0.04539303f, -0.01607015f, 
    -0.00949061f, 0.01770708f, -0.05410716f, 0.00367106f, -0.04375944f, 0.01632890f, 0.01966586f, 0.00279571f, 
    -0.05364257f, 0.04209536f, -0.02551943f, 0.01363274f, -0.02929534f, 0.02403187f, 0.02607537f, -0.01143551f, 
    0.02525582f, -0.02370819f, 0.04292842f, -0.03441334f, 0.02036414f, 0.03493501f, 0.02537897f, -0.02173269f, 
    0.02405891f, 0.02911217f, -0.01167771f, -0.03695102f, 0.00996330f, 0.00181127f, -0.01602986f, -0.02986522f, 
    -0.00614503f, -0.04749185f, 0.01684600f, -0.03694357f, -0.04298835f, -0.01814327f, -0.03023855f, 0.01426586f, 
    0.02547962f, -0.00688240f, -0.01182480f, 0.03941096f, 0.04826788f, 0.03146816f, 0.04879143f, 0.03204768f, 
    -0.05303146f, -0.02945419f, 0.03382928f, -0.01189891f, 0.01314287f, -0.01041540f, -0.01002590f, 0.03764692f, 
    0.02291873f, 0.03285022f, 0.02426889f, 0.02030594f, -0.04263023f, 0.02302393f, 0.00123141f, -0.01625711f, 
    -0.00333807f, 0.03040866f, 0.05261155f, -0.04281684f, 0.04192580f, 0.02527421f, -0.02829162f, 0.04105695f, 
    -0.02916944f, -0.03764902f, -0.05285015f, -0.00196897f, -0.00770828f, 0.00208727f, -0.03660627f, -0.05408543f, 
    0.00759168f, 0.03762292f, 0.03126406f, -0.01501218f, 0.03647416f, 0.03731430f, -0.00962212f, -0.02527449f, 
    -0.04675931f, 0.05047203f, 0.03924476f, 0.04739376f, -0.01180663f, 0.02562033f, -0.00205398f, 0.03759075f, 
    -0.01829071f, 0.01853478f, -0.01045866f, -0.03410148f, -0.00120746f, -0.01170043f, -0.00262735f, -0.01286522f, 
    -0.00528638f, 0.05139809f, 0.03756820f, 0.00976387f, 0.00540414f, -0.03522941f, -0.02784045f, -0.04434490f, 
    -0.00849520f, 0.03786325f, 0.04257792f, -0.03986359f, -0.00011758f, 0.00320600f, 0.00899818f, -0.00350838f, 
    0.03586122f, 0.01982131f, -0.04763467f, 0.00346370f, 0.04300581f, 0.00613180f, -0.00097696f, 0.02388994f, 
    0.04308109f, -0.01810034f, -0.01051010f, -0.03569517f, -0.01194419f, -0.02541400f, -0.01072489f, -0.01553795f, 
    -0.04749965f, -0.00236888f, 0.02751862f, -0.02791226f, -0.01503319f, 0.04449753f, -0.05505951f, -0.00840586f, 
    0.02050825f, 0.00368783f, 0.02978368f, 0.00711647f, 0.00231818f, -0.02106927f, -0.01384933f, -0.05372458f, 
    0.00885695f, -0.01959655f, -0.03612001f, -0.01656798f, 0.02720248f, 0.00235589f, -0.03412998f, -0.03666550f, 
    -0.03146455f, -0.01050316f, 0.01126944f, -0.04041820f, -0.03413812f, -0.02874785f, 0.04194741f, -0.02759571f, 
    -0.01824862f, 0.00203968f, 0.02584618f, 0.03577493f, -0.03476288f, 0.03501694f, 0.01027321f, 0.02509875f, 
    0.02311928f, -0.03558931f, -0.01593573f, -0.03025502f, -0.01540450f, 0.02727887f, -0.05352493f, 0.00092747f, 
    -0.00463586f, 0.00556079f, 0.02315143f, -0.04704035f, -0.03227689f, -0.03366726f, -0.03859612f, -0.02164939f, 
    0.02063275f, 0.00570179f, 0.02537499f, 0.04840792f, -0.01106603f, -0.03344002f, 0.02189090f, -0.05022222f, 
    -0.02872220f, 0.02951868f, 0.02655388f, -0.04808155f, -0.02947506f, -0.00169235f, 0.03378399f, -0.04768084f, 
    0.02203696f, 0.03075218f, 0.01984916f, -0.02321912f, 0.02891657f, 0.03675668f, -0.04877782f, 0.00512380f, 
    -0.04094089f, 0.01716887f, 0.03623312f, 0.03859431f, 0.01134673f, 0.04198188f, -0.01558620f, 0.03607423f, 
    0.00758157f, -0.01101803f, 0.00888016f, -0.03266523f, -0.02552074f, 0.03528997f, -0.00691511f, -0.00765027f, 
    -0.00627630f, 0.02712961f, 0.01524393f, 0.02896345f, 0.05313567f, -0.00269723f, 0.01136446f, 0.02668286f, 
    -0.01579616f, 0.02336036f, 0.04941055f, -0.03671424f, 0.00070247f, -0.02083592f, -0.02566703f, -0.05534434f, 
    -0.02285694f, 0.00987621f, -0.03444121f, -0.01012531f, -0.02179347f, 0.04113801f, 0.00673638f, 0.03642647f, 
    0.00750759f, -0.00164775f, 0.03057509f, -0.01590506f, 0.01482801f, -0.04837637f, 0.01973471f, -0.06042227f, 
    0.00581492f, -0.02421001f, -0.04729340f, 0.01458879f, -0.05175830f, -0.02746179f, 0.01492445f, -0.03075372f, 
    0.03863283f, -0.02295296f, -0.00581915f, -0.00386142f, -0.01244830f, -0.04275300f, 0.03355534f, 0.04040332f, 
    -0.05093785f, -0.03095611f, -0.05167199f, 0.03505621f, 0.01584327f, 0.02220847f, -0.03534188f, 0.02974737f, 
    0.03119300f, 0.02887913f, -0.03837897f, -0.00585135f, -0.03807027f, 0.01330748f, 0.01732777f, -0.03172072f, 
    0.00203431f, -0.03858129f, -0.00678003f, -0.04259260f, 0.00632309f, -0.03488229f, -0.00908635f, -0.03317449f, 
    0.02054372f, -0.01753241f, -0.02163796f, 0.03058111f, -0.03008050f, 0.03116901f, 0.02638122f, 0.03124356f, 
    -0.04340000f, -0.01906578f, -0.01040266f, 0.03281497f, -0.00669972f, -0.05511973f, 0.02171974f, -0.05413370f, 
    -0.00457993f, -0.01863178f, 0.04111745f, 0.03352721f, 0.00054870f, -0.01295699f, -0.03401138f, -0.02554005f, 
    -0.00289984f, -0.04465592f, 0.03060354f, -0.04694538f, 0.03597930f, -0.04933527f, 0.02827205f, -0.01770161f, 
    -0.05755286f, 0.03348111f, -0.05217364f, -0.02464477f, -0.03674411f, -0.05411518f, -0.00462494f, -0.03747342f, 
    0.03497186f, -0.00212119f, 0.04617476f, 0.02524498f, 0.02060371f, -0.03802487f, 0.02212148f, -0.05191945f, 
    0.02316153f, -0.01159274f, 0.01765279f, -0.04517490f, -0.00095360f, 0.04379458f, 0.03927457f, -0.01731619f, 
    -0.04646314f, -0.05504351f, -0.02543672f, -0.04415706f, -0.05717314f, -0.02048008f, -0.04911508f, -0.01988699f, 
    0.04599666f, -0.02906802f, -0.00952142f, -0.05771171f, -0.03664137f, -0.02532374f, -0.03867575f, 0.02458825f, 
    -0.02626428f, 0.03775378f, -0.05237537f, -0.01103802f, -0.01199954f, -0.02263664f, 0.01838073f, 0.01001130f, 
    0.01282863f, 0.02593830f, -0.02503437f, -0.05387004f, -0.00384408f, 0.02307509f, 0.00245261f, 0.02031366f, 
    0.02531832f, -0.02096936f, 0.02688898f, -0.04699222f, -0.01228646f, 0.01074392f, 0.01013192f, 0.02045469f, 
    0.03269112f, 0.01537998f, 0.01207309f, -0.02026420f, 0.01632575f, 0.04472082f, -0.02520453f, -0.01537281f, 
    0.02490631f, -0.03499427f, -0.03764044f, -0.03226959f, -0.04372699f, 0.04101826f, 0.00881641f, 0.00091660f, 
    0.04010417f, -0.04338969f, -0.01281062f, -0.03342801f, -0.00166649f, 0.04347684f, -0.03756682f, -0.04764598f, 
    -0.05371401f, 0.01547647f, 0.01973330f, 0.04546457f, -0.03115230f, -0.00682703f, 0.02169725f, -0.03940222f, 
    0.03868702f, -0.03187872f, -0.00179409f, 0.01831304f, -0.04111713f, 0.01555525f, -0.00654825f, -0.04603282f, 
    0.04212665f, -0.05323898f, -0.01475236f, -0.01078853f, 0.03733144f, 0.03027855f, -0.02049904f, -0.05194870f, 
    0.04023784f, 0.03796709f, -0.02985885f, -0.03507015f, -0.00921433f, 0.01578720f, -0.03772294f, -0.04768373f, 
    0.02161377f, -0.00819433f, 0.00248614f, -0.02735676f, -0.01296374f, 0.00140955f, 0.00278543f, -0.02884184f, 
    -0.05783414f, -0.02075128f, -0.00116839f, -0.01095688f, -0.03681691f, -0.00556788f, -0.03929503f, 0.00676936f, 
    -0.01932362f, 0.00576850f, 0.01517174f, 0.04116829f, -0.00265714f, -0.01598456f, -0.01959777f, -0.01885661f, 
    -0.05191035f, 0.01491957f, 0.04248493f, -0.04229382f, 0.02274096f, 0.00056627f, 0.03249498f, 0.01146459f, 
    -0.00576233f, 0.01065926f, -0.01360638f, 0.05067527f, -0.02355760f, -0.00292695f, -0.01447193f, 0.01270734f, 
    -0.02739483f, 0.02691223f, -0.03030629f, -0.02178578f, 0.05750474f, 0.04626227f, 0.01205184f, -0.04064824f, 
    0.03783641f, 0.04861913f, 0.01614111f, -0.04196152f, 0.01482455f, 0.02108598f, 0.02442136f, 0.03796495f, 
    -0.02054010f, -0.02388283f, -0.04514899f, 0.03575836f, -0.04239382f, 0.02080567f, -0.00228373f, -0.05220952f, 
    0.01814240f, -0.04097963f, -0.05693213f, 0.03072712f, 0.02042739f, -0.01722067f, -0.02901777f, -0.03687552f, 
    -0.03960912f, -0.04030815f, -0.06112696f, 0.02572919f, 0.03259793f, 0.00230003f, 0.03921197f, -0.05683383f, 
    -0.04395154f, 0.03213504f, -0.02690087f, -0.05645872f, 0.01101881f, 0.02443058f, -0.02736393f, 0.04134718f, 
    0.28515080f, 0.06919890f, 0.00188831f, 0.17053458f, 0.04605225f, -0.06762069f, 0.09271088f, 0.02770478f, 
    -0.03360467f, 0.07030547f, 0.03186445f, -0.05424169f, 0.37798890f, 0.14645019f, -0.03045606f, 0.04590754f, 
    0.12730484f, 0.13569920f, 0.09077917f, -0.13058366f, -0.03956725f, -0.14738198f, -0.01643063f, 0.07918186f, 
    0.32628405f, 0.21265326f, 0.22954717f, 0.10882310f, -0.19506194f, -0.15628728f, 0.04931143f, 0.07951537f, 
    -0.11396384f, 0.13220887f, 0.08883888f, 0.29698509f, 0.03774353f, -0.02602963f, -0.04003616f, -0.05933983f, 
    0.21957238f, 0.42459846f, -0.03553744f, -0.47811899f, 0.03048456f, -0.09496646f, 0.15777604f, 0.15375897f, 
    0.12727323f, -0.18594012f, 0.10736535f, -0.04804784f, -0.08285536f, 0.02935183f, -0.00475215f, 0.00183998f, 
    -0.05553579f, -0.02085755f, 0.02702619f, -0.08054306f, 0.02794681f, 0.03202256f, 0.07764149f, 0.00606071f, 
    0.08722555f, 0.20060870f, 0.22070363f, 0.21149917f, -0.04618701f, 0.13157950f, -0.02315526f, -0.00928414f, 
    0.09329075f, -0.04846403f, 0.07611126f, 0.12675887f, 0.18104890f, -0.08804276f, -0.11133271f, -0.15039741f, 
    0.00419449f, 0.07216889f, 0.02680206f, -0.09251936f, 0.00998636f, -0.06225193f, 0.00735222f, 0.07880849f, 
    -0.06142969f, 0.11768972f, 0.14408801f, -0.09005417f, -0.15592487f, -0.25645676f, 0.12314206f, 0.18183498f, 
    -0.08898592f, -0.06132543f, -0.08938994f, -0.11842975f, 0.29664177f, 0.19478711f, -0.00525125f, -0.38962904f, 
    -0.19477107f, -0.03735818f, 0.28635997f, -0.10239537f, 0.00258727f, 0.02049767f, 0.04231546f, -0.09052225f, 
    -0.02600703f, -0.40963691f, -0.04930153f, -0.22745629f, -0.13038434f, 0.05801948f, 0.02942640f, 0.08395490f, 
    0.04395431f, -0.10310475f, 0.04831226f, -0.22495472f, 0.25801831f, -0.03261409f, 0.17367584f, 0.25781286f, 
    0.03810757f, -0.02607539f, -0.03746652f, 0.03500387f, 0.03001132f, 0.11358500f, -0.14469808f, -0.07967065f, 
    0.26242876f, -0.11633097f, 0.05791193f, 0.29699418f, 0.00799321f, 0.31107220f, -0.05756407f, 0.08317943f, 
    -0.04379246f, 0.05454471f, 0.06324602f, -0.04855175f, -0.12242848f, -0.08114893f, 0.21221167f, -0.24370582f, 
    0.04995950f, -0.13405262f, 0.04750021f, 0.11099865f, 0.04904751f, 0.01846015f, -0.08406746f, 0.16468543f, 
    -0.09951468f, -0.02622876f, -0.11553118f, -0.05227343f, -0.29516008f, -0.03093856f, -0.17962430f, 0.17156599f, 
    -0.04071824f, -0.00033656f, 0.00074327f, -0.01240679f, 0.25506487f, -0.11940052f, -0.07555394f, 0.03678714f, 
    0.09541276f, 0.07030233f, 0.07088039f, 0.02337833f, -0.04513594f, 0.01545986f, -0.03305454f, -0.01819685f, 
    0.40213159f, -0.28917885f, 0.15870050f, 0.18336736f, -0.04748011f, 0.05836215f, 0.03699833f, 0.05548979f, 
    -0.06668138f, 0.10452035f, 0.20413342f, -0.01411704f, -0.22607352f, -0.46477655f, 0.05365137f, -0.31044301f, 
    -0.01343433f, 0.01650714f, -0.04543313f, 0.38641939f, 0.04844363f, 0.15811388f, -0.03963811f, -0.06908137f, 
    -0.42040843f, -0.30641529f, 0.18043153f, -0.38928846f, -0.27466586f, -0.20732890f, -0.16406845f, -0.02444949f, 
    -0.09146685f, -0.05060095f, 0.03141728f, -0.12189937f, -0.26406577f, -0.20443524f, -0.21245506f, 0.13554081f, 
    0.08616287f, 0.14770070f, 0.16023152f, 0.05602500f, -0.06625395f, 0.10504778f, 0.07306965f, 0.01127245f, 
    -0.04780247f, 0.13447338f, 0.40724358f, 0.03887774f, -0.05593795f, -0.09235261f, 0.01356966f, 0.07862633f, 
    0.10363325f, 0.29341099f, 0.09669038f, 0.04433533f, -0.32174730f, -0.08822158f, -0.17459805f, -0.21273096f, 
    -0.09413941f, 0.10643340f, 0.40437612f, -0.01033185f, 0.04446663f, 0.09778810f, 0.00811684f, -0.05256081f, 
    0.04234811f, -0.13311733f, -0.08640045f, -0.29573965f, 0.00851817f, 0.07224456f, 0.01046220f, 0.03265705f, 
    0.04705325f, -0.00230664f, -0.05579843f, 0.09815170f, 0.06882312f, -0.00448276f, -0.10824067f, -0.04373784f, 
    0.01242224f, -0.07975064f, 0.01975086f, 0.11093597f, -0.00384297f, -0.08059645f, 0.02120052f, -0.09368522f, 
    -0.16703378f, -0.05995330f, -0.08973511f, -0.02581105f, -0.02458206f, -0.02474286f, 0.05149681f, 0.03130946f, 
    -0.11662704f, -0.04632272f, -0.03989506f, -0.02618372f, 0.23194535f, -0.20935224f, 0.32519296f, 0.20847426f, 
    0.12012383f, -0.05688802f, -0.05731797f, 0.00582166f, 0.13370067f, 0.30829936f, 0.25541085f, -0.08516115f, 
    0.10361120f, -0.02434977f, -0.00331330f, -0.07508592f, -0.08462632f, -0.03062039f, 0.10694735f, 0.03001685f, 
    -0.03800229f, -0.03939040f, -0.09375736f, -0.02216744f, -0.50647998f, -0.28047585f, -0.32081735f, -0.00326545f, 
    0.00301317f, -0.26299220f, 0.19836769f, -0.01189879f, -0.03811419f, 0.01990192f, -0.07512851f, -0.01017917f, 
    -0.11746479f, -0.25661674f, -0.21845809f, 0.15728799f, -0.03128129f, -0.15608008f, 0.05360130f, -0.00551991f, 
    0.12291075f, -0.10562268f, 0.04256861f, 0.28662318f, -0.50764400f, -0.37439781f, -0.31104657f, -0.41216096f, 
    -0.04182242f, -0.10918040f, 0.12821411f, 0.02306212f, -0.08619434f, 0.01759545f, 0.04148967f, 0.02142740f, 
    0.19488636f, 0.05526619f, -0.46107712f, -0.13280621f, -0.01162595f, 0.16372164f, -0.06547128f, 0.02208753f, 
    -0.01656881f, -0.03808887f, 0.03889515f, 0.07887218f, -0.12196803f, 0.05175756f, -0.18339984f, -0.05391018f, 
    0.04877691f, 0.00744698f, 0.04376439f, 0.14215706f, 0.15967095f, -0.10133697f, 0.00297964f, 0.11904421f, 
    0.13427991f, -0.02853356f, -0.02310665f, 0.00780132f, -0.03322890f, -0.04255988f, 0.01266376f, -0.00033024f, 
    -0.10688378f, -0.08431439f, -0.19778331f, -0.06417979f, 0.06436154f, 0.04252021f, -0.05004166f, -0.04711159f, 
    -0.01099120f, -0.07242524f, 0.03723537f, -0.07299553f, -0.16602211f, -0.01918731f, -0.02687746f, -0.11511886f, 
    0.13830653f, 0.10291802f, -0.04841644f, 0.04772657f, -0.02873262f, 0.21849521f, -0.05726400f, -0.22421560f, 
    -0.00476356f, -0.05932854f, 0.06059587f, 0.02212724f, -0.32036141f, -0.25481725f, -0.03018392f, -0.09354613f, 
    -0.05642005f, -0.05656926f, -0.01205029f, -0.10278775f, 0.04611133f, 0.03587085f, 0.18930297f, 0.19298930f, 
    -0.20964634f, -0.12502588f, 0.13837378f, 0.23799944f, 0.07815341f, 0.04327719f, 0.15965742f, 0.16229977f, 
    0.13387723f, -0.05743531f, 0.06229876f, 0.01305350f, 0.16465917f, 0.01220173f, -0.01918870f, -0.00669850f, 
    0.01458766f, -0.09357432f, -0.01330437f, 0.05505821f, -0.01298216f, 0.02856224f, -0.19062281f, -0.04310461f, 
    0.01805141f, -0.31381941f, -0.14180169f, -0.09355468f, 0.04291662f, -0.03425271f, 0.01334435f, 0.01800469f, 
    0.05834771f, 0.06483891f, 0.18340060f, 0.04667168f, -0.13278343f, 0.17262280f, 0.12836897f, -0.00683110f, 
    0.09816442f, 0.17960162f, -0.03283741f, -0.13563900f, 0.16516939f, 0.02960023f, 0.09189853f, 0.02557305f, 
    -0.08867835f, -0.13181341f, -0.12081341f, 0.03264441f, 0.07352525f, -0.07391027f, 0.00579604f, 0.14092419f, 
    0.07000195f, -0.01314135f, 0.01124744f, 0.02699937f, 0.11547461f, 0.02804815f, 0.12122226f, 0.19453666f, 
    0.00841308f, 0.29842713f, -0.03868496f, 0.32742417f, 0.07220662f, -0.08409453f, 0.03603853f, 0.04147755f, 
    -0.09350121f, -0.09384535f, -0.13373502f, 0.25939712f, 0.08510585f, -0.11582927f, 0.09014592f, 0.18216252f, 
    0.06271039f, 0.24859124f, 0.01417722f, 0.23376295f, -0.17058285f, 0.33956742f, -0.26148298f, -0.39798933f, 
    0.05802881f, -0.02738342f, -0.01505252f, -0.07912464f, -0.12960429f, -0.13705470f, -0.07034617f, -0.08598290f, 
    0.37759984f, -0.30521223f, -0.16695610f, 0.28077501f, 0.06627338f, -0.30427179f, 0.00381731f, -0.11803761f, 
    0.20716268f, 0.21306251f, 0.27825162f, -0.17835209f, -0.19127496f, -0.12135205f, -0.07779237f, 0.28290513f, 
    -0.00551027f, 0.04725372f, 0.01307590f, -0.05997467f, 0.23227869f, 0.09139894f, 0.20306645f, -0.11564992f, 
    -0.08372845f, -0.07811929f, 0.14496282f, 0.01597732f, 0.09814180f, 0.00838848f, -0.06968159f, -0.01781292f, 
    0.00909560f, 0.00031385f, -0.08213757f, -0.03995047f, 0.13300765f, 0.06145969f, 0.06786102f, -0.30866817f, 
    0.07189170f, -0.13022134f, -0.09445433f, -0.04353630f, -0.00444498f, 0.08620834f, -0.01969601f, -0.01041285f, 
    -0.01293006f, 0.11536483f, -0.03572512f, -0.15562363f, 0.03625075f, -0.14716478f, -0.03348160f, 0.03309049f, 
    0.19270037f, 0.04999503f, 0.07767821f, 0.20219445f, -0.31670228f, 0.04667623f, 0.24067958f, -0.02155075f, 
    0.05020633f, -0.02816285f, 0.22243577f, -0.07766502f, -0.02230843f, -0.02003526f, 0.18611321f, -0.04602314f, 
    -0.23813297f, -0.04517782f, -0.28737861f, 0.02557413f, 0.10793456f, -0.03163764f, -0.12871976f, -0.06648850f, 
    0.12079523f, -0.03439174f, 0.00473105f, -0.01457378f, -0.04802270f, 0.19836149f, 0.38134274f, 0.23382507f, 
    0.12956189f, 0.02147236f, -0.03159007f, -0.02082599f, 0.05867854f, -0.03866288f, -0.04180210f, -0.01541578f, 
    -0.44729370f, 0.14850032f, -0.20554851f, 0.04721290f, 0.05687393f, 0.17946835f, 0.19687895f, -0.01318247f, 
    -0.01001493f, 0.00654243f, 0.05804424f, -0.00715814f, -0.00963147f, -0.08759131f, -0.03406560f, 0.23530476f, 
    -0.15751426f, 0.01499260f, 0.17022078f, 0.04381933f, 0.00407215f, -0.02296175f, 0.08395821f, 0.08249171f, 
    -0.16012573f, 0.19144173f, 0.06322334f, 0.17532466f, 0.12055416f, -0.16087596f, 0.25297216f, 0.16437863f, 
    -0.00150405f, -0.06055313f, -0.05520759f, -0.08019184f, 0.05887602f, 0.15808640f, 0.12446569f, -0.07749553f, 
    0.00201897f, 0.03749126f, -0.05210187f, 0.00578912f, -0.02408401f, -0.02439133f, 0.03779936f, -0.04706148f, 
    0.03951856f, 0.11789934f, 0.00080704f, -0.01530435f, 0.13222188f, 0.04121096f, -0.06351929f, 0.05811928f, 
    -0.00177877f, -0.01755280f, -0.09245386f, -0.05865556f, -0.06260394f, -0.02403051f, 0.00340076f, 0.08142649f, 
    0.04040477f, 0.07169251f, -0.00972935f, 0.01396757f, 0.13298433f, 0.00898927f, 0.10237772f, 0.07101366f, 
    -0.08090262f, 0.01049874f, -0.23431453f, 0.25902450f, 0.17888202f, 0.01827667f, 0.13035791f, 0.01142940f, 
    0.16290517f, 0.03009287f, -0.03393576f, 0.03082716f, 0.21666977f, -0.01724022f, 0.27648193f, 0.10100011f, 
    0.02886226f, 0.14753158f, 0.05632681f, 0.02388161f, -0.03113242f, 0.06121055f, -0.07732224f, 0.07827723f, 
    -0.18931206f, -0.28726208f, 0.19132471f, -0.24898963f, 0.10123605f, -0.02166577f, 0.23588654f, 0.06190132f, 
    0.04574526f, 0.13624652f, -0.04513180f, 0.12835394f, -0.10111535f, -0.15584551f, 0.04290641f, 0.06228730f, 
    0.06924295f, 0.10056719f, 0.04778099f, 0.05663400f, 0.10626221f, 0.03498489f, 0.00077053f, 0.10842387f, 
    0.20647442f, 0.23485024f, -0.03732137f, 0.09765971f, 0.01796293f, 0.05230986f, -0.00593297f, 0.06825019f, 
    0.01957430f, 0.08476203f, -0.05104447f, -0.05502480f, 0.11018096f, 0.09220719f, 0.24429828f, -0.10700303f, 
    -0.05803114f, 0.04452679f, 0.01198629f, -0.03362145f, -0.17052332f, 0.08412056f, 0.23703940f, -0.07230622f, 
    -0.04900623f, -0.07846982f, -0.18139544f, 0.07904322f, -0.12742704f, 0.05643130f, 0.02108838f, -0.03774553f, 
    0.15010293f, 0.23558907f, -0.22520626f, -0.04800135f, -0.06737334f, 0.05913944f, -0.21230581f, -0.10510804f, 
    -0.11717571f, 0.01793294f, 0.04541484f, 0.05383049f, 0.10395610f, 0.19558513f, 0.13925208f, -0.15114383f, 
    0.05801965f, 0.12584871f, 0.20085582f, 0.18224631f, -0.09859760f, 0.13969278f, -0.00815140f, -0.02609865f, 
    0.00255424f, 0.17112941f, 0.16612799f, 0.08911490f, -0.14186402f, -0.11450841f, -0.07421558f, 0.00975018f, 
    0.10226481f, 0.03766872f, 0.04508401f, -0.07543484f, -0.02960547f, 0.10628334f, 0.13029881f, 0.14003782f, 
    -0.08474724f, -0.02092449f, -0.11393660f, 0.15046737f, 0.01188557f, -0.08956034f, -0.03896808f, 0.15345982f, 
    -0.15170880f, 0.12198287f, 0.02310353f, 0.05463035f, -0.07457497f, -0.22574425f, 0.13325413f, -0.05964603f, 
    -0.03046207f, -0.06464496f, -0.01945372f, 0.05484955f, 0.25146797f, -0.01086523f, 0.02163156f, 0.00087700f, 
    -0.20250832f, -0.01377315f, -0.02271396f, -0.01836250f, 0.02090405f, -0.07230372f, -0.08604735f, -0.05862544f, 
    -0.14458661f, 0.02076325f, 0.11705479f, -0.01163996f, -0.46395719f, -0.09100818f, 0.03195155f, 0.25137153f, 
    0.02424746f, 0.03103293f, -0.17008519f, -0.02709824f, -0.11695409f, 0.10684788f, -0.00971234f, 0.04432936f, 
    0.04045955f, -0.00982103f, 0.00907847f, 0.10148552f, 0.04856977f, -0.02346954f, 0.02697749f, 0.01154175f, 
    -0.03174647f, 0.01011435f, -0.02329568f, 0.21688792f, 0.00534262f, -0.25950786f, -0.12580916f, 0.01505719f, 
    -0.12316937f, 0.00279785f, 0.20320503f, -0.03375598f, 0.00097202f, -0.16836618f, -0.04021752f, 0.07808579f, 
    -0.02555323f, -0.07138600f, -0.18148383f, 0.03009296f, -0.03764806f, 0.15433596f, 0.26324269f, 0.03746681f, 
    0.01201113f, 0.11782590f, 0.02621635f, 0.18922058f, -0.59762514f, 0.90700167f, 0.06604789f, -0.01641279f, 
    0.02552245f, 0.06001262f, -0.10498492f, 0.03052919f, -0.11054263f, -0.17395930f, 0.04451381f, 0.16356024f, 
    0.18272962f, -0.00247040f, -0.27565178f, -0.06171684f, 0.04042728f, -0.02536007f, 0.06185419f, -0.08210079f, 
    0.00264986f, 0.03719431f, -0.12585102f, 0.03815422f, 0.10572699f, 0.12385512f, 0.37115070f, 0.15571353f, 
    -0.04608048f, 0.00415861f, -0.10678806f, -0.03617186f, -0.08632126f, 0.20860659f, 0.13378628f, 0.04880749f, 
    0.03659650f, -0.41476238f, -0.09765422f, -0.05876037f, -0.12887090f, -0.00419146f, 0.15952396f, -0.19912109f, 
    0.06892054f, 0.03261371f, -0.23686393f, 0.04078336f, -0.32992339f, 0.19839261f, -0.02659847f, 0.27735242f, 
    -0.01851488f, 0.00016277f, -0.07470527f, 0.06205827f, 0.01481172f, 0.11710562f, 0.11364108f, -0.09359911f, 
    -0.20587528f, 0.20053366f, 0.23259182f, -0.05784385f, 0.01265662f, 0.09704226f, 0.01921802f, -0.07823354f, 
    0.11310036f, 0.10544229f, -0.00386130f, 0.09480375f, -0.25769415f, -0.09353613f, -0.13801038f, 0.21611103f, 
    0.03836035f, 0.09800651f, 0.13111812f, -0.01519833f, 0.06045673f, 0.09036673f, 0.00833990f, 0.05817013f, 
    0.08710938f, -0.21438456f, -0.30162543f, 0.04313916f, 0.11568231f, -0.10204985f, -0.07044991f, 0.12565862f, 
    0.03080535f, -0.03787453f, 0.06131353f, 0.10907085f, -0.06416398f, -0.09178895f, -0.11868954f, 0.36708745f, 
    -0.04742024f, 0.31325722f, 0.18331164f, -0.13614306f, -0.02137650f, 0.00522051f, 0.02954935f, 0.00129151f, 
    -0.16103631f, 0.13176572f, 0.22589622f, 0.24941680f, 0.15400575f, -0.03138077f, -0.15301631f, 0.00593664f, 
    -0.02058642f, 0.17401735f, 0.12738241f, 0.11843496f, -0.07501886f, -0.13962708f, -0.01270171f, 0.12932044f, 
    -0.08540452f, -0.08592544f, 0.02319164f, 0.03346993f, -0.02089527f, 0.13857275f, -0.05700446f, -0.01003414f, 
    -0.31010166f, 0.01297178f, -0.07293157f, 0.35644558f, -0.02235892f, 0.12927583f, 0.01593822f, 0.19121428f, 
    -0.09075380f, 0.02132673f, -0.13935256f, 0.04934480f, -0.01512949f, 0.04302278f, -0.01839094f, -0.08094899f, 
    -0.06514305f, -0.04204658f, -0.13595282f, 0.03777486f, -0.10260302f, -0.02011584f, 0.01173928f, -0.10834853f, 
    -0.14874814f, -0.28526253f, -0.07232855f, -0.15363111f, 0.07092256f, 0.09116670f, -0.07898756f, -0.14508425f, 
    0.00684905f, 0.07241079f, 0.01657051f, -0.04211439f, -0.46488664f, 0.11980705f, 0.22568198f, 0.04508033f, 
    0.13257216f, 0.08014069f, -0.12672363f, -0.09594269f, -0.19074540f, 0.15285881f, 0.00708295f, 0.29004389f, 
    -0.08866919f, 0.06230906f, 0.06287833f, 0.06463582f, -0.00661986f, -0.26971838f, -0.00262537f, -0.02244075f, 
    0.04319747f, -0.19508895f, 0.15672080f, 0.06699731f, -0.26982781f, 0.18163055f, -0.12663119f, 0.22652277f, 
    0.12999749f, -0.00946541f, 0.13513634f, 0.09674808f, -0.07878087f, 0.05495223f, -0.07598521f, -0.04617285f, 
    0.19160800f, 0.17687224f, -0.16222452f, -0.14988244f, 0.00474028f, -0.01591766f, -0.07158693f, -0.13582079f, 
    0.04228520f, 0.09208247f, 0.13101302f, 0.06228615f, -0.17570011f, -0.17992529f, -0.12048305f, 0.02044860f, 
    0.15931040f, -0.04623900f, 0.03454269f, 0.03959407f, -0.03336064f, -0.00545229f, 0.06662194f, 0.02292806f, 
    0.21958001f, 0.10547933f, -0.07559902f, -0.07862389f, 0.09127942f, 0.06247265f, -0.00101563f, 0.32850069f, 
    -0.15136664f, 0.01176872f, -0.01192633f, -0.01445509f, 0.00404450f, -0.02982840f, 0.23636378f, -0.09924539f, 
    -0.05972174f, -0.02357306f, 0.27978045f, -0.04297157f, 0.02332281f, 0.21366151f, 0.08743444f, -0.02523361f, 
    0.00061684f, 0.04816017f, -0.03317166f, 0.00099874f, -0.04991982f, -0.04522298f, -0.00746627f, 0.03238821f, 
    -0.01478150f, 0.00672874f, -0.05162307f, -0.00488736f, -0.00038879f, 0.04542378f, 0.02765850f, -0.02118045f, 
    0.01842170f, 0.04325245f, 0.02004321f, -0.04764536f, 0.03700577f, -0.01096570f, 0.04131052f, -0.04560557f, 
    -0.04977137f, -0.01752235f, 0.04139047f, -0.03992673f, 0.00026861f, -0.04222186f, 0.03929396f, -0.01435122f, 
    0.04273687f, -0.05035023f, -0.04606377f, -0.04081833f, -0.05600262f, -0.01608446f, -0.00752122f, 0.03700535f, 
    -0.03551162f, -0.00225376f, -0.02555399f, -0.00662068f, -0.02130366f, -0.05055944f, -0.03901656f, -0.05100626f, 
    0.02685425f, -0.02009567f, 0.03208567f, -0.01777379f, -0.04981750f, -0.02211058f, 0.00852595f, -0.02156641f, 
    -0.01560304f, 0.02350294f, -0.02968038f, -0.01537799f, -0.00670631f, -0.04873386f, -0.04994529f, 0.01128389f, 
    0.03644342f, 0.02517721f, -0.05525809f, 0.03676920f, -0.03338939f, -0.03251287f, -0.03013691f, 0.04763399f, 
    -0.01000549f, -0.00024496f, 0.02170579f, 0.00563693f, -0.02648368f, 0.02541808f, 0.00888871f, -0.05000572f, 
    -0.02551061f, 0.00534133f, 0.03957339f, -0.02874443f, -0.04821967f, -0.04439378f, 0.00239103f, -0.04837687f, 
    0.00593368f, -0.02408171f, 0.03971808f, -0.03210213f, 0.03978864f, 0.02562403f, 0.01586258f, -0.01085555f, 
    -0.02126294f, -0.00180686f, 0.04029251f, 0.03092361f, 0.01406974f, -0.01843717f, -0.05069197f, -0.03602325f, 
    -0.04975373f, -0.05006380f, -0.01124413f, 0.04189949f, 0.02863778f, -0.03963947f, -0.03382914f, -0.05181817f, 
    -0.00258943f, -0.00793032f, 0.01923444f, 0.04244741f, -0.01937326f, -0.02821101f, -0.01649080f, 0.04369510f, 
    0.00943611f, -0.00526513f, -0.01625691f, -0.00814464f, 0.03056415f, -0.03197377f, 0.01163579f, -0.04965107f, 
    -0.03972633f, 0.03441595f, 0.02896784f, 0.00807889f, -0.04309666f, -0.04270510f, -0.00141926f, -0.01096477f, 
    0.04301404f, 0.01612704f, -0.05254848f, -0.05172289f, 0.02584249f, 0.00876286f, 0.02327490f, -0.05047319f, 
    0.02063533f, 0.01039435f, -0.03249097f, 0.01986799f, 0.03382426f, -0.00498965f, 0.03269271f, -0.04154701f, 
    0.04361616f, 0.00719205f, 0.02589724f, -0.03172337f, 0.03832241f, 0.01555514f, -0.01589179f, 0.01751668f, 
    0.01118021f, -0.01447515f, 0.03933290f, 0.01304271f, -0.04826453f, -0.00792569f, 0.04270661f, 0.02914556f, 
    0.04056902f, -0.01590296f, -0.04963940f, -0.05025259f, -0.04346314f, -0.04215314f, -0.05607802f, -0.03371672f, 
    -0.01563063f, -0.02022902f, -0.01532600f, -0.04893388f, 0.03814422f, 0.04342923f, -0.04932959f, -0.00119518f, 
    0.01296015f, 0.00720257f, 0.02325080f, -0.04664418f, -0.03854175f, -0.01196019f, 0.00993272f, -0.00772790f, 
    -0.03546738f, 0.00884245f, -0.01789539f, -0.03982787f, -0.03046681f, -0.03408786f, 0.00090978f, -0.04934759f, 
    -0.03597030f, -0.00640559f, 0.04157294f, -0.00644730f, 0.00966064f, 0.00851860f, -0.04762754f, 0.00589707f, 
    -0.00011297f, -0.04460286f, 0.02931540f, -0.03791241f, -0.00245024f, 0.00030394f, -0.01202567f, -0.00944255f, 
    -0.01504623f, 0.02467233f, -0.01177583f, 0.01447944f, -0.01822378f, -0.03232149f, 0.02732400f, 0.00340344f, 
    -0.02041986f, -0.03964280f, -0.02232274f, 0.01528715f, -0.04811599f, -0.01899789f, -0.04896957f, -0.03680222f, 
    0.03360612f, -0.01827223f, -0.01053340f, -0.04395626f, -0.00638434f, -0.05532194f, 0.01949462f, -0.01345084f, 
    -0.00451774f, 0.02868200f, 0.02483319f, -0.05048105f, 0.01273213f, -0.01282276f, 0.03350039f, -0.00169438f, 
    -0.00724478f, 0.01792258f, 0.03416858f, -0.02989706f, 0.02641355f, -0.00801479f, 0.03391568f, -0.02822536f, 
    -0.02810164f, -0.01288183f, 0.02179338f, 0.03596632f, -0.04768436f, -0.01349476f, -0.05647060f, 0.03710463f, 
    0.01335510f, -0.04107582f, 0.02421453f, -0.01548496f, -0.02395471f, -0.01505324f, -0.00497894f, 0.03044237f, 
    -0.04740948f, -0.04271812f, 0.04357106f, 0.01421818f, -0.03953023f, 0.03510512f, -0.00476867f, -0.04173528f, 
    0.02706137f, 0.00987384f, 0.01309047f, 0.01083785f, -0.00710766f, -0.03437338f, -0.03322712f, 0.04477845f, 
    -0.03263328f, -0.02283113f, 0.04303913f, -0.03343564f, -0.01688190f, -0.04287763f, -0.02141623f, 0.00505752f, 
    -0.05376663f, 0.04206165f, -0.05559299f, -0.00390078f, 0.04259488f, 0.00925908f, -0.00536491f, 0.00440324f, 
    -0.02765301f, -0.01889606f, -0.01030082f, -0.01734033f, 0.00113369f, 0.02586335f, -0.03680743f, -0.02330172f, 
    -0.03594759f, 0.04314569f, 0.03750299f, 0.04303380f, -0.05162787f, -0.00600033f, 0.00562229f, -0.02026343f, 
    -0.01358820f, -0.02384798f, -0.00367163f, 0.01119261f, -0.02802662f, 0.02928287f, 0.03371306f, -0.02599224f, 
    0.01682748f, -0.04816290f, 0.03128480f, -0.02083157f, 0.00972318f, -0.04184281f, -0.04154886f, 0.02227719f, 
    -0.02805795f, -0.02276868f, -0.04958286f, -0.01544322f, 0.03594969f, 0.01321483f, 0.03143379f, -0.04051350f, 
    -0.04747163f, 0.00715507f, 0.00398988f, 0.03799421f, -0.01606764f, -0.03352278f, -0.00853595f, 0.02496242f, 
    0.01781688f, -0.00957013f, 0.04511788f, -0.04201781f, 0.00751279f, 0.03044771f, -0.03801915f, 0.03511637f, 
    -0.03289338f, -0.01973527f, -0.01171841f, 0.03132732f, -0.01294065f, -0.03400265f, -0.05392932f, 0.03335384f, 
    -0.04096320f, -0.04681477f, 0.00536841f, 0.00848910f, 0.02094130f, -0.01418224f, 0.01281592f, -0.03610083f, 
    -0.02115874f, 0.03399054f, -0.04623337f, -0.01076534f, -0.00986326f, 0.01060911f, -0.00970232f, -0.01186575f, 
    -0.01791594f, -0.05929810f, 0.00114567f, -0.04322068f, -0.00377888f, -0.03849204f, 0.00797780f, -0.00517054f, 
    -0.04658436f, -0.06355777f, -0.02632203f, -0.05380161f, -0.01263447f, -0.06372941f, -0.01120788f, 0.02584266f, 
    0.01146545f, -0.04189702f, -0.01226972f, 0.02529847f, -0.05369461f, 0.00061392f, 0.00291160f, 0.01716370f, 
    -0.06096355f, 0.01098676f, -0.06373274f, 0.03268740f, -0.00073370f, -0.06018498f, -0.04196543f, 0.02016161f, 
    -0.05620760f, -0.03474483f, 0.02455631f, -0.03496031f, 0.02519831f, 0.03343054f, -0.00378315f, 0.00207459f, 
    0.04081992f, -0.02574911f, 0.01066101f, 0.00021811f, -0.05012113f, 0.01739830f, 0.02452159f, 0.02350039f, 
    -0.04052042f, 0.00831887f, 0.01015104f, 0.00188644f, -0.03130472f, 0.00967999f, -0.04504309f, -0.04639031f, 
    -0.05025831f, -0.06420922f, -0.02453721f, 0.00003467f, -0.00526542f, 0.02264961f, -0.02112640f, -0.00860470f, 
    0.02555933f, 0.00152153f, 0.01737406f, -0.00801548f, 0.00852002f, 0.02285779f, 0.00120452f, -0.00474106f, 
    -0.03277308f, 0.00534720f, -0.04461459f, 0.00664887f, -0.01864384f, -0.01710378f, 0.03252255f, -0.01653854f, 
    -0.01604557f, -0.02954646f, -0.05082034f, -0.03418959f, 0.00771517f, -0.02797019f, 0.00589981f, -0.03019150f, 
    -0.03310707f, -0.00919887f, -0.02319978f, 0.02753420f, -0.03401565f, 0.05373839f, 0.01071444f, -0.01067662f, 
    0.02568071f, -0.00220276f, -0.05699307f, -0.05266330f, 0.03687434f, -0.00835316f, 0.01267926f, 0.02985306f, 
    -0.02457001f, 0.06081275f, -0.03757811f, -0.02506637f, 0.00285623f, 0.01231107f, 0.02353923f, -0.02078654f, 
    0.00017589f, 0.03667811f, -0.00691124f, -0.02857086f, 0.04438478f, -0.02098159f, -0.04954735f, 0.00129488f, 
    -0.02264481f, -0.02005034f, 0.00477903f, -0.01639843f, 0.01045822f, -0.04009289f, -0.02023993f, -0.03916013f, 
    -0.00639039f, -0.06491247f, 0.01370410f, 0.04397967f, 0.02501136f, 0.02860917f, 0.02127487f, -0.01865113f, 
    0.00628407f, 0.02768713f, -0.03931842f, -0.04869597f, -0.03660178f, -0.05822780f, -0.05698800f, -0.07811135f, 
    -0.05259983f, -0.03426389f, -0.00339838f, 0.00400139f, -0.02200073f, -0.04268681f, -0.06127528f, -0.01532187f, 
    -0.05036796f, 0.01047256f, -0.00096590f, -0.00528012f, -0.04642555f, -0.03900412f, 0.01291744f, 0.00182332f, 
    -0.01564281f, 0.00478690f, -0.01111502f, -0.02479297f, -0.03525825f, 0.05630498f, -0.03039435f, -0.02549415f, 
    -0.03677452f, 0.01642485f, -0.03786902f, -0.06311127f, -0.02347735f, 0.00475329f, -0.01933626f, 0.00406427f, 
    0.00186556f, 0.03726315f, -0.01788046f, 0.05159046f, -0.00925801f, -0.07280599f, 0.00139458f, 0.01289531f, 
    0.00344958f, -0.01513848f, -0.01906178f, 0.00734008f, 0.03196356f, -0.06149709f, -0.04636204f, -0.01723789f, 
    -0.08136039f, -0.05246790f, -0.00942641f, -0.03363162f, 0.02873497f, 0.02276811f, 0.05346779f, -0.04004288f, 
    -0.03225385f, 0.01991698f, -0.02871203f, 0.02460075f, 0.03807896f, 0.03779956f, -0.00014937f, 0.02849077f, 
    0.01538136f, -0.01683153f, 0.02975097f, 0.03740470f, -0.04094128f, 0.02292202f, -0.02065211f, 0.03093867f, 
    0.02452368f, 0.02957688f, 0.02047750f, 0.02500646f, -0.01352369f, 0.04730333f, -0.00114086f, 0.01217251f, 
    0.03668019f, -0.03561122f, 0.02519108f, -0.02660425f, -0.02792521f, 0.01110943f, -0.04848560f, -0.04704738f, 
    0.02450878f, 0.01140973f, -0.00336407f, 0.00777273f, -0.04528658f, -0.02643761f, 0.01780077f, -0.02999979f, 
    -0.04117376f, -0.02709108f, -0.03380721f, 0.00207188f, 0.04369349f, -0.02302711f, -0.06713468f, 0.01798054f, 
    -0.04161081f, 0.03467346f, -0.06099693f, -0.02195483f, 0.00405526f, -0.02146531f, 0.00551653f, -0.00537771f, 
    0.04090129f, -0.03923453f, -0.05163168f, -0.00522797f, -0.02587608f, 0.00068020f, -0.03069229f, -0.01113209f, 
    0.03779772f, 0.01935950f, -0.02587366f, -0.02717269f, 0.00903333f, -0.04220134f, -0.03248144f, 0.01165638f, 
    0.02390840f, 0.01715457f, -0.02580976f, -0.00423832f, 0.02699468f, -0.00404098f, 0.02337882f, -0.01364748f, 
    0.01855407f, -0.01550868f, 0.01115894f, -0.04850192f, -0.02469671f, -0.01468606f, -0.01147704f, -0.03213275f, 
    -0.02255257f, 0.01717381f, -0.04738032f, -0.04834511f, 0.01510800f, -0.06049820f, 0.00162227f, -0.03232966f, 
    -0.07040794f, -0.00452837f, -0.03839224f, -0.06048873f, -0.01475538f, 0.03810795f, 0.00175271f, -0.03609256f, 
    -0.03716191f, -0.00315364f, -0.04900266f, 0.01139272f, -0.01048726f, 0.02026374f, -0.04379586f, -0.03918870f, 
    0.00231383f, -0.00235298f, -0.03920743f, 0.00116426f, 0.01430628f, -0.03796767f, 0.02973458f, -0.03905950f, 
    0.04509996f, -0.01836937f, 0.00737786f, 0.01262888f, -0.03979694f, 0.02917030f, 0.01634187f, -0.02136949f, 
    -0.00289455f, 0.03401978f, -0.02777212f, -0.06613436f, -0.02900362f, 0.01542886f, -0.00566787f, -0.04330502f, 
    -0.03527306f, -0.01914655f, -0.04050426f, -0.01053659f, -0.00703024f, 0.02328482f, -0.04228038f, 0.02268912f, 
    -0.01322519f, 0.01963373f, -0.07503802f, -0.03347981f, -0.01618862f, 0.01028017f, 0.02019816f, 0.01457638f, 
    0.01025481f, -0.02588537f, 0.00797250f, -0.04769298f, -0.03061923f, -0.03304769f, -0.03566814f, -0.03924746f, 
    -0.05214258f, -0.01083731f, 0.00297443f, 0.01060112f, -0.00789485f, 0.02235199f, 0.01208657f, 0.00414083f, 
    0.00162209f, 0.01307913f, 0.03583105f, 0.04881691f, -0.04703426f, 0.02583592f, -0.03239877f, 0.01874057f, 
    -0.03551875f, -0.02922344f, 0.01423172f, 0.04619758f, -0.02405534f, -0.02424294f, 0.02002235f, -0.04630723f, 
    -0.08533279f, 0.01593588f, 0.12923506f, -0.04847967f, -0.10144773f, -0.03364718f, -0.10522729f, 0.00959561f, 
    -0.03352557f, 0.04808890f, 0.15503129f, 0.15238099f, -0.09688622f, 0.07830089f, -0.11177772f, 0.14088476f, 
    -0.04760444f, 0.00144334f, 0.01101316f, -0.01272250f, 0.18197730f, 0.05639613f, 0.03752882f, 0.22318137f, 
    -0.35957196f, -0.16648778f, 0.16417904f, 0.04065607f, 0.06610447f, -0.02084869f, -0.06911782f, 0.02434616f, 
    -0.04014625f, 0.20543632f, -0.05342405f, 0.08748963f, 0.20305617f, 0.07758845f, -0.12177006f, 0.14060363f, 
    0.16168843f, 0.11938047f, 0.07736465f, 0.02064377f, -0.13514033f, -0.07734300f, 0.10893056f, 0.22641020f, 
    -0.15011646f, -0.30147669f, 0.09353884f, 0.27504426f, 0.01756662f, 0.10846084f, -0.00002406f, -0.03166771f, 
    0.11061999f, 0.09553428f, -0.17030041f, 0.18614510f, 0.25776881f, 0.08963150f, -0.12645216f, -0.23176661f, 
    0.22071315f, -0.02088412f, 0.08042461f, -0.01907404f, -0.02678787f, -0.01633251f, -0.17774171f, 0.00414248f, 
    0.20905612f, 0.05700951f, -0.17868881f, -0.05471502f, 0.05989553f, 0.05383354f, -0.10952374f, -0.08705038f, 
    0.04337246f, 0.11331603f, 0.09477820f, 0.24276413f, -0.24282138f, 0.39226809f, -0.04864023f, 0.27783328f, 
    -0.15395744f, -0.20863366f, 0.17477439f, -0.13868740f, -0.07674712f, -0.15694343f, 0.05584018f, 0.17732239f, 
    0.06052441f, -0.04953870f, 0.06934761f, 0.00379311f, 0.11239244f, 0.00818891f, -0.09755633f, -0.17491795f, 
    -0.03150685f, -0.04786899f, 0.04336764f, -0.21688797f, -0.15286319f, -0.32384005f, 0.41912758f, 0.11490133f, 
    -0.04340544f, -0.21033318f, -0.09129984f, -0.06487576f, -0.02008020f, -0.02861808f, 0.06854663f, 0.00197154f, 
    0.01179950f, 0.04872382f, -0.08981845f, 0.15036874f, 0.16073139f, -0.08745987f, 0.04965519f, -0.09106655f, 
    -0.02308912f, -0.07264045f, -0.00344402f, 0.19994257f, -0.21048477f, 0.38913095f, -0.26383957f, -0.01587510f, 
    0.22472486f, -0.03233292f, 0.12697761f, 0.06221178f, -0.03578913f, -0.01681498f, -0.07511773f, -0.08237692f, 
    -0.06317513f, 0.48735154f, -0.09216373f, -0.20580810f, 0.28916243f, 0.03670945f, 0.04535922f, -0.15404266f, 
    -0.00985497f, -0.17878158f, -0.14980721f, 0.05991725f, 0.34433511f, -0.14614719f, -0.19202431f, 0.16601233f, 
    0.04909742f, -0.03273393f, 0.15921789f, -0.03680104f, -0.18197326f, -0.16098242f, -0.08666811f, -0.03911003f, 
    0.20313932f, 0.10979497f, 0.08492710f, 0.01800139f, 0.01834001f, -0.12414063f, 0.01795484f, 0.10980085f, 
    -0.04537736f, 0.04820601f, -0.13447912f, -0.15394482f, -0.41111973f, 0.42527118f, -0.04749011f, -0.14581217f, 
    0.07170263f, 0.01939915f, 0.03173641f, -0.02237324f, -0.05918093f, -0.04463323f, -0.03636876f, -0.24452898f, 
    -0.08574884f, 0.06032505f, -0.35725456f, -0.14433472f, 0.03179116f, 0.00775863f, 0.00538900f, -0.01907176f, 
    -0.23828514f, 0.15298259f, -0.04438525f, -0.07602493f, 0.08463188f, 0.22546005f, -0.01377151f, 0.15358911f, 
    0.02727838f, 0.02630774f, 0.02934729f, 0.01784719f, -0.05008446f, 0.04465530f, -0.05323917f, 0.11418424f, 
    0.27745315f, -0.21156608f, 0.10012995f, 0.28755292f, 0.00608355f, 0.02629958f, -0.05759233f, -0.16532364f, 
    -0.13497038f, -0.03541547f, 0.00067146f, -0.04976002f, -0.20382041f, 0.39940691f, -0.05579233f, 0.10611206f, 
    0.08736425f, -0.16698861f, 0.15585528f, 0.01925739f, -0.07259861f, 0.05727458f, -0.01869789f, -0.04468845f, 
    -0.11602247f, 0.12420768f, 0.03552528f, 0.38849330f, 0.08438809f, -0.02120548f, 0.15484652f, -0.06773548f, 
    -0.07718745f, -0.01264546f, 0.02837047f, 0.06242276f, -0.03578149f, -0.12642756f, -0.09243750f, -0.10392711f, 
    0.09530759f, 0.10609523f, -0.22487609f, 0.10743537f, 0.03337743f, -0.10545689f, -0.05297710f, 0.16175349f, 
    -0.15615867f, 0.26489076f, -0.06267730f, 0.27984267f, 0.01687944f, -0.17017634f, 0.06781302f, 0.05498720f, 
    -0.04745685f, 0.04830252f, -0.10029354f, -0.07530716f, 0.10420644f, 0.15931515f, 0.13259086f, -0.00198135f, 
    -0.10594252f, -0.02379575f, -0.01414152f, 0.04275932f, -0.01548862f, -0.03064835f, 0.13204277f, -0.05156477f, 
    0.30525947f, 0.22521181f, 0.19707695f, -0.08283204f, -0.11646484f, 0.11435933f, -0.08993423f, -0.16033089f, 
    0.08308445f, 0.02649716f, -0.01785353f, -0.08572943f, -0.25591609f, 0.23486942f, -0.78530473f, 0.26912901f, 
    0.02831918f, 0.05932237f, 0.10807369f, 0.19656184f, -0.09681419f, -0.03007542f, 0.08308349f, -0.00333320f, 
    0.01132331f, 0.17755859f, -0.38288614f, 0.05834770f, 0.09402470f, -0.07115728f, -0.03897613f, 0.00310923f, 
    -0.21490648f, 0.06860809f, -0.18726231f, -0.19805226f, -0.03986261f, 0.09648482f, 0.04451820f, 0.23999090f, 
    -0.29967707f, -0.13507387f, 0.03800971f, -0.12916140f, -0.05624222f, 0.05158072f, -0.06069753f, -0.13072030f, 
    0.36635217f, -0.04017384f, -0.04945372f, 0.29753789f, 0.14048621f, 0.18022332f, 0.24834292f, -0.01597156f, 
    -0.01222801f, 0.00192479f, 0.11165950f, 0.15508240f, 0.04966791f, -0.20677330f, 0.03864485f, 0.14356588f, 
    0.10067176f, 0.00590162f, 0.09925685f, 0.06886677f, -0.07612254f, -0.01648375f, 0.06110245f, -0.09859212f, 
    0.20707563f, -0.10342145f, 0.59513807f, -0.32752258f, -0.05605335f, 0.05660042f, -0.01369409f, -0.10883475f, 
    0.02581087f, -0.02642150f, 0.11256560f, -0.02158339f, 0.12664574f, -0.15531737f, 0.52930999f, -0.10139157f, 
    -0.09238971f, 0.05299371f, 0.01159004f, 0.01126546f, 0.21169834f, 0.13410914f, 0.21902181f, 0.18185653f, 
    -0.00506604f, -0.37536618f, -0.00921579f, -0.11715558f, 0.00415970f, -0.06247544f, 0.14798144f, 0.07201546f, 
    0.13587731f, 0.23335353f, 0.06024433f, 0.07427756f, 0.07831693f, -0.18258077f, -0.38799864f, 0.11935830f, 
    0.12256523f, 0.06965576f, 0.21770315f, 0.27643615f, 0.22953096f, 0.04960802f, 0.03352359f, 0.23734242f, 
    0.19906433f, -0.21494389f, -0.25253725f, -0.12253018f, 0.01343223f, 0.13749172f, 0.09538971f, 0.03081583f, 
    0.28108913f, -0.03040078f, 0.21120632f, 0.27916694f, -0.03590748f, -0.01609893f, 0.07940627f, -0.00150003f, 
    -0.06965087f, 0.01666486f, -0.02655341f, -0.12595433f, -0.01709323f, -0.17791857f, -0.07013423f, 0.28030601f, 
    0.41484457f, 0.13053484f, 0.31030452f, -0.05991052f, -0.12696773f, -0.02042048f, -0.02173316f, -0.00206367f, 
    0.18415469f, -0.05432779f, 0.03301708f, -0.02617889f, 0.04352638f, 0.01792176f, -0.04381731f, -0.01181342f, 
    0.03552511f, 0.05180550f, -0.16703203f, 0.05128903f, -0.09562775f, 0.08943585f, -0.29629716f, -0.19654602f, 
    0.30881032f, 0.02623418f, 0.21643142f, 0.04312914f, 0.04063218f, -0.09546667f, -0.03510963f, 0.06898873f, 
    0.05362187f, 0.13446333f, 0.34149590f, 0.24388741f, -0.08738858f, -0.26088661f, 0.05977618f, 0.22059080f, 
    -0.07708652f, -0.01912730f, 0.24818236f, -0.10984724f, 0.29062402f, -0.04059451f, -0.16998023f, 0.02063286f, 
    -0.13161565f, -0.20685805f, 0.00443098f, 0.05837642f, 0.01819044f, 0.05293003f, -0.06718387f, -0.05971751f, 
    -0.12664223f, -0.31299540f, -0.08221211f, -0.38905126f, 0.64408070f, 0.08389533f, 0.22370988f, -0.10035864f, 
    0.11185268f, 0.22000225f, -0.26623777f, 0.00132461f, -0.10803407f, 0.02734422f, 0.03712803f, -0.09443010f, 
    0.21373473f, 0.15752658f, -0.05377613f, 0.01824889f, 0.13920768f, -0.06844904f, 0.10343518f, 0.09356756f, 
    -0.00400775f, 0.07550514f, -0.21762186f, 0.17987885f, 0.03013330f, 0.18650612f, -0.24598692f, 0.13245469f, 
    0.17657912f, -0.06435256f, -0.02692604f, -0.02197755f, -0.24971132f, -0.00222957f, 0.11453024f, -0.09396764f, 
    0.03368582f, 0.06484666f, 0.27479017f, 0.25986314f, -0.12127504f, 0.02834073f, -0.07776046f, -0.01571489f, 
    0.20658636f, 0.11848653f, -0.08569814f, -0.22766954f, -0.18260676f, 0.13405688f, -0.06996949f, 0.04577399f, 
    0.18022321f, -0.05473437f, -0.02776513f, -0.07500224f, 0.07813884f, -0.12060934f, 0.17529202f, -0.00728568f, 
    0.14239372f, 0.14979467f, -0.03394808f, -0.14920327f, -0.08733414f, 0.05884923f, -0.03606006f, -0.07608959f, 
    -0.05450789f, -0.17281888f, -0.17621571f, -0.12222793f, -0.04416864f, -0.26500598f, 0.04511357f, 0.15765509f, 
    0.05029117f, -0.01714284f, 0.06733709f, 0.03071279f, 0.02730975f, -0.18360250f, -0.13184136f, -0.06163467f, 
    -0.28410262f, 0.11229835f, -0.19518247f, 0.10018148f, 0.00854505f, -0.19857545f, -0.12243822f, -0.01093423f, 
    -0.00191386f, 0.32316929f, 0.16704418f, 0.33571520f, -0.13919203f, 0.10061236f, 0.02045566f, -0.18022139f, 
    -0.15131015f, 0.11760429f, 0.05729496f, 0.04854773f, -0.19728579f, 0.13021897f, 0.17792791f, 0.15013318f, 
    0.06809927f, 0.12799026f, -0.10673137f, -0.19615543f, -0.03774677f, -0.05693738f, -0.15595151f, -0.08788501f, 
    -0.15344635f, -0.23166664f, -0.08123933f, -0.10369505f, 0.14178745f, 0.08115923f, 0.40973264f, 0.11385416f, 
    0.21300524f, -0.12828830f, 0.04476695f, 0.15825129f, -0.12130582f, -0.05455502f, -0.11897545f, -0.08152298f, 
    -0.33238634f, 0.48471305f, -0.07588079f, -0.26097691f, 0.02239206f, 0.02246495f, 0.04602037f, 0.18882276f, 
    -0.12382101f, 0.08021449f, 0.04960699f, 0.11792865f, 0.12520584f, 0.13142371f, 0.19600540f, 0.00614895f, 
    0.03413111f, 0.15207361f, 0.23649713f, 0.17238051f, 0.04249193f, 0.16605203f, 0.08262254f, 0.14988312f, 
    -0.18934715f, 0.04636277f, -0.12411857f, 0.15301576f, -0.09268277f, -0.12560301f, 0.00611859f, 0.01435788f, 
    0.02240334f, 0.04255639f, -0.03618225f, -0.01599407f, 0.11858688f, -0.16096944f, -0.01752715f, -0.08002233f, 
    -0.03814030f, 0.09746814f, -0.04901830f, -0.02782825f, -0.04097155f, -0.13631710f, 0.00359552f, 0.01268537f, 
    0.14213566f, -0.00079638f, -0.03834368f, -0.23498793f, 0.10827884f, 0.05173602f, -0.11919110f, -0.03005798f, 
    -0.14098340f, -0.07885067f, -0.09231789f, -0.17860906f, -0.29683566f, -0.11486314f, 0.10385541f, 0.12937987f, 
    0.01500492f, 0.08595514f, -0.26512930f, 0.13810718f, 0.10835648f, 0.08933800f, 0.07538681f, -0.05487149f, 
    -0.13637464f, 0.05825976f, -0.32104585f, 0.03296629f, 0.10212262f, -0.11315590f, 0.12479714f, -0.05175441f, 
    -0.04752281f, -0.09319721f, -0.33685386f, -0.16357903f, 0.16724800f, -0.27951196f, 0.12768802f, -0.25956932f, 
    0.25120661f, 0.03655864f, 0.00079057f, 0.06540439f, -0.23148030f, 0.01274556f, -0.11118902f, -0.15742078f, 
    0.07822721f, -0.20410754f, 0.14131781f, -0.09043384f, 0.24290793f, 0.13858429f, 0.37664950f, 0.26585206f, 
    0.15088785f, -0.05704441f, 0.10576172f, 0.36144543f, 0.13425012f, 0.09494363f, -0.07530366f, -0.12008503f, 
    0.10337909f, -0.07825036f, -0.00563547f, -0.06609631f, 0.02253083f, -0.13065189f, -0.11150008f, 0.03078087f, 
    -0.05159521f, 0.04454572f, -0.02839011f, -0.03259750f, 0.03916970f, 0.06571088f, -0.06565513f, 0.12410663f, 
    -0.03790198f, -0.03655659f, 0.12211099f, 0.07307094f, -0.11471573f, -0.15386659f, 0.13934450f, -0.21767592f, 
    0.07201049f, 0.09067482f, 0.07189130f, -0.01992189f, 0.28728741f, 0.11817659f, 0.17619726f, 0.13667083f, 
    -0.31779715f, -0.06331380f, -0.18771671f, -0.08180688f, -0.03239348f, 0.23715596f, 0.11812846f, 0.06771025f, 
    0.15878613f, 0.13044314f, 0.04126146f, 0.36434427f, -0.20194922f, -0.22948466f, -0.23309480f, 0.03540498f, 
    0.03601563f, 0.08179020f, 0.04255239f, 0.04381655f, 0.32701269f, 0.26332307f, 0.11936440f, 0.42487738f, 
    -0.10201028f, 0.47965935f, 0.03000428f, 0.00781365f, 0.17390865f, 0.11142821f, -0.13647570f, -0.13093629f, 
    0.16573910f, 0.09826178f, 0.01949951f, 0.20864987f, -0.17837542f, -0.05096460f, -0.13861598f, 0.19289678f, 
    -0.13906233f, 0.00923926f, 0.02162351f, 0.09624215f, 0.05174984f, 0.01249598f, 0.18677764f, 0.27649388f, 
    0.26049769f, 0.38834682f, 0.11328234f, -0.08401623f, -0.19858408f, -0.04197633f, -0.05383389f, -0.01023953f, 
    0.26638952f, 0.03847764f, 0.00420738f, 0.09394239f, 0.05411849f, -0.15242282f, -0.09374085f, -0.11645130f, 
    0.07419750f, -0.16136067f, 0.05858103f, 0.00063586f, -0.08773416f, -0.09534509f, -0.10445491f, -0.26952663f, 
    0.11618224f, 0.27325514f, 0.10080433f, 0.26037148f, -0.04733502f, 0.04431854f, 0.03067769f, -0.03556020f, 
    0.16081594f, 0.15793526f, 0.19626825f, 0.23995656f, -0.17486806f, -0.02318714f, 0.07258741f, -0.17977577f, 
    0.15012440f, 0.10090758f, 0.04818835f, -0.35110953f, 0.12214180f, -0.28263468f, -0.37556303f, 0.06953419f, 
    -0.08844920f, -0.13843039f, 0.22733276f, 0.00660417f, -0.04817066f, -0.11849802f, -0.10254361f, 0.02351079f, 
    -0.23382923f, -0.27338740f, -0.25685495f, -0.54217404f, -0.47591498f, 0.23908634f, 0.19080654f, -0.02170778f, 
    0.03021725f, -0.06208747f, -0.04102194f, -0.15242589f, -0.09720606f, -0.17987531f, 0.08289592f, -0.09367046f, 
    0.25392199f, -0.09319048f, 0.00537946f, 0.20444030f, -0.00202648f, -0.02559960f, 0.03901078f, 0.00478616f, 
    0.00111968f, 0.03268272f, -0.00223088f, 0.19590434f, 0.11840521f, 0.39563227f, -0.02826343f, 0.08935636f, 
    0.18364774f, 0.01324292f, -0.00620417f, 0.20798895f, 0.01751161f, 0.02409663f, -0.02615733f, -0.07310321f, 
    0.35208967f, -0.05605851f, -0.13261546f, 0.13099404f, 0.05988855f, 0.08378062f, -0.01383286f, -0.12036112f, 
    0.12154996f, -0.06795723f, -0.02863909f, -0.03054684f, 0.19171791f, 0.25584936f, 0.12245860f, 0.12583321f, 
    -0.05672795f, -0.11787915f, -0.11672685f, -0.05244119f, -0.01701883f, -0.23704566f, -0.02241274f, -0.08967397f, 
    -0.23447460f, -0.17213838f, -0.17739277f, -0.06443132f, 0.05590439f, -0.08779426f, 0.10759453f, -0.10816259f, 
    -0.13741660f, -0.13801415f, -0.46843955f, -0.37319887f, 0.07964517f, 0.10138800f, -0.07143292f, -0.01786628f, 
    -0.06744501f, 0.12537071f, 0.17252943f, -0.00013652f, -0.15872791f, 0.06429791f, -0.13221741f, -0.26848891f, 
    0.28051928f, -0.31608281f, 0.06525513f, 0.02681276f, 0.16016114f, -0.02698515f, -0.15079033f, -0.06424908f, 
    -0.11238819f, 0.13703822f, 0.31916970f, 0.09021569f, -0.30102545f, -0.31925619f, -0.05249063f, 0.01143118f, 
    0.01857104f, 0.03844644f, -0.02641470f, 0.02998930f, -0.03318221f, 0.00553285f, 0.05688878f, 0.05835093f, 
    0.05638048f, -0.36527359f, -0.02833203f, 0.08682366f, 0.03189807f, -0.00722314f, -0.10818023f, 0.05680435f, 
    -0.09883317f, -0.19059636f, -0.02885070f, -0.17542267f, -0.19099951f, 0.10123010f, 0.01695276f, 0.20665854f, 
    0.12689619f, 0.02582843f, 0.08619181f, 0.07046713f, -0.18888162f, 0.08138887f, -0.23985590f, -0.10959949f, 
    -0.18471886f, 0.63394624f, 0.58646059f, 0.34121981f, -0.03634051f, -0.05732852f, 0.16775498f, -0.07555765f, 
    -0.03332594f, -0.06503361f, 0.00076539f, 0.13154477f, -0.27908835f, 0.00300546f, -0.05833135f, 0.00494319f, 
    0.04043392f, 0.29462144f, 0.10319922f, -0.00636106f, 0.26452863f, 0.09553145f, 0.10845341f, 0.24563456f, 
    -0.48963821f, -0.20923902f, -0.01520002f, -0.06975496f, 0.19440010f, -0.03537596f, -0.00796034f, -0.01887993f, 
    0.08177631f, -0.01287911f, -0.14934359f, -0.18040781f, -0.07876619f, -0.03474997f, -0.10422135f, 0.02655938f, 
    0.13204342f, 0.04633310f, -0.03387081f, 0.12551849f, -0.12097207f, -0.16470720f, -0.00532099f, -0.09782926f, 
    -0.28664663f, -0.17267296f, -0.14046404f, 0.14080577f, 0.08206889f, 0.13407606f, 0.01699908f, -0.08896162f, 
    -0.06938525f, -0.18975186f, -0.24629964f, -0.26819667f, 0.05497365f, -0.11910577f, 0.01022053f, 0.04716576f, 
    0.02412944f, 0.02405816f, -0.12920827f, 0.13580883f, 0.15679690f, 0.09154511f, 0.24188022f, 0.02417822f, 
    -0.05074438f, -0.10451677f, -0.11490957f, -0.00028825f, 0.10713755f, -0.00439768f, -0.01009203f, -0.04968420f, 
    -0.14326654f, -0.16934754f, -0.19213240f, -0.42650533f, 0.05355825f, -0.07490017f, -0.12558590f, 0.01047673f, 
    -0.15308157f, -0.15499620f, 0.23241177f, 0.09074476f, 0.03111333f, -0.00094298f, -0.00498475f, -0.17088324f, 
    0.05574983f, -0.39378428f, 0.13319744f, 0.20788880f, -0.01549519f, 0.00793313f, 0.13685347f, 0.09602733f, 
    0.21331184f, 0.09515081f, 0.30495152f, 0.17895010f, -0.07700260f, -0.15719788f, 0.00518372f, 0.03851036f, 
    -0.26160696f, -0.28085318f, 0.08358054f, 0.18643565f, 0.15634386f, 0.07150949f, 0.03464198f, -0.08279022f, 
    -0.02330153f, -0.00343345f, -0.06716987f, -0.06027759f, -0.06437358f, 0.09169344f, 0.04755628f, -0.13009280f, 
    0.03236564f, -0.10855708f, 0.09168731f, -0.01860527f, -0.08631851f, 0.02817941f, -0.00654698f, -0.11265655f, 
    0.08048369f, -0.01790380f, 0.19405720f, -0.12071453f, 0.17755951f, 0.16203582f, 0.13348787f, 0.45883447f, 
    -0.10991412f, 0.09166885f, -0.09988894f, -0.08574086f, -0.08635828f, 0.12012582f, -0.10223641f, -0.04616443f, 
    0.03708703f, -0.04349999f, 0.23182347f, 0.09635440f, -0.08200555f, -0.10682582f, -0.06056908f, -0.10441537f, 
    -0.08930319f, -0.11211205f, -0.23300973f, -0.03519257f, -0.18480231f, -0.16134934f, -0.05179583f, 0.12916169f, 
    0.25238314f, -0.01061342f, -0.29288068f, 0.04759964f, 0.00425973f, -0.11642916f, -0.01645061f, 0.06507048f, 
    0.12194564f, -0.13335907f, -0.14950021f, 0.16429061f, 0.01319785f, 0.17278351f, 0.18960695f, 0.30309692f, 
    0.05704848f, 0.13435836f, 0.00592543f, 0.13734414f, -0.03588837f, 0.07274430f, -0.08773828f, -0.15339553f, 
    0.18236376f, 0.32376233f, 0.07294271f, -0.00764967f, -0.11180627f, 0.07508428f, 0.04170796f, -0.16254674f, 
    0.13317783f, -0.05372883f, 0.01362163f, 0.13645139f, -0.02316654f, -0.16344430f, 0.00143187f, -0.04414206f, 
    0.02641751f, -0.04377257f, -0.04298954f, -0.05315532f, 0.11163571f, -0.06935704f, -0.03121948f, -0.09957951f, 
    -0.20512252f, 0.27618635f, 0.03598377f, 0.07291085f, 0.00638147f, 0.00575244f, 0.00909250f, 0.07871193f, 
    0.04062289f, 0.02270317f, -0.02010024f, 0.03792622f, -0.06282260f, 0.17379820f, -0.31729564f, 0.00141454f, 
    -0.19119556f, -0.15836214f, 0.06873802f, 0.16635205f, 0.16468763f, 0.03819599f, -0.08584525f, -0.12767316f, 
    -0.02476585f, 0.16576076f, 0.08597054f, 0.08319187f, -0.11575080f, 0.27286538f, 0.13881075f, -0.04061936f, 
    -0.10086155f, -0.04636469f, -0.01064447f, -0.11788673f, -0.25569266f, -0.02167815f, -0.27070948f, -0.02931156f, 
    0.13356821f, 0.15669809f, -0.08467474f, -0.23774019f, -0.09199485f, 0.17552583f, -0.16553821f, -0.11336319f, 
    0.07987091f, 0.26665512f, 0.30947027f, 0.04612351f, 0.07780734f, 0.22439334f, -0.05419692f, 0.06884623f, 
    -0.13077910f, -0.09000589f, -0.10731078f, -0.01518916f, 0.15413475f, -0.25860280f, 0.11882685f, 0.24648668f, 
    -0.05410928f, 0.05406381f, 0.04137111f, -0.02005287f, 0.19364214f, -0.02512977f, -0.04904918f, 0.09838073f, 
    -0.63283312f, 0.25005451f, 0.08654634f, -0.22296487f, -0.03843516f, 0.09544294f, -0.07716822f, 0.13208289f, 
    -0.01374624f, -0.05654001f, 0.03597203f, 0.13842820f, 0.46978608f, 0.27744475f, 0.13587809f, -0.09453980f, 
    0.02988621f, -0.09559245f, 0.09746902f, 0.22922213f, -0.00080394f, -0.14723118f, -0.11975163f, 0.01102843f, 
    -0.04252490f, -0.06375312f, -0.03685362f, -0.05601996f, 0.25235599f, 0.12177065f, 0.12005373f, 0.15643594f, 
    -0.14835115f, -0.02649504f, 0.10279658f, 0.08799844f, -0.14570585f, 0.15042473f, 0.09899762f, 0.22066227f, 
    -0.09952822f, 0.12880743f, -0.01133989f, 0.04744457f, 0.11955938f, -0.18172073f, -0.21136032f, -0.11174221f, 
    -0.15050827f, 0.17400889f, 0.12464473f, 0.12269638f, -0.01315590f, -0.02361589f, 0.01329951f, 0.04076323f, 
    0.10817565f, 0.00383484f, -0.14818080f, -0.03755744f, -0.00408568f, -0.05174861f, 0.10580280f, 0.21777783f, 
    0.20670086f, 0.02400656f, -0.25836340f, 0.05537630f, 0.02590073f, -0.01508890f, -0.05147556f, 0.05546842f, 
    0.22538847f, 0.09365801f, 0.41583532f, 0.10427113f, -0.10648394f, 0.04971877f, 0.43468389f, 0.17197357f, 
    -0.01683603f, 0.05898313f, -0.03833534f, 0.03642116f, -0.06473032f, 0.03287202f, -0.03855436f, 0.13280338f, 
    0.09482992f, 0.10334987f, -0.04904072f, 0.20327668f, 0.06065316f, -0.05176860f, -0.04229017f, -0.00933798f, 
    0.37572792f, 0.15583386f, 0.14563818f, 0.14085795f, 0.02763921f, -0.10739277f, -0.01850417f, 0.09860872f, 
    0.08856896f, -0.03889085f, -0.00537106f, 0.03707661f, 0.04995946f, 0.17302653f, 0.16191944f, 0.03589480f, 
    0.21673720f, 0.23671241f, -0.04757729f, 0.16130519f, 0.07578889f, 0.06784751f, 0.05988915f, 0.00411504f, 
    0.04705353f, -0.17053352f, -0.05752463f, -0.33588764f, -0.03871414f, 0.08936774f, 0.03384636f, 0.04575025f, 
    -0.02081473f, -0.00370085f, 0.25982201f, 0.12434763f, -0.07404950f, -0.33245084f, -0.11510348f, 0.09891353f, 
    -0.11317784f, -0.09520546f, 0.03823123f, -0.01027811f, -0.06355197f, -0.00648592f, -0.18753490f, -0.08058181f, 
    -0.17921253f, -0.28211993f, -0.16192803f, -0.01421996f, -0.14157055f, 0.02125659f, 0.03178596f, -0.04309777f, 
    0.00065937f, -0.04669520f, -0.02958392f, -0.14478660f, 0.06402992f, 0.14295901f, 0.08668322f, -0.05180052f, 
    -0.13422216f, -0.20318767f, -0.07789265f, -0.05925410f, 0.08378737f, -0.22431530f, 0.00003048f, -0.00221173f, 
    0.12186242f, -0.09966768f, 0.21730065f, -0.22259562f, 0.03776010f, 0.09038281f, 0.04077768f, 0.07353786f, 
    -0.07355431f, 0.01128567f, 0.01361612f, -0.05930137f, -0.04471950f, 0.16907564f, 0.13063145f, -0.00724279f, 
    0.02474825f, 0.25012895f, -0.09166651f, 0.10337725f, 0.08512914f, 0.08578707f, 0.12542243f, 0.03322796f, 
    -0.14876264f, 0.16125840f, 0.18567829f, 0.34537235f, -0.06875728f, 0.14675389f, -0.09326366f, 0.08877521f, 
    -0.13028458f, 0.21772797f, -0.03844962f, -0.11303849f, 0.18417533f, 0.27351403f, 0.16409379f, 0.13542685f, 
    -0.07389080f, 0.12735415f, -0.10401740f, 0.07995289f, 0.12614687f, 0.10342460f, 0.02367996f, -0.10163050f, 
    -0.20887104f, -0.31095949f, 0.16157417f, 0.02365150f, 0.01898359f, -0.03581360f, 0.01566527f, -0.20887372f, 
    0.10537070f, 0.03049662f, 0.04089807f, 0.00129433f, 0.23378703f, -0.08843970f, -0.33940497f, 0.16162193f, 
    -0.12280300f, -0.08009081f, -0.24360004f, 0.03274334f, -0.00192939f, -0.10121679f, -0.20623176f, 0.07083209f, 
    -0.18761127f, -0.04067105f, -0.02030717f, -0.14006239f, -0.09255277f, 0.07489041f, -0.13630022f, 0.15843584f, 
    0.01894146f, 0.05282812f, -0.09882303f, 0.04245710f, -0.08170816f, -0.03974918f, 0.06874894f, -0.12192766f, 
    -0.14727657f, 0.06904709f, -0.04029549f, -0.08984112f, -0.10092662f, 0.17189817f, 0.01841341f, -0.12818156f, 
    -0.28354171f, 0.06242556f, -0.09399457f, 0.44718891f, -0.03762820f, 0.16490698f, -0.04572846f, 0.00424492f, 
    0.09674928f, 0.14211248f, -0.01230764f, 0.10467725f, 0.08818480f, -0.05577720f, 0.02323357f, -0.02951546f, 
    0.14892836f, -0.05056699f, -0.05362066f, 0.04848589f, 0.02790365f, 0.00829962f, 0.01354109f, -0.01983480f, 
    -0.16752560f, -0.11845349f, -0.23172547f, 0.29103893f, 0.04346230f, 0.21895678f, -0.12907894f, -0.07815014f, 
    -0.11295787f, 0.11381773f, -0.10835724f, 0.00551674f, 0.11303967f, 0.26851791f, -0.15391064f, -0.17928801f, 
    0.02447795f, -0.13560981f, 0.08760810f, 0.28287357f, -0.05166018f, 0.02295635f, 0.02871840f, -0.01149236f, 
    0.19713402f, -0.00254213f, -0.09952084f, -0.08280873f, 0.09063045f, 0.09734362f, -0.04046370f, 0.00400638f, 
    -0.12929021f, -0.10276802f, 0.11560888f, -0.06247065f, -0.44395736f, 0.17869280f, 0.09611773f, -0.09646624f, 
    -0.02155694f, 0.08339915f, -0.02689869f, -0.17260361f, -0.08778485f, 0.05543509f, -0.05719117f, 0.18045737f, 
    0.02772810f, -0.24720183f, -0.09006664f, 0.03746543f, 0.13325047f, 0.11360749f, 0.00831748f, -0.09177589f, 
    0.16670713f, 0.06180031f, 0.16674533f, 0.31833124f, -0.52132761f, -0.31234854f, 0.52963656f, 0.11612325f, 
    -0.24670203f, 0.06173117f, 0.02557288f, -0.18927823f, 0.07546140f, -0.29005614f, 0.22698782f, -0.09353004f, 
    0.13390374f, -0.19705229f, 0.12789689f, 0.09226789f, 0.09067496f, 0.13115956f, -0.02293800f, 0.07525939f, 
    0.02968993f, 0.04423879f, -0.03972041f, 0.04329298f, 0.14202024f, 0.76534683f, -0.43070048f, -0.40747964f, 
    -0.11746588f, -0.04818096f, 0.13053349f, 0.00320509f, -0.10610650f, -0.06379928f, 0.15248057f, 0.10493382f, 
    0.95455581f, -0.22389960f, 0.10181741f, -0.07675231f, 0.07114482f, 0.01194530f, 0.01687210f, -0.08376147f, 
    0.07682875f, -0.03662898f, -0.05086846f, -0.03218471f, 0.23245925f, 0.02837583f, -0.08409633f, 0.15599771f, 
    0.13045235f, 0.09233205f, 0.03355083f, 0.10927162f, 0.08025784f, 0.20675845f, 0.04762264f, -0.16578674f, 
    0.17073569f, -0.07340362f, 0.35032395f, -0.06523698f, -0.07322051f, 0.00169293f, -0.19695354f, 0.03328178f, 
    0.04549245f, -0.04727631f, -0.05540523f, 0.14936937f, -0.13278668f, 0.38657960f, -0.07514153f, -0.13277090f, 
    -0.00638671f, 0.00595088f, -0.07844736f, -0.08170292f, 0.11445178f, 0.22907832f, 0.19989190f, 0.12387072f, 
    0.28179222f, 0.29400164f, 0.02953184f, -0.49766180f, -0.06387302f, 0.02227820f, 0.13327298f, -0.04185732f, 
    0.22953895f, 0.09734931f, 0.13040708f, 0.02792336f, -0.12026464f, -0.01252343f, 0.16637348f, -0.00532356f, 
    -0.00040721f, 0.02998316f, 0.13800032f, 0.02331082f, -0.17860688f, 0.06737614f, -0.04244330f, -0.05912871f, 
    0.08730111f, -0.14019883f, -0.36003205f, 0.06983384f, 0.11589412f, -0.02843476f, 0.20925394f, 0.02207652f, 
    0.03947498f, -0.05984491f, 0.00279983f, 0.04550217f, -0.02552169f, 0.40882039f, 0.09790317f, 0.11991856f, 
    -0.00219683f, -0.08986377f, 0.11881471f, -0.02469370f, 0.03456843f, -0.04544791f, 0.12732892f, 0.09631740f, 
    -0.33823252f, -0.00516671f, -0.11930580f, 0.35180089f, 0.08739538f, 0.12930579f, 0.13147247f, -0.04313062f, 
    -0.00691763f, 0.02495234f, -0.01681430f, 0.02364087f, -0.04578775f, -0.15964568f, -0.15508163f, 0.15419123f, 
    0.01370765f, 0.05715659f, -0.05132822f, -0.00631520f, -0.06062473f, -0.13177560f, -0.09131762f, -0.08724623f, 
    -0.38856718f, 0.59836477f, 0.23515938f, 0.52292132f, 0.08533823f, 0.05759549f, -0.06579798f, -0.07045386f, 
    -0.20954211f, 0.16691509f, -0.18998653f, 0.02298246f, -0.27915126f, 0.05717606f, -0.02921379f, -0.21745184f, 
    0.00756981f, -0.16660106f, -0.36216336f, -0.09057944f, -0.04056906f, -0.15009581f, -0.00505553f, 0.01131312f, 
    -0.44243914f, -0.15622804f, -0.26003140f, -0.12536874f, -0.19384566f, -0.44611329f, -0.27612644f, -0.05408066f, 
    -0.26001254f, 0.02650104f, 0.02444579f, -0.23069018f, -0.39026719f, 0.54783100f, 0.01154247f, -0.20315221f, 
    0.10731801f, 0.13701220f, 0.08046253f, -0.16407269f, 0.03379646f, 0.01902276f, 0.09397895f, 0.05411915f, 
    -0.20788977f, -0.03126909f, 0.23624741f, 0.15093914f, -0.06534769f, -0.10564906f, -0.21663073f, -0.14503258f, 
    0.07638833f, -0.09401785f, 0.26463398f, 0.21081491f, -0.05375566f, 0.16730523f, 0.04428102f, 0.26255065f, 
    0.09814021f, 0.06995397f, 0.00277865f, 0.06874465f, 0.03416865f, 0.12816699f, -0.03743047f, -0.01346570f, 
    0.45512706f, 0.02904860f, -0.20941506f, -0.04499739f, 0.26194710f, 0.19356453f, 0.13453142f, 0.16695002f, 
    -0.12079652f, 0.04189207f, -0.05907590f, 0.09511323f, -0.03336341f, -0.24398136f, -0.16654967f, -0.05376288f, 
    0.23007029f, 0.10592167f, 0.01741133f, 0.04397009f, -0.02348842f, -0.06980341f, -0.09189978f, -0.07557306f, 
    -0.40208670f, 0.12402222f, 0.08117748f, 0.26110476f, 0.11446316f, 0.14563961f, -0.13962576f, 0.25454602f, 
    -0.05688737f, -0.09245110f, 0.05035643f, 0.18966925f, -0.13528836f, -0.04712952f, 0.50120932f, -0.07443375f, 
    -0.23540449f, -0.02670129f, 0.06532536f, 0.02050578f, 0.09176030f, 0.20163098f, 0.00334441f, -0.21080816f, 
    -0.02531859f, -0.04136744f, 0.03949886f, -0.00456128f, 0.13197032f, -0.00407281f, -0.07559008f, 0.00882727f, 
    0.16889440f, 0.04977556f, 0.12391734f, -0.03213907f, -0.02893542f, -0.20452796f, 0.07323202f, 0.10833244f, 
    0.04388163f, -0.03851228f, 0.01473983f, 0.10480606f, 0.06400449f, 0.02550231f, -0.06779524f, 0.08037879f, 
    -0.04768007f, -0.07258058f, -0.30648986f, -0.17072162f, 0.05494488f, 0.21574497f, -0.15464047f, -0.00652958f, 
    0.16439603f, -0.13227841f, 0.01596416f, 0.08895292f, -0.24567060f, -0.02985766f, 0.21538420f, 0.13960969f, 
    -0.11233598f, -0.07995281f, -0.06009414f, 0.14322735f, 0.24804127f, -0.00858238f, 0.03479698f, 0.07907620f, 
    -0.04887012f, 0.09331460f, 0.17811428f, -0.01089121f, -0.05784762f, 0.00110402f, 0.01576427f, 0.00976360f, 
    -0.01811745f, 0.04301164f, 0.06380755f, -0.12087270f, -0.02771600f, 0.14853877f, -0.30212855f, 0.22239159f, 
    -0.09118205f, -0.03577779f, -0.20717578f, 0.03455966f, -0.12121133f, 0.15087381f, -0.21187979f, -0.07496356f, 
    0.23355033f, -0.11155529f, 0.29143587f, 0.39662841f, 0.13619670f, -0.07282922f, -0.03150713f, 0.02692516f, 
    0.12983742f, -0.03961716f, 0.16690865f, 0.17194822f, 0.05226561f, -0.32261142f, -0.08567358f, -0.17161626f, 
    0.05220959f, 0.01703913f, 0.05317593f, -0.02513084f, 0.14870146f, 0.02822896f, -0.08061732f, -0.00334736f, 
    0.09234674f, -0.12750468f, -0.19481540f, -0.03143766f, 0.01675111f, 0.22530863f, -0.05103092f, -0.08575313f, 
    -0.00029082f, -0.22276926f, -0.03103800f, -0.05144330f, -0.30282858f, 0.30919689f, 0.03350165f, 0.24491322f, 
    0.01283484f, 0.14524615f, -0.25385907f, -0.04542363f, -0.10385904f, -0.06829237f, 0.09416327f, -0.27190998f, 
    0.16819333f, 0.13277142f, 0.31579933f, 0.28290293f, -0.04258234f, -0.03013486f, -0.16478801f, 0.02766015f, 
    -0.01609310f, -0.03346139f, -0.19786179f, -0.01216260f, 0.11005082f, 0.11313216f, 0.02572232f, 0.03155871f, 
    -0.09937136f, -0.01508852f, 0.05412335f, 0.09251632f, -0.13596125f, 0.02133991f, -0.06392504f, -0.04095931f, 
    0.34535673f, -0.19746169f, 0.24300142f, 0.29505783f, -0.04948599f, -0.07106320f, -0.00941364f, -0.15094548f, 
    0.13558467f, 0.05386362f, -0.04800927f, 0.02516948f, 0.23494640f, 0.23553047f, -0.33635709f, 0.00280035f, 
    0.17070745f, -0.10450303f, -0.04052740f, -0.11388459f, 0.22586824f, -0.00255005f, 0.08207569f, -0.05991670f, 
    0.20673250f, 0.18375956f, 0.15029623f, 0.30941656f, 0.17448716f, 0.10106561f, 0.03079521f, 0.20171779f, 
    -0.02718352f, -0.07017915f, -0.00941790f, -0.06779280f, 0.04361342f, -0.21285918f, 0.17934133f, 0.04509969f, 
    -0.06563862f, 0.11806151f, 0.05700018f, 0.06103941f, -0.04165970f, -0.09325094f, -0.14434063f, 0.07324067f, 
    -0.00517893f, 0.06095665f, 0.05741971f, -0.00380513f, 0.08645846f, -0.05902292f, 0.00036735f, -0.11935864f, 
    0.02888863f, -0.00102776f, -0.04522127f, 0.01225427f, -0.36739656f, -0.05817769f, 0.33037817f, -0.15400289f, 
    -0.08609843f, -0.00706472f, -0.03400346f, 0.08220819f, -0.03213871f, 0.04603591f, 0.06668350f, 0.08338297f, 
    -0.05250980f, 0.24529529f, -0.11504117f, -0.03264863f, 0.10498287f, -0.07962061f, 0.20874099f, -0.04455799f, 
    0.07039892f, -0.05019338f, -0.14531650f, 0.05391968f, 0.23991695f, 0.10836485f, 0.41382349f, 0.19889562f, 
    -0.09439607f, -0.07005458f, 0.12526903f, 0.26276144f, -0.07219040f, -0.08058444f, 0.02880587f, -0.11264110f, 
    -0.21501306f, -0.01166919f, 0.12686278f, -0.26304203f, 0.03567202f, -0.01536788f, 0.00024477f, -0.09304100f, 
    -0.05436372f, -0.02073643f, 0.07735806f, 0.00282238f, 0.06473827f, 0.20824683f, 0.18371619f, 0.15960534f, 
    0.04715938f, -0.01467155f, 0.02575421f, 0.23010889f, 0.02270772f, 0.15537316f, 0.16769461f, 0.07289185f, 
    -0.02791011f, 0.15056476f, -0.17336152f, -0.15842476f, 0.05969686f, -0.05836327f, -0.07073078f, 0.19356009f, 
    -0.00398647f, 0.01483632f, 0.09723816f, 0.00179359f, -0.34404022f, -0.40000725f, 0.07173537f, 0.17851758f, 
    0.09179255f, -0.19567680f, -0.09034444f, -0.21059081f, 0.24867976f, -0.04345390f, -0.03418479f, 0.05579814f, 
    -0.15474078f, 0.03623113f, -0.02495685f, 0.03035614f, 0.03983791f, -0.22474921f, 0.00788074f, 0.22170304f, 
    0.09240483f, -0.04910704f, 0.01224957f, -0.16984926f, -0.11694022f, -0.07593603f, 0.38978058f, -0.39692837f, 
    -0.06913950f, 0.07697557f, -0.19766288f, -0.01103721f, 0.09347211f, -0.17893669f, -0.13209902f, -0.06601366f, 
    -0.13186784f, 0.04788596f, -0.08240990f, -0.25424412f, -0.11075875f, -0.01663428f, -0.08883274f, -0.12496004f, 
    -0.03838680f, -0.07687867f, -0.19894797f, 0.12147593f, 0.05854798f, -0.07651357f, 0.40255913f, -0.01586144f, 
    0.28410521f, 0.10793853f, 0.06682231f, 0.00405720f, -0.19211823f, 0.03360246f, 0.02716421f, -0.04206320f, 
    -0.44961095f, -0.01857687f, -0.01363633f, -0.07802840f, 0.08787738f, -0.06027755f, -0.11578885f, 0.14521253f, 
    0.06657533f, -0.00332733f, 0.04737787f, 0.22081248f, 0.07018217f, 0.13321717f, 0.11252294f, 0.15367918f, 
    0.03409547f, 0.18529269f, 0.06285186f, 0.15370938f, 0.09522249f, -0.03918987f, -0.01182713f, -0.01549499f, 
    -0.36008996f, 0.14389014f, -0.30113313f, 0.30296344f, 0.08591601f, -0.13742280f, -0.08347718f, 0.15488862f, 
    0.16464593f, -0.01751797f, 0.16786085f, 0.06994288f, -0.08113300f, 0.04970936f, -0.08872536f, 0.22206911f, 
    0.05726289f, 0.05211083f, -0.13480571f, -0.12170570f, 0.26940256f, -0.01768399f, -0.16320291f, -0.11159147f, 
    -0.08320726f, -0.05007498f, -0.20371653f, -0.04644286f, -0.11866438f, -0.03166288f, -0.01425316f, -0.06601184f, 
    -0.08040012f, 0.01739290f, -0.19863562f, -0.09824392f, -0.04633954f, 0.01780312f, -0.11265925f, -0.25787392f, 
    -0.04546311f, -0.07254728f, -0.05764430f, -0.07019024f, -0.02210467f, 0.00458922f, 0.04575588f, -0.06617138f, 
    -0.07218835f, 0.13612439f, 0.05871550f, 0.22729340f, 0.03649859f, 0.08223508f, 0.04866328f, -0.12729712f, 
    -0.03498286f, 0.03607196f, -0.04075051f, -0.04752673f, -0.20195776f, -0.27162015f, -0.03120285f, 0.05468651f, 
    0.03298888f, -0.11081661f, -0.03183845f, 0.17563775f, 0.01221270f, 0.10405611f, 0.15121073f, 0.21675806f, 
    -0.30166262f, -0.08945936f, 0.06636328f, 0.43318796f, -0.00721611f, 0.02422533f, 0.16995731f, 0.01483383f, 
    0.01938943f, -0.01977290f, -0.06132229f, 0.14447339f, 0.13370499f, -0.04998572f, 0.07602273f, -0.18244004f, 
    -0.09866887f, -0.02451978f, -0.05578920f, 0.03896314f, 0.12835918f, 0.17943272f, -0.05022440f, -0.03073674f, 
    -0.14285034f, -0.19624576f, -0.28494790f, -0.01714846f, 0.01659089f, 0.01484976f, -0.03209595f, 0.02606108f, 
    -0.06713897f, 0.02029491f, -0.06916038f, -0.00905297f, -0.35431227f, 0.23472506f, 0.18990999f, 0.10206952f, 
    0.03709206f, 0.10184249f, 0.16745290f, -0.14358401f, -0.04280127f, 0.04916210f, 0.01957990f, 0.11251445f, 
    0.07674026f, -0.04440844f, -0.05730823f, 0.10527354f, 0.02660479f, -0.06212109f, 0.07951114f, -0.01417783f, 
    -0.03866363f, 0.07081165f, -0.00083430f, 0.15956338f, -0.29008302f, 0.09478970f, 0.00434582f, 0.29022536f, 
    -0.09291689f, -0.02436124f, 0.07429041f, 0.13897493f, -0.04795982f, 0.12321992f, 0.08418545f, -0.10001633f, 
    -0.13298762f, -0.01727773f, -0.12489966f, 0.32894641f, 0.03462854f, 0.18765318f, 0.19870026f, 0.09986407f, 
    0.15545310f, 0.18554057f, 0.10014578f, 0.14886847f, -0.25388455f, 0.45797756f, -0.12036414f, -0.34093451f, 
    0.02159001f, -0.00617989f, -0.08049590f, -0.11642007f, 0.08682936f, -0.12121531f, -0.10518780f, 0.06285989f, 
    0.10358712f, -0.07736708f, -0.42566290f, 0.18380772f, 0.22782682f, 0.07543885f, 0.02234158f, -0.21729083f, 
    -0.00534873f, 0.10409824f, -0.00003060f, -0.01954233f, 0.51082391f, 0.07928012f, 0.19257697f, 0.15741277f, 
    -0.13584681f, -0.15132189f, 0.10603262f, 0.03837658f, 0.00158471f, 0.07925420f, 0.07397002f, 0.00854492f, 
    -0.10601730f, -0.26304737f, 0.07170844f, 0.30059245f, 0.19528018f, -0.01508320f, 0.13106029f, -0.11753926f, 
    0.00051102f, -0.02098231f, -0.06135503f, -0.10996137f, -0.18062522f, 0.22840668f, 0.13899001f, -0.19375513f, 
    -0.08394776f, -0.14058374f, -0.10755072f, -0.05173827f, 0.08620045f, 0.01562469f, -0.01236578f, -0.06928533f, 
    0.18786950f, 0.13451004f, -0.11562505f, -0.37445745f, 0.04841240f, -0.06373890f, -0.01626647f, -0.05897158f, 
    0.10562447f, 0.11040076f, -0.01457972f, 0.04864395f, -0.32062373f, -0.29699633f, 0.15445282f, 0.48030129f, 
    0.12355520f, -0.04581083f, 0.08019943f, -0.11435530f, -0.03739776f, -0.01192122f, 0.01859973f, 0.04691318f, 
    -0.01437213f, -0.17421107f, -0.02518432f, 0.30894616f, 0.03906652f, -0.16494308f, -0.07946135f, 0.23087144f, 
    0.03632843f, 0.02180761f, -0.05971412f, 0.03065428f, -0.13796033f, -0.00323777f, -0.04646007f, 0.38679022f, 
    -0.10472874f, 0.19205119f, -0.04429127f, -0.17370726f, -0.03284024f, -0.06420963f, -0.10328712f, -0.07531086f, 
    -0.23211455f, -0.06243168f, 0.33505207f, 0.30469018f, 0.06327305f, -0.08035856f, 0.10298810f, 0.00781093f, 
    -0.05230832f, -0.12248082f, 0.03503082f, -0.03556801f, -0.21236444f, -0.17093258f, -0.09965188f, 0.27772814f, 
    0.05684093f, 0.02731647f, 0.00820654f, 0.01930524f, 0.09118073f, -0.05798734f, 0.00002498f, -0.00452967f, 
    -0.31304720f, 0.03192255f, 0.18467231f, 0.30189508f, 0.11820659f, -0.01036781f, 0.18568595f, 0.00826045f, 
    -0.07643584f, -0.12143657f, -0.00382573f, -0.04281382f, -0.00172285f, 0.13426733f, 0.02661119f, -0.16221483f, 
    -0.08528209f, -0.01597299f, -0.00471529f, -0.09300897f, -0.05018579f, 0.08830792f, -0.03949909f, -0.08224400f, 
    -0.09026839f, -0.00489026f, -0.03447342f, -0.18582441f, 0.00254681f, 0.07137703f, -0.04312210f, -0.09130949f, 
    0.08397336f, 0.04800142f, -0.02961999f, -0.02599032f, -0.25060600f, 0.32919440f, 0.19172406f, -0.04876325f, 
    0.05265633f, 0.06540255f, -0.03130447f, -0.01789509f, -0.01636865f, -0.08828663f, 0.04601776f, 0.13787918f, 
    -0.01068971f, 0.07743768f, 0.10652876f, 0.09655986f, 0.04700433f, -0.00476884f, 0.06088993f, -0.05906290f, 
    -0.01806384f, 0.05709317f, 0.27014416f, -0.03626963f, -0.04837693f, 0.18631823f, 0.20362200f, 0.32582864f, 
    -0.16208978f, 0.18207371f, -0.05281027f, 0.16917852f, 0.02941401f, 0.10055959f, 0.04049261f, 0.05038879f, 
    -0.08404627f, 0.04940091f, 0.30223083f, 0.00905109f, 0.02600775f, -0.10591118f, 0.00528249f, -0.04763096f, 
    -0.07293592f, 0.03880420f, 0.01129776f, -0.07110091f, -0.15756777f, -0.15648913f, 0.10291443f, 0.25909653f, 
    -0.02982298f, -0.01373238f, 0.01921133f, 0.10709249f, 0.09050412f, 0.11818968f, -0.03946389f, -0.02026589f, 
    0.14609163f, 0.05958747f, 0.21630946f, -0.00907730f, -0.04756363f, -0.02962098f, 0.08459190f, -0.00552206f, 
    0.01201402f, 0.03696126f, 0.00188698f, -0.11499655f, 0.22868575f, -0.00070611f, 0.11198668f, -0.11303561f, 
    -0.12034217f, -0.10214036f, 0.11667467f, -0.12342267f, -0.10720699f, -0.04662316f, -0.06033425f, -0.03259226f, 
    0.00860702f, 0.01152439f, -0.10488639f, 0.07324151f, 0.03228033f, 0.05497520f, 0.00122869f, 0.00550592f, 
    -0.15076913f, -0.05035988f, 0.01519953f, -0.00466902f, -0.03041438f, 0.03395849f, -0.02844273f, -0.03096442f, 
    0.07209577f, -0.01773759f, 0.04259360f, 0.01046802f, -0.18171270f, -0.10833898f, -0.00565187f, 0.20279469f, 
    -0.12753895f, -0.18274401f, -0.00641426f, -0.04315402f, 0.03638805f, 0.07397520f, 0.06376045f, 0.01320439f, 
    0.02147262f, -0.09956922f, -0.08954394f, 0.01625825f, -0.01284709f, 0.04565496f, 0.05235885f, -0.02929037f, 
    -0.12558964f, -0.04698710f, -0.04899158f, 0.01805101f, 0.01307947f, -0.01567702f, -0.00660976f, -0.10723429f, 
    0.22469094f, 0.16011573f, 0.13625307f, 0.00863915f, 0.01221115f, -0.11855508f, -0.04403266f, -0.02432291f, 
    0.01629326f, -0.02624495f, 0.03735587f, 0.00026415f, -0.07140240f, -0.12592106f, 0.13128266f, 0.02365891f, 
    -0.16454861f, 0.10707837f, -0.13305925f, 0.18730266f, -0.14553306f, -0.02233104f, -0.17818274f, -0.23776275f, 
    0.17082499f, 0.10817924f, 0.15811005f, 0.10470181f, -0.04498435f, -0.07505439f, -0.00072654f, -0.12919073f, 
    0.08804923f, 0.06413832f, -0.14524119f, 0.21547535f, 0.07267362f, -0.07836993f, -0.00625955f, 0.06382205f, 
    0.07065157f, -0.09903090f, 0.13816915f, 0.10019457f, 0.13596976f, 0.08626501f, -0.10986927f, -0.27329648f, 
    0.15073645f, -0.07205859f, -0.11469865f, 0.02847775f, -0.03692188f, 0.00642556f, -0.07537622f, 0.02097554f, 
    0.01224639f, -0.12547410f, -0.02280060f, 0.01431513f, -0.11805462f, 0.60585314f, -0.18999355f, 0.25049579f, 
    0.13981307f, -0.05568727f, -0.09772798f, 0.03566372f, -0.03382823f, 0.13724627f, -0.16871567f, -0.02786485f, 
    0.14979851f, 0.24343726f, -0.06290783f, -0.00992004f, 0.04761922f, 0.11638744f, 0.07972207f, -0.06083835f, 
    -0.13014056f, -0.06020825f, 0.01907923f, 0.03200358f, 0.25756514f, -0.78125918f, 0.00617711f, 0.17349061f, 
    0.01036772f, 0.07786686f, -0.00612344f, 0.01480140f, 0.03973798f, -0.14301015f, 0.05265254f, -0.05452632f, 
    -0.08008870f, 0.19251476f, 0.01015037f, 0.10061791f, -0.03723621f, 0.06085182f, -0.04863929f, -0.17351213f, 
    0.16310470f, -0.05734328f, -0.03870982f, 0.13319623f, 0.15405415f, 0.30165952f, 0.06030386f, -0.08138885f, 
    0.03855881f, 0.13110797f, -0.11973311f, -0.16669600f, 0.21992819f, -0.09789903f, 0.02890618f, -0.05025414f, 
    -0.00030874f, 0.07218569f, -0.28641400f, 0.08349311f, 0.08318643f, 0.02400280f, 0.10318812f, 0.04162388f, 
    0.00215997f, -0.07799727f, 0.06563879f, -0.07604600f, 0.06920432f, -0.57199109f, 0.09049749f, 0.15898997f, 
    0.01198547f, 0.08810291f, 0.04442564f, 0.10778549f, 0.00624416f, -0.07140682f, 0.00428080f, -0.13780396f, 
    -0.04964665f, -0.04198195f, 0.06563690f, 0.30244741f, -0.06027623f, -0.07176145f, 0.04388615f, -0.00211245f, 
    -0.12190282f, -0.12252681f, 0.05677171f, 0.10933766f, -0.01414882f, -0.14485697f, -0.13955534f, 0.04896494f, 
    -0.16128823f, -0.05267053f, -0.15125735f, -0.00937323f, 0.00397544f, -0.02878410f, 0.11686989f, 0.00637087f, 
    0.11361909f, 0.10372503f, 0.03097172f, 0.01595213f, -0.13422449f, 0.05879226f, -0.08581226f, 0.07249676f, 
    -0.00654462f, -0.00612382f, -0.11376872f, 0.06613658f, 0.32771635f, -0.33152595f, 0.14900525f, -0.05723078f, 
    -0.01105275f, 0.19425669f, 0.06876766f, 0.43554753f, 0.04759198f, -0.00917443f, 0.00016571f, -0.03634601f, 
    0.10411835f, -0.05542916f, 0.24571486f, -0.05144894f, -0.11508619f, -0.10105092f, -0.15526877f, 0.23147750f, 
    -0.02663977f, -0.14378308f, -0.15988711f, 0.02498112f, 0.12344489f, 0.22266059f, 0.08710540f, -0.06873972f, 
    0.08998597f, 0.11247537f, 0.00531071f, 0.03244227f, 0.03406779f, 0.04329782f, 0.14532802f, -0.05095219f, 
    0.00720814f, -0.20190573f, 0.13342443f, -0.09712410f, 0.03303491f, -0.00552275f, 0.09603569f, 0.12904693f, 
    0.00469581f, 0.01636927f, 0.10511636f, -0.07724734f, -0.05323125f, -0.16952828f, 0.00466841f, -0.08168367f, 
    0.01223480f, 0.14478724f, 0.11009644f, 0.03972961f, 0.09569075f, 0.00817499f, -0.12096351f, 0.03805251f, 
    0.04250387f, 0.02196519f, 0.04387086f, -0.02718430f, 0.11794335f, 0.05126105f, 0.11924002f, 0.16573901f, 
    0.15220599f, -0.01786490f, -0.08305001f, 0.00054056f, -0.09174115f, -0.19441153f, 0.41308960f, -0.06452013f, 
    -0.01078010f, 0.03633045f, -0.02879395f, 0.09059264f, -0.01110096f, -0.13951200f, 0.00922197f, -0.16967170f, 
    -0.05286257f, -0.01735465f, 0.11478838f, -0.11627316f, -0.04274952f, 0.12495349f, 0.02428518f, 0.05113203f, 
    -0.01990354f, -0.06257728f, 0.10559835f, -0.03449675f, 0.27664381f, -0.16862711f, 0.10966685f, -0.22016883f, 
    0.09213664f, -0.04625167f, -0.06380369f, 0.15820818f, -0.10909322f, -0.10785733f, -0.00375772f, -0.07862024f, 
    -0.11947919f, 0.12387506f, 0.11377059f, -0.03155957f, -0.07365257f, -0.03989211f, 0.01366648f, 0.01304926f, 
    0.08963609f, 0.15280890f, 0.05634072f, -0.12491288f, 0.14546101f, 0.23877361f, 0.09846986f, 0.02961308f, 
    -0.21740921f, -0.06209421f, -0.03371080f, 0.02239325f, -0.02813031f, -0.02140479f, -0.03502798f, 0.02086998f, 
    -0.14082229f, -0.02043884f, -0.02710416f, 0.02357067f, 0.04387165f, -0.13660850f, 0.30340585f, -0.00999074f, 
    0.16663338f, 0.09061248f, 0.06986123f, 0.03774629f, -0.17900102f, 0.01924011f, -0.33469227f, 0.18557517f, 
    0.04414400f, 0.00464391f, 0.05040791f, -0.07790589f, 0.04010049f, -0.01109843f, -0.23018007f, 0.19808309f, 
    0.02195146f, -0.37267998f, 0.03103499f, 0.24037568f, 0.15006222f, 0.25018534f, 0.10645901f, -0.12452738f, 
    0.12717655f, 0.09060477f, 0.02477065f, 0.23106837f, -0.16803423f, -0.27838740f, -0.19185902f, -0.01045570f, 
    -0.01317890f, 0.07453902f, 0.09607526f, 0.08924095f, 0.06592823f, 0.11107910f, 0.03930553f, 0.22307941f, 
    -0.36523405f, -0.34689963f, -0.34115237f, -0.04264360f, -0.05138850f, -0.02342070f, 0.01375829f, 0.01220656f, 
    0.03443392f, -0.06220017f, 0.01834559f, 0.05748360f, 0.23355956f, 0.04921459f, -0.00806853f, -0.23130754f, 
    0.06125763f, 0.19247876f, 0.22114111f, 0.14818831f, 0.12460143f, 0.11630653f, 0.00399203f, 0.17152511f, 
    0.42303517f, -0.06183973f, 0.14453436f, -0.11402128f, -0.01327173f, -0.00518350f, -0.01662823f, 0.14471836f, 
    -0.08330625f, 0.00807682f, 0.08243817f, -0.03727588f, -0.30628741f, -0.00253668f, -0.08705898f, -0.13294838f, 
    -0.25204971f, 0.12334830f, -0.12820259f, -0.12861162f, -0.27521530f, 0.01943095f, -0.40091965f, -0.35522023f, 
    0.28574952f, 0.14391650f, 0.32522869f, 0.18431152f, 0.19213721f, -0.07874765f, -0.04670024f, -0.04596602f, 
    0.11820065f, 0.14215274f, 0.03783272f, 0.13204283f, -0.03367940f, -0.52028555f, -0.04017745f, -0.06586821f, 
    -0.02662902f, 0.08229100f, -0.01221480f, 0.08888990f, 0.03025152f, -0.08385112f, -0.37639713f, -0.08447021f, 
    0.15114361f, -0.10642418f, -0.21409106f, -0.03801163f, 0.11328530f, 0.08553366f, -0.14110862f, -0.05145226f, 
    -0.17190444f, -0.28639650f, -0.01665884f, -0.27096084f, -0.10766540f, 0.52458531f, -0.31917092f, 0.57407176f, 
    -0.07210251f, 0.01183045f, 0.02145725f, 0.08119456f, -0.20463248f, 0.08938099f, -0.05567436f, 0.03741430f, 
    0.21734734f, 0.26398265f, -0.05344321f, 0.06982873f, 0.13870835f, 0.07873367f, 0.12316664f, -0.06899010f, 
    0.00462801f, -0.04516277f, -0.08812916f, 0.26090714f, -0.06357447f, -0.07770379f, 0.15070273f, 0.01095487f, 
    -0.07545706f, 0.05648458f, -0.13461602f, -0.08370459f, -0.23187090f, -0.17679150f, -0.08170746f, -0.05575933f, 
    0.32038042f, 0.21635330f, 0.29537642f, -0.30732486f, 0.15856238f, -0.14737840f, -0.15850927f, -0.12448451f, 
    0.04805345f, 0.05278601f, -0.15435566f, 0.11473342f, -0.04742201f, 0.18384399f, -0.33506820f, 0.00342986f, 
    -0.09673999f, 0.04159895f, 0.03718622f, -0.08885444f, 0.08973263f, -0.03540611f, -0.14598727f, -0.11395338f, 
    0.28196341f, 0.22981372f, -0.14931744f, 0.25574437f, 0.07594995f, 0.10291443f, 0.20928313f, 0.08442020f, 
    -0.06344875f, 0.03998913f, -0.11089463f, -0.32342750f, -0.14494611f, -0.41957849f, 0.12668508f, -0.01118177f, 
    -0.15714815f, 0.05981215f, 0.07684239f, -0.11591125f, -0.15842332f, -0.18828732f, -0.22165160f, 0.00382026f, 
    -0.20603482f, 0.17432077f, -0.00367669f, 0.05185903f, -0.14722413f, -0.02358784f, -0.10045799f, -0.23396878f, 
    0.06584907f, -0.00558254f, 0.02120819f, 0.12588423f, 0.13278653f, -0.00651826f, -0.24585107f, -0.06257967f, 
    -0.11062796f, 0.09278764f, 0.18668477f, 0.17788647f, 0.00536473f, 0.08211916f, 0.23355138f, 0.02975667f, 
    0.31874451f, 0.12301439f, -0.48960799f, 0.06048579f, 0.09879677f, 0.12972277f, -0.02475251f, 0.20889208f, 
    0.01555629f, -0.16236195f, -0.02274672f, -0.00994770f, 0.57555932f, -0.15881860f, 0.40787753f, 0.22821534f, 
    0.11937895f, 0.08780099f, 0.04132052f, 0.13895226f, 0.03181531f, 0.13008982f, -0.24938117f, -0.09349004f, 
    -0.10943414f, -0.16286889f, -0.21683061f, -0.08077013f, 0.08809704f, 0.10929313f, -0.11337327f, 0.14565609f, 
    -0.07189365f, 0.14168814f, -0.03326129f, -0.01846196f, 0.35222429f, 0.13045968f, 0.28120920f, 0.20583865f, 
    0.13609815f, 0.10573905f, -0.00338350f, 0.37412056f, 0.06202854f, 0.23503833f, 0.07988691f, 0.06874051f, 
    -0.05950952f, -0.19959718f, -0.01566398f, -0.16337520f, 0.24119914f, 0.10195465f, 0.03356991f, 0.24527819f, 
    -0.15349419f, 0.09845971f, -0.12261195f, -0.11867439f, -0.28352717f, -0.19183233f, -0.09846604f, 0.24563947f, 
    0.11366357f, 0.01064250f, 0.08775292f, -0.42944673f, -0.03122589f, 0.00773564f, 0.00321500f, -0.04240907f, 
    -0.06094447f, -0.18055929f, -0.00169704f, 0.22969136f, 0.15728137f, 0.10788677f, -0.07650411f, -0.06373671f, 
    0.08024459f, -0.04288488f, -0.16254622f, -0.18376307f, -0.24368615f, -0.07664392f, 0.14561412f, -0.08171678f, 
    -0.09727556f, -0.03372629f, -0.38222146f, -0.10448301f, -0.09276114f, 0.06102440f, -0.09421941f, -0.10487746f, 
    -0.22580907f, 0.00587256f, -0.20849994f, -0.24977858f, 0.01113464f, 0.01602885f, -0.00180221f, -0.05947658f, 
    -0.27436414f, -0.17150313f, -0.22006080f, -0.24096042f, 0.22164431f, -0.11586558f, 0.02550488f, -0.22705323f, 
    0.25323942f, -0.00479847f, 0.11626964f, -0.02963394f, -0.19496819f, 0.08252336f, -0.22136714f, -0.18925059f, 
    0.20515689f, 0.05201129f, -0.22047427f, -0.38247806f, 0.06432819f, 0.24344479f, -0.00612124f, 0.01402016f, 
    0.27251908f, 0.11071128f, 0.05520212f, 0.36739761f, 0.33289179f, 0.24458610f, -0.00779032f, -0.04824458f, 
    0.00312109f, 0.14560775f, 0.25547126f, 0.27149847f, 0.12139128f, 0.00203415f, 0.01761477f, 0.10024885f, 
    -0.24267907f, 0.04821973f, -0.17769894f, 0.33136553f, 0.05282566f, -0.03630465f, -0.01464283f, 0.10538526f, 
    -0.04101772f, -0.09952489f, 0.12966214f, -0.01730464f, -0.32632998f, -0.04890713f, -0.16376963f, 0.39742672f, 
    0.00724871f, 0.13351397f, 0.10236013f, -0.11200996f, 0.37297612f, -0.04483249f, -0.06324019f, 0.29821545f, 
    0.00916473f, 0.02463363f, 0.00525941f, -0.03093455f, -0.00446094f, 0.04501082f, 0.01950971f, -0.02196728f, 
    0.00699840f, 0.02185068f, 0.02009709f, -0.00274266f, -0.04600646f, 0.00631704f, -0.01745643f, -0.00762879f, 
    0.01698876f, -0.03452030f, -0.02859120f, -0.03630836f, -0.01735937f, -0.04890075f, -0.03980266f, 0.04059359f, 
    0.00295289f, -0.02266208f, -0.00741903f, -0.04264061f, 0.03624887f, 0.00962620f, -0.01606965f, 0.03528923f, 
    0.03662978f, -0.05495102f, -0.02217796f, -0.04679336f, -0.04932202f, 0.02120072f, -0.00875668f, 0.03824105f, 
    0.00916696f, -0.04816596f, 0.04467672f, -0.04798852f, -0.05503914f, -0.01909750f, -0.04806948f, -0.03675228f, 
    -0.03723468f, 0.02027333f, 0.03576363f, -0.01457924f, -0.03707521f, 0.02157583f, -0.04125326f, 0.03121075f, 
    -0.04732006f, -0.03820733f, -0.00080597f, -0.02186126f, -0.01030980f, 0.03864366f, 0.03891237f, -0.02561074f, 
    -0.00993270f, -0.04663006f, 0.00212716f, -0.03251513f, -0.00477740f, -0.05418189f, -0.05561230f, -0.03364468f, 
    -0.00382844f, 0.02546835f, -0.02583846f, -0.03631206f, 0.04261825f, 0.00954837f, -0.02668877f, 0.02817892f, 
    -0.04052585f, -0.01574926f, -0.05329060f, -0.02731993f, -0.03789639f, 0.04362169f, -0.03014797f, -0.03451921f, 
    -0.04972740f, -0.05617341f, -0.03275698f, -0.03438170f, -0.03647371f, 0.04096193f, -0.02447047f, 0.04127815f, 
    -0.01952709f, -0.03763046f, 0.03712396f, 0.02334192f, -0.00429571f, 0.04248043f, -0.00217714f, 0.01578144f, 
    0.01711109f, -0.00354065f, 0.04156258f, -0.04154159f, 0.00529227f, 0.01618356f, 0.02694733f, -0.05036655f, 
    -0.05574724f, -0.00873891f, 0.02525181f, -0.03827113f, 0.01566404f, 0.00213647f, 0.00372698f, -0.00652265f, 
    -0.01529786f, 0.01183570f, -0.05606157f, -0.02015109f, -0.05150932f, -0.00598742f, -0.03712568f, 0.01882838f, 
    0.02817773f, 0.01650075f, 0.01609813f, -0.01433781f, -0.00681240f, -0.00698502f, -0.01422422f, -0.04892726f, 
    -0.03659574f, 0.00656714f, -0.03545323f, -0.04413576f, -0.00760274f, -0.01140138f, 0.04000963f, -0.03585598f, 
    0.01349809f, -0.02121429f, 0.01979608f, -0.04049469f, -0.00268308f, 0.03215817f, -0.01065083f, -0.04740983f, 
    -0.02024696f, 0.01729639f, -0.00776432f, -0.04491776f, -0.01112973f, -0.04565142f, 0.03021759f, -0.01827866f, 
    -0.00422724f, -0.03239852f, -0.01452176f, -0.02911902f, 0.01111806f, -0.02229836f, -0.05419815f, 0.01842160f, 
    -0.03760419f, -0.01871952f, 0.00841929f, -0.04993296f, 0.04432644f, 0.00451194f, 0.02324807f, -0.02498696f, 
    0.02160222f, 0.02010872f, -0.05449241f, 0.02546705f, -0.01169994f, 0.04628317f, 0.02536053f, 0.01896946f, 
    0.02787200f, -0.04676770f, -0.03003902f, -0.05541985f, -0.03277338f, 0.00711539f, 0.00839920f, 0.01265166f, 
    -0.00652347f, -0.02425645f, -0.02337856f, -0.02979791f, -0.01200474f, -0.00568030f, -0.01153658f, -0.03048154f, 
    -0.04352333f, -0.03170716f, -0.04940337f, 0.03643994f, -0.03296952f, -0.03655274f, -0.00078537f, 0.02962729f, 
    -0.01472257f, 0.00372940f, -0.01850084f, -0.01866965f, 0.01874570f, -0.01519410f, 0.01718273f, -0.00963562f, 
    0.00392674f, 0.02434909f, -0.03296153f, 0.02556946f, 0.00647113f, 0.01247571f, 0.00851370f, 0.02211411f, 
    -0.04032099f, 0.01647746f, 0.01598834f, -0.03812166f, 0.04489647f, -0.00536624f, 0.01049377f, -0.00720903f, 
    -0.00922227f, -0.01645396f, 0.01465395f, -0.03550585f, -0.00353840f, 0.01640055f, 0.04117621f, -0.04162662f, 
    -0.01327015f, -0.00902585f, 0.00441728f, -0.05560973f, -0.04242443f, -0.00050488f, -0.05290739f, 0.00182077f, 
    0.04023999f, 0.03709999f, 0.03435087f, -0.01740863f, 0.03827332f, -0.01744763f, 0.04163758f, -0.05604735f, 
    -0.02897068f, 0.01100795f, -0.01579054f, -0.05351612f, 0.03740214f, -0.00777977f, -0.01010674f, 0.03235779f, 
    -0.00770639f, -0.01369542f, 0.00096780f, -0.00188586f, -0.04313372f, -0.00229577f, 0.04288602f, -0.00524406f, 
    -0.02061230f, 0.01696208f, 0.02694047f, -0.03922842f, 0.01848776f, 0.02889390f, 0.01322567f, 0.00413524f, 
    0.02435543f, -0.03887200f, 0.00902094f, -0.02034292f, -0.05018387f, -0.04022012f, 0.00953388f, -0.04926254f, 
    0.00195580f, 0.03274473f, -0.00366091f, -0.03013056f, -0.00980156f, -0.02353095f, -0.04205474f, 0.02169968f, 
    0.04306931f, -0.00812675f, -0.00016304f, 0.04901492f, -0.00360712f, 0.01309379f, -0.03349263f, 0.01107137f, 
    0.03728589f, -0.01465614f, 0.04186058f, 0.03317484f, -0.04012914f, -0.00208499f, -0.01800905f, 0.01943997f, 
    -0.01366580f, 0.02021888f, -0.03716899f, 0.00314716f, -0.03055100f, -0.04303069f, 0.03594707f, 0.01749634f, 
    -0.01985401f, -0.01465434f, -0.04687640f, 0.02298163f, -0.01538912f, 0.01168829f, 0.01734994f, -0.03026455f, 
    -0.00308609f, 0.02230495f, 0.02791118f, 0.01227321f, 0.00194461f, -0.01501725f, 0.02386893f, 0.00189528f, 
    0.02751304f, -0.05406569f, -0.04426417f, -0.02620378f, -0.05454068f, 0.04272994f, -0.05042095f, 0.03966798f, 
    -0.01363171f, -0.03463133f, -0.05533483f, 0.00235859f, 0.01426376f, 0.00133896f, -0.00878303f, -0.00956255f, 
    -0.02674944f, -0.03572446f, -0.01641488f, -0.03371899f, -0.00561173f, -0.00622450f, -0.03341547f, -0.05448559f, 
    0.00019148f, 0.01961458f, 0.01716718f, -0.03611651f, 0.03105006f, -0.05208177f, -0.02425102f, -0.01262167f, 
    -0.02467798f, 0.02197983f, 0.00740128f, 0.03642700f, -0.00397575f, 0.02580132f, 0.01493122f, -0.00887826f, 
    -0.03013311f, -0.03649818f, 0.01174348f, 0.03044132f, 0.00471044f, 0.00160509f, 0.02775040f, -0.00283065f, 
    0.03323405f, -0.00029480f, -0.03560580f, -0.08385322f, 0.04527102f, -0.07915528f, 0.01473429f, -0.05372179f, 
    0.12595862f, -0.03142866f, 0.01073600f, -0.25725418f, -0.02778537f, -0.03801175f, -0.04598667f, -0.01162549f, 
    -0.02005950f, -0.03248014f, 0.08241780f, -0.01319091f, 0.00793303f, -0.03040818f, 0.02301123f, -0.11108364f, 
    -0.01745773f, 0.01114617f, 0.04493945f, -0.02360621f, -0.14022550f, 0.16857079f, 0.08963735f, 0.04334806f, 
    0.11665823f, 0.17747808f, 0.13419332f, 0.16370465f, -0.11399011f, 0.02218285f, 0.32516205f, 0.14978848f, 
    0.04803122f, -0.14532541f, -0.01823501f, 0.11153215f, 0.18755729f, 0.05042531f, -0.00095563f, -0.10331716f, 
    -0.15754674f, 0.05484676f, 0.03142215f, 0.07279706f, -0.23464963f, -0.19708306f, 0.06477068f, -0.00806100f, 
    -0.19452447f, 0.03077265f, 0.06011414f, 0.02613456f, -0.10274991f, -0.01433963f, -0.00985837f, -0.04018717f, 
    -0.03703769f, 0.12125256f, -0.10591109f, 0.20356177f, 0.00089158f, 0.07715150f, -0.07609086f, 0.00542866f, 
    0.08230466f, -0.13979727f, 0.10383504f, 0.29384089f, 0.01104814f, -0.14815010f, 0.03187685f, -0.03209031f, 
    0.06316619f, -0.05166346f, 0.15603015f, 0.08968914f, 0.06938198f, -0.15241705f, -0.02029609f, 0.04649680f, 
    -0.07132826f, 0.03047933f, 0.05122661f, 0.05404687f, 0.04252019f, 0.06024585f, 0.10158057f, -0.15488620f, 
    -0.11343411f, -0.09935412f, -0.10350684f, -0.05341530f, 0.00234858f, 0.08521132f, -0.00221318f, 0.06483961f, 
    0.04717503f, -0.06992099f, 0.05090571f, 0.01428162f, 0.23001096f, 0.01371820f, 0.38481113f, -0.23876572f, 
    0.10905678f, 0.00718903f, 0.03375107f, 0.04425715f, 0.04822307f, -0.08373333f, 0.03893435f, -0.08131865f, 
    -0.05555316f, -0.10440804f, 0.21930823f, 0.00679217f, 0.03285868f, -0.02197610f, -0.02471935f, -0.03010168f, 
    0.15129057f, 0.11904446f, 0.01512291f, 0.01607418f, -0.14523812f, 0.13595505f, -0.17690273f, 0.05780662f, 
    -0.05297244f, -0.03585384f, -0.01406663f, 0.00227983f, -0.01358113f, 0.01800796f, 0.08356745f, 0.01915393f, 
    0.32270649f, -0.24759983f, -0.02015942f, 0.39176661f, -0.04223962f, 0.00619122f, 0.07220817f, -0.02405679f, 
    0.20583744f, 0.12753843f, 0.00624388f, 0.03352447f, -0.25346193f, 0.23982926f, 0.05971798f, -0.01498159f, 
    0.09421145f, -0.01244700f, -0.05729502f, 0.05140873f, 0.10911387f, 0.06979002f, 0.13613458f, -0.02790474f, 
    -0.12412452f, -0.10971574f, -0.07348433f, -0.06328109f, -0.05941400f, 0.02418510f, 0.05240142f, 0.05550891f, 
    0.07267265f, -0.03642574f, 0.02445971f, 0.08767577f, 0.03829179f, -0.29776523f, 0.03036431f, 0.11326916f, 
    -0.07147561f, 0.02142238f, 0.04562370f, -0.00831198f, 0.10067853f, 0.03027214f, 0.12567177f, 0.05014400f, 
    0.05221223f, 0.08382632f, 0.10789330f, 0.12163085f, 0.03992773f, 0.03464148f, -0.02871333f, -0.01140653f, 
    0.05117691f, 0.12525816f, 0.14115995f, 0.05813099f, -0.25513163f, -0.02516790f, 0.21133375f, 0.08122652f, 
    -0.22971772f, 0.07023168f, 0.08184174f, 0.12089464f, 0.06812095f, 0.07848066f, 0.05946013f, 0.00925075f, 
    -0.34669989f, 0.13851683f, 0.07942360f, -0.31878933f, 0.01536801f, -0.15277852f, 0.16820230f, 0.13971511f, 
    -0.01224719f, -0.06020799f, -0.03771862f, 0.02519219f, 0.12772924f, -0.07172935f, 0.08407912f, -0.23948886f, 
    -0.13417073f, 0.11360948f, 0.16618021f, 0.06099422f, -0.03651653f, -0.02489073f, 0.06532685f, -0.10999324f, 
    -0.02631179f, 0.08015858f, 0.37589532f, -0.15956125f, -0.23367199f, -0.07284106f, 0.09459679f, 0.23798139f, 
    -0.06864893f, 0.08522748f, 0.12148149f, 0.05212948f, -0.06277446f, 0.02735783f, 0.02869735f, 0.08796285f, 
    -0.07951356f, -0.06724718f, 0.22601296f, 0.08176771f, -0.00949269f, 0.10767985f, 0.03400960f, -0.01215470f, 
    -0.14436352f, 0.00217959f, -0.04412568f, -0.01420950f, -0.07122969f, 0.05024280f, 0.02548488f, 0.14210474f, 
    -0.01112000f, 0.05313001f, 0.00055843f, 0.07943184f, -0.04870727f, -0.07036012f, 0.03264078f, -0.14030793f, 
    -0.12031147f, 0.00698593f, -0.03788620f, 0.00729944f, 0.00604472f, -0.02920760f, -0.09760990f, 0.01577317f, 
    -0.09586618f, 0.02318803f, 0.03506278f, -0.19189319f, 0.00588402f, -0.17953502f, 0.07895229f, 0.15987352f, 
    -0.03041791f, -0.05055345f, 0.03602190f, -0.03321558f, -0.29328218f, -0.03328703f, 0.42525148f, -0.07326397f, 
    0.12877560f, -0.05943484f, -0.06506132f, 0.00243580f, 0.07568959f, 0.06677486f, -0.06440024f, 0.01118094f, 
    -0.10198558f, 0.07679336f, 0.02361711f, -0.05931777f, -0.00332845f, -0.05083422f, 0.00552916f, 0.07008547f, 
    0.04899830f, -0.02409772f, -0.04090636f, 0.29356402f, -0.15420999f, -0.09397423f, 0.08794439f, 0.01987221f, 
    0.44095859f, 0.05862144f, 0.07045622f, 0.06413425f, -0.01473764f, 0.04570011f, 0.00372496f, -0.04562491f, 
    -0.28479478f, 0.09304273f, -0.21956828f, -0.14822394f, 0.21746048f, -0.18913710f, -0.05356763f, 0.11066341f, 
    0.15443343f, -0.06052709f, 0.08906583f, 0.11611443f, -0.27287269f, -0.06575136f, 0.01381532f, -0.00937490f, 
    0.13351110f, 0.02147163f, -0.00134807f, -0.03032959f, 0.01710282f, -0.02754241f, -0.04893069f, 0.03889200f, 
    -0.05275973f, 0.21406747f, -0.18935943f, 0.10085317f, 0.04175005f, 0.02766985f, -0.00160953f, 0.30732572f, 
    0.10527708f, 0.02140006f, 0.00176283f, 0.05264907f, -0.14549066f, 0.03622532f, -0.00150211f, -0.13061695f, 
    0.01560566f, -0.03469690f, 0.05372766f, 0.04589077f, -0.14464737f, 0.08156154f, -0.06015387f, -0.18424717f, 
    -0.02111899f, 0.02922627f, -0.01153887f, 0.00560891f, -0.04932005f, 0.02080639f, -0.04377597f, 0.02617688f, 
    -0.00176736f, 0.03467363f, 0.03389744f, 0.00450515f, -0.00878225f, 0.04332034f, 0.00437812f, -0.03264200f, 
    -0.02330492f, -0.01354708f, 0.00497308f, 0.00837430f, 0.00325438f, 0.03605202f, 0.02936302f, 0.04047768f, 
    -0.02138201f, -0.05619469f, -0.02830895f, -0.01818478f, 0.03542425f, 0.01919711f, -0.00707946f, -0.03118450f, 
    0.03385244f, -0.05603015f, -0.05564035f, 0.02467081f, -0.01067010f, 0.02304582f, 0.00404247f, 0.03480445f, 
    -0.00604334f, 0.00422988f, 0.00606077f, 0.00694570f, 0.03602467f, -0.04498380f, -0.05001450f, -0.05218215f, 
    0.01642128f, -0.02903413f, -0.03455358f, -0.00465270f, -0.02345473f, 0.04039236f, -0.02837977f, 0.00661736f, 
    0.03869685f, -0.00212001f, -0.04993385f, 0.01948280f, -0.02037250f, 0.00606352f, -0.00149233f, -0.04864962f, 
    -0.05613860f, 0.03840503f, -0.01806689f, -0.02641944f, -0.05701073f, -0.00636380f, -0.04450417f, 0.02171514f, 
    -0.03757958f, -0.00416003f, -0.00251306f, -0.00331565f, -0.01716238f, -0.03356676f, -0.04841249f, -0.01820868f, 
    -0.00132487f, -0.05446626f, 0.01521249f, -0.03012446f, -0.00866454f, -0.05192400f, -0.02982515f, -0.01547529f, 
    -0.01813516f, 0.03797855f, 0.03415257f, 0.04198742f, -0.02720623f, -0.02903837f, 0.02005711f, -0.02282300f, 
    -0.02327876f, -0.01660067f, 0.01643035f, -0.00458537f, -0.03397821f, -0.02323916f, -0.02595050f, -0.02792790f, 
    -0.05804477f, 0.01448562f, -0.03645280f, 0.02027022f, -0.05562833f, -0.05556703f, -0.01998747f, 0.02112257f, 
    -0.03988706f, -0.02551339f, 0.03939472f, 0.03299223f, -0.02109631f, 0.03522012f, -0.00609603f, 0.00620899f, 
    0.00609108f, 0.03559929f, -0.01445633f, -0.03951303f, -0.01395920f, 0.00037949f, -0.00549164f, 0.02832173f, 
    -0.01015436f, -0.00293995f, -0.00071275f, -0.01455888f, 0.01279360f, -0.01148944f, -0.05527813f, -0.05202274f, 
    0.04177722f, -0.04971470f, -0.02199272f, -0.01233822f, 0.03744598f, 0.00725103f, 0.03809988f, 0.00354553f, 
    0.03086828f, -0.03979318f, 0.00879350f, -0.02657538f, 0.00008962f, 0.02710622f, -0.01246971f, -0.01262192f, 
    -0.04004049f, -0.04681600f, 0.04199221f, 0.03306040f, -0.00380272f, 0.00342617f, 0.01602411f, 0.02254126f, 
    -0.02837368f, 0.02607504f, -0.05072989f, 0.02297077f, 0.02997817f, -0.04386091f, -0.04479955f, 0.01394448f, 
    0.00282038f, -0.02138873f, -0.01069800f, 0.02280029f, 0.04218188f, 0.02383001f, 0.02014642f, 0.00687054f, 
    -0.05665825f, 0.03887405f, 0.02189347f, 0.00576072f, 0.03295323f, 0.02224411f, 0.03250054f, 0.00034883f, 
    -0.05665705f, -0.02892320f, 0.00725990f, 0.01765252f, 0.03303360f, -0.05494218f, 0.02392739f, -0.02209157f, 
    -0.05003753f, 0.01539957f, -0.00392419f, 0.00731879f, 0.02376720f, -0.00850304f, 0.01141897f, 0.04450171f, 
    0.00049398f, -0.01041549f, -0.04573659f, -0.03518583f, -0.02154102f, 0.00890756f, -0.04326548f, 0.01901924f, 
    -0.02963735f, 0.00147036f, -0.05005740f, -0.04669640f, 0.03274281f, -0.04041144f, -0.00109125f, -0.05007592f, 
    -0.00305854f, 0.01270389f, -0.00551891f, -0.02813224f, 0.02954126f, 0.03881739f, -0.04611164f, -0.01698842f, 
    -0.00502397f, -0.04212767f, -0.00340092f, -0.05371406f, -0.05451910f, -0.02249528f, -0.05532958f, -0.01329308f, 
    -0.05795085f, 0.03201303f, 0.02887358f, -0.02970470f, 0.00677438f, -0.02056888f, -0.00856807f, -0.05019791f, 
    0.02190740f, -0.02393941f, -0.05148662f, 0.01443123f, -0.03129295f, -0.02756928f, -0.03677148f, 0.03221774f, 
    0.00751628f, -0.02810582f, 0.03484397f, -0.00651715f, 0.02359840f, -0.04376306f, -0.00589721f, -0.03001411f, 
    -0.05454417f, -0.00304382f, 0.02064262f, -0.03459258f, -0.00297245f, -0.03794899f, -0.01345565f, 0.00878054f, 
    0.00905026f, -0.05615726f, -0.04020062f, 0.02731217f, 0.01060804f, 0.00157747f, -0.01215433f, 0.01936701f, 
    -0.00213729f, -0.05116654f, -0.02794785f, 0.00913011f, 0.04425980f, 0.01068523f, 0.00935448f, 0.02142015f, 
    -0.00207919f, 0.01244215f, -0.01397907f, 0.03583173f, -0.02741940f, -0.03549431f, -0.04775175f, -0.02242043f, 
    -0.02275709f, 0.00667612f, -0.04117980f, 0.03109430f, 0.00489235f, -0.02200077f, 0.03073222f, 0.03386832f, 
    -0.04026477f, -0.04691878f, -0.01556904f, -0.04014694f, 0.00989254f, -0.02554751f, 0.01665881f, -0.02059164f, 
    0.00540619f, -0.04041563f, -0.01158673f, -0.02173780f, 0.02578612f, 0.01986733f, -0.01135228f, 0.02986687f, 
    0.03384018f, -0.05503620f, -0.02677429f, -0.05723036f, 0.02983741f, -0.02449890f, -0.00555814f, -0.03646742f, 
    0.01574999f, 0.03714864f, 0.03961881f, -0.01060538f, -0.00589417f, -0.00802970f, -0.02461507f, 0.00553879f, 
    -0.03945113f, -0.04895057f, -0.01088232f, 0.01336189f, -0.04490262f, 0.02915408f, -0.01810085f, -0.00820813f, 
    0.00037627f, -0.01217898f, 0.00048430f, -0.01193033f, -0.00155493f, 0.02375499f, -0.01815910f, -0.05624522f, 
    0.00352582f, 0.03075536f, 0.04393898f, 0.05052785f, 0.04033373f, 0.00351322f, -0.04334738f, -0.02233874f, 
    0.01402364f, -0.01520215f, 0.03217250f, 0.02909149f, -0.01402496f, -0.00423804f, 0.02960795f, 0.00484409f, 
    -0.02437010f, 0.01057673f, -0.00157404f, -0.02626267f, -0.05397653f, 0.00238629f, 0.03801403f, -0.05575736f, 
    0.04002340f, -0.05570411f, 0.02467538f, 0.01292558f, 0.00704709f, -0.02692836f, 0.02404546f, -0.01980261f, 
    -0.03860847f, 0.01404739f, -0.03591308f, -0.02673084f, -0.05741832f, -0.02509322f, 0.00000138f, -0.02226741f, 
    -0.10279825f, -0.07157805f, -0.10135110f, -0.02972638f, 0.02413888f, -0.00828824f, -0.07398336f, 0.05318702f, 
    0.20555256f, 0.05277056f, 0.10513367f, -0.02403599f, -0.09134112f, -0.08018820f, -0.06910636f, -0.00135122f, 
    -0.08944891f, 0.00996383f, -0.00930697f, -0.01219747f, 0.06425947f, 0.18723695f, -0.07180149f, -0.01625053f, 
    -0.01021749f, -0.01632066f, -0.04208301f, 0.00380787f, -0.12496195f, -0.00558088f, -0.08046752f, 0.00446026f, 
    0.08254684f, 0.32050762f, 0.10781116f, 0.14888400f, 0.12427266f, 0.32906651f, 0.19923903f, 0.27802843f, 
    0.14502637f, 0.12654628f, 0.14777765f, -0.07662123f, 0.04953911f, 0.04521035f, -0.03550287f, -0.13093108f, 
    0.06149576f, 0.30151471f, 0.04233692f, -0.16841027f, -0.03405425f, 0.03614959f, 0.00440230f, 0.00397104f, 
    0.04433371f, 0.06497169f, -0.01465984f, 0.03656013f, -0.05188167f, -0.05792845f, 0.07617746f, -0.00662297f, 
    0.15069248f, 0.01632153f, 0.28834251f, 0.04209744f, 0.20920058f, -0.03418069f, 0.39597714f, -0.01426049f, 
    -0.32523409f, 0.34747258f, 0.05796846f, 0.06429964f, -0.00766813f, 0.08537134f, -0.00939142f, 0.03112778f, 
    0.02499956f, -0.01587344f, 0.16830125f, 0.03207874f, 0.12075602f, 0.09466502f, -0.10706004f, 0.01081874f, 
    0.08950307f, 0.03897974f, -0.04801343f, 0.12552254f, -0.08788505f, 0.02242373f, 0.02215888f, 0.14160386f, 
    -0.25468120f, 0.13412298f, 0.20161100f, 0.09437857f, 0.05705582f, 0.04645700f, 0.05522870f, 0.00136664f, 
    -0.12523144f, 0.00952642f, -0.09746411f, -0.03706965f, 0.07646637f, -0.40976274f, 0.05544892f, -0.37970749f, 
    0.17044821f, -0.16621435f, -0.01037107f, -0.19643612f, 0.04161288f, -0.04979384f, 0.02322414f, 0.09076751f, 
    0.01033951f, -0.07355057f, -0.03647055f, -0.39526987f, 0.07636515f, 0.02673069f, 0.10657709f, 0.16967106f, 
    0.13395718f, 0.08730204f, 0.15616526f, -0.05391842f, -0.01150972f, -0.00127873f, 0.17665377f, 0.19075990f, 
    -0.11505527f, -0.03166095f, -0.01985586f, -0.05103002f, 0.01428920f, 0.02457256f, 0.22009774f, 0.24604149f, 
    -0.27976334f, 0.11684930f, 0.04642439f, 0.03340292f, -0.01176576f, -0.03172918f, 0.04088298f, 0.41172236f, 
    0.07409380f, 0.09671613f, 0.10219993f, 0.14466462f, -0.52365541f, -0.16912591f, 0.31165883f, -0.21353614f, 
    -0.11376953f, 0.08187711f, 0.04880910f, 0.28930047f, -0.02112483f, 0.18195604f, -0.23031060f, 0.04753591f, 
    -0.34835333f, -0.20799431f, -0.12990372f, -0.29332224f, -0.10884578f, 0.08412614f, -0.20813613f, 0.14224710f, 
    -0.04141889f, 0.01771145f, 0.05329852f, 0.02998508f, 0.09787019f, 0.30090004f, -0.14511259f, 0.26249218f, 
    -0.01274867f, -0.02425393f, -0.02727734f, -0.01779084f, 0.04951404f, 0.05016915f, 0.08182541f, 0.10824218f, 
    0.00468985f, -0.21466763f, 0.04738770f, 0.20131770f, -0.08052834f, 0.05689149f, 0.03707042f, 0.06066684f, 
    0.12191083f, 0.14365552f, 0.18032773f, 0.07673285f, 0.20962083f, 0.29848695f, -0.06639467f, -0.11066125f, 
    0.17451724f, 0.13381043f, 0.13432190f, -0.10522987f, 0.07082551f, 0.09524212f, -0.04312031f, 0.03034968f, 
    -0.28535438f, -0.08368894f, 0.40204155f, -0.24358541f, -0.06187053f, 0.22630180f, 0.10259509f, 0.06368356f, 
    -0.05566165f, -0.05100811f, -0.03049034f, -0.10488985f, -0.20483904f, 0.22595565f, -0.28599316f, -0.34134126f, 
    0.04561649f, 0.02915813f, 0.00180937f, -0.19307053f, 0.00192507f, 0.00011095f, -0.02746746f, 0.00547527f, 
    0.50436002f, 0.32274890f, 0.26640344f, 0.08574943f, -0.04221877f, 0.14735395f, 0.12601964f, -0.06753406f, 
    0.23400176f, 0.11219907f, 0.11830904f, 0.00390877f, -0.03808321f, 0.10047955f, -0.02428929f, -0.27195746f, 
    0.06143632f, 0.09482975f, 0.10045434f, -0.24250707f, -0.03098359f, 0.02341606f, 0.05347761f, 0.04345928f, 
    0.06021945f, -0.01981632f, -0.03527272f, -0.09447438f, -0.13736947f, 0.14104734f, -0.15488121f, -0.02232752f, 
    0.03082026f, 0.05100181f, -0.06970769f, 0.03107808f, 0.06062289f, 0.08469676f, -0.03164813f, 0.11296332f, 
    -0.00839207f, -0.00423004f, 0.05022381f, 0.02560625f, -0.07021940f, -0.02208288f, 0.10929527f, 0.16050005f, 
    -0.04293700f, -0.06993295f, 0.00689234f, 0.03717841f, -0.00748208f, -0.01053331f, 0.09589164f, 0.00242080f, 
    -0.03044175f, -0.03672085f, 0.07081673f, 0.07014316f, 0.38850403f, 0.01272071f, -0.36557195f, 0.38793075f, 
    -0.07992144f, -0.06855875f, -0.03145699f, -0.00116895f, 0.20554797f, 0.21777023f, 0.11179636f, 0.31267598f, 
    0.11930474f, -0.05156982f, 0.00723604f, 0.02881780f, 0.26207036f, 0.14604263f, 0.00093315f, 0.21141215f, 
    0.00100196f, 0.11266039f, -0.04876653f, 0.24332011f, 0.14169990f, 0.02468777f, -0.43564874f, 0.03262569f, 
    -0.13454314f, -0.00797508f, 0.09224825f, -0.02974973f, 0.19313800f, 0.00822216f, 0.14557974f, 0.09451938f, 
    0.04076725f, -0.06511025f, -0.19866851f, 0.46216598f, 0.02322618f, -0.11417464f, -0.03347446f, -0.07522702f, 
    0.18698360f, -0.04940579f, 0.09170228f, -0.08862256f, 0.01648754f, -0.02117432f, -0.04525062f, -0.18398260f, 
    0.08358952f, -0.01270026f, -0.07110672f, -0.22492997f, 0.01001859f, 0.01845861f, 0.02308318f, 0.02747767f, 
    0.06441750f, -0.13475861f, 0.07681285f, -0.01069566f, -0.07165623f, 0.10708433f, -0.00637705f, 0.24757464f, 
    -0.09254890f, -0.04589842f, 0.02022804f, 0.07718582f, -0.14054415f, -0.14136103f, -0.02404167f, -0.17657460f, 
    -0.09644029f, -0.02972000f, -0.22578590f, 0.16852477f, -0.10906006f, -0.14276586f, -0.10053059f, -0.06492546f, 
    -0.06863619f, 0.08663137f, 0.05474077f, -0.03846385f, -0.07866669f, -0.10158697f, -0.15813686f, -0.10591940f, 
    -0.12562044f, -0.11420655f, 0.11747041f, 0.04893491f, -0.03592353f, 0.11080654f, 0.12349428f, 0.00336369f, 
    -0.16527003f, -0.10220992f, -0.09292332f, -0.09532169f, -0.01464051f, 0.12506157f, 0.01063560f, 0.13269301f, 
    -0.24994551f, 0.11162180f, 0.33313617f, -0.05427071f, -0.00412921f, -0.12812631f, -0.09112319f, 0.07139783f, 
    -0.13657822f, 0.19614232f, -0.04467165f, 0.05252580f, 0.36099309f, 0.13940591f, 0.05033016f, 0.12847666f, 
    0.23613089f, 0.04241239f, 0.10384205f, 0.15954718f, -0.04076895f, -0.03564378f, 0.01805313f, -0.10090230f, 
    -0.53730142f, -0.53458226f, -0.06905077f, 0.12758814f, -0.07261918f, 0.02455305f, 0.19707869f, 0.08752232f, 
    0.01074391f, 0.14545536f, -0.13766086f, 0.08555087f, 0.10086136f, 0.14593485f, -0.04971740f, -0.22734621f, 
    0.20192638f, -0.01523703f, 0.18923579f, -0.05789189f, -0.00618798f, -0.13282527f, 0.04488745f, 0.23889451f, 
    0.34185541f, -0.25276196f, -0.27757162f, 0.00359345f, 0.13777086f, 0.02369107f, 0.02402751f, -0.00866019f, 
    0.05443595f, 0.04720567f, -0.04910241f, 0.01367841f, 0.10849219f, 0.21883319f, 0.15594122f, 0.16592626f, 
    -0.24264905f, -0.04691625f, 0.11942326f, -0.05765429f, -0.30734339f, -0.17582296f, 0.09320945f, 0.20588771f, 
    -0.08152155f, -0.00431895f, -0.03180384f, -0.07817066f, 0.10465747f, 0.07960016f, 0.00547261f, -0.00419907f, 
    -0.00460630f, 0.05377173f, -0.05284355f, -0.02529735f, -0.19119982f, -0.20089859f, 0.71517348f, 0.03917720f, 
    0.13986851f, -0.11119829f, -0.00156230f, 0.15202841f, -0.02226137f, 0.05411974f, 0.06705196f, -0.01330558f, 
    -0.06322008f, -0.13019715f, 0.13278963f, 0.07774764f, 0.20684984f, -0.04707982f, 0.04775221f, -0.03748184f, 
    0.09187961f, -0.00913585f, 0.30935946f, 0.15492103f, 0.14516713f, 0.13898289f, 0.04313997f, 0.18912941f, 
    -0.03620152f, -0.07960846f, 0.04898007f, -0.11490989f, 0.09873528f, -0.00083751f, 0.07164603f, 0.02436200f, 
    0.27757871f, 0.15623352f, -0.03457023f, -0.18098651f, 0.18092775f, -0.11313494f, 0.16618760f, -0.11923654f, 
    -0.04397633f, -0.02632907f, 0.08223237f, 0.06788154f, 0.01023019f, -0.27843696f, -0.42861709f, 0.09521756f, 
    -0.11489437f, 0.19048800f, 0.26854026f, 0.33062941f, -0.11406598f, 0.04580423f, -0.10200776f, 0.10477577f, 
    -0.16813479f, 0.07500520f, 0.12205643f, -0.02946364f, -0.00631366f, -0.15633267f, -0.06750733f, 0.17359360f, 
    -0.07513639f, 0.06859326f, -0.05831685f, -0.07097785f, 0.02276023f, 0.33924612f, 0.12091269f, 0.07635424f, 
    -0.12669790f, -0.08536810f, -0.10601698f, -0.16607739f, -0.10939141f, 0.05449454f, 0.05230857f, -0.05540183f, 
    0.39946023f, 0.14543554f, -0.10400689f, -0.06785060f, -0.02755863f, -0.04337735f, -0.12300425f, -0.17286620f, 
    -0.01053106f, 0.07457236f, 0.00874824f, -0.09211951f, 0.33037469f, 0.38868305f, 0.11055394f, -0.04130766f, 
    -0.08778108f, 0.08926380f, 0.14757764f, 0.05236730f, 0.07114442f, 0.01479211f, -0.03990056f, 0.08886449f, 
    0.01839185f, -0.09790237f, 0.21097934f, -0.03275059f, 0.02995638f, 0.09948351f, 0.30432189f, -0.10443947f, 
    -0.12895751f, -0.00339637f, -0.08196037f, 0.00357675f, 0.15473923f, 0.52514809f, -0.05133789f, -0.38902673f, 
    0.03026577f, -0.27775338f, 0.03619456f, -0.13865474f, -0.04963291f, 0.00503067f, 0.00290695f, -0.07591441f, 
    0.30205974f, -0.22712557f, -0.00459641f, 0.12279320f, -0.16815913f, 0.07282361f, 0.19658783f, 0.05106637f, 
    0.06132839f, 0.08614322f, 0.05525054f, 0.00746193f, -0.01299162f, -0.02265958f, -0.05875181f, -0.17288037f, 
    0.04356186f, -0.17711802f, -0.19198622f, 0.10073148f, -0.10370395f, -0.16508883f, -0.09580094f, 0.15651937f, 
    -0.13585201f, 0.22384751f, -0.09266872f, 0.09205122f, 0.10528996f, 0.01688172f, 0.02667189f, 0.05120811f, 
    -0.10772157f, -0.01474173f, -0.01021045f, -0.07360650f, 0.21857385f, 0.28195983f, 0.27001262f, 0.03848031f, 
    -0.10004137f, -0.05767427f, -0.13894008f, -0.06811920f, -0.12974523f, -0.09418118f, 0.09423690f, 0.09967141f, 
    0.20307881f, 0.20448245f, 0.12165348f, -0.07630360f, -0.07230733f, -0.19261479f, 0.00650881f, -0.08324257f, 
    -0.06922469f, 0.00665837f, -0.03682000f, 0.00937472f, 0.06404783f, 0.46052143f, -0.22006129f, 0.11747515f, 
    -0.02078188f, -0.10889070f, 0.06948739f, -0.02279699f, 0.04843354f, 0.24143256f, 0.16749576f, 0.08683229f, 
    -0.02710003f, 0.05263236f, -0.07161681f, -0.10201695f, -0.00018828f, 0.22267953f, -0.19955306f, 0.01935080f, 
    -0.09142032f, 0.14593099f, -0.14964324f, 0.02642688f, -0.00364202f, 0.13255896f, 0.13869867f, 0.10862333f, 
    -0.15740500f, -0.07084253f, 0.09424991f, -0.15453520f, 0.15842494f, 0.06151525f, 0.04110696f, -0.03153285f, 
    0.43986970f, 0.10393894f, -0.24722540f, 0.24004276f, 0.09683206f, 0.12803671f, 0.04196654f, -0.00668751f, 
    -0.07275597f, -0.08892585f, -0.01073112f, -0.01071039f, 0.05234760f, -0.20764375f, -0.02727396f, -0.07517234f, 
    0.19406772f, 0.11453723f, 0.09659193f, 0.13399822f, -0.00350775f, -0.06091401f, 0.01755825f, -0.15177087f, 
    0.16671254f, 0.22299030f, 0.47901759f, 0.09274060f, 0.07099310f, 0.22988774f, -0.26346666f, -0.08558466f, 
    -0.15380999f, -0.11782283f, 0.00146760f, -0.03124798f, 0.05712733f, 0.14401262f, 0.34853628f, -0.00983719f, 
    -0.01090159f, -0.05868326f, -0.05249107f, 0.05114583f, -0.06196154f, 0.01803974f, 0.05770790f, 0.14570314f, 
    0.01211181f, -0.03711517f, 0.03263208f, 0.01583080f, 0.01390023f, -0.07136706f, -0.01781873f, -0.06807854f, 
    0.05297249f, -0.02442654f, 0.08702158f, -0.01008342f, 0.09179160f, 0.00784378f, 0.16474384f, 0.03652581f, 
    -0.02113866f, -0.06597059f, -0.12733135f, -0.08402047f, -0.04611261f, 0.03412406f, -0.00030797f, -0.10400379f, 
    0.21607788f, -0.06623990f, 0.06674030f, -0.02551578f, -0.05824241f, -0.09607575f, 0.10026104f, 0.08384720f, 
    0.04705200f, 0.06427946f, 0.16788635f, -0.06853853f, 0.21113947f, 0.15163180f, 0.13305297f, -0.15362538f, 
    0.14121912f, 0.14051132f, 0.05567584f, 0.02193543f, 0.08993632f, -0.05005834f, -0.12396382f, -0.02403047f, 
    0.25516346f, 0.02411053f, -0.22812794f, -0.25815821f, 0.05047611f, -0.01777681f, 0.13562681f, 0.18945028f, 
    -0.08550334f, -0.03018448f, 0.08214462f, -0.10268453f, -0.07409284f, -0.00521452f, 0.01028575f, 0.05499276f, 
    0.03314006f, 0.00136726f, 0.05617126f, -0.07294629f, 0.07724822f, -0.08056779f, 0.20460583f, 0.01584765f, 
    -0.17391972f, -0.00519630f, 0.17972310f, -0.20429562f, -0.04074599f, 0.08438782f, 0.10040982f, 0.07434777f, 
    0.19513205f, -0.01983249f, -0.07904226f, -0.06462713f, 0.36908519f, -0.08523583f, -0.00578106f, -0.15678354f, 
    0.10738553f, 0.17711203f, -0.19940922f, 0.06400887f, -0.03147344f, 0.16332652f, -0.04138783f, -0.12825494f, 
    -0.19187789f, -0.02906814f, -0.03997652f, -0.18258420f, 0.02926524f, 0.06804121f, 0.18660814f, 0.05171460f, 
    -0.05639640f, 0.05506361f, 0.00701136f, 0.03371710f, 0.36912841f, 0.06786265f, -0.16107996f, -0.24190596f, 
    0.13463731f, 0.08426745f, 0.20655265f, 0.09377649f, 0.07344941f, -0.03451200f, -0.01935312f, 0.05468785f, 
    0.01320802f, -0.00268559f, 0.11171269f, -0.37215382f, 0.02904016f, 0.00666923f, 0.10994429f, 0.27131307f, 
    0.14025559f, -0.02846375f, 0.09346263f, -0.10375711f, 0.45281360f, -0.21044070f, 0.50385016f, 0.26886225f, 
    -0.22135010f, -0.09476525f, -0.10917789f, -0.05778234f, 0.05037697f, 0.03962168f, 0.13476220f, 0.06460793f, 
    -0.03419839f, -0.11765146f, 0.29853880f, -0.25980204f, -0.11227177f, 0.10622533f, -0.04803696f, 0.24674319f, 
    -0.00873047f, 0.12653348f, 0.18570575f, -0.01515307f, -0.57663655f, -0.22270226f, 0.12643102f, -0.12475388f, 
    -0.01622995f, 0.06390320f, 0.04609442f, 0.22573514f, 0.09710279f, 0.27057371f, 0.04367958f, 0.11427382f, 
    -0.10021623f, -0.01273851f, -0.06885817f, -0.22941573f, 0.03521402f, 0.21197793f, -0.00818856f, 0.17105967f, 
    -0.00788538f, 0.00533550f, 0.14406314f, 0.10274837f, 0.42657182f, 0.15643649f, 0.13361882f, 0.27544644f, 
    -0.06036421f, -0.10296383f, -0.10270979f, -0.13475664f, -0.03381754f, -0.01185596f, 0.02398496f, 0.18058099f, 
    0.23136954f, 0.19097140f, 0.32566318f, 0.21731335f, -0.10880850f, 0.02011638f, 0.02431167f, 0.04071116f, 
    0.37329075f, -0.06661742f, 0.11354254f, 0.03192789f, 0.41376510f, 0.23419242f, -0.01186354f, -0.34149209f, 
    0.12607886f, 0.03759988f, 0.08496958f, 0.25681135f, 0.07300773f, -0.00935978f, 0.05582250f, 0.02672965f, 
    -0.21566124f, 0.21922429f, -0.09016368f, -0.25088876f, 0.08339816f, 0.18717054f, 0.14030652f, 0.18910243f, 
    -0.09718618f, -0.07288504f, -0.03796313f, 0.01587186f, 0.22166005f, -0.05866219f, 0.03841830f, -0.16179310f, 
    0.21486004f, 0.15431605f, -0.01191085f, -0.05191243f, -0.06751475f, -0.10741683f, -0.05662798f, 0.01860647f, 
    0.27074358f, -0.33592331f, -0.46834192f, -0.32254997f, 0.02537394f, 0.14281677f, 0.08394388f, 0.34023732f, 
    0.18545701f, 0.09849893f, 0.06280874f, 0.02857464f, 0.25232306f, 0.10826769f, 0.12478546f, -0.02431727f, 
    0.11334708f, -0.05412219f, 0.19772089f, 0.06097372f, -0.08755542f, -0.02087735f, 0.06369808f, 0.04680388f, 
    0.25193092f, -0.20894285f, -0.14016271f, -0.15032144f, 0.09326311f, 0.20973276f, 0.03344483f, 0.03650239f, 
    0.05893931f, -0.01237520f, 0.01986239f, 0.03083601f, 0.16041185f, 0.19434299f, -0.03064499f, 0.13519181f, 
    0.08031313f, -0.13406672f, -0.00966007f, -0.09669873f, -0.07208458f, -0.04693583f, -0.07569940f, 0.04202754f, 
    -0.06252970f, 0.00337711f, -0.05220058f, 0.11191493f, -0.01499701f, -0.07626043f, 0.01856654f, -0.05199489f, 
    -0.07210345f, -0.10717818f, -0.08861556f, -0.06297425f, 0.58899659f, 0.08639976f, 0.16395177f, 0.21492217f, 
    -0.07982020f, -0.12502378f, -0.02574288f, -0.22623256f, 0.29440251f, 0.21186979f, 0.11538079f, 0.16757882f, 
    0.03109623f, -0.14809021f, 0.03704942f, -0.08020213f, 0.01699866f, 0.21722174f, -0.04568540f, 0.02713113f, 
    0.06000037f, 0.09710985f, -0.03268443f, 0.02942432f, 0.08203173f, 0.06090885f, -0.07300492f, -0.17970148f, 
    0.21476206f, 0.15425752f, 0.05805859f, -0.05075172f, 0.19494945f, -0.03824544f, 0.14409834f, 0.15351091f, 
    -0.04518597f, 0.02348042f, -0.20819108f, -0.19680277f, 0.16189963f, 0.10153114f, 0.05065531f, 0.08473133f, 
    0.06379247f, 0.03849771f, -0.16925144f, -0.11394767f, 0.07281779f, 0.16655818f, -0.04320105f, -0.17401916f, 
    0.24173523f, 0.14771898f, 0.05425339f, -0.06316313f, -0.05529853f, -0.02085413f, 0.01210657f, 0.08926468f, 
    -0.03601853f, 0.12129242f, -0.17314550f, 0.22876538f, 0.14372846f, 0.13592298f, 0.16372751f, 0.13384119f, 
    -0.08954843f, 0.01612553f, -0.13625245f, 0.03001188f, -0.10093588f, 0.04318264f, 0.00917238f, 0.22685161f, 
    0.06436476f, -0.00696455f, 0.05879912f, 0.10322450f, -0.12762840f, -0.02416603f, 0.07105711f, -0.14131278f, 
    -0.03975658f, -0.00883955f, -0.02625585f, 0.03534691f, -0.04699181f, -0.03844815f, 0.04348369f, -0.05427925f, 
    -0.00957190f, 0.03111579f, 0.03518880f, -0.02062136f, -0.02411881f, 0.01496621f, 0.01787413f, -0.03071957f, 
    -0.03795946f, 0.00834853f, -0.05471288f, 0.02725267f, -0.03386687f, -0.03894919f, 0.01923490f, 0.02715559f, 
    -0.01103069f, 0.02287541f, 0.02061402f, -0.04141418f, 0.03279802f, 0.04231318f, 0.00342318f, 0.02475785f, 
    -0.02985278f, 0.00720639f, -0.04720577f, -0.04605997f, 0.00996513f, -0.00061937f, -0.01198767f, 0.02960562f, 
    0.00549897f, 0.03487474f, -0.04408237f, 0.02103772f, -0.05604436f, -0.03414170f, -0.00578747f, -0.04573373f, 
    0.00632777f, 0.01443753f, 0.02446038f, -0.00089670f, 0.01780767f, 0.03124278f, 0.02301379f, -0.00718859f, 
    -0.04750532f, 0.00839879f, -0.03111476f, 0.01373880f, -0.02747912f, 0.03962823f, -0.04182943f, -0.04573650f, 
    0.01513155f, -0.05114552f, -0.04800826f, -0.03280722f, -0.02117404f, -0.05556867f, -0.05501908f, -0.04084548f, 
    0.00236582f, -0.04986494f, -0.00200715f, 0.00340889f, -0.00297424f, -0.05136385f, 0.04496491f, 0.00835313f, 
    0.01488145f, -0.00842014f, -0.01102065f, 0.03826673f, 0.02564374f, 0.00761407f, 0.00830648f, 0.02456502f, 
    -0.02177125f, -0.02890918f, 0.00806808f, -0.03129047f, -0.01733626f, 0.02835477f, 0.03201679f, -0.03708254f, 
    0.02697742f, -0.04910561f, -0.01862238f, -0.01775489f, -0.00374556f, -0.05001722f, 0.00794382f, 0.00835054f, 
    -0.03094438f, -0.04049020f, 0.00653350f, -0.05467017f, 0.01819202f, -0.01944482f, -0.02965067f, 0.02385953f, 
    -0.04969806f, 0.02748155f, -0.00126057f, 0.01082676f, -0.03725158f, 0.02762854f, -0.01595518f, 0.03799917f, 
    0.03215678f, 0.04459311f, 0.02563470f, -0.03142773f, 0.01153636f, -0.02322970f, 0.00811362f, 0.01927612f, 
    0.00274236f, 0.00123093f, 0.01263277f, 0.01778609f, -0.02636082f, 0.01013249f, 0.01312682f, 0.03648042f, 
    0.03040355f, 0.00773217f, -0.03962544f, 0.01847398f, -0.01883348f, -0.02405374f, -0.04760704f, -0.01986074f, 
    0.01737568f, 0.00347898f, -0.05139554f, -0.02021678f, 0.01961258f, -0.04674405f, -0.03255809f, 0.04245042f, 
    -0.00200698f, 0.01314421f, -0.00930529f, -0.00368218f, -0.03728137f, 0.02025044f, -0.04208456f, 0.00044847f, 
    0.00897013f, 0.00297115f, -0.03601660f, -0.02646809f, -0.00467840f, -0.01747541f, 0.03506422f, -0.03890255f, 
    -0.02885800f, -0.05040871f, 0.03858251f, 0.04200082f, -0.04158387f, -0.04579167f, -0.01743502f, 0.01983471f, 
    -0.01595135f, -0.04330908f, -0.02452478f, -0.01548843f, 0.01209498f, 0.01684484f, 0.03711986f, 0.01965922f, 
    -0.05604282f, 0.01288099f, -0.02048090f, -0.03910045f, 0.04532270f, 0.02100918f, -0.03089866f, -0.01444819f, 
    -0.04162870f, 0.01513633f, 0.02669479f, -0.05372742f, -0.03083506f, -0.01905616f, 0.01753525f, -0.04306643f, 
    -0.03586103f, 0.01204210f, -0.01612592f, -0.04974658f, -0.03701226f, -0.02139282f, 0.03668749f, 0.03114977f, 
    -0.05135050f, -0.01264258f, 0.02127283f, -0.02427819f, -0.01087635f, -0.00706861f, 0.00995320f, 0.00292180f, 
    -0.04814330f, -0.03522302f, -0.04074945f, 0.00339241f, -0.01480860f, -0.00951664f, 0.02639166f, 0.02853067f, 
    -0.02957253f, -0.02089583f, -0.02745720f, 0.03446497f, -0.03341458f, 0.00071277f, 0.04118723f, -0.05450633f, 
    0.00041220f, 0.00649147f, -0.05245002f, -0.01167831f, -0.02442688f, -0.04755142f, -0.04713807f, -0.00279369f, 
    0.00620819f, -0.01663096f, 0.02259306f, 0.00841380f, 0.00690313f, -0.03369284f, 0.03901476f, -0.02079056f, 
    -0.05614525f, 0.00741682f, -0.04629752f, 0.00170637f, -0.04996291f, 0.00848202f, -0.00322321f, -0.00571236f, 
    0.01356795f, -0.04351323f, 0.01668856f, -0.02042845f, 0.01352630f, -0.00067338f, -0.01027808f, -0.04973576f, 
    -0.05630517f, 0.01005477f, -0.05275775f, -0.04461528f, -0.00884824f, -0.04472807f, 0.01797241f, 0.00040144f, 
    0.01029589f, -0.03425862f, 0.00502067f, -0.00697443f, 0.00458909f, 0.01192106f, -0.03432941f, 0.03380348f, 
    -0.01115241f, -0.05011456f, -0.00119237f, 0.03253311f, 0.03341015f, -0.04926080f, -0.00855395f, 0.03722768f, 
    0.02650096f, -0.01688614f, 0.01782326f, -0.02374608f, -0.04055918f, 0.00134659f, -0.04214638f, -0.01617853f, 
    0.00850586f, -0.04105238f, -0.01846695f, -0.05016388f, 0.04548459f, -0.01309767f, 0.00735569f, 0.01392853f, 
    -0.02934038f, -0.02497536f, -0.01581598f, -0.04099125f, 0.00758043f, 0.00659943f, -0.04637010f, 0.04308205f, 
    0.01386092f, 0.04056551f, -0.05468044f, -0.00567239f, -0.00910743f, -0.05175405f, -0.05489834f, -0.05541370f, 
    -0.01625899f, 0.00087525f, 0.01160504f, -0.01512027f, 0.01649094f, -0.02253868f, -0.04481936f, 0.02743040f, 
    0.03094342f, -0.02958799f, -0.00603259f, 0.00943817f, -0.03663572f, 0.04310086f, 0.02586296f, -0.00717435f, 
    -0.00693914f, -0.01148094f, -0.00548483f, 0.01252101f, -0.05222031f, -0.04331335f, -0.03429966f, 0.02466704f, 
    -0.04166576f, 0.00038844f, -0.03529031f, -0.01635333f, 0.03084336f, -0.03638167f, -0.02234330f, 0.00528284f, 
    0.03739042f, 0.03120023f, -0.03917493f, 0.02396451f, 0.00438779f, -0.02574010f, -0.02417609f, -0.05444290f, 
    0.03414828f, -0.00932477f, -0.03521496f, -0.05387506f, -0.04701450f, 0.02044277f, -0.01219618f, -0.02136319f, 
    -0.00441543f, -0.05056052f, 0.01299427f, 0.01634272f, -0.01813258f, 0.02879505f, -0.05166082f, 0.01245976f, 
    0.00469981f, 0.04159690f, -0.00609835f, 0.00368797f, 0.01871830f, 0.02067396f, 0.03446706f, -0.00277381f, 
    0.05386423f, 0.16126895f, 0.10571559f, -0.05145597f, -0.06444045f, -0.01479361f, -0.05490667f, 0.03575643f, 
    0.31227481f, 0.09682573f, 0.26192552f, 0.21816340f, 0.13820916f, 0.05729743f, 0.20573078f, 0.01770767f, 
    -0.02028554f, -0.08234056f, -0.10516772f, -0.08395856f, 0.17605133f, 0.10155155f, 0.14604597f, 0.12862726f, 
    0.20334826f, 0.44405210f, -0.01850784f, 0.00759187f, 0.03261974f, -0.05943437f, 0.07921258f, 0.00369012f, 
    0.10775442f, 0.08164353f, -0.05303290f, -0.09163830f, -0.13080262f, 0.10333224f, 0.14217296f, 0.39045778f, 
    -0.01611517f, 0.14246796f, 0.03689892f, 0.31025842f, -0.00229823f, -0.05117331f, 0.02877113f, -0.00659808f, 
    -0.39003733f, -0.00851381f, -0.15986997f, -0.00461231f, -0.02067264f, 0.02576763f, 0.30127493f, -0.05758160f, 
    0.18636584f, 0.08211755f, -0.01926289f, -0.01066256f, 0.17763841f, 0.11911207f, -0.05194578f, 0.02951879f, 
    0.07833011f, -0.02788836f, 0.07816942f, -0.07026517f, 0.04187600f, -0.03605938f, -0.00329369f, 0.05877131f, 
    -0.02598369f, -0.17771657f, -0.20703654f, -0.03661530f, -0.08490031f, -0.01731746f, -0.09805857f, 0.05023607f, 
    0.02474089f, -0.08622298f, 0.04946021f, -0.02750117f, 0.11213537f, 0.18779506f, 0.02420138f, -0.25293744f, 
    0.00467916f, 0.11875100f, 0.08780395f, -0.05445445f, 0.01830911f, -0.09179416f, 0.07281982f, 0.11748736f, 
    -0.01471445f, 0.08551571f, 0.08729760f, -0.01504670f, -0.10033701f, -0.13089226f, 0.21570531f, 0.01372253f, 
    -0.09596966f, 0.06953609f, 0.09632317f, -0.04421078f, -0.04017615f, 0.00356279f, -0.00546494f, -0.01552157f, 
    -0.04858965f, -0.01294101f, 0.18189611f, -0.06286083f, 0.06564331f, 0.05166822f, 0.06287870f, -0.11275775f, 
    -0.03419944f, -0.26197603f, 0.32214016f, 0.34109512f, -0.02887718f, 0.15416104f, -0.24457572f, 0.04858379f, 
    -0.04038008f, -0.10230497f, -0.05958313f, -0.16883424f, 0.29163009f, 0.20682968f, 0.14833583f, 0.11804675f, 
    0.08523330f, -0.04864399f, -0.01149082f, 0.02286808f, 0.08800423f, 0.15450718f, -0.23926401f, -0.12625204f, 
    0.02889498f, -0.29542035f, -0.11124437f, 0.00473788f, 0.17347065f, 0.06215038f, -0.06539759f, 0.10111476f, 
    -0.14003630f, 0.01301262f, 0.10750113f, -0.08385206f, 0.53260654f, -0.01707630f, -0.00105282f, -0.09247058f, 
    0.05480875f, -0.29683188f, 0.20883891f, 0.20010626f, 0.03427105f, -0.01736699f, 0.08860505f, 0.16696854f, 
    -0.13953891f, -0.04727134f, 0.10717249f, 0.05354830f, 0.09249643f, -0.01874078f, -0.12452623f, 0.17781369f, 
    -0.06131400f, -0.00230590f, -0.02375300f, 0.00434566f, 0.09175678f, 0.23518233f, 0.08748801f, -0.14462936f, 
    0.06857030f, 0.07858806f, 0.01475916f, -0.02987979f, 0.03654445f, 0.03598803f, -0.08244758f, -0.04815564f, 
    0.37080008f, -0.14026518f, 0.12130877f, -0.28184614f, 0.06346262f, 0.03240233f, 0.03547586f, -0.04811824f, 
    -0.00079851f, -0.07083073f, -0.23122527f, -0.30773950f, -0.05911651f, -0.08913951f, 0.47292766f, -0.04863411f, 
    0.19712614f, -0.04206189f, 0.03334875f, 0.24482022f, 0.00820290f, -0.02366633f, -0.21023904f, 0.02283774f, 
    -0.16488852f, -0.10423808f, 0.23038115f, 0.17148080f, 0.12329292f, -0.14868572f, 0.39450198f, -0.01502237f, 
    0.00116250f, 0.03864321f, -0.02736046f, -0.00678858f, -0.48206988f, 0.08691349f, -0.21198605f, 0.10411475f, 
    -0.06613120f, 0.03524766f, 0.02672022f, -0.07971774f, -0.03673780f, 0.01501487f, 0.00358422f, 0.04019692f, 
    0.05749876f, 0.07803880f, 0.11745785f, 0.04810144f, -0.05965157f, -0.15550870f, 0.30711961f, -0.26337031f, 
    0.10353167f, 0.02315073f, 0.11152241f, -0.09995530f, -0.21551564f, 0.03553975f, -0.11299670f, 0.12011568f, 
    0.08117931f, 0.08541872f, 0.02648333f, -0.01022699f, -0.04987704f, -0.03939275f, -0.01855508f, 0.00846128f, 
    -0.00957280f, 0.10309513f, -0.08253052f, -0.26313496f, 0.01462170f, 0.04858565f, -0.04736746f, -0.01898137f, 
    -0.06149530f, -0.05584089f, -0.01434343f, 0.06633889f, 0.17136952f, 0.05097739f, 0.04352093f, 0.11574881f, 
    -0.01671200f, -0.02810284f, -0.03332058f, 0.00388166f, -0.00908187f, -0.03327031f, -0.00302259f, -0.03087286f, 
    -0.02906151f, 0.05528190f, -0.12204672f, 0.01863187f, 0.01338605f, -0.06772052f, -0.01304808f, -0.08028296f, 
    0.01576394f, -0.01301423f, 0.05223981f, -0.03038029f, 0.28577450f, 0.21966669f, 0.13192932f, -0.17808603f, 
    0.09915573f, 0.05550833f, -0.05003835f, 0.02722199f, 0.09191269f, -0.14739279f, -0.06801887f, -0.03673113f, 
    0.14130361f, -0.02967976f, 0.09889553f, -0.11491763f, -0.05937587f, 0.06704470f, -0.08497117f, 0.00867755f, 
    0.00845504f, 0.03790893f, -0.01896065f, -0.06375722f, -0.60163796f, 0.13763107f, 0.05982807f, 0.26627061f, 
    -0.14171067f, 0.17972706f, 0.11910702f, -0.17726949f, 0.03680742f, 0.05521566f, 0.06378887f, 0.00977645f, 
    -0.03251001f, 0.01600496f, 0.17762582f, 0.43941137f, 0.05036024f, -0.04046901f, -0.18018097f, 0.07654847f, 
    -0.10274324f, -0.18834880f, -0.07061400f, 0.00613169f, -0.27838740f, -0.20293936f, 0.17026053f, 0.31867984f, 
    0.16037580f, 0.15017122f, 0.10163753f, 0.23062693f, -0.03770982f, 0.04933236f, -0.06355806f, -0.10275633f, 
    0.05381951f, 0.05473451f, -0.20157778f, 0.00157345f, -0.13172683f, 0.15929203f, -0.10306009f, -0.06047111f, 
    0.03583517f, -0.05230951f, 0.07872840f, -0.00086492f, 0.23479760f, 0.23736723f, -0.04456633f, 0.01258038f, 
    -0.11221834f, -0.03951177f, -0.06388678f, 0.07455201f, 0.30438933f, 0.15046187f, 0.13644451f, -0.02609179f, 
    -0.11576563f, -0.11950023f, -0.04452008f, 0.06693441f, 0.04181417f, 0.04289059f, -0.05078020f, 0.06819087f, 
    -0.00214171f, -0.06738413f, -0.00458793f, -0.13935775f, -0.18904741f, -0.13165307f, 0.01195157f, -0.01303998f, 
    -0.05218115f, 0.00260790f, -0.10851265f, 0.05622318f, -0.22141777f, -0.03762377f, -0.04537012f, -0.12939472f, 
    -0.20156415f, -0.19126014f, -0.26858214f, 0.09677137f, -0.00051491f, 0.07439017f, -0.11882497f, -0.02473208f, 
    -0.04411122f, -0.22731397f, -0.29181394f, -0.06390734f, 0.10869174f, 0.19272904f, 0.08334928f, -0.12690558f, 
    0.14844333f, -0.13102211f, 0.02722694f, -0.04565397f, -0.00271980f, 0.02204359f, 0.00259014f, 0.02789589f, 
    0.05387977f, 0.03331703f, -0.12836319f, 0.07034051f, 0.18047698f, 0.28040645f, -0.12237678f, 0.03082327f, 
    -0.10836811f, -0.00205673f, 0.01480345f, -0.04900521f, -0.07354931f, -0.06000390f, -0.06076944f, 0.13248277f, 
    -0.02689306f, -0.15681121f, 0.07438808f, 0.10250467f, -0.05726970f, -0.00989318f, 0.12349951f, 0.09823795f, 
    -0.13466358f, 0.04149526f, 0.04627435f, -0.09508640f, 0.08532584f, 0.08481021f, 0.15944532f, 0.07062376f, 
    -0.06550238f, -0.08795409f, -0.07579698f, -0.24716736f, -0.02482072f, -0.11139756f, -0.10176316f, -0.13537751f, 
    0.04605765f, -0.08404694f, -0.22633916f, -0.01519342f, -0.00562933f, 0.06805120f, 0.03189902f, 0.00502066f, 
    0.08795158f, 0.07955231f, -0.00306511f, 0.08098371f, 0.07627126f, 0.27391356f, -0.09655277f, -0.11372899f, 
    0.10234268f, 0.12224267f, 0.14010638f, 0.23427510f, -0.52881736f, -0.05681970f, -0.01021454f, 0.23671423f, 
    0.03288752f, 0.17436063f, -0.27356485f, -0.09928726f, -0.00830979f, -0.07305690f, 0.08921397f, 0.04577198f, 
    0.24608524f, 0.23387668f, 0.24028017f, -0.08317085f, -0.07606915f, 0.07645538f, -0.08543890f, 0.10881380f, 
    -0.11177696f, -0.05589345f, -0.11808136f, -0.01037589f, 0.15394939f, 0.12828845f, 0.10990222f, -0.14237794f, 
    -0.17921476f, -0.04891993f, 0.11457398f, 0.01756697f, -0.03155810f, -0.05202386f, 0.15549472f, 0.18602565f, 
    -0.09528360f, 0.09344639f, 0.28622371f, -0.42866585f, -0.08707926f, -0.14266054f, 0.09708405f, 0.15384786f, 
    -0.06220247f, -0.06259659f, -0.09294412f, 0.08288050f, -0.02128239f, 0.02704731f, -0.06107873f, 0.11447792f, 
    -0.03576570f, 0.08354905f, -0.08325350f, -0.07485732f, 0.16578448f, 0.23011011f, 0.09249209f, -0.10903613f, 
    0.21444422f, 0.18339872f, 0.03195652f, 0.07308317f, 0.18762609f, 0.13625023f, 0.06656904f, -0.05168605f, 
    0.02846988f, 0.06993449f, 0.19535717f, 0.10639002f, -0.00666326f, 0.29422238f, -0.01412483f, 0.05069601f, 
    -0.05881610f, 0.01249368f, 0.03416517f, 0.00494747f, 0.08493201f, 0.05823748f, 0.01672966f, 0.14151941f, 
    -0.07888362f, 0.13918053f, -0.05521762f, -0.09859465f, -0.04975249f, -0.02293697f, 0.06578948f, 0.02913473f, 
    0.31322140f, -0.06083682f, -0.08742391f, -0.06361610f, 0.18152811f, 0.22127868f, -0.02646123f, -0.07032296f, 
    0.14791846f, 0.01908379f, 0.04593268f, -0.02112836f, -0.04478452f, -0.05486402f, 0.01514092f, 0.10796038f, 
    0.20526803f, 0.17277987f, -0.41056564f, 0.12940244f, 0.13829118f, 0.22912531f, 0.37016732f, 0.05234619f, 
    0.08452918f, -0.01719507f, 0.02585439f, 0.16814427f, 0.47491118f, 0.32447582f, 0.17441669f, 0.19580181f, 
    -0.07742035f, -0.08260325f, 0.00279239f, 0.06724107f, 0.06542923f, -0.06352576f, 0.01470694f, -0.00523798f, 
    0.15240979f, -0.30106938f, -0.37027669f, 0.01525063f, 0.21703684f, 0.24327554f, -0.02251459f, -0.06039322f, 
    0.08814663f, -0.18700407f, 0.02793309f, -0.02589456f, 0.21938920f, 0.15797377f, 0.15447454f, 0.13789620f, 
    0.10533205f, 0.02110402f, -0.09567200f, 0.06741054f, 0.00823048f, 0.01601586f, 0.06836295f, 0.00305942f, 
    0.15259996f, 0.08574176f, 0.01299106f, 0.23452932f, 0.17138501f, 0.12411588f, -0.21720183f, -0.12545177f, 
    0.02805542f, 0.07152574f, 0.04420409f, 0.01698180f, -0.36349186f, -0.12568323f, -0.03881434f, 0.12105621f, 
    0.11168380f, -0.08968732f, -0.00541348f, -0.08624837f, 0.00047901f, 0.01464557f, 0.06505194f, 0.19398595f, 
    -0.12690455f, -0.06197375f, -0.05350046f, 0.05569386f, -0.16258250f, -0.09133805f, -0.02054774f, 0.01301130f, 
    0.03826438f, 0.01084627f, 0.06852674f, 0.00111237f, 0.23388243f, 0.11838277f, -0.28367543f, -0.39655218f, 
    -0.20210215f, 0.09456052f, 0.09291884f, -0.17259344f, 0.19006369f, -0.03921192f, -0.17564251f, 0.11714192f, 
    -0.01747305f, 0.09876627f, 0.20720872f, 0.02195296f, -0.10029389f, 0.00972776f, -0.07202995f, -0.06807807f, 
    0.08731814f, -0.02745992f, 0.21223985f, 0.22417024f, 0.39917001f, 0.24268726f, 0.02451922f, -0.01139539f, 
    0.21469320f, 0.24173333f, 0.03564523f, 0.11182021f, 0.08019681f, 0.06421205f, 0.03761422f, 0.12902278f, 
    -0.02859561f, 0.06995752f, -0.14491206f, -0.13213149f, -0.01496044f, 0.09006996f, -0.08782414f, 0.03947354f, 
    -0.06417733f, -0.03686467f, -0.09692489f, -0.21230882f, 0.36280403f, 0.20596452f, -0.02667975f, -0.06246864f, 
    0.09195137f, 0.30150768f, -0.03550342f, 0.05936310f, 0.08168186f, 0.02367864f, -0.05833453f, 0.04830128f, 
    -0.36112711f, -0.13901101f, 0.19633766f, 0.37709698f, 0.13621469f, -0.16307582f, -0.14567634f, 0.11260596f, 
    -0.02172766f, 0.03892192f, 0.01432737f, 0.04823367f, -0.21641785f, -0.18039601f, 0.00242975f, 0.16095634f, 
    -0.05711250f, 0.04846040f, -0.11115480f, -0.06883039f, 0.04285344f, -0.03732941f, -0.10127225f, -0.16533437f, 
    -0.04630494f, -0.00125248f, 0.03732503f, 0.03123872f, 0.00085554f, -0.04546488f, -0.04365691f, 0.03342638f, 
    0.03907198f, -0.04022489f, 0.02496235f, -0.00279572f, -0.01633356f, 0.04138356f, -0.00677500f, -0.03754615f, 
    0.00728448f, -0.02399112f, -0.03741299f, 0.02383984f, -0.04420076f, 0.03712898f, 0.04024956f, -0.03303742f, 
    -0.05138008f, 0.03530900f, -0.00956837f, -0.05943708f, -0.03634178f, -0.02061971f, 0.03646909f, -0.02824935f, 
    0.02949307f, 0.03603518f, 0.00744898f, -0.04718867f, 0.03514947f, 0.02209663f, 0.03320522f, -0.04869973f, 
    -0.00277683f, -0.01196843f, 0.03754951f, 0.04419172f, -0.03533116f, -0.03158158f, 0.01426757f, -0.04312157f, 
    -0.05524909f, 0.02467252f, -0.00072665f, 0.05167093f, 0.04292067f, -0.01072821f, -0.02014791f, -0.02734251f, 
    0.02306517f, -0.02808896f, 0.00602661f, 0.02178443f, -0.05771714f, 0.00992995f, -0.00395650f, -0.00430583f, 
    0.03347429f, -0.05929979f, -0.00282025f, -0.02273637f, 0.00241145f, -0.02966437f, -0.01733523f, -0.02714757f, 
    0.04659149f, 0.02952456f, -0.05116193f, 0.04000298f, 0.00652761f, -0.01342321f, -0.02247372f, 0.01799658f, 
    -0.02329491f, -0.00569498f, 0.01357819f, -0.01709469f, 0.02775554f, -0.00215714f, 0.04117202f, 0.01398331f, 
    -0.01143416f, 0.02417595f, -0.01351159f, -0.03264161f, 0.00444005f, 0.03165684f, 0.01350872f, 0.00519960f, 
    -0.05377156f, 0.04140119f, -0.00376655f, -0.00135546f, -0.02513222f, 0.01298841f, 0.00550643f, 0.04185514f, 
    -0.01419513f, -0.02900881f, -0.05324610f, -0.00376088f, -0.02447904f, -0.04688516f, 0.02886545f, -0.04233545f, 
    -0.02736727f, 0.02262583f, 0.00881193f, -0.00722053f, -0.03001388f, 0.04342910f, 0.03992256f, -0.02835149f, 
    0.03174326f, 0.03311172f, 0.03759307f, -0.02374785f, 0.01159543f, -0.04725508f, 0.00118155f, -0.03593648f, 
    0.01683186f, -0.01689341f, 0.05162178f, -0.04364073f, -0.03655315f, 0.04126586f, 0.02056897f, 0.00821176f, 
    -0.00285460f, -0.05718536f, 0.04047402f, -0.02538733f, -0.03438298f, -0.00580355f, -0.04502090f, -0.03807339f, 
    0.02890436f, 0.03394485f, -0.00190870f, 0.01809131f, 0.03309847f, -0.02826957f, -0.04476618f, -0.00242371f, 
    0.00970273f, 0.00788477f, -0.01155627f, 0.02963253f, -0.00851198f, -0.00460157f, 0.04507835f, 0.01839488f, 
    0.04077998f, -0.01183727f, 0.04693839f, -0.02907271f, 0.01374004f, -0.03748439f, -0.03753856f, 0.02585572f, 
    -0.04985722f, 0.02728743f, -0.00137859f, -0.02660710f, -0.04989237f, -0.04390582f, 0.04187271f, -0.03918601f, 
    0.00282619f, -0.03089439f, 0.02527607f, 0.00894498f, 0.00783799f, 0.02388896f, 0.03545664f, 0.01379626f, 
    -0.00974813f, -0.05047489f, -0.05579135f, -0.01189938f, -0.05636672f, -0.05535785f, 0.03244483f, -0.00281090f, 
    -0.03191202f, 0.00680072f, 0.03978220f, -0.02714833f, -0.03058821f, -0.02739367f, -0.00088137f, -0.00420564f, 
    0.04242287f, -0.04579709f, -0.02266276f, 0.04095309f, -0.02201204f, 0.02854971f, -0.02456731f, -0.00971598f, 
    -0.05243394f, -0.00246795f, -0.04437625f, 0.04720213f, 0.03243161f, -0.04972165f, 0.00094988f, 0.03495196f, 
    -0.01118065f, 0.01958692f, -0.01575614f, -0.01540113f, -0.04715298f, -0.03695202f, -0.04334453f, 0.00483296f, 
    0.00524520f, 0.01932558f, 0.04912537f, -0.05142232f, -0.00379028f, -0.04651594f, 0.04047307f, -0.02640910f, 
    -0.01841969f, -0.02699130f, 0.02471050f, 0.01784918f, -0.01076292f, -0.01679808f, 0.01615104f, -0.03058217f, 
    -0.00211888f, 0.01201296f, 0.01727539f, -0.04323654f, -0.01637106f, -0.01797074f, -0.03077647f, 0.02253074f, 
    -0.01479977f, -0.03340791f, 0.04722534f, -0.01643989f, -0.03393765f, -0.02149523f, -0.02711953f, -0.02006352f, 
    0.02828078f, -0.02178267f, -0.05479530f, 0.00612139f, -0.02946345f, -0.03605761f, 0.03276108f, 0.01408802f, 
    -0.02120327f, -0.00813856f, 0.02857974f, 0.03317853f, 0.03945498f, -0.04335444f, -0.01747867f, -0.04673686f, 
    -0.00248949f, -0.05192118f, 0.03121620f, -0.00595936f, -0.00424860f, -0.00658606f, 0.01728517f, -0.00342393f, 
    -0.01326491f, -0.03186108f, 0.04249075f, -0.01464920f, 0.04006707f, 0.00820212f, 0.03021505f, 0.01538777f, 
    0.02186777f, 0.01758757f, 0.03822992f, -0.00899161f, -0.02407749f, -0.03801350f, -0.04346678f, -0.00983927f, 
    -0.05259439f, -0.02998386f, -0.02258794f, 0.04861816f, 0.04136989f, -0.00188444f, -0.00906239f, 0.02439310f, 
    0.02512724f, 0.03350371f, 0.01352446f, -0.05533461f, -0.04580611f, 0.02831648f, -0.00517476f, -0.04055618f, 
    -0.01690027f, -0.04025786f, 0.00806652f, 0.00158851f, -0.02283309f, -0.00428814f, -0.02919437f, 0.02262404f, 
    -0.01460003f, -0.00396821f, 0.00250025f, 0.01437787f, -0.02502318f, -0.02162692f, 0.00030276f, -0.02486227f, 
    -0.05753830f, -0.02588716f, -0.02521838f, 0.00428684f, 0.01927146f, -0.02632487f, 0.02829153f, 0.01161827f, 
    -0.01393540f, -0.03464964f, 0.04136897f, 0.01744896f, -0.00509199f, -0.01044240f, -0.05005462f, -0.03862910f, 
    0.00810718f, 0.03228628f, -0.02531823f, -0.00054805f, -0.04934718f, -0.04756514f, -0.02540935f, 0.02569099f, 
    -0.01412435f, 0.01461010f, -0.01285741f, 0.01174406f, -0.00160817f, -0.04855492f, 0.02363487f, -0.00210122f, 
    -0.03730566f, -0.05654200f, -0.04858939f, -0.00508054f, -0.04307960f, -0.05438296f, -0.03910469f, 0.01971923f, 
    -0.05766664f, 0.01053269f, 0.01462387f, -0.01380632f, -0.02022671f, -0.04736280f, 0.00099258f, 0.02306806f, 
    -0.00323524f, -0.03608977f, -0.04333253f, 0.02620729f, -0.05749895f, 0.02760510f, 0.03965264f, -0.00238611f, 
    0.00440435f, -0.07931290f, -0.01263874f, -0.02337421f, -0.02181701f, -0.05966564f, -0.08652591f, -0.13361056f, 
    0.17224909f, 0.02318705f, 0.07912982f, 0.01519760f, -0.06457090f, 0.03452894f, -0.07877359f, 0.03496931f, 
    -0.04138124f, -0.05536098f, -0.05141887f, -0.09015318f, 0.10234223f, -0.00392814f, -0.11162926f, -0.00491247f, 
    0.20496047f, -0.02446495f, 0.16022263f, -0.15536581f, -0.04081270f, 0.04448158f, -0.05716182f, 0.08294564f, 
    -0.02246531f, 0.19785541f, -0.00897216f, -0.03833172f, -0.11054309f, 0.02536058f, 0.06897011f, 0.10466291f, 
    0.03264782f, -0.06216675f, 0.07314441f, -0.00350313f, 0.09312122f, 0.02101032f, 0.02517126f, -0.12700126f, 
    -0.30527446f, -0.29112968f, 0.29239100f, 0.03725471f, 0.03265836f, -0.00150558f, 0.22365803f, 0.17507890f, 
    0.01945621f, 0.06009555f, -0.09779382f, 0.04259287f, -0.01130856f, -0.03517801f, 0.07664605f, 0.03939580f, 
    0.01885563f, 0.05977284f, -0.01685894f, -0.10125854f, 0.04190537f, -0.07792401f, 0.05669066f, 0.05048959f, 
    -0.23838355f, -0.25924805f, -0.23705345f, 0.09582344f, 0.00798833f, -0.08650914f, 0.06721517f, 0.01056290f, 
    0.06913989f, 0.07642321f, -0.05059236f, 0.01298619f, 0.26239240f, 0.12068940f, 0.00471386f, 0.20178142f, 
    0.00980182f, 0.01263384f, 0.03279956f, 0.05945951f, -0.10638022f, -0.11572854f, 0.13139537f, -0.05725602f, 
    -0.19165726f, 0.03840839f, -0.04209967f, 0.03232833f, 0.15914036f, -0.02912864f, -0.07522429f, -0.03708490f, 
    -0.08028735f, -0.11851273f, -0.06561489f, -0.06001062f, 0.32486236f, -0.08253989f, 0.16142842f, 0.06773752f, 
    0.33526501f, -0.04442387f, -0.02640617f, 0.13872154f, -0.07045083f, 0.08170296f, -0.01944877f, 0.05002985f, 
    -0.26027095f, 0.22012691f, -0.10108931f, 0.07456767f, 0.08513765f, -0.19786519f, 0.10863880f, -0.00349285f, 
    0.17915180f, 0.01570339f, 0.26113504f, 0.09157149f, -0.11337063f, -0.28200784f, 0.26623496f, 0.34365094f, 
    0.00071254f, 0.00120143f, -0.11197219f, -0.10068423f, 0.14426643f, -0.01799289f, 0.00612718f, 0.13282880f, 
    -0.60537368f, 0.25564301f, -0.18065590f, 0.04035659f, 0.09576619f, -0.08057504f, 0.12049730f, 0.10138337f, 
    -0.02726263f, -0.02802076f, 0.07414668f, -0.01627500f, -0.30569330f, -0.08711223f, -0.09823798f, -0.01670865f, 
    -0.09474360f, 0.06105905f, 0.01836280f, 0.10422416f, 0.02172845f, -0.00286840f, -0.12442405f, 0.09234326f, 
    -0.12117220f, 0.00838821f, -0.08807578f, 0.04848929f, 0.20000005f, -0.01583940f, 0.10895228f, 0.02014312f, 
    -0.06322136f, 0.03665924f, -0.09188669f, 0.00682980f, 0.14229558f, 0.02687442f, 0.14522062f, 0.25154099f, 
    -0.16246782f, -0.07163645f, -0.07238425f, -0.04139767f, -0.04492807f, -0.09229691f, -0.06207503f, -0.01132616f, 
    -0.11260992f, 0.03047280f, 0.00143893f, 0.24320078f, 0.02781839f, 0.01301405f, -0.04767870f, 0.01747812f, 
    -0.05297323f, 0.09632574f, -0.07125574f, -0.04130875f, 0.07866284f, 0.24445166f, -0.03164356f, 0.31607533f, 
    0.02643063f, -0.02401386f, 0.00723893f, 0.01823531f, 0.03851820f, -0.06710955f, -0.02559560f, 0.05686271f, 
    -0.15209731f, 0.15604885f, 0.43021685f, 0.06905319f, -0.05190061f, 0.04470172f, -0.08622286f, 0.09685915f, 
    -0.04302406f, -0.04106640f, -0.10637811f, -0.03001593f, 0.25898397f, 0.28753081f, 0.09768438f, -0.15822962f, 
    -0.04763755f, -0.06122278f, -0.09062383f, -0.02383940f, -0.05178313f, 0.01874864f, 0.00721490f, -0.07663929f, 
    0.38827285f, -0.08913599f, 0.19267650f, -0.26849896f, -0.04861676f, -0.01646629f, 0.10926387f, 0.17840634f, 
    0.11242986f, 0.06073532f, 0.05048527f, -0.03007522f, 0.12171005f, 0.09852725f, 0.11628783f, -0.04899195f, 
    -0.01240717f, -0.13890086f, -0.11398450f, 0.07355865f, -0.00797017f, -0.10958125f, -0.00345387f, -0.02225782f, 
    0.09412547f, -0.10152238f, -0.07451137f, -0.09047080f, -0.14668553f, -0.00413943f, 0.03666204f, 0.23163004f, 
    0.04505309f, -0.09776054f, -0.02518583f, -0.08155479f, 0.20371026f, 0.15039454f, 0.11648914f, 0.10379252f, 
    -0.11846168f, -0.04612885f, -0.10511100f, -0.07799380f, -0.06545111f, -0.02952966f, 0.02519521f, -0.00434032f, 
    0.22676556f, 0.04307245f, 0.02701250f, -0.08423165f, -0.05302411f, -0.00898072f, -0.06289952f, -0.09130501f, 
    -0.02977300f, -0.15314020f, -0.11278939f, -0.01510469f, 0.30937684f, -0.02820935f, -0.12901029f, 0.22983049f, 
    -0.09726480f, -0.13423319f, -0.06630233f, 0.04463938f, 0.07108065f, -0.03629443f, -0.15231456f, 0.22115493f, 
    -0.07279763f, 0.14177829f, -0.09866901f, -0.03802861f, 0.08146182f, 0.13157731f, -0.07400122f, 0.08059391f, 
    -0.00524609f, 0.10948509f, -0.22689253f, 0.04855026f, 0.32287550f, -0.02852378f, 0.29948753f, 0.08097807f, 
    -0.04371560f, 0.11373437f, 0.06465624f, -0.02617942f, 0.09228808f, -0.02690820f, 0.11642145f, 0.06676069f, 
    -0.43484062f, 0.00698527f, 0.12763155f, 0.13218211f, -0.05971232f, -0.24653415f, -0.26197827f, -0.23403831f, 
    0.08460979f, -0.07166504f, -0.08739655f, -0.17984922f, 0.08721001f, 0.18155366f, 0.29979894f, 0.16389322f, 
    0.02099718f, 0.03958787f, -0.04474696f, 0.11294140f, 0.05183505f, -0.04814785f, 0.05195054f, -0.06978080f, 
    0.42707571f, 0.14730075f, 0.43687108f, -0.00548287f, 0.12125228f, 0.07734215f, 0.04658702f, -0.00166237f, 
    -0.00897045f, -0.07031424f, -0.01835627f, -0.13573000f, 0.14674996f, 0.01956827f, 0.03088276f, 0.01506919f, 
    0.10330383f, -0.01729596f, -0.09770498f, 0.03392487f, -0.02455467f, -0.10951222f, -0.03657116f, 0.01649858f, 
    -0.07818874f, -0.01804503f, -0.06534220f, -0.08065487f, -0.08593409f, 0.05092758f, -0.07013807f, -0.08413967f, 
    -0.00005862f, 0.07024748f, 0.13829084f, 0.19762120f, -0.15633124f, -0.12948850f, -0.07850236f, -0.05044366f, 
    -0.09846112f, -0.05960889f, -0.03725115f, -0.02113490f, 0.05015616f, 0.11772106f, 0.14625414f, 0.06425652f, 
    -0.16802572f, -0.10725925f, 0.07902445f, -0.05219266f, 0.06270670f, -0.13670373f, -0.03546888f, 0.14719094f, 
    -0.09798943f, 0.07635498f, -0.12559170f, 0.05978691f, 0.27033842f, 0.20256369f, -0.09556944f, 0.19010125f, 
    0.03201784f, 0.09457871f, 0.03076825f, 0.10289986f, 0.00919501f, 0.07624932f, 0.08882381f, -0.05700287f, 
    0.23435608f, 0.05094846f, 0.11790735f, 0.11954711f, -0.02964280f, 0.08085161f, 0.08724046f, -0.00677988f, 
    0.12182310f, 0.17188923f, -0.11129276f, 0.08985642f, -0.16082709f, -0.01636472f, -0.05708157f, -0.14657699f, 
    0.17549148f, 0.06855974f, -0.01743783f, -0.04041957f, 0.02908548f, -0.15419364f, 0.00335953f, 0.01386603f, 
    0.07238783f, 0.22602704f, -0.06048136f, 0.02138322f, -0.07368103f, 0.01875767f, -0.02434699f, -0.00515981f, 
    0.03957063f, 0.12451300f, -0.02824150f, -0.06697840f, -0.02637713f, -0.17233889f, -0.15540700f, 0.10144572f, 
    -0.27449021f, -0.09690730f, 0.09487676f, 0.16531953f, -0.06417885f, -0.02658018f, -0.03797726f, 0.07527982f, 
    0.21882673f, 0.25268534f, 0.22085463f, 0.07208064f, 0.01109750f, 0.08012977f, 0.03284688f, 0.09252199f, 
    0.01682026f, 0.05080504f, 0.03374187f, -0.02014615f, -0.22016875f, -0.38908702f, -0.27056709f, 0.14224648f, 
    0.20001923f, -0.06235329f, 0.06242745f, -0.13865900f, -0.00030279f, 0.09862553f, -0.10250533f, 0.05587435f, 
    -0.03291683f, 0.16435954f, 0.10444482f, 0.15311433f, -0.08363132f, 0.06832431f, -0.00357447f, -0.18957970f, 
    -0.02400429f, -0.13072537f, 0.06285181f, 0.00353770f, -0.28375441f, -0.14905104f, 0.07852973f, 0.19575147f, 
    0.00948199f, 0.01885556f, 0.02998992f, 0.00971500f, 0.03167079f, 0.03357050f, -0.05145331f, 0.06857555f, 
    -0.43015146f, 0.34638023f, 0.10200201f, -0.25010529f, 0.01385827f, 0.12353867f, 0.09782472f, -0.01231346f, 
    -0.05906481f, 0.05094959f, -0.02487907f, 0.01719260f, 0.61681169f, 0.25351197f, 0.15258802f, -0.02851596f, 
    0.11390750f, -0.02813219f, 0.04019750f, 0.14859164f, -0.31452847f, -0.08458507f, 0.01606549f, 0.14453843f, 
    0.07586847f, 0.05231484f, 0.06336626f, 0.10673781f, 0.01392341f, 0.02554603f, 0.21550819f, 0.00155167f, 
    -0.12498031f, 0.00940295f, 0.02071976f, -0.04885882f, -0.49301821f, -0.05055545f, -0.01799281f, 0.11064641f, 
    -0.01024887f, 0.06116047f, -0.02854412f, 0.05426354f, -0.06025851f, -0.05322832f, -0.10847333f, -0.15757672f, 
    -0.13147862f, -0.01631286f, -0.13356817f, -0.07997074f, -0.00286704f, 0.05360124f, -0.02128740f, -0.03993789f, 
    -0.33248851f, -0.07377946f, -0.16604519f, -0.26120365f, 0.29811355f, 0.10035791f, -0.10230247f, 0.37018362f, 
    -0.03520759f, -0.06641395f, -0.13074753f, 0.19692799f, 0.05314969f, 0.00634196f, -0.08841118f, 0.00783243f, 
    0.45741126f, 0.12041648f, 0.47376651f, 0.33025903f, -0.01708509f, -0.02797273f, 0.18396184f, 0.03120622f, 
    -0.05000153f, 0.08465445f, 0.00425704f, -0.01061296f, -0.20831853f, 0.07287705f, -0.17886327f, -0.00186681f, 
    0.08075859f, -0.09978312f, 0.05003425f, 0.06180101f, -0.00460585f, 0.00188412f, -0.07743194f, 0.01809461f, 
    0.37908179f, 0.03318527f, 0.27768198f, 0.17592572f, 0.12509707f, -0.04443999f, 0.04312034f, 0.12965158f, 
    -0.01370122f, 0.02762481f, 0.02173915f, 0.05369586f, -0.03157412f, 0.12304081f, 0.04775204f, -0.08671415f, 
    0.09706105f, -0.05110792f, -0.24484341f, 0.10378515f, 0.05382014f, -0.01405307f, -0.01907346f, 0.05892038f, 
    0.16294573f, -0.07905062f, -0.01648083f, -0.04131731f, -0.05162528f, 0.19113868f, -0.01983043f, 0.01863937f, 
    -0.03526537f, -0.01128157f, 0.12506282f, -0.01765902f, -0.24260353f, -0.31312388f, -0.17462945f, -0.04965748f, 
    -0.07029357f, -0.04896977f, 0.03577931f, 0.03716408f, -0.07299432f, 0.02599401f, 0.02766832f, -0.05547339f, 
    -0.06683083f, -0.10714706f, -0.08508097f, -0.08247756f, 0.00763576f, 0.04889561f, 0.05365485f, -0.06887339f, 
    0.09173948f, 0.01780900f, 0.13218988f, 0.02113822f, -0.11613836f, 0.18605930f, -0.23071624f, -0.09821785f, 
    -0.02467502f, 0.03605787f, 0.03699166f, 0.08559516f, -0.37747362f, -0.07500035f, -0.04073995f, 0.00521731f, 
    0.09137919f, 0.02221023f, 0.10353721f, -0.14273843f, 0.02462750f, 0.07719159f, -0.07076021f, 0.05700042f, 
    -0.18580477f, 0.03999214f, -0.00606811f, -0.12501740f, -0.06229297f, 0.36550525f, 0.06767613f, 0.16950318f, 
    -0.19631368f, -0.02300090f, -0.00045227f, -0.00784517f, 0.01465434f, -0.00227066f, -0.03505652f, -0.08569851f, 
    0.17516544f, 0.35699081f, 0.13422887f, 0.39622629f, -0.22990246f, 0.23492420f, -0.06606292f, 0.04584039f, 
    -0.07434520f, 0.11969472f, 0.02870167f, 0.00336485f, 0.17631972f, 0.08900937f, 0.18283156f, 0.16961536f, 
    -0.11561191f, -0.05076636f, -0.03606846f, 0.17268567f, 0.11921834f, 0.06870137f, 0.02771291f, -0.08126390f, 
    -0.00756351f, -0.31282902f, 0.32467481f, -0.19518253f, -0.03019003f, 0.09443949f, -0.11819663f, -0.14471366f, 
    -0.05090145f, -0.04929050f, -0.00905138f, -0.03322942f, 0.01555440f, -0.12800825f, -0.17842714f, -0.02218914f, 
    -0.11303593f, -0.08339951f, 0.00656532f, 0.02243083f, 0.20944355f, 0.06862053f, 0.08289067f, 0.22548276f, 
    0.01439671f, -0.09584596f, 0.01775011f, 0.01726520f, -0.00835335f, 0.00581501f, 0.01302308f, 0.07427767f, 
    0.10681476f, 0.08899235f, 0.01247257f, 0.09012514f, 0.03705495f, 0.08575068f, -0.06847467f, 0.15265661f, 
    0.03666050f, -0.01736058f, 0.06648680f, 0.09957049f, 0.15555091f, -0.04343593f, 0.00428915f, 0.02051061f, 
    0.41933763f, -0.06384858f, 0.09917382f, -0.14511204f, 0.12041321f, -0.00384103f, -0.03113651f, 0.03030538f, 
    0.15528698f, 0.17167227f, 0.26457381f, 0.07221797f, -0.13538177f, -0.02945622f, -0.04042487f, 0.07000674f, 
    -0.05866004f, 0.12291529f, 0.08592839f, 0.02932316f, -0.05265048f, -0.00852133f, 0.10379286f, 0.07296637f, 
    -0.10133793f, -0.07451922f, 0.12449807f, -0.15223551f, 0.07078837f, 0.14251071f, -0.08516018f, -0.09948210f, 
    0.33897147f, -0.08666169f, -0.07306094f, 0.01653700f, 0.07549702f, 0.02918283f, 0.06354303f, -0.01852725f, 
    0.08233561f, 0.00241854f, 0.00948214f, -0.10214688f, 0.07927526f, -0.06893834f, 0.08230873f, 0.02049088f, 
    -0.26888740f, -0.03872005f, -0.06390057f, -0.03683225f, -0.13155507f, 0.09452526f, 0.06088052f, 0.03546490f, 
    0.18631189f, 0.24051863f, 0.15862660f, 0.09647068f, 0.27954140f, 0.22370386f, 0.07378214f, 0.04432477f, 
    0.06517950f, 0.05344596f, -0.03361720f, -0.00778232f, -0.06352434f, -0.17361502f, -0.01765052f, -0.05119600f, 
    -0.19205384f, -0.00169510f, 0.07900669f, -0.08863690f, -0.15035008f, -0.24608298f, -0.04718073f, 0.05495394f, 
    -0.16881403f, -0.05304673f, -0.12595339f, -0.24787550f, 0.73605955f, 0.05717536f, -0.14581287f, -0.11337821f, 
    0.15970917f, -0.15238313f, -0.00117206f, 0.14954191f, -0.10235952f, 0.15403764f, -0.05451183f, 0.05923848f, 
    -0.15412952f, 0.11493462f, -0.19142802f, 0.12994476f, 0.03142862f, -0.15203547f, 0.14941280f, 0.05380390f, 
    0.11603591f, 0.06272390f, 0.12861378f, 0.05094879f, -0.04951387f, -0.27785546f, 0.26031300f, 0.25363150f, 
    0.04875384f, 0.02271449f, -0.03155356f, 0.08195762f, 0.09945194f, 0.02866821f, 0.01381845f, 0.02923099f, 
    -0.79506052f, 0.19724268f, -0.14782056f, 0.14133412f, -0.01528185f, 0.20660067f, 0.03782815f, 0.15129192f, 
    0.08856632f, -0.19146007f, -0.00066740f, -0.16157617f, -0.11227164f, -0.10669164f, 0.17023894f, -0.03132445f, 
    -0.18572579f, -0.13747248f, -0.02407913f, 0.04108866f, -0.02496206f, -0.08992538f, -0.18142344f, -0.02864393f, 
    -0.13105765f, 0.02168228f, -0.08744110f, -0.08383758f, 0.09980200f, -0.01450272f, 0.00183414f, 0.00460534f, 
    -0.13842250f, -0.04527399f, -0.07178662f, -0.06993365f, 0.01749734f, 0.27667233f, -0.05465019f, 0.05427041f, 
    0.01795463f, 0.03891448f, 0.02692062f, 0.07463697f, -0.09307056f, -0.03035821f, 0.00008507f, -0.03847591f, 
    -0.14797442f, -0.00097994f, -0.01830248f, 0.26752219f, 0.03503495f, -0.06430691f, -0.03978984f, 0.15601292f, 
    -0.23152393f, 0.20827726f, 0.07251729f, 0.10541038f, 0.09644126f, 0.05855858f, -0.01315932f, 0.11594196f, 
    0.12148750f, 0.03435511f, -0.00503369f, -0.04216072f, -0.02901589f, 0.03510855f, 0.04415025f, -0.06839223f, 
    -0.05302037f, -0.03990716f, 0.45530310f, 0.08361769f, -0.07739893f, -0.01021076f, -0.28275830f, 0.06457049f, 
    -0.05509849f, 0.00977039f, -0.04793072f, -0.10387162f, -0.30787197f, 0.04594755f, 0.01546872f, 0.11441178f, 
    0.02035896f, -0.06362244f, -0.22408329f, -0.02256127f, -0.07961641f, 0.04211151f, -0.00537884f, 0.06515662f, 
    0.22683783f, 0.29476234f, 0.12664938f, -0.19083996f, -0.09792208f, -0.16230953f, 0.05269524f, 0.02831038f, 
    0.04494945f, 0.15460178f, -0.05377727f, -0.10846342f, -0.01996296f, 0.07622043f, 0.04638014f, 0.00054129f, 
    0.08095667f, 0.14670019f, 0.07210213f, 0.00445696f, -0.01360703f, 0.00060810f, -0.05659618f, 0.07265208f, 
    0.11291995f, -0.15780914f, -0.14704530f, -0.08980756f, -0.20821621f, -0.00946874f, 0.00955013f, -0.09167650f, 
    0.07793156f, -0.08706237f, -0.03494586f, -0.06992918f, 0.34449390f, 0.09831803f, 0.04889294f, 0.07664353f, 
    -0.05553344f, 0.06654867f, 0.01413087f, 0.01734018f, -0.04631653f, -0.07772216f, 0.03110611f, -0.15030792f, 
    0.21541354f, 0.07772750f, 0.03849044f, 0.01708237f, -0.01204850f, 0.01973190f, -0.06191994f, -0.10461846f, 
    -0.01966383f, -0.11747020f, -0.11436043f, 0.02394229f, 0.51025808f, -0.02075798f, -0.20789944f, 0.30902794f, 
    -0.05006028f, -0.10199317f, -0.02401035f, 0.18374534f, -0.06450132f, 0.12125329f, 0.09961697f, 0.02328136f, 
    0.11958923f, 0.06564488f, -0.21377623f, 0.21592431f, 0.10684752f, -0.05921712f, 0.08563145f, 0.00652236f, 
    -0.08272940f, 0.02744224f, -0.21031584f, -0.16028719f, -0.00407483f, -0.05183650f, 0.13662173f, 0.05297745f, 
    -0.16070168f, 0.08026409f, 0.02512401f, 0.06249785f, -0.01801470f, -0.05421613f, -0.03430440f, 0.06360664f, 
    -0.24299136f, -0.18774123f, 0.36632797f, 0.12393010f, -0.04168892f, 0.01059078f, 0.13739921f, -0.08491101f, 
    -0.01413415f, -0.00113606f, -0.01382214f, -0.01349746f, 0.03230017f, 0.03532269f, 0.21714725f, 0.16220407f, 
    -0.03101029f, -0.06524722f, -0.04064503f, 0.01929768f, 0.09640418f, -0.01758095f, -0.00561529f, -0.03877201f, 
    0.37655464f, -0.04437072f, 0.30898717f, -0.19766429f, -0.12694930f, -0.20621637f, 0.15754679f, -0.15096971f, 
    -0.06910352f, -0.07848045f, 0.04298813f, -0.03903768f, 0.30818686f, -0.01487271f, 0.06132220f, -0.18888856f, 
    -0.01734714f, -0.01732723f, -0.05568040f, 0.05617964f, 0.28463021f, -0.09973469f, 0.02906930f, 0.13490874f, 
    -0.05336018f, -0.16708300f, -0.14908543f, -0.10614928f, 0.07275282f, -0.00508582f, 0.04487581f, -0.00959709f, 
    0.15134719f, 0.17087199f, -0.18880285f, -0.07658833f, -0.07739808f, -0.11938573f, -0.25939932f, -0.17072812f, 
    -0.02819411f, -0.06255981f, 0.08044799f, 0.06275889f, 0.02428650f, 0.07428063f, 0.00964092f, -0.08547605f, 
    0.18497932f, -0.06823801f, -0.25952801f, -0.03460395f, -0.01214353f, 0.26368320f, 0.03512278f, -0.14868774f, 
    0.17356001f, -0.03767713f, 0.19541068f, 0.08061041f, -0.42106754f, -0.29908365f, 0.04539976f, -0.10870332f, 
    -0.14799818f, -0.15549026f, 0.00514462f, -0.05819507f, 0.08168767f, 0.07688428f, 0.11631317f, 0.17743438f, 
    0.04159127f, 0.23278204f, 0.25940192f, 0.24932465f, 0.07365494f, 0.04243912f, 0.02671959f, 0.08804128f, 
    0.05589401f, -0.08355528f, -0.01577209f, -0.11960937f, -0.02630107f, -0.13503015f, 0.03509347f, 0.02641240f, 
    -0.21459121f, -0.02983108f, -0.15514272f, 0.10436514f, 0.02085401f, 0.11885109f, -0.05879633f, -0.14125791f, 
    -0.14304614f, -0.05336738f, 0.05759833f, 0.05931603f, 0.07045899f, -0.01365006f, 0.06898974f, 0.08004021f, 
    0.04843908f, 0.03556448f, 0.13919199f, -0.07652988f, -0.21404420f, -0.16415015f, 0.10261429f, -0.02159654f, 
    0.13418102f, 0.15919121f, -0.06781308f, -0.05409085f, 0.16312151f, 0.00698473f, -0.05126289f, -0.06815311f, 
    0.02930870f, -0.11114114f, -0.01455023f, 0.12257640f, -0.03167824f, -0.11734801f, 0.01883383f, 0.02790709f, 
    -0.02451636f, -0.12358600f, -0.05776511f, 0.01744779f, 0.30487746f, 0.21763170f, -0.21558270f, 0.12340578f, 
    0.07287226f, 0.25110474f, -0.04527320f, 0.12904593f, -0.07384995f, -0.08665301f, 0.10258853f, -0.13794547f, 
    -0.04164997f, 0.05763163f, -0.17869979f, 0.12895155f, 0.02502762f, -0.00971379f, 0.17537369f, 0.17193907f, 
    0.10118426f, 0.19852631f, -0.04574534f, 0.06863643f, -0.22500217f, 0.15996650f, -0.07985088f, -0.11923663f, 
    0.02571400f, -0.05387934f, -0.05150138f, -0.01580975f, -0.06846335f, -0.00022235f, 0.01202767f, 0.08250128f, 
    0.00469567f, -0.10585415f, -0.14454325f, 0.38736388f, -0.05499201f, -0.00254510f, 0.04366895f, 0.00863158f, 
    0.11370166f, 0.11453951f, 0.04795499f, -0.13919264f, -0.05492599f, 0.28752178f, 0.36576954f, 0.17415284f, 
    0.01864048f, -0.07520371f, -0.09317970f, -0.18866923f, 0.30805933f, 0.12839432f, 0.23350924f, -0.12195522f, 
    0.04500842f, -0.02163787f, -0.02867076f, 0.10796874f, 0.20727138f, 0.08696327f, 0.10036375f, -0.21630502f, 
    0.01197823f, -0.03761343f, -0.12855212f, -0.10176559f, 0.14917177f, -0.31500119f, -0.08523542f, 0.08333705f, 
    -0.00358956f, -0.10926561f, -0.03775807f, 0.09822133f, 0.07971355f, -0.05746851f, 0.08664476f, 0.11192153f, 
    -0.30820209f, -0.04481981f, 0.04902073f, 0.04915709f, 0.10701096f, -0.06332249f, -0.01500267f, 0.01710786f, 
    0.06245376f, 0.18965572f, 0.19116537f, 0.28220585f, -0.41993982f, -0.24807681f, 0.02112459f, 0.26743212f, 
    0.06958312f, 0.03831447f, 0.10951028f, -0.10053677f, -0.11922801f, -0.00796933f, 0.04111213f, -0.05505599f, 
    -0.21595205f, 0.06077614f, -0.19257124f, 0.08742113f, 0.02604691f, -0.10194129f, -0.33423662f, 0.16600312f, 
    0.02918730f, -0.10852169f, -0.01852994f, -0.02181653f, 0.05507289f, -0.21610807f, 0.36029056f, 0.50422001f, 
    0.06475867f, 0.22330421f, -0.00350194f, 0.16856678f, -0.01105278f, 0.00745749f, -0.08843385f, -0.04171338f, 
    -0.30052769f, 0.36938709f, 0.34602574f, 0.00299706f, 0.12592803f, 0.08706439f, 0.05433345f, 0.21166195f, 
    -0.08533446f, 0.01761963f, 0.03111445f, 0.00357087f, 0.00019951f, -0.02329958f, -0.00342297f, 0.25504178f, 
    -0.10201970f, 0.10033496f, 0.19818640f, 0.04194995f, 0.02832276f, 0.05626396f, 0.06541655f, -0.12052105f, 
    -0.19511896f, -0.10086174f, 0.18636772f, 0.16656344f, 0.06675868f, 0.01333149f, 0.19209224f, 0.09688392f, 
    -0.04868171f, -0.03808039f, -0.09595159f, -0.07269765f, -0.20803477f, -0.24559030f, -0.16700017f, -0.23034838f, 
    0.00959889f, 0.08798578f, -0.06702326f, -0.08252029f, 0.00806267f, 0.03182288f, -0.07946906f, 0.00653766f, 
    -0.08304965f, -0.17045709f, -0.14551273f, -0.09307463f, 0.11440126f, 0.03953044f, -0.08939270f, 0.04199388f, 
    -0.11411563f, -0.08122790f, -0.14059733f, -0.08086090f, -0.19381112f, -0.27486897f, 0.48136714f, 0.01635433f, 
    -0.00491694f, 0.03181659f, -0.15515321f, 0.05828516f, 0.04551569f, -0.08538847f, 0.05569371f, 0.08712304f, 
    -0.15668866f, 0.09550484f, -0.04167628f, 0.23612514f, -0.01253166f, -0.13047881f, 0.17585240f, -0.02086589f, 
    0.13212810f, -0.03612738f, 0.10282172f, 0.11721115f, 0.16904068f, -0.05637953f, 0.21882352f, 0.00842183f, 
    0.25505248f, 0.17955472f, 0.02352390f, 0.28243983f, -0.09375671f, -0.02411615f, -0.03251040f, 0.00042380f, 
    -0.31545249f, -0.09704130f, 0.30221981f, -0.32138959f, 0.04739136f, -0.14101772f, 0.13557233f, 0.03933113f, 
    0.05643743f, 0.12465711f, -0.14027944f, -0.01465824f, -0.11494672f, 0.07170965f, 0.09667789f, 0.15105265f, 
    -0.11579543f, -0.06569964f, 0.01517650f, 0.02076417f, 0.05658902f, 0.00031992f, -0.02951662f, 0.07590841f, 
    0.04760240f, 0.12925491f, -0.23763403f, 0.12900501f, 0.06437925f, -0.05026305f, 0.15847167f, 0.23424682f, 
    0.05083330f, 0.08159052f, 0.07320485f, -0.05866049f, -0.04226956f, -0.11436569f, -0.18180853f, -0.21247078f, 
    0.03380455f, 0.01578386f, 0.01196722f, -0.06415603f, 0.01373445f, -0.01335309f, -0.11464184f, -0.11575443f, 
    -0.05680212f, -0.17041710f, -0.00684774f, -0.12831163f, 0.05854221f, -0.05521516f, -0.07149120f, -0.08797084f, 
    -0.01160564f, -0.08542620f, -0.03818341f, 0.01985468f, -0.08996554f, -0.25684497f, -0.09859305f, -0.13257602f, 
    0.02271437f, -0.02382319f, -0.00354182f, -0.12714763f, -0.10465061f, -0.10639028f, 0.10448952f, -0.05033170f, 
    -0.04446321f, -0.27514163f, -0.01934728f, -0.36384252f, -0.04861124f, 0.00121847f, 0.03306537f, 0.00803229f, 
    0.03081723f, -0.05217322f, -0.05924410f, -0.11121049f, 0.08669651f, 0.18014957f, 0.02058444f, 0.06743557f, 
    0.07545092f, 0.28266913f, 0.03814799f, 0.09635415f, 0.05947609f, -0.03711219f, -0.00853883f, 0.14722204f, 
    0.24342249f, 0.05604864f, 0.26571649f, -0.04972323f, -0.06673857f, -0.04268158f, -0.02299991f, 0.15198743f, 
    -0.01964019f, -0.00870332f, 0.00313376f, -0.01303789f, -0.35453993f, 0.03473883f, -0.18244039f, 0.04289793f, 
    0.15159389f, -0.00144218f, 0.03249003f, -0.17466415f, 0.02389812f, -0.00339413f, 0.01322242f, 0.08233182f, 
    0.05635840f, -0.08316568f, 0.16170765f, 0.10338384f, 0.01340220f, 0.03267468f, -0.05481740f, -0.03436726f, 
    -0.01954596f, 0.04838460f, 0.00685254f, 0.01602634f, 0.35454813f, -0.24051915f, -0.13819914f, -0.31343791f, 
    -0.06173677f, 0.14802663f, -0.08221336f, 0.03491375f, 0.05760385f, 0.10808816f, 0.03155284f, -0.17944555f, 
    0.15127943f, 0.12294657f, 0.01380137f, -0.09491310f, 0.03005369f, -0.09257487f, -0.01810227f, 0.04353072f, 
    0.13514118f, 0.11212029f, -0.05037512f, -0.10478489f, 0.04281243f, 0.06277726f, -0.28838199f, -0.07158159f, 
    -0.07271862f, 0.10257247f, -0.05589420f, 0.04769966f, 0.05199294f, 0.06973974f, -0.08505507f, 0.14808993f, 
    0.24711396f, 0.11227892f, 0.28746969f, 0.16790555f, -0.01690288f, -0.18146369f, -0.04896144f, 0.19705215f, 
    0.01708121f, -0.04199578f, 0.12253578f, 0.09905969f, -0.18978617f, -0.56148660f, 0.21381415f, -0.15320852f, 
    -0.04318997f, -0.09037527f, -0.03386690f, 0.11010519f, -0.02299280f, 0.08593080f, 0.09304120f, -0.00860556f, 
    0.12276752f, -0.06623585f, 0.34263203f, 0.09794088f, 0.01869103f, -0.08331445f, -0.08265007f, 0.01260206f, 
    0.08814387f, 0.06417771f, 0.03378094f, 0.01200968f, -0.24073493f, 0.27535254f, -0.10231074f, 0.21392368f, 
    -0.00866023f, 0.15626432f, 0.02948084f, -0.00638984f, 0.10436791f, 0.08613022f, 0.16096075f, 0.15815508f, 
    -0.08286192f, 0.14747655f, -0.15471433f, -0.06179019f, -0.05224388f, 0.02885292f, 0.02781437f, 0.01960780f, 
    0.00556479f, 0.04576204f, -0.05679683f, 0.01031984f, -0.02915209f, -0.59563684f, -0.07144244f, -0.23830119f, 
    -0.04438920f, -0.02620313f, 0.03433559f, -0.07282683f, -0.08915254f, -0.06458655f, -0.02675404f, -0.07463242f, 
    -0.21593125f, -0.32504979f, -0.19472878f, 0.00776049f, 0.00284639f, -0.03978049f, -0.12326316f, 0.01400084f, 
    -0.02679769f, -0.26072749f, 0.00910219f, -0.06792678f, 0.45317987f, 0.31062150f, 0.44144955f, -0.27257672f, 
    -0.03794836f, 0.06908351f, 0.12042867f, 0.12969232f, 0.04896712f, -0.13109516f, -0.00006653f, 0.02002000f, 
    0.11909230f, 0.33007631f, 0.18575738f, 0.13133065f, 0.01726293f, -0.03762739f, -0.09932642f, -0.07217518f, 
    -0.03258067f, 0.02258903f, 0.01460295f, -0.07006264f, -0.08180304f, -0.33195767f, -0.05410798f, -0.24500957f, 
    -0.03471646f, -0.06532046f, -0.07850676f, 0.19692010f, 0.07925343f, -0.00115319f, -0.05400448f, 0.00299218f, 
    0.25194526f, 0.03493848f, -0.18668653f, -0.20356968f, -0.07278082f, 0.07842913f, 0.00109343f, 0.08762193f, 
    -0.06625000f, 0.12621100f, 0.05144858f, -0.03255919f, 0.26825967f, 0.30973440f, 0.34938118f, 0.19982612f, 
    0.01288809f, -0.04249778f, 0.06332392f, 0.03247589f, -0.04561413f, -0.06818883f, 0.05507743f, 0.07563932f, 
    0.27059054f, 0.06498044f, -0.22761504f, -0.21589963f, -0.00004260f, -0.04985347f, 0.05623481f, -0.00531098f, 
    0.03965089f, -0.02472088f, -0.11661748f, -0.07535291f, -0.43228266f, -0.40376270f, -0.43424746f, -0.26017600f, 
    0.02585582f, -0.01721724f, -0.09776913f, -0.12395854f, 0.02452411f, 0.05017640f, 0.00027217f, -0.05556307f, 
    -0.23877226f, -0.10322589f, -0.28654677f, -0.11076726f, 0.17079690f, 0.11990084f, 0.05557620f, -0.06609498f, 
    0.08288722f, 0.01589922f, -0.07892200f, 0.07583574f, 0.36625275f, -0.54372638f, -0.25085732f, -0.30961648f, 
    0.01312356f, 0.04491015f, 0.04166217f, -0.05217954f, -0.12436725f, 0.06599399f, -0.06493671f, -0.09100199f, 
    0.11710888f, -0.07555136f, -0.17353769f, -0.21330830f, 0.03044037f, 0.06149065f, 0.03679696f, 0.08629237f, 
    0.14381360f, 0.05980401f, -0.24859771f, -0.03385343f, 0.31683314f, 0.01731389f, 0.27457017f, -0.02040473f, 
    -0.03078767f, -0.04122478f, 0.25846937f, -0.06750347f, -0.07188798f, -0.13388868f, 0.01209615f, 0.11813817f, 
    -0.09684417f, -0.01724015f, 0.14928275f, 0.04569360f, 0.07431320f, 0.01633538f, 0.02974981f, 0.06379858f, 
    0.04840429f, -0.11300159f, -0.00035065f, 0.01550303f, 0.29332879f, 0.36081499f, 0.22737497f, 0.22319989f, 
    0.09776769f, -0.08345896f, 0.15620874f, 0.19943449f, -0.01563996f, -0.01695373f, 0.05791408f, 0.02336541f, 
    0.03574521f, 0.10769197f, -0.42832142f, 0.09054474f, -0.17381568f, -0.00998223f, -0.03954133f, 0.00879643f, 
    0.12362909f, -0.04180329f, -0.05649258f, -0.16991723f, -0.27782455f, -0.00372235f, -0.32413417f, -0.17449623f, 
    0.03350177f, 0.03808671f, -0.06329393f, -0.10674998f, -0.02061842f, 0.14343233f, -0.03217893f, 0.11831646f, 
    -0.01294126f, 0.02033031f, 0.15440588f, -0.06442699f, -0.01265202f, 0.14865534f, 0.06859589f, -0.11440809f, 
    0.08209137f, 0.16584909f, 0.09721804f, 0.30517006f, -0.02382634f, -0.13883978f, 0.21747200f, -0.04327365f, 
    -0.08589114f, 0.18371284f, 0.01904229f, 0.03409098f, 0.13553306f, 0.16982770f, 0.16359113f, 0.26391971f, 
    -0.29095110f, 0.10901595f, 0.08043346f, -0.24126400f, 0.03939451f, -0.07398064f, 0.03836272f, -0.01505906f, 
    0.19572617f, 0.00237582f, 0.06206844f, 0.04554589f, -0.12108967f, -0.09473056f, -0.13333888f, 0.04195817f, 
    -0.18864642f, 0.00625459f, -0.06434892f, 0.21536000f, 0.22839144f, 0.08509919f, 0.05137525f, 0.11037589f, 
    0.10559222f, -0.00095740f, 0.18265536f, -0.29286143f, -0.23286280f, -0.23591280f, 0.05005471f, 0.21136329f, 
    0.01096103f, 0.04674810f, 0.13502735f, -0.16204374f, -0.25877264f, 0.09538674f, -0.10886435f, -0.03334251f, 
    0.00779063f, -0.03115626f, -0.14432098f, -0.17080037f, -0.21826734f, 0.08703034f, -0.24424426f, -0.08418186f, 
    0.46960101f, -0.06747418f, 0.29901776f, 0.30891752f, -0.05986805f, -0.08897763f, 0.00264838f, -0.18005584f, 
    0.20090280f, 0.01875803f, 0.02549599f, 0.11583697f, 0.24711172f, -0.48842013f, -0.01167099f, -0.29093468f, 
    0.08853377f, 0.24016875f, 0.07882301f, -0.20054586f, 0.01473310f, -0.15811878f, -0.24191578f, 0.10300540f, 
    0.32447895f, -0.09591671f, 0.01202319f, -0.06496925f, -0.04937026f, -0.05364202f, -0.14781997f, 0.00841249f, 
    -0.06075959f, -0.03451379f, 0.10870662f, -0.24717565f, -0.38444161f, 0.59794772f, -0.11260331f, 0.29661587f, 
    0.03863175f, 0.00226706f, 0.16968483f, 0.01911778f, -0.20589769f, 0.02175996f, -0.14746359f, -0.12132591f, 
    0.19447720f, 0.03471383f, 0.16467816f, 0.22268347f, -0.05708160f, 0.10631078f, -0.21187258f, -0.05357358f, 
    0.10814316f, -0.17054081f, -0.15859902f, 0.09252933f, 0.10925311f, -0.06852026f, 0.23638655f, 0.04166367f, 
    -0.11964097f, 0.02751566f, -0.13337462f, 0.05178936f, -0.09916005f, 0.05908952f, 0.03031906f, -0.23618963f, 
    0.38704440f, -0.16213393f, 0.07962728f, 0.14481241f, -0.14655472f, 0.17839241f, 0.11637636f, -0.32721868f, 
    0.14437152f, -0.08699162f, -0.13948831f, 0.09953590f, 0.33764476f, 0.32343256f, -0.13651119f, 0.10554298f, 
    -0.01882291f, -0.07574878f, -0.15787812f, -0.06682619f, -0.02041635f, -0.09017374f, 0.09231616f, 0.06868838f, 
    0.02893597f, 0.01927124f, -0.09510873f, 0.44999075f, -0.00733622f, 0.03284129f, 0.21643704f, 0.07208726f, 
    -0.06805447f, -0.15015206f, -0.08923299f, -0.19378461f, 0.05931260f, -0.35761923f, 0.13466309f, -0.17147832f, 
    -0.01642834f, 0.11882319f, 0.13120069f, -0.10981601f, -0.28743881f, 0.04060075f, -0.17032380f, -0.20456217f, 
    0.37592694f, 0.01644115f, 0.10804754f, 0.00440259f, -0.07573550f, 0.01134153f, -0.22113432f, -0.39053458f, 
    -0.06185551f, 0.09311841f, 0.13769075f, -0.09867632f, -0.15360855f, -0.31660298f, 0.06860565f, 0.02111614f, 
    -0.22029680f, -0.01946840f, -0.03377611f, 0.25089315f, 0.16866544f, 0.03517649f, 0.12639758f, 0.02710383f, 
    -0.02985696f, -0.01242464f, -0.09520532f, 0.20081405f, 0.04328100f, -0.06523516f, 0.13119656f, -0.02293945f, 
    -0.07557943f, -0.01374946f, 0.02543108f, 0.00827986f, 0.26119730f, -0.49147442f, 0.04176259f, 0.05902538f, 
    0.02184097f, 0.13386723f, 0.07922921f, 0.11535150f, -0.09230731f, 0.06275749f, -0.12255360f, -0.15581295f, 
    -0.01099577f, -0.22623457f, 0.19924064f, -0.27513838f, -0.09898334f, -0.19149546f, -0.01126995f, 0.02945666f, 
    -0.02290673f, 0.08156678f, -0.00011035f, 0.03450628f, -0.01600294f, 0.19641843f, 0.14637008f, 0.23077025f, 
    0.07768942f, -0.10264022f, 0.01887170f, 0.19368348f, -0.01167937f, 0.14922279f, 0.12595718f, 0.15387449f, 
    -0.04315110f, -0.45210874f, -0.28644061f, -0.59647441f, 0.30613315f, -0.00300530f, -0.04475340f, 0.22555009f, 
    -0.04485138f, 0.03723138f, 0.17931119f, -0.15726376f, -0.15778242f, -0.11650424f, -0.00705485f, 0.06964842f, 
    0.10941555f, -0.03178846f, 0.03692034f, -0.08360230f, 0.04768410f, 0.07681391f, 0.03341286f, 0.07590429f, 
    -0.21438119f, -0.07239725f, -0.09078332f, 0.02743576f, 0.13502951f, 0.02902700f, 0.25752148f, 0.06905538f, 
    0.16518146f, 0.05093335f, 0.09413848f, -0.09904525f, 0.07991315f, -0.23919341f, 0.42821237f, -0.23275937f, 
    0.01314220f, -0.01650267f, -0.20853336f, -0.09715547f, 0.06168749f, 0.18461452f, 0.02357465f, -0.01620888f, 
    -0.07815601f, -0.08359846f, 0.03361838f, -0.36767569f, -0.00731441f, 0.11704625f, -0.10968880f, -0.23075035f, 
    -0.18763879f, -0.11096507f, -0.30902684f, -0.20079027f, -0.22318894f, -0.13013698f, 0.19759814f, -0.04069207f, 
    0.18376222f, -0.02177119f, 0.24321224f, -0.00800118f, -0.17782992f, -0.09266996f, -0.10236351f, -0.15920837f, 
    -0.23994033f, -0.13248198f, -0.10095287f, 0.01759077f, -0.04253010f, -0.00020009f, -0.22922096f, -0.02093860f, 
    0.18469185f, -0.00333997f, 0.13526101f, 0.32487783f, 0.01047792f, 0.12686273f, 0.12363505f, 0.21610063f, 
    -0.02584035f, 0.00376259f, 0.13096747f, 0.34077752f, 0.05339920f, 0.05661022f, -0.01672972f, -0.01301404f, 
    -0.18626541f, 0.22045745f, -0.48775086f, 0.01000540f, 0.11389816f, 0.00726512f, 0.00075072f, -0.08098934f, 
    0.14952175f, -0.04619495f, 0.07321642f, 0.00607941f, -0.22010301f, 0.27524880f, -0.31108990f, 0.25732511f, 
    0.10730113f, -0.09446483f, 0.27837729f, -0.20744199f, 0.24965538f, 0.21268359f, 0.07118266f, 0.35090703f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04724278f, -0.03094280f, 0.20292878f, -0.02426643f, 0.04985072f, -0.04910097f, -0.05739443f, -0.09529789f, 
    0.00173610f, 0.05891524f, 0.11238255f, -0.02580009f, -0.01528841f, 0.02271979f, 0.00263020f, -0.15573078f, 
    -0.02833925f, 0.18033718f, 0.02371798f, 0.26238492f, 0.04219002f, 0.17549732f, 0.02870007f, 0.05338958f, 
    0.05946643f, 0.00216112f, 0.22353788f, -0.05495197f, 0.06151240f, 0.07887249f, -0.03461704f, -0.01932080f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.10398796f, 0.11287181f, -0.04348784f, -0.42252487f, -0.43075904f, 0.07590689f, 0.13818209f, 0.11994477f, 
    0.28500059f, -0.08004916f, 0.13768849f, -0.02056574f, -0.06791785f, -0.57318020f, 0.23025586f, 0.43728182f, 
    -0.16087338f, -0.37086040f, 0.12988558f, 0.04335424f, 0.15120114f, 0.13747589f, -0.00422323f, -0.40838945f, 
    0.19524291f, -0.13313065f, -0.21333881f, 0.20102923f, -0.17995960f, -0.44355801f, 0.15437467f, -0.15657942f, 
    -0.06153254f, 0.06658200f, 0.08052845f, -0.10058131f, -0.31724903f, -0.14188074f, -0.13489363f, 0.01555829f, 
    -0.42561156f, -0.63249832f, 0.11366055f, -0.56927812f, -0.38743758f, -0.11282508f, -0.15037253f, -0.78243488f, 
    0.07189222f, -0.12042277f, -0.10976116f, 0.24303424f, 0.36196819f, 0.29982463f, 0.16300401f, 0.16004460f, 
    0.03738426f, -0.09025094f, 0.28790188f, 0.28856218f, 0.38985229f, -0.42987788f, 0.37271601f, -0.33758727f, 
    0.09543911f, -0.07108550f, 0.09936906f, -0.06995731f, -0.17561509f, 0.15543154f, 0.12474059f, 0.08027855f, 
    0.14969899f, 0.61920762f, 0.31925493f, 0.28560996f, 0.37096828f, -0.10511187f, 0.11532826f, -1.15630531f, 
    0.06156871f, 0.12512235f, 0.13088143f, 0.22276025f, 0.07628420f, -0.31201071f, -0.13510957f, 0.03334793f, 
    -0.14623582f, -0.14664562f, -0.11562236f, -0.07527938f, -0.20340358f, -0.05397560f, -0.50770694f, -0.16058245f, 
    0.07193907f, -0.09227441f, -0.79083991f, 0.17626782f, 0.37641525f, 0.00812426f, -0.00691236f, 0.39526656f, 
    0.04411000f, 0.21856177f, -0.05369162f, 0.44157588f, 0.15585731f, 0.16762038f, -0.52226782f, 0.06877214f, 
    -0.10956831f, -0.24557297f, -0.08741745f, -0.17247258f, 0.09542029f, -0.32998496f, -0.16175821f, 0.01887356f, 
    0.10496944f, 0.16634500f, -0.16524872f, 0.11448158f, -0.24107352f, 0.00665809f, 0.01073941f, -0.04336817f, 
    -0.04582684f, -0.11712217f, -0.27787983f, 0.08403344f, -0.32090795f, -0.03375014f, -0.02799158f, 0.14663760f, 
    0.12920947f, 0.36958072f, 0.16310111f, -0.56917298f, 0.33151022f, 0.08628862f, 0.32742426f, 0.19553483f, 
    0.09467721f, -0.27314514f, -0.15565889f, -0.21351357f, -0.23467268f, -0.36218807f, -0.07781663f, -0.03281811f, 
    -0.00550190f, 0.08401364f, 0.03674858f, 0.14211556f, 0.29736841f, 0.26148981f, 0.17483634f, 0.31167987f, 
    0.12791593f, 0.15518886f, -0.22179045f, 0.19927852f, -0.18341216f, 0.08196554f, 0.11492777f, -0.50562727f, 
    0.09755278f, -0.99238276f, 0.05282708f, -0.09809186f, 0.43239528f, -0.16854948f, 0.02977055f, -0.07738314f, 
    0.07134508f, 0.09537869f, -0.08709648f, 0.05437255f, -0.22830924f, 0.29911721f, -0.03339554f, -0.09115930f, 
    0.24772018f, 0.13226603f, 0.09606078f, -0.16173111f, -0.11159252f, 0.25963700f, 0.28339073f, -0.08233723f, 
    0.04214165f, -0.09309474f, 0.21142173f, 0.18577315f, 0.18056723f, -0.18028419f, 0.08631974f, -0.50918967f, 
    0.32856035f, 0.43849477f, -0.31408554f, -0.14199933f, -0.77508491f, 0.02142182f, -0.03819767f, -0.73673075f, 
    0.12215531f, -0.02901203f, -0.16923138f, 0.17212306f, -0.63829732f, 0.14833903f, 0.12273439f, -0.05708448f, 
    -0.39978945f, 0.02082300f, -0.27984175f, -0.69507873f, 0.27850962f, 0.40473551f, -0.61098891f, -0.21914448f, 
    0.03579225f, 0.07154544f, 0.06571548f, 0.10046920f, -0.34923482f, -0.10688058f, 0.01942830f, -0.01932713f, 
    -0.14188853f, -0.19731373f, -0.38298699f, 0.45154783f, 0.34519818f, 0.14178732f, -0.06546069f, 0.03271683f, 
    0.06904021f, 0.17193052f, -0.04169560f, -0.39289567f, 0.22895899f, 0.03930247f, -0.14348698f, 0.34170189f, 
    -0.28050593f, -0.13570555f, -0.31302798f, -0.80648589f, -0.25568160f, -0.17609812f, -0.28692514f, 0.56039232f, 
    -0.07497510f, -0.11156688f, -0.16831951f, 0.22131205f, 0.01073706f, -0.08166762f, -0.07380677f, -0.04610290f, 
    -0.77056587f, 0.08872857f, -0.75953186f, 0.48575816f, -0.39219466f, 0.26226887f, -0.04347985f, -0.18170321f, 
    0.06491987f, 0.00371871f, -0.15393856f, 0.25782520f, 0.36649874f, 0.12570356f, 0.11319306f, -0.20327505f, 
    0.08735584f, 0.12866719f, 0.09089994f, -0.47150329f, -0.49601895f, 0.11951097f, -0.47460070f, -0.39034411f, 
    0.13246006f, -0.00521137f, 0.16426399f, -0.19196469f, 0.15643370f, 0.04046414f, -0.03282366f, -0.87374926f, 
    0.10751907f, 0.31964216f, -0.28322387f, -0.80102038f, 0.25612801f, -0.21113181f, 0.27652603f, 0.42923591f, 
    -0.14471994f, 0.20688973f, -0.02797114f, 0.02868487f, -0.21836056f, 0.03772316f, -0.02022044f, -0.15092298f, 
    -0.39771765f, -0.05458916f, -0.01327514f, -0.10357712f, -0.17544305f, 0.14952466f, 0.36992574f, 0.67280883f, 
    0.15165161f, 0.04952854f, -0.30293870f, -0.42923993f, 0.42295566f, 0.15996394f, 0.05468889f, -0.26619551f, 
    -0.65153927f, -0.60151738f, 0.42151922f, 0.10528671f, -0.40687221f, 0.41858566f, 0.13529678f, -0.38181487f, 
    0.13946705f, 0.03363940f, -0.06789021f, 0.09560700f, -0.09407785f, -0.02642199f, -0.12021816f, -0.02060672f, 
    0.08838962f, -0.11373324f, 0.07928944f, 0.41401672f, -0.09355566f, 0.21310605f, -0.73552483f, -0.49573478f, 
    0.05591629f, -0.06184179f, -0.25105399f, 0.28908265f, 0.06027474f, 0.06929857f, -0.17275994f, 0.36267060f, 
    0.49706402f, -0.52981985f, -0.65839982f, -0.05022255f, -0.21010803f, 0.15045793f, -0.15738036f, -0.04462318f, 
    0.12094144f, 0.26305640f, -0.03530436f, 0.06257530f, 0.38784099f, -0.14497092f, -0.13153696f, -0.35264909f, 
    -0.64563137f, -0.00001611f, 0.36493799f, -0.02459470f, 0.34973496f, 0.27893916f, -0.23063727f, -0.52974391f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.16171852f, 0.12104537f, -0.11386253f, -0.26835877f, -0.13876957f, 0.02476469f, 0.01172328f, -0.25004005f, 
    0.15376297f, -0.01674988f, 0.15046133f, 0.04740223f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
