#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.05547985f, 0.03665819f, 0.07159069f, -1.31099653f, 0.84359878f, -0.85449028f, 0.33026055f, -0.23353072f, 
    0.69498962f, 0.81307787f, 0.37154156f, 0.05131447f, -0.95240420f, -1.15398908f, -0.64510763f, -0.32391667f, 
    -0.10281713f, 0.71952468f, 0.96828669f, 0.71162516f, 0.83529711f, 0.61076915f, 0.50422400f, 0.36913180f, 
    -0.47575924f, 0.58383417f, 0.14735663f, -1.00288022f, -0.77558464f, -1.33528161f, -0.68492806f, 0.47072580f, 
    1.14139903f, 0.06654371f, -0.39904970f, 0.21902399f, -1.14641595f, -0.22324133f, -0.85039127f, 0.73227102f, 
    0.96470708f, 0.20781223f, -0.25846118f, 0.46651667f, -0.50389576f, 0.58229995f, 1.11229002f, -0.98884189f, 
    0.06391176f, -0.87948728f, -0.50400716f, 0.60246271f, 0.04105097f, -0.48386726f, -1.03140724f, -0.76470053f, 
    -0.74718505f, 0.66295391f, 0.63463736f, -0.23962349f, 0.66372442f, 0.08331972f, 0.26314601f, 1.17523789f, 
    1.22970021f, 0.91818982f, -0.91025358f, 0.66438198f, -0.62861317f, -0.16922002f, -0.02117531f, 0.04986931f, 
    0.53888941f, -1.06012917f, -1.13519204f, -0.48644239f, -0.42477721f, -0.92029893f, -0.10534193f, 0.18314476f, 
    0.37609583f, 0.31054220f, 1.00444520f, -1.33791018f, 0.14965479f, -0.00768897f, 0.10255924f, 0.36892524f, 
    0.19763421f, 0.98835564f, 0.83871901f, -0.36357528f, 0.37731746f, -0.21065573f, -1.04367089f, 0.08664292f, 
    -1.07899380f, -0.53426307f, -0.79900259f, -1.02131164f, 0.06812328f, -0.97599494f, 0.02454914f, 1.16802263f, 
    0.25000119f, 0.62556988f, -0.68357372f, 0.22657576f, -1.07112861f, -1.29462886f, 0.94134355f, 0.57339275f, 
    0.46272689f, 0.66159326f, 0.34633470f, -0.53567463f, -0.12905003f, -1.03773677f, -1.50004756f, -0.47837263f, 
    0.31709233f, -0.81672692f, -0.66248143f, 0.12043951f, 0.36812213f, 0.32876375f, -0.90793496f, 1.08965611f, 
    -0.63494349f, 0.77657062f, -0.46779430f, -0.78491372f, -0.31272203f, -0.40488288f, -0.27047014f, 1.24526024f, 
    0.95929348f, 1.11087704f, -0.55878687f, -0.71510851f, 0.38886520f, -0.02769483f, -0.29904407f, -0.31506428f, 
    1.07643569f, 1.21089923f, -0.19110568f, 0.49474120f, -0.23960325f, -0.21933517f, 0.63288379f, 0.31461832f, 
    0.08608755f, 0.90121847f, 0.72750390f, 0.82740808f, 0.34372690f, -0.95614117f, 0.73239213f, -0.05590782f, 
    0.60737509f, 0.38842779f, -1.01829445f, 0.54832435f, 0.80037391f, -0.85015696f, -0.54281813f, -0.85071939f, 
    0.25520951f, 0.55420983f, 0.41954842f, 0.25538450f, 0.21453622f, 0.16721833f, -0.94734615f, -1.30859447f, 
    -0.50690585f, 0.45564246f, 0.64236939f, -0.05745805f, -1.01638365f, 0.13587070f, 0.51450044f, 0.42264700f, 
    1.33111465f, 0.54355025f, -0.27612436f, 0.06124947f, 0.24662098f, 0.87245810f, 0.09563465f, 1.46270800f, 
    0.93661666f, -0.26240671f, 0.51443225f, 0.73738956f, 0.27116689f, -0.27763695f, 1.06233442f, -0.00853489f, 
    -0.12595464f, -1.02100933f, 0.45088306f, 0.94925398f, 0.37113544f, -0.48262835f, 0.48207399f, -0.83813292f, 
    -1.03850853f, -0.11092905f, -0.78527004f, 0.83831698f, -0.69059581f, -0.40438247f, 0.34825814f, -0.43899578f, 
    -0.01962431f, 0.19407877f, 0.73487264f, -0.89775813f, 0.83682460f, 1.37211788f, -0.66806620f, 0.73224139f, 
    -0.13965602f, -0.89607304f, 1.17995763f, 0.70424098f, 0.60833949f, -0.10286825f, -0.04703912f, -0.75485981f, 
    -0.27339450f, -0.49268019f, 0.54838008f, 0.78497231f, -0.25049281f, 1.14520717f, 1.14971912f, -0.07049777f, 
    0.07873985f, 0.18850087f, -0.29311672f, -0.90266252f, -1.12867379f, -1.06118739f, 0.33788538f, 0.67980212f, 
    0.48541546f, -0.30265096f, -0.73176736f, -0.43799603f, -0.86429513f, -1.11738014f, -0.80118579f, -0.88937694f, 
    -0.94185412f, 0.35345885f, -0.15275735f, 0.44726446f, 0.22964841f, -0.03334283f, 0.31287378f, -0.01598684f, 
    0.93627238f, 0.62312537f, 0.45039564f, 0.36578080f, -0.83300471f, -0.83684832f, 1.12103069f, -1.36866558f, 
    0.06493294f, 0.98933476f, -1.11797225f, 0.84371948f, -0.00729897f, -0.59900552f, 0.18336087f, -1.60963333f, 
    0.81592578f, -0.17132659f, 0.09617501f, 0.69510806f, 0.16332665f, -0.04684472f, 0.19983466f, 0.95546103f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.04001846f, 0.02619107f, 0.41925308f, 0.08528777f, 0.26652399f, 0.20920512f, 0.01244930f, 0.25009710f, 
    0.62948316f, -0.30447099f, 0.04226176f, 0.05169708f, 0.21313009f, 0.36715001f, -0.34221259f, 0.31233159f, 
    -0.30593053f, -0.16324022f, -0.02865987f, 0.04241768f, -0.20430720f, 0.22799142f, -0.05418140f, -0.03870808f, 
    0.08661072f, 0.01874713f, -0.00950558f, 0.01088418f, 0.17140421f, 0.15290794f, -0.09755622f, 0.24288461f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04834408f, -0.02332774f, 0.00503872f, 0.00254569f, -0.05477362f, 0.02514515f, -0.03578823f, -0.03965734f, 
    0.01324347f, 0.00262088f, 0.03991890f, -0.01686943f, -0.00849543f, 0.01995257f, 0.03524505f, 0.04880569f, 
    0.02287903f, -0.05163626f, 0.03988083f, 0.01455555f, -0.03886319f, 0.04500904f, -0.04010287f, -0.05334910f, 
    0.03760517f, -0.02866703f, -0.06277993f, -0.03589309f, -0.01874650f, -0.00977008f, 0.00709863f, 0.04249378f, 
    0.02391337f, 0.01370612f, 0.03772881f, 0.01256767f, 0.02234339f, 0.02570656f, -0.05623764f, -0.02067398f, 
    0.04674947f, -0.00602443f, 0.02996775f, -0.04615371f, -0.01090838f, 0.03979280f, -0.00408672f, -0.02530160f, 
    0.01121478f, 0.03816361f, 0.01695523f, 0.04997582f, 0.05027894f, -0.03612797f, -0.00463245f, -0.00454105f, 
    0.01242543f, -0.02018941f, -0.00579871f, 0.00038641f, 0.01966317f, -0.05895728f, -0.03750724f, -0.04653633f, 
    0.02754240f, -0.01857568f, 0.04596773f, 0.00406323f, -0.03046660f, 0.01848522f, -0.04818887f, -0.02145958f, 
    -0.02936378f, 0.01567532f, -0.03148990f, -0.03643563f, -0.03997825f, 0.01708707f, 0.02249803f, -0.06552564f, 
    -0.01010379f, 0.04479904f, 0.03645165f, 0.00667728f, -0.03154524f, -0.00484289f, -0.04687864f, 0.01218224f, 
    -0.00336200f, 0.03788994f, -0.01927471f, -0.04193166f, -0.01711949f, 0.00690818f, 0.02518154f, -0.01545279f, 
    -0.01195221f, -0.05321967f, -0.00738545f, 0.01809505f, 0.02177979f, -0.00223581f, -0.03110555f, 0.03427147f, 
    -0.04665827f, -0.02156901f, -0.05006092f, -0.03166809f, 0.00548309f, -0.01135190f, 0.02727233f, -0.05475896f, 
    -0.01758206f, -0.06053899f, -0.05331371f, 0.04585527f, -0.00898322f, 0.04946719f, 0.03330056f, -0.00562664f, 
    0.02301107f, -0.05227600f, -0.04603421f, 0.04361739f, 0.00321141f, 0.01518080f, -0.03962531f, -0.02458293f, 
    -0.06092358f, -0.02739526f, 0.02302491f, 0.02282213f, -0.00029232f, 0.03863191f, 0.01248599f, 0.00602028f, 
    -0.05758447f, 0.04586234f, -0.01843162f, -0.01647335f, -0.04436531f, -0.03128649f, -0.01792540f, -0.05429479f, 
    0.01674835f, -0.04580975f, 0.02257885f, 0.03513272f, 0.00057694f, 0.01010984f, 0.03990902f, 0.01265890f, 
    0.02015981f, 0.01071837f, 0.02502517f, 0.02407211f, -0.04817424f, -0.05904869f, -0.01771245f, -0.01176903f, 
    -0.03672319f, 0.05445287f, -0.05707192f, 0.03719034f, 0.04460457f, -0.06108417f, -0.04347996f, -0.01248565f, 
    -0.05550256f, 0.03479294f, -0.02453039f, 0.00740288f, -0.03219545f, 0.02834338f, -0.02431969f, -0.05170761f, 
    -0.04059022f, -0.05348781f, -0.05749732f, 0.00643161f, -0.00680123f, 0.00835266f, 0.03016517f, 0.00406777f, 
    -0.04808277f, 0.01492708f, -0.06280167f, -0.06072943f, -0.01464427f, -0.05354793f, 0.01229709f, -0.00527482f, 
    -0.00068262f, -0.05357751f, -0.05581119f, -0.05248891f, 0.03816821f, 0.01840833f, -0.00732750f, 0.03839195f, 
    -0.00174951f, 0.01571211f, 0.03987119f, -0.03951072f, 0.02890944f, -0.02607848f, -0.05473456f, 0.02147713f, 
    0.01805646f, 0.04443884f, -0.06204779f, -0.00557556f, 0.03260846f, -0.05031077f, 0.04540472f, -0.05979672f, 
    -0.01283734f, -0.06160334f, 0.00372225f, -0.04542510f, -0.04960521f, 0.03577308f, 0.04845366f, 0.03327323f, 
    0.01545216f, -0.03026848f, -0.06362607f, 0.01637291f, -0.00212928f, -0.06362487f, -0.02421586f, -0.02393828f, 
    0.04814129f, -0.04004071f, -0.04287755f, 0.02724207f, -0.04848958f, -0.01421467f, -0.06445280f, 0.03099718f, 
    0.04283924f, -0.02607490f, 0.04268206f, -0.05801338f, 0.01707009f, -0.03939052f, -0.01939694f, -0.04816008f, 
    -0.05699963f, 0.03309096f, 0.03024534f, -0.02636205f, 0.02891657f, -0.00759918f, -0.00874358f, 0.01313948f, 
    -0.05110974f, -0.00610645f, -0.01029116f, 0.00119825f, -0.04526296f, -0.05413843f, -0.05475062f, -0.00672059f, 
    0.04287080f, -0.00127431f, -0.02338558f, 0.01008480f, -0.05895505f, -0.05994697f, 0.00260735f, 0.04969409f, 
    -0.00470017f, -0.01234993f, -0.00411520f, -0.04440235f, -0.04015864f, -0.00248213f, 0.00603475f, 0.03228153f, 
    -0.06514207f, 0.02057597f, -0.02134530f, -0.04061086f, -0.05110496f, 0.04461000f, -0.03012278f, 0.01100801f, 
    0.04908245f, 0.04514941f, -0.05405367f, 0.00328879f, 0.04219399f, -0.00693563f, -0.05578876f, 0.00504880f, 
    0.05225605f, -0.05167134f, 0.05168589f, 0.05527126f, 0.03717183f, 0.00211432f, 0.00987565f, 0.01658279f, 
    0.01045381f, 0.00180053f, -0.01354991f, -0.04421559f, -0.03889619f, -0.04255827f, -0.03864658f, -0.01041148f, 
    0.04784887f, -0.01475461f, 0.00260137f, 0.02059552f, 0.02045791f, 0.04552141f, 0.03507182f, 0.03548829f, 
    -0.04587509f, 0.02265462f, 0.04919427f, 0.03588641f, 0.03831185f, 0.02386034f, 0.00334774f, -0.01490162f, 
    -0.02099179f, -0.03182452f, 0.00994583f, -0.06110901f, 0.03902610f, 0.05167200f, -0.04159277f, -0.00261008f, 
    -0.00026109f, 0.00885006f, -0.03373993f, 0.04271282f, -0.03018299f, -0.05649707f, -0.00775913f, -0.00076296f, 
    -0.05780061f, 0.02272109f, 0.00924349f, 0.03409751f, 0.01844070f, 0.02856716f, 0.01986965f, -0.04707808f, 
    -0.00503948f, -0.00502112f, 0.04800528f, 0.04793633f, -0.01416685f, -0.05694360f, -0.02405267f, 0.03991087f, 
    0.00431154f, -0.03737188f, 0.03538374f, -0.02457474f, -0.01439294f, -0.04181773f, -0.05336933f, -0.05026740f, 
    0.04965197f, 0.05018992f, -0.00926736f, -0.00388594f, -0.00671729f, -0.05430741f, -0.06161096f, 0.03878413f, 
    -0.01388988f, -0.04074729f, -0.02748205f, 0.04689820f, -0.04126645f, -0.02555183f, -0.06206228f, -0.01367809f, 
    -0.01063874f, -0.01116544f, -0.04971346f, 0.01336621f, 0.05138066f, -0.04127515f, -0.01817355f, -0.02563944f, 
    -0.00018479f, -0.06253470f, -0.04677056f, 0.00535891f, 0.04484157f, -0.05608114f, -0.03983720f, -0.01433358f, 
    -0.01478160f, 0.03164538f, -0.02135460f, 0.00750766f, 0.01848269f, 0.00874770f, -0.05202230f, 0.05376913f, 
    -0.01785498f, 0.04856148f, 0.02916786f, -0.03283144f, -0.05972589f, 0.03996924f, -0.05668369f, 0.03295620f, 
    0.00070204f, -0.05238235f, 0.00550555f, 0.02283103f, 0.01491896f, -0.02667239f, 0.04250872f, 0.04900596f, 
    -0.05382100f, 0.04308271f, 0.03517054f, 0.04253706f, -0.03564749f, 0.03216736f, -0.04490265f, 0.01406640f, 
    -0.03612829f, 0.03193460f, -0.01271156f, -0.01362593f, -0.03764652f, 0.03123152f, -0.01232420f, -0.03412544f, 
    0.03548654f, -0.05763595f, -0.00963013f, -0.04323893f, -0.04371142f, -0.02042671f, 0.03537494f, -0.06292962f, 
    -0.00350784f, -0.01841759f, -0.05153306f, -0.02833693f, -0.05488730f, 0.02019165f, -0.06590202f, 0.00453778f, 
    -0.03184068f, 0.03205879f, 0.01682977f, -0.05433029f, -0.05796561f, -0.00709840f, 0.01515371f, 0.02472422f, 
    -0.05574759f, 0.03637420f, -0.04940720f, -0.00829947f, -0.00051958f, 0.02228381f, -0.02996120f, -0.03773620f, 
    -0.00345251f, 0.00221339f, -0.05537216f, 0.02309405f, -0.06031364f, -0.02322220f, -0.05446438f, 0.01338584f, 
    -0.04674115f, 0.04743619f, -0.03293294f, -0.01108264f, 0.03373853f, 0.02648332f, 0.00456200f, -0.01163372f, 
    -0.00229729f, -0.05429674f, -0.00303564f, 0.00384646f, -0.01158933f, -0.03965242f, 0.04953029f, 0.02939198f, 
    -0.00053833f, -0.02715451f, -0.00111937f, -0.03824504f, -0.05418720f, 0.03471867f, -0.01019103f, -0.01252893f, 
    0.02468202f, 0.04828213f, -0.05974784f, -0.02549127f, -0.00551592f, 0.01886973f, 0.03262240f, 0.04215113f, 
    0.04595811f, -0.01218393f, -0.01427015f, -0.02614392f, 0.00475614f, -0.04601400f, -0.04502467f, 0.01128631f, 
    -0.03895782f, -0.04053628f, -0.03962009f, 0.02888417f, 0.01886726f, 0.04736165f, 0.02381534f, -0.04429775f, 
    -0.06539699f, -0.04263758f, -0.05739670f, -0.01210806f, -0.03415028f, -0.04940157f, 0.01301942f, 0.00646592f, 
    0.00294742f, -0.06130982f, 0.04772048f, -0.03959218f, 0.04368789f, 0.00704834f, 0.00832366f, 0.01306789f, 
    -0.01133390f, 0.03664910f, -0.05688526f, 0.00282349f, 0.00302686f, -0.02210300f, -0.03607564f, 0.02066840f, 
    0.04112285f, 0.02586813f, 0.04318070f, 0.02972785f, -0.00628095f, -0.05280882f, 0.01443741f, -0.00265676f, 
    0.04660149f, 0.01731197f, 0.02705209f, 0.00867196f, 0.01339381f, 0.01907677f, -0.06019847f, -0.04504510f, 
    -0.00998372f, -0.05994185f, -0.02007590f, -0.06401269f, 0.00507685f, -0.01399828f, -0.01279094f, -0.02671470f, 
    -0.07847730f, 0.06160071f, 0.04262729f, -0.01043727f, -0.14352621f, 0.25559649f, -0.05146318f, -0.06995012f, 
    -0.10332111f, 0.18341811f, 0.14263761f, -0.15914097f, 0.06454906f, 0.06580824f, -0.22344649f, -0.07429498f, 
    -0.16942391f, -0.08278407f, -0.09853477f, 0.20630896f, -0.13982049f, 0.00737814f, 0.03868591f, 0.10561941f, 
    -0.10216011f, -0.03044968f, -0.20727909f, 0.15156798f, -0.29044801f, 0.35350943f, 0.28218076f, 0.16680489f, 
    0.04600453f, -0.02153837f, 0.09246976f, 0.21855503f, -0.28213641f, -0.04382269f, 0.26095197f, -0.03388481f, 
    0.14458652f, 0.13994476f, -0.04494938f, 0.00833469f, 0.04001895f, -0.13291475f, -0.04087556f, 0.18105857f, 
    -0.38094619f, -0.07018425f, -0.29074514f, 0.11181410f, 0.07690002f, 0.01247462f, -0.35366186f, -0.27107537f, 
    0.14968081f, 0.16543484f, 0.21128568f, -0.10769013f, -0.16852337f, 0.10013208f, -0.01959085f, -0.15918706f, 
    0.02757920f, -0.17389037f, -0.13761270f, -0.30773389f, 0.02096215f, -0.04330200f, 0.00688673f, -0.06130643f, 
    0.28390694f, 0.09205148f, 0.08550976f, -0.08650807f, 0.00774410f, -0.00610374f, -0.01846245f, 0.07635546f, 
    0.02466058f, -0.18612272f, 0.16736467f, -0.16354977f, -0.07635543f, 0.13456182f, 0.08340698f, -0.06116601f, 
    -0.12389836f, -0.05591377f, 0.53494543f, 0.08943277f, -0.01878120f, 0.02844744f, 0.12565048f, -0.13404910f, 
    0.07062336f, -0.00043763f, 0.04408560f, -0.25534344f, -0.08014452f, 0.04338848f, 0.09972950f, 0.19804552f, 
    -0.03032952f, -0.12475226f, -0.01809022f, 0.01597791f, 0.24955921f, 0.04157779f, -0.11865635f, 0.14656295f, 
    0.04457332f, 0.02512247f, 0.07537674f, -0.06983544f, -0.14625655f, -0.33496186f, -0.05803746f, 0.16917142f, 
    0.09988051f, -0.00631588f, 0.11707156f, 0.09413365f, 0.07268596f, 0.07863466f, 0.14663185f, 0.25080353f, 
    0.11263262f, 0.01136670f, 0.18565251f, -0.02904224f, -0.05361895f, -0.09238455f, -0.02920380f, -0.00573404f, 
    -0.05446323f, -0.00391902f, 0.07239994f, 0.02866744f, -0.13933292f, -0.02166203f, 0.02175622f, 0.00529920f, 
    -0.10921735f, 0.12561642f, 0.10112456f, -0.23705593f, 0.10473265f, -0.28891408f, -0.06922829f, -0.01174035f, 
    -0.13402165f, -0.07468624f, -0.01100232f, 0.13703868f, -0.03314080f, 0.12226135f, -0.17910102f, -0.05374594f, 
    -0.25946698f, -0.02365055f, 0.29463273f, 0.00305071f, -0.02055095f, -0.02869120f, -0.10995717f, -0.06728578f, 
    0.05627629f, -0.07691237f, 0.11485296f, 0.13877681f, 0.08983521f, -0.10189859f, -0.00669261f, -0.06107138f, 
    -0.17639242f, 0.17681316f, 0.04192098f, 0.02281296f, 0.09716685f, 0.05979823f, -0.00933767f, 0.03074720f, 
    -0.03000064f, -0.04805106f, -0.05985650f, 0.08619162f, -0.11477754f, 0.12895478f, -0.02496738f, -0.04556978f, 
    -0.05540979f, 0.03019171f, 0.01521848f, 0.04262944f, -0.18388435f, -0.08534570f, -0.02847681f, -0.02614732f, 
    -0.16259229f, -0.15380105f, -0.14232793f, 0.14114448f, 0.13878702f, -0.11889028f, -0.18884498f, -0.00037535f, 
    -0.17977126f, 0.20536572f, 0.46592766f, -0.08276533f, 0.02496778f, -0.03003118f, 0.23683609f, 0.09589037f, 
    -0.14938143f, 0.02499354f, 0.00412018f, -0.04352948f, 0.03841780f, 0.03489363f, 0.08504058f, -0.37732312f, 
    0.06627351f, 0.08060111f, 0.20678151f, -0.01359090f, -0.17748913f, -0.03461488f, 0.25048071f, -0.20854208f, 
    0.05401031f, -0.14391516f, 0.02102616f, 0.33750170f, 0.03747751f, -0.11742490f, -0.07330517f, 0.15626431f, 
    -0.07798833f, 0.03850339f, -0.22199310f, -0.01578977f, -0.15229945f, 0.42576033f, 0.16542958f, 0.20277463f, 
    0.20446168f, -0.14701973f, 0.12243868f, 0.31818068f, 0.05631761f, -0.12783885f, 0.24567531f, 0.32991478f, 
    0.17049481f, 0.12230311f, 0.07833137f, -0.12811702f, -0.14836366f, 0.01839133f, 0.25231797f, 0.14719220f, 
    -0.15392730f, -0.03898075f, 0.19411577f, -0.14779125f, -0.02649349f, -0.07201754f, 0.36195639f, 0.10617450f, 
    -0.04176551f, -0.41012159f, -0.22723289f, -0.04283544f, 0.08276580f, -0.02518587f, 0.15038298f, -0.07087988f, 
    -0.30870983f, 0.09452043f, -0.00067812f, 0.09392662f, -0.08158046f, 0.11672721f, 0.18087836f, -0.03086327f, 
    0.26641291f, 0.09245308f, -0.20453458f, -0.00917821f, 0.04714275f, -0.05966141f, -0.15676957f, -0.08313648f, 
    -0.16908522f, 0.02183526f, 0.06212301f, 0.04037385f, -0.13476036f, 0.09044022f, -0.36010510f, -0.02469051f, 
    0.22558263f, 0.04728911f, -0.27243292f, 0.10942938f, 0.17279111f, -0.01929270f, -0.00915430f, -0.03990924f, 
    -0.02727556f, 0.09358414f, 0.03914354f, 0.04452944f, 0.13237649f, 0.22704199f, -0.11129834f, -0.16356640f, 
    0.07262680f, 0.18662916f, -0.12147501f, -0.05752307f, 0.42160201f, -0.00403234f, 0.14722721f, -0.22680208f, 
    0.03182227f, 0.02354629f, -0.16406709f, 0.03137959f, 0.03291625f, -0.12176223f, -0.08648291f, -0.12447883f, 
    0.03906049f, -0.10667547f, 0.00856277f, -0.08987166f, 0.18355429f, -0.07079723f, 0.27861598f, 0.13793105f, 
    0.21070835f, -0.04546391f, 0.06110636f, -0.02720675f, 0.11628177f, 0.05744930f, 0.08396969f, -0.03927802f, 
    0.40991753f, 0.16414239f, 0.08378048f, 0.04751540f, -0.00674343f, 0.06334721f, -0.06820971f, -0.04662892f, 
    0.01418048f, -0.11073206f, -0.05919119f, -0.04098045f, 0.03290301f, -0.06398433f, -0.03733315f, -0.08179384f, 
    0.02006578f, 0.26597586f, 0.06057061f, -0.29172772f, 0.19492029f, 0.01011353f, -0.10370974f, -0.19368625f, 
    -0.14357609f, -0.38619137f, -0.25315928f, 0.25702325f, 0.16480552f, 0.02262853f, -0.11287915f, -0.03676406f, 
    -0.03761296f, 0.10579842f, 0.06578474f, -0.12305271f, 0.10708015f, 0.07401375f, -0.06954803f, -0.13798669f, 
    -0.05923712f, 0.06396896f, -0.04803780f, 0.07047864f, 0.03930708f, -0.18407187f, -0.24328586f, -0.19752920f, 
    0.04110489f, -0.08558122f, -0.15109961f, -0.05873846f, -0.11611354f, -0.05166636f, -0.31263784f, 0.21404433f, 
    -0.23553029f, -0.05114572f, -0.10156354f, 0.08700852f, -0.06633165f, 0.01454922f, 0.47518218f, 0.29689851f, 
    0.11704918f, -0.15482883f, 0.11042096f, 0.06950990f, -0.20491429f, 0.12583849f, 0.22393574f, -0.28376117f, 
    0.24329165f, 0.15734951f, 0.03437563f, 0.08091477f, -0.01067029f, 0.02868973f, 0.10604259f, 0.10513780f, 
    -0.07390402f, 0.10860107f, 0.00717379f, -0.00312833f, 0.10680885f, 0.14847772f, -0.28020561f, 0.17822297f, 
    -0.00367618f, -0.19785307f, 0.22161829f, 0.03697454f, 0.02657573f, 0.31580508f, 0.03918035f, -0.17913057f, 
    0.19033745f, 0.12845172f, 0.36944184f, -0.12545875f, -0.11376844f, -0.02142132f, -0.11919390f, -0.16222918f, 
    -0.14110339f, -0.04044725f, -0.11670277f, -0.02134165f, -0.02145649f, 0.03394797f, -0.22749732f, 0.04846971f, 
    -0.16601562f, -0.22649498f, 0.08771874f, -0.02656643f, 0.21866654f, 0.03473990f, 0.04668592f, -0.10036607f, 
    -0.20903370f, 0.11683191f, -0.02551457f, 0.09082089f, 0.03619252f, -0.08284441f, 0.21800512f, -0.01911407f, 
    0.18274595f, 0.16617231f, 0.06346579f, 0.06816219f, 0.07688976f, -0.16313034f, -0.01235774f, 0.09930918f, 
    -0.18396930f, 0.12021109f, -0.07021575f, 0.07291058f, 0.00099857f, 0.04378929f, 0.00445297f, 0.26934856f, 
    0.03981436f, 0.08699718f, -0.12040274f, 0.22107442f, -0.07658491f, -0.24641013f, -0.08239319f, 0.15028304f, 
    0.04525990f, 0.12483706f, -0.33534792f, -0.39539480f, 0.04629643f, 0.13666247f, -0.11363873f, 0.04237299f, 
    -0.00226213f, 0.58768702f, 0.06715209f, 0.07483321f, -0.03247253f, 0.20743489f, 0.11957885f, -0.13565177f, 
    0.12506074f, 0.24587347f, 0.01799693f, -0.18889873f, 0.07255950f, -0.03664683f, -0.26247761f, -0.02725991f, 
    -0.14363119f, 0.07040770f, 0.13499559f, -0.10984332f, -0.02115078f, 0.36495715f, -0.13003482f, -0.09366456f, 
    0.16389325f, 0.15394995f, -0.01238292f, 0.15442580f, 0.26644370f, -0.16180508f, 0.09799633f, -0.09164844f, 
    -0.00174522f, 0.02049644f, 0.15315600f, 0.06410120f, -0.11285914f, 0.08242589f, -0.07223989f, -0.04366319f, 
    0.10727795f, -0.02250902f, 0.07641996f, 0.06987734f, -0.05630327f, -0.01475322f, -0.21238416f, 0.08893428f, 
    -0.18700744f, 0.12499133f, 0.05216775f, -0.19826098f, -0.14367776f, 0.09278982f, -0.02019657f, 0.17770070f, 
    -0.05518982f, -0.17135832f, -0.08257881f, 0.05436108f, 0.02154663f, 0.11751015f, -0.01784329f, -0.19827315f, 
    -0.13236545f, 0.15710422f, 0.02042975f, -0.06280807f, -0.14936697f, -0.12135160f, -0.09506873f, 0.12558278f, 
    -0.00036935f, 0.11072035f, 0.13149160f, -0.16382204f, 0.15707698f, -0.03180441f, -0.17762424f, 0.20638944f, 
    0.06628513f, -0.18419845f, -0.14380667f, -0.24126847f, -0.26605245f, 0.01901977f, 0.06425224f, 0.15832511f, 
    0.03187195f, -0.01273737f, -0.13717827f, -0.15953405f, -0.01708565f, 0.27910036f, 0.00473193f, -0.03950280f, 
    0.07254183f, -0.05817844f, 0.00335058f, 0.09012880f, -0.12916148f, -0.00558139f, 0.20950209f, 0.05254386f, 
    0.03994943f, 0.05028550f, -0.27026746f, -0.04538751f, 0.17021252f, 0.18754449f, 0.29160327f, 0.23215236f, 
    0.10219754f, -0.00719619f, -0.12986161f, 0.06307203f, 0.15919666f, 0.00323279f, 0.05959987f, 0.03784880f, 
    0.05353171f, 0.01772862f, 0.17906019f, 0.00459146f, -0.36894444f, -0.08099215f, 0.01534760f, 0.25360772f, 
    0.17853637f, -0.19914892f, 0.12198450f, -0.08868729f, 0.01947121f, 0.06206418f, 0.14346059f, 0.08172239f, 
    0.13554697f, 0.11367478f, 0.02899254f, -0.06529815f, 0.02566859f, 0.01504924f, 0.16903667f, 0.16670789f, 
    0.08498111f, 0.23065528f, -0.12844378f, 0.13824728f, 0.08820280f, 0.17961261f, 0.06267595f, 0.16770346f, 
    -0.30673757f, -0.10504171f, 0.14381772f, -0.02718596f, -0.24839061f, -0.00210141f, 0.05553607f, 0.05968006f, 
    0.29543641f, 0.00822578f, 0.03816603f, -0.36498234f, -0.10949159f, 0.15779653f, 0.00461771f, 0.10724426f, 
    -0.00123498f, -0.10241279f, 0.16628341f, 0.16568655f, -0.12253762f, -0.09275182f, 0.01714233f, 0.15492530f, 
    0.09272589f, 0.04394343f, 0.15940921f, -0.08644324f, -0.11282352f, 0.17115451f, 0.07565521f, 0.13221465f, 
    -0.17593934f, 0.16435960f, -0.03764960f, 0.03503138f, -0.18312377f, -0.10262863f, -0.02811604f, -0.05889229f, 
    -0.13693129f, -0.14425649f, -0.23120996f, 0.05426754f, 0.08164092f, -0.12316398f, 0.11125410f, 0.18476638f, 
    0.11144836f, -0.50595760f, 0.18394150f, 0.01310633f, -0.06152418f, 0.19287261f, 0.07798447f, 0.03946796f, 
    -0.03718659f, -0.03611418f, 0.05352795f, 0.16605139f, 0.08811565f, -0.12943462f, -0.14726599f, 0.09562812f, 
    -0.19229782f, 0.08162061f, -0.31944135f, -0.22143880f, -0.12914790f, 0.03813028f, -0.00679498f, 0.27590716f, 
    -0.17478004f, -0.33767176f, -0.12365955f, 0.28288972f, 0.01157785f, -0.08063614f, -0.08130589f, 0.00119795f, 
    0.19945234f, -0.00116533f, -0.07659578f, -0.05539762f, 0.01587198f, -0.01198688f, -0.01092253f, 0.02487426f, 
    -0.11156914f, 0.29485118f, 0.19015464f, -0.14585885f, -0.44441476f, -0.03050276f, 0.10036761f, 0.20793398f, 
    0.00599358f, 0.12336706f, -0.05895349f, 0.07595501f, -0.16527387f, 0.01830783f, -0.23674484f, -0.48215699f, 
    0.00512134f, 0.43390572f, 0.04465709f, 0.02641885f, -0.06917407f, -0.13261701f, -0.23742349f, 0.11368165f, 
    -0.18475012f, 0.13368404f, 0.19315572f, 0.08257224f, 0.07397608f, -0.18239903f, -0.18757485f, -0.25473168f, 
    -0.00623866f, 0.08049384f, 0.04928450f, -0.28738204f, 0.10372934f, -0.02682755f, 0.07398197f, 0.15339896f, 
    -0.28470659f, 0.13099454f, 0.04067373f, -0.14509048f, 0.14864369f, 0.29185224f, 0.13532095f, -0.30977148f, 
    -0.01711706f, -0.16261013f, -0.02932601f, -0.07535267f, -0.16579215f, -0.00858698f, 0.19064413f, -0.02372111f, 
    0.00798813f, -0.01416999f, -0.29815575f, 0.03198645f, 0.05900841f, 0.33833846f, 0.20566578f, 0.10084978f, 
    0.12720731f, 0.02344396f, -0.22924694f, -0.12712534f, -0.21262105f, 0.24692591f, -0.05751890f, -0.02864445f, 
    0.09224027f, -0.11819243f, 0.04936406f, 0.42224857f, 0.13092542f, -0.10998229f, 0.07186376f, 0.07614873f, 
    0.09482102f, 0.01455435f, -0.05906948f, -0.02594931f, 0.00856019f, -0.38587263f, -0.16079792f, 0.02038852f, 
    -0.03729577f, 0.14093859f, 0.26901057f, 0.02074676f, 0.10185829f, -0.14900510f, 0.21813624f, 0.14733477f, 
    -0.07560702f, -0.08384014f, 0.04085828f, 0.15916574f, 0.06940187f, 0.03062354f, -0.23074237f, -0.18404289f, 
    0.35896340f, 0.20935886f, -0.05905789f, 0.02119463f, 0.16071229f, 0.06419983f, -0.03543723f, -0.19691297f, 
    0.04629183f, 0.02273379f, 0.01967648f, 0.02190150f, -0.01683418f, 0.02772134f, -0.01297090f, -0.05803237f, 
    -0.05926506f, -0.01889997f, -0.04029464f, -0.05575230f, -0.01729037f, 0.02232527f, 0.03847298f, 0.01789793f, 
    -0.02430071f, -0.02307345f, 0.01184851f, -0.05505997f, 0.01368602f, -0.05369456f, -0.02722908f, -0.00823290f, 
    0.00473103f, -0.00707174f, 0.01058620f, 0.01751889f, 0.00361716f, 0.00533070f, 0.00529120f, -0.04649705f, 
    0.03831163f, 0.01548490f, -0.02505318f, 0.01100367f, 0.01430108f, 0.01824694f, 0.00882869f, 0.00956143f, 
    -0.04924516f, -0.03029501f, 0.04855272f, 0.03436764f, -0.05580900f, -0.05331475f, -0.00095318f, 0.05135902f, 
    0.02329233f, 0.04380369f, 0.01401805f, 0.04409515f, 0.01654060f, -0.02354384f, 0.05223886f, -0.02845348f, 
    -0.03068683f, 0.01848896f, -0.03455807f, -0.01457749f, 0.04210024f, -0.05100422f, -0.01088617f, -0.05878756f, 
    -0.05374866f, -0.02483314f, -0.01082736f, 0.02750747f, -0.04809480f, 0.01984216f, -0.03322574f, 0.01514944f, 
    -0.04503447f, 0.03276365f, 0.04021705f, -0.04697293f, -0.00982813f, 0.03489892f, 0.01618893f, 0.02680095f, 
    0.00481551f, -0.06433225f, 0.01108200f, 0.02830539f, -0.00621634f, -0.05227107f, 0.03499341f, 0.03382586f, 
    0.00481921f, 0.02662485f, -0.00571210f, -0.00373784f, 0.05401482f, -0.01614441f, -0.05418101f, -0.03850816f, 
    -0.00407934f, -0.03312792f, -0.04494799f, 0.00257655f, 0.04982810f, 0.00789967f, -0.03689999f, 0.02737951f, 
    -0.04949464f, 0.04714245f, -0.05322440f, -0.02273080f, -0.04230101f, 0.00626841f, -0.04104306f, -0.00163196f, 
    -0.00314098f, -0.06092779f, -0.00341668f, -0.02497641f, -0.05296461f, -0.06259727f, -0.00807265f, -0.01559947f, 
    0.01812627f, -0.02911441f, -0.01864880f, -0.03761293f, -0.04140836f, -0.02465218f, -0.04423406f, -0.01181007f, 
    -0.03862515f, -0.00782448f, 0.03728247f, -0.05718103f, -0.05974892f, 0.00820655f, -0.01704176f, 0.01147588f, 
    -0.00020337f, 0.00726945f, -0.03546741f, 0.03231752f, 0.02795643f, 0.03713216f, -0.00764038f, 0.03608626f, 
    -0.01824719f, 0.00800977f, -0.02934015f, -0.06743179f, 0.03010494f, -0.06261929f, 0.00418223f, -0.01686988f, 
    -0.00061249f, -0.04596389f, -0.04132606f, -0.04607019f, -0.04022871f, 0.04425205f, -0.00783122f, -0.00392449f, 
    -0.01126112f, -0.03977605f, 0.03212199f, -0.02441492f, 0.00999313f, 0.02043069f, 0.01013361f, 0.04962186f, 
    0.01054728f, 0.03703279f, 0.02917213f, -0.01154063f, 0.01180795f, -0.01761626f, -0.04937802f, 0.00195028f, 
    -0.03479278f, 0.02664539f, -0.02629399f, -0.04030723f, 0.02669071f, 0.01269274f, -0.01452564f, -0.03043232f, 
    0.01089639f, -0.04611380f, 0.02428170f, -0.01196295f, 0.04973638f, 0.01804424f, -0.03341042f, 0.03362894f, 
    -0.04597144f, 0.03587942f, -0.04481101f, 0.01452594f, 0.03891199f, 0.02539154f, -0.00236339f, -0.01422617f, 
    -0.02961249f, -0.03081298f, 0.04486343f, 0.00838195f, -0.00421668f, 0.00230916f, -0.03298210f, -0.01881620f, 
    0.01488215f, 0.00098702f, -0.04545791f, 0.03181044f, 0.00815819f, 0.04046761f, 0.05473248f, 0.00097641f, 
    -0.04194817f, 0.03540213f, -0.05857065f, 0.02895274f, 0.01749850f, -0.04603142f, 0.01736402f, -0.05092858f, 
    -0.02579997f, -0.05016035f, 0.01760701f, -0.02581585f, 0.02646702f, -0.02355844f, 0.03900811f, -0.04483603f, 
    -0.04638248f, 0.01743048f, 0.04370359f, -0.00034015f, -0.05835718f, -0.03814754f, -0.05727549f, 0.02424297f, 
    -0.06155995f, -0.01486934f, 0.03294834f, -0.05192119f, -0.00632912f, -0.03049490f, -0.00995872f, -0.04533649f, 
    -0.03517491f, -0.01298599f, -0.03946935f, -0.03485270f, 0.00621452f, -0.02489994f, -0.01099022f, 0.03164882f, 
    0.02404979f, 0.00649018f, -0.05835399f, -0.04627812f, 0.03133595f, -0.02434814f, -0.03729671f, 0.00063995f, 
    -0.04441337f, 0.04439968f, 0.03136256f, 0.00392725f, -0.01292789f, 0.00617655f, -0.00012597f, -0.03504966f, 
    -0.03665120f, -0.04081475f, 0.02802799f, 0.01712396f, 0.01321633f, -0.04863054f, -0.05397154f, 0.03293887f, 
    0.03005202f, -0.06225302f, -0.01700112f, -0.03529621f, 0.00000479f, 0.02404982f, 0.04062082f, -0.04385820f, 
    -0.14362244f, -0.11626004f, -0.10928429f, 0.21413817f, -0.05199057f, 0.19613677f, -0.23631436f, 0.19219455f, 
    -0.31217647f, 0.49047670f, 0.19123456f, 0.22086774f, -0.22521695f, -0.50523388f, 0.15648234f, 0.13782027f, 
    -0.00178967f, -0.04393997f, -0.25631782f, -0.00717452f, 0.00596692f, -0.02640997f, 0.18758601f, 0.02449187f, 
    0.10478400f, -0.05981063f, 0.18598542f, -0.14131601f, 0.16480725f, -0.04497430f, -0.05756048f, 0.02033721f, 
    -0.17251334f, 0.18213011f, 0.19544762f, 0.06298244f, 0.18519062f, 0.22755228f, 0.01152052f, -0.01407458f, 
    -0.09419075f, -0.08936875f, -0.01811275f, 0.16805281f, 0.11429875f, 0.33147296f, -0.04758484f, -0.14092021f, 
    0.06149233f, 0.02025807f, -0.06925387f, 0.14204608f, 0.17714180f, -0.30304626f, -0.18024866f, 0.01255804f, 
    -0.12465845f, 0.01248130f, 0.00146242f, 0.05809756f, 0.11166212f, 0.09369245f, 0.10847229f, 0.20385171f, 
    -0.20144503f, -0.00154815f, -0.06706665f, 0.12663132f, 0.29396877f, 0.03600643f, 0.03600358f, 0.23254262f, 
    0.12061574f, 0.08691005f, -0.08667302f, 0.21442938f, -0.09050120f, 0.18595476f, 0.01661543f, -0.03748906f, 
    -0.11835916f, -0.33295384f, -0.26591522f, -0.06290785f, 0.10707830f, -0.11368575f, -0.08087396f, 0.15464167f, 
    -0.11350784f, -0.10667191f, -0.30285794f, -0.00001074f, -0.04117902f, 0.03553201f, -0.13300334f, 0.38086972f, 
    -0.36864257f, 0.16707085f, 0.06258794f, 0.04219422f, 0.02694485f, -0.27479619f, 0.00322307f, 0.18582734f, 
    -0.01975797f, 0.08052335f, 0.00097192f, -0.25605521f, -0.47727773f, 0.22280619f, -0.07780211f, 0.07353555f, 
    -0.00454188f, -0.01224680f, -0.19344805f, 0.26097780f, 0.01445512f, 0.14167936f, -0.08973232f, -0.39928839f, 
    -0.00261131f, 0.05146349f, 0.29495323f, -0.00604271f, 0.22490340f, -0.00715008f, -0.03975684f, -0.57532877f, 
    -0.20381252f, 0.04037289f, -0.09649936f, -0.12630881f, -0.00330362f, -0.10092135f, -0.10989895f, 0.37702078f, 
    -0.36367345f, 0.01996816f, 0.03940407f, -0.14349544f, 0.13495573f, 0.05210586f, 0.01337099f, 0.16817765f, 
    -0.04233392f, -0.26380542f, 0.14210275f, 0.03390170f, 0.04333384f, -0.10630383f, 0.25275043f, -0.11851292f, 
    -0.05420805f, -0.37826464f, -0.07665578f, 0.10503805f, 0.12713635f, -0.25316232f, 0.08602186f, 0.02901074f, 
    0.11815410f, 0.31299976f, 0.33694583f, -0.22708580f, 0.17126921f, 0.06331258f, 0.01518798f, 0.16878958f, 
    -0.08992054f, -0.08635829f, 0.23698585f, 0.39916199f, 0.18678889f, 0.04529322f, 0.01717646f, -0.16906416f, 
    0.31056213f, -0.01501708f, -0.00870486f, -0.16737087f, -0.24546772f, 0.18422771f, -0.00546276f, -0.01892066f, 
    -0.05439068f, -0.13780913f, -0.00725979f, 0.00423729f, 0.02878678f, -0.53700775f, -0.29121706f, 0.05116398f, 
    0.30829310f, -0.00551327f, 0.16727750f, 0.22413209f, 0.11390515f, 0.10116892f, -0.08695494f, -0.09249311f, 
    0.02172781f, 0.02202775f, -0.13251814f, 0.09114769f, 0.17805304f, 0.21995127f, 0.12379498f, -0.04292964f, 
    0.07930580f, 0.08398963f, -0.00572856f, -0.28418636f, -0.01117720f, 0.07766476f, -0.11725932f, -0.21054125f, 
    0.33954340f, -0.08692564f, 0.02929942f, 0.00736158f, 0.03556367f, 0.11648171f, 0.02075907f, -0.00609855f, 
    0.05971204f, -0.50333244f, -0.21709464f, 0.01555910f, 0.34387940f, -0.10543246f, 0.13440418f, -0.10326517f, 
    0.05712669f, -0.00942677f, 0.07490436f, 0.01206468f, -0.16855104f, 0.02861148f, 0.13483596f, -0.03406729f, 
    -0.11563610f, 0.01436352f, 0.03437218f, 0.18282412f, 0.23201989f, -0.06548804f, -0.01914925f, 0.05163829f, 
    -0.25419229f, 0.03950313f, 0.02564133f, 0.17832518f, -0.01364249f, 0.25430748f, -0.24895911f, 0.00386147f, 
    0.06484424f, 0.24850124f, 0.21631031f, 0.16720292f, -0.06595034f, -0.02890641f, -0.17677802f, -0.05518891f, 
    0.19386417f, 0.30547711f, 0.02999132f, 0.12733813f, 0.12767027f, 0.00695872f, -0.20316787f, -0.16997448f, 
    -0.13158947f, -0.01956913f, 0.18050168f, 0.15238993f, -0.10784326f, -0.07667527f, 0.21275793f, 0.04840732f, 
    0.01011749f, 0.03315293f, 0.11728510f, -0.05274999f, -0.07054508f, -0.09007175f, -0.15120849f, 0.14675255f, 
    0.00157129f, -0.32541558f, -0.23545107f, -0.02121311f, -0.08138393f, 0.20091568f, -0.02969605f, -0.00327153f, 
    -0.06561869f, -0.08338167f, -0.27427700f, -0.16286871f, 0.02224507f, 0.14313923f, 0.26686287f, -0.33269179f, 
    -0.08388718f, -0.01191839f, 0.22333299f, 0.23552473f, 0.03441280f, 0.09999970f, -0.10145429f, 0.06521865f, 
    -0.06325835f, 0.01938774f, 0.26933116f, 0.64643830f, -0.01289009f, 0.02305103f, 0.33436617f, -0.15299460f, 
    -0.14376776f, 0.00522082f, 0.03483516f, 0.05221966f, 0.22125363f, 0.01563170f, -0.04882446f, 0.01840730f, 
    0.04307617f, -0.13618228f, 0.24065542f, 0.14153607f, -0.16144240f, -0.28786436f, -0.41995162f, -0.10597197f, 
    -0.04670294f, -0.05327745f, 0.05080569f, 0.04710799f, 0.13608709f, -0.04505247f, 0.31908271f, 0.22261062f, 
    0.01030634f, -0.22877212f, -0.09798253f, 0.18055551f, 0.11849137f, 0.06818806f, -0.10157966f, 0.12821278f, 
    0.09820457f, 0.00791668f, -0.08286408f, -0.07785524f, 0.08777168f, -0.18146299f, 0.20585740f, 0.07311314f, 
    -0.14355595f, -0.37864670f, 0.02983257f, 0.00455355f, 0.21981819f, 0.17210762f, -0.06447618f, 0.04858605f, 
    -0.01540110f, 0.30958903f, -0.22115272f, 0.00849137f, -0.28280434f, 0.10842647f, -0.20767075f, -0.06658016f, 
    0.00026206f, -0.02087695f, -0.39250413f, -0.07710747f, 0.01562789f, -0.03011430f, 0.06596929f, 0.01495344f, 
    -0.17287803f, 0.12733112f, -0.10092574f, 0.73823643f, -0.01656404f, -0.07217372f, 0.22173195f, 0.15275395f, 
    0.20735617f, 0.04411687f, -0.07436410f, -0.12092641f, -0.03844842f, 0.25579354f, 0.15274528f, 0.10436016f, 
    0.07384922f, -0.31142449f, 0.09922503f, 0.00987194f, 0.10931186f, 0.18253426f, 0.05604053f, 0.03706800f, 
    0.09788977f, 0.09652967f, 0.05181625f, 0.04064456f, 0.10291059f, -0.00875359f, -0.31337371f, -0.51635772f, 
    -0.27117622f, 0.13319008f, 0.20353982f, 0.04027246f, -0.02838874f, -0.21133630f, -0.27704713f, -0.04112704f, 
    -0.04357864f, -0.38262597f, 0.13075209f, -0.04980440f, 0.03377831f, -0.16557808f, -0.01885579f, -0.03357894f, 
    -0.26987717f, -0.27518794f, 0.05999110f, -0.02945149f, -0.18624213f, 0.03132970f, 0.02386185f, -0.02773530f, 
    0.01526643f, -0.19574848f, -0.05903785f, -0.05210503f, 0.17097393f, -0.15427822f, 0.08742458f, -0.12272511f, 
    -0.10415862f, 0.31713217f, -0.47314641f, -0.27363580f, -0.59352666f, 0.07635245f, 0.12188408f, 0.20921887f, 
    0.06405045f, 0.01188292f, 0.04519651f, -0.38342375f, -0.15714927f, -0.06117488f, 0.05303336f, -0.00524892f, 
    0.25823060f, -0.05004644f, -0.01719761f, 0.15237850f, -0.06542159f, 0.22357187f, 0.15611409f, 0.01998378f, 
    -0.14496878f, -0.17402650f, 0.05519217f, -0.06011107f, 0.04270553f, -0.23907609f, 0.07573812f, 0.11854846f, 
    -0.18283664f, -0.05544195f, -0.03368460f, -0.11812191f, 0.10114712f, 0.15484451f, 0.01286306f, 0.02021918f, 
    -0.09593471f, 0.05332333f, -0.08430361f, 0.03120009f, 0.11524914f, -0.12798947f, 0.09100173f, -0.01803599f, 
    -0.24764910f, -0.13049899f, -0.04231226f, 0.14035641f, 0.30434209f, 0.20300907f, -0.17267121f, -0.03357302f, 
    -0.10598367f, 0.17993328f, -0.07142161f, 0.11304861f, 0.01286127f, -0.20887138f, 0.16407987f, 0.18010564f, 
    0.07634733f, 0.04948865f, -0.31964415f, -0.03059198f, 0.00041775f, 0.17190062f, -0.02455892f, 0.00262931f, 
    0.15395588f, -0.03053058f, 0.08125330f, -0.07991761f, 0.14207457f, 0.03089647f, -0.06838438f, -0.16957526f, 
    -0.14776750f, 0.09251513f, 0.13458826f, 0.50435770f, 0.14403173f, -0.02590772f, 0.12636101f, -0.09212401f, 
    -0.21730186f, 0.10242119f, 0.17283313f, -0.13743137f, 0.04562905f, -0.21396047f, -0.06756283f, 0.20514981f, 
    0.00996607f, 0.22906205f, -0.00148192f, -0.07606941f, 0.09880500f, 0.15209685f, 0.18156658f, -0.02039438f, 
    0.13184424f, 0.02144234f, -0.06341020f, 0.15177713f, 0.07690156f, -0.17834534f, -0.64921016f, 0.04591968f, 
    -0.02453135f, 0.05027297f, 0.31038719f, -0.21074043f, 0.11377448f, 0.01445916f, -0.13416892f, -0.04299745f, 
    0.29168141f, -0.09802852f, -0.15272583f, -0.02378412f, 0.22357373f, 0.01245435f, 0.06709263f, 0.08678780f, 
    -0.01373478f, 0.16695906f, 0.22118568f, 0.38631219f, -0.00358887f, 0.09435154f, -0.03633870f, -0.17353202f, 
    -0.10465816f, 0.13166507f, 0.43889505f, 0.09131818f, 0.24469584f, 0.11832260f, -0.10251123f, 0.11235593f, 
    -0.07245294f, 0.15276147f, -0.84482688f, -0.11555996f, 0.12841004f, -0.13826834f, 0.11626248f, 0.06723000f, 
    0.03414059f, -0.02045721f, -0.02013792f, 0.18304609f, -0.13312979f, -0.01672427f, -0.00117959f, 0.02949582f, 
    -0.14426991f, -0.16103946f, 0.07755610f, -0.10403844f, 0.43309698f, 0.01966859f, -0.09162671f, -0.14507936f, 
    -0.04148572f, 0.00556719f, -0.05772368f, -0.03815766f, 0.14641672f, 0.02464040f, -0.03299606f, -0.11982082f, 
    0.26318541f, 0.02400265f, 0.06808688f, 0.20890757f, -0.02143840f, -0.09846202f, 0.36380336f, 0.13266650f, 
    -0.04289615f, -0.22555459f, -0.05822228f, 0.04680316f, 0.04226476f, -0.00939898f, 0.02353027f, -0.05580192f, 
    0.25254455f, 0.15102698f, 0.05975811f, 0.12368646f, -0.03131529f, 0.12395410f, -0.29875278f, -0.00185787f, 
    0.11410852f, 0.02510335f, 0.17110905f, -0.00960687f, -0.05300105f, 0.05752447f, 0.10161781f, 0.05147678f, 
    0.21030420f, -0.05125968f, -0.35084733f, 0.16337255f, 0.11890025f, -0.00236108f, -0.08845444f, 0.06357060f, 
    -0.05820934f, -0.01822287f, -0.19149409f, 0.21497798f, 0.27017304f, 0.13012736f, 0.10284600f, -0.09624799f, 
    -0.13165297f, -0.23586836f, -0.07802273f, 0.29708111f, -0.10233836f, -0.09276678f, 0.22433490f, 0.09406593f, 
    -0.04610243f, -0.08332423f, -0.03447304f, 0.02103929f, 0.07378166f, -0.19254388f, -0.03679848f, -0.15086433f, 
    -0.00569292f, -0.05517765f, 0.13899352f, -0.11892667f, 0.03092012f, 0.13986269f, -0.14933458f, 0.26575071f, 
    -0.22061713f, -0.04394450f, -0.02669826f, 0.11534269f, 0.04303703f, 0.21218543f, 0.28681281f, -0.28239235f, 
    -0.13292535f, -0.15512271f, -0.15564269f, -0.00963063f, 0.08027533f, -0.05806728f, 0.11610892f, -0.49068773f, 
    0.17369519f, 0.35943151f, 0.03331636f, 0.07399713f, -0.11349794f, 0.02119008f, 0.05436781f, -0.03807435f, 
    -0.47618151f, -0.32356036f, -0.28959873f, 0.08472345f, 0.13257109f, 0.05281873f, 0.02184383f, -0.05245411f, 
    -0.10831106f, -0.57343602f, -0.20323403f, 0.10815954f, 0.06733771f, 0.16117477f, 0.09516633f, -0.18054819f, 
    0.26100820f, -0.07686467f, 0.47491476f, -0.00997783f, 0.16874959f, 0.02626375f, -0.10925878f, -0.04358134f, 
    0.02880689f, 0.08837105f, 0.06511767f, 0.33668560f, 0.17084688f, 0.27822435f, 0.22114879f, -0.03303454f, 
    0.00957282f, -0.00621104f, 0.22604539f, -0.07769317f, 0.42858931f, -0.00890072f, -0.21739490f, 0.00295986f, 
    -0.11444129f, 0.10585400f, 0.11242259f, -0.08903406f, -0.10761670f, -0.56006026f, -0.07248086f, -0.08439846f, 
    0.09045584f, 0.20515122f, 0.01016099f, -0.11757132f, 0.08598743f, 0.04716092f, -0.47920129f, -0.27367797f, 
    -0.03336290f, 0.19122525f, -0.18251619f, -0.10374787f, 0.08226723f, 0.00282411f, 0.00205830f, 0.21509072f, 
    -0.04623801f, -0.02339373f, -0.18212292f, -0.02474531f, 0.20712948f, -0.05122675f, -0.01868287f, -0.02470781f, 
    0.17552312f, 0.18306735f, -0.01522181f, -0.16832332f, -0.07501344f, -0.02623191f, 0.11166669f, -0.09509992f, 
    0.15251030f, 0.25105888f, 0.14266731f, -0.16371734f, -0.03238535f, 0.02121254f, 0.03481815f, -0.05243295f, 
    -0.14573655f, 0.10819058f, -0.24487719f, -0.12538537f, 0.07132839f, 0.03925846f, -0.20174341f, 0.04901209f, 
    -0.04969928f, 0.05796031f, -0.03129289f, 0.10638203f, -0.40639299f, -0.18299970f, -0.17138201f, 0.08181792f, 
    0.06275190f, -0.12978689f, 0.04666783f, 0.09687869f, -0.08759584f, -0.18553002f, 0.17169315f, -0.05606623f, 
    0.03660810f, 0.12419095f, 0.02419233f, 0.00333906f, 0.04908984f, 0.02732332f, -0.34365571f, -0.13339868f, 
    0.04515577f, 0.20705761f, 0.03820985f, -0.16995646f, 0.03090841f, -0.06428508f, 0.00225300f, 0.08039473f, 
    0.02032985f, 0.12983297f, 0.26659054f, 0.01000955f, -0.11464014f, -0.16742700f, -0.02988836f, 0.37598225f, 
    0.09820344f, -0.30020902f, -0.11898919f, 0.03538159f, -0.05350033f, 0.31326288f, 0.04514509f, -0.11930346f, 
    0.12127989f, -0.02237252f, -0.38147470f, 0.01534480f, 0.06375008f, 0.24887192f, 0.11097243f, -0.07285006f, 
    -0.18695320f, 0.13885333f, -0.08485194f, -0.10931920f, 0.28636196f, 0.01835276f, -0.07566012f, -0.00397149f, 
    -0.02124642f, 0.25994074f, -0.01323826f, 0.15401061f, 0.14911038f, 0.04856554f, 0.01075552f, 0.08394770f, 
    0.02301462f, -0.02432541f, 0.05285222f, 0.52272320f, 0.10534894f, -0.05165937f, -0.03721446f, 0.17225406f, 
    0.12148738f, 0.08532701f, -0.08002026f, 0.14956968f, -0.11061563f, -0.14771205f, -0.11616103f, -0.06132149f, 
    -0.11936034f, -0.06276071f, 0.08689100f, 0.14469241f, -0.01730451f, 0.07427187f, -0.35816893f, -0.04551822f, 
    0.07608813f, -0.00656806f, -0.04170567f, -0.09318060f, 0.03569683f, 0.13850190f, 0.01587053f, -0.18520185f, 
    0.01677899f, -0.01230360f, -0.00238831f, -0.10799463f, 0.01834417f, -0.06765494f, -0.05296188f, 0.52842975f, 
    0.19152580f, -0.11029452f, -0.07536003f, -0.00154469f, 0.12132140f, 0.02808136f, -0.04266204f, -0.16169921f, 
    0.13784805f, -0.02678461f, -0.24976052f, -0.01682741f, 0.11521244f, -0.09341000f, -0.02311838f, 0.07328381f, 
    0.02006737f, 0.12992550f, -0.14017972f, 0.13113333f, 0.17703302f, -0.11954488f, -0.08125262f, -0.11398241f, 
    0.06170596f, -0.17502946f, -0.16525556f, 0.14544050f, 0.17523916f, 0.15890190f, 0.04553486f, 0.01697883f, 
    -0.02699018f, -0.21812096f, -0.04785707f, 0.35593367f, -0.04436661f, -0.24408968f, 0.00180941f, 0.16637686f, 
    0.03481869f, -0.05634732f, 0.11773204f, -0.07811536f, -0.29871863f, 0.04653165f, 0.01911723f, -0.03402667f, 
    0.21298650f, -0.07696236f, -0.06168779f, 0.03195661f, -0.13069747f, 0.10282995f, 0.04450450f, -0.18602909f, 
    -0.09269404f, 0.07783135f, -0.04432253f, 0.00769502f, 0.00852037f, 0.03794029f, -0.46572292f, -0.31513062f, 
    -0.25011641f, -0.14834714f, -0.05099778f, 0.14107858f, 0.05014412f, 0.09046646f, -0.08479682f, 0.04277153f, 
    0.06319805f, 0.00595376f, 0.03673578f, 0.06257915f, 0.10811856f, -0.01450767f, 0.14852130f, -0.08353159f, 
    0.36398453f, -0.15146704f, 0.24062206f, -0.04842385f, -0.04737775f, 0.09563345f, -0.07608250f, -0.00260778f, 
    0.10123979f, 0.12310960f, 0.32172698f, 0.13836014f, -0.04783060f, 0.05816988f, 0.01200645f, -0.00692061f, 
    -0.03756569f, -0.00995882f, -0.37681365f, 0.09797966f, -0.13222833f, 0.02919771f, -0.00553671f, 0.05684353f, 
    0.05276968f, 0.05171232f, -0.08803005f, -0.21435970f, 0.23080038f, 0.12347159f, 0.21032938f, -0.06036791f, 
    0.05824967f, -0.11879818f, 0.12500229f, 0.16477612f, -0.38183588f, 0.10002059f, -0.02916011f, 0.01185496f, 
    0.02282175f, -0.02283631f, -0.01741510f, 0.14483790f, 0.18417250f, 0.10096309f, 0.07897047f, 0.11880986f, 
    -0.13592751f, 0.00145613f, 0.04465791f, -0.05059645f, -0.04006656f, -0.14599586f, 0.12581514f, -0.01868805f, 
    0.11262134f, -0.18019776f, -0.26957992f, -0.05827854f, 0.16291100f, 0.01617881f, -0.16037160f, 0.15500209f, 
    -0.19718295f, -0.24494699f, 0.01068437f, 0.01555380f, 0.30853137f, 0.06830596f, 0.08788195f, -0.09924647f, 
    -0.21320058f, 0.13165891f, -0.20114806f, 0.01273252f, -0.10407502f, 0.07584315f, -0.02575280f, -0.12325918f, 
    -0.09985972f, 0.27076575f, -0.23977278f, -0.06928864f, -0.08245797f, 0.18013343f, -0.08348522f, 0.19904456f, 
    0.17642318f, -0.03691138f, -0.14899412f, -0.20020807f, 0.22739786f, -0.10590205f, -0.10450646f, -0.13974369f, 
    -0.19857331f, -0.00408708f, -0.00274849f, 0.14814901f, -0.01639568f, -0.13478963f, -0.16108015f, -0.05051187f, 
    0.01346928f, 0.13156827f, 0.18552810f, 0.02598983f, -0.04003672f, 0.02474833f, 0.09728411f, -0.03978694f, 
    -0.17806502f, -0.09229518f, -0.17531280f, 0.00252764f, 0.19230345f, -0.32002094f, -0.01924847f, 0.09728969f, 
    0.12535463f, -0.07771069f, 0.06225228f, -0.03359280f, 0.18650749f, -0.25557834f, -0.33930129f, 0.27374738f, 
    -0.03763148f, -0.03670853f, 0.08454217f, -0.10604703f, 0.15290311f, -0.02738507f, -0.05982556f, -0.26171270f, 
    0.13880265f, -0.17050751f, -0.03909955f, 0.09587146f, -0.04792826f, -0.15308514f, -0.04199639f, -0.03378595f, 
    0.09749873f, 0.04317912f, -0.01056858f, -0.14217469f, -0.19945514f, 0.21701752f, 0.09080847f, -0.16629751f, 
    0.25629464f, -0.11287849f, -0.00498397f, 0.24657209f, -0.02724434f, -0.04871623f, 0.02706002f, -0.19938490f, 
    -0.28249845f, 0.24703433f, 0.08163779f, 0.14844319f, 0.19422337f, -0.05569208f, 0.04517828f, 0.14379220f, 
    0.15215476f, 0.15862355f, -0.00053113f, -0.06524885f, -0.04873620f, -0.17365952f, 0.06381164f, 0.28275165f, 
    0.04703715f, -0.01540475f, -0.02869646f, 0.03342102f, 0.18702278f, -0.12212514f, -0.24088466f, 0.02345541f, 
    0.00617024f, 0.02429936f, 0.08587366f, -0.14388812f, 0.16185620f, -0.05702098f, -0.10813460f, 0.05525641f, 
    -0.26784167f, 0.10314835f, 0.05886364f, -0.02504555f, 0.08629130f, -0.08647998f, -0.01041743f, 0.05254706f, 
    -0.06108187f, 0.07824680f, 0.14861655f, 0.10964109f, 0.14093895f, -0.00407528f, 0.03901650f, 0.06933280f, 
    0.29513541f, 0.15334257f, -0.15935458f, 0.10822026f, 0.20484965f, -0.21356572f, -0.02161904f, 0.13178760f, 
    -0.48529699f, -0.29586208f, 0.42754331f, 0.02143141f, 0.24913244f, 0.06992690f, -0.11417466f, -0.11653344f, 
    -0.14201221f, -0.31486341f, -0.30437565f, 0.06450338f, -0.24266137f, 0.06577393f, -0.05994681f, 0.08809180f, 
    -0.09321415f, 0.10640986f, -0.09157332f, 0.13517384f, 0.26724032f, 0.06247636f, -0.06119405f, 0.07624685f, 
    0.14014904f, 0.05671554f, 0.25026634f, 0.30382764f, 0.29279077f, -0.20031494f, -0.07981426f, 0.17551517f, 
    0.02381884f, 0.18682295f, -0.06990013f, -0.17479387f, -0.31452370f, -0.06535876f, 0.11507635f, 0.10224736f, 
    -0.07664067f, -0.13652103f, 0.13967805f, 0.07760897f, 0.10168941f, -0.47271329f, -0.09516240f, -0.06290703f, 
    0.12739193f, 0.10877660f, -0.09298608f, 0.19326630f, 0.27979904f, 0.06127894f, -0.01464930f, -0.08601356f, 
    -0.06396433f, 0.17917682f, -0.06447709f, 0.13317606f, 0.07293702f, -0.16118032f, 0.24656926f, 0.03470894f, 
    0.11297573f, 0.27613696f, 0.05743017f, -0.26876396f, -0.00169441f, 0.09232406f, 0.00440493f, 0.09072711f, 
    -0.19825728f, -0.15233536f, 0.03473501f, -0.08004808f, -0.07910344f, -0.05687006f, 0.02083620f, -0.05701023f, 
    -0.18843022f, 0.05411798f, 0.12880088f, 0.23273724f, 0.23809227f, -0.21986113f, -0.07390258f, -0.01895731f, 
    0.06683687f, 0.05689574f, -0.04757008f, 0.05221191f, -0.18863222f, -0.03247936f, -0.02318775f, 0.01980777f, 
    0.13057724f, 0.14056924f, 0.01337835f, 0.03247502f, -0.05328831f, 0.36615017f, -0.20624857f, -0.04198910f, 
    0.05955013f, -0.14798056f, -0.13696291f, 0.06010918f, 0.03103159f, 0.17364605f, -0.06094995f, -0.22289990f, 
    -0.02163428f, -0.10603959f, 0.11350018f, -0.10211921f, 0.11985353f, -0.06564788f, 0.21604791f, 0.24853453f, 
    0.08451255f, 0.21922942f, 0.00446339f, 0.01692370f, 0.13678539f, -0.17356631f, -0.15988514f, -0.04132746f, 
    -0.27472022f, 0.02878259f, -0.06646316f, -0.02022680f, -0.07887719f, 0.02320632f, 0.17779860f, -0.17178757f, 
    0.06237384f, 0.27075988f, 0.02619779f, 0.12322740f, 0.24223012f, -0.25780657f, -0.06699076f, -0.14823343f, 
    -0.01000785f, -0.01311884f, -0.15421149f, 0.20615996f, 0.18725997f, -0.11665592f, 0.25242701f, -0.02126584f, 
    0.26688445f, 0.12086945f, 0.03534591f, 0.07357067f, 0.06230447f, -0.15288360f, -0.13846935f, 0.00752306f, 
    0.05924971f, 0.10810944f, -0.16547656f, -0.29253241f, -0.08174908f, -0.09535159f, -0.13230477f, -0.29486677f, 
    0.05397660f, 0.11244456f, 0.10547632f, 0.27377117f, 0.00398233f, -0.13993993f, 0.00352970f, -0.09836069f, 
    0.06732428f, 0.21997602f, -0.08695728f, -0.01469928f, -0.56416649f, -0.36346573f, 0.13346376f, 0.08145839f, 
    0.10056297f, 0.03954301f, 0.07637521f, 0.00502962f, 0.19999340f, 0.27557540f, 0.05220705f, 0.01736748f, 
    -0.03901802f, -0.07258086f, -0.13065499f, 0.04851668f, 0.20479909f, 0.00648049f, -0.39404365f, -0.25945204f, 
    -0.10545772f, 0.04808147f, 0.19543292f, -0.13159412f, 0.01978858f, -0.03087506f, -0.01624358f, 0.01868253f, 
    0.11165272f, -0.08278240f, -0.11571418f, 0.18108098f, -0.12224457f, 0.14209320f, 0.22435199f, 0.18561059f, 
    -0.01961891f, -0.06134019f, -0.04169144f, -0.02186100f, -0.01191761f, 0.00850213f, -0.01944518f, -0.03459171f, 
    0.04082117f, -0.05515941f, -0.05461523f, -0.03429047f, -0.03365370f, 0.01862882f, 0.03401949f, 0.02192309f, 
    0.01261816f, -0.03187563f, -0.03788850f, -0.03346153f, -0.03253579f, -0.02801174f, -0.05039425f, 0.00786952f, 
    -0.04986880f, 0.03420841f, 0.03444973f, -0.05348717f, 0.03874915f, -0.01157268f, 0.04212299f, 0.03342156f, 
    -0.03472316f, 0.05162647f, -0.00020179f, 0.02533172f, -0.03135564f, -0.06521653f, -0.01892753f, -0.01962691f, 
    -0.01279795f, -0.05079948f, -0.02915797f, -0.05098366f, -0.00146073f, 0.02743345f, -0.02614694f, -0.01795074f, 
    -0.02572273f, -0.03884549f, -0.06472144f, -0.03730963f, 0.00245875f, 0.02472555f, 0.04898844f, -0.05413798f, 
    -0.03370686f, -0.00898785f, -0.02641628f, 0.04161091f, -0.01098272f, -0.03787642f, -0.06093918f, -0.00327814f, 
    -0.03728090f, 0.03639800f, -0.01348138f, -0.04129056f, -0.03884297f, -0.00370844f, 0.00615028f, 0.03451272f, 
    -0.04540762f, -0.04521312f, -0.03144420f, -0.00268603f, -0.04074048f, -0.04512642f, -0.03792517f, 0.02426689f, 
    -0.02392445f, -0.04993508f, -0.00415564f, -0.03348463f, 0.04559331f, -0.02321318f, 0.03767917f, 0.01890105f, 
    0.00545600f, -0.02241543f, -0.00193380f, 0.04454610f, 0.02694896f, -0.02580390f, -0.03048462f, -0.04435104f, 
    -0.05739874f, -0.04103104f, 0.00379080f, -0.05681092f, 0.04118809f, 0.02369559f, -0.04192631f, 0.02866814f, 
    0.02553983f, 0.03267865f, 0.03527292f, -0.02899247f, 0.03433326f, -0.03938530f, -0.06392555f, -0.04085713f, 
    0.00846029f, -0.03029739f, -0.05685078f, -0.01287043f, -0.03136005f, 0.01533755f, -0.00259660f, -0.04321985f, 
    0.02007036f, 0.00629854f, -0.02366447f, -0.02583088f, 0.00795702f, -0.03061416f, -0.03029260f, 0.04941853f, 
    0.02235819f, 0.03200560f, -0.04613502f, -0.01296159f, 0.01789912f, -0.02193021f, -0.04529848f, 0.03920465f, 
    -0.03755334f, 0.04499931f, -0.06629034f, 0.02043566f, -0.04924597f, -0.03255596f, 0.01160341f, -0.03131920f, 
    0.03962626f, -0.05415618f, 0.03676964f, 0.01784804f, 0.02835812f, 0.02323714f, 0.00977517f, -0.04432722f, 
    0.02030968f, -0.01464351f, 0.04987615f, -0.04749269f, 0.03780730f, -0.01567137f, -0.04372191f, 0.04062445f, 
    0.03615337f, -0.04665830f, -0.04407491f, 0.02376493f, -0.00136281f, 0.00064213f, -0.04038332f, -0.01778776f, 
    0.04610449f, -0.00355880f, 0.00341375f, -0.03337897f, -0.04349659f, 0.03368230f, 0.02103307f, 0.01069774f, 
    -0.01026763f, 0.01108785f, -0.04208650f, -0.04916424f, -0.00963441f, 0.03739719f, -0.03815897f, 0.00644544f, 
    -0.05465116f, 0.00615512f, -0.01745134f, 0.05053606f, -0.00828408f, -0.02481289f, 0.04097003f, -0.02360154f, 
    0.01446244f, -0.02661043f, -0.05362379f, 0.02350094f, 0.01510009f, -0.03101684f, -0.06296258f, -0.02360268f, 
    -0.05322948f, 0.00572921f, -0.04823082f, 0.01699278f, 0.02366698f, -0.04652412f, 0.01870235f, -0.03892126f, 
    -0.01312008f, -0.01942766f, 0.00751367f, -0.04375111f, -0.00914359f, 0.04384178f, -0.04235358f, -0.03363615f, 
    0.03917086f, 0.04471586f, -0.00504090f, -0.01450039f, 0.01085275f, 0.00475462f, -0.05459277f, -0.05127008f, 
    -0.05240116f, -0.05999496f, 0.04960497f, -0.03016308f, 0.03248990f, 0.00154193f, 0.01469443f, -0.03512158f, 
    -0.04399157f, -0.04914020f, -0.03163216f, -0.05793360f, 0.04574554f, 0.01314635f, -0.03995866f, -0.00302705f, 
    -0.04199161f, 0.05017869f, -0.01794796f, 0.00115537f, -0.06290602f, -0.04501728f, -0.03053555f, -0.06222646f, 
    -0.01895537f, -0.00989207f, -0.04211179f, 0.02999780f, 0.04150055f, 0.03999392f, 0.03753499f, 0.02800533f, 
    0.03327207f, 0.04203440f, -0.02478630f, 0.04622391f, 0.03580176f, -0.03146227f, 0.03556332f, 0.02877918f, 
    0.04573611f, 0.04764652f, -0.02428670f, -0.04524364f, 0.01347870f, 0.00370616f, -0.02380176f, -0.01467116f, 
    -0.01534312f, 0.02965751f, 0.02296924f, 0.01190110f, -0.04561990f, -0.00701209f, -0.04644580f, 0.01395124f, 
    -0.00492898f, -0.04480096f, 0.02014759f, -0.02025298f, -0.00963954f, -0.03647494f, 0.02414181f, 0.03484507f, 
    0.02494062f, -0.05593706f, -0.04476678f, 0.00284974f, 0.03990277f, 0.24975638f, 0.00292361f, -0.04128720f, 
    -0.15296109f, 0.15718974f, 0.28932467f, 0.02592083f, 0.10892978f, -0.02740559f, 0.15234515f, -0.14584656f, 
    0.19930807f, 0.21706966f, -0.50240761f, -0.20155440f, -0.14764449f, 0.00199530f, 0.02477718f, -0.02101472f, 
    0.04057464f, -0.07307151f, -0.03717455f, -0.19180331f, 0.25071743f, -0.04685822f, 0.20835926f, 0.29343373f, 
    -0.20862581f, -0.04512996f, 0.10704660f, 0.04755551f, 0.26291364f, 0.17855778f, 0.05980667f, -0.07108165f, 
    -0.29021537f, -0.09349838f, 0.24732400f, 0.08817289f, -0.08423947f, -0.00838304f, -0.16684252f, 0.08650371f, 
    -0.21924277f, -0.02752248f, 0.17657591f, -0.05448006f, 0.05261652f, -0.05388824f, 0.29602024f, 0.23095784f, 
    -0.03081960f, -0.19397612f, -0.15877779f, 0.16849075f, 0.21345684f, 0.26383859f, -0.04994801f, -0.61574090f, 
    0.05807967f, -0.13785015f, 0.12974986f, 0.11755087f, 0.09078701f, -0.22674875f, -0.05921893f, 0.04905554f, 
    0.00935850f, 0.17743760f, -0.10414874f, -0.02163629f, -0.09497166f, -0.14954479f, 0.05491929f, -0.08951358f, 
    -0.03307428f, -0.07059644f, 0.15996987f, -0.03458846f, -0.04204423f, -0.20928884f, 0.09947959f, 0.16374885f, 
    0.00813627f, 0.20235434f, -0.17184359f, -0.21779847f, 0.18766120f, 0.04983590f, 0.11938813f, 0.08631112f, 
    0.03246066f, -0.03759072f, 0.12815882f, 0.32888338f, 0.16557303f, -0.04310041f, 0.00551182f, -0.08599161f, 
    -0.08237033f, 0.23339279f, 0.06893665f, -0.05064512f, 0.19098459f, 0.23637308f, 0.07450205f, 0.09826579f, 
    -0.01259819f, 0.00354067f, 0.09609964f, 0.04593626f, 0.01324769f, -0.07829988f, 0.10796798f, -0.07557645f, 
    -0.14896923f, -0.04837864f, 0.02235276f, -0.22373241f, 0.14790754f, -0.11508405f, 0.01006951f, -0.51603633f, 
    0.00215651f, -0.06742805f, 0.02618694f, 0.04553990f, 0.05859603f, 0.09894189f, -0.09792694f, -0.47391820f, 
    -0.05892992f, -0.10036381f, -0.03559509f, 0.14429267f, 0.14326817f, 0.03094535f, -0.08739479f, -0.07187498f, 
    0.03247429f, 0.03784981f, -0.00193406f, -0.06413123f, 0.08299884f, 0.11910257f, -0.07655831f, 0.02376234f, 
    0.01547784f, -0.35507342f, -0.07752136f, -0.20927906f, -0.02121374f, 0.04367046f, 0.14403245f, -0.13355720f, 
    0.10596508f, -0.05771019f, 0.09028612f, -0.10823839f, -0.24891032f, -0.12274041f, -0.06338301f, -0.14052832f, 
    0.07530383f, 0.04822936f, 0.07124466f, 0.21542186f, 0.10047812f, -0.08212344f, -0.04326279f, -0.10762793f, 
    -0.07431099f, 0.10717324f, -0.10243691f, 0.19870006f, 0.42397785f, 0.10524455f, -0.02804254f, -0.00115613f, 
    -0.06631804f, 0.03639649f, 0.19962874f, -0.10106996f, 0.08003157f, -0.54374170f, 0.03300565f, -0.09802669f, 
    0.08955156f, 0.15720104f, -0.12324357f, -0.00796897f, -0.17769064f, 0.17171393f, -0.08465150f, -0.13851005f, 
    -0.08245146f, 0.10446872f, 0.07096969f, 0.08666338f, -0.08522018f, 0.13488711f, -0.18370657f, -0.00921239f, 
    0.11531457f, -0.24104835f, 0.23006169f, 0.10515022f, -0.01398306f, -0.00137263f, -0.09307252f, -0.11704518f, 
    -0.12687829f, -0.02697844f, -0.12133475f, 0.11452343f, 0.05655287f, -0.02984951f, -0.10408641f, 0.04942571f, 
    -0.01198026f, -0.21343848f, -0.31505907f, -0.29401052f, 0.11289527f, -0.02010637f, -0.03754470f, 0.18389803f, 
    -0.07906136f, -0.17834654f, 0.01964222f, -0.00809342f, -0.04620114f, -0.17130843f, -0.06562316f, 0.14758863f, 
    0.34494755f, -0.11275223f, 0.14961307f, 0.07260292f, 0.27818120f, -0.06175324f, -0.10737993f, -0.09153134f, 
    -0.25227621f, 0.17480575f, 0.16673814f, -0.06123837f, -0.10672124f, 0.13486469f, -0.24343440f, -0.04119758f, 
    -0.04723288f, -0.16597310f, 0.13612546f, -0.10859941f, 0.12384467f, 0.14814541f, -0.05880727f, -0.07545451f, 
    0.04659485f, 0.01335107f, -0.04182940f, 0.21977496f, 0.08318584f, -0.15768334f, -0.28864363f, 0.05903852f, 
    0.08264135f, -0.03188623f, -0.01276062f, 0.17462237f, -0.16679744f, 0.04248679f, -0.07278313f, 0.02090039f, 
    -0.17516595f, -0.00744325f, -0.26235920f, -0.13388646f, 0.04919833f, 0.14973360f, -0.10429578f, 0.22867930f, 
    0.10272785f, -0.20273036f, -0.14062279f, -0.15726566f, -0.09459579f, 0.13109800f, -0.20710665f, -0.10642003f, 
    -0.19807157f, 0.20746566f, 0.09033048f, 0.02735766f, -0.31642681f, -0.18718660f, -0.14058337f, -0.02925332f, 
    -0.09667811f, -0.00595304f, 0.02249241f, 0.01983298f, 0.01502155f, -0.07882095f, 0.02936179f, 0.15414268f, 
    0.10486074f, 0.02733063f, -0.24448486f, 0.22042024f, 0.09519053f, -0.07952315f, 0.05170424f, 0.04709328f, 
    -0.18675348f, 0.10002583f, -0.13824028f, 0.12359042f, 0.12550588f, 0.23621961f, -0.09998786f, 0.31643024f, 
    0.13018985f, 0.06214854f, 0.00885489f, 0.09053433f, 0.16823877f, -0.16351242f, 0.11229154f, 0.09423930f, 
    -0.20020618f, -0.15764147f, -0.08667045f, 0.03098420f, -0.05417595f, -0.06317914f, -0.04361305f, 0.31955710f, 
    -0.10582129f, 0.27513662f, 0.20616911f, 0.07156177f, 0.25968003f, 0.02822950f, -0.08131221f, -0.11235254f, 
    -0.26521897f, 0.09235088f, -0.35422149f, 0.08219355f, 0.04991620f, 0.16862009f, -0.04358766f, -0.02796903f, 
    -0.05209890f, 0.05870261f, 0.02569448f, -0.19906013f, 0.11846328f, 0.15990382f, 0.01265027f, -0.13162418f, 
    0.00830740f, -0.41309309f, 0.30239013f, 0.00214330f, 0.25816250f, 0.06895231f, 0.11737400f, 0.00022061f, 
    -0.14400041f, 0.11024362f, 0.29208794f, 0.02743399f, 0.03887314f, -0.43926707f, -0.20368959f, 0.16086647f, 
    0.16227660f, -0.06552545f, -0.01236617f, -0.01693661f, 0.21973808f, -0.22260593f, 0.11371306f, 0.08596946f, 
    -0.12269423f, -0.05377983f, -0.24202166f, 0.06145042f, -0.14049329f, 0.50153619f, -0.10793783f, 0.18790500f, 
    0.10863511f, -0.33442643f, -0.18358937f, 0.05951193f, -0.01133182f, -0.34687763f, -0.04362141f, 0.24385987f, 
    0.17464837f, 0.10565393f, 0.33322549f, 0.22045845f, -0.05792342f, -0.09053022f, 0.22843774f, 0.26989830f, 
    0.14532244f, -0.14898317f, 0.02139147f, -0.14179634f, 0.25436112f, 0.12428223f, 0.17458378f, 0.08950290f, 
    -0.01671219f, -0.04405830f, -0.28279620f, -0.03143603f, 0.04361032f, 0.21799874f, -0.06158480f, -0.01195952f, 
    -0.11127939f, 0.27838764f, -0.01489246f, 0.03106116f, -0.28621316f, 0.08833136f, 0.11122667f, 0.05156412f, 
    0.12218869f, -0.04482273f, 0.00339260f, -0.24599352f, -0.36550090f, -0.05773043f, -0.10048772f, 0.19519766f, 
    0.09345143f, -0.18031631f, -0.23326169f, -0.26861268f, 0.18883611f, 0.08773272f, -0.11357028f, 0.20188442f, 
    -0.00731149f, 0.05427578f, -0.05021946f, -0.20559414f, -0.26857343f, 0.09492023f, -0.09460583f, -0.05566907f, 
    -0.09515011f, -0.07708183f, 0.18905260f, -0.06860746f, 0.19554099f, 0.35469720f, -0.04154474f, 0.07832680f, 
    -0.10128739f, -0.27209440f, 0.09308551f, 0.01087586f, 0.13513078f, -0.23894140f, 0.00107150f, -0.19093303f, 
    0.05689964f, 0.34371898f, 0.15901773f, -0.06563553f, -0.11696673f, 0.01524163f, 0.21254413f, -0.03805828f, 
    -0.50170076f, -0.21873555f, -0.17142835f, -0.01947613f, -0.07131399f, 0.11366748f, -0.10096204f, -0.07230642f, 
    0.15321144f, 0.15770742f, 0.06682876f, 0.22307009f, 0.38491789f, 0.06655414f, -0.25823680f, -0.02279514f, 
    -0.39150038f, -0.10344347f, -0.22637676f, -0.24607618f, 0.06959379f, -0.20899299f, 0.20817989f, 0.20528683f, 
    -0.20401174f, 0.07191247f, 0.25042975f, 0.21555972f, -0.17386128f, 0.02639433f, 0.00828727f, 0.06747192f, 
    -0.02928371f, 0.05400037f, -0.40263546f, 0.09284004f, -0.05990161f, 0.06955174f, -0.02308582f, 0.07184496f, 
    0.16344555f, 0.33608061f, -0.00447868f, 0.27390584f, 0.24686120f, 0.12537573f, 0.17083396f, 0.23922724f, 
    -0.00084662f, -0.11884976f, 0.12940575f, 0.24414928f, 0.16282597f, -0.06304009f, 0.18761583f, 0.09795125f, 
    0.06092061f, 0.14808378f, 0.10830874f, 0.19405203f, -0.09737264f, -0.06814209f, 0.08151613f, -0.10875241f, 
    -0.01389204f, 0.21182540f, 0.00560626f, -0.03072788f, 0.09257902f, 0.16165322f, 0.20429596f, -0.39299923f, 
    -0.30980915f, -0.22138509f, -0.05459449f, 0.14408951f, 0.01153162f, -0.02533903f, -0.06885371f, 0.36476880f, 
    -0.12773067f, -0.11938859f, 0.16595958f, -0.19176425f, -0.05224308f, 0.12292933f, -0.00106825f, 0.14224739f, 
    -0.04696740f, -0.05386611f, -0.02555767f, 0.00794977f, 0.03957990f, -0.01373889f, 0.04498970f, 0.00237321f, 
    0.03499330f, -0.06357886f, 0.04315818f, 0.00297491f, 0.01449350f, -0.03083113f, 0.05091073f, -0.00576332f, 
    0.04590269f, -0.06384234f, -0.02930876f, -0.03843910f, 0.00042079f, 0.01612325f, -0.00362968f, -0.02282767f, 
    0.00239183f, 0.00337617f, -0.00710718f, 0.02180657f, 0.02346237f, -0.01777037f, -0.00245888f, -0.05012280f, 
    -0.00744338f, 0.01402133f, 0.00174455f, 0.00061753f, 0.03050385f, 0.04879829f, 0.01391405f, 0.02956185f, 
    0.00807581f, 0.01091466f, 0.00041022f, 0.05065945f, -0.04219136f, 0.02579076f, 0.01570640f, 0.01354647f, 
    -0.03701415f, -0.06022501f, 0.04067269f, -0.02258714f, -0.01092739f, 0.04513806f, -0.05469856f, -0.05981568f, 
    0.01096835f, 0.03939317f, -0.01741204f, -0.02394315f, -0.03666713f, 0.04739115f, -0.03249731f, -0.04090174f, 
    -0.03895244f, -0.05631181f, -0.03730520f, 0.02690947f, -0.02284379f, -0.04406741f, -0.06030161f, 0.00836696f, 
    -0.04764212f, -0.01218415f, -0.06099049f, 0.00445398f, 0.04285409f, 0.02217745f, 0.04444955f, -0.04079625f, 
    -0.02254805f, 0.00917630f, 0.00019516f, -0.04457310f, 0.05731385f, -0.00799496f, 0.00852365f, -0.02784603f, 
    -0.05117015f, -0.05809583f, 0.00331683f, -0.03316266f, 0.01485882f, -0.05336985f, -0.02185902f, 0.03197895f, 
    -0.03780662f, 0.01118100f, 0.01059892f, -0.04320540f, -0.00136267f, 0.00039528f, -0.01905321f, -0.00491260f, 
    -0.05388293f, 0.00622825f, -0.02608864f, 0.03223782f, -0.05436537f, 0.02727630f, -0.05330766f, -0.02337361f, 
    -0.01618808f, -0.03803815f, -0.05363397f, -0.04253514f, -0.06419790f, -0.04707871f, 0.01553044f, -0.00695463f, 
    0.00838217f, 0.00441237f, -0.03915155f, -0.02565605f, -0.05201996f, 0.00225640f, -0.03558311f, 0.00235992f, 
    0.03571985f, -0.06071147f, 0.02086537f, -0.05880710f, 0.02593926f, -0.01033970f, -0.02308264f, -0.02585090f, 
    -0.04444935f, -0.03660596f, 0.01194201f, -0.03947908f, 0.03465696f, -0.02079990f, -0.00106705f, -0.06323501f, 
    0.03428570f, -0.04754146f, 0.03040925f, -0.02206015f, -0.01566857f, -0.05923138f, 0.00044117f, 0.02199796f, 
    -0.04828773f, 0.05146544f, 0.03856688f, 0.02484517f, 0.02545829f, -0.05459111f, 0.02485450f, 0.01031161f, 
    0.04427590f, -0.03745923f, -0.00228266f, -0.03167605f, -0.04653579f, -0.05273725f, -0.04176254f, -0.05325371f, 
    -0.01885189f, 0.00698562f, -0.06033292f, 0.00295331f, -0.00519861f, -0.03466411f, 0.03889105f, -0.03263471f, 
    -0.00340211f, -0.04025522f, -0.02641151f, 0.00094835f, 0.03720530f, -0.00881032f, -0.00549196f, -0.00322749f, 
    0.03692717f, 0.02350168f, 0.04286187f, 0.04213941f, -0.05887873f, 0.01363364f, 0.04706528f, -0.00110504f, 
    0.03252358f, 0.04187639f, -0.01049284f, -0.02461066f, -0.01293682f, -0.03860926f, -0.02225256f, -0.05199934f, 
    0.03279399f, -0.00881182f, -0.00810586f, 0.00279385f, -0.01359643f, -0.02898961f, -0.01769820f, 0.02027313f, 
    0.00793515f, -0.01299272f, 0.00766089f, -0.03915515f, -0.04401295f, 0.03906607f, 0.02766566f, -0.05888081f, 
    0.01124678f, -0.02434306f, -0.05357030f, 0.04551937f, 0.04980851f, 0.04864212f, -0.00908878f, 0.03011917f, 
    -0.06119994f, 0.05028034f, 0.01039435f, -0.03832521f, 0.03737107f, -0.05107718f, -0.06460561f, -0.04561754f, 
    -0.03826090f, 0.03694095f, -0.01813738f, -0.02975952f, -0.05108219f, -0.04197041f, 0.02773132f, 0.01624129f, 
    -0.05713403f, -0.01141833f, -0.04366664f, -0.03578730f, -0.02919563f, -0.05367032f, -0.01389658f, 0.01090097f, 
    0.01537825f, -0.04816509f, 0.03302208f, 0.01476647f, 0.02459757f, -0.05350567f, -0.01522786f, 0.04309514f, 
    0.03924191f, -0.02649892f, 0.03705236f, -0.04178576f, -0.03069440f, 0.05195927f, -0.00501990f, 0.00086852f, 
    -0.01939924f, 0.04963811f, -0.06103269f, 0.00436783f, -0.03338978f, -0.05366068f, -0.05149898f, -0.02030423f, 
    -0.03491524f, -0.03609311f, 0.04802344f, 0.04589920f, 0.00616485f, 0.03779807f, -0.02298108f, -0.05013303f, 
    0.03360824f, -0.01539806f, -0.01566464f, -0.01911336f, -0.05803851f, -0.04407793f, 0.00509751f, -0.02739201f, 
    -0.03609770f, -0.02091932f, -0.05741051f, -0.02706970f, 0.03694711f, -0.03021945f, -0.00716046f, -0.03278493f, 
    -0.00121752f, 0.04734081f, -0.03513165f, -0.03181510f, -0.00244845f, 0.03662609f, -0.03285113f, 0.00473340f, 
    -0.03340597f, 0.02980877f, -0.01550909f, -0.01172558f, 0.01861183f, -0.03106291f, -0.00152954f, 0.04593221f, 
    0.03130450f, 0.01209305f, -0.02252181f, -0.03383703f, -0.05775081f, -0.02471987f, -0.00823592f, -0.03621175f, 
    0.00383049f, 0.01901422f, 0.04748520f, 0.04270540f, -0.06072275f, 0.04158696f, 0.03701025f, 0.02756669f, 
    0.03546843f, 0.03764473f, -0.04646205f, 0.01192599f, 0.04254759f, -0.05451489f, -0.00159134f, 0.03468679f, 
    0.04618834f, -0.06327951f, -0.00855767f, 0.01625797f, 0.04138207f, -0.04007448f, -0.04139325f, 0.04595291f, 
    0.03600479f, -0.05009350f, 0.00246044f, -0.05410598f, 0.03545083f, -0.04412117f, -0.01670478f, -0.03294474f, 
    -0.03514870f, 0.02469380f, -0.03578460f, -0.06087172f, -0.00446670f, -0.06530640f, -0.01209354f, -0.01800109f, 
    -0.04445408f, 0.01917564f, -0.05529442f, 0.04075827f, -0.02861626f, 0.03829405f, 0.03513150f, -0.06565713f, 
    0.04535314f, -0.03232430f, -0.00522922f, 0.01428177f, 0.04917521f, -0.01004761f, 0.05362061f, 0.02472276f, 
    -0.06676741f, -0.04144908f, 0.02151535f, -0.02051363f, -0.03448648f, 0.03571824f, 0.04444105f, -0.01688482f, 
    0.03798980f, -0.00304509f, -0.04865228f, 0.03773387f, -0.05834354f, -0.02086656f, -0.03563292f, 0.03904459f, 
    0.00727388f, -0.02723414f, 0.03512530f, 0.05028641f, -0.00092359f, -0.02136056f, 0.02844903f, -0.04025731f, 
    0.03270596f, -0.03359970f, -0.00387195f, -0.03969806f, -0.04789376f, -0.01638125f, -0.04294669f, -0.03137419f, 
    -0.02270945f, -0.01804639f, -0.01691048f, -0.01005246f, -0.01756615f, 0.00684140f, 0.03885367f, 0.05643733f, 
    -0.06275440f, -0.01171992f, 0.01117392f, -0.05829164f, -0.02550962f, -0.03214171f, 0.04795756f, 0.03594895f, 
    -0.05436574f, -0.01765899f, -0.02057131f, -0.03441255f, -0.01996368f, 0.04025819f, 0.02287034f, -0.04443626f, 
    -0.01460256f, 0.00680457f, 0.02828887f, -0.04988737f, -0.01457080f, 0.03165190f, -0.02500854f, 0.01181590f, 
    0.00030602f, 0.02707823f, 0.02230878f, 0.03979295f, 0.04592010f, 0.01582168f, 0.03130767f, -0.05167862f, 
    0.03118358f, 0.01672588f, 0.01220129f, -0.00259717f, -0.06644879f, -0.02510292f, -0.00425524f, -0.03326019f, 
    -0.03522329f, 0.04620973f, 0.01015967f, -0.00740177f, -0.04460234f, 0.04255854f, 0.04270565f, -0.02911098f, 
    -0.03084268f, -0.05306494f, 0.04028150f, -0.05461231f, -0.01429346f, -0.04746109f, 0.03597999f, 0.01298749f, 
    0.04831422f, 0.01911511f, -0.06313957f, -0.04769292f, -0.01077848f, 0.01879682f, -0.05314578f, -0.03717647f, 
    -0.03741174f, -0.03989802f, -0.02256843f, 0.02745931f, -0.03518632f, -0.03097648f, 0.00216703f, 0.01989089f, 
    -0.02101025f, -0.05603316f, 0.04040005f, -0.03428378f, -0.00005206f, 0.02504503f, 0.00825550f, 0.01241891f, 
    -0.00752963f, -0.02558809f, 0.03148944f, -0.03568745f, -0.06117771f, 0.02852143f, -0.05226518f, -0.02326887f, 
    -0.00424214f, -0.04875745f, 0.00251525f, -0.01743799f, -0.00082181f, 0.01118938f, -0.04064842f, -0.02874441f, 
    -0.04941576f, -0.05098446f, 0.01637924f, -0.00600394f, -0.06017220f, 0.03324335f, -0.01674094f, -0.06378351f, 
    -0.01324146f, -0.03903670f, -0.00236499f, -0.06015535f, 0.03329586f, -0.00589926f, -0.07008687f, 0.04407961f, 
    -0.02045365f, 0.04400673f, -0.01016324f, -0.01740212f, 0.00396979f, 0.03617707f, -0.03849826f, 0.01251481f, 
    -0.01680024f, 0.04223163f, -0.06308925f, -0.05820318f, 0.00384877f, 0.04235226f, -0.06589467f, -0.05599269f, 
    -0.05224561f, -0.02547589f, 0.00256276f, 0.01467967f, -0.06673585f, -0.01792302f, -0.04976408f, 0.00511710f, 
    -0.04091600f, -0.06143558f, -0.05078678f, -0.01479134f, -0.01322734f, 0.02481318f, -0.03870037f, -0.00868473f, 
    -0.01422954f, -0.05150956f, 0.00678314f, 0.03629287f, -0.01149393f, 0.01836093f, -0.06142009f, -0.06956727f, 
    0.02489044f, -0.01559286f, -0.04263994f, -0.03377026f, 0.03102947f, 0.02999840f, 0.04540012f, 0.04111094f, 
    -0.05682208f, -0.06071823f, -0.00153214f, 0.04051857f, 0.01086804f, -0.00957880f, -0.02220244f, -0.04213133f, 
    -0.00147211f, 0.02511650f, -0.05599872f, 0.00630365f, 0.04669499f, -0.05404302f, 0.05576650f, -0.02996253f, 
    -0.00405994f, -0.03367914f, -0.01152772f, 0.02670593f, -0.04846774f, -0.05893597f, -0.02336658f, -0.01916236f, 
    0.03807533f, 0.02637283f, 0.02007645f, -0.03842846f, -0.02539466f, 0.05668887f, 0.02293516f, 0.03129416f, 
    0.03413472f, 0.02722118f, 0.04767255f, -0.05026673f, 0.03861129f, 0.02411093f, -0.02722581f, -0.05269266f, 
    -0.02597825f, -0.00235922f, 0.00374851f, 0.04736286f, -0.02391344f, -0.05953263f, -0.00339705f, 0.01286041f, 
    0.04966826f, -0.02084394f, -0.05807283f, 0.01348053f, 0.04194451f, 0.03270591f, -0.03534292f, 0.02993561f, 
    -0.05057970f, -0.06288316f, -0.04324168f, -0.04511148f, 0.03133227f, -0.04644373f, -0.05496208f, 0.04469115f, 
    -0.04486376f, -0.05161740f, -0.03714303f, -0.05077031f, 0.05366262f, 0.04905352f, -0.05261888f, -0.04796807f, 
    0.00555084f, 0.00387275f, 0.02890535f, 0.01227229f, -0.02586328f, 0.02744930f, -0.01557106f, 0.04614609f, 
    0.02170066f, -0.03002549f, 0.03413870f, -0.02999621f, 0.03926004f, -0.03664201f, 0.00069005f, 0.03598039f, 
    -0.04379901f, -0.06017106f, 0.00827670f, -0.04127425f, -0.05844232f, -0.01357636f, 0.01587492f, -0.04658838f, 
    -0.00790146f, 0.03300340f, -0.05634421f, 0.03112697f, -0.00843919f, -0.03460729f, 0.00748815f, -0.07005377f, 
    0.01121018f, 0.00316450f, -0.05737210f, 0.03700565f, -0.04791757f, -0.06050903f, 0.03275434f, -0.03800989f, 
    -0.06583537f, 0.00981416f, -0.01760923f, -0.05943871f, 0.03597457f, 0.04013882f, -0.05343932f, 0.03731587f, 
    0.00088102f, 0.02131596f, -0.02330417f, 0.04613110f, 0.00239657f, -0.00200593f, 0.01114595f, -0.03020134f, 
    -0.06547908f, 0.01554492f, -0.00078046f, 0.05420275f, 0.01936997f, -0.05089647f, 0.00369299f, 0.03276850f, 
    -0.01740438f, -0.00570238f, 0.01439190f, -0.04309018f, -0.04759733f, -0.00593276f, -0.00515157f, 0.00078446f, 
    -0.03123628f, 0.02150880f, -0.03720731f, 0.03413261f, -0.05296277f, 0.03212225f, -0.02210804f, 0.01358001f, 
    -0.05584832f, 0.03553754f, 0.05305779f, -0.03003532f, 0.04278435f, 0.02825451f, -0.00447545f, -0.00975859f, 
    -0.05073951f, 0.04755134f, -0.04191595f, -0.05292736f, -0.00528381f, -0.04524194f, -0.01640751f, 0.04493331f, 
    -0.03894663f, -0.05204440f, 0.05114888f, -0.03894120f, 0.01203572f, -0.03858949f, -0.03262330f, -0.05530022f, 
    0.00094307f, -0.05111548f, -0.04367431f, 0.00139774f, -0.02165391f, 0.03387394f, 0.01560675f, 0.01420412f, 
    -0.04987264f, 0.00438404f, -0.06525380f, -0.03858608f, 0.00403411f, -0.00697800f, 0.05620698f, -0.03858437f, 
    0.04344423f, -0.06086247f, 0.03127473f, -0.00185278f, 0.01493994f, 0.02509607f, -0.02286935f, -0.02619353f, 
    0.04722097f, 0.02923700f, -0.05808047f, 0.02067049f, -0.02472502f, 0.04682734f, 0.04227372f, -0.02284026f, 
    0.03045920f, -0.03657807f, -0.02261043f, 0.04683156f, -0.01450874f, -0.05033367f, 0.02508891f, -0.01360686f, 
    -0.02538559f, -0.04820187f, -0.02100215f, 0.01723218f, -0.02850391f, -0.05141984f, -0.00371458f, -0.03172171f, 
    0.01289492f, -0.03012004f, -0.03487284f, -0.02293613f, 0.00053714f, 0.04682752f, -0.05622368f, 0.03789882f, 
    -0.03518776f, 0.03387066f, 0.01581377f, -0.02804897f, 0.00627301f, -0.02350136f, -0.06692540f, -0.05465922f, 
    -0.04262035f, -0.00933967f, -0.06085436f, 0.00411826f, -0.05322232f, 0.03334640f, -0.00343852f, -0.05345091f, 
    0.01185746f, 0.02494416f, 0.03403369f, 0.02717275f, -0.01943274f, -0.00202827f, 0.03573624f, -0.02929131f, 
    -0.02759097f, 0.02187472f, -0.03657544f, -0.02869825f, 0.01970596f, 0.03582262f, 0.04656787f, 0.01126791f, 
    0.02381602f, -0.00962152f, 0.02885594f, 0.02765940f, -0.02795088f, 0.01623993f, -0.01484216f, 0.00088165f, 
    0.05276273f, 0.00640300f, 0.04331629f, -0.03888712f, -0.04763038f, -0.00401184f, 0.03649537f, -0.01446156f, 
    -0.01738173f, -0.02540981f, -0.01978384f, -0.04924519f, -0.04822932f, -0.03774412f, 0.02181418f, -0.03961512f, 
    -0.07110281f, -0.15698348f, -0.19427006f, -0.07202733f, 0.17080468f, 0.07275797f, 0.20832126f, 0.01845300f, 
    -0.08306418f, -0.47599199f, 0.07871962f, -0.25529167f, -0.13672069f, 0.03331013f, 0.01394869f, 0.03180214f, 
    -0.01939946f, 0.01746976f, 0.44163266f, 0.02774655f, 0.21046385f, -0.05681034f, 0.01016062f, 0.08923016f, 
    -0.00745353f, 0.21957904f, 0.00081058f, -0.01414612f, -0.10679175f, 0.11684026f, -0.09956545f, 0.05157849f, 
    0.12001123f, -0.19662589f, -0.00786189f, -0.02784923f, -0.14486136f, -0.25472307f, -0.06253857f, 0.19657549f, 
    0.08623665f, -0.04629640f, 0.24837992f, 0.05455086f, 0.02902301f, -0.36462659f, -0.01489195f, -0.42590246f, 
    0.02488229f, 0.04729670f, -0.02197188f, -0.11391173f, 0.02090717f, 0.15999363f, 0.12327162f, -0.23563775f, 
    0.37336284f, 0.02252160f, 0.12298123f, 0.07258952f, 0.03352151f, -0.08647989f, -0.07023214f, -0.05561715f, 
    -0.08902646f, 0.12561905f, -0.00225825f, 0.13471834f, 0.00164113f, -0.04205123f, -0.14410317f, 0.02260460f, 
    -0.02476116f, 0.03434159f, 0.15896405f, -0.14905748f, 0.00830868f, 0.02646926f, -0.10344621f, -0.00407604f, 
    0.08497347f, -0.32326156f, 0.04066382f, -0.15337937f, 0.08368231f, 0.04213214f, -0.17258191f, -0.08593015f, 
    -0.17223401f, -0.02700250f, -0.08837312f, 0.16634370f, -0.06540701f, -0.00113094f, 0.03028040f, 0.09373681f, 
    -0.23871917f, -0.02023163f, 0.03202245f, -0.08522772f, -0.23389871f, -0.04197790f, 0.12546752f, 0.02391718f, 
    0.06499558f, -0.13373883f, -0.12431032f, 0.09118145f, 0.44888717f, -0.26554689f, 0.22119741f, -0.00785529f, 
    -0.07874031f, -0.07711936f, -0.02545222f, -0.02880051f, 0.02127858f, 0.28783166f, -0.03413711f, 0.53990477f, 
    0.25669324f, -0.04975273f, -0.05108663f, 0.00574990f, -0.02428718f, 0.10307843f, -0.59385049f, -0.32615137f, 
    -0.50755906f, -0.00819049f, 0.16357768f, -0.26384079f, 0.17641151f, 0.07473434f, 0.04549241f, -0.35158587f, 
    -0.07657430f, 0.35035390f, 0.01876131f, 0.09124589f, 0.02057715f, -0.03978331f, 0.05124401f, -0.01618258f, 
    -0.21224865f, 0.33622837f, 0.19112451f, -0.12540312f, -0.22712503f, -0.07335009f, 0.07019059f, -0.14527740f, 
    0.05825600f, 0.15777680f, -0.10372910f, 0.16307440f, -0.10792577f, 0.07824850f, -0.09166618f, -0.01479751f, 
    0.00320784f, 0.10067338f, -0.37750658f, 0.17547940f, -0.27460250f, 0.14444685f, 0.16937007f, -0.08414225f, 
    0.06281796f, 0.04440819f, -0.04141715f, -0.21053301f, 0.04540762f, -0.25499102f, 0.05199770f, 0.02363146f, 
    0.03649081f, 0.11777651f, -0.08109809f, 0.19421409f, 0.10784640f, -0.15148883f, -0.01080846f, -0.02816176f, 
    -0.05998717f, -0.00040392f, -0.08853039f, 0.10434292f, -0.21782179f, 0.12285685f, 0.00554371f, 0.09186177f, 
    -0.08183792f, -0.04180072f, -0.11579816f, -0.12687920f, -0.05479951f, -0.08734508f, -0.26068738f, -0.06419796f, 
    0.06406962f, 0.01358952f, -0.20881580f, 0.01654060f, -0.01329500f, -0.25127339f, 0.03143686f, 0.00194055f, 
    -0.05212723f, 0.03933312f, -0.08089507f, 0.07324716f, -0.11665690f, -0.06489272f, 0.03918611f, 0.15933123f, 
    0.08151629f, 0.17626487f, 0.13737656f, 0.05516776f, 0.04880277f, -0.10740870f, 0.03223211f, 0.08880735f, 
    -0.11634929f, -0.17883943f, -0.35401455f, -0.19964929f, 0.25409734f, 0.16277795f, -0.34437028f, 0.08481415f, 
    0.18286499f, 0.02777876f, 0.32419136f, 0.25348455f, -0.03880461f, 0.06959361f, -0.06994703f, -0.06205947f, 
    0.05847491f, 0.04216751f, 0.07485357f, 0.25193197f, -0.15955876f, 0.32355070f, 0.03844113f, -0.08500906f, 
    -0.17050031f, 0.07572820f, 0.07572763f, 0.10805605f, -0.17232758f, 0.01636479f, 0.26801646f, 0.00465644f, 
    -0.12989956f, 0.03698080f, -0.03471476f, 0.18078728f, 0.24807563f, 0.20590018f, -0.02668774f, 0.26688823f, 
    0.08462001f, -0.00436924f, 0.14092433f, 0.17343773f, -0.12541382f, 0.03488681f, 0.24829657f, 0.04238731f, 
    -0.15427217f, -0.09513299f, 0.02595811f, 0.02161491f, 0.07063622f, -0.05176295f, 0.16311671f, 0.00301757f, 
    -0.11588149f, -0.05396749f, 0.07342032f, 0.13354284f, 0.05753303f, 0.15641743f, -0.03894688f, 0.04709041f, 
    0.06218435f, 0.01216417f, 0.07956138f, 0.07683650f, 0.26949584f, -0.00333784f, -0.10389950f, -0.01934120f, 
    -0.19125812f, 0.39437556f, 0.30666593f, -0.10899017f, 0.10984151f, -0.05854343f, 0.11337467f, 0.03737217f, 
    0.04615838f, 0.10852995f, 0.14924224f, 0.21928389f, 0.15451884f, 0.01060731f, 0.19360566f, -0.22425027f, 
    0.01502568f, 0.07714618f, -0.13363241f, -0.08043066f, 0.16276862f, -0.43206561f, -0.04071974f, 0.11096306f, 
    0.21616940f, -0.05193369f, 0.03512986f, 0.06939211f, -0.15152839f, -0.44003418f, -0.13587658f, 0.26563409f, 
    0.11085856f, -0.00663163f, 0.02450971f, -0.05462597f, -0.21151711f, 0.32846683f, 0.12346791f, 0.15468927f, 
    0.10476756f, -0.06448284f, 0.06882259f, 0.19130310f, 0.05447328f, 0.13043392f, -0.26581728f, -0.15817358f, 
    -0.22712712f, 0.08350609f, 0.20889500f, -0.07657211f, 0.15274625f, -0.17756578f, -0.22448613f, 0.48824978f, 
    0.26906180f, 0.02184854f, 0.01623885f, -0.15224923f, -0.06186919f, -0.18729313f, 0.07084630f, 0.02384264f, 
    -0.09704556f, 0.07351134f, -0.40575314f, 0.08992483f, 0.10786786f, -0.05995250f, -0.05440279f, 0.09206740f, 
    -0.21365973f, -0.09436268f, 0.13167736f, 0.32528389f, -0.16270603f, -0.10697901f, -0.02560262f, -0.07742292f, 
    0.00874135f, 0.04243030f, 0.28644347f, 0.16578829f, 0.11501680f, -0.08044303f, 0.05581907f, -0.01147565f, 
    -0.17061660f, -0.04147657f, 0.14453357f, 0.03549934f, -0.19354601f, -0.07530992f, 0.08539598f, 0.12923644f, 
    0.05078460f, -0.18913239f, 0.13988613f, -0.00563135f, -0.00174110f, -0.11551565f, 0.07126961f, 0.03775772f, 
    0.01494630f, 0.21827647f, 0.20972788f, 0.07274044f, 0.09836997f, -0.11083034f, 0.03314862f, -0.45268402f, 
    0.07793918f, 0.15906700f, -0.02785088f, 0.16075009f, 0.09600944f, -0.02970066f, -0.29011101f, -0.40698689f, 
    -0.06623802f, -0.16132118f, -0.12877563f, 0.06824595f, 0.09838236f, -0.17978197f, 0.04478218f, 0.37145126f, 
    0.26331854f, 0.34738106f, -0.02050173f, -0.16588686f, -0.06755538f, 0.07084727f, -0.00742238f, 0.21676731f, 
    0.50524485f, 0.38562009f, -0.02870177f, 0.05483485f, -0.09999539f, -0.14701465f, 0.09594352f, 0.35941797f, 
    0.04339422f, 0.53575522f, 0.38368392f, 0.19777225f, -0.06575257f, -0.02986901f, -0.15039779f, 0.06513791f, 
    0.00520661f, 0.07388864f, -0.05156887f, -0.04840581f, 0.05690913f, -0.00292878f, 0.03517064f, -0.26821131f, 
    -0.07552832f, -0.07370517f, -0.03344104f, 0.35924801f, 0.29199576f, -0.07873340f, 0.08332458f, 0.12117174f, 
    0.12707487f, 0.12448045f, -0.18224597f, 0.07400666f, 0.14644919f, -0.36963552f, -0.00888714f, 0.17513806f, 
    0.18376093f, 0.15092567f, -0.04300929f, -0.15713973f, -0.09008262f, 0.50655317f, 0.00516340f, 0.14166619f, 
    0.01731084f, -0.06649498f, 0.35912067f, 0.04683952f, 0.14582887f, -0.14638425f, -0.12364493f, 0.04241669f, 
    0.29908594f, -0.23389967f, 0.10932238f, -0.10820886f, 0.09262800f, 0.08796483f, 0.03145730f, -0.21129833f, 
    -0.24108329f, -0.39064014f, 0.04657577f, 0.27316716f, -0.04353417f, 0.19113708f, -0.05782278f, 0.16484864f, 
    -0.07763207f, -0.52732813f, 0.07149886f, -0.03195553f, 0.03025671f, -0.13014141f, 0.14439099f, 0.20251058f, 
    -0.02632322f, -0.07674588f, -0.31896427f, 0.09301088f, -0.27649370f, -0.01125996f, -0.13106103f, 0.06627568f, 
    -0.11542175f, -0.01289057f, 0.08660654f, -0.01858141f, 0.05959638f, 0.12347139f, 0.39258766f, 0.14381336f, 
    -0.04610475f, 0.07584815f, -0.08436126f, 0.14667344f, -0.11647820f, -0.54983133f, 0.11338700f, -0.02671691f, 
    -0.09214181f, -0.06822501f, -0.10324641f, -0.10099063f, -0.37229756f, 0.20589529f, -0.60058194f, -0.04689371f, 
    0.14852342f, 0.00154810f, -0.09537525f, 0.12733842f, -0.09165753f, -0.12106735f, -0.25639468f, -0.07906708f, 
    0.15775275f, 0.17951286f, 0.01842588f, -0.07121173f, 0.01863518f, -0.17080721f, 0.53516471f, -0.16961384f, 
    -0.14985511f, 0.04516667f, 0.21027517f, 0.14135803f, -0.03026656f, 0.20324147f, 0.13123129f, 0.24501763f, 
    -0.41683710f, -0.14424424f, -0.20045264f, 0.02508078f, -0.00198384f, -0.12125076f, -0.15163793f, -0.09764265f, 
    -0.04136532f, 0.00312981f, -0.01685843f, -0.04802804f, -0.00973724f, -0.00556282f, -0.05017364f, -0.02979786f, 
    0.05380891f, 0.01313509f, 0.03113748f, 0.04354819f, -0.05569630f, -0.03382273f, -0.03912055f, -0.05972024f, 
    0.04412396f, -0.00205338f, 0.03891189f, -0.03523697f, 0.03949162f, -0.02884216f, -0.02702198f, -0.00467293f, 
    -0.05997135f, 0.03639989f, 0.03546751f, 0.02910704f, 0.01649467f, 0.02075292f, -0.01043498f, -0.03168256f, 
    0.04705089f, -0.01577271f, -0.03086302f, 0.02171234f, 0.02736024f, 0.02517923f, 0.00618868f, -0.02724977f, 
    0.02802545f, -0.04371716f, -0.03133371f, 0.01520881f, -0.00515411f, 0.00921870f, -0.06262350f, 0.03114269f, 
    -0.01648742f, -0.03340126f, -0.04903974f, 0.00191450f, 0.00001670f, -0.03674199f, -0.03736309f, -0.02468195f, 
    -0.00696410f, -0.03722253f, 0.06100492f, -0.05774470f, 0.04141559f, -0.04100490f, 0.04301384f, -0.01688674f, 
    0.03006078f, -0.06317284f, -0.03698109f, -0.00619232f, -0.03896051f, -0.06295595f, 0.01539472f, 0.00059088f, 
    0.02622931f, 0.00335844f, 0.01534209f, -0.00494617f, 0.02481996f, 0.01383275f, 0.00699356f, -0.03281382f, 
    -0.03332553f, -0.05833601f, -0.03828032f, -0.03716526f, -0.01269067f, 0.04737918f, -0.01466238f, 0.01469340f, 
    0.00565774f, 0.04385577f, -0.00814611f, -0.00159602f, 0.01010382f, -0.02587836f, -0.00129215f, 0.01000803f, 
    -0.03754674f, 0.01959215f, -0.02741490f, -0.04950916f, 0.03585890f, -0.05153399f, -0.06165025f, 0.00298121f, 
    -0.04908644f, -0.06195336f, -0.02611951f, -0.04116737f, -0.01229785f, 0.05164512f, 0.00507977f, -0.03209328f, 
    0.00306247f, 0.03435918f, 0.03187180f, -0.06054230f, -0.05622387f, -0.04808510f, 0.02209021f, -0.00325559f, 
    -0.05099676f, -0.03131801f, 0.04006363f, 0.02098425f, 0.01200582f, -0.00616571f, -0.03992463f, -0.03485487f, 
    0.01018185f, 0.01852635f, 0.05070631f, 0.00999030f, -0.05684591f, 0.03689218f, -0.01496181f, 0.03644847f, 
    0.02390243f, 0.04405941f, 0.03448718f, -0.01235624f, -0.06022622f, -0.01447046f, 0.01665541f, 0.01891303f, 
    0.02065751f, 0.01338782f, 0.03020103f, -0.04741852f, 0.03561038f, 0.04435160f, 0.00931394f, -0.00780999f, 
    0.03737106f, -0.02066088f, -0.04205982f, -0.04064395f, -0.00784542f, -0.06214405f, -0.00858773f, 0.01150674f, 
    -0.02962770f, 0.00229079f, -0.02690042f, -0.06427020f, -0.05022942f, 0.01720352f, -0.00228164f, -0.03046684f, 
    -0.01814523f, 0.02108897f, -0.04658200f, -0.00348739f, -0.02458607f, -0.02994446f, 0.01797431f, -0.00597664f, 
    -0.05035847f, 0.05173499f, -0.00136657f, 0.03294231f, 0.04486712f, 0.04372108f, -0.00043786f, -0.02638975f, 
    -0.01720293f, 0.01460169f, -0.02201847f, 0.04263097f, 0.05160778f, 0.04097499f, -0.05386407f, 0.01970937f, 
    0.03672624f, 0.01207217f, -0.00473076f, 0.00118570f, -0.01349035f, -0.01267944f, 0.01803886f, -0.04712334f, 
    0.00013368f, -0.04120857f, 0.03649639f, -0.03588225f, 0.04733890f, 0.03883706f, -0.03481409f, 0.05107112f, 
    -0.04002474f, -0.05627229f, 0.03836944f, 0.01586834f, -0.00419480f, -0.04462861f, -0.00483282f, 0.00032764f, 
    0.00876510f, 0.01324664f, -0.00910614f, -0.05570289f, 0.03413538f, -0.00578201f, -0.05090228f, 0.02329974f, 
    -0.00732575f, -0.04877625f, 0.03420509f, 0.04407708f, -0.00088019f, -0.04003131f, 0.02632608f, 0.03301362f, 
    0.02517872f, -0.03301863f, 0.00840394f, 0.04793838f, 0.03281613f, 0.00330553f, -0.05550499f, -0.04827353f, 
    -0.05508975f, -0.06443387f, 0.02333053f, -0.01882906f, -0.04910610f, -0.01592584f, -0.05869075f, 0.01281202f, 
    -0.03370563f, -0.05338718f, -0.06145499f, 0.00777886f, -0.01844689f, -0.05854734f, 0.04671659f, -0.05264972f, 
    -0.02025658f, -0.00834515f, -0.06192885f, 0.00336723f, 0.02814214f, -0.03126924f, -0.04395907f, -0.03456269f, 
    -0.06017579f, -0.01891379f, -0.03218988f, -0.02471229f, 0.01008414f, 0.00002877f, -0.05865861f, 0.04148652f, 
    -0.05094336f, 0.02807487f, 0.03751461f, -0.01304599f, -0.02836629f, -0.03570329f, 0.03064914f, 0.04190844f, 
    -0.00811815f, -0.05232798f, -0.00308391f, 0.03513509f, -0.00905458f, -0.05023066f, -0.03959951f, 0.02969786f, 
    -0.14165798f, -0.26819605f, -0.35085765f, 0.14561783f, 0.13207859f, 0.04825728f, -0.07914356f, 0.05093742f, 
    -0.37995252f, 0.22851157f, -0.04463173f, 0.10605840f, -0.16328891f, 0.04711957f, -0.11046017f, 0.02575354f, 
    -0.07069603f, 0.07879084f, 0.08313981f, 0.15819570f, 0.17972319f, 0.01796281f, -0.10254305f, -0.11629441f, 
    -0.09208132f, -0.01597287f, 0.06225293f, -0.06348844f, 0.47186750f, -0.53371209f, 0.12749752f, -0.10394054f, 
    0.12854746f, -0.04762679f, 0.01139243f, 0.01577405f, 0.32051528f, 0.11698290f, 0.09552140f, 0.24961790f, 
    0.13458505f, -0.06970870f, 0.00952799f, -0.15233482f, 0.09787049f, 0.12723200f, -0.09874031f, 0.17190844f, 
    -0.26383185f, 0.07191824f, 0.01490189f, 0.06180015f, 0.06485265f, -0.03707495f, 0.11714102f, 0.19993109f, 
    0.06720311f, 0.09725219f, 0.35796207f, 0.09992126f, 0.13538750f, 0.04630459f, 0.04048131f, -0.13578886f, 
    0.00988103f, 0.10203073f, 0.04849209f, -0.01682037f, -0.25751561f, -0.03855572f, 0.03230635f, 0.08612522f, 
    0.05490116f, 0.01130574f, 0.19435738f, -0.02259629f, 0.01923793f, -0.14762607f, -0.00878550f, 0.11800659f, 
    -0.14018093f, 0.22361802f, -0.19002496f, -0.14081052f, 0.09931463f, 0.11008010f, 0.09015977f, -0.07693257f, 
    0.03484114f, -0.14198078f, 0.13535365f, -0.17269211f, -0.10841054f, -0.19880201f, 0.08836472f, 0.04514799f, 
    -0.02854202f, 0.14372054f, 0.08820681f, 0.46217692f, 0.28034037f, -0.18509175f, 0.12449063f, -0.00784918f, 
    -0.03857866f, -0.14323346f, -0.02161350f, 0.02219354f, -0.34644976f, 0.42407939f, 0.08215816f, -0.06766953f, 
    0.02475837f, -0.07840607f, -0.03612793f, -0.04927502f, 0.12251364f, -0.40909427f, -0.12065744f, -0.05591840f, 
    -0.01291292f, -0.01675249f, -0.27096143f, -0.11860698f, -0.21370913f, 0.00941312f, 0.67372489f, -0.26281467f, 
    -0.11410122f, 0.10169388f, -0.28360954f, -0.06162529f, 0.07696722f, 0.25270611f, -0.06955221f, 0.00415600f, 
    0.12259455f, -0.00945994f, -0.15805182f, -0.04828944f, -0.04399921f, -0.07133179f, 0.00531226f, 0.10918263f, 
    0.26517901f, -0.11807509f, 0.33227015f, -0.09327354f, 0.12060138f, 0.11384320f, -0.02229604f, -0.07896471f, 
    -0.03943932f, -0.15714633f, -0.07448854f, -0.12573546f, 0.06286870f, 0.10804420f, -0.11031674f, 0.00910321f, 
    -0.09634588f, -0.05477764f, -0.62398833f, -0.01664901f, -0.05972164f, -0.10311203f, -0.08921204f, -0.17864902f, 
    -0.09380761f, 0.03905616f, 0.13422672f, -0.06549408f, -0.31574360f, -0.11525197f, -0.00420532f, -0.12493713f, 
    -0.01683682f, 0.19317487f, -0.03257807f, 0.07601286f, 0.16685228f, 0.37551242f, 0.26881930f, -0.13439107f, 
    -0.06819607f, -0.06743470f, -0.07539102f, -0.02429553f, 0.15176898f, 0.06189234f, 0.00048569f, -0.08248380f, 
    0.21377832f, 0.02336164f, -0.00336976f, -0.21962306f, 0.01686783f, 0.06959350f, -0.21663000f, -0.19873358f, 
    -0.34715936f, -0.03577891f, 0.09603754f, 0.08843894f, -0.09905151f, -0.13929562f, -0.01520801f, -0.51736039f, 
    -0.00705943f, 0.15627633f, 0.16583252f, 0.09772864f, 0.01974406f, -0.07505989f, 0.01189598f, -0.11781185f, 
    -0.70554435f, 0.15904406f, -0.50057989f, -0.06799723f, 0.12121232f, -0.04677998f, -0.00366095f, -0.12609833f, 
    0.08992045f, 0.09788266f, 0.15749897f, 0.25180465f, 0.06503648f, -0.08963135f, 0.00823850f, 0.06179824f, 
    -0.05958360f, 0.11444289f, 0.07982139f, -0.18408202f, -0.09906625f, -0.20516053f, 0.04500343f, -0.18605214f, 
    -0.19654126f, -0.05356000f, 0.22147216f, -0.00718034f, 0.28120115f, -0.16658853f, 0.09183847f, 0.03218405f, 
    0.03312280f, -0.03280715f, 0.02651515f, 0.08794403f, -0.29670376f, -0.07931171f, -0.42188227f, 0.08853476f, 
    -0.18916418f, -0.10359080f, 0.13369370f, 0.06016761f, 0.05280491f, -0.07940865f, -0.03404541f, 0.05898531f, 
    -0.17203616f, 0.08600436f, -0.08631643f, 0.03066122f, 0.11918478f, 0.30000535f, 0.42206147f, -0.38164693f, 
    0.04661572f, 0.00756454f, 0.16726573f, 0.22510783f, -0.13246547f, -0.00566521f, -0.02785324f, 0.64926350f, 
    0.14915863f, -0.07081462f, 0.01752288f, -0.08958340f, -0.02073265f, 0.08937740f, -0.13047522f, -0.03565335f, 
    0.04643575f, 0.02860483f, 0.03349825f, -0.00344796f, 0.01588656f, -0.05911881f, -0.06113332f, -0.03504716f, 
    0.03865153f, 0.01993297f, 0.04196503f, 0.03149647f, -0.00985873f, 0.03179758f, 0.00351436f, 0.00915743f, 
    0.05016121f, -0.04407617f, 0.03560329f, 0.04189365f, 0.05063282f, 0.01272333f, -0.03013735f, 0.04368860f, 
    -0.06239939f, -0.03529484f, -0.02409445f, 0.02147831f, -0.04064003f, -0.06113274f, 0.02547740f, -0.02112278f, 
    0.04066935f, -0.00924874f, -0.03183208f, -0.04334898f, -0.00620995f, -0.00214015f, 0.03390327f, 0.03610302f, 
    0.00940751f, 0.02288765f, 0.01948364f, -0.02959177f, -0.01574596f, 0.01808493f, -0.05938169f, 0.03216067f, 
    -0.04790673f, 0.03772864f, -0.00515673f, -0.03542248f, -0.00171241f, -0.02242336f, 0.02246376f, -0.04246089f, 
    -0.00228718f, 0.02751485f, 0.04288988f, -0.03808837f, -0.00152706f, 0.02617065f, 0.04413678f, -0.01753908f, 
    0.03795859f, -0.02398071f, -0.01056581f, -0.00963580f, -0.02037883f, -0.01180952f, 0.02799900f, -0.02489315f, 
    -0.04490285f, 0.01038873f, 0.01922641f, -0.03147283f, -0.01292457f, -0.04736709f, -0.02531902f, -0.04689993f, 
    -0.03855382f, 0.01731757f, 0.03790276f, -0.01463573f, -0.00334281f, 0.01162936f, 0.01847354f, 0.03096881f, 
    -0.01147608f, -0.04516399f, -0.02043482f, -0.02730358f, -0.04605921f, 0.02154313f, -0.01300247f, 0.04323118f, 
    -0.04029725f, 0.05060662f, -0.04957311f, -0.05601950f, -0.05687625f, -0.06162791f, 0.03523060f, -0.02325560f, 
    0.05259438f, 0.01863134f, -0.01320254f, -0.03129947f, 0.03093312f, 0.03169997f, -0.05628271f, 0.04687925f, 
    -0.03083639f, 0.01964229f, -0.01797600f, -0.03706554f, 0.00924435f, 0.03927544f, -0.03371866f, -0.03311951f, 
    0.04251997f, -0.05375031f, -0.04253687f, -0.03329411f, 0.03476686f, -0.04840786f, -0.05105742f, -0.01403720f, 
    -0.05173920f, 0.00168294f, 0.00214006f, -0.03851917f, 0.00369039f, 0.05188667f, 0.04819958f, -0.06329917f, 
    -0.05668409f, 0.04347487f, -0.03411455f, -0.02374920f, 0.02839653f, -0.04727793f, -0.05812145f, -0.00256599f, 
    -0.01121836f, 0.03394679f, 0.00695248f, -0.04816210f, -0.02575389f, 0.00347942f, -0.00226257f, 0.04400323f, 
    0.04390829f, 0.04021681f, -0.06199453f, -0.02521030f, -0.04159211f, -0.04845444f, 0.00447449f, 0.02151769f, 
    0.00209873f, 0.00148721f, -0.00849674f, 0.02107400f, 0.03981480f, 0.02773901f, -0.04933876f, 0.04616636f, 
    -0.05535346f, 0.02479582f, -0.00511018f, -0.01309126f, 0.02460115f, -0.04846180f, 0.01277696f, -0.04177778f, 
    0.04301506f, -0.00098065f, -0.00686969f, -0.04296915f, -0.04282145f, -0.06046150f, -0.05578334f, 0.03197655f, 
    0.01743053f, -0.01259191f, -0.01722206f, -0.04678725f, -0.03811743f, -0.02906412f, 0.04315149f, -0.01374546f, 
    0.02425808f, 0.01485603f, 0.00818766f, 0.00606505f, -0.04592367f, -0.05544906f, -0.03594233f, -0.05196150f, 
    -0.01976634f, -0.01526845f, -0.02776200f, 0.05231450f, -0.02984069f, 0.02831390f, 0.00514528f, 0.01720891f, 
    -0.06148516f, 0.03405720f, -0.01480487f, -0.02131492f, -0.03536984f, 0.02013986f, -0.04155234f, -0.03227687f, 
    -0.04651371f, 0.00080530f, 0.04212625f, -0.02355504f, -0.02366990f, -0.04214043f, 0.03388252f, -0.01160974f, 
    -0.01167355f, -0.06269213f, -0.03875843f, 0.01386058f, 0.00282315f, -0.00705160f, -0.05979829f, -0.05742800f, 
    -0.03747274f, -0.02200054f, -0.04147110f, -0.05488354f, 0.01772728f, -0.04407551f, 0.03189468f, -0.04632023f, 
    -0.04690669f, 0.02476758f, -0.04479750f, 0.03739888f, -0.04107687f, -0.06044131f, 0.04469040f, -0.05931893f, 
    -0.02165757f, -0.02930139f, -0.02957177f, 0.01336605f, -0.00563792f, -0.03161861f, 0.03149853f, 0.03733968f, 
    -0.00851919f, -0.02406590f, 0.02279197f, -0.04331968f, -0.05037390f, 0.02911160f, 0.05202406f, -0.05549704f, 
    0.02458466f, -0.03343434f, -0.01436938f, -0.01565214f, -0.00746048f, -0.05076151f, 0.00838583f, -0.00297436f, 
    0.03962920f, -0.02636706f, -0.03176178f, 0.04050212f, -0.05389646f, -0.04572498f, -0.02150578f, -0.00647266f, 
    0.03163562f, -0.00568884f, 0.04003419f, -0.01800255f, 0.04957588f, 0.01991417f, 0.04462535f, 0.02969815f, 
    -0.06147112f, 0.02171763f, -0.05825542f, -0.04170548f, 0.03112490f, -0.02883760f, -0.02251448f, -0.02995382f, 
    0.01778825f, -0.05934737f, 0.02223559f, 0.00761854f, -0.00830790f, -0.02437653f, 0.03705552f, -0.04473866f, 
    -0.02675273f, 0.03702763f, 0.04065513f, -0.05165517f, 0.02363073f, 0.02473439f, -0.05246182f, -0.02447974f, 
    0.00782999f, -0.04969198f, 0.00346633f, -0.02746569f, -0.03773386f, -0.04971966f, 0.01621216f, 0.00888364f, 
    0.03827348f, -0.04688843f, 0.01031053f, -0.05666641f, -0.01292333f, 0.05214445f, -0.01959003f, 0.03255929f, 
    -0.03889430f, 0.02071926f, -0.02089106f, -0.01082134f, -0.02101692f, 0.00370558f, -0.02869389f, 0.04197185f, 
    -0.06021503f, -0.03661642f, -0.02676262f, 0.00039437f, 0.02191434f, 0.00459384f, -0.03373995f, 0.05003993f, 
    0.00490147f, 0.00699369f, -0.01134609f, -0.01209764f, -0.00529599f, -0.00776539f, -0.01799762f, 0.01982480f, 
    -0.02509635f, -0.06090802f, 0.01465765f, -0.00538082f, 0.05173557f, -0.01095613f, -0.05668878f, -0.04534709f, 
    -0.04147303f, -0.03675631f, -0.02056352f, -0.00585798f, -0.03688456f, -0.05441280f, 0.02568034f, -0.05242022f, 
    -0.03603676f, -0.04721964f, 0.01722492f, 0.02475796f, 0.05849935f, 0.05362606f, 0.02268547f, -0.04968553f, 
    0.05171740f, 0.01332229f, -0.02004243f, 0.05192597f, 0.03784901f, 0.03183813f, 0.04281424f, -0.02528818f, 
    -0.00741619f, -0.05074913f, 0.01954866f, -0.05836209f, -0.03181099f, 0.02323106f, 0.01652385f, 0.04329157f, 
    0.01269097f, 0.04964025f, -0.06318665f, 0.01436621f, -0.05539839f, 0.02125536f, -0.00364888f, 0.00392406f, 
    -0.02585163f, -0.01467104f, 0.03678238f, -0.04844714f, -0.05213319f, -0.03742194f, 0.02027197f, 0.00297385f, 
    -0.01611523f, 0.04441806f, -0.03602972f, -0.01711417f, -0.03475490f, 0.02859928f, 0.01284993f, 0.02063340f, 
    -0.02608741f, -0.04873178f, -0.04664602f, -0.04979073f, -0.05116586f, -0.04206073f, 0.01013586f, 0.03463396f, 
    -0.00331792f, 0.01323912f, 0.02043317f, 0.01094335f, -0.06249951f, 0.00625466f, 0.00745202f, 0.03437022f, 
    -0.04308193f, -0.04197364f, -0.01463471f, 0.01889699f, 0.01493617f, 0.03344309f, -0.02977742f, -0.03769659f, 
    0.03088558f, -0.04175678f, 0.04489204f, -0.03090169f, -0.03398590f, -0.04014489f, 0.02973850f, 0.04411036f, 
    -0.03186374f, -0.03111943f, 0.01790591f, -0.02340138f, 0.03724799f, -0.00630113f, -0.03165251f, -0.01095581f, 
    0.00879305f, -0.02106106f, -0.03427942f, 0.00595856f, -0.02795690f, -0.04690099f, 0.00191340f, -0.02884854f, 
    -0.00633562f, 0.04913455f, -0.01038669f, 0.03052676f, 0.02741485f, 0.01375673f, -0.05146413f, -0.06073667f, 
    0.00673562f, 0.04864307f, 0.03154705f, 0.01486393f, 0.00524775f, -0.05652317f, 0.02554369f, -0.02326805f, 
    -0.01120129f, 0.04274835f, 0.03903644f, -0.04459812f, 0.02514347f, -0.06308545f, -0.05203757f, 0.00520473f, 
    -0.00906086f, -0.05859654f, 0.00402111f, -0.02060246f, 0.02035468f, 0.02982741f, -0.00087489f, 0.03947894f, 
    0.00524936f, 0.05297542f, -0.06017927f, -0.04974418f, -0.05005427f, -0.04836087f, -0.04930517f, 0.01049766f, 
    -0.01805830f, -0.01577344f, -0.03918897f, 0.00102898f, -0.00247361f, -0.04983984f, -0.00079892f, 0.00593241f, 
    0.05100799f, 0.01084031f, -0.01762706f, -0.04732888f, 0.01815121f, 0.00599565f, 0.00534603f, 0.01863978f, 
    -0.01011386f, 0.02728801f, 0.00599540f, -0.06123711f, 0.00133505f, -0.02137739f, -0.05681802f, -0.02997339f, 
    0.03915109f, -0.05366385f, 0.01179130f, -0.01569892f, 0.04640385f, 0.00492285f, -0.03609383f, -0.01424303f, 
    -0.00812020f, -0.05398558f, -0.05433907f, -0.01752082f, -0.01391861f, -0.01400387f, -0.02411668f, -0.00246587f, 
    0.00322186f, -0.00098251f, -0.00076133f, 0.02049018f, -0.01879073f, 0.00086947f, 0.04311376f, -0.04967609f, 
    0.04709302f, -0.05856204f, 0.05041296f, -0.02708174f, 0.02081066f, -0.00402039f, 0.01949410f, -0.01742559f, 
    -0.00098741f, 0.03328485f, 0.01168658f, 0.02706621f, -0.03130320f, 0.03110018f, -0.06357050f, 0.03670722f, 
    0.03371072f, -0.02398411f, 0.01773985f, -0.05560696f, 0.02737278f, -0.05251231f, -0.02554246f, -0.05334574f, 
    -0.42740247f, 0.06460994f, 0.16845942f, -0.15762199f, 0.17368279f, 0.17834087f, 0.19088417f, -0.15753697f, 
    -0.28613752f, 0.17774025f, -0.15454072f, 0.21948597f, -0.25567928f, 0.17325513f, 0.00961615f, 0.26588708f, 
    0.09932382f, 0.23679897f, 0.15463735f, 0.24002743f, 0.30483615f, 0.15648241f, 0.26310283f, -0.00232749f, 
    0.14316474f, -0.00083521f, 0.07332354f, -0.37903175f, -0.22121397f, -0.35039029f, 0.17816766f, 0.13265522f, 
    0.07063793f, 0.05775519f, -0.26496249f, 0.15906046f, -0.34633195f, -0.08729734f, -0.03914528f, 0.20103650f, 
    0.14445880f, 0.09676660f, -0.02165241f, -0.00422545f, -0.06099636f, -0.11731570f, -0.35890734f, 0.03872681f, 
    -0.05491443f, -0.03230864f, -0.16912992f, -0.06129299f, -0.08665510f, 0.12463596f, -0.42285234f, 0.04156545f, 
    -0.10683384f, 0.20470352f, 0.16131033f, -0.15060069f, -0.00816253f, -0.05022232f, -0.23695214f, 0.03726100f, 
    0.44267589f, 0.54496557f, 0.03035603f, 0.09314011f, -0.00692896f, 0.10650568f, 0.00644835f, 0.02292365f, 
    0.08765136f, 0.00746879f, -0.25997674f, 0.18571989f, -0.02225287f, -0.03259750f, 0.01608681f, 0.15655756f, 
    0.17383093f, 0.12297679f, -0.14114742f, -0.09843353f, -0.09800451f, -0.25347760f, -0.14547190f, -0.15549797f, 
    -0.02499657f, -0.17759001f, 0.06984463f, 0.15118894f, -0.04831293f, 0.04506848f, 0.14177878f, -0.07764544f, 
    0.00995909f, 0.14986542f, 0.01105803f, -0.73302186f, -0.29980913f, 0.21277805f, 0.00040727f, 0.26349953f, 
    0.14219381f, 0.05074609f, -0.06337218f, -0.01585675f, -0.55429024f, -0.01457417f, -0.23880769f, 0.08333941f, 
    -0.13424721f, -0.20346111f, -0.16310970f, 0.21259114f, 0.08228450f, -0.59931737f, -0.19021103f, -0.27344972f, 
    0.22365665f, 0.06542345f, -0.33860910f, 0.10132301f, -0.03452726f, 0.04078783f, -0.16206884f, 0.11600427f, 
    0.27660665f, -0.02436822f, 0.05709740f, -0.08740120f, 0.30186167f, -0.00912296f, 0.12644522f, 0.29170361f, 
    0.09603560f, 0.42434812f, 0.11684116f, 0.14206463f, -0.05523823f, 0.19424449f, 0.04621566f, 0.11379506f, 
    0.04197105f, -0.14887352f, -0.03717949f, -0.16984899f, -0.14192848f, -0.16158797f, 0.00251883f, -0.00007926f, 
    -0.11342566f, -0.02054469f, 0.03245460f, 0.25412703f, 0.08599771f, 0.07442430f, 0.19283950f, 0.27768594f, 
    -0.10514330f, -0.00611375f, 0.08968259f, -0.16438153f, 0.07108260f, 0.00498612f, -0.02962770f, -0.01011271f, 
    0.00905999f, 0.02881068f, 0.10484555f, 0.12585831f, -0.09798264f, 0.07322820f, -0.07657796f, 0.09790402f, 
    -0.01982491f, 0.24086410f, -0.03078504f, 0.14387895f, -0.36344463f, -0.08019175f, -0.22881737f, 0.17511329f, 
    0.24422574f, 0.00872476f, -0.14535603f, -0.11146487f, 0.05304319f, -0.19574755f, 0.26951215f, 0.27721286f, 
    0.29570520f, 0.09910766f, -0.02799326f, 0.17922804f, -0.07439069f, -0.04781507f, 0.31126085f, -0.07590875f, 
    -0.08909565f, 0.01584544f, 0.07330034f, 0.19157203f, -0.00273885f, -0.07958412f, 0.22438632f, -0.25557202f, 
    0.19167015f, -0.22945961f, 0.11768205f, 0.02960187f, 0.04518793f, -0.36904615f, 0.07873326f, -0.34879327f, 
    -0.22658999f, 0.09556172f, 0.06110825f, 0.11917020f, -0.03810723f, 0.19588099f, -0.24500741f, 0.07795478f, 
    0.08932950f, 0.47562706f, 0.17677982f, -0.02633791f, -0.03770596f, 0.01778894f, 0.00176186f, -0.06215240f, 
    0.09193097f, 0.13835946f, -0.29851532f, -0.11234334f, 0.06479584f, 0.10770249f, 0.15014397f, 0.04386225f, 
    0.02981837f, 0.08699929f, -0.10626443f, -0.31925681f, -0.15699825f, -0.20173493f, 0.14737469f, 0.02508345f, 
    0.12833044f, 0.03481694f, -0.00052917f, 0.17819910f, -0.06972840f, -0.06235890f, -0.43169963f, 0.30523071f, 
    0.25091878f, -0.05165392f, 0.24606663f, 0.02570624f, -0.16718829f, 0.04364156f, 0.06469422f, 0.08504952f, 
    0.10441183f, -0.00681892f, 0.29048637f, 0.12961975f, 0.12173455f, 0.15096782f, -0.67335403f, -0.28348380f, 
    -0.76077473f, 0.15394506f, -0.06980778f, -0.04199986f, -0.13278025f, -0.05988375f, -0.03660531f, -0.65255535f, 
    -0.10083652f, 0.07577905f, -0.06388026f, 0.13582188f, 0.04510776f, 0.09297720f, 0.06076013f, 0.01234578f, 
    -0.11830383f, -0.02041106f, 0.17379296f, -0.00195414f, 0.20151149f, -0.04443832f, -0.30855629f, -0.20352592f, 
    -0.30428353f, 0.18398426f, -0.15277207f, -0.15465216f, 0.04853620f, -0.02324121f, -0.07265633f, -0.27414113f, 
    -0.10376688f, 0.07463904f, -0.48321274f, -0.09622825f, -0.02188493f, -0.04239408f, 0.09357164f, -0.02139031f, 
    0.01074789f, 0.06263912f, -0.05001698f, 0.17917703f, 0.01281065f, 0.30397168f, 0.26722544f, 0.11068150f, 
    0.12691614f, 0.02589471f, 0.14377898f, 0.00122580f, 0.23610729f, 0.26790592f, 0.17887348f, 0.16353148f, 
    0.09817380f, -0.17756890f, -0.02346633f, 0.14065875f, 0.02509066f, -0.20995548f, 0.09540591f, -0.08743277f, 
    -0.10073011f, 0.00431930f, 0.11743546f, 0.10165595f, -0.02432065f, -0.07098614f, 0.10750055f, 0.13729353f, 
    0.40738127f, -0.16461316f, 0.08559379f, -0.03279187f, -0.12229139f, 0.16413693f, 0.10835496f, -0.69630486f, 
    -0.46441549f, -0.12446424f, 0.23961119f, 0.14310308f, -0.17712542f, -0.41037235f, -0.05633642f, -0.00722593f, 
    0.32913607f, 0.08200639f, 0.22331928f, 0.00215990f, -0.01955133f, -0.06092818f, -0.16835232f, -0.09017286f, 
    -0.12280130f, -0.04740965f, 0.15029225f, 0.25171888f, -0.22702977f, 0.05149322f, 0.02272073f, 0.02224781f, 
    0.17076212f, 0.08563709f, 0.04381834f, -0.04520877f, 0.33220673f, -0.06252381f, -0.33341116f, -0.08462661f, 
    -0.18827957f, -0.23787166f, -0.20133220f, 0.02417498f, 0.10716560f, 0.15783206f, 0.00657763f, 0.13764066f, 
    0.05533563f, -0.01370714f, 0.03013041f, -0.02840793f, 0.23573196f, -0.08024086f, 0.02284425f, 0.14226072f, 
    -0.00654621f, -0.30416524f, 0.06497635f, -0.07320955f, 0.09114984f, 0.13310772f, 0.14431369f, 0.26707339f, 
    -0.06159366f, 0.01791209f, -0.07600231f, -0.22296879f, 0.08701310f, 0.05730663f, 0.46887526f, 0.40604749f, 
    0.23393925f, -0.02560361f, 0.10662813f, -0.05704860f, 0.01714099f, -0.00906258f, 0.00986563f, -0.42067015f, 
    -0.31233042f, -0.01479889f, -0.01838432f, -0.15820847f, -0.06241396f, -0.21447702f, -0.25543502f, 0.00452164f, 
    -0.24586853f, -0.06237258f, -0.26815465f, -0.06231486f, -0.03690857f, -0.08194878f, 0.20613401f, 0.14027432f, 
    0.01969640f, -0.10794469f, -0.16052032f, -0.03876485f, 0.03672976f, -0.20316848f, -0.03536222f, 0.10578761f, 
    0.15954885f, -0.04404046f, 0.27607131f, -0.12657590f, -0.08021624f, 0.01965131f, -0.21856789f, 0.11865792f, 
    -0.10960480f, 0.11607919f, 0.09005047f, 0.13341564f, 0.01224716f, -0.25041127f, -0.13221727f, -0.15242639f, 
    -0.03642903f, -0.15405853f, 0.05177331f, 0.18586141f, 0.02468262f, 0.04946096f, 0.00775823f, 0.18865563f, 
    0.10865724f, -0.34232390f, 0.07554057f, 0.09124834f, 0.01605935f, -0.36022583f, 0.05924007f, -0.18840763f, 
    0.06197529f, -0.22496942f, -0.14812665f, 0.06396712f, 0.06573419f, 0.02273601f, -0.34208658f, -0.21727464f, 
    -0.14854985f, -0.05182214f, 0.00373513f, -0.38301164f, 0.15320873f, -0.14470358f, 0.24846426f, 0.13236405f, 
    0.36033162f, 0.32691273f, 0.09314109f, 0.04287704f, 0.07589159f, -0.22839591f, -0.04625173f, -0.25566959f, 
    -0.11942169f, 0.09539545f, 0.05334933f, 0.31043032f, -0.00904100f, -0.25113320f, -0.09544428f, 0.02490726f, 
    0.17142993f, -0.02941544f, -0.03145415f, -0.35872066f, -0.00746501f, 0.16478503f, 0.05032960f, -0.17330384f, 
    0.07469044f, -0.22043754f, -0.14115351f, 0.08511077f, -0.10526247f, -0.08304566f, 0.04414527f, -0.29043162f, 
    0.24095032f, -0.00669138f, -0.00614015f, 0.39649597f, 0.17802276f, 0.22781898f, 0.20000328f, 0.08062305f, 
    -0.05251233f, 0.09957787f, 0.09798532f, 0.20721330f, 0.23987152f, 0.30175820f, 0.33337513f, -0.07355072f, 
    -0.09605525f, -0.07587683f, -0.01899695f, 0.01716872f, -0.02806015f, 0.08298774f, -0.10093883f, -0.14303453f, 
    0.07839336f, -0.05857512f, -0.24255852f, 0.15069962f, -0.13056862f, 0.10503370f, 0.08056767f, 0.15620115f, 
    -0.43608961f, -0.02676274f, -0.19257149f, -0.03688637f, -0.01693257f, -0.18319227f, -0.07178371f, -0.30772328f, 
    -0.19471072f, 0.02289684f, -0.04559808f, 0.06611192f, -0.04672293f, 0.03342359f, 0.20000285f, 0.00528769f, 
    -0.23919559f, -0.29640368f, -0.06580689f, -0.15796654f, 0.08006422f, -0.20319758f, 0.21216358f, -0.00158898f, 
    0.04341270f, -0.32966807f, 0.02946737f, 0.04387090f, 0.01984674f, 0.10083762f, 0.00153915f, -0.00492917f, 
    0.08198138f, -0.01992568f, 0.01028377f, -0.19219698f, 0.16829823f, 0.16545591f, -0.00809288f, 0.01182473f, 
    -0.16704343f, 0.03705465f, -0.09678356f, -0.12915576f, 0.01401198f, 0.21450333f, -0.14498049f, -0.11684228f, 
    0.09909953f, -0.19757208f, -0.00655585f, -0.10654826f, 0.03053667f, -0.06534043f, 0.40988517f, 0.05579564f, 
    -0.14443615f, 0.02497734f, 0.00098879f, 0.08180461f, 0.00753981f, 0.08959113f, 0.06104762f, -0.10975491f, 
    -0.00995392f, 0.14166810f, -0.10972491f, 0.17457306f, -0.24614745f, 0.13729706f, 0.04530318f, -0.06528305f, 
    0.07374147f, -0.18063071f, -0.10640167f, 0.08694055f, 0.07945369f, -0.04350097f, 0.19775712f, -0.24347852f, 
    -0.44355035f, 0.21000761f, 0.12387689f, 0.08787603f, -0.00001553f, 0.16585855f, 0.06435386f, -0.23313110f, 
    0.17768650f, 0.17487612f, 0.11751078f, -0.04416599f, -0.10416353f, -0.00995162f, 0.09653743f, 0.11138678f, 
    0.17774616f, 0.21882039f, -0.12886891f, -0.12738752f, 0.00578903f, -0.06714897f, 0.07710234f, -0.08895013f, 
    0.09752670f, -0.00062274f, -0.13345821f, -0.02600695f, -0.10344183f, 0.12045334f, 0.15805541f, -0.08207082f, 
    0.03134452f, 0.01488099f, 0.03099367f, -0.00422805f, -0.11713183f, 0.16691872f, 0.01484156f, 0.00449994f, 
    -0.06027338f, 0.03728823f, -0.07318216f, 0.19093555f, 0.30710143f, 0.19746546f, 0.16202445f, -0.03659433f, 
    -0.19992520f, -0.11372136f, 0.05231028f, 0.05054710f, -0.08851250f, -0.14864756f, -0.05357954f, 0.05984184f, 
    0.05009252f, -0.14722690f, -0.11681805f, 0.02001391f, -0.10719427f, -0.07166379f, -0.12174874f, -0.43794444f, 
    -0.48483643f, 0.09632243f, -0.00267199f, -0.11622231f, 0.06717075f, -0.18312304f, -0.09615847f, -0.54856950f, 
    0.10964707f, -0.05851166f, 0.22863962f, 0.04245073f, -0.05227872f, 0.16384846f, 0.04218325f, -0.14149624f, 
    0.14070894f, -0.17586042f, -0.14545953f, 0.25444740f, 0.01565815f, 0.05473341f, -0.00579654f, -0.13990383f, 
    0.05564731f, -0.01262099f, -0.23699437f, -0.25874728f, 0.18272352f, 0.10738607f, -0.03280421f, -0.13006289f, 
    0.18116562f, -0.02280448f, -0.08588775f, 0.15472001f, -0.03484388f, 0.13224344f, -0.01403943f, -0.18171935f, 
    0.07700606f, -0.10305387f, 0.08492886f, 0.15432185f, -0.03661533f, -0.15098567f, 0.18464011f, 0.06672919f, 
    -0.17438826f, 0.08148783f, -0.22733220f, 0.09780462f, 0.27391681f, 0.22377105f, 0.15978004f, -0.28441146f, 
    -0.16591145f, 0.04763766f, 0.00343174f, 0.18008575f, -0.09656598f, 0.22356820f, -0.02734292f, -0.06631435f, 
    0.00614273f, -0.06287969f, -0.02220851f, 0.19160712f, -0.04468655f, -0.12687573f, -0.04116527f, -0.17685692f, 
    -0.05856770f, 0.17829233f, 0.06510407f, 0.09653999f, 0.02830154f, 0.14340550f, -0.30725017f, -0.27978149f, 
    -0.07873283f, -0.19759093f, 0.23467287f, 0.18213704f, -0.08820388f, 0.01653666f, 0.18249014f, -0.05013537f, 
    -0.04017715f, -0.08644147f, 0.25217989f, -0.16038634f, 0.20982057f, 0.16306444f, 0.08911570f, 0.01767397f, 
    -0.04397029f, 0.03930005f, 0.32540196f, 0.01406532f, 0.04258254f, -0.08090048f, 0.04443468f, 0.09647730f, 
    -0.07344010f, -0.13255918f, 0.21385886f, 0.14833607f, 0.30644798f, -0.03854723f, -0.00565487f, 0.18014637f, 
    -0.01722325f, -0.00628214f, 0.05355724f, -0.25128362f, -0.00382526f, 0.36522055f, -0.10533226f, 0.05304893f, 
    0.04490228f, -0.23851980f, -0.14537109f, 0.01010879f, -0.05367704f, 0.03022973f, -0.01329278f, 0.11763464f, 
    -0.08477600f, -0.07748925f, -0.03848109f, 0.08657865f, 0.10834554f, 0.09265608f, 0.01508960f, 0.24061403f, 
    -0.00810334f, 0.01740186f, 0.04130141f, -0.01541071f, 0.16944130f, 0.17720149f, 0.23348854f, 0.13114119f, 
    0.12136436f, -0.12940593f, 0.08928753f, -0.42787203f, 0.08378515f, 0.04094195f, -0.15556662f, 0.23731387f, 
    0.15348309f, 0.16244949f, -0.15422031f, -0.26762885f, -0.00051116f, 0.15850329f, 0.01930610f, 0.09585965f, 
    -0.12457239f, 0.00708992f, -0.46627554f, 0.31719157f, 0.08214489f, 0.21933022f, 0.05896706f, -0.03787446f, 
    -0.09630587f, -0.29563215f, -0.10202764f, -0.38204420f, 0.24802278f, 0.09929444f, 0.10025733f, 0.03785440f, 
    -0.04794589f, 0.02456771f, 0.20328686f, 0.08939485f, -0.04326151f, 0.12748136f, 0.03113911f, -0.11644237f, 
    0.08124757f, 0.26338229f, -0.02146218f, -0.06092940f, 0.05073798f, 0.32508779f, -0.10885771f, 0.27553347f, 
    0.11831007f, -0.04631477f, 0.14324702f, -0.05974651f, -0.10477419f, -0.20062360f, -0.11678319f, 0.05644367f, 
    0.03621697f, 0.03635713f, -0.11489442f, 0.03126325f, -0.10999862f, -0.02899198f, 0.22311451f, -0.32867792f, 
    -0.13679035f, 0.06439644f, 0.09863530f, -0.25171533f, 0.10341202f, 0.05658117f, -0.15175900f, -0.20269322f, 
    0.33289593f, -0.02537746f, -0.13315985f, 0.11112674f, -0.15692300f, -0.22247085f, 0.16348930f, -0.11268231f, 
    -0.05522700f, -0.43202823f, 0.16445938f, 0.13709275f, 0.18249860f, -0.18675919f, -0.04699605f, 0.04571729f, 
    -0.18249585f, 0.19824471f, -0.02595791f, 0.03105836f, -0.08700942f, 0.02034813f, -0.12034521f, 0.04285828f, 
    0.03655177f, -0.05600606f, 0.39048451f, -0.17025533f, -0.02488016f, -0.19969378f, -0.06957404f, -0.13372587f, 
    0.04025720f, 0.30088177f, 0.09289016f, -0.31763384f, -0.20694099f, 0.03505233f, 0.15435949f, 0.21783201f, 
    0.03093701f, 0.21675533f, 0.11650295f, 0.04892991f, 0.00459694f, -0.02811304f, 0.00248646f, -0.20319428f, 
    0.24510138f, -0.07013901f, -0.07763879f, 0.09241937f, 0.32023266f, 0.05376352f, 0.02314411f, 0.00121039f, 
    -0.03860496f, -0.24135916f, 0.22438495f, 0.05407923f, 0.06541128f, 0.06806537f, 0.01634730f, 0.56150079f, 
    -0.22799784f, -0.19485362f, -0.12984869f, -0.11177735f, 0.16812474f, 0.24938482f, -0.45151302f, -0.04392528f, 
    -0.60456151f, 0.15049388f, -0.16198085f, -0.15264452f, 0.00139806f, 0.03656777f, -0.10204863f, -0.26208803f, 
    0.28615654f, 0.11917248f, 0.09132978f, 0.07795557f, 0.03528921f, -0.00760363f, 0.16225390f, 0.01965217f, 
    0.33312166f, 0.39387032f, -0.02709871f, -0.28497553f, -0.08071888f, -0.18743311f, -0.20186771f, 0.07460506f, 
    0.05390576f, 0.12145109f, 0.27091828f, 0.10349790f, 0.17128287f, -0.04920052f, -0.02722045f, 0.10049696f, 
    0.05918001f, 0.03278477f, -0.28700641f, 0.14086063f, -0.43414819f, 0.08254477f, 0.06146192f, 0.03666180f, 
    -0.05234570f, 0.11681889f, 0.02025180f, -0.07148688f, -0.04884007f, -0.50035167f, 0.14043912f, 0.00987985f, 
    -0.01567672f, 0.00100295f, 0.12691920f, -0.08678672f, -0.12146809f, -0.14656368f, 0.13465649f, 0.04010992f, 
    -0.08774137f, 0.01007548f, -0.09178031f, 0.09445516f, 0.08872288f, 0.05554711f, 0.39782938f, -0.07653986f, 
    -0.04357158f, -0.03873450f, -0.09446628f, 0.02931318f, 0.07741689f, 0.16330473f, 0.23280734f, -0.00171734f, 
    0.14473915f, -0.04103969f, -0.08439061f, -0.03056404f, 0.01684525f, -0.01322849f, 0.26052508f, -0.34731480f, 
    0.00495369f, -0.09485336f, 0.02116679f, -0.19685522f, -0.02687899f, -0.07249805f, -0.13113776f, -0.09014753f, 
    -0.31820640f, 0.03904264f, -0.08161176f, 0.24663377f, -0.00766000f, -0.16121548f, 0.04734933f, 0.08634045f, 
    -0.08138819f, -0.46012264f, -0.18434818f, -0.27996755f, -0.03008967f, -0.00684158f, -0.14569083f, 0.17253467f, 
    0.16938098f, 0.04777983f, 0.28677687f, 0.04152712f, -0.53896552f, 0.03026463f, -0.07852266f, -0.12300023f, 
    0.01035535f, -0.02777401f, 0.20498182f, 0.25672635f, 0.04895287f, 0.22862947f, 0.02190557f, -0.10015195f, 
    -0.24349223f, -0.02178155f, 0.07357599f, -0.14421843f, -0.47125265f, 0.08996645f, 0.24691589f, 0.00659878f, 
    0.08869153f, -0.06753867f, 0.00371018f, -0.24456805f, 0.12599759f, -0.03449769f, -0.00098364f, -0.08709066f, 
    0.09908306f, -0.03481846f, -0.21728870f, 0.04741366f, -0.06871313f, -0.07093784f, -0.00146178f, 0.08939365f, 
    0.01171616f, -0.01204237f, 0.12970522f, 0.07088574f, 0.09967045f, 0.12648614f, -0.09241015f, -0.05510565f, 
    -0.35636982f, 0.31812271f, -0.01718961f, -0.06193165f, 0.25742784f, -0.10254525f, 0.02047124f, 0.26767513f, 
    -0.39984292f, -0.04392406f, 0.12085702f, -0.05888942f, -0.14073785f, 0.05280444f, -0.19315962f, -0.03260363f, 
    -0.15371089f, 0.34221086f, -0.52472180f, -0.19210325f, -0.10411084f, 0.01870411f, 0.03698126f, -0.05492800f, 
    -0.17324914f, -0.17988344f, -0.29987952f, 0.08173893f, 0.09981849f, -0.08903635f, -0.00625544f, 0.08135191f, 
    0.04496330f, 0.13720261f, -0.01720255f, -0.06747627f, 0.22861394f, -0.00813204f, -0.02282189f, -0.16184667f, 
    0.01506928f, 0.08668844f, 0.04121702f, -0.08814202f, -0.09329605f, 0.16921188f, 0.23257171f, 0.04771228f, 
    0.21334451f, -0.02915102f, 0.02359693f, 0.23387939f, 0.08392621f, 0.37307194f, 0.01355931f, -0.28823534f, 
    -0.04434377f, -0.17199978f, -0.06714682f, -0.13122691f, -0.04814811f, -0.21906421f, 0.03153874f, 0.30259374f, 
    0.17328650f, -0.09564541f, 0.17563230f, -0.01419631f, 0.05856891f, 0.32048437f, 0.06251979f, -0.28291535f, 
    -0.71916127f, 0.13017634f, 0.02170006f, 0.05543184f, 0.19781558f, -0.03043238f, -0.03791067f, -0.08500959f, 
    0.26481947f, 0.26468855f, -0.19351996f, -0.14728455f, -0.19554026f, -0.02476090f, 0.14114775f, -0.09083909f, 
    -0.00503766f, 0.63370061f, 0.09051223f, 0.07171704f, -0.31318155f, 0.00402488f, 0.08152232f, 0.15165746f, 
    0.13808405f, 0.12310416f, -0.06926395f, 0.05184251f, 0.23307198f, 0.04013619f, 0.21391642f, -0.02849463f, 
    -0.12458441f, -0.10817607f, 0.07631439f, 0.06003390f, 0.17033933f, 0.15119305f, 0.04783644f, -0.09752513f, 
    0.00619713f, -0.08889925f, 0.04958731f, -0.26964337f, 0.13785520f, -0.09137844f, -0.05062280f, -0.10195421f, 
    0.06651795f, -0.13526963f, -0.08620618f, 0.24806477f, 0.14761473f, -0.01951662f, 0.18914784f, -0.05395174f, 
    -0.14317079f, -0.10222179f, 0.06110350f, 0.12141319f, 0.10655586f, -0.00293069f, 0.80379498f, -0.22829664f, 
    -0.04494561f, 0.08060365f, -0.20941874f, -0.07829159f, -0.01367354f, 0.06438271f, 0.12821880f, -0.12494386f, 
    -0.59382075f, 0.03126064f, 0.01522884f, 0.16073275f, -0.05150730f, -0.01990979f, -0.06545174f, -0.00880356f, 
    0.29978919f, 0.07725145f, 0.21532659f, -0.05556224f, -0.12262498f, 0.21884055f, -0.06818240f, -0.10003021f, 
    -0.06269582f, -0.08021361f, -0.44211268f, -0.23420222f, 0.09521437f, 0.08867312f, 0.20680697f, 0.09921611f, 
    0.09808803f, -0.00785084f, -0.15364160f, 0.16859943f, 0.21079470f, 0.26137087f, -0.11815973f, -0.02227178f, 
    -0.03923650f, -0.15721495f, 0.05951940f, 0.15251003f, -0.53445846f, -0.01876151f, -0.09443512f, 0.07255284f, 
    -0.11561982f, 0.02389879f, -0.11398069f, -0.02817921f, -0.31064990f, 0.14418440f, 0.25069112f, -0.06946129f, 
    -0.02884263f, -0.19555350f, -0.03469601f, 0.18312968f, 0.05757945f, -0.14466472f, -0.15468977f, -0.21376896f, 
    0.15535092f, 0.08931536f, 0.18975937f, 0.03790044f, -0.04319401f, -0.08463820f, -0.25619474f, -0.14832662f, 
    -0.29196051f, 0.06646024f, 0.05682175f, -0.14969842f, -0.10100119f, -0.16598487f, 0.01291083f, 0.06142110f, 
    0.40316501f, 0.11606369f, 0.08679758f, 0.04346417f, 0.10889593f, -0.01019499f, -0.12707563f, -0.13877043f, 
    0.10714744f, 0.14578006f, 0.23196200f, -0.19382079f, -0.17377362f, 0.08166960f, 0.13583574f, 0.01776436f, 
    -0.15606166f, 0.49032807f, -0.21058123f, -0.01255716f, -0.02399309f, -0.01791701f, -0.01074469f, -0.00515178f, 
    -0.07126466f, 0.12944710f, 0.04409533f, -0.02005507f, -0.00165491f, -0.12149175f, -0.18191737f, -0.03958390f, 
    -0.08726804f, 0.13824560f, 0.01518014f, 0.10357617f, 0.29897729f, 0.27544275f, 0.00102710f, 0.12544619f, 
    0.07668480f, 0.06633080f, 0.21198189f, -0.06899365f, -0.09650178f, 0.31670812f, -0.08184477f, -0.04618703f, 
    -0.25172719f, 0.01998955f, -0.01506321f, 0.19287705f, 0.18688704f, -0.00677091f, -0.17908032f, 0.09839014f, 
    0.17936659f, 0.05936275f, -0.02240660f, 0.00486920f, 0.11881881f, 0.11336762f, 0.32528716f, -0.06482162f, 
    -0.41697836f, -0.10479409f, 0.20920038f, 0.15267023f, -0.15028736f, 0.02772177f, -0.10271563f, -0.05979645f, 
    0.14959539f, 0.08389601f, -0.08551173f, -0.15477388f, -0.14028086f, -0.05122640f, 0.03934101f, 0.07735751f, 
    0.31306124f, 0.05801670f, -0.09390111f, 0.06018560f, -0.28707421f, -0.10984822f, 0.01898210f, 0.07447492f, 
    0.10051692f, 0.06404773f, 0.10410739f, 0.04573991f, -0.47092429f, -0.02353771f, 0.19772257f, -0.14842798f, 
    0.08519876f, 0.20172545f, -0.08843680f, 0.25319675f, 0.38366100f, 0.15940738f, 0.08667545f, 0.14000669f, 
    0.22128636f, 0.02572162f, -0.04120373f, -0.10064213f, -0.14057134f, -0.47044554f, 0.03823191f, -0.04986768f, 
    0.03264091f, 0.27696252f, -0.03869423f, 0.01552072f, 0.12135626f, -0.10795280f, -0.24733379f, 0.18129361f, 
    0.08907843f, 0.18412822f, 0.11311873f, -0.16273278f, -0.08246053f, 0.10577764f, 0.03216028f, 0.24772932f, 
    -0.04618163f, -0.06804526f, -0.04922438f, -0.01561743f, 0.16504925f, 0.04524215f, -0.18583944f, -0.31298026f, 
    -0.16831149f, 0.19947907f, -0.00261058f, 0.04180531f, -0.07935300f, -0.11821833f, -0.20036958f, -0.01479413f, 
    0.01716072f, 0.19959371f, 0.02001251f, -0.03665205f, 0.12624227f, 0.00164318f, 0.09301024f, -0.13732889f, 
    -0.51461035f, -0.12677851f, 0.23574792f, 0.02239061f, -0.04574628f, 0.00425451f, 0.03444066f, 0.00309236f, 
    0.19271576f, -0.39530826f, 0.14143072f, 0.20825958f, -0.19436045f, -0.04153558f, -0.14459948f, -0.18647406f, 
    -0.08245102f, 0.03036438f, 0.12911646f, 0.11937677f, -0.07688925f, -0.20060287f, -0.01406351f, -0.00866340f, 
    0.21928932f, 0.31323388f, -0.03306481f, 0.13417424f, 0.08924460f, -0.05895494f, 0.18286455f, 0.06471822f, 
    -0.05972312f, 0.02152920f, -0.34604955f, -0.17354707f, 0.32200110f, 0.31417695f, -0.33153740f, 0.13305391f, 
    0.08412490f, 0.14754531f, 0.12244342f, 0.02551183f, -0.06696077f, -0.31170401f, -0.33688918f, -0.02778379f, 
    0.20564528f, 0.10929883f, -0.09871177f, 0.05452864f, 0.14664793f, 0.15811558f, -0.17474000f, -0.04691638f, 
    0.21188556f, 0.11362897f, 0.14813645f, -0.15213868f, 0.06276602f, 0.00734154f, 0.07760237f, 0.00019914f, 
    0.03119488f, 0.07977945f, -0.08058517f, 0.00349399f, 0.26730564f, -0.00791468f, 0.13184753f, -0.08259340f, 
    -0.27248585f, 0.16289946f, 0.18752749f, 0.22721501f, -0.19994177f, 0.00033236f, -0.09224328f, -0.18649128f, 
    -0.00613637f, -0.18922710f, 0.13220811f, 0.19049619f, -0.26594809f, 0.09418602f, 0.03926344f, -0.03653105f, 
    -0.14790449f, -0.19660106f, 0.11563781f, -0.08322346f, -0.28845364f, 0.05955018f, -0.05552428f, -0.04748284f, 
    -0.08352292f, -0.09515232f, 0.33612067f, 0.12464381f, -0.01602930f, 0.05477375f, -0.45432681f, 0.14013828f, 
    -0.05709788f, -0.09204318f, 0.16968313f, 0.36620608f, 0.38064617f, 0.18514186f, 0.19256149f, -0.04716552f, 
    -0.04659388f, -0.04784329f, -0.06685130f, -0.27582690f, -0.26721776f, -0.11368787f, 0.03071632f, 0.25570178f, 
    0.06593533f, 0.30877349f, 0.06111294f, 0.00737735f, -0.14972581f, -0.03765209f, -0.64104164f, 0.14352790f, 
    -0.11212555f, -0.00522978f, -0.06028374f, 0.01454637f, -0.07355102f, 0.21150309f, -0.10715491f, -0.30199352f, 
    -0.15735874f, -0.13342722f, 0.04425763f, -0.12466665f, 0.11138052f, 0.06018410f, 0.05816037f, -0.32426941f, 
    -0.02174745f, 0.11271874f, 0.01938221f, -0.13806300f, -0.10387322f, -0.03010364f, 0.06700279f, 0.28048876f, 
    -0.14476611f, -0.12049633f, -0.02181310f, 0.42438224f, -0.00269369f, -0.15313984f, -0.14546816f, -0.08313998f, 
    0.13183163f, -0.08358064f, -0.17724040f, 0.10791772f, 0.12138045f, 0.09274682f, 0.15547863f, -0.12616724f, 
    0.26768914f, -0.03047219f, -0.13620299f, 0.39146066f, 0.02183096f, -0.19857009f, 0.14955676f, 0.02740871f, 
    0.14734949f, 0.00713744f, 0.01303708f, -0.12025217f, -0.31110099f, -0.12358757f, -0.02428963f, 0.05144464f, 
    0.12548667f, -0.05114515f, -0.02836436f, -0.06023842f, 0.03617845f, 0.09590468f, 0.28673321f, -0.00840270f, 
    0.08693358f, -0.03267880f, 0.02752924f, 0.20079218f, 0.18115102f, -0.17794280f, 0.23375924f, -0.28295460f, 
    -0.21483199f, 0.18269446f, 0.06925475f, -0.28619197f, 0.17206036f, -0.02225976f, -0.16001433f, 0.31767058f, 
    -0.14852330f, -0.20944388f, 0.08425289f, 0.12849310f, -0.10200830f, 0.21702541f, -0.17994839f, 0.15415986f, 
    0.15700297f, 0.08715191f, -0.07311156f, 0.05746131f, 0.20765664f, -0.04904113f, -0.22037207f, -0.00511427f, 
    0.10781361f, -0.54992670f, 0.31122443f, 0.03301705f, 0.01499209f, 0.00780635f, 0.22113809f, 0.24732615f, 
    0.03556714f, -0.04328651f, 0.11633748f, -0.26709780f, -0.14847985f, 0.07088504f, 0.11037112f, 0.19439618f, 
    -0.12609716f, 0.08257527f, 0.15099272f, 0.28843901f, 0.10749287f, -0.00130617f, -0.09292505f, 0.10433662f, 
    -0.08923149f, -0.02568614f, 0.08120332f, 0.05000449f, 0.31429324f, 0.27033350f, 0.11558080f, -0.15356000f, 
    -0.12483306f, -0.09624308f, -0.04116035f, -0.05218109f, 0.09930456f, 0.22348240f, -0.46214762f, 0.33291590f, 
    -0.20664287f, 0.09587206f, 0.06869359f, 0.18445170f, 0.05953022f, 0.02215405f, 0.27647591f, 0.03634248f, 
    0.24306752f, -0.05065187f, -0.06980185f, -0.02403764f, 0.01013359f, 0.04861748f, 0.00016788f, -0.21985325f, 
    0.14786865f, -0.17859031f, 0.09014113f, 0.04478607f, 0.13369410f, -0.05410464f, -0.01243632f, 0.00649868f, 
    -0.13654721f, -0.50455517f, -0.03544258f, 0.32689020f, -0.12175408f, 0.05750897f, -0.01115905f, -0.04058539f, 
    -0.07533242f, 0.06009720f, 0.04752047f, -0.01133680f, -0.04823959f, -0.10309028f, -0.05743506f, -0.02870833f, 
    0.03531424f, 0.05905345f, -0.69267696f, -0.24539134f, -0.11948269f, -0.03938356f, 0.04946680f, -0.01526772f, 
    -0.16499723f, 0.16939192f, 0.09178251f, -0.01868387f, 0.28061074f, 0.34337184f, 0.09395299f, -0.15033020f, 
    0.18480524f, 0.11781882f, 0.00988526f, -0.13013110f, 0.33328173f, 0.09710837f, -0.14893736f, -0.08996852f, 
    -0.10152332f, 0.06190579f, -0.02788778f, 0.00939626f, 0.11165044f, -0.12803623f, -0.40188766f, 0.17169960f, 
    -0.18495503f, -0.03707870f, -0.10382956f, 0.01808132f, 0.17561266f, 0.19956952f, 0.01097529f, -0.09759425f, 
    0.16289911f, -0.00670182f, 0.05850942f, -0.15793678f, -0.26356348f, -0.17902656f, -0.14039011f, -0.27449185f, 
    0.13380323f, -0.25060660f, -0.04931613f, 0.10532166f, 0.18364352f, -0.03869770f, -0.09737392f, 0.15342239f, 
    0.27384290f, -0.10008319f, 0.15804179f, -0.19253734f, -0.06764327f, 0.06078503f, 0.24275798f, -0.11199364f, 
    0.01255323f, -0.35782018f, 0.08280423f, -0.09816761f, -0.11281495f, 0.00948596f, 0.21549813f, 0.15606810f, 
    -0.06490065f, -0.00657952f, 0.27917391f, 0.11553585f, -0.26580617f, -0.02091990f, -0.01879863f, -0.02591306f, 
    -0.12777056f, -0.19433898f, 0.04703077f, -0.31044269f, 0.08204155f, 0.10521074f, 0.17064293f, 0.11250319f, 
    0.09288734f, 0.20093457f, 0.12167557f, -0.07242610f, 0.56781524f, 0.10007180f, -0.05856305f, -0.14692679f, 
    -0.15005518f, 0.21745512f, -0.11411225f, -0.05892989f, 0.06322397f, -0.20518064f, -0.02700378f, -0.16245700f, 
    0.02865401f, 0.08310968f, 0.19756329f, -0.08502381f, 0.11101702f, -0.09377662f, 0.40259358f, 0.13962232f, 
    -0.24882989f, 0.08709708f, -0.03802916f, 0.23707816f, -0.23442511f, 0.13509874f, 0.25294149f, 0.05633900f, 
    -0.32408151f, -0.26070762f, -0.43598005f, -0.07583722f, -0.26688260f, -0.07430904f, -0.00062405f, 0.08426379f, 
    -0.00741005f, 0.08995359f, -0.09490439f, -0.03900784f, 0.00935741f, 0.06730217f, -0.31266165f, 0.11892155f, 
    0.17753923f, 0.19929835f, -0.25020400f, -0.05250257f, -0.11755492f, -0.07475058f, 0.24668325f, -0.05426403f, 
    0.15401608f, -0.02701854f, 0.25264651f, -0.17965868f, -0.07840104f, 0.14861962f, 0.08716137f, 0.06098420f, 
    0.12299512f, 0.16947386f, 0.07276107f, 0.07104610f, 0.17747559f, 0.09010118f, -0.22584923f, -0.06481735f, 
    -0.10959910f, -0.12693767f, -0.07828152f, -0.05430621f, 0.51894808f, -0.43475637f, -0.23914540f, -0.12552220f, 
    -0.02943585f, -0.36670056f, 0.02661346f, -0.12470178f, 0.20804885f, 0.00202873f, 0.04958719f, -0.12598507f, 
    -0.09370290f, -0.17734684f, 0.07620101f, 0.11485464f, 0.06453824f, 0.07922193f, -0.08580699f, -0.10196167f, 
    -0.02793625f, 0.03627161f, 0.03095883f, 0.10719308f, 0.15253456f, -0.22382557f, -0.19242828f, 0.41309562f, 
    0.14098819f, -0.11329895f, -0.07012621f, 0.06727468f, 0.08919722f, 0.05538972f, 0.02305742f, 0.16294788f, 
    -0.02289586f, -0.03725969f, 0.03787306f, -0.02077830f, -0.03160080f, -0.04554204f, 0.04024285f, -0.07991688f, 
    -0.05695760f, 0.01395092f, 0.01974333f, -0.05399331f, 0.02635587f, -0.02980121f, 0.04459426f, -0.00985915f, 
    0.04286115f, 0.01232770f, -0.03375930f, -0.05351599f, -0.06479355f, -0.02973344f, -0.03478027f, -0.02786709f, 
    -0.02404227f, -0.04194460f, 0.03289514f, 0.02948188f, -0.00079148f, -0.03304313f, 0.01701427f, 0.03935598f, 
    0.03902488f, -0.04126216f, 0.02523946f, -0.03149919f, 0.00599240f, 0.04728860f, -0.06324711f, -0.06858312f, 
    -0.03728657f, -0.01278215f, -0.06701964f, -0.04923886f, -0.02089749f, 0.04641453f, -0.04127849f, -0.04168709f, 
    0.00312261f, 0.00560421f, -0.06430721f, 0.02121929f, -0.04380159f, 0.00060355f, 0.05469356f, 0.05536077f, 
    -0.03274264f, -0.05265215f, 0.00907371f, 0.03733063f, -0.06454096f, -0.00044927f, -0.03911831f, 0.00369656f, 
    -0.00136219f, -0.03414977f, -0.05787603f, -0.01316037f, -0.07141140f, -0.07334291f, -0.04010852f, 0.05194836f, 
    -0.03872434f, 0.04261938f, -0.05711821f, -0.05000035f, 0.03832327f, 0.04234353f, -0.00493638f, -0.05185112f, 
    -0.03934942f, -0.03282417f, -0.02759058f, 0.03474844f, 0.00747462f, -0.02165262f, 0.03401441f, 0.00456110f, 
    -0.00266708f, -0.06963323f, 0.05815068f, -0.00628915f, -0.00104169f, 0.05357561f, -0.03188691f, 0.00735449f, 
    0.01746812f, -0.00325691f, -0.04467040f, 0.05186427f, -0.00441329f, -0.05163080f, -0.05709401f, 0.00272745f, 
    -0.03589797f, -0.01611009f, -0.06366847f, 0.02340480f, 0.03474388f, -0.03043350f, -0.00521454f, 0.01053848f, 
    -0.01732060f, -0.05520628f, -0.03696753f, -0.04806267f, 0.01459747f, -0.05649130f, -0.04311164f, -0.04366547f, 
    -0.04913154f, 0.01139245f, 0.04950786f, -0.05469842f, -0.05192610f, -0.04761390f, 0.02049414f, -0.01979120f, 
    0.02866177f, 0.02724610f, -0.02717412f, -0.02591999f, 0.05141571f, -0.01346842f, -0.00431562f, -0.00509510f, 
    0.01913604f, 0.04326150f, -0.00208835f, 0.00144520f, -0.02965255f, 0.02048816f, -0.00333512f, 0.03944179f, 
    0.02866040f, -0.01172138f, -0.05429161f, -0.05936543f, -0.02877377f, -0.00240804f, -0.03558484f, -0.00265697f, 
    0.03034336f, -0.07035654f, -0.03254065f, -0.01051456f, -0.03516040f, -0.00132102f, -0.02706124f, 0.03162258f, 
    -0.02721770f, 0.02964522f, -0.02928683f, 0.03650350f, 0.01807669f, 0.03093806f, -0.02220224f, -0.03047782f, 
    0.04540111f, 0.01875038f, 0.03120402f, 0.02019656f, -0.05136792f, -0.06227801f, 0.03019099f, 0.00632191f, 
    -0.00534155f, -0.00896931f, 0.00676677f, 0.03070775f, -0.05946716f, -0.02280062f, 0.05717884f, -0.06805739f, 
    -0.04299432f, 0.02087024f, -0.03478303f, -0.04741445f, 0.04184477f, -0.02428699f, 0.03065391f, -0.07035161f, 
    -0.02502621f, -0.06384584f, -0.00850471f, 0.02350836f, -0.07740857f, -0.01537578f, -0.02245326f, -0.03068131f, 
    -0.03291197f, -0.00160977f, -0.06437100f, 0.04023845f, -0.05316833f, -0.01094731f, -0.01571212f, -0.03707425f, 
    -0.02723067f, -0.00460495f, -0.00456686f, -0.01822628f, -0.05331466f, 0.06352929f, 0.02249023f, -0.00209341f, 
    0.01312841f, -0.01454408f, -0.04269491f, 0.00429627f, 0.01435498f, -0.01576597f, -0.03523606f, -0.00974920f, 
    -0.02814014f, 0.04494045f, 0.00230994f, 0.02439880f, -0.02028622f, 0.01705222f, -0.00539991f, -0.03634410f, 
    0.01316696f, 0.03274282f, 0.01991735f, 0.02220304f, -0.01956664f, -0.04430349f, -0.04428287f, -0.04450556f, 
    -0.05056022f, -0.04008479f, -0.02442452f, 0.05156980f, 0.00578710f, 0.03005904f, 0.03859271f, 0.03885026f, 
    -0.06866542f, -0.03272131f, -0.01236996f, -0.04741838f, 0.01643576f, -0.06174000f, -0.05616276f, 0.02482569f, 
    0.00785777f, -0.02367709f, 0.03853955f, -0.02840270f, -0.02220664f, 0.01527493f, -0.00782918f, -0.02311725f, 
    -0.01620508f, -0.02375963f, -0.00348892f, -0.00855214f, 0.00529975f, 0.00829950f, -0.02804515f, -0.04873962f, 
    -0.00999576f, -0.05662919f, 0.01489342f, 0.04723618f, -0.04101149f, 0.00587692f, -0.05186704f, -0.03056742f, 
    0.03332516f, -0.03037047f, 0.02416323f, -0.00885163f, -0.03139588f, 0.00456268f, 0.03415608f, 0.04595631f, 
    0.20220441f, -0.01942671f, -0.14271207f, 0.01918932f, 0.01023552f, 0.16134427f, 0.01203190f, 0.15904568f, 
    -0.15675877f, 0.30881572f, 0.26375350f, 0.17470820f, 0.14274646f, -0.18431188f, -0.10466006f, -0.26670727f, 
    -0.03707883f, -0.12754522f, -0.02601364f, -0.21183199f, -0.09195544f, -0.07448518f, 0.14223777f, -0.04882582f, 
    0.14233837f, -0.05150878f, 0.16515063f, -0.12056056f, 0.14868790f, 0.14058189f, 0.02446467f, 0.10246913f, 
    -0.31605214f, 0.02138703f, 0.00141059f, 0.11443478f, 0.17775129f, 0.06643780f, 0.13547882f, -0.03385269f, 
    -0.00544083f, 0.22377066f, -0.23114130f, -0.10257055f, 0.08218586f, 0.18888153f, -0.12744518f, -0.18162961f, 
    0.15054351f, -0.04847293f, -0.07364455f, 0.02962531f, 0.03572663f, 0.06887314f, 0.18522759f, 0.06285065f, 
    -0.03298233f, -0.16469236f, 0.30100286f, -0.01437958f, -0.02640263f, 0.04438838f, 0.03486537f, 0.03407328f, 
    0.19280361f, -0.12921460f, 0.12745963f, 0.15033063f, 0.18408501f, 0.02635411f, -0.10791933f, -0.01357767f, 
    0.11228770f, -0.04672110f, 0.01735445f, 0.17522006f, -0.26457584f, 0.10445106f, 0.13369867f, -0.05048554f, 
    -0.07213248f, 0.17792495f, 0.28406623f, -0.27167314f, 0.08219102f, 0.10699955f, -0.10809690f, 0.18575202f, 
    -0.09540512f, -0.23272438f, -0.33844221f, 0.17779297f, -0.15458812f, 0.18489742f, -0.06420515f, 0.03205709f, 
    -0.03894537f, -0.17615184f, 0.17904031f, 0.07525209f, -0.04675136f, 0.09895341f, -0.01518606f, 0.22862756f, 
    -0.12365284f, -0.04217710f, 0.13318206f, 0.02278670f, -0.14829636f, 0.18668549f, -0.01100435f, -0.07931995f, 
    0.04024323f, 0.10098428f, -0.16600776f, -0.00932701f, -0.00292803f, 0.28636968f, 0.16660887f, 0.02605977f, 
    -0.13188466f, -0.18449549f, -0.02351360f, -0.12583709f, 0.09604947f, -0.02761268f, -0.47962585f, -0.25180745f, 
    0.10915998f, 0.16213463f, 0.27072537f, -0.12659468f, 0.02577986f, -0.08113893f, -0.02595863f, 0.48592490f, 
    0.25680763f, -0.15913038f, 0.20506673f, 0.03369636f, -0.00457689f, 0.06757049f, -0.14905693f, 0.14115372f, 
    0.51622605f, -0.25171497f, -0.22135964f, 0.10430604f, -0.02863324f, -0.20014153f, 0.26210803f, 0.14709339f, 
    0.07719017f, 0.05110104f, -0.05298594f, -0.04774455f, -0.04950967f, -0.03804028f, -0.13477658f, 0.25300619f, 
    0.11658709f, 0.32605320f, 0.08117867f, -0.02808450f, -0.11176084f, -0.20744069f, -0.23669556f, 0.15672390f, 
    0.02451082f, -0.10475419f, 0.00494742f, 0.24459386f, -0.06424155f, -0.31451830f, 0.00237171f, -0.06952656f, 
    0.12485655f, -0.00576224f, -0.02113010f, -0.00629964f, 0.00794679f, -0.01923410f, -0.11728333f, 0.00912581f, 
    0.01876843f, 0.05829998f, -0.10310616f, 0.10469244f, 0.04188391f, 0.20401663f, -0.15354848f, -0.13636415f, 
    0.06833436f, -0.05720385f, -0.09527188f, -0.02680687f, -0.10641575f, -0.00888945f, -0.30598971f, 0.15856189f, 
    0.11092342f, 0.26234671f, -0.08085836f, 0.10558093f, 0.10681416f, 0.01034267f, -0.02103815f, -0.23947501f, 
    0.14470883f, -0.32716507f, -0.01658047f, 0.03093694f, -0.01552856f, 0.09695847f, -0.02608346f, -0.06071982f, 
    -0.31592143f, 0.07448813f, -0.10275030f, -0.07227930f, -0.12343802f, -0.18013842f, 0.19197504f, -0.05208490f, 
    0.09642260f, -0.04236680f, -0.00022004f, -0.02356813f, 0.17696084f, -0.00083356f, 0.10884017f, -0.03415544f, 
    -0.14294320f, -0.11981565f, 0.18596192f, -0.28787062f, -0.28121546f, -0.01207350f, 0.04219900f, 0.17734574f, 
    0.16193865f, -0.02174515f, -0.02754408f, 0.07886815f, 0.14526083f, 0.22003333f, -0.20270282f, 0.12402248f, 
    -0.19502090f, -0.11465136f, 0.00936222f, 0.00967970f, 0.24138688f, 0.45355645f, -0.37724110f, 0.16885643f, 
    -0.20810057f, 0.03744383f, 0.04931134f, 0.08407404f, 0.16012044f, -0.06739882f, -0.24145338f, -0.25469455f, 
    0.15427917f, 0.07994387f, 0.07970674f, -0.10716958f, 0.11226514f, -0.18369687f, -0.59060502f, -0.07081547f, 
    0.09480409f, 0.09410465f, -0.11278456f, 0.13656245f, 0.02641561f, 0.04455210f, -0.16385351f, -0.15891337f, 
    0.07909795f, 0.12518366f, 0.04809473f, 0.03175305f, 0.01264912f, -0.04154732f, 0.10738934f, 0.04486792f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.04137569f, -0.00437271f, -0.07837842f, -0.06473623f, 0.03691103f, 0.01750694f, 0.16757035f, 0.09495502f, 
    0.16634883f, 0.02748585f, 0.14853983f, 0.03597675f, 0.02164383f, -0.07663350f, -0.02594598f, -0.04279092f, 
    0.03185298f, 0.06378284f, 0.01112080f, 0.00904198f, -0.07905016f, 0.02353281f, -0.05397676f, 0.15010719f, 
    -0.09657228f, 0.10503624f, 0.03676017f, -0.10779192f, 0.08325363f, -0.02982870f, 0.01115952f, 0.03030306f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.15538406f, -0.13730524f, -0.01118321f, -0.20721845f, -0.02208476f, -0.07919851f, -0.08754559f, 0.06136343f, 
    -0.23679565f, -0.29391634f, 0.31470808f, 0.00509411f, 0.15583879f, 0.58063561f, 0.14490657f, 0.01296449f, 
    -0.16189174f, -0.41727659f, 0.01828610f, 0.07251193f, 1.01057470f, -0.04033546f, -0.16198830f, -0.38431153f, 
    -0.15759613f, -0.12014255f, -0.15737639f, -0.31497157f, 0.28115210f, -0.06422970f, 0.09965682f, -0.81337553f, 
    0.10196918f, -0.17259204f, -0.52222735f, -0.30613792f, -0.44436324f, 0.07887238f, -0.20605651f, 0.69760686f, 
    0.00734636f, 0.75294739f, 0.26969647f, 0.01079414f, -0.13335946f, -0.04738256f, -0.12965529f, -0.06143449f, 
    0.06472703f, 0.58138269f, 0.08035128f, -0.17664102f, 0.00600138f, -0.02964040f, -0.16959926f, -0.17401753f, 
    0.11015948f, -0.35587698f, 0.04986627f, -0.02807446f, 0.08209244f, -0.21773969f, 0.01855062f, -0.27065137f, 
    0.11038540f, -0.04149340f, 0.20970641f, 0.57212204f, -0.11460911f, 0.04375795f, -0.66054195f, 0.25470382f, 
    0.13731849f, 0.18433633f, -0.34438312f, -0.10981314f, 0.25329724f, -0.25776294f, -0.07959459f, -0.03386421f, 
    0.16109665f, -0.38003156f, 0.03239949f, 0.06570727f, -0.32524160f, -0.05869868f, 0.09331027f, -0.23466581f, 
    -0.87186652f, -0.03199049f, -0.00126999f, -0.79377991f, 0.02003087f, 0.80388564f, -0.01901202f, 0.06592999f, 
    0.14666824f, 0.00168714f, -0.07171452f, 0.11690257f, 0.20248669f, 0.00439893f, 0.40409347f, -0.65742356f, 
    0.68033773f, 0.11038297f, -0.09366938f, 0.03054605f, -0.01333125f, -0.43033251f, 0.04674671f, 0.14729321f, 
    -0.11239583f, -0.32476461f, -0.38471964f, -0.05380369f, 0.22301169f, -0.01976811f, 0.08442642f, -0.44860822f, 
    0.10815364f, 0.06647003f, -0.26461059f, 0.60859084f, -0.19936095f, 0.02320977f, 0.12960522f, -0.61168998f, 
    -0.06524490f, -0.01510350f, 0.29911074f, 0.34035704f, 0.22695686f, -0.14204443f, -0.37371257f, -0.22022359f, 
    0.09581558f, -0.33797774f, 0.05959613f, -0.12372206f, -0.41792509f, 0.15425883f, 0.01924867f, -0.00493345f, 
    -0.13825233f, 0.39937440f, -0.58972466f, 0.11515627f, -0.01365974f, 0.06873834f, -0.05725786f, 0.53561312f, 
    -0.19700828f, 0.41919696f, -0.33089668f, -0.11608546f, -0.21498212f, -0.07167494f, 0.01493343f, -0.21968417f, 
    -0.07853901f, -0.04336359f, -0.19521141f, -0.17821407f, -0.36864665f, 0.09574042f, 0.26228136f, 0.14888151f, 
    -0.59207326f, -0.46781570f, 0.43384758f, 0.15835720f, -0.46548274f, 0.13895856f, 0.11851670f, 0.11839406f, 
    -0.02214805f, -0.43791145f, -0.08500665f, 0.15965833f, -0.46942750f, -0.07843185f, 0.04933989f, 0.33875579f, 
    0.36977157f, -0.62664288f, -0.00418058f, -0.30212367f, 0.62677717f, 0.14561594f, 0.02133453f, -0.05557984f, 
    0.16156642f, -0.04655856f, -0.14419670f, 0.38146558f, 0.02906991f, 0.02828550f, -0.15399554f, -0.66172987f, 
    0.41794452f, 0.18667720f, 0.09633984f, -0.00565844f, -0.08110728f, -0.25245899f, 0.11147901f, -0.05041155f, 
    0.11616015f, -0.20389302f, 0.63504428f, 0.02678865f, -0.58076435f, 0.03263109f, -0.04846177f, 0.50067723f, 
    -0.93807584f, -0.11190426f, -0.53613514f, -0.23917565f, -0.20725983f, -0.76967990f, -0.04344957f, -0.27413231f, 
    0.09620776f, 0.09067645f, 0.36072949f, 0.27920964f, -0.14815384f, -0.15828177f, -0.48217654f, -0.09037352f, 
    -0.64756101f, -0.07242995f, -0.35912293f, 0.12182737f, 0.33816236f, 0.39953241f, 0.16657618f, -0.07742886f, 
    0.11789179f, 0.17905007f, -0.39734721f, -0.00697514f, 0.54039037f, -0.13545506f, -0.16557366f, -0.20413829f, 
    0.40320921f, -0.15234077f, 0.09748229f, 0.43448040f, -0.26476640f, -0.19203757f, 0.03159144f, 0.02750377f, 
    0.09524377f, -0.00877282f, -0.10811222f, -0.66829848f, -0.43167248f, -0.14302868f, 0.11858375f, 0.04088278f, 
    -0.67073339f, -0.00555041f, -0.11430842f, -0.15594608f, 0.02657698f, -0.35632104f, -0.17715172f, -0.12745880f, 
    0.03907667f, 0.61430860f, 0.17216825f, -0.13561310f, 0.35669193f, -0.14699198f, 0.12045917f, -0.00301212f, 
    -0.20664509f, 0.53975064f, 0.77345771f, 0.16791603f, -0.64169592f, -0.41515324f, 0.01407158f, 0.28317925f, 
    -0.10240966f, 0.07688881f, 0.48898235f, -0.51176286f, 0.40258327f, 0.07959716f, -0.39332163f, -0.62968844f, 
    -0.26932371f, -0.36590913f, -0.24914764f, -0.02260860f, -0.05353693f, 0.00604131f, -0.03839005f, -0.11796933f, 
    0.17295472f, 0.31978181f, 0.39974478f, 0.07038383f, -0.31730705f, 0.03735470f, -0.06000999f, -0.25785774f, 
    -0.06065908f, -0.30197209f, 0.70047200f, -0.47663000f, 0.47612610f, 0.15519729f, 0.07059810f, -0.07591815f, 
    -0.05436052f, -0.11770073f, -0.36272430f, -0.07126837f, -0.25070596f, -0.07163486f, 0.40063244f, 0.46171251f, 
    0.47193789f, -0.41203007f, 0.10154992f, 0.04018902f, 0.69963652f, -0.60960609f, -0.08049376f, -0.11228703f, 
    -0.04636016f, -0.17115809f, -0.21866025f, -0.07305357f, -1.00575745f, -0.02970891f, 0.04918803f, -0.48683411f, 
    0.31040457f, 0.29457858f, 0.00283658f, -0.39569354f, -0.42843810f, 0.01970439f, -0.02401846f, 0.40123862f, 
    0.15523472f, 0.09539277f, -0.23035271f, -0.10957834f, 0.43771335f, -0.08440993f, 0.45804861f, -0.14616257f, 
    -0.09919515f, 0.08666965f, -0.69507909f, -0.10667755f, -0.30967677f, 0.06122202f, -0.14256686f, 0.00066000f, 
    0.03748812f, -0.74107361f, 0.18692344f, -0.01971065f, -0.19866484f, 0.13440724f, 0.12096944f, -0.25076574f, 
    -0.68612283f, 0.24761467f, -0.40537664f, -0.03259572f, -0.12999421f, 0.00064066f, -0.03248255f, 0.72935086f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05894304f, -0.09116177f, -0.24640918f, -0.03063033f, -0.04166443f, 0.00066526f, 0.00566094f, -0.19804618f, 
    -0.10184640f, 0.24566184f, 0.24592331f, 0.09028786f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
