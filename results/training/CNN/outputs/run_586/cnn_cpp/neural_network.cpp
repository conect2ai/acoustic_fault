#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.23597991f, -0.47353202f, 0.11992019f, 0.65871060f, -0.62958044f, 0.48201984f, 0.15348670f, -0.16089091f, 
    0.19616693f, 0.31488961f, -0.45962539f, -0.37840754f, 0.79093862f, 0.50038320f, -0.52857780f, 0.06631000f, 
    0.08473095f, 0.31491259f, -0.35872883f, 0.21207125f, -0.04125943f, 0.43659732f, 0.92122167f, 0.29816192f, 
    -0.07640938f, -0.26304397f, -0.08911175f, -0.13544123f, -0.48493850f, -0.33759615f, -0.13035552f, 0.94592470f, 
    -0.44508743f, 0.13727251f, -0.18457329f, -0.24711844f, -0.27880925f, 0.45298314f, -0.41063857f, 0.57599479f, 
    0.00558841f, 0.64804405f, -0.41096491f, 0.05773208f, -0.53348768f, 0.44676253f, 0.79539400f, 0.09715086f, 
    -0.40170783f, -0.00921869f, 0.05722053f, -0.16445312f, -0.20431508f, -0.28956273f, -0.96990740f, 0.36492425f, 
    0.14647141f, -0.17216517f, 0.82374001f, 0.38340202f, -0.27150917f, 0.22966902f, 0.21077371f, 0.98432833f, 
    0.45292315f, 0.38083017f, 0.49448687f, 0.51044756f, 0.51477003f, 0.20756006f, 0.15770099f, -0.33288106f, 
    0.47488883f, 0.67140508f, 0.52796376f, -0.53170216f, 0.68471384f, -0.47283524f, -0.07006636f, 0.08029038f, 
    0.21396655f, 0.88432133f, 0.00382907f, -0.00821323f, 0.27566200f, -0.51443917f, -0.28222921f, -0.47012484f, 
    0.20400241f, -0.41130278f, -0.52106625f, -0.36524311f, -0.10237516f, -0.71064419f, -0.41713774f, -0.42150435f, 
    -0.13210128f, 0.05170954f, -0.62036502f, -0.23369795f, 0.42067879f, -0.35961860f, -0.62371999f, -0.45623890f, 
    0.09565233f, -0.45923907f, 0.30762696f, -0.26393199f, 0.56758314f, 0.62408638f, 0.60011333f, -0.69726896f, 
    -0.11063497f, -0.41597348f, -0.03012937f, 0.08668895f, 0.51578146f, 0.46497712f, 0.64818180f, -0.84874362f, 
    0.02886121f, 0.22777557f, 0.02444783f, 0.16567042f, -0.08603072f, -0.06801185f, -0.31078815f, -0.46665791f, 
    0.33805221f, -0.58014995f, 0.53329366f, -0.60069537f, -0.01326001f, 0.43883708f, 0.14114510f, 0.15409200f, 
    -0.07208699f, -0.01465048f, -0.56257576f, 0.75172019f, 0.70174807f, -0.29719457f, -0.06643393f, -0.39903307f, 
    -0.52659786f, -0.54161447f, -0.57250553f, 0.53173780f, 0.22785498f, 0.31450704f, -0.23532280f, -0.14644492f, 
    -0.08565927f, -0.35019574f, 0.76880276f, -0.29082811f, -0.06123379f, 0.54776067f, 0.28272033f, 0.17037621f, 
    0.09599819f, -0.38690835f, 0.59856474f, -0.29299885f, 0.70953315f, 0.21377523f, 0.02769999f, 0.37870464f, 
    -0.17803247f, -0.23787642f, 0.37842911f, -0.27565086f, -0.58837581f, -0.55513257f, -0.29035735f, -0.21908371f, 
    0.01781946f, -0.42182496f, 0.49028537f, 0.05723107f, -1.14487588f, -0.25894347f, 0.26220104f, 0.19864759f, 
    -0.40425721f, 0.05248774f, 0.27014360f, -0.03740060f, 0.39630395f, -0.62553734f, -0.56767404f, -0.08906895f, 
    0.54795516f, 0.52877277f, 0.46504810f, 0.21240504f, -0.14969689f, 0.15033016f, 0.82041293f, 0.51688617f, 
    0.56098855f, 0.39078644f, -0.13327490f, -0.36960188f, 0.41279715f, -0.04096949f, 0.16321371f, 0.46256459f, 
    0.13586035f, 0.20694691f, -0.12348786f, -0.35599291f, 0.77042890f, 0.50829476f, -0.19254309f, -0.55234480f, 
    -0.59077924f, -0.39770496f, -0.35120302f, 0.01938830f, 0.26958549f, 0.18822423f, 0.02789805f, -0.55466026f, 
    0.04196422f, -0.53707409f, -0.50219291f, -0.60837752f, 0.13684419f, -0.32118958f, 0.27794525f, 0.27950230f, 
    0.03609338f, -0.12922356f, -0.36760753f, 0.35747203f, 0.45428604f, 0.45065135f, 0.23123491f, 0.44082499f, 
    0.47506800f, -0.28787220f, 0.36136550f, -0.33153763f, -0.61367112f, -0.44131282f, 0.31793520f, 0.22519743f, 
    0.32497537f, -0.45136884f, 0.24513945f, -0.23686558f, -0.44059369f, -0.75235438f, -0.49487123f, -0.73149019f, 
    -0.22670887f, 0.15416349f, -0.06219522f, -0.01612813f, 0.15067670f, -0.00607147f, 0.76700228f, -0.45752650f, 
    0.00413893f, -0.86647040f, -0.57926351f, -0.17016117f, -0.14443190f, 0.06427114f, 0.38251108f, 0.56417978f, 
    0.78496844f, -0.51198018f, -0.46021369f, -0.39893827f, 0.26521030f, -0.15655732f, -0.33961847f, 0.42029020f, 
    -0.55864590f, -0.50883448f, -0.12678812f, -0.75157195f, -0.20016886f, 0.56214225f, 0.02318889f, 0.05356301f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.21221675f, 0.16708992f, -0.08526503f, -0.13245711f, -0.14163855f, -0.31215620f, -0.07365602f, -0.41869017f, 
    -0.15850760f, 0.18928140f, -0.08636969f, 0.23847824f, -0.08945493f, -0.06109491f, -0.20603083f, -0.19083111f, 
    -0.02271810f, -0.12361358f, 0.35291269f, 0.20049116f, 0.25730714f, 0.06120969f, 0.06544527f, 0.07732288f, 
    -0.13933150f, 0.00469004f, -0.10698596f, 0.20041293f, 0.21517788f, 0.23800646f, 0.15254216f, 0.10869034f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.10922094f, 0.04547669f, 0.15202957f, -0.08202809f, 0.21686938f, 0.00835150f, -0.16606842f, 0.01145779f, 
    -0.06790699f, -0.05307996f, 0.12886773f, -0.00528163f, 0.00614300f, 0.04296118f, 0.13513695f, -0.09600252f, 
    0.10029438f, -0.02096330f, -0.08807140f, 0.02080747f, 0.02398326f, -0.09694755f, -0.07087218f, 0.12584588f, 
    -0.00523843f, -0.06067056f, 0.11452069f, -0.22135554f, 0.11489417f, 0.19779263f, -0.08286122f, -0.08116400f, 
    0.14814152f, -0.03004782f, 0.07048762f, 0.18097793f, -0.00099004f, -0.01985295f, 0.11451857f, 0.04053653f, 
    0.04486011f, 0.18997073f, 0.06767955f, -0.13765994f, 0.03870380f, -0.00180557f, 0.15082930f, -0.16202410f, 
    0.13232264f, 0.07949644f, -0.09133727f, 0.07474680f, -0.08578031f, -0.07964072f, 0.02273973f, 0.18541829f, 
    -0.05357281f, -0.08323922f, -0.04417727f, 0.06295455f, 0.18284199f, -0.03004597f, -0.09052728f, -0.03111702f, 
    -0.21733448f, -0.03788297f, -0.03957789f, 0.16315922f, 0.28137493f, -0.08148517f, -0.05288974f, -0.23349501f, 
    -0.12875536f, 0.18441254f, -0.01277604f, -0.10245323f, 0.14042564f, -0.00564027f, 0.05220228f, -0.07812314f, 
    0.07079468f, 0.22315091f, 0.14353393f, 0.10829204f, 0.15877427f, -0.10697871f, 0.14304557f, 0.14668055f, 
    0.10910837f, -0.08097584f, -0.17933981f, 0.12462094f, 0.19325794f, 0.00633129f, 0.01516377f, -0.09512852f, 
    -0.05431994f, 0.09197014f, 0.05141515f, -0.02920374f, 0.04595096f, 0.13198371f, -0.09633660f, -0.00020890f, 
    -0.02260455f, 0.04063105f, 0.10848843f, 0.01255287f, 0.04342959f, 0.09563901f, -0.13567543f, -0.01813174f, 
    0.01069861f, -0.05802853f, 0.13144659f, -0.00612636f, -0.10346287f, 0.27857971f, 0.10563940f, 0.10322017f, 
    -0.01061105f, 0.03345776f, 0.12912385f, 0.21011561f, -0.10600659f, 0.04867242f, -0.29268491f, 0.12036425f, 
    -0.12228622f, 0.07164190f, -0.12336952f, 0.08353964f, -0.00087121f, -0.03608789f, 0.09892352f, -0.13718791f, 
    0.08461385f, 0.20238416f, -0.24563156f, 0.07935112f, 0.06096398f, 0.07617532f, 0.01429791f, -0.03080468f, 
    -0.13118069f, -0.22343886f, 0.27223414f, 0.04383980f, -0.00334670f, 0.06891982f, -0.13624935f, -0.04037412f, 
    0.06629006f, -0.06801079f, 0.08401912f, 0.09452583f, -0.12533098f, -0.01605385f, 0.21774264f, -0.01541166f, 
    -0.17488723f, 0.01966316f, 0.18743585f, -0.01321890f, -0.22752571f, -0.01384226f, 0.03565259f, 0.03434093f, 
    0.01088045f, 0.11793534f, -0.09621792f, 0.02661350f, 0.04720644f, 0.04265809f, 0.12031914f, -0.18701309f, 
    0.13809370f, 0.01792280f, -0.15181448f, -0.08327601f, 0.01478020f, 0.15548234f, -0.01686083f, -0.11360364f, 
    0.11835190f, 0.02316208f, 0.15981972f, 0.09174722f, -0.11473110f, -0.16896360f, -0.16129869f, 0.03690700f, 
    0.03669584f, 0.05927769f, 0.00434266f, -0.06685469f, -0.15804607f, -0.01295356f, 0.03064185f, 0.03181122f, 
    -0.14937767f, 0.01969655f, -0.07107332f, 0.04857014f, -0.15298958f, -0.07274593f, 0.05369977f, -0.13363120f, 
    0.07782527f, -0.15023750f, 0.00758156f, 0.09573134f, 0.14131935f, 0.03003921f, -0.03738785f, -0.25554886f, 
    -0.12298763f, -0.27861464f, 0.09761667f, -0.05521676f, -0.00214741f, 0.06040848f, -0.08116470f, 0.00170542f, 
    0.05871268f, -0.07244200f, -0.11549712f, -0.01719152f, 0.07402727f, 0.05301363f, 0.19872779f, 0.03703513f, 
    -0.08605100f, -0.00206514f, -0.01033943f, -0.10360010f, -0.12057687f, 0.04082364f, 0.10036280f, 0.05273812f, 
    0.02975814f, 0.01638813f, -0.05377485f, -0.18054038f, -0.17013887f, 0.24403919f, 0.00951175f, -0.01682100f, 
    0.04329082f, -0.03663333f, -0.12150836f, 0.09762024f, -0.04480422f, -0.07225159f, 0.08943585f, 0.05988407f, 
    -0.00415055f, 0.03468939f, 0.03263504f, -0.00258917f, -0.12189059f, 0.21797749f, 0.06159733f, 0.01770206f, 
    0.07488889f, 0.07281714f, -0.11777391f, 0.03301016f, -0.05614002f, 0.18311845f, -0.03860569f, 0.17891194f, 
    -0.16839930f, 0.13934404f, -0.02964609f, -0.01801129f, 0.05491264f, -0.04926893f, 0.02005903f, 0.02132438f, 
    0.04870721f, -0.05108687f, -0.05103088f, 0.07106530f, -0.01838707f, 0.17510951f, 0.03636991f, -0.10317981f, 
    -0.02460505f, 0.08528107f, -0.20425977f, -0.01799568f, 0.04689369f, -0.11666322f, -0.02617954f, 0.10495941f, 
    0.10284994f, 0.13544980f, 0.11606234f, 0.09726356f, -0.14710681f, -0.11255508f, 0.00965904f, 0.06931430f, 
    0.14332847f, 0.07799561f, 0.11524177f, 0.16762266f, 0.16823123f, 0.01676790f, -0.08870409f, -0.08335781f, 
    0.11040676f, 0.07772978f, -0.03886155f, -0.06073602f, 0.27901751f, 0.23311220f, -0.19890176f, -0.02904475f, 
    0.08993232f, 0.03218391f, -0.07162995f, 0.08335977f, 0.02076182f, -0.07295196f, 0.07963767f, -0.13441947f, 
    0.11502945f, 0.13039181f, 0.00574031f, 0.02971403f, -0.26079682f, -0.27752799f, 0.14030145f, 0.01053736f, 
    0.01215329f, 0.00351753f, 0.10012306f, 0.14531825f, -0.03399504f, -0.32066232f, 0.12448775f, 0.03666486f, 
    -0.08085959f, 0.10180105f, -0.04710354f, -0.01113803f, 0.08285800f, 0.09258589f, -0.14671972f, 0.13200773f, 
    0.01527226f, 0.04876263f, -0.07647881f, 0.03042478f, 0.15650974f, -0.11220670f, 0.02047902f, -0.12613368f, 
    0.00474964f, -0.10969879f, -0.06609815f, -0.05492045f, 0.02950282f, 0.00779210f, -0.00050534f, 0.11118869f, 
    -0.13019815f, 0.00061526f, 0.17395969f, 0.01865068f, -0.22368740f, -0.11862490f, 0.05286739f, 0.09047967f, 
    -0.05111531f, -0.07591316f, 0.21153118f, -0.06530464f, 0.04498950f, 0.28261483f, 0.06505891f, -0.08397073f, 
    -0.14450440f, -0.06832995f, -0.01352453f, -0.13465269f, 0.06073764f, -0.14315519f, -0.08938454f, 0.06095476f, 
    -0.07303747f, -0.00451209f, -0.05212412f, -0.02784262f, -0.03493072f, -0.07567844f, -0.03203627f, -0.02576723f, 
    0.02440755f, -0.06835365f, -0.09281169f, 0.08471464f, -0.10340534f, -0.13547060f, -0.09629153f, 0.09972417f, 
    -0.05295680f, -0.06132764f, 0.01600593f, 0.14857885f, 0.05123289f, -0.02869747f, 0.04061970f, -0.16828337f, 
    0.11308761f, -0.00249235f, -0.02967399f, 0.10954215f, -0.18660396f, 0.16377823f, -0.15654522f, -0.00732458f, 
    0.08791384f, 0.10707887f, -0.02467256f, 0.18890680f, -0.02958043f, 0.05572999f, 0.02522861f, 0.05157895f, 
    -0.03441533f, -0.04710174f, 0.30189589f, 0.04234785f, 0.13512871f, 0.10535877f, -0.04916343f, 0.12375475f, 
    0.00840089f, -0.13623369f, 0.03965143f, -0.01818665f, -0.13937302f, -0.14251004f, 0.00378373f, -0.03611608f, 
    -0.11992645f, -0.03082689f, 0.16741896f, -0.01808121f, -0.29341641f, -0.12169351f, 0.02503022f, -0.02439241f, 
    0.10491450f, -0.04034810f, -0.17210828f, 0.06263371f, 0.00012067f, 0.22614031f, 0.15405157f, -0.13158420f, 
    0.06659286f, -0.16149017f, 0.08325814f, -0.06981223f, 0.11371328f, -0.18198216f, 0.06315622f, -0.08021984f, 
    -0.04823175f, -0.09441430f, 0.01740622f, 0.03918828f, -0.06828467f, 0.02630393f, 0.05578681f, 0.16145943f, 
    -0.02266739f, -0.14914234f, 0.02103205f, 0.15772080f, 0.03155733f, -0.09826351f, -0.10756530f, 0.04000260f, 
    -0.00626812f, -0.14325017f, -0.00105640f, 0.07910859f, -0.12985691f, 0.09632304f, -0.07189982f, -0.13879147f, 
    -0.01250707f, -0.23203979f, -0.17092222f, 0.03220388f, 0.02337535f, -0.02100246f, 0.03957591f, -0.00360530f, 
    -0.09836566f, -0.12979339f, 0.19077832f, 0.14263839f, 0.02949870f, 0.06381350f, -0.07210235f, 0.01423543f, 
    0.08927055f, -0.00899534f, 0.01085148f, 0.24261646f, -0.06654153f, 0.02123429f, 0.25880188f, 0.05315485f, 
    0.06485231f, -0.00651786f, 0.09397294f, -0.04787936f, -0.16588201f, 0.12845308f, 0.00077430f, 0.01260249f, 
    0.05747365f, 0.02525185f, 0.02918985f, 0.11776766f, -0.15420043f, 0.28294572f, 0.01248530f, 0.14133646f, 
    0.09664793f, 0.02512112f, 0.00271673f, 0.08899302f, -0.01940230f, -0.05622419f, 0.17886305f, 0.08289587f, 
    -0.05722190f, -0.09131394f, -0.13639411f, 0.03816089f, 0.11284602f, 0.05100855f, 0.17005968f, -0.17955446f, 
    -0.12625410f, 0.08489729f, -0.16207945f, -0.10468195f, 0.10481052f, 0.01927829f, -0.15434700f, 0.09954725f, 
    0.04323134f, -0.02794082f, 0.03182532f, -0.06891782f, 0.08210732f, 0.03446408f, -0.22993778f, -0.01131697f, 
    0.19898699f, 0.06846849f, -0.00294622f, -0.08080294f, -0.02876015f, -0.03500410f, 0.09861150f, 0.11962966f, 
    -0.01274959f, 0.00521807f, -0.02845992f, -0.04693761f, -0.06109484f, 0.02772306f, 0.04564354f, -0.00700755f, 
    -0.02847618f, -0.04979159f, 0.05417499f, 0.00625811f, -0.01839255f, -0.01918252f, 0.03913073f, -0.05449830f, 
    0.02765464f, 0.02898559f, -0.03192769f, 0.03112106f, -0.01876848f, 0.01381100f, 0.03282304f, -0.05512203f, 
    0.04706727f, 0.01470735f, 0.04135412f, 0.01345522f, -0.05877575f, 0.03245430f, 0.02105272f, 0.03735051f, 
    0.01475226f, 0.04736683f, 0.01396615f, 0.05319619f, 0.00301197f, -0.02884299f, -0.02395579f, 0.05271853f, 
    -0.00340627f, -0.01231166f, 0.01240643f, -0.05922726f, -0.03570641f, 0.05857789f, -0.02340499f, -0.04261442f, 
    -0.02725932f, 0.05206734f, 0.04560137f, 0.03108951f, 0.04597826f, -0.01282993f, -0.03208498f, -0.01629718f, 
    -0.05352116f, -0.05800301f, 0.04190888f, -0.04866225f, 0.02954656f, -0.03796875f, 0.00486650f, 0.01704480f, 
    -0.04668739f, -0.04901566f, 0.00092662f, 0.02926423f, 0.04722604f, -0.05834581f, 0.01911379f, 0.01431813f, 
    0.03151408f, -0.03846266f, 0.03334761f, -0.00103860f, 0.05089100f, -0.04855886f, 0.03011834f, 0.03607645f, 
    -0.00882455f, 0.00499871f, -0.03820168f, -0.01879634f, -0.05030684f, -0.01396588f, -0.03178921f, 0.03114866f, 
    0.05042392f, -0.05089776f, 0.01469162f, -0.01056308f, 0.00879573f, -0.00274020f, 0.04919462f, 0.01124828f, 
    0.00411304f, 0.04397813f, 0.04819819f, -0.02055575f, 0.01908668f, -0.06369670f, -0.02592512f, 0.02150653f, 
    -0.00671543f, -0.04777299f, -0.06245815f, 0.00427831f, 0.02234248f, -0.03568194f, -0.04378083f, -0.01654711f, 
    -0.01671727f, 0.03730461f, -0.06179922f, -0.01916450f, -0.01269775f, -0.04483442f, 0.04162177f, -0.05838554f, 
    0.02393649f, -0.04199190f, -0.04508872f, 0.01602244f, 0.00242015f, 0.01280235f, 0.05939028f, 0.01221646f, 
    0.03466522f, 0.02073009f, 0.05417040f, 0.02927393f, 0.04960777f, 0.01597505f, -0.01014117f, -0.01453460f, 
    0.01315140f, 0.01834514f, -0.03996712f, 0.04423056f, 0.04636804f, -0.00656387f, -0.02146964f, 0.00215075f, 
    -0.01962805f, 0.04806845f, 0.03146182f, 0.02040486f, -0.00685747f, 0.02986172f, -0.03181192f, 0.01413710f, 
    -0.05999110f, 0.00336859f, 0.00876538f, 0.02814124f, 0.00517449f, -0.05366445f, 0.05172262f, -0.05972650f, 
    -0.01875900f, 0.02054013f, -0.04926226f, 0.05278767f, -0.06372277f, -0.05641968f, -0.05742341f, 0.02290902f, 
    0.03712459f, -0.03548956f, 0.00313514f, -0.05327061f, 0.03701971f, -0.01885185f, 0.03404481f, -0.00725170f, 
    -0.01634462f, 0.00514999f, 0.03353544f, -0.05591311f, 0.01039106f, -0.05755806f, 0.01061873f, 0.00886061f, 
    0.01831462f, 0.02355884f, 0.03666480f, 0.05188445f, -0.05176301f, -0.02614232f, -0.02812582f, -0.05452029f, 
    -0.02487162f, 0.05193184f, -0.03049984f, -0.05693138f, -0.01309963f, 0.01785096f, -0.06437144f, 0.02783162f, 
    -0.01785141f, 0.01297240f, -0.01652795f, -0.04219137f, -0.01410968f, -0.03554683f, 0.03496024f, -0.03301746f, 
    -0.01569669f, 0.00218584f, 0.05287867f, -0.00074229f, 0.04109856f, -0.01385327f, -0.00039780f, -0.00061449f, 
    -0.00947422f, -0.04438656f, 0.02248540f, 0.05431594f, -0.02440551f, -0.00113547f, -0.06124493f, 0.02144136f, 
    -0.00703971f, -0.05142912f, 0.00260309f, 0.03040410f, -0.03416054f, -0.00335295f, -0.04875876f, -0.01421853f, 
    -0.01340716f, -0.00675795f, -0.03493024f, -0.01772853f, -0.03183657f, -0.04250801f, -0.02758159f, -0.06472123f, 
    0.03363226f, -0.04266042f, -0.01991802f, 0.01285898f, 0.01876435f, 0.04886545f, 0.02260210f, 0.02796507f, 
    -0.03739105f, -0.02947561f, -0.01447243f, -0.02663945f, -0.02373220f, 0.00370801f, -0.04365130f, 0.04557852f, 
    -0.02716710f, -0.03171235f, -0.02057729f, -0.03265979f, -0.01367051f, -0.05822929f, 0.00680610f, -0.00505536f, 
    -0.02652426f, -0.05104819f, 0.03991710f, 0.02276744f, -0.04208128f, 0.01895378f, -0.05451754f, -0.05028407f, 
    -0.00124350f, -0.05982247f, -0.05811751f, 0.03299673f, 0.03935146f, -0.03166161f, -0.03062743f, -0.01302864f, 
    -0.04272394f, -0.00198741f, -0.03754127f, 0.02825612f, -0.02936706f, -0.01653484f, -0.02640349f, 0.05260042f, 
    0.01454098f, 0.01069633f, -0.06852633f, -0.04323174f, 0.04703351f, 0.04188988f, -0.01273974f, -0.01271012f, 
    0.04418115f, -0.00080328f, -0.00558576f, -0.00426012f, -0.03774492f, 0.03461889f, 0.00823804f, -0.03659094f, 
    -0.04900524f, -0.06276599f, -0.02103355f, -0.01282557f, -0.03052595f, 0.03170265f, -0.06356190f, 0.00689214f, 
    -0.00065870f, 0.02288438f, -0.01123269f, 0.01864893f, 0.00502596f, 0.04868423f, -0.02825088f, 0.00641170f, 
    -0.01080337f, -0.02410803f, -0.06288023f, -0.05301209f, -0.03599178f, -0.01428837f, -0.00826207f, 0.02151876f, 
    -0.04951489f, -0.00910637f, -0.05854820f, -0.04397057f, -0.02736665f, -0.02072693f, -0.02820990f, -0.00849631f, 
    -0.00003088f, -0.01208377f, -0.06282991f, -0.02115239f, -0.02877724f, 0.03155250f, -0.01355437f, -0.05117469f, 
    0.01121099f, -0.03129851f, 0.03213004f, 0.00516118f, -0.00135479f, -0.05459293f, -0.04667292f, -0.05178396f, 
    -0.03051605f, -0.00618170f, -0.06210499f, -0.00414063f, 0.04883627f, 0.01571030f, -0.04531857f, 0.03337685f, 
    0.04273253f, -0.06349808f, -0.00329842f, -0.03540800f, -0.01629195f, -0.05160849f, -0.06615532f, -0.04377768f, 
    -0.05823005f, -0.05813231f, -0.04527656f, -0.01550975f, -0.00048183f, -0.02281879f, 0.00132474f, 0.04948055f, 
    -0.04977516f, 0.01365794f, 0.03412923f, -0.04831387f, -0.04006261f, -0.01807734f, -0.01990646f, -0.01625076f, 
    0.05323686f, -0.00515233f, -0.00424397f, -0.05766648f, 0.04482304f, -0.01984191f, -0.05381812f, 0.00025209f, 
    -0.04066281f, 0.00533816f, 0.04722786f, 0.00969464f, -0.00484586f, 0.03313708f, -0.03348997f, -0.00828882f, 
    -0.01564320f, -0.04878818f, 0.01168093f, -0.00705497f, -0.05631792f, 0.03182733f, 0.04532497f, 0.01436126f, 
    -0.00399159f, -0.04840130f, -0.03697551f, -0.03781984f, 0.03112310f, -0.06234384f, -0.00968249f, -0.02454394f, 
    0.04722918f, -0.06733078f, 0.01233875f, -0.01130158f, -0.06071888f, 0.01397939f, -0.00673465f, 0.02335919f, 
    -0.00923660f, 0.02662515f, -0.00141300f, -0.01660314f, -0.03664316f, 0.02667929f, -0.02959218f, 0.03508094f, 
    0.00470407f, 0.02091895f, -0.02551558f, 0.03192291f, 0.01637800f, 0.02670047f, -0.04165435f, -0.04422009f, 
    0.04653165f, -0.02932903f, -0.01660413f, -0.01446905f, -0.02965019f, 0.04926110f, -0.05371705f, -0.02284197f, 
    -0.03805810f, -0.05959598f, 0.00611769f, 0.01040063f, 0.03112450f, 0.03776514f, -0.03384177f, 0.04940770f, 
    -0.03024756f, -0.01343197f, -0.05780671f, 0.02565128f, 0.02848873f, 0.00537226f, 0.03196077f, -0.02373575f, 
    0.02848204f, 0.03301016f, -0.04249499f, 0.04369565f, -0.02912066f, 0.03586560f, 0.04013573f, -0.05898980f, 
    0.04944269f, -0.05345308f, -0.05831613f, 0.03307829f, -0.03217223f, 0.04795655f, -0.00057527f, 0.00832541f, 
    -0.00275326f, -0.00633022f, -0.05442627f, 0.03567451f, -0.04447928f, 0.00529894f, -0.03765624f, 0.00626510f, 
    0.03297893f, 0.03693886f, -0.00632518f, 0.00227959f, -0.01868164f, -0.03470979f, 0.03085174f, -0.03630980f, 
    0.04940948f, 0.04514807f, 0.01017912f, -0.05989978f, 0.02071624f, 0.04436281f, 0.01856731f, -0.02428312f, 
    0.01651032f, -0.04002367f, 0.01819450f, 0.03795313f, -0.06282689f, -0.00494659f, 0.02816664f, -0.01888485f, 
    0.03047365f, 0.03348062f, 0.00292659f, -0.04724512f, -0.05727928f, -0.00991902f, 0.04765062f, 0.00196913f, 
    0.04587381f, -0.00205912f, -0.00933895f, 0.04449512f, -0.02700305f, 0.01923842f, 0.04310838f, -0.03860174f, 
    -0.06347232f, -0.02257728f, 0.01086799f, 0.02602786f, 0.03794386f, -0.04609685f, 0.04879815f, 0.01467854f, 
    -0.04980370f, -0.02763136f, -0.00362986f, 0.00003123f, -0.05295183f, -0.03606135f, 0.02241530f, -0.01179208f, 
    -0.00551378f, 0.03362102f, -0.03798226f, 0.03907585f, 0.02570343f, -0.03528645f, 0.04456381f, -0.03174289f, 
    -0.00780164f, 0.04427497f, 0.01492271f, -0.05037465f, -0.02664534f, 0.02524368f, 0.00331247f, 0.02521839f, 
    -0.02708596f, 0.00282030f, -0.03437163f, -0.03096031f, -0.06172244f, -0.01891830f, -0.02640940f, 0.03866487f, 
    0.01633641f, -0.00894099f, 0.04458553f, -0.06498580f, 0.02299332f, -0.03860104f, -0.03132818f, 0.01249207f, 
    -0.01995029f, 0.02955044f, 0.03585020f, -0.02541840f, -0.01193558f, -0.03303558f, -0.01200674f, -0.04153848f, 
    -0.02065953f, -0.04564957f, -0.05163390f, 0.01180744f, -0.01672338f, 0.00448727f, 0.03539616f, -0.01362875f, 
    0.02274575f, 0.02358876f, 0.00889667f, -0.05234840f, 0.01045431f, -0.05351089f, 0.02448339f, -0.00269972f, 
    -0.05372721f, -0.05419712f, -0.03761858f, 0.03140780f, 0.00381870f, -0.01029538f, -0.00395065f, 0.03612640f, 
    -0.06330607f, 0.01737557f, -0.01751021f, -0.05497371f, 0.01912134f, -0.00361079f, -0.00851295f, -0.00502543f, 
    -0.05861905f, 0.02671968f, 0.03689470f, -0.00871143f, -0.01830992f, -0.05493752f, -0.05960779f, -0.04705020f, 
    0.00706237f, -0.02897928f, 0.04426994f, 0.00522413f, -0.04450433f, -0.00365571f, -0.04515941f, 0.00617941f, 
    0.03364746f, 0.04372612f, -0.05585764f, 0.00284102f, -0.01811145f, 0.02574433f, -0.04577010f, 0.02666915f, 
    -0.02274296f, -0.05355824f, 0.03091486f, 0.00898524f, -0.04480848f, 0.02695257f, -0.03846472f, 0.01738369f, 
    0.03652045f, 0.01203974f, -0.00473492f, -0.00438654f, -0.06516089f, -0.06100836f, -0.00967240f, -0.06233541f, 
    0.02286527f, 0.02782312f, 0.00459787f, 0.02438931f, -0.02528770f, -0.03936065f, -0.02775949f, -0.05518318f, 
    -0.00941421f, 0.01075390f, -0.00967217f, -0.00268519f, 0.04417937f, 0.02439989f, -0.01566991f, 0.02376522f, 
    0.03035468f, -0.01099082f, 0.04443877f, 0.04868869f, -0.06281488f, -0.04095760f, -0.02197796f, -0.00601992f, 
    -0.04670316f, -0.03614184f, -0.03460192f, -0.05343712f, 0.02585316f, -0.01895612f, -0.05125182f, 0.02369559f, 
    -0.05625286f, -0.04458742f, -0.06438456f, 0.02678192f, 0.03670927f, 0.01921016f, -0.01149108f, -0.05403205f, 
    0.04478667f, 0.02665775f, -0.03959357f, 0.02232518f, 0.03891311f, 0.05146709f, 0.04545867f, -0.02514013f, 
    -0.06065826f, 0.01722983f, 0.03907748f, -0.04367933f, 0.02648790f, 0.00019570f, -0.00146037f, -0.00489553f, 
    0.04594406f, -0.06368082f, 0.04279560f, -0.05961311f, -0.05670222f, 0.04127447f, 0.02541669f, -0.05489628f, 
    -0.03060896f, 0.01195065f, -0.01285749f, -0.06250808f, 0.03490976f, 0.04242619f, 0.01016896f, 0.04071558f, 
    -0.01398865f, 0.03292974f, -0.01995893f, -0.05263599f, -0.02065884f, 0.03931949f, -0.06127942f, 0.03369283f, 
    -0.00573056f, -0.01263636f, -0.01568874f, 0.03484253f, 0.04936062f, -0.06772277f, -0.02463596f, 0.01258936f, 
    -0.02083324f, -0.04825326f, 0.03839955f, -0.05128530f, -0.03167818f, -0.02847667f, -0.04218724f, -0.06018737f, 
    0.03977068f, 0.01818587f, 0.03002449f, -0.03083921f, -0.00881692f, -0.04445636f, 0.04508660f, -0.03517216f, 
    -0.00557658f, 0.04121581f, 0.02339997f, -0.05761298f, -0.03831676f, 0.01295958f, -0.01264209f, 0.02589016f, 
    0.04108627f, 0.03597115f, 0.04183736f, 0.01344625f, -0.03815279f, 0.03934434f, -0.06090109f, -0.03691512f, 
    -0.05843148f, -0.02736224f, -0.04899903f, 0.02695545f, -0.01095220f, -0.04856275f, -0.06758118f, 0.00836087f, 
    0.01293052f, -0.03698279f, 0.04619595f, 0.01941546f, -0.05785669f, 0.04027230f, 0.01630200f, 0.03205727f, 
    0.04416030f, -0.03588367f, -0.06240160f, -0.02841758f, 0.03890682f, -0.01183257f, 0.01873828f, 0.00266570f, 
    -0.05010247f, 0.01508777f, -0.04205649f, -0.00600292f, -0.04583040f, 0.04026600f, -0.02034587f, -0.03703310f, 
    -0.03866708f, -0.05257405f, -0.01226231f, -0.01656938f, 0.03812895f, 0.03714055f, 0.00794879f, 0.03805523f, 
    -0.06462662f, -0.01880038f, -0.05133783f, 0.00539166f, 0.04600658f, -0.01295722f, 0.03516355f, -0.04020834f, 
    -0.05884475f, -0.06380554f, 0.00135789f, -0.00556205f, 0.00963448f, -0.02887346f, -0.06408527f, 0.04941584f, 
    -0.05704613f, 0.03000413f, -0.04776430f, 0.04772081f, -0.04705952f, -0.02535437f, 0.00351244f, 0.02057182f, 
    -0.01797281f, 0.02641415f, 0.00571045f, -0.03887057f, 0.02068966f, -0.03163628f, 0.04934722f, 0.03859032f, 
    -0.02872824f, -0.06160176f, 0.03355788f, -0.01769791f, 0.02842468f, -0.01513518f, -0.04075643f, -0.02068321f, 
    -0.02065301f, -0.02873039f, 0.02133995f, -0.06202918f, 0.02870881f, 0.02319549f, -0.03377355f, 0.04569862f, 
    -0.04141298f, -0.03512750f, 0.05239479f, -0.07135900f, -0.02493196f, 0.01395804f, 0.04788972f, -0.01703111f, 
    0.01962122f, 0.05523185f, -0.01177950f, 0.01447195f, -0.03514471f, 0.00498935f, -0.01730239f, -0.02413099f, 
    0.02490420f, 0.05651272f, 0.04535144f, 0.02887807f, 0.01237153f, -0.02474111f, 0.01662033f, -0.02733615f, 
    -0.03422841f, -0.05112488f, 0.01684192f, 0.03022356f, -0.04340239f, -0.01966409f, 0.04940306f, -0.06189460f, 
    0.01558393f, 0.01990818f, -0.00549074f, 0.00161157f, 0.02581613f, 0.00367773f, 0.05037093f, 0.03447983f, 
    -0.01736332f, 0.01057218f, 0.00705156f, 0.04873870f, -0.02186124f, 0.01629556f, -0.02384529f, -0.06535271f, 
    0.03993966f, 0.01015815f, -0.04113071f, -0.02108342f, -0.05425535f, -0.01883416f, -0.01519550f, -0.01856093f, 
    -0.01857922f, -0.03114526f, 0.04490246f, 0.05018135f, -0.04785132f, 0.03083936f, 0.05361577f, -0.03856384f, 
    0.05899253f, -0.03916187f, -0.01277358f, -0.03878411f, 0.04164454f, 0.02878696f, -0.05583775f, 0.02767461f, 
    -0.05935802f, -0.06583887f, -0.01970951f, 0.00856774f, 0.04221880f, 0.02146940f, -0.04012251f, -0.03745674f, 
    0.00358761f, -0.03077086f, 0.01194924f, 0.04799458f, -0.02736498f, 0.03523546f, 0.03246047f, 0.01915888f, 
    -0.04232998f, -0.03763289f, -0.03294952f, -0.02022325f, -0.06529843f, 0.01005195f, -0.01135921f, -0.05210976f, 
    -0.01944061f, -0.02306827f, 0.03134564f, 0.01405070f, 0.03951671f, -0.01267650f, 0.01401020f, 0.03504412f, 
    -0.02619423f, 0.03997863f, -0.06932908f, 0.04899880f, 0.05263387f, 0.00863449f, 0.03585625f, 0.00550976f, 
    -0.02662351f, -0.04294052f, -0.01411880f, -0.05724395f, 0.00613161f, 0.03668865f, -0.04712916f, 0.01850853f, 
    -0.00286387f, -0.01123598f, 0.02921935f, -0.05784363f, -0.04311647f, 0.04627499f, 0.02993023f, -0.02173607f, 
    -0.00591194f, 0.02315525f, 0.02568641f, 0.03916574f, -0.06144979f, -0.02033696f, -0.00297408f, -0.01048691f, 
    -0.04980664f, -0.00139147f, 0.04982395f, 0.02159391f, -0.00811080f, -0.01997551f, 0.01915719f, -0.00057101f, 
    -0.05010606f, -0.04370870f, 0.03729694f, 0.01928826f, -0.03937756f, -0.04758133f, 0.00214978f, 0.02596818f, 
    0.03384622f, 0.00703624f, -0.02666436f, -0.02457028f, 0.00047882f, 0.02672366f, -0.03739008f, -0.00046547f, 
    0.01881490f, -0.02342781f, 0.03725438f, -0.05586065f, 0.01632580f, -0.05869471f, -0.03979028f, -0.04166416f, 
    0.02228907f, -0.04593780f, -0.05996240f, -0.06888264f, -0.03186528f, -0.05488868f, -0.01808600f, 0.03581440f, 
    0.03413101f, -0.04056911f, -0.05406808f, -0.01326295f, -0.02955271f, -0.06103865f, 0.01743778f, 0.00676385f, 
    0.03633703f, -0.00761037f, -0.01043422f, 0.01502177f, 0.03162297f, 0.01834198f, -0.01746764f, -0.00311399f, 
    0.03021349f, -0.01479169f, -0.05456279f, 0.03017490f, -0.04482110f, -0.02062590f, -0.00598708f, -0.01824432f, 
    -0.04268349f, -0.00450490f, 0.02779401f, 0.04766427f, -0.06253323f, -0.00124540f, 0.01763195f, 0.00563914f, 
    -0.00130374f, 0.01623098f, -0.06690169f, 0.04779007f, -0.02575032f, -0.06813510f, 0.01131724f, -0.06119200f, 
    0.03721423f, 0.00027400f, -0.05216629f, -0.00652930f, 0.03081647f, -0.00987039f, -0.03591098f, 0.04123321f, 
    -0.02033338f, 0.03196603f, -0.00103179f, 0.03741292f, 0.03797286f, -0.04511481f, 0.03835874f, 0.01143694f, 
    0.03529802f, 0.00162594f, -0.02854898f, 0.04480926f, 0.00340152f, 0.01471319f, 0.00861311f, -0.01313473f, 
    -0.04987779f, -0.04192815f, 0.01406934f, -0.02152981f, 0.04950373f, 0.04679336f, -0.00300778f, 0.03390329f, 
    -0.00661079f, 0.00158677f, -0.00713727f, 0.00954390f, -0.02249353f, 0.04010480f, -0.03890137f, -0.04087077f, 
    0.04213082f, -0.02131796f, -0.06162296f, -0.01795204f, 0.03259991f, -0.01114339f, -0.06892159f, -0.03494998f, 
    0.01635745f, -0.01184550f, -0.01520156f, -0.06548653f, -0.06755227f, -0.00386657f, -0.05346343f, -0.01526420f, 
    0.01342010f, 0.03091207f, -0.04401165f, -0.04648989f, 0.02886576f, 0.03551921f, 0.04344834f, -0.00456246f, 
    -0.02424983f, 0.02593905f, -0.01707210f, 0.01091948f, 0.00628747f, -0.03983431f, -0.03453042f, 0.03260383f, 
    -0.22902766f, -0.19828574f, -0.19758444f, -0.01596593f, 0.07913709f, -0.08767270f, -0.11387161f, -0.16442886f, 
    -0.22125167f, -0.26537386f, -0.07777060f, -0.11865813f, 0.00057664f, 0.00706771f, -0.03054737f, -0.07443810f, 
    0.06546547f, -0.12273723f, 0.19403815f, 0.10024910f, 0.11368635f, 0.05479478f, 0.08423048f, 0.02881001f, 
    0.07231499f, -0.05887423f, 0.05298886f, -0.68229568f, 0.01452311f, -0.06799446f, -0.01443519f, -0.11800538f, 
    -0.15504517f, -0.06293170f, -0.07279333f, -0.03762011f, 0.12190332f, 0.06906915f, 0.14927146f, 0.11520461f, 
    0.08881935f, 0.04885909f, 0.01976285f, 0.11969486f, -0.00003766f, -0.28559232f, 0.07991486f, 0.11808720f, 
    0.11175340f, -0.05161224f, -0.07250818f, -0.07455932f, 0.07586644f, -0.06603516f, 0.13401668f, -0.07732249f, 
    0.20369194f, -0.02658220f, 0.11935172f, 0.08835130f, -0.07221863f, -0.01917784f, 0.00463449f, -0.30340278f, 
    0.03204499f, 0.07626181f, 0.12231165f, 0.08868998f, 0.01165007f, 0.17435819f, -0.08126590f, -0.10354116f, 
    -0.38607422f, 0.17825566f, 0.26457834f, 0.08707477f, 0.08579513f, 0.11739099f, -0.02955081f, 0.06858833f, 
    -0.10620683f, 0.13368644f, -0.03739152f, 0.14999317f, -0.11328299f, 0.13367634f, 0.03922077f, 0.00435625f, 
    0.04427312f, 0.08144579f, -0.02389904f, 0.00311003f, 0.07713106f, 0.29388583f, 0.14707755f, 0.00807792f, 
    0.11570335f, 0.03259932f, -0.05890798f, 0.00282724f, -0.04253275f, 0.01190634f, -0.19696099f, 0.04101278f, 
    -0.01034955f, -0.09550036f, 0.13199644f, 0.12541509f, 0.04767043f, 0.03470485f, 0.21797423f, -0.25998098f, 
    0.07677004f, -0.03114992f, 0.04581156f, 0.03317858f, -0.00572586f, -0.11050396f, -0.13771282f, 0.07062865f, 
    -0.15511341f, -0.12871580f, -0.21899755f, -0.03144267f, 0.09570544f, -0.11006153f, -0.15843301f, -0.07493094f, 
    0.09794970f, 0.10045236f, -0.11239813f, 0.05505817f, -0.09551813f, -0.03026193f, 0.05459476f, -0.23446919f, 
    0.04949340f, -0.04259825f, 0.01101207f, 0.03441029f, 0.04475528f, -0.03847691f, 0.03898697f, 0.14846134f, 
    -0.03158266f, 0.13843079f, -0.19875225f, 0.13685431f, 0.00641891f, 0.07521906f, 0.00276928f, 0.00847320f, 
    -0.02292022f, 0.05888411f, -0.12416218f, 0.04828119f, -0.11602977f, 0.14885040f, 0.05172864f, 0.04925453f, 
    -0.02372480f, 0.04057007f, 0.18518336f, 0.16728547f, -0.01523093f, 0.01431875f, 0.14552233f, 0.01660890f, 
    -0.05957353f, -0.09552044f, -0.08195164f, 0.00320627f, 0.22193068f, 0.05468759f, 0.21755971f, 0.09806082f, 
    -0.10052739f, 0.02425075f, 0.01196140f, 0.03694396f, -0.11152539f, -0.19254577f, -0.18176481f, 0.14693287f, 
    0.02114630f, -0.10827763f, 0.02348056f, 0.03107526f, -0.15657267f, -0.20782770f, -0.01857592f, -0.18076448f, 
    0.12462531f, 0.12638183f, 0.05050435f, 0.15691417f, 0.02400692f, -0.04846247f, -0.08044187f, 0.07512693f, 
    0.22265497f, 0.12084419f, 0.06793141f, -0.07617708f, 0.05229010f, -0.09109948f, 0.06266674f, -0.20160122f, 
    -0.17481504f, -0.12187019f, -0.15725093f, 0.15464397f, 0.05902081f, 0.04687261f, -0.01993172f, -0.02247933f, 
    -0.28858626f, -0.13977337f, -0.23251010f, 0.07480542f, 0.05456177f, 0.17881323f, 0.11277776f, -0.11625957f, 
    0.09189963f, -0.24443351f, -0.02792150f, -0.11569522f, 0.21651648f, 0.15034728f, -0.05921388f, -0.00731136f, 
    -0.01609571f, -0.13449334f, -0.19828910f, 0.10234161f, 0.03419696f, 0.11916806f, 0.10837345f, -0.02961561f, 
    -0.00590535f, 0.04505096f, -0.17651577f, -0.11766557f, 0.19799599f, -0.20744072f, 0.22596860f, -0.00630551f, 
    -0.01290208f, -0.14617981f, 0.00696787f, -0.01897936f, -0.13617231f, -0.15344326f, 0.07251424f, 0.29875326f, 
    0.10314876f, 0.03025625f, 0.03974203f, -0.05985690f, 0.11225026f, 0.11734369f, -0.02798910f, 0.19318250f, 
    -0.17234327f, 0.15220150f, -0.09747305f, 0.02586484f, 0.09446206f, 0.11235238f, -0.04870240f, 0.07478732f, 
    0.32592112f, -0.11131334f, -0.01786376f, -0.12327584f, 0.05510616f, 0.08567942f, 0.20030914f, -0.01712171f, 
    -0.05534990f, -0.17857803f, 0.02849250f, -0.00988982f, 0.02219792f, 0.11717776f, 0.03758509f, 0.11032791f, 
    0.03845166f, 0.04258079f, 0.00662379f, 0.03631176f, -0.02798278f, 0.00132439f, -0.06593440f, 0.05201704f, 
    -0.00530205f, -0.04895130f, 0.00626217f, -0.00958875f, -0.00810833f, 0.04664825f, -0.05376704f, -0.01489489f, 
    -0.02773500f, -0.05392278f, 0.02066643f, 0.04014792f, 0.03881463f, 0.00963916f, 0.03203148f, 0.02456233f, 
    0.04290358f, 0.03733637f, 0.04375928f, 0.01981289f, 0.01024304f, 0.04848975f, -0.01450259f, 0.03390133f, 
    0.05047652f, 0.04503796f, -0.03833614f, 0.00976115f, 0.00279374f, 0.04646396f, -0.02714899f, -0.02177458f, 
    -0.04977378f, 0.01355688f, 0.02593785f, 0.02570728f, -0.06420744f, -0.06859279f, 0.04777838f, 0.01110092f, 
    -0.00602133f, 0.02825332f, -0.06258611f, 0.00909207f, -0.00660938f, -0.03833164f, -0.01266585f, -0.04885570f, 
    -0.01251609f, 0.01734470f, 0.04805312f, -0.00524127f, -0.00268698f, -0.00752667f, -0.03013144f, -0.05131870f, 
    -0.05571974f, -0.02568366f, 0.02348080f, 0.02907284f, 0.03358027f, 0.05145370f, 0.05461020f, 0.02822207f, 
    -0.03524346f, -0.04631959f, -0.03034482f, -0.06191609f, 0.00006663f, -0.06171468f, -0.01347410f, 0.00077211f, 
    -0.01952497f, -0.00296068f, -0.02232767f, -0.01425104f, -0.02697820f, -0.06395838f, -0.01037036f, -0.04785636f, 
    -0.02790649f, -0.02809808f, 0.03958023f, -0.05644195f, 0.02536380f, 0.03300679f, -0.02365609f, 0.04487501f, 
    0.00041017f, -0.03344198f, 0.01796899f, -0.05435778f, -0.00168535f, 0.00087092f, -0.03793187f, -0.04100524f, 
    0.04336226f, 0.01830378f, 0.04331795f, 0.02937114f, 0.01242850f, 0.02688433f, 0.04385747f, 0.03850251f, 
    0.03860678f, 0.01709100f, 0.02470385f, -0.06097642f, 0.02424797f, -0.04095281f, -0.02377326f, -0.01631254f, 
    -0.02790364f, -0.02238680f, 0.00101538f, 0.01879565f, 0.02291914f, 0.05001308f, -0.02213330f, -0.04372841f, 
    -0.04121184f, -0.06010523f, -0.02356113f, -0.00265767f, 0.00905866f, 0.01287970f, -0.04134420f, -0.03189662f, 
    -0.05981892f, -0.02438511f, 0.02275062f, -0.03688323f, -0.02020673f, -0.01748912f, -0.06510528f, 0.02293167f, 
    0.05459508f, 0.01515902f, -0.01918439f, -0.01108127f, -0.05786970f, 0.04106022f, -0.02435704f, -0.01332161f, 
    -0.04616225f, -0.03771082f, -0.00402109f, 0.04404730f, -0.04874230f, 0.02760461f, 0.02915320f, -0.04652540f, 
    0.03638755f, 0.04801826f, -0.05737553f, 0.00617581f, 0.00318055f, -0.03534117f, -0.03018837f, 0.00199601f, 
    0.00909068f, -0.03877165f, -0.02153815f, 0.01916851f, -0.03676846f, -0.03856358f, 0.03797596f, -0.04820170f, 
    0.03687634f, -0.03991060f, 0.04049382f, 0.04167651f, 0.04873085f, -0.00961878f, -0.01424464f, 0.02024045f, 
    -0.05255836f, -0.04545917f, 0.02997490f, 0.03529836f, -0.05522761f, -0.04901825f, -0.01238216f, -0.00644164f, 
    0.05190848f, 0.02057391f, -0.06601878f, -0.01728950f, -0.05338097f, 0.02846435f, 0.01107948f, 0.00360868f, 
    -0.00026804f, 0.03400865f, 0.04238123f, -0.00971672f, -0.04035709f, 0.05011868f, -0.04619178f, -0.04227692f, 
    -0.03995230f, 0.03803795f, -0.01543181f, -0.04200435f, -0.04320751f, -0.00434808f, -0.05770687f, 0.00751330f, 
    0.05775573f, -0.03954918f, 0.02790804f, 0.03558551f, -0.05296900f, -0.05946112f, -0.04038683f, 0.01591037f, 
    -0.00731740f, 0.02800960f, 0.00628115f, 0.04019860f, -0.06419718f, 0.03320350f, 0.01059189f, 0.03725164f, 
    0.01610623f, 0.04037867f, -0.01662458f, 0.01941979f, 0.00464316f, -0.04216355f, -0.03841718f, -0.04295243f, 
    -0.02797736f, 0.00077210f, -0.03319121f, 0.01010683f, 0.04692861f, -0.05948781f, 0.01076674f, -0.01568811f, 
    -0.01011215f, -0.03320617f, -0.06338477f, -0.02522400f, 0.03803952f, 0.01516929f, 0.01932324f, -0.02903567f, 
    -0.05385474f, -0.05765719f, -0.01081248f, 0.02443264f, -0.03000106f, -0.05276052f, -0.06031185f, -0.05800430f, 
    0.04739239f, -0.03018242f, -0.03529066f, -0.01753463f, -0.05847960f, -0.06157975f, 0.01153503f, -0.00844266f, 
    -0.00553603f, -0.01762417f, -0.00442857f, 0.04141548f, -0.03922040f, 0.04455441f, -0.02790840f, -0.05227739f, 
    0.04056710f, -0.00029565f, -0.05381065f, 0.02688061f, 0.02296996f, -0.06561725f, -0.01159049f, 0.01703917f, 
    0.02099677f, 0.04286063f, -0.05086787f, 0.05514965f, -0.03820412f, 0.00186034f, -0.03986789f, -0.05635182f, 
    -0.03603313f, -0.06167736f, -0.00845780f, 0.02849694f, -0.01917588f, -0.04037505f, -0.04143495f, 0.02559256f, 
    0.04143445f, -0.00147630f, -0.07560776f, -0.02258007f, -0.01078964f, -0.02020675f, -0.01054762f, -0.02260279f, 
    -0.07171024f, 0.04042482f, -0.01354790f, 0.04307009f, -0.05512828f, 0.00683332f, -0.04559393f, 0.00831013f, 
    0.05330622f, 0.02553947f, -0.02035560f, -0.02214905f, -0.05304255f, -0.07086242f, 0.00834395f, -0.06285376f, 
    -0.02067409f, -0.04338240f, -0.06895333f, 0.04878065f, 0.02840652f, -0.02309860f, -0.04759572f, 0.01978145f, 
    -0.06632639f, -0.03782262f, 0.03744479f, -0.02704212f, -0.00526119f, 0.02302731f, 0.03640659f, -0.01623765f, 
    0.03816568f, -0.04554301f, 0.03665098f, -0.04114750f, 0.03502018f, -0.00550980f, -0.02780320f, -0.06246420f, 
    -0.06526640f, 0.03327681f, 0.04895626f, 0.02110812f, 0.05777775f, 0.03326480f, 0.03406948f, -0.02172302f, 
    0.03309318f, -0.00069491f, 0.02280983f, 0.04246965f, -0.01580611f, -0.04873407f, -0.02330055f, -0.02345571f, 
    -0.05163957f, -0.00284620f, 0.03116029f, -0.06275246f, -0.05296474f, 0.01793212f, 0.02106421f, 0.00850872f, 
    -0.03833780f, -0.01207893f, 0.03150036f, -0.03683957f, -0.06894527f, 0.00157374f, 0.04792220f, 0.01115703f, 
    0.03074882f, 0.01323460f, 0.06555662f, 0.02768642f, -0.04818544f, 0.02576808f, 0.00870909f, 0.03214311f, 
    0.00079539f, -0.04506902f, 0.04381200f, 0.02077448f, 0.02064006f, 0.01531975f, -0.01607846f, -0.05300124f, 
    -0.05117719f, -0.00438390f, -0.00315515f, -0.05940488f, 0.01153517f, 0.01640299f, -0.00587455f, 0.02991565f, 
    -0.03538657f, 0.04903551f, 0.01465851f, -0.04206872f, 0.03791400f, 0.00105069f, -0.02263550f, -0.03512925f, 
    -0.04105382f, 0.03252977f, 0.03297799f, -0.01995177f, 0.03524305f, -0.02380861f, -0.05183835f, 0.03286399f, 
    0.00413058f, -0.06296854f, -0.00893800f, -0.05212224f, -0.06025593f, 0.04515176f, 0.04267879f, 0.00345975f, 
    -0.03898009f, 0.03716585f, -0.03021000f, -0.03376633f, 0.03367493f, 0.01753304f, -0.02566419f, -0.03880433f, 
    -0.00347751f, 0.03123495f, -0.06770211f, -0.04809383f, 0.04392494f, 0.01453066f, -0.01792971f, 0.01002291f, 
    -0.03862992f, 0.00305988f, -0.02850056f, -0.05133121f, 0.02513219f, -0.01642426f, -0.04445989f, -0.01946987f, 
    0.03478903f, -0.07516940f, -0.02669657f, 0.02262537f, 0.04930156f, 0.04490657f, -0.05285066f, -0.05191637f, 
    0.01240669f, -0.05692301f, 0.02888831f, -0.01925744f, -0.02157713f, 0.04593336f, -0.06100764f, 0.04290199f, 
    0.02367475f, 0.03661010f, -0.02803316f, 0.03008302f, 0.04968697f, -0.06015330f, 0.03854511f, 0.01145934f, 
    0.02666507f, 0.01002817f, -0.05236961f, -0.01332018f, -0.02616682f, -0.02386191f, -0.03832892f, 0.03063823f, 
    0.03335245f, -0.01290678f, 0.01710597f, 0.02193429f, 0.03880435f, -0.01080165f, -0.01568059f, 0.00741017f, 
    -0.02789246f, 0.01888930f, -0.03848837f, -0.03414420f, -0.04628015f, 0.04475000f, -0.05905426f, 0.01724821f, 
    -0.05166646f, -0.05103336f, -0.05324340f, -0.00839629f, 0.00763413f, -0.02116592f, 0.00677129f, 0.03874746f, 
    0.00234571f, 0.03770889f, 0.02187553f, 0.03483943f, -0.04370444f, -0.04134164f, -0.06166013f, -0.02840543f, 
    0.03398914f, 0.04399998f, 0.01457419f, -0.06939530f, -0.00949391f, 0.03958921f, 0.03241057f, -0.04350813f, 
    0.04954982f, -0.01141873f, 0.03745174f, 0.03377116f, -0.04472266f, -0.05770351f, -0.01283524f, -0.00367547f, 
    -0.05576479f, 0.02174573f, 0.00156848f, 0.04537827f, -0.00616824f, -0.03276598f, 0.03027591f, -0.01150011f, 
    0.00765163f, 0.04500729f, 0.03386477f, 0.05108260f, -0.00187407f, 0.04694911f, 0.00091050f, -0.06009381f, 
    -0.02734970f, -0.06882595f, -0.05388751f, -0.00227077f, -0.05008944f, 0.00899242f, 0.00511751f, 0.01368503f, 
    -0.01117269f, -0.06239024f, -0.01445254f, 0.00284682f, -0.03721318f, -0.04117209f, -0.04650223f, 0.02369443f, 
    -0.06301309f, -0.03493561f, 0.03568996f, -0.05219852f, 0.01309137f, -0.06100376f, -0.00160455f, 0.03626902f, 
    -0.01286227f, -0.01106842f, 0.03634038f, -0.00278842f, -0.02722067f, -0.02463438f, -0.05474202f, -0.00398785f, 
    -0.00623656f, -0.05048130f, -0.04159763f, -0.06616040f, 0.03899877f, 0.03674632f, -0.05236404f, 0.04895705f, 
    0.03700615f, 0.04433715f, -0.02796884f, 0.04279422f, 0.01440209f, -0.02298877f, -0.03001518f, -0.05221879f, 
    -0.03351903f, -0.05961982f, 0.04247284f, 0.01304085f, 0.02693421f, -0.02881326f, -0.00476068f, -0.03573385f, 
    -0.05237742f, -0.05300470f, -0.04458308f, 0.02841068f, -0.03181027f, -0.01922747f, -0.01936060f, -0.03373164f, 
    -0.00169001f, 0.02649840f, 0.05441029f, -0.06096018f, 0.00540572f, -0.01954615f, -0.05256559f, 0.04058836f, 
    -0.02475896f, -0.04503548f, 0.05600035f, -0.04733717f, -0.06354116f, -0.02874708f, -0.03554740f, -0.01890647f, 
    -0.05129944f, 0.04130149f, 0.03661209f, 0.00666928f, -0.05601125f, -0.01056071f, -0.01814779f, 0.05557298f, 
    0.05116251f, -0.04707450f, 0.02971706f, -0.04134938f, 0.01977652f, -0.04420225f, -0.03522330f, 0.04801939f, 
    0.01661025f, -0.04029234f, -0.05905028f, 0.01467483f, 0.00679388f, 0.03222435f, -0.04600041f, 0.00031149f, 
    -0.02622214f, 0.03999333f, 0.03885987f, -0.03471134f, -0.01716850f, 0.01360036f, 0.04896414f, -0.03314343f, 
    -0.04026068f, 0.00423687f, 0.01991632f, 0.00950701f, 0.02508796f, 0.01392876f, -0.05995185f, 0.04653456f, 
    -0.03939332f, 0.03405932f, 0.02045269f, 0.03615000f, -0.00676197f, -0.00984168f, -0.04847344f, -0.01178412f, 
    0.00269377f, -0.04081418f, 0.00349750f, 0.01874214f, 0.01619941f, -0.05782530f, -0.02365911f, -0.04934282f, 
    0.00880987f, 0.04750705f, -0.05550053f, -0.02613299f, 0.03363838f, -0.03936777f, -0.06987263f, 0.00206829f, 
    -0.05717301f, 0.01093430f, -0.05704574f, -0.04855778f, 0.02324631f, 0.00833279f, -0.01000457f, 0.01160822f, 
    0.01270177f, 0.00048439f, 0.04754564f, 0.01640720f, 0.04043548f, -0.04831412f, -0.05548170f, -0.06973956f, 
    0.02944827f, 0.03126496f, -0.02169974f, 0.03773125f, 0.00643401f, 0.00152796f, 0.01975297f, -0.01797400f, 
    0.03960240f, -0.06124221f, 0.04723059f, 0.00444344f, -0.03109872f, -0.06234188f, -0.01644727f, -0.02172995f, 
    -0.05595866f, -0.02084089f, 0.03846323f, -0.04708570f, 0.04905406f, 0.03663523f, 0.00539458f, -0.05145902f, 
    -0.05111270f, 0.00349318f, -0.02010052f, -0.02335959f, 0.05049777f, 0.01342387f, -0.05002279f, -0.03976920f, 
    -0.02571344f, -0.01030315f, -0.00169632f, -0.03933937f, -0.01208192f, 0.01570101f, 0.04902146f, -0.01861104f, 
    0.03752859f, -0.03152074f, -0.05964065f, -0.04884807f, 0.03203649f, -0.04970933f, -0.01696376f, 0.00189737f, 
    -0.05223194f, 0.00975524f, 0.00606768f, 0.02369296f, 0.00157733f, -0.00914767f, 0.02573239f, -0.06138295f, 
    -0.05017622f, -0.03933980f, 0.02135259f, 0.03525933f, 0.03839974f, -0.04207651f, -0.04242035f, 0.01914480f, 
    -0.00952366f, 0.02464318f, -0.06095126f, -0.05444402f, 0.03101603f, -0.04724751f, 0.04014970f, -0.02859918f, 
    -0.02738997f, 0.00761371f, -0.04100634f, 0.03192618f, 0.02277985f, 0.01407716f, 0.05211973f, -0.00681273f, 
    0.01171683f, -0.01625827f, 0.04739116f, 0.00368482f, -0.00174445f, 0.03664390f, 0.00039832f, -0.05788765f, 
    -0.00977244f, 0.01216001f, 0.03638331f, 0.03719058f, 0.04529093f, -0.03816387f, 0.03888640f, 0.01855296f, 
    0.04436792f, 0.02502463f, 0.01731215f, 0.01509391f, -0.03865226f, -0.02371590f, -0.05721842f, -0.04233280f, 
    0.04648580f, -0.06340458f, 0.01891539f, 0.02408462f, -0.05340672f, -0.04545854f, -0.02130917f, -0.02478709f, 
    0.01188197f, -0.05176528f, 0.01678017f, -0.04638643f, 0.00985006f, 0.02530453f, -0.02887909f, -0.02593642f, 
    -0.04006272f, -0.02578681f, -0.01064407f, -0.04261837f, 0.01701018f, 0.02511666f, -0.01381284f, -0.02490490f, 
    -0.04218943f, -0.00438939f, -0.00255776f, 0.03325569f, -0.01971238f, -0.05946230f, 0.03574590f, -0.05244204f, 
    0.01927664f, 0.02983386f, -0.02628088f, -0.02166089f, 0.01483949f, -0.05449168f, -0.06465448f, 0.03540421f, 
    -0.01124887f, -0.02494676f, 0.05238144f, 0.02490534f, 0.03426855f, -0.06272216f, 0.00839491f, -0.04519911f, 
    0.19041686f, 0.15757477f, -0.05188670f, 0.05036530f, 0.11234238f, 0.07616144f, 0.08636323f, -0.04759766f, 
    0.05186846f, 0.12631381f, 0.17858168f, -0.10662854f, -0.15969336f, -0.04751085f, -0.02768057f, -0.09093420f, 
    0.07719120f, 0.00069040f, 0.01656171f, 0.00201973f, 0.11809651f, -0.15415099f, -0.01247474f, -0.14168024f, 
    -0.11508784f, 0.09624848f, 0.00150873f, 0.15178217f, -0.05577826f, 0.09284927f, -0.10173971f, 0.13151802f, 
    0.04645287f, -0.12494970f, 0.04737234f, -0.13364871f, -0.06895474f, -0.04037035f, 0.06833654f, 0.04041547f, 
    -0.05493722f, 0.07251655f, -0.07798143f, -0.01130233f, 0.06852571f, -0.20550457f, -0.25336868f, 0.10538518f, 
    0.06143840f, -0.16864185f, -0.00525408f, -0.00337405f, -0.02217358f, 0.11001998f, -0.02208073f, 0.20287871f, 
    0.21902177f, 0.02233415f, -0.01518790f, -0.04524615f, -0.05585625f, -0.07899518f, 0.00720554f, 0.03963245f, 
    0.06005576f, 0.15279052f, 0.07616657f, -0.07754059f, -0.15177894f, -0.02036778f, 0.06200128f, -0.05537255f, 
    -0.14476539f, -0.41648772f, 0.03520999f, -0.00228111f, 0.01277666f, -0.00558983f, -0.05793611f, -0.08716350f, 
    0.03955371f, -0.08576102f, 0.20580038f, 0.04129681f, 0.02181805f, -0.06374812f, -0.02721959f, 0.01101346f, 
    -0.10306942f, -0.09814009f, -0.25515223f, 0.09270407f, -0.09367733f, 0.08968019f, -0.03729268f, -0.00372941f, 
    -0.01292171f, 0.03245302f, 0.08042017f, -0.11865974f, -0.16235878f, -0.08699200f, 0.12653840f, -0.13842067f, 
    0.07650631f, 0.01301733f, -0.14596671f, 0.07800501f, -0.24014454f, -0.26317167f, -0.02948482f, 0.11367195f, 
    0.00842887f, 0.03113739f, 0.14632918f, 0.05665005f, -0.04286689f, 0.08061893f, -0.00211336f, -0.16768904f, 
    0.04789828f, -0.15633732f, -0.14943196f, -0.01700594f, 0.00339602f, 0.12282723f, -0.30534902f, -0.01407449f, 
    -0.18013848f, -0.05673796f, 0.04378394f, 0.01244891f, 0.02098151f, -0.01036187f, -0.03552332f, -0.07453340f, 
    0.01571744f, 0.20142280f, -0.08562639f, -0.00275830f, -0.15524603f, -0.07603674f, -0.15520582f, 0.04727757f, 
    -0.06526159f, 0.14833105f, 0.01929537f, -0.00806115f, 0.04209096f, 0.16708496f, 0.01205261f, -0.07158469f, 
    -0.02041709f, 0.13455437f, -0.08009125f, 0.13837779f, 0.03388673f, -0.05637904f, -0.10947310f, 0.09477752f, 
    0.00812346f, 0.04713149f, 0.10245803f, 0.05362161f, 0.06397312f, 0.06739689f, -0.05244413f, -0.02474221f, 
    -0.08922002f, 0.11729769f, -0.11469418f, 0.08573499f, 0.16225459f, -0.17229208f, 0.07627346f, -0.05508731f, 
    -0.01845354f, 0.05487964f, 0.09972062f, -0.07755264f, -0.40439132f, 0.14931734f, -0.08943633f, -0.15398398f, 
    -0.01097808f, -0.00531468f, -0.06512449f, -0.07459628f, 0.01067670f, -0.10436816f, 0.19909298f, 0.17795129f, 
    0.01428117f, 0.13817401f, -0.01613984f, 0.02318326f, 0.04017386f, -0.05209604f, 0.07604480f, -0.22476028f, 
    0.22700857f, 0.11567219f, 0.01896883f, -0.10665670f, -0.00888910f, 0.03991877f, 0.14143579f, 0.14946797f, 
    -0.10306226f, -0.07775147f, 0.01252023f, -0.12794490f, 0.00272501f, -0.10098261f, -0.13516304f, 0.07468879f, 
    -0.05806540f, 0.51893991f, -0.17436869f, 0.06105740f, -0.00001754f, 0.02301103f, -0.05824628f, -0.01340776f, 
    -0.00683548f, 0.03454811f, 0.26037973f, 0.01140438f, 0.04726719f, 0.08357277f, -0.00536195f, 0.02168302f, 
    0.04093998f, 0.04694994f, -0.00265987f, 0.17773584f, 0.22882189f, -0.13943562f, -0.00838315f, -0.16276067f, 
    0.06570014f, 0.01701819f, -0.07304300f, -0.04816079f, 0.05472246f, -0.03703324f, -0.02284748f, -0.01384449f, 
    0.14154093f, 0.03905793f, 0.00193979f, 0.05738916f, -0.26304409f, 0.34269834f, -0.04135000f, 0.09604675f, 
    0.00204170f, 0.04468849f, -0.02211027f, -0.02694809f, 0.16828234f, 0.00550863f, -0.33487228f, -0.11042217f, 
    0.02884715f, -0.04649718f, -0.06786402f, 0.14094369f, -0.02569486f, -0.06773648f, -0.14019904f, -0.27570081f, 
    0.11917588f, 0.08241090f, 0.07002050f, -0.00888877f, -0.03520350f, -0.06088316f, 0.17353019f, 0.26660982f, 
    0.27700156f, -0.32949594f, -0.04725676f, -0.02697973f, -0.08664386f, 0.04131176f, -0.05182930f, 0.12285247f, 
    0.19894381f, 0.06059573f, -0.07455364f, -0.13045676f, 0.16792309f, 0.04044405f, 0.12819019f, -0.09155682f, 
    0.01312171f, -0.13219176f, 0.25294018f, -0.03853423f, -0.07142681f, -0.05854449f, -0.04356612f, 0.06039427f, 
    0.11889777f, -0.25704092f, 0.01255681f, 0.10734762f, 0.06112208f, 0.06886962f, -0.04365833f, -0.19675741f, 
    -0.05172008f, 0.11767616f, 0.03183218f, 0.02625747f, 0.25042194f, 0.17527041f, 0.04332647f, -0.03677714f, 
    -0.10355413f, -0.08678700f, 0.00508297f, -0.05487522f, 0.34117883f, -0.08915601f, 0.00865355f, 0.01852531f, 
    0.10139789f, -0.00174938f, 0.05154721f, -0.04662984f, 0.05632110f, 0.05752352f, 0.05342011f, -0.03983289f, 
    0.14352608f, -0.13263661f, 0.00552982f, -0.21159242f, -0.19332924f, -0.03647971f, 0.04116256f, 0.06118968f, 
    0.03657523f, 0.06734321f, -0.06757999f, 0.07032955f, -0.03054099f, 0.04149533f, 0.01881798f, -0.09390776f, 
    -0.04350664f, 0.17632942f, -0.02089267f, -0.02412635f, -0.08339648f, 0.20370440f, -0.10611448f, 0.15390685f, 
    -0.21285982f, 0.08041284f, 0.01935555f, 0.17014772f, 0.00292478f, 0.06901997f, -0.17255713f, -0.10807995f, 
    0.02183099f, 0.19186245f, -0.10095835f, 0.14633492f, -0.06722531f, 0.00038771f, -0.02952084f, -0.02792173f, 
    -0.05010291f, -0.05090389f, 0.16403016f, -0.12365587f, 0.12856644f, 0.11482883f, 0.05815409f, -0.13008310f, 
    0.04204949f, -0.01879720f, -0.11510512f, -0.00133065f, 0.00366568f, -0.02018816f, -0.09462079f, -0.17439033f, 
    0.06099205f, -0.05056993f, -0.01827177f, -0.09131774f, -0.11159536f, -0.21483552f, -0.00117045f, -0.08907527f, 
    -0.11963544f, 0.03467504f, -0.22328517f, -0.03400604f, -0.02281944f, -0.07243127f, 0.38635755f, 0.10557141f, 
    -0.00053312f, 0.00364754f, -0.11779477f, -0.09815525f, 0.00717897f, -0.06420318f, 0.08963507f, -0.01517727f, 
    0.23408394f, -0.00813235f, -0.17350875f, 0.15591660f, 0.00577033f, -0.12439207f, -0.17348737f, 0.26955268f, 
    -0.02301607f, -0.02995218f, 0.14698194f, 0.01361474f, -0.08115960f, 0.09701119f, -0.09715579f, -0.00591619f, 
    0.13876364f, 0.03590680f, 0.11984036f, 0.12106677f, 0.02042576f, -0.07599630f, 0.04287484f, 0.05405229f, 
    0.16808933f, -0.01051338f, 0.08020990f, 0.07285533f, 0.02330947f, -0.08975259f, -0.14529049f, -0.03114971f, 
    -0.09625619f, -0.07004242f, 0.06424163f, -0.18869132f, -0.10572041f, -0.10508719f, 0.02104948f, -0.10649025f, 
    -0.12225987f, -0.00240534f, -0.05275519f, -0.10664748f, 0.18729670f, 0.20876633f, -0.05729890f, -0.08349563f, 
    0.02083502f, 0.07919968f, 0.00703083f, -0.08564949f, 0.03871960f, -0.07933442f, 0.03797731f, -0.00115756f, 
    -0.08502010f, 0.05702636f, -0.06663464f, 0.04015648f, 0.05375917f, 0.17918894f, 0.12753578f, 0.02610998f, 
    0.02320465f, 0.01439260f, -0.13085891f, 0.01505296f, 0.06810937f, 0.01878383f, -0.11407649f, -0.05649677f, 
    -0.06188920f, -0.09033980f, -0.06371621f, -0.02898104f, -0.12537573f, -0.03728471f, 0.00042889f, -0.04708857f, 
    -0.08426705f, -0.14130923f, 0.06832232f, -0.09534164f, 0.01190448f, 0.15552880f, -0.10438925f, -0.00338202f, 
    0.15000954f, 0.01357210f, 0.10618949f, 0.17465170f, 0.12854449f, -0.02953182f, -0.01554621f, 0.06453219f, 
    0.02511303f, -0.00821239f, -0.04784046f, 0.16866678f, 0.13412422f, 0.10858378f, -0.01801834f, 0.07980037f, 
    0.06119196f, 0.12513423f, -0.14571375f, 0.02459985f, 0.15320835f, 0.04463223f, 0.02181791f, -0.06673400f, 
    0.01061529f, -0.02545509f, 0.08143789f, 0.07519605f, -0.00268238f, 0.06989306f, 0.07365728f, 0.08026715f, 
    0.05893361f, -0.08637101f, -0.04707623f, -0.06378667f, 0.07619383f, 0.10206124f, 0.08340699f, -0.01731559f, 
    -0.03175081f, -0.13883039f, 0.02215285f, -0.00162622f, 0.03130250f, 0.21482697f, 0.07462105f, 0.05792721f, 
    -0.07082204f, -0.14869776f, -0.12574311f, -0.09698459f, -0.03032305f, 0.08832673f, -0.09677394f, -0.28291664f, 
    0.01322465f, -0.05736566f, -0.03802749f, -0.08677348f, 0.00215521f, -0.09746815f, 0.04818419f, 0.07722413f, 
    0.02571802f, -0.11710352f, -0.18688758f, 0.12667762f, 0.04877286f, 0.12716535f, -0.13767043f, -0.07982223f, 
    0.08607824f, 0.01259363f, 0.02338957f, 0.02748411f, -0.07426895f, 0.03322014f, 0.04581005f, 0.02192823f, 
    -0.07949711f, -0.03217288f, 0.21077769f, -0.12772612f, -0.10639769f, 0.09808024f, 0.03534001f, 0.04263581f, 
    0.04811073f, 0.02561005f, 0.31214529f, 0.07282828f, -0.07063193f, 0.03386505f, 0.01514508f, 0.03410542f, 
    0.04376531f, 0.02490487f, -0.02965862f, 0.12902197f, 0.23195487f, -0.01911042f, -0.06634063f, -0.03488109f, 
    0.04008231f, 0.06120176f, 0.05336863f, -0.01670904f, 0.44622600f, -0.06233742f, 0.01745263f, -0.04446880f, 
    0.15720981f, 0.06573778f, 0.00872882f, -0.12527153f, 0.04129324f, -0.49430987f, 0.06203428f, -0.06784987f, 
    -0.02212195f, 0.03954161f, -0.07250040f, -0.00732074f, -0.04067804f, -0.02042653f, 0.10614468f, 0.13920186f, 
    0.01456293f, -0.06433994f, -0.00021950f, 0.05571865f, -0.02113630f, -0.08790774f, -0.02292219f, -0.07286995f, 
    -0.02593757f, -0.14558946f, 0.03724847f, 0.08869737f, 0.02497225f, 0.03190654f, -0.08359727f, -0.14381677f, 
    -0.52685207f, 0.09036326f, -0.01810278f, 0.02732077f, 0.05056400f, -0.08697337f, -0.04066995f, -0.06841446f, 
    -0.00631167f, -0.25420070f, 0.14245047f, 0.09265301f, 0.24699751f, -0.07849000f, 0.03277047f, 0.02805512f, 
    0.00619951f, 0.08206854f, 0.14491460f, 0.04228004f, 0.11246403f, -0.02905663f, 0.02085025f, -0.02991461f, 
    -0.21046434f, 0.16621713f, -0.13719252f, -0.01565697f, -0.00005162f, 0.02707802f, -0.17345542f, 0.09004129f, 
    -0.08871827f, -0.10557323f, -0.06380846f, 0.01721922f, -0.39716643f, -0.00902101f, 0.00808676f, 0.15064235f, 
    0.03094771f, -0.05154575f, -0.09233346f, -0.01107918f, -0.01464709f, -0.08896842f, -0.03769274f, -0.13352154f, 
    -0.03739356f, -0.03679270f, -0.01373310f, -0.10771719f, 0.15310112f, -0.11529640f, 0.08123220f, -0.09437932f, 
    0.03436061f, -0.06850023f, -0.03871648f, -0.00499224f, -0.12282112f, 0.09254872f, 0.09414908f, 0.00907568f, 
    -0.07710294f, -0.11919720f, -0.04337375f, -0.04082516f, -0.10948017f, -0.07170824f, 0.07648217f, -0.03949967f, 
    0.19839287f, 0.09660488f, 0.15686464f, 0.11094235f, 0.12239977f, 0.16100566f, -0.03407670f, -0.01218410f, 
    0.10349825f, 0.19249471f, -0.03934697f, 0.00544642f, -0.05643522f, 0.14897397f, 0.03488502f, -0.07806113f, 
    0.01995136f, 0.03219059f, 0.00476279f, -0.00666405f, -0.07555626f, 0.08154044f, 0.03948914f, -0.07933076f, 
    -0.05438289f, 0.11345037f, -0.06255548f, -0.00491236f, 0.07781735f, 0.03921469f, 0.07967652f, -0.03544911f, 
    0.00634592f, 0.04819909f, -0.00632765f, -0.07849738f, 0.14310190f, -0.01298506f, -0.00774033f, -0.03537818f, 
    -0.04984493f, 0.05273739f, 0.04033843f, -0.01509194f, -0.06661873f, 0.20327361f, 0.11037411f, -0.02281114f, 
    0.01434895f, -0.00209594f, 0.11048432f, 0.11885632f, -0.03366291f, -0.13313662f, -0.24063094f, 0.08831082f, 
    -0.04260955f, 0.13223325f, 0.03693853f, -0.04401178f, -0.09735694f, 0.00925428f, 0.10896762f, -0.09418362f, 
    -0.02299210f, -0.08353158f, -0.01529124f, 0.13339241f, -0.06701136f, 0.05064104f, -0.00760279f, -0.06568159f, 
    0.05493136f, 0.06452541f, -0.11286827f, 0.17436725f, -0.08162744f, -0.05693034f, -0.08298302f, -0.07823490f, 
    0.01457520f, 0.13734226f, 0.06229633f, 0.14420979f, -0.00794162f, -0.02152098f, -0.06141414f, 0.05145619f, 
    0.02961822f, 0.02595077f, 0.06372762f, 0.11892660f, -0.02574294f, 0.05444066f, 0.08450848f, 0.14680064f, 
    0.13140664f, 0.07597040f, -0.22200401f, 0.08281759f, 0.13382559f, 0.23019755f, 0.02015809f, 0.08697289f, 
    0.02322654f, -0.04330880f, -0.07267451f, 0.00589076f, 0.08623669f, 0.04559838f, -0.06172800f, 0.09401499f, 
    -0.00877498f, -0.09611873f, 0.04492254f, 0.09670407f, -0.04642627f, 0.23891638f, 0.05540217f, -0.06220615f, 
    -0.08489954f, 0.03561693f, -0.06599943f, -0.00356520f, 0.07068227f, -0.03102499f, -0.22398007f, 0.02635914f, 
    -0.01057499f, 0.08578271f, -0.01838786f, -0.06683142f, -0.07156762f, -0.03697831f, 0.01465375f, 0.01858241f, 
    0.01692028f, -0.17113379f, -0.18685542f, 0.04248473f, -0.12137047f, 0.01610706f, -0.00264313f, -0.06172632f, 
    -0.03417246f, -0.04375698f, 0.04288440f, -0.06269965f, 0.04707980f, -0.00321971f, -0.06637553f, 0.03946545f, 
    0.01199989f, 0.00131580f, -0.04341874f, -0.01448046f, 0.04527168f, 0.03038101f, -0.01491377f, -0.00775635f, 
    0.04151909f, 0.03097614f, -0.01746909f, 0.04500277f, -0.05277360f, 0.04748060f, 0.02427224f, 0.04858824f, 
    0.00824000f, 0.01319553f, 0.04457122f, 0.02338583f, -0.04263674f, -0.00804406f, 0.04235495f, -0.03249590f, 
    -0.04051768f, -0.05143407f, -0.03384735f, 0.04349624f, -0.04490196f, -0.01097982f, -0.00993339f, 0.02603879f, 
    -0.02602656f, -0.06286345f, 0.01271192f, -0.00147823f, -0.04781307f, 0.01753106f, 0.01584522f, 0.02572460f, 
    0.05784219f, 0.03637869f, -0.06224982f, -0.01144325f, -0.03720122f, 0.03212806f, -0.05578469f, -0.01400169f, 
    0.01337841f, 0.01335052f, 0.04199581f, 0.03716056f, -0.04708584f, 0.00708407f, -0.00233754f, -0.04007537f, 
    -0.05828236f, -0.01294572f, -0.05582842f, -0.01931109f, 0.04037129f, 0.02475613f, 0.02068415f, 0.04758557f, 
    -0.02430300f, -0.03433351f, -0.00047870f, 0.00745994f, -0.01974359f, 0.02276125f, -0.01680166f, -0.03763489f, 
    -0.02371843f, 0.00283610f, -0.01051507f, -0.02074244f, 0.01117681f, 0.02646174f, 0.03742793f, -0.01333842f, 
    0.04539346f, -0.01185422f, -0.03590878f, -0.05846860f, 0.02784372f, -0.03445925f, 0.01740339f, -0.01637283f, 
    -0.04178505f, 0.02280899f, 0.00816382f, -0.01452741f, 0.00715244f, 0.00729134f, 0.00288365f, 0.01827792f, 
    -0.03408682f, -0.03816039f, 0.03124883f, -0.05117643f, 0.02422508f, 0.00821371f, -0.04680011f, -0.05547265f, 
    -0.04183137f, -0.04433713f, -0.05723573f, -0.03763318f, 0.00359221f, -0.00055965f, 0.01256838f, -0.03753173f, 
    -0.06538683f, -0.02267559f, -0.01430092f, 0.03486629f, -0.01309144f, -0.06315639f, -0.01949405f, 0.01183482f, 
    0.01767475f, 0.03759550f, 0.03979818f, -0.06055249f, -0.06391211f, -0.04410780f, -0.03325009f, -0.04459456f, 
    -0.02175253f, 0.04079604f, -0.03157089f, -0.04821609f, -0.01408553f, 0.00729441f, -0.04819463f, -0.03423158f, 
    0.01313546f, -0.04511325f, -0.04729061f, 0.01047755f, -0.06401867f, -0.04052704f, -0.05778353f, 0.00696101f, 
    0.02562560f, -0.06014355f, 0.00945711f, -0.01485448f, -0.01102011f, 0.04979938f, -0.04283692f, -0.03607666f, 
    0.04844529f, 0.04064357f, -0.04879313f, -0.02345631f, 0.02011200f, -0.04089915f, 0.02799569f, -0.05685153f, 
    0.01971782f, -0.03633633f, -0.02022566f, 0.00123166f, 0.04761463f, -0.06420992f, -0.00695509f, 0.03349600f, 
    -0.04831698f, -0.01609514f, -0.02731379f, 0.00324811f, -0.03747706f, -0.06389054f, -0.04105939f, -0.03034945f, 
    0.04272829f, 0.02948855f, 0.03637622f, -0.02924009f, 0.04053261f, -0.06187876f, -0.02716786f, -0.05102653f, 
    -0.00223115f, -0.06338714f, 0.00434249f, -0.05545833f, 0.02097324f, -0.03991813f, -0.00793567f, -0.05810598f, 
    -0.00682624f, -0.02718630f, 0.03098140f, -0.03830930f, -0.03317947f, -0.02531995f, 0.02967929f, 0.00059124f, 
    -0.05768953f, -0.01552632f, 0.04720662f, 0.02862774f, 0.00686936f, -0.05220806f, -0.05244331f, -0.00764742f, 
    0.01627503f, -0.01230769f, -0.06325775f, -0.06031594f, 0.02251343f, 0.04899791f, -0.01875066f, -0.05930833f, 
    -0.05888155f, -0.02888829f, 0.00942222f, 0.00484975f, -0.00714688f, 0.03980924f, 0.03416906f, -0.04063001f, 
    -0.01942244f, -0.00097036f, -0.01032797f, -0.04836497f, -0.02544498f, -0.00853639f, -0.01470235f, 0.03576891f, 
    -0.00857597f, -0.05442576f, -0.03026845f, 0.00273854f, -0.06505406f, -0.00162579f, -0.06062655f, 0.03841123f, 
    0.02999083f, -0.06415138f, 0.02459751f, 0.00267098f, 0.01613509f, -0.06564210f, -0.03572193f, -0.03538126f, 
    0.03085785f, -0.01984141f, -0.04229233f, 0.00125737f, -0.03429996f, 0.03793927f, -0.05215534f, 0.04009895f, 
    0.04326475f, 0.03648277f, 0.01670727f, 0.04459595f, -0.05560947f, -0.05315640f, 0.01668827f, -0.02159140f, 
    0.00359148f, -0.05167678f, -0.06007252f, 0.01396319f, -0.06041085f, 0.00725808f, -0.05711995f, -0.05219213f, 
    -0.06685653f, 0.01327067f, -0.00502331f, -0.00042398f, -0.01565198f, -0.02228559f, -0.05077221f, 0.01942698f, 
    -0.06102934f, -0.19394694f, 0.08347670f, 0.05079216f, 0.00799711f, -0.07623584f, 0.05182568f, 0.05953308f, 
    -0.06493705f, 0.08525543f, 0.20568936f, -0.01711176f, 0.13219096f, -0.05621906f, 0.09182873f, 0.18985824f, 
    0.02234451f, -0.19261324f, -0.09458246f, -0.23936842f, 0.08588333f, 0.00942326f, -0.01291765f, 0.04475216f, 
    -0.00474394f, -0.00959579f, -0.06049139f, 0.15668836f, 0.13026294f, 0.07337341f, 0.07347426f, -0.09103719f, 
    0.13495077f, 0.09790999f, -0.13678567f, -0.13624457f, 0.12364727f, -0.13341595f, -0.01346734f, 0.03191481f, 
    -0.03536154f, -0.08952497f, 0.07886935f, -0.03111105f, 0.10588055f, -0.09311470f, 0.11191312f, 0.11510158f, 
    -0.08081045f, -0.01454933f, 0.01667263f, 0.04714881f, 0.01866229f, -0.02352736f, -0.04634335f, -0.21187285f, 
    0.05944018f, 0.10680830f, 0.07119982f, 0.08433687f, -0.11405575f, 0.13446163f, -0.02121371f, 0.14369021f, 
    0.06361140f, 0.05615631f, -0.09366017f, -0.05785402f, -0.14382297f, 0.12770706f, 0.01791050f, 0.14202899f, 
    -0.14934680f, 0.13287114f, 0.02177601f, -0.05817270f, -0.01069834f, -0.08495643f, -0.02841850f, -0.00317915f, 
    0.10373872f, 0.07795992f, -0.12019791f, 0.14888114f, -0.06075052f, -0.10554025f, -0.10389466f, -0.14699809f, 
    0.01387230f, 0.01121229f, 0.03999789f, -0.07182909f, -0.00814457f, 0.05022306f, -0.04149306f, -0.07670789f, 
    -0.28053284f, -0.01741626f, 0.08229893f, -0.05489490f, -0.04916866f, -0.07927375f, -0.05483840f, 0.01019989f, 
    -0.00632781f, -0.21891579f, -0.06555533f, -0.01683856f, -0.31370932f, -0.16105455f, -0.04204024f, -0.09832346f, 
    -0.06291653f, 0.00533526f, -0.09770829f, 0.02754937f, 0.04576314f, -0.18154587f, 0.05138967f, -0.02225813f, 
    -0.05958284f, -0.04511640f, -0.04728194f, 0.02595014f, 0.02126442f, -0.06264744f, -0.04918920f, 0.09565841f, 
    0.02651431f, 0.14092997f, -0.07263197f, 0.11981260f, -0.13537408f, -0.20248349f, -0.00187842f, -0.20380372f, 
    0.12846616f, 0.10480146f, 0.16217846f, 0.10728215f, -0.16141257f, 0.03911538f, 0.03185069f, 0.17261843f, 
    0.29528573f, 0.06250980f, 0.14827226f, 0.13445233f, -0.00506031f, 0.06495253f, 0.16294549f, 0.02352413f, 
    0.09865205f, -0.20219345f, -0.04818732f, 0.02413987f, 0.10071627f, -0.05929263f, -0.02078788f, -0.02027092f, 
    0.10898139f, -0.04466020f, 0.10292473f, 0.15350986f, -0.02780483f, 0.00490355f, -0.12623008f, -0.14551888f, 
    0.07386019f, -0.00597727f, 0.08164779f, 0.14333881f, 0.26457274f, 0.12561518f, -0.04809332f, 0.01679908f, 
    0.05805944f, -0.01832190f, 0.00973250f, 0.00575320f, 0.11494605f, -0.02716016f, 0.19949828f, -0.03843369f, 
    -0.01292124f, 0.03658180f, -0.03924784f, -0.03451188f, 0.03939392f, 0.14114311f, 0.05518994f, 0.07369723f, 
    -0.05467233f, 0.00869216f, 0.16578825f, 0.07524926f, -0.11071125f, 0.06706803f, 0.05704327f, 0.16242182f, 
    -0.11113800f, -0.17909551f, -0.01263350f, -0.10733677f, -0.11707857f, -0.00590603f, -0.00967272f, -0.09426480f, 
    0.12833118f, -0.10168708f, -0.12613188f, 0.03677189f, -0.10597401f, 0.10115531f, 0.07734952f, 0.06652125f, 
    0.22650501f, 0.15850478f, 0.17061578f, 0.10240918f, -0.10798892f, 0.12669094f, 0.01505576f, -0.03812399f, 
    0.04277094f, 0.22903946f, 0.25431028f, 0.10704727f, -0.02300049f, 0.05721984f, 0.06066496f, 0.00756524f, 
    0.11050669f, -0.12464143f, 0.00800744f, -0.07362406f, 0.16002622f, 0.01974461f, -0.19024074f, 0.05889403f, 
    -0.13687968f, 0.03858998f, 0.14798990f, 0.14541656f, 0.16673774f, 0.06648660f, 0.04971379f, 0.06908412f, 
    -0.03441305f, 0.07542526f, 0.07054146f, 0.03592726f, 0.23601611f, 0.15080598f, 0.05574936f, 0.06724618f, 
    -0.02988147f, -0.02002811f, -0.05765449f, 0.07362503f, 0.11295418f, -0.09250139f, -0.17423379f, -0.06315786f, 
    -0.21552691f, -0.07726742f, 0.15923260f, -0.10024494f, -0.00111521f, -0.09809040f, -0.37590840f, -0.03541758f, 
    -0.11058240f, -0.10225277f, -0.02189665f, 0.07236478f, -0.04927227f, 0.01963592f, -0.00167321f, -0.08360112f, 
    0.05157074f, -0.03564496f, 0.00147128f, 0.00329427f, 0.15816273f, -0.01936376f, -0.02373648f, -0.06589302f, 
    -0.03031817f, 0.01806083f, 0.04224629f, 0.00086014f, -0.03304008f, 0.00327725f, -0.04849270f, -0.06430513f, 
    0.03855579f, -0.02864215f, 0.03241012f, 0.05557328f, 0.04754760f, 0.02445798f, -0.04121162f, -0.00811910f, 
    0.01877862f, -0.02867956f, 0.02888164f, 0.02950714f, -0.04643937f, 0.01584571f, -0.02669493f, -0.02922256f, 
    -0.05840984f, -0.02919345f, 0.05532636f, -0.01894400f, 0.00227876f, -0.04960029f, -0.05145044f, -0.00021883f, 
    0.00363316f, -0.02308846f, -0.01520779f, -0.03502659f, -0.00786090f, 0.02593806f, -0.05631707f, -0.00385862f, 
    -0.01515847f, -0.02563079f, -0.00862353f, 0.02476238f, -0.06229258f, 0.03822220f, -0.05749008f, -0.02039719f, 
    0.02049478f, -0.04809435f, -0.05456103f, -0.04685521f, 0.03264187f, -0.00039758f, -0.03909433f, -0.00328207f, 
    0.03348956f, 0.00987006f, -0.01933221f, -0.03336044f, 0.02133995f, -0.04813071f, 0.04446016f, -0.01262449f, 
    -0.00357388f, -0.02504792f, 0.04447635f, 0.00603680f, 0.02926417f, 0.01898489f, -0.03258787f, -0.00038496f, 
    -0.03861062f, 0.00343178f, 0.02722909f, -0.05156219f, 0.04925964f, -0.05832874f, 0.01843241f, 0.03503545f, 
    -0.06135642f, -0.00409424f, -0.05393755f, 0.03710596f, -0.01632120f, 0.02664128f, 0.00849674f, 0.01669939f, 
    -0.02868201f, -0.05573897f, 0.02634899f, -0.04811741f, -0.05649589f, -0.04237511f, 0.04999334f, 0.04672097f, 
    -0.04323946f, -0.04637531f, 0.02730162f, -0.01632994f, -0.03193676f, 0.00574140f, -0.06137221f, 0.00827470f, 
    0.05390918f, -0.01930513f, 0.00056095f, -0.03370190f, -0.01704854f, -0.04994816f, -0.05077674f, -0.00303578f, 
    -0.02570131f, 0.02145124f, -0.03232681f, 0.03580981f, -0.03595940f, 0.05803494f, 0.03855358f, -0.00103914f, 
    0.03502870f, -0.04247623f, -0.05075869f, 0.03857140f, -0.02133257f, -0.02652843f, 0.02903117f, -0.02427232f, 
    0.03011492f, -0.02267926f, 0.03913306f, -0.03601656f, 0.04420306f, 0.03181954f, 0.01801215f, 0.02617950f, 
    -0.04755774f, -0.06018455f, -0.01885639f, 0.04214033f, 0.00522044f, 0.01228097f, 0.01346946f, -0.01876476f, 
    0.02048216f, -0.01798212f, -0.04300248f, -0.04462492f, 0.03639015f, 0.05388615f, -0.04579343f, -0.00414998f, 
    -0.04536448f, 0.05025839f, -0.01124846f, 0.04838066f, -0.05624512f, -0.04049208f, -0.01902857f, -0.00704178f, 
    -0.00858765f, -0.02200123f, -0.04674888f, -0.02424186f, 0.05116684f, 0.03742567f, 0.02779107f, 0.00843313f, 
    -0.05140464f, 0.02063853f, -0.01060531f, 0.01736902f, -0.05539237f, -0.00104225f, 0.02332443f, -0.02478177f, 
    0.05003189f, -0.00649591f, -0.02577799f, 0.02634926f, -0.04985894f, 0.01681488f, -0.02935787f, -0.05744992f, 
    0.02427251f, -0.00815193f, 0.03217613f, -0.03603317f, -0.05786235f, -0.04287174f, -0.04701179f, -0.03215018f, 
    0.03881840f, 0.00783184f, 0.01295866f, 0.03723321f, 0.00065543f, -0.05478450f, 0.01530292f, 0.04617012f, 
    0.04124160f, 0.01784720f, 0.01524797f, 0.05624633f, 0.01769154f, -0.05176563f, -0.01624781f, -0.01754834f, 
    -0.03397375f, -0.03598038f, 0.04253001f, -0.05898708f, 0.03467531f, 0.00714434f, 0.00105404f, -0.05546518f, 
    0.04892012f, 0.04348549f, -0.03323206f, -0.00111936f, 0.02498762f, 0.04923751f, -0.01215672f, -0.01823193f, 
    0.04650358f, 0.01152156f, -0.01645215f, -0.01144403f, 0.02634163f, -0.04260495f, 0.03650958f, 0.05299262f, 
    0.03609753f, 0.02627592f, -0.00905685f, -0.03915108f, -0.01123484f, 0.04988274f, -0.02643049f, -0.04870522f, 
    0.01671465f, -0.00593453f, 0.05406817f, -0.02034309f, -0.03716486f, -0.02071235f, -0.01869007f, -0.04150286f, 
    -0.04481415f, -0.01930527f, 0.01493748f, 0.04311525f, 0.02691691f, -0.04160451f, -0.02427646f, -0.04029507f, 
    -0.01422083f, -0.04400863f, 0.03993258f, 0.00180882f, -0.05455129f, 0.04666695f, -0.00472786f, -0.05705876f, 
    -0.05553522f, -0.05824621f, -0.04018138f, -0.03944298f, 0.00992612f, 0.04676027f, 0.02767784f, 0.02146270f, 
    0.03346938f, -0.04724475f, -0.00212620f, -0.02834802f, -0.04784971f, -0.00473501f, 0.03926416f, -0.01139850f, 
    -0.01237676f, -0.05485473f, -0.04499184f, 0.03304195f, -0.05284515f, -0.05517824f, 0.01928742f, -0.00897353f, 
    -0.37753549f, 0.07117640f, 0.04559984f, 0.17818475f, 0.11958889f, 0.05046053f, -0.20294440f, -0.06218359f, 
    -0.22719769f, -0.04580778f, -0.56041062f, 0.10677464f, 0.04217603f, -0.00701159f, 0.02390510f, -0.03878602f, 
    0.00984108f, -0.12255291f, 0.13104169f, 0.00862711f, 0.10703263f, 0.02476113f, -0.03711654f, 0.02667494f, 
    -0.05075841f, -0.00038279f, -0.04891600f, 0.22061323f, -0.46159527f, -0.17489293f, 0.01627203f, 0.14290349f, 
    0.02160147f, -0.10487584f, 0.02458620f, -0.06757274f, 0.06020393f, 0.02346171f, -0.06346349f, -0.01485076f, 
    -0.13643390f, -0.01972993f, 0.14749059f, -0.00650901f, 0.03195852f, 0.07710540f, 0.09072454f, -0.22938392f, 
    -0.17532884f, -0.02551675f, 0.04002996f, -0.04147888f, 0.05888005f, -0.09330021f, -0.00916981f, 0.15958494f, 
    -0.08494165f, -0.04849103f, 0.13630210f, -0.12344795f, -0.01599700f, 0.03733155f, -0.02900734f, 0.10234988f, 
    -0.05704940f, 0.03526567f, -0.06419373f, -0.01346170f, -0.10365964f, -0.10913882f, 0.02420194f, -0.01182068f, 
    0.26321420f, 0.11978737f, -0.16471885f, -0.14873879f, -0.05651540f, -0.02428845f, -0.10095080f, 0.01244696f, 
    -0.01631012f, -0.08585938f, -0.11259585f, 0.19011420f, 0.03243493f, -0.00050250f, -0.04642574f, -0.03473169f, 
    0.06855283f, -0.07748376f, -0.25399232f, -0.14845717f, -0.17330272f, 0.14629824f, -0.01154236f, 0.11061271f, 
    0.14838971f, 0.04889508f, 0.06064707f, -0.23340572f, 0.03494162f, -0.10041936f, 0.05126795f, 0.00301310f, 
    0.03898060f, 0.04447242f, -0.04201075f, 0.12337016f, 0.15091836f, 0.11461052f, -0.16205660f, -0.01359081f, 
    -0.08655260f, 0.03303770f, -0.03182621f, -0.01322500f, 0.11477379f, 0.07302872f, -0.59231681f, -0.21726212f, 
    0.01860335f, -0.00534643f, -0.06325778f, 0.00932298f, 0.01292039f, 0.11184153f, -0.13191304f, -0.24748088f, 
    -0.05211256f, 0.03919904f, 0.06393448f, 0.09873632f, -0.02540994f, -0.02366486f, -0.03131313f, -0.23855796f, 
    0.08530768f, -0.19570361f, 0.05409898f, 0.06119284f, 0.00480306f, 0.08331455f, -0.01281407f, 0.08897088f, 
    0.19203261f, 0.12556501f, -0.10583232f, 0.03697649f, -0.06864568f, -0.06163127f, 0.16779695f, 0.10275852f, 
    -0.00564616f, 0.18099827f, 0.01970690f, -0.25765103f, -0.13187958f, 0.10815143f, 0.02981976f, 0.04775584f, 
    0.02685196f, 0.13380863f, -0.15364018f, 0.01667985f, 0.00446637f, 0.01099410f, 0.06016407f, 0.03670504f, 
    0.17118493f, 0.04674144f, 0.16518879f, -0.19053189f, -0.19389947f, 0.06075714f, -0.00011441f, 0.01170563f, 
    -0.01659255f, -0.07621878f, -0.08501706f, -0.02088272f, -0.12229589f, 0.35663104f, -0.07267585f, -0.00772736f, 
    0.01423972f, 0.06232298f, 0.03027860f, -0.08459977f, 0.01160942f, -0.01870739f, 0.24466895f, 0.04337716f, 
    0.00674562f, 0.01686230f, -0.06500208f, 0.06455529f, -0.06988326f, -0.00960809f, -0.08789931f, -0.02663794f, 
    0.23512486f, -0.03253328f, -0.04760356f, -0.02310202f, 0.09125958f, -0.07605833f, -0.02979800f, -0.26070896f, 
    0.15065457f, -0.04349556f, 0.03163658f, -0.17387038f, 0.15332337f, 0.00990930f, 0.04715937f, -0.00093432f, 
    0.22179300f, 0.29740798f, -0.19138272f, 0.06202319f, -0.05444617f, 0.11140990f, 0.15565605f, 0.13117689f, 
    -0.10428603f, 0.08403258f, 0.17673890f, 0.05523430f, 0.08218088f, 0.05233084f, 0.08138672f, -0.03703720f, 
    -0.02384315f, 0.05020867f, 0.04757600f, 0.24530999f, 0.11754170f, -0.02190232f, 0.10644742f, -0.06525439f, 
    0.01323583f, 0.00036247f, -0.07525502f, 0.18953189f, -0.15718758f, 0.04887057f, 0.08300887f, 0.02420070f, 
    -0.01761312f, 0.17289938f, 0.13127103f, 0.12384672f, 0.19642024f, -0.18195158f, 0.00378668f, -0.10470106f, 
    -0.06934976f, -0.01211110f, 0.10579293f, 0.00884052f, 0.10277563f, -0.23282640f, -0.34443390f, -0.09544130f, 
    -0.06326639f, 0.08429021f, 0.04568458f, -0.03709911f, -0.04901870f, 0.12366633f, -0.09785435f, 0.15050088f, 
    0.00848614f, 0.01906076f, -0.05736182f, -0.04737942f, 0.00929655f, -0.02273771f, -0.00642010f, -0.36674589f, 
    -0.22999808f, 0.05395974f, 0.00466770f, 0.16170743f, 0.09271891f, -0.02434728f, 0.07809314f, -0.10512216f, 
    -0.27508315f, -0.23051269f, 0.00042367f, 0.16125129f, -0.08304769f, 0.01675610f, 0.03637639f, -0.11800142f, 
    -0.11187968f, -0.19931135f, -0.03984049f, -0.19322222f, 0.04197039f, 0.23444504f, 0.06387156f, 0.17410155f, 
    0.12128551f, -0.10106427f, 0.25866127f, 0.28705326f, -0.20956102f, 0.06069181f, -0.04920471f, 0.02194528f, 
    0.11675873f, -0.08574267f, -0.01255861f, 0.00594786f, -0.13585815f, -0.14170378f, 0.02059900f, -0.11370245f, 
    0.18064275f, 0.03712500f, -0.16663322f, -0.08348572f, 0.05116463f, 0.12714237f, -0.13207939f, 0.22427833f, 
    -0.02245846f, -0.17060547f, 0.08546761f, 0.08869610f, 0.03191715f, -0.08304639f, 0.04337746f, -0.05582189f, 
    -0.01562377f, 0.03419251f, 0.01944983f, 0.07985745f, -0.01063478f, -0.06632455f, -0.03258498f, 0.23970725f, 
    -0.18409276f, 0.17731836f, -0.10990439f, 0.11435991f, 0.09315481f, -0.01160790f, -0.08405950f, 0.09740328f, 
    0.07991322f, -0.10200909f, -0.08604780f, 0.03148672f, 0.00523855f, 0.18982874f, 0.00525817f, 0.02784166f, 
    0.05921810f, 0.01551859f, 0.03269448f, 0.05147558f, 0.22897433f, 0.07176656f, -0.01390446f, 0.01552366f, 
    0.00012827f, -0.20945093f, -0.12171969f, 0.11682982f, -0.03432612f, -0.13069594f, 0.25326109f, 0.14946252f, 
    0.16171822f, 0.08723944f, -0.26199353f, -0.24399838f, 0.07448596f, -0.10797129f, -0.07090653f, 0.07297227f, 
    0.00779427f, -0.00339233f, -0.08442076f, -0.20871726f, -0.00416164f, -0.03603175f, -0.00789396f, -0.14480442f, 
    0.05839761f, -0.06160871f, -0.07478978f, 0.16162892f, 0.14791027f, -0.01536633f, -0.00425229f, -0.00175666f, 
    0.08040410f, 0.13226075f, -0.03612404f, 0.02936654f, 0.15686905f, -0.32605162f, 0.16158390f, -0.09264765f, 
    -0.05118809f, 0.00985854f, 0.13637145f, 0.02032109f, 0.11881531f, -0.05834829f, -0.13577341f, -0.29773423f, 
    0.11877004f, 0.06036778f, -0.06832976f, 0.03895940f, -0.02676550f, 0.06707547f, -0.20272900f, -0.03018347f, 
    -0.01826514f, -0.41626883f, -0.02331998f, -0.03913897f, 0.01900591f, 0.16901605f, 0.05344918f, -0.05353034f, 
    0.13625623f, 0.17502077f, -0.43489009f, -0.09898205f, -0.00394038f, 0.01264739f, 0.07337543f, -0.14754309f, 
    -0.06405593f, 0.13890176f, 0.16815749f, -0.11183418f, -0.03996600f, -0.00601926f, -0.13028124f, 0.08403456f, 
    0.08637807f, -0.05694108f, 0.00800489f, 0.09046761f, 0.05634638f, 0.05126353f, 0.16229773f, -0.02682090f, 
    0.11075613f, 0.04750123f, 0.18597130f, -0.33545411f, -0.26497871f, 0.10295852f, -0.02637470f, 0.02042755f, 
    0.02263917f, -0.07757492f, 0.09007517f, 0.11976524f, -0.27589577f, -0.13647170f, 0.07419563f, 0.01169718f, 
    0.06527558f, -0.01058963f, 0.08087616f, 0.20335917f, 0.10478204f, 0.16274206f, 0.11636839f, -0.39743891f, 
    0.02348099f, 0.04398610f, -0.08248073f, -0.06046230f, 0.06366949f, -0.00771440f, 0.08986722f, 0.05157789f, 
    0.10561527f, 0.10610052f, 0.08018571f, 0.08213528f, -0.03016360f, -0.03113523f, -0.02433371f, -0.04241295f, 
    0.11253686f, -0.08212053f, 0.03641361f, 0.00250818f, -0.01683600f, 0.06694420f, 0.05000293f, -0.06964933f, 
    0.06763347f, 0.18701737f, -0.47684732f, -0.04046519f, -0.12601677f, -0.05867600f, 0.03605020f, 0.01424599f, 
    0.00652411f, 0.02609818f, -0.05157723f, -0.37144855f, 0.02601043f, 0.20701185f, 0.07560845f, 0.14665650f, 
    -0.02864211f, -0.07561025f, 0.05263253f, 0.06723753f, 0.02792742f, -0.08778080f, -0.09568498f, 0.05851681f, 
    0.01367663f, -0.08807705f, 0.09548832f, 0.02713262f, -0.15494572f, -0.19317254f, -0.04574524f, 0.11978483f, 
    0.05383511f, 0.00543067f, -0.00341729f, -0.04334824f, -0.26778823f, -0.18040600f, -0.10639032f, 0.09057049f, 
    -0.02833210f, 0.02485602f, 0.14060372f, 0.09790346f, 0.08836598f, -0.00128525f, -0.06402762f, 0.05086108f, 
    -0.02755088f, -0.02391857f, 0.10302897f, 0.00158147f, -0.07513218f, 0.11866745f, 0.07459915f, 0.10994029f, 
    0.00174965f, 0.00567519f, 0.12156275f, 0.16226405f, 0.01666279f, 0.01167644f, 0.13781202f, -0.33311918f, 
    -0.17797805f, 0.10190068f, 0.00444759f, 0.12009394f, -0.11062498f, 0.06361684f, -0.05078463f, 0.12114289f, 
    -0.03301107f, 0.17840306f, 0.09499100f, -0.00948264f, -0.03361388f, -0.03107461f, 0.11417782f, 0.08109637f, 
    0.11598010f, 0.15067695f, -0.03905999f, 0.06470527f, -0.14642368f, -0.29356989f, 0.08710984f, 0.06387049f, 
    0.05717906f, 0.28152958f, -0.00884126f, -0.07382346f, 0.01156267f, 0.00489541f, -0.13867399f, -0.06334677f, 
    -0.02348186f, 0.03262117f, -0.05036966f, -0.04207319f, -0.13723756f, -0.21736282f, 0.08954707f, -0.09656326f, 
    0.15355441f, 0.08704557f, -0.12421943f, -0.13971989f, 0.01817860f, -0.09702539f, -0.03726671f, 0.02087731f, 
    -0.10760441f, 0.00641993f, -0.06953371f, -0.04779883f, -0.04208482f, -0.39789227f, -0.02349982f, -0.05661810f, 
    0.16095865f, 0.03271078f, 0.11536685f, -0.20076779f, -0.19245823f, -0.08333896f, 0.11829756f, 0.09525651f, 
    -0.01008052f, -0.15408047f, -0.00153903f, -0.15308549f, 0.02176743f, 0.04978578f, -0.01518744f, -0.19934544f, 
    -0.18946423f, 0.12565359f, -0.15888381f, -0.08807037f, -0.12801117f, -0.04619731f, 0.10239200f, 0.09397645f, 
    -0.04871448f, -0.07312657f, 0.03673078f, 0.02030087f, 0.08953533f, 0.12259931f, -0.09743247f, 0.07083111f, 
    0.06949519f, -0.25616515f, 0.28287119f, 0.02165532f, -0.01268638f, 0.17137939f, -0.00025046f, -0.06186700f, 
    -0.18743554f, 0.04275137f, 0.15355010f, 0.11369650f, 0.12994353f, -0.00192653f, -0.17623177f, 0.06821050f, 
    -0.16995986f, -0.01793823f, 0.00580734f, 0.06531985f, 0.06695150f, 0.20155355f, 0.07280245f, 0.09894960f, 
    0.05784455f, -0.08298879f, -0.10362340f, -0.01641111f, 0.05585295f, 0.04774298f, 0.05157819f, 0.09405878f, 
    0.11898613f, 0.03751764f, 0.03339035f, -0.17558059f, -0.01659393f, -0.43329677f, -0.13591248f, -0.21771334f, 
    -0.02438903f, -0.10554249f, -0.06951310f, -0.15797414f, -0.23448570f, 0.06035281f, 0.37962890f, -0.00594622f, 
    0.02545139f, -0.15606801f, -0.01563316f, 0.17164008f, -0.05671258f, 0.00103869f, 0.02062399f, 0.16049424f, 
    -0.05036442f, 0.08658358f, -0.02396793f, -0.18084133f, -0.01202031f, -0.06174874f, -0.00608175f, -0.04306150f, 
    0.15491788f, 0.06339826f, -0.07465965f, -0.13571438f, 0.13289751f, -0.16901118f, 0.03515860f, 0.02320278f, 
    -0.05675339f, -0.02172921f, -0.09317705f, 0.08435326f, 0.03315533f, -0.07636999f, -0.06006738f, 0.13789272f, 
    -0.04621988f, 0.07642738f, -0.42013422f, 0.00941008f, 0.19798039f, 0.14759076f, -0.03752838f, -0.07960048f, 
    0.13140421f, 0.08236801f, 0.02078007f, 0.15031286f, 0.03130567f, 0.00732163f, 0.03263460f, -0.11582028f, 
    0.16831179f, 0.05071060f, -0.12972908f, -0.08887864f, 0.16839118f, 0.08986937f, -0.08538114f, -0.12686238f, 
    0.15023245f, -0.08113373f, 0.09945801f, 0.04348417f, 0.00192628f, 0.07776752f, 0.05522294f, 0.00225648f, 
    -0.09383584f, 0.06784264f, -0.07928409f, 0.07116605f, 0.01133765f, 0.01907861f, -0.48836201f, -0.06306361f, 
    0.11276560f, 0.20554911f, 0.22726735f, 0.09337544f, 0.09302227f, 0.02362018f, 0.06046394f, -0.21706672f, 
    -0.01895349f, 0.17655714f, 0.01874292f, -0.09005726f, -0.03764278f, 0.20515124f, 0.04485166f, 0.10198105f, 
    0.01007952f, -0.08579164f, -0.03621743f, -0.21067782f, 0.04101339f, -0.10506168f, -0.10392097f, -0.10581154f, 
    0.02767556f, 0.06003547f, 0.09751152f, 0.00914818f, -0.17874157f, -0.05481738f, -0.03659608f, 0.11873834f, 
    0.10462406f, 0.02574902f, 0.10215960f, -0.05210041f, 0.01421710f, 0.00601255f, 0.02699795f, 0.10414107f, 
    0.20293723f, 0.00001325f, 0.03160739f, 0.07261812f, 0.07622367f, -0.02778169f, -0.10390883f, 0.06320068f, 
    -0.11786710f, 0.03267413f, 0.02522923f, -0.12807319f, -0.05164415f, 0.10247513f, 0.18183842f, 0.07822649f, 
    0.07468617f, 0.15549539f, -0.16190220f, -0.01348865f, -0.13193415f, 0.14237320f, 0.15109564f, -0.10081849f, 
    0.16079399f, 0.20858407f, 0.01980083f, -0.12525269f, 0.01103742f, -0.01398223f, 0.19568011f, 0.15560514f, 
    0.12678275f, 0.09214862f, 0.08041494f, -0.01209328f, -0.14764424f, -0.04350868f, -0.07372092f, 0.14899106f, 
    0.20638315f, 0.00414796f, 0.11218120f, -0.01646036f, 0.09741299f, 0.10900294f, 0.10309737f, 0.08692271f, 
    0.10054421f, -0.14264038f, -0.11226792f, -0.09135391f, 0.04330984f, 0.02988120f, -0.02390026f, 0.11572658f, 
    -0.14676017f, -0.10340180f, 0.06209337f, 0.03845050f, 0.07260092f, 0.05479140f, -0.01190474f, -0.06041731f, 
    0.07062050f, -0.13645656f, -0.20276241f, -0.13663146f, -0.00701533f, 0.04580255f, 0.04597691f, 0.10457999f, 
    -0.07004172f, 0.22580045f, -0.00141183f, 0.01167922f, -0.06715392f, -0.00240643f, -0.00446095f, -0.01760850f, 
    -0.06972923f, -0.28551334f, 0.13381729f, 0.21710572f, -0.11514955f, -0.11385696f, -0.03001134f, 0.16065167f, 
    0.04010298f, 0.02116574f, -0.05186712f, -0.03724183f, -0.11187686f, 0.39608729f, -0.03644462f, -0.04885412f, 
    0.02411086f, 0.04887798f, -0.07038985f, 0.09711225f, 0.05028989f, -0.04428778f, -0.14873095f, 0.20914638f, 
    0.08320486f, 0.01578166f, -0.03781733f, -0.05033780f, 0.05306934f, 0.07425964f, -0.12837934f, -0.44744465f, 
    -0.48875660f, -0.28013036f, 0.07668920f, 0.17821093f, 0.06115443f, 0.01665944f, 0.02349321f, -0.22761188f, 
    0.30267680f, -0.07796858f, -0.03050718f, 0.01808845f, -0.07597858f, -0.01349770f, -0.05213004f, 0.06670229f, 
    0.05151310f, 0.10115354f, 0.06585376f, -0.03010763f, 0.02965227f, -0.03979267f, -0.02822980f, 0.07441795f, 
    0.08421433f, 0.11551894f, -0.16372469f, 0.15849954f, -0.07275032f, -0.01455011f, -0.08492191f, -0.04806001f, 
    0.02113795f, -0.12225691f, 0.23565832f, -0.10051383f, 0.12991108f, 0.08769670f, 0.04706683f, 0.08869382f, 
    -0.03729462f, 0.07249664f, 0.04089487f, 0.07264102f, 0.20534725f, -0.03413886f, 0.09492449f, 0.04260034f, 
    -0.05691323f, -0.03693603f, 0.05156805f, 0.04823439f, -0.06460233f, 0.17607473f, 0.28364971f, 0.01123023f, 
    0.12337732f, 0.12902641f, -0.08868571f, 0.06004016f, 0.02346058f, -0.03932213f, -0.16763882f, 0.12718301f, 
    -0.10018425f, -0.03367270f, -0.21156432f, -0.26902077f, 0.13775048f, -0.00210738f, 0.04548030f, -0.20956197f, 
    0.06770035f, -0.12063028f, -0.08051582f, -0.02113583f, 0.09710582f, 0.15403154f, -0.20821561f, -0.03436531f, 
    0.08756591f, 0.02296133f, 0.11058298f, -0.08539912f, 0.07239592f, 0.08481296f, -0.07388473f, 0.09141211f, 
    0.06828811f, -0.09134659f, 0.05047639f, 0.03848470f, -0.04096700f, 0.06266987f, 0.01080068f, 0.07441416f, 
    0.08170517f, 0.01471457f, -0.07796504f, 0.07818862f, -0.27632871f, 0.01625275f, -0.04251491f, 0.09013849f, 
    0.12599896f, -0.04180022f, -0.19434746f, 0.10634528f, 0.11985967f, -0.00177425f, 0.04748636f, -0.15769833f, 
    -0.10848766f, 0.09201600f, -0.02818882f, 0.10434366f, 0.06148483f, 0.09676120f, 0.05389653f, -0.16560413f, 
    0.03319417f, 0.04216309f, 0.03155901f, 0.01182676f, -0.02453225f, -0.07530104f, 0.02138683f, 0.04516353f, 
    0.16936816f, 0.13392964f, 0.04252852f, -0.04889091f, 0.00391231f, -0.05475891f, 0.18636602f, -0.16243111f, 
    -0.03177828f, -0.01058781f, -0.04462789f, 0.05705056f, 0.00153926f, 0.09995178f, -0.02541436f, 0.04396180f, 
    -0.19358028f, -0.11355712f, 0.30584690f, 0.19111046f, -0.01725378f, -0.02073906f, -0.15765379f, -0.10215796f, 
    -0.04503090f, 0.04404584f, 0.20397584f, -0.00599435f, 0.03999184f, -0.05220480f, 0.00079413f, 0.07535285f, 
    0.10433691f, 0.16026002f, -0.04993695f, 0.01564809f, -0.06449888f, -0.09282532f, 0.02883511f, -0.05056612f, 
    0.04346299f, 0.12723398f, -0.11387274f, -0.12489611f, -0.06847550f, 0.01387620f, 0.09457416f, 0.03969752f, 
    -0.08517598f, 0.02200901f, -0.25819767f, 0.07096096f, 0.03906299f, 0.10517088f, -0.00209710f, 0.00006184f, 
    0.07022217f, -0.04874156f, -0.06347022f, 0.11201816f, 0.00053666f, 0.17242536f, 0.03393108f, -0.18659891f, 
    -0.06034362f, -0.03514932f, 0.05834388f, 0.03181145f, 0.07835288f, 0.18337034f, 0.07727002f, 0.08054820f, 
    0.11770590f, -0.06126942f, -0.03697949f, 0.12655064f, 0.04520433f, 0.04832672f, 0.30511644f, -0.02620204f, 
    -0.10444187f, 0.03752280f, -0.02527268f, -0.08093096f, 0.13370077f, 0.07252815f, 0.07065631f, 0.06261224f, 
    -0.04690227f, 0.02771285f, -0.18857834f, -0.10835743f, -0.08651336f, -0.00099700f, 0.12848853f, -0.00771410f, 
    0.04775729f, 0.10373388f, 0.00256218f, -0.10007136f, 0.16865277f, 0.08250780f, 0.01051711f, 0.02378638f, 
    -0.00072233f, 0.09614599f, -0.01984176f, 0.18712826f, -0.01416105f, -0.02194244f, 0.05975742f, -0.08086745f, 
    -0.10426591f, 0.03825962f, 0.15376993f, -0.01108055f, -0.06804528f, -0.06360106f, -0.11816978f, -0.02420147f, 
    -0.00672255f, 0.16732310f, 0.07520083f, 0.14090373f, -0.10915552f, -0.13515770f, -0.08707466f, -0.20767838f, 
    0.14280726f, -0.19843669f, 0.07120182f, -0.15765104f, 0.03693297f, -0.14240170f, -0.08879726f, 0.24220878f, 
    0.09785220f, -0.14157291f, 0.09092721f, -0.00046713f, 0.06075179f, -0.32372674f, -0.01476918f, -0.02302465f, 
    0.00241969f, 0.00470212f, -0.05200834f, -0.07677393f, 0.07675384f, -0.07843995f, -0.13475744f, 0.05226700f, 
    0.16734329f, -0.17757945f, -0.04368181f, 0.11277971f, -0.00627415f, 0.02392751f, 0.04363092f, 0.15085974f, 
    0.03281422f, -0.13195336f, -0.03855598f, 0.12936230f, -0.08091000f, 0.07601321f, -0.04520166f, -0.00550388f, 
    -0.05542588f, 0.00028917f, -0.49536666f, 0.09952748f, 0.05102829f, 0.02410893f, -0.12624542f, -0.02733246f, 
    0.03761639f, 0.16521835f, 0.01297268f, 0.03881666f, 0.02959252f, 0.14825454f, 0.12063779f, 0.14527482f, 
    0.18941504f, -0.04111407f, -0.05143789f, 0.01740894f, -0.17054713f, 0.18586019f, 0.04653063f, -0.07690258f, 
    0.05054172f, 0.02695566f, 0.17681813f, -0.16710940f, -0.01680633f, -0.08810342f, -0.01436869f, 0.01852393f, 
    -0.12474013f, 0.15380503f, 0.07727277f, -0.10535797f, -0.03136816f, 0.09016269f, -0.31871974f, 0.06596588f, 
    0.07172437f, 0.10153303f, -0.01135386f, -0.08692738f, -0.04721369f, 0.06693653f, 0.09811352f, -0.03287826f, 
    0.01566498f, 0.08004423f, -0.18503116f, 0.01048547f, 0.18763457f, 0.02927953f, -0.24795130f, -0.25953144f, 
    -0.22211784f, 0.05818014f, -0.09399343f, 0.10883841f, -0.01358062f, -0.18381332f, 0.15420695f, -0.08343473f, 
    -0.20437312f, 0.01737026f, -0.07178243f, 0.01049650f, 0.00856130f, -0.11167280f, 0.00833633f, 0.01351081f, 
    0.02750340f, -0.10258724f, 0.22218049f, 0.09602837f, -0.07092021f, 0.04078499f, -0.11101182f, -0.00307244f, 
    -0.01048514f, -0.20565611f, -0.08129346f, -0.08102402f, 0.01699948f, -0.03656410f, -0.10683849f, 0.09788143f, 
    0.18770427f, -0.09421697f, -0.10841770f, 0.04689958f, -0.00422476f, 0.04142116f, 0.05487411f, -0.00230503f, 
    -0.08068025f, -0.03795276f, 0.05055297f, -0.19764893f, -0.01223053f, 0.15081844f, 0.14236556f, -0.09174584f, 
    -0.10646183f, -0.06246097f, -0.09170404f, -0.16343822f, -0.02142718f, -0.09477249f, 0.02153878f, -0.08347569f, 
    -0.01254639f, -0.09069714f, 0.07448076f, -0.03436754f, 0.13019583f, 0.11405705f, -0.05876853f, 0.18217519f, 
    -0.08937366f, -0.06299701f, 0.03952274f, -0.10908435f, 0.05920785f, 0.03843586f, 0.22803251f, 0.15550591f, 
    -0.08006170f, -0.02258145f, 0.11308421f, -0.07982524f, 0.03594556f, -0.01911223f, -0.07048251f, -0.01418313f, 
    -0.04799256f, -0.07565192f, 0.05424362f, 0.07362130f, 0.04730234f, -0.05907252f, 0.16256465f, -0.07838836f, 
    -0.01193619f, -0.17956747f, 0.11929164f, 0.08784602f, -0.02495231f, 0.02635249f, 0.04235499f, 0.05582398f, 
    0.04529230f, -0.31592467f, -0.00357257f, 0.23737185f, 0.11268027f, 0.03323786f, 0.03969625f, -0.12026576f, 
    0.10305715f, 0.05545838f, 0.19041453f, 0.12368789f, 0.06141553f, 0.12549093f, 0.00010028f, 0.00016517f, 
    -0.04944817f, 0.09010503f, 0.09081261f, -0.04871983f, -0.00725266f, 0.23433897f, -0.00509903f, 0.01223190f, 
    0.02765400f, -0.00739887f, 0.02695861f, -0.03443476f, -0.22518881f, -0.04053296f, 0.26661181f, 0.09586684f, 
    0.03161971f, -0.14991079f, -0.02118042f, -0.04766290f, 0.06270400f, -0.05537172f, 0.11848065f, -0.46266073f, 
    0.02611293f, -0.13033891f, -0.00968319f, -0.10838421f, -0.00644856f, 0.13952936f, -0.10238780f, 0.24744010f, 
    -0.22777563f, 0.19264692f, -0.06400549f, -0.01259371f, 0.09412462f, 0.06662689f, 0.11492672f, 0.04254152f, 
    -0.01063321f, 0.00277674f, 0.08451577f, 0.07051536f, -0.12885992f, -0.07084633f, 0.10743967f, -0.11687292f, 
    -0.03280643f, -0.02266469f, 0.03339386f, 0.02116415f, 0.03004381f, -0.04922664f, 0.03469298f, 0.03723050f, 
    -0.01242631f, 0.01295975f, 0.05604234f, -0.01317377f, -0.03836282f, -0.03553622f, 0.02972945f, -0.04205162f, 
    -0.06316824f, -0.05312389f, 0.00060483f, 0.03967180f, -0.00153186f, -0.01856747f, 0.03237690f, -0.04629949f, 
    -0.03401253f, 0.06398408f, -0.00382125f, -0.01941010f, 0.05124578f, -0.01022035f, -0.00456143f, -0.00676149f, 
    -0.02895201f, 0.00608129f, 0.01515896f, -0.01586322f, -0.00219687f, 0.02829069f, 0.04672592f, -0.06062662f, 
    0.04001423f, -0.00769278f, -0.06426911f, -0.03282766f, 0.01787054f, 0.02350439f, 0.04692736f, -0.03546062f, 
    -0.02816165f, -0.04794035f, 0.02369790f, -0.06077181f, -0.03824768f, 0.03451875f, 0.00429095f, 0.00904160f, 
    -0.01260923f, -0.01550914f, -0.03166729f, -0.05260905f, -0.04969450f, -0.00502865f, -0.03372697f, -0.01345517f, 
    -0.04931445f, -0.00859184f, 0.00788554f, 0.03519576f, -0.06461424f, -0.01373434f, 0.04627206f, 0.01574419f, 
    -0.03732323f, -0.05754165f, 0.01343809f, 0.02507191f, -0.05204011f, -0.02791987f, 0.01611684f, -0.02022209f, 
    0.04402914f, -0.01729692f, -0.03200132f, 0.02325745f, -0.03979657f, 0.04061114f, 0.04531261f, 0.01623592f, 
    -0.04952084f, 0.02513492f, 0.01547168f, -0.02952790f, 0.02688450f, -0.02747490f, -0.02487871f, 0.02680222f, 
    -0.04947834f, 0.03196501f, 0.01829595f, 0.04223020f, -0.00814665f, 0.02519181f, -0.03181842f, 0.04125579f, 
    0.02682268f, 0.05065717f, -0.01742614f, 0.00718970f, -0.02122840f, 0.03748005f, -0.04728971f, -0.01384854f, 
    0.01749734f, 0.04116821f, -0.02507350f, -0.05781844f, -0.04420061f, 0.05141313f, -0.02098237f, 0.03032469f, 
    0.05563972f, -0.02157938f, -0.05185381f, -0.06117443f, 0.04509667f, 0.02904041f, 0.04492090f, -0.04679305f, 
    -0.06342831f, -0.01659864f, 0.01560702f, -0.00765930f, 0.02486721f, -0.05357967f, -0.01632098f, -0.03003656f, 
    -0.04661618f, -0.03939562f, -0.00558504f, -0.04996623f, 0.04036197f, 0.01062365f, 0.00786789f, -0.04565866f, 
    -0.01537512f, 0.00511550f, -0.02121373f, -0.00882068f, -0.00733814f, 0.03016324f, -0.04184414f, -0.05172467f, 
    -0.04725194f, -0.03769704f, 0.03139418f, -0.06178974f, 0.00331426f, 0.02948316f, -0.00826812f, -0.01342513f, 
    0.00843891f, -0.04890520f, -0.05153695f, -0.01397015f, -0.02582891f, 0.00513385f, 0.04611113f, 0.01035626f, 
    0.01238509f, 0.04913310f, -0.01202481f, 0.03579741f, -0.03993798f, 0.01860812f, 0.00893516f, -0.01857376f, 
    -0.05324540f, -0.04588759f, 0.03608033f, 0.00746709f, 0.06117684f, -0.05288688f, -0.05176150f, 0.03944198f, 
    -0.05708051f, -0.01270784f, 0.03576853f, 0.01373323f, 0.00305328f, -0.04795191f, -0.03404804f, -0.00153324f, 
    0.04908981f, -0.06171644f, -0.00155616f, 0.01820936f, 0.04677298f, 0.04646875f, -0.01500247f, 0.02360951f, 
    -0.00549910f, 0.00331148f, 0.00829232f, 0.02407870f, -0.05030124f, -0.04536668f, -0.03322492f, 0.01396051f, 
    -0.04557019f, -0.02441107f, -0.05708604f, -0.06465689f, -0.00637124f, -0.01795509f, 0.00571829f, 0.03882730f, 
    0.01166595f, -0.02725595f, 0.05074954f, -0.00894255f, 0.04286602f, -0.02667741f, -0.05423624f, -0.06352698f, 
    -0.04853498f, 0.00638572f, 0.02176421f, -0.06351355f, -0.05136355f, -0.05471259f, 0.00820826f, -0.05496588f, 
    -0.01417354f, -0.06414478f, -0.01553632f, 0.03232292f, -0.00573600f, 0.05243321f, -0.02347058f, 0.03889191f, 
    -0.03824448f, -0.02006481f, 0.00122913f, -0.01650945f, -0.04263677f, 0.02096092f, 0.00436818f, 0.02650865f, 
    0.01563649f, -0.00396866f, -0.04301739f, 0.03066291f, -0.00695561f, 0.02571098f, 0.02288098f, -0.02187251f, 
    0.02134854f, -0.00746235f, -0.00840704f, -0.01685487f, -0.02326177f, -0.03276089f, -0.03995522f, -0.03312159f, 
    -0.05895225f, -0.03607427f, -0.03447358f, 0.02666063f, -0.03012406f, -0.05601220f, -0.00908666f, 0.05003725f, 
    -0.01211073f, -0.05077526f, 0.00300200f, -0.06065078f, -0.01809258f, 0.01867822f, 0.00343869f, -0.04443013f, 
    0.05900742f, 0.02957494f, -0.02664762f, -0.03007399f, 0.02098798f, -0.03968416f, 0.02851795f, -0.02144397f, 
    0.39843431f, -0.18949094f, -0.14988136f, 0.19026616f, 0.22181204f, 0.16163582f, -0.10125277f, 0.08110859f, 
    0.01610653f, -0.13924378f, -0.17141254f, -0.11032864f, 0.05838814f, 0.00916590f, 0.03919084f, -0.05541573f, 
    0.24413899f, -0.07020652f, 0.38619879f, -0.04663122f, 0.07249599f, 0.12221500f, 0.01666244f, -0.03775702f, 
    -0.08098165f, -0.05620563f, -0.08801185f, -0.04480912f, -0.17049395f, -0.36463937f, 0.06528790f, 0.08619458f, 
    0.00531098f, 0.04663188f, -0.09505984f, -0.04526051f, -0.20871568f, -0.02390969f, 0.05121580f, 0.01795731f, 
    -0.26863104f, 0.05763714f, -0.03115062f, -0.07188439f, 0.06320535f, 0.24071714f, 0.11478578f, -0.00323500f, 
    0.02170516f, 0.00435096f, -0.14324254f, -0.08904874f, 0.04616488f, -0.06043977f, 0.75702256f, -0.07094190f, 
    0.33174425f, 0.04694813f, 0.04221676f, 0.01837979f, -0.07796323f, 0.04384731f, -0.10498265f, -0.04126209f, 
    0.06868537f, -0.08269057f, -0.06057426f, 0.00621323f, -0.03574965f, 0.05732553f, -0.11440221f, -0.00670295f, 
    0.00494794f, -0.07292681f, -0.03419686f, -0.00944276f, -0.07646718f, -0.04992348f, 0.08506643f, -0.02676069f, 
    0.08234950f, 0.19928373f, 0.06151772f, 0.05968226f, -0.05041899f, -0.05550699f, -0.07417757f, -0.02489572f, 
    0.10819105f, 0.01516390f, -0.18871973f, -0.20225333f, -0.11239766f, 0.09513241f, 0.07177701f, 0.10568764f, 
    0.19024107f, -0.01623182f, -0.03631716f, -0.13589960f, -0.02507102f, -0.01033743f, 0.07895170f, -0.10101782f, 
    -0.18671134f, -0.02191348f, 0.12777594f, -0.01438831f, 0.17950197f, 0.05670835f, 0.15673234f, -0.20556840f, 
    -0.03424225f, -0.10016534f, -0.02952831f, 0.06010545f, -0.01260996f, -0.11992157f, 0.25868279f, 0.40951869f, 
    -0.16106796f, -0.06461278f, -0.09435765f, -0.02915028f, 0.02460572f, 0.15968306f, -0.19299051f, -0.26685405f, 
    0.03274462f, 0.09956254f, 0.16527364f, 0.06326330f, 0.06554170f, -0.15478523f, -0.01283684f, -0.24126035f, 
    -0.05903975f, -0.27230331f, -0.13889150f, -0.11491733f, -0.15832287f, -0.03615561f, 0.05178508f, 0.06831834f, 
    0.15718667f, -0.07876034f, -0.28486788f, 0.28215724f, 0.00608908f, 0.15541027f, -0.07387087f, -0.10416727f, 
    0.03586733f, 0.11081087f, -0.26316908f, -0.25225672f, -0.12388916f, -0.00068597f, -0.02381510f, -0.05106260f, 
    -0.02096885f, -0.08514872f, 0.19400418f, 0.04203761f, -0.05954597f, -0.04222517f, 0.12182193f, -0.00230505f, 
    0.09279143f, 0.07058165f, -0.07277084f, -0.39106342f, 0.02201799f, -0.19249952f, 0.01441253f, 0.02725981f, 
    -0.03190425f, 0.08898383f, -0.01168086f, -0.02509658f, -0.11902767f, 0.02894036f, -0.08096065f, 0.00451302f, 
    0.06742183f, -0.08971156f, -0.05167688f, -0.05583300f, -0.06257433f, 0.02352342f, 0.06382453f, 0.04455632f, 
    0.19554551f, 0.09102118f, 0.10713197f, -0.12399141f, 0.00402424f, -0.02338599f, 0.00796185f, 0.10664021f, 
    0.06538785f, 0.04573696f, -0.09863077f, 0.04867764f, -0.02772770f, 0.01769232f, -0.05867001f, 0.03539085f, 
    0.06372451f, 0.07376868f, -0.13109545f, -0.15039372f, 0.08864459f, -0.06428277f, 0.10603747f, 0.19065486f, 
    0.23499797f, 0.28143129f, -0.15059701f, 0.18621768f, -0.01744262f, 0.16214122f, -0.13468532f, 0.19144613f, 
    -0.12023426f, 0.10147008f, -0.07242965f, -0.19465376f, 0.09950008f, 0.17340423f, 0.09065975f, 0.01630362f, 
    -0.04233241f, 0.03603015f, -0.15665168f, -0.01692931f, 0.05545099f, -0.03748190f, 0.19712584f, -0.00357189f, 
    -0.03594653f, 0.02033745f, -0.01230210f, -0.06868458f, -0.01789263f, -0.27058426f, 0.16072105f, -0.00943788f, 
    0.07580533f, -0.01653519f, 0.03773712f, 0.03325725f, -0.00526694f, 0.25881779f, -0.11473060f, 0.01221604f, 
    0.01817306f, 0.04772523f, -0.06976895f, 0.13413297f, 0.03214199f, 0.06482939f, -0.03320184f, 0.19683523f, 
    -0.04203553f, 0.11553331f, -0.06006662f, -0.02295883f, 0.12302344f, 0.06306016f, 0.14709099f, 0.09593462f, 
    0.01626315f, -0.17253283f, -0.12728749f, -0.06702795f, -0.06068615f, 0.06933694f, 0.12308188f, 0.05841131f, 
    -0.24417549f, 0.11261282f, 0.01686895f, 0.10849463f, 0.11407383f, 0.00661972f, 0.09043190f, 0.10225460f, 
    -0.03887168f, -0.34415457f, 0.05238197f, 0.06436669f, 0.05122653f, 0.10831457f, 0.17907952f, 0.08627527f, 
    -0.06150722f, 0.02349767f, -0.09657697f, -0.02835028f, -0.03998459f, 0.05391116f, 0.00973953f, 0.01026676f, 
    -0.07171637f, 0.00118936f, -0.00983965f, -0.24452423f, -0.05083574f, 0.03553216f, -0.06113860f, -0.11248647f, 
    0.00630686f, 0.02564357f, 0.03989308f, 0.35846141f, -0.02000689f, -0.07558040f, 0.11552986f, 0.00061500f, 
    -0.01267758f, -0.10043959f, -0.03957645f, -0.17328721f, 0.11601018f, -0.06023679f, 0.02991263f, 0.14576922f, 
    0.05842511f, -0.10299747f, -0.19505028f, 0.06963635f, -0.03831828f, 0.24060501f, -0.07391969f, -0.15515189f, 
    0.11278206f, -0.15357305f, 0.15221547f, -0.02405939f, -0.10437984f, 0.02621469f, -0.42145658f, -0.04051716f, 
    -0.06194080f, 0.09344228f, -0.08424833f, 0.02443314f, -0.09389629f, 0.01395871f, 0.10909204f, -0.30125430f, 
    -0.47331852f, 0.00422378f, 0.07373942f, 0.00358799f, 0.04141993f, 0.12926269f, -0.07548532f, 0.13331190f, 
    0.20589882f, -0.01926010f, -0.12279796f, 0.06461953f, -0.04891849f, 0.19874607f, 0.09861208f, -0.06417399f, 
    0.07286435f, 0.01038154f, -0.00044639f, -0.11339284f, 0.13234507f, -0.00475923f, 0.01923282f, -0.08096638f, 
    -0.19743335f, 0.10270937f, -0.14350720f, 0.05175712f, -0.21718612f, -0.09901775f, -0.13487674f, 0.14481255f, 
    -0.07731508f, 0.06223780f, -0.00053457f, 0.00610353f, 0.09210739f, -0.04920579f, -0.00514874f, -0.01434452f, 
    -0.01037173f, -0.09097995f, -0.07574172f, -0.13580847f, 0.19047238f, 0.10863412f, -0.08058386f, 0.04972854f, 
    0.04527371f, 0.23093101f, 0.10951157f, -0.06269292f, 0.08790623f, 0.14449367f, 0.06677110f, -0.01016032f, 
    0.12956809f, 0.08437256f, -0.13564037f, -0.19685680f, 0.08906198f, 0.23635843f, -0.07683344f, 0.16283265f, 
    -0.42169157f, 0.03447441f, -0.07588328f, 0.05125146f, -0.08058941f, -0.07425039f, -0.10604291f, -0.12555233f, 
    -0.00332929f, -0.11263248f, 0.01706374f, -0.04310651f, -0.07392955f, -0.11279622f, -0.11048538f, -0.05875310f, 
    0.17538330f, 0.06962806f, 0.12584631f, -0.04994661f, 0.11487520f, -0.10079923f, -0.00731752f, 0.03620909f, 
    -0.04194640f, 0.02187108f, -0.06923234f, 0.01911774f, 0.01945975f, 0.08781683f, 0.03882527f, -0.06750199f, 
    0.09837331f, 0.03266272f, -0.15350911f, 0.11960734f, -0.04958736f, 0.03279675f, 0.06512541f, 0.00934018f, 
    0.08364575f, -0.03576034f, -0.05585918f, 0.07128190f, 0.05382104f, -0.08711601f, -0.08200359f, 0.00271602f, 
    0.04443255f, -0.00752530f, 0.09708770f, -0.10110358f, -0.31499487f, 0.08298865f, 0.00568508f, -0.05434628f, 
    0.08981528f, 0.12816435f, -0.04528362f, -0.05480985f, -0.01261088f, -0.24184988f, 0.02319566f, 0.01261097f, 
    0.08555331f, 0.06233259f, -0.10427839f, -0.01062164f, 0.09826144f, -0.02567880f, 0.34805033f, -0.11578824f, 
    0.10559384f, -0.03669399f, 0.07850702f, 0.04630739f, 0.01905991f, -0.06164442f, 0.16682889f, 0.08231224f, 
    -0.11721387f, -0.12285509f, -0.00828029f, 0.01251501f, -0.06436171f, 0.09790389f, 0.08432139f, -0.01045983f, 
    0.00334488f, 0.16676944f, -0.01736616f, 0.08853805f, 0.17125402f, -0.22161885f, -0.00829996f, -0.01367980f, 
    -0.14478819f, 0.01723307f, 0.02193610f, 0.01108064f, 0.13207251f, 0.07221774f, -0.10780185f, 0.09343186f, 
    0.09180466f, -0.06227054f, -0.16624597f, -0.01571340f, -0.05635032f, 0.08931476f, -0.05483926f, -0.06127406f, 
    0.09401660f, 0.13655160f, -0.04990511f, 0.21823251f, 0.03679768f, 0.09698779f, -0.04941741f, -0.00408327f, 
    -0.09263364f, 0.00987204f, -0.07847743f, -0.00702652f, 0.01700375f, 0.25941205f, -0.23569688f, -0.00791061f, 
    -0.05483612f, -0.10029755f, -0.06249749f, 0.08926285f, 0.02389638f, -0.05060189f, -0.08716077f, 0.08137127f, 
    0.10259748f, 0.11077738f, 0.03061293f, 0.04303351f, -0.04384638f, -0.10133617f, 0.27642539f, -0.25023350f, 
    -0.07926945f, -0.01971010f, -0.00250753f, 0.15956891f, 0.01169330f, 0.07390703f, 0.05481665f, -0.12529856f, 
    -0.05492009f, -0.12236077f, 0.09256587f, -0.28371477f, 0.12834693f, -0.01722348f, 0.06753290f, -0.17418495f, 
    -0.33941296f, 0.09589814f, -0.00824502f, 0.05744838f, -0.05562671f, -0.08035600f, -0.11395379f, 0.03626787f, 
    -0.12413519f, 0.01886050f, -0.12950259f, 0.21104637f, -0.05962421f, -0.06069368f, -0.01735923f, -0.02701552f, 
    -0.04862285f, -0.05624406f, 0.21579689f, 0.10761420f, 0.10087785f, 0.01633298f, -0.20661490f, 0.12056567f, 
    0.03070260f, 0.14235713f, 0.03407282f, 0.01467264f, -0.05915775f, -0.08142208f, 0.06291960f, 0.06232003f, 
    -0.01448374f, 0.08108149f, -0.04733564f, 0.06027450f, 0.08137869f, 0.09870893f, -0.05651169f, 0.02573269f, 
    0.08120977f, -0.06139409f, -0.03975829f, 0.03872231f, -0.03878958f, 0.06562196f, -0.04632397f, -0.26131994f, 
    -0.00770657f, 0.00066518f, 0.01458746f, -0.08502632f, 0.07774716f, -0.00245513f, 0.28552890f, 0.15427105f, 
    0.06904131f, -0.15856466f, -0.08814663f, -0.02235730f, -0.10466303f, 0.03206307f, 0.02334198f, 0.11661141f, 
    -0.02274016f, -0.00549842f, -0.01955084f, -0.14450592f, 0.11255138f, 0.07448185f, 0.02341566f, 0.22263014f, 
    -0.04793685f, 0.00494930f, -0.15900482f, 0.05144961f, 0.07367270f, -0.00896107f, -0.14031614f, 0.02046011f, 
    -0.11872370f, -0.24295025f, 0.02445314f, 0.10422278f, 0.05156757f, 0.03129876f, 0.05229135f, -0.23330636f, 
    0.08045876f, -0.01968162f, 0.03015492f, -0.24100263f, -0.22840646f, 0.04139856f, 0.05779956f, 0.06661818f, 
    0.00670755f, 0.04007027f, 0.01256854f, -0.29514259f, -0.16063876f, -0.31999317f, 0.03883577f, 0.06295486f, 
    -0.01311566f, -0.06689461f, -0.02416322f, -0.18992575f, -0.25589782f, 0.00462030f, -0.29600233f, 0.04966383f, 
    0.17487916f, 0.11256734f, -0.16881289f, 0.00587160f, -0.02435425f, 0.05950364f, -0.22113708f, -0.35260057f, 
    0.01283305f, 0.01373046f, -0.05518673f, -0.01956426f, -0.04606587f, 0.06515018f, -0.01500763f, -0.07524462f, 
    -0.18198051f, 0.08597732f, -0.15463836f, 0.03210292f, 0.02632029f, -0.06961246f, -0.02067741f, 0.00320539f, 
    0.06206118f, 0.00134192f, 0.03454074f, -0.05727859f, 0.06615414f, -0.09395447f, 0.03532898f, 0.02102046f, 
    0.14968406f, 0.09811386f, 0.16232128f, -0.08761929f, -0.07349011f, -0.07135950f, 0.03491060f, 0.05325058f, 
    0.05458771f, 0.11564464f, 0.07137080f, -0.04412932f, -0.05007828f, 0.04213075f, -0.04251387f, 0.06396639f, 
    -0.04265397f, 0.24041164f, -0.21943878f, 0.05887045f, 0.04885105f, 0.04994234f, -0.08457414f, 0.09195957f, 
    0.06888033f, -0.05174968f, 0.16427259f, 0.02985837f, 0.00404208f, -0.00801881f, -0.10662729f, -0.04090860f, 
    0.03398004f, -0.11641814f, 0.04314251f, -0.12532805f, 0.13274440f, -0.01335675f, 0.02306637f, -0.10539648f, 
    -0.16949312f, -0.09920574f, 0.04221955f, -0.06852971f, 0.05068451f, 0.25091249f, 0.09216134f, 0.14093481f, 
    -0.10477609f, 0.03812514f, 0.01236714f, 0.03073289f, -0.01858681f, 0.03510166f, -0.04288804f, -0.00596806f, 
    0.12440863f, 0.09683634f, 0.15666175f, 0.02741012f, 0.01743197f, 0.01880218f, 0.11173212f, -0.21328397f, 
    0.12743345f, -0.11067872f, 0.03572299f, -0.17785196f, -0.04913091f, 0.19445120f, -0.05927571f, 0.27310562f, 
    0.08579489f, -0.06427937f, -0.08588642f, 0.08459675f, 0.03416871f, 0.08480861f, 0.15541264f, 0.07553662f, 
    0.02142842f, -0.07953893f, 0.11115757f, 0.23799211f, -0.00782437f, 0.07611452f, -0.15521935f, -0.05316656f, 
    0.05028138f, -0.01481590f, 0.26836652f, 0.16565479f, 0.17277758f, 0.04856753f, 0.09830864f, 0.03169623f, 
    0.05432903f, 0.09807295f, 0.03552468f, 0.13261196f, 0.07000200f, 0.19423328f, -0.04518717f, 0.02121687f, 
    -0.06433411f, 0.04113970f, 0.08464894f, -0.05248868f, 0.41332045f, -0.08282802f, -0.03620214f, -0.01054278f, 
    -0.06416647f, 0.03775429f, -0.03054871f, 0.02679848f, 0.17023228f, -0.16495417f, -0.23943357f, -0.31454962f, 
    0.04633777f, 0.08215825f, 0.03624046f, -0.05350938f, 0.02703112f, -0.16129002f, -0.09958998f, 0.08724641f, 
    -0.18839644f, 0.05888079f, 0.09106486f, 0.06443346f, -0.00649991f, -0.08991639f, 0.01421584f, -0.13437478f, 
    0.02935995f, 0.11727949f, -0.01139182f, 0.04554172f, 0.00688476f, 0.02417129f, 0.15163817f, -0.12580983f, 
    0.01466836f, 0.02399662f, -0.03119351f, -0.06397421f, -0.07401644f, 0.01172176f, -0.00275358f, -0.04981951f, 
    -0.01311591f, -0.07468064f, -0.05004535f, -0.04627716f, -0.05637832f, -0.00722408f, 0.00054435f, 0.01825669f, 
    -0.05889142f, -0.00483072f, 0.01142670f, 0.01447127f, -0.00397428f, -0.07843459f, -0.06491211f, -0.01228912f, 
    -0.04084226f, -0.05723293f, 0.01406055f, -0.03155215f, -0.07823977f, -0.07398571f, -0.02897064f, -0.07404345f, 
    -0.05301753f, -0.02262921f, -0.06686576f, -0.05345402f, -0.03535677f, 0.00264423f, -0.08361621f, -0.00224312f, 
    -0.07766700f, -0.05315173f, -0.03265788f, -0.09206928f, 0.02145412f, -0.02416970f, -0.03809872f, -0.07540213f, 
    0.02415849f, 0.00982262f, 0.02674964f, -0.07648235f, -0.03963427f, 0.02455037f, -0.07508799f, 0.02273545f, 
    -0.03080274f, -0.02199069f, 0.01226467f, 0.00622295f, -0.03081832f, 0.00366395f, 0.00628187f, 0.00642193f, 
    0.02232575f, 0.00798397f, -0.02884933f, -0.01408565f, 0.01294731f, -0.00893416f, 0.00827599f, -0.05864555f, 
    -0.05508359f, -0.07748521f, -0.07895232f, 0.01770065f, -0.01078871f, -0.08009555f, 0.01790931f, 0.00847463f, 
    -0.02542326f, 0.00915445f, -0.02554844f, 0.02822395f, -0.03530934f, -0.05451847f, 0.00860550f, -0.02922158f, 
    -0.03492932f, 0.01571267f, 0.01978313f, 0.01017971f, -0.08114036f, -0.04600648f, -0.02967463f, -0.07535999f, 
    -0.02458308f, -0.07630280f, 0.00050146f, -0.02551514f, -0.05220166f, -0.00211590f, -0.02828898f, -0.03991942f, 
    -0.05434353f, -0.06096803f, 0.01272336f, -0.05790321f, -0.02354635f, -0.05041675f, -0.06310321f, 0.02156099f, 
    0.01905306f, -0.04401837f, -0.05397116f, 0.02077785f, -0.00763409f, 0.00083727f, -0.00376386f, -0.03185460f, 
    -0.01014724f, -0.06844572f, -0.01113650f, -0.03200145f, -0.07416601f, -0.08052465f, -0.06574898f, 0.00913513f, 
    -0.06229828f, -0.00995452f, -0.00484628f, -0.04084015f, -0.04263990f, -0.04680311f, -0.07332692f, -0.05759422f, 
    -0.06032211f, -0.06052712f, -0.03298781f, -0.09032211f, -0.00069848f, -0.07366329f, -0.04085912f, -0.06789022f, 
    -0.03444309f, -0.08992479f, 0.00449903f, 0.00367999f, -0.01938443f, -0.08253620f, -0.02968451f, -0.07140763f, 
    -0.04311616f, -0.04415907f, 0.00832380f, -0.03196368f, -0.04932062f, -0.03378110f, -0.07904951f, -0.02690183f, 
    0.03235968f, -0.04545665f, 0.03107421f, -0.03651091f, -0.01483306f, -0.01503664f, -0.03850617f, 0.03398516f, 
    -0.05077633f, -0.06230879f, 0.00115397f, -0.00344368f, -0.00163821f, -0.02486987f, 0.00920240f, -0.02264620f, 
    -0.08848269f, 0.02225442f, 0.00013268f, -0.04764233f, -0.01423480f, -0.08413706f, -0.07836200f, -0.08535539f, 
    0.01254369f, -0.04164233f, 0.01981660f, 0.02335577f, -0.00804490f, -0.05069783f, -0.06008487f, -0.03830381f, 
    -0.05896143f, -0.08298930f, -0.03912707f, -0.06244459f, -0.06403945f, -0.07412860f, -0.00114753f, -0.04934538f, 
    -0.06261493f, -0.05794240f, -0.03418171f, -0.08476251f, 0.01688949f, -0.09663931f, -0.05265164f, 0.01925303f, 
    -0.05825579f, -0.07852404f, -0.07617884f, 0.01727210f, -0.03964942f, -0.08006564f, -0.05600429f, -0.01247852f, 
    -0.07000253f, -0.08175892f, -0.04085307f, 0.00011389f, 0.02070586f, 0.00772887f, -0.02490246f, -0.03584242f, 
    -0.02781007f, 0.00812022f, -0.07976049f, -0.09439071f, -0.03193054f, -0.00465088f, 0.01264321f, -0.06352308f, 
    0.01384301f, -0.03034402f, -0.02634245f, -0.06865121f, 0.00926993f, 0.02671730f, -0.03598454f, -0.02315181f, 
    -0.05448620f, -0.04516031f, 0.01910646f, -0.08546884f, 0.00517759f, -0.05173749f, -0.03069137f, -0.03629110f, 
    -0.07109708f, -0.01504262f, -0.01954676f, -0.00201010f, 0.00266813f, -0.01467750f, 0.02493480f, -0.01225663f, 
    0.00918744f, 0.01235569f, 0.00728134f, -0.01779854f, -0.02535119f, 0.00185508f, -0.02429220f, -0.06075088f, 
    -0.02175566f, -0.06922116f, 0.01252138f, -0.00116755f, -0.01616064f, 0.01706830f, -0.04024268f, -0.06589311f, 
    0.01807997f, -0.01524222f, -0.06768625f, -0.05754476f, -0.03496924f, 0.01926906f, 0.00091960f, -0.04213639f, 
    -0.08278377f, -0.04464737f, -0.02653908f, -0.02536793f, -0.03974275f, -0.07223129f, -0.01716023f, -0.02743592f, 
    -0.10197368f, -0.07256925f, -0.06801948f, 0.18127595f, -0.16376582f, -0.26458013f, -0.16222747f, 0.07523226f, 
    -0.14779431f, 0.24627845f, -0.29477987f, 0.08007671f, 0.03247347f, -0.03672716f, -0.04660803f, 0.04327993f, 
    0.02344921f, -0.00531657f, 0.02329830f, -0.07226935f, 0.08261169f, -0.04681464f, 0.10747094f, -0.05098623f, 
    0.09594543f, 0.14959916f, 0.09863378f, 0.01826308f, -0.22431715f, 0.18878160f, -0.06034970f, -0.08981551f, 
    0.00003674f, 0.13527593f, 0.08395708f, 0.06144801f, -0.09552947f, -0.10440093f, 0.10649861f, -0.04615435f, 
    0.00718170f, 0.06241490f, 0.12486012f, -0.17314650f, 0.03432602f, -0.05256242f, -0.09558435f, 0.01527323f, 
    0.14440282f, 0.01111504f, 0.05849433f, -0.01998872f, 0.07293701f, -0.03710454f, 0.14213295f, 0.02831543f, 
    -0.08314204f, 0.05350694f, -0.09539469f, 0.02533603f, -0.01169762f, 0.10131198f, 0.07989268f, -0.18635066f, 
    -0.04703799f, 0.14011163f, 0.06067818f, -0.15219389f, 0.19416286f, -0.21371716f, -0.04017987f, -0.06332237f, 
    0.06368095f, 0.04184573f, 0.10238518f, -0.13323542f, 0.00537885f, 0.08436483f, -0.03929755f, 0.00087306f, 
    -0.34074339f, 0.02408472f, -0.05707351f, 0.13897780f, 0.20464534f, -0.32936898f, 0.11414294f, -0.05237700f, 
    0.01034974f, -0.00936831f, 0.11520105f, -0.08354238f, -0.11379413f, -0.00908935f, 0.03041567f, -0.05077156f, 
    0.03834164f, -0.04987458f, 0.18914908f, 0.00926915f, 0.01095593f, 0.03827132f, 0.06090586f, 0.03737646f, 
    0.05071841f, 0.10123907f, 0.07223689f, 0.07545098f, 0.07988006f, -0.13814701f, -0.09099944f, 0.16261172f, 
    0.05685808f, 0.00010923f, 0.11168742f, -0.07308705f, -0.07129633f, -0.11314002f, -0.24317019f, -0.05389324f, 
    0.14372173f, 0.04102023f, 0.04961111f, 0.05835060f, -0.07047497f, -0.14088050f, 0.12186025f, -0.11135930f, 
    0.00719821f, 0.07182450f, -0.21103819f, -0.10562754f, 0.09850974f, -0.11345348f, 0.06154609f, -0.12821583f, 
    0.19811513f, 0.03366880f, 0.01646492f, -0.04380944f, -0.06681881f, 0.09419350f, 0.03287294f, -0.00117417f, 
    0.03228830f, -0.26359233f, -0.00293449f, -0.12126080f, 0.02721597f, -0.08878367f, 0.14431757f, 0.00501433f, 
    0.17537472f, -0.00115405f, 0.04171774f, 0.05824407f, 0.06762638f, 0.00556421f, 0.13652156f, 0.14716251f, 
    0.03454247f, 0.04521044f, -0.13269244f, 0.00359651f, -0.01123250f, 0.03390175f, 0.15472268f, 0.12821433f, 
    0.01500587f, -0.00518843f, -0.06583411f, 0.13876615f, -0.07921304f, 0.21258287f, 0.04056794f, -0.04482951f, 
    0.06011539f, 0.15669276f, -0.01966172f, 0.06064771f, 0.26942673f, 0.11750914f, 0.02685727f, -0.04603717f, 
    -0.05235299f, -0.14121708f, 0.02300111f, -0.06054470f, -0.12334169f, 0.18225998f, -0.03549205f, -0.04143916f, 
    -0.18156961f, 0.03322897f, -0.13430966f, 0.01260282f, 0.00886149f, -0.00551316f, -0.15302217f, -0.26251492f, 
    0.16143884f, -0.07822864f, 0.13441730f, 0.15936397f, -0.07563269f, -0.02127983f, -0.07774895f, -0.25643075f, 
    0.06520984f, 0.06609406f, 0.06337234f, 0.00221405f, -0.11467785f, 0.07151212f, -0.21109681f, 0.01229421f, 
    0.16114621f, -0.04051993f, -0.07907227f, -0.31068355f, 0.14341946f, -0.04548527f, 0.02822304f, -0.06393622f, 
    -0.04173528f, 0.06660395f, -0.20676972f, 0.09946608f, -0.09788875f, 0.04436452f, -0.06043704f, -0.14714569f, 
    -0.12525792f, 0.01605323f, -0.00457896f, -0.00920682f, -0.02476566f, -0.11292759f, -0.07318334f, -0.09941918f, 
    0.17888969f, 0.03248893f, -0.03298361f, 0.07000391f, -0.06066912f, 0.06282497f, 0.04929346f, -0.03181336f, 
    0.04934563f, 0.13282681f, -0.03716131f, 0.07533629f, -0.03562388f, -0.22929636f, 0.23270044f, -0.04863818f, 
    0.10737377f, -0.01278030f, -0.01374122f, -0.12098182f, 0.08497149f, 0.12601279f, -0.15929204f, -0.10238045f, 
    0.11644360f, 0.14179263f, -0.03138390f, 0.04550087f, -0.03982738f, 0.09898688f, -0.04676400f, -0.03670860f, 
    0.12150726f, 0.09342967f, 0.08702330f, -0.07724965f, 0.02762830f, -0.02224501f, -0.03516330f, -0.01442400f, 
    -0.17249629f, 0.21053109f, -0.02390121f, -0.03251839f, 0.03718152f, -0.11354204f, 0.04556728f, 0.05232606f, 
    0.22303843f, 0.06674349f, -0.23108171f, 0.10433351f, 0.17891933f, -0.04302968f, -0.11940429f, 0.12709790f, 
    0.18816526f, -0.09690078f, 0.08214262f, 0.03030664f, -0.23044397f, -0.03452369f, -0.02767815f, 0.12423774f, 
    0.02837654f, -0.00657701f, -0.13641010f, 0.09545243f, -0.04198191f, 0.08444009f, 0.04319187f, -0.00429945f, 
    0.00335067f, 0.12768896f, 0.05618561f, -0.03656141f, -0.12418750f, 0.18075657f, -0.00783378f, -0.08082862f, 
    0.01184256f, -0.04602274f, 0.09272828f, -0.14007023f, -0.20475836f, 0.04227993f, 0.14491309f, -0.00443311f, 
    -0.00954491f, -0.04929795f, -0.11176954f, -0.04151601f, 0.07151262f, -0.04268505f, -0.37716427f, -0.26933834f, 
    -0.05638160f, -0.01100633f, 0.13125461f, 0.05797121f, 0.13828456f, -0.10341852f, -0.18564712f, 0.10909916f, 
    0.06815034f, 0.02622989f, -0.03390996f, 0.01648889f, -0.00215320f, -0.05896881f, 0.13660137f, -0.35645768f, 
    0.17294349f, 0.05347521f, 0.04276275f, 0.03309771f, -0.05663351f, 0.00438154f, -0.04608825f, 0.12710485f, 
    -0.17684872f, -0.17851202f, 0.02061176f, -0.04185361f, 0.09020700f, 0.08888080f, -0.07889055f, 0.00890009f, 
    -0.10723829f, -0.05429826f, -0.26197934f, 0.02169093f, -0.03759076f, -0.11102969f, -0.04460990f, 0.05232577f, 
    -0.11781363f, 0.05838684f, -0.11527470f, 0.38485605f, 0.25912353f, 0.03840736f, -0.03228431f, -0.09518161f, 
    -0.05768311f, -0.08436462f, -0.02502603f, 0.07449944f, -0.04950021f, 0.12400818f, -0.03148235f, 0.10663415f, 
    0.10895189f, -0.01943871f, -0.01705632f, -0.06499643f, -0.11310470f, -0.21791722f, 0.06935411f, -0.00345559f, 
    0.06501242f, 0.10676984f, 0.05016401f, -0.01186296f, 0.02061708f, 0.23425911f, -0.11278813f, -0.07959069f, 
    -0.17879176f, -0.00732280f, -0.04341204f, -0.17376438f, 0.21018508f, -0.22838528f, -0.08485988f, 0.17137744f, 
    0.27674478f, -0.00884001f, 0.01507174f, -0.05207635f, 0.01116443f, -0.07344349f, -0.14865534f, 0.04000984f, 
    -0.06773879f, -0.03309358f, 0.13782716f, -0.11934335f, 0.01470784f, 0.13827166f, -0.10415599f, 0.13521443f, 
    0.11565863f, 0.04836646f, -0.06699741f, 0.02632586f, 0.13664350f, 0.11654718f, 0.07930312f, 0.10255789f, 
    0.07765654f, -0.05351939f, 0.24266687f, -0.13909984f, 0.04227747f, -0.07358157f, 0.14387137f, 0.06718025f, 
    -0.05275895f, -0.03024073f, -0.00223563f, -0.23011163f, -0.16819021f, -0.03280236f, 0.08537487f, 0.09655847f, 
    -0.05303335f, 0.10204683f, 0.04980076f, 0.02738437f, 0.07942333f, -0.07108279f, 0.01901012f, -0.15698193f, 
    -0.09466550f, 0.03592235f, 0.09087300f, -0.04429401f, -0.09616644f, 0.02844282f, -0.00356081f, -0.15976368f, 
    0.02004036f, 0.03941493f, -0.08650143f, -0.06615176f, 0.14461827f, 0.19605644f, 0.09616736f, -0.07492527f, 
    0.10571807f, -0.07977310f, -0.02776382f, 0.03979557f, 0.14923391f, 0.08195768f, -0.25659391f, -0.31673032f, 
    -0.16381858f, 0.08526906f, 0.07903317f, 0.13279065f, -0.00827893f, 0.01951473f, 0.12444486f, 0.05342871f, 
    -0.32637614f, -0.11699389f, -0.02194059f, 0.11318453f, 0.04617012f, -0.03216979f, 0.01585937f, 0.06289094f, 
    0.01330201f, 0.09323984f, -0.06804116f, 0.09453984f, -0.03093426f, 0.09310946f, -0.03886306f, 0.06354683f, 
    -0.10087274f, 0.09252255f, 0.06537583f, -0.14046004f, 0.09588400f, -0.03368970f, -0.00003475f, -0.02158163f, 
    0.12728566f, 0.07613292f, -0.27681509f, 0.00097635f, -0.01394300f, 0.05709098f, -0.04207454f, 0.02430039f, 
    -0.04125196f, -0.03326944f, -0.00237491f, 0.09429745f, 0.03368549f, -0.07204183f, 0.02621222f, 0.07786357f, 
    -0.01791230f, -0.05775950f, 0.14959030f, 0.06947912f, -0.17320107f, 0.11061420f, -0.07291050f, -0.01102160f, 
    -0.08289783f, 0.01964822f, 0.01861524f, 0.09404777f, -0.06157672f, 0.41442177f, 0.00686398f, 0.06421226f, 
    0.01935779f, -0.01646255f, 0.03769850f, 0.05425487f, 0.14898692f, -0.03734453f, 0.10942577f, -0.30137330f, 
    0.03429164f, 0.06466006f, 0.00602488f, 0.09292812f, 0.02772474f, 0.01454609f, -0.03293006f, 0.29171303f, 
    -0.03932195f, -0.23871981f, -0.03784476f, -0.04319408f, -0.02281105f, 0.00253910f, 0.14441350f, -0.03707153f, 
    -0.06653839f, -0.01879120f, -0.02884548f, -0.03002600f, 0.03706420f, -0.05998464f, 0.04214101f, 0.02310231f, 
    0.02461210f, -0.05676378f, -0.03670994f, 0.01177670f, -0.04522509f, 0.01304379f, -0.00471540f, -0.05161844f, 
    0.01869347f, 0.02890943f, -0.05186319f, 0.05001798f, -0.02673405f, -0.01150322f, 0.00100678f, -0.05041436f, 
    -0.00313013f, -0.00940049f, 0.03341519f, -0.01957418f, -0.03257188f, -0.05232092f, -0.01397349f, 0.01123174f, 
    0.04139379f, 0.04743398f, -0.06528927f, -0.04109709f, 0.01156892f, -0.05996520f, -0.01689743f, -0.00041687f, 
    0.01464359f, -0.05388064f, 0.02186642f, -0.05228151f, 0.04295642f, 0.04093921f, -0.04964992f, -0.00309126f, 
    0.01784750f, 0.00983141f, -0.06772070f, -0.05302398f, 0.01652702f, -0.03199187f, -0.03783112f, 0.04067220f, 
    0.00084885f, 0.03687213f, -0.00229625f, -0.01643815f, -0.02841870f, -0.05936717f, 0.03945809f, 0.03804378f, 
    0.01245036f, -0.05039160f, 0.02017228f, 0.04985180f, -0.00831258f, -0.00099396f, -0.04372505f, 0.05926421f, 
    0.04097948f, -0.05040709f, 0.04690870f, -0.03134459f, 0.03334318f, -0.02756133f, -0.01361999f, -0.05210116f, 
    -0.03880901f, -0.01750696f, 0.01262498f, -0.01147203f, 0.00916696f, -0.04861130f, -0.01908126f, 0.04095178f, 
    -0.03355169f, -0.03777051f, -0.02397919f, 0.01243727f, -0.06506962f, -0.00073467f, 0.00913666f, -0.01888339f, 
    -0.00299282f, 0.01758200f, -0.04583744f, -0.06123348f, 0.01085505f, -0.03667956f, 0.01883189f, 0.01854585f, 
    -0.05746841f, -0.05979514f, 0.01804084f, -0.00176788f, 0.00872008f, 0.01560318f, 0.02492927f, -0.00142228f, 
    0.01566004f, -0.01797086f, 0.04559619f, -0.02947372f, -0.00857528f, -0.03736082f, -0.03683099f, 0.04573349f, 
    -0.02541707f, 0.04861997f, 0.01182966f, -0.04772244f, -0.01730412f, 0.05061764f, -0.03612812f, 0.02794601f, 
    -0.04656178f, -0.04981890f, -0.02889286f, 0.03108955f, 0.00108291f, 0.03365365f, -0.02817528f, 0.05379849f, 
    -0.06452439f, -0.06821554f, 0.01942713f, -0.06241560f, 0.03217285f, 0.05293422f, -0.05003154f, -0.01615221f, 
    -0.05578456f, -0.05358436f, -0.00234414f, -0.04358988f, 0.03902404f, -0.03249013f, 0.04400700f, -0.05789861f, 
    0.03944127f, -0.01061144f, -0.02273687f, 0.01096484f, 0.03077058f, -0.03889591f, 0.00702144f, -0.05152705f, 
    -0.01015833f, -0.00212151f, -0.02197264f, 0.05055691f, -0.06756078f, 0.04955087f, 0.03399390f, -0.02686979f, 
    0.01980640f, -0.00718159f, -0.03314296f, 0.00956367f, -0.03170103f, -0.03779081f, -0.02514436f, -0.04077645f, 
    0.03469905f, -0.01689359f, 0.03543291f, -0.01617314f, -0.01627600f, 0.00847409f, -0.01035084f, 0.02387810f, 
    -0.03417037f, 0.02003013f, 0.02303511f, 0.03731255f, -0.04206195f, -0.00896929f, 0.02173597f, 0.03999878f, 
    0.01826838f, 0.03028248f, -0.01099101f, 0.01444804f, 0.03814101f, -0.01617740f, -0.02734416f, -0.03398882f, 
    -0.02457496f, -0.01777322f, -0.03780445f, 0.03797099f, -0.04486541f, -0.03269155f, -0.03074861f, 0.04755456f, 
    0.03545050f, -0.05270462f, -0.06701998f, 0.00642586f, 0.02914060f, 0.00028078f, 0.00008990f, 0.04197815f, 
    0.01533944f, -0.04185735f, -0.04410321f, -0.00201986f, -0.05873474f, 0.01277961f, -0.05110088f, -0.00270117f, 
    0.04868609f, 0.02113139f, 0.03747226f, -0.04450272f, -0.05228384f, -0.00944263f, 0.02452956f, -0.00888425f, 
    -0.01586649f, 0.05252448f, -0.04590930f, -0.01920580f, -0.04473953f, -0.00380634f, -0.02085177f, 0.02318749f, 
    0.02343566f, -0.03063230f, 0.02912067f, 0.02473132f, -0.01291555f, -0.06406046f, -0.03301425f, 0.03964147f, 
    -0.05021081f, 0.05349116f, -0.01376107f, -0.04670408f, -0.03546666f, -0.05650927f, -0.05405208f, -0.00799544f, 
    -0.02996079f, 0.02604686f, -0.03171498f, -0.05959566f, 0.02848093f, -0.00066862f, -0.03814748f, 0.02100640f, 
    -0.03982947f, 0.04888337f, 0.02991871f, -0.01063183f, 0.00478978f, 0.04365173f, -0.03483625f, 0.04874098f, 
    0.02897111f, 0.00068480f, -0.01810008f, -0.01146974f, -0.00361256f, 0.00954079f, 0.05992169f, -0.04712779f, 
    -0.01862954f, -0.02944321f, -0.01826787f, -0.01615577f, -0.03829343f, -0.02159766f, -0.03717224f, 0.00404844f, 
    -0.21476425f, -0.16225635f, 0.06386669f, 0.07093511f, 0.02825365f, 0.11443899f, 0.22791153f, 0.14846201f, 
    -0.12653929f, 0.17288177f, 0.15323396f, -0.01408022f, -0.07052267f, -0.00183796f, 0.06859766f, 0.20668828f, 
    0.05477051f, 0.12962858f, 0.05833070f, -0.11110356f, -0.03525469f, 0.06292149f, -0.00501247f, -0.06529842f, 
    0.10256273f, -0.05293648f, 0.02247106f, -0.08853681f, -0.17554912f, -0.13302439f, -0.07356260f, 0.06257132f, 
    -0.02857444f, 0.19351374f, -0.00939007f, -0.27428412f, -0.10644918f, -0.05225843f, -0.03435336f, 0.13777527f, 
    0.10748710f, -0.08709216f, 0.05147338f, 0.07734068f, -0.02971515f, 0.09561513f, -0.03036152f, -0.36959261f, 
    0.20260301f, 0.02091806f, 0.01629201f, -0.10246494f, -0.22663160f, -0.03375838f, -0.08392209f, -0.09409707f, 
    0.00701292f, 0.06362828f, 0.10472168f, -0.14197071f, 0.12534790f, -0.06282546f, -0.02192254f, -0.57813567f, 
    -0.48912501f, -0.12316769f, -0.06914400f, -0.02647346f, -0.09886614f, -0.00170771f, -0.12526478f, 0.00312924f, 
    -0.34483373f, -0.04341242f, -0.18691054f, 0.12873639f, 0.00839780f, 0.03563541f, -0.00442481f, -0.07127592f, 
    0.09164368f, -0.17371087f, 0.02879334f, 0.13014597f, -0.00910968f, 0.11119514f, 0.00371327f, -0.06947298f, 
    -0.02641053f, -0.13065498f, 0.09286559f, 0.04521096f, 0.06574159f, -0.06732690f, -0.09745811f, -0.02691487f, 
    -0.23826140f, -0.02325284f, -0.08368158f, 0.09572126f, 0.05145269f, 0.00416731f, 0.19647507f, -0.00614651f, 
    0.11357803f, 0.12610343f, -0.03877551f, -0.00261259f, -0.16417849f, 0.08519717f, -0.10538083f, 0.03916467f, 
    0.05993536f, 0.07345453f, -0.03556887f, 0.07746179f, 0.09492287f, -0.18924369f, -0.01638864f, 0.00907732f, 
    -0.16611624f, 0.16668122f, 0.07606944f, 0.00070177f, 0.13253281f, 0.01065435f, -0.19582261f, -0.04242251f, 
    0.05501414f, -0.11943656f, -0.01535782f, 0.16066603f, 0.03377338f, 0.01046933f, 0.09662774f, 0.02484262f, 
    -0.23529869f, -0.10924897f, -0.05055724f, -0.03170059f, -0.24126410f, 0.10075237f, 0.22404642f, 0.03197796f, 
    0.27413964f, 0.08349783f, 0.17796905f, -0.14098860f, -0.04837177f, 0.01200725f, -0.01488109f, 0.08908682f, 
    0.05893907f, -0.08079636f, -0.12611948f, -0.00381987f, 0.13733084f, 0.04834941f, -0.02717304f, -0.03946289f, 
    0.11181692f, -0.07556466f, -0.41783392f, 0.00344368f, 0.06994002f, 0.01150110f, 0.08983656f, -0.07545719f, 
    -0.01854173f, -0.04656861f, 0.00560555f, 0.15727086f, -0.06598586f, -0.05733828f, 0.05861836f, -0.03838106f, 
    0.08097229f, 0.00545465f, 0.04139563f, 0.01222302f, 0.00512390f, 0.10644322f, -0.08922549f, -0.05021402f, 
    -0.13344938f, 0.03384579f, -0.02737236f, -0.07721070f, 0.07206365f, 0.13870186f, 0.07104754f, 0.15113704f, 
    0.05380304f, -0.03734859f, -0.11027939f, 0.02624884f, -0.03595939f, 0.07867277f, -0.23034728f, -0.30560440f, 
    -0.13154817f, 0.03788402f, -0.07150595f, 0.07458156f, 0.09030712f, -0.02207669f, 0.06788699f, -0.16826102f, 
    -0.12052104f, -0.01001901f, 0.11898726f, 0.02941250f, -0.09847605f, 0.07454360f, 0.08868337f, 0.04448039f, 
    0.06268679f, 0.04277939f, 0.00286390f, -0.20798805f, -0.04376078f, -0.07424404f, -0.12062396f, 0.05796347f, 
    0.00740063f, 0.04230576f, 0.10631568f, -0.05466814f, -0.00706967f, -0.07852127f, -0.01793285f, 0.14675750f, 
    0.08266168f, -0.03723988f, -0.03920575f, -0.07245865f, -0.10573387f, 0.03079944f, 0.02310092f, -0.20024753f, 
    -0.02715104f, 0.06155335f, 0.04310893f, 0.23902313f, 0.12814413f, 0.18838102f, -0.09668078f, -0.07750949f, 
    -0.10141899f, 0.19285551f, 0.04074223f, -0.01720263f, -0.04043918f, 0.02354523f, -0.10461727f, 0.04786417f, 
    -0.03899121f, -0.02273512f, -0.02812632f, -0.03722251f, 0.02829316f, 0.17200951f, 0.01219255f, 0.15623523f, 
    0.09576307f, -0.08945020f, -0.02873718f, -0.04637035f, 0.06245115f, -0.04552726f, 0.17850253f, 0.14865707f, 
    -0.10655810f, 0.06674959f, -0.00687671f, 0.19675140f, -0.10391563f, -0.08611562f, -0.02457376f, 0.09266433f, 
    -0.11138078f, -0.08303124f, 0.00649840f, 0.03318933f, 0.14524248f, 0.16830523f, 0.08249899f, -0.15480457f, 
    -0.33577776f, 0.05988513f, 0.06218747f, 0.09584684f, 0.07182613f, 0.16090262f, -0.02127014f, -0.07775212f, 
    -0.16497244f, -0.27019903f, -0.15370890f, -0.04328303f, 0.16929305f, -0.01185091f, -0.01035311f, -0.07352452f, 
    -0.15801235f, -0.03066904f, -0.35137042f, -0.19426522f, -0.06742832f, 0.01847641f, 0.08489189f, -0.06966633f, 
    -0.09395479f, 0.03946869f, -0.03710369f, -0.14338207f, -0.32434261f, -0.30809146f, 0.11817496f, 0.03764405f, 
    0.03049351f, 0.07587580f, 0.04108173f, -0.01199172f, -0.12934756f, 0.00743312f, 0.21720131f, -0.04683856f, 
    0.09842341f, -0.13382006f, -0.10843851f, -0.14017768f, 0.04739224f, 0.49324462f, 0.01520108f, 0.09061208f, 
    0.20757820f, 0.01981646f, 0.07775722f, -0.12640616f, 0.08166613f, 0.01547788f, -0.48377666f, -0.36358014f, 
    -0.16251351f, -0.01812748f, -0.00976514f, 0.01384140f, -0.03982927f, -0.01108989f, 0.01348446f, 0.34968734f, 
    0.00900158f, 0.27420872f, 0.14997754f, 0.04546920f, 0.06157285f, -0.00859842f, 0.12855598f, -0.07145992f, 
    0.29475138f, 0.37792212f, -0.03042282f, -0.03235706f, 0.05747478f, 0.07491652f, 0.02792693f, -0.00434662f, 
    0.05127244f, 0.05093731f, 0.15933062f, 0.02551497f, 0.00452335f, 0.08908067f, 0.00720917f, 0.07674836f, 
    0.02788315f, 0.06118529f, -0.00681449f, -0.01755065f, -0.16684030f, 0.02531409f, 0.07779744f, -0.04806555f, 
    0.06124800f, 0.06295407f, -0.05936547f, -0.02162226f, 0.00358896f, 0.00162572f, -0.08523444f, 0.04421913f, 
    0.08800893f, 0.11376318f, -0.01961849f, 0.04701612f, 0.41961172f, 0.21230429f, 0.06922375f, 0.00034509f, 
    0.00203468f, 0.12604290f, 0.07823089f, -0.10946356f, 0.04276522f, 0.17446518f, -0.07644845f, 0.55249625f, 
    -0.05594980f, -0.12421772f, -0.15843789f, -0.01481692f, -0.03033126f, -0.00320136f, 0.01770218f, 0.08832861f, 
    -0.23791075f, -0.05175030f, 0.02887650f, -0.09415621f, -0.04972976f, -0.11537496f, -0.01694810f, 0.19558501f, 
    -0.05310431f, 0.12806079f, 0.02642999f, 0.00987886f, 0.06771854f, -0.06795639f, 0.21195392f, -0.04249664f, 
    -0.15945838f, -0.06754786f, -0.05426333f, -0.11256152f, 0.00178717f, -0.06655957f, 0.04705361f, -0.04617322f, 
    0.03033759f, -0.14234486f, -0.13562521f, 0.12430298f, -0.00574294f, 0.11615447f, -0.08405638f, -0.10074653f, 
    0.21908639f, 0.01701703f, 0.18029442f, 0.06575431f, -0.01814327f, 0.03623745f, 0.04650095f, 0.10158554f, 
    0.09455772f, 0.01260387f, 0.12054703f, -0.04734775f, 0.19665506f, -0.26247206f, 0.12181145f, -0.11933769f, 
    0.00012007f, 0.09563172f, -0.01751290f, -0.02919201f, -0.34785911f, -0.10997764f, -0.13339664f, -0.02091135f, 
    0.03854837f, -0.07180841f, 0.23550063f, 0.00128068f, -0.00136144f, -0.34354031f, -0.29165292f, -0.27830940f, 
    0.10970335f, 0.02890418f, -0.00875754f, -0.06209713f, -0.02440758f, 0.04335352f, 0.44719175f, 0.15996398f, 
    0.00056962f, -0.01960224f, -0.02896856f, -0.01366001f, 0.06043570f, 0.08352599f, -0.00100753f, 0.13482553f, 
    0.08261368f, 0.07242712f, 0.07067063f, -0.00539495f, 0.03637078f, 0.10734699f, -0.01075134f, -0.04603334f, 
    -0.24986744f, -0.27757671f, 0.08807223f, -0.03003018f, 0.02379083f, -0.02349111f, -0.07652608f, 0.04508125f, 
    0.06957492f, -0.15683800f, 0.03849311f, -0.20242266f, -0.03486848f, 0.04158662f, 0.15029907f, 0.01080382f, 
    -0.07579941f, -0.08272604f, -0.35166925f, -0.06826635f, -0.06526852f, 0.13281809f, 0.09236673f, 0.05352928f, 
    0.26541221f, -0.08109944f, -0.10032419f, -0.14743270f, -0.03269647f, -0.06799126f, 0.00829086f, 0.01452850f, 
    -0.03190154f, 0.11822083f, -0.05790220f, 0.05048962f, -0.06862777f, -0.06606267f, -0.29663110f, 0.02349819f, 
    0.09227282f, 0.04877280f, -0.00845273f, 0.06660933f, 0.01098763f, 0.02132050f, -0.10847973f, -0.09886674f, 
    -0.13668084f, 0.03057724f, 0.01478569f, -0.09982648f, 0.02640175f, 0.07382102f, 0.31979963f, 0.22207968f, 
    0.11339167f, 0.02167662f, 0.15869337f, 0.01310382f, 0.14850044f, -0.04356389f, 0.03386869f, 0.01703704f, 
    -0.11930835f, -0.42174941f, -0.05238464f, 0.12592632f, 0.04184895f, 0.03215535f, -0.12257791f, -0.02933767f, 
    -0.29016951f, 0.13282149f, 0.06529054f, 0.04054527f, -0.08166751f, 0.05300885f, 0.02001862f, 0.11960097f, 
    -0.07645404f, -0.13165110f, -0.01936020f, 0.11453240f, 0.13711908f, 0.13681892f, 0.01891939f, 0.15606058f, 
    -0.00803134f, 0.15935194f, 0.07994621f, 0.01671194f, 0.02436000f, -0.08863816f, -0.15846431f, -0.29623279f, 
    0.09276352f, -0.07827414f, 0.07870483f, -0.18626367f, -0.07178612f, -0.06880615f, -0.06089776f, -0.06881893f, 
    0.10760923f, 0.19699927f, -0.19912161f, 0.01427517f, 0.16910969f, 0.15157670f, 0.11141330f, -0.09392040f, 
    -0.01959130f, -0.27153525f, -0.00167137f, -0.02154952f, 0.09833760f, -0.12739938f, -0.11116870f, -0.14501309f, 
    -0.03471598f, -0.05645743f, 0.02903818f, -0.08048716f, -0.08604193f, -0.01566858f, 0.04167873f, -0.14136657f, 
    0.00989160f, -0.03337954f, 0.10125647f, 0.02075947f, -0.05885074f, -0.06151496f, 0.02755459f, 0.11937817f, 
    0.03818578f, -0.09194373f, -0.09404273f, -0.24157971f, -0.21165508f, -0.11572601f, 0.14496742f, 0.14905564f, 
    -0.01594361f, 0.12723611f, -0.00758118f, 0.03653836f, -0.03166372f, -0.00090729f, 0.05450821f, 0.04633598f, 
    0.27491409f, -0.24760348f, 0.06368776f, -0.00250931f, 0.15596817f, 0.00038243f, -0.00091961f, -0.08982187f, 
    0.09377789f, 0.07499050f, -0.06397983f, -0.04494277f, 0.13579792f, 0.07016178f, 0.13297662f, 0.22625461f, 
    0.04908545f, -0.06770893f, -0.15330894f, 0.00676239f, -0.09240901f, -0.03048794f, 0.12186304f, -0.03850055f, 
    0.06302375f, 0.06709810f, 0.10222960f, -0.20120594f, -0.09613745f, -0.06574088f, -0.10338386f, 0.10964321f, 
    -0.00229213f, 0.07103302f, -0.08882289f, -0.03723476f, 0.21595035f, -0.05356566f, 0.01401417f, -0.18259381f, 
    -0.02586570f, -0.01621230f, -0.13881251f, -0.10487828f, 0.04363542f, 0.06128014f, -0.03448601f, -0.05524423f, 
    0.03950054f, -0.03002657f, 0.12086440f, 0.21666284f, -0.00246036f, -0.03357971f, -0.13333726f, 0.01814767f, 
    0.14079180f, -0.07168426f, 0.07295976f, -0.03219302f, -0.21327819f, 0.03462878f, 0.11967060f, -0.09042506f, 
    -0.05757835f, 0.05460735f, 0.08927641f, -0.01937908f, -0.07589580f, -0.12307522f, -0.02435042f, -0.14597417f, 
    0.05155646f, 0.04776784f, -0.01815078f, -0.12802467f, -0.11426543f, -0.01386269f, -0.14027075f, 0.15362203f, 
    -0.03669906f, 0.16947867f, -0.03120316f, 0.14412269f, 0.08598389f, 0.10584503f, 0.06246114f, -0.15482800f, 
    0.08946785f, 0.11907148f, 0.04504559f, -0.22830544f, -0.05129553f, 0.02618633f, 0.02901801f, 0.07953228f, 
    0.11021052f, -0.11643696f, -0.08806958f, -0.02453445f, -0.15266545f, -0.11427159f, -0.20785011f, 0.08418280f, 
    0.05428375f, 0.12123758f, 0.11200675f, 0.15169668f, -0.06193536f, -0.03637210f, 0.05526035f, -0.12117959f, 
    -0.09783203f, -0.06606463f, -0.05414507f, -0.02825946f, 0.01122067f, -0.00323658f, 0.06584293f, 0.02641317f, 
    -0.00581578f, 0.04252453f, -0.03057915f, 0.06732133f, -0.07904936f, 0.03686462f, 0.01865341f, 0.12237881f, 
    0.09412698f, -0.01535358f, 0.01669523f, -0.09332690f, -0.15768954f, 0.18811084f, 0.12770811f, 0.09388870f, 
    -0.21401933f, -0.04406374f, -0.19162439f, 0.04886464f, -0.02530636f, -0.11034593f, 0.03605683f, -0.08694381f, 
    -0.07052570f, -0.07747313f, -0.08356016f, 0.07128243f, 0.14965241f, 0.05231025f, 0.11853229f, 0.14610867f, 
    -0.06716859f, -0.16823724f, 0.06148288f, 0.16595624f, -0.02628303f, -0.08377751f, -0.11181314f, -0.12398977f, 
    0.01978108f, 0.15688019f, -0.03038404f, -0.02485674f, 0.07216913f, 0.10398456f, 0.11816509f, 0.08856041f, 
    -0.03086123f, 0.04216285f, -0.16635428f, 0.02609485f, -0.26677620f, -0.12259773f, -0.02745778f, 0.21264613f, 
    0.10989299f, 0.07324485f, -0.00380072f, 0.06106671f, 0.01256315f, -0.11896519f, -0.01603983f, 0.07093996f, 
    0.10753332f, 0.06822542f, 0.13993108f, 0.03703365f, -0.12606333f, 0.00550642f, 0.01694682f, -0.15308936f, 
    0.01122915f, 0.18460231f, 0.00712423f, 0.07868966f, -0.03496654f, 0.01704239f, 0.08326570f, -0.04833044f, 
    -0.03123754f, 0.18457432f, 0.18436673f, -0.01604031f, 0.06905568f, 0.02661651f, 0.24288046f, -0.14425115f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.06735401f, 0.01784879f, 0.04170150f, -0.00532689f, -0.05642038f, 0.03667396f, 0.06622887f, 0.04283926f, 
    0.00215939f, 0.02331295f, -0.06944142f, -0.13532566f, -0.02387933f, -0.04278867f, -0.05998692f, 0.02284221f, 
    0.05913511f, 0.13414612f, 0.08792640f, -0.00038972f, 0.06480411f, 0.02969926f, 0.06392685f, -0.06492505f, 
    0.09844801f, -0.06035916f, 0.08249382f, -0.01141998f, 0.03524030f, 0.15487416f, 0.08239389f, 0.11098863f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15721041f, 0.04262710f, 0.06951113f, 0.12336336f, 0.01271109f, -0.00788085f, 0.12944074f, 0.13990453f, 
    -0.12374979f, 0.02403715f, -0.13662013f, 0.07180884f, -0.08380035f, -0.11281972f, -0.12774692f, 0.15050368f, 
    -0.17171696f, -0.06229118f, -0.15629078f, -0.06474563f, 0.10167727f, -0.08776898f, -0.08878990f, 0.08891265f, 
    -0.14942211f, -0.15301085f, 0.04336807f, -0.13536695f, -0.15427496f, -0.04212108f, -0.13132317f, -0.10551887f, 
    0.33977780f, -0.17892140f, -0.07865057f, -0.13669081f, 0.06446066f, 0.04798967f, 0.22284898f, -0.07396155f, 
    0.09168404f, -0.15601185f, 0.02325705f, -0.05274016f, 0.01408544f, 0.10421521f, -0.13443156f, 0.10351428f, 
    -0.26877007f, -0.15220925f, 0.30235797f, 0.06336921f, 0.17957523f, 0.08601169f, -0.20904402f, -0.04635574f, 
    -0.05497957f, 0.16035667f, 0.02378781f, 0.13677685f, 0.10145156f, 0.20345317f, 0.21061096f, -0.13346857f, 
    -0.05187735f, -0.23186314f, 0.02702321f, -0.12518832f, 0.10372012f, 0.05141758f, 0.12082831f, -0.01533671f, 
    0.14950466f, 0.15081435f, 0.05450618f, -0.11882323f, 0.17443141f, 0.08598100f, 0.41028070f, -0.07210323f, 
    0.35987473f, 0.06625541f, 0.21651407f, -0.24863622f, -0.02451206f, 0.00768946f, 0.06975996f, -0.07465371f, 
    0.27672696f, 0.01035478f, -0.28456497f, -0.17978954f, -0.16580130f, -0.05367672f, 0.27345935f, 0.36033168f, 
    0.33055338f, 0.23310897f, -0.11711659f, -0.04749514f, 0.10519568f, -0.05598200f, 0.30218369f, -0.12425330f, 
    0.09082154f, -0.07391835f, -0.43852678f, -0.16758688f, 0.39526919f, -0.14041518f, -0.24350104f, 0.12569234f, 
    -0.09481160f, -0.02964226f, 0.05432689f, 0.29532093f, -0.15901823f, 0.06378962f, 0.21087486f, -0.39284262f, 
    -0.06290258f, -0.01242085f, -0.03910998f, 0.08998470f, 0.05514577f, -0.21532576f, -0.03899950f, -0.06625188f, 
    0.03234541f, 0.20920874f, 0.00740423f, -0.15395077f, -0.16173249f, -0.08518235f, 0.37829268f, -0.07768881f, 
    -0.15660346f, -0.12086514f, 0.19327843f, 0.08329307f, 0.19823174f, -0.01349022f, 0.08013778f, -0.05092056f, 
    -0.12752958f, 0.43623957f, 0.15121451f, -0.18665092f, -0.37702653f, -0.10122114f, -0.15303648f, -0.16972233f, 
    -0.23892917f, 0.10786887f, 0.02921600f, 0.27520475f, -0.15407531f, -0.30221361f, -0.19794068f, 0.12766191f, 
    0.25268090f, -0.06277388f, 0.11217480f, 0.07943793f, 0.11007555f, 0.07551459f, -0.16168489f, 0.04912640f, 
    0.14374261f, -0.11250325f, 0.07425356f, -0.07149267f, 0.22371273f, 0.10960973f, -0.41980618f, -0.15919131f, 
    -0.00780392f, -0.06985497f, 0.09686527f, 0.25682244f, 0.32549635f, 0.02294752f, 0.36857808f, -0.12454681f, 
    0.18126108f, 0.00174145f, 0.06719665f, -0.21003389f, -0.07799043f, 0.19583531f, -0.12997872f, -0.03085252f, 
    0.07243380f, -0.06046860f, -0.01608286f, -0.13743369f, -0.11761691f, 0.12459309f, -0.12435375f, 0.11483391f, 
    0.02929749f, -0.08816013f, -0.48708802f, -0.30063435f, 0.00902126f, -0.04950967f, 0.03357872f, 0.13751069f, 
    0.25624695f, 0.00202260f, 0.15653847f, 0.12417251f, -0.18134917f, 0.00208243f, 0.15816872f, -0.05396797f, 
    0.05516589f, 0.15534796f, 0.20989856f, -0.21862206f, -0.07385939f, 0.14387138f, 0.26306081f, 0.05767550f, 
    0.15849937f, -0.01563923f, 0.12593512f, -0.11949635f, 0.00489389f, 0.12467350f, 0.13934067f, 0.11652831f, 
    0.11329541f, -0.13760827f, 0.13550587f, -0.39479223f, 0.41879088f, -0.05890991f, -0.00681579f, -0.17303000f, 
    0.26591617f, -0.04124409f, -0.16584595f, -0.00391427f, 0.16791150f, 0.13109435f, -0.30613464f, -0.33372936f, 
    -0.04979431f, 0.09569418f, 0.24536373f, 0.03122035f, 0.14421670f, -0.27938280f, -0.06141234f, 0.17134388f, 
    0.03134689f, 0.23022489f, 0.02188681f, 0.01681741f, -0.10664550f, 0.09793107f, 0.32284412f, 0.16481335f, 
    0.03648721f, 0.00021092f, 0.19387853f, 0.14461255f, 0.07334358f, 0.00589122f, 0.39995170f, 0.07730731f, 
    -0.27551720f, 0.10474571f, -0.11887652f, -0.16669276f, 0.13199545f, -0.03869435f, 0.09653809f, -0.20250042f, 
    -0.14274864f, 0.00811611f, -0.25319752f, -0.11944366f, 0.15261258f, 0.05932378f, -0.04022302f, 0.32940972f, 
    0.00536929f, -0.06502910f, 0.14382651f, -0.09078937f, 0.13925354f, -0.01568958f, 0.07260454f, -0.02515513f, 
    0.15551317f, -0.12965618f, -0.31446069f, -0.16552250f, 0.14784893f, -0.00660183f, -0.06066271f, -0.15444079f, 
    0.57609773f, 0.16847324f, -0.13942762f, 0.29428875f, -0.13944866f, 0.10393863f, 0.11451748f, 0.13559832f, 
    0.11987984f, -0.10011582f, 0.21276489f, -0.19510078f, 0.00113133f, -0.14967193f, -0.23901714f, -0.02940265f, 
    -0.14388932f, -0.18576588f, 0.09417789f, -0.13780801f, 0.06685885f, -0.09153695f, 0.07307709f, 0.12330917f, 
    0.11351135f, 0.04616734f, 0.00784994f, 0.05566739f, -0.03086353f, 0.08683854f, -0.09932315f, -0.01032617f, 
    0.07882664f, -0.00218964f, 0.04403059f, -0.09307429f, 0.09304714f, 0.11833710f, -0.02729210f, -0.06134275f, 
    -0.13034561f, -0.05919231f, -0.07560681f, -0.15827006f, -0.17418972f, 0.13627170f, 0.00918435f, 0.00821501f, 
    0.07843287f, -0.02079444f, -0.09461460f, 0.10420480f, 0.06786001f, 0.07268051f, 0.02979069f, 0.01570398f, 
    -0.11045392f, 0.15070298f, 0.43510479f, 0.25484315f, -0.17668404f, -0.02150484f, 0.01213954f, 0.10658611f, 
    -0.13748360f, 0.04924184f, 0.01524893f, -0.06595149f, 0.55446965f, -0.14928761f, 0.03021993f, 0.14971358f, 
    -0.17391773f, 0.01488416f, -0.08748475f, -0.04106980f, -0.02173410f, -0.17711768f, 0.40946159f, 0.13439335f, 
    0.16795537f, 0.00792123f, 0.05680029f, 0.17733103f, -0.05415514f, -0.09990967f, 0.11544409f, -0.11080130f, 
    -0.15320125f, -0.07714279f, -0.02651123f, -0.31144914f, 0.14984509f, 0.07213318f, -0.08045970f, 0.01195751f, 
    0.26914519f, -0.04400726f, -0.19319518f, 0.04175736f, 0.47379217f, 0.07776616f, 0.17420065f, 0.00450916f, 
    0.26567358f, -0.12510310f, 0.12231134f, -0.37906390f, 0.14483285f, 0.17877319f, -0.31280199f, 0.30013296f, 
    -0.12410232f, -0.25814930f, -0.07864171f, 0.11957577f, 0.05592502f, 0.03648266f, 0.09723500f, 0.02985572f, 
    -0.17275874f, 0.06132155f, -0.36742029f, 0.11131953f, -0.12396116f, -0.11505123f, 0.11455719f, 0.03296266f, 
    0.39549989f, 0.17996782f, -0.04997173f, -0.26659149f, -0.24821202f, 0.04083468f, 0.28935245f, 0.29397297f, 
    -0.42562550f, 0.13100442f, 0.11963991f, 0.13279912f, 0.07680497f, -0.20280762f, 0.42965263f, -0.00131821f, 
    -0.26085687f, 0.02672936f, 0.15126330f, 0.04564325f, -0.13174151f, 0.10877304f, 0.20431270f, 0.12117573f, 
    0.05221960f, 0.15453722f, -0.20321210f, 0.55986768f, 0.39111644f, 0.10618119f, 0.47203955f, -0.11361429f, 
    -0.16936244f, 0.12081515f, -0.19577052f, -0.12257281f, -0.25181109f, -0.03862897f, 0.17934272f, 0.35114551f, 
    -0.12113007f, -0.14286931f, -0.28761289f, -0.00652063f, -0.17007610f, 0.08179380f, -0.04266329f, -0.18213101f, 
    -0.04808684f, -0.12163352f, -0.01328536f, -0.08645493f, -0.01157639f, 0.02449458f, -0.19662316f, 0.03662333f, 
    0.07198406f, -0.05369856f, -0.48519731f, -0.15433151f, 0.05666112f, -0.04494359f, -0.21623364f, 0.02645658f, 
    0.35650837f, 0.06999090f, 0.28237301f, 0.16862699f, -0.12948985f, -0.15075323f, -0.29634309f, 0.21133779f, 
    -0.10310907f, -0.14505477f, 0.06667782f, -0.14411648f, -0.07119472f, 0.38732284f, 0.44173974f, 0.20573582f, 
    0.22759569f, 0.35563058f, -0.11776292f, -0.09740918f, -0.05467259f, 0.17754687f, -0.12530868f, -0.01975555f, 
    -0.00575750f, 0.03182295f, 0.17651851f, 0.27276415f, 0.32128692f, 0.07888116f, 0.05961483f, 0.06848132f, 
    -0.08034392f, 0.17212275f, -0.19406284f, 0.14131936f, -0.04949280f, 0.00950417f, 0.03662458f, -0.26905620f, 
    -0.21361901f, 0.13449357f, 0.25579748f, 0.27074289f, 0.13938640f, -0.08016677f, -0.36766300f, -0.07734835f, 
    -0.35765433f, -0.03136241f, -0.14224580f, -0.05235111f, -0.11746328f, -0.14298634f, -0.25975919f, 0.10422598f, 
    0.00403927f, -0.11782320f, 0.07231678f, 0.10634113f, -0.14286952f, 0.06597476f, 0.31226882f, -0.12808333f, 
    0.38615182f, 0.22687452f, 0.02395088f, -0.15673001f, -0.03364469f, 0.10735820f, 0.09995352f, 0.25896963f, 
    0.15090835f, -0.13162027f, 0.05402050f, 0.05319269f, 0.17173690f, 0.00243615f, 0.46269980f, 0.14968294f, 
    0.26908541f, 0.01782106f, 0.10370910f, 0.04705415f, 0.03106705f, 0.05507065f, 0.14977582f, -0.05543910f, 
    0.14059599f, 0.01055070f, -0.32906801f, 0.04873061f, -0.30890197f, 0.04065323f, -0.00668479f, -0.06415480f, 
    -0.24058539f, 0.30127221f, -0.15418223f, -0.17175825f, 0.34210539f, 0.11323255f, 0.10194505f, 0.03716000f, 
    0.15279843f, 0.05135138f, -0.31628412f, 0.00593952f, 0.08312631f, 0.25809157f, -0.09184496f, 0.00186766f, 
    -0.05324828f, -0.04328391f, 0.11086634f, -0.06486152f, 0.02661016f, 0.12160946f, -0.05332190f, 0.04177268f, 
    -0.04346540f, 0.01691186f, -0.24318722f, -0.18170391f, 0.37211722f, 0.11098630f, -0.02713666f, 0.10019555f, 
    0.27945438f, 0.14146812f, 0.25475141f, -0.03487141f, -0.11349487f, 0.09676889f, -0.52008033f, 0.17027366f, 
    -0.09266411f, 0.08121850f, -0.03247454f, 0.08073595f, -0.09299330f, 0.34180084f, 0.27441245f, 0.19865192f, 
    0.28483206f, -0.05485447f, 0.09701394f, 0.03172080f, -0.01749873f, -0.01336487f, 0.14674321f, -0.09230677f, 
    0.00212456f, -0.12416114f, 0.17939939f, -0.15948385f, 0.30901319f, 0.14042746f, -0.33016688f, 0.00416751f, 
    0.03100932f, 0.12254983f, 0.12867157f, 0.13582696f, 0.22700225f, 0.08445244f, -0.49577036f, -0.11857834f, 
    0.20292422f, -0.01576075f, -0.04099951f, -0.01095315f, 0.00903622f, 0.40697220f, -0.10902991f, 0.03354685f, 
    0.42848980f, 0.04131178f, 0.05653135f, -0.14802185f, -0.06213902f, 0.07630134f, 0.21821092f, -0.04428451f, 
    0.15349694f, -0.05099449f, -0.02714007f, 0.03696334f, 0.11379991f, -0.12639536f, -0.21207295f, -0.12953526f, 
    -0.36294785f, 0.05410276f, 0.06977081f, 0.09035367f, -0.17275870f, 0.05974559f, -0.16801573f, -0.10249998f, 
    -0.09942129f, 0.00141900f, 0.19798164f, 0.00993485f, -0.16875146f, -0.07301465f, 0.21196310f, -0.25326324f, 
    -0.02249795f, 0.18196851f, -0.10563371f, -0.06587546f, 0.03862055f, -0.00848038f, -0.00379126f, 0.03406926f, 
    0.09314296f, -0.07634901f, -0.14783391f, 0.30639389f, 0.36167899f, -0.14441934f, 0.32970738f, -0.15986243f, 
    -0.08249950f, -0.15656690f, 0.14754601f, -0.06231917f, -0.24065843f, -0.15875287f, -0.28616866f, -0.10981027f, 
    -0.10758635f, 0.03269176f, 0.13231573f, 0.37684372f, 0.08656343f, 0.59668905f, -0.27522022f, -0.02050116f, 
    0.12355404f, 0.14640270f, 0.11922584f, -0.14729834f, 0.13296317f, -0.03589410f, 0.38601932f, 0.04966931f, 
    -0.14254871f, -0.17597458f, 0.13934956f, 0.39464509f, -0.03541268f, 0.12525663f, -0.03848281f, 0.17031139f, 
    -0.20106205f, 0.13947998f, 0.16695456f, 0.16874495f, -0.24222265f, 0.11727785f, -0.10232887f, 0.13294075f, 
    -0.30832389f, 0.14228073f, -0.09029201f, 0.13426304f, 0.08248907f, -0.28833720f, 0.12170822f, -0.26110223f, 
    -0.07959782f, -0.14618796f, -0.03851107f, 0.07118158f, 0.16856501f, -0.07890948f, 0.11029690f, -0.00083350f, 
    -0.02017546f, -0.03856064f, -0.01573451f, -0.01448275f, -0.14427768f, -0.03114420f, -0.14169401f, 0.15358515f, 
    -0.19244267f, 0.00684149f, -0.13674133f, 0.08990534f, 0.10607958f, -0.16712746f, -0.12357944f, -0.03764434f, 
    -0.11396554f, 0.01050953f, -0.06551778f, -0.01084847f, 0.09830029f, 0.07838686f, -0.00038600f, -0.06496507f, 
    0.26634687f, -0.24993737f, 0.06576389f, 0.06052827f, -0.16991845f, -0.06423522f, -0.00062697f, -0.11346752f, 
    0.05742361f, 0.07537074f, -0.38328093f, -0.08090063f, -0.56022125f, 0.07888722f, -0.01592723f, 0.03274336f, 
    -0.21713866f, 0.31616536f, -0.27116790f, -0.08436255f, 0.48498902f, -0.11199398f, -0.11066908f, 0.01736243f, 
    -0.08632492f, 0.14023449f, -0.05931414f, -0.22568138f, 0.07979199f, 0.35376742f, 0.22623821f, 0.30714700f, 
    0.32893717f, 0.36873218f, -0.05421945f, 0.14661597f, 0.10260418f, -0.00689885f, 0.07091468f, -0.11772214f, 
    0.02323621f, -0.07842154f, -0.41355509f, 0.16331168f, 0.12098318f, -0.05382963f, 0.03481647f, 0.11088583f, 
    -0.01491782f, 0.08883934f, -0.08142678f, 0.16540959f, 0.33000231f, -0.16583821f, 0.34582308f, -0.42408448f, 
    -0.09969778f, -0.05963641f, 0.00259085f, -0.17277798f, -0.09374738f, -0.07230200f, -0.04314118f, -0.30530417f, 
    0.08262695f, 0.02605413f, 0.03157265f, 0.13485336f, 0.15166441f, 0.18084142f, 0.37164471f, -0.09624375f, 
    -0.13164203f, -0.06529975f, 0.10560912f, 0.36452445f, -0.08745820f, 0.12082276f, 0.42055851f, 0.16335627f, 
    0.00931791f, 0.16709742f, -0.17989397f, 0.10451908f, -0.14638399f, -0.10687107f, 0.19339237f, -0.12099116f, 
    -0.31143442f, 0.00078882f, -0.13603233f, 0.24550979f, 0.04415754f, -0.16323505f, -0.00960720f, -0.11309335f, 
    -0.08854224f, 0.08949548f, 0.09589851f, -0.00816715f, 0.04136388f, -0.00870201f, -0.12456381f, -0.04715991f, 
    -0.10833777f, -0.04622211f, -0.11045788f, -0.16034786f, -0.04027193f, 0.16738157f, 0.01393636f, 0.09963624f, 
    0.08866633f, -0.08884013f, 0.12512159f, -0.09174026f, -0.19749857f, 0.01750045f, -0.06579715f, -0.15180342f, 
    -0.12158447f, 0.14494568f, -0.11674158f, -0.05141418f, -0.02190910f, -0.20088702f, -0.16275282f, -0.00204794f, 
    0.04114162f, -0.04034924f, -0.01608661f, 0.12959380f, -0.04846288f, -0.06744745f, -0.15498888f, 0.10224516f, 
    0.10765686f, 0.11527210f, 0.10633222f, -0.06629683f, -0.11237629f, 0.01019171f, -0.02521984f, -0.00562635f, 
    -0.12757115f, -0.18899815f, -0.15353642f, -0.01596045f, 0.09383299f, -0.00477501f, 0.15632287f, -0.04672309f, 
    -0.08715951f, 0.16212541f, 0.04994367f, -0.14931071f, 0.00949956f, 0.06907618f, -0.02177570f, -0.12985079f, 
    0.18256783f, 0.22995451f, 0.07336330f, -0.09783906f, -0.10953115f, 0.18355390f, -0.10581993f, -0.10892858f, 
    0.06203454f, -0.08688922f, -0.07465818f, -0.37044045f, 0.06829187f, 0.00250547f, -0.25255060f, -0.09869786f, 
    0.37315455f, -0.10492830f, 0.27823254f, 0.23869139f, -0.01910586f, -0.03109408f, -0.00216293f, -0.24206203f, 
    0.38142166f, -0.04516601f, 0.21751314f, -0.17498936f, 0.18315986f, -0.19266701f, 0.13351543f, -0.03842593f, 
    -0.05635091f, 0.09740726f, 0.08037411f, 0.02904885f, -0.05009784f, 0.11978714f, 0.29767957f, 0.09552553f, 
    -0.03329988f, -0.06121576f, -0.11910532f, -0.19195691f, -0.18510544f, 0.13218102f, 0.23821498f, 0.09472615f, 
    0.48477188f, 0.11956168f, 0.22843812f, -0.19515131f, -0.04156727f, -0.12828243f, 0.11566636f, -0.20099510f, 
    0.00041933f, 0.08621639f, 0.06554337f, -0.23170231f, -0.14622867f, 0.06503341f, 0.10112337f, 0.31194651f, 
    0.08249608f, -0.11642584f, 0.07146388f, 0.01525755f, -0.16811413f, 0.07781889f, -0.09232736f, 0.12445654f, 
    0.01398430f, 0.06274106f, -0.07104614f, 0.01757148f, 0.03452545f, -0.01938068f, 0.08981951f, -0.04276421f, 
    0.24038871f, 0.13579594f, 0.20478010f, -0.19566323f, 0.26156351f, 0.15736295f, 0.37453952f, -0.10723191f, 
    0.38542160f, -0.02578172f, -0.01928417f, -0.38599330f, -0.14294207f, 0.25983292f, -0.08892820f, 0.00449416f, 
    0.29186824f, 0.06937055f, 0.06449897f, 0.08650546f, 0.01179600f, -0.13840495f, 0.25924137f, -0.09797448f, 
    -0.13881315f, -0.00453824f, -0.23115243f, -0.28775355f, 0.15747099f, 0.12596886f, -0.03016828f, -0.11636989f, 
    0.10335618f, -0.31571442f, -0.17124374f, 0.41799086f, 0.09153628f, 0.02209898f, -0.00532767f, -0.03822830f, 
    0.26759270f, 0.02275394f, 0.23516750f, -0.39581257f, -0.13624310f, -0.32792243f, 0.21029817f, -0.21824466f, 
    -0.03637564f, 0.01716510f, -0.09051917f, 0.08263677f, 0.03293638f, 0.15816601f, -0.16571945f, -0.01752772f, 
    0.04523178f, 0.15562190f, 0.20550250f, 0.51074588f, 0.18398575f, 0.13830306f, 0.44330540f, 0.04104924f, 
    0.23741978f, -0.00200305f, -0.07523830f, 0.00721784f, 0.00088898f, 0.13822132f, -0.11504529f, 0.11824798f, 
    -0.00630256f, 0.02956311f, 0.02741374f, -0.05241041f, 0.08764900f, -0.00786172f, -0.37973124f, -0.12654065f, 
    0.15395346f, -0.15587693f, 0.09163108f, 0.00665358f, 0.15042710f, 0.14847197f, 0.02104329f, -0.01590980f, 
    0.05705968f, 0.00665136f, 0.16219924f, -0.02647264f, -0.26318079f, 0.05523553f, 0.01336364f, 0.13644877f, 
    -0.17171459f, -0.09819549f, -0.13080983f, -0.09083740f, 0.41415894f, 0.15397929f, 0.22007819f, -0.04758836f, 
    0.15732524f, -0.05196277f, -0.17044741f, -0.02181560f, -0.01996699f, 0.03223596f, 0.48444062f, 0.03199030f, 
    0.00056344f, 0.05034491f, -0.14543200f, 0.06749655f, 0.15447353f, 0.01957781f, 0.29154834f, -0.08272370f, 
    -0.17081030f, 0.11027747f, 0.25072816f, -0.30421740f, 0.33378649f, -0.02789745f, -0.01892884f, 0.02836279f, 
    -0.23491365f, -0.12172063f, 0.23010518f, -0.06741566f, 0.22771698f, 0.06281686f, -0.28663209f, -0.14973040f, 
    -0.08658047f, -0.07735994f, 0.13335915f, -0.23602057f, 0.05692830f, 0.03435187f, 0.25868919f, 0.19263159f, 
    -0.00861938f, 0.21277232f, 0.04872898f, -0.01459480f, -0.08339083f, 0.13261198f, -0.34966660f, -0.13479798f, 
    0.04766892f, -0.01558878f, 0.34878823f, 0.13002716f, 0.10908195f, 0.00307508f, 0.10565377f, -0.02915019f, 
    -0.02495875f, -0.02858844f, 0.05190936f, 0.07092208f, 0.02968710f, 0.03755560f, -0.40989414f, 0.38752064f, 
    0.20257126f, 0.11900853f, 0.01790101f, 0.31448197f, -0.10008471f, 0.29327840f, -0.14462490f, -0.12494719f, 
    -0.10375827f, 0.06582097f, -0.12903880f, -0.00270241f, -0.08915520f, 0.02271524f, -0.00434766f, -0.11058036f, 
    -0.16811648f, 0.07859042f, 0.25907737f, 0.06983842f, 0.03163027f, -0.13601488f, 0.08512107f, 0.13136050f, 
    -0.01009643f, -0.17486751f, -0.08256355f, -0.14503881f, 0.44570765f, 0.16531391f, 0.25839397f, -0.05993726f, 
    -0.18800309f, 0.06453715f, -0.20894112f, 0.01961996f, -0.09600788f, 0.18550806f, 0.32093054f, -0.00442248f, 
    0.02927590f, -0.02633080f, -0.00444940f, 0.14647324f, -0.15761559f, -0.02791619f, 0.19534719f, 0.10035740f, 
    0.09678408f, 0.14837536f, 0.19874930f, 0.23228022f, -0.18523805f, -0.16327041f, -0.03587946f, -0.13345133f, 
    0.01638575f, 0.07459391f, -0.03933562f, 0.26015881f, -0.34652397f, 0.00961856f, 0.28429320f, 0.35895354f, 
    -0.24096774f, -0.11704569f, 0.13505386f, 0.43629563f, 0.03510974f, -0.27078211f, -0.11325738f, -0.04734075f, 
    0.07740160f, -0.08775860f, 0.03785398f, 0.00290185f, -0.02156403f, -0.10695473f, -0.13605441f, 0.09422562f, 
    0.00395750f, -0.14394704f, -0.04462904f, -0.05157096f, 0.03123975f, 0.04622205f, 0.08702673f, -0.10034952f, 
    -0.13550575f, -0.00487498f, -0.01940508f, -0.08811413f, 0.15214975f, 0.13713419f, 0.00978020f, 0.08436953f, 
    -0.19657919f, 0.05488898f, -0.08916612f, -0.06320641f, -0.12043852f, -0.14726309f, -0.04013143f, -0.17576289f, 
    0.09106509f, 0.03656039f, -0.06552710f, -0.00965904f, -0.11107568f, -0.02763068f, -0.40765929f, 0.15220296f, 
    -0.14106517f, -0.09653401f, 0.36029145f, -0.06832733f, 0.05058999f, 0.08702420f, -0.04975712f, 0.07690199f, 
    0.35257310f, -0.11224061f, 0.10455616f, 0.23073439f, -0.08922247f, 0.01543187f, 0.04481443f, 0.28583619f, 
    0.27675650f, 0.14410821f, 0.21129628f, 0.27899304f, 0.07415030f, 0.17628568f, -0.19224744f, -0.02071932f, 
    -0.07380944f, -0.20759465f, 0.02623628f, -0.05320366f, -0.09486179f, 0.02569499f, 0.10610319f, 0.07865185f, 
    0.03964739f, -0.13363479f, -0.25297713f, -0.12346724f, -0.00293656f, -0.05388116f, 0.11808260f, -0.16118757f, 
    -0.05810886f, 0.39618009f, 0.35906217f, -0.11425398f, -0.22770201f, -0.13461462f, 0.14394611f, -0.20213394f, 
    -0.30607826f, 0.02586386f, 0.09914857f, -0.01444372f, 0.10591178f, 0.44977319f, -0.07729019f, 0.43348461f, 
    0.24650596f, -0.05886811f, 0.06650321f, -0.10097158f, -0.11452547f, 0.12801026f, -0.14396861f, 0.05636872f, 
    -0.06039529f, 0.15742049f, -0.09545773f, 0.03914059f, 0.26530734f, -0.02007495f, -0.09479101f, 0.14325210f, 
    0.11302858f, -0.02919331f, 0.18116881f, 0.35186517f, -0.09380434f, 0.03847836f, -0.48238871f, 0.14631237f, 
    0.03637965f, -0.14681152f, 0.30196771f, 0.43426931f, -0.07018737f, 0.29531479f, -0.24666458f, -0.19937110f, 
    -0.16627145f, -0.01536438f, 0.04592169f, -0.09994812f, 0.08926489f, -0.14593503f, -0.18652190f, 0.08529178f, 
    -0.03791728f, 0.15271145f, 0.05190662f, -0.08262312f, -0.17089432f, -0.07996212f, -0.10362540f, 0.13406962f, 
    -0.13231346f, -0.11254705f, 0.05319996f, -0.07325209f, -0.04687862f, -0.15869613f, 0.03852167f, -0.01964196f, 
    0.10609283f, 0.05577823f, 0.05163391f, -0.08473305f, 0.16855761f, 0.10909823f, 0.11976394f, -0.16553414f, 
    -0.01266814f, 0.14478625f, 0.01080974f, 0.17059460f, -0.16929637f, -0.08221584f, -0.15566435f, -0.17339887f, 
    -0.01866314f, -0.07645594f, 0.16390045f, -0.19742145f, -0.12592894f, -0.01272323f, 0.08808923f, 0.05742152f, 
    0.53668958f, 0.06601035f, 0.28980020f, 0.09866869f, -0.30184773f, -0.14456569f, -0.11903173f, -0.23124827f, 
    0.07073101f, -0.13277034f, 0.24066664f, 0.01557678f, 0.06050154f, -0.21906747f, 0.31026104f, -0.03900704f, 
    0.28498092f, 0.11664919f, -0.07402217f, 0.13949004f, 0.01521700f, 0.08559248f, 0.15785027f, -0.15639372f, 
    0.01969716f, -0.17376588f, -0.02467238f, -0.31151024f, 0.17428978f, 0.15423654f, -0.06144006f, 0.08186191f, 
    -0.01168560f, -0.23069149f, 0.03645785f, 0.18509872f, -0.09533322f, 0.05816961f, -0.37929827f, 0.08741257f, 
    -0.16045624f, -0.12462083f, 0.28321254f, 0.11508515f, -0.03902226f, -0.24951835f, -0.00067011f, -0.09166630f, 
    -0.12322470f, -0.24165843f, 0.10460610f, 0.07177343f, 0.07527553f, -0.16227010f, 0.13656016f, -0.04718696f, 
    -0.04729234f, 0.09695391f, -0.05652047f, -0.12347353f, -0.02036122f, 0.15165485f, 0.07658321f, -0.10083142f, 
    0.06113099f, 0.12721226f, 0.25739595f, -0.07114090f, 0.32211199f, -0.03370826f, 0.34800053f, 0.19238459f, 
    -0.08257164f, -0.00342714f, -0.19218440f, -0.09831135f, -0.09254471f, 0.18669420f, 0.06352722f, 0.12072767f, 
    0.25779203f, -0.12268324f, -0.00962741f, -0.14570107f, -0.07542592f, 0.17735082f, 0.02794199f, 0.01551019f, 
    0.15651797f, 0.12538446f, -0.52277184f, 0.03782644f, -0.46081463f, 0.08280236f, -0.21249646f, 0.12531321f, 
    -0.49871799f, 0.22273850f, -0.13029389f, -0.05618920f, 0.48127133f, -0.03972585f, 0.05973410f, -0.10149001f, 
    -0.20274927f, 0.16984162f, -0.20046690f, -0.00213040f, -0.03592235f, 0.33767733f, 0.10106551f, 0.37181702f, 
    -0.03396286f, 0.06926651f, -0.05453371f, -0.11180962f, -0.10334542f, 0.16338527f, -0.17551163f, 0.10408704f, 
    0.00078339f, 0.04520912f, -0.09215306f, 0.09338399f, -0.03156820f, 0.16492493f, 0.23554182f, 0.00534151f, 
    -0.15945433f, -0.19426735f, -0.20972411f, -0.03709359f, 0.11493076f, 0.13603181f, 0.33737820f, 0.13481456f, 
    -0.05374010f, 0.07487526f, -0.14887543f, 0.06735115f, -0.07481097f, 0.31640077f, -0.10508557f, 0.19699743f, 
    -0.17180371f, 0.10679448f, 0.07702250f, 0.08835212f, 0.17191122f, 0.02566882f, -0.08450236f, -0.05327020f, 
    -0.06622861f, -0.01392397f, -0.08731341f, -0.06213851f, 0.09540436f, 0.15660247f, 0.04529422f, -0.10443207f, 
    0.02533554f, -0.17371409f, -0.13847885f, 0.05292587f, -0.07408353f, 0.08450434f, -0.10689186f, 0.10148540f, 
    -0.03177166f, 0.16208757f, -0.12037075f, -0.02097433f, -0.02780834f, -0.08859241f, -0.02809802f, -0.00478171f, 
    -0.15082960f, -0.15412581f, 0.11541118f, 0.12023702f, -0.14300717f, 0.05666690f, 0.15694480f, 0.12936540f, 
    -0.07507218f, -0.09243999f, 0.32132003f, 0.14845867f, -0.38667232f, -0.16699259f, 0.13694121f, 0.04505353f, 
    0.22249442f, 0.34545484f, -0.14704730f, 0.24777952f, -0.07140991f, -0.10853867f, 0.42335716f, 0.54254436f, 
    -0.25898412f, 0.10104287f, -0.14997526f, -0.12632903f, -0.15866913f, 0.13394970f, -0.16090755f, 0.19355637f, 
    0.04120529f, 0.18291943f, -0.15652673f, 0.09886540f, 0.14546567f, 0.08256938f, -0.27071148f, -0.12590548f, 
    -0.02349748f, 0.00544997f, 0.34702101f, -0.03050406f, 0.16457804f, 0.07265316f, -0.21274558f, 0.08237308f, 
    0.05474161f, -0.05754335f, 0.15671195f, 0.11432908f, 0.25282803f, 0.02108060f, 0.24857323f, -0.24293284f, 
    -0.29132411f, 0.05340275f, 0.05193128f, 0.34393141f, 0.07299928f, 0.26417446f, -0.21768543f, 0.12539198f, 
    0.02739063f, -0.18810311f, -0.14169668f, 0.01561220f, 0.03970418f, 0.02780811f, -0.10363209f, -0.16606204f, 
    -0.12625505f, -0.16542514f, 0.09125838f, -0.13685134f, 0.05648250f, 0.11795219f, -0.01134453f, -0.03752494f, 
    -0.09097327f, 0.10743698f, 0.03198664f, -0.06554642f, -0.10180739f, -0.10096659f, -0.07153664f, -0.14679417f, 
    -0.11958136f, -0.10956463f, -0.17375217f, -0.07017357f, -0.08611859f, 0.06641962f, -0.04221888f, -0.04645989f, 
    -0.10218647f, 0.31116846f, 0.12185339f, 0.09194856f, -0.12823240f, 0.13444723f, 0.04076940f, -0.05890365f, 
    0.05740465f, -0.05210073f, 0.10920575f, 0.27597699f, -0.02408486f, 0.12815069f, 0.20003262f, 0.15279321f, 
    0.42888835f, 0.17498983f, -0.12741937f, 0.00595288f, -0.60005611f, 0.01079928f, 0.07904387f, -0.02870015f, 
    -0.01808730f, 0.04777576f, 0.21845622f, 0.01374872f, -0.05614609f, -0.40437526f, -0.07173001f, 0.12157486f, 
    0.03318932f, 0.16355789f, 0.04871065f, -0.03353102f, -0.15157340f, -0.05055624f, 0.11756415f, 0.10089308f, 
    0.06194567f, 0.06790058f, -0.36221397f, 0.32722852f, -0.06595361f, -0.02303251f, 0.27985594f, 0.01418138f, 
    -0.12908913f, 0.34835625f, -0.07997140f, 0.15726842f, -0.19468053f, -0.17205878f, 0.33296764f, 0.01034289f, 
    -0.20773920f, -0.13103497f, -0.06005091f, 0.21533523f, -0.10622936f, -0.13354722f, -0.00770745f, -0.18178838f, 
    -0.02560441f, -0.23076318f, 0.12768237f, -0.09269314f, -0.16331401f, -0.05174194f, 0.20010743f, -0.09709415f, 
    0.10537805f, -0.04625867f, 0.03664156f, -0.21951668f, -0.08441082f, 0.03915685f, 0.12619856f, -0.12713563f, 
    0.45246929f, -0.07940500f, 0.00759957f, 0.39562282f, -0.16687094f, 0.06234495f, -0.16650653f, 0.16571148f, 
    -0.13885562f, -0.02988438f, 0.18934062f, -0.03800601f, 0.07382208f, -0.07684123f, 0.12455457f, -0.10061634f, 
    -0.13473082f, 0.16956942f, 0.04687385f, 0.01107805f, 0.07584905f, -0.07798783f, 0.27642569f, -0.05014282f, 
    -0.13310891f, 0.04874603f, -0.10473369f, 0.45290831f, 0.28501171f, -0.14371754f, 0.25157732f, -0.00632538f, 
    -0.05905085f, -0.38696313f, -0.30741045f, 0.09675985f, -0.01960416f, 0.08412667f, 0.13164465f, 0.25129196f, 
    0.03591858f, 0.11533165f, -0.21954140f, 0.01985690f, 0.03883564f, 0.17607306f, 0.08824410f, -0.32328606f, 
    0.05664966f, 0.19405372f, -0.05578638f, -0.07950018f, 0.15406370f, 0.07301726f, -0.20437995f, 0.15586364f, 
    -0.00093259f, -0.11588137f, -0.30964884f, -0.03296675f, 0.22804427f, 0.14197658f, -0.24246757f, -0.02011178f, 
    0.22352618f, 0.09607284f, 0.03935509f, -0.13614923f, -0.09669437f, -0.00906172f, 0.31981453f, 0.02240286f, 
    0.34619430f, -0.05995895f, 0.15728506f, 0.20075090f, -0.11703421f, -0.17616689f, -0.22431536f, -0.10950527f, 
    -0.09673367f, 0.25573379f, 0.01011920f, -0.14476126f, 0.04802257f, 0.13541609f, -0.05566845f, -0.11145370f, 
    0.14378817f, -0.06507929f, 0.18575306f, -0.00106407f, 0.03823164f, 0.03591014f, 0.47200459f, 0.05016040f, 
    0.35706365f, -0.04148937f, -0.22345044f, -0.08582655f, 0.23880859f, 0.00400541f, 0.21569419f, 0.15280864f, 
    0.08844309f, -0.13106319f, 0.08314070f, -0.25221270f, 0.12756880f, -0.19092359f, 0.23808759f, 0.08505732f, 
    0.00928177f, 0.01589493f, 0.05205157f, -0.13098024f, 0.02129267f, 0.00355934f, 0.00563232f, 0.05881496f, 
    0.05730072f, 0.14881803f, -0.14673309f, 0.00853324f, -0.13021010f, -0.09701305f, -0.04210209f, 0.10328275f, 
    -0.12328758f, -0.01132315f, -0.10330611f, -0.00880268f, -0.14520244f, 0.04909349f, -0.01266353f, -0.11189231f, 
    0.14327976f, 0.12582737f, -0.03876077f, 0.06612922f, 0.16720255f, -0.11044339f, -0.10825570f, -0.13348269f, 
    0.27969581f, 0.05544985f, -0.07985959f, 0.17482346f, -0.05628954f, -0.13854875f, -0.36819005f, 0.08309563f, 
    -0.03980635f, -0.04837474f, 0.19010900f, 0.26235959f, 0.13007893f, 0.08949036f, 0.16747414f, -0.09523261f, 
    0.19604705f, -0.31588581f, -0.00798704f, 0.03957245f, -0.03799231f, 0.07124632f, -0.38111451f, 0.09542044f, 
    -0.16574034f, -0.12033911f, 0.10267597f, 0.27895859f, -0.12458730f, -0.01307081f, -0.39443126f, 0.08982023f, 
    -0.05924808f, 0.15493090f, 0.10861118f, 0.05198812f, 0.03501027f, -0.13477521f, -0.30389589f, 0.05463642f, 
    0.09767851f, 0.00044460f, 0.34923750f, 0.04674730f, -0.08600297f, -0.09597351f, -0.16094659f, -0.04408370f, 
    -0.35826063f, -0.21087527f, 0.28289410f, 0.27301770f, 0.09319353f, 0.15830278f, -0.13016033f, 0.43905216f, 
    0.03939446f, 0.09126109f, -0.01527603f, 0.18860376f, 0.02490201f, 0.49478117f, 0.28873748f, 0.02175134f, 
    -0.09612832f, -0.17692363f, -0.08475689f, 0.08591045f, -0.05224235f, 0.04359409f, 0.12796272f, -0.02574337f, 
    -0.01415797f, 0.02505099f, -0.13611168f, 0.08465546f, -0.11925060f, -0.08292000f, -0.13575795f, -0.05274735f, 
    0.12325248f, -0.00574160f, 0.01366053f, 0.02023918f, 0.06209362f, -0.10600293f, -0.16731375f, -0.10025156f, 
    -0.08039925f, -0.00968556f, -0.08709978f, -0.01645650f, -0.07223479f, -0.03737086f, -0.04829003f, -0.09132043f, 
    -0.13281271f, -0.10735402f, 0.08756793f, 0.10930582f, -0.00719330f, 0.11196780f, 0.18178575f, 0.06743716f, 
    -0.07358826f, -0.09266299f, 0.20253342f, 0.05579332f, -0.13981733f, -0.09149837f, 0.35455185f, 0.01427962f, 
    0.35260594f, 0.24182281f, 0.30573532f, -0.29490092f, -0.01721516f, -0.04613128f, -0.04375897f, -0.00828312f, 
    -0.08659006f, 0.05028090f, -0.00307660f, -0.17182176f, 0.07809936f, -0.01353647f, 0.12667346f, 0.11490142f, 
    0.22893198f, 0.00706950f, 0.00516934f, -0.16063733f, 0.15883571f, 0.03311625f, 0.08734062f, -0.15018663f, 
    0.17157337f, 0.13431829f, 0.22853659f, -0.33458036f, -0.19198187f, -0.13571893f, -0.06772713f, 0.04081040f, 
    -0.02203874f, -0.34978718f, 0.37706783f, 0.14207150f, 0.47849876f, -0.12733850f, -0.09159561f, -0.01276442f, 
    -0.23381379f, 0.03206478f, 0.26850995f, 0.07867438f, -0.07874919f, -0.17478864f, 0.38759002f, -0.07111689f, 
    0.25067127f, 0.16279183f, 0.10251736f, 0.07181338f, -0.12124716f, -0.13363354f, 0.21240266f, 0.15554139f, 
    -0.07925847f, -0.11040266f, -0.14095739f, 0.07137117f, 0.08784992f, -0.06684715f, -0.18294927f, -0.05418525f, 
    -0.39872441f, 0.21129899f, -0.07983329f, 0.33571279f, -0.25939658f, -0.17551073f, 0.22452341f, 0.19889463f, 
    -0.34710476f, -0.18159218f, 0.05628259f, 0.16732438f, 0.01348090f, -0.11791564f, 0.07905474f, -0.32620275f, 
    -0.10461285f, -0.01787775f, 0.04244154f, 0.13383062f, 0.15035029f, 0.05388226f, -0.00848672f, 0.14225960f, 
    0.02527243f, -0.14513759f, 0.36138809f, 0.12268022f, 0.11032439f, -0.00880088f, 0.14676017f, -0.03526064f, 
    0.27487153f, 0.04337667f, -0.26355511f, 0.12843643f, 0.13047643f, 0.02644714f, 0.08694895f, 0.56457460f, 
    0.38207397f, 0.11321580f, -0.06367533f, -0.26080841f, 0.06547513f, 0.11431767f, -0.17253233f, 0.28731647f, 
    0.20874560f, 0.11656158f, 0.13713974f, 0.09173185f, -0.01717371f, 0.09132597f, 0.15726602f, 0.07609463f, 
    0.15566507f, 0.12552963f, -0.13042313f, -0.18304707f, -0.02267617f, -0.14477856f, -0.05168842f, 0.12833767f, 
    -0.35622051f, -0.34790394f, 0.02772108f, 0.40206531f, 0.35860667f, 0.16054252f, 0.05607228f, -0.01806937f, 
    -0.11273967f, -0.12971933f, -0.01307709f, -0.22789058f, 0.16812795f, -0.22458205f, 0.30285868f, -0.05988102f, 
    -0.01373563f, 0.08291265f, -0.06229947f, 0.13142866f, -0.14493819f, -0.14493802f, -0.36043170f, 0.01650669f, 
    0.06601335f, 0.09630936f, -0.22331919f, -0.19277719f, 0.35760039f, -0.08491761f, -0.06081298f, 0.13614127f, 
    0.38031325f, 0.07545169f, 0.39235219f, 0.04265824f, -0.25494626f, 0.13988043f, -0.24199742f, -0.37569255f, 
    0.36857343f, -0.14040877f, -0.00817510f, 0.33745277f, 0.03249719f, 0.10763779f, 0.14035335f, 0.01876167f, 
    -0.09194573f, -0.04858775f, 0.14834513f, -0.07707005f, 0.01176232f, -0.11464845f, 0.07167812f, 0.04815423f, 
    0.01175403f, -0.14603345f, 0.15825215f, 0.52979904f, -0.06828288f, 0.13772961f, 0.29016009f, -0.13689300f, 
    -0.05377270f, 0.29750693f, -0.09753334f, 0.07709131f, -0.19808023f, -0.11880937f, 0.32515663f, 0.26042607f, 
    -0.36037043f, 0.06126614f, -0.05559324f, 0.02393617f, -0.16697475f, -0.25442564f, 0.20395198f, -0.04487373f, 
    -0.31025091f, -0.15884723f, 0.00610015f, 0.01092092f, 0.15956391f, -0.11399341f, -0.05036145f, -0.10171580f, 
    0.02947429f, 0.02829501f, 0.22886522f, 0.20866141f, -0.27647185f, -0.14486343f, 0.35066679f, -0.06079437f, 
    0.40155253f, 0.27835160f, 0.29085004f, -0.33545750f, -0.13108338f, -0.09228110f, 0.11442202f, -0.09786161f, 
    -0.06928600f, 0.14413358f, -0.03845706f, 0.32873496f, -0.02156793f, 0.11720776f, 0.22416651f, 0.13012391f, 
    0.23255958f, -0.01582098f, -0.05144042f, -0.09494176f, 0.06157950f, -0.02338185f, -0.05356572f, 0.14927651f, 
    0.02700705f, -0.11115532f, -0.10949880f, 0.09281786f, 0.27493095f, 0.06665762f, -0.05479667f, 0.17574802f, 
    -0.26854289f, 0.06916802f, -0.00421046f, 0.03401522f, 0.24761556f, 0.13413356f, -0.15699340f, 0.16859867f, 
    0.11152539f, 0.03842703f, -0.20360537f, -0.23456860f, -0.05792494f, 0.35476482f, 0.11367683f, 0.13352251f, 
    0.18585145f, 0.26122394f, -0.14234793f, 0.01478560f, -0.13177849f, 0.10434233f, -0.26823074f, -0.13677584f, 
    -0.00740215f, -0.00026681f, 0.03054353f, -0.18914121f, 0.29617622f, -0.08599511f, -0.03382974f, -0.06220535f, 
    0.30879232f, -0.12231584f, -0.09448627f, -0.07390627f, 0.42300525f, -0.09530924f, 0.30691916f, 0.08557818f, 
    0.41039979f, -0.12963535f, 0.08970740f, -0.24311405f, -0.14127855f, 0.42404187f, -0.28168899f, 0.19715714f, 
    0.25592861f, 0.10143531f, 0.10651047f, -0.08405551f, 0.04975344f, 0.07710330f, 0.39952800f, -0.05591200f, 
    -0.01706848f, 0.00717100f, 0.03691123f, -0.02827441f, 0.11942557f, 0.03762990f, -0.05703009f, -0.04932339f, 
    -0.30873513f, -0.17712933f, 0.18161453f, -0.05269448f, 0.35754326f, 0.05802618f, 0.14698344f, -0.52260071f, 
    -0.23115195f, 0.16179459f, -0.20266855f, -0.14414641f, -0.04452378f, 0.18218772f, 0.07857323f, 0.05420694f, 
    -0.06299960f, 0.12637746f, 0.17393802f, 0.05406313f, 0.05295124f, 0.01029923f, 0.07404143f, -0.17498672f, 
    -0.04023683f, -0.04893489f, -0.06815294f, -0.09645988f, -0.14329374f, 0.08928675f, -0.03439078f, 0.05168441f, 
    -0.14319421f, -0.13669817f, -0.12514465f, -0.20707199f, -0.11264227f, 0.08626423f, -0.09806760f, 0.05310427f, 
    -0.11203378f, -0.16975109f, -0.03201178f, 0.07586823f, -0.05619464f, 0.02281934f, 0.13361652f, -0.04165323f, 
    -0.05347135f, 0.03563124f, 0.03313142f, -0.17269011f, 0.17625833f, 0.05289510f, -0.22089830f, 0.10924590f, 
    -0.04390324f, -0.05519589f, -0.00502837f, -0.11186869f, 0.02283496f, -0.00838183f, 0.05133467f, -0.14791623f, 
    0.38257012f, 0.08102240f, 0.39484358f, -0.24718434f, -0.06178875f, -0.13111278f, -0.06508215f, -0.40100673f, 
    0.01985407f, -0.06427113f, 0.21810803f, 0.23987521f, 0.08289963f, 0.10714545f, 0.13545801f, 0.41292888f, 
    0.06969519f, -0.16554715f, -0.00723600f, -0.14500229f, 0.07908271f, 0.07457052f, -0.01899023f, 0.00192470f, 
    0.12083992f, 0.11699773f, 0.09528362f, -0.02680685f, -0.15304846f, -0.16923206f, -0.06601518f, -0.00631400f, 
    -0.01696741f, -0.14066933f, 0.05299501f, -0.00591415f, 0.03371801f, -0.08570471f, -0.11076821f, -0.10926695f, 
    -0.07927066f, 0.10788912f, -0.17246434f, -0.00600970f, -0.07345993f, -0.12184734f, -0.09556314f, 0.05898754f, 
    -0.11103404f, -0.05886180f, 0.03291751f, -0.13909502f, -0.01612358f, 0.17222583f, -0.15197438f, -0.09158836f, 
    0.14300859f, 0.08025840f, 0.02231909f, -0.06102089f, -0.16199169f, -0.10273801f, -0.14594872f, 0.11712752f, 
    0.01235289f, 0.00422619f, -0.06125510f, -0.15333878f, -0.15114734f, -0.17266485f, -0.02021434f, -0.06882584f, 
    0.08520255f, 0.12038662f, 0.04531552f, 0.11181188f, -0.14602816f, 0.06123289f, 0.02908083f, -0.14021689f, 
    0.25998911f, -0.24795721f, -0.04493051f, -0.04006064f, -0.03697741f, 0.08056892f, -0.21829137f, 0.06770789f, 
    0.13283759f, -0.09665426f, 0.34217817f, -0.03704046f, -0.04724047f, 0.02922998f, 0.02774502f, -0.04651455f, 
    -0.11017682f, 0.03438133f, 0.06592472f, 0.19334613f, 0.27662390f, -0.15349244f, -0.00394758f, 0.08339629f, 
    0.06026491f, -0.10877700f, -0.09544001f, 0.02835092f, -0.09363585f, -0.17254680f, -0.02184309f, -0.32865337f, 
    -0.05315394f, -0.17848597f, 0.16587591f, -0.15551119f, 0.05383613f, -0.13279048f, -0.18738852f, -0.13502185f, 
    -0.10865168f, 0.00775763f, -0.05630103f, -0.03410135f, -0.12598373f, -0.07791102f, -0.10568197f, 0.10871324f, 
    -0.08857550f, -0.16858168f, 0.14887851f, 0.09570136f, 0.07078134f, -0.13990353f, -0.13203244f, -0.08828813f, 
    -0.12172267f, -0.09578640f, -0.01320163f, -0.01244646f, 0.00126702f, -0.04517423f, 0.01851763f, 0.05408134f, 
    0.03769759f, -0.30425355f, -0.15481746f, 0.15811262f, -0.06632496f, -0.00185501f, -0.19284345f, 0.10401305f, 
    -0.06467775f, -0.08803132f, 0.23677914f, -0.06915281f, 0.03068488f, 0.05087500f, -0.23940001f, 0.09491510f, 
    -0.32726687f, -0.08874502f, 0.07603021f, 0.37762973f, -0.11700234f, 0.06430071f, 0.24860540f, 0.60574794f, 
    -0.10768897f, -0.08333948f, -0.00121508f, 0.14596958f, 0.07826408f, 0.09662389f, 0.26057380f, -0.09847435f, 
    0.21805485f, 0.36536482f, 0.11102489f, 0.10627419f, 0.08474812f, 0.11822588f, 0.13776384f, -0.05286722f, 
    0.12592739f, -0.08690190f, -0.32432285f, -0.03717886f, 0.32324305f, 0.12350601f, -0.01200510f, -0.02742352f, 
    0.36763000f, 0.18895604f, 0.00250002f, -0.09901940f, -0.06685932f, 0.07911278f, -0.01114357f, -0.29377511f, 
    0.48804924f, -0.13274649f, 0.03489250f, 0.12922677f, -0.06748299f, -0.09290797f, -0.35842180f, 0.04715709f, 
    -0.08026553f, -0.02059462f, -0.14755243f, 0.00441391f, -0.16173013f, -0.13455699f, -0.08808118f, -0.08293398f, 
    -0.12040398f, -0.13333857f, -0.11079873f, 0.04205168f, 0.01772372f, -0.11641381f, 0.12294137f, -0.11912505f, 
    0.01783680f, -0.06861534f, -0.07445934f, -0.08484017f, 0.09391272f, 0.13492194f, 0.06813946f, -0.06560218f, 
    -0.17080292f, 0.09673726f, 0.05660503f, -0.09514760f, 0.02692558f, -0.16107488f, -0.14732441f, -0.04182088f, 
    0.08963867f, -0.18289356f, 0.05109237f, 0.08410639f, 0.00062171f, 0.07172783f, -0.06323960f, 0.00003772f, 
    -0.15526868f, -0.12953916f, 0.06594488f, -0.10127117f, -0.01535831f, -0.09324113f, -0.13896762f, 0.10420739f, 
    -0.05920078f, -0.04888832f, 0.05345434f, -0.12204525f, 0.10258764f, 0.10959293f, -0.15692674f, -0.03988923f, 
    -0.17454618f, 0.13940765f, -0.08026192f, 0.10801593f, 0.00735593f, 0.14357023f, -0.06312516f, -0.14355740f, 
    0.16944191f, 0.21065386f, 0.15038064f, 0.11546157f, -0.01333367f, 0.17249069f, 0.06819122f, -0.10764440f, 
    -0.01569263f, -0.11612480f, 0.13812435f, 0.19821931f, 0.29486609f, 0.00691491f, 0.26965237f, -0.04636555f, 
    -0.17999521f, -0.26334810f, -0.00489410f, 0.13875136f, 0.10670895f, 0.13266471f, -0.33196911f, 0.32027733f, 
    0.00412601f, 0.06868413f, 0.26332387f, -0.05708807f, -0.14172441f, 0.30772474f, -0.18852443f, -0.25451303f, 
    -0.07689251f, 0.15415092f, -0.13428199f, -0.16199417f, -0.00311642f, 0.14093414f, -0.04796230f, -0.01493072f, 
    0.06892367f, 0.12400091f, 0.01007386f, -0.16162401f, -0.11201006f, 0.17551614f, -0.01614740f, 0.05438566f, 
    0.15260229f, 0.03750164f, 0.02529364f, -0.03917078f, -0.12229122f, -0.02914307f, -0.05061765f, -0.03582225f, 
    -0.02742637f, -0.09504381f, -0.15703398f, -0.08771452f, -0.12116249f, 0.15344016f, -0.07824501f, -0.04223600f, 
    -0.21758005f, 0.21767853f, -0.12374406f, -0.07590385f, -0.14456266f, 0.09150796f, -0.13308291f, 0.02041978f, 
    -0.03608166f, -0.02646968f, 0.12378919f, 0.23124206f, 0.17573972f, -0.12096444f, 0.35942429f, -0.04505655f, 
    0.17504883f, -0.05553272f, -0.02887770f, -0.14007615f, 0.27869958f, 0.17671584f, -0.17751245f, 0.25495443f, 
    0.30562454f, 0.13199753f, -0.10664544f, -0.32251930f, 0.15827060f, 0.35540006f, 0.09036031f, 0.41890621f, 
    -0.00854090f, -0.24848090f, -0.17894091f, 0.02708047f, 0.13859023f, -0.05010692f, -0.21138456f, 0.11438551f, 
    -0.13097192f, -0.15470861f, 0.29975784f, -0.20548478f, 0.25806302f, 0.12371724f, -0.22828244f, 0.17012185f, 
    0.30953255f, -0.05849157f, 0.20241201f, 0.23352334f, 0.00927785f, 0.04506784f, -0.28732949f, 0.44611385f, 
    0.13474816f, -0.02378273f, 0.03858846f, -0.09198549f, 0.06979842f, 0.17332834f, 0.31759012f, 0.22543316f, 
    0.21009952f, 0.13020171f, -0.10931581f, -0.14779469f, -0.12386627f, 0.00827325f, 0.30845356f, -0.12634337f, 
    0.08336630f, 0.17844106f, -0.06607647f, -0.22060144f, -0.05050634f, 0.04320352f, 0.00447615f, -0.02853957f, 
    -0.15923563f, -0.15937094f, -0.00455954f, -0.10228039f, 0.31551775f, 0.01605660f, 0.37511194f, -0.35578287f, 
    0.12776409f, 0.06195208f, -0.03242445f, -0.20040841f, 0.17112269f, -0.26506665f, 0.33542147f, 0.05398143f, 
    0.17478314f, -0.12656888f, -0.15156634f, -0.09591883f, -0.16594122f, 0.04883612f, 0.31546062f, -0.10263789f, 
    -0.12356117f, -0.13884617f, 0.06504058f, 0.38220900f, -0.05983082f, 0.01603106f, -0.11996508f, 0.14579906f, 
    -0.28095627f, -0.01988445f, -0.19692756f, 0.37880066f, 0.14580484f, 0.02436720f, 0.14606993f, 0.40888652f, 
    -0.38593203f, -0.12252098f, 0.11176372f, 0.16950513f, 0.04379464f, -0.25304192f, 0.05507936f, -0.07967236f, 
    0.07537591f, 0.27035207f, -0.15441370f, -0.15010367f, -0.07436450f, -0.02386359f, -0.00878252f, -0.10522442f, 
    0.06679659f, -0.02991898f, -0.12428378f, 0.40002930f, -0.17870116f, -0.13377416f, 0.21885310f, 0.03725454f, 
    0.20712821f, 0.26616755f, -0.32322010f, 0.07073421f, -0.04331318f, 0.09398597f, 0.20551284f, 0.25863275f, 
    -0.12860976f, -0.15873580f, 0.20404713f, 0.35176206f, 0.07179263f, 0.05821580f, -0.29802063f, -0.17840137f, 
    0.11527142f, 0.03438147f, 0.01023648f, -0.05709996f, 0.08661612f, -0.14461353f, -0.34507978f, 0.15615182f, 
    0.14997178f, -0.02574751f, -0.06948534f, 0.44948146f, 0.17221783f, 0.03290851f, -0.01057847f, -0.03936155f, 
    -0.12759054f, 0.11640879f, -0.19920194f, 0.15560912f, 0.27212262f, 0.11830123f, 0.33776757f, 0.02907424f, 
    -0.05255254f, 0.05515883f, -0.09878872f, 0.17127976f, 0.06743322f, -0.18532136f, -0.32577702f, 0.01667846f, 
    0.08396807f, -0.12683216f, -0.09245550f, -0.14758001f, -0.13496920f, -0.02564581f, -0.13182032f, 0.04782605f, 
    -0.09221353f, -0.05992938f, -0.11237856f, -0.14847356f, 0.05879262f, -0.05114863f, 0.01941275f, -0.01876184f, 
    -0.05095457f, -0.13033544f, -0.10282362f, -0.15238903f, 0.08042980f, 0.12374409f, -0.01553645f, -0.01698783f, 
    0.09801953f, -0.03840145f, 0.02580704f, -0.10934991f, 0.11077949f, 0.02651835f, -0.12988040f, -0.05380382f, 
    -0.11298186f, -0.00461396f, 0.12023493f, 0.15038216f, 0.14848332f, -0.15245026f, 0.00115728f, -0.06307027f, 
    -0.09393729f, -0.14501542f, 0.01212091f, 0.10257650f, -0.13479269f, -0.16242877f, -0.00435249f, -0.06213109f, 
    -0.06006672f, 0.10084183f, 0.04344323f, -0.08870553f, -0.06046043f, -0.16609903f, -0.06435961f, -0.12809995f, 
    0.08041400f, -0.03310934f, -0.18245068f, -0.06467272f, -0.12339950f, -0.15387185f, -0.14426461f, 0.03204789f, 
    0.22741286f, -0.05708854f, 0.15384352f, 0.05296375f, -0.09820919f, -0.04413673f, 0.04415162f, -0.17613433f, 
    -0.15508880f, -0.16585025f, 0.42434242f, -0.03045140f, -0.27418956f, 0.08773105f, 0.01366548f, -0.10123587f, 
    -0.20581077f, 0.06666190f, 0.09894154f, 0.07653694f, -0.07087775f, 0.11085418f, 0.00026835f, 0.26432616f, 
    -0.39904869f, 0.17046581f, 0.19692104f, 0.17442164f, -0.13538286f, -0.24358785f, 0.34924817f, 0.10888147f, 
    0.04526855f, 0.26091659f, 0.03859104f, 0.15025036f, -0.10071633f, 0.01050447f, 0.25051537f, 0.12258247f, 
    0.08179829f, -0.00992745f, 0.32868090f, 0.23818016f, -0.21610226f, 0.00430597f, 0.20133859f, 0.11024317f, 
    0.34360150f, 0.30722347f, -0.00182074f, -0.06563453f, -0.34903160f, 0.07169853f, -0.18020734f, -0.08753575f, 
    -0.17806263f, -0.01327138f, 0.09191824f, 0.19864762f, 0.06222057f, -0.06473573f, -0.09898452f, 0.12431533f, 
    -0.01715700f, -0.35648808f, 0.06701631f, -0.12871677f, -0.08243184f, 0.03799249f, 0.05431580f, -0.01246797f, 
    -0.17839387f, -0.16007221f, 0.00071808f, 0.37838602f, -0.16611998f, 0.00758066f, 0.29685965f, 0.14342800f, 
    -0.12013765f, 0.31713280f, -0.08657458f, 0.11993308f, -0.17113754f, -0.13599643f, -0.10943779f, 0.46325493f, 
    0.14012571f, 0.14888628f, -0.28826052f, -0.02285847f, 0.05036859f, 0.00690704f, 0.17405990f, 0.10872699f, 
    -0.06454281f, -0.31320813f, 0.16092080f, 0.09673158f, 0.16131027f, -0.17400883f, -0.10058984f, 0.15422222f, 
    -0.02528844f, 0.11380683f, -0.51817667f, -0.03580664f, 0.18841964f, 0.05976502f, 0.16872387f, -0.05427338f, 
    0.07612498f, 0.10317398f, 0.04369251f, 0.05540544f, 0.02974704f, -0.11969213f, -0.07436519f, 0.38730356f, 
    0.17338273f, 0.09952670f, -0.18072905f, -0.08691284f, 0.00326880f, 0.23056737f, 0.23032765f, 0.17778610f, 
    0.05289075f, -0.18907543f, 0.06092909f, 0.02144749f, -0.03308108f, 0.14447303f, 0.22139947f, 0.02053868f, 
    -0.06005620f, 0.07041109f, -0.43945798f, -0.22086728f, 0.11838368f, 0.04410439f, 0.25005114f, -0.16449431f, 
    0.16173892f, 0.08073439f, 0.06119655f, 0.11054846f, 0.08422627f, -0.07487613f, 0.09151509f, 0.08881979f, 
    0.13764872f, 0.14715257f, -0.21659485f, -0.44289511f, 0.09788766f, 0.25692856f, 0.30850738f, 0.31847182f, 
    0.35978457f, 0.09094563f, -0.13289343f, -0.08945421f, 0.02198547f, 0.02204590f, 0.14249036f, -0.19142006f, 
    0.14333481f, 0.13939328f, -0.16079998f, 0.14492677f, -0.05449534f, 0.13864695f, -0.28278658f, -0.10134857f, 
    -0.11623628f, -0.08084051f, 0.14730127f, -0.07634541f, 0.12284000f, -0.03729446f, 0.20027746f, -0.03770347f, 
    -0.52894884f, 0.01049143f, 0.21625838f, 0.12266100f, -0.05421881f, -0.27645776f, 0.22941671f, -0.05583976f, 
    0.01392571f, -0.22149278f, 0.10842148f, 0.02633177f, -0.06406464f, -0.12503076f, 0.20029904f, -0.13809508f, 
    -0.01755710f, 0.06600589f, 0.19355640f, 0.20973219f, 0.03175210f, 0.13027439f, -0.13749737f, 0.12810442f, 
    -0.13034457f, -0.00666571f, -0.13429420f, 0.18680368f, -0.19055906f, 0.07168914f, -0.37057722f, 0.42960876f, 
    0.00671281f, -0.02506391f, 0.19584425f, 0.32964477f, -0.13024080f, 0.18835168f, 0.09015299f, 0.24387303f, 
    0.09278242f, -0.01141497f, -0.09622365f, -0.15307248f, -0.12135638f, -0.07533149f, 0.15024307f, -0.10289118f, 
    0.13997172f, 0.13083877f, -0.38572130f, -0.00832684f, 0.10562734f, -0.09406684f, -0.21959710f, 0.02006173f, 
    -0.44771910f, 0.17618418f, -0.12851873f, 0.10472813f, 0.08406326f, 0.06961749f, -0.02202610f, 0.00499298f, 
    -0.24465865f, -0.10341930f, 0.13088816f, -0.37925431f, -0.08283078f, 0.09267788f, -0.15344022f, 0.17933056f, 
    -0.27133375f, -0.15945366f, -0.11113485f, 0.06553387f, -0.15749660f, 0.05258757f, -0.28898758f, 0.10765126f, 
    0.01640508f, -0.10573413f, 0.27652577f, 0.03411270f, -0.22485630f, -0.10060825f, 0.04828034f, 0.18041524f, 
    0.25223735f, -0.01498933f, 0.24609572f, 0.17433758f, 0.06130877f, -0.01426282f, 0.05842686f, 0.50431895f, 
    0.24089620f, -0.16395754f, -0.13284308f, -0.00636558f, 0.09106223f, 0.13382320f, 0.38163167f, 0.11543323f, 
    0.34837133f, -0.26651523f, -0.06759905f, -0.03386433f, 0.06722549f, 0.16259119f, 0.03710143f, -0.03914176f, 
    0.04100800f, 0.09247333f, -0.05697164f, -0.27582446f, 0.05863912f, -0.17513981f, -0.32099324f, 0.06052119f, 
    -0.44041607f, 0.04408018f, 0.34310773f, 0.33795303f, -0.15633045f, 0.08006105f, -0.19544536f, 0.25531933f, 
    -0.12229654f, -0.06424470f, 0.10429459f, 0.03408548f, -0.17302740f, 0.29146612f, 0.36238417f, -0.10963079f, 
    -0.15297951f, 0.25855055f, 0.07933797f, 0.05356994f, -0.05502757f, -0.16214016f, 0.19500999f, 0.04092970f, 
    -0.15954116f, -0.08998332f, -0.23444973f, 0.04233842f, 0.04426742f, -0.06668275f, 0.16336706f, -0.08828656f, 
    0.29736716f, 0.31141344f, -0.11523592f, -0.00524669f, -0.24870652f, -0.16901891f, 0.02917669f, -0.26872852f, 
    -0.00126019f, 0.05668185f, 0.25380108f, 0.36133072f, 0.04719592f, -0.01814858f, -0.22685769f, 0.07815180f, 
    -0.01640254f, -0.22146282f, 0.05935302f, 0.12254439f, 0.09462716f, 0.03165209f, 0.00540527f, -0.01234774f, 
    -0.07657342f, -0.17221092f, -0.04528571f, -0.23685995f, -0.06440511f, 0.16425341f, -0.03740878f, 0.16180789f, 
    0.50899953f, 0.01927276f, 0.10467795f, 0.24317767f, -0.41997102f, -0.13818592f, -0.01013252f, 0.26818511f, 
    -0.33076698f, -0.13443333f, 0.13734168f, 0.01184128f, -0.11402326f, -0.43214375f, 0.41103742f, -0.02470510f, 
    0.21647012f, 0.19733514f, -0.05528361f, -0.06399217f, -0.11790179f, -0.06234186f, 0.03892456f, 0.08480849f, 
    0.02111172f, 0.08053791f, 0.38317952f, 0.19858986f, 0.19059719f, 0.01896439f, 0.02857530f, 0.09467767f, 
    0.18722717f, 0.04160988f, -0.04261260f, -0.15346287f, 0.14930893f, -0.11940465f, -0.52308768f, 0.03048460f, 
    0.25266302f, 0.00972317f, 0.09790730f, 0.21440281f, 0.05624202f, 0.44160181f, -0.15857781f, 0.37736261f, 
    -0.00360157f, 0.12334475f, -0.09040705f, 0.14718384f, 0.15323420f, -0.02991655f, -0.15205072f, 0.17086199f, 
    -0.07979633f, 0.02652973f, -0.06726047f, 0.00400142f, -0.13553262f, -0.08182219f, -0.18217547f, 0.13479692f, 
    0.02099272f, -0.12589577f, -0.09767628f, -0.13693452f, 0.11704632f, -0.05234287f, -0.00528148f, -0.02580130f, 
    0.15129146f, 0.08091592f, -0.11477473f, -0.06449155f, 0.14116773f, 0.02387886f, -0.16220085f, 0.16511199f, 
    0.18563758f, -0.17102985f, 0.08541792f, -0.00292396f, -0.03435718f, -0.16920306f, 0.06444526f, 0.10767637f, 
    0.13869956f, -0.14101990f, -0.15574427f, 0.34194258f, 0.05468351f, -0.13188313f, 0.12179350f, 0.05433258f, 
    -0.39703226f, 0.21233957f, -0.04892706f, 0.11932214f, -0.08421101f, 0.08294504f, 0.19976369f, 0.38246238f, 
    -0.14670974f, 0.10133320f, -0.00877315f, 0.17554602f, 0.06048342f, 0.03239074f, 0.02098973f, -0.16992556f, 
    0.14819138f, -0.09197180f, 0.03995360f, 0.13083231f, 0.07588670f, 0.14292778f, 0.33319187f, -0.01695203f, 
    0.09673554f, 0.03715271f, -0.23322932f, -0.20509751f, -0.15333682f, -0.11924095f, -0.07781648f, -0.03718541f, 
    0.37967139f, -0.04379861f, -0.02867855f, 0.34006917f, 0.11575273f, -0.05169855f, 0.26497391f, 0.02478025f, 
    0.06383942f, -0.11156097f, 0.15002371f, 0.10565835f, 0.09000035f, -0.22783919f, 0.06479314f, -0.31282142f, 
    0.07855514f, 0.19512366f, -0.06407123f, 0.16026528f, -0.08242057f, 0.15994720f, -0.27095616f, -0.16509733f, 
    -0.03529086f, -0.17055602f, 0.36465132f, -0.03200684f, 0.09735361f, 0.12903602f, -0.32356170f, -0.13922392f, 
    0.13222496f, -0.27393097f, 0.13097364f, 0.03769048f, 0.35031521f, 0.14119570f, 0.15256564f, -0.12395860f, 
    0.17321928f, 0.14797309f, 0.25968766f, 0.03146935f, -0.09835710f, -0.01493521f, 0.21206142f, 0.11910657f, 
    -0.01879201f, -0.17576656f, 0.03229143f, 0.12521838f, 0.02498113f, 0.16686112f, -0.24832928f, 0.08897898f, 
    -0.14667463f, -0.15435345f, 0.01117774f, -0.22798258f, -0.15560970f, 0.06015996f, -0.11025016f, 0.04064078f, 
    0.48245001f, 0.03616177f, 0.11329580f, 0.24384145f, -0.00595224f, 0.13371260f, 0.25903013f, 0.43659416f, 
    0.25533760f, -0.01209199f, 0.27981099f, 0.03486382f, -0.07894822f, 0.03150315f, -0.13376839f, -0.17305160f, 
    -0.03319806f, -0.00105432f, -0.16333322f, 0.04301412f, 0.03170756f, 0.11582603f, 0.08422352f, -0.08409601f, 
    0.16852871f, -0.15072839f, 0.32260111f, -0.18389457f, 0.25845191f, -0.05157489f, 0.07695508f, -0.05852884f, 
    0.23714738f, 0.24649011f, 0.24450049f, -0.15247035f, -0.24944866f, -0.09232240f, -0.14513227f, 0.13030320f, 
    0.16694772f, -0.10502667f, -0.23707506f, -0.02376110f, -0.16299938f, -0.07982659f, -0.17990598f, 0.18042409f, 
    0.02404321f, -0.10252820f, 0.02708980f, -0.13023773f, -0.12221871f, -0.14753056f, 0.16829407f, -0.15589546f, 
    -0.06073315f, -0.00954432f, -0.18251844f, -0.04024960f, -0.17519461f, -0.11784891f, 0.23788375f, 0.00581835f, 
    -0.29400116f, 0.17817210f, 0.05900860f, 0.07562859f, -0.16716823f, -0.10396555f, 0.46354893f, -0.24814521f, 
    -0.35286459f, -0.11712845f, -0.12135037f, 0.21263064f, 0.07716163f, -0.32221925f, 0.09570451f, 0.20535657f, 
    0.15820146f, 0.22728093f, -0.15249808f, 0.07363458f, 0.13863732f, -0.08602231f, -0.25843433f, 0.05616640f, 
    0.16308521f, 0.14769489f, 0.22730020f, -0.21458670f, -0.03193944f, 0.02520061f, 0.02236085f, 0.17427225f, 
    0.19744821f, -0.16975470f, 0.09551687f, 0.20123385f, 0.43618965f, -0.05571138f, -0.08842527f, 0.03622445f, 
    0.07147987f, -0.10832049f, 0.29266006f, 0.14340414f, -0.03140808f, 0.35439405f, -0.25031525f, 0.06188426f, 
    0.08024929f, 0.24561976f, -0.04229503f, 0.09489268f, -0.08056495f, 0.17721753f, 0.02780967f, 0.03309613f, 
    -0.17118874f, -0.06107775f, 0.26732931f, -0.11301112f, -0.28204504f, 0.08444205f, -0.00821852f, -0.10027621f, 
    0.28980038f, 0.36131191f, -0.14175309f, -0.12184276f, 0.22104047f, -0.10775162f, 0.28433147f, 0.07132528f, 
    0.00895776f, 0.07739201f, -0.16459152f, -0.21147859f, 0.03012168f, -0.08593853f, -0.32528135f, 0.24907406f, 
    -0.05715733f, 0.32768440f, -0.13158111f, -0.06081229f, -0.12717605f, -0.10173991f, 0.06429958f, 0.09909493f, 
    -0.09780791f, 0.08386171f, -0.41227949f, -0.35047987f, 0.23184952f, -0.07372689f, 0.12034419f, 0.01745777f, 
    0.58111173f, -0.01789900f, -0.00234213f, 0.20521463f, -0.04832154f, -0.00101511f, 0.15033260f, -0.37114638f, 
    0.29277018f, -0.10037062f, 0.27799192f, -0.10530806f, -0.10338894f, -0.31213760f, -0.09847002f, -0.12007716f, 
    0.23083144f, -0.04567314f, 0.12075870f, 0.01689252f, -0.00561777f, -0.01253070f, 0.01145972f, -0.12029855f, 
    -0.09032965f, 0.05932423f, 0.13346572f, -0.11441286f, 0.09640868f, 0.01901694f, -0.43504059f, 0.01681107f, 
    -0.17822737f, -0.20727292f, 0.16957912f, 0.38704512f, 0.26230714f, -0.00200568f, -0.08938743f, 0.18291019f, 
    -0.19164008f, -0.01158081f, 0.27302918f, 0.13486505f, -0.16536938f, 0.04302010f, 0.19221662f, -0.27010950f, 
    0.22125654f, -0.22966915f, -0.15009992f, 0.09226900f, -0.15532169f, -0.08330242f, 0.17732437f, -0.12056717f, 
    0.10941195f, 0.02913577f, 0.11002382f, -0.35366905f, -0.30469713f, 0.04195191f, -0.18176056f, -0.12327382f, 
    0.19890027f, -0.06026124f, -0.07663124f, 0.35457024f, 0.38441223f, -0.00156416f, 0.11743508f, 0.42014340f, 
    0.16368833f, -0.10063718f, 0.13739473f, -0.49568546f, -0.06763209f, -0.07284109f, 0.13420255f, -0.01908767f, 
    0.18087094f, 0.20704675f, -0.09231926f, 0.09282386f, -0.10764817f, 0.06494585f, 0.24599227f, -0.15469611f, 
    -0.01860763f, -0.11213938f, -0.08113857f, 0.04233672f, 0.29287112f, -0.13404606f, 0.21489209f, -0.05142116f, 
    -0.42956027f, 0.21717362f, -0.01310547f, -0.14003308f, -0.08451129f, -0.14061603f, -0.07583699f, -0.22326581f, 
    0.01457680f, 0.15626302f, -0.17383274f, 0.30117282f, 0.01439199f, 0.32991165f, -0.29657394f, 0.25097427f, 
    -0.11226495f, -0.05121611f, 0.01174569f, -0.03698630f, -0.05437287f, 0.06570623f, 0.04457618f, -0.14594491f, 
    -0.15011641f, 0.07273528f, 0.08898234f, -0.17150004f, -0.02869464f, 0.08205140f, -0.10148504f, 0.15278706f, 
    -0.03409001f, -0.08845111f, -0.00386055f, -0.03501116f, -0.03310607f, -0.02179723f, -0.11060007f, 0.08073238f, 
    -0.15859836f, 0.00058780f, -0.13040063f, -0.01179759f, 0.06812756f, 0.00120523f, 0.13561824f, -0.14577089f, 
    -0.02704947f, 0.08217286f, 0.05307868f, -0.08921493f, 0.09168130f, -0.16154964f, -0.19461973f, -0.07236961f, 
    0.13293219f, 0.10227203f, 0.03604656f, -0.11446440f, -0.03342530f, -0.17126623f, 0.08529311f, -0.06192826f, 
    -0.08883583f, -0.04001125f, -0.13694029f, -0.08307681f, -0.02527391f, -0.01061272f, 0.13332459f, -0.04983043f, 
    0.03492890f, -0.13578373f, -0.05692678f, -0.17503546f, -0.16822727f, 0.07299594f, 0.05050075f, -0.18801422f, 
    0.08249374f, -0.18514188f, -0.10951074f, 0.04721399f, -0.03113925f, -0.04014129f, 0.31399283f, 0.02409799f, 
    0.15104403f, -0.11202881f, 0.20687672f, -0.12849604f, -0.13246098f, 0.07714717f, 0.21986000f, -0.05534128f, 
    -0.21234801f, 0.16516285f, -0.00816422f, 0.19638529f, 0.32725507f, 0.03993123f, 0.10786136f, 0.15965731f, 
    -0.27476159f, -0.16268885f, -0.22351104f, -0.26846328f, 0.01830221f, -0.27175760f, 0.10836694f, 0.25693488f, 
    -0.07207765f, -0.08622766f, -0.04534611f, 0.05758193f, 0.01696220f, -0.01672310f, -0.04688090f, 0.04389593f, 
    -0.08876177f, 0.02501367f, 0.09262043f, -0.14554627f, 0.01335820f, -0.14568987f, -0.11281079f, 0.16959380f, 
    -0.04033048f, -0.18343195f, -0.11425927f, -0.06986134f, -0.19242452f, 0.13033924f, -0.11226507f, 0.03049509f, 
    0.08883829f, 0.02912702f, -0.11045505f, 0.00772540f, -0.10094266f, 0.10451374f, 0.11159179f, -0.00360153f, 
    0.32805321f, 0.23452821f, -0.06972799f, 0.17692320f, -0.13515495f, 0.06374380f, 0.05728988f, 0.09954253f, 
    0.11369321f, 0.16172971f, 0.18057407f, 0.30646360f, 0.04089159f, -0.13992743f, -0.04952941f, 0.11917151f, 
    -0.32903314f, -0.01778310f, -0.00462514f, 0.20447293f, 0.41388792f, 0.18025784f, 0.02696321f, 0.00602420f, 
    -0.00730400f, -0.01841827f, -0.02231485f, 0.00513887f, -0.06718623f, 0.25345284f, -0.32786697f, 0.16611844f, 
    0.05886126f, 0.16082293f, 0.15636180f, 0.09010922f, -0.02505319f, -0.01843375f, 0.05016365f, 0.13460679f, 
    -0.02640329f, 0.10147804f, 0.37622592f, 0.20389897f, 0.08783434f, -0.00484196f, 0.16372912f, -0.05783420f, 
    -0.32453245f, 0.37856984f, 0.10458259f, -0.21284463f, -0.14419898f, -0.11256266f, -0.15146904f, -0.00811998f, 
    -0.35523477f, 0.16011998f, -0.15303005f, 0.47072449f, 0.09522912f, 0.08240683f, 0.17139350f, 0.25738776f, 
    -0.00572855f, 0.15872093f, -0.07151373f, -0.15226676f, 0.04325950f, 0.12005868f, 0.44761914f, 0.11673612f, 
    -0.12185256f, 0.11017530f, -0.22451198f, 0.07066108f, -0.10876463f, 0.09559429f, 0.08817758f, -0.03663345f, 
    0.21830598f, 0.15011294f, 0.09314031f, -0.10302663f, -0.06831090f, 0.16105141f, 0.27681631f, -0.05739711f, 
    0.13433890f, 0.03007973f, -0.24842405f, -0.19594635f, 0.12311935f, -0.31822115f, 0.04363245f, 0.20861240f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07030863f, -0.09559892f, 0.20153871f, 0.16344716f, -0.01405715f, 0.08604336f, 0.29533991f, -0.03539540f, 
    0.04493015f, 0.18769892f, -0.14334875f, -0.15493649f, 0.27852893f, -0.02518296f, 0.05211584f, 0.15810716f, 
    0.19577686f, -0.02412837f, 0.00918559f, 0.18835349f, 0.07102166f, 0.11939798f, -0.06965156f, -0.20576778f, 
    -0.14820716f, 0.26591799f, 0.13235059f, -0.07365713f, 0.03673970f, -0.16400278f, 0.13526870f, 0.00969335f, 
    0.06951648f, 0.17541930f, 0.14659537f, 0.05724777f, -0.02537323f, -0.15800303f, -0.04062755f, 0.02153395f, 
    -0.14887555f, -0.02836720f, 0.37301207f, -0.03510189f, -0.06592460f, -0.09181832f, 0.27764884f, 0.35896763f, 
    0.17220999f, 0.23158577f, -0.10317055f, 0.24430865f, 0.28398839f, -0.16278413f, -0.16876978f, -0.00490228f, 
    0.02651059f, -0.08549465f, 0.00912905f, -0.17974202f, -0.15469193f, -0.09825578f, -0.11874781f, 0.03764538f, 
    0.04697418f, 0.07211826f, 0.14698806f, 0.06046871f, 0.11866223f, 0.09795637f, -0.05749631f, -0.02269761f, 
    -0.02435774f, 0.18960766f, 0.20343749f, -0.13434994f, 0.11248454f, -0.18632232f, 0.02943526f, 0.12335673f, 
    -0.15257676f, -0.00505262f, -0.00592024f, -0.01538341f, -0.04214562f, -0.06702796f, -0.06778637f, -0.01685538f, 
    -0.00286460f, -0.01975302f, 0.03169833f, -0.05513338f, -0.07966967f, -0.06727421f, -0.07274373f, -0.09291788f, 
    -0.10008777f, -0.03257450f, 0.09883435f, 0.28256416f, 0.04208689f, -0.09847333f, -0.01156599f, -0.07725821f, 
    0.23652737f, 0.14562376f, -0.04519106f, -0.10951840f, -0.14767548f, -0.07412893f, 0.09448897f, 0.14774404f, 
    0.08533318f, 0.24092649f, 0.31022581f, 0.23067854f, 0.12947671f, -0.04791839f, -0.00394478f, 0.20718747f, 
    0.07833926f, -0.00058466f, 0.00972404f, 0.21881418f, -0.06176111f, 0.15330547f, 0.04750632f, 0.04801634f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.03166353f, -0.43797770f, -0.05250677f, 0.15750895f, 0.22722420f, 0.11791784f, -0.04928773f, -0.28313151f, 
    0.08141229f, 0.23541965f, -0.05968717f, -0.49094391f, 0.13675053f, -0.09784756f, 0.00732497f, -0.60079968f, 
    0.31260780f, -0.07579663f, 0.12347294f, -0.48594829f, -0.26521111f, -0.18449745f, -0.09287365f, -0.10912626f, 
    0.00116781f, -0.44751251f, 0.18496692f, 0.21379030f, -0.00627261f, 0.03902809f, -0.00572969f, 0.04366986f, 
    0.12260954f, -0.25602627f, -0.14372991f, -0.41392320f, -0.36632603f, -0.69269729f, -0.34157875f, 0.28012592f, 
    -0.05292566f, 0.11792602f, 0.12166914f, -0.06096744f, -0.05883593f, -0.07231821f, -0.37151778f, 0.02401191f, 
    -0.37584120f, 0.01429213f, 0.04972279f, 0.26958171f, 0.24985681f, -0.06995222f, 0.28555143f, 0.20559870f, 
    -0.28681540f, -0.52154350f, 0.34361291f, -0.02992887f, -0.05566056f, -0.50134003f, -0.43698668f, 0.03062551f, 
    -0.04310549f, -0.38697365f, 0.14319550f, 0.04729584f, -0.35633242f, -0.07025906f, 0.21200302f, 0.06279621f, 
    -0.36720502f, 0.15962377f, -0.01820778f, 0.00910123f, 0.03648414f, -0.03462959f, 0.00493200f, -0.24950309f, 
    0.01236521f, -0.14821993f, 0.27453846f, -0.00285658f, -0.01233438f, -0.44197735f, -0.08415391f, -0.25651640f, 
    -0.59309351f, -0.08468010f, -0.00174800f, 0.33635682f, 0.39548540f, -0.08254456f, -0.04702842f, -0.24951555f, 
    0.14023910f, -0.11064198f, -0.23004255f, -0.13930358f, -0.02127890f, -0.32614577f, -0.30526194f, -0.28310585f, 
    -0.44619590f, 0.24547614f, -0.54805201f, -0.13025412f, -0.08926320f, 0.05897252f, 0.04700750f, -0.04989374f, 
    0.11558899f, 0.10549764f, 0.26075074f, 0.00256644f, 0.40716767f, 0.15997645f, -0.46133012f, -0.14661081f, 
    0.15376411f, 0.01178259f, -0.07808702f, -0.13081697f, 0.07597603f, 0.08630653f, 0.00179711f, 0.12898923f, 
    -0.06947228f, -0.36278778f, 0.11230969f, -0.24104650f, -0.10565326f, -0.16093893f, 0.16944183f, 0.06254357f, 
    -0.09337719f, 0.14812364f, 0.01771058f, -0.09569661f, 0.03986269f, 0.43257251f, -0.13167845f, 0.31648755f, 
    -0.09021710f, 0.28925395f, -0.21381202f, 0.15299220f, -0.27990073f, -0.57583368f, 0.05479807f, -0.43785873f, 
    -0.05749674f, -0.05627387f, -0.15395696f, -0.03547109f, 0.01204804f, -0.08345291f, 0.02266374f, 0.21511750f, 
    0.00675857f, -0.06378271f, 0.19979165f, -0.12054607f, -0.17372139f, 0.29389638f, 0.10201960f, -0.07105397f, 
    0.00838432f, 0.10015539f, 0.08654625f, -0.01947191f, -0.01345155f, 0.28485501f, -0.09049065f, 0.04393680f, 
    -0.32790461f, -0.03891522f, 0.01182613f, 0.15590316f, -0.02889255f, 0.03067976f, 0.15565981f, -0.04643075f, 
    0.20005377f, -0.00743879f, -0.14119308f, 0.19766395f, -0.05240426f, -0.12792695f, -0.00711681f, 0.04431035f, 
    0.15716235f, -0.00769362f, -0.28891784f, -0.01123414f, -0.32954141f, 0.07506522f, 0.00832816f, 0.29379699f, 
    -0.34705263f, -0.02370727f, -0.38918155f, -0.00078058f, 0.25316048f, -0.11516962f, -0.06915103f, 0.30729935f, 
    0.03764857f, -0.19423968f, -0.01303796f, 0.00403742f, 0.02593699f, 0.09961233f, 0.05175249f, 0.14063337f, 
    0.04087678f, -0.07629818f, -0.46422449f, 0.06990024f, -0.35610944f, 0.05294172f, 0.04617014f, -0.08307376f, 
    0.14683919f, -0.07486328f, 0.07529922f, 0.07567152f, -0.04072584f, -0.19436195f, -0.12782198f, 0.17738876f, 
    -0.41221547f, 0.12986150f, 0.33366817f, -0.00463190f, 0.02207022f, -0.32406119f, 0.05900656f, 0.00203036f, 
    0.16361961f, 0.06103899f, -0.06998391f, 0.13609514f, 0.07508018f, 0.18673031f, -0.35265762f, 0.04192993f, 
    -0.25520691f, -0.00179802f, 0.00398012f, -0.02622308f, -0.00605067f, -0.27350593f, -0.14289808f, 0.01775486f, 
    -0.08742595f, 0.11152507f, 0.10845789f, 0.15488638f, -0.45666927f, 0.20066859f, 0.22742677f, 0.06485630f, 
    -0.42314249f, 0.25790316f, -0.01457547f, -0.31927872f, 0.21092284f, -0.30553705f, -0.25843787f, 0.11165484f, 
    -0.30452588f, -0.02725956f, 0.02579688f, 0.11220194f, 0.23031946f, -0.02599354f, -0.37346506f, -0.38880831f, 
    -0.02154833f, -0.18940942f, 0.15614189f, -0.66773599f, -0.05293536f, -0.00206578f, 0.28076747f, 0.11085732f, 
    0.19139372f, 0.45062968f, -0.45529601f, 0.02823814f, 0.00293401f, -0.68607366f, -0.49883452f, -0.55543745f, 
    0.01996804f, 0.08032792f, -0.28555501f, 0.07398992f, -0.02359125f, 0.12760629f, 0.09835211f, 0.03371423f, 
    -0.62221640f, 0.00465987f, 0.07696458f, -0.43501404f, -0.33903942f, 0.08000728f, -0.21411516f, -0.24637672f, 
    0.11510377f, -0.30057475f, 0.25600761f, -0.00002486f, -0.07391826f, -0.47998923f, -0.14760062f, -0.08833475f, 
    -0.06450041f, 0.05857592f, -0.24828418f, 0.07664422f, 0.16310805f, 0.32001364f, -0.81158763f, -0.23070623f, 
    0.03254638f, 0.25809547f, -0.04078364f, 0.03313079f, -0.05138301f, -0.01033793f, -0.08382969f, -0.06990745f, 
    -0.08839658f, -0.23253317f, 0.39375687f, 0.04564920f, -0.08970709f, -0.08849256f, -0.03370691f, 0.06122466f, 
    0.23231256f, 0.06094929f, -0.53440785f, -0.20076865f, -0.14210546f, -0.01331307f, -0.04602798f, -0.70920581f, 
    -0.34428144f, -0.21053231f, 0.16517259f, 0.16021280f, -0.24698398f, -0.29766712f, -0.35336497f, -0.02649439f, 
    0.02398491f, -0.03633845f, -0.22656171f, -0.02170458f, -0.04758894f, -0.34698352f, 0.19531119f, 0.05450086f, 
    0.17177194f, 0.13620286f, -0.53513575f, 0.03340910f, -0.01662695f, 0.40438411f, 0.18414310f, 0.15519656f, 
    -0.33152217f, -0.07242446f, 0.01692533f, -0.35481048f, -0.02097434f, -0.15243621f, -0.73924702f, 0.15497223f, 
    -0.06290656f, 0.26385507f, -0.40367818f, 0.00527179f, 0.14350893f, -0.01409768f, -0.15667696f, 0.05338446f, 
    -0.33067274f, -0.19450057f, 0.01060572f, -0.02006954f, -0.45969135f, -0.20946968f, -0.84012789f, -0.02127015f, 
    0.07547248f, -0.08352314f, -0.06156366f, 0.04474023f, 0.15960895f, 0.26675287f, 0.11660422f, 0.17481752f, 
    -0.09599528f, -0.52571398f, -0.14015597f, -0.08734544f, -0.00016693f, 0.08483709f, -0.04109976f, -0.20632273f, 
    -0.26940793f, -0.39928809f, -0.24418503f, -0.14982428f, -0.11846597f, 0.03804891f, -0.30180660f, 0.18877326f, 
    0.04900942f, 0.15817827f, 0.00177521f, 0.25472933f, 0.06037316f, 0.06733038f, 0.28254744f, -0.17625155f, 
    -0.06596557f, -0.26787177f, -0.02082981f, -0.26142722f, 0.21500880f, 0.05715419f, -0.27292308f, 0.00419369f, 
    -0.05376945f, -0.72449154f, 0.06070668f, -0.47480386f, -0.02455768f, 0.03809918f, 0.22150216f, 0.00020258f, 
    -0.15981555f, 0.25826731f, 0.16944137f, -0.50997120f, -0.21739452f, 0.18008564f, -0.21854077f, 0.18221876f, 
    -0.19281401f, -0.21386494f, -0.04752861f, 0.05077904f, 0.14423469f, -0.05018866f, -0.08150993f, 0.17805456f, 
    -0.08302514f, 0.05985269f, -0.00297933f, -0.01560125f, -0.06765004f, 0.05270858f, -0.06537715f, -0.39751375f, 
    0.02985042f, -0.34236708f, 0.09916040f, 0.11591352f, 0.04164082f, -0.01676840f, -0.06106798f, 0.20016374f, 
    0.16913676f, -0.20120926f, -0.25449765f, -0.54922360f, 0.31946740f, 0.12024081f, -0.47606146f, -0.08875030f, 
    0.24586150f, 0.13730933f, -0.54508722f, 0.17663786f, -0.02192261f, 0.05891499f, 0.01305839f, 0.07403475f, 
    0.04491547f, -0.24469668f, -0.09834608f, 0.20745869f, -0.26612198f, -0.22714156f, 0.39032054f, -0.61275518f, 
    0.04891819f, 0.01975275f, 0.03639152f, -0.49910802f, -0.09172036f, 0.11285069f, 0.18135607f, -0.49374536f, 
    -0.09342773f, 0.10473183f, -0.07731712f, 0.17185989f, 0.25791204f, -0.03188222f, -0.04587746f, 0.54527348f, 
    0.20121893f, 0.06148794f, 0.06654903f, -0.17899545f, 0.21971580f, -0.60400367f, -0.19991527f, -0.14293292f, 
    0.16062291f, -0.47468448f, -0.16970858f, 0.07086826f, 0.19379221f, 0.26653486f, -0.02682631f, 0.06201570f, 
    0.03856895f, -0.46804386f, 0.03280097f, 0.05256252f, 0.05428899f, -0.04926998f, 0.07206701f, 0.05935954f, 
    -0.16605137f, 0.32999304f, -0.75693196f, -0.27963254f, 0.29887989f, -0.70862305f, -0.20641454f, -0.05874209f, 
    -0.03489950f, -0.19688609f, -0.08597738f, 0.04629860f, -0.00880318f, -0.06128154f, 0.48999235f, -0.18325102f, 
    -0.45591527f, -0.40876418f, -0.04967934f, -0.24189353f, -0.02672023f, -0.01883194f, 0.09143078f, -0.12327400f, 
    0.15422992f, 0.29227602f, -0.23445505f, -0.02926282f, 0.00271198f, -0.91883826f, -0.26316276f, -0.07339606f, 
    -0.13088402f, 0.09894213f, 0.06166646f, -0.09614626f, 0.19467987f, -0.18316409f, -0.23049951f, -0.47356948f, 
    -0.03399966f, -0.03405727f, 0.22749478f, -0.03683444f, -0.04046933f, -0.07122946f, -0.06746730f, -0.31295037f, 
    -0.09942827f, -0.34854391f, 0.10625629f, -0.04436244f, -0.07468407f, 0.19736966f, 0.07711515f, -0.10841101f, 
    -0.09266872f, 0.03940405f, 0.05257028f, -0.11737020f, -0.42361698f, -0.04119197f, 0.01249117f, -0.00322795f, 
    0.11765102f, -0.51566631f, -0.25355834f, 0.00730042f, 0.06946072f, 0.07387255f, 0.09020306f, -0.46780422f, 
    -0.02950919f, 0.09848971f, -0.28741491f, 0.18155886f, 0.04509465f, -0.15758671f, 0.09338000f, -0.00460750f, 
    -0.30033615f, 0.00920323f, -0.05993066f, 0.08974566f, -0.03765456f, 0.13767123f, -0.00559840f, 0.01489948f, 
    0.11183591f, -0.06009163f, 0.05842895f, 0.07588459f, -0.10133699f, 0.12388305f, -0.03702147f, -0.03517389f, 
    0.00551012f, 0.01806901f, 0.18763673f, -0.08179531f, 0.23923321f, -0.30451840f, -0.05057233f, -0.14691615f, 
    0.23346041f, -0.13787098f, 0.05893375f, 0.00425242f, -0.13962094f, 0.20045875f, 0.57593912f, 0.01515824f, 
    -0.28281096f, 0.04170443f, 0.29201570f, 0.14907281f, 0.00475384f, -0.17059906f, 0.08381328f, 0.19404083f, 
    -0.00418883f, 0.54765725f, -0.22687417f, 0.18915455f, 0.03999917f, 0.06087938f, -0.32640147f, 0.12574475f, 
    -0.05935380f, -0.42508811f, 0.32306707f, 0.03320794f, 0.06688956f, 0.05770013f, -0.11184600f, 0.02294090f, 
    -0.08285438f, -0.37206760f, 0.26517811f, -0.19153865f, 0.04738538f, -0.18475646f, -0.60806078f, 0.15608908f, 
    0.57227618f, -0.12680480f, 0.06382838f, 0.18988433f, -0.40133536f, -0.04453320f, -0.09638918f, 0.10580461f, 
    -0.04570086f, 0.06651438f, -0.42478517f, -0.08283023f, -0.07029561f, 0.22089936f, -0.28005001f, 0.06560253f, 
    0.21564348f, -0.21887720f, -0.00893525f, 0.01811024f, -0.36394432f, -0.22294101f, 0.19888981f, 0.19660054f, 
    0.02348424f, -0.36587495f, 0.03715046f, -0.00949692f, -0.05314677f, -0.09465659f, 0.04763544f, -0.38146117f, 
    -0.04387110f, -0.15141639f, -0.12484568f, -0.06333748f, 0.05784407f, -0.04940367f, -0.01970304f, 0.02165594f, 
    0.04752921f, -0.10693298f, -0.02021161f, -0.02639578f, -0.39563820f, 0.04161257f, -0.00479617f, -0.01598128f, 
    0.10644273f, 0.46200478f, 0.20723379f, 0.17658393f, -0.10677812f, 0.09778535f, -0.37023550f, -0.01838511f, 
    -0.01431653f, 0.03052887f, -0.09233638f, 0.00836986f, 0.04018667f, 0.14772576f, -0.07086565f, -0.31559870f, 
    -0.31327093f, 0.32574576f, 0.14152119f, -0.33338359f, -0.05150650f, -0.37872455f, -0.72591764f, -0.10855632f, 
    0.11861660f, -0.06803235f, 0.04232770f, 0.19860181f, -0.01300199f, -0.12230895f, 0.14380476f, 0.19153142f, 
    0.02670391f, 0.16603981f, 0.04974991f, 0.15038072f, -0.00754469f, -0.02701893f, 0.14205110f, -0.36634713f, 
    -0.09561966f, -0.08987314f, 0.04241132f, 0.09167080f, -0.37546822f, 0.29422006f, -0.24094363f, 0.14208767f, 
    -0.24205923f, 0.09090438f, -0.50560713f, 0.06943882f, -0.32794032f, 0.24515775f, -0.47555625f, 0.20309672f, 
    -0.05538647f, -0.59544903f, 0.07547648f, 0.07177845f, 0.02769672f, 0.09077644f, 0.06859899f, -0.01117637f, 
    -0.12112971f, 0.16321142f, -0.38811326f, 0.18978220f, 0.07359114f, -0.57859868f, 0.13428195f, 0.07145425f, 
    -0.02844537f, -0.31137291f, -0.03154465f, -0.21431251f, -0.07889329f, 0.29071814f, -0.07529283f, 0.00314893f, 
    -0.47174650f, -0.55110133f, 0.00021074f, -0.22200860f, -0.10050494f, 0.08198213f, -0.03754134f, 0.05765483f, 
    0.10389457f, -0.46486863f, 0.08251014f, -0.03074043f, 0.03914446f, 0.01291409f, 0.11754195f, -0.07039101f, 
    0.00865186f, 0.26350945f, 0.18500401f, -0.63316411f, 0.29223382f, 0.14302519f, 0.25076878f, 0.05543388f, 
    -0.20056909f, -0.50698894f, 0.12813236f, 0.04678969f, 0.07471294f, -0.12948364f, 0.03856798f, -0.05771267f, 
    0.06955116f, 0.14744367f, -0.32046720f, -0.05146283f, -0.08439688f, -0.82801741f, 0.06045082f, -0.41277137f, 
    -0.02752097f, 0.21593545f, 0.10445744f, -0.35413510f, -0.09733250f, 0.00821062f, -0.02206775f, 0.30539995f, 
    -0.06771607f, -0.11090618f, -0.08101917f, 0.07495561f, 0.31651026f, -0.13374233f, -0.23356628f, -0.03288262f, 
    0.29136232f, -0.12958577f, 0.47432661f, -0.43235669f, 0.07246863f, -0.00318275f, 0.08867085f, 0.03142489f, 
    -0.16721256f, -0.38702163f, 0.26830423f, -0.37628126f, -0.52144063f, -0.04576104f, 0.18994690f, 0.00071968f, 
    -0.21556947f, 0.02124664f, -0.03764415f, -0.03414752f, 0.03213590f, -0.35981983f, 0.06001418f, 0.03135530f, 
    -0.04995417f, -0.15714909f, -0.16448613f, -0.05250488f, 0.05472922f, -0.22151251f, -0.33292615f, 0.07369871f, 
    0.15630920f, 0.01944545f, 0.00508119f, 0.18336038f, -0.10009296f, -0.07665154f, 0.28072035f, -0.10448124f, 
    0.17918563f, 0.14334530f, -0.00376433f, -0.04166656f, -0.07918549f, 0.01730005f, 0.09305543f, 0.12392767f, 
    -0.04060466f, -0.27014008f, 0.20559765f, 0.18951371f, 0.05578065f, -0.06661565f, -0.26756665f, -0.28882793f, 
    -0.17133997f, -0.02224193f, 0.14728147f, 0.29670778f, -0.28893873f, 0.06514344f, 0.03914488f, -0.00330952f, 
    -0.02409517f, 0.01062279f, -0.66705418f, 0.11941330f, -0.05559649f, -0.19878267f, -0.22258966f, -0.44297945f, 
    -0.24097295f, 0.04586112f, 0.06240403f, -0.18454769f, -0.14472210f, -0.04366842f, 0.16152400f, 0.19697456f, 
    -0.45547098f, 0.39625564f, 0.06571106f, 0.12904048f, -0.05049262f, 0.19406015f, 0.05002210f, -0.03330562f, 
    -0.23668034f, -0.45638457f, 0.05128295f, 0.10322309f, -0.24712066f, -0.05147113f, 0.18948214f, -0.07687283f, 
    0.09829561f, -0.00297744f, -0.23427445f, -0.05071276f, -0.25806025f, 0.04147287f, 0.00991521f, -0.39802295f, 
    -0.11538324f, -0.29392785f, 0.19067717f, -0.01475525f, -0.08608899f, 0.17672545f, -0.05777427f, 0.24114883f, 
    -0.31902340f, -0.05545952f, 0.08876801f, 0.29058319f, 0.14378645f, -0.01535669f, -0.00102428f, -0.15158994f, 
    0.14029920f, 0.07774475f, -0.09700956f, -0.24428116f, -0.36257440f, 0.03268319f, -0.09658516f, -0.11300529f, 
    -0.59974432f, 0.12230444f, -0.41354749f, 0.19934428f, 0.03511468f, 0.15005663f, -0.21367954f, -0.10160940f, 
    -0.23332849f, -0.29334787f, -0.30146962f, -0.07383309f, -0.00447373f, -0.03205455f, -0.30462953f, -0.05480002f, 
    0.14865571f, -0.02191175f, -0.02461407f, -0.31185752f, 0.04480371f, 0.13269001f, 0.07685936f, -0.14531140f, 
    -0.00413494f, -0.03099450f, 0.11822588f, -0.50894785f, -0.24895476f, 0.06447264f, -0.29407382f, 0.07617582f, 
    0.24307157f, -0.61140501f, -0.06695051f, 0.49510825f, 0.11383686f, -0.32252088f, -0.06080167f, -0.29690364f, 
    -0.18026300f, 0.12884335f, -0.10317490f, -0.01595377f, 0.05346245f, -0.47674280f, -0.30296326f, -0.19485261f, 
    0.04566927f, -0.04172400f, -0.35635799f, -0.12558946f, -0.00691718f, -0.03101032f, 0.00054833f, -0.03449438f, 
    0.10923354f, -0.30151275f, 0.10633693f, 0.35131487f, 0.21832743f, -0.15462053f, 0.41181198f, -0.20205149f, 
    -0.04353517f, 0.07092432f, -0.29550040f, -0.39796096f, -0.06219691f, -0.02375748f, -0.50420624f, 0.11809084f, 
    -0.15320268f, 0.01863121f, -0.01624358f, 0.03062984f, 0.17599452f, -0.01977200f, -0.10699571f, -0.55249500f, 
    -0.40630198f, -0.17523783f, -0.37674737f, 0.17802122f, 0.00825528f, -0.30176386f, 0.13551629f, -0.05145787f, 
    0.10194571f, 0.21822992f, -0.53642756f, 0.15479182f, 0.02110081f, -0.26527989f, -0.02103150f, 0.16643137f, 
    0.04918640f, 0.13094944f, 0.18211213f, -0.02460434f, 0.09631613f, 0.11514098f, 0.08542947f, 0.24851224f, 
    0.03723637f, 0.03940246f, -0.34754071f, 0.02617959f, -0.09844887f, -0.16898695f, -0.05537070f, 0.30334660f, 
    0.23348789f, 0.10294862f, -0.10315049f, -0.40014237f, 0.30052665f, -0.00163287f, -0.04206804f, 0.09586907f, 
    -0.09735283f, -0.00802422f, -0.07227658f, -0.07599030f, -0.15351629f, -0.09050588f, -0.58356911f, 0.23763548f, 
    -0.25144657f, -0.38548690f, -0.41353732f, 0.19700092f, -0.00890400f, -0.36710936f, -0.22447486f, 0.18806326f, 
    -0.07522058f, 0.02700814f, -0.23783451f, 0.11804146f, 0.15871592f, -0.53371179f, 0.01891888f, 0.15136006f, 
    -0.18161462f, -0.04132932f, -0.06271286f, 0.14126119f, 0.04827831f, 0.14883323f, 0.02946365f, -0.03730470f, 
    0.05272897f, 0.03883791f, -0.13904075f, 0.11533406f, -0.26917437f, 0.16277155f, 0.10088799f, -0.38094938f, 
    0.14731014f, -0.05775288f, 0.00704528f, 0.03550513f, 0.20928410f, -0.28371564f, 0.18716189f, -0.08631723f, 
    -0.02800237f, -0.26605928f, 0.39136317f, -0.59428340f, -0.20178203f, 0.03138630f, -0.13410735f, -0.02619059f, 
    0.04416054f, 0.39438146f, 0.33494204f, 0.08044836f, -0.00620109f, 0.05314615f, -0.09265635f, 0.01398017f, 
    0.11248314f, 0.12370046f, 0.07814590f, 0.20493643f, -0.07224587f, -0.42599645f, 0.29731590f, -0.06391530f, 
    -0.10851440f, -0.29344213f, 0.06069627f, -0.35853624f, -0.08153108f, -0.43427190f, -0.52376688f, 0.16058818f, 
    0.69646996f, 0.32347390f, -0.08614514f, 0.10191477f, 0.01038978f, -0.00706112f, -0.54801095f, 0.12934569f, 
    -0.21919882f, 0.35521176f, -0.10112244f, -0.01694907f, -0.08207019f, -0.64931500f, -0.05885801f, 0.04735757f, 
    -0.21763045f, 0.11707079f, 0.15121529f, -0.11568835f, 0.35773721f, -0.57964647f, 0.00180638f, -0.46727577f, 
    0.03862064f, 0.09700757f, 0.32317930f, -0.06445045f, -0.28691530f, 0.05129122f, 0.02086958f, 0.03452360f, 
    -0.13667941f, 0.11266144f, -0.16977122f, -0.04369977f, 0.05894767f, -0.02346566f, 0.01138644f, -0.07075905f, 
    -0.46027961f, 0.11448163f, 0.15721455f, 0.10325730f, 0.09348454f, 0.02328275f, -0.05110858f, -0.03383194f, 
    -0.30670959f, -0.18547642f, -0.03624477f, 0.09649944f, 0.15869826f, -0.31559440f, 0.48122028f, -0.22646011f, 
    0.01387087f, -0.13040920f, -0.65698183f, -0.27231887f, -0.04983877f, 0.14481136f, 0.09263496f, 0.00973780f, 
    -0.02020974f, -0.63247144f, 0.18671452f, 0.05989115f, 0.09203874f, -0.11182470f, 0.01256530f, 0.14244133f, 
    0.03430849f, -0.00508007f, 0.00443934f, 0.17784384f, 0.01265198f, 0.20477186f, -0.15310617f, -0.00213698f, 
    0.03644069f, 0.05801895f, 0.07327984f, -0.02070507f, -0.11994444f, 0.12277801f, 0.20099194f, -0.11843236f, 
    -0.08207374f, -0.06763140f, 0.03786132f, -0.46616393f, 0.02700021f, -0.23654287f, -0.11464006f, 0.33545211f, 
    0.03377439f, 0.05427926f, -0.25356472f, 0.35169107f, 0.21472818f, -0.15145467f, 0.20143355f, -0.43738273f, 
    0.01241587f, -0.07261996f, -0.19573654f, -0.52654719f, -0.04450747f, -0.01079164f, 0.03083219f, -0.09107178f, 
    0.10570048f, -0.31635195f, 0.01599943f, -0.13928726f, 0.12007804f, 0.10610093f, -0.17789668f, -0.34703803f, 
    -0.05316188f, 0.11932274f, 0.31108263f, 0.15332228f, -0.02127905f, -0.07714520f, -0.09840522f, 0.05663293f, 
    -0.12108999f, 0.24881993f, 0.05450596f, -0.36862352f, 0.19322172f, -0.02226847f, -0.62984115f, -0.23207223f, 
    -0.38671729f, -0.25636593f, 0.01429489f, -0.25228956f, 0.03677262f, -0.01365836f, 0.23170905f, -0.08287790f, 
    -0.09468126f, -0.13555597f, -0.19229457f, -0.11271607f, -0.31714720f, 0.36413032f, -0.51683998f, -0.02859002f, 
    0.24221770f, 0.23834254f, 0.01512523f, 0.04051066f, 0.29481679f, -0.06740145f, -0.02453319f, -0.09797407f, 
    0.01730905f, 0.04275826f, 0.03026047f, -0.04085329f, -0.06433485f, 0.11970611f, -0.03258622f, 0.25827852f, 
    0.24092403f, -0.27331778f, -0.53622323f, -0.28149024f, -0.02531216f, -0.01055252f, 0.05051553f, -0.27207658f, 
    -0.23351267f, -0.23484381f, 0.20598346f, 0.11179943f, -0.38596320f, 0.04043185f, 0.10682061f, 0.08277988f, 
    0.16728204f, -0.07116382f, -0.32999030f, 0.21056056f, 0.01535100f, -0.12155298f, -0.38952896f, 0.07041494f, 
    -0.05645759f, 0.06164486f, -0.22777241f, 0.15375438f, -0.49177393f, -0.17860991f, -0.10991168f, -0.30393061f, 
    0.14239801f, -0.04683379f, -0.04090643f, -0.49398485f, -0.02434149f, 0.07506783f, 0.09314444f, -0.51059818f, 
    -0.07267128f, -0.06186459f, -0.26728424f, -0.10876035f, -0.32396030f, 0.06799123f, 0.04179460f, 0.14785616f, 
    -0.51149094f, 0.17068546f, 0.08594888f, -0.15197912f, -0.07471813f, 0.05516980f, 0.01757549f, 0.21580644f, 
    -0.06209921f, -0.08935425f, -0.11861465f, -0.01912024f, -0.01401567f, 0.13051717f, -0.22339757f, 0.08971874f, 
    -0.10292686f, -0.28100836f, -0.25324833f, -0.13585465f, 0.05254445f, 0.00792244f, -0.01448439f, -0.33107671f, 
    -0.19930662f, 0.22989576f, -0.09077161f, -0.22686860f, -0.19256999f, -0.06193647f, -0.43130705f, 0.24687518f, 
    -0.08269371f, 0.19012508f, -0.29527140f, 0.15958467f, 0.02646287f, -0.08378308f, 0.24318267f, -0.01947632f, 
    -0.06125565f, 0.07055819f, -0.04079578f, 0.22554062f, -0.08985081f, 0.05946614f, 0.04289804f, -0.10186853f, 
    0.33468252f, -0.00286892f, -0.06795858f, -0.05606784f, -0.03840283f, -0.22468428f, 0.21076506f, -0.09087243f, 
    -0.37578544f, 0.02317650f, 0.20281288f, 0.21136507f, 0.17697608f, -0.23260689f, 0.11332793f, -0.45678067f, 
    -0.01312775f, -0.06706483f, -0.50539982f, 0.06820692f, -0.43740198f, -0.08620357f, -0.07813641f, 0.23196633f, 
    -0.01062317f, 0.49725690f, -0.43707156f, -0.00796661f, 0.02740879f, 0.06835165f, -0.04328043f, -0.11197651f, 
    0.36557934f, -0.34377334f, 0.38406000f, 0.06171377f, 0.07827591f, -0.00899786f, -0.09353362f, 0.18847778f, 
    -0.14751916f, 0.25451893f, 0.10774111f, 0.00159928f, -0.07006397f, 0.19628997f, -0.15134721f, 0.23194638f, 
    0.22276425f, -0.21339431f, 0.40287319f, -0.12311551f, 0.06113144f, 0.20467587f, 0.10900611f, -0.04012024f, 
    0.27616468f, -0.16587496f, -0.19172218f, 0.04229613f, -0.12890972f, -0.18682565f, 0.31805459f, 0.25955153f, 
    -0.39926037f, -0.04728284f, 0.04770216f, -0.00202549f, 0.05039208f, 0.01075477f, -0.22500983f, -0.41321388f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.00481788f, 0.06784574f, -0.02989705f, -0.04379313f, 0.06291533f, -0.01052293f, 0.02021107f, -0.26968688f, 
    -0.11872824f, 0.05294168f, 0.11151981f, -0.00752092f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
