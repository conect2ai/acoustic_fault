#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.46346471f, 0.62417203f, 0.34369436f, 0.55475664f, 0.13864589f, -0.32213208f, 0.32902247f, -0.14858446f, 
    -0.26649106f, 0.30033693f, 0.37503827f, -0.02232631f, -0.19449671f, 0.03688909f, -0.22627668f, -0.04974902f, 
    -0.13387360f, 0.14956422f, 0.01482999f, 0.02002429f, 0.01411486f, -0.06555366f, 0.12362147f, -0.15263078f, 
    0.19992961f, -0.20831399f, -0.28867465f, -0.10095922f, -0.34791598f, -0.33113956f, 0.33033773f, -0.35232815f, 
    0.03119634f, -0.03099041f, -0.15804954f, -0.37174612f, -0.15097351f, 0.32989448f, -0.14635569f, -0.30608109f, 
    0.17290087f, 0.33958405f, 0.02919028f, -0.28719458f, 0.09792013f, -0.03627318f, -0.01170573f, -0.16311468f, 
    0.31981483f, 0.17512266f, -0.42321885f, -0.11608449f, -0.29962456f, -0.50985235f, -0.32261088f, 0.11634838f, 
    0.60716188f, 0.26616046f, -0.44750509f, 0.19024660f, -0.27322483f, 0.05296120f, -0.00414251f, 0.21521783f, 
    -0.07052232f, 0.06914230f, -0.08259296f, 0.11024304f, 0.14281577f, 0.01680717f, 0.18851827f, 0.09430271f, 
    -0.14532146f, 0.14657897f, 0.23877154f, 0.84368974f, -0.02450779f, -0.04487916f, 0.42190170f, -0.21209274f, 
    0.38414213f, 0.28901431f, 0.17583437f, 0.42739472f, 0.08969549f, -0.07421707f, 0.32758096f, -0.13730389f, 
    0.11547687f, 0.09663990f, 0.27307004f, -0.10247313f, -0.24365757f, -0.09420169f, 0.19066769f, -0.28164229f, 
    -0.25601321f, 0.05044973f, 0.01231460f, -0.03744646f, 0.13581218f, 0.43990505f, -0.01981259f, 0.27637044f, 
    0.55444092f, 0.27134186f, -0.00159502f, -0.32735205f, -0.55873954f, -0.26202670f, -0.00272754f, 0.10065808f, 
    0.27874491f, 0.10367540f, 0.25839031f, 0.35060874f, -0.11178631f, 0.26029462f, -0.25552395f, -0.06404599f, 
    -0.24785720f, 0.02361345f, 0.14736865f, 0.07855347f, 0.17762139f, -0.42591321f, -0.34290680f, -0.15979174f, 
    -0.02739649f, -0.25587603f, 0.18268728f, 0.36468485f, 0.38377395f, 0.00656638f, 0.47039124f, 0.13054705f, 
    -0.30079651f, 0.24067573f, -0.01775577f, 0.28426072f, -0.21736686f, -0.18814352f, -0.19582205f, -0.06421607f, 
    -0.11211524f, -0.12566598f, 0.22269544f, 0.00090403f, -0.13195260f, 0.28587624f, -0.45921516f, -0.35752589f, 
    -0.09961901f, -0.28888363f, 0.66397381f, 0.25035554f, 0.17621776f, -0.21464199f, -0.32950628f, -0.32693630f, 
    0.00466621f, -0.07160705f, 0.21079966f, 0.32040197f, 0.00206898f, 0.38809258f, -0.39493912f, -0.33951229f, 
    -0.20482515f, 0.12344513f, -0.02796170f, 0.40485606f, 0.25850448f, 0.05338367f, 0.14437577f, -0.39929628f, 
    -0.42315087f, -0.27378303f, -0.27597821f, -0.44285715f, 0.23755790f, 0.02283222f, 0.30586493f, 0.14396730f, 
    -0.19844930f, -0.04308705f, 0.41564044f, -0.21897063f, 0.18216154f, 0.05151769f, 0.08015754f, 0.09960914f, 
    -0.03786411f, 0.08173653f, -0.23543777f, -0.17203698f, 0.05831709f, 0.18550846f, -0.17730238f, 0.24065785f, 
    -0.11398411f, 0.19822241f, 0.08023651f, -0.18698087f, -0.40336433f, 0.15131344f, -0.70949805f, -0.05218942f, 
    0.16809060f, -0.12068488f, 0.26715469f, -0.11327679f, 0.19719075f, 0.13692194f, -0.26704213f, -0.07478201f, 
    0.05741392f, -0.25933260f, 0.11088303f, 0.16804065f, -0.21946602f, 0.15965568f, 0.10490584f, 0.34820363f, 
    0.24494265f, 0.64164507f, 0.26563630f, -0.60440230f, -0.95613468f, -0.33425394f, 0.23303828f, -0.07840241f, 
    -0.41949552f, -0.49116999f, -0.31471217f, 0.19389407f, 0.17714392f, 0.21270104f, 0.04853116f, -0.03331223f, 
    0.02703984f, 0.20470180f, 0.02756298f, -0.10089123f, -0.01974405f, 0.06944279f, -0.22484306f, 0.07684595f, 
    0.13543403f, 0.00455940f, 0.55736226f, -0.17536736f, -0.30726057f, -0.10729123f, 0.09428262f, 0.55437893f, 
    0.56590080f, 0.25718987f, 0.34031263f, 0.22059242f, -0.00421801f, 0.31677705f, -0.35488385f, -0.08775184f, 
    -0.28201532f, 0.08651309f, -0.13360141f, -0.10554441f, 0.06562929f, -0.07705695f, 0.23681484f, 0.04649351f, 
    0.01251446f, 0.15438110f, 0.05363462f, 0.66079545f, 0.72763520f, 0.09593496f, -0.08555637f, -0.44622722f, 
    -0.34917212f, -0.36193278f, -0.42751274f, -0.19877636f, -0.05093318f, 0.33382601f, 0.36767969f, 0.05227045f, 
    -0.14478627f, 0.04846782f, 0.22877192f, -0.21963321f, 0.08261175f, 0.06654458f, -0.06973713f, -0.13810159f, 
    0.25928286f, 0.19529071f, -0.20280057f, -0.12093054f, 0.50782716f, 0.06189132f, -0.03724207f, 0.48824459f, 
    0.19023509f, -0.18079624f, -0.51921147f, -0.35781404f, -0.41444835f, -0.44896379f, -0.52574438f, -0.06775783f, 
    0.36007759f, 0.20539767f, -0.01838253f, 0.26074561f, -0.19143242f, 0.17230512f, 0.32114413f, 0.02541694f, 
    0.09080330f, 0.13439685f, -0.11402869f, -0.36825031f, -0.23316967f, 0.53103244f, 0.18218154f, 0.26368037f, 
    0.65038252f, 0.73019540f, 0.48766950f, -0.02598794f, -0.48706964f, 0.38396582f, 0.13862397f, -0.23987845f, 
    0.09747502f, -0.15685554f, 0.00407630f, -0.09310451f, -0.08803301f, -0.02162380f, -0.05833351f, 0.01497916f, 
    -0.14909804f, -0.04204296f, 0.29515415f, -0.09393222f, -0.07060073f, 0.02390342f, -0.66612661f, 0.25960481f, 
    0.03466974f, -0.29192385f, -0.19870338f, 0.16215557f, 0.53089428f, -0.19094244f, 0.35898918f, -0.07235304f, 
    0.29168555f, -0.07785377f, -0.42012516f, -0.14026234f, 0.07035978f, -0.01615825f, 0.12761043f, -0.24386415f, 
    -0.13763046f, -0.06657808f, -0.02335214f, 0.14503062f, -0.07290742f, -0.21321218f, -0.27555496f, -0.03089473f, 
    0.22663243f, 0.19878916f, -0.28713861f, -0.13217770f, 0.04513890f, 0.01341089f, -0.11133149f, 0.29960445f, 
    -0.04359218f, -0.45231527f, 0.10475199f, -0.29044390f, 0.16035484f, -0.37036631f, -0.30945799f, 0.10134277f, 
    0.18626994f, -0.20904289f, 0.22347793f, -0.30876940f, -0.06439745f, -0.47494006f, -0.18568385f, 0.47919947f, 
    0.16910775f, 0.13366771f, 0.22240955f, 0.67919540f, -0.05104007f, 0.30358517f, -0.17320493f, -0.51640868f, 
    0.37240449f, 0.20067842f, -0.06057176f, -0.11777117f, -0.25888014f, -0.09727343f, 0.04398305f, 0.21332109f, 
    -0.01771233f, -0.19835888f, -0.21465556f, 0.41497210f, -0.11679439f, 0.24495387f, 0.32189789f, -0.25127336f, 
    0.43287089f, -0.48684782f, -0.26921982f, 0.11859749f, 0.26986498f, 0.24886160f, 0.29472783f, 0.70816147f, 
    0.49697161f, 0.14495057f, 0.53730905f, -0.47491267f, -0.10452905f, -0.00290558f, -0.22325084f, -0.18456250f, 
    -0.27771553f, -0.10118324f, 0.13824655f, -0.07553344f, 0.01028938f, 0.22752866f, -0.24168028f, 0.10488854f, 
    -0.16122639f, -0.04943506f, 0.16576408f, 0.90552872f, -0.65478462f, -0.26630607f, 0.12667695f, 0.32354584f, 
    -0.10916526f, -0.52200454f, 0.03300245f, -0.25669992f, 0.21894217f, -0.35387683f, 0.01398355f, 0.37221280f, 
    0.27242303f, 0.21921141f, -0.01929845f, 0.04184060f, 0.11675720f, 0.01953621f, 0.17640653f, 0.03714216f, 
    -0.15942901f, 0.07800930f, 0.37471598f, 0.25876224f, 0.38024309f, 0.64082140f, 0.63625991f, 0.33615211f, 
    -0.02393058f, 0.02560033f, -0.30720541f, 0.23432304f, -0.41501284f, -0.02435701f, 0.25035521f, 0.09554542f, 
    0.33113098f, -0.10413793f, 0.04363389f, 0.20928198f, -0.04888257f, -0.06784500f, -0.09450193f, -0.24604815f, 
    0.08723775f, -0.22777799f, 0.19737609f, -0.14992134f, 0.62158912f, 0.63488293f, 0.79601258f, -0.35416406f, 
    -0.53938609f, 0.11118668f, -0.50574541f, 0.17312205f, 0.16617104f, 0.01594766f, 0.17517799f, 0.15128173f, 
    -0.02005491f, 0.12775473f, 0.04427999f, -0.48064145f, -0.08820303f, -0.05298873f, 0.04564957f, -0.05796445f, 
    0.11200304f, 0.18766430f, -0.22208081f, 0.34868398f, 0.11098023f, -0.07606036f, -0.00185198f, -0.50422078f, 
    -0.29826054f, -0.06821056f, 0.42432612f, -0.27633274f, -0.31732574f, -0.01980466f, -0.03583729f, -0.31219968f, 
    -0.42880592f, -0.24916594f, 0.01131785f, -0.18055373f, -0.31151512f, 0.19339547f, 0.11230943f, 0.17592265f, 
    0.07658432f, 0.19471158f, -0.08152737f, -0.17858161f, -0.13275348f, -0.17434964f, 0.39294803f, -0.12869740f, 
    -0.34678811f, -0.63172537f, -0.33402908f, 0.20535536f, 0.46555081f, -0.34739611f, 0.23970665f, 0.42671794f, 
    0.09368407f, -0.17938854f, -0.45961505f, -0.17567569f, -0.24693772f, -0.17862482f, 0.06401467f, -0.06238642f, 
    -0.14118791f, 0.09722391f, 0.02384086f, -0.16206506f, -0.18581618f, -0.12289057f, 0.08372546f, 0.82342887f, 
    0.35770953f, 0.32232851f, 0.07157581f, 0.03950134f, -0.30352393f, -0.55072671f, 0.28675669f, 0.27436885f, 
    0.18873057f, -0.02849802f, -0.20239528f, 0.08245113f, -0.26965865f, -0.04038847f, 0.05398670f, 0.26260480f, 
    0.22727817f, 0.02123632f, -0.31689328f, 0.08013672f, 0.09788924f, 0.29747823f, -0.10038142f, 0.06299563f, 
    0.03138380f, -0.55803788f, -0.03411017f, 0.36875746f, -0.31735587f, -0.17820536f, 0.30513322f, 0.12920518f, 
    -0.42499965f, -0.26106066f, -0.27657950f, 0.09677464f, -0.24546145f, 0.12902755f, -0.29422033f, -0.26392543f, 
    -0.10486115f, -0.38609019f, -0.10131208f, -0.05679603f, -0.20298880f, 0.25055966f, -0.18031293f, 0.25965193f, 
    0.22595589f, 0.23966020f, 0.48709035f, -0.03141374f, 0.22357403f, 0.44250163f, -0.02774184f, 0.16323593f, 
    0.21992953f, 0.21328424f, -0.45696655f, -0.08005360f, -0.24059026f, 0.03249643f, 0.16941561f, 0.37809864f, 
    0.13210395f, -0.18110481f, 0.19356911f, 0.26371551f, 0.29703495f, 0.35368931f, 0.18786137f, 0.17986433f, 
    0.21898037f, 0.36288407f, 0.03593754f, -0.57160294f, -0.44525605f, -0.38272038f, -0.59288734f, -0.16279042f, 
    0.05696699f, 0.40118641f, 0.20041560f, 0.38131467f, 0.27436119f, -0.00165303f, 0.19289288f, 0.25402403f, 
    0.21314985f, -0.07675597f, 0.02761675f, 0.01314546f, -0.07919254f, 0.12876603f, -0.23417473f, 0.07578320f, 
    -0.25794449f, 0.40182814f, -0.33087340f, -0.10206471f, -0.38215545f, -0.11905319f, -0.38044852f, -0.37920928f, 
    -0.11879781f, -0.33185023f, -0.23171158f, 0.15424575f, 0.00954491f, 0.40578741f, -0.00856438f, -0.15855595f, 
    -0.07405953f, -0.21339197f, -0.17132576f, 0.16142213f, -0.29133785f, -0.06519822f, 0.16614613f, 0.20540218f, 
    0.13277733f, -0.06260145f, 0.13139354f, -0.25912559f, -0.03676685f, -0.34251204f, -0.34613407f, 0.04659719f, 
    -0.22847806f, -0.33258533f, -0.22809280f, -0.45811298f, -0.34160650f, 0.00142704f, 0.07451711f, 0.05212931f, 
    -0.17262194f, 0.16907102f, -0.34558606f, 0.15076230f, -0.01430939f, -0.07826870f, -0.15505332f, 0.30711392f, 
    -0.24366158f, -0.20569313f, 0.19887678f, 0.03921146f, -0.16953510f, 0.06409752f, 0.26959568f, 0.52994144f, 
    0.34706864f, 0.50828230f, 0.47540563f, -0.11166745f, -0.53537357f, 0.19970961f, 0.15258606f, 0.06431571f, 
    0.06422497f, 0.25747535f, -0.00397315f, -0.39493677f, -0.03530897f, -0.12863877f, 0.09297615f, 0.04806989f, 
    -0.27523863f, 0.25903338f, -0.15641917f, 0.17284839f, 0.00839688f, 0.07204039f, 0.74058944f, 0.45053264f, 
    -0.21366335f, 0.35082600f, -0.71694291f, -0.41549131f, -0.03170973f, -0.34240627f, 0.49254656f, -0.27502656f, 
    0.24945328f, -0.05633596f, 0.12956399f, -0.02435312f, -0.38408935f, -0.00644707f, -0.03672863f, -0.11053329f, 
    -0.09566974f, -0.16718936f, -0.36540067f, 0.00534980f, 0.01769852f, 0.01916641f, 0.01910672f, -0.93188238f, 
    0.39711288f, 0.01291364f, -0.24884927f, -0.20129123f, 0.18913020f, -0.33979177f, -0.26361576f, 0.30466112f, 
    -0.12373018f, -0.18596347f, -0.17100179f, -0.26141557f, 0.06549571f, -0.13352716f, -0.06380410f, -0.06422278f, 
    0.00266900f, -0.18046506f, -0.30527270f, 0.02721955f, 0.01083348f, 0.19568793f, 0.24836421f, 0.14237700f, 
    -0.78223777f, 0.59329581f, 0.31768164f, -0.07823303f, 0.08901921f, -0.36192924f, 0.27963725f, 0.21296459f, 
    -0.64251089f, -0.31108400f, 0.08562352f, -0.15935649f, 0.11814646f, 0.01246441f, -0.22890270f, 0.18549639f, 
    0.08029532f, -0.10959850f, 0.22241113f, 0.09862240f, -0.02506451f, -0.20853890f, -0.23470311f, -0.01612064f, 
    0.12688467f, -0.12530644f, -0.66542166f, -0.29012489f, 0.33651313f, -0.27863088f, -0.43446022f, -0.14611319f, 
    -0.20196742f, -0.25482172f, -0.03077441f, 0.06210915f, -0.04477428f, 0.19266547f, 0.06578321f, 0.22477485f, 
    -0.37735164f, 0.06553432f, 0.32316381f, 0.00644312f, 0.15108664f, 0.15735821f, 0.04669859f, 0.12721340f, 
    0.25063270f, -0.14128487f, 0.51112050f, 0.55367702f, 0.55351228f, 0.13989814f, 0.59942049f, 0.01081270f, 
    0.06845640f, -0.45457232f, -0.00634506f, -0.43024439f, 0.13778432f, 0.13251634f, 0.26194260f, 0.15154384f, 
    0.08888004f, 0.02567449f, -0.03125871f, -0.07366334f, -0.25684693f, -0.00370653f, -0.06894080f, -0.01152276f, 
    0.34335479f, 0.06796484f, -0.07036588f, 0.60199052f, -0.42256689f, -0.01878593f, -0.19081403f, -0.65250784f, 
    0.19056040f, -0.59836537f, -0.13501365f, 0.08872155f, 0.40674019f, 0.47266075f, -0.10758904f, 0.05998489f, 
    -0.19578823f, 0.05525263f, -0.23471078f, 0.07898536f, 0.21792898f, 0.27032009f, 0.00030608f, -0.04358677f, 
    -0.23156062f, 0.12132050f, -0.13415152f, -0.01842634f, 0.17227569f, -0.28852779f, -0.22995158f, 0.53259420f, 
    0.47810552f, -0.25890914f, 0.14200823f, -0.41572413f, -0.60183734f, -0.14207540f, 0.33159953f, 0.36534077f, 
    0.37453082f, 0.05205562f, -0.01594018f, 0.26690415f, 0.21639171f, -0.05974073f, 0.09760844f, 0.04042131f, 
    0.16384526f, -0.02506601f, -0.27546436f, 0.25014043f, 0.09506334f, -0.43087238f, -0.18302740f, 0.48072577f, 
    0.53935486f, -0.13900843f, 0.43583629f, 0.63508892f, -0.29980758f, 0.07125580f, -0.36098918f, 0.19354127f, 
    0.20969112f, -0.22337295f, 0.14046849f, 0.37950641f, 0.16720293f, -0.14208630f, -0.18727708f, -0.24692765f, 
    0.12595567f, 0.11615561f, 0.27534351f, -0.22277857f, 0.16476817f, -0.12001883f, -0.48281571f, 0.16084352f, 
    -0.19706741f, -0.37137622f, -0.62107474f, 0.53667623f, 0.05027636f, -0.40290201f, -0.16906412f, 0.31011283f, 
    0.31404844f, 0.24155767f, 0.20788376f, 0.04447271f, -0.14939642f, 0.35411105f, -0.21377663f, 0.06708397f, 
    0.11818421f, 0.23855163f, 0.17034560f, -0.32683215f, 0.20446843f, -0.00591136f, -0.21753241f, -0.55009919f, 
    -0.89105535f, -0.38855401f, 0.18616571f, 0.16908248f, 0.47632509f, 0.81785256f, 0.03855219f, 0.21973991f, 
    0.28347611f, -0.13870610f, 0.18533239f, -0.07382159f, 0.44685864f, 0.27392063f, -0.07368083f, 0.24873257f, 
    0.05234897f, 0.07799088f, 0.10903345f, 0.11710811f, 0.12393276f, -0.11734089f, -0.18897617f, 0.04965445f, 
    -0.15544747f, -0.38369173f, 0.56397676f, 0.41856566f, -0.74580759f, 0.00821409f, -0.40404156f, 0.59112376f, 
    -0.07050277f, -0.18544538f, 0.02590922f, -0.23010181f, -0.23336078f, -0.03053598f, 0.17810868f, -0.23476759f, 
    0.17384392f, -0.12314511f, -0.22971214f, -0.04950515f, 0.02210473f, 0.18223514f, 0.17403397f, 0.06380656f, 
    -0.16933876f, 0.64724755f, 0.21946938f, 0.31886938f, 0.72306490f, 0.08148530f, -0.16907470f, 0.31638232f, 
    -0.02793217f, 0.40017983f, -0.11905149f, -0.14857544f, -0.10683956f, 0.07196527f, 0.16722798f, -0.05466995f, 
    -0.24137472f, -0.18291651f, 0.07537542f, 0.16623402f, 0.05102829f, 0.06437106f, -0.18455172f, -0.13657103f, 
    0.01737441f, -0.05104896f, -0.36095908f, 0.68208277f, -0.38725734f, -0.17097855f, -0.58534694f, 0.72024596f, 
    0.19934796f, -0.70034802f, 0.49968016f, 0.30527157f, 0.27327687f, -0.27372923f, -0.13385013f, -0.12476117f, 
    -0.19396862f, 0.15159154f, -0.21711223f, 0.01458956f, 0.05223946f, 0.13624907f, -0.05748288f, -0.01629325f, 
    -0.22737329f, -0.00747091f, 0.07611594f, -0.49100947f, -0.52848810f, -0.21429253f, 0.22865425f, 0.15602638f, 
    0.35989276f, 0.66419321f, 0.24988219f, 0.28652313f, -0.08647197f, -0.18563209f, -0.01721581f, 0.18036044f, 
    0.15421626f, -0.23612158f, -0.17843251f, -0.22376953f, -0.46379441f, -0.38390073f, 0.19857699f, -0.34381500f, 
    -0.10781971f, -0.08118852f, 0.16783962f, -0.33972260f, 0.45010984f, -0.43305233f, -0.20329927f, 0.26277372f, 
    0.46562350f, 0.36350912f, 0.39085513f, -0.18167031f, 0.25501221f, 0.40639433f, -0.05793489f, 0.40902233f, 
    -0.19091618f, 0.24257253f, -0.20398204f, -0.21895945f, -0.02947075f, -0.27332211f, -0.27976677f, -0.29822299f, 
    -0.20532836f, -0.28128883f, 0.28564364f, 0.00494651f, -0.19392915f, -0.17096977f, -0.54022866f, -0.31293753f, 
    -0.36611909f, -0.19354700f, 0.37367547f, -0.16369495f, 0.19742574f, 0.43179360f, -0.11294280f, -0.10896797f, 
    -0.01996730f, -0.17892295f, -0.08526416f, 0.23257469f, 0.20315719f, 0.23795837f, -0.06160670f, -0.02210405f, 
    0.12883595f, 0.04588740f, -0.09199771f, -0.03232768f, 0.26724070f, -0.03435535f, 0.49364159f, 0.38103011f, 
    0.37601086f, 0.60928530f, 0.28669187f, 0.05387687f, -0.03091368f, -0.28675336f, -0.37587839f, 0.37587968f, 
    0.03334064f, 0.11251809f, 0.19508542f, 0.06628003f, -0.14120847f, -0.29969472f, -0.16747977f, 0.25797105f, 
    0.02760569f, -0.20442435f, 0.18564121f, -0.15210773f, -0.15603219f, 0.09950165f, -0.09366646f, 0.39912066f, 
    -0.32972875f, -0.51245707f, 0.13135064f, 0.10086826f, -0.37783965f, -0.14130777f, 0.17598362f, 0.53707689f, 
    -0.60888481f, -0.44414783f, -0.23828490f, 0.14483644f, 0.05780881f, -0.22417547f, 0.23767550f, -0.22372168f, 
    0.16347611f, 0.06189877f, -0.00426631f, 0.21213408f, -0.19098309f, -0.08298415f, 0.34411418f, -0.09997256f, 
    -0.11097676f, 0.50143808f, 0.55138528f, 0.15205207f, -0.38022178f, -0.46981397f, 0.08467935f, 0.24796507f, 
    0.56884229f, -0.13231392f, -0.24063657f, 0.09768782f, 0.04583516f, -0.51196104f, -0.02480978f, 0.10926152f, 
    0.10566773f, 0.18444580f, 0.35901219f, 0.03569106f, 0.25551185f, -0.24538024f, -0.25263897f, -0.16378851f, 
    0.23476909f, -0.56814176f, -0.13004670f, 0.34523830f, -0.15495086f, -0.34861684f, 0.35907501f, 0.00885527f, 
    -0.47688115f, -0.50698024f, 0.23510505f, -0.05079011f, 0.32729703f, 0.03046132f, 0.07559623f, 0.26250124f, 
    -0.35663989f, -0.19959487f, 0.08013590f, -0.01393403f, 0.08600859f, 0.10722069f, 0.07604125f, -0.01193383f, 
    -0.22947012f, -0.35819897f, 0.74812561f, 0.69781560f, -0.18049574f, -0.75300628f, -0.32514578f, -0.25450328f, 
    -0.21857980f, 0.29983607f, -0.05157936f, 0.31183290f, 0.01650271f, 0.22594115f, 0.31932399f, 0.00251335f, 
    -0.12796217f, 0.29487279f, 0.00157397f, -0.12176618f, -0.02758448f, -0.12385084f, 0.19798636f, -0.24509907f, 
    0.08282487f, -0.19702511f, 0.14804776f, -0.42815790f, -0.68210024f, 0.11052557f, 0.12551096f, -0.43965185f, 
    -0.45954174f, 0.23180121f, -0.29642078f, 0.08004148f, 0.23455346f, 0.28578573f, 0.23567550f, 0.22795387f, 
    -0.06296660f, -0.03406631f, 0.07044058f, -0.21041539f, 0.07833944f, 0.13637957f, -0.06434061f, 0.03112605f, 
    -0.04484766f, 0.21033695f, 0.23038577f, 0.31567070f, 0.64587492f, 0.15632953f, 0.18902870f, 0.31942084f, 
    0.78129226f, 0.03088867f, -0.22187012f, 0.63357979f, -0.06187512f, -0.45284879f, 0.02840247f, -0.28267318f, 
    -0.34901479f, -0.29262149f, 0.05968150f, 0.01439951f, 0.06077189f, 0.15264222f, 0.25853086f, 0.13654619f, 
    0.01845215f, 0.11709899f, -0.01944737f, -0.01784313f, -0.17136389f, -0.41026074f, -0.38839549f, -0.35494146f, 
    -0.43666768f, -0.26372692f, -0.47346589f, -0.00789767f, 0.34456176f, 0.27363440f, 0.04515507f, -0.24228102f, 
    0.28938276f, 0.24466200f, -0.12869173f, -0.12335379f, 0.19839257f, -0.11267018f, 0.16760625f, 0.12420651f, 
    0.06496283f, -0.07448877f, 0.10207418f, -0.06547987f, -0.35284594f, 0.34304523f, 0.18204044f, -0.41230139f, 
    -0.60121721f, -0.31174046f, -0.00945016f, -0.63692123f, 0.54113299f, 0.56830466f, -0.65378791f, 0.18581308f, 
    0.37573096f, 0.15153432f, 0.18178956f, -0.01928813f, 0.29345784f, -0.05446934f, 0.10107583f, -0.02100030f, 
    -0.14060639f, -0.41973987f, -0.03377669f, -0.12235083f, -0.08502225f, -0.20947373f, 0.09031395f, -0.53541678f, 
    0.35259834f, 0.07760149f, 0.48175594f, 0.06831824f, -0.08316460f, 0.37577817f, -0.68426734f, 0.16289324f, 
    -0.19268094f, -0.01201922f, -0.00056030f, 0.18392482f, -0.31535295f, -0.29551363f, -0.23191932f, 0.24618895f, 
    0.35808885f, -0.11755083f, -0.01450820f, -0.12234815f, -0.34960645f, -0.37190288f, -0.26670253f, -0.22020949f, 
    0.71660405f, 0.08488507f, -0.06987002f, 0.92510515f, 0.14051497f, 0.70836413f, -0.04458960f, -0.36069536f, 
    0.10897892f, -0.30012113f, -0.06464902f, 0.04532904f, -0.00644588f, -0.06604192f, -0.12640060f, -0.06823873f, 
    0.06067247f, -0.01793603f, -0.16851942f, -0.02854545f, 0.21155113f, -0.04499035f, 0.38328150f, -0.27635542f, 
    0.33580863f, -0.31171438f, -0.93833011f, -0.36340153f, 0.12703049f, 0.15395674f, -0.56509840f, 0.34040353f, 
    0.16748334f, -0.21073414f, -0.18021499f, 0.21573190f, -0.18814072f, -0.06435259f, 0.07383847f, 0.07801501f, 
    -0.17284602f, 0.26157165f, 0.24398126f, 0.10455737f, -0.18785787f, -0.12298191f, -0.37286535f, 0.00010311f, 
    -0.14852381f, 0.14074585f, 0.60673296f, 0.28925869f, -0.57315171f, -0.76930052f, -0.02458020f, 0.31024835f, 
    0.26495057f, -0.23178872f, -0.24621998f, 0.15711303f, -0.32329518f, 0.00728026f, 0.05678799f, 0.12266118f, 
    0.17444079f, -0.22235972f, -0.09570760f, -0.13954711f, 0.00435854f, 0.10781485f, -0.16282041f, 0.11256537f, 
    -0.27833134f, -0.19360512f, 0.02158307f, 0.17344256f, 0.08152060f, 0.13058713f, 0.61127472f, 0.10323926f, 
    0.37368655f, 0.29321176f, -0.04493515f, 0.30907911f, 0.20670928f, -0.00922538f, -0.30002168f, 0.17933205f, 
    0.00494587f, -0.17250684f, -0.22276983f, -0.24551833f, -0.46483228f, -0.33754244f, 0.06033912f, -0.37503365f, 
    -0.25934476f, 0.08486050f, 0.11336784f, -0.42775208f, 0.20397834f, -0.90198553f, -0.44637254f, 0.15220180f, 
    -0.43797308f, -0.25057480f, 0.73327279f, 0.07055922f, -0.12131271f, 0.25645235f, 0.27776307f, -0.04129434f, 
    0.00402160f, 0.30633333f, -0.03604872f, -0.07260000f, -0.13979186f, 0.07661300f, 0.08658890f, 0.09312741f, 
    0.11900944f, 0.06122038f, 0.07457395f, -0.10652956f, -0.00286391f, -0.02906692f, -0.01823526f, -0.59796131f, 
    -0.63746727f, -0.05887160f, 0.44610864f, -0.54833603f, -0.39773247f, -0.19497554f, -0.25411788f, -0.03955185f, 
    0.46159923f, 0.21379481f, 0.10185464f, 0.06240957f, 0.10140920f, 0.05965346f, -0.07148662f, -0.03785757f, 
    0.24694067f, 0.08981944f, 0.14491466f, 0.19725722f, 0.08771171f, 0.08491552f, 0.72438765f, 0.30519626f, 
    0.04325395f, -0.32568863f, -0.57163948f, 0.18477635f, -0.39405757f, 0.37246343f, 0.26265153f, 0.41997883f, 
    0.14879903f, -0.05077714f, -0.16599785f, -0.14559051f, 0.44975460f, 0.09721226f, -0.14309078f, -0.18366617f, 
    -0.11788079f, -0.33876705f, 0.13574639f, 0.39916900f, -0.00850492f, 0.35248581f, -0.16308020f, -0.06062478f, 
    -0.55033189f, -0.43921578f, -0.38412452f, -0.04647607f, -0.06111104f, 0.16110295f, 0.40702853f, 0.25990400f, 
    0.14096709f, 0.07583469f, 0.13117568f, 0.02850424f, -0.39901632f, -0.47384587f, 0.03016545f, 0.43017194f, 
    0.47016749f, 0.37806448f, -0.14308707f, 0.16841914f, -0.26476723f, -0.29418984f, -0.33525798f, -0.10599771f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25048727f, 0.17647804f, 0.21308707f, -0.04611547f, -0.06052063f, 0.12786809f, 0.05633057f, 0.24793239f, 
    0.16195218f, 0.21591765f, -0.06106196f, 0.13099748f, 0.03205933f, 0.27381381f, 0.04717987f, 0.06755785f, 
    0.18814681f, -0.09161130f, 0.15636285f, -0.10669353f, 0.06943274f, -0.05793820f, -0.00546597f, 0.24173272f, 
    0.03485207f, 0.12749538f, 0.07902440f, 0.16642359f, 0.10463969f, 0.06374182f, 0.02022770f, 0.12590462f, 
    0.10020275f, 0.08559152f, -0.02536611f, 0.12244167f, 0.18537474f, 0.19159566f, 0.20963818f, 0.18611176f, 
    0.19789778f, 0.12475736f, 0.06294242f, 0.09900670f, 0.11172631f, 0.04147631f, 0.23670815f, 0.13123819f, 
    0.05699196f, 0.22681278f, 0.11344112f, 0.26442233f, 0.00321406f, 0.17462176f, -0.08688825f, 0.25661314f, 
    -0.02247206f, 0.20431225f, 0.28657252f, 0.07008727f, 0.22612765f, 0.23110949f, 0.10270369f, 0.11671812f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.20497544f, 0.04573181f, 0.21374243f, 0.02054625f, -0.11709160f, 0.02876398f, 0.10144070f, 0.00497634f, 
    0.03519061f, 0.06504587f, 0.01191953f, -0.02031502f, -0.00184621f, -0.02785394f, -0.00163777f, -0.03159261f, 
    0.20318663f, -0.08507913f, -0.03468687f, -0.01096056f, 0.05349128f, 0.15371917f, 0.05868375f, 0.11165011f, 
    0.05455502f, -0.01933947f, -0.01445540f, -0.21655637f, 0.14312856f, -0.04490422f, -0.03530281f, 0.11678303f, 
    0.08680043f, 0.06313211f, -0.03126308f, 0.05185323f, 0.13491234f, 0.28267363f, -0.10302293f, 0.02886980f, 
    0.05277340f, 0.04910985f, 0.03266171f, 0.16844811f, 0.15504572f, -0.04820769f, 0.16462867f, -0.04200302f, 
    0.16882749f, 0.18013386f, -0.03427542f, -0.23179071f, 0.04062103f, -0.06551458f, 0.00369698f, 0.14212644f, 
    0.02255869f, 0.05205272f, -0.09651225f, 0.04895285f, 0.04297767f, 0.07801671f, -0.07688414f, -0.21344361f, 
    0.05612550f, -0.06600490f, -0.01341159f, -0.05369547f, 0.03840441f, 0.09689108f, 0.03901706f, 0.26369494f, 
    0.01442635f, -0.07748891f, -0.17002301f, 0.05523048f, 0.04750649f, 0.08351079f, 0.08433709f, -0.02240520f, 
    0.04403728f, 0.02963391f, -0.01816284f, -0.09422841f, -0.05313283f, -0.03249064f, -0.09184002f, -0.09396475f, 
    0.07930660f, 0.03493263f, -0.01816058f, 0.10395367f, 0.04726193f, 0.00311514f, 0.02615330f, 0.07533216f, 
    -0.02728193f, 0.07515351f, 0.09847365f, 0.05139951f, 0.02158765f, -0.04101247f, 0.00609935f, 0.02145450f, 
    0.02933773f, -0.11865047f, 0.06753191f, 0.06643663f, -0.24380288f, -0.01557417f, 0.40865159f, 0.10593201f, 
    0.04686445f, 0.08116519f, -0.01387596f, 0.11522204f, 0.00252666f, -0.02293270f, -0.00107991f, -0.03898629f, 
    -0.09402186f, 0.25511751f, -0.01113237f, -0.03982278f, 0.13012147f, 0.03193222f, -0.03736037f, 0.00272212f, 
    0.00592169f, 0.17047498f, 0.12122177f, -0.01304638f, -0.14442778f, 0.14998193f, 0.20271620f, 0.06203613f, 
    -0.12058151f, 0.07021719f, 0.01263876f, 0.05355030f, -0.02076516f, -0.03226691f, 0.00585359f, -0.07040624f, 
    0.12630093f, 0.10086542f, -0.00693738f, -0.06057308f, 0.02334254f, 0.13987280f, 0.10330690f, -0.00998613f, 
    -0.08660591f, -0.04606204f, -0.15940143f, 0.21650505f, 0.02231546f, 0.30746368f, -0.07009364f, -0.03456553f, 
    0.03929692f, -0.03022384f, 0.08399773f, -0.07735810f, -0.08333883f, 0.04861089f, -0.05980718f, 0.00903162f, 
    0.07571095f, -0.09260114f, 0.04839052f, 0.02797016f, 0.04421626f, 0.23044455f, -0.00637484f, 0.09026175f, 
    0.04415000f, -0.00885640f, 0.11269148f, 0.00501853f, -0.03760710f, 0.08251723f, 0.07601831f, -0.09947369f, 
    0.02476617f, -0.03058246f, 0.19002920f, 0.05094759f, -0.19728586f, 0.13472466f, 0.06522527f, 0.21824579f, 
    -0.06682056f, 0.18909653f, -0.04191667f, 0.02129552f, 0.05208832f, 0.03320272f, -0.04602044f, 0.00224599f, 
    -0.02002631f, 0.04419004f, 0.12515226f, -0.03820611f, 0.05631123f, 0.09656526f, -0.00209596f, -0.08077183f, 
    0.15273145f, 0.06904366f, 0.00392390f, -0.00398131f, 0.01773472f, -0.02739720f, 0.02025765f, 0.16407505f, 
    0.02098910f, 0.09153390f, 0.44978026f, -0.20000406f, -0.05693602f, 0.02135285f, 0.10984000f, 0.01629981f, 
    -0.03094186f, 0.01854456f, -0.03328338f, -0.06822781f, 0.19378160f, 0.26533449f, -0.08324882f, -0.09005189f, 
    0.00926393f, 0.04986318f, 0.05636964f, 0.05380704f, -0.03778364f, 0.05959015f, 0.03488357f, 0.09454580f, 
    -0.02388963f, 0.17724068f, 0.25963289f, 0.05697917f, -0.05047650f, 0.05576796f, 0.17174827f, 0.03554972f, 
    -0.08150043f, -0.07221857f, 0.05806443f, 0.08623891f, -0.10300165f, 0.04685016f, 0.21462697f, -0.12189065f, 
    0.07269593f, 0.03756176f, 0.11541297f, 0.01765718f, -0.10807128f, 0.04137887f, 0.02918463f, 0.17966692f, 
    -0.21320747f, -0.14970411f, 0.19621971f, -0.04772319f, 0.09170751f, 0.06361633f, 0.08167097f, 0.11651190f, 
    0.00863015f, 0.22861093f, 0.14231302f, 0.05627696f, 0.13307375f, -0.04189530f, 0.05994961f, 0.10628653f, 
    0.02528203f, 0.01063881f, 0.03319236f, 0.05420810f, -0.09896503f, 0.13373628f, -0.05165130f, -0.03213596f, 
    -0.03451096f, 0.19514860f, -0.08239995f, 0.15117770f, -0.06179993f, 0.13890438f, -0.09225212f, 0.11800773f, 
    -0.11280578f, 0.11342581f, 0.21472938f, 0.23907304f, 0.02163643f, 0.02501578f, -0.03451161f, -0.08389983f, 
    0.04409937f, -0.12590389f, 0.02829959f, -0.00471201f, -0.03023164f, -0.03663183f, 0.02958572f, -0.02488072f, 
    -0.06318016f, -0.20352340f, -0.16385293f, -0.07064787f, 0.10527687f, -0.00196323f, -0.01396722f, 0.12141779f, 
    -0.02650817f, -0.02774415f, -0.06688132f, 0.14732821f, -0.12099294f, -0.12021538f, -0.03681181f, 0.08703408f, 
    -0.00959043f, 0.07018779f, 0.06360864f, -0.04908282f, 0.00268573f, 0.02377386f, 0.06451631f, 0.03923847f, 
    -0.12864622f, 0.15862375f, 0.20433611f, 0.01191094f, -0.12556481f, 0.14961585f, 0.00403110f, 0.08470979f, 
    0.09145623f, 0.05953097f, -0.01910661f, -0.10463712f, -0.02517682f, 0.18817288f, 0.03457750f, -0.12863417f, 
    -0.00905621f, -0.01334742f, -0.01011240f, -0.01594282f, -0.08341567f, 0.12917410f, -0.01457477f, 0.08037522f, 
    -0.08201740f, 0.34640399f, 0.08436307f, 0.14908129f, -0.05783575f, -0.01468210f, 0.08930678f, 0.05465270f, 
    0.05350089f, -0.00067363f, 0.08605646f, -0.03042373f, 0.04001568f, 0.04038404f, 0.00460587f, 0.24369213f, 
    0.03505451f, -0.00735365f, -0.05688566f, 0.01941080f, 0.02598320f, 0.02379736f, 0.15120639f, 0.08465009f, 
    0.24483748f, 0.03787082f, -0.06734186f, 0.05841194f, 0.04359652f, -0.08353975f, 0.12905538f, 0.13585876f, 
    0.16344470f, -0.05300598f, 0.05663487f, -0.11536631f, -0.04331195f, -0.12950782f, 0.05036155f, 0.03232082f, 
    0.03084076f, 0.09129699f, 0.02893691f, 0.08945088f, -0.00094957f, 0.00981001f, -0.00634567f, 0.13385460f, 
    0.08301400f, 0.22570020f, 0.06702603f, -0.27909136f, -0.02790631f, -0.00139832f, -0.01917564f, 0.05844825f, 
    -0.04056507f, -0.05703583f, 0.05902115f, 0.02759495f, 0.14146149f, 0.02019129f, 0.01239209f, 0.07358777f, 
    0.08847696f, 0.06532954f, 0.22246929f, 0.09765399f, 0.01832572f, -0.00748930f, -0.01915880f, 0.04121051f, 
    0.07323609f, 0.19586198f, 0.03435978f, -0.03457712f, 0.00280961f, 0.05672833f, -0.07264752f, 0.08803247f, 
    0.11589622f, 0.13448769f, -0.02451904f, -0.09921670f, -0.06630290f, 0.22021167f, -0.00792841f, 0.05753998f, 
    0.05209570f, 0.11555958f, 0.08740629f, 0.12955733f, 0.10204170f, 0.03802939f, 0.06087541f, -0.10500854f, 
    -0.16789505f, -0.11342430f, 0.07588809f, -0.29077768f, 0.07631204f, 0.05098690f, 0.01543872f, -0.00854772f, 
    0.10270289f, 0.03635263f, -0.01435259f, -0.08266267f, -0.07463420f, 0.00500319f, -0.13045588f, -0.09973043f, 
    0.15630488f, 0.00421891f, -0.06059911f, -0.00510527f, 0.14081825f, -0.02380738f, -0.04083746f, 0.05354116f, 
    0.20062700f, 0.22307567f, -0.07301683f, 0.20330466f, 0.00199127f, 0.11664747f, 0.04744179f, 0.02416017f, 
    -0.04519212f, 0.00506339f, 0.10928667f, 0.00439967f, -0.09335563f, 0.15619929f, -0.02173570f, 0.12592711f, 
    -0.03408097f, 0.06218096f, 0.14376457f, 0.03471572f, 0.09101281f, 0.01451748f, -0.06166213f, 0.12290262f, 
    0.27575386f, -0.02932180f, 0.26347974f, -0.21269882f, 0.01453693f, 0.10382421f, 0.14558201f, -0.03967541f, 
    0.02682271f, 0.03424837f, 0.15618068f, -0.04200399f, -0.00902418f, 0.09885266f, -0.21592966f, 0.08585300f, 
    0.08718269f, 0.07799096f, -0.03222488f, 0.24837811f, 0.06970835f, 0.18968247f, 0.05300292f, 0.05945312f, 
    -0.14147946f, 0.22860943f, 0.07807714f, -0.08560581f, 0.04273305f, 0.02253115f, 0.08212976f, 0.05575669f, 
    0.08488940f, 0.21070105f, 0.01608136f, 0.03678519f, -0.00863543f, -0.11264651f, -0.24101384f, -0.10059734f, 
    0.11098573f, 0.06225236f, 0.00596515f, 0.08149075f, 0.13198684f, -0.07598195f, 0.19078073f, -0.01080218f, 
    -0.13997771f, 0.13265380f, 0.01994268f, -0.10979874f, -0.02912285f, 0.11756279f, 0.11039450f, 0.03529827f, 
    -0.04621922f, 0.08705284f, -0.07061712f, 0.02697599f, -0.00965075f, 0.19418117f, -0.02330746f, 0.21343206f, 
    0.06903134f, -0.01009126f, -0.03434893f, -0.01948269f, 0.12569602f, -0.02977478f, 0.09978236f, 0.13536295f, 
    0.15969181f, 0.02178446f, 0.07043589f, 0.43332297f, 0.02131501f, 0.03066552f, 0.10286881f, 0.08937777f, 
    0.07890522f, 0.08958402f, 0.02675689f, 0.06010201f, -0.16494067f, 0.12630552f, -0.00867566f, -0.11475807f, 
    -0.00785261f, 0.01933854f, -0.01862925f, 0.02922856f, 0.04554408f, -0.07088293f, 0.04744868f, 0.12006758f, 
    0.04365890f, -0.30038846f, 0.19589093f, -0.04568998f, -0.11996465f, 0.05993098f, 0.17418234f, 0.07259414f, 
    -0.00767411f, 0.01787541f, 0.02161137f, -0.01233787f, -0.09604432f, -0.21948087f, -0.15954624f, 0.00168058f, 
    -0.06006621f, -0.15214783f, 0.00601983f, -0.00579111f, 0.14456294f, 0.14405102f, -0.03421724f, -0.04426131f, 
    0.28802180f, 0.21742165f, -0.09798317f, -0.02391303f, 0.03235126f, -0.00491038f, 0.11827553f, 0.00275577f, 
    0.06341424f, 0.01715865f, 0.03080542f, 0.04338463f, 0.05471477f, -0.23603390f, -0.18008342f, 0.08785435f, 
    0.06771971f, 0.01947780f, 0.06731094f, 0.14645781f, -0.00210524f, 0.00584646f, 0.07057491f, 0.08828840f, 
    -0.12574206f, -0.26489758f, -0.14686823f, 0.07996184f, 0.03234192f, 0.00817482f, -0.08721852f, 0.07350677f, 
    0.05060271f, 0.08942301f, 0.02616416f, 0.09555522f, 0.17710654f, 0.13649322f, 0.16793701f, 0.13635497f, 
    0.08714284f, 0.04910677f, 0.09580497f, 0.15229779f, 0.16816767f, 0.11964222f, -0.10836457f, 0.13848865f, 
    -0.02500221f, 0.27459452f, -0.20540778f, 0.09297860f, 0.18020447f, 0.02938046f, -0.04875870f, -0.03173479f, 
    -0.14877407f, -0.00190410f, 0.04744187f, 0.10592601f, 0.11864278f, 0.00201756f, -0.19938226f, 0.19819312f, 
    0.02066150f, -0.00516338f, 0.04459925f, 0.10771824f, 0.10872658f, -0.00923925f, 0.02356814f, -0.00221544f, 
    -0.13707139f, 0.03438801f, 0.29654914f, 0.02073057f, 0.05074081f, -0.00075829f, 0.02876261f, 0.13227403f, 
    0.04613029f, 0.08690747f, -0.06203498f, 0.13173911f, -0.04736705f, 0.15299588f, -0.10117193f, -0.05527762f, 
    -0.00221393f, 0.11559861f, -0.01905577f, 0.09684069f, 0.01543128f, 0.04471903f, 0.02646906f, 0.09163398f, 
    -0.24004979f, -0.06339799f, -0.01714632f, -0.05799385f, 0.02649090f, 0.12161020f, 0.02896666f, -0.04078754f, 
    0.00232758f, 0.20788485f, 0.08230545f, 0.01769928f, -0.22924723f, -0.08792824f, 0.18244873f, -0.05440339f, 
    -0.05897605f, 0.07880916f, -0.00346229f, -0.01172260f, -0.04173270f, -0.07895161f, 0.01299399f, 0.01074048f, 
    0.19773978f, 0.02133275f, 0.06211948f, -0.04152318f, 0.03679855f, -0.01254450f, 0.13195871f, -0.01523819f, 
    0.05849162f, 0.05915135f, 0.13981245f, -0.04486880f, 0.16351490f, -0.13165238f, -0.12924950f, -0.00101204f, 
    0.17441007f, 0.12531908f, 0.03106860f, 0.09028053f, 0.06093049f, 0.02417144f, -0.03649509f, -0.00285280f, 
    0.00931790f, 0.02831331f, -0.01565276f, -0.01176700f, 0.01429861f, 0.01817514f, -0.02660018f, 0.01918164f, 
    -0.01123224f, 0.00996157f, 0.00372216f, 0.00275546f, 0.02043582f, -0.00894827f, 0.01975768f, 0.00920296f, 
    -0.00730086f, -0.03728826f, 0.01541794f, -0.03640839f, -0.02434195f, 0.00286133f, -0.01052240f, -0.01660062f, 
    0.00921619f, -0.03178490f, 0.02070269f, -0.02653301f, -0.01252003f, -0.03078504f, 0.01456549f, 0.02452250f, 
    0.00820852f, -0.03021021f, 0.01235134f, -0.02918877f, 0.03952923f, 0.00303223f, -0.00719027f, -0.00726516f, 
    0.02533241f, -0.03112753f, 0.01778227f, 0.00390054f, 0.01153807f, 0.01969813f, 0.01560224f, -0.00992008f, 
    0.01071637f, -0.02092338f, -0.00764490f, 0.01800916f, -0.03174070f, 0.01522214f, 0.02252608f, -0.01262532f, 
    -0.00327420f, -0.00773757f, 0.01669216f, -0.00881701f, 0.03586654f, -0.02304964f, -0.03056738f, -0.02269464f, 
    -0.01371006f, -0.00509482f, -0.03695799f, -0.03330793f, -0.00711792f, -0.02537183f, -0.01965694f, -0.02423004f, 
    -0.01519309f, -0.03952640f, 0.02203164f, -0.02636963f, -0.01439519f, -0.02959919f, 0.03059652f, -0.00162767f, 
    0.00130634f, -0.00444333f, -0.02555940f, 0.00708204f, -0.00315830f, -0.03512115f, 0.02420072f, -0.01100948f, 
    0.02733291f, -0.02457890f, -0.03951923f, -0.03999510f, -0.03560212f, 0.00972834f, 0.01225132f, 0.01976156f, 
    -0.02904509f, -0.00697555f, 0.01535426f, 0.01034323f, -0.02179541f, -0.01652871f, -0.00163399f, -0.03272584f, 
    0.02977376f, -0.03174724f, 0.01582180f, -0.00325824f, -0.03064821f, -0.00024930f, -0.01801511f, -0.02231980f, 
    0.02689104f, -0.01980886f, -0.00609151f, 0.01002244f, -0.00285016f, -0.03184485f, -0.00610936f, 0.02161198f, 
    0.02631637f, 0.00743649f, -0.03427221f, -0.00579320f, 0.01973222f, 0.00002568f, 0.02734460f, 0.01400894f, 
    0.01884918f, 0.02528674f, 0.02229975f, 0.01304748f, -0.01027205f, -0.01916180f, 0.02904342f, 0.02546527f, 
    0.00057361f, 0.02672838f, -0.00528611f, -0.03383048f, -0.02141978f, 0.00443761f, 0.00319475f, 0.01007849f, 
    -0.02885429f, 0.00746269f, 0.02259730f, -0.00776693f, 0.01811381f, 0.01501106f, 0.03144506f, 0.00904816f, 
    0.00353928f, -0.03991606f, -0.03972707f, -0.01003719f, -0.02369404f, -0.04120718f, 0.02577895f, -0.00247184f, 
    -0.02280600f, -0.01351506f, 0.01223055f, -0.02381706f, 0.00264452f, -0.01273901f, -0.00795098f, 0.00990719f, 
    0.01236538f, -0.00697822f, -0.04218171f, -0.03559311f, -0.01465515f, 0.02958054f, 0.01555554f, 0.02181998f, 
    0.04076499f, -0.00484304f, -0.00031715f, 0.02471711f, -0.00020476f, -0.03067551f, 0.00664258f, 0.03382087f, 
    0.01645692f, 0.00572613f, -0.02699675f, 0.03468900f, -0.03755496f, 0.02651296f, -0.04063812f, -0.03185001f, 
    -0.00979987f, 0.00848072f, 0.01181494f, -0.01379862f, -0.00824481f, 0.00260264f, 0.02831518f, 0.02789463f, 
    -0.01356671f, 0.01936750f, -0.03778929f, 0.01366910f, 0.00639447f, 0.02021872f, -0.04146835f, 0.00535038f, 
    -0.04013503f, -0.00734259f, -0.00812820f, -0.01783871f, 0.01186154f, -0.00190608f, -0.03796357f, -0.02042321f, 
    0.01003882f, -0.02143218f, 0.03359092f, -0.02297753f, 0.00148634f, -0.00046449f, 0.01681760f, -0.01833608f, 
    -0.01959734f, -0.01926262f, 0.03470260f, 0.00254920f, 0.03894874f, 0.00404848f, -0.01404014f, 0.00072701f, 
    -0.01201468f, 0.02394825f, -0.04152361f, -0.01330728f, -0.01268580f, 0.02206794f, 0.02944338f, -0.02499344f, 
    0.02813864f, 0.02285800f, 0.00029406f, -0.01209726f, 0.01046491f, 0.03625838f, -0.03171522f, 0.00275569f, 
    0.00521880f, -0.00780029f, -0.03161028f, 0.02981608f, -0.04150705f, 0.01376927f, -0.00551635f, -0.03307156f, 
    -0.00365742f, -0.01092978f, -0.03265360f, -0.03300533f, -0.02899123f, -0.03509216f, -0.03345287f, 0.00579184f, 
    0.01305351f, 0.03147180f, -0.01000286f, -0.02210465f, -0.00569735f, 0.01346507f, -0.03537880f, 0.03078678f, 
    0.01941232f, -0.03485101f, 0.00352893f, -0.03716153f, -0.02699898f, -0.00879520f, -0.01296106f, -0.00589988f, 
    -0.00215951f, 0.02505186f, -0.01977648f, -0.02222732f, 0.00980952f, 0.02500805f, -0.00597196f, -0.01405207f, 
    -0.03309507f, -0.01417616f, 0.00435128f, -0.03089153f, -0.02696079f, 0.00177002f, -0.02329599f, -0.04006838f, 
    0.01447536f, -0.03152487f, 0.01909582f, -0.03748126f, -0.01187704f, -0.02833321f, -0.00988134f, -0.01564726f, 
    -0.04216953f, -0.00499973f, 0.00084369f, -0.02572880f, -0.00646801f, -0.01889556f, 0.00527373f, 0.01061009f, 
    0.01939766f, -0.00710744f, 0.00696565f, 0.01910089f, -0.03106099f, -0.01995407f, -0.03027964f, 0.00700562f, 
    0.01021428f, 0.02144596f, 0.00256065f, 0.01617260f, 0.00057225f, 0.02731481f, 0.03573831f, -0.04340503f, 
    0.03222181f, 0.01067431f, -0.03888579f, 0.01640351f, -0.01972320f, 0.00359393f, -0.01809784f, -0.00836089f, 
    0.00268066f, -0.02069098f, 0.02185982f, 0.00953486f, -0.01469991f, 0.00125431f, -0.01113458f, -0.01725361f, 
    -0.00657489f, -0.00971736f, 0.00594803f, -0.03026734f, -0.01291908f, 0.00391469f, 0.00397821f, -0.02527204f, 
    0.00356483f, -0.03076598f, 0.01494358f, -0.03581635f, -0.00399227f, -0.01333126f, 0.01796136f, -0.00839982f, 
    0.00269372f, -0.00210408f, 0.03267875f, -0.03134973f, -0.01555518f, 0.00369059f, -0.00148766f, -0.03560403f, 
    -0.04005944f, 0.00594148f, -0.02394822f, -0.03055053f, -0.02070584f, 0.00197586f, -0.03016809f, -0.03527080f, 
    -0.02779720f, 0.01029928f, 0.01668163f, 0.02267679f, 0.01885058f, 0.00640978f, 0.01430156f, -0.02641811f, 
    0.01078145f, -0.03162802f, -0.00585717f, -0.02572820f, 0.00772456f, -0.01383139f, -0.02158748f, -0.00935849f, 
    0.03318359f, -0.00608324f, 0.00249522f, 0.02503556f, 0.03217669f, -0.01534303f, -0.03889982f, -0.01830020f, 
    -0.02444607f, -0.01244667f, -0.03265024f, 0.03708813f, 0.02299461f, 0.01110126f, -0.02052781f, -0.01665846f, 
    0.00500161f, -0.01000686f, 0.02780032f, 0.03158234f, -0.02733750f, -0.00403369f, -0.00794669f, 0.01532598f, 
    -0.01667260f, -0.03062642f, 0.02615952f, -0.00236567f, 0.02149807f, -0.00092972f, -0.00067017f, -0.00603066f, 
    0.00942589f, 0.02764807f, 0.00420696f, -0.01693818f, 0.00799110f, -0.01194955f, 0.01905931f, 0.00942129f, 
    -0.02969364f, 0.03383771f, -0.00458497f, 0.00165733f, 0.03766131f, -0.00017272f, -0.00520525f, -0.00420260f, 
    -0.00563818f, 0.02141006f, -0.02199767f, 0.03574315f, 0.01097592f, 0.01200982f, -0.01054771f, 0.02455949f, 
    -0.03012508f, -0.02849779f, -0.02108902f, -0.00773651f, -0.00876555f, -0.02078717f, -0.03152110f, 0.02961377f, 
    -0.01064146f, -0.02685342f, -0.02075791f, -0.01562717f, 0.01619583f, 0.03043199f, -0.03614708f, 0.01702893f, 
    -0.02960186f, -0.01762472f, -0.03848434f, 0.02499144f, -0.03328707f, 0.02728152f, 0.04077747f, -0.02103912f, 
    -0.00001251f, -0.02818805f, -0.03608518f, -0.03695583f, -0.03720504f, -0.03517563f, 0.02159761f, -0.01452139f, 
    0.00713085f, -0.02303569f, -0.01206907f, -0.01517895f, 0.04150096f, -0.01488420f, -0.01785130f, -0.00371850f, 
    -0.02543209f, 0.00400951f, 0.00461537f, -0.01136194f, -0.00353428f, -0.01320063f, -0.02078162f, 0.03712528f, 
    0.02321410f, 0.00552513f, -0.01221737f, -0.03291744f, -0.01034794f, -0.01386048f, -0.00095217f, -0.02980232f, 
    -0.03243142f, 0.00056825f, -0.00173846f, 0.02367303f, 0.01048638f, 0.02950106f, 0.02013198f, -0.00378707f, 
    0.03168394f, -0.01013357f, -0.00174309f, 0.02128050f, -0.00380048f, -0.01052330f, -0.00614277f, -0.00790705f, 
    -0.02689060f, 0.02565237f, -0.02270598f, -0.01064378f, -0.03285455f, -0.01684078f, 0.01848904f, -0.00244693f, 
    0.02617870f, 0.01708236f, -0.03943673f, 0.01181857f, 0.01235886f, 0.01754948f, -0.02253047f, -0.03866750f, 
    0.02181341f, -0.01905569f, -0.01932165f, -0.02404520f, -0.01447183f, -0.03046868f, -0.02347467f, 0.00616406f, 
    0.02070648f, 0.00851003f, -0.03081049f, 0.02770671f, 0.02832841f, -0.01665103f, -0.00120652f, -0.01747088f, 
    -0.02502703f, -0.00372507f, 0.00173051f, 0.01951048f, -0.00584790f, 0.00799027f, 0.00423241f, -0.00310322f, 
    0.00105437f, -0.02003091f, -0.03502130f, -0.03414116f, -0.01275907f, 0.02225067f, 0.02030141f, 0.02489779f, 
    0.01360851f, -0.00962776f, -0.01402693f, 0.02204407f, -0.04108927f, -0.00126816f, -0.03854112f, 0.02045112f, 
    0.01120574f, 0.01674935f, 0.00427461f, 0.00870630f, -0.00916205f, -0.01260428f, -0.01443814f, 0.01335708f, 
    -0.00211442f, 0.00860892f, 0.02935620f, -0.02197820f, 0.02170142f, -0.02789409f, 0.00420434f, -0.02470112f, 
    -0.02580934f, 0.01900614f, 0.03175141f, -0.00678943f, -0.02666978f, 0.02177048f, -0.02860283f, 0.03275023f, 
    0.03305212f, -0.00566748f, 0.01376016f, -0.01357437f, 0.00104502f, -0.01678784f, -0.01807899f, -0.00093825f, 
    -0.02159342f, 0.03582942f, 0.02414619f, -0.01982736f, -0.00315078f, 0.00884058f, -0.02398801f, -0.00983866f, 
    -0.02552834f, -0.03985169f, 0.00217950f, -0.03452802f, 0.01402072f, -0.01376148f, 0.02946190f, -0.02874316f, 
    -0.02416472f, -0.00779583f, -0.03683668f, -0.03668800f, 0.01757683f, -0.03773701f, -0.04187325f, 0.02995365f, 
    -0.03046499f, 0.01558391f, -0.03288380f, 0.01036908f, 0.01115090f, -0.02463891f, -0.02264249f, -0.03847142f, 
    -0.03346135f, -0.00877581f, -0.04001614f, -0.03272989f, 0.00705912f, 0.01479188f, -0.03671710f, 0.00186614f, 
    -0.01533174f, 0.02361000f, -0.03329816f, 0.01365819f, 0.02694470f, -0.01605122f, 0.01383163f, -0.03275410f, 
    -0.00503022f, -0.00023249f, -0.01860261f, -0.00057656f, -0.00490504f, 0.01986476f, 0.01194229f, 0.01332831f, 
    0.01191255f, -0.01460580f, 0.00120538f, 0.02951036f, 0.01105064f, -0.00413890f, 0.02103697f, -0.01774466f, 
    -0.00210087f, 0.03835254f, -0.00773501f, -0.00431998f, -0.03179418f, -0.04138280f, 0.02745549f, 0.03392168f, 
    0.00487422f, -0.00540982f, -0.01308179f, -0.03897132f, -0.01480803f, 0.01101935f, -0.03490144f, -0.02862983f, 
    0.01202153f, -0.03261780f, 0.01361729f, -0.01804461f, -0.03991482f, -0.03523613f, -0.01166332f, -0.02192546f, 
    -0.04152407f, -0.01110554f, -0.01768252f, -0.01540103f, -0.04294832f, 0.02277803f, 0.00762306f, -0.00437843f, 
    0.01243572f, -0.03268327f, 0.01053821f, 0.02696381f, -0.02695359f, -0.02725129f, -0.00498811f, 0.01510144f, 
    -0.01806442f, -0.00977818f, 0.01628226f, -0.03169420f, 0.00191341f, 0.02065694f, -0.01870032f, -0.01749890f, 
    0.01691093f, 0.02416479f, -0.01237928f, -0.02216999f, 0.03049224f, -0.03069502f, -0.01339983f, 0.00669567f, 
    0.01339589f, -0.04412828f, 0.01045123f, 0.01296857f, 0.01246153f, -0.00023109f, 0.03735827f, 0.00248795f, 
    -0.01522462f, -0.01491129f, -0.01883187f, -0.00149872f, 0.02347612f, 0.01666070f, -0.03205862f, -0.03194632f, 
    0.00589000f, -0.00841647f, -0.03102774f, 0.01358571f, -0.03033923f, 0.00444142f, 0.02388941f, 0.03648585f, 
    0.00171655f, 0.02175700f, -0.03061173f, -0.02847255f, -0.00497317f, -0.00447561f, -0.00071933f, 0.02815480f, 
    0.01887024f, -0.03577254f, -0.02318258f, 0.00926354f, 0.00680998f, -0.01988679f, 0.01597041f, 0.00581112f, 
    -0.03710543f, 0.00225973f, -0.02550851f, -0.01137351f, 0.01785137f, 0.00093805f, -0.00019651f, 0.02337395f, 
    -0.01106445f, -0.01777433f, -0.01369381f, 0.01304602f, -0.02661139f, -0.00406194f, -0.02850141f, -0.02561978f, 
    0.01723430f, 0.02178982f, 0.02439415f, 0.02518556f, -0.00359029f, -0.04066689f, -0.00589436f, 0.01530273f, 
    0.02646024f, 0.01995402f, -0.00779222f, 0.02478103f, -0.03166005f, 0.00293004f, -0.02190193f, -0.00021656f, 
    0.00278035f, -0.02316769f, 0.01890985f, 0.00969615f, -0.02272557f, -0.00093932f, 0.02182067f, -0.03435770f, 
    0.02884734f, 0.00607797f, -0.02691141f, 0.02122734f, -0.01416109f, -0.02907435f, 0.01829923f, -0.03321150f, 
    -0.02022271f, -0.01231846f, -0.01130782f, 0.00797232f, 0.00510441f, 0.02744698f, -0.03716440f, -0.02035606f, 
    0.02629716f, 0.02842626f, -0.01993827f, -0.02636137f, -0.00449771f, 0.01186319f, 0.00754643f, -0.02347257f, 
    -0.00377591f, -0.04108471f, -0.04050381f, -0.00526482f, 0.00218203f, -0.00463363f, -0.02563134f, 0.01074849f, 
    0.02329835f, 0.01823549f, 0.00324026f, -0.00724649f, 0.00931043f, 0.01893467f, -0.03457414f, -0.00496664f, 
    0.02373905f, 0.02404650f, -0.02246744f, 0.00005619f, -0.01061348f, 0.01809960f, 0.00406495f, -0.02012755f, 
    0.01624438f, -0.02733642f, -0.01568918f, -0.01145034f, -0.01593023f, -0.03044358f, 0.02779740f, 0.02610016f, 
    -0.00091745f, 0.01820091f, 0.00095363f, -0.01303483f, -0.00342697f, 0.02990799f, -0.03382232f, 0.01207310f, 
    -0.00552297f, 0.01651713f, 0.02390174f, 0.00294225f, 0.02859531f, 0.01411409f, -0.03683897f, 0.01151238f, 
    -0.02097344f, -0.00310911f, -0.04149189f, -0.03416148f, -0.02099128f, -0.01139965f, -0.01259335f, 0.00736576f, 
    -0.00461246f, -0.01967379f, -0.00461408f, -0.01604188f, -0.01024071f, 0.01261914f, -0.00685486f, 0.02561110f, 
    -0.01221217f, 0.01090304f, -0.01846060f, 0.00480434f, -0.03414738f, -0.01091728f, -0.02930649f, -0.02269008f, 
    0.02527291f, -0.02885797f, 0.00242351f, 0.00017708f, 0.00697294f, -0.03545143f, -0.00545846f, 0.02958188f, 
    -0.03447706f, 0.01728689f, 0.00829302f, -0.03610453f, -0.02283091f, -0.03675275f, 0.02604330f, -0.00550877f, 
    -0.03093163f, -0.02400772f, -0.03220408f, -0.00521028f, -0.01964745f, -0.04006385f, -0.01660948f, -0.00060608f, 
    -0.01400349f, -0.02835529f, 0.01586947f, 0.00872905f, -0.00821323f, 0.02729767f, 0.00183726f, -0.03439093f, 
    -0.00019531f, -0.01895586f, -0.02102907f, -0.01357007f, 0.00475769f, -0.02627199f, -0.03427210f, 0.02733237f, 
    0.02878959f, 0.02610525f, -0.03237240f, 0.02955294f, 0.02702443f, 0.02011457f, -0.04130019f, -0.02720625f, 
    -0.02625870f, 0.02079431f, 0.02860440f, -0.00640802f, 0.02788735f, -0.00499781f, -0.03446994f, -0.00323634f, 
    -0.03410968f, 0.00338408f, -0.01288381f, 0.00429813f, 0.00401472f, -0.01422016f, -0.02135287f, -0.01888531f, 
    -0.01208096f, -0.01528929f, -0.02377410f, 0.00864498f, 0.00446440f, -0.02701130f, 0.01449406f, -0.00705551f, 
    0.02520928f, 0.00169956f, -0.00741340f, -0.01738758f, -0.02359363f, 0.00393133f, -0.01683404f, 0.00859257f, 
    -0.00966703f, -0.03137140f, 0.02266585f, -0.02855129f, 0.02532446f, -0.01154827f, -0.00362071f, -0.01959801f, 
    -0.00091679f, -0.00982846f, -0.01824098f, -0.01793556f, -0.01285615f, 0.02982660f, -0.02127172f, 0.02983915f, 
    -0.00939319f, -0.01085312f, -0.02886117f, -0.00616078f, -0.00131228f, -0.03651176f, 0.02270107f, -0.01206496f, 
    -0.00672859f, -0.03181154f, 0.00501592f, -0.03141034f, -0.01350118f, -0.00806795f, 0.01989239f, 0.01618901f, 
    -0.01788574f, 0.00464546f, -0.02451605f, -0.03990281f, -0.00529751f, 0.01647588f, 0.01893329f, 0.01867543f, 
    -0.01082258f, -0.01777702f, 0.01087598f, -0.00003087f, -0.00166430f, 0.02539906f, 0.00874304f, 0.00931931f, 
    0.02963957f, 0.01117581f, 0.00488108f, -0.00887094f, -0.01732981f, -0.01076632f, -0.01128110f, 0.01812246f, 
    -0.00410890f, 0.01736299f, -0.01108628f, -0.01059405f, 0.02122738f, -0.00899425f, 0.02055110f, 0.00188105f, 
    -0.02042661f, -0.03611920f, 0.02571674f, -0.00454632f, -0.01653630f, 0.02073090f, -0.03170835f, 0.00324703f, 
    0.01385415f, 0.02525930f, -0.00785582f, 0.00537217f, -0.03052552f, 0.00339901f, 0.02929811f, 0.02704932f, 
    0.00196025f, 0.02990646f, 0.01501940f, -0.00623938f, -0.00276639f, -0.01705823f, -0.03593365f, -0.01295880f, 
    0.00888863f, -0.03154068f, -0.01536005f, 0.00003638f, -0.00370067f, -0.00194049f, -0.02537921f, -0.01224547f, 
    0.00531783f, 0.02986079f, -0.01451444f, -0.02611413f, 0.00535006f, -0.03977630f, 0.02199977f, -0.00422653f, 
    -0.01936522f, -0.02370694f, 0.01179680f, -0.04038772f, -0.00209350f, -0.02436029f, 0.00495865f, -0.00747135f, 
    -0.03852202f, -0.02272141f, -0.01087941f, 0.02545300f, 0.02929229f, 0.00287637f, -0.02168685f, -0.03242397f, 
    -0.03388403f, -0.00074721f, 0.02513639f, 0.01633631f, -0.02776580f, 0.02480245f, -0.00982477f, -0.04001615f, 
    0.02176981f, -0.00211695f, -0.00429182f, 0.02833514f, 0.01287728f, -0.03329060f, -0.03045354f, 0.02835840f, 
    -0.03015122f, -0.03558513f, 0.02101131f, -0.01019042f, 0.00066358f, -0.01223242f, 0.02190553f, -0.03880351f, 
    0.01943771f, -0.00087443f, -0.02949281f, 0.01736943f, -0.01002348f, -0.03602961f, 0.01869093f, -0.02916914f, 
    0.02015043f, -0.01894530f, 0.00882788f, 0.01293157f, -0.03288649f, 0.00436395f, 0.02461556f, -0.00446707f, 
    -0.00971841f, 0.02958975f, -0.01183844f, -0.04204211f, 0.00714940f, -0.02277260f, 0.00027860f, -0.03657902f, 
    -0.02465114f, -0.02695843f, -0.03057924f, 0.00632979f, 0.00997647f, -0.00048794f, -0.03829314f, -0.03877747f, 
    0.01601550f, -0.03754051f, 0.01135790f, 0.01396258f, 0.01150276f, -0.04021499f, 0.01566867f, -0.01110599f, 
    -0.03552442f, 0.02366486f, -0.00059860f, -0.00185143f, -0.01524687f, -0.00710753f, -0.01947350f, -0.02784516f, 
    -0.03007175f, -0.01335184f, -0.02542705f, -0.03289022f, 0.01803354f, -0.03868979f, 0.01912579f, 0.02779960f, 
    0.02150415f, 0.02870553f, 0.02678074f, 0.00419767f, -0.01656347f, 0.00746931f, -0.02238745f, -0.01950633f, 
    0.00006224f, -0.00998076f, -0.03025112f, -0.01106457f, -0.02851357f, -0.03575754f, -0.03924998f, -0.01860775f, 
    -0.02973490f, -0.04022830f, 0.00327950f, -0.03967230f, 0.02913604f, -0.00535670f, -0.01913380f, -0.02711308f, 
    -0.01888192f, 0.02734159f, -0.01641469f, -0.02857437f, -0.04160536f, 0.01114476f, 0.00311525f, -0.03722849f, 
    -0.01275837f, -0.02146439f, 0.01094582f, -0.00988314f, -0.00937733f, 0.01088674f, -0.01391860f, -0.02075522f, 
    0.00648515f, -0.02011239f, -0.01059918f, -0.02487631f, 0.00726165f, 0.02796618f, -0.03816372f, -0.00412602f, 
    0.02468490f, -0.02834681f, 0.00022134f, 0.00411067f, -0.04145714f, -0.01700469f, -0.02923053f, -0.00163733f, 
    -0.03104196f, -0.00714360f, 0.00004588f, -0.03319366f, -0.00751421f, -0.03644490f, 0.02357619f, -0.00139843f, 
    0.00034267f, 0.01035085f, -0.01272167f, 0.02142361f, -0.02690843f, 0.02785790f, -0.02033105f, -0.01478148f, 
    -0.03499712f, -0.01672483f, 0.01140495f, -0.00447384f, 0.01646111f, -0.03683505f, 0.02850668f, 0.02039889f, 
    -0.00024905f, -0.02426390f, 0.02883941f, -0.02427511f, -0.01295712f, -0.03707265f, -0.00811164f, -0.02610907f, 
    0.01670238f, -0.04202149f, -0.02383974f, -0.03179327f, -0.01206344f, 0.02958937f, 0.02204551f, -0.03858430f, 
    -0.03718062f, 0.00351873f, 0.01410317f, -0.03201631f, 0.02938218f, -0.03626139f, -0.03558489f, 0.00594829f, 
    -0.02168399f, -0.01683921f, -0.00576066f, 0.01625766f, 0.01501093f, -0.00537417f, 0.01522677f, -0.04104668f, 
    -0.00692351f, -0.03571126f, 0.02054825f, 0.02931451f, -0.04021428f, -0.00764272f, 0.00028824f, -0.00509335f, 
    -0.02709462f, -0.02255465f, -0.03935720f, 0.02750574f, 0.00285195f, -0.02766761f, -0.00090477f, 0.02896231f, 
    0.00285711f, 0.00492840f, -0.02220113f, 0.00909637f, -0.01362822f, -0.01205281f, 0.02284674f, -0.01689291f, 
    -0.04064321f, 0.02888605f, 0.01949674f, -0.01350044f, -0.01277384f, -0.00208956f, -0.00181719f, 0.01732183f, 
    -0.01527044f, 0.02198126f, -0.03509832f, -0.02358650f, -0.03351792f, -0.02178033f, -0.01660267f, -0.03915291f, 
    0.02253691f, -0.01638235f, -0.03912418f, 0.00428709f, -0.01877892f, 0.02213925f, 0.00029182f, -0.01917960f, 
    0.01490840f, -0.02251592f, -0.01126710f, -0.03540980f, -0.02456498f, -0.01450717f, 0.01911316f, 0.01467389f, 
    -0.02906310f, -0.02194095f, -0.03922017f, 0.02711425f, -0.02339993f, -0.00283477f, 0.01791619f, 0.00210084f, 
    -0.03364283f, 0.01391887f, -0.03502890f, -0.01897663f, 0.00093055f, 0.01647625f, -0.00645555f, -0.01944178f, 
    -0.00181428f, -0.01251256f, 0.00337091f, -0.02362688f, 0.00418075f, 0.01042656f, -0.04124038f, 0.01556225f, 
    0.01707122f, -0.01617184f, -0.03861340f, -0.02641767f, -0.00796667f, -0.02740292f, 0.02677037f, -0.00347026f, 
    -0.00158090f, 0.01259995f, -0.03557491f, -0.00883352f, -0.02316399f, -0.03120611f, -0.02735393f, 0.02077580f, 
    0.02631046f, -0.04036170f, -0.00037063f, 0.02482880f, 0.00124376f, -0.03687259f, -0.04204424f, 0.01172732f, 
    0.01944868f, -0.02298359f, -0.02547023f, -0.00715838f, 0.00062697f, -0.01802788f, -0.01416935f, 0.02591805f, 
    0.01673785f, -0.03888660f, -0.03478238f, 0.01125071f, -0.02393324f, -0.00264336f, -0.00498914f, -0.01358662f, 
    -0.01283795f, -0.03092016f, -0.00319741f, -0.04034869f, -0.02829945f, 0.02802065f, -0.00850134f, -0.01999893f, 
    -0.00372860f, -0.00067075f, -0.00143277f, 0.00564124f, 0.02942445f, 0.00263233f, -0.03337911f, 0.02570349f, 
    -0.00036576f, -0.00174359f, 0.02538461f, -0.00823184f, 0.01747315f, -0.03118679f, 0.01952842f, -0.01062643f, 
    -0.01443880f, -0.04174997f, 0.02383098f, -0.03506391f, -0.00856386f, 0.01007446f, -0.03208714f, -0.01947836f, 
    -0.04069974f, -0.00759016f, 0.02410668f, 0.01603259f, 0.02171644f, -0.03825571f, -0.02320358f, -0.03465748f, 
    -0.00826477f, 0.00903167f, -0.03505642f, 0.02174763f, -0.02799986f, 0.01209841f, 0.02356246f, 0.01852864f, 
    -0.00915618f, 0.01190501f, -0.03111459f, -0.00105340f, 0.02776404f, 0.00546090f, 0.00890702f, -0.01855855f, 
    -0.02780446f, -0.02721212f, 0.02095146f, -0.03056467f, 0.02389303f, -0.04055505f, -0.03441639f, 0.02314335f, 
    -0.01814711f, -0.01689721f, -0.01776665f, -0.00734484f, 0.01053833f, 0.00657560f, -0.03549600f, 0.00822482f, 
    -0.01881321f, -0.02320795f, -0.03488815f, 0.01311326f, 0.00288120f, -0.01887946f, -0.01769384f, 0.02849381f, 
    -0.03974432f, -0.00098753f, 0.00408450f, -0.03303842f, 0.02764099f, -0.04191282f, -0.03211516f, -0.03230354f, 
    -0.01733089f, -0.02651828f, -0.02124675f, -0.03638057f, -0.00360222f, -0.03726038f, 0.01781903f, -0.01160810f, 
    -0.00948212f, 0.02435596f, 0.02654348f, 0.01270526f, -0.03016125f, -0.03056599f, -0.00448225f, 0.01833872f, 
    -0.00881471f, 0.02053951f, -0.00471396f, -0.01326135f, -0.00885405f, 0.02623168f, 0.02979724f, -0.01639706f, 
    0.01452503f, -0.01213367f, -0.01599926f, -0.00901814f, -0.02761945f, 0.01919033f, -0.02400269f, -0.02132298f, 
    -0.01081468f, 0.00596718f, 0.00965455f, -0.02870408f, -0.02322791f, 0.02546330f, -0.02824027f, -0.01350514f, 
    -0.02991220f, 0.01193682f, -0.00881259f, 0.02352078f, 0.00351316f, -0.03129535f, 0.01153196f, 0.03154445f, 
    -0.01965470f, -0.01262037f, -0.00672106f, 0.01752524f, 0.01357787f, -0.01719222f, -0.00127797f, -0.02239968f, 
    0.00860994f, -0.01076513f, -0.02459177f, -0.01491882f, 0.02081716f, -0.01092131f, 0.00465833f, -0.00485115f, 
    0.00669998f, -0.01448746f, 0.02493575f, -0.00297942f, 0.00086048f, -0.03918281f, -0.02287300f, 0.01789037f, 
    -0.01911675f, -0.01733022f, 0.01076013f, -0.02342692f, -0.00656036f, 0.02108923f, -0.00191834f, 0.00687949f, 
    0.01886315f, -0.01151401f, -0.02494715f, -0.04038541f, 0.01818401f, -0.01146591f, -0.02825535f, 0.02796097f, 
    -0.02789246f, 0.01888857f, -0.02023061f, 0.00304327f, -0.03369328f, -0.02902267f, -0.03268057f, -0.01471999f, 
    -0.01024939f, 0.02807194f, 0.02347933f, 0.00141075f, 0.00794841f, -0.02076741f, -0.00742564f, 0.02733650f, 
    0.00981861f, -0.00798598f, 0.02358005f, 0.01681937f, 0.02845222f, 0.00948331f, -0.00120147f, -0.00211384f, 
    -0.00010805f, -0.00757050f, 0.02737311f, -0.01713028f, 0.00247719f, 0.01168500f, 0.00654606f, 0.01134045f, 
    -0.03806091f, 0.00396898f, -0.02928228f, 0.00601330f, -0.01598657f, -0.03198099f, -0.00037566f, 0.01370775f, 
    0.01987327f, -0.02990794f, -0.01429258f, 0.01373949f, 0.02584846f, -0.02157915f, 0.02764243f, -0.00879576f, 
    0.00495054f, -0.03032108f, -0.04051736f, -0.01943859f, 0.00586119f, -0.00146664f, -0.01369911f, -0.01098178f, 
    0.00833454f, -0.03344859f, -0.02158904f, 0.01042033f, -0.01305969f, -0.02295659f, -0.03281541f, 0.02046295f, 
    -0.03456719f, 0.00753713f, -0.02370379f, -0.00922569f, -0.04000418f, -0.00636803f, -0.02681938f, 0.01459370f, 
    0.01216531f, -0.01309318f, 0.00957376f, 0.02264271f, 0.01743052f, -0.03372975f, 0.00350469f, -0.03437207f, 
    -0.02781013f, 0.01220064f, -0.03604305f, 0.00684540f, -0.02596811f, -0.00319867f, 0.00094105f, 0.00894024f, 
    -0.03770259f, 0.02012830f, -0.00458049f, -0.03066275f, -0.00235832f, -0.01656927f, -0.02649435f, 0.02078672f, 
    0.01386670f, -0.03924252f, 0.01487443f, -0.02772382f, 0.00589734f, -0.00267972f, 0.03106678f, 0.00183901f, 
    0.00443076f, 0.01879159f, -0.00518966f, -0.02705157f, -0.01288003f, -0.00615739f, 0.00755287f, -0.03971520f, 
    -0.03000535f, -0.02668750f, 0.00718305f, -0.02152259f, -0.02453204f, -0.02125699f, -0.02165807f, 0.00031844f, 
    0.01104823f, -0.02648755f, -0.02149624f, -0.01358980f, 0.00351632f, 0.00293614f, 0.00584622f, 0.01220428f, 
    0.02156381f, 0.02141423f, 0.01894668f, -0.00711888f, -0.03531102f, -0.00518782f, 0.02926804f, -0.00753414f, 
    0.02434270f, 0.01215305f, -0.03656122f, -0.01675630f, -0.02394366f, 0.02279527f, 0.02469133f, 0.00948132f, 
    0.02188639f, -0.01393869f, -0.00642378f, -0.03896428f, -0.01103471f, -0.01785161f, 0.00928454f, -0.00876831f, 
    -0.02453784f, 0.02119349f, 0.01266237f, 0.00571428f, 0.01268094f, 0.02565492f, -0.01605864f, 0.02179582f, 
    -0.01045058f, -0.00762939f, -0.00117199f, -0.00243655f, -0.03513431f, 0.01126711f, -0.03967559f, -0.03570312f, 
    0.00244207f, -0.00752873f, -0.00145245f, 0.01908376f, 0.01601428f, -0.01423771f, -0.00375228f, -0.03680902f, 
    -0.03562309f, 0.00992097f, 0.00713156f, 0.03138589f, -0.02524276f, -0.03064774f, 0.02632653f, -0.03109445f, 
    -0.02695840f, -0.04033819f, 0.02903195f, 0.03032882f, -0.01378169f, -0.03922103f, 0.02503971f, 0.01450182f, 
    0.01202735f, 0.02568839f, -0.02537430f, -0.01724431f, 0.02691394f, -0.00002935f, 0.01316721f, 0.03177663f, 
    -0.01377751f, -0.00165774f, -0.03365026f, -0.00320019f, -0.03575706f, 0.00335552f, 0.01873433f, -0.01859239f, 
    -0.02036333f, 0.02175812f, -0.03507469f, -0.00559925f, -0.01879463f, 0.01060417f, 0.02007228f, -0.01830553f, 
    0.00404683f, -0.02829260f, -0.01087682f, -0.03831216f, 0.02989280f, -0.00087761f, -0.02520297f, -0.03158301f, 
    -0.02589415f, -0.01090271f, -0.01701964f, -0.03121229f, 0.00790753f, 0.01361624f, -0.02394295f, -0.01796028f, 
    -0.02758693f, 0.02301249f, 0.00089469f, -0.00492085f, 0.01587068f, 0.00474430f, 0.01105896f, -0.03480804f, 
    -0.03722725f, -0.01607643f, -0.00767654f, 0.02296765f, 0.01472829f, -0.02512326f, 0.01012311f, 0.00765951f, 
    0.00302795f, -0.01803240f, -0.03524032f, -0.03156993f, -0.01821155f, -0.01502623f, -0.01587738f, -0.01997372f, 
    0.02212637f, 0.00364281f, 0.01605160f, -0.00226312f, 0.01136806f, 0.01515871f, -0.00289993f, -0.01740931f, 
    0.02147694f, -0.02972578f, 0.02893146f, 0.01442205f, 0.00372637f, 0.01002992f, -0.03483356f, -0.00468554f, 
    -0.00374498f, -0.03470079f, -0.00977612f, -0.02498807f, 0.01770936f, -0.03647882f, -0.00812015f, -0.01644209f, 
    -0.01385975f, 0.01947060f, 0.01055089f, -0.01403513f, 0.01753199f, 0.00312448f, 0.00974682f, -0.03053206f, 
    -0.00941629f, -0.01421408f, -0.01920616f, -0.03724816f, -0.01845930f, 0.02567124f, -0.00160164f, -0.03144661f, 
    -0.02324907f, -0.02631467f, -0.03123912f, -0.01122880f, -0.02629868f, 0.00594564f, 0.01961879f, 0.01726429f, 
    0.02908997f, -0.00364200f, -0.00386635f, 0.01406856f, 0.00322665f, 0.02597526f, -0.00224193f, -0.02055196f, 
    0.01889812f, -0.00540064f, -0.02832309f, 0.00164113f, -0.00220736f, 0.02401904f, -0.01242896f, -0.00446618f, 
    0.02986596f, -0.03702650f, 0.01228840f, 0.01043626f, 0.02970296f, 0.01700799f, 0.00687876f, -0.00676487f, 
    0.01853469f, 0.00733721f, -0.03265768f, -0.01961317f, 0.02297686f, 0.01939927f, -0.00506231f, 0.00558493f, 
    -0.01172296f, 0.02467999f, -0.01581565f, 0.01322242f, -0.02623459f, -0.00830469f, 0.02979993f, 0.00968250f, 
    -0.03902603f, -0.00251244f, 0.01197728f, 0.00413385f, 0.01995719f, 0.00792234f, -0.03840072f, 0.00741719f, 
    -0.02606811f, -0.00415096f, 0.01116803f, -0.00235113f, 0.01013722f, -0.03761498f, 0.01845880f, 0.02473352f, 
    -0.00784059f, -0.03271796f, -0.01639858f, -0.01656448f, -0.00604748f, 0.02280114f, -0.01467440f, 0.00665184f, 
    -0.01505877f, 0.02231359f, -0.01867690f, 0.01772384f, -0.02103243f, -0.00835976f, -0.01986306f, 0.00077314f, 
    -0.00192469f, -0.02325518f, -0.03018044f, -0.01049428f, -0.02299479f, -0.02373619f, 0.00429303f, -0.01681951f, 
    0.02263656f, 0.02373033f, 0.00159727f, -0.01661701f, -0.02412500f, 0.02911962f, -0.00853626f, 0.02702701f, 
    0.02676439f, 0.00017944f, -0.00271384f, -0.02212199f, 0.00240823f, -0.00327993f, -0.03056580f, -0.00585896f, 
    -0.01680551f, 0.01690272f, -0.03344859f, 0.02581806f, -0.02571894f, -0.00391445f, 0.00970085f, -0.03463522f, 
    -0.02073956f, -0.01066792f, -0.03631243f, 0.02877558f, -0.01748383f, -0.01350778f, 0.03059985f, 0.02672624f, 
    0.01576587f, -0.01193904f, 0.00380579f, -0.02207395f, 0.01219524f, 0.01632029f, -0.00136070f, -0.01004648f, 
    0.03101079f, -0.02245660f, -0.03711859f, 0.00755532f, -0.01703183f, -0.01936017f, -0.03973269f, 0.02877828f, 
    0.02476431f, -0.00157159f, -0.03990054f, 0.01377389f, 0.02984677f, 0.00362235f, -0.00016875f, -0.03739450f, 
    -0.01239594f, 0.01194581f, -0.03059579f, -0.03633215f, -0.03090424f, 0.00289868f, 0.01684296f, -0.03565360f, 
    -0.01469986f, 0.00965960f, 0.00935781f, -0.03691578f, -0.03545938f, 0.00797779f, -0.00074776f, -0.03158746f, 
    -0.02009328f, -0.00100662f, -0.02657309f, 0.01911071f, -0.00600620f, 0.01650686f, 0.00921040f, -0.03576136f, 
    0.02204237f, 0.02175129f, -0.02847411f, -0.01843658f, -0.03920003f, -0.00711859f, -0.00881241f, 0.00358449f, 
    0.01202452f, 0.00232030f, 0.00247517f, -0.02038911f, -0.02606287f, -0.00403016f, 0.01882300f, -0.03732482f, 
    -0.03529016f, 0.02707245f, -0.00470431f, 0.02962248f, 0.00003423f, 0.01490678f, 0.00251991f, 0.01099384f, 
    0.03003908f, -0.03821127f, -0.01334824f, 0.02948330f, -0.01400263f, 0.00273081f, 0.02323734f, -0.01884026f, 
    -0.03666780f, -0.00850677f, -0.03459064f, 0.00751546f, -0.02865779f, -0.00694673f, -0.00836269f, -0.02424427f, 
    -0.03703197f, -0.00136692f, 0.01617147f, -0.00835561f, -0.02584138f, -0.01461585f, -0.01044443f, 0.00966933f, 
    0.00737952f, 0.01522597f, 0.01798424f, -0.00697649f, 0.01614265f, 0.02525414f, 0.01525871f, -0.01561917f, 
    0.00939631f, -0.00343415f, 0.01692691f, -0.00921838f, -0.02929891f, -0.01333980f, -0.02161240f, -0.01889701f, 
    0.02272245f, -0.01317356f, -0.03819118f, -0.02382045f, -0.00935836f, 0.01742198f, 0.02027389f, 0.00225742f, 
    -0.01865823f, 0.00565425f, -0.00211265f, 0.01669117f, -0.01830182f, -0.02852399f, -0.01741568f, -0.00104559f, 
    -0.00814652f, 0.01729411f, 0.02721929f, 0.00029996f, -0.01749990f, -0.00781178f, -0.00795559f, 0.02492628f, 
    -0.02942497f, -0.01411934f, 0.01396040f, 0.00371565f, 0.00600270f, 0.00122101f, 0.01412390f, 0.00165496f, 
    -0.02189835f, -0.03500277f, -0.02362164f, 0.02685689f, 0.02825449f, 0.02121643f, 0.01241262f, 0.00005941f, 
    -0.00008941f, -0.03158640f, -0.02255344f, -0.00775028f, -0.03872557f, -0.01676898f, -0.03845155f, 0.01924734f, 
    0.00677925f, -0.00401718f, 0.02842019f, 0.01955381f, -0.04013937f, 0.00974503f, 0.00215401f, 0.00368179f, 
    0.03224229f, -0.03081646f, 0.02664615f, -0.01979501f, 0.00362761f, 0.01688605f, 0.01799352f, 0.02035049f, 
    0.00758325f, 0.02800142f, -0.02446085f, 0.02607601f, -0.03858144f, 0.01101087f, 0.02840417f, -0.03680034f, 
    -0.03602825f, -0.01779220f, -0.00923507f, -0.00045202f, 0.02918988f, 0.02900945f, 0.00714866f, 0.01559950f, 
    0.01290611f, 0.00688294f, -0.00682631f, -0.02760670f, 0.01937828f, 0.00789150f, 0.00994447f, 0.02700171f, 
    -0.03113606f, -0.03362195f, -0.01047859f, -0.01061283f, 0.00286736f, 0.01355591f, 0.02549476f, 0.02354720f, 
    -0.02633318f, 0.00578678f, 0.02220443f, 0.01782524f, -0.01436749f, 0.01419831f, 0.00376611f, -0.03996494f, 
    0.03053208f, -0.02799310f, -0.00628159f, 0.02798798f, -0.01201636f, -0.01935849f, 0.02460203f, 0.02698817f, 
    0.00132054f, 0.02920259f, -0.03266431f, -0.03571819f, 0.01218556f, -0.00530090f, -0.01397113f, -0.02260750f, 
    -0.00695891f, 0.03130725f, -0.02387010f, -0.01646487f, 0.01678250f, -0.01561453f, 0.00503331f, -0.01863670f, 
    -0.01480951f, -0.02450124f, 0.02050383f, 0.02228171f, -0.00727866f, -0.01263639f, -0.03108319f, -0.02002686f, 
    0.00181280f, 0.02261717f, 0.02936777f, 0.02349438f, 0.02631578f, -0.02386496f, -0.01249233f, -0.03037623f, 
    -0.00609831f, -0.03849700f, 0.03060180f, -0.03046076f, -0.00625145f, 0.01826915f, 0.01341729f, -0.00301207f, 
    -0.01051320f, 0.00198115f, 0.00646295f, -0.03839160f, -0.00556880f, -0.00194506f, -0.01822948f, 0.01792359f, 
    -0.00613972f, -0.02635656f, -0.01451413f, -0.00056501f, 0.02087455f, 0.02818718f, -0.01655943f, 0.00058023f, 
    -0.03278345f, 0.02969549f, 0.01353950f, -0.03356232f, -0.03610705f, -0.00487091f, -0.02637225f, 0.00450255f, 
    0.01099694f, -0.03901700f, 0.00228392f, -0.00817983f, -0.02613619f, 0.01176374f, -0.01656140f, 0.01520133f, 
    -0.01422116f, 0.00328044f, -0.03399759f, -0.02181824f, -0.01537543f, 0.00288872f, 0.00999475f, -0.03691735f, 
    -0.01991501f, -0.01496007f, -0.02965230f, 0.00814070f, -0.03022896f, -0.02059639f, -0.00528602f, 0.00949434f, 
    -0.00464066f, 0.03084436f, -0.01811200f, 0.02263868f, -0.02809212f, -0.00101155f, 0.00206173f, 0.02179886f, 
    -0.01723494f, 0.01486313f, 0.00262990f, -0.01740756f, 0.01501407f, -0.03543778f, 0.00439931f, -0.00710389f, 
    -0.01292342f, -0.00039097f, -0.03456912f, -0.02924386f, 0.01150934f, 0.01109384f, -0.02627716f, -0.00372690f, 
    -0.00277954f, -0.02890501f, -0.00842072f, -0.01740705f, -0.02400231f, -0.00905687f, -0.03084799f, -0.03254059f, 
    0.02212633f, 0.01595383f, -0.03430133f, -0.01466873f, -0.00759475f, 0.02615748f, -0.02063156f, -0.01848694f, 
    0.03016330f, 0.01009645f, 0.02594023f, -0.01462504f, -0.03209167f, 0.00505838f, -0.03445192f, 0.00070434f, 
    0.01807815f, 0.00313705f, -0.00068873f, -0.03600002f, 0.01107543f, -0.03347239f, -0.00625783f, -0.01190338f, 
    0.00905180f, 0.01232364f, -0.01004604f, 0.00327817f, 0.02787726f, 0.00658596f, 0.01737809f, -0.00081013f, 
    0.00417107f, -0.02078452f, 0.01031580f, 0.00749287f, -0.02078574f, 0.00517460f, 0.02405713f, -0.00566127f, 
    -0.02269812f, 0.01752784f, -0.03314982f, -0.00602509f, 0.01311619f, -0.01043540f, 0.00337009f, 0.01747933f, 
    -0.00109780f, 0.02909508f, -0.02180685f, 0.00969802f, 0.00428887f, -0.01675124f, -0.02979420f, -0.01832128f, 
    -0.02549273f, -0.03235326f, -0.00385291f, 0.02386758f, -0.01570305f, 0.02880097f, -0.01721650f, 0.00078520f, 
    -0.03726116f, -0.03669327f, -0.00001211f, -0.02722793f, 0.00489551f, -0.02507908f, -0.03738639f, 0.02770390f, 
    0.03152247f, 0.01017428f, -0.04276315f, 0.02219521f, 0.01739991f, -0.02362389f, -0.02136889f, -0.01448802f, 
    0.00136708f, -0.00492284f, 0.03375588f, -0.02527103f, -0.00040218f, 0.02669635f, -0.00721892f, -0.03269222f, 
    0.00460746f, -0.03614362f, 0.01052334f, -0.03333876f, 0.01370231f, 0.01148715f, -0.01933819f, -0.03617670f, 
    0.00347834f, 0.02744059f, -0.00294081f, -0.02618151f, 0.00995827f, -0.00714892f, -0.01123619f, -0.02144966f, 
    0.00605193f, -0.00356464f, -0.03582922f, -0.03251241f, -0.01661622f, -0.02930916f, -0.00409787f, -0.01399385f, 
    0.01870304f, 0.02840392f, -0.00087628f, 0.00643130f, -0.00400046f, -0.00794651f, 0.02703955f, -0.02064100f, 
    -0.01441405f, -0.02587443f, 0.02091227f, -0.02603115f, -0.03306836f, -0.01176991f, 0.02576359f, -0.02798016f, 
    0.01066266f, 0.01110151f, 0.01056793f, 0.01552542f, -0.02123588f, -0.01509380f, -0.01317482f, 0.01494716f, 
    -0.01630122f, 0.02935259f, -0.00556282f, 0.02179734f, 0.02751859f, -0.00713453f, 0.01943029f, 0.00773758f, 
    -0.01616051f, -0.00057419f, 0.01536415f, -0.02702343f, 0.03009309f, 0.01457029f, 0.01761970f, 0.02070970f, 
    -0.01048433f, -0.00651744f, -0.01001281f, -0.02944736f, -0.03881754f, -0.01904963f, 0.01012629f, -0.02447998f, 
    0.01998837f, -0.00915641f, 0.00886297f, 0.02366832f, -0.00067174f, 0.01340873f, -0.02064592f, -0.02823494f, 
    -0.02906453f, -0.02674044f, 0.01642514f, 0.01614995f, -0.00026406f, 0.02311698f, -0.02419693f, -0.01187159f, 
    -0.02923180f, 0.02776465f, -0.02297999f, -0.02791060f, 0.01898526f, -0.01096685f, 0.02890664f, -0.00094994f, 
    0.02983113f, 0.00598155f, -0.01059444f, -0.03203897f, -0.00571888f, 0.02453043f, 0.02568367f, -0.04111805f, 
    -0.01642221f, 0.00695338f, 0.00799108f, 0.02720821f, 0.02931333f, 0.01253067f, -0.00429557f, -0.00858636f, 
    -0.01564757f, 0.00318972f, 0.01789143f, -0.02763306f, -0.00460004f, 0.02117875f, -0.02878738f, -0.02183612f, 
    -0.03157261f, 0.02155570f, -0.00417699f, 0.02584862f, -0.01196565f, 0.01988213f, 0.01704735f, -0.01049040f, 
    -0.03679327f, -0.00429347f, -0.02258524f, 0.01993061f, 0.03342783f, -0.03239056f, -0.03729985f, 0.02414078f, 
    0.00521198f, -0.00453606f, -0.02918756f, 0.01845302f, -0.00610775f, -0.00662921f, 0.01857122f, -0.00936557f, 
    0.00029217f, 0.01200689f, -0.01354555f, -0.03790670f, 0.01102186f, -0.02251525f, 0.00041879f, -0.01247907f, 
    0.01380140f, -0.02201799f, 0.02561050f, -0.04175064f, 0.03581864f, -0.02225136f, -0.01881052f, -0.00579805f, 
    -0.00193541f, -0.00491163f, 0.02459441f, 0.02833674f, 0.02299353f, 0.01806379f, 0.02100548f, 0.02238435f, 
    -0.02873531f, -0.01673082f, -0.01280786f, 0.00133566f, 0.00340516f, -0.03284034f, -0.02266690f, -0.02453806f, 
    -0.04007436f, -0.04281286f, 0.03431716f, 0.00348310f, -0.04201779f, -0.00830181f, 0.03026562f, -0.03726405f, 
    -0.02557613f, 0.01449491f, 0.02838668f, -0.03017505f, 0.00090328f, -0.04268158f, -0.03463784f, 0.03112048f, 
    -0.01810406f, 0.01316878f, 0.00851403f, 0.00379277f, -0.01640828f, -0.03126119f, 0.01054376f, -0.00208639f, 
    -0.02444010f, 0.03137749f, -0.02612296f, -0.02648962f, -0.00669212f, 0.01194197f, 0.02781196f, -0.02393371f, 
    -0.00910125f, -0.02998285f, -0.03499941f, 0.00231334f, -0.03455305f, -0.02498201f, 0.03212230f, -0.02900023f, 
    -0.04032525f, 0.01162309f, -0.02962744f, 0.00378869f, -0.01882198f, 0.02735783f, 0.02242978f, -0.00901951f, 
    -0.01985690f, 0.03034243f, 0.02876715f, -0.03545874f, 0.00272060f, 0.00019334f, -0.03753109f, -0.00385133f, 
    -0.01654906f, -0.02988319f, -0.03466968f, -0.01842646f, -0.03159954f, 0.02604868f, 0.01319685f, 0.00142260f, 
    -0.02173948f, 0.00306826f, -0.02496976f, -0.01911334f, -0.03313501f, 0.01540670f, -0.00232385f, 0.01501472f, 
    0.01269103f, -0.03393694f, -0.03043459f, 0.02560786f, 0.03411956f, -0.03652123f, 0.00873249f, 0.02168060f, 
    0.00777845f, 0.00580540f, 0.01037534f, 0.01445945f, -0.01826853f, -0.03908252f, -0.02565327f, -0.00895301f, 
    0.00009069f, 0.02677207f, 0.01815856f, -0.01275555f, 0.00995409f, 0.00168790f, 0.03563441f, -0.00999966f, 
    -0.00996101f, -0.00371622f, 0.02695805f, 0.02836852f, 0.01635081f, -0.03413200f, -0.01137911f, 0.01509387f, 
    -0.01086865f, -0.01887705f, 0.01933497f, 0.02833803f, 0.01473224f, -0.00685698f, 0.02455387f, 0.01968667f, 
    0.00862044f, 0.02785663f, -0.02677136f, -0.03512459f, 0.01573395f, -0.02386899f, 0.01324318f, -0.02400486f, 
    0.01371216f, -0.00071759f, -0.00568357f, -0.02749971f, 0.02665399f, 0.00024932f, 0.00191022f, -0.02651509f, 
    0.00095571f, 0.00330740f, -0.02608926f, 0.01259396f, 0.00078264f, -0.03515819f, 0.01172569f, 0.01835803f, 
    0.02596127f, -0.00818887f, 0.00287907f, 0.00203986f, 0.02910414f, -0.01005342f, 0.01103765f, -0.02650067f, 
    -0.03911922f, 0.00758716f, 0.01024987f, -0.03578443f, -0.02519226f, 0.02051568f, -0.04123845f, 0.02124601f, 
    0.02470398f, 0.01578941f, 0.00158535f, 0.01239931f, -0.01367797f, -0.03605299f, 0.00064368f, 0.02708984f, 
    -0.00320396f, 0.00563689f, -0.00413767f, 0.00659376f, 0.02994716f, -0.03536469f, 0.01201062f, -0.03771057f, 
    -0.02600685f, -0.03965308f, -0.01478950f, -0.04118596f, -0.02212447f, -0.00409212f, 0.00356523f, 0.00953894f, 
    0.01020098f, 0.00839197f, -0.02764966f, 0.00077815f, 0.02192611f, -0.01149465f, 0.02289381f, -0.00940392f, 
    0.03553671f, 0.00980984f, -0.03655660f, 0.01377424f, -0.03448239f, 0.00878450f, -0.01762430f, -0.02790688f, 
    0.01084011f, -0.00133897f, 0.00744374f, -0.02879852f, -0.01037089f, -0.01147677f, -0.02478666f, -0.00604448f, 
    -0.02624642f, -0.00262975f, -0.02005906f, 0.02759995f, 0.01922954f, 0.03429126f, -0.01997629f, -0.01509673f, 
    0.01609459f, 0.00094387f, 0.02909762f, 0.01774000f, 0.00339878f, 0.00131577f, 0.00821344f, -0.01664483f, 
    0.00961320f, 0.03800334f, 0.01841186f, -0.01557452f, -0.00413078f, -0.00713405f, -0.00002397f, -0.02350581f, 
    0.01123224f, 0.01208601f, -0.02365179f, -0.00033877f, 0.01865892f, -0.01847102f, 0.02839771f, 0.01511353f, 
    0.00697785f, 0.01853685f, -0.02369041f, -0.01755879f, -0.03572476f, -0.03950391f, 0.01973392f, -0.01703095f, 
    0.02927134f, -0.00760152f, -0.02342941f, -0.04089832f, 0.00000971f, -0.02390123f, -0.03630510f, -0.03861171f, 
    0.01671568f, -0.02913826f, 0.03106285f, 0.00736784f, -0.01094323f, -0.01700920f, 0.02994425f, -0.01877334f, 
    -0.01956097f, 0.01962875f, -0.01469483f, -0.02906419f, -0.01742068f, -0.03715419f, -0.03329087f, -0.03220485f, 
    -0.02991444f, 0.01833794f, 0.02383789f, -0.00927315f, -0.01911357f, 0.00623135f, -0.02503487f, -0.02953532f, 
    0.00746188f, -0.03200842f, -0.01382303f, 0.01228020f, -0.03649899f, -0.03778883f, 0.02646815f, -0.01382944f, 
    0.01501532f, -0.00098524f, 0.02942717f, 0.02962708f, -0.04343879f, 0.02278468f, -0.03250039f, 0.01291693f, 
    -0.01909647f, 0.01423929f, 0.01432557f, 0.02654155f, -0.03507087f, 0.02908532f, -0.03397963f, 0.01454282f, 
    0.02049749f, -0.02373807f, 0.01885131f, -0.02775176f, -0.00525536f, -0.00314686f, 0.01293073f, 0.00636007f, 
    0.00168294f, -0.03054603f, 0.01270741f, 0.01547250f, -0.04167717f, 0.00465585f, -0.00257864f, -0.03052399f, 
    -0.02630753f, -0.01834556f, -0.04158979f, -0.03996003f, -0.00360315f, 0.00451636f, 0.01628257f, -0.02996507f, 
    0.01815153f, -0.01667846f, 0.00429311f, 0.00373599f, -0.02104939f, 0.02737071f, -0.03823289f, 0.00296792f, 
    -0.00566158f, 0.02733478f, -0.00974810f, -0.02334907f, -0.03071584f, 0.00620588f, 0.01337813f, 0.00991549f, 
    -0.00616858f, 0.02425691f, -0.04036444f, -0.01160749f, 0.00921081f, -0.03482743f, -0.02230007f, 0.00759151f, 
    -0.00213863f, -0.00533152f, 0.02424854f, -0.01267736f, -0.02384276f, 0.00020261f, 0.00125624f, -0.02389678f, 
    -0.02643747f, 0.03039752f, -0.01677065f, 0.01176229f, -0.00962833f, -0.00330224f, 0.01591048f, 0.00752694f, 
    -0.03352442f, 0.02840207f, -0.03630165f, -0.00538402f, -0.03761352f, 0.00934016f, -0.03606498f, 0.01983573f, 
    -0.01261104f, -0.02982946f, 0.00849088f, 0.01684346f, 0.02172925f, 0.02875602f, -0.04020882f, -0.03396192f, 
    0.00692097f, -0.02133309f, -0.01823134f, -0.02879336f, 0.01264546f, 0.01225304f, -0.01265569f, -0.02935177f, 
    0.01630234f, 0.01002671f, 0.01758988f, -0.02584643f, -0.01919031f, 0.01478316f, -0.04090623f, -0.01293651f, 
    -0.01232607f, -0.02748947f, -0.02817062f, -0.01011899f, 0.02110786f, -0.00261455f, -0.02809826f, 0.02443722f, 
    -0.02376396f, -0.02279516f, 0.00175493f, -0.01569663f, 0.02220267f, 0.00332761f, 0.02427678f, 0.03063225f, 
    -0.03047105f, -0.01317732f, -0.02950364f, 0.02836625f, -0.03232650f, 0.01354832f, -0.03507934f, -0.00814023f, 
    -0.01814680f, 0.02333124f, -0.02048622f, 0.01572588f, -0.00806399f, -0.02392828f, -0.03567574f, 0.01718202f, 
    -0.02087183f, -0.03605189f, 0.02687529f, -0.01449905f, -0.00461997f, -0.04155002f, -0.01222878f, -0.01792854f, 
    0.02217973f, 0.00363204f, 0.00213080f, -0.01458602f, 0.02652358f, -0.00137894f, -0.00440725f, 0.00054380f, 
    -0.02656175f, 0.02510329f, -0.01271494f, 0.02292056f, 0.00252104f, 0.00278822f, -0.01630589f, 0.02624832f, 
    -0.00601083f, 0.00540615f, -0.01049360f, 0.03153688f, 0.00488813f, 0.02667669f, 0.01813568f, 0.01178061f, 
    0.08192940f, 0.03729104f, 0.06978377f, 0.19010589f, 0.09612986f, 0.04008508f, 0.03428397f, -0.06225947f, 
    0.11929920f, 0.06313670f, 0.14869063f, 0.07441280f, -0.17061086f, -0.17721027f, 0.20089886f, -0.10642812f, 
    -0.04853835f, 0.05714377f, 0.08593438f, 0.01537920f, 0.05514714f, -0.00878394f, 0.04697773f, 0.01422050f, 
    -0.13780467f, -0.04250614f, -0.07946404f, -0.01902071f, 0.02876428f, 0.07047544f, 0.10129042f, 0.08264118f, 
    0.11656424f, 0.10804521f, 0.03881129f, -0.01511728f, 0.31580627f, 0.01613889f, 0.03111675f, 0.05194037f, 
    0.12663592f, 0.09093904f, -0.02245533f, -0.15710486f, -0.01026950f, 0.04687309f, 0.00006530f, 0.20536561f, 
    0.10928039f, 0.14648387f, 0.21320677f, 0.16090968f, 0.07839473f, 0.09543309f, 0.05402232f, -0.01771597f, 
    0.00162390f, 0.06940056f, 0.18093725f, 0.17885913f, -0.11119934f, -0.05679413f, -0.10818893f, 0.18375883f, 
    -0.03905478f, 0.06243261f, 0.11288542f, 0.16452467f, -0.04963273f, -0.02741598f, -0.01792181f, -0.00906248f, 
    -0.10521553f, 0.01681291f, -0.05775963f, -0.21038856f, 0.10869005f, -0.01315557f, 0.09496922f, 0.19005726f, 
    -0.00506052f, 0.05823468f, 0.05990927f, 0.19193654f, -0.14491519f, 0.00145979f, -0.07992482f, -0.12878914f, 
    0.11029850f, 0.08456467f, 0.09086280f, 0.06272823f, 0.08671811f, 0.01325421f, 0.00564288f, 0.12935546f, 
    -0.05800741f, -0.12659551f, 0.04478060f, -0.06971757f, -0.07954378f, 0.11111557f, 0.02405758f, -0.02671297f, 
    -0.02400077f, 0.04966142f, 0.10430805f, 0.09756760f, 0.14867677f, 0.07287194f, 0.18497184f, -0.00241451f, 
    0.06064348f, 0.11341907f, 0.29278767f, -0.02357579f, 0.14579043f, 0.02205559f, 0.14367190f, 0.07912122f, 
    0.22572155f, -0.10619131f, 0.05846964f, -0.00457478f, 0.10129797f, 0.03233352f, 0.00446757f, -0.01230400f, 
    0.14741011f, -0.13289131f, -0.04284883f, 0.14332627f, 0.09378793f, 0.02536647f, 0.13700327f, -0.03750081f, 
    0.00411688f, -0.05095646f, 0.16271587f, -0.11162984f, 0.09283508f, 0.02051670f, 0.09154994f, 0.16654694f, 
    0.17229496f, -0.03093281f, 0.06953018f, 0.24263960f, 0.00472131f, -0.12706186f, -0.02506732f, 0.10275204f, 
    0.06455600f, 0.12889618f, 0.25260568f, 0.09941217f, 0.24361512f, -0.19031508f, 0.14271563f, 0.17668810f, 
    0.08265308f, -0.02241886f, 0.00168453f, 0.12180740f, 0.15475030f, 0.09460335f, 0.02948817f, 0.12270363f, 
    -0.06891396f, -0.14330892f, -0.08832456f, -0.17509122f, -0.03023812f, -0.09415624f, 0.19109391f, 0.08156289f, 
    0.15774733f, 0.08462326f, -0.17086782f, 0.06377792f, 0.05849904f, 0.02392376f, 0.02728258f, 0.01348698f, 
    0.13113333f, 0.08815715f, -0.16113578f, -0.05666151f, 0.07244055f, -0.04508391f, 0.16702342f, -0.05066811f, 
    0.08523016f, 0.02231574f, 0.18207920f, 0.10622744f, 0.07024971f, -0.01561592f, 0.03914967f, -0.02670305f, 
    0.10142804f, 0.04643074f, -0.01302773f, 0.19380099f, -0.05939106f, 0.23834147f, -0.02047499f, 0.04645250f, 
    0.04891559f, -0.01335260f, -0.00653779f, 0.13819365f, 0.06275887f, -0.02358845f, 0.01459289f, -0.18006380f, 
    0.19662799f, -0.13333304f, -0.11332770f, -0.06620815f, -0.09466097f, 0.08661648f, 0.10424221f, -0.03095199f, 
    0.24064858f, 0.06828395f, 0.18881659f, 0.15952465f, 0.17009537f, 0.07557628f, 0.19849955f, 0.25367001f, 
    0.09575992f, 0.03380282f, -0.04115075f, -0.01946177f, -0.00515342f, 0.03761056f, 0.07560618f, 0.12659508f, 
    -0.04006392f, 0.05951786f, 0.10918174f, 0.08140077f, -0.01270762f, 0.09227078f, -0.01645502f, -0.06682293f, 
    0.18452112f, 0.06948821f, 0.15596533f, -0.00489836f, -0.05956693f, -0.23543306f, 0.12826976f, 0.04530294f, 
    0.05707395f, -0.07969476f, 0.01880931f, 0.17512102f, 0.15076378f, 0.03465581f, 0.06073729f, -0.06564796f, 
    0.19523509f, -0.33270010f, 0.09075376f, 0.04067083f, 0.01498136f, 0.04843589f, 0.02216350f, -0.00171191f, 
    0.06396999f, -0.07083069f, 0.02714598f, 0.00677105f, 0.09712785f, -0.06109947f, 0.18515436f, 0.20040387f, 
    0.01408307f, -0.01314072f, -0.02918255f, -0.07099295f, 0.10513677f, -0.05060518f, 0.15978961f, 0.15178518f, 
    -0.38839144f, 0.12457675f, -0.20759253f, -0.00265050f, -0.00641838f, 0.00344333f, 0.03008109f, 0.17276900f, 
    -0.03319355f, -0.01352678f, -0.12330210f, -0.02645212f, 0.34734306f, 0.09802056f, 0.11496778f, 0.17991449f, 
    0.01140737f, 0.07619750f, -0.00926366f, 0.08548475f, 0.23022655f, 0.16576113f, 0.10162276f, 0.06575754f, 
    0.14111854f, -0.15618862f, -0.02777234f, 0.12617327f, 0.12035904f, 0.11321543f, 0.11130065f, 0.13760263f, 
    -0.03072225f, 0.12393696f, 0.02771532f, 0.01961574f, -0.00031479f, -0.04798876f, 0.09737083f, -0.00470016f, 
    0.15000524f, -0.02894988f, 0.19240546f, 0.06453840f, 0.06566688f, 0.06536265f, -0.04223097f, 0.09818549f, 
    -0.08390435f, -0.04809026f, 0.07799132f, 0.11844007f, 0.05169040f, -0.04322878f, 0.20038617f, -0.01141866f, 
    0.03385491f, 0.16070066f, 0.14454100f, 0.21894026f, 0.06896875f, -0.08533510f, 0.22181632f, 0.22974654f, 
    -0.05845365f, 0.07427175f, 0.02031131f, 0.16712451f, 0.18845440f, 0.04419757f, 0.03816957f, 0.07856061f, 
    0.02751781f, -0.13672434f, 0.11078495f, -0.00540191f, 0.01340444f, 0.07674427f, 0.06186810f, -0.12606318f, 
    0.02089900f, 0.03314584f, 0.05857562f, 0.11057736f, -0.02566218f, -0.21454610f, 0.04739388f, 0.05942944f, 
    -0.06706312f, 0.11307655f, 0.10855059f, 0.04569739f, 0.10963303f, 0.01747352f, -0.00675026f, -0.02519850f, 
    -0.15693058f, 0.17130220f, -0.00625820f, -0.28394893f, 0.10245462f, 0.09423739f, -0.10637591f, 0.05242949f, 
    -0.05042697f, 0.18605360f, 0.19975100f, 0.10881644f, -0.15565057f, -0.07953882f, -0.05969874f, 0.17245901f, 
    0.13902622f, 0.08979728f, 0.08510445f, 0.07669573f, 0.04311258f, 0.10005406f, 0.15171635f, 0.16038296f, 
    0.18946670f, 0.05324654f, 0.25694665f, 0.36192766f, -0.04753970f, 0.11843545f, 0.02423248f, -0.05365197f, 
    0.15815812f, 0.06462754f, 0.03384361f, 0.12681131f, 0.09414227f, -0.05260931f, 0.13926725f, 0.10818268f, 
    0.07565528f, 0.09450608f, 0.05653114f, 0.01790245f, 0.24093466f, -0.05370299f, 0.06894818f, 0.19202688f, 
    -0.00245865f, 0.05353499f, 0.07597081f, 0.08793384f, 0.08977202f, 0.04225787f, -0.08944228f, 0.07737453f, 
    0.13111763f, 0.07446165f, 0.13291276f, 0.18726447f, -0.25923410f, 0.02090557f, -0.03163517f, -0.14910057f, 
    0.05863935f, 0.07857011f, -0.00793874f, 0.14291525f, 0.00258169f, 0.01636208f, -0.03332276f, 0.09299819f, 
    -0.09198186f, -0.06586513f, 0.06733683f, -0.09360544f, 0.11437852f, 0.02535957f, 0.08579081f, 0.01496192f, 
    0.08845109f, 0.05384872f, 0.12577906f, 0.04979127f, -0.21843442f, 0.09413241f, -0.21368301f, 0.04431543f, 
    0.17057915f, -0.02147914f, 0.06783882f, 0.11591283f, 0.05281216f, 0.00648552f, 0.03151451f, 0.07724721f, 
    -0.40573952f, -0.14068522f, -0.05686408f, -0.13732031f, 0.06053780f, 0.04861793f, 0.03244684f, 0.07190707f, 
    0.10598654f, 0.09184005f, -0.06601259f, -0.04305687f, 0.21442907f, 0.07655271f, 0.16759843f, 0.35306913f, 
    0.06390130f, 0.02709553f, -0.04968513f, 0.00719021f, 0.07298984f, 0.13865466f, 0.12052458f, 0.04090502f, 
    0.20569645f, -0.19630036f, 0.03443813f, 0.02987155f, 0.04252478f, -0.06595951f, 0.02443421f, -0.08959863f, 
    0.15632366f, -0.02648219f, 0.00030464f, -0.06198160f, -0.23299894f, 0.15994762f, -0.11761107f, -0.05206098f, 
    0.06660713f, -0.01320522f, 0.12070135f, 0.07182301f, -0.09217378f, 0.01486799f, 0.02012902f, 0.06061848f, 
    0.24199165f, -0.02924421f, 0.07152496f, 0.07984346f, 0.08364239f, 0.03226450f, 0.18203293f, 0.11916953f, 
    0.11732227f, -0.06672595f, -0.01372100f, 0.06202000f, -0.20835431f, -0.18952993f, 0.09079599f, 0.03374000f, 
    0.10193529f, 0.00358126f, 0.06458166f, -0.11227957f, 0.08982573f, 0.12529297f, -0.11085942f, 0.12869848f, 
    0.14650942f, -0.01580184f, 0.19266975f, 0.24122794f, 0.01264684f, 0.00848799f, -0.01731258f, -0.01087767f, 
    0.14225292f, 0.01140581f, 0.16258101f, 0.04776532f, -0.07142298f, -0.09365890f, -0.08535581f, 0.08391684f, 
    0.04567833f, 0.00738632f, 0.03567871f, 0.09289253f, 0.04837663f, 0.00614183f, 0.03370359f, 0.08621444f, 
    0.14047274f, -0.08705678f, 0.01122088f, 0.01428662f, 0.09655733f, 0.01764257f, -0.11235052f, 0.08363383f, 
    0.01570685f, 0.05922885f, 0.09248964f, 0.09290252f, -0.42700449f, -0.08062330f, -0.01089542f, -0.03200838f, 
    0.04627876f, 0.07948737f, 0.04732506f, 0.07278983f, 0.06571806f, 0.07453013f, 0.11171138f, 0.03142905f, 
    0.18108231f, -0.02457193f, 0.14702787f, -0.18285848f, -0.05010033f, 0.09087969f, 0.12357932f, -0.05493044f, 
    0.02901320f, 0.06043527f, 0.09192087f, 0.08314519f, -0.14604746f, -0.08976006f, -0.11746036f, 0.14819810f, 
    0.10391989f, 0.00389738f, 0.07972198f, 0.18928936f, 0.02003969f, -0.06004274f, 0.08291700f, 0.17431363f, 
    0.22155561f, 0.15284902f, 0.11920279f, 0.15692838f, 0.01933841f, -0.07236844f, -0.10211337f, -0.01227378f, 
    0.16221440f, 0.06175677f, 0.00794272f, 0.18663657f, -0.21247704f, -0.02939478f, -0.02749452f, 0.05752656f, 
    0.07436426f, 0.09445187f, 0.02692853f, 0.13339108f, 0.00971104f, -0.00513221f, 0.04705876f, 0.05850790f, 
    -0.12109309f, 0.13359556f, -0.18400857f, -0.09470166f, 0.20678923f, 0.13393918f, 0.12375841f, 0.13748235f, 
    0.04251432f, 0.03000776f, 0.09419724f, -0.04741290f, -0.06801152f, 0.07222606f, -0.05944908f, -0.04139047f, 
    0.08174697f, 0.11709097f, -0.05661676f, -0.04436779f, 0.10660612f, -0.00986254f, 0.17938533f, -0.04312723f, 
    0.12889020f, -0.07654593f, 0.25970834f, 0.10786096f, -0.01019839f, -0.00189077f, 0.03567789f, -0.02220146f, 
    0.21210220f, 0.11038777f, 0.11969216f, 0.06652164f, -0.20723356f, 0.04360431f, -0.10181622f, 0.06433590f, 
    0.17876478f, 0.08447831f, -0.03753752f, 0.11659369f, 0.00164919f, 0.00761731f, 0.06999093f, 0.15029687f, 
    0.17774870f, -0.19495586f, 0.05586409f, -0.16030274f, 0.11977363f, 0.06141220f, 0.11268244f, 0.00091581f, 
    0.05019145f, 0.07889263f, 0.14059380f, -0.00758500f, 0.11304718f, 0.08046649f, -0.01039559f, 0.16098276f, 
    0.07480518f, 0.08709536f, 0.17973319f, 0.01779660f, 0.00277569f, 0.05272793f, -0.05709509f, 0.06067264f, 
    -0.24011533f, 0.02103762f, -0.08644390f, 0.19975831f, 0.10101390f, -0.03532542f, 0.02054808f, 0.20066281f, 
    0.09841599f, 0.05697101f, 0.08536682f, -0.03400460f, -0.00525887f, -0.09170643f, 0.09371027f, -0.01076537f, 
    0.02671195f, 0.07657366f, 0.17475957f, 0.05424062f, 0.08328660f, 0.11843940f, 0.15540522f, 0.12913603f, 
    0.28455937f, -0.14909361f, 0.01858103f, -0.05984751f, 0.15815522f, 0.02281291f, 0.08262123f, -0.02248905f, 
    0.11737721f, 0.03316951f, -0.05548933f, 0.16979298f, -0.07136019f, 0.01693461f, 0.07638221f, 0.09049901f, 
    0.07930727f, -0.02855649f, -0.01020328f, 0.08771560f, 0.12544416f, 0.00035645f, 0.01396152f, -0.00908299f, 
    0.08727429f, 0.09545480f, 0.06363898f, -0.00753260f, 0.10507346f, -0.03914302f, 0.03322575f, 0.01331434f, 
    0.11319221f, 0.05577568f, -0.01519927f, 0.02900002f, -0.14815392f, 0.05501195f, 0.07160151f, 0.01269550f, 
    -0.11355421f, -0.04745827f, 0.00104540f, 0.06406426f, 0.10585832f, 0.06326850f, 0.09326220f, 0.10576205f, 
    -0.21031196f, -0.12211548f, -0.20798434f, 0.06756675f, 0.00687630f, -0.07588602f, -0.00115411f, -0.05008262f, 
    -0.00984055f, -0.01366292f, 0.05355001f, -0.04690563f, 0.11014381f, 0.24449584f, 0.22680371f, 0.04669232f, 
    0.03539600f, 0.10441441f, 0.05650746f, -0.10491273f, -0.07057457f, 0.04751132f, 0.03106727f, 0.11160558f, 
    -0.12471699f, 0.12396467f, -0.14140639f, -0.02638173f, 0.00299731f, 0.14936370f, -0.02969710f, -0.00773104f, 
    -0.08586895f, -0.02407410f, -0.08070102f, -0.10028645f, -0.22112745f, -0.09961332f, 0.04288559f, 0.08162034f, 
    0.04483610f, 0.01871197f, 0.02302801f, 0.03825312f, 0.01654806f, 0.05259833f, 0.01683674f, -0.00206560f, 
    -0.06827723f, -0.03393359f, -0.26514047f, 0.01199995f, 0.06816985f, -0.04377559f, -0.06494454f, -0.05992695f, 
    -0.16684301f, -0.04073106f, 0.04529632f, 0.05876238f, -0.14564037f, -0.04756206f, -0.08623188f, 0.20195921f, 
    0.06725925f, -0.09550066f, 0.01921873f, 0.02163916f, -0.00533829f, 0.00672998f, -0.02333429f, -0.06180684f, 
    0.03258273f, -0.05638318f, 0.01949218f, -0.15834585f, -0.09967440f, -0.12179601f, 0.02342212f, 0.05439106f, 
    -0.06001705f, -0.03489419f, 0.10738549f, -0.00709129f, 0.37417847f, 0.13725889f, -0.17100498f, 0.24311893f, 
    0.13132110f, 0.09324323f, -0.12419895f, 0.01588899f, 0.10015292f, 0.10851051f, -0.01505253f, 0.08116604f, 
    -0.01315074f, -0.01328456f, 0.01154639f, 0.28554294f, 0.02129162f, 0.07120600f, 0.03096757f, -0.00549755f, 
    0.08958210f, 0.00069612f, -0.03547496f, 0.11988188f, 0.19714960f, 0.11499430f, -0.17627263f, 0.03927920f, 
    0.03166133f, 0.02907426f, 0.10274522f, -0.04608425f, -0.01470176f, 0.02732427f, -0.00805310f, 0.02711105f, 
    -0.27657577f, 0.04170065f, -0.16173187f, -0.06093204f, 0.03076825f, -0.06703996f, 0.13065428f, 0.00913742f, 
    -0.02782366f, 0.08150501f, -0.01995040f, -0.01731516f, -0.12976307f, 0.36402985f, 0.07750104f, -0.13366103f, 
    0.02610615f, 0.13318357f, 0.02534080f, 0.05033609f, 0.08302502f, 0.01932195f, -0.00515006f, 0.03970444f, 
    -0.34793833f, -0.24405596f, -0.23013783f, 0.08610638f, 0.07273262f, -0.07470613f, -0.00891281f, -0.00735176f, 
    -0.00776322f, -0.00648352f, 0.13630548f, -0.03984214f, -0.10004055f, -0.10810313f, 0.15292199f, 0.12430228f, 
    -0.07513875f, -0.11216898f, 0.11423106f, -0.03365734f, 0.07349620f, 0.06859801f, 0.20135140f, 0.06600786f, 
    0.01821194f, 0.10018475f, 0.21344057f, -0.22706562f, -0.09397515f, 0.07888066f, 0.04768552f, -0.03280238f, 
    -0.05484634f, -0.12568404f, 0.00739810f, -0.15920751f, 0.05203966f, -0.29871067f, -0.03387249f, 0.20282441f, 
    0.07112852f, 0.04952652f, 0.00608608f, -0.05862684f, 0.10770874f, -0.00940964f, -0.00912713f, 0.17338412f, 
    -0.18207206f, -0.01697508f, -0.05334066f, 0.22669065f, 0.04857453f, 0.04538338f, -0.14053623f, 0.00409649f, 
    -0.06792603f, -0.09278172f, -0.12242075f, -0.14249536f, 0.00922417f, 0.11809356f, 0.22735861f, -0.09783893f, 
    0.06720898f, 0.06821015f, -0.02315504f, 0.01119870f, 0.00885547f, 0.05801391f, 0.14612952f, -0.01341672f, 
    0.43605635f, 0.05364930f, 0.04005843f, 0.00555965f, -0.01138815f, 0.01061565f, 0.00658658f, 0.10174978f, 
    -0.00924700f, -0.09433281f, 0.06170680f, -0.00645599f, -0.19122969f, -0.00440587f, -0.05853475f, 0.07093452f, 
    -0.12458675f, 0.09636538f, -0.06479592f, -0.03468172f, -0.07997461f, -0.02657434f, 0.07947512f, 0.05543465f, 
    0.07207088f, 0.10509220f, -0.22861561f, 0.26078498f, -0.01330758f, 0.12695916f, -0.05870397f, 0.11880339f, 
    0.07629046f, -0.00826990f, 0.11096074f, 0.04521758f, 0.09494087f, 0.16421345f, 0.01848910f, 0.07337021f, 
    0.11957856f, 0.01426699f, 0.10922119f, 0.04371578f, 0.04472855f, -0.00550241f, 0.00912476f, 0.02369298f, 
    -0.10949098f, -0.05459849f, -0.02638371f, -0.14105566f, 0.14538932f, -0.13635772f, 0.00612745f, 0.00583459f, 
    -0.11228245f, 0.03762539f, 0.10348649f, 0.17918019f, 0.03826970f, -0.09750848f, 0.11015763f, 0.21755841f, 
    0.08266935f, 0.04509135f, -0.03389332f, -0.09326408f, -0.02797475f, -0.18909158f, -0.23631255f, -0.18948433f, 
    -0.07921845f, 0.14670183f, 0.10691060f, 0.05120844f, 0.14565560f, -0.02132696f, 0.05460490f, 0.04300830f, 
    0.12801179f, 0.03222771f, -0.01596536f, -0.06038204f, 0.13874145f, 0.13819411f, -0.05069710f, -0.04842912f, 
    0.06117814f, -0.00767430f, -0.01196016f, 0.13381059f, -0.01184178f, 0.00742251f, -0.00391405f, 0.09863912f, 
    -0.07626104f, 0.08781174f, -0.10570585f, -0.04440130f, 0.12016448f, 0.06859937f, 0.00976826f, 0.07306521f, 
    -0.00999663f, 0.08127441f, -0.05909592f, 0.11366531f, -0.02086312f, 0.27336043f, 0.06578293f, -0.09657370f, 
    0.03367125f, -0.04409337f, 0.03905116f, 0.01837206f, -0.02460785f, 0.00286397f, 0.01905246f, -0.08529770f, 
    0.09699623f, 0.05470158f, 0.03133184f, -0.10683740f, 0.15184699f, 0.07641541f, 0.13544816f, -0.01572799f, 
    -0.02160282f, 0.11908915f, 0.12043892f, 0.15783548f, -0.28318122f, -0.25722080f, 0.09610798f, -0.00222135f, 
    -0.12217222f, -0.04635626f, 0.05474707f, -0.07061237f, -0.00293346f, 0.01764622f, 0.14495364f, 0.09056777f, 
    0.36863890f, -0.29599288f, -0.14089318f, -0.07522268f, -0.01195620f, -0.02029739f, 0.00692828f, -0.05085871f, 
    -0.08954918f, 0.12214642f, -0.01271548f, -0.09535221f, -0.47533607f, 0.16251722f, 0.00006174f, -0.15158083f, 
    0.05673739f, 0.05477345f, 0.09869388f, 0.04744105f, -0.02907437f, -0.00388139f, -0.05673206f, -0.05203372f, 
    -0.04767132f, 0.19857427f, 0.02990791f, 0.24913944f, 0.06149853f, 0.07010788f, -0.01028745f, -0.02975804f, 
    -0.03581567f, 0.02537887f, 0.10350145f, 0.05908718f, 0.22289640f, 0.23964624f, -0.21691312f, -0.01248224f, 
    0.02500419f, 0.02365012f, 0.03758335f, 0.07260939f, -0.00147122f, -0.08987114f, 0.06441741f, -0.01338741f, 
    -0.20928082f, 0.26365736f, -0.28091151f, -0.05199440f, 0.00487883f, -0.02872736f, -0.12541509f, -0.05199413f, 
    -0.01225855f, 0.03523850f, -0.04516980f, -0.07306489f, 0.24717084f, -0.07792383f, -0.07473331f, -0.04396370f, 
    0.02927424f, 0.01131896f, -0.10001049f, -0.09808960f, -0.07583031f, -0.09464968f, -0.11733382f, 0.05396790f, 
    -0.30103940f, -0.05269999f, 0.11086658f, 0.03258230f, -0.02181338f, 0.02144259f, 0.05006556f, 0.03131911f, 
    -0.00870745f, 0.01968255f, -0.04655406f, -0.00595940f, -0.06109330f, -0.09508268f, -0.05304394f, 0.01041174f, 
    0.11460022f, -0.01552357f, 0.04601829f, -0.06450336f, -0.04434677f, 0.10790706f, -0.12399773f, -0.10501255f, 
    0.14874843f, 0.06349225f, 0.04984694f, -0.27249336f, 0.12851554f, -0.07314061f, -0.00495126f, 0.07482735f, 
    0.11037958f, -0.02023411f, 0.01429965f, 0.00923832f, 0.04488426f, 0.14581953f, 0.26647717f, -0.04303163f, 
    0.10776892f, -0.01513039f, 0.02123692f, -0.02631822f, 0.01895436f, 0.00070379f, -0.06687636f, 0.03501754f, 
    -0.54782701f, -0.13206175f, 0.05457683f, 0.12840407f, -0.01625636f, -0.05975083f, -0.08215073f, 0.12428976f, 
    0.01188415f, -0.00771730f, 0.03787469f, -0.01178205f, -0.02944939f, -0.27485675f, 0.06043964f, 0.10593136f, 
    0.06717566f, 0.08924957f, 0.03424342f, -0.06323524f, -0.02605144f, 0.04364752f, 0.16034998f, 0.16122642f, 
    -0.05463666f, 0.11108028f, 0.02501472f, 0.01418926f, 0.07229876f, 0.00628637f, 0.01860495f, -0.12464034f, 
    0.11811977f, -0.09061371f, 0.08746142f, 0.09363957f, -0.18764868f, -0.04370741f, -0.07848745f, -0.02109866f, 
    -0.09614292f, -0.14926139f, 0.01150515f, 0.09291799f, 0.00405487f, -0.00483061f, 0.02576102f, -0.00431158f, 
    0.05776602f, 0.21218655f, 0.14238192f, -0.08705766f, 0.04649584f, 0.02821920f, -0.05777818f, 0.04031707f, 
    0.02278032f, -0.00233385f, -0.00114366f, 0.09758458f, -0.11758095f, -0.04304942f, -0.20958848f, -0.07027736f, 
    -0.12265240f, -0.05511186f, 0.01645411f, -0.03125772f, -0.09005591f, -0.00181155f, -0.01946564f, -0.03575205f, 
    0.18450947f, -0.23338938f, 0.15196642f, 0.04544752f, -0.01626827f, 0.00332535f, 0.12453055f, 0.07577505f, 
    0.10123725f, -0.00746038f, -0.00812740f, -0.03649599f, 0.00229569f, -0.09343708f, -0.03884325f, -0.24210633f, 
    -0.05824227f, 0.04598523f, 0.09229823f, -0.01819017f, 0.05553791f, -0.04314238f, -0.01226743f, 0.07243337f, 
    0.45909533f, 0.13130292f, -0.15942980f, 0.34549192f, 0.03199432f, 0.09208719f, 0.04554207f, -0.07795547f, 
    0.05199041f, 0.02080519f, 0.05439588f, -0.00489476f, -0.28065574f, -0.07689801f, 0.02020183f, -0.02971451f, 
    0.06709412f, 0.01945644f, 0.07848546f, -0.01656336f, -0.09773841f, 0.06184739f, 0.06137262f, -0.05676861f, 
    0.04223856f, 0.12711979f, -0.16940129f, 0.17270114f, 0.17015404f, -0.06810385f, 0.18023519f, 0.07916456f, 
    -0.02019167f, 0.09030255f, -0.15896784f, 0.12451655f, -0.24115820f, -0.18331087f, 0.12673016f, 0.16492835f, 
    0.01696666f, -0.04666821f, -0.01519685f, 0.12814511f, -0.01605927f, 0.03091831f, -0.04795169f, 0.05355741f, 
    0.16350302f, 0.05370923f, -0.13507186f, 0.11499155f, -0.03518769f, 0.05039166f, 0.12801935f, 0.19752946f, 
    -0.04806877f, 0.06633329f, 0.12591596f, -0.01969993f, -0.05296813f, -0.08757492f, 0.11915508f, -0.10939383f, 
    0.02090269f, -0.03441582f, -0.00705828f, 0.11227180f, -0.07498185f, -0.05965386f, 0.09126996f, -0.00975941f, 
    -0.13017491f, 0.26419052f, 0.21533999f, -0.32753634f, 0.00676458f, 0.03711914f, 0.14251071f, -0.09218523f, 
    0.02462387f, -0.02842920f, 0.18244590f, -0.04038151f, 0.04015652f, 0.02694388f, 0.00896215f, -0.02365904f, 
    0.11001460f, -0.06347873f, -0.02933200f, 0.04934900f, 0.01417406f, -0.03385008f, 0.19895744f, 0.04108856f, 
    0.17467095f, 0.25884885f, -0.06463872f, 0.21918948f, 0.04872944f, 0.12644520f, -0.01101639f, -0.07135631f, 
    0.13894589f, 0.06892053f, -0.00146121f, 0.04171785f, 0.00149421f, 0.03117757f, 0.25467920f, 0.00413167f, 
    0.06960715f, -0.06190775f, 0.06945822f, -0.01078529f, 0.06595525f, -0.05368910f, 0.15623502f, 0.11244784f, 
    0.10874402f, 0.13641226f, -0.08770634f, -0.16893849f, 0.14203297f, 0.06231363f, 0.03293448f, 0.07521004f, 
    -0.00065816f, 0.03683493f, 0.01454862f, 0.00166565f, 0.03130196f, 0.18972853f, -0.06481525f, 0.12867485f, 
    0.04959893f, 0.03561903f, -0.07294973f, 0.06748114f, 0.14865115f, 0.01396061f, -0.02629664f, -0.01690329f, 
    0.18475227f, 0.37807521f, -0.00586059f, 0.15177457f, 0.03437391f, -0.07948143f, -0.04765730f, 0.10195362f, 
    0.04359689f, -0.08429516f, 0.14670102f, 0.01231131f, -0.07476086f, -0.11130015f, -0.00852677f, 0.22013383f, 
    0.04593360f, -0.13837136f, 0.07443252f, -0.06899595f, -0.08022127f, 0.02832732f, 0.09117226f, -0.09878755f, 
    -0.12902603f, -0.03719724f, 0.02776551f, -0.12686850f, -0.01677673f, 0.05517505f, 0.00376918f, 0.04849086f, 
    0.01128879f, 0.06877537f, 0.02814147f, -0.15103643f, 0.21333739f, -0.06421980f, -0.19613695f, 0.15927920f, 
    -0.05370385f, 0.00660007f, -0.05535198f, 0.04365180f, 0.02715303f, 0.09727103f, 0.02398027f, -0.02673862f, 
    -0.05514300f, -0.12546843f, 0.02067546f, 0.11915449f, -0.02289796f, 0.07259168f, 0.08234879f, -0.09700726f, 
    -0.01636455f, -0.06476364f, -0.14314823f, 0.12568611f, -0.33293614f, 0.04318233f, 0.01555772f, -0.00899040f, 
    -0.02210866f, -0.02257958f, 0.03239084f, 0.06443036f, 0.05473585f, -0.07531532f, -0.02791464f, -0.03531487f, 
    -0.03952894f, -0.01692748f, 0.19499551f, 0.10713584f, -0.01774999f, -0.05275407f, -0.00164986f, 0.07828496f, 
    -0.16969939f, -0.02953289f, 0.07962883f, -0.00394696f, -0.16384327f, -0.10382167f, 0.02332379f, -0.09939542f, 
    0.07950491f, 0.13252723f, 0.03526332f, 0.00807764f, 0.00655782f, -0.04285727f, 0.03669182f, 0.04142134f, 
    -0.02433962f, 0.15292968f, 0.08965844f, -0.03182658f, 0.06945599f, -0.07462517f, -0.02400696f, 0.11410403f, 
    0.02978479f, -0.12000592f, 0.17818151f, -0.04272942f, 0.08868928f, 0.01976871f, -0.09529930f, -0.02412688f, 
    -0.01586311f, 0.08443683f, -0.05068579f, -0.05244346f, 0.00430060f, 0.00746103f, 0.01780404f, 0.01454119f, 
    0.31819022f, -0.14597481f, -0.02860057f, 0.25715172f, -0.00963425f, 0.01285391f, 0.04319115f, 0.07031319f, 
    0.07759276f, -0.03450054f, -0.22018445f, 0.02641737f, 0.00560384f, -0.13224374f, -0.11658822f, 0.26681340f, 
    -0.05185829f, 0.06538498f, -0.00490167f, 0.11259626f, 0.00186360f, 0.02338407f, -0.10438112f, -0.11860421f, 
    -0.30316117f, -0.13879555f, -0.09823194f, -0.09626759f, 0.02412087f, 0.04394609f, 0.03582927f, -0.03803054f, 
    -0.02918503f, 0.03518832f, 0.01294768f, -0.07387477f, -0.15582657f, -0.09570575f, -0.03468783f, 0.29068500f, 
    -0.04194687f, 0.02487127f, -0.05697165f, -0.03050934f, 0.05482572f, -0.02672551f, -0.06946616f, -0.03106519f, 
    0.22536367f, 0.17381856f, 0.11081305f, 0.16927753f, 0.07822315f, 0.07318594f, 0.01736829f, -0.03036442f, 
    -0.02013205f, -0.19371749f, -0.04489153f, 0.04906630f, 0.10324590f, 0.03308991f, -0.07020061f, -0.11934364f, 
    -0.00236150f, 0.01624574f, 0.05019661f, 0.07433009f, -0.00855409f, 0.01966800f, 0.01785308f, 0.05502480f, 
    0.13626611f, 0.26502162f, 0.20570762f, 0.09731337f, 0.01613702f, 0.07754762f, 0.02315102f, -0.01251475f, 
    -0.03345252f, 0.07300404f, 0.15774931f, 0.16037996f, -0.10639293f, -0.02881335f, 0.09378624f, 0.07140270f, 
    0.13016167f, -0.12962706f, 0.04839449f, 0.10271192f, 0.13914676f, 0.02878922f, -0.01290843f, 0.00493350f, 
    -0.05693683f, 0.10548701f, 0.05127773f, -0.04089744f, -0.03073271f, -0.06192929f, -0.09187515f, 0.10103723f, 
    0.06040417f, -0.02096485f, -0.02470420f, -0.06534996f, -0.31747121f, 0.01897956f, -0.02971114f, -0.10238113f, 
    0.01637849f, -0.03342565f, 0.04559773f, 0.03138506f, -0.07238889f, -0.00481947f, -0.00622714f, 0.01712485f, 
    0.15302645f, 0.15094899f, 0.02053573f, 0.29076234f, 0.05875907f, -0.01466578f, -0.00209944f, -0.05106078f, 
    0.00005350f, 0.02431884f, -0.01173716f, -0.06325777f, -0.01742667f, 0.03620799f, 0.23216797f, -0.12507334f, 
    -0.14741713f, 0.00809604f, 0.10640013f, 0.08491594f, -0.02118426f, 0.09346282f, -0.00618240f, -0.00742216f, 
    -0.17638049f, -0.11593305f, -0.04486119f, 0.11932573f, 0.07722761f, -0.08576088f, -0.15379937f, 0.07034091f, 
    0.06037300f, 0.05597852f, -0.00990331f, -0.03947409f, 0.22868802f, 0.07283919f, -0.11541934f, 0.20086554f, 
    -0.09316728f, -0.02710134f, 0.21021466f, -0.05815150f, -0.00514346f, 0.07660136f, 0.10065826f, 0.13831383f, 
    -0.23776262f, -0.01840319f, -0.03060023f, 0.19876824f, -0.06641410f, 0.06550526f, 0.08001492f, 0.02490392f, 
    0.04553948f, 0.02402387f, 0.07505675f, -0.01765788f, 0.04337453f, -0.01985663f, -0.04811047f, 0.01679681f, 
    -0.00825074f, 0.13257289f, -0.02177874f, 0.00671150f, 0.06780317f, 0.17125192f, -0.07740465f, 0.01521370f, 
    0.12841097f, 0.11250643f, 0.26811087f, -0.04229032f, 0.03843025f, -0.02711185f, 0.14700782f, 0.09609190f, 
    -0.05775375f, 0.00769976f, 0.08103363f, 0.10161784f, 0.05855416f, -0.00132122f, 0.08409069f, -0.07954028f, 
    0.03925103f, -0.02181050f, -0.02342479f, 0.01211887f, 0.04024558f, -0.14484477f, 0.06953583f, -0.07778609f, 
    -0.00783335f, 0.00714796f, -0.05739110f, -0.06653532f, 0.00080056f, 0.08553813f, -0.10043637f, -0.05559392f, 
    -0.00748923f, -0.04420260f, 0.00057792f, 0.02818044f, 0.17378958f, 0.15765704f, -0.17180949f, 0.09916220f, 
    -0.08136015f, 0.04743952f, 0.02922968f, -0.01074916f, -0.09176732f, 0.10548091f, 0.03706013f, -0.00240303f, 
    0.17709045f, -0.00356750f, 0.00479465f, -0.00312964f, -0.02557105f, 0.01193597f, -0.02482437f, 0.05673488f, 
    -0.00749500f, 0.11647981f, 0.01438939f, -0.04773619f, -0.06964589f, 0.03894112f, -0.12780559f, -0.03845269f, 
    -0.02541448f, -0.05386642f, 0.02073466f, 0.05036903f, -0.01419869f, -0.02741110f, -0.08157413f, 0.17519675f, 
    -0.10819186f, 0.07178701f, 0.07685670f, 0.08103814f, 0.03159076f, 0.14811754f, 0.02513161f, -0.05322348f, 
    0.10245478f, 0.09041427f, 0.09786379f, 0.09932352f, 0.51621801f, 0.23056351f, 0.10358791f, 0.00010363f, 
    -0.06789559f, -0.00171298f, 0.00442576f, 0.04058225f, -0.03645797f, 0.03901032f, -0.04809714f, 0.05759571f, 
    -0.16355257f, 0.02982602f, 0.11826415f, 0.19717002f, -0.01970883f, -0.12942576f, 0.13388829f, 0.11202286f, 
    0.01064565f, -0.00680230f, 0.03674541f, -0.08143416f, -0.12920918f, 0.11734129f, -0.01875199f, -0.07586558f, 
    -0.04554541f, -0.09658210f, -0.07530421f, 0.07438425f, -0.10645572f, -0.04568327f, -0.18090449f, -0.06152858f, 
    -0.13637698f, 0.01389346f, 0.09010904f, 0.03590727f, -0.10732295f, -0.05778414f, -0.08859003f, 0.09459673f, 
    -0.03885737f, 0.01233419f, 0.10489972f, 0.00257341f, -0.02274370f, -0.02730548f, -0.15385140f, 0.02739718f, 
    -0.02547840f, -0.05334142f, 0.04273451f, -0.00623475f, 0.03437283f, -0.03846668f, -0.10645698f, -0.02527556f, 
    -0.04509982f, -0.07038501f, 0.18429673f, 0.03877790f, 0.00758950f, -0.06808486f, 0.01706514f, 0.00271689f, 
    0.00787490f, -0.03412778f, -0.06191998f, -0.05862513f, -0.11075696f, 0.10574345f, 0.04962155f, -0.05065234f, 
    0.04216187f, 0.00343881f, 0.01629174f, 0.03066386f, -0.05288262f, 0.04477894f, 0.15625758f, -0.10235590f, 
    0.23002732f, 0.05718438f, -0.14731151f, 0.21724616f, 0.02834757f, 0.06979918f, 0.01438497f, 0.00516371f, 
    -0.03093074f, -0.00431844f, -0.08607370f, 0.00152012f, -0.32999372f, 0.05523032f, -0.01360771f, -0.03805861f, 
    -0.07333830f, 0.03186511f, 0.01696905f, 0.02636157f, -0.03615808f, 0.00780442f, 0.06392629f, -0.03507536f, 
    0.05256166f, -0.24406113f, 0.15175694f, -0.00445100f, 0.08390965f, 0.07594123f, -0.01016160f, 0.02078840f, 
    -0.07173495f, -0.00918940f, 0.04144202f, 0.11119575f, 0.03783915f, 0.08800496f, 0.11618856f, -0.20132861f, 
    0.02070845f, 0.06126849f, 0.04113151f, -0.03518580f, 0.01503725f, -0.01350351f, 0.08406730f, 0.04433517f, 
    0.06757175f, 0.07619270f, 0.01708372f, 0.13283034f, 0.08701957f, 0.09652807f, -0.03638942f, 0.02880870f, 
    0.07652826f, 0.01025128f, 0.11707541f, 0.01736054f, -0.04912196f, 0.02069699f, -0.05773452f, -0.05636328f, 
    0.06455970f, -0.02027075f, 0.08106157f, 0.16620715f, 0.10579643f, -0.06125432f, 0.05198811f, 0.09016889f, 
    -0.08146188f, -0.07269756f, -0.07452381f, -0.10660481f, 0.01449078f, 0.00289347f, 0.08033984f, 0.02004002f, 
    0.00147898f, 0.06963442f, -0.00983217f, 0.06791153f, 0.10762021f, -0.05216518f, -0.13647938f, -0.11027394f, 
    -0.05602400f, 0.03379398f, -0.10234214f, -0.01616201f, -0.06817531f, -0.05323103f, 0.01772837f, -0.11715602f, 
    0.02241235f, -0.13273805f, 0.04384810f, -0.07272501f, 0.00344077f, 0.01425445f, 0.00107042f, 0.01290023f, 
    -0.03118586f, -0.02192818f, -0.04358258f, 0.12136250f, 0.18801256f, 0.17401308f, 0.08957792f, 0.00286076f, 
    0.10638490f, -0.02511894f, 0.06443306f, -0.12015808f, 0.01562404f, -0.04788027f, 0.02303693f, -0.07711747f, 
    -0.10344448f, 0.03100504f, 0.16059364f, -0.05077779f, 0.03311229f, 0.00221059f, 0.14148304f, 0.03522311f, 
    0.05990271f, 0.03994315f, 0.03222757f, -0.06444632f, 0.10813415f, 0.13981614f, 0.14787276f, 0.02628076f, 
    0.00509154f, 0.04543792f, -0.04373407f, 0.00664942f, 0.09043736f, -0.00963967f, -0.07230438f, 0.08160443f, 
    -0.08960680f, -0.29241166f, -0.19012670f, 0.12855266f, -0.05348821f, 0.06785017f, 0.05933038f, -0.09167636f, 
    0.04212419f, -0.02879764f, -0.01321170f, -0.09530342f, 0.02426648f, 0.16289744f, -0.07336365f, 0.00871652f, 
    0.04627451f, -0.01000402f, -0.00729127f, -0.09644804f, -0.03748549f, -0.01594137f, -0.02691632f, -0.11633824f, 
    0.31331474f, -0.14647144f, 0.15814427f, -0.19452551f, 0.09806351f, 0.14256303f, 0.14282581f, -0.03274771f, 
    0.04127439f, 0.02477053f, 0.05613897f, 0.02903727f, 0.07812611f, 0.06538836f, 0.00010643f, 0.01831419f, 
    -0.03611224f, 0.04819185f, 0.05860251f, -0.02758398f, 0.06395847f, 0.05742852f, 0.05222813f, -0.09407707f, 
    -0.34994981f, -0.11544204f, 0.01407187f, -0.03609143f, 0.07520489f, 0.02187565f, 0.05174065f, -0.05859400f, 
    0.04177243f, -0.01826491f, -0.02379747f, 0.09778603f, -0.00896552f, 0.20404068f, 0.27357787f, -0.02979185f, 
    0.05100170f, 0.06294143f, 0.12898460f, 0.13784854f, 0.11960661f, 0.14669843f, -0.10172051f, 0.04405789f, 
    0.21543972f, 0.08813381f, 0.04900181f, -0.11008521f, -0.06892556f, -0.04321563f, 0.00581127f, -0.00430313f, 
    0.00337105f, -0.12596603f, -0.01448326f, -0.01237896f, -0.28677636f, 0.10886434f, 0.06304716f, -0.10148875f, 
    0.00355142f, 0.00668882f, -0.02181157f, 0.05817928f, 0.02146574f, 0.10179713f, -0.04280954f, -0.01465054f, 
    -0.00872794f, -0.18619350f, -0.07677533f, 0.32817942f, 0.05833200f, 0.02423405f, 0.03815824f, 0.08307447f, 
    0.09752622f, -0.04771473f, 0.04032142f, -0.00773182f, -0.04816584f, -0.03511813f, -0.06156611f, -0.10910294f, 
    -0.05642811f, -0.05337676f, 0.08590787f, 0.11252019f, 0.04660243f, -0.07870307f, 0.08667237f, 0.13789946f, 
    -0.22581071f, 0.10034665f, 0.08120786f, -0.07952885f, 0.03354761f, 0.02013617f, -0.02389410f, -0.07797024f, 
    0.01189039f, -0.03614876f, 0.07906327f, -0.02233012f, 0.31127858f, -0.12197435f, -0.23573519f, 0.15941659f, 
    -0.02978870f, 0.02590650f, -0.05784465f, 0.00111123f, -0.04737047f, -0.11876652f, -0.01146853f, -0.06327550f, 
    -0.19952057f, -0.16636610f, -0.12223662f, 0.02109351f, 0.05410055f, 0.11324947f, -0.04280015f, -0.01718034f, 
    -0.03005433f, 0.04531438f, 0.09867229f, -0.10961169f, -0.10262069f, -0.06028331f, -0.02902207f, -0.05554730f, 
    -0.04762708f, 0.03799055f, 0.00852027f, 0.00337304f, 0.02178206f, 0.16159004f, 0.09918424f, 0.06767648f, 
    -0.03861726f, -0.01639823f, 0.02159731f, -0.01979616f, 0.02476951f, -0.03322606f, 0.01616774f, 0.02359554f, 
    0.03008710f, 0.01330967f, 0.02529959f, -0.02566008f, -0.03437433f, 0.03186187f, 0.02470055f, 0.02889123f, 
    -0.00429017f, 0.00411581f, -0.02309933f, -0.01369078f, -0.02394550f, -0.03397101f, 0.02181117f, -0.03276871f, 
    -0.03661444f, -0.00517583f, -0.03623722f, 0.02254118f, -0.01453969f, -0.02582547f, -0.01043381f, -0.00650802f, 
    0.01930184f, 0.02267804f, -0.00219331f, 0.03077931f, 0.02064763f, -0.01717748f, -0.01999001f, -0.03190262f, 
    0.02786424f, 0.00984518f, 0.01773709f, -0.01307847f, -0.03283492f, -0.01715211f, -0.03321067f, -0.03193574f, 
    -0.03180937f, 0.01803368f, 0.01516195f, 0.02674107f, -0.00978086f, 0.00618619f, -0.03406472f, -0.02903044f, 
    -0.04098670f, -0.01893268f, -0.03788735f, 0.00461014f, -0.00086577f, -0.02292206f, 0.00228488f, 0.02189910f, 
    -0.00218551f, 0.00922365f, -0.02668094f, -0.01600245f, -0.00906155f, -0.00019767f, 0.01882059f, -0.00488781f, 
    -0.01607989f, 0.00062187f, -0.04102254f, -0.01427136f, 0.00340814f, -0.00508738f, -0.03632127f, -0.00855285f, 
    -0.03407989f, -0.02437671f, -0.03596764f, -0.01981073f, 0.01047325f, -0.02075060f, -0.01978823f, 0.00198232f, 
    -0.00067699f, -0.03622786f, -0.03084159f, -0.02320522f, -0.00175442f, 0.01485780f, -0.03574140f, -0.00663193f, 
    0.01630495f, 0.03090950f, -0.00499347f, 0.02712813f, 0.01944141f, -0.00761609f, 0.02577047f, -0.01624873f, 
    -0.00549926f, -0.02696146f, 0.01818832f, -0.02522282f, 0.02494884f, 0.01798862f, -0.02168288f, 0.01257250f, 
    0.01253368f, -0.03327449f, -0.01985076f, -0.01131865f, -0.00111948f, -0.02476991f, 0.02414838f, -0.00215316f, 
    -0.01683801f, -0.00926718f, -0.00214372f, -0.01832938f, -0.03809537f, -0.03630772f, -0.01390202f, -0.02953483f, 
    0.00664091f, 0.01422432f, -0.00371277f, -0.00992804f, -0.03533838f, 0.02014379f, -0.01459802f, -0.00652539f, 
    -0.00335167f, -0.02745135f, -0.02918142f, -0.00300415f, 0.00621195f, -0.00257312f, -0.03631534f, 0.01124654f, 
    -0.01241882f, -0.03081113f, 0.01984035f, 0.00306369f, 0.02819298f, 0.02675700f, 0.01456762f, 0.01507587f, 
    -0.02529055f, 0.00224465f, -0.02520392f, 0.02009865f, 0.01204327f, -0.03621694f, -0.01728569f, -0.03164014f, 
    -0.03143407f, -0.03417458f, -0.03519738f, -0.04073356f, -0.03631235f, -0.00295922f, -0.03094501f, 0.00005152f, 
    0.01167509f, 0.00472653f, 0.00857122f, 0.00898828f, -0.00908044f, 0.02334880f, -0.03398938f, -0.01759051f, 
    0.00798674f, -0.04021080f, 0.03048949f, 0.02320649f, 0.02344127f, 0.00423386f, -0.00610656f, -0.00577616f, 
    0.00178783f, 0.02490956f, -0.02389307f, 0.02762310f, -0.02832324f, -0.00295869f, -0.02423042f, -0.01587393f, 
    -0.03796222f, -0.03688802f, -0.03301352f, -0.00541032f, 0.00523319f, -0.01880777f, -0.02001312f, -0.00844080f, 
    -0.00208789f, 0.02861628f, 0.00573890f, 0.02096248f, -0.00847953f, -0.03899977f, 0.01390278f, 0.00585888f, 
    0.02466424f, -0.01578789f, -0.01365389f, -0.03368526f, -0.00994121f, -0.03105218f, 0.00991447f, 0.00807674f, 
    0.01540393f, 0.00048673f, 0.02597520f, -0.01109253f, -0.02451974f, -0.00096252f, 0.00853036f, -0.02882024f, 
    -0.02660616f, 0.00772344f, -0.03257864f, -0.00239217f, -0.01096913f, 0.00335567f, 0.02460703f, 0.02741062f, 
    0.01173407f, -0.02579875f, -0.02681184f, 0.02950407f, 0.00625511f, -0.04108324f, -0.02852692f, 0.00190843f, 
    -0.00983755f, -0.03985893f, -0.01845071f, 0.00611397f, -0.03940602f, 0.00405099f, -0.03216458f, 0.01514876f, 
    0.03496484f, 0.02152941f, -0.01697401f, 0.00018688f, -0.03703003f, 0.00421096f, -0.01034870f, -0.02225527f, 
    0.03067332f, -0.03610574f, -0.02214826f, 0.02071761f, -0.00770459f, -0.01123789f, -0.02223226f, 0.01779712f, 
    0.01144759f, -0.03672442f, -0.01233627f, 0.01232011f, -0.02313001f, -0.01077068f, -0.03314140f, 0.00768023f, 
    0.00126797f, -0.03836662f, 0.00868393f, 0.02290171f, 0.02823478f, 0.00583042f, 0.02064782f, 0.02777940f, 
    -0.02169644f, -0.00588901f, 0.01233210f, -0.01815067f, 0.02077044f, -0.01682454f, -0.02514314f, -0.00892216f, 
    0.01518738f, -0.03394043f, 0.01642687f, -0.02195084f, -0.02689894f, -0.03092500f, -0.03298601f, 0.02202135f, 
    -0.03991476f, -0.01695471f, 0.00833479f, 0.02722478f, 0.01157694f, -0.04119118f, 0.01782103f, 0.01160885f, 
    -0.03237056f, -0.03762598f, 0.02967822f, -0.01816105f, 0.01853447f, 0.02327110f, -0.01514596f, -0.00034713f, 
    0.01997227f, 0.02605456f, -0.00304931f, -0.02793610f, 0.02711553f, -0.00358976f, 0.01932514f, 0.00356640f, 
    -0.03571155f, -0.03665283f, -0.02618654f, -0.03901720f, -0.04055713f, 0.00242242f, 0.02784406f, 0.00384964f, 
    -0.01796440f, 0.00752646f, -0.03352186f, -0.01992799f, -0.01016086f, 0.02735204f, -0.03091978f, -0.03334333f, 
    -0.03007118f, -0.01597055f, 0.01323097f, -0.00000598f, 0.01168448f, 0.01959234f, -0.01603007f, -0.03461256f, 
    0.00494166f, -0.03210286f, 0.00818828f, -0.00463937f, 0.00294696f, 0.02785860f, -0.00862903f, -0.00202554f, 
    -0.00651531f, -0.02697100f, 0.01406068f, -0.03924144f, -0.03703528f, -0.00788508f, -0.01713636f, -0.00756315f, 
    0.01585778f, 0.02992434f, 0.02816093f, -0.00430159f, 0.02576861f, -0.04034103f, 0.00221364f, -0.00564046f, 
    -0.03596128f, -0.03938698f, -0.01179416f, -0.03855864f, -0.02070179f, 0.02892051f, -0.00380582f, 0.03552990f, 
    -0.02245646f, 0.02156606f, 0.01029310f, 0.02925208f, 0.00730473f, -0.03259179f, -0.04060332f, -0.01436151f, 
    -0.00849216f, -0.01137573f, -0.03578943f, -0.01467842f, -0.03899127f, -0.02002578f, 0.03492661f, 0.01003284f, 
    -0.01242204f, -0.03594501f, -0.00540196f, -0.00660586f, -0.01405550f, 0.03086607f, -0.00767239f, 0.00056705f, 
    -0.01382743f, 0.02083200f, 0.02998541f, 0.02980092f, 0.02694929f, 0.00458050f, -0.00832575f, -0.03441351f, 
    0.02911600f, -0.01366544f, 0.02813598f, 0.00332854f, -0.00712721f, -0.02271530f, 0.01924101f, 0.02980775f, 
    0.02039490f, 0.00609657f, 0.00627057f, -0.03363525f, 0.01078165f, -0.03740480f, -0.02720878f, -0.03575413f, 
    0.03046077f, -0.00773843f, -0.02444161f, -0.01411639f, -0.03176908f, 0.01583738f, -0.01253270f, -0.00220834f, 
    -0.00646754f, 0.02835090f, -0.01751058f, -0.01544185f, -0.00038621f, 0.02565635f, 0.00741759f, -0.01730751f, 
    -0.04002834f, -0.00356454f, 0.02104676f, -0.00382812f, -0.03914676f, -0.02466555f, -0.03912727f, -0.02990249f, 
    -0.03265129f, 0.00386729f, 0.01057640f, 0.02715279f, -0.04055210f, -0.01250994f, -0.01740888f, 0.00354685f, 
    -0.01601018f, -0.00506282f, 0.02788729f, 0.00615312f, -0.03821786f, -0.02113622f, -0.00345341f, -0.01820164f, 
    -0.03478145f, 0.02940330f, 0.00230200f, -0.01557960f, -0.00914522f, -0.03699157f, 0.00890425f, -0.01114659f, 
    0.02639208f, 0.00429595f, -0.01370846f, -0.01765322f, -0.01525238f, -0.00733737f, -0.03408450f, 0.00582737f, 
    -0.01866916f, 0.01657855f, -0.02359900f, 0.02169608f, -0.00562389f, 0.00246311f, -0.02534130f, -0.02925078f, 
    -0.01862916f, 0.00947120f, -0.01409870f, -0.00698816f, -0.03628467f, 0.02390150f, 0.01081705f, -0.00777352f, 
    -0.03558087f, 0.02171637f, -0.01169787f, -0.03731284f, 0.00587312f, -0.03818551f, 0.02183775f, 0.02174142f, 
    0.00803296f, 0.02112363f, 0.02414083f, 0.01065395f, -0.00948416f, 0.01343087f, -0.01370275f, -0.00446023f, 
    -0.02413347f, 0.01819034f, -0.02760026f, -0.03202504f, 0.02972874f, -0.03840031f, -0.00603688f, 0.01705704f, 
    -0.02242160f, 0.00157457f, -0.02505549f, 0.02964428f, -0.03472597f, 0.00812883f, 0.00840802f, 0.01279932f, 
    -0.02584011f, -0.00890696f, -0.02352276f, 0.02924742f, -0.01053552f, -0.00273752f, -0.03797276f, -0.00048638f, 
    -0.04099342f, 0.01660339f, -0.01418666f, -0.02261304f, -0.00964205f, 0.02579623f, 0.01103733f, -0.03698665f, 
    -0.02945416f, -0.01047329f, 0.00345361f, 0.02514437f, 0.01640239f, -0.02286623f, -0.03016564f, -0.02700115f, 
    -0.02257226f, -0.03793619f, -0.00207096f, 0.01433314f, -0.00798633f, 0.01195372f, -0.03955338f, -0.03650467f, 
    0.02603821f, 0.00587281f, 0.00006676f, -0.03810438f, -0.03234050f, 0.00649719f, -0.03582281f, -0.02634942f, 
    -0.02746664f, -0.03577060f, 0.01887720f, -0.01924248f, -0.03188439f, 0.00273640f, 0.00443665f, -0.02661021f, 
    -0.02495409f, -0.03456269f, 0.00954802f, -0.00576903f, 0.01540288f, 0.01489151f, -0.00961398f, -0.00961040f, 
    0.03007736f, 0.02578481f, -0.03468736f, -0.00110918f, 0.02662037f, -0.02079628f, 0.00931017f, -0.03037252f, 
    -0.02839731f, 0.01568020f, -0.02712279f, -0.02128597f, -0.02758691f, 0.02983020f, -0.00573655f, -0.01861390f, 
    0.02141948f, 0.01638037f, -0.02002666f, -0.01804580f, 0.02291843f, 0.02206025f, -0.00432881f, -0.03010609f, 
    0.02172674f, 0.00684990f, 0.02316701f, -0.03953727f, 0.01736568f, -0.03844534f, -0.01130798f, 0.00753752f, 
    -0.03153867f, -0.00136056f, -0.02249545f, 0.01808752f, 0.00195413f, -0.00704589f, 0.01697905f, 0.00286528f, 
    -0.03664630f, 0.01058844f, 0.00078694f, -0.01974301f, -0.00663782f, -0.01385480f, -0.01106922f, -0.00719136f, 
    -0.01339973f, 0.00579432f, 0.00884332f, 0.02549719f, 0.02344540f, 0.02850142f, -0.02120835f, -0.04031103f, 
    -0.02406532f, -0.01596808f, -0.02628093f, -0.00490146f, -0.00949169f, 0.00058458f, -0.03509645f, -0.03812577f, 
    -0.00492994f, 0.01853366f, 0.02697393f, -0.01309335f, -0.02396804f, -0.01616063f, 0.02255134f, -0.01660006f, 
    -0.00049228f, -0.00462973f, -0.02364850f, 0.02118841f, 0.00067942f, 0.01855300f, -0.00974722f, -0.03266631f, 
    -0.00109471f, -0.03265234f, -0.03595131f, 0.02660556f, -0.02805384f, -0.00159874f, -0.02731479f, -0.00694077f, 
    0.01205350f, -0.02073482f, 0.00707583f, -0.01919148f, -0.02807554f, 0.01958447f, 0.02172251f, 0.02721928f, 
    -0.01034987f, 0.02144170f, 0.01701742f, 0.00946203f, -0.00759918f, 0.02746337f, -0.01705453f, -0.03550408f, 
    0.01251453f, -0.02083191f, -0.00307430f, -0.03939933f, -0.02496968f, -0.03174588f, -0.00609606f, 0.01638382f, 
    0.02846789f, 0.01002167f, -0.00466254f, 0.02981773f, -0.00351655f, 0.03056999f, 0.01434427f, 0.03201716f, 
    -0.03945486f, 0.00408459f, 0.00043001f, 0.00323441f, 0.00192510f, 0.02053334f, 0.01585499f, 0.02432693f, 
    0.02567893f, 0.00167052f, 0.01695043f, 0.00487430f, -0.03342226f, -0.03541452f, 0.02435827f, -0.00368633f, 
    0.03085992f, -0.02833723f, 0.00508733f, -0.03097406f, 0.01368999f, -0.03226361f, 0.02119650f, -0.01889212f, 
    0.03008967f, -0.01297499f, -0.02792813f, -0.03877786f, 0.02737696f, 0.00375641f, -0.00848555f, -0.03407122f, 
    0.03360196f, 0.02871825f, -0.02895733f, 0.00772762f, -0.00185683f, -0.03510424f, 0.01137212f, -0.00789000f, 
    -0.03431429f, -0.00282212f, -0.00598410f, -0.03632857f, -0.00194302f, 0.03047838f, -0.03918065f, -0.03956752f, 
    0.00646931f, -0.02517749f, -0.01131735f, -0.00689429f, -0.03404585f, 0.02641577f, 0.00164486f, -0.00181274f, 
    0.01702545f, 0.01593228f, 0.03057808f, -0.01178311f, -0.02574117f, -0.03716096f, 0.02782579f, 0.01460071f, 
    -0.01652349f, 0.01903461f, -0.01538141f, -0.03587516f, -0.02720462f, -0.02966580f, -0.00259191f, 0.02872900f, 
    0.00013199f, -0.02685796f, 0.01477731f, -0.01003928f, -0.00047450f, -0.00423254f, 0.02361293f, 0.01682030f, 
    0.00561037f, -0.01150953f, 0.02928074f, 0.01223205f, 0.00124637f, -0.02116818f, 0.01386982f, -0.02613112f, 
    0.02322478f, 0.02877168f, -0.02816107f, -0.00761454f, -0.01545962f, 0.01710745f, 0.00614533f, -0.00885744f, 
    0.02605462f, 0.00218418f, -0.01104278f, -0.00436515f, -0.03681514f, 0.00291858f, 0.02359745f, 0.03755541f, 
    -0.02921097f, -0.01143380f, 0.00280503f, 0.02144695f, -0.00554412f, -0.04015695f, 0.01975947f, 0.00843079f, 
    0.00038809f, -0.00013021f, 0.03548467f, 0.02867445f, 0.00762660f, -0.01800481f, -0.03433781f, -0.00354393f, 
    -0.00938479f, 0.00475015f, 0.02093958f, -0.03312295f, -0.02781777f, -0.03190278f, 0.01639498f, 0.02915610f, 
    -0.02844542f, 0.01374769f, -0.02951648f, -0.01282517f, 0.01819996f, -0.04091403f, 0.02153544f, 0.00520897f, 
    -0.02918308f, 0.02793565f, 0.02938000f, -0.01808259f, 0.01228680f, -0.03208206f, -0.03214306f, 0.02190348f, 
    0.01577115f, -0.01984165f, -0.02427801f, -0.00844215f, -0.01091519f, 0.00130084f, -0.01241283f, 0.00208836f, 
    -0.00338091f, 0.02877390f, -0.02342887f, 0.01879855f, 0.02793625f, 0.01781056f, -0.02935862f, -0.01525101f, 
    -0.00974350f, -0.01223867f, -0.01821633f, -0.00478144f, 0.00403772f, -0.00356554f, 0.01764792f, 0.03095513f, 
    -0.01651854f, 0.01751220f, -0.02546793f, -0.03654135f, -0.01728802f, 0.01170145f, -0.03273350f, 0.01636363f, 
    0.03894704f, -0.03900845f, 0.01782522f, 0.02281450f, -0.02924456f, -0.01815534f, 0.00423200f, 0.02169898f, 
    0.01154520f, 0.02452724f, 0.00019236f, 0.03923758f, 0.01976273f, 0.00012748f, -0.01907744f, -0.01613623f, 
    0.00119503f, 0.02421007f, 0.00055063f, -0.02053455f, 0.03099685f, 0.01899664f, 0.02556454f, 0.02307240f, 
    -0.02806755f, 0.01437655f, -0.03506727f, 0.00369528f, -0.00169167f, -0.00636393f, 0.02852600f, -0.01477577f, 
    0.01505942f, 0.02455641f, 0.01978083f, -0.00098461f, 0.02775872f, -0.01453019f, 0.03607637f, 0.01884091f, 
    0.02777179f, -0.01483088f, 0.00238369f, -0.01199821f, 0.01428401f, -0.00561498f, -0.00008742f, 0.01297924f, 
    -0.01202096f, -0.01598319f, -0.00408184f, -0.01155844f, -0.03550955f, -0.01889061f, -0.02123526f, 0.02985409f, 
    -0.01555709f, -0.01060411f, 0.01797595f, 0.02956260f, -0.03293001f, -0.01882626f, 0.01745191f, -0.03531563f, 
    -0.02034405f, 0.03290970f, -0.02207737f, -0.00953039f, -0.00200120f, -0.01976009f, -0.02117775f, 0.00213037f, 
    -0.01109495f, -0.03547886f, 0.02270294f, 0.02777971f, -0.02158085f, -0.01858743f, -0.02579528f, 0.00886485f, 
    -0.03314938f, -0.02304271f, 0.02588198f, -0.03689583f, 0.00120557f, 0.01642467f, 0.00135424f, -0.01198864f, 
    -0.04176186f, -0.02508541f, 0.00759414f, 0.01003168f, 0.02802131f, 0.00193425f, -0.00649848f, 0.00129607f, 
    -0.01494820f, -0.00418523f, 0.00409133f, -0.01273589f, 0.01161821f, -0.03168968f, 0.02775082f, 0.00078524f, 
    -0.03950335f, -0.03857788f, -0.01800747f, -0.04089132f, -0.00699616f, -0.01384282f, 0.00219598f, -0.00814648f, 
    0.01173807f, -0.01040601f, -0.02475517f, 0.00964818f, -0.01934741f, -0.02323959f, -0.03020439f, 0.01542113f, 
    -0.02079561f, -0.01876938f, -0.03550141f, -0.00408640f, 0.02665919f, -0.01149339f, 0.01887120f, 0.03932379f, 
    -0.02924718f, -0.03216833f, -0.01667762f, 0.01349367f, 0.02455458f, 0.02559358f, 0.00404505f, 0.01306735f, 
    -0.02852449f, 0.01053993f, -0.02603936f, -0.03614127f, -0.00943186f, 0.01220305f, 0.01640394f, -0.01024607f, 
    -0.02676762f, 0.01051385f, 0.02678600f, -0.01374102f, -0.04186529f, -0.03988987f, -0.04032467f, -0.00502621f, 
    0.01578010f, 0.00651507f, 0.01095869f, -0.03713156f, 0.02028451f, 0.02238494f, 0.02810333f, -0.01975965f, 
    -0.00366289f, -0.00489323f, 0.02401248f, -0.02194679f, -0.00419280f, 0.02378792f, 0.00529225f, -0.01992349f, 
    0.01940025f, 0.00064410f, 0.00467831f, -0.01006652f, 0.00368693f, -0.00312450f, -0.02488272f, -0.00436747f, 
    -0.03891190f, -0.00002545f, -0.01555421f, 0.00118267f, -0.02231767f, -0.01933079f, 0.02851531f, 0.03691388f, 
    0.01594096f, -0.01623249f, -0.00165972f, -0.02692676f, -0.02333775f, 0.00765454f, -0.00158976f, -0.02551919f, 
    -0.00090566f, 0.02053292f, -0.00311439f, 0.00981657f, -0.00110043f, -0.01912137f, 0.02540160f, -0.00930870f, 
    -0.02303474f, -0.03040031f, -0.02585346f, -0.02487689f, -0.01918060f, 0.01419397f, -0.02139180f, 0.03902758f, 
    -0.00092507f, 0.01374940f, -0.02171828f, -0.00685864f, 0.01060536f, 0.03074145f, 0.02221994f, 0.00914258f, 
    -0.01502965f, -0.02606325f, -0.03818749f, -0.01729878f, 0.00929419f, 0.02386662f, 0.02300558f, 0.03664638f, 
    0.01035663f, -0.01508421f, 0.02320834f, -0.03062414f, -0.02148711f, 0.02282902f, -0.03423471f, 0.00124144f, 
    -0.03724687f, -0.02308860f, -0.02125829f, -0.02615560f, 0.02986757f, -0.02601049f, 0.02747003f, -0.04135441f, 
    0.01226827f, -0.01424646f, -0.01175841f, -0.02849701f, 0.00269608f, -0.00399383f, 0.01292153f, -0.03400297f, 
    0.02973918f, 0.01872984f, -0.03054126f, -0.01173804f, -0.00969441f, -0.01801026f, -0.00375716f, 0.00081447f, 
    -0.03042693f, -0.03496611f, 0.01537791f, 0.02286508f, 0.03379636f, -0.02476981f, 0.01013148f, -0.03701566f, 
    0.03549784f, 0.00981303f, 0.04192955f, -0.03609199f, -0.01595011f, -0.02566018f, 0.00844017f, -0.03846762f, 
    0.01387260f, -0.02976629f, 0.01589107f, 0.02000024f, -0.03427225f, -0.02684239f, -0.01443336f, 0.03542921f, 
    -0.00139418f, 0.01082229f, -0.00078106f, -0.03727525f, 0.00339788f, 0.00540894f, 0.01258372f, 0.00644956f, 
    -0.01717362f, 0.02994389f, 0.01398625f, -0.03244123f, -0.02830493f, -0.01577546f, 0.01861708f, -0.02167636f, 
    0.00421798f, 0.01234976f, -0.01277541f, -0.03268947f, 0.01643405f, -0.02453039f, 0.02531279f, -0.01345164f, 
    -0.02518281f, -0.04126856f, 0.02821972f, -0.03004547f, -0.03180671f, -0.04178496f, -0.01637788f, 0.03398581f, 
    -0.02963822f, -0.00723069f, -0.03760617f, -0.02813110f, -0.01573721f, 0.02209877f, -0.01482066f, 0.00019063f, 
    -0.00313677f, -0.01754828f, -0.00293977f, -0.00660341f, 0.00677186f, -0.00907500f, -0.04124503f, 0.02237808f, 
    -0.01583885f, 0.00182875f, 0.02412460f, 0.01645362f, -0.01128446f, 0.01334237f, -0.02990114f, 0.00397549f, 
    -0.03631097f, 0.02341268f, 0.02413305f, -0.02551736f, -0.01296874f, 0.02761484f, -0.02137370f, -0.03878146f, 
    -0.01658557f, -0.00306985f, -0.01483489f, 0.02247887f, -0.03536907f, 0.01639042f, 0.02041067f, -0.00448869f, 
    0.02805744f, 0.01753994f, 0.04013566f, 0.01834265f, -0.01739760f, 0.00767546f, -0.03536542f, 0.02983605f, 
    -0.02460016f, 0.00272007f, -0.01727365f, -0.00661651f, 0.00126995f, 0.01678909f, -0.02310135f, 0.00340760f, 
    0.01716981f, -0.01325498f, -0.01157560f, -0.01663780f, 0.01289399f, -0.02605472f, -0.01167723f, -0.01148340f, 
    -0.00493653f, 0.03884295f, -0.02681245f, 0.04084365f, 0.00946184f, -0.00018701f, -0.01620248f, -0.03952282f, 
    -0.03476102f, 0.02949492f, -0.02518693f, -0.02527658f, -0.02152447f, 0.00081792f, -0.03769062f, 0.02780005f, 
    0.01532257f, -0.03954339f, -0.00208652f, -0.03174622f, -0.01252474f, -0.01047556f, 0.00609983f, -0.01064810f, 
    -0.02876215f, -0.02245199f, -0.01553144f, -0.01551806f, -0.00383033f, 0.01677872f, -0.02829142f, -0.00099964f, 
    -0.03162920f, 0.02723889f, 0.01024827f, -0.00515234f, 0.02152709f, -0.02227711f, 0.00735363f, 0.03995080f, 
    -0.00687315f, 0.02061088f, -0.01695689f, 0.00772266f, -0.02361901f, 0.00810546f, -0.02205649f, -0.03874156f, 
    -0.01846805f, 0.02110510f, 0.01838195f, 0.02243712f, 0.01603920f, -0.02195320f, -0.01389123f, -0.01077607f, 
    0.01253156f, 0.00123487f, -0.02405184f, 0.02232062f, 0.02749809f, 0.00184332f, 0.02667808f, 0.01121772f, 
    -0.00385425f, -0.04073136f, -0.00351904f, -0.00679667f, -0.01570484f, -0.03232436f, -0.00995699f, 0.01889380f, 
    -0.03608916f, 0.02905789f, 0.00862466f, -0.03606578f, 0.02172863f, -0.00485842f, -0.02887988f, 0.02547116f, 
    -0.02527277f, 0.03804758f, -0.03135332f, 0.02365309f, 0.01370731f, -0.01184202f, 0.02119129f, -0.02615829f, 
    0.00722188f, -0.00279321f, -0.02385731f, -0.01342430f, -0.01083294f, -0.02295287f, 0.04000855f, -0.00818804f, 
    -0.00564103f, -0.03450287f, 0.00526406f, 0.00802682f, -0.03951690f, -0.00813941f, 0.01364511f, 0.00984332f, 
    0.01725721f, -0.01256682f, 0.02734402f, 0.00148022f, 0.01301829f, -0.02770347f, 0.01358413f, -0.03495006f, 
    -0.03824851f, -0.00152618f, 0.02437211f, -0.01094513f, -0.02329202f, -0.00269536f, 0.00232393f, -0.03181469f, 
    -0.02533944f, 0.03516085f, -0.01150629f, 0.02057144f, 0.02680005f, -0.02499481f, 0.00688803f, 0.00620247f, 
    -0.03562626f, -0.01045186f, 0.02302095f, 0.02874954f, 0.02369482f, -0.00029175f, -0.00217632f, -0.02917064f, 
    0.02224630f, -0.02599850f, -0.01620154f, -0.00599127f, 0.01695389f, -0.02257134f, -0.02955658f, -0.03388182f, 
    -0.03282990f, 0.01305815f, -0.00466544f, -0.02870325f, -0.02648818f, -0.01198698f, 0.01664076f, -0.01183651f, 
    -0.01609979f, 0.02597013f, -0.01673534f, -0.04199725f, -0.01094379f, -0.01830439f, 0.00002638f, 0.01575683f, 
    0.00768267f, 0.01273398f, -0.03445058f, -0.01924507f, -0.02054767f, 0.02078153f, -0.02042739f, 0.00432399f, 
    -0.02493326f, -0.02759643f, -0.01688594f, -0.00313196f, 0.02843344f, -0.01355045f, -0.00426338f, 0.01520152f, 
    0.01313667f, 0.02285149f, 0.02058777f, -0.03361312f, 0.01803176f, 0.00431184f, -0.02789474f, -0.03782189f, 
    -0.04079126f, 0.01454492f, -0.03983254f, 0.01270155f, -0.00756853f, 0.00378530f, -0.01649675f, 0.00488613f, 
    -0.03298373f, 0.00982331f, -0.02712346f, 0.01922421f, -0.01210230f, -0.02232293f, -0.00556283f, -0.02416212f, 
    -0.02521360f, -0.03551830f, -0.03211518f, 0.01287460f, -0.01471524f, -0.04013600f, -0.04020797f, 0.02176992f, 
    0.01805722f, 0.02839335f, -0.02668474f, -0.02422314f, -0.03762770f, -0.04199237f, -0.00074331f, 0.00780448f, 
    -0.04082673f, -0.01816325f, -0.00310351f, 0.00625284f, -0.02360921f, 0.00857520f, 0.02862844f, -0.01578650f, 
    0.00239116f, -0.03100164f, 0.01272019f, 0.02492611f, -0.03993190f, 0.01552370f, -0.02902946f, 0.02785628f, 
    -0.01931156f, 0.02990685f, -0.00477981f, 0.01417926f, 0.01040271f, -0.02780981f, -0.00159072f, -0.01672264f, 
    -0.01103288f, 0.00637108f, 0.02114440f, 0.02210631f, 0.01809675f, 0.02105091f, 0.00434857f, -0.03414394f, 
    0.03658623f, 0.00446246f, 0.02852022f, 0.03221414f, -0.02700891f, 0.01494434f, 0.00594915f, -0.03782175f, 
    -0.03959678f, 0.01999838f, -0.01797605f, -0.01112286f, -0.01838033f, 0.00350113f, -0.01943742f, -0.00717226f, 
    0.02343107f, 0.01285395f, -0.02615665f, 0.02150735f, -0.03492270f, -0.02193105f, 0.00653926f, -0.02083253f, 
    -0.03592493f, -0.00416723f, 0.00718400f, 0.01115692f, 0.00775570f, 0.00208986f, 0.01489382f, -0.02760170f, 
    0.17700996f, -0.17604753f, -0.03786351f, -0.27236620f, -0.05529505f, 0.03191477f, -0.03002003f, -0.00414420f, 
    0.08659947f, -0.00334964f, 0.01393709f, 0.05719945f, 0.16433598f, 0.10677876f, -0.11032171f, 0.32197279f, 
    0.09455194f, 0.06280389f, 0.05555137f, 0.08676361f, -0.09196529f, -0.01787056f, 0.02070746f, -0.00259479f, 
    0.04639895f, -0.02607797f, 0.07595478f, 0.17062515f, 0.09797794f, 0.11373182f, -0.01430172f, 0.03102554f, 
    -0.01094429f, -0.00320093f, 0.01820607f, -0.08207607f, -0.30538869f, -0.02108719f, 0.12647152f, -0.21418457f, 
    0.03327283f, -0.01244975f, 0.12177559f, 0.02946776f, 0.09435950f, 0.03246399f, -0.02236626f, -0.03767328f, 
    -0.02160251f, -0.25478086f, 0.04577734f, 0.13234882f, -0.01538164f, -0.01173649f, 0.00140768f, 0.07645202f, 
    -0.09709810f, -0.06368512f, 0.07148626f, -0.01575584f, -0.12789196f, -0.00829128f, 0.05298246f, -0.04324726f, 
    0.09003385f, 0.00641214f, 0.05858900f, 0.08897144f, 0.08010192f, 0.07012522f, -0.01568506f, 0.03240085f, 
    0.11799182f, -0.01371570f, -0.02714282f, 0.30280828f, -0.06719725f, 0.13581082f, 0.02012649f, 0.00208133f, 
    0.04956226f, 0.04405532f, 0.11985398f, 0.11539426f, 0.20845999f, 0.04991737f, 0.02970982f, 0.28829682f, 
    0.09434392f, 0.08552822f, 0.02639048f, 0.04253129f, 0.05305868f, 0.05419764f, -0.03675516f, -0.00098785f, 
    0.05096690f, 0.03004438f, 0.00884154f, 0.07816304f, 0.03335152f, 0.01339310f, -0.07751215f, 0.07189222f, 
    0.06078499f, 0.01140600f, -0.02549663f, 0.02395829f, 0.05986844f, -0.23252346f, 0.02612712f, 0.21154615f, 
    0.12391508f, -0.07515273f, -0.05920297f, 0.03452956f, -0.03009953f, 0.14599043f, -0.00081662f, -0.02950616f, 
    -0.24193333f, -0.08746683f, 0.06550833f, -0.08206783f, 0.12302519f, 0.02530048f, 0.08673238f, -0.09480406f, 
    -0.04961823f, 0.11838400f, -0.06305905f, -0.08283547f, 0.16976742f, -0.01958483f, -0.02073883f, 0.07016397f, 
    -0.03793357f, -0.16815090f, -0.09742471f, -0.09945418f, 0.04264874f, 0.01313858f, 0.08872780f, -0.04846343f, 
    -0.12055259f, 0.02704965f, -0.09486313f, 0.04897888f, -0.05206943f, -0.02324444f, 0.07502991f, -0.08590367f, 
    -0.00856250f, -0.00873392f, -0.13506222f, 0.03214085f, -0.12657364f, 0.21000212f, -0.18145759f, -0.24115580f, 
    0.10937244f, -0.00520832f, -0.00978680f, -0.02196779f, 0.05901911f, 0.00927539f, 0.10740709f, 0.11911116f, 
    -0.15135957f, 0.10136344f, 0.03769027f, 0.10128243f, 0.13754554f, 0.09837514f, -0.00692507f, -0.01836251f, 
    -0.08827763f, 0.01926149f, 0.06632876f, 0.01318184f, -0.04149109f, 0.01958655f, 0.07633016f, 0.07722366f, 
    -0.04218921f, -0.04136867f, 0.17202574f, 0.05099456f, 0.08306766f, 0.09904092f, -0.08982830f, 0.15889545f, 
    0.14314370f, -0.00545668f, 0.13054788f, -0.18855441f, 0.07761207f, -0.05301791f, -0.00202623f, 0.01337580f, 
    -0.07521962f, -0.05231580f, 0.07734717f, 0.06056682f, -0.24584050f, -0.03100063f, -0.08994477f, -0.14679797f, 
    0.07775959f, 0.02143176f, 0.04256846f, 0.02536453f, -0.05672728f, 0.05918123f, 0.05031245f, -0.02898223f, 
    -0.08168127f, -0.13888408f, 0.08809242f, 0.30651081f, 0.18080997f, -0.05329507f, 0.03853803f, -0.01289734f, 
    -0.12657188f, 0.00934359f, -0.06789679f, 0.01673599f, -0.20658292f, -0.06539749f, 0.00154137f, -0.12871370f, 
    -0.12562183f, 0.00200841f, -0.10402238f, 0.01965494f, 0.00071112f, 0.01211766f, -0.05387367f, 0.01580357f, 
    0.36498499f, -0.10034541f, 0.07406106f, -0.29444504f, -0.09016776f, 0.05199594f, -0.01158755f, 0.07528450f, 
    0.02265392f, 0.09220082f, 0.09442293f, 0.05055994f, 0.19897237f, 0.08732634f, -0.11393666f, 0.20263094f, 
    -0.02354688f, 0.09956636f, 0.09131688f, -0.11408770f, -0.09275173f, 0.02968575f, 0.00107757f, 0.08797055f, 
    0.10151353f, 0.07287270f, 0.02356495f, 0.04535811f, -0.12272059f, -0.07575291f, 0.15676801f, 0.07347438f, 
    0.11720488f, 0.07338383f, -0.10583948f, -0.00075458f, 0.24509321f, 0.24771109f, -0.20657657f, -0.18363924f, 
    0.03350548f, -0.00237125f, 0.01585593f, -0.00902421f, 0.08881701f, 0.05066009f, -0.02297527f, 0.00058143f, 
    0.07786693f, 0.04751635f, 0.12865482f, 0.15733805f, -0.00302737f, 0.05007828f, -0.02778207f, 0.06643128f, 
    0.06797072f, 0.14314690f, 0.06051883f, 0.14043190f, 0.00532543f, -0.07039259f, 0.05806265f, -0.04323925f, 
    0.10373792f, 0.04435068f, 0.00155203f, -0.06066142f, -0.13924627f, -0.09705938f, -0.06822195f, 0.01920745f, 
    -0.01592608f, 0.16648756f, -0.02434333f, 0.01902339f, 0.00430178f, -0.05329775f, -0.00869148f, -0.04949197f, 
    0.07846802f, 0.00621239f, 0.02600314f, -0.03128384f, 0.18545710f, -0.03334755f, 0.02809086f, 0.11302841f, 
    0.02268876f, 0.02591036f, -0.05047913f, 0.04482292f, -0.01635229f, 0.05153513f, -0.02194298f, 0.07452288f, 
    0.20162363f, 0.00257127f, -0.02172897f, 0.04509991f, 0.17567880f, -0.00671375f, 0.01040998f, 0.00842041f, 
    0.10462833f, -0.05633240f, -0.07029211f, -0.04280042f, -0.04746532f, 0.11311799f, -0.24357784f, -0.16862531f, 
    0.05855475f, -0.01109113f, -0.08325209f, 0.00162645f, 0.01397465f, 0.06632257f, 0.03855655f, 0.01642687f, 
    0.15422459f, 0.04308578f, -0.03209272f, -0.20867205f, -0.12658386f, -0.05575458f, 0.03177278f, 0.00936462f, 
    -0.04712169f, 0.11590911f, 0.04822334f, -0.02274558f, -0.11821822f, 0.08727627f, -0.08772822f, 0.14525104f, 
    0.05364246f, -0.01396348f, 0.04507762f, -0.01751979f, -0.00020780f, 0.01362824f, 0.08058070f, 0.16682403f, 
    0.02853841f, -0.20211484f, 0.02193078f, 0.25888163f, -0.05354355f, 0.08525632f, -0.07501433f, 0.06836873f, 
    0.07327725f, -0.04620929f, -0.05099976f, 0.01605371f, 0.09329053f, 0.11149398f, 0.01385671f, 0.01264028f, 
    0.03532368f, -0.00773469f, -0.08012113f, -0.10040826f, 0.01360522f, -0.05676669f, 0.02197836f, -0.09905252f, 
    0.06794966f, -0.15294006f, -0.18918209f, 0.04363945f, -0.04633764f, -0.04203799f, 0.05862907f, -0.01273930f, 
    -0.00652296f, -0.04362115f, -0.01387240f, 0.00894358f, 0.20456052f, -0.04596414f, -0.17327416f, -0.02947339f, 
    0.00001485f, -0.12115388f, 0.01032089f, 0.02983239f, -0.04997322f, 0.02560775f, 0.09502093f, -0.01815315f, 
    -0.15578659f, 0.01563956f, 0.00773374f, -0.05568076f, 0.09256740f, -0.08435547f, 0.05303437f, 0.02005639f, 
    -0.02739205f, 0.11755740f, -0.05834371f, -0.00753605f, -0.02265047f, 0.09287259f, 0.11737911f, 0.00135324f, 
    -0.00383631f, 0.05656121f, 0.07528307f, -0.02591082f, 0.01006483f, 0.01205602f, -0.02327438f, 0.15916233f, 
    -0.03519752f, -0.11720087f, 0.05173536f, 0.17099883f, 0.02359945f, 0.03085219f, 0.06013250f, -0.01641645f, 
    0.03541847f, 0.01048872f, -0.06483836f, -0.09293529f, 0.22672231f, 0.08209082f, -0.01557127f, -0.03985098f, 
    0.01101571f, 0.04533984f, 0.08008637f, -0.04073755f, -0.15875562f, 0.02036130f, -0.05616827f, -0.00702353f, 
    0.31149188f, 0.17182302f, 0.02710264f, 0.11558149f, -0.03279234f, -0.00570948f, 0.04417175f, 0.06941240f, 
    -0.00184039f, 0.11847207f, 0.12607163f, 0.02695651f, -0.15664440f, -0.03337779f, -0.07178478f, -0.39252883f, 
    0.01965882f, 0.00724384f, -0.06965303f, -0.06776388f, 0.05298989f, -0.03767091f, -0.05758230f, 0.04006401f, 
    -0.47538510f, -0.09525283f, 0.17098545f, -0.09291098f, 0.03288142f, -0.09031587f, 0.05101794f, 0.15181018f, 
    0.01893038f, 0.00884047f, 0.01706142f, -0.05146973f, -0.02251193f, 0.10609937f, 0.00296539f, -0.07418371f, 
    0.11573958f, 0.01376296f, -0.00062472f, 0.10744727f, -0.03426209f, 0.00932149f, 0.05473997f, 0.00581765f, 
    -0.25434780f, 0.07656902f, -0.13660210f, -0.06615096f, 0.20236667f, 0.00199467f, -0.04119495f, -0.11653105f, 
    0.02197114f, 0.03989663f, -0.02140574f, -0.13025482f, 0.33474851f, 0.19089989f, -0.06250601f, 0.12972647f, 
    0.08894759f, -0.01844748f, 0.03836971f, 0.12561171f, -0.09387878f, -0.06320096f, -0.00240561f, -0.06224646f, 
    0.00649790f, -0.04108876f, -0.05502072f, -0.26834756f, 0.14039759f, -0.01085962f, 0.02303637f, -0.02914422f, 
    -0.01212619f, 0.00304007f, -0.04712442f, -0.01105036f, 0.30311570f, 0.10458157f, -0.01756725f, 0.01443961f, 
    0.03517142f, -0.03122414f, -0.11100963f, -0.03698497f, 0.02911946f, 0.03675963f, 0.00354007f, -0.03655739f, 
    -0.03943926f, 0.11217698f, -0.08476368f, -0.24829666f, -0.13562742f, 0.14722238f, -0.06759091f, 0.00842292f, 
    0.05336161f, 0.01851161f, -0.00369902f, 0.07959787f, 0.34439251f, 0.07231923f, -0.12296756f, 0.15843809f, 
    0.01145348f, 0.19893236f, 0.02578309f, -0.04839098f, 0.04082339f, 0.00130123f, -0.12424206f, 0.06252234f, 
    0.05311003f, 0.03429808f, 0.12371191f, 0.08378784f, 0.01816096f, -0.02022525f, 0.11168015f, -0.07952886f, 
    -0.00839648f, 0.05242500f, -0.06235556f, 0.05750873f, 0.04417589f, 0.29449460f, 0.03999195f, -0.04641507f, 
    0.09574372f, 0.03656368f, 0.04663625f, 0.00778110f, -0.10456841f, -0.00764940f, -0.00816814f, -0.04881779f, 
    -0.18359213f, -0.02899357f, -0.16185838f, -0.03926203f, 0.06920361f, 0.03494505f, 0.06249486f, -0.05424876f, 
    -0.04018144f, -0.01164499f, 0.04784956f, -0.13166037f, 0.14577742f, 0.22280140f, 0.02093951f, 0.08639096f, 
    -0.02854094f, 0.09018200f, -0.04594904f, -0.06048738f, -0.01710671f, 0.11854147f, 0.00415461f, 0.01166661f, 
    0.15219437f, -0.05801485f, 0.13442220f, 0.10261498f, 0.00271246f, 0.07636340f, 0.16672055f, -0.11879706f, 
    -0.12343354f, 0.06788753f, -0.04767321f, -0.08089250f, -0.23044239f, 0.02193828f, -0.00298038f, -0.00329518f, 
    0.03896511f, 0.01023850f, 0.03358496f, 0.07920685f, -0.10674484f, 0.01580606f, 0.13631779f, -0.02965558f, 
    0.00932507f, 0.07803747f, 0.07915001f, -0.34345311f, 0.18171307f, -0.06564046f, 0.02433365f, -0.03077916f, 
    -0.01978675f, -0.03067892f, 0.07267577f, 0.10904205f, 0.17583521f, 0.09379712f, 0.00463897f, 0.07920544f, 
    0.03793691f, 0.08269186f, -0.00632363f, 0.01523444f, -0.08596247f, 0.03041820f, 0.04707834f, -0.11670715f, 
    0.15214393f, -0.11985255f, 0.01109369f, 0.34116071f, 0.03386128f, 0.06765600f, 0.11138233f, -0.06497298f, 
    0.05463126f, 0.04041611f, 0.10260448f, 0.02141017f, -0.10983365f, 0.06209244f, 0.14373493f, -0.21938545f, 
    0.14072211f, -0.01439919f, -0.03053131f, 0.00545597f, 0.04128530f, -0.04561398f, 0.03100968f, 0.00266835f, 
    0.11768900f, 0.03208573f, -0.00771463f, -0.00075312f, 0.16988720f, 0.10977109f, 0.08461075f, 0.01266592f, 
    -0.02440051f, -0.00930358f, -0.18120939f, 0.04600495f, 0.00305089f, -0.04175304f, -0.07620282f, 0.25645247f, 
    0.12481278f, -0.05032561f, -0.09115101f, 0.01361425f, 0.06624182f, 0.09864046f, -0.04630142f, -0.08378647f, 
    0.12102468f, -0.04325096f, 0.11082698f, -0.04797677f, 0.00738664f, -0.02744291f, 0.05859166f, 0.03615201f, 
    -0.07473825f, 0.07683997f, 0.06611007f, 0.05318854f, 0.25922525f, 0.08990233f, -0.00743337f, 0.12346949f, 
    -0.07041548f, 0.01066044f, 0.09186182f, -0.04532262f, -0.04270531f, 0.01863092f, -0.03674810f, -0.17045540f, 
    0.24776889f, 0.33825043f, -0.05796363f, -0.12074342f, 0.07581202f, -0.01979978f, 0.04620542f, 0.06478264f, 
    0.07910972f, 0.06620093f, 0.07760774f, 0.12459355f, 0.03444382f, 0.01100114f, -0.05161608f, -0.15633574f, 
    -0.26578650f, 0.05762052f, 0.01723485f, 0.00093026f, 0.09924845f, 0.02184178f, 0.03384823f, 0.02930678f, 
    0.06828227f, -0.03818475f, -0.24115041f, -0.08774049f, -0.11703972f, 0.05025346f, 0.04280570f, -0.10922392f, 
    -0.02244504f, 0.03822877f, 0.02718506f, 0.05035362f, -0.23921643f, -0.20927025f, 0.03531969f, 0.00409030f, 
    0.04647189f, 0.05777999f, 0.01657643f, -0.02160883f, -0.02484672f, 0.01639528f, -0.03934580f, -0.08381265f, 
    0.13300809f, 0.01637411f, -0.11594662f, -0.03336672f, 0.02628278f, -0.02243388f, 0.07943650f, -0.08541897f, 
    0.02197016f, 0.01741922f, -0.02280156f, -0.04339468f, 0.08252987f, -0.08757615f, 0.01221586f, 0.03218160f, 
    -0.00445676f, 0.09940708f, 0.07056291f, 0.14154170f, 0.07707442f, -0.00685408f, 0.07098989f, -0.09401628f, 
    0.19443725f, -0.10872047f, 0.15781763f, -0.07171813f, 0.07017720f, -0.04736631f, -0.02599650f, -0.06631940f, 
    0.02435892f, -0.09831164f, 0.02305420f, -0.06531692f, -0.14575723f, -0.04781178f, -0.12075040f, -0.21809684f, 
    -0.04811839f, 0.05303127f, -0.02152731f, -0.07948426f, -0.05038020f, 0.10915563f, 0.08434081f, -0.07929178f, 
    0.06746983f, -0.00517899f, 0.03346147f, 0.06766316f, -0.12366111f, -0.00512134f, 0.04199326f, 0.01069729f, 
    0.01621174f, -0.00826112f, -0.09747604f, 0.05070931f, 0.20298892f, 0.00915049f, -0.27419883f, 0.00980747f, 
    0.03689671f, 0.01964396f, -0.00014643f, -0.04487122f, 0.02396742f, 0.05498856f, -0.01375900f, 0.05311835f, 
    0.05221844f, -0.20503271f, -0.19891776f, -0.08213508f, 0.01305067f, -0.04241043f, 0.09686094f, 0.20605956f, 
    0.03369603f, -0.03481471f, 0.08872519f, 0.05868995f, 0.16960844f, 0.33645678f, 0.11087266f, -0.00906671f, 
    0.08275034f, 0.12789844f, 0.03255975f, 0.06829610f, 0.02748582f, 0.08781478f, -0.00370045f, 0.06677368f, 
    0.15424789f, 0.20872013f, 0.02446465f, 0.00317857f, 0.07940164f, 0.03164500f, -0.00847435f, 0.02974424f, 
    0.00426280f, -0.06198198f, 0.10591709f, -0.05579063f, 0.07005139f, -0.13291126f, 0.13222532f, -0.13284470f, 
    -0.08130597f, 0.01078051f, 0.01677738f, 0.04867962f, 0.01011327f, 0.14048778f, 0.06387595f, 0.02618924f, 
    0.17342739f, -0.26345468f, -0.03532744f, -0.10773308f, -0.00873732f, -0.01631970f, -0.00710714f, 0.03302308f, 
    -0.01552803f, 0.08617074f, 0.09100501f, 0.02167806f, -0.00974988f, -0.10197814f, -0.05118808f, 0.16854480f, 
    -0.08950970f, -0.01528600f, 0.03120470f, 0.04527326f, 0.22127704f, 0.10546444f, 0.04659510f, -0.06751891f, 
    0.20028338f, -0.03528657f, 0.02351553f, 0.08149033f, -0.06928218f, 0.05653345f, 0.08306753f, 0.01499988f, 
    0.07333543f, 0.05786505f, -0.03738432f, 0.00650693f, 0.20713532f, -0.26174936f, -0.07230994f, -0.11821736f, 
    -0.03070585f, 0.02368055f, -0.04733067f, 0.10972244f, 0.04276257f, 0.03060791f, 0.01263467f, 0.26033187f, 
    0.20452194f, -0.01234508f, -0.00297916f, 0.21686822f, 0.06618404f, 0.05244033f, -0.03555058f, 0.02666870f, 
    0.05139643f, 0.01328882f, 0.00823557f, 0.01515997f, 0.31610242f, 0.21646552f, 0.05022254f, -0.24290952f, 
    0.04029899f, -0.05462593f, -0.01700365f, -0.07125008f, 0.12637462f, 0.07111283f, 0.06475934f, -0.04944050f, 
    -0.09607190f, 0.32676631f, -0.00649521f, 0.26553985f, 0.09371618f, -0.07533099f, -0.17938414f, 0.04388125f, 
    0.08039523f, 0.00468354f, -0.14592622f, 0.04901228f, -0.02869607f, -0.24289602f, -0.09338026f, -0.05976906f, 
    -0.01838993f, 0.03946930f, -0.02080178f, 0.05919531f, 0.08973505f, -0.01251179f, 0.03026484f, 0.02908449f, 
    0.14146832f, -0.04801391f, -0.18139711f, -0.00844816f, 0.01928315f, 0.02661823f, -0.03356938f, -0.02588904f, 
    -0.04394929f, 0.05826947f, 0.13238841f, 0.00367377f, -0.11900328f, 0.37364274f, 0.20778097f, 0.06664465f, 
    0.03976122f, 0.10320281f, 0.03484482f, 0.05787070f, 0.00472504f, 0.03057369f, 0.10377192f, -0.03849649f, 
    0.07928234f, 0.04471060f, 0.06144536f, 0.00924769f, 0.05359776f, 0.00227578f, 0.02854481f, -0.14640760f, 
    0.11648968f, -0.01923989f, 0.17813089f, -0.05982203f, -0.11195390f, 0.05943064f, 0.08963387f, 0.04987849f, 
    0.01310648f, 0.04338177f, -0.03521169f, 0.09090461f, 0.07203000f, -0.07807191f, -0.03110720f, -0.05426337f, 
    -0.17412430f, -0.19156915f, -0.12169652f, -0.14325039f, 0.02854511f, 0.10053872f, 0.04357424f, -0.08663525f, 
    0.02498967f, 0.02008983f, 0.00056585f, -0.04508142f, -0.09200889f, 0.05253016f, -0.04249229f, -0.14125010f, 
    -0.00669943f, 0.03196060f, -0.00591647f, -0.08917124f, 0.05517648f, -0.00343091f, 0.13896716f, -0.01153300f, 
    0.02093727f, 0.09443593f, -0.17775990f, -0.01902294f, 0.02908284f, -0.04705941f, -0.06411880f, 0.01175294f, 
    -0.08142698f, 0.06125428f, 0.07717983f, 0.03327490f, 0.13410182f, -0.14279862f, 0.07594457f, 0.00790605f, 
    0.00091856f, -0.03213669f, 0.09309749f, 0.00131696f, 0.02405439f, -0.01217247f, 0.08541290f, 0.15627947f, 
    -0.19371410f, 0.22302696f, 0.18489295f, 0.13691176f, 0.25848368f, 0.09698671f, 0.00807856f, -0.00869551f, 
    0.06964563f, 0.08793373f, 0.10563050f, 0.15137501f, -0.01715898f, -0.12272466f, 0.10831914f, 0.10223558f, 
    -0.07988530f, 0.06624524f, -0.02009296f, -0.06035079f, -0.07029641f, 0.09048345f, 0.06356031f, 0.00106053f, 
    -0.01383769f, 0.04119922f, 0.18244922f, 0.09057573f, -0.10358648f, 0.07372727f, 0.11841165f, 0.05451427f, 
    0.01941393f, -0.01062825f, 0.07402071f, -0.01258860f, -0.02116157f, 0.14160080f, -0.13196985f, -0.00795332f, 
    0.08124931f, 0.01609923f, 0.06806556f, -0.03869867f, -0.11531590f, 0.02919267f, -0.14399774f, -0.02003064f, 
    0.21772879f, 0.23342504f, -0.01239269f, -0.10422760f, 0.06163827f, -0.02428753f, -0.00288011f, -0.03856080f, 
    0.05194061f, 0.10326666f, 0.04312884f, 0.04149249f, -0.11250109f, -0.01451492f, 0.11421549f, 0.18700413f, 
    0.16986343f, -0.01266289f, -0.01672358f, 0.08196484f, -0.04285871f, 0.02173012f, -0.00645355f, -0.02727357f, 
    0.33009428f, 0.01520320f, -0.00948952f, 0.06349426f, -0.01670921f, 0.12132324f, 0.12001225f, 0.06868177f, 
    -0.01607383f, -0.16671665f, 0.09902627f, -0.02944014f, 0.43420497f, -0.23708859f, 0.12997863f, 0.16286598f, 
    0.15440616f, 0.02161036f, -0.03033402f, -0.02966483f, 0.07738205f, 0.03252514f, 0.13831076f, -0.07675033f, 
    0.16972198f, 0.00854378f, -0.13223308f, 0.01903476f, 0.04919999f, 0.09517423f, -0.07031617f, 0.05411697f, 
    -0.01355464f, -0.02627627f, 0.10584403f, 0.02145796f, 0.11540081f, -0.21343255f, 0.03260147f, -0.09627379f, 
    0.07006010f, 0.06541598f, 0.08620791f, 0.08475668f, 0.02644178f, -0.00291672f, -0.06869715f, -0.00677149f, 
    -0.17960842f, -0.04658275f, 0.08193790f, 0.08762553f, 0.19204742f, -0.04091187f, -0.00008245f, 0.01044537f, 
    0.06537033f, -0.02768080f, 0.10776959f, 0.01494256f, 0.09481879f, 0.06058874f, 0.15409860f, -0.17648090f, 
    0.04685769f, 0.08801014f, -0.03842766f, -0.01520818f, -0.00966671f, 0.04431415f, 0.06538869f, -0.00511872f, 
    0.46538016f, -0.12142359f, -0.09466313f, 0.12934573f, -0.08139575f, 0.11243750f, 0.01149645f, 0.01212749f, 
    -0.02056481f, -0.01148050f, 0.00581864f, 0.10335257f, 0.17612508f, -0.22356457f, 0.03780770f, -0.13158736f, 
    -0.01312644f, 0.08597008f, 0.03893887f, -0.03279961f, 0.04863545f, -0.02809932f, 0.05008219f, 0.05311390f, 
    0.24265456f, -0.23892030f, 0.13587362f, -0.01748681f, -0.11502646f, 0.00820062f, 0.17586848f, 0.09722548f, 
    0.14073962f, 0.07809576f, 0.15424207f, 0.05335464f, -0.01005806f, -0.11066677f, -0.13570392f, -0.26354861f, 
    -0.07311638f, 0.03044541f, 0.00302524f, -0.03285595f, -0.02040820f, 0.10113484f, -0.02381832f, -0.01354610f, 
    0.34575179f, 0.20212381f, 0.03242690f, -0.09204214f, 0.01640012f, -0.04277765f, -0.00902074f, 0.03239607f, 
    0.05898410f, 0.09109960f, 0.02932696f, 0.11819963f, -0.32786119f, 0.10280365f, 0.13934731f, -0.03479977f, 
    0.07134277f, 0.02396845f, 0.16912436f, 0.08661270f, 0.04605630f, 0.02489905f, 0.05447893f, -0.01368220f, 
    -0.08407426f, 0.18869504f, 0.20811571f, 0.12629703f, -0.00683584f, -0.03892810f, 0.11197846f, -0.04519954f, 
    0.12916870f, 0.03079469f, 0.06982742f, -0.14135787f, 0.00685032f, -0.06760567f, 0.06265232f, 0.01985583f, 
    0.05420218f, 0.01832808f, 0.11005927f, 0.07925651f, 0.03853334f, 0.07313178f, 0.14532782f, -0.07060715f, 
    -0.13676693f, 0.35239115f, -0.14727713f, 0.20298000f, 0.23541522f, 0.08603756f, -0.09601884f, 0.05372320f, 
    0.06497912f, 0.02616413f, 0.11345901f, 0.02764870f, -0.01525141f, 0.05717604f, -0.03541844f, -0.04624376f, 
    -0.00623003f, 0.09754089f, -0.06625877f, -0.05514577f, 0.05070318f, 0.08779833f, 0.09218601f, -0.01739598f, 
    -0.14612603f, 0.09142085f, 0.23776938f, -0.14710228f, 0.03983561f, 0.04623694f, 0.01963077f, 0.09634601f, 
    -0.02225552f, 0.04112129f, -0.05978393f, 0.16430953f, -0.16508114f, -0.02350054f, -0.16932940f, -0.22534516f, 
    -0.01558143f, -0.00228521f, 0.04531973f, 0.01933559f, 0.08743402f, -0.02198425f, 0.00617757f, -0.02779995f, 
    -0.35802531f, 0.15538098f, -0.19834313f, -0.09615881f, 0.12813112f, -0.04575293f, 0.03077358f, 0.11358365f, 
    0.06561065f, -0.02014269f, 0.03124266f, -0.02357761f, 0.27379659f, 0.06967029f, 0.08418825f, 0.01407348f, 
    -0.06506461f, 0.02510564f, 0.07191969f, 0.02560290f, 0.13161652f, 0.06081159f, -0.02567209f, 0.11833524f, 
    -0.07400251f, -0.20440473f, 0.00006786f, -0.00298225f, -0.01812571f, 0.07539233f, -0.02715260f, -0.08608198f, 
    0.00537636f, 0.02570979f, 0.08219267f, -0.05004073f, -0.03848531f, 0.08170566f, -0.00078921f, -0.10707812f, 
    0.05010882f, -0.06445862f, 0.12505876f, 0.05344614f, 0.08883703f, 0.04514199f, -0.07346481f, 0.01217203f, 
    0.04202112f, 0.04051279f, -0.21353012f, -0.07984101f, 0.05907326f, 0.09179344f, 0.08974088f, 0.00749576f, 
    0.09380929f, 0.03409733f, 0.02681412f, 0.07154718f, 0.19981778f, -0.18407419f, 0.00315313f, -0.05711661f, 
    -0.05880762f, -0.09567096f, -0.01539018f, 0.00119994f, -0.01239299f, 0.05004906f, 0.13936140f, 0.04741634f, 
    0.01014102f, 0.03135450f, 0.02552016f, -0.00558461f, 0.09460771f, -0.05768006f, 0.06819107f, -0.01836982f, 
    -0.01207953f, -0.12516630f, 0.13423219f, -0.02028045f, 0.19785140f, -0.03598318f, -0.07495760f, -0.19225726f, 
    0.00275438f, 0.00271625f, -0.01993967f, -0.05811332f, -0.01927239f, -0.06143893f, 0.00462095f, 0.08692586f, 
    -0.25781766f, 0.22178522f, -0.06799502f, 0.23732184f, 0.05830277f, 0.05926414f, -0.06757472f, 0.07654595f, 
    -0.02616519f, -0.01827899f, 0.07094253f, 0.02768674f, -0.19956848f, -0.04954981f, -0.17768900f, -0.10901482f, 
    0.02775917f, 0.00020148f, 0.06032592f, 0.06898289f, -0.02247236f, 0.03134540f, 0.01374361f, 0.04997693f, 
    -0.02045097f, 0.02723893f, 0.01653818f, 0.02010603f, 0.01358563f, -0.00319162f, 0.02014478f, 0.00290806f, 
    0.01890132f, 0.02581888f, 0.00783943f, -0.01943411f, 0.00883315f, 0.01778014f, -0.03803604f, -0.01104608f, 
    -0.01505364f, -0.03146558f, -0.01723946f, -0.01783320f, -0.00082060f, -0.01047671f, -0.02208749f, -0.01993310f, 
    -0.02367393f, -0.01860001f, 0.00498518f, -0.01327282f, 0.01058910f, -0.00654355f, -0.02875752f, -0.02105109f, 
    -0.02985912f, -0.03046412f, -0.00374338f, 0.02230783f, 0.01542396f, 0.00240682f, 0.00454526f, 0.01751748f, 
    -0.00915614f, -0.03583470f, -0.02599022f, 0.02650104f, 0.00385576f, -0.00445025f, -0.03295643f, -0.03244911f, 
    -0.01987475f, -0.02380236f, 0.00968645f, -0.02067639f, 0.01128164f, -0.03415261f, -0.02519345f, -0.01535542f, 
    -0.03126745f, 0.00856567f, 0.01301490f, -0.01170116f, 0.00168378f, -0.00325678f, -0.02971512f, -0.00731515f, 
    0.01929420f, 0.00975344f, -0.02643973f, 0.02478299f, -0.02604740f, -0.02045592f, -0.01021398f, -0.00434084f, 
    -0.00734547f, 0.01097495f, -0.03194058f, 0.00560686f, -0.00234170f, 0.02501032f, -0.00973442f, -0.02396736f, 
    0.02102494f, 0.01497953f, -0.01432221f, -0.01025454f, -0.03820475f, -0.00607017f, -0.03993566f, -0.02102171f, 
    0.00071500f, -0.01145412f, 0.01626497f, -0.03142206f, -0.00600322f, -0.02245850f, 0.01715109f, -0.00068867f, 
    -0.01906287f, 0.00490139f, -0.01844206f, 0.00109021f, -0.01588246f, -0.03495685f, 0.01070418f, -0.00871038f, 
    -0.03564554f, 0.00418258f, -0.01333666f, -0.01740798f, 0.02110642f, 0.02048884f, -0.02944044f, 0.01087502f, 
    -0.04120611f, 0.02443481f, 0.00194475f, 0.00479644f, -0.02301607f, 0.02675504f, -0.02288279f, 0.02368747f, 
    -0.01540827f, -0.02961846f, 0.01496300f, -0.01877831f, 0.01214535f, -0.02778453f, 0.02358276f, -0.03532592f, 
    -0.00012672f, -0.01339198f, -0.02247374f, 0.01261504f, -0.04322185f, -0.03731344f, -0.00464604f, -0.01427924f, 
    0.01871136f, 0.02433219f, 0.02731984f, -0.01101960f, 0.00005528f, -0.00346106f, -0.00676705f, -0.03689117f, 
    0.00707415f, 0.02836501f, 0.00759835f, -0.00904313f, -0.01010428f, -0.01365960f, -0.01528385f, 0.02000501f, 
    0.02204717f, 0.02731624f, -0.01904658f, 0.00762020f, 0.00829069f, 0.01948073f, 0.00160153f, -0.02729130f, 
    0.01117985f, 0.01121105f, -0.00806436f, 0.01910396f, 0.02059497f, 0.02745550f, -0.02680736f, -0.04213575f, 
    0.01740514f, 0.02932519f, 0.02691441f, 0.01937653f, 0.01191557f, -0.04287488f, -0.00449277f, 0.02185586f, 
    0.00015360f, -0.01698440f, -0.04270660f, -0.03308738f, 0.00951922f, -0.01155852f, 0.01314005f, -0.03430462f, 
    -0.04284693f, -0.02952765f, -0.00235697f, 0.01733167f, -0.01112972f, -0.00929863f, -0.01693300f, -0.01914746f, 
    0.02038279f, 0.01978080f, -0.02303656f, -0.04220836f, 0.00912602f, -0.03497634f, 0.00587706f, -0.02520811f, 
    -0.00699593f, -0.03104967f, 0.02199621f, 0.02079818f, -0.03766068f, -0.03142896f, -0.02873134f, 0.00528200f, 
    0.00644363f, -0.01135282f, -0.02825008f, 0.01886772f, -0.02949097f, -0.00882711f, -0.02647214f, -0.03907742f, 
    0.00056767f, -0.00235824f, 0.00985171f, 0.00538098f, -0.01897247f, -0.00497338f, -0.02699778f, 0.02389757f, 
    0.01266379f, -0.03951456f, -0.00452565f, -0.00862118f, 0.01483188f, 0.01430061f, -0.01245404f, -0.00910460f, 
    0.00983878f, 0.01397454f, 0.02704072f, 0.02544387f, -0.03319334f, 0.02306954f, -0.01284886f, -0.01666291f, 
    -0.00589923f, -0.00627287f, 0.01805895f, 0.02209640f, 0.01137994f, 0.02317549f, -0.02907810f, 0.00536034f, 
    -0.04291765f, 0.00473963f, -0.02744735f, 0.01310983f, -0.03412984f, 0.01381153f, -0.01423377f, -0.03893857f, 
    -0.00231545f, 0.01759150f, 0.00324555f, -0.01738174f, 0.01415651f, -0.04336321f, -0.00105288f, -0.02846162f, 
    -0.01945702f, -0.01006800f, -0.02320420f, -0.01962426f, 0.01110580f, -0.02278635f, -0.00303805f, -0.02210004f, 
    -0.01814739f, 0.01873072f, 0.02828810f, 0.03117834f, 0.00096136f, -0.03957712f, -0.02759028f, 0.00917840f, 
    -0.03764940f, -0.02042911f, -0.00007216f, 0.01118717f, -0.03950647f, -0.00616829f, -0.02376603f, 0.01028763f, 
    0.01978385f, 0.02604153f, 0.00921763f, -0.04383101f, 0.01140216f, -0.03058391f, 0.01706346f, 0.00115423f, 
    0.01487616f, 0.02589047f, -0.02178057f, 0.01008878f, -0.04351283f, -0.00076976f, -0.00611039f, 0.02460348f, 
    0.02746858f, -0.04436099f, 0.02261757f, 0.01713039f, 0.02509225f, 0.01512441f, -0.02849791f, -0.02408721f, 
    -0.03600707f, -0.01712232f, 0.01244347f, -0.01576108f, -0.03145752f, -0.01464989f, 0.02701938f, -0.04402573f, 
    -0.00734965f, -0.03172036f, 0.01089178f, 0.01011224f, 0.00046142f, -0.02129003f, 0.01629341f, -0.01827708f, 
    0.00456308f, 0.01011920f, -0.04012757f, 0.00479249f, -0.00192524f, -0.02760945f, 0.02367272f, 0.02117632f, 
    -0.02264400f, -0.00446158f, 0.00272796f, 0.00076995f, -0.02819841f, 0.01107212f, 0.01776652f, 0.01032062f, 
    -0.02453844f, -0.02273349f, 0.01572499f, 0.00424438f, -0.01434690f, -0.00229239f, 0.00968848f, -0.03984274f, 
    -0.03589747f, 0.01089813f, -0.03636334f, 0.00415005f, -0.00906766f, 0.00732053f, -0.01860657f, -0.00537123f, 
    -0.00192635f, -0.03898946f, -0.02764676f, -0.00078617f, -0.01254588f, -0.02889915f, -0.04111323f, -0.02193116f, 
    -0.04050922f, -0.04202329f, -0.00193177f, -0.03454674f, 0.00976996f, -0.00209934f, 0.00353385f, -0.02645708f, 
    0.00948673f, -0.03289208f, -0.02643988f, -0.01892605f, -0.01711336f, -0.02677248f, -0.02185041f, -0.02447237f, 
    -0.00232716f, -0.00510251f, -0.03893328f, -0.01714532f, -0.01884480f, 0.02223275f, -0.03682202f, 0.01776298f, 
    0.01353145f, -0.03140593f, -0.03594474f, -0.03035633f, -0.01301245f, 0.00086350f, 0.01287640f, 0.00639862f, 
    -0.03674731f, 0.02677079f, 0.01619229f, 0.01351935f, -0.03558960f, -0.00257195f, -0.04232576f, -0.02441598f, 
    -0.02627700f, 0.00016426f, 0.02757718f, -0.00460071f, 0.02508124f, -0.01768427f, 0.02091214f, -0.03796775f, 
    0.02083304f, 0.01645509f, -0.01262052f, 0.02510778f, -0.01025641f, -0.00769431f, -0.01651414f, -0.01681960f, 
    0.02466133f, -0.01821633f, -0.02730928f, -0.02576716f, -0.02141192f, 0.00763998f, -0.04201557f, -0.00859431f, 
    -0.03743167f, -0.02896227f, 0.01237370f, -0.01244188f, -0.01243215f, 0.00074322f, -0.01061691f, -0.01846647f, 
    0.02344757f, 0.02538903f, 0.00224194f, -0.00922955f, 0.00323641f, -0.00068202f, -0.00424686f, -0.03092488f, 
    0.02209644f, 0.02260228f, -0.02047843f, 0.01720997f, -0.02316274f, -0.04201354f, 0.01017150f, -0.01374365f, 
    -0.02384452f, -0.03071792f, 0.00045621f, 0.00361048f, -0.03955087f, -0.03318843f, 0.00484662f, -0.01617314f, 
    -0.01129959f, -0.02473960f, -0.00931892f, 0.01872545f, 0.00422978f, -0.03667849f, 0.02369585f, -0.01741950f, 
    -0.00786019f, -0.04170887f, 0.02377473f, 0.02298554f, -0.04049382f, -0.03571213f, -0.01998619f, -0.02373937f, 
    -0.04411288f, 0.00841457f, -0.03108609f, -0.03896553f, -0.03425147f, -0.03546417f, 0.00173809f, -0.02563846f, 
    -0.01354092f, -0.00215687f, -0.02919731f, 0.02258277f, -0.00830458f, 0.01991242f, -0.03414705f, -0.02189561f, 
    0.02062613f, -0.01605889f, 0.02386924f, -0.00497823f, -0.03685517f, -0.01210036f, 0.01449114f, -0.01503386f, 
    -0.02388046f, -0.00659251f, 0.01197339f, -0.00644304f, -0.02505787f, -0.01405768f, 0.00423497f, -0.04373461f, 
    0.02439592f, -0.02107547f, -0.04086795f, 0.01670986f, -0.01411424f, 0.02281042f, 0.00395207f, 0.02646822f, 
    -0.03458633f, -0.00496797f, -0.02713701f, 0.00563050f, -0.00196405f, -0.00952961f, 0.02489897f, -0.03564307f, 
    0.01587843f, -0.01332757f, -0.00624211f, -0.02691001f, 0.01143058f, -0.02476855f, -0.01035493f, -0.03802843f, 
    0.00350492f, -0.01637433f, -0.03113620f, -0.04338329f, 0.01253239f, 0.01101076f, -0.01860870f, -0.00247500f, 
    0.01006920f, -0.00095828f, 0.01502096f, 0.01760100f, 0.00354210f, 0.00048557f, -0.01622595f, 0.01281956f, 
    0.00982659f, 0.00196691f, -0.01122735f, 0.02521472f, -0.03498790f, -0.03458175f, -0.00844794f, 0.02255771f, 
    0.00611080f, -0.03421675f, -0.03367410f, -0.00513520f, 0.00196919f, -0.01426885f, -0.02633921f, -0.02988618f, 
    0.01616614f, -0.02411719f, 0.01104191f, -0.03316200f, -0.03194804f, 0.00706142f, -0.01533536f, 0.01361718f, 
    -0.02478098f, -0.04252463f, -0.00137721f, 0.01631563f, 0.02030694f, -0.03510908f, 0.02273268f, -0.02459203f, 
    -0.00747013f, 0.00059656f, 0.01744916f, -0.02273002f, -0.02169198f, -0.04271040f, -0.01479164f, -0.00579711f, 
    -0.02605624f, 0.02035187f, -0.01667853f, -0.01463053f, -0.04130141f, -0.02098698f, -0.03260536f, 0.02528748f, 
    0.02428870f, 0.01299522f, 0.01311537f, -0.00073479f, -0.03006320f, 0.00022527f, -0.03745931f, 0.00478573f, 
    -0.03266673f, 0.02605873f, -0.01765885f, -0.01941880f, -0.01039049f, -0.02242341f, 0.00326669f, -0.02681323f, 
    -0.02151125f, -0.02740289f, -0.00997565f, 0.00366574f, -0.02003023f, 0.02723522f, -0.02158342f, -0.01795340f, 
    0.01448058f, -0.01624982f, -0.03656582f, 0.00971826f, -0.03086809f, -0.03714947f, 0.01596087f, 0.01962809f, 
    -0.00025850f, -0.03361731f, -0.00066321f, -0.01158463f, -0.04053386f, -0.03030960f, 0.00680270f, -0.04140964f, 
    -0.03229012f, 0.00187422f, -0.04350638f, 0.02573159f, 0.00194081f, -0.01941779f, -0.03244461f, -0.01657756f, 
    -0.01069354f, -0.01858676f, 0.02127994f, -0.00708364f, 0.00400227f, -0.02567891f, 0.02741550f, -0.02276379f, 
    0.02126330f, 0.00938943f, 0.01143976f, 0.02934912f, -0.00955241f, -0.00058085f, -0.03904882f, -0.00279006f, 
    -0.02457987f, -0.02215247f, -0.00171175f, -0.00113016f, -0.02374332f, 0.01736166f, 0.00210839f, 0.00578002f, 
    -0.00067490f, 0.01668793f, -0.03057100f, -0.01777803f, -0.00864751f, -0.01681613f, 0.02237711f, 0.01467708f, 
    0.01516445f, -0.01654643f, 0.02517175f, -0.03599546f, 0.00826307f, -0.02869110f, -0.03702968f, 0.02658233f, 
    -0.03363766f, -0.01653814f, -0.00967700f, 0.02061748f, -0.01858672f, 0.00035337f, -0.02294300f, 0.02432831f, 
    0.00555530f, 0.01276415f, 0.00159560f, -0.02406366f, 0.02443194f, -0.03424695f, 0.02283138f, 0.01453964f, 
    0.02533113f, -0.04010043f, 0.00050369f, -0.01611858f, -0.03150785f, 0.00434980f, 0.01382709f, -0.00365889f, 
    -0.00544622f, -0.04110202f, -0.02861446f, -0.01935708f, -0.01551437f, 0.00273784f, 0.00595855f, -0.01160214f, 
    0.01265829f, 0.01398370f, 0.00417820f, 0.01420231f, 0.02185957f, -0.01546545f, 0.00886285f, -0.00771216f, 
    -0.02788301f, 0.00805175f, -0.02153783f, -0.03176066f, -0.01770272f, 0.00748084f, 0.01362622f, -0.02506300f, 
    0.01853260f, -0.04311287f, -0.00221667f, -0.02692811f, 0.02186147f, -0.00106260f, 0.02741470f, 0.01561059f, 
    -0.02848363f, -0.03175837f, 0.01071302f, -0.02041169f, 0.01898390f, -0.03362792f, 0.00175103f, 0.01753288f, 
    0.00579061f, -0.02206174f, 0.00796752f, -0.01706079f, -0.00187133f, -0.01620148f, -0.00123632f, -0.02645205f, 
    0.00658801f, -0.01552480f, -0.02862228f, -0.00544459f, 0.02092490f, 0.01273611f, 0.01109745f, -0.03246316f, 
    -0.03250930f, -0.20400652f, 0.11798293f, 0.18104383f, -0.11391950f, 0.00538427f, -0.00393731f, 0.06631187f, 
    -0.06593494f, 0.01288167f, 0.01773975f, -0.15479574f, 0.15313855f, -0.01481516f, 0.06458146f, -0.05790665f, 
    0.12877388f, -0.06951857f, 0.04612917f, 0.02555263f, -0.05356479f, 0.09573104f, -0.06852593f, 0.01716360f, 
    -0.02053280f, 0.03366011f, 0.27240595f, -0.07669840f, 0.09715839f, -0.02156951f, 0.02230662f, 0.08935636f, 
    -0.01152408f, -0.02471813f, -0.08769973f, 0.11389899f, 0.30864814f, -0.00570307f, -0.20147271f, 0.02343938f, 
    -0.03875549f, -0.12194800f, -0.03194385f, 0.24123856f, 0.14152555f, -0.00551419f, 0.10392319f, -0.02343003f, 
    0.01389158f, 0.06298454f, 0.18093869f, -0.02754132f, 0.01538086f, -0.06952827f, -0.05406577f, 0.03886321f, 
    -0.01382120f, 0.02154611f, -0.09180220f, -0.02619434f, 0.06725731f, 0.07612944f, -0.04354535f, -0.17763773f, 
    0.03037911f, -0.01352409f, -0.13850911f, -0.01686385f, -0.05072106f, -0.03291238f, 0.01404463f, 0.10093365f, 
    -0.21391405f, 0.02662198f, 0.08292986f, -0.05545840f, -0.00401544f, -0.01213856f, -0.00541707f, 0.06879390f, 
    0.00264410f, 0.01544865f, -0.05259695f, -0.05639300f, 0.17437990f, 0.10212427f, 0.03125628f, -0.13092451f, 
    0.00131755f, -0.00079578f, -0.04900622f, 0.01253959f, 0.03793566f, -0.05517440f, 0.01333247f, 0.06767076f, 
    0.01818725f, 0.02697823f, -0.02812788f, -0.00096133f, 0.07956529f, 0.00932934f, -0.05842841f, -0.03930865f, 
    0.00319782f, -0.02290485f, 0.00940550f, 0.01442843f, -0.07591344f, 0.06119542f, 0.24748529f, -0.07741443f, 
    -0.00619989f, 0.02689989f, 0.18058230f, 0.10027090f, -0.08460132f, -0.06656217f, -0.00476932f, -0.07475787f, 
    0.09454472f, 0.07137087f, 0.03698558f, -0.15620734f, 0.05459380f, 0.00760165f, 0.00172563f, -0.11256468f, 
    -0.06086846f, 0.12941499f, 0.10754427f, -0.02352264f, 0.09662609f, -0.19544698f, -0.04774309f, 0.03579698f, 
    -0.13777320f, -0.00309086f, -0.07043126f, 0.08420580f, 0.00543670f, -0.02317983f, 0.01668620f, -0.09158462f, 
    0.21626918f, 0.01106966f, 0.07900892f, 0.14348117f, -0.02873415f, 0.14047623f, 0.01846775f, 0.00905651f, 
    0.04837684f, -0.08159148f, -0.14585850f, 0.07182410f, 0.34148386f, -0.06455444f, -0.07955059f, 0.36304587f, 
    -0.03621289f, 0.01130275f, -0.02864191f, 0.01786134f, -0.05182006f, -0.00986456f, -0.04480653f, 0.01544159f, 
    0.21344489f, 0.31268868f, 0.22031662f, -0.04112506f, -0.05345883f, 0.20361960f, -0.03760624f, 0.09848477f, 
    0.06678126f, 0.01315509f, 0.07697072f, 0.08179745f, 0.02615224f, 0.14005500f, 0.01367773f, -0.20531693f, 
    0.12163839f, -0.03188121f, 0.07761732f, 0.04784344f, -0.13875270f, -0.02004960f, 0.00299778f, 0.12670368f, 
    0.02627295f, 0.06461172f, -0.09051786f, 0.23170590f, 0.10372102f, -0.07030363f, -0.11173741f, 0.06031726f, 
    -0.02885415f, -0.05935492f, 0.11509190f, 0.06510753f, -0.28111744f, 0.25126883f, 0.11114208f, 0.03374032f, 
    0.08978342f, 0.09239690f, 0.03052244f, -0.05101020f, -0.10775266f, 0.03427215f, -0.02198643f, -0.04922975f, 
    0.20914908f, 0.18285592f, 0.09807678f, -0.32657030f, -0.06056946f, -0.07090807f, 0.05429878f, -0.03377613f, 
    0.00872551f, -0.08332395f, -0.07146998f, -0.00378735f, 0.13390149f, -0.13303700f, 0.01290416f, 0.29571837f, 
    -0.08885123f, 0.01163918f, 0.09981707f, 0.02491063f, -0.06011624f, -0.00886954f, -0.05332502f, -0.04900442f, 
    0.12412865f, -0.12338722f, 0.03039295f, -0.16758943f, -0.03548210f, -0.08184271f, 0.18560691f, -0.11948726f, 
    0.03606831f, -0.08656243f, 0.09877346f, 0.01252330f, 0.09504300f, 0.09376685f, 0.10970066f, 0.03606820f, 
    -0.01463101f, -0.05217748f, 0.13276397f, 0.03774739f, -0.02642764f, 0.03011395f, 0.04195702f, 0.16456893f, 
    -0.11718415f, 0.04127862f, 0.25999957f, -0.14986295f, -0.03932605f, -0.01253377f, 0.05906978f, 0.05604571f, 
    -0.02320373f, 0.15601861f, 0.10197724f, 0.16866976f, 0.28406057f, -0.24909890f, -0.09408424f, -0.01629955f, 
    -0.06808370f, -0.02418920f, -0.03643485f, 0.00088565f, -0.06372686f, 0.12475547f, -0.09891347f, -0.08870617f, 
    -0.11740004f, 0.04960741f, 0.10651089f, 0.02094580f, -0.05384675f, 0.04477629f, -0.05901377f, 0.15773313f, 
    -0.06342738f, 0.09457246f, 0.00769474f, 0.11234460f, 0.15954354f, 0.09217216f, -0.05976466f, -0.07413658f, 
    -0.06349314f, -0.02783761f, -0.06399234f, -0.09815804f, -0.03117900f, -0.07918019f, -0.01276035f, -0.07139282f, 
    0.21725026f, -0.06459300f, -0.02631687f, -0.07749794f, -0.11159754f, -0.00680363f, -0.08351435f, 0.15616636f, 
    -0.02847952f, 0.00006022f, -0.00619629f, 0.05221736f, -0.03749828f, -0.04016432f, 0.03323117f, 0.11967965f, 
    -0.09994546f, 0.08654465f, 0.08926341f, 0.03283615f, -0.04824493f, -0.00913853f, 0.00431642f, 0.01019909f, 
    -0.14898317f, -0.04991117f, 0.20709831f, 0.00864308f, -0.14021273f, 0.08006787f, 0.04378230f, 0.05154804f, 
    0.06326331f, 0.01119259f, -0.02924371f, -0.13195315f, 0.10012241f, 0.02339786f, -0.00298365f, 0.20974319f, 
    -0.03572098f, -0.01301984f, -0.02317474f, 0.00779532f, -0.03986190f, 0.15764172f, -0.13470586f, 0.05566652f, 
    0.34996170f, -0.11986963f, -0.32200551f, -0.03616143f, -0.18498689f, -0.04671068f, -0.01150936f, 0.03796757f, 
    0.07338399f, 0.04792188f, 0.07887664f, -0.09589565f, 0.25247896f, 0.23814817f, -0.05304173f, -0.14355254f, 
    -0.01016861f, -0.03223366f, -0.05822347f, 0.04646753f, 0.02350749f, -0.07063771f, -0.07092913f, 0.01289375f, 
    -0.21815616f, 0.20102969f, 0.05507450f, -0.06816171f, 0.12882867f, -0.07637423f, 0.07750371f, 0.00901921f, 
    0.04424853f, 0.00179669f, 0.03852706f, -0.13414139f, 0.00362161f, -0.21643558f, 0.02678022f, 0.06634492f, 
    -0.11927770f, -0.09135783f, -0.08626593f, -0.01079168f, 0.10861408f, -0.14194597f, -0.08622908f, -0.05437171f, 
    0.18356796f, -0.11582338f, 0.08828801f, 0.01954547f, -0.11475157f, -0.04879638f, -0.09100878f, 0.02131740f, 
    -0.02441642f, -0.04876614f, -0.01753587f, -0.07479187f, 0.11887498f, -0.05112258f, 0.02756074f, -0.12032630f, 
    -0.12850735f, 0.02185875f, 0.09794956f, 0.00639190f, 0.06568461f, 0.11781276f, -0.15000416f, -0.02611437f, 
    -0.18186143f, -0.15748860f, 0.17721069f, 0.06949249f, 0.04565078f, -0.05762177f, -0.04376552f, -0.08684892f, 
    0.07460015f, 0.09766869f, -0.07683716f, -0.18333161f, -0.30306977f, 0.17809083f, 0.01662495f, -0.02884037f, 
    -0.05737986f, -0.01275299f, 0.01602211f, 0.07880924f, -0.00422988f, -0.02462134f, 0.05825435f, -0.10618478f, 
    0.21820952f, 0.05091639f, 0.06667184f, -0.14224613f, 0.02041821f, 0.07763004f, 0.05577401f, -0.03514110f, 
    0.00366619f, -0.04847347f, -0.12905428f, -0.01819280f, -0.07380969f, 0.22793175f, 0.01126845f, -0.01955749f, 
    -0.00362006f, 0.00120470f, -0.08092219f, 0.02270621f, 0.07607777f, -0.05344782f, 0.03629936f, 0.08670723f, 
    -0.06995468f, -0.16632687f, -0.01985350f, -0.01631480f, -0.17065944f, 0.16615056f, -0.03205220f, -0.11862099f, 
    -0.10809134f, -0.04824350f, 0.00398513f, 0.04404368f, 0.30592152f, -0.01068626f, -0.19811998f, 0.25596690f, 
    -0.08917829f, -0.06283373f, 0.13877825f, 0.03155938f, 0.12678596f, -0.05724445f, 0.04349437f, 0.06510630f, 
    0.37370920f, 0.15549205f, 0.07569284f, -0.14340478f, 0.05134351f, 0.07301043f, 0.06409790f, -0.01230440f, 
    0.00611616f, 0.02360586f, 0.04039460f, 0.01593055f, -0.14788947f, 0.26169232f, -0.01593014f, 0.08545793f, 
    0.05714963f, 0.01840042f, -0.01916921f, 0.16136217f, 0.08632617f, 0.05593138f, 0.00084405f, 0.00114350f, 
    0.00203457f, 0.13313654f, -0.12605733f, 0.01999169f, 0.01624596f, 0.01451898f, -0.09869592f, 0.06764832f, 
    -0.07953163f, 0.15093546f, -0.01911213f, 0.05296520f, -0.00383037f, 0.01014138f, 0.05922312f, -0.00967703f, 
    0.02953820f, 0.06178771f, 0.03547960f, 0.04299733f, 0.00313321f, -0.10424735f, 0.08931455f, 0.09093314f, 
    -0.04015559f, -0.16211179f, -0.04847456f, 0.21546063f, -0.05086076f, -0.02987560f, 0.11466348f, 0.01595603f, 
    0.03795124f, -0.01215208f, 0.01958775f, -0.05727902f, 0.28079367f, 0.11561262f, 0.10776932f, 0.06054990f, 
    0.10585666f, -0.06515105f, -0.06952862f, -0.15150419f, -0.01179520f, -0.01123404f, 0.05850739f, 0.08172242f, 
    0.02784781f, 0.17779645f, -0.15256581f, 0.08459134f, 0.06443959f, 0.03792258f, 0.04812480f, -0.04260708f, 
    -0.03908095f, 0.00755309f, 0.01688609f, 0.01796096f, -0.14524713f, 0.07014878f, 0.12670338f, -0.06122037f, 
    -0.04583012f, -0.01170690f, -0.15639740f, -0.01246903f, -0.00911285f, -0.00168765f, -0.11456586f, 0.10061163f, 
    0.03697411f, -0.27820203f, 0.00531558f, -0.33424789f, -0.17686352f, -0.03561661f, 0.07168677f, 0.08533084f, 
    -0.01286547f, 0.04442171f, -0.06738339f, -0.12442130f, 0.04173468f, -0.02269143f, -0.07108551f, 0.03532405f, 
    -0.04899032f, -0.13360775f, -0.05302154f, -0.01504019f, -0.01044172f, -0.03690531f, -0.14987165f, -0.05985598f, 
    0.37138334f, 0.00067884f, 0.09147290f, 0.10665956f, -0.03172866f, 0.05055517f, 0.03831760f, -0.14671019f, 
    0.12139704f, 0.01474108f, 0.13833563f, -0.09633511f, 0.12103942f, 0.06514786f, 0.02761314f, 0.08427547f, 
    -0.00285754f, -0.00750751f, 0.05077476f, 0.03180084f, -0.05595842f, 0.00819205f, 0.05370323f, -0.05023195f, 
    0.01329928f, -0.09445552f, 0.05679937f, 0.02907001f, 0.02515519f, -0.06153751f, -0.05415211f, -0.09424502f, 
    0.03964521f, 0.05319208f, -0.03689523f, 0.05753879f, -0.06047318f, 0.06726927f, -0.04454755f, 0.03241809f, 
    0.07229859f, 0.06708634f, 0.10180408f, 0.00178270f, 0.06616355f, 0.12461898f, -0.09801459f, -0.01957979f, 
    0.35593438f, 0.12006702f, -0.12090871f, 0.34154922f, 0.05376233f, -0.04976642f, -0.09995048f, 0.06777780f, 
    -0.10871020f, 0.04316351f, -0.10447134f, 0.12245294f, -0.15651341f, 0.02603558f, 0.03109187f, 0.03617476f, 
    -0.09987551f, -0.05765472f, 0.03978323f, -0.00232720f, 0.05722907f, 0.04047082f, -0.11974140f, -0.05799794f, 
    0.02327699f, -0.13254923f, 0.17500946f, -0.07878365f, -0.00421792f, -0.06745557f, -0.03237550f, 0.11564125f, 
    -0.09021512f, 0.01332564f, 0.01837110f, 0.07059877f, -0.05352525f, 0.08541687f, -0.18678243f, 0.21054384f, 
    -0.00736684f, 0.16717614f, -0.03610704f, 0.07641727f, -0.03006731f, 0.04026326f, 0.09878303f, 0.13387157f, 
    -0.07415474f, -0.06885394f, 0.00095182f, -0.04966253f, -0.11005460f, 0.06515340f, -0.06010205f, 0.00144944f, 
    0.01375087f, 0.00718773f, -0.04387794f, -0.00120940f, -0.00749842f, -0.07444690f, 0.09129619f, 0.00514864f, 
    -0.10450908f, -0.00928538f, 0.03296866f, 0.06646882f, -0.08208831f, -0.06277806f, -0.01427768f, -0.13760954f, 
    0.18219446f, -0.33612496f, -0.04240658f, -0.23769645f, -0.02472261f, 0.06459437f, 0.07031068f, -0.09667471f, 
    -0.00416870f, 0.03619622f, 0.09226820f, 0.02546294f, 0.02407382f, 0.10012390f, 0.05826731f, -0.05480899f, 
    0.04262413f, 0.13934495f, 0.07154229f, 0.12651186f, 0.01123205f, 0.15122323f, -0.03502778f, 0.03462462f, 
    0.00540886f, -0.01766796f, -0.01061872f, -0.01648502f, -0.00341487f, -0.02520700f, -0.03009996f, 0.01519778f, 
    -0.01950408f, -0.01326601f, -0.02896228f, -0.03586008f, -0.03411612f, 0.01643440f, 0.01600282f, -0.03224018f, 
    -0.03550578f, 0.00209524f, -0.00314350f, 0.01201895f, 0.02562236f, -0.00623384f, -0.03017639f, -0.00951732f, 
    0.03466549f, -0.03393001f, -0.00464348f, 0.03386317f, 0.00222346f, 0.02396672f, 0.02610943f, 0.00324929f, 
    -0.01775199f, -0.02886155f, -0.01869048f, 0.00001874f, -0.00539650f, 0.00292752f, 0.00659233f, 0.02369687f, 
    -0.02628417f, -0.01325748f, 0.00373757f, -0.01820807f, 0.00791954f, 0.01056839f, -0.03261404f, -0.01685287f, 
    -0.01961393f, 0.01882704f, -0.01572364f, -0.01075583f, -0.00684215f, -0.03291872f, -0.00208340f, -0.01946314f, 
    0.02070170f, 0.00614985f, -0.01558711f, 0.02416083f, 0.02354780f, 0.02856551f, -0.01989211f, -0.00926013f, 
    -0.02416953f, 0.00077073f, 0.03470854f, 0.01934490f, -0.00631814f, -0.00610925f, 0.00211648f, 0.01187823f, 
    -0.01908095f, -0.02544642f, 0.01264615f, 0.01144313f, -0.01652817f, 0.01907148f, -0.03308347f, 0.03577988f, 
    -0.00227917f, 0.01346912f, -0.00356752f, 0.02801975f, 0.01657091f, -0.03301719f, 0.02239812f, 0.00748101f, 
    0.00582048f, 0.01399903f, 0.00564254f, -0.03308282f, -0.03136174f, -0.02305211f, -0.01236793f, -0.00912736f, 
    -0.02065516f, 0.02467820f, -0.02183088f, 0.02687857f, -0.01571696f, 0.00864344f, -0.02620804f, -0.02350653f, 
    -0.01657254f, 0.00211885f, -0.01538068f, 0.00340867f, -0.03208084f, -0.00628892f, 0.00377049f, 0.00955229f, 
    -0.02791137f, -0.01871106f, -0.01313707f, -0.03045350f, -0.02702960f, 0.00670706f, 0.02106968f, 0.01122202f, 
    0.00203721f, 0.00245988f, 0.01880900f, -0.01771891f, 0.00560790f, 0.00553936f, 0.03464109f, 0.03321104f, 
    -0.00538807f, 0.00293148f, 0.02981752f, -0.00168396f, 0.01305991f, -0.01393211f, -0.00492684f, 0.01536098f, 
    0.03118898f, -0.01381976f, -0.01796999f, 0.00208891f, -0.01395110f, 0.01196152f, -0.02863595f, 0.01352730f, 
    -0.01027497f, -0.00669983f, 0.03295345f, 0.00798939f, 0.00715031f, -0.01366012f, 0.00013288f, 0.00648742f, 
    0.02079518f, -0.02304266f, 0.03462371f, 0.01151913f, -0.00273693f, -0.00692414f, -0.01918221f, 0.02999606f, 
    -0.02759272f, 0.00227067f, -0.02388265f, -0.00314993f, 0.00881056f, -0.00941869f, -0.03443448f, -0.03406017f, 
    -0.01329997f, -0.01115575f, 0.01145351f, -0.01551241f, 0.01021212f, -0.03374539f, -0.03348897f, -0.00074415f, 
    -0.00420586f, 0.02393771f, 0.03299008f, -0.00337649f, -0.02886687f, -0.03017333f, 0.02918403f, 0.01711340f, 
    -0.03007459f, -0.00947754f, -0.00408704f, -0.03348782f, 0.02728714f, -0.01715035f, -0.02956310f, 0.01469223f, 
    -0.00354750f, -0.01501910f, -0.00994914f, 0.02693594f, 0.01653852f, -0.01270086f, 0.01141589f, 0.01513230f, 
    -0.02029829f, 0.03306840f, 0.02104405f, 0.03491948f, 0.01902529f, -0.00669736f, 0.00762486f, -0.00308527f, 
    -0.01741995f, 0.02801469f, -0.03061867f, 0.01283197f, -0.01732515f, -0.03297523f, 0.01237638f, 0.02541675f, 
    -0.02873847f, -0.02357441f, -0.01529328f, 0.01667702f, -0.03433312f, 0.02533669f, -0.01699675f, 0.02172973f, 
    -0.01837838f, -0.01895782f, 0.01166145f, 0.01027133f, 0.01897899f, -0.03322182f, -0.02833986f, -0.01737508f, 
    0.01858740f, 0.00132495f, 0.00148629f, -0.02108667f, 0.02755204f, -0.02011980f, 0.01026792f, 0.03327958f, 
    -0.02310153f, -0.01315259f, -0.01116056f, 0.02057482f, -0.03092135f, 0.02212740f, -0.02307378f, -0.02446987f, 
    0.00224083f, -0.00834670f, -0.01397010f, -0.00384362f, -0.02406964f, -0.02528498f, -0.00768559f, -0.01157429f, 
    -0.02608174f, 0.00784253f, 0.01651762f, 0.03023740f, -0.02360008f, 0.02881838f, -0.01606988f, -0.02836049f, 
    -0.02882380f, -0.00702485f, -0.01220204f, 0.00967048f, -0.01064085f, 0.00035311f, -0.03322431f, 0.01322237f, 
    -0.02374577f, -0.00718560f, -0.03503964f, 0.01461821f, -0.00341895f, -0.00443350f, -0.02879700f, -0.02165988f, 
    0.00150238f, -0.03404235f, -0.02618578f, 0.00426963f, -0.00836175f, 0.01592535f, -0.00911923f, -0.02361341f, 
    0.01707436f, 0.02370641f, 0.02333407f, 0.01909637f, -0.03376960f, 0.02811523f, -0.01829137f, 0.02542478f, 
    0.02205189f, 0.02455758f, 0.03607748f, 0.01954971f, -0.01281880f, 0.03554982f, 0.02391174f, 0.00204377f, 
    0.00058520f, 0.01270160f, 0.03479110f, -0.03555859f, 0.03471284f, 0.00078403f, 0.02733899f, -0.00409098f, 
    0.01621925f, -0.01965077f, 0.00103391f, 0.02188755f, 0.03484062f, -0.01850860f, 0.03390921f, -0.01236844f, 
    -0.02927301f, 0.02047729f, 0.01576108f, 0.01677926f, 0.00665290f, 0.02107018f, -0.00920189f, 0.01914897f, 
    0.00650428f, -0.02115237f, -0.00523212f, 0.03606832f, -0.00111707f, -0.00627989f, -0.02044289f, -0.02994110f, 
    -0.00227281f, -0.02522145f, -0.00937800f, 0.02125138f, -0.00974529f, -0.00252250f, -0.01788080f, -0.00785389f, 
    -0.01930701f, -0.01001815f, 0.00386961f, 0.03563955f, -0.01561012f, -0.03366585f, 0.02687065f, 0.01208343f, 
    -0.00695770f, 0.00589274f, -0.02981455f, -0.03409340f, -0.01526171f, 0.03559630f, -0.02821729f, -0.03322129f, 
    -0.03135020f, -0.00994852f, -0.00168781f, 0.01721229f, 0.03362057f, 0.01963437f, 0.01155831f, 0.02661659f, 
    0.01844070f, -0.02055932f, 0.01805555f, 0.02078903f, 0.01670757f, -0.01941928f, -0.03607478f, -0.00009386f, 
    -0.00711767f, 0.02204284f, 0.02114852f, -0.01261385f, -0.00174314f, 0.00840736f, -0.02382349f, -0.03489219f, 
    -0.01331545f, 0.03088155f, -0.00221395f, 0.02449459f, -0.00967642f, 0.03568049f, 0.00644237f, -0.00592621f, 
    -0.03211643f, -0.02944798f, 0.01861839f, -0.00059578f, -0.01921977f, 0.02278846f, 0.00377769f, 0.02426912f, 
    -0.01856075f, 0.00474681f, -0.02742006f, 0.02018195f, 0.02682931f, 0.01302049f, -0.00086703f, 0.00308445f, 
    -0.01205706f, -0.00236148f, -0.00509992f, -0.01784883f, 0.01518800f, -0.01890133f, 0.01960758f, 0.01684483f, 
    -0.00848254f, 0.00752532f, -0.01583673f, 0.02269783f, 0.00918620f, -0.02658087f, -0.02876639f, -0.00541243f, 
    0.02319936f, -0.01627414f, 0.00178576f, 0.01091075f, -0.01124500f, 0.02792311f, -0.02626068f, -0.02784680f, 
    -0.01547764f, 0.03349668f, 0.02176045f, -0.02819771f, -0.01160598f, -0.02498073f, -0.01336302f, -0.03186283f, 
    0.03563705f, -0.01635958f, 0.02440035f, 0.02894240f, 0.03604363f, -0.01838614f, -0.00943130f, 0.00014791f, 
    -0.00903851f, 0.03260862f, 0.01934522f, 0.01216143f, -0.02890318f, -0.01717119f, -0.01854845f, -0.00955019f, 
    -0.01466925f, 0.02394758f, -0.03485741f, -0.02117219f, -0.01731476f, 0.01822067f, 0.02728495f, 0.01270563f, 
    -0.00953516f, 0.01708110f, -0.03600447f, -0.03044637f, 0.00301619f, -0.02988148f, 0.00922873f, -0.00735673f, 
    -0.00775890f, 0.01859680f, -0.00819681f, -0.00225168f, 0.01274767f, 0.00949205f, 0.00107434f, 0.01903846f, 
    -0.03235251f, -0.01227626f, 0.02186030f, 0.02582414f, -0.02848486f, 0.00740018f, -0.01889337f, 0.01019412f, 
    -0.02247893f, 0.01310925f, -0.03570437f, 0.00732733f, -0.02349652f, -0.00159156f, 0.02003221f, -0.00636891f, 
    -0.00969119f, 0.01949461f, 0.01225143f, -0.00313349f, -0.01554898f, 0.00351389f, -0.00449862f, 0.01415740f, 
    0.02378280f, -0.03555119f, -0.02559712f, -0.03395804f, -0.03288087f, -0.02954118f, -0.02654284f, -0.01283075f, 
    0.01553607f, -0.02453072f, 0.03054376f, -0.02768799f, 0.02974741f, 0.01132492f, 0.01771349f, 0.00133716f, 
    0.01220397f, 0.01872974f, -0.02987201f, 0.02502983f, 0.01165667f, -0.02165291f, 0.02041988f, -0.03338367f, 
    -0.01677039f, 0.01663999f, -0.00954902f, -0.02063089f, -0.03555978f, -0.01307568f, -0.02317226f, -0.01837969f, 
    0.00980619f, 0.03404452f, 0.00561415f, -0.02590774f, -0.03378309f, 0.01814746f, 0.02661105f, -0.00960122f, 
    0.01025746f, -0.01968580f, 0.00473980f, -0.02195123f, -0.00613117f, 0.01980529f, 0.02199620f, 0.00837505f, 
    0.01745374f, -0.01554269f, -0.01986816f, 0.01924306f, -0.02735837f, -0.02748482f, -0.00202880f, 0.01226973f, 
    -0.00998168f, -0.03114541f, -0.01573723f, -0.02962297f, -0.03024958f, -0.00707408f, -0.03412518f, 0.01895995f, 
    -0.00809759f, -0.02702551f, -0.00247891f, 0.00180661f, -0.01019097f, 0.01187673f, 0.01265868f, -0.01378227f, 
    0.02924744f, 0.00020405f, 0.02899263f, 0.03177426f, 0.03404371f, -0.02344016f, 0.02062522f, -0.00133122f, 
    0.02950182f, 0.01470102f, -0.02256807f, 0.00005202f, 0.03436663f, -0.00054748f, -0.02663602f, 0.01497941f, 
    0.00136192f, -0.00557428f, 0.02419636f, 0.01622099f, -0.00702031f, 0.03269426f, -0.03549459f, 0.00640237f, 
    0.00741444f, -0.01946494f, -0.03125856f, 0.02157782f, -0.01371244f, -0.01058631f, 0.03214793f, -0.03287790f, 
    -0.02178233f, -0.01918544f, 0.02351738f, 0.02669076f, -0.00385784f, 0.01614580f, -0.01442446f, -0.00202449f, 
    -0.01934638f, 0.00580416f, 0.00641055f, 0.02517042f, -0.03371162f, 0.00751271f, -0.00021175f, -0.01268303f, 
    0.01032944f, -0.00067365f, 0.00555009f, -0.00315320f, -0.02696328f, 0.00052871f, -0.03501406f, 0.03591875f, 
    0.01329078f, 0.03116920f, 0.03423940f, 0.02074587f, -0.01509191f, -0.02432949f, -0.00469756f, 0.00296752f, 
    -0.01633431f, -0.01282166f, -0.03490683f, -0.01988874f, 0.03259301f, -0.01576003f, 0.02182342f, 0.02282343f, 
    0.00666879f, 0.00516070f, 0.02834776f, -0.03115377f, -0.00922163f, 0.00958271f, -0.02896363f, -0.00943412f, 
    0.02068775f, -0.00329710f, -0.01400679f, -0.03231607f, -0.03573269f, -0.00628181f, 0.01719852f, -0.03322299f, 
    0.01301173f, -0.00835354f, -0.00286430f, 0.00970945f, 0.01062014f, -0.01534179f, 0.03562024f, 0.03188705f, 
    0.00860512f, 0.00072142f, -0.02403317f, -0.01632980f, -0.00687624f, 0.02078998f, 0.01686218f, 0.02316073f, 
    -0.00426941f, -0.02417240f, 0.02368739f, -0.01773328f, 0.03354422f, -0.03325584f, -0.02495563f, 0.02903458f, 
    0.00757083f, 0.03034882f, -0.03535360f, -0.01673877f, -0.01917473f, 0.00580651f, -0.03160227f, 0.01142493f, 
    -0.02323112f, -0.01543524f, -0.02004962f, -0.01429378f, 0.00291608f, 0.00985716f, -0.02304793f, -0.02463005f, 
    -0.03217909f, 0.00914699f, 0.00704216f, -0.03312379f, 0.02025856f, -0.01839133f, -0.00885896f, 0.01755368f, 
    0.02857701f, 0.00273365f, 0.02435577f, -0.02591115f, 0.00659395f, 0.01203601f, -0.02973741f, 0.01105628f, 
    0.01471487f, -0.02594277f, -0.00800886f, 0.00685093f, -0.00843655f, -0.00116858f, -0.00062704f, 0.01487666f, 
    -0.03536360f, 0.00072153f, -0.02453058f, -0.02955259f, 0.01052589f, 0.02668844f, 0.01579886f, 0.00644494f, 
    0.02482141f, -0.02875040f, 0.00907727f, 0.01545141f, 0.01137074f, 0.03001750f, 0.02849954f, -0.01927928f, 
    -0.00249593f, 0.02900061f, -0.00347821f, -0.01403589f, -0.00593633f, 0.02256341f, 0.00288872f, -0.01218052f, 
    0.02624736f, -0.01765863f, 0.00597559f, -0.01941138f, 0.02436556f, -0.02742841f, 0.01930406f, -0.00022500f, 
    0.01573909f, 0.00964000f, 0.01922282f, 0.02250243f, 0.00937517f, 0.00514742f, 0.02277652f, -0.03159886f, 
    -0.01520608f, 0.01337439f, -0.01780775f, -0.00964694f, 0.02944175f, 0.02743845f, -0.00404315f, 0.00707091f, 
    -0.02485294f, 0.01508075f, 0.02167533f, 0.00410481f, 0.01612978f, -0.02604140f, 0.01528881f, 0.00443138f, 
    -0.03912215f, -0.00903171f, -0.01768262f, 0.02587625f, -0.02153557f, 0.00070175f, -0.04122958f, -0.01862572f, 
    -0.01597266f, -0.00955565f, -0.02931939f, -0.03002127f, 0.02381407f, 0.03025335f, 0.00991453f, 0.00033457f, 
    -0.01592856f, -0.01959217f, 0.02264723f, -0.02560701f, -0.02458567f, -0.01588728f, 0.01978876f, 0.02316962f, 
    0.01565327f, -0.03461529f, -0.00952453f, 0.02009608f, -0.03063111f, -0.01707098f, 0.01133282f, 0.01891286f, 
    -0.03798955f, -0.01132110f, -0.01674999f, 0.00628485f, -0.03397848f, -0.00317037f, 0.02634843f, 0.02942931f, 
    -0.01507895f, 0.00394950f, 0.02479797f, 0.01785836f, -0.00268016f, -0.03395424f, 0.00082210f, -0.00333282f, 
    -0.01509358f, -0.02885994f, -0.02233206f, -0.03844218f, 0.02526871f, 0.02614080f, 0.02841432f, -0.03394572f, 
    -0.02736690f, 0.02241611f, 0.00436339f, -0.02581201f, -0.04102360f, 0.03168429f, 0.01511357f, 0.01257254f, 
    -0.01587946f, 0.02766861f, -0.00084308f, -0.02983168f, 0.00651797f, -0.03007795f, -0.02965796f, 0.01951739f, 
    -0.04175652f, 0.02031423f, 0.01980705f, 0.00203127f, 0.02510325f, 0.01661316f, -0.00116132f, -0.01399346f, 
    0.00969981f, 0.02523870f, -0.03852573f, 0.02280226f, 0.01295240f, 0.00702283f, -0.01819915f, -0.04321782f, 
    -0.02969435f, -0.02447268f, 0.00849272f, 0.01519064f, -0.04065361f, -0.01675189f, 0.01816420f, 0.00953189f, 
    0.02635092f, 0.00988140f, 0.00105646f, -0.00232363f, -0.00322973f, 0.01171666f, -0.02653498f, -0.01914897f, 
    -0.03595615f, 0.01531618f, 0.00102164f, 0.00820391f, -0.03950324f, 0.01184486f, 0.00281841f, 0.01200094f, 
    0.01305581f, -0.02329608f, 0.01431058f, -0.01532312f, -0.00032933f, 0.01446577f, -0.01222920f, -0.02289635f, 
    -0.02747575f, -0.03411428f, -0.00009542f, -0.01304882f, -0.00268252f, -0.01250711f, -0.03771460f, -0.00685849f, 
    -0.02769007f, -0.00026446f, 0.02064532f, -0.01018136f, -0.00741226f, -0.00346540f, -0.03579475f, -0.00207684f, 
    -0.02177760f, -0.03020758f, 0.00346315f, -0.02829432f, -0.02517117f, -0.00303305f, 0.02760093f, -0.02530968f, 
    -0.02134501f, -0.00053520f, -0.02367317f, -0.01483244f, -0.01047712f, 0.00731513f, -0.01020215f, -0.01247716f, 
    -0.01467636f, -0.00673855f, -0.03392420f, -0.03409314f, 0.01270084f, 0.01957231f, 0.02618978f, 0.00572288f, 
    0.02757365f, -0.03915751f, -0.01598069f, -0.01768091f, -0.03109325f, -0.01093611f, -0.03566942f, 0.02434901f, 
    -0.03343698f, -0.03789177f, 0.01850257f, 0.02009388f, -0.02275308f, -0.00004856f, 0.00706900f, -0.01177338f, 
    0.03011077f, -0.02743886f, 0.02753632f, -0.02713411f, 0.03079498f, -0.00145016f, -0.02674470f, -0.00037920f, 
    -0.00921703f, 0.02097848f, -0.00219121f, -0.04209884f, -0.00158181f, 0.02278272f, 0.00647808f, 0.01762863f, 
    -0.02728528f, -0.03412890f, 0.02332339f, -0.02348862f, -0.00481586f, -0.02060492f, 0.01098474f, -0.01335943f, 
    0.01451264f, 0.00690291f, 0.01126818f, -0.00552209f, 0.02693387f, -0.02319568f, -0.00683886f, 0.00610259f, 
    -0.02559897f, 0.00976952f, 0.02764997f, 0.02826208f, -0.02266922f, 0.00144700f, 0.01041481f, -0.03260669f, 
    -0.00532507f, 0.00758619f, -0.00323904f, 0.01666099f, -0.00260576f, -0.00716370f, -0.02979044f, -0.03417192f, 
    -0.02742176f, -0.00923236f, 0.02044872f, 0.01637281f, 0.02472130f, 0.02529030f, 0.02721383f, -0.01608030f, 
    0.02870053f, 0.00517603f, 0.02173564f, 0.00352005f, -0.03791519f, -0.00028004f, 0.02912750f, -0.01620164f, 
    0.02587703f, 0.02562442f, 0.02553391f, 0.00336685f, 0.00245748f, 0.02189418f, -0.03836568f, -0.01759117f, 
    -0.00317879f, -0.03112790f, -0.00115051f, -0.00073096f, 0.02271530f, -0.03988233f, 0.00205998f, 0.00380005f, 
    0.01021369f, 0.01786673f, 0.00210070f, -0.01420476f, -0.03007394f, -0.03519500f, 0.02175706f, -0.00821985f, 
    0.00420599f, 0.02284321f, -0.00805525f, -0.00527876f, 0.00983582f, -0.02234537f, 0.00648691f, -0.00995682f, 
    0.00035905f, -0.00400698f, 0.01590551f, -0.00683567f, 0.01169782f, 0.02575635f, 0.00997247f, -0.02334562f, 
    -0.00041437f, -0.03655118f, 0.00769276f, 0.02067847f, 0.02108996f, -0.02604232f, -0.00131331f, -0.02187208f, 
    -0.02668080f, 0.01313078f, -0.00644612f, 0.02783648f, -0.00897055f, 0.00907480f, 0.02382752f, 0.00182609f, 
    -0.02187249f, 0.02010490f, -0.01403822f, 0.00273401f, 0.01847399f, -0.02955201f, 0.02509183f, 0.02136199f, 
    -0.00537255f, -0.03350362f, -0.04007956f, -0.00237465f, 0.00111975f, 0.03038916f, -0.00386254f, -0.00661288f, 
    0.03242862f, 0.00704514f, -0.02773328f, -0.02551861f, -0.02770129f, 0.00006868f, 0.00464663f, -0.03561606f, 
    -0.02028706f, -0.00325937f, 0.02860046f, -0.02279565f, 0.03035486f, -0.00583258f, -0.00066444f, 0.00436077f, 
    -0.00917288f, -0.03221934f, -0.02797172f, -0.03141587f, -0.01690920f, 0.01157475f, 0.01449987f, 0.00083192f, 
    -0.02472027f, -0.00985449f, 0.00527845f, 0.01202107f, -0.03857685f, 0.02388909f, 0.00780711f, -0.01358678f, 
    -0.00921301f, -0.01582714f, -0.00550937f, 0.01825694f, 0.00334522f, 0.02128035f, -0.03840387f, 0.03049579f, 
    -0.03373634f, -0.01917818f, -0.02910242f, -0.02926961f, 0.02633692f, -0.01727314f, -0.00535770f, -0.01638409f, 
    -0.03296362f, -0.03086383f, 0.01394565f, 0.01575512f, -0.01323360f, -0.01481424f, 0.00642855f, 0.01268598f, 
    -0.01630471f, -0.02482832f, 0.02237048f, 0.02848934f, -0.02354187f, 0.00779430f, 0.01299218f, -0.03880787f, 
    -0.01355006f, -0.00266600f, -0.02095765f, 0.00442649f, -0.00332455f, -0.01990521f, -0.03410415f, 0.03057763f, 
    -0.02039942f, 0.01772097f, -0.00809215f, -0.02791605f, 0.00302212f, 0.00750047f, 0.01325248f, -0.02891608f, 
    -0.03549611f, -0.02897068f, -0.01590022f, 0.00781885f, 0.00035908f, -0.01765073f, 0.02662040f, 0.00760213f, 
    0.02935169f, 0.02142373f, -0.00832077f, 0.02971303f, 0.02290020f, -0.02965644f, -0.04163281f, -0.00251590f, 
    0.01349996f, 0.02268213f, -0.00202237f, -0.03792335f, -0.03599094f, -0.02053515f, -0.02624071f, -0.01353449f, 
    0.02602988f, -0.01096613f, 0.02418010f, -0.02657072f, 0.01569845f, -0.00599004f, -0.01665641f, -0.00387931f, 
    -0.01377208f, -0.00508410f, -0.02546372f, -0.01525084f, 0.00466616f, -0.03886413f, -0.02858169f, 0.01965654f, 
    0.02147943f, 0.01338152f, 0.02318831f, -0.01491443f, -0.02264090f, -0.01013311f, 0.00029817f, 0.02581521f, 
    -0.00399373f, -0.00657448f, -0.01278872f, 0.01583995f, 0.00725237f, -0.02416749f, 0.02666183f, -0.02823589f, 
    -0.01502184f, -0.03334717f, -0.04105681f, -0.03358171f, -0.03758726f, -0.03227556f, -0.02203843f, -0.01886543f, 
    -0.00407839f, 0.00938833f, 0.02955725f, -0.01597879f, -0.00913094f, 0.01879264f, 0.00945228f, 0.01070553f, 
    -0.02205377f, 0.02995035f, -0.00270254f, -0.03838861f, 0.02726964f, -0.04029290f, -0.03169493f, -0.02788115f, 
    -0.01437170f, -0.03334339f, 0.03011934f, -0.03965188f, -0.01232832f, -0.03559042f, -0.00733836f, 0.02794997f, 
    0.02250888f, -0.01560549f, 0.00408851f, -0.01806296f, -0.02730315f, -0.02928654f, 0.02253308f, -0.02758118f, 
    -0.03913586f, 0.02647495f, -0.02960171f, -0.03313379f, 0.03258549f, -0.03215676f, -0.02038004f, -0.02242078f, 
    0.02284804f, -0.03981474f, 0.00125151f, 0.00196252f, -0.04040977f, -0.00638952f, 0.02162127f, 0.01217949f, 
    0.02816566f, -0.01399208f, 0.01366705f, -0.01928956f, -0.01027826f, -0.00821749f, -0.03357077f, 0.01744280f, 
    0.02256947f, 0.00859762f, -0.02832531f, -0.00082924f, -0.02654869f, 0.00514194f, 0.00619540f, 0.00607895f, 
    -0.00162130f, -0.00585839f, 0.02738570f, -0.00523133f, -0.00516990f, -0.00692182f, -0.02569683f, 0.00837299f, 
    0.00650949f, -0.02183173f, -0.00975706f, 0.00635959f, -0.03754890f, -0.03450589f, -0.02855654f, 0.00915953f, 
    0.03403042f, -0.02382052f, -0.01157048f, 0.00159670f, 0.02615505f, -0.01530266f, 0.02433340f, 0.02833569f, 
    -0.03570398f, -0.02558385f, -0.01846532f, -0.00789308f, 0.02466639f, 0.02804392f, -0.00648793f, -0.03226688f, 
    -0.00244144f, 0.01796225f, -0.00457771f, 0.01329356f, -0.02387386f, -0.01239790f, -0.02965294f, -0.04030470f, 
    0.01333908f, -0.02411881f, 0.02885017f, -0.00902492f, -0.03046945f, -0.03094120f, -0.03423038f, -0.03221283f, 
    -0.02046911f, 0.01802648f, 0.02475676f, -0.01585183f, 0.02236676f, 0.02931006f, -0.02215248f, -0.01550274f, 
    -0.01545453f, -0.00052397f, -0.02440211f, -0.01874142f, 0.02294807f, -0.01054675f, -0.01126718f, -0.04043623f, 
    -0.03340493f, -0.04168118f, -0.00400094f, 0.00860346f, 0.00090898f, -0.00321083f, 0.00394405f, -0.03651896f, 
    0.01729145f, 0.02783502f, -0.01793810f, -0.00299384f, -0.01528836f, -0.01757123f, 0.02640183f, 0.00151561f, 
    -0.02721344f, -0.00948369f, -0.02090324f, 0.01437030f, 0.00553097f, -0.01380099f, -0.02431139f, 0.01397488f, 
    0.01623457f, 0.01472216f, -0.00499589f, -0.00959704f, -0.03519833f, 0.02530151f, 0.02975603f, -0.03142063f, 
    -0.00172942f, 0.01847353f, -0.02941935f, -0.02295462f, -0.01598920f, 0.01592006f, 0.00016336f, 0.01358542f, 
    0.01555205f, 0.01790757f, -0.01558766f, -0.03093902f, -0.03081774f, -0.01626277f, -0.03828218f, -0.00979338f, 
    -0.01016783f, 0.01949204f, -0.02044198f, 0.02453616f, 0.02495351f, -0.02732597f, 0.00209366f, -0.04366002f, 
    0.01953176f, 0.02713009f, -0.03366042f, 0.00146257f, 0.02283557f, -0.03695240f, -0.00201288f, 0.00131931f, 
    -0.03837684f, 0.02266282f, 0.00058569f, -0.03093646f, 0.02644907f, 0.00241359f, -0.03073784f, -0.03200230f, 
    0.01444538f, -0.00410963f, -0.01476888f, 0.00149116f, 0.01994678f, -0.00478777f, 0.00855434f, -0.03513180f, 
    0.01038925f, 0.02728768f, -0.01033288f, -0.01821332f, 0.00105321f, 0.02327705f, -0.01537293f, -0.01880533f, 
    0.00743533f, -0.01902892f, 0.01990174f, -0.00467957f, -0.00042247f, 0.01310290f, 0.02795331f, -0.03597234f, 
    -0.01775002f, 0.01836328f, -0.00511598f, -0.00193209f, 0.00033700f, -0.00703222f, 0.00262915f, -0.00317375f, 
    -0.00043220f, -0.03846714f, -0.01288377f, -0.02499224f, -0.00088714f, 0.00613486f, 0.00451145f, 0.01419727f, 
    -0.04200176f, -0.00490622f, -0.02814233f, -0.01602121f, 0.00193810f, 0.00513887f, 0.02530770f, -0.03502883f, 
    0.01209012f, -0.01442711f, 0.00579597f, -0.01223902f, 0.02702928f, -0.02687235f, 0.01184206f, -0.02338424f, 
    0.02664847f, 0.00895808f, -0.02070319f, -0.01649402f, 0.02241508f, -0.03729589f, -0.02820791f, 0.02323437f, 
    -0.03329808f, -0.01320492f, 0.01222942f, -0.00295400f, -0.00468068f, -0.02393770f, 0.00299683f, 0.02233680f, 
    -0.01332710f, -0.02317058f, -0.03736965f, -0.00934977f, 0.02713842f, -0.03139595f, 0.00470737f, -0.02415787f, 
    -0.01023992f, -0.01166280f, -0.02659590f, -0.00746053f, -0.02776084f, -0.02172063f, 0.01601393f, -0.04125399f, 
    -0.01099321f, 0.02849245f, -0.01761600f, 0.02527948f, -0.00752569f, -0.02741551f, -0.04191957f, -0.02345595f, 
    0.02786456f, 0.00461888f, 0.01705639f, -0.02128285f, -0.00991273f, -0.00351690f, 0.01715110f, 0.01399552f, 
    0.02419314f, 0.02088746f, 0.00371466f, -0.01039539f, 0.02423646f, -0.02354763f, 0.00834254f, 0.01135161f, 
    -0.03265824f, 0.00985513f, -0.00659152f, -0.02203498f, -0.04025173f, -0.01351393f, 0.02771504f, -0.00515306f, 
    -0.01507355f, -0.02373539f, 0.01962186f, 0.01080796f, -0.02688494f, 0.02461675f, -0.01807158f, -0.03556495f, 
    -0.01811412f, 0.00739205f, 0.00333262f, 0.00658248f, 0.02486590f, -0.00112206f, 0.02040785f, 0.00306795f, 
    -0.02901940f, -0.03747284f, -0.03181954f, -0.01852022f, -0.00506837f, 0.02564493f, -0.01163464f, 0.01670333f, 
    -0.02619708f, -0.04097281f, 0.02423571f, 0.00076410f, 0.00465434f, -0.04158204f, -0.04155806f, -0.02508193f, 
    0.01119101f, -0.02413630f, 0.00044906f, -0.00243291f, -0.00828975f, -0.03889982f, 0.02803878f, 0.00527352f, 
    -0.02194005f, 0.00465530f, -0.00459169f, 0.01208124f, 0.00935917f, -0.01191227f, 0.02941258f, -0.02486352f, 
    -0.03987765f, 0.00943560f, 0.02342192f, -0.02938054f, -0.03014620f, -0.00119763f, 0.01971277f, -0.03260633f, 
    -0.01519175f, 0.01946400f, -0.03387594f, 0.01824268f, -0.00756858f, -0.02697140f, -0.03975733f, 0.01873163f, 
    -0.00485825f, -0.01391903f, -0.00122744f, -0.02386135f, -0.02829782f, 0.01738649f, 0.01092936f, -0.01330717f, 
    0.01818255f, 0.02915383f, -0.03617373f, 0.01974528f, -0.03723671f, -0.00237528f, 0.00268391f, 0.00270552f, 
    0.02046926f, -0.00972232f, -0.01926172f, -0.03288912f, -0.02216135f, 0.00620800f, 0.00281113f, -0.03538344f, 
    0.00701282f, -0.02571884f, 0.02006658f, 0.00306746f, -0.02871235f, 0.01548078f, -0.01653007f, 0.00992162f, 
    -0.02280004f, 0.02827601f, -0.00470827f, -0.03939436f, -0.03853429f, -0.01622856f, -0.00133432f, -0.03711935f, 
    -0.01890459f, -0.03592188f, 0.02088150f, -0.01740187f, -0.04069617f, -0.02360450f, -0.03539416f, 0.01415442f, 
    -0.02131210f, -0.03747347f, 0.02585299f, -0.02135876f, 0.02910058f, -0.00308422f, -0.00582113f, -0.03401812f, 
    -0.03046453f, -0.03023984f, 0.01689868f, -0.01676444f, 0.02146736f, 0.02293170f, -0.02698500f, -0.00587130f, 
    -0.01139468f, 0.00433494f, 0.00770421f, 0.01978393f, -0.02926461f, 0.00691445f, 0.01448417f, -0.00978486f, 
    -0.03696988f, -0.01350993f, -0.03061952f, 0.01617527f, 0.01143327f, -0.00335225f, -0.01488945f, 0.02303356f, 
    -0.00636753f, 0.04198925f, -0.02240605f, -0.03327509f, 0.02858588f, -0.02145581f, -0.01157863f, 0.01267313f, 
    -0.01324888f, -0.00967144f, -0.03074215f, -0.02334870f, 0.01270791f, -0.03550762f, -0.00341643f, -0.01799699f, 
    -0.03350991f, -0.00268755f, -0.01015140f, -0.03835059f, -0.02318171f, 0.01321681f, -0.00902546f, -0.00218176f, 
    -0.02715601f, -0.01918836f, 0.00362293f, 0.00555622f, 0.02939542f, -0.00433954f, -0.04067680f, -0.04098578f, 
    0.00647681f, -0.03800516f, -0.01426744f, 0.02334710f, -0.00511086f, 0.02732468f, -0.02864377f, -0.00612150f, 
    -0.03007314f, 0.01483043f, -0.02154156f, 0.02184409f, -0.02582944f, -0.03436162f, 0.02299012f, 0.02872113f, 
    0.01587977f, -0.00633618f, 0.02826919f, -0.02790472f, -0.01793089f, -0.01406210f, -0.00532817f, -0.02753972f, 
    -0.03561786f, -0.00363826f, -0.03786173f, -0.00010408f, -0.00504614f, -0.03087623f, -0.03174785f, 0.00143886f, 
    -0.00710026f, -0.00018048f, -0.01025227f, -0.01905866f, 0.02543273f, -0.01742388f, -0.03447514f, -0.02955538f, 
    0.01832614f, -0.02665382f, 0.02946411f, -0.03413610f, -0.02436051f, -0.03119602f, 0.00127069f, -0.03109736f, 
    0.00415420f, -0.01032988f, 0.01934102f, -0.02491708f, -0.02976523f, 0.02754090f, -0.03312831f, -0.03312840f, 
    -0.04026791f, 0.01034193f, 0.01451812f, 0.02618357f, -0.01428608f, 0.01860109f, -0.03434185f, -0.01134381f, 
    -0.04189423f, -0.00356958f, 0.00410123f, 0.04033399f, -0.02851718f, -0.02939572f, -0.02661120f, -0.00400544f, 
    -0.01971702f, 0.01517273f, 0.02821159f, -0.02276695f, 0.01475885f, -0.03614550f, 0.02471827f, -0.03948306f, 
    -0.00182966f, -0.01729084f, 0.01289080f, -0.01348247f, -0.00331253f, 0.01027631f, 0.01926135f, -0.03594629f, 
    -0.01587767f, 0.01151162f, 0.01430123f, 0.00344275f, 0.02693340f, -0.01368850f, 0.02347688f, 0.02153037f, 
    -0.00172016f, 0.02897849f, -0.00524928f, -0.01440510f, -0.03917459f, -0.03516922f, 0.02044153f, -0.03714862f, 
    0.00943926f, 0.01459289f, 0.02148823f, -0.01354176f, 0.00315786f, -0.01815901f, 0.02405102f, 0.02104848f, 
    -0.01488180f, -0.00435825f, -0.01727027f, -0.03416775f, -0.00980150f, 0.00724848f, -0.01993829f, -0.02515430f, 
    0.02610230f, 0.02383455f, -0.03492482f, -0.00940957f, -0.03657001f, 0.02186180f, -0.02642567f, 0.00690934f, 
    -0.02734868f, -0.02989379f, 0.01173886f, -0.00462679f, -0.03627081f, -0.00824599f, 0.00356362f, -0.03970619f, 
    0.02007644f, -0.01544014f, -0.03689275f, 0.01183860f, 0.00357198f, -0.01756251f, 0.01539553f, -0.01734744f, 
    -0.03102895f, -0.01821312f, 0.00972977f, 0.02280549f, -0.03570142f, -0.00554982f, -0.01470707f, 0.02142556f, 
    -0.04162060f, -0.00876301f, -0.00662543f, 0.00147010f, -0.02616296f, 0.02108586f, -0.02725450f, 0.02716994f, 
    -0.01601162f, 0.01165070f, -0.00386096f, 0.03805983f, 0.01860272f, -0.02582546f, 0.02837933f, 0.00229695f, 
    -0.01628908f, -0.02268677f, -0.02836879f, 0.02071199f, -0.01236945f, -0.00234842f, -0.01038329f, 0.00901369f, 
    0.02066113f, -0.00193740f, 0.00020980f, 0.01863565f, 0.01527363f, -0.01686217f, -0.03268569f, -0.00999419f, 
    -0.02402594f, -0.03986621f, -0.00371587f, -0.00095778f, -0.02287140f, -0.02764606f, -0.03283596f, 0.00952694f, 
    0.02464202f, 0.01207646f, -0.03708567f, -0.00382031f, -0.00836975f, -0.02003643f, -0.03271482f, 0.02931909f, 
    0.00966911f, -0.00129543f, -0.00688555f, 0.02504740f, -0.03939473f, 0.01906789f, -0.00446499f, -0.01087915f, 
    -0.03696809f, 0.02447220f, -0.01112052f, -0.02800358f, 0.00611561f, 0.02283582f, -0.04237821f, 0.01620454f, 
    -0.01658372f, -0.02053026f, -0.02318084f, -0.03176071f, 0.01781910f, -0.03723991f, -0.00844945f, -0.02468507f, 
    0.00637136f, 0.00161779f, 0.02432736f, -0.02212825f, 0.01018461f, 0.01191171f, -0.00083493f, -0.02916720f, 
    -0.00530286f, -0.00545620f, -0.00737857f, -0.02093295f, -0.01678908f, -0.02337090f, -0.04067101f, -0.02091856f, 
    -0.02682626f, 0.00555297f, -0.01529001f, -0.01978422f, -0.00675301f, 0.00272693f, -0.01702719f, 0.01231962f, 
    -0.02732885f, -0.03251382f, 0.01276875f, -0.01284066f, 0.00212636f, -0.00130418f, -0.03228144f, 0.01923681f, 
    -0.01957488f, 0.01392564f, -0.02757873f, 0.02803350f, 0.01308512f, 0.00446292f, -0.01172683f, -0.00355395f, 
    0.00669971f, 0.00106727f, -0.04292814f, 0.00812967f, -0.01383780f, -0.03743064f, 0.00941618f, -0.03761137f, 
    -0.01154240f, -0.00619333f, -0.03109807f, -0.02109881f, -0.00709337f, 0.02759977f, 0.02750878f, -0.03108024f, 
    -0.04250625f, -0.02719590f, -0.00550486f, -0.01192935f, 0.00910503f, 0.00762328f, -0.00914224f, 0.02447363f, 
    0.01191140f, -0.02247395f, 0.02032345f, 0.00898805f, 0.00750131f, -0.03176486f, -0.01537941f, -0.00810812f, 
    0.01968768f, -0.00437473f, -0.01756340f, -0.00026118f, -0.01749847f, -0.03964081f, -0.03233083f, -0.01831801f, 
    -0.02858404f, -0.00249117f, 0.02456764f, -0.01929041f, -0.00869645f, -0.00758831f, -0.02603260f, -0.01725416f, 
    -0.03933816f, -0.00330813f, -0.03555299f, 0.02518341f, 0.02676669f, 0.00269238f, 0.00407885f, -0.00971038f, 
    0.01874672f, 0.01247389f, -0.00086429f, 0.00216871f, 0.02636130f, 0.00350785f, -0.02020660f, 0.02395030f, 
    -0.02756931f, -0.01576622f, 0.02021826f, 0.02399718f, 0.01969339f, -0.01572741f, 0.01449973f, -0.01927137f, 
    -0.02098636f, 0.01067630f, -0.01786724f, -0.01911035f, -0.00092123f, -0.00981578f, 0.02689818f, 0.02174482f, 
    0.00057750f, -0.03328725f, 0.01246241f, 0.02420218f, -0.03093501f, -0.03831230f, -0.00697541f, 0.00548238f, 
    -0.03159076f, 0.02708650f, 0.02181323f, 0.00390274f, 0.00677504f, -0.00370632f, 0.00210668f, 0.00580869f, 
    0.00294988f, -0.01969296f, 0.01165194f, -0.00870880f, -0.04301962f, -0.00191298f, -0.04240158f, -0.01523433f, 
    0.01753867f, 0.00469208f, -0.00578779f, -0.00515643f, 0.02485119f, -0.02461011f, -0.01540384f, -0.00418324f, 
    -0.01667280f, 0.02115988f, 0.01073028f, -0.02318045f, -0.01656307f, -0.03825054f, -0.03543564f, -0.00985697f, 
    0.00317093f, -0.01118708f, -0.01623812f, 0.01140539f, 0.00031033f, -0.02797008f, -0.00948330f, -0.01357216f, 
    0.01748166f, -0.00211214f, -0.02291857f, -0.01478882f, -0.02574882f, 0.02215100f, 0.02531706f, 0.01823785f, 
    -0.02421476f, 0.00047495f, -0.02763738f, -0.02829439f, -0.01089021f, -0.01876453f, 0.02817533f, 0.00026236f, 
    0.01729655f, -0.00270813f, 0.00987110f, -0.01098319f, -0.02167624f, -0.01016762f, -0.00768405f, -0.04084796f, 
    0.02551211f, -0.00063039f, 0.02695189f, 0.02835912f, 0.00436461f, -0.03742569f, -0.00742164f, 0.02498575f, 
    -0.02623574f, -0.01896561f, 0.02020977f, 0.02129386f, -0.02770574f, 0.00115762f, -0.02383387f, -0.01457489f, 
    -0.01758664f, -0.00863178f, 0.01134064f, -0.02532464f, 0.02342133f, -0.02427106f, 0.00260949f, 0.00124164f, 
    0.02262381f, -0.04195121f, -0.02586493f, -0.00332697f, -0.03945986f, 0.02163226f, 0.02739372f, -0.01255588f, 
    -0.00737959f, 0.02339021f, -0.03395744f, 0.00376081f, -0.01976307f, -0.03431947f, 0.01392131f, 0.00969798f, 
    0.02029574f, 0.02271879f, -0.02976228f, 0.02646941f, -0.04119759f, 0.01689559f, -0.00172793f, 0.00427992f, 
    0.00641625f, 0.00764057f, -0.03314338f, -0.01194995f, 0.01777680f, 0.01169977f, 0.02222097f, -0.00899849f, 
    0.01396609f, 0.01698625f, -0.03650757f, 0.02936600f, 0.01784071f, -0.03906254f, -0.02066256f, 0.00258110f, 
    -0.03109687f, -0.02706928f, -0.00129420f, -0.03928497f, 0.02239088f, 0.01483807f, 0.00104445f, -0.04264395f, 
    -0.00417521f, 0.00754368f, -0.03357253f, -0.01470604f, -0.03744478f, 0.01499698f, 0.00423864f, -0.00668610f, 
    -0.01252245f, 0.00196837f, 0.02857099f, -0.00184814f, 0.02747594f, -0.00738979f, 0.01562454f, 0.01571791f, 
    -0.02477619f, 0.01467544f, 0.00645000f, -0.02169751f, -0.03867440f, 0.00512355f, 0.00220248f, -0.03575850f, 
    -0.01077858f, 0.00906959f, -0.00407457f, 0.02054543f, -0.00396406f, -0.00374794f, 0.01760475f, 0.01969002f, 
    0.00254517f, -0.03364194f, -0.02728078f, -0.02832655f, -0.02554257f, 0.00563923f, -0.02219765f, 0.02707564f, 
    0.01141050f, -0.01212070f, 0.01237882f, 0.02155661f, -0.02232671f, -0.00913933f, -0.02362770f, -0.03628923f, 
    -0.01755730f, -0.00621403f, 0.00210674f, -0.00637273f, 0.02561649f, 0.02712036f, -0.00712049f, -0.01395803f, 
    0.00475191f, 0.01254675f, 0.01755019f, -0.03257375f, 0.02087798f, 0.02698915f, -0.00234211f, 0.02299967f, 
    -0.00602932f, 0.00428345f, -0.03378865f, 0.00698086f, -0.02974748f, -0.00043120f, 0.01740396f, -0.02791985f, 
    -0.04174985f, 0.02369249f, -0.04295751f, 0.00666041f, -0.02591653f, -0.03800696f, 0.00520314f, -0.00590003f, 
    0.02722550f, 0.03703200f, -0.01691036f, -0.03909082f, 0.04000424f, -0.02453847f, -0.01953668f, -0.00076022f, 
    0.01870421f, 0.00971507f, -0.00258367f, -0.01360137f, 0.01798788f, -0.00811264f, 0.02572728f, 0.04011235f, 
    0.00964913f, 0.00488473f, 0.04002043f, 0.00814941f, -0.03925480f, -0.01527040f, -0.00458768f, 0.00582605f, 
    -0.01126183f, 0.01028184f, 0.01858201f, 0.00896619f, 0.00877014f, -0.03227448f, -0.02663949f, -0.03761425f, 
    -0.00752066f, 0.01161729f, -0.00596090f, 0.00873082f, -0.01360942f, -0.01210844f, 0.02364424f, -0.01835779f, 
    0.03065500f, -0.02728639f, -0.02299753f, -0.03071133f, 0.02266267f, -0.02651893f, 0.01064916f, -0.00380343f, 
    -0.04082585f, -0.01290166f, -0.03425909f, 0.02896412f, 0.00006150f, 0.03273469f, -0.01499388f, -0.00572606f, 
    -0.03327032f, -0.00138278f, 0.00062128f, -0.00988536f, -0.02687798f, 0.03350332f, 0.01993832f, 0.00361708f, 
    -0.02747220f, 0.03662572f, 0.00601710f, -0.01669087f, -0.00127274f, 0.00373316f, -0.02327172f, 0.02937482f, 
    0.00344400f, 0.02788669f, -0.03275250f, -0.04146152f, 0.02649560f, -0.03168412f, 0.02344939f, 0.01864567f, 
    0.02846099f, -0.00719578f, 0.00168936f, 0.01058066f, -0.03049983f, 0.01154792f, -0.02333476f, 0.00498805f, 
    -0.02090271f, 0.01509670f, -0.02134407f, -0.04122934f, 0.02440489f, -0.03285609f, -0.03646931f, -0.04184858f, 
    0.02371917f, 0.00738512f, 0.01894609f, 0.00076775f, 0.00142829f, -0.03691387f, -0.04098500f, -0.00208892f, 
    -0.03375217f, -0.02407384f, -0.00804926f, 0.02672053f, -0.00999820f, 0.03072604f, 0.00279127f, 0.01940501f, 
    -0.01473210f, -0.03277367f, 0.00844442f, 0.00475602f, 0.01481281f, -0.02910341f, 0.01333354f, 0.03054767f, 
    -0.03847000f, -0.01579898f, 0.03335911f, -0.03333703f, -0.02659309f, 0.01645692f, 0.03304081f, -0.02330955f, 
    -0.00197826f, 0.00183408f, -0.01853925f, 0.02818459f, 0.00091111f, 0.00023311f, -0.03706366f, 0.01130768f, 
    0.02979746f, 0.00483101f, -0.02076220f, -0.02766246f, -0.01664265f, -0.03198464f, -0.03167086f, -0.00331713f, 
    -0.01653588f, -0.01480967f, -0.04096801f, 0.01683217f, -0.02103153f, 0.02482106f, 0.02344957f, -0.02683789f, 
    0.02025377f, -0.02553840f, -0.00823013f, 0.00685158f, 0.00655087f, -0.01921950f, -0.01703831f, -0.01573334f, 
    0.01867889f, -0.02031830f, -0.01945772f, -0.01255816f, -0.01959221f, -0.02526438f, -0.01912775f, -0.01745151f, 
    0.00829222f, 0.01418104f, 0.00041313f, -0.04132086f, 0.02289341f, -0.01906122f, 0.02948807f, -0.01020814f, 
    -0.00738868f, -0.01006800f, 0.01953507f, -0.02589081f, -0.00276960f, 0.00620432f, -0.03432574f, 0.02198822f, 
    0.00535809f, 0.03722752f, 0.01802500f, 0.01857691f, -0.03617502f, 0.00321528f, 0.03878466f, -0.03258430f, 
    0.03650769f, 0.00616161f, 0.00632610f, 0.01457467f, -0.03694004f, 0.00540079f, -0.03430894f, 0.03791397f, 
    -0.03574455f, 0.04140682f, 0.01848824f, 0.00377605f, -0.02891792f, 0.00075509f, -0.02219892f, -0.02499684f, 
    0.00892733f, -0.02818370f, -0.03822133f, -0.04097849f, 0.00253971f, -0.03619483f, 0.03226309f, -0.00580776f, 
    -0.01831176f, -0.00143466f, 0.00738012f, -0.00473838f, 0.01420074f, -0.02808479f, -0.01884880f, -0.00039593f, 
    -0.01272070f, -0.00519105f, 0.03246941f, -0.00335533f, 0.01664522f, -0.02737342f, -0.04178099f, -0.01622288f, 
    -0.00087187f, -0.04102955f, -0.01717016f, -0.01766206f, 0.01147768f, -0.00167193f, 0.02821858f, -0.01182625f, 
    -0.02280049f, 0.00140521f, -0.00114225f, 0.02240881f, 0.04125360f, 0.01355301f, 0.00557781f, -0.01773256f, 
    -0.02968003f, -0.02972637f, -0.02739183f, 0.02107632f, -0.02644427f, -0.03703794f, 0.02977731f, -0.01855667f, 
    -0.01264413f, 0.01447446f, -0.00681387f, -0.01910465f, -0.00978145f, -0.00766659f, -0.03549121f, -0.03701856f, 
    0.03661609f, -0.04189339f, 0.01477709f, 0.02910125f, -0.00697257f, 0.01706952f, 0.00639031f, -0.02423034f, 
    -0.02374723f, -0.00581264f, 0.02576644f, -0.02137551f, 0.02742380f, -0.02078916f, 0.02970597f, 0.03001618f, 
    -0.01163672f, -0.01148277f, 0.01025874f, -0.01263757f, -0.02833487f, -0.03837235f, -0.01371394f, -0.01990061f, 
    0.03174602f, -0.03568903f, 0.01678428f, 0.02042978f, 0.01922821f, 0.01696185f, -0.01336880f, -0.02066862f, 
    -0.03208766f, -0.03081186f, 0.01940682f, -0.03356232f, -0.00200352f, -0.02291741f, 0.02049763f, 0.00150777f, 
    -0.02304709f, -0.01484253f, -0.03145890f, 0.00170414f, 0.01475632f, -0.00841512f, -0.02640881f, 0.01836323f, 
    -0.02658530f, 0.00835285f, 0.02864564f, 0.02069000f, -0.01343044f, -0.01730073f, -0.02405295f, -0.00483813f, 
    -0.01801942f, 0.01438313f, -0.01607793f, 0.02448018f, 0.02100939f, 0.02467060f, -0.02663572f, 0.00517545f, 
    -0.00048953f, -0.02820897f, -0.02050144f, 0.00563616f, -0.02023469f, -0.00158791f, 0.01297618f, 0.03974628f, 
    0.01513038f, -0.00463461f, -0.03965336f, -0.00341710f, -0.02684774f, -0.02484568f, 0.01626302f, -0.00815600f, 
    -0.01881695f, -0.00941840f, -0.02842982f, 0.00651446f, 0.02132712f, -0.02421154f, -0.03363226f, 0.01917026f, 
    0.00680965f, -0.00032723f, -0.01113762f, -0.00988888f, 0.00829015f, 0.02665938f, 0.02111220f, 0.03125872f, 
    0.01383626f, -0.01932753f, 0.01767098f, 0.00049355f, 0.01821311f, -0.02114016f, -0.01852420f, 0.01914673f, 
    -0.03310373f, -0.03247466f, -0.00790731f, 0.04191848f, 0.00123795f, -0.00771076f, -0.02763174f, -0.01412940f, 
    -0.00426336f, -0.02169259f, -0.00024162f, 0.00702702f, 0.02187995f, -0.00274847f, -0.01113384f, 0.00680822f, 
    0.00874369f, -0.00345400f, -0.01093248f, 0.03763472f, -0.03092200f, 0.02575887f, -0.03692725f, -0.01984706f, 
    0.02588022f, 0.02102923f, 0.02787774f, -0.00694981f, -0.02584538f, -0.01643401f, 0.02030798f, 0.02268643f, 
    -0.01039409f, 0.02162900f, 0.03859600f, 0.02298754f, 0.00402689f, 0.02254223f, -0.01593224f, -0.02735555f, 
    -0.03400722f, -0.02129989f, 0.03132805f, -0.03269110f, -0.00286937f, -0.03646955f, -0.01356920f, -0.00377422f, 
    -0.03914375f, 0.00931463f, 0.02394558f, -0.03255039f, -0.00266720f, -0.01791759f, 0.01821959f, -0.00927356f, 
    -0.03255655f, 0.00718328f, -0.01079094f, -0.00042713f, -0.00384038f, 0.00723225f, -0.02270343f, -0.02914714f, 
    -0.01004177f, -0.01722071f, 0.00461360f, 0.01175668f, -0.01445967f, -0.01693885f, 0.01860650f, 0.02650730f, 
    -0.01697138f, -0.00901452f, 0.01443199f, 0.02564055f, 0.01316141f, -0.03699249f, -0.03751104f, -0.01358779f, 
    -0.01301621f, 0.01052459f, 0.01725046f, 0.03684271f, 0.01170748f, -0.01062831f, 0.01264087f, 0.03518714f, 
    -0.02211450f, 0.03091846f, 0.00186815f, -0.01628467f, 0.02265262f, 0.02094373f, 0.02295932f, -0.01359029f, 
    0.00134634f, -0.02210498f, -0.03997849f, 0.02673958f, -0.00980064f, 0.01862596f, -0.00937195f, 0.01145411f, 
    -0.00268966f, -0.01200282f, -0.00046047f, -0.03229193f, 0.01794839f, -0.03930396f, 0.00844166f, -0.00137593f, 
    0.02982578f, -0.00270199f, -0.01854973f, 0.02247701f, 0.02740193f, 0.01465641f, 0.00709917f, -0.02434276f, 
    0.00005013f, -0.01867865f, -0.01844839f, -0.00889902f, 0.02397698f, -0.02233104f, -0.01718607f, 0.03571123f, 
    0.01882473f, 0.00382542f, -0.00205633f, 0.01927155f, -0.02629714f, 0.00848517f, -0.01632012f, -0.03057800f, 
    -0.03361877f, 0.00831983f, 0.00121187f, -0.00387710f, -0.00811686f, 0.03542110f, -0.00368428f, -0.00810020f, 
    0.00266732f, 0.01221981f, -0.02675193f, 0.00587997f, 0.00274650f, 0.01240543f, -0.00353572f, -0.01342312f, 
    0.02760380f, 0.02342130f, 0.02104833f, -0.02780999f, -0.01300464f, -0.02312680f, -0.02891576f, 0.00877890f, 
    0.02753563f, -0.02528278f, -0.00894980f, 0.00963266f, -0.00895259f, 0.02488566f, 0.01357463f, -0.02364780f, 
    -0.02361732f, -0.01944938f, 0.00356887f, -0.01422311f, -0.02380332f, -0.00755217f, 0.00961854f, -0.00151382f, 
    -0.00768731f, 0.02838357f, -0.03146300f, 0.02720522f, -0.01434678f, -0.03223158f, 0.01265224f, 0.02719920f, 
    0.03949013f, 0.03997523f, -0.00119808f, -0.03794237f, -0.00115588f, -0.00786896f, -0.00922477f, 0.00659536f, 
    -0.01550581f, 0.00088335f, 0.01382548f, 0.03171562f, -0.00249629f, -0.01799442f, -0.01335821f, 0.02698722f, 
    0.00753614f, -0.00404930f, 0.00418409f, 0.00615973f, 0.02253876f, 0.03511578f, -0.02627210f, -0.01170810f, 
    -0.01034249f, 0.01595826f, -0.03425455f, -0.02905819f, 0.02209891f, 0.02953423f, -0.01137155f, 0.02169396f, 
    0.00187274f, -0.01304444f, 0.00685007f, -0.01650226f, -0.03171146f, -0.01943998f, -0.04137556f, -0.02444156f, 
    0.01345208f, 0.02081511f, -0.00933894f, 0.00751872f, -0.03868286f, 0.01287509f, 0.01677473f, 0.01108794f, 
    -0.02600461f, 0.01978275f, 0.02694737f, -0.02126468f, -0.02527362f, -0.01036665f, -0.01805701f, -0.01254903f, 
    -0.04204590f, 0.02799079f, 0.00304231f, -0.02538917f, 0.00523358f, -0.03053840f, -0.01100399f, -0.02953767f, 
    0.00797645f, 0.01632738f, 0.02391329f, -0.00714782f, -0.00180236f, -0.02930425f, -0.03688924f, 0.02166534f, 
    -0.01756635f, 0.02664167f, -0.00751633f, -0.02506173f, 0.02120984f, 0.00745360f, -0.02172543f, -0.04028832f, 
    -0.04052185f, 0.00689224f, 0.00887321f, -0.03522374f, -0.00369866f, 0.02525027f, -0.00453329f, -0.03112083f, 
    -0.03884716f, -0.00781890f, -0.03407336f, -0.00932250f, 0.01567223f, -0.01616386f, 0.03493411f, 0.01061289f, 
    -0.04041849f, 0.02573658f, 0.04130783f, 0.02109823f, -0.01750114f, 0.04169022f, 0.04027661f, 0.02368174f, 
    -0.03582541f, 0.00123526f, 0.02194681f, 0.00817255f, -0.00230440f, -0.00720628f, -0.00159591f, 0.02745680f, 
    -0.03187984f, 0.01683471f, 0.00125736f, -0.00244355f, -0.00763670f, -0.00957797f, -0.02646258f, -0.02881841f, 
    -0.03153432f, -0.00193941f, 0.03222737f, -0.02310372f, -0.00696950f, 0.03043409f, 0.00829178f, 0.04148715f, 
    -0.01140645f, 0.01258426f, -0.03792164f, -0.00597686f, -0.03547793f, 0.00935996f, 0.02701188f, 0.00621268f, 
    0.01976975f, -0.02097418f, 0.01170581f, -0.03420370f, -0.00555192f, 0.02700989f, -0.00791703f, 0.02027712f, 
    0.01624805f, -0.00777703f, 0.03633848f, -0.03087793f, -0.01074749f, 0.00644728f, -0.01510688f, -0.03846275f, 
    -0.02592953f, -0.00216326f, 0.01628982f, -0.02695260f, 0.00517761f, -0.00291562f, 0.01738712f, -0.02566303f, 
    0.01373545f, 0.02002260f, -0.01057364f, -0.02608528f, -0.02829396f, -0.00331399f, -0.04059020f, 0.00615782f, 
    -0.02025995f, 0.02016629f, 0.01004879f, -0.02607307f, 0.03516120f, 0.00044044f, 0.02791443f, 0.03467621f, 
    0.00887909f, -0.01525728f, 0.03683681f, 0.01348170f, 0.00713651f, 0.02981463f, 0.03733017f, 0.00566113f, 
    0.02179481f, -0.01247283f, 0.03826724f, 0.00726020f, 0.00408309f, 0.02331254f, 0.01505163f, -0.01952094f, 
    -0.00134571f, 0.03522325f, -0.00347315f, -0.00369616f, 0.01470310f, 0.01290083f, 0.01433470f, 0.00127832f, 
    -0.01628903f, 0.00724016f, -0.03491114f, -0.01858287f, -0.00661951f, -0.03195526f, 0.01167186f, -0.00966903f, 
    -0.00663512f, -0.00172243f, -0.02884993f, -0.00270963f, -0.03870503f, -0.01639256f, 0.02879455f, 0.00483913f, 
    -0.01091913f, -0.02169576f, 0.00259077f, 0.00537456f, 0.01411301f, 0.01118446f, 0.01583232f, 0.00080721f, 
    -0.00717574f, -0.03526645f, 0.01631667f, 0.01528571f, 0.00711873f, 0.02766837f, 0.01657370f, -0.01714670f, 
    -0.00014355f, -0.03024948f, 0.02964502f, -0.01585635f, -0.02777918f, 0.01729731f, -0.00396030f, -0.01188974f, 
    0.02776225f, 0.02771060f, 0.00304253f, 0.01108607f, 0.01905339f, -0.00498997f, 0.00540511f, 0.00654684f, 
    -0.01581736f, 0.02978149f, 0.03126748f, 0.00716845f, 0.00085728f, 0.01587957f, 0.01879642f, 0.01809011f, 
    -0.03654334f, -0.01018016f, 0.00176037f, 0.00638591f, 0.00957465f, 0.01053913f, 0.03161228f, 0.02656493f, 
    -0.02357946f, 0.01193352f, -0.00603405f, -0.01264712f, -0.01417546f, 0.01434953f, 0.00058175f, 0.01957695f, 
    -0.00721660f, -0.01564360f, -0.02729206f, 0.00729846f, 0.01265397f, -0.00928837f, 0.00768600f, -0.03017772f, 
    -0.01247067f, -0.00428662f, -0.03866176f, -0.02121775f, -0.00824153f, -0.02319302f, 0.00186705f, 0.03164447f, 
    -0.00449111f, -0.00706145f, -0.04500322f, 0.00515021f, -0.02603357f, 0.02892742f, -0.02714195f, -0.00276839f, 
    0.02396270f, 0.02204248f, 0.01881561f, 0.03200259f, -0.02623577f, 0.00007204f, -0.02032755f, 0.00131682f, 
    0.01872163f, 0.03018853f, 0.02926747f, 0.00946189f, -0.03840981f, 0.03349499f, 0.01760702f, 0.01162051f, 
    -0.03717152f, 0.00592010f, 0.01720805f, -0.03269808f, 0.00577260f, -0.01794094f, -0.00572510f, 0.02389630f, 
    -0.01142075f, -0.00907593f, 0.01399631f, -0.03272573f, -0.01563272f, 0.01142251f, -0.02789843f, -0.03196647f, 
    -0.02051395f, 0.03421930f, -0.03521461f, 0.01228424f, -0.03105611f, -0.02878160f, -0.03723531f, -0.00668472f, 
    -0.02928478f, 0.01505089f, -0.00239195f, 0.02502246f, 0.03092711f, 0.01045898f, -0.03429712f, 0.01641803f, 
    0.00921421f, -0.00248930f, -0.01292756f, 0.01248844f, -0.01254961f, 0.02960515f, -0.00282264f, -0.03761300f, 
    -0.03670474f, 0.03931866f, -0.00036707f, -0.01653430f, 0.03529940f, 0.02278119f, 0.03016101f, 0.01143136f, 
    -0.01367014f, 0.04511235f, 0.01918906f, 0.00281105f, -0.03453156f, 0.00396408f, -0.01350977f, 0.00335284f, 
    0.04063225f, -0.02740479f, -0.01617023f, 0.01652097f, 0.00294467f, 0.00879681f, -0.03662165f, -0.01552827f, 
    0.01125779f, -0.00254181f, 0.01201558f, -0.03901735f, -0.02651681f, 0.03259621f, -0.01080992f, -0.03875897f, 
    -0.02570187f, -0.03119500f, -0.01632597f, -0.02712255f, -0.00371714f, -0.02677627f, 0.00436856f, 0.00269406f, 
    0.01650576f, 0.03783949f, 0.00111009f, 0.02853811f, 0.00174091f, -0.01463583f, 0.01502743f, -0.02704557f, 
    -0.02659143f, 0.00622280f, -0.01769759f, -0.01532007f, -0.03576038f, -0.01552407f, 0.01880404f, -0.01878097f, 
    -0.03947973f, 0.01420061f, -0.01306664f, -0.01700937f, -0.01635544f, -0.03314495f, 0.00859465f, -0.03435594f, 
    -0.03776076f, 0.02464086f, 0.03017393f, 0.02900671f, -0.01182603f, -0.03360141f, -0.02902292f, 0.00641641f, 
    -0.00221639f, 0.00013879f, -0.03397005f, -0.03671307f, 0.00336187f, 0.00529765f, -0.00220957f, -0.00926791f, 
    -0.02881554f, -0.01929820f, -0.02007688f, 0.02086740f, -0.02942967f, -0.02925962f, -0.02920928f, -0.03309568f, 
    0.04140896f, -0.03616220f, -0.02132568f, -0.03819484f, -0.03146886f, -0.01259317f, -0.01102277f, -0.00060128f, 
    0.00603080f, 0.02701150f, 0.02305326f, -0.00945621f, 0.03417938f, -0.02081132f, -0.03597715f, 0.00624911f, 
    0.00153243f, -0.03278600f, 0.00664593f, 0.01202188f, -0.02783925f, 0.02074301f, -0.00980174f, -0.00458854f, 
    0.03646781f, 0.00857466f, -0.01294737f, -0.00645214f, -0.00028427f, -0.00239052f, 0.02218323f, 0.02465680f, 
    -0.01539048f, 0.03533965f, -0.02944702f, -0.02966225f, 0.00999811f, -0.01323025f, 0.00524680f, 0.02960036f, 
    0.01946232f, 0.01284408f, 0.02847759f, 0.03886293f, 0.02257443f, -0.03808069f, -0.00193640f, -0.01328162f, 
    0.00204606f, 0.00298607f, 0.04510844f, -0.01856638f, -0.03579917f, 0.01411301f, -0.02691791f, -0.00578954f, 
    -0.00139634f, -0.02935200f, 0.02805009f, 0.00390231f, 0.02060070f, -0.01284660f, -0.02088492f, -0.03697504f, 
    -0.00641251f, 0.00490813f, 0.01120622f, -0.02032118f, -0.02456218f, -0.02497527f, 0.02552841f, 0.02720645f, 
    -0.03474522f, 0.00659371f, 0.00460229f, 0.01341135f, 0.02180526f, -0.03186415f, -0.01512226f, -0.01214117f, 
    -0.03015754f, -0.01109004f, 0.00247196f, -0.00492326f, 0.03130800f, 0.01671090f, -0.02393220f, 0.00729797f, 
    0.01927538f, 0.01395437f, -0.02957579f, 0.00325098f, 0.00707287f, -0.00232612f, 0.00146332f, -0.03502182f, 
    0.02710046f, -0.00307114f, -0.00659783f, 0.02685751f, -0.02197804f, -0.00996011f, 0.00046217f, 0.00236954f, 
    -0.02104968f, -0.03712358f, -0.01193267f, -0.03116510f, -0.03309068f, 0.01060728f, 0.01963534f, 0.01374627f, 
    -0.02048634f, -0.00656068f, 0.02098566f, 0.00145619f, -0.01042435f, -0.02709198f, 0.00193244f, -0.00898309f, 
    -0.03789254f, -0.03789652f, 0.00347799f, 0.01017433f, 0.00406924f, -0.01162290f, -0.01746563f, 0.00923178f, 
    -0.02118330f, -0.00093794f, 0.01880323f, -0.01749608f, -0.02938282f, 0.02598050f, -0.01818836f, 0.01552965f, 
    -0.00475161f, 0.02234514f, 0.03282117f, -0.02522359f, 0.01004185f, 0.01657992f, 0.02826066f, -0.03234060f, 
    -0.01287927f, 0.03055892f, 0.02468287f, -0.03001228f, 0.00753427f, 0.02408564f, -0.00713717f, -0.01658213f, 
    -0.01381398f, -0.03112569f, 0.01115312f, 0.01140135f, -0.00820909f, 0.00944819f, -0.01326537f, -0.01266892f, 
    0.02639719f, -0.03028795f, 0.02370626f, -0.03454591f, 0.02420831f, -0.03146407f, -0.02358005f, 0.00268801f, 
    -0.01911387f, -0.01849844f, -0.00898764f, 0.01094488f, -0.02187391f, 0.02421904f, 0.01075832f, 0.00044316f, 
    0.01673939f, 0.02395440f, 0.00096470f, -0.01588206f, -0.00418937f, -0.02268425f, 0.02926281f, 0.01383208f, 
    0.00552202f, 0.03116968f, 0.02041557f, -0.01665457f, -0.02346912f, -0.00632596f, 0.00035310f, 0.03115909f, 
    -0.01503774f, -0.01503175f, -0.03372445f, 0.00593582f, 0.02057550f, 0.00860994f, -0.01098374f, 0.00731109f, 
    0.01639291f, 0.02639835f, 0.02043021f, 0.03108160f, 0.02503907f, -0.03692807f, -0.03710422f, -0.02914112f, 
    -0.00974951f, 0.03794969f, -0.03917218f, -0.00333538f, -0.00631024f, 0.03309225f, 0.02025638f, -0.02638721f, 
    -0.01034392f, -0.03530471f, -0.01746346f, -0.00681947f, -0.02143640f, 0.00203633f, -0.00578007f, -0.04105458f, 
    0.02992364f, -0.00930956f, -0.00272799f, -0.00219772f, 0.00995856f, 0.01337963f, -0.01296621f, -0.01594076f, 
    0.03602960f, -0.01876626f, -0.03595148f, -0.03369539f, -0.02728382f, 0.01565004f, -0.03157725f, -0.02424975f, 
    -0.01903863f, 0.00160543f, 0.01691142f, -0.00091925f, -0.01881948f, -0.03169676f, -0.04411317f, -0.03966745f, 
    -0.02858210f, 0.00921137f, -0.00636780f, 0.01738080f, 0.00482145f, -0.00550081f, 0.01249491f, -0.03428674f, 
    -0.01680138f, -0.01228324f, 0.00791726f, -0.00068393f, -0.02841112f, -0.01109043f, 0.02413462f, -0.02813013f, 
    0.01785245f, -0.02297909f, 0.00535195f, -0.03465663f, 0.02333702f, 0.02711515f, 0.02123917f, 0.01728621f, 
    -0.02994210f, 0.00150987f, -0.00349629f, -0.01963771f, -0.00919172f, 0.01615662f, -0.02737265f, -0.03151539f, 
    -0.02406948f, -0.02855483f, -0.02290095f, -0.01977790f, -0.01941834f, 0.03430927f, -0.00436543f, 0.01173636f, 
    -0.01055511f, -0.00338301f, -0.01051610f, -0.00548740f, -0.04288037f, -0.00131161f, 0.01593039f, 0.00553621f, 
    -0.01336346f, -0.00245612f, -0.01464559f, 0.00519605f, -0.03481673f, 0.03109762f, 0.01325888f, 0.01221303f, 
    0.02197996f, -0.00516777f, -0.00975314f, -0.03523314f, 0.01141889f, -0.02367280f, 0.00716874f, 0.00279055f, 
    0.01734044f, -0.02924121f, -0.03166585f, -0.00788146f, -0.03612391f, -0.02995428f, -0.01025821f, -0.03095273f, 
    0.01995883f, 0.00026361f, 0.03352010f, 0.00853147f, 0.00330521f, -0.02176908f, 0.01785951f, -0.03411990f, 
    -0.03580610f, 0.02122075f, -0.02278283f, -0.01287342f, -0.02918166f, -0.03207584f, -0.02417458f, 0.01847392f, 
    0.02935247f, -0.00320810f, -0.00218805f, -0.03063825f, -0.02031780f, 0.03308985f, 0.01961073f, 0.00598722f, 
    0.02440189f, -0.02306656f, -0.00469453f, 0.03348808f, -0.01008421f, -0.00376625f, -0.03753797f, 0.02579875f, 
    0.00392705f, -0.01917011f, -0.02755314f, 0.03516102f, 0.02796102f, -0.03231758f, 0.03029134f, -0.01171657f, 
    -0.01476273f, -0.03018863f, -0.02525913f, -0.00834823f, 0.01239520f, 0.01912998f, -0.00055257f, 0.03761414f, 
    -0.03137348f, -0.03880219f, 0.02386527f, -0.01288311f, -0.02410463f, -0.01724161f, 0.00670237f, 0.02064997f, 
    -0.01256900f, 0.01995467f, 0.00972591f, 0.02374435f, -0.03250661f, 0.00206408f, -0.03399380f, -0.01509475f, 
    0.00907890f, -0.03387715f, 0.02989652f, -0.00182677f, 0.00342500f, 0.01686613f, -0.00731366f, -0.03540723f, 
    0.00177716f, -0.02377356f, 0.02694114f, 0.01826010f, -0.00950285f, 0.01607133f, 0.00581486f, -0.02895886f, 
    -0.02512230f, -0.04636294f, 0.02068174f, 0.00469380f, 0.03679788f, -0.01109667f, 0.02080909f, -0.02393789f, 
    0.02267769f, -0.02269654f, -0.03619963f, 0.00392397f, 0.00686182f, 0.00359137f, -0.00569028f, 0.01469747f, 
    -0.03218428f, -0.01946686f, 0.01428430f, -0.03827167f, 0.02076351f, 0.01158819f, 0.00283299f, -0.01104582f, 
    -0.01809969f, -0.04120475f, -0.02565156f, 0.00100280f, 0.01175454f, -0.01102442f, -0.01168628f, 0.01464362f, 
    0.02629968f, 0.04051717f, -0.02228512f, -0.02637538f, 0.02599444f, -0.01641713f, -0.03391650f, -0.00654968f, 
    0.02184171f, -0.00423718f, 0.00399415f, 0.00717549f, -0.00420717f, 0.03084031f, 0.00844542f, 0.02077850f, 
    0.01199670f, -0.00013317f, -0.02707091f, -0.03074835f, -0.00256506f, -0.01661537f, -0.02466150f, 0.01335728f, 
    -0.00629346f, 0.00999981f, -0.03315250f, -0.02626239f, 0.00683173f, 0.00394475f, -0.02911460f, -0.00155699f, 
    0.03196357f, 0.02553954f, 0.00950355f, 0.01301766f, 0.00313349f, 0.03518542f, -0.03464544f, -0.03499222f, 
    0.00550473f, -0.01873074f, 0.00042888f, -0.00824480f, 0.01662965f, -0.01533247f, -0.03688128f, -0.00354093f, 
    -0.01348015f, -0.00262275f, 0.00305340f, 0.01384168f, 0.02015211f, -0.01727775f, -0.00875324f, 0.01600195f, 
    0.01415563f, -0.02924368f, 0.00130016f, -0.02040573f, -0.00269227f, 0.00648962f, 0.00859626f, 0.01503884f, 
    -0.02925975f, -0.01268074f, 0.00206230f, -0.03414792f, -0.03345970f, -0.01709130f, -0.03101901f, -0.02643551f, 
    -0.00037529f, 0.01242253f, -0.00798481f, -0.02082067f, 0.03381260f, -0.03481531f, -0.01489178f, -0.02672711f, 
    -0.00354444f, -0.01253718f, 0.01752917f, 0.00338786f, 0.01463933f, -0.02752647f, 0.00699373f, -0.01803934f, 
    -0.02431107f, 0.01057628f, 0.00800393f, 0.02653488f, -0.03778787f, 0.03870502f, 0.02285985f, 0.01979669f, 
    0.01001141f, -0.01241922f, -0.02076653f, 0.02256444f, -0.01582989f, -0.02731790f, -0.01844393f, -0.03498047f, 
    0.01978752f, -0.00306629f, -0.03037689f, 0.00866664f, -0.00863472f, 0.01776727f, -0.00100214f, 0.00474308f, 
    0.20275393f, 0.10839270f, -0.06681526f, 0.09823204f, 0.06186553f, 0.02370919f, -0.02744997f, -0.04368754f, 
    0.01899971f, -0.03252966f, 0.02014927f, 0.13305254f, -0.12713696f, 0.07267775f, 0.07048522f, -0.17101683f, 
    0.02231822f, -0.07880628f, 0.02672915f, -0.00593863f, -0.01644403f, -0.06311333f, -0.00366770f, 0.02716142f, 
    0.15138529f, 0.13108949f, -0.07084936f, -0.13621376f, -0.06441277f, -0.07434163f, -0.05903363f, 0.05700212f, 
    -0.01942270f, 0.07904596f, 0.10488641f, -0.02553739f, 0.20833604f, -0.17044425f, 0.01569303f, -0.06737536f, 
    0.09593163f, -0.00492475f, -0.00063085f, -0.00120319f, -0.01598768f, 0.06090466f, 0.01504974f, 0.04955978f, 
    0.05809890f, -0.04004144f, -0.18969844f, -0.00238885f, 0.04378090f, 0.04254108f, -0.03712378f, -0.02070536f, 
    0.11270283f, 0.00993830f, -0.12722151f, -0.06619699f, 0.23161465f, 0.12474415f, 0.02305938f, 0.06675915f, 
    -0.02848407f, -0.06558422f, 0.01061792f, 0.10253830f, -0.01287571f, 0.04416140f, 0.01311155f, -0.08711944f, 
    0.19268531f, -0.07985180f, 0.00532117f, 0.00063361f, -0.05212359f, -0.05197816f, 0.00119096f, -0.14828044f, 
    0.02996974f, 0.07436889f, -0.12766699f, -0.01429787f, 0.05369934f, -0.00001980f, 0.06066048f, -0.07148790f, 
    -0.04672448f, -0.02244074f, 0.02649096f, 0.01913992f, -0.02161399f, 0.03700384f, 0.05566931f, -0.02309126f, 
    -0.18811551f, 0.12252157f, 0.06250130f, -0.12030645f, 0.07858225f, 0.02693935f, -0.01314757f, 0.01473529f, 
    -0.03843786f, 0.10639362f, 0.17220250f, -0.00973940f, 0.14238365f, -0.02978538f, 0.06115250f, -0.25813103f, 
    0.04648656f, -0.03678475f, 0.00108217f, -0.04324791f, -0.01586772f, 0.02182074f, 0.11755835f, 0.07678814f, 
    0.22630338f, 0.08075353f, 0.04668213f, 0.07191579f, 0.00082971f, 0.01920000f, 0.10324107f, 0.14844002f, 
    -0.01885706f, -0.06990785f, 0.04233593f, 0.09331202f, 0.23266773f, 0.06451713f, 0.03239150f, -0.25476396f, 
    0.07236899f, 0.08040518f, 0.03553845f, 0.00436410f, -0.00370822f, 0.07627669f, 0.01429586f, 0.00298392f, 
    -0.08155207f, -0.12746936f, -0.02130671f, -0.13798949f, -0.01453067f, 0.02602810f, -0.02110732f, -0.01080990f, 
    0.14133622f, 0.13481277f, 0.01841859f, 0.00137667f, -0.03858839f, -0.15929583f, 0.06195144f, 0.09720406f, 
    -0.01982701f, 0.03358194f, -0.03605549f, -0.11514433f, 0.08913517f, 0.04469697f, 0.10709673f, -0.02969163f, 
    0.05387748f, -0.22596416f, -0.13590612f, -0.17416380f, 0.02616001f, -0.05913265f, -0.01871524f, 0.07074677f, 
    -0.00713165f, -0.01276568f, 0.00539921f, -0.12934472f, 0.06059779f, 0.01637482f, -0.12919119f, 0.05905939f, 
    -0.17657340f, 0.08118396f, 0.04948264f, 0.02187043f, 0.05002844f, 0.09167988f, 0.02047396f, -0.01729277f, 
    0.09799989f, -0.17510052f, -0.01920798f, 0.09295966f, 0.05725181f, 0.07012979f, 0.08924599f, -0.03540706f, 
    -0.01371021f, 0.06427073f, 0.10931272f, 0.09394927f, 0.36647165f, -0.08217860f, -0.01018002f, -0.02295358f, 
    -0.02022698f, 0.03773711f, 0.04018110f, 0.13271721f, 0.09854838f, 0.06007367f, 0.02132894f, 0.12739924f, 
    0.20803864f, -0.18917142f, -0.01058038f, -0.04010684f, 0.01868386f, -0.00607704f, -0.01472269f, 0.08701124f, 
    0.05088549f, -0.03198535f, -0.02232446f, 0.02712442f, 0.07428919f, -0.05386568f, -0.13023391f, 0.04319526f, 
    0.12443126f, 0.00340400f, -0.06648268f, -0.09955169f, 0.11583415f, 0.00646963f, -0.08810036f, -0.03900546f, 
    0.06981491f, 0.11160640f, 0.00354751f, 0.00167076f, -0.09008909f, 0.01571116f, 0.06514733f, 0.02153927f, 
    0.03619796f, 0.02234169f, 0.01846582f, 0.08793996f, -0.12043024f, -0.12125497f, 0.05292356f, -0.20111784f, 
    0.04200327f, 0.00583598f, -0.14637119f, 0.05867409f, 0.02402946f, -0.04310684f, -0.06588786f, 0.00123803f, 
    0.17653812f, -0.10354076f, -0.02755740f, -0.20106255f, 0.05406740f, -0.02639243f, -0.03366013f, 0.02274581f, 
    -0.02747433f, 0.05534419f, 0.06202886f, 0.00260881f, -0.13418618f, 0.07815065f, 0.07638927f, 0.01288627f, 
    0.03007724f, -0.04808412f, 0.07856239f, 0.04295594f, -0.01618411f, -0.02835892f, 0.02368313f, -0.05303605f, 
    0.02141663f, -0.10968666f, -0.06206936f, 0.07812372f, -0.01533922f, 0.00043418f, -0.09991986f, -0.10368060f, 
    0.11649492f, 0.05194421f, 0.00972621f, -0.05765462f, -0.10766689f, 0.01142679f, -0.04515339f, 0.06160548f, 
    -0.01905936f, 0.03642130f, 0.01247815f, 0.02494839f, -0.01781170f, 0.09287892f, -0.02381406f, 0.06772208f, 
    0.12206410f, -0.05362910f, 0.07585926f, 0.01226152f, 0.01111892f, -0.09441876f, 0.14992012f, 0.02606755f, 
    0.01475429f, 0.04352036f, -0.06717649f, -0.01811364f, -0.04483070f, -0.05941299f, 0.11817384f, -0.17791757f, 
    -0.00416083f, 0.02952362f, -0.03974563f, 0.00150107f, 0.06260541f, -0.04684404f, 0.07704157f, 0.02856388f, 
    -0.04518492f, 0.05887833f, -0.07798457f, -0.04695401f, 0.04636838f, -0.02063864f, 0.05078591f, -0.02695272f, 
    -0.03005691f, -0.10703776f, 0.01945850f, 0.08608841f, 0.18745685f, -0.10269500f, 0.09405765f, 0.12107027f, 
    0.06148305f, 0.04223565f, -0.00205465f, -0.04681482f, 0.03977961f, 0.06080832f, 0.11591183f, -0.00721993f, 
    0.14587972f, -0.09738463f, -0.05095406f, -0.02108137f, 0.10878493f, -0.04390256f, 0.00218616f, 0.13256788f, 
    0.02907324f, 0.05236314f, -0.00163660f, 0.00396460f, -0.26182613f, -0.05610203f, -0.02712642f, -0.12139496f, 
    0.03183853f, -0.00566450f, -0.01385847f, -0.07434358f, -0.02251277f, 0.03721265f, 0.06190902f, 0.05342044f, 
    0.09136172f, 0.07201408f, 0.02243392f, -0.11157958f, 0.01793593f, 0.17869489f, -0.11357496f, -0.07308878f, 
    -0.06201458f, 0.02497230f, -0.03426072f, 0.06899634f, 0.24334775f, 0.00931553f, -0.07324197f, 0.01073986f, 
    0.03841134f, 0.07010105f, -0.00653918f, -0.08814739f, 0.05861569f, 0.02862358f, 0.06429806f, 0.12634084f, 
    0.15802968f, -0.00088549f, -0.05589492f, -0.06322295f, 0.10441375f, 0.03227139f, 0.04470713f, -0.03542712f, 
    0.11292028f, 0.07482950f, -0.03780237f, -0.04543972f, -0.01903056f, -0.00024007f, 0.18665940f, -0.01198640f, 
    0.10093084f, 0.05654519f, -0.00284684f, -0.01377710f, -0.02819505f, 0.07649244f, 0.07544859f, 0.06301492f, 
    0.20654286f, 0.05994834f, -0.08568661f, 0.05974504f, 0.01362999f, 0.08344555f, 0.05552330f, -0.00373864f, 
    -0.01502956f, 0.01605129f, 0.06150958f, -0.03688147f, 0.28904030f, -0.14003067f, 0.02336189f, 0.08843169f, 
    0.03238097f, 0.02498347f, 0.04285913f, -0.01203333f, 0.04214250f, 0.05183540f, 0.00651919f, 0.00688352f, 
    -0.03979163f, 0.04650228f, 0.08896234f, -0.13783981f, -0.04417818f, 0.01413971f, -0.06968058f, 0.02092832f, 
    0.05733633f, -0.02248998f, 0.10826137f, -0.00148734f, 0.52253270f, -0.12764019f, -0.03381752f, -0.00691657f, 
    0.07718822f, 0.03662799f, 0.06474137f, 0.10213763f, 0.02192651f, 0.00503988f, -0.02550288f, 0.04368568f, 
    -0.09314653f, 0.20119615f, 0.02411974f, 0.07648584f, -0.05300565f, -0.03995715f, 0.02902018f, -0.01688744f, 
    0.09162534f, 0.00623886f, 0.04007431f, -0.00938327f, -0.10564286f, -0.14948922f, -0.08788460f, 0.07670449f, 
    0.00071391f, -0.00500652f, -0.05884501f, 0.01652720f, 0.02683004f, 0.02575540f, -0.02084051f, 0.06042079f, 
    0.07807887f, -0.13822812f, 0.02147956f, -0.09961791f, -0.09209911f, 0.04962167f, 0.06515729f, 0.06533405f, 
    -0.06090454f, 0.03930629f, -0.01654267f, 0.07209272f, 0.28567350f, 0.01009592f, 0.09054428f, 0.02697901f, 
    -0.02124276f, 0.04957686f, -0.02100717f, -0.06802610f, -0.04469347f, 0.04600817f, 0.04831248f, -0.06715464f, 
    0.20087425f, -0.01669130f, 0.03374464f, 0.07045586f, -0.05323803f, 0.06516811f, -0.05855541f, 0.06766597f, 
    0.06095275f, 0.02635628f, 0.04753010f, -0.02417227f, 0.05873324f, 0.07993977f, 0.08408142f, -0.00420244f, 
    0.01673913f, -0.01515293f, 0.05987570f, 0.04443229f, 0.01946184f, 0.06130119f, -0.00452302f, 0.03924928f, 
    0.10604813f, 0.08420999f, -0.01066059f, 0.10222235f, 0.04352365f, 0.01668712f, 0.01498626f, -0.04261984f, 
    0.05206985f, 0.04636478f, 0.04154276f, 0.02651760f, -0.22555555f, -0.15110250f, 0.06420424f, 0.03402835f, 
    -0.06245971f, 0.04109410f, 0.07340445f, 0.20892794f, -0.00813526f, 0.08565339f, -0.00934402f, 0.08645295f, 
    -0.05638878f, 0.05815133f, -0.09241620f, 0.06864803f, -0.04411191f, 0.02409526f, -0.06336544f, -0.00324117f, 
    -0.00424383f, -0.09272168f, -0.01370061f, -0.01622168f, 0.11550197f, -0.04235926f, -0.02841202f, -0.02500407f, 
    -0.04702658f, -0.01878681f, 0.07406528f, 0.05831369f, -0.04931064f, 0.04357891f, 0.06563844f, -0.04205497f, 
    0.01299277f, 0.28908718f, 0.08189436f, 0.01498845f, 0.09838381f, -0.05532070f, -0.00885793f, 0.14053737f, 
    -0.00790021f, 0.04393153f, 0.05776635f, 0.04526445f, 0.11693167f, -0.01114373f, 0.10801629f, -0.07922851f, 
    -0.01751507f, 0.03753871f, -0.11543301f, 0.02759709f, 0.05128450f, 0.06483416f, 0.04935358f, 0.04347838f, 
    -0.38756859f, 0.09420375f, 0.01505123f, 0.14260575f, 0.01299012f, -0.00598725f, -0.10105927f, 0.08363877f, 
    0.00329760f, 0.02646807f, -0.07900634f, -0.03313170f, -0.03501955f, 0.05319367f, -0.04151664f, -0.08172450f, 
    -0.02458901f, -0.08692501f, -0.04651662f, 0.05195271f, 0.02556791f, 0.01495761f, -0.00773347f, 0.04279025f, 
    0.37037522f, 0.10634095f, -0.05905744f, 0.05190922f, 0.01845632f, -0.08509896f, 0.02376188f, 0.10064279f, 
    -0.01391504f, 0.03646101f, 0.01884415f, -0.11629968f, 0.21175568f, -0.05604940f, -0.25427970f, 0.12451433f, 
    -0.01564404f, 0.00500701f, -0.06643492f, -0.04526113f, -0.05720454f, -0.07302033f, 0.04110025f, 0.05399461f, 
    -0.13958703f, -0.27722397f, -0.09650944f, 0.04748428f, 0.10405588f, 0.04866313f, 0.00208563f, -0.01861922f, 
    0.06282989f, 0.12542945f, 0.01095846f, -0.01726903f, 0.40271288f, -0.01639944f, 0.02167116f, 0.07256947f, 
    0.01100877f, -0.01494308f, 0.05104980f, 0.06546318f, -0.03418261f, -0.01414712f, 0.04214787f, 0.01740932f, 
    0.08063852f, 0.14993872f, 0.01638966f, -0.25424129f, -0.07176669f, -0.01490628f, 0.04729760f, -0.00361689f, 
    -0.03014498f, 0.06409371f, -0.01487901f, -0.00428152f, 0.06765911f, -0.07918488f, 0.06762468f, 0.12147480f, 
    0.08669712f, -0.01612857f, -0.05995950f, -0.04946911f, 0.01608104f, 0.07625648f, 0.03751855f, -0.02943297f, 
    0.34703094f, -0.04798205f, -0.04973114f, 0.04985832f, 0.01206769f, 0.00777059f, 0.13682666f, 0.07049111f, 
    -0.00582526f, -0.02054713f, -0.00838265f, 0.08493921f, -0.04722744f, 0.07816687f, 0.10234548f, -0.22630249f, 
    0.06420872f, -0.06394137f, 0.05655497f, 0.00142875f, 0.01023275f, 0.11715355f, 0.00311573f, 0.01618055f, 
    0.01146755f, 0.13859199f, 0.16034836f, 0.12229806f, -0.06371643f, -0.01272158f, 0.03321098f, 0.04502335f, 
    0.00828358f, -0.00295190f, 0.00860894f, 0.16583855f, 0.05545413f, 0.00293658f, -0.06709289f, -0.03042684f, 
    0.01733173f, -0.02059089f, 0.08005459f, 0.09178563f, 0.02622965f, -0.09393998f, -0.06747792f, -0.01544003f, 
    0.01303110f, 0.02055073f, -0.00763459f, 0.00346281f, 0.01839333f, 0.00001177f, 0.00800350f, 0.02800129f, 
    0.02445422f, 0.02359282f, -0.01867655f, -0.03418903f, 0.00664078f, -0.00550652f, -0.01157469f, -0.02414782f, 
    0.00449583f, -0.02314260f, -0.00370931f, -0.03457453f, 0.02313923f, -0.01632022f, -0.02477723f, -0.01598128f, 
    -0.02222154f, -0.03728057f, -0.01322623f, 0.00296213f, -0.02080183f, 0.02880703f, -0.03132712f, -0.01477549f, 
    0.02090675f, 0.00966618f, -0.00427290f, -0.01913359f, 0.00979798f, -0.03117950f, 0.00647285f, 0.00628361f, 
    -0.01663529f, -0.02218615f, 0.00488601f, -0.02681375f, -0.00545114f, 0.00072783f, 0.02727210f, -0.03000862f, 
    0.01785076f, -0.02558186f, -0.03329423f, 0.02438688f, -0.02920257f, -0.01100142f, -0.00889242f, -0.01735720f, 
    -0.03291684f, 0.01704275f, -0.01881918f, -0.04190826f, -0.00111217f, -0.01857640f, -0.03706491f, -0.00740346f, 
    -0.01748794f, 0.02244689f, -0.02934942f, -0.00541794f, 0.01982765f, -0.02850763f, 0.01530752f, 0.01691195f, 
    -0.02944554f, -0.02713160f, 0.01693849f, 0.01072347f, 0.01764737f, -0.00164521f, 0.01288573f, -0.01803531f, 
    0.01962922f, 0.02977140f, -0.00552971f, -0.00054915f, -0.03151250f, 0.01034582f, -0.02028390f, -0.03374758f, 
    -0.00917456f, -0.01942244f, -0.00557927f, -0.02619177f, -0.00279062f, 0.01363737f, 0.02347585f, 0.02336573f, 
    -0.02407228f, 0.00402384f, -0.00478339f, -0.02313370f, -0.02748400f, -0.01311556f, 0.00159183f, 0.00406849f, 
    -0.00141726f, 0.02332350f, 0.01525248f, -0.01701328f, -0.00891262f, 0.02109751f, -0.01591451f, 0.01390804f, 
    -0.00868003f, -0.02932277f, 0.00334034f, 0.01466470f, 0.02381680f, -0.03082886f, -0.03442487f, -0.00185755f, 
    -0.02756573f, -0.02722295f, -0.00631194f, -0.00909576f, -0.02547541f, 0.01036450f, 0.02502098f, 0.01397972f, 
    -0.00069092f, 0.01361314f, -0.02418301f, -0.01649638f, -0.03331830f, 0.02340771f, 0.00899429f, 0.01855174f, 
    -0.04161112f, -0.00583002f, 0.02628549f, -0.03369769f, -0.01245851f, -0.00568572f, 0.00627701f, 0.00789097f, 
    -0.03260297f, 0.00069289f, -0.02579247f, 0.00860160f, -0.02757406f, -0.01176215f, 0.02282735f, 0.02474715f, 
    0.00075791f, 0.02563220f, 0.00716513f, -0.02038490f, 0.02636783f, 0.00492001f, -0.02641575f, -0.03466424f, 
    0.01923452f, -0.00660205f, 0.01861107f, 0.02740422f, 0.01405795f, 0.00260361f, 0.00597573f, 0.01888947f, 
    -0.03957564f, -0.01208499f, 0.01048696f, -0.03081792f, 0.00006092f, -0.02445932f, -0.01084226f, 0.02900193f, 
    -0.01551210f, -0.00583131f, 0.01195061f, -0.01020161f, -0.02081407f, -0.03081574f, 0.01894422f, -0.01768159f, 
    -0.04166885f, -0.01295197f, -0.01498686f, -0.01880999f, 0.02660446f, 0.01469971f, 0.00539663f, -0.02805702f, 
    -0.01828884f, -0.01716785f, 0.01328314f, -0.00091276f, -0.02322391f, -0.02454724f, 0.02884278f, -0.01679780f, 
    -0.04190545f, -0.03843769f, 0.02908849f, -0.01162625f, -0.02248225f, -0.00173023f, 0.01733759f, 0.01157435f, 
    -0.01364524f, -0.00998968f, -0.00088688f, 0.02259121f, -0.01348673f, -0.00978595f, 0.01588745f, -0.01241903f, 
    0.00698144f, -0.00118771f, 0.02977303f, 0.00303025f, -0.03890863f, -0.00846897f, 0.00702964f, -0.02350127f, 
    0.02509439f, -0.03576285f, -0.02068150f, -0.02290226f, 0.02727583f, -0.00963036f, -0.00401710f, -0.02925004f, 
    -0.03698124f, -0.03497112f, -0.00183171f, 0.00999472f, 0.00974844f, 0.00804901f, 0.02387923f, 0.02355626f, 
    -0.01593862f, -0.02671379f, 0.01170858f, 0.02238021f, -0.03470105f, 0.02637368f, -0.02124710f, -0.01969459f, 
    0.01234503f, -0.02394069f, -0.00027973f, 0.03377763f, -0.02900912f, 0.01667312f, -0.00362089f, 0.01252328f, 
    0.01987961f, 0.02452371f, 0.00920564f, -0.03508645f, 0.00214617f, -0.03532584f, -0.02294190f, 0.00553268f, 
    -0.01753393f, -0.02815377f, 0.02010485f, -0.01480555f, -0.03845048f, -0.01234297f, -0.03199945f, -0.01739016f, 
    0.00300663f, -0.03554595f, 0.00774716f, -0.03751703f, 0.01350303f, -0.02502394f, -0.00787290f, 0.00887937f, 
    0.00839045f, -0.02442570f, -0.01751091f, -0.04116862f, -0.00523934f, -0.04164460f, -0.00047625f, 0.01157394f, 
    0.01213972f, 0.02869602f, -0.00298519f, 0.00422858f, -0.03937254f, 0.01823912f, -0.00896336f, -0.00275515f, 
    0.00982933f, 0.02542867f, 0.00099900f, -0.01432755f, -0.02170947f, 0.00107726f, -0.02267292f, -0.01474137f, 
    0.02232637f, 0.01558709f, -0.03066093f, -0.03160786f, -0.02540961f, 0.01823062f, -0.01372643f, 0.00316104f, 
    -0.03863013f, 0.01275108f, -0.01844371f, -0.00326495f, -0.02505359f, -0.04128829f, 0.02910028f, 0.00965138f, 
    0.01527724f, -0.01335470f, 0.00285084f, 0.01108175f, -0.00202810f, -0.00751233f, 0.00302118f, -0.00404203f, 
    -0.01948549f, -0.03352784f, 0.00403179f, -0.00359772f, -0.00576890f, -0.01563026f, 0.02753527f, 0.00159019f, 
    -0.02719734f, 0.00459596f, -0.02196723f, -0.02329781f, 0.00074505f, -0.00148412f, 0.00866460f, -0.02575051f, 
    -0.00532181f, -0.01373649f, -0.03424482f, -0.03905584f, -0.00458029f, -0.02421300f, -0.00573320f, -0.00010374f, 
    0.02500354f, -0.02256262f, 0.03000460f, -0.03172813f, 0.01045030f, -0.02490385f, -0.02768083f, -0.02012536f, 
    0.00124115f, -0.01458009f, -0.01279259f, -0.02671571f, 0.01322229f, 0.00526960f, -0.02955749f, 0.01967227f, 
    0.00736745f, -0.01495193f, -0.02526438f, -0.00719529f, -0.02285244f, -0.00063156f, 0.01654087f, -0.01518237f, 
    -0.03678893f, -0.03470732f, 0.00391435f, -0.00190076f, -0.00921756f, -0.00596806f, 0.00915781f, -0.03189722f, 
    -0.02732511f, -0.03022150f, 0.00809099f, -0.01796580f, 0.02509440f, 0.01545632f, -0.01250676f, -0.00468137f, 
    0.00720804f, 0.02971777f, -0.01895982f, 0.00997806f, 0.00517808f, -0.02059738f, -0.02711452f, -0.00542198f, 
    0.01986374f, -0.03904897f, 0.02262692f, -0.00160385f, 0.00387767f, 0.00887268f, 0.01649061f, -0.03535037f, 
    -0.03469368f, -0.00511107f, 0.02157798f, -0.00380412f, -0.03807268f, 0.01251681f, -0.00832816f, -0.01017931f, 
    -0.00218848f, -0.01943338f, -0.04164869f, -0.00669369f, -0.04195250f, -0.01845951f, -0.02244410f, -0.00393734f, 
    -0.02402270f, 0.01806868f, -0.02009253f, 0.00692375f, -0.00841980f, -0.04054630f, 0.00687049f, 0.00892276f, 
    0.02151635f, 0.00795852f, 0.01368122f, -0.00910370f, -0.01326811f, -0.01448000f, 0.00672777f, 0.03259628f, 
    -0.03833899f, -0.03722728f, -0.03138151f, -0.03241125f, -0.03460174f, -0.00318669f, 0.02465042f, -0.00699391f, 
    -0.00016447f, -0.01895515f, 0.00965468f, -0.01006602f, -0.01953110f, -0.03138522f, 0.01562811f, -0.03981839f, 
    -0.02332465f, -0.02870723f, -0.01171161f, 0.00730327f, -0.01830534f, 0.02235819f, 0.01231836f, -0.00139381f, 
    -0.03290707f, 0.02262027f, -0.03030730f, -0.01958525f, 0.00129246f, 0.01308679f, -0.03449667f, -0.00953758f, 
    -0.00142486f, -0.00535263f, -0.02518850f, -0.01276184f, -0.01608055f, 0.02571595f, -0.00448585f, -0.03077062f, 
    -0.00723091f, -0.00983138f, 0.02202656f, -0.00279432f, 0.00870777f, -0.04194365f, 0.01941825f, -0.03951964f, 
    -0.03620838f, -0.02839895f, -0.03399965f, -0.02828069f, 0.00463082f, -0.03901537f, -0.01525041f, -0.04050642f, 
    0.02924900f, -0.03839623f, 0.01760385f, -0.01361964f, -0.03018705f, -0.01108561f, 0.02459414f, -0.00938623f, 
    -0.01800820f, -0.02175696f, -0.01169382f, 0.01170655f, -0.03286141f, 0.01824722f, 0.02093759f, -0.00294705f, 
    -0.01602180f, -0.03754628f, 0.02796117f, 0.02336682f, -0.03072925f, -0.02336583f, 0.01651224f, 0.01237196f, 
    -0.02533445f, -0.01914509f, -0.02681010f, -0.00535694f, -0.04132089f, -0.02928517f, 0.00368433f, -0.01086189f, 
    0.03860645f, 0.00224365f, 0.00829905f, -0.01309571f, -0.03166664f, -0.02344629f, 0.02816241f, -0.00835676f, 
    -0.00992441f, 0.01068983f, 0.00730640f, -0.03375420f, -0.02705183f, -0.01038229f, -0.02032599f, 0.01442592f, 
    0.00699354f, -0.02218287f, 0.01297149f, -0.00990450f, -0.02590118f, -0.01866203f, 0.00813808f, -0.00445997f, 
    -0.03295890f, -0.03350902f, -0.04129550f, 0.01581190f, -0.04009442f, 0.00157219f, 0.02584940f, 0.02426343f, 
    -0.02584997f, -0.01546153f, 0.02647640f, -0.01718524f, -0.00710431f, 0.02210790f, -0.01306033f, -0.02994537f, 
    -0.01877926f, -0.00349677f, 0.01657938f, 0.02163278f, 0.01613674f, 0.00420706f, -0.01915332f, 0.00067161f, 
    0.02704304f, -0.03237706f, -0.00600049f, 0.00097973f, -0.00133269f, -0.01318196f, -0.03111678f, -0.02036032f, 
    -0.02172220f, 0.00158952f, 0.02296268f, -0.03124262f, -0.01674920f, -0.02666726f, 0.02044567f, 0.02682541f, 
    0.00382599f, 0.00837483f, 0.00569030f, 0.01184627f, -0.03379110f, -0.01160119f, 0.00905972f, -0.00459884f, 
    -0.03450421f, -0.02947931f, 0.01229940f, 0.01014276f, -0.00300114f, 0.02957140f, 0.02086900f, -0.01051899f, 
    0.01414883f, 0.01511554f, 0.00872179f, -0.02481187f, 0.02834243f, 0.00757888f, -0.00014851f, 0.00501478f, 
    -0.02622938f, -0.03934899f, -0.03770926f, -0.03517089f, 0.00210465f, -0.01771887f, 0.01485838f, -0.03575263f, 
    -0.03860639f, 0.00764505f, -0.03874230f, -0.03492807f, 0.02500526f, -0.03314292f, 0.02718487f, 0.00680512f, 
    0.02154603f, -0.00366609f, -0.03156340f, -0.02196732f, -0.00934411f, 0.01750144f, 0.01735738f, -0.02039957f, 
    0.01300628f, -0.03308614f, -0.00604505f, -0.02303519f, 0.02527053f, -0.01718809f, -0.04205828f, -0.03386600f, 
    -0.03988101f, 0.00977766f, -0.03577312f, 0.02215109f, 0.00828655f, 0.02978044f, -0.01285188f, 0.00675511f, 
    0.00105679f, 0.00098892f, -0.04185716f, 0.01432982f, -0.01088699f, -0.01932306f, 0.02273471f, -0.02842005f, 
    0.02598242f, -0.02392443f, 0.00537071f, 0.01969539f, -0.00778408f, 0.02080336f, -0.00598089f, -0.01829543f, 
    0.02046766f, -0.02221725f, -0.03574344f, -0.02356729f, 0.01931016f, 0.01621144f, 0.00324113f, -0.03045034f, 
    0.02642926f, -0.01552733f, -0.03228313f, -0.00771113f, -0.01386412f, -0.03114696f, -0.03511501f, -0.02665870f, 
    -0.00170611f, -0.01528561f, 0.01550704f, -0.03931078f, -0.01271257f, -0.03340328f, -0.01340857f, -0.02774982f, 
    -0.01861215f, 0.02018674f, -0.03214673f, 0.02756014f, -0.00363744f, -0.02236816f, -0.03174288f, 0.00264357f, 
    0.01434431f, 0.00084837f, 0.00535211f, 0.02956677f, 0.01805640f, 0.01523706f, -0.03494732f, -0.01339887f, 
    0.00647047f, 0.01656974f, -0.00371868f, -0.02609958f, -0.02911615f, 0.00235887f, 0.01622529f, -0.04098916f, 
    0.02361761f, -0.00850753f, -0.04078994f, -0.02803931f, -0.03698432f, -0.03267801f, 0.01955227f, 0.02579916f, 
    -0.00201362f, 0.01145643f, 0.02362665f, -0.00552742f, 0.01770733f, 0.03975954f, 0.01780157f, 0.02990453f, 
    -0.02605460f, -0.01396640f, -0.03173005f, -0.01856445f, 0.01806831f, 0.01399358f, 0.01600450f, 0.00639145f, 
    0.01092026f, -0.00565195f, -0.04088447f, 0.01741182f, 0.01533408f, 0.00154302f, 0.01415664f, 0.01343918f, 
    -0.02752674f, -0.00623474f, 0.01149439f, -0.03783757f, 0.01950601f, 0.01939547f, -0.01145543f, 0.00242407f, 
    -0.00243665f, 0.02003730f, -0.00555721f, -0.01374443f, -0.00837833f, -0.03019680f, -0.02224933f, -0.00861997f, 
    0.01165656f, -0.02618088f, -0.00704082f, -0.01448782f, 0.02346130f, -0.01117482f, 0.01949607f, 0.00553236f, 
    -0.04327758f, -0.01889862f, -0.01604562f, -0.02282246f, -0.01517389f, -0.01590007f, -0.02519490f, -0.01589801f, 
    -0.02742874f, -0.02810044f, -0.01667004f, -0.00895868f, -0.01433909f, -0.01293905f, 0.00195527f, 0.02007323f, 
    -0.03625735f, 0.01112067f, 0.01577264f, 0.01953651f, -0.02266055f, 0.01688008f, -0.01888408f, -0.04119970f, 
    0.02655604f, 0.00560318f, -0.03596573f, -0.00511727f, -0.04752701f, -0.02120936f, -0.01005051f, 0.02163992f, 
    -0.01161367f, -0.04344857f, -0.03342603f, -0.03298216f, 0.02131495f, 0.02977606f, -0.04415563f, 0.00591610f, 
    -0.03255944f, -0.02367522f, 0.02544421f, -0.03251369f, -0.01894508f, -0.02394912f, -0.03522448f, 0.00032219f, 
    0.01009339f, -0.02402307f, -0.03551149f, 0.01888727f, -0.03918536f, -0.01861584f, 0.02997408f, -0.01939918f, 
    -0.03154223f, -0.02761142f, -0.00898452f, 0.00148062f, -0.00827189f, -0.02393335f, 0.00193446f, -0.01361351f, 
    0.00052719f, -0.04173209f, -0.03205632f, -0.00213929f, -0.02331022f, 0.01601281f, -0.03268655f, -0.03752388f, 
    -0.04022238f, -0.01468187f, 0.01296059f, 0.00751154f, 0.00067984f, 0.02043375f, 0.00132096f, -0.00740986f, 
    0.02237162f, 0.02138972f, -0.00306319f, 0.01106202f, -0.02734303f, -0.02285924f, 0.02135651f, -0.02436306f, 
    0.02825101f, -0.02918396f, 0.02876751f, -0.01433739f, 0.02778697f, -0.01366462f, -0.00963365f, -0.02738144f, 
    -0.00903590f, -0.04109262f, 0.01226154f, -0.02380840f, -0.03003814f, 0.00724946f, -0.04947200f, 0.02625955f, 
    -0.03715310f, 0.01071866f, -0.03351001f, 0.02926510f, -0.00593654f, -0.04028489f, -0.04315426f, -0.00588923f, 
    -0.01961089f, -0.02470152f, -0.00957562f, -0.03573873f, -0.00565861f, 0.02251490f, -0.02995604f, -0.02888340f, 
    -0.03617088f, -0.00664473f, 0.01504710f, -0.01459685f, 0.00123550f, 0.02608796f, -0.02291748f, 0.00966792f, 
    0.03268791f, -0.01860663f, -0.03538962f, 0.01514980f, 0.01902976f, 0.01268054f, -0.00229566f, 0.02517531f, 
    -0.02212494f, 0.00474308f, -0.00261926f, -0.01458235f, -0.00764056f, 0.00613707f, 0.00473253f, -0.03014680f, 
    -0.02906425f, -0.02514569f, 0.01842983f, -0.02717753f, -0.03157232f, -0.00301310f, 0.03269883f, 0.01550398f, 
    -0.03372375f, -0.00045247f, 0.00537210f, 0.01780711f, -0.01765368f, -0.03040463f, -0.00033356f, 0.01378987f, 
    0.00300708f, -0.00248949f, 0.02211049f, 0.01972147f, -0.01104858f, -0.02547729f, -0.02164706f, -0.00407403f, 
    0.02747898f, -0.02584906f, -0.02304141f, -0.02814140f, -0.01827790f, -0.03720335f, -0.00680066f, 0.00834514f, 
    0.01176372f, -0.00634861f, -0.00538912f, 0.02129938f, -0.03325295f, -0.01855472f, -0.03791556f, -0.02650346f, 
    -0.01960779f, -0.02936766f, 0.00889724f, 0.02111164f, 0.01765134f, -0.01101668f, -0.01948672f, 0.00187197f, 
    0.00595820f, -0.00307210f, 0.01032819f, -0.03743737f, 0.00149797f, 0.00904499f, 0.01223732f, -0.03118239f, 
    0.01727822f, -0.01683341f, -0.00018997f, 0.01366298f, -0.03038415f, 0.03761199f, 0.01791759f, -0.01800168f, 
    0.02789370f, 0.01153324f, -0.02996581f, -0.01194102f, 0.02565735f, -0.02352423f, -0.00895666f, -0.01091036f, 
    -0.02008730f, -0.01700264f, -0.02307834f, -0.00119746f, 0.02111548f, -0.02154176f, -0.02299585f, -0.00445542f, 
    -0.03368821f, 0.01553605f, -0.01028097f, -0.02608408f, -0.04277707f, 0.00078174f, -0.00215566f, -0.01812297f, 
    -0.00308021f, 0.02143482f, 0.00465031f, -0.00619924f, -0.02698035f, 0.00160897f, 0.02042189f, -0.03376826f, 
    0.01256618f, -0.04681012f, 0.00189339f, 0.01344906f, -0.00169885f, 0.01419720f, -0.02152032f, 0.01729705f, 
    0.00183597f, 0.01249844f, 0.01548387f, -0.02334076f, -0.03515898f, 0.00359372f, -0.02058388f, 0.01072843f, 
    0.02697524f, 0.00024098f, 0.00460206f, -0.01357776f, 0.02006903f, 0.02958262f, 0.01332197f, -0.00703111f, 
    -0.03527990f, 0.01866660f, -0.03454449f, -0.01038892f, 0.00972408f, -0.01076814f, 0.01742548f, 0.03110878f, 
    -0.00284990f, -0.03353148f, -0.02731443f, 0.02610921f, -0.02372543f, 0.01411913f, 0.02385325f, 0.00867713f, 
    -0.03897240f, -0.00091949f, 0.00817539f, -0.01187894f, 0.00423805f, 0.01941307f, -0.02606997f, 0.01076320f, 
    0.00383733f, -0.03625534f, -0.04320375f, -0.02254179f, -0.01090031f, 0.01273013f, -0.02150182f, 0.00791117f, 
    0.01889824f, -0.03223232f, -0.01940555f, 0.02168225f, 0.02365436f, -0.00583732f, 0.02810892f, -0.03156627f, 
    -0.01000452f, 0.02514572f, -0.00050402f, -0.03797729f, -0.00635715f, 0.01823290f, -0.03770601f, 0.00945084f, 
    0.03380947f, -0.00570244f, 0.01311581f, -0.01473095f, 0.01085510f, -0.00966825f, -0.00867956f, -0.02640699f, 
    0.01262189f, 0.00052342f, 0.01647557f, 0.03315014f, 0.01780414f, 0.02267464f, 0.01526787f, 0.00085894f, 
    0.02344083f, -0.02769036f, 0.00141901f, -0.00881122f, -0.02843330f, 0.00081009f, 0.00892590f, 0.02595979f, 
    -0.02579396f, 0.00306472f, -0.01456089f, 0.00651342f, 0.03184174f, 0.01450370f, 0.02921445f, -0.01124104f, 
    0.02760085f, -0.03257379f, 0.02849780f, -0.03307420f, -0.00935644f, -0.01474627f, -0.01673655f, -0.01164607f, 
    -0.01149616f, 0.00180570f, 0.01135351f, -0.00225691f, -0.02653536f, -0.01995197f, 0.03140985f, -0.02191668f, 
    0.03106496f, -0.00941949f, 0.03469766f, 0.02439669f, -0.01789815f, 0.00501452f, 0.02693428f, -0.03145260f, 
    -0.01794927f, 0.02206457f, -0.00635256f, 0.01496291f, -0.01065413f, 0.01082184f, 0.00466147f, -0.03546755f, 
    -0.01277297f, -0.01809203f, -0.00122029f, -0.02867125f, -0.02841225f, -0.00213357f, -0.00758709f, 0.01252014f, 
    -0.03355251f, -0.02640530f, -0.03148656f, -0.01182145f, 0.02449507f, -0.04067397f, 0.01901086f, -0.00390780f, 
    0.02123805f, 0.02101688f, -0.04385233f, 0.01952702f, -0.03502231f, 0.02419084f, -0.02005368f, -0.00365629f, 
    -0.00446309f, 0.01339235f, 0.01874398f, -0.02806895f, -0.02785775f, -0.02318886f, -0.02515238f, 0.00965044f, 
    0.02818802f, -0.03691291f, 0.02898359f, 0.00676943f, 0.02249906f, -0.00994885f, 0.02046885f, -0.00770093f, 
    -0.02150414f, -0.00713368f, -0.01412102f, 0.00918442f, 0.02121458f, 0.01003114f, 0.00777970f, -0.00505615f, 
    -0.01049674f, -0.03379533f, -0.03493175f, -0.02112053f, -0.02673937f, -0.01664332f, 0.02977923f, 0.00388991f, 
    -0.00041658f, 0.00868853f, -0.04128232f, -0.01523913f, -0.03142812f, 0.01173958f, -0.03562177f, -0.02217632f, 
    -0.03039839f, 0.01891770f, 0.01784446f, -0.02612999f, 0.01441336f, -0.02991509f, 0.00716321f, 0.01171096f, 
    -0.01936093f, -0.01962622f, -0.03291669f, -0.00500914f, 0.00459151f, -0.03366911f, -0.01825646f, -0.01627116f, 
    0.01020112f, 0.00748997f, 0.02243532f, -0.02426850f, 0.02990633f, 0.02476513f, 0.00050516f, -0.02607504f, 
    -0.00788177f, 0.00555588f, -0.01923089f, 0.03057710f, 0.00307608f, 0.00950943f, -0.01330280f, -0.01011015f, 
    -0.02448109f, 0.01875424f, 0.02984521f, 0.01196148f, 0.00572080f, -0.03573049f, 0.02580380f, -0.01668736f, 
    0.00572906f, -0.03043626f, 0.03134620f, -0.02985717f, 0.01003375f, -0.03906812f, 0.01990067f, -0.01233854f, 
    0.00167726f, -0.00151942f, -0.03526855f, 0.00642476f, -0.01422335f, -0.04818603f, 0.00284081f, -0.02473807f, 
    -0.00319106f, -0.00142964f, 0.00664220f, -0.03887092f, 0.00112106f, 0.01995451f, 0.02130344f, -0.03108876f, 
    0.01105945f, -0.01399681f, -0.01626775f, -0.00590315f, -0.01593348f, 0.01551315f, -0.01004246f, 0.02571355f, 
    -0.01013074f, -0.02250935f, 0.02501018f, 0.00203844f, -0.01914983f, -0.02409552f, -0.00610983f, 0.03348619f, 
    -0.01407438f, 0.01982807f, -0.00112163f, 0.02432959f, 0.00552543f, 0.00733510f, -0.01982794f, 0.00413360f, 
    -0.01277022f, -0.01992952f, -0.03237947f, -0.02096549f, -0.04088029f, -0.02051061f, -0.00020813f, 0.01664220f, 
    0.02769780f, -0.02125952f, -0.01050817f, -0.02078146f, 0.00454054f, -0.02456701f, -0.01978750f, 0.02336678f, 
    0.03351825f, 0.03434281f, -0.02365207f, 0.03201689f, -0.01581601f, -0.01102865f, -0.00080926f, -0.03246817f, 
    -0.00074382f, -0.03626495f, -0.02489848f, 0.01953734f, 0.02901942f, 0.02430741f, -0.01989895f, -0.02384330f, 
    0.00029285f, -0.00895693f, -0.01856812f, -0.03464114f, -0.02576305f, -0.00173325f, 0.00768099f, 0.01404285f, 
    -0.02188210f, -0.01362546f, 0.02378426f, 0.03405622f, 0.03026854f, -0.01392969f, -0.02249523f, -0.03051207f, 
    -0.03146206f, -0.01368673f, -0.01799123f, 0.02229731f, 0.02541885f, 0.00999745f, -0.00717046f, 0.00299354f, 
    0.01338961f, -0.03551294f, -0.01148179f, -0.03781277f, -0.00277335f, -0.02364568f, -0.00413370f, 0.02905539f, 
    0.00900755f, -0.03976579f, -0.02138389f, -0.00829581f, 0.01114183f, 0.01188740f, 0.01238882f, -0.01494999f, 
    0.00336030f, -0.00560559f, -0.04097772f, 0.03675332f, 0.02535266f, 0.02617238f, -0.01418803f, -0.04188293f, 
    -0.00088562f, 0.02720541f, -0.01463457f, -0.01099803f, -0.03135644f, 0.01365867f, 0.01713907f, 0.00958752f, 
    -0.03775576f, 0.02453659f, -0.02657051f, 0.00659567f, -0.00158688f, -0.00245897f, 0.02024763f, -0.02596360f, 
    0.00639417f, -0.01553646f, -0.01892270f, -0.01862490f, 0.01966023f, -0.03656306f, -0.01026227f, 0.01965192f, 
    -0.03461049f, -0.02036222f, 0.01203011f, -0.04199876f, -0.00413849f, 0.01872241f, -0.03960138f, 0.01870315f, 
    -0.00215076f, -0.02649838f, 0.02077477f, -0.02032991f, -0.03476505f, 0.00005912f, 0.01917948f, 0.03543757f, 
    0.03349068f, 0.02152046f, 0.01811130f, -0.00444671f, 0.00969846f, -0.04164246f, -0.00841986f, 0.02619310f, 
    0.02025949f, 0.00430791f, -0.01105091f, 0.01630595f, -0.01509934f, -0.01062590f, 0.01740998f, 0.02649888f, 
    -0.02676400f, 0.02477928f, 0.00047788f, 0.01530600f, -0.01380708f, -0.01140335f, 0.01416767f, 0.00320985f, 
    0.01166097f, 0.00581054f, -0.02469694f, 0.01573229f, -0.03176776f, -0.02417495f, 0.02544249f, -0.03028979f, 
    -0.01041729f, 0.00284952f, -0.02663952f, -0.00189984f, 0.02838497f, -0.01133540f, 0.00122200f, -0.01042001f, 
    0.00455334f, 0.00225313f, -0.03557791f, -0.02576805f, 0.01459183f, -0.01758974f, -0.00024716f, 0.01565359f, 
    -0.00776570f, -0.04135470f, 0.02211533f, 0.00087627f, 0.00955110f, 0.03765941f, 0.01625134f, 0.02972484f, 
    -0.00584746f, -0.02527107f, -0.04165320f, 0.01386656f, 0.01675638f, -0.02884749f, -0.01809271f, -0.03179655f, 
    0.00084105f, 0.00810996f, 0.00797074f, -0.03265810f, 0.00032623f, -0.03840507f, 0.00929574f, -0.04285428f, 
    0.00264996f, -0.02010847f, -0.01846190f, -0.04022655f, 0.00216011f, -0.03858331f, -0.03947440f, 0.01520945f, 
    -0.04077654f, -0.01120562f, -0.03263400f, -0.00483209f, 0.02222266f, 0.03007327f, -0.01837133f, -0.03110619f, 
    -0.03259121f, 0.00005721f, -0.01375022f, -0.01371506f, -0.00026968f, 0.00739001f, 0.02897785f, -0.00899742f, 
    -0.01226903f, -0.03706687f, -0.03410279f, -0.03461178f, -0.00236589f, -0.03419914f, -0.04094454f, 0.01318085f, 
    0.02712988f, 0.02711503f, -0.01672172f, -0.02647607f, -0.04179746f, -0.02332608f, -0.01328734f, 0.02772626f, 
    0.00367199f, 0.00519662f, 0.01404161f, 0.00509009f, -0.03059396f, -0.00436370f, -0.03568435f, 0.00396928f, 
    -0.03048057f, 0.02035119f, -0.03060111f, 0.00277288f, 0.00017366f, -0.02662639f, -0.00272852f, -0.03593665f, 
    0.01666507f, -0.00351092f, -0.01437430f, -0.01551009f, 0.02498762f, -0.00260389f, -0.00338575f, 0.02863001f, 
    0.00699169f, -0.02863223f, -0.00069553f, -0.01912246f, 0.01021169f, -0.01070720f, -0.01027959f, -0.00126001f, 
    0.02402612f, -0.04425468f, -0.02034966f, -0.01103298f, 0.03262487f, -0.02661751f, 0.01844448f, -0.03959287f, 
    -0.03828802f, 0.01572387f, -0.01612917f, 0.00212897f, -0.01320885f, -0.03654373f, -0.02476988f, 0.02594290f, 
    -0.01115942f, -0.02187562f, 0.02180203f, -0.04362182f, 0.01238515f, -0.04052568f, -0.02527234f, 0.02149519f, 
    -0.01653298f, -0.03976088f, 0.02529113f, 0.01703710f, 0.01733386f, -0.02121351f, -0.00300307f, -0.01466377f, 
    0.01078117f, 0.01983954f, 0.00361552f, 0.01453491f, 0.00262619f, -0.01443655f, -0.02210376f, -0.04185775f, 
    0.00205857f, -0.03817607f, 0.01470271f, -0.03764196f, -0.03356420f, -0.00060824f, -0.00142947f, -0.02464390f, 
    -0.01177801f, -0.02882821f, -0.02056150f, -0.02100179f, 0.02475105f, -0.02375949f, 0.02037345f, -0.00061048f, 
    0.02834169f, 0.00762406f, -0.02664426f, -0.00152876f, -0.02543456f, 0.00209478f, -0.01224761f, -0.00495388f, 
    -0.00019597f, 0.00592924f, -0.00536091f, 0.01145236f, 0.02293903f, -0.01699139f, -0.01539909f, 0.01303777f, 
    0.00029050f, -0.03912781f, 0.00768715f, 0.01024668f, -0.04290706f, 0.02325520f, -0.00521205f, -0.01496152f, 
    -0.02028704f, -0.02626919f, 0.02520477f, -0.04012454f, 0.01425967f, -0.03049088f, -0.01970365f, 0.00814550f, 
    -0.03021911f, 0.01312700f, 0.00201589f, -0.03998838f, -0.01554064f, -0.00367636f, -0.02434949f, 0.01225485f, 
    -0.01996425f, 0.01449961f, -0.03917375f, 0.01312792f, -0.03379619f, -0.03874784f, -0.01737371f, -0.00975536f, 
    -0.00369441f, -0.01388082f, -0.04147868f, 0.00755052f, -0.01438198f, 0.02554590f, 0.00108935f, 0.02739954f, 
    -0.03532906f, 0.01394242f, -0.02641462f, 0.02692207f, -0.00897229f, 0.02807764f, -0.01273995f, -0.03643115f, 
    0.01586872f, 0.00998032f, 0.00425646f, 0.01803109f, -0.00707715f, 0.00667938f, -0.02101201f, 0.02077997f, 
    -0.00318030f, 0.01436850f, -0.03872117f, 0.01002516f, 0.01140812f, 0.00784795f, -0.03210095f, -0.01387069f, 
    -0.01395132f, 0.01457088f, -0.02542227f, -0.01278128f, 0.02524761f, -0.01863880f, -0.00741974f, 0.02349780f, 
    0.01128437f, 0.02331805f, 0.01362274f, 0.01939997f, 0.03315073f, -0.01790216f, 0.00692715f, 0.02738513f, 
    0.03111156f, 0.02591284f, -0.00378105f, -0.01205459f, 0.00084119f, 0.01328318f, 0.03434104f, -0.01811451f, 
    -0.01873129f, 0.01595294f, -0.01071978f, -0.02375256f, 0.01435464f, 0.01832625f, 0.02248856f, 0.00368649f, 
    0.02685645f, 0.00394815f, -0.03089965f, -0.02080152f, -0.00584512f, -0.01896213f, -0.00137043f, -0.03442644f, 
    -0.03054597f, -0.01554914f, 0.00646597f, 0.00768653f, -0.01903172f, -0.03422978f, -0.04189697f, -0.02947964f, 
    0.02230289f, 0.01302662f, 0.01689233f, -0.02048509f, -0.01157018f, -0.04004421f, -0.04381420f, -0.04158441f, 
    -0.00300460f, 0.00232213f, 0.01388496f, 0.01139359f, 0.00768335f, -0.01103503f, 0.02447537f, -0.02647036f, 
    0.02084850f, -0.03264060f, -0.01837701f, -0.00432224f, 0.01436479f, -0.00264866f, -0.04146446f, -0.02580686f, 
    -0.01022924f, 0.03422975f, 0.00855736f, -0.02165384f, -0.02073367f, -0.00931591f, -0.02163506f, -0.03633708f, 
    0.01988341f, 0.00925703f, -0.00217009f, -0.01957556f, -0.00579795f, 0.00978182f, -0.01044389f, -0.03654289f, 
    -0.03627596f, -0.03061546f, -0.00268428f, 0.02389787f, -0.01358471f, -0.03067226f, -0.02248059f, 0.01737863f, 
    -0.01114397f, 0.02034829f, 0.03177277f, -0.00130696f, 0.03242392f, -0.04360478f, -0.02859039f, -0.03317538f, 
    0.02752866f, -0.02607502f, 0.00390601f, 0.02116231f, 0.01034984f, -0.01729833f, -0.03437475f, -0.01918661f, 
    0.00270207f, -0.01965127f, -0.01207729f, 0.03120167f, 0.01238330f, -0.02473756f, -0.01720450f, -0.02986240f, 
    0.02811083f, -0.01804810f, 0.02206827f, -0.03512622f, -0.00616269f, 0.01500148f, 0.03000627f, 0.01690949f, 
    -0.01128188f, 0.00833481f, -0.01970028f, 0.00417082f, 0.02830421f, -0.01036492f, -0.00933785f, 0.02769010f, 
    -0.03226960f, 0.01253916f, -0.02785222f, 0.00359251f, -0.03854806f, -0.00885699f, -0.03300960f, 0.00284441f, 
    -0.00217807f, 0.00678958f, 0.01779804f, 0.00112986f, -0.00985292f, 0.02792889f, 0.00902057f, 0.03845795f, 
    0.01081736f, 0.00177978f, -0.00603738f, 0.01156603f, 0.00259147f, -0.01698812f, 0.02309668f, -0.00058637f, 
    -0.01644024f, -0.01781538f, -0.02159887f, 0.00178150f, -0.01616164f, 0.00500060f, 0.00548470f, 0.00434227f, 
    -0.02939873f, -0.03877826f, 0.01820933f, 0.01051303f, -0.01920764f, 0.01939313f, 0.00887950f, 0.01149997f, 
    0.01760473f, 0.01356947f, 0.02011604f, -0.00212430f, 0.02870845f, 0.01391964f, 0.03235361f, -0.01338317f, 
    0.01351427f, 0.02198058f, -0.01990921f, -0.02953251f, -0.01762585f, -0.02816113f, -0.04058031f, -0.00078148f, 
    0.01944106f, 0.03786593f, -0.03043984f, 0.02194926f, -0.03462976f, -0.02592005f, -0.01738694f, -0.03422160f, 
    0.02684016f, -0.01111735f, -0.01064029f, 0.01330569f, -0.01673548f, 0.02793188f, 0.01577032f, 0.00623806f, 
    -0.03639392f, -0.02105413f, 0.01456864f, 0.00117993f, -0.02224736f, -0.04144178f, -0.03140997f, 0.01002221f, 
    -0.00354055f, 0.01919340f, -0.04219446f, 0.01065467f, 0.00926614f, -0.00817958f, 0.02145689f, 0.02665033f, 
    -0.02118448f, -0.02746016f, 0.02095314f, -0.00714233f, 0.00968182f, -0.00448347f, -0.00962599f, 0.01366318f, 
    0.00891380f, -0.01233909f, -0.00074805f, 0.02138930f, -0.04393354f, 0.00544783f, 0.00596562f, -0.01433043f, 
    0.01171471f, -0.02268885f, 0.01455621f, -0.01870098f, 0.01506240f, 0.00687499f, -0.01224458f, -0.03159602f, 
    -0.01580467f, -0.02461280f, 0.00667414f, 0.01201075f, 0.02376107f, -0.00613925f, -0.02558480f, -0.00307528f, 
    -0.00325580f, -0.02688793f, 0.00013799f, 0.00418178f, 0.01419664f, -0.02730977f, 0.00104236f, 0.00921332f, 
    -0.00358058f, 0.00690508f, -0.00464414f, 0.02514468f, -0.01850016f, -0.03048795f, 0.01915782f, 0.01727109f, 
    -0.01104514f, -0.00913584f, -0.00850204f, 0.00939569f, 0.00530373f, 0.01842959f, -0.03596040f, 0.01391899f, 
    0.02311355f, 0.00166276f, 0.00939912f, -0.03776396f, 0.00755243f, -0.01317536f, -0.02045415f, 0.00127268f, 
    -0.02837891f, 0.01109813f, -0.00172175f, 0.00921945f, 0.00822015f, -0.00309940f, -0.00407044f, -0.01918087f, 
    -0.02780975f, -0.01642724f, -0.03756818f, -0.01910760f, 0.01792054f, -0.01213273f, 0.02636987f, -0.04292549f, 
    -0.00867342f, -0.00214953f, 0.00501629f, -0.02897617f, 0.01354973f, 0.00044904f, -0.04176826f, 0.00801042f, 
    0.02602783f, 0.01996772f, -0.02102754f, -0.00212448f, -0.02684882f, 0.01731634f, -0.02304378f, -0.03638537f, 
    0.00420223f, -0.04341177f, -0.02617689f, 0.01920261f, -0.02625334f, -0.03284906f, -0.02635095f, -0.01806057f, 
    0.00402157f, -0.03334300f, -0.00489154f, 0.00448926f, -0.04292269f, -0.02105863f, -0.03208727f, 0.03527708f, 
    -0.01702315f, 0.02505641f, 0.02070612f, -0.03078819f, -0.00345594f, 0.00380929f, -0.02780538f, 0.01064937f, 
    -0.03120869f, 0.02252266f, -0.01043999f, 0.00557541f, 0.01123238f, -0.01452500f, 0.00473759f, -0.02874059f, 
    0.01181447f, -0.01189306f, 0.02452933f, -0.02831150f, -0.02255720f, 0.02361625f, -0.00475062f, 0.02612613f, 
    0.03421742f, 0.01662091f, -0.03845279f, -0.00324550f, -0.01027458f, -0.01213483f, 0.00345906f, 0.01174673f, 
    -0.02796141f, 0.01546337f, 0.00289759f, 0.01487182f, 0.01339591f, -0.01150491f, -0.03879754f, 0.00693283f, 
    0.00050255f, 0.00899069f, -0.02209772f, -0.00566889f, -0.01615106f, -0.00297078f, -0.00373876f, 0.00208987f, 
    -0.02038213f, -0.02057295f, 0.02901813f, -0.02532620f, -0.01103976f, -0.03541347f, -0.01199601f, -0.00392822f, 
    -0.04139135f, -0.02897183f, 0.02769106f, -0.00030801f, -0.02040344f, -0.00876384f, -0.01348300f, -0.01724396f, 
    -0.03178981f, -0.01387976f, -0.03158749f, -0.02967194f, 0.00820990f, 0.00319163f, -0.02747349f, 0.03446377f, 
    -0.02168651f, 0.02678510f, -0.01910303f, 0.00068892f, -0.01063250f, -0.02617887f, -0.02404014f, 0.00235416f, 
    0.02151151f, 0.01632199f, 0.01633932f, -0.02589821f, -0.01666331f, -0.03454570f, -0.00563588f, -0.04336439f, 
    -0.01037066f, -0.03592888f, -0.02814835f, -0.02238551f, -0.00977297f, -0.02319242f, -0.02291958f, -0.00778195f, 
    -0.00592853f, -0.03661000f, 0.01731065f, 0.02597117f, -0.00130037f, -0.00451943f, 0.00497073f, 0.01947715f, 
    -0.03508560f, -0.00755050f, 0.03133148f, -0.00508257f, 0.01958487f, 0.00518525f, 0.01455635f, -0.03230629f, 
    -0.01414206f, -0.01161588f, 0.00616739f, 0.01250947f, 0.01794748f, 0.02170278f, 0.01610063f, -0.03986681f, 
    0.00220586f, -0.01214373f, -0.02076665f, -0.03357174f, 0.00687078f, -0.00824306f, -0.01691776f, 0.03098568f, 
    0.01861487f, -0.03487398f, -0.01106805f, -0.02183974f, -0.04250820f, 0.00150549f, -0.00096230f, -0.04190896f, 
    -0.03938792f, 0.00673139f, -0.03225321f, 0.00900317f, -0.01547277f, -0.01225223f, -0.03289363f, -0.00883760f, 
    0.00505088f, -0.00913487f, -0.00443155f, -0.02067860f, 0.01837131f, 0.01163780f, -0.00971318f, -0.03411704f, 
    0.00370530f, 0.03444429f, 0.00441965f, 0.01366918f, 0.01370455f, -0.00456465f, 0.01999632f, -0.01272153f, 
    -0.03595158f, 0.02031683f, 0.02071466f, 0.02353532f, 0.01781066f, -0.01430203f, -0.02602263f, -0.03099559f, 
    -0.02986297f, 0.01813649f, -0.00729114f, 0.01430149f, 0.01465708f, -0.04258651f, -0.03334839f, 0.02613120f, 
    0.01577522f, 0.02577256f, 0.03836044f, -0.02868300f, 0.01885192f, 0.01115638f, 0.02393548f, -0.03277392f, 
    -0.01536696f, -0.00319342f, -0.00763422f, -0.00246818f, 0.02112013f, -0.03269646f, -0.01601546f, 0.02735336f, 
    0.01332217f, -0.02931622f, -0.01015587f, -0.02910552f, -0.02696731f, 0.03280851f, 0.03230135f, -0.01672769f, 
    -0.00842102f, -0.02381289f, -0.02819989f, -0.00789507f, -0.01899168f, 0.00174732f, -0.00875396f, -0.01702338f, 
    -0.02126674f, 0.00361759f, -0.00047167f, -0.00913208f, 0.01997670f, 0.01619159f, -0.00568529f, -0.00063812f, 
    -0.01479420f, -0.01727759f, -0.02311991f, 0.02244378f, -0.03912969f, 0.01458640f, 0.02340499f, -0.02096723f, 
    0.01068746f, -0.02259661f, 0.00210233f, -0.02257177f, -0.02844999f, -0.00712203f, -0.02352569f, -0.01105925f, 
    -0.03775081f, 0.01550571f, -0.01357200f, -0.00340815f, 0.00744820f, 0.01900821f, -0.01106178f, -0.02189993f, 
    -0.03249846f, 0.00799373f, -0.03183006f, 0.02223428f, -0.01884736f, -0.04116682f, -0.00395239f, 0.03151270f, 
    -0.03280751f, -0.00715950f, -0.01154697f, 0.01887365f, -0.03420582f, 0.00567288f, 0.01565570f, -0.00298957f, 
    -0.00800469f, 0.02622736f, -0.03459207f, 0.00433772f, -0.03788036f, -0.02466541f, 0.02609798f, -0.01559709f, 
    -0.03871923f, -0.00757000f, -0.02713636f, 0.03076319f, -0.04160799f, -0.01363799f, 0.00880953f, -0.00239698f, 
    0.00750664f, 0.00861029f, -0.02278614f, 0.00293514f, -0.00266764f, 0.01250761f, -0.03004636f, 0.00253758f, 
    -0.00439443f, 0.00253299f, -0.02224169f, -0.02132690f, 0.02101509f, -0.00546969f, 0.00901287f, 0.01730328f, 
    -0.00231107f, 0.01938529f, -0.03336059f, 0.01338702f, -0.02155300f, 0.03015737f, -0.02405332f, -0.03677336f, 
    -0.03285204f, -0.02192766f, -0.02714936f, -0.01859280f, -0.00851264f, -0.01669121f, -0.02026469f, -0.02880646f, 
    -0.01362159f, -0.03203686f, 0.00662845f, -0.01719907f, -0.02743049f, 0.00424014f, -0.01997489f, 0.00892197f, 
    -0.01195415f, -0.00747280f, -0.01417337f, 0.01371352f, -0.01088294f, -0.02959041f, 0.02623108f, -0.00739544f, 
    0.00662042f, -0.02681755f, -0.01441380f, -0.02196976f, -0.03012237f, -0.01427390f, 0.02964529f, 0.03703085f, 
    -0.02088111f, -0.02861305f, 0.01480946f, -0.03225421f, -0.03750976f, 0.00831300f, 0.00578297f, -0.00855783f, 
    -0.00131217f, 0.02468507f, -0.03654162f, 0.01594356f, 0.01319768f, -0.00070425f, -0.03723756f, 0.02003886f, 
    0.02641389f, -0.00122490f, 0.02849440f, 0.01495638f, -0.01271659f, -0.00943033f, -0.02388056f, -0.03819453f, 
    -0.01325134f, -0.03085181f, 0.02831222f, 0.01393882f, 0.02523584f, -0.01235438f, -0.00134163f, -0.02154357f, 
    0.00454854f, -0.03242847f, -0.00771099f, 0.03242428f, -0.01913617f, 0.01899401f, 0.01839995f, -0.00744425f, 
    0.00095849f, -0.01452674f, -0.00319591f, -0.00578916f, -0.00846910f, -0.03453586f, -0.03154467f, 0.02312667f, 
    -0.03464815f, -0.00501205f, -0.02194854f, -0.02841578f, 0.02199308f, -0.01932356f, -0.02570338f, 0.03209921f, 
    -0.01659709f, -0.02088277f, 0.01772564f, 0.03867079f, -0.03851228f, 0.00314253f, 0.01882757f, 0.01167293f, 
    0.01843115f, -0.02285380f, -0.03621488f, -0.00684921f, 0.01954528f, 0.01132412f, 0.01953295f, 0.03160584f, 
    0.01049461f, 0.00848286f, 0.02141302f, -0.03445327f, 0.01097473f, -0.01396363f, 0.00519354f, 0.02482402f, 
    -0.01579496f, 0.01588054f, -0.01375661f, -0.01876473f, -0.01961279f, -0.00911101f, -0.01973569f, -0.00845931f, 
    0.02288094f, -0.01475272f, -0.02827502f, 0.02028694f, -0.02755092f, 0.03717951f, -0.02184645f, 0.02247097f, 
    -0.00066366f, -0.02878223f, -0.01676989f, -0.01383560f, 0.00329515f, 0.01401877f, 0.00427072f, 0.02843143f, 
    -0.01570993f, 0.01930928f, 0.01727583f, -0.01817144f, -0.00228816f, 0.01075550f, 0.00179491f, 0.02994167f, 
    -0.02748320f, -0.01052105f, -0.00426220f, -0.03399004f, 0.02454446f, -0.00159612f, -0.02201855f, 0.02549142f, 
    -0.01767750f, -0.00255080f, 0.00513196f, 0.00544913f, 0.02893606f, 0.02927780f, 0.02679634f, -0.01156649f, 
    -0.03075272f, 0.01818364f, 0.02794079f, 0.00015281f, -0.00667052f, -0.02840315f, 0.01019366f, -0.03177027f, 
    0.02345601f, 0.01084518f, -0.03806835f, 0.02363770f, 0.00732127f, 0.02407604f, -0.00540549f, -0.00069318f, 
    -0.01731534f, 0.02032408f, -0.00119016f, 0.01352206f, 0.00078654f, -0.01040112f, 0.02978995f, -0.01089896f, 
    0.02718920f, 0.02908400f, -0.02536379f, -0.02563101f, -0.03485000f, -0.01526228f, -0.03316434f, -0.00620749f, 
    -0.03681740f, 0.01660000f, -0.02884197f, 0.01354414f, -0.01649064f, 0.01220815f, -0.02974921f, 0.01313325f, 
    -0.00172407f, 0.01785525f, 0.00624746f, 0.00380791f, 0.03081669f, -0.00779687f, -0.02370010f, 0.01208922f, 
    -0.02456484f, -0.02587306f, 0.00349817f, 0.03505659f, -0.01031204f, 0.00540785f, -0.03588865f, -0.00914864f, 
    0.02661039f, -0.02866083f, -0.00879831f, 0.01807044f, -0.01987182f, 0.02765128f, -0.04067791f, 0.01439997f, 
    0.00299805f, -0.02747301f, 0.00034827f, -0.00725893f, -0.02641470f, 0.00829722f, 0.00487128f, 0.02591443f, 
    -0.03469576f, 0.02129169f, -0.03882052f, -0.03137831f, -0.00761227f, 0.02913444f, -0.01701683f, 0.02214703f, 
    0.00575956f, -0.00815089f, 0.00391335f, -0.03697954f, 0.02255541f, -0.03980799f, -0.00344867f, -0.02188244f, 
    0.00314317f, 0.01578009f, -0.01576603f, 0.01934198f, 0.02505841f, -0.02340673f, -0.02733881f, -0.02415249f, 
    -0.02416035f, -0.01168523f, -0.01123924f, -0.00365524f, 0.01714091f, -0.00296936f, -0.01738483f, 0.02240027f, 
    0.00324595f, 0.00337001f, -0.01033435f, -0.03645446f, 0.02690439f, 0.01728917f, 0.02015648f, -0.02649161f, 
    -0.01069644f, -0.03267451f, -0.01463688f, -0.00838514f, 0.02675300f, 0.01135519f, 0.03104127f, -0.02859081f, 
    0.00376411f, -0.01031383f, -0.02686641f, 0.03359869f, -0.02610328f, 0.03145943f, -0.00877393f, -0.01810487f, 
    0.03230699f, 0.00755155f, -0.02900693f, 0.01737422f, -0.01906181f, -0.03714415f, 0.01437659f, -0.00834158f, 
    -0.02780989f, -0.00007817f, -0.00445910f, -0.00016801f, -0.00450588f, 0.01211994f, -0.00103128f, -0.03558879f, 
    -0.00756589f, 0.00787370f, 0.00133571f, 0.02900084f, -0.00413707f, 0.03126256f, 0.01660186f, -0.03291324f, 
    -0.04106271f, -0.04449360f, -0.03760105f, -0.00259536f, 0.01509291f, 0.00411748f, 0.00326283f, -0.04330207f, 
    -0.02361887f, 0.02571251f, 0.00261549f, 0.01970423f, 0.01619179f, -0.01856662f, -0.01554452f, -0.03193270f, 
    -0.00357161f, -0.02917022f, -0.01018900f, -0.02670645f, -0.01904598f, 0.02595129f, -0.00270545f, 0.00976390f, 
    -0.01845548f, -0.01682772f, -0.03079754f, 0.00832741f, -0.02742982f, 0.03357482f, 0.02268314f, -0.00828116f, 
    0.03269541f, -0.00065249f, -0.02614210f, -0.02229764f, 0.03082399f, 0.01995869f, -0.03020882f, 0.01824848f, 
    0.00346167f, -0.03704035f, -0.00583271f, -0.00566120f, 0.00222942f, -0.02028569f, -0.02419369f, 0.02032053f, 
    0.00850710f, -0.03954769f, 0.00282939f, -0.01649215f, 0.00609637f, -0.01076357f, 0.02758512f, 0.01623849f, 
    0.01150315f, 0.00465564f, -0.00450617f, -0.00587541f, -0.04276040f, 0.00613004f, 0.03260580f, -0.03342971f, 
    0.00786719f, 0.00485022f, -0.02855004f, -0.00301386f, 0.01642646f, 0.00280200f, -0.01030732f, -0.01507943f, 
    -0.01841605f, -0.00478476f, -0.00162639f, 0.02466827f, 0.00621625f, 0.01682030f, 0.00674880f, 0.00584693f, 
    0.01711450f, -0.00214809f, 0.02498798f, 0.02708540f, -0.00954619f, -0.01534839f, 0.00806771f, 0.02589966f, 
    0.00270316f, 0.02683266f, 0.01824797f, -0.02785694f, 0.01176034f, 0.02170452f, 0.02488372f, -0.00662871f, 
    -0.04247797f, -0.04089324f, -0.00591249f, 0.03813451f, 0.01204809f, -0.00517912f, -0.02952324f, 0.03074735f, 
    -0.00015094f, 0.00299468f, 0.02062410f, -0.01608215f, 0.02589221f, -0.01438391f, 0.02797305f, 0.02421162f, 
    -0.00949228f, -0.03671543f, -0.02438730f, -0.03007196f, -0.01509130f, -0.00745811f, -0.00121309f, 0.02241357f, 
    0.03582330f, 0.01304195f, -0.02559832f, 0.00502295f, 0.01005626f, -0.01219992f, -0.00296173f, 0.01614933f, 
    -0.02869541f, 0.02711394f, 0.02392927f, -0.01639947f, -0.03488770f, -0.00612533f, -0.00106502f, -0.02223691f, 
    -0.04448415f, 0.03526743f, 0.02254274f, 0.01796500f, 0.01160720f, 0.02005859f, 0.00488143f, -0.01492411f, 
    0.02200173f, 0.00530014f, -0.01074436f, 0.02514834f, 0.02386338f, -0.01419854f, 0.02390784f, -0.00990841f, 
    -0.01878970f, -0.00866865f, -0.02255492f, 0.00533764f, 0.01437591f, 0.00008819f, -0.02782195f, -0.01335516f, 
    0.00071148f, 0.00136044f, 0.02183326f, 0.01478448f, -0.01320080f, 0.02253792f, 0.02207524f, -0.01334334f, 
    -0.01500617f, 0.00678728f, -0.02077957f, -0.03772379f, 0.03167147f, -0.03255309f, 0.03319673f, 0.00369610f, 
    -0.01234914f, 0.02411266f, 0.00583120f, -0.02600400f, 0.00439478f, 0.02843800f, -0.01241991f, 0.01639121f, 
    -0.02880780f, -0.00282362f, -0.04072789f, -0.00654869f, 0.00286225f, 0.01837167f, 0.03234028f, -0.00215732f, 
    -0.03619010f, 0.02553237f, 0.00793010f, -0.01437503f, -0.01680027f, 0.02458639f, -0.03465937f, -0.01831478f, 
    -0.03776102f, -0.00869486f, -0.02802396f, 0.01295543f, -0.03917377f, 0.01884127f, 0.03133040f, 0.03082543f, 
    -0.02257781f, 0.03117362f, 0.01402043f, 0.02498457f, -0.01016298f, -0.03203493f, 0.00868060f, 0.01840196f, 
    -0.02387241f, 0.00896990f, 0.01266338f, 0.01701638f, -0.00076424f, -0.04012653f, -0.02125215f, -0.01789465f, 
    0.00258055f, -0.00445043f, -0.01445856f, 0.01050470f, 0.02886569f, 0.01387302f, 0.01677582f, -0.03915397f, 
    -0.03638991f, -0.04297770f, -0.00659997f, 0.00076752f, -0.03087029f, 0.00909707f, -0.02379952f, 0.00444661f, 
    0.02909960f, -0.02494977f, -0.00844117f, -0.03184640f, 0.00255183f, -0.02004221f, 0.03675554f, 0.00501342f, 
    0.02956617f, -0.00893048f, -0.02955681f, 0.00325419f, -0.01899458f, -0.02327619f, 0.02639574f, 0.00158844f, 
    0.02935055f, -0.02961670f, -0.02917272f, 0.01930923f, 0.00988904f, -0.01455788f, -0.03096521f, -0.00977059f, 
    0.00718768f, -0.04118810f, -0.02602482f, 0.01420560f, 0.00976882f, 0.03049974f, 0.01037691f, -0.00399601f, 
    0.00158618f, 0.00235319f, -0.01254313f, -0.01999478f, -0.00361570f, 0.00253784f, 0.02603091f, 0.01644980f, 
    -0.01094796f, -0.01472491f, 0.00068228f, -0.01786359f, 0.02643448f, -0.00268772f, -0.03361348f, 0.01286587f, 
    -0.02538997f, -0.02180652f, -0.03879897f, 0.01740479f, 0.00622838f, -0.03673429f, -0.01774585f, 0.02719222f, 
    -0.01252198f, 0.02745080f, -0.00996657f, -0.00277784f, -0.01670503f, -0.02551161f, 0.01948401f, -0.03846817f, 
    -0.02010837f, 0.01351696f, 0.00036435f, 0.00588479f, -0.00355678f, -0.02877581f, -0.02861600f, 0.01843487f, 
    0.01419573f, 0.02594449f, 0.02552912f, -0.02050132f, -0.01934825f, -0.02766207f, 0.02899674f, -0.01888292f, 
    -0.01742437f, -0.00099358f, -0.00832567f, -0.03900677f, 0.00399844f, 0.01784927f, -0.03409925f, -0.03953050f, 
    -0.03541414f, -0.00246415f, -0.02590154f, -0.00451559f, 0.01047360f, -0.02925928f, 0.01695667f, 0.01431519f, 
    0.00457594f, 0.00557190f, 0.03261380f, -0.01660682f, -0.01737366f, -0.02422216f, -0.03740849f, 0.00603719f, 
    -0.03137457f, -0.03360593f, -0.00148751f, -0.00810145f, 0.00947233f, 0.02821702f, -0.00037538f, 0.01367575f, 
    0.00686645f, -0.03104411f, 0.01367359f, -0.00573509f, 0.01981718f, 0.00533289f, -0.01306698f, 0.00344154f, 
    -0.02632299f, -0.01615000f, -0.00563150f, -0.01028072f, 0.02260673f, 0.02422994f, 0.03069237f, 0.01457930f, 
    -0.01727679f, 0.01156872f, 0.02793553f, -0.03492783f, -0.02454446f, -0.00917860f, 0.01264330f, 0.00190666f, 
    0.00642122f, -0.02083470f, -0.02269831f, -0.03868907f, -0.02520450f, -0.01990424f, -0.01124148f, -0.01411002f, 
    0.01193864f, -0.03382101f, -0.03141763f, -0.01222503f, -0.02551727f, -0.02246201f, -0.04313695f, 0.01456991f, 
    0.00910721f, 0.02326163f, 0.03493118f, 0.02928478f, 0.01730658f, -0.01079209f, -0.02469516f, 0.02264362f, 
    0.01077628f, -0.00245636f, 0.01086526f, -0.02812042f, -0.04085122f, -0.02990311f, 0.01113689f, 0.01930124f, 
    -0.02783850f, -0.02760029f, 0.00913128f, -0.01320018f, 0.00967117f, 0.02168870f, -0.01244281f, 0.02785889f, 
    -0.00964739f, -0.03347610f, 0.01537698f, -0.02802455f, 0.01792065f, -0.03685590f, 0.01588512f, 0.02646616f, 
    0.00060401f, -0.02379712f, 0.02708967f, -0.03291435f, -0.01383323f, -0.03780694f, 0.02609390f, -0.03260506f, 
    0.01074617f, 0.01185407f, -0.01470638f, 0.00694215f, -0.04116208f, -0.02643823f, 0.02742518f, 0.00139548f, 
    0.01615341f, -0.03971963f, -0.02554687f, 0.01238184f, -0.04211842f, -0.02695636f, -0.00714209f, -0.00951146f, 
    0.03231397f, -0.00480202f, 0.00788381f, -0.03125595f, 0.00637571f, 0.00651149f, -0.03714355f, -0.03125061f, 
    -0.00775412f, -0.04267093f, -0.02184111f, 0.02193876f, -0.01266001f, -0.00355149f, 0.00593395f, 0.02578897f, 
    0.02395576f, 0.02224752f, -0.02510246f, 0.00232607f, 0.01926966f, -0.02817313f, -0.01670789f, -0.02078994f, 
    0.02129828f, -0.02183899f, -0.01273973f, 0.01674182f, -0.02804248f, 0.02827485f, -0.00294985f, -0.02684915f, 
    0.02337870f, -0.01518391f, -0.03693919f, 0.02876612f, 0.00486911f, -0.00488872f, 0.01841159f, 0.00631802f, 
    -0.00938280f, -0.00458770f, -0.01624282f, 0.00432359f, -0.02869632f, -0.00161518f, -0.03383511f, 0.01608430f, 
    -0.02231576f, 0.02634186f, -0.03883036f, 0.01594238f, 0.01450335f, -0.01069982f, -0.01424880f, 0.01999781f, 
    0.00584249f, -0.00791906f, -0.00005729f, -0.02320678f, -0.02953639f, -0.01592836f, -0.02438689f, -0.00440310f, 
    0.02837375f, 0.01001002f, -0.02573450f, -0.02302064f, 0.01909392f, -0.01995388f, -0.02427199f, -0.04129310f, 
    -0.02271574f, -0.02988354f, 0.02032742f, -0.02899408f, -0.04225069f, 0.00098405f, 0.02867176f, -0.03526160f, 
    -0.03298664f, -0.00091156f, -0.03411173f, -0.03916451f, -0.03559450f, -0.02537018f, -0.03548785f, 0.00546374f, 
    -0.02435120f, 0.00603578f, -0.01902005f, -0.02768071f, -0.03521990f, -0.00054566f, -0.02086476f, -0.00151438f, 
    -0.03456792f, -0.03792224f, -0.02085793f, -0.01300067f, 0.02775445f, -0.01170816f, 0.02586541f, 0.02563243f, 
    -0.03769977f, -0.03531041f, 0.00434705f, -0.02137822f, 0.01157489f, 0.01215566f, 0.00605456f, -0.03296344f, 
    0.01325588f, -0.00277294f, -0.01662243f, -0.00296096f, -0.03379966f, -0.01810929f, 0.01329447f, -0.03508259f, 
    0.00744919f, 0.00988557f, 0.00748437f, -0.02807350f, -0.02457029f, -0.03442688f, -0.04188864f, -0.00396248f, 
    0.02154572f, 0.02227892f, 0.00818574f, 0.02481270f, -0.03122551f, 0.00168483f, 0.01139686f, -0.00049354f, 
    0.02234185f, -0.03225660f, -0.02869818f, 0.02486800f, -0.03672507f, 0.01912019f, -0.02844797f, -0.00982304f, 
    0.02805624f, 0.03067112f, 0.02871910f, 0.01670804f, 0.01890671f, -0.01238164f, -0.01634748f, 0.00886094f, 
    -0.03866079f, -0.01358980f, -0.02766604f, -0.02157748f, -0.03179579f, 0.00471887f, -0.02373853f, -0.03976931f, 
    -0.00491303f, -0.02601562f, 0.00964035f, 0.01777947f, -0.03322858f, -0.01148172f, -0.03161260f, 0.02833919f, 
    -0.03047016f, -0.00625449f, -0.03507936f, 0.00191997f, 0.01887552f, -0.04260995f, -0.02056152f, 0.01798904f, 
    0.01378556f, -0.03120674f, -0.02550238f, 0.00248695f, -0.02338069f, 0.00159069f, 0.02446867f, -0.04045217f, 
    0.02672948f, 0.01066860f, -0.02505755f, -0.04170616f, 0.01229468f, 0.01542281f, 0.02787621f, 0.02662827f, 
    -0.03351799f, -0.02678990f, -0.03312292f, 0.00829707f, 0.02928098f, -0.04102817f, 0.00295292f, -0.03566737f, 
    -0.01219147f, 0.01697620f, -0.01853413f, 0.01629332f, -0.04196549f, 0.01835244f, 0.01150574f, -0.03304218f, 
    -0.03555844f, -0.01103504f, -0.00738518f, -0.02872794f, 0.00455766f, -0.00432749f, 0.00783999f, 0.01677289f, 
    0.01144772f, 0.00393966f, 0.02250690f, -0.02974583f, -0.04185160f, -0.02042161f, -0.04083491f, -0.02959538f, 
    -0.04282215f, -0.02805698f, -0.03587081f, 0.02542684f, 0.00353930f, 0.01874646f, -0.04145235f, -0.02960966f, 
    0.01945248f, -0.01158249f, -0.02293464f, -0.01200977f, -0.01731901f, -0.03713784f, -0.01463888f, 0.02007698f, 
    0.01503405f, -0.02523849f, -0.04116358f, 0.00258617f, 0.01143013f, -0.02865630f, -0.02256128f, -0.02028072f, 
    0.01191089f, 0.00817578f, 0.01073084f, -0.00279264f, -0.04120643f, 0.01577398f, -0.00526316f, -0.01129857f, 
    -0.01416948f, -0.02633379f, -0.04118258f, -0.00025851f, 0.03512438f, 0.00213315f, -0.00119001f, 0.01315122f, 
    -0.03710511f, -0.03527648f, 0.01207197f, -0.01958788f, -0.02394610f, -0.02356157f, -0.00476315f, -0.02331068f, 
    0.01623368f, -0.00024990f, 0.01616628f, -0.00409263f, -0.00445053f, -0.01500854f, -0.02127003f, -0.00627668f, 
    -0.00162569f, -0.03564243f, 0.00641577f, 0.01190202f, -0.02679993f, -0.00455530f, -0.02535344f, -0.00330614f, 
    0.01572960f, -0.01113479f, 0.01639139f, -0.01147041f, 0.02145274f, 0.00534841f, -0.02898573f, 0.02174219f, 
    0.00591546f, 0.01934659f, 0.00551065f, -0.00681240f, -0.02198670f, 0.01257072f, 0.01605862f, -0.00878011f, 
    0.00816391f, 0.02525520f, -0.02619146f, -0.00370245f, -0.00974731f, -0.01849950f, -0.02277275f, 0.02671110f, 
    0.00975062f, 0.02859997f, 0.01844778f, 0.00195279f, -0.00317774f, 0.00547272f, -0.03429258f, -0.02869383f, 
    -0.00682072f, 0.01023993f, -0.00762645f, -0.03993337f, -0.02436717f, -0.02962082f, -0.02272277f, -0.02449840f, 
    -0.02199884f, -0.00195739f, 0.02691825f, -0.01367732f, -0.02988136f, 0.00095170f, 0.01497444f, -0.02740010f, 
    -0.00142715f, 0.02605809f, 0.00616823f, -0.01516677f, -0.01833781f, 0.02176692f, -0.02048879f, 0.00631370f, 
    -0.03118977f, 0.00850613f, 0.00479441f, -0.01896634f, -0.00269332f, -0.03679322f, 0.02314649f, -0.03572766f, 
    -0.00015622f, -0.02864602f, 0.01610650f, 0.03034318f, 0.02346833f, -0.02848028f, -0.01829535f, 0.02154370f, 
    0.01492169f, 0.01645376f, 0.01355448f, -0.03630377f, 0.00301246f, 0.02475658f, 0.02544619f, 0.01791861f, 
    0.00633931f, 0.01147594f, 0.00832999f, -0.01075222f, 0.02818754f, 0.00205090f, -0.01313103f, 0.02180002f, 
    0.01790149f, 0.01369886f, 0.01513539f, -0.03766359f, 0.02632023f, -0.02567662f, -0.03167242f, -0.01453283f, 
    -0.01937710f, -0.04050427f, -0.02184821f, -0.01510088f, -0.02842459f, 0.02789606f, -0.03014112f, -0.01499677f, 
    0.02361541f, -0.01254043f, -0.03645805f, -0.01306534f, 0.02291810f, 0.01194635f, -0.01440880f, -0.01494797f, 
    -0.01103993f, -0.00320070f, -0.01510023f, -0.00706294f, -0.00504893f, -0.01673666f, -0.02501524f, -0.03487168f, 
    -0.00375812f, 0.00183517f, -0.03362749f, -0.03898376f, 0.02269472f, -0.03415297f, -0.00418725f, -0.00835030f, 
    -0.03741128f, -0.00770742f, 0.02047706f, 0.02455495f, -0.03508674f, -0.02356675f, -0.03932306f, 0.01225580f, 
    0.00189119f, -0.02544695f, -0.02662078f, 0.00885102f, -0.03830389f, -0.00253250f, 0.00117324f, -0.00211133f, 
    0.00948498f, -0.03317472f, 0.02218705f, 0.01964961f, 0.00618354f, -0.02280316f, -0.00766387f, -0.03572398f, 
    -0.00298528f, -0.03917560f, -0.04181029f, -0.01919438f, 0.00198054f, -0.02917082f, -0.03627500f, 0.00487518f, 
    0.00165024f, -0.00078742f, -0.00146658f, -0.01493595f, 0.02101393f, 0.01709932f, -0.00464735f, -0.02429410f, 
    0.00229009f, -0.03767444f, -0.00450870f, -0.02403734f, 0.02219624f, -0.04283281f, 0.01727293f, 0.02685083f, 
    -0.02740593f, -0.02186843f, -0.03193588f, 0.01754988f, 0.01226750f, -0.01260839f, 0.00922233f, -0.02493001f, 
    -0.03705325f, 0.01585367f, -0.03886105f, -0.03927454f, -0.00143392f, 0.00844818f, -0.04234834f, -0.03557107f, 
    -0.00694577f, 0.01431743f, -0.02386943f, 0.02736605f, -0.01494175f, 0.00596578f, -0.00262985f, -0.03769574f, 
    -0.02059177f, 0.00833347f, -0.02349276f, -0.02534987f, 0.00381674f, -0.01029411f, -0.03812978f, -0.02330268f, 
    -0.00645208f, 0.02681941f, 0.01404527f, -0.01629720f, -0.00326349f, -0.00265082f, -0.03407565f, 0.00451195f, 
    -0.00898731f, -0.03277082f, 0.00156973f, -0.03898019f, 0.01138992f, -0.03386433f, 0.02502691f, -0.02220977f, 
    -0.03629490f, -0.03053274f, -0.00724538f, -0.00798986f, -0.01528948f, -0.01986467f, -0.03986013f, 0.00407596f, 
    0.02779774f, 0.00240688f, 0.00682798f, -0.00953779f, 0.02365517f, 0.01450919f, 0.00016940f, -0.00085963f, 
    -0.01523325f, -0.03195482f, -0.01148561f, -0.00083484f, 0.01732041f, -0.03739475f, 0.01880949f, -0.01306824f, 
    0.01143743f, 0.02503136f, -0.01732910f, -0.02863171f, -0.03137764f, 0.02821444f, -0.04273602f, 0.00830455f, 
    0.01443179f, -0.02542157f, 0.01756688f, -0.03737079f, -0.03536428f, -0.01043991f, -0.03636918f, -0.02477974f, 
    0.01094364f, 0.00895115f, -0.02668602f, -0.03728485f, 0.00632047f, -0.00775416f, -0.01084541f, -0.02164762f, 
    -0.03943612f, -0.03664099f, -0.03242449f, -0.03941707f, -0.03200833f, 0.02826471f, -0.01431842f, -0.01292693f, 
    0.00875545f, 0.02752554f, 0.01487852f, 0.01591780f, -0.03161603f, 0.01230584f, -0.01231867f, 0.02708423f, 
    -0.03126692f, 0.02272407f, -0.03043635f, -0.01822638f, 0.00777608f, -0.01009938f, 0.00483598f, -0.01559872f, 
    -0.02562413f, -0.00715714f, -0.01021046f, 0.00219864f, 0.01714154f, -0.02225777f, -0.01174258f, 0.02004384f, 
    -0.03888449f, -0.01258516f, 0.02475421f, -0.00822668f, 0.02007683f, -0.00750230f, 0.02749703f, 0.01335291f, 
    0.00062017f, -0.02496296f, -0.00219314f, -0.01561927f, -0.03991090f, -0.03695313f, 0.02482000f, -0.02857518f, 
    0.00183396f, -0.01901287f, -0.00425181f, -0.03108369f, -0.00678285f, -0.04163747f, -0.02423235f, -0.02521586f, 
    -0.03438676f, -0.03914721f, -0.03825934f, -0.00593922f, -0.03961372f, -0.00445074f, 0.00615368f, 0.01665118f, 
    -0.03485758f, 0.01647389f, -0.02524736f, 0.02175438f, 0.00238794f, -0.00196110f, 0.01656104f, 0.01105591f, 
    -0.01573233f, -0.02639080f, -0.01550474f, 0.02043162f, -0.03639754f, -0.01467162f, 0.00954883f, 0.02043398f, 
    -0.04276957f, 0.00914825f, -0.00885720f, 0.00509384f, -0.01850411f, -0.02887276f, -0.01037472f, -0.03050787f, 
    -0.00777198f, 0.00744078f, -0.04032009f, 0.00969086f, -0.00695995f, -0.00130755f, 0.01777577f, -0.00676794f, 
    -0.01107673f, -0.00788903f, 0.00581781f, -0.03536119f, -0.01737521f, -0.03340892f, 0.00274099f, -0.02264233f, 
    0.00873608f, -0.00117889f, -0.02540867f, -0.02738084f, 0.01882788f, 0.01395334f, -0.00389231f, -0.02974045f, 
    0.01723104f, 0.02638447f, -0.02186255f, -0.01797913f, 0.01303309f, 0.02691381f, -0.01072974f, -0.03135290f, 
    0.02448504f, -0.03387410f, 0.02246162f, 0.02077190f, -0.00793062f, 0.02220969f, 0.02139593f, -0.03499799f, 
    -0.03034756f, -0.01876726f, 0.02346350f, -0.01548614f, -0.01996323f, 0.02746201f, -0.00049906f, 0.02066338f, 
    0.01185016f, 0.02251335f, -0.01796886f, 0.01111808f, 0.01596935f, -0.03852798f, -0.00258773f, -0.02195113f, 
    -0.00973095f, 0.01661138f, 0.02803815f, -0.00771786f, 0.01060859f, 0.01224227f, 0.00731822f, -0.01198008f, 
    -0.01043330f, -0.02176560f, 0.00797815f, 0.02517454f, -0.01888893f, 0.02490600f, 0.01245848f, -0.02543230f, 
    -0.01572554f, -0.00054053f, -0.03581246f, -0.01116645f, -0.04172996f, -0.01520146f, -0.04068639f, -0.00314539f, 
    -0.03357845f, -0.03296270f, -0.01850566f, -0.02519700f, -0.01790459f, -0.00099150f, -0.00865496f, -0.01518980f, 
    -0.02966150f, -0.01926279f, -0.00048839f, 0.01020320f, 0.00763033f, 0.00628730f, -0.00676849f, 0.02582607f, 
    0.02620246f, 0.00108864f, -0.01036262f, 0.00196263f, 0.02874956f, -0.04081791f, -0.00852886f, -0.03303193f, 
    -0.00485947f, 0.01808896f, -0.02917103f, 0.00634911f, 0.03910260f, 0.03266487f, 0.03187364f, 0.01976989f, 
    -0.03257094f, 0.02318591f, 0.02891172f, -0.03185444f, -0.00607426f, -0.01476483f, 0.02730517f, 0.03609478f, 
    0.01460796f, 0.00590408f, 0.00254672f, -0.01260974f, -0.04140468f, 0.03643863f, -0.01292625f, -0.00579915f, 
    -0.02244329f, -0.01280202f, -0.03536310f, 0.02355278f, -0.02763876f, 0.01835637f, -0.03700430f, -0.04098078f, 
    -0.03590195f, 0.03548078f, -0.03487059f, 0.00106308f, -0.01999848f, 0.01283148f, -0.02435221f, 0.00946887f, 
    0.02700354f, 0.00984980f, -0.00508271f, 0.00318862f, -0.02875282f, -0.01193064f, 0.03080712f, -0.03153855f, 
    -0.04115688f, 0.03185179f, 0.00770130f, 0.03796390f, 0.01234898f, 0.01627965f, -0.03765415f, 0.02930704f, 
    -0.02990720f, -0.03260879f, 0.01427564f, -0.00853702f, -0.03729224f, 0.01455517f, -0.01346065f, 0.04155731f, 
    0.01743889f, 0.01977728f, -0.03006253f, -0.03223083f, 0.01886094f, -0.03285835f, 0.03769448f, 0.00245955f, 
    -0.03539801f, 0.01756093f, -0.02960972f, -0.02641914f, 0.02777839f, -0.03890981f, -0.01878445f, 0.02790318f, 
    -0.01726566f, -0.00991601f, -0.01036368f, 0.00207085f, -0.03185156f, -0.00685294f, 0.02998008f, 0.00054573f, 
    -0.02758848f, -0.02270309f, 0.02169482f, -0.00715908f, -0.01827191f, 0.00622307f, 0.03771144f, -0.01961633f, 
    0.01196736f, 0.01604597f, 0.02694080f, -0.03639773f, -0.01830289f, 0.01403776f, 0.01642456f, 0.00325281f, 
    0.00580061f, -0.00901079f, -0.02130759f, 0.01377444f, -0.03203249f, 0.00561631f, -0.02869508f, 0.00834640f, 
    0.01071480f, -0.02553645f, -0.00396063f, 0.02532049f, -0.02008751f, -0.02191174f, -0.02564117f, -0.00357604f, 
    0.02988380f, 0.01506304f, -0.00325436f, 0.01582939f, -0.01241866f, 0.01605278f, -0.00599979f, -0.00743175f, 
    0.02541286f, 0.00186167f, -0.00962352f, -0.00819586f, -0.00425771f, 0.01691755f, -0.04161384f, -0.00497890f, 
    0.01105204f, -0.00278032f, 0.00702275f, -0.03670548f, 0.02088196f, 0.02898510f, -0.01623522f, -0.02512790f, 
    -0.03678832f, 0.02764062f, 0.00058296f, -0.02846345f, 0.00217480f, -0.01882477f, 0.02394352f, -0.03142972f, 
    -0.02462672f, 0.00741266f, 0.02569921f, 0.00029849f, 0.00944034f, -0.02699537f, 0.01526347f, 0.01770307f, 
    0.00281678f, 0.02065426f, -0.01878256f, -0.01213809f, 0.02790108f, -0.01233928f, 0.03657001f, 0.01214080f, 
    0.02782113f, -0.00730071f, -0.02416533f, -0.01351043f, -0.00565316f, -0.02307348f, -0.03677369f, -0.00937864f, 
    0.00648105f, 0.00307021f, 0.01746043f, 0.02595803f, -0.01201999f, 0.00085052f, -0.03858541f, 0.02634381f, 
    0.01232501f, 0.00624804f, -0.02669945f, -0.02635829f, -0.00347774f, 0.02358076f, -0.01769477f, 0.01894446f, 
    -0.03704100f, 0.02736238f, -0.03531008f, 0.03495239f, -0.01617848f, 0.02047965f, -0.02040750f, -0.00526148f, 
    -0.02540009f, -0.00087405f, -0.02211059f, 0.00938040f, -0.00554101f, -0.01968802f, 0.00724411f, 0.01456782f, 
    0.00527394f, -0.03759020f, -0.01855107f, 0.02557035f, 0.03687839f, -0.03996302f, 0.01535592f, -0.00071945f, 
    -0.00304407f, -0.03507774f, -0.02824854f, -0.00546117f, -0.00258573f, 0.01786431f, 0.00368970f, 0.02698930f, 
    0.02091906f, -0.02885916f, -0.02242278f, -0.00641106f, -0.02013980f, 0.03615894f, -0.03404913f, -0.01758838f, 
    -0.01149463f, -0.02162659f, 0.01853286f, -0.02073217f, 0.01735411f, -0.02160020f, 0.02128163f, -0.01968457f, 
    -0.03504776f, 0.03516050f, 0.02337145f, -0.00406689f, 0.01553657f, -0.01311509f, 0.00543510f, 0.02404625f, 
    -0.03532045f, 0.00866263f, -0.02808407f, 0.02045081f, -0.02976979f, 0.01819670f, -0.00867940f, -0.02295939f, 
    -0.01064884f, -0.01540226f, -0.03134442f, -0.01855352f, -0.03299447f, -0.02274974f, -0.03942432f, 0.01729488f, 
    -0.01291445f, 0.03819506f, -0.01348783f, -0.02775030f, -0.01530430f, -0.03021730f, -0.01103702f, 0.00598424f, 
    -0.00684250f, 0.01549076f, -0.02068555f, -0.04199033f, 0.00463598f, 0.02288591f, -0.02201634f, -0.00832646f, 
    0.02530881f, 0.02342502f, -0.01576682f, -0.04154163f, 0.02033607f, -0.02206279f, -0.01646924f, -0.01485464f, 
    0.01585829f, -0.02188063f, 0.02343939f, 0.00665398f, 0.01101532f, -0.01967835f, 0.02936169f, -0.00861164f, 
    -0.03013424f, -0.01019747f, -0.01633128f, -0.01076582f, 0.01221015f, -0.01853222f, 0.02073658f, 0.03896932f, 
    -0.00001143f, 0.00653611f, -0.01246381f, -0.01183645f, -0.02041677f, 0.00207435f, -0.00863495f, -0.01734582f, 
    0.02086198f, 0.01004865f, -0.01949675f, 0.01853469f, -0.01370925f, -0.03486890f, -0.03223865f, 0.01812324f, 
    -0.04080648f, 0.02575927f, 0.02202862f, -0.02382737f, 0.00566856f, 0.01145876f, -0.02651714f, 0.01114843f, 
    -0.02332295f, -0.02265795f, -0.02900100f, 0.01155444f, -0.03927291f, -0.01814817f, 0.02823223f, 0.02285106f, 
    0.01549956f, -0.01441831f, 0.01792777f, -0.02790450f, 0.00782009f, 0.02203216f, -0.01053097f, -0.00923724f, 
    0.01063142f, -0.02654656f, 0.01099510f, 0.02939399f, -0.03227348f, -0.03935547f, -0.03434290f, -0.04009705f, 
    0.00459458f, 0.02035262f, -0.00981813f, 0.00050878f, 0.02084482f, -0.04041638f, -0.01664757f, 0.00453573f, 
    0.00723443f, 0.01008839f, -0.01315775f, -0.00969108f, -0.01081249f, -0.01497023f, -0.01024642f, 0.03588328f, 
    0.01037675f, -0.02030284f, -0.02360235f, 0.01893681f, -0.00863731f, -0.02794896f, -0.02053449f, 0.00591670f, 
    -0.03228055f, -0.01857769f, -0.00823855f, -0.01400546f, 0.02231753f, 0.01722262f, 0.01142279f, -0.00800752f, 
    -0.01930285f, 0.03330552f, -0.02804432f, 0.01951295f, -0.01915995f, -0.00686076f, 0.00253854f, 0.02404704f, 
    -0.03764978f, 0.02169605f, -0.03616876f, 0.00941874f, 0.00064897f, 0.02704385f, -0.01867808f, 0.03025923f, 
    0.02304826f, 0.02713188f, -0.03146180f, -0.00339668f, -0.02371637f, -0.02392896f, 0.00636348f, -0.02716726f, 
    0.00884418f, -0.01862290f, -0.02558023f, -0.03886638f, 0.03680348f, 0.01579772f, -0.00484336f, -0.02444860f, 
    0.02792205f, -0.02278898f, -0.00554520f, 0.02439561f, 0.02590210f, 0.00107481f, -0.00928793f, -0.02888435f, 
    -0.03697307f, -0.03600425f, -0.02203200f, 0.01484875f, -0.02826461f, -0.03833274f, 0.02006791f, -0.02767314f, 
    -0.03593363f, -0.02666927f, -0.00131814f, 0.02424972f, 0.01618970f, 0.02395860f, 0.00352460f, -0.01046634f, 
    -0.01969049f, -0.01337540f, 0.01399228f, -0.02722108f, -0.02979231f, -0.01819491f, -0.00377763f, -0.03745620f, 
    0.00174031f, -0.00798244f, 0.01485723f, -0.02782755f, -0.01045277f, -0.01751563f, 0.02379477f, -0.00849164f, 
    0.00895709f, -0.01403960f, -0.03040263f, -0.01087938f, 0.01137974f, 0.00884215f, 0.02997993f, -0.02680918f, 
    -0.00768979f, -0.02025367f, -0.03045956f, -0.01584141f, -0.03994603f, -0.04123876f, 0.00685754f, -0.02290813f, 
    0.01866240f, 0.02162791f, -0.01000337f, -0.00335895f, -0.00423492f, -0.00772343f, 0.01964818f, -0.02744466f, 
    0.01644743f, 0.01139192f, -0.00426452f, -0.04020201f, -0.02738036f, -0.02769185f, -0.01779097f, -0.01216771f, 
    0.02599081f, 0.03584081f, -0.01089715f, 0.02039670f, -0.01264831f, -0.01792030f, 0.00938533f, 0.00415362f, 
    0.00510916f, -0.00810935f, -0.03974256f, -0.00278025f, -0.01331177f, -0.02525806f, -0.00578135f, 0.00639642f, 
    0.00697083f, 0.03998930f, 0.02094744f, 0.00779409f, 0.01147820f, 0.01075058f, -0.00611210f, 0.00304159f, 
    -0.01740351f, -0.03066885f, -0.00266973f, 0.02226906f, -0.01724863f, -0.00673636f, 0.01967634f, -0.01508417f, 
    -0.01963867f, -0.01635015f, -0.00756401f, -0.02192252f, 0.00685045f, 0.02355502f, 0.00190403f, 0.04126506f, 
    0.02671045f, -0.01584738f, -0.03625803f, 0.01294223f, -0.00413958f, -0.01812227f, -0.01892293f, 0.00711018f, 
    0.01026986f, 0.01742571f, 0.00540849f, 0.02326208f, -0.02573922f, -0.02010391f, -0.01787907f, 0.00255216f, 
    -0.03548793f, -0.00842025f, -0.03245037f, 0.01784480f, -0.00852790f, -0.00868011f, 0.02029776f, 0.01011841f, 
    -0.02589843f, -0.02989252f, -0.03422090f, 0.00231731f, -0.04160394f, -0.01289963f, 0.00210004f, 0.02553476f, 
    -0.00691101f, -0.03736780f, -0.02657693f, -0.01335388f, -0.00044984f, -0.00985628f, -0.01000670f, -0.01899737f, 
    0.01118111f, 0.00795331f, -0.01123916f, -0.00325448f, -0.03741926f, 0.01733268f, 0.02016069f, 0.00535039f, 
    0.00732989f, -0.01558176f, -0.00221624f, 0.02141147f, -0.00095092f, -0.00075365f, 0.02517321f, -0.01223531f, 
    -0.03239991f, 0.04024406f, -0.00688210f, 0.00157525f, 0.02942454f, 0.00138471f, -0.02996498f, -0.02286744f, 
    -0.02196328f, -0.00445914f, -0.00161185f, 0.01070519f, -0.00151519f, -0.01333354f, -0.00175575f, -0.01721746f, 
    0.01721288f, 0.01667583f, -0.03387027f, 0.00481313f, -0.00728866f, 0.01348811f, 0.01641149f, -0.01310430f, 
    -0.02655283f, 0.03279519f, 0.00096616f, -0.01796329f, -0.03372771f, -0.00252886f, -0.00145717f, 0.00070491f, 
    0.00942584f, -0.02171037f, -0.03262462f, -0.03666437f, -0.01954189f, 0.02649350f, 0.00495258f, 0.00598690f, 
    0.01781591f, -0.01789355f, 0.00625180f, -0.00328701f, -0.01200427f, 0.00557115f, -0.01345336f, -0.01459396f, 
    0.02952045f, 0.01911991f, -0.03465623f, -0.02013471f, -0.00296362f, -0.01033769f, -0.02854267f, -0.00610621f, 
    0.00400639f, -0.01463596f, -0.00493756f, 0.02618770f, -0.03857752f, -0.01626529f, -0.02793677f, -0.00055790f, 
    0.01736159f, -0.00992878f, 0.00017429f, -0.00869686f, 0.00756533f, -0.00146029f, -0.02745799f, -0.00449986f, 
    -0.01275513f, 0.02137309f, -0.00365413f, 0.01385941f, -0.01021586f, -0.00889983f, -0.00976315f, -0.00962468f, 
    -0.03195259f, -0.02113056f, 0.00996079f, 0.00685927f, -0.02076118f, 0.02190090f, -0.02059330f, 0.02784275f, 
    -0.00205485f, 0.01250591f, -0.00137049f, 0.00594335f, 0.02775061f, -0.02782476f, -0.01083385f, -0.03408639f, 
    -0.01020518f, -0.02113274f, -0.03586334f, 0.01617085f, 0.00245928f, -0.01857872f, -0.01434143f, 0.02648618f, 
    0.00533983f, -0.02611839f, 0.00008138f, 0.01038125f, -0.00138623f, 0.00198721f, 0.01267937f, -0.03093494f, 
    -0.03286710f, 0.00646411f, -0.02632585f, 0.00215710f, 0.01785938f, -0.00550590f, 0.00221872f, -0.00893273f, 
    0.00927550f, -0.00279433f, -0.03586463f, 0.00390490f, -0.03740740f, -0.02610398f, 0.04163391f, 0.02963741f, 
    -0.03585136f, 0.00807522f, 0.00958026f, 0.00494276f, 0.00306859f, 0.00765725f, 0.02288082f, -0.01990552f, 
    0.00431141f, -0.00749736f, -0.00566313f, 0.02382228f, -0.00022126f, 0.03884001f, 0.03474176f, 0.01233643f, 
    0.01978761f, 0.00143242f, -0.02749595f, 0.01342025f, -0.03373652f, -0.01402359f, 0.02849571f, 0.01316838f, 
    -0.02705111f, 0.00264737f, -0.00150526f, -0.01118939f, -0.04022897f, -0.03689505f, -0.00153295f, -0.01584055f, 
    -0.01569434f, -0.02571438f, -0.00604591f, -0.01911628f, 0.00343149f, 0.04148379f, 0.02397852f, -0.03470642f, 
    -0.00511593f, -0.00348420f, -0.03568228f, 0.00697760f, -0.02955719f, -0.00950166f, -0.00890288f, 0.01785912f, 
    0.20017204f, -0.16108610f, -0.17175338f, -0.02261747f, 0.08508165f, -0.01439590f, -0.12211787f, -0.09493539f, 
    0.02705948f, 0.00366285f, 0.13738234f, 0.03851453f, 0.18893154f, -0.07241651f, -0.09782679f, 0.08398021f, 
    -0.05664151f, 0.09847570f, 0.10728290f, 0.06976545f, 0.02199792f, -0.07698955f, -0.04824659f, -0.09502809f, 
    -0.05843457f, -0.08912980f, -0.00034185f, 0.05681297f, -0.04990168f, 0.16366406f, 0.12314152f, 0.06870691f, 
    0.09177097f, -0.04032707f, 0.09281475f, 0.01607041f, -0.03968510f, -0.17165066f, 0.03642554f, 0.02166855f, 
    0.05679109f, -0.00718117f, 0.01292904f, -0.17602274f, -0.07529503f, 0.09544381f, -0.09985874f, 0.02017602f, 
    0.05109951f, -0.11792658f, 0.22619279f, 0.19595498f, 0.04828807f, 0.06581470f, 0.14967151f, -0.04515322f, 
    -0.04893581f, -0.04320444f, 0.17095114f, 0.18417391f, -0.11407304f, -0.06071154f, -0.00437080f, -0.03008183f, 
    -0.04543026f, 0.01897388f, 0.05604301f, -0.02624712f, -0.03157755f, -0.01147818f, -0.00402306f, -0.13513491f, 
    -0.06924544f, 0.09068029f, 0.32129526f, 0.26020789f, 0.00786069f, 0.08413730f, 0.04426193f, 0.16133595f, 
    0.04772159f, 0.06166989f, 0.14860186f, 0.11536478f, 0.02289875f, -0.04379019f, -0.08228171f, -0.02293894f, 
    -0.00333692f, 0.09102520f, 0.01723471f, 0.00095369f, 0.07784163f, 0.01342219f, 0.00280120f, 0.17336784f, 
    0.10116441f, -0.00533556f, -0.10558178f, 0.10577785f, 0.01987113f, 0.11829571f, -0.00125812f, 0.09584955f, 
    0.02841823f, -0.13826227f, -0.09080324f, 0.10222299f, 0.15422456f, 0.10041300f, -0.04435465f, 0.16469771f, 
    0.01662576f, -0.10177004f, 0.07412065f, 0.00829987f, 0.04237293f, 0.05713727f, -0.04726186f, 0.01416003f, 
    0.04437989f, -0.20822102f, -0.16897659f, -0.17680605f, -0.03631157f, -0.04272784f, 0.01014240f, -0.03824030f, 
    -0.01748737f, -0.01526473f, -0.04622827f, 0.03330455f, 0.33962747f, 0.09851002f, -0.18979320f, 0.05864206f, 
    0.11955609f, -0.05580169f, -0.05825587f, 0.04020274f, -0.04533126f, -0.08750202f, 0.06698844f, 0.08305798f, 
    0.25931287f, -0.07023402f, -0.16906953f, 0.18235296f, 0.00697720f, -0.09352092f, 0.06694470f, 0.10454036f, 
    -0.02501005f, -0.00027324f, 0.15331265f, 0.03448778f, 0.06470841f, -0.17828925f, -0.00246994f, 0.14301693f, 
    0.04312066f, -0.05361844f, -0.05488039f, -0.04774926f, 0.06630565f, 0.04131692f, 0.05399231f, 0.06789295f, 
    -0.16085398f, 0.24132094f, 0.15015948f, 0.06023061f, 0.05902984f, -0.01548324f, -0.04719167f, -0.00208099f, 
    0.14129892f, 0.08804826f, -0.13626249f, 0.11022411f, 0.15988374f, -0.06087594f, 0.13228446f, 0.05459503f, 
    0.08396961f, 0.06777980f, -0.12905785f, -0.00065700f, 0.12444275f, -0.07157694f, -0.03340447f, -0.03640743f, 
    0.11816800f, -0.06946364f, -0.02051442f, 0.01380720f, 0.04604225f, -0.07826938f, 0.00336576f, -0.07608894f, 
    0.05095790f, 0.06721860f, -0.19357125f, 0.02976369f, -0.23713940f, 0.19566976f, 0.07881188f, -0.26052654f, 
    -0.05842813f, -0.01497227f, 0.02024044f, 0.03407414f, -0.05947598f, -0.10072006f, 0.01390113f, -0.32383665f, 
    0.19787413f, 0.20565811f, -0.11478822f, 0.18916085f, 0.02968044f, 0.02393269f, 0.00803340f, -0.05208695f, 
    0.05035013f, -0.01161079f, 0.12468413f, 0.15079726f, 0.03519233f, -0.30731311f, 0.11674198f, 0.14008750f, 
    0.04141944f, -0.01925419f, -0.03722176f, -0.11387006f, -0.04071366f, -0.02873492f, -0.00279171f, 0.08994972f, 
    0.41408303f, -0.11421178f, -0.12288321f, 0.01581349f, 0.10345863f, 0.01060693f, -0.07875669f, 0.03759485f, 
    0.11008976f, 0.03274605f, 0.04697230f, 0.01083539f, 0.33207983f, 0.03157131f, -0.09809667f, 0.00414720f, 
    0.03974461f, 0.02303138f, -0.03435261f, 0.08044502f, 0.22784288f, -0.00230142f, 0.07280530f, -0.07835274f, 
    0.42019004f, 0.12454066f, -0.17346843f, 0.02166689f, -0.11795089f, 0.05180328f, -0.06331597f, -0.08701067f, 
    0.02944885f, -0.05353009f, -0.06510986f, 0.03722094f, 0.19476885f, 0.03709417f, -0.20274992f, 0.01344341f, 
    0.11741529f, 0.06805719f, -0.06120102f, -0.09900670f, 0.05754380f, -0.13023704f, 0.03095924f, 0.07965049f, 
    -0.06858116f, 0.04059071f, 0.09664086f, 0.09423780f, 0.05831025f, -0.01551759f, 0.19718014f, 0.15570004f, 
    0.12265290f, -0.01363156f, -0.09641825f, -0.11124774f, 0.05808773f, 0.03557735f, 0.16850045f, -0.09417666f, 
    0.07490816f, 0.16361180f, 0.02082548f, 0.10540950f, 0.05864290f, 0.01570608f, 0.10361227f, 0.10342950f, 
    0.02606099f, 0.05947616f, -0.05274596f, -0.03695146f, -0.09510604f, -0.00007564f, -0.04628280f, -0.00356403f, 
    -0.02467441f, 0.16310579f, 0.08022352f, -0.02974970f, 0.12941171f, 0.09156004f, -0.02671247f, 0.19981921f, 
    0.03331590f, -0.09612359f, 0.03883299f, 0.04355661f, -0.00112563f, 0.08242581f, -0.16845484f, 0.07472553f, 
    0.06496195f, -0.02594943f, 0.05944888f, 0.15584096f, 0.06015027f, -0.15330078f, 0.02010251f, 0.06934241f, 
    0.04502192f, 0.02052020f, 0.08372734f, 0.14212395f, -0.00741954f, -0.24409790f, -0.03741302f, 0.16229060f, 
    0.06822859f, 0.10646196f, 0.10048830f, 0.00075325f, 0.11317067f, -0.01055381f, -0.05159629f, 0.00239116f, 
    0.20249254f, 0.11271519f, -0.16944934f, -0.00290860f, -0.07794392f, 0.16109100f, -0.05060926f, -0.05799372f, 
    -0.02283122f, -0.06684220f, -0.00385194f, 0.09996721f, -0.02069433f, 0.03490967f, 0.19923270f, 0.10784171f, 
    0.02881800f, 0.08107963f, 0.09641274f, 0.08416912f, 0.05263639f, -0.01360993f, -0.05386843f, -0.06065822f, 
    -0.36924717f, -0.04515247f, 0.27801141f, 0.16497801f, 0.01526067f, -0.04000201f, -0.09017438f, 0.05517138f, 
    0.01830604f, 0.06341443f, 0.12825672f, 0.08356140f, -0.06512035f, 0.09905849f, 0.07152183f, 0.05429021f, 
    0.01275418f, -0.13041939f, -0.09012519f, 0.00701459f, -0.01077428f, 0.02718645f, 0.08126958f, -0.11471251f, 
    0.24722047f, -0.21000119f, -0.12151271f, 0.27289444f, 0.06694870f, 0.12849951f, 0.04878296f, -0.02663909f, 
    -0.01114106f, -0.05629902f, -0.02269895f, 0.03991544f, 0.18558021f, 0.05624565f, -0.10885151f, 0.02279490f, 
    -0.02768200f, -0.03577094f, -0.15595086f, 0.03862424f, 0.17375052f, -0.00445753f, 0.02411189f, 0.05111097f, 
    -0.13025503f, -0.09655673f, 0.10790906f, 0.00825296f, 0.08765659f, -0.07295828f, 0.21597183f, -0.06893431f, 
    -0.06815255f, -0.03224574f, 0.03605924f, 0.20537762f, -0.14691204f, -0.02863051f, 0.13002114f, 0.04573701f, 
    -0.04016823f, -0.10262227f, -0.08651797f, 0.03232186f, 0.00222197f, 0.09665379f, -0.00447386f, 0.08587270f, 
    0.19477755f, 0.07562062f, -0.14356618f, 0.12008312f, 0.02630888f, 0.00872642f, -0.06131106f, 0.05600739f, 
    0.06338239f, -0.04755666f, 0.03379098f, 0.05212986f, -0.31924182f, 0.20171557f, -0.01917802f, -0.06310806f, 
    -0.00190017f, 0.01773421f, 0.02506182f, -0.04101279f, -0.06276507f, -0.03306752f, 0.15542354f, 0.03609688f, 
    0.06263363f, -0.24926160f, -0.00746544f, -0.00144694f, 0.04355881f, -0.07517882f, 0.04462668f, 0.16207093f, 
    -0.01037726f, 0.10271553f, 0.03962374f, -0.05489946f, 0.12672944f, -0.15866461f, -0.00762298f, -0.01541501f, 
    0.10076812f, -0.06209968f, -0.14542346f, -0.06449948f, -0.01235777f, -0.00807786f, 0.15048911f, -0.00005014f, 
    0.17247637f, 0.10046704f, -0.21035716f, -0.03352137f, 0.10282407f, -0.06788244f, -0.09781558f, -0.05769875f, 
    0.05141991f, -0.07738795f, -0.01347383f, -0.01474697f, -0.26983148f, 0.13579695f, 0.16206984f, -0.09620527f, 
    -0.03437039f, -0.10998405f, 0.14534126f, -0.08820867f, -0.03499938f, -0.00398351f, -0.03540999f, -0.00500026f, 
    0.01980147f, -0.05948952f, -0.02532579f, -0.02447890f, -0.05909979f, 0.00824632f, 0.08489946f, -0.04979837f, 
    0.04489246f, -0.07911427f, 0.02672013f, -0.04870508f, 0.06245985f, -0.06074031f, -0.00228793f, -0.03899705f, 
    -0.04468266f, -0.00199613f, 0.05842323f, -0.05704527f, -0.02051248f, 0.12943207f, -0.15603085f, 0.02336082f, 
    0.17818278f, -0.23192881f, -0.07944889f, 0.07030337f, 0.09263349f, -0.02678606f, 0.00738319f, -0.12144417f, 
    0.04660846f, -0.09187993f, 0.05150238f, -0.07243019f, 0.15521960f, 0.06450080f, 0.21180800f, -0.14585651f, 
    0.04133008f, 0.05543987f, 0.06972902f, -0.09892309f, 0.00677421f, 0.03849858f, 0.00921416f, -0.07560603f, 
    0.09774730f, 0.08506002f, 0.05114963f, -0.23429009f, 0.13457878f, -0.00847260f, -0.11573308f, 0.08552548f, 
    -0.01910492f, 0.10105619f, 0.10507064f, 0.07395640f, -0.01088111f, -0.05162608f, 0.10754354f, 0.15413103f, 
    0.05724184f, 0.10332486f, 0.01639436f, 0.09221376f, 0.01022073f, 0.08049593f, 0.06508673f, -0.05215830f, 
    -0.01065488f, 0.28257677f, -0.04072205f, -0.03845086f, 0.03505000f, -0.06105211f, -0.12022094f, -0.06843353f, 
    0.13293214f, 0.08355834f, -0.09990640f, 0.06546303f, 0.05448711f, 0.22894357f, 0.11603051f, 0.15036637f, 
    0.00735189f, -0.00263961f, 0.06849408f, 0.02279312f, 0.04597084f, -0.14053200f, 0.03910801f, 0.18535528f, 
    -0.05575811f, -0.08793998f, 0.20992719f, 0.02283379f, 0.03282507f, 0.06631064f, -0.06124578f, -0.13797122f, 
    0.01881105f, -0.06519993f, 0.12171464f, 0.11657570f, -0.04882943f, 0.14027928f, 0.02900943f, -0.02450566f, 
    -0.00700256f, 0.14617026f, -0.03420436f, -0.10872362f, 0.06357028f, -0.00362193f, -0.07672254f, 0.11443812f, 
    -0.27447921f, 0.23342639f, -0.00156317f, -0.03799405f, 0.08529132f, 0.02721642f, 0.03562174f, -0.07001131f, 
    0.04030274f, 0.06617341f, -0.04736096f, 0.06005814f, -0.15340102f, 0.05242713f, 0.05034008f, 0.00398298f, 
    0.03735070f, 0.01691051f, -0.03029892f, -0.06534624f, 0.00585492f, 0.11280923f, 0.12508593f, -0.00057155f, 
    0.15341437f, -0.17288131f, 0.18187243f, 0.17035320f, -0.06201382f, 0.02682731f, 0.03594167f, 0.05013425f, 
    0.03739648f, -0.00003774f, -0.05631459f, 0.05439974f, -0.42029372f, 0.05195489f, 0.10854062f, -0.11459294f, 
    0.06480873f, -0.00754219f, 0.02192428f, -0.14160609f, -0.00013967f, 0.01608340f, 0.01469931f, 0.02212297f, 
    0.10724587f, -0.10035378f, -0.18777853f, -0.01435603f, 0.03546117f, 0.08705680f, -0.06332947f, -0.01695726f, 
    0.09900452f, 0.13672103f, 0.11483730f, -0.00888525f, 0.06815732f, -0.04706449f, 0.06007385f, -0.09043019f, 
    0.04495896f, -0.06347896f, 0.06943447f, -0.12780792f, -0.00192801f, 0.02880682f, -0.11581372f, -0.14815731f, 
    -0.15811941f, -0.00624335f, -0.07141642f, 0.15504788f, 0.07280383f, -0.14635907f, -0.08057448f, 0.06578786f, 
    0.08153179f, -0.05629172f, -0.02831897f, -0.02426151f, 0.22728126f, 0.07945069f, -0.02404267f, 0.22834942f, 
    0.01858231f, 0.02518133f, -0.02180334f, 0.00975190f, 0.10933799f, 0.04226987f, 0.03241888f, 0.08126988f, 
    0.25402564f, -0.08950057f, -0.19575298f, -0.17313682f, 0.08237578f, -0.00972979f, -0.01279062f, 0.08783922f, 
    0.05599931f, 0.02079228f, -0.11156589f, -0.00926269f, -0.02299060f, 0.14951666f, -0.04176820f, -0.15751946f, 
    -0.05590073f, 0.09612374f, -0.10714815f, 0.01543801f, 0.09472194f, 0.03155070f, -0.06962622f, -0.04183525f, 
    -0.42916426f, -0.11353323f, -0.04234618f, -0.17413801f, 0.00703336f, 0.05091954f, -0.10971408f, -0.06726764f, 
    0.06094078f, 0.00807077f, -0.04202780f, 0.01146508f, 0.11029224f, 0.15539120f, -0.09554695f, 0.16737382f, 
    0.08895335f, -0.00469295f, -0.11734925f, -0.00554913f, 0.00061518f, 0.06840070f, 0.03411335f, 0.11433607f, 
    0.10458468f, 0.03991495f, 0.04991414f, 0.04366154f, 0.00136275f, 0.08236486f, 0.00581757f, 0.09819804f, 
    0.00286300f, 0.01244569f, -0.01598752f, -0.01235619f, -0.27994001f, 0.17065983f, -0.09678893f, -0.10888933f, 
    0.02835376f, 0.09879278f, 0.06284131f, -0.03646381f, 0.13124511f, -0.10586918f, 0.03062769f, 0.01066043f, 
    -0.02049322f, -0.05648421f, -0.13010126f, -0.02142989f, -0.02303920f, -0.11048234f, -0.06371669f, 0.10280728f, 
    0.05342621f, 0.02213785f, 0.05230889f, 0.00878439f, 0.11609901f, 0.05814746f, 0.03940553f, -0.12983705f, 
    0.05823157f, -0.04547194f, 0.11921437f, -0.09478834f, 0.06796797f, 0.05344901f, 0.01180276f, 0.10929433f, 
    0.22280796f, 0.10793356f, -0.09087696f, 0.08652449f, -0.06315383f, -0.02288857f, 0.05101181f, -0.04005837f, 
    0.12248798f, 0.00944281f, 0.07595630f, 0.02202098f, 0.20113802f, 0.12023197f, 0.10820893f, 0.12995355f, 
    0.04379733f, 0.09490551f, 0.11727445f, 0.10284553f, -0.00674970f, 0.06826773f, -0.06635102f, 0.02961238f, 
    0.14414217f, 0.10992052f, 0.10659316f, 0.08770344f, 0.07866117f, -0.02178374f, 0.07055471f, 0.08148880f, 
    0.13005243f, 0.05950490f, 0.00157330f, 0.01755659f, -0.19697060f, -0.07767660f, 0.02869199f, 0.08909991f, 
    -0.01476889f, 0.04159584f, -0.14067039f, 0.04629526f, 0.05670153f, -0.05785599f, -0.00602974f, -0.04275278f, 
    -0.10389541f, 0.19550836f, -0.03076820f, -0.03925747f, -0.05088171f, 0.09085154f, -0.03022489f, -0.01619597f, 
    -0.00299145f, 0.08755945f, 0.03941527f, -0.03649407f, -0.34735942f, -0.04733946f, 0.09671579f, 0.14267467f, 
    0.03140258f, 0.04597818f, -0.05959078f, -0.05682719f, -0.00178156f, 0.05406180f, 0.06782981f, 0.00847263f, 
    -0.13566895f, 0.02144364f, 0.11459082f, -0.04628088f, 0.03141862f, 0.10258674f, -0.00797279f, -0.02905539f, 
    -0.09565330f, 0.04063699f, -0.00478031f, 0.02619732f, -0.30487749f, 0.23086587f, -0.11463838f, -0.19925363f, 
    0.13539852f, -0.07150359f, 0.00512594f, -0.11061267f, -0.06187153f, -0.04044873f, 0.10946338f, -0.03286554f, 
    -0.01486620f, 0.09801789f, 0.02472620f, 0.17445888f, 0.01271874f, 0.05541368f, 0.06676935f, 0.00254723f, 
    -0.08779472f, -0.09178557f, 0.02648821f, 0.04693445f, 0.05433811f, -0.02790859f, 0.03192176f, 0.02591035f, 
    0.02427701f, -0.02173375f, 0.08320715f, 0.06277672f, -0.03644470f, 0.12170838f, -0.09373119f, 0.13913472f, 
    -0.22397971f, 0.02686340f, 0.02958068f, -0.04052801f, 0.03779484f, -0.05015026f, -0.06393083f, 0.05604845f, 
    0.09699174f, 0.07035483f, 0.05075188f, 0.04978356f, 0.10104764f, -0.04434754f, -0.11141375f, -0.00322645f, 
    0.00560057f, -0.07968498f, 0.00364039f, 0.01747172f, 0.04350005f, 0.10712487f, 0.12716544f, 0.03956995f, 
    -0.25655663f, 0.05323485f, 0.22154216f, 0.01324415f, 0.11714281f, 0.05410971f, 0.00913656f, 0.04101153f, 
    -0.00700613f, 0.03874249f, 0.02634421f, -0.00825461f, -0.42255026f, -0.02403914f, -0.03470292f, -0.13224725f, 
    0.08154572f, -0.04843240f, -0.08603612f, 0.02403556f, -0.03176337f, 0.00579672f, 0.01171806f, 0.08477786f, 
    -0.19943447f, -0.09187960f, 0.04864091f, -0.03594472f, 0.15940827f, 0.09507042f, 0.03654615f, 0.00404313f, 
    -0.11872099f, 0.12274013f, -0.04566862f, 0.05713709f, 0.00654099f, 0.24699317f, -0.03590878f, 0.08156339f, 
    -0.08887693f, 0.08908705f, 0.15207110f, -0.05093548f, -0.05798458f, 0.04380414f, -0.06654223f, 0.02483149f, 
    -0.22578396f, 0.17387515f, -0.04830014f, -0.00594197f, -0.00037957f, 0.13053314f, 0.06553710f, 0.08915160f, 
    0.12134238f, -0.05919784f, -0.07376885f, 0.05624550f, -0.23093504f, -0.15968329f, 0.01648915f, 0.05870709f, 
    0.09309337f, 0.12234230f, -0.01446149f, -0.08065817f, 0.04049538f, 0.11829066f, -0.02982004f, 0.12919027f, 
    0.36006746f, 0.10351884f, 0.21346596f, 0.06056865f, -0.02266195f, 0.08100110f, 0.04468987f, 0.06775963f, 
    -0.04438616f, -0.06307090f, 0.04806352f, 0.16267617f, -0.14060888f, -0.08780292f, -0.05450819f, -0.15344864f, 
    0.10394945f, -0.02954867f, 0.06368801f, 0.01456595f, 0.01590736f, 0.12731136f, 0.06819894f, 0.11368621f, 
    -0.02040316f, 0.08710338f, -0.06508718f, -0.12233023f, -0.00231628f, 0.01682687f, 0.05303178f, -0.08344997f, 
    0.03942166f, 0.00402545f, 0.03173994f, 0.05183513f, 0.12088785f, 0.07792746f, -0.02504052f, -0.02040216f, 
    0.01946578f, -0.04102332f, 0.01855510f, 0.02148192f, -0.04157278f, -0.02180555f, 0.02347354f, 0.05354831f, 
    0.21236959f, 0.10793839f, 0.14453860f, -0.05909703f, 0.02338343f, 0.05371180f, -0.01917291f, 0.06527077f, 
    0.06549725f, -0.01103726f, -0.19099587f, -0.02835317f, -0.32437375f, 0.13227043f, -0.15020365f, -0.22992453f, 
    0.14715515f, -0.02658728f, -0.08019086f, -0.10349819f, -0.10098428f, -0.06039415f, 0.15292905f, 0.03283684f, 
    -0.27250743f, -0.02473570f, 0.28186432f, 0.11014183f, -0.01089141f, 0.00895947f, 0.03461487f, -0.00891932f, 
    0.03901461f, -0.09710807f, -0.00966730f, 0.02267102f, 0.11529803f, 0.16742574f, 0.05661326f, 0.18926254f, 
    0.04791864f, -0.04178223f, 0.02631259f, -0.00357117f, -0.00012530f, 0.06346230f, 0.04689494f, 0.02794964f, 
    0.13784485f, -0.04611942f, -0.04870944f, 0.16019610f, 0.00452823f, -0.00841960f, 0.02283435f, 0.10767595f, 
    0.09596064f, -0.12228017f, -0.04905532f, 0.05396103f, 0.17635931f, 0.16044982f, 0.05842950f, 0.03084630f, 
    -0.02381298f, 0.06330187f, -0.04731668f, -0.05505189f, -0.04205409f, 0.10236318f, 0.00838159f, 0.04680515f, 
    -0.45145282f, -0.08627456f, -0.09765762f, -0.28236979f, 0.07905266f, -0.00141124f, -0.05351473f, -0.00864673f, 
    -0.07205147f, -0.04503023f, 0.05548738f, 0.02635863f, -0.18140334f, 0.01173020f, -0.13964269f, 0.05802895f, 
    0.03685479f, 0.06155175f, 0.12932307f, 0.00297911f, -0.08014005f, -0.00330978f, 0.00657540f, -0.01382724f, 
    0.04240688f, 0.15399322f, -0.01743860f, -0.12866084f, 0.02348261f, -0.01630756f, -0.02380428f, 0.10322525f, 
    -0.00651021f, 0.12377016f, 0.04216991f, 0.09037629f, -0.02378282f, 0.23912495f, -0.01846619f, 0.05058780f, 
    0.01941561f, -0.00100196f, 0.08663837f, 0.07347925f, 0.08850624f, 0.01434832f, -0.00102827f, 0.10277416f, 
    -0.01348895f, 0.14580618f, -0.03967417f, 0.00821808f, -0.01899757f, -0.04832345f, 0.17864905f, -0.00301386f, 
    0.03397184f, 0.09916311f, 0.05022821f, 0.06139693f, 0.07351944f, 0.04186568f, -0.04409683f, -0.01034337f, 
    -0.05046411f, -0.07552941f, 0.01725108f, 0.00593019f, -0.00681205f, 0.06076292f, 0.03200505f, -0.01971379f, 
    0.46358925f, 0.09927373f, 0.03125243f, 0.23212917f, 0.08725984f, 0.08948047f, 0.10908540f, 0.06906124f, 
    -0.07704426f, 0.12312244f, 0.06164018f, 0.08691597f, -0.38403782f, -0.12521368f, -0.02022346f, -0.12917227f, 
    0.02483114f, 0.03637287f, 0.02501332f, -0.10361990f, 0.00889802f, 0.03265170f, -0.05944229f, 0.04325169f, 
    -0.33184293f, 0.14382176f, 0.10453339f, -0.02176529f, 0.06665070f, 0.08184345f, 0.09971920f, 0.07164234f, 
    0.12247739f, 0.02371799f, 0.05872715f, 0.11187741f, 0.23352587f, 0.04373816f, -0.06070099f, 0.03695512f, 
    -0.03210860f, -0.07044227f, -0.07337911f, 0.07053534f, 0.08584397f, 0.01373730f, 0.00626635f, -0.01004837f, 
    -0.26398301f, 0.23238344f, -0.07145291f, 0.03999961f, 0.02632220f, -0.07803697f, -0.02137231f, -0.09628075f, 
    -0.02836859f, 0.03788254f, 0.01468517f, -0.08497035f, 0.23329900f, 0.00678236f, -0.09285035f, 0.01905718f, 
    0.02360459f, 0.03652462f, -0.01215061f, 0.01008306f, -0.04079929f, -0.04038857f, 0.03317776f, -0.04302559f, 
    -0.36681381f, -0.10848276f, -0.06575163f, -0.09908352f, 0.07924410f, 0.05029523f, -0.08544205f, -0.03055240f, 
    -0.03662308f, -0.01458137f, -0.00205460f, -0.00950775f, 0.14031757f, -0.07703704f, 0.08416236f, 0.17376375f, 
    -0.03261121f, -0.00134407f, 0.04589244f, -0.02667214f, 0.02492093f, 0.01767531f, 0.03379613f, 0.01833308f, 
    -0.11165629f, -0.18312305f, 0.02442397f, 0.10803896f, 0.01111399f, 0.07000680f, -0.12369462f, -0.04936974f, 
    0.00288712f, 0.06117821f, 0.00119224f, 0.11559626f, 0.21535413f, 0.12223989f, -0.12333506f, 0.03517308f, 
    0.04045062f, -0.00921129f, 0.03061834f, -0.06638374f, 0.06960211f, 0.05782386f, -0.05375432f, 0.12068179f, 
    -0.10223553f, -0.32263038f, 0.06975106f, 0.11139958f, -0.05197936f, 0.06457042f, 0.01390998f, 0.01140297f, 
    -0.06482822f, -0.09613750f, 0.07183477f, 0.12316187f, 0.11300141f, 0.13106214f, 0.07882990f, -0.07202968f, 
    0.06531928f, 0.03041875f, 0.09153280f, -0.05316071f, -0.00435248f, 0.08899850f, 0.05415803f, 0.06358581f, 
    -0.09173900f, -0.18283790f, -0.15209661f, -0.12862487f, -0.02276444f, -0.03128529f, 0.00440021f, 0.00822646f, 
    -0.04217392f, 0.08641708f, 0.11670306f, -0.01841359f, 0.25606856f, 0.00219610f, 0.10005816f, 0.01315364f, 
    0.04212106f, 0.04838636f, 0.07460658f, 0.02582479f, -0.05847155f, 0.12276097f, 0.00004734f, 0.00782940f, 
    0.03304526f, -0.18354557f, 0.02868350f, -0.08886805f, -0.21595560f, 0.05411021f, -0.03001889f, 0.03145171f, 
    -0.00187938f, 0.00906973f, -0.06111531f, 0.02387782f, -0.04361927f, 0.14488354f, 0.17015165f, 0.16094787f, 
    -0.04247679f, -0.09160364f, -0.01118055f, 0.24048766f, 0.01619440f, 0.09206438f, -0.03323322f, 0.02999115f, 
    -0.15247460f, 0.24108244f, 0.00235073f, -0.10583178f, 0.02136302f, -0.05026843f, 0.03570970f, 0.03508464f, 
    -0.03773372f, -0.01333912f, 0.02977872f, 0.10819595f, 0.13946189f, -0.06619947f, 0.04279285f, 0.02115295f, 
    -0.06003119f, 0.12016711f, 0.01175635f, 0.03004178f, 0.01711161f, 0.07322217f, -0.03677401f, -0.02672225f, 
    -0.14695790f, 0.12462617f, 0.01322558f, 0.21901318f, -0.01464680f, 0.14893356f, 0.00986252f, 0.07937503f, 
    0.11610949f, -0.06527010f, -0.00770687f, -0.00855206f, -0.16917968f, 0.03202325f, -0.02374178f, -0.13067414f, 
    0.05106783f, -0.08737488f, -0.14184962f, -0.01518827f, 0.12341268f, -0.05383698f, -0.05221457f, -0.02790803f, 
    0.05948501f, 0.09371708f, 0.01703617f, -0.13397160f, -0.00502263f, 0.13148828f, 0.06317379f, -0.09732638f, 
    0.00614325f, 0.09265178f, -0.01373165f, 0.08754019f, 0.00693965f, 0.12772708f, -0.04588848f, 0.05370996f, 
    0.03276955f, 0.05708092f, -0.02113871f, -0.04373375f, 0.02167481f, 0.01783283f, 0.03602095f, 0.10480218f, 
    -0.13588922f, 0.02565412f, -0.02944116f, 0.04953206f, 0.03385598f, 0.13376926f, 0.09342464f, -0.04968557f, 
    0.00796829f, 0.07861505f, -0.00429153f, -0.05047160f, 0.20141263f, -0.07618492f, 0.07147978f, -0.06710326f, 
    -0.05568929f, 0.03665416f, 0.01157075f, 0.03942273f, 0.02388184f, 0.03410811f, 0.03990119f, 0.07265014f, 
    0.01202765f, 0.01261389f, 0.00149799f, 0.01370141f, -0.01615230f, 0.01371343f, -0.03127355f, 0.02544645f, 
    -0.02959149f, -0.01270231f, -0.04108079f, 0.01018270f, -0.01050764f, -0.01160469f, 0.00705192f, 0.00642499f, 
    -0.00060129f, -0.00248910f, -0.03770629f, 0.02029254f, 0.00194147f, -0.02838917f, 0.01691692f, -0.00266677f, 
    -0.00153829f, -0.02187107f, -0.01407657f, -0.01787906f, -0.03033155f, -0.02967115f, 0.01760676f, -0.02657545f, 
    -0.00877824f, -0.02380985f, 0.01870520f, -0.03462998f, 0.00680216f, 0.02222682f, -0.04025614f, -0.03571223f, 
    -0.03831855f, -0.02743562f, 0.00561209f, 0.01012378f, 0.01738389f, -0.01288559f, -0.04191400f, 0.02097146f, 
    -0.01648731f, 0.01842611f, -0.01703854f, 0.00548539f, -0.02539397f, -0.00579259f, -0.00605896f, -0.02436619f, 
    -0.01629832f, -0.03942086f, -0.02728397f, -0.03803589f, 0.00991796f, 0.00750132f, -0.02385911f, -0.02183894f, 
    -0.04149949f, 0.01961021f, -0.03131388f, 0.02460749f, -0.03316598f, -0.03781877f, -0.01951839f, -0.01739107f, 
    -0.03286226f, -0.01287434f, 0.00541218f, 0.01774150f, 0.02231652f, -0.03846526f, 0.02035527f, -0.00242542f, 
    -0.01066811f, 0.02426075f, 0.00391498f, -0.01505803f, 0.00762633f, -0.02208776f, -0.01548503f, -0.01738826f, 
    -0.01784342f, 0.00243524f, 0.02271366f, -0.03044518f, 0.00250755f, 0.01675284f, -0.00370064f, -0.02174534f, 
    0.01480712f, -0.03128187f, -0.03107914f, -0.00668237f, 0.01144297f, -0.00405928f, -0.01737193f, -0.02713901f, 
    -0.01978971f, 0.01817043f, 0.00229964f, -0.00867680f, -0.00788021f, 0.00170537f, -0.01664019f, -0.03942456f, 
    -0.01940861f, 0.00428190f, 0.01327471f, 0.02388575f, -0.01744965f, -0.00514975f, -0.00072024f, -0.02306853f, 
    0.00311631f, 0.01428474f, -0.02146053f, -0.00957968f, 0.00716830f, -0.02457787f, -0.02343255f, -0.01276583f, 
    0.02716131f, -0.03047122f, 0.01082247f, 0.02467804f, -0.02617376f, -0.03667207f, -0.00432617f, -0.03545528f, 
    0.02008351f, -0.01825654f, -0.04025887f, -0.03802189f, -0.00589683f, -0.00820963f, -0.00126169f, -0.02646454f, 
    0.01670944f, 0.00430360f, -0.00314299f, 0.02611958f, -0.01248375f, -0.03117625f, 0.02041093f, -0.03671300f, 
    0.00029699f, 0.01470289f, -0.01447378f, 0.00049226f, -0.00620752f, -0.03036753f, 0.00016824f, -0.03138977f, 
    -0.03682010f, 0.00452354f, -0.03152467f, -0.00676375f, -0.02503691f, -0.03733746f, -0.01424336f, 0.00277270f, 
    -0.02540135f, 0.00725108f, -0.02619333f, 0.01659035f, 0.01962674f, -0.00155738f, -0.02598861f, -0.01491263f, 
    0.02239436f, 0.00069805f, 0.01506740f, 0.00231695f, 0.00377057f, -0.02544816f, 0.00285500f, -0.02374467f, 
    0.03318950f, 0.02269762f, 0.00427135f, -0.00610057f, -0.03506395f, 0.02468469f, -0.02746285f, -0.01146497f, 
    -0.01285869f, 0.01988342f, -0.02756215f, -0.01169573f, -0.03194906f, 0.00724789f, -0.00028194f, -0.01069357f, 
    -0.02401266f, -0.01885125f, 0.00560229f, -0.00314158f, -0.03758943f, 0.01149564f, 0.01598055f, 0.00268270f, 
    0.01818336f, 0.02579663f, -0.04023072f, -0.00824764f, 0.02400980f, 0.02994680f, -0.01146696f, 0.01329259f, 
    0.00626642f, 0.01949980f, 0.00820878f, 0.02917446f, -0.03726599f, -0.01592217f, -0.01319313f, 0.01142055f, 
    -0.00843177f, -0.00317552f, 0.00462458f, 0.01635284f, -0.01994135f, 0.02534771f, 0.01471696f, 0.02980308f, 
    0.00351035f, -0.01961861f, 0.01178200f, 0.00061026f, -0.03255916f, -0.00927830f, -0.02309362f, 0.02318281f, 
    0.02545172f, -0.03112249f, 0.01266764f, 0.02561453f, 0.01889724f, -0.02806011f, 0.01190714f, 0.02832445f, 
    -0.00132696f, -0.02008087f, 0.00366840f, 0.02497010f, -0.02547038f, -0.03114300f, -0.01613660f, -0.02619109f, 
    0.00407444f, 0.01244217f, 0.01114830f, -0.00611272f, -0.03696273f, -0.00816486f, 0.00635178f, 0.01122263f, 
    0.00413052f, -0.02692233f, -0.04055209f, 0.01449477f, -0.00128438f, -0.01433965f, -0.01111098f, -0.02407957f, 
    -0.03554729f, -0.01866334f, -0.01319318f, -0.02118793f, 0.01823287f, -0.02122645f, -0.03000624f, 0.02216334f, 
    0.02892999f, 0.01617572f, 0.02162636f, -0.02356562f, -0.00578358f, 0.00183927f, 0.02582518f, -0.01699461f, 
    0.00646956f, 0.02264650f, 0.00206436f, -0.00195974f, 0.04007221f, -0.00541564f, -0.02886025f, 0.01927480f, 
    -0.00567930f, -0.00198377f, -0.02362799f, -0.03283285f, 0.01277926f, 0.02531779f, 0.02687956f, -0.01344373f, 
    -0.03478855f, -0.02413332f, 0.02672985f, 0.02814825f, -0.03832598f, -0.01531488f, -0.02520294f, 0.00164448f, 
    -0.02746553f, -0.01321335f, -0.02718344f, -0.02422087f, -0.00682032f, -0.03661837f, -0.00002447f, -0.04077528f, 
    -0.03553697f, -0.01130267f, -0.00606259f, -0.00368987f, -0.01800522f, -0.00676658f, -0.03211724f, -0.03535866f, 
    -0.01132950f, -0.03440801f, -0.00267702f, -0.00769157f, -0.01133478f, -0.01185323f, 0.00350686f, 0.02227965f, 
    -0.00884549f, -0.00106738f, -0.00872490f, -0.02412700f, -0.01497614f, -0.01463593f, -0.02422959f, 0.01946548f, 
    -0.03447396f, -0.01922607f, -0.01122185f, -0.01422638f, -0.02672833f, -0.01674938f, 0.02588609f, -0.03784748f, 
    0.02876057f, 0.00267225f, -0.00543306f, 0.00530798f, -0.03208198f, 0.02085148f, 0.00801082f, -0.03782447f, 
    -0.01751559f, -0.00613177f, -0.00309162f, -0.00533105f, -0.02711334f, 0.02291809f, -0.03342631f, -0.02351890f, 
    -0.02962903f, 0.02704041f, -0.01487361f, -0.01045311f, -0.00531357f, 0.02804721f, -0.02621483f, 0.00910963f, 
    0.02981757f, -0.00630598f, 0.01649927f, 0.00923839f, 0.02766697f, -0.01168670f, 0.01907937f, 0.00834189f, 
    0.00062047f, 0.00220175f, 0.01915593f, -0.04001436f, 0.00226867f, 0.00184309f, -0.03153482f, 0.02343817f, 
    -0.02249059f, 0.00996171f, -0.03734253f, 0.02041681f, 0.01930739f, -0.02324297f, -0.03177248f, -0.00336299f, 
    0.02923640f, 0.00599343f, 0.00678350f, 0.02686012f, -0.02620543f, -0.01388628f, 0.00870250f, -0.02118866f, 
    0.01969565f, -0.02126655f, -0.02737817f, -0.01380752f, -0.01651376f, -0.03481948f, 0.01136869f, 0.00249423f, 
    -0.02322584f, -0.03638334f, -0.02718468f, -0.01710925f, 0.02170076f, -0.01765005f, 0.00237301f, 0.00349303f, 
    -0.01486227f, 0.02755322f, -0.00708756f, -0.03206415f, 0.01019116f, -0.01612033f, 0.01475738f, 0.01405225f, 
    0.01105642f, -0.02497997f, -0.03459648f, -0.03363329f, -0.01616961f, 0.01800120f, 0.00677086f, -0.00884902f, 
    0.00371034f, 0.00309372f, 0.01288688f, -0.03112282f, -0.03314395f, -0.00940786f, -0.03114890f, -0.01374971f, 
    0.02610149f, -0.00863409f, 0.00688672f, -0.02476588f, 0.02955027f, 0.00083148f, -0.02949731f, -0.02395183f, 
    -0.02345043f, -0.00122837f, 0.00552552f, 0.02493831f, -0.00311844f, -0.02419397f, -0.00966948f, -0.00148968f, 
    -0.02933457f, -0.02302658f, 0.01731867f, -0.01320715f, -0.00764850f, 0.01275436f, 0.02336971f, 0.00332548f, 
    0.00512050f, 0.01535576f, 0.02560349f, -0.04167370f, -0.03984789f, -0.02622281f, -0.03927160f, -0.02064379f, 
    0.01553841f, -0.00570142f, -0.00653515f, -0.02834801f, -0.00210332f, -0.01505469f, 0.01490362f, -0.00434221f, 
    -0.02667974f, -0.00789371f, -0.00796154f, 0.02351332f, 0.00282462f, 0.01999595f, 0.00826846f, 0.00828621f, 
    -0.02643978f, 0.01077860f, -0.01851350f, -0.01618286f, -0.00807476f, -0.03181660f, -0.01583496f, -0.03604181f, 
    -0.02093416f, 0.00326689f, -0.03877653f, 0.02565755f, 0.00584889f, 0.00745074f, -0.00332841f, -0.02912900f, 
    -0.00552021f, -0.02417643f, -0.03448666f, -0.03442250f, 0.00755469f, 0.02223810f, 0.01067890f, -0.01099364f, 
    0.02565928f, -0.02617357f, -0.02430397f, -0.00446688f, -0.01516948f, -0.01129643f, 0.03565963f, 0.01530772f, 
    -0.03601742f, 0.02426101f, -0.00530050f, -0.01932306f, -0.03851158f, 0.00972575f, 0.01972271f, -0.00863419f, 
    0.02276203f, 0.00195395f, -0.04162744f, 0.02656605f, 0.01444443f, -0.02253097f, -0.01341439f, -0.00318040f, 
    -0.02668770f, 0.00209201f, -0.01740821f, 0.01704612f, 0.00716760f, -0.00387393f, -0.02298286f, -0.01333904f, 
    -0.03642095f, -0.01074146f, 0.02470853f, -0.03875955f, 0.01946189f, 0.00903307f, -0.00871135f, -0.04138795f, 
    -0.03768001f, -0.03307147f, -0.03148635f, 0.00814547f, -0.02309808f, 0.02747869f, 0.02748160f, -0.00958981f, 
    0.01328784f, 0.01547041f, 0.00193564f, -0.00994724f, 0.01749486f, 0.01729234f, 0.02739261f, 0.01896715f, 
    0.00261508f, -0.00557942f, -0.01561080f, -0.01383872f, -0.03633491f, -0.02415130f, 0.01801623f, -0.00933510f, 
    -0.01826864f, 0.01102731f, -0.00643843f, -0.03472480f, -0.03023044f, -0.01590340f, 0.01150968f, 0.01086351f, 
    0.01120137f, -0.03654878f, -0.03228179f, -0.03642930f, -0.01837267f, 0.01909142f, -0.01324577f, -0.01573755f, 
    -0.01146741f, 0.01040649f, 0.02647544f, -0.02710739f, 0.00677933f, 0.00379747f, -0.02318939f, -0.00806357f, 
    -0.00064900f, -0.01325364f, -0.00021147f, 0.00788867f, 0.02889975f, 0.01329469f, -0.03115048f, -0.02866736f, 
    -0.00805221f, 0.02157637f, -0.02150248f, -0.04204128f, -0.02945945f, 0.01458856f, 0.01048314f, 0.00134868f, 
    0.00181354f, 0.02426375f, -0.04002623f, -0.03919389f, 0.02760710f, 0.02641336f, -0.02806632f, -0.01166467f, 
    0.02869439f, -0.00614672f, 0.01929046f, 0.01532898f, 0.01278071f, -0.04201736f, -0.02831301f, -0.02079257f, 
    -0.02141854f, -0.02106001f, -0.02839813f, -0.03108490f, -0.03436341f, -0.00795740f, -0.00922437f, -0.02426961f, 
    0.00850677f, -0.03973085f, 0.00549887f, -0.03421564f, 0.01649591f, 0.02543985f, 0.01804168f, 0.01833142f, 
    -0.02668422f, -0.00008992f, 0.02806192f, 0.01864004f, 0.02268883f, -0.00497954f, 0.02679093f, 0.00534715f, 
    -0.03554201f, 0.00672595f, 0.02874089f, -0.00066876f, -0.03950199f, 0.00874330f, 0.02108088f, -0.03280696f, 
    -0.02899972f, 0.01328602f, -0.02084988f, -0.00882356f, -0.01082628f, -0.02803634f, -0.03770046f, 0.02125775f, 
    -0.01734719f, -0.03644629f, 0.01830127f, 0.01372283f, 0.00249494f, 0.00638852f, -0.03134014f, -0.00790639f, 
    0.02796590f, -0.01817981f, -0.00380415f, -0.04176866f, -0.03989387f, 0.01531263f, -0.04168388f, 0.00511161f, 
    -0.00619376f, -0.03339814f, -0.00781829f, 0.00177117f, -0.01899947f, -0.02968054f, -0.03384448f, -0.00029456f, 
    0.00541888f, -0.03805209f, -0.01990134f, -0.03204840f, 0.02203503f, 0.02463971f, -0.03309187f, -0.01917140f, 
    -0.02058260f, -0.03398274f, 0.02436972f, -0.03834882f, -0.00921455f, -0.03168948f, -0.03298399f, -0.03380825f, 
    -0.01271259f, -0.03977183f, 0.00224640f, -0.02002704f, -0.02352965f, -0.00800451f, 0.01417778f, -0.02706321f, 
    -0.00769672f, -0.03116756f, -0.00853603f, 0.01801803f, -0.00332585f, 0.01624518f, 0.00192207f, 0.02780870f, 
    -0.02921860f, -0.03780057f, -0.00632557f, -0.01183526f, 0.02607687f, -0.03061465f, 0.01026244f, -0.01326641f, 
    0.02729129f, 0.01615940f, -0.02882597f, 0.02820103f, 0.02902306f, -0.01925376f, -0.01064696f, 0.01621382f, 
    -0.01200069f, -0.00377985f, 0.00274883f, 0.01648055f, -0.01195555f, 0.02171693f, -0.03394797f, 0.01341714f, 
    -0.00579565f, -0.01562429f, 0.01128416f, -0.00920835f, -0.01254519f, 0.02050707f, -0.01973633f, -0.03970946f, 
    -0.02894451f, -0.01858737f, -0.12603699f, -0.01065790f, -0.02518738f, 0.05042509f, -0.07087038f, 0.03465691f, 
    -0.03060072f, 0.00691328f, 0.06327048f, -0.01054505f, 0.21446085f, 0.11916037f, -0.04436527f, -0.03214525f, 
    0.03446159f, 0.05011941f, 0.08516493f, 0.04568407f, -0.07372307f, -0.00673209f, 0.02775708f, -0.00627869f, 
    0.20057563f, 0.13896336f, 0.09799448f, 0.03334184f, -0.08786523f, -0.07741602f, -0.01184183f, 0.01525094f, 
    -0.03821521f, 0.04685797f, 0.04516997f, 0.04833202f, -0.03101486f, -0.26852146f, 0.03699770f, -0.03940367f, 
    -0.07102299f, -0.08184952f, -0.01086591f, 0.05029154f, 0.05717035f, 0.02454226f, -0.02851142f, 0.07605112f, 
    -0.14993425f, -0.17713425f, -0.10368736f, 0.08618391f, 0.00232920f, -0.01722903f, -0.09225792f, -0.05316265f, 
    0.11332079f, 0.01652049f, -0.07085171f, -0.06648730f, 0.32288688f, 0.09301858f, 0.09508959f, 0.04928381f, 
    -0.01730030f, -0.01076309f, -0.02798499f, 0.03949496f, 0.03483266f, -0.11924899f, -0.01500012f, -0.00852133f, 
    0.29413497f, 0.12040094f, 0.02297437f, -0.05888224f, -0.05738636f, -0.06586211f, -0.03856907f, -0.12052555f, 
    0.04888544f, 0.01551060f, -0.12381741f, -0.04218369f, 0.28872034f, 0.04458754f, 0.10975941f, -0.02684714f, 
    -0.13320851f, 0.07020661f, 0.05775947f, 0.05947721f, -0.00002559f, 0.06153256f, 0.03227102f, -0.07448493f, 
    -0.05642831f, 0.00776072f, 0.00472980f, 0.05459662f, 0.11411078f, 0.02466220f, 0.00461614f, 0.08407585f, 
    0.11715572f, 0.21782196f, 0.05536399f, -0.01689852f, 0.16802861f, -0.25812870f, -0.17326552f, -0.09487958f, 
    -0.02947930f, 0.01461325f, 0.08016524f, 0.08494166f, -0.05820052f, 0.02044016f, 0.11113333f, -0.02691198f, 
    0.10196825f, -0.12882024f, 0.09413811f, 0.02833137f, -0.04073035f, -0.02033694f, 0.04455449f, 0.08402422f, 
    -0.08569805f, -0.08016635f, 0.08910706f, 0.00494007f, -0.04704821f, -0.28860411f, -0.07882610f, -0.05511935f, 
    0.06549031f, 0.06165235f, -0.02145157f, 0.06662740f, 0.11535772f, 0.09220288f, -0.00888609f, 0.00316899f, 
    0.05469762f, -0.15746623f, 0.19599520f, -0.01389210f, 0.01181835f, 0.13334851f, -0.08783115f, -0.03370161f, 
    0.17197099f, -0.02442536f, -0.04617169f, -0.16838248f, 0.03541787f, -0.28001633f, 0.03700412f, 0.08411354f, 
    -0.08602388f, 0.02933227f, -0.00646621f, -0.01002907f, -0.02491895f, -0.05396640f, 0.11321768f, 0.01608559f, 
    0.12983096f, 0.24070029f, -0.01012681f, -0.04493416f, -0.03672365f, 0.03519193f, 0.00245392f, 0.01272925f, 
    -0.10565779f, 0.08114203f, -0.03599331f, -0.01462427f, 0.03150381f, 0.15816000f, -0.12443233f, 0.05211809f, 
    -0.11319494f, 0.06592788f, 0.05642547f, 0.14396556f, 0.11467633f, 0.04295767f, -0.05235326f, 0.00228053f, 
    0.09539026f, -0.20515245f, -0.07165784f, 0.24463496f, 0.08511607f, -0.01780022f, 0.15422781f, 0.07957438f, 
    0.07756929f, -0.03598841f, 0.21808031f, 0.14063603f, 0.01257420f, -0.04168249f, -0.00673334f, 0.02416602f, 
    -0.06754138f, -0.01970435f, 0.01266702f, 0.13346471f, 0.03091890f, 0.12620831f, 0.02599686f, 0.10763709f, 
    0.15958664f, -0.18904686f, -0.16061291f, 0.06116721f, -0.02662924f, 0.06113904f, -0.03567600f, 0.07678515f, 
    0.03069576f, 0.03949055f, -0.00385351f, -0.09290718f, -0.23986904f, -0.18167526f, -0.02530872f, -0.03824994f, 
    -0.07193186f, -0.10263474f, -0.01329520f, 0.04776879f, 0.16377406f, 0.01056090f, -0.12304496f, -0.03459125f, 
    -0.28757837f, -0.18340375f, -0.04742115f, 0.03460708f, -0.03180907f, -0.11281038f, -0.06969906f, 0.01165364f, 
    0.09242535f, 0.12040216f, -0.14011541f, 0.01515543f, 0.13874255f, -0.01324107f, -0.05535401f, 0.04143739f, 
    -0.06539787f, -0.01865326f, -0.00835306f, 0.06035710f, 0.05917283f, 0.02308952f, 0.02841473f, -0.01100642f, 
    -0.00687376f, -0.02128037f, -0.01477185f, -0.09895368f, -0.05397862f, -0.06729434f, 0.06152001f, -0.03750851f, 
    -0.04579354f, -0.00469582f, -0.02760982f, 0.02500009f, -0.12142256f, -0.10984663f, -0.03411164f, -0.03347833f, 
    -0.07755235f, -0.00066247f, -0.00214700f, 0.02416826f, 0.07215435f, -0.01231521f, -0.10201024f, -0.05355445f, 
    0.24209841f, -0.08773603f, 0.18146388f, 0.08587407f, 0.00186271f, -0.02111509f, 0.07533589f, -0.04950580f, 
    0.17020839f, 0.08930562f, 0.02070657f, -0.05736759f, -0.19232874f, -0.01617295f, -0.09875997f, -0.00823178f, 
    -0.05968696f, 0.02200655f, -0.03529077f, 0.04335698f, -0.04658016f, 0.05118487f, -0.05129053f, 0.05205506f, 
    0.20815217f, 0.04967905f, 0.11572204f, -0.06066159f, -0.11278639f, -0.02055526f, 0.11929564f, -0.06379262f, 
    0.06099404f, -0.05161736f, 0.01436064f, 0.07275799f, 0.14918263f, 0.03009773f, 0.11107788f, -0.12211628f, 
    -0.08130988f, 0.07940367f, -0.03065358f, 0.02477846f, 0.05454671f, 0.10806695f, 0.12515245f, 0.02416533f, 
    0.19672178f, 0.04973415f, -0.13062656f, -0.01491076f, 0.07183133f, -0.00060517f, 0.02078420f, 0.01012212f, 
    0.01474407f, -0.14423463f, 0.03931846f, 0.02022567f, 0.12839632f, -0.17328621f, -0.05996354f, 0.08635800f, 
    -0.00796393f, 0.04709013f, -0.08754105f, -0.00485615f, 0.04934931f, -0.05827701f, 0.03881278f, 0.02577835f, 
    0.19321072f, -0.47255981f, -0.01131297f, 0.06087464f, 0.12702429f, -0.05637674f, 0.00284649f, 0.10786844f, 
    0.07741824f, 0.04486735f, -0.00980756f, -0.03337392f, 0.12818415f, 0.26842454f, -0.08578378f, -0.30591783f, 
    0.02752018f, 0.02382481f, -0.04867247f, 0.07569087f, -0.07425949f, -0.02836267f, 0.03127549f, 0.03828655f, 
    -0.18104544f, 0.21455871f, 0.05112034f, -0.05383274f, 0.09024047f, 0.16723675f, 0.00477787f, -0.08906631f, 
    -0.10388003f, 0.02804673f, -0.06606710f, 0.06791417f, 0.38054264f, 0.00864202f, -0.12940699f, 0.06191067f, 
    -0.06207705f, 0.02803963f, 0.00074928f, -0.08101945f, 0.02834399f, -0.06094994f, 0.04885551f, 0.04696143f, 
    -0.13071072f, -0.22981468f, 0.05083096f, -0.15324469f, -0.06758399f, -0.09152998f, 0.05204378f, -0.00416987f, 
    0.06581711f, 0.08935537f, -0.07711057f, -0.13280240f, -0.09975169f, -0.12718989f, 0.06707636f, -0.02240827f, 
    -0.04422218f, -0.00528376f, 0.02595384f, -0.00899538f, -0.00812228f, 0.14681202f, -0.07576971f, 0.05143597f, 
    0.09917712f, -0.22468768f, -0.01184905f, 0.06782303f, 0.00079915f, 0.03506185f, 0.11397067f, 0.02579942f, 
    -0.00888009f, -0.03812320f, 0.00196271f, -0.11500812f, 0.10837657f, -0.16048799f, 0.00609881f, 0.02280231f, 
    0.11066568f, -0.02824553f, 0.04071432f, -0.05843158f, -0.05283346f, 0.03160772f, 0.05688271f, -0.04800504f, 
    0.23173353f, 0.12740989f, -0.01447018f, 0.07632869f, -0.07157370f, -0.01701593f, -0.03457355f, 0.04280441f, 
    0.02389822f, 0.02289096f, 0.06157203f, 0.02237251f, 0.54269028f, -0.03909143f, -0.01690628f, 0.09009393f, 
    -0.12142640f, -0.04256238f, 0.10054127f, 0.17317441f, -0.12290470f, 0.00517828f, 0.05838332f, 0.02685343f, 
    -0.14598291f, -0.05521816f, 0.12828360f, 0.18077481f, -0.02196719f, 0.12012046f, 0.06556361f, -0.10574943f, 
    0.07724628f, 0.01876656f, -0.00776069f, 0.18551692f, -0.09795178f, -0.22486924f, -0.06533346f, -0.11855727f, 
    -0.10067101f, -0.05840101f, -0.08421829f, 0.12117546f, 0.05124728f, -0.02254220f, 0.01845894f, 0.03831330f, 
    0.02128029f, 0.03877544f, -0.05992888f, 0.06155213f, -0.07481403f, 0.14450018f, 0.08073252f, 0.11672531f, 
    0.03719656f, 0.02904434f, -0.00164763f, 0.10746305f, 0.29224944f, 0.15315640f, 0.10331364f, 0.08990254f, 
    -0.00911201f, -0.02991306f, 0.04523719f, 0.02730810f, 0.06957562f, -0.06853539f, 0.00896086f, 0.03349645f, 
    0.13947518f, -0.01994910f, -0.06560528f, 0.11089917f, -0.02504389f, 0.11210393f, -0.12355725f, 0.12621005f, 
    0.00370014f, 0.02212699f, 0.05368656f, 0.07408553f, 0.25273898f, 0.13504359f, 0.18305174f, -0.06506857f, 
    0.02554716f, 0.04399246f, 0.10382400f, 0.00094438f, -0.05767388f, 0.01147100f, 0.00637934f, 0.04542045f, 
    0.01119225f, -0.16173671f, -0.00990729f, 0.15914431f, -0.02576368f, -0.03707671f, -0.06759129f, 0.00661507f, 
    0.07552009f, -0.01755289f, 0.06406129f, 0.06269104f, 0.14863423f, -0.19953158f, 0.16820538f, 0.00770433f, 
    0.04804776f, -0.00131200f, 0.14069861f, 0.16161200f, 0.02911298f, 0.09942163f, 0.00003901f, 0.02754065f, 
    -0.35838053f, 0.12477550f, -0.08410300f, -0.16082481f, -0.04051602f, 0.00636936f, -0.03283852f, -0.04337734f, 
    -0.03968149f, -0.11830384f, -0.05766928f, -0.01543524f, 0.25213939f, 0.11022604f, 0.00701872f, 0.11353295f, 
    0.00153487f, -0.05111324f, -0.05621221f, 0.04079054f, -0.01322441f, 0.05039880f, 0.01917206f, -0.02055929f, 
    -0.12763739f, -0.08461846f, -0.03028093f, 0.05392231f, 0.07738181f, -0.04670129f, -0.02587677f, 0.12745734f, 
    -0.02979819f, 0.11049292f, 0.04774544f, 0.01458311f, 0.18215008f, 0.18178824f, 0.11356181f, -0.08983798f, 
    0.04090167f, 0.06033014f, -0.09449382f, 0.03060417f, -0.02281585f, -0.01297096f, 0.03152018f, -0.01447200f, 
    -0.19583918f, -0.16457853f, 0.14125954f, -0.01236155f, -0.03585250f, 0.05549703f, -0.04786361f, 0.08940403f, 
    0.00063198f, 0.03930704f, 0.05464454f, -0.11692747f, 0.20939103f, 0.22038355f, 0.07568563f, -0.20393416f, 
    -0.02683648f, -0.11543178f, 0.07873403f, -0.02567331f, -0.05729084f, 0.01333017f, 0.09245723f, -0.02660504f, 
    0.43392360f, -0.07116190f, 0.13683362f, -0.01204798f, -0.02097378f, -0.07487057f, -0.03129866f, -0.00258228f, 
    -0.05815658f, -0.03622922f, -0.07574682f, -0.07837243f, 0.14163803f, 0.03232209f, -0.24626690f, 0.12696432f, 
    0.03524855f, -0.02321520f, 0.00339714f, 0.10118391f, -0.06521485f, 0.00789066f, 0.07443260f, -0.02268316f, 
    0.08739052f, -0.30677322f, -0.08188526f, 0.08472583f, -0.01309128f, -0.02492527f, 0.01684327f, 0.03147012f, 
    0.09250373f, 0.13993981f, -0.03688184f, -0.01241439f, 0.27210304f, -0.00626042f, 0.15515044f, 0.03596183f, 
    -0.06376509f, 0.03242437f, 0.09083831f, 0.09563355f, -0.06096185f, 0.11608464f, -0.01637706f, 0.03678788f, 
    0.09803829f, -0.07168904f, -0.02779122f, -0.01332341f, -0.10736439f, 0.03285607f, 0.03544101f, 0.04280875f, 
    -0.07374993f, -0.10106362f, 0.09480903f, 0.00649081f, 0.01132265f, -0.11293005f, 0.03846785f, 0.13290200f, 
    0.00208731f, 0.00131719f, 0.01923751f, -0.01737674f, 0.10503114f, 0.05079636f, 0.11465969f, 0.03158664f, 
    0.52266783f, -0.09295212f, 0.00578874f, 0.02899508f, -0.10236753f, 0.04286231f, 0.07242010f, 0.01642501f, 
    0.00604894f, -0.07389517f, -0.04096677f, 0.16673803f, 0.29666725f, -0.02314091f, -0.16347274f, -0.08480394f, 
    0.08117817f, 0.01565149f, 0.05650165f, 0.09010325f, -0.01395904f, 0.09385881f, 0.05343485f, -0.10417138f, 
    -0.25449389f, -0.15901317f, 0.05720117f, 0.14200331f, -0.03973289f, 0.08933727f, -0.06959987f, -0.03733541f, 
    -0.10169778f, 0.00561362f, -0.00048119f, 0.18119194f, 0.05451770f, 0.01878058f, 0.04280308f, -0.14187098f, 
    -0.05253660f, -0.03946233f, 0.06491373f, 0.07141562f, 0.02301531f, 0.07933614f, 0.02818770f, 0.05506499f, 
    0.01587641f, 0.02298279f, 0.00342516f, -0.02748756f, 0.00030879f, -0.00723147f, -0.01478477f, -0.00552024f, 
    0.02308147f, -0.03976366f, 0.00072892f, 0.01844120f, -0.00877416f, -0.03887403f, 0.00612537f, 0.00387056f, 
    0.00763932f, -0.01045895f, 0.01937181f, -0.01263248f, 0.00361909f, 0.01299871f, -0.02837777f, 0.02348239f, 
    -0.01515559f, -0.00579226f, -0.00926406f, 0.01542240f, -0.04084382f, 0.00061078f, -0.01514814f, -0.02721647f, 
    0.02610470f, 0.00134377f, 0.00152585f, 0.01002755f, -0.00516286f, -0.00861128f, -0.02699772f, -0.00183573f, 
    0.00415613f, 0.00551045f, -0.00041709f, -0.01994679f, -0.03136148f, 0.01033538f, -0.00783260f, -0.02435891f, 
    0.00344269f, -0.04176693f, -0.01166075f, 0.00548578f, -0.04174328f, -0.01720217f, -0.02852404f, -0.00120316f, 
    -0.02955724f, -0.03647521f, 0.00126375f, -0.02245195f, 0.01392242f, -0.00105455f, -0.00383676f, 0.02730770f, 
    0.00380634f, -0.03727578f, -0.02423731f, -0.04220622f, -0.00827910f, 0.02617302f, -0.01054146f, -0.00474067f, 
    0.00579588f, -0.03027432f, -0.03001409f, 0.02223210f, -0.00442429f, 0.01631183f, -0.00835455f, -0.03299435f, 
    0.00181116f, 0.02671050f, -0.03663106f, -0.01765334f, -0.04005200f, -0.00043237f, -0.02913434f, -0.01746277f, 
    -0.01712561f, -0.01541444f, -0.00755802f, -0.01594559f, 0.01901629f, -0.02161897f, 0.02311952f, -0.03722780f, 
    -0.00282562f, 0.00208079f, -0.03698465f, -0.01363402f, 0.00967437f, 0.02808071f, 0.01612690f, 0.01932121f, 
    -0.01716921f, -0.02116892f, -0.00366471f, 0.01844904f, -0.00901059f, -0.03126977f, -0.01922906f, -0.01718204f, 
    -0.02316491f, 0.01452293f, 0.01115310f, 0.00426347f, -0.01777531f, 0.02377925f, 0.01875991f, 0.02670857f, 
    -0.00674488f, -0.00058114f, -0.02095024f, 0.01772968f, 0.02307891f, -0.04281787f, 0.02875312f, 0.00022902f, 
    -0.04048683f, 0.01687276f, -0.01501434f, -0.04065922f, -0.01399261f, -0.01967775f, -0.02090339f, -0.01509175f, 
    -0.00280466f, 0.01095212f, -0.03581114f, -0.01350854f, -0.04169883f, -0.03239539f, -0.00453443f, -0.01274665f, 
    -0.03396370f, -0.04274241f, -0.02882126f, 0.02079612f, -0.01013380f, 0.00127735f, 0.01733162f, 0.00935210f, 
    0.01689460f, 0.00867268f, -0.02694041f, -0.02063525f, 0.01027751f, 0.00543770f, -0.00110379f, -0.02674472f, 
    0.02784947f, -0.02499326f, -0.02615000f, 0.02027079f, 0.02442387f, 0.00487818f, 0.01628837f, -0.03995590f, 
    -0.03741714f, -0.02431937f, -0.00482605f, -0.01339974f, 0.01037103f, -0.00154501f, -0.03479996f, 0.01528543f, 
    -0.00487859f, 0.00663606f, 0.00042633f, -0.04108422f, -0.01966542f, -0.02012300f, -0.02389150f, -0.04394950f, 
    0.00422872f, -0.02589426f, -0.04070023f, -0.01266704f, -0.02812497f, -0.03679628f, -0.04141795f, 0.00112264f, 
    0.00292936f, -0.00775876f, -0.03956763f, 0.02759873f, -0.03199759f, 0.02336531f, 0.00107084f, 0.02703292f, 
    0.00431385f, 0.02013691f, -0.03663980f, -0.04148798f, -0.00317359f, 0.01197788f, -0.02908526f, -0.02235561f, 
    -0.03143471f, -0.00723452f, 0.02061983f, 0.00446542f, -0.01475536f, -0.04116452f, -0.01735325f, -0.01730014f, 
    0.01612914f, 0.02559421f, 0.00362976f, -0.01500763f, -0.02264632f, -0.00815658f, -0.00850378f, -0.00564875f, 
    -0.02793811f, 0.01437503f, 0.00856999f, -0.01791863f, 0.00311190f, -0.01114783f, -0.02342940f, 0.02447514f, 
    -0.04341387f, -0.04276426f, -0.00226851f, 0.00576760f, 0.01676842f, 0.00190959f, 0.00130088f, -0.02186300f, 
    0.00096684f, 0.01872988f, 0.00764625f, 0.01282113f, -0.00793499f, -0.01409761f, -0.01250613f, -0.01858274f, 
    0.01688760f, -0.00173371f, -0.00974589f, -0.00077734f, -0.00524550f, -0.03910189f, 0.00504198f, 0.01145608f, 
    0.00060223f, -0.02082795f, 0.02437767f, 0.00537463f, -0.03409376f, -0.02452063f, 0.00480232f, -0.01973498f, 
    0.01829472f, 0.02288768f, -0.02499511f, -0.03526144f, 0.00937197f, 0.01803469f, -0.02582574f, 0.01988402f, 
    -0.02954444f, -0.01573636f, 0.00104325f, -0.03055998f, -0.03061762f, -0.03546980f, -0.01880314f, -0.02325871f, 
    0.00837456f, 0.02350778f, -0.03501547f, -0.02384154f, -0.03665262f, -0.03735511f, -0.01730745f, 0.01682828f, 
    -0.01239213f, 0.00615368f, -0.01690699f, 0.01707659f, -0.02909375f, -0.03109552f, -0.02642691f, 0.02233572f, 
    0.00119741f, -0.03100383f, -0.01799842f, -0.01231302f, 0.01564387f, 0.01106255f, 0.02573362f, 0.00283967f, 
    -0.01079200f, 0.00083572f, -0.01393391f, 0.02873553f, -0.02444525f, -0.02799449f, -0.02321703f, 0.02694349f, 
    0.00075703f, 0.02684510f, 0.00504243f, -0.03851333f, -0.03305013f, 0.00496569f, 0.01953612f, 0.00326784f, 
    0.02223845f, -0.03980790f, -0.03439022f, -0.01531691f, 0.00724594f, 0.00606262f, -0.00387229f, -0.03095241f, 
    0.02139936f, -0.00679002f, -0.00394137f, -0.04172668f, 0.00064608f, -0.02666627f, 0.02084275f, 0.00742471f, 
    -0.02326843f, 0.00711686f, -0.02316145f, 0.00719141f, -0.02530955f, -0.04010839f, 0.00774018f, 0.00962879f, 
    -0.02099057f, 0.00500156f, 0.01506460f, -0.03345639f, 0.00592931f, 0.01492591f, 0.01557750f, -0.00573660f, 
    -0.03444731f, -0.01505239f, 0.02174547f, 0.02818813f, -0.01772726f, -0.00357214f, -0.04169668f, 0.00717717f, 
    -0.03462192f, -0.01595889f, 0.00974789f, -0.00864145f, 0.01255702f, -0.01992105f, -0.00635120f, -0.03587865f, 
    -0.01662190f, -0.01335125f, -0.01623814f, -0.02413599f, -0.03122741f, 0.00833201f, -0.00813486f, 0.02689008f, 
    0.02101065f, -0.02446171f, 0.01085091f, 0.00784246f, 0.00774806f, -0.03034075f, -0.04119857f, 0.00424854f, 
    -0.04071182f, -0.03798749f, -0.01465196f, 0.01740261f, 0.01929308f, 0.00526597f, -0.00159967f, -0.04142994f, 
    0.01975706f, -0.03471012f, 0.02842653f, -0.00549462f, -0.02064585f, -0.00339323f, 0.01007304f, 0.00756054f, 
    0.01218980f, 0.00091339f, -0.00017370f, -0.03305415f, -0.02898970f, 0.00435598f, 0.01383704f, -0.00026270f, 
    -0.03388512f, -0.00027017f, -0.02800826f, -0.02009451f, 0.02238566f, -0.02374336f, -0.02770144f, 0.01844721f, 
    -0.01584175f, 0.01938068f, 0.02380611f, -0.01731208f, -0.00879685f, 0.02193753f, 0.00026937f, 0.02842128f, 
    0.01266614f, -0.00486503f, 0.00144815f, -0.03010353f, -0.01877050f, -0.00042155f, -0.02604531f, -0.00404433f, 
    -0.00755239f, -0.03617518f, -0.02209546f, 0.01007705f, -0.03182124f, 0.00920288f, 0.01832134f, -0.01454521f, 
    -0.01309303f, -0.04188634f, 0.00991137f, 0.02849253f, -0.04159354f, -0.04106127f, 0.02420827f, 0.02366987f, 
    -0.02970091f, -0.01544273f, -0.03524971f, 0.01368719f, 0.01868966f, -0.00297344f, -0.03675892f, 0.00935774f, 
    0.01786434f, 0.01159184f, -0.03005569f, -0.03404006f, 0.02147967f, -0.02124914f, 0.02673039f, 0.01436136f, 
    -0.03347304f, -0.01397711f, -0.00525849f, -0.01613787f, 0.02804381f, 0.00371546f, 0.01144403f, -0.01349955f, 
    -0.02764519f, 0.01371244f, -0.01862807f, 0.00141497f, 0.00459652f, -0.01425539f, 0.01779484f, 0.01160509f, 
    -0.02340643f, -0.03503670f, -0.02255920f, -0.03632886f, 0.01580974f, -0.03854622f, -0.02634159f, -0.03505583f, 
    0.01130263f, 0.01718827f, -0.01822311f, 0.01208284f, 0.00977060f, -0.03042984f, -0.03799087f, -0.00533629f, 
    0.01414504f, -0.02707347f, 0.01096428f, 0.01353109f, -0.04345808f, -0.02988038f, 0.01299701f, 0.01733443f, 
    -0.01049785f, -0.01146414f, 0.02351818f, 0.00621961f, 0.01267862f, 0.01941099f, 0.00633061f, -0.02023142f, 
    -0.03617399f, -0.04137684f, -0.03198385f, -0.03444555f, -0.01322689f, 0.00368116f, 0.01915012f, 0.01502608f, 
    0.01134254f, 0.00602335f, 0.01028630f, -0.03503700f, -0.01737615f, -0.01837553f, -0.01617218f, -0.01357916f, 
    0.00295488f, -0.01726339f, -0.03478966f, -0.04227585f, 0.01488505f, 0.00778628f, -0.00745095f, 0.01257660f, 
    -0.01531311f, -0.00889259f, 0.01308804f, -0.03731650f, 0.02502254f, -0.03732584f, -0.01359620f, 0.01268015f, 
    0.01018892f, -0.02524976f, -0.03309289f, -0.02834883f, 0.02644304f, 0.02834250f, -0.00750676f, 0.01558965f, 
    -0.02357860f, -0.03256693f, 0.02005763f, -0.03819459f, 0.01762022f, 0.00775326f, 0.01848618f, -0.02090572f, 
    -0.03154848f, -0.02250693f, -0.01247296f, -0.00833252f, -0.03435147f, -0.03532994f, 0.00570359f, -0.01284408f, 
    -0.00670972f, -0.00657145f, -0.04319393f, -0.00494806f, 0.00330664f, 0.00839479f, 0.02733441f, 0.00709512f, 
    0.02313649f, 0.01502220f, -0.03863915f, -0.03866470f, -0.03655092f, 0.02009971f, 0.00936980f, 0.02082922f, 
    0.01804284f, 0.02208681f, 0.02117665f, -0.04181123f, -0.00215789f, 0.00968301f, 0.01706849f, -0.00788495f, 
    0.00656221f, 0.01046334f, 0.02589645f, -0.03292599f, 0.02050525f, 0.00843600f, -0.01485182f, 0.02315849f, 
    0.00292193f, -0.03893422f, -0.03645603f, -0.02213003f, -0.01959962f, -0.04214912f, 0.01377318f, 0.01344966f, 
    -0.00605155f, 0.00626343f, -0.00119904f, 0.00148405f, 0.00156511f, -0.00113311f, -0.02020975f, -0.01584231f, 
    0.00780869f, -0.03510338f, 0.01213164f, 0.02262774f, 0.02184408f, -0.00424144f, 0.01994513f, 0.00706630f, 
    -0.00576220f, -0.03820209f, -0.00871023f, -0.02285754f, -0.00634041f, -0.04151624f, -0.01295696f, -0.03361876f, 
    0.01192904f, -0.02597200f, -0.00294407f, -0.02051605f, -0.01425240f, -0.01190233f, 0.01458544f, -0.02670580f, 
    0.01748426f, -0.03130367f, -0.03467542f, -0.00611622f, 0.01494853f, -0.01257245f, 0.01825187f, -0.01158117f, 
    0.00632469f, 0.00060073f, -0.03910136f, -0.00163652f, -0.00590026f, 0.00653197f, 0.02998672f, -0.01666379f, 
    -0.02117936f, -0.02258329f, 0.02282604f, -0.03883730f, 0.00345352f, -0.00738788f, -0.01493500f, 0.02299030f, 
    -0.02096009f, 0.01802487f, 0.01140731f, 0.01509286f, -0.00392176f, 0.02813232f, 0.00509273f, -0.01203536f, 
    -0.03699667f, -0.01986531f, -0.04061040f, -0.03195839f, -0.03237152f, 0.00577777f, 0.00811753f, -0.04183280f, 
    0.00106001f, 0.01122167f, -0.00261553f, -0.02897262f, -0.01940893f, 0.02693122f, 0.02075636f, 0.02460564f, 
    -0.03388687f, -0.02099432f, 0.02533559f, -0.00869309f, 0.02018527f, -0.00002331f, 0.00807780f, 0.00357675f, 
    0.01685152f, 0.00011483f, -0.01036433f, 0.02390035f, -0.02864669f, 0.00934382f, 0.01209116f, 0.00140388f, 
    -0.02007443f, 0.01643584f, -0.00486615f, 0.02050467f, -0.01445324f, -0.00066532f, -0.00124662f, 0.01643156f, 
    0.02016330f, -0.01475312f, 0.00435076f, 0.00741287f, -0.00955154f, -0.01430546f, -0.01903015f, 0.00112990f, 
    -0.04177514f, 0.02092284f, 0.02182543f, 0.01287321f, -0.00158807f, 0.02319644f, -0.01828331f, -0.01989243f, 
    -0.01329452f, -0.00139857f, -0.03718231f, -0.03707381f, 0.02630227f, -0.02848702f, -0.04011188f, 0.01611179f, 
    -0.01470170f, 0.00928278f, 0.00508966f, 0.00036179f, -0.02958698f, 0.02754677f, 0.01487770f, 0.02139764f, 
    -0.00205175f, 0.00671743f, 0.02616067f, -0.01334492f, -0.04260900f, 0.02812960f, -0.00212413f, -0.02880851f, 
    -0.01824203f, -0.02618943f, 0.01755974f, 0.02762743f, 0.01044691f, 0.00603639f, -0.02319391f, -0.04153259f, 
    -0.03088742f, -0.01428974f, -0.02767892f, -0.02114994f, -0.01527376f, -0.03087903f, 0.00381172f, -0.00200582f, 
    0.03538915f, -0.04146958f, -0.12958480f, -0.08648676f, 0.18437715f, 0.05099262f, -0.06870854f, 0.06608243f, 
    -0.01244469f, 0.06505127f, -0.00089426f, -0.07437510f, 0.11649500f, 0.14569862f, 0.00857507f, 0.06823567f, 
    0.02657560f, -0.04229650f, 0.00048567f, 0.06022430f, -0.00152722f, -0.02461706f, -0.02725505f, 0.05502916f, 
    0.06320035f, -0.00949957f, 0.32024372f, 0.25480720f, -0.03869411f, -0.10758264f, -0.03106764f, -0.02089528f, 
    -0.09503303f, -0.15210398f, 0.04727671f, -0.00127544f, -0.29207429f, 0.06270523f, -0.04342117f, -0.17585748f, 
    0.11590758f, -0.07565602f, 0.05050411f, 0.09197481f, 0.01041797f, -0.06662156f, 0.09001201f, -0.01833104f, 
    0.00945631f, -0.18535350f, -0.15672925f, 0.11468418f, 0.09669705f, -0.02588312f, -0.12934744f, -0.05122361f, 
    -0.00646735f, -0.10718617f, 0.03451074f, -0.11296637f, 0.11889622f, -0.07952855f, 0.20722771f, 0.02977245f, 
    0.10202089f, -0.04650329f, -0.00456666f, 0.12381084f, -0.02490707f, 0.02732287f, 0.07116176f, -0.01169126f, 
    0.00754300f, 0.08414783f, 0.05380734f, 0.07279678f, 0.01945841f, -0.09824128f, -0.08824044f, -0.01050492f, 
    0.06786753f, -0.11959419f, 0.08732226f, 0.03727990f, 0.24115098f, 0.07963709f, 0.34428072f, 0.16881199f, 
    -0.00094675f, -0.03182455f, -0.06667460f, 0.02858301f, -0.07007221f, 0.02484036f, -0.08625683f, -0.04439367f, 
    0.25559703f, 0.03257736f, -0.10672910f, -0.10191680f, -0.01912981f, 0.00699612f, -0.09346676f, 0.08994382f, 
    0.05522929f, 0.09829160f, 0.03673950f, -0.01835049f, -0.12295005f, 0.06151246f, -0.24630719f, -0.07842774f, 
    0.03453770f, -0.04647724f, -0.04034897f, -0.04907724f, -0.03169841f, 0.02396427f, -0.05520556f, -0.00232620f, 
    -0.21337977f, 0.23984721f, -0.00961627f, 0.15232955f, 0.05106413f, -0.00989979f, 0.15554036f, 0.03734788f, 
    -0.08861033f, 0.06962031f, 0.08210373f, -0.08306675f, 0.01044118f, 0.04181389f, 0.01608690f, -0.03746643f, 
    0.08182950f, 0.07406974f, -0.06227074f, -0.10950368f, 0.19307263f, 0.08964828f, 0.01378361f, -0.12007850f, 
    -0.27632657f, 0.05789923f, 0.02533062f, 0.11960090f, 0.15680422f, 0.09800663f, 0.04995202f, -0.01699821f, 
    0.11137833f, -0.00356486f, -0.11920504f, -0.18103686f, -0.05522900f, 0.00466945f, -0.01108405f, 0.04867731f, 
    0.16003564f, 0.00584738f, -0.00695309f, -0.02167027f, 0.07709446f, -0.02834072f, 0.02726445f, 0.11247380f, 
    0.35359180f, 0.06849659f, 0.12442630f, -0.00361402f, 0.06172104f, -0.02435311f, -0.01291732f, 0.03683631f, 
    -0.11719717f, -0.03762221f, 0.19653545f, 0.04891283f, -0.09328275f, 0.03007594f, 0.09403774f, 0.05543431f, 
    -0.10439572f, -0.04535466f, 0.05120547f, 0.12547235f, 0.03496590f, 0.09125664f, -0.09854262f, 0.17911559f, 
    0.04459567f, -0.17029271f, 0.09276916f, -0.02005209f, 0.06643163f, 0.03538278f, -0.15523361f, 0.09453046f, 
    0.01850367f, -0.09069390f, 0.00592371f, 0.01774232f, 0.06040143f, -0.13056453f, -0.07991499f, 0.05448606f, 
    -0.02628525f, 0.03921117f, 0.07056884f, 0.03152216f, -0.03423065f, 0.03047494f, -0.04548665f, 0.14909101f, 
    0.05892042f, -0.01153015f, -0.14130828f, 0.08970384f, 0.15256330f, 0.02492018f, -0.08542373f, -0.01520620f, 
    -0.05094082f, -0.06609452f, -0.01714786f, -0.07074319f, -0.13797590f, -0.06398098f, -0.03734272f, -0.00742744f, 
    0.04880964f, -0.07774754f, -0.14670508f, 0.09997974f, 0.03769034f, 0.07628617f, -0.01870682f, -0.04921178f, 
    0.30605209f, -0.04799734f, -0.06554137f, -0.36145833f, 0.15057397f, 0.08310893f, -0.06049396f, -0.12854616f, 
    0.05026549f, 0.06349656f, 0.01548110f, 0.02572802f, 0.04554565f, -0.00294956f, -0.01803432f, 0.19945055f, 
    -0.17626780f, 0.04450372f, 0.04623354f, -0.22108972f, -0.11492922f, 0.05492174f, 0.04786450f, 0.13853924f, 
    -0.21575123f, 0.20871739f, 0.29916614f, 0.19287942f, -0.10622130f, 0.08388090f, 0.20230217f, 0.08044399f, 
    0.09786254f, 0.00284127f, 0.10009954f, 0.11442821f, -0.07845736f, 0.14355397f, -0.10352942f, -0.12317506f, 
    0.04351315f, 0.11348499f, -0.02106085f, -0.02684089f, 0.07363052f, 0.21032363f, 0.00354269f, 0.01250009f, 
    0.11029587f, -0.02868374f, 0.27049410f, -0.11628442f, 0.12714887f, -0.09829728f, -0.00732378f, -0.05038167f, 
    0.03026490f, 0.03073322f, 0.10322696f, 0.15726994f, 0.01592047f, -0.05583221f, -0.16262452f, -0.03303568f, 
    0.12313280f, 0.06179734f, -0.02097279f, -0.09110618f, -0.13825573f, -0.09603842f, -0.02871459f, -0.07941278f, 
    -0.01775662f, 0.32442853f, 0.28467295f, 0.16102275f, -0.05860128f, 0.06352714f, 0.03139597f, 0.04604644f, 
    0.06362624f, -0.04379440f, 0.01188392f, -0.11529475f, 0.16702124f, 0.08657173f, 0.11601007f, -0.15853381f, 
    -0.00898445f, 0.05691581f, -0.04262935f, 0.05475804f, -0.04921477f, 0.00248200f, 0.12959373f, 0.03157765f, 
    0.14451092f, 0.03613979f, 0.00459204f, -0.19775012f, 0.06786627f, 0.11455829f, -0.02641282f, 0.01349879f, 
    -0.00571365f, -0.08041999f, -0.03725454f, -0.06618994f, 0.08330909f, 0.04685747f, -0.22484165f, -0.02190210f, 
    0.14359392f, -0.02739074f, -0.14420913f, -0.04982150f, -0.04028144f, 0.01410573f, 0.01464167f, 0.04280617f, 
    -0.18093975f, -0.08290163f, 0.06435940f, -0.28660718f, -0.05673866f, -0.02074971f, -0.06849433f, 0.00283241f, 
    0.14049844f, 0.20530954f, 0.09536033f, 0.01228152f, 0.39815030f, 0.06852676f, -0.06784929f, -0.20412476f, 
    -0.04826227f, 0.02985520f, -0.13776088f, 0.05703568f, 0.05074270f, 0.04019352f, 0.10746608f, 0.20314480f, 
    0.09220985f, 0.05047826f, -0.01336077f, -0.09707168f, -0.10954236f, -0.10729975f, -0.01637714f, -0.00674362f, 
    -0.08438612f, 0.04454255f, -0.03996667f, 0.01064153f, 0.15713407f, -0.02862053f, 0.04423143f, -0.16211614f, 
    -0.01544577f, -0.04550752f, -0.11553629f, -0.04882768f, 0.03257948f, -0.00870503f, -0.18038267f, -0.11376349f, 
    -0.01410752f, -0.11937897f, -0.21763946f, -0.01161731f, 0.12918864f, 0.02269177f, -0.14575447f, -0.02719293f, 
    0.00288379f, 0.08142193f, -0.02404002f, -0.10032857f, -0.11391760f, 0.03159568f, 0.17594711f, -0.11328422f, 
    -0.05400359f, 0.00360385f, 0.04706784f, -0.05496980f, -0.12065595f, 0.07432310f, -0.04969910f, -0.02419066f, 
    0.11481530f, 0.04283394f, -0.09912621f, 0.01805306f, 0.14374417f, -0.10954069f, 0.10646635f, 0.04750502f, 
    0.00196072f, -0.00569637f, -0.09391476f, -0.10435863f, 0.26974773f, -0.02497005f, -0.03704034f, -0.14472792f, 
    0.15504983f, -0.05809106f, -0.02923606f, 0.01213485f, 0.04470793f, -0.01858051f, 0.04337725f, 0.03740482f, 
    0.34262910f, 0.03853969f, 0.04666572f, 0.15749170f, -0.05832704f, 0.06373392f, -0.03948593f, 0.07578624f, 
    -0.04747361f, -0.02137841f, -0.08162326f, -0.00029607f, 0.15794052f, -0.05741351f, 0.27568918f, 0.08571783f, 
    -0.10090458f, -0.06401415f, 0.04534244f, 0.02062640f, -0.06230306f, -0.10046588f, -0.04749240f, -0.01651988f, 
    0.19777881f, -0.13481851f, 0.24256158f, -0.29489559f, -0.06346551f, 0.08565012f, -0.06327337f, 0.00580534f, 
    -0.01614091f, 0.03024985f, 0.00478736f, 0.20597132f, -0.03842701f, 0.01038795f, -0.05662036f, -0.27474746f, 
    0.13822789f, 0.01462141f, -0.00246882f, -0.02547049f, -0.02899127f, 0.02849490f, 0.03505595f, 0.02004604f, 
    -0.04932987f, 0.03126876f, 0.13407983f, 0.10949663f, -0.00751179f, 0.13757186f, 0.02010585f, 0.13428904f, 
    -0.05970192f, 0.01977051f, 0.08783504f, 0.10132084f, 0.07200329f, 0.03263265f, 0.17270330f, 0.12561598f, 
    0.05802301f, -0.07260574f, 0.08502573f, 0.26500204f, 0.08579746f, -0.03329927f, 0.04727814f, 0.08761913f, 
    -0.22226363f, 0.07722525f, -0.08389331f, -0.02014241f, 0.14116718f, -0.04551275f, -0.02336992f, 0.06383307f, 
    -0.07057763f, 0.15031637f, 0.09654807f, 0.07180540f, 0.13837916f, 0.11308423f, 0.18702246f, 0.19574517f, 
    -0.04419445f, -0.03377975f, 0.00314157f, 0.22574677f, -0.20215674f, -0.18679513f, 0.06567207f, -0.08558051f, 
    -0.10325439f, -0.04352353f, -0.11280107f, 0.00936721f, 0.18635345f, -0.05365665f, -0.06362706f, 0.06659935f, 
    0.01080123f, 0.00036995f, 0.03689540f, 0.00551615f, -0.03644776f, 0.09506435f, -0.11310133f, 0.09575193f, 
    0.01492785f, -0.07889374f, 0.06701213f, 0.09273617f, 0.00983272f, 0.16111661f, -0.01122086f, 0.07095119f, 
    -0.06425475f, 0.06170342f, -0.00377488f, -0.24115805f, -0.14199719f, 0.21235079f, 0.05390557f, -0.00987752f, 
    0.03467787f, -0.03751917f, -0.04826699f, -0.03190075f, 0.47713709f, -0.12658882f, 0.06145802f, -0.16494229f, 
    -0.03974339f, 0.13005210f, 0.04614338f, 0.02754474f, 0.05820986f, 0.10071851f, -0.08406975f, 0.09863788f, 
    -0.15373641f, 0.14508158f, -0.18807919f, 0.17746843f, 0.01209122f, 0.02687193f, 0.10357172f, -0.09703755f, 
    0.06277210f, 0.01315586f, -0.00458549f, 0.04689075f, 0.18182714f, 0.05462418f, 0.14934051f, -0.20096007f, 
    0.06433660f, 0.06396080f, -0.00414916f, -0.11947720f, -0.08807401f, 0.04092397f, -0.02853628f, -0.11956027f, 
    -0.06020809f, -0.06173100f, -0.16930950f, -0.06763704f, 0.19312781f, -0.07126867f, 0.13071693f, 0.02051961f, 
    0.04425653f, 0.04350542f, 0.08385493f, -0.22058989f, 0.15553802f, 0.30447108f, 0.20361106f, 0.25346324f, 
    -0.08445299f, -0.01461573f, -0.05303776f, -0.02408855f, 0.02668653f, 0.00723935f, -0.03652654f, -0.05581738f, 
    0.14863309f, 0.15218590f, 0.12758400f, 0.02650960f, 0.01715096f, -0.11442831f, 0.08547152f, -0.01260273f, 
    -0.00848723f, 0.04191755f, -0.04920522f, 0.09149805f, -0.01735136f, -0.02003263f, -0.06033852f, -0.00004861f, 
    -0.03577702f, -0.06136416f, 0.00139797f, 0.11219261f, -0.02430151f, 0.14402968f, -0.08212550f, 0.08563104f, 
    0.08344276f, 0.12211227f, -0.01625999f, -0.16595879f, 0.17321749f, -0.03843282f, 0.01090520f, 0.03481981f, 
    0.05624765f, -0.03712914f, -0.02337751f, 0.02473219f, 0.04631416f, 0.05389714f, 0.13386890f, -0.01240907f, 
    -0.08964484f, 0.03402394f, 0.13913274f, 0.05090971f, -0.04980100f, 0.10476720f, -0.04719579f, -0.03282515f, 
    -0.20871785f, 0.20844682f, -0.08572131f, 0.31802717f, 0.06758472f, 0.10167849f, 0.01270663f, 0.04890120f, 
    0.07906114f, -0.02172726f, -0.03497459f, 0.00968666f, -0.02966123f, -0.06544469f, -0.07391161f, 0.00816953f, 
    0.15619273f, -0.01341708f, -0.10939306f, 0.11678810f, 0.07068125f, -0.01322293f, 0.17763589f, 0.15766896f, 
    0.04212321f, 0.18873970f, 0.28270704f, -0.10990249f, 0.06434845f, 0.13507593f, 0.02795064f, -0.00863409f, 
    -0.00043676f, -0.02303381f, -0.00893020f, 0.00431217f, 0.05911998f, 0.10441827f, -0.11495379f, 0.00835445f, 
    0.10092840f, -0.03170560f, -0.04248250f, 0.03582767f, 0.01809778f, -0.04234727f, -0.06053925f, -0.05435924f, 
    -0.18813477f, -0.01198786f, 0.18738197f, -0.02064736f, -0.08721060f, 0.13281292f, 0.01032251f, -0.11610071f, 
    -0.00290574f, 0.03779481f, 0.07315826f, 0.09873980f, -0.12003465f, 0.21230605f, 0.18136860f, 0.35488939f, 
    -0.21271573f, 0.06913181f, 0.08868630f, -0.05910680f, -0.07436755f, 0.07202091f, 0.03878604f, -0.02148275f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00117660f, -0.00526196f, 0.00609188f, -0.01865321f, -0.02958530f, 0.05450311f, 0.02883687f, 0.02798373f, 
    -0.00559972f, -0.03282376f, 0.05988402f, 0.06742660f, -0.01494037f, -0.07933372f, 0.01591452f, 0.01574699f, 
    0.01676361f, -0.01954498f, 0.01747988f, -0.00366846f, 0.02346213f, -0.00488313f, -0.03954799f, -0.02170064f, 
    -0.00329345f, 0.01614540f, 0.00853575f, 0.06208988f, -0.02622135f, 0.03603928f, -0.02758947f, 0.02367427f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03316002f, -0.01627043f, -0.08673023f, 0.15380135f, 0.16673814f, -0.08787966f, -0.13780673f, 0.07576106f, 
    0.02640152f, 0.16669022f, -0.04461040f, 0.01444206f, 0.12855737f, -0.02505497f, 0.06574582f, -0.00251530f, 
    -0.08921881f, 0.09367839f, 0.05300455f, -0.06218792f, 0.16716020f, 0.14242814f, 0.14706801f, 0.16596919f, 
    0.12875544f, -0.10118040f, -0.10704981f, -0.07760701f, 0.09650984f, -0.10792727f, -0.08283160f, -0.06682703f, 
    0.10368250f, -0.03662331f, -0.10927366f, 0.15917535f, 0.08474098f, 0.02094103f, -0.35862765f, 0.27390301f, 
    0.01763660f, 0.10369550f, 0.00553245f, -0.04239522f, 0.10675994f, 0.45424944f, 0.02398227f, 0.11950012f, 
    0.14266007f, -0.05195874f, -0.14423145f, -0.19932216f, 0.00641249f, 0.12248250f, 0.07069629f, 0.16894564f, 
    -0.13112044f, -0.00580962f, 0.46727264f, 0.25160196f, -0.03108746f, -0.18223254f, 0.10499378f, -0.11181627f, 
    0.04771436f, -0.03846325f, -0.04942382f, 0.05118898f, 0.07632049f, -0.12526235f, 0.18272375f, -0.20590501f, 
    -0.13462430f, 0.06756257f, 0.30858612f, -0.06595235f, 0.16632830f, -0.03120600f, -0.03388659f, 0.00775461f, 
    0.01241146f, -0.06026352f, 0.15879898f, -0.02235293f, -0.02811641f, 0.16342522f, 0.03653016f, 0.13922325f, 
    0.04667772f, 0.11480953f, -0.21091610f, 0.44842440f, -0.10636690f, -0.10515328f, 0.08648451f, 0.25370106f, 
    0.00797026f, 0.12545460f, -0.04423989f, 0.07239717f, 0.01464641f, 0.12032077f, -0.06290238f, 0.30217698f, 
    0.09783236f, -0.04928212f, -0.17861670f, -0.11240388f, -0.00937335f, 0.37787077f, -0.13228884f, 0.01320382f, 
    -0.01283383f, 0.08373106f, -0.14135832f, -0.33908403f, -0.14979649f, 0.03172485f, -0.09373291f, -0.00208814f, 
    -0.16565821f, 0.03982526f, 0.15080261f, -0.06041135f, -0.02957151f, -0.08063727f, 0.04504636f, 0.20700316f, 
    0.18380292f, 0.10067723f, 0.11527736f, 0.09635844f, -0.00269291f, 0.28335634f, -0.08636991f, 0.09712292f, 
    0.14392795f, -0.09780294f, -0.31298903f, 0.28767282f, -0.13633193f, 0.12689589f, -0.00645331f, 0.09164082f, 
    -0.09295793f, -0.10826332f, 0.11407192f, -0.04895246f, -0.06469373f, 0.15712495f, 0.13469012f, -0.17083131f, 
    0.14514707f, 0.12523006f, -0.07013852f, -0.10159444f, -0.15904516f, -0.27033669f, -0.10322283f, -0.53055298f, 
    -0.08259655f, 0.06076635f, -0.17210408f, -0.13805716f, -0.06867161f, -0.06734549f, -0.13103151f, 0.08818717f, 
    0.14995608f, -0.13734463f, 0.01650623f, -0.02507358f, 0.14705601f, -0.02174206f, -0.02882870f, -0.05285212f, 
    -0.15591489f, 0.17379455f, -0.04564670f, -0.01710439f, 0.08317442f, -0.04014536f, 0.07751975f, -0.05829075f, 
    -0.13587688f, -0.00134436f, -0.16425338f, -0.13222802f, 0.06377324f, 0.04960793f, 0.00078469f, 0.03251977f, 
    0.16941528f, -0.01716038f, -0.06374688f, -0.18128073f, 0.13630860f, -0.01701993f, 0.04239845f, -0.35081145f, 
    0.13646421f, 0.04903401f, 0.18255328f, -0.00933928f, -0.01484954f, -0.00242332f, 0.02159126f, 0.15542476f, 
    -0.00205926f, 0.16270895f, -0.13507135f, 0.42719650f, -0.17228688f, -0.04610568f, -0.06675331f, 0.02837708f, 
    0.09656416f, 0.16239232f, -0.30696839f, 0.05436417f, -0.14858468f, 0.20993145f, 0.11036772f, 0.33660585f, 
    0.20160601f, -0.06692353f, 0.02592423f, 0.15689908f, -0.10353214f, -0.28158751f, -0.04447975f, 0.12658308f, 
    -0.14135373f, 0.07840725f, 0.22633925f, 0.24725415f, 0.05038423f, 0.43013170f, 0.13240184f, -0.13286784f, 
    -0.12549680f, -0.05624862f, 0.05347968f, 0.22191250f, -0.11690415f, 0.11019963f, 0.05097992f, -0.18401562f, 
    -0.12246398f, -0.04458611f, -0.08412327f, 0.23957439f, -0.08138932f, 0.27240992f, -0.13628015f, 0.31012714f, 
    -0.09154996f, -0.03542107f, -0.08750997f, 0.15102172f, -0.00891945f, 0.24026099f, -0.43171215f, -0.23708697f, 
    0.11477081f, -0.16636594f, 0.07495880f, 0.27801228f, -0.04754664f, 0.11130098f, 0.02802137f, -0.04776201f, 
    -0.07414506f, 0.02264225f, 0.02104662f, 0.21797298f, 0.05133528f, -0.04794880f, -0.06695586f, -0.15818068f, 
    0.00955818f, -0.09461230f, 0.19902085f, -0.38975790f, -0.00270232f, 0.02900962f, -0.08033346f, 0.19150186f, 
    0.01383313f, -0.14405379f, -0.14630897f, -0.05915970f, 0.12098105f, -0.05244144f, 0.16108260f, 0.33840856f, 
    0.11214572f, 0.03940722f, 0.38307649f, -0.27806860f, 0.07873347f, 0.41078520f, -0.00886637f, -0.03190388f, 
    -0.00132755f, -0.11908527f, -0.03632687f, -0.28073427f, 0.02325537f, -0.08341012f, -0.05635928f, -0.16772974f, 
    0.11963560f, 0.04777153f, 0.32111046f, -0.11918398f, -0.13568278f, -0.09897208f, -0.13105224f, 0.14837101f, 
    -0.01683984f, -0.09776618f, 0.14342947f, -0.09871139f, -0.13842788f, 0.16110754f, 0.05989771f, -0.24771672f, 
    -0.10246838f, 0.07765671f, -0.00361642f, -0.08168015f, -0.14277852f, 0.29989129f, -0.10506455f, -0.14129330f, 
    -0.05196185f, -0.13761869f, -0.07378445f, 0.26800492f, 0.00545992f, 0.00920571f, 0.00670519f, -0.09020742f, 
    0.06996956f, -0.06276356f, 0.27775198f, -0.34208378f, -0.09340894f, 0.30569500f, 0.10249978f, -0.19879036f, 
    -0.05515328f, -0.05313759f, 0.02759540f, -0.03287981f, 0.10125533f, 0.14665234f, 0.54523951f, -0.37238574f, 
    0.14969762f, -0.13256621f, 0.32499918f, -0.03391741f, -0.07569137f, -0.30800128f, 0.09593624f, 0.02197995f, 
    -0.17331007f, -0.00956032f, -0.06094006f, 0.30733582f, 0.02909873f, -0.12863067f, -0.16914868f, 0.04441899f, 
    0.14709090f, 0.17765410f, -0.03425352f, -0.08609805f, -0.11576290f, -0.14931455f, -0.02014059f, -0.04538018f, 
    0.06845423f, -0.10938571f, -0.06484549f, 0.13302095f, -0.04274215f, -0.15878908f, -0.03368133f, -0.14565849f, 
    -0.13279523f, 0.05913230f, 0.11834550f, 0.08584864f, 0.05615405f, -0.06302034f, -0.11216991f, -0.09286001f, 
    0.00558206f, 0.03662461f, -0.14516506f, -0.06865143f, 0.09171244f, -0.12123550f, 0.08804972f, -0.09643280f, 
    0.05791242f, -0.17538224f, 0.10952822f, -0.15110427f, -0.17084678f, -0.00147314f, -0.10081366f, -0.00625281f, 
    0.25511059f, 0.17771538f, -0.02303444f, -0.02777208f, 0.09172267f, 0.23736261f, 0.27147660f, 0.18880916f, 
    0.00903350f, -0.08767784f, -0.30860549f, 0.40320352f, 0.13956955f, 0.10454100f, -0.13367185f, 0.16769598f, 
    0.13173014f, 0.09751182f, -0.06176383f, -0.02496033f, 0.01206968f, -0.03498933f, -0.00951517f, -0.09097569f, 
    -0.13326454f, -0.12037819f, 0.08258937f, -0.31679317f, 0.00859039f, -0.15241182f, 0.05951630f, -0.03339338f, 
    0.04943848f, -0.13156748f, -0.11081304f, 0.14892444f, 0.12736495f, -0.17623028f, -0.04721712f, 0.05518541f, 
    0.09697235f, 0.05210897f, -0.02239375f, -0.00846802f, 0.01760601f, -0.15981159f, 0.03774895f, 0.10732175f, 
    0.08182156f, 0.04935135f, 0.05828553f, -0.14823227f, -0.08375037f, 0.15918560f, -0.16615091f, -0.13884710f, 
    0.08064365f, -0.02050333f, -0.16037087f, 0.11531694f, 0.06014848f, 0.06776021f, 0.11496007f, -0.11069302f, 
    -0.12040126f, 0.01522043f, -0.00460469f, 0.07349416f, 0.07190967f, -0.12438500f, 0.16853397f, -0.16179463f, 
    -0.04403045f, 0.01795298f, -0.11976697f, -0.05695162f, 0.09643355f, -0.12603092f, -0.14467500f, 0.07339840f, 
    -0.01056708f, -0.15661193f, -0.12357195f, -0.16454612f, 0.08134154f, -0.13763809f, -0.09488016f, 0.03272865f, 
    0.03474900f, -0.13754874f, -0.00741544f, -0.08544163f, 0.08788617f, 0.13506413f, 0.07228155f, -0.02980545f, 
    0.13903755f, 0.03055650f, -0.13429427f, 0.02898715f, 0.01539100f, 0.28790236f, -0.10390156f, -0.07731363f, 
    0.00729406f, -0.08342769f, -0.03677111f, -0.30281028f, 0.01227894f, 0.67742682f, -0.12654793f, -0.17750658f, 
    -0.07171667f, 0.13939667f, -0.09438162f, -0.13527957f, -0.02860158f, -0.06565157f, 0.18153131f, -0.08275372f, 
    0.02601763f, 0.15819690f, 0.21981308f, -0.24898669f, 0.12642024f, -0.21083014f, -0.08892187f, 0.00103681f, 
    0.27144367f, -0.13857083f, 0.03267762f, 0.14623670f, -0.02815096f, 0.14545573f, -0.08705097f, 0.30633837f, 
    -0.05511840f, 0.11325608f, 0.06678365f, -0.06220150f, 0.03926484f, 0.06565460f, 0.00668097f, 0.10826080f, 
    0.11950643f, 0.09165055f, -0.13509563f, -0.17452084f, -0.12170398f, 0.10956886f, 0.00503033f, -0.12575936f, 
    0.01075200f, 0.07776255f, -0.28077614f, 0.50392574f, 0.05617151f, 0.06957778f, 0.14595856f, -0.25818038f, 
    -0.09146628f, -0.02248741f, 0.14007911f, -0.07287101f, -0.09708448f, -0.03707220f, -0.05908089f, -0.08827879f, 
    0.00226999f, -0.11857139f, -0.00059267f, -0.17349821f, 0.06514656f, 0.06992865f, 0.12526618f, 0.14156641f, 
    -0.05429641f, -0.04834431f, -0.04564720f, -0.15778193f, -0.08207363f, 0.12222985f, 0.03175534f, -0.14219722f, 
    0.01945806f, 0.07081726f, -0.02195639f, 0.12316461f, 0.17323558f, 0.02166451f, 0.08038111f, -0.08933692f, 
    -0.24718043f, 0.13661703f, -0.12185603f, 0.02512015f, -0.04803330f, 0.06362613f, 0.04611696f, 0.34420198f, 
    0.12553500f, -0.13206542f, 0.33867660f, -0.42272624f, -0.07049853f, 0.29474241f, -0.13631840f, -0.01783905f, 
    0.10093737f, 0.11093599f, -0.08443169f, -0.21123171f, -0.08235721f, -0.10947741f, -0.16925099f, 0.14360815f, 
    -0.14202519f, 0.01889116f, 0.16258700f, 0.24507032f, 0.03524357f, 0.36806297f, -0.06631853f, 0.29311174f, 
    0.31402692f, -0.03344882f, -0.17513740f, -0.09675547f, -0.08251642f, 0.10591114f, 0.06517372f, -0.07197964f, 
    -0.00520113f, 0.03118671f, 0.16603257f, -0.24446636f, 0.12451764f, 0.03884222f, 0.04428194f, -0.06341989f, 
    0.01486769f, 0.16331807f, 0.08254570f, 0.04406315f, -0.07729008f, 0.10677341f, 0.08604445f, 0.07566240f, 
    0.02007490f, -0.10770489f, -0.21102051f, 0.13460886f, 0.14944082f, -0.39972040f, 0.05303896f, -0.04998409f, 
    0.06300193f, -0.07426716f, 0.13043009f, 0.15795597f, 0.05077770f, 0.11192916f, 0.34293583f, 0.41523963f, 
    -0.04997581f, 0.09447210f, 0.25353768f, 0.17266972f, 0.06586608f, -0.05072992f, 0.01330304f, -0.11950064f, 
    0.16076575f, -0.09752692f, 0.12069467f, -0.25642484f, -0.09321836f, 0.16504824f, -0.11216662f, 0.09687483f, 
    0.16350302f, -0.08626029f, -0.40560827f, -0.24533582f, 0.06227545f, -0.08633928f, 0.13955581f, 0.26853573f, 
    -0.14278777f, 0.03651721f, 0.05801130f, -0.05609962f, 0.02004066f, 0.07746541f, -0.07734846f, 0.26496890f, 
    0.03141282f, 0.03461127f, 0.12028868f, 0.42509857f, 0.05207985f, -0.37083995f, -0.16374691f, -0.13746466f, 
    -0.13829911f, -0.15009820f, -0.05815195f, 0.14172034f, -0.04659235f, -0.04047358f, -0.09154831f, -0.15857522f, 
    -0.14596277f, 0.10487518f, 0.47268245f, -0.28448123f, -0.04455310f, 0.24269284f, -0.15761897f, -0.25617722f, 
    0.20436114f, 0.11741844f, 0.10225470f, -0.09711829f, 0.05998902f, -0.14776993f, 0.26666030f, 0.08020523f, 
    -0.08537413f, 0.04675198f, 0.40425357f, 0.02956619f, -0.10881720f, -0.38095215f, -0.14124221f, 0.14133631f, 
    0.06761347f, 0.17319584f, -0.16293474f, -0.21341138f, -0.09901599f, 0.08499809f, 0.01668929f, -0.05282086f, 
    0.05123369f, 0.03939814f, 0.28199577f, 0.29556513f, -0.08414412f, -0.39706236f, -0.01080797f, 0.02220653f, 
    -0.04907500f, -0.14159517f, -0.09045658f, -0.11781480f, 0.05981882f, 0.19275708f, 0.14558765f, 0.04351221f, 
    -0.04313707f, 0.02680558f, 0.36210418f, -0.06839543f, -0.09711714f, -0.30099946f, 0.12852508f, -0.05265427f, 
    -0.03387976f, 0.09430814f, 0.01517674f, -0.23263280f, -0.09037504f, -0.15948464f, -0.05491684f, 0.14479353f, 
    -0.01540184f, 0.03234069f, 0.43257281f, 0.10719046f, 0.14353035f, -0.37339339f, -0.02744364f, -0.14487712f, 
    -0.13624606f, -0.09873603f, -0.04221378f, 0.09813716f, -0.03821213f, 0.27986938f, 0.13583107f, -0.18391439f, 
    0.09671731f, 0.12444595f, -0.27457291f, 0.19645555f, -0.13011283f, -0.52020001f, -0.12813763f, 0.03762211f, 
    0.07180181f, 0.04650132f, -0.09570728f, 0.30862701f, -0.07602440f, 0.06441841f, -0.05055127f, 0.00747968f, 
    0.10864103f, -0.05946094f, -0.03783498f, 0.28267011f, -0.03613890f, 0.11024582f, -0.01987328f, 0.27366614f, 
    -0.04567460f, -0.00267447f, 0.15622030f, 0.17031203f, 0.13249899f, 0.17274848f, 0.27316752f, -0.46020594f, 
    0.05550200f, 0.00490238f, -0.10770079f, 0.01629765f, -0.17104831f, -0.08877202f, 0.05480932f, -0.08486496f, 
    -0.16478565f, 0.08088313f, 0.15744877f, 0.17180610f, -0.17256992f, -0.08506351f, -0.11341247f, 0.00778165f, 
    -0.05690547f, 0.08025344f, 0.17873631f, 0.03387291f, -0.15208735f, -0.07033097f, -0.09580296f, -0.34190705f, 
    0.06834489f, -0.14618383f, -0.06018042f, 0.02496012f, 0.06240269f, -0.07243486f, -0.32102057f, 0.07577111f, 
    0.07558405f, 0.12433299f, 0.22021753f, -0.20509616f, -0.10703881f, 0.01373391f, -0.15306313f, 0.11992312f, 
    -0.11967530f, -0.04750700f, -0.11923218f, 0.07284782f, 0.07080336f, 0.16203116f, -0.00030955f, -0.02055846f, 
    -0.09956107f, -0.13778441f, -0.03812907f, 0.48347449f, 0.02157841f, 0.47392669f, -0.10054506f, 0.11774982f, 
    -0.21912716f, -0.16841306f, -0.07980717f, -0.14461218f, -0.09410209f, -0.03330882f, -0.18764821f, 0.18945742f, 
    -0.00375731f, 0.13409673f, 0.32626826f, -0.07642679f, 0.17400862f, -0.04450735f, 0.01707183f, -0.11791160f, 
    0.05169731f, 0.09832007f, -0.07925709f, -0.01891962f, 0.07799482f, -0.06424186f, -0.06914940f, -0.02294222f, 
    -0.04430170f, -0.09323080f, 0.18181923f, 0.16887552f, 0.16791655f, 0.28543389f, 0.05557965f, 0.20234598f, 
    0.06048425f, -0.12084094f, -0.13668069f, -0.07351045f, 0.04318178f, -0.16331844f, 0.11882042f, -0.17292203f, 
    0.11606180f, 0.03792489f, 0.14551032f, 0.07955546f, -0.14899150f, -0.18554462f, 0.13949184f, 0.09624829f, 
    -0.00674246f, 0.15625250f, -0.12550743f, 0.00332685f, 0.15873085f, -0.16387954f, -0.05099788f, -0.05900219f, 
    0.02441710f, -0.00851366f, -0.10433313f, -0.14145669f, -0.12967892f, -0.11756447f, 0.02603354f, -0.06461722f, 
    -0.18571164f, 0.00525236f, 0.16747415f, 0.13261446f, -0.01491921f, 0.10634079f, -0.04775332f, 0.10820109f, 
    -0.12989923f, 0.01285106f, -0.05992375f, -0.11864961f, 0.16250195f, 0.10432865f, -0.09444523f, -0.08509187f, 
    0.01402826f, -0.12031531f, 0.01662622f, 0.00587038f, 0.13983282f, 0.09774078f, -0.05362979f, -0.10779355f, 
    -0.05684196f, 0.15395609f, -0.05065697f, 0.07436575f, 0.09685794f, -0.08067495f, -0.07748635f, -0.10603552f, 
    -0.17857671f, -0.01927627f, -0.00746267f, -0.08606406f, -0.07086660f, 0.06567816f, 0.28147206f, 0.37207422f, 
    0.05381609f, -0.10779118f, -0.16320698f, 0.25913587f, 0.16572714f, -0.34200150f, 0.12254988f, -0.03084718f, 
    -0.09017084f, -0.05325508f, -0.08215822f, -0.18139778f, -0.00715565f, -0.10685218f, -0.12555908f, 0.07521159f, 
    0.14609987f, -0.16682945f, 0.24645381f, 0.16434872f, 0.17137317f, -0.19505011f, 0.10258590f, 0.49938211f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12634599f, 0.04056154f, -0.00992104f, 0.08332517f, 0.04935556f, 0.01504641f, 0.20309971f, -0.09236144f, 
    -0.06736791f, 0.03260885f, 0.03909913f, 0.08463567f, 0.11285719f, 0.02496425f, -0.03591879f, -0.07485082f, 
    -0.00281386f, 0.17552763f, -0.03478882f, -0.10868426f, -0.07120639f, 0.20484887f, -0.08585054f, -0.11418623f, 
    0.07642002f, 0.07014038f, 0.11047806f, 0.15627550f, 0.09633077f, -0.17180839f, -0.14360473f, -0.09812374f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.00751156f, 0.35952327f, -1.26703894f, 0.18967253f, 0.18916407f, -0.00641385f, -0.08956324f, 0.18492456f, 
    0.26361436f, -0.31799680f, 0.12139477f, -0.51367873f, -0.03673639f, 0.19682066f, -0.07263925f, -0.12963191f, 
    0.36335808f, 0.05725668f, 0.06805192f, -0.26280853f, -0.01608442f, -0.23413238f, -0.02932262f, -0.55183995f, 
    -0.18431649f, -0.28135961f, -0.47766116f, -0.10964945f, -0.54737759f, -0.00757939f, 0.00104705f, -0.34974968f, 
    0.03306962f, -0.38025543f, -0.28452271f, -0.45341662f, 0.47248462f, 0.11288113f, 0.04353977f, -0.20376013f, 
    -0.06510177f, 0.00817196f, 0.37649804f, 0.26132351f, -0.04029784f, 0.00725887f, -0.05152991f, 0.05801958f, 
    0.14108713f, -0.09176311f, 0.08859020f, 0.23807397f, -0.11403417f, -0.02943149f, 0.05948942f, -0.58802289f, 
    -0.12419822f, -0.10059608f, 0.44778112f, 0.06443724f, 0.18349496f, -0.10682357f, -0.00274612f, -0.52752066f, 
    0.06800948f, -0.73600465f, 0.06546269f, -0.34325105f, -0.28196821f, -0.01463583f, 0.43383673f, 0.17350177f, 
    0.30669251f, -0.59317446f, 0.01538940f, 0.20817724f, 0.03494403f, -0.04451618f, -0.09226858f, 0.10706130f, 
    -0.01467590f, -0.18593985f, -0.04481249f, -0.45801333f, 0.20012751f, 0.01219491f, -0.20720769f, -0.39284635f, 
    -0.75697345f, 0.16889298f, -0.34494463f, 0.10306156f, -0.30151218f, 0.16487533f, -0.19869477f, -0.18940422f, 
    0.15534493f, 0.29823592f, -0.50290114f, 0.08950385f, -0.88038474f, -0.16445103f, -0.15602888f, 0.25158489f, 
    -0.06971195f, 0.15770347f, 0.08225897f, -0.68399674f, 0.01806762f, -0.12045552f, -0.16277000f, -0.00164682f, 
    0.20340417f, 0.05715873f, -0.16279371f, 0.22102405f, -0.13170561f, -0.18610242f, 0.13455160f, -0.14486651f, 
    -0.18341404f, -0.24354532f, -0.69164234f, 0.13672778f, 0.06943443f, 0.00035541f, -0.02359331f, 0.08228453f, 
    0.02217438f, 0.03452078f, -0.46387196f, 0.56098437f, -0.01881556f, 0.13067736f, -0.16339619f, -0.17530681f, 
    -0.15787670f, 0.31061247f, -0.28953522f, -0.16039185f, 0.09760432f, 0.01099211f, -0.16017427f, -0.04991114f, 
    0.31980184f, 0.20488319f, -0.09074318f, 0.17509077f, 0.06007392f, 0.26483816f, -0.34648228f, -0.12530585f, 
    0.00551529f, -0.12344535f, -0.56508136f, -0.15333021f, -0.16478486f, 0.00285741f, 0.02191556f, 0.16459738f, 
    0.10946971f, 0.30862525f, -1.07656491f, 0.04087448f, 0.05826518f, 0.06939103f, -0.41558081f, -0.44725478f, 
    -0.03318641f, -0.00072145f, -0.14489543f, 0.03783458f, 0.12929581f, 0.10513572f, 0.05240946f, -0.13685046f, 
    0.19335394f, 0.09339814f, 0.13832618f, -0.34721932f, 0.08504862f, -0.20953847f, 0.28130940f, 0.26873878f, 
    0.44788161f, -0.11239592f, 0.04050590f, -0.32888618f, -0.23506829f, -0.17144820f, -0.05730344f, -0.03111998f, 
    -0.17499050f, -0.33348888f, -0.43766412f, -0.28168112f, 0.04956021f, -0.01670546f, -0.09728107f, 0.15707807f, 
    -0.31713292f, -0.38587540f, -0.27910668f, -0.05573372f, -0.13359277f, 0.20677350f, 0.13900420f, -0.14363943f, 
    -0.57005620f, 0.17553979f, 0.02375950f, -0.40473545f, -0.23664060f, 0.27868792f, 0.30927691f, 0.01171246f, 
    -0.14004964f, 0.05357700f, -0.53593528f, -0.28863487f, -0.16549315f, 0.11218306f, -0.17321333f, 0.32008731f, 
    -0.01372369f, 0.06917502f, 0.49486548f, 0.01882632f, -0.02180585f, 0.03298002f, -0.11093692f, 0.17594747f, 
    -0.42578232f, 0.26407632f, -0.28646258f, 0.05168897f, -0.11240418f, -0.55908924f, -0.03765704f, 0.01703651f, 
    -0.14314510f, -0.03464663f, -0.04880907f, 0.31337476f, -0.16468747f, -0.04564463f, -0.32891524f, 0.30625540f, 
    0.14971772f, -0.42498684f, -0.15451492f, 0.18071914f, 0.25820515f, 0.07671925f, -0.09176297f, -0.04104701f, 
    0.13158591f, -0.39048991f, 0.08941241f, 0.01477431f, -0.39903823f, 0.09595304f, -0.01573814f, -0.30263746f, 
    0.21095712f, -0.35030738f, 0.12467197f, 0.22668239f, 0.11003618f, 0.03934842f, -0.02263612f, -0.17299460f, 
    0.07128911f, -0.77538455f, 0.05959874f, 0.04841963f, -0.29952222f, -0.38244998f, 0.14505714f, -0.28348911f, 
    0.05791184f, 0.22018175f, 0.34084150f, -0.43540362f, -0.14593017f, 0.08583533f, -0.10896362f, 0.38972011f, 
    -0.00625603f, -0.24199671f, 0.49987683f, -0.48732084f, -0.19240059f, -0.16986586f, 0.16267402f, 0.17451939f, 
    -0.35097921f, -0.07574430f, -0.32644692f, 0.16188015f, 0.10308509f, -0.04902113f, -0.09430059f, -0.03466736f, 
    0.04498539f, 0.16471028f, -0.15563606f, -0.26250342f, 0.38509938f, 0.04655465f, -0.57268280f, 0.28351417f, 
    0.04507688f, -0.10701321f, 0.03279017f, -0.17641337f, -0.40033618f, 0.05150197f, 0.12999971f, 0.01761477f, 
    0.11924734f, -0.12262292f, -0.03898533f, -0.51732421f, -0.68667442f, 0.00383081f, 0.05947854f, 0.01441314f, 
    0.08952282f, -0.49359033f, -0.24640790f, -0.13997468f, 0.13231225f, -0.31752461f, -0.11570344f, 0.04196469f, 
    -0.56349027f, 0.27721122f, -0.10733900f, 0.13603412f, -0.21012972f, -0.15688495f, 0.13880131f, -0.06339372f, 
    0.00353270f, 0.25370055f, 0.00448803f, 0.35831165f, 0.28246230f, 0.01568123f, -0.16144632f, 0.01578149f, 
    0.10763264f, -0.15222163f, -0.57809430f, -0.23333316f, -0.54949552f, -0.08230899f, -0.05871381f, 0.12672472f, 
    0.33832964f, 0.08623771f, -0.05428950f, 0.06630113f, -0.09160431f, -0.03829688f, 0.17010531f, 0.03129918f, 
    -0.04360434f, -0.37816647f, 0.14109741f, -0.00289085f, -0.23118819f, 0.13974132f, 0.42514303f, 0.08120620f, 
    0.24606806f, -0.22592196f, -0.75329792f, -0.38630983f, 0.16980907f, 0.02475370f, -0.02713414f, 0.23513828f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.06381186f, -0.00450367f, 0.07480185f, 0.00490064f, 0.17822289f, 0.01270279f, 0.12196178f, -0.09223931f, 
    -0.16957673f, 0.17744182f, 0.02184930f, 0.01622018f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
